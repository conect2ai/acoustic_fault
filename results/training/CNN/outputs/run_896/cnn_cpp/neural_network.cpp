#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.93145019f, 0.68037689f, 0.08670788f, 0.13788562f, 0.14405183f, -0.18138725f, -0.62623471f, -0.00479047f, 
    -0.13629594f, 0.07716227f, 0.04039196f, 0.27866721f, 0.18457749f, 0.01785774f, 0.04973092f, 0.14465053f, 
    -0.11972509f, 0.20098719f, 0.05634635f, 0.24534935f, 0.05162948f, 0.24793406f, 0.02802051f, -0.13265508f, 
    -0.06178115f, -0.37857434f, -0.48325062f, 0.18662968f, 0.10348535f, -0.45335653f, 0.02733492f, -0.07322174f, 
    0.14822690f, -0.24328938f, -0.13114026f, -0.04786118f, 0.06450035f, -0.31933799f, -0.27854455f, -0.34909108f, 
    -0.00250980f, 0.05962655f, -0.30267733f, -0.04822681f, -0.13398203f, 0.15701619f, 0.02351411f, 0.17864867f, 
    0.52019078f, -0.22395964f, -0.67595100f, 0.44907308f, 0.21155548f, -0.16122349f, 0.34892264f, -0.70563030f, 
    0.02335440f, -0.11918728f, -0.31645095f, -0.64507258f, 0.07670037f, 0.02829327f, 0.21398830f, 0.05794387f, 
    0.38933918f, 0.16794598f, 0.12423608f, 0.11076835f, 0.15358722f, -0.16492267f, 0.01523728f, -0.07191153f, 
    -0.21327321f, -0.08115281f, -0.01493063f, 0.82354933f, 0.34131932f, 0.69072056f, -0.26529455f, -0.27153346f, 
    0.05700980f, -0.53826219f, 0.20150712f, 0.22517160f, 0.32768029f, 0.19589102f, 0.10472678f, -0.22662129f, 
    -0.12142149f, 0.03160178f, 0.08701265f, 0.27969599f, -0.12450776f, -0.26172712f, 0.01162730f, -0.13463742f, 
    0.15795505f, 0.13051313f, 0.20103009f, -0.03032006f, 0.86231911f, 0.14186431f, 0.16826339f, 0.30404660f, 
    0.50452781f, 0.67217267f, -0.03958628f, -0.18371846f, 0.18823433f, 0.22784725f, -0.22843890f, 0.09410802f, 
    -0.25666824f, -0.09706917f, -0.16600579f, -0.22026256f, -0.20100950f, -0.09499591f, -0.20931512f, -0.20046091f, 
    -0.01033603f, 0.14258927f, 0.06063865f, 0.11931895f, 0.08418059f, -0.04183187f, -0.50188917f, -0.36915395f, 
    -0.50019485f, -0.02893116f, 0.00091977f, -0.78381371f, -0.35849106f, 0.21982948f, 0.05954436f, -0.38406646f, 
    0.07903076f, -0.17139351f, 0.03224433f, -0.15533413f, -0.05972880f, -0.01467617f, 0.22986360f, 0.13149905f, 
    -0.05182961f, -0.11696985f, -0.20190930f, -0.11044387f, -0.03701364f, -0.13515081f, 0.73417783f, 0.79486400f, 
    0.52403200f, -0.27645010f, -0.46635294f, -0.00778354f, 0.12510698f, -0.35562047f, -0.44217888f, 0.18779404f, 
    0.07739113f, 0.23662496f, 0.09818409f, 0.08608837f, -0.10121757f, -0.19161147f, -0.15138097f, 0.10228783f, 
    0.09974750f, -0.36513996f, 0.00788381f, 0.18203229f, 0.06218518f, -0.06141639f, 0.09133474f, -0.37275353f, 
    -1.13809180f, -0.55542803f, 0.29532677f, 0.40056175f, -0.32607627f, 0.67442185f, 0.25604504f, -0.33455613f, 
    0.06953658f, 0.25229666f, -0.03750873f, -0.09461459f, -0.09071724f, 0.15099317f, -0.08811754f, -0.06567353f, 
    -0.13102069f, -0.16005951f, -0.16111346f, -0.07347912f, -0.04962527f, -0.11891150f, -0.10830934f, -0.04248193f, 
    -0.11839289f, 0.35218588f, -0.50826287f, 0.10254047f, -0.32756934f, -0.39168283f, -0.28062618f, 0.21691814f, 
    0.49188411f, -0.36183760f, -0.29244205f, 0.03416183f, 0.20328315f, 0.01664923f, -0.20278065f, 0.01687223f, 
    -0.13730469f, 0.24034971f, 0.27229908f, -0.03365384f, 0.27924991f, -0.06473184f, 0.01037247f, -0.14794241f, 
    0.10782511f, 0.20166546f, -0.23768470f, -0.61771148f, -0.69835985f, -0.49862650f, 0.14213033f, 0.13364969f, 
    0.15603100f, -0.12387969f, 0.08102588f, 0.42449915f, 0.02303814f, 0.03915455f, 0.20424210f, -0.00183446f, 
    0.18211187f, 0.05779809f, 0.01605880f, 0.13862813f, 0.28696254f, -0.06780088f, -0.05567719f, 0.10412924f, 
    -0.16296166f, 0.28558987f, -0.61189955f, 0.07699707f, -0.44110364f, -0.10107245f, -0.24975844f, 0.11163910f, 
    0.03566246f, 0.07300880f, 0.57306612f, 0.31876105f, 0.43461388f, 0.08967705f, -0.15904362f, 0.30046588f, 
    0.18865609f, 0.20376132f, -0.16521676f, 0.22429627f, -0.04464298f, 0.24974850f, 0.27206001f, 0.06100477f, 
    -0.22846660f, 0.29745847f, 0.05731838f, 0.20111395f, -0.08444133f, 0.43529126f, 0.24657375f, -0.31119302f, 
    -0.08884262f, 0.28302196f, 0.62192363f, 0.24131221f, 0.27903247f, -0.14749491f, -0.01630933f, -0.09997735f, 
    -0.23669682f, -0.37173331f, 0.12557627f, 0.24629252f, -0.05705602f, -0.02909188f, -0.14630102f, 0.22000660f, 
    -0.24195051f, -0.25870565f, -0.36554185f, -0.17279199f, 0.25702441f, 0.29703707f, -0.03061574f, -0.43705142f, 
    0.58087873f, -0.01811038f, 0.22190505f, 0.48885536f, 0.34523323f, 0.40923923f, -0.26113382f, 0.19115597f, 
    -0.06203328f, 0.02525458f, -0.16273110f, -0.30222046f, -0.06993170f, -0.33847657f, 0.02350737f, -0.15385289f, 
    0.01657758f, -0.05129091f, 0.07522584f, 0.16781250f, -0.08947338f, 0.59564340f, 0.28443587f, 0.21407883f, 
    0.89499420f, 0.49452859f, 0.00799748f, 0.21612963f, -0.03970613f, 0.14147340f, -0.03256448f, -0.22439285f, 
    -0.11838110f, 0.09943274f, 0.07480866f, -0.02673585f, -0.00449373f, 0.15935518f, 0.13706821f, 0.19115645f, 
    0.01379965f, 0.01990623f, -0.02328019f, 0.08430330f, -0.02754460f, 0.19330311f, -0.33200359f, 0.65238118f, 
    -0.40077448f, -0.59441447f, 0.45111102f, 0.60883534f, -0.12813109f, -0.57218474f, 0.15397692f, -0.26765156f, 
    -0.00217337f, 0.22092189f, -0.07876773f, 0.11404552f, 0.04906549f, -0.07053975f, 0.04716797f, -0.02257625f, 
    -0.16474681f, -0.20543590f, -0.00802390f, -0.07106323f, 0.06126040f, -0.02264169f, 0.18270181f, -0.37435013f, 
    -0.52510625f, -0.61584330f, -0.32223129f, 0.00110713f, 0.08082411f, 0.26428813f, 0.12354207f, 0.01464309f, 
    0.43229368f, -0.29904810f, -0.08423999f, -0.10432122f, -0.21914887f, -0.14026080f, -0.19732291f, 0.19383384f, 
    0.26411548f, 0.11104443f, -0.21653053f, 0.08469855f, -0.23859747f, -0.22225374f, -0.30906886f, -0.05403838f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06206590f, -0.02183697f, 0.05327115f, 0.14347073f, 0.18897425f, 0.20586473f, 0.19107695f, 0.14075461f, 
    0.16841431f, 0.10061924f, 0.23182867f, 0.00530835f, 0.10848097f, 0.00486400f, 0.11797252f, 0.08229086f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.33795524f, 0.22201192f, 0.10975400f, -0.13700467f, 0.02277589f, 0.01755067f, 0.04474396f, 0.17338094f, 
    -0.01788695f, -0.19959541f, -0.11906686f, -0.11608232f, 0.09557698f, 0.17650971f, 0.00354797f, 0.12799288f, 
    0.12358853f, 0.04220319f, -0.00344798f, 0.18270484f, 0.00575480f, 0.26685187f, 0.17765863f, 0.06197340f, 
    0.14466798f, -0.03074020f, 0.10866325f, 0.17418881f, 0.12253180f, -0.03184280f, 0.16659302f, 0.11556283f, 
    -0.08277464f, -0.03574331f, 0.08786142f, -0.10804386f, 0.19117996f, -0.04608609f, -0.15074834f, 0.08237731f, 
    -0.01278701f, 0.01049444f, 0.01476068f, 0.04465616f, -0.01766334f, -0.00801376f, -0.01635258f, -0.11284389f, 
    -0.06791939f, 0.15992779f, -0.08028584f, 0.07582229f, 0.04290626f, -0.00437830f, -0.04671768f, 0.07254463f, 
    -0.03314579f, 0.06414416f, 0.04509851f, 0.09801051f, 0.20255408f, 0.06276639f, 0.08369253f, 0.03216032f, 
    0.05936704f, -0.01878836f, 0.04291571f, 0.04745128f, 0.09145822f, 0.03021541f, -0.07964656f, 0.17058995f, 
    0.07220117f, 0.27707237f, 0.19557743f, 0.08448932f, -0.05909695f, 0.04370365f, -0.06367482f, 0.00666973f, 
    -0.09006494f, 0.04435347f, -0.03431824f, 0.02414941f, -0.43860283f, 0.19243582f, -0.05835797f, 0.10208116f, 
    0.18806581f, 0.10810243f, 0.09807133f, -0.00733129f, 0.13898611f, 0.13345239f, 0.07867511f, 0.05562912f, 
    0.31656483f, 0.39883932f, 0.18845946f, 0.19392608f, 0.12192153f, 0.06971331f, 0.12660094f, -0.05714352f, 
    -0.15511757f, -0.01601254f, 0.05907501f, 0.10937642f, -0.09639557f, -0.18748406f, -0.06055328f, 0.00566092f, 
    0.05466016f, -0.08459460f, -0.07306267f, 0.00289402f, 0.02627861f, 0.05249385f, -0.08482569f, 0.03411960f, 
    -0.05316245f, 0.03107503f, -0.09528986f, -0.18589385f, 0.00523711f, -0.03386462f, 0.12484654f, -0.11116447f, 
    -0.00738957f, -0.13214999f, -0.02526365f, -0.13938087f, 0.07621030f, 0.02612050f, 0.11289539f, 0.11641689f, 
    -0.03827969f, 0.12292894f, 0.11161010f, -0.00196137f, 0.06346050f, 0.12623271f, 0.06886016f, -0.07724161f, 
    -0.05851848f, 0.01263448f, -0.00415745f, -0.37493306f, 0.00859107f, -0.04819660f, -0.12535268f, 0.04005636f, 
    -0.03627115f, -0.07577431f, 0.08860268f, 0.11259438f, -0.24573627f, 0.15781038f, 0.06211089f, -0.18041667f, 
    0.01453840f, -0.00572357f, 0.02586639f, -0.02475963f, 0.03278127f, -0.00089546f, 0.01536512f, 0.18059093f, 
    0.25987539f, 0.02292559f, 0.40766630f, 0.06995880f, 0.04648664f, 0.00461833f, 0.12059229f, -0.02198813f, 
    -0.06158938f, -0.01080202f, 0.08733476f, 0.02379016f, -0.06646077f, -0.09313261f, -0.12411022f, -0.09579992f, 
    0.12964074f, 0.11352502f, 0.03194061f, 0.07605781f, -0.07096008f, 0.03016892f, 0.06018050f, 0.19642921f, 
    -0.03956385f, -0.00881858f, -0.03399817f, -0.04405949f, -0.03429747f, -0.01380346f, 0.02922514f, 0.01436504f, 
    -0.07043247f, 0.03282578f, -0.02698338f, -0.01472985f, -0.00786670f, 0.05545566f, -0.00863223f, 0.04069712f, 
    -0.07361437f, -0.02267167f, -0.03829308f, 0.05165427f, -0.02082798f, -0.03708700f, -0.05886708f, -0.05911844f, 
    -0.05370973f, -0.01569601f, 0.00495315f, 0.05096713f, -0.01000333f, 0.02171607f, 0.03021411f, -0.04597731f, 
    -0.00437275f, -0.04132899f, 0.03606346f, 0.01674566f, -0.00030083f, 0.00815554f, -0.05797192f, 0.00702495f, 
    -0.00306361f, -0.05845163f, -0.01678615f, 0.00687178f, -0.02608047f, -0.02342355f, 0.01912252f, 0.04578621f, 
    -0.06960619f, -0.08095365f, 0.00445194f, 0.00426081f, 0.01266956f, -0.05927146f, 0.02155015f, -0.01476933f, 
    -0.05230368f, -0.02607854f, -0.05911906f, -0.01225967f, -0.01241858f, -0.00767677f, -0.02996652f, -0.03889180f, 
    -0.04675164f, -0.01098784f, -0.00188206f, -0.01787802f, 0.05996745f, 0.01338735f, -0.01087039f, 0.01372922f, 
    0.04199276f, -0.01747327f, 0.03947105f, -0.02825901f, -0.06080519f, -0.03292609f, 0.00781851f, 0.00075651f, 
    -0.06572555f, -0.03548638f, -0.03608971f, 0.00572979f, 0.03172260f, 0.04424914f, -0.03092040f, -0.00668727f, 
    -0.05017606f, 0.01855281f, -0.03386273f, -0.03333389f, -0.03558020f, -0.06516013f, -0.06642315f, -0.07870469f, 
    0.05839882f, 0.02214923f, 0.04015028f, 0.01505913f, -0.07689502f, -0.04292774f, -0.06776744f, 0.04178569f, 
    -0.00665546f, -0.00895329f, -0.03801426f, 0.01885142f, 0.03417417f, 0.04361657f, 0.01251405f, -0.02570033f, 
    -0.06530879f, 0.03221369f, -0.05515585f, -0.03050648f, 0.04725185f, -0.07130400f, -0.05605619f, 0.06254724f, 
    -0.05110298f, 0.05052179f, 0.01515615f, 0.05625758f, -0.03141595f, -0.02747034f, -0.03888198f, -0.02601702f, 
    -0.04012832f, 0.02758973f, -0.01147839f, 0.02711600f, 0.04949938f, -0.06491297f, 0.06325431f, -0.02544313f, 
    -0.05373679f, -0.00843818f, 0.06035494f, -0.00899158f, -0.00187291f, -0.03690853f, -0.00539008f, 0.01216230f, 
    0.00548598f, -0.07532573f, -0.06537338f, -0.03126207f, 0.03991467f, -0.02104329f, -0.05621136f, 0.00306833f, 
    0.05355421f, -0.06658470f, -0.05263755f, -0.00563338f, 0.00861258f, 0.00860084f, -0.04422135f, -0.06159484f, 
    -0.05392246f, -0.04924564f, -0.07951038f, -0.03991519f, -0.01019888f, 0.01317730f, 0.05270113f, -0.06304597f, 
    -0.04437921f, -0.02408041f, -0.01386149f, 0.03084628f, -0.07446031f, -0.02864636f, -0.06698950f, -0.00616665f, 
    0.03941210f, -0.00444765f, 0.06080086f, 0.03097862f, 0.03799450f, 0.03292463f, 0.06183102f, 0.03927774f, 
    -0.02200355f, 0.05358509f, -0.07089040f, -0.07109474f, -0.03461564f, 0.01346501f, 0.03296056f, 0.00408524f, 
    -0.03550750f, 0.05888334f, 0.03393887f, -0.00246665f, -0.07634363f, -0.02838769f, -0.00950541f, 0.00792668f, 
    -0.04288693f, -0.07677768f, -0.04091710f, -0.04694941f, -0.02270316f, 0.02789579f, 0.01382332f, -0.00664700f, 
    0.00919777f, -0.07563920f, -0.03052666f, -0.00098693f, -0.07702370f, 0.03101130f, -0.01779796f, -0.03673819f, 
    0.00999519f, 0.01543011f, 0.04144826f, 0.05282867f, -0.06751474f, -0.07156841f, 0.03471795f, -0.05800217f, 
    0.05229159f, 0.01652209f, 0.00574035f, -0.04801130f, 0.03877018f, 0.01851411f, -0.03297998f, 0.04249617f, 
    0.00958628f, -0.06954848f, -0.01073567f, -0.06659627f, -0.07520152f, 0.05340904f, -0.00024993f, -0.03484241f, 
    0.02529797f, 0.01027547f, -0.04261454f, -0.07411468f, -0.04788982f, -0.00750452f, 0.06103534f, 0.04186945f, 
    0.02331365f, -0.04945501f, 0.05450343f, 0.04407171f, 0.01451412f, 0.01455982f, 0.04492192f, -0.02311246f, 
    -0.05158417f, 0.01734635f, -0.00557325f, 0.05015202f, -0.04345484f, -0.03942367f, -0.07081062f, 0.00436321f, 
    0.01863444f, -0.05352904f, -0.03494413f, -0.06978362f, -0.04476520f, 0.03248696f, -0.04841766f, -0.05467243f, 
    -0.02480014f, -0.07570595f, -0.03561756f, -0.02185180f, -0.01323895f, 0.04839991f, -0.00363902f, -0.03179290f, 
    -0.02085178f, 0.05018989f, 0.04773507f, 0.01057169f, -0.03615790f, 0.00629621f, -0.03760682f, -0.04692043f, 
    0.01860766f, -0.03801918f, -0.06465194f, 0.00012120f, 0.01950612f, -0.05883012f, 0.03485337f, -0.00960580f, 
    -0.04209406f, 0.03571919f, 0.06345468f, 0.05759156f, 0.01513294f, -0.06951714f, -0.04468530f, -0.00886561f, 
    -0.03218767f, -0.01683628f, -0.07487262f, -0.01006728f, -0.00393216f, -0.07149967f, 0.02016442f, 0.06156607f, 
    0.00532683f, -0.02727321f, -0.02397275f, 0.05406012f, -0.04190860f, 0.00557534f, -0.03561793f, -0.04200273f, 
    0.06529481f, -0.06844753f, 0.00751181f, -0.02706298f, -0.04631830f, -0.04167525f, 0.04450223f, 0.01384487f, 
    0.04462624f, -0.06658188f, 0.02002184f, 0.05714809f, -0.02580539f, 0.02895635f, 0.05957043f, -0.00921667f, 
    0.04844423f, -0.04326662f, -0.01844721f, 0.06974794f, -0.04152608f, 0.04503739f, 0.06322271f, 0.02055138f, 
    -0.04856214f, 0.01586092f, 0.02762635f, 0.00297899f, 0.04884685f, 0.03477251f, 0.06540819f, 0.00846439f, 
    0.06442914f, -0.05253709f, 0.01566742f, 0.00864134f, 0.06546849f, -0.07569959f, -0.03422958f, -0.03223863f, 
    0.01910670f, -0.07514251f, -0.06883353f, -0.00481479f, 0.00489986f, -0.00764429f, 0.04706590f, -0.00950879f, 
    -0.04850513f, -0.01523359f, -0.05109487f, 0.03215788f, -0.01825036f, -0.04738129f, -0.05178985f, -0.01696869f, 
    -0.07692394f, 0.01850871f, -0.01947373f, 0.04543875f, -0.01420516f, -0.03254735f, -0.01474601f, 0.02331555f, 
    -0.01500514f, -0.03444697f, 0.06522004f, 0.01271643f, -0.02345518f, -0.06991532f, -0.01911367f, -0.04882839f, 
    -0.07591531f, -0.04452797f, 0.03338378f, -0.04292353f, -0.03533796f, -0.09518465f, -0.05096079f, 0.05906974f, 
    -0.03159344f, -0.01565192f, -0.00587514f, -0.01562590f, -0.04393518f, -0.01134477f, -0.05625756f, 0.06085226f, 
    -0.00047852f, -0.03065042f, -0.06372777f, -0.03330005f, 0.03896217f, 0.04218655f, 0.04909516f, 0.03347383f, 
    0.05641744f, -0.01299584f, 0.04524694f, 0.05181377f, 0.03009521f, 0.00213995f, -0.00594620f, 0.02878270f, 
    -0.02712767f, -0.03386970f, -0.03902861f, 0.01006589f, 0.04031150f, -0.07148203f, -0.04273368f, 0.04719377f, 
    -0.07248890f, -0.01514804f, -0.04307859f, 0.01977695f, 0.04320845f, 0.03410850f, 0.01082205f, 0.01798914f, 
    0.01329151f, 0.05893636f, 0.00308228f, 0.00529193f, -0.01961482f, -0.08787883f, -0.05314052f, -0.06900886f, 
    0.06379164f, -0.06121048f, -0.01251114f, 0.00273287f, -0.02088171f, 0.01248875f, -0.00088051f, 0.00679869f, 
    -0.02282759f, 0.06228362f, -0.01038529f, -0.05224876f, -0.01733717f, -0.06346066f, 0.00149797f, 0.00210409f, 
    0.04686296f, -0.01968225f, -0.02092862f, -0.04488287f, -0.07564497f, 0.02322538f, -0.04691925f, 0.04209495f, 
    0.05657052f, 0.03279308f, 0.05691599f, -0.05678884f, -0.02678158f, -0.00006636f, -0.05033526f, 0.03928511f, 
    0.04070595f, 0.00834861f, -0.00986660f, 0.02391089f, -0.04463057f, 0.03030243f, -0.01773074f, -0.00123435f, 
    0.06173512f, -0.00787515f, -0.05660889f, -0.07872933f, -0.01823010f, -0.01841115f, 0.05560022f, 0.01770664f, 
    -0.02792215f, -0.05874585f, -0.07965332f, -0.02887055f, 0.00960454f, -0.03718920f, -0.06624661f, -0.07205952f, 
    0.01323533f, -0.00749645f, 0.02241448f, -0.06453998f, 0.00621432f, -0.03044895f, 0.03911090f, -0.06410671f, 
    0.04322399f, -0.06838305f, -0.06956075f, 0.03922333f, 0.02391486f, -0.02348261f, -0.00059019f, 0.01634005f, 
    -0.06933153f, -0.00161501f, -0.08485071f, -0.05835430f, 0.02167398f, -0.07808331f, -0.06448681f, 0.00258809f, 
    -0.06919643f, -0.02784162f, -0.05430672f, 0.06070344f, 0.00130225f, -0.03370729f, 0.05601633f, 0.01058724f, 
    0.03706436f, -0.03643395f, 0.03543453f, 0.04663724f, -0.04501417f, 0.01418133f, -0.01422202f, -0.01811849f, 
    -0.02107349f, 0.06882186f, -0.00519813f, -0.07774583f, 0.05076826f, 0.05314699f, -0.02979205f, -0.00462950f, 
    -0.00027780f, 0.01031793f, 0.04657745f, 0.04191571f, 0.01551313f, 0.00125419f, 0.02301189f, -0.05508661f, 
    0.05214848f, -0.02120051f, 0.00465253f, -0.08762380f, 0.05197741f, 0.03953960f, 0.02703974f, -0.01531584f, 
    -0.04531400f, -0.07344543f, -0.02014603f, -0.03961602f, 0.03957491f, -0.06658641f, -0.01929636f, -0.01437616f, 
    0.03507631f, -0.08049289f, 0.05601835f, 0.03866331f, -0.02553827f, 0.00258254f, 0.04908666f, -0.05516450f, 
    -0.07013993f, -0.07786341f, -0.08358764f, -0.01292652f, -0.00669587f, 0.03255498f, 0.02357466f, -0.05355394f, 
    0.01472173f, -0.05709259f, -0.06170500f, -0.03883952f, 0.03018389f, -0.04010103f, -0.05305925f, 0.03537046f, 
    0.02963356f, -0.03844130f, 0.03042321f, 0.01731176f, 0.04094082f, 0.05625141f, 0.00041550f, 0.05094582f, 
    -0.07947725f, 0.06932605f, -0.01843789f, 0.02637211f, 0.05624039f, 0.02611540f, -0.01703560f, 0.01734784f, 
    0.04138040f, -0.08185765f, -0.06322129f, 0.04191632f, -0.06164034f, 0.01208457f, -0.06378735f, 0.05054352f, 
    0.04301595f, -0.07233127f, -0.02253619f, -0.00856556f, 0.06125501f, 0.01417261f, 0.03377081f, -0.04433877f, 
    -0.02317391f, 0.02497637f, 0.01025794f, -0.02368298f, 0.00879945f, -0.02166655f, -0.05528915f, 0.01336361f, 
    0.04508049f, -0.00257300f, -0.06378762f, -0.01202096f, 0.05277533f, 0.05165965f, -0.07089368f, 0.01937867f, 
    -0.00834229f, 0.04921148f, 0.00643713f, -0.00119765f, 0.05806387f, 0.00489020f, -0.07171550f, 0.00270809f, 
    -0.02339418f, -0.06610099f, 0.03663542f, -0.01480616f, -0.01388682f, 0.05071451f, -0.00936101f, -0.06552257f, 
    -0.01097330f, -0.04185738f, -0.04659584f, -0.02487138f, 0.00979335f, 0.03858872f, -0.01097421f, -0.06576820f, 
    -0.00193868f, -0.03076424f, -0.03525737f, -0.02553083f, -0.03584040f, 0.03256607f, 0.02721890f, 0.00819838f, 
    -0.04144305f, -0.07728603f, 0.00284731f, 0.01472802f, -0.00144891f, 0.00133089f, -0.03673934f, -0.07525223f, 
    0.04595901f, -0.06132131f, -0.06456911f, -0.02311002f, 0.02567441f, 0.05709524f, 0.00360237f, -0.06360012f, 
    -0.07394735f, -0.08465438f, -0.04301970f, -0.00464750f, -0.05189934f, -0.05258735f, -0.03607688f, 0.01173907f, 
    -0.05967342f, -0.07757521f, -0.00951157f, 0.01044211f, -0.08276378f, -0.02167130f, -0.05084525f, -0.06244409f, 
    0.02361288f, -0.07582855f, 0.00450026f, -0.08352290f, 0.04445978f, 0.00183355f, 0.00229548f, -0.00820603f, 
    -0.04870951f, -0.02701280f, -0.06712622f, 0.04810258f, -0.03733031f, 0.06281795f, -0.08098241f, -0.02084164f, 
    0.03046088f, -0.06578374f, -0.06123525f, 0.05703419f, -0.00692555f, 0.03644323f, -0.06616589f, 0.02378915f, 
    -0.01977821f, -0.00415284f, 0.01812523f, -0.01784799f, -0.04554977f, -0.02505301f, -0.02172792f, -0.02499607f, 
    0.01396945f, 0.05511271f, -0.02271856f, 0.01272207f, -0.04276226f, 0.04892443f, -0.02140217f, -0.02313786f, 
    0.00507985f, -0.02798956f, -0.04860836f, 0.02038363f, 0.04317557f, -0.07470603f, 0.05104319f, 0.00854008f, 
    0.03704824f, -0.00978426f, 0.00029366f, -0.07276133f, 0.00706895f, -0.03857006f, 0.01012345f, 0.01199712f, 
    -0.02481939f, 0.28290036f, 0.33838624f, -0.05598958f, -0.13110334f, -0.25368553f, 0.01620560f, 0.05508030f, 
    -0.00162930f, 0.03194707f, 0.02375973f, 0.11280677f, -0.02302911f, 0.14362995f, -0.11942701f, 0.04315098f, 
    0.13724224f, 0.19943097f, -0.02129338f, 0.06827006f, -0.10351951f, 0.09811936f, 0.02859196f, -0.07199140f, 
    0.10262076f, -0.18141280f, -0.01105369f, 0.09683438f, -0.12942964f, -0.20852518f, -0.01628679f, 0.11947639f, 
    -0.00115988f, 0.10628083f, 0.09078079f, 0.05727902f, 0.27687612f, 0.06860927f, 0.31168234f, 0.03561586f, 
    -0.06010628f, -0.15018307f, -0.15431546f, -0.06127129f, -0.03818019f, 0.10537057f, 0.02822907f, -0.01878024f, 
    0.17673780f, 0.10894392f, 0.23304617f, 0.05019878f, 0.07320418f, -0.03446089f, 0.09486919f, 0.06757537f, 
    0.04913691f, -0.01883746f, -0.02458707f, 0.01645732f, 0.46270326f, -0.06515086f, -0.11465023f, 0.20546952f, 
    0.17185889f, -0.14461231f, 0.15357466f, -0.00600265f, 0.00077594f, 0.04043808f, 0.09497239f, 0.01013850f, 
    0.08347785f, 0.08181933f, 0.27416319f, 0.01345479f, -0.17199339f, -0.16069525f, 0.04807987f, -0.03755327f, 
    -0.04148058f, 0.03591791f, -0.03630121f, 0.00315860f, -0.48070663f, 0.12700015f, -0.22351798f, -0.30766216f, 
    0.30958125f, 0.07304757f, -0.04300192f, -0.04742949f, -0.05781795f, 0.00385207f, 0.04568799f, -0.03115883f, 
    -0.00696681f, 0.19152944f, 0.11138184f, 0.23090643f, -0.12149762f, 0.01005104f, -0.09422413f, -0.09879179f, 
    -0.02124600f, 0.08906244f, -0.09841915f, -0.05725956f, -0.26937172f, 0.00317092f, -0.05640480f, 0.26915842f, 
    0.10107787f, 0.04106048f, 0.01998615f, -0.03435972f, 0.06384512f, 0.18492655f, -0.02322774f, -0.07714004f, 
    -0.08998787f, -0.23036975f, -0.07151132f, -0.04787781f, 0.05933089f, -0.01580834f, 0.12512158f, -0.09357930f, 
    0.15969722f, 0.17637186f, -0.04643548f, -0.00356145f, 0.15618727f, 0.19541304f, 0.03589547f, -0.08425431f, 
    0.01500048f, 0.01906432f, 0.01497307f, 0.10256664f, 0.10760579f, -0.13186923f, 0.10069590f, -0.09281210f, 
    -0.12337293f, -0.09637617f, 0.04694646f, -0.03360275f, 0.03073753f, 0.02120530f, -0.16174118f, 0.00113897f, 
    0.09235385f, -0.02183510f, 0.03832487f, -0.24462306f, -0.02732870f, 0.31426531f, 0.17864358f, -0.21382788f, 
    0.03726757f, 0.13545969f, 0.06689636f, 0.07359535f, 0.12185257f, 0.20048021f, -0.07038463f, -0.01713482f, 
    -0.33604282f, -0.10619712f, 0.13957490f, 0.13409294f, 0.04190307f, -0.03910822f, 0.17385013f, 0.06120616f, 
    -0.07544596f, 0.12116422f, 0.06393625f, -0.06992295f, 0.08717691f, 0.09164005f, -0.18051897f, 0.09853072f, 
    0.15236896f, 0.15601446f, -0.01203116f, -0.09831391f, -0.00326966f, -0.01312006f, 0.12357688f, 0.00678459f, 
    0.02332757f, 0.13233913f, 0.11625426f, 0.05423805f, -0.02590775f, 0.08895485f, -0.05159019f, -0.04253206f, 
    0.04382840f, 0.03600293f, 0.05988901f, -0.07459746f, -0.04339818f, -0.01083892f, 0.01611268f, -0.20726027f, 
    0.05322058f, 0.05250998f, 0.03938068f, 0.02848761f, -0.07510015f, 0.02420540f, -0.06404675f, 0.02848157f, 
    0.20744085f, -0.22472155f, -0.01729978f, 0.04607600f, -0.05663856f, -0.07870137f, 0.00085032f, 0.00722039f, 
    -0.05157906f, 0.12975849f, 0.08968528f, -0.07262129f, 0.28435022f, 0.05672788f, 0.05301274f, 0.03741658f, 
    -0.01014782f, 0.01630359f, 0.02153917f, -0.06205634f, -0.00610311f, -0.02228956f, -0.02817727f, 0.00247111f, 
    0.06219295f, 0.30479392f, 0.02036368f, 0.16526268f, 0.17314813f, 0.00875033f, -0.08621756f, -0.01020744f, 
    0.02533377f, -0.01142418f, -0.01128210f, 0.01688338f, -0.14287156f, -0.12965466f, 0.13857213f, 0.04714496f, 
    -0.03177725f, -0.01112440f, -0.05144177f, 0.05372200f, -0.06284218f, -0.06242802f, -0.04265221f, -0.04787875f, 
    0.10154381f, 0.20641045f, 0.12278837f, 0.03690867f, 0.05387449f, 0.08497077f, -0.00453347f, -0.01513243f, 
    -0.06998413f, -0.00119882f, 0.07101111f, -0.01641737f, -0.55696511f, 0.12389474f, -0.08462745f, -0.15466049f, 
    0.02691262f, -0.03808917f, -0.05930626f, 0.02194056f, 0.12918718f, 0.09213202f, 0.01784088f, 0.09670084f, 
    0.07078832f, -0.08281276f, 0.08762786f, -0.05520478f, 0.06584557f, -0.11420386f, -0.07764521f, 0.04740117f, 
    0.00225635f, 0.04428170f, -0.01635913f, -0.04705710f, -0.23558676f, 0.25148806f, 0.11730499f, 0.02745747f, 
    0.03253762f, 0.07375754f, -0.10234790f, 0.07212022f, 0.03978007f, -0.08043105f, -0.07127384f, 0.00070266f, 
    -0.04419906f, -0.08232116f, 0.08657964f, 0.10262422f, -0.03747670f, -0.00415119f, 0.13200705f, -0.06023987f, 
    0.04179652f, -0.01062867f, 0.02709959f, -0.03478394f, 0.18468672f, 0.01853886f, 0.06435907f, 0.15905079f, 
    0.01810024f, 0.10485501f, 0.03302913f, 0.02967925f, 0.13010138f, 0.09027921f, -0.03350458f, 0.05864346f, 
    0.14565977f, -0.04159157f, -0.05629577f, 0.13129193f, 0.03269095f, 0.01736728f, -0.19495326f, 0.01113227f, 
    -0.07421973f, 0.00087973f, -0.00660692f, 0.05963515f, 0.05882725f, 0.22258024f, 0.14116840f, 0.15078989f, 
    0.11558343f, 0.04536263f, 0.00835655f, -0.08939163f, -0.01957910f, 0.11806133f, 0.01782130f, 0.01710085f, 
    -0.21823141f, 0.07656365f, 0.18854477f, -0.09315227f, 0.05547586f, -0.01065236f, 0.01432334f, -0.01362076f, 
    0.03466197f, 0.00135833f, 0.07451627f, 0.02527866f, -0.32419014f, -0.05988357f, 0.13888943f, 0.03588228f, 
    0.06740564f, -0.01639445f, -0.07370313f, 0.03590203f, 0.06135164f, -0.03265799f, -0.08757500f, 0.05132325f, 
    -0.21918540f, -0.11658598f, 0.19940625f, 0.09864217f, -0.02856854f, -0.09490877f, 0.03026783f, -0.07671046f, 
    -0.05460288f, 0.07620768f, 0.07409234f, 0.16779360f, -0.30418831f, 0.15737087f, -0.12626813f, 0.13787034f, 
    0.01915500f, -0.01033408f, 0.30913395f, 0.13562499f, 0.04667688f, -0.06201169f, -0.10710408f, -0.00506269f, 
    0.06974684f, -0.10787001f, -0.19166736f, -0.13323641f, 0.03548611f, -0.08825400f, -0.06215990f, 0.05102372f, 
    -0.06231957f, 0.13950038f, 0.15459767f, 0.07996381f, 0.02706261f, -0.01644725f, 0.17790622f, 0.05985936f, 
    0.08645314f, 0.04837302f, -0.00889302f, -0.15610054f, 0.11981475f, -0.06773561f, -0.00089430f, 0.15713292f, 
    0.03968726f, -0.10539114f, 0.25031966f, 0.14662862f, 0.05423160f, -0.01667243f, 0.09192702f, -0.04449359f, 
    0.16753276f, 0.02336966f, -0.05241439f, 0.04555915f, -0.05198896f, -0.03743681f, 0.03937646f, 0.22415835f, 
    0.08210463f, -0.04522396f, 0.08106527f, 0.11723009f, 0.10686167f, -0.06900811f, 0.07676324f, -0.07712922f, 
    -0.08558626f, 0.03190942f, 0.09718737f, 0.04559181f, 0.07833526f, -0.05533269f, 0.11149438f, -0.02629058f, 
    0.05782676f, -0.03663715f, 0.04519264f, 0.05028907f, -0.57133442f, 0.07242402f, -0.30484700f, -0.35129476f, 
    0.03539705f, 0.06547932f, -0.12806948f, -0.04022478f, -0.01033842f, -0.02649822f, -0.10441672f, -0.03014386f, 
    -0.00274561f, -0.07880417f, 0.03389517f, 0.16815302f, -0.02802560f, 0.09692977f, -0.01037697f, -0.06777753f, 
    0.02069069f, -0.00192130f, 0.15119331f, -0.14633524f, -0.22665796f, 0.03278870f, -0.09965883f, 0.10661098f, 
    0.10191261f, 0.13385125f, -0.07097061f, 0.04534272f, 0.07648363f, 0.04231928f, 0.04405085f, 0.12471487f, 
    -0.01368732f, -0.17888077f, -0.08915621f, 0.10844638f, 0.08675576f, 0.00265590f, 0.07732554f, 0.16391172f, 
    0.21537480f, 0.22937205f, 0.06653870f, 0.19896485f, 0.15636949f, 0.00372528f, -0.05336132f, -0.10485467f, 
    0.10968345f, -0.09457301f, -0.20202072f, 0.01587556f, 0.11802690f, -0.02842088f, 0.02809570f, -0.03772318f, 
    0.31385869f, -0.12014972f, 0.07409904f, -0.11399180f, 0.00173316f, 0.08328011f, -0.06814741f, 0.05617614f, 
    0.02761031f, 0.04378121f, 0.04345362f, -0.17070520f, 0.08406953f, 0.07330111f, 0.08511904f, 0.05920120f, 
    0.13244659f, -0.03345721f, -0.02720019f, -0.09404363f, 0.19079447f, 0.14576790f, 0.10585134f, 0.00750028f, 
    -0.22013636f, -0.10252400f, 0.10219045f, 0.03522026f, -0.01302985f, 0.03838298f, 0.15563782f, -0.01607704f, 
    -0.00628008f, -0.05691878f, 0.11900349f, 0.05471663f, -0.11932256f, 0.03384509f, -0.06707139f, 0.05484435f, 
    0.08413298f, 0.08759768f, -0.12115864f, -0.04711320f, 0.26209837f, -0.14205115f, -0.10504255f, -0.14281800f, 
    0.02698433f, 0.22188394f, 0.05472283f, 0.05276180f, 0.04915879f, 0.12416272f, -0.05484853f, -0.03505655f, 
    0.03985705f, 0.08331718f, 0.08140632f, -0.04162150f, 0.01148628f, 0.00130028f, -0.01656703f, -0.12543863f, 
    -0.08991399f, -0.07297513f, -0.01934590f, -0.15200219f, -0.03703600f, -0.07401780f, 0.10619057f, -0.00212379f, 
    0.11750416f, -0.08864955f, -0.06291024f, -0.16469589f, 0.04317887f, 0.04459158f, -0.15989614f, -0.06586496f, 
    -0.02844648f, -0.08607768f, 0.00058536f, -0.00115245f, -0.18515569f, 0.28346071f, 0.13627119f, 0.11738876f, 
    0.05451111f, -0.08151864f, -0.01812109f, 0.08546681f, 0.06090949f, -0.05945849f, 0.06385821f, -0.03671951f, 
    -0.06744801f, 0.04226792f, 0.12557498f, -0.14353450f, -0.03206223f, 0.05765104f, 0.10148796f, 0.01715209f, 
    0.03353849f, 0.01238594f, -0.01041560f, 0.04190519f, -0.07173139f, 0.04255128f, -0.14150517f, -0.15662669f, 
    0.02851759f, -0.02827259f, 0.00771676f, -0.01006393f, 0.07169765f, 0.07054920f, 0.02282443f, -0.02341349f, 
    0.31365660f, 0.06567225f, -0.16765845f, 0.10367723f, 0.03174582f, -0.03323877f, 0.00851755f, 0.01479732f, 
    0.08073172f, 0.02644405f, 0.00278138f, 0.09466231f, 0.59345233f, -0.19102988f, -0.00591904f, -0.06360374f, 
    -0.04116242f, 0.02400687f, -0.04479371f, 0.03810420f, 0.06387559f, 0.06475271f, 0.14648536f, 0.06362633f, 
    -0.25650042f, -0.08350670f, 0.05645652f, 0.07274203f, 0.01133154f, -0.00343552f, 0.09487015f, 0.05116124f, 
    0.01942266f, 0.01424924f, 0.00762177f, -0.04008592f, 0.08716229f, 0.18721028f, -0.17104267f, -0.15560164f, 
    0.03065023f, -0.08948229f, -0.01046615f, -0.12586778f, 0.00723379f, -0.01223710f, 0.12877645f, -0.01851781f, 
    -0.20792204f, -0.09942403f, 0.09495726f, 0.01044896f, 0.00387506f, -0.00388183f, -0.10097455f, 0.02776178f, 
    -0.06207085f, 0.02457953f, -0.06698479f, 0.09695555f, -0.09377606f, -0.01229278f, -0.02803023f, 0.04783478f, 
    0.17086610f, 0.01582996f, 0.04294017f, -0.04555537f, -0.08498320f, -0.13430741f, 0.07026754f, 0.00507025f, 
    -0.18511730f, 0.21448959f, 0.09919766f, 0.33538365f, -0.00650386f, -0.00775195f, 0.09999548f, 0.11662144f, 
    0.09378603f, 0.01346572f, 0.02735706f, -0.01979935f, -0.00899586f, 0.02945277f, 0.08228214f, -0.22730592f, 
    0.12857117f, 0.04515574f, -0.02060722f, -0.01307646f, 0.05337970f, -0.01921755f, -0.08051811f, -0.16091505f, 
    -0.15241461f, -0.14958690f, -0.15870558f, 0.12161778f, 0.12557305f, 0.13046089f, 0.02643468f, -0.02841887f, 
    0.16460402f, 0.12827539f, -0.00166908f, -0.05458941f, -0.03052428f, 0.02056668f, -0.06531291f, -0.19367506f, 
    -0.04091845f, -0.04402518f, 0.08332310f, -0.09778233f, -0.11955775f, 0.02635662f, -0.02371873f, 0.04021168f, 
    -0.03203806f, -0.06718294f, 0.05900163f, 0.04055425f, -0.00453232f, -0.05270141f, -0.06076092f, -0.07273582f, 
    -0.00832278f, 0.03178154f, 0.03793583f, -0.06083599f, 0.01482075f, -0.02426045f, 0.04559026f, -0.01368627f, 
    -0.05772961f, 0.03757288f, 0.04335522f, 0.00957773f, -0.01164274f, 0.03376913f, -0.00423985f, -0.07066236f, 
    -0.02365728f, 0.00360143f, -0.06222539f, 0.00471830f, 0.04061650f, -0.03575529f, 0.02432753f, -0.01811414f, 
    0.04135101f, -0.07525972f, 0.01085168f, 0.00460134f, -0.04257068f, -0.00782635f, 0.06660701f, -0.05225336f, 
    -0.06905802f, -0.07500380f, -0.00114485f, -0.03979418f, 0.02178668f, -0.03689522f, 0.06197082f, 0.01377177f, 
    0.02402459f, -0.01202201f, 0.06450506f, -0.03657032f, 0.05858589f, -0.03575031f, 0.01349707f, -0.01446324f, 
    -0.02519953f, -0.01224029f, 0.06479827f, -0.01553738f, -0.06212046f, 0.04004326f, -0.06185848f, -0.00044499f, 
    -0.04361325f, -0.06169242f, -0.06744929f, 0.02438824f, -0.06359156f, 0.02372903f, -0.03495674f, -0.03694522f, 
    0.05616949f, 0.05689999f, -0.04993468f, -0.03297748f, -0.06444152f, -0.07554771f, -0.01889558f, -0.03234020f, 
    -0.04917482f, -0.04642461f, -0.02966884f, -0.03365885f, 0.04593754f, -0.05234758f, 0.05031438f, 0.00813890f, 
    0.03178015f, 0.00165647f, 0.03709253f, 0.02607557f, -0.00706219f, -0.03335218f, -0.06279679f, -0.04674283f, 
    -0.04980355f, -0.07309153f, 0.03061389f, -0.00853078f, -0.07047395f, -0.04316972f, 0.03640839f, 0.06180550f, 
    0.04328014f, -0.07338376f, 0.01079978f, -0.02130906f, 0.05888474f, 0.04669354f, 0.06444380f, 0.06167968f, 
    0.00918208f, 0.05458433f, 0.01402812f, 0.03251387f, 0.02587360f, -0.06303182f, -0.05525120f, 0.05719721f, 
    0.01582790f, -0.03610699f, 0.02562201f, -0.00041803f, 0.03530302f, 0.00042174f, 0.02404124f, -0.05779246f, 
    -0.03900809f, 0.05993678f, 0.05101120f, 0.03355265f, -0.06022959f, -0.05824527f, -0.04063776f, -0.02469479f, 
    -0.05845135f, -0.01801479f, 0.03335842f, 0.01135815f, -0.00565564f, 0.03755552f, -0.00303099f, 0.06405886f, 
    -0.04445777f, 0.04231032f, -0.00619316f, -0.04424570f, -0.07453326f, 0.06591064f, -0.04311398f, -0.00232933f, 
    -0.06937784f, -0.05517586f, -0.04515079f, 0.03677515f, 0.06565707f, -0.06277382f, 0.00254274f, 0.01895296f, 
    -0.05091185f, -0.01788540f, -0.00508435f, -0.05391625f, 0.03441698f, -0.04341449f, -0.07519244f, -0.01123870f, 
    -0.03976496f, 0.00789029f, -0.04476113f, -0.00576887f, -0.07073830f, -0.02898315f, -0.00699170f, 0.02683437f, 
    -0.05154564f, 0.04831624f, 0.01267103f, -0.03631606f, -0.03519386f, 0.04179398f, 0.05214213f, -0.02987256f, 
    -0.02430039f, 0.05263333f, -0.05202758f, -0.05607345f, -0.03372890f, -0.06965862f, 0.00813965f, 0.05237290f, 
    0.03515304f, -0.01214986f, -0.01966351f, 0.12884262f, 0.05739188f, -0.02222938f, 0.07838896f, -0.01225567f, 
    0.04909966f, 0.07202426f, 0.13825999f, -0.04913430f, -0.02438792f, -0.08706982f, -0.03273344f, 0.11463378f, 
    -0.12399191f, -0.13255034f, 0.12603368f, 0.00070230f, -0.01401104f, -0.09360581f, -0.15853979f, 0.07757353f, 
    -0.02993963f, 0.14020762f, 0.12327434f, -0.06314906f, 0.05353346f, 0.04742444f, -0.04727769f, -0.15377831f, 
    -0.13767965f, -0.01966890f, -0.11949676f, 0.02640291f, -0.20863739f, 0.05969534f, -0.16401942f, 0.06347339f, 
    -0.07915727f, -0.08428336f, 0.12071421f, 0.02637164f, 0.04140783f, -0.04523753f, 0.06492615f, 0.05290986f, 
    0.27069572f, -0.05822733f, 0.21017158f, 0.23428424f, -0.04942690f, 0.01035124f, -0.00604161f, 0.07150378f, 
    -0.04194081f, 0.01330412f, -0.00828681f, 0.04290147f, -0.34222171f, 0.09538956f, 0.22890209f, -0.11216348f, 
    -0.00371520f, 0.03071707f, -0.10045461f, -0.01781656f, 0.07172230f, -0.12417900f, 0.11348798f, -0.05217501f, 
    -0.10749169f, 0.01163780f, -0.24380027f, -0.02445970f, -0.00028766f, 0.03609564f, 0.11967477f, 0.05551897f, 
    -0.01342060f, -0.07415365f, 0.11633431f, -0.11833826f, 0.49862674f, -0.02247949f, 0.29567808f, 0.01974916f, 
    -0.23422359f, 0.10083091f, -0.07900956f, -0.00145631f, 0.02626912f, 0.02702568f, -0.16159417f, -0.03472947f, 
    -0.06333905f, -0.23689449f, -0.22837749f, -0.07966150f, 0.09392145f, -0.11729148f, -0.01783004f, 0.14080733f, 
    -0.00824719f, 0.00308254f, -0.00284670f, 0.11513456f, 0.13993129f, 0.20106006f, 0.10878435f, 0.00646779f, 
    -0.04804034f, -0.06056897f, 0.11073441f, 0.03897607f, -0.02300819f, -0.04799483f, 0.03307194f, 0.04148783f, 
    -0.00703297f, 0.11429837f, 0.07593653f, 0.17063284f, -0.00762582f, -0.10558359f, -0.09760391f, 0.09321321f, 
    -0.07035536f, 0.01297171f, -0.04303124f, -0.01551850f, 0.15323488f, -0.04544834f, 0.06822456f, 0.14966945f, 
    0.03768606f, -0.21251759f, 0.06597243f, 0.01605250f, -0.05791487f, 0.04598159f, -0.05463639f, -0.04321889f, 
    0.24988079f, 0.04422218f, 0.00468831f, 0.06635452f, -0.02572560f, -0.02883029f, 0.12874755f, -0.01690091f, 
    -0.12130595f, -0.05516291f, -0.03841631f, 0.00459364f, 0.35414344f, 0.00648849f, 0.13050964f, 0.44389236f, 
    -0.04585996f, 0.03682838f, 0.08264332f, -0.05768551f, 0.01709022f, 0.01397927f, -0.03430459f, -0.00470612f, 
    0.08333515f, 0.04317964f, -0.11214660f, -0.27745071f, -0.05241848f, -0.10423350f, 0.05815770f, -0.10987392f, 
    -0.03181013f, 0.00024108f, 0.02194752f, 0.05738731f, -0.02642127f, 0.15596558f, 0.31688026f, 0.08356531f, 
    0.14100552f, -0.03208175f, -0.04784044f, 0.08486959f, 0.07512392f, 0.00706283f, -0.00268459f, -0.04053714f, 
    0.29674563f, 0.22021216f, -0.00557113f, 0.11994160f, -0.03452359f, -0.06924202f, 0.11380500f, 0.04409330f, 
    0.07451849f, -0.05048995f, -0.09602090f, 0.00879963f, -0.08509210f, -0.07339971f, 0.01679498f, -0.02694375f, 
    -0.05748175f, -0.01406177f, -0.02034595f, -0.04757292f, -0.04814994f, 0.08868394f, 0.12130833f, -0.11515715f, 
    -0.10135856f, 0.10298390f, 0.01931069f, 0.00956151f, -0.04872797f, 0.07555214f, -0.00780455f, -0.00036287f, 
    0.09424276f, -0.10455205f, -0.06388655f, -0.00755041f, 0.23596257f, 0.27268559f, 0.03915467f, -0.01957931f, 
    -0.08177283f, -0.15018620f, -0.02646220f, 0.06912420f, 0.10636463f, 0.04729690f, 0.06489803f, 0.01224681f, 
    0.13683794f, 0.09164022f, 0.00006662f, -0.02852237f, -0.01918631f, 0.02943395f, -0.02630981f, 0.09307159f, 
    -0.05773807f, -0.04380702f, 0.19484544f, 0.07757594f, 0.14949426f, -0.02151751f, -0.06710657f, 0.00173617f, 
    0.08034689f, 0.06025545f, -0.00959200f, 0.04777132f, 0.09905041f, 0.05221228f, 0.00952805f, 0.07278556f, 
    0.49630311f, 0.11597439f, -0.07555576f, 0.08928597f, -0.01812761f, -0.06441278f, 0.04637545f, -0.07157212f, 
    0.11792594f, 0.04047658f, 0.09039825f, 0.05129474f, 0.53586751f, -0.17366658f, -0.10742041f, 0.10978971f, 
    0.05028023f, 0.13069606f, 0.21454901f, 0.00326095f, -0.07770135f, 0.09559351f, 0.22124924f, 0.08342759f, 
    -0.35551521f, 0.09293692f, -0.01902542f, 0.03351549f, -0.06934074f, 0.06121697f, 0.15276918f, 0.02439721f, 
    0.19556636f, -0.04266531f, -0.12837221f, 0.06321347f, 0.26996559f, -0.11225410f, -0.08919585f, 0.02464622f, 
    0.15739930f, -0.09864309f, 0.09485029f, 0.04033214f, -0.08233690f, -0.05011061f, 0.04167122f, -0.05552170f, 
    -0.11371703f, 0.02920746f, -0.02400130f, 0.01331292f, 0.11252133f, 0.13785157f, -0.13605563f, 0.19254170f, 
    -0.16216019f, 0.03279344f, -0.05701948f, 0.01203222f, -0.27429056f, 0.09159075f, -0.04273457f, -0.10559572f, 
    0.02220239f, -0.01142183f, 0.20144515f, -0.04906061f, -0.02400326f, -0.01010535f, 0.03103907f, -0.02468603f, 
    -0.46426868f, 0.19843352f, 0.08314840f, 0.11819949f, 0.18215400f, 0.07033885f, 0.20056164f, 0.11389770f, 
    0.17401604f, 0.03248268f, 0.07461221f, -0.10310933f, 0.16141725f, 0.06511907f, -0.03151050f, -0.13032208f, 
    0.05709355f, -0.03786341f, -0.06879513f, 0.06614807f, 0.05951959f, -0.03557586f, -0.13857803f, -0.22689354f, 
    -0.07564204f, -0.23612553f, -0.15923682f, 0.12672348f, -0.01486538f, 0.03481858f, -0.02991088f, 0.10347337f, 
    0.04453820f, 0.00450291f, -0.03132840f, 0.00461084f, 0.09786869f, -0.02114717f, -0.15515554f, -0.00566822f, 
    0.06424856f, 0.03822186f, 0.14308828f, -0.06309312f, -0.09398850f, 0.03563917f, 0.14394827f, 0.02431258f, 
    -0.09429230f, 0.04091955f, -0.09995999f, 0.18388057f, 0.00558876f, 0.26439485f, -0.14384377f, 0.03379477f, 
    0.07462635f, 0.02375531f, -0.00368438f, -0.03284800f, 0.08570901f, 0.08762874f, 0.20040408f, -0.07832496f, 
    -0.07889374f, -0.02143201f, 0.17728901f, 0.15825818f, -0.13951905f, 0.05580891f, 0.01903295f, 0.10337600f, 
    -0.09485965f, 0.19538061f, 0.37515074f, 0.03410537f, 0.08086763f, 0.03536513f, 0.08194340f, -0.06201629f, 
    0.05310803f, 0.03414994f, -0.00964168f, 0.02651831f, -0.41396323f, 0.04521977f, -0.22420108f, 0.22453739f, 
    0.06161975f, 0.10333817f, -0.10121111f, -0.04020688f, 0.07078790f, 0.09107834f, -0.02264143f, 0.14247529f, 
    -0.29964396f, -0.04630083f, 0.11504313f, -0.16790742f, -0.22039215f, 0.03167117f, 0.11574687f, 0.03520193f, 
    0.14260581f, -0.02518903f, 0.08900163f, 0.08840436f, 0.06356122f, 0.05041173f, 0.03973905f, 0.02941869f, 
    0.02625493f, 0.09539640f, 0.10606311f, -0.01557537f, 0.14866561f, 0.04409810f, 0.05863670f, 0.03185401f, 
    -0.36555958f, 0.04834335f, -0.02681459f, 0.31744218f, 0.20634559f, -0.08570147f, -0.16927218f, 0.03984713f, 
    -0.05543498f, 0.01755861f, 0.04388031f, 0.06858618f, -0.17788857f, 0.07004273f, 0.10222691f, -0.09509306f, 
    -0.02984320f, -0.10228761f, 0.10830867f, 0.11322268f, 0.09132704f, -0.09685529f, -0.00271645f, 0.12017674f, 
    0.21663901f, 0.05662546f, 0.34488213f, 0.08262709f, 0.13051453f, 0.10350507f, 0.12766913f, 0.01712687f, 
    0.02269824f, 0.03777586f, 0.08792559f, 0.04472544f, -0.01209797f, 0.29148474f, -0.32231259f, -0.03603260f, 
    -0.01154255f, 0.17914799f, 0.02985418f, -0.11142606f, 0.22949818f, -0.06368218f, -0.03109266f, -0.06265084f, 
    -0.03455135f, -0.03407168f, -0.00776883f, -0.05978582f, 0.08382063f, -0.01289941f, 0.08295427f, -0.02876341f, 
    0.03873315f, 0.02234881f, 0.01107483f, 0.03492771f, -0.04826244f, -0.29687443f, 0.14029627f, 0.03135533f, 
    0.08895169f, 0.01131231f, -0.17569363f, -0.00961465f, -0.08358207f, 0.08294073f, 0.12301408f, 0.22616829f, 
    -0.07889678f, -0.16413854f, -0.03031038f, 0.24216478f, -0.13568607f, -0.01364084f, -0.17963105f, -0.01982948f, 
    0.01971280f, 0.08768492f, 0.06387852f, 0.17868511f, 0.07573298f, 0.07164907f, 0.28437811f, -0.17922860f, 
    -0.05119318f, -0.02345561f, -0.00215736f, 0.02655118f, -0.03644957f, 0.16099513f, 0.13259530f, -0.12716089f, 
    0.20049481f, 0.04365564f, -0.12756883f, 0.03251170f, -0.05626674f, 0.03841453f, -0.10697746f, 0.08406556f, 
    0.09138094f, 0.03998060f, -0.07180436f, 0.05118665f, -0.34558421f, 0.10565290f, 0.14176117f, -0.24133079f, 
    -0.06598971f, -0.01347871f, 0.07227851f, 0.05431063f, 0.02891036f, -0.01501036f, 0.07599681f, 0.13375703f, 
    -0.07893874f, -0.00671985f, -0.06348013f, -0.00062223f, 0.01445633f, -0.08244805f, 0.01824166f, -0.03653513f, 
    -0.06972025f, 0.05021890f, 0.06098751f, 0.04479185f, -0.05722221f, -0.01391228f, 0.03039136f, -0.06781658f, 
    -0.03307928f, -0.05469334f, -0.05185560f, -0.06852180f, -0.01325525f, -0.00654045f, -0.00906119f, 0.04747740f, 
    0.03044747f, -0.01508105f, -0.05114179f, -0.00270996f, -0.05136329f, -0.04025969f, 0.04638698f, 0.03720109f, 
    -0.01879303f, 0.01330987f, 0.04756424f, -0.02745084f, 0.01515546f, 0.03404023f, -0.04080473f, -0.04994747f, 
    0.02681888f, 0.01193867f, 0.01914603f, 0.04306874f, 0.00609678f, -0.00982291f, 0.00211141f, -0.03273196f, 
    0.05624672f, -0.07986694f, 0.01496911f, 0.04308925f, -0.03427828f, -0.06958892f, -0.05554226f, 0.01661030f, 
    0.01519314f, -0.03168099f, 0.00022329f, 0.05355822f, -0.07293405f, -0.01786263f, -0.04071879f, -0.01659991f, 
    -0.05236217f, -0.07203941f, 0.03350845f, -0.05824643f, -0.04284056f, -0.02929782f, -0.07142550f, -0.07783020f, 
    0.05243437f, 0.01999936f, 0.05918895f, 0.03344494f, -0.04945418f, -0.06955080f, -0.04416371f, -0.00083211f, 
    0.06278479f, -0.02924351f, -0.01506621f, 0.04330338f, -0.01541361f, -0.02712716f, 0.04719758f, 0.00801186f, 
    0.02503977f, 0.04230823f, -0.01330195f, 0.00638969f, -0.00456062f, 0.04168293f, -0.01366396f, -0.07353237f, 
    -0.05567560f, -0.04990064f, -0.04944228f, -0.05975591f, 0.05910024f, 0.02787929f, -0.04322732f, -0.04392863f, 
    0.02346703f, -0.05561037f, 0.00599881f, -0.03657548f, -0.00283095f, 0.05197205f, -0.04977959f, -0.04089010f, 
    -0.06290713f, 0.05851024f, -0.00006358f, -0.05775914f, -0.04772442f, -0.00276308f, 0.05215016f, -0.05899760f, 
    0.05917103f, -0.06672062f, -0.00617575f, 0.02233053f, 0.05542853f, -0.00112468f, 0.02926594f, -0.02100435f, 
    -0.05702957f, -0.02197766f, -0.03626500f, -0.03424070f, -0.05481427f, -0.05587193f, 0.03701563f, 0.03253878f, 
    -0.03903960f, 0.03939523f, -0.03955672f, 0.06013698f, -0.01275987f, 0.03156723f, -0.07444651f, -0.01392864f, 
    -0.02493977f, -0.00233625f, 0.04203378f, -0.03746933f, 0.00528602f, -0.01376172f, -0.03767559f, 0.01083894f, 
    -0.00620916f, -0.02018189f, 0.03826705f, 0.05079094f, 0.04858835f, -0.05677958f, 0.02385435f, 0.01256877f, 
    -0.03417476f, 0.02199491f, 0.05807346f, -0.01105757f, 0.05443311f, 0.02342385f, -0.07274750f, -0.03898303f, 
    -0.03443096f, 0.02829538f, -0.01792869f, 0.02248247f, 0.03531888f, 0.01396011f, -0.00736720f, 0.02790037f, 
    -0.00249185f, -0.05678665f, -0.03620087f, -0.06426757f, 0.03546687f, 0.04726443f, 0.03060445f, -0.06007792f, 
    0.01719539f, -0.00730986f, -0.00706651f, -0.06958461f, 0.02435460f, 0.05744975f, 0.01536477f, 0.03293853f, 
    -0.05250859f, -0.05509662f, 0.03849027f, 0.01170904f, -0.07764607f, -0.06957164f, 0.02459913f, -0.04799963f, 
    -0.03723942f, -0.02809355f, -0.01007140f, -0.05635591f, -0.06965757f, -0.02990143f, -0.03069388f, 0.03169010f, 
    -0.00527129f, 0.02397492f, 0.06449597f, -0.05115844f, -0.03955016f, -0.07214268f, -0.04988388f, 0.01205888f, 
    -0.04525397f, 0.03394916f, -0.03460091f, -0.01489319f, -0.03736839f, 0.02792287f, -0.03821508f, 0.02694950f, 
    -0.01484707f, 0.01077362f, -0.06296919f, 0.00638689f, -0.03923532f, 0.01591357f, 0.04513036f, 0.03608768f, 
    -0.01729202f, 0.01756494f, 0.00725435f, -0.00115154f, -0.02842624f, -0.06441186f, -0.02094379f, -0.02459859f, 
    0.06275318f, -0.03444397f, 0.00481872f, 0.04991055f, -0.01231553f, -0.00624430f, -0.02505693f, -0.03827303f, 
    -0.04686067f, -0.01637932f, 0.02956133f, 0.03888607f, -0.00398310f, 0.03970266f, 0.05524507f, -0.06498542f, 
    0.01022245f, 0.00059436f, 0.00473305f, -0.02989305f, 0.03743564f, -0.03158922f, -0.07154278f, -0.06097211f, 
    -0.05923143f, 0.06025942f, 0.06289881f, 0.03592838f, 0.02547826f, 0.02857760f, 0.05902996f, -0.02121257f, 
    -0.06009636f, -0.07881408f, -0.01162739f, -0.02675259f, -0.06253231f, 0.02296226f, -0.05889091f, 0.03253889f, 
    0.00912085f, 0.02118701f, -0.06705580f, -0.05670923f, -0.05313959f, -0.05597408f, -0.02434289f, -0.01718116f, 
    0.05525520f, -0.04888701f, 0.03975879f, 0.02666447f, 0.01208829f, 0.06286912f, -0.04306201f, 0.02913271f, 
    0.05806433f, -0.00521227f, -0.04581351f, 0.05325190f, -0.07662323f, -0.03104810f, 0.03465986f, 0.06617881f, 
    -0.05202582f, -0.02547830f, -0.06022275f, 0.03086483f, -0.03013730f, 0.04301982f, -0.05746002f, -0.04256039f, 
    -0.07998106f, 0.00586540f, 0.04163005f, 0.05224812f, 0.00880306f, 0.01505520f, -0.00750558f, -0.02659589f, 
    0.03526093f, -0.04583174f, 0.01112027f, 0.03317763f, -0.03975942f, 0.05230039f, -0.01604764f, -0.03772091f, 
    -0.06415186f, 0.04641441f, -0.00210950f, 0.01210872f, -0.05330608f, 0.05068551f, -0.06760642f, -0.02557050f, 
    -0.05338366f, -0.03219896f, -0.05239879f, -0.03304420f, 0.00163408f, -0.03847888f, -0.07430870f, 0.01570046f, 
    -0.00138863f, 0.00448456f, -0.07129882f, 0.06512716f, 0.00917553f, 0.01625566f, -0.03917137f, -0.06917629f, 
    0.03778502f, 0.05701063f, -0.03465426f, -0.03151402f, 0.04685047f, -0.01218452f, 0.05586793f, 0.02608592f, 
    0.02194696f, 0.06751086f, -0.03283716f, -0.00187807f, -0.04284443f, -0.04558998f, -0.01184310f, 0.06447325f, 
    -0.06831688f, -0.05799184f, -0.07146864f, 0.01772393f, -0.03347857f, -0.03333937f, -0.02489198f, 0.01945028f, 
    0.01095155f, -0.04153838f, -0.00619537f, -0.00584816f, 0.01460646f, 0.01192468f, -0.00922944f, -0.02305589f, 
    -0.17597030f, 0.15074955f, -0.18847100f, -0.09600732f, 0.23676249f, 0.03480669f, -0.08325909f, -0.04802474f, 
    -0.14430694f, 0.06699964f, 0.06344484f, 0.07647720f, 0.03061333f, 0.24315713f, -0.00976206f, 0.19791670f, 
    0.11517704f, -0.13250749f, 0.00439349f, 0.08325263f, -0.04448432f, -0.05566599f, -0.03889729f, 0.08772214f, 
    0.33149156f, -0.40139475f, -0.21210758f, -0.06085991f, 0.02665435f, -0.03450869f, -0.21510527f, -0.06417090f, 
    -0.03184434f, -0.06014781f, 0.17190841f, 0.04974386f, 0.22162309f, -0.03394751f, 0.05559267f, -0.18034603f, 
    0.13699609f, -0.01691410f, 0.00975170f, 0.02093719f, 0.01308808f, -0.02832964f, -0.06620808f, 0.04716283f, 
    -0.02972246f, 0.10061589f, -0.22309035f, -0.18902212f, 0.11125138f, -0.00973466f, 0.06251156f, -0.18590280f, 
    0.08263499f, 0.02389864f, -0.03745227f, -0.07953636f, 0.09757981f, 0.01786563f, -0.16278374f, 0.03382391f, 
    -0.01028775f, -0.04001595f, -0.08413441f, 0.04728688f, 0.03796276f, 0.04136716f, 0.11810321f, 0.00703043f, 
    0.28372586f, -0.19725308f, -0.07465249f, 0.03028708f, 0.06062188f, 0.02861509f, 0.09663349f, 0.05800063f, 
    0.01765252f, -0.03698231f, 0.14011088f, 0.13420591f, 0.15294188f, -0.11173168f, 0.12763794f, 0.00498778f, 
    0.00839289f, -0.00368661f, -0.11167970f, 0.09232505f, -0.00068791f, 0.00294896f, 0.01999054f, -0.14103444f, 
    -0.01725327f, 0.04349240f, 0.00636777f, -0.01503803f, -0.04631899f, -0.03382619f, -0.07905903f, 0.02057405f, 
    0.05053233f, -0.00356015f, 0.01628287f, -0.03832088f, 0.17343593f, 0.18066885f, 0.25049278f, 0.05577379f, 
    -0.04620939f, -0.10472886f, -0.04443046f, 0.04766873f, -0.09828433f, 0.00145380f, 0.04328888f, 0.02844936f, 
    -0.07329490f, 0.03618256f, 0.19793431f, 0.10043911f, -0.04650756f, -0.00330633f, 0.15502051f, 0.02172171f, 
    0.01419539f, 0.01445541f, -0.01618878f, 0.12507883f, 0.29209653f, 0.14121364f, -0.11262727f, -0.03549843f, 
    -0.09316310f, 0.09100201f, 0.01877676f, -0.08694442f, 0.12580509f, -0.03298645f, -0.04777197f, 0.03606250f, 
    0.08346603f, 0.07750741f, -0.05971232f, 0.09856947f, 0.14142452f, 0.05446291f, 0.02660456f, -0.01939955f, 
    0.06686307f, -0.02818225f, -0.09570019f, -0.01395728f, -0.27084324f, -0.23452969f, -0.00041189f, -0.33190548f, 
    0.23837967f, 0.01876260f, 0.00860476f, -0.20979370f, 0.08049256f, -0.05295713f, 0.01043102f, 0.00363272f, 
    -0.33047569f, 0.18324694f, -0.07185553f, 0.20981885f, 0.14296082f, 0.03825575f, -0.06865091f, 0.10593945f, 
    0.12292679f, 0.01254068f, 0.13706307f, 0.04534210f, 0.14559649f, 0.08865790f, 0.05587908f, 0.06198855f, 
    -0.01249657f, 0.04413695f, -0.02542930f, -0.05343468f, -0.05978514f, -0.03711895f, 0.08537911f, -0.20747119f, 
    -0.07839821f, 0.01544059f, 0.07935978f, 0.11789416f, 0.02250086f, -0.14153682f, 0.13286804f, -0.08602736f, 
    -0.07054542f, 0.16891129f, -0.01287336f, 0.10816933f, -0.13275585f, -0.03175210f, -0.21467286f, 0.12441060f, 
    -0.10378802f, -0.05324733f, 0.19358386f, -0.05859247f, 0.11716670f, -0.04139499f, -0.20149471f, 0.13390908f, 
    0.14143459f, -0.03967957f, -0.14602932f, -0.14587876f, -0.01060612f, -0.00983137f, -0.15382631f, -0.07107717f, 
    0.00001930f, -0.00165260f, 0.10360326f, 0.02983673f, 0.01701055f, 0.09363373f, 0.15886031f, 0.08030028f, 
    0.06425422f, -0.07139749f, 0.02939777f, -0.02262439f, 0.06989369f, -0.13356841f, 0.06232575f, 0.00022819f, 
    0.19599740f, -0.08203493f, 0.27331826f, 0.06847028f, 0.02274840f, 0.05550948f, 0.04115307f, -0.05036786f, 
    -0.02836844f, 0.01199036f, 0.02617164f, -0.04209724f, -0.17139445f, 0.02746077f, 0.03826081f, 0.01254577f, 
    0.02492892f, 0.07384755f, -0.00774647f, 0.00369371f, 0.14274763f, -0.09815461f, 0.17111771f, 0.01416444f, 
    -0.01706428f, 0.00098036f, 0.02507617f, 0.00020201f, 0.04571444f, 0.01064044f, 0.05536671f, 0.05164568f, 
    -0.02247317f, -0.05491407f, 0.09152412f, 0.05373733f, 0.29081041f, -0.11807413f, 0.01629255f, -0.13632460f, 
    -0.00337602f, 0.07025217f, -0.17439225f, -0.04177665f, -0.03447456f, -0.09172057f, -0.10217543f, -0.00557779f, 
    -0.14846879f, -0.26176119f, -0.14042050f, 0.09821855f, -0.01155226f, -0.00887443f, -0.04225360f, 0.07531616f, 
    0.05083014f, -0.06847677f, 0.07209182f, -0.07047059f, 0.09522863f, 0.16307828f, 0.03172427f, 0.09445602f, 
    0.06734905f, -0.07805497f, 0.03383240f, 0.16931304f, -0.02740571f, 0.07567447f, 0.09903399f, 0.19098368f, 
    -0.12332028f, -0.14188786f, 0.04047324f, 0.13422404f, -0.06425699f, 0.04871572f, -0.09387759f, 0.15750030f, 
    0.16221474f, 0.11245326f, 0.02814687f, 0.10485932f, 0.15779801f, 0.12637006f, -0.12699921f, 0.06111639f, 
    0.10360333f, -0.11210898f, -0.10005558f, -0.04667893f, 0.02968109f, -0.05561662f, -0.01668846f, -0.00907599f, 
    0.26677826f, 0.07524232f, 0.11034577f, 0.02999206f, 0.02375807f, 0.06063285f, 0.09950757f, 0.08904084f, 
    0.13257223f, -0.02384133f, -0.05119769f, -0.16304493f, 0.10841582f, -0.09302469f, 0.07806061f, 0.21488440f, 
    0.08593088f, 0.06256049f, -0.09348248f, -0.03129887f, 0.09667321f, -0.02793038f, 0.06362539f, -0.01591140f, 
    -0.33790281f, -0.03854081f, -0.02882064f, -0.20796111f, -0.00921487f, 0.06341506f, 0.04086623f, -0.07581007f, 
    0.05495660f, 0.05259689f, -0.01601451f, 0.01986116f, 0.07205646f, -0.00362699f, -0.01588677f, 0.00034089f, 
    0.06966621f, 0.08427035f, -0.11404984f, -0.02843016f, 0.17609872f, -0.10716646f, -0.03678845f, -0.04523806f, 
    -0.03588074f, 0.03868837f, 0.00510603f, -0.04407923f, 0.04772653f, 0.05949846f, 0.01934869f, -0.00933018f, 
    -0.00380342f, -0.01434894f, -0.00707932f, -0.07799428f, -0.06994753f, -0.00767141f, -0.00543111f, -0.06023460f, 
    -0.04602089f, -0.02439259f, -0.05159039f, 0.02799810f, 0.04498127f, 0.00487038f, -0.00355374f, -0.04818088f, 
    0.01138646f, -0.02350492f, 0.01529730f, -0.00665280f, 0.04587727f, -0.05415135f, -0.07447065f, 0.05195706f, 
    0.06223125f, -0.03996208f, -0.07190357f, -0.05494722f, -0.01304477f, 0.02426268f, 0.05429780f, 0.02958896f, 
    0.04904201f, -0.00462001f, -0.04194832f, -0.07547244f, -0.01427894f, -0.07284366f, -0.04982257f, -0.01081333f, 
    -0.03386522f, 0.02036987f, -0.06604853f, -0.03839565f, -0.06727518f, -0.03893806f, -0.07115839f, 0.03115985f, 
    0.01381482f, 0.03386492f, 0.05178082f, -0.05093452f, -0.07300643f, -0.05400731f, -0.01420485f, -0.02421482f, 
    0.01167755f, 0.06706499f, -0.03294691f, -0.05520888f, 0.05548569f, 0.00265381f, -0.07482533f, 0.04941050f, 
    -0.05672990f, 0.00284223f, -0.00682789f, 0.06362277f, 0.03024728f, -0.05981150f, -0.03616372f, 0.02471675f, 
    0.05874159f, 0.04316992f, 0.00305548f, 0.05299075f, -0.02517739f, 0.00429139f, 0.07585813f, 0.04956844f, 
    0.02054178f, -0.05649232f, -0.06546177f, 0.04361960f, -0.05237297f, -0.06473330f, 0.06230201f, -0.07066699f, 
    0.00974282f, -0.02327795f, -0.03936215f, 0.00608870f, 0.02259746f, -0.05631664f, 0.02204276f, 0.01444617f, 
    -0.02581548f, -0.00296638f, -0.03127472f, -0.06704161f, -0.05651304f, -0.02272468f, -0.06073407f, -0.04336901f, 
    0.04961096f, -0.03317914f, -0.02885564f, 0.01732434f, -0.03105557f, 0.05055273f, -0.00094156f, -0.00795463f, 
    0.02442716f, 0.02240306f, -0.03030038f, 0.05067759f, -0.05321725f, -0.03358583f, 0.02346985f, -0.07906830f, 
    0.00225323f, 0.01587492f, 0.06584619f, -0.04103693f, -0.02065398f, 0.01957299f, 0.00576829f, -0.04408012f, 
    0.03462282f, -0.00104080f, -0.03428691f, 0.05631727f, -0.04031849f, -0.06645316f, 0.00234980f, 0.05052027f, 
    0.02327911f, 0.06284069f, 0.00296629f, 0.06408390f, -0.07343918f, 0.02940519f, -0.02648274f, -0.03221663f, 
    -0.06295383f, -0.04065341f, 0.04942372f, 0.06268239f, -0.00833743f, -0.05615886f, -0.03517996f, -0.03946444f, 
    0.05476882f, -0.05239655f, 0.00292714f, 0.00315331f, -0.02856625f, 0.03180946f, 0.05526273f, -0.07696906f, 
    -0.00135219f, 0.02638453f, 0.01695917f, 0.01193935f, -0.06357507f, 0.04205001f, -0.02081638f, 0.06075230f, 
    0.05025569f, 0.05984308f, -0.06222559f, -0.04269730f, -0.03103282f, 0.01397357f, 0.00979794f, 0.05846168f, 
    -0.03708067f, -0.04778385f, -0.00120237f, -0.03569038f, 0.02881141f, -0.04367160f, -0.05492620f, 0.00994252f, 
    -0.29478720f, 0.21815129f, 0.07828248f, -0.15654969f, 0.09911655f, 0.06854286f, -0.04218410f, -0.06579784f, 
    -0.06175806f, 0.09810656f, 0.15865324f, 0.09718971f, -0.23712799f, 0.08683597f, 0.08643977f, 0.01416339f, 
    -0.06828117f, 0.10019239f, -0.01651338f, -0.03712624f, 0.03739886f, -0.10532440f, 0.08024318f, -0.12702093f, 
    0.32167536f, -0.14296570f, -0.25030142f, 0.06824701f, -0.07424631f, -0.08607227f, -0.01383119f, -0.02279448f, 
    0.05798409f, 0.03243429f, 0.01504559f, -0.01013243f, -0.36993271f, 0.21040154f, 0.04549016f, 0.00704132f, 
    0.13566311f, -0.01411066f, 0.01470763f, 0.00435525f, 0.01616868f, -0.04249341f, 0.04357281f, -0.06508302f, 
    -0.01371735f, -0.04049440f, 0.21348472f, -0.26518005f, 0.11682825f, -0.01079061f, 0.10139935f, -0.09131311f, 
    0.11096513f, 0.08615541f, -0.03808537f, 0.01391829f, -0.04980370f, -0.02420534f, -0.13805558f, 0.08599886f, 
    0.13090754f, 0.00350094f, 0.04621327f, 0.00930165f, 0.07630333f, -0.01529712f, 0.05444313f, -0.12666950f, 
    -0.00826730f, -0.05062147f, -0.16924888f, -0.00135069f, 0.10204957f, 0.03732783f, 0.04218933f, 0.07893707f, 
    0.00222234f, 0.08968692f, 0.07874149f, -0.06660795f, 0.33882016f, 0.00597551f, 0.17675532f, -0.23017991f, 
    0.12047595f, -0.04686303f, 0.02950064f, 0.09071103f, -0.01680614f, -0.08666872f, -0.03428915f, 0.02855368f, 
    -0.21417241f, 0.19784266f, -0.06645524f, 0.05124660f, 0.03408379f, 0.12623674f, 0.05099971f, -0.14521231f, 
    0.02352859f, 0.13616465f, -0.01590428f, -0.05803951f, -0.07737827f, 0.18745944f, 0.01400646f, 0.07049334f, 
    0.08326274f, -0.07980429f, -0.01751632f, 0.00793280f, 0.07798720f, -0.10360687f, 0.03237565f, -0.03150116f, 
    0.04789578f, 0.02931164f, 0.06631652f, 0.13709095f, -0.08292256f, -0.03646681f, 0.00359364f, 0.09390841f, 
    0.08308907f, 0.13232818f, -0.05394839f, -0.02039549f, 0.09770820f, 0.04304258f, -0.17308211f, -0.17520301f, 
    -0.02239711f, -0.04387758f, -0.05008825f, -0.06240112f, -0.05621273f, -0.16467956f, -0.04645152f, 0.08929101f, 
    0.10410931f, 0.15886924f, -0.16630007f, 0.21191098f, 0.04266800f, -0.03227373f, 0.08066192f, -0.13740373f, 
    0.11582312f, -0.01190164f, -0.13885111f, -0.01309271f, -0.11357197f, 0.05847042f, 0.13169949f, -0.43618333f, 
    0.09595953f, -0.04029246f, -0.12947385f, 0.00530006f, -0.02004760f, 0.12649022f, 0.06471363f, -0.02928720f, 
    0.02235236f, -0.18091275f, -0.18756941f, 0.26751786f, 0.18988611f, 0.01500601f, 0.08134025f, 0.10081043f, 
    0.00542622f, 0.08919559f, 0.09632824f, 0.07779136f, 0.18617365f, 0.07804621f, -0.05154821f, 0.15669826f, 
    -0.08055945f, 0.13916703f, 0.04597761f, -0.03553418f, 0.02159562f, -0.09815966f, 0.03490660f, -0.05319883f, 
    0.25161046f, 0.07809350f, -0.31114578f, 0.17141871f, 0.04899857f, -0.02664459f, -0.05070500f, 0.03272397f, 
    0.03322703f, -0.04347683f, -0.05972736f, -0.00088991f, -0.23805331f, -0.14369871f, 0.15789121f, -0.07535047f, 
    0.07511266f, -0.01658528f, 0.25007895f, 0.14036539f, 0.07126139f, 0.10051864f, -0.12690812f, -0.12436918f, 
    -0.31055051f, 0.02628389f, 0.21796247f, 0.17695518f, -0.09078984f, 0.00164191f, -0.11078284f, -0.05480523f, 
    -0.06660348f, -0.04598535f, 0.03662155f, -0.01931584f, 0.39363232f, -0.09075484f, -0.25313184f, -0.18657298f, 
    -0.07343796f, -0.08740159f, -0.09837695f, 0.07187991f, 0.06815568f, -0.07631420f, 0.03402213f, 0.13083267f, 
    0.13217762f, -0.11054291f, -0.08272495f, 0.28719032f, 0.15494512f, 0.06619067f, -0.03119693f, -0.03163981f, 
    -0.00935779f, 0.02950710f, 0.08483575f, 0.02017776f, 0.15271065f, 0.01219644f, -0.01996366f, 0.13405867f, 
    -0.11163618f, -0.04329631f, 0.02095181f, 0.16191007f, 0.07690281f, -0.01940054f, 0.09210058f, 0.02322405f, 
    0.41650406f, 0.01376494f, -0.21862619f, 0.06233582f, -0.04319206f, -0.10134256f, 0.09875444f, -0.06442789f, 
    0.02010587f, -0.08758374f, 0.10902315f, 0.03321740f, -0.57183909f, 0.24379914f, 0.13454269f, -0.05718048f, 
    0.02659679f, -0.00858684f, 0.16472524f, -0.04301745f, 0.00124044f, 0.05926695f, 0.01575269f, -0.00984831f, 
    0.20920463f, 0.16762657f, -0.20144612f, -0.19311468f, -0.04646854f, 0.02384056f, -0.05374910f, 0.04579368f, 
    -0.06215222f, -0.01466779f, 0.10667510f, -0.06256117f, 0.07569485f, 0.11715961f, -0.02503341f, 0.19574384f, 
    0.05549660f, 0.00916493f, -0.03695394f, 0.11613948f, 0.02037820f, 0.09087669f, -0.12515005f, -0.10924971f, 
    0.08281736f, 0.10564371f, -0.15302490f, 0.09368212f, 0.05884162f, -0.00119818f, -0.08291537f, 0.06449459f, 
    -0.05570278f, -0.11555152f, -0.19356045f, -0.07323024f, -0.08573423f, 0.10388929f, 0.00459463f, 0.03518546f, 
    -0.21809940f, -0.13391158f, 0.04285778f, 0.13431196f, 0.01687729f, 0.15908438f, 0.00701851f, 0.00526913f, 
    -0.02654213f, 0.04281352f, 0.00675833f, -0.11722960f, 0.14165165f, -0.00133618f, 0.00381802f, -0.00224343f, 
    0.02857670f, -0.03466634f, -0.10086651f, -0.00692140f, 0.26403648f, 0.03967969f, 0.15896088f, 0.31328529f, 
    0.10531377f, -0.02468736f, 0.06457177f, -0.08728260f, -0.03855138f, 0.01605021f, 0.08178867f, -0.02035202f, 
    0.16816612f, -0.08123746f, 0.07966813f, 0.20838326f, 0.07232577f, -0.04332402f, -0.06672856f, -0.01296314f, 
    0.04717582f, -0.08720966f, 0.01730542f, 0.00454076f, -0.17841409f, 0.17799845f, 0.15939033f, 0.13396011f, 
    -0.07142591f, 0.00097563f, -0.00548047f, -0.03871389f, 0.03854734f, 0.05435183f, -0.01784902f, -0.14494924f, 
    0.26805136f, 0.14713247f, -0.04936713f, 0.00685338f, 0.05131184f, -0.14139892f, 0.03571646f, 0.02417098f, 
    -0.04319154f, 0.09773021f, 0.09439377f, 0.20529710f, -0.30823058f, -0.02297946f, -0.28134361f, 0.04311730f, 
    -0.08795673f, -0.08927140f, 0.06443824f, -0.07172420f, 0.10723482f, -0.03829045f, -0.14177255f, -0.10953113f, 
    0.00352240f, 0.07697341f, -0.16337872f, -0.10961237f, -0.04668518f, 0.12329850f, -0.03148491f, 0.10000290f, 
    -0.05254814f, -0.01905663f, 0.09923608f, 0.11015997f, -0.00734787f, 0.08205941f, -0.01690068f, 0.09236025f, 
    0.03941820f, -0.08461980f, 0.16614816f, 0.01956305f, 0.04275982f, -0.10211370f, 0.16276379f, -0.00417704f, 
    0.16339655f, -0.33738622f, 0.18169333f, 0.09476403f, 0.05521286f, 0.02709160f, 0.02258026f, -0.12944518f, 
    -0.04477644f, 0.03408011f, -0.01823609f, -0.02017585f, -0.07239835f, -0.04122167f, 0.11379880f, 0.02202883f, 
    0.08779828f, -0.00223601f, -0.00643800f, -0.03401376f, 0.02625458f, -0.08705151f, 0.13398644f, -0.05676560f, 
    0.26326469f, 0.04484335f, -0.24173471f, -0.02783160f, -0.06627181f, -0.02551855f, 0.05696192f, 0.03541931f, 
    0.13132039f, 0.03763332f, 0.04737017f, -0.05778689f, 0.22075129f, 0.00946828f, -0.12829839f, -0.00603822f, 
    0.09610370f, 0.09111136f, 0.03104833f, -0.04567278f, 0.00701687f, -0.07024504f, 0.03726919f, 0.00465718f, 
    -0.20528503f, -0.05318286f, -0.14215301f, -0.03996755f, 0.01016831f, 0.05997086f, 0.04717640f, 0.03065188f, 
    -0.04887715f, 0.08777273f, 0.12389357f, 0.05769532f, 0.09961233f, -0.02248049f, -0.04544630f, -0.01439540f, 
    0.16042368f, -0.01316283f, -0.00716482f, -0.00993916f, -0.08930247f, 0.07969029f, 0.13004583f, 0.11448258f, 
    0.06253143f, -0.02054496f, -0.08605848f, -0.04070272f, -0.04722846f, -0.02352318f, -0.08885656f, 0.06368078f, 
    0.08261745f, 0.17444865f, -0.10374016f, 0.16189282f, -0.06799289f, 0.11497783f, -0.23997821f, 0.00318620f, 
    0.05176305f, -0.11552653f, -0.15389548f, -0.00538242f, 0.08996130f, -0.00213211f, -0.10931397f, -0.09047672f, 
    0.02310293f, 0.13226122f, 0.02892923f, -0.09194288f, 0.01485334f, 0.02022079f, 0.09328428f, 0.05394676f, 
    0.00643955f, 0.00010617f, -0.18933924f, -0.08683141f, 0.04835625f, -0.19705112f, -0.08225321f, 0.09626137f, 
    0.08006810f, 0.06138895f, -0.17600849f, -0.13264729f, 0.13633065f, -0.02399101f, 0.06097782f, 0.09743507f, 
    -0.14995944f, -0.15602946f, 0.05429363f, 0.05538612f, 0.07185069f, -0.04512609f, 0.06188327f, -0.02657355f, 
    0.05754451f, -0.08362257f, 0.09903761f, 0.15958638f, 0.18992971f, 0.10072077f, -0.05503640f, -0.00486311f, 
    0.05863283f, 0.14065711f, -0.11768494f, -0.01129249f, 0.02741929f, -0.15432425f, 0.03205204f, -0.14134344f, 
    -0.00917552f, -0.04147049f, -0.02339890f, -0.06777404f, 0.06568176f, 0.08432879f, 0.02351911f, -0.19586401f, 
    0.14279152f, -0.00503165f, -0.13553073f, -0.14413112f, 0.14534613f, 0.04237780f, 0.10566831f, -0.11546223f, 
    -0.01567402f, -0.00031751f, -0.31577727f, -0.06101234f, -0.04462830f, -0.03042534f, 0.22486529f, -0.04424177f, 
    0.04033878f, -0.03154346f, -0.08141184f, 0.05754770f, -0.10160645f, 0.08472151f, 0.05174824f, 0.07988901f, 
    0.04774331f, 0.00701921f, -0.08809552f, -0.10679474f, 0.32593936f, -0.08725453f, 0.13980107f, -0.14105466f, 
    -0.05802073f, 0.16721649f, -0.05350925f, -0.04408177f, 0.04400231f, 0.20564702f, 0.03861064f, -0.10316864f, 
    0.04812155f, 0.32907668f, -0.32113066f, -0.20137742f, 0.12852825f, -0.01188568f, -0.17912315f, -0.09025898f, 
    -0.03720747f, -0.00165245f, 0.06668726f, 0.07329148f, 0.10205132f, 0.00406920f, -0.04482643f, 0.10151928f, 
    -0.06279931f, -0.04146745f, 0.13742137f, 0.06597503f, -0.07085603f, 0.07116069f, -0.17493732f, -0.01275657f, 
    0.09184168f, -0.04954622f, 0.23750076f, -0.03375974f, -0.02733308f, 0.16627781f, 0.06501589f, -0.08672626f, 
    0.06361424f, 0.07111692f, -0.10592556f, 0.13005289f, 0.11787985f, -0.11707347f, -0.05249586f, 0.32812399f, 
    0.05961096f, 0.10306469f, 0.07843453f, 0.01126423f, 0.01144662f, 0.04120707f, 0.06271178f, 0.02380235f, 
    0.06198341f, 0.01834866f, -0.09250769f, 0.03903320f, -0.01355886f, 0.04007328f, 0.02039073f, -0.03875802f, 
    -0.00353341f, 0.11672314f, -0.01116839f, -0.00404205f, 0.01615626f, -0.19558287f, 0.27867591f, -0.06335654f, 
    0.00016847f, -0.06604794f, 0.07233063f, -0.01475795f, -0.15589756f, -0.14823180f, -0.06727397f, -0.18346031f, 
    0.26152891f, 0.11853987f, 0.14835759f, -0.08748758f, 0.07174419f, -0.00100171f, 0.10876604f, -0.05290481f, 
    -0.10617560f, -0.17185459f, 0.08024959f, -0.15302381f, -0.01626295f, -0.02404647f, 0.00508112f, 0.06185369f, 
    -0.02508798f, 0.19185811f, 0.12311866f, 0.02998711f, 0.05604862f, 0.17171080f, 0.09412817f, 0.07527154f, 
    -0.02588657f, -0.00489332f, -0.13773218f, -0.10471297f, -0.08911467f, 0.08014086f, 0.06000545f, 0.01162963f, 
    0.08531258f, 0.09072336f, 0.07678155f, 0.18281160f, -0.15190442f, -0.08044228f, -0.35475978f, -0.01193360f, 
    0.02424476f, -0.13798644f, -0.00204062f, -0.05774733f, -0.14425036f, 0.00794365f, -0.04858870f, 0.10700101f, 
    0.15512362f, 0.21575424f, 0.04357310f, -0.13187990f, 0.08635994f, -0.07494245f, -0.07188995f, 0.04246280f, 
    -0.01427125f, -0.09128810f, 0.02626604f, 0.03784622f, 0.07505522f, -0.27262974f, 0.01474089f, 0.26423916f, 
    -0.07346042f, -0.00009423f, 0.25437415f, 0.10331136f, -0.16582677f, 0.12227446f, -0.07759600f, 0.12412684f, 
    -0.04748894f, -0.07186108f, -0.04664733f, -0.06549780f, -0.01408041f, 0.05639046f, 0.03800369f, -0.06267042f, 
    -0.02594231f, -0.07622007f, -0.01159963f, 0.04301128f, 0.01488126f, 0.05281031f, -0.00648273f, -0.05786037f, 
    -0.00230074f, 0.00788944f, 0.04098750f, 0.02493699f, 0.04610586f, -0.01607250f, -0.00420256f, -0.06016531f, 
    0.06289862f, 0.04953166f, 0.02886198f, 0.05230649f, -0.03737373f, 0.05084611f, -0.07549666f, 0.03959658f, 
    -0.01377943f, -0.05506274f, -0.08424191f, 0.00219879f, -0.01565309f, 0.03016705f, 0.04830229f, -0.01673856f, 
    -0.00974082f, 0.04162424f, 0.03502847f, 0.02998424f, -0.00156978f, 0.02275982f, -0.02249581f, -0.01019307f, 
    -0.05699692f, 0.02210727f, -0.00479443f, 0.00487523f, 0.00569408f, -0.02986683f, -0.05440927f, 0.04714097f, 
    -0.02701601f, 0.00335737f, -0.02608475f, 0.03957010f, -0.02240071f, -0.02853292f, -0.00704238f, -0.06381391f, 
    -0.04907429f, -0.02133634f, -0.02032075f, -0.04047944f, -0.06540669f, 0.00287760f, -0.05166731f, -0.05094980f, 
    -0.05752097f, -0.03144867f, -0.06115967f, 0.05706383f, -0.02766202f, -0.04707419f, -0.03194683f, -0.04385154f, 
    0.06120863f, -0.02525513f, 0.02660145f, -0.05799272f, -0.02022302f, -0.04365300f, -0.07218451f, -0.05898993f, 
    0.00431382f, -0.02038632f, 0.01334232f, 0.04211475f, 0.05628927f, 0.00810061f, 0.00710265f, -0.07078408f, 
    -0.02840376f, -0.06405100f, -0.05921774f, -0.05409114f, 0.05428202f, -0.04705478f, -0.03493163f, 0.02712338f, 
    0.01950144f, 0.04656967f, -0.04439835f, -0.07171223f, 0.05439852f, -0.07120463f, -0.05963887f, 0.03868987f, 
    -0.06671765f, -0.03469343f, -0.00007481f, -0.01910974f, 0.00954925f, 0.05448154f, 0.05833318f, 0.00992951f, 
    -0.04730180f, -0.01173001f, 0.02584444f, 0.04503370f, -0.00880898f, 0.00512839f, -0.07437118f, -0.05592520f, 
    -0.06712187f, 0.04947141f, -0.03718935f, -0.05187615f, 0.00809957f, -0.01447319f, -0.01966540f, -0.02199458f, 
    0.03908373f, 0.02893560f, -0.06771521f, -0.03654354f, -0.02536151f, -0.07717993f, -0.00558519f, 0.02575644f, 
    0.03571039f, -0.00743170f, 0.00762074f, -0.02501178f, -0.05952629f, 0.01148680f, 0.02105608f, 0.01990069f, 
    -0.07379845f, 0.03003580f, 0.00693727f, -0.04940327f, -0.02855215f, -0.00731641f, -0.03210248f, -0.02421311f, 
    0.03503414f, 0.01813633f, -0.04427311f, 0.00507393f, -0.05686260f, -0.04835429f, 0.05197215f, 0.05554932f, 
    0.06198601f, -0.00677997f, 0.03400053f, -0.07166695f, 0.05455545f, -0.00938962f, -0.02499205f, -0.06947914f, 
    -0.00879226f, -0.03712353f, -0.05147851f, 0.04127440f, 0.00568500f, 0.06367896f, -0.02267413f, -0.03900202f, 
    -0.02477247f, 0.01395528f, 0.05096428f, 0.01341520f, -0.06958064f, 0.00634274f, -0.07363375f, -0.02191297f, 
    -0.19008042f, -0.22601195f, 0.17486855f, 0.21908140f, -0.14161710f, 0.04025263f, 0.09463020f, -0.01046380f, 
    -0.00264615f, 0.00024471f, 0.03257755f, 0.06660344f, 0.21582137f, -0.05954760f, 0.12939818f, 0.18607573f, 
    -0.06653163f, 0.04396629f, -0.07525452f, -0.08017913f, -0.03037515f, -0.02177403f, 0.01378855f, 0.05810529f, 
    0.05848674f, 0.24561296f, 0.09574143f, -0.09420957f, 0.08367345f, 0.09673166f, 0.05769865f, -0.07716520f, 
    0.10285023f, -0.03296227f, -0.06421465f, -0.00039583f, -0.51270622f, -0.06870521f, 0.09544928f, 0.12695409f, 
    0.06478656f, 0.03723109f, 0.06439978f, 0.02107930f, 0.02317015f, 0.13374726f, 0.04264893f, -0.04794920f, 
    -0.03929126f, -0.08848050f, 0.22277088f, -0.11601796f, -0.12718356f, 0.09263099f, 0.12909080f, 0.03203649f, 
    0.05493646f, -0.08256175f, -0.02277214f, 0.14914404f, -0.03551681f, 0.04550911f, 0.00495520f, 0.09493335f, 
    0.13918938f, 0.12977682f, 0.06722082f, -0.05285344f, -0.04132633f, -0.08982757f, -0.02969663f, -0.05198089f, 
    -0.44841519f, -0.13429606f, 0.05620140f, 0.05885085f, -0.03184273f, -0.04270667f, 0.00972764f, 0.00524028f, 
    0.06152723f, 0.01761133f, -0.13649446f, 0.01528644f, 0.69380051f, -0.12810506f, 0.02112004f, 0.04487476f, 
    -0.07656420f, 0.01577701f, -0.08384596f, 0.03400988f, 0.00713294f, 0.06518351f, 0.06079978f, 0.04849893f, 
    -0.03107142f, -0.21451728f, 0.05251659f, 0.09114462f, 0.09954997f, 0.07240573f, 0.04670480f, 0.13322337f, 
    -0.00057947f, -0.01311946f, -0.09019852f, 0.04963783f, 0.10189311f, 0.02295833f, -0.08143838f, -0.07835413f, 
    -0.00873976f, 0.14321268f, 0.07986654f, 0.07489302f, 0.01317687f, 0.10411763f, 0.10133148f, -0.01579761f, 
    0.00512406f, -0.04325989f, -0.10764693f, -0.06814466f, 0.14642996f, 0.05138806f, -0.09775379f, 0.05106412f, 
    -0.00950761f, 0.13851358f, 0.10453702f, -0.09310713f, -0.11451241f, -0.05390731f, 0.14231402f, -0.10417066f, 
    0.12964435f, 0.00158628f, 0.05601990f, -0.03686399f, -0.14842632f, -0.01425783f, 0.19628693f, 0.13073124f, 
    -0.02266350f, 0.05366298f, 0.01295624f, 0.19731762f, -0.02686282f, -0.01642916f, 0.14464712f, 0.10407482f, 
    0.09042284f, 0.02099412f, 0.03454117f, -0.05814584f, 0.17330433f, 0.11599952f, 0.10481545f, -0.16381903f, 
    -0.12398136f, 0.09190324f, -0.03365510f, 0.18358749f, 0.09560888f, 0.05058923f, -0.09078835f, -0.22434692f, 
    -0.04881208f, -0.05895502f, -0.22457170f, -0.12881842f, -0.08791586f, -0.09220625f, 0.13307714f, -0.05529604f, 
    -0.10810757f, 0.22835582f, -0.04394723f, -0.04448537f, 0.13060978f, 0.06741608f, 0.08624636f, -0.03371773f, 
    0.07002501f, -0.15018377f, 0.03619704f, 0.08505960f, -0.02329880f, 0.03316409f, 0.06059883f, 0.16552736f, 
    0.34298190f, -0.01651494f, 0.16542311f, -0.19310977f, -0.03037958f, -0.15893115f, -0.01623451f, -0.07404491f, 
    -0.03536591f, -0.10156980f, -0.04770743f, 0.11029077f, 0.03904152f, 0.09754645f, -0.07252979f, 0.14915575f, 
    -0.03375323f, -0.08196266f, -0.13284460f, 0.02881723f, 0.06845099f, 0.08024393f, 0.13639688f, -0.00351735f, 
    -0.22633766f, 0.22471818f, -0.03023996f, 0.01331453f, 0.05118458f, -0.02270482f, 0.00689746f, 0.03202604f, 
    -0.03406431f, 0.05887173f, -0.00600287f, 0.08281337f, -0.02770743f, -0.04391311f, -0.11943854f, -0.03591837f, 
    -0.10949972f, -0.06113638f, 0.07544338f, -0.07144695f, -0.15080826f, 0.01093831f, 0.17025030f, -0.02979111f, 
    0.20508006f, -0.11197949f, 0.13514361f, 0.08445497f, -0.15539581f, -0.05500509f, -0.09917669f, 0.00958589f, 
    -0.17273185f, 0.07400949f, 0.00560145f, -0.05053837f, 0.04358955f, -0.05579158f, 0.28690132f, -0.05422496f, 
    0.05179910f, 0.09323166f, 0.11364166f, 0.02833719f, -0.02302953f, 0.02176944f, -0.11246049f, 0.00995046f, 
    -0.13690546f, 0.22347784f, -0.00013020f, -0.22349046f, -0.03509182f, -0.03080748f, -0.04618631f, -0.08355893f, 
    -0.01883439f, 0.09580426f, -0.04628403f, 0.09477629f, 0.35169572f, 0.29455414f, -0.02571638f, 0.22685391f, 
    -0.02739266f, -0.00270869f, 0.10475279f, 0.06256338f, 0.09486496f, 0.09729321f, -0.03122680f, -0.02078494f, 
    -0.03282831f, 0.04204663f, -0.08388206f, -0.03140874f, 0.03488570f, 0.01575296f, 0.00149448f, -0.02648184f, 
    -0.14536592f, -0.02583373f, 0.10947985f, 0.22415334f, 0.24746121f, -0.18385966f, -0.03428532f, -0.33002096f, 
    -0.08116475f, 0.01928505f, 0.19991726f, -0.01670257f, 0.07589830f, 0.05572054f, -0.06638455f, 0.00211391f, 
    0.27326888f, 0.18213557f, -0.08112795f, -0.18311663f, 0.02869150f, -0.10586476f, 0.00866886f, -0.01875017f, 
    0.00528555f, -0.03427062f, 0.01678536f, -0.07162964f, 0.00842507f, 0.02033209f, -0.28318807f, 0.09653261f, 
    0.01863824f, 0.07137293f, 0.07225724f, -0.02349492f, 0.12633935f, -0.06413416f, 0.03452661f, -0.01598268f, 
    0.06359909f, 0.06008344f, 0.01281228f, -0.23012969f, -0.02165291f, -0.05478917f, 0.05237870f, -0.02939971f, 
    0.05303036f, -0.02247840f, 0.03476487f, 0.04443099f, -0.00224830f, -0.14379664f, -0.34053344f, 0.37207896f, 
    -0.26623070f, -0.13283442f, -0.17904179f, -0.08118439f, 0.06558560f, -0.04766783f, 0.02715744f, -0.01701864f, 
    0.07852180f, -0.07001011f, 0.21267803f, -0.36099848f, 0.04072857f, -0.17070965f, 0.06600108f, -0.00656352f, 
    0.08063925f, 0.09136711f, -0.00739559f, 0.08020966f, 0.31506172f, 0.11621892f, 0.12254045f, 0.00190252f, 
    0.06261525f, -0.08257012f, 0.04643157f, 0.16032434f, 0.15373461f, 0.00882406f, -0.11457236f, 0.10440873f, 
    0.11983043f, -0.46896216f, -0.08981358f, 0.14941563f, -0.04594171f, 0.06190822f, 0.06330090f, -0.10206269f, 
    0.13983661f, 0.08835545f, -0.07898518f, -0.08166295f, 0.01980311f, -0.16836746f, 0.13377438f, -0.02536745f, 
    0.04922430f, -0.08182235f, 0.00110470f, 0.04948229f, 0.08025122f, -0.05830028f, -0.08283393f, 0.08820914f, 
    -0.34493110f, 0.27297878f, 0.20379877f, 0.07617813f, 0.03979100f, 0.11636072f, 0.06501471f, -0.06071777f, 
    0.05674969f, -0.06703077f, -0.11741050f, -0.08541422f, 0.20598099f, -0.28676534f, -0.02256511f, -0.13381723f, 
    -0.00535528f, 0.11802961f, -0.11422457f, -0.10810950f, 0.13145457f, -0.02411384f, -0.04684310f, 0.09804928f, 
    0.09308174f, -0.08769111f, -0.05317025f, 0.14978610f, 0.05609833f, 0.11969027f, -0.09906995f, 0.00731116f, 
    0.11130577f, -0.02247111f, 0.08866411f, 0.04855571f, -0.03589267f, 0.00300132f, 0.13779719f, 0.00229770f, 
    -0.21245885f, 0.09888586f, -0.04217822f, 0.10603856f, 0.12510169f, -0.00081256f, 0.13354005f, -0.00790325f, 
    -0.01965294f, -0.25116834f, 0.04173670f, -0.07677444f, -0.04127723f, 0.00305703f, -0.05176564f, -0.03458023f, 
    0.18303683f, -0.16402882f, 0.02193017f, 0.01189161f, -0.04424200f, 0.05835510f, -0.05669215f, 0.28379050f, 
    -0.06024554f, 0.05941115f, 0.09326217f, -0.00973427f, -0.07518245f, -0.01385092f, -0.02153092f, 0.04484172f, 
    0.04512756f, -0.37127355f, -0.21352021f, -0.19463901f, -0.09716862f, 0.09849185f, 0.11131890f, 0.12508091f, 
    0.11157498f, -0.01599168f, -0.06403415f, -0.00348344f, 0.29696795f, -0.18239571f, 0.16458401f, 0.01809930f, 
    -0.04368591f, -0.02802047f, 0.14863133f, 0.15532498f, -0.06910513f, 0.02216993f, 0.05253718f, -0.07675572f, 
    0.23768449f, 0.15470123f, 0.00636422f, 0.09646820f, 0.19467522f, -0.02809228f, -0.12903638f, 0.14528273f, 
    -0.07376868f, -0.17108360f, -0.02020948f, 0.02284950f, -0.26507530f, -0.11677822f, 0.17133221f, 0.03771302f, 
    -0.01914596f, 0.02121953f, 0.17750897f, 0.13190313f, -0.05422090f, 0.16680427f, -0.04652302f, 0.03980888f, 
    0.10985965f, -0.09113418f, -0.02373160f, 0.09036005f, 0.03955278f, 0.02003543f, 0.21157059f, 0.02057085f, 
    0.04974512f, 0.13810241f, 0.04304247f, 0.08731861f, 0.38609514f, -0.11584746f, -0.06995811f, 0.40384007f, 
    -0.06689212f, -0.03110057f, 0.03131660f, 0.05968763f, -0.02784464f, -0.05925188f, 0.00852887f, -0.13849607f, 
    0.40622666f, 0.11582073f, -0.29376480f, -0.28320986f, -0.05445481f, -0.09078562f, -0.09741397f, 0.11479034f, 
    0.02051440f, -0.00640398f, -0.04906983f, -0.00749118f, -0.09741253f, 0.06471342f, 0.19092777f, 0.22259133f, 
    -0.13072790f, -0.11520014f, -0.05609287f, 0.08723208f, 0.07966585f, 0.11848229f, 0.10611667f, -0.05395290f, 
    0.03789877f, 0.24133882f, -0.10488628f, -0.06642224f, 0.12817879f, -0.07442740f, -0.04509519f, 0.09695665f, 
    0.04199809f, -0.05070382f, 0.05104908f, 0.00166748f, -0.19083793f, 0.06144728f, 0.22671822f, 0.06679545f, 
    -0.02984444f, -0.04407813f, -0.01401768f, 0.12062281f, 0.14902784f, -0.04876128f, 0.01486176f, -0.23324093f, 
    -0.09617436f, -0.05218339f, 0.02085190f, 0.25867087f, -0.04608309f, -0.13731602f, 0.08529456f, 0.05823487f, 
    -0.01542636f, -0.06341894f, 0.04066700f, 0.05236154f, 0.04515405f, -0.02645748f, -0.12322509f, -0.21814397f, 
    0.07774835f, 0.00296460f, -0.08126244f, 0.03003719f, -0.00344444f, -0.07574590f, 0.01034609f, -0.00149742f, 
    0.10898139f, -0.19297706f, -0.06578795f, -0.05982590f, 0.07919711f, 0.03040591f, 0.05745005f, 0.04447751f, 
    0.03125649f, -0.04072141f, 0.01437211f, -0.03250679f, 0.23308198f, 0.03004147f, -0.23586132f, 0.07006330f, 
    0.18552303f, -0.03872624f, -0.06716081f, -0.06701963f, 0.00443225f, 0.04390452f, -0.04042432f, -0.08537606f, 
    0.13281512f, -0.01036681f, -0.25894630f, -0.08633705f, 0.04206847f, -0.00412218f, 0.08304515f, -0.07930008f, 
    -0.01645863f, 0.02710800f, -0.01292705f, 0.03534904f, 0.15265535f, 0.08110116f, 0.22297925f, -0.10175900f, 
    0.13265671f, -0.05482877f, 0.09078322f, -0.05821816f, -0.02389647f, -0.00301478f, -0.13624573f, -0.08211260f, 
    0.13130768f, 0.36871916f, -0.23683785f, -0.14099905f, -0.01173225f, 0.15284343f, -0.07574109f, -0.09289404f, 
    -0.04711731f, 0.02704188f, 0.03418152f, 0.01912039f, 0.09497066f, 0.10846327f, 0.16176623f, 0.09678035f, 
    -0.02849615f, -0.09715286f, 0.11935003f, -0.03107370f, 0.02261616f, -0.07851347f, -0.08758372f, -0.09973910f, 
    0.23611845f, 0.28552985f, 0.06210596f, 0.09378090f, -0.11224806f, 0.07497239f, 0.08741082f, 0.08129081f, 
    0.07664846f, 0.12827274f, -0.16437927f, -0.06641465f, -0.07274952f, 0.10491392f, -0.11653914f, -0.06990534f, 
    -0.12236286f, -0.01226984f, -0.01016545f, 0.14339283f, 0.04733710f, -0.01513075f, -0.08439820f, -0.10424903f, 
    -0.03022113f, 0.06551023f, -0.11500215f, 0.07788774f, 0.05575560f, 0.10745825f, 0.07224170f, -0.09819837f, 
    0.05986654f, -0.15524243f, -0.09809740f, -0.05116231f, -0.11815266f, -0.17230496f, -0.06825556f, -0.11263795f, 
    0.14359404f, 0.08698080f, -0.02863861f, 0.09846178f, -0.01299667f, 0.02656563f, 0.02765368f, 0.10157715f, 
    0.19391942f, -0.03379184f, -0.11907195f, 0.34931397f, 0.24995655f, -0.09967045f, 0.04024834f, -0.00962827f, 
    0.00000350f, 0.04727221f, 0.11628158f, -0.06346229f, 0.20838240f, 0.26012316f, 0.18669467f, 0.15346387f, 
    -0.13264357f, 0.15675515f, 0.04882419f, -0.06001364f, 0.06189113f, -0.04791284f, -0.02489996f, -0.27969396f, 
    -0.09348670f, 0.13352831f, 0.12563442f, -0.05221056f, 0.06523859f, 0.11571690f, -0.04083114f, -0.01744511f, 
    0.08240172f, 0.19572873f, 0.09284978f, 0.14082207f, -0.10604630f, 0.05339670f, -0.19480646f, 0.02072262f, 
    -0.02122236f, -0.08204991f, 0.12295363f, -0.10810202f, 0.07944866f, -0.05636393f, -0.08352774f, 0.06836480f, 
    0.09802371f, 0.06005729f, -0.19653772f, -0.16489042f, -0.04494107f, -0.03733900f, -0.17088673f, 0.04232732f, 
    -0.02869471f, 0.03837966f, 0.12045586f, 0.09808665f, -0.16816606f, 0.03225278f, 0.09266878f, 0.05580429f, 
    0.14136006f, 0.01364097f, 0.12041485f, 0.03177599f, 0.02393682f, 0.01238833f, 0.08854806f, 0.07488788f, 
    -0.01800800f, -0.21260566f, 0.09847017f, 0.04395692f, -0.02715237f, 0.06631609f, 0.05012535f, -0.05177100f, 
    0.03270368f, 0.10373034f, 0.03431593f, 0.00763953f, -0.20946278f, 0.08619767f, 0.19567998f, -0.09052901f, 
    0.00411398f, 0.02597709f, 0.11410047f, 0.02728152f, -0.02085479f, -0.02418013f, 0.06447980f, -0.05793124f, 
    0.01680537f, 0.11739375f, -0.15147592f, 0.05761089f, 0.04262677f, 0.12365872f, -0.01932538f, 0.03003943f, 
    0.05090639f, 0.09322792f, 0.03540124f, 0.06343909f, 0.27698675f, 0.03255574f, 0.01766475f, 0.02513944f, 
    -0.04205513f, -0.07042008f, -0.01991086f, 0.01375578f, -0.01959937f, -0.09974120f, -0.01277121f, -0.04679296f, 
    -0.26224267f, -0.19539508f, -0.00075990f, -0.03604655f, 0.11274149f, -0.03592740f, -0.03853493f, 0.04027392f, 
    0.09356107f, 0.04293009f, 0.15846115f, 0.06951262f, 0.14772309f, 0.04604081f, -0.07306685f, -0.25460204f, 
    0.07149812f, -0.07987507f, 0.07483115f, -0.03848600f, 0.05415780f, -0.09966905f, 0.11639948f, 0.15036209f, 
    -0.07118442f, -0.06773070f, 0.07502333f, 0.00276653f, 0.01909911f, 0.05787468f, -0.01934402f, 0.08860151f, 
    0.14787520f, 0.19572932f, 0.00571721f, 0.25911859f, 0.05716376f, 0.03429758f, -0.23200947f, 0.06729797f, 
    0.15557349f, -0.00558645f, -0.08604550f, -0.05053526f, 0.03876995f, -0.11185529f, -0.00609972f, -0.00301269f, 
    0.14914241f, 0.07740766f, -0.03968168f, 0.07058549f, -0.00531240f, 0.05460203f, 0.02506044f, 0.15255086f, 
    -0.01095263f, 0.01761883f, 0.02090980f, -0.10390142f, -0.09952124f, -0.23412895f, -0.20664826f, 0.16894369f, 
    0.11120050f, 0.00769563f, -0.06718177f, 0.02780278f, 0.08501898f, 0.04007459f, 0.05683628f, 0.15511590f, 
    -0.30949000f, 0.00822180f, -0.04337041f, -0.03905590f, 0.07781658f, 0.03846363f, 0.09704488f, -0.04277460f, 
    0.08841770f, 0.11282859f, -0.00611890f, 0.08491556f, 0.11325097f, 0.11273447f, -0.10714900f, -0.21155472f, 
    0.04720465f, 0.00435842f, -0.08705232f, 0.02914914f, 0.13241524f, -0.12904145f, -0.10729895f, 0.03604257f, 
    0.36057836f, 0.18392792f, 0.18010621f, -0.02631511f, 0.02427603f, -0.13022462f, 0.04340854f, 0.06623437f, 
    0.06358338f, -0.00028068f, 0.00594153f, -0.04088683f, -0.11221113f, -0.10352357f, -0.24011487f, -0.03124824f, 
    -0.02568647f, 0.07135944f, -0.05288251f, -0.07103254f, 0.09504885f, 0.08139992f, 0.08821942f, -0.07191063f, 
    0.17626768f, 0.09711639f, -0.09440892f, 0.01169384f, -0.00075027f, 0.01128001f, 0.05890127f, -0.00901034f, 
    -0.08260811f, -0.00900194f, -0.02437483f, -0.06808919f, 0.06884051f, 0.15196873f, 0.24427344f, 0.09314783f, 
    -0.06971536f, -0.08440109f, 0.06392366f, 0.05146900f, -0.04554669f, 0.02638052f, 0.04433033f, -0.01197108f, 
    0.22152418f, 0.01045339f, 0.15090571f, 0.11677142f, 0.01407172f, -0.02683059f, 0.04638294f, 0.18103470f, 
    -0.00496394f, 0.02760467f, 0.07303109f, 0.17692150f, -0.22287066f, -0.14372981f, 0.13796686f, 0.10249114f, 
    0.12464552f, 0.02957635f, 0.03431466f, -0.02351034f, -0.04840335f, -0.03231114f, -0.00827717f, 0.09690338f, 
    0.11846709f, 0.31973448f, 0.14645097f, -0.14408076f, -0.08640449f, -0.01441164f, 0.04343661f, -0.02349091f, 
    0.02208946f, 0.08205838f, -0.16079539f, 0.10081360f, 0.00773687f, 0.09408344f, -0.06152227f, 0.02875419f, 
    -0.02119883f, 0.19570652f, 0.05616496f, -0.06573179f, 0.15191589f, 0.01654907f, 0.12257580f, -0.03515073f, 
    -0.18442816f, -0.05918069f, 0.06809387f, 0.14044689f, 0.04076818f, 0.05433358f, 0.05659514f, 0.12579519f, 
    0.10642730f, 0.02986642f, -0.08454987f, 0.12759675f, -0.07372336f, -0.16221549f, -0.11067016f, -0.07046870f, 
    0.07426998f, -0.05012929f, 0.14996575f, 0.02351260f, -0.07304295f, 0.00813062f, -0.03199841f, -0.03617059f, 
    0.03268833f, -0.10521452f, -0.10544482f, -0.07114074f, 0.10240413f, -0.00275486f, -0.09827711f, 0.02301947f, 
    -0.13220941f, 0.04359053f, 0.00987935f, -0.07147834f, 0.00212086f, -0.00593075f, -0.05420836f, 0.15237908f, 
    0.09941035f, -0.03331490f, 0.18432929f, 0.05650692f, 0.05680238f, -0.08364257f, -0.01581204f, -0.14158246f, 
    -0.09526573f, 0.08411047f, 0.07032175f, -0.14191382f, 0.13031128f, 0.01072216f, 0.10008904f, 0.12688762f, 
    0.02872824f, -0.01944492f, 0.13898934f, 0.10562753f, 0.19072649f, 0.09347010f, -0.12084978f, 0.05444214f, 
    -0.09046004f, 0.12530047f, -0.08424679f, 0.04503885f, 0.04516944f, 0.01063428f, 0.01618151f, -0.01368760f, 
    -0.03084978f, -0.17490001f, 0.25900754f, -0.08942641f, -0.07782441f, -0.03375568f, 0.23296529f, -0.04395450f, 
    -0.08792604f, 0.04262710f, -0.07502731f, 0.14706947f, -0.03928533f, -0.11377581f, -0.08347882f, -0.06810830f, 
    0.13800380f, -0.03117655f, 0.09331450f, 0.02155127f, 0.00641467f, -0.02265773f, -0.08496968f, 0.13634071f, 
    0.26900801f, 0.02015099f, 0.21795247f, -0.06208989f, -0.18426338f, -0.05541576f, 0.07375727f, 0.13036910f, 
    0.01328780f, -0.03689137f, -0.01525742f, 0.00276329f, 0.06920528f, 0.01443384f, -0.15548781f, 0.22555110f, 
    -0.01753444f, 0.01853637f, -0.03769222f, 0.13097550f, -0.08435283f, 0.17764926f, 0.13859023f, 0.07992181f, 
    -0.08775698f, 0.31293187f, 0.08445365f, 0.15700491f, 0.07604604f, 0.06404207f, 0.11033747f, 0.08506313f, 
    0.02201123f, -0.00531820f, -0.02296401f, 0.06851430f, -0.22292674f, -0.02938297f, -0.08459049f, 0.29473838f, 
    -0.03354520f, -0.03195228f, 0.08286500f, 0.03174841f, -0.08295799f, 0.10679059f, -0.06864317f, -0.14150353f, 
    0.11145769f, -0.22912422f, 0.07697544f, 0.05573368f, -0.07845798f, -0.01209200f, 0.08131786f, 0.17948544f, 
    -0.03641885f, -0.03731826f, -0.00105509f, 0.07840068f, 0.12145087f, 0.01097172f, 0.07294497f, 0.07118674f, 
    0.15393464f, 0.00710976f, 0.00549287f, -0.00024249f, 0.07866367f, 0.01108723f, 0.02558339f, 0.06891090f, 
    -0.33702710f, 0.17418712f, 0.21871242f, 0.04976035f, -0.06748366f, -0.16851325f, 0.05167112f, 0.13430460f, 
    -0.01320503f, -0.07543941f, -0.07951479f, 0.02002321f, -0.04697471f, 0.15919483f, -0.13065831f, -0.07100599f, 
    0.16873246f, -0.02660384f, -0.06929912f, 0.03213967f, 0.07515517f, 0.02485585f, -0.02201696f, -0.00406396f, 
    0.21453436f, 0.08749016f, 0.14158554f, 0.15040861f, 0.06450451f, 0.11041979f, 0.09349572f, 0.02679714f, 
    -0.06829859f, 0.03249756f, -0.04761214f, 0.13796431f, 0.06696089f, -0.20986910f, -0.17814878f, -0.04365994f, 
    0.04668595f, 0.08418714f, 0.04647177f, -0.03226285f, 0.03377290f, 0.17987233f, 0.01310742f, -0.01353788f, 
    0.12325761f, 0.03503337f, -0.15113658f, -0.19402763f, -0.01714685f, -0.14399928f, -0.03831977f, -0.13389590f, 
    0.05268010f, -0.01258138f, 0.06265031f, -0.01082185f, 0.09092592f, 0.03848863f, 0.07763436f, -0.02513261f, 
    0.00850270f, -0.12979224f, -0.05447437f, 0.00796988f, 0.01041725f, -0.07862652f, 0.00912167f, -0.03806204f, 
    -0.04332748f, -0.00004645f, 0.15570375f, -0.23604406f, 0.04563555f, -0.01859662f, 0.03319519f, 0.01931226f, 
    0.10789432f, -0.18602575f, -0.02016551f, 0.06154737f, 0.02572462f, 0.22630732f, 0.08282892f, -0.08825599f, 
    -0.11694188f, 0.03796767f, -0.05282936f, 0.05533940f, 0.21980236f, -0.02641740f, 0.00759351f, 0.04986518f, 
    0.16221064f, -0.11133423f, 0.35562903f, -0.13337807f, -0.05227171f, -0.08455824f, 0.22702245f, -0.02323682f, 
    -0.12954974f, 0.07608011f, 0.02881589f, 0.02716007f, 0.11599013f, 0.00700572f, -0.18765257f, -0.15787871f, 
    0.08362069f, -0.02201623f, -0.00662496f, 0.15592009f, 0.05733932f, -0.03229827f, 0.07071618f, 0.17962196f, 
    0.00183335f, -0.05200794f, 0.02335396f, -0.02340567f, -0.02274296f, -0.07862341f, -0.04160833f, -0.08665591f, 
    0.04675501f, -0.00465955f, -0.00602596f, -0.03341555f, -0.05400319f, -0.07002284f, -0.05635064f, 0.04990390f, 
    0.03650683f, -0.03832722f, -0.01429887f, -0.01835999f, 0.05412184f, -0.02616963f, 0.00176737f, -0.02979491f, 
    -0.03046723f, -0.01217871f, -0.05319922f, -0.03642299f, 0.02841327f, -0.08456798f, 0.01969864f, -0.01527895f, 
    -0.02892398f, -0.05231546f, -0.01613676f, -0.08269066f, -0.08988106f, -0.02851431f, -0.04066412f, -0.08690707f, 
    -0.04965144f, -0.03364856f, -0.05285903f, 0.05084097f, 0.00810144f, -0.06149422f, -0.05902601f, 0.03556863f, 
    -0.06108759f, 0.01677648f, -0.00689022f, -0.00243109f, 0.05055846f, -0.04195930f, 0.02610940f, -0.00138779f, 
    -0.03507107f, -0.07509596f, 0.01922138f, -0.03060930f, -0.08387448f, -0.03799115f, -0.07835977f, -0.05760580f, 
    -0.04376033f, -0.04823983f, -0.06211499f, 0.03430581f, -0.01941246f, -0.05731664f, -0.07361982f, 0.07760049f, 
    0.03151515f, -0.07361653f, 0.00245716f, -0.06097474f, 0.02391883f, 0.01754606f, -0.03858642f, -0.06016294f, 
    -0.08183079f, -0.05202967f, 0.04090196f, -0.05023015f, -0.02025797f, -0.08075926f, -0.01917363f, -0.04887362f, 
    0.03690459f, -0.04869139f, 0.03122994f, -0.05897260f, -0.03589927f, -0.00719392f, 0.04223470f, -0.03974395f, 
    -0.01732061f, 0.01013634f, 0.01451174f, -0.04004914f, 0.00179508f, -0.00822476f, 0.00833912f, 0.00250066f, 
    -0.05247159f, 0.05283758f, 0.03864648f, 0.04050433f, -0.01591208f, -0.03332596f, -0.01313518f, 0.02895553f, 
    -0.05641629f, -0.06991596f, -0.05242369f, 0.03816517f, -0.06414893f, 0.03188308f, -0.03875719f, -0.05582579f, 
    -0.05570310f, -0.03666585f, 0.02644353f, -0.05618713f, 0.00659191f, -0.02260721f, -0.05742928f, -0.07352076f, 
    -0.04871977f, -0.02472511f, -0.03262421f, -0.02796758f, -0.01024698f, -0.07476935f, -0.01779799f, 0.02001386f, 
    0.00350892f, -0.07792015f, -0.07496472f, 0.02542105f, 0.03512546f, -0.03523272f, 0.03152690f, -0.04434841f, 
    0.04306934f, -0.00567632f, 0.00224771f, -0.07447937f, -0.00244375f, -0.04866819f, -0.01108574f, -0.06746268f, 
    0.00688166f, -0.04275429f, -0.08416107f, -0.04438606f, -0.06458364f, -0.05575286f, 0.02949787f, 0.03468701f, 
    0.00738218f, -0.04926831f, 0.07141046f, 0.05204744f, -0.05125532f, 0.00274992f, 0.02332628f, 0.04318263f, 
    0.01954681f, -0.03384954f, -0.08046817f, 0.02302180f, -0.09337838f, -0.03328183f, 0.00546686f, 0.02945431f, 
    -0.04992938f, 0.00146326f, 0.03715273f, -0.08226547f, 0.02699789f, -0.08626431f, -0.01770241f, -0.02341501f, 
    -0.08377018f, 0.05134667f, -0.02228997f, -0.04579235f, -0.05377975f, -0.08006501f, 0.01558950f, 0.01514589f, 
    0.01931731f, -0.02150111f, -0.03228428f, 0.00451960f, 0.04188174f, -0.06572656f, 0.03447337f, -0.03654115f, 
    0.01181852f, -0.04134079f, -0.06121771f, -0.02806501f, -0.04545505f, -0.05199000f, 0.02673806f, 0.01917268f, 
    -0.00688544f, 0.02587719f, -0.04481256f, 0.05533607f, 0.05749159f, -0.03390668f, -0.05371674f, -0.04464541f, 
    -0.00102112f, 0.06026347f, -0.01960286f, -0.02669328f, 0.05782757f, -0.01226488f, -0.03535325f, 0.06291194f, 
    0.04759505f, 0.05446542f, -0.02647591f, 0.06255305f, 0.05611454f, 0.03754317f, 0.00921366f, 0.03262648f, 
    -0.00707937f, -0.03699877f, -0.00852339f, -0.04749121f, -0.03843386f, -0.06407764f, 0.05979018f, -0.03336897f, 
    0.00855196f, 0.01278497f, -0.06177923f, 0.01840712f, 0.03447807f, -0.07415287f, -0.05723976f, -0.01899037f, 
    0.04504201f, 0.00620387f, -0.06813738f, 0.05142614f, -0.06580118f, -0.05508009f, -0.06598338f, 0.01460923f, 
    -0.06265454f, -0.04787519f, 0.02679375f, -0.05505852f, 0.02537914f, -0.05336671f, -0.06830144f, 0.01982357f, 
    -0.00284392f, 0.03070825f, 0.04111694f, 0.05276290f, -0.05288613f, 0.02787919f, 0.06029686f, 0.00492330f, 
    -0.03922394f, -0.01089224f, -0.01531124f, 0.01018285f, 0.00259526f, 0.05281947f, -0.02089829f, 0.03345926f, 
    -0.04759231f, -0.01377457f, -0.02987083f, -0.01870817f, -0.07525533f, -0.01866826f, -0.03314041f, 0.04860923f, 
    0.03504749f, -0.00586788f, -0.06786751f, -0.00701424f, 0.02688422f, -0.00963131f, -0.06433935f, -0.01256075f, 
    -0.01103401f, 0.01316260f, -0.02213114f, -0.00416686f, 0.06345550f, -0.06279147f, 0.05763118f, 0.01866684f, 
    0.04158628f, -0.03216893f, -0.05390093f, 0.01524333f, 0.06348918f, -0.05683467f, 0.02178466f, -0.02047092f, 
    -0.06024940f, -0.07215478f, -0.04597722f, -0.03943662f, -0.05416342f, 0.00307068f, -0.07788686f, 0.03729194f, 
    0.02849321f, 0.06113130f, -0.06503028f, -0.01882675f, 0.04677705f, 0.00964346f, -0.00580794f, 0.05772919f, 
    -0.05400367f, -0.02529187f, -0.05794740f, -0.03314286f, 0.03161460f, -0.05884152f, 0.06321187f, -0.07654568f, 
    -0.00076541f, 0.00558872f, -0.04523006f, -0.02101027f, 0.01462100f, -0.05727133f, -0.01700214f, -0.01274370f, 
    0.06090894f, -0.04501702f, -0.00724394f, -0.07084257f, -0.06053161f, -0.06325940f, -0.02004597f, 0.07079865f, 
    -0.03863583f, 0.05488213f, -0.02641945f, -0.04978338f, -0.02251969f, 0.07150234f, -0.03270191f, -0.01490720f, 
    -0.07481389f, -0.04009851f, 0.04149958f, 0.03752832f, -0.04151268f, 0.04232839f, -0.04111523f, -0.00597301f, 
    -0.03736893f, 0.04119831f, -0.02165718f, 0.01482702f, 0.01223895f, -0.05935530f, 0.02419379f, -0.05315890f, 
    -0.04184663f, 0.05550632f, 0.05988120f, -0.05788018f, 0.03529519f, 0.02651397f, -0.00493027f, 0.05830658f, 
    -0.07737549f, 0.04671931f, 0.05094936f, 0.02401164f, -0.03473151f, 0.02651403f, -0.05720137f, 0.02629541f, 
    0.05422441f, -0.05303261f, -0.05625721f, 0.00105747f, -0.01692311f, -0.00775725f, -0.05082314f, -0.04171186f, 
    -0.01129484f, -0.05722804f, -0.00205062f, -0.06455947f, 0.02902368f, -0.00465951f, -0.00146381f, -0.07613902f, 
    -0.07880775f, -0.00966880f, 0.01030091f, -0.04191910f, 0.06097857f, -0.06930811f, -0.07081193f, -0.07676045f, 
    0.01701844f, 0.03483718f, 0.04612209f, -0.06091095f, 0.00177850f, 0.00228003f, -0.07536348f, -0.00477896f, 
    0.00752529f, 0.00515249f, 0.03302702f, -0.07318536f, 0.01109335f, 0.04898934f, -0.04804906f, -0.00539644f, 
    0.05454927f, 0.04660210f, -0.00587411f, -0.06088832f, 0.05417632f, 0.01658162f, -0.06031793f, -0.06681563f, 
    0.04798026f, 0.03891636f, 0.05491871f, -0.01872722f, -0.02252959f, -0.07664548f, -0.06768083f, -0.02983980f, 
    -0.02166796f, 0.04415845f, -0.06198856f, -0.00538805f, -0.02028020f, -0.00967180f, 0.00225233f, -0.05488777f, 
    -0.02095947f, -0.05074055f, 0.05021205f, 0.04131940f, -0.03085817f, 0.04694163f, -0.07947627f, -0.02355814f, 
    0.03274084f, 0.03229602f, -0.02748997f, -0.04545321f, -0.02286653f, -0.04504859f, 0.03146719f, -0.04089802f, 
    -0.00327500f, 0.01341955f, -0.04540422f, -0.02712372f, 0.00679319f, 0.03693394f, 0.02131718f, 0.02671468f, 
    -0.07679466f, 0.06439888f, -0.01551604f, 0.01203158f, -0.04834766f, 0.02773188f, -0.00262726f, 0.02815793f, 
    -0.00479917f, 0.05601812f, -0.02244003f, 0.05465573f, 0.01818831f, -0.04700729f, -0.06619199f, 0.03628494f, 
    0.04274256f, -0.07654925f, 0.00972684f, 0.00782988f, -0.07909068f, -0.00011692f, -0.00332972f, 0.03155750f, 
    -0.05074608f, -0.07433795f, -0.05923062f, 0.00612452f, -0.00708183f, -0.02518473f, -0.02539119f, 0.00058735f, 
    0.01893429f, 0.06367413f, -0.06502295f, -0.02712545f, -0.06377451f, -0.06166615f, 0.03642520f, 0.04129991f, 
    -0.02658748f, 0.03558783f, -0.01652298f, 0.05122933f, 0.01813592f, -0.07248823f, -0.06762850f, -0.02989043f, 
    -0.04565789f, 0.06141695f, 0.02784140f, -0.01205286f, -0.03533217f, 0.04036579f, 0.02606562f, 0.01858126f, 
    -0.02698789f, -0.00971827f, -0.01683326f, -0.06170771f, 0.04240163f, -0.08097233f, -0.01255755f, -0.06598403f, 
    -0.04289449f, 0.05819558f, -0.07812539f, -0.03062850f, 0.04156827f, 0.01462121f, 0.04717584f, 0.04741728f, 
    -0.05121171f, 0.06017479f, 0.02641072f, 0.02369846f, 0.03012436f, 0.01776606f, -0.06001389f, -0.06504942f, 
    -0.05778462f, 0.06272694f, -0.04835246f, -0.07363915f, 0.03117424f, 0.01740602f, -0.07600759f, -0.04430449f, 
    0.05800940f, -0.03502419f, 0.04450037f, -0.01280667f, 0.03480075f, 0.00289958f, 0.03664457f, -0.06051333f, 
    -0.17602591f, 0.19373521f, -0.07893924f, 0.05347321f, -0.05215086f, 0.05825122f, -0.01127665f, 0.08202880f, 
    -0.00004135f, 0.00196770f, -0.04005129f, -0.01736866f, 0.23393740f, 0.15598562f, 0.05570970f, -0.10106961f, 
    0.09476805f, 0.08088282f, 0.05411146f, 0.14148587f, -0.11190958f, -0.01332875f, -0.00484445f, 0.07574538f, 
    0.35650271f, -0.33622441f, 0.12736593f, -0.00114807f, 0.03511979f, 0.01691966f, -0.00034416f, 0.00570006f, 
    0.08054887f, -0.05186556f, 0.05187324f, -0.00196452f, 0.24722219f, 0.00998892f, -0.05812382f, -0.00603878f, 
    0.00807198f, -0.00293828f, -0.00530004f, 0.02803368f, 0.09934245f, -0.04429171f, -0.08405659f, -0.04937163f, 
    -0.21367958f, 0.32059813f, -0.05803023f, 0.04416300f, 0.07218662f, 0.03985181f, 0.01707807f, -0.09234880f, 
    0.03027522f, 0.02685950f, -0.01768083f, 0.02584708f, -0.02210783f, 0.12746406f, -0.05648673f, 0.06117111f, 
    -0.06732173f, -0.04172394f, -0.03860942f, 0.04240042f, -0.00854128f, 0.02123818f, 0.06830763f, 0.06624896f, 
    0.18364012f, -0.13170952f, 0.03948300f, 0.12030441f, 0.08642483f, 0.03432208f, 0.02932132f, 0.09614846f, 
    -0.09494568f, -0.08959600f, 0.01819062f, -0.02800307f, -0.23056647f, -0.18503881f, 0.02086085f, -0.13360122f, 
    0.11696579f, -0.07598557f, -0.01452744f, -0.01246999f, 0.04126911f, 0.04443644f, -0.00790682f, -0.03444659f, 
    0.06667046f, 0.09426814f, 0.15172438f, 0.17382036f, 0.02524397f, -0.05831436f, 0.07638746f, -0.06681984f, 
    0.02205517f, 0.00813039f, -0.00918849f, -0.08545154f, -0.20752023f, 0.23995678f, 0.02860957f, 0.13043506f, 
    0.00944122f, -0.03950728f, -0.22543642f, -0.00562623f, 0.01154449f, -0.04624287f, -0.00129781f, 0.07171854f, 
    -0.31441763f, -0.15816790f, 0.11841480f, 0.02173031f, 0.00212520f, -0.00094982f, 0.12436411f, -0.05136823f, 
    0.03894692f, -0.06797694f, -0.02563988f, -0.05937415f, 0.24151593f, -0.00769064f, 0.19266719f, 0.08011743f, 
    0.05509558f, 0.03664358f, -0.07949523f, 0.01479127f, 0.03055686f, 0.05026615f, 0.14384916f, 0.18367013f, 
    0.07364269f, -0.01051092f, 0.04368824f, 0.13623311f, -0.00754622f, -0.07040179f, -0.10270596f, -0.07920254f, 
    -0.02262775f, 0.03421727f, 0.01018456f, 0.06563526f, -0.13050446f, 0.15909651f, 0.20124184f, -0.27424777f, 
    0.15095475f, 0.04191885f, 0.09031545f, -0.10433921f, -0.08220280f, 0.09934182f, 0.00150252f, 0.02886163f, 
    -0.21483730f, 0.11519162f, 0.09039982f, 0.04868001f, -0.05593037f, 0.12302672f, -0.07833449f, 0.03330247f, 
    0.02763034f, -0.04733033f, 0.04125015f, -0.09405512f, -0.22291857f, -0.06473817f, -0.03568957f, 0.06228142f, 
    -0.02231149f, 0.17564499f, -0.01139981f, -0.09510451f, -0.05583429f, -0.01878259f, 0.02399255f, -0.06674191f, 
    -0.06973786f, 0.03249440f, -0.03463292f, -0.01268062f, 0.03306874f, -0.07201394f, -0.07579133f, -0.02051406f, 
    -0.04863472f, -0.00257002f, -0.03241742f, -0.03399805f, -0.02872768f, -0.04923647f, -0.00002399f, -0.06047756f, 
    0.02769090f, 0.05148204f, -0.08000780f, -0.07665237f, -0.04229004f, 0.04734348f, 0.01599406f, 0.00351220f, 
    -0.03259588f, 0.02477122f, 0.01084997f, 0.02843837f, -0.03292529f, 0.00023854f, -0.04361689f, 0.01489545f, 
    -0.00431996f, -0.00694372f, -0.04231129f, 0.04799980f, 0.04907419f, 0.05580793f, -0.01314137f, -0.01989389f, 
    0.01399288f, 0.04112510f, -0.06395011f, 0.00233097f, 0.03381445f, 0.04475346f, 0.00332955f, -0.06183704f, 
    -0.00326682f, 0.01294131f, -0.04710175f, 0.06090804f, 0.01506287f, 0.04493521f, -0.04189590f, -0.06947464f, 
    0.00650207f, -0.04930436f, 0.04088857f, 0.02873116f, -0.05855497f, -0.03332267f, -0.07112768f, 0.04757763f, 
    0.04780079f, 0.01135490f, -0.08079714f, -0.01867727f, 0.02716079f, 0.03814967f, -0.03514616f, 0.00059258f, 
    0.00416379f, -0.05800952f, -0.06325278f, 0.03736306f, 0.00085884f, 0.03825172f, 0.00723955f, 0.03892069f, 
    -0.07526700f, 0.01389749f, 0.01829145f, -0.01216557f, 0.05378111f, -0.02340534f, 0.02566567f, -0.04842341f, 
    0.00894389f, 0.05630549f, -0.03567819f, -0.00227576f, -0.02632461f, -0.05755039f, -0.09124807f, 0.06371666f, 
    -0.06560735f, 0.04325515f, -0.06035153f, -0.00615056f, -0.02030649f, 0.03193218f, -0.02469111f, -0.04300335f, 
    0.03238692f, -0.08457731f, -0.01738220f, -0.07091684f, -0.02368724f, -0.04765374f, 0.03626766f, 0.02249311f, 
    -0.06905879f, -0.04761725f, 0.03659768f, -0.04734046f, -0.05638193f, -0.01526758f, -0.05781354f, 0.01123587f, 
    0.06180602f, -0.02037878f, -0.08137193f, -0.04183332f, -0.03780570f, -0.06940316f, 0.00681773f, -0.05265830f, 
    -0.05227515f, 0.00757702f, 0.03660704f, -0.02270652f, 0.02614810f, 0.05945335f, -0.01878125f, 0.01757148f, 
    -0.03351377f, -0.01460475f, 0.06047926f, -0.07393641f, -0.03867757f, -0.08266366f, 0.00992033f, 0.00170562f, 
    -0.02914855f, -0.03423541f, -0.03911611f, -0.03302786f, 0.03378544f, 0.05999519f, 0.05089421f, 0.04595510f, 
    -0.06137924f, 0.02654867f, -0.01532997f, -0.00031786f, 0.05229028f, -0.08530221f, -0.00625573f, -0.00757118f, 
    0.02916188f, 0.04223969f, -0.03818979f, -0.03159740f, 0.02539869f, -0.05434287f, 0.03609480f, 0.05302756f, 
    0.05804013f, 0.03099276f, 0.01936552f, 0.04587002f, -0.03572913f, 0.01380165f, -0.05452525f, -0.03525565f, 
    0.02915980f, -0.06477820f, -0.06786681f, -0.00303913f, -0.01554372f, 0.04868177f, 0.02258226f, 0.02462032f, 
    -0.02333003f, 0.01030111f, -0.05288707f, -0.05593935f, -0.08511888f, -0.00160176f, -0.08543764f, 0.05620785f, 
    -0.26313093f, -0.22374485f, 0.03958164f, -0.05006059f, -0.05608136f, -0.06182314f, 0.12800537f, -0.02592165f, 
    -0.06309905f, -0.04172036f, 0.00552447f, -0.13539872f, 0.23456581f, 0.00681414f, 0.11290874f, -0.11259294f, 
    0.06960650f, 0.15913965f, -0.13527152f, 0.03483567f, -0.11205865f, 0.05163782f, 0.00394195f, 0.03441257f, 
    0.16609961f, 0.03102845f, 0.13040179f, 0.12907152f, 0.01272532f, 0.01387295f, 0.11735746f, 0.00189551f, 
    0.09849870f, -0.00893235f, -0.07159499f, -0.05304121f, 0.05463470f, -0.13710462f, 0.02147105f, -0.14845872f, 
    0.06868418f, 0.09926097f, 0.03282882f, -0.06416745f, 0.04026933f, 0.19089223f, -0.09514890f, -0.10888262f, 
    -0.03737906f, 0.30455503f, -0.08043163f, 0.00434230f, 0.00292231f, -0.01771393f, 0.02611735f, 0.04640905f, 
    -0.03668372f, -0.09383412f, -0.06348894f, 0.02544086f, 0.02553980f, -0.02974650f, -0.02942082f, 0.13850503f, 
    -0.09298774f, 0.11683549f, 0.03525756f, 0.03791555f, -0.09390539f, 0.02639865f, -0.03180129f, 0.07919521f, 
    -0.37788138f, -0.06359617f, 0.32852939f, -0.21179827f, -0.05077200f, 0.06993468f, 0.07633154f, -0.05650566f, 
    -0.05453442f, -0.03822985f, 0.00143156f, -0.04673759f, -0.19488950f, -0.06015038f, 0.06648592f, 0.11718227f, 
    -0.01575217f, -0.01164609f, -0.03882927f, -0.03340008f, 0.00924370f, -0.02378819f, -0.02852993f, -0.02728986f, 
    0.18159263f, 0.07238927f, 0.03539617f, 0.05041839f, -0.04204821f, -0.05560603f, 0.01361638f, 0.02205190f, 
    -0.01486117f, -0.01387424f, -0.03934288f, -0.00978926f, -0.14296584f, 0.06923411f, 0.18855235f, 0.11560097f, 
    -0.06100571f, 0.04396559f, -0.02360301f, 0.03423699f, -0.05244185f, 0.11590922f, -0.06520815f, -0.08857794f, 
    0.22697343f, 0.07076267f, 0.16689637f, -0.03827592f, 0.03441975f, 0.02783503f, 0.09728492f, -0.01560154f, 
    -0.02976287f, -0.00609900f, 0.06009617f, -0.12313094f, -0.03170006f, -0.05176539f, 0.15202370f, 0.03391394f, 
    -0.04934423f, 0.12845865f, 0.10756867f, 0.04458854f, -0.02331134f, 0.14882864f, -0.01557114f, 0.15861788f, 
    0.22887048f, -0.05907824f, -0.13608676f, -0.02293715f, -0.08259945f, 0.09276096f, -0.02408671f, -0.09977780f, 
    -0.04695835f, 0.03670510f, 0.13116693f, 0.02243689f, -0.05483852f, 0.07781612f, -0.06215026f, -0.02205561f, 
    -0.13427114f, 0.05748640f, 0.05822797f, 0.16402313f, -0.06508530f, 0.11283353f, 0.10127953f, 0.08711918f, 
    0.24225934f, 0.16631484f, -0.02950669f, -0.13972297f, 0.04702568f, 0.01557479f, 0.11441153f, 0.03663563f, 
    -0.07423130f, 0.01575645f, 0.01754093f, -0.10461514f, -0.03070113f, -0.09902878f, 0.05913456f, 0.27086672f, 
    -0.09850921f, -0.03529409f, 0.03434977f, 0.01771172f, -0.07933806f, 0.01286171f, -0.01616630f, 0.16979191f, 
    0.40682793f, 0.27279356f, -0.03223154f, 0.02657834f, 0.07985101f, 0.19803599f, -0.14571458f, 0.23082606f, 
    0.19689324f, -0.09266233f, 0.01056786f, 0.03517496f, 0.00535763f, -0.14781985f, 0.03178455f, -0.18005049f, 
    -0.11819436f, -0.01754439f, 0.11366006f, 0.04991847f, 0.01355706f, -0.02088031f, 0.13515143f, -0.04201010f, 
    -0.32800701f, 0.13681710f, 0.20415048f, -0.04217831f, -0.07383496f, -0.04719193f, -0.01884085f, -0.08113021f, 
    0.07846123f, 0.04321216f, 0.02366969f, -0.00889803f, -0.03041287f, 0.10819185f, -0.20670499f, 0.06358497f, 
    -0.09266003f, -0.02502421f, -0.04220008f, 0.11861631f, -0.00819786f, 0.09310911f, 0.04462621f, 0.04016888f, 
    -0.06393587f, -0.08229880f, 0.02561049f, 0.08339458f, -0.14166670f, 0.01121081f, -0.03484792f, 0.19163288f, 
    -0.00078017f, 0.08932351f, 0.11280768f, 0.12183239f, 0.00165596f, 0.00062607f, 0.15277423f, -0.20862851f, 
    0.06893262f, -0.04431169f, 0.12289679f, -0.14898206f, -0.04414878f, 0.09078114f, -0.12737760f, 0.01963246f, 
    0.13004266f, 0.26500696f, -0.13163739f, 0.15081039f, 0.11566156f, 0.06839104f, -0.07167299f, 0.05617176f, 
    0.02762871f, 0.17258480f, 0.01955527f, 0.07344755f, -0.19070415f, 0.22349977f, 0.07860229f, 0.05866784f, 
    -0.01576325f, -0.02927893f, 0.16654187f, -0.03005725f, 0.12558059f, -0.06792810f, 0.00996289f, 0.11611973f, 
    0.04444836f, 0.27577150f, 0.25382501f, -0.07651845f, 0.17698163f, 0.06517027f, 0.11397815f, 0.04258278f, 
    -0.00926198f, -0.03763004f, 0.02885123f, 0.21661150f, 0.01788739f, -0.03071583f, -0.39022475f, -0.29402512f, 
    -0.06256675f, 0.03989306f, 0.18072902f, -0.21001640f, 0.14355114f, 0.04634768f, 0.01151808f, -0.04605369f, 
    0.04182047f, 0.01090762f, -0.11056615f, -0.13052890f, 0.08345215f, 0.11652862f, 0.03214695f, -0.09124043f, 
    -0.04016772f, 0.03047700f, 0.05599096f, 0.03953500f, -0.24866253f, -0.21728274f, -0.01603762f, 0.11425258f, 
    0.14052258f, -0.00527759f, -0.02066927f, -0.02718842f, 0.02950967f, 0.03229821f, 0.02374665f, 0.03911177f, 
    -0.35548210f, -0.05759066f, 0.01322689f, -0.06123016f, 0.03922886f, 0.06873798f, -0.07331818f, 0.16227281f, 
    0.04300884f, 0.10061343f, 0.10157124f, 0.18561649f, -0.03139996f, 0.02176661f, 0.00806371f, 0.10801096f, 
    -0.04900983f, 0.08427314f, -0.02578403f, 0.00428448f, -0.07699700f, 0.07485288f, 0.13510415f, 0.03668514f, 
    0.23361593f, -0.07126348f, 0.10661756f, 0.15788558f, -0.01428843f, 0.01967181f, 0.08061676f, 0.03536801f, 
    0.08113831f, 0.11103524f, 0.00609048f, 0.08854016f, -0.26272002f, -0.04517232f, -0.02944985f, -0.37185115f, 
    0.03353722f, -0.08378991f, 0.04428759f, 0.00975424f, -0.03543063f, 0.05101402f, -0.01523903f, 0.18105997f, 
    0.01893087f, -0.06079551f, 0.04026067f, -0.04708650f, -0.03654379f, -0.00391000f, -0.00414293f, -0.07515790f, 
    -0.06975596f, -0.05943779f, -0.06186944f, -0.03018388f, -0.06976634f, 0.01757109f, -0.03098999f, 0.01377586f, 
    -0.01952613f, -0.03636938f, 0.04049143f, -0.04288295f, -0.03108121f, 0.04828921f, -0.08143401f, -0.02247973f, 
    -0.00194011f, -0.07078180f, -0.05526845f, -0.04546775f, 0.05397766f, -0.01543701f, -0.01907871f, -0.02808991f, 
    -0.07139361f, 0.04293529f, -0.05805942f, 0.02934379f, -0.05806394f, 0.02259414f, -0.01752314f, -0.06403360f, 
    -0.05983882f, -0.00838666f, 0.05696585f, 0.00122024f, -0.00510339f, -0.08033187f, -0.03877340f, -0.04911441f, 
    -0.06859057f, -0.07010350f, -0.02390065f, 0.02106333f, 0.05908653f, -0.06077281f, -0.08023244f, -0.00617174f, 
    -0.01712602f, -0.04641102f, 0.06070499f, 0.02877850f, -0.03594416f, -0.04659369f, -0.03227137f, -0.01599348f, 
    -0.06847315f, -0.01253297f, -0.07588476f, 0.02749124f, 0.03308370f, 0.00833759f, -0.07235806f, 0.02386797f, 
    -0.04485826f, 0.00304418f, 0.00858314f, -0.06877549f, 0.01656296f, 0.00879800f, -0.04918876f, -0.02126095f, 
    -0.07162111f, 0.00911804f, 0.04569520f, 0.01560241f, -0.01853695f, 0.03568919f, 0.04964772f, -0.07889675f, 
    -0.02573104f, 0.05083204f, -0.03379677f, -0.06319193f, -0.01777069f, -0.04873711f, -0.04593322f, -0.02809499f, 
    -0.02409265f, -0.05525884f, -0.07770374f, 0.05608357f, 0.04430095f, -0.00820333f, -0.03183943f, -0.01811046f, 
    -0.05039991f, -0.04044447f, 0.05509363f, -0.06240724f, 0.01914398f, -0.00492162f, 0.04701949f, -0.06477851f, 
    0.06487163f, -0.05204336f, -0.07338998f, -0.01887868f, -0.02853539f, -0.05650826f, -0.07859159f, 0.04046380f, 
    0.00393336f, -0.06602142f, -0.04741905f, 0.04039402f, -0.06355589f, -0.01960903f, -0.00691377f, 0.03782201f, 
    -0.03636757f, 0.03720944f, 0.04424151f, -0.06042985f, 0.02507367f, -0.02892546f, 0.01878863f, -0.07563415f, 
    -0.01135922f, 0.06167883f, 0.02963324f, -0.04404466f, 0.05214097f, -0.05209382f, 0.05143326f, -0.05231392f, 
    0.00310039f, -0.02684274f, -0.01909637f, -0.06697377f, -0.04089437f, -0.06918915f, -0.07795507f, 0.03635946f, 
    -0.04980233f, -0.03036144f, 0.05930251f, 0.05352978f, 0.04828174f, -0.03681299f, -0.02487667f, -0.04773819f, 
    0.05348513f, 0.03418498f, -0.00708504f, -0.01083903f, 0.06149869f, 0.03541154f, 0.03641364f, 0.03917858f, 
    -0.02982952f, -0.06034762f, -0.04942853f, 0.03703426f, -0.06562953f, 0.00977933f, 0.04299723f, -0.00037249f, 
    0.01825702f, -0.03313009f, -0.06557129f, 0.03827921f, -0.05015112f, -0.05490635f, -0.01953115f, -0.00224992f, 
    0.00679987f, -0.00720392f, -0.05091028f, -0.02341110f, 0.04757960f, 0.05060060f, 0.02209569f, 0.03787270f, 
    0.26393479f, -0.27432400f, -0.13649286f, 0.29851916f, -0.10036078f, 0.07856552f, 0.06152016f, 0.00935524f, 
    -0.09295990f, -0.00420724f, 0.05457828f, 0.06904960f, -0.13762021f, -0.00051062f, -0.05908295f, 0.16722049f, 
    0.02187619f, -0.10422092f, 0.17918210f, 0.10940546f, 0.14279976f, -0.00263816f, -0.15603702f, 0.16271168f, 
    -0.16025737f, 0.34954426f, 0.07758441f, 0.03861890f, 0.04843972f, 0.11483732f, 0.11443412f, 0.09483197f, 
    0.01504451f, -0.06728608f, 0.10721987f, 0.11462852f, -0.14534555f, -0.07643284f, -0.25440764f, 0.12991773f, 
    0.04710874f, -0.04199159f, 0.17079177f, -0.00063678f, 0.08191958f, 0.02053514f, -0.08859030f, -0.00277793f, 
    -0.12884299f, -0.30566141f, -0.00583104f, 0.15527506f, -0.06177380f, 0.02104287f, 0.02524939f, 0.06121027f, 
    0.10927187f, 0.00864456f, 0.06967880f, -0.05483015f, 0.07144990f, -0.04794973f, 0.10659868f, 0.16763414f, 
    0.04747034f, 0.06731468f, -0.06345899f, 0.08098190f, 0.24309741f, 0.00605318f, 0.20045485f, 0.05816009f, 
    -0.09995590f, -0.17996284f, -0.00760103f, 0.23299566f, -0.06791579f, -0.10110917f, 0.05166467f, 0.05716492f, 
    0.13762647f, -0.04169150f, 0.09311108f, -0.03170867f, -0.35359964f, 0.00996189f, -0.18447202f, -0.08069770f, 
    -0.00520051f, 0.02653576f, 0.07623070f, -0.01973387f, -0.04244282f, 0.05215155f, -0.05401157f, -0.08596721f, 
    0.26927531f, 0.10631277f, 0.06164631f, 0.11051127f, -0.02139495f, 0.19133922f, 0.10191024f, 0.09841204f, 
    -0.01667624f, -0.03684994f, -0.05251091f, 0.03213952f, 0.20115599f, -0.23118529f, -0.18932760f, 0.11870925f, 
    0.05742260f, 0.02998640f, -0.14449337f, 0.16664048f, -0.00634004f, 0.11330944f, 0.11298003f, 0.10084748f, 
    0.00622963f, -0.00601678f, -0.15031479f, -0.14019342f, -0.00574384f, -0.04542743f, -0.10077816f, -0.05187593f, 
    0.21666209f, 0.13487309f, -0.09829289f, 0.08996128f, -0.00295316f, -0.01526310f, 0.07212216f, -0.11866052f, 
    0.08530999f, -0.13859378f, -0.20612024f, 0.02007392f, 0.04626143f, 0.05865853f, 0.08483329f, 0.00374331f, 
    0.05312685f, -0.03498819f, 0.12324946f, -0.27380368f, -0.01751221f, -0.01514994f, 0.02413956f, 0.02907576f, 
    0.04538560f, -0.09975018f, -0.10424977f, 0.09504803f, 0.15290569f, -0.00955985f, 0.14541687f, -0.02362185f, 
    -0.01089376f, -0.08364715f, -0.02927746f, 0.06531836f, 0.11362875f, -0.05169551f, 0.09587307f, 0.09412775f, 
    0.33363444f, -0.03201348f, 0.05442864f, 0.03432287f, -0.05043334f, 0.01771844f, 0.07866404f, 0.06419619f, 
    -0.11045159f, -0.06509878f, -0.06424434f, -0.03211251f, -0.03389074f, 0.12207023f, -0.09302828f, -0.07494799f, 
    0.06111215f, 0.02795161f, -0.03312299f, -0.01822862f, 0.07725955f, 0.03056311f, 0.11420961f, -0.04272619f, 
    -0.24308416f, -0.05353926f, -0.09200986f, 0.07692508f, 0.07732801f, 0.12012836f, -0.03152130f, -0.10155290f, 
    0.07853663f, 0.06981295f, -0.01976932f, -0.02005888f, 0.12335734f, -0.00232308f, 0.22919826f, -0.12509637f, 
    -0.10655966f, 0.00313374f, -0.17195742f, -0.06309558f, 0.03885734f, -0.03404051f, 0.20054348f, -0.04958610f, 
    0.16727269f, 0.02063862f, -0.03632026f, 0.00431987f, -0.01500312f, 0.07482186f, 0.08680496f, -0.02641590f, 
    -0.04056532f, -0.09237669f, -0.08118426f, 0.00057550f, -0.25371966f, 0.03553693f, 0.09596378f, 0.02991196f, 
    0.02631250f, 0.04126438f, 0.02507696f, 0.15375903f, 0.01525539f, 0.07327886f, 0.05934350f, -0.03974419f, 
    -0.12433956f, 0.03708258f, -0.06187862f, -0.31059283f, -0.02580991f, 0.06604286f, 0.03999636f, -0.04825305f, 
    0.10370599f, 0.00025276f, 0.17462763f, 0.07559673f, -0.05723355f, -0.00460641f, -0.20910034f, 0.04424087f, 
    0.02341924f, 0.04854927f, 0.07762893f, -0.02257121f, 0.11607198f, 0.04213121f, -0.03472804f, -0.06165097f, 
    0.05856003f, -0.10675476f, 0.02602447f, 0.10287111f, 0.04160913f, 0.11101896f, -0.03286177f, -0.07176138f, 
    0.02568769f, 0.15139046f, -0.05929560f, -0.04281291f, 0.59115922f, -0.09363649f, 0.11043918f, 0.06751464f, 
    -0.09181604f, -0.06362613f, 0.09281147f, 0.02243245f, -0.01740576f, -0.00563556f, 0.09438292f, 0.04393302f, 
    -0.14150532f, 0.02520479f, 0.06730156f, 0.06667405f, 0.01628260f, 0.07242189f, 0.11616858f, 0.02873407f, 
    0.10856694f, 0.05794852f, -0.05670176f, 0.09270062f, 0.15769109f, -0.06100921f, 0.00530922f, 0.10039415f, 
    -0.00357233f, -0.06688979f, 0.05916248f, -0.09238373f, -0.03305787f, -0.09272914f, 0.03650231f, -0.04239072f, 
    0.21323809f, 0.14900294f, 0.17212497f, 0.06916593f, 0.03896080f, 0.14284584f, -0.04080039f, 0.11048453f, 
    -0.05029007f, 0.01634933f, 0.08292422f, 0.01881779f, -0.20400958f, 0.03580033f, -0.03582875f, -0.17681494f, 
    -0.03092053f, 0.11964219f, 0.14496419f, 0.01223304f, -0.17686372f, 0.08475218f, 0.09749743f, 0.07746658f, 
    -0.14837559f, 0.00676518f, -0.12633426f, 0.20078918f, 0.06058957f, 0.02084024f, 0.11390477f, -0.04457232f, 
    0.01828911f, 0.12106491f, 0.02746057f, 0.02880543f, -0.09487519f, -0.07380035f, -0.02248485f, -0.37159884f, 
    0.03857588f, -0.02012264f, -0.05888730f, 0.14851084f, -0.07366279f, 0.05355966f, 0.03425546f, -0.01369498f, 
    0.35014647f, -0.06946746f, -0.29108009f, 0.29112229f, 0.08383856f, 0.05074430f, -0.01191157f, 0.15852901f, 
    0.08939842f, 0.02820922f, -0.04666787f, 0.01080102f, 0.18197452f, -0.10870698f, -0.09494530f, 0.17311017f, 
    -0.20320374f, 0.00313665f, 0.16557781f, 0.06900487f, -0.18428856f, 0.06936229f, 0.05141279f, 0.10118915f, 
    0.00076830f, -0.06562371f, 0.04600125f, 0.02608111f, 0.00097367f, -0.01250211f, -0.07351131f, -0.04235146f, 
    0.03321758f, -0.04455952f, -0.01630477f, 0.01897250f, -0.02652461f, 0.04785262f, -0.01189837f, -0.00947118f, 
    -0.03954755f, 0.02847528f, -0.02769991f, -0.07839743f, -0.07131568f, -0.02745074f, 0.06096362f, 0.01067550f, 
    0.04093797f, -0.07808463f, 0.04899053f, -0.01700295f, 0.05652312f, -0.06961727f, 0.05435032f, 0.05796325f, 
    -0.06010031f, -0.04666856f, -0.05512385f, -0.04390598f, -0.00171379f, -0.06811532f, -0.03930956f, 0.00956716f, 
    -0.04976546f, 0.04681586f, 0.03077221f, 0.02084775f, 0.02870652f, 0.05291781f, -0.07500560f, -0.02339164f, 
    0.05552314f, 0.00989224f, -0.01490799f, -0.05361094f, -0.00550052f, -0.06819520f, 0.01232979f, 0.00151937f, 
    0.04976182f, -0.01066220f, 0.05155640f, -0.06889963f, 0.00483041f, 0.06558101f, -0.01674420f, -0.08151522f, 
    -0.04217244f, -0.03191883f, 0.05624988f, -0.03661192f, -0.08010025f, 0.05845930f, -0.00191674f, -0.01527414f, 
    -0.06330474f, 0.05096426f, 0.05110933f, 0.02364441f, -0.07038935f, 0.02626648f, 0.06038220f, -0.07275981f, 
    -0.07578705f, -0.06189855f, 0.02097673f, 0.02530078f, -0.04300617f, -0.03023956f, -0.01987037f, -0.03069515f, 
    0.05365324f, -0.01494437f, 0.03715361f, 0.01791480f, 0.04601319f, -0.01402609f, -0.07034452f, -0.04241840f, 
    0.02651219f, 0.00447459f, 0.02587813f, 0.02979324f, 0.00170240f, 0.01737620f, 0.01083896f, -0.01762689f, 
    -0.04246717f, -0.00794771f, 0.05169932f, -0.04997929f, 0.02601416f, 0.01295740f, -0.07873526f, -0.05496453f, 
    -0.02108140f, 0.02990007f, -0.03699260f, -0.05695823f, -0.02721758f, 0.01730733f, -0.03252355f, -0.04481341f, 
    -0.01742716f, -0.00811924f, -0.01870860f, 0.05981762f, -0.05896641f, -0.00646500f, 0.05900865f, -0.06411885f, 
    -0.02333693f, -0.00649493f, -0.01966606f, -0.07554527f, -0.05498527f, 0.01200810f, 0.03529412f, -0.01082960f, 
    0.00368740f, -0.05766865f, -0.03640739f, 0.02010010f, -0.01058504f, 0.02757965f, 0.04362377f, 0.03854190f, 
    -0.06112617f, 0.05036451f, -0.05764616f, -0.03102279f, -0.04088177f, -0.02735743f, -0.03559047f, -0.02691325f, 
    0.04256979f, -0.06532921f, -0.03989684f, -0.01900601f, -0.05565881f, 0.05649102f, 0.01904965f, 0.00599341f, 
    0.03992067f, -0.00166748f, 0.04323719f, -0.02436111f, -0.08291546f, 0.00278165f, -0.07558892f, -0.06700746f, 
    0.03643971f, -0.04254517f, -0.05215595f, -0.07875351f, -0.04984383f, -0.06015687f, 0.02113334f, -0.00001233f, 
    -0.04604051f, -0.06634291f, -0.03588466f, -0.04584463f, -0.04436401f, 0.01052623f, 0.00112082f, 0.03968617f, 
    0.00244683f, -0.03785160f, -0.00588159f, 0.02665653f, -0.04690778f, -0.02202757f, 0.05313021f, 0.05365045f, 
    -0.23240840f, -0.09105211f, 0.05380986f, 0.05157546f, 0.01009511f, 0.00092831f, 0.03420559f, -0.16074030f, 
    0.06277389f, 0.11400206f, 0.12281949f, 0.10487495f, -0.21235020f, -0.18707973f, 0.08767685f, 0.03104331f, 
    -0.02282422f, 0.03527506f, -0.03727043f, -0.13839734f, 0.03699423f, -0.06042462f, 0.04679480f, -0.05146562f, 
    -0.03031118f, 0.25720572f, -0.11478385f, 0.10314625f, -0.02332238f, 0.11454301f, 0.04221715f, 0.10936556f, 
    0.05787978f, -0.05667587f, -0.08089958f, 0.14331521f, -0.49118069f, 0.09302787f, 0.06789754f, 0.03348831f, 
    0.12700541f, 0.01936604f, 0.01987301f, -0.02019703f, 0.09877355f, 0.05840952f, 0.09411676f, 0.00339292f, 
    0.05002672f, -0.26028448f, 0.25377476f, -0.03299056f, 0.10910887f, -0.03038632f, 0.05310790f, -0.06186611f, 
    0.07759186f, -0.04579923f, -0.03668955f, -0.00097720f, -0.23092416f, -0.05449788f, 0.00889123f, 0.11612043f, 
    0.24803765f, 0.11057292f, 0.07330132f, -0.06714767f, -0.03869511f, 0.03352351f, 0.07777023f, 0.02301121f, 
    -0.29543942f, -0.03566525f, -0.06265905f, -0.05085885f, 0.03260413f, 0.01299267f, 0.13546360f, -0.00562511f, 
    0.12676775f, 0.03581959f, 0.00499964f, -0.10420962f, 0.38780195f, -0.09347814f, 0.08972392f, -0.09221686f, 
    0.05117553f, 0.04877028f, 0.07023415f, 0.05253803f, -0.02229284f, -0.09139026f, -0.01286271f, 0.00802614f, 
    -0.01713255f, 0.08401655f, -0.15232085f, -0.07686065f, 0.07332745f, 0.19200362f, 0.13235274f, -0.08005875f, 
    -0.00226014f, 0.13313268f, 0.03812943f, 0.01728612f, 0.03556904f, -0.06815270f, -0.01212941f, 0.04547876f, 
    0.08960497f, -0.04602623f, 0.05861203f, 0.03928568f, 0.01047810f, -0.02886493f, 0.07097097f, 0.03522746f, 
    0.31347048f, 0.15705658f, 0.02793282f, 0.09961160f, 0.05402675f, -0.01295445f, -0.06796271f, 0.07812892f, 
    0.11063993f, 0.23177527f, 0.00844348f, -0.05334933f, -0.14966743f, -0.05071674f, -0.02400285f, -0.19993737f, 
    -0.02979645f, -0.10384724f, -0.10684548f, 0.07701240f, -0.07068725f, -0.11546084f, -0.03346872f, 0.01686476f, 
    0.07122425f, 0.05034311f, -0.12424946f, 0.03145957f, -0.03039445f, 0.01596186f, 0.18024686f, -0.00094435f, 
    0.07784190f, -0.09296744f, -0.00403458f, -0.02969309f, 0.19925019f, -0.05254210f, 0.04104564f, 0.01613989f, 
    -0.05374258f, 0.00066134f, -0.09559620f, 0.04497530f, 0.06220562f, 0.00751338f, -0.06037974f, 0.00780445f, 
    0.30153224f, -0.17363320f, -0.26724327f, 0.02349924f, 0.10289688f, -0.07888994f, 0.16755211f, -0.00739577f, 
    -0.02689146f, 0.13665263f, 0.02827860f, 0.02164037f, 0.13646939f, 0.04704329f, -0.03914098f, 0.15629175f, 
    -0.11231737f, -0.10655353f, 0.05411571f, 0.00673989f, -0.04235337f, 0.00152465f, 0.01591817f, -0.05168317f, 
    -0.16771922f, 0.01793406f, -0.08722350f, -0.00026580f, 0.12343792f, 0.03528938f, 0.01686369f, -0.16138856f, 
    0.03647441f, -0.01038579f, -0.02536746f, -0.12337717f, 0.13573547f, 0.18880205f, 0.13498859f, -0.12810357f, 
    0.03239463f, 0.07786185f, -0.26616871f, -0.01154176f, -0.06496258f, 0.12473208f, 0.11922853f, 0.03096493f, 
    0.09948573f, -0.21209048f, -0.05299666f, 0.00151170f, -0.03321077f, -0.01987260f, 0.01020804f, 0.03872303f, 
    0.06233298f, -0.03830430f, -0.02179721f, -0.00686457f, 0.34398052f, 0.00073447f, 0.20058490f, -0.14116591f, 
    0.11532278f, 0.10353038f, -0.08040291f, -0.01672667f, 0.02874702f, 0.01919844f, -0.04203618f, -0.01788621f, 
    -0.14870436f, 0.29024616f, -0.37918350f, -0.29383492f, 0.10604299f, 0.06869291f, -0.04937357f, -0.11504801f, 
    0.00223004f, 0.00038415f, 0.10443377f, -0.06632946f, 0.27328071f, 0.12279825f, -0.19388974f, 0.02117131f, 
    -0.07337391f, -0.05428304f, 0.03585245f, 0.00870923f, 0.09006101f, 0.06357574f, 0.04513724f, 0.04305996f, 
    0.40256378f, -0.11781252f, 0.04024656f, 0.00782578f, 0.10544732f, 0.01090503f, -0.08887061f, -0.08564071f, 
    -0.01905669f, 0.09318519f, 0.11782186f, 0.11156023f, 0.19006240f, -0.16665713f, -0.02147871f, 0.19221462f, 
    0.11979288f, -0.05278312f, 0.06245630f, 0.02238622f, 0.05372369f, 0.05796241f, 0.14372851f, -0.08899105f, 
    -0.25970259f, 0.01550076f, -0.00735906f, 0.07330678f, -0.13146254f, 0.10340667f, -0.00151002f, -0.05564822f, 
    0.16370466f, 0.15319264f, -0.05359573f, -0.05715052f, 0.10475904f, -0.07368011f, 0.26121280f, 0.00904668f, 
    0.00323307f, -0.12059078f, 0.01629835f, -0.02782477f, -0.02434029f, -0.01368492f, 0.07806479f, -0.13268512f, 
    0.07106020f, -0.10994516f, 0.18020141f, 0.08710364f, 0.06598377f, 0.14800140f, 0.07122201f, 0.15489325f, 
    -0.06718381f, -0.05096146f, 0.09659130f, 0.01210168f, -0.08312261f, 0.00323232f, 0.12855612f, 0.01306912f, 
    -0.00710103f, 0.13250554f, 0.08837692f, 0.02435751f, 0.01523962f, 0.06647035f, 0.06386490f, 0.04404572f, 
    -0.15001453f, 0.02883913f, 0.02305140f, 0.23803255f, 0.07983008f, 0.10528460f, 0.08977968f, 0.10674233f, 
    0.07258338f, 0.16703476f, 0.11790074f, 0.02358941f, -0.32996595f, -0.00756824f, -0.19740731f, -0.37932768f, 
    0.18584181f, -0.12882116f, 0.03411947f, -0.00205150f, -0.09898836f, -0.00576545f, -0.03214699f, -0.07812964f, 
    0.01588588f, 0.14022274f, -0.24117188f, 0.15319447f, 0.02560371f, 0.05852264f, -0.02941243f, 0.13288215f, 
    0.14152892f, -0.08663250f, 0.03590608f, 0.02532862f, 0.17205109f, -0.07003316f, -0.13031933f, 0.13444442f, 
    -0.24265940f, 0.03011864f, 0.11789902f, -0.04272696f, -0.19589789f, 0.05281844f, 0.09389778f, 0.06586182f, 
    -0.02514369f, -0.01883167f, 0.02202887f, -0.07410845f, -0.02098194f, -0.07874243f, -0.01583046f, -0.00610728f, 
    0.00305570f, -0.03504390f, -0.03070877f, -0.07253925f, -0.07188340f, -0.06396426f, 0.04873599f, -0.02713514f, 
    -0.04802434f, 0.00206684f, -0.06413864f, -0.00738769f, -0.04487428f, -0.06235405f, 0.01685033f, -0.03808285f, 
    -0.01362088f, -0.03779685f, 0.06457920f, -0.05953019f, 0.05885509f, -0.00584052f, 0.02833697f, -0.07501934f, 
    -0.06884710f, 0.03684934f, -0.03027665f, -0.06665742f, -0.05332445f, 0.00740893f, 0.05837500f, -0.06176447f, 
    -0.01249548f, 0.05208402f, 0.01763549f, 0.06158105f, -0.04693000f, 0.02472326f, 0.05180668f, -0.07013032f, 
    -0.06022681f, 0.03258338f, -0.02437475f, -0.06752393f, -0.02664958f, -0.01855271f, -0.06659713f, -0.01364885f, 
    0.05958659f, -0.01641389f, 0.06288059f, 0.05091717f, -0.04712718f, -0.03483577f, -0.03715252f, -0.04757921f, 
    -0.07190178f, -0.03876689f, 0.03321749f, -0.02149735f, -0.02379651f, 0.00201932f, -0.04511661f, 0.05275247f, 
    -0.02655858f, -0.02712890f, 0.04015324f, -0.05843052f, 0.05886650f, -0.01829747f, 0.01276896f, 0.05001524f, 
    -0.05098814f, 0.04506449f, -0.05493213f, 0.04543944f, 0.01428470f, -0.06782754f, -0.05625740f, -0.06629635f, 
    0.05252833f, 0.00645168f, -0.05412504f, -0.01389735f, -0.04220284f, 0.04460728f, -0.05308301f, 0.01849918f, 
    0.03283318f, 0.05532723f, 0.06517087f, 0.02523744f, -0.04993682f, 0.01829565f, -0.00374998f, -0.00174401f, 
    -0.05633776f, -0.00560526f, -0.03423220f, 0.03660993f, -0.02629190f, -0.04263718f, 0.06014815f, -0.00756499f, 
    0.06100428f, -0.04972287f, -0.04070045f, 0.05968684f, -0.05130358f, -0.07584722f, -0.06164890f, -0.07528351f, 
    -0.06887516f, -0.01970925f, -0.01598668f, 0.00822723f, -0.02884307f, 0.00846045f, 0.01663403f, -0.01013458f, 
    0.00984521f, -0.06997613f, 0.03639644f, -0.02380069f, 0.03522836f, -0.02706964f, -0.05646536f, -0.03881769f, 
    -0.06465360f, 0.02200422f, -0.00016260f, 0.05345004f, 0.03105363f, 0.01609555f, -0.06490656f, -0.07224800f, 
    -0.06200705f, -0.04140210f, 0.01371727f, 0.05392344f, 0.03001635f, -0.06777215f, -0.02605930f, 0.01894173f, 
    -0.03356636f, -0.08082752f, -0.02654338f, -0.03322345f, 0.05580973f, -0.05293311f, -0.01155270f, -0.00244288f, 
    0.01659002f, 0.01760551f, 0.03589097f, 0.00047269f, 0.01811755f, -0.07929185f, 0.02491522f, 0.03925348f, 
    -0.07760474f, 0.01868392f, -0.06786734f, -0.02496794f, -0.00643765f, 0.01125782f, -0.04080694f, 0.05058032f, 
    -0.05424549f, -0.07639716f, -0.03675226f, 0.00003111f, 0.00581008f, 0.00133380f, -0.03164492f, -0.01591273f, 
    0.06599746f, 0.05856919f, -0.02543856f, -0.03492543f, -0.04435608f, 0.01617787f, 0.06006524f, -0.03092486f, 
    -0.43371341f, -0.44933406f, -0.05184028f, -0.03562846f, -0.07778709f, 0.12427356f, -0.03008138f, -0.11581968f, 
    0.00372049f, 0.19674700f, -0.09258907f, 0.02062628f, 0.26752311f, 0.21296234f, 0.20748347f, 0.17901096f, 
    0.09616922f, 0.10320897f, -0.08743041f, 0.02138335f, -0.00905110f, -0.15009932f, -0.04473765f, 0.22575556f, 
    0.02391914f, 0.01001730f, -0.08455962f, -0.09354728f, 0.03747478f, 0.10899423f, 0.08152952f, 0.01416610f, 
    0.04715789f, 0.09582419f, 0.02516463f, -0.03482196f, -0.18835837f, -0.27293813f, 0.00434663f, 0.00478043f, 
    0.09171005f, 0.16788632f, 0.02414449f, -0.20579790f, 0.01249077f, 0.04852109f, -0.11263249f, 0.02823134f, 
    -0.16960287f, 0.18142971f, -0.20651470f, -0.16577595f, -0.09692693f, 0.12071702f, -0.02331434f, -0.05505030f, 
    0.01659526f, -0.12892835f, 0.05788525f, 0.05241110f, 0.09707561f, 0.10843530f, -0.07098471f, 0.09351169f, 
    -0.08574505f, 0.12486418f, 0.10310637f, 0.06687589f, 0.06499198f, 0.04461718f, 0.00263110f, -0.01628501f, 
    -0.38743591f, -0.40018141f, 0.06548243f, -0.01490072f, 0.03679437f, 0.11348006f, 0.03898006f, -0.06483907f, 
    0.05044936f, 0.05985963f, 0.01946513f, 0.05553623f, 0.35237947f, -0.08762343f, -0.01245684f, 0.24828348f, 
    -0.09878606f, -0.10915902f, -0.10196619f, 0.15857527f, -0.00103825f, 0.01114504f, -0.08679157f, -0.03630327f, 
    0.15221557f, -0.13963880f, 0.02082441f, 0.03015276f, 0.04817211f, 0.09620310f, 0.13575384f, 0.06696875f, 
    0.05645483f, 0.09671213f, 0.02271808f, -0.03273272f, 0.20580824f, 0.03261787f, 0.27665776f, -0.05063986f, 
    -0.15957946f, 0.07265178f, 0.03290001f, 0.02887702f, 0.02506612f, 0.12589860f, 0.12757266f, 0.09256227f, 
    0.09597947f, 0.04697388f, 0.17393127f, 0.04452281f, 0.02142917f, -0.07159358f, 0.10757860f, 0.13632639f, 
    0.06209479f, -0.04735086f, 0.15449248f, 0.11702955f, 0.09138750f, -0.02921441f, 0.07517537f, -0.09848610f, 
    0.06661260f, 0.19904733f, 0.06701819f, -0.06933496f, 0.04068214f, 0.07382743f, 0.12784116f, 0.15405840f, 
    0.19193029f, -0.14047292f, -0.13386452f, 0.08592747f, -0.01217855f, 0.07922321f, -0.02357221f, -0.02291647f, 
    0.13266101f, 0.12531970f, 0.06652344f, -0.04795535f, -0.16903977f, -0.20584145f, -0.16598634f, -0.13228403f, 
    -0.02837761f, -0.07769790f, -0.07158598f, 0.04345851f, 0.06341095f, -0.13608003f, -0.01577407f, 0.02058357f, 
    -0.01269855f, 0.33571476f, -0.19817507f, -0.17235185f, -0.02067638f, -0.08379483f, -0.00890941f, 0.03690509f, 
    0.07576329f, 0.04781697f, 0.01641313f, -0.06806381f, 0.20722529f, -0.05137334f, 0.07898191f, 0.12021098f, 
    -0.03158893f, -0.12968281f, 0.00380015f, 0.13158065f, -0.09584229f, 0.08939605f, 0.16783760f, 0.11988397f, 
    -0.01924208f, 0.04580347f, -0.05236939f, -0.02164604f, -0.05479833f, 0.03699298f, -0.03247917f, -0.05983441f, 
    -0.07215871f, 0.03774679f, 0.02964031f, -0.01763446f, 0.05901206f, 0.03468506f, -0.05265359f, -0.04873083f, 
    -0.02244535f, -0.00074659f, -0.05473750f, 0.01937789f, -0.04039939f, 0.01007879f, 0.05001569f, -0.06186684f, 
    -0.03059901f, 0.04769558f, -0.01648502f, -0.03551872f, -0.05765928f, 0.04324284f, 0.01932312f, -0.03910254f, 
    -0.01671922f, 0.03643799f, -0.07313640f, 0.05095866f, 0.05060710f, -0.02831529f, -0.00975876f, -0.02588321f, 
    0.00080924f, 0.05064123f, 0.01897282f, -0.02832883f, 0.02908805f, 0.02567319f, -0.06454015f, -0.06076910f, 
    -0.05021901f, -0.02679656f, -0.01929415f, 0.05303164f, -0.07894935f, -0.03606994f, 0.04595353f, 0.00420844f, 
    0.00023103f, -0.04542205f, 0.00687133f, 0.02186886f, 0.01742778f, -0.06549235f, -0.08065058f, 0.00524255f, 
    0.04676899f, -0.07466908f, 0.03525776f, 0.04324862f, 0.06046201f, -0.06781577f, -0.02329647f, -0.06982041f, 
    -0.05658529f, -0.04020413f, -0.06989058f, 0.01620932f, 0.01023510f, 0.03292310f, -0.01702062f, 0.06645697f, 
    -0.07243491f, -0.03128970f, -0.04688484f, 0.00030673f, -0.01682394f, 0.03718591f, 0.01700225f, 0.03770629f, 
    -0.01231997f, 0.00266049f, 0.02443705f, -0.06569956f, -0.01262343f, -0.01741917f, 0.00075436f, -0.04074817f, 
    -0.05765831f, -0.06939207f, -0.07266301f, -0.01971357f, -0.02537950f, 0.05025319f, 0.05209346f, 0.05958955f, 
    -0.05782405f, 0.03172677f, -0.04450609f, -0.01196706f, -0.05881180f, 0.05263702f, 0.02269142f, 0.01311782f, 
    0.02273962f, -0.04829556f, -0.04079428f, -0.06692079f, 0.03945428f, -0.07826328f, 0.04767858f, 0.05046126f, 
    0.03973112f, 0.01367851f, -0.03268727f, -0.02779895f, -0.00829596f, 0.05101341f, -0.02639976f, -0.05858429f, 
    -0.06480923f, 0.02670184f, -0.05849623f, -0.06375899f, 0.03493204f, 0.02270042f, 0.04978361f, 0.04194877f, 
    -0.04624938f, 0.00058860f, -0.03227850f, -0.05994773f, -0.03651955f, -0.01922055f, -0.08110747f, -0.05544859f, 
    0.02639472f, 0.04041029f, -0.06656861f, -0.07962709f, -0.04003080f, 0.01549303f, -0.05060726f, 0.00439112f, 
    -0.00079454f, -0.05573504f, -0.05435444f, 0.04442811f, -0.02901757f, 0.01810580f, 0.01308562f, 0.01972238f, 
    0.01144826f, 0.01363217f, 0.01696289f, -0.02165747f, -0.03772408f, 0.05562178f, 0.05112426f, -0.05393391f, 
    -0.01874075f, -0.02174407f, -0.06155065f, 0.03736212f, -0.06043315f, 0.00386133f, 0.04669375f, 0.04314055f, 
    -0.06669439f, -0.07608840f, 0.02462536f, 0.02894531f, -0.00787669f, 0.01113490f, -0.07288817f, 0.01467962f, 
    0.02252019f, -0.00601487f, -0.04300162f, 0.06002351f, 0.01703504f, -0.07505227f, -0.06779472f, 0.05191194f, 
    -0.34461546f, 0.09374612f, 0.02810930f, -0.12355407f, -0.16807382f, -0.19262435f, -0.01574549f, 0.02419589f, 
    -0.09925925f, 0.05974361f, 0.09306321f, 0.03057958f, 0.15547572f, 0.23917623f, 0.37143448f, 0.20242536f, 
    0.06358971f, 0.09271464f, 0.07073040f, 0.04687269f, 0.01456834f, -0.04432404f, -0.06836046f, -0.11768906f, 
    0.29877698f, 0.00764240f, 0.24022926f, 0.02563089f, -0.02036922f, -0.05203621f, -0.09781155f, -0.01510556f, 
    0.02596362f, 0.05904285f, -0.09572442f, -0.07251851f, -0.28052795f, -0.09370863f, 0.12435462f, -0.35439274f, 
    -0.04300378f, 0.06306139f, -0.14020988f, 0.00840823f, -0.15502214f, 0.12855852f, 0.03436663f, -0.05009227f, 
    0.01023945f, -0.00443438f, -0.21092092f, -0.17405653f, -0.15296656f, -0.05496837f, 0.01313505f, -0.05542714f, 
    -0.00406740f, 0.01285363f, -0.03254641f, -0.02119391f, 0.30116758f, 0.27029279f, -0.00829864f, 0.26183102f, 
    0.07521743f, 0.13375111f, 0.07177329f, -0.06088921f, -0.15640335f, -0.20322503f, 0.07747392f, 0.04536851f, 
    -0.20990880f, -0.20076293f, -0.13704799f, -0.07019109f, -0.06863070f, -0.12277170f, 0.01889190f, -0.06177069f, 
    -0.03955196f, -0.01370590f, 0.07564100f, -0.07770623f, 0.11565448f, 0.09583006f, 0.23090574f, -0.12880424f, 
    0.13262530f, 0.25610802f, -0.00234929f, 0.11421692f, -0.09002835f, 0.02386518f, -0.17204374f, 0.03301353f, 
    0.16169338f, 0.24727516f, 0.09337159f, 0.01031755f, 0.07416806f, 0.00860414f, 0.03251870f, -0.15938815f, 
    -0.13404576f, -0.12670614f, -0.00900826f, -0.07675231f, 0.09114934f, 0.17658816f, 0.06924035f, 0.15996498f, 
    0.15569845f, 0.16272238f, 0.00953187f, -0.00362036f, 0.01673317f, 0.07613306f, -0.01448595f, -0.01165244f, 
    -0.04541265f, -0.04799660f, -0.01897122f, 0.03288402f, 0.20258473f, 0.09831172f, 0.14303781f, 0.10966483f, 
    0.14428623f, -0.04539170f, 0.10123739f, -0.04687065f, -0.01995010f, -0.07025828f, 0.02012089f, -0.23572883f, 
    -0.08467389f, 0.05684618f, 0.05373648f, -0.14769109f, -0.01675165f, -0.10972235f, 0.05968288f, 0.21234204f, 
    0.05651282f, -0.22279543f, -0.10219999f, 0.04762671f, -0.13302501f, 0.05229006f, 0.03090031f, -0.09858638f, 
    0.00717856f, -0.13925199f, 0.05458144f, 0.02454742f, -0.06171171f, -0.14542520f, -0.16079412f, -0.31303209f, 
    -0.06286010f, 0.00460090f, 0.00620985f, -0.02014822f, 0.04374308f, 0.02490821f, -0.10603779f, -0.03230807f, 
    -0.19112201f, 0.26671636f, -0.28749794f, 0.12497617f, 0.12371978f, -0.05827174f, -0.01235880f, -0.00340774f, 
    -0.05515694f, 0.12437575f, -0.01914253f, -0.06715605f, 0.18733802f, 0.10652467f, 0.10084927f, 0.16453302f, 
    0.20051831f, 0.18416189f, 0.07865395f, -0.05141804f, 0.01226848f, 0.01614762f, -0.02582751f, 0.04215688f, 
    0.03522668f, -0.03891780f, -0.08432417f, -0.12487988f, 0.05487655f, 0.07745471f, -0.12793379f, 0.01704877f, 
    0.01750778f, 0.00455309f, -0.00750514f, -0.02626832f, 0.07838274f, 0.04921420f, 0.25894213f, 0.07938844f, 
    0.03180722f, 0.04595283f, -0.08848102f, 0.15985513f, -0.07721223f, -0.06576769f, 0.18106934f, -0.04716215f, 
    -0.16471392f, 0.03269965f, 0.23829688f, 0.07732461f, 0.02182619f, -0.12382594f, 0.07942678f, 0.01727154f, 
    0.04526990f, 0.05111406f, 0.05941644f, -0.02670239f, 0.01199423f, -0.09519625f, -0.12942471f, -0.22456193f, 
    -0.04312397f, 0.14502491f, -0.05614141f, -0.07557128f, -0.03850652f, 0.09680337f, -0.03407912f, 0.02470545f, 
    0.02675831f, -0.01383290f, -0.10986030f, 0.07748363f, 0.06357997f, 0.05195894f, -0.04807048f, -0.05144155f, 
    -0.11700010f, -0.06911151f, 0.02962119f, 0.02931858f, 0.13419300f, 0.08989083f, 0.06351490f, -0.05586033f, 
    -0.02618751f, 0.10729297f, 0.09860887f, -0.03894392f, -0.16494785f, -0.00423167f, -0.17995080f, -0.02141919f, 
    -0.13745192f, 0.07603605f, 0.02438796f, -0.14289345f, 0.01461360f, 0.08694813f, 0.08981303f, -0.00507334f, 
    -0.05620205f, 0.15289895f, -0.06562950f, -0.05993490f, -0.23737559f, 0.16548523f, 0.16983868f, 0.09651366f, 
    0.08344434f, 0.00729859f, 0.09059589f, -0.01183326f, 0.04266640f, 0.07623885f, -0.06612998f, 0.07003511f, 
    0.29841721f, 0.28212619f, -0.07688188f, -0.20473300f, 0.04927409f, 0.03801191f, 0.01151249f, 0.02758253f, 
    -0.01482392f, 0.01334724f, 0.15017711f, 0.10612332f, 0.01206579f, 0.02126265f, 0.06746928f, -0.10784324f, 
    -0.18478040f, 0.01952032f, 0.10962612f, -0.06278584f, 0.01587318f, 0.02525577f, 0.03735135f, -0.07678200f, 
    0.25892952f, 0.17029360f, 0.00992379f, -0.09499950f, 0.01638340f, -0.05451465f, 0.08602086f, -0.10857805f, 
    0.00793844f, -0.02734270f, 0.11659090f, -0.13308924f, -0.01092530f, -0.01373005f, 0.08601741f, -0.04133363f, 
    -0.14389108f, 0.11080620f, 0.07837453f, 0.04161551f, 0.08598714f, 0.02496901f, -0.02212740f, 0.03809031f, 
    0.09418346f, -0.13877738f, -0.11280699f, -0.04361856f, -0.07939313f, 0.08547983f, -0.11219375f, -0.15974468f, 
    -0.03959846f, -0.06289072f, 0.03990258f, 0.05182723f, 0.03937536f, -0.05800815f, -0.04246857f, 0.15182680f, 
    0.00694835f, -0.01125006f, 0.07225626f, 0.04398564f, -0.06799195f, 0.00736284f, -0.00015007f, 0.12782373f, 
    0.30405015f, 0.24691816f, 0.11874248f, -0.01077687f, 0.06508347f, -0.02111192f, 0.01090023f, 0.03431854f, 
    -0.02826325f, -0.00728981f, 0.04595790f, -0.00699225f, 0.00135569f, 0.08428491f, 0.25274795f, 0.06162364f, 
    -0.01415202f, -0.03352908f, 0.09653573f, 0.04698803f, 0.01684452f, 0.02429182f, 0.02544356f, 0.06201251f, 
    -0.22430240f, 0.01878326f, 0.25012839f, 0.07982295f, 0.07142313f, -0.04977609f, 0.14858569f, -0.14741005f, 
    -0.02016430f, 0.09066004f, 0.01310627f, 0.07194182f, 0.04009427f, 0.03010715f, -0.23505457f, -0.02514881f, 
    0.08853982f, 0.06981093f, 0.04339150f, -0.03330442f, 0.03669167f, -0.07178673f, -0.05561340f, 0.24564694f, 
    0.31344011f, -0.21926518f, -0.33174017f, -0.12712990f, 0.07276595f, 0.09119400f, 0.01280061f, 0.11638346f, 
    -0.06651016f, 0.03286646f, 0.11739061f, 0.03003775f, 0.31052440f, -0.02960898f, 0.28028896f, 0.04619404f, 
    0.03191256f, 0.12639956f, 0.10091156f, -0.08156420f, 0.02274224f, -0.10722873f, 0.08468042f, 0.07819851f, 
    0.01232711f, 0.35819760f, 0.03148182f, 0.18033676f, 0.19630066f, -0.02553258f, 0.00835313f, -0.15224965f, 
    0.01761150f, 0.01677271f, -0.00782790f, -0.02638888f, -0.36506754f, 0.02239013f, 0.23065156f, -0.01144832f, 
    0.02826066f, 0.02007083f, -0.05018205f, 0.22359703f, 0.10547126f, 0.07840893f, 0.15555839f, 0.07031949f, 
    -0.13286999f, -0.01349528f, 0.13452990f, -0.07830284f, 0.01761916f, 0.18562345f, 0.16347598f, 0.02941211f, 
    0.02250911f, -0.04864391f, 0.07340893f, 0.06270222f, 0.01379282f, -0.01078880f, -0.16656087f, 0.02367851f, 
    -0.09055144f, 0.02419614f, -0.23121746f, 0.08103173f, 0.11270852f, 0.04406250f, 0.01519358f, 0.03433647f, 
    -0.15345506f, -0.40690783f, -0.04237671f, 0.07605867f, 0.05919282f, -0.02915905f, -0.07191686f, 0.07380567f, 
    -0.00593757f, 0.03599357f, 0.02783693f, 0.00909698f, -0.10356148f, 0.12984671f, 0.28701791f, -0.00654144f, 
    -0.07221838f, -0.09374082f, -0.15879142f, 0.18400271f, -0.00909051f, -0.04556965f, 0.04517329f, 0.18779314f, 
    -0.06215873f, -0.17618307f, 0.02621352f, 0.16905336f, -0.12122156f, -0.10756006f, 0.06567014f, 0.00041292f, 
    0.11659030f, 0.01480678f, 0.12388103f, 0.13337204f, 0.47480616f, 0.07971027f, -0.07155008f, 0.24958189f, 
    0.07600489f, 0.07090222f, 0.11299153f, -0.07216027f, 0.13787751f, 0.06668179f, -0.02934537f, 0.06915227f, 
    0.49762630f, -0.00959624f, 0.05948341f, 0.00347514f, -0.01876123f, 0.08358601f, 0.06914588f, -0.07497135f, 
    -0.11837506f, 0.04547588f, -0.01100039f, 0.03223648f, 0.04360705f, -0.00961748f, 0.00623611f, 0.26905987f, 
    0.10825472f, -0.02493072f, -0.04765029f, -0.06465764f, -0.01602497f, 0.09173761f, 0.01814415f, 0.12916282f, 
    -0.24437860f, 0.16947362f, 0.17373320f, -0.37470773f, -0.00643069f, 0.07409320f, 0.03926129f, -0.03495316f, 
    0.07484641f, -0.01135961f, 0.07084811f, -0.02480821f, -0.09697267f, -0.17888391f, 0.02128839f, 0.11507516f, 
    0.16028413f, -0.07334890f, -0.05009848f, 0.07572055f, 0.19304748f, -0.04623716f, -0.12577337f, 0.04097676f, 
    -0.00076373f, -0.13047875f, -0.07345018f, 0.17123419f, 0.02035530f, -0.01143171f, 0.00684768f, -0.06289461f, 
    0.06951154f, 0.01939678f, 0.04832307f, 0.06639084f, 0.00118688f, -0.00686060f, 0.02403410f, -0.06115657f, 
    0.06442451f, -0.15333292f, -0.07824489f, 0.08964331f, -0.01634585f, 0.03399640f, -0.03933560f, -0.05790858f, 
    -0.01748264f, 0.27946427f, 0.05929584f, 0.11945210f, -0.04426870f, 0.07134713f, 0.09715310f, 0.18128388f, 
    0.00124134f, 0.02780521f, 0.16964704f, 0.18442014f, -0.10603435f, -0.17631850f, -0.08723064f, 0.00728415f, 
    0.09074088f, 0.16678402f, 0.02057840f, -0.01134129f, 0.01791430f, 0.06647006f, -0.08797238f, 0.10302822f, 
    -0.33997947f, -0.27411121f, -0.09945001f, -0.22379701f, 0.06342132f, -0.00947792f, 0.14464124f, -0.02017299f, 
    0.08942197f, -0.12740919f, -0.12497914f, 0.03044466f, 0.25326619f, -0.00112630f, -0.07068627f, 0.19238709f, 
    0.10003947f, -0.04183200f, -0.00022044f, -0.17470179f, 0.12375118f, 0.07369331f, 0.01521856f, 0.03774321f, 
    -0.22495966f, -0.14271672f, 0.01169981f, 0.25227794f, 0.13580568f, -0.12285224f, 0.02767457f, -0.03915614f, 
    -0.00348892f, -0.02301309f, 0.08544759f, -0.01323896f, -0.24125355f, -0.03100745f, -0.21944377f, -0.01001975f, 
    0.15740262f, -0.08211196f, 0.13639370f, -0.03280534f, -0.02367126f, -0.03869212f, -0.06691144f, -0.02529459f, 
    0.29936475f, 0.30413610f, 0.04882310f, 0.00550657f, -0.03654776f, 0.24298149f, 0.00450096f, -0.10725284f, 
    -0.12595846f, 0.01797150f, 0.12142421f, -0.00481826f, 0.02480908f, -0.09428328f, 0.03495226f, 0.03837414f, 
    0.07235623f, 0.02427129f, -0.11641736f, 0.06710262f, 0.01782152f, -0.01333322f, 0.10106502f, -0.04529900f, 
    0.14145258f, 0.08240609f, 0.08103571f, -0.08038031f, -0.09722828f, 0.07457940f, -0.01241763f, 0.10224376f, 
    0.09003004f, 0.18660724f, 0.04997747f, 0.06762619f, -0.15353695f, -0.09670410f, -0.03168506f, -0.25038347f, 
    0.02766622f, -0.05028488f, -0.15981536f, 0.15255755f, 0.04857268f, -0.03339756f, 0.07546236f, 0.04218487f, 
    -0.07693944f, -0.08664963f, -0.15318939f, -0.05029909f, -0.01604179f, 0.10053386f, 0.07334532f, -0.01557492f, 
    -0.03501934f, -0.10784498f, -0.03249386f, 0.07738452f, -0.09994295f, -0.10178034f, 0.10137917f, -0.24692824f, 
    0.08559247f, -0.09037628f, 0.04184255f, 0.03629649f, -0.02403608f, -0.02948402f, 0.11638536f, 0.11671766f, 
    0.33250138f, -0.00669037f, -0.05342748f, 0.20161599f, 0.02395222f, -0.01525404f, -0.01735771f, 0.12573749f, 
    0.07889731f, 0.01796806f, -0.04896450f, 0.07372095f, -0.06180703f, -0.02873686f, -0.13695203f, 0.01743257f, 
    -0.04746622f, 0.07782681f, -0.04457228f, -0.13303338f, 0.05980135f, -0.04352732f, 0.05487802f, -0.12602824f, 
    0.04160357f, -0.16779137f, 0.18998802f, 0.11465432f, -0.08046446f, -0.12784266f, 0.01985547f, -0.03580446f, 
    0.06606745f, 0.09700957f, 0.05366052f, 0.13866745f, -0.31563440f, -0.20155770f, -0.17892605f, -0.00485679f, 
    -0.00567806f, 0.06822564f, 0.16176760f, 0.03120452f, 0.06385195f, 0.01930249f, -0.14564236f, -0.01973571f, 
    -0.23072845f, 0.09975047f, -0.09160387f, 0.02903382f, 0.01265636f, 0.07790745f, -0.08187363f, 0.14785834f, 
    -0.01552809f, 0.13756530f, 0.06786866f, 0.14602682f, -0.00071635f, -0.13551979f, 0.04630265f, -0.05616803f, 
    0.05348464f, -0.00235412f, -0.01661603f, -0.15383711f, 0.14378108f, 0.04788132f, 0.01389481f, 0.17660667f, 
    0.38643587f, -0.26613158f, 0.20979655f, 0.32906148f, 0.14052872f, -0.04646615f, -0.03465007f, 0.03877554f, 
    -0.02561257f, 0.00823346f, -0.09665047f, 0.10729423f, -0.15667285f, -0.14748694f, 0.13052717f, 0.12294978f, 
    0.03016591f, 0.09366219f, 0.10454686f, 0.15302084f, -0.02680825f, 0.00376728f, 0.09704583f, 0.00480808f, 
    -0.09967930f, 0.06352691f, 0.06039482f, -0.10725248f, -0.01790308f, -0.03045869f, 0.19483916f, -0.07943839f, 
    0.12205959f, -0.08232503f, 0.09690628f, -0.00920265f, -0.56951106f, 0.21111612f, -0.15138838f, -0.13558561f, 
    0.13916606f, 0.02933092f, -0.03079173f, -0.00330502f, 0.04622917f, 0.01446333f, -0.10948615f, 0.01849825f, 
    0.08497772f, -0.16631548f, -0.15947944f, -0.17993468f, -0.04776047f, -0.02313423f, -0.09662361f, 0.06250261f, 
    0.07540004f, 0.05707572f, 0.03632511f, -0.05647115f, -0.10271707f, -0.06247375f, -0.03924067f, -0.00128124f, 
    0.03763752f, 0.04551020f, 0.01508829f, 0.04492440f, -0.06649541f, 0.10229085f, -0.02685912f, 0.02701261f, 
    0.20855755f, -0.01103691f, -0.06964710f, 0.11899015f, 0.03255041f, 0.04973040f, -0.00601277f, 0.00633866f, 
    0.21000701f, 0.03917895f, 0.01358297f, 0.02652408f, 0.00932623f, 0.05368614f, 0.00209865f, 0.07770094f, 
    0.03383428f, -0.03014370f, -0.11268899f, 0.05114175f, 0.07700390f, 0.04897111f, -0.10263698f, -0.01706136f, 
    0.38229010f, -0.17302951f, -0.09549320f, -0.21016383f, 0.01877045f, 0.08669620f, 0.11444936f, 0.05269466f, 
    -0.09011662f, -0.00686505f, -0.04443054f, -0.10973216f, 0.45781773f, -0.06426152f, 0.01695460f, 0.53682226f, 
    -0.04083485f, -0.05070698f, -0.03701504f, -0.10525593f, 0.01942044f, 0.04432430f, 0.12532076f, 0.09325711f, 
    0.11307160f, -0.01742550f, 0.08474302f, -0.15165983f, 0.00523594f, -0.15880558f, 0.04687515f, -0.08237906f, 
    0.02332416f, -0.08097222f, 0.10453954f, 0.12666182f, -0.21326216f, 0.03236907f, 0.06559766f, 0.19670446f, 
    0.13995561f, -0.12047897f, -0.03787231f, 0.07228514f, 0.19688514f, -0.10777320f, -0.06511079f, -0.18463744f, 
    -0.07686444f, -0.13618243f, -0.10022871f, 0.14582559f, -0.06401231f, 0.05319366f, -0.09873613f, 0.00009751f, 
    -0.07342007f, -0.03860341f, 0.10276745f, -0.00446410f, 0.08587449f, 0.13894191f, 0.02956582f, 0.05464805f, 
    0.05703703f, 0.03872247f, 0.18200292f, 0.22430290f, 0.02599765f, 0.02603118f, 0.00627355f, 0.00179083f, 
    -0.02460140f, -0.04788865f, 0.17299053f, 0.10203350f, 0.08220140f, -0.03954554f, 0.09078297f, 0.11700115f, 
    0.02325872f, -0.03693918f, 0.17462559f, 0.13695066f, -0.09997349f, -0.08551924f, -0.08151047f, 0.04527120f, 
    -0.01013715f, 0.13045909f, 0.05328593f, -0.13049024f, 0.10337954f, 0.03321312f, -0.11854702f, 0.01612049f, 
    -0.22500379f, -0.01140532f, -0.04654025f, -0.04350447f, 0.04346845f, -0.01875414f, 0.06245920f, 0.01323836f, 
    0.16568023f, -0.02924190f, -0.06007921f, -0.04879197f, 0.28309622f, 0.02859361f, -0.10514016f, 0.15623239f, 
    0.05167601f, -0.05521555f, -0.04042570f, 0.10287410f, 0.05858682f, 0.07099987f, 0.09199239f, 0.08044332f, 
    -0.22731128f, -0.17221878f, -0.02086581f, 0.15522011f, 0.05025325f, -0.05606765f, 0.05529120f, -0.00822312f, 
    0.00867939f, -0.01229836f, 0.06633586f, 0.02978877f, -0.44489875f, -0.01771905f, -0.12633796f, -0.10422796f, 
    0.12144870f, -0.04533456f, 0.08134245f, 0.09284717f, 0.00011372f, 0.03839838f, 0.00252151f, 0.00853309f, 
    0.27040255f, 0.15385054f, 0.04857000f, 0.15567328f, -0.00129545f, 0.11853079f, -0.01891563f, -0.07173582f, 
    -0.11954070f, 0.05009082f, 0.09073175f, -0.05491540f, -0.11982974f, 0.05564543f, -0.00810160f, 0.14911123f, 
    -0.03111486f, 0.13701782f, -0.08165088f, -0.03474780f, 0.14705141f, 0.03501000f, -0.05591974f, 0.07108661f, 
    -0.02690858f, 0.04662631f, -0.05690297f, -0.06288298f, 0.04617892f, 0.00891226f, 0.03285081f, -0.07238574f, 
    0.16776817f, 0.06913172f, 0.05591835f, -0.00307549f, -0.00715557f, 0.02041542f, 0.17308003f, -0.08988028f, 
    -0.04273449f, -0.06572868f, -0.22853510f, 0.12170230f, -0.00456909f, 0.10280021f, 0.08398266f, 0.10376219f, 
    0.02459374f, -0.15282221f, 0.01186834f, -0.07598269f, -0.07425781f, 0.03523234f, -0.12916853f, -0.10135324f, 
    0.06380955f, -0.04245782f, -0.05878592f, 0.03187856f, -0.12953302f, 0.04703595f, 0.25751477f, -0.20352462f, 
    0.02464000f, -0.04882758f, 0.02472813f, -0.09822989f, 0.00643906f, 0.10257561f, 0.05130807f, 0.09871119f, 
    0.16696289f, 0.03520234f, 0.05779510f, 0.17328201f, -0.01225571f, 0.04267392f, -0.01575565f, 0.04209828f, 
    0.03655868f, -0.00284884f, -0.00850650f, -0.07185815f, -0.10029095f, 0.07645863f, -0.04320966f, 0.05605080f, 
    -0.07949612f, 0.08489197f, -0.05409234f, 0.02173900f, -0.02390040f, 0.08324000f, 0.01584418f, -0.03258280f, 
    0.00027994f, -0.06939970f, 0.04061390f, -0.10569391f, 0.05059800f, -0.08639102f, -0.06950428f, -0.05932533f, 
    -0.08497602f, -0.02631980f, 0.03487427f, -0.09657712f, -0.05162594f, 0.02734880f, 0.01545261f, 0.01825571f, 
    0.00841052f, 0.01743665f, -0.00645251f, -0.06326584f, -0.09350345f, -0.06580263f, -0.06962276f, 0.04446629f, 
    -0.08511502f, -0.11109099f, -0.01151434f, -0.04095873f, 0.01395668f, -0.04948961f, -0.03760603f, 0.00404536f, 
    -0.08452772f, 0.04775788f, -0.08642939f, 0.01818288f, -0.08635157f, -0.04115224f, -0.09262493f, -0.07983412f, 
    0.01793724f, 0.00554724f, 0.04325830f, -0.10263591f, 0.00984015f, -0.03721609f, -0.02800884f, -0.10033029f, 
    -0.06497925f, -0.02733476f, -0.09957755f, -0.09650482f, 0.05414629f, -0.00491634f, -0.00892593f, -0.00920003f, 
    -0.05192480f, -0.03399491f, 0.04650963f, -0.09317808f, -0.07212521f, 0.06247511f, -0.02031452f, -0.04088436f, 
    -0.01586692f, 0.03116737f, -0.07722086f, 0.00913751f, 0.01488886f, -0.02166345f, -0.02757608f, 0.08098269f, 
    -0.04113325f, 0.03432017f, 0.00471567f, -0.03443345f, 0.01681773f, 0.04455306f, 0.03909688f, -0.09643660f, 
    -0.01425560f, -0.09356259f, 0.00669526f, 0.00201868f, -0.02066960f, 0.00866473f, 0.07817956f, 0.02664631f, 
    -0.06309852f, -0.07399741f, -0.08163743f, 0.04198551f, 0.02092603f, 0.05470289f, -0.05417031f, 0.02912400f, 
    -0.01622537f, -0.07113978f, -0.04464708f, -0.01853010f, -0.01332174f, 0.06065648f, 0.05761060f, -0.04425706f, 
    -0.06767680f, 0.00040887f, -0.01336102f, 0.02191660f, -0.02516940f, 0.07788472f, 0.03674749f, -0.04566571f, 
    0.03486277f, -0.06401884f, -0.06133256f, -0.08646845f, -0.04083718f, -0.09542774f, 0.03934948f, 0.02092638f, 
    0.01359341f, 0.00699885f, -0.01046609f, -0.00186881f, -0.07180963f, -0.02108245f, 0.04521420f, -0.02429732f, 
    -0.01021586f, -0.07718354f, -0.06217902f, -0.06840500f, -0.04529821f, 0.01995463f, 0.00651314f, -0.08147109f, 
    -0.07159790f, -0.04118736f, -0.07193083f, -0.09141033f, -0.03557339f, -0.04908699f, -0.04596705f, -0.02148453f, 
    -0.06484321f, -0.05816914f, -0.07461968f, 0.02880384f, 0.02016330f, 0.00971436f, -0.05260343f, -0.05009558f, 
    -0.03804572f, -0.02445378f, -0.07275297f, -0.04549101f, 0.01297157f, -0.07428842f, -0.08689971f, -0.00362477f, 
    0.05996438f, 0.02416971f, 0.00149555f, -0.02140125f, -0.02095804f, -0.01784556f, -0.01458390f, 0.03844403f, 
    -0.06012312f, -0.01297646f, 0.04499069f, -0.02398284f, -0.01811261f, 0.01030220f, -0.02955488f, -0.00150484f, 
    0.02825942f, -0.04462605f, 0.00324670f, -0.09814829f, 0.05569470f, 0.10200918f, 0.05838739f, -0.04594805f, 
    -0.01841287f, -0.04899484f, 0.00656928f, -0.04696862f, -0.02576488f, -0.05431145f, 0.01166079f, -0.07318548f, 
    0.05379940f, 0.06068330f, 0.00325967f, -0.03704614f, -0.00141836f, -0.03027338f, 0.05130068f, 0.00341828f, 
    0.05406684f, -0.00781778f, -0.06719989f, -0.01264888f, -0.07358319f, -0.05416689f, -0.06981576f, 0.04174334f, 
    -0.06510050f, 0.03615987f, 0.00458632f, 0.05566969f, -0.00715443f, 0.03280228f, 0.02795078f, 0.01306091f, 
    0.01492707f, -0.06281789f, 0.04132967f, -0.03912266f, -0.07465865f, 0.01782005f, 0.00304698f, -0.05830921f, 
    0.04271908f, -0.03805766f, -0.00880063f, -0.05496853f, 0.04529049f, 0.05977514f, -0.01002384f, -0.03544816f, 
    0.02643695f, -0.02217974f, -0.01385082f, 0.02289017f, 0.05910778f, 0.02814692f, 0.05563370f, -0.05586341f, 
    -0.01281394f, 0.04581060f, 0.03374398f, 0.04495885f, -0.02427179f, 0.02598256f, 0.00223327f, 0.00942654f, 
    -0.01573983f, -0.03652452f, 0.02390995f, -0.03591012f, 0.06874918f, -0.02933446f, 0.00713780f, -0.01604827f, 
    0.02642495f, 0.03269205f, -0.02683932f, -0.04380075f, -0.03830366f, 0.05145796f, -0.05780963f, -0.06321638f, 
    -0.02930340f, -0.06428285f, 0.01367161f, 0.02686520f, 0.06096433f, 0.04088884f, 0.01357327f, 0.04069458f, 
    -0.07173608f, -0.01920654f, 0.04738444f, -0.02816461f, -0.06201259f, -0.00127699f, -0.07899656f, -0.02899014f, 
    0.01974188f, -0.02644928f, -0.06210880f, -0.03657551f, 0.06806116f, 0.02885877f, -0.01171658f, -0.01208121f, 
    -0.00662098f, -0.06441730f, -0.04243303f, -0.00684372f, 0.06426439f, -0.06251842f, -0.03169410f, 0.03916911f, 
    -0.05264257f, -0.04497399f, -0.07414988f, -0.02939421f, 0.00674232f, 0.04583229f, -0.01595530f, 0.01614504f, 
    0.07585831f, -0.03872033f, 0.00540437f, 0.04244471f, 0.03119898f, -0.02711873f, -0.02104167f, -0.05360006f, 
    0.06688851f, 0.01356625f, -0.04327502f, 0.00302794f, -0.04006618f, -0.01889114f, -0.04287787f, 0.01145531f, 
    -0.05102517f, 0.01570336f, -0.05346661f, -0.03023730f, -0.00259109f, -0.01334117f, -0.06981607f, 0.01506508f, 
    -0.05808866f, 0.03408894f, -0.05441818f, 0.01463606f, 0.01166473f, -0.03749801f, -0.03557122f, -0.02556902f, 
    0.03953383f, -0.06961901f, -0.06506147f, -0.03615348f, -0.03010523f, -0.05167960f, -0.06261297f, 0.02302573f, 
    -0.03549116f, -0.04728515f, 0.01731418f, 0.01817325f, -0.02942206f, 0.04110623f, -0.04108052f, 0.01277136f, 
    0.03148820f, 0.04697338f, -0.06617973f, -0.00465569f, -0.06931690f, 0.03416241f, 0.06448973f, -0.05775452f, 
    -0.06394359f, -0.03992955f, 0.02552757f, -0.04237631f, -0.07507057f, 0.02766159f, 0.02700342f, 0.00077588f, 
    -0.01256556f, 0.03281230f, 0.05748424f, 0.03775092f, -0.01495409f, -0.01741602f, -0.02983951f, -0.00159350f, 
    -0.03813715f, 0.04103742f, 0.00176637f, 0.00413660f, -0.02467998f, 0.00983379f, -0.01772755f, -0.01804399f, 
    -0.04505647f, -0.01525508f, 0.00147318f, 0.14379738f, 0.03659974f, 0.11127368f, -0.05188113f, -0.01465495f, 
    0.01227769f, -0.05058799f, -0.06541072f, -0.04001709f, 0.13476133f, -0.01773119f, 0.27145422f, -0.21697599f, 
    0.05586861f, 0.09433647f, -0.18564129f, 0.03887042f, -0.09553476f, 0.15208927f, 0.18200082f, 0.03295771f, 
    0.14742434f, 0.02925246f, 0.11641084f, 0.17357053f, 0.00502313f, 0.05813525f, 0.06455670f, 0.11177213f, 
    0.05723770f, -0.07611953f, -0.01987505f, -0.07470842f, -0.11230019f, 0.05971857f, 0.06593735f, -0.00496513f, 
    0.08789185f, 0.12501676f, -0.05103843f, 0.06186997f, 0.09570111f, 0.09010136f, -0.05555735f, -0.11472787f, 
    -0.17658424f, 0.20236616f, -0.21495482f, -0.21166240f, 0.13008317f, 0.00616876f, -0.00464973f, 0.07905970f, 
    0.10583653f, -0.05349157f, 0.06518670f, 0.03774149f, 0.18893062f, -0.06203057f, -0.21759465f, 0.25115666f, 
    0.00031995f, 0.05325652f, 0.03853578f, 0.03947302f, 0.08517384f, 0.09833683f, -0.06564377f, 0.06265730f, 
    -0.08708920f, -0.07808352f, 0.12692592f, 0.12134030f, -0.03894885f, -0.02134460f, -0.02071607f, 0.01949793f, 
    0.14253955f, 0.10934049f, -0.12875712f, 0.07260741f, 0.00532061f, -0.07533119f, -0.10852468f, 0.01099292f, 
    0.07652457f, -0.10645936f, 0.09433549f, 0.12198743f, 0.09297793f, 0.04044609f, 0.14453407f, 0.02206537f, 
    -0.04721125f, 0.24994597f, 0.07103892f, 0.14984497f, -0.05744969f, 0.12685993f, 0.03805676f, -0.09677397f, 
    0.04418052f, 0.13891576f, -0.11782304f, -0.01918129f, 0.01864371f, -0.16250835f, -0.01015409f, 0.17732477f, 
    0.07017368f, -0.04709669f, -0.03213077f, -0.06446584f, 0.00146686f, -0.09723149f, -0.00167592f, -0.15786406f, 
    0.14604381f, -0.05617258f, 0.03068024f, -0.08793127f, 0.10391161f, 0.00209786f, -0.01896739f, 0.04451654f, 
    -0.13433467f, -0.08103915f, 0.00759730f, -0.10990587f, -0.20774734f, -0.00904449f, 0.06570783f, -0.09952966f, 
    -0.08395012f, 0.19221234f, 0.07443017f, 0.15947214f, -0.03171701f, 0.13935645f, 0.06815366f, 0.14526576f, 
    -0.20898621f, 0.01170676f, -0.02337438f, 0.06940553f, 0.03203254f, 0.06352587f, 0.05522254f, -0.03297389f, 
    0.13872117f, 0.06347402f, 0.15708955f, 0.12759210f, -0.09471980f, 0.14883469f, -0.02273548f, -0.51185858f, 
    0.06217412f, -0.02795199f, 0.02220592f, 0.02259786f, 0.00942312f, 0.11889903f, -0.09483696f, -0.01018196f, 
    0.29538542f, -0.10759021f, -0.20624717f, 0.21646084f, -0.06287292f, 0.03369561f, 0.04242694f, 0.05667194f, 
    -0.02724542f, 0.03860104f, -0.05871417f, -0.00388422f, 0.02464173f, -0.09686553f, -0.14805469f, 0.20176144f, 
    -0.16104907f, 0.05269530f, 0.11458368f, 0.03593344f, -0.05274465f, 0.06105866f, 0.13740997f, 0.10071268f, 
    -0.07476864f, 0.07970052f, 0.25970897f, 0.06654907f, 0.04058001f, 0.05777070f, 0.19476599f, -0.15051736f, 
    0.05036845f, -0.02934722f, -0.06911189f, -0.13358530f, 0.10236361f, -0.00613371f, -0.06824823f, -0.18057734f, 
    -0.07982574f, 0.13327163f, -0.25229388f, -0.16563648f, -0.13053370f, 0.01115057f, 0.08403851f, 0.09587792f, 
    0.38394308f, -0.15158693f, -0.13571587f, -0.11995708f, -0.03037203f, 0.04210905f, 0.01480266f, -0.10930176f, 
    0.05674981f, 0.04924269f, -0.05266663f, -0.05527658f, -0.03125898f, 0.11761878f, 0.31993887f, 0.13548563f, 
    0.07438125f, 0.06967110f, -0.05995271f, 0.03660653f, 0.10252374f, 0.03829015f, 0.04436349f, -0.12780684f, 
    -0.08363758f, 0.31313637f, -0.00579151f, -0.12378503f, 0.00585428f, -0.05497921f, 0.08191966f, 0.03587975f, 
    0.07809775f, -0.00828755f, 0.07428637f, 0.06612178f, -0.24119508f, 0.01493998f, -0.02159419f, 0.02538730f, 
    -0.03331097f, 0.04563781f, -0.02589034f, 0.10264193f, 0.07351633f, 0.07713181f, 0.00806581f, 0.05030275f, 
    -0.03667615f, 0.07781997f, 0.29542115f, 0.05438894f, 0.07713631f, 0.12026505f, -0.03056994f, 0.01462547f, 
    -0.00147900f, 0.07065863f, -0.00726675f, 0.02368766f, 0.35749841f, -0.24131048f, -0.12006784f, 0.15150656f, 
    -0.06043243f, -0.05851154f, -0.06075751f, 0.07939408f, 0.06531176f, -0.00069156f, 0.19924331f, 0.03591295f, 
    -0.31217343f, -0.30972567f, 0.09012332f, 0.22804110f, 0.08563358f, 0.00913138f, 0.12110463f, 0.08676445f, 
    0.06076758f, -0.01177226f, -0.17859912f, 0.08337737f, -0.11875657f, -0.03984001f, 0.09206786f, 0.05551018f, 
    -0.01170319f, -0.05367162f, 0.08360723f, 0.05839938f, -0.02245294f, -0.05770229f, -0.04183963f, -0.00808626f, 
    -0.01002628f, -0.21576235f, 0.15914069f, 0.10507261f, 0.04471333f, 0.06972100f, -0.01314365f, 0.07312575f, 
    -0.16816741f, -0.05974245f, 0.07187075f, -0.10197364f, 0.12766457f, 0.00105619f, 0.10013581f, 0.21206957f, 
    0.09655569f, 0.10287814f, 0.17435007f, -0.06109032f, -0.07575969f, -0.00737129f, 0.16595191f, 0.05464647f, 
    0.00719388f, 0.09101582f, 0.06102950f, 0.18364394f, 0.00190934f, 0.01166650f, -0.05099511f, 0.16686293f, 
    0.03867131f, 0.18768781f, 0.18340643f, 0.07229945f, 0.08397714f, 0.23755446f, -0.05010836f, -0.32357168f, 
    0.08563607f, -0.00743946f, 0.00558882f, 0.13377987f, 0.05094383f, 0.16101080f, 0.02096494f, -0.03057321f, 
    -0.12958725f, -0.00265243f, -0.08281475f, -0.23763709f, -0.08454943f, 0.03725153f, 0.01389140f, 0.02885597f, 
    -0.01735524f, 0.06270402f, -0.05237478f, -0.00669536f, -0.09426458f, -0.31623605f, -0.19048743f, 0.09013435f, 
    0.00712311f, -0.06693248f, 0.08694275f, 0.06868687f, -0.10314801f, 0.01334341f, 0.01497959f, 0.30627328f, 
    -0.00125317f, -0.01221330f, 0.00068265f, -0.06876554f, -0.02948582f, -0.06726918f, 0.03084256f, -0.05203676f, 
    -0.06476299f, 0.01595442f, -0.03892837f, 0.00664620f, 0.03425745f, -0.06177304f, -0.04106968f, 0.03352582f, 
    0.03570227f, -0.06999311f, 0.05651476f, -0.00959384f, -0.06496199f, 0.01844801f, 0.00370134f, 0.05805172f, 
    0.02988528f, 0.01341235f, -0.08486463f, -0.03503300f, -0.02775946f, -0.07099364f, -0.01474260f, 0.02862744f, 
    -0.05050403f, -0.00879708f, -0.08165972f, -0.06380578f, -0.03485665f, -0.04313928f, -0.06782543f, -0.07109510f, 
    0.01595364f, 0.03935396f, -0.03789821f, -0.03000592f, -0.07496026f, -0.05670690f, -0.08512874f, -0.00954618f, 
    0.02946568f, 0.00067812f, -0.00706450f, 0.03276606f, -0.07675941f, 0.03522269f, 0.01650857f, -0.03097647f, 
    -0.05994111f, 0.02820934f, -0.00222879f, 0.00686219f, 0.01690972f, -0.05934451f, -0.05193025f, -0.07198630f, 
    0.04093776f, 0.01243674f, -0.07840332f, 0.04033370f, 0.02473785f, -0.08310619f, -0.01181124f, -0.07690666f, 
    -0.03730623f, -0.02243567f, -0.04603846f, -0.03183486f, -0.02867723f, 0.02619835f, -0.01583159f, -0.04856155f, 
    0.02637746f, 0.03594236f, -0.02368395f, -0.02021690f, -0.06091337f, 0.05401421f, -0.01655683f, -0.00368765f, 
    -0.06052377f, 0.01068379f, -0.05032998f, -0.07540501f, -0.05449491f, 0.03712338f, -0.01996703f, -0.03980171f, 
    -0.01821010f, 0.02243824f, 0.03011241f, -0.03499326f, 0.01227974f, -0.07398902f, -0.02988979f, 0.01310436f, 
    -0.00406042f, -0.04937349f, 0.03777588f, 0.03581936f, -0.02017528f, 0.04069616f, -0.07449859f, 0.01338396f, 
    0.01157776f, -0.02815875f, -0.08295708f, 0.02619080f, 0.01579252f, -0.04805963f, -0.04728262f, -0.06187151f, 
    0.03613275f, -0.04137612f, 0.02310635f, -0.01920132f, 0.00558251f, 0.00599409f, -0.05702937f, -0.04739394f, 
    0.01570950f, -0.00739350f, -0.08190434f, -0.01213107f, -0.04033297f, -0.03090551f, 0.02076427f, 0.03496817f, 
    -0.00347416f, -0.02029706f, -0.06925935f, -0.02808109f, 0.04691843f, -0.06357239f, -0.05408947f, -0.02849056f, 
    -0.04549398f, 0.02671256f, -0.01502235f, 0.03373288f, 0.05034979f, -0.00399182f, 0.03467464f, -0.03404599f, 
    0.02139185f, -0.07460438f, 0.00638990f, -0.05551924f, 0.04297058f, -0.01619392f, -0.04501229f, 0.03289177f, 
    0.02513855f, 0.02366445f, 0.03459186f, -0.03255622f, -0.03187052f, -0.01424285f, 0.03765138f, -0.03738352f, 
    -0.06545670f, -0.02766718f, -0.04749440f, -0.01113687f, -0.00345532f, -0.07786851f, 0.01811691f, -0.08433551f, 
    -0.02559521f, -0.05747663f, -0.01479544f, -0.00097728f, -0.03143040f, 0.02778538f, -0.06722648f, -0.05192544f, 
    -0.05493536f, -0.06159435f, -0.03381975f, -0.00221608f, -0.06682522f, 0.05163244f, -0.04428909f, -0.01780655f, 
    0.18709779f, 0.33208123f, -0.10695605f, 0.16960773f, -0.04193458f, 0.16793624f, -0.01829115f, -0.02870119f, 
    -0.03886894f, -0.14618513f, 0.05824625f, 0.02151787f, -0.02459819f, -0.02893874f, 0.04305228f, -0.29461956f, 
    0.03664264f, 0.02634513f, 0.10146693f, 0.06096119f, -0.01739478f, 0.17248493f, 0.11648325f, -0.03835437f, 
    0.03624972f, -0.07519154f, 0.16482383f, 0.17918289f, 0.02370969f, 0.00358506f, 0.11135072f, 0.05908056f, 
    0.00731732f, -0.09290358f, 0.08256453f, -0.06165167f, 0.12731506f, 0.05203897f, -0.10366803f, 0.19178207f, 
    0.00827411f, 0.08821260f, -0.06858323f, 0.08614771f, 0.10929978f, 0.00308133f, -0.03655478f, 0.02760268f, 
    -0.18566898f, 0.11579933f, 0.04094139f, -0.05477846f, 0.05174281f, -0.08394992f, 0.07265813f, -0.00867630f, 
    0.18430039f, 0.13004078f, 0.14250657f, 0.05093166f, 0.05675036f, -0.06871797f, -0.09402449f, 0.13119999f, 
    0.06475157f, -0.00206474f, -0.01061503f, 0.10594248f, 0.09421298f, 0.07748702f, -0.02612573f, 0.06515008f, 
    0.27843931f, 0.13041398f, 0.01761925f, 0.32904017f, 0.08308478f, 0.02659995f, -0.06729443f, 0.01244598f, 
    0.00385078f, 0.01962035f, -0.05774625f, -0.04410082f, -0.48959902f, -0.03382616f, -0.05282193f, -0.22292656f, 
    0.09857564f, -0.00173850f, 0.15365554f, -0.00262800f, 0.01058459f, 0.01443102f, 0.06276130f, 0.12716302f, 
    0.08834195f, 0.24601318f, 0.19280204f, 0.14095350f, 0.07685862f, 0.09877855f, 0.08286054f, -0.00265362f, 
    -0.01095863f, 0.05317005f, 0.02576588f, 0.01189450f, -0.16845143f, 0.07632861f, -0.17362083f, 0.21175635f, 
    0.13439637f, -0.01368288f, -0.13650297f, -0.01207084f, 0.10213601f, -0.00418626f, -0.13054761f, -0.14266090f, 
    -0.00634806f, -0.09393342f, -0.00906753f, -0.00869935f, 0.01451382f, -0.04254575f, 0.00953472f, -0.08983595f, 
    0.04790463f, -0.09571204f, -0.06378780f, -0.03507375f, 0.01477920f, 0.03419149f, 0.11381232f, -0.00296702f, 
    0.02166251f, -0.02103540f, -0.17087774f, 0.18914661f, 0.03537364f, 0.05170768f, 0.11060213f, 0.12835836f, 
    -0.19734430f, -0.05533798f, 0.01067967f, -0.01172872f, -0.00206465f, -0.00605632f, -0.07621399f, 0.00360730f, 
    -0.03600767f, 0.03973890f, -0.06458841f, 0.18211731f, -0.09247676f, 0.23155317f, 0.19246295f, -0.27677912f, 
    0.16361099f, -0.02076947f, 0.03135791f, -0.16275957f, -0.05840668f, 0.08350646f, 0.01831860f, 0.05913069f, 
    0.25098482f, -0.18373655f, 0.02866852f, 0.20506018f, -0.07585871f, 0.03194432f, -0.06751134f, 0.00816848f, 
    -0.04312221f, -0.02156334f, 0.01957397f, 0.11263739f, -0.28596389f, -0.01197297f, -0.15300250f, -0.03408317f, 
    -0.03893584f, 0.09517276f, 0.06919447f, -0.11166461f, 0.11836607f, -0.04954034f, 0.00513373f, 0.06007392f, 
    -0.00415174f, 0.01863160f, 0.03274645f, -0.05338506f, 0.01567636f, 0.02962376f, -0.02544047f, -0.04741589f, 
    0.03333944f, -0.06136380f, 0.03059936f, -0.05219869f, -0.04125331f, 0.02963620f, 0.02816139f, 0.04205610f, 
    -0.05397448f, -0.00157105f, -0.01945384f, -0.02192449f, -0.02625296f, 0.05603097f, 0.00981393f, 0.00186272f, 
    -0.03475818f, 0.01038499f, -0.01505237f, -0.05798717f, -0.04036714f, -0.06307244f, -0.08004182f, 0.05557950f, 
    -0.04480912f, 0.02305007f, 0.03351567f, -0.04060228f, 0.04893469f, -0.03321175f, -0.02603879f, 0.03945789f, 
    -0.01117981f, -0.01185688f, -0.05552110f, 0.01681883f, -0.01741514f, -0.06207345f, 0.04165389f, 0.00597910f, 
    -0.03266130f, 0.03919936f, -0.01857955f, 0.00658276f, -0.07525109f, -0.04922692f, -0.04576139f, -0.01353309f, 
    0.05600985f, 0.00951197f, -0.03915100f, 0.00673742f, 0.01191902f, -0.05185537f, -0.06500368f, 0.01810543f, 
    -0.02431900f, -0.06253615f, 0.00036708f, -0.02809479f, 0.01602096f, -0.06500863f, -0.00989041f, 0.01882876f, 
    -0.06188267f, -0.02849447f, -0.07596516f, 0.05161702f, 0.02865943f, 0.01873419f, -0.02417841f, 0.01627577f, 
    -0.06312899f, 0.02367843f, -0.05560410f, -0.04961244f, -0.05117136f, -0.05345103f, 0.06041311f, 0.04200782f, 
    0.03851714f, 0.05419954f, 0.04135745f, 0.03916842f, -0.05593544f, -0.02200308f, -0.00200648f, 0.00962452f, 
    -0.06526116f, -0.04958199f, -0.03136342f, -0.02260052f, 0.05480357f, 0.00129606f, 0.02861406f, -0.05165550f, 
    -0.05559995f, -0.00665325f, -0.01973991f, 0.03760631f, 0.04907071f, -0.06530681f, -0.02645629f, -0.05375658f, 
    0.03675419f, -0.05496789f, -0.02874244f, -0.04694206f, -0.01435078f, 0.01484424f, -0.03312477f, 0.01789324f, 
    -0.06796627f, 0.00068498f, 0.06080912f, -0.00872378f, 0.02457406f, 0.05750949f, 0.02137205f, 0.05483154f, 
    -0.07668505f, -0.03686062f, 0.04579869f, -0.07911181f, -0.03450821f, 0.01465412f, 0.05413683f, 0.05564891f, 
    0.06328940f, -0.04009521f, -0.03953896f, 0.02387691f, 0.04075722f, 0.01723156f, 0.00444389f, 0.00956326f, 
    -0.01516887f, 0.03880258f, -0.04316572f, 0.00460654f, 0.04767684f, 0.02176372f, -0.06183691f, 0.03868879f, 
    -0.01547207f, -0.07264320f, -0.03872207f, 0.00868579f, -0.04101487f, 0.03199684f, 0.05370731f, -0.06917584f, 
    0.05525920f, 0.00979102f, 0.05643740f, 0.05692611f, -0.01589980f, -0.01699980f, 0.01012700f, -0.06730079f, 
    -0.05748696f, -0.00309554f, 0.03859046f, -0.03290628f, -0.05779074f, 0.03382989f, 0.01427586f, -0.03977865f, 
    -0.01334214f, 0.03506966f, -0.06264091f, -0.01073972f, 0.00417858f, -0.05044825f, 0.01168261f, 0.02033115f, 
    0.01304201f, 0.04356835f, 0.04995254f, -0.00733516f, -0.04991012f, -0.01805093f, -0.01328931f, 0.05448941f, 
    -0.01652496f, 0.00811089f, -0.04270467f, -0.01573454f, -0.06710097f, -0.07453119f, 0.01369877f, -0.02314410f, 
    -0.01920564f, 0.03813669f, -0.02083885f, 0.06067678f, 0.03340368f, 0.06136812f, 0.04472900f, 0.01912070f, 
    -0.02799661f, -0.03013837f, -0.06773553f, 0.02287226f, -0.04523097f, -0.03033994f, -0.06580660f, 0.03755249f, 
    -0.01515317f, -0.06026839f, -0.04978612f, 0.04590397f, -0.07671946f, 0.05340052f, -0.01704072f, 0.05179494f, 
    -0.07205360f, 0.00110080f, 0.00864710f, 0.04337961f, -0.06670009f, -0.03410206f, 0.02003168f, 0.04982068f, 
    0.04912786f, 0.02344426f, -0.02957058f, -0.07911520f, -0.04067148f, -0.01157283f, 0.00651224f, -0.07513092f, 
    0.02604396f, -0.00871635f, 0.04951534f, 0.01703551f, -0.07183851f, -0.02378883f, -0.06440923f, 0.02731974f, 
    -0.05017307f, -0.05722272f, -0.07090548f, 0.02624111f, -0.02739548f, -0.06478041f, 0.02876483f, -0.08338696f, 
    0.00928681f, 0.02977216f, -0.01741091f, 0.04282711f, 0.03439034f, -0.05129689f, 0.04543512f, 0.04300350f, 
    -0.07327642f, 0.07128303f, -0.07913821f, 0.00824382f, -0.05357805f, -0.02192134f, -0.02734156f, -0.03150504f, 
    -0.07359623f, 0.05529768f, 0.00272179f, -0.02063242f, -0.06206219f, -0.07276992f, -0.05371026f, -0.06082004f, 
    0.06337538f, -0.02821330f, -0.04705597f, -0.03323764f, -0.00088065f, 0.05607027f, 0.04956018f, -0.06011978f, 
    0.03760715f, -0.04227683f, -0.04340761f, -0.01428621f, -0.04739500f, 0.03555236f, 0.02873820f, -0.02907345f, 
    -0.06715913f, -0.01210246f, -0.00216924f, 0.05674756f, -0.05486489f, -0.03814203f, 0.00080385f, -0.01237028f, 
    -0.07948585f, 0.01161240f, -0.03446933f, 0.05857243f, 0.02142999f, -0.07090482f, -0.06137570f, -0.03795152f, 
    0.01337802f, -0.07199658f, 0.04126656f, 0.05613315f, 0.03770268f, 0.01536540f, 0.03042016f, 0.02145913f, 
    0.02294508f, 0.00730597f, -0.04369966f, -0.06123722f, 0.06224537f, -0.04041221f, -0.00641975f, -0.04460490f, 
    0.02872455f, 0.01354358f, -0.05437556f, 0.06573974f, 0.04745929f, 0.00997609f, -0.00391938f, -0.03075752f, 
    0.01163851f, 0.05698222f, 0.03499771f, 0.06240283f, -0.04151426f, 0.05393820f, -0.06344525f, -0.07965985f, 
    0.00288677f, 0.00474710f, 0.02400890f, -0.06020512f, -0.03467439f, 0.00760587f, -0.02797465f, -0.01517080f, 
    -0.05358465f, -0.05785207f, -0.00541622f, 0.05456702f, 0.03606565f, 0.04941168f, -0.06516483f, -0.01801110f, 
    0.00058092f, 0.03019808f, -0.03292462f, 0.03821117f, 0.04952776f, 0.00369635f, 0.05609892f, 0.02438572f, 
    0.04910938f, -0.00008178f, -0.03117149f, -0.08136748f, -0.02320393f, 0.05693923f, -0.03303681f, 0.00044549f, 
    -0.04554390f, -0.02670996f, -0.08094618f, 0.00159325f, -0.01822481f, -0.00765674f, -0.01204837f, 0.01438417f, 
    -0.13536057f, -0.13981329f, -0.27738908f, 0.08340313f, 0.00380396f, 0.01771247f, -0.09765393f, 0.01904121f, 
    0.01595871f, 0.03407625f, -0.07481295f, -0.06028908f, 0.15275130f, 0.14094637f, 0.30042383f, 0.22107512f, 
    0.11300045f, -0.02596146f, 0.03887539f, 0.11839013f, -0.00294101f, -0.05634991f, -0.07498861f, -0.10177750f, 
    -0.19185610f, -0.11695147f, 0.28441364f, -0.00972286f, -0.00238524f, -0.01352045f, -0.08314840f, -0.00562683f, 
    0.01067471f, 0.02080508f, 0.00774287f, -0.08277040f, 0.03757342f, -0.07557523f, -0.12079360f, -0.18440636f, 
    0.02242449f, 0.01797445f, -0.09955990f, -0.06908098f, 0.03958441f, 0.01916305f, -0.02202437f, 0.09266420f, 
    0.10106707f, 0.14755824f, -0.06438669f, -0.11204804f, -0.09991144f, 0.00507340f, -0.00110088f, -0.05487390f, 
    -0.07710286f, -0.01961633f, -0.01546635f, -0.07985172f, 0.37051579f, 0.15120162f, -0.17172164f, 0.01855678f, 
    -0.18146779f, -0.03612819f, -0.08932156f, 0.01086072f, 0.04028663f, -0.04446710f, -0.02328588f, 0.00477958f, 
    0.19930793f, -0.22304951f, -0.08276291f, 0.07434787f, 0.02927072f, 0.03567424f, 0.02495033f, 0.01186619f, 
    0.06528855f, -0.04041361f, 0.07444475f, -0.00829246f, 0.09781113f, -0.07168137f, 0.14257634f, 0.09317099f, 
    -0.05643127f, -0.03918998f, 0.14235972f, 0.03815045f, -0.08596864f, 0.05481894f, -0.08101372f, 0.01535669f, 
    0.21776490f, 0.12532079f, -0.05386128f, -0.08526647f, -0.01499509f, -0.03638339f, -0.01691522f, 0.02100837f, 
    0.09783054f, -0.08121419f, 0.06069959f, 0.00241451f, 0.08123549f, 0.20222673f, 0.19735251f, 0.08319858f, 
    -0.02390883f, 0.00576320f, 0.05760888f, -0.02576488f, 0.05142024f, 0.04945234f, 0.01230455f, -0.04898419f, 
    -0.06245412f, 0.22583604f, -0.02477202f, -0.02157270f, 0.09894738f, 0.10464725f, 0.02166030f, 0.00974971f, 
    0.03725925f, -0.03609327f, -0.04793630f, 0.02335326f, -0.00306742f, 0.06841860f, 0.16255450f, -0.11199213f, 
    -0.09200437f, 0.12197459f, 0.07537549f, 0.02191463f, 0.01300289f, 0.12388310f, 0.12183211f, 0.05546462f, 
    0.02814502f, -0.02061263f, -0.01695278f, 0.18192232f, 0.00927751f, 0.00254885f, 0.08000526f, -0.07672681f, 
    -0.00124136f, -0.02749781f, 0.07502083f, -0.01150885f, 0.07718970f, 0.01923444f, 0.09565447f, 0.07133889f, 
    0.01032863f, -0.01340485f, 0.15270527f, -0.02631540f, -0.17371906f, -0.01746803f, 0.04649098f, -0.06902253f, 
    0.00404205f, 0.28185001f, -0.18726072f, 0.10600136f, 0.06536844f, -0.11227171f, -0.15513298f, 0.16055129f, 
    0.08489367f, 0.08944508f, 0.06987353f, -0.04932363f, -0.00647111f, 0.06884128f, 0.24991755f, 0.07953063f, 
    -0.03595309f, 0.00122518f, 0.02252509f, -0.02974737f, -0.05177518f, 0.14186276f, 0.08333428f, -0.16587928f, 
    0.23790906f, -0.08029012f, 0.04942384f, 0.14720440f, -0.02645692f, -0.16911164f, -0.06620403f, 0.05167639f, 
    0.04915422f, 0.07723326f, 0.06825180f, 0.16457064f, -0.22293070f, -0.01237617f, -0.09458361f, 0.00296611f, 
    0.03535594f, -0.03050000f, 0.14867322f, -0.02729688f, 0.06950236f, 0.05030582f, -0.07259147f, 0.08242559f, 
    -0.42265120f, 0.11599647f, 0.01894751f, -0.10437233f, -0.14805929f, -0.07000187f, -0.06046008f, -0.03881113f, 
    0.03334763f, 0.07720233f, 0.10952727f, 0.17525841f, 0.36962995f, -0.11013059f, 0.12103835f, -0.04681356f, 
    0.06780089f, -0.12011782f, -0.13533749f, -0.13358621f, 0.10962577f, -0.02202663f, 0.14707607f, 0.21748397f, 
    0.35770315f, -0.15248305f, 0.11662541f, 0.34064692f, 0.03703751f, 0.01828096f, 0.02947305f, 0.03430205f, 
    0.04551616f, -0.00090315f, -0.05356399f, -0.07847461f, 0.09549414f, -0.08478877f, 0.20735003f, -0.02749008f, 
    -0.05714258f, -0.00414652f, 0.05485183f, 0.01844907f, 0.02939155f, -0.10427532f, 0.10752167f, 0.04116427f, 
    0.22534780f, 0.05198698f, -0.02562758f, -0.17376709f, -0.00127892f, -0.02364188f, 0.08166155f, -0.03608120f, 
    0.06970473f, -0.12356155f, 0.12949879f, 0.01218835f, -0.64873242f, 0.32081228f, -0.17477490f, 0.09785940f, 
    0.00616253f, 0.03031436f, 0.06758719f, -0.01714993f, -0.03503716f, -0.08688802f, 0.05215807f, -0.03022448f, 
    0.03572840f, -0.21486680f, -0.11096533f, -0.16592725f, -0.00737779f, 0.02884954f, -0.13548553f, 0.08090245f, 
    0.00491622f, -0.12761627f, 0.04317778f, -0.06677355f, 0.15973882f, -0.01596727f, 0.05630475f, 0.01576634f, 
    0.12290697f, 0.10764785f, 0.07873275f, 0.06590552f, -0.06532290f, 0.12447726f, -0.02314685f, 0.09316545f, 
    0.12249777f, -0.02772169f, -0.18474336f, 0.10940361f, 0.12705757f, 0.07905683f, -0.07021422f, 0.09238791f, 
    0.11390496f, -0.01262913f, -0.10731824f, 0.05217539f, -0.03864239f, 0.02944258f, 0.02970214f, 0.04529347f, 
    -0.07356822f, -0.14033906f, -0.05861354f, 0.06862719f, 0.09501919f, 0.09107796f, 0.05188951f, -0.10535245f, 
    0.05898195f, -0.11554556f, 0.00466568f, 0.03444188f, 0.11030180f, -0.00678919f, -0.00803745f, -0.01068206f, 
    -0.05157911f, 0.01326979f, -0.09740570f, -0.12654273f, 0.27580252f, -0.06198264f, -0.02714392f, 0.47972372f, 
    0.02199563f, -0.05879174f, -0.03364443f, -0.05188067f, 0.12545322f, 0.04623645f, 0.05153709f, -0.08257020f, 
    -0.19287071f, -0.04603799f, 0.03490417f, -0.07125545f, -0.02488867f, -0.08873197f, 0.03516680f, 0.02124828f, 
    0.08012958f, 0.00143169f, 0.02574614f, -0.04801134f, -0.13680141f, 0.20674986f, 0.01860598f, 0.13457425f, 
    0.11336937f, 0.03806537f, -0.08304617f, -0.09123824f, 0.09845936f, -0.02442318f, 0.01650727f, -0.18994252f, 
    0.03079791f, -0.14308262f, 0.02528366f, 0.04523636f, -0.14912492f, 0.02481311f, 0.02568617f, 0.02244459f, 
    0.02092366f, 0.04406741f, -0.00486671f, -0.11848392f, 0.03860792f, -0.09820753f, 0.16447182f, -0.14137267f, 
    0.08563315f, 0.10300947f, -0.12743935f, 0.06677836f, -0.04324180f, 0.02166419f, 0.09868163f, 0.05281489f, 
    -0.29643539f, 0.11224841f, 0.18730401f, 0.16358960f, 0.00332391f, 0.00522456f, 0.12759858f, -0.00825004f, 
    0.00228172f, 0.04429006f, 0.04096581f, -0.07786430f, 0.04170427f, -0.21709658f, -0.06027480f, -0.06279369f, 
    -0.01270156f, 0.00399051f, -0.08665001f, -0.01522926f, -0.00919217f, 0.05647165f, -0.05305288f, -0.04884410f, 
    -0.05776887f, 0.13369235f, -0.04459175f, 0.08006223f, 0.04784298f, -0.03539239f, 0.03519915f, 0.03236445f, 
    0.02154525f, 0.02878654f, -0.05717671f, 0.01192605f, 0.03265468f, -0.00364800f, -0.06553056f, 0.16075198f, 
    -0.11310116f, 0.05265883f, 0.07305023f, 0.02704157f, -0.10490881f, -0.03402983f, -0.01547224f, 0.02031316f, 
    -0.30589962f, -0.07218555f, 0.23015222f, -0.10966770f, -0.04999628f, 0.06099212f, -0.03109135f, -0.02610550f, 
    0.05567588f, 0.06878147f, -0.08844656f, -0.10509796f, -0.49662331f, 0.11541648f, -0.02556554f, 0.06671510f, 
    0.14547269f, -0.03510945f, 0.13198479f, -0.01534874f, 0.02241048f, 0.00212603f, 0.02247862f, 0.13526216f, 
    0.34771708f, 0.07973929f, -0.10459367f, -0.10174267f, 0.03823115f, 0.02444435f, -0.05670994f, -0.05480925f, 
    -0.06847466f, 0.01262849f, -0.04027396f, 0.04976530f, -0.08790238f, -0.09109153f, 0.10133139f, 0.12844206f, 
    -0.04732250f, 0.04030458f, -0.00458198f, -0.04053851f, 0.12925746f, 0.04589487f, -0.03493654f, -0.03484154f, 
    0.16616276f, 0.07420576f, 0.04283686f, -0.08613515f, 0.04878521f, -0.00067517f, 0.01929360f, -0.09134395f, 
    0.09601019f, 0.00908863f, 0.08677010f, -0.08427753f, -0.16451831f, -0.00358822f, 0.16945952f, -0.05663729f, 
    -0.17721428f, 0.12155035f, 0.04965760f, 0.06084906f, 0.03878823f, 0.02894251f, -0.03922506f, 0.05206450f, 
    0.09121619f, -0.14967291f, -0.16840293f, -0.12240738f, 0.00624340f, 0.12069355f, -0.02525773f, -0.05328412f, 
    -0.07374702f, -0.04839428f, 0.09884129f, -0.02993984f, 0.11827997f, 0.10676425f, 0.10257252f, 0.14611554f, 
    -0.11627994f, -0.08120424f, 0.05850688f, 0.02388927f, -0.13093187f, 0.09306381f, 0.08791681f, 0.05638100f, 
    0.40694338f, 0.12242708f, 0.00549335f, 0.01559422f, -0.05255865f, -0.01325344f, -0.04146725f, 0.00440443f, 
    -0.10256813f, -0.03214513f, 0.02105373f, 0.02175950f, -0.05516324f, -0.02169273f, 0.00357896f, 0.14774653f, 
    -0.04401525f, 0.00340063f, 0.09426130f, 0.04034045f, 0.06954170f, 0.07985058f, 0.00860084f, 0.04681911f, 
    0.21231799f, -0.09987785f, 0.27170244f, -0.14002559f, -0.05476080f, -0.12414876f, 0.16945560f, 0.03069049f, 
    -0.07041305f, 0.00340996f, -0.08144966f, 0.01844282f, 0.05086377f, -0.04876089f, -0.22895634f, 0.10228527f, 
    0.02390938f, 0.05423197f, -0.15209977f, -0.01880497f, 0.04091960f, -0.00944295f, 0.03329540f, 0.10419090f, 
    0.03916825f, 0.04451979f, -0.09834617f, -0.07163370f, 0.00953225f, 0.04667993f, -0.01739695f, -0.02087905f, 
    0.01078342f, 0.07786652f, -0.02355010f, -0.02678183f, 0.30379564f, 0.01092964f, 0.20904395f, 0.07073435f, 
    -0.02531703f, 0.02372437f, 0.05070184f, -0.05851489f, -0.04094410f, -0.04564800f, 0.05640416f, -0.08432047f, 
    0.22981897f, 0.20201354f, 0.04935661f, 0.18531691f, 0.08526494f, 0.07180255f, -0.01944879f, 0.04111739f, 
    -0.10375602f, 0.01597191f, 0.06156051f, 0.04108329f, -0.10009118f, -0.06061951f, 0.16771495f, -0.09657683f, 
    -0.07265276f, 0.03854010f, 0.02407481f, 0.03281121f, -0.01437960f, 0.06034003f, -0.03806837f, 0.04404389f, 
    -0.03600838f, 0.13342002f, 0.24929762f, -0.15698665f, -0.11605075f, 0.06099126f, 0.07514740f, -0.06091542f, 
    -0.07095689f, 0.04740798f, -0.08731934f, 0.01501429f, 0.23229469f, -0.03250271f, -0.12593783f, 0.26003459f, 
    0.02400263f, 0.07120922f, -0.12603883f, 0.00638682f, 0.01175235f, 0.09751526f, -0.00284753f, -0.00394448f, 
    -0.24636246f, -0.35706818f, 0.03365792f, 0.01013522f, -0.06702021f, -0.03505037f, -0.04246432f, 0.12299259f, 
    0.11043148f, -0.06695312f, -0.02255631f, 0.03173195f, -0.01911614f, -0.12772943f, 0.17005235f, -0.20133857f, 
    0.07340340f, -0.02328047f, 0.08074810f, 0.11128259f, -0.09830020f, 0.03732377f, -0.03149552f, -0.02243160f, 
    0.03213880f, -0.09230164f, 0.03006621f, 0.04508819f, 0.02013616f, -0.08833382f, -0.02697427f, 0.06575830f, 
    0.01957292f, -0.00135806f, -0.00292356f, -0.00614877f, 0.08893833f, -0.00724015f, 0.03257182f, 0.20439692f, 
    0.18633331f, 0.06856787f, 0.22356188f, -0.03164389f, 0.05945550f, -0.03692820f, 0.03348339f, -0.14588806f, 
    0.11052244f, 0.09980779f, 0.07515571f, -0.04318825f, 0.09984645f, 0.08238576f, 0.08658344f, 0.16117539f, 
    0.01851294f, 0.08567440f, 0.12859365f, -0.01144593f, 0.14060965f, 0.03631187f, -0.21851708f, 0.36201248f, 
    -0.06412796f, 0.04784048f, -0.00485893f, 0.00658740f, 0.09833139f, -0.10099131f, -0.05123345f, -0.06630364f, 
    -0.19678251f, 0.02029964f, 0.19443810f, -0.37154949f, -0.02349466f, -0.03606983f, 0.10138515f, -0.02503486f, 
    -0.01356364f, -0.06065405f, 0.03745667f, -0.01788806f, 0.13085188f, -0.12840487f, -0.03989688f, -0.02917588f, 
    0.14633580f, -0.11961070f, -0.06892819f, 0.10953520f, 0.01863609f, 0.05897489f, 0.00941663f, 0.08435843f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02943295f, -0.06865071f, -0.02278420f, -0.05911201f, -0.04677524f, 0.01445797f, -0.07415040f, 0.06121680f, 
    0.05110236f, 0.05606649f, -0.02144359f, 0.07706214f, 0.11902758f, -0.05243232f, -0.04051197f, 0.08222111f, 
    0.07563554f, -0.04451795f, 0.13422585f, -0.09897539f, 0.04038412f, -0.01020362f, 0.04209849f, 0.11947367f, 
    0.00786341f, -0.02656458f, 0.03157027f, 0.10462062f, 0.01530157f, 0.05812849f, 0.03342706f, -0.01250128f, 
    -0.01646299f, -0.03003978f, -0.06205107f, -0.10401442f, 0.03288249f, -0.05759556f, 0.12470835f, 0.08613898f, 
    -0.01586059f, 0.09252518f, 0.06573615f, 0.04505886f, 0.14388679f, 0.02511551f, 0.05040466f, -0.08754528f, 
    0.00518949f, 0.04842324f, -0.03465927f, 0.06432903f, 0.04770827f, -0.03137502f, 0.13982388f, -0.02368414f, 
    -0.06879719f, 0.06142098f, 0.06057905f, 0.04545991f, -0.06230479f, 0.06842497f, -0.05221618f, 0.01342855f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.04075586f, -0.07891669f, -0.01251508f, 0.08580338f, -0.01728717f, 0.06481952f, -0.01697323f, 0.19615112f, 
    -0.28386831f, 0.04178275f, 0.14206767f, -0.06639303f, -0.02610836f, 0.01093721f, 0.10026932f, -0.24201931f, 
    0.12185084f, 0.00710948f, -0.18906343f, 0.19713485f, 0.03788677f, -0.25050235f, -0.06419696f, 0.17203027f, 
    0.14295246f, 0.28105816f, -0.01834833f, -0.03028502f, -0.03691113f, 0.09940307f, 0.02125933f, -0.07664997f, 
    -0.04973039f, -0.18589944f, 0.11467800f, 0.18709922f, -0.12553211f, -0.07048719f, 0.35183617f, -0.05146535f, 
    0.06369700f, 0.28723204f, -0.33238748f, 0.06380139f, 0.02499874f, -0.10473303f, 0.20397565f, -0.01681349f, 
    0.12128568f, 0.06293956f, 0.47164661f, 0.08973884f, 0.01609247f, 0.12312496f, -0.09089343f, -0.07257434f, 
    0.01366153f, 0.06479329f, -0.01636838f, 0.06391794f, -0.05748448f, 0.41021088f, 0.19512866f, 0.04011189f, 
    0.16813539f, -0.07974863f, 0.04426783f, 0.06598180f, 0.09179778f, 0.07406464f, -0.01067138f, -0.12731485f, 
    0.27968460f, -0.09775479f, -0.02592917f, 0.11270082f, 0.17478010f, 0.05005516f, -0.03787233f, -0.25769359f, 
    -0.03132533f, 0.08759350f, 0.08309691f, -0.13684414f, 0.22262239f, -0.13016739f, 0.10376060f, 0.28645101f, 
    0.41989678f, -0.17837705f, 0.02140475f, 0.06303928f, 0.27423087f, 0.30594492f, -0.08796592f, 0.12694444f, 
    0.07075721f, -0.26575622f, 0.05263461f, -0.14794596f, 0.31552568f, 0.08283106f, -0.01029907f, -0.04274070f, 
    0.00578335f, 0.29635194f, -0.14032312f, -0.06214751f, -0.27018911f, 0.11190340f, -0.36045915f, -0.03706650f, 
    -0.19330983f, 0.00157701f, -0.16177969f, -0.12759231f, -0.09781064f, -0.11467779f, 0.13145342f, 0.15877503f, 
    -0.12745407f, 0.03675826f, 0.08292148f, -0.02437507f, -0.08679457f, -0.09567218f, -0.24182862f, 0.09668456f, 
    -0.27811912f, -0.04502152f, -0.02424251f, -0.01642000f, 0.02643097f, -0.18818788f, -0.26565012f, 0.02999861f, 
    0.19648492f, -0.05812141f, 0.03243026f, 0.07734761f, -0.15410611f, 0.03682818f, 0.01335832f, 0.14672546f, 
    0.16492146f, -0.07228462f, 0.18150668f, -0.28085712f, 0.18349114f, -0.12557593f, -0.11447147f, 0.30316532f, 
    0.18600628f, 0.08975247f, -0.15423700f, 0.28092203f, -0.12148619f, 0.12033708f, 0.02706586f, -0.10299304f, 
    -0.02066208f, -0.21307422f, 0.05209367f, -0.18415096f, -0.00117853f, -0.01190408f, 0.04451192f, 0.01123654f, 
    0.06513689f, 0.33647534f, 0.04495665f, 0.03645498f, 0.34718084f, -0.01608568f, 0.19206423f, -0.10693608f, 
    0.10199153f, -0.03281590f, -0.05791584f, -0.10038234f, -0.03838440f, 0.05880686f, -0.12506333f, 0.13607414f, 
    0.04321896f, -0.32399809f, -0.00859376f, 0.01516160f, -0.10171514f, -0.00967806f, -0.32451239f, 0.24430989f, 
    0.17032370f, -0.05429996f, 0.11979398f, -0.00543680f, 0.08005686f, 0.12561792f, 0.05975923f, 0.36737293f, 
    -0.03495379f, -0.12331478f, 0.10082251f, -0.05302036f, -0.01885247f, -0.03305243f, -0.01388566f, 0.09251575f, 
    0.24869175f, 0.11358088f, 0.08264188f, 0.23145933f, 0.19657744f, -0.53569198f, 0.11743759f, -0.20349997f, 
    0.25875831f, -0.33075741f, 0.19884034f, 0.17815927f, 0.10461693f, 0.04482691f, -0.01423790f, 0.00333734f, 
    0.10568192f, 0.06117281f, 0.06805502f, -0.31486395f, -0.00970660f, -0.10836383f, 0.21557400f, -0.25457746f, 
    0.06012046f, 0.00415638f, -0.29756919f, 0.03543061f, -0.27143192f, 0.09408058f, 0.11406577f, 0.02870997f, 
    0.18584912f, 0.05372997f, 0.27435896f, 0.05755465f, 0.04534217f, 0.11653170f, -0.26135379f, -0.24764308f, 
    -0.08430930f, -0.02415461f, 0.08738489f, 0.00221722f, -0.19239566f, 0.30805054f, -0.01973223f, -0.03139913f, 
    -0.04497356f, -0.02490692f, 0.03792026f, -0.09162930f, -0.02275296f, -0.15095724f, -0.14393777f, -0.15412116f, 
    0.27515262f, 0.06176765f, 0.03694263f, -0.01421022f, 0.14445925f, -0.04572272f, 0.05217340f, 0.37391877f, 
    0.09574831f, 0.12336444f, 0.33921611f, 0.05858887f, 0.14507610f, 0.08236359f, 0.11052003f, 0.02896005f, 
    0.06375439f, -0.05770726f, 0.32076454f, 0.35479632f, -0.22576594f, -0.15341803f, -0.02285215f, 0.04577072f, 
    0.01333609f, -0.02732568f, -0.04451054f, -0.16921644f, 0.03768144f, -0.02198484f, -0.26242504f, 0.15318611f, 
    -0.12120729f, 0.16250849f, 0.17761219f, 0.10824521f, 0.32895529f, -0.02805341f, 0.18520997f, 0.18228912f, 
    0.06757057f, 0.00434039f, -0.14780734f, 0.05494754f, 0.10050987f, 0.04932841f, -0.03162754f, -0.03213935f, 
    0.05300364f, -0.01601232f, 0.05876126f, -0.03277453f, 0.16991791f, 0.09814332f, -0.22865860f, -0.15297045f, 
    0.15396069f, -0.08441758f, -0.11510264f, 0.02408454f, -0.08088099f, 0.29740459f, 0.04062978f, 0.07195955f, 
    -0.10849015f, -0.01947868f, -0.09641873f, -0.07533166f, 0.09120233f, 0.08469851f, -0.00725312f, 0.11956760f, 
    -0.10410712f, 0.08353239f, 0.32849061f, 0.08273620f, 0.07714503f, -0.08202057f, 0.08528653f, 0.07156809f, 
    -0.16136801f, -0.31612808f, 0.37721917f, -0.15064284f, -0.05049112f, 0.17411575f, 0.09932438f, 0.02780872f, 
    -0.04939390f, 0.04967412f, 0.12478127f, 0.12646806f, -0.21353705f, 0.04045163f, 0.12224821f, -0.03935532f, 
    0.07893226f, 0.15141664f, 0.09199697f, -0.05237668f, -0.21253325f, 0.01313681f, 0.41170561f, 0.09149761f, 
    -0.16468872f, 0.39087984f, -0.08021082f, 0.24197690f, 0.12836854f, 0.11563651f, 0.09110980f, 0.05170907f, 
    0.09113851f, 0.16003692f, -0.11728993f, -0.12162900f, 0.14369611f, 0.01542011f, 0.15185560f, -0.23523593f, 
    0.15016873f, -0.01524791f, 0.06633411f, -0.04312107f, -0.11270171f, -0.05657287f, 0.32346204f, 0.00483000f, 
    0.00447602f, 0.06623916f, 0.31696117f, -0.11516182f, -0.10522638f, 0.09992129f, -0.07002327f, 0.20830500f, 
    0.22090749f, 0.10315793f, 0.22227001f, -0.15409231f, 0.15134589f, 0.07854633f, 0.05349099f, -0.00729664f, 
    0.32533273f, -0.16751552f, 0.07108277f, 0.26604980f, 0.16297311f, 0.03640182f, -0.06844779f, -0.07105707f, 
    0.02288498f, 0.07489368f, -0.02817118f, 0.12133363f, 0.08439302f, 0.04855863f, -0.29566470f, -0.05294321f, 
    -0.02268028f, -0.08588757f, -0.15316127f, 0.06055046f, -0.17619488f, 0.01506716f, -0.24023050f, 0.02356501f, 
    0.30179220f, -0.46905550f, 0.07070518f, -0.29118925f, -0.07010379f, 0.02040578f, -0.21380067f, 0.20304646f, 
    -0.05665906f, -0.09256042f, -0.01268237f, -0.03636536f, -0.02397095f, 0.01500259f, -0.12296558f, 0.18353172f, 
    -0.02062437f, -0.11108445f, -0.07053821f, -0.01755775f, 0.06943885f, -0.15016277f, -0.19263844f, -0.11241934f, 
    0.27328965f, -0.07554790f, 0.09567317f, 0.17286779f, -0.09330820f, -0.09986294f, -0.04116807f, 0.11654748f, 
    -0.07379053f, -0.08035652f, 0.23745272f, 0.05105682f, 0.33073747f, 0.06215614f, -0.00454981f, 0.03234828f, 
    0.17841282f, -0.01528761f, 0.21432894f, 0.19214797f, 0.00382545f, 0.00103282f, -0.11359654f, 0.02151042f, 
    0.00222697f, -0.24849623f, 0.12139503f, -0.21431081f, -0.01505817f, -0.04120816f, 0.11444366f, 0.36456826f, 
    0.01725164f, 0.48073581f, 0.13696332f, -0.05982960f, -0.10235059f, 0.09794145f, -0.05686428f, 0.00724089f, 
    -0.06293540f, 0.16433647f, -0.01107537f, -0.18474464f, -0.07223171f, -0.12885696f, 0.13230592f, -0.01618773f, 
    0.09227666f, 0.04945625f, -0.11018361f, -0.00313283f, -0.18600616f, -0.14929993f, -0.09060551f, -0.13413331f, 
    -0.03891835f, 0.05467097f, 0.10681987f, 0.03777204f, 0.06887438f, -0.08266938f, 0.04522168f, 0.07871937f, 
    -0.02122894f, 0.02140510f, -0.05223989f, -0.14396521f, -0.11111899f, 0.10720206f, -0.07354701f, 0.01640943f, 
    0.03003307f, 0.02896471f, 0.00853379f, -0.00745591f, 0.05484777f, -0.12039937f, 0.05817111f, 0.07955687f, 
    -0.03114920f, -0.08794995f, 0.01135325f, -0.13164681f, -0.14379290f, 0.07764027f, -0.05759917f, 0.00954486f, 
    -0.08816369f, -0.05793834f, -0.11984472f, -0.00933288f, -0.08254766f, 0.06265375f, 0.07986417f, 0.05563689f, 
    -0.10440069f, 0.00087990f, -0.02118365f, -0.05003054f, 0.06588186f, -0.02182102f, -0.02645582f, -0.11252031f, 
    0.09798007f, -0.11915759f, 0.01881566f, -0.13876903f, -0.02068268f, -0.02019319f, -0.01706394f, -0.09720700f, 
    -0.09868482f, -0.04002137f, -0.08102586f, 0.06964543f, -0.09016750f, -0.03180448f, 0.06297565f, 0.07065628f, 
    0.00335240f, 0.01518725f, 0.07127179f, 0.11556427f, -0.02081266f, 0.03492594f, 0.06821621f, 0.05241223f, 
    -0.07294835f, -0.02924350f, -0.06973547f, -0.01263153f, -0.11460357f, -0.01579811f, 0.01639643f, 0.06759689f, 
    0.08283717f, 0.11622234f, -0.11054442f, -0.07422147f, -0.08185779f, 0.06445502f, -0.11387452f, 0.06200013f, 
    -0.09279601f, -0.08288711f, 0.03582290f, -0.13660879f, 0.00024339f, -0.09174667f, 0.08311896f, 0.11353594f, 
    -0.06428508f, 0.04311676f, -0.11135274f, -0.07972939f, 0.02681390f, 0.07232073f, -0.02791103f, -0.09561770f, 
    0.00513098f, 0.08856249f, -0.14433582f, 0.00479339f, -0.12288354f, 0.09510280f, 0.06117459f, -0.13354272f, 
    -0.09501535f, -0.07890959f, 0.05342308f, 0.00826568f, -0.02434684f, -0.01647206f, -0.09927046f, 0.03463981f, 
    -0.04287927f, 0.06764010f, -0.09528369f, 0.04062489f, -0.04731005f, 0.01677468f, -0.03789028f, -0.00367830f, 
    0.08807750f, -0.02780772f, 0.08864816f, -0.06074391f, 0.06144448f, -0.13599733f, 0.13469461f, 0.09217546f, 
    0.01236393f, -0.03977938f, -0.05570809f, -0.04415153f, 0.31585315f, 0.10702010f, -0.02604395f, -0.24238592f, 
    -0.16099089f, 0.01858188f, -0.13416402f, 0.15747344f, -0.00900846f, -0.08500968f, 0.06817213f, 0.10667250f, 
    0.00692893f, 0.14651173f, -0.09388837f, 0.09713617f, -0.05807646f, 0.03704669f, 0.00883083f, -0.04475384f, 
    0.03890268f, 0.07493352f, 0.09221266f, 0.16098739f, 0.36394382f, 0.09591751f, 0.20901656f, 0.05081116f, 
    -0.07084301f, 0.01046461f, -0.10770515f, -0.05171520f, 0.22552827f, -0.06360929f, -0.13830937f, 0.26373491f, 
    -0.10389198f, 0.40882745f, 0.19413547f, 0.26757964f, -0.09945273f, -0.08167255f, 0.02357577f, -0.03665064f, 
    0.03406078f, -0.05597812f, -0.03266803f, -0.01741323f, 0.16000818f, 0.25638410f, 0.31739271f, -0.06967764f, 
    -0.02611434f, 0.01669340f, 0.06774108f, 0.01361596f, -0.12766077f, 0.07398263f, 0.21669573f, 0.04899919f, 
    -0.08297592f, 0.01875143f, 0.13292143f, -0.07454688f, -0.21340626f, 0.08802208f, -0.00665384f, 0.34359068f, 
    0.10993672f, -0.01488051f, -0.01816147f, 0.05266415f, -0.00940654f, 0.20431457f, 0.05939447f, -0.07056555f, 
    -0.10532118f, 0.02724322f, -0.10174453f, 0.14918445f, -0.12071861f, -0.19902144f, -0.00933185f, 0.07703827f, 
    -0.00152010f, 0.21887887f, 0.08130790f, 0.17136762f, -0.28351086f, 0.06951870f, -0.20962577f, 0.01836287f, 
    -0.05152796f, -0.11009316f, 0.26031682f, 0.00766458f, 0.29669273f, 0.05644315f, 0.48724082f, 0.00857138f, 
    0.36164078f, -0.07991175f, 0.09481438f, -0.01740594f, 0.09820056f, 0.10877387f, -0.12778027f, 0.14447589f, 
    0.08262123f, -0.07550662f, -0.09490125f, 0.00029565f, -0.04843814f, 0.03368366f, -0.00161231f, 0.21946423f, 
    -0.20796748f, -0.03512461f, -0.02675380f, 0.06422471f, 0.03926807f, -0.00451565f, 0.08403565f, 0.17482877f, 
    0.23166187f, 0.12249159f, 0.16323213f, 0.21157964f, 0.09686827f, -0.08899314f, -0.05331932f, 0.02768662f, 
    0.27996701f, 0.01101008f, -0.09163046f, -0.10844762f, 0.09034958f, -0.08868191f, -0.08922440f, 0.16458616f, 
    -0.32931185f, 0.24102367f, -0.26759139f, -0.07478847f, 0.13640660f, -0.08588530f, -0.08824520f, 0.11185598f, 
    -0.11234675f, 0.18525936f, -0.06354871f, -0.00612073f, -0.08186805f, 0.08988047f, -0.10044516f, 0.04182492f, 
    -0.06887050f, 0.05424674f, 0.10018296f, -0.05555082f, 0.18128747f, -0.09568051f, 0.05974790f, -0.25750145f, 
    0.23340243f, -0.10698491f, 0.03499990f, -0.26479760f, 0.05081246f, -0.07740939f, 0.19342902f, 0.32936659f, 
    0.07292680f, 0.10124903f, -0.09596017f, -0.02694707f, -0.11176571f, 0.15529160f, -0.13856772f, 0.21905597f, 
    -0.07550788f, -0.03677711f, -0.00627224f, -0.09243026f, 0.12337323f, 0.40278262f, 0.05075525f, 0.53183562f, 
    0.18468428f, -0.05899321f, -0.26250654f, 0.08624212f, 0.18784040f, -0.09623043f, 0.07257614f, 0.04047235f, 
    0.01610453f, 0.02972759f, 0.08209351f, 0.04726428f, -0.01225010f, -0.23765245f, 0.06872941f, -0.14064865f, 
    -0.19954738f, -0.06939934f, -0.16555832f, 0.26553378f, 0.17055663f, -0.05849764f, -0.13913201f, 0.09034898f, 
    0.11347517f, 0.06168283f, 0.06458342f, -0.25350821f, 0.19636720f, -0.10366855f, 0.02076809f, 0.02624928f, 
    0.05022089f, -0.08496730f, 0.14302316f, -0.01773804f, -0.17223799f, 0.05749060f, 0.02775437f, -0.22402757f, 
    0.04214369f, -0.06782147f, 0.26297548f, 0.05660617f, 0.12622367f, -0.00117160f, -0.00679199f, 0.14537565f, 
    -0.05448980f, 0.09268706f, -0.04191165f, -0.10900144f, 0.00312622f, 0.44836381f, 0.07705174f, 0.00490159f, 
    -0.09489896f, 0.07057106f, 0.04303892f, -0.05504209f, 0.00414508f, -0.10111392f, -0.16742301f, 0.11221440f, 
    -0.24033538f, -0.06823356f, 0.11792735f, -0.13188758f, 0.04193880f, 0.00693083f, -0.11867704f, -0.09479422f, 
    0.06553444f, 0.00430555f, 0.26116118f, -0.24260308f, -0.07428331f, 0.08153567f, 0.08668366f, 0.30756757f, 
    -0.04700636f, 0.04337024f, -0.00407778f, 0.01867222f, -0.06648970f, 0.08086994f, -0.05800911f, -0.01786530f, 
    0.00033338f, -0.16151324f, 0.08871716f, 0.38075775f, -0.15450951f, -0.05861658f, 0.00893198f, 0.20375998f, 
    -0.08188764f, 0.44200322f, -0.19357277f, 0.09829799f, 0.31306273f, 0.05273761f, 0.51750892f, 0.24010727f, 
    0.10657412f, 0.25835544f, 0.11732362f, 0.17046149f, 0.06395812f, -0.06173468f, 0.16225469f, 0.10636713f, 
    0.02239393f, -0.09231551f, -0.00475168f, -0.03834449f, 0.02328294f, -0.20153341f, 0.27101493f, -0.18852326f, 
    -0.02637498f, -0.07533103f, -0.00001056f, 0.07789954f, -0.12494095f, 0.01369662f, -0.00116288f, 0.02863216f, 
    0.01282586f, 0.09086075f, -0.05182549f, -0.08022282f, -0.09965989f, -0.06558763f, 0.04075499f, -0.06876261f, 
    -0.03411906f, -0.04222508f, 0.04810155f, -0.03342661f, -0.15171324f, 0.05746792f, 0.06261612f, -0.06161466f, 
    -0.01599509f, 0.03197543f, -0.06655402f, -0.04417473f, 0.06423090f, 0.05339960f, -0.00832047f, 0.07291570f, 
    -0.07300952f, -0.04724624f, 0.04254608f, 0.05452101f, -0.12690502f, -0.05420780f, -0.07603823f, -0.04049520f, 
    0.04131869f, -0.05725997f, 0.03798660f, 0.04856995f, -0.07504072f, -0.09159452f, -0.09592232f, -0.01564800f, 
    0.03502156f, -0.05765609f, -0.05578905f, -0.07808084f, -0.07653195f, -0.09624230f, 0.01956989f, -0.14824134f, 
    0.08384934f, 0.01313639f, 0.09507641f, 0.10723147f, -0.00919962f, 0.01207521f, -0.07521692f, 0.00203346f, 
    0.14473946f, -0.09519613f, -0.07275507f, -0.09737364f, 0.03864263f, 0.27394614f, 0.18298697f, -0.03139884f, 
    -0.15400364f, 0.02086511f, 0.03451769f, 0.02938930f, 0.08562887f, 0.00372921f, -0.04362959f, -0.36642548f, 
    -0.04640766f, 0.02928643f, -0.16386369f, -0.21544218f, -0.23050167f, 0.05741662f, 0.07000280f, 0.31312644f, 
    0.24556492f, -0.01134415f, -0.02810294f, -0.09338374f, 0.00667634f, 0.11009038f, -0.04663422f, -0.04324813f, 
    -0.01076348f, -0.04649693f, -0.08428184f, 0.39089063f, 0.06318226f, 0.01796610f, -0.00450689f, -0.07781425f, 
    -0.10453115f, -0.01457273f, -0.16261044f, -0.04942414f, 0.04125474f, 0.02941343f, 0.08176116f, 0.23408999f, 
    -0.00167303f, -0.09719460f, 0.15002212f, -0.03204951f, 0.08984482f, -0.10288697f, -0.04355399f, 0.10181943f, 
    -0.06679265f, -0.10672878f, 0.10469946f, 0.00702193f, 0.01417132f, -0.10325681f, 0.31623283f, 0.14475828f, 
    -0.06348856f, 0.01170478f, -0.10652329f, 0.03783858f, -0.09222572f, -0.07606592f, 0.10136861f, -0.04568377f, 
    -0.05390915f, -0.06515227f, -0.10003117f, -0.07494453f, 0.11058091f, -0.05753108f, -0.06704605f, 0.01746369f, 
    -0.09741691f, 0.11058348f, -0.03345360f, -0.08000629f, 0.04961202f, -0.08814612f, 0.08261724f, 0.11508716f, 
    -0.04009415f, -0.06557251f, 0.01350470f, -0.11210353f, -0.03245160f, -0.10730356f, 0.02839765f, 0.00116248f, 
    0.10000254f, -0.10024438f, 0.10642032f, 0.02972256f, 0.06973001f, 0.09898926f, -0.07863837f, -0.09006380f, 
    0.10283375f, -0.01827917f, 0.02368985f, 0.03222714f, -0.10105735f, 0.07100398f, 0.06699552f, 0.11136809f, 
    0.08926588f, 0.03958678f, 0.00012144f, -0.07064917f, -0.08260530f, -0.12071595f, -0.12590514f, -0.12128790f, 
    0.10720757f, -0.08191313f, -0.11963252f, -0.00146600f, 0.01640564f, 0.09459876f, 0.00001361f, 0.07164999f, 
    -0.15543029f, 0.03264033f, 0.05289626f, 0.07020919f, -0.03699798f, 0.04328796f, 0.20285302f, 0.23544379f, 
    0.11512215f, 0.08506669f, 0.08145204f, -0.08941032f, 0.16044202f, 0.02735296f, 0.08010602f, 0.13366440f, 
    0.04626931f, 0.10574654f, 0.42985323f, 0.02435312f, -0.16997758f, 0.02411917f, 0.01182869f, -0.00327812f, 
    -0.46704552f, 0.09147959f, 0.22550264f, -0.07074119f, -0.24833441f, -0.14705008f, 0.08746828f, -0.00798170f, 
    -0.03228314f, 0.12483388f, -0.07432114f, 0.28374687f, -0.08602800f, -0.11401218f, -0.07737108f, 0.04782918f, 
    -0.05212005f, 0.26741597f, 0.00256517f, -0.02263142f, 0.19620489f, -0.10359707f, 0.42891875f, 0.15205906f, 
    0.19992301f, 0.31003338f, 0.19515467f, 0.26026639f, -0.07651585f, -0.05934783f, 0.16852213f, -0.05258041f, 
    0.04719772f, 0.05687492f, -0.06649424f, 0.01895094f, 0.01425700f, -0.04933889f, 0.27173606f, -0.19785289f, 
    0.07286762f, -0.01842642f, 0.02683987f, 0.02574838f, -0.08234025f, 0.18298215f, -0.02043060f, 0.22262450f, 
    -0.17013338f, -0.12942518f, -0.25401780f, 0.02481537f, -0.01356706f, 0.06183193f, 0.08256976f, 0.16612788f, 
    0.02706373f, -0.04011739f, -0.01140925f, 0.14140739f, 0.09526528f, -0.15526114f, 0.03561216f, 0.00805757f, 
    0.03687547f, 0.17754163f, 0.34452158f, -0.17867212f, -0.11633988f, 0.02608981f, -0.03973401f, 0.11546732f, 
    0.01743501f, -0.09200517f, -0.01899491f, -0.06869925f, -0.16946054f, 0.01832426f, 0.32635957f, 0.01896900f, 
    0.06050626f, 0.10404357f, 0.15898521f, -0.11501144f, 0.12638982f, 0.00677290f, 0.60776186f, -0.06716684f, 
    -0.17548873f, 0.50519133f, 0.11174832f, 0.22761747f, -0.00321434f, 0.00494615f, 0.14343309f, -0.23717164f, 
    -0.06538405f, 0.12238465f, 0.09674253f, -0.10011709f, 0.16970462f, 0.26821718f, 0.16944504f, -0.12705642f, 
    -0.04723020f, -0.03855634f, -0.02667767f, 0.03442458f, 0.00528334f, -0.03893142f, 0.06978080f, -0.12768672f, 
    -0.11612481f, -0.09885751f, -0.02857967f, 0.00733375f, -0.06011985f, 0.04305431f, 0.02113937f, -0.11222488f, 
    -0.00945236f, 0.11920041f, 0.08657017f, -0.03027424f, 0.00852978f, -0.07930368f, 0.00440187f, -0.01148839f, 
    0.02675744f, -0.05676278f, 0.07602154f, -0.13861810f, -0.00573273f, -0.12153547f, 0.12073916f, 0.10620186f, 
    -0.12024505f, -0.06206378f, -0.08831266f, 0.10734784f, 0.03330803f, -0.11099717f, 0.03096620f, 0.03296310f, 
    -0.07766841f, -0.01929080f, -0.12948319f, -0.00050001f, 0.04000010f, -0.04667467f, -0.04495721f, 0.08381972f, 
    0.05236544f, 0.05559338f, -0.03415344f, 0.03111959f, -0.08275899f, -0.07472657f, -0.01766899f, 0.03439576f, 
    -0.11047120f, -0.05175668f, -0.09953766f, 0.11212644f, -0.13235334f, -0.02970399f, 0.06358036f, -0.11670054f, 
    -0.04156265f, 0.01679894f, -0.10828236f, 0.02822377f, 0.01872154f, 0.09155791f, -0.12574659f, -0.09819005f, 
    -0.06519768f, 0.12340869f, 0.05383748f, -0.07201048f, -0.11341498f, 0.10204192f, -0.10261105f, 0.02549060f, 
    -0.01165450f, -0.01780619f, -0.03986787f, -0.12127707f, 0.06184626f, -0.05300136f, 0.09257154f, 0.06270563f, 
    -0.12801088f, -0.02614481f, -0.02381821f, -0.10664532f, -0.03357178f, -0.07988393f, -0.00514618f, 0.10347611f, 
    -0.09473194f, 0.07477755f, 0.08161356f, 0.03221630f, -0.03228327f, 0.00586958f, -0.04814813f, -0.11094517f, 
    0.10780525f, 0.05011457f, -0.08942663f, 0.03636141f, 0.01698323f, -0.00570436f, -0.02175661f, 0.00146910f, 
    -0.09477226f, 0.00180991f, 0.08303505f, -0.04483742f, -0.01453079f, -0.08386765f, -0.11938420f, -0.02674804f, 
    -0.01815259f, -0.15734491f, -0.06182481f, -0.10220304f, 0.06218315f, 0.11181450f, -0.13745005f, -0.02476727f, 
    -0.08611351f, -0.12120500f, -0.09463404f, -0.10856249f, -0.04236689f, 0.04323830f, 0.03435487f, 0.00908686f, 
    -0.04412206f, 0.08655147f, -0.06639747f, 0.09308875f, 0.02151351f, -0.08857729f, 0.03951976f, -0.13302179f, 
    -0.07730300f, 0.01778695f, 0.12991889f, 0.07307737f, 0.22103369f, 0.30553827f, -0.10930281f, -0.01593334f, 
    0.37372938f, 0.28725165f, 0.11851443f, -0.05171030f, 0.13858186f, -0.10339268f, -0.06782267f, -0.01256596f, 
    0.07719180f, -0.37035537f, 0.12676820f, -0.01713940f, -0.08971138f, 0.11832789f, -0.15271269f, 0.12824102f, 
    -0.03023513f, 0.20429721f, 0.01219204f, -0.03308951f, 0.11484370f, 0.06829776f, 0.21477786f, 0.12896399f, 
    -0.01011715f, 0.03011039f, 0.24230771f, -0.10289918f, -0.02306382f, 0.12268172f, 0.12356481f, -0.09856644f, 
    -0.09149801f, -0.09361338f, 0.06967747f, 0.10411236f, 0.13190247f, 0.08598941f, 0.19919202f, 0.01289054f, 
    -0.15354286f, -0.05634487f, 0.06450416f, -0.03640255f, -0.00389300f, -0.04391306f, -0.07359865f, 0.03880066f, 
    -0.08873464f, -0.04180853f, 0.02514774f, -0.04515374f, -0.12516198f, -0.08761124f, 0.11960614f, 0.02346372f, 
    -0.01784224f, -0.06552570f, 0.01394673f, -0.06091233f, -0.01785874f, -0.08754086f, 0.01679868f, -0.08301144f, 
    -0.08091431f, -0.11848569f, 0.05761247f, -0.02213348f, -0.09736498f, -0.03741907f, 0.12281133f, 0.07553110f, 
    0.12466858f, 0.00574915f, 0.04242641f, -0.07046899f, -0.15908603f, 0.04590960f, -0.15611148f, 0.09489241f, 
    -0.05530158f, 0.00812019f, -0.10708357f, -0.04838271f, 0.05482981f, -0.00505534f, 0.09762748f, 0.01741763f, 
    0.02963320f, 0.06516361f, -0.03891996f, -0.01746198f, 0.03218819f, -0.01870732f, -0.00321801f, -0.08647161f, 
    -0.04347612f, -0.04773195f, -0.10914047f, 0.11617646f, -0.11509821f, -0.06730202f, 0.03934976f, -0.12859304f, 
    0.04432727f, -0.10192630f, -0.03990794f, -0.03017291f, 0.08199538f, -0.09073249f, -0.07228695f, 0.01540619f, 
    -0.22151031f, 0.08732463f, 0.37428790f, 0.03434980f, -0.08079883f, -0.00196784f, 0.06399564f, -0.02914758f, 
    0.12299778f, -0.06651916f, 0.07786205f, 0.55897635f, 0.27045885f, -0.16763526f, 0.06896710f, -0.03824513f, 
    0.11312804f, 0.32106733f, 0.39238089f, -0.08352035f, 0.15074192f, 0.04474756f, -0.00496931f, -0.07786422f, 
    -0.01786981f, -0.18974622f, 0.01133950f, 0.03696715f, -0.03584312f, 0.07422774f, 0.39366227f, -0.07096568f, 
    -0.04621348f, 0.26214990f, -0.26415038f, 0.00816355f, -0.28433651f, 0.09214562f, 0.14230655f, 0.15760534f, 
    0.11943503f, -0.02273081f, 0.43151957f, 0.04716973f, 0.01879435f, -0.05740435f, 0.01551293f, -0.22089002f, 
    -0.11012501f, 0.01741466f, -0.10567141f, 0.02169549f, 0.14766569f, 0.18518814f, 0.25285989f, -0.07691486f, 
    -0.01737313f, 0.07310497f, 0.03356811f, -0.03681218f, 0.09408191f, -0.27740192f, -0.04092293f, 0.17485785f, 
    -0.08599259f, -0.05089654f, 0.22844461f, -0.02628341f, 0.18712367f, -0.11010351f, -0.01734469f, 0.02964765f, 
    0.23982121f, 0.08489675f, 0.04929918f, -0.01575777f, 0.26983207f, -0.20736027f, -0.05346574f, 0.08033753f, 
    0.09692369f, 0.18435246f, 0.04654402f, 0.24550219f, 0.06254433f, -0.02350229f, 0.00031118f, -0.12253696f, 
    0.03366035f, -0.14866443f, 0.00809541f, -0.24025247f, 0.18885684f, 0.02779482f, 0.50139028f, 0.14492846f, 
    -0.06651312f, 0.26871008f, -0.15751338f, 0.05230217f, 0.10593373f, 0.12997431f, -0.09946491f, 0.00971134f, 
    0.01178773f, 0.19596392f, 0.22437455f, 0.08397944f, -0.14596291f, 0.11190574f, -0.12075324f, -0.01140480f, 
    0.03995434f, 0.08027038f, -0.06728979f, -0.01140979f, -0.17504987f, 0.06292216f, -0.02078932f, -0.05211450f, 
    -0.11369094f, 0.11055985f, 0.00179926f, -0.09054898f, -0.02894726f, 0.09506533f, 0.06717050f, 0.31219542f, 
    -0.01393966f, -0.10212334f, 0.17564608f, 0.01581982f, 0.19378506f, -0.00985154f, 0.04048534f, -0.11738317f, 
    0.24318889f, 0.01789959f, 0.05679391f, -0.06445491f, 0.21293937f, -0.38667998f, 0.02641785f, 0.21533482f, 
    0.22467959f, 0.11890075f, 0.16317102f, 0.28834349f, -0.04438687f, 0.15834476f, -0.02791999f, 0.06784478f, 
    -0.02399968f, -0.27566588f, 0.02480121f, -0.13777845f, 0.01773705f, 0.04416113f, 0.07804896f, 0.07117110f, 
    -0.11432247f, 0.15039149f, -0.19768426f, 0.03250574f, 0.09014162f, -0.09415098f, 0.09315565f, -0.02969471f, 
    -0.05494828f, 0.05885369f, 0.13480186f, 0.06148202f, -0.13023502f, -0.03969261f, -0.15361537f, -0.03981691f, 
    0.01098389f, 0.04581531f, -0.12199168f, -0.09612467f, -0.09335133f, 0.19734165f, -0.22756839f, -0.00573818f, 
    0.09162210f, -0.07649321f, 0.02101527f, -0.05470465f, 0.12108115f, 0.22338744f, 0.05450409f, 0.24911302f, 
    0.20875047f, -0.05711843f, -0.11610361f, 0.05023872f, -0.04637504f, 0.11334635f, -0.07622294f, -0.18320090f, 
    0.18258345f, 0.10792912f, 0.13654883f, -0.34342656f, 0.08339003f, -0.24879144f, 0.02325648f, 0.30381820f, 
    -0.39100423f, -0.35979050f, -0.59151471f, 0.22323519f, 0.18448582f, 0.11171763f, 0.10412252f, 0.01324973f, 
    0.06657279f, 0.14336970f, 0.03298752f, -0.34090179f, -0.14144294f, -0.06437263f, 0.23329896f, -0.08301707f, 
    -0.01550635f, 0.09197999f, -0.34410730f, 0.04639858f, -0.09447338f, -0.09142984f, -0.30915940f, -0.39521146f, 
    0.11834324f, 0.09239516f, -0.00376783f, 0.09829846f, -0.11579638f, 0.05040404f, -0.05862589f, 0.05298480f, 
    0.04663068f, 0.11760951f, 0.11149715f, -0.01990334f, -0.29874915f, -0.21642892f, -0.29900816f, 0.07774638f, 
    0.09769966f, -0.08616564f, -0.05765794f, -0.00334096f, -0.00904736f, -0.25946161f, 0.08578327f, -0.19462928f, 
    -0.21015640f, 0.04652581f, -0.03101887f, -0.08332562f, 0.06284492f, 0.02801284f, 0.05863050f, -0.28727597f, 
    -0.24748687f, -0.01368989f, -0.10941572f, -0.14095557f, -0.13842407f, 0.32572439f, 0.07915336f, 0.02687259f, 
    0.03573807f, 0.23702979f, -0.32553905f, -0.05028578f, 0.12887914f, 0.01247565f, -0.03390445f, 0.11836969f, 
    0.12136824f, -0.06893864f, -0.00731028f, 0.27089313f, 0.02794148f, -0.03219743f, 0.00331034f, 0.07637138f, 
    -0.06294757f, 0.11312647f, 0.13856255f, -0.11212187f, 0.17942940f, -0.04072873f, -0.16088280f, 0.14044367f, 
    0.11233413f, 0.18875018f, 0.13147020f, -0.07130148f, -0.03833276f, -0.05038625f, 0.19555043f, 0.22565915f, 
    -0.08740216f, 0.12873609f, 0.04699773f, 0.08567309f, -0.07524464f, -0.11594073f, 0.33815250f, -0.02863937f, 
    0.14051618f, -0.07506012f, -0.10208166f, -0.09547867f, 0.07533647f, -0.05380365f, -0.22016189f, -0.40001982f, 
    0.22360228f, -0.10490522f, 0.08327068f, 0.21751384f, 0.26532853f, 0.09740324f, -0.03040482f, -0.08646323f, 
    -0.23290859f, -0.07535257f, 0.11009825f, 0.23723875f, -0.10347212f, 0.00508982f, 0.00354128f, 0.26811868f, 
    0.07251819f, 0.15902844f, -0.02188948f, -0.15053082f, -0.09014829f, 0.13722554f, -0.08369538f, 0.02075186f, 
    0.00581487f, -0.04301997f, -0.12292356f, -0.08300832f, 0.41439945f, 0.10377058f, 0.30655688f, 0.15445735f, 
    -0.03113616f, 0.06150238f, 0.10142338f, 0.09986085f, -0.00456647f, -0.08384240f, -0.25168827f, 0.09512839f, 
    -0.29699811f, 0.06612419f, -0.22864355f, 0.17207177f, -0.09091471f, -0.06907960f, 0.23399606f, -0.12341622f, 
    -0.09940004f, 0.23198873f, 0.11300416f, 0.02401501f, 0.25219023f, -0.21884796f, 0.00157730f, -0.19543567f, 
    0.03772186f, 0.06689058f, 0.00743844f, -0.02376650f, 0.02669835f, 0.30743796f, 0.31831753f, 0.24934672f, 
    0.23891145f, 0.07992967f, -0.12871514f, 0.12826380f, 0.09478794f, 0.10100952f, -0.02206731f, 0.10885799f, 
    -0.00122268f, 0.06450383f, 0.21280676f, 0.03440292f, 0.13978955f, -0.03102708f, 0.08161697f, -0.11144248f, 
    -0.06589343f, -0.12249595f, -0.02512494f, 0.20639411f, 0.04966170f, -0.07789426f, -0.00536747f, -0.10039079f, 
    0.00891197f, 0.11730059f, 0.05317357f, -0.20035875f, 0.17060408f, -0.05009798f, -0.06794678f, -0.04306073f, 
    -0.09341429f, -0.05806565f, 0.14983438f, -0.11104933f, -0.43526968f, 0.00551941f, -0.30534074f, -0.12951873f, 
    0.11077419f, -0.08854026f, 0.06466944f, 0.05669735f, 0.11651843f, 0.11076320f, 0.14893970f, 0.08798321f, 
    0.04887898f, 0.27233300f, 0.02823790f, 0.01302346f, -0.25267431f, 0.08534729f, -0.12776637f, -0.03322029f, 
    0.00554026f, -0.07041769f, 0.02027234f, -0.04997552f, 0.05383909f, 0.00455216f, -0.02283542f, 0.08203083f, 
    -0.09367594f, -0.01580115f, -0.00416371f, -0.05638032f, 0.01676450f, -0.08984052f, 0.01063162f, 0.07456496f, 
    0.06269223f, -0.06787548f, 0.12128519f, -0.07745721f, 0.07097930f, -0.01215898f, 0.06369969f, -0.06512800f, 
    0.09827960f, -0.10271025f, -0.10474151f, -0.05419386f, -0.11234554f, 0.07540055f, 0.07104363f, 0.11638008f, 
    -0.01109202f, -0.03899284f, -0.11102387f, 0.00422157f, -0.01006757f, 0.10419127f, -0.02982821f, -0.07481230f, 
    -0.07006984f, -0.12580441f, -0.02249880f, 0.01895922f, -0.01124488f, -0.09350423f, 0.02268320f, -0.08396762f, 
    0.00714812f, 0.08769178f, -0.07216768f, -0.11425044f, 0.10562924f, -0.02529817f, -0.10013128f, -0.00995777f, 
    0.02823098f, -0.00715447f, 0.02203061f, -0.12782042f, -0.00281124f, 0.08714847f, -0.07949921f, -0.00202639f, 
    0.27331474f, 0.06235951f, 0.06933054f, 0.04652389f, 0.13455480f, 0.42292789f, 0.32758602f, 0.28138483f, 
    0.11869761f, 0.04257695f, -0.13297316f, 0.10501242f, -0.04534026f, 0.08811431f, 0.04832215f, -0.09218094f, 
    0.11225995f, 0.07656006f, 0.19097029f, 0.22392926f, -0.01434454f, 0.07688340f, -0.06868047f, -0.10983599f, 
    -0.11964278f, -0.17759956f, -0.04210478f, -0.10915707f, 0.35484686f, 0.09468865f, -0.07008210f, -0.11351904f, 
    -0.07543914f, 0.35720456f, -0.04090376f, -0.00040432f, 0.03387851f, 0.07104760f, -0.29421502f, -0.06185787f, 
    -0.00600633f, -0.14327976f, -0.01428388f, 0.03382194f, -0.35345736f, -0.12044251f, -0.33003607f, -0.00728654f, 
    0.16568308f, -0.14464629f, 0.15263306f, -0.03322169f, -0.04577609f, -0.00873942f, 0.06376431f, 0.33371380f, 
    0.07356589f, 0.17999205f, 0.02837739f, -0.06047065f, -0.27562454f, 0.05939147f, 0.03426408f, 0.15841493f, 
    0.10273706f, 0.08837602f, 0.03985541f, 0.07301790f, -0.07064992f, -0.06610660f, 0.06092443f, 0.02019148f, 
    -0.15189727f, -0.06260313f, -0.12779652f, 0.05247166f, 0.18208341f, 0.01431148f, 0.06534894f, 0.08025187f, 
    -0.19253989f, -0.06188971f, -0.32806152f, 0.08042742f, -0.35520238f, 0.23138541f, 0.09113069f, 0.21653637f, 
    -0.17065945f, 0.39915833f, -0.09034040f, -0.29382205f, -0.09089319f, 0.00977161f, 0.09357081f, -0.06245922f, 
    -0.10157134f, 0.24831264f, -0.04980917f, 0.12501498f, -0.03580461f, 0.10880056f, 0.16428736f, 0.14941259f, 
    -0.05951897f, -0.27594551f, 0.21578087f, 0.07000867f, 0.44898558f, 0.00028524f, 0.30830979f, 0.10319785f, 
    -0.06717481f, 0.11344241f, -0.07910030f, 0.11928453f, -0.06482043f, 0.02060071f, 0.16486807f, 0.20975611f, 
    -0.04010702f, -0.02782133f, 0.08004677f, -0.02845728f, 0.32237113f, -0.02494321f, 0.25657651f, -0.06847493f, 
    0.14537834f, 0.07745547f, -0.07727449f, 0.11308872f, 0.06021919f, 0.30126393f, 0.20292430f, 0.43023607f, 
    -0.26533696f, -0.00682650f, -0.15875226f, -0.18196124f, -0.04450720f, 0.11033309f, -0.10066666f, -0.17926458f, 
    0.03774137f, -0.06818353f, -0.10525574f, -0.11671539f, -0.00662913f, -0.01742144f, 0.11921979f, 0.09577096f, 
    0.22032563f, -0.07806598f, -0.26536641f, 0.02865165f, 0.13373783f, 0.37814489f, -0.05826245f, -0.10690886f, 
    0.04410110f, 0.00904830f, 0.09780333f, 0.18067381f, 0.05835206f, 0.11210545f, 0.19344452f, -0.40946719f, 
    0.08325554f, -0.06051823f, -0.31016803f, -0.01340435f, -0.19959888f, 0.01928726f, 0.04376702f, 0.04994854f, 
    0.22416517f, 0.11889966f, 0.37860018f, 0.06168296f, 0.09555980f, -0.02672964f, 0.06566264f, -0.08090258f, 
    0.04785718f, 0.01633343f, 0.04942881f, -0.08355151f, -0.38392165f, 0.16164693f, 0.23394322f, 0.31146133f, 
    0.08853284f, -0.06212956f, -0.06999704f, 0.01966275f, -0.07527912f, 0.20990899f, -0.03366613f, 0.13781461f, 
    -0.02609752f, 0.10341015f, -0.27489340f, -0.10399705f, 0.02177418f, -0.04727181f, -0.09224851f, -0.20306891f, 
    0.01715991f, 0.01118266f, -0.12884031f, -0.43227836f, -0.11273443f, 0.32563087f, -0.07419816f, 0.10768126f, 
    0.21639411f, -0.02470447f, -0.15299916f, 0.07821022f, 0.21196900f, 0.24010447f, -0.04013373f, 0.01365604f, 
    0.07284897f, -0.24345598f, -0.12202488f, 0.33795235f, 0.09544508f, -0.11416752f, -0.12107097f, 0.13560627f, 
    -0.09208654f, -0.07169241f, 0.23186365f, 0.06028617f, 0.29647037f, -0.00228560f, -0.12844430f, 0.00312473f, 
    0.20083165f, 0.03456630f, -0.07892121f, 0.04243254f, -0.00322915f, -0.01875177f, 0.17164165f, 0.23556688f, 
    -0.06769609f, -0.06878608f, -0.05137103f, -0.11058536f, -0.25936052f, 0.13167316f, 0.17666709f, 0.22451599f, 
    0.01450795f, -0.09986542f, 0.03036695f, 0.00045406f, -0.07884557f, -0.11991617f, -0.23309195f, -0.17588779f, 
    0.08718916f, 0.06833568f, 0.15714988f, 0.14324431f, -0.12920347f, -0.03636340f, -0.07237945f, -0.07323603f, 
    0.15884990f, -0.03919783f, -0.00044494f, -0.22330754f, -0.07352244f, 0.24527715f, 0.10143276f, 0.28528127f, 
    0.16390614f, 0.36651716f, -0.18533367f, 0.12903860f, 0.16125958f, -0.05549983f, 0.09157512f, 0.04189678f, 
    0.04888014f, -0.34197050f, 0.04639059f, 0.21511534f, -0.18810271f, -0.07689560f, 0.12518556f, 0.23605320f, 
    0.12409212f, 0.32236451f, 0.28138161f, -0.11273618f, 0.15748906f, 0.07846980f, 0.00190830f, -0.09774082f, 
    -0.02229081f, -0.01683842f, 0.08842953f, -0.23579156f, -0.04565875f, -0.03511229f, 0.14599971f, 0.22688638f, 
    -0.10691617f, -0.15928391f, -0.08864725f, -0.04712629f, -0.19066924f, -0.03923042f, 0.01260190f, 0.23138492f, 
    0.15340653f, -0.06850881f, 0.07150699f, -0.06888063f, -0.11982878f, -0.14722897f, 0.14657494f, -0.16896099f, 
    -0.16902408f, -0.10109944f, 0.15026750f, 0.15211001f, -0.04135583f, -0.05846417f, 0.00184327f, 0.00902178f, 
    -0.06928360f, 0.06052234f, -0.15880172f, 0.35987988f, -0.00929128f, 0.38334587f, 0.03145598f, -0.18680134f, 
    0.37196091f, 0.17954969f, 0.29733863f, -0.12771583f, 0.01613116f, 0.04887267f, -0.05199914f, -0.04535605f, 
    0.01032934f, -0.18466714f, 0.06012431f, 0.07948030f, 0.14857195f, -0.05693494f, -0.11926607f, -0.04060239f, 
    -0.05645460f, -0.05839210f, 0.02497670f, 0.00299043f, -0.17817509f, 0.05561649f, -0.03330505f, 0.31026182f, 
    0.04286040f, -0.02872579f, 0.18117535f, -0.11068411f, -0.01260867f, 0.07434635f, -0.09119005f, -0.17254443f, 
    -0.05327686f, -0.05239543f, -0.00156372f, -0.05226913f, 0.07101151f, 0.32712415f, 0.26600951f, 0.19084293f, 
    0.11338067f, 0.09412347f, -0.02755693f, 0.10614518f, -0.08616678f, 0.30525324f, 0.21698181f, 0.38287222f, 
    0.02960164f, -0.04240036f, 0.13389836f, 0.23229697f, -0.02060958f, -0.06864185f, -0.00955826f, 0.06122070f, 
    0.27914265f, 0.04686350f, -0.16124001f, 0.15459739f, 0.22361735f, -0.12539974f, -0.10874221f, -0.10702315f, 
    0.30321637f, 0.04142026f, -0.19915363f, 0.17270638f, 0.32577735f, 0.01410325f, -0.00990573f, -0.02408365f, 
    -0.09661787f, -0.04095294f, -0.03886839f, -0.20261019f, 0.03845488f, 0.05531351f, -0.04528139f, -0.25565106f, 
    -0.12684792f, -0.37830827f, -0.07289963f, 0.02400200f, -0.21339144f, 0.03674076f, -0.31749320f, 0.03976935f, 
    0.17962272f, -0.37458462f, 0.16774887f, 0.05684678f, 0.06904068f, 0.02534389f, -0.14373034f, 0.03373984f, 
    0.00727472f, 0.19406806f, -0.08219101f, -0.04986127f, 0.03033274f, 0.35248366f, -0.28540874f, 0.14224632f, 
    -0.10146412f, -0.05609661f, -0.02893431f, -0.06868303f, -0.04997170f, -0.05237528f, 0.08397870f, -0.12584193f, 
    -0.13932748f, 0.00498307f, -0.11722530f, -0.03705908f, 0.04680528f, -0.11958174f, 0.02402937f, 0.04713447f, 
    -0.12521961f, -0.02573659f, -0.09962050f, -0.13263658f, -0.01987732f, 0.03594504f, -0.00796252f, 0.03190845f, 
    -0.09348245f, 0.06062977f, -0.10368437f, 0.02462222f, 0.09982246f, -0.07896727f, -0.05942293f, 0.06592374f, 
    0.09408861f, -0.00964244f, -0.06278978f, 0.10707121f, 0.00220902f, 0.04217526f, -0.02024480f, 0.02631099f, 
    0.03104511f, -0.10217207f, -0.06907849f, -0.00577013f, -0.01030388f, -0.11493543f, 0.07279592f, -0.05952704f, 
    -0.08735488f, 0.09947140f, -0.11515944f, 0.04442902f, 0.07878420f, -0.10960606f, -0.11200317f, 0.00314496f, 
    -0.02109820f, -0.05800572f, 0.02284931f, 0.06533556f, -0.12980178f, 0.04328368f, -0.07389491f, -0.11935763f, 
    0.30398908f, -0.02569898f, 0.08329290f, -0.11047255f, 0.03072831f, -0.06766278f, 0.04145961f, -0.27129662f, 
    0.02957872f, -0.09914729f, 0.19443896f, -0.10871483f, 0.14147584f, 0.09395872f, 0.08756062f, -0.21611962f, 
    -0.20550939f, 0.11647927f, -0.05457344f, -0.07892312f, -0.13340309f, 0.18475270f, -0.02526672f, 0.06908386f, 
    0.38418019f, -0.16701633f, -0.12138398f, -0.02404029f, 0.11194878f, 0.19188549f, 0.01954811f, 0.03292011f, 
    0.01889542f, 0.11777722f, -0.09686664f, 0.18000685f, 0.25958180f, -0.02134373f, -0.12924968f, 0.06135198f, 
    0.01034824f, -0.02227786f, -0.10870258f, -0.04787118f, 0.10519268f, -0.09805787f, -0.40464446f, 0.29538798f, 
    0.06035697f, -0.09613601f, -0.21530037f, -0.00028376f, -0.00765708f, -0.05352310f, 0.05429692f, 0.05850493f, 
    -0.05285637f, 0.18126343f, 0.05303223f, 0.03254167f, -0.06995012f, -0.35671067f, 0.16001880f, 0.15082017f, 
    0.05212142f, -0.02001568f, 0.08379180f, -0.02957237f, 0.03297007f, -0.14741987f, -0.20514448f, -0.18106419f, 
    0.21088555f, 0.00867069f, 0.09366632f, 0.21889590f, 0.15930766f, -0.11819628f, 0.03455380f, -0.03840829f, 
    0.08732723f, 0.01230299f, 0.20116048f, -0.17932871f, 0.16603073f, -0.08142980f, 0.07071019f, 0.23167081f, 
    0.19996800f, -0.17848244f, 0.13111489f, 0.32963586f, 0.10793911f, 0.13272220f, -0.09369182f, 0.04230613f, 
    0.08187638f, -0.24857736f, -0.03457767f, -0.19501492f, 0.26792663f, -0.06128354f, 0.05959697f, 0.22502233f, 
    -0.13403295f, 0.25888035f, -0.00015317f, 0.10230210f, 0.08589223f, 0.12037579f, -0.26445246f, -0.04459513f, 
    -0.03896168f, 0.06922954f, -0.15370719f, -0.04001001f, -0.10020713f, 0.03735754f, 0.02542534f, 0.15315573f, 
    0.04749900f, -0.00523304f, 0.04668228f, 0.00656337f, -0.15617366f, -0.21134469f, -0.19695036f, -0.02087600f, 
    0.02276241f, -0.01929764f, -0.02218742f, -0.07469111f, 0.06196946f, -0.02322392f, 0.01856868f, 0.11772211f, 
    0.00831467f, -0.12395179f, -0.11344749f, 0.08992657f, 0.07767998f, 0.06284994f, 0.07115557f, -0.13034572f, 
    -0.06873740f, -0.10489793f, 0.00302197f, 0.08371925f, -0.12486833f, -0.08654062f, 0.04069831f, -0.04331396f, 
    -0.13905072f, -0.09196909f, 0.10130351f, -0.08181992f, -0.01913355f, 0.11272577f, -0.09863672f, -0.06940645f, 
    0.08857483f, -0.14318913f, -0.11169847f, -0.01538254f, -0.05902662f, -0.02276070f, -0.06249709f, -0.01641279f, 
    -0.04698823f, -0.12650593f, -0.09202211f, 0.04379845f, 0.09480461f, -0.00213068f, 0.04052122f, -0.12450042f, 
    -0.00523583f, -0.03501568f, 0.10389866f, -0.10835815f, -0.05687086f, 0.08439074f, 0.08174329f, -0.09226680f, 
    0.03218620f, -0.13122623f, 0.03385248f, 0.01309254f, -0.08500931f, 0.09509376f, -0.10733447f, 0.05326165f, 
    -0.07496638f, -0.09872074f, -0.06882875f, -0.16169843f, 0.03842618f, 0.09087103f, 0.01795243f, -0.06959891f, 
    0.15708531f, 0.09852447f, 0.08186359f, 0.12644666f, -0.16792278f, 0.11643204f, -0.02801761f, 0.13988231f, 
    0.23462939f, -0.08584376f, -0.04985766f, -0.27283895f, 0.02415841f, 0.13932365f, 0.10899260f, 0.25583610f, 
    0.11327869f, 0.07638881f, -0.04241420f, 0.16526406f, -0.05691321f, -0.07372637f, 0.10543173f, 0.08861230f, 
    0.02130022f, -0.09179837f, 0.03517613f, 0.05248696f, -0.26434013f, -0.01242772f, -0.24050461f, -0.05278980f, 
    -0.12383685f, -0.02845539f, 0.24167958f, 0.01493047f, 0.37267658f, -0.05670851f, 0.46703053f, -0.02313535f, 
    0.19926178f, -0.24172768f, -0.05129914f, -0.00940638f, 0.05578703f, -0.10868394f, -0.11181770f, 0.00893548f, 
    -0.11021481f, -0.24326567f, -0.02424557f, -0.03206238f, 0.28439149f, 0.10558339f, -0.19643797f, 0.24722005f, 
    0.01425693f, 0.03458808f, 0.13089824f, -0.05515656f, 0.01696985f, 0.01128204f, 0.07135617f, -0.08574212f, 
    -0.14036195f, -0.01768339f, 0.05715599f, 0.06164783f, 0.09025202f, 0.05939117f, 0.07941799f, -0.13691245f, 
    0.08847377f, -0.02696393f, -0.10321017f, 0.07735293f, 0.07422156f, -0.06028181f, -0.06853500f, 0.06812798f, 
    -0.03951893f, -0.05503578f, 0.02968208f, 0.05049958f, -0.15937425f, -0.06237799f, -0.03768632f, 0.10294983f, 
    0.01522211f, -0.13517319f, -0.11997556f, -0.05253364f, -0.02394406f, -0.05290450f, 0.08581289f, -0.02349562f, 
    -0.03623275f, -0.11664305f, 0.00046711f, -0.06427079f, -0.11010496f, -0.00612629f, 0.02861123f, -0.02077789f, 
    -0.11481772f, -0.01480673f, 0.02321711f, 0.02570952f, 0.07274539f, -0.00157113f, 0.02142369f, 0.04121294f, 
    -0.02829228f, -0.07655117f, -0.09366855f, -0.01026870f, -0.14481099f, -0.06836153f, 0.08701585f, -0.14523792f, 
    0.11316335f, -0.11726773f, -0.10185984f, -0.01257347f, 0.04200915f, 0.00123281f, 0.03035447f, -0.11864281f, 
    0.23821138f, 0.11516184f, -0.17781138f, 0.18477103f, -0.12742117f, 0.10886763f, 0.07712331f, 0.40827149f, 
    0.14358620f, 0.04568284f, 0.23280333f, -0.35967800f, 0.06513702f, 0.17437211f, -0.02588112f, 0.07921723f, 
    -0.18185823f, -0.27903450f, -0.05002952f, 0.18046188f, 0.12255232f, -0.12457952f, 0.01862846f, 0.00228899f, 
    0.11745256f, 0.36209553f, -0.09640941f, 0.07338355f, -0.09420927f, 0.08847043f, -0.18048830f, 0.31104779f, 
    0.01479350f, -0.10603073f, 0.30705041f, -0.07076935f, 0.07872886f, -0.08501607f, -0.04503062f, -0.20114405f, 
    0.28478184f, -0.10245816f, -0.22260946f, -0.10269154f, 0.06458191f, -0.03227191f, 0.21008155f, 0.31624556f, 
    0.03681383f, -0.01252632f, 0.08429702f, 0.04091496f, -0.19760138f, -0.37808338f, -0.28218031f, 0.13828631f, 
    0.18310164f, -0.06174623f, 0.00659357f, -0.08085388f, 0.07988825f, 0.16911076f, 0.15638360f, -0.13651747f, 
    0.03222048f, 0.01955208f, -0.14712459f, 0.08277931f, 0.22167951f, 0.02691423f, -0.06973651f, -0.01517201f, 
    -0.16176851f, 0.04273907f, -0.10914919f, 0.01490013f, -0.18018925f, 0.10829544f, -0.08388823f, 0.03853548f, 
    -0.23721126f, -0.06684557f, -0.01464381f, -0.23309121f, -0.07575684f, 0.03107888f, -0.08716556f, 0.06502479f, 
    -0.06894290f, 0.45286435f, -0.08887620f, 0.09545886f, 0.14711235f, 0.05213898f, 0.05001847f, -0.00924645f, 
    -0.05247593f, -0.03967778f, -0.02935239f, 0.01942766f, 0.11240406f, 0.09740001f, 0.06735871f, 0.14566630f, 
    0.00889041f, 0.33922404f, -0.14364852f, 0.35905802f, -0.01194405f, -0.08944338f, 0.25097656f, 0.03136813f, 
    0.11941243f, 0.29780066f, -0.09597544f, -0.09255514f, 0.12535666f, -0.02762886f, 0.34464902f, -0.11354026f, 
    0.22334720f, 0.11332753f, -0.09927536f, 0.12358931f, 0.09100863f, -0.06342011f, 0.00964378f, 0.08824544f, 
    -0.01620862f, 0.10742345f, 0.15536125f, 0.19632708f, -0.02301402f, -0.01313712f, 0.08091205f, -0.09561722f, 
    0.08735970f, 0.10038838f, -0.32257590f, 0.26832673f, 0.14685164f, -0.06495602f, -0.11903842f, 0.06887420f, 
    0.26595399f, 0.26383343f, -0.18647127f, -0.09764747f, 0.20132212f, 0.11096200f, -0.05606632f, 0.11872220f, 
    0.12201338f, -0.07404443f, 0.06929307f, -0.19285387f, 0.11866575f, -0.12251586f, 0.39328343f, -0.28206024f, 
    0.11178315f, -0.32612312f, 0.05233658f, 0.09818854f, -0.06713929f, 0.07081938f, -0.19900195f, -0.13421656f, 
    0.21205109f, -0.04869973f, 0.24659672f, 0.11792797f, 0.01842718f, -0.04105792f, -0.00721420f, 0.12389380f, 
    0.07265905f, 0.09096775f, 0.07660728f, 0.09211423f, -0.06240328f, 0.35344973f, -0.22779188f, 0.26248801f, 
    0.20998260f, 0.03549266f, -0.03001926f, -0.08251042f, 0.09921958f, -0.14213696f, 0.03001334f, -0.63338846f, 
    0.04132682f, -0.08036260f, 0.21977150f, 0.10001173f, 0.04807131f, 0.10406682f, -0.09565760f, 0.38285348f, 
    -0.13998705f, 0.11356417f, -0.20875326f, 0.21884295f, -0.09986141f, 0.08493417f, 0.03555977f, -0.03423555f, 
    0.37299728f, 0.21103610f, 0.06618029f, -0.12133092f, -0.07240741f, 0.14628710f, -0.07116160f, 0.01700342f, 
    0.00617069f, 0.08398358f, 0.00090555f, -0.00541800f, -0.12303158f, 0.02515049f, 0.08854663f, 0.09368774f, 
    0.00319621f, -0.33754522f, 0.07775658f, -0.12345593f, 0.06654771f, 0.11449914f, 0.20357263f, 0.10263044f, 
    -0.13637219f, -0.11456556f, -0.28503808f, 0.02013799f, -0.01892955f, 0.08670487f, 0.02785358f, -0.03913528f, 
    -0.03331569f, -0.08032144f, 0.05164006f, 0.00418193f, 0.25957569f, -0.00345024f, -0.10423420f, 0.08248983f, 
    0.30619320f, -0.00690501f, 0.04987426f, -0.06567699f, -0.12344586f, -0.03340980f, -0.05678833f, -0.02996189f, 
    -0.22665037f, 0.02618713f, -0.38703734f, 0.00567373f, -0.02164585f, 0.09736577f, 0.05490394f, 0.25104052f, 
    -0.14574613f, -0.09866143f, 0.08168124f, -0.18654080f, 0.11394339f, 0.23832057f, -0.05401820f, -0.22041425f, 
    0.09024489f, -0.14215109f, 0.12987116f, 0.05034083f, 0.05523558f, 0.17810066f, 0.03781513f, -0.03446528f, 
    -0.01644168f, -0.02051103f, 0.03072538f, 0.16400443f, 0.01938311f, 0.10890418f, 0.23912509f, 0.09324501f, 
    -0.06334557f, 0.02758990f, 0.16652568f, -0.05540338f, 0.15440091f, 0.03046828f, -0.13452238f, 0.13179915f, 
    0.07187799f, 0.44349915f, -0.14632502f, 0.22198893f, 0.04354391f, -0.07967893f, 0.17922209f, -0.07070899f, 
    0.09637795f, 0.19166942f, 0.02590604f, 0.10763558f, -0.17850028f, -0.16545977f, 0.10405272f, 0.03689360f, 
    0.22292623f, -0.04801870f, 0.00625009f, -0.00066047f, -0.08401117f, 0.01803818f, 0.24125239f, 0.22113837f, 
    -0.25752872f, 0.08069525f, -0.10430533f, -0.25457323f, 0.09624293f, 0.11192990f, 0.04885963f, 0.18960190f, 
    0.01145582f, -0.01389570f, -0.23909779f, -0.01100724f, 0.04079296f, 0.06482249f, -0.10704165f, -0.33816329f, 
    -0.07697429f, -0.12371320f, -0.10543481f, 0.11593519f, -0.13223524f, 0.18254118f, -0.02007801f, -0.01306423f, 
    -0.04415676f, 0.37611124f, 0.08678954f, 0.22472417f, -0.18242645f, 0.06917048f, 0.26765457f, -0.37183529f, 
    0.04505267f, -0.20917240f, 0.00730422f, 0.10305700f, 0.20316207f, 0.03433618f, 0.01479816f, 0.03732970f, 
    0.32417241f, 0.05527189f, 0.13192007f, 0.24294336f, 0.05612509f, 0.07830837f, -0.15736687f, 0.11334516f, 
    0.06742357f, 0.08675159f, -0.02908113f, 0.11246565f, -0.13510668f, 0.13086385f, 0.00462190f, 0.16577561f, 
    -0.08761915f, 0.02559288f, 0.01383287f, 0.06792443f, 0.03481376f, 0.00605699f, -0.27029157f, -0.02931727f, 
    0.11695031f, 0.02304288f, 0.15838490f, 0.15700589f, -0.15191095f, -0.12828636f, -0.06717952f, 0.02960143f, 
    0.08576982f, 0.03721937f, -0.08235797f, -0.06392528f, 0.19032004f, 0.21128547f, -0.08484998f, 0.03759414f, 
    0.32688135f, 0.08314884f, 0.09033133f, 0.09621894f, 0.01465285f, 0.16048934f, 0.06612121f, -0.09954028f, 
    -0.11257263f, -0.28182942f, -0.07342706f, 0.05293066f, -0.11120326f, 0.04203268f, 0.05288804f, 0.02256071f, 
    -0.03854754f, 0.22899805f, -0.15528215f, -0.09484777f, 0.22115949f, 0.09643072f, 0.13363256f, 0.15195282f, 
    0.11555111f, -0.11282290f, 0.12639239f, -0.26392400f, 0.00676117f, 0.03453853f, -0.14105405f, -0.02889666f, 
    0.12210295f, -0.29104316f, -0.03132477f, 0.03582007f, -0.01301602f, -0.03036686f, -0.16374677f, 0.17205194f, 
    0.17730096f, -0.05054407f, 0.03822008f, -0.10371559f, -0.02488233f, 0.25726190f, -0.04746748f, -0.12199517f, 
    0.18691622f, 0.09903444f, -0.21086061f, 0.17572272f, 0.17448209f, -0.08359087f, 0.03203666f, 0.31254277f, 
    0.05973002f, -0.03473358f, 0.35232955f, 0.05756766f, -0.21274896f, -0.01127581f, 0.03323669f, 0.14978480f, 
    -0.43886018f, -0.07600365f, 0.06316049f, -0.16599241f, -0.06149564f, 0.09191895f, -0.08864648f, -0.03167024f, 
    -0.05279633f, 0.43667060f, 0.07429964f, 0.11336736f, -0.14906162f, -0.07690553f, -0.00236694f, 0.24977018f, 
    -0.02797989f, -0.01202472f, 0.29464728f, -0.07987115f, 0.15078346f, -0.05164576f, 0.37872949f, 0.07409929f, 
    0.05426021f, 0.25515941f, -0.24553879f, 0.32031673f, -0.03776724f, -0.05036362f, 0.33143741f, 0.01821057f, 
    0.04331682f, 0.10885821f, 0.04466021f, -0.07286864f, 0.05115432f, -0.23179370f, 0.02980304f, -0.18855840f, 
    0.11459146f, 0.11506483f, 0.08801711f, 0.03220678f, 0.04210279f, 0.32762152f, -0.04998892f, 0.11763787f, 
    -0.12046593f, -0.11617573f, -0.35596144f, 0.03148468f, -0.17482977f, -0.12629379f, 0.07410207f, 0.19976610f, 
    -0.01013992f, 0.09282197f, 0.14789131f, 0.12835801f, -0.05112065f, 0.39230481f, 0.03740935f, -0.20478848f, 
    0.33131263f, -0.14705937f, 0.34273398f, 0.00691973f, 0.07912264f, -0.09258448f, 0.01298747f, 0.09601899f, 
    0.05473195f, 0.03651328f, 0.09592881f, 0.20558520f, 0.08227113f, -0.09221047f, -0.24904378f, -0.05066163f, 
    -0.02898820f, -0.04496156f, 0.19709399f, -0.12010342f, 0.03284892f, -0.11144082f, 0.37836429f, 0.29260367f, 
    -0.13061504f, 0.18415427f, 0.14224400f, -0.01804028f, -0.08017874f, 0.09032089f, 0.10329660f, -0.14882693f, 
    0.08744769f, 0.00865420f, 0.02777175f, -0.08697924f, 0.12520367f, 0.04913718f, 0.13521270f, 0.00643491f, 
    -0.15689962f, 0.12020281f, -0.07614516f, -0.07790659f, -0.05136114f, -0.02608506f, 0.29697666f, -0.14083798f, 
    0.06369255f, -0.07917456f, 0.38240495f, 0.07591619f, 0.09821767f, 0.06570285f, 0.03536306f, -0.20136838f, 
    0.02728615f, -0.00875471f, 0.10508236f, 0.17248875f, -0.07946888f, 0.00972596f, -0.02993361f, 0.05892134f, 
    0.01838358f, 0.09848361f, -0.00179049f, 0.03753232f, 0.07057003f, -0.18758418f, -0.05766223f, 0.01310810f, 
    -0.04347165f, 0.00404507f, 0.03713049f, 0.08201387f, 0.08216383f, 0.07215007f, -0.32084858f, 0.08771525f, 
    0.03089968f, 0.23711024f, -0.09796575f, -0.11851378f, -0.17701681f, 0.04011707f, -0.16411337f, 0.16929218f, 
    0.03713479f, -0.34513870f, 0.12633660f, 0.00109672f, 0.00502584f, -0.01129326f, -0.12252929f, 0.16246198f, 
    -0.08891647f, 0.08027156f, -0.03691107f, 0.05547153f, 0.09062126f, 0.02291801f, 0.02514501f, 0.00095923f, 
    -0.14470282f, -0.00070871f, 0.08923398f, -0.11100396f, -0.09933203f, -0.07914717f, 0.06088098f, 0.01339042f, 
    0.13641895f, 0.01289769f, 0.30218017f, -0.01082786f, 0.18463944f, 0.01627742f, 0.05121247f, 0.02276844f, 
    0.12103572f, -0.06963349f, 0.34986889f, -0.08522358f, -0.15503235f, -0.11239040f, 0.06807497f, 0.28019044f, 
    -0.34181666f, 0.07592657f, -0.05110923f, -0.16793428f, 0.02397640f, 0.00527583f, -0.15024556f, -0.08056834f, 
    0.10706001f, 0.17291114f, 0.05522167f, 0.26653069f, -0.31943029f, 0.01453430f, -0.10816017f, 0.11097172f, 
    -0.08570508f, 0.35945737f, 0.11907613f, -0.06265201f, 0.25876611f, 0.09497599f, 0.42732725f, -0.18027693f, 
    0.24880071f, -0.10733537f, 0.06776287f, 0.02843238f, -0.00151934f, 0.04775275f, 0.12306748f, 0.22620058f, 
    0.07689197f, 0.10594764f, 0.05000247f, 0.02400336f, -0.08119962f, -0.20980915f, 0.08660182f, 0.06070241f, 
    -0.02680632f, 0.06290509f, -0.01118582f, -0.08755466f, 0.07800011f, 0.11075255f, 0.00753873f, 0.05701625f, 
    -0.09557854f, -0.11217181f, -0.10863540f, -0.08059138f, 0.07068183f, -0.07142118f, 0.03713548f, -0.10803952f, 
    -0.10739058f, -0.00082159f, 0.08083203f, -0.12142482f, 0.01616905f, -0.06582925f, 0.09076783f, -0.11223557f, 
    0.06806797f, -0.08483881f, 0.05377790f, -0.09618411f, -0.03579111f, -0.03953273f, -0.02621810f, -0.06575595f, 
    -0.05142682f, 0.05732147f, -0.11602318f, -0.03361825f, -0.00368949f, 0.12113148f, -0.07486079f, -0.02441172f, 
    0.01467009f, -0.11651644f, -0.10553618f, -0.09859537f, -0.00027614f, 0.07883167f, -0.12958300f, -0.12291575f, 
    -0.08566097f, 0.03920549f, -0.08518629f, -0.09981030f, 0.04261634f, -0.01454499f, 0.05186461f, 0.03201920f, 
    -0.04068273f, -0.09525982f, 0.05544851f, -0.01069146f, 0.06535508f, 0.07389588f, 0.04072597f, -0.12629803f, 
    -0.10208026f, 0.00716826f, 0.09729530f, -0.07637535f, 0.04403305f, 0.07572228f, 0.06357872f, -0.05554867f, 
    -0.10289753f, -0.04851548f, 0.09971730f, -0.11656830f, -0.13354895f, -0.06276834f, -0.10620764f, -0.07266895f, 
    -0.11971916f, 0.04511289f, -0.10462243f, -0.04401188f, -0.07586814f, -0.09931860f, -0.09234688f, -0.09444846f, 
    0.06416017f, 0.09042297f, -0.10561473f, 0.08185049f, -0.04222795f, -0.15139398f, 0.01731919f, -0.04821390f, 
    -0.03078090f, -0.02972651f, 0.11353514f, 0.10232094f, -0.02731541f, -0.02706693f, -0.07999134f, 0.03295132f, 
    -0.06019649f, -0.10621843f, -0.13410297f, 0.02922684f, 0.04830710f, -0.03048795f, -0.11609785f, 0.02630783f, 
    -0.01011090f, 0.10575338f, -0.01275617f, -0.02739935f, 0.10818414f, -0.10259376f, -0.09223998f, -0.02104015f, 
    0.11759579f, 0.01338321f, 0.08883128f, -0.02677894f, 0.09784414f, -0.03090473f, -0.05735829f, -0.13720275f, 
    -0.02764749f, -0.09358200f, 0.06121644f, -0.07864797f, 0.08823827f, -0.12674166f, 0.10109201f, -0.06290399f, 
    -0.10475720f, -0.00035797f, 0.02942110f, -0.09234080f, -0.04578016f, 0.01750393f, 0.10298333f, -0.10891584f, 
    -0.13247710f, 0.00487302f, -0.14577304f, 0.08844747f, 0.10641298f, -0.12374113f, 0.09591223f, 0.05772270f, 
    0.08562429f, 0.09736852f, -0.02205299f, -0.08738597f, -0.12705465f, -0.13756292f, 0.03540479f, 0.00171460f, 
    0.03753765f, 0.01817124f, -0.08245070f, -0.15296564f, -0.00611381f, -0.07609436f, 0.11244221f, 0.01039218f, 
    0.09689076f, 0.03447874f, -0.01855394f, 0.02542020f, -0.06682196f, 0.11475700f, -0.13630368f, -0.04194001f, 
    -0.09612047f, -0.05480487f, 0.00352486f, -0.01696217f, -0.07419656f, -0.04157914f, -0.11923996f, -0.01022018f, 
    -0.07735573f, -0.04841971f, -0.10963175f, 0.00131074f, 0.08045586f, -0.01635314f, -0.03725635f, -0.09304314f, 
    0.13531026f, -0.03024234f, -0.00275672f, -0.03782348f, -0.00460120f, -0.10516386f, 0.26934361f, -0.06543151f, 
    -0.19201054f, -0.00436376f, -0.09145015f, 0.17198616f, -0.05009191f, -0.08046945f, -0.01096550f, -0.11525378f, 
    -0.02072408f, 0.06774219f, -0.40641457f, 0.47708124f, 0.12560263f, 0.31017548f, -0.09244398f, -0.21808587f, 
    0.11940759f, 0.36183596f, -0.06052266f, 0.09605727f, 0.08510692f, -0.11504482f, 0.00816950f, -0.07601145f, 
    -0.01604579f, -0.05372705f, 0.04582961f, -0.02283731f, 0.21552964f, -0.03949074f, 0.10473435f, -0.15225278f, 
    0.05566889f, -0.19992384f, 0.18142578f, 0.01196902f, -0.14339860f, -0.01590112f, -0.27955693f, 0.12196641f, 
    0.16748899f, 0.09057816f, 0.24834111f, 0.06758989f, 0.06016234f, -0.10076818f, -0.07386140f, -0.00425892f, 
    -0.05562922f, 0.12267406f, 0.01914278f, 0.05773606f, -0.03618215f, 0.47844210f, 0.24297751f, 0.20830655f, 
    0.11820475f, -0.05305135f, 0.09152165f, 0.08388121f, 0.04133918f, 0.03276255f, 0.11773036f, -0.08216442f, 
    0.08226772f, 0.08840596f, -0.23423146f, 0.15259214f, -0.08564503f, 0.03851799f, 0.02254728f, 0.33065364f, 
    -0.11241053f, 0.07802483f, 0.08066102f, 0.21632932f, 0.17201917f, 0.17545308f, 0.09191509f, -0.27258220f, 
    -0.37624151f, -0.05437555f, 0.19380632f, -0.01887340f, -0.08926263f, 0.01202535f, -0.05491474f, -0.05690648f, 
    -0.08914790f, 0.29633373f, -0.08912528f, -0.05644817f, 0.13432279f, 0.03942375f, 0.12688218f, 0.13774422f, 
    0.08240988f, -0.18948390f, 0.32215109f, 0.12401630f, -0.30873442f, -0.05664237f, -0.04899552f, 0.05059116f, 
    -0.09825753f, 0.05221848f, -0.03226405f, 0.08214694f, 0.01772866f, -0.03187978f, 0.21241416f, 0.12901162f, 
    0.13519426f, 0.24444802f, 0.03104177f, 0.08867175f, 0.10583212f, 0.04746480f, 0.00721884f, -0.12613986f, 
    0.02834612f, -0.02988116f, 0.08971471f, -0.11319011f, -0.09509188f, 0.21658099f, -0.06909464f, -0.09429371f, 
    0.16608149f, 0.05095643f, -0.11663067f, 0.23316383f, -0.13996445f, 0.07320145f, -0.04159042f, -0.09457819f, 
    -0.05675711f, -0.08777928f, -0.01306933f, -0.06204048f, -0.09537097f, 0.40699285f, 0.00239442f, 0.10880440f, 
    0.04872705f, 0.15233245f, 0.07214468f, -0.16111249f, 0.24844037f, 0.04669609f, -0.04620159f, -0.04388702f, 
    -0.00914174f, -0.22777537f, 0.01501557f, 0.15527388f, -0.09611673f, 0.09553593f, -0.18635033f, 0.33214346f, 
    -0.10288125f, 0.21022989f, 0.23541853f, -0.02067072f, 0.00552550f, -0.03268350f, -0.24744967f, -0.14407676f, 
    -0.11032995f, -0.03258894f, -0.03826720f, -0.18011631f, -0.06129180f, -0.07216680f, 0.30170712f, 0.34669656f, 
    -0.03769711f, 0.07798637f, -0.11296093f, -0.07231812f, -0.10906151f, 0.08674284f, 0.05016462f, 0.22497359f, 
    -0.10470171f, -0.09542298f, 0.06515145f, 0.11332157f, -0.03597650f, 0.10427435f, -0.02194909f, -0.03131774f, 
    0.08193054f, 0.02461711f, -0.02196322f, -0.02147530f, -0.07853875f, -0.05225230f, -0.07450194f, 0.07611977f, 
    -0.01203478f, 0.03532535f, 0.10156334f, 0.00770991f, -0.08590431f, -0.06474523f, -0.00469866f, -0.09227815f, 
    -0.07891317f, 0.06323982f, -0.03409467f, -0.02152738f, -0.04886596f, -0.01500033f, -0.06062891f, 0.06555273f, 
    0.02751413f, -0.03312733f, 0.05174052f, 0.02146356f, 0.06962162f, -0.08466034f, -0.06088985f, -0.01642066f, 
    0.11110626f, -0.00134258f, -0.06718843f, -0.07565601f, 0.06337454f, -0.09753947f, -0.13406308f, -0.03233766f, 
    0.07800694f, 0.09582841f, 0.02419835f, 0.13171910f, -0.02493569f, -0.04325506f, -0.07428376f, 0.00082513f, 
    -0.02442524f, -0.08299701f, -0.10705411f, -0.02149430f, 0.09783833f, -0.06074520f, -0.14497937f, 0.08215297f, 
    -0.11450152f, -0.06559794f, 0.13083731f, 0.10230301f, 0.00109570f, -0.20160356f, 0.08128162f, 0.11418696f, 
    0.28850359f, -0.10017904f, 0.16094871f, -0.05019248f, 0.22651838f, -0.08742858f, -0.02507569f, 0.27174625f, 
    0.17379150f, 0.11127589f, 0.09842370f, -0.26312059f, -0.04469900f, -0.02473894f, -0.11566177f, 0.23813948f, 
    -0.22127081f, 0.19985260f, -0.23892921f, 0.29168910f, -0.05689149f, -0.19991954f, -0.04088088f, -0.03890865f, 
    0.07340071f, 0.07053997f, -0.08768931f, -0.08000193f, 0.01862480f, -0.00578853f, -0.20515454f, 0.21386823f, 
    -0.04273146f, -0.06845792f, 0.21708564f, -0.13215251f, 0.53627938f, -0.04014485f, 0.18894379f, 0.03793897f, 
    0.20163731f, -0.05933593f, -0.07879829f, -0.11717425f, 0.01269673f, 0.11938272f, 0.04202266f, 0.24384353f, 
    0.07459208f, 0.09885632f, -0.10036884f, 0.11571954f, 0.31971386f, -0.09216384f, -0.25162452f, 0.07587038f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.05077497f, 0.12180784f, 0.22679946f, 0.08555431f, 0.05155911f, 0.11148553f, -0.15432069f, 0.16875225f, 
    -0.12999772f, -0.12415560f, 0.01856456f, -0.01650757f, 0.11548313f, 0.08321606f, -0.10059138f, -0.12655468f, 
    -0.10638045f, 0.06154421f, 0.08856933f, 0.20452346f, 0.01735252f, -0.08013280f, -0.02211281f, -0.13740759f, 
    0.04573634f, 0.24849336f, 0.00324241f, 0.23202032f, 0.06592080f, 0.01078714f, 0.01461228f, 0.01568193f, 
    0.02387203f, 0.04529124f, -0.01069807f, 0.00377406f, -0.03091794f, -0.01961930f, 0.16273312f, -0.01054959f, 
    0.01306501f, 0.12515782f, 0.04841890f, -0.09644039f, -0.14456919f, 0.13146678f, 0.03766290f, 0.09325649f, 
    -0.04134604f, 0.13440028f, 0.07680102f, -0.12008533f, 0.01281644f, 0.09697195f, -0.03100411f, 0.10693747f, 
    0.06802382f, -0.09176990f, 0.09929676f, -0.03868718f, 0.15978174f, 0.14024048f, 0.00057517f, 0.01732101f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.10728384f, 0.19828142f, -0.41046095f, 0.16684817f, -0.37408689f, -0.15265468f, 0.21418221f, -0.19038022f, 
    -0.12317461f, 0.06266925f, 0.07820790f, -0.27913231f, -0.21106124f, 0.00714190f, -0.05894608f, -0.03184974f, 
    0.29303661f, 0.04087916f, -0.35429391f, -0.21773370f, 0.09490986f, -0.13486946f, 0.16737895f, 0.03556679f, 
    0.09906705f, -0.01690452f, 0.07191481f, -0.31450990f, 0.06189172f, -0.14542273f, 0.02313489f, -0.06842805f, 
    0.11377692f, -0.36206073f, 0.32584691f, 0.14088820f, -0.10473914f, 0.36579424f, 0.16724940f, -0.03439276f, 
    0.27400330f, -0.03555534f, 0.01326977f, -0.09540702f, 0.02035595f, -0.57860351f, -0.17881621f, 0.04012150f, 
    -0.31029487f, -0.05091587f, 0.03171912f, 0.13456663f, -0.48953772f, 0.14362223f, 0.09450009f, -0.52546734f, 
    0.01154031f, 0.04313626f, -0.13660766f, 0.17094009f, -0.37030369f, -0.05423684f, 0.06668351f, -0.39691409f, 
    0.14552768f, 0.11550587f, 0.51138186f, 0.03967011f, -0.08990832f, -0.34694132f, -0.02515315f, 0.00606243f, 
    -0.06599844f, -0.02225074f, -0.16976093f, -0.06854167f, 0.22226879f, 0.10131460f, -0.18703517f, -0.03510179f, 
    -0.14998308f, -0.04707176f, -0.37251189f, -0.00113256f, -0.04724640f, 0.04063693f, 0.04416224f, -0.12482327f, 
    0.17746048f, 0.15610625f, 0.22077708f, 0.44998237f, -0.26586944f, -0.07343034f, -0.04721833f, 0.12830371f, 
    -0.06842103f, 0.14918052f, 0.09012292f, -0.08373157f, 0.20595963f, 0.01100856f, 0.18951902f, 0.08511892f, 
    -0.40656587f, 0.06330102f, 0.10074007f, 0.33459929f, -0.06208250f, -0.15704873f, -0.36730283f, 0.22592750f, 
    0.27082664f, -0.36270013f, -0.11164668f, 0.24033780f, -0.25294027f, -0.32016259f, -0.07894175f, -0.12519538f, 
    -0.08716564f, -0.02248698f, -0.06054588f, 0.03752021f, -0.21531779f, 0.01956835f, -0.07688070f, 0.05262053f, 
    -0.27123830f, 0.09093203f, 0.11233676f, -0.25864801f, 0.09189108f, -0.15697776f, 0.26635036f, 0.33532673f, 
    0.09071958f, -0.07171728f, -0.52978754f, 0.17883642f, 0.13617037f, -0.20394817f, 0.26302716f, -0.14199014f, 
    -0.15448259f, -0.06411462f, 0.04800577f, -0.64795214f, -0.05365874f, -0.01206309f, 0.19476046f, 0.06311935f, 
    0.12548669f, 0.03638295f, -0.03510383f, -0.43064851f, 0.16435470f, -0.27742565f, 0.02441430f, -0.04352333f, 
    0.04440523f, -0.51246256f, -0.33601296f, -0.02162014f, 0.28634015f, -0.04206633f, -0.18390806f, -0.07666649f, 
    0.13066047f, 0.19991666f, -0.11441261f, 0.12451561f, 0.00431605f, 0.36214378f, -0.38654554f, -0.19082232f, 
    -0.39290851f, -0.09188828f, -0.40831223f, 0.14510950f, -0.09900452f, -0.20913634f, 0.24515031f, 0.27263543f, 
    -0.07119265f, -0.06627420f, 0.00203947f, -0.22239344f, -0.21481560f, 0.23677418f, -0.14643762f, 0.03181155f, 
    -0.02696769f, -0.09556935f, -0.20229191f, -0.24740964f, -0.07379072f, -0.10961302f, -0.45849892f, 0.09329537f, 
    -0.05101410f, 0.01846559f, 0.23387140f, -0.26939058f, -0.38311863f, -0.55827510f, 0.11989854f, -0.01450329f, 
    -0.05327461f, -0.09004173f, -0.05798675f, 0.02704147f, 0.05956391f, -0.09396287f, 0.06450661f, -0.01342578f, 
    0.21750155f, 0.21357143f, -0.19706199f, -0.07774188f, 0.33123836f, 0.30554852f, -0.47360089f, 0.00261926f, 
    -0.76385981f, 0.21612850f, -0.21714208f, -0.10820850f, 0.00019298f, 0.23370585f, -0.51272607f, -0.08439790f, 
    0.34465894f, 0.04342750f, 0.07456784f, -0.43995786f, -0.13216686f, -0.34446347f, 0.18872429f, 0.01476808f, 
    0.12559696f, 0.25950518f, 0.18042570f, -0.00710806f, -0.02527239f, -0.11544265f, -0.10554061f, -0.19034003f, 
    0.04338304f, -0.10173841f, -0.00480160f, 0.14052120f, -0.00887128f, -0.18027288f, 0.06265903f, -0.01918214f, 
    0.27341571f, -0.19957884f, -0.13673936f, -0.30107856f, -0.50570321f, 0.03449384f, -0.31600031f, -0.28253400f, 
    0.03649895f, -0.09874503f, 0.14483660f, -0.01367130f, 0.11113900f, 0.00137841f, 0.23757449f, -0.10684474f, 
    0.17081127f, -0.09062023f, 0.24779490f, 0.06338286f, -0.01032351f, -0.02991225f, 0.05668582f, -0.09027437f, 
    0.10502290f, -0.04640548f, -0.11682672f, -0.68130594f, 0.29973474f, -0.09170005f, -0.07638079f, 0.05562927f, 
    0.06012603f, 0.24982168f, 0.14191583f, 0.09939799f, 0.07726736f, 0.06187620f, -0.17405637f, -0.05213671f, 
    -0.13083391f, -0.39437664f, 0.02846052f, -0.12810032f, -0.05278015f, -0.34076273f, 0.11253756f, -0.05259793f, 
    -0.29413199f, -0.11873646f, 0.00347877f, -0.19187400f, 0.01599068f, -0.10379761f, 0.10870351f, 0.12807730f, 
    -0.03390311f, 0.06338657f, -0.15761806f, 0.13148560f, -0.11352055f, 0.09829681f, -0.02473630f, -0.05430216f, 
    0.10442112f, 0.01494402f, -0.31832165f, 0.32909167f, -0.15052404f, 0.26053464f, 0.02122912f, -0.06181350f, 
    -0.11917916f, -0.04562031f, -0.07853334f, -0.14157718f, -0.05287948f, 0.14070109f, 0.01590728f, -0.07917900f, 
    -0.10334313f, 0.10121508f, 0.08924384f, 0.21347165f, 0.07828908f, -0.07084532f, -0.27215773f, 0.00731215f, 
    0.18835042f, 0.14818020f, 0.15373868f, 0.19234461f, -0.35402632f, -0.17681703f, 0.15004168f, -0.06913947f, 
    0.12686394f, -0.29888421f, 0.25687912f, -0.10586534f, -0.32855788f, -0.25481507f, 0.08641453f, 0.00352249f, 
    -0.14179419f, -0.10337541f, 0.03448537f, -0.53121948f, 0.02669520f, -0.01344929f, 0.02946417f, 0.04561133f, 
    0.09859945f, 0.16038764f, 0.29542819f, -0.35772029f, 0.04783683f, -0.12473530f, -0.28363222f, -0.04979677f, 
    0.12667347f, 0.02031604f, 0.01550977f, -0.09092769f, 0.01468174f, -0.24756615f, 0.03489672f, -0.27185160f, 
    -0.42515078f, 0.34851676f, -0.13818236f, -0.28236666f, -0.05307094f, -0.10239042f, -0.05436631f, -0.01499751f, 
    -0.07611920f, -0.17119069f, 0.01839415f, -0.68323326f, 0.09769579f, 0.10693938f, -0.11911648f, 0.02513368f, 
    0.04674226f, 0.08309554f, -0.16091180f, -0.43328807f, 0.07009327f, 0.05231759f, -0.41987076f, 0.00494986f, 
    -0.43613890f, 0.01256226f, -0.00625343f, 0.19451970f, 0.10458157f, 0.33290619f, 0.18220483f, -0.12619255f, 
    0.11356515f, 0.05375360f, -0.10109792f, 0.05739015f, -0.06736226f, -0.52019501f, 0.00631046f, 0.02230624f, 
    0.33310121f, 0.35409531f, -0.00456740f, -0.36181897f, -0.05144515f, 0.20765312f, 0.12960778f, -0.05725955f, 
    -0.07394715f, -0.10463392f, -0.27126133f, -0.44711348f, 0.10309550f, -0.40059951f, 0.08039616f, -0.02191227f, 
    -0.04360903f, 0.00083457f, 0.09505641f, -0.16960190f, -0.03154942f, 0.03707921f, 0.07557340f, 0.16434757f, 
    -0.26581571f, -0.33030087f, -0.09612916f, -0.05173536f, 0.27144605f, 0.25827894f, 0.25208417f, -0.16337346f, 
    0.03924683f, -0.03858786f, -0.15812677f, 0.20391041f, -0.13744839f, -0.27482638f, 0.16518763f, 0.06915426f, 
    0.07124481f, -0.02406816f, 0.24858914f, 0.12690790f, -0.11528274f, 0.06550305f, 0.00780387f, 0.05073249f, 
    -0.03518954f, -0.31947476f, -0.22625411f, -0.03381148f, -0.33483556f, 0.08190861f, -0.17562830f, -0.02825670f, 
    0.04891798f, 0.19191079f, -0.16133347f, -0.31246978f, -0.24497144f, 0.00600866f, -0.16962127f, 0.06715553f, 
    -0.03084472f, -0.20420277f, -0.06830923f, 0.30249506f, -0.12852331f, 0.09982996f, 0.11537171f, -0.40966225f, 
    0.24814919f, -0.12857634f, -0.12078860f, 0.10819069f, 0.24476101f, 0.18817477f, 0.18814161f, 0.10114807f, 
    0.02065504f, 0.02604467f, -0.06956200f, -0.49747723f, 0.02959053f, -0.20697166f, 0.01919417f, 0.12948638f, 
    -0.04016046f, -0.44619671f, -0.18308699f, 0.19261621f, 0.29157853f, -0.30026451f, 0.18875836f, -0.09228179f, 
    0.07328559f, -0.05853665f, 0.15587841f, 0.17919514f, 0.14181912f, 0.19615950f, -0.19376412f, 0.01261794f, 
    -0.49085954f, -0.10293676f, 0.29456767f, -0.19213830f, -0.05353262f, -0.09829845f, -0.06221409f, -0.11181937f, 
    0.15022580f, 0.15981615f, 0.12543301f, -0.45908737f, -0.19470882f, -0.27349967f, 0.20083360f, 0.06285845f, 
    0.04606453f, -0.18262102f, -0.24707301f, -0.58642644f, -0.33797124f, 0.11925480f, 0.18510827f, 0.05465488f, 
    -0.49096271f, -0.18683179f, -0.00622903f, 0.04667033f, -0.04783247f, -0.11235690f, -0.08176482f, 0.00250457f, 
    -0.34572721f, -0.55724424f, 0.15200230f, -0.18540409f, -0.18968701f, -0.24394399f, 0.34290993f, 0.01183123f, 
    -0.12730795f, 0.09336305f, 0.03221586f, 0.22568300f, 0.06658567f, -0.61319667f, -0.05515705f, 0.29625788f, 
    -0.49968657f, -0.23888466f, -0.14645208f, -0.37091255f, -0.10836433f, -0.15512721f, 0.07439423f, -0.29420546f, 
    -0.08033326f, 0.06813278f, -0.18790203f, 0.36465794f, 0.10687520f, 0.04899492f, -0.15762691f, -0.09552085f, 
    -0.02879316f, 0.03378158f, -0.10802132f, -0.22042823f, -0.02482726f, 0.08803821f, -0.14958754f, -0.04959384f, 
    -0.50974447f, -0.24221189f, -0.49353606f, -0.18942791f, 0.12247986f, -0.30443120f, 0.04923347f, 0.12038111f, 
    0.13156046f, 0.19945759f, 0.03155759f, 0.24817930f, 0.01650929f, -0.05959840f, 0.04754931f, 0.00924947f, 
    0.01890295f, -0.20656399f, -0.03600856f, 0.24435456f, 0.09165134f, 0.39127800f, 0.04981142f, 0.03043193f, 
    0.15179479f, 0.18705285f, 0.29836589f, -0.09669711f, 0.03304321f, 0.02180864f, -0.30197442f, -0.08610687f, 
    0.10477166f, 0.07419681f, 0.00219181f, 0.09581049f, 0.06204315f, 0.08496914f, -0.01514638f, 0.17409202f, 
    -0.01023061f, -0.04255199f, 0.47126663f, -0.14824830f, 0.28855586f, 0.00827923f, -0.30645916f, 0.18566838f, 
    -0.09574109f, -0.02954848f, 0.11380964f, -0.07219585f, -0.02600997f, 0.10616347f, 0.30883309f, 0.07817237f, 
    -0.06319299f, -0.01379349f, 0.20428444f, 0.09479611f, -0.01429969f, -0.10845010f, 0.15493189f, -0.00491783f, 
    -0.15817671f, 0.16881782f, 0.30500445f, -0.17259806f, -0.06447861f, -0.08375607f, -0.18747897f, -0.05140599f, 
    -0.78155971f, -0.02949234f, -0.31248835f, 0.19567125f, 0.14881788f, -0.27259660f, -0.43338892f, -0.01618111f, 
    -0.26231131f, 0.25622135f, 0.02895411f, 0.18698694f, 0.00862855f, 0.06941809f, -0.14727241f, -0.33892688f, 
    -0.39640796f, 0.11761690f, -0.05720731f, 0.11243109f, 0.02099603f, 0.02050163f, -0.42519858f, 0.03563107f, 
    0.12742136f, -0.10426316f, 0.05554092f, -0.34107924f, -0.27402529f, -0.05549070f, 0.04915832f, 0.22382085f, 
    -0.33414069f, 0.10383255f, -0.28296846f, -0.19627531f, 0.11456122f, 0.16739561f, -0.52853382f, 0.27144104f, 
    0.05262935f, 0.06123474f, -0.06429589f, -0.33876866f, -0.09644397f, 0.15242201f, -0.31489050f, -0.01233839f, 
    -0.36310184f, -0.00722529f, -0.04356089f, 0.20320080f, 0.06658762f, -0.04044594f, 0.22551449f, 0.10362088f, 
    0.10415795f, -0.09639522f, -0.21252756f, -0.69528568f, -0.23101923f, 0.20968473f, 0.20561966f, -0.11255310f, 
    0.07080524f, -0.17185719f, -0.41741675f, -0.12661926f, -0.08358842f, 0.19676159f, -0.05131736f, -0.03723006f, 
    -0.26073983f, 0.05017400f, -0.01604695f, -0.23847675f, -0.01521713f, 0.04777612f, 0.03672184f, -0.08066984f, 
    -0.28196356f, 0.15112674f, -0.44902387f, -0.11792740f, 0.07571954f, 0.24357636f, -0.08054873f, -0.38260707f, 
    0.11003675f, 0.08021655f, -0.02193030f, 0.19447403f, 0.36939377f, 0.24992168f, -0.04185870f, -0.21611787f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.00926860f, 0.06479555f, -0.17342575f, -0.01854395f, 0.02798465f, -0.06527839f, -0.07760389f, -0.15038677f, 
    -0.02552245f, 0.07080846f, -0.02387209f, -0.00746916f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
