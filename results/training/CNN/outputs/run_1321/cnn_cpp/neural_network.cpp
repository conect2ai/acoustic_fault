#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.83974981f, -0.09045684f, 0.13630751f, 0.36616933f, 0.76763815f, -0.28860423f, 0.01359214f, 0.13404724f, 
    -0.13241982f, 0.24054474f, 0.05663428f, -0.08103310f, 0.46855861f, 0.13528945f, -0.10008261f, -0.18240181f, 
    0.03618184f, -0.09491707f, 0.17952718f, -0.10977705f, -0.06483436f, -0.29820716f, 0.18046045f, 0.59482056f, 
    0.57855564f, -1.14703035f, -0.75706011f, 0.17011148f, 1.09621871f, 0.79026771f, 0.79568142f, 0.26838234f, 
    -0.90860718f, -0.22060122f, -0.15527387f, -0.15751170f, -0.06636749f, -0.03597186f, 0.45383185f, -0.32548627f, 
    0.01648109f, 0.07490487f, 0.04437140f, 0.17089717f, -0.22567661f, 0.05481080f, -0.07629994f, -0.04632846f, 
    0.14813466f, -0.28348747f, -0.29021636f, 0.49305078f, 0.31205189f, 0.34887400f, 0.53391057f, 0.45414847f, 
    0.52545959f, 0.56924415f, 0.45798981f, 0.19734055f, 0.02124125f, -0.00555829f, 0.14426970f, -0.06856278f, 
    0.10342477f, 0.12225282f, -0.18592210f, -0.13809405f, -0.17798145f, -0.20441486f, -0.09117407f, 0.17665829f, 
    0.06043149f, -0.20143713f, -0.15272205f, 1.55780852f, -0.21405359f, -0.58691162f, -0.44908068f, -0.92563248f, 
    0.77427846f, 0.33723691f, 0.07950323f, -0.06694098f, -0.01725556f, -0.26787472f, -0.00673611f, -0.09146172f, 
    -0.04754908f, 0.09560651f, 0.21219738f, -0.29057679f, -0.06296684f, -0.31906435f, -0.23742747f, -0.23456138f, 
    -0.56799990f, -0.40495351f, -0.24793710f, -0.25792196f, -0.18569677f, -0.96511436f, 0.58293903f, 0.74989140f, 
    0.46102485f, -1.04542148f, -0.55270308f, -0.97370869f, -1.16227913f, -0.07770085f, -0.04398420f, -0.12567908f, 
    0.42472264f, 0.09150967f, 0.43100134f, 0.09350962f, -0.36025822f, -0.25941041f, 0.18799891f, 0.19976373f, 
    0.02723202f, -0.26592219f, -0.12553820f, 0.23948547f, -0.24256091f, -0.39983907f, 0.46565774f, 0.51043457f, 
    -0.48566225f, -0.60821533f, -0.25103581f, -0.40894169f, -0.60025591f, -0.32012531f, -0.05516999f, -0.09468183f, 
    -0.41426671f, -0.57275778f, -0.45367944f, 0.51078296f, 0.18050818f, 0.42377371f, 0.48521227f, 0.30255368f, 
    0.17267467f, -0.16870697f, -0.43476322f, -0.36207274f, -0.30227888f, -0.43016416f, 0.75995916f, -0.89154130f, 
    0.02329902f, 0.41179216f, 0.19127114f, 0.75350231f, -0.19093581f, -0.44224250f, 0.01797809f, -0.10641721f, 
    -0.08647066f, 0.14906232f, -0.15161949f, -0.22009633f, -0.02044416f, -0.34583485f, -0.09798782f, 0.25861576f, 
    0.09009828f, 0.14622194f, -0.00339412f, -0.13502935f, -0.23294432f, 0.02063636f, 0.50490755f, -0.59155798f, 
    -0.34587580f, 0.49268746f, -0.49844688f, -0.40957031f, 0.68541485f, -0.62081176f, -0.89400297f, -0.62589103f, 
    -0.38763237f, -0.34464154f, -0.45724067f, -0.36886770f, -0.52361917f, -0.54820633f, -0.03850339f, 0.18541208f, 
    0.20807040f, 0.16400778f, 0.13102278f, -0.01758840f, 0.48971969f, 0.18306279f, 0.07143188f, 0.26095831f, 
    0.78730685f, 0.04763125f, -0.03310494f, -0.19680275f, -0.03974478f, 0.46424088f, 0.01254649f, -0.34817880f, 
    -0.57127303f, 0.38006806f, -0.22873233f, 0.35670039f, 0.06115835f, -0.49009031f, -0.52186865f, 0.17296936f, 
    0.42396781f, 0.35372993f, -0.40366644f, -0.37173975f, -0.46032411f, 0.09408905f, -0.10527408f, -0.20134990f, 
    -0.36833644f, -0.88538361f, 0.73419452f, 0.44727212f, -0.27543733f, 0.18962936f, -1.06033099f, -0.27865356f, 
    0.27649334f, 0.02609801f, 0.02502474f, -0.05112080f, -0.52587324f, 1.16559362f, -0.76154280f, 0.11789481f, 
    -0.15023381f, 0.27481377f, -0.07736282f, -0.41069373f, -0.15225527f, 0.04370731f, 0.14973943f, -0.24726842f, 
    -0.00401104f, 0.14925683f, -0.50230247f, -0.64021540f, -1.21925497f, -0.49760124f, -0.64068609f, 1.17968392f, 
    0.44729522f, 0.30379152f, -0.09161603f, 0.55161095f, -0.10415020f, 0.17224202f, 0.00251992f, -0.15735480f, 
    -0.08080047f, -0.10613173f, -0.53818423f, 0.32497951f, 0.06547064f, -0.51976973f, 0.17400254f, 0.19071594f, 
    0.14471340f, 0.31534776f, 0.23505802f, -0.48648357f, 0.13330652f, -0.48640105f, -0.88195771f, -0.49957728f, 
    -0.13524422f, -0.34570199f, -0.79040009f, -0.69276190f, -1.09545684f, 0.09551917f, -0.14044753f, 0.69104815f, 
    0.29902828f, 0.14245516f, 0.06759857f, -0.32633355f, -0.02757489f, -0.10154174f, -0.12467515f, -0.16389625f, 
    0.36300161f, 0.36513263f, -0.07371432f, 0.45632359f, -0.19655345f, -0.82528490f, -0.61730784f, -0.70328099f, 
    -0.75772393f, -0.01346396f, 0.44000474f, -0.24331471f, -0.51841426f, -0.16979854f, -0.49116835f, -0.74071085f, 
    -0.75766611f, 0.10450399f, 0.15436935f, 0.08951552f, -0.24860540f, -0.15813887f, -0.05428197f, -0.06316350f, 
    -0.16445892f, -0.30183056f, -0.26251525f, 0.00149136f, -0.25612214f, -1.21397102f, -0.34701106f, -1.14037943f, 
    -0.81182641f, -0.25789052f, -0.09519863f, 0.40015373f, 0.01127049f, -0.28041145f, -0.16651157f, 0.74755263f, 
    0.46971527f, 0.26504427f, 0.20472807f, 0.18320717f, -0.17388777f, 0.05139333f, -0.07005303f, -0.10774807f, 
    -0.19086500f, -0.55913997f, -0.26024517f, 0.08235745f, -0.19813089f, -0.28296423f, 0.47788459f, 0.07604423f, 
    0.34418398f, 0.40370828f, -0.12408585f, 0.08661020f, 0.07848718f, 0.69667631f, -0.58385712f, 0.19424483f, 
    -0.09252280f, 0.07258198f, 0.16022281f, 0.14360416f, -0.44564602f, 0.01007028f, 0.43490332f, 0.28543174f, 
    0.13808471f, 0.12628314f, -0.00090103f, -0.17113300f, -0.46685594f, -0.18193130f, -0.09264257f, 0.62682676f, 
    0.71058589f, 0.51770312f, 0.06995313f, -0.79288167f, 0.00653390f, -0.01655529f, -0.47014397f, 0.04256001f, 
    -0.18692946f, 0.35968232f, -0.17639574f, -0.35865590f, 0.50679636f, -0.24610637f, -0.21765426f, -0.28626519f, 
    0.02584885f, 0.36445847f, 0.47242761f, 0.16432519f, 0.00281652f, 0.16853376f, -0.21758701f, -0.04422330f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05606687f, 0.31227410f, -0.09586094f, 0.29833201f, 0.53615564f, -0.18012483f, 0.61830974f, 0.12491766f, 
    0.42854378f, 0.31380668f, 0.34438470f, 0.16960661f, -0.41537800f, 0.17620000f, 0.22026742f, 0.48252782f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.02842383f, 0.03824932f, -0.07114086f, -0.06218695f, 0.03250678f, -0.01790597f, 0.05619113f, -0.03353132f, 
    0.06898390f, 0.00698033f, -0.06902175f, 0.05860455f, 0.03771487f, -0.01094311f, 0.03355152f, -0.04669917f, 
    -0.07782000f, -0.01232644f, 0.04643330f, -0.05017871f, -0.05854667f, 0.05436579f, -0.07676710f, -0.02562409f, 
    -0.00272396f, -0.05528350f, 0.02528737f, -0.04843650f, 0.02884934f, -0.03147783f, -0.04042210f, -0.03393612f, 
    -0.02220625f, 0.03959071f, 0.02183427f, -0.07195055f, -0.01107631f, 0.06006928f, -0.06668522f, 0.04200882f, 
    -0.04784866f, -0.04817871f, 0.05823112f, 0.06082904f, -0.03619843f, 0.03610577f, -0.00891908f, 0.05164109f, 
    0.01118979f, 0.02220271f, -0.05292170f, -0.03111431f, -0.06249292f, -0.06779476f, -0.07498002f, -0.05212989f, 
    -0.01781418f, 0.02680345f, -0.05728412f, -0.00161264f, -0.00859292f, -0.03801272f, 0.02749968f, -0.02523398f, 
    0.05704940f, -0.07406649f, -0.02073096f, 0.05605773f, -0.02356474f, 0.01286279f, -0.06881183f, 0.00268539f, 
    -0.00140088f, -0.06427015f, 0.01359183f, 0.05681391f, 0.04678553f, -0.06341214f, -0.07954932f, -0.01099599f, 
    -0.00777180f, 0.00549487f, -0.00931730f, 0.00808325f, -0.04058038f, 0.02985957f, -0.05397641f, -0.01705824f, 
    0.02032570f, 0.00688325f, 0.02685934f, -0.00796326f, -0.06639354f, 0.01918178f, -0.01055545f, 0.05692915f, 
    0.05113440f, 0.05993152f, -0.00039469f, -0.01742167f, -0.03183633f, 0.05834856f, 0.02724880f, 0.06146148f, 
    -0.05773459f, -0.06236745f, -0.04120852f, 0.04192204f, -0.05950917f, -0.02365271f, 0.00789134f, -0.03561295f, 
    -0.04721154f, 0.00198203f, 0.01352328f, -0.04926789f, 0.03399619f, 0.00995215f, -0.04254881f, -0.02312986f, 
    -0.05565303f, 0.05471746f, 0.01822268f, -0.00923789f, -0.06108892f, 0.01759332f, -0.05072450f, -0.07752752f, 
    0.04664054f, -0.04021375f, -0.01955962f, -0.01740606f, -0.07440571f, -0.02256156f, -0.06972840f, -0.00523975f, 
    -0.03059948f, -0.07361230f, 0.03533029f, -0.03608926f, -0.07167421f, 0.05729108f, 0.02608907f, -0.03242230f, 
    -0.04984178f, -0.02533342f, 0.04722949f, 0.04591866f, 0.04001700f, -0.01643003f, -0.04594868f, 0.00737216f, 
    -0.03389472f, -0.04171138f, 0.04470185f, 0.05972893f, -0.07484779f, -0.01694146f, 0.04994846f, -0.06024771f, 
    -0.01975981f, 0.04898560f, 0.00662108f, 0.01335053f, 0.02141077f, 0.00059335f, 0.00499709f, -0.00587255f, 
    -0.04364035f, -0.00815220f, 0.00625745f, 0.03578270f, 0.00809344f, 0.00587299f, 0.03515771f, 0.00539842f, 
    -0.03965693f, -0.06366879f, -0.02638562f, -0.00705356f, 0.02567064f, 0.03173624f, -0.07655700f, -0.06971575f, 
    -0.04761298f, -0.07959802f, -0.03548577f, -0.06256806f, -0.00253160f, -0.04935304f, -0.06921124f, -0.00407904f, 
    -0.23262309f, -0.01769132f, 0.28522688f, 0.07295167f, 0.03043112f, -0.00549378f, -0.18241592f, 0.07710703f, 
    -0.53292626f, -0.28062382f, -0.47725892f, -0.64589274f, 0.19624031f, 0.18738301f, 0.38235489f, 0.20561805f, 
    0.22127073f, 0.28776169f, -0.41485494f, -0.14262807f, -0.15128729f, 0.16087364f, 0.02476590f, 0.12986811f, 
    0.05136387f, 0.06362949f, -0.06478160f, 0.23079251f, 0.00021334f, -0.05118123f, -0.12193698f, -0.11030183f, 
    0.15070255f, -0.08122616f, 0.08123881f, 0.09219753f, -0.10216895f, 0.37346125f, 0.14703338f, -0.15566555f, 
    -0.29265290f, -0.08917135f, 0.21433403f, 0.12857178f, 0.35073480f, 0.26990965f, 0.24019857f, 0.47021809f, 
    -0.01835718f, -0.22200893f, -0.07787745f, 0.19236992f, 0.36184075f, -0.00994818f, 0.25863326f, 0.35882184f, 
    0.07237571f, 0.05946823f, -0.20864354f, 0.01146773f, 0.11977789f, -0.12529738f, -0.03041883f, 0.30255929f, 
    0.09788063f, 0.33864960f, 0.29013547f, 0.34803593f, 0.18105251f, 0.23238397f, 0.11071670f, 0.59667903f, 
    -0.26740927f, -0.33047462f, 0.53872943f, -0.15763140f, -0.00455417f, -0.08494348f, -0.03239565f, 0.01014076f, 
    -0.02871402f, 0.14120823f, -0.08767925f, -0.33396775f, -0.16286804f, -0.11281957f, 0.10369670f, -0.18692861f, 
    0.11269277f, 0.23862113f, -0.19984688f, 0.12778859f, -0.14009444f, -0.09645902f, 0.01076977f, -0.22045045f, 
    -0.10582986f, -0.31520844f, -0.05252080f, -0.11243143f, 0.09719753f, 0.13157706f, 0.26734453f, 0.15539642f, 
    0.33960405f, 0.21610370f, 0.19541879f, 0.25424358f, -0.22015987f, 0.41019213f, -0.51571530f, 0.05520552f, 
    0.02114553f, -0.08696456f, 0.18104067f, -0.17174330f, 0.02523695f, -0.01150861f, -0.23998064f, -0.00844120f, 
    0.09619839f, 0.03786583f, 0.41860494f, 0.05293233f, 0.00814128f, -0.12565948f, -0.10074525f, -0.11029122f, 
    -0.06385520f, -0.28756255f, -0.14286730f, -0.17635432f, 0.11847484f, 0.22664881f, -0.41413030f, -0.07194072f, 
    0.08894588f, 0.07609371f, -0.00980655f, 0.07178792f, -0.06323393f, -0.16855429f, -0.22852188f, -0.21247749f, 
    -0.12505493f, -0.01021245f, -0.13909385f, 0.13940546f, 0.31248596f, 0.14678426f, 0.17723258f, 0.23529990f, 
    0.22108401f, 0.00798421f, 0.18291263f, 0.34755117f, 0.24916595f, 0.44791037f, 0.41653159f, 0.27452040f, 
    0.03794533f, -0.17659105f, 0.02371106f, 0.20566280f, 0.23821147f, -0.02047957f, 0.03083109f, 0.17589185f, 
    -0.25613770f, -0.25456986f, -0.29572719f, -0.07141114f, -0.00885578f, -0.01057237f, 0.04019661f, 0.16599952f, 
    0.02667560f, 0.22137031f, -0.09425230f, 0.18757851f, -0.26765358f, 0.17661288f, -0.47849128f, 0.17385015f, 
    0.19974157f, 0.26517078f, 0.30492687f, 0.01444696f, 0.13944852f, -0.37120441f, -0.29321688f, -0.05030197f, 
    0.03023162f, 0.02811202f, -0.05140185f, -0.05114353f, 0.03818175f, -0.04266167f, -0.05572983f, 0.00312435f, 
    0.02822828f, -0.06703403f, 0.02189802f, -0.06094329f, 0.01156210f, -0.00476487f, 0.04928118f, -0.01367807f, 
    -0.01236766f, 0.04823409f, -0.00618091f, 0.00794167f, -0.01491752f, -0.07968569f, 0.02175513f, 0.00001852f, 
    0.02441527f, 0.05415168f, 0.04824747f, 0.02496521f, -0.07525552f, -0.02837683f, -0.05447712f, 0.05420537f, 
    0.03424266f, -0.06898139f, 0.01126604f, -0.07961272f, 0.02607242f, 0.05406824f, 0.05117205f, -0.02290392f, 
    -0.03695006f, 0.04922366f, 0.02647879f, -0.02965468f, -0.07611679f, 0.04403628f, -0.06983274f, -0.03469592f, 
    -0.03237888f, -0.08216561f, 0.01443979f, -0.06648899f, 0.01881505f, -0.07564183f, -0.05802030f, 0.04981762f, 
    0.04393995f, 0.02956572f, -0.05725479f, 0.01371136f, 0.00553904f, -0.05100184f, -0.00591154f, -0.02219313f, 
    -0.04763720f, 0.02295847f, -0.00501943f, -0.05096643f, -0.08254167f, 0.04668380f, -0.03810640f, 0.04839870f, 
    -0.07415015f, 0.03521321f, -0.04364455f, 0.03124478f, -0.03197114f, -0.06533479f, 0.01567298f, 0.03861741f, 
    0.05366424f, 0.06147041f, -0.08456229f, -0.07294577f, -0.01410248f, 0.05287533f, 0.04433401f, -0.03971229f, 
    0.00400033f, 0.03027305f, -0.07833356f, -0.08307021f, 0.00179513f, -0.04630233f, -0.05063105f, -0.04327906f, 
    -0.00911382f, -0.00592129f, -0.08582331f, -0.05992619f, 0.01006839f, -0.06036993f, 0.00609762f, 0.01436949f, 
    -0.06669639f, -0.00746967f, 0.00095458f, 0.02118339f, 0.04768059f, -0.07472109f, 0.03103724f, 0.05240494f, 
    0.02534124f, -0.04072703f, 0.01134285f, -0.00465575f, -0.07050156f, 0.04451593f, -0.06935493f, 0.03455852f, 
    -0.06101376f, -0.06353022f, -0.01015940f, -0.00730111f, 0.00349554f, -0.05566834f, -0.03576303f, 0.05027003f, 
    -0.03015177f, 0.02236804f, -0.06557783f, 0.02125763f, -0.01357233f, 0.05146734f, -0.02333481f, 0.00716482f, 
    0.02008686f, -0.00305351f, -0.06711967f, 0.02020512f, -0.08386771f, 0.00779110f, -0.08269119f, -0.04272176f, 
    -0.00094818f, -0.03460670f, -0.07525888f, -0.05361418f, 0.05470824f, -0.01435502f, -0.04966855f, 0.02496140f, 
    -0.01648922f, -0.02823535f, 0.00886334f, 0.00394014f, 0.05398791f, -0.01368366f, -0.04830310f, 0.00929035f, 
    0.06013029f, -0.04179628f, -0.05679234f, -0.01291537f, -0.06033169f, -0.07447685f, 0.03424616f, -0.05178103f, 
    0.03109116f, -0.08659140f, 0.05716309f, 0.04196942f, 0.00732785f, -0.06145611f, -0.01034529f, -0.03858560f, 
    0.02078005f, 0.02814149f, -0.04898170f, -0.02214028f, 0.02764863f, -0.05702684f, -0.05886139f, -0.03458019f, 
    -0.08228409f, 0.04278199f, 0.00241048f, -0.05511111f, -0.04445756f, -0.07357977f, -0.03446056f, 0.00748319f, 
    0.03230065f, -0.07015403f, 0.02240230f, -0.31264272f, 0.00153471f, 0.08913732f, 0.13673638f, -0.08415531f, 
    0.23110686f, 0.17502718f, 0.23038541f, -0.01162339f, -0.30346295f, 1.05899096f, -0.08869719f, -0.01721884f, 
    -0.07561417f, -0.08346809f, 0.29624137f, 0.03770968f, -0.03210454f, -0.12603600f, 0.20367201f, 0.11336266f, 
    -0.11664122f, -0.26208764f, -0.03126423f, -0.04303424f, -0.27465606f, -0.17865999f, -0.20287110f, -0.23832907f, 
    0.09297251f, 0.08497789f, -0.00666939f, -0.07851660f, -0.22081487f, 0.05999661f, -0.19410288f, 0.16452132f, 
    -0.03959287f, 0.18148552f, 0.09685160f, 0.05645736f, 0.04439697f, -0.12003165f, -0.34274593f, -0.41957405f, 
    -0.09248982f, 0.13488892f, 0.25514287f, -0.14880277f, 0.25598744f, 0.01942668f, 0.00294510f, 0.07275916f, 
    0.07268795f, 0.01042031f, 0.00968604f, 0.06717199f, 0.02905209f, -0.13582256f, 0.29026291f, -0.15767598f, 
    -0.04596128f, -0.24458565f, 0.05927729f, 0.18676652f, -0.02067724f, -0.04615108f, -0.10461628f, -0.21111979f, 
    -0.28998968f, 0.61503947f, -0.04650084f, 0.18453600f, -0.09688995f, -0.00833474f, 0.03503611f, -0.08934581f, 
    -0.02432594f, 0.08296639f, 0.06264010f, 0.12116335f, -0.00949272f, 0.12554777f, 0.29642993f, -0.00481657f, 
    0.08125120f, 0.00915858f, 0.33676463f, 0.09891868f, 0.02337268f, 0.05421570f, 0.00786585f, 0.08552982f, 
    -0.03205210f, 0.58451468f, -0.02159071f, 0.23754697f, -0.12337999f, -0.16766366f, -0.02264786f, 0.22021487f, 
    -0.00896824f, -0.29529285f, 0.08007608f, 0.06854336f, 0.12015218f, -0.04387758f, 0.75474572f, 0.15982294f, 
    0.21783078f, 0.23057431f, -0.13416103f, 0.23897411f, -0.00975613f, -0.01337205f, 0.27217016f, 0.16724283f, 
    -0.23831815f, -0.11285211f, -0.21472956f, -0.09886427f, 0.02658026f, 0.21080542f, 0.11526584f, -0.04058126f, 
    0.06732574f, -0.07062669f, 0.02866227f, -0.06546941f, -0.04022724f, -0.06785708f, 0.10059232f, 0.01740282f, 
    0.18264362f, 0.24194580f, 0.18747547f, -0.13257301f, 0.09416074f, -0.02353636f, 0.05264197f, 0.04495044f, 
    0.11963070f, 0.10645708f, -0.01001775f, -0.02331939f, -0.02700678f, -0.08659763f, -0.17342570f, 0.18317638f, 
    0.06296766f, 0.12983645f, -0.14820951f, -0.11616830f, -0.08845544f, -0.01824133f, -0.17069553f, 0.04041359f, 
    0.10397873f, -0.05219368f, -0.05328506f, -0.05487547f, -0.18118978f, 0.01053259f, -0.14486298f, -0.02403831f, 
    0.04175805f, -0.12095329f, 0.03147087f, 0.00840179f, -0.03699701f, -0.32303682f, -0.18864882f, 0.00143448f, 
    -0.07786875f, 0.20206788f, 0.39039063f, -0.16283272f, -0.31557110f, 0.06075707f, 0.56114948f, 0.07562111f, 
    -0.05047221f, -0.07597516f, -0.04513760f, 0.02319318f, 0.20002156f, 0.21175988f, 0.03087739f, 0.06762195f, 
    0.39614016f, -0.06204607f, 0.02770149f, -0.26063240f, -0.10528807f, -0.06578943f, -0.03145453f, 0.07107815f, 
    0.21439373f, 0.12146282f, -0.04937292f, -0.11859538f, -0.10618828f, 0.73972112f, -0.12527604f, -0.25651333f, 
    -0.05621972f, 0.10609446f, 0.09386875f, -0.18517481f, -0.03278854f, 0.18487161f, -0.00119549f, 0.18239598f, 
    0.16150531f, 0.02126272f, -0.04744995f, -0.48836893f, -0.08570518f, -0.17104305f, -0.15153626f, -0.07990208f, 
    0.22108926f, 0.11340467f, 0.10506369f, -0.12915827f, -0.43919706f, -0.10919780f, -0.27837846f, 0.48196745f, 
    -0.03403246f, 0.08327030f, 0.01156784f, 0.20979291f, 0.04363250f, -0.13562079f, 0.00060754f, -0.09897017f, 
    0.06942095f, -0.17274739f, 0.09860255f, 0.26456630f, 0.27532536f, 0.05175480f, 0.12250029f, 0.06037762f, 
    0.19225211f, -0.07240596f, -0.02825957f, 0.12607148f, 0.06444648f, -0.06724754f, 0.17425650f, 0.26670188f, 
    -0.15217777f, -0.04105382f, 0.19305551f, 0.22665037f, -0.03359041f, -0.09732534f, -0.00578872f, -0.13474767f, 
    -0.31858379f, 0.46746853f, 0.22867697f, 0.09368613f, 0.04054452f, -0.10856224f, 0.29658854f, -0.09192432f, 
    0.00010711f, 0.08437994f, -0.05439863f, 0.12916733f, 0.06206029f, 0.06606574f, 0.30542132f, 0.21524446f, 
    0.19270061f, 0.02764700f, 0.13249464f, -0.29780048f, -0.01457340f, 0.06322213f, 0.06298160f, 0.05515732f, 
    -0.16469425f, 0.38750339f, 0.08321459f, 0.29574484f, -0.22014476f, 0.03098795f, -0.00750055f, 0.14284174f, 
    -0.09612083f, 0.12172475f, -0.13979143f, -0.00516264f, 0.57386297f, -0.06692034f, 0.60936594f, -0.05910784f, 
    0.23581888f, -0.03774096f, 0.24227092f, 0.36638045f, -0.05323024f, 0.14015980f, 0.13908948f, 0.17860886f, 
    -0.46619433f, -0.18278295f, -0.34327662f, 0.04164949f, 0.18268569f, -0.05468234f, 0.07632831f, -0.04175918f, 
    0.05941174f, 0.12177602f, 0.08160874f, -0.02345206f, -0.15881512f, -0.11816563f, -0.03980507f, 0.14330181f, 
    0.17781651f, 0.00729866f, -0.09839664f, -0.10633406f, -0.05923809f, -0.04786002f, -0.19547403f, 0.06807972f, 
    -0.09832231f, -0.10026306f, -0.28634322f, 0.11100754f, 0.01410215f, -0.07939744f, -0.03714003f, 0.00275467f, 
    -0.02274820f, -0.07858749f, 0.00854679f, 0.00627720f, -0.25591594f, -0.14389896f, -0.31873739f, 0.04242346f, 
    0.15183513f, 0.13615015f, -0.07153541f, 0.16093060f, 0.04253084f, -0.26933092f, -0.16783817f, -0.16044237f, 
    -0.17321658f, -0.10704251f, -0.06312884f, -0.06077486f, -0.19419800f, -0.29732478f, 0.06891914f, 0.04666046f, 
    -0.25314566f, 0.34206837f, -0.00169223f, -0.21609461f, -0.19700021f, -0.08424187f, 0.42338166f, 0.30132756f, 
    0.09510776f, -0.03895054f, -0.01657584f, -0.06954226f, 0.08863012f, -0.08200201f, 0.00707812f, 0.01067906f, 
    -0.00686460f, 0.03487752f, -0.02306874f, -0.04489724f, -0.02431335f, -0.05090041f, -0.04894794f, -0.06857581f, 
    -0.02165863f, -0.00582654f, 0.01477008f, -0.05189813f, 0.04700699f, 0.00687101f, -0.01597824f, -0.07147411f, 
    -0.01872217f, -0.04536303f, -0.04736676f, -0.00644389f, -0.06219001f, 0.05743966f, 0.01828010f, 0.04114921f, 
    -0.03064271f, -0.04662055f, 0.03654255f, -0.02590902f, -0.06930362f, -0.05936049f, 0.00575334f, -0.05273985f, 
    0.05076987f, 0.02457338f, -0.06160345f, -0.02709466f, 0.01839785f, -0.00669635f, 0.01779391f, 0.01282958f, 
    -0.01264145f, -0.04481451f, -0.06671046f, -0.01209049f, 0.05059800f, 0.04839804f, 0.02660018f, -0.06889030f, 
    -0.02351962f, 0.03348951f, -0.02561398f, 0.04408660f, -0.00200919f, -0.03821144f, -0.03777732f, -0.07145599f, 
    -0.02902759f, 0.04487567f, 0.01633964f, 0.02805318f, -0.03242639f, 0.05106131f, -0.03845318f, 0.02544413f, 
    -0.03909843f, 0.01326792f, 0.05556218f, 0.01266990f, -0.05404750f, -0.07232547f, -0.07358918f, 0.01385512f, 
    -0.00849452f, -0.03072753f, 0.05298856f, 0.03806503f, 0.02918769f, 0.04484464f, -0.06626146f, -0.03504400f, 
    0.03660084f, 0.01650146f, -0.01017562f, -0.01237251f, 0.05454144f, -0.07473179f, -0.00219759f, -0.05677791f, 
    -0.00478060f, 0.00215968f, 0.03807338f, 0.05965120f, 0.01765403f, -0.02619095f, -0.06980836f, -0.03988938f, 
    -0.03636055f, 0.02905104f, -0.08040973f, 0.03032020f, -0.04749564f, -0.05342865f, 0.04574502f, -0.06984639f, 
    -0.06341273f, 0.01904967f, -0.02963764f, -0.04298996f, 0.06055349f, 0.00589904f, -0.02609346f, -0.01219553f, 
    -0.03887186f, 0.04315628f, 0.00262245f, 0.00572531f, -0.07537454f, -0.00005035f, -0.00960726f, 0.05341902f, 
    -0.05909848f, -0.02593838f, -0.06924231f, -0.02827225f, 0.05779087f, 0.00514133f, 0.05738693f, 0.02893458f, 
    0.04193416f, -0.04255014f, 0.03933068f, 0.04109369f, 0.07115919f, -0.00228185f, 0.01779914f, -0.02537953f, 
    -0.03766129f, 0.00477721f, -0.01497706f, -0.02851403f, -0.02998940f, -0.06389032f, -0.06534688f, -0.03809958f, 
    -0.04349951f, -0.01631192f, 0.00084184f, -0.02014364f, 0.04689698f, -0.07927933f, -0.03871008f, 0.02888691f, 
    -0.01881495f, -0.07866167f, -0.03274474f, 0.01984290f, -0.07529172f, -0.04609066f, -0.00431027f, 0.00834032f, 
    -0.07220491f, -0.02126170f, -0.00327296f, 0.05232906f, 0.03521127f, -0.04589410f, 0.04335966f, -0.02906901f, 
    -0.07173017f, -0.02159032f, -0.01322655f, 0.04536274f, 0.02573767f, 0.01038474f, -0.04227783f, 0.01770333f, 
    -0.02062469f, -0.04521814f, -0.01539633f, 0.05761220f, -0.05505654f, -0.03708648f, -0.04455757f, 0.02751295f, 
    -0.01243305f, 0.05740935f, 0.06231907f, 0.01711105f, -0.00452548f, 0.01033165f, -0.05997224f, 0.04252908f, 
    0.00808482f, -0.04881810f, 0.07187188f, -0.02954352f, 0.24412538f, 0.08764408f, 0.00084644f, 0.05494793f, 
    -0.08658003f, -0.02627167f, -0.00859589f, -0.01765764f, -0.00245170f, -0.58390844f, -0.04261339f, 0.24952377f, 
    0.05216372f, 0.25632945f, -0.15436634f, -0.30618787f, 0.05068325f, -0.13924570f, -0.04868897f, 0.24371357f, 
    -0.14273529f, 0.14273722f, 0.03272204f, -0.02960948f, 0.03489765f, 0.05156070f, -0.04430450f, -0.09632284f, 
    0.12578253f, 0.23335861f, 0.10019641f, 0.13013351f, -0.22635776f, -0.16036350f, 0.24376836f, -0.02007408f, 
    -0.03503150f, -0.05573896f, -0.05217958f, 0.14231808f, -0.14969736f, -0.01688057f, -0.04577263f, 0.18450432f, 
    0.46357825f, -0.00034053f, 0.28891274f, -0.14077404f, -0.26523697f, 0.04191447f, 0.04470691f, 0.09047632f, 
    0.07824175f, 0.04742785f, 0.04649960f, 0.01782919f, 0.22773862f, 0.23045927f, -0.27602336f, -0.13626187f, 
    -0.05224189f, 0.05490886f, 0.16755785f, 0.03130028f, 0.09999355f, 0.03856792f, 0.06477165f, 0.12566322f, 
    0.12734982f, -0.28377309f, 0.15944274f, 0.26344419f, -0.07100703f, -0.01213194f, -0.00231730f, 0.07265258f, 
    -0.21605909f, 0.02382009f, 0.04923964f, -0.11860009f, 0.18597257f, -0.07327378f, -0.22836430f, 0.18903340f, 
    -0.20151073f, 0.04507271f, -0.07652609f, -0.28036502f, -0.02303822f, -0.03701982f, -0.04469524f, 0.02293721f, 
    -0.12495220f, 0.07495346f, -0.01368219f, 0.17332670f, -0.03430764f, -0.03993414f, 0.19425492f, -0.09402931f, 
    -0.08659174f, 0.22035371f, 0.05861063f, -0.08517908f, -0.37619537f, 0.18000333f, 0.44523427f, -0.27885512f, 
    -0.08712208f, -0.02432141f, 0.08561384f, 0.06389356f, 0.07469422f, -0.11332452f, -0.03787532f, -0.16861902f, 
    0.26774338f, -0.01872745f, -0.17570823f, 0.03259712f, -0.08772667f, -0.20351645f, -0.17704265f, -0.03493640f, 
    -0.07507436f, -0.14169404f, -0.08676343f, -0.03670225f, 0.34351528f, 0.28386447f, 0.25054491f, -0.00477967f, 
    -0.20001355f, 0.12014986f, -0.09074114f, 0.25965667f, 0.02879271f, -0.06943561f, -0.09284844f, 0.05255421f, 
    0.10093441f, -0.02103592f, -0.32272327f, -0.12149021f, -0.02981203f, 0.05532623f, -0.07419421f, 0.16592652f, 
    0.07486351f, 0.20305187f, 0.12104937f, 0.01989929f, 0.09337149f, -0.09508767f, 0.00387919f, 0.16234162f, 
    0.06126888f, 0.02567139f, -0.07391565f, 0.06397704f, 0.13604057f, 0.03464393f, 0.03877385f, -0.00352104f, 
    0.01217706f, -0.16410695f, 0.04463708f, 0.05232658f, 0.12497010f, 0.16731964f, 0.10696781f, -0.00701755f, 
    0.00792542f, -0.05682902f, -0.07802005f, -0.05935699f, 0.22563492f, 0.04487161f, 0.22680132f, 0.28016225f, 
    -0.04602206f, 0.01813248f, 0.16741779f, -0.05405240f, -0.05872117f, -0.04425455f, -0.08439770f, 0.06956249f, 
    -0.03454840f, -0.06379309f, 0.07766134f, 0.02625371f, 0.01912531f, -0.14550190f, -0.16117574f, 0.05324620f, 
    0.13347697f, 0.11285904f, -0.28322986f, -0.00063707f, -0.51476008f, 0.46805546f, -0.19599147f, 0.23774588f, 
    0.03058448f, 0.04485440f, 0.05414829f, -0.01720382f, 0.05269142f, 0.05792091f, 0.15000051f, 0.08077040f, 
    -0.10638639f, -0.07085877f, -0.10065556f, -0.18683878f, 0.09583995f, 0.08713497f, -0.00563407f, 0.17123869f, 
    -0.06042699f, -0.07111469f, 0.05099494f, -0.00399274f, -0.22948812f, 0.21591635f, -0.22595714f, 0.28831336f, 
    -0.01492704f, 0.06457365f, 0.01320695f, -0.08172280f, 0.12225854f, 0.12364081f, 0.22015242f, 0.05603734f, 
    -0.14149782f, -0.14369537f, -0.17024679f, 0.30021045f, 0.17092033f, -0.04583757f, 0.12990287f, -0.08116523f, 
    -0.00373248f, -0.03864839f, -0.05679861f, 0.12641156f, 0.12780817f, -0.08997161f, 0.05818248f, 0.08100350f, 
    -0.15430482f, 0.05127930f, 0.18040605f, -0.00001270f, 0.07790893f, 0.03263967f, 0.11036908f, 0.08644128f, 
    -0.59585220f, 0.28164244f, -0.15429573f, 0.39408162f, 0.10564954f, -0.00689436f, 0.11634159f, 0.19607796f, 
    0.04993792f, -0.11938243f, -0.01330403f, -0.08153530f, -0.00568962f, -0.02567057f, 0.11403805f, 0.04631998f, 
    0.24893151f, -0.16291429f, 0.17160311f, -0.37292901f, -0.10844818f, -0.06490967f, 0.02412764f, -0.02613710f, 
    0.01861521f, 0.25930092f, -0.11245527f, 0.27401125f, -0.11874682f, 0.11177687f, 0.09826896f, -0.22213484f, 
    -0.16459566f, 0.28308606f, -0.04059498f, -0.07540238f, 0.43623608f, -0.24591009f, 0.98723835f, -0.44590235f, 
    0.04492942f, 0.09974390f, -0.03223112f, 0.22828305f, -0.06045236f, 0.04488719f, 0.11607011f, 0.22445054f, 
    -0.56772858f, 0.43074846f, 0.00045389f, 0.22315858f, 0.21182434f, 0.04660643f, 0.02909045f, 0.02863347f, 
    0.04165222f, 0.03715295f, 0.04717083f, 0.05751960f, -0.01765517f, -0.05784242f, -0.20681505f, 0.03864374f, 
    0.16151054f, -0.19068925f, -0.31815323f, -0.21372482f, 0.02745602f, 0.01637122f, -0.04333794f, 0.00312031f, 
    -0.21926694f, -0.01914791f, -0.34456608f, 0.03929973f, -0.09465540f, 0.20599464f, -0.06921594f, -0.22382110f, 
    0.01672368f, 0.08626328f, -0.02880333f, 0.21428046f, -0.32738715f, 0.17067403f, 0.19043855f, 0.16795747f, 
    -0.03394024f, -0.03731656f, 0.00749396f, -0.05915276f, -0.15037635f, 0.13194977f, -0.02471470f, -0.00858514f, 
    0.03320644f, -0.00208443f, -0.03658640f, -0.07105277f, 0.06082779f, -0.07941115f, 0.12044004f, 0.13241446f, 
    -0.36371160f, 0.14197911f, 0.05757582f, 0.00396908f, -0.02072030f, -0.17650227f, 0.36853915f, 0.29857948f, 
    -0.00006306f, -0.04669916f, 0.01703952f, -0.01368857f, 0.05420361f, -0.10473152f, -0.03146435f, 0.06953888f, 
    0.03618230f, 0.09484316f, -0.02973389f, 0.00737006f, 0.00251012f, -0.07778508f, 0.14837448f, -0.00664429f, 
    0.23170753f, -0.06691933f, 0.05175437f, 0.00623707f, 0.51206982f, 0.26891255f, 0.17427561f, -0.32652378f, 
    -0.14786585f, -0.35720265f, 0.23704141f, 0.03460075f, 0.15777372f, -0.06778881f, -0.00708090f, 0.12644905f, 
    0.02603026f, 0.11553355f, 0.19042166f, -0.01098475f, 0.02340535f, 0.01990606f, -0.04878129f, -0.08418258f, 
    -0.08693953f, 0.12018889f, 0.04923136f, 0.25497559f, 0.02706594f, -0.51188433f, 0.09130122f, 0.10656792f, 
    0.02594795f, 0.07831705f, -0.10529768f, -0.08134471f, 0.13949789f, -0.11196426f, -0.02142928f, -0.02511463f, 
    0.95623863f, 0.86748767f, 0.01337797f, 0.02753492f, -0.12059969f, -0.06344479f, 0.00464990f, -0.14648931f, 
    -0.01365090f, 0.01742660f, 0.15061222f, 0.04054358f, 0.03086818f, 0.24425289f, 0.28124422f, -0.00322125f, 
    0.18882652f, 0.00726112f, -0.22749439f, -0.02856623f, -0.13761373f, -0.07844561f, -0.05838627f, -0.26459852f, 
    0.43939087f, 0.30638504f, -0.04565644f, 0.04868231f, -0.06812986f, -0.09901116f, 0.01291451f, -0.16858855f, 
    0.09764375f, 0.05254830f, -0.03389105f, 0.19733872f, 0.35919234f, 0.54525483f, -0.12122109f, 0.12422180f, 
    0.10050296f, -0.01241052f, 0.14468347f, 0.21347530f, -0.09877683f, 0.11953337f, 0.04583342f, -0.00591706f, 
    -0.08044434f, -0.04320559f, -0.11159276f, -0.04128543f, -0.16189437f, 0.04207662f, -0.06503844f, -0.01351126f, 
    0.00057149f, 0.01543617f, -0.13299310f, 0.18374367f, 0.52015036f, 0.31338823f, -0.42262837f, -0.38097119f, 
    0.34356573f, 0.11735918f, -0.05898036f, 0.15875056f, 0.04622255f, 0.13899086f, -0.02302917f, -0.01446246f, 
    -0.15867652f, -0.32056043f, -0.56651133f, 0.23641582f, -0.08750418f, 0.18570501f, 0.16580565f, -0.07555538f, 
    -0.03033038f, -0.20658247f, -0.00624603f, -0.09377683f, 0.22812402f, -0.12057862f, -0.08758159f, 0.13233738f, 
    -0.00467051f, -0.01916098f, 0.17388730f, 0.23791358f, -0.07825217f, 0.05869129f, 0.01154448f, 0.04598374f, 
    0.51383406f, 0.17172655f, 0.29319853f, 0.11555845f, 0.01054041f, -0.00750528f, -0.02714032f, -0.08643758f, 
    -0.00368304f, -0.04259242f, 0.00587830f, 0.19359426f, 0.18530472f, -0.37181655f, -0.61586189f, -0.12282774f, 
    0.18824519f, 0.43432158f, 0.33260518f, -0.00680740f, 0.13902837f, 0.03628995f, -0.14679763f, -0.00576523f, 
    -0.11275437f, 0.08893574f, 0.04987120f, 0.03103468f, -0.00617934f, 0.06733254f, 0.10076476f, -0.05589920f, 
    0.29439220f, -0.20082577f, 0.05025486f, 0.01395808f, -0.08729991f, -0.08762410f, 0.19384128f, 0.13005099f, 
    0.16910475f, -0.17770505f, -0.24989672f, 0.11872233f, -0.12629329f, -0.11327714f, 0.13732463f, -0.07097253f, 
    -0.08810173f, -0.23040991f, 0.01104631f, -0.25272506f, -0.21504308f, -0.12514360f, -0.03252363f, -0.11633918f, 
    0.59123749f, -0.00592018f, 0.33634797f, 0.16822316f, 0.25325927f, 0.53968704f, -0.06185133f, -0.21569866f, 
    -0.09735012f, -0.31485727f, 0.16021866f, 0.22020295f, 0.10688434f, 0.10256407f, -0.04259598f, 0.10949348f, 
    -0.09032007f, -0.03020254f, 0.08559009f, -0.24789672f, -0.17226282f, -0.19524026f, -0.02417703f, -0.14027202f, 
    -0.15254930f, 0.14036562f, 0.15917523f, 0.16068734f, 0.40795553f, 0.12609155f, 0.02882652f, 0.04832061f, 
    0.20053639f, -0.01409799f, -0.01210333f, 0.06804845f, 0.03998771f, -0.01853911f, -0.01593579f, -0.17787048f, 
    -0.03975976f, -0.08988457f, -0.66540402f, 0.01066429f, 0.00244157f, 0.33198914f, 0.05500063f, -0.16140328f, 
    0.02680211f, -0.00101609f, 0.18195924f, -0.00071168f, -0.27572763f, -0.42860970f, -0.13378225f, -0.16963047f, 
    0.14318494f, 0.09660724f, -0.21232486f, -0.10633139f, -0.04416778f, -0.07814924f, -0.21976367f, -0.15074532f, 
    0.11695145f, 0.17249699f, -0.26251182f, 0.27403378f, 0.03965233f, 0.05146084f, 0.10412942f, -0.02390084f, 
    0.29154879f, -0.09108678f, 0.29187608f, 0.38046539f, 0.18783383f, 0.01235005f, -0.23075055f, 0.14803079f, 
    0.27554819f, 0.01419840f, 0.09259661f, 0.09783518f, 0.07078190f, 0.03998817f, -0.08399715f, 0.17293893f, 
    -0.00601055f, -0.16188270f, -0.12146454f, 0.23836677f, 0.08399367f, -0.02083620f, 0.13168792f, 0.05771597f, 
    -0.17181584f, -0.03779542f, -0.15238172f, 0.10811914f, 0.50082380f, -0.20457755f, 0.09781030f, 0.17887434f, 
    0.07506438f, 0.16666037f, 0.32220703f, 0.04534638f, -0.10961805f, 0.21065752f, 0.02930064f, 0.21945806f, 
    0.00809801f, 0.03759502f, 0.20659976f, 0.40064347f, -0.02049118f, 0.20645267f, 0.25540397f, 0.15724179f, 
    0.01143815f, 0.11369180f, 0.00243209f, 0.08411340f, -0.15111953f, -0.47315562f, -0.18248443f, 0.02082450f, 
    -0.01575264f, -0.16118887f, -0.02805419f, -0.23750983f, -0.11263876f, 0.02837313f, 0.14793809f, 0.20204337f, 
    0.31658807f, -0.06004845f, 0.03011763f, 0.03230334f, -0.03918945f, 0.14550610f, -0.06650557f, -0.27238125f, 
    -0.01526810f, -0.15373503f, -0.06017141f, -0.06200457f, -0.09576318f, -0.01771932f, 0.12518923f, -0.33800691f, 
    0.05572022f, 0.24099328f, 0.09443215f, 0.27868736f, -0.13278136f, -0.00453046f, -0.12965100f, -0.09266790f, 
    -0.14520882f, -0.05184426f, -0.00485042f, -0.23235109f, -0.07359299f, -0.02095599f, -0.05198357f, -0.12861291f, 
    0.12494709f, -0.08576369f, -0.08078706f, -0.15856564f, -0.10090219f, -0.21657988f, -0.24052310f, -0.21376336f, 
    0.10134599f, 0.00457823f, 0.06706913f, 0.04323981f, 0.02854635f, 0.04753384f, 0.14622734f, -0.10266930f, 
    -0.04292414f, -0.00435964f, -0.05187508f, 0.02287154f, 0.03641352f, -0.01346267f, 0.01879456f, 0.02995031f, 
    -0.02284044f, 0.00943219f, -0.02197124f, 0.05105020f, -0.05141064f, -0.07881911f, -0.03021014f, -0.01066284f, 
    0.05926478f, -0.05235427f, 0.03672495f, 0.03172361f, 0.02557271f, 0.05962730f, 0.02466709f, -0.08110950f, 
    -0.06373136f, -0.06705046f, -0.01915134f, 0.00262405f, 0.05251089f, -0.04882206f, -0.02443883f, -0.02118083f, 
    -0.02736469f, -0.01304382f, 0.01041287f, -0.06088078f, -0.05596736f, -0.06438666f, -0.00883922f, -0.06191079f, 
    -0.05369994f, 0.01368142f, -0.07911228f, 0.01234994f, 0.06390494f, 0.02950816f, 0.04049036f, 0.03786581f, 
    -0.04703072f, 0.03524651f, 0.01076270f, -0.01994451f, -0.01764987f, -0.02784115f, -0.04009380f, -0.01220679f, 
    -0.00634048f, -0.04437299f, -0.07498037f, -0.07695483f, 0.04959609f, 0.00964480f, -0.05271735f, -0.05006095f, 
    -0.01505637f, 0.04690592f, 0.02711962f, -0.04759398f, -0.04180524f, 0.00323341f, -0.04245671f, 0.02401277f, 
    -0.06141982f, 0.02485201f, -0.00657116f, -0.04032994f, 0.00925015f, 0.01916434f, 0.05672528f, -0.02089451f, 
    -0.00296230f, 0.00675983f, -0.07226633f, -0.02820604f, 0.06265979f, 0.00683401f, -0.00217814f, 0.03742421f, 
    -0.03169201f, -0.01253443f, 0.01561815f, -0.03210811f, 0.01386235f, 0.02977378f, 0.03236395f, -0.04516459f, 
    -0.07952346f, 0.04172604f, -0.04875842f, 0.02593871f, -0.08226719f, 0.03181199f, 0.04962579f, -0.03053917f, 
    0.04967339f, 0.04178567f, 0.02130700f, -0.01366286f, -0.03398503f, -0.04336046f, -0.01885973f, 0.05097879f, 
    0.06253546f, -0.01283521f, 0.05708439f, -0.04671095f, -0.02847900f, 0.02432530f, 0.03481102f, -0.01676508f, 
    0.03426091f, -0.05568518f, -0.06886914f, 0.01064944f, -0.04787676f, -0.06650982f, -0.02234046f, -0.00986134f, 
    -0.04022577f, 0.05632312f, 0.01932742f, 0.02919224f, 0.00319770f, -0.03695737f, -0.02025299f, -0.06313788f, 
    0.03470588f, -0.00798652f, -0.06406069f, 0.02203221f, 0.04462862f, 0.01601409f, -0.06036514f, 0.05962535f, 
    -0.05292746f, 0.06108193f, 0.00787298f, -0.02711396f, -0.01662660f, 0.05428945f, -0.02548868f, -0.02451259f, 
    0.03905619f, -0.07419279f, -0.03070097f, -0.05432156f, -0.04480520f, -0.06196909f, -0.03885548f, -0.08110342f, 
    -0.03796041f, -0.01603984f, -0.03939961f, -0.04367436f, 0.00918930f, 0.06940290f, 0.03287963f, -0.03299180f, 
    0.00242226f, -0.03716169f, -0.03145869f, -0.00834068f, 0.04502896f, 0.02743855f, -0.06652264f, 0.06166982f, 
    -0.05887979f, -0.02418984f, -0.00238545f, -0.01632908f, 0.04599572f, -0.03807275f, -0.01314694f, -0.01156195f, 
    0.05411412f, -0.04319548f, 0.03801876f, -0.06465549f, -0.05362949f, -0.07826963f, -0.00895180f, 0.04269558f, 
    -0.05560111f, -0.03353127f, -0.01500713f, -0.02652424f, 0.01945689f, -0.01770390f, -0.04037008f, -0.00367703f, 
    -0.06603798f, 0.05452783f, 0.04904489f, 0.01808342f, -0.07420022f, -0.05905270f, 0.00029043f, -0.02500510f, 
    -0.02381983f, -0.04854020f, -0.03358913f, -0.06412489f, -0.01544323f, -0.05219059f, -0.07967617f, -0.02269177f, 
    -0.00833373f, 0.02944203f, 0.01246827f, 0.03120974f, -0.03286158f, -0.03252430f, -0.04608475f, -0.07026814f, 
    0.01101886f, 0.05612639f, -0.08229481f, -0.03165637f, -0.04399525f, -0.02817442f, -0.06552687f, -0.07991827f, 
    -0.01824715f, 0.03061344f, -0.07251720f, -0.07684114f, -0.00711048f, -0.03218443f, 0.00340371f, 0.01414438f, 
    -0.03356855f, -0.01492413f, -0.06001791f, 0.05081252f, -0.00724606f, -0.04204731f, -0.05614930f, 0.03513998f, 
    -0.07650533f, 0.02648954f, -0.08369790f, -0.04283318f, 0.00886089f, -0.05745143f, -0.02782542f, -0.01629462f, 
    -0.05212762f, 0.05048079f, -0.07193477f, -0.05619041f, -0.02255100f, 0.05717219f, 0.03721017f, 0.01375976f, 
    0.01085759f, 0.05904179f, 0.03328094f, -0.02486989f, 0.04493347f, 0.01230790f, 0.04771672f, -0.01523652f, 
    0.03037065f, 0.02152449f, -0.04325826f, 0.06055659f, 0.02769093f, 0.00373805f, 0.00840337f, 0.03898708f, 
    -0.07518241f, 0.01799679f, 0.04957290f, -0.06657331f, 0.06471964f, -0.03650663f, 0.02511882f, 0.06218230f, 
    -0.01717760f, 0.02046059f, -0.02608479f, -0.07308436f, -0.06680036f, -0.04084314f, -0.02901362f, -0.04204112f, 
    -0.04189074f, -0.04557433f, -0.02539361f, 0.00946139f, 0.06835742f, -0.04004837f, 0.01759549f, 0.01868044f, 
    0.05062829f, -0.05908075f, -0.05571640f, 0.00388915f, -0.05974678f, -0.04686028f, 0.06267146f, -0.02107402f, 
    -0.01065002f, 0.02718974f, -0.04573365f, 0.01554491f, -0.00575351f, 0.00108558f, 0.02601535f, -0.04594890f, 
    0.01257047f, 0.02874157f, -0.00038447f, -0.00524674f, -0.01878547f, -0.03363504f, -0.00828977f, 0.05077738f, 
    -0.07833142f, 0.05520352f, 0.01418502f, -0.05145741f, -0.07367390f, 0.00930042f, 0.04785203f, -0.04381768f, 
    -0.07464113f, 0.05022997f, -0.04707982f, -0.05295704f, -0.07103902f, 0.03752961f, -0.01402410f, -0.02639285f, 
    -0.03030421f, 0.02512269f, 0.03281756f, 0.03822584f, -0.05060691f, 0.03668310f, -0.02391459f, -0.04418543f, 
    -0.02237824f, -0.02294186f, -0.03962031f, -0.04271982f, 0.05314408f, -0.02814911f, -0.00414605f, -0.06179830f, 
    0.00610799f, -0.03218779f, 0.00603693f, 0.04592682f, -0.02709462f, -0.03369027f, 0.02540348f, -0.00697048f, 
    -0.03050894f, 0.02245999f, -0.03524962f, -0.05036771f, -0.05409354f, -0.04962173f, -0.01074400f, -0.06623087f, 
    0.05142941f, 0.05254939f, 0.02117463f, 0.04057518f, 0.02567457f, 0.04424320f, 0.03008690f, 0.06085227f, 
    -0.01584747f, -0.04990841f, -0.17368926f, -0.01642742f, -0.03224897f, 0.12799899f, -0.15916495f, 0.09765939f, 
    -0.15299118f, 0.17585503f, -0.09564441f, 0.02857086f, -0.50712395f, 0.22301461f, 0.41212210f, -0.11742071f, 
    -0.20288648f, 0.10232805f, -0.01538214f, 0.03219792f, 0.10999667f, -0.11983895f, -0.14685738f, 0.09651130f, 
    -0.32347232f, -0.57799536f, -0.33022690f, -0.02233579f, 0.12561685f, -0.08858218f, -0.12044695f, 0.12321289f, 
    0.23012374f, -0.01831253f, -0.02505346f, -0.02811515f, -0.02851333f, 0.30731916f, -0.13468155f, -0.11476942f, 
    0.13108057f, -0.00272355f, -0.02929793f, -0.04785996f, 0.18671946f, -0.05430372f, -0.11556920f, -0.12268380f, 
    -0.28219777f, 0.05343215f, 0.34494019f, 0.32742006f, 0.11574204f, 0.08965240f, -0.17761992f, 0.15824747f, 
    -0.00424689f, -0.00341338f, -0.00256746f, 0.14774482f, 0.06102163f, 0.00514581f, 0.11270670f, 0.44162354f, 
    0.06220964f, -0.20180437f, 0.00105459f, 0.03520225f, -0.10972857f, -0.12770455f, -0.11524373f, -0.07267798f, 
    -0.37453893f, -0.04044786f, -0.03649124f, -0.35030001f, -0.03836776f, -0.01619425f, -0.09085536f, 0.06998113f, 
    -0.04331997f, -0.06525670f, -0.16130501f, 0.01309712f, -0.08273525f, -0.15156376f, 0.52156645f, 0.25020215f, 
    0.13568680f, -0.13588974f, 0.17801203f, 0.06224474f, 0.05490479f, -0.01399570f, 0.02065025f, -0.02362834f, 
    0.23499951f, -0.12488142f, -0.01481773f, -0.22029856f, -0.03122980f, 0.01774680f, -0.07588189f, 0.15595116f, 
    0.22995664f, -0.16535546f, 0.02309406f, 0.05642238f, 0.03444810f, -0.00105422f, 0.22162209f, 0.57117528f, 
    -0.00437608f, 0.03051190f, -0.28696480f, -0.04806973f, 0.05097290f, -0.11012076f, 0.20174482f, 0.08089077f, 
    -0.02029394f, 0.34670377f, 0.30501190f, 0.06407454f, 0.14069436f, 0.03619710f, 0.08815006f, -0.18574595f, 
    0.08161266f, -0.03913150f, -0.00268925f, -0.07857712f, 0.01978496f, 0.22400720f, 0.32443473f, 0.41025856f, 
    0.08916731f, 0.02429385f, 0.18609525f, 0.19909057f, 0.01956201f, 0.09511892f, -0.03996015f, 0.00119829f, 
    -0.45883527f, 0.15420279f, 0.04824789f, 0.16688721f, -0.05565806f, -0.08772445f, -0.09998240f, 0.09248177f, 
    0.11114912f, 0.12322372f, 0.05050780f, 0.14986083f, 0.01924763f, 0.15851611f, 0.20012812f, 0.17261840f, 
    0.10864057f, -0.14012775f, 0.12651739f, 0.13795036f, -0.11985050f, -0.00990176f, 0.02256531f, 0.12030671f, 
    -0.08749349f, -0.16015211f, -0.26148239f, -0.02065054f, 0.12876303f, 0.00590940f, -0.17599362f, 0.02684342f, 
    0.00340975f, 0.17982806f, 0.11942222f, -0.19535451f, -0.24222626f, 0.12874152f, -0.28581783f, 0.12134866f, 
    0.27201891f, 0.03497881f, -0.16331957f, -0.09647477f, 0.23717104f, 0.14704691f, -0.08459899f, -0.12737857f, 
    -0.11097609f, 0.06886544f, 0.12500450f, -0.20903127f, -0.05308044f, 0.02030497f, -0.12528126f, 0.13408528f, 
    0.09916156f, 0.18856566f, 0.15109733f, 0.06739403f, 0.25587234f, -0.11118970f, 0.15734151f, -0.47168946f, 
    0.03043926f, -0.02555788f, -0.13179122f, -0.17744723f, -0.07849666f, 0.02566428f, -0.02822999f, 0.13139388f, 
    -0.29562607f, -0.05441182f, -0.04313517f, -0.12369059f, -0.02942573f, -0.11618659f, -0.01557019f, -0.16519268f, 
    0.08526435f, 0.04196090f, -0.07413513f, 0.16825034f, -0.00926867f, -0.21858814f, -0.18205942f, -0.05289055f, 
    0.07128369f, -0.19788970f, -0.07502957f, -0.05164558f, 0.07854060f, -0.43315786f, -0.41570565f, -0.30058157f, 
    0.39605951f, 0.35273245f, 0.46432459f, -0.03405940f, 0.01999232f, 0.40662080f, -0.04936290f, 0.22588322f, 
    0.11748783f, 0.02402459f, -0.03785926f, 0.02552943f, -0.01179370f, 0.23922865f, -0.07323934f, 0.40806785f, 
    0.30046064f, -0.05240714f, -0.21416567f, 0.02236913f, -0.11845636f, -0.10087772f, -0.01010249f, -0.07052429f, 
    0.21938457f, -0.49335888f, 0.07579418f, -0.14153267f, 0.07882809f, 0.07959396f, -0.08658978f, 0.02350820f, 
    -0.07252286f, 0.01425511f, -0.04141479f, 0.04238043f, 0.26055214f, 0.07933518f, 0.00231233f, 0.23958410f, 
    0.19114226f, 0.13202679f, 0.22920707f, 0.09549424f, -0.01779232f, -0.00625284f, 0.15385263f, 0.03756632f, 
    -0.00003382f, -0.13970637f, -0.08688409f, 0.09058388f, 0.01122446f, -0.09060944f, 0.05304635f, -0.00235780f, 
    -0.05619238f, -0.14464016f, 0.03975910f, -0.25000310f, 0.15811497f, 0.32465026f, 0.60059893f, 0.55773109f, 
    -0.02712581f, 0.30640376f, 0.08838299f, -0.03897747f, -0.01707159f, -0.15358773f, 0.04224467f, 0.14160781f, 
    0.39627400f, -0.13979672f, -0.20826751f, 0.06744358f, 0.04173436f, 0.07362445f, 0.18901898f, -0.02139138f, 
    0.03051061f, 0.06060961f, 0.07420062f, -0.00696988f, 0.36992246f, 0.41344669f, 0.23022804f, 0.18472469f, 
    -0.11941804f, 0.18138619f, 0.18425061f, 0.28857809f, 0.06475838f, 0.13268086f, 0.10329796f, 0.10627582f, 
    0.10983518f, 0.25467810f, -0.02823997f, 0.11633898f, 0.16734017f, 0.05906506f, -0.10944257f, 0.10464058f, 
    0.01606043f, -0.02208138f, -0.14722499f, 0.05036841f, 0.22232863f, 0.20040196f, -0.09330764f, 0.11270183f, 
    0.08315516f, -0.02064490f, -0.05596364f, 0.19868679f, -0.00105239f, 0.00566491f, -0.16573074f, -0.04218262f, 
    -0.26648709f, -0.27334049f, -0.18537436f, 0.11126699f, 0.13061550f, -0.10512329f, -0.20282796f, -0.05133570f, 
    -0.06945834f, -0.08704705f, -0.12087310f, -0.34426033f, -0.21482974f, 0.01277336f, -0.48876986f, 0.16378325f, 
    -0.07773218f, 0.16222386f, 0.28174406f, -0.05552788f, 0.14335142f, 0.10520107f, -0.15050893f, 0.00415297f, 
    -0.23804317f, -0.09232607f, -0.22401483f, 0.09733576f, 0.06904393f, -0.02590603f, -0.02971579f, 0.08575886f, 
    0.12242480f, -0.13826080f, -0.04904997f, -0.00326627f, -0.42286158f, -0.49705413f, 0.14248866f, 0.36533406f, 
    0.16516718f, 0.13575980f, 0.06071039f, 0.18094012f, 0.15570639f, 0.10564876f, 0.11375313f, 0.00826010f, 
    0.01099695f, 0.08706028f, -0.10414873f, -0.06646536f, -0.05206050f, -0.06003414f, -0.12589157f, -0.08408511f, 
    -0.13923410f, 0.04259552f, -0.07457006f, 0.10528383f, 0.68967974f, 0.19822831f, 0.36985207f, -0.02447199f, 
    0.06639452f, -0.04383026f, -0.03675953f, 0.01093956f, -0.16945679f, 0.03406147f, 0.42848688f, 0.38997754f, 
    -0.04728520f, 0.03072751f, -0.26730028f, 0.29204735f, -0.21260455f, -0.00925746f, 0.08468951f, -0.01198653f, 
    -0.02873501f, 0.00643821f, 0.10910670f, 0.06743293f, 0.14419910f, -0.15715927f, -0.10963750f, -0.05434966f, 
    -0.00990369f, 0.03126860f, 0.11651112f, -0.30984759f, 0.06590965f, 0.00088768f, -0.09469502f, 0.04218416f, 
    0.22909011f, 0.00205650f, -0.33477804f, 0.12016015f, -0.02194079f, 0.06562643f, -0.06029759f, 0.17870370f, 
    0.10866718f, -0.09250841f, 0.02482623f, 0.18004251f, -0.16536537f, -0.26808929f, -0.13504517f, 0.39931116f, 
    -0.06709742f, -0.21747597f, -0.14258450f, -0.13541567f, -0.03257840f, 0.03914870f, -0.14016406f, -0.10499243f, 
    0.29939866f, -0.02073018f, 0.17980357f, -0.11649612f, -0.02076610f, 0.26429331f, 0.06427786f, 0.08730595f, 
    -0.05202797f, 0.05470644f, 0.09829562f, 0.15221463f, 0.01188458f, -0.26479432f, -0.20404315f, -0.35339692f, 
    -0.03893339f, 0.00710582f, -0.04565712f, 0.05269217f, 0.06698926f, 0.29843882f, -0.14805996f, -0.04687089f, 
    0.05146653f, 0.46432018f, 0.30727315f, 0.19522871f, -0.17224820f, -0.21352328f, 0.05470755f, 0.35861364f, 
    -0.19375138f, 0.00799219f, -0.03892166f, -0.00719253f, -0.25649858f, -0.19108264f, 0.40500814f, 0.15349638f, 
    -0.05878108f, -0.19001427f, -0.20062263f, 0.16843154f, -0.13605969f, -0.01710180f, -0.01421432f, -0.06515505f, 
    -0.14857578f, -0.08800085f, 0.14202976f, -0.04904192f, -0.10661002f, 0.01070418f, 0.23936667f, -0.07121643f, 
    0.16681498f, 0.05584866f, 0.18167399f, 0.05114303f, -0.26169688f, -0.11655902f, 0.36244726f, 0.07913788f, 
    -0.20906188f, 0.03689776f, 0.04943693f, 0.04460924f, 0.09444285f, 0.35995734f, 0.14050996f, 0.11265075f, 
    0.10323966f, 0.07941213f, 0.03890438f, -0.21809441f, -0.01858967f, 0.24318866f, 0.10664310f, -0.07208683f, 
    0.24765815f, -0.00565389f, -0.01657348f, 0.09805997f, 0.48259109f, -0.00962316f, 0.33116299f, -0.17378563f, 
    0.23271509f, -0.07356857f, 0.07288203f, -0.12158900f, -0.01628554f, -0.04871970f, 0.10184668f, 0.01375325f, 
    0.03355725f, -0.02558943f, 0.03354240f, -0.06587882f, -0.00251294f, 0.04367601f, -0.00160567f, -0.01572246f, 
    -0.05049708f, -0.04778535f, 0.03643274f, 0.00638412f, 0.00779859f, 0.01534521f, -0.05853930f, -0.05628308f, 
    -0.00101338f, -0.07248883f, 0.03446093f, -0.03366091f, 0.05139551f, -0.06018436f, -0.01037974f, -0.05098417f, 
    0.03231667f, 0.00965811f, -0.08867653f, 0.04988500f, -0.04638054f, 0.04686001f, -0.02387024f, 0.05000112f, 
    -0.01905481f, 0.04245026f, 0.05166775f, 0.00550879f, -0.03422001f, 0.03345056f, 0.03631854f, -0.01945239f, 
    -0.03966291f, -0.07724869f, -0.02277471f, -0.03126212f, 0.02664534f, 0.02079353f, -0.00810876f, 0.04483806f, 
    0.02923085f, 0.05354863f, 0.01935818f, -0.06057158f, 0.05396781f, -0.04008353f, -0.01840287f, 0.05465977f, 
    0.04081392f, 0.00444469f, -0.03033612f, -0.00415365f, 0.02871422f, 0.02580613f, 0.00033395f, -0.01137264f, 
    -0.05092229f, -0.06635699f, -0.03640542f, 0.01537272f, -0.00243678f, 0.05949504f, 0.04976570f, 0.00273438f, 
    -0.08893795f, -0.04613291f, 0.03727448f, -0.02235244f, -0.04246782f, 0.00728979f, -0.01394572f, -0.00536208f, 
    0.01362666f, -0.01349551f, 0.01300783f, 0.00472571f, -0.04321270f, -0.04822959f, 0.03680140f, 0.04153207f, 
    -0.00780646f, 0.03466323f, -0.04049344f, -0.02500580f, -0.07025176f, 0.05184169f, 0.03554233f, 0.05523131f, 
    0.01959161f, -0.00254123f, 0.01439525f, 0.04076531f, -0.03794330f, -0.08306171f, -0.06822293f, -0.07075936f, 
    0.02640354f, -0.06017218f, -0.07222199f, -0.00345182f, 0.01288955f, 0.02573442f, 0.05527607f, -0.02956610f, 
    0.04948199f, -0.04957559f, -0.04216494f, -0.00940848f, -0.02115828f, -0.05510525f, 0.02113420f, 0.01106514f, 
    0.05375824f, -0.05803801f, 0.00935058f, -0.02196370f, 0.04020284f, -0.03628187f, -0.07890104f, -0.05269097f, 
    0.02399097f, -0.01542672f, -0.03675300f, -0.05727201f, 0.02328957f, -0.06114459f, -0.06477964f, 0.05238123f, 
    -0.02664521f, -0.03507094f, 0.01335548f, 0.00160508f, 0.01874080f, 0.03223576f, -0.03286610f, -0.01767619f, 
    0.04966151f, 0.05261075f, -0.02265238f, 0.01086388f, -0.05900782f, 0.00155942f, -0.02204972f, 0.02214128f, 
    -0.07137416f, 0.01951950f, 0.05426222f, -0.02059450f, 0.00530414f, 0.01568805f, -0.04041036f, -0.03230750f, 
    -0.04411601f, 0.01934307f, 0.03837121f, -0.06196856f, -0.01124497f, 0.02837051f, 0.01258087f, 0.03844224f, 
    -0.01620650f, 0.03797034f, 0.02606780f, -0.00507994f, 0.02121927f, 0.02536306f, -0.01740190f, -0.07385825f, 
    -0.06966551f, -0.07783204f, -0.00713651f, 0.05229585f, -0.03648663f, -0.04555387f, -0.04105202f, -0.00109780f, 
    -0.00294222f, 0.02631043f, -0.04523077f, 0.03254601f, -0.02922265f, -0.01593901f, -0.00805463f, -0.02768953f, 
    -0.27129436f, -0.04266263f, 0.12404987f, 0.04326588f, -0.06522018f, -0.07812938f, 0.07100884f, 0.00821137f, 
    -0.05784220f, -0.10641315f, -0.15666418f, -0.01805712f, 0.04424904f, -0.09569315f, 0.08819119f, 0.08532105f, 
    0.27740720f, 0.01893572f, -0.02944497f, -0.05024168f, -0.05542916f, 0.18086046f, 0.24699493f, 0.05245349f, 
    0.15519318f, 0.13716896f, 0.09936653f, 0.14932404f, -0.01971053f, -0.06667451f, -0.10090631f, 0.02189323f, 
    0.00898202f, 0.04407939f, 0.13551787f, 0.22216441f, 0.65456688f, 0.00272092f, -0.24956763f, 0.16416278f, 
    0.10404269f, -0.00588137f, 0.05572792f, -0.08283329f, 0.39026535f, 0.04594817f, 0.11995034f, 0.03147950f, 
    -0.44385597f, -0.16373205f, -0.70666933f, 0.23431154f, 0.08911119f, 0.13399932f, 0.14393459f, 0.10098507f, 
    -0.04538481f, -0.13188624f, 0.10990891f, 0.05999859f, -0.01884082f, -0.34110728f, -0.24062756f, 0.19099344f, 
    -0.06892269f, 0.14028513f, 0.26852593f, 0.10886918f, 0.00228101f, 0.03661440f, 0.22688700f, 0.11411678f, 
    -0.04540446f, 0.17508397f, -0.01565098f, 0.48371038f, 0.03107106f, 0.14345849f, 0.02461996f, -0.09678960f, 
    0.24071324f, -0.08787251f, -0.01404856f, 0.03493828f, -0.01689971f, -0.04353550f, -0.30156037f, -0.21580365f, 
    0.33439267f, -0.18924169f, 0.29157224f, -0.33936858f, -0.16396296f, -0.06527612f, -0.01023665f, -0.22424601f, 
    0.31719422f, -0.23501308f, -0.10435747f, 0.03475941f, 0.14535487f, 0.13691983f, -0.10913868f, 0.10031237f, 
    0.17566338f, 0.32191589f, -0.12637353f, 0.22819799f, 0.59821081f, -0.64767528f, 0.54821217f, -0.65032822f, 
    -0.08145790f, 0.24185410f, 0.10367373f, 0.38211998f, 0.00360753f, 0.10385266f, 0.03070025f, 0.15341447f, 
    -0.65501243f, 0.09922032f, -0.35446009f, 0.26152366f, 0.03590197f, -0.28598034f, -0.09707599f, 0.03587734f, 
    -0.27613586f, -0.03071049f, -0.01774615f, -0.03378462f, -0.34654576f, -0.16476353f, -0.25434446f, -0.24583384f, 
    0.03005449f, -0.33001634f, -0.15850291f, -0.18247761f, -0.07958999f, -0.11439686f, -0.05956157f, -0.06000609f, 
    -0.51834220f, -0.62754864f, -1.00720489f, 0.25589734f, 0.00983276f, 0.20921332f, -0.05603474f, -0.04932372f, 
    -0.00930591f, 0.05535765f, 0.05569366f, 0.03814340f, -1.05561376f, 0.09352865f, 0.02706325f, -0.30600619f, 
    -0.31941080f, 0.14637740f, -0.03027067f, 0.09022453f, -0.06940693f, -0.01515944f, -0.03723777f, 0.00097372f, 
    0.11186501f, 0.05528529f, 0.05375834f, -0.03303139f, -0.12082982f, -0.15091851f, 0.05079084f, 0.10489181f, 
    0.31739444f, 0.10785817f, -0.07266764f, 0.04385217f, 0.40679821f, -0.09623490f, 0.09940594f, 0.23426259f, 
    0.20465641f, 0.16770178f, 0.02796842f, -0.12707937f, -0.03941869f, -0.12468715f, -0.05007749f, -0.00700281f, 
    0.30632985f, -0.00222658f, -0.25959128f, -0.10092997f, 0.01130654f, 0.05782615f, 0.01952392f, -0.00180998f, 
    -0.00361665f, 0.05989193f, 0.17253028f, 0.02407863f, 0.13556834f, 0.59399760f, -0.39785770f, -0.10257554f, 
    0.32552645f, 0.10834163f, 0.01156836f, 0.01672571f, -0.16969386f, 0.15999551f, 0.06974772f, -0.03864108f, 
    0.11339027f, 0.15443854f, -0.03627331f, -0.10095107f, -0.10095975f, -0.09873114f, 0.04147357f, -0.07226028f, 
    -0.06991036f, -0.02220780f, 0.00322533f, 0.06438538f, -0.44926164f, 0.37257522f, 0.43014207f, 0.26579443f, 
    -0.02914139f, -0.04465810f, 0.01195435f, -0.03415635f, 0.02590285f, 0.12551434f, 0.25273201f, 0.23901153f, 
    0.03378005f, -0.22088259f, -0.02015475f, 0.40472856f, 0.06823221f, 0.00958311f, 0.08921029f, 0.10677282f, 
    0.04312787f, 0.06435224f, 0.04467689f, -0.10420655f, 0.00761279f, -0.37886515f, 0.01123381f, 0.10404355f, 
    0.06240333f, 0.09203060f, 0.10124251f, 0.09389250f, 0.16327013f, 0.01041184f, -0.18563429f, 0.08545030f, 
    -0.01014387f, 0.26920342f, 0.20500183f, -0.52089894f, 0.04562199f, -0.04366760f, 0.09720650f, 0.03182352f, 
    -0.02500802f, 0.02760532f, 0.07226938f, -0.01743162f, -0.30983943f, -0.31856194f, 0.24335957f, 0.26287925f, 
    0.07848176f, 0.05031794f, -0.19793221f, 0.15036759f, -0.00407741f, -0.04155724f, -0.11920771f, -0.01562958f, 
    -0.41040835f, 0.06441332f, 0.37912986f, 0.21368781f, -0.02068786f, -0.03176612f, 0.17214769f, -0.00563154f, 
    0.29674962f, 0.13134435f, 0.05813102f, 0.13410488f, 0.65865904f, -0.05969855f, -0.76128823f, 0.07084902f, 
    0.23272052f, -0.02697539f, 0.23927818f, -0.09115348f, 0.04868439f, 0.05585918f, 0.04196390f, -0.06844290f, 
    -0.18392356f, -0.31751686f, 0.37619793f, 0.34252647f, 0.20653465f, 0.08952008f, 0.24089316f, 0.16372433f, 
    0.19310871f, 0.04177359f, 0.05813146f, 0.10182529f, -0.33674151f, -0.51395446f, -0.11488074f, 0.08664168f, 
    0.04776602f, 0.06342538f, 0.05325555f, 0.19562390f, 0.05158562f, 0.05174412f, 0.00006130f, -0.14392407f, 
    -0.50419044f, -0.28512281f, -0.08149173f, 0.20281400f, -0.14224234f, 0.14596993f, 0.30397299f, 0.12866116f, 
    0.05527849f, -0.02516270f, 0.00113584f, -0.08427293f, 0.01032901f, -0.31587717f, 0.18743534f, 0.13003832f, 
    -0.02371581f, -0.16409998f, 0.06060676f, 0.06684079f, 0.06773742f, 0.19503668f, 0.08092856f, 0.06575108f, 
    -0.03511118f, 0.04940137f, 0.09518693f, -0.13789113f, -0.08885548f, 0.12160437f, 0.09418433f, -0.01155649f, 
    -0.02348852f, 0.07093391f, -0.00509512f, 0.18242534f, -0.10572696f, 0.33525556f, 0.26589212f, -0.26453343f, 
    -0.07080273f, 0.14024700f, 0.07458526f, 0.34534866f, 0.06063896f, 0.02374296f, 0.08186579f, -0.00245697f, 
    -0.01442368f, 0.01673977f, 0.03438417f, -0.01742354f, 0.00385446f, 0.05098442f, 0.04423945f, -0.05049362f, 
    0.02711117f, 0.06260061f, -0.03868543f, 0.00456113f, 0.03827366f, 0.02632983f, 0.04077037f, 0.00067455f, 
    0.06620447f, -0.01317732f, 0.00461435f, -0.04033385f, -0.03106169f, 0.02933828f, -0.01644141f, -0.01414524f, 
    0.01544277f, -0.01906008f, -0.04894206f, 0.01422990f, -0.02911431f, -0.05975130f, 0.00458774f, -0.05772857f, 
    -0.03455298f, 0.06347608f, 0.06123386f, -0.00104308f, -0.01134756f, 0.02512417f, 0.02220745f, -0.02724634f, 
    -0.03400865f, -0.02589559f, -0.05286163f, 0.05407164f, -0.07148446f, 0.01718442f, -0.05056871f, -0.05561054f, 
    -0.04654661f, -0.01178288f, 0.01346044f, 0.00709735f, -0.06008836f, 0.00880159f, -0.01946257f, 0.04494970f, 
    0.06295837f, -0.06499053f, -0.05988292f, -0.00579504f, 0.03551039f, -0.06885166f, -0.00900807f, 0.02931401f, 
    -0.07062929f, -0.06939877f, 0.02567588f, -0.00342938f, -0.07057760f, -0.05892417f, -0.05614851f, -0.02531963f, 
    -0.07686219f, 0.00798704f, 0.05938205f, -0.05365713f, 0.01032117f, -0.06971221f, 0.01919618f, -0.01460275f, 
    0.01119622f, -0.01665971f, -0.07082656f, 0.04165912f, -0.05674621f, -0.06452443f, 0.04935860f, -0.02839658f, 
    0.02097517f, -0.02218401f, -0.01711652f, -0.05344747f, 0.06278042f, -0.00797650f, 0.01218369f, -0.06843728f, 
    -0.04687102f, -0.02044364f, 0.05354625f, 0.00531513f, -0.05634403f, 0.04822488f, -0.00970116f, -0.02052864f, 
    -0.00179268f, -0.04787162f, -0.07007279f, -0.03020908f, -0.04342402f, 0.01740423f, 0.06473255f, 0.00879156f, 
    -0.04813013f, 0.05031653f, -0.02040080f, 0.07183240f, -0.05969105f, -0.07325822f, -0.02652960f, -0.07331008f, 
    -0.02778755f, -0.05564568f, -0.00844519f, -0.00837133f, -0.00108513f, -0.05624058f, -0.01498260f, 0.01152018f, 
    0.05354834f, -0.02601465f, 0.06310863f, -0.07725579f, 0.02984966f, -0.00426273f, -0.06840208f, 0.05848198f, 
    -0.07037300f, -0.05627779f, -0.02863964f, -0.04878994f, 0.01274177f, 0.05860218f, 0.05747793f, 0.00570591f, 
    -0.03351926f, -0.03932926f, -0.01687740f, 0.04427140f, -0.07399667f, 0.05948240f, 0.02884566f, 0.03911971f, 
    -0.01094445f, 0.02685989f, 0.02662993f, 0.07159643f, 0.04349357f, -0.00047048f, -0.06339812f, -0.02900859f, 
    -0.01062989f, -0.02695235f, 0.05126686f, 0.01947617f, 0.05649159f, -0.03468386f, 0.06773844f, 0.00681190f, 
    0.01080405f, -0.01392382f, -0.00717980f, -0.02067289f, 0.03482280f, -0.07114787f, 0.04156823f, 0.00951185f, 
    -0.05973836f, 0.00766968f, -0.03916113f, -0.05024001f, -0.03282294f, -0.03801613f, 0.01328337f, 0.00860658f, 
    -0.06065449f, 0.00020161f, 0.00222849f, -0.06879400f, -0.06665715f, 0.03183848f, -0.04021718f, -0.00686235f, 
    -0.05958975f, -0.02735352f, 0.03552563f, 0.02674096f, -0.02133144f, -0.09121517f, 0.02109756f, -0.07239614f, 
    0.06685166f, -0.01347984f, 0.06224848f, -0.05225518f, -0.05277872f, -0.35957733f, 0.28698727f, 0.13452725f, 
    -0.07613516f, -0.22616550f, 0.06421269f, -0.07282543f, 0.23481224f, -0.12194903f, 0.02760081f, 0.12720488f, 
    0.01848962f, -0.01800017f, 0.05835861f, 0.15511669f, -0.09567074f, -0.05780292f, -0.15020810f, -0.12460632f, 
    0.20434120f, 0.08634698f, 0.01593156f, 0.11302656f, 0.21519862f, -0.15781669f, -0.27430484f, -0.24454997f, 
    0.01760277f, -0.01056069f, 0.08252657f, 0.01793388f, 0.08474042f, -0.12583590f, -0.44983017f, -0.39761826f, 
    0.15958168f, 0.15592799f, 0.41325492f, -0.17856877f, -0.01306159f, 0.05485713f, -0.13710755f, 0.14242506f, 
    0.07432847f, 0.07592762f, -0.03313284f, -0.03058151f, -0.26926509f, 0.30511016f, -0.10262948f, -0.15143830f, 
    0.02543228f, -0.20957480f, -0.15706980f, -0.03483176f, -0.20294656f, -0.11009932f, 0.15634985f, -0.11027755f, 
    0.15556864f, -0.24757230f, -0.00491180f, 0.30779120f, -0.10017346f, 0.29254803f, -0.07606400f, -0.07350920f, 
    0.10313566f, 0.04036830f, -0.09537814f, 0.09666711f, 0.01006397f, 0.17014059f, 0.01200447f, -0.08622655f, 
    0.10269897f, 0.03014305f, 0.45527530f, -0.12162899f, 0.00351338f, -0.05649095f, 0.05882778f, -0.05437072f, 
    0.25918815f, 0.27357721f, 0.08044134f, 0.14838584f, 0.08134849f, 0.07121594f, -0.06699905f, 0.23484692f, 
    -0.01523695f, -0.15831283f, 0.12559405f, -0.01606823f, -0.37712044f, 0.02412654f, 0.80761909f, 0.23659049f, 
    0.05781457f, 0.19907385f, -0.01412309f, 0.19300234f, -0.13251293f, -0.05683922f, 0.18260072f, 0.16324784f, 
    -0.23898081f, -0.02189674f, -0.16669510f, -0.26426467f, -0.11534826f, 0.11863340f, -0.04877067f, 0.03815437f, 
    -0.08855847f, -0.10181740f, -0.13815284f, -0.00575067f, 0.06139826f, 0.22801721f, 0.26868418f, -0.05215331f, 
    0.04365418f, 0.15764233f, 0.25887400f, 0.07359392f, 0.03942561f, -0.00132829f, 0.04154364f, 0.09169212f, 
    0.17608273f, 0.22745220f, 0.02508458f, -0.12794770f, -0.03030986f, -0.19761133f, -0.24419232f, 0.13306996f, 
    0.11387014f, 0.15352841f, -0.08049950f, 0.01266121f, -0.02276933f, 0.34307966f, 0.08676245f, -0.05444934f, 
    -0.07092499f, 0.01709916f, -0.02882718f, 0.03177725f, 0.06968674f, -0.14186053f, -0.02825190f, -0.01035250f, 
    -0.10732472f, -0.08842807f, -0.01625640f, 0.09862609f, 0.18682542f, -0.17152132f, -0.26526490f, 0.09451227f, 
    -0.14381988f, 0.08495123f, 0.05329506f, -0.22549872f, 0.20825271f, -0.05899910f, 0.06176464f, 0.33346495f, 
    0.13194531f, 0.03214185f, 0.10781098f, 0.08730830f, 0.01714383f, 0.10763612f, -0.10498635f, 0.01168923f, 
    -0.32846960f, 0.01640603f, 0.04779994f, 0.13936844f, 0.19020261f, 0.07718328f, 0.03388503f, -0.24996991f, 
    0.01377000f, -0.16202468f, -0.14895278f, -0.20032920f, -0.16743600f, -0.23015870f, 0.15445776f, 0.19345245f, 
    0.29617861f, 0.03142642f, -0.03180363f, 0.10197063f, 0.00261215f, 0.03149541f, -0.06234017f, -0.18466878f, 
    -0.45481405f, -0.34145346f, -0.16968246f, 0.34137285f, 0.15508477f, 0.11799195f, -0.09395599f, 0.03948050f, 
    -0.26084110f, 0.02809502f, -0.00425158f, 0.01535275f, 0.28670514f, -0.25696144f, 0.07662466f, -0.14872245f, 
    -0.06489296f, -0.00847104f, -0.04364963f, -0.05968900f, -0.04671188f, 0.10868587f, 0.17239738f, 0.28441945f, 
    0.26606116f, 0.49422726f, 0.05780549f, -0.11605604f, 0.03887830f, -0.03992678f, 0.11578610f, 0.10174415f, 
    -0.06203497f, 0.01140904f, 0.12457415f, -0.05681174f, 0.34836504f, 0.18951678f, 0.00204307f, -0.00726963f, 
    0.16245465f, 0.12354503f, 0.04197622f, 0.13497244f, 0.05634212f, 0.15203749f, 0.14812176f, 0.21306556f, 
    -0.08689021f, -0.34418967f, -0.13796218f, -0.26379248f, 0.11374385f, -0.16073084f, -0.21783121f, -0.19916517f, 
    -0.04402721f, -0.13974760f, -0.06374247f, -0.15919386f, 0.35943270f, 0.33174351f, -0.23196925f, 0.01542003f, 
    -0.24504153f, 0.05722696f, -0.13600798f, 0.25096065f, -0.04622344f, -0.07402399f, -0.20326579f, -0.17997093f, 
    0.15882467f, -0.18704826f, -0.22643220f, -0.21260267f, 0.02378610f, 0.09993976f, 0.06954509f, 0.08682466f, 
    -0.12104837f, -0.00644349f, 0.12638049f, 0.28298309f, -0.20224375f, 0.21618731f, -0.38985616f, -0.10835629f, 
    0.02884002f, -0.01270927f, -0.12429524f, -0.06910957f, 0.17791888f, 0.04951080f, -0.24542689f, -0.16661185f, 
    0.58790290f, 0.25027841f, -0.02333554f, 0.05017527f, 0.16616732f, 0.12552178f, 0.12021886f, 0.03067805f, 
    0.04945134f, -0.08717614f, -0.00647929f, -0.01701439f, 0.52821809f, 0.40063539f, 0.18294574f, 0.05933138f, 
    -0.00110961f, 0.08511397f, -0.03066651f, 0.16376364f, -0.08295462f, -0.14244519f, -0.01470151f, -0.23569305f, 
    0.25466615f, 0.11138304f, 0.36536092f, 0.26758230f, 0.35757726f, 0.38851392f, 0.24879070f, 0.18113057f, 
    -0.03026043f, -0.05907667f, 0.02663561f, 0.24308433f, 0.30597475f, 0.05317893f, -0.02388193f, 0.15260908f, 
    0.13560005f, 0.01852733f, -0.09494058f, -0.14338210f, -0.02088290f, 0.20036018f, 0.19769390f, 0.18945570f, 
    -0.02070904f, -0.14429981f, -0.28165215f, -0.13157457f, 0.01932781f, 0.32491460f, 0.08682105f, -0.08885328f, 
    0.17716421f, -0.01527114f, 0.03995017f, 0.31889629f, 0.08665203f, -0.15848307f, -0.44920602f, -0.18083639f, 
    0.01972310f, -0.02001363f, 0.11549916f, 0.11436707f, -0.04862533f, -0.09600794f, -0.08657724f, -0.20344056f, 
    0.11152425f, 0.30225396f, -0.22682828f, -0.28464183f, 0.21805485f, 0.07573101f, 0.05163178f, -0.13528396f, 
    -0.49020895f, -0.23047504f, -0.42976204f, -0.45154324f, 0.27684394f, 0.45641470f, 0.07262634f, -0.33459482f, 
    0.00178005f, 0.08069463f, -0.12955967f, -0.11653183f, -0.09940274f, 0.03247083f, 0.02757412f, 0.17662212f, 
    0.40873998f, -0.10550591f, -0.16703944f, -0.15499584f, -0.23093826f, -0.13952495f, 0.23118150f, 0.20202547f, 
    -0.02837154f, 0.06991679f, 0.01533383f, 0.10390946f, -0.50150263f, 0.04061392f, -0.13841261f, 0.36774537f, 
    -0.19801497f, 0.07094081f, -0.01419423f, 0.08949099f, -0.04807673f, 0.15269610f, 0.11997794f, 0.33189875f, 
    -0.18723744f, 0.27194875f, 0.40241086f, -0.03675791f, 0.12440448f, -0.05851059f, -0.01371888f, 0.15166736f, 
    0.09735648f, -0.00986222f, -0.04170783f, 0.09689315f, 0.12210011f, 0.21531184f, -0.00202665f, -0.08526015f, 
    0.23756872f, 0.20775452f, 0.22943997f, 0.14817436f, 0.22227210f, 0.20054306f, 0.09849668f, 0.23592487f, 
    -0.37097728f, 0.39185968f, 0.26309291f, -0.23633663f, -0.01753310f, -0.16139404f, 0.11452871f, 0.05471799f, 
    -0.08525966f, -0.10198088f, -0.28247738f, -0.34593832f, 0.01427983f, 0.12428145f, -0.11389541f, -0.21065879f, 
    -0.09386843f, 0.11005970f, -0.19274315f, 0.13168336f, -0.31573954f, -0.20614424f, 0.03780936f, -0.29173207f, 
    -0.20766094f, 0.41409880f, -0.08804032f, 0.27330187f, 0.06974158f, -0.15633884f, -0.13698986f, -0.26593286f, 
    -0.02097053f, 0.03010461f, 0.14911492f, 0.09213817f, -0.16746785f, 0.03065520f, 0.89976227f, -0.04643480f, 
    0.11131259f, 0.09131608f, 0.12186655f, -0.01093946f, -0.08069612f, -0.30787155f, 0.18881953f, -0.05107662f, 
    -0.01493663f, 0.13368006f, -0.35924241f, 0.19019975f, -0.11915825f, -0.04825953f, -0.06624186f, -0.13169873f, 
    0.07114627f, -0.25213239f, -0.17703331f, -0.15375635f, 0.34921134f, 0.11461153f, -0.10870682f, 0.21391116f, 
    0.14400901f, 0.01203339f, -0.09463946f, 0.16230026f, 0.11450495f, -0.05960809f, -0.12969366f, -0.31308192f, 
    -0.08350344f, 0.15999821f, -0.17212537f, -0.07673470f, 0.19756895f, 0.09408979f, 0.08702829f, 0.13287769f, 
    0.09501876f, 0.17666756f, -0.10842786f, 0.13140498f, 0.73184699f, 0.17059781f, -0.12000122f, 0.44573405f, 
    -0.06938738f, -0.15017092f, 0.14036448f, 0.06723399f, 0.07554854f, 0.10761868f, -0.04583623f, -0.03309241f, 
    0.00565039f, 0.17633560f, 0.03822283f, 0.14431155f, -0.16264574f, -0.04855894f, -0.01421197f, -0.05578388f, 
    0.01368929f, 0.13159652f, 0.03295484f, 0.11375436f, -0.46150890f, 0.23824754f, 0.48469204f, 0.06361497f, 
    -0.14401025f, 0.02659227f, -0.22137703f, -0.00039860f, -0.00273162f, -0.12256366f, -0.09420747f, -0.13339956f, 
    -0.03449696f, -0.00688807f, -0.05898457f, 0.00523634f, -0.04158374f, -0.02391013f, 0.04517673f, -0.01528415f, 
    0.05066325f, -0.00076214f, -0.05175611f, 0.01484347f, -0.05762367f, -0.02387344f, 0.04189264f, -0.00487307f, 
    0.00404487f, 0.01606704f, 0.05041452f, -0.02972266f, -0.03039435f, -0.04326402f, 0.01937523f, -0.02479431f, 
    0.01614012f, -0.03232471f, 0.05393062f, 0.01219010f, -0.00436886f, 0.01364050f, -0.00786967f, 0.00303335f, 
    0.03059890f, -0.03863335f, 0.01118877f, 0.01894189f, -0.00896894f, -0.02588395f, -0.04645474f, -0.07530922f, 
    -0.00920766f, -0.04162672f, -0.06992331f, 0.03846967f, -0.07601995f, -0.05479975f, -0.01287368f, -0.04176619f, 
    0.00740125f, 0.03282355f, -0.00492808f, 0.05858174f, -0.01091110f, -0.06862406f, 0.00561202f, -0.00575516f, 
    0.00752141f, -0.04916002f, 0.05693913f, -0.03617885f, -0.00944498f, -0.02716730f, -0.05432221f, -0.00739445f, 
    -0.03956640f, 0.03937880f, 0.06033998f, -0.01117411f, -0.00729658f, 0.03413292f, -0.06282386f, 0.01474645f, 
    -0.01488979f, -0.06154411f, 0.01013144f, -0.00476643f, 0.04889682f, -0.07844338f, 0.02071051f, -0.00225958f, 
    0.03757795f, 0.05440446f, -0.05838281f, 0.02064499f, 0.00771274f, 0.05800113f, -0.04503363f, 0.04911420f, 
    -0.00228420f, 0.05182983f, 0.04329728f, 0.04473370f, -0.05587536f, -0.05217701f, 0.06551068f, -0.01616299f, 
    -0.00586603f, -0.01034031f, -0.03669927f, 0.00276756f, -0.04439098f, -0.07249523f, -0.00212300f, -0.02196454f, 
    -0.01227320f, 0.02371684f, -0.02560981f, 0.01315661f, -0.03182539f, -0.03301769f, 0.03102145f, 0.02992577f, 
    -0.03529549f, 0.03664136f, 0.05943296f, 0.05349690f, -0.02545955f, 0.02392719f, -0.04386579f, -0.05849534f, 
    0.04319917f, 0.02444480f, 0.02715019f, 0.04007888f, -0.07281011f, -0.01964750f, 0.04150333f, 0.02871536f, 
    0.03594046f, 0.03226744f, -0.03923946f, 0.00578599f, -0.07638880f, 0.02949426f, -0.03093608f, -0.00347743f, 
    0.01127720f, -0.05834222f, -0.06799667f, -0.07229768f, -0.04160851f, 0.04873146f, -0.02605067f, 0.01477123f, 
    -0.01431599f, 0.05751653f, -0.01198482f, -0.04771484f, -0.00964863f, 0.05781437f, -0.04545703f, -0.04303686f, 
    -0.07803287f, -0.03229306f, -0.01511391f, 0.00475645f, 0.01657289f, -0.02706918f, 0.05453221f, -0.05145559f, 
    -0.03473745f, -0.00955926f, 0.01573481f, 0.01816364f, 0.02001493f, -0.03136545f, 0.00903561f, -0.04427388f, 
    -0.06454176f, 0.02224210f, 0.05071219f, -0.03189520f, -0.03969805f, -0.03589159f, -0.00416865f, 0.03611258f, 
    -0.03294327f, -0.01541738f, -0.04700816f, 0.02743345f, -0.02462443f, -0.04498797f, -0.07502505f, -0.01313127f, 
    0.03090156f, -0.02729561f, -0.06018708f, -0.05987065f, -0.02231023f, 0.01689807f, 0.02958658f, -0.07099060f, 
    0.05832030f, 0.04340263f, -0.08284170f, -0.02812614f, 0.02144064f, -0.07719437f, -0.07994049f, 0.03211147f, 
    -0.02191818f, 0.04998362f, 0.01388336f, -0.03661079f, -0.04987518f, 0.04500387f, 0.02369561f, 0.04179632f, 
    -0.07539714f, -0.04077386f, 0.03829731f, 0.06136499f, 0.02609176f, -0.02639426f, -0.04498717f, -0.03967177f, 
    -0.01676532f, -0.03897592f, 0.02985643f, 0.01022806f, -0.00732171f, -0.04921194f, -0.06932463f, 0.05553759f, 
    0.04788438f, -0.02477838f, 0.00942953f, 0.02749104f, 0.02489444f, 0.06429788f, -0.04625456f, -0.03766550f, 
    0.01716742f, -0.07773130f, 0.05685006f, 0.06445227f, -0.03249597f, -0.06016373f, 0.05483161f, 0.01657499f, 
    -0.04676551f, -0.00143536f, 0.06476438f, -0.03450804f, -0.05727503f, 0.03418982f, -0.03068983f, 0.04629983f, 
    -0.05823016f, 0.01156690f, -0.06655983f, -0.03054675f, -0.02821689f, 0.07130498f, 0.05072771f, -0.05101024f, 
    0.04942621f, -0.00019617f, 0.05290926f, 0.00052269f, 0.06783394f, -0.00752362f, -0.07179551f, -0.04923020f, 
    0.05592572f, -0.06437549f, -0.05247035f, -0.02722873f, -0.02473037f, -0.00018406f, 0.00449251f, -0.06612282f, 
    0.05939528f, -0.02120908f, -0.04346063f, -0.01322397f, 0.04592882f, -0.05228987f, -0.08217049f, -0.01048228f, 
    -0.07784896f, -0.07546907f, -0.05796054f, 0.01329172f, -0.03999709f, -0.05354634f, -0.04035667f, 0.06017377f, 
    0.03351938f, 0.01758489f, -0.02169533f, -0.02550553f, 0.05409419f, 0.02280081f, -0.05731991f, 0.00313511f, 
    0.02826983f, -0.01170316f, 0.00448999f, -0.00031473f, -0.03527900f, -0.00132735f, -0.01647059f, -0.01604765f, 
    -0.05708565f, 0.02587829f, -0.06725840f, -0.01966252f, -0.02180330f, 0.02094303f, -0.04132308f, 0.03418769f, 
    -0.02207696f, 0.01820100f, -0.06000275f, -0.02270975f, 0.05416910f, -0.02802478f, -0.00329818f, 0.02349987f, 
    -0.04741418f, -0.06180586f, -0.00735961f, -0.01667291f, -0.03785298f, -0.02992570f, -0.07236429f, -0.00535890f, 
    0.02853801f, 0.00788590f, -0.01128729f, 0.04595716f, -0.02750320f, 0.05216738f, -0.03674112f, 0.02054088f, 
    0.01242130f, -0.00941563f, 0.03125565f, 0.03185920f, -0.03714955f, -0.01840519f, -0.04066846f, 0.05496910f, 
    -0.04712221f, -0.01716730f, -0.00527312f, 0.03459874f, -0.03765195f, -0.03031653f, -0.05875079f, -0.03920716f, 
    -0.05479071f, 0.03765567f, -0.06936701f, -0.03775283f, 0.02885098f, 0.01630344f, 0.02942174f, -0.07687107f, 
    -0.01816470f, -0.06993063f, -0.00351551f, 0.04075227f, -0.00373485f, -0.02610188f, 0.01302500f, -0.02086254f, 
    -0.04431930f, 0.05862293f, -0.02040103f, 0.02137842f, 0.04705233f, -0.03010565f, -0.01667125f, 0.05420447f, 
    0.00789488f, -0.06304274f, -0.02489588f, -0.00291401f, 0.03384524f, 0.03132089f, -0.03122630f, -0.00856817f, 
    0.32530272f, -0.10358385f, -0.01636338f, 0.07388125f, 0.07236289f, -0.05475632f, -0.16454422f, 0.11064494f, 
    -0.06510086f, 0.01748220f, -0.05991711f, 0.04972166f, 0.22290935f, -1.08105123f, 0.27417755f, -0.00058737f, 
    -0.03227172f, -0.07155465f, -0.22868271f, -0.13776505f, 0.17071572f, 0.20696089f, -0.08437075f, 0.07361721f, 
    0.20816427f, 0.11979014f, 0.08693493f, -0.03180644f, 0.08069769f, -0.06177650f, -0.04908917f, -0.02341400f, 
    0.22547223f, -0.01899133f, -0.00542867f, 0.03220553f, -0.22363283f, 0.29361245f, -0.18781653f, -0.28487521f, 
    0.00357216f, 0.05877015f, 0.10314973f, 0.07725609f, 0.04271080f, 0.10271932f, -0.03211853f, 0.08065157f, 
    0.05539058f, -0.33289698f, 0.45266190f, 0.20448193f, 0.12713531f, 0.04592500f, 0.03159219f, 0.22942215f, 
    0.09406964f, -0.08014957f, -0.14453977f, -0.00027690f, -0.24973977f, 0.19602193f, -0.24906307f, 0.27399242f, 
    0.04780440f, 0.04224123f, 0.05798132f, 0.15715684f, -0.09204095f, -0.09099858f, 0.11965157f, 0.12690508f, 
    0.05186703f, -0.41988111f, 0.51087344f, -0.28028181f, 0.16465761f, 0.05224359f, 0.10176346f, 0.13695955f, 
    -0.03589665f, -0.13293944f, 0.02962587f, -0.02635345f, -0.26367250f, -0.19612147f, 0.36636120f, -0.12129378f, 
    0.05353462f, -0.05359216f, 0.11205291f, -0.11519064f, 0.03317564f, -0.02720154f, 0.10795910f, 0.02290749f, 
    0.21952443f, 0.03770558f, 0.10688742f, -0.20558107f, 0.06542130f, 0.06277091f, 0.21744056f, -0.06664658f, 
    0.15538126f, 0.08266133f, 0.22804393f, -0.11090808f, -0.15632202f, 0.24904227f, -0.06442929f, 0.39580250f, 
    0.00431907f, -0.13033023f, 0.04255686f, -0.04687178f, 0.16166995f, -0.06467325f, 0.10131960f, -0.15330096f, 
    -0.34399429f, -0.14459831f, 0.13097632f, -0.14447179f, -0.07483190f, -0.16101608f, -0.01734684f, -0.08163822f, 
    0.10646801f, -0.08000313f, 0.03808457f, 0.12109347f, -0.15117256f, 0.18019146f, 0.22088033f, -0.01625101f, 
    -0.02371833f, 0.04439387f, 0.18413289f, 0.12859640f, 0.06504616f, 0.05848781f, -0.09051145f, -0.01714473f, 
    -0.32089946f, 0.11982197f, 0.02133791f, -0.09576868f, 0.03966619f, -0.11584450f, 0.01547869f, 0.20014767f, 
    -0.07139052f, 0.04463571f, 0.02438224f, 0.21501422f, -0.16801403f, 0.27224866f, 0.10066579f, 0.04273716f, 
    -0.16479911f, -0.27878782f, 0.01571696f, 0.01616041f, 0.20018712f, -0.22303398f, 0.04808827f, 0.02443700f, 
    0.02771889f, -0.00528624f, -0.08004311f, 0.11343752f, 0.13106254f, -0.05086987f, -0.00983449f, 0.09363646f, 
    -0.16234615f, 0.06013182f, -0.12745716f, -0.05166233f, 0.03425507f, 0.20976204f, -0.30182460f, 0.24783871f, 
    0.27808204f, 0.24928731f, 0.06724888f, 0.03189493f, 0.14211650f, 0.19694176f, -0.14906564f, 0.09267909f, 
    -0.03301181f, -0.03723076f, -0.15567516f, -0.05358015f, 0.09156752f, -0.05197768f, 0.06118147f, -0.14469065f, 
    0.19697259f, -0.01511876f, 0.14100671f, -0.00776643f, 0.05787335f, 0.51360536f, -0.20731272f, -0.09398921f, 
    0.07120311f, 0.02844491f, 0.16351771f, 0.08976399f, -0.01780731f, -0.07377696f, 0.17797506f, 0.01709020f, 
    0.15885507f, 0.20316052f, 0.20814659f, 0.06929670f, -0.12209657f, -0.02207925f, -0.08553183f, -0.09302956f, 
    -0.17313564f, 0.15596339f, -0.04678129f, -0.08192091f, 0.27371839f, -0.26437312f, 0.42284539f, 0.32268175f, 
    0.00642964f, -0.04994300f, 0.02508332f, 0.00335647f, -0.12756492f, -0.04947846f, -0.06727325f, -0.08906636f, 
    0.06318108f, 0.23736848f, -0.15097880f, -0.17548388f, -0.10877725f, -0.02697030f, 0.08978465f, -0.05132993f, 
    -0.09265170f, 0.02336885f, 0.15493518f, -0.08208502f, 0.24049455f, -0.11000772f, 0.17595668f, -0.41324294f, 
    0.18076256f, 0.12954138f, 0.02391605f, 0.05367931f, -0.00455544f, -0.05980950f, -0.17165649f, -0.02490314f, 
    0.38207361f, 0.25918153f, -0.09663405f, 0.08934505f, -0.13049954f, -0.09276084f, -0.24611470f, -0.19800843f, 
    0.13729939f, -0.03133231f, 0.05837395f, 0.04685442f, 0.24184529f, 0.11562208f, -0.37044573f, 0.20866393f, 
    -0.19738832f, 0.11040487f, -0.13040835f, 0.17706102f, -0.04675974f, -0.05279394f, -0.09602247f, 0.14492750f, 
    -0.09284706f, 0.30257604f, 0.17685652f, 0.20672926f, -0.06999690f, -0.11702075f, 0.04347993f, 0.23061754f, 
    -0.18861213f, -0.03880251f, -0.01859681f, 0.08563828f, 0.08014395f, -0.06546260f, -0.13562830f, -0.03153822f, 
    0.13144228f, 0.16675444f, 0.00485177f, -0.03620464f, -0.02447257f, 0.11124524f, 0.00472084f, -0.00620011f, 
    0.46522704f, -0.08259971f, -0.25329122f, 0.02508418f, -0.00204556f, 0.05766175f, 0.12095697f, 0.08746983f, 
    -0.07686583f, 0.07481910f, 0.08937480f, -0.03715327f, 0.23615915f, -0.18359406f, 0.05850291f, 0.11500961f, 
    -0.05737501f, 0.18580122f, 0.06177543f, 0.12139870f, -0.13185747f, -0.02035988f, 0.02258204f, -0.02832545f, 
    0.41292843f, 0.00446665f, 0.14671455f, 0.18045741f, 0.12319037f, 0.12375376f, 0.06230641f, 0.03162843f, 
    -0.07752983f, 0.05741461f, -0.02341687f, -0.07700931f, 0.12873225f, -0.50150263f, -0.29684752f, -0.10499615f, 
    0.15307225f, 0.25285500f, 0.11454887f, 0.09854052f, -0.05784879f, 0.22063462f, -0.10140546f, -0.14835665f, 
    0.11894778f, 0.20032208f, 0.10128780f, -0.00582638f, -0.13013667f, 0.20607409f, 0.00317691f, -0.13810261f, 
    0.33555824f, -0.09312627f, 0.09071633f, -0.05757977f, 0.19137295f, 0.11298487f, 0.18815668f, -0.32212728f, 
    -0.31294438f, -0.05210471f, -0.01198976f, -0.11293978f, -0.11840779f, -0.08046029f, 0.13765721f, -0.13858388f, 
    0.02112210f, 0.04951286f, 0.09130510f, -0.12519367f, 0.11757617f, 0.04598998f, 0.05068721f, -0.05053967f, 
    -0.01311842f, -0.10642068f, -0.03872586f, 0.01456497f, 0.30486897f, -0.18068105f, 0.19157876f, -0.38396546f, 
    0.00359363f, 0.23869260f, -0.06678927f, -0.14566837f, -0.10172807f, 0.10920020f, -0.04937090f, -0.12668008f, 
    0.21295127f, 0.35625753f, 0.28088427f, 0.14296383f, -0.06038478f, -0.09593458f, -0.05394793f, -0.14429913f, 
    0.26248354f, 0.18356816f, 0.14318027f, -0.10271769f, 0.45916989f, -0.10386568f, 0.07251098f, 0.11432744f, 
    -0.09177627f, -0.01013375f, 0.22408828f, 0.26778403f, -0.01296731f, -0.06250694f, -0.02146137f, -0.20217150f, 
    -0.25416201f, -0.26468059f, 0.11338229f, -0.04801743f, 0.10225597f, 0.13421588f, 0.25468555f, 0.15997753f, 
    0.04713548f, 0.02302976f, -0.08127343f, -0.00043042f, 0.04297684f, -0.03917002f, -0.05823718f, 0.38593081f, 
    -0.01430765f, 0.20735192f, 0.09151281f, 0.10952467f, -0.00099543f, -0.07438768f, 0.01471707f, 0.06237678f, 
    0.32021260f, -0.10509300f, 0.33989102f, 0.07272775f, 0.01836233f, -0.05206072f, -0.16235848f, -0.20370422f, 
    0.02331848f, 0.03211582f, 0.03363231f, 0.03074663f, -0.15144940f, -0.46108493f, 0.04214089f, 0.14206631f, 
    -0.10839857f, 0.21996465f, 0.01340085f, 0.01025185f, 0.00158631f, -0.06315032f, 0.04329840f, 0.13923657f, 
    0.22456512f, 0.14483948f, 0.14466488f, 0.17486477f, -0.02143675f, 0.10233122f, 0.03234424f, 0.19353417f, 
    -0.04744835f, -0.05954820f, -0.01358875f, 0.07389141f, -0.15819645f, 0.18120047f, -0.29461855f, 0.26355585f, 
    -0.09488349f, -0.00774946f, 0.11963900f, -0.08776830f, 0.01765836f, -0.08928061f, 0.11394218f, -0.12623236f, 
    0.26578590f, -0.53576100f, -0.57535124f, -0.46539459f, 0.00491414f, -0.21238381f, 0.02345773f, 0.09500565f, 
    -0.05016625f, 0.13614728f, 0.10153939f, 0.02965726f, 0.15167719f, 0.24876201f, -0.04313204f, 0.07828373f, 
    -0.05848106f, 0.29328647f, 0.10963696f, 0.21918574f, 0.01609940f, 0.04389310f, 0.11915720f, 0.07863324f, 
    0.20636000f, -0.28407136f, -0.67906994f, -0.01200312f, -0.04370667f, 0.06929377f, 0.09869035f, 0.24751665f, 
    -0.07037254f, 0.12218605f, 0.02144023f, 0.12893432f, -0.35988310f, -0.37672794f, -0.44477317f, -0.31699365f, 
    0.21321541f, 0.14545055f, -0.04429938f, 0.09585838f, 0.36867067f, -0.01712683f, -0.05674066f, -0.11581670f, 
    0.12741418f, 0.08702280f, 0.02611925f, 0.08663133f, -0.06365421f, 0.01556050f, -0.04295243f, -0.09397739f, 
    0.08751182f, 0.16361111f, -0.04455680f, -0.10642882f, 0.27482158f, 0.00733045f, -0.31079304f, 0.21899809f, 
    -0.09966685f, 0.19454888f, 0.13044353f, -0.06670617f, -0.04553276f, -0.02715073f, 0.01030520f, -0.11519166f, 
    -0.25770798f, 0.00688502f, 0.06589691f, 0.09188689f, -0.09676987f, 0.12883981f, 0.07003209f, 0.04973514f, 
    -0.21062392f, -0.06553044f, 0.09135815f, -0.00995199f, 0.27279389f, -0.48772928f, 0.31928551f, 0.13203591f, 
    0.02667228f, 0.12032244f, 0.10331994f, 0.27387571f, 0.01949101f, 0.13472027f, 0.03294674f, -0.12153515f, 
    0.20817930f, -0.10566007f, 0.14086984f, 0.23627762f, -0.03951813f, -0.08878095f, -0.03721976f, -0.03679359f, 
    0.10286465f, -0.01546686f, -0.04404813f, -0.01239697f, 0.67680764f, 0.00658591f, 0.02159413f, -0.26294875f, 
    0.03030432f, -0.13000385f, 0.01435642f, -0.08315106f, 0.07905529f, 0.11878049f, -0.02211087f, -0.08538482f, 
    -0.54471517f, 0.07380398f, -0.13870914f, -0.21838915f, -0.06957292f, 0.15183540f, -0.12246744f, 0.06282776f, 
    -0.17009984f, -0.03823477f, 0.01850367f, -0.04759086f, -0.13339639f, 0.01152939f, -0.34227252f, -0.22995897f, 
    0.43367758f, 0.17215481f, -0.12069385f, -0.19696768f, -0.07083260f, -0.06183282f, -0.02575169f, 0.05082596f, 
    0.32200631f, -0.06064059f, -0.19727907f, -0.03203287f, 0.11186777f, 0.23437825f, -0.08645447f, 0.09316247f, 
    0.30998880f, 0.03483995f, 0.17234878f, 0.15696855f, 0.09313917f, 0.11826898f, -0.28790951f, 0.00184957f, 
    -0.05189248f, 0.18519028f, -0.04793984f, 0.32225946f, -0.00411260f, 0.05307244f, -0.03691834f, 0.03564815f, 
    0.41657791f, -0.14405502f, -0.06735647f, -0.15778212f, 0.22768316f, 0.00395097f, -0.10384301f, 0.08314038f, 
    -0.08889933f, -0.15018725f, 0.08451460f, 0.20945007f, -0.49992007f, -0.35610610f, 0.09745114f, 0.43987417f, 
    -0.01384535f, 0.15428300f, 0.11709361f, -0.15214549f, -0.00468554f, -0.08493000f, -0.06706578f, 0.22151358f, 
    0.45053759f, 0.43844113f, 0.28466484f, 0.01864659f, -0.08385424f, 0.03841230f, -0.01777997f, 0.08251971f, 
    -0.11938836f, 0.08493093f, -0.02850589f, -0.01708265f, -0.02799032f, -0.04221523f, 0.20007758f, 0.08625685f, 
    0.06945446f, 0.05005327f, 0.07724709f, -0.07439741f, -0.15448216f, 0.01641838f, 0.18150260f, 0.06401356f, 
    0.10606364f, 0.05241905f, 0.44945854f, -0.19717413f, 0.05899384f, 0.02623697f, -0.01848259f, -0.12359004f, 
    -0.06263466f, -0.14645433f, -0.09833713f, -0.18018681f, 0.19879267f, 0.07075374f, 0.28020537f, -0.08883602f, 
    -0.06905948f, -0.03352848f, -0.03051977f, 0.04958515f, -0.05910345f, 0.17837885f, 0.03307923f, 0.03810746f, 
    0.07998712f, 0.09804722f, 0.14336006f, 0.10174792f, 0.02989322f, 0.09237879f, -0.15258019f, -0.00659132f, 
    0.10995622f, -0.10727637f, 0.04050116f, 0.03901411f, 0.29478285f, 0.04183681f, -0.28666529f, -0.22793943f, 
    0.01762125f, -0.03632645f, 0.00286762f, -0.01137305f, 0.07851052f, 0.18819723f, 0.12965764f, -0.10393612f, 
    -0.07968239f, -0.11490694f, -0.23093234f, -0.00182099f, 0.16446888f, 0.00874034f, -0.17205733f, -0.03821460f, 
    0.12873681f, 0.05529940f, 0.01858929f, -0.07393198f, -0.80478019f, 0.59742248f, -0.12433021f, 0.79439139f, 
    0.34507266f, 0.29171041f, -0.12859610f, -0.07882524f, -0.14380577f, 0.07015481f, 0.02069561f, 0.10431816f, 
    -0.42904642f, -0.06480390f, -0.13314730f, 0.02841821f, 0.05699041f, 0.03143017f, 0.01117751f, -0.08557656f, 
    0.03649561f, 0.11704572f, -0.03495065f, 0.05867783f, -0.14953427f, 0.27742332f, 0.20006734f, -0.02604984f, 
    0.04610933f, 0.12494757f, -0.04172193f, -0.06871714f, 0.12576073f, 0.10631418f, 0.01631723f, 0.14261942f, 
    -0.10260886f, -0.06797211f, -0.05200194f, 0.15672491f, 0.06372581f, 0.07048676f, 0.07922969f, 0.11073332f, 
    0.00729371f, -0.00483744f, 0.06246885f, 0.03683327f, 0.15497093f, -0.36991486f, 0.06768908f, 0.07323574f, 
    -0.06071720f, -0.22130175f, 0.06303051f, 0.01640710f, 0.00797884f, 0.10707492f, -0.15259241f, -0.17676316f, 
    -0.33929369f, 0.35289165f, -0.30333841f, 0.32950476f, 0.05107727f, -0.20038813f, -0.10220721f, 0.12457128f, 
    -0.04701182f, 0.02429751f, -0.04375719f, 0.02992274f, -0.13391627f, -0.39037216f, 0.15683575f, 0.40884259f, 
    0.03350321f, -0.16558518f, 0.15461648f, -0.12178584f, -0.03085697f, 0.09031274f, -0.08292928f, -0.11623453f, 
    -0.17401369f, -0.16356276f, -0.03823540f, -0.07594697f, -0.17555150f, -0.08545045f, 0.06315342f, 0.02793605f, 
    0.10276099f, 0.06768879f, -0.02020812f, 0.09334048f, 0.34381664f, 0.02590244f, -0.06610940f, -0.16406064f, 
    0.07193998f, 0.06080833f, -0.14771919f, 0.05887541f, -0.11457785f, 0.09760859f, 0.13842539f, -0.08386882f, 
    0.01375624f, 0.38693073f, 0.48023808f, 0.32520536f, 0.04278082f, 0.01254326f, -0.04226385f, -0.17243238f, 
    0.01763800f, -0.07296003f, 0.09499536f, -0.08949420f, -0.05899394f, -0.12031951f, 0.14015788f, 0.11542401f, 
    -0.08779598f, 0.13929243f, -0.04772132f, 0.24634826f, 0.10831749f, -0.07159086f, 0.00647406f, -0.01157566f, 
    -0.42701298f, -0.13783520f, -0.16290085f, 0.18939595f, -0.19894652f, 0.16655184f, 0.02885322f, 0.06058186f, 
    0.22766513f, 0.19675982f, 0.19366223f, 0.05572254f, -0.34007418f, -0.11414242f, 0.11272357f, 0.15442573f, 
    0.08073002f, -0.11131768f, 0.05515268f, 0.08918723f, 0.00545147f, 0.17389733f, -0.05037292f, 0.04440285f, 
    -0.03553320f, -0.18816036f, 0.08574353f, -0.14588675f, -0.06920949f, 0.08658115f, 0.04659045f, 0.10840951f, 
    0.17786226f, 0.16414981f, 0.09142538f, -0.06520540f, 0.05311782f, 0.16619608f, 0.42704025f, 0.21122108f, 
    0.17353003f, 0.22705959f, 0.10769690f, -0.14136820f, 0.08170647f, -0.00947176f, -0.16629995f, -0.12420916f, 
    -0.11233847f, -0.28975824f, 0.07176620f, 0.08031134f, 0.05253424f, -0.15478474f, -0.04198126f, 0.16423315f, 
    0.08118420f, 0.04893516f, -0.01795762f, 0.11204214f, -0.00137299f, -0.34486020f, 0.04332073f, 0.22457762f, 
    0.03309856f, -0.27629969f, 0.02940834f, 0.05967529f, 0.14734505f, -0.08545287f, 0.10766989f, -0.08933479f, 
    -0.24238601f, 0.01686711f, -0.03725072f, 0.29909050f, -0.07289599f, -0.11975939f, -0.22094135f, -0.11983882f, 
    0.09358118f, -0.06518123f, 0.16210169f, -0.03908215f, 0.13770612f, -0.02720984f, -0.09408379f, -0.40929210f, 
    -0.11972113f, 0.17207064f, 0.22269846f, -0.07447118f, 0.26802531f, 0.18159798f, 0.08994113f, -0.10496230f, 
    0.50005317f, -0.10446837f, 0.14821228f, -0.25081700f, 0.44844198f, 0.00423120f, 0.07482752f, 0.17772898f, 
    0.06545851f, 0.03153514f, -0.08980867f, -0.09962290f, -0.25815451f, 0.20689929f, 0.16202566f, -0.21184157f, 
    -0.25437486f, -0.21378560f, 0.06445153f, 0.41660061f, -0.02485875f, 0.03498570f, 0.28450409f, -0.02130706f, 
    0.09822548f, -0.39202183f, 0.16912030f, -0.11403568f, -0.02295091f, 0.13361841f, 0.07029735f, -0.19375257f, 
    0.09649555f, 0.11824337f, 0.06611618f, 0.15014008f, -0.05379121f, 0.23484980f, 0.36701757f, -0.41085011f, 
    0.07492026f, 0.14451484f, 0.27634826f, 0.14307766f, 0.04968657f, 0.12057773f, 0.15825927f, 0.10081280f, 
    0.10117719f, 0.10701460f, 0.25080693f, -0.15182127f, 0.06372291f, 0.31529668f, 0.05919914f, 0.29529706f, 
    0.26114637f, 0.18707386f, 0.01520488f, -0.13686410f, -0.23562680f, 0.38680047f, -0.45753521f, 0.13103363f, 
    0.30576694f, -0.18513422f, -0.03398132f, 0.31957605f, 0.10191355f, 0.13627261f, -0.01948451f, 0.04507998f, 
    -0.43098179f, -0.41604492f, 0.02543183f, -0.60464454f, 0.14097762f, 0.28711444f, 0.15976799f, 0.01983377f, 
    0.08715573f, 0.10595239f, 0.09141724f, 0.04386320f, -0.10993728f, 0.26488286f, -0.30812573f, -0.51455295f, 
    0.19735061f, 0.25018460f, 0.18185313f, -0.24951975f, -0.01612479f, -0.04103305f, -0.04417032f, 0.06387296f, 
    0.32149589f, 0.06305337f, 0.14378966f, -0.08418037f, 0.14136752f, -0.27403715f, -0.08464225f, 0.16084573f, 
    0.02986300f, -0.13679716f, 0.03632446f, -0.13450651f, -0.14018136f, 0.40773493f, 0.03490845f, -0.38343611f, 
    -0.01018273f, 0.05356366f, -0.10360310f, -0.14027902f, 0.09423002f, -0.35181668f, -0.01131311f, 0.06512911f, 
    -0.19160347f, -0.22746269f, -0.25976562f, -0.05636831f, 0.14727494f, -0.12050864f, 0.04139721f, 0.13104624f, 
    0.04379248f, 0.17727491f, 0.02363746f, -0.08290190f, 0.09103128f, -0.11473805f, -0.27947843f, -0.04174959f, 
    0.17903061f, 0.20158140f, 0.11889137f, 0.19857101f, 0.03475414f, -0.05920721f, 0.03707806f, 0.12846133f, 
    -0.04330758f, -0.16982283f, -0.19079715f, -0.04295774f, 0.02930817f, 0.07233736f, 0.01157929f, -0.02103589f, 
    0.01030806f, 0.12642360f, 0.03040438f, -0.02053097f, -0.27212322f, -0.45714352f, -0.07723452f, 0.37438110f, 
    0.23921883f, 0.17406119f, -0.00094676f, 0.25617900f, 0.33888292f, 0.12284155f, 0.17909415f, -0.13312501f, 
    0.07526986f, 0.06313986f, -0.07705662f, -0.15110789f, -0.26599640f, -0.07282312f, -0.05105512f, -0.20357256f, 
    0.04570547f, 0.05175177f, 0.00584909f, -0.09458423f, 0.47587836f, 0.10934467f, 0.29948485f, -0.15092809f, 
    -0.00619098f, 0.04450752f, 0.17315561f, 0.04468248f, 0.00083371f, 0.01156369f, 0.05497852f, 0.00073711f, 
    -0.10438787f, -0.13219804f, 0.04928840f, -0.09269458f, 0.01282678f, -0.17721137f, 0.08831812f, -0.04934605f, 
    -0.06055733f, 0.03474334f, 0.01696521f, -0.05901742f, -0.18558104f, 0.04108111f, -0.06095030f, -0.25124165f, 
    0.04096010f, -0.13533551f, 0.14870855f, -0.02102538f, 0.02390602f, 0.01744640f, -0.19139273f, -0.10431816f, 
    0.34837186f, 0.04106520f, -0.08851074f, 0.18702613f, -0.03498286f, 0.18550764f, -0.03122011f, 0.23022699f, 
    0.17698444f, 0.12624733f, 0.09663174f, 0.10294003f, -0.09537677f, 0.00335394f, 0.04204250f, 0.01903425f, 
    -0.10481506f, 0.04390024f, 0.24837598f, 0.03935461f, -0.04036937f, -0.13284327f, -0.14618313f, 0.02573271f, 
    0.20714477f, 0.41938958f, 0.65735584f, 0.18709949f, 0.13864353f, 0.10170632f, 0.05473948f, 0.62210482f, 
    0.22748253f, 0.04175491f, 0.51442719f, 0.09406714f, -0.14930843f, -0.35047284f, 0.13450411f, 0.07282518f, 
    0.23048502f, 0.18913154f, 0.00122971f, 0.17392899f, -0.23483741f, 0.09324411f, 0.23859988f, 0.15109260f, 
    -0.05120536f, 0.04401831f, 0.10189372f, -0.21844895f, -0.27893165f, -0.13498297f, 0.10799213f, 0.46402910f, 
    -0.22523269f, -0.04378456f, -0.13004166f, -0.17817329f, -0.34026703f, -0.24093691f, 0.35703537f, -0.16953240f, 
    0.03618230f, -0.01970723f, 0.12632295f, -0.07501513f, -0.02845157f, -0.09980683f, -0.06616694f, 0.02851768f, 
    0.41527489f, 0.05955606f, 0.30282480f, -0.16984104f, 0.06326173f, -0.18131521f, 0.10096749f, 0.28693467f, 
    -0.01072481f, 0.05689095f, -0.05996069f, -0.21802551f, -0.23786274f, -0.00771890f, 0.32474872f, -0.25551710f, 
    -0.26247624f, -0.08567009f, -0.06544995f, 0.25204328f, 0.11049700f, -0.03125890f, -0.00797167f, -0.03028405f, 
    0.02455458f, 0.05466036f, 0.12433159f, -0.17053542f, 0.02799629f, -0.00539354f, 0.00666311f, -0.02516143f, 
    -0.03812685f, 0.12122223f, 0.19495735f, 0.13772108f, 0.40256509f, 0.22147760f, 0.51246506f, -0.22599462f, 
    0.02533477f, 0.10103122f, 0.18055212f, 0.10255593f, 0.00469400f, 0.18375812f, 0.28638744f, 0.16136739f, 
    -0.03875607f, 0.05631205f, -0.02716571f, -0.07206418f, -0.02012317f, 0.02209071f, 0.01065090f, 0.01528972f, 
    -0.03069564f, 0.02719762f, -0.02337600f, -0.01497323f, -0.05188994f, 0.05412414f, -0.07314548f, -0.01977938f, 
    0.05283117f, -0.06505064f, 0.04430784f, 0.04910275f, 0.05617708f, 0.00842803f, -0.01270167f, -0.04372582f, 
    0.05169141f, -0.00587278f, -0.04961965f, -0.01320393f, -0.06311355f, 0.01328460f, 0.06034617f, -0.03823126f, 
    -0.06086996f, -0.06687123f, 0.01141425f, 0.02944079f, 0.00199411f, -0.02007392f, -0.05205318f, -0.00489815f, 
    -0.06028186f, 0.01234858f, -0.03092524f, -0.04530033f, -0.07420903f, 0.04195046f, 0.03235950f, -0.06571664f, 
    -0.07617985f, 0.00433260f, -0.02279433f, -0.04503201f, -0.04142528f, -0.03973043f, -0.08188151f, -0.00177135f, 
    -0.03343238f, -0.05065509f, 0.02563297f, -0.03191456f, -0.00817662f, 0.04560625f, -0.01073916f, -0.02118396f, 
    0.04902086f, 0.00768188f, -0.02000098f, -0.00650439f, -0.02677434f, -0.04940816f, 0.03518206f, 0.03766086f, 
    -0.01413801f, 0.00038591f, -0.07569313f, -0.06006505f, -0.06054937f, -0.00068338f, 0.05659315f, 0.01156825f, 
    -0.00958636f, 0.01579716f, 0.00164642f, -0.01409612f, 0.06079014f, 0.03361234f, 0.06172952f, -0.01328884f, 
    0.03477288f, -0.07444125f, -0.00612151f, -0.01944991f, 0.00698813f, -0.05485400f, -0.03260847f, -0.01497239f, 
    0.07391742f, 0.02426507f, -0.04165551f, -0.01060907f, 0.01321824f, 0.00114509f, 0.00868017f, 0.04643561f, 
    -0.06364907f, -0.04819901f, 0.04580753f, -0.02971927f, -0.01363657f, 0.02643754f, -0.05681710f, 0.03875424f, 
    0.02013046f, 0.01293678f, -0.05907773f, -0.01707708f, 0.03781702f, 0.03527766f, 0.03522338f, -0.04852667f, 
    -0.00939831f, -0.01355894f, 0.03127340f, 0.01774582f, -0.00105232f, 0.04258126f, 0.03928409f, -0.08224068f, 
    -0.05825124f, -0.00275345f, 0.03977902f, 0.02542950f, 0.03567423f, -0.02639824f, -0.00283033f, -0.02582835f, 
    0.03562351f, -0.00945726f, -0.04091546f, 0.03006516f, -0.05103254f, 0.00213021f, -0.05171570f, 0.05345692f, 
    -0.03049762f, -0.03991838f, 0.00374000f, -0.01809766f, -0.03166151f, 0.06631733f, -0.03015331f, -0.04692125f, 
    0.06008818f, -0.06549101f, -0.05328739f, 0.01672330f, -0.03482153f, 0.01904232f, -0.00225647f, 0.05435396f, 
    0.01876501f, -0.02339848f, -0.05266289f, -0.07599057f, 0.01797066f, -0.02818937f, 0.00435854f, -0.07554132f, 
    -0.00210438f, 0.02568205f, -0.01588958f, -0.03381485f, -0.06429473f, 0.05668773f, -0.05183091f, -0.05038324f, 
    -0.00447498f, -0.02251581f, -0.04301687f, 0.04217621f, 0.06004984f, -0.02980538f, -0.06857230f, -0.04405504f, 
    0.05609673f, 0.00012998f, -0.00762725f, -0.07584028f, 0.00152568f, 0.06031739f, 0.00305998f, -0.07860991f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04638208f, 0.01027701f, -0.06606784f, 0.07799757f, -0.00290835f, -0.05105946f, -0.05359151f, -0.00793556f, 
    0.05028795f, 0.35633716f, -0.01074951f, -0.04741737f, 0.03333314f, 0.09157094f, 0.22568840f, 0.04561246f, 
    0.15241538f, 0.06705160f, -0.06379407f, 0.19549382f, -0.07223689f, -0.20862681f, 0.02201208f, -0.06048035f, 
    0.10407466f, 0.03286732f, -0.02306405f, 0.12942100f, 0.10691589f, 0.21700504f, 0.38584512f, -0.01656365f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.11196609f, 0.19192632f, 0.11831383f, -0.12557736f, -0.23724619f, 0.00253502f, 0.24906677f, 0.08722760f, 
    0.28293523f, 0.02435431f, -0.18491544f, 0.16283181f, -0.33770490f, 0.12252687f, -0.85580999f, 0.04449928f, 
    -0.14583381f, -0.60509509f, -0.03204345f, 0.01647653f, 0.34347084f, 0.39216131f, -0.14630416f, 0.14736786f, 
    -0.50774199f, 0.28287452f, -0.25285149f, 0.11824653f, -0.69571841f, 0.06327102f, -0.42500716f, 0.16127391f, 
    -0.01476009f, -0.57913333f, -0.16841514f, -0.04127987f, -0.51369119f, 0.04285597f, -0.22511053f, -0.40755263f, 
    0.22417259f, 0.24844089f, 0.01812329f, -0.15597765f, 0.01364393f, 0.05096320f, 0.31687450f, -0.17478247f, 
    0.70957506f, -0.34796083f, 0.13560341f, 0.11607082f, 0.24550466f, -0.73630720f, 0.16283099f, -0.09923053f, 
    -0.30587551f, 0.57027447f, 0.14415842f, 0.25577781f, -0.19112240f, -0.07970081f, 0.15129468f, -0.11413812f, 
    0.02600904f, 0.15091556f, 0.05717057f, 0.12375426f, -0.39890394f, 0.14024086f, -0.45851359f, 0.04287471f, 
    -0.18211132f, 0.29088181f, 0.10084452f, 0.09655756f, 0.01754235f, -0.59621489f, 0.10561845f, 0.11965287f, 
    -1.12345076f, 0.38845032f, -0.04320424f, -0.18180320f, -0.22894786f, 0.24270840f, 0.09551994f, -0.10556734f, 
    -0.00682755f, -0.32835945f, -1.06358385f, 0.27477020f, 0.21133219f, 0.13245283f, 0.22721612f, -0.16593964f, 
    -0.08797216f, 0.18935470f, 0.09798044f, 0.17989279f, 0.45786989f, 0.13661641f, -0.31667149f, 0.34285441f, 
    0.11843517f, -0.08159519f, -0.04849637f, 0.15330446f, 0.22873928f, -0.06780605f, -0.30533519f, 0.00100450f, 
    -0.74906588f, 0.31248003f, -0.08186089f, -0.53266102f, 0.20548184f, 0.07942258f, 0.13395400f, 0.12438653f, 
    -0.47303557f, 0.19715838f, 0.14259645f, -0.73783368f, 0.42278543f, -0.40762910f, -0.70477134f, 0.12538841f, 
    -0.01466917f, 0.14883056f, 0.14676464f, -0.39565855f, -0.23878078f, 0.02973097f, 0.19878893f, 0.05540889f, 
    0.00379729f, -0.91409367f, -0.00648514f, -0.14056909f, 0.33497897f, 0.19789056f, 0.07926136f, -0.15238096f, 
    -0.23447405f, -0.18170492f, -0.17788628f, 0.10430517f, 0.19527480f, 0.22368309f, -0.12488083f, -0.04989024f, 
    0.48402205f, -0.60995829f, 0.00906635f, -0.01796940f, 0.07630406f, -0.38683966f, -0.37557700f, -0.12290311f, 
    0.01809922f, -0.18289626f, -0.15222880f, 0.33141020f, 0.19974250f, 0.08566687f, -0.26819643f, -0.10107172f, 
    0.03909937f, -0.12929755f, 0.01421836f, 0.11572850f, 0.24385700f, 0.18184997f, -0.48306093f, 0.00193370f, 
    -0.19497234f, -0.38754478f, 0.13804670f, 0.43925300f, -0.09050721f, -0.33856258f, -0.01208984f, -0.11827252f, 
    0.40996754f, -0.41485590f, 0.10553774f, -0.13268499f, -0.19606505f, 0.52600664f, -0.01523554f, 0.07997361f, 
    -0.06597339f, 0.20674817f, 0.13326463f, -0.72545803f, 0.19776906f, -0.03345000f, -0.30710930f, 0.40548757f, 
    -0.61851358f, 0.45380238f, 0.00414724f, 0.10246506f, -0.23262727f, -0.90364838f, 0.42907390f, -0.09056472f, 
    0.59399796f, -0.09755684f, -0.02350486f, -0.27854788f, -0.27230617f, -0.51824367f, 0.00041755f, 0.08973970f, 
    0.02449820f, -0.70045680f, -0.19238688f, 0.08134098f, 0.00276460f, 0.02690266f, 0.11953205f, -0.07600997f, 
    0.15913697f, 0.18914588f, -0.02262934f, -0.05414391f, 0.31479260f, -0.09627794f, -0.14020972f, -0.52679783f, 
    -0.20032927f, -0.48396516f, 0.17474788f, -0.16481398f, -0.01388675f, -0.27479640f, -0.12275344f, -0.14565013f, 
    -0.62287098f, 0.27972060f, 0.09000450f, -0.32905293f, -0.65793800f, 0.54746711f, -0.13965791f, 0.05588441f, 
    0.25674531f, 0.20142891f, 0.19453816f, 0.07692127f, -0.82029885f, -0.20223291f, 0.18213297f, 0.11087842f, 
    -0.09931944f, -0.77435714f, -0.07125996f, -0.12757829f, 0.50021517f, 0.00512281f, 0.09881368f, -0.28117374f, 
    0.50468785f, 0.63615316f, -0.04080352f, 0.09275340f, -0.64775711f, 0.18720885f, -0.06292388f, 0.06906696f, 
    -0.12981853f, 0.31863290f, -0.14070123f, -0.18328254f, -0.97051781f, -0.58395511f, -0.15415680f, -0.04795503f, 
    0.05672235f, 0.20350653f, -0.02698391f, -0.62946844f, -0.22066343f, -0.04236292f, -0.01374185f, -0.03892390f, 
    -0.13480569f, 0.44323725f, -0.00241443f, -0.87278801f, -1.12997591f, -0.12881665f, 0.55104989f, -0.60757691f, 
    -0.59029102f, -0.55678695f, 0.11458327f, 0.15113825f, -0.15580830f, -0.10974628f, 0.17409685f, -0.01773616f, 
    -0.39091155f, 0.06788532f, -0.06224633f, -0.17415366f, 0.33637252f, -0.68424904f, -0.07262289f, -0.10622646f, 
    0.18139935f, 0.04196759f, 0.14911838f, 0.01166805f, 0.20139386f, 0.41482303f, 0.11976836f, -0.10160901f, 
    -0.04278678f, -0.68529546f, -0.05656096f, 0.53347224f, 0.20287724f, -0.14425012f, 0.10566390f, 0.31357354f, 
    -0.69586509f, 0.53056115f, 0.11749087f, 0.03808567f, 0.21642336f, 0.25120068f, -0.08374947f, 0.07057208f, 
    -0.69300079f, -0.17637166f, -0.18157262f, 0.22477901f, -0.55024636f, 0.11962872f, -0.02500657f, 0.06274623f, 
    -0.36491567f, 0.19602661f, -0.13440257f, 0.15995128f, 0.31478313f, -0.78470421f, 0.04260116f, 0.09602837f, 
    0.13665320f, -0.57194799f, 0.07374185f, 0.34547955f, 0.52703726f, 0.07857049f, 0.41818455f, 0.57848233f, 
    -0.07914048f, -0.72312218f, -0.07744530f, 0.09626871f, -0.33861154f, -0.59049380f, 0.31714383f, -0.16550682f, 
    0.23792037f, -0.07606456f, 0.03164331f, 0.16319154f, -0.03125903f, 0.25116715f, 0.04975501f, -0.06623581f, 
    -0.15900290f, 0.07555334f, -0.28136656f, -0.66148657f, 0.22850911f, -0.04064876f, 0.33999544f, -0.02672236f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.04056668f, -0.14672452f, 0.26660275f, -0.17777045f, -0.20490348f, 0.24697329f, 0.03450083f, -0.06266142f, 
    -0.04644506f, -0.04503777f, 0.00976669f, -0.05152050f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
