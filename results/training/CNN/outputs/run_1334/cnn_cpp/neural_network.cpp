#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.30730167f, -0.94468224f, 0.08086035f, 0.72579885f, 0.63571715f, -0.37686166f, -0.19359525f, -0.42346004f, 
    0.39384139f, -0.00850946f, 0.06232916f, -0.48038495f, -0.92043090f, -0.70409733f, -0.73180044f, -0.10391068f, 
    0.15272941f, -0.07217396f, -0.72441369f, 0.04044653f, 0.68809181f, -0.43285897f, 0.36626860f, -0.24000324f, 
    0.12284481f, 0.50060260f, -0.24306411f, -0.93179953f, 0.01743123f, 0.92164379f, 0.73824447f, -0.21902607f, 
    -0.19161204f, -0.17371972f, -0.16302599f, -0.06724324f, -0.27222943f, -1.10564148f, 0.77678066f, -0.70981145f, 
    -1.03209198f, -1.19337189f, 0.28224093f, 0.15834253f, 0.43476510f, -0.89503479f, -0.49400529f, 0.29644942f, 
    -0.67009568f, -1.00257075f, 0.48746091f, 0.20920704f, -0.64357287f, -0.45719692f, 0.75585049f, -0.62267119f, 
    0.22369830f, -0.22322819f, -0.60144180f, -0.64505655f, 0.46999514f, 0.49460557f, 0.39027673f, -0.55252546f, 
    -0.30837250f, -0.64530563f, 0.81474602f, -0.65004480f, -0.65629268f, -0.71947330f, -0.46771923f, 0.13109669f, 
    0.19223991f, -0.63934201f, 0.48694929f, -0.12871701f, 0.20755516f, 0.27064389f, -0.60945582f, -0.50329214f, 
    0.77659261f, -1.13502312f, -0.89946258f, 0.30922732f, -0.19070575f, 0.21395689f, -0.46840116f, 0.01567448f, 
    -0.29519525f, -0.04119312f, 0.37423825f, 0.93562049f, 0.72625196f, -0.59294099f, -0.21385895f, -0.11567437f, 
    -0.09562183f, 0.00317589f, 0.10924689f, 0.70751071f, 0.55237204f, -0.76831841f, -0.35058787f, 0.08212046f, 
    0.48804685f, -0.22221443f, 0.07308306f, -0.20589195f, -0.12281333f, 0.05019704f, -1.10148418f, -0.80946469f, 
    -0.13381250f, 0.52357352f, -0.73117685f, -0.63102275f, -0.61669016f, 1.07688475f, -0.67184848f, -0.51713771f, 
    0.01602371f, 0.38235751f, -0.52827835f, 0.13207443f, 0.08446097f, 0.09626024f, -0.34292310f, -0.00592013f, 
    0.35822296f, -0.12309494f, 0.09326835f, 0.05866101f, 0.48891088f, -0.45289022f, 0.01943949f, 1.06929207f, 
    -0.08166637f, -0.74114048f, 0.62919331f, 0.12364288f, -0.15331267f, -0.25930142f, 0.08659571f, -0.11286757f, 
    0.56255317f, -0.13262492f, -0.21043412f, 0.44007969f, 0.03336596f, 0.07393566f, 0.30888358f, -0.03430819f, 
    -0.09904932f, -0.86458158f, -0.86798877f, -0.20593895f, 0.59476602f, 0.21665554f, 0.07146863f, -0.00256331f, 
    0.38970125f, 0.15216157f, -0.87469727f, 0.82916862f, -0.67308480f, -0.17590433f, 0.97534591f, 0.08645867f, 
    -0.00537261f, 0.16792166f, -0.60498357f, 0.25523484f, -0.46614093f, 0.17590971f, 0.41273522f, 0.52006865f, 
    -0.76529318f, -0.09940401f, -0.07446554f, 0.18923010f, 0.42503428f, -1.06004810f, 0.82177651f, 0.16535166f, 
    -0.18331648f, -0.32552370f, -0.12554553f, 0.14844246f, 0.27776584f, -1.09786749f, 0.30408347f, -0.88080192f, 
    0.47796711f, -0.13762631f, 0.31469211f, 0.40019190f, -0.08935192f, 0.39826956f, 1.38300228f, -0.56177419f, 
    -0.58654934f, 0.04085098f, -0.66170025f, -0.73645157f, -0.35559291f, -0.15928340f, 0.21478055f, -0.81296235f, 
    -0.92493635f, 0.34940699f, 0.27866891f, 0.66370076f, -0.43090895f, -0.43268755f, -0.03628311f, -0.91177410f, 
    -0.77692449f, -0.77653825f, -0.11017284f, 0.15288137f, -1.07451499f, -0.62389082f, 0.07259735f, 0.11995853f, 
    0.18197605f, 0.70114970f, 0.57850116f, 0.49745405f, -0.41241553f, 0.21046449f, 0.11085863f, -0.04180354f, 
    -0.21633770f, -0.45761582f, -0.24207108f, 0.99223447f, -0.98093313f, -0.62881428f, -0.62374395f, -0.94340485f, 
    -0.48868594f, -0.41800028f, -0.61852056f, -0.59518343f, -0.18028761f, -0.43840152f, 0.71407342f, -0.33537161f, 
    -0.36196494f, 0.35806984f, 0.85356361f, -0.32966137f, 1.09055972f, -0.36619326f, -0.80675596f, 0.34156266f, 
    0.24497673f, -0.50108421f, 0.10915031f, 0.51531458f, -0.49025178f, -0.22193962f, -1.46933508f, -0.64766556f, 
    0.52635783f, 0.83672827f, 0.28988802f, 0.31974843f, -0.22977695f, -0.04519570f, 1.04232526f, -0.92867833f, 
    -1.31558275f, 0.72523540f, 0.16161729f, 0.73412263f, -0.47630635f, -0.13297606f, 0.15354933f, -0.75181502f, 
    -0.19535217f, 0.14722410f, -0.19647205f, -0.21554072f, 0.48500553f, 0.37877950f, 0.30898213f, 0.00834952f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04358600f, -0.13465776f, -0.00895509f, 0.03410779f, 0.13272604f, 0.22242399f, -0.02457000f, -0.15090665f, 
    0.20287228f, -0.11399298f, 0.13928893f, 0.40725657f, -0.40591332f, 0.23601104f, 0.26256618f, 0.11469381f, 
    0.08563790f, 0.06673886f, 0.04696433f, 0.30434722f, 0.01107535f, 0.14957199f, 0.32869029f, 0.09700056f, 
    -0.10483176f, -0.28707701f, -0.31428105f, 0.15787446f, 0.31563348f, 0.12194876f, 0.07297797f, -0.25635186f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.39552906f, -0.02368726f, -0.43229264f, -0.09819502f, 0.04762156f, 0.08834413f, 0.03031393f, 0.04931691f, 
    -0.18959920f, -0.05066569f, -0.01692607f, -0.08130595f, -0.04871077f, -0.02719787f, 0.00429609f, -0.11385991f, 
    0.11144502f, 0.05975747f, -0.03476491f, -0.05457386f, 0.26382029f, 0.36228329f, 0.01314769f, -0.35214406f, 
    -0.21904261f, 0.06897497f, 0.06942637f, 0.01616389f, 0.00597100f, 0.05578592f, -0.00924630f, -0.02415191f, 
    -0.00525444f, 0.04084645f, 0.03566532f, -0.02760763f, -0.00633820f, 0.00341831f, 0.09180738f, -0.02561791f, 
    -0.00401380f, 0.01081996f, 0.16069941f, -0.03368252f, 0.04013657f, -0.13843247f, 0.08926439f, 0.15900612f, 
    0.08205421f, -0.03415691f, -0.13842095f, -0.00031790f, -0.23000750f, -0.03465943f, -0.19299842f, -0.01096553f, 
    0.00319241f, -0.08240633f, -0.14672324f, -0.08523466f, 0.19379541f, 0.25674754f, -0.42188600f, -0.71178311f, 
    -0.04763770f, -0.14502065f, -0.07699251f, 0.10389683f, 0.06082549f, 0.06123083f, 0.05016193f, -0.01542427f, 
    -0.07864916f, -0.03762789f, -0.09426085f, -0.14717858f, -0.02524641f, 0.05753163f, 0.06506846f, 0.11209990f, 
    0.45083648f, 0.57288229f, 0.00551009f, -0.77304018f, -0.14661290f, 0.06900457f, 0.03818818f, 0.02599385f, 
    -0.06383365f, 0.12281482f, 0.08106621f, -0.05432317f, 0.04759271f, 0.00716667f, 0.00298161f, -0.01771134f, 
    -0.03000920f, -0.06116797f, 0.11260454f, -0.13699996f, 0.28380933f, 0.31357336f, 0.30407676f, -0.52183205f, 
    0.05898636f, 0.00178473f, 0.21042024f, 0.03624843f, 0.01390109f, -0.01603782f, 0.00728115f, -0.05782486f, 
    -0.09674208f, -0.20477559f, -0.07448793f, 0.03840550f, 0.00802153f, 0.05135565f, -0.21550053f, 0.02032258f, 
    0.18767995f, 0.15761440f, -0.05670256f, -0.11697569f, -0.01106144f, -0.15479040f, -0.09111407f, -0.29592577f, 
    -0.03525624f, -0.14453840f, 0.00994213f, 0.01926165f, -0.01407526f, 0.04762300f, -0.02329729f, -0.06234990f, 
    -0.02020874f, -0.03948996f, -0.23370591f, 0.01129375f, 0.40177706f, 0.35695511f, -0.05653559f, -0.09715330f, 
    -0.08536395f, -0.04102480f, 0.13278522f, 0.10716496f, -0.19237067f, 0.05314179f, -0.04920795f, -0.03222936f, 
    0.04389713f, -0.00751317f, 0.04640228f, -0.04517673f, -0.12345583f, 0.01621597f, -0.19570708f, -0.00286491f, 
    -0.53745103f, -0.16018680f, 0.27766341f, -0.09936084f, 0.14679742f, 0.02504147f, -0.00213445f, 0.01471045f, 
    0.05553461f, 0.01156229f, 0.12762418f, 0.12983978f, 0.02155090f, -0.12920982f, -0.18877612f, -0.24312155f, 
    -0.02060918f, -0.04026572f, -0.00754431f, -0.12507425f, 0.45376214f, 0.26678917f, 0.03944965f, -0.43570644f, 
    -0.06778100f, 0.07771380f, 0.18182644f, 0.24006619f, 0.04035391f, 0.07012457f, 0.00195834f, -0.02733918f, 
    0.00944643f, 0.01949566f, -0.00675739f, 0.00659364f, -0.05198764f, -0.09300619f, -0.03131357f, -0.06604768f, 
    -0.26878637f, -0.15567975f, -0.17199531f, -0.02354372f, 0.07814041f, 0.05775747f, 0.01169893f, -0.04426691f, 
    0.02965069f, 0.01048629f, 0.06536486f, 0.04888498f, 0.02909820f, 0.10464742f, 0.05268072f, 0.04862606f, 
    0.08649697f, -0.08891632f, -0.01209611f, -0.03081018f, -0.67228532f, -0.31568447f, -0.46550888f, 0.12761147f, 
    -0.57517868f, -0.02011749f, -0.05966226f, -0.09208177f, 0.01682307f, 0.09729225f, 0.10778114f, 0.00608917f, 
    -0.08186101f, -0.02638916f, 0.04572175f, -0.09570216f, -0.01850505f, -0.10280709f, 0.07401436f, -0.12777694f, 
    0.24623796f, 0.26965806f, 0.38066268f, 0.08142786f, -0.22889203f, 0.09163907f, 0.10945320f, 0.18598008f, 
    -0.02515794f, 0.10274913f, -0.01010405f, -0.00373326f, -0.00914961f, -0.19982408f, -0.26100448f, 0.05707569f, 
    0.09858278f, -0.11851714f, 0.01566792f, 0.04305507f, -0.01156415f, -0.01386626f, -0.23269318f, 0.10913599f, 
    -0.05070812f, -0.02402584f, -0.01423869f, -0.02051759f, 0.01277221f, -0.06394030f, -0.22995600f, 0.09928630f, 
    -0.17580850f, -0.04545277f, -0.09128766f, -0.10384321f, -0.10511221f, -0.08309625f, -0.13502663f, 0.04500087f, 
    -0.20306532f, -0.11430094f, 0.09570505f, -0.01292694f, 0.05922272f, 0.02841913f, 0.03211683f, 0.05688813f, 
    0.03415146f, -0.03177830f, -0.13070640f, -0.12316258f, -0.30291724f, -0.09386918f, -0.10236660f, -0.15678822f, 
    -0.11931969f, 0.00860240f, -0.10040380f, -0.02574538f, -0.60019684f, -0.24882637f, -0.27225000f, 0.30134654f, 
    -0.05962970f, 0.02079381f, 0.05058244f, -0.00298157f, 0.02077469f, 0.06485442f, 0.09323678f, -0.10058140f, 
    -0.00971123f, -0.03808432f, 0.02107405f, 0.00429651f, -0.04739288f, -0.02071023f, 0.04008079f, -0.04376230f, 
    -0.03523441f, -0.02664740f, -0.03928264f, 0.10646776f, 0.04013227f, -0.01557091f, 0.00429380f, 0.01877777f, 
    0.06682611f, 0.03437085f, -0.16705608f, -0.26568758f, -0.19092745f, -0.22378053f, -0.20348690f, 0.00611029f, 
    -0.05442368f, -0.08998818f, 0.01125022f, -0.05558717f, 0.31416401f, 0.30750355f, -0.11523378f, -0.04341515f, 
    0.14793579f, 0.08002871f, 0.11457826f, 0.14369826f, -0.13407503f, -0.22476538f, -0.05022949f, -0.09594154f, 
    -0.04675928f, 0.01580792f, 0.00612466f, 0.01243151f, 0.04992215f, 0.04309601f, 0.03256716f, -0.02313720f, 
    -0.24571407f, -0.48492464f, -0.14198115f, 0.16610377f, -0.03352675f, -0.03548824f, -0.02173810f, -0.06311157f, 
    0.03509001f, 0.05086181f, -0.01978172f, -0.05444887f, -0.03715834f, 0.08405980f, -0.02298440f, 0.00335247f, 
    0.14293692f, 0.06670993f, -0.13319221f, -0.03262086f, 0.05611105f, -0.10979250f, -0.18929310f, 0.00219650f, 
    0.02397124f, -0.00897235f, -0.05658090f, -0.04624488f, -0.00796265f, -0.01633651f, -0.09136382f, -0.18763132f, 
    -0.11494116f, -0.03472800f, -0.09455092f, -0.20202437f, -0.03809319f, -0.11473219f, -0.16437450f, -0.02734024f, 
    0.03673017f, 0.09578242f, 0.04411041f, -0.14148885f, 0.10120945f, -0.13970880f, 0.05766807f, 0.06762803f, 
    -0.23441255f, 0.00366610f, 0.09957869f, 0.01177588f, -0.00111614f, -0.06182136f, -0.07005423f, -0.09695364f, 
    0.06669325f, -0.09530697f, -0.12200197f, -0.22671483f, 0.13926750f, 0.03910016f, 0.05708015f, 0.01590067f, 
    0.08924378f, 0.07701403f, 0.07473568f, 0.10529905f, -0.01937458f, 0.00370718f, -0.13983193f, -0.13280016f, 
    -0.11329389f, -0.12373141f, 0.04561721f, -0.04027496f, 0.01880470f, -0.01296340f, -0.02006849f, -0.01424912f, 
    -0.13453320f, 0.10093564f, -0.18945247f, -0.14176019f, -0.21877098f, -0.13864143f, -0.13109440f, -0.05584263f, 
    -0.11569735f, -0.16015632f, -0.07311217f, -0.04141998f, -0.02450617f, 0.00344219f, -0.00269912f, 0.01627042f, 
    0.02163697f, 0.07024974f, -0.06893088f, 0.08805319f, 0.45351210f, 0.17903399f, -0.08877758f, -0.29353014f, 
    -0.06736964f, 0.06251929f, -0.02643774f, 0.16380015f, 0.03493296f, 0.15542267f, -0.04864093f, 0.02581753f, 
    -0.16104630f, -0.01344944f, -0.12028287f, -0.08766468f, -0.01961934f, 0.07263483f, -0.14575201f, 0.09064389f, 
    0.41770101f, 0.37478277f, 0.03439909f, -0.46453497f, -0.05720657f, 0.06636783f, 0.14800341f, 0.19498992f, 
    -0.08584616f, 0.10508779f, -0.00240484f, -0.02478703f, 0.03097332f, 0.00613769f, 0.01775975f, 0.03898863f, 
    -0.08272534f, -0.02664787f, -0.06654346f, 0.15898573f, -0.03777098f, -0.11356341f, -0.23541318f, -0.00635290f, 
    0.22846243f, 0.08825471f, 0.04417889f, -0.00079595f, 0.04024140f, 0.05626078f, 0.06277847f, 0.06564175f, 
    0.06122417f, 0.11933608f, 0.07516219f, 0.17779565f, 0.00150209f, -0.06333511f, -0.03768174f, -0.06219693f, 
    -0.00723123f, 0.37348694f, 0.16734403f, -0.19850615f, -0.28278196f, -0.01348736f, 0.15907772f, -0.05318438f, 
    -0.06239771f, 0.07222510f, -0.01646313f, -0.04834789f, -0.03162715f, 0.02914643f, -0.01420197f, -0.02297568f, 
    0.03532682f, 0.05246007f, -0.07362848f, 0.17485431f, 0.35351881f, 0.23734713f, -0.16684951f, -0.07996230f, 
    0.10113031f, 0.01448560f, 0.10697421f, 0.08867835f, -0.18867056f, -0.14450729f, -0.06306692f, -0.09849788f, 
    -0.01722576f, -0.00536370f, 0.02002621f, -0.06155139f, -0.02687048f, -0.08574373f, -0.10024806f, 0.03750555f, 
    -0.20346843f, -0.20075850f, -0.47113663f, 0.14750709f, 0.06581070f, -0.07637702f, -0.08681022f, -0.14189279f, 
    -0.04555530f, 0.03609536f, -0.26805279f, -0.11555956f, -0.22466806f, -0.27416313f, -0.19985595f, -0.11968514f, 
    -0.13823508f, 0.00028512f, -0.09575615f, 0.08404037f, 0.30336857f, -0.04200000f, -0.61660969f, 0.06846073f, 
    0.05193431f, 0.17058393f, 0.09829725f, 0.15209433f, -0.21630841f, 0.19213118f, -0.06757758f, -0.07348271f, 
    -0.18485215f, 0.07593020f, -0.01848313f, 0.03957708f, 0.08120836f, 0.04764598f, -0.01911794f, 0.06757263f, 
    0.06563048f, -0.45991060f, -0.65242940f, 0.07878259f, 0.06736764f, 0.10564193f, 0.05514825f, 0.00912050f, 
    -0.13643870f, -0.02201421f, -0.06981292f, 0.01505244f, -0.05877546f, -0.15425564f, 0.00927358f, 0.09662286f, 
    0.12151098f, -0.07435536f, 0.02926357f, -0.01345905f, 0.15327615f, 0.11358454f, 0.22294410f, 0.00048789f, 
    0.06437889f, 0.11238278f, 0.09381673f, 0.10997994f, 0.05999345f, 0.02255196f, -0.03360161f, -0.04954292f, 
    -0.12450308f, 0.01954296f, 0.04704598f, -0.00941517f, -0.05731155f, -0.04177484f, 0.04269178f, -0.01076771f, 
    0.09793483f, -0.47806644f, 0.28175348f, 0.10348647f, 0.07736708f, 0.14413013f, 0.05679498f, 0.13883531f, 
    0.07359342f, -0.25520054f, 0.14012001f, -0.20305024f, 0.09328421f, -0.16983499f, -0.24342535f, 0.17678413f, 
    0.03743105f, 0.00509155f, -0.04076502f, -0.07705554f, -0.12724885f, -0.03984436f, -0.14721899f, 0.08823296f, 
    -0.15505247f, -0.11133476f, -0.01091490f, -0.32880306f, -0.14797460f, 0.01235758f, -0.00485468f, 0.01259746f, 
    0.02824255f, 0.08815964f, 0.12348869f, 0.01616629f, 0.07751881f, -0.00640706f, -0.18622623f, 0.01215481f, 
    -0.02363136f, -0.00340366f, -0.06571880f, -0.04642914f, 0.12914084f, -0.17263477f, -0.02835869f, 0.02758343f, 
    0.12091222f, 0.06287376f, -0.00580129f, 0.06757549f, -0.04709885f, 0.14936227f, 0.03388402f, -0.15601476f, 
    -0.00192365f, 0.02466597f, 0.15788093f, -0.03606058f, -0.17548542f, -0.08215606f, -0.11762690f, -0.02731918f, 
    0.32333604f, -0.01119848f, -0.07751702f, -0.00982502f, 0.00906695f, -0.02466935f, -0.04480398f, 0.09558541f, 
    0.30038583f, -0.10816681f, 0.20934974f, 0.14467239f, -0.00513458f, 0.04271762f, -0.08036528f, -0.12163418f, 
    -0.53998268f, 0.30584732f, -0.19943240f, 0.17217779f, 0.04499404f, -0.14642443f, -0.00450882f, -0.17889301f, 
    0.15943177f, -0.12318359f, -0.06687675f, 0.00996623f, 0.07699535f, 0.05243516f, 0.06893882f, -0.00732071f, 
    0.00832795f, 0.13351057f, -0.07558908f, 0.05880335f, -0.40872526f, 0.18111037f, -0.31272396f, -0.07502364f, 
    0.28240338f, 0.04090498f, -0.08959834f, 0.08965771f, -0.05955221f, -0.15023723f, -0.04115953f, 0.04311057f, 
    0.00505042f, -0.06752767f, 0.05630674f, 0.04786887f, 0.00819047f, 0.11780748f, -0.07368180f, -0.05607528f, 
    -0.22364436f, 0.02413996f, -0.11930782f, -0.04671073f, -0.04755706f, 0.06653827f, 0.08969888f, -0.08795182f, 
    -0.01287290f, 0.06848738f, -0.05738132f, -0.08090660f, 0.09203560f, 0.14267434f, 0.04777296f, 0.00400648f, 
    -0.02496112f, 0.00827996f, 0.15622291f, 0.03156095f, 0.04113944f, 0.40055865f, 0.13987875f, 0.29719013f, 
    -0.03533714f, 0.15419006f, 0.02547757f, -0.11681923f, 0.13358030f, -0.08616921f, 0.03290500f, -0.00078156f, 
    0.02728949f, -0.07973628f, -0.07109230f, -0.03922777f, 0.02958379f, 0.01330927f, -0.00351108f, 0.21136238f, 
    -0.10460935f, 0.15211953f, 0.20716827f, 0.08903039f, 0.19152045f, -0.03660364f, 0.04908670f, 0.09456564f, 
    -0.03581960f, 0.00993396f, -0.04791957f, -0.09664863f, 0.01930338f, -0.03130389f, -0.21411563f, 0.19286442f, 
    0.20653582f, -0.00682770f, -0.14732349f, -0.01326533f, 0.03629240f, 0.14126077f, 0.09312672f, 0.05681254f, 
    0.18297350f, 0.03134840f, 0.05062415f, -0.04969624f, 0.06457199f, -0.13822696f, 0.09051470f, 0.00911591f, 
    0.03844063f, -0.03137722f, -0.03293519f, 0.04429094f, 0.08963224f, -0.00780085f, -0.13796930f, -0.17974350f, 
    0.28501666f, 0.02978794f, -0.03189901f, -0.02129188f, 0.07532959f, 0.02384146f, -0.04727325f, -0.04896573f, 
    -0.06458742f, -0.02531503f, -0.01358804f, -0.03709504f, -0.00157184f, -0.01014676f, 0.03798624f, -0.01238203f, 
    0.17341284f, -0.20689529f, 0.07904170f, 0.04891104f, 0.26758403f, 0.02988448f, 0.25634253f, 0.09681861f, 
    -0.11129437f, 0.01385433f, 0.02512602f, -0.01554375f, -0.04948305f, 0.01321464f, -0.02708800f, 0.00251109f, 
    -0.03791919f, 0.08270213f, -0.02935928f, -0.08874389f, -0.08488827f, 0.00718527f, 0.16412370f, 0.05795695f, 
    -0.14439899f, 0.41233289f, 0.29343027f, 0.11826986f, -0.23829626f, 0.06423222f, 0.06405203f, 0.07693304f, 
    -0.12996395f, 0.07866433f, -0.00706115f, 0.00408435f, -0.00350444f, -0.08531035f, 0.07049152f, -0.13458601f, 
    -0.33912104f, -0.01942582f, -0.09401160f, -0.02109463f, 0.18400615f, 0.03671877f, -0.14419238f, -0.05178507f, 
    -0.13088419f, -0.02186735f, 0.09998822f, 0.02158594f, -0.10684782f, 0.05405191f, 0.14955537f, 0.16064596f, 
    0.14671393f, 0.01225782f, 0.07119328f, -0.03451734f, -0.05619681f, -0.05908545f, 0.11920220f, 0.04654790f, 
    0.01465456f, 0.11141489f, -0.02495763f, -0.01592350f, 0.14818309f, -0.10823610f, 0.01584494f, -0.00956195f, 
    0.08091946f, -0.02630673f, 0.06047389f, 0.02709603f, -0.01236197f, 0.01328801f, 0.05946153f, -0.09801781f, 
    -0.12509137f, 0.07125697f, 0.10152630f, -0.10441206f, 0.76911229f, 0.08318746f, -0.07529948f, 0.04213248f, 
    -0.00199149f, -0.01512079f, -0.07195391f, -0.05834656f, -0.01284738f, -0.03721666f, -0.10405195f, 0.08090056f, 
    -0.05899581f, -0.02031479f, 0.03970611f, 0.07415085f, -0.06320960f, 0.09467093f, 0.19082299f, 0.09759190f, 
    0.24545939f, 0.02323253f, 0.00701537f, 0.11512829f, 0.05768771f, -0.04253307f, -0.04252426f, -0.02771390f, 
    -0.00320642f, -0.02008425f, 0.04602855f, 0.14458722f, -0.07375302f, -0.02258891f, -0.05378842f, -0.09665821f, 
    -0.08895320f, -0.11812667f, -0.01055375f, 0.00640018f, -0.08318877f, -0.12116757f, -0.11361179f, -0.04218690f, 
    -0.06743145f, 0.03247055f, 0.08485262f, 0.11303768f, 0.06219811f, -0.11837063f, -0.04860825f, -0.01212762f, 
    -0.02588716f, 0.02370699f, -0.01145826f, -0.05277025f, 0.00189376f, 0.04318163f, -0.02205007f, 0.05315792f, 
    -0.50902319f, -0.73877513f, 0.23486520f, -0.01534655f, -0.11291731f, -0.07594367f, 0.08745447f, -0.11938615f, 
    -0.12039930f, 0.10864741f, 0.10440132f, -0.06647363f, -0.07853147f, 0.03579130f, -0.02875949f, 0.00214507f, 
    -0.02611707f, -0.20564105f, 0.12362637f, 0.06361929f, 0.21371853f, -0.10617723f, -0.05698115f, 0.08623701f, 
    0.05143547f, 0.08701292f, 0.05135219f, 0.06089887f, 0.01780342f, -0.10346253f, -0.07516435f, 0.06960466f, 
    0.10177786f, -0.01889802f, -0.06670664f, 0.15862951f, -0.02077249f, 0.05955577f, -0.05277429f, -0.13027212f, 
    -0.20370089f, 0.15582430f, -0.10767752f, -0.12612922f, 0.02444154f, -0.03744703f, -0.01653745f, 0.14247091f, 
    -0.08406045f, 0.16932867f, -0.14585993f, 0.01406774f, 0.17725463f, 0.13385259f, 0.00816524f, -0.08036343f, 
    0.06183255f, 0.08272021f, -0.11837600f, 0.00821731f, -0.30594027f, -0.19180943f, -0.11324288f, -0.08445575f, 
    -0.05208525f, 0.00379271f, 0.06072959f, 0.01846305f, 0.02115322f, -0.23442261f, -0.10914914f, 0.16886485f, 
    -0.00278296f, 0.09831200f, 0.00627667f, -0.02058547f, -0.00091364f, -0.01006643f, -0.00504619f, 0.01610978f, 
    0.24413997f, 0.15973161f, -0.52524418f, -0.11290286f, -0.54056883f, -0.14271452f, -0.19606012f, -0.11870047f, 
    -0.27097383f, 0.19065851f, -0.04780360f, -0.01135112f, 0.08542741f, 0.07482108f, -0.00183999f, 0.04302271f, 
    0.08366294f, -0.08768118f, 0.04057543f, -0.03248915f, 0.07162908f, -0.17264281f, 0.07913362f, -0.20311913f, 
    0.03299039f, -0.12138800f, -0.06645117f, -0.17961304f, 0.18163539f, 0.14553726f, 0.20122637f, 0.01974738f, 
    -0.02050982f, 0.07702934f, -0.11625064f, 0.05350957f, -0.10805397f, -0.26460698f, 0.09800337f, -0.22778481f, 
    -0.16161042f, 0.19292185f, -0.10960617f, 0.33301145f, 0.08247396f, -0.09590966f, 0.19714226f, 0.03012747f, 
    0.12677504f, -0.03056549f, -0.02782350f, -0.08315300f, 0.03353376f, -0.04678784f, 0.08416612f, 0.00076514f, 
    0.05137037f, 0.04310084f, -0.33329630f, 0.08005526f, 0.38738739f, 0.18347061f, 0.12418771f, 0.14269762f, 
    0.19875823f, -0.04971495f, -0.01446509f, 0.01802584f, -0.02580096f, -0.00581382f, -0.04126427f, -0.01068385f, 
    0.02521025f, -0.00575877f, 0.04058957f, -0.04260745f, 0.00664991f, -0.01949258f, 0.08979627f, -0.05090970f, 
    -0.38833770f, -0.01112973f, -0.13964854f, -0.01086848f, -0.75742733f, 0.15813394f, -0.04852984f, -0.34911978f, 
    -0.38509160f, 0.00698707f, -0.01911100f, 0.11105686f, 0.06915388f, 0.04093036f, 0.03798186f, -0.22776133f, 
    -0.01687683f, -0.26542974f, -0.30775070f, -0.30437177f, -0.20528077f, 0.04931578f, -0.36574402f, 0.00543748f, 
    -0.07700307f, 0.02245817f, 0.04229257f, 0.12537721f, 0.35992485f, -0.10927062f, -0.04823292f, -0.00969128f, 
    -0.06076869f, -0.00679488f, 0.08486512f, -0.09274728f, 0.01606718f, 0.12721419f, -0.03521782f, -0.00278542f, 
    0.54948556f, 0.11438860f, -0.16895910f, 0.11056990f, -0.21276353f, -0.04799657f, -0.06933070f, -0.12330359f, 
    0.02209746f, -0.08835384f, 0.03725383f, 0.14280421f, -0.06449746f, 0.09902077f, 0.23660071f, -0.02404180f, 
    -0.12440545f, 0.07651477f, 0.16329722f, 0.12827216f, 0.19041665f, -0.38808304f, -0.14288256f, 0.02259805f, 
    -0.12578259f, 0.02413440f, -0.00418105f, 0.07267630f, -0.17811114f, 0.00102368f, 0.14096348f, -0.30946830f, 
    0.03746531f, -0.18152951f, 0.03205695f, 0.00826261f, -0.06527365f, -0.05931883f, -0.06145532f, -0.00444262f, 
    1.50283086f, -0.03724265f, -0.05964253f, 0.11093334f, -0.25808680f, -0.00762054f, 0.02961898f, 0.01235794f, 
    0.00351250f, -0.04706223f, 0.21680783f, -0.26515374f, -0.10231832f, -0.17133027f, -0.21938145f, 0.08144228f, 
    0.09187772f, -0.13156779f, -0.07471880f, 0.05695799f, -0.13868532f, -0.11590631f, -0.05712223f, -0.08539375f, 
    0.04504370f, -0.03637589f, 0.03092494f, 0.15161414f, 0.08704148f, 0.01393138f, -0.18920687f, 0.09387039f, 
    -0.22203556f, 0.09151106f, -0.07578777f, -0.09054509f, -0.00424228f, -0.02751706f, -0.05649821f, 0.08888213f, 
    -0.02828335f, -0.22123551f, 0.64083004f, 0.13190724f, 0.12938312f, 0.01094040f, -0.10664412f, 0.04359936f, 
    0.20492214f, -0.17511345f, 0.02730193f, 0.11892322f, 0.13250150f, -0.03968076f, 0.07170680f, -0.00716200f, 
    0.01181131f, 0.00326998f, 0.06560024f, -0.12213185f, -0.73000830f, -0.89579988f, -0.31698656f, -0.04842131f, 
    -0.41311285f, 0.08260723f, 0.10001169f, -0.03442238f, -0.03121695f, -0.11239147f, -0.01338124f, -0.01049075f, 
    -0.01080120f, -0.02333326f, -0.04190047f, -0.02149261f, -0.01198173f, -0.06412180f, -0.09472696f, 0.11282370f, 
    0.28122085f, -0.03686249f, -0.19304442f, -0.05463748f, 0.06219301f, -0.00925822f, -0.06502141f, -0.08276238f, 
    0.03569596f, 0.19940579f, -0.18071046f, 0.01233636f, -0.00120822f, 0.05925246f, -0.04928021f, 0.12118126f, 
    -0.06113640f, -0.11013019f, 0.04542211f, 0.02532512f, 0.44190037f, 0.15734430f, -0.22741249f, 0.11938418f, 
    0.27359363f, 0.07044195f, 0.09525642f, -0.15012640f, 0.07384379f, -0.13303183f, -0.04344796f, 0.06362411f, 
    -0.00046429f, -0.40672314f, 0.02938602f, -0.11006289f, 0.05702676f, 0.09000476f, 0.05761116f, 0.06905966f, 
    -0.36145523f, -0.85516554f, -0.68860584f, -0.25353351f, -0.46624526f, 0.06040242f, 0.02916276f, -0.18882653f, 
    -0.04824834f, 0.01188284f, 0.00527732f, 0.02644531f, 0.00418744f, -0.00959662f, -0.11148486f, -0.02355974f, 
    0.02381909f, 0.05567354f, -0.17450711f, -0.11540873f, 0.11424357f, 0.54060018f, -0.53655535f, 0.14305227f, 
    0.12563708f, 0.09938467f, 0.09344525f, 0.14377959f, 0.09411475f, 0.18532971f, -0.04855048f, 0.03235237f, 
    0.00069111f, 0.09091256f, -0.04957356f, 0.02250532f, -0.01306480f, 0.05563372f, -0.26118323f, 0.12001149f, 
    -0.26366526f, 0.00098017f, -0.00459712f, -0.04617772f, -0.05500002f, -0.11825962f, 0.01725382f, -0.25399104f, 
    -0.27062953f, -0.08982762f, 0.08686572f, 0.00396192f, -0.01756148f, 0.04344305f, -0.05020324f, 0.00807936f, 
    0.02813318f, 0.01490387f, -0.26161125f, -0.16831215f, -0.30688450f, -0.49309433f, 0.02692145f, 0.62843978f, 
    -0.13452467f, -0.02223273f, -0.07637034f, 0.03993745f, 0.13296506f, -0.06157912f, 0.05754656f, 0.05416736f, 
    -0.00482143f, -0.01215590f, -0.00682221f, -0.11583737f, 0.08337674f, 0.05304263f, 0.01424570f, 0.06361804f, 
    0.24456230f, 0.11494524f, -0.26842320f, -0.13162299f, -0.01198247f, -0.01865966f, -0.00702183f, 0.01769855f, 
    -0.02034727f, -0.10880027f, -0.05442353f, 0.04115035f, 0.04854419f, -0.18721597f, 0.05406676f, -0.01008132f, 
    0.08303014f, 0.11841327f, 0.10118980f, 0.03277345f, 0.31363562f, -0.24086958f, 0.43742850f, 0.39981234f, 
    0.21810451f, -0.05709536f, 0.16677237f, -0.19135810f, 0.20836921f, 0.13011660f, -0.01872749f, -0.02090146f, 
    0.03205873f, -0.02519804f, -0.01327108f, -0.00938065f, 0.06643354f, -0.02712379f, -0.05791088f, 0.06114586f, 
    -0.39127544f, -0.11722846f, 0.28713784f, -0.39630210f, 0.11909724f, -0.00877406f, -0.00996182f, -0.06870437f, 
    0.03545127f, 0.05692421f, 0.03251693f, -0.00053441f, 0.04246929f, 0.04865066f, 0.00319251f, -0.10674310f, 
    -0.10434660f, -0.15661843f, -0.04312332f, 0.02763463f, -0.12890530f, 0.04382658f, 0.10730544f, 0.04134738f, 
    0.07005138f, 0.04168703f, 0.00100548f, 0.02130105f, 0.00520726f, 0.16402273f, 0.01595465f, 0.03443927f, 
    -0.02904867f, 0.05865318f, 0.00198960f, -0.06404771f, -0.08517723f, 0.14241618f, 0.10784854f, -0.09156591f, 
    -0.05440160f, -0.12440233f, 0.03077553f, 0.33188108f, -0.16677509f, 0.01063649f, -0.13236652f, 0.11601237f, 
    -0.18725201f, 0.15129864f, 0.04936413f, -0.02529754f, 0.06382080f, 0.00773423f, -0.02118032f, -0.03241664f, 
    0.06972548f, -0.04517909f, 0.14664292f, -0.12087592f, -0.15240911f, 0.10161096f, -0.04531324f, -0.01741763f, 
    0.00713954f, -0.05324724f, -0.06949095f, -0.10573816f, -0.13810444f, -0.03240475f, 0.19019011f, -0.16947544f, 
    0.08275232f, -0.02132878f, 0.01742764f, 0.03061550f, 0.02965824f, -0.10734197f, 0.12063003f, -0.07685440f, 
    0.14094880f, -0.01423126f, -0.07600498f, -0.08752941f, 0.16707166f, 0.03360195f, -0.06502172f, -0.00618247f, 
    0.00264691f, 0.03479124f, -0.04711714f, 0.08074956f, 0.06147705f, 0.08154210f, -0.12863654f, 0.05410109f, 
    0.02028712f, 0.02365810f, -0.02582783f, 0.00478148f, -0.53502214f, 0.30213121f, 0.09540202f, -0.24331911f, 
    -0.13261148f, 0.02078840f, -0.02902468f, -0.01191911f, -0.05184883f, 0.10281875f, -0.01771364f, 0.06327311f, 
    -0.15274692f, -0.09534413f, 0.09885045f, -0.03493745f, 0.05002744f, -0.04225743f, 0.15485194f, 0.00926846f, 
    -0.12420566f, 0.05465861f, 0.00729444f, -0.11142002f, 0.03943000f, 0.02359002f, 0.01476770f, 0.00715513f, 
    0.02765579f, 0.00425212f, -0.12459525f, -0.07016847f, -0.12736030f, 0.02771638f, 0.03449040f, 0.01848238f, 
    0.03909451f, 0.08357770f, 0.03273027f, -0.04999901f, 0.06780508f, -0.05554643f, 0.39898306f, 0.25687391f, 
    0.20095418f, 0.01359063f, -0.09209485f, 0.07093859f, 0.20706338f, -0.07479762f, 0.06972414f, 0.09643698f, 
    0.08045994f, 0.02555764f, 0.05871376f, 0.01618657f, -0.09530395f, 0.00448247f, -0.00497033f, -0.02814043f, 
    0.45905238f, -0.41928896f, 0.31534281f, -0.26672366f, 0.24136998f, -0.03799465f, -0.07768297f, 0.01379760f, 
    -0.18309137f, 0.06890640f, -0.02820478f, -0.11142816f, -0.09775966f, 0.00393192f, 0.12881836f, 0.17382930f, 
    -0.03618323f, -0.17076822f, 0.05322934f, 0.06565435f, -0.07883664f, 0.04669711f, -0.03408716f, -0.08268429f, 
    0.03443799f, 0.04787414f, -0.07468759f, 0.03604429f, 0.02500097f, 0.04855865f, -0.06513295f, 0.05857144f, 
    0.30778018f, -0.18117855f, -0.07463818f, 0.04922885f, -0.17583494f, 0.01998229f, 0.12949011f, 0.02256741f, 
    0.07549512f, 0.22970214f, -0.14388858f, -0.07675234f, 0.06575266f, -0.12476239f, -0.26383096f, -0.24331917f, 
    -0.09265021f, 0.10075615f, 0.01872691f, -0.10191438f, 0.12778383f, -0.03089835f, -0.10624301f, -0.05197765f, 
    0.00778519f, -0.07973037f, -0.02452690f, -0.02600634f, 0.11096191f, 0.04935391f, 0.12189680f, 0.13998286f, 
    0.15152240f, 0.01713502f, -0.06571164f, 0.06742705f, 0.06500446f, -0.34778762f, -0.08374990f, 0.05313991f, 
    0.06915395f, 0.02950834f, 0.09950937f, 0.02625774f, -0.05565905f, 0.00197216f, 0.06573430f, -0.05796746f, 
    -0.77005446f, 0.48274469f, 0.31150454f, 0.21047086f, -0.33466935f, -0.00382317f, 0.14408556f, -0.08832914f, 
    -0.25448191f, -0.02310573f, 0.06008445f, 0.07983706f, 0.03179282f, -0.00687502f, -0.00169600f, 0.00200241f, 
    0.07835408f, 0.12807964f, 0.06450595f, 0.09365430f, -0.02328039f, -0.14883617f, 0.44811782f, 0.26770177f, 
    0.39503726f, -0.12441796f, 0.06900702f, -0.12068608f, 0.21012698f, -0.00358220f, -0.00563935f, 0.04254679f, 
    0.02413965f, 0.01480149f, -0.00097764f, 0.05488965f, -0.08953894f, -0.00138724f, -0.06441718f, 0.03349095f, 
    0.15128374f, -0.51903391f, -0.22096720f, 0.34752315f, -0.58402681f, 0.00635219f, -0.00909112f, -0.00864774f, 
    0.05253511f, -0.08710396f, -0.00704964f, 0.01973886f, 0.01464639f, 0.03879334f, -0.04120265f, -0.01922130f, 
    -0.01384395f, 0.07987845f, -0.06483185f, -0.12529734f, -0.58299708f, -0.51147139f, -0.22602183f, -0.68146229f, 
    -0.52778369f, 0.02969482f, -0.01216994f, -0.00151040f, 0.02505947f, 0.09058984f, 0.00215673f, 0.03021887f, 
    -0.02707063f, 0.06308955f, 0.00225675f, -0.05829569f, -0.10472666f, 0.05496618f, 0.01454945f, 0.03387248f, 
    -0.01430974f, -1.26755869f, 0.13051610f, -0.40915409f, -0.44331056f, -0.01939847f, -0.17207350f, -0.29886135f, 
    0.03369338f, -0.26686284f, -0.03896168f, -0.08286244f, 0.00516872f, -0.05368370f, -0.01706574f, -0.14745848f, 
    -0.12178928f, -0.11747340f, 0.30511877f, 0.20265514f, 0.13068885f, -0.10721897f, -0.04396378f, -0.00560741f, 
    -0.10292485f, 0.08435298f, -0.22262123f, -0.22941877f, 0.26729745f, -0.18130097f, 0.03981688f, 0.13527589f, 
    -0.11836611f, 0.04075327f, -0.05187212f, 0.02214363f, -0.07613041f, -0.01642637f, 0.13282642f, -0.03556442f, 
    -0.25165769f, 0.15455978f, -0.02432802f, -0.12128561f, -0.05368562f, -0.02905818f, -0.07906523f, -0.17113005f, 
    -0.09806626f, 0.02522244f, 0.12670292f, -0.00810058f, -0.11299659f, 0.01529965f, 0.02529689f, 0.05374343f, 
    -0.03703934f, -0.07713592f, 0.02646412f, -0.02296363f, -0.09253509f, -0.12163623f, 0.69470459f, 0.04841509f, 
    0.28862759f, -0.08039124f, -0.05795254f, 0.08322975f, 0.18297912f, -0.11694052f, 0.08505858f, 0.02256630f, 
    0.19493406f, -0.19702828f, 0.19269565f, 0.01820366f, -0.01934582f, -0.00430458f, 0.01358413f, -0.02844832f, 
    -0.42663577f, 0.45924643f, 0.60844207f, 0.19893400f, 0.03189945f, -0.12461185f, -0.03386521f, 0.16297866f, 
    -0.13327312f, 0.06914895f, 0.13401999f, 0.04677837f, 0.08878155f, -0.07754975f, 0.01904112f, -0.05245150f, 
    0.04720378f, 0.18554273f, 0.03768297f, -0.09744402f, 0.12217090f, 0.06988123f, -0.07903969f, 0.04173481f, 
    0.13246594f, -0.04888725f, 0.04628233f, -0.05417057f, 0.00609672f, -0.09662582f, -0.18093245f, -0.03484786f, 
    -0.14373720f, 0.01033028f, 0.04489760f, 0.06535254f, -0.02172381f, -0.01957496f, -0.07164188f, 0.02108939f, 
    -0.73752743f, 0.70991635f, -0.14133400f, -0.21650621f, 0.07666650f, 0.30856803f, 0.11473386f, 0.06577539f, 
    -0.10909048f, 0.03351755f, -0.17132245f, -0.09239557f, -0.00132519f, -0.10529244f, 0.14182647f, -0.02762696f, 
    0.10819998f, -0.07007662f, 0.12376278f, -0.02888298f, 0.15799445f, -0.08376762f, -0.07674069f, 0.08810831f, 
    0.37248969f, -0.01899317f, 0.01391504f, 0.14774716f, 0.02967421f, 0.05259022f, -0.04681815f, -0.03067338f, 
    0.02422271f, -0.02209711f, 0.00577685f, -0.17282729f, -0.10365049f, -0.05663739f, -0.10009098f, 0.11519241f, 
    0.37064457f, 0.54447287f, -0.25512251f, -0.51982027f, 0.14003332f, 0.06129900f, -0.06926297f, -0.13760340f, 
    -0.19145703f, 0.12362248f, 0.00600670f, -0.17373906f, -0.03928236f, -0.17985308f, 0.04474655f, 0.18164098f, 
    0.20000426f, -0.02177104f, -0.00304677f, 0.29744345f, 0.42651734f, 1.25865090f, 0.53432423f, -0.43161938f, 
    0.03750017f, 0.07685523f, 0.12612250f, 0.05274940f, -0.01688711f, -0.13127419f, -0.18272834f, -0.07328545f, 
    0.01069599f, -0.10902058f, 0.11858018f, -0.03643362f, -0.01290654f, -0.04765888f, -0.07930456f, -0.13482168f, 
    0.03366006f, -0.09509099f, -0.28584161f, 0.16374058f, 0.29512185f, 0.21567596f, -0.00791581f, 0.04242556f, 
    0.06558157f, 0.07272679f, 0.11247355f, 0.01496254f, -0.10539751f, -0.05484719f, -0.01572104f, 0.01337710f, 
    -0.13132945f, 0.25382921f, -0.34909105f, -0.01949702f, 0.18225922f, -0.09149440f, -0.09711667f, -0.28653324f, 
    0.12123458f, 0.02286958f, 0.02002054f, -0.12360995f, 0.10102498f, -0.13759284f, -0.00619228f, -0.03806134f, 
    0.00327130f, 0.06746313f, -0.03032258f, -0.14492291f, -0.09301069f, 0.07377217f, -0.11962430f, -0.09360036f, 
    -0.24115358f, -0.11225837f, -0.14468999f, 0.20444436f, -0.03865016f, 0.07577179f, 0.09111813f, 0.19329764f, 
    0.07466540f, 0.14812353f, -0.00375096f, 0.00883874f, -0.11627637f, 0.03769669f, 0.04025701f, 0.05272266f, 
    -0.18472911f, 0.15630980f, -0.10530399f, -0.17439599f, 0.05786668f, -0.11310174f, -0.42606691f, -0.11471995f, 
    0.29762280f, -0.11006214f, 0.05165180f, -0.07571577f, -0.02238967f, 0.15479840f, -0.05783593f, 0.15546790f, 
    -0.21743120f, -0.00641900f, 0.13772619f, -0.06609526f, 0.02086440f, 0.16022499f, 0.06008676f, -0.09368853f, 
    -0.35438022f, 0.45056087f, -0.33052874f, -0.18038617f, -0.68722212f, 0.11561197f, 0.03922180f, 0.01932367f, 
    -0.07996960f, 0.01587014f, 0.08704860f, -0.15407437f, -0.01150886f, -0.20304839f, 0.03355766f, 0.11196598f, 
    -0.06600479f, -0.33856517f, -0.14162920f, -0.22759639f, -0.05189655f, 0.13724394f, -0.09826975f, -0.19368020f, 
    0.30248997f, 0.13394247f, -0.02280173f, -0.09513953f, -0.13910304f, -0.03733768f, -0.03046010f, 0.23219955f, 
    0.01311213f, 0.08436514f, 0.06536864f, 0.00905285f, 0.02989492f, 0.12733978f, 0.02153780f, 0.08016099f, 
    -0.57047945f, -0.30635211f, 0.57455051f, -0.30991769f, 0.01553223f, -0.27176481f, -0.19862491f, 0.03816504f, 
    -0.00277136f, -0.29604152f, 0.13233626f, 0.02401643f, 0.05258869f, 0.09490763f, 0.06272922f, 0.02343878f, 
    0.03156598f, -0.05541993f, -0.06671747f, -0.04865838f, 0.02564989f, -0.17158774f, 0.35024154f, 0.25896785f, 
    0.09480320f, -0.06290089f, 0.02134745f, -0.08559868f, 0.03585757f, -0.36895725f, -0.00696081f, 0.06960815f, 
    0.01596086f, -0.03033359f, -0.08014575f, -0.02485621f, -0.13640550f, 0.15445814f, -0.10337856f, 0.03818176f, 
    0.33813685f, -0.28994033f, -0.23904534f, -0.06456296f, 0.25271335f, -0.09259424f, 0.03994913f, 0.04673148f, 
    0.13308011f, -0.07041112f, 0.01119320f, 0.09795266f, 0.01426261f, 0.01070951f, 0.00339654f, -0.03829553f, 
    0.15006860f, 0.20767331f, -0.01579908f, -0.00174685f, -0.72012782f, 0.28819862f, -0.32451546f, 0.28673571f, 
    -0.07315061f, 0.00706991f, -0.21011145f, 0.14941125f, -0.02698762f, 0.01857114f, -0.02033116f, 0.05306013f, 
    -0.01746946f, -0.16673863f, -0.17334925f, 0.16689263f, 0.08984473f, -0.00565980f, 0.02306648f, -0.28833824f, 
    0.19109714f, -0.16972601f, 0.16157997f, -0.47328213f, -0.54414237f, -0.07244174f, 0.07505477f, -0.08180657f, 
    -0.00634256f, -0.31726140f, 0.09864291f, -0.04452985f, 0.15497570f, -0.15020634f, -0.23382579f, -0.12041106f, 
    0.05436999f, -0.21474555f, 0.12255216f, -0.13051374f, -0.52599251f, -0.15909065f, 0.14550982f, 0.26271889f, 
    -0.19351254f, 0.03928379f, 0.10742861f, 0.03687566f, 0.02116335f, -0.11283869f, 0.09160405f, -0.13715638f, 
    0.03552404f, 0.00071813f, -0.08043017f, -0.01171528f, -0.03511318f, -0.07305337f, -0.07862607f, -0.11799818f, 
    -0.52103174f, -0.25223708f, -0.26933077f, -0.02181543f, -0.07275197f, 0.01794239f, -0.04778351f, -0.07403924f, 
    -0.18945335f, -0.19227244f, -0.15451916f, 0.04604360f, -0.02962652f, -0.00166168f, -0.18333873f, 0.05835034f, 
    0.13649319f, -0.00877920f, -0.10427050f, -0.13169777f, -0.46244025f, 0.16425942f, -0.20781586f, -0.12478448f, 
    0.30091152f, 0.29844010f, -0.00116374f, -0.04002709f, 0.03237084f, -0.18373406f, -0.25265291f, 0.07210921f, 
    0.00775278f, 0.07312916f, 0.12708297f, 0.05452622f, 0.05161399f, -0.01381997f, -0.00795428f, 0.02165937f, 
    0.87140137f, 0.03910218f, -0.55715585f, -0.15126790f, -0.13720714f, 0.13262290f, -0.07280736f, 0.07426362f, 
    -0.13352616f, -0.02886712f, -0.38063890f, -0.23219399f, 0.09377645f, -0.09635220f, -0.03618214f, -0.15026067f, 
    0.11585851f, -0.24169998f, 0.10950221f, 0.18080692f, -0.62477028f, 0.28763586f, -0.21126366f, -0.07877393f, 
    -0.42039308f, 0.11345702f, -0.10015257f, 0.13544606f, -0.12317161f, -0.08230692f, -0.06957065f, -0.21733874f, 
    -0.09628832f, -0.20421578f, -0.18452229f, -0.04397489f, -0.11695390f, -0.03108187f, -0.03847277f, -0.14960483f, 
    -0.59158289f, 0.08063942f, -0.11843238f, 0.59579444f, -0.14041173f, 0.04057620f, -0.11347624f, 0.07833211f, 
    -0.12176095f, -0.27579993f, -0.17623682f, -0.09823766f, -0.29801619f, -0.09265955f, 0.02632495f, 0.13576880f, 
    -0.16658181f, 0.23422231f, -0.25279856f, -0.31066966f, 0.18635958f, -0.44311768f, -0.26157868f, -0.00897556f, 
    0.32061565f, 0.17182951f, 0.09895684f, 0.01109051f, -0.07787565f, -0.06994685f, -0.10766939f, 0.03955006f, 
    0.16259745f, 0.10331172f, -0.03259730f, -0.01875127f, -0.04110399f, 0.09842499f, 0.07405505f, -0.14936556f, 
    -0.43832839f, -0.01364108f, -0.09430322f, 0.36061853f, 0.30636999f, -0.14087385f, -0.06163091f, 0.24957186f, 
    -0.13608947f, 0.00185405f, -0.05519186f, 0.11989295f, -0.16369474f, -0.00879442f, 0.09251151f, -0.17649662f, 
    -0.05384917f, -0.01151832f, 0.00531252f, -0.03598354f, -0.13262266f, 0.41627875f, -0.18435630f, -0.02684895f, 
    0.12150270f, 0.07514248f, 0.02176062f, 0.14067771f, -0.04944614f, 0.09852295f, -0.17525038f, 0.06222464f, 
    0.08414873f, 0.08018041f, 0.15009455f, -0.09662615f, 0.02195381f, 0.11694556f, 0.09043515f, 0.05800283f, 
    -0.10018324f, -0.09745725f, -0.29644379f, -0.08742245f, 0.20317608f, 0.14728996f, -0.02028765f, -0.07492923f, 
    0.08800144f, -0.01912027f, -0.03402702f, 0.05648664f, -0.13361618f, 0.05388246f, -0.10597955f, -0.07750493f, 
    -0.05881122f, 0.14982137f, -0.15825899f, 0.06070355f, -1.13167810f, -0.17985415f, 0.07238486f, -0.00925314f, 
    -0.35514244f, -0.12191979f, -0.03020744f, 0.13880537f, 0.15037622f, -0.04874073f, 0.12287702f, 0.08181343f, 
    0.11683166f, 0.04353099f, -0.04863861f, -0.04506385f, -0.10187530f, -0.11594528f, -0.06902707f, -0.07158405f, 
    0.18667671f, -0.27809066f, -0.15474118f, 0.06341082f, 0.51696515f, -0.07994585f, 0.24335067f, -0.00967495f, 
    0.02363526f, 0.13509740f, -0.08067475f, -0.04591595f, -0.12806600f, -0.16796064f, 0.04299344f, 0.07066409f, 
    -0.12227505f, -0.01238896f, 0.17650884f, -0.00057217f, -0.19986619f, -0.12081958f, -0.49157196f, 0.04063182f, 
    0.28373462f, 0.16186899f, -0.01687078f, 0.10729100f, 0.07470622f, 0.09360614f, -0.09999524f, 0.02216058f, 
    0.11418241f, 0.09369176f, -0.00442594f, 0.10314897f, -0.00190414f, 0.14666800f, 0.01418783f, 0.14863808f, 
    -0.63209730f, 0.31667536f, 0.06982467f, 0.47787321f, 0.06052658f, -0.04946738f, -0.19672036f, 0.01404345f, 
    -0.16834754f, -0.08392642f, 0.02192327f, 0.06060942f, 0.20599625f, 0.08925765f, -0.25226381f, 0.15818274f, 
    -0.01917367f, 0.00879999f, -0.05144670f, -0.04365250f, -0.51229161f, 0.85640848f, 0.08383675f, -0.15039989f, 
    0.37550938f, 0.30536363f, 0.02454398f, 0.02280108f, -0.19372804f, 0.09764449f, -0.23651472f, 0.09477936f, 
    0.12908827f, 0.01528120f, 0.15482427f, 0.02389210f, 0.01050956f, -0.10403756f, 0.01257585f, 0.08022883f, 
    0.27659580f, 0.65256423f, 0.20088863f, -0.01073507f, 0.43704683f, 0.25720870f, 0.21909055f, -0.09040529f, 
    -0.03625790f, 0.04827468f, -0.05373418f, 0.00388527f, 0.04226103f, 0.01485724f, 0.06952310f, 0.03181566f, 
    -0.12824674f, 0.04484491f, 0.04958649f, -0.13187088f, 0.48253310f, 0.07999122f, -0.17659475f, -0.10557828f, 
    0.22908309f, 0.14074120f, 0.08379427f, -0.07912725f, 0.02251749f, -0.09123237f, -0.16340262f, 0.08940786f, 
    -0.03253874f, -0.13856138f, -0.10438788f, 0.24702120f, 0.05905654f, 0.03625473f, 0.16627693f, 0.10091833f, 
    0.12604077f, -0.23551276f, -0.03351599f, -0.09278359f, -0.05598471f, -0.32902300f, -0.17358182f, 0.02879620f, 
    -0.06848474f, 0.03239515f, -0.25145596f, 0.10808431f, 0.04199255f, -0.08167187f, 0.01797288f, -0.04542761f, 
    0.00938721f, 0.06705202f, -0.09593558f, -0.00976918f, -0.04230966f, 0.19106553f, 0.28354666f, 0.22445840f, 
    0.13006179f, -0.07969825f, 0.06195747f, -0.02745052f, 0.02390043f, 0.25019071f, 0.01516411f, -0.00307348f, 
    -0.02719913f, -0.01167184f, -0.01719216f, -0.01046546f, -0.02561729f, -0.16082796f, 0.06558143f, 0.00680983f, 
    -0.05308159f, 0.03834531f, 0.03273344f, 0.22260182f, -0.05617845f, 0.18289466f, -0.05467550f, -0.09600122f, 
    -0.16081597f, 0.05847489f, -0.12384731f, -0.17536622f, 0.17552063f, -0.02381246f, 0.10521713f, -0.04990036f, 
    -0.19003624f, -0.05300809f, -0.30024192f, -0.07483642f, 0.19079785f, -1.24253869f, -0.31098616f, 0.08984487f, 
    -0.76480782f, 0.04879277f, -0.00543474f, 0.14649034f, -0.25143361f, 0.14505553f, -0.01412509f, -0.07237894f, 
    -0.25125712f, 0.16532831f, -0.25406641f, -0.22157617f, -0.17116416f, 0.04070324f, -0.06133070f, 0.18851347f, 
    0.12244853f, 0.24144928f, 0.36899143f, 0.37482378f, 0.30540496f, -0.12944202f, 0.14537242f, -0.01370467f, 
    0.03239356f, 0.16391961f, -0.13308957f, 0.02135508f, -0.04871088f, 0.06318573f, 0.02823643f, -0.04529236f, 
    -0.08582143f, -0.21568409f, -0.06645598f, -0.18036459f, -0.15503435f, -0.17082621f, -0.01525233f, 0.10491034f, 
    -0.05550478f, -0.14293829f, -0.08225319f, -0.04387146f, -0.17441808f, -0.04566726f, 0.05484649f, -0.01221507f, 
    -0.04983487f, 0.04330333f, -0.02811138f, 0.00085105f, 0.09746816f, -0.11194114f, 0.15184934f, 0.05174201f, 
    0.10541015f, 0.09546164f, 0.25142515f, -0.11521740f, 0.22474785f, 0.03946328f, 0.00186787f, 0.01254598f, 
    -0.03285705f, 0.10261131f, 0.06869531f, 0.24106397f, 0.00865910f, -0.00835263f, 0.01869715f, 0.03290111f, 
    -0.06982623f, -0.17821948f, -0.27660328f, -0.34149817f, -0.15006226f, -0.12442102f, 0.42071289f, -0.05629610f, 
    -0.03109313f, -0.23246029f, 0.03311177f, 0.00628324f, 0.08931557f, -0.26220733f, 0.02229759f, -0.09277357f, 
    0.01121640f, 0.00414411f, -0.00615299f, -0.06422347f, 0.10944242f, -0.04448603f, -0.02609873f, -0.13330294f, 
    0.06013508f, -0.29713857f, -0.16307199f, -0.22827251f, -0.16162361f, 0.00174420f, 0.07439525f, -0.03876502f, 
    0.11735018f, 0.04324949f, -0.04869052f, -0.26846769f, -0.03570231f, -0.04687188f, 0.04449333f, -0.55827379f, 
    -0.16142602f, -0.01697904f, 0.09001428f, -0.27459002f, -0.01251825f, -0.05067248f, -0.03211680f, 0.29095802f, 
    0.08048183f, -0.19576444f, 0.00696776f, 0.03357347f, -0.25383741f, -0.15107685f, -0.04148068f, -0.00027609f, 
    0.01909370f, 0.07436186f, 0.05170786f, -0.01329042f, -0.08431201f, -0.01938549f, -0.05401867f, 0.10749891f, 
    0.13477603f, 0.09348492f, -0.03353629f, 0.21838705f, 0.25852945f, 0.05209526f, 0.07259482f, 0.07205216f, 
    0.05914784f, 0.02500906f, 0.14360093f, 0.00978644f, 0.00878437f, -0.01529600f, 0.05495267f, -0.03508183f, 
    -0.03515425f, 0.07819953f, -0.00938871f, 0.02106944f, -0.61950159f, 0.18103677f, -0.29487088f, -0.42960855f, 
    -0.09010679f, 0.07658929f, -0.08121911f, 0.03648511f, 0.00735292f, 0.02478036f, 0.03577381f, -0.03865950f, 
    0.02961369f, -0.10819348f, 0.02758170f, -0.06355693f, 0.04168532f, 0.06814373f, -0.23026633f, 0.10912777f, 
    -0.45993701f, -0.05431716f, -0.06525145f, -0.11986448f, 0.10449607f, -0.07756014f, 0.16784009f, -0.09662297f, 
    -0.05930687f, -0.03569544f, -0.03189074f, -0.00442402f, -0.02874423f, 0.16057047f, 0.22422512f, 0.10916824f, 
    0.08438775f, 0.10252559f, -0.01668461f, 0.20171671f, 0.15640472f, -0.18659824f, 0.10910509f, -0.08126689f, 
    0.01300678f, 0.06164843f, 0.05212459f, 0.11461741f, -0.04972744f, -0.07650643f, 0.02133739f, -0.12603307f, 
    -0.01073973f, 0.04297954f, 0.00112664f, 0.01070525f, -0.10655921f, -0.06425551f, -0.17674565f, -0.28030944f, 
    -0.06175852f, -0.06975388f, -0.09050185f, 0.06967980f, -0.14055261f, 0.02594406f, 0.06968594f, 0.00222665f, 
    -0.09705861f, 0.00425371f, -0.06668061f, -0.12944055f, -0.01593581f, -0.01659774f, -0.06568509f, 0.16702569f, 
    0.00404393f, 0.03787870f, -0.11206339f, 0.00667300f, -0.18198001f, 0.06876797f, 0.06182178f, -0.33585444f, 
    -0.10026867f, 0.10005581f, 0.06296654f, -0.05225537f, -0.00699198f, 0.05215237f, 0.01377105f, 0.06258450f, 
    0.11503383f, 0.14685653f, -0.08865698f, -0.15236570f, 0.02264829f, -0.06989892f, -0.15406324f, -0.05697425f, 
    0.02620645f, -0.00631299f, -0.03050371f, -0.06498724f, -0.01742684f, 0.10627278f, 0.01392761f, 0.05496750f, 
    0.03367353f, 0.05306574f, 0.12437928f, -0.05722996f, -0.00594258f, -0.04274843f, -0.05558049f, 0.07541241f, 
    0.06596258f, -0.02485817f, -0.04377062f, -0.00074582f, 0.29533416f, -0.19762062f, 0.22144507f, 0.11739488f, 
    0.05658607f, -0.11731655f, -0.11246064f, -0.05587000f, -0.01290289f, 0.01044286f, 0.13875119f, -0.12274659f, 
    0.04087377f, -0.02771972f, 0.09693990f, 0.08840803f, -0.00003707f, 0.03831688f, -0.00340277f, -0.05859647f, 
    0.19787267f, -0.16118149f, -0.07385059f, -0.21821785f, -0.06850838f, 0.02348458f, -0.11580042f, 0.14296724f, 
    0.22162008f, 0.08636876f, -0.02297343f, 0.01840363f, -0.01119020f, -0.22788787f, -0.05893771f, -0.07089909f, 
    -0.08591630f, 0.13756055f, -0.29250625f, 0.08972516f, 0.07490602f, -0.08297776f, -0.03500262f, -0.11706531f, 
    -0.07131261f, 0.05545347f, -0.00675807f, 0.00090825f, 0.03722995f, 0.04522506f, -0.10348372f, -0.06912720f, 
    0.02155622f, -0.07024831f, -0.04993853f, 0.05543778f, -0.19635533f, -0.02316944f, -0.08752576f, -0.17131010f, 
    0.01576046f, -0.07989076f, 0.09957283f, -0.12924233f, 0.25784084f, 0.22254111f, 0.04123086f, -0.00477844f, 
    0.04676251f, 0.00441310f, -0.03489951f, 0.02925641f, -0.04888453f, 0.08907972f, -0.02269426f, 0.02090161f, 
    -0.20570788f, -0.12418734f, -0.21202242f, -0.11483660f, 0.12524857f, 0.10660051f, 0.13642088f, 0.11375409f, 
    0.01570273f, -0.02544481f, -0.06575385f, -0.20897435f, 0.02491425f, -0.06250211f, 0.17358495f, -0.14116873f, 
    -0.11054540f, 0.02048573f, 0.05069638f, 0.10978928f, 0.04097774f, -0.10520539f, -0.06595226f, -0.00477039f, 
    0.19278766f, 0.02034564f, 0.40239888f, -0.21723004f, 0.23205160f, 0.08312161f, 0.20039248f, 0.00318799f, 
    -0.03408558f, -0.09266149f, 0.04438735f, -0.10959443f, -0.04307048f, -0.05148625f, -0.08808690f, -0.10693471f, 
    -0.01090003f, -0.19872263f, -0.07957411f, -0.08894333f, -0.22622927f, -0.23411393f, 0.10172496f, 0.04213203f, 
    0.23781662f, -0.07833974f, 0.01786312f, -0.04325608f, -0.41600287f, -0.06889310f, -0.04223463f, -0.01893869f, 
    0.00022555f, -0.12118103f, -0.23571418f, -0.10987569f, 0.04172703f, 0.00872004f, -0.12570170f, 0.33471876f, 
    0.11692505f, 0.04195553f, 0.20048250f, 0.17847593f, 0.07615403f, -0.21341152f, -0.07579219f, -0.01814382f, 
    0.02563065f, 0.00781377f, 0.02592683f, 0.00076485f, 0.03708616f, 0.05048402f, 0.01933639f, 0.00835534f, 
    -0.08780210f, -0.10303336f, 0.06094037f, -0.05659152f, 0.10513940f, 0.09764126f, 0.06007863f, 0.21835254f, 
    0.36665842f, 0.11292761f, 0.09054124f, -0.00618537f, 0.07271787f, 0.10364966f, 0.14153095f, 0.05954453f, 
    0.04011998f, -0.00085500f, 0.05364465f, 0.03100922f, 0.09311847f, 0.03208647f, -0.12709349f, 0.19006895f, 
    0.11531584f, 0.12410514f, 0.07775928f, 0.33906871f, 0.05864867f, 0.08657674f, 0.17282948f, 0.05969901f, 
    0.12259986f, 0.17779665f, 0.01563948f, -0.05207477f, -0.00781735f, -0.00252314f, -0.02300493f, 0.04771979f, 
    0.11559239f, 0.01278662f, 0.05506562f, 0.34633163f, 0.09155207f, 0.16376518f, 0.13189699f, 0.23158577f, 
    -0.02056661f, -0.03845995f, -0.09770289f, -0.11854446f, -0.21529996f, 0.04915683f, 0.02660834f, -0.04157427f, 
    0.05286901f, 0.12786236f, 0.02465682f, 0.11138128f, 0.00379722f, -0.09713685f, -0.09169222f, -0.06609925f, 
    0.11226282f, -0.18750606f, -0.04125273f, -0.21376443f, -0.09231631f, 0.04084380f, 0.02458661f, 0.19599047f, 
    -0.10757624f, -0.02006286f, 0.02951967f, -0.01007421f, -0.10811538f, -0.03565345f, -0.25214919f, -0.01355901f, 
    0.07614692f, -0.21468416f, -0.20995016f, -0.17262933f, -0.00131950f, -0.13867292f, 0.26375616f, -0.01797104f, 
    0.06529862f, -0.16045135f, -0.01416675f, -0.09015553f, 0.05314144f, 0.00544664f, -0.05901112f, -0.01056422f, 
    -0.10034135f, 0.00955513f, -0.03553728f, 0.06324276f, 0.04833262f, 0.06629496f, -0.00173665f, -0.09924540f, 
    -0.76339298f, -0.42672354f, 0.11870669f, -0.04822731f, -0.06708159f, -0.24987492f, -0.04658856f, -0.26952314f, 
    -0.01075579f, 0.01233803f, -0.08331095f, -0.13708067f, -0.10648359f, 0.21268651f, 0.04244436f, -0.00112515f, 
    0.06466036f, -0.05893875f, -0.05956601f, -0.06860743f, 0.01457204f, 0.05414936f, 0.13635920f, 0.02118922f, 
    0.14037487f, -0.02367994f, -0.02455761f, 0.01007854f, 0.05431107f, 0.05887554f, 0.15019999f, 0.03374738f, 
    0.09765188f, 0.00760745f, 0.03583175f, 0.08062428f, -0.00955829f, -0.00102201f, -0.01389574f, 0.01401404f, 
    -0.31767914f, 0.00530975f, -0.22341563f, -0.34489065f, -0.17800663f, -0.13642079f, 0.02849107f, -0.13946861f, 
    -0.13990328f, 0.14059466f, 0.09710634f, 0.22950003f, -0.19998410f, 0.15409103f, 0.01189104f, -0.12581633f, 
    -0.16352168f, 0.01707841f, 0.04863083f, 0.19633086f, 0.16597615f, 0.02877894f, 0.25228396f, 0.09348992f, 
    -0.16648622f, 0.18956488f, -0.00355886f, 0.20145449f, -0.04387791f, -0.09669697f, 0.02318047f, 0.02038291f, 
    -0.01127167f, 0.07455473f, 0.07056349f, 0.00885827f, 0.02750085f, 0.00141269f, -0.10376880f, -0.03523487f, 
    -0.12002750f, -0.14628083f, 0.06267055f, 0.07698043f, -0.20341593f, 0.12901631f, -0.08250032f, 0.09496538f, 
    0.15832655f, -0.10198399f, 0.17407286f, -0.06602198f, -0.02751841f, -0.07662147f, 0.11161201f, 0.11414612f, 
    0.02043471f, 0.15293734f, 0.03376525f, 0.03970781f, -0.51196790f, -0.09881097f, 0.28129452f, 0.10862210f, 
    -0.18336427f, -0.01779107f, -0.07384882f, -0.12217677f, 0.15117915f, -0.03758749f, 0.01603598f, -0.06899630f, 
    -0.28170657f, 0.03510877f, -0.05742899f, 0.11514619f, -0.01825751f, -0.08289988f, 0.02659487f, -0.09038852f, 
    0.13165711f, -0.22615595f, 0.49965021f, -0.12540668f, -0.41307154f, 0.02632366f, 0.07870956f, 0.00054764f, 
    -0.03561752f, -0.04888546f, 0.08470161f, -0.03445279f, 0.00163889f, -0.02479699f, 0.06044653f, -0.04544414f, 
    0.10148038f, -0.03340487f, 0.00464652f, 0.17501429f, 0.06635743f, -0.02218922f, 0.28186429f, 0.23326057f, 
    -0.25924429f, -0.00261796f, 0.13608858f, 0.07889187f, -0.02211793f, 0.11241326f, 0.10243199f, 0.06150971f, 
    0.02353386f, 0.05526425f, 0.06986941f, -0.09158562f, -0.14225507f, -0.05768969f, -0.07886153f, -0.05309699f, 
    0.18719727f, -0.03302476f, 0.07359017f, -0.15085644f, 0.01130712f, -0.04937294f, 0.03009082f, 0.18156533f, 
    -0.01382435f, 0.00189556f, -0.04544792f, -0.12658784f, -0.05010317f, -0.10851827f, -0.02804271f, 0.01854910f, 
    0.13017237f, 0.11085803f, 0.13267612f, 0.19963393f, -0.22816348f, 0.03347671f, 0.16682105f, -0.10979309f, 
    -0.04515158f, 0.24844784f, -0.08119091f, -0.09278237f, -0.05580743f, 0.17726530f, -0.00489577f, -0.02274924f, 
    0.03377225f, 0.12261693f, 0.05761387f, 0.11222106f, -0.10252128f, -0.26609978f, -0.09851063f, 0.01507422f, 
    0.34117672f, -0.67178804f, -0.02306185f, 0.24138533f, 0.13328363f, 0.06105060f, -0.06819069f, -0.10078577f, 
    -0.11335777f, 0.14304245f, 0.00216147f, 0.28839305f, 0.00157716f, 0.05547231f, 0.22608645f, 0.08599319f, 
    -0.34241280f, 0.06297440f, 0.08254799f, 0.55245602f, -0.18410170f, -0.05898629f, 0.16758376f, 0.00633130f, 
    -0.35026273f, 0.14123069f, -0.06395287f, 0.06363668f, 0.11195869f, 0.04475585f, 0.03616265f, 0.03311060f, 
    -0.10787009f, -0.01566075f, 0.02941341f, -0.05505666f, 0.02894384f, 0.03625704f, 0.11110004f, 0.06336460f, 
    -0.34759155f, -0.33564013f, -0.18815480f, 0.19081703f, 0.02816988f, 0.12363620f, 0.09123188f, 0.02074447f, 
    0.02267979f, 0.06808288f, -0.04018034f, -0.06555047f, -0.01626893f, 0.05026757f, -0.01906553f, 0.06670392f, 
    -0.12550442f, 0.29294047f, -0.08489843f, -0.04986974f, 0.68416119f, -0.07157955f, -0.26493573f, 0.06655274f, 
    0.25715187f, 0.05299360f, -0.00623591f, -0.04152121f, -0.04424199f, 0.07670644f, 0.08634955f, 0.01597505f, 
    0.10135278f, -0.07183641f, 0.04698427f, 0.05463578f, 0.14465861f, -0.07235027f, -0.05373051f, -0.13768707f, 
    0.29547957f, 0.02596149f, -0.00301267f, 0.13413192f, -0.10384463f, -0.01002193f, -0.31718892f, -0.15968190f, 
    -0.05336961f, 0.13253658f, 0.06621905f, -0.00105827f, 0.06198254f, -0.09765668f, -0.14643031f, -0.07993596f, 
    -0.01416751f, -0.27817822f, -0.08207955f, -0.26167464f, 0.02992155f, -0.10866819f, 0.05692716f, -0.25769258f, 
    0.15790489f, 0.07703305f, -0.04468572f, 0.01734520f, -0.00642558f, 0.07741473f, -0.06110429f, -0.09546429f, 
    -0.09984569f, -0.09682178f, -0.13384612f, 0.06240712f, 0.05540534f, 0.24937530f, 0.01496901f, 0.07272948f, 
    0.00613650f, -0.11853869f, -0.13453066f, 0.04315040f, 0.02572074f, 0.16496998f, -0.12025787f, 0.03646613f, 
    0.02821454f, 0.03423844f, 0.04167633f, -0.01106059f, 0.14426878f, 0.02430110f, 0.18371606f, 0.04244273f, 
    0.16200258f, -0.02901668f, -0.03100775f, 0.10863106f, 0.11346444f, -0.09985548f, -0.25111648f, -0.29812166f, 
    0.13971709f, -0.11526446f, 0.06021123f, 0.00890266f, -0.04189139f, -0.04495712f, 0.20397945f, -0.17797109f, 
    -0.13447751f, -0.17488542f, 0.06045114f, 0.01578853f, -0.09900313f, -0.01224886f, -0.02190568f, -0.06878564f, 
    -0.12901323f, -0.04205083f, -0.25614190f, -0.07421305f, 0.07749958f, 0.12011469f, 0.07783648f, 0.00816302f, 
    -0.10809058f, 0.05749898f, 0.04554985f, -0.01092634f, 0.13521409f, 0.10803660f, 0.12901673f, -0.03290679f, 
    0.04599885f, 0.19856097f, 0.06875718f, 0.03792332f, -0.48729727f, -0.14246911f, -0.18545227f, -0.26836726f, 
    -0.19476897f, -0.01132161f, 0.06959463f, -0.05866665f, 0.00564616f, 0.01359681f, 0.09597974f, 0.05638209f, 
    -0.06162980f, -0.10465756f, -0.10587802f, -0.02567240f, -0.03217693f, 0.02870097f, -0.01177065f, 0.00594005f, 
    -0.16877839f, 1.20662165f, -0.57625920f, 0.13359854f, 0.16103210f, -0.05075883f, -0.25090787f, 0.02762305f, 
    -0.01280198f, -0.02542655f, 0.09459122f, 0.05226810f, -0.13862489f, 0.30231151f, 0.13292450f, -0.00793616f, 
    -0.07053875f, 0.36219075f, 0.02132710f, -0.26134968f, -0.06535111f, -0.03384563f, -0.07223507f, -0.20097807f, 
    0.10109331f, -0.24249570f, 0.05409636f, -0.15242812f, -0.07505345f, 0.08633086f, 0.29671207f, 0.23262121f, 
    -0.04523864f, 0.03682270f, 0.08631594f, -0.10688210f, 0.04626646f, -0.01159859f, 0.18584310f, 0.19893773f, 
    0.31902280f, -0.25965008f, 0.13908538f, 0.08638552f, -0.18544666f, -0.17042568f, 0.15276745f, -0.11440406f, 
    0.06851648f, -0.00118287f, 0.12848003f, -0.00925881f, 0.05738011f, 0.02901011f, 0.03082596f, 0.15157777f, 
    0.00807640f, 0.06090990f, 0.28622290f, 0.32794210f, -0.38372681f, 0.37443453f, -0.20037246f, -0.11826155f, 
    -0.10342926f, -0.05482958f, -0.08935121f, 0.10248889f, 0.04290979f, 0.39414695f, 0.08109375f, -0.13299058f, 
    -0.01870608f, -0.03216184f, -0.11085548f, -0.04366747f, 0.06246722f, 0.14850974f, 0.07584577f, 0.06041139f, 
    0.10842109f, 0.01952354f, 0.16844988f, -0.17143722f, 0.15702240f, -0.01038399f, 0.21624660f, -0.02489242f, 
    0.21205978f, 0.12930250f, 0.03692915f, 0.08433584f, -0.06693859f, -0.06185689f, 0.02884964f, -0.12010903f, 
    -0.07098483f, -0.03894334f, 0.04282652f, 0.06674498f, -0.11666096f, -0.04936362f, 0.12606785f, -0.04256571f, 
    -0.29788998f, -0.02259400f, -0.26175085f, 0.11535690f, -0.04170334f, -0.33769190f, -0.10222729f, 0.00388791f, 
    -0.04613082f, -0.14992236f, 0.16065699f, -0.12939510f, -0.08115325f, -0.08792891f, -0.10726657f, -0.21188857f, 
    -0.03999962f, -0.10465579f, 0.37493959f, -0.11748940f, -0.20304307f, 0.26286918f, 0.01620105f, 0.04211282f, 
    -0.10663077f, -0.08904633f, 0.07101066f, 0.04243610f, -0.01416556f, 0.06672182f, 0.03992293f, 0.02487901f, 
    0.05601494f, -0.06653538f, 0.27211165f, 0.13197969f, -0.22368978f, -0.32679132f, -0.06701241f, 0.16422808f, 
    -0.02287062f, 0.17300054f, 0.05115004f, -0.04443109f, 0.00434790f, 0.00739391f, -0.03586598f, -0.05205170f, 
    -0.03710229f, 0.07982276f, -0.00990249f, -0.21346629f, -0.13730446f, 0.26211455f, -0.00404982f, -0.07631093f, 
    0.25506237f, 0.25199115f, 0.42265263f, 0.08716188f, 0.02837072f, -0.05928926f, -0.21678129f, 0.21196288f, 
    0.20842473f, -0.07854515f, 0.09109908f, 0.01012711f, 0.03885087f, 0.00401830f, -0.00583984f, 0.14205487f, 
    -0.01089290f, -0.05154605f, -0.20786370f, -0.46140879f, -0.17933320f, 0.07208481f, 0.21759002f, -0.49273798f, 
    -0.11373905f, -0.07592399f, 0.11165252f, 0.13421616f, -0.24903528f, -0.09537421f, 0.20502667f, 0.06686749f, 
    -0.03009281f, -0.09713396f, -0.00006610f, 0.04740829f, 0.00802070f, -0.05799196f, 0.06852539f, 0.09896491f, 
    -0.04193999f, 0.03433895f, -0.12282597f, -0.60352749f, 0.25334314f, 0.07676853f, 0.17416327f, 0.02354902f, 
    -0.03962670f, -0.10497006f, 0.10365739f, -0.11950179f, -0.01840697f, -0.11725613f, -0.01030569f, 0.00660329f, 
    0.02245756f, 0.03955943f, 0.05235737f, -0.18627588f, -0.13847633f, -0.18599482f, -0.59434897f, -0.28358448f, 
    -0.09807561f, 0.08361026f, 0.07517159f, -0.09224557f, 0.00352453f, -0.06628605f, -0.00803152f, 0.23152098f, 
    -0.16341950f, -0.00957915f, -0.19901556f, -0.06042280f, 0.00769309f, 0.04358283f, -0.01698530f, 0.06180367f, 
    -0.59946215f, -0.17209621f, -0.27352268f, -0.46572909f, -0.01951370f, 0.00917711f, -0.07740399f, -0.06229367f, 
    -0.10373130f, 0.04410505f, -0.09525645f, 0.18340740f, 0.11222202f, -0.16858755f, 0.09298222f, -0.05646032f, 
    -0.10991247f, -0.00758309f, 0.03204748f, 0.13320680f, 0.00689970f, 0.15871452f, -0.05331841f, 0.13832362f, 
    -0.20350799f, 0.01628127f, -0.05202484f, -0.16495465f, 0.01297408f, 0.12659872f, 0.21044888f, -0.20174792f, 
    0.07034460f, -0.11839169f, 0.03878498f, 0.04664363f, 0.08005272f, 0.01412132f, -0.01842808f, -0.01081559f, 
    -0.20875275f, 0.28432378f, 0.27506158f, -0.12571783f, 0.19153103f, 0.03878682f, -0.07704449f, 0.03818360f, 
    -0.08562279f, 0.18353526f, 0.02012379f, 0.18404961f, -0.01220359f, 0.23624434f, 0.00732824f, 0.02358399f, 
    0.05406581f, 0.03575679f, 0.01165091f, 0.13608764f, -0.30982953f, -0.56658101f, -0.51290131f, -0.37002772f, 
    0.15950052f, -0.21419397f, 0.17580882f, -0.17821603f, -0.01882545f, -0.40051979f, 0.07262516f, -0.09390627f, 
    -0.05637226f, -0.08607884f, -0.02372508f, -0.00174811f, 0.00439297f, 0.08521715f, 0.20842347f, 0.07938084f, 
    -0.12973389f, -0.21421127f, 0.31511745f, 0.07680331f, 0.10613415f, -0.18786797f, -0.03127916f, -0.02407862f, 
    -0.15694252f, 0.00888630f, 0.10228722f, 0.00083015f, 0.16343710f, -0.03090445f, 0.07967854f, -0.05112164f, 
    -0.01551666f, -0.11474315f, 0.05157045f, -0.12111203f, 0.00499465f, 0.00170889f, 0.06948862f, 0.07439817f, 
    -0.08262963f, -0.06085379f, 0.06887498f, -0.20076403f, -0.02150884f, 0.15699543f, 0.06862382f, 0.16803628f, 
    0.04123612f, 0.02064934f, -0.12489105f, 0.03495335f, 0.08577804f, 0.04333755f, 0.17106238f, 0.19065772f, 
    -1.11012542f, -1.11659324f, -0.65939152f, -0.18928847f, 0.22195277f, -0.10283360f, 0.10007627f, -0.35141861f, 
    -0.08882509f, -0.59257340f, 0.01040406f, -0.07820382f, -0.09781133f, -0.00355273f, 0.02941234f, -0.02851392f, 
    0.04702285f, 0.09159455f, 0.27423841f, 0.03642009f, -0.48951173f, -0.60959190f, -0.84743673f, 0.15601891f, 
    0.07026625f, -0.15148863f, -0.03704957f, 0.08181493f, -0.25505394f, -0.04850673f, 0.03369623f, -0.06729010f, 
    0.04773936f, -0.15420251f, -0.06887320f, 0.03599212f, 0.03346919f, -0.13546431f, 0.20327665f, -0.04844590f, 
    0.10825174f, -0.04816918f, -0.21519817f, -0.04618172f, 0.06456082f, -0.07313783f, 0.05401265f, -0.06688548f, 
    -0.05673201f, -0.21595521f, 0.11984770f, -0.03047523f, -0.12462132f, -0.03827761f, 0.04975775f, -0.02368702f, 
    -0.01351367f, 0.13776179f, -0.18778181f, -0.16838112f, -0.19623819f, -1.04422688f, -0.87444681f, -0.10344048f, 
    -0.02964250f, 0.27591747f, -0.07317901f, -0.02672394f, -0.12731096f, -0.32152361f, -0.02300682f, 0.03722085f, 
    -0.02831112f, 0.18282521f, -0.18381533f, -0.08717425f, -0.03716552f, 0.17235529f, 0.10027088f, 0.04776623f, 
    -0.03244890f, 0.20556913f, -0.03537489f, -0.15988995f, 0.08886689f, -0.09289321f, 0.02807475f, -0.03235752f, 
    0.03034092f, 0.10417828f, 0.04847588f, -0.00225755f, -0.14090380f, 0.17474072f, 0.03946566f, 0.13611859f, 
    0.04463843f, -0.03512062f, 0.03213958f, 0.00977489f, -0.58022428f, -0.70778078f, -0.13602968f, -0.21886055f, 
    -0.20744719f, -0.17254156f, -0.13849820f, 0.20312893f, -0.18336886f, 0.01390329f, 0.01429936f, 0.00948009f, 
    -0.02050920f, -0.01778163f, -0.07132960f, -0.03477181f, -0.04579291f, -0.04737616f, 0.10153908f, -0.01061531f, 
    0.17161433f, -0.28524610f, -0.23967580f, -0.25745746f, 0.18224642f, -0.07727117f, 0.11814184f, 0.19958667f, 
    -0.03692780f, 0.00675622f, -0.11328107f, -0.08739384f, -0.08682198f, -0.02860508f, -0.03930226f, -0.15163620f, 
    -0.09113634f, -0.18725200f, 0.08714614f, 0.00875040f, 0.19949985f, 0.07726322f, -0.02719664f, -0.27743337f, 
    0.16341721f, -0.00935190f, -0.02067684f, 0.06127017f, 0.05680994f, -0.05102086f, 0.01587739f, -0.04049564f, 
    0.11967261f, -0.09163329f, -0.04502327f, 0.12864187f, 0.11867206f, -0.10588262f, 0.00181300f, 0.10302018f, 
    -0.36769897f, -0.54157060f, -0.34802052f, -0.71739495f, 0.56332892f, -0.13162437f, 0.03692180f, -0.08612193f, 
    -0.05023857f, -0.12120368f, 0.05400728f, -0.01080091f, 0.02884902f, 0.02040204f, -0.11088812f, -0.06542949f, 
    0.15719050f, 0.05624231f, 0.19176829f, -0.09845380f, 0.09828924f, 0.25595194f, -0.01301034f, 0.12315065f, 
    -0.02286180f, 0.07122664f, -0.01544400f, -0.02491491f, -0.08848450f, -0.01454151f, -0.03676901f, 0.03558434f, 
    -0.05912857f, 0.00314830f, 0.16031930f, 0.07094783f, -0.08620620f, 0.13080837f, -0.20961730f, -0.13714640f, 
    0.02884588f, -0.04887537f, 0.09145176f, 0.08093897f, 0.00559763f, -0.02475770f, -0.05265902f, -0.05397521f, 
    0.02537774f, 0.13244715f, -0.08639011f, 0.11881872f, 0.07162388f, -0.05947569f, 0.04739385f, -0.07020624f, 
    0.00017828f, -0.11531668f, -0.04659139f, -0.02215529f, 0.04362548f, 0.15720128f, 0.11583164f, -0.15350023f, 
    0.00663123f, 0.06040834f, 0.03484766f, 0.01338196f, -0.05900264f, -0.14347172f, -0.03402439f, -0.02848699f, 
    0.16361077f, 0.06339773f, 0.14470001f, 0.15124239f, -0.08458465f, -0.02429743f, -0.32107401f, 0.00003519f, 
    0.14614709f, 0.09646606f, -0.02155846f, -0.08764752f, 0.01900859f, 0.08745721f, -0.05828327f, -0.00602918f, 
    -0.05046135f, 0.01218454f, -0.00686671f, -0.00507169f, 0.04152733f, -0.06111756f, -0.01792064f, -0.03205557f, 
    -0.00800497f, -0.07893163f, -0.10001815f, 0.03470959f, -0.55805886f, 0.45046231f, 0.50856930f, -0.05093891f, 
    0.07851198f, -0.07759402f, -0.05135429f, -0.07375895f, -0.12011234f, 0.28532788f, -0.21267150f, 0.17459776f, 
    0.04240634f, 0.06232996f, -0.00562531f, 0.00208431f, -0.03893102f, -0.04729130f, -0.07198022f, 0.00390560f, 
    -0.29408598f, -0.03550472f, 0.30074391f, 0.07715346f, 0.11610537f, 0.00489732f, -0.07343558f, -0.02290533f, 
    0.29699364f, 0.05370015f, 0.00705409f, 0.20403534f, 0.17472479f, -0.05760393f, 0.14287813f, 0.02227863f, 
    0.09490062f, -0.08301676f, 0.05417545f, -0.11502410f, 0.01385114f, -0.08330403f, 0.10587121f, 0.11787624f, 
    -0.03458035f, 0.07009348f, 0.02830368f, -0.00153552f, -0.01106278f, -0.01386549f, 0.14963526f, 0.02300923f, 
    -0.03751981f, 0.14913672f, 0.03192377f, 0.09416169f, 0.03145991f, 0.03932212f, -0.14042349f, 0.00385544f, 
    -0.05906877f, -0.13057423f, -0.11049962f, 0.05048228f, 0.12451229f, 0.00635799f, 0.16018370f, -0.00518078f, 
    0.21738154f, 0.09991466f, 0.10105453f, -0.15336734f, -0.12304487f, -0.03165432f, 0.06285323f, -0.01520813f, 
    0.01617769f, -0.17265135f, 0.11883736f, -0.17529188f, -0.53541923f, 0.32566890f, 0.40864423f, -0.08922897f, 
    0.06054189f, -0.17003296f, -0.09391480f, 0.02629608f, -0.09697934f, 0.18321662f, 0.02769251f, 0.06579733f, 
    -0.00457574f, 0.04436709f, 0.12700830f, -0.01180017f, -0.04079189f, -0.09675847f, -0.02923940f, 0.01641195f, 
    0.40856636f, -0.15361728f, -0.48486134f, -0.20066194f, -0.03517798f, -0.05502041f, 0.14996569f, 0.15212385f, 
    0.01022216f, -0.24847175f, 0.05650096f, -0.03163036f, -0.07484980f, 0.05366895f, 0.13195705f, -0.04600387f, 
    -0.01428828f, 0.23006800f, -0.04712740f, 0.11798247f, 0.17723010f, -0.35470852f, 0.01795179f, 0.32928154f, 
    0.28100121f, -0.13356292f, 0.07379374f, -0.01108353f, 0.01803055f, 0.06410430f, -0.03357396f, 0.05281265f, 
    0.15720199f, -0.02379308f, -0.33459044f, 0.08730704f, 0.16471694f, 0.14438234f, 0.15346177f, 0.05664715f, 
    -0.83355433f, -0.54584414f, -0.20212403f, 0.16886328f, -0.33862376f, -0.18790469f, -0.04932053f, -0.05570354f, 
    -0.11222836f, -0.29117313f, 0.01743763f, 0.02775477f, -0.01993356f, 0.02804501f, 0.00148096f, -0.03762660f, 
    -0.02407252f, 0.05827255f, 0.13559413f, 0.01428987f, -0.11851697f, -0.20582324f, -0.32976651f, -0.37780532f, 
    -0.11446507f, 0.02893420f, 0.00196262f, 0.08925626f, -0.09228176f, -0.03595481f, -0.06071907f, -0.07179382f, 
    -0.08343513f, -0.08247960f, -0.12032691f, -0.11376426f, 0.04971377f, -0.15944998f, -0.00183883f, 0.10332359f, 
    -0.75391668f, -0.51638603f, -1.10307956f, -0.15990596f, -0.06216777f, -0.24191731f, 0.16436201f, -0.23886570f, 
    0.17237511f, -0.52280200f, 0.02519180f, -0.07887808f, -0.04247859f, -0.02163251f, 0.11555706f, -0.00530546f, 
    -0.08977476f, 0.29465735f, 0.11356056f, 0.08041885f, -0.62512881f, -0.29902178f, 0.47277611f, 0.36241812f, 
    -0.40201175f, -0.12905885f, -0.18904813f, -0.12552607f, -0.31030554f, -0.04295431f, -0.04967810f, -0.01940550f, 
    0.12437223f, -0.00601837f, 0.05459410f, 0.04901640f, -0.00107366f, 0.04430932f, -0.17470999f, -0.02366250f, 
    0.21199532f, 0.20232449f, -0.01495113f, -0.02171982f, -0.24220312f, 0.19796756f, 0.12404331f, 0.10631834f, 
    -0.13603760f, -0.13488476f, 0.00040218f, 0.02905481f, 0.09328556f, -0.04475313f, 0.08756026f, 0.12405672f, 
    -0.09570687f, 0.06984253f, -0.17517516f, -0.10838529f, -0.69077289f, 0.61461049f, 0.44026887f, -0.13715938f, 
    0.38988182f, -0.14824355f, -0.04429895f, -0.12462351f, -0.01369565f, 0.27985317f, 0.00260572f, 0.12064999f, 
    0.12694287f, 0.07201590f, 0.07265430f, 0.03637382f, 0.02221702f, -0.06370223f, 0.02264191f, -0.03614620f, 
    -0.46095800f, 0.72511554f, -0.04840202f, -0.21850604f, 0.53163821f, -0.03276233f, -0.06599858f, -0.07040698f, 
    0.16967304f, -0.03298759f, 0.17612541f, 0.16894001f, 0.06455871f, 0.17529272f, -0.01043175f, 0.05121844f, 
    -0.01877991f, 0.07665057f, -0.00038248f, -0.02635390f, -0.29581845f, 0.01489452f, 0.14482258f, -0.06761879f, 
    -0.08547025f, -0.23374335f, -0.10747544f, -0.12895522f, -0.17216408f, 0.04592688f, -0.09189638f, -0.00985815f, 
    0.15559253f, -0.05961356f, 0.04217425f, 0.02178492f, -0.08576049f, -0.08408082f, 0.05475871f, -0.09467419f, 
    0.41275468f, -0.36416468f, -0.02210010f, -0.21185818f, 0.01802614f, 0.04521664f, 0.11321133f, -0.25677830f, 
    0.07842478f, 0.00705286f, -0.07723151f, 0.00685267f, 0.07159751f, -0.01138294f, 0.13998781f, -0.02409914f, 
    0.01936580f, -0.06931929f, 0.02513992f, 0.07067076f, -0.45742822f, -0.42676592f, -0.29986432f, 0.32236055f, 
    0.05197829f, -0.08312195f, 0.07717219f, -0.03496576f, 0.05622957f, 0.16705495f, 0.06346320f, 0.00953301f, 
    -0.03054823f, -0.09326977f, -0.08124355f, 0.01872280f, -0.04639161f, -0.05447862f, 0.07985397f, -0.15604235f, 
    0.05742874f, 0.02064758f, -0.11542508f, 0.04749665f, -0.11044776f, 0.20953843f, 0.05936508f, 0.07612790f, 
    0.01152801f, -0.12484820f, -0.03275384f, -0.04397732f, 0.16644375f, -0.08305434f, 0.01698242f, 0.01272272f, 
    -0.05473382f, -0.04465656f, -0.05770961f, -0.06396753f, 0.25725621f, 0.07183766f, 0.08894319f, -0.33112872f, 
    -0.06865420f, 0.05212865f, 0.06620026f, -0.05495866f, 0.08636896f, -0.02285776f, -0.13377139f, 0.04764255f, 
    0.07004995f, -0.08275411f, -0.17435037f, -0.10964516f, 0.12431896f, 0.08372653f, -0.02203628f, -0.11433571f, 
    -0.90827608f, -1.01557267f, 0.30973780f, 0.69662368f, 0.32050931f, 0.05972399f, 0.08116838f, -0.07333789f, 
    0.01529391f, -0.02201724f, 0.12589000f, 0.06568427f, -0.01333716f, -0.01444941f, 0.04309086f, 0.04356387f, 
    -0.01440247f, -0.11284694f, 0.19337967f, 0.02657164f, 0.36136481f, -0.75085115f, -0.30949631f, 0.48215228f, 
    -0.13641684f, 0.12031250f, 0.08908572f, -0.18939272f, 0.11630076f, 0.04322074f, 0.04338204f, 0.01112730f, 
    -0.12832466f, -0.05542344f, 0.07148305f, -0.13367584f, 0.06759600f, -0.04396014f, 0.10999636f, -0.16699378f, 
    -0.26351523f, -0.32314992f, 0.13673897f, 0.17941163f, 0.07216987f, 0.13338359f, 0.02897681f, 0.03410976f, 
    0.06421786f, 0.11453014f, 0.05793183f, -0.00213107f, 0.02159469f, 0.03448598f, 0.03497003f, 0.03112647f, 
    0.00531310f, -0.10265081f, 0.11747354f, 0.04185408f, -0.11499876f, -0.81586951f, 0.76527601f, -0.54608548f, 
    -0.14724113f, -0.14871339f, 0.21218428f, -0.04848536f, 0.23725790f, -0.02942784f, -0.02857501f, 0.02665800f, 
    0.01522013f, -0.14886907f, -0.01494567f, 0.04693557f, 0.09371321f, -0.06188807f, 0.04105705f, 0.06158528f, 
    0.08159800f, 0.04123046f, -0.22816613f, 0.09489512f, -0.06699368f, 0.04249420f, 0.12415638f, 0.06312726f, 
    -0.08633970f, -0.00821288f, -0.06109075f, 0.02353521f, 0.03717204f, 0.00598993f, -0.16826417f, -0.11924021f, 
    -0.06059589f, 0.03117199f, -0.20356855f, -0.03913022f, 0.66224289f, -0.64950120f, -0.64380133f, -0.50646371f, 
    -0.15666956f, 0.09415629f, -0.01653040f, -0.04893983f, 0.25475982f, 0.06994233f, -0.00225526f, 0.04638958f, 
    -0.00240829f, -0.07327797f, 0.01384512f, 0.04770076f, -0.08510431f, -0.10981178f, 0.09904441f, 0.01213724f, 
    -0.05081087f, 0.14923407f, -0.02990673f, -0.00593853f, -0.22626673f, -0.04095678f, -0.01798235f, -0.08491402f, 
    -0.04908067f, -0.06648413f, 0.05138146f, 0.03413415f, 0.09689140f, 0.00204776f, 0.01075059f, -0.17143592f, 
    -0.31423172f, 0.16434573f, 0.05175776f, -0.04816768f, -0.12508588f, 0.09984341f, -0.06837410f, 0.00344788f, 
    -0.09529805f, -0.07061792f, 0.03241827f, 0.07197136f, -0.10399501f, -0.03000671f, 0.05496178f, 0.04400806f, 
    0.00516923f, -0.02103399f, 0.02059635f, -0.06095662f, -0.18229513f, -0.03956648f, -0.10673913f, 0.11943390f, 
    -0.68886161f, 0.03934779f, -0.65555614f, -0.04306770f, -0.04907416f, 0.26187825f, -0.03495297f, 0.09765291f, 
    -0.03319152f, -0.02080536f, 0.02199388f, -0.01091668f, -0.06017225f, -0.01891725f, -0.02247395f, 0.00390581f, 
    0.21549477f, 0.22719161f, -0.07949426f, 0.06098809f, -0.19170924f, -0.03696645f, 0.21853785f, -0.08730222f, 
    0.11165508f, -0.04569071f, 0.01078433f, 0.02147888f, 0.05492934f, -0.03211673f, -0.12405691f, 0.00694247f, 
    -0.10883655f, 0.05270495f, 0.01215260f, 0.02962142f, -0.00206761f, -0.05543250f, 0.02686542f, -0.01106946f, 
    0.00114211f, 0.11101793f, 0.05224435f, -0.07719646f, -0.14851280f, 0.03258988f, -0.00767123f, 0.03807265f, 
    0.02829815f, -0.11117517f, -0.12873320f, -0.05226925f, -0.21345030f, -0.07517239f, -0.12526295f, 0.05110962f, 
    -0.08254812f, 0.00995310f, -0.04610787f, -0.08860014f, -0.10640724f, 0.06437916f, 0.17122267f, 0.08168969f, 
    0.10640103f, 0.08055665f, -0.04148531f, 0.11111322f, -0.04022808f, -0.01633852f, 0.08126922f, -0.07018845f, 
    0.09680638f, 0.01340259f, -0.14030004f, -0.10553263f, 0.02590449f, -0.16276674f, 0.00602200f, -0.02259331f, 
    -0.04646632f, 0.08664820f, 0.13208665f, -0.10524740f, -0.00641953f, -0.02428887f, -0.02027572f, 0.00453000f, 
    -0.03172850f, -0.04415276f, 0.02033675f, -0.28375256f, -0.18767612f, -0.20046034f, -0.19695437f, 0.00869885f, 
    -0.00054390f, -0.08468346f, 0.05092492f, -0.01075847f, 0.51342136f, -0.21473116f, -0.18143719f, -0.22224779f, 
    -0.19905242f, -0.11407807f, 0.00781880f, -0.08650380f, 0.02219803f, -0.11768907f, 0.03505669f, -0.02197193f, 
    0.14652905f, 0.03395464f, 0.12415922f, -0.01187469f, 0.02158767f, -0.03646706f, 0.05412154f, 0.03324643f, 
    0.42758486f, 0.30575860f, -0.18815987f, -0.01831100f, -0.37576130f, 0.05478134f, 0.04556242f, 0.03101255f, 
    -0.11446984f, -0.05314060f, -0.15942757f, -0.13587169f, -0.00393629f, -0.28575194f, -0.36790970f, 0.07349614f, 
    -0.02534240f, 0.07214858f, 0.03498552f, 0.06328159f, -0.02933113f, 0.17593619f, 0.15068047f, -0.08631010f, 
    0.03891844f, -0.04904541f, 0.04954519f, -0.07547846f, -0.05515458f, -0.05788432f, -0.02619878f, -0.02031850f, 
    -0.12048955f, -0.10441529f, 0.00883186f, -0.11078469f, 0.01799542f, -0.08834770f, -0.01941161f, -0.01948752f, 
    -0.12826091f, -0.05625301f, 0.16956455f, -0.04157015f, 0.11178986f, -0.05382629f, 0.10066430f, -0.14023711f, 
    0.05454389f, -0.17925337f, 0.09448366f, -0.02085185f, -0.03681722f, -0.01383741f, 0.05928399f, 0.00634672f, 
    -0.06680271f, 0.05428655f, 0.01340636f, -0.04296990f, 0.58442718f, -0.07082891f, -0.24378143f, -0.19873098f, 
    -0.11229853f, 0.02016538f, -0.02225255f, -0.03320289f, -0.08055884f, -0.08692022f, 0.03705655f, -0.15187900f, 
    0.07087341f, 0.06744080f, 0.02793519f, -0.00525109f, -0.03749398f, -0.02685452f, 0.08088157f, 0.00686268f, 
    -0.83183235f, -0.79381710f, 0.61880296f, -0.40035829f, 0.28149861f, 0.02166311f, -0.10731535f, 0.09298517f, 
    0.02529225f, 0.03813012f, 0.05400698f, -0.03846727f, 0.01668129f, 0.05751105f, -0.03435956f, 0.14039366f, 
    -0.07491703f, 0.03691593f, -0.28379223f, -0.11473032f, 0.25593230f, -1.01516414f, -0.31920964f, -0.75383836f, 
    -0.20319681f, -0.00159373f, 0.06426983f, -0.09904815f, 0.13224766f, 0.03705594f, -0.00876092f, -0.00745712f, 
    -0.07781865f, -0.16460186f, 0.02863993f, -0.17445610f, -0.11487268f, -0.22784427f, 0.04153145f, 0.05102462f, 
    0.40297088f, -0.49512684f, 0.59646904f, -0.09674978f, 0.07160915f, -0.16756824f, 0.22509465f, -0.08096178f, 
    0.22680552f, 0.15065816f, 0.05333475f, 0.02549833f, 0.04024389f, -0.03652294f, 0.04673880f, 0.01790619f, 
    -0.01010334f, -0.02790345f, 0.06823100f, -0.05589196f, -0.05313544f, 0.12306479f, 0.05575022f, 0.00040228f, 
    -0.23530357f, 0.02167089f, 0.06248547f, 0.03137862f, 0.00810705f, -0.03802056f, 0.03944476f, 0.02531074f, 
    0.06913327f, -0.00333370f, 0.01908293f, 0.00818634f, -0.10060137f, -0.21535851f, 0.14705060f, 0.01012895f, 
    -0.35753241f, -0.24874184f, -0.24891171f, 0.43791968f, -0.09533440f, -0.03408465f, 0.02376096f, 0.15828528f, 
    -0.07436597f, 0.17569841f, 0.05721950f, -0.07378662f, -0.05397079f, -0.07365181f, -0.05492556f, -0.04706160f, 
    0.14416969f, -0.05487967f, 0.09381145f, -0.00236731f, 0.54324067f, -0.58338535f, 0.06574629f, -0.18630098f, 
    -0.14180040f, -0.07669327f, 0.22932474f, -0.05682513f, 0.01766486f, 0.09646820f, -0.00650236f, -0.03988944f, 
    0.09080684f, 0.04441446f, 0.07601268f, -0.01573720f, 0.02571048f, -0.14389755f, 0.05779282f, -0.02492329f, 
    -0.22341791f, -0.01903736f, 0.20673551f, -0.10288721f, 0.14814056f, 0.02981919f, -0.03621708f, 0.04071145f, 
    -0.04372127f, 0.02575801f, -0.03154245f, 0.00269088f, 0.05897799f, 0.12384497f, -0.11250230f, -0.01960843f, 
    0.05438638f, -0.14561599f, 0.02825668f, -0.03884559f, 0.33373582f, -0.42530280f, -0.27506644f, -0.15919386f, 
    -0.18947636f, -0.08427792f, -0.10505031f, -0.00374115f, 0.09221696f, -0.11014677f, -0.07544266f, 0.11022374f, 
    0.03660488f, 0.09652629f, 0.12917353f, 0.01232136f, 0.04445573f, -0.01292209f, 0.06451652f, 0.05106902f, 
    -0.36739126f, -0.52682990f, -0.20481652f, -0.03205954f, 0.02947694f, 0.11096818f, 0.13723293f, 0.15484156f, 
    0.08639660f, 0.03100719f, -0.16103140f, 0.15499987f, 0.00507640f, 0.14570767f, -0.04339068f, -0.04309398f, 
    0.01952070f, -0.00845965f, 0.05491568f, 0.08615129f, 0.33929247f, 0.00212628f, -0.16110122f, 0.05426314f, 
    -0.09548932f, 0.18812454f, 0.03089863f, 0.06105306f, -0.07054821f, 0.04395149f, -0.00315472f, -0.00624031f, 
    0.19713798f, 0.06067742f, 0.02844915f, 0.06465644f, 0.03946066f, 0.02974650f, 0.05858722f, -0.10607714f, 
    0.23560679f, -0.18875980f, -0.41327715f, 0.20715687f, -0.05725397f, -0.17857336f, 0.01052257f, 0.19462980f, 
    0.13878737f, 0.17385460f, 0.15909588f, -0.18117350f, -0.14136386f, -0.09995568f, -0.02767012f, 0.00278614f, 
    -0.05637144f, 0.01232752f, 0.00184195f, -0.02920705f, -0.03431616f, -0.62549514f, 0.00375726f, -0.05421273f, 
    -0.06922156f, 0.07699561f, -0.03978069f, 0.02729174f, 0.06657669f, -0.35687864f, -0.04306940f, -0.01717774f, 
    0.00830121f, 0.01507787f, 0.01784309f, 0.02660400f, 0.09258687f, 0.13248654f, 0.09428112f, -0.02152571f, 
    0.05715677f, 0.04732823f, -0.10075086f, -0.03059481f, -0.18724769f, -0.04641147f, 0.04100113f, -0.14783537f, 
    -0.04736546f, -0.15176736f, 0.06252363f, 0.02643803f, 0.09820409f, -0.03785903f, 0.06670119f, -0.14948384f, 
    0.14615305f, 0.05393314f, 0.22992465f, 0.04590048f, 0.18402618f, 0.04799785f, -0.15142058f, -0.06094425f, 
    -0.05489865f, -0.03904708f, -0.15609927f, -0.01627257f, 0.11880320f, -0.17750353f, 0.09976075f, 0.10931920f, 
    0.09905696f, 0.20132892f, -0.04765662f, -0.16675366f, -0.05934490f, -0.16291057f, -0.10665824f, 0.07671333f, 
    0.92385066f, -0.47995132f, -0.24931198f, -0.20499095f, -0.30420673f, -0.06310654f, -0.20589902f, -0.14592890f, 
    -0.01322517f, -0.08272387f, -0.04841802f, 0.08642773f, 0.03246316f, -0.03275822f, 0.02426780f, 0.03361454f, 
    0.10238171f, 0.07996878f, 0.13199611f, 0.15664275f, 0.13476489f, -0.14227036f, -0.48048714f, -0.18173887f, 
    0.04968895f, 0.10550039f, -0.01241143f, 0.09220027f, 0.18256758f, -0.02907229f, 0.00898054f, -0.02149984f, 
    0.03688961f, 0.14791910f, -0.01064692f, 0.10687650f, -0.00754591f, 0.00661657f, -0.08145278f, -0.18150638f, 
    0.33088219f, -0.10739210f, 0.00635503f, 0.07140823f, -0.17368680f, 0.02684053f, -0.21193120f, -0.31139696f, 
    -0.19227920f, -0.11448150f, 0.08591104f, 0.10003066f, 0.12428118f, -0.07354773f, 0.04272356f, -0.06111724f, 
    0.07019257f, 0.18948680f, 0.22846898f, 0.26720190f, 0.27575588f, -0.22247235f, -0.82651442f, -0.38205823f, 
    0.12350778f, 0.05283256f, -0.14829405f, 0.23478974f, -0.11238974f, -0.15510868f, 0.01116563f, -0.01167543f, 
    -0.07642286f, -0.00965869f, 0.02672726f, 0.10068647f, 0.07448970f, 0.10269028f, -0.08052602f, -0.21218997f, 
    0.15244149f, 0.07301798f, 0.09178133f, 0.03106736f, -0.33788267f, 0.01582623f, 0.06096404f, -0.04226710f, 
    -0.06814613f, -0.02999720f, -0.09377821f, -0.01089458f, -0.09979165f, 0.14228584f, -0.12465275f, 0.04183830f, 
    0.05155257f, 0.00027802f, -0.04040028f, -0.21655203f, -0.27369624f, -0.16331406f, -0.98867625f, -0.73745829f, 
    -0.12829824f, 0.11829026f, 0.05874913f, 0.05272240f, 0.14804041f, -0.00303297f, 0.00091635f, -0.02677037f, 
    -0.06325870f, 0.04808437f, 0.06088281f, 0.08683683f, -0.02077775f, 0.04786968f, -0.01541941f, 0.07511239f, 
    -0.26017648f, 0.23143058f, 0.22244538f, 0.06456391f, -0.23598576f, -0.07550543f, -0.09020853f, -0.05199884f, 
    0.00828613f, -0.15483758f, -0.06962322f, -0.00705980f, -0.06165544f, -0.04119990f, -0.01673682f, 0.03237484f, 
    0.10812816f, -0.00265649f, 0.04689896f, -0.02846856f, -0.64293295f, 0.03456877f, 0.19442737f, 0.08041970f, 
    0.10164407f, -0.05403044f, 0.08651758f, -0.10606485f, -0.07473574f, -0.04096904f, -0.08348020f, -0.03327301f, 
    0.08172125f, -0.04273855f, -0.05847355f, -0.01441764f, 0.01338381f, -0.02483491f, 0.02402034f, -0.08856913f, 
    0.27882949f, -0.66695482f, -0.55505282f, 0.10542808f, 0.37107977f, 0.04114017f, 0.30784184f, -0.00235329f, 
    0.31713116f, 0.03775933f, 0.03880916f, -0.07464276f, 0.01667400f, 0.01327261f, 0.14616168f, 0.10450672f, 
    -0.23970202f, -0.13962698f, -0.20027497f, -0.39606413f, -0.05486482f, -0.16732955f, -0.01697611f, 0.16454810f, 
    -0.00243179f, 0.03716489f, -0.02074918f, -0.07602418f, -0.15959263f, 0.05449805f, 0.08728509f, 0.10267564f, 
    0.00886348f, 0.13649955f, -0.03367502f, 0.05979506f, 0.13937481f, 0.02455389f, 0.06936786f, 0.21596268f, 
    0.05300859f, 0.00812583f, -0.00855485f, -0.11798969f, -0.03173464f, -0.05433340f, 0.03213218f, -0.06152526f, 
    0.04418537f, -0.03478389f, -0.01773499f, 0.08234018f, 0.12084106f, 0.03157700f, 0.12933426f, -0.02793370f, 
    0.06214495f, 0.02393320f, 0.14264087f, 0.09175675f, -0.66663486f, -0.18761733f, 0.26484236f, 0.11058312f, 
    0.00541808f, -0.11974877f, -0.08916043f, -0.07801069f, -0.05314724f, 0.00175546f, -0.07433195f, 0.04096196f, 
    0.11179622f, 0.13294908f, 0.04753210f, 0.01037670f, -0.03110054f, -0.01639261f, -0.06335279f, 0.09959724f, 
    -0.25268692f, -0.08762931f, 0.07277250f, -0.02771997f, -0.03352930f, 0.01085618f, -0.02018224f, -0.02345552f, 
    -0.00173805f, 0.01706313f, 0.08319952f, 0.07592564f, 0.08544660f, 0.11040843f, 0.19769037f, -0.01681793f, 
    0.11362023f, 0.11350572f, 0.09105747f, 0.11460351f, 0.03240128f, -0.40162274f, -0.67875558f, -0.16546312f, 
    -0.07644728f, -0.05193366f, 0.03053699f, 0.18079813f, 0.11732981f, 0.30941468f, 0.17028949f, -0.08297811f, 
    -0.01656459f, -0.09031466f, -0.18068837f, -0.08165532f, 0.06332330f, 0.03431050f, 0.04845405f, -0.03865609f, 
    0.13014469f, -0.23508686f, 0.11465217f, -0.22151121f, -0.17670731f, -0.21838531f, 0.24996839f, 0.02334872f, 
    0.08792365f, -0.25864241f, 0.02432315f, 0.18145378f, 0.03488868f, -0.06669912f, -0.03380341f, -0.06168701f, 
    -0.10991120f, -0.16344382f, 0.06890532f, -0.04300910f, -0.00584668f, -0.05816853f, 0.00378530f, 0.06644836f, 
    -0.12731600f, -0.08809263f, -0.01414430f, 0.03823246f, -0.00717588f, 0.06191678f, 0.02261864f, -0.01961248f, 
    0.07152174f, 0.07203352f, 0.16701409f, 0.09129752f, 0.10841027f, 0.02864363f, -0.00200592f, 0.13711698f, 
    0.61803836f, -0.20228866f, 0.00905153f, -0.01782769f, -0.18781847f, 0.01419568f, -0.21274063f, -0.29845574f, 
    -0.13366961f, 0.01414146f, 0.11364354f, 0.09953763f, -0.01827942f, 0.02154567f, 0.17892261f, -0.00832146f, 
    0.20423469f, -0.09666480f, 0.09842995f, 0.08680033f, 0.13900436f, -0.41132340f, -0.33271810f, -0.26071092f, 
    -0.04399626f, 0.02745056f, 0.04874182f, 0.15075237f, 0.08198771f, 0.20605931f, 0.08799163f, 0.05887880f, 
    -0.13948885f, -0.11558495f, -0.06452627f, 0.05072133f, 0.08781131f, 0.03954109f, -0.02410614f, 0.05312716f, 
    0.33378237f, -0.35882342f, -0.02249729f, 0.27258557f, 0.15501167f, 0.18495157f, -0.00170271f, 0.08328092f, 
    -0.11179972f, 0.10952538f, 0.07030107f, 0.01044491f, 0.18340710f, -0.01479750f, -0.03373165f, 0.05744855f, 
    -0.03508648f, 0.09187256f, -0.25582796f, -0.06668284f, 0.23427540f, 0.27204382f, -0.37331650f, -0.03123243f, 
    0.15126605f, 0.20726165f, 0.20778795f, -0.01138676f, 0.19691224f, 0.01852191f, 0.01340846f, -0.07094342f, 
    -0.02210813f, 0.09608272f, 0.08838455f, 0.19942960f, 0.10756532f, 0.08170507f, -0.11401016f, -0.21749145f, 
    -0.17186698f, -0.55192643f, -0.76828498f, -0.22990726f, 0.03034846f, 0.08635672f, -0.26438442f, 0.08346853f, 
    -0.05476676f, -0.03807294f, -0.06425414f, -0.02639954f, -0.06416515f, 0.00521338f, 0.02905312f, 0.02156329f, 
    0.04907220f, 0.02107646f, -0.03746164f, 0.04429649f, -0.62700897f, 0.27822149f, 0.26796314f, 0.05529323f, 
    -0.25203755f, -0.09912269f, -0.06652337f, -0.12049689f, -0.09798340f, -0.13444121f, -0.12971659f, -0.10671758f, 
    -0.01451548f, -0.10958548f, -0.06778382f, 0.02941459f, 0.06328570f, -0.12475146f, -0.03173130f, -0.04261828f, 
    -0.04905949f, -0.30148840f, 0.23228973f, -0.21796769f, -0.27314588f, 0.03486540f, -0.18991514f, 0.01264379f, 
    -0.23242487f, -0.58345854f, 0.01970849f, -0.00474007f, 0.02173567f, 0.05608328f, 0.06568317f, 0.10311760f, 
    0.04056270f, -0.01066943f, -0.16440913f, -0.51024038f, -0.10042401f, -0.27634037f, -0.39777568f, -0.03367665f, 
    0.10859459f, -0.13686010f, -0.00096563f, 0.20699911f, 0.13781954f, 0.24846609f, -0.03304708f, -0.16810864f, 
    -0.14654756f, -0.11110147f, -0.10450644f, -0.14861085f, 0.09987541f, 0.15335034f, -0.03273161f, 0.05656570f, 
    -0.39359352f, -0.22398801f, 0.10898542f, 0.16267796f, 0.04037758f, 0.01652021f, -0.01456103f, -0.00344427f, 
    -0.03847472f, 0.13425380f, 0.05980295f, 0.03838886f, -0.07004169f, 0.17932284f, 0.02517663f, -0.06549227f, 
    0.05917813f, 0.10144636f, 0.01321256f, 0.17599291f, -0.01594983f, -0.69234341f, -0.41720974f, -0.15522914f, 
    0.01331414f, -0.21879640f, 0.07638196f, 0.15597977f, 0.21405759f, 0.14624566f, 0.11730772f, -0.10281380f, 
    -0.12797856f, -0.06916852f, -0.08454125f, -0.01977109f, 0.00621225f, 0.04678097f, 0.03188254f, -0.09422999f, 
    -0.42892605f, -0.98578584f, -0.20895079f, 0.09639633f, 0.29011011f, 0.11936098f, 0.06825966f, 0.14990924f, 
    -0.10884254f, -0.07687730f, 0.17079377f, 0.14228547f, -0.02426747f, 0.25532198f, -0.00784905f, -0.04452872f, 
    -0.04961541f, -0.03412220f, -0.01826499f, -0.08402157f, -0.04597874f, -0.19430104f, -0.20891161f, -0.11968978f, 
    -0.05699679f, -0.10740838f, -0.00547896f, 0.01930665f, 0.03450079f, 0.02338840f, 0.08643629f, -0.00263507f, 
    0.08927888f, -0.05405890f, -0.05406694f, -0.01840236f, 0.03680852f, 0.00138189f, 0.13809510f, -0.00426417f, 
    -0.01242173f, -0.00726251f, -0.17779152f, 0.38643071f, -0.22086272f, -0.32579571f, 0.26173666f, -0.37716198f, 
    0.03005102f, -0.20828316f, 0.07052902f, -0.08938015f, 0.11260925f, 0.13943513f, 0.00322279f, 0.02122298f, 
    0.13329950f, 0.03541616f, -0.11867303f, -0.05512632f, -0.03578721f, 0.06808112f, -0.17747375f, 0.02882083f, 
    -0.12776572f, 0.06783579f, -0.26097351f, 0.20554282f, 0.10908908f, 0.30336201f, -0.03428825f, 0.14221202f, 
    0.01296490f, -0.09843574f, -0.13041411f, 0.01460043f, -0.00343848f, 0.03882438f, 0.06471323f, 0.04459372f, 
    -0.31206402f, 0.00907774f, -0.07740869f, 0.08972733f, 0.14470491f, 0.03566104f, 0.18002631f, -0.29637849f, 
    -0.04136044f, -0.12545365f, 0.07636248f, -0.04174074f, -0.17808963f, -0.05418654f, -0.03503203f, 0.19002871f, 
    -0.10952280f, -0.15065904f, -0.12684654f, -0.17183976f, -0.59722197f, -0.17755996f, -0.11772893f, 0.04313492f, 
    0.12594685f, -0.22042795f, 0.16971074f, -0.09422735f, -0.06698654f, 0.06010998f, 0.06387345f, -0.16687375f, 
    0.10066814f, 0.09283575f, -0.24586636f, 0.12482781f, 0.14175288f, -0.00928756f, -0.09576905f, 0.20154117f, 
    0.17066506f, -0.26193160f, -0.51744288f, 0.36653569f, -0.50359434f, -0.18745600f, 0.02492186f, 0.08321526f, 
    0.05232133f, 0.08027291f, -0.03750042f, -0.07521845f, -0.05084164f, -0.09409746f, -0.00596198f, 0.07809156f, 
    -0.05810680f, -0.06615739f, 0.06214587f, -0.19549385f, -0.31634980f, -0.01579441f, 0.21515094f, 0.28781226f, 
    -0.47188523f, 0.07788432f, -0.36157557f, -0.03790703f, -0.09994184f, 0.07002993f, 0.08133972f, 0.08439299f, 
    0.10767481f, 0.09418380f, 0.05671336f, -0.08315524f, 0.07919457f, 0.03629526f, 0.19285382f, 0.22616090f, 
    0.25685996f, 0.06884001f, 0.23623534f, 0.09282617f, -0.16984589f, 0.10307910f, 0.03553524f, 0.11766795f, 
    0.04619014f, 0.05027553f, 0.03373712f, -0.08908068f, -0.09915240f, -0.11059754f, -0.03923562f, 0.08419786f, 
    -0.13011882f, -0.15563777f, -0.04206622f, -0.08276208f, 0.34597877f, -0.37813967f, -0.49344626f, -0.12496150f, 
    -0.32110435f, -0.35141230f, 0.19965674f, -0.12370635f, 0.05362862f, 0.27160668f, 0.09941785f, -0.00205554f, 
    0.06311416f, -0.05403829f, -0.04313237f, -0.08108825f, -0.00113639f, 0.07564504f, -0.01729901f, -0.12091911f, 
    -0.19902861f, 0.11896168f, -0.26963690f, 0.15013562f, 0.03506907f, 0.14436486f, -0.10171951f, -0.03348895f, 
    -0.01968409f, -0.13377787f, 0.11449280f, 0.09169389f, -0.01503178f, 0.00254779f, -0.06462868f, -0.14275293f, 
    0.13566530f, -0.02921399f, -0.05016408f, 0.02323510f, -0.69452542f, 0.01182093f, -0.10510270f, 0.41926867f, 
    -0.65778631f, 0.09282100f, -0.02791209f, -0.04358228f, 0.04896261f, 0.11391858f, 0.07655035f, -0.03506687f, 
    0.07046957f, 0.07063264f, 0.05550650f, -0.00905856f, 0.00641065f, 0.06257568f, 0.02533596f, -0.02065983f, 
    -0.24031787f, 0.15096048f, -0.66825467f, 0.07368197f, -0.01420411f, 0.08271062f, 0.13893086f, 0.38048881f, 
    -0.00501997f, 0.11000300f, 0.08618649f, 0.00010193f, 0.05168542f, 0.02904606f, -0.03671230f, 0.11959466f, 
    0.07202087f, 0.06420122f, 0.01929105f, 0.09052126f, -0.29848203f, -0.06487241f, -0.17169994f, -0.20585015f, 
    0.02494448f, 0.01234678f, -0.02171372f, 0.14733423f, 0.00374702f, -0.04583774f, 0.01347734f, 0.03838049f, 
    -0.00047389f, -0.03588771f, 0.05635180f, 0.07981150f, 0.10529581f, 0.02744221f, 0.02675167f, 0.10563148f, 
    0.05956756f, -0.33459178f, -0.29209802f, 0.30081677f, -0.40284735f, 0.21589167f, -0.43032828f, -0.06116357f, 
    0.01231585f, -0.02919141f, -0.01411053f, 0.01238324f, -0.03585031f, 0.09663961f, 0.16954473f, -0.02064163f, 
    -0.05759609f, 0.20741129f, 0.03873422f, 0.28311801f, 0.04439045f, 0.06915868f, 0.50228995f, -0.37971696f, 
    -0.12435313f, -0.00189120f, -0.05608889f, -0.04945897f, 0.04210923f, -0.00730436f, 0.03188999f, 0.04505954f, 
    0.01998889f, 0.08750075f, -0.01011684f, -0.07401519f, 0.00873473f, -0.11793004f, -0.16521586f, -0.00172947f, 
    -0.04059242f, 0.00799011f, -0.05789538f, 0.13202652f, 0.09412140f, -0.06369419f, 0.09419035f, -0.00029136f, 
    -0.04322217f, -0.12418698f, 0.04018367f, -0.03834903f, 0.00357730f, -0.10501219f, 0.05003559f, 0.05839878f, 
    -0.02505909f, -0.04137810f, 0.00233148f, 0.03095686f, 0.10970773f, -0.33729830f, 0.13277526f, -0.45537731f, 
    0.08951188f, -0.04422299f, -0.15625690f, 0.11514188f, 0.09440459f, 0.06968505f, -0.03232388f, 0.08749381f, 
    0.03870469f, -0.02997941f, -0.07960388f, 0.12339371f, 0.15759489f, 0.12086735f, -0.04556557f, 0.04139005f, 
    0.14200541f, -0.10737324f, 0.26320362f, -0.22450021f, 0.09038831f, -0.03512970f, -0.00412610f, 0.02027230f, 
    0.05783600f, -0.05832908f, 0.10382859f, 0.08090146f, 0.10029244f, 0.02121364f, 0.06730592f, 0.26466265f, 
    0.01237651f, 0.00179723f, -0.02933504f, -0.03092830f, 0.07763457f, 0.11937352f, 0.20046036f, 0.23785436f, 
    -0.12117936f, 0.03706933f, -0.06355852f, -0.45312396f, -0.17942764f, -0.30380604f, 0.08192786f, 0.00054073f, 
    0.06042287f, 0.12242257f, 0.07623134f, 0.05305383f, -0.00538384f, 0.04619369f, 0.00361903f, -0.04358029f, 
    -0.37529951f, 0.12823972f, 0.00118647f, 0.05340257f, 0.02972085f, 0.10188737f, 0.06400665f, -0.11911766f, 
    -0.29173535f, -0.14386655f, 0.08588399f, -0.13813747f, 0.03639662f, -0.08394355f, -0.12111504f, 0.16670673f, 
    0.22806567f, -0.16189195f, -0.08010957f, 0.08257987f, 0.10153616f, -0.31063017f, 0.02016624f, -0.06437845f, 
    0.08641510f, -0.10265338f, 0.16482934f, -0.11251669f, -0.11440996f, -0.06656949f, 0.01240972f, 0.02443359f, 
    -0.06482657f, 0.00402932f, -0.02812227f, -0.03985329f, 0.07019328f, -0.03900297f, -0.18215172f, 0.01098435f, 
    -0.01806865f, -0.47388938f, -0.16065419f, 0.08477601f, -0.14167292f, 0.16264552f, 0.18388957f, -0.17631809f, 
    -0.25745234f, -0.19375911f, 0.04600455f, 0.02801507f, -0.14725801f, -0.04425794f, -0.02762226f, 0.04936218f, 
    -0.07492740f, -0.18468314f, -0.37048203f, 0.04489558f, 0.07833761f, 0.13386309f, 0.35812521f, 0.24397768f, 
    -0.21263675f, 0.01632085f, 0.00477809f, -0.38422519f, -0.25665399f, -0.19679801f, 0.14035580f, -0.03326727f, 
    0.22974174f, 0.06882432f, 0.05239738f, 0.02880683f, -0.11607167f, -0.07681453f, -0.03141934f, -0.15646707f, 
    0.13612792f, -0.11140873f, -0.20958126f, -0.13961223f, -0.17130239f, 0.17042147f, -0.21997346f, 0.11666196f, 
    -0.04318716f, -0.01259726f, -0.03770965f, -0.01480186f, -0.03505795f, -0.06724115f, 0.08754994f, 0.04439561f, 
    -0.01102558f, 0.04741294f, -0.04830774f, -0.09292559f, -0.31856403f, 0.14404491f, -0.17203780f, 0.28323355f, 
    -0.20608072f, -0.00303824f, 0.20237902f, -0.35759720f, 0.14982314f, -0.05338348f, 0.10044873f, -0.12356930f, 
    0.06261738f, 0.02025602f, 0.07474795f, 0.12204053f, 0.18317227f, 0.00053933f, 0.13898998f, 0.18443878f, 
    -0.43466273f, -0.47663617f, 0.07079030f, 0.04471816f, -0.12918362f, -0.17028010f, -0.15887989f, 0.20319739f, 
    0.13557060f, 0.22563502f, 0.04015183f, -0.00452254f, 0.02471730f, -0.01596422f, -0.02410043f, 0.01875887f, 
    0.07748982f, 0.04648418f, -0.02123903f, -0.18062264f, -0.32573575f, -0.15825613f, -0.66267163f, -0.24560227f, 
    0.28489113f, -0.06045265f, 0.18921371f, 0.31975111f, 0.06688484f, -0.02876422f, 0.00960141f, -0.06015033f, 
    0.03336657f, 0.02580143f, -0.07628962f, 0.15537582f, 0.12992224f, -0.02774778f, 0.08177650f, 0.08377988f, 
    -0.28461945f, -0.35025173f, -0.51271975f, -0.02857335f, 0.04460026f, 0.05869937f, -0.08683784f, -0.09543274f, 
    -0.26145211f, 0.23305653f, 0.00257034f, 0.06337395f, 0.07988371f, 0.08201299f, -0.07451122f, 0.01231123f, 
    0.02168629f, 0.18179107f, 0.07213813f, 0.26628917f, -0.08536125f, -0.45498678f, 0.24529046f, -0.41008139f, 
    -0.06007109f, 0.00165698f, -0.02652669f, -0.26258838f, -0.06706190f, 0.05711725f, -0.06805088f, 0.18441601f, 
    -0.02873412f, 0.02339394f, -0.00197333f, 0.03208813f, -0.01561177f, -0.06501023f, -0.07345083f, -0.01584950f, 
    0.17440119f, -0.20809419f, 0.39237103f, -0.55202657f, -0.00804813f, -0.09622630f, -0.14675048f, -0.15335308f, 
    0.21962154f, 0.12647653f, -0.14988787f, 0.13590081f, 0.06309003f, -0.00459446f, 0.09074374f, -0.00314664f, 
    0.13331313f, -0.09679404f, -0.12694745f, 0.01872656f, 0.24715714f, 0.06619544f, 0.48376116f, 0.63123089f, 
    -0.60877323f, 0.17658472f, -0.10834152f, -0.46004695f, 0.05504770f, -0.30258691f, 0.09476560f, 0.04187236f, 
    0.11822343f, 0.16916478f, 0.03962103f, 0.10365564f, 0.00309840f, -0.07400013f, 0.01761272f, 0.06908315f, 
    0.10533468f, -0.12568408f, 0.22305007f, -0.26925945f, -0.46983010f, -0.08618989f, -0.37718213f, -0.20474218f, 
    0.06185960f, -0.28732634f, -0.20392530f, 0.07275953f, -0.04149157f, 0.12955442f, -0.11561406f, 0.08373860f, 
    -0.00592456f, 0.02611078f, -0.08753287f, 0.07082106f, -0.30809459f, 0.07387199f, 0.30125087f, 0.42914772f, 
    -0.07623009f, 0.12106752f, -0.21186371f, -0.04409058f, -0.19780523f, -0.16643722f, 0.14856981f, -0.00884091f, 
    0.08276124f, 0.00725758f, 0.03949464f, -0.01791637f, -0.19507265f, -0.11835219f, 0.08309734f, -0.07059970f, 
    0.02629615f, 0.21729963f, 0.00847066f, 0.01490767f, 0.00330455f, 0.21812154f, -0.05639564f, -0.10502697f, 
    0.11716549f, 0.01969996f, -0.16077626f, 0.12513985f, -0.07570857f, 0.00273461f, 0.02696842f, -0.04926026f, 
    0.04942261f, -0.14466442f, 0.01238105f, -0.10323364f, -0.25702238f, -0.06001969f, -0.33516392f, -0.00559423f, 
    0.02014600f, -0.04849003f, -0.06949696f, 0.01956640f, -0.19787152f, -0.21032031f, -0.01128848f, 0.15410151f, 
    0.06642972f, 0.07082456f, -0.05576840f, 0.08309595f, -0.04888545f, -0.13738872f, -0.18162942f, -0.17407776f, 
    -0.02980758f, -0.15201561f, 0.27722010f, -0.21300046f, 0.00503509f, -0.05576728f, -0.05533000f, 0.21230918f, 
    0.03394100f, -0.00839215f, 0.03941213f, 0.16142501f, 0.10840202f, 0.09662575f, 0.00858323f, 0.05149350f, 
    0.10309725f, 0.19732147f, 0.07617990f, 0.11501580f, 0.47139555f, 0.03853306f, 0.13674073f, 0.31941453f, 
    0.02745869f, 0.03017976f, -0.01435293f, 0.11399223f, -0.23834142f, -0.06784697f, -0.01249425f, -0.03950215f, 
    -0.01712867f, -0.07622236f, 0.21108179f, 0.03522948f, -0.24409010f, -0.16088493f, 0.07457410f, -0.12528199f, 
    -0.78022325f, -0.03309540f, 0.07332469f, -0.07226744f, 0.11726019f, -0.02320599f, -0.13168275f, 0.14118594f, 
    -0.04646309f, 0.12243193f, -0.05763575f, 0.15428026f, 0.02883090f, 0.15303102f, 0.03288397f, 0.05189725f, 
    0.00907640f, -0.03397457f, 0.06226319f, 0.05396052f, -0.25579491f, 0.05644771f, 0.10101981f, -0.07787593f, 
    0.12442724f, 0.00900896f, -0.01369828f, -0.13591924f, -0.02196580f, 0.15668678f, -0.11658662f, 0.06386944f, 
    -0.14648718f, 0.06575730f, 0.06597399f, 0.15092072f, -0.17040579f, -0.06954823f, -0.16739474f, -0.05347106f, 
    -0.55176765f, -0.08560826f, -0.33070269f, 0.02486017f, -0.03583331f, 0.02862471f, -0.02888672f, 0.07275760f, 
    0.15165868f, 0.03756259f, -0.07614379f, -0.06431677f, -0.00206171f, 0.01940590f, -0.04180789f, 0.05813057f, 
    0.05860656f, 0.01948269f, 0.33168545f, 0.40825564f, -0.31460950f, -0.00430588f, -0.54551417f, 0.11255421f, 
    0.25254276f, -0.16641247f, 0.02545719f, 0.17357428f, -0.18105827f, 0.15820207f, -0.02112104f, 0.06203170f, 
    -0.03230428f, -0.04968414f, -0.00598851f, 0.06178561f, 0.05708414f, -0.36617553f, 0.00074291f, -0.14781843f, 
    -0.27429506f, -0.34566686f, 0.31463811f, -0.12423324f, -0.13833642f, -0.24208228f, -0.15354121f, -0.05159757f, 
    0.29318047f, -0.13814963f, 0.00503881f, -0.00163892f, -0.02140617f, 0.04104147f, 0.13836320f, 0.07577082f, 
    0.00246172f, 0.05015065f, 0.34476683f, -0.01666521f, -0.17913754f, 0.17697705f, 0.07566012f, -0.02333213f, 
    0.16223624f, -0.11372782f, -0.21950464f, -0.05434427f, -0.03828286f, 0.11880959f, -0.12212850f, 0.12426139f, 
    0.05278873f, -0.01421496f, 0.10931897f, 0.04141891f, -0.01647731f, -0.10689245f, -0.01162278f, -0.08085981f, 
    -0.10038906f, -0.49155641f, -0.20320983f, -0.22984904f, -0.04171049f, -0.32721856f, -0.27836633f, 0.08496502f, 
    -0.07660313f, -0.17706460f, -0.14319003f, 0.09696556f, -0.07956359f, -0.06251165f, -0.03986241f, 0.11805440f, 
    -0.09915205f, 0.05092094f, -0.01501653f, -0.08854380f, -0.04827126f, -0.07051582f, 0.06361461f, -0.00054451f, 
    0.00465892f, -0.01846305f, -0.04442625f, 0.03427237f, -0.07271366f, -0.10970706f, -0.00448630f, 0.05811214f, 
    0.09792931f, 0.12184177f, 0.04650663f, -0.01629063f, -0.00386008f, 0.01763367f, -0.14488667f, -0.04424147f, 
    -0.17686230f, -0.25286075f, -0.13023348f, -0.15801276f, -0.11245475f, -0.18272965f, 0.20592262f, -0.02134027f, 
    -0.10041923f, -0.13396746f, 0.04569273f, 0.07126710f, -0.13996218f, 0.13732767f, 0.01653294f, 0.03343610f, 
    -0.17093392f, 0.07505997f, -0.27916992f, -0.13084112f, -0.20521577f, 0.13944317f, 0.03111419f, 0.23640938f, 
    -0.01234847f, -0.01841288f, 0.10034662f, -0.12002213f, 0.21557659f, 0.07051823f, -0.15976031f, -0.17656499f, 
    0.11014226f, 0.01183216f, 0.04632248f, 0.02982429f, 0.02203855f, -0.03011361f, 0.23081584f, 0.15474872f, 
    0.07247303f, -0.20595208f, 0.12374165f, 0.15240076f, -0.00914823f, -0.16712464f, -0.06553587f, 0.10682341f, 
    -0.05868286f, 0.03809333f, -0.08254702f, 0.03689691f, -0.26154116f, 0.23851639f, -0.03348184f, -0.05399477f, 
    -0.05887520f, 0.11987101f, -0.06182615f, 0.18854198f, -0.13629135f, -0.07033851f, -0.37066627f, 0.32032242f, 
    -0.10402527f, -0.00306988f, -0.08824241f, -0.07043760f, -0.02765545f, 0.05078531f, -0.02309396f, 0.11363100f, 
    -0.10122224f, 0.13503484f, -0.10227735f, -0.09749769f, 0.17340328f, 0.05728314f, 0.00821975f, -0.00908595f, 
    -0.02904632f, -0.15072595f, -0.35099247f, 0.22626117f, -0.11739916f, -0.18084484f, -0.02558908f, -0.15336798f, 
    -0.00701276f, 0.04236747f, -0.15161732f, -0.01831668f, 0.02431744f, 0.06084000f, 0.08779570f, -0.02659138f, 
    -0.03475827f, 0.05269248f, 0.11605028f, 0.10854141f, 0.17282851f, 0.15945822f, -0.25181517f, 0.05991288f, 
    -0.00103124f, 0.03896038f, 0.05118695f, -0.12971570f, -0.02380139f, 0.05257959f, -0.10617402f, 0.16727917f, 
    -0.04848783f, -0.16481186f, -0.10073691f, 0.03308743f, 0.02385984f, -0.11760354f, 0.12462050f, 0.03227876f, 
    0.58731526f, -0.71603483f, 0.60462248f, 0.16805011f, -0.23610295f, 0.01951203f, -0.11808172f, 0.16125983f, 
    0.24426834f, -0.14655352f, -0.02043247f, 0.00559267f, -0.11429193f, -0.03880052f, -0.25908652f, -0.22549880f, 
    0.01790338f, 0.14384837f, -0.14671136f, -0.14084418f, -0.10974544f, 0.15049329f, 0.28781646f, -0.00388000f, 
    -0.14405879f, 0.00714047f, 0.08571244f, -0.06587312f, 0.08748864f, 0.03343683f, -0.09400159f, 0.07763182f, 
    -0.03974479f, 0.07103100f, 0.09320731f, -0.13541938f, 0.22517747f, -0.01637766f, 0.04666929f, 0.18515673f, 
    -0.81533813f, -0.04974335f, -0.04411215f, 0.20902894f, -0.00798207f, -0.03621879f, -0.07685171f, 0.23695809f, 
    0.32984248f, 0.14499062f, -0.08046135f, 0.00446402f, 0.00926203f, -0.06435410f, -0.01248558f, -0.21146949f, 
    0.10550633f, 0.14768575f, 0.25301638f, 0.31287614f, 0.35709685f, -0.23464593f, 0.05815626f, 0.12407034f, 
    0.06387482f, 0.10642678f, 0.09802077f, 0.19986691f, 0.05637297f, -0.00861426f, -0.15253125f, 0.08317269f, 
    -0.03267962f, -0.06312133f, -0.03645427f, 0.00496009f, 0.03954936f, 0.11491463f, 0.15699767f, 0.15236387f, 
    -0.27811182f, 0.20626765f, -0.51592684f, 0.14762223f, -0.06023580f, 0.13165005f, -0.05292699f, -0.14054525f, 
    0.32702866f, 0.09237540f, -0.08966552f, 0.00868527f, -0.02793144f, -0.05521712f, -0.06624234f, 0.07417383f, 
    -0.03026942f, -0.56620067f, -0.03188759f, 0.01930518f, -0.01482788f, 0.25590900f, 0.06931421f, 0.12700713f, 
    -0.06054972f, 0.22940509f, -0.05216733f, 0.04059603f, -0.03675093f, -0.10831667f, -0.06512782f, 0.05026270f, 
    0.05968287f, -0.00593350f, -0.04457503f, -0.10551387f, -0.06376300f, 0.08539800f, -0.17276171f, -0.14646851f, 
    -0.37260437f, 0.16969806f, -0.33612651f, -0.07799992f, 0.23844047f, -0.12226037f, -0.05476382f, -0.11736936f, 
    -0.17832255f, -0.10254032f, -0.12527959f, 0.09048514f, 0.02718689f, 0.00606485f, 0.02999217f, 0.01260037f, 
    -0.02660254f, -0.24641021f, 0.08436952f, 0.08198045f, 0.09078923f, -0.45784977f, -0.12944062f, -0.45793897f, 
    -0.09306403f, -0.14967291f, -0.28818136f, -0.19506504f, -0.09472430f, -0.12113792f, -0.22061154f, 0.06743696f, 
    -0.10745720f, -0.01828505f, -0.03165229f, 0.17700624f, -0.19801614f, -0.16109458f, -0.16471362f, -0.14903072f, 
    0.02953730f, -0.21256565f, -0.48435152f, -0.26839578f, 0.01075701f, -0.08451743f, -0.12895139f, 0.45285001f, 
    -0.13132294f, -0.13230118f, 0.04722372f, 0.12156853f, 0.01732638f, 0.02458713f, -0.03493378f, 0.08113969f, 
    -0.14860564f, 0.05325114f, -0.54906350f, -0.32000431f, -0.06751542f, 0.15620483f, 0.13891275f, 0.12124455f, 
    0.24161913f, -0.01229080f, 0.12265354f, -0.02683352f, 0.10558566f, -0.04171761f, -0.18079872f, 0.04410055f, 
    0.08126028f, -0.05133625f, -0.05572872f, 0.06416161f, 0.05761562f, -0.07907214f, 0.04305075f, 0.09025430f, 
    -0.10136191f, 0.14631099f, 0.23032245f, 0.19176960f, 0.04644553f, 0.02325785f, -0.01128005f, -0.09890757f, 
    0.10477728f, 0.13839456f, -0.03810222f, -0.05476533f, 0.11002243f, -0.01365242f, 0.04476802f, -0.14432141f, 
    -0.02322033f, 0.02043019f, 0.04680346f, 0.16239592f, -0.23041950f, 0.31086683f, -0.01922230f, 0.04211090f, 
    0.00360451f, 0.01455675f, -0.12335631f, -0.10194414f, 0.01077472f, -0.05547832f, -0.03629650f, 0.08479578f, 
    -0.10073092f, -0.01551657f, -0.11477952f, -0.01980288f, -0.09246341f, 0.00054831f, -0.06136297f, -0.00442018f, 
    -0.47417852f, 0.20984203f, -0.18022750f, 0.31255338f, 0.09446529f, 0.06870928f, -0.11833957f, -0.02957168f, 
    0.08584256f, 0.10315066f, 0.06515262f, -0.17607254f, -0.00246678f, -0.04070382f, -0.10240214f, -0.04120799f, 
    -0.08707076f, -0.11854824f, 0.11008630f, -0.02421964f, 0.00495866f, -0.20115559f, 0.19628742f, -0.27275079f, 
    -0.08061353f, -0.21960597f, 0.12161818f, -0.01492740f, 0.09090279f, -0.05852713f, 0.12384724f, 0.07881930f, 
    -0.17617778f, 0.03699352f, 0.09664347f, 0.03951512f, 0.02630421f, 0.07512615f, 0.13729098f, 0.19100070f, 
    -0.60096711f, 0.38041240f, -0.31470922f, 0.31741989f, -0.27839643f, 0.23427168f, 0.01048849f, 0.15611446f, 
    -0.06152068f, 0.07651074f, -0.00302814f, -0.19216461f, 0.04087870f, -0.02404199f, -0.05946602f, 0.11299942f, 
    -0.08754965f, 0.12256771f, 0.01747785f, -0.06368525f, -0.11400444f, -0.33095655f, -0.14393583f, -0.15799308f, 
    0.03250721f, -0.06795903f, -0.33145130f, -0.01974495f, -0.20214121f, -0.24510971f, 0.05596470f, 0.07426462f, 
    0.00362647f, -0.00136966f, -0.00676982f, 0.06845026f, 0.03560742f, -0.00066967f, 0.15814070f, -0.13494183f, 
    -0.11994018f, 0.09108786f, -0.21587366f, -0.01021578f, 0.12164334f, -0.07993109f, 0.13027973f, 0.09007299f, 
    -0.11356226f, 0.09144614f, -0.07558422f, 0.24464962f, -0.09254093f, -0.03295726f, -0.10116389f, 0.02187680f, 
    -0.05971421f, 0.00506017f, -0.20418297f, 0.03587972f, -0.84573919f, -0.29413396f, -0.06480196f, 0.20994937f, 
    -0.03077595f, 0.24699752f, 0.12902008f, 0.39783874f, -0.21450959f, 0.08375108f, -0.10769311f, -0.01872254f, 
    0.08610959f, 0.12086518f, 0.28962693f, 0.07413232f, 0.15564892f, -0.05990554f, 0.09636588f, -0.05342958f, 
    -0.34950292f, -0.32753366f, -0.12877034f, 0.02187166f, -0.16301379f, 0.16633435f, -0.60382420f, 0.31106785f, 
    -0.32114154f, -0.10704529f, 0.03295342f, 0.00127772f, -0.03139669f, -0.00261456f, -0.05398791f, -0.03184997f, 
    -0.07189336f, -0.02104594f, -0.03664847f, -0.13271360f, 0.46689805f, -0.55725616f, 0.48743698f, 0.00038602f, 
    0.18959096f, -0.08499389f, -0.10363446f, -0.15268198f, 0.08483113f, -0.15827088f, 0.02771115f, -0.00610541f, 
    0.12513746f, 0.04885913f, -0.06229459f, 0.04614116f, 0.06967212f, 0.12408859f, 0.09046311f, -0.09673334f, 
    0.07553985f, 0.18075086f, 0.03419040f, 0.31000030f, -0.07546480f, -0.15112869f, -0.06373755f, -0.03187912f, 
    -0.00073995f, -0.17994088f, -0.03691433f, 0.04924649f, -0.03743591f, -0.04905710f, 0.05148730f, -0.02764480f, 
    -0.08167689f, -0.00749955f, -0.11908786f, -0.21442246f, -0.17055252f, -0.08718516f, -0.10707904f, 0.21653084f, 
    -0.13513222f, -0.07829776f, -0.31067294f, 0.18614157f, -0.01414383f, -0.00509937f, -0.03425813f, -0.00472080f, 
    0.03508271f, -0.03548855f, -0.03885528f, 0.22758301f, 0.00337806f, 0.07432668f, 0.07146078f, -0.00887744f, 
    0.03041823f, 0.04479237f, 0.02400669f, -0.09913310f, 0.12581481f, 0.05052336f, 0.05790039f, 0.17186354f, 
    0.07322231f, -0.16176008f, -0.02371830f, -0.06573644f, 0.08269130f, 0.09743056f, 0.13580506f, 0.20644793f, 
    -0.01404884f, -0.17362049f, 0.02488745f, -0.19669095f, -0.08961134f, -0.32241711f, -0.24121819f, 0.14523138f, 
    -0.30939421f, -0.17513072f, -0.04064739f, -0.12415291f, -0.23395637f, -0.00405301f, 0.03942554f, 0.07052150f, 
    0.11273897f, -0.01427452f, -0.08609681f, -0.03781887f, 0.01139119f, 0.14639466f, 0.04417305f, 0.00609162f, 
    0.49976486f, 0.17666550f, 0.48365146f, -0.11024804f, -0.32957086f, -0.04540355f, 0.02778968f, -0.12579110f, 
    0.04501121f, 0.06592037f, -0.18696457f, 0.09631898f, 0.04670341f, -0.01120245f, -0.00976118f, -0.00081875f, 
    0.17189442f, 0.03897614f, -0.06088819f, 0.18977362f, 0.40816966f, -0.32331240f, 0.01906295f, 0.34653136f, 
    0.15355551f, -0.05181515f, 0.17359637f, -0.12475610f, 0.24172768f, -0.09807581f, -0.16717011f, 0.03486339f, 
    -0.02485571f, -0.00046707f, -0.02562872f, 0.02092187f, 0.03164424f, 0.13297246f, 0.10518450f, 0.00967054f, 
    0.02492005f, -0.47163844f, 0.32030174f, -0.56788969f, -0.04656120f, -0.11385221f, -0.04361571f, -0.00014636f, 
    -0.01148569f, -0.33504468f, -0.06199770f, 0.07281092f, 0.05534187f, 0.00201144f, -0.00880006f, 0.18901724f, 
    0.15090720f, 0.02954212f, 0.11739428f, 0.11016864f, -0.17197856f, -0.01406152f, -0.17069264f, 0.30954087f, 
    0.07921280f, -0.18076159f, 0.12606998f, 0.01224791f, 0.24612802f, -0.00597115f, 0.00775775f, -0.01176356f, 
    -0.04897999f, -0.07429813f, 0.06836811f, -0.03455862f, 0.06068366f, 0.04501156f, -0.08673669f, -0.04425250f, 
    -0.08151890f, 0.09382037f, 0.01571300f, 0.04616920f, -0.05688793f, 0.06634142f, -0.03451232f, 0.05621427f, 
    -0.00415905f, 0.04650826f, 0.07774547f, 0.00750688f, 0.03970733f, 0.03316521f, -0.00272118f, 0.01301711f, 
    0.06666459f, -0.06842398f, -0.00254349f, -0.14505549f, -0.18304047f, -0.12471480f, -0.31074446f, 0.34850252f, 
    0.14693582f, -0.03773271f, 0.21672262f, 0.06616566f, 0.27677405f, 0.12256232f, -0.23732068f, 0.02700895f, 
    0.06010276f, 0.01111699f, 0.00848884f, 0.08305034f, 0.12280642f, 0.17101546f, -0.05611767f, -0.17261238f, 
    -0.18478888f, 0.00680830f, -0.09856092f, 0.19917746f, -0.16431075f, -0.10141845f, 0.12821718f, 0.21107848f, 
    0.12384696f, 0.10283373f, -0.12460613f, 0.01733852f, 0.15422785f, 0.07643430f, -0.04541006f, -0.03670488f, 
    0.04817861f, 0.03440735f, -0.28844437f, -0.10959069f, -0.44476461f, 0.05429769f, -0.22561568f, 0.21689460f, 
    -0.27458835f, 0.01894519f, -0.06162290f, -0.01721578f, 0.00231101f, 0.11081687f, -0.01182982f, -0.14990030f, 
    -0.07152331f, -0.06365558f, -0.01279243f, -0.01254605f, -0.09370548f, -0.08984118f, -0.09464779f, 0.03331866f, 
    -0.40691999f, 0.30209008f, -0.66665399f, 0.21642973f, 0.35398918f, 0.09568746f, 0.26074877f, -0.16670968f, 
    0.17169492f, 0.11695664f, -0.08550285f, 0.10951895f, 0.22774677f, 0.12936020f, 0.06490643f, -0.11040916f, 
    0.00983816f, 0.10209877f, 0.07550059f, 0.11030788f, -0.35599127f, 0.21258526f, -0.12358732f, 0.19067624f, 
    -0.18147248f, 0.04918583f, 0.07169703f, 0.23969035f, 0.02665055f, -0.00234974f, 0.05933050f, -0.15246947f, 
    -0.09561574f, 0.09515420f, -0.03154235f, 0.01407561f, -0.01893927f, 0.09190717f, 0.07670528f, -0.17287682f, 
    -0.20595218f, 0.41861960f, 0.06862736f, 0.32876980f, -0.36350748f, 0.06276982f, -0.07224603f, 0.19677660f, 
    0.16184261f, -0.07040794f, -0.15804434f, 0.03051910f, -0.01976867f, 0.01628174f, 0.07590110f, 0.19382523f, 
    -0.32066864f, -0.00262094f, 0.05691281f, -0.13504377f, -0.28872520f, -0.17245603f, 0.02618037f, 0.13398533f, 
    -0.05401934f, 0.03159507f, -0.13790727f, -0.08861676f, 0.19820419f, 0.14688638f, -0.10149018f, 0.11388034f, 
    -0.16092761f, -0.25492540f, -0.06579670f, -0.17810893f, -0.15852959f, -0.12897742f, 0.08844060f, -0.09003656f, 
    -0.05952107f, -0.19391577f, 0.32684162f, 0.44784841f, -0.18611582f, 0.05652023f, -0.12510383f, -0.07693592f, 
    0.21979751f, -0.25864241f, -0.06838328f, 0.04459773f, 0.01776670f, -0.00858111f, 0.10357384f, 0.06772602f, 
    0.13452357f, 0.27318433f, 0.27112049f, -0.16716494f, -0.27782100f, -0.01235037f, -0.39523026f, 0.05941283f, 
    -0.25713873f, 0.20015582f, 0.28772572f, 0.19079421f, -0.27210605f, 0.05381967f, 0.10490189f, 0.04867106f, 
    0.10832927f, 0.22348477f, 0.14266460f, 0.00561974f, 0.10117718f, 0.20754880f, 0.04919979f, 0.13043533f, 
    -0.01633696f, -0.30656803f, -0.13989887f, -0.06703572f, -0.14795558f, 0.06234735f, -0.34156746f, -0.22572948f, 
    -0.20103043f, -0.05251624f, 0.05288971f, 0.03117028f, 0.06387887f, -0.03238584f, -0.06100317f, 0.08194997f, 
    -0.04326089f, -0.01942970f, -0.11676439f, -0.15743054f, 0.51491606f, -0.07144428f, 0.29761857f, 0.00706453f, 
    -0.24982934f, -0.02499763f, -0.03382286f, -0.06238404f, 0.00198878f, 0.03324125f, -0.18871267f, -0.05914654f, 
    0.00391926f, -0.16243090f, -0.03057339f, 0.13977644f, 0.12120339f, 0.03700231f, 0.02272816f, 0.14301369f, 
    0.00544667f, -0.51135105f, -0.32887924f, -0.27254620f, 0.30150455f, -0.25680700f, -0.42239785f, -0.12081404f, 
    0.09219858f, -0.18063860f, 0.04080569f, 0.05906675f, 0.09053537f, -0.12554994f, -0.09900466f, 0.11439150f, 
    0.02755374f, -0.11032948f, 0.10317020f, 0.08594774f, -0.08165957f, 0.19685246f, -0.44140831f, 0.40065843f, 
    0.19001469f, -0.10005493f, -0.19287375f, -0.01289012f, -0.10871465f, 0.11925622f, -0.05962878f, -0.06416816f, 
    -0.16042709f, -0.06795901f, -0.02501758f, 0.06761858f, -0.09904160f, 0.07902897f, 0.04091754f, -0.27880481f, 
    -0.22815420f, -0.00313052f, -0.18313828f, 0.68504781f, 0.21192549f, -0.11301098f, 0.18283521f, 0.11372519f, 
    0.33283842f, 0.09199829f, -0.07884219f, -0.09010720f, 0.02208366f, 0.08423723f, 0.02148159f, -0.03795829f, 
    0.09741931f, 0.18555474f, -0.09579357f, -0.00748456f, -0.77732676f, 0.12552361f, -0.58574599f, 0.21068341f, 
    -0.58272672f, -0.02025403f, 0.11385357f, 0.00480819f, 0.02846096f, 0.04307937f, -0.10377612f, -0.08075747f, 
    0.04058784f, 0.01204429f, -0.15980326f, 0.04117289f, -0.00082403f, 0.02874588f, -0.09197953f, 0.11860479f, 
    -0.71047789f, -0.06392816f, -0.09710512f, 0.11926065f, -0.35522485f, -0.06012628f, 0.09283285f, 0.01051019f, 
    0.21611913f, -0.01454053f, -0.15056802f, -0.24314260f, 0.00483869f, -0.09973537f, 0.15571737f, 0.13173500f, 
    -0.13789323f, 0.10606141f, -0.02599626f, 0.03281854f, -0.01318416f, -0.25858384f, 0.06795777f, 0.03476752f, 
    0.23521174f, 0.07545243f, 0.05629005f, -0.03895264f, -0.00221196f, 0.01338652f, 0.08197430f, 0.23196530f, 
    0.00292298f, 0.01393098f, -0.01824964f, -0.03923411f, -0.11085092f, 0.03782800f, -0.19553404f, -0.19288959f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19241962f, 0.08664662f, 0.06471299f, -0.13639462f, -0.05792978f, 0.03624625f, 0.01754757f, -0.11781172f, 
    0.06668323f, 0.01648187f, 0.03743646f, -0.01401456f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
