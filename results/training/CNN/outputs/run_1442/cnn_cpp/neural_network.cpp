#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.14400177f, -0.27304441f, -0.11369183f, 0.21524359f, 0.65349114f, 1.35857666f, -0.34406132f, -0.56949818f, 
    0.98580396f, -1.02870274f, -0.91130215f, -0.08678039f, 0.60642815f, 0.07653068f, -1.02269363f, -0.33883479f, 
    0.17158249f, -0.36722264f, -1.59563065f, 0.82262123f, 0.29558739f, 0.56236207f, -0.33504739f, 0.33457822f, 
    -0.37187973f, -0.20319612f, -0.37809739f, 0.41742596f, 0.32595915f, 0.49744585f, 0.35247087f, 0.19483475f, 
    0.61864686f, 0.69347125f, -0.37935829f, 0.15413550f, 0.06193599f, -0.67047304f, -0.72465628f, 0.66428816f, 
    0.68374032f, 0.85227329f, -0.61777103f, -0.40303487f, -0.37865800f, -0.51034498f, -0.52393788f, -0.45896447f, 
    -0.03674839f, -0.27032003f, -0.00139028f, 0.31363934f, 0.49466112f, 0.97589540f, -1.74892676f, -0.65096474f, 
    0.43996423f, -0.41169021f, -0.42939398f, -0.01668468f, 0.14517817f, 0.10556774f, 0.44374150f, 1.43253100f, 
    -1.09112144f, -0.74638104f, 1.00213289f, -0.27572471f, 0.08400150f, 0.00783674f, 0.06686331f, -0.50316614f, 
    0.02506915f, -0.35995895f, 0.76119274f, -0.97148311f, -1.02090049f, -0.93170774f, 0.42315638f, -0.03242140f, 
    0.70287865f, -0.48272902f, -0.82075948f, -0.35393429f, 0.58585364f, 0.74196303f, 0.06974535f, 0.84113479f, 
    0.43944290f, 0.22082335f, -0.93761450f, -0.75209725f, -0.82040125f, 0.13205975f, 0.74738646f, 0.52565223f, 
    -0.08291761f, -0.22911662f, -0.65878987f, 0.52648157f, -0.20534602f, -0.02023022f, -0.30772108f, -0.53942895f, 
    1.06827211f, 0.10299000f, 0.27574220f, 0.28077361f, 0.03481754f, 0.10127654f, -0.99618942f, -0.58883709f, 
    -0.45025823f, -0.55867451f, -0.13536094f, -0.75851637f, -0.13552316f, -0.09652907f, 0.58402210f, 0.69499981f, 
    0.51059777f, -0.42230815f, -0.40831935f, -0.21912682f, 0.45286453f, -0.63881367f, 0.22855295f, -0.31512487f, 
    -0.06378496f, -0.06941634f, -0.19389527f, 0.14606673f, -0.02501795f, -0.78719062f, -0.70106292f, 1.10030973f, 
    1.38212013f, -1.15212715f, -0.66137606f, -0.34152970f, 0.38301849f, -0.19491613f, 0.47767159f, -0.54704452f, 
    -0.53961945f, 0.12213171f, 0.45577028f, -0.53016895f, -0.38817757f, -0.56641167f, 0.41703001f, 0.73104286f, 
    0.54723591f, -0.92481238f, 1.52245867f, -1.13192844f, 0.44738647f, -0.09695350f, 0.46150044f, -0.20336761f, 
    -0.41964561f, 0.20138095f, -0.14376713f, -0.09531986f, -0.75134158f, -0.45204222f, 0.11635066f, -0.03215334f, 
    -0.76584941f, -0.00390299f, -1.11120415f, 0.40123144f, 0.56442463f, -0.02084984f, 0.45102957f, 0.56009930f, 
    0.13326976f, -0.36089927f, -0.58824348f, -0.29677784f, 0.60022849f, 0.19127864f, 0.91760540f, -1.17338908f, 
    -0.25637853f, 0.90783608f, 0.04419581f, 0.00196117f, 0.04684541f, -0.11338667f, 0.71371233f, 0.27697673f, 
    -0.64978391f, -0.16885011f, -0.86180598f, -0.40959337f, -0.71793371f, -0.68278527f, -0.09430528f, -0.26789647f, 
    -0.62170005f, -0.58536702f, -0.49024788f, -0.53034723f, -0.25531653f, -0.43279925f, -0.12972260f, 0.88937610f, 
    -0.43271053f, -0.49101964f, -0.45757750f, 0.89081866f, -0.16318981f, 0.43341184f, 0.13681914f, 0.63156229f, 
    0.52722359f, 0.71032333f, 0.54183596f, -0.05084768f, 0.42659450f, -0.22173715f, 0.29791972f, 0.43987653f, 
    0.69142711f, 1.03239214f, -0.07151710f, -1.24408937f, -0.15274659f, -0.25892636f, -0.30548894f, 0.88385952f, 
    -0.09822854f, 0.40564194f, 1.02327764f, -1.26556361f, -0.03461898f, -0.83458608f, -0.58586371f, -0.92278051f, 
    -0.50076759f, 0.11446331f, -0.05365750f, 0.32515794f, 0.21340682f, 1.01538527f, 0.30654222f, -0.37887505f, 
    -0.26075512f, -0.55199265f, -0.88343525f, 0.34331068f, -0.46861094f, -0.59352982f, -0.96533525f, 0.74424809f, 
    0.53836417f, -0.10573102f, -0.34968764f, -0.21135524f, -0.62856710f, 0.18178838f, 0.25706390f, -0.66427821f, 
    0.83377886f, -0.15952924f, 0.10617981f, -0.37682810f, 0.49949512f, 0.12841946f, -1.26077199f, 1.22576034f, 
    -0.60192353f, -0.39780915f, -0.16373764f, -0.36259347f, 0.11764384f, 0.90789133f, -0.51163071f, -0.05525593f, 
    0.88565087f, -0.13875413f, 0.89250904f, 1.28643024f, -0.25539145f, 0.06160951f, 0.03933332f, -0.00224038f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02367163f, -0.38227347f, -0.29147521f, 0.52021480f, -0.19221245f, 0.26735520f, 0.52550626f, 0.33208293f, 
    0.20923989f, 0.16797449f, 0.41557980f, 0.38915902f, -0.39211169f, 0.59203005f, 0.55573386f, -0.02721197f, 
    0.19015788f, 0.16290465f, -0.02224153f, 0.23784342f, 0.42082292f, 0.11139680f, -0.59798628f, 0.42671129f, 
    0.09831383f, 0.54630971f, 0.71627957f, -0.29217294f, 0.27568883f, 0.67493987f, -0.03488155f, -0.13948366f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.07346470f, 0.07723393f, -0.26651829f, 0.04814300f, -0.17869404f, -0.17193687f, 0.11226059f, -0.06289249f, 
    0.16063118f, -0.16902533f, -0.26780152f, 0.23134194f, 0.06487429f, -0.10013399f, -0.34779060f, -0.05694803f, 
    -0.02293424f, -0.41383788f, -0.30913028f, -0.10531445f, 0.16328076f, 0.02738514f, 0.00019630f, -0.00276715f, 
    0.22364955f, -0.30089462f, -0.07525869f, 0.25451079f, 0.12551624f, 0.05722905f, 0.02859672f, -0.12196759f, 
    -0.27101058f, -0.16120960f, -0.00406505f, -0.03770951f, 0.19543031f, 0.11700740f, -0.29383826f, -0.08461302f, 
    -0.26531446f, 0.12891236f, -0.06713571f, -0.02993055f, 0.19080473f, -0.17481819f, 0.14619190f, -0.21373555f, 
    -0.02490571f, 0.05023408f, 0.02724119f, 0.11216250f, -0.05686084f, -0.11869240f, -0.70986301f, -0.28148782f, 
    -0.02091796f, 0.06785565f, 0.13059095f, -0.08142590f, 0.16643703f, -0.09176926f, -0.12490727f, 0.51304191f, 
    -0.05796010f, 0.09011113f, -0.02138827f, 0.04403365f, 0.42321339f, -0.07791544f, -0.00746105f, 0.23024945f, 
    0.01063391f, -0.05901415f, -0.42872858f, -0.01605477f, 0.16817196f, 0.10891221f, 0.22809932f, -0.03980580f, 
    0.06067213f, -0.01938878f, 0.10675231f, -0.17430082f, -0.17243227f, 0.01065938f, -0.03876838f, 0.06195344f, 
    0.05062611f, 0.02920889f, -0.29446116f, -0.26424584f, -0.45302284f, -0.03552341f, -0.16904205f, 0.18284109f, 
    0.00851084f, 0.05295406f, 0.00441891f, 0.23586626f, 0.02372715f, 0.06293786f, -0.02351958f, -0.06333534f, 
    0.18566716f, 0.21042478f, 0.02227214f, 0.00444197f, 0.21941388f, 0.41472700f, -0.15001307f, -0.06256738f, 
    -0.02303515f, -0.09268404f, 0.04031607f, -0.01357886f, 0.07525226f, 0.01981742f, -0.15694450f, 0.10095239f, 
    0.16427568f, 0.00895876f, -0.04306344f, 0.18822140f, 0.24087469f, 0.23072274f, 0.10979321f, -0.08100550f, 
    0.04599452f, 0.09029089f, 0.11721517f, 0.17776842f, -0.07019018f, 0.19290690f, 0.12287796f, 0.39900973f, 
    -0.15489548f, -0.28698885f, -0.04599048f, -0.03999180f, 0.19777289f, 0.52634519f, -0.08165301f, -0.05540871f, 
    -0.40263274f, 0.28881848f, 0.14119563f, 0.10653077f, 0.04583711f, -0.00356590f, 0.12689719f, 0.04158982f, 
    0.08351829f, -0.02326924f, 0.25094667f, -0.21519184f, -0.15600373f, -0.30839720f, 0.35966992f, 0.07280280f, 
    -0.13968877f, -0.00949915f, -0.08467384f, -0.44446492f, -0.40456793f, -0.07198408f, -0.09246828f, -0.05871396f, 
    0.08460659f, 0.02088334f, -0.04524244f, 0.13358277f, 0.04661281f, -0.00776439f, 0.03362412f, 0.02809846f, 
    -0.02558586f, -0.03213783f, 0.01315856f, 0.18701357f, 0.14167383f, -0.11241081f, 0.01691310f, 0.03795861f, 
    0.19380100f, -0.10771883f, 0.27686086f, 0.12609701f, 0.01368133f, -0.13491337f, -0.59715778f, -0.40560088f, 
    0.05039494f, 0.10898560f, 0.02116765f, -0.16848376f, -0.02283331f, -0.15182936f, 0.45288789f, 0.33682585f, 
    0.16230501f, -0.04577811f, -0.03326602f, -0.14369194f, 0.10792919f, 0.07617923f, 0.10061911f, 0.27824625f, 
    0.12536405f, 0.01418456f, 0.07513143f, -0.01079281f, 0.14468031f, 0.11860263f, 0.00095903f, -0.04692370f, 
    0.33647710f, 0.07438073f, -0.03394436f, -0.04616566f, 0.06028704f, -0.07073329f, 0.02123864f, 0.06139919f, 
    -0.01076221f, 0.33152959f, 0.34530380f, -0.03835962f, 0.14373063f, 0.24393038f, 0.12666935f, 0.10805654f, 
    0.05478252f, -0.04873759f, -0.02425827f, -0.41301665f, -0.34668183f, 0.09621059f, 0.23018807f, 0.19900431f, 
    0.27565777f, 0.04746570f, -0.13855380f, 0.03956810f, -0.00427438f, -0.13173331f, 0.13038212f, 0.06801742f, 
    -0.15989541f, -0.18782072f, 0.19221465f, 0.37039840f, -0.18436688f, -0.20355089f, -0.40201691f, 0.00616401f, 
    -0.03553835f, 0.04907791f, -0.15476006f, -0.03379609f, 0.04980145f, 0.25403664f, 0.22737552f, -0.14706646f, 
    0.12356043f, -0.18030331f, 0.06156384f, -0.03009740f, 0.07220878f, 0.14008702f, -1.17134881f, -0.30799845f, 
    -0.04558197f, 0.03240896f, -0.26395997f, -0.19252668f, 0.09570669f, 0.08415148f, 0.17995299f, 0.02480064f, 
    0.14223689f, -0.03428540f, -0.03368632f, -0.23339736f, -0.19738021f, 0.00237060f, -0.08543221f, -0.07799251f, 
    -0.05813891f, -0.74850070f, 0.15347418f, -0.42677179f, 0.08750225f, -0.41372398f, -0.03706524f, 0.04305975f, 
    -0.01370622f, -0.46791047f, -0.07025794f, 0.11968400f, 0.11507054f, -0.07974552f, 0.07163972f, 0.24917971f, 
    -0.06929085f, -0.12991720f, -0.66014242f, -0.00878691f, -0.06830724f, 0.18759525f, -0.45492366f, -0.15126720f, 
    -0.38671088f, -0.25015095f, -0.09983323f, -0.46309966f, -0.05449719f, 0.07309429f, -0.03874720f, 0.08784542f, 
    0.05380074f, -0.01816840f, 0.00098517f, 0.24506781f, 0.10133482f, -0.00733309f, 0.14292157f, -0.26783323f, 
    -0.01493250f, -0.38186148f, -0.00712826f, -0.02789320f, -0.05592764f, -0.34649807f, -0.17361878f, 0.12294172f, 
    -0.16442987f, 0.20715497f, 0.05915468f, -0.05862416f, 0.06008303f, -0.01325324f, -0.19122399f, -0.02519130f, 
    0.14815988f, -0.05628374f, 0.09948913f, -0.01707485f, 0.13673359f, 0.09149683f, 0.13727240f, 0.24215902f, 
    0.03991525f, -0.43819571f, -0.43880272f, 0.00730732f, 0.07032634f, 0.06796246f, 0.06106298f, 0.04243064f, 
    0.43889815f, -0.38528642f, -0.33910537f, -0.13244933f, 0.10303333f, 0.00717108f, -0.04953988f, -0.06373888f, 
    0.13925098f, -0.31108713f, -0.34068164f, -0.15470074f, -0.11844054f, -0.02835879f, 0.00680938f, 0.05788414f, 
    0.25216758f, 0.12597494f, 0.18408905f, 0.41372171f, 0.45850638f, 0.01742275f, 0.06164213f, 0.10784391f, 
    0.00947546f, 0.03710793f, -0.00591416f, -0.03773700f, -0.20987688f, 0.20050688f, 0.17604707f, 0.18883108f, 
    -0.07982386f, 0.28247717f, 0.17436570f, 0.29997686f, -0.10863146f, -0.31172514f, -0.28073323f, 0.10379420f, 
    -0.19553237f, 0.02584922f, 0.22960517f, 0.08101989f, 0.10087921f, -0.31876931f, -0.35363942f, 0.28435579f, 
    0.12482196f, 0.24433193f, 0.06225387f, 0.17537341f, 0.23135521f, 0.07049023f, 0.08144515f, 0.13762665f, 
    0.18597198f, -0.01598021f, 0.22233330f, 0.00212818f, 0.30942196f, -0.02362651f, -0.10393754f, 0.14571321f, 
    -0.68977487f, 0.05374081f, -0.20929559f, -0.25901690f, -0.20374529f, -0.09966965f, -0.34168640f, 0.09270527f, 
    0.40128189f, -0.09426226f, 0.01810571f, -0.03557906f, 0.11401613f, -0.19911793f, 0.07445011f, -0.08997999f, 
    0.21401112f, -0.06886509f, 0.21090718f, -0.44171700f, 0.14044909f, 0.07071950f, -0.20032620f, -0.07481166f, 
    0.12634803f, 0.04475558f, 0.04513429f, -0.02007136f, 0.11067002f, -0.15602490f, -0.00501253f, 0.22999640f, 
    0.22402646f, 0.02876712f, 0.13777798f, 0.05085454f, -0.18121947f, 0.06202142f, -0.17022260f, 0.21494611f, 
    0.01959066f, 0.21622111f, -0.08444062f, -0.17748737f, -0.32961553f, -0.96082300f, 0.09258393f, 0.05696581f, 
    -0.05310191f, -0.14337488f, 0.14791575f, 0.20859841f, 0.31496155f, -0.11876765f, -0.48284549f, -0.02749137f, 
    0.16352433f, 0.01682585f, -0.05057995f, -0.00881112f, 0.06512905f, 0.03379038f, -0.32364428f, -0.37429953f, 
    -0.21265602f, 0.06594528f, -0.17987901f, -0.11084512f, 0.24581359f, 0.07224246f, 0.03563725f, 0.06139708f, 
    0.21867180f, -0.17581487f, -0.11867408f, 0.11546088f, 0.13827527f, 0.07446630f, 0.23313560f, 0.35339209f, 
    -0.26997727f, -0.18153799f, -0.10653696f, 0.04792250f, -0.20539215f, -0.10916540f, -0.07910161f, 0.15831368f, 
    0.27615815f, 0.05069275f, 0.18934083f, -0.26039994f, -0.04837470f, -0.01876832f, 0.32473135f, 0.12826931f, 
    0.01841416f, -0.07928433f, 0.13198660f, 0.04007483f, -0.03659594f, -0.09895306f, 0.13123184f, -0.12300398f, 
    0.11819872f, 0.13529724f, 0.09371416f, -0.72680503f, -0.40206689f, -0.23029396f, -0.21694075f, 0.16844575f, 
    -0.13291664f, 0.00828570f, -0.09026741f, -0.22993191f, 0.08099023f, 0.27263084f, 0.22218168f, -0.07299091f, 
    0.10112922f, 0.19727243f, 0.03724902f, -0.10245296f, 0.09114627f, 0.38224846f, 0.05251389f, -0.32255858f, 
    0.05573342f, 0.10169525f, 0.41580898f, 0.11632717f, 0.25629142f, 0.27513340f, -0.51068616f, -0.44794419f, 
    -0.10509431f, 0.08262337f, -0.06109391f, -0.27771822f, -0.24376561f, -0.17752719f, -0.08618955f, -0.43878642f, 
    -0.01897826f, -0.10081922f, -0.00911120f, -0.32373798f, -0.36220297f, 0.30049688f, 0.18621787f, -0.03055486f, 
    -0.05817031f, -0.05696379f, -0.04288623f, 0.00133778f, -0.03384393f, 0.03961781f, -0.00806649f, -0.04398656f, 
    0.01334696f, -0.05393838f, -0.00825069f, -0.02450187f, -0.01815731f, 0.05714062f, -0.00939084f, 0.02506853f, 
    0.04041019f, -0.02405391f, -0.05624374f, -0.03726698f, 0.02768518f, -0.00967562f, 0.00832902f, -0.05638883f, 
    -0.04638200f, -0.05585119f, 0.02544437f, -0.02169474f, -0.02096220f, 0.00533752f, -0.05915488f, -0.03474184f, 
    0.00790165f, 0.03538408f, -0.02697873f, 0.03586972f, 0.03411913f, 0.03230730f, 0.01144775f, -0.04529110f, 
    0.03575413f, -0.04340045f, 0.04537474f, -0.00164380f, 0.00924101f, -0.00981316f, 0.05220784f, -0.03261343f, 
    0.02135810f, -0.04149283f, 0.00696909f, 0.05867990f, -0.01641126f, -0.03227140f, 0.01574654f, -0.02974431f, 
    -0.04580966f, 0.04187135f, -0.00806182f, 0.03862392f, 0.05160088f, -0.04974843f, -0.00466308f, -0.00977716f, 
    0.05310923f, -0.00858367f, -0.05884775f, -0.03863905f, -0.05680572f, 0.03502134f, 0.00030761f, 0.00465736f, 
    -0.03999052f, -0.03571620f, -0.00062940f, 0.01429073f, -0.02227781f, 0.02256036f, 0.03921500f, 0.05093957f, 
    -0.00569402f, -0.00451092f, -0.03545077f, 0.03616059f, -0.00247532f, -0.03332106f, 0.00579355f, -0.02633390f, 
    0.02500164f, 0.00597490f, -0.05708105f, -0.00681634f, -0.05913899f, -0.02503203f, -0.06044459f, -0.03803745f, 
    -0.00929266f, 0.04707112f, -0.02031598f, -0.05022720f, 0.00857775f, 0.01107526f, 0.04304353f, -0.06319458f, 
    -0.02799801f, 0.01352439f, -0.02780762f, -0.04650637f, 0.04185746f, 0.05110496f, -0.02887836f, -0.01107087f, 
    -0.04643098f, 0.00251745f, -0.02122721f, 0.00631365f, -0.05792757f, 0.02260002f, -0.04355720f, 0.00663601f, 
    0.03706267f, -0.00430676f, -0.00754204f, 0.04250288f, -0.00271929f, -0.04067284f, 0.02474235f, 0.02121551f, 
    0.02932213f, -0.01059864f, -0.05842796f, -0.06232787f, 0.00529254f, -0.00310660f, 0.03508524f, 0.00273485f, 
    0.00675975f, 0.04638325f, -0.02832705f, 0.00876530f, -0.01697099f, 0.02668146f, -0.00273223f, 0.04977052f, 
    -0.02907964f, -0.04512828f, 0.05214966f, -0.00321910f, -0.03542463f, -0.06248381f, -0.04782296f, -0.03730598f, 
    0.01723471f, 0.00663740f, -0.01890729f, 0.04002494f, -0.00965480f, 0.00112148f, 0.00382746f, -0.03039310f, 
    0.04212920f, 0.02695417f, 0.03595483f, 0.00243324f, 0.04228079f, -0.03544286f, 0.05081405f, 0.00056635f, 
    -0.03533270f, 0.01150230f, 0.02338946f, 0.00827593f, -0.03763102f, -0.00269194f, -0.03567455f, 0.04728956f, 
    0.03657430f, -0.01354322f, -0.06131662f, -0.03762968f, -0.00878793f, -0.03596005f, -0.04441291f, 0.04781365f, 
    -0.04044946f, 0.04455340f, -0.05631917f, -0.03648508f, -0.06106253f, 0.00724413f, -0.02029940f, -0.04574953f, 
    -0.03172634f, -0.05481001f, 0.02791947f, -0.05357475f, 0.01830276f, 0.02951986f, 0.02574432f, -0.01207954f, 
    -0.04803053f, -0.00434016f, -0.02588456f, -0.04428450f, -0.02331236f, 0.00509171f, 0.04927078f, -0.02472171f, 
    -0.01531932f, -0.04591557f, 0.03348222f, 0.05113943f, 0.04814876f, -0.05923560f, -0.01697640f, -0.05449230f, 
    0.04003381f, -0.02087349f, -0.01832089f, 0.00158682f, 0.02103645f, 0.04379091f, 0.02496584f, -0.04505817f, 
    0.01953408f, -0.04642896f, -0.02986107f, 0.03503091f, -0.02683054f, -0.05131072f, -0.03758800f, 0.01676789f, 
    -0.01121953f, 0.03989612f, 0.03782866f, -0.00511492f, -0.05688722f, -0.00196034f, -0.03875338f, -0.06317560f, 
    -0.06128661f, 0.01840227f, 0.00687947f, 0.03947191f, 0.01687715f, 0.03710594f, -0.01768376f, 0.01294459f, 
    -0.02634428f, -0.05636087f, -0.06320763f, 0.01825330f, 0.02346030f, -0.03709255f, -0.02979158f, -0.05766298f, 
    -0.01954314f, 0.03788467f, -0.06374746f, -0.04809795f, 0.03563733f, 0.02498727f, -0.04774354f, -0.02332239f, 
    -0.03833346f, 0.01444283f, 0.00748298f, -0.03850118f, 0.00838218f, 0.04671356f, 0.01297446f, -0.01620898f, 
    -0.04162822f, -0.03265431f, 0.01035901f, -0.03410980f, -0.02056171f, -0.03474814f, -0.04562888f, 0.02229971f, 
    -0.01810308f, 0.00231972f, 0.00340751f, 0.04432316f, -0.00232472f, -0.03217375f, -0.06009318f, -0.02957256f, 
    -0.02754097f, -0.01447323f, -0.04380806f, -0.02377266f, -0.00904041f, 0.01719711f, -0.05702724f, -0.00466305f, 
    -0.00793966f, 0.02016818f, -0.02932065f, -0.01379774f, -0.01295718f, -0.05508130f, 0.04944488f, -0.00567856f, 
    -0.02700853f, 0.05596363f, -0.02909098f, -0.01371469f, -0.04485295f, -0.00468211f, 0.01669542f, -0.02022592f, 
    0.02130775f, 0.03823524f, -0.05878865f, -0.01650900f, -0.02596242f, -0.01590152f, 0.02923592f, 0.02747148f, 
    0.03787345f, -0.01590708f, -0.06184556f, 0.05655726f, 0.00531617f, 0.00936602f, -0.00111192f, -0.02085529f, 
    -0.05987938f, 0.01054332f, -0.03363091f, 0.01726961f, 0.04674583f, -0.03998357f, -0.00147535f, 0.00851283f, 
    -0.01590489f, 0.04065247f, 0.02595375f, 0.00319741f, 0.02372755f, -0.04599180f, 0.04497781f, 0.04416857f, 
    -0.04702839f, 0.02215834f, -0.04826979f, -0.00047711f, -0.03790420f, -0.00356935f, -0.03290586f, -0.02959969f, 
    -0.00784859f, 0.00831026f, -0.02053860f, -0.02324959f, -0.04594937f, -0.03021723f, -0.02391564f, 0.04994400f, 
    -0.04034170f, -0.03218309f, 0.01867756f, 0.00941701f, 0.03758693f, 0.02760861f, 0.02630768f, -0.05373371f, 
    0.03815346f, 0.03693983f, -0.03387973f, 0.00006553f, 0.00592520f, 0.01511839f, 0.00778975f, -0.01700658f, 
    0.04630791f, 0.01273192f, 0.00606384f, -0.03431309f, -0.01701400f, 0.02851875f, 0.04210068f, 0.01302858f, 
    -0.01068098f, -0.03070171f, 0.04127375f, -0.04063440f, -0.05401496f, -0.05436173f, -0.05975587f, -0.02494666f, 
    -0.02146268f, 0.01491502f, 0.03845196f, 0.05549280f, 0.01189732f, 0.01969557f, -0.00379259f, -0.05537254f, 
    0.01249055f, 0.01801788f, -0.03398036f, -0.00681694f, -0.04543580f, 0.01171838f, -0.04254732f, -0.03063709f, 
    -0.00602532f, 0.03481780f, -0.02385358f, 0.01360490f, -0.04631526f, -0.02884661f, -0.02971742f, -0.06383913f, 
    -0.01493809f, 0.03210886f, -0.01698050f, 0.01691607f, -0.00606977f, 0.04340859f, 0.01528961f, 0.02928453f, 
    0.00793670f, -0.04089821f, -0.03998026f, -0.00499251f, 0.00028197f, -0.01291412f, -0.04067719f, -0.05346948f, 
    -0.03080257f, 0.01790007f, -0.03778898f, -0.01511589f, -0.04765869f, -0.02716671f, 0.02756423f, -0.04383263f, 
    0.01687996f, 0.00615288f, -0.06352101f, 0.02251087f, -0.05585625f, -0.03390713f, -0.02942249f, -0.02959835f, 
    0.02329050f, -0.04013615f, -0.02422453f, -0.03633190f, 0.03006967f, 0.05424837f, 0.02292600f, -0.05970446f, 
    -0.02604990f, -0.01268942f, 0.03035544f, 0.02406019f, -0.02897087f, 0.01513836f, 0.01921361f, -0.05417736f, 
    0.03863763f, 0.03788433f, 0.00875621f, -0.03562560f, 0.00375650f, -0.04819660f, 0.01473879f, 0.03100837f, 
    0.04804648f, 0.02315201f, 0.03582976f, 0.03220903f, -0.01684254f, -0.01680379f, 0.02184850f, -0.00418522f, 
    -0.03202936f, 0.04153416f, 0.02556801f, 0.01392703f, -0.04317869f, -0.06585709f, 0.05383949f, -0.01416114f, 
    -0.02220008f, 0.03525611f, 0.04441040f, 0.03929086f, -0.00845614f, 0.02644258f, -0.01522891f, 0.00179982f, 
    0.01283417f, -0.03714684f, 0.00407244f, -0.01434953f, -0.03294085f, 0.01931228f, 0.00661465f, -0.01656744f, 
    0.03957441f, 0.04723635f, -0.00184172f, -0.01479567f, -0.02353638f, 0.00548914f, -0.02237675f, 0.00108227f, 
    -0.04987844f, -0.05293458f, -0.05044220f, -0.04366633f, -0.00598841f, 0.00459500f, -0.05882407f, -0.01434450f, 
    0.02429729f, -0.03673946f, 0.00559926f, 0.03121643f, -0.01740626f, -0.01809388f, -0.01151276f, -0.02290924f, 
    -0.04317264f, 0.03935827f, 0.01975805f, -0.01441468f, 0.02508959f, -0.06541926f, -0.01186793f, 0.04312860f, 
    0.05260069f, -0.00647309f, -0.06198321f, 0.00218727f, -0.01281692f, -0.05490832f, 0.04900541f, -0.05458801f, 
    -0.02089662f, -0.03663826f, -0.05707974f, -0.01061875f, -0.01178356f, -0.02258122f, 0.00250603f, -0.05933621f, 
    -0.04199696f, -0.00240540f, 0.03217479f, 0.03670055f, -0.05560990f, -0.04606391f, -0.04430787f, -0.04142329f, 
    -0.06066611f, 0.05621042f, 0.03017106f, -0.05240972f, -0.00992532f, 0.00785523f, -0.03523754f, -0.01490616f, 
    0.03506312f, 0.02102640f, -0.06040972f, -0.02831443f, -0.01383025f, -0.06230586f, -0.05214122f, 0.03485179f, 
    0.00625083f, -0.40643764f, 0.00227880f, -0.02702583f, 0.19784626f, -0.18414982f, 0.04931660f, 0.10998224f, 
    -0.01251098f, 0.00017938f, -0.15755555f, -0.28776601f, -0.01765464f, 0.11483708f, -0.09711223f, 0.20834696f, 
    -0.36768124f, 0.03232776f, -0.50681889f, 0.27976912f, 0.48129070f, 0.05973697f, 0.01417353f, 0.28199050f, 
    -0.45234910f, -0.18730630f, -0.23783278f, -0.05148498f, -0.10556106f, -0.05716051f, -0.14401792f, -0.30632481f, 
    0.08220929f, -0.22538719f, 0.01653103f, -0.05139778f, 0.01846443f, -0.16696271f, -0.38597959f, 0.28466487f, 
    0.05458352f, 0.07191287f, -0.12580529f, -0.03284571f, -0.26978871f, -0.01223132f, 0.00489810f, -0.01934940f, 
    -0.31041005f, 0.05621452f, -0.13139774f, 0.11021613f, -0.03724684f, 0.01391575f, -0.02651183f, -0.04420718f, 
    0.03967274f, 0.01162413f, -0.05761298f, -0.06018412f, 0.07060948f, -0.05750601f, -0.07534827f, -0.06851988f, 
    0.07571287f, 0.17030975f, 0.07285252f, 0.09058466f, -0.07740410f, -0.09532060f, -0.52086008f, -0.21787900f, 
    0.03051061f, 0.11659671f, 0.37177587f, 0.05962346f, 0.05431494f, 0.07175288f, 0.15082519f, -0.08382993f, 
    -0.16492812f, 0.05892450f, -0.11149444f, -0.09840158f, -0.06653020f, -0.08063282f, -0.00130107f, -0.07803943f, 
    0.12706636f, -0.09785318f, -0.03042631f, -0.31407759f, -0.25436571f, 0.04734604f, 0.09249984f, -0.06957066f, 
    -0.09369454f, -0.05815425f, 0.02069479f, -0.15798981f, -0.13313243f, 0.24606089f, -0.08615831f, -0.11541411f, 
    0.03658788f, 0.06826952f, 0.23736641f, 0.16193873f, 0.12335087f, 0.04212191f, -0.00267402f, -0.05370338f, 
    0.15026553f, 0.17945765f, 0.12680882f, -0.02466312f, 0.19932444f, -0.12635000f, -0.04846071f, 0.18332236f, 
    0.10400569f, 0.11340886f, -0.10938436f, -0.16557419f, 0.14486241f, -0.06007459f, 0.12517637f, 0.01050948f, 
    0.00488257f, 0.07021991f, 0.11970288f, 0.18075019f, -0.13808453f, -0.41409555f, -0.18074769f, 0.63458586f, 
    -0.10341817f, -0.12660441f, 0.17691131f, 0.11290966f, 0.12799847f, 0.17848125f, 0.25113624f, 0.01043054f, 
    -0.14437218f, 0.26819479f, 0.27178878f, -0.01235722f, 0.07612483f, 0.00207004f, 0.06853766f, 0.12702674f, 
    0.16690990f, 0.09323528f, 0.31852970f, 0.14543925f, -0.06713279f, 0.16510892f, 0.41315040f, -0.21189658f, 
    0.48653504f, 0.04364846f, -0.30225465f, -0.09233537f, 0.18253754f, 0.05291566f, -0.02899256f, 0.12556407f, 
    0.11369736f, -0.08750395f, 0.18747136f, 0.14000934f, -0.00971821f, -0.10820501f, 0.05760171f, -0.12758538f, 
    0.13855265f, -0.26823121f, 0.12982643f, -0.46157727f, -0.07957505f, -0.21231598f, 0.12963298f, 0.06380210f, 
    -0.00326217f, 0.00667676f, -0.10200356f, 0.22536688f, -0.09214623f, -0.05981189f, 0.00000478f, 0.05677367f, 
    0.03955612f, 0.01187704f, 0.05764343f, -0.09800365f, -0.09801190f, -0.44345897f, 0.05452244f, -0.09090598f, 
    -0.12354854f, -0.05487684f, 0.02528459f, 0.11556019f, 0.14683534f, -0.04527169f, 0.21540534f, -0.05956373f, 
    -0.11122707f, 0.18686275f, 0.02760327f, 0.06255102f, -0.21425964f, -0.05034398f, 0.19187644f, 0.03328786f, 
    -0.02984648f, -0.05219747f, -0.05763387f, -0.15608564f, 0.02286055f, 0.03166617f, -0.10929400f, 0.18967742f, 
    0.09276660f, 0.00373560f, 0.40553287f, -0.03901311f, 0.01947040f, 0.11873069f, -0.04531458f, 0.00976475f, 
    -0.12100390f, -0.03734184f, 0.11845752f, 0.03462711f, 0.28154758f, 0.11925256f, 0.00564286f, 0.13337180f, 
    0.08674987f, -0.08678889f, -0.01978457f, 0.12456436f, -0.00736984f, 0.15651692f, 0.03199673f, -0.08758799f, 
    0.03562757f, -0.26429209f, -0.38724050f, 0.00910551f, -0.14435071f, -0.03470562f, -0.37347245f, 0.07115255f, 
    0.09776693f, -0.10966470f, -0.26357409f, -0.18237485f, -0.04483821f, 0.10688247f, 0.13862383f, -0.21646768f, 
    0.07380148f, 0.24574749f, -0.00755437f, -0.08024879f, 0.01198636f, 0.01662697f, -0.72279692f, 0.58325124f, 
    0.64482433f, -0.03641940f, 0.29370701f, 0.26873919f, -0.05442818f, 0.20564580f, 0.20371045f, 0.11398409f, 
    0.07860637f, -0.17620412f, 0.01663869f, -0.46129176f, 0.05992123f, 0.00748817f, 0.30315873f, -0.02723321f, 
    0.14666456f, 0.10289017f, -0.08851229f, 0.04158979f, 0.18203034f, -0.03451996f, 0.03661828f, 0.02817301f, 
    -0.02082185f, -0.07653608f, 0.03711446f, 0.11925151f, -0.02529029f, 0.04988858f, 0.00933072f, -0.04034871f, 
    0.11248821f, 0.31735066f, 0.21132194f, -0.28253493f, -0.58477819f, -0.06768689f, 0.14279014f, -0.05949168f, 
    0.02031964f, -0.04229995f, 0.14176533f, 0.19649322f, 0.22612189f, 0.02313422f, -0.05035310f, 0.04756220f, 
    0.05078700f, 0.12075514f, 0.19296774f, 0.16086523f, -0.10144818f, -0.10161532f, 0.03143249f, 0.02022162f, 
    0.10093722f, 0.04411946f, 0.01124937f, -0.19055457f, -0.03229084f, -0.35473052f, -0.27703798f, -0.12951134f, 
    -0.03727570f, 0.06988236f, -0.07612201f, 0.09254761f, 0.04506694f, -0.09761161f, -0.00799534f, -0.26814154f, 
    -0.17902943f, 0.17030548f, 0.00778890f, 0.05853421f, 0.02741993f, 0.08521117f, 0.10378283f, -0.50760698f, 
    0.23707697f, 0.38037723f, -0.03428891f, 0.05570572f, 0.18305629f, -0.05087801f, 0.15210348f, 0.12639780f, 
    -0.20387140f, -0.61429733f, -0.11571091f, -0.14219815f, -0.16540681f, -0.32582644f, 0.07755098f, -0.00178176f, 
    -0.00773286f, -0.20490567f, -0.31860358f, -0.06721532f, -0.11083074f, 0.09371337f, 0.07849991f, 0.06407272f, 
    -0.04222238f, 0.06328312f, 0.00406285f, -0.17029588f, 0.34778562f, 0.16654100f, 0.27066341f, 0.29313505f, 
    -0.06588678f, -0.02913327f, 0.00295482f, 0.03159693f, 0.02688877f, -0.07329653f, 0.13958457f, 0.21894498f, 
    0.06989561f, 0.08486132f, 0.05366315f, -0.08699559f, -0.01576732f, -0.12409286f, 0.21626081f, -0.02523012f, 
    -0.09434143f, -0.08382060f, -0.08306056f, 0.16620632f, 0.10501417f, 0.21254240f, 0.07294665f, 0.00542284f, 
    -0.16936240f, -0.05356261f, 0.02628854f, 0.18505105f, 0.12154717f, 0.01917631f, 0.12958708f, 0.21349077f, 
    0.28986987f, -0.06245257f, 0.05248453f, -0.08239532f, 0.09760422f, 0.23599149f, 0.19270025f, 0.27723947f, 
    -0.30443263f, 0.17567515f, -0.05711344f, -0.26207972f, -0.10637505f, -0.28309751f, 0.26358458f, 0.15241128f, 
    -0.07310127f, -0.33241010f, -0.26977375f, 0.07249662f, 0.04483009f, -0.21827133f, 0.04150579f, -0.21451339f, 
    -0.03854022f, 0.24691093f, -0.48919192f, -0.41477588f, 0.04676488f, 0.15694559f, -0.16238002f, 0.12287351f, 
    -0.01343280f, -0.06667178f, 0.02224878f, -0.00167372f, 0.22199988f, 0.09625021f, 0.03070950f, 0.19794801f, 
    -0.03127727f, 0.02772219f, 0.26550204f, 0.06051376f, 0.06864575f, -0.01852369f, -0.10366669f, 0.03197427f, 
    -0.04188044f, 0.12003809f, 0.17615409f, 0.12280411f, 0.63503850f, 0.18169968f, -0.17579614f, -0.04015896f, 
    -0.05187405f, 0.12441385f, -0.05725336f, 0.07549907f, -0.02195903f, 0.47358438f, 0.05558703f, 0.56990272f, 
    -0.16182774f, 0.10191241f, -0.00207804f, 0.06436223f, 0.10525391f, 0.10807216f, -0.12184054f, 0.03667834f, 
    0.38003463f, 0.03618366f, 0.05493914f, 0.04570773f, -0.03566036f, 0.10188588f, 0.14966911f, -0.00454814f, 
    0.08330534f, -0.05176327f, -0.00742404f, 0.08546146f, -0.05783628f, 0.02744367f, -0.15540679f, 0.07720740f, 
    0.09859735f, 0.10482621f, -0.00159040f, -0.00917932f, 0.05269320f, -0.10015987f, 0.06004994f, 0.05078157f, 
    0.10774162f, -0.32429957f, 0.05875703f, 0.19478597f, 0.01026429f, -0.02724124f, 0.00824420f, -0.05897659f, 
    0.10434785f, -0.15068422f, 0.17814365f, 0.09156667f, 0.13372409f, 0.06877638f, -0.01866145f, 0.01363865f, 
    0.09916592f, 0.00445145f, 0.19588065f, -0.01827724f, 0.00610927f, 0.17133979f, -0.31353205f, -0.05330678f, 
    -0.08336844f, 0.05596263f, 0.06988109f, -0.11588457f, -0.03974343f, -0.02927646f, 0.32508710f, 0.13774303f, 
    0.32020667f, 0.31130528f, -0.08764852f, 0.06969681f, 0.21425478f, -0.09634858f, 0.00007560f, 0.08051088f, 
    -0.03164199f, 0.01216449f, 0.12201125f, 0.17456500f, 0.00290174f, 0.02678247f, -0.08574910f, -0.77878791f, 
    -0.20719615f, -0.24722210f, -0.03875304f, -0.33473152f, 0.10972582f, -0.10642541f, 0.26783174f, -0.01524660f, 
    -0.18324107f, -0.13302676f, -0.07680824f, 0.16914357f, -0.05436014f, 0.14868355f, -0.00265701f, 0.10831523f, 
    0.12147611f, -0.28934032f, 0.13954777f, -0.21869369f, 0.11569472f, -0.48434669f, -0.00717145f, 0.06774265f, 
    0.03690842f, 0.09188456f, 0.17248262f, -0.25001365f, 0.15626396f, -0.19213493f, 0.18675664f, -0.05375236f, 
    0.13928729f, -0.14716241f, 0.58576703f, 0.15084979f, -0.17424776f, -0.11804128f, -0.23188369f, -0.08231664f, 
    -0.43128234f, 0.05013176f, 0.17865519f, 0.12024714f, 0.02672029f, 0.00986355f, -0.02881698f, -0.02117530f, 
    -0.19510545f, 0.16073158f, 0.10418085f, 0.07625031f, 0.18216880f, -0.08880894f, 0.25108111f, -0.30164570f, 
    -0.17483540f, -0.03953639f, -0.04063988f, 0.03831909f, 0.15998472f, -0.12313727f, 0.12895343f, 0.29139736f, 
    0.10904057f, 0.06337976f, -0.15426102f, -0.02970176f, 0.05034136f, 0.04848574f, 0.05449612f, 0.16513473f, 
    0.00027936f, -0.00974333f, -0.05642289f, 0.00369729f, -0.00401390f, 0.00956782f, -0.04689695f, -0.30732557f, 
    0.22163796f, -0.03973770f, -0.01667002f, 0.07600352f, -0.16529186f, -0.00506869f, 0.31427503f, 0.17247637f, 
    -0.60762596f, -0.10705123f, 0.65960896f, -0.03065636f, -0.08379091f, -0.09056623f, -0.03488398f, -0.13861889f, 
    0.04355033f, 0.04002468f, -0.07985335f, -0.03398334f, -0.32694650f, -0.06828373f, -0.00809281f, -0.08408032f, 
    -0.10284456f, 0.08370532f, 0.01177803f, -0.11960831f, -0.10748772f, 0.02465480f, -0.06925573f, 0.27453008f, 
    -0.07678708f, 0.19143774f, 0.00872919f, -0.23752372f, -0.18584320f, -0.14340691f, -0.18051706f, -0.17079601f, 
    -0.08044690f, 0.02835623f, 0.13358338f, 0.08321515f, 0.22347116f, -0.43493843f, 0.02769862f, 0.02530005f, 
    -0.15861028f, -0.07269739f, 0.16679601f, -0.20099752f, -0.11450162f, 0.02052961f, 0.20343627f, -0.15383059f, 
    0.02315404f, 0.04896852f, -0.10798879f, -0.52664822f, 0.25627023f, -0.04338868f, -0.06423098f, 0.04269806f, 
    -0.15876959f, -0.05623379f, 0.03038767f, -0.16220905f, 0.38288528f, 0.26944968f, -0.01006704f, 0.05351802f, 
    0.04132286f, -0.01869611f, -0.15438363f, 0.10849261f, 0.09923097f, -0.00621074f, 0.14560492f, 0.08182511f, 
    0.05013339f, 0.02546718f, 0.40683877f, -0.26715353f, 0.02635563f, -0.05533228f, 0.01562264f, -0.00240832f, 
    0.12302507f, 0.15904367f, -0.03454354f, -0.06601222f, -0.27746925f, 0.57279289f, 0.02965628f, -0.02726104f, 
    0.19300807f, -0.03040748f, 0.05557027f, -0.11866854f, -0.06880639f, -0.03529321f, -0.16760388f, -0.02428425f, 
    0.11631617f, 0.25295639f, 0.27019921f, 0.15480128f, 0.01436455f, 0.16888981f, -0.28277391f, 0.09807736f, 
    -0.18114808f, -0.04558545f, 0.37194607f, 0.00008355f, -0.31251723f, -0.27098131f, -0.09751447f, 0.10827184f, 
    -0.02021126f, -0.13168775f, 0.08629273f, 0.05051214f, -0.11816490f, -0.12781075f, 0.01920837f, 0.16167307f, 
    0.05246544f, 0.17060710f, -0.00215699f, -0.10041710f, 0.09791303f, 0.02354979f, 0.03293729f, -0.19432873f, 
    0.21397506f, -0.03022054f, -0.11322371f, -0.14476864f, 0.13449261f, -0.06300922f, 0.10288469f, 0.07394256f, 
    0.07684550f, 0.01995536f, -0.24298625f, -0.10206033f, -0.05067872f, 0.00659332f, 0.17632413f, 0.07665917f, 
    -0.02266684f, 0.09588269f, -0.07635362f, -0.13598914f, -0.00623863f, 0.09425545f, -0.06727667f, 0.05038164f, 
    0.00725284f, 0.13009959f, 0.35527334f, 0.32484534f, 0.02270667f, 0.09402712f, 0.05395783f, 0.19270688f, 
    -0.09200046f, -0.03259458f, -0.72563565f, -0.19402167f, 0.31690714f, -0.07771503f, -0.03524633f, -0.09710751f, 
    0.08529085f, -0.24127777f, -0.05234875f, -0.12155833f, -0.09461802f, 0.03323926f, -0.07604519f, -0.12495279f, 
    -0.10521420f, 0.23661134f, -0.00512612f, -0.02814623f, 0.09468741f, -0.22724105f, -0.17008655f, 0.02742282f, 
    -0.08549587f, 0.13455446f, 0.03593231f, 0.17126665f, 0.03742991f, 0.00130065f, 0.12181747f, 0.00685455f, 
    -0.15981892f, 0.24628775f, -0.05057849f, -0.01060181f, 0.06057946f, 0.26087242f, 0.23044328f, 0.12280419f, 
    0.23721841f, -0.23297243f, 0.40244931f, -0.07012016f, -0.07201605f, 0.21692993f, 0.05771882f, 0.19054304f, 
    0.10950193f, -0.05985701f, -0.34917438f, -0.21776183f, -0.06566032f, -0.20334059f, 0.19428401f, -0.04382285f, 
    -0.50240684f, 0.14795269f, -0.35038558f, 0.15268856f, 0.26117963f, -0.05473141f, 0.19707359f, 0.32407537f, 
    -0.04114447f, -0.17603928f, 0.09497890f, 0.26117870f, -0.10029940f, 0.18242653f, -0.09116944f, -0.07414778f, 
    -0.05401357f, -0.06313148f, -0.30584484f, 0.64532948f, 0.54078466f, -0.09322987f, -0.36918634f, 0.08730841f, 
    -0.01240528f, 0.11453330f, 0.13813689f, -0.11429589f, -0.33008847f, -0.32380632f, 0.09081733f, 0.05580700f, 
    0.04719198f, 0.23273163f, -0.04683451f, 0.26028043f, 0.06505631f, 0.16183335f, -0.24532007f, 0.11232994f, 
    0.06206315f, -0.09476388f, 0.04865007f, 0.16617253f, 0.23839287f, -0.00661646f, -0.04241730f, 0.23117727f, 
    -0.15288767f, 0.07680582f, -0.16147640f, -0.02852103f, -0.11651116f, -0.34638050f, 0.40406415f, -0.17820360f, 
    0.22662458f, 0.27836913f, -0.03565813f, 0.02571025f, 0.11497351f, 0.10367628f, -0.25167289f, 0.11173239f, 
    0.29489490f, -0.05738880f, 0.11308103f, -0.07044443f, -0.28158519f, 0.02507949f, 0.12904505f, 0.07823576f, 
    0.04549290f, -0.05146500f, -0.03464148f, -0.21561258f, -0.02469490f, 0.01150639f, -0.25248799f, -0.10321488f, 
    -0.06932606f, -0.38908261f, -0.06946893f, 0.02264287f, 0.17598779f, -0.08748271f, 0.10693981f, 0.14901966f, 
    -0.08804317f, -0.01407270f, 0.02614147f, 0.13409027f, 0.08891048f, 0.17687753f, 0.17201105f, 0.07135215f, 
    0.10562670f, 0.12494048f, 0.22454198f, 0.37914661f, 0.24212390f, -0.34578428f, 0.02882531f, -0.14275642f, 
    -0.26723850f, 0.02258682f, 0.22743136f, -0.15087192f, -0.01710789f, 0.02493944f, -0.01747140f, -0.06889131f, 
    0.01009284f, 0.06026807f, 0.08416540f, -0.04907418f, -0.14152086f, -0.18163045f, -0.11214089f, 0.22690839f, 
    -0.13133384f, 0.15784521f, 0.07740786f, -0.04119846f, -0.21996640f, 0.11488456f, 0.30555534f, 0.14014198f, 
    0.12660655f, 0.11850800f, 0.32210898f, -0.09991355f, 0.06263912f, 0.15934053f, 0.21330442f, 0.65071726f, 
    -0.04421303f, -0.62280762f, 0.30516025f, -0.25296184f, 0.12287710f, 0.10975353f, -0.07283266f, -0.29923856f, 
    0.18050602f, -0.14017776f, 0.28646922f, -0.17887647f, -0.02174190f, -0.03986638f, -0.19668959f, -0.22119461f, 
    -0.24217185f, -0.07431781f, 0.35330623f, -0.60923058f, 0.05618081f, -0.03029525f, -0.10821348f, -0.07849289f, 
    0.04299781f, 0.00014063f, -0.11010183f, 0.03641655f, 0.29442066f, 0.03777513f, 0.03298754f, 0.19072230f, 
    -0.03683800f, -0.11067980f, 0.08980509f, 0.30592531f, 0.06866246f, 0.03451165f, 0.36013681f, 0.15138488f, 
    -0.07559172f, 0.15227708f, -0.24434589f, -0.10414819f, -0.17526576f, -0.58967268f, -0.62413687f, 0.10093431f, 
    -0.15585876f, -0.14044623f, 0.04776664f, 0.19565023f, -0.05188050f, -0.16188036f, 0.12462738f, 0.22400890f, 
    -0.04396059f, -0.17752914f, -0.06810659f, -0.22915205f, -0.09494147f, -0.14807536f, -0.00241299f, -0.12362716f, 
    -0.06478453f, 0.01437968f, -0.08168123f, -0.01390758f, 0.11783428f, -0.17065705f, -0.17294453f, -0.14991932f, 
    -0.01308518f, -0.22550853f, -0.24656452f, -0.00181802f, 0.03058933f, -0.05542110f, 0.04753080f, -0.09570429f, 
    -0.30983907f, -0.35022137f, 0.25273794f, 0.06526583f, -0.06893040f, 0.12983467f, -0.20651145f, -0.12434926f, 
    -0.21844143f, 0.09196281f, 0.24339309f, -0.23798107f, -0.03824213f, 0.25845611f, 0.11667076f, 0.17731452f, 
    -0.01529353f, -0.10373031f, 0.02700479f, -0.02926779f, 0.04517435f, 0.14276977f, 0.07223742f, -0.12456927f, 
    0.19162412f, -0.07363322f, 0.13383050f, -0.08478991f, -0.15261894f, -0.40939835f, 0.01687599f, 0.07323036f, 
    -0.23854369f, 0.01022895f, 0.13334230f, -0.17244953f, -0.16633905f, 0.22540495f, 0.08081299f, 0.10320207f, 
    0.11351395f, 0.03761352f, -0.02594808f, 0.13574179f, 0.06465700f, 0.10894276f, 0.06886267f, -0.23473234f, 
    -0.05428373f, 0.03742293f, 0.10069497f, 0.11201614f, -0.09448728f, 0.16887234f, -0.09320881f, -0.24464937f, 
    -0.09535848f, -0.34110829f, 0.02761832f, 0.24828227f, -0.10289357f, -0.11263026f, 0.06952788f, -0.32609370f, 
    -0.47971252f, -0.57718956f, 0.00688096f, 0.17201270f, 0.10134106f, 0.14343256f, -0.01153714f, -0.14984493f, 
    0.00488757f, 0.01416103f, 0.03586679f, 0.15135354f, -0.20775241f, -0.42436025f, -0.06828120f, -0.08733951f, 
    0.09003448f, 0.56725329f, -0.37019962f, -0.35856768f, -0.07096440f, 0.03618079f, -0.15442593f, 0.24920155f, 
    -0.00304565f, 0.23072764f, 0.76373333f, 0.16578928f, -0.42327642f, 0.03446998f, 0.09301039f, -0.33734897f, 
    -0.23603892f, 0.21002290f, -0.20718949f, -0.05566385f, 0.14928229f, 0.18959679f, 0.03382578f, 0.07973383f, 
    -0.09113662f, 0.02779876f, -0.04178993f, 0.05045153f, 0.13506564f, -0.19753698f, 0.20310785f, 0.07493506f, 
    -0.09792297f, -0.23871098f, -0.02393628f, -0.04457008f, -0.10697407f, 0.31707716f, -0.29818442f, 0.05540819f, 
    0.09149011f, 0.10923273f, -0.09689858f, 0.08076794f, -0.07113805f, 0.18137118f, 0.87510812f, -0.01950335f, 
    -0.44958436f, -0.06996402f, -0.07692232f, -0.08014183f, 0.03726581f, -0.03631068f, 0.04957030f, 0.11058476f, 
    -0.67348671f, 0.04276986f, -0.13076724f, -0.03145140f, -0.10178656f, 0.18623605f, 0.07266343f, -0.10278427f, 
    0.36315247f, 0.18768753f, -0.07932155f, 0.04820779f, 0.04358725f, 0.11080422f, 0.06658245f, 0.19688672f, 
    0.21692283f, 0.24892892f, -0.16518787f, 0.08840450f, -0.01260510f, 0.22621936f, -0.03405655f, 0.15569583f, 
    -0.05579755f, 0.03150016f, 0.29025975f, -0.14992090f, 0.08453175f, -0.10127221f, -0.08087230f, -0.16030708f, 
    0.05799426f, 0.15623495f, -0.20944650f, -0.42052636f, -0.07333901f, 0.07884230f, 0.16525468f, -0.08440820f, 
    -0.24972261f, 0.00030967f, -0.12119001f, 0.12321917f, 0.18682142f, 0.04354480f, -0.40040675f, -0.03176113f, 
    -0.17855744f, 0.08075278f, 0.07512932f, 0.04913693f, -0.16861701f, 0.02571151f, 0.03204140f, 0.25358182f, 
    -0.04023378f, -0.05147013f, 0.09035137f, 0.02397861f, -0.05422572f, -0.01705815f, -0.19378492f, -0.08821357f, 
    0.04457996f, 0.09988794f, -0.10529013f, -0.10530265f, -0.06203574f, 0.17339595f, 0.02658951f, -0.80243671f, 
    0.15498064f, -0.00617395f, -0.03386174f, -0.27306974f, 0.23237824f, -0.06625231f, -0.09913137f, -0.04253343f, 
    0.40240690f, -0.12601528f, -0.33891460f, 0.14632051f, 0.04263442f, 0.10938083f, 0.14110446f, 0.10005699f, 
    0.18886876f, 0.27196455f, 0.02127600f, -0.21979924f, -0.00114238f, -0.01199405f, 0.16009939f, -0.11236577f, 
    0.10505641f, -0.26054403f, -0.00182773f, -0.12351483f, -0.18875100f, 0.04535037f, -0.11829858f, -0.05930377f, 
    -0.06311701f, 0.16613640f, 0.11912450f, -0.06900955f, 0.06736979f, 0.31189778f, -0.21276200f, -0.06549586f, 
    0.06830134f, -0.11986420f, 0.16643465f, -0.02919568f, -0.30567846f, 0.10803518f, -0.08519983f, 0.01231955f, 
    -0.09788101f, 0.04152892f, 0.12543610f, 0.20959945f, 0.33738530f, -0.34553197f, -0.12615247f, -0.17396511f, 
    0.08257709f, -0.01580619f, 0.02265520f, -0.11524095f, 0.08505942f, 0.08728225f, 0.28695291f, 0.18076819f, 
    -0.38533193f, -0.09630722f, -0.07469214f, 0.04726407f, 0.16757464f, 0.06815238f, -0.18501152f, -0.12773202f, 
    -0.19907595f, 0.25506821f, 0.18975666f, -0.01151490f, -0.12759981f, 0.19231912f, -0.02646719f, 0.10523025f, 
    -0.21813953f, 0.00276515f, 0.03797126f, -0.17007598f, 0.00567215f, 0.11683174f, 0.08576712f, -0.07686696f, 
    0.07944547f, -0.05278964f, -0.31355807f, -0.04318363f, -0.14118728f, -0.22677118f, 0.36511615f, -0.03048375f, 
    0.06648426f, 0.02605514f, 0.29644972f, 0.04408093f, -0.08667040f, -0.08691494f, 0.05936923f, 0.08833325f, 
    0.02520798f, -0.04405211f, -0.06249193f, -0.21522862f, -0.14725012f, -0.00623723f, -0.02770582f, -0.08206198f, 
    -0.02414864f, -0.35865435f, 0.08502121f, -0.36101067f, 0.24998987f, -0.60493207f, 0.02652266f, -0.19535014f, 
    -0.06341325f, -0.27210295f, 0.04099083f, 0.04492952f, 0.02332825f, -0.09088302f, -0.12757091f, 0.13522933f, 
    -0.17153890f, 0.09699556f, 0.12865704f, 0.27146786f, -0.01650826f, 0.05370537f, 1.05446208f, 0.31760892f, 
    -0.14134532f, -0.30799165f, 0.25532654f, 0.22643679f, 0.09519699f, -0.00646091f, 0.02848013f, -0.05071661f, 
    0.14041774f, 0.38654840f, -0.55476886f, -0.26587021f, -0.13209757f, 0.17499964f, 0.00087651f, 0.03202629f, 
    0.03077737f, -0.03210568f, 0.02066625f, -0.03509537f, -0.03496706f, 0.04849509f, 0.01746107f, -0.01473434f, 
    0.04817529f, 0.05566045f, -0.04009809f, 0.05386658f, 0.02291563f, 0.00865168f, 0.02462535f, 0.02929150f, 
    -0.02112731f, -0.02421395f, 0.04764575f, 0.05327805f, 0.00240023f, 0.02968726f, 0.02445512f, 0.03251773f, 
    -0.05199072f, -0.00822189f, 0.00586569f, 0.03072469f, -0.02806680f, 0.02120918f, 0.02681517f, 0.00802573f, 
    0.00218066f, 0.01741366f, 0.02823359f, -0.04719782f, -0.01863342f, -0.01557208f, 0.01725750f, 0.03033681f, 
    0.01405859f, -0.02074099f, -0.01605552f, -0.02911074f, 0.01440028f, 0.01352531f, 0.02962364f, 0.03680632f, 
    -0.02676631f, -0.04080613f, 0.01740278f, -0.02801579f, -0.00968360f, -0.02745019f, -0.04657364f, -0.04125222f, 
    0.03015049f, -0.00972369f, 0.05315939f, -0.02592441f, 0.03008340f, -0.02724691f, -0.03046100f, -0.00291672f, 
    0.01208468f, 0.03920333f, -0.01320115f, 0.02077779f, -0.01639478f, 0.01082935f, -0.07048426f, 0.03264675f, 
    -0.00378479f, -0.02739879f, -0.01458049f, -0.00745255f, 0.02676684f, 0.00556315f, 0.04321265f, 0.00288427f, 
    -0.05788914f, -0.05286662f, -0.01448400f, -0.04119573f, 0.00594771f, 0.04717410f, 0.05345091f, 0.05632973f, 
    -0.04618650f, -0.02447984f, -0.02540089f, -0.03978090f, 0.02129951f, -0.04659241f, -0.05276940f, -0.05757955f, 
    0.04594189f, -0.02204061f, -0.00201569f, 0.02962784f, 0.01003413f, -0.03390605f, 0.01110019f, -0.04961422f, 
    -0.01582581f, 0.03072613f, 0.01789014f, -0.01184405f, 0.02158022f, -0.03953468f, -0.04284990f, 0.02638427f, 
    0.04629317f, 0.01600257f, 0.04560677f, -0.05694298f, -0.04720357f, -0.00197894f, -0.06007244f, -0.02043573f, 
    0.02560901f, -0.03032176f, 0.02589147f, 0.04810111f, -0.03081460f, -0.05624203f, -0.05116903f, 0.01582139f, 
    -0.06592149f, -0.03727500f, -0.06384454f, 0.02221404f, -0.00072483f, -0.06319634f, -0.00544859f, -0.01179879f, 
    -0.05075752f, -0.01063303f, 0.00929124f, -0.06109182f, -0.02658984f, 0.02899700f, -0.04305093f, -0.05224682f, 
    0.03523923f, 0.05387113f, -0.05626602f, -0.06089466f, 0.00589575f, -0.05099855f, -0.01742797f, -0.04454892f, 
    0.01257628f, -0.03917548f, -0.00454803f, 0.03497116f, -0.03400384f, 0.03811278f, 0.04527675f, -0.02950598f, 
    0.01119798f, 0.01166164f, -0.03578305f, -0.02337250f, -0.01696843f, 0.03728208f, -0.03702275f, -0.07067533f, 
    -0.00903746f, 0.05621610f, 0.00991553f, -0.01126778f, -0.01763485f, -0.03608045f, 0.01662377f, 0.04945836f, 
    -0.04701899f, -0.04317472f, -0.02572337f, -0.00235207f, 0.04472245f, 0.02401943f, 0.01974421f, -0.02548683f, 
    -0.00893397f, 0.03253181f, -0.05673485f, -0.04799773f, 0.01894341f, 0.00100177f, -0.01669504f, -0.05561071f, 
    -0.00743251f, -0.04280058f, -0.01905802f, 0.02453454f, -0.02575979f, -0.05743914f, -0.00224046f, -0.05260194f, 
    -0.04456324f, 0.02821239f, 0.05378526f, 0.02766139f, -0.03736576f, 0.05630887f, -0.04089449f, -0.05244267f, 
    0.01511926f, 0.01232455f, 0.04359558f, -0.03982833f, 0.00222593f, -0.04698169f, -0.01783693f, 0.03950457f, 
    -0.00014061f, -0.02591579f, 0.03924257f, -0.02445816f, -0.01349549f, -0.02636025f, 0.03102660f, -0.05222429f, 
    -0.04762757f, -0.06674144f, 0.03689586f, -0.06595071f, 0.04037457f, -0.01807946f, 0.02003173f, -0.00259859f, 
    -0.00015212f, -0.03308400f, 0.02289361f, 0.00814030f, 0.02391483f, 0.04249275f, -0.02223914f, -0.02334419f, 
    -0.03729824f, -0.02307258f, -0.02153363f, -0.05638640f, -0.03148339f, -0.00451562f, 0.02435161f, 0.03322068f, 
    0.02421457f, 0.04368298f, -0.04750744f, 0.04276613f, 0.00321356f, -0.00846641f, 0.03374522f, -0.01683965f, 
    -0.03027507f, -0.01507729f, -0.04989185f, -0.02803016f, -0.01975106f, -0.03061310f, -0.02812918f, -0.00900251f, 
    0.02983036f, -0.01619879f, -0.06662355f, 0.01691196f, -0.01971444f, 0.04010834f, 0.00159362f, 0.03063789f, 
    0.02501445f, 0.03589203f, -0.00074345f, 0.05784156f, 0.02163802f, 0.01688109f, -0.05439983f, -0.00338547f, 
    0.02689235f, -0.01190645f, -0.02223927f, -0.03367484f, -0.02674023f, 0.03699213f, -0.05086307f, -0.03930099f, 
    -0.00992463f, 0.00325160f, 0.00987614f, -0.05499201f, -0.03957655f, -0.06172927f, 0.01922593f, 0.03335527f, 
    -0.03478944f, -0.02616971f, 0.00497014f, 0.02175210f, 0.01003450f, 0.00639320f, -0.02878262f, 0.00085909f, 
    0.03738184f, 0.00152255f, -0.01596883f, -0.04485188f, 0.03604462f, -0.06486497f, -0.04611154f, 0.01144115f, 
    0.01030535f, 0.02385736f, -0.04314945f, 0.02910218f, 0.02775062f, 0.03892263f, 0.01257535f, 0.04015905f, 
    0.04519517f, -0.03186565f, -0.03989699f, -0.02019660f, 0.01311750f, 0.03496140f, -0.06530351f, 0.03624541f, 
    -0.02530140f, 0.03726961f, -0.02370630f, -0.02751013f, 0.00212679f, -0.02745367f, -0.06209487f, -0.04381638f, 
    -0.02720655f, 0.00167590f, -0.06663243f, -0.00843027f, -0.02949042f, 0.01229568f, 0.04535771f, 0.00916545f, 
    -0.07135583f, 0.03845175f, -0.01429086f, 0.00609068f, -0.05453751f, -0.03335885f, -0.03006572f, -0.02361279f, 
    0.00821435f, -0.01418897f, -0.06100905f, -0.05584616f, -0.04166253f, -0.00319661f, -0.00288992f, 0.04964947f, 
    0.02088567f, 0.01381061f, -0.03426683f, -0.02523810f, -0.00429603f, -0.00690140f, 0.03650679f, 0.02396996f, 
    -0.02843755f, -0.04853439f, -0.01196538f, -0.05562270f, 0.00330631f, -0.02908385f, -0.04020413f, 0.03310730f, 
    -0.00005805f, 0.03693379f, -0.05893069f, -0.01627722f, 0.01316636f, 0.01359837f, 0.00152437f, -0.05219558f, 
    0.00542920f, 0.04188366f, -0.01246041f, -0.03105866f, 0.00328755f, -0.05539674f, 0.04133574f, 0.04386052f, 
    -0.03863763f, -0.02499943f, 0.02368980f, -0.04253210f, 0.01856414f, -0.05715260f, -0.06872746f, -0.06194610f, 
    0.03083861f, -0.02889010f, 0.04047234f, -0.02657118f, 0.00151421f, -0.06534325f, 0.04120266f, -0.04261436f, 
    0.03774413f, -0.00947086f, -0.04358310f, -0.02975216f, 0.00490432f, 0.00502511f, 0.02386020f, -0.03023328f, 
    -0.03755980f, 0.02565618f, -0.03458597f, -0.05356291f, -0.00213719f, 0.04175223f, 0.00170660f, -0.05975340f, 
    0.02662644f, -0.03853579f, -0.05252045f, -0.01033579f, 0.04248191f, 0.03416033f, -0.01992286f, -0.00448871f, 
    -0.05157043f, -0.06254695f, 0.02911634f, 0.03830430f, -0.05088069f, -0.06045031f, 0.00074012f, 0.02373029f, 
    0.00127494f, 0.01433586f, 0.03632713f, -0.01557279f, 0.04684418f, -0.00264087f, -0.06516181f, 0.00313687f, 
    -0.03625626f, 0.00806624f, -0.02813183f, 0.00435331f, -0.00749287f, -0.06376531f, -0.03365942f, -0.04057077f, 
    -0.06755197f, 0.00059425f, -0.02333999f, 0.00449376f, 0.03252503f, 0.00810123f, -0.02415970f, -0.02866581f, 
    -0.02272220f, -0.01390106f, -0.04973706f, -0.06961896f, 0.00144693f, -0.02165266f, -0.05255503f, -0.00076666f, 
    0.03035253f, -0.00766363f, 0.01851501f, 0.04117852f, 0.04644597f, -0.00867279f, -0.01975201f, 0.00270773f, 
    -0.04968819f, -0.03881475f, -0.03974025f, 0.03193432f, 0.01503019f, -0.03626930f, -0.05525208f, -0.02928730f, 
    -0.03283891f, -0.03036016f, -0.06447833f, 0.04632985f, -0.06267035f, 0.03871901f, -0.03841204f, -0.03553673f, 
    -0.01843792f, 0.01740445f, -0.04861757f, -0.04904012f, -0.05376686f, 0.01220191f, -0.01097299f, 0.02280936f, 
    -0.03447363f, -0.00944511f, -0.03442325f, 0.00438156f, 0.00221822f, -0.03487024f, 0.00998933f, -0.05063974f, 
    0.03891742f, -0.02207363f, -0.05992686f, -0.05846060f, -0.03978994f, -0.06656176f, -0.00336732f, -0.05305754f, 
    0.01686340f, 0.01039104f, -0.06403561f, -0.01230704f, 0.01753735f, -0.03455802f, 0.03021096f, -0.05942042f, 
    0.04300148f, 0.04463825f, -0.05030709f, -0.02807413f, 0.03319418f, 0.01407947f, 0.00526811f, 0.02828518f, 
    0.01872543f, -0.02805183f, -0.02943843f, 0.03304354f, -0.06024010f, -0.05072715f, 0.02407486f, -0.00294328f, 
    -0.04066402f, -0.03743710f, -0.02270197f, 0.02891125f, 0.00269006f, -0.02649715f, 0.04562722f, 0.04460808f, 
    -0.02531905f, -0.02028948f, 0.00649597f, -0.02882193f, -0.05217448f, 0.02384728f, -0.04803723f, -0.00197372f, 
    -0.00388035f, -0.02406975f, 0.03692904f, 0.01522493f, 0.04512254f, 0.03019921f, -0.06717125f, 0.02548862f, 
    0.03195086f, 0.03250419f, -0.00400386f, -0.01289731f, -0.05391097f, -0.04051488f, -0.01938380f, -0.02889123f, 
    0.08404744f, -0.24108826f, 0.23098408f, -0.26094946f, -0.09160511f, -0.11360273f, -0.03282817f, -0.05236400f, 
    0.12739776f, 0.32616362f, 0.02000411f, 0.14618683f, -0.05846754f, -0.07961626f, -0.14104411f, 0.21844114f, 
    -0.09357284f, 0.08623917f, -0.92362267f, -0.34713823f, -0.35332662f, -0.36970073f, 0.00303722f, -0.17048246f, 
    0.26462218f, -0.01292852f, -0.05973883f, -0.20626467f, -0.25416273f, -0.06581250f, 0.03293404f, -0.04071244f, 
    -0.07243980f, 0.10101283f, 0.09168122f, -0.09553535f, 0.46580392f, -0.83992285f, -0.40262944f, -0.17856286f, 
    -0.12993711f, 0.13066909f, 0.11951035f, 0.08795349f, 0.08790347f, 0.28958142f, 0.43211019f, 0.36959288f, 
    -0.10883598f, -0.05114366f, -0.09701332f, 0.16813150f, 0.02838621f, 0.11119054f, 0.29371312f, 0.28832611f, 
    0.26536742f, -0.24313790f, -0.06017007f, 0.28042263f, 0.14444044f, -0.03993280f, 0.02361458f, -0.07099815f, 
    -0.79463297f, -0.67907500f, -0.09416545f, -0.01742307f, -0.04688378f, 0.08242494f, -0.06845582f, -0.06623767f, 
    0.43631431f, 0.32916638f, 0.20014448f, -0.39601257f, 0.07472797f, -0.24026893f, -0.01901036f, -0.07545619f, 
    0.12430740f, 0.18026869f, -0.16255638f, -0.31826332f, -0.00501776f, -0.11867389f, 0.03634330f, 0.05945072f, 
    0.22032955f, -0.11995193f, 0.34447601f, -0.12149546f, 0.03221191f, -0.00783336f, 0.00341450f, 0.28917700f, 
    -0.01873707f, 0.10683981f, -0.10736824f, -0.19013238f, -0.25695693f, 0.26116979f, -0.15782526f, -0.05493539f, 
    -0.18164082f, 0.21028441f, 0.26125962f, 0.03309610f, 0.17656597f, 0.35056373f, 0.49826083f, -0.06916744f, 
    0.13193336f, 0.28291866f, 0.14106534f, 0.04724671f, -0.04200765f, -0.58255982f, -0.52837127f, -0.00127764f, 
    -0.02189454f, -0.01718645f, -0.09318146f, -0.15297340f, 0.18288888f, -0.00438710f, 0.24449964f, -0.07369918f, 
    0.32788748f, -0.04478140f, -0.04322217f, -0.00357505f, 0.07772963f, 0.03370668f, -0.00261662f, -0.17400746f, 
    -0.64325792f, -1.51700473f, -0.13861968f, -0.15157713f, 0.16704929f, 0.12407892f, 0.00788596f, -0.07404555f, 
    0.15773694f, 0.16155428f, 0.28630066f, -0.13322124f, 0.13091102f, -0.07865942f, 0.13960020f, 0.18810496f, 
    0.16077100f, -0.38609019f, -0.31402433f, -0.49888882f, -0.22878046f, -0.01996387f, 0.22553568f, 0.22960798f, 
    0.01861942f, 0.02926158f, -0.03296776f, 0.07683299f, 0.50857663f, 0.16861837f, 0.02776450f, 0.15975040f, 
    0.14583607f, -0.05403627f, 0.00311674f, 0.08610021f, -0.11080822f, 0.13440330f, -0.04370808f, -0.12529369f, 
    -0.16941813f, 0.11503716f, -0.18400085f, 0.02517297f, -0.44421211f, -0.64567626f, -0.28243914f, -0.08595964f, 
    -0.13121396f, -0.09816763f, 0.05059404f, 0.07698250f, -0.01186802f, -0.09583834f, -0.23964478f, -0.10613038f, 
    0.06480927f, -0.11049021f, -0.10589784f, 0.04220390f, 0.00123291f, -0.00824084f, 0.31983709f, 0.23841226f, 
    0.54325670f, -0.05636556f, 0.16270663f, 0.23071480f, 0.15083876f, 0.02578234f, -0.04312498f, -0.17069200f, 
    -0.17563766f, -0.16383606f, -0.12589942f, -0.02709734f, -0.02504471f, 0.16166149f, 0.23320930f, 0.11125741f, 
    0.25704622f, -0.10678337f, -0.13695759f, 0.16761130f, 0.23074892f, 0.04186241f, 0.48057631f, 0.20941159f, 
    0.46874800f, 0.24664046f, 0.30140993f, -0.36870587f, -0.14097010f, 0.04602552f, 0.02014916f, 0.05185213f, 
    0.15241569f, -0.18937287f, 0.27176538f, 0.13901162f, 0.20092306f, -0.06265887f, 0.12014741f, -0.12320918f, 
    -0.05084281f, -0.12995049f, -0.05100907f, -0.44036126f, -0.83663011f, 0.01420552f, 0.08336359f, 0.03952017f, 
    0.00712458f, 0.09689908f, 0.01785979f, -0.10596946f, 0.27929154f, -0.12578481f, -0.19486660f, 0.03902133f, 
    0.12764901f, 0.21867940f, 0.07066765f, -0.01645984f, 0.00386734f, -0.14529198f, -0.20372352f, -0.49763373f, 
    -0.06230129f, 0.07057908f, 0.10088375f, 0.02590251f, -0.00847405f, 0.01256107f, -0.41821724f, 0.14960012f, 
    0.20919777f, -0.32776329f, 0.00095858f, 0.04693192f, 0.03764163f, 0.31345397f, -0.01390040f, 0.06592007f, 
    0.30563718f, -0.30845603f, -0.13414578f, -0.26271763f, 0.01065978f, 0.34652898f, 0.23439401f, 0.13280813f, 
    -0.04378193f, -0.02637650f, -0.03617377f, 0.04636469f, -0.03957109f, 0.02228087f, -0.04654523f, -0.06941346f, 
    0.01617369f, -0.03712857f, -0.05293979f, -0.05820998f, -0.04770398f, -0.03421336f, 0.05782306f, 0.02867118f, 
    0.04176614f, 0.00044407f, -0.04642523f, 0.04622650f, 0.02715618f, 0.01737491f, -0.03445457f, 0.02253200f, 
    0.01776835f, -0.03029170f, -0.03427417f, 0.02311463f, 0.04343086f, -0.00729728f, -0.03566949f, -0.06851798f, 
    0.03910764f, -0.02719143f, 0.03981973f, -0.02414511f, 0.03422631f, 0.04412238f, 0.05065707f, -0.05409352f, 
    -0.00055912f, -0.04740835f, 0.00227933f, 0.01702812f, -0.01760828f, -0.01217267f, 0.00569426f, 0.01962857f, 
    -0.01906314f, -0.05701895f, -0.02181735f, 0.03330779f, -0.03348823f, -0.01284480f, 0.03800469f, 0.02167629f, 
    -0.06141527f, -0.04221947f, 0.04300923f, -0.01002110f, -0.01527423f, -0.01121867f, 0.02504568f, 0.04639090f, 
    -0.02853400f, -0.02389283f, -0.01210914f, -0.06090192f, -0.05076552f, -0.02526948f, -0.03877461f, -0.05277159f, 
    -0.02570093f, -0.06594186f, -0.04654794f, 0.02679814f, -0.02569044f, -0.01071959f, 0.05092034f, 0.04536888f, 
    -0.02984742f, -0.05482669f, 0.01743338f, -0.04488440f, 0.02054778f, -0.07096026f, -0.04272442f, 0.00954406f, 
    0.00350886f, 0.00698247f, 0.00650673f, -0.00892908f, 0.02610397f, -0.03465601f, -0.00343430f, -0.05953256f, 
    0.05143845f, 0.01461698f, -0.04632423f, 0.01299842f, -0.05919594f, 0.00396099f, 0.00577762f, -0.00853949f, 
    0.00575875f, 0.01327308f, -0.02314552f, -0.04986137f, 0.01006725f, -0.06478309f, -0.04209820f, 0.01882979f, 
    0.01384319f, -0.01223878f, -0.04076932f, -0.05970462f, 0.04941531f, 0.03070099f, -0.01181852f, 0.00618204f, 
    -0.01222542f, 0.03614428f, -0.00657362f, -0.02907682f, 0.03420113f, 0.03900698f, -0.02756280f, -0.01725200f, 
    0.01887920f, -0.02004152f, -0.00288934f, -0.00915367f, -0.04614593f, 0.04421183f, -0.00826064f, -0.04280436f, 
    0.05113769f, -0.00855070f, -0.01769966f, 0.02365302f, -0.04137342f, -0.01788265f, 0.04073303f, -0.01309662f, 
    -0.01608860f, 0.00949144f, 0.00126787f, 0.01376737f, -0.02623673f, -0.06649441f, 0.00787719f, -0.03481419f, 
    0.04600221f, -0.02710828f, -0.05117330f, -0.03225060f, 0.02835874f, -0.03440664f, 0.04023086f, -0.05266474f, 
    0.01694946f, -0.02009554f, 0.00315087f, -0.06531861f, -0.05121025f, 0.01501381f, -0.03610659f, 0.03168565f, 
    0.04406012f, -0.01826161f, 0.03102226f, 0.03716266f, -0.02696330f, 0.03616026f, 0.02197189f, -0.02528657f, 
    -0.06672769f, -0.04348467f, -0.02141597f, -0.05343442f, -0.00689805f, 0.02816223f, -0.00538245f, -0.06121279f, 
    -0.04168824f, 0.02327872f, 0.03290754f, -0.06607200f, -0.00334144f, -0.03462425f, -0.05588700f, -0.00406577f, 
    0.02148094f, -0.05075226f, -0.04602025f, 0.00341048f, -0.00845398f, 0.00246822f, 0.04336546f, 0.02536664f, 
    -0.04385287f, 0.01812164f, -0.01968489f, 0.02064194f, -0.04453278f, -0.03285091f, -0.02290959f, 0.04374809f, 
    -0.02393992f, -0.04270093f, 0.04071556f, 0.02410986f, 0.03754599f, 0.01463022f, -0.05793042f, 0.00396953f, 
    -0.06609620f, -0.00144303f, 0.04358999f, 0.01494145f, 0.04450934f, -0.06508420f, -0.01611783f, -0.03570952f, 
    0.01667246f, 0.04855861f, 0.02717614f, -0.06991546f, -0.01906753f, 0.03704288f, -0.03735154f, 0.01453480f, 
    0.02076226f, -0.03113955f, -0.02239735f, -0.04904772f, 0.03829592f, 0.04724177f, 0.04958664f, -0.05636116f, 
    -0.00214780f, -0.06130394f, -0.03300462f, -0.05650743f, -0.03598272f, 0.01373467f, -0.03180880f, 0.00922947f, 
    -0.03022719f, 0.02122973f, -0.06246159f, -0.00413385f, 0.00947529f, -0.00869421f, 0.02937218f, 0.00415570f, 
    -0.01813566f, -0.01856900f, 0.05479796f, 0.00988171f, 0.00700043f, -0.03983964f, -0.00124472f, -0.02191367f, 
    0.00877259f, -0.00243627f, 0.04633901f, 0.00159374f, -0.05820823f, 0.01064413f, -0.00873298f, -0.01971208f, 
    -0.00145504f, 0.04366729f, -0.01403173f, -0.02187416f, 0.01012808f, 0.03244068f, 0.00619933f, -0.06605234f, 
    0.00109185f, -0.00272948f, 0.02184999f, -0.05176568f, 0.03475782f, -0.05483152f, 0.03686063f, 0.03435452f, 
    -0.08647685f, 0.10794079f, -0.13626774f, 0.22035375f, 0.12949856f, 0.17059138f, 0.12311664f, -0.05491948f, 
    0.19449097f, -0.18711938f, 0.14048566f, 0.07974375f, -0.06697679f, -0.09400325f, -0.17551896f, -0.11463411f, 
    -0.29358307f, -0.04764692f, 0.11855302f, 0.01634756f, -0.28117231f, -0.14681868f, -0.00927456f, 0.13867232f, 
    -0.19851582f, -0.12576675f, -0.56561238f, 0.06677899f, 0.06101726f, -0.09082309f, 0.14167222f, -0.14310957f, 
    0.00141300f, -0.22762026f, 0.04378089f, -0.06733675f, -0.19829737f, -0.00399211f, -0.02442303f, -0.03358998f, 
    0.06623753f, 0.08263830f, -0.06680099f, -0.25941309f, -0.04190116f, -0.01697278f, -0.05017514f, -0.19412924f, 
    -0.08225929f, -0.06609539f, -0.35515922f, 0.20438549f, 0.07335190f, 0.09149984f, -0.15085024f, -0.10947377f, 
    -0.18122463f, -0.10917781f, -0.02421508f, -0.07570115f, 0.05251069f, 0.04524092f, 0.12391577f, 0.02466606f, 
    0.06687258f, -0.26834908f, 0.22459212f, 0.19250992f, -0.15706567f, 0.06826827f, -0.04840766f, -0.16671306f, 
    -0.14423227f, -0.29585415f, -0.16000603f, 0.28940043f, 0.06895366f, 0.03075955f, 0.20684387f, 0.21290004f, 
    0.17253356f, 0.07575160f, 0.22621079f, 0.01432575f, 0.03301166f, 0.35330999f, 0.11133015f, -0.02560762f, 
    0.14034748f, 0.19271518f, 0.01663008f, 0.15177535f, 0.11755534f, -0.27663743f, 0.00183035f, 0.20835604f, 
    -0.10185979f, -0.09883459f, 0.02636179f, 0.20739783f, -0.00728017f, -0.12739590f, 0.12504420f, -0.08002830f, 
    0.02955357f, 0.23224863f, 0.17099601f, 0.10999974f, -0.03120848f, -0.02087950f, -0.10087738f, 0.09122983f, 
    0.04822239f, -0.03085149f, 0.08016070f, 0.07424637f, 0.14657567f, -0.04869879f, -0.05842310f, -0.07733425f, 
    0.21244325f, -0.03025082f, 0.03722723f, 0.10757202f, 0.00082351f, -0.14038177f, 0.09866443f, 0.18671608f, 
    -0.12241169f, 0.09569340f, -0.02682732f, 0.08950921f, 0.05055481f, 0.05806680f, 0.20903751f, 0.08724121f, 
    -0.15111531f, -0.21647352f, -0.05920708f, 0.01645104f, 0.00053942f, 0.15402259f, -0.14437848f, 0.03530748f, 
    -0.29480809f, -0.12151200f, -0.05413575f, -0.01629313f, -0.20241000f, -0.18729107f, 0.22768664f, 0.08969717f, 
    0.22019383f, -0.03529407f, 0.02812741f, -0.26648211f, 0.28278726f, -0.24004187f, 0.00733800f, 0.03081087f, 
    -0.06003562f, -0.04779425f, -0.09738641f, -0.04857045f, 0.15446015f, -0.15711056f, 0.05477047f, 0.05050479f, 
    -0.07452168f, -0.19983964f, -0.13680780f, -0.07696173f, 0.09160393f, 0.00940653f, 0.08945928f, -0.04744232f, 
    0.20021203f, 0.07313351f, -0.27616838f, -0.07763326f, -0.11651595f, 0.10374886f, -0.20848288f, 0.12576266f, 
    0.15132575f, -0.02652671f, 0.01285447f, -0.00365268f, 0.21478252f, -0.40378487f, 0.09736333f, -0.08353217f, 
    0.09812507f, 0.02838465f, 0.11730291f, -0.12138784f, 0.00354419f, -0.02811916f, -0.21084550f, -0.21835411f, 
    -0.26692510f, 0.01163593f, -0.00573616f, -0.12746705f, 0.10267622f, -0.00038648f, 0.05248994f, 0.28583446f, 
    -0.17515142f, -0.20354342f, 0.15826330f, 0.04752083f, -0.14124861f, 0.23395558f, 0.10014822f, 0.04293071f, 
    -0.07301133f, -0.15812115f, -0.01948322f, -0.21277671f, -0.22681777f, 0.01281476f, 0.01294777f, 0.08352246f, 
    0.01588212f, 0.33885995f, -0.28433356f, -0.59648246f, 0.16963328f, 0.03985592f, -0.18309501f, 0.12159151f, 
    0.21033420f, -0.04782351f, 0.25499517f, -0.35972720f, 0.04427779f, 0.39478138f, 0.37714016f, 0.05681211f, 
    0.23702483f, 0.00739844f, -0.03521294f, -0.19638743f, 0.17137671f, -0.36333019f, 0.13068180f, -0.04078512f, 
    0.08077803f, -0.36420405f, 0.08813963f, 0.01034437f, -0.27661058f, 0.29837853f, 0.17377086f, -0.23076162f, 
    -0.04639955f, -0.08100139f, -0.00241368f, -0.19620614f, -0.00344562f, 0.07972424f, 0.24572949f, 0.08486912f, 
    0.23738948f, 0.25452116f, -0.12287712f, 0.00179387f, 0.04500604f, 0.24394529f, -0.57079154f, 0.07059953f, 
    0.09257635f, 0.16169454f, -0.00628399f, 0.07722791f, 0.32867193f, 0.11476765f, -0.12029848f, -0.18382384f, 
    -0.10994119f, 0.03877339f, 0.12697576f, 0.13586992f, 0.18108654f, -0.01291247f, 0.09493227f, 0.13610151f, 
    0.09463938f, -0.00594163f, 0.04983819f, -0.31354275f, -0.09213458f, -0.06553503f, 0.11933433f, 0.09084026f, 
    0.12987903f, -0.55614096f, 0.16698909f, 0.30919147f, -0.01660000f, -0.04192802f, -0.16072063f, 0.00220700f, 
    -0.13678034f, -0.17377670f, -0.24410678f, -0.76150310f, -0.34327966f, -0.30533642f, -0.06171655f, -0.13787696f, 
    0.28783605f, -0.13798718f, -0.13476892f, 0.05665402f, 0.10984863f, 0.17442167f, -0.01751526f, 0.13552506f, 
    -0.18413576f, 0.13173775f, 0.04466119f, 0.14075974f, -0.47952309f, -0.15631483f, 0.10835113f, 0.01572731f, 
    0.02343807f, -0.21970144f, 0.13008751f, 0.08717348f, 0.00170650f, 0.07790601f, 0.18863016f, 0.28203741f, 
    -0.09228606f, 0.16760324f, -0.04499959f, 0.03704860f, 0.00914718f, -0.01906658f, -0.07055824f, 0.33467525f, 
    0.45900559f, 0.05072744f, 0.05755899f, 0.06135963f, -0.04568477f, 0.00104818f, -0.12437175f, 0.65778875f, 
    0.15902324f, -0.30516049f, 0.14154655f, -0.03957091f, -0.25601646f, 0.14889468f, -0.13056184f, -0.01888045f, 
    -0.71129364f, -0.80392987f, -0.31130025f, -0.05155069f, -0.29462475f, -0.07589453f, -0.11809584f, 0.01353371f, 
    -0.13028125f, -0.18196987f, 0.45715892f, 0.13275450f, -0.32395941f, -0.22118922f, 0.06407553f, -0.03694722f, 
    0.07815303f, 0.04217385f, -0.38942462f, 0.17244461f, 0.26419666f, 0.08096502f, 0.13617846f, -0.02303817f, 
    0.06672095f, 0.07541490f, 0.04140360f, 0.05987782f, 0.01153406f, 0.09266641f, 0.01754691f, 0.18491198f, 
    -0.07942959f, 0.13664798f, 0.08736408f, -0.02054412f, -0.28451931f, 0.16626154f, -0.06784882f, -0.10327733f, 
    -0.04880643f, -0.17477493f, -0.00743084f, 0.08715042f, -0.12554875f, 0.12704886f, -0.03376183f, -0.05210336f, 
    0.01183024f, -0.01140309f, 0.01265262f, 0.12675424f, 0.28789398f, 0.23193717f, 0.24003729f, 0.15500407f, 
    0.01388143f, 0.12427884f, 0.24706121f, 0.11409241f, 0.06306036f, 0.11651053f, 0.08150421f, -0.02670671f, 
    -0.04373582f, -0.43832245f, 0.16630059f, -0.00970672f, 0.10186920f, -0.02263673f, -0.01357236f, 0.23156607f, 
    -0.60308951f, -0.59994847f, -0.20646013f, -0.08406197f, -0.15768309f, 0.13853697f, -0.04177892f, -0.06281080f, 
    0.07421710f, 0.04834550f, -0.33361921f, -0.41405517f, -0.25355664f, 0.01496701f, 0.36997437f, 0.27800646f, 
    0.15292239f, 0.06161480f, -0.33277476f, 0.34299552f, -0.06408167f, 0.04591931f, -0.01176168f, 0.12056882f, 
    0.08447300f, -0.10466821f, 0.12863448f, 0.07226524f, 0.10887432f, 0.08100992f, -0.13390170f, -0.00407094f, 
    -0.09544961f, -0.09994246f, -0.27294800f, -0.03059830f, -0.26501256f, -0.18505646f, 0.00209050f, 0.06128507f, 
    -0.20589054f, 0.12613134f, -0.03559783f, 0.20797703f, 0.12208278f, 0.29912582f, 0.12722389f, -0.10856902f, 
    0.09831891f, 0.14648008f, -0.02566339f, 0.10768674f, 0.28492320f, 0.01946130f, -0.09813593f, 0.35195854f, 
    -0.00212412f, -0.16225503f, -0.22370140f, -0.30149591f, -0.05947937f, -0.02526944f, -0.12727635f, 0.09789411f, 
    0.03628487f, -0.03102996f, -0.43489456f, 0.16340394f, -0.17591690f, 0.03875763f, 0.08490276f, 0.11550055f, 
    -0.23477134f, -0.11596780f, -0.04250173f, -0.15432696f, -0.02393922f, -0.09134272f, 0.09371857f, 0.12049140f, 
    0.12361751f, 0.57135469f, 0.04923096f, -0.36885691f, 0.11941800f, 0.03207442f, 0.02681573f, 0.19626237f, 
    -0.16093190f, 0.05413190f, -0.09103667f, -0.13320056f, -0.24748851f, 0.03218572f, -0.13139589f, -0.16264594f, 
    -0.01949348f, -0.03921582f, -0.10516868f, 0.03218740f, -0.04322065f, -0.08364872f, -0.11461492f, -0.03439624f, 
    -0.16092443f, -0.09433303f, -0.23941080f, -0.42191845f, -0.33211115f, 0.31318575f, 0.22733344f, 0.14467642f, 
    0.08421110f, 0.09723404f, 0.08865771f, 0.05893856f, -0.04380577f, 0.00254324f, 0.13063215f, 0.04859758f, 
    0.22384976f, 0.12240382f, 0.33683676f, 0.01668602f, 0.31474748f, 0.16057746f, -0.24230322f, 0.32591692f, 
    0.31661582f, -0.04437884f, 0.11758825f, 0.12928338f, -0.04280515f, -0.03881444f, 0.27531821f, -0.08220718f, 
    0.09138361f, 0.20675632f, -0.58106589f, -0.23538511f, -0.13957238f, -0.07108396f, 0.12740779f, -0.00266009f, 
    -0.00939360f, -0.01705648f, 0.03851445f, 0.04846178f, 0.03419148f, 0.04207310f, -0.04101295f, 0.01791556f, 
    0.00686636f, -0.04616760f, -0.01577567f, 0.00344420f, 0.01118239f, 0.02118108f, -0.00394209f, 0.02938362f, 
    -0.05306033f, -0.05713739f, 0.05151840f, -0.01977900f, 0.03077477f, -0.03057212f, -0.04440064f, -0.04001587f, 
    0.03935146f, 0.01419446f, 0.04392596f, -0.05216287f, 0.04735908f, 0.03619916f, 0.00550547f, 0.01923717f, 
    -0.01452683f, -0.02127071f, 0.00803152f, 0.02281103f, 0.02909957f, 0.05096753f, 0.01723619f, -0.01670265f, 
    -0.04755308f, -0.02549109f, 0.02119131f, -0.00822385f, 0.01874885f, 0.03480133f, -0.02416010f, -0.03841151f, 
    -0.04920463f, -0.00283461f, -0.03406220f, -0.04819088f, -0.00616423f, -0.05391568f, -0.02567837f, 0.01529071f, 
    0.00511480f, -0.04391536f, -0.02291132f, 0.02254557f, -0.05850339f, -0.00143863f, -0.05113254f, 0.04250572f, 
    -0.03516387f, 0.02412511f, -0.05815493f, -0.05329581f, 0.03913887f, -0.03208203f, -0.01112734f, -0.05039132f, 
    0.04421090f, 0.00961820f, 0.00699216f, -0.05978896f, -0.01848355f, 0.01196825f, -0.01555913f, -0.00419521f, 
    -0.01546990f, 0.04488527f, 0.00371916f, -0.03355585f, -0.01037133f, 0.03923237f, 0.04717508f, -0.06191687f, 
    -0.00524030f, 0.01940547f, -0.05621051f, -0.00868290f, 0.01271229f, -0.00257697f, 0.05706980f, -0.04417549f, 
    -0.00193147f, -0.03616953f, -0.05220978f, -0.01116480f, -0.05272392f, -0.05671179f, 0.02512186f, -0.05648706f, 
    -0.01592298f, 0.01156587f, 0.02165743f, -0.01971736f, 0.03567683f, 0.04010968f, 0.04867920f, 0.03642431f, 
    -0.01486917f, 0.05045457f, -0.02409523f, -0.04854802f, -0.03832262f, 0.02519490f, -0.04551641f, -0.00832373f, 
    -0.01241597f, -0.00322295f, 0.01044614f, -0.02403968f, 0.03337194f, -0.02822077f, -0.04138621f, 0.04042477f, 
    -0.02045134f, -0.04959108f, -0.04247579f, -0.01299769f, 0.01309980f, 0.03039204f, 0.01043002f, -0.01000240f, 
    -0.01660570f, -0.04217689f, -0.01660334f, 0.03500565f, 0.03857028f, -0.03545393f, -0.00440228f, 0.04412723f, 
    -0.04358558f, -0.03849234f, -0.04243012f, -0.02012750f, -0.02661747f, 0.03187998f, -0.04990800f, 0.04963517f, 
    0.04598834f, -0.00384817f, -0.04968153f, 0.01934564f, -0.02034950f, -0.04519805f, 0.05338154f, 0.03835982f, 
    -0.05422360f, 0.03151502f, 0.02494952f, -0.04129041f, 0.04569661f, -0.00356493f, 0.02182477f, 0.05795483f, 
    0.04236141f, 0.05211953f, -0.03163022f, 0.03037976f, -0.04929502f, 0.05191483f, -0.03593099f, -0.05838761f, 
    -0.03154330f, -0.05728169f, 0.03487342f, -0.03358756f, 0.02030771f, 0.05206236f, 0.01976408f, -0.05499752f, 
    0.04721018f, 0.05285798f, -0.05933101f, 0.02505966f, -0.05130268f, -0.04793252f, -0.04119723f, -0.03732277f, 
    -0.05605020f, 0.05100650f, -0.04523311f, 0.04112686f, -0.00385597f, 0.04900782f, -0.00526034f, -0.00543366f, 
    -0.03708640f, 0.00783072f, -0.00230176f, -0.05554916f, -0.02109491f, -0.00314670f, -0.01755741f, 0.02222840f, 
    -0.06057870f, 0.04842557f, -0.00517527f, -0.01064956f, -0.02510849f, 0.00184179f, 0.00409085f, -0.02989857f, 
    -0.05302388f, -0.04084279f, 0.01252854f, 0.04698683f, -0.06156376f, -0.03419441f, -0.03862076f, -0.05478830f, 
    -0.02229959f, -0.01417575f, -0.04269482f, 0.02164330f, 0.02200937f, -0.01339623f, -0.01343565f, -0.00213494f, 
    -0.00891477f, -0.00633126f, -0.05510869f, 0.04868468f, -0.05967597f, -0.05021756f, -0.01076285f, -0.03191982f, 
    -0.04075734f, -0.03129910f, -0.05218967f, -0.02879487f, -0.03676234f, -0.01061622f, 0.02724067f, 0.01163231f, 
    0.02354034f, 0.02504329f, 0.02301399f, 0.01069720f, 0.04066026f, -0.05631588f, -0.05805924f, 0.01359007f, 
    0.05083323f, -0.03338840f, -0.05484740f, 0.02902276f, 0.01269375f, 0.03097752f, 0.03789773f, -0.00468222f, 
    -0.04047054f, 0.04802042f, -0.04851403f, -0.05958983f, -0.03018421f, 0.00320928f, -0.00865713f, -0.02320858f, 
    0.04556328f, 0.05174047f, -0.02679739f, -0.05973163f, -0.02055398f, 0.05309813f, 0.05620121f, -0.01807443f, 
    -0.03629448f, -0.05679562f, -0.01309675f, -0.05534004f, -0.03754075f, -0.00539150f, -0.01680111f, -0.04504057f, 
    0.05263269f, 0.28298438f, 0.11721625f, 0.01351474f, 0.21870920f, 0.07966462f, -0.09161441f, -0.19164123f, 
    -0.27324092f, 0.08132641f, 0.03479973f, -0.27948123f, -0.05172684f, 0.15450796f, 0.10974611f, 0.05254064f, 
    0.04562765f, 0.13342200f, 0.26276666f, 0.11023901f, 0.25021920f, 0.29075080f, -0.08542054f, 0.19097172f, 
    0.11353526f, 0.05858301f, 0.46871877f, 0.06508595f, -0.12066750f, -0.04082373f, 0.05604879f, 0.14712749f, 
    0.14253171f, 0.10620248f, 0.13516559f, -0.09613473f, 0.15874429f, 0.32347539f, 0.31699046f, -0.00357790f, 
    0.04038352f, -0.04603712f, -0.02733622f, 0.15924373f, -0.09882151f, 0.01360028f, 0.18350759f, 0.17157336f, 
    0.13067967f, 0.18625620f, -0.30083266f, -0.02879565f, -0.35533744f, -0.46490180f, -0.27374721f, -0.07200798f, 
    -0.16897814f, 0.32458237f, 0.11591774f, -0.01756184f, -0.01241862f, -0.04073610f, -0.13458095f, -0.44875222f, 
    0.31666303f, 0.70576656f, 0.04800687f, -0.00896684f, 0.26532325f, -0.09960099f, 0.45807424f, 0.23312600f, 
    -0.26866150f, 0.09870923f, -0.44864231f, -0.00382323f, 0.24756525f, -0.26335672f, -0.10000937f, -0.28203812f, 
    -0.44439444f, 0.05135622f, -0.07083820f, 0.26491025f, 0.03339085f, 0.04701566f, 0.05998702f, 0.12149187f, 
    -0.07853059f, -0.70168388f, 0.18736947f, 0.12631974f, 0.20189914f, -0.13799511f, 0.11857007f, -0.01459736f, 
    0.11446614f, 0.11946905f, 0.27742597f, -0.07523068f, 0.10642606f, 0.08419710f, -0.05166059f, 0.18079808f, 
    -0.04556142f, -0.16966915f, -0.11427534f, 0.08939853f, -0.38666815f, -0.34431750f, -0.05720324f, 0.29451272f, 
    0.26959664f, -0.36625075f, -0.23227422f, 0.01607281f, 0.17310092f, 0.28329247f, 0.23208167f, -0.23206240f, 
    -0.01417216f, 0.00050709f, 0.09226645f, 0.05012926f, 0.11793755f, -0.16384199f, -0.11309923f, -0.13773540f, 
    -0.04300786f, -0.02801096f, 0.12616405f, 0.08591731f, -0.08128318f, 0.15961160f, 0.09344111f, -0.59535968f, 
    -0.30009973f, 0.09203407f, -0.02071184f, -0.22853257f, 0.15329047f, 0.23868376f, 0.13466442f, 0.31613427f, 
    0.01259218f, 0.00064960f, -0.13992715f, -0.01690714f, -0.13689491f, -0.48317644f, -0.43103287f, -0.76286739f, 
    -0.59144956f, 0.16875190f, -0.17249081f, 0.23653327f, 0.24402300f, -0.02827529f, 0.23558263f, 0.08755445f, 
    0.12323628f, 0.40493667f, -0.19026309f, -0.20608696f, 0.06856896f, 0.15555125f, 0.20694691f, 0.18939492f, 
    0.05771498f, 0.09920746f, 0.42276037f, 0.03774202f, -0.17015344f, -0.36635658f, 0.07795452f, 0.21454073f, 
    0.03491621f, 0.08669091f, 0.11303832f, -0.07351485f, -0.10864492f, 0.14396144f, -0.22899812f, 0.04908013f, 
    -0.00763203f, -0.03759532f, 0.15040573f, -0.02239466f, -0.07548638f, -0.08997642f, 0.07094724f, -0.13911656f, 
    0.07881352f, 0.06607448f, 0.18088418f, 0.18881775f, 0.13186331f, 0.07129277f, -0.27088934f, -0.17856045f, 
    -0.05831591f, 0.37645435f, 0.33029780f, -0.09849702f, -0.16412398f, -0.06059943f, 0.12001310f, 0.02168053f, 
    0.05528487f, 0.24652599f, 0.11830875f, 0.14498033f, -0.12124083f, -0.03080257f, -0.30388451f, -0.17083094f, 
    -0.02062408f, -0.12553906f, 0.02923577f, 0.07461807f, -0.02496428f, 0.00678648f, -0.01736523f, -0.10459611f, 
    -0.25745535f, 0.01724974f, 0.28106883f, 0.30019960f, 0.31429663f, -0.05806382f, -0.25373650f, -0.30467188f, 
    -0.14491574f, -0.13066497f, -0.25602052f, 0.16316529f, 0.32183453f, 0.07833479f, 0.09638515f, 0.04612523f, 
    -0.07118346f, 0.19158731f, 0.15500088f, -0.32667121f, 0.05874339f, -0.06548444f, 0.08922227f, 0.10651460f, 
    0.07218238f, 0.02567916f, 0.14490443f, 0.00367428f, 0.24805105f, 0.04080123f, 0.25633463f, 0.08856385f, 
    0.04763967f, 0.08185737f, 0.13926801f, 0.22801423f, 0.40329814f, 0.02281290f, -0.08489410f, 0.22388659f, 
    0.17276944f, -0.27081257f, 0.08747982f, 0.04915720f, -0.02031081f, 0.11910713f, -0.14750390f, -0.56941003f, 
    -0.28651276f, -0.04974417f, 0.06554905f, 0.00771105f, -0.06702430f, -0.11365321f, -0.12397272f, 0.12450138f, 
    -0.51277077f, -0.09917213f, 0.09572306f, 0.09530199f, 0.25639558f, -0.36158654f, -0.12414405f, 0.13644350f, 
    -0.43514943f, -0.32170686f, -0.10237493f, 0.03660359f, 0.14619373f, 0.12173056f, 0.03901985f, -0.00288280f, 
    -0.00994417f, 0.47344002f, -0.23183239f, 0.10458231f, 0.31843504f, 0.24303813f, 0.26324800f, 0.04757544f, 
    0.12825230f, -0.19769123f, -0.28682783f, 0.65605128f, 0.07530895f, -0.11326939f, 0.03350648f, 0.04107418f, 
    0.27689445f, 0.13550404f, 0.13175690f, 0.13082118f, 0.16902623f, -0.03202472f, 0.13536942f, -0.04024657f, 
    -0.00678882f, 0.00460929f, 0.02517769f, -0.05715798f, 0.17666942f, -0.59208190f, 0.00144354f, 0.02811725f, 
    0.02505414f, 0.08989350f, 0.14425270f, 0.17369471f, 0.13630803f, -0.07568494f, -0.01593501f, 0.02685029f, 
    0.02564817f, 0.05594291f, 0.20937517f, -0.18659998f, -0.13975148f, 0.14368245f, -0.18584564f, -0.02780933f, 
    0.13985825f, 0.03266926f, -0.06814031f, -0.00848124f, 0.04561731f, -0.01749318f, -0.00953993f, 0.18746881f, 
    0.21723817f, -0.21283381f, 0.11041118f, 0.15577079f, -0.10513353f, -0.07570059f, 0.01319597f, -0.06411044f, 
    0.21202458f, 0.37486702f, -0.22780371f, 0.14573136f, 0.07127301f, -0.20604587f, -0.11918554f, -0.05744226f, 
    -0.07190351f, 0.05870076f, -0.38178238f, -0.21662037f, 0.05896316f, 0.01709936f, 0.08271194f, -0.24897513f, 
    -0.08830853f, -0.10251683f, -0.00570447f, -0.39226314f, 0.10044496f, -0.12516384f, -0.13527282f, -0.04161005f, 
    0.12470727f, -0.04736481f, 0.03970321f, 0.23120423f, 0.14084999f, -0.18355951f, -0.05522452f, 0.03998097f, 
    -0.01137044f, -0.03115634f, -0.16250823f, -0.17836456f, 0.27916864f, 0.06977770f, 0.26425409f, 0.25247699f, 
    0.14610091f, 0.16612057f, -0.10396935f, 0.03038401f, -0.01085137f, 0.03052852f, 0.06832583f, -0.24910712f, 
    0.04814248f, -0.14555919f, 0.07968979f, -0.01716046f, 0.03198660f, 0.04301795f, -0.02129924f, 0.12935391f, 
    0.01552422f, 0.10180455f, -0.00761632f, -0.08112590f, 0.11249082f, 0.04108459f, -0.14120974f, -0.09021919f, 
    0.72276819f, -0.28358451f, 0.26156151f, -0.28002062f, -0.03927097f, 0.33232182f, -0.06050128f, -0.14528106f, 
    0.05603000f, -0.00215968f, 0.06553420f, -0.09412866f, -0.07608638f, -0.04191628f, -0.01686228f, -0.09227709f, 
    0.14208032f, -0.39922228f, 0.27886000f, -0.23032376f, -0.18161228f, -0.14827178f, 0.03699777f, -0.00013411f, 
    0.13672745f, 0.11237995f, -0.08657768f, -0.12659755f, 0.27553311f, 0.08924236f, 0.16076742f, 0.11888878f, 
    -0.07248612f, 0.00985216f, -0.20751318f, 0.09643963f, 0.08029982f, 0.06588435f, 0.09056150f, 0.00290791f, 
    0.15681359f, -0.06471616f, 0.15123515f, -0.05169997f, 0.19333823f, 0.04896764f, -0.23781061f, 0.02105927f, 
    0.02505508f, -0.28512707f, 0.04358957f, 0.04601522f, 0.24942331f, -0.07520797f, 0.04160903f, 0.07755408f, 
    -0.05363912f, -0.22913247f, 0.13647762f, -0.08230350f, -0.01602997f, 0.05278369f, 0.24772964f, 0.08654622f, 
    0.14929383f, 0.27482355f, 0.14929542f, 0.28308621f, -0.04720190f, 0.04996004f, 0.04467526f, -0.09416483f, 
    0.00719522f, -0.23647043f, 0.09545341f, 0.01911371f, 0.22369169f, 0.13186093f, -0.18534340f, -0.21116903f, 
    0.03344073f, 0.05696000f, 0.02776034f, -0.06413975f, -0.10825851f, 0.29115486f, -0.10641076f, -0.15640047f, 
    -0.02242294f, 0.05486833f, 0.30753043f, -0.29739997f, 0.13383327f, -0.07950445f, 0.00764796f, 0.02175190f, 
    0.03179869f, -0.18922350f, -0.14118451f, 0.26670787f, -0.27517146f, 0.18168151f, 0.19032314f, -0.19054163f, 
    0.15034917f, 0.00723722f, -0.05338759f, 0.41588721f, 0.24915960f, -0.45290333f, -0.00609071f, -0.02375194f, 
    -0.02477497f, 0.10105395f, 0.15597525f, 0.09197438f, -0.03669879f, -0.27267742f, 0.11158515f, -0.06933662f, 
    -0.05250387f, -0.05771775f, 0.03497646f, 0.00342158f, -0.02111109f, 0.01658756f, -0.08210064f, -0.11665558f, 
    -0.03657149f, 0.10699341f, 0.00634463f, -0.16970883f, -0.01463532f, 0.00903543f, -0.00431453f, 0.01523013f, 
    -0.39937210f, 0.03887478f, 0.03266064f, -0.23110218f, -0.10832028f, -0.05627623f, -0.09061691f, -0.08643976f, 
    0.06500334f, 0.05477319f, -0.04301551f, -0.06008183f, 0.33919418f, -0.08225673f, 0.02853062f, -0.07801305f, 
    -0.14686517f, -0.14129257f, -0.21866325f, -0.06585113f, 0.04107450f, -0.10580803f, -0.14044650f, -0.12081315f, 
    0.12679018f, 0.31018585f, -0.02325816f, -0.04516357f, -0.16156864f, -0.11348623f, -0.14094374f, 0.05587822f, 
    -0.12339588f, -0.02633311f, -0.16901815f, -0.34755784f, -0.27103180f, -0.19972281f, -0.02410604f, -0.04008265f, 
    0.20168558f, 0.00578192f, 0.15647878f, 0.30757958f, 0.24983452f, 0.21696892f, -0.04373440f, -0.05589170f, 
    -0.07042260f, -0.09358260f, -0.03066704f, 0.12851615f, -0.32403687f, -0.39795688f, -0.23420835f, -0.17110655f, 
    -0.07637057f, -0.20065574f, -0.14861296f, -0.22218771f, 0.07889856f, -0.27284831f, -0.55742854f, -0.33661413f, 
    -0.06297705f, 0.13262591f, 0.14114437f, 0.13137603f, 0.02123820f, 0.00037382f, 0.41104633f, -0.75102997f, 
    -0.50698698f, 0.04605893f, 0.00010286f, 0.10345799f, -0.00948497f, -0.02116873f, 0.04802448f, 0.22404043f, 
    -0.06590984f, -0.03496243f, 0.17844070f, 0.15972042f, 0.34191799f, -0.00926267f, 0.07807838f, 0.09374428f, 
    0.06575269f, -0.04782961f, 0.45894903f, -0.23921889f, 0.07779022f, -0.12060229f, 0.08563998f, 0.25362521f, 
    -0.04847358f, -0.09499424f, -0.37608573f, -0.32899028f, -0.17825761f, 0.23084432f, 0.20492744f, 0.10552383f, 
    0.04156820f, 0.00918824f, -0.12169208f, -0.76726526f, -0.72564656f, -0.11451834f, -0.01463311f, -0.16961218f, 
    -0.07853564f, -0.00100855f, 0.04427766f, 0.06769442f, 0.09552745f, 0.03270689f, 0.22922772f, 0.17344125f, 
    0.04382035f, 0.02029252f, -0.04798684f, 0.09216660f, -0.61164200f, -0.50808400f, -1.13253927f, -0.11798240f, 
    -0.01274809f, -0.19830763f, 0.06895221f, 0.12233006f, -0.03990711f, 0.25443870f, 0.24935803f, 0.37019914f, 
    0.03876153f, -0.03552472f, -0.11506004f, 0.09667362f, 0.01517875f, 0.16661891f, -0.15628414f, 0.25436026f, 
    0.23445973f, 0.06826600f, -0.02772570f, 0.07609907f, -0.02348163f, 0.01648819f, -0.00732345f, 0.05314404f, 
    0.11595106f, 0.30361679f, 0.20930119f, -0.16922075f, -0.06803062f, -0.12066703f, 0.01749814f, 0.05739859f, 
    -0.14027110f, -0.09111886f, 0.26918381f, 0.25995266f, -0.00312991f, 0.00137654f, 0.07641115f, 0.12020026f, 
    0.13405730f, -0.03222788f, -0.20896862f, -0.40195501f, 0.16476569f, 0.02585996f, 0.35848165f, 0.09882215f, 
    -0.06993425f, -0.17280167f, -0.04174626f, -0.22915536f, -0.40846720f, -0.05464497f, 0.09728037f, -0.12724057f, 
    -0.03329957f, 0.02053526f, -0.17148392f, 0.12084443f, 0.10246124f, 0.03324958f, 0.06106989f, -0.05992188f, 
    -0.10517075f, 0.05268531f, -0.09034164f, 0.13983779f, 0.55214030f, 0.13788179f, 0.20540407f, 0.01954825f, 
    -0.02222607f, -0.04069086f, -0.03016117f, 0.15924513f, 0.21146049f, -0.04764620f, 0.16562602f, 0.18325794f, 
    -0.04344068f, -0.10377202f, -0.04754688f, -0.08679701f, 0.08627322f, -0.05187533f, -0.33802927f, -0.44053972f, 
    -0.81333983f, -0.11745969f, -0.08515087f, -0.12141668f, 0.03371283f, 0.11396521f, -0.02173241f, -0.08377894f, 
    0.04600385f, 0.06648836f, 0.04912243f, 0.14510655f, 0.27579263f, 0.13358805f, -0.08842725f, 0.10582881f, 
    0.24841200f, 0.31002381f, 0.02356042f, -0.02401038f, -0.21854226f, -0.09031489f, -0.05894258f, -0.10112229f, 
    0.00433195f, -0.56982780f, -0.27788177f, -0.01011656f, 0.22371945f, 0.24577086f, 0.26141053f, 0.09521909f, 
    0.08819402f, 0.16532107f, 0.46635836f, -0.26377797f, 0.11160230f, 0.09234234f, 0.17679074f, 0.28320131f, 
    0.12211939f, 0.27539486f, -0.10697500f, 0.12184607f, -0.07214954f, -0.02805279f, -0.16311158f, -0.01274467f, 
    -0.10266621f, 0.08707451f, 0.03932465f, 0.08480166f, -0.21532989f, -0.73252714f, -0.77233440f, -0.10506898f, 
    0.09130564f, -0.19082591f, 0.03512599f, -0.06223359f, 0.03827564f, 0.05971147f, -0.02271199f, 0.10316854f, 
    0.01485773f, 0.07727418f, 0.23937528f, 0.18535523f, -0.17387350f, 0.03998998f, 0.09605303f, -0.92879176f, 
    -0.60288155f, 0.08387669f, -0.27169999f, 0.06382976f, 0.10152651f, -0.11582572f, 0.15321007f, 0.23615253f, 
    0.12839386f, -0.08513483f, -0.24138969f, -0.19239017f, -0.07510451f, 0.09532633f, -0.25538927f, -0.05605999f, 
    -0.07111794f, 0.21793377f, -0.05787893f, -0.04983801f, -0.02434173f, 0.14974861f, -0.38023254f, -0.11187027f, 
    0.11991630f, 0.08984212f, 0.03744897f, 0.13484485f, 0.04827741f, 0.01961309f, -0.18233442f, -0.06917122f, 
    0.05406152f, 0.02412101f, 0.39637029f, -0.10842377f, 0.20246020f, -0.06522414f, 0.09549814f, -0.08699413f, 
    -0.17915207f, -0.02140291f, 0.01365362f, 0.04926500f, 0.06899031f, -0.08902937f, 0.08845250f, -0.00718815f, 
    0.06497118f, 0.09961791f, 0.10212239f, 0.03825466f, -0.11775333f, 0.36601293f, 0.12602764f, 0.10693455f, 
    0.02332840f, 0.18253379f, 0.08268474f, 0.07304218f, 0.26052490f, 0.01728492f, 0.00087866f, 0.01299792f, 
    0.15478306f, 0.00888084f, -0.09405141f, 0.32067281f, -0.20709056f, -0.01597826f, -0.07466709f, 0.07586955f, 
    -0.02658789f, 0.06105003f, -0.15332405f, -0.09250364f, -0.00400161f, -0.06653114f, -0.09677141f, -0.51674294f, 
    0.10054815f, -0.12611741f, -0.22655708f, -0.16559622f, 0.03880738f, -0.03162828f, -0.11029697f, 0.23449126f, 
    0.08006986f, 0.08452341f, -0.29607642f, 0.25484627f, -0.06399228f, 0.07933815f, -0.02688924f, -0.14418972f, 
    -0.33927786f, -0.04129676f, -0.02794340f, 0.21652353f, 0.14091988f, 0.06324271f, -0.12116413f, 0.15739982f, 
    -0.15308900f, 0.14113359f, -0.35231471f, 0.26011050f, -0.02818350f, 0.16005768f, 0.01100817f, 0.24493380f, 
    -0.04678996f, 0.03259998f, -0.05803123f, -0.06406467f, 0.02062374f, -0.09458744f, -0.00785930f, -0.04486053f, 
    0.04411751f, -0.14521500f, 0.00662364f, -0.01908527f, 0.10673661f, 0.24564373f, 0.30837920f, 0.37065396f, 
    0.01489333f, 0.16554157f, -0.04942276f, -0.06120811f, 0.03518250f, 0.08743893f, -0.23808286f, -0.15887013f, 
    -0.07935470f, 0.10286583f, -0.00115106f, 0.07512101f, 0.07740013f, -0.02776605f, -0.03453779f, -0.07025264f, 
    -0.25962967f, -0.03087034f, 0.04006215f, -0.00925199f, -0.17813404f, -0.16088720f, 0.17790748f, -0.12245570f, 
    0.30065823f, -0.55471402f, -0.02146401f, 0.05406020f, -0.01359947f, 0.34013250f, 0.12781914f, 0.07637206f, 
    -0.02394739f, -0.02755414f, -0.13011327f, 0.18619211f, -0.07040732f, 0.02890595f, -0.06237490f, -0.42935365f, 
    -0.21705689f, 0.14915483f, 0.11767613f, -0.20448297f, -0.03452092f, 0.10458914f, -0.01206992f, -0.20081346f, 
    -0.09967658f, 0.10690179f, 0.03656651f, -0.07075486f, -0.12082025f, 0.05362421f, 0.05496869f, 0.10306855f, 
    -0.07154299f, 0.01351566f, 0.01128219f, -0.01256313f, 0.05745988f, -0.20739324f, 0.16630737f, 0.06998954f, 
    0.05728627f, 0.12746707f, 0.04387161f, 0.16081700f, -0.21961690f, -0.08990900f, -0.51349497f, 0.09418341f, 
    -0.11727785f, -0.03227943f, 0.08878624f, 0.23743229f, -0.02601412f, 0.26802516f, 0.16069230f, 0.34602037f, 
    -0.13584381f, -0.08183692f, 0.01135943f, 0.10186934f, 0.07504833f, 0.09716059f, 0.30011970f, 0.14548945f, 
    0.25056177f, 0.54617667f, 0.08986393f, 0.26256856f, -0.11133787f, -0.09264810f, 0.05727120f, -0.06654032f, 
    -0.02821860f, 0.07567152f, 0.03870520f, 0.13875593f, 0.09193658f, -0.16928957f, -0.26571628f, -0.28418097f, 
    0.00558887f, 0.13873771f, 0.08291464f, 0.08776023f, 0.16085550f, 0.18973324f, 0.10583143f, -0.00645424f, 
    -0.26771256f, 0.21999969f, 0.02273510f, 0.12278397f, -0.10745180f, 0.06541470f, -0.09335701f, -0.04607344f, 
    -0.29632798f, -0.21697742f, -0.19421166f, 0.23223720f, 0.03946598f, 0.29755306f, -0.10298733f, 0.09749489f, 
    -0.05850947f, -0.09894845f, -0.08429676f, 0.20922273f, -0.54050440f, -0.59109074f, 0.10526142f, 0.09314664f, 
    0.05166421f, 0.14236492f, 0.18614003f, 0.09026567f, -0.20149171f, 0.14508526f, -0.06508537f, 0.22255740f, 
    -0.12995635f, 0.02216084f, 0.05202859f, 0.06227214f, 0.08997375f, -0.07016403f, -0.05654920f, 0.24612546f, 
    -0.07299515f, -0.04668671f, -0.08670769f, -0.19565549f, -0.26597401f, -0.01168951f, 0.34336892f, 0.29300684f, 
    0.12848961f, -0.06160023f, 0.21337593f, 0.00556849f, -0.00096405f, 0.14867261f, 0.18275465f, 0.17497303f, 
    0.22255242f, 0.26385912f, 0.04214897f, 0.14694132f, 0.08219715f, -0.30604038f, -0.33641177f, 0.01425102f, 
    0.08047950f, 0.13645995f, -0.19714054f, 0.09984966f, 0.06546408f, -0.00071220f, 0.09540591f, -0.08059526f, 
    0.31959158f, -0.38806120f, 0.10540836f, 0.67887092f, 0.09116926f, 0.07513794f, -0.14269742f, -0.01579178f, 
    0.03582278f, -0.19196355f, -0.09301054f, -0.65363342f, 0.22231045f, 0.15460218f, -0.13932000f, -0.21951334f, 
    -0.29348761f, -0.11920746f, -0.33556107f, -0.15129904f, -0.15818885f, -0.15573953f, -0.06156861f, 0.02137505f, 
    0.08103202f, -0.00859031f, 0.05079091f, 0.01946079f, -0.44333878f, 0.19708033f, -0.08413345f, 0.27633324f, 
    -0.20901132f, -0.08315632f, -0.19812001f, -0.24652654f, -0.13444671f, 0.05830871f, 0.14149053f, 0.06587260f, 
    -0.06893203f, -0.10834718f, -0.08154519f, 0.13008621f, 0.26354074f, 0.06227567f, 0.29152274f, 0.16101588f, 
    0.14037825f, 0.13417146f, 0.22320855f, -0.05056392f, 0.17494325f, 0.08945381f, -0.03158902f, 0.14449312f, 
    -0.00463922f, 0.08193562f, 0.19159949f, -0.20427172f, 0.26949686f, -0.05864094f, -0.03081665f, 0.15283406f, 
    -0.47851107f, -0.07834046f, 0.39688516f, 0.02948555f, 0.11340057f, 0.09932642f, 0.12933306f, 0.19515434f, 
    0.23810634f, -0.03979695f, 0.31136698f, 0.32937431f, 0.09676018f, -0.01843086f, 0.16218430f, 0.15367496f, 
    0.15472014f, 0.02481995f, -0.20812742f, 0.46201441f, 0.33201677f, 0.17471360f, -0.03405607f, -0.05471657f, 
    0.02536369f, -0.11090422f, -0.20020016f, -0.03488659f, 0.14170927f, -0.16801380f, 0.16780536f, 0.27812693f, 
    0.12118023f, 0.01659637f, -0.03795480f, -0.08812612f, 0.10300018f, 0.27251250f, 0.24423400f, 0.17181925f, 
    0.09405734f, 0.12693679f, 0.00708297f, 0.02003052f, 0.19270222f, -0.31582347f, -0.12889472f, 0.17279780f, 
    0.02870451f, -0.09565666f, 0.01382795f, 0.03946851f, 0.12433244f, -0.21472375f, 0.11713935f, -0.04401400f, 
    -0.16488798f, 0.05172320f, -0.07480699f, 0.00065493f, -0.09568423f, -0.05622680f, -0.20788899f, 0.13301919f, 
    -0.13201864f, -0.09721734f, -0.27621052f, 0.01748189f, 0.18144378f, -0.08842018f, 0.13229005f, 0.17073551f, 
    -0.10165967f, 0.05963216f, 0.08461700f, 0.10275147f, -0.00028350f, 0.02944554f, -0.05521723f, 0.26771864f, 
    0.10117700f, -0.03976482f, -0.46405372f, 0.25696403f, 0.01804178f, 0.19093019f, 0.03766229f, -0.11361908f, 
    0.07088961f, -0.13603838f, 0.28510907f, 0.27615243f, 0.01420647f, 0.17974851f, -0.02733286f, 0.09839310f, 
    -0.18373831f, -0.07061762f, 0.17317311f, -0.18147026f, -0.17998417f, -0.29777381f, 0.06463451f, -0.05672084f, 
    -0.05638650f, 0.02434985f, -0.05662507f, -0.05295955f, -0.15633301f, -0.09964524f, -0.06161983f, -0.06014670f, 
    0.13167894f, -0.05324668f, -0.02477504f, 0.12455475f, -0.07155544f, 0.12823933f, -0.36134294f, 0.23463714f, 
    0.36527309f, 0.13007167f, -0.09341460f, -0.04459394f, 0.06913087f, -0.18685906f, 0.15592341f, 0.19344075f, 
    0.33197060f, 0.14808957f, 0.07067189f, 0.08042018f, -0.04264402f, 0.09987548f, 0.11113682f, -0.15033239f, 
    0.02027762f, 0.07661437f, 0.13214476f, 0.14747253f, -0.01485214f, -0.07168272f, -0.00854023f, 0.05539213f, 
    -0.09791428f, -0.14709961f, -0.16423614f, 0.03347180f, 0.08431125f, -0.04810946f, 0.10202947f, 0.14206345f, 
    0.19299206f, -0.37340242f, -0.06918563f, 0.33349144f, -0.13621385f, 0.29944277f, 0.06490834f, -0.00014287f, 
    0.01593246f, 0.09183189f, 0.15504251f, 0.11243742f, 0.41291678f, -0.03602429f, 0.21853144f, 0.34257674f, 
    0.04552681f, 0.18526506f, 0.18934207f, -0.47084054f, -0.31376705f, 0.10573108f, 0.13373645f, 0.08477733f, 
    -0.03181992f, -0.01102322f, -0.01112138f, -0.03092221f, -0.18451482f, 0.29785639f, 0.50105447f, 0.12139064f, 
    -0.07526152f, -0.07370438f, -0.04090407f, -0.06842227f, -0.23072915f, 0.11149453f, 0.10149855f, 0.31200951f, 
    -0.06290260f, 0.04785980f, 0.07095732f, 0.13047928f, 0.08340626f, 0.03888947f, 0.38038668f, 0.45344284f, 
    0.54296243f, 0.07610168f, 0.19137120f, -0.11658170f, -0.19605856f, 0.03425348f, 0.12050840f, 0.05539699f, 
    -0.00971472f, -0.14743203f, 0.21694875f, 0.09249891f, 0.09498221f, -0.24827400f, 0.07950860f, -0.02194978f, 
    0.03836358f, -0.04153367f, -0.01912590f, -0.05222329f, 0.01371897f, -0.00704477f, 0.00034808f, -0.05964851f, 
    -0.02254976f, -0.04575122f, -0.02721931f, -0.04783233f, -0.05204193f, 0.03795641f, -0.02768835f, 0.04635786f, 
    0.00053094f, 0.04500734f, 0.02970005f, 0.03931979f, 0.00790403f, 0.03638655f, 0.05095839f, -0.01162249f, 
    0.00136979f, 0.01703873f, -0.01223517f, 0.02879858f, 0.01923416f, -0.00593169f, -0.05397503f, 0.05241894f, 
    0.03562375f, 0.04218112f, -0.03923814f, -0.03659928f, 0.01759443f, 0.02238895f, 0.02901669f, 0.04194618f, 
    0.00813362f, -0.05755392f, -0.04214671f, -0.04296676f, -0.03279901f, 0.03187693f, -0.05934183f, -0.00549575f, 
    0.03322954f, 0.00968887f, 0.04105273f, 0.02733013f, 0.01137510f, -0.03255681f, -0.05398440f, -0.04081252f, 
    0.02577023f, 0.00502127f, -0.00926637f, 0.04037988f, 0.00357142f, 0.00315290f, -0.02229523f, 0.02450348f, 
    -0.03591919f, 0.00401134f, -0.00772506f, 0.02775094f, -0.02798349f, -0.04874349f, -0.06425005f, -0.01638382f, 
    -0.02599781f, -0.00118803f, -0.05682962f, 0.05212241f, -0.03577270f, 0.02193402f, 0.03202369f, 0.02616466f, 
    0.00580596f, -0.02415310f, 0.00679189f, 0.02037286f, -0.03133744f, 0.01840415f, -0.01887205f, -0.00481799f, 
    -0.05646250f, -0.04087665f, 0.01610863f, -0.04063965f, 0.01891065f, -0.05295227f, -0.06357496f, -0.05923527f, 
    0.01840417f, -0.02118057f, 0.01979873f, -0.00490719f, 0.02427601f, -0.04998050f, -0.03652944f, -0.05069028f, 
    -0.02897140f, -0.05165318f, -0.05250774f, -0.03547243f, 0.00128767f, -0.03334030f, -0.03728298f, 0.02386919f, 
    -0.05788807f, 0.01840932f, -0.01865341f, 0.03638960f, -0.06335400f, -0.01222849f, -0.04389372f, 0.03687752f, 
    0.03030667f, -0.01969495f, 0.02820890f, -0.01458035f, 0.04574429f, -0.04481541f, -0.02614187f, -0.00837157f, 
    0.04513999f, 0.01936647f, 0.02132374f, 0.03812845f, 0.03421205f, 0.04273707f, -0.05149594f, -0.03293255f, 
    -0.03107553f, 0.03625451f, -0.03515100f, -0.00659619f, -0.04247721f, -0.02800321f, 0.02010947f, -0.05160318f, 
    -0.04985989f, -0.04795541f, 0.03838899f, 0.04359952f, 0.03987853f, 0.00321413f, -0.01461569f, -0.03911270f, 
    -0.06084383f, 0.00148054f, 0.03863640f, 0.00840035f, 0.00100719f, -0.05253993f, -0.06125809f, -0.01119659f, 
    -0.05841606f, 0.00505075f, 0.00903966f, -0.06191567f, -0.01145412f, -0.01752208f, -0.03298337f, -0.01227608f, 
    -0.03846249f, 0.04223317f, -0.03278178f, -0.04942188f, -0.02591870f, -0.02435619f, -0.04358381f, -0.06196260f, 
    -0.02921288f, -0.03534036f, -0.00284171f, 0.04509963f, -0.00930442f, 0.04844604f, -0.04035263f, -0.04817889f, 
    -0.06006220f, -0.01098871f, 0.03879366f, 0.04942234f, -0.03504607f, 0.02348103f, -0.05329973f, 0.03395377f, 
    -0.03786204f, 0.02323124f, 0.01876627f, 0.04858484f, -0.05907644f, -0.05708263f, -0.03018276f, 0.03599178f, 
    0.00636824f, 0.00221636f, 0.00721960f, 0.03785828f, 0.00057391f, 0.03470251f, 0.04820099f, 0.03743065f, 
    -0.02061871f, -0.03640544f, -0.03378765f, -0.03984200f, 0.01991351f, -0.03186112f, 0.02471471f, -0.00479371f, 
    -0.05818171f, -0.03471270f, 0.04488124f, 0.05140373f, -0.00509517f, -0.01456057f, -0.03451553f, -0.03836758f, 
    0.04647329f, -0.00716447f, 0.00142698f, -0.01490743f, -0.01748913f, 0.01685363f, -0.01130818f, 0.04888672f, 
    -0.03785869f, -0.02119914f, -0.03404560f, 0.03021105f, 0.03355189f, -0.03527152f, -0.01315655f, -0.03012388f, 
    0.02760543f, 0.02325200f, -0.04226197f, -0.04647828f, 0.02452631f, 0.01617775f, -0.02527707f, -0.02582378f, 
    -0.05506388f, 0.02208457f, -0.03633896f, 0.02647877f, -0.01702408f, -0.03316754f, 0.03605197f, -0.04418983f, 
    -0.01940932f, -0.00513219f, -0.01905626f, 0.04142107f, -0.01753068f, 0.02623076f, -0.02803740f, -0.04458608f, 
    -0.06277025f, -0.06156057f, -0.02958536f, -0.01812732f, -0.05948493f, -0.00097888f, -0.04273868f, 0.02544414f, 
    -0.00941040f, -0.00522615f, -0.04392618f, -0.04798197f, -0.01861539f, -0.01360966f, 0.01393321f, -0.03584911f, 
    0.03210166f, -0.05832280f, 0.05162328f, 0.02925633f, -0.01866204f, 0.05082460f, 0.05700249f, -0.02966045f, 
    -0.03064426f, 0.04242387f, -0.03907814f, 0.00085664f, -0.02643993f, 0.02215574f, -0.03885423f, -0.00184709f, 
    -0.04846910f, -0.03936921f, 0.01108509f, 0.04571252f, -0.01984228f, 0.00874634f, -0.04596492f, -0.01163823f, 
    0.04697641f, -0.03953540f, 0.01647366f, -0.02522427f, -0.03353705f, -0.04931031f, 0.01293034f, -0.04635562f, 
    -0.04492038f, -0.04617064f, -0.04739485f, -0.06697621f, 0.00847993f, -0.05464771f, -0.02186216f, 0.04806741f, 
    0.03305416f, -0.02247996f, 0.01609829f, -0.01401769f, -0.03376260f, 0.00437956f, -0.02748522f, 0.04391258f, 
    0.00542235f, 0.02842089f, 0.03747732f, -0.02913664f, -0.01416099f, 0.05219502f, -0.06701003f, -0.04652404f, 
    0.04117696f, -0.04675728f, -0.03444921f, 0.05220506f, -0.02071424f, -0.03593596f, -0.00485171f, -0.02863034f, 
    -0.05412418f, -0.02717787f, -0.04385099f, -0.06130318f, -0.05469868f, -0.05022924f, 0.04757697f, -0.00836088f, 
    -0.03235429f, 0.04715524f, 0.04459918f, -0.00324984f, 0.01991433f, -0.01151741f, -0.06455138f, -0.04342172f, 
    -0.02895422f, -0.04137297f, -0.01537097f, -0.02343819f, -0.02352808f, -0.03175934f, 0.00840738f, 0.04799801f, 
    -0.03494945f, -0.02523357f, 0.04290408f, 0.01996324f, -0.04250515f, 0.04182122f, -0.00365976f, -0.00276515f, 
    0.04093304f, -0.05791006f, 0.05477120f, 0.00385861f, -0.02439777f, 0.03680241f, -0.00688607f, 0.00781749f, 
    -0.02386461f, 0.01089932f, -0.05443538f, 0.01057970f, 0.01962236f, 0.04767402f, -0.02465442f, 0.01966871f, 
    0.00025543f, 0.02811899f, 0.01315655f, 0.00180283f, 0.03547399f, 0.03347339f, 0.04644888f, 0.02034700f, 
    -0.04825266f, 0.05145425f, -0.00908731f, -0.05561463f, 0.03294867f, 0.03368785f, -0.06108379f, -0.00887538f, 
    0.01669109f, -0.00135564f, 0.03643722f, -0.01440095f, -0.06142848f, 0.04228609f, -0.00756206f, -0.06026608f, 
    0.00457744f, -0.06209196f, 0.05039646f, -0.02856401f, -0.04147696f, 0.00593445f, 0.04342826f, -0.04777018f, 
    -0.05809135f, -0.03457780f, -0.05859111f, -0.06215344f, -0.04378156f, 0.00326571f, 0.02192336f, 0.04846453f, 
    0.03889680f, -0.00944605f, -0.01838443f, -0.05198937f, 0.01008553f, 0.02646270f, -0.00558765f, -0.03214180f, 
    -0.03429310f, -0.00758408f, 0.04616506f, -0.05355347f, -0.00809697f, -0.03851482f, 0.02766824f, 0.01580933f, 
    -0.04120428f, -0.06136928f, 0.04268930f, -0.02284327f, -0.01449946f, -0.02582260f, -0.00983397f, -0.05646300f, 
    -0.02039131f, -0.04988433f, 0.04325482f, -0.05236840f, 0.01915731f, 0.03364790f, -0.00851172f, -0.05543752f, 
    -0.02176099f, -0.01975542f, -0.06485761f, -0.06503671f, 0.04879390f, -0.04011285f, -0.03117979f, -0.02762087f, 
    -0.06378088f, -0.02924799f, -0.03274107f, -0.03501396f, 0.04483641f, 0.01834041f, -0.05644530f, 0.02178875f, 
    -0.01707450f, 0.04429916f, 0.00641918f, -0.01204010f, 0.02340725f, 0.04151711f, -0.01793440f, 0.06365969f, 
    -0.01313539f, -0.03846167f, -0.00696445f, -0.01271683f, -0.01626443f, 0.01118323f, -0.06067774f, 0.00823651f, 
    0.03177896f, 0.00977093f, 0.02934733f, -0.00377591f, -0.05624104f, -0.06210479f, -0.04284863f, -0.05452393f, 
    -0.04315670f, -0.01212041f, -0.05402693f, -0.04758205f, 0.03760894f, -0.05383430f, -0.06337464f, -0.00252910f, 
    0.03947539f, -0.01935472f, -0.00035699f, 0.02180578f, -0.06086313f, -0.04540071f, -0.01266401f, 0.02211384f, 
    0.04923004f, 0.03163262f, 0.00962126f, 0.00116770f, -0.06066812f, -0.00794710f, 0.00748975f, 0.00812157f, 
    -0.03111172f, 0.02008927f, 0.04967413f, -0.01320115f, 0.03662926f, -0.02289809f, -0.01096311f, 0.05074095f, 
    -0.01186628f, -0.01281872f, -0.02891827f, 0.04658366f, 0.02089504f, 0.00372108f, 0.03768250f, 0.02754761f, 
    0.02626473f, -0.01713026f, 0.03144086f, -0.04099200f, -0.04550453f, -0.02886997f, -0.04135547f, -0.06478754f, 
    0.00179070f, -0.00393313f, 0.00979511f, 0.02152449f, 0.00897452f, 0.03951083f, -0.02056477f, -0.03549579f, 
    -0.01930066f, 0.02181150f, -0.06266193f, -0.02430945f, 0.02656693f, 0.01042916f, -0.05150143f, 0.06347833f, 
    -0.06143718f, -0.04111308f, 0.02028062f, -0.05721427f, 0.00851945f, 0.03772923f, 0.02868661f, -0.02655566f, 
    0.01962774f, 0.29348463f, 0.28169265f, -0.20231383f, -0.26976466f, 0.02026373f, 0.09933136f, 0.09929793f, 
    -0.05858475f, 0.07359439f, -0.35823002f, -0.68436575f, -0.11066955f, -0.12073369f, 0.01759538f, -0.04275262f, 
    -0.04855348f, 0.06335315f, -0.40782851f, -0.00572567f, -0.10365769f, -0.27964202f, 0.09044928f, -0.01561592f, 
    0.45188656f, -0.02544337f, 0.38417181f, 0.04522217f, 0.05612303f, 0.18519445f, 0.15911719f, 0.03577003f, 
    0.01975242f, -0.03094659f, 0.04100134f, 0.09187471f, 0.20939951f, 0.02138391f, 0.10868901f, -0.12358689f, 
    -0.29258329f, -0.22762021f, 0.02433156f, 0.11224922f, -0.04118706f, -0.32097858f, 0.46494126f, 0.22477049f, 
    -0.16969402f, -0.06259045f, 0.00836836f, -0.09404980f, -0.33534631f, -0.12128677f, -0.98897427f, 0.23559232f, 
    0.21286422f, -0.00865027f, 0.06274106f, 0.21121478f, 0.03755677f, -0.15435444f, -0.01639638f, 0.39561537f, 
    -0.04935449f, -0.06964656f, 0.19758047f, 0.02537442f, 0.08159878f, 0.33997977f, 0.12190899f, 0.10391115f, 
    0.20497213f, -0.21322276f, -0.85868502f, -0.22152402f, -0.14977421f, 0.13062586f, -0.16575703f, 0.00258581f, 
    -0.07623485f, -0.18656048f, 0.13984455f, 0.36208346f, -0.15357055f, -0.07517212f, -0.03701733f, 0.02918526f, 
    -0.01229030f, -0.16455925f, 0.07591826f, -0.08104146f, 0.21640429f, 0.01769074f, 0.13261977f, 0.05705211f, 
    0.12573884f, 0.11262905f, 0.14733434f, 0.19551419f, 0.17181270f, 0.16626589f, -0.01812433f, 0.12968425f, 
    -0.06428655f, -0.09316037f, 0.16697679f, -0.11547626f, 0.14441827f, -0.50614083f, -0.65994078f, -0.09104848f, 
    -0.06516562f, -0.21144493f, 0.04409243f, 0.11766527f, 0.09767774f, -0.02824554f, -0.15323050f, 0.12052400f, 
    -0.05701329f, 0.21606803f, 0.06798072f, 0.24073867f, -0.07580344f, 0.12995571f, 0.14347458f, -0.01629746f, 
    0.10339612f, 0.18703717f, 0.07303534f, 0.05616198f, 0.18387343f, 0.02547108f, 0.17088851f, 0.38919023f, 
    -0.14236102f, -0.45292559f, -0.13972424f, -0.11976216f, 0.02606892f, -0.05118490f, 0.11126207f, 0.18462376f, 
    -0.16576520f, -0.03061931f, -0.35991070f, 0.07544388f, -0.15192486f, -0.09745733f, -0.24555096f, -0.18374790f, 
    -0.29244199f, -0.52492946f, -0.00148562f, 0.28912643f, -0.03568899f, -0.08010546f, 0.12988915f, 0.03261599f, 
    0.15655394f, 0.28515378f, 0.27405107f, -0.17404608f, -0.37228483f, 0.00948214f, 0.33056366f, 0.13757415f, 
    0.00416748f, 0.09880695f, 0.03896724f, -0.11572742f, 0.04813297f, 0.24152756f, -0.09571513f, -0.07758733f, 
    -0.07704461f, 0.05642399f, 0.06575952f, 0.13345417f, 0.22634330f, -0.14450485f, -0.15574069f, 0.07675743f, 
    0.09892450f, 0.20170851f, -0.01296716f, 0.05290351f, 0.09811497f, -0.00397164f, -0.84154510f, -0.29877189f, 
    0.10221582f, 0.12595919f, 0.17494965f, -0.03232840f, 0.01049805f, 0.04410907f, 0.04653935f, -0.14250462f, 
    -0.22377440f, -0.19500598f, -0.20398405f, -0.28940651f, 0.06099291f, 0.09077723f, 0.09003801f, 0.28649831f, 
    0.29331478f, 0.06689089f, 0.00672113f, 0.05882010f, 0.07855945f, 0.07043947f, -0.02471387f, -0.17363441f, 
    0.06116459f, -0.28554386f, -0.15796536f, 0.08380034f, 0.06815121f, 0.03837638f, -0.09124544f, -0.06622586f, 
    -0.20065190f, 0.61730719f, 0.45895326f, -0.17675388f, 0.32529789f, 0.23115490f, 0.20277889f, -0.02920653f, 
    -0.04228581f, -0.17249115f, -0.26084742f, -0.43581566f, -1.43758917f, -0.00876300f, 0.05897964f, 0.17589572f, 
    0.20769210f, 0.05889856f, -0.09479547f, -0.35645801f, -0.27942201f, -0.07816716f, -0.15589444f, -0.00345283f, 
    -0.02083549f, 0.11926211f, -0.01166168f, 0.03024982f, 0.10125018f, -0.15231456f, 0.13567026f, 0.01028949f, 
    0.02857759f, 0.17316999f, -0.00775768f, 0.05598554f, 0.19680771f, 0.28830275f, 0.13025504f, 0.07601281f, 
    0.13776107f, -0.23720194f, 0.07669620f, 0.13764076f, 0.35977879f, 0.37967387f, -1.34896886f, -0.02341853f, 
    -0.49510497f, 0.12285017f, -0.13913709f, -0.45249960f, -0.00299192f, -0.17342347f, -0.06148696f, -0.29967511f, 
    -0.15505892f, 0.14216232f, -0.02884008f, -0.03728615f, -0.12885743f, -0.03403996f, 0.00154260f, 0.06700821f, 
    -0.50464994f, -0.52250427f, 0.09291287f, 0.07680771f, 0.08631319f, 0.01047937f, 0.27008832f, -0.12979405f, 
    0.09216913f, 0.88252836f, 0.21675743f, 0.25732607f, 0.08104481f, -0.11756737f, 0.09814670f, 0.05117026f, 
    0.03508832f, 0.10244049f, -1.01862931f, 0.23113631f, 0.11080870f, 0.23595729f, 0.10015500f, -0.03876243f, 
    0.17809901f, 0.02449686f, -0.02936756f, -0.05925021f, -0.22706059f, -0.26391360f, -0.24994358f, -0.00809290f, 
    0.11645447f, 0.06611654f, 0.12992363f, -0.04660005f, 0.89831710f, -0.24684823f, 0.43222770f, -0.02230457f, 
    -0.05501575f, 0.19995420f, 0.09088863f, -0.00519698f, -0.01910905f, -0.09166242f, 0.23256640f, 0.00012392f, 
    0.12549177f, 0.14912361f, 0.11512309f, -0.18264297f, -0.04170563f, 0.09101123f, 0.11047509f, 0.26362008f, 
    -0.00200428f, -0.06907610f, 0.14954485f, 0.24014154f, -0.05471751f, 0.17459156f, -0.03987342f, 1.13649976f, 
    0.02772320f, -0.40139812f, -0.20339465f, -0.06792280f, 0.13853541f, 0.04481028f, 0.05968513f, -0.14957665f, 
    -0.06753217f, 0.27958134f, -0.27729264f, -0.28146392f, -0.07459825f, -0.04988372f, -0.08592670f, -0.07896917f, 
    0.17297223f, -0.06481422f, -0.46604151f, -0.71965170f, 0.03814945f, 0.24246205f, 0.29093611f, -0.11117427f, 
    0.00585579f, 0.10125869f, 0.22794968f, -0.06284884f, 0.30707669f, 0.12425505f, -0.08208382f, -0.06389501f, 
    0.05052185f, 0.05065275f, -0.01680918f, 0.05084547f, -0.25426015f, 0.35699874f, -0.10557537f, 0.19295308f, 
    0.08357082f, 0.12018899f, 0.22025777f, -0.24814029f, -0.15650491f, 0.24981709f, 0.25971079f, 0.19013584f, 
    0.00355161f, 0.15480655f, 0.00070064f, 0.04289095f, 0.10356487f, -0.00158174f, -0.40279976f, -0.22842757f, 
    0.07257681f, -0.14715295f, -0.14540173f, -0.06579503f, -0.15946503f, 0.04940067f, -0.01604456f, 0.06535637f, 
    0.27196178f, 0.09843675f, -0.00478375f, 0.09549122f, -0.00405824f, -0.07016724f, -0.30609202f, -0.51856321f, 
    -0.44922090f, 0.42655408f, -0.13919871f, 0.03406204f, 0.04644116f, -0.17324832f, 0.04186190f, -0.11614613f, 
    -0.08789050f, 0.29516178f, -0.07740808f, -0.24110575f, -0.03874598f, 0.04709825f, -0.01527882f, 0.03311081f, 
    0.13971397f, -1.76071477f, 0.06472141f, -0.19803019f, -0.00900171f, -0.24828452f, 0.03875031f, -0.09869776f, 
    0.08230814f, -0.01780474f, 0.12198060f, 0.05295737f, 0.35664770f, 0.03273142f, 0.13083944f, 0.18282074f, 
    -0.10329632f, -0.04913642f, -0.02990848f, 0.50921220f, -0.60172516f, -0.53700179f, -0.05051175f, 0.10255965f, 
    0.07001358f, -0.31252828f, -0.07271460f, 0.11307757f, 0.23388807f, -0.52886015f, 0.47567043f, -0.25533563f, 
    -0.17641781f, -0.18767102f, 0.16195402f, 0.13710096f, 0.00790790f, -0.31399316f, -0.11219825f, -0.12230742f, 
    0.08247422f, -0.03292534f, -0.42306682f, 0.10712501f, -0.04749655f, 0.09274403f, 0.05936171f, 0.29375088f, 
    0.19500530f, 0.09718608f, 0.08665686f, 0.25244874f, -0.04962727f, 0.01355892f, 0.13043956f, 0.18244246f, 
    0.00245933f, -0.38424298f, -0.11313724f, -0.00593867f, 0.05710121f, 0.05616936f, 0.02990095f, -0.06071774f, 
    0.32786626f, -0.01974571f, -0.17894728f, -0.05722893f, -0.07918249f, 0.02079234f, -0.01280617f, -0.01058920f, 
    0.03843153f, 0.00592389f, 0.28536162f, -0.11726674f, -0.12660047f, -0.18263197f, -0.02826018f, 0.17117776f, 
    0.27120495f, -0.00320013f, -0.05274574f, 0.22172162f, -0.37366521f, -0.33379382f, -0.22649792f, -0.16744198f, 
    -0.08341374f, 0.05520386f, 0.07349418f, 0.11193306f, -0.27702731f, -0.57434589f, 0.20173033f, 0.04225886f, 
    -0.01038183f, 0.16656700f, 0.17931220f, -0.17628850f, 0.31656474f, 0.06395730f, 0.36334231f, 0.06055943f, 
    -0.06138570f, 0.02037546f, 0.06917108f, -0.00288675f, -0.04860913f, 0.25302070f, -0.35902935f, -0.61323649f, 
    -0.00142748f, -0.19428149f, 0.13240467f, -0.33785218f, -0.04005629f, -0.11148443f, -0.07665252f, -0.34426135f, 
    -0.06582163f, 0.12446291f, -0.12945549f, -0.36058599f, -0.01927654f, 0.05899977f, -0.02299945f, -0.34596184f, 
    -0.75532657f, -0.65774226f, 0.01459378f, 0.06909692f, -0.01111293f, -0.19287233f, -0.00005617f, 0.20858513f, 
    -0.05562640f, 0.06896271f, 0.15091035f, -0.12146768f, -0.32746673f, 0.05063999f, -0.08335936f, -0.01825644f, 
    0.03849094f, 0.15285815f, -0.08624662f, 0.00493255f, -0.02172443f, 0.02780259f, -0.00136138f, 0.17515965f, 
    -0.01103356f, 0.14357577f, -0.38988972f, 0.52371562f, 0.03682747f, 0.19611815f, 0.12977582f, 0.03930815f, 
    0.13800181f, -0.22013451f, -0.31312239f, -0.16631064f, 0.02037881f, 0.26681921f, -0.04865510f, 0.03042274f, 
    0.18931802f, -0.10849548f, 0.10747189f, 0.04933795f, 0.10217521f, -0.12369208f, -0.10756031f, -0.20540269f, 
    -0.29710042f, -0.13214110f, 0.08821906f, -0.22441168f, -0.11824383f, -0.00108405f, 0.17777525f, 0.11912359f, 
    0.07769955f, 0.04734362f, -0.03876678f, 0.11002646f, 0.07242775f, 0.06083596f, -0.62419981f, 0.00430887f, 
    -0.15136373f, 0.08227299f, 0.01026106f, 0.14441980f, 0.08990480f, 0.11213401f, -0.06518416f, 0.20830689f, 
    -0.72006941f, 0.18384394f, -0.32443985f, 0.09380459f, 0.24889603f, 0.01789313f, 0.02139308f, -0.07993626f, 
    0.19292426f, 0.61937457f, -0.52271956f, -0.22109251f, 0.26609266f, 0.15125258f, 0.12052082f, 0.24161780f, 
    0.09023651f, 0.15539525f, -0.17063050f, 0.18868761f, -0.07638577f, 0.02840750f, -0.19346344f, -0.10594754f, 
    -0.00292566f, 0.06208372f, -0.10550407f, -0.15885550f, -0.03908635f, -0.12243322f, -0.10567771f, -0.17172016f, 
    0.15506399f, -0.12197135f, -0.05071486f, -0.05417959f, 0.22919062f, 0.26161996f, 0.06723403f, -0.22578175f, 
    0.25283766f, -0.12087946f, 0.06227524f, -0.11521298f, -0.06533180f, -0.10477237f, 0.14987354f, 0.01486715f, 
    0.18269189f, -0.25341031f, -0.07728253f, 0.08584179f, 0.06938060f, -0.32059735f, 0.07058985f, 0.20094447f, 
    -0.06252372f, 0.21944624f, 0.02229002f, 0.08474246f, -0.01348326f, -0.05496928f, 0.00486095f, -0.11148473f, 
    -0.14408806f, -0.02853602f, 0.12076080f, 0.07489910f, -0.06531230f, -0.17627288f, -0.45459458f, -0.43253803f, 
    -0.35412416f, 0.05299512f, 0.06744705f, 0.08023977f, 0.22915573f, -0.28817660f, -0.02557010f, 0.12643804f, 
    -0.00013239f, 0.42492834f, -0.26170945f, 0.12422635f, 0.20965616f, 0.01832148f, 0.20291819f, 0.10626238f, 
    0.03841402f, -0.26841336f, 0.21362439f, 0.25557825f, 0.04215241f, 0.32017079f, 0.15508111f, -0.10707093f, 
    -0.05205926f, 0.19794929f, 0.19970991f, 0.12156245f, -0.14522077f, -0.03315262f, 0.04769500f, 0.00116968f, 
    0.02093031f, -0.13127382f, 0.12888794f, -0.02866206f, -0.04457882f, 0.00708800f, 0.05652310f, -0.03210682f, 
    0.04465101f, 0.25794148f, 0.19282477f, -0.01946612f, -0.48945579f, 0.22249413f, -0.10829783f, 0.01388872f, 
    -0.02457316f, 0.24170014f, 0.22156537f, 0.01141850f, 0.03978244f, -0.52749079f, -0.20832060f, -0.30111152f, 
    0.09314855f, 0.13340771f, 0.09514204f, -0.18815610f, -0.11639833f, -0.39635682f, 0.15149286f, -0.30080953f, 
    0.28685322f, -0.02284097f, 0.04426765f, -0.14915492f, 0.00269065f, 0.15933444f, 0.02757038f, -0.01255315f, 
    0.16197401f, 0.40478244f, 0.13125713f, -0.01220912f, 0.34070086f, -0.14058799f, -0.03210934f, 0.17114973f, 
    -0.16661717f, 0.07709468f, 0.05996308f, 0.10502978f, -0.01726106f, -0.13120563f, -0.07222831f, 0.01884119f, 
    0.11846329f, -0.36544803f, -0.00103454f, 0.69086921f, -0.16951461f, 0.06698884f, 0.24904175f, -0.00281723f, 
    0.06425774f, 0.00103492f, 0.00956038f, -0.33784056f, 0.34820780f, -0.12269581f, -0.06337355f, 0.15510087f, 
    0.02799842f, 0.21155339f, 0.13050234f, -0.25788632f, -0.09662037f, 0.29918569f, 0.08188368f, 0.02685600f, 
    0.04524184f, 0.34388041f, -0.06224716f, -0.22243246f, 0.37651518f, -0.25506982f, -0.14489469f, -0.17409146f, 
    -0.02714454f, -0.29773101f, 0.07103574f, -0.16145693f, -0.11583678f, 0.20794311f, 0.06892051f, 0.36934224f, 
    -0.04859867f, 0.06007994f, 0.03799323f, 0.07804213f, -0.14396890f, 0.15992649f, -0.93079591f, 0.43579280f, 
    -0.34353337f, 0.16246367f, 0.40605921f, 0.31518027f, -0.08180492f, 0.09062230f, -0.06429231f, 0.01997488f, 
    0.06736866f, 0.22894737f, 0.22171029f, -0.10360302f, -0.05488530f, 0.02638409f, 0.03297246f, 0.03780854f, 
    -0.00666693f, 0.04360618f, -0.06049618f, -0.05044673f, -0.03508348f, -0.01211843f, 0.02909912f, 0.03387683f, 
    0.01636652f, 0.04411640f, -0.03369121f, -0.03569615f, 0.02572945f, 0.00656323f, -0.03370661f, -0.05580244f, 
    -0.04014547f, 0.03845617f, -0.02486508f, 0.00204767f, -0.02787074f, -0.04308933f, 0.02620724f, 0.04974719f, 
    0.00336024f, 0.00926493f, 0.03108104f, 0.02036154f, -0.05402542f, 0.01163377f, -0.00787311f, 0.03871665f, 
    -0.04726017f, 0.00276501f, -0.06042887f, 0.00649592f, -0.05096830f, -0.03796579f, -0.05475286f, 0.04460835f, 
    0.01344776f, 0.01933953f, -0.05984258f, -0.01981618f, -0.02612443f, 0.03502112f, 0.00362321f, 0.03307287f, 
    0.03000820f, -0.03062068f, -0.06514210f, -0.04489674f, -0.03234248f, -0.01941033f, -0.05378289f, 0.04663068f, 
    0.01381032f, 0.01766326f, 0.04636629f, -0.00575991f, -0.06071365f, -0.05057040f, -0.03607131f, -0.06774562f, 
    0.00388460f, -0.02748305f, -0.06114595f, -0.05601190f, -0.04422148f, -0.02854375f, 0.00544132f, 0.03234456f, 
    0.02699793f, -0.02069927f, 0.02903855f, -0.00412372f, 0.03087075f, 0.01303310f, 0.03733234f, 0.01782074f, 
    0.00150394f, -0.05115603f, -0.06318428f, 0.03704822f, -0.06197542f, -0.01580451f, -0.01275174f, 0.00799262f, 
    0.02371272f, 0.03857202f, -0.04283353f, -0.06196497f, -0.03648392f, 0.01049501f, -0.05465096f, 0.04672930f, 
    0.03111635f, -0.01679247f, 0.02139453f, -0.02097091f, 0.01306813f, 0.03432488f, -0.04112487f, -0.01019351f, 
    -0.00933980f, 0.02952359f, 0.04292890f, -0.04213501f, -0.06010647f, 0.00641416f, -0.01145528f, 0.02770955f, 
    -0.03743818f, -0.02358570f, 0.01835139f, 0.00296815f, 0.04619796f, 0.00830708f, -0.02978864f, -0.02441811f, 
    -0.05461435f, 0.04661319f, -0.04753891f, -0.06387744f, -0.00013562f, 0.02600005f, 0.03808524f, -0.01447384f, 
    0.02171038f, -0.01270939f, -0.05579114f, -0.01235294f, -0.03119823f, 0.04180673f, 0.01133574f, 0.04815246f, 
    -0.04347444f, 0.04926822f, 0.01493888f, -0.00593847f, 0.01319567f, -0.02363054f, -0.00208957f, 0.04870255f, 
    -0.04810580f, 0.02320256f, 0.00560869f, -0.03150335f, -0.05285811f, -0.04831439f, -0.00978230f, -0.02791106f, 
    -0.00553286f, -0.06159152f, 0.02113584f, -0.01358793f, 0.00351195f, 0.00736039f, 0.01758024f, -0.00619021f, 
    -0.06580808f, -0.03540146f, 0.01189609f, -0.00649848f, -0.04489810f, -0.04077143f, -0.06835460f, 0.04822293f, 
    -0.02753077f, 0.04742956f, 0.03265527f, 0.00965588f, 0.03961294f, 0.02524062f, 0.05209845f, -0.01140501f, 
    -0.03141005f, -0.05015102f, 0.03438916f, -0.03061085f, 0.03411631f, -0.02471815f, -0.05351516f, 0.05059056f, 
    -0.05891057f, -0.05877977f, -0.04123207f, 0.04084442f, -0.00654774f, 0.02809905f, 0.02378695f, 0.04311934f, 
    -0.00520133f, 0.02313741f, -0.01458622f, 0.03720785f, -0.01202538f, -0.05627532f, -0.02005082f, 0.03907688f, 
    0.01794975f, -0.06644224f, 0.04902455f, 0.02434041f, -0.01590119f, 0.02648203f, 0.01151421f, -0.02864569f, 
    0.04654142f, 0.02904893f, -0.03039546f, 0.02107143f, -0.02012341f, -0.04126821f, 0.00693003f, -0.05326704f, 
    -0.02790264f, -0.00222205f, -0.04402725f, -0.03401177f, 0.00955968f, -0.05890643f, -0.05965018f, 0.00141506f, 
    -0.01165388f, 0.02230053f, -0.01578579f, -0.00607258f, 0.00298910f, -0.00899327f, 0.04532869f, -0.02799683f, 
    0.00812679f, -0.01055280f, 0.01714642f, 0.03476518f, -0.01770454f, 0.04332250f, -0.02529998f, -0.04749732f, 
    0.04816750f, -0.03257197f, -0.00211110f, 0.02519203f, -0.03720965f, 0.00852464f, 0.00117354f, 0.05015386f, 
    0.00565927f, 0.02952505f, 0.02628066f, -0.02311270f, 0.00432529f, 0.03496965f, 0.02363274f, 0.04295079f, 
    0.01798717f, 0.01433031f, 0.01769990f, -0.00196926f, -0.02461688f, 0.01861620f, 0.02470268f, 0.00258730f, 
    -0.04967652f, 0.02388180f, 0.02286097f, -0.03098612f, -0.03280516f, -0.03283453f, -0.03139878f, -0.00246413f, 
    0.00615076f, -0.00901053f, -0.05530630f, -0.05078910f, -0.03044022f, -0.00699657f, 0.03790370f, 0.05071852f, 
    -0.06593242f, 0.04473888f, 0.02772023f, 0.01847198f, -0.01486350f, -0.02051341f, -0.05954710f, 0.01038168f, 
    -0.61117321f, -0.26029193f, -0.27367678f, 0.09750927f, 0.10879280f, -0.20160082f, 0.17629440f, 0.16589175f, 
    0.09829564f, 0.01032189f, 0.32306305f, -0.42054242f, 0.04200076f, 0.18575273f, -0.02233841f, -0.09835955f, 
    0.00744207f, -0.05242786f, 1.10696769f, 0.80792630f, 0.07632682f, -0.27006632f, 0.19627273f, 0.14787129f, 
    -0.19033635f, -0.27817574f, -0.35901615f, 0.10842052f, -0.11106815f, 0.17796549f, -0.02179944f, 0.06481387f, 
    0.27299652f, 0.00492251f, 0.05231709f, 0.26587150f, -0.04450424f, 0.16071159f, -0.21821049f, -0.10774174f, 
    -0.02723119f, 0.18828715f, -0.01618218f, -0.07826142f, -0.19260333f, 0.05457357f, 0.05788705f, 0.08373588f, 
    0.19295348f, 0.00681586f, 0.25792539f, 0.08806816f, 0.12418752f, 0.17341432f, 0.51409692f, 0.09950584f, 
    -0.06748504f, 0.34462622f, -0.09342759f, 0.02894426f, 0.10227151f, 0.11317671f, -0.03468513f, -0.15132265f, 
    0.29806218f, 0.26112214f, 0.03780938f, -0.21970016f, -0.26683056f, 0.17118432f, -0.07151391f, -0.14840554f, 
    0.43521827f, 0.06431288f, 0.04361862f, -0.25930414f, -0.38718244f, 0.12085124f, 0.06710896f, -0.01487736f, 
    0.26706553f, -0.73391259f, -0.49457818f, -0.46784168f, 0.17231190f, 0.23804511f, 0.17381608f, 0.06705274f, 
    0.25415432f, 0.01431726f, -0.02618517f, 0.04187894f, -0.06349622f, 0.00246075f, -0.01892362f, 0.09050211f, 
    -0.10060593f, 0.09659974f, -0.02629154f, -0.83556366f, -0.22652633f, -0.16975656f, 0.15532441f, -0.05166906f, 
    -0.00486442f, 0.27267966f, 0.36049446f, -0.28303394f, 0.37517059f, -0.00668909f, -0.26237044f, 0.14686207f, 
    0.08717042f, -0.13959883f, 0.16373628f, -0.03618265f, -0.09484729f, -0.31733108f, 0.30807817f, 0.18377690f, 
    -0.51710463f, 0.01966451f, 0.25150934f, -0.06714912f, 0.01726783f, 0.08901691f, -0.08690387f, 0.10911453f, 
    -0.02498816f, 0.17836899f, 0.06642256f, 0.10469731f, 0.20701240f, -0.20519905f, -0.10251376f, 0.00189753f, 
    -0.46931922f, 0.29913881f, -0.33129671f, 0.10307046f, -0.19347855f, -0.06706457f, -0.16087136f, 0.11523959f, 
    0.17214695f, 0.29998416f, -0.00719181f, -0.08606952f, -0.02098173f, 0.08313076f, 0.00401076f, -0.00915339f, 
    0.20044816f, 0.15338688f, -0.47399268f, -0.44644037f, 0.09415971f, 0.27326110f, -0.18678182f, 0.14141114f, 
    -0.13191523f, 0.13903251f, 0.30535412f, 0.04549120f, -0.12279934f, 0.11210930f, 0.00486462f, 0.07403293f, 
    -0.04322350f, -0.14117937f, -0.10015371f, 0.18684323f, -0.13236113f, -0.23170909f, -0.10102784f, 0.08463312f, 
    0.09097816f, -0.01042218f, -0.28754202f, 0.02497112f, -0.43151480f, -0.36454591f, 0.16247201f, -0.26472163f, 
    -0.21706408f, -0.13019530f, 0.14191249f, 0.11608383f, 0.20020370f, 0.26310468f, -0.02417396f, 0.29543725f, 
    -0.22887385f, 0.00415216f, 0.03531719f, 0.15909055f, -0.13210030f, -0.01797039f, 0.27351567f, 0.11684325f, 
    -0.13749887f, 0.10722432f, -0.11458440f, -0.12951586f, 0.08786611f, 0.10894009f, -0.03460106f, -0.82317376f, 
    0.00336702f, -0.36139196f, -0.07966829f, -0.10640965f, 0.15423493f, 0.00335784f, 0.38032430f, 0.00733529f, 
    -0.39314586f, -0.03296074f, -0.06744654f, -0.21877581f, 0.15306249f, 0.27903521f, -0.05964892f, 0.29700658f, 
    0.26764795f, 0.04495547f, 0.20582072f, -0.06579373f, -0.19379349f, 0.02807047f, 0.00090500f, 0.10407190f, 
    0.09872387f, 0.07677919f, -0.18585359f, 0.20970213f, -0.10342368f, -0.12885664f, -0.29985636f, 0.03095364f, 
    -0.09762456f, 0.07825863f, 0.04505961f, -0.01380441f, -0.15983444f, 0.58783692f, -0.00419504f, -0.11467034f, 
    -0.13689628f, 0.19706577f, 0.03055143f, 0.11262635f, 0.15132488f, -0.01232181f, -0.19613548f, -0.06271914f, 
    0.04058866f, 0.04778736f, 0.03200907f, -0.08114537f, 0.01781874f, 0.00886663f, -0.50491261f, -0.34086820f, 
    0.07620806f, 0.21619083f, -0.26771250f, 0.09899722f, 0.09210264f, 0.18181585f, 0.31301183f, 0.03126420f, 
    -0.34721205f, 0.16152459f, -0.20196716f, -0.04368008f, -0.06673749f, 0.03478246f, -0.11872926f, -0.01545130f, 
    -0.65343207f, -0.85487288f, -0.21689627f, -0.00291363f, -0.14073186f, 0.00665901f, 0.02267049f, 0.06786282f, 
    0.14586264f, 0.02264036f, -0.59869611f, 0.13955368f, -0.11839587f, -0.12381575f, 0.10422928f, 0.11427583f, 
    -0.22987331f, 0.40617520f, 0.21877865f, 0.23832084f, 0.20033042f, -0.06612450f, 0.15844700f, -0.00786821f, 
    0.04088073f, 0.14158212f, 0.23867425f, 0.39852363f, -0.09202597f, -0.38636002f, 0.28206500f, 0.38795862f, 
    0.16546075f, -0.00161095f, 0.10996183f, 0.28487709f, 0.31266809f, 0.07060557f, -0.09656604f, -0.00073308f, 
    -0.12462747f, 0.11550938f, -0.04173998f, -0.00238430f, 0.26661769f, -0.33403143f, -0.28617722f, -0.03466910f, 
    -0.14317191f, 0.09963922f, 0.03321816f, 0.00299665f, -0.10301528f, 0.27989036f, 0.37275675f, 0.13563919f, 
    0.11582759f, 0.02609347f, -0.17054752f, 0.07802767f, -0.11357614f, -0.32061157f, 0.09163480f, 0.23942298f, 
    0.25916788f, 0.01605434f, -0.15025175f, -0.05785952f, 0.06609467f, -0.14102422f, -0.01748878f, -0.34078324f, 
    -0.05265258f, 0.08185346f, -0.30359918f, -0.10540494f, 0.17749415f, 0.08868615f, 0.04691939f, -0.12288546f, 
    0.24615327f, 0.34743267f, 0.28417674f, 0.17864555f, -0.09920298f, -0.31313771f, -0.06759798f, -0.06307931f, 
    -0.06023534f, 0.33251941f, -0.12672417f, -0.47379580f, -0.05899243f, 0.13291700f, -0.02298391f, -0.02028351f, 
    0.05192968f, -0.20251378f, 0.29863381f, -0.23308317f, 0.03007451f, -0.06439931f, 0.11604096f, 0.12140196f, 
    -0.05678525f, -0.09904063f, 0.05437556f, 0.09759019f, -0.33411613f, -0.19524238f, -0.05952625f, -0.01595691f, 
    -0.11315604f, -0.14851324f, 0.03468920f, -0.01187079f, 0.15017061f, 0.02174123f, 0.20189749f, -0.04575840f, 
    0.09107834f, 0.04018627f, -0.22704144f, 0.13360889f, 0.01639393f, -0.12789169f, 0.16764450f, 0.07307842f, 
    -0.20002177f, 0.02011144f, -0.11267365f, -0.07366879f, 0.03717982f, -0.09659442f, -0.11939106f, -0.03352107f, 
    0.22270040f, -0.07568749f, -0.01597100f, -0.02980246f, -0.00079201f, -0.08894503f, 0.09875053f, -0.01978251f, 
    0.07806329f, 0.07523241f, -0.23800962f, -0.03098629f, -0.05864846f, 0.14988551f, 0.11433522f, -0.15694547f, 
    0.00341589f, 0.17355053f, 0.20899393f, -0.02014998f, -0.04670253f, -0.11403822f, 0.15509433f, -0.11860516f, 
    -0.10410144f, 0.04321644f, 0.04527807f, -0.45080391f, 0.02635823f, -0.36578247f, 0.12112322f, -0.14941606f, 
    -0.04357032f, -0.06327098f, -0.16882360f, -0.23233384f, 0.05350890f, -0.09211293f, 0.16758810f, 0.12562820f, 
    -0.13574557f, -0.00363311f, 0.20252730f, 0.05038333f, 0.24942596f, -0.16033465f, 0.08063044f, -0.12177756f, 
    -0.08487009f, -0.01852542f, -0.03999648f, -0.19659817f, 0.28738734f, -0.00067237f, 0.05477685f, -0.19834691f, 
    -0.10486288f, -0.18063389f, -0.06760823f, -0.00998401f, -0.05054951f, -0.05053177f, 0.36271745f, 0.11981671f, 
    0.05737830f, 0.04585677f, -0.13469622f, 0.05501658f, 0.02078300f, 0.00357236f, 0.11392877f, 0.21058458f, 
    0.35649982f, 0.13872537f, 0.26232582f, 0.12142410f, -0.16081633f, 0.03186457f, 0.10339571f, -0.12362076f, 
    0.04342740f, 0.01202185f, -0.05879512f, 0.07122345f, -0.08493754f, -0.09261236f, 0.03485969f, -0.17806503f, 
    -0.00663745f, 0.21594283f, 0.21050543f, -0.10078876f, -0.08634405f, 0.02865398f, -0.00281266f, 0.11809129f, 
    -0.01377938f, 0.07088351f, 0.12795813f, -0.05904977f, 0.12426201f, 0.14274889f, -0.14606078f, -0.06455994f, 
    0.16078597f, -0.32693252f, -0.15882990f, 0.14495640f, 0.19543685f, 0.06724825f, 0.11331071f, -0.05644399f, 
    -0.06206866f, 0.00922384f, -0.27523109f, 0.14235675f, 0.39399773f, 0.39753652f, 0.15408495f, -0.06106692f, 
    0.08096929f, -0.08446051f, 0.07406124f, -0.27015248f, 0.20482512f, -0.15090978f, -0.01980527f, 0.08402400f, 
    -0.03555383f, 0.07807413f, -0.12946039f, 0.07659771f, 0.07260020f, -0.27401987f, -0.07768448f, -0.24391854f, 
    -0.10781304f, 0.02693646f, -0.05845591f, -0.25886661f, 0.11325599f, -0.24675874f, 0.15654552f, 0.10258904f, 
    -0.28070605f, 0.07394232f, 0.03184421f, 0.09428225f, 0.25245553f, -0.03111943f, 0.32109046f, -0.03620409f, 
    0.20526671f, -0.45491925f, 0.14979100f, -0.14875208f, 0.11784691f, 0.00025364f, -0.06769155f, 0.01045521f, 
    0.03882578f, -0.02593752f, -0.05976976f, 0.02866416f, 0.02638200f, -0.00762275f, 0.02622706f, 0.01015724f, 
    -0.01264818f, 0.04590558f, 0.03476794f, 0.00292115f, 0.03713179f, -0.00298288f, -0.02846801f, 0.01041908f, 
    -0.06015966f, -0.04527245f, -0.02655135f, -0.01490987f, 0.01800363f, -0.01749495f, 0.02967771f, -0.06103218f, 
    0.00509037f, 0.03333808f, 0.04729568f, 0.02577577f, 0.04140731f, -0.01979631f, 0.00797765f, -0.02393757f, 
    0.03781978f, -0.05781864f, -0.01892203f, 0.01123317f, -0.05273839f, -0.01330036f, 0.01559641f, 0.02835686f, 
    -0.00165925f, -0.00422073f, -0.02046872f, -0.03669789f, -0.06316284f, 0.00623427f, 0.03559444f, -0.01371449f, 
    0.03702338f, 0.00101181f, 0.02419551f, -0.04599084f, 0.05587911f, 0.05008756f, -0.00356258f, -0.00459513f, 
    0.03103856f, 0.02376820f, -0.03377431f, 0.00947046f, -0.04433123f, -0.04095277f, 0.00652597f, 0.00916088f, 
    -0.05376138f, -0.03071153f, 0.02326651f, -0.02660399f, -0.04224572f, 0.02747897f, -0.02300851f, -0.04021336f, 
    -0.00053642f, -0.00913533f, -0.00478353f, -0.02137708f, -0.04765722f, 0.03837943f, -0.02156720f, 0.00254550f, 
    0.05137748f, -0.04381264f, -0.05542214f, -0.03173658f, -0.03363948f, 0.00657188f, -0.04431753f, -0.00838451f, 
    0.02187838f, 0.03040969f, 0.00712052f, -0.04365849f, -0.05198371f, -0.05223325f, -0.03322187f, -0.04368149f, 
    -0.00121035f, -0.03192535f, 0.01553703f, -0.01849335f, -0.04040554f, -0.01302065f, -0.04336891f, -0.02303798f, 
    0.04447105f, -0.05647582f, -0.04575219f, 0.02277311f, -0.03466553f, -0.02704157f, -0.04823440f, 0.03151081f, 
    -0.00953567f, -0.02491429f, -0.00054111f, -0.01775645f, 0.02996985f, 0.00428396f, -0.01756070f, -0.01871766f, 
    -0.02707919f, -0.00683656f, -0.03351688f, 0.03644619f, 0.00603421f, 0.04609711f, -0.01962036f, -0.04335246f, 
    -0.06370603f, -0.03492567f, 0.02069238f, 0.02245662f, 0.05316043f, 0.01144847f, 0.03407285f, -0.03329071f, 
    0.02068163f, -0.01660559f, -0.01323330f, -0.04022582f, 0.03047270f, 0.03770057f, -0.05226534f, 0.00579949f, 
    -0.02124705f, -0.03752495f, -0.06301681f, 0.01862720f, -0.02449734f, -0.04184655f, -0.02721631f, -0.01096024f, 
    0.02279608f, 0.04638354f, -0.02131454f, -0.02089870f, -0.05046040f, -0.05856226f, -0.01231223f, 0.03787646f, 
    -0.05596914f, 0.03070457f, -0.01010574f, 0.05345757f, -0.04533447f, -0.00252051f, -0.01822542f, 0.02291527f, 
    -0.03412320f, -0.00092757f, -0.05286985f, 0.04918945f, -0.03658254f, 0.01812319f, -0.03568741f, -0.01603111f, 
    0.01923279f, 0.02303255f, -0.06011655f, 0.01249797f, 0.01025458f, 0.02761390f, 0.03947691f, 0.03038901f, 
    -0.03757413f, -0.00665561f, -0.01698091f, -0.04256859f, -0.01418850f, 0.00943471f, -0.00146712f, -0.03173827f, 
    0.03428532f, -0.01954887f, -0.06323683f, 0.00614683f, -0.01177665f, 0.02444148f, -0.05798441f, -0.00285213f, 
    0.00999962f, -0.03537267f, -0.02889079f, 0.01296163f, 0.01685030f, -0.05136002f, 0.00143415f, 0.03428291f, 
    0.04055987f, 0.02135756f, -0.00946390f, -0.03550687f, -0.05164981f, 0.00615775f, -0.03089425f, 0.01197358f, 
    -0.06244730f, -0.04172190f, 0.03209950f, -0.03014786f, 0.01411258f, -0.04111061f, -0.03362322f, 0.00388593f, 
    0.00864132f, -0.05085807f, 0.01328960f, -0.05565514f, 0.00044418f, -0.05662825f, -0.01443777f, 0.00711368f, 
    0.04301725f, -0.02455734f, -0.00432758f, -0.00170142f, 0.02257373f, -0.04873348f, -0.05320251f, -0.04458562f, 
    -0.03721245f, -0.06122090f, 0.02375097f, 0.02930271f, -0.04491406f, 0.03965917f, 0.05289615f, 0.01568489f, 
    0.00175777f, -0.01392746f, -0.05053257f, 0.01491134f, -0.04542020f, 0.00884546f, 0.04240430f, 0.04179593f, 
    -0.01587371f, 0.01821397f, -0.02555777f, 0.03325546f, 0.01276265f, 0.01244984f, -0.04398930f, 0.01621182f, 
    -0.02545666f, -0.02958310f, -0.04817238f, -0.02018579f, -0.03152820f, 0.04900163f, -0.05154247f, 0.05086821f, 
    0.05602510f, 0.01772181f, -0.04268504f, 0.00091240f, 0.01156774f, -0.06203514f, -0.01380836f, 0.01471002f, 
    0.03411898f, 0.05420004f, 0.03591830f, -0.01436843f, -0.05330860f, 0.02147833f, -0.05030908f, 0.00322883f, 
    -0.06517657f, -0.02773211f, 0.09867991f, -0.41955400f, -0.32674429f, -0.52747363f, -0.01643728f, -0.20334351f, 
    -0.03295849f, -0.12908171f, 0.04019153f, 0.31563681f, -0.21421640f, 0.03463268f, 0.04784183f, 0.11680422f, 
    0.21069176f, -0.04052893f, -0.51281375f, -0.51571774f, 0.06525145f, 0.09583802f, -0.06610473f, -0.17314538f, 
    -0.29058433f, -0.27695373f, -0.18054697f, 0.10184197f, 0.13060677f, 0.11799230f, 0.12687430f, 0.02698010f, 
    -0.16803895f, -0.04487037f, -0.02583790f, -0.01810887f, -0.11060075f, 0.10482266f, 0.12998234f, -0.08095737f, 
    -0.20891266f, -0.25999662f, -0.01314202f, -0.25335985f, -0.03310719f, 0.23528810f, 0.14757848f, 0.21996567f, 
    0.04034759f, -0.10163540f, 0.07433727f, 0.07080892f, 0.03007678f, 0.02186091f, 0.04406231f, 0.12387137f, 
    0.11839602f, 0.01866553f, -0.03691375f, 0.09807020f, 0.07303294f, -0.00379971f, -0.05576276f, 0.09813004f, 
    -0.29102492f, 0.03194761f, 0.15923911f, -0.17334278f, 0.14153476f, -0.36331120f, -0.24218974f, -0.41069117f, 
    0.12651843f, 0.31792927f, 0.72831482f, 0.02084116f, 0.12811534f, 0.06553948f, 0.06047295f, 0.04447732f, 
    0.11585373f, 0.08345527f, 0.03184120f, 0.14510152f, -0.07788400f, -0.06683969f, -0.07617728f, 0.01374934f, 
    0.09669513f, 0.05292594f, -0.25418150f, 0.05477325f, 0.14347036f, -0.09789532f, -0.11104850f, -0.31618485f, 
    0.04834823f, -0.04984106f, 0.03612494f, -0.01541692f, 0.13969147f, -0.17974779f, 0.01045209f, -0.01286884f, 
    -0.04835954f, -0.06500719f, -0.03032564f, 0.03899139f, 0.32784995f, 0.49331337f, 0.28850317f, 0.05776636f, 
    0.01283367f, -0.02967399f, 0.13320629f, 0.20787239f, 0.08774344f, -0.18836218f, -0.04000780f, 0.18117905f, 
    0.08706031f, 0.12506339f, 0.03377806f, -0.14422010f, -0.08338083f, -0.16620806f, -0.05032773f, -0.07081980f, 
    -0.03654315f, -0.00300267f, 0.03945488f, 0.01111493f, -0.11540880f, -0.09657028f, -0.21125397f, 0.00588801f, 
    -0.08119282f, 0.07860142f, 0.00485684f, 0.07599692f, 0.02848238f, -0.19399999f, -0.01735855f, -0.03090841f, 
    0.11831659f, 0.34750089f, 0.45776811f, 0.36554304f, 0.14828454f, 0.09494355f, 0.10236276f, -0.01807722f, 
    0.12583628f, -0.08089356f, 0.08576971f, 0.21503860f, -0.16114101f, 0.18890138f, -0.25448552f, -0.09333782f, 
    -0.16310935f, -0.11935760f, -0.03594268f, 0.02078527f, -0.10887514f, 0.03233491f, -0.12704276f, -0.18153155f, 
    -0.10676824f, 0.14957185f, -0.05347810f, 0.02281941f, 0.03017638f, 0.11636464f, 0.12512794f, 0.01973404f, 
    0.07608844f, -0.13422734f, -0.21146262f, -0.21204680f, -0.21909852f, -0.01045917f, -0.03556298f, -0.05391024f, 
    0.05378138f, -0.07481100f, 0.20919266f, -0.01078435f, 0.06741498f, 0.15485902f, -0.29665461f, 0.02758075f, 
    0.04613287f, 0.02900434f, 0.05896577f, -0.03284075f, -0.25315848f, -0.11158471f, 0.12501712f, 0.44984800f, 
    0.29997817f, 0.03732620f, 0.01690402f, 0.07044914f, 0.27056760f, 0.29498520f, 0.23329169f, -0.07203545f, 
    0.02186700f, 0.11292405f, 0.11800195f, -0.09320056f, 0.05250393f, -0.03786691f, 0.14432989f, 0.11818361f, 
    0.16678663f, 0.06067472f, 0.09499513f, 0.30516735f, 0.13969317f, 0.14926820f, 0.25350296f, 0.04661628f, 
    0.06002625f, -0.12089136f, 0.11653869f, 0.02249802f, -0.02127644f, -0.05338725f, 0.07722284f, -0.03883826f, 
    -0.00052695f, 0.15643786f, 0.05408785f, 0.09989189f, 0.10069326f, 0.06380039f, 0.04887636f, 0.18034998f, 
    0.07791172f, 0.08073498f, -0.37883696f, -0.07780667f, -0.08305617f, 0.12317100f, 0.14749417f, 0.12472244f, 
    0.07739599f, -0.03272326f, 0.06457669f, -0.00923958f, -0.20936446f, -0.06788336f, 0.07968611f, -0.23724437f, 
    0.00015168f, -0.17446649f, -0.03754056f, -0.15310639f, -0.15739512f, 0.09561022f, -0.00610954f, 0.11730377f, 
    -0.28574488f, -0.06158778f, -0.09958714f, 0.07986566f, -0.16209504f, -0.07390618f, 0.18385607f, 0.30076745f, 
    0.45371068f, -0.20621502f, 0.28347132f, 0.03126976f, -0.15187111f, 0.01696081f, -0.44707218f, 0.29562977f, 
    0.18060426f, 0.15745161f, 0.04924000f, -0.11882040f, -0.16701822f, -0.10467307f, -0.21845163f, -0.08953075f, 
    0.02511200f, 0.02368910f, -0.06233566f, 0.01362507f, -0.03492465f, -0.02324364f, 0.04720086f, -0.01480627f, 
    0.03018250f, 0.03662794f, -0.04787187f, -0.02585331f, 0.02690843f, 0.02997096f, 0.04440273f, -0.04617376f, 
    0.04295237f, -0.00919490f, -0.04380078f, -0.05092948f, -0.05080171f, -0.02559138f, 0.03340371f, 0.05211031f, 
    -0.00717283f, 0.03123784f, 0.01619458f, -0.00522071f, -0.02142876f, 0.03038127f, -0.00931458f, 0.01792388f, 
    0.01934766f, 0.01313140f, -0.02381753f, 0.00770328f, 0.05200020f, -0.05401998f, -0.06356446f, 0.01928402f, 
    -0.04588440f, 0.03692126f, -0.05238029f, -0.00305319f, 0.00900961f, 0.02736176f, -0.01585991f, 0.01094499f, 
    0.03134319f, -0.03864848f, -0.00802266f, -0.03535644f, -0.03908818f, 0.00212178f, -0.00045871f, -0.03396718f, 
    -0.01681615f, 0.01426287f, 0.00769501f, -0.03768455f, 0.04793424f, 0.01315756f, -0.04073223f, 0.04370761f, 
    -0.01154457f, 0.02065569f, -0.05813144f, 0.00668234f, -0.00803459f, 0.01522170f, -0.03507122f, -0.01886400f, 
    -0.03807148f, -0.02623493f, -0.06300314f, 0.05309335f, 0.04492408f, 0.03722911f, -0.01791648f, 0.02644257f, 
    0.05543834f, 0.02664068f, -0.02994198f, -0.02602640f, -0.05422562f, 0.04070517f, -0.04269595f, 0.04631412f, 
    -0.01641342f, -0.00249674f, -0.02645138f, -0.04088953f, -0.00535625f, -0.02404021f, 0.01892263f, -0.04289680f, 
    0.04118077f, -0.01676395f, 0.02996498f, -0.06188269f, -0.03465899f, -0.01378975f, 0.02432113f, -0.02734719f, 
    -0.05979904f, 0.04422143f, 0.04694508f, 0.00446827f, -0.06296907f, 0.01827939f, 0.03593891f, 0.02202542f, 
    -0.01674329f, -0.00969966f, 0.00385461f, 0.03730530f, 0.02699364f, -0.01761653f, 0.03541728f, -0.00185908f, 
    0.02711920f, 0.04144438f, 0.03735314f, 0.02385959f, -0.03326119f, 0.00027334f, -0.04551430f, -0.03499578f, 
    -0.02578179f, -0.03591237f, -0.06181223f, -0.02933054f, -0.03115171f, 0.01000401f, 0.01386625f, -0.02772721f, 
    -0.04212166f, -0.02468943f, -0.01134740f, -0.01505429f, -0.04796669f, -0.03972116f, -0.01778265f, 0.03840956f, 
    -0.02610300f, -0.04129641f, -0.04743253f, -0.05582900f, 0.04062962f, -0.00411525f, 0.01912452f, -0.02426742f, 
    -0.01822886f, -0.03266782f, -0.02328393f, 0.03611282f, -0.05307447f, 0.03044520f, 0.04174226f, -0.01648173f, 
    0.04917273f, -0.04315666f, -0.00925839f, -0.02237561f, -0.05579929f, 0.00409642f, 0.03656866f, -0.01552910f, 
    0.00296132f, -0.04119401f, 0.01490943f, -0.04484338f, 0.04191997f, -0.01766530f, 0.04226966f, -0.00430775f, 
    -0.00802480f, 0.03463392f, -0.00596993f, 0.01034578f, -0.04479199f, -0.05938192f, 0.00388757f, -0.06318547f, 
    0.05010583f, -0.00578115f, -0.05214580f, -0.04815295f, -0.04088387f, 0.01721009f, -0.02227658f, -0.06493361f, 
    0.02786998f, -0.02270795f, -0.01451395f, -0.00094443f, -0.00746827f, -0.01666930f, -0.05720796f, 0.01692433f, 
    0.01968937f, 0.01828125f, -0.05559799f, -0.04696669f, 0.01505018f, 0.00966700f, -0.00226928f, -0.05755117f, 
    0.00203929f, 0.01125410f, -0.00446393f, 0.02034298f, -0.04708153f, 0.04873314f, 0.01460338f, -0.04222051f, 
    -0.01583838f, -0.02615100f, 0.01823292f, 0.04239238f, 0.04236519f, 0.04804120f, -0.02414094f, 0.00221855f, 
    -0.02317673f, -0.06587839f, -0.01443468f, -0.01171906f, -0.03199346f, -0.02827596f, 0.03727089f, -0.01641355f, 
    0.03745560f, -0.02354565f, -0.02118509f, 0.02193278f, 0.03934425f, 0.01837587f, 0.01783533f, -0.03468334f, 
    0.03955138f, -0.00122301f, -0.02119679f, 0.03633631f, -0.03573289f, 0.02131017f, -0.01119748f, -0.02222802f, 
    -0.04846339f, 0.05238622f, -0.03140485f, -0.04955221f, -0.05984126f, -0.00514027f, -0.01336698f, 0.03162479f, 
    -0.06093974f, -0.02025532f, 0.01365104f, -0.03046570f, -0.04530741f, -0.05410553f, -0.01698758f, -0.02953925f, 
    0.01496313f, -0.01516517f, -0.03528726f, -0.04176689f, -0.05140144f, -0.02738604f, 0.01340750f, 0.05323564f, 
    -0.01410323f, -0.01934019f, -0.05275595f, -0.05118873f, -0.00988138f, -0.06032665f, -0.02712121f, 0.02814658f, 
    -0.02216796f, 0.04859341f, 0.04922679f, 0.01120063f, -0.06256266f, -0.01973695f, 0.00373255f, -0.03829452f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.22978228f, 0.38461795f, -0.04425440f, -0.00749304f, 0.05887196f, 0.23558027f, -0.02805719f, 0.13355058f, 
    0.08025491f, 0.02817466f, 0.04012141f, 0.01996992f, 0.02279010f, 0.06501316f, 0.37192106f, -0.03936112f, 
    -0.02588089f, -0.11575572f, 0.37675995f, -0.21241301f, 0.06707342f, 0.04527197f, 0.02745803f, 0.44415033f, 
    -0.10561503f, 0.07149180f, -0.02181869f, 0.12334687f, -0.16353072f, -0.01005384f, 0.05566787f, -0.02811286f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00070314f, -1.02497065f, -0.16754109f, 0.10355352f, -0.00771765f, -0.58200783f, -0.16245046f, -0.02792207f, 
    0.28786752f, 0.14843956f, 0.00395144f, 0.56660122f, 0.15903936f, -0.15216203f, -0.20629749f, -0.15151288f, 
    0.00744865f, 0.31304806f, 0.08192824f, 0.05593508f, -0.23910812f, 0.10195556f, 0.14350018f, -0.16563562f, 
    0.56075633f, 0.09335615f, 0.13037597f, 0.14409076f, 0.38633507f, -0.02925566f, 0.04819232f, -0.12370508f, 
    0.21839914f, 0.27896073f, 0.00297867f, 0.02595494f, -0.09296523f, -0.14671735f, -0.28632891f, 0.16770038f, 
    -0.19862975f, 0.02632895f, -0.12649208f, -0.08108415f, 0.00878825f, -0.06701325f, -0.00961848f, 0.11537786f, 
    -0.28338024f, 0.13204771f, 0.31846023f, -0.33479697f, -0.01109260f, -0.09914678f, 0.10423183f, 0.20638768f, 
    1.08889437f, 0.09422669f, -0.14771841f, 0.09847355f, -0.63089031f, 0.10705863f, 0.13464276f, -0.09573523f, 
    -0.31117016f, 0.46871775f, -0.05066567f, 0.01023054f, -0.44276178f, -0.01641529f, -0.12124012f, 0.57727736f, 
    -0.03598320f, 0.06187094f, 0.05197588f, -0.98162425f, 0.12200164f, 0.10969210f, 0.59739113f, 0.02124686f, 
    0.23504674f, 0.05836374f, -0.17373061f, 0.28177258f, 0.09094240f, -0.00243610f, -0.02451166f, -0.05537467f, 
    -0.11311123f, -0.18730229f, 0.10710080f, -0.52687234f, -1.03520536f, -0.16479690f, -0.27093333f, -0.01332563f, 
    -0.52802742f, -0.52236468f, 0.09743939f, -0.15205626f, -0.47388083f, 0.05655069f, 0.54918903f, -0.01163714f, 
    0.21812066f, 0.02930637f, -0.10185750f, -0.42061827f, 0.06619442f, 0.00171200f, -1.00325966f, 0.09693689f, 
    0.28560492f, -0.04063989f, -0.51930070f, 0.27930832f, -0.00123158f, -0.04542021f, 0.07949657f, -0.40216362f, 
    -0.11522458f, -0.16779654f, 0.14524601f, 0.79397613f, 0.12429219f, 0.07861075f, 0.17962027f, -0.09110738f, 
    -0.19911434f, -0.60820317f, -0.01905803f, -0.03706299f, -0.18634252f, 0.01261087f, -0.09010915f, -0.18225096f, 
    -0.19817878f, -0.09193373f, -0.00727574f, 0.49896684f, -0.13493949f, -0.41262293f, 0.12537530f, -0.15924019f, 
    0.12392866f, -0.11759683f, -0.11522766f, 0.17896767f, 0.18055715f, 0.11049680f, 0.07348932f, -0.09213094f, 
    -0.18670425f, -0.13383892f, -0.14436756f, -0.16857974f, -0.00201962f, 0.00670846f, 0.41980124f, -0.17882694f, 
    0.14843784f, 0.23265858f, 0.00723622f, -0.12684613f, 0.50222558f, -0.09542231f, -0.15838267f, 0.58475178f, 
    -0.30469713f, -0.12108379f, -0.17406777f, 0.20826836f, -0.07337734f, 0.30524290f, -0.10465799f, -0.01346389f, 
    -0.28666258f, -0.06154354f, -0.11577231f, -0.02905758f, -0.06512538f, -0.05020791f, -0.06813594f, -0.29753205f, 
    -0.35267004f, 0.03985065f, -0.11209001f, 0.11369231f, 0.05826972f, 0.08479600f, 0.02330018f, 0.05029899f, 
    0.33925486f, -0.42422700f, -0.02836694f, -0.02710938f, -0.12513793f, 0.19742012f, -0.00577503f, -1.13673949f, 
    -0.58258045f, -0.01140630f, -0.12894712f, -0.30073330f, -0.00669205f, 0.28561279f, 0.51837122f, -0.03006442f, 
    0.31985083f, -0.11982089f, -0.48810372f, -0.04345927f, -0.15633580f, -0.00361909f, 0.02908107f, 0.69305593f, 
    -0.06167907f, -0.56095129f, 0.05690359f, -0.36879641f, -0.11489233f, 0.15362330f, -0.59547162f, 0.07196666f, 
    0.17135994f, -1.15766799f, 0.15830436f, -0.09517942f, 0.03532858f, 0.00008223f, 0.41271168f, 0.18112229f, 
    0.28042883f, -0.11951541f, 0.02924448f, -1.07991445f, 0.14294150f, -0.27488124f, -0.14400791f, -0.07748409f, 
    -0.15242510f, -0.04719424f, 0.35666317f, 0.24069725f, -0.07714068f, -0.08911588f, 0.08450031f, -0.39484483f, 
    0.27277416f, -0.23995130f, 0.06900761f, -0.61945724f, 0.29313856f, 0.16570105f, -0.03674623f, 0.01145804f, 
    -0.38988477f, 0.06415188f, -0.13679515f, 0.06763551f, -0.23783739f, 0.16562413f, -0.62385237f, -0.74306256f, 
    0.32462037f, 0.10100356f, -0.10944141f, -0.41255918f, 0.07225837f, 0.53646743f, -0.44437155f, -0.05498892f, 
    -0.18298383f, -0.39821014f, 0.51077306f, -0.55771333f, 0.42458537f, -0.14398551f, -0.07573079f, -0.15981816f, 
    -0.39034277f, -0.01761140f, -0.02236623f, -0.04244779f, -0.42937189f, -0.10811782f, -0.11419952f, 0.12319668f, 
    0.02505432f, 0.76966661f, -0.17917536f, -0.12006460f, -0.49039671f, 0.14001638f, 0.13674848f, -0.23971400f, 
    -0.11444052f, 0.11680423f, -0.04812258f, 0.45301014f, 0.16122106f, -0.28080496f, -0.10596852f, 0.13125649f, 
    0.19901623f, 0.42557386f, -0.24756286f, -0.25383869f, -0.33246365f, -0.11141300f, 0.08706204f, 0.39229602f, 
    -0.38746369f, 0.24874169f, 0.04362933f, -1.03980827f, 0.51026559f, -0.02427358f, -0.23604257f, -0.03494596f, 
    -0.51125735f, 0.10722311f, 0.05107385f, -0.15999873f, 0.73524582f, -0.29864785f, 0.28489283f, -0.47442833f, 
    0.14558320f, 0.05782529f, -0.12200255f, -0.31518888f, 0.12162873f, -0.23247923f, 0.32790422f, -0.10672302f, 
    -0.45998794f, -0.67356682f, -0.63997352f, -0.19868320f, 0.31084850f, 0.16587031f, 0.00042868f, -0.07475012f, 
    -0.68752164f, 0.57562786f, -0.03400826f, -0.08558752f, -0.34415486f, 0.00373963f, 0.02308855f, -0.07314779f, 
    -0.06386262f, -0.38868231f, -0.11696024f, 0.11254861f, -0.12864234f, 0.40109187f, -0.25044945f, -0.65964520f, 
    -0.92067337f, -0.03977389f, 0.02965540f, -0.25679344f, -0.04464855f, -0.37889823f, -0.64732283f, -0.15156701f, 
    0.53674275f, -0.80324769f, 0.25760487f, -0.49795395f, 0.19743995f, 0.04865608f, 0.02084656f, -0.01198442f, 
    -0.17042635f, 0.48099414f, 0.12294716f, 0.23116846f, 0.09484750f, 0.00225758f, -0.61990601f, 0.13581996f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.44952545f, 0.14304975f, 0.24868686f, -0.00448881f, -0.11290438f, 0.01751252f, 0.00685694f, -0.11030803f, 
    -0.10773113f, 0.14032760f, 0.11076097f, 0.25885028f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
