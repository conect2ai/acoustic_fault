#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.06791802f, 0.84211737f, 0.94123292f, 0.15069394f, 0.70317793f, -1.17963696f, 0.28992736f, -0.41996178f, 
    -0.44244602f, -0.29405907f, 0.45890021f, -0.08779044f, 0.33773795f, 0.16591500f, 0.15122958f, 0.13072261f, 
    0.14647979f, -0.14584754f, -0.10882737f, 0.41518730f, -0.60919726f, -0.02337376f, 0.04742565f, -0.19449891f, 
    -0.04467720f, 0.89354461f, 0.54949993f, 0.87436110f, 0.79691452f, 0.11228037f, -0.36866361f, -0.02789926f, 
    -0.46047407f, 0.12442605f, 0.67596042f, 0.12383357f, -0.39541617f, -0.39292067f, -0.05868936f, -0.53238899f, 
    -0.38022080f, -0.28396130f, -0.07754338f, 0.12663262f, -0.50283539f, 0.01346914f, 0.40060988f, 0.02544067f, 
    0.48526144f, -0.03150751f, -0.83486068f, -1.07304049f, -0.07794602f, 0.68781090f, -0.98297310f, -0.59395474f, 
    0.25753903f, 0.80576307f, 0.30712381f, -0.03910368f, -0.24658014f, -0.33801258f, -0.21767643f, 0.64311510f, 
    -0.47634608f, -0.27664995f, -0.17292282f, 0.03262915f, -0.58773017f, -0.00685849f, 0.04347608f, 0.14345814f, 
    0.28938130f, -0.14798552f, 0.34438533f, 1.15472150f, 1.25104034f, 0.70164901f, -0.01623655f, -0.40660933f, 
    -0.39210418f, -0.83093798f, 0.05745197f, -0.46390545f, 0.10661200f, 0.27021447f, 0.24312852f, 0.01200239f, 
    0.02834484f, -0.01919699f, -0.15198204f, -0.09939098f, 0.14570469f, -0.05351350f, -0.05866003f, -0.08843529f, 
    0.43613547f, 0.27362984f, -0.14706233f, 0.26822084f, -0.10154674f, 0.39504674f, -0.45977050f, 0.10761851f, 
    0.53394479f, -0.54469997f, -0.63043857f, 0.53833503f, 0.23584299f, -0.00606435f, -0.08728606f, -0.06951535f, 
    -0.41955045f, -0.12390761f, 0.43861952f, 0.47294706f, -0.47415313f, 0.53458792f, -0.30801716f, 0.25573048f, 
    0.62002772f, 0.47723386f, -0.17527331f, 0.25172681f, 0.56718153f, 1.25660825f, 0.20967802f, 0.09701110f, 
    1.06669509f, 0.68213958f, -0.80443674f, -0.34353134f, 0.05649725f, -0.39997146f, -0.40945745f, -0.29857555f, 
    -0.43534961f, 0.31004691f, -0.28840902f, 0.19913127f, 0.24838850f, 0.31843150f, 0.13427837f, 0.05790762f, 
    0.13166988f, -0.07507582f, -0.01196461f, -0.03282751f, -0.27461261f, 0.08021966f, -0.44120559f, -0.41720557f, 
    -1.17529094f, -0.57419419f, 0.54675949f, -0.56406903f, 0.22736305f, 0.62749982f, 0.30689526f, 0.45484835f, 
    -0.28444600f, -0.14576717f, 0.31965703f, -0.24507019f, -0.12049277f, 0.10468299f, -0.26248845f, -0.19954944f, 
    -0.53638953f, -0.29696271f, -0.26137614f, -0.13546607f, -0.17599495f, 0.49146172f, 0.01885915f, -0.27490622f, 
    -0.03674021f, -0.62963313f, -0.97316688f, -0.55831665f, 0.18036929f, 0.36581701f, -0.19574109f, -0.57219291f, 
    0.45376018f, 0.28896496f, -0.02889705f, -0.50640374f, -0.33474922f, -0.35680899f, 0.05922312f, 0.10351324f, 
    0.37112257f, 0.29183295f, 0.30133510f, -0.06986509f, 0.22002012f, 0.20425247f, -0.04841280f, 0.62679255f, 
    0.75703055f, -0.06119748f, 0.53360963f, -0.49674228f, -0.66455215f, -0.45064268f, -0.33725822f, -0.06131236f, 
    -0.19387662f, -0.02267522f, 0.02266036f, -0.32228601f, 0.18052270f, 0.61290109f, -0.51904523f, -0.54696864f, 
    -0.16339189f, 0.17112912f, -0.56640345f, 0.05697312f, 0.66875452f, 0.12388560f, 0.02874744f, -0.30454057f, 
    -0.25031742f, 1.28850913f, 0.31928498f, -0.15721548f, -0.73205173f, -0.94423175f, -0.28159010f, 0.35428086f, 
    -0.03462526f, -0.10488598f, -0.17883164f, 0.62449110f, 0.32650697f, 0.22569261f, 0.13156237f, 0.31896454f, 
    0.23001765f, 0.36064526f, 0.01838933f, 0.20582244f, 0.40345848f, -0.46807256f, 0.05107149f, -0.01469134f, 
    0.09171047f, -0.07034455f, -0.45440367f, -0.06270523f, 0.79147726f, 0.29914764f, 0.36064953f, -1.04698086f, 
    -0.52638030f, -0.82686853f, -0.68223405f, 0.24957193f, 0.08877107f, 0.41820267f, 0.04362934f, 0.12147497f, 
    -0.04318327f, -0.27761525f, -0.12386203f, -0.32827675f, 0.19790640f, -0.33884639f, 0.33364463f, 0.28732845f, 
    -0.01004368f, 0.11160388f, 0.26559985f, 0.59377509f, -0.73818189f, 0.75333595f, 0.60992128f, -0.40665898f, 
    -0.21336700f, -0.07539175f, 0.07469197f, -0.06129865f, -0.05542939f, 0.21365562f, -0.12616079f, -0.13222866f, 
    -0.46275541f, 0.16848888f, -0.49348751f, -0.54533762f, -0.70163357f, 0.12064752f, 0.08252588f, -0.51166862f, 
    0.33894619f, 0.35733581f, -0.13143222f, 0.61787200f, 0.31895402f, -0.47732610f, -0.52223718f, -0.91327858f, 
    -0.00507388f, 0.57178581f, -0.87483865f, -0.03262867f, 0.13355653f, 0.23265260f, -0.14973314f, -0.25547037f, 
    -0.43058208f, -0.26294017f, -0.51289010f, 0.35158953f, 0.08834326f, 0.55878580f, 0.40369192f, -0.04674165f, 
    -0.05666684f, 0.35636735f, -0.41409987f, -0.14642160f, -0.00118347f, 0.44698811f, -0.49000382f, 0.00041678f, 
    1.20442784f, 0.97829127f, -0.46160722f, -0.36984235f, 0.39345112f, -0.16191244f, 0.46355629f, 0.50587982f, 
    0.28579521f, -0.30885395f, 0.03198924f, 0.15267131f, -0.03591728f, 0.11535498f, 0.76776689f, -0.04286558f, 
    -0.20182438f, 0.22214276f, 0.28651240f, 0.17367105f, -0.47913122f, 0.05497956f, 0.70157927f, 0.37535709f, 
    0.52274978f, 0.70341885f, 0.33968684f, 0.95509511f, 0.48834783f, -0.33738649f, -0.65652549f, -0.23888259f, 
    0.24327081f, 0.55508745f, 0.38732404f, 0.27426538f, -0.45145914f, 0.37978774f, 0.48400936f, 0.41823027f, 
    0.14831367f, 0.33459622f, -0.24313453f, -0.11885338f, 0.20614929f, -0.02382223f, 0.44841006f, -0.24917462f, 
    -0.11082949f, -0.68946213f, -0.04265242f, -1.00816667f, 1.16872644f, 1.14713991f, -0.40014535f, 0.49141049f, 
    0.81060892f, -0.07583918f, -0.13479829f, -0.21867260f, -0.37083721f, 0.09694705f, -0.12369155f, -0.01052010f, 
    -0.06526446f, -0.12274586f, -0.08800733f, -0.04636172f, -0.18085569f, 0.10457674f, 0.43128702f, -0.12875044f, 
    0.11366894f, 0.03863409f, 0.62776953f, -0.65963978f, 0.34821248f, -1.15574431f, -0.38997537f, -0.46279782f, 
    -0.66483402f, -1.14694905f, 0.06084731f, 0.28238690f, -0.29830658f, 0.03325659f, -0.14250547f, -0.31209767f, 
    -0.18629181f, -0.04798344f, -0.16357806f, 0.52660882f, 0.38909638f, 0.06950445f, -0.13848299f, 0.07219629f, 
    -0.29300672f, 0.70696497f, 1.18653619f, -0.49772683f, 1.00562787f, 0.10752514f, -0.25264898f, 0.18266253f, 
    -1.06080043f, 0.39646679f, -0.09475663f, 0.36928165f, -0.26253897f, 0.25181466f, 0.45987067f, -0.55900782f, 
    0.02051336f, -0.10912638f, 0.16904408f, -0.10352672f, -0.57204807f, 0.23120299f, -0.07685478f, 0.14521763f, 
    0.04326519f, 0.27115014f, 1.27102673f, -0.10708631f, -1.21277845f, -0.51138496f, 0.52376300f, -0.24240865f, 
    0.32500738f, -0.12610190f, 0.42155021f, 0.29560632f, -0.33303693f, -0.23533978f, 0.27414513f, 0.05533297f, 
    0.55335391f, -0.06443986f, -0.26599181f, -0.05396693f, -0.26087704f, 0.13628206f, 0.29008901f, 0.10276517f, 
    0.39067072f, 0.33382702f, -0.15007564f, 1.02636325f, 0.65057677f, 1.23423684f, 0.84817481f, 0.83440751f, 
    0.49418104f, -0.40515456f, -0.09838606f, 0.24460445f, -0.06741725f, 0.03585186f, 0.10313928f, -0.50594372f, 
    0.20432213f, -0.02293909f, 0.30517873f, -0.08451315f, -0.17533545f, 0.11757661f, 0.12785622f, 0.18849722f, 
    0.24613319f, 0.09651690f, -0.50311506f, 0.34033197f, -0.52152783f, -0.71306956f, -1.06014347f, -0.72435206f, 
    -0.47399488f, -0.33896032f, 0.99169022f, 0.80250555f, 0.40023139f, 0.65306169f, -0.23668317f, -0.13170865f, 
    -0.09817855f, -0.44770867f, -0.03570656f, -0.21481073f, 0.34652260f, 0.23625840f, 0.22032171f, -0.12980530f, 
    -0.17463529f, 0.02733707f, -0.07863524f, -0.38237894f, -0.06374826f, -0.78338206f, 0.76134646f, 0.95469564f, 
    -0.32288063f, -1.07912147f, 0.28273016f, 0.47073093f, -0.47531882f, -0.01579212f, 0.85286880f, 0.09613176f, 
    0.46047467f, 0.09378339f, -0.18033765f, 0.17658624f, 0.16932274f, -0.46245858f, 0.13087963f, 0.18381761f, 
    -0.36024147f, -0.08090916f, 0.04700227f, 0.10859308f, 0.01690461f, 0.03463903f, -0.85460442f, 0.73429960f, 
    -0.10241001f, -0.53199768f, 0.71131879f, -0.86086881f, 0.57437211f, -0.47550911f, -1.04005146f, -0.64470607f, 
    -0.42431962f, 0.23926672f, 0.38363156f, -0.06722059f, -0.05976136f, 0.39625841f, 0.36260030f, 0.34790075f, 
    0.28135476f, 0.07114857f, -0.00980888f, -0.05740317f, 0.02567631f, 0.01066893f, 0.18281807f, -1.39143443f, 
    1.16470873f, 0.21989155f, -0.94264227f, -0.42728660f, 0.25582749f, 0.87228298f, -0.30016193f, 0.57488072f, 
    -0.02156214f, -0.48772714f, -0.03138139f, -0.29142210f, -0.16745120f, -0.12496561f, 0.04083652f, 0.17013073f, 
    -0.17314368f, -0.11570945f, -0.02100712f, 0.10052231f, -0.07080565f, -0.10925865f, -0.01858613f, 0.45633620f, 
    -0.30957133f, 1.15664697f, 0.29418853f, -1.16717625f, -0.38275111f, 0.80814064f, -1.03719008f, -0.35661513f, 
    -0.01069095f, -0.24265444f, 0.18174803f, -0.00875855f, -0.07890631f, 0.59390974f, -0.25302970f, 0.21789086f, 
    0.10427671f, -0.04567683f, -0.35442159f, -0.28524855f, -0.22692484f, 0.10529199f, 0.34715807f, -0.10492355f, 
    0.05256150f, -0.45739257f, -0.89765376f, -0.65998542f, -0.55213511f, -0.18845218f, 0.43777081f, -0.39855707f, 
    -0.07089629f, -0.28079972f, -0.26772249f, -0.36756694f, 0.55613250f, 0.54364592f, 0.17184074f, -0.20504475f, 
    -0.66712874f, 0.01815522f, -0.02460244f, 0.21490838f, -0.13668726f, 0.16034721f, -0.26517150f, 0.32744539f, 
    -0.01324579f, -0.23165610f, -0.52704352f, -1.31582260f, -0.26791877f, -0.02627213f, 0.27085453f, -0.83027774f, 
    1.12051225f, 0.84279597f, -0.62604022f, 0.29969165f, 0.13451253f, -0.02653823f, 0.10450931f, -0.08317249f, 
    0.09417024f, -0.31226861f, -0.39251277f, -0.29232064f, 0.02710784f, -0.16179781f, 0.21428400f, 0.08496947f, 
    -0.17663491f, 0.13325274f, -0.00056708f, 0.55022389f, -1.39519274f, 0.67915338f, 0.65298420f, 0.28914624f, 
    0.78406745f, 1.08980644f, 0.51517063f, 0.56664240f, 0.38025403f, -0.03803264f, 0.45649713f, -0.33385134f, 
    0.13777365f, -0.42553881f, 0.03195832f, -0.16880259f, -0.24259676f, -0.23422438f, -0.20680974f, 0.13392171f, 
    0.06089931f, -0.06421304f, -0.07712383f, -0.18031855f, -0.88526917f, 0.27746108f, 1.16820490f, -0.23574096f, 
    0.15347488f, 0.81302851f, 0.12723473f, -0.19850312f, -0.07242066f, 0.34576535f, -0.67057896f, -0.12403948f, 
    -0.44278294f, 0.38241285f, -0.59854192f, -0.10426116f, -0.37306795f, -0.32772943f, -0.60854614f, 0.03040875f, 
    -0.17675708f, -0.18007676f, -0.28587893f, -0.18124822f, -0.74173385f, 1.30918050f, 0.59368724f, -0.32917139f, 
    1.11796725f, 0.96292293f, 0.98505038f, 0.37683246f, 0.24790491f, 0.55649447f, 0.36201286f, -0.42441633f, 
    -0.17188570f, -0.04723731f, -0.18412517f, 0.05038764f, -0.15881938f, -0.14000946f, 0.05411988f, -0.19446987f, 
    0.09770423f, 0.03144305f, -0.19463132f, -0.04764757f, 0.06866010f, 0.12864898f, -1.06669724f, -1.14345348f, 
    -0.81991589f, 0.07316444f, 0.72773838f, 0.19967084f, -0.30966714f, -0.24754131f, -0.15945037f, -0.01541424f, 
    0.31122038f, 0.08801525f, 0.36632726f, -0.16852085f, -0.12749615f, 0.09930322f, -0.03607428f, 0.17444421f, 
    0.05902371f, -0.07854481f, 0.01384124f, -0.06353258f, -0.16886836f, -0.32046658f, -0.27428809f, -1.22019327f, 
    -0.15168439f, -0.17594747f, -0.17186734f, -0.17540975f, -0.68900442f, -0.34116629f, -0.20410840f, -0.45383561f, 
    -0.04057389f, 0.33026657f, 0.78916240f, 0.14440961f, 0.08177865f, 0.01725658f, 0.45348647f, -0.26868635f, 
    -0.01572579f, -0.15960182f, -0.24137962f, -0.40905413f, 0.08899753f, 0.28557739f, -0.00590732f, -0.00323644f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03840723f, 0.14500546f, 0.19993763f, 0.23298955f, 0.25126424f, -0.13457635f, 0.02332409f, -0.08929507f, 
    0.10480897f, 0.14167395f, 0.36526895f, 0.24470805f, 0.13652791f, 0.25378677f, 0.27552038f, 0.23451410f, 
    0.05680910f, 0.34382775f, 0.17574969f, 0.35612890f, 0.23627305f, -0.05306870f, 0.33586377f, -0.09652758f, 
    0.10797441f, 0.30106395f, 0.32383111f, 0.08678000f, -0.01274209f, 0.10122075f, 0.36023867f, 0.33728620f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02959688f, -0.10054279f, -0.21272396f, 0.02788019f, -0.13339435f, -0.10302326f, -0.01792683f, 0.18564057f, 
    0.12263279f, 0.09687951f, 0.03475633f, -0.04771037f, 0.20870484f, -0.03451610f, -0.04564551f, 0.30375627f, 
    0.03139294f, -0.11939459f, 0.03634714f, 0.01689396f, -0.14639843f, 0.07779834f, -0.02483112f, -0.09034491f, 
    0.01375482f, 0.14260197f, -0.39323607f, 0.20513743f, -0.17878819f, 0.07691503f, -0.09046620f, 0.12657160f, 
    -0.00808294f, -0.03145229f, -0.10498587f, 0.00689992f, 0.11055382f, 0.09326861f, 0.11962657f, -0.23252943f, 
    -0.14702703f, -0.12158684f, 0.00236870f, 0.09194380f, -0.10999059f, -0.19829333f, -0.11913568f, -0.06415509f, 
    0.14047267f, -0.04448230f, -0.11225379f, -0.18721764f, 0.10528377f, -0.24295832f, 0.00263583f, -0.11502080f, 
    0.05664550f, 0.09054242f, 0.04492156f, 0.10124720f, 0.32175937f, -0.04857692f, -0.15664817f, 0.36770740f, 
    -0.20959625f, 0.04263851f, -0.04688276f, 0.15454377f, 0.02321740f, 0.06677865f, 0.01744264f, -0.08930179f, 
    -0.01387087f, 0.31224009f, -0.11107186f, -0.38817596f, -0.06542469f, 0.07027619f, 0.00882354f, -0.06852026f, 
    -0.00280597f, 0.13491105f, 0.08694547f, 0.02481251f, -0.09414819f, -0.12112403f, 0.21744314f, -0.50932288f, 
    0.14379042f, -0.03470710f, 0.14581363f, 0.15605704f, -0.05516294f, -0.02114672f, -0.00136067f, 0.05425639f, 
    -0.18174496f, 0.06148937f, 0.00379228f, -0.12881070f, 0.09502494f, 0.01215691f, -0.07133009f, 0.00333395f, 
    -0.24628156f, 0.17313462f, -0.13456915f, -0.05749973f, -0.44058624f, 0.06721725f, 0.22487214f, -0.00130831f, 
    -0.07028203f, 0.05765693f, -0.03078603f, 0.10411432f, 0.02699720f, -0.03261363f, 0.02132651f, -0.05184079f, 
    -0.14845797f, -0.01549513f, -0.00585383f, 0.22834866f, -0.08007625f, 0.08894709f, -0.13820478f, -0.08864207f, 
    -0.12313255f, 0.01523443f, -0.21114530f, 0.11015832f, 0.07868730f, -0.02871557f, -0.04556857f, 0.35293797f, 
    -0.10190617f, -0.06739422f, -0.04134069f, -0.01928111f, -0.13985291f, 0.01927814f, -0.17908165f, 0.08078431f, 
    0.27720448f, -0.31778771f, 0.31889436f, -0.31029966f, -0.12286706f, 0.01179880f, 0.12836674f, -0.06270135f, 
    0.01253439f, 0.12951972f, -0.07845556f, 0.05403113f, 0.27308652f, -0.17185979f, -0.04822777f, 0.38728270f, 
    -0.20899944f, 0.05028452f, -0.11988232f, -0.00721181f, -0.07538506f, -0.07954340f, -0.06516809f, -0.02573966f, 
    -0.09271440f, 0.12124591f, -0.06095855f, 0.02838324f, -0.21658829f, -0.16585678f, -0.14343087f, 0.04439085f, 
    0.02926345f, 0.20804241f, -0.23134150f, 0.10795123f, 0.53604960f, 0.15278415f, 0.09910115f, -0.27773905f, 
    0.09861868f, 0.07365315f, -0.09368704f, -0.06700805f, -0.01681370f, -0.04011449f, 0.03822489f, 0.15815246f, 
    -0.00837070f, 0.17971539f, -0.05776713f, -0.04908643f, -0.03649909f, 0.02421862f, -0.19247429f, 0.04597824f, 
    0.18154518f, -0.34111589f, 0.05729273f, -0.09429015f, -0.07493007f, 0.13666196f, -0.01787529f, 0.14996403f, 
    -0.03746752f, -0.05816139f, -0.05364921f, -0.01146164f, -0.02762942f, -0.01088163f, -0.02627062f, -0.14623867f, 
    0.01491301f, 0.09198033f, 0.03788317f, -0.21611746f, -0.18421830f, 0.00632247f, 0.11638782f, 0.01072766f, 
    -0.16229679f, 0.07063011f, 0.03166748f, 0.02249089f, 0.22747400f, -0.14378253f, -0.06801932f, 0.07913390f, 
    -0.20437355f, -0.08742444f, -0.04856261f, 0.03785469f, 0.11171117f, -0.00698724f, 0.02352379f, -0.13546547f, 
    0.01878882f, 0.21473008f, 0.00134737f, -0.52460146f, 0.08134971f, 0.07337920f, 0.07869614f, 0.10961090f, 
    0.04083708f, -0.12331139f, 0.03459419f, 0.16161382f, 0.29673266f, 0.11128518f, 0.15768509f, 0.04276427f, 
    -0.17461360f, 0.18819830f, 0.10747214f, -0.15499601f, 0.08788133f, 0.09020219f, -0.03594216f, -0.07178157f, 
    -0.49227902f, -0.15683538f, -0.01040486f, 0.00426022f, 0.09384022f, 0.06012144f, -0.07364964f, 0.02219035f, 
    0.02341548f, -0.09713180f, -0.00219185f, -0.00636198f, 0.78483236f, 0.12663524f, 0.28177541f, -0.11720081f, 
    -0.00230479f, 0.14643583f, -0.01037377f, 0.02459661f, 0.01717453f, -0.04048423f, -0.19252273f, 0.01004724f, 
    -0.36387610f, 0.14806978f, 0.05626933f, -0.42706475f, -0.16566086f, 0.01187514f, 0.04977426f, -0.11240907f, 
    0.02481609f, 0.06243053f, -0.12328677f, -0.02997266f, -0.08935709f, -0.17290375f, 0.04366158f, -0.08354063f, 
    0.01508423f, -0.04571803f, 0.12480998f, -0.02117084f, -0.08738558f, 0.11363063f, -0.01279120f, -0.07348420f, 
    -0.55619878f, 0.18360613f, -0.20825325f, -0.10442236f, 0.03829208f, -0.11428607f, -0.12337140f, 0.07349702f, 
    0.03177719f, -0.05257779f, 0.00101899f, 0.01898439f, -0.08585276f, 0.20020291f, -0.09673562f, 0.25158632f, 
    0.01404586f, 0.09913001f, 0.18458577f, -0.14291334f, -0.16487575f, 0.11624899f, -0.00005254f, -0.05414844f, 
    -0.45916548f, -0.18134828f, 0.13359205f, 0.18954277f, -0.08779930f, -0.22577302f, 0.07855412f, -0.04164978f, 
    0.06540181f, -0.12996049f, 0.12599178f, -0.15314652f, 0.21587080f, -0.18509626f, 0.08612261f, 0.42140514f, 
    -0.23023376f, 0.07868789f, 0.00794592f, 0.10106684f, -0.13443412f, 0.07745230f, -0.01160165f, -0.03984719f, 
    -0.11936448f, -0.46252766f, 0.03690950f, 0.10604557f, -0.04208317f, -0.03562302f, -0.10631091f, 0.13314095f, 
    0.03390181f, -0.00901660f, -0.02424809f, -0.09591484f, -0.48348767f, -0.22259608f, 0.01531025f, 0.14938995f, 
    0.14145871f, -0.03504096f, -0.03887971f, 0.05055263f, 0.11375692f, 0.08930610f, -0.03532412f, -0.20900236f, 
    -0.01761627f, 0.14653730f, -0.11410388f, -0.28469267f, -0.05291328f, 0.00635018f, 0.08774768f, -0.23185576f, 
    0.09850859f, -0.02228357f, -0.07142089f, 0.06658771f, 0.29223451f, 0.10896112f, 0.15564662f, 0.38208312f, 
    -0.29014871f, -0.01130795f, 0.18294634f, 0.05023589f, 0.02682475f, -0.10623764f, -0.06486190f, 0.12273552f, 
    -0.44830561f, 0.01915525f, -0.25757572f, 0.20929204f, -0.21000431f, -0.11152473f, -0.09143515f, 0.26117799f, 
    0.08534710f, -0.07337346f, 0.03785946f, 0.09410712f, 0.15581578f, 0.04609410f, -0.07420921f, 0.16786881f, 
    -0.03252326f, -0.09342860f, 0.10974590f, -0.02064854f, -0.03787236f, 0.00441781f, 0.08861137f, 0.18849242f, 
    -0.03279404f, -0.08233049f, -0.24747033f, 0.23561411f, 0.18041353f, 0.08194896f, -0.05878644f, 0.05516387f, 
    0.04663252f, 0.04906017f, -0.09239472f, -0.01411194f, 0.29983965f, -0.17735815f, -0.06674678f, 0.19547614f, 
    0.02931283f, 0.07834750f, -0.10996393f, -0.03803501f, 0.07555051f, 0.02734085f, -0.12293874f, 0.01288729f, 
    0.19273667f, -0.11841904f, 0.14839038f, -0.27555630f, 0.23301452f, 0.16820467f, -0.08556619f, 0.14121862f, 
    0.00733958f, -0.36399820f, -0.16702279f, -0.09238605f, 0.07429282f, -0.10673213f, -0.25007501f, -0.21789731f, 
    -0.03104172f, 0.13208535f, 0.01491464f, 0.01349383f, 0.21286164f, -0.02758259f, 0.13694949f, -0.05250579f, 
    -0.03736421f, 0.01256235f, -0.09073641f, -0.12709452f, 0.01330420f, -0.07455786f, 0.12327537f, 0.08930939f, 
    0.13539082f, -0.10068835f, 0.08337016f, -0.18807404f, 0.51924723f, -0.12596893f, -0.02143058f, -0.07210086f, 
    0.07497986f, -0.22153817f, -0.00644336f, -0.14923847f, -0.11783016f, 0.24909669f, 0.01724636f, 0.15618812f, 
    -0.28656742f, -0.14419103f, -0.18828355f, -0.14905560f, 0.00412037f, 0.03587802f, -0.00944447f, 0.15132681f, 
    0.10481737f, 0.16540502f, -0.08048321f, -0.20137721f, -0.25935081f, 0.10373209f, 0.01778083f, 0.29002118f, 
    -0.05468683f, -0.04000917f, -0.01417745f, 0.05456603f, -0.06814810f, 0.03401981f, -0.07372784f, -0.23291881f, 
    0.04252560f, -0.02280753f, 0.09928619f, -0.33763009f, 0.15503985f, 0.08288813f, -0.09515874f, 0.05814837f, 
    0.12219620f, -0.13339676f, 0.07953831f, -0.00704679f, -0.23188585f, -0.08063562f, 0.05580584f, 0.29540220f, 
    -0.05610305f, -0.12498514f, 0.08637174f, 0.15751481f, -0.01311255f, 0.04013779f, 0.26029643f, 0.07586792f, 
    0.11173256f, 0.05101337f, 0.22366285f, 0.04017938f, -0.02709446f, 0.07828929f, -0.09733532f, -0.07864927f, 
    -0.05661067f, -0.19209681f, 0.05145660f, 0.05432312f, -0.14675567f, -0.31367534f, -0.02812304f, -0.08846855f, 
    0.07418171f, -0.29624999f, -0.05428538f, -0.20179987f, -0.02531207f, 0.08261319f, -0.06820770f, 0.14525469f, 
    -0.40534881f, -0.04680073f, -0.13606752f, -0.08880198f, 0.03033856f, -0.09102472f, -0.20477781f, 0.09313102f, 
    0.05040784f, 0.13055263f, 0.02298133f, 0.06412338f, 0.41408941f, -0.17967333f, -0.07448678f, -0.00227539f, 
    -0.09405278f, -0.05684891f, -0.00092895f, 0.12284353f, -0.13281064f, 0.02209576f, 0.06414913f, -0.08402091f, 
    0.50842369f, -0.36077452f, 0.14278077f, -0.47018877f, -0.04398935f, -0.01766662f, -0.03709253f, -0.07645414f, 
    -0.13803381f, -0.02917581f, -0.18638314f, 0.05715933f, 0.35153040f, -0.01647982f, 0.23773755f, 0.11096784f, 
    -0.11409672f, -0.05509560f, 0.04118239f, -0.00463811f, -0.07520685f, -0.08615384f, 0.09281980f, 0.07737797f, 
    0.30520964f, -0.11338367f, -0.06642178f, -0.25170743f, 0.20433599f, -0.08824135f, -0.06805057f, 0.12431375f, 
    0.16084976f, -0.04171789f, 0.04539466f, -0.10411670f, -0.65067196f, 0.03647758f, -0.01000890f, -0.04567089f, 
    -0.17856683f, -0.03947498f, 0.00738986f, -0.02576455f, 0.02773793f, 0.04091378f, -0.00518980f, 0.11805533f, 
    0.04334050f, 0.15891010f, -0.10797283f, -0.47403640f, -0.11126712f, 0.22053745f, -0.02206362f, -0.03988424f, 
    0.12804180f, 0.15227729f, 0.14465092f, 0.04921557f, -1.20678425f, -0.00102705f, -0.23193868f, -0.21565036f, 
    0.01786727f, -0.15438746f, -0.02984332f, 0.10271576f, 0.09313096f, -0.08400383f, 0.01046835f, -0.15878575f, 
    -0.32254821f, -0.07727738f, 0.02123977f, -0.26414391f, 0.10387116f, -0.14319195f, 0.13641423f, -0.05725360f, 
    0.10846505f, -0.05105965f, 0.05927406f, -0.02303264f, 0.18554719f, -0.20819384f, 0.17501590f, 0.00803051f, 
    -0.05310014f, -0.14177656f, -0.01200794f, 0.08483245f, 0.13070972f, -0.17334771f, 0.10210959f, -0.09853434f, 
    0.34829447f, -0.15132725f, -0.05151422f, 0.04663566f, -0.03712309f, 0.08142520f, -0.02901040f, 0.03007055f, 
    0.03109328f, -0.07012472f, -0.05661018f, -0.11337022f, 0.61618400f, -0.00144539f, 0.13662940f, 0.10735646f, 
    -0.07643358f, 0.18699065f, 0.03358918f, 0.02980595f, 0.09766608f, -0.14079465f, -0.02119993f, -0.04509941f, 
    -0.03554347f, 0.09666189f, -0.19506359f, -0.04183096f, -0.01717957f, 0.11090893f, -0.10555389f, -0.35856959f, 
    -0.19413657f, 0.15562674f, -0.14011653f, -0.29888999f, 0.35167477f, -0.11937299f, 0.12208935f, 0.16604552f, 
    -0.15265702f, 0.00267991f, -0.07954019f, 0.01846031f, 0.05472691f, 0.09234830f, 0.09891826f, 0.10983581f, 
    0.27829885f, 0.18356271f, -0.06934237f, -0.10561921f, 0.12228391f, -0.03083781f, -0.10986376f, -0.05183917f, 
    -0.18866366f, -0.15988995f, 0.15187049f, 0.06292523f, -0.12709512f, 0.09924441f, -0.16676259f, -0.12662168f, 
    -0.03502120f, 0.03519773f, 0.01287637f, 0.01383807f, -0.05212863f, -0.03854837f, -0.08738153f, 0.05745902f, 
    0.22329026f, 0.01069874f, -0.30758634f, 0.29310995f, 0.22592247f, 0.11620422f, 0.00063706f, -0.13467270f, 
    0.02212847f, -0.00633545f, -0.14195767f, -0.10501090f, -0.11159180f, 0.19255297f, -0.01553493f, 0.00726519f, 
    0.04005374f, 0.08925227f, -0.04686237f, -0.05171986f, -0.02663551f, 0.13644861f, 0.04699838f, -0.05021923f, 
    0.20704430f, -0.02741682f, -0.08616997f, 0.06123589f, -0.32692873f, 0.10684350f, -0.15956527f, 0.09195123f, 
    0.04485764f, 0.04580821f, 0.09128662f, 0.00199223f, -0.45248792f, 0.09732553f, 0.03086555f, -0.25213307f, 
    0.07328635f, 0.11196429f, 0.09271103f, -0.13012803f, -0.09024844f, 0.06194623f, -0.01562216f, -0.03340734f, 
    -0.11330117f, -0.17240137f, 0.08080333f, 0.00981583f, -0.04048465f, -0.08907321f, 0.13432913f, -0.15398511f, 
    0.02918981f, -0.00823961f, -0.04976129f, 0.09626951f, 0.05463617f, 0.01524255f, -0.19183429f, 0.07668945f, 
    0.10591900f, 0.11014935f, -0.15091573f, 0.08999471f, 0.05397705f, 0.07213735f, -0.06217435f, -0.03715849f, 
    0.32838663f, -0.07723657f, -0.04676295f, 0.21517915f, -0.13627987f, 0.03869618f, -0.21261930f, 0.01980422f, 
    0.08443201f, 0.10655360f, 0.00865654f, 0.01135764f, -0.18978043f, -0.17104967f, 0.37991685f, -0.08189294f, 
    0.08780079f, -0.21159858f, -0.12849651f, -0.22988285f, 0.00984113f, 0.05164951f, 0.05846775f, 0.07957801f, 
    -0.73438692f, 0.07628588f, -0.00623748f, -0.07047315f, -0.08245858f, -0.03678996f, 0.04079731f, -0.18768972f, 
    0.08930169f, 0.18375789f, -0.19304524f, -0.04574765f, -0.09677091f, -0.04025433f, -0.06081231f, -0.13723889f, 
    0.01104918f, -0.05108223f, 0.15909512f, 0.08438991f, -0.19149590f, -0.17388073f, -0.05761938f, -0.11318511f, 
    0.33687124f, 0.01328302f, -0.22449510f, -0.06657989f, -0.16399804f, -0.01255664f, -0.03534577f, -0.04151757f, 
    0.00668971f, -0.06140580f, -0.02371744f, -0.03844578f, -0.05888427f, -0.09029656f, -0.18966024f, -0.08849736f, 
    -0.03688198f, 0.13844773f, -0.02480327f, -0.03865259f, -0.00311863f, 0.09673559f, 0.10055263f, -0.05323594f, 
    -0.48104674f, -0.20431992f, 0.04494011f, 0.09206197f, -0.05107746f, -0.01654700f, -0.00817619f, -0.01810202f, 
    0.00176932f, 0.07037974f, -0.09114575f, 0.08501564f, 0.17141494f, -0.13947608f, 0.12414932f, -0.01951233f, 
    0.03527185f, 0.09169571f, 0.00177722f, -0.05804566f, -0.08582133f, 0.04954420f, -0.11209632f, -0.03099034f, 
    0.14878525f, -0.14308475f, -0.00118878f, 0.01864300f, 0.00080086f, 0.04575177f, -0.04710382f, -0.02872035f, 
    -0.08835257f, 0.04800928f, -0.06813182f, -0.01743042f, 0.35680240f, 0.02162864f, 0.29273006f, 0.17224689f, 
    0.05078880f, 0.05482419f, 0.00802687f, 0.05425447f, -0.07892906f, -0.00789152f, 0.02166599f, -0.14177883f, 
    -0.09868372f, -0.03985174f, -0.43116492f, -0.23366140f, 0.09116643f, 0.04899976f, 0.03957397f, -0.14266627f, 
    0.06295817f, 0.02753407f, 0.07109803f, -0.05861171f, 0.19093512f, 0.04704839f, -0.07662348f, -0.19156167f, 
    0.11696907f, -0.10315600f, -0.00170072f, -0.12199555f, -0.18728684f, 0.24059206f, -0.05666815f, -0.13368814f, 
    0.00694418f, -0.22673351f, -0.03173291f, 0.03319583f, -0.10624125f, 0.03852490f, 0.10077798f, -0.01164370f, 
    -0.13698435f, -0.12122761f, -0.17994352f, -0.06315033f, -0.04494317f, 0.03100044f, -0.14218238f, 0.10748519f, 
    0.10650104f, 0.02949957f, 0.05041482f, -0.06758172f, 0.15965772f, 0.00314595f, -0.00168837f, -0.08424595f, 
    0.39001215f, 0.20050398f, 0.19962479f, 0.44174936f, -0.14875111f, -0.15062021f, 0.08125836f, 0.24351229f, 
    -0.06170161f, 0.00591818f, -0.03546770f, -0.03492861f, 0.39032787f, -0.01979560f, 0.06266231f, -0.39860633f, 
    -0.15469182f, 0.02575789f, 0.13552772f, 0.09278905f, -0.08848854f, -0.05771702f, 0.08865364f, -0.05492433f, 
    0.07065393f, -0.08664387f, -0.31620482f, -0.31478533f, 0.05254432f, -0.11066386f, -0.12630095f, -0.07299163f, 
    -0.04809977f, -0.05410105f, -0.00692384f, 0.03139800f, 0.53802717f, -0.01332422f, -0.37258694f, -0.08393110f, 
    -0.05928952f, 0.06919165f, 0.06588831f, -0.08900872f, -0.09653828f, -0.04496762f, 0.08453631f, -0.08608808f, 
    -0.34879145f, 0.30428037f, -0.24126227f, -0.10001712f, 0.20649914f, 0.12879816f, 0.05974729f, -0.01467213f, 
    -0.15454076f, 0.06835774f, -0.10336094f, -0.06040653f, -0.38822189f, -0.03653173f, 0.17703372f, -0.17921580f, 
    -0.25211030f, -0.06947169f, -0.12538902f, -0.01805223f, -0.13100424f, -0.02510199f, -0.18845183f, -0.03860434f, 
    0.61812866f, -0.06006228f, 0.00156470f, 0.25699440f, -0.17396343f, -0.02891741f, -0.03985819f, -0.06015765f, 
    0.05832297f, -0.02636409f, 0.05698248f, 0.07450910f, -0.05576381f, -0.08305822f, 0.03246005f, -0.02849746f, 
    -0.07272983f, 0.08499857f, 0.01751411f, 0.07044977f, 0.07796073f, 0.01764916f, 0.12059671f, -0.09427992f, 
    0.40253294f, -0.06141543f, -0.22146007f, -0.03283671f, -0.19903646f, 0.07414791f, 0.06115187f, 0.17057545f, 
    -0.04937350f, 0.16398138f, 0.03600841f, -0.08992479f, 0.24848858f, -0.11560304f, 0.05756599f, -0.11122572f, 
    0.13306606f, -0.06729784f, 0.11718728f, 0.03643845f, 0.02095303f, 0.08310571f, 0.06425884f, -0.05985548f, 
    0.17354752f, -0.39393309f, 0.18846418f, -0.06143085f, -0.32372114f, -0.09590960f, -0.14106171f, -0.07290608f, 
    -0.06700189f, 0.03234044f, -0.01832550f, -0.05985526f, 0.13301179f, -0.09296207f, 0.05372310f, -0.28279546f, 
    0.02872944f, -0.12687814f, -0.25165728f, -0.00211380f, -0.00935638f, -0.11830593f, 0.10665683f, -0.24706686f, 
    -0.73269260f, 0.07541747f, 0.18275666f, 0.21337828f, 0.11921985f, 0.08166845f, 0.16708089f, 0.10265292f, 
    -0.06255744f, -0.07900789f, -0.09646934f, -0.10553630f, -0.46022081f, -0.27602383f, -0.37441796f, 0.20997022f, 
    -0.02437509f, -0.05135952f, -0.10519567f, -0.08613349f, 0.12645032f, 0.07056484f, 0.13914102f, -0.03625700f, 
    0.29373688f, 0.03828120f, 0.08009177f, -0.20773792f, -0.07965203f, 0.01602880f, 0.06044408f, 0.01951308f, 
    -0.20458195f, -0.05010588f, 0.09943923f, 0.07861891f, 0.23975143f, -0.65538764f, -0.44337881f, 0.13566388f, 
    -0.04035469f, 0.04297654f, -0.05100500f, 0.07291234f, -0.04690931f, -0.01890964f, -0.10407970f, -0.16790642f, 
    0.07602373f, 0.15127964f, -0.00036106f, 0.10685816f, -0.04716574f, 0.03564385f, 0.00003387f, -0.25719723f, 
    0.05627206f, -0.10488755f, -0.11329125f, -0.09742407f, 0.35583681f, -0.33917311f, 0.23780832f, -0.08603185f, 
    0.08049247f, 0.13347819f, 0.01758222f, -0.18537997f, 0.01727284f, -0.13922635f, 0.12720942f, -0.17451793f, 
    0.13659164f, 0.15608278f, 0.11432596f, 0.14754216f, -0.09089642f, -0.18233767f, -0.11730115f, -0.09014886f, 
    -0.11604396f, 0.24946246f, 0.03571907f, -0.05221063f, -0.06294110f, -0.03555875f, 0.01280107f, -0.14809266f, 
    -0.23809151f, -0.07123643f, -0.07291321f, 0.02508477f, 0.05406185f, -0.10618276f, -0.11480770f, 0.14526995f, 
    -0.15020388f, 0.16253115f, 0.09352175f, 0.05449317f, -0.06403068f, 0.02635427f, -0.11972262f, 0.00582050f, 
    0.08032685f, 0.16887455f, 0.05331512f, 0.35910600f, -0.04640928f, -0.38048956f, -0.31004763f, -0.08050381f, 
    -0.21616299f, -0.08044380f, 0.02389445f, 0.36758944f, 0.17246860f, -0.11300518f, -0.02346041f, -0.07560460f, 
    -0.19742934f, 0.39344412f, -0.02284208f, 0.32639328f, 0.00635877f, 0.03259820f, -0.01632444f, -0.14908536f, 
    -0.02147871f, -0.03553831f, 0.04893925f, -0.06347948f, 0.08030975f, 0.04472224f, 0.01909350f, -0.09199355f, 
    0.15821782f, -0.02598126f, 0.02338281f, 0.03480450f, 0.08925132f, -0.07421479f, 0.11552533f, 0.03501026f, 
    -0.14614315f, 0.09585278f, -0.11962909f, 0.02416699f, -0.18044998f, 0.01252116f, 0.00120058f, -0.03863696f, 
    0.05398753f, 0.11384223f, -0.03782031f, 0.16648881f, -0.05077388f, -0.02066302f, 0.09706233f, 0.19069855f, 
    -0.04356350f, 0.29937959f, -0.03217635f, -0.15231979f, 0.12202247f, 0.08277405f, -0.00442502f, -0.11010258f, 
    -0.05196019f, -0.49241823f, -0.01664978f, 0.28923196f, -0.06331958f, -0.14480880f, -0.00412312f, 0.03149802f, 
    -0.03011974f, -0.08042997f, -0.03415067f, 0.08566477f, -0.11668394f, -0.10926005f, -0.18551925f, -0.07678162f, 
    -0.11994691f, 0.04432139f, 0.03157168f, -0.01281409f, -0.12605675f, -0.17443450f, 0.07827339f, -0.13675006f, 
    -0.01931017f, 0.41110569f, 0.19570193f, 0.14060244f, 0.10184528f, 0.11903002f, 0.04840632f, -0.02172443f, 
    -0.09054327f, -0.01454976f, 0.09046260f, -0.10598878f, 0.32716224f, -0.16859603f, -0.42949763f, -0.19929908f, 
    0.01178009f, -0.02298612f, 0.00734840f, -0.12938480f, -0.13042830f, -0.02736353f, 0.02701216f, 0.07807117f, 
    0.23288448f, 0.05913588f, 0.11064412f, 0.14513521f, -0.04412427f, 0.17471655f, -0.04543044f, 0.02142356f, 
    -0.19253968f, -0.01695284f, 0.17214690f, 0.06159110f, -0.32655448f, -0.58374572f, -0.44938141f, 0.19273174f, 
    -0.11822936f, -0.01006198f, 0.07235106f, -0.11583860f, -0.02244250f, 0.00070114f, 0.00966827f, -0.13125247f, 
    -0.09316115f, -0.12649274f, -0.16279578f, -0.21138337f, -0.19644867f, 0.00431422f, 0.02265376f, -0.07338204f, 
    -0.06307027f, -0.09693054f, -0.11240033f, 0.04769637f, -0.41495392f, 0.14112942f, 0.14445701f, -0.20763841f, 
    -0.12277760f, -0.02475182f, -0.09704334f, 0.02922054f, -0.08593284f, -0.16803703f, -0.01140815f, 0.12177945f, 
    -0.00166502f, 0.23585644f, 0.30308354f, -0.00639683f, 0.14317685f, 0.07318041f, -0.05545511f, 0.08146413f, 
    -0.06027474f, 0.10630798f, -0.11489686f, 0.05876990f, -0.19151875f, 0.43483880f, 0.12760948f, -0.05299641f, 
    0.00886789f, 0.14546302f, 0.09522779f, 0.12698215f, 0.03456525f, -0.09910724f, -0.01552171f, -0.03296449f, 
    0.51264328f, 0.09040228f, 0.01254964f, 0.00311447f, -0.04446160f, -0.11429479f, -0.02892481f, 0.20826137f, 
    0.06905065f, 0.10036483f, 0.01907884f, -0.08368754f, 0.24436826f, 0.08270407f, -0.27693865f, 0.08065741f, 
    -0.09433610f, 0.03188136f, 0.05168973f, 0.07836287f, -0.02905458f, 0.00065667f, 0.11845270f, 0.13029586f, 
    0.21766834f, 0.15733875f, 0.14556305f, 0.16208054f, -0.00556464f, -0.02933091f, -0.01471892f, -0.02702970f, 
    -0.04512286f, 0.07737430f, -0.20699491f, 0.16226809f, -0.48726684f, -0.18691252f, -0.18442294f, -0.17938675f, 
    -0.07855260f, -0.02250617f, -0.08925541f, -0.06832992f, 0.03792915f, 0.16449946f, -0.00218877f, -0.17507261f, 
    0.16272332f, -0.08094523f, 0.20634744f, 0.05070394f, 0.01045290f, -0.09006357f, 0.20474941f, 0.10121129f, 
    0.07893315f, 0.00344721f, 0.01863416f, 0.02727116f, -0.56026739f, -0.31551173f, -0.43383417f, -0.10103337f, 
    -0.10255931f, -0.09157351f, -0.05392192f, -0.06057122f, 0.10975596f, -0.20581895f, 0.15281780f, 0.03826275f, 
    0.15884441f, 0.05128887f, -0.16211502f, 0.05608266f, -0.11557794f, 0.06637919f, -0.04826150f, 0.16851285f, 
    -0.00380421f, 0.01919767f, -0.01856125f, 0.00539686f, -0.08674122f, 0.25792331f, 0.04546312f, 0.08504584f, 
    0.01352717f, -0.10458221f, -0.23450963f, 0.04210936f, 0.01717393f, 0.08051245f, 0.06985002f, 0.07767908f, 
    -0.51230472f, -0.00311445f, 0.02229176f, 0.06213806f, -0.13026103f, -0.11445506f, 0.02622454f, -0.09171453f, 
    -0.11665576f, -0.03535561f, -0.12502588f, -0.04708496f, -0.22562338f, 0.12120844f, 0.12712315f, 0.02804842f, 
    -0.03617362f, 0.03938385f, -0.13317341f, 0.15007217f, 0.21710582f, -0.05486637f, 0.01907132f, 0.10154437f, 
    -0.34231541f, -0.20660748f, -0.03565036f, -0.17133152f, 0.21559763f, 0.09966493f, -0.16187987f, 0.04699052f, 
    -0.09968866f, -0.01197916f, 0.03666216f, 0.02939222f, -0.56283969f, -0.34486341f, 0.17675643f, 0.12326593f, 
    -0.19700995f, -0.00350474f, -0.03484190f, -0.18568307f, 0.09388310f, 0.11054921f, 0.00309689f, -0.10810661f, 
    0.39559618f, -0.11903197f, -0.20526540f, 0.12374029f, -0.18115820f, -0.19809364f, 0.09112642f, -0.00230651f, 
    -0.02173796f, -0.06317022f, 0.01321409f, -0.16447695f, 0.16718805f, 0.11841068f, 0.14870125f, 0.12894706f, 
    0.03946131f, 0.01221212f, -0.00441138f, -0.03689151f, 0.15259314f, 0.10827354f, 0.02480082f, -0.01908039f, 
    0.05272602f, -0.10897331f, -0.25545257f, 0.22716863f, -0.04681201f, -0.04772091f, 0.12315322f, 0.10377309f, 
    -0.07521570f, 0.07901303f, 0.04891840f, -0.01476463f, -0.17536028f, -0.14429641f, 0.19182038f, 0.27503726f, 
    0.12012308f, 0.00435908f, -0.00245226f, 0.00227592f, -0.08237657f, 0.07760592f, -0.00201493f, 0.13991642f, 
    0.07774343f, -0.15327632f, 0.19833381f, -0.06473915f, -0.15442680f, 0.11349167f, -0.17730092f, -0.04568876f, 
    -0.09636597f, -0.07854371f, -0.03853196f, 0.02526488f, -0.08518657f, -0.07034395f, 0.17759940f, -0.08188976f, 
    -0.06153002f, 0.13767342f, 0.12834209f, -0.00808771f, 0.15213858f, 0.02608670f, 0.05660174f, -0.03133896f, 
    -0.19878264f, -0.11386395f, 0.06036732f, 0.09648802f, -0.00262224f, -0.07132370f, -0.15724416f, -0.04341655f, 
    0.15139075f, -0.01063102f, 0.08365870f, 0.08612462f, -0.30232871f, 0.19787161f, 0.24403217f, -0.21288347f, 
    -0.06441192f, -0.00124825f, -0.02444073f, 0.10627814f, -0.07831900f, -0.09185115f, 0.14758511f, -0.18574227f, 
    -0.10043345f, -0.04971549f, -0.11830880f, 0.28162658f, 0.02791635f, -0.12568077f, 0.02461496f, 0.12159976f, 
    -0.17224163f, 0.04760531f, 0.04607462f, 0.12331434f, -0.20093071f, -0.25024390f, -0.01818644f, 0.07204797f, 
    0.06300268f, 0.03366209f, 0.17533161f, -0.11689162f, 0.15633640f, 0.01927763f, -0.12894937f, -0.11877935f, 
    -0.12684724f, 0.20046848f, -0.09692419f, -0.33255512f, -0.05394749f, 0.03022284f, -0.02993068f, 0.09350005f, 
    -0.13979945f, -0.03124786f, 0.05374455f, -0.09502356f, -0.70752418f, -0.05911666f, 0.08571528f, 0.26923767f, 
    0.01146009f, -0.05701603f, -0.16796927f, 0.07156285f, -0.09152468f, -0.10946447f, 0.00609923f, 0.06571357f, 
    -0.15349406f, -0.26940754f, 0.28318393f, -0.02624843f, 0.02591944f, -0.01528617f, 0.09624646f, -0.29248592f, 
    -0.02878603f, -0.12430222f, 0.08284930f, -0.02831267f, -0.13932228f, 0.02030595f, 0.20267192f, 0.03055739f, 
    -0.06885065f, 0.15103920f, 0.07213673f, -0.17320527f, 0.07029524f, 0.02516493f, -0.06881696f, -0.03081227f, 
    0.30779406f, -0.21796034f, -0.35963327f, -0.05253046f, 0.02308088f, -0.10074406f, -0.06347004f, 0.06850462f, 
    -0.04143226f, -0.05838336f, -0.15084542f, -0.01659335f, -0.03322960f, 0.15708819f, 0.06930060f, 0.06256367f, 
    -0.11309510f, -0.04715830f, 0.01879583f, 0.02610891f, 0.18446614f, -0.11840542f, -0.12780362f, -0.04165427f, 
    -0.49010277f, -0.03670657f, 0.26285732f, 0.30694944f, -0.14480382f, 0.01960739f, 0.09492703f, -0.03512911f, 
    -0.06173102f, 0.05503025f, 0.21911940f, 0.04063647f, -0.22356091f, -0.06552472f, -0.13762926f, -0.32074699f, 
    0.08557320f, -0.19082777f, -0.16799590f, 0.04763532f, 0.00779749f, 0.02292365f, -0.21935737f, 0.09493271f, 
    -0.17757063f, 0.23282360f, 0.26749527f, 0.08120229f, 0.05098487f, -0.05177668f, 0.01752882f, -0.01510069f, 
    0.17593206f, -0.02724846f, 0.00683190f, -0.01062103f, 0.27505621f, 0.23894988f, 0.04382425f, -0.02029057f, 
    -0.03801361f, -0.09904163f, 0.23942976f, -0.10809296f, 0.12246828f, 0.20122142f, -0.14356627f, 0.13419257f, 
    0.43303180f, -0.06827287f, -0.09037845f, -0.13383304f, -0.09931631f, 0.09781461f, 0.05682577f, 0.09320731f, 
    -0.06591576f, 0.07657418f, 0.05633068f, 0.04660618f, -0.00437355f, 0.14359851f, 0.01655490f, -0.09605493f, 
    0.19501190f, 0.01769399f, 0.05311159f, 0.05265150f, 0.06793552f, -0.01367071f, -0.13410464f, -0.01073457f, 
    -0.78817254f, 0.01748258f, -0.03932209f, -0.00436327f, -0.08022038f, -0.01580823f, 0.02431024f, -0.07388645f, 
    -0.08785948f, -0.11274631f, 0.06895342f, 0.18354765f, -0.48738128f, 0.35556346f, 0.00435883f, -0.03500570f, 
    -0.06472576f, -0.00117168f, 0.06329534f, 0.05141226f, 0.04846505f, 0.09899154f, -0.01662143f, -0.01485014f, 
    0.14637458f, 0.35124233f, -0.27762407f, -0.12868574f, -0.06542698f, 0.10257190f, 0.05012186f, 0.24339408f, 
    -0.01941560f, 0.06457862f, 0.00815301f, 0.16562194f, 0.30968821f, -0.06823416f, -0.28558612f, 0.11251807f, 
    -0.02810546f, -0.00601740f, 0.08947478f, 0.08024503f, -0.15001023f, -0.12454955f, 0.08261632f, 0.02738174f, 
    -0.38576177f, 0.17501266f, -0.01319638f, -0.07418417f, 0.05696122f, 0.05580175f, 0.12471788f, 0.08765934f, 
    0.22191043f, -0.01568031f, 0.07151769f, -0.07760469f, 0.23240601f, -0.10397416f, 0.33472648f, 0.05097106f, 
    0.03693646f, -0.02155042f, 0.05754825f, -0.03475402f, 0.01400680f, 0.08290348f, -0.08214613f, 0.09260920f, 
    0.19995712f, -0.00308150f, 0.04487298f, 0.16395015f, -0.00066739f, 0.07249714f, 0.11840953f, 0.05890564f, 
    -0.16863684f, -0.10644977f, 0.21175708f, 0.16963993f, 0.01456555f, -0.15324174f, -0.05003751f, -0.01794223f, 
    -0.01664270f, -0.05915642f, -0.12660623f, -0.05408036f, -0.07437628f, -0.07625066f, -0.11484189f, -0.13772213f, 
    -0.21640268f, 0.01190140f, -0.20768435f, 0.18410273f, 0.39759895f, -0.02735520f, 0.16187975f, -0.24119344f, 
    -0.03991869f, -0.05717692f, -0.05156062f, -0.14881991f, 0.04194251f, 0.18873997f, 0.03292559f, 0.19851044f, 
    -0.16037387f, -0.06593284f, -0.02639326f, 0.06064789f, 0.09614450f, -0.16632119f, 0.13256337f, -0.01955685f, 
    -0.09984984f, 0.04747152f, 0.15604855f, -0.15532073f, -0.11267869f, 0.23132846f, -0.15816581f, 0.12013832f, 
    0.03974871f, 0.03693379f, 0.10672272f, 0.04456233f, -0.12828319f, -0.15067671f, -0.01115320f, -0.17943624f, 
    -0.05983491f, -0.24129057f, -0.00694224f, 0.04881919f, -0.09182186f, -0.06852487f, 0.10415246f, 0.29636127f, 
    -0.27754143f, 0.05082690f, -0.11182390f, -0.42073524f, -0.01998720f, 0.29529202f, 0.15377167f, -0.21225891f, 
    -0.03422958f, -0.13438062f, -0.04081460f, -0.16559675f, 0.07170482f, -0.02809783f, -0.01037119f, 0.04958482f, 
    0.08932935f, 0.10698003f, -0.11488186f, 0.15464155f, 0.03667650f, 0.01195845f, -0.12222550f, 0.04769795f, 
    0.06003090f, -0.02208546f, 0.01566799f, 0.21924883f, 0.14687915f, -0.32418260f, 0.04131991f, -0.00712886f, 
    -0.06674670f, -0.05578586f, 0.13683765f, -0.08603744f, 0.12092070f, 0.25156039f, -0.09334814f, 0.16286457f, 
    -0.09085440f, -0.07886416f, 0.23228993f, 0.13639909f, -0.17367506f, 0.09041002f, 0.05662841f, 0.12146568f, 
    0.25031120f, 0.03432065f, 0.04145169f, 0.18526982f, -0.06568364f, -0.06771309f, 0.13509163f, 0.03455298f, 
    -0.13408026f, -0.01110280f, 0.00735233f, 0.10864931f, -0.07109094f, -0.15819833f, 0.02482174f, 0.02134144f, 
    -0.23301531f, 0.19191521f, 0.19876069f, 0.06557479f, 0.06922922f, -0.06536260f, -0.07294481f, -0.13662402f, 
    0.02424870f, -0.09038163f, -0.15615366f, -0.01774662f, 0.10611274f, 0.05514131f, -0.19128129f, 0.01862048f, 
    0.21271968f, -0.20187390f, -0.04029948f, -0.16869530f, -0.01378524f, 0.08900486f, -0.16506784f, -0.46837643f, 
    0.06823480f, -0.00968917f, -0.11995941f, 0.05322484f, 0.19806251f, 0.00418592f, 0.05533868f, 0.15313756f, 
    -0.10421140f, -0.07865840f, 0.14018744f, 0.26752064f, -0.14899358f, 0.04677638f, 0.26238245f, 0.02888317f, 
    0.07158162f, -0.04723394f, 0.11854273f, 0.17631759f, -0.04034937f, 0.38770518f, -0.27170464f, -0.11613942f, 
    -0.02213656f, -0.00527474f, 0.15223530f, -0.07513633f, -0.03609097f, 0.05611917f, -0.02681423f, -0.31520283f, 
    0.09266349f, 0.02928182f, 0.06764465f, 0.17256747f, -0.06732848f, -0.11960870f, 0.22960064f, 0.04854457f, 
    -0.13598987f, 0.14080602f, 0.00544066f, 0.09387976f, -0.03278866f, 0.03592161f, 0.08670117f, 0.11746031f, 
    -0.06775382f, -0.03628897f, 0.00655226f, -0.13402636f, 0.10886335f, -0.33528173f, 0.01461697f, 0.10161704f, 
    0.04867257f, -0.22017720f, -0.00264463f, -0.19734605f, 0.03289206f, -0.08354472f, 0.07858089f, -0.08641750f, 
    0.22848706f, -0.00736241f, 0.14530583f, -0.18451454f, -0.00905217f, 0.09964895f, 0.09374850f, 0.17425264f, 
    0.04536588f, 0.07505124f, 0.08202869f, -0.12188117f, -0.04788741f, 0.12725464f, -0.09322224f, 0.19686031f, 
    -0.25582615f, 0.06217780f, -0.38401589f, -0.12969884f, 0.17378409f, 0.10642008f, -0.10928260f, -0.19002926f, 
    0.05010208f, -0.05168573f, -0.13617036f, 0.08629097f, -0.28101000f, -0.22297865f, -0.24022970f, -0.00293631f, 
    0.12099996f, -0.26878479f, -0.10071042f, 0.05700682f, -0.00978207f, -0.10791038f, 0.08582649f, 0.05317083f, 
    0.09267896f, -0.24878745f, -0.05976202f, 0.11676778f, 0.05590390f, -0.02121499f, 0.18695384f, 0.00401192f, 
    0.05185064f, 0.02428478f, 0.21377584f, 0.15669575f, 0.01165542f, -0.42272806f, 0.18226801f, 0.25262994f, 
    0.04013184f, 0.03772446f, -0.22676213f, -0.17789257f, 0.11019715f, 0.01207987f, 0.11093677f, -0.01869815f, 
    -0.48429239f, 0.03632465f, 0.27687690f, 0.32180020f, -0.10090154f, 0.10824123f, 0.18832026f, -0.16672759f, 
    -0.09672938f, -0.12328081f, -0.04047908f, -0.01468179f, -0.61472225f, -0.30566302f, -0.18441780f, 0.15012549f, 
    0.06601900f, 0.08960071f, 0.04162997f, -0.01813214f, 0.02621155f, 0.09753160f, 0.36952475f, 0.06648692f, 
    -0.50951523f, 0.01985436f, -0.15926749f, -0.32874107f, 0.11828415f, 0.05787399f, -0.01645419f, 0.10160585f, 
    -0.04732585f, 0.08059077f, 0.00024725f, -0.25633562f, -0.55503809f, 0.33564258f, 0.10337629f, -0.05399754f, 
    0.07136443f, -0.32746741f, -0.11654767f, -0.01796320f, 0.09296793f, -0.11315277f, -0.17418966f, 0.03153488f, 
    -0.06348483f, 0.08716395f, 0.33349204f, 0.14253585f, 0.11010220f, -0.09023139f, 0.01624586f, -0.06671050f, 
    -0.13574016f, -0.22403893f, -0.31238467f, -0.22946912f, 0.10202953f, 0.20237766f, 0.27492794f, -0.38176617f, 
    -0.05716082f, 0.04528892f, -0.10613821f, -0.08606695f, 0.02100239f, 0.08402234f, -0.07311708f, -0.04366689f, 
    -0.35959101f, -0.18767117f, -0.20693520f, -0.25491312f, 0.03903056f, 0.23188376f, -0.08557636f, -0.19301790f, 
    0.01189882f, 0.08947522f, 0.08642575f, 0.06854802f, -0.01676606f, -0.14009717f, 0.00621056f, 0.22268796f, 
    -0.14333999f, 0.00697272f, 0.03377541f, -0.00131965f, 0.04917347f, 0.03250977f, 0.15358338f, 0.32640630f, 
    0.29147366f, 0.30142272f, 0.15763806f, -0.36036330f, -0.08051387f, -0.03824337f, 0.07939277f, 0.03162491f, 
    0.08524933f, -0.10583745f, -0.16917834f, -0.14108393f, 0.02701721f, 0.23806541f, 0.18429036f, -0.19615532f, 
    0.00829967f, -0.03723936f, 0.04718959f, -0.02056428f, -0.07448728f, 0.16895701f, 0.17031413f, 0.17948312f, 
    -0.07916681f, -0.26735798f, 0.10022254f, -0.48369956f, -0.08536614f, -0.04614894f, 0.16990131f, -0.17315504f, 
    -0.05364499f, -0.04706764f, 0.19256733f, 0.15072396f, -0.32009977f, 0.18453561f, -0.04682327f, 0.12191788f, 
    0.02128941f, 0.15413782f, -0.11527336f, 0.17827958f, 0.06428181f, 0.12676792f, -0.20869689f, -0.12033854f, 
    -0.33804333f, 0.15797199f, 0.06118179f, -0.06356796f, 0.08580770f, 0.08574978f, 0.23853801f, -0.13053125f, 
    0.07749769f, -0.17097893f, 0.09243599f, -0.05733790f, 0.18375075f, 0.37663421f, 0.25007448f, -0.45127913f, 
    -0.07709040f, 0.23254018f, 0.06590898f, -0.00347001f, -0.05428566f, 0.11988728f, 0.05242599f, -0.18903647f, 
    -0.52541965f, -0.08169912f, 0.18723477f, -0.19661309f, 0.05876990f, -0.06693143f, 0.01123707f, -0.07308551f, 
    0.09116539f, -0.02548703f, 0.00080099f, 0.12808049f, -0.09309004f, -0.00529291f, -0.80336201f, 0.04882693f, 
    -0.08378395f, -0.14383063f, 0.04139156f, -0.15971403f, -0.03959963f, 0.05554485f, -0.22389854f, -0.18081519f, 
    -0.19086699f, -0.05368939f, -0.24672398f, 0.14537261f, -0.09610607f, 0.07023205f, -0.08031637f, 0.01617111f, 
    -0.13819480f, -0.03774479f, -0.02886566f, 0.27084136f, -0.36682752f, -0.15985629f, -0.08546190f, 0.27265713f, 
    0.14195631f, 0.09971903f, -0.29628816f, -0.02385909f, 0.03383034f, -0.20573503f, -0.07238680f, -0.23125462f, 
    -0.00132723f, 0.01043666f, -0.13166377f, -0.28152007f, 0.10655291f, 0.01907327f, -0.01396313f, -0.12563674f, 
    0.01270437f, -0.00649728f, -0.03896911f, -0.08841073f, 0.38072810f, 0.03323606f, 0.00789633f, -0.16805023f, 
    0.13838303f, -0.05030609f, -0.02690607f, -0.02214940f, 0.02620418f, -0.01446877f, 0.02163998f, -0.09503095f, 
    -0.20019819f, -0.04977757f, -0.01090740f, 0.10025497f, 0.03195371f, 0.00119575f, 0.12486041f, -0.12346309f, 
    -0.12121927f, -0.00968483f, 0.04940110f, 0.08357268f, 0.59071219f, 0.07240303f, 0.29454622f, -0.35073215f, 
    -0.22709820f, 0.24856563f, 0.18120793f, -0.00561842f, -0.03887210f, 0.10807352f, -0.08520503f, 0.11809415f, 
    0.12023327f, -0.10327962f, -0.11275586f, -0.05386729f, -0.15635574f, 0.02487719f, -0.03898217f, -0.13579640f, 
    0.14626691f, -0.07857607f, -0.15671688f, -0.29605725f, 0.23066512f, -0.16399175f, -0.01907140f, 0.03949193f, 
    -0.10477548f, 0.20775196f, -0.02345284f, -0.07909975f, -0.03759322f, 0.10058690f, 0.13897313f, 0.11224072f, 
    0.08435567f, -0.07110123f, -0.19607806f, -0.14664645f, 0.08699719f, 0.17584899f, 0.01175119f, 0.00829143f, 
    -0.12431467f, -0.17752816f, -0.12414072f, 0.17864580f, -0.24266581f, 0.21806191f, 0.05522536f, 0.12827376f, 
    0.18610479f, 0.03436977f, -0.01805417f, 0.12083986f, 0.12449593f, 0.23148446f, 0.07453237f, 0.03694170f, 
    -0.56660587f, -0.04690139f, 0.20658992f, -0.00948112f, -0.00607407f, 0.06693120f, -0.05312727f, -0.06474657f, 
    0.04278195f, -0.10481150f, 0.00664973f, 0.09437988f, -0.20285533f, 0.31630778f, 0.14745797f, -0.38153166f, 
    -0.07559635f, -0.02581953f, -0.04179529f, 0.17190567f, 0.03503548f, 0.05950037f, 0.01884536f, -0.04902023f, 
    -0.44136739f, -0.44906992f, -0.10476061f, -0.25369754f, 0.07849508f, -0.02766823f, -0.01455569f, -0.03185280f, 
    0.09320427f, -0.04090601f, 0.12524365f, 0.19909804f, 0.12129080f, 0.06641111f, 0.02879561f, 0.35688338f, 
    0.02880115f, 0.05834029f, -0.12452839f, 0.00965197f, -0.09032349f, 0.11522529f, -0.08738834f, -0.18403363f, 
    -0.00218141f, -0.17781083f, -0.14628892f, 0.02036049f, -0.03785205f, 0.08496709f, -0.08103030f, 0.08152223f, 
    -0.10337842f, -0.20566478f, -0.22431229f, -0.13391361f, 0.14126377f, -0.17465323f, -0.22872491f, 0.18572409f, 
    -0.03596628f, 0.04491924f, 0.18286933f, 0.07849865f, -0.12480075f, -0.08564544f, -0.27757743f, -0.03421674f, 
    0.19283457f, 0.02952895f, -0.11232141f, 0.29453534f, -0.20871441f, 0.02101225f, -0.10238700f, 0.05482796f, 
    -0.09221495f, 0.12819730f, 0.01097262f, -0.02521108f, 0.04422231f, -0.05375795f, -0.01147927f, -0.36323074f, 
    0.02338186f, 0.02227439f, 0.06718520f, -0.06687823f, 0.04589088f, 0.08996592f, -0.17965135f, 0.07936788f, 
    0.44491637f, -0.22442061f, 0.07143500f, -0.10079961f, -0.08243734f, -0.08150643f, 0.04184004f, -0.02667311f, 
    0.07290979f, -0.18183145f, 0.27104557f, 0.28056422f, 0.38957405f, -0.60313207f, 0.14956991f, 0.14324738f, 
    0.00580010f, -0.07185813f, 0.02975412f, 0.08828477f, -0.18236354f, -0.09517720f, 0.25051683f, 0.06002959f, 
    0.09232605f, -0.32396623f, -0.15448347f, 0.17906921f, -0.05661946f, -0.00570444f, 0.08174408f, 0.17818394f, 
    0.15780392f, -0.06387839f, 0.24766214f, 0.20621783f, -0.44425905f, 0.07768469f, 0.08888832f, -0.16229600f, 
    -0.16155358f, 0.03068817f, 0.00667411f, 0.15929629f, -0.04316613f, -0.15905194f, -0.03977420f, 0.05494012f, 
    0.01059106f, 0.11198872f, -0.10719099f, -0.15783504f, -0.01051931f, -0.06962748f, 0.00630427f, 0.11153467f, 
    -0.00854618f, 0.13079697f, -0.18860221f, 0.06307530f, -0.13817824f, 0.24045469f, -0.05403979f, -0.20599152f, 
    -0.04492329f, -0.00585403f, 0.00511657f, -0.09034242f, -0.08990413f, -0.04190345f, 0.05452571f, -0.21322669f, 
    0.07366762f, -0.76105875f, 0.18000540f, 0.05867340f, -0.09932718f, 0.02684383f, -0.14207040f, -0.02860632f, 
    -0.10063915f, -0.03244554f, -0.03498736f, -0.03652760f, -0.12982543f, -0.20722376f, -0.08775216f, -0.33883971f, 
    -0.05860607f, -0.08160049f, -0.07259659f, -0.05495096f, -0.12706684f, 0.04521802f, -0.01686019f, -0.09072462f, 
    0.14734066f, 0.00779997f, 0.16209017f, 0.06903147f, 0.02174934f, 0.00580045f, -0.04444259f, -0.16580983f, 
    -0.05114882f, 0.08988571f, -0.00650649f, -0.06696044f, -0.42722738f, -0.16531028f, -0.21469018f, -0.07377619f, 
    0.04482652f, -0.03916293f, -0.07068714f, -0.01448149f, -0.18364425f, 0.08325546f, 0.02339257f, -0.02508045f, 
    -0.26492834f, -0.04076947f, -0.10525582f, -0.13171828f, 0.15781662f, -0.14228289f, -0.10037852f, -0.08512874f, 
    -0.09512030f, 0.12068704f, 0.05783018f, -0.02569812f, 0.02142863f, 0.13625583f, 0.06758837f, 0.01625270f, 
    -0.04670754f, -0.00200887f, 0.03400751f, -0.06363190f, 0.00432071f, -0.02714176f, 0.08319626f, -0.08199995f, 
    0.13057593f, -0.07089779f, 0.11239095f, 0.20465411f, 0.08721121f, 0.10640844f, 0.05785915f, 0.08274452f, 
    -0.07847508f, -0.02980230f, 0.05466377f, 0.00104420f, 0.09125688f, 0.35061195f, 0.21177715f, 0.30759007f, 
    0.21674296f, 0.09093515f, 0.12413985f, -0.00114232f, -0.06142837f, -0.02229739f, -0.05928077f, -0.09396085f, 
    0.05165349f, -0.17367305f, 0.01710321f, -0.00505710f, -0.07142190f, -0.08063374f, 0.05480851f, -0.08230150f, 
    0.00442621f, -0.12334400f, 0.09650771f, -0.05128385f, -0.09424909f, 0.12748130f, -0.02638046f, -0.02271606f, 
    -0.01485476f, -0.05611210f, -0.11527654f, -0.01596056f, 0.04405030f, 0.01436760f, -0.14536034f, -0.05911413f, 
    0.05249014f, -0.27334183f, 0.06480028f, -0.04776185f, 0.05139463f, -0.08071584f, -0.07500703f, -0.04648938f, 
    0.00232444f, -0.00232826f, -0.02816723f, -0.05635812f, 0.12065028f, 0.00260890f, -0.27373409f, -0.16137379f, 
    0.02863610f, -0.11158598f, -0.07961980f, -0.11853353f, -0.08251758f, -0.02051874f, -0.14775734f, 0.07812262f, 
    0.12700424f, 0.18573764f, -0.00239449f, 0.11173879f, 0.08947158f, 0.03569163f, 0.06158746f, 0.01855250f, 
    -0.13756058f, 0.09131024f, -0.00808975f, 0.01541148f, 0.01622722f, 0.16386731f, -0.16550574f, -0.29053444f, 
    0.02078290f, -0.05119309f, -0.00712257f, -0.06316214f, -0.08659652f, -0.02558485f, 0.04653513f, -0.02980409f, 
    -0.35023645f, 0.00747818f, -0.07233784f, -0.16289273f, -0.04985447f, -0.06195370f, -0.07850710f, -0.07085317f, 
    -0.08518034f, 0.02990640f, -0.06899614f, -0.06330032f, -0.12750870f, 0.29162669f, -0.05806725f, 0.05678257f, 
    0.05936681f, 0.00236913f, -0.06284224f, 0.15119597f, -0.00303855f, 0.03096253f, -0.02324508f, -0.04409286f, 
    0.22853987f, -0.28952277f, 0.13425142f, 0.23206741f, -0.05048595f, -0.10515825f, -0.08038145f, -0.03480413f, 
    -0.02349632f, -0.11544521f, -0.07419955f, -0.06584935f, -0.61278772f, 0.19102576f, -0.14130910f, -0.24997438f, 
    -0.12844072f, -0.02928128f, -0.01009849f, -0.05997092f, -0.19035767f, 0.13011064f, 0.04412620f, -0.04088460f, 
    -0.18958384f, 0.06513752f, -0.19651182f, 0.11562534f, -0.08088063f, 0.06158803f, -0.05588991f, -0.06630266f, 
    -0.08486035f, 0.05181369f, -0.08173113f, -0.17903033f, -0.26723242f, -0.07131956f, -0.25899631f, -0.24453057f, 
    -0.12325914f, 0.04379247f, -0.00641531f, -0.15689848f, -0.10864419f, -0.02420001f, 0.07514765f, -0.04944472f, 
    0.14782314f, 0.17727917f, 0.26094797f, 0.08154831f, 0.15911080f, 0.02556879f, 0.12054537f, -0.04861581f, 
    -0.03791987f, 0.11816379f, -0.02308502f, -0.05802588f, 0.46708456f, 0.12757014f, -0.06655434f, 0.18413648f, 
    0.22887860f, 0.11406551f, 0.01941976f, -0.08524346f, -0.00901503f, -0.05338871f, -0.03300158f, -0.01324985f, 
    0.12305686f, -0.19053620f, 0.20670381f, 0.26144546f, -0.06937911f, -0.09366234f, -0.15723343f, -0.08268866f, 
    0.08766741f, 0.03193567f, -0.12480241f, -0.02740290f, 0.11420704f, 0.10788811f, 0.13257141f, 0.23524879f, 
    0.22785673f, -0.05374865f, 0.03092239f, 0.03877134f, -0.00820741f, -0.04725317f, -0.03551017f, 0.09539698f, 
    0.10642593f, 0.10691848f, 0.08580592f, 0.44387636f, 0.11803029f, -0.10110899f, -0.13689399f, 0.04949109f, 
    -0.05498756f, 0.19472948f, 0.07404087f, -0.01478041f, 0.17129172f, 0.18649371f, 0.08396127f, 0.20765463f, 
    0.02911347f, 0.04483697f, -0.05254831f, -0.00003429f, -0.12301838f, -0.03875156f, -0.17380410f, -0.00685439f, 
    0.27096090f, -0.13525634f, 0.27416095f, -0.09184465f, -0.05537050f, 0.11312762f, -0.04396613f, -0.11836492f, 
    -0.07795557f, 0.13991965f, -0.03852345f, -0.00936018f, -0.23680265f, -0.21919805f, -0.04350208f, -0.15719038f, 
    -0.05258406f, 0.06024219f, -0.15984790f, -0.12578180f, -0.05209291f, 0.02073068f, -0.07672888f, -0.03248680f, 
    0.19286209f, 0.04474501f, -0.01851165f, 0.06642248f, 0.07129293f, -0.00444159f, 0.04369625f, -0.11899707f, 
    -0.01120131f, 0.02866077f, -0.00020597f, 0.05923758f, -0.28906059f, 0.25897917f, -0.05274922f, -0.10324960f, 
    -0.12009423f, 0.01590134f, -0.04275890f, -0.11074036f, -0.03910749f, 0.08471617f, -0.07916488f, -0.20601448f, 
    -0.19263099f, -0.04563281f, 0.18299505f, -0.00163147f, 0.03318568f, -0.03613318f, 0.06453374f, -0.08203777f, 
    -0.04756171f, 0.00738315f, -0.10341269f, -0.05315981f, 0.26219088f, -0.05384588f, 0.18366589f, 0.16006251f, 
    0.07045403f, -0.07182427f, 0.04420188f, -0.00375567f, -0.10233757f, -0.04931780f, -0.02336910f, -0.06681487f, 
    0.09017673f, -0.16971922f, -0.05126693f, 0.10571203f, 0.06024993f, -0.07141814f, -0.13590124f, -0.01835118f, 
    0.02267728f, 0.16302006f, -0.01335898f, -0.00722482f, -0.04314296f, -0.31026772f, -0.09838559f, 0.10536826f, 
    0.18611877f, -0.08719205f, 0.00557314f, -0.01807047f, 0.08915315f, -0.06795963f, 0.08629872f, -0.19994324f, 
    -0.03413253f, -0.33148476f, 0.33243912f, 0.03830000f, -0.00488969f, -0.07597065f, 0.09387299f, 0.01434981f, 
    -0.10222778f, -0.04065263f, -0.09452428f, -0.12164230f, 0.17196751f, 0.12580770f, -0.21518581f, -0.04714357f, 
    0.21229744f, 0.17017561f, -0.07897498f, -0.00683641f, 0.02053502f, 0.03156934f, 0.01202453f, 0.09379084f, 
    -0.24101911f, -0.00078751f, -0.03682082f, -0.13000192f, -0.03069030f, 0.09417626f, -0.06397993f, 0.30135217f, 
    -0.00851572f, -0.05120587f, -0.17282954f, -0.01570608f, -0.29253525f, -0.36468473f, 0.09149608f, 0.11041184f, 
    0.08141885f, -0.01561344f, 0.04835843f, -0.06063954f, 0.14552738f, 0.02595685f, 0.07711311f, 0.07311904f, 
    -0.34976283f, 0.08482153f, 0.18140273f, -0.01952559f, -0.17869787f, -0.01296426f, -0.00344705f, -0.33464387f, 
    -0.00104453f, -0.03638665f, -0.13440487f, -0.02370594f, -0.02099052f, 0.23035188f, -0.05523717f, -0.13180377f, 
    0.00236362f, 0.04109835f, 0.00109019f, -0.04837102f, 0.02611505f, -0.14422707f, 0.09518217f, 0.07815874f, 
    0.04188978f, -0.28156334f, -0.24244832f, -0.18612666f, -0.15778454f, 0.02519829f, -0.07340472f, 0.09799703f, 
    0.13519602f, 0.07934061f, 0.10159263f, -0.35793480f, 0.13351426f, 0.23530580f, -0.35315788f, -0.24984296f, 
    -0.03987826f, 0.21231897f, -0.02315000f, -0.15351619f, 0.10301960f, 0.06478524f, 0.05119539f, 0.06241887f, 
    -0.29279014f, -0.12260649f, -0.09141517f, -0.32391074f, -0.06395083f, -0.00013552f, 0.09286766f, 0.01064178f, 
    0.07331790f, -0.01224563f, 0.10573081f, 0.08555610f, -0.00185811f, -0.17596419f, -0.02644155f, -0.12617300f, 
    0.05036855f, -0.00563401f, -0.01072665f, -0.13372885f, -0.03204787f, 0.09953589f, -0.11688684f, -0.05321813f, 
    -0.34693423f, 0.23607779f, 0.01235267f, 0.05818229f, -0.19557872f, -0.01544873f, -0.23223683f, 0.11265013f, 
    0.14824186f, -0.10881878f, 0.10240591f, -0.08154444f, 0.01199561f, -0.11504924f, 0.01594795f, 0.08891266f, 
    0.10316020f, -0.13211024f, -0.05327528f, 0.10835052f, 0.08505942f, 0.04172090f, 0.01305546f, -0.05122607f, 
    0.20622917f, 0.16646199f, -0.06228114f, 0.13046727f, 0.06884709f, 0.05969193f, -0.09045822f, -0.07750277f, 
    0.00788828f, -0.10401921f, 0.19076382f, 0.15936787f, 0.25069955f, 0.09810163f, -0.05479506f, 0.12426333f, 
    -0.18936689f, -0.04109370f, 0.14039242f, 0.01331104f, -0.09830917f, -0.08353794f, -0.21033178f, 0.06472830f, 
    -0.12010735f, -0.25973824f, -0.13109510f, -0.49153078f, 0.09076586f, -0.08722322f, -0.07868598f, 0.03004427f, 
    0.08141648f, 0.20727524f, -0.11299037f, -0.10915826f, 0.19698276f, -0.31588650f, -0.09947152f, 0.21873921f, 
    0.04346047f, -0.01748155f, -0.07105619f, 0.03660594f, 0.01057232f, -0.16337091f, 0.25766373f, 0.06914488f, 
    -0.24729149f, 0.34339532f, 0.04165146f, 0.17406105f, -0.12347258f, -0.03625543f, 0.02957250f, 0.07992403f, 
    0.07327514f, 0.07285167f, 0.00617937f, -0.37106940f, -0.03226991f, 0.01424428f, 0.07617743f, 0.31761238f, 
    0.11249817f, 0.09849428f, -0.04826073f, -0.06539319f, -0.11763915f, 0.02220386f, 0.02315677f, -0.06599925f, 
    -0.13621373f, 0.11220543f, 0.10565352f, 0.20031214f, -0.16857798f, 0.00575275f, -0.16435839f, -0.08151697f, 
    0.04339940f, 0.02415551f, -0.09672286f, -0.08934968f, 0.37213629f, 0.13911916f, -0.18157107f, 0.00552623f, 
    0.10011292f, -0.01221765f, 0.17290026f, 0.07091075f, -0.04698052f, -0.11479594f, 0.17099985f, 0.04481706f, 
    -0.23879755f, -0.05543778f, -0.35049912f, -0.12111267f, -0.03762856f, -0.15833195f, -0.09607435f, -0.23183991f, 
    0.04761906f, -0.00575670f, 0.08463107f, -0.00357550f, 0.25712818f, 0.17453793f, -0.34580594f, -0.12325419f, 
    -0.04069101f, -0.02685986f, -0.22462957f, -0.02234752f, 0.04582348f, -0.08176893f, 0.04170229f, -0.01597757f, 
    0.02035807f, 0.26815698f, -0.33365238f, -0.33775356f, 0.18505009f, -0.24587411f, -0.11075108f, 0.04281980f, 
    0.09805910f, -0.00760342f, -0.07580455f, 0.07451030f, -0.38218269f, 0.16107668f, 0.08856195f, -0.16508397f, 
    0.01009394f, 0.06918737f, 0.01766729f, -0.03342070f, -0.04704107f, -0.03910888f, 0.09631079f, 0.04372150f, 
    -0.14437403f, -0.04978442f, 0.10399719f, 0.01494096f, 0.05637856f, -0.00953428f, -0.06114849f, -0.01098811f, 
    0.15403156f, 0.01115768f, -0.03608588f, -0.02377737f, 0.36252815f, -0.07450302f, 0.13234559f, 0.11201081f, 
    -0.15700728f, -0.07486388f, -0.06676132f, -0.03622438f, 0.05951244f, -0.20429322f, -0.17602406f, -0.00196023f, 
    0.13153931f, -0.22136313f, 0.08831059f, -0.15170020f, -0.08987046f, -0.20459017f, -0.10503337f, -0.21241848f, 
    -0.05446116f, -0.21774124f, 0.12658733f, -0.05851194f, 0.39662373f, -0.03508024f, 0.17727795f, 0.21239099f, 
    0.09393252f, -0.00774628f, -0.01094618f, -0.02770700f, -0.06332973f, 0.05216037f, 0.06556771f, -0.14572267f, 
    -0.48768461f, -0.15163368f, 0.21573199f, -0.07555607f, -0.18486938f, -0.01783289f, -0.08573981f, -0.11434281f, 
    0.00905473f, 0.07188115f, 0.02050314f, 0.07498602f, -0.14776838f, -0.19474927f, -0.09203622f, -0.21049739f, 
    0.06366048f, 0.06343370f, 0.04394879f, -0.06295816f, 0.02982262f, 0.04628828f, -0.03656206f, 0.21396299f, 
    0.09018268f, -0.26384744f, 0.12585592f, -0.33912867f, 0.00362992f, -0.02825017f, -0.24937294f, 0.06064930f, 
    0.14360440f, 0.04839894f, 0.16241232f, -0.07919170f, -0.08841446f, -0.08360463f, 0.06748161f, -0.32187590f, 
    -0.03788428f, 0.16086887f, -0.14662084f, -0.07466154f, -0.00657036f, -0.08025263f, -0.05307729f, 0.02120841f, 
    0.30722529f, 0.36746490f, 0.22810474f, 0.10438418f, -0.07152702f, -0.11204766f, 0.08925995f, 0.05627371f, 
    0.02901296f, 0.22546349f, -0.02448833f, -0.03796197f, 0.26972935f, -0.00927027f, 0.22576401f, -0.15877768f, 
    0.10645644f, 0.07574853f, 0.05093323f, -0.14752622f, -0.25136441f, -0.02526629f, -0.06227015f, -0.11291452f, 
    -0.14822443f, -0.18975720f, 0.28055298f, 0.12412952f, -0.19586430f, -0.02094683f, 0.05496958f, -0.01666427f, 
    -0.08334426f, -0.05240501f, -0.11988088f, -0.09920751f, -0.31622875f, -0.17207973f, -0.28636163f, -0.20053151f, 
    -0.07109184f, -0.20039743f, 0.02610988f, -0.03059936f, -0.13656333f, -0.07622276f, -0.04628835f, -0.05410641f, 
    0.18642390f, -0.38098949f, -0.02681443f, 0.32949910f, -0.03758501f, -0.12941496f, -0.01997694f, 0.26785895f, 
    0.03761731f, 0.11505009f, 0.16334549f, 0.07298512f, -0.17581891f, -0.32737458f, 0.03830123f, -0.01605815f, 
    0.07078324f, -0.07794944f, -0.13829046f, -0.04291321f, -0.27861995f, 0.11474887f, 0.01333826f, 0.04821324f, 
    0.33993366f, 0.08807503f, 0.07064199f, 0.03632149f, 0.12160241f, 0.19054151f, 0.21016608f, 0.03275283f, 
    -0.04589970f, 0.14276761f, -0.13141766f, 0.10091503f, 0.02006082f, 0.15804055f, 0.06830822f, 0.09783978f, 
    -0.08907580f, 0.03148871f, -0.08637535f, -0.05189322f, -0.05200196f, -0.18030323f, 0.01256889f, -0.05971999f, 
    -0.16734894f, -0.03380389f, 0.27093282f, -0.38755700f, 0.03639277f, 0.03036685f, 0.05067015f, -0.12501405f, 
    -0.06319788f, -0.12194467f, -0.04490038f, 0.00740652f, 0.14693746f, -0.01853955f, -0.07028784f, -0.20435524f, 
    0.23944825f, -0.06094422f, -0.05485881f, -0.04760580f, -0.02785098f, 0.07126622f, 0.03675046f, 0.36763528f, 
    0.22208278f, 0.10455506f, -0.07998798f, -0.08747198f, -0.06263281f, -0.04089302f, 0.07207146f, 0.16965431f, 
    -0.20283546f, 0.19767284f, 0.06792583f, -0.05553071f, -0.20492978f, 0.16717592f, 0.05203160f, -0.18855166f, 
    -0.05664280f, -0.09236100f, -0.06746475f, -0.14251494f, 0.05660309f, 0.06588707f, -0.02210378f, -0.11935081f, 
    0.00529919f, 0.48551750f, -0.23511980f, -0.16512653f, 0.32662153f, 0.00551275f, -0.00894552f, 0.24214154f, 
    0.10491730f, 0.06363947f, -0.17794846f, -0.25971159f, -0.55658060f, -0.05701557f, 0.12774971f, -0.15182622f, 
    0.13971722f, 0.01940803f, -0.00263049f, 0.09243699f, 0.30193892f, 0.09066305f, -0.04112748f, 0.06060354f, 
    0.20080350f, -0.25388366f, -0.37900978f, -0.18085200f, -0.21509397f, 0.00049177f, 0.00407631f, -0.03912973f, 
    -0.09637145f, 0.11729351f, 0.10491484f, 0.01379914f, -0.58168232f, 0.09965357f, 0.19967489f, -0.19547947f, 
    0.05073834f, -0.11763833f, -0.00479201f, -0.03171249f, -0.03334759f, 0.03216415f, -0.23254554f, -0.01787324f, 
    -0.48749876f, 0.59366226f, 0.09147866f, 0.20428300f, 0.15745975f, 0.03563610f, -0.21100140f, 0.11105029f, 
    0.03036089f, -0.11481669f, 0.08677968f, 0.16147189f, -0.03263609f, 0.08618501f, 0.04868972f, -0.29540709f, 
    0.13135912f, 0.14695038f, 0.03961072f, -0.09056151f, -0.17431229f, -0.01100169f, 0.00206858f, -0.21495773f, 
    -0.00327433f, -0.35143036f, -0.12337873f, 0.05236947f, -0.02366014f, 0.02044593f, 0.01280785f, 0.21956497f, 
    -0.22323330f, 0.04892673f, -0.01168320f, -0.07434228f, 0.02706875f, -0.03333356f, 0.33383644f, -0.11203789f, 
    0.07776412f, 0.06354890f, 0.02540679f, -0.00555564f, -0.06881542f, 0.07532090f, -0.02267747f, 0.02568289f, 
    0.44453079f, -0.17658526f, -0.30813390f, -0.07448098f, -0.04321286f, -0.04415885f, 0.10915925f, 0.13719498f, 
    -0.01611106f, 0.01034836f, -0.15995565f, -0.17064096f, -0.01114179f, -0.40366474f, 0.22598103f, 0.02427980f, 
    -0.03384239f, -0.08636502f, 0.08173119f, 0.14030236f, -0.23872863f, 0.06939012f, 0.26319242f, 0.14641365f, 
    -0.29920137f, -0.21780106f, 0.25039393f, -0.41915387f, -0.05841806f, 0.07922575f, -0.20148313f, 0.14465918f, 
    0.13192758f, -0.18059227f, -0.01834644f, 0.00077871f, -0.21824846f, -0.13177578f, -0.10195208f, 0.32026502f, 
    0.08536093f, 0.01939698f, -0.18305019f, -0.04527867f, -0.04858253f, -0.00557004f, -0.00717534f, 0.11513318f, 
    0.05128917f, -0.49996787f, -0.11634827f, 0.22490013f, 0.05057633f, -0.02947881f, -0.04117729f, -0.05849439f, 
    -0.11325588f, 0.13688838f, -0.03450997f, -0.07953975f, 0.35903499f, 0.12163338f, -0.06900080f, -0.21997266f, 
    0.20386834f, 0.02203948f, 0.05886634f, -0.16245145f, 0.02752637f, 0.13302916f, 0.06510501f, 0.12295935f, 
    -0.05120592f, -0.11617677f, 0.20418294f, -0.29613310f, 0.05292556f, 0.11851620f, -0.04640215f, 0.01050963f, 
    0.11983434f, 0.05676600f, 0.13631436f, 0.23688997f, -0.61847657f, 0.40410042f, -0.21573262f, -0.22680520f, 
    0.15811005f, 0.03617191f, 0.08433642f, -0.15718770f, 0.07875332f, 0.06925363f, -0.05954976f, 0.00563035f, 
    0.06101440f, -0.19703381f, 0.10709179f, 0.37864032f, 0.08142000f, 0.13586479f, 0.04384683f, -0.04279256f, 
    0.09990600f, 0.03677692f, 0.00692094f, -0.03373678f, -0.10934876f, -0.41470459f, -0.19729839f, 0.16748837f, 
    0.04219107f, 0.15062650f, 0.03652252f, 0.11384191f, -0.01694146f, -0.12062002f, 0.00936689f, -0.18803938f, 
    -0.35441339f, 0.20487069f, -0.12366123f, -0.29796666f, 0.11046536f, 0.01767552f, -0.22189157f, 0.01412715f, 
    0.18272902f, 0.03544858f, -0.06769603f, 0.10621027f, -0.39797181f, -0.17530559f, 0.14091818f, -0.10344660f, 
    0.16182519f, 0.05973724f, 0.03878583f, -0.05257230f, -0.08872283f, 0.03996682f, -0.09309872f, 0.01738842f, 
    0.23164983f, -0.14087436f, 0.06659669f, -0.07015240f, -0.06430925f, -0.08065990f, -0.01739191f, 0.10357105f, 
    0.21691798f, 0.01783958f, -0.07107189f, 0.04153574f, -0.60971862f, -0.00752397f, 0.20225614f, 0.00942139f, 
    0.15745007f, -0.10334154f, 0.02827551f, -0.12796156f, 0.01313049f, 0.16587192f, 0.05973529f, 0.22906554f, 
    0.23687589f, 0.14889109f, 0.05770741f, 0.07601178f, 0.14590453f, 0.05948367f, 0.00163868f, 0.21048956f, 
    0.05568027f, 0.31849518f, 0.18037158f, 0.34123692f, -0.82704037f, -0.39480999f, -0.11712321f, -0.16457556f, 
    -0.08033802f, -0.07561671f, -0.04676139f, 0.05855755f, -0.11572758f, 0.15157966f, -0.04352493f, 0.05930575f, 
    0.18476178f, 0.00453474f, 0.04582390f, -0.04920344f, 0.00072395f, -0.06569845f, 0.01209990f, -0.01132062f, 
    0.11429824f, -0.22960277f, -0.06046348f, -0.14625938f, 0.01206019f, -0.06901626f, -0.14946780f, -0.04618248f, 
    -0.12225074f, 0.00926384f, -0.00658191f, 0.09050285f, 0.15333793f, 0.13106474f, 0.00655698f, -0.06332652f, 
    -0.24796633f, -0.03656664f, 0.22839290f, 0.03590955f, -0.00142730f, 0.07723385f, 0.03733967f, 0.06051144f, 
    -0.05061328f, 0.00884113f, -0.07122316f, -0.14922760f, -0.45729789f, -0.21721604f, 0.29679763f, -0.07668472f, 
    0.21441564f, 0.02243206f, 0.02971274f, -0.12250938f, 0.02667980f, 0.02210419f, 0.12896244f, 0.18080792f, 
    0.36922944f, 0.27731803f, 0.19916417f, -0.04468271f, 0.06146003f, 0.09529869f, 0.06611482f, 0.19514073f, 
    0.03087284f, 0.07722624f, 0.07921842f, -0.04205647f, 0.04024189f, 0.10222275f, 0.05371221f, 0.10308374f, 
    -0.06477475f, 0.03259828f, 0.14081711f, -0.13756612f, 0.14435139f, 0.24317420f, -0.15384012f, 0.04850112f, 
    -0.25549546f, 0.09330479f, 0.08943781f, 0.08712954f, 0.08095165f, -0.00357018f, 0.04736417f, -0.19280256f, 
    0.10391766f, 0.01818158f, -0.00397541f, -0.10942829f, -0.15800369f, -0.05785075f, -0.21537872f, 0.10707259f, 
    0.08473705f, -0.24702257f, -0.01532976f, 0.13555954f, -0.24047373f, 0.05407398f, 0.14638065f, 0.11040540f, 
    -0.40733790f, -0.30193958f, -0.12765838f, -0.14303087f, 0.06167361f, 0.00312735f, -0.01471316f, -0.04966094f, 
    0.06060162f, 0.13134013f, 0.26685092f, 0.04753512f, 0.16495764f, 0.18773133f, -0.16845006f, -0.03165473f, 
    -0.07313501f, -0.09514429f, 0.17729668f, -0.01255893f, 0.13160385f, 0.05159358f, -0.02942398f, 0.08668951f, 
    0.27506107f, 0.23189542f, 0.13013628f, -0.16780902f, 0.03095060f, 0.02985115f, -0.10026807f, 0.27515265f, 
    -0.01956223f, 0.04401319f, -0.12000740f, 0.12621537f, -0.31444582f, -0.48242801f, 0.10655456f, 0.06583099f, 
    -0.02343582f, 0.15149026f, 0.06277981f, 0.24809901f, 0.16697298f, -0.03652593f, 0.15530922f, 0.03137100f, 
    -0.23856902f, -0.50758928f, 0.00967856f, 0.13754229f, 0.00578122f, 0.09105075f, 0.19332744f, 0.12678321f, 
    0.25245786f, 0.06711727f, 0.07470552f, 0.03007866f, -0.70243037f, -0.40670076f, -0.10580242f, -0.45049551f, 
    0.06343106f, -0.08977893f, -0.05378165f, -0.06341110f, -0.05026094f, -0.03677488f, -0.03106917f, 0.18852401f, 
    0.33365649f, -0.03644595f, 0.05054685f, -0.10936961f, -0.20112796f, -0.12686218f, 0.00483515f, -0.11780141f, 
    -0.03872133f, -0.05928004f, -0.02975473f, -0.04774762f, -0.37934628f, 0.06256854f, -0.35345703f, 0.16951334f, 
    0.03548597f, -0.10811013f, -0.08143193f, 0.01742152f, -0.12644625f, -0.03869824f, 0.09785483f, 0.00598995f, 
    0.17964776f, 0.19989435f, -0.04629802f, -0.03604021f, -0.10173688f, 0.05963897f, 0.11857005f, -0.01778272f, 
    0.03363840f, 0.07941587f, 0.12642746f, 0.03163857f, -0.59214008f, -0.04623921f, -0.37019500f, -0.14462772f, 
    0.02007893f, -0.01169563f, -0.23876664f, -0.02007398f, -0.06224297f, 0.03937352f, -0.17300335f, -0.28777099f, 
    -0.45231685f, -0.12943390f, -0.06641407f, -0.01899502f, 0.30412409f, 0.00448147f, 0.11750010f, -0.16301736f, 
    -0.14791338f, 0.00468170f, 0.04462775f, 0.03974301f, 0.25046650f, 0.08043902f, 0.02986426f, -0.08033865f, 
    -0.10857057f, -0.11074974f, 0.04904803f, 0.01050674f, -0.03449785f, 0.00667996f, 0.05719227f, -0.28712863f, 
    0.39337939f, 0.02784031f, -0.00244668f, 0.09878580f, -0.00382905f, 0.07688781f, -0.03303163f, 0.02398496f, 
    -0.08090072f, 0.11569910f, -0.09342603f, -0.12935272f, 0.21904063f, -0.02883904f, -0.21036007f, -0.05231380f, 
    -0.04820734f, 0.09339079f, -0.00958283f, -0.03501821f, -0.08400382f, -0.15760855f, -0.01594210f, -0.04916192f, 
    -0.41108397f, 0.20527618f, -0.08478844f, -0.00277580f, 0.02432151f, -0.17420945f, -0.19313015f, -0.07112228f, 
    -0.05032272f, -0.21978478f, -0.11015037f, -0.10358272f, -0.43630430f, -0.23895131f, -0.29784712f, -0.20944788f, 
    0.13131151f, -0.00164010f, -0.02986417f, -0.04992199f, -0.00543916f, 0.00825871f, -0.01261893f, -0.01224647f, 
    0.27583563f, 0.27921614f, -0.00865227f, 0.06850671f, 0.02259491f, -0.30617815f, -0.01964072f, 0.11692883f, 
    -0.13520715f, -0.23274274f, 0.02416217f, 0.02519705f, 0.36574295f, 0.27644339f, -0.09544877f, -0.22452289f, 
    0.02939922f, 0.12969722f, 0.16727015f, -0.18081275f, 0.01454240f, -0.02071016f, 0.00405370f, -0.01698917f, 
    0.09613137f, 0.02603410f, -0.29406130f, 0.24913515f, -0.07608279f, -0.03170653f, -0.05968805f, 0.07813365f, 
    -0.09026651f, 0.10096073f, 0.11509062f, -0.06318749f, 0.57953441f, 0.13052019f, -0.21890242f, -0.48809654f, 
    0.16420321f, -0.04381974f, -0.02731192f, -0.02796033f, -0.07978512f, 0.01462746f, 0.02846745f, -0.10589267f, 
    -0.13134047f, 0.16735856f, 0.13974600f, -0.36409163f, -0.20060980f, 0.00085815f, -0.16402748f, 0.00999443f, 
    0.13332367f, 0.04146965f, -0.04833216f, -0.18587384f, 0.67516649f, 0.16564848f, -0.15217882f, -0.10011579f, 
    0.03298240f, -0.06478389f, -0.05402288f, 0.04871454f, 0.17576040f, 0.03789774f, 0.03714521f, -0.02952614f, 
    0.06488860f, 0.25296485f, -0.04740975f, -0.10150287f, 0.13140567f, 0.01740161f, -0.02730716f, -0.06910539f, 
    -0.03954240f, -0.00968200f, -0.23350056f, -0.08257685f, -0.46129358f, 0.32071850f, 0.00833440f, -0.15296596f, 
    0.13258165f, -0.05314278f, 0.00988890f, 0.03142143f, 0.01461438f, -0.14719516f, -0.10073381f, -0.00039157f, 
    -0.12727140f, 0.06997160f, 0.01678896f, -0.12534955f, 0.14991747f, -0.19108565f, 0.00000015f, -0.04832148f, 
    0.09022814f, 0.09693811f, 0.06810015f, -0.00007820f, 0.20168495f, -0.08174646f, -0.10191101f, 0.08438567f, 
    -0.17520326f, -0.17071246f, -0.05051043f, -0.15127206f, -0.05191145f, 0.06344731f, -0.00788817f, -0.25550723f, 
    0.35849315f, 0.11586832f, -0.14726439f, -0.04451662f, -0.05327367f, -0.03803894f, -0.05662662f, 0.00412660f, 
    0.12247376f, -0.12207916f, -0.01353797f, 0.00298465f, 0.10011050f, -0.00638208f, 0.11277533f, -0.09569050f, 
    0.09978842f, -0.00929609f, -0.08223681f, -0.19329958f, 0.00420045f, 0.02232752f, -0.05775165f, -0.04126090f, 
    0.14231576f, -0.16771717f, -0.17847352f, 0.03129254f, -0.04541302f, -0.02815415f, 0.04512917f, 0.21834533f, 
    0.05554048f, -0.00478684f, 0.03284183f, 0.07073892f, 0.03173117f, -0.01923651f, 0.05962272f, 0.00799866f, 
    0.11752409f, -0.18730588f, -0.18231793f, 0.17731062f, -0.02454429f, 0.18287063f, 0.11779760f, 0.19071291f, 
    0.27282310f, -0.01376075f, -0.12201159f, 0.00582823f, -0.00024377f, -0.09639355f, -0.00123332f, -0.09297091f, 
    -0.25486532f, 0.01123921f, -0.11575650f, -0.11648184f, -0.16889657f, 0.22912908f, -0.00013902f, -0.17839085f, 
    0.05447442f, -0.07398314f, 0.06664240f, -0.07206193f, -0.14668350f, -0.15374990f, -0.24615675f, 0.03898764f, 
    0.22561809f, -0.40798536f, 0.01423145f, 0.02714866f, 0.14744785f, -0.03664635f, -0.00359196f, -0.13114432f, 
    -0.12431796f, -0.01935391f, -0.14624271f, -0.01236823f, -0.01823281f, -0.38393655f, -0.09113007f, 0.09224685f, 
    -0.01505991f, 0.02921611f, 0.04318321f, 0.20579775f, -0.06140896f, -0.09417313f, -0.05267063f, 0.00498226f, 
    0.06348689f, 0.01784857f, -0.04913399f, 0.40807047f, -0.09422188f, 0.00482283f, 0.03248929f, 0.08271971f, 
    0.14203489f, -0.01984566f, -0.15522116f, -0.20592944f, 0.44219917f, 0.01321542f, -0.23475167f, -0.23081025f, 
    0.04984234f, -0.01345296f, -0.00878173f, 0.04137212f, -0.13541383f, 0.08298358f, 0.01960469f, 0.09110194f, 
    -0.05007566f, 0.36231366f, -0.02643049f, 0.10887872f, 0.24673273f, -0.12291195f, 0.00762528f, 0.07205500f, 
    0.11848395f, 0.13323037f, 0.06469949f, 0.01163241f, 0.35051885f, -0.27248865f, -0.17499697f, -0.25740716f, 
    0.04864411f, 0.04222516f, 0.06126694f, 0.07530218f, -0.05606773f, -0.06634913f, 0.14509138f, -0.01192478f, 
    -0.17923597f, 0.19003958f, 0.02410601f, 0.09379525f, -0.15827066f, -0.12714085f, -0.01067008f, -0.06308031f, 
    0.00256313f, 0.14715475f, 0.09231865f, -0.08742686f, 0.20660222f, -0.16782312f, 0.19217297f, 0.10256164f, 
    -0.10011957f, 0.16693006f, -0.09536827f, -0.00221056f, 0.15349649f, 0.13535966f, 0.05217294f, -0.05459185f, 
    -0.24564084f, 0.10486992f, -0.00800436f, 0.29287738f, 0.06063971f, -0.01669080f, -0.09730222f, -0.00972024f, 
    -0.18779889f, -0.13669260f, 0.02257810f, -0.10229041f, -0.35047579f, 0.05867042f, -0.02857279f, 0.18636616f, 
    -0.17546245f, 0.04526303f, -0.10133174f, 0.08024261f, -0.05694069f, 0.04366450f, 0.14506623f, 0.20923354f, 
    0.27783194f, -0.58406031f, -0.05237908f, 0.24512033f, -0.06496133f, 0.05278477f, -0.12858132f, -0.04845258f, 
    0.10088894f, -0.07106916f, -0.01813257f, 0.17931712f, 0.11450552f, 0.10887662f, -0.18181643f, 0.04622419f, 
    -0.02097996f, 0.00030923f, -0.11226946f, 0.01585618f, 0.03292264f, 0.01339785f, -0.20875210f, -0.01935115f, 
    -0.58541131f, 0.38872164f, -0.14531249f, 0.00892740f, 0.16134121f, -0.03319181f, 0.20396034f, 0.04746620f, 
    -0.01575509f, -0.02769341f, 0.05191638f, 0.02367182f, -0.63123178f, -0.40213290f, -0.17733912f, -0.28633395f, 
    0.07790848f, 0.02691424f, 0.03393159f, 0.15592583f, -0.09751022f, 0.00927546f, -0.09070525f, 0.05907239f, 
    -0.37192947f, 0.03386617f, -0.04406349f, -0.09759184f, -0.04187977f, 0.15657359f, 0.01577773f, -0.10729612f, 
    -0.03483512f, -0.00833961f, 0.09709979f, 0.17895141f, -0.22358553f, -0.41206744f, -0.03280232f, -0.07553802f, 
    0.16463996f, 0.00351361f, 0.07253841f, 0.05923121f, 0.03141994f, 0.05395663f, -0.03955097f, -0.05645118f, 
    0.28727672f, 0.09367609f, -0.05795138f, 0.01625241f, -0.08847672f, -0.09106299f, 0.19665882f, 0.01392720f, 
    0.03003235f, 0.02045212f, 0.04171852f, 0.08294231f, -0.12581092f, 0.12413094f, -0.13694572f, -0.11658181f, 
    -0.10066606f, -0.09028678f, 0.07684151f, 0.05895541f, -0.05777195f, -0.02809141f, -0.15324350f, -0.19532534f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11548121f, 0.05522195f, -0.02676543f, -0.03280396f, -0.00695121f, 0.02017363f, 0.05827726f, -0.07498013f, 
    -0.05010368f, 0.06448471f, 0.11523099f, 0.03226267f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
