#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.32716638f, 0.52658540f, -0.04240626f, 0.39157823f, 0.31680530f, -0.31713098f, -0.19723815f, 0.38865963f, 
    0.26368907f, -1.02360690f, 0.18672706f, 0.71340001f, 0.34248877f, -0.31893152f, -0.40024835f, -0.19024222f, 
    0.02124794f, 0.33925128f, -0.69084901f, -0.48279256f, -0.88250262f, 0.33629990f, 0.39192328f, 0.11370541f, 
    0.31836641f, 0.09368659f, 0.41155270f, 0.60509896f, 0.07203322f, 0.38622910f, 0.26699406f, 0.11078317f, 
    0.25606149f, -0.07613813f, -0.28803226f, -0.35737047f, -0.36484081f, -0.18341291f, -0.22201391f, -0.36850685f, 
    -0.37648898f, -0.43397811f, -0.13781972f, -0.33658963f, -0.24497248f, 0.09430782f, -0.33034980f, 0.32086459f, 
    -0.16897380f, 0.07611552f, -0.18338650f, 0.21747951f, 0.47602931f, 0.39678797f, 0.06340006f, -0.84456664f, 
    -0.40834376f, -0.24405226f, -0.59776485f, 0.36270383f, 0.23381235f, 0.28214887f, -0.20830031f, -0.82018828f, 
    0.86216402f, 0.00958247f, 0.29931521f, -0.01666152f, 0.12412155f, -0.28751150f, -0.29145551f, -0.32047850f, 
    1.16563213f, -0.66447699f, -0.71536636f, 0.70803612f, -0.10668837f, 0.00831928f, -0.25102240f, 0.10778140f, 
    -0.35655770f, -0.76765257f, -0.79696274f, 0.28646845f, 0.73142719f, -0.20866787f, -0.15260857f, -0.26748899f, 
    -0.29451609f, -0.44280067f, -0.97165138f, 0.30510497f, -0.69229007f, 0.13799548f, 0.79675305f, 0.51619619f, 
    -0.05072575f, 0.12517746f, -0.17916253f, 0.44572392f, 0.15652138f, 0.14444482f, -0.71156687f, -0.31391224f, 
    0.49531907f, -0.34017333f, -0.10698387f, 0.61247623f, 0.04699085f, 0.39469957f, 0.16609174f, -0.53348482f, 
    0.29960322f, -0.35151350f, 0.43926090f, -0.05750160f, -0.08243150f, 0.78944772f, 1.01905859f, -0.75071603f, 
    -0.42454463f, 0.21423645f, -0.09664669f, -0.30434063f, 0.28302768f, -0.14651990f, 0.90264779f, -0.95829475f, 
    -0.01792969f, -0.20869569f, 0.01983209f, -0.58681619f, -0.07629384f, 0.02417083f, 0.35310128f, 0.02728931f, 
    0.39587003f, -0.42992979f, -0.33765110f, -0.54285300f, -0.49770862f, -0.32407007f, -0.43906260f, -0.43171588f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.15544122f, 0.13476428f, -0.01824351f, -0.01970831f, -0.36774641f, -0.07075831f, 0.12887937f, -0.14351577f, 
    0.00255775f, -0.32906258f, 0.05467093f, 0.11274638f, -0.00236989f, 0.30024102f, 0.28171051f, -0.03096337f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05300608f, -0.04484603f, 0.02948057f, 0.01644673f, -0.03563005f, -0.04880489f, 0.00447305f, 0.03716055f, 
    -0.01886581f, 0.03223908f, -0.00632044f, 0.00506684f, 0.04136114f, -0.04236766f, 0.02240295f, -0.03781368f, 
    0.00068146f, -0.00098068f, 0.01487606f, 0.04065062f, -0.02930608f, 0.02835904f, 0.03100280f, -0.03754440f, 
    0.02720562f, 0.02768247f, -0.04111813f, -0.01731407f, -0.02173559f, 0.01139635f, -0.04392023f, -0.05551407f, 
    -0.01792113f, 0.00521225f, 0.03694919f, 0.00811294f, -0.02116825f, -0.05555268f, 0.01662873f, 0.02128824f, 
    -0.03949665f, -0.03305080f, -0.00081877f, 0.04540444f, 0.01257559f, 0.00543823f, -0.00016915f, 0.02227449f, 
    -0.00585007f, 0.02744483f, -0.04847986f, 0.00468206f, -0.04419203f, 0.00263372f, 0.04636101f, 0.02366618f, 
    -0.05491189f, -0.01842667f, 0.00400819f, 0.00381366f, -0.02867837f, 0.04979020f, -0.03399922f, 0.00890531f, 
    -0.03210843f, -0.04026798f, -0.04686752f, 0.00746340f, 0.02435008f, -0.05693747f, 0.02527297f, -0.06051325f, 
    -0.03155536f, -0.04903971f, -0.05592889f, -0.00197249f, 0.02184309f, -0.06100082f, -0.03092112f, 0.04776116f, 
    0.02686351f, -0.03321451f, -0.01743844f, 0.01267222f, -0.02356930f, -0.01710618f, -0.02434769f, -0.04984188f, 
    0.00074705f, -0.05465490f, 0.01982438f, 0.04261163f, -0.03984941f, -0.04877295f, -0.05590607f, 0.01851117f, 
    -0.01884273f, -0.03874199f, -0.03576196f, 0.00699354f, -0.02980546f, 0.05531998f, -0.05052692f, 0.00265475f, 
    -0.00166379f, 0.01340311f, 0.02192859f, -0.00262114f, -0.00327848f, 0.00164648f, 0.03072037f, -0.01943718f, 
    0.00023637f, -0.06154815f, 0.02899553f, -0.01909523f, -0.01324779f, -0.02124743f, -0.05587069f, -0.04192643f, 
    -0.01061833f, 0.02833594f, -0.03380607f, 0.01355384f, -0.04657144f, -0.03358220f, -0.00571267f, -0.02163851f, 
    -0.04023121f, -0.05062832f, -0.05088011f, -0.04130324f, -0.02435344f, 0.03533597f, 0.00090414f, 0.01705029f, 
    -0.00448160f, -0.00653833f, 0.01642710f, 0.04195115f, 0.02631638f, 0.02481502f, 0.03435236f, 0.00764330f, 
    -0.04711134f, -0.02604584f, -0.05758108f, -0.03164283f, -0.06137003f, -0.05725678f, 0.03081160f, 0.04027931f, 
    0.04625566f, 0.03469148f, -0.05913622f, -0.00979536f, 0.01261381f, 0.03829986f, -0.00763225f, -0.01185541f, 
    0.00781217f, -0.04624154f, 0.01618067f, -0.04830123f, -0.00669083f, 0.04187970f, -0.01788122f, -0.05857315f, 
    0.04577107f, -0.01026084f, 0.04565498f, -0.03878196f, -0.01167063f, -0.00178767f, -0.00886633f, -0.01516813f, 
    -0.05584896f, 0.01754662f, 0.00904251f, -0.01273326f, -0.06000150f, 0.02787846f, -0.05698567f, 0.04276114f, 
    -0.04216367f, 0.00511053f, 0.01893235f, 0.00648853f, 0.02702027f, -0.04219707f, -0.04917566f, 0.03739456f, 
    -0.06082812f, -0.04625540f, -0.02618998f, 0.00513665f, -0.04903526f, -0.01102829f, 0.04038004f, 0.00202038f, 
    0.03673963f, -0.03315936f, 0.01306212f, -0.03373343f, -0.00790557f, -0.01641740f, -0.03062363f, -0.02361725f, 
    0.02977310f, -0.03128608f, 0.02681668f, -0.04091820f, -0.02364716f, 0.02794212f, 0.03403988f, -0.02489997f, 
    -0.01458278f, 0.03709780f, 0.00138753f, -0.03577960f, -0.02623338f, 0.01817724f, -0.03096719f, -0.01550933f, 
    -0.02620952f, -0.03295859f, -0.03135076f, 0.04169691f, 0.02528362f, 0.02554504f, -0.02595680f, 0.02384169f, 
    -0.05326581f, -0.02414105f, -0.00869596f, 0.02711698f, 0.01049629f, 0.03505336f, -0.03825772f, 0.04759580f, 
    -0.03640637f, 0.05277994f, -0.00503633f, -0.04841478f, 0.03391634f, -0.01689067f, -0.04014708f, -0.04840206f, 
    -0.03467588f, 0.03827975f, -0.06008133f, 0.04405458f, 0.00673012f, -0.03835144f, -0.00955892f, -0.05862516f, 
    -0.02495006f, -0.04778366f, -0.02683181f, 0.02836936f, 0.04185434f, -0.02849147f, -0.04248902f, 0.02170338f, 
    -0.01529515f, 0.04983987f, -0.02114367f, -0.01741854f, -0.06143835f, -0.03709528f, 0.03297894f, -0.00914491f, 
    -0.01601879f, -0.02462880f, 0.03654255f, -0.01445474f, -0.01706935f, -0.06110753f, 0.03473926f, 0.00634916f, 
    -0.02484589f, -0.03143296f, 0.03478620f, -0.03775761f, 0.00665184f, -0.02353861f, -0.03041672f, 0.00125921f, 
    0.01312110f, 0.01411566f, 0.03199200f, 0.00116225f, -0.03979059f, -0.01524894f, 0.00066736f, 0.00839544f, 
    -0.05898969f, -0.01479136f, -0.01099541f, -0.03964318f, 0.01020196f, 0.00004520f, -0.03920796f, 0.01434007f, 
    -0.04331190f, 0.02732180f, -0.03665096f, 0.01267354f, -0.00187564f, 0.03034011f, -0.01210210f, 0.02138654f, 
    0.01718431f, 0.02926321f, 0.00172767f, -0.05542244f, 0.01882371f, 0.03569310f, 0.04729011f, 0.02255488f, 
    -0.06478813f, -0.03518680f, -0.07562348f, 0.08222310f, -0.17631719f, 0.00038106f, -0.06774341f, -0.06640664f, 
    -0.02153872f, -0.03991538f, -0.02403013f, -0.09000508f, -0.01921177f, -0.05041117f, 0.15558694f, -0.12880629f, 
    0.12828028f, 0.00374022f, -0.02016244f, 0.00321930f, 0.24334918f, 0.56948930f, 0.18608621f, -0.15006623f, 
    0.27822754f, 0.09328046f, -0.11051358f, 0.24766909f, 0.07251070f, 0.03051013f, 0.01526901f, 0.08499498f, 
    0.03685956f, -0.05359093f, 0.09473892f, -0.09510831f, -0.06674360f, -0.02082124f, 0.03370332f, -0.00666965f, 
    0.56696361f, -0.17382099f, -0.41744211f, -0.06309708f, -0.03299771f, 0.03220896f, 0.01109142f, 0.04785606f, 
    0.03552023f, -0.03554826f, -0.02996294f, 0.08057916f, 0.00777213f, -0.10834827f, -0.00553646f, -0.01567818f, 
    0.05292813f, 0.01631979f, 0.07341405f, -0.01189658f, -0.00602362f, -0.24061288f, -0.05064483f, 0.19043779f, 
    0.03320253f, -0.03668845f, -0.12966634f, -0.01022341f, 0.02991763f, -0.05076361f, -0.08843458f, 0.07169034f, 
    -0.04972550f, -0.01410690f, 0.06492118f, -0.01761693f, -0.06439014f, 0.03445072f, 0.00062870f, -0.07381985f, 
    0.13393120f, 0.19452186f, -0.10767716f, -0.11663705f, 0.08187294f, -0.01057861f, 0.13753636f, 0.15013419f, 
    -0.01766209f, 0.17481768f, -0.04883879f, 0.01582540f, 0.03795349f, -0.03245594f, 0.02897412f, 0.13936377f, 
    -0.07243463f, -0.10632338f, -0.06475746f, -0.04187432f, -0.21526669f, -0.10157406f, -0.02983976f, -0.01558646f, 
    -0.11187770f, -0.03258032f, 0.06174921f, -0.00661354f, -0.03498012f, 0.01537671f, 0.03791957f, 0.04914758f, 
    -0.05394275f, -0.03893305f, -0.08048868f, -0.04202561f, 0.01520686f, 0.05469429f, 0.04846977f, 0.09966245f, 
    0.26261359f, 0.11008325f, -0.12417610f, -0.14317451f, 0.27004087f, 0.14805879f, -0.07369821f, -0.00127744f, 
    -0.05411909f, -0.00120773f, -0.01960592f, 0.02743512f, -0.01982842f, -0.00440634f, 0.01732507f, 0.06212869f, 
    -0.03892921f, -0.01532529f, -0.00660646f, 0.05166572f, 0.19324489f, -0.10771595f, -0.06352057f, 0.20800304f, 
    0.02323081f, -0.05630108f, 0.02338354f, 0.10721850f, 0.00837128f, -0.05627182f, 0.03006734f, 0.01180771f, 
    -0.04599222f, 0.08343086f, 0.02337138f, 0.08710725f, 0.01735370f, 0.03165988f, 0.06222240f, 0.07130773f, 
    0.05197366f, 0.24166347f, -0.22038792f, 0.47733334f, 0.19230613f, -0.02825348f, 0.05235267f, 0.01797169f, 
    -0.05268633f, 0.08601120f, -0.01236968f, 0.04178655f, -0.12760313f, -0.00694058f, 0.02133009f, -0.10419995f, 
    -0.02781327f, -0.15608130f, 0.14202027f, -0.00849667f, 0.18688007f, 0.47937959f, 0.11864530f, -0.09045832f, 
    0.20213389f, 0.14328206f, 0.08220906f, 0.28728017f, 0.11911743f, -0.02805595f, 0.00813918f, 0.02720267f, 
    -0.05653549f, -0.01723924f, 0.14959109f, 0.13946119f, 0.08185343f, 0.04867150f, 0.02975056f, 0.11995125f, 
    0.71083719f, -0.17309693f, -0.12686191f, -0.17861745f, -0.32716602f, 0.15189882f, 0.12702329f, 0.11053926f, 
    0.02072858f, -0.07873200f, -0.04365120f, 0.01614338f, -0.03838217f, 0.00025646f, -0.03750893f, 0.00472962f, 
    -0.04627069f, 0.05953887f, -0.10933200f, 0.01237243f, -0.16634661f, -0.26872829f, 0.56463283f, 0.07380700f, 
    -0.06646143f, 0.00699459f, 0.02378487f, -0.27666616f, 0.00902978f, -0.12117141f, -0.04196637f, 0.02018431f, 
    0.06481652f, 0.09392765f, 0.04557167f, 0.11294309f, 0.01876902f, 0.03610402f, 0.03098838f, -0.11099113f, 
    -0.15755010f, -0.02659627f, 0.31980556f, 0.12422132f, -0.16615413f, -0.25009409f, 0.02315990f, -0.05160192f, 
    -0.02668698f, -0.02846245f, -0.03808469f, 0.11922485f, 0.05797754f, 0.11498582f, 0.05448785f, 0.05831308f, 
    0.06711385f, -0.04424241f, -0.03984102f, -0.01224034f, -0.33959800f, -0.04530743f, 0.21315254f, 0.24449758f, 
    -0.03676566f, -0.02380395f, -0.02798374f, -0.05215839f, 0.00386751f, 0.00665225f, -0.00712323f, 0.01038266f, 
    -0.02143761f, 0.04352900f, 0.02137500f, 0.03125797f, 0.09797106f, 0.11153015f, -0.01933341f, 0.04621039f, 
    -0.18538579f, 0.21733552f, 0.11478832f, 0.08942329f, 0.02260072f, -0.05972688f, -0.06190596f, 0.19539715f, 
    0.14746183f, 0.16219968f, -0.02888273f, 0.07998324f, 0.03047292f, 0.05250141f, -0.11585846f, 0.02973206f, 
    0.04354186f, -0.06582920f, 0.12542166f, 0.05433965f, -0.03857611f, 0.09512070f, 0.02549876f, -0.09890479f, 
    -0.01503203f, 0.04203814f, 0.01412110f, 0.17624412f, 0.01423674f, 0.26340294f, -0.04742127f, -0.05906897f, 
    -0.00642360f, 0.00308126f, -0.00151979f, 0.15879090f, 0.00420107f, -0.07296421f, -0.03502259f, 0.10199171f, 
    -0.03927281f, 0.01997148f, 0.04138445f, -0.03977708f, -0.00159912f, 0.02359355f, -0.03655012f, -0.05552705f, 
    -0.05900563f, -0.00717196f, 0.01813133f, -0.01647940f, -0.01863716f, -0.03109561f, -0.01105400f, -0.05827866f, 
    -0.05981907f, -0.04634056f, -0.01352480f, -0.04539577f, -0.04641918f, -0.06127885f, -0.03826172f, 0.02050290f, 
    0.02593800f, -0.06131671f, 0.00399666f, -0.02628279f, -0.03613722f, -0.01788995f, 0.04766310f, 0.02609020f, 
    -0.04432447f, -0.03744091f, -0.02401877f, -0.04072057f, 0.02153276f, 0.02848093f, -0.02026752f, -0.03207016f, 
    0.03042542f, 0.03890522f, -0.04232649f, -0.01545385f, -0.05319141f, -0.05795717f, 0.01544145f, -0.00008062f, 
    0.04383703f, -0.02476810f, -0.04992479f, -0.01462681f, -0.01826001f, 0.01691882f, -0.03072409f, 0.04445605f, 
    -0.01458262f, -0.05050194f, 0.04437609f, -0.02670238f, 0.02233094f, -0.01541171f, -0.04442507f, -0.00090836f, 
    0.01062506f, -0.04953913f, 0.03236793f, -0.02244375f, -0.00976599f, -0.00748369f, -0.04836896f, 0.04591541f, 
    0.02620105f, 0.04658783f, 0.03980516f, -0.02250334f, -0.02227041f, 0.01108800f, 0.04737863f, 0.04565741f, 
    0.03806376f, 0.05017769f, -0.02623062f, 0.04602030f, -0.04898914f, -0.03387158f, -0.00524482f, 0.01591419f, 
    0.05438916f, -0.06018948f, 0.02944335f, -0.02098985f, -0.03143110f, 0.03232126f, 0.02383522f, -0.01060840f, 
    -0.02964523f, -0.05351950f, 0.03337953f, 0.01028404f, -0.00135849f, 0.04403813f, 0.01711361f, 0.03003071f, 
    0.00258618f, -0.05884241f, 0.02916167f, -0.02759655f, 0.04953242f, 0.01839245f, -0.04614769f, 0.02397302f, 
    -0.01803904f, 0.04423189f, 0.02023054f, -0.06034240f, -0.05264140f, -0.03582361f, -0.03847526f, 0.03117210f, 
    -0.00993187f, -0.01847489f, 0.00716171f, -0.02142413f, -0.02124359f, 0.02992650f, -0.02665580f, -0.03558755f, 
    -0.01737572f, -0.02413424f, 0.01507482f, 0.02111020f, -0.04780792f, -0.05843404f, 0.00991562f, 0.04930519f, 
    -0.00345549f, -0.04956269f, 0.00262560f, -0.04963666f, 0.03262368f, -0.02784015f, -0.00004244f, -0.04031678f, 
    -0.02839850f, -0.00659266f, 0.00135920f, 0.01171367f, -0.05682969f, 0.02326638f, 0.01705152f, 0.00320727f, 
    -0.01822737f, -0.02759360f, -0.03970438f, 0.02304782f, -0.01575933f, -0.00250393f, -0.02784728f, -0.04009494f, 
    -0.00408870f, 0.00479334f, 0.02054750f, 0.01544920f, -0.00787423f, -0.00567200f, -0.04915616f, 0.02642030f, 
    -0.04031313f, -0.03943047f, -0.01003068f, 0.00779451f, -0.02081637f, -0.00377183f, -0.00279877f, -0.04122368f, 
    -0.04660677f, -0.02776758f, 0.01220653f, -0.04254927f, 0.02261995f, -0.03238450f, -0.03871020f, -0.05576263f, 
    -0.05446342f, 0.02255294f, -0.02911125f, -0.02197387f, 0.05328492f, -0.04585850f, -0.00809588f, 0.04357089f, 
    -0.01146219f, -0.05043079f, -0.04943873f, -0.00695316f, -0.00841868f, -0.05906402f, -0.04561523f, 0.04567644f, 
    0.01284471f, -0.04811450f, -0.01412892f, 0.02662504f, 0.00034593f, 0.01557534f, 0.04534328f, -0.01575657f, 
    0.01813744f, -0.01471732f, -0.04362715f, 0.00379760f, -0.02083710f, -0.02672746f, -0.04740700f, 0.01982139f, 
    0.00015344f, 0.01364680f, 0.04095719f, -0.04753401f, -0.03215073f, -0.04860386f, 0.01040350f, -0.01844263f, 
    -0.04214362f, 0.03839874f, 0.00968357f, 0.02918574f, -0.05240684f, 0.01818005f, -0.03974992f, -0.03492554f, 
    -0.00829259f, -0.00518023f, -0.03953752f, -0.03830795f, -0.00828290f, 0.03970490f, 0.03147467f, -0.00144842f, 
    0.03279515f, 0.04519373f, 0.02960328f, -0.02017963f, 0.01438930f, -0.01121653f, 0.01223966f, 0.04040909f, 
    -0.05992031f, -0.04055093f, 0.01789648f, 0.03666656f, 0.00588271f, 0.03043701f, -0.01622973f, -0.05532401f, 
    -0.02957349f, -0.03869662f, 0.02748277f, 0.02458316f, 0.03790144f, 0.03228024f, -0.05539650f, -0.00119695f, 
    0.04281375f, -0.03768259f, -0.04071032f, 0.00824651f, 0.00682744f, -0.00840001f, 0.03768698f, -0.03768424f, 
    -0.01500563f, 0.02880297f, -0.01986308f, 0.04251326f, -0.00850549f, -0.04232738f, 0.04003673f, -0.00042569f, 
    0.04256200f, 0.00759189f, 0.04366098f, 0.03612900f, 0.00569048f, -0.03368926f, -0.02034265f, 0.04381650f, 
    0.02829031f, 0.01846050f, -0.02888287f, -0.05129032f, -0.03684724f, -0.03121202f, 0.02974243f, 0.00498067f, 
    -0.01631724f, -0.04318311f, -0.01441927f, -0.05318731f, -0.02538115f, -0.01910597f, 0.02078431f, -0.03224768f, 
    0.03513312f, -0.03186140f, -0.02007300f, -0.02218934f, 0.04248247f, -0.04426194f, 0.01018386f, -0.04786447f, 
    0.03838693f, 0.02156341f, -0.00180770f, -0.02303918f, 0.00570067f, 0.01343557f, -0.05163709f, -0.00571075f, 
    -0.21936361f, -0.08629351f, 0.06386795f, 0.04730550f, -0.22793260f, -0.09530328f, 0.01743834f, 0.07791925f, 
    0.00303690f, 0.01276630f, 0.04357836f, -0.04320310f, 0.05157852f, 0.04091439f, 0.14293824f, -0.00142372f, 
    0.11785468f, 0.12998217f, -0.02835209f, 0.10448062f, 0.33520690f, 0.03655234f, 0.39226818f, -0.00587582f, 
    -0.11378495f, 0.10061342f, -0.11201701f, 0.23842956f, -0.04826942f, 0.07210598f, -0.08907422f, -0.02426910f, 
    0.02530027f, 0.13903719f, 0.08998354f, 0.06540839f, -0.07102873f, -0.07076293f, 0.01050840f, 0.14861046f, 
    0.31233713f, -0.22049187f, -0.27002910f, -0.09139499f, 0.00074280f, -0.19014052f, 0.02164020f, 0.01667291f, 
    0.17519630f, 0.18532972f, 0.14337401f, 0.11112500f, -0.04432506f, -0.19623509f, -0.09524839f, 0.02206755f, 
    0.01683439f, -0.00470485f, 0.11925248f, -0.03625724f, -0.16098338f, -0.11839750f, 0.08939259f, 0.20835114f, 
    -0.26786417f, 0.01967675f, -0.08634793f, -0.17437941f, -0.01794328f, -0.08650465f, -0.07790858f, -0.00636025f, 
    -0.08942538f, 0.01637899f, -0.07310142f, 0.10144292f, 0.01450978f, 0.01363108f, 0.04354511f, 0.21506551f, 
    -0.19891147f, -0.05109747f, -0.08890524f, 0.06312838f, -0.01241550f, -0.14436953f, -0.00118823f, -0.00391597f, 
    0.01634353f, -0.09189247f, -0.00845015f, -0.00679608f, -0.04076619f, 0.03780385f, 0.03127925f, 0.13992171f, 
    0.04090054f, -0.06411798f, 0.01878932f, -0.08552741f, 0.01966600f, -0.03728033f, -0.13428497f, 0.07006429f, 
    -0.14898074f, -0.02099834f, -0.03970611f, -0.04655487f, -0.07970944f, -0.08374473f, 0.07546864f, 0.05514643f, 
    0.04664281f, -0.04567539f, 0.03023971f, -0.04674970f, 0.16626123f, 0.13105507f, 0.14473709f, 0.12735675f, 
    0.15472120f, -0.03806108f, -0.18512380f, 0.10554443f, 0.17529856f, -0.03248311f, -0.01397764f, -0.00280278f, 
    0.04897191f, -0.01109603f, -0.02524289f, -0.05236780f, 0.00283769f, -0.03871556f, 0.12021346f, -0.02245158f, 
    -0.02010043f, -0.04834658f, 0.07183804f, -0.03249004f, 0.31848803f, -0.23207872f, 0.01031411f, 0.03172711f, 
    -0.05767252f, -0.00224027f, 0.04072781f, -0.03445960f, -0.02526349f, -0.26014969f, -0.04709236f, -0.01660551f, 
    -0.13886033f, 0.11168124f, -0.01481562f, -0.19949988f, -0.06533897f, -0.03872752f, -0.09989671f, -0.16453309f, 
    -0.36773556f, 0.17269892f, -0.10714459f, 0.32036877f, 0.31912175f, 0.16983065f, 0.11409058f, 0.01058715f, 
    -0.01877360f, 0.10979075f, -0.02290311f, -0.04699294f, -0.15256129f, 0.13429433f, 0.07882161f, -0.16702271f, 
    -0.17745236f, -0.20334117f, -0.00492320f, -0.05951523f, -0.05142613f, -0.17089890f, -0.27342820f, 0.22404359f, 
    -0.01049606f, -0.06257914f, 0.02276538f, 0.18662567f, -0.04958988f, -0.12354919f, -0.10826969f, 0.00581456f, 
    -0.03740831f, 0.02276000f, -0.03336210f, 0.06633421f, -0.04587324f, -0.08497259f, 0.08227526f, -0.07543047f, 
    0.37175831f, -0.19984795f, -0.12219608f, -0.32677305f, -0.18004824f, -0.22063410f, 0.01639033f, 0.09174182f, 
    0.08407741f, 0.00015800f, 0.06385151f, 0.16902767f, 0.00089742f, -0.06874128f, -0.12285865f, -0.02448618f, 
    -0.13409682f, 0.11950646f, -0.03879596f, -0.08709230f, -0.00906326f, -0.21269010f, 0.24962239f, 0.21951430f, 
    -0.08732907f, 0.07883044f, 0.12267742f, -0.11769522f, 0.24798279f, -0.01297644f, -0.20796540f, -0.07021960f, 
    0.09339947f, -0.01272920f, -0.03314840f, 0.07637701f, -0.06520521f, 0.05067384f, 0.19539380f, 0.06652963f, 
    -0.12494678f, 0.06649356f, 0.15350050f, 0.10157330f, -0.14294675f, -0.04400508f, -0.05332284f, 0.09381797f, 
    -0.06377184f, -0.10470939f, -0.12579116f, 0.00292357f, 0.00837151f, 0.08315561f, 0.04589111f, 0.00930868f, 
    0.11570142f, 0.24520913f, 0.07618651f, 0.18812101f, -0.20591778f, -0.02311329f, 0.09914185f, 0.21427204f, 
    0.01868649f, 0.08128916f, 0.01310203f, 0.14987300f, -0.01927708f, 0.07717120f, -0.10622297f, 0.05165889f, 
    0.10570455f, -0.05465100f, -0.09338347f, 0.02978232f, -0.12958597f, 0.23051362f, 0.00207460f, 0.02326418f, 
    0.16859764f, -0.10268609f, 0.26551831f, 0.27052832f, 0.19822916f, 0.10345878f, 0.00685956f, -0.02706331f, 
    0.30561030f, 0.07490763f, -0.10869842f, 0.13840592f, 0.00020590f, 0.04806098f, 0.06174384f, -0.01913133f, 
    0.01522818f, -0.08323951f, 0.18944071f, 0.09188054f, 0.06607641f, 0.03986903f, 0.07039276f, 0.09370199f, 
    0.01449247f, -0.01290384f, -0.02981075f, 0.18788128f, 0.03497268f, -0.01291051f, 0.04532458f, 0.01588144f, 
    0.04304531f, 0.02162458f, -0.07613671f, 0.10765364f, 0.05314655f, 0.00672665f, -0.10189667f, -0.03182398f, 
    -0.03443798f, 0.00449174f, -0.03536136f, -0.06475797f, -0.02550578f, 0.01366869f, 0.01649060f, -0.07130834f, 
    -0.06997543f, -0.07588693f, 0.00919453f, -0.02888437f, 0.02475188f, -0.05706949f, 0.01625083f, -0.04250912f, 
    -0.01388678f, -0.06614906f, -0.08599246f, -0.03641343f, -0.07430484f, 0.00199315f, -0.01948964f, -0.03848191f, 
    -0.05245904f, -0.05450421f, -0.00649227f, -0.02822433f, 0.02826340f, -0.00884353f, -0.08061914f, -0.02220364f, 
    -0.07790063f, 0.01312077f, -0.02612681f, 0.00383161f, -0.08318517f, -0.04704551f, -0.05591911f, -0.07390630f, 
    -0.04871746f, -0.03336727f, 0.00908609f, -0.03251483f, -0.05301786f, 0.02243464f, -0.04331231f, -0.04347961f, 
    -0.03656346f, -0.07919834f, -0.07482659f, 0.02739586f, -0.03508990f, 0.01811437f, -0.07504630f, 0.00990200f, 
    -0.03099712f, 0.01375198f, -0.06535494f, -0.05696914f, -0.02766931f, -0.06784393f, -0.07299376f, -0.06591652f, 
    -0.05123330f, -0.08478478f, -0.06821506f, -0.05801783f, 0.02314216f, -0.06341413f, -0.04711879f, -0.06386670f, 
    -0.02817843f, 0.00104806f, 0.01084356f, -0.04469286f, 0.02068179f, -0.04485096f, -0.01710347f, -0.00436231f, 
    -0.02751047f, -0.08105732f, -0.01688977f, -0.03873028f, -0.04841374f, -0.04035496f, -0.03329276f, -0.08498847f, 
    -0.03402852f, -0.02001998f, -0.07322244f, -0.06375357f, -0.06531741f, -0.06527689f, 0.00520981f, -0.07272706f, 
    -0.08545019f, -0.02508858f, -0.07080372f, -0.01958259f, -0.07055598f, -0.04939936f, 0.01518091f, -0.02098560f, 
    -0.05503094f, -0.00346242f, 0.01034075f, -0.01091316f, 0.03049616f, -0.02316382f, 0.01159819f, -0.04442005f, 
    -0.04401000f, -0.05113592f, -0.03233895f, -0.07921208f, -0.00693371f, -0.07073940f, -0.06107187f, -0.00916758f, 
    0.01459819f, 0.01383354f, -0.07403477f, -0.05253305f, -0.07639717f, -0.01802984f, -0.02271757f, -0.03622597f, 
    -0.08022087f, -0.03821261f, -0.04554522f, -0.08633803f, -0.02527113f, -0.06846651f, -0.02335494f, -0.03104624f, 
    -0.00200980f, -0.07608543f, -0.07884733f, -0.02115320f, -0.07762366f, -0.03724305f, 0.00778309f, -0.06432139f, 
    -0.01971806f, -0.00237167f, 0.00225747f, -0.06449300f, -0.08354060f, -0.07576795f, -0.05408084f, 0.01666387f, 
    0.02692262f, -0.07439184f, -0.01150476f, -0.06994502f, -0.01769688f, -0.05233502f, -0.01665582f, -0.04677215f, 
    -0.06409401f, -0.01182330f, -0.06517531f, 0.00182621f, 0.01405344f, 0.00169528f, -0.06646944f, -0.01720220f, 
    -0.02205855f, -0.02017241f, -0.02519357f, -0.06248593f, 0.01950944f, 0.02213952f, -0.00172472f, -0.05445186f, 
    -0.03990711f, 0.00483621f, -0.00580371f, -0.03663632f, 0.01887222f, -0.01421056f, 0.00634828f, 0.02018866f, 
    -0.02591675f, -0.06789093f, -0.04782324f, 0.00283331f, -0.03381060f, -0.04767125f, -0.07962319f, -0.01289511f, 
    -0.06562342f, -0.03194593f, -0.01586726f, 0.01579043f, -0.01114734f, 0.00504809f, 0.01925409f, -0.04879544f, 
    0.01667176f, -0.04970634f, -0.07318070f, -0.05543707f, -0.04650088f, 0.01949047f, -0.07630809f, -0.08541172f, 
    -0.04459756f, -0.04805428f, -0.00574586f, 0.00997776f, -0.06283586f, -0.05227267f, -0.03299854f, -0.01004972f, 
    -0.04773650f, 0.00158739f, 0.00369555f, 0.02061751f, -0.01473044f, 0.00084760f, -0.01617283f, -0.04594902f, 
    0.01869683f, -0.01466669f, -0.04756662f, -0.00489458f, -0.03964444f, -0.04281004f, -0.07349798f, -0.05970754f, 
    -0.05620091f, -0.04247651f, 0.00764438f, -0.00372572f, -0.05240835f, -0.07981519f, -0.03776484f, -0.03230444f, 
    -0.04928680f, -0.01964251f, -0.05232381f, -0.01879570f, 0.01609207f, 0.00641972f, -0.03697244f, -0.05674836f, 
    -0.01397388f, -0.03172976f, -0.08055875f, -0.03911597f, 0.00379847f, 0.02322508f, 0.02353561f, -0.06378229f, 
    -0.07230922f, -0.05648365f, -0.00928864f, -0.05442980f, 0.00711750f, 0.00049842f, -0.04357303f, -0.02557274f, 
    0.00360985f, -0.07037078f, -0.07328273f, -0.05584146f, -0.07200000f, 0.01644319f, -0.00017767f, -0.01195510f, 
    0.00386764f, -0.05538128f, 0.03242199f, -0.03733153f, -0.07328212f, 0.01363621f, -0.04075538f, -0.07947548f, 
    -0.01446550f, 0.01032161f, -0.00699427f, -0.04672214f, -0.06302054f, -0.00814588f, -0.01098356f, 0.00176416f, 
    -0.05323316f, -0.00147514f, -0.08332865f, 0.01732574f, -0.04893473f, -0.07800639f, -0.02985591f, -0.02686980f, 
    -0.07361042f, -0.01040793f, -0.02151571f, -0.00705407f, -0.01615723f, -0.07741294f, -0.06194105f, -0.00615854f, 
    -0.05069675f, -0.06418901f, -0.02995506f, -0.06610756f, -0.00197582f, -0.05183151f, -0.07671193f, -0.04653368f, 
    -0.06940670f, -0.00106486f, -0.06748695f, -0.03963451f, -0.04992638f, -0.01256379f, 0.02089348f, -0.02633646f, 
    0.01214517f, -0.02220589f, -0.00806381f, -0.02654953f, -0.01388954f, 0.04335742f, -0.00429770f, 0.01520546f, 
    0.01485181f, -0.03460279f, 0.02942472f, 0.03457872f, -0.00017006f, -0.00756996f, -0.01245661f, -0.03797463f, 
    -0.01559175f, -0.00222009f, 0.00055302f, -0.04894791f, -0.04607873f, 0.04666056f, -0.04980329f, -0.01606608f, 
    -0.00214402f, -0.00965728f, 0.00574472f, 0.03515309f, 0.04998759f, 0.02895676f, 0.04633471f, -0.03877231f, 
    -0.00310541f, -0.02449683f, 0.00378811f, -0.01979417f, 0.02827688f, -0.04150207f, 0.02427510f, -0.02516614f, 
    -0.02869035f, 0.02940228f, -0.02822203f, 0.04159639f, 0.02039975f, 0.00188171f, -0.02188664f, -0.02461862f, 
    0.02381726f, 0.00209641f, 0.01285700f, 0.02092250f, -0.00572449f, -0.04275507f, 0.00716149f, -0.02972147f, 
    -0.05687026f, -0.00278109f, -0.03954015f, -0.02929003f, 0.05617708f, -0.04339726f, 0.02905761f, -0.03473628f, 
    0.00655993f, -0.00704956f, -0.02547955f, -0.00060625f, -0.02047145f, -0.02028898f, -0.03076415f, -0.04422240f, 
    -0.01015484f, 0.04261766f, -0.03958783f, 0.00471740f, 0.01762286f, -0.00157607f, -0.00001709f, -0.02962331f, 
    -0.01946069f, -0.05904836f, 0.04891548f, -0.02235605f, -0.03186625f, -0.01661145f, 0.02146007f, 0.03218665f, 
    -0.04253651f, 0.00095914f, 0.01715795f, -0.00222896f, 0.01169075f, 0.04352305f, -0.01300178f, 0.00407302f, 
    -0.01020836f, -0.01367187f, -0.04848438f, -0.02291543f, -0.04462476f, -0.00016472f, 0.02761675f, -0.01194812f, 
    -0.02920135f, 0.03678806f, -0.01519290f, 0.01196965f, -0.00080729f, -0.02213827f, 0.03281315f, -0.05851100f, 
    0.03192759f, -0.00042545f, 0.03682765f, 0.02262117f, 0.01363397f, -0.02157177f, 0.01959962f, -0.02605387f, 
    -0.02438830f, -0.05206877f, -0.00033347f, -0.05860428f, -0.04359406f, -0.02713860f, -0.01604680f, -0.03023185f, 
    0.01643039f, -0.02778226f, 0.04453462f, -0.04886485f, 0.03872154f, 0.04820371f, 0.01636917f, -0.00364344f, 
    -0.01795528f, 0.04144644f, 0.00890066f, -0.01404393f, 0.03505123f, 0.01824627f, 0.05359035f, -0.03041066f, 
    0.00924538f, -0.04596670f, -0.06167151f, 0.00747296f, -0.05170163f, 0.03468632f, 0.01311674f, 0.05656696f, 
    0.02948630f, 0.00899174f, 0.05396839f, 0.02458148f, 0.03709298f, -0.00670895f, -0.01814466f, 0.00850660f, 
    -0.01706470f, 0.01134492f, -0.03347650f, 0.01067630f, -0.00354842f, 0.03235228f, 0.04417865f, 0.01417383f, 
    -0.02648491f, -0.05249385f, 0.00007957f, -0.01803540f, 0.01619218f, -0.04600187f, 0.04714560f, -0.01863458f, 
    0.05448255f, 0.00260848f, -0.02030699f, -0.05122482f, 0.02509308f, 0.02553565f, 0.00785973f, -0.02161030f, 
    -0.03073076f, 0.03780954f, -0.04846081f, 0.00631811f, 0.05199011f, 0.03241204f, 0.06064158f, 0.02668685f, 
    -0.03191908f, -0.05437696f, -0.05415442f, 0.03879622f, 0.02332027f, -0.05890096f, -0.00544387f, -0.02555097f, 
    0.02970780f, -0.00336099f, 0.02982300f, 0.02670285f, -0.05542599f, -0.01503163f, 0.00966562f, -0.00429651f, 
    -0.05499056f, 0.01303581f, -0.05019731f, 0.04318296f, 0.01536488f, -0.01702065f, -0.04749225f, -0.02081964f, 
    -0.05960358f, -0.04534664f, -0.04096664f, -0.02571708f, -0.03163221f, 0.02023581f, 0.01028083f, -0.00955862f, 
    -0.05116147f, 0.00171491f, 0.02209565f, 0.01740299f, -0.05760776f, 0.03989048f, -0.04607884f, 0.01823933f, 
    -0.04470358f, -0.02713879f, 0.01963378f, -0.05478132f, -0.05721065f, 0.01281671f, 0.04778546f, 0.03093489f, 
    0.04218842f, 0.00519490f, 0.00475363f, -0.03075381f, -0.02116181f, -0.05790849f, 0.01283256f, 0.00688439f, 
    -0.00219304f, -0.03207946f, -0.02869883f, 0.03487117f, 0.00684677f, -0.02340018f, 0.04740733f, -0.03672789f, 
    0.01368811f, -0.02798259f, -0.01736945f, -0.05581956f, -0.05036031f, 0.01829739f, -0.05803774f, 0.01659339f, 
    -0.03880746f, -0.02521917f, -0.04709245f, 0.02812551f, -0.00789589f, 0.03202275f, -0.05557192f, 0.03610798f, 
    0.03035841f, -0.03920684f, 0.00501379f, -0.01499530f, 0.01644709f, -0.06029998f, -0.04768079f, 0.01944076f, 
    -0.01289272f, 0.04641176f, -0.05814772f, 0.00625874f, 0.04016168f, 0.04282872f, -0.05343602f, -0.02059506f, 
    -0.01352263f, 0.02409134f, -0.04344316f, 0.02177531f, -0.01555277f, -0.05739423f, 0.01467947f, 0.00404713f, 
    -0.02890776f, 0.04954774f, 0.02647888f, -0.04291854f, -0.05676482f, 0.03366181f, -0.04830662f, 0.03802295f, 
    0.02264158f, 0.04563649f, 0.02090557f, -0.01586301f, 0.00488132f, 0.03716591f, -0.02012310f, 0.01411578f, 
    -0.04378741f, -0.04687427f, -0.04267763f, 0.00318834f, -0.03317350f, -0.03606210f, -0.04806642f, -0.00897184f, 
    0.02526138f, -0.11822274f, -0.09883491f, -0.07031233f, 0.08536621f, -0.10452811f, 0.05767813f, -0.15096340f, 
    -0.05314016f, 0.03269888f, 0.01472366f, -0.05558323f, 0.01720189f, -0.00697054f, -0.02507100f, 0.01571427f, 
    0.04897555f, 0.03507884f, -0.04532030f, -0.01977074f, -0.17477977f, 0.15448011f, 0.52718920f, 0.18833129f, 
    -0.08592760f, 0.07812284f, 0.07177030f, -0.04058097f, 0.03808213f, 0.04384246f, 0.02994252f, -0.01052199f, 
    -0.05163310f, -0.13124587f, 0.17627320f, 0.07982041f, -0.00710573f, -0.28531325f, -0.00112861f, -0.02424238f, 
    -0.22130090f, -0.15065728f, -0.06250734f, 0.30575365f, -0.02162160f, 0.09470135f, -0.20180598f, -0.08731628f, 
    -0.04074223f, 0.00226987f, -0.02036961f, -0.03020023f, -0.00547350f, -0.04082238f, 0.04023649f, -0.02221999f, 
    0.00461414f, -0.00173805f, 0.01289085f, 0.08051788f, 0.21802455f, -0.33338168f, -0.12245116f, 0.00076137f, 
    0.09849096f, -0.05029332f, 0.00680068f, -0.04410928f, -0.03457305f, -0.09867762f, -0.03763263f, 0.01717879f, 
    0.06861104f, -0.06131855f, -0.05344219f, 0.04711132f, -0.00329933f, 0.21778096f, 0.12506469f, -0.13958831f, 
    -0.11632404f, 0.06061610f, 0.29454017f, 0.36541718f, 0.12530695f, -0.04032783f, -0.03255605f, 0.10561407f, 
    0.07284126f, 0.11453599f, 0.06346211f, 0.09456272f, 0.00870113f, -0.00672337f, 0.01844115f, 0.12968525f, 
    0.12109045f, -0.16568871f, -0.36813584f, -0.20649399f, -0.11987670f, -0.04551212f, -0.12388545f, 0.00843628f, 
    -0.05330897f, 0.04262333f, -0.04164026f, -0.03802141f, 0.07279414f, -0.04571137f, -0.00553034f, 0.04267428f, 
    -0.00936241f, -0.09950686f, -0.10323257f, 0.13110907f, -0.02112677f, 0.01430358f, -0.14921284f, -0.01519166f, 
    0.17797430f, 0.03309491f, 0.43287981f, 0.43017858f, 0.10873780f, 0.19599459f, -0.08542170f, -0.02440609f, 
    -0.00781984f, 0.05557393f, 0.01823219f, 0.13318306f, 0.05122844f, -0.04700573f, -0.03089671f, 0.05428888f, 
    0.00842811f, 0.04125736f, 0.05458681f, 0.09059903f, 0.07758881f, 0.07802353f, -0.01744007f, -0.08534350f, 
    0.22869188f, 0.10856291f, 0.07772155f, -0.01647480f, 0.12015335f, 0.07609934f, -0.05957275f, -0.09857828f, 
    -0.15798496f, 0.05625138f, -0.06706569f, -0.14216106f, -0.12639701f, 0.11006704f, 0.36087900f, -0.11104255f, 
    -0.33477509f, 0.31665567f, 0.05268581f, 0.10219786f, 0.08393458f, -0.03546787f, 0.02277513f, 0.01136082f, 
    0.10004752f, -0.01183219f, -0.08832553f, -0.03138148f, -0.08028092f, -0.08495105f, 0.03657750f, 0.03169524f, 
    -0.15055227f, 0.03203157f, 0.18127687f, -0.18439893f, -0.61879534f, 0.07642225f, 0.33375809f, 0.42326546f, 
    -0.05875603f, 0.07839984f, 0.03375615f, 0.14580768f, -0.14751147f, -0.04632888f, -0.02629326f, -0.03347929f, 
    -0.01813960f, 0.13002880f, 0.10336337f, -0.11175292f, -0.09087170f, -0.04568648f, -0.13286926f, 0.08617735f, 
    -0.13461353f, 0.55727077f, -0.34986079f, 0.19763160f, -0.05666196f, 0.16666330f, -0.03794246f, -0.05076171f, 
    -0.08155705f, -0.14779328f, 0.03065641f, -0.07537550f, 0.00357540f, 0.14544587f, 0.02901207f, -0.09707148f, 
    -0.04440173f, 0.18491365f, -0.06801137f, 0.11086148f, 0.16480400f, -0.20168778f, 0.16928402f, 0.22814816f, 
    -0.06398717f, 0.02830658f, 0.13205174f, -0.23274042f, 0.00803465f, 0.03540965f, 0.04019782f, 0.25590745f, 
    0.15053576f, -0.08199181f, 0.14149185f, -0.06492803f, -0.15576191f, -0.00647582f, -0.29232311f, 0.05458445f, 
    -0.23437594f, 0.13962714f, 0.06836046f, 0.12487172f, 0.05578680f, 0.08689535f, -0.02325701f, -0.05157623f, 
    0.04346510f, 0.02869924f, 0.01859017f, -0.07868288f, 0.01777749f, 0.14762890f, 0.03868115f, 0.14097890f, 
    0.00119286f, 0.10103378f, -0.00712385f, -0.01583304f, 0.66290146f, -0.11839791f, -0.06210814f, 0.24220534f, 
    0.26956171f, 0.00162127f, 0.07708500f, -0.17332715f, -0.06709452f, 0.07075270f, -0.07059872f, -0.00324729f, 
    0.04504249f, 0.03794041f, 0.01784284f, 0.02608788f, -0.02623275f, 0.09340154f, -0.02396658f, -0.16079310f, 
    -0.25124976f, 0.12503229f, 0.47968313f, 0.24300601f, 0.11949975f, 0.08992469f, -0.22787857f, 0.09404906f, 
    0.18939868f, 0.20294870f, -0.00049860f, -0.05006463f, 0.01381136f, -0.17666145f, -0.03018839f, 0.08455238f, 
    -0.14219306f, -0.10290394f, 0.19430564f, 0.12762417f, 0.25052476f, 0.03540741f, 0.26619643f, 0.23180214f, 
    0.31797045f, 0.01770897f, -0.02157623f, 0.06530122f, 0.10803261f, 0.21231744f, 0.09391640f, 0.08248205f, 
    0.01689784f, -0.04715748f, -0.02064389f, 0.17615804f, 0.08844854f, -0.15004565f, -0.10859262f, -0.07775664f, 
    -0.19870102f, 0.06872267f, 0.12935247f, -0.04113090f, -0.09040134f, -0.10337629f, -0.17055787f, -0.07306234f, 
    -0.03536036f, -0.21190378f, 0.05398569f, 0.02166802f, -0.02588163f, 0.07736298f, 0.08065813f, -0.08221078f, 
    0.12471521f, 0.00402368f, 0.16888201f, 0.19410165f, 0.22545220f, 0.25074744f, 0.16386069f, 0.06436107f, 
    0.17099428f, 0.11739005f, 0.06540162f, 0.01421320f, 0.24240831f, 0.01550723f, -0.01255302f, 0.07652760f, 
    0.13925372f, 0.00938556f, 0.06122824f, 0.01181182f, 0.19073269f, 0.10523716f, -0.15691853f, 0.06273022f, 
    0.03788997f, -0.32729456f, -0.13782626f, -0.09026486f, 0.02573258f, 0.15672557f, 0.02205999f, 0.03859706f, 
    0.10442580f, -0.13307036f, 0.09594367f, -0.01699489f, 0.18121786f, 0.07605627f, -0.01409092f, 0.07411678f, 
    0.01182397f, -0.00373849f, 0.03821111f, 0.02162979f, -0.05568428f, 0.16533636f, 0.08560663f, 0.10186832f, 
    -0.03760114f, -0.05366884f, -0.05110758f, -0.09156004f, -0.10710037f, -0.15847751f, -0.12699468f, -0.01256735f, 
    -0.04190248f, 0.01005105f, -0.05677300f, 0.02654237f, -0.00881238f, 0.07533728f, 0.06928736f, -0.08434699f, 
    -0.06521460f, -0.04138647f, -0.06504106f, 0.02697228f, -0.11533289f, 0.07250654f, -0.15078864f, -0.04701298f, 
    0.10775548f, 0.01276598f, -0.03249973f, 0.00156424f, -0.03937645f, -0.05415871f, -0.00085108f, -0.08529639f, 
    0.06467325f, 0.06351595f, -0.12205797f, -0.09343306f, -0.08028655f, -0.26549545f, -0.23241763f, -0.07401019f, 
    -0.24701194f, -0.09173439f, -0.09028184f, 0.01920737f, 0.02084027f, -0.13453881f, 0.04900670f, 0.00617901f, 
    0.15058883f, 0.05857819f, -0.05457895f, -0.05834334f, 0.35322356f, 0.12437157f, 0.30373070f, 0.20233715f, 
    -0.14437838f, -0.07296853f, -0.24963844f, -0.00351807f, 0.14247882f, 0.05068871f, -0.02131623f, 0.18995503f, 
    0.04205300f, 0.12587312f, -0.12042636f, -0.00679216f, -0.01075066f, 0.06183923f, 0.06360734f, 0.04382284f, 
    0.13674124f, 0.03901049f, -0.13412049f, 0.07642595f, -0.13382126f, 0.39095891f, 0.03073049f, 0.14546391f, 
    0.08136775f, -0.04484621f, 0.01868103f, 0.01740356f, -0.11032794f, -0.06394586f, -0.00449040f, -0.10497749f, 
    -0.00892314f, -0.03816890f, -0.02489328f, 0.01317253f, -0.20200902f, -0.05875837f, 0.00098196f, -0.14100562f, 
    0.33190757f, 0.15543015f, 0.15497831f, -0.06529412f, 0.27614003f, -0.08510116f, -0.18054244f, -0.00423951f, 
    0.00871810f, 0.02471783f, -0.06086813f, 0.04832407f, 0.03290199f, -0.08772618f, -0.07477391f, 0.03651727f, 
    0.06563035f, -0.05357521f, 0.10557919f, 0.13161029f, 0.04749260f, 0.30321822f, 0.19146800f, -0.05062844f, 
    0.13227127f, 0.04979848f, -0.04507372f, -0.20380870f, 0.44332612f, 0.01897173f, 0.13183810f, -0.07421035f, 
    -0.07195832f, -0.04408434f, 0.03036414f, 0.03666163f, -0.13077746f, -0.14700255f, -0.10837569f, -0.18007825f, 
    0.44207498f, 0.02537253f, 0.01433307f, -0.09442212f, -0.15873438f, 0.04166255f, -0.06665979f, -0.06828974f, 
    -0.18989827f, -0.27756369f, 0.04104014f, 0.05780102f, 0.01535389f, 0.13806564f, 0.16278283f, 0.13955753f, 
    0.06313351f, -0.09586093f, 0.08595676f, 0.00149152f, -0.10509283f, 0.10823105f, -0.28901652f, 0.23737524f, 
    -0.15877481f, 0.04267551f, -0.04148158f, 0.15490447f, -0.13899919f, 0.12614930f, 0.00338529f, 0.04175376f, 
    0.03606212f, 0.01183478f, -0.04346928f, 0.12017307f, 0.02487802f, 0.02303795f, 0.12600613f, 0.11717837f, 
    0.06678178f, -0.03025339f, 0.01823504f, -0.23494223f, 0.00836581f, -0.11627109f, 0.06638152f, -0.09669994f, 
    0.06653436f, -0.11476906f, -0.06151168f, -0.05899911f, 0.10231717f, 0.12811562f, -0.02211966f, 0.01006826f, 
    0.11061930f, 0.07606752f, 0.18294419f, 0.05412829f, -0.10718020f, 0.10669946f, 0.43200472f, -0.04536941f, 
    -0.01375356f, -0.24698287f, -0.08888648f, -0.07367439f, 0.00052942f, -0.04340077f, -0.02607587f, 0.04173479f, 
    -0.12780750f, 0.08139839f, 0.05934513f, -0.00783685f, 0.08783777f, -0.13895705f, 0.04941560f, 0.08138126f, 
    -0.00247604f, -0.12507382f, -0.18206380f, 0.15841010f, -0.16680089f, -0.03485545f, 0.06703631f, 0.09718508f, 
    -0.07191844f, 0.18701707f, 0.05701119f, 0.04165960f, 0.09380756f, 0.15231803f, -0.06573723f, 0.12835088f, 
    0.10291065f, 0.01612877f, 0.03454968f, 0.09800988f, -0.10733730f, -0.14098614f, -0.02103915f, -0.04152993f, 
    -0.03738943f, 0.09456523f, -0.02212630f, 0.07151832f, 0.05845141f, 0.14357592f, 0.01017655f, 0.04065758f, 
    0.02073192f, 0.05953982f, 0.02485404f, -0.10245599f, -0.10935985f, 0.01622593f, -0.09506395f, -0.16355644f, 
    0.01104502f, 0.03824568f, 0.21873729f, -0.06037704f, -0.13048023f, 0.12626515f, -0.06492053f, -0.00713078f, 
    0.12336913f, 0.00345521f, 0.02910603f, -0.08143670f, 0.00333428f, -0.04469249f, 0.06918094f, 0.06505005f, 
    0.10692208f, 0.02670399f, 0.20036152f, -0.02735942f, 0.04036118f, 0.20857142f, 0.27193469f, 0.10195620f, 
    0.36876708f, 0.14600267f, -0.01087813f, 0.19373484f, -0.06731926f, 0.04292395f, -0.10230342f, 0.11094815f, 
    -0.00378031f, 0.13907033f, -0.08941601f, -0.00012816f, -0.08210222f, -0.17664562f, -0.04237508f, -0.04173863f, 
    -0.12799567f, -0.15500337f, 0.17219499f, 0.25118643f, 0.30233392f, -0.01445765f, -0.00897733f, 0.07901612f, 
    0.01938150f, -0.02776147f, -0.03241355f, 0.09470200f, 0.07950750f, -0.13542479f, -0.03191056f, -0.06844735f, 
    -0.16603819f, -0.07056937f, 0.07561123f, -0.16143452f, 0.05929547f, -0.04018607f, 0.02991603f, 0.00619099f, 
    -0.15175615f, -0.04192862f, -0.05935351f, 0.06603967f, 0.06708082f, 0.06985312f, -0.06465159f, -0.03325153f, 
    -0.02491634f, -0.08131938f, -0.08541964f, 0.13328093f, -0.03064895f, -0.02972154f, -0.00244759f, -0.08980085f, 
    -0.10687832f, -0.09982336f, -0.24321011f, 0.17958203f, 0.25019512f, -0.02861243f, 0.05185860f, 0.03145589f, 
    0.04851777f, -0.01882389f, -0.12128247f, 0.01927691f, -0.05655315f, -0.11687987f, -0.09873790f, 0.03880955f, 
    -0.13262005f, 0.02658287f, -0.11674882f, 0.06956242f, -0.06407817f, -0.10750201f, -0.12512942f, 0.00064038f, 
    -0.04548301f, -0.00668386f, 0.02869153f, 0.07039723f, -0.05215126f, 0.07082048f, -0.01380973f, 0.04785157f, 
    -0.07745596f, -0.11170439f, -0.11673756f, 0.02571969f, 0.01742354f, 0.06099626f, 0.14806233f, 0.00744822f, 
    -0.17064644f, 0.11472627f, -0.15952848f, 0.07196630f, 0.44794083f, -0.03205737f, 0.00942820f, -0.06861421f, 
    -0.01382190f, -0.11102029f, 0.11278461f, -0.03064193f, 0.04882063f, -0.00431533f, 0.08323758f, 0.06003163f, 
    -0.04390477f, 0.01146123f, -0.09661187f, 0.06580443f, 0.27998900f, -0.32657909f, -0.02845707f, -0.15019120f, 
    0.02384715f, 0.07904323f, 0.16307959f, 0.09490252f, 0.16082510f, -0.06844480f, 0.00215497f, -0.01174923f, 
    -0.08833015f, -0.07230237f, -0.05122602f, 0.08104271f, -0.07494336f, -0.11418280f, -0.01205415f, -0.10559119f, 
    0.01459870f, 0.51608551f, -0.13452734f, 0.29898661f, 0.02987838f, 0.04894463f, -0.11299054f, -0.06049456f, 
    -0.16469888f, 0.10107182f, 0.00600091f, 0.04785917f, 0.09041893f, 0.00137422f, -0.06419526f, 0.07468982f, 
    0.04018731f, -0.09550413f, 0.00698129f, 0.03051021f, -0.26306283f, 0.24050452f, 0.06025241f, 0.28058171f, 
    0.23811795f, 0.03109246f, -0.00227599f, 0.11181492f, 0.04239205f, 0.01166450f, -0.11590007f, 0.00819056f, 
    0.02697432f, 0.02042871f, 0.02651701f, 0.02762061f, -0.00701619f, -0.10473836f, -0.07219190f, -0.19143412f, 
    0.24964909f, -0.37366393f, 0.25125664f, -0.12822831f, -0.04000674f, 0.05264250f, 0.14260311f, 0.09431091f, 
    0.00536384f, -0.05369671f, -0.09410360f, 0.05452076f, -0.14007840f, -0.06877280f, -0.01019284f, -0.01381041f, 
    -0.11527997f, -0.13476640f, -0.02222752f, -0.09987199f, 0.16638450f, 0.02546672f, 0.34138581f, -0.04633595f, 
    0.10198581f, -0.13848634f, 0.23612815f, -0.10485756f, 0.08878385f, -0.05495799f, -0.04024291f, -0.07776102f, 
    0.01125378f, 0.15815437f, 0.01904423f, -0.04320933f, 0.09081726f, -0.02981572f, 0.00646877f, -0.14572272f, 
    0.23183672f, -0.13926823f, 0.24412204f, 0.09718068f, -0.08590843f, -0.16432302f, -0.03287297f, -0.29045093f, 
    0.02950466f, 0.02550572f, -0.01249175f, 0.02313356f, 0.11884680f, 0.10616715f, 0.07823812f, -0.03304217f, 
    0.05789996f, -0.01776607f, 0.11070866f, -0.00621937f, 0.10911151f, -0.08293056f, 0.47029757f, 0.33349010f, 
    -0.02163225f, -0.02287818f, -0.10204634f, -0.08538396f, 0.09037104f, -0.07327447f, -0.05852070f, -0.01931353f, 
    0.07469780f, 0.17825632f, -0.03559631f, -0.09920499f, -0.02687690f, 0.09390856f, 0.16576654f, 0.04439038f, 
    -0.31233281f, 0.15729193f, -0.23231111f, 0.38200864f, -0.09828901f, 0.03282140f, -0.08930366f, 0.11208820f, 
    0.22379355f, 0.04644788f, -0.07683180f, 0.05389484f, 0.12457754f, 0.04002810f, -0.13572222f, -0.03795952f, 
    -0.05139617f, 0.16037269f, 0.13344042f, -0.01386744f, -0.04917593f, -0.16573961f, -0.13215259f, -0.00076296f, 
    0.15338358f, 0.05871724f, 0.01421555f, 0.07980935f, 0.10285497f, 0.02429798f, 0.01058595f, -0.04180891f, 
    0.06327253f, 0.03845205f, -0.06275578f, -0.03293593f, -0.15315615f, -0.14681229f, 0.02935531f, 0.03461212f, 
    0.00714707f, -0.04028196f, -0.06118757f, -0.00490560f, -0.02765278f, -0.04127819f, 0.01713589f, -0.01399040f, 
    -0.02323071f, 0.03862967f, -0.01530203f, 0.01503053f, 0.05435266f, -0.02447413f, -0.01634333f, -0.06260454f, 
    -0.02908636f, 0.01546055f, 0.02249336f, -0.04656311f, -0.04002793f, -0.03365189f, -0.03979677f, 0.00440232f, 
    -0.02741859f, 0.03157040f, -0.06017121f, -0.01530433f, -0.03042467f, -0.02479016f, -0.01754843f, -0.02928337f, 
    -0.04607503f, -0.02903977f, -0.01356503f, -0.00600422f, 0.02387938f, 0.02508957f, -0.03883680f, 0.05832646f, 
    0.01615442f, 0.01226933f, 0.03864250f, 0.00541360f, -0.01861223f, -0.04278727f, 0.04562346f, -0.02073427f, 
    0.05819570f, -0.03088370f, -0.04908031f, -0.05128234f, -0.00146570f, 0.04787187f, -0.00516029f, 0.01662200f, 
    0.02654421f, -0.03050434f, 0.04034973f, -0.05310947f, -0.05625811f, 0.01950129f, 0.03956494f, 0.03622390f, 
    -0.02909239f, -0.01521979f, -0.05620090f, -0.02968107f, 0.03574053f, 0.01779138f, -0.02902550f, 0.04350859f, 
    -0.05152284f, -0.06122603f, -0.04912421f, 0.00947158f, -0.00429937f, -0.01782354f, -0.02027519f, -0.02878279f, 
    0.01872737f, 0.04710540f, -0.03346768f, -0.04489720f, 0.00232662f, -0.05417473f, -0.02930473f, -0.06728926f, 
    0.03866303f, 0.03898888f, -0.04114066f, 0.01024407f, -0.00383019f, 0.02312544f, 0.05121082f, -0.04766693f, 
    0.01256347f, 0.03610508f, -0.02873390f, -0.05037203f, -0.00874413f, -0.01494070f, 0.03444958f, -0.05436577f, 
    -0.01313750f, 0.04736757f, -0.02906265f, 0.02171192f, 0.04379865f, 0.00834201f, -0.05583220f, -0.05533721f, 
    -0.01097567f, -0.04485789f, -0.01992765f, -0.02202089f, 0.04560178f, 0.01131987f, -0.05078792f, 0.02700784f, 
    0.01689832f, 0.02040354f, -0.03969279f, 0.03007319f, -0.03799387f, -0.06182260f, -0.06358289f, -0.01727141f, 
    0.04496751f, 0.04868894f, -0.04229284f, -0.03621243f, 0.01865931f, 0.01861439f, 0.02382094f, -0.04410429f, 
    0.02966307f, -0.04651457f, -0.04755113f, -0.01308290f, -0.02923554f, -0.06730003f, -0.00834896f, 0.01174396f, 
    -0.01536570f, -0.00765003f, -0.06560797f, 0.04867265f, 0.02284275f, 0.03954721f, -0.00541920f, -0.05232991f, 
    -0.00983936f, -0.00532695f, -0.04750209f, -0.05931539f, 0.00848873f, -0.02717994f, 0.03881706f, 0.04936215f, 
    0.00889097f, 0.02805600f, -0.03805872f, -0.01836730f, -0.01020007f, 0.01280032f, -0.02589377f, 0.00594504f, 
    -0.05275299f, 0.05170512f, 0.02827946f, 0.04108655f, 0.02427862f, -0.01974979f, -0.04424711f, 0.01641387f, 
    -0.05986715f, 0.02784812f, -0.00573458f, 0.04124652f, 0.00252633f, 0.03739996f, -0.07472264f, 0.01136687f, 
    -0.02282892f, -0.02282781f, 0.03749136f, 0.00523866f, 0.02635838f, -0.04081242f, 0.03965639f, 0.00218680f, 
    -0.04226879f, 0.00287907f, -0.03788130f, -0.06439591f, 0.02013640f, 0.00424023f, 0.03504111f, -0.03277539f, 
    0.02433836f, 0.03574289f, -0.00468577f, -0.03751776f, -0.02447375f, 0.01604148f, -0.02652165f, -0.05681861f, 
    -0.00011214f, 0.02885524f, 0.04165273f, -0.00845581f, -0.01556226f, 0.00684613f, 0.00647409f, 0.03066196f, 
    -0.02029225f, -0.03737403f, -0.05606498f, -0.02675487f, 0.01659063f, -0.00473314f, -0.04180812f, 0.01956454f, 
    -0.03358641f, -0.04014876f, -0.00180341f, 0.03080543f, -0.05687909f, 0.04830008f, 0.04998751f, 0.03451846f, 
    0.00475314f, 0.03200113f, -0.01478863f, -0.01869208f, -0.00943159f, 0.05403636f, -0.03280330f, -0.03367391f, 
    0.00796967f, 0.04978609f, -0.03053001f, -0.04586053f, 0.01713714f, 0.03842186f, -0.05043931f, -0.02666776f, 
    0.00270625f, 0.00011830f, -0.01349979f, -0.00649819f, -0.04785035f, 0.03677827f, 0.04273629f, 0.02449180f, 
    -0.03212024f, -0.00988750f, 0.04205607f, 0.04705847f, -0.06511211f, 0.04472835f, -0.05121817f, -0.01393163f, 
    0.00552645f, -0.03705860f, -0.05836429f, -0.00563458f, -0.02149026f, 0.04294032f, -0.02683163f, 0.02286242f, 
    -0.05134708f, 0.05314995f, -0.00862685f, -0.04965242f, -0.04650700f, -0.01574101f, -0.04876085f, -0.05981699f, 
    0.04537770f, 0.03309869f, -0.00851459f, -0.03154295f, -0.00091447f, -0.02953776f, -0.05516789f, 0.00677475f, 
    -0.00331180f, 0.05424704f, 0.04183359f, 0.03289105f, -0.05746679f, -0.00480903f, 0.01038200f, -0.03664131f, 
    -0.04638259f, -0.03034488f, -0.01061931f, 0.02557812f, 0.01613505f, -0.02829353f, -0.01178444f, 0.01126787f, 
    0.01410650f, 0.03203211f, -0.00228674f, 0.03537102f, 0.00809308f, 0.02251039f, -0.00959382f, -0.03249859f, 
    -0.03061401f, -0.03162555f, -0.00476023f, -0.03257674f, 0.00087940f, -0.04927241f, 0.00632091f, -0.05511476f, 
    0.03733846f, -0.00022458f, 0.04614183f, -0.01109313f, -0.04969533f, -0.03207796f, -0.04212737f, 0.01261639f, 
    0.02851791f, -0.01029699f, -0.04766282f, -0.02674625f, 0.02547801f, -0.02339755f, -0.05154623f, -0.01884174f, 
    -0.02949601f, 0.00691216f, 0.02770067f, 0.04353848f, -0.05764490f, 0.01415286f, 0.02298378f, -0.03605139f, 
    -0.00958693f, -0.02997064f, 0.02447741f, 0.01651611f, -0.05330807f, -0.06213143f, 0.01528919f, -0.02280401f, 
    0.04872125f, 0.01409511f, -0.05930319f, -0.06068442f, 0.01409968f, 0.00811100f, -0.02838033f, -0.01505569f, 
    0.03758546f, 0.02279760f, -0.00888418f, 0.03044793f, 0.00381601f, -0.01462434f, -0.05138630f, 0.03246231f, 
    0.04195613f, 0.04699299f, 0.03989746f, -0.05044922f, -0.00652381f, -0.06038793f, 0.04262615f, 0.02200701f, 
    0.01419361f, -0.00901165f, -0.02475771f, 0.01272485f, 0.04564219f, -0.05506812f, -0.04168751f, 0.02847079f, 
    -0.03837565f, -0.03921973f, -0.01758206f, -0.03571891f, 0.00337623f, 0.04845465f, -0.02417614f, 0.04653063f, 
    -0.02114174f, -0.01049997f, -0.03850763f, -0.04319318f, -0.03815154f, -0.03451197f, 0.03669834f, -0.00747096f, 
    0.01196734f, -0.05405453f, 0.03529797f, -0.03673966f, -0.00784375f, -0.00423315f, -0.01567320f, 0.02231764f, 
    0.00925143f, -0.05643518f, -0.05357056f, 0.01756636f, -0.02851762f, 0.03899410f, -0.01530771f, -0.00312481f, 
    -0.05729503f, -0.03281123f, 0.00819135f, 0.04473529f, -0.01188996f, -0.02796861f, 0.04163601f, 0.05298263f, 
    -0.04859868f, -0.04071401f, 0.01172712f, -0.04261623f, -0.05017902f, -0.00753483f, -0.05660311f, -0.01776211f, 
    0.00012034f, 0.03740520f, -0.01354358f, -0.01684017f, -0.03718324f, -0.02199952f, -0.01782532f, -0.05326438f, 
    0.02463982f, -0.01019493f, -0.02154220f, 0.02217549f, -0.02187217f, 0.01981505f, -0.03211027f, -0.04041728f, 
    -0.03150683f, 0.02281286f, -0.01207676f, -0.05201491f, 0.04289884f, -0.04207478f, 0.01291900f, 0.03216872f, 
    -0.02935197f, -0.03671680f, -0.00272160f, 0.03128792f, 0.01409860f, -0.04423979f, 0.01508151f, 0.03645724f, 
    0.00805388f, 0.02780632f, -0.03400311f, -0.03710276f, -0.02539133f, -0.04364891f, 0.03991921f, 0.02444053f, 
    -0.03209999f, 0.01745933f, -0.02239607f, -0.01901224f, 0.00090755f, -0.02217224f, -0.06120502f, 0.04638964f, 
    -0.03939999f, 0.04274204f, 0.01130099f, -0.05331253f, -0.03229386f, 0.02037907f, 0.02339046f, 0.02914879f, 
    0.02812819f, -0.06119786f, 0.03485304f, -0.01959017f, -0.01211593f, 0.03868705f, 0.02878888f, -0.06247129f, 
    0.02885013f, -0.03011069f, 0.01269891f, -0.06286927f, -0.04890000f, -0.05095894f, -0.03281326f, -0.02585528f, 
    -0.04671725f, 0.04382303f, -0.05078687f, -0.05437035f, 0.03778685f, 0.02813260f, 0.04367702f, -0.03997386f, 
    -0.03577665f, 0.02442859f, -0.00231537f, -0.05397849f, -0.01103532f, 0.03828808f, 0.03504073f, -0.01728221f, 
    0.04827961f, -0.02258858f, 0.01707972f, -0.00070729f, 0.01079656f, -0.01876994f, -0.04745371f, -0.01493681f, 
    0.03096252f, -0.03276170f, 0.02498432f, -0.02604255f, 0.01267716f, -0.05624617f, 0.03814229f, 0.02611678f, 
    0.02342913f, -0.03512781f, 0.03889411f, -0.01803654f, -0.00981976f, -0.04396467f, -0.06106440f, 0.03526903f, 
    -0.03082450f, -0.05685638f, 0.02258693f, 0.00967428f, -0.04928415f, -0.00626107f, -0.04754043f, -0.05481843f, 
    -0.03335998f, -0.01390671f, -0.03255108f, -0.01525600f, 0.03175736f, 0.03954197f, 0.02693181f, 0.04254342f, 
    -0.00221361f, -0.04801508f, 0.01684231f, -0.03870926f, -0.01518282f, 0.02151825f, 0.02674364f, 0.00909452f, 
    0.04189736f, -0.05534943f, 0.04417589f, -0.01103688f, 0.00040063f, -0.03986160f, -0.01771231f, 0.01915994f, 
    -0.02743586f, -0.05947756f, -0.03718841f, 0.03824565f, 0.04198020f, -0.02819020f, -0.02586801f, -0.00837855f, 
    -0.01212229f, 0.03210017f, -0.01331257f, -0.00585826f, -0.05936556f, 0.02301363f, -0.02833012f, -0.03919726f, 
    -0.03997721f, -0.01178003f, 0.03494206f, 0.03932653f, -0.04158033f, -0.03502336f, 0.02219323f, 0.00022631f, 
    -0.06016757f, 0.02340403f, 0.01322293f, 0.03330107f, 0.01967802f, 0.04088303f, -0.01905204f, -0.04593952f, 
    0.02350752f, 0.01506111f, 0.01859711f, -0.02622463f, -0.01478567f, 0.04005640f, 0.02163996f, -0.05731384f, 
    -0.05953239f, 0.00396554f, -0.03752465f, 0.00753712f, -0.02553210f, -0.05209432f, 0.01141793f, 0.03036695f, 
    -0.01661308f, 0.00435385f, 0.03537471f, -0.02697349f, 0.02848348f, -0.02118735f, -0.00938131f, 0.01071485f, 
    0.01492540f, -0.01927400f, 0.02849350f, -0.03380354f, 0.02311299f, -0.02442425f, -0.00706232f, 0.04761419f, 
    0.02381037f, 0.02542338f, 0.04260631f, -0.06022688f, -0.03987243f, -0.02085750f, -0.03437970f, 0.04389159f, 
    0.01132937f, 0.00155855f, -0.06643464f, 0.00546962f, -0.03117870f, -0.01060377f, -0.03892938f, -0.01435191f, 
    -0.03581247f, 0.03156060f, -0.05070190f, 0.02207693f, 0.02128981f, -0.06215025f, -0.02281626f, -0.06453127f, 
    0.02981081f, 0.02336520f, 0.01671365f, -0.02028609f, 0.03458651f, 0.02052864f, -0.04992115f, 0.02562941f, 
    -0.03916129f, -0.00373215f, -0.02644632f, 0.03676404f, -0.02532164f, 0.03160191f, 0.01894713f, 0.04173179f, 
    0.00712259f, -0.04923502f, 0.00311512f, 0.03216926f, -0.03640287f, 0.03790772f, -0.00833141f, -0.01259752f, 
    0.02614195f, -0.02036780f, 0.00232678f, 0.04130473f, 0.02988821f, 0.03587358f, -0.01504457f, -0.03605464f, 
    -0.05738412f, 0.01059024f, -0.02893217f, 0.02599423f, 0.01045915f, -0.05249130f, -0.05916369f, 0.03664359f, 
    -0.02416748f, -0.02431359f, 0.01282112f, 0.01872487f, 0.04218604f, -0.03006496f, -0.05364058f, -0.00815862f, 
    0.00573178f, 0.03330156f, 0.02460641f, -0.01591825f, 0.02439213f, 0.01444105f, -0.06073972f, 0.03480496f, 
    -0.04807395f, -0.00944347f, -0.02557604f, -0.06091172f, 0.02380114f, 0.01505247f, -0.03139495f, -0.00294187f, 
    0.02314706f, 0.01108757f, -0.03467332f, 0.02915187f, 0.00222456f, -0.04340891f, -0.01072800f, 0.01525842f, 
    0.02520009f, -0.04290865f, 0.00000277f, 0.00430265f, 0.03343012f, 0.02433800f, -0.06059176f, 0.04247872f, 
    -0.00886822f, 0.04214813f, 0.00316084f, 0.03939838f, -0.04145485f, 0.02899124f, -0.03161888f, 0.00693526f, 
    -0.00129330f, 0.00419110f, 0.02974508f, 0.03125913f, -0.02349265f, 0.03658217f, -0.02291676f, 0.00469582f, 
    0.00846856f, 0.03537624f, 0.03091386f, -0.01507751f, -0.04774952f, 0.03592028f, -0.04674849f, -0.02807359f, 
    -0.00173279f, -0.04937825f, -0.03851774f, 0.01082216f, -0.04779236f, 0.02342873f, -0.05402363f, -0.01506577f, 
    -0.06110639f, 0.00623025f, -0.02071624f, 0.04369109f, -0.00277408f, 0.04257181f, 0.03000964f, 0.02464425f, 
    0.00870186f, 0.01956753f, 0.04691217f, 0.00576246f, 0.00936908f, -0.02822402f, -0.02631907f, -0.05303608f, 
    -0.00835974f, -0.05850606f, -0.03220541f, -0.03625757f, -0.01124299f, -0.04987654f, 0.04351145f, -0.02592944f, 
    -0.01107475f, -0.05072577f, 0.03307743f, -0.00571871f, -0.03388616f, 0.02480037f, -0.05324193f, 0.02737938f, 
    0.01725911f, -0.06425641f, 0.04374932f, 0.02969856f, 0.04247713f, 0.01090348f, -0.04432948f, -0.04116706f, 
    -0.00768464f, 0.03482514f, -0.02040972f, -0.04409751f, -0.01845655f, 0.05336018f, -0.04652616f, 0.01960927f, 
    -0.02664392f, -0.03566760f, -0.04363421f, -0.04335568f, -0.05699052f, -0.03123601f, 0.03123318f, 0.02177641f, 
    -0.02624796f, -0.02118263f, -0.04652338f, -0.02416711f, 0.03665153f, 0.02469525f, 0.01768557f, -0.01191701f, 
    -0.04040482f, 0.03549506f, 0.01319448f, -0.05664064f, 0.02897626f, 0.02199369f, -0.05204987f, 0.03200476f, 
    -0.01868803f, -0.01199301f, -0.04536315f, 0.01505209f, -0.04271403f, 0.04044210f, -0.03807848f, -0.02179998f, 
    -0.02128825f, -0.01801485f, -0.01756804f, -0.02030475f, -0.05073665f, 0.02806689f, 0.03310027f, 0.03948127f, 
    -0.05031125f, -0.02979444f, -0.05862218f, -0.00236202f, -0.05019801f, -0.03322922f, 0.00088359f, 0.01789067f, 
    -0.05657167f, 0.02998369f, -0.03231781f, 0.01946627f, 0.02225767f, -0.00114164f, -0.01862238f, -0.02366949f, 
    -0.03378967f, -0.05693644f, 0.02074136f, 0.00003775f, -0.06486731f, 0.02597160f, -0.01022414f, 0.01294256f, 
    -0.03841130f, -0.02576250f, -0.05874904f, 0.01699511f, -0.04739131f, 0.01781002f, -0.03232419f, -0.01329039f, 
    -0.01214256f, -0.05266907f, -0.01311073f, -0.02077797f, -0.04789650f, -0.01335118f, -0.02944084f, 0.02440548f, 
    -0.05099166f, -0.02104773f, -0.00234442f, 0.03014329f, 0.02355560f, -0.03079610f, -0.02706717f, -0.01371058f, 
    0.03294269f, -0.02689239f, -0.05443296f, -0.06194156f, -0.01633562f, -0.05010961f, -0.01116810f, -0.01261610f, 
    0.03543638f, -0.00857222f, -0.03187323f, -0.05708228f, 0.02164740f, -0.05729380f, 0.02620209f, 0.02078071f, 
    -0.04766417f, -0.04497039f, -0.04593641f, -0.06326889f, 0.04114833f, -0.06475458f, -0.01995672f, 0.02221373f, 
    0.00570878f, -0.05341288f, 0.02104489f, -0.00486496f, 0.04147609f, 0.00501587f, -0.05158841f, 0.02680042f, 
    0.02998401f, -0.06466259f, 0.01586036f, -0.02246196f, 0.02325701f, 0.00932897f, -0.01863099f, 0.01099759f, 
    0.02448631f, 0.02334904f, 0.01622033f, -0.01276216f, -0.03295019f, -0.02448250f, -0.03280562f, 0.00783907f, 
    0.02832927f, 0.01808891f, 0.03518076f, -0.04945382f, 0.02949025f, 0.01610917f, -0.04964394f, -0.04616577f, 
    -0.03922442f, 0.02715063f, -0.01224766f, -0.02057289f, -0.04271881f, -0.02649287f, -0.02725635f, -0.04088040f, 
    -0.00719440f, 0.02043157f, 0.00901043f, 0.00688548f, 0.00544673f, 0.03125877f, -0.03222277f, -0.01644591f, 
    -0.05519263f, 0.04233620f, 0.03114089f, 0.04991329f, -0.01147852f, -0.02426125f, -0.02577988f, 0.01204343f, 
    -0.02565793f, -0.04145401f, 0.03771142f, -0.04177669f, 0.03055989f, -0.01871938f, 0.01331612f, 0.00275558f, 
    -0.05810254f, 0.01964948f, 0.00635367f, 0.00191092f, -0.02415579f, -0.04079868f, -0.03263732f, -0.06484624f, 
    -0.04338244f, 0.03850646f, -0.01954649f, 0.01254741f, 0.00665815f, -0.02672442f, -0.00414242f, -0.03357568f, 
    0.02501974f, -0.04395927f, 0.00634698f, -0.05550236f, -0.02778677f, -0.04854370f, -0.03921691f, -0.03129608f, 
    -0.00176006f, -0.02519555f, -0.03209873f, -0.01830364f, -0.02529391f, -0.05061940f, -0.01077530f, 0.00849514f, 
    -0.04935724f, 0.01078808f, -0.04004979f, 0.03813948f, -0.01818749f, -0.04631739f, 0.00184781f, 0.05845512f, 
    0.01037565f, 0.01435702f, -0.04926797f, 0.00929479f, -0.01096583f, -0.01400199f, -0.04452847f, 0.00569790f, 
    -0.02763889f, 0.02435749f, 0.00394841f, -0.05647867f, 0.01754948f, -0.00436494f, -0.05415543f, 0.01285315f, 
    0.00664537f, 0.03583241f, -0.01386274f, 0.02024090f, 0.01871078f, -0.06516824f, -0.02786415f, -0.04594694f, 
    -0.05408232f, -0.01220394f, 0.03368640f, 0.04454317f, -0.01352355f, -0.06334125f, -0.00701797f, -0.05883300f, 
    -0.01057566f, 0.02084464f, -0.02359777f, 0.03419851f, 0.04122320f, -0.06104406f, 0.01606219f, 0.03143873f, 
    0.00944067f, 0.05278872f, -0.01923077f, -0.03737697f, 0.06009757f, 0.04224450f, 0.04651100f, 0.00423472f, 
    0.03925711f, -0.00348074f, -0.05092144f, 0.00339641f, -0.03510314f, -0.05563347f, 0.03714065f, -0.00336321f, 
    0.03634652f, -0.00750696f, 0.00954661f, -0.03136990f, -0.01831344f, 0.02555283f, 0.01876328f, -0.02181280f, 
    0.03969925f, 0.03735296f, 0.00599340f, 0.00424241f, 0.01026031f, -0.05894885f, -0.03794487f, -0.06084897f, 
    -0.03728178f, -0.04059367f, -0.04500433f, -0.03832949f, 0.02501602f, -0.02274518f, 0.01404197f, -0.03989533f, 
    -0.05684806f, -0.01417880f, -0.02571348f, 0.04500639f, 0.01181158f, -0.01999166f, -0.05076917f, 0.00466467f, 
    0.03321672f, -0.02798734f, -0.05227663f, 0.04645439f, -0.00987667f, 0.03298311f, -0.01455097f, 0.05411347f, 
    -0.02765789f, -0.01388850f, -0.02875023f, -0.03330135f, 0.03912630f, 0.04501846f, -0.00390555f, -0.02901547f, 
    -0.02343541f, 0.04940967f, -0.00859965f, -0.03659878f, -0.04205672f, 0.04297842f, 0.02625022f, 0.04096867f, 
    -0.00644634f, 0.00414034f, 0.04450428f, -0.05510605f, 0.04659286f, 0.00169066f, -0.01689550f, 0.03773200f, 
    -0.03507465f, -0.05261640f, 0.05745931f, -0.00639632f, -0.03367900f, 0.03378670f, -0.03291418f, -0.03871680f, 
    -0.02637693f, -0.00280587f, -0.02212940f, 0.01969157f, -0.05599145f, -0.02690627f, -0.03876437f, 0.02530066f, 
    0.02502207f, 0.01849053f, -0.02504505f, 0.02558354f, -0.02183363f, -0.00429493f, -0.01610444f, 0.00779391f, 
    -0.04870826f, 0.04232467f, -0.05991730f, -0.03442918f, 0.01349455f, -0.03965002f, 0.02874953f, -0.04518964f, 
    -0.03891563f, 0.01470105f, -0.03632495f, -0.02916790f, 0.03813810f, 0.04060323f, 0.03145818f, 0.04187221f, 
    -0.02824470f, -0.00819375f, -0.00095466f, -0.05117688f, 0.01135786f, -0.00152520f, -0.02633557f, -0.01273772f, 
    -0.02907436f, -0.01046937f, -0.00558557f, 0.03153609f, -0.02962286f, 0.04671180f, -0.06634257f, -0.06184226f, 
    -0.06048021f, -0.03179008f, -0.05715040f, 0.00256955f, -0.04559122f, 0.03606641f, -0.02438452f, -0.00598900f, 
    -0.01001932f, -0.00990217f, -0.06039003f, 0.05092899f, 0.03695909f, 0.04120245f, -0.03067878f, -0.04532538f, 
    0.03564652f, 0.04550679f, 0.00592513f, 0.03674248f, -0.01162687f, -0.04613208f, 0.01940367f, -0.01911819f, 
    -0.03728383f, 0.01718795f, 0.03731874f, -0.00166683f, 0.02152876f, 0.00894054f, 0.01085093f, 0.04552960f, 
    0.01879111f, 0.04758863f, 0.04175615f, -0.03629047f, 0.01843283f, -0.05511005f, 0.04307962f, -0.01463335f, 
    -0.01629760f, -0.00760781f, 0.05482199f, -0.04062971f, 0.04903567f, 0.01694623f, 0.04098912f, -0.03856002f, 
    0.00543796f, 0.01107139f, 0.05805862f, -0.05210486f, -0.05418315f, 0.03863987f, -0.04090189f, -0.04966408f, 
    -0.00575566f, 0.00288735f, -0.00586970f, 0.00546595f, -0.03719977f, -0.01567284f, -0.01920171f, -0.00134908f, 
    -0.09574044f, -0.24053535f, -0.31389782f, -0.21057196f, -0.18976173f, 0.04904162f, -0.09852098f, -0.08224399f, 
    -0.02016749f, -0.01666042f, -0.13178362f, 0.01634436f, 0.01323815f, -0.06909402f, 0.01521872f, -0.09795731f, 
    -0.08063998f, -0.22159952f, -0.13532361f, -0.07469624f, -0.19095768f, 0.21145914f, -0.13134821f, -0.08209608f, 
    -0.03847296f, 0.02685926f, -0.08933421f, 0.01756720f, 0.00364877f, 0.00223298f, 0.05359320f, 0.06628668f, 
    -0.00932343f, 0.09635758f, -0.07357858f, -0.16402440f, -0.05230383f, 0.00352783f, -0.10507723f, -0.10333165f, 
    0.30338809f, 0.09070084f, -0.12726128f, 0.14331025f, -0.08293699f, -0.02251146f, 0.06732815f, 0.03932366f, 
    0.05619208f, -0.10213691f, 0.04887187f, 0.04271670f, -0.00584419f, -0.05837167f, -0.03534909f, -0.05965404f, 
    -0.07146711f, -0.07774917f, -0.04990450f, -0.12223808f, -0.08644177f, -0.32372192f, -0.35550395f, -0.20688172f, 
    -0.01082523f, -0.04638013f, 0.03456179f, -0.03016951f, -0.07984705f, -0.03221676f, -0.08756972f, 0.01541539f, 
    0.05360156f, -0.03142434f, -0.04889171f, -0.10787196f, 0.04886860f, -0.05366864f, 0.08901402f, 0.00769747f, 
    0.10137375f, 0.14661299f, 0.10215817f, 0.09201997f, 0.10059653f, 0.09813966f, 0.09190229f, 0.08626818f, 
    0.02510987f, 0.07162730f, 0.02555164f, -0.05273984f, 0.03719229f, 0.02113089f, -0.07556968f, 0.05483072f, 
    -0.00009227f, 0.05536141f, 0.00326248f, 0.02506273f, 0.03525535f, 0.14432211f, 0.07134710f, -0.08805830f, 
    -0.04244974f, 0.05846688f, -0.04655275f, 0.06603828f, -0.06812386f, 0.04774664f, -0.01054670f, 0.05023398f, 
    0.07224044f, 0.00363185f, -0.04123300f, -0.11236766f, -0.24513985f, -0.09968808f, -0.19216163f, -0.17536454f, 
    0.12463702f, 0.17483126f, 0.25843641f, 0.08797794f, 0.03862974f, 0.07994145f, 0.04537473f, 0.06433073f, 
    -0.00224105f, -0.00002766f, -0.05480509f, 0.02297339f, -0.01442916f, 0.02207039f, -0.03270773f, 0.12425121f, 
    -0.00177854f, -0.15393114f, -0.06086635f, 0.05838456f, -0.04691983f, -0.04331018f, -0.00303385f, 0.16315453f, 
    -0.16427693f, 0.06440276f, -0.02209265f, 0.00906034f, -0.06362689f, 0.01539444f, -0.01370638f, -0.07946786f, 
    0.10121659f, 0.06500117f, 0.09881794f, 0.04632182f, 0.11802675f, 0.00845798f, -0.09016446f, 0.30050594f, 
    0.38493511f, -0.09863506f, 0.02892333f, 0.10375237f, -0.14593232f, -0.09311165f, 0.03914034f, 0.05577067f, 
    -0.05394769f, 0.00562036f, 0.01125598f, -0.10972081f, -0.02134744f, 0.12041550f, 0.03873490f, -0.11531698f, 
    0.05774355f, 0.00452371f, -0.12809473f, -0.02572010f, 0.21417138f, 0.17447363f, 0.24730895f, -0.12470584f, 
    0.18302958f, -0.02801271f, 0.02726787f, 0.12901725f, -0.06037556f, -0.11208276f, 0.04856982f, 0.06415949f, 
    0.01983828f, 0.12244304f, 0.03906793f, 0.11711457f, 0.09766728f, -0.02419075f, 0.03046124f, 0.12991309f, 
    0.25192782f, 0.00242796f, -0.06923742f, 0.05422397f, -0.10227096f, 0.06504368f, -0.04070266f, 0.03460892f, 
    -0.01363062f, 0.03640712f, 0.00015023f, -0.03135668f, -0.01215449f, -0.10313552f, 0.02417738f, 0.07866937f, 
    -0.02422281f, -0.13532422f, -0.14647515f, 0.00982769f, -0.29096866f, -0.19385873f, -0.02198127f, -0.20681274f, 
    -0.06582163f, 0.07312326f, -0.00911167f, 0.02929977f, -0.22178030f, -0.10872948f, -0.01594726f, -0.02254941f, 
    0.01155096f, 0.04221822f, -0.06363161f, -0.08134517f, 0.02525678f, 0.01751509f, -0.04428774f, -0.13639234f, 
    -0.14095530f, 0.07008367f, -0.00233713f, -0.04911358f, -0.23933075f, -0.05495183f, 0.08551850f, -0.08041785f, 
    -0.03131189f, 0.01812452f, -0.00471343f, -0.02449251f, -0.03064551f, -0.00526063f, -0.02229978f, 0.00495893f, 
    -0.07601757f, -0.21138348f, -0.13937964f, -0.09415556f, -0.37468752f, -0.26117113f, -0.32741821f, -0.29935029f, 
    -0.32103398f, 0.11044268f, -0.09414872f, 0.06136926f, -0.12491624f, -0.04641513f, -0.02593891f, -0.04716886f, 
    -0.05642673f, -0.00109407f, -0.10906794f, -0.06353379f, 0.06397773f, -0.04596877f, -0.03325611f, -0.01713024f, 
    0.03589888f, 0.12831663f, 0.19996847f, -0.21916249f, 0.12303786f, -0.06905194f, 0.05294809f, 0.13557646f, 
    -0.14857747f, 0.09660985f, -0.00269208f, 0.05055581f, 0.08099186f, -0.08683389f, -0.04634957f, -0.12518856f, 
    -0.10209271f, 0.00881157f, -0.12629376f, -0.08909132f, -0.02236394f, 0.24562591f, 0.13324560f, 0.13212076f, 
    0.05743773f, 0.01938965f, -0.05078669f, 0.02911058f, -0.10939515f, 0.16921014f, -0.04803152f, -0.06670289f, 
    -0.09732072f, -0.05869516f, -0.01547011f, -0.10178035f, 0.13446619f, 0.00644463f, 0.02543188f, 0.10949931f, 
    -0.14949352f, -0.00554693f, 0.03662689f, 0.01857359f, 0.03523487f, -0.12593867f, -0.09449345f, -0.14751901f, 
    -0.08321123f, 0.01171371f, 0.00601621f, -0.07713177f, 0.16611768f, 0.04661069f, 0.03941159f, 0.02719449f, 
    -0.14797541f, -0.13941525f, -0.20283967f, -0.10241565f, 0.46258223f, 0.03398679f, 0.34734270f, -0.21635613f, 
    -0.07741757f, -0.02737360f, 0.07851876f, -0.24345721f, 0.13257840f, -0.01913923f, 0.12544185f, 0.03543734f, 
    -0.11193449f, -0.03548623f, 0.11800159f, 0.13754492f, -0.00702701f, -0.11605290f, 0.17181578f, 0.15306033f, 
    0.08213712f, -0.03992545f, 0.13053979f, -0.06386062f, 0.42149946f, 0.19184260f, -0.05279748f, -0.08231547f, 
    0.10771601f, 0.03634611f, 0.01120768f, 0.03070282f, 0.00591761f, -0.04757419f, 0.00761140f, -0.14470671f, 
    -0.20806758f, 0.05180565f, 0.11920004f, 0.18484716f, -0.22199889f, 0.08403063f, 0.13761263f, 0.04643911f, 
    0.00021184f, 0.00431161f, -0.05604708f, -0.08510844f, -0.04453283f, -0.14878345f, 0.10540126f, -0.06584768f, 
    -0.07674796f, 0.03716844f, 0.06047343f, 0.02605757f, 0.05698363f, 0.10684331f, 0.06184994f, 0.11080445f, 
    -0.05127472f, -0.14127836f, 0.03123405f, -0.05406580f, -0.05505504f, -0.06248102f, 0.08136616f, -0.07285763f, 
    0.00814757f, 0.14205235f, -0.00511680f, -0.13068692f, -0.02592908f, 0.07544691f, 0.00949784f, -0.01545202f, 
    0.17332971f, 0.03383979f, 0.00891315f, -0.02257363f, -0.02192692f, -0.12749626f, -0.13999067f, 0.02063035f, 
    -0.02599620f, -0.04756054f, -0.19310063f, -0.03920062f, -0.10221434f, -0.02736016f, 0.05610928f, -0.05804985f, 
    -0.09714475f, -0.11259807f, -0.11570502f, 0.05448550f, -0.03717581f, -0.19820741f, -0.11223199f, 0.02945651f, 
    0.07044534f, -0.27361119f, 0.17245620f, 0.01564160f, -0.02641514f, 0.14816390f, 0.05151052f, 0.04185350f, 
    -0.01342675f, -0.02867136f, 0.00082543f, 0.01743306f, 0.01476971f, -0.07662808f, -0.03385833f, -0.13461655f, 
    0.01339881f, 0.03210184f, 0.07987230f, 0.07028688f, 0.65854901f, 0.25367519f, 0.08822464f, 0.02774067f, 
    -0.25111565f, -0.22350493f, 0.04114824f, 0.00669225f, -0.02613797f, -0.00853406f, -0.06561093f, -0.05031696f, 
    0.22060284f, 0.01574309f, -0.01524939f, -0.10165556f, 0.08830000f, -0.08840806f, 0.15640731f, 0.23186693f, 
    -0.52048492f, -0.21660152f, 0.36667287f, -0.26168123f, 0.36531410f, 0.06847499f, 0.03454502f, 0.06736965f, 
    0.07934624f, 0.00253365f, 0.01718918f, -0.01090771f, 0.05333259f, 0.02634001f, 0.02359259f, 0.05357532f, 
    -0.10177676f, 0.10626173f, 0.14124702f, 0.12964943f, -0.27388406f, -0.11452538f, 0.03816853f, -0.27944264f, 
    -0.02643169f, -0.03995038f, 0.11612340f, -0.22269836f, 0.03870154f, -0.03778735f, -0.08507486f, 0.02604564f, 
    -0.05535104f, 0.15353908f, 0.06997455f, -0.08941460f, 0.12289502f, 0.20245469f, 0.05543334f, 0.05022379f, 
    0.24101128f, 0.43804118f, -0.28446472f, -0.06262029f, 0.14414902f, -0.02012785f, 0.02282551f, 0.03356869f, 
    0.14566901f, -0.02724747f, -0.04302906f, 0.09292291f, 0.13127758f, 0.07360379f, 0.00926976f, -0.25247052f, 
    -0.19021772f, 0.17336559f, -0.03073674f, 0.02664324f, -0.51121348f, -0.05812173f, -0.45034054f, 0.39577082f, 
    0.02781140f, 0.12878217f, -0.12514052f, 0.09017446f, 0.11907782f, -0.01684399f, 0.02489184f, 0.11879220f, 
    -0.06257352f, -0.07137464f, 0.15967616f, -0.04583049f, -0.01287816f, 0.00865196f, 0.01372126f, -0.03857983f, 
    -0.31969154f, -0.05235559f, -0.21975142f, 0.08456226f, -0.07152823f, 0.25405449f, 0.05729135f, 0.05329409f, 
    -0.05290442f, -0.08516892f, 0.06824093f, -0.05530982f, 0.09506651f, -0.09114093f, -0.02985260f, 0.07611911f, 
    0.02646549f, 0.02723116f, -0.11052094f, -0.09964516f, -0.16038486f, 0.17267466f, -0.03082165f, 0.06130404f, 
    0.21543877f, 0.04957818f, -0.08322218f, 0.12922406f, -0.15284957f, -0.06447403f, 0.11419545f, -0.04413506f, 
    0.13936581f, -0.10539006f, -0.00917895f, 0.15077145f, -0.12179291f, 0.15589970f, -0.04995126f, -0.20013575f, 
    -0.00001641f, -0.24977008f, 0.38211319f, -0.04863602f, 0.25058305f, 0.18796368f, 0.04588982f, 0.18297395f, 
    -0.03938185f, -0.02115073f, 0.08978719f, 0.13760863f, -0.16137223f, -0.18981060f, 0.03736043f, 0.05183556f, 
    -0.02296430f, -0.03117493f, 0.02015605f, 0.10227830f, 0.28949571f, -0.14696661f, 0.19089364f, 0.09883370f, 
    0.28498113f, -0.05317216f, 0.13538466f, 0.09950752f, 0.12817948f, 0.11203323f, 0.05035050f, -0.04699049f, 
    0.00335371f, -0.13844885f, -0.05683054f, -0.04011723f, 0.09686520f, 0.15270998f, -0.00004836f, 0.04235580f, 
    -0.04239998f, -0.26333991f, -0.38446328f, -0.17018782f, -0.00974569f, -0.08129490f, 0.07881895f, -0.08599805f, 
    -0.02896670f, 0.03329141f, -0.00084638f, 0.00946533f, 0.21559449f, 0.05289574f, 0.00099803f, 0.05360064f, 
    0.01885904f, -0.08089180f, 0.04610572f, -0.03728601f, 0.03050536f, 0.05139875f, 0.09771893f, 0.18472470f, 
    -0.20760165f, 0.10964648f, -0.07049014f, -0.07870002f, 0.06284069f, 0.13631195f, 0.05435473f, -0.08246709f, 
    -0.09375793f, 0.01135150f, 0.14590415f, 0.09746884f, -0.06877264f, -0.21881704f, 0.06396583f, 0.08161478f, 
    0.07637757f, 0.31008279f, 0.29621363f, 0.29180807f, 0.10802975f, -0.01464342f, 0.12523244f, 0.04416414f, 
    0.02023046f, 0.14041929f, -0.05644728f, -0.06452966f, -0.17303658f, 0.01072589f, -0.01659023f, 0.02171739f, 
    -0.02122918f, -0.05695001f, -0.04423176f, 0.01749973f, -0.06721140f, -0.32390934f, -0.22374189f, -0.16083220f, 
    -0.03697050f, -0.06068539f, 0.00431430f, -0.09048266f, 0.00073181f, -0.00367810f, -0.05671006f, 0.03254005f, 
    0.04706437f, -0.04426492f, 0.06839702f, 0.11252356f, 0.10437696f, 0.16868003f, 0.10833387f, 0.07336068f, 
    -0.18406215f, 0.01576297f, 0.26948982f, 0.17605862f, -0.11369552f, -0.09582322f, -0.01030016f, 0.15213607f, 
    0.03640451f, -0.07423032f, 0.00868954f, 0.05119172f, 0.00597774f, 0.02797060f, 0.03355514f, 0.14948396f, 
    0.16461624f, 0.04362016f, -0.05538296f, -0.01755837f, 0.11755974f, -0.00535212f, -0.06544645f, -0.02653155f, 
    0.05394421f, -0.05698310f, -0.06970608f, -0.02540294f, 0.01093668f, -0.00372993f, 0.09097975f, -0.00397862f, 
    0.06913573f, 0.03804819f, 0.03004597f, 0.11891240f, -0.06605519f, -0.00663910f, -0.16667180f, -0.02009862f, 
    0.25287092f, 0.07979704f, 0.45036957f, 0.33124298f, -0.01292563f, 0.09270620f, -0.07250656f, 0.06746683f, 
    0.01211459f, -0.03608746f, 0.06813128f, 0.03036398f, -0.00542150f, -0.08040715f, -0.12169814f, 0.00840951f, 
    -0.07615963f, -0.11153091f, -0.02574088f, 0.02129345f, 0.04437402f, -0.02931718f, 0.00008685f, -0.01988286f, 
    0.10905877f, 0.02255449f, -0.05931816f, -0.14009732f, 0.05298907f, -0.00876646f, -0.08201764f, 0.04414774f, 
    -0.11315861f, -0.06543291f, -0.10890617f, -0.17146799f, 0.04877584f, -0.00062728f, 0.15704843f, 0.14009503f, 
    -0.23972780f, 0.05537277f, 0.00846816f, -0.06596656f, 0.00740382f, -0.03899453f, 0.18221124f, -0.04689598f, 
    -0.03648478f, -0.09712429f, -0.02493384f, -0.17238878f, -0.05857302f, 0.01972233f, 0.02653364f, -0.03475304f, 
    -0.02383336f, 0.00080187f, 0.04904761f, 0.03253582f, -0.25454217f, -0.25003386f, 0.04622184f, 0.22028354f, 
    -0.12041781f, -0.11334679f, 0.00483385f, 0.10331312f, -0.30199102f, -0.09951554f, -0.01292992f, -0.08118598f, 
    -0.10533695f, -0.05937107f, 0.06748097f, 0.07138135f, 0.06299008f, -0.05515284f, -0.15724286f, 0.19940943f, 
    -0.22699119f, 0.47674945f, 0.02817161f, 0.25321260f, 0.23721753f, 0.14060378f, 0.06130070f, 0.07667673f, 
    0.20163311f, 0.10021609f, 0.00082746f, 0.03107890f, 0.08005656f, 0.04075316f, -0.04140919f, -0.08350486f, 
    -0.07704308f, 0.14255680f, -0.01955183f, -0.07412756f, -0.12144314f, -0.31932360f, -0.06736669f, 0.09776621f, 
    0.08745797f, -0.02194233f, 0.25061589f, -0.07403554f, 0.09925650f, 0.23098159f, -0.01171796f, 0.09264215f, 
    0.08403680f, 0.04227484f, 0.13150200f, -0.04523601f, -0.11347485f, 0.06376112f, -0.13861690f, 0.20277753f, 
    -0.33311665f, 0.13780256f, -0.14091174f, 0.02254633f, 0.04234967f, 0.19014348f, -0.01511370f, 0.17502998f, 
    0.00393845f, -0.02856133f, 0.00971238f, 0.00142153f, 0.04593275f, 0.11445519f, 0.06369562f, 0.06508471f, 
    0.04849502f, 0.06747305f, 0.06667408f, 0.06724090f, 0.15539747f, -0.17988460f, -0.51434302f, -0.07535201f, 
    -0.00028338f, 0.12866463f, 0.18001170f, -0.04944908f, -0.12188642f, 0.15859470f, 0.02236277f, -0.06467700f, 
    0.06818603f, -0.00091725f, -0.04602199f, 0.06825783f, 0.04437786f, 0.11396324f, 0.04279957f, 0.06293801f, 
    0.29775468f, 0.20791842f, 0.55494040f, 0.07262032f, 0.22064324f, 0.06960001f, 0.03688920f, -0.01504216f, 
    0.17333464f, 0.07380374f, -0.04300877f, -0.03084241f, 0.06739699f, -0.01886435f, -0.05419530f, 0.03021580f, 
    -0.09781384f, -0.12126438f, 0.04126931f, 0.15861689f, 0.00013167f, 0.17852250f, 0.25386563f, 0.15342422f, 
    0.05606162f, 0.02510541f, 0.06792640f, 0.17945129f, 0.19059038f, 0.10240221f, 0.08508684f, 0.04334841f, 
    0.07680544f, -0.03272896f, -0.09892342f, 0.19945376f, 0.22689727f, 0.03048646f, -0.07775758f, 0.03401209f, 
    0.01222314f, -0.02909679f, -0.01143865f, 0.00184422f, 0.04251918f, -0.05691612f, 0.03875494f, -0.00836087f, 
    -0.05690777f, -0.02587417f, 0.03181824f, -0.04812458f, -0.04897103f, -0.05296518f, 0.02357796f, 0.03874352f, 
    0.04081263f, -0.01337395f, 0.01918071f, 0.03387615f, 0.03691875f, -0.02225271f, 0.00167786f, 0.01206100f, 
    -0.03834707f, -0.00992723f, -0.04323278f, -0.02628355f, 0.01137337f, -0.01139074f, 0.04091552f, 0.03152871f, 
    -0.05028647f, -0.00974821f, -0.00359998f, -0.03529684f, -0.04541485f, -0.05992243f, 0.04069073f, 0.04100199f, 
    0.01809822f, -0.06014309f, 0.00249537f, -0.04959121f, -0.03322228f, -0.01803474f, 0.04092152f, 0.03249219f, 
    0.05488080f, -0.02675667f, 0.04446815f, 0.03962192f, -0.00790787f, -0.02856075f, -0.01189382f, -0.00975377f, 
    0.01253504f, -0.01743743f, -0.01950063f, 0.00723379f, 0.01418702f, 0.04081257f, 0.01357393f, 0.00424442f, 
    -0.01306086f, 0.00340603f, -0.04266232f, -0.04062072f, -0.02477399f, 0.04475653f, -0.00028831f, 0.02852312f, 
    -0.00289406f, -0.01426220f, -0.03618659f, -0.00095590f, 0.00446844f, -0.00345682f, 0.00349666f, -0.01229507f, 
    -0.01274068f, -0.00312443f, -0.01777756f, 0.02089473f, 0.02274325f, -0.00514617f, 0.00162824f, 0.04852824f, 
    0.04411422f, 0.00915617f, 0.03539612f, 0.01189553f, -0.02136823f, 0.01120327f, 0.01968745f, 0.04234141f, 
    0.04061467f, 0.03623300f, -0.01454777f, 0.00839254f, -0.04651499f, -0.06065487f, 0.05435646f, -0.02711293f, 
    0.01354765f, -0.05255100f, 0.02203291f, 0.03009859f, -0.03248090f, -0.03619070f, -0.03937142f, -0.00902753f, 
    0.01523146f, -0.04982306f, 0.02068747f, 0.01597702f, 0.03919386f, -0.05338936f, -0.05690942f, -0.05342114f, 
    -0.00112338f, -0.04202870f, -0.04051812f, -0.01569975f, 0.04083297f, 0.03783848f, 0.01651982f, 0.01005913f, 
    -0.05252601f, -0.04744903f, -0.01763911f, -0.00342198f, -0.02061421f, -0.02760767f, 0.00201648f, -0.00797390f, 
    -0.01290509f, -0.03376259f, 0.01384358f, -0.00128463f, 0.01090297f, -0.03390807f, -0.03155816f, 0.00482580f, 
    -0.05592134f, 0.04000129f, -0.05140646f, 0.03807791f, -0.02886675f, 0.02842520f, -0.02698211f, 0.04979293f, 
    0.03128111f, -0.03605266f, 0.01589207f, -0.02810279f, 0.01209899f, 0.00301969f, -0.00821496f, 0.04713700f, 
    -0.05187119f, 0.00101899f, 0.00725806f, -0.00152515f, -0.00750203f, 0.03092079f, -0.02300047f, 0.01504763f, 
    -0.05289428f, -0.02873703f, -0.04501644f, 0.00368311f, -0.05520778f, 0.00588240f, 0.00184378f, -0.05619632f, 
    -0.05158890f, -0.04018839f, -0.01427614f, -0.03809691f, -0.05767867f, -0.03126001f, -0.00037709f, -0.04689354f, 
    -0.01595373f, 0.04084629f, 0.03276457f, -0.06051686f, -0.05677182f, -0.04578003f, 0.01979425f, -0.01647560f, 
    -0.03047924f, -0.05942721f, -0.01536052f, 0.02986524f, -0.02237409f, -0.04141637f, 0.02616842f, 0.00713867f, 
    0.00999429f, -0.03096979f, -0.03806399f, 0.03534586f, 0.01154080f, -0.01452792f, -0.05358484f, 0.01623313f, 
    -0.05940915f, 0.04757185f, -0.02645221f, -0.05452737f, 0.04699516f, -0.04660456f, 0.01971593f, -0.04831889f, 
    -0.04096728f, -0.02189232f, 0.00093261f, -0.05720126f, -0.03828600f, -0.03744698f, -0.02873889f, -0.05588466f, 
    -0.04871658f, 0.01221479f, -0.01080146f, -0.02623089f, -0.01855008f, -0.02439630f, -0.05377378f, 0.03203347f, 
    -0.02337120f, -0.03047955f, 0.03995863f, -0.04962493f, -0.05484905f, -0.03340990f, 0.02299381f, 0.04105651f, 
    0.01877980f, -0.04366520f, -0.03597335f, -0.05175395f, -0.00816441f, -0.02120332f, 0.00224763f, 0.04067130f, 
    -0.02078155f, 0.02428073f, 0.00582257f, -0.04016577f, -0.02422187f, 0.00858414f, -0.01786459f, 0.00870283f, 
    -0.03105922f, 0.03490069f, 0.00436802f, 0.03812088f, 0.04977639f, 0.03233271f, -0.05638959f, -0.02454594f, 
    0.03579431f, 0.04918149f, -0.03172973f, 0.02021209f, -0.03623805f, 0.00178896f, -0.04249828f, -0.01867573f, 
    -0.01376346f, -0.00828123f, -0.00116430f, 0.04133328f, -0.01452179f, 0.04208860f, -0.05275834f, 0.02336535f, 
    -0.03508591f, -0.04255684f, -0.03735403f, -0.03712264f, -0.04659903f, -0.03596129f, -0.05100211f, -0.04638719f, 
    0.00995010f, 0.03533418f, 0.03060025f, 0.02163410f, -0.01519704f, -0.05687580f, 0.04376304f, -0.00493824f, 
    -0.03777771f, 0.00317393f, 0.04256677f, 0.00041142f, -0.03804289f, 0.03403033f, -0.04317810f, -0.02118537f, 
    0.01765191f, -0.02295197f, -0.05122953f, 0.02815331f, -0.02922841f, 0.03699610f, 0.01566820f, 0.01046910f, 
    0.02955676f, -0.04373320f, 0.02521600f, 0.01955614f, -0.05093046f, 0.01036768f, 0.01202024f, 0.03426756f, 
    0.05034268f, 0.03508224f, 0.11141782f, -0.08921183f, 0.07422339f, 0.08587530f, -0.28103694f, -0.10674313f, 
    -0.03401076f, -0.10247659f, -0.07335896f, 0.03557416f, 0.07734092f, -0.07414044f, -0.06039673f, 0.01415974f, 
    -0.14553128f, -0.25361070f, -0.13493545f, -0.16727723f, 0.42918903f, 0.22451109f, -0.03101350f, -0.14260876f, 
    0.12885936f, 0.01867832f, 0.28052682f, -0.11593471f, 0.11716872f, 0.03279355f, 0.00472915f, 0.03959308f, 
    -0.05733703f, -0.02640604f, -0.01792083f, 0.04242467f, -0.00500012f, -0.00617417f, 0.11928157f, 0.05784081f, 
    0.49307072f, -0.12239327f, 0.65996313f, 0.03517583f, 0.41755798f, -0.03685863f, -0.13973749f, -0.10549701f, 
    0.17357348f, -0.33760810f, 0.09679358f, 0.06414706f, 0.02638417f, 0.06541550f, 0.07284050f, -0.15377979f, 
    -0.17819022f, -0.00123447f, 0.01878211f, -0.00442398f, -0.09143087f, 0.10396729f, 0.12149761f, 0.00719332f, 
    0.06100120f, -0.01485567f, -0.01931757f, -0.02806885f, -0.21574384f, -0.15633400f, 0.01039995f, -0.00053786f, 
    0.00677568f, 0.06063994f, 0.00666283f, -0.00981098f, 0.11937229f, 0.13188207f, 0.03348729f, 0.12736192f, 
    -0.17309178f, -0.30233502f, -0.13351014f, 0.01112725f, -0.12326100f, -0.00993035f, 0.14232302f, 0.01066443f, 
    0.03456965f, 0.15410818f, -0.05131499f, -0.01299680f, 0.01693609f, 0.04774913f, -0.09381495f, -0.01232955f, 
    0.00830793f, 0.08693127f, 0.06129601f, 0.22355439f, 0.00624397f, -0.16443057f, 0.03117551f, -0.04383386f, 
    -0.00231158f, -0.10322185f, -0.18450424f, -0.12031004f, -0.02810423f, 0.11018819f, 0.04266114f, -0.05790428f, 
    -0.06958656f, -0.00336785f, -0.16566275f, -0.14288123f, -0.20255898f, -0.23961325f, -0.14042625f, -0.21362871f, 
    -0.25587171f, 0.00986373f, 0.08638316f, -0.07245003f, -0.00077800f, 0.00839809f, 0.05070706f, 0.09849101f, 
    0.01456199f, 0.00133192f, -0.00287163f, -0.02300985f, 0.03437500f, -0.00601519f, -0.04603242f, 0.04858106f, 
    0.11835153f, -0.05754346f, 0.12387430f, 0.08098769f, 0.46752137f, 0.05924705f, 0.04108224f, 0.17667958f, 
    -0.11790713f, -0.04198610f, -0.12905265f, 0.04065785f, -0.15820864f, -0.07851463f, 0.09854685f, -0.05084927f, 
    0.17378820f, -0.07878672f, 0.07575452f, 0.13155943f, 0.25112447f, 0.01581916f, 0.06114854f, 0.31358367f, 
    -0.12438723f, -0.16715424f, 0.41598493f, -0.17182176f, -0.10237671f, -0.05522849f, -0.08316708f, 0.09654949f, 
    -0.03840301f, -0.05551907f, 0.09552432f, 0.07356224f, 0.15527652f, -0.02067150f, 0.07149629f, 0.05430496f, 
    0.04715283f, 0.04701905f, 0.06299044f, 0.16197030f, -0.15345266f, -0.04057622f, 0.19337209f, -0.19087656f, 
    0.20215668f, -0.00872786f, 0.08703128f, -0.22294863f, 0.24346979f, -0.04408415f, 0.00607425f, 0.10067011f, 
    0.08468573f, -0.09106211f, -0.05624842f, -0.01320832f, 0.17255834f, 0.12225355f, 0.04193651f, 0.17774777f, 
    0.38653749f, 0.02382400f, 0.48049417f, 0.05600590f, 0.23074792f, -0.07323606f, -0.16597228f, -0.03845996f, 
    0.02293559f, -0.03196391f, 0.07236216f, 0.00710416f, 0.08163439f, 0.07067395f, 0.23767066f, 0.04354196f, 
    0.01430324f, 0.02953055f, 0.09081469f, 0.05965611f, -0.48938298f, 0.06589392f, -0.49259597f, 0.20164359f, 
    0.12175219f, 0.02278311f, -0.11707105f, 0.21112980f, -0.17989923f, -0.05825736f, 0.04505361f, -0.04860793f, 
    -0.19308856f, -0.12010431f, -0.00551762f, 0.03058540f, 0.06994136f, 0.03223477f, -0.14235485f, -0.07383474f, 
    -0.25190634f, -0.25135988f, 0.02963411f, -0.08412401f, 0.13124913f, 0.03127765f, 0.06909196f, 0.09852561f, 
    0.09247214f, 0.13118201f, 0.19145894f, -0.14554612f, -0.07465870f, -0.05792014f, -0.17876774f, -0.04169491f, 
    -0.01659065f, -0.25428897f, -0.10542536f, -0.16011313f, -0.35909146f, 0.13932995f, 0.14736763f, -0.12243175f, 
    0.04693326f, 0.00099466f, -0.07680502f, 0.15326838f, -0.07157567f, -0.02210880f, 0.07591505f, -0.12245683f, 
    0.03962323f, -0.07206582f, -0.03329694f, 0.15050505f, -0.00257959f, 0.06354582f, -0.14081173f, -0.04778762f, 
    -0.11435319f, -0.07528080f, 0.16163637f, -0.05603258f, -0.08888206f, 0.04229228f, 0.26163462f, 0.14450100f, 
    -0.12120917f, -0.05406915f, 0.11769082f, 0.05305500f, -0.04362911f, -0.00730764f, -0.09132650f, 0.00054369f, 
    0.03108450f, 0.04224937f, -0.09568912f, -0.03287802f, -0.13449141f, -0.31593460f, 0.01298319f, 0.14959173f, 
    0.05054481f, 0.01619177f, 0.18238533f, 0.09595935f, 0.07645505f, 0.05099068f, -0.03333844f, -0.09018265f, 
    -0.08754539f, -0.00252200f, 0.04556854f, 0.05500391f, 0.11925060f, 0.10119782f, 0.14035591f, 0.24001703f, 
    -0.06316581f, -0.04041664f, -0.00410389f, 0.04087463f, -0.01352790f, -0.02339762f, -0.05789058f, -0.01343421f, 
    -0.00768409f, -0.01636524f, -0.04679875f, 0.00760646f, -0.00599465f, 0.01641558f, 0.04123100f, -0.00714951f, 
    -0.02708679f, -0.00386795f, -0.02012536f, -0.05471715f, 0.03416139f, -0.03378133f, 0.02030406f, 0.02832588f, 
    0.04036446f, 0.04922391f, 0.04358631f, -0.03729632f, -0.02724689f, -0.01982886f, 0.01081142f, 0.00457848f, 
    -0.00043145f, -0.01160499f, -0.03345887f, -0.04010292f, -0.02496559f, 0.04474286f, 0.02499859f, -0.02794152f, 
    -0.02350515f, -0.04979629f, -0.01969033f, 0.03868944f, 0.03060072f, -0.05042660f, -0.05940194f, 0.04824015f, 
    0.02739469f, 0.03322794f, -0.01455645f, -0.02099163f, -0.01333468f, -0.02414838f, -0.03687786f, -0.05433520f, 
    -0.04577996f, -0.00999609f, 0.00160451f, 0.04505506f, -0.05207056f, -0.04373467f, -0.05250535f, 0.02923869f, 
    -0.03825419f, -0.01365422f, -0.01918163f, -0.05357712f, -0.02461332f, 0.01422879f, 0.00850315f, -0.05305795f, 
    0.02225333f, 0.05250352f, -0.05041623f, -0.04876775f, 0.00020284f, 0.00195962f, -0.00193958f, 0.03767225f, 
    0.00223155f, 0.00199548f, 0.00620762f, 0.03006422f, 0.03835154f, -0.04654600f, -0.00252503f, 0.01573659f, 
    -0.04440249f, 0.00361723f, 0.01859110f, 0.01928473f, -0.00440569f, -0.03646615f, 0.04474493f, -0.01654721f, 
    -0.05326840f, 0.00273390f, -0.01816152f, -0.01599982f, -0.03954644f, -0.05726606f, 0.02697351f, -0.03099136f, 
    0.02572267f, -0.00350858f, -0.04768161f, -0.01679846f, 0.01341287f, 0.02697091f, 0.03234098f, 0.00535414f, 
    0.02562134f, 0.00406319f, -0.03041744f, 0.01060596f, -0.01636097f, 0.05138015f, -0.03208441f, -0.04836630f, 
    0.00893320f, 0.02631463f, -0.02616324f, -0.00529050f, -0.04479446f, 0.03181480f, -0.00811926f, -0.01668275f, 
    0.04512858f, -0.04631148f, -0.02195271f, -0.05516129f, 0.04901210f, 0.03600860f, -0.02682148f, 0.03330600f, 
    0.01983288f, -0.01701698f, 0.04098493f, -0.00843095f, -0.02280520f, -0.03569209f, 0.03617820f, -0.03221812f, 
    0.02138738f, -0.04322601f, 0.02841925f, 0.01264327f, 0.00349089f, -0.03086991f, -0.06280008f, -0.04459930f, 
    -0.00250143f, -0.05392244f, 0.04357278f, -0.04645588f, 0.02342002f, -0.05143601f, -0.00617978f, 0.03397620f, 
    -0.00894704f, 0.02425975f, -0.04422501f, 0.02882929f, -0.02809106f, -0.02476195f, -0.04999384f, 0.03092237f, 
    -0.05413451f, 0.04494452f, -0.02238164f, 0.04825455f, -0.04178936f, 0.03713476f, 0.03153761f, -0.01156115f, 
    0.01032081f, 0.00918595f, -0.04321642f, -0.04381626f, -0.04209903f, -0.05979054f, 0.00699272f, 0.00183718f, 
    -0.02477731f, -0.03038553f, -0.03167811f, 0.04269057f, 0.03172723f, -0.00821774f, -0.03961224f, -0.02905132f, 
    -0.03081266f, 0.02661172f, 0.01549620f, 0.01244926f, 0.00026558f, -0.04495399f, 0.00179844f, -0.02650686f, 
    -0.04526589f, -0.02089594f, -0.04652008f, 0.00774820f, 0.00413174f, 0.02135037f, -0.01713674f, -0.05126284f, 
    0.02637778f, -0.05793197f, 0.04347030f, -0.01991631f, 0.03171071f, -0.00097927f, 0.03019279f, -0.03094419f, 
    -0.04168995f, 0.04140723f, 0.00683451f, 0.01527328f, 0.00913093f, -0.00659982f, 0.03788115f, -0.01341088f, 
    -0.02325111f, -0.00766077f, -0.03460112f, -0.01598308f, -0.02502008f, -0.05255802f, -0.00926889f, -0.04845861f, 
    0.00987214f, -0.01833453f, 0.03730707f, 0.02939785f, -0.03379805f, -0.00485634f, -0.04172239f, -0.00440051f, 
    -0.02797509f, -0.00192607f, -0.04841942f, -0.02406101f, 0.03585741f, 0.00866934f, -0.05685444f, -0.05852559f, 
    -0.04962748f, 0.03565146f, -0.03745323f, -0.04867425f, -0.04813940f, -0.05575489f, 0.01886953f, -0.05666740f, 
    0.00016086f, -0.02826540f, -0.04791802f, 0.05115332f, -0.02515335f, 0.02014473f, -0.02108511f, 0.04276264f, 
    -0.05748231f, 0.01291944f, 0.03715416f, 0.04891585f, -0.04482263f, -0.05703439f, 0.01937617f, -0.01258186f, 
    -0.05067934f, 0.02645821f, 0.05275606f, -0.01143626f, -0.03700085f, 0.00406258f, 0.03807312f, 0.03175466f, 
    -0.03528876f, -0.00592051f, -0.03616560f, 0.04302929f, 0.03598374f, 0.04655982f, 0.01414820f, -0.02800739f, 
    0.01890096f, -0.02475058f, 0.00972163f, 0.03378933f, -0.02615391f, -0.05859815f, 0.02782537f, -0.00335060f, 
    -0.04589822f, -0.02831415f, 0.03112543f, 0.01611701f, -0.03257857f, -0.03895159f, 0.03053737f, -0.02840850f, 
    0.00678957f, 0.02103292f, -0.01963349f, -0.01273139f, -0.00112954f, -0.00730890f, -0.04928650f, 0.00462122f, 
    -0.00468051f, -0.05695375f, 0.01965290f, -0.04853429f, -0.05500933f, 0.00430035f, -0.03848026f, 0.04428533f, 
    -0.08557861f, 0.00050980f, 0.09354629f, 0.03128067f, -0.19237171f, -0.00517583f, 0.00453272f, 0.03810611f, 
    0.05263909f, 0.00002396f, -0.03401845f, -0.02774917f, -0.05764985f, -0.01446519f, 0.14276889f, -0.00024597f, 
    0.18149351f, 0.04363257f, -0.02155876f, 0.04208195f, 0.19617289f, 0.03548046f, 0.17235476f, 0.06950205f, 
    0.12085933f, 0.04959467f, -0.15983409f, 0.14636952f, -0.01880413f, -0.01762739f, -0.16428269f, -0.06431683f, 
    -0.02078728f, 0.06422235f, 0.09084839f, 0.03454922f, -0.02455177f, -0.09923813f, 0.02308947f, 0.05399764f, 
    -0.08135413f, -0.21309985f, -0.09734732f, -0.06196577f, 0.18331100f, -0.10507948f, 0.04570216f, 0.11294410f, 
    0.20467520f, 0.19468206f, -0.00629407f, 0.01213465f, -0.12091837f, -0.19605915f, -0.06417660f, 0.03575594f, 
    -0.05268735f, -0.06972072f, 0.00269343f, 0.03399740f, -0.06983966f, -0.02475321f, 0.19399032f, 0.14774287f, 
    -0.20312662f, -0.03877366f, -0.04794395f, -0.07146737f, 0.00121987f, -0.00387123f, -0.02038601f, 0.05883011f, 
    0.02905459f, 0.09312342f, 0.06628783f, 0.15674534f, 0.02294752f, -0.03231095f, -0.13037191f, -0.08086736f, 
    -0.17248867f, -0.10101803f, -0.29052776f, 0.05191479f, 0.00727082f, -0.18988758f, -0.01296284f, 0.03461673f, 
    -0.06172521f, -0.09124576f, 0.09040558f, 0.04881478f, 0.07527925f, 0.05152139f, 0.03244559f, 0.22334012f, 
    0.00034243f, 0.00830860f, 0.01978542f, 0.02864569f, -0.08124039f, -0.05807298f, -0.01815391f, 0.08591081f, 
    -0.04612248f, -0.01784400f, 0.01453259f, 0.03010511f, 0.00735338f, 0.03596555f, 0.12341913f, 0.10422977f, 
    -0.07011598f, -0.08442970f, -0.04241302f, -0.02201063f, 0.04066177f, 0.03796699f, 0.10784955f, 0.05848037f, 
    -0.03797423f, -0.02111417f, -0.24059990f, 0.04148701f, 0.31371990f, -0.05592762f, -0.04339690f, -0.13964249f, 
    -0.01765212f, -0.07249469f, 0.05532065f, -0.07351695f, -0.01738553f, -0.04728443f, 0.04696470f, 0.07364218f, 
    0.10505845f, 0.06069639f, 0.04753110f, 0.02359607f, 0.24968681f, -0.26815054f, -0.02364992f, -0.10133118f, 
    -0.08764401f, 0.01407825f, 0.04862576f, 0.03573879f, 0.01841433f, -0.12024951f, 0.04306124f, 0.01723942f, 
    -0.02780937f, 0.15444466f, 0.10637385f, -0.05671865f, -0.07598538f, -0.08596185f, -0.09792420f, -0.21299589f, 
    -0.13497791f, 0.22199860f, -0.27592954f, 0.39021829f, 0.17263582f, 0.00154358f, -0.02501315f, -0.06069204f, 
    -0.01446349f, 0.01701727f, -0.05296684f, -0.00152179f, -0.12632452f, 0.13723592f, 0.03766876f, -0.05239295f, 
    0.01203308f, -0.19230977f, 0.06212367f, -0.14815019f, -0.22284268f, 0.09249452f, -0.28094664f, 0.22076593f, 
    0.10751560f, 0.04562517f, -0.01948039f, 0.15893389f, -0.02968717f, -0.11280375f, -0.02768786f, 0.05401738f, 
    0.03224424f, 0.04420036f, 0.02671110f, 0.12639621f, -0.01460096f, 0.05129332f, 0.09582215f, 0.07738055f, 
    0.22889510f, -0.47241208f, -0.00115476f, -0.26939130f, -0.03201614f, -0.07177309f, 0.03497153f, 0.08181076f, 
    0.14216812f, -0.01146020f, -0.03434609f, 0.06958090f, -0.05924534f, -0.11948684f, -0.07476706f, -0.06784225f, 
    -0.08625391f, -0.03882204f, -0.01977470f, -0.05241146f, 0.09083059f, -0.15919358f, 0.32834890f, 0.12911466f, 
    0.04329929f, -0.10430389f, 0.05459414f, -0.09170042f, 0.12426402f, -0.09503430f, -0.13565384f, -0.09002927f, 
    0.04582777f, 0.01657967f, -0.02625567f, 0.02479849f, -0.03273597f, -0.08706589f, 0.11200042f, -0.06781016f, 
    0.03511073f, -0.02532095f, 0.18282928f, 0.11825769f, -0.03607153f, -0.13025095f, -0.08972218f, -0.12622064f, 
    -0.01179333f, -0.13177158f, -0.06541789f, -0.04869419f, -0.00874055f, 0.01719010f, 0.10716675f, -0.04290455f, 
    0.03072787f, 0.02432868f, 0.02304937f, 0.09333073f, -0.09181476f, -0.11908066f, 0.27972251f, 0.28241330f, 
    0.09924707f, -0.01206991f, 0.02808912f, -0.03871215f, 0.05844724f, -0.01740948f, -0.07646643f, -0.01903616f, 
    0.04836692f, 0.09926526f, 0.01809684f, 0.02394171f, -0.02039546f, 0.12752317f, -0.00209116f, -0.03256524f, 
    -0.05207690f, -0.00175229f, -0.09304116f, 0.30891556f, -0.04246240f, 0.09221099f, -0.03622381f, -0.02258189f, 
    0.32154733f, 0.01395173f, -0.07714953f, 0.09394325f, 0.01722400f, 0.09536559f, 0.03407276f, 0.07213191f, 
    0.03105846f, 0.03372866f, 0.17923607f, 0.05328022f, -0.04259183f, -0.13439532f, -0.06597434f, -0.04097457f, 
    0.04923815f, 0.03035105f, -0.00318825f, 0.02637793f, 0.04739620f, 0.05541048f, 0.09924963f, 0.09382846f, 
    0.03079619f, 0.07562216f, 0.01415496f, 0.15440081f, -0.06808240f, -0.02470828f, 0.00057156f, -0.03255821f, 
    0.01461056f, 0.01187760f, -0.00708493f, -0.02602881f, -0.04456567f, -0.04256593f, 0.02495094f, 0.01538632f, 
    0.02958195f, -0.05884088f, -0.05613459f, -0.03057093f, 0.02831539f, -0.02601167f, 0.00404654f, 0.03343108f, 
    0.02869102f, -0.02341255f, -0.01562452f, -0.03193237f, -0.05990032f, -0.02162438f, 0.02058538f, -0.05777773f, 
    0.01865057f, -0.05490888f, 0.04640805f, -0.01365995f, 0.04986097f, -0.05759259f, -0.03365391f, -0.03045445f, 
    -0.05837591f, -0.01092551f, -0.02624311f, 0.01231117f, 0.01395473f, -0.00705707f, -0.05731643f, 0.03068849f, 
    -0.01162753f, -0.01678697f, 0.02144397f, -0.04254525f, 0.04059874f, -0.02742196f, 0.04092422f, -0.04036589f, 
    0.03501325f, 0.04703008f, -0.05631732f, -0.04962228f, 0.04208430f, 0.03018697f, -0.04305266f, -0.00467900f, 
    0.03032645f, -0.04607328f, -0.05487332f, -0.03162354f, 0.00672515f, -0.02942541f, -0.01209127f, -0.01017255f, 
    0.02645036f, -0.00787846f, 0.00012759f, 0.00973260f, 0.01791585f, -0.04623253f, 0.02590543f, -0.02849990f, 
    0.02387655f, -0.04699166f, 0.02470809f, -0.02194557f, 0.03195904f, -0.00501572f, 0.04163586f, -0.03242137f, 
    0.00917248f, -0.03569584f, -0.00118100f, -0.05423458f, -0.00250022f, -0.01917732f, -0.05081894f, 0.02801879f, 
    0.00175023f, 0.03952339f, 0.04265689f, -0.05610881f, -0.04752416f, 0.00181302f, 0.00825009f, -0.05937764f, 
    0.00479699f, -0.00243649f, 0.02641553f, -0.01713869f, -0.03921339f, -0.04879472f, 0.04481931f, -0.02952128f, 
    -0.04809137f, -0.02959868f, -0.02206014f, -0.00705880f, 0.01332591f, -0.01674886f, 0.01292659f, 0.00949282f, 
    0.04108460f, 0.03901508f, 0.04151320f, -0.05640494f, 0.01860533f, -0.06257723f, 0.01763969f, -0.00566732f, 
    0.01926211f, -0.04365893f, -0.04239051f, -0.02967407f, 0.01669210f, 0.04397905f, -0.06047677f, -0.05920376f, 
    -0.02365885f, -0.01478478f, -0.05915504f, 0.03593575f, 0.00934656f, 0.02202158f, 0.03631625f, -0.05114946f, 
    -0.00798444f, 0.00284913f, 0.02249991f, -0.01372014f, 0.02984359f, 0.01971380f, -0.00117194f, -0.01293449f, 
    0.00117959f, 0.04590136f, -0.03846048f, 0.03250531f, 0.00318899f, -0.04028054f, -0.05012672f, 0.04223089f, 
    -0.03979445f, -0.03557131f, -0.02377766f, -0.00794709f, 0.01846880f, -0.01146998f, 0.01513031f, 0.01556069f, 
    0.04378952f, 0.02237899f, 0.03548810f, 0.03839737f, -0.01687310f, -0.03091313f, -0.00188371f, -0.01079541f, 
    -0.03701509f, 0.00008653f, 0.00410030f, 0.04178518f, -0.00679916f, 0.03208350f, 0.00369981f, 0.03194426f, 
    -0.05218931f, -0.00144182f, -0.04928375f, 0.00082755f, -0.02473949f, -0.03522196f, 0.00329689f, -0.01148924f, 
    -0.00459840f, -0.03069381f, -0.02114683f, 0.00609304f, 0.04212509f, -0.00137529f, -0.04876430f, -0.02148932f, 
    -0.03172060f, 0.03396974f, -0.04190515f, -0.04335939f, -0.05848723f, -0.01514808f, -0.02593936f, -0.05250079f, 
    -0.02304184f, -0.01031116f, -0.02856566f, 0.03147399f, -0.01372987f, -0.01060049f, 0.01097643f, -0.02704098f, 
    -0.04003144f, -0.02433265f, -0.04805499f, 0.01603709f, -0.03703516f, -0.00875888f, -0.05213998f, 0.00983567f, 
    -0.01769054f, 0.03247664f, -0.02042463f, 0.03672348f, -0.05802580f, -0.05553190f, -0.06227312f, -0.01599779f, 
    -0.06040972f, -0.05041948f, 0.03060688f, 0.02022140f, 0.00122243f, -0.00342188f, 0.03293962f, 0.00970610f, 
    0.00611456f, 0.04468730f, 0.03407288f, -0.03356287f, -0.03519731f, -0.00549106f, 0.04791190f, -0.02142246f, 
    -0.04299453f, -0.03494999f, 0.01852034f, -0.05107816f, 0.03824457f, 0.01820043f, 0.02387979f, 0.03585132f, 
    -0.03409557f, -0.03216705f, 0.00338617f, -0.03243572f, -0.03205674f, 0.01466346f, 0.00698553f, -0.01010210f, 
    -0.03217962f, 0.02985236f, 0.02991294f, 0.00481808f, -0.03234123f, -0.02583231f, -0.01771466f, -0.02920704f, 
    0.04637807f, -0.04985946f, -0.01313683f, -0.02146503f, 0.03300598f, -0.01460335f, 0.00082947f, -0.02047545f, 
    -0.05995546f, -0.03084844f, -0.01246646f, 0.01268731f, -0.00020769f, -0.00049431f, -0.04494798f, -0.02661658f, 
    -0.03695146f, -0.01192895f, -0.03450744f, 0.03553361f, 0.01344721f, 0.02850159f, 0.02469291f, 0.00917647f, 
    -0.01579949f, -0.01751744f, -0.01790890f, -0.04075477f, -0.05089541f, 0.03967294f, 0.01181176f, -0.03236575f, 
    -0.01939719f, 0.03769309f, 0.03262269f, -0.05857678f, -0.02766045f, 0.01232508f, 0.04473937f, 0.00633798f, 
    0.02297001f, 0.04771843f, 0.03219952f, 0.00387782f, -0.02753670f, -0.05823196f, -0.03946568f, 0.03739373f, 
    -0.03981381f, 0.02609023f, -0.05956217f, 0.04499174f, -0.05834557f, 0.01367514f, 0.00072627f, 0.02695303f, 
    0.01687692f, 0.04649513f, 0.00294892f, -0.03603196f, -0.01030118f, 0.00624353f, -0.04010764f, 0.00715245f, 
    -0.03180622f, 0.01859876f, 0.04496145f, -0.04393629f, 0.04484941f, 0.04062701f, 0.00460013f, -0.01927903f, 
    0.04277945f, 0.00547091f, -0.02188950f, 0.02388963f, 0.00143268f, -0.00021261f, -0.03908119f, 0.03732289f, 
    -0.05014195f, -0.03552654f, 0.04509704f, -0.05104251f, 0.03608155f, -0.02245332f, -0.02471062f, 0.02850408f, 
    0.00829031f, -0.05639914f, -0.05573375f, -0.04041241f, 0.03495236f, -0.03519406f, 0.00132687f, 0.04563953f, 
    -0.05324231f, -0.04532502f, -0.05134584f, 0.01376050f, -0.01564786f, -0.02909636f, 0.02911551f, -0.03425184f, 
    -0.04092804f, -0.03975554f, -0.04611930f, -0.04118566f, 0.00005351f, 0.02680476f, -0.03132627f, -0.00577138f, 
    -0.01202696f, -0.03721221f, -0.06041402f, -0.04317934f, -0.02168104f, 0.01135399f, -0.02238757f, -0.02537120f, 
    -0.05180481f, -0.02930503f, -0.02525037f, -0.02656176f, -0.00204057f, -0.05320202f, -0.06311931f, 0.03020938f, 
    0.03588253f, -0.02999108f, -0.04382020f, 0.00686436f, -0.02179569f, -0.04537705f, -0.02090823f, -0.05256146f, 
    0.03191710f, -0.03400920f, 0.04814541f, 0.02800319f, 0.00116384f, -0.01695985f, 0.04385841f, -0.04635188f, 
    -0.01831505f, -0.05684494f, -0.00234340f, -0.03877943f, 0.03769379f, 0.02534463f, -0.02350281f, 0.01717386f, 
    0.02855190f, -0.06046845f, 0.01414343f, -0.01959886f, 0.03655558f, -0.04340685f, 0.04266204f, -0.02858075f, 
    0.03476598f, 0.03672568f, 0.00092524f, 0.00155193f, 0.03366898f, 0.00120931f, 0.03410611f, 0.01397560f, 
    -0.03250409f, 0.03600723f, -0.04685659f, 0.01711500f, -0.03225254f, -0.04060019f, -0.00004668f, -0.06557833f, 
    0.00969846f, 0.04891127f, -0.02585232f, -0.06149649f, 0.03247694f, -0.04613269f, -0.06227832f, -0.03639801f, 
    -0.05312265f, -0.01277432f, 0.03670916f, 0.03682514f, 0.00775294f, -0.03809510f, 0.03222286f, -0.01895246f, 
    -0.05926527f, -0.01332591f, -0.03383154f, 0.04485930f, -0.02993672f, 0.04220729f, 0.00226526f, 0.00544132f, 
    0.03788821f, -0.03872083f, -0.03408544f, -0.00526963f, -0.05856462f, -0.05576336f, -0.05338131f, 0.02290935f, 
    0.03780637f, -0.01629028f, 0.03759117f, -0.04620012f, 0.01595180f, 0.02999630f, 0.03002116f, 0.00273578f, 
    -0.06031243f, -0.01401379f, 0.01089359f, 0.03698634f, -0.01856478f, 0.01831806f, -0.03052405f, -0.04146938f, 
    0.03589719f, 0.01742573f, 0.03559602f, -0.03374831f, 0.03411892f, -0.03610733f, 0.02554536f, -0.01668165f, 
    -0.02543678f, -0.01033644f, -0.04164848f, 0.01560399f, -0.02455858f, 0.03155552f, 0.00067333f, 0.04381415f, 
    0.03246607f, 0.01201219f, 0.04667902f, -0.04805916f, -0.03962773f, 0.02865431f, -0.00588955f, -0.00917853f, 
    0.01407419f, 0.03975936f, 0.00442951f, -0.04428953f, 0.02477922f, -0.00706783f, 0.04639805f, 0.04955486f, 
    0.00176442f, -0.00914352f, -0.05131143f, -0.04355896f, -0.05548774f, -0.02156053f, -0.04464107f, 0.00049303f, 
    -0.04587683f, 0.04676776f, 0.00404623f, -0.05897084f, 0.00891686f, -0.00388663f, -0.05409277f, 0.00673595f, 
    0.01187733f, 0.01685476f, 0.04425718f, -0.01302220f, -0.04033943f, 0.01103100f, -0.04444128f, 0.02047902f, 
    0.00676015f, -0.05024108f, -0.01492528f, -0.01308604f, 0.04485570f, 0.00942755f, -0.05248609f, 0.01613704f, 
    -0.03945521f, 0.00741548f, 0.03815784f, 0.04095723f, -0.05273855f, -0.02054937f, -0.03355690f, 0.03009999f, 
    -0.02964247f, -0.06368936f, 0.03660006f, -0.00464289f, -0.01516304f, -0.02812286f, 0.02532796f, 0.03765320f, 
    0.00469053f, -0.03295623f, 0.03166777f, -0.06021491f, -0.01440138f, 0.02084768f, -0.00115376f, 0.02396525f, 
    -0.01202341f, -0.02322433f, -0.05020051f, -0.05161822f, 0.01589024f, 0.00285929f, -0.06377728f, 0.03603579f, 
    -0.03304548f, -0.04596598f, 0.03386671f, 0.04570244f, -0.04578982f, -0.02854810f, 0.03892891f, -0.06555916f, 
    -0.01597233f, -0.00353802f, -0.02386228f, -0.02817007f, 0.03375131f, 0.02576737f, 0.02493211f, -0.04061204f, 
    0.03664126f, 0.04388222f, -0.00491749f, 0.02142036f, -0.00321480f, -0.01487798f, 0.01724081f, -0.06285409f, 
    -0.01789879f, 0.03413847f, -0.01384595f, 0.02455566f, -0.03431377f, -0.02695264f, 0.03773484f, -0.05533325f, 
    -0.05915352f, -0.05321449f, -0.01526510f, -0.00485402f, -0.01377666f, -0.01109668f, -0.04422887f, 0.03026729f, 
    -0.01542563f, -0.03028077f, -0.01501108f, -0.02790982f, 0.04247347f, 0.02093128f, 0.05024526f, -0.01354791f, 
    0.00292176f, -0.04660612f, -0.05195173f, 0.02843972f, -0.03084904f, -0.04935258f, -0.05503592f, 0.00064949f, 
    0.05873979f, 0.13881445f, 0.13256970f, 0.08297072f, 0.01712172f, 0.02923237f, -0.08696490f, -0.06424350f, 
    -0.02475399f, -0.06772434f, 0.06942698f, 0.09599904f, -0.00127581f, 0.08493183f, 0.08657167f, 0.02973391f, 
    -0.04092166f, -0.12084582f, 0.00701730f, -0.06596784f, 0.31135169f, 0.14791577f, 0.25283808f, 0.03269254f, 
    0.05215451f, 0.16720419f, -0.10745801f, 0.07563829f, 0.15185101f, 0.07138999f, -0.17633960f, 0.08275064f, 
    0.17581907f, 0.01411326f, 0.04681271f, 0.05316002f, 0.21823917f, 0.11123996f, 0.00123015f, 0.20004505f, 
    0.01397759f, -0.65629673f, -0.26650813f, -0.12945895f, 0.01426323f, -0.11285882f, -0.14206564f, 0.09465602f, 
    0.19343296f, 0.00008478f, 0.01687523f, 0.00028902f, -0.07042642f, -0.08896497f, -0.11193568f, -0.04923217f, 
    0.01542499f, -0.03695765f, -0.06114124f, -0.05709322f, 0.24053605f, 0.25970358f, 0.26171482f, 0.13624944f, 
    0.03950582f, -0.08897285f, -0.09801126f, -0.06674059f, -0.09718106f, -0.06646114f, 0.03333445f, 0.00343211f, 
    0.06685368f, -0.00014916f, 0.05998042f, 0.01304269f, -0.02893642f, -0.04857683f, -0.12215531f, -0.08039739f, 
    -0.06708279f, -0.11067700f, 0.05715310f, 0.14223327f, -0.00677344f, 0.05869123f, -0.09800751f, -0.10722978f, 
    0.04901189f, -0.06525890f, -0.00134465f, 0.00313848f, 0.04194322f, 0.01353551f, 0.09846752f, -0.03545683f, 
    0.18955892f, 0.12815887f, 0.11704206f, 0.13598193f, -0.07593238f, -0.14718328f, -0.14030318f, 0.01453582f, 
    -0.09287903f, -0.02207008f, 0.01360609f, 0.03354361f, 0.00081266f, 0.04485208f, -0.03837736f, -0.02505941f, 
    -0.01347368f, -0.04618480f, -0.00431282f, -0.07479426f, 0.11657649f, 0.05811640f, -0.02946083f, -0.05087873f, 
    0.06144710f, -0.16323094f, -0.31761876f, 0.04099026f, 0.20879045f, -0.06099254f, 0.10171704f, 0.09024479f, 
    0.01507531f, 0.03466619f, -0.01790379f, 0.05361081f, -0.00717675f, 0.01789368f, -0.01369364f, 0.02906030f, 
    0.10645287f, 0.12120687f, -0.10848576f, 0.12221141f, 0.09563153f, 0.19265667f, -0.02104535f, -0.14634971f, 
    -0.12785777f, -0.01490399f, -0.02495326f, -0.02795154f, -0.05699557f, -0.07629643f, -0.03669535f, 0.03103625f, 
    0.06831016f, -0.00661900f, 0.04079409f, 0.00403040f, -0.17542997f, -0.03622662f, 0.05158113f, -0.10496508f, 
    0.31484953f, 0.32103556f, 0.13180757f, -0.05209563f, 0.03138541f, 0.16851005f, -0.02783790f, 0.02484056f, 
    -0.04802627f, 0.07850652f, 0.09144366f, 0.08147926f, -0.00698146f, -0.09673224f, -0.11771926f, -0.00856449f, 
    -0.03923009f, -0.11858798f, 0.13461252f, -0.02073987f, 0.00783512f, -0.17590950f, 0.25864571f, 0.12846218f, 
    -0.02041314f, 0.16302337f, -0.12280497f, -0.11521662f, 0.22209093f, 0.00764053f, -0.01301664f, 0.08181664f, 
    -0.00770319f, 0.01159764f, -0.08293293f, -0.04568209f, -0.09287252f, -0.08336495f, 0.04257869f, -0.10226098f, 
    -0.09955814f, -0.32064673f, -0.31736103f, -0.26859659f, -0.15276094f, -0.16343260f, -0.04425684f, 0.04665686f, 
    -0.00777027f, -0.04803149f, -0.05242602f, 0.02948249f, -0.05075098f, -0.04496595f, 0.01781924f, -0.04805081f, 
    -0.04696141f, -0.17830028f, -0.00000318f, -0.08717582f, 0.28786644f, 0.16741693f, -0.02210356f, 0.17904618f, 
    -0.02103533f, -0.01646924f, 0.01188093f, 0.09406164f, -0.16124766f, 0.11654059f, 0.00526084f, 0.04490937f, 
    0.06219338f, -0.04629008f, -0.06289530f, 0.05898276f, 0.06251898f, 0.12587275f, -0.11255570f, 0.04506471f, 
    0.08906977f, 0.09412742f, 0.04754038f, -0.02491765f, -0.11011221f, -0.04657582f, -0.02958521f, -0.14793046f, 
    -0.04134528f, -0.03040019f, 0.06847572f, -0.08875116f, 0.11968051f, -0.02041049f, 0.04746481f, 0.07606965f, 
    -0.01288940f, 0.08654944f, 0.02819599f, 0.04908043f, 0.30336848f, 0.23445976f, 0.34093013f, 0.20209597f, 
    0.13873528f, -0.13058983f, -0.15649301f, -0.18920895f, -0.06362418f, -0.01415710f, -0.01445536f, 0.07733238f, 
    0.06985301f, 0.10560880f, 0.03818482f, -0.00206558f, -0.11677567f, -0.14427224f, 0.05760048f, 0.00343106f, 
    0.26133615f, -0.17181924f, 0.01802699f, 0.11665114f, 0.10694334f, 0.04364456f, 0.13180438f, 0.01737631f, 
    -0.09831151f, 0.00862831f, 0.02020071f, 0.12790813f, 0.10576893f, 0.01567491f, -0.02733001f, 0.04296908f, 
    0.14503272f, 0.07140092f, 0.10468012f, 0.01384339f, 0.08124311f, -0.09850085f, 0.05515846f, 0.05001437f, 
    0.04714019f, 0.07377138f, -0.05426519f, -0.14746106f, -0.00705098f, -0.01104107f, 0.03299722f, 0.12437781f, 
    0.14284702f, 0.05812445f, -0.01167116f, -0.00802936f, 0.15855750f, -0.16550766f, -0.04310524f, -0.10200305f, 
    0.03460224f, -0.02803096f, -0.00033497f, -0.04295601f, 0.03841717f, -0.04544143f, -0.01224309f, -0.01815652f, 
    -0.02229800f, -0.03630972f, 0.02078836f, -0.04573452f, -0.05287528f, -0.00439358f, 0.03494701f, -0.01859921f, 
    0.01001802f, -0.00243359f, -0.01572552f, -0.03795014f, 0.03381054f, 0.04589796f, -0.02630595f, 0.04373936f, 
    -0.05763872f, 0.01160515f, -0.05166205f, -0.01028880f, 0.04288886f, 0.04045800f, -0.05813601f, 0.03018768f, 
    0.03169581f, 0.03581562f, 0.04873998f, -0.05430265f, -0.00042421f, -0.00628858f, -0.00030500f, 0.00206094f, 
    0.01893756f, -0.02529779f, 0.04025520f, -0.02793349f, -0.06060626f, 0.01553422f, -0.05755191f, 0.02150875f, 
    0.03816405f, 0.00145412f, 0.02950653f, 0.04726133f, -0.05615344f, -0.02986816f, 0.03477994f, -0.03414670f, 
    -0.02310714f, 0.00548683f, 0.03372563f, -0.01517918f, 0.04889582f, 0.02855925f, 0.03574835f, -0.02770120f, 
    -0.04197756f, 0.04009009f, 0.00109182f, -0.04391249f, 0.03706243f, -0.02973192f, 0.03418019f, 0.01457194f, 
    -0.01273288f, -0.05019322f, 0.04112386f, -0.02682476f, 0.02611490f, -0.06129748f, -0.03905666f, -0.00870350f, 
    0.02097554f, 0.01928254f, -0.03579620f, -0.02145495f, 0.03492296f, -0.04381719f, -0.01608529f, 0.01209045f, 
    -0.03222326f, 0.04761508f, 0.01959226f, -0.01307484f, 0.03864405f, -0.02957001f, -0.04937316f, -0.03004731f, 
    -0.02707784f, -0.02366958f, 0.01073600f, 0.04740357f, 0.00952944f, -0.01202932f, -0.04067456f, 0.03891581f, 
    0.00969848f, -0.03514221f, -0.00438701f, -0.05786513f, 0.02005302f, -0.05224153f, -0.01996550f, -0.03734071f, 
    -0.00329515f, -0.06120798f, 0.01822726f, 0.01970492f, -0.00399558f, 0.01849902f, -0.00371964f, 0.00063459f, 
    0.03129999f, 0.01735906f, -0.02005590f, -0.05962115f, 0.03024514f, -0.02604419f, 0.00800232f, 0.00825235f, 
    0.03995559f, -0.02311125f, -0.01362817f, 0.00303019f, -0.00246764f, -0.02471198f, -0.03739921f, 0.03309036f, 
    -0.04820578f, -0.03464476f, 0.02871410f, -0.03756062f, -0.05147256f, 0.04768281f, 0.01626409f, -0.00552031f, 
    -0.02757259f, 0.01731048f, -0.03096149f, -0.04735253f, -0.03212136f, -0.02896151f, -0.01931635f, -0.02182869f, 
    -0.01680449f, 0.01370697f, 0.04254463f, -0.01657228f, 0.00447616f, -0.05401186f, -0.02063691f, -0.02382645f, 
    -0.05107956f, -0.05103584f, 0.00870594f, -0.06035298f, 0.01750901f, 0.00380346f, 0.02591202f, -0.00429901f, 
    -0.02237520f, -0.00719156f, 0.01533992f, 0.00503164f, -0.01601795f, 0.02505721f, -0.00961495f, -0.04009062f, 
    -0.00512688f, 0.00423794f, -0.05138680f, -0.06105127f, 0.01632123f, 0.05248459f, -0.04401705f, 0.04900719f, 
    -0.04592656f, -0.02083937f, 0.02847472f, 0.04917888f, -0.05250055f, -0.01709148f, -0.01311934f, 0.01675486f, 
    0.03385369f, -0.01710391f, -0.05358046f, 0.04558011f, -0.05644240f, -0.01578492f, -0.04749122f, -0.01632270f, 
    0.03816309f, 0.04181695f, -0.03599880f, -0.01230108f, -0.03898823f, -0.06115028f, -0.01754411f, 0.02945693f, 
    -0.04736932f, -0.01515159f, 0.01616180f, 0.01102465f, -0.03571650f, 0.00407601f, 0.04976947f, -0.00241017f, 
    -0.06089450f, -0.01492387f, 0.03157003f, 0.00193318f, 0.03419004f, 0.01320858f, -0.03061326f, -0.02406585f, 
    0.00266061f, -0.02332689f, -0.03672584f, -0.04111372f, -0.00129724f, -0.03022686f, 0.02237087f, 0.01304172f, 
    -0.02462992f, -0.03842921f, 0.03007988f, 0.00393062f, 0.02539890f, 0.03127340f, -0.01393739f, 0.04485439f, 
    -0.05413206f, -0.04221193f, -0.04232680f, -0.03576753f, -0.02979897f, -0.03702379f, -0.03509818f, -0.03909634f, 
    0.04235470f, 0.03381320f, -0.01070548f, 0.04965632f, -0.04524041f, -0.05592616f, -0.02376779f, -0.05964086f, 
    -0.02730565f, -0.01869016f, 0.01139236f, 0.02414419f, -0.00170451f, -0.00619437f, 0.03232819f, -0.01950647f, 
    -0.00553175f, -0.05375915f, -0.04805860f, -0.00685653f, -0.00788653f, -0.00755576f, -0.05151367f, 0.02203101f, 
    0.01404815f, 0.00493405f, 0.02845011f, -0.00054443f, -0.05200314f, -0.00097538f, 0.00286115f, -0.03327466f, 
    -0.04395038f, 0.01889322f, -0.00351147f, 0.00548385f, 0.04456767f, 0.00434698f, -0.05038976f, 0.01492303f, 
    0.00462263f, -0.03468335f, 0.01916410f, 0.03871549f, -0.00424615f, -0.03121346f, -0.05828082f, -0.04628219f, 
    0.03810143f, -0.01718950f, -0.03395021f, -0.04551364f, 0.01954707f, 0.00370430f, -0.02536016f, -0.05328070f, 
    -0.05043057f, -0.05210002f, 0.02312996f, 0.03268208f, 0.04452138f, 0.00823740f, -0.03153353f, -0.02392769f, 
    0.03709095f, -0.02591688f, 0.01923815f, 0.02096166f, 0.01528330f, -0.03947512f, -0.05906810f, -0.01844145f, 
    0.02085758f, -0.03039434f, -0.04744364f, -0.00357716f, -0.03068705f, 0.00664823f, -0.00596516f, -0.03130408f, 
    -0.01031893f, -0.05148337f, 0.00644330f, -0.02735768f, -0.00287207f, -0.03890997f, 0.00713872f, 0.02580646f, 
    0.03763927f, -0.04667607f, -0.01696965f, 0.02954317f, 0.01690825f, 0.02107255f, -0.01272771f, 0.01933761f, 
    -0.04497446f, -0.00063011f, -0.03742236f, -0.03749800f, -0.01782574f, 0.00480355f, -0.03227035f, 0.00807500f, 
    -0.00072738f, 0.03632797f, -0.02350107f, -0.03622834f, 0.01548109f, -0.00156701f, 0.01298669f, -0.01613602f, 
    -0.00492107f, -0.00264468f, 0.03504459f, 0.01913672f, -0.03674170f, -0.04105062f, 0.01501540f, 0.04874923f, 
    0.01696636f, -0.02379606f, -0.05516366f, -0.03051814f, 0.03213302f, 0.01914796f, 0.01049173f, -0.03296716f, 
    0.01615200f, 0.01895893f, 0.02108950f, -0.05416022f, -0.01369633f, -0.03841835f, 0.01563035f, -0.02096613f, 
    0.01300058f, 0.00824195f, -0.00578152f, -0.03046216f, 0.00371861f, -0.00377832f, 0.01130838f, 0.04880336f, 
    -0.05114881f, -0.01478710f, 0.03172415f, -0.03537074f, -0.02635559f, -0.04791865f, -0.01952301f, 0.04786296f, 
    0.02628537f, -0.03126547f, 0.03408454f, -0.03224758f, -0.02738517f, -0.02726274f, -0.05073752f, -0.02701919f, 
    -0.01554943f, -0.05246407f, -0.02408506f, 0.01652295f, -0.03018494f, -0.03340001f, -0.00553394f, 0.03394818f, 
    -0.05789154f, -0.05989096f, 0.00038369f, 0.00020608f, -0.04989522f, 0.05311891f, -0.01298624f, -0.04698040f, 
    -0.01771329f, -0.04414899f, 0.05456850f, -0.05548962f, -0.03605201f, 0.01244022f, -0.04574598f, -0.04995870f, 
    0.04002728f, -0.03859418f, -0.04382470f, -0.01756721f, 0.03692155f, -0.00748136f, 0.00234434f, 0.02301760f, 
    -0.01805791f, 0.01316186f, 0.00310286f, 0.01549580f, -0.04465106f, 0.04817183f, -0.01173203f, 0.00480065f, 
    0.03146286f, 0.00756241f, -0.01107728f, -0.01721020f, -0.04608106f, -0.00579919f, -0.05421175f, -0.05020544f, 
    0.02551193f, 0.02695500f, -0.01478239f, -0.04100101f, 0.02302848f, 0.00155213f, -0.00988497f, -0.04385105f, 
    0.00904796f, 0.02064552f, -0.02621610f, -0.03392925f, 0.04251976f, 0.03642395f, -0.02803014f, -0.02689247f, 
    -0.00972903f, 0.01376799f, 0.01927135f, -0.01215879f, -0.01916388f, -0.01299310f, 0.02127202f, -0.05547086f, 
    0.00326241f, -0.04684936f, 0.01803692f, -0.01422473f, 0.04883975f, -0.02769943f, 0.03314403f, 0.00751440f, 
    0.03314616f, 0.03033507f, -0.02938270f, -0.05182097f, -0.05765441f, -0.02894735f, -0.03022603f, 0.01547186f, 
    0.04861910f, 0.03910581f, 0.04952176f, -0.01607640f, -0.02594565f, 0.03601482f, -0.02366631f, -0.03852054f, 
    0.03638491f, -0.01038641f, -0.05951112f, 0.02244456f, 0.04417650f, -0.02542308f, -0.03598522f, -0.00016775f, 
    0.03294317f, -0.03408254f, 0.01500261f, -0.02829432f, 0.02524808f, -0.01736116f, 0.01660042f, 0.01465559f, 
    -0.01511972f, -0.01853591f, 0.03408941f, -0.04029690f, 0.04518433f, -0.04100403f, 0.00578950f, -0.05883608f, 
    -0.03202644f, 0.02158771f, -0.00723299f, 0.01651522f, -0.03606545f, 0.03722328f, 0.05031056f, -0.05650278f, 
    -0.02012414f, -0.02834134f, -0.02039556f, -0.04617137f, 0.02555829f, -0.02037108f, 0.03467352f, 0.00087458f, 
    -0.05194226f, -0.00340011f, 0.00550286f, -0.05433915f, 0.00575952f, -0.03042375f, 0.04269277f, 0.00390129f, 
    -0.05369704f, 0.04435094f, -0.01293306f, 0.01553915f, -0.00153737f, -0.05757189f, 0.04282249f, 0.00192132f, 
    0.03760143f, -0.01378725f, 0.01522789f, -0.05014233f, -0.03873600f, -0.02646801f, 0.04310096f, -0.04110875f, 
    -0.01678323f, 0.00669352f, 0.03160864f, 0.04200070f, 0.01345885f, 0.00176756f, -0.05336528f, -0.03681550f, 
    -0.05569621f, -0.04514964f, 0.00782719f, -0.00484954f, -0.00132736f, -0.02411484f, 0.01576529f, 0.01479243f, 
    0.02979046f, 0.02155065f, -0.01030110f, -0.01334221f, -0.00044244f, -0.03803099f, -0.04439070f, 0.00150090f, 
    -0.04852248f, 0.04252902f, -0.03844331f, -0.02226997f, 0.01545726f, 0.03701039f, -0.01728973f, 0.01268145f, 
    0.04784329f, -0.02841979f, -0.03447130f, 0.03381083f, 0.03010750f, -0.04688800f, 0.01586396f, -0.01717889f, 
    0.00895995f, -0.01834844f, 0.01230059f, -0.01932121f, 0.00390585f, 0.03368317f, 0.01315284f, 0.01672873f, 
    0.01031704f, -0.06081564f, -0.01743228f, -0.03211631f, 0.04712548f, -0.03326151f, 0.02432013f, 0.04021251f, 
    -0.03599295f, -0.00123599f, 0.03851093f, 0.00341405f, -0.03926147f, 0.01038748f, -0.01642000f, -0.01407698f, 
    -0.01757025f, 0.02855604f, 0.00281210f, 0.02549140f, -0.01996419f, 0.00850605f, -0.02839027f, 0.00548340f, 
    0.10637598f, 0.17746647f, -0.06940374f, 0.20429941f, 0.13798945f, 0.00540279f, 0.14855847f, 0.11677266f, 
    -0.01590384f, -0.05231266f, 0.17207603f, 0.24674881f, 0.10887809f, 0.07996031f, 0.12239061f, -0.12324496f, 
    0.02097503f, 0.01390067f, -0.04233456f, 0.02314817f, -0.04991513f, 0.01952711f, -0.14271516f, -0.19473276f, 
    -0.29059938f, -0.07309693f, -0.00359009f, 0.07886963f, 0.06385890f, 0.03069261f, 0.00819337f, -0.09411077f, 
    0.13172984f, -0.06488449f, 0.15724739f, -0.01179865f, 0.00955669f, 0.17049576f, 0.02981319f, 0.11524129f, 
    0.24126850f, -0.10210202f, -0.48221317f, -0.33071053f, -0.39390361f, -0.04927293f, 0.01999057f, -0.01539890f, 
    0.01386739f, 0.07828952f, -0.07666025f, -0.12368947f, -0.06459646f, 0.01633415f, -0.17115757f, -0.04621109f, 
    -0.01161544f, -0.01354460f, -0.04515867f, 0.02491762f, 0.27823567f, 0.13089135f, 0.13931063f, 0.27335277f, 
    0.27133814f, 0.07130641f, 0.06595018f, -0.04118800f, 0.04831794f, 0.05304450f, 0.16295752f, 0.04550536f, 
    0.03881999f, 0.10444262f, 0.11477482f, -0.12153812f, 0.03773563f, -0.08055307f, 0.00923346f, -0.12177845f, 
    0.19812602f, 0.23888710f, 0.29794663f, -0.11490610f, -0.05713335f, 0.20539130f, 0.11104897f, -0.00106355f, 
    0.12743162f, 0.14752543f, -0.07377192f, -0.08991324f, -0.10256614f, 0.09520236f, 0.12162091f, -0.01299832f, 
    0.01975279f, -0.07651643f, 0.11924643f, -0.06686977f, 0.10209323f, 0.06107736f, 0.07496771f, 0.05557475f, 
    -0.00001320f, -0.00420112f, 0.13682732f, 0.00611653f, -0.01070253f, 0.09304737f, 0.14074348f, 0.04494930f, 
    0.11079848f, 0.01016384f, -0.13178992f, -0.05880414f, 0.04709851f, -0.02729847f, -0.04900203f, 0.01809503f, 
    0.22298826f, -0.04941964f, 0.09594434f, -0.03817546f, -0.30186316f, 0.09886506f, 0.08198360f, 0.06294782f, 
    -0.01890166f, 0.17447208f, -0.10463533f, -0.05996931f, 0.03567321f, 0.00688680f, -0.08693097f, -0.09687456f, 
    0.00943057f, -0.03461144f, -0.03033784f, 0.11406086f, -0.23177812f, 0.31857705f, 0.07625097f, 0.32546070f, 
    0.10306438f, -0.10436442f, -0.11112630f, 0.06350387f, -0.07564747f, -0.04581138f, 0.00208986f, -0.02719918f, 
    0.03009949f, 0.05180487f, 0.08813882f, -0.11941589f, -0.01596288f, 0.13577740f, -0.07090454f, -0.01205944f, 
    0.29679701f, -0.35029337f, -0.14001805f, -0.17959110f, 0.07297455f, 0.07255698f, 0.06964616f, 0.05973800f, 
    0.14914185f, -0.02401311f, 0.02581210f, -0.11664576f, -0.00937345f, -0.04531417f, -0.01992263f, -0.13735460f, 
    -0.03115970f, -0.04891659f, 0.01412067f, 0.12936243f, 0.32106975f, -0.07047801f, -0.01769505f, -0.33218557f, 
    -0.07345115f, -0.09822293f, -0.03949331f, 0.00656187f, 0.04087432f, 0.05588866f, -0.02929635f, -0.09804332f, 
    -0.05903168f, -0.04983016f, 0.13228640f, -0.02785446f, -0.13736874f, -0.07779381f, 0.05053497f, -0.02646057f, 
    0.11496355f, 0.19965896f, -0.33296925f, -0.11703034f, -0.26624939f, -0.04589588f, -0.11637387f, -0.16135740f, 
    -0.14033686f, 0.09964580f, 0.03841349f, 0.05000716f, -0.01723169f, 0.10767414f, -0.07373122f, -0.05784066f, 
    0.02522566f, 0.04664692f, -0.04505446f, -0.15653764f, -0.03754405f, 0.05332182f, 0.08135853f, 0.17928819f, 
    -0.10511393f, 0.15739466f, -0.07445963f, -0.11677524f, -0.04426729f, 0.10726921f, 0.09499520f, -0.07991323f, 
    0.14892420f, 0.05401718f, 0.02491452f, -0.00351003f, 0.01571752f, 0.20612679f, -0.06352916f, 0.00892160f, 
    -0.04399728f, 0.18290101f, 0.07403407f, 0.15056726f, 0.02716716f, 0.05235750f, 0.06707439f, 0.33204123f, 
    -0.03259269f, -0.05445624f, 0.02276338f, 0.08471029f, 0.08353807f, 0.01890883f, 0.02895102f, 0.02946802f, 
    -0.02613893f, 0.17060858f, -0.10064662f, -0.12958962f, 0.09188357f, 0.26145416f, -0.32821557f, 0.06294653f, 
    0.04498721f, 0.01068653f, 0.04309596f, 0.10823321f, -0.04113495f, 0.11742827f, 0.01908570f, 0.03512840f, 
    -0.00880954f, 0.04087333f, 0.03895709f, 0.07027793f, 0.08532693f, -0.02157426f, -0.12590216f, -0.08463668f, 
    0.42149031f, -0.01135505f, 0.39517346f, -0.39732775f, 0.18217261f, 0.02275478f, 0.13389730f, -0.04757308f, 
    -0.02690264f, 0.18921322f, 0.03995027f, 0.04616979f, 0.06498712f, 0.03442956f, 0.04848103f, -0.07313734f, 
    0.10709856f, -0.18719748f, -0.04084659f, 0.14493433f, 0.14486304f, 0.40062213f, 0.21997738f, 0.07331990f, 
    -0.10213831f, 0.03165190f, -0.00041908f, 0.03464655f, 0.00782103f, 0.13777509f, -0.08557473f, -0.06200663f, 
    -0.00030889f, 0.08095406f, 0.04003591f, 0.01985338f, 0.08555986f, -0.01908196f, -0.15929009f, -0.10062949f, 
    -0.04155298f, 0.08620007f, 0.24047838f, 0.01155919f, 0.00380168f, 0.04244692f, -0.04836952f, 0.05252907f, 
    -0.03768419f, -0.04592448f, 0.04958312f, 0.12100131f, -0.00420842f, 0.10651083f, 0.06359284f, -0.08347114f, 
    0.08363888f, 0.03486207f, 0.10304045f, 0.03539313f, 0.04682725f, 0.00836070f, 0.04475946f, 0.25722855f, 
    0.21411976f, -0.00056564f, 0.07721248f, 0.24186905f, 0.07903704f, 0.08111094f, -0.13053113f, 0.08701107f, 
    0.01497664f, 0.10531058f, 0.02705197f, -0.05943651f, 0.03039614f, 0.08431072f, -0.00469928f, -0.13739005f, 
    0.25588065f, -0.19604678f, 0.26715291f, 0.04277974f, -0.23303357f, -0.17166373f, -0.21935615f, -0.15273705f, 
    0.06152079f, -0.03246745f, -0.08671538f, 0.02985789f, 0.12785444f, -0.02595588f, -0.11908266f, -0.02821719f, 
    -0.02959783f, -0.11175795f, -0.04056318f, -0.03659999f, 0.16090812f, -0.04779521f, -0.00979077f, 0.13909990f, 
    0.08864229f, -0.20665726f, -0.07654437f, 0.06317563f, -0.04053244f, -0.06260771f, 0.02740410f, 0.03307886f, 
    0.04270250f, -0.01843522f, 0.01467721f, 0.16316357f, -0.02408237f, 0.00251453f, 0.04905079f, -0.07815158f, 
    -0.17864238f, -0.10252009f, -0.31115222f, 0.19576098f, -0.06551016f, -0.03125248f, -0.11933344f, -0.04006705f, 
    -0.04216938f, 0.03234371f, -0.07338158f, 0.02562461f, 0.06175822f, -0.09401163f, -0.02974113f, 0.12107313f, 
    -0.06921140f, 0.01229860f, -0.04499213f, 0.09073032f, -0.27067310f, -0.15329930f, 0.00203288f, -0.00259322f, 
    0.00535046f, 0.09587252f, 0.05842958f, 0.08265920f, -0.00203679f, -0.05507660f, 0.00029830f, 0.00356927f, 
    -0.02116684f, 0.01641719f, -0.07285249f, -0.06614573f, -0.00235851f, 0.08399095f, 0.01773546f, -0.01570409f, 
    -0.39943817f, 0.15065157f, -0.17057982f, 0.17504483f, 0.01829075f, 0.00126192f, -0.03635424f, -0.04563476f, 
    0.08353222f, -0.08470897f, -0.14652009f, -0.07532425f, 0.04990738f, 0.00932455f, -0.00637017f, 0.04184944f, 
    0.11321471f, -0.09824049f, -0.05192590f, 0.18234746f, -0.10021082f, -0.32466564f, -0.03996643f, 0.19043395f, 
    0.14060450f, -0.15338282f, -0.04103507f, 0.05887068f, -0.08220840f, -0.11326286f, 0.07836137f, 0.04856203f, 
    -0.03795886f, -0.11710802f, -0.00445480f, 0.03656393f, -0.14135884f, -0.02866758f, 0.06395413f, -0.17196813f, 
    0.28790998f, 0.15078337f, -0.27864057f, 0.29115099f, -0.11296722f, -0.03710390f, -0.20472673f, -0.18504067f, 
    0.07626165f, -0.01202247f, 0.03435854f, 0.16029757f, 0.09288859f, -0.10185339f, 0.04471217f, 0.00025558f, 
    0.15368366f, -0.09167895f, 0.09057701f, 0.21366291f, -0.16918960f, 0.04614662f, -0.27159688f, 0.38592997f, 
    0.02235967f, 0.01683790f, -0.00122129f, -0.08945641f, 0.10235915f, -0.08059549f, -0.01878273f, -0.10717972f, 
    -0.06953275f, -0.06444519f, 0.04998014f, 0.11422250f, 0.04045410f, -0.03784628f, 0.01052442f, -0.10039153f, 
    0.38069925f, -0.01037911f, 0.44571918f, -0.17894198f, -0.26334572f, -0.04530574f, -0.11510623f, -0.16677329f, 
    -0.05610171f, -0.15209869f, -0.07774784f, -0.10010919f, -0.11048720f, -0.04512576f, -0.09419607f, 0.00359922f, 
    -0.02692419f, -0.00375549f, 0.04906727f, -0.11050203f, -0.12646802f, 0.24869831f, 0.04818830f, 0.06177263f, 
    -0.13280106f, -0.00382599f, -0.00855554f, -0.04305201f, 0.02161128f, -0.03278418f, -0.12678932f, -0.06107462f, 
    0.09193069f, 0.18556778f, -0.09937077f, 0.12060948f, 0.10326838f, 0.04929092f, 0.12641297f, -0.01055216f, 
    -0.01058994f, -0.15708278f, 0.18836729f, -0.01298330f, 0.03164889f, -0.04329616f, 0.20227364f, 0.06009061f, 
    -0.02954347f, 0.02441120f, 0.03689553f, -0.05107570f, -0.05131574f, 0.02607955f, -0.04083166f, 0.10494325f, 
    -0.01873459f, 0.01060440f, 0.11080910f, -0.07980281f, 0.00793757f, 0.19645028f, 0.35345888f, -0.07141329f, 
    -0.04401638f, -0.20240797f, -0.17688414f, -0.06351663f, 0.09101848f, -0.03990681f, 0.04232583f, 0.04161592f, 
    0.03852946f, 0.23275422f, 0.01860667f, -0.09331334f, 0.01538423f, 0.01200809f, 0.11980008f, 0.10999350f, 
    -0.27236176f, 0.08584997f, -0.04960126f, 0.22758234f, -0.23506197f, 0.11704084f, 0.08816886f, -0.02851797f, 
    0.25964734f, 0.11186114f, -0.06334816f, -0.04431600f, 0.23400624f, 0.05196752f, 0.01887369f, 0.00380026f, 
    0.02726564f, 0.05256246f, 0.22675085f, 0.06570555f, -0.10293706f, -0.20230226f, -0.37609667f, -0.08658913f, 
    -0.10514104f, 0.16599970f, -0.03939152f, 0.11076421f, -0.09884909f, 0.07576557f, -0.06378365f, 0.05052702f, 
    0.05371664f, 0.05068712f, -0.02890687f, 0.12061591f, -0.00636639f, -0.09653317f, -0.06553610f, 0.08436882f, 
    -0.00745121f, -0.13233967f, -0.20833111f, -0.12964858f, -0.01167532f, 0.12042981f, -0.06439281f, -0.01044110f, 
    0.07529406f, 0.09560458f, -0.06993617f, 0.11555950f, 0.01722245f, -0.02313405f, 0.07333958f, 0.04894665f, 
    -0.08353820f, -0.14826159f, -0.01417250f, 0.06583082f, -0.02844430f, 0.08112046f, -0.32149795f, -0.02959399f, 
    -0.16874325f, 0.01967657f, 0.05494934f, 0.09879406f, 0.08182544f, 0.01238687f, 0.06764300f, 0.08891067f, 
    0.03735274f, -0.00271171f, -0.02747700f, 0.09588350f, -0.12102097f, 0.06749236f, 0.00740558f, 0.01144713f, 
    0.51699775f, 0.17771050f, 0.23358683f, 0.19430947f, -0.17092524f, -0.24265184f, -0.09661730f, -0.11272693f, 
    0.04500553f, -0.09200551f, 0.13817860f, 0.01766308f, -0.04736490f, 0.05808633f, 0.08151504f, -0.00845191f, 
    0.02736702f, 0.08044171f, -0.11611916f, -0.07222348f, -0.01520772f, -0.12359785f, -0.20630084f, -0.19569862f, 
    0.17521378f, -0.11551343f, -0.07917555f, -0.00169229f, -0.06602386f, 0.00511403f, -0.17302023f, -0.01494796f, 
    0.00272550f, 0.05526916f, 0.12756649f, 0.05347605f, 0.16318011f, 0.13201140f, 0.03190843f, 0.11766535f, 
    0.04431114f, 0.10783042f, 0.19585411f, -0.01233802f, -0.12387521f, 0.14377502f, 0.10840860f, 0.05383353f, 
    0.03291388f, 0.08438677f, 0.12311163f, -0.05179979f, 0.05235617f, 0.10860046f, -0.06758010f, 0.07868908f, 
    0.06572033f, 0.09316561f, 0.08559144f, 0.04826538f, 0.03808956f, 0.15225671f, 0.24542929f, -0.10964587f, 
    0.09107032f, -0.14021426f, -0.10284086f, -0.10165080f, -0.01003818f, 0.07236557f, 0.11406013f, 0.08949734f, 
    0.05774175f, 0.03542180f, 0.03097598f, -0.06683963f, -0.20191956f, -0.09573162f, -0.19459042f, -0.14765976f, 
    0.05566920f, 0.12367231f, 0.28475681f, 0.14653851f, -0.13472870f, 0.00818528f, 0.01257365f, 0.09124640f, 
    0.02711655f, -0.04292760f, 0.05415474f, -0.01258403f, 0.01042889f, -0.02443990f, 0.00808362f, 0.13189578f, 
    0.06518745f, -0.18978211f, 0.05661436f, 0.05599430f, -0.05025207f, -0.12826318f, -0.05138094f, 0.16923580f, 
    0.01420113f, 0.14133582f, -0.21659118f, -0.09463026f, -0.14297676f, -0.07923259f, 0.08932852f, -0.00048178f, 
    0.07673174f, -0.00733767f, -0.03062511f, 0.13395892f, 0.18689829f, 0.10071952f, -0.06304062f, 0.23034813f, 
    0.28846985f, -0.27224436f, 0.07828227f, -0.14993648f, -0.21661058f, -0.00264332f, -0.01432493f, -0.06898832f, 
    -0.04856164f, 0.00752004f, 0.03892771f, -0.04248004f, -0.00236481f, 0.05922670f, -0.07324129f, -0.03543948f, 
    0.14856970f, 0.02145050f, -0.01591477f, 0.03138721f, 0.22954029f, -0.13195932f, 0.05504987f, 0.02607961f, 
    0.05082740f, -0.04467275f, -0.00161025f, -0.08020175f, -0.01730079f, -0.11758768f, 0.20545508f, 0.00687694f, 
    0.08226500f, -0.02560124f, -0.05690078f, 0.11068983f, 0.18445106f, 0.08023621f, 0.07059204f, 0.19657658f, 
    0.04094845f, 0.13032173f, 0.36034966f, 0.12521848f, 0.03216679f, -0.14892519f, -0.25367501f, -0.17061757f, 
    0.03335619f, 0.12868427f, 0.12113992f, -0.00614804f, -0.02516622f, -0.06679893f, 0.05312977f, 0.18265589f, 
    0.12778023f, 0.07248473f, -0.12489996f, 0.02371633f, -0.54897100f, -0.03105736f, -0.19809124f, -0.03781218f, 
    -0.06150585f, 0.24546316f, 0.00373272f, 0.09627481f, -0.08498569f, -0.05836717f, 0.05280700f, -0.16058074f, 
    -0.11045732f, 0.01921302f, 0.00503010f, -0.01841289f, 0.17116430f, -0.00267698f, -0.11756557f, 0.00275390f, 
    -0.27875128f, 0.00644777f, -0.08910012f, -0.11241937f, 0.05765079f, 0.13598990f, 0.19648457f, 0.08931900f, 
    -0.04995243f, 0.11507986f, 0.09518503f, 0.07510021f, -0.11336914f, 0.03384610f, 0.04192440f, 0.09889644f, 
    -0.03824352f, -0.23898400f, -0.19902222f, 0.02375209f, -0.42308983f, -0.00886778f, -0.48053908f, -0.47800323f, 
    -0.18816951f, 0.18144847f, -0.00936907f, 0.11161532f, -0.00431199f, 0.21565613f, 0.01462112f, -0.15929545f, 
    -0.06739856f, -0.01764825f, 0.01598208f, 0.11357643f, 0.08425137f, 0.01871425f, -0.06981830f, 0.04081995f, 
    0.26072732f, -0.00529127f, 0.25170726f, -0.33856347f, 0.11503037f, 0.03871441f, 0.15140930f, 0.07536344f, 
    -0.07086210f, 0.12347842f, 0.07982826f, 0.04231014f, 0.02339974f, 0.03258396f, -0.07121387f, -0.08181422f, 
    0.02472145f, -0.12884411f, -0.02270244f, -0.05307369f, -0.06362890f, 0.11823595f, 0.07289752f, 0.05507357f, 
    -0.08730341f, 0.13307627f, 0.01463012f, 0.09229910f, 0.04215777f, 0.01594870f, -0.04770963f, -0.01068468f, 
    0.02347315f, 0.00452094f, -0.06437291f, 0.01570937f, 0.12637419f, 0.09003358f, 0.04268640f, 0.15720274f, 
    0.01777088f, -0.12118807f, 0.12339729f, -0.06103317f, 0.09601280f, 0.09209708f, 0.03408942f, -0.05405827f, 
    0.04499724f, -0.02416837f, -0.11225846f, -0.10744996f, -0.03149519f, 0.02078081f, -0.05111691f, -0.03394521f, 
    0.02069949f, -0.08946674f, 0.10354088f, -0.05948000f, 0.14808759f, 0.01686123f, 0.10201975f, 0.15874214f, 
    0.15856153f, 0.20309158f, 0.03361836f, -0.12748973f, 0.04596392f, -0.01376973f, 0.13135172f, 0.00173569f, 
    0.01855307f, 0.00908923f, 0.02484774f, -0.02163054f, 0.07549001f, -0.02583361f, 0.00182095f, 0.12425900f, 
    -0.45271289f, 0.12331380f, 0.22304966f, -0.03658500f, 0.32065117f, -0.07700072f, -0.20187031f, 0.18940456f, 
    0.04372912f, 0.06937514f, 0.00658203f, -0.01167285f, 0.00386356f, -0.12922031f, 0.00225362f, -0.06235476f, 
    -0.02278049f, -0.10788524f, -0.04328832f, -0.19216974f, -0.02339487f, 0.12297002f, 0.15865183f, -0.02942120f, 
    -0.16258614f, 0.03444457f, -0.05578697f, -0.05062683f, -0.11388241f, -0.02630032f, 0.05606563f, -0.08175217f, 
    0.01150711f, -0.14649568f, -0.04842166f, 0.00849736f, -0.01343281f, -0.00569909f, -0.02891937f, -0.10335229f, 
    -0.14669707f, -0.19943942f, -0.19376162f, -0.11712881f, -0.16953914f, -0.19330296f, -0.03725551f, 0.05189982f, 
    -0.03316942f, -0.30508175f, -0.17154044f, -0.04690988f, 0.01749522f, -0.13474214f, 0.04040239f, -0.07777195f, 
    -0.05745958f, 0.01197263f, -0.10898925f, 0.05162648f, 0.07418493f, -0.17339472f, -0.17788735f, -0.05053342f, 
    -0.01847478f, -0.04413541f, -0.05668223f, -0.08831586f, -0.06457495f, -0.09017034f, -0.14611498f, -0.05070852f, 
    0.07976580f, -0.09182423f, -0.00685521f, 0.05428514f, -0.12680592f, -0.10677561f, -0.09667743f, -0.09727040f, 
    0.01337812f, 0.12284078f, -0.22602795f, -0.16968650f, 0.29872239f, -0.14751755f, 0.05421225f, -0.00553460f, 
    0.01702858f, -0.04463692f, 0.07805239f, 0.02336262f, 0.08479536f, -0.07733069f, 0.01474289f, 0.05349978f, 
    0.08835514f, 0.13764329f, 0.02066454f, -0.03177113f, -0.12570615f, -0.00432797f, 0.07861127f, -0.18572596f, 
    0.13255517f, 0.06985261f, -0.01680001f, -0.19009060f, 0.11348442f, -0.08782884f, 0.01173964f, 0.14740300f, 
    -0.04239727f, -0.10709091f, -0.05608562f, 0.14748935f, 0.03709237f, -0.05559685f, 0.05227124f, 0.00999713f, 
    -0.37231806f, 0.66577870f, 0.10617628f, 0.07342630f, -0.07625255f, -0.01024564f, 0.17023650f, 0.01715633f, 
    -0.23670909f, -0.12595390f, -0.05507635f, 0.12665793f, 0.13068941f, 0.03552156f, -0.00040807f, 0.15452333f, 
    0.13705640f, 0.12451522f, 0.17311656f, 0.00342072f, -0.21628711f, 0.05453854f, 0.22650376f, 0.18096304f, 
    0.02156745f, 0.02630992f, 0.07562232f, 0.02806943f, -0.10484576f, -0.00002782f, -0.09404550f, 0.04803767f, 
    -0.08233695f, 0.00489845f, -0.04657602f, 0.00608037f, -0.05238625f, 0.14048719f, -0.01997563f, 0.01969862f, 
    -0.25081676f, -0.08277150f, 0.33500931f, -0.06581280f, 0.37872535f, 0.08334629f, 0.02203212f, 0.07420688f, 
    0.10963409f, 0.11442270f, 0.04833185f, 0.05399101f, 0.05733380f, 0.07889263f, 0.04839296f, -0.10236556f, 
    -0.09798564f, -0.04177998f, -0.00816297f, -0.01651370f, 0.39551267f, -0.10747802f, 0.24042344f, -0.02359007f, 
    0.27266496f, -0.16551994f, 0.27073276f, -0.04960069f, 0.01518547f, 0.23982984f, 0.02363435f, 0.06688236f, 
    -0.03103780f, -0.04473758f, -0.01703111f, 0.10817406f, -0.10517759f, 0.02889258f, -0.04050727f, 0.10654014f, 
    0.09423585f, -0.17162029f, -0.00840406f, 0.02684244f, 0.06548230f, 0.16301140f, -0.06412460f, -0.08190598f, 
    0.04821112f, -0.03891008f, -0.00657848f, -0.04249567f, 0.05601903f, 0.05253135f, -0.04521755f, -0.04757668f, 
    0.02867259f, -0.05123563f, 0.14808346f, 0.08058387f, 0.31308517f, -0.16647731f, 0.31479827f, 0.26039064f, 
    0.07845300f, 0.06277453f, 0.12526232f, -0.23558113f, 0.04964214f, -0.11797760f, 0.02519177f, -0.02486030f, 
    0.09160964f, -0.02278814f, 0.00848356f, 0.04481303f, -0.07057611f, -0.00713263f, 0.21794522f, 0.00661369f, 
    -0.07188991f, 0.13951631f, -0.51362562f, 0.24066277f, -0.26255524f, 0.05569829f, 0.05366228f, -0.08219408f, 
    -0.00985749f, -0.10971521f, -0.02865871f, 0.03699242f, -0.02034829f, -0.03604210f, -0.03122680f, 0.11387517f, 
    -0.07831531f, 0.06665578f, 0.17126206f, 0.09125965f, -0.10020102f, -0.19769606f, -0.03097734f, -0.22169283f, 
    -0.06119760f, -0.08636694f, 0.04581258f, 0.00097562f, 0.08423550f, -0.16647384f, 0.01038711f, 0.03950514f, 
    0.10261005f, -0.07497840f, -0.03328425f, -0.02896241f, -0.03898064f, -0.11294610f, 0.14037903f, 0.03163696f, 
    -0.00456744f, -0.06090745f, 0.02819691f, -0.04168219f, -0.00512636f, -0.00065587f, -0.03842491f, 0.01388755f, 
    -0.03691694f, 0.03216213f, 0.01918497f, 0.03249576f, -0.02466841f, -0.04286586f, -0.04963322f, -0.03318212f, 
    -0.01545678f, -0.03497202f, -0.05644575f, -0.02600445f, -0.04264793f, -0.04887653f, -0.03227580f, 0.02913305f, 
    0.00572403f, 0.02774869f, 0.01707101f, 0.00623462f, 0.00297379f, -0.00235119f, 0.02859366f, 0.01222992f, 
    -0.02734827f, -0.02350731f, -0.00333662f, -0.02787714f, -0.06074336f, 0.03925338f, 0.01696827f, 0.04334022f, 
    0.02178120f, 0.04233255f, 0.04046037f, 0.02423536f, -0.02587659f, 0.04142748f, -0.00482554f, -0.00798680f, 
    0.03771706f, 0.04856082f, 0.01818641f, -0.03287317f, 0.00973552f, -0.02881641f, 0.02177842f, 0.04558070f, 
    -0.04106160f, 0.01639942f, 0.03506903f, 0.02499649f, 0.02548826f, -0.03872924f, -0.05735455f, -0.06310584f, 
    -0.04478256f, -0.00661439f, 0.01964500f, -0.00697873f, -0.03063544f, -0.05921165f, 0.02435971f, -0.05048680f, 
    0.03852027f, -0.04443446f, 0.04848606f, -0.03332178f, -0.06007136f, -0.05763750f, 0.01726228f, -0.05414410f, 
    -0.03381472f, 0.00606432f, -0.05431664f, 0.01187318f, -0.05800689f, 0.01553733f, 0.01863354f, -0.05174259f, 
    0.02339398f, 0.01442681f, 0.01100602f, -0.01379955f, 0.00942703f, -0.04810815f, 0.00558403f, 0.02916101f, 
    0.00027100f, -0.00662585f, 0.00047453f, -0.05610154f, -0.00101525f, 0.02986855f, 0.04422320f, -0.05767217f, 
    0.01953858f, 0.00829885f, 0.00403468f, 0.04467629f, 0.02529564f, 0.00593263f, 0.03822307f, 0.00186777f, 
    0.03404056f, 0.01015340f, -0.02099434f, -0.04314838f, -0.02069980f, -0.02903032f, -0.00761991f, 0.02329181f, 
    0.00243741f, -0.03934164f, 0.02298220f, -0.02004242f, 0.00412088f, -0.04104641f, 0.04207507f, -0.01785485f, 
    -0.05547368f, -0.05549660f, -0.05775096f, 0.02119536f, -0.04866796f, -0.01027356f, 0.03503604f, 0.04333487f, 
    0.00703688f, 0.01902032f, 0.00770303f, 0.00488373f, 0.02623423f, -0.04314180f, 0.00322047f, 0.02581066f, 
    -0.05100838f, 0.00537385f, -0.00829479f, -0.01017435f, 0.03245901f, -0.03042808f, -0.04489523f, -0.05782916f, 
    0.03152235f, -0.05380529f, 0.00876129f, -0.00468657f, -0.05140504f, 0.02526483f, 0.00049056f, 0.01519875f, 
    0.01655742f, -0.00432387f, 0.01707743f, 0.04493234f, -0.00311947f, -0.00482648f, 0.02800300f, -0.03143016f, 
    0.02694980f, -0.04225971f, -0.00838293f, -0.03064742f, -0.02651842f, -0.06120681f, -0.02080272f, 0.02058506f, 
    -0.00360377f, -0.05547056f, -0.00518328f, -0.02519984f, 0.00872178f, -0.05034710f, 0.03879380f, 0.03998929f, 
    -0.00828235f, -0.04015781f, -0.04242876f, -0.02778967f, -0.05878883f, -0.03727533f, 0.01465428f, -0.05879651f, 
    -0.04054827f, -0.02032745f, -0.03711806f, -0.03084869f, -0.05702985f, -0.05035369f, 0.03744335f, 0.00595123f, 
    -0.05127526f, 0.01341212f, 0.02959943f, -0.05187410f, -0.06259994f, 0.01160269f, 0.04252494f, -0.06182792f, 
    -0.03184299f, -0.05915375f, -0.00105927f, 0.02464891f, -0.00768018f, -0.03821813f, 0.04309555f, -0.02613050f, 
    0.03705803f, -0.00315622f, 0.03497123f, -0.02918691f, 0.01560297f, -0.03254357f, 0.00315656f, -0.04709229f, 
    0.02276602f, 0.00394563f, -0.00586549f, 0.02576954f, -0.03361699f, 0.03405670f, -0.02249101f, 0.01343613f, 
    0.04722187f, -0.02204495f, 0.04101449f, -0.02089773f, -0.02179231f, -0.05141030f, -0.01214634f, -0.01162753f, 
    -0.01390940f, -0.00342988f, 0.01608664f, -0.03350213f, -0.05934546f, -0.02984495f, 0.02457867f, -0.03461085f, 
    0.00586969f, -0.05011810f, -0.02237021f, -0.01966247f, 0.00531296f, 0.01109127f, 0.01654381f, -0.03282723f, 
    -0.06052199f, -0.03006797f, 0.02430917f, 0.04846184f, 0.01482057f, -0.03758848f, -0.04576718f, 0.04084593f, 
    -0.04681354f, 0.00958587f, -0.02357057f, -0.01184302f, -0.05770309f, 0.00300362f, -0.00445164f, -0.03489275f, 
    0.01476607f, 0.04768520f, -0.03608991f, -0.00968182f, 0.03605523f, 0.00246515f, 0.01506621f, -0.04529645f, 
    0.03876131f, 0.00321698f, 0.04447016f, -0.03039024f, 0.02142708f, -0.03723267f, -0.02963549f, -0.00525154f, 
    0.03526245f, 0.01128175f, 0.02685420f, -0.00635786f, -0.01398323f, -0.02105126f, 0.03836166f, 0.03965937f, 
    0.00122995f, 0.04844856f, -0.03722522f, -0.05666562f, 0.01662921f, -0.01414390f, 0.02655361f, -0.00688517f, 
    -0.02247097f, -0.04004421f, 0.04456516f, -0.01792876f, -0.04070525f, 0.00973183f, -0.04156964f, 0.02662071f, 
    -0.01166674f, -0.05558299f, -0.01735451f, -0.02395474f, -0.03863243f, -0.01637658f, 0.01570358f, -0.02620226f, 
    0.03549332f, 0.09605338f, 0.34831783f, 0.08058180f, 0.02930997f, 0.09194107f, 0.06643647f, 0.08315517f, 
    0.04221098f, 0.12298613f, -0.08806638f, 0.00335074f, 0.01243391f, 0.14566608f, 0.05016875f, -0.03340635f, 
    -0.07222445f, -0.03556172f, -0.03612654f, -0.06239527f, -0.16698144f, -0.14571074f, -0.04530091f, 0.03708824f, 
    0.36508647f, -0.01304070f, 0.15963387f, -0.03367360f, -0.14269662f, -0.00235371f, 0.11430445f, 0.11184588f, 
    -0.08603250f, 0.15674588f, -0.21443471f, -0.01761501f, -0.00258013f, 0.12030020f, 0.11683997f, -0.03560265f, 
    -0.42301628f, 0.41141349f, 0.48698112f, 0.09056447f, 0.17805973f, -0.04665946f, 0.00675937f, -0.00958052f, 
    -0.00777634f, 0.13601983f, -0.15269007f, 0.03499676f, 0.03243004f, -0.06471930f, -0.09743672f, -0.20988946f, 
    -0.20086083f, -0.08536837f, -0.07398866f, -0.08293539f, -0.14988801f, 0.09680218f, 0.13898411f, -0.03904071f, 
    0.01176951f, -0.09566191f, 0.01503468f, 0.15726396f, 0.02618481f, 0.04922413f, -0.06966121f, 0.03951416f, 
    0.17168973f, 0.06918196f, 0.08698622f, 0.09915440f, 0.00564956f, -0.02067794f, -0.18007125f, -0.04130782f, 
    -0.03317887f, -0.18124095f, -0.36243075f, -0.07605821f, 0.04455820f, -0.02377627f, -0.02987868f, -0.04600330f, 
    -0.08066827f, -0.10608418f, -0.16937442f, -0.04289765f, -0.04077508f, -0.04588601f, -0.11458849f, -0.11179882f, 
    -0.20507683f, 0.29382828f, 0.17946893f, 0.13179408f, -0.11779001f, -0.03529769f, 0.13093029f, -0.01352627f, 
    0.01942748f, -0.08835597f, -0.00168393f, 0.04856559f, 0.07615400f, 0.07719593f, 0.03829549f, 0.04660746f, 
    -0.13154103f, -0.00687920f, -0.01592850f, -0.10206743f, -0.09971954f, -0.03850541f, 0.04214879f, -0.16761577f, 
    -0.29707739f, -0.05048808f, -0.13235645f, -0.09687491f, -0.00802608f, -0.12896320f, 0.00646635f, -0.09404476f, 
    0.00722149f, -0.04011090f, 0.01653189f, 0.01167931f, 0.03489527f, -0.15993233f, -0.01997440f, 0.02772629f, 
    -0.04863724f, 0.16007835f, 0.12216996f, 0.11222941f, 0.20614851f, -0.10292768f, 0.16480352f, -0.16793509f, 
    0.10261025f, -0.11626506f, 0.01414391f, -0.00617901f, -0.11315103f, 0.01358281f, 0.04936251f, 0.12970741f, 
    0.19564824f, -0.15265566f, 0.09645543f, 0.21377723f, 0.05176758f, 0.01974495f, 0.10626786f, 0.06528760f, 
    -0.04065769f, -0.01819582f, -0.01029748f, -0.03581486f, 0.01634761f, -0.02418206f, -0.13314858f, -0.02125267f, 
    0.01783767f, 0.00713851f, -0.03975089f, 0.05028383f, 0.27105150f, 0.07955006f, -0.05319034f, 0.16783722f, 
    0.13078403f, 0.23605751f, 0.00960757f, 0.25605211f, -0.14639710f, 0.18953301f, -0.23684029f, 0.03168012f, 
    0.10887063f, 0.04391510f, 0.10076571f, -0.06188827f, 0.02394281f, 0.12569311f, -0.17123690f, -0.06505972f, 
    -0.01108940f, 0.18565668f, -0.03109236f, 0.00755457f, 0.10086051f, 0.21970497f, 0.09907931f, 0.02511218f, 
    -0.00454353f, 0.11368138f, 0.46856695f, 0.15940382f, 0.34171492f, 0.03250094f, 0.13085073f, 0.03148796f, 
    0.16857427f, 0.23954149f, -0.10256240f, -0.01754590f, 0.08461446f, 0.08230691f, 0.08368716f, -0.11474697f, 
    -0.15346566f, -0.14210112f, 0.12726921f, 0.01871603f, 0.18993448f, 0.39231259f, -0.20420192f, -0.26341349f, 
    0.16622542f, 0.03093782f, 0.08285679f, 0.29437324f, 0.23227946f, -0.09038088f, 0.01017442f, -0.06436265f, 
    -0.12653407f, 0.12805673f, 0.00526697f, 0.10065345f, 0.14206170f, 0.00405198f, 0.01767886f, -0.22336647f, 
    0.29446048f, -0.20415640f, -0.09419058f, 0.02738707f, 0.14516418f, -0.05173272f, 0.09055593f, 0.09273946f, 
    0.01471399f, -0.02272599f, 0.06745027f, 0.00740952f, 0.03182971f, -0.12753557f, 0.01991217f, -0.13486308f, 
    -0.05914014f, -0.03957064f, 0.09086332f, -0.03841798f, 0.02454365f, 0.11398410f, 0.46440288f, 0.09171554f, 
    0.15917665f, -0.09054737f, -0.03070405f, -0.03509295f, 0.25700492f, -0.18201272f, -0.00192336f, 0.05707978f, 
    0.05970212f, 0.09060933f, 0.05955530f, 0.02296520f, 0.15750986f, 0.07935376f, 0.07848552f, -0.00416941f, 
    -0.32119545f, 0.11223341f, -0.60043430f, 0.29790887f, -0.26391983f, 0.07327551f, -0.02488576f, 0.00596180f, 
    0.06571808f, -0.11243954f, 0.00756613f, 0.00395077f, -0.08119814f, -0.05411604f, -0.01067921f, -0.03398244f, 
    -0.01199308f, 0.34142724f, -0.07754587f, -0.01405815f, 0.04844721f, -0.26137599f, -0.35465169f, -0.14075488f, 
    0.01448733f, -0.09683830f, 0.03478513f, -0.06944407f, -0.02714556f, -0.14831212f, -0.08589662f, -0.04307147f, 
    0.06508019f, -0.05197766f, -0.04762556f, 0.04350819f, -0.00791257f, 0.22659555f, 0.19245259f, 0.14625673f, 
    0.14301942f, -0.03331759f, -0.07286485f, -0.06035768f, 0.10206657f, 0.10549901f, -0.04528451f, -0.06694116f, 
    0.03182865f, 0.07826323f, -0.12010622f, -0.02803759f, 0.02733024f, -0.08454911f, 0.04161121f, -0.00736552f, 
    -0.15378681f, -0.00451817f, 0.13924511f, -0.09860715f, -0.26085925f, 0.00489969f, -0.14566036f, 0.38731021f, 
    0.13212688f, 0.19065523f, 0.02919072f, 0.27107078f, 0.13410664f, 0.04216599f, 0.12177978f, -0.01853514f, 
    0.14736038f, 0.06768774f, -0.16215006f, -0.23462239f, 0.06379293f, 0.05136545f, -0.11739442f, -0.13885875f, 
    0.03603609f, 0.12389930f, 0.23238455f, 0.28244263f, -0.10906519f, -0.11494539f, -0.00718888f, 0.25714174f, 
    0.16342139f, -0.27403590f, -0.02921855f, -0.06540016f, 0.09647459f, -0.02517300f, 0.00405865f, 0.05186469f, 
    0.01550804f, 0.00408580f, 0.00285429f, 0.02588588f, 0.41734341f, -0.14133175f, -0.28874186f, -0.21998495f, 
    -0.00790984f, -0.03563666f, 0.02013923f, 0.04545232f, 0.03920713f, 0.09252141f, -0.04051051f, 0.04707883f, 
    0.06324554f, 0.00691586f, 0.03895849f, -0.01299421f, -0.00941829f, -0.01398457f, 0.14381664f, 0.05610881f, 
    -0.08747227f, 0.06252476f, 0.11640098f, 0.17084399f, 0.00418728f, 0.09190096f, -0.05058094f, 0.10326472f, 
    0.03547580f, -0.00781549f, -0.01125180f, -0.03164179f, 0.03219524f, -0.19620529f, -0.05253079f, -0.09341162f, 
    -0.05662106f, 0.11397888f, 0.07976113f, 0.30314073f, -0.05520966f, -0.01941644f, -0.00847398f, -0.04621219f, 
    0.06111862f, -0.00443673f, 0.05516974f, 0.14651190f, 0.07546697f, 0.12012807f, -0.08701501f, 0.13302739f, 
    -0.01132890f, 0.05636499f, -0.02968579f, -0.10565589f, -0.13551839f, 0.02487092f, -0.07087928f, -0.13915771f, 
    -0.06689616f, 0.24011026f, 0.11425216f, 0.05559790f, -0.04919534f, -0.05368534f, -0.02343526f, 0.05667708f, 
    0.01815739f, -0.01593893f, -0.02723028f, -0.02377622f, -0.02724242f, -0.04608480f, -0.02086136f, -0.00460970f, 
    -0.03699145f, 0.01587564f, -0.16114609f, 0.07789648f, -0.55759203f, -0.41276509f, -0.11418201f, 0.12892509f, 
    0.14752528f, 0.05819254f, -0.11810381f, 0.06874786f, 0.02276044f, -0.07497077f, 0.10330575f, 0.11419648f, 
    0.04388265f, 0.09815086f, 0.15504099f, 0.26375160f, 0.17470521f, -0.10146206f, 0.05188033f, 0.18018778f, 
    0.50829279f, 0.23712952f, -0.04327976f, 0.20090814f, -0.87644541f, 0.05906166f, -0.06230104f, -0.13989659f, 
    -0.03886787f, -0.10609565f, 0.02384077f, 0.03383694f, 0.00587467f, 0.04561691f, 0.08581026f, 0.08619267f, 
    -0.10596625f, 0.12805395f, 0.05653736f, -0.06731813f, 0.28048366f, -0.14209923f, 0.36909065f, 0.34401411f, 
    0.15568262f, -0.06533485f, -0.07389797f, 0.16098692f, 0.02697374f, -0.07039730f, 0.10577519f, -0.01646276f, 
    0.05625487f, -0.00302238f, -0.16714266f, 0.23669513f, 0.07302319f, 0.05933180f, -0.17146181f, -0.07921800f, 
    -0.50908339f, -0.32669076f, 0.41575566f, 0.15089411f, 0.04272003f, 0.00790150f, -0.00610717f, 0.13206612f, 
    0.16173331f, 0.08298869f, 0.05692325f, 0.00593834f, -0.04913484f, -0.11487137f, -0.01990595f, 0.07207960f, 
    0.06729127f, -0.09122964f, 0.04250062f, 0.09945425f, 0.13865992f, -0.06219541f, 0.35544631f, -0.22473668f, 
    0.22357410f, -0.06272509f, -0.01039341f, -0.06344417f, -0.16408934f, 0.00507655f, 0.03286842f, -0.04076254f, 
    0.00031972f, 0.07142802f, -0.17218602f, -0.01827879f, 0.11770123f, 0.13978459f, -0.08173992f, 0.07411305f, 
    0.10413651f, -0.15361768f, 0.14250089f, 0.05886776f, -0.11085011f, -0.05101095f, -0.03998924f, -0.31529641f, 
    0.01493029f, 0.07692248f, -0.05174014f, -0.09236121f, 0.05684848f, 0.07936153f, -0.04712404f, 0.20116323f, 
    -0.15758710f, -0.21450078f, -0.01112143f, -0.03639713f, 0.14846225f, -0.22730458f, -0.20594718f, -0.11589900f, 
    -0.18686746f, 0.13281652f, -0.11709974f, -0.12146589f, 0.02082748f, 0.02891905f, -0.07233326f, 0.08651452f, 
    0.03667893f, 0.08280310f, 0.07175580f, -0.02552294f, 0.06981295f, 0.07817311f, 0.21126989f, 0.00937658f, 
    -0.18720759f, 0.12060579f, 0.07461455f, -0.08915217f, -0.08679147f, -0.12300935f, 0.02722202f, 0.13154964f, 
    -0.02676078f, -0.13724765f, -0.02518859f, -0.13557962f, 0.12812880f, -0.03754580f, 0.01851462f, -0.12850004f, 
    -0.01396460f, 0.08484056f, 0.06070492f, -0.10367242f, -0.18823752f, 0.12753311f, 0.13922541f, 0.06451918f, 
    -0.19701447f, 0.19631368f, -0.13440232f, -0.11486271f, -0.06493785f, -0.01522136f, -0.13079104f, -0.04607156f, 
    -0.00853421f, -0.06343424f, 0.03804646f, -0.27866668f, -0.08588075f, -0.10197987f, 0.03687609f, 0.31677431f, 
    -0.12609747f, -0.07195272f, 0.05954064f, -0.01560603f, -0.10030089f, -0.07676631f, 0.03366901f, -0.09569582f, 
    -0.01825569f, -0.09347617f, -0.04843180f, -0.04438095f, -0.10559700f, -0.00377234f, 0.10085821f, 0.01732753f, 
    0.00443394f, -0.04307866f, -0.02278401f, -0.03217298f, 0.11560637f, 0.00091419f, 0.21512111f, -0.06657886f, 
    0.18368024f, 0.08876695f, -0.05887747f, -0.08010375f, -0.02858158f, -0.02312207f, 0.13688305f, 0.05821139f, 
    -0.04591815f, 0.05601580f, 0.10145332f, 0.12285244f, 0.18277398f, -0.02846987f, 0.04462090f, 0.20192996f, 
    -0.62177765f, 0.10830188f, -0.11073261f, -0.12155870f, 0.22622612f, 0.04613938f, 0.01885409f, 0.13963462f, 
    -0.05686083f, 0.23298426f, 0.01373056f, 0.01854419f, -0.01084303f, -0.07487003f, -0.06538621f, -0.00769051f, 
    -0.02274634f, -0.02151410f, -0.02525549f, 0.04747048f, -0.35514525f, 0.04601528f, 0.16706395f, -0.03465581f, 
    -0.18765488f, 0.07512038f, -0.02208685f, -0.09785718f, 0.01013115f, 0.00597568f, -0.06006341f, -0.14806907f, 
    -0.05422248f, 0.00088702f, -0.06815542f, -0.00324908f, 0.02179538f, 0.09404866f, -0.03791331f, -0.08301091f, 
    0.07862385f, -0.06125604f, -0.07289468f, -0.17300382f, 0.00796671f, -0.05443061f, -0.12698713f, 0.02621154f, 
    -0.02989458f, -0.11246489f, -0.05240421f, -0.00369662f, -0.06665298f, -0.12074132f, -0.01046209f, -0.00613580f, 
    0.00896829f, 0.04090321f, -0.01432245f, -0.09013493f, 0.20143619f, -0.00291079f, -0.30906549f, -0.03228425f, 
    -0.27279854f, -0.19815637f, -0.13954951f, -0.15360102f, -0.05136290f, -0.11006933f, 0.00601919f, 0.03495702f, 
    0.10560109f, -0.10509845f, 0.10403556f, -0.11267742f, 0.06361373f, -0.11088965f, 0.02473695f, 0.02582150f, 
    0.13230945f, -0.03784443f, -0.21599019f, -0.10334371f, 0.19886391f, -0.01749664f, 0.13095149f, -0.02527422f, 
    0.03510723f, 0.05288095f, 0.07291464f, 0.10477345f, 0.00646224f, -0.04123824f, 0.05786296f, -0.08815345f, 
    -0.00167711f, 0.25225174f, 0.00420121f, 0.00126486f, -0.05066714f, 0.29739630f, 0.15053776f, -0.31344685f, 
    0.10393247f, 0.00048837f, 0.03860129f, -0.13686864f, 0.08998179f, -0.05519155f, -0.14367712f, 0.14559108f, 
    -0.04099353f, -0.02953427f, -0.05237018f, 0.01965361f, -0.11910553f, 0.06514789f, 0.08021696f, -0.16178368f, 
    -0.31333700f, 0.25471130f, 0.11689700f, -0.02979008f, 0.28013617f, 0.01462211f, 0.09646887f, 0.00340087f, 
    -0.06880365f, 0.00587391f, 0.01647910f, 0.01256035f, 0.14734995f, -0.00879576f, 0.01332046f, 0.09134033f, 
    0.03773131f, 0.09770328f, 0.11606018f, -0.05178038f, -0.05217844f, 0.21862507f, 0.04832246f, -0.11367676f, 
    -0.00173559f, 0.15405363f, 0.01280620f, 0.01012515f, -0.10525491f, 0.05449357f, -0.07447971f, -0.07826479f, 
    0.03372365f, 0.09170185f, -0.00857977f, 0.00808733f, -0.02677123f, 0.17010260f, -0.00465103f, -0.22986528f, 
    -0.16530919f, 0.07170630f, -0.11390983f, -0.02549550f, 0.24317867f, -0.01485551f, 0.15941001f, 0.06816144f, 
    0.00220076f, 0.07785400f, 0.03603031f, 0.04929169f, 0.03830532f, 0.07073713f, 0.04808640f, -0.07032911f, 
    -0.01450862f, -0.06763429f, 0.04000691f, -0.13035798f, 0.43977550f, 0.03575254f, 0.11066900f, -0.01558394f, 
    0.09743404f, -0.02505912f, 0.15720610f, 0.03701086f, 0.05409674f, 0.10891971f, 0.01782847f, 0.11116105f, 
    -0.04629857f, -0.05158224f, 0.16325553f, -0.00202380f, -0.03899881f, 0.07028300f, 0.00179873f, 0.03331267f, 
    0.15812264f, 0.03641893f, -0.12192401f, -0.06986699f, 0.03862064f, 0.05652681f, -0.06679217f, -0.17123961f, 
    -0.00332628f, -0.11256116f, -0.10088552f, 0.01323617f, 0.07601386f, 0.01701011f, 0.14513351f, -0.09381868f, 
    0.04300373f, 0.10654610f, 0.06535980f, 0.15746979f, 0.14349659f, -0.10022703f, 0.36548015f, 0.36514455f, 
    0.12201914f, -0.05153917f, 0.09972603f, -0.23691076f, 0.09951824f, -0.14085549f, -0.03622732f, 0.09111949f, 
    -0.05773654f, -0.02709457f, 0.05912127f, -0.00778536f, 0.02022129f, -0.01375155f, 0.14662589f, -0.09446260f, 
    0.18567228f, 0.00769681f, -0.48333693f, 0.30049461f, -0.04356332f, 0.07600521f, -0.05715476f, -0.00203554f, 
    -0.11372357f, -0.02464446f, 0.08472867f, 0.14672440f, -0.09145387f, 0.02711644f, 0.08015920f, 0.17316224f, 
    -0.02415444f, 0.21966530f, 0.05683403f, 0.11658289f, 0.10699022f, -0.05242635f, -0.02560286f, -0.12316230f, 
    0.07716463f, -0.08807167f, -0.07521973f, -0.00893169f, 0.12755695f, -0.08992014f, 0.14018375f, -0.00102984f, 
    0.09993695f, 0.00185324f, 0.04146113f, 0.01885075f, -0.03350565f, -0.00644225f, 0.03136417f, -0.23241353f, 
    -0.01407206f, -0.01593160f, 0.03746607f, -0.01649421f, 0.01885918f, 0.02150752f, 0.03894993f, -0.02436298f, 
    0.03667175f, 0.03790518f, -0.06001786f, -0.00295271f, 0.03506198f, 0.02450740f, 0.02890816f, -0.03410487f, 
    0.01902675f, 0.03664432f, 0.02506652f, -0.06177524f, -0.03139905f, -0.06651948f, -0.04090063f, -0.02220755f, 
    -0.00239813f, 0.01509093f, -0.05528521f, -0.00104949f, 0.00417943f, -0.04424727f, 0.01433890f, 0.03048690f, 
    -0.03968962f, -0.04700029f, -0.01914483f, 0.01877075f, 0.02891547f, -0.05745000f, -0.03662650f, 0.00608662f, 
    -0.05135615f, -0.00082046f, 0.02569725f, 0.01289867f, -0.05811045f, -0.02608651f, -0.03986873f, 0.00705795f, 
    0.01616062f, 0.01005925f, 0.00669931f, -0.00727311f, 0.04551908f, -0.02771216f, -0.03979584f, -0.03273465f, 
    -0.01831599f, 0.01452850f, -0.05652738f, 0.02526247f, 0.02703623f, 0.02610873f, 0.03455584f, 0.01967467f, 
    -0.06889726f, 0.01629309f, -0.01543655f, -0.01707283f, -0.05868284f, -0.00591966f, 0.03676945f, -0.05037197f, 
    -0.00882824f, -0.03144603f, -0.01250984f, 0.04096597f, -0.01408262f, -0.04905657f, 0.01694279f, -0.01081218f, 
    0.03762405f, -0.04516862f, 0.00803048f, 0.04023298f, 0.04392840f, -0.02657028f, -0.01051047f, 0.01875926f, 
    -0.06607278f, 0.00407856f, -0.03203419f, -0.03365128f, 0.00703545f, -0.05649836f, -0.04442548f, -0.06111663f, 
    -0.05561816f, -0.00706035f, -0.01621766f, -0.02162513f, -0.00014037f, -0.02442368f, -0.03317302f, 0.00747138f, 
    0.01980190f, -0.06073520f, 0.02059063f, 0.03144845f, -0.00442234f, -0.04277403f, 0.03869309f, -0.04429945f, 
    -0.04271233f, -0.03682517f, -0.02662630f, -0.01810533f, -0.00067642f, -0.01842198f, -0.01545567f, 0.01452294f, 
    0.01682417f, -0.02252368f, -0.00368490f, 0.00514779f, 0.04033053f, -0.03695330f, -0.00610640f, 0.00880969f, 
    -0.03228495f, -0.04157777f, 0.02617839f, 0.00179196f, -0.01176237f, 0.01919067f, 0.03992067f, -0.01536156f, 
    0.02045904f, -0.02738040f, 0.00437208f, -0.05689079f, -0.01737762f, -0.03776884f, -0.01712833f, -0.00969489f, 
    0.03153272f, -0.02167735f, -0.06490575f, -0.05456273f, -0.05651686f, 0.00771551f, -0.02814198f, -0.06568354f, 
    0.00103241f, -0.01412970f, 0.00467951f, -0.00247733f, -0.03775039f, -0.02104057f, -0.01873156f, 0.00847579f, 
    -0.02166554f, -0.02062523f, 0.02076513f, 0.01511217f, -0.02620043f, -0.02260338f, 0.02936886f, -0.03053656f, 
    0.00661171f, 0.02298017f, 0.03384995f, -0.06678691f, -0.01893201f, -0.05635976f, -0.04376171f, -0.00650100f, 
    -0.05601332f, 0.04732613f, -0.06046048f, -0.04677086f, 0.02935078f, -0.03155427f, -0.01029062f, -0.01345776f, 
    0.01065741f, 0.03258241f, 0.02260661f, -0.04840831f, -0.03477741f, 0.00565357f, -0.04220311f, 0.01566215f, 
    0.03494706f, 0.04917475f, -0.02464289f, 0.00184918f, 0.03346646f, -0.05002825f, -0.05498229f, -0.00021103f, 
    0.03481044f, -0.01087502f, 0.01227310f, -0.03620554f, 0.02121867f, -0.02027716f, 0.00201222f, -0.05285283f, 
    0.00440181f, -0.00804969f, -0.01877702f, -0.03800478f, 0.01577012f, -0.04309669f, -0.05027478f, -0.01990960f, 
    0.00942360f, 0.02350065f, -0.06242912f, -0.06519336f, 0.01567456f, 0.00388503f, -0.02847840f, -0.06382087f, 
    -0.00601267f, -0.03922668f, -0.06589270f, -0.01601556f, -0.05806740f, 0.02848393f, 0.02695668f, -0.03867925f, 
    0.00223695f, 0.00266185f, -0.01257445f, -0.05741233f, -0.02074610f, -0.00854198f, -0.02318920f, 0.03564399f, 
    0.01859732f, -0.01138375f, -0.03476355f, -0.06881608f, -0.03137459f, 0.03985335f, -0.02143097f, -0.01025227f, 
    0.01364272f, 0.02954344f, 0.01137207f, -0.01175260f, 0.02131810f, -0.01536641f, 0.02419426f, 0.00999314f, 
    -0.05532996f, 0.02608316f, 0.03631424f, -0.02777225f, -0.03055889f, -0.02202711f, -0.06780780f, 0.02671822f, 
    -0.03739639f, -0.06344318f, 0.01979482f, 0.03656447f, -0.02735399f, 0.04339962f, -0.01488948f, -0.00588262f, 
    0.02893369f, -0.03772758f, -0.00636320f, 0.00977002f, -0.06103619f, 0.03133762f, -0.01430504f, -0.02118130f, 
    0.00505622f, -0.06162770f, 0.03076596f, -0.07136721f, -0.05609396f, 0.04172668f, 0.02933090f, 0.00613517f, 
    -0.00674224f, -0.00027901f, -0.00940637f, 0.01280865f, -0.01254581f, -0.03181715f, 0.03619419f, -0.06330684f, 
    -0.04549157f, -0.00059838f, 0.01913485f, -0.04969778f, -0.01771848f, -0.00018875f, -0.04382452f, 0.01228688f, 
    0.04167735f, 0.01157900f, -0.03204917f, 0.02350027f, -0.06294240f, -0.02753676f, -0.00094160f, -0.02584993f, 
    -0.01076158f, 0.01448086f, 0.02900977f, -0.06274030f, 0.01622087f, 0.00217624f, -0.00278449f, -0.03505704f, 
    -0.03409438f, -0.05819605f, -0.02945282f, 0.02996154f, -0.02531159f, -0.06302161f, 0.01805256f, 0.03102806f, 
    -0.02872174f, -0.04607690f, -0.03292276f, -0.04546593f, 0.00670227f, -0.04339070f, -0.05042325f, -0.00342740f, 
    0.04023479f, 0.01988004f, 0.03687198f, -0.06099303f, -0.02831799f, -0.04223136f, -0.03532381f, -0.05838120f, 
    -0.04960887f, 0.02643258f, -0.05074992f, -0.06272366f, 0.02907621f, 0.04610811f, -0.05180036f, -0.05376732f, 
    0.03176626f, -0.02481693f, -0.02045485f, -0.02687855f, -0.01605397f, -0.01839504f, 0.03529966f, -0.02981163f, 
    -0.03647785f, 0.02614439f, 0.02666405f, -0.02738665f, 0.02460549f, 0.03669711f, -0.01119004f, 0.01466827f, 
    -0.00706303f, 0.00835682f, -0.04936629f, -0.01635061f, 0.01408918f, -0.01581188f, -0.01325724f, -0.05120135f, 
    0.02310629f, 0.02356441f, -0.05322323f, -0.01835789f, 0.04153894f, 0.00990362f, 0.01343385f, 0.02579062f, 
    -0.01321814f, -0.01384550f, -0.04977552f, -0.01822719f, -0.05819661f, -0.05546359f, 0.01897285f, -0.02789439f, 
    -0.06078197f, 0.00935878f, -0.03147012f, -0.00109042f, -0.04640181f, -0.03834423f, 0.02168227f, -0.03973886f, 
    -0.03050816f, -0.00642879f, 0.01032958f, 0.04583110f, 0.02581952f, -0.03783055f, -0.01608055f, -0.03481393f, 
    -0.05568741f, -0.05218943f, 0.01453862f, -0.05611244f, 0.03654521f, 0.03991475f, -0.04853886f, -0.05476714f, 
    -0.03679975f, 0.00804249f, -0.03530612f, -0.06187321f, -0.05585572f, -0.00650611f, -0.05951510f, -0.04925570f, 
    0.04525109f, -0.00972137f, -0.05348705f, 0.01252736f, 0.03322158f, 0.02074136f, -0.02125841f, -0.01468109f, 
    -0.05522597f, 0.04530461f, -0.03660975f, -0.05988022f, -0.02633330f, -0.01496742f, -0.03640335f, 0.01349710f, 
    -0.01358796f, 0.00409891f, -0.05008121f, -0.01196901f, -0.02691524f, 0.04523233f, -0.06157485f, 0.03503137f, 
    0.03650381f, 0.03521906f, -0.00522950f, 0.04762991f, 0.00083327f, -0.01193045f, 0.01791684f, -0.04723407f, 
    0.02896002f, 0.01469620f, 0.01299728f, -0.03205827f, -0.02595367f, 0.03039128f, 0.02204606f, -0.00389505f, 
    0.03584842f, 0.04509920f, -0.05926527f, -0.02412974f, 0.03328324f, -0.05987363f, -0.03002437f, 0.02332490f, 
    0.02902375f, -0.00498004f, -0.02857007f, 0.01682070f, -0.01375316f, 0.04421860f, -0.05568105f, -0.03205042f, 
    -0.06004771f, 0.03246813f, 0.00722309f, -0.05970170f, -0.02203722f, 0.03440694f, -0.00219991f, -0.05690772f, 
    -0.05461695f, -0.02182177f, 0.02826174f, 0.02636721f, -0.05986536f, -0.00206007f, 0.01029736f, -0.05084957f, 
    -0.01601805f, 0.02702845f, 0.00501468f, -0.04699135f, 0.04302499f, 0.03448461f, -0.02626674f, -0.02526348f, 
    -0.01691950f, -0.00331383f, -0.05151179f, -0.01241580f, 0.04121082f, 0.04752067f, -0.03125210f, 0.03637275f, 
    0.04158264f, -0.05514214f, -0.00136934f, 0.04187424f, 0.03845203f, 0.02091448f, -0.01939197f, -0.02017529f, 
    -0.04498188f, 0.00848366f, 0.02491762f, 0.04216521f, 0.01860983f, -0.03628546f, -0.02663176f, 0.02250778f, 
    0.00072432f, 0.01793836f, -0.05956375f, 0.03246580f, -0.01271495f, -0.01028523f, -0.03461624f, -0.03002040f, 
    0.02281483f, -0.02780185f, -0.02765157f, -0.01149961f, 0.04787222f, -0.04921261f, -0.03148939f, -0.00831808f, 
    -0.04448612f, 0.04731398f, 0.04225849f, 0.01966537f, 0.01633169f, -0.04681914f, -0.04199491f, 0.02834771f, 
    -0.06327677f, -0.03096861f, 0.02033665f, 0.01194529f, 0.03717107f, 0.01069875f, -0.02303914f, -0.04889495f, 
    0.04623426f, 0.03127025f, 0.01110466f, 0.03187517f, 0.00310731f, 0.00438426f, -0.04303040f, -0.01090045f, 
    -0.06139772f, 0.02283772f, -0.04871300f, -0.00887897f, -0.01039932f, -0.01430336f, -0.04442946f, -0.05406247f, 
    0.01155604f, -0.01532718f, -0.02017006f, -0.01021548f, -0.01972013f, 0.04274045f, 0.04903333f, -0.01558615f, 
    -0.05899470f, 0.00826443f, 0.01939807f, -0.05762533f, 0.01780787f, -0.03219501f, 0.00584089f, 0.03904018f, 
    0.04507573f, -0.01041609f, -0.01782637f, -0.04526742f, 0.00331742f, 0.01808384f, -0.04960095f, -0.03204288f, 
    0.00551082f, -0.02966827f, 0.03354852f, -0.01753389f, 0.00896401f, 0.02062217f, -0.02837303f, -0.04372860f, 
    -0.06135761f, -0.02527202f, -0.02995791f, -0.05733815f, -0.06347932f, 0.01732732f, 0.04355547f, -0.00742466f, 
    -0.02162180f, 0.03654414f, -0.05344978f, 0.02736508f, 0.02650556f, -0.01841637f, -0.01665441f, -0.04060309f, 
    -0.03255667f, -0.00993687f, -0.03064957f, -0.05593808f, 0.03652841f, 0.00320127f, 0.04177064f, 0.04504982f, 
    -0.00642365f, 0.03511491f, 0.02317315f, 0.01753805f, -0.00007684f, 0.02573960f, -0.00626113f, 0.01728660f, 
    0.06463116f, -0.08249340f, -0.02098604f, -0.18630467f, 0.05898219f, 0.08428591f, -0.06592821f, -0.09115373f, 
    0.03246002f, -0.06458628f, 0.06635836f, 0.19490606f, -0.05820189f, 0.12180596f, 0.02193013f, 0.11578080f, 
    0.10910437f, 0.03941143f, 0.08005768f, -0.07172585f, -0.24555087f, 0.14636457f, -0.04435906f, 0.27908272f, 
    0.38065284f, 0.08814736f, 0.14116301f, 0.07224875f, 0.03207894f, 0.04377466f, -0.03716188f, 0.15552178f, 
    0.06512661f, -0.15629824f, -0.05608936f, -0.03159400f, 0.12140177f, 0.10456946f, -0.24016342f, -0.11145800f, 
    -0.09255777f, -0.10817582f, 0.13368608f, 0.15673432f, -0.08415771f, 0.02282040f, -0.13510233f, -0.01679567f, 
    -0.01508090f, -0.18803935f, 0.13430218f, 0.04481768f, 0.21566045f, 0.00861339f, -0.00064667f, -0.04938768f, 
    -0.11973611f, -0.09672316f, -0.08402839f, -0.02743390f, 0.17273512f, -0.08766994f, -0.14562565f, -0.21154286f, 
    -0.02985490f, -0.18880790f, -0.08176298f, 0.02614546f, -0.20917508f, -0.13491328f, -0.07487975f, 0.05895380f, 
    0.01425467f, -0.07019483f, -0.15700236f, 0.15330568f, 0.10380006f, 0.17139630f, 0.10025865f, -0.11961838f, 
    -0.03286544f, -0.16563092f, -0.10356756f, 0.13649759f, -0.12160753f, 0.01185292f, -0.21478786f, -0.09227113f, 
    -0.07480414f, 0.01267081f, -0.01771152f, 0.03995488f, -0.03779537f, -0.11234825f, 0.02500934f, -0.14260870f, 
    0.00939915f, 0.18309689f, -0.10208099f, 0.11187811f, -0.18819104f, -0.15595056f, -0.19282746f, -0.07003313f, 
    0.02771730f, 0.04756247f, 0.03400041f, -0.03414762f, 0.00280507f, -0.18192604f, 0.03457014f, 0.14623654f, 
    0.08254738f, 0.06646495f, -0.03639808f, -0.06934129f, -0.03576450f, -0.05382658f, -0.08851341f, -0.05990723f, 
    -0.21188641f, 0.07214765f, -0.01667179f, 0.11992688f, 0.08605605f, 0.02354706f, -0.01440133f, 0.04771866f, 
    0.05345066f, 0.06942806f, 0.00323730f, 0.04290622f, 0.07046942f, -0.03125225f, 0.05855675f, 0.13088836f, 
    0.03135123f, 0.07201266f, -0.11380686f, 0.01909747f, -0.54583484f, 0.07242555f, -0.03033289f, -0.06526162f, 
    0.21366894f, 0.08165682f, -0.01861432f, -0.16679148f, -0.11236492f, -0.04751675f, 0.01983060f, -0.01581907f, 
    -0.01089777f, -0.09187669f, -0.05631008f, 0.24715088f, -0.05630630f, 0.11208598f, 0.14721240f, -0.02444511f, 
    0.41547850f, 0.07253887f, 0.25664508f, -0.16059044f, -0.36775067f, -0.04117298f, -0.12986957f, -0.08558408f, 
    -0.15304188f, -0.03285148f, -0.13949668f, 0.04614697f, 0.09092604f, -0.04615462f, -0.04110021f, 0.24913013f, 
    0.21536584f, 0.33067700f, 0.17104496f, 0.11730697f, 0.03110578f, 0.24103762f, 0.34280559f, 0.15110530f, 
    0.03015903f, 0.11869179f, 0.03683695f, -0.19124967f, 0.28378847f, -0.02440015f, 0.08547526f, -0.07685301f, 
    0.07476450f, 0.02398990f, 0.07197051f, 0.12160595f, 0.11827553f, -0.01001958f, -0.10229691f, -0.10264365f, 
    -0.04237308f, 0.04357732f, 0.10488900f, 0.27812070f, 0.00093897f, 0.22440991f, -0.09520180f, -0.14596947f, 
    -0.13197532f, -0.14547393f, -0.02487629f, 0.00615590f, 0.05498658f, 0.18657647f, 0.26127672f, 0.14438225f, 
    -0.01641501f, -0.29395092f, 0.15606718f, 0.05031977f, 0.34307361f, 0.31416020f, -0.17098294f, -0.13992083f, 
    -0.10429607f, -0.01242782f, -0.11404720f, 0.01573466f, -0.20598097f, 0.13694888f, 0.13669559f, 0.09721892f, 
    -0.07107820f, 0.00647653f, -0.07284074f, 0.06221974f, 0.03261700f, -0.00642450f, -0.03677635f, 0.15640758f, 
    0.17760684f, 0.00939541f, -0.00244029f, -0.45537180f, 0.02332440f, -0.16870688f, 0.02360490f, -0.15545210f, 
    0.15306418f, 0.04048765f, 0.13174330f, -0.04208475f, -0.06133038f, -0.00137503f, -0.08778543f, 0.07467221f, 
    -0.07183784f, -0.03414391f, 0.16698106f, -0.06678333f, 0.36560318f, 0.07202373f, 0.43106961f, -0.11191181f, 
    -0.00496177f, -0.15241738f, -0.17106207f, -0.40451947f, 0.00955804f, 0.08451097f, 0.06973282f, 0.05758383f, 
    -0.17660215f, 0.18172576f, 0.01742454f, 0.00493898f, 0.22294828f, -0.09489426f, 0.22166458f, 0.06768331f, 
    -0.18002975f, 0.11145478f, -0.23305935f, 0.18774664f, -0.22561342f, -0.08973891f, -0.05537852f, 0.04899335f, 
    -0.25359383f, 0.00289006f, 0.02185633f, -0.09431516f, 0.01807815f, 0.07776148f, -0.09248833f, 0.06814101f, 
    -0.00604478f, 0.21935695f, 0.04033612f, -0.00269276f, -0.09882405f, -0.21020937f, -0.16046086f, -0.10101402f, 
    -0.13602026f, 0.19776814f, -0.18269561f, -0.14445935f, -0.08685008f, 0.04248260f, -0.08236483f, -0.01068744f, 
    -0.04639444f, 0.02916041f, 0.05335016f, -0.12684540f, 0.03677247f, 0.00183377f, -0.01473185f, 0.06486308f, 
    0.06950708f, -0.13086678f, -0.10180788f, 0.03355253f, 0.16805990f, 0.00200258f, -0.13064557f, -0.03752881f, 
    -0.12390517f, -0.09697594f, 0.13763136f, 0.06672295f, -0.15125245f, -0.00825197f, -0.09469346f, -0.11264227f, 
    0.00479186f, 0.01363554f, 0.01387134f, 0.12666939f, -0.14519329f, 0.12555632f, -0.03846628f, 0.03849776f, 
    0.10130330f, 0.08641772f, 0.02145183f, -0.11549834f, 0.18256186f, 0.10331047f, 0.06580417f, 0.08119174f, 
    0.06527698f, -0.03584825f, 0.00309380f, 0.01719988f, 0.09897953f, 0.09370877f, -0.04226503f, 0.22678345f, 
    -0.49351901f, 0.16352364f, 0.05770196f, -0.17599846f, -0.16553912f, 0.23027459f, 0.09686431f, 0.08156189f, 
    -0.07674558f, -0.11954203f, 0.02594615f, 0.05976343f, 0.02812254f, 0.04353586f, -0.11650480f, -0.08831344f, 
    -0.00833092f, 0.07395502f, 0.03807724f, 0.05845765f, 0.20354724f, 0.12170208f, 0.00783410f, 0.04826544f, 
    0.28892046f, 0.01092355f, 0.05757667f, -0.10959772f, -0.02831404f, -0.07129086f, -0.09139183f, -0.11463919f, 
    -0.09611974f, 0.00858812f, -0.07848144f, -0.10483585f, -0.01811286f, 0.08174124f, 0.13052577f, -0.20767555f, 
    0.17172958f, 0.22551507f, 0.13725638f, -0.16264769f, -0.10174092f, 0.18228455f, 0.04094627f, 0.00799364f, 
    -0.00257850f, -0.08694128f, -0.03364189f, -0.10024269f, 0.02036671f, 0.06284782f, 0.20202577f, -0.27604282f, 
    -0.04354411f, 0.04779600f, -0.08426756f, -0.07202112f, 0.03912217f, -0.12295392f, -0.02206814f, -0.06489179f, 
    -0.04519736f, -0.09205439f, -0.04361810f, -0.12568179f, 0.01144325f, -0.22883995f, -0.06284607f, -0.12327754f, 
    0.05740718f, -0.01660457f, -0.10556433f, -0.20417258f, 0.01537281f, -0.02757268f, -0.02245037f, 0.14694245f, 
    0.01318623f, 0.19357942f, -0.02724704f, -0.11060891f, -0.09887397f, 0.20069213f, 0.18886383f, 0.00395978f, 
    0.01661704f, 0.12761652f, -0.07332015f, 0.10610348f, 0.03533069f, 0.04481148f, 0.03395957f, -0.01993158f, 
    0.01850603f, 0.01873041f, 0.05859485f, 0.15882827f, -0.48346266f, 0.62571847f, 0.08349682f, 0.08899528f, 
    0.33175576f, -0.09793917f, -0.07354430f, 0.00101009f, -0.10319321f, 0.00159111f, -0.08212340f, -0.06814950f, 
    -0.05892607f, -0.01878667f, -0.02351899f, 0.02555596f, -0.13211811f, 0.03107308f, 0.16552933f, -0.15187411f, 
    0.30163270f, 0.33790487f, -0.07824276f, -0.16758016f, -0.04250000f, -0.09973483f, -0.09379046f, -0.03238584f, 
    0.09466899f, 0.04325284f, 0.05799977f, 0.11063258f, 0.02409068f, -0.14766356f, 0.02122826f, 0.05988575f, 
    0.02022146f, 0.08907678f, 0.19238985f, 0.07471053f, 0.29892504f, 0.35212034f, 0.24253397f, -0.25776482f, 
    -0.05657024f, -0.00512592f, 0.10845363f, -0.05923080f, 0.16388936f, -0.00996069f, -0.00681092f, 0.01273029f, 
    0.07104931f, -0.09340169f, 0.15247753f, 0.03788662f, -0.18015742f, -0.10622096f, 0.07312102f, -0.00473794f, 
    -0.31881222f, 0.22123466f, 0.14462455f, 0.09468336f, 0.04930897f, 0.12119850f, -0.13012581f, -0.03337321f, 
    -0.16401353f, -0.11739053f, 0.08591398f, 0.09250104f, 0.05023322f, 0.05946212f, 0.04259761f, -0.04861966f, 
    -0.00080319f, 0.01925682f, 0.14129555f, -0.02864942f, -0.01757564f, 0.02330852f, -0.08486158f, 0.00560233f, 
    -0.13469826f, -0.08484705f, -0.11608684f, 0.08774403f, -0.12663099f, 0.22379537f, 0.10235999f, 0.20800355f, 
    0.02555806f, 0.01750847f, -0.05637324f, 0.03972729f, 0.05439653f, -0.02592932f, -0.07361555f, 0.10876729f, 
    0.02272059f, -0.12343758f, 0.13268460f, -0.09284923f, 0.15997967f, 0.01346802f, -0.03107682f, 0.01589859f, 
    -0.01758784f, 0.07980325f, -0.04974947f, 0.06259721f, -0.08509851f, 0.07083791f, -0.13316882f, 0.00651603f, 
    -0.04819476f, 0.03603702f, 0.00196372f, -0.11516237f, 0.37803108f, 0.03963224f, 0.01005653f, -0.12050202f, 
    -0.10650710f, -0.11033247f, -0.05977089f, 0.04902702f, -0.03354508f, 0.13612449f, 0.07184604f, 0.00219319f, 
    -0.19728169f, 0.04377003f, -0.10247380f, 0.01004359f, 0.01308485f, -0.14204869f, -0.00124139f, -0.02036089f, 
    0.11856300f, 0.25939488f, -0.24449517f, -0.13586070f, -0.15691306f, -0.05944897f, -0.00404432f, -0.05343872f, 
    -0.16402285f, 0.11788943f, 0.05535503f, 0.02056498f, 0.06885020f, 0.07362118f, 0.00835762f, 0.00549221f, 
    0.11895819f, 0.04064669f, 0.05624950f, 0.34342593f, -0.04232593f, 0.15505895f, 0.01911895f, -0.09296054f, 
    -0.20175834f, 0.05475557f, 0.03703937f, 0.01125535f, -0.02347191f, 0.04137788f, -0.09285023f, 0.00699291f, 
    0.06943245f, 0.12430608f, 0.13478273f, -0.09411059f, -0.05399967f, -0.01132940f, -0.19561523f, -0.21985413f, 
    -0.22658154f, -0.07698269f, -0.02409636f, -0.00760499f, 0.02217966f, -0.14231452f, -0.10262278f, -0.05702992f, 
    -0.00250275f, -0.23523228f, 0.04323496f, 0.07377684f, -0.01419140f, -0.01507747f, 0.03872951f, 0.00839728f, 
    0.04331081f, 0.02404040f, -0.03219474f, 0.12342717f, 0.26980621f, -0.08743012f, 0.17868686f, 0.01725917f, 
    -0.06027785f, 0.13429542f, -0.05557498f, -0.17084762f, 0.14043118f, -0.01195689f, 0.06789944f, 0.03012090f, 
    0.06146767f, 0.01777876f, 0.05046310f, 0.15762934f, 0.09509759f, 0.00556455f, 0.13146336f, 0.29893556f, 
    -0.60961056f, 0.04961455f, -0.00186203f, -0.27614513f, 0.17604040f, -0.04879868f, 0.06544542f, 0.10181652f, 
    0.05920018f, 0.23278350f, -0.00441423f, 0.06080150f, -0.06386752f, -0.08856989f, -0.03005772f, 0.00147243f, 
    0.02213445f, -0.04469964f, 0.00008617f, 0.08354418f, -0.31533381f, 0.19645505f, 0.18510970f, 0.02313644f, 
    -0.25276437f, 0.04086729f, 0.00493026f, -0.23510726f, -0.05021025f, -0.10877439f, 0.02996527f, -0.16705556f, 
    -0.19623798f, 0.02968432f, 0.00636961f, -0.05433131f, -0.03535620f, 0.02958922f, -0.07572895f, -0.01436631f, 
    0.00415070f, -0.00345524f, -0.03487769f, -0.13619679f, -0.15184002f, 0.02067062f, -0.05527887f, -0.04606384f, 
    0.03483274f, -0.18360122f, -0.08282118f, -0.06453852f, -0.08257489f, 0.04279951f, 0.09078347f, -0.04884502f, 
    0.15280767f, 0.02591929f, -0.04044078f, -0.13173226f, 0.24945995f, -0.12274451f, -0.26112363f, -0.02186595f, 
    -0.22447112f, -0.15837792f, -0.10731825f, -0.12841389f, -0.08404753f, -0.09998811f, -0.06280567f, -0.04825129f, 
    0.06737413f, -0.16815493f, 0.02252172f, -0.08378677f, 0.24134137f, -0.05511017f, 0.16167502f, 0.20196816f, 
    0.14754625f, -0.12103417f, -0.24529193f, -0.12692517f, 0.06704963f, 0.05668533f, 0.15652934f, 0.06465262f, 
    0.10042994f, 0.12543957f, -0.03282733f, -0.05104956f, 0.03340278f, -0.08468560f, -0.02824195f, -0.09150454f, 
    0.08263736f, 0.05784223f, 0.04475781f, -0.06233478f, -0.15552816f, 0.32757881f, 0.15971671f, -0.16699879f, 
    0.05681487f, -0.09912432f, -0.03412301f, -0.17530847f, -0.02123077f, -0.14081302f, -0.02762669f, 0.12366685f, 
    -0.02217396f, -0.05888152f, -0.00053094f, -0.10406350f, -0.07831684f, -0.03261290f, 0.00335862f, -0.21955749f, 
    -0.24107663f, 0.22800127f, 0.16619372f, -0.15053485f, 0.21504015f, 0.00873939f, 0.04791451f, 0.04065210f, 
    -0.09467840f, 0.02369129f, -0.02220834f, 0.03034684f, 0.10904846f, -0.05947752f, 0.02950453f, 0.07374422f, 
    -0.06169154f, 0.10534765f, 0.06983603f, -0.01717641f, 0.03399899f, 0.01329579f, 0.04456865f, -0.13738540f, 
    -0.13208044f, 0.02610245f, -0.01242241f, -0.12030395f, -0.00621081f, -0.05978298f, -0.08996908f, -0.03621647f, 
    -0.02316441f, -0.01540882f, -0.02197709f, -0.01727558f, -0.11745413f, 0.09148174f, -0.13183422f, -0.16190052f, 
    -0.35656080f, 0.06940431f, -0.17156006f, -0.14002116f, 0.26644510f, -0.14487873f, 0.09290604f, -0.03791185f, 
    -0.02278842f, -0.02824346f, 0.13425635f, 0.10881124f, 0.04094061f, 0.15952320f, 0.06528819f, -0.07166817f, 
    0.02433211f, 0.04463592f, 0.03537062f, -0.11749771f, 0.16880777f, -0.03833469f, -0.15798049f, 0.20337704f, 
    -0.03816618f, -0.00639555f, 0.08494812f, 0.10289510f, -0.01900980f, 0.22517757f, 0.04905602f, 0.05631355f, 
    -0.06411414f, 0.01174999f, 0.00371870f, 0.10807869f, 0.00221873f, 0.12436196f, 0.00695678f, 0.19375311f, 
    -0.03905974f, -0.01637039f, -0.13058695f, -0.15083909f, 0.00412524f, 0.12152078f, -0.13271607f, -0.07358443f, 
    -0.09017816f, -0.13338228f, -0.05743451f, 0.01497337f, 0.01464167f, 0.07514386f, 0.07952958f, -0.02051620f, 
    0.06456555f, 0.21005954f, 0.03578955f, 0.09685158f, 0.03934454f, -0.08751597f, 0.11754335f, 0.16053018f, 
    0.11956692f, -0.02905317f, 0.07253665f, -0.06724817f, -0.01960183f, -0.11726792f, -0.06322676f, -0.00223923f, 
    0.02480273f, -0.01471432f, 0.05319418f, 0.01348424f, -0.05928107f, 0.01029715f, 0.00432708f, -0.04922637f, 
    0.36339498f, -0.14173131f, -0.29895633f, 0.12378619f, -0.05240512f, 0.05120399f, 0.09745023f, 0.00720311f, 
    -0.04404021f, -0.01324874f, 0.09351043f, 0.04462723f, -0.00724429f, 0.02349959f, 0.13853128f, 0.22067279f, 
    0.02009901f, 0.15099579f, 0.14226118f, 0.28800869f, -0.01891809f, -0.03041862f, 0.05543773f, -0.10773199f, 
    -0.07316059f, 0.05149193f, -0.01032270f, 0.05371149f, 0.07779727f, -0.15487975f, 0.13654266f, -0.03813375f, 
    0.11728945f, 0.04670506f, 0.07839222f, 0.03883973f, -0.03083944f, 0.01392843f, -0.03610510f, -0.25961629f, 
    -0.15686075f, 0.22058359f, 0.10293952f, 0.14331783f, -0.20533258f, -0.06974436f, 0.06611917f, -0.01299293f, 
    0.05893373f, -0.07291903f, -0.08749472f, 0.01791467f, -0.15047936f, 0.04515728f, 0.07671542f, 0.04192278f, 
    0.20872989f, 0.03454070f, -0.14200880f, -0.07844514f, 0.13673705f, 0.33468729f, 0.19236884f, -0.37422514f, 
    0.21351637f, 0.01858560f, 0.03966344f, 0.03756573f, -0.12303821f, -0.06569883f, -0.00865171f, 0.01439290f, 
    -0.07433823f, -0.03940335f, 0.04265526f, -0.08935598f, 0.04489895f, 0.08023524f, -0.05229386f, -0.05922054f, 
    0.02232687f, -0.20597641f, -0.50712657f, -0.22152285f, 0.10489551f, 0.32101151f, 0.08301906f, 0.03136819f, 
    -0.01329672f, 0.21694420f, -0.05065293f, -0.09790324f, -0.07678604f, -0.05865217f, -0.03979604f, 0.06423152f, 
    0.04938458f, -0.02161600f, 0.02071380f, 0.04778435f, -0.20156188f, 0.08365706f, 0.28263882f, 0.15503329f, 
    -0.27861774f, -0.00608888f, -0.00100933f, 0.01717430f, 0.01361946f, -0.03799353f, 0.03120485f, 0.00709142f, 
    0.07957572f, 0.03085120f, -0.03662575f, 0.09916052f, 0.07692701f, 0.00199656f, -0.16508715f, -0.04615391f, 
    0.31352419f, 0.10611817f, -0.17116053f, -0.27900183f, 0.23299710f, 0.04675921f, 0.02078057f, -0.02663776f, 
    -0.04802507f, 0.11201318f, 0.01585680f, -0.04571536f, -0.06991124f, -0.15089646f, -0.11589839f, 0.10612863f, 
    -0.01167178f, 0.11170532f, 0.10515510f, 0.05238595f, -0.21579711f, -0.03921284f, -0.10980994f, -0.03711040f, 
    -0.24011999f, -0.05582625f, 0.02098736f, 0.09040211f, -0.09053846f, -0.03411853f, 0.13931033f, 0.14023203f, 
    0.01564976f, -0.05358787f, 0.07245202f, -0.03807658f, 0.01780998f, -0.05100043f, 0.02542054f, 0.00485553f, 
    0.07816754f, -0.17469755f, -0.24127832f, -0.21062191f, 0.21245976f, 0.08410092f, -0.09195386f, -0.02242935f, 
    -0.04249113f, 0.04580585f, 0.00638364f, -0.07547954f, 0.04745153f, -0.01095849f, 0.02407613f, 0.06032583f, 
    -0.04147076f, 0.17861202f, -0.07127851f, -0.00429750f, 0.28544283f, 0.14098050f, 0.04737418f, -0.16198856f, 
    -0.03048722f, -0.18414901f, 0.19888872f, 0.03013113f, -0.03186391f, 0.02146281f, -0.15506402f, 0.02612709f, 
    0.08069848f, 0.08133832f, 0.10145470f, 0.07688957f, -0.00537458f, 0.07532244f, 0.06377552f, 0.00277978f, 
    -0.24817425f, -0.22252697f, 0.04268868f, 0.28087258f, 0.46776432f, -0.04411235f, -0.01782749f, 0.12296090f, 
    0.00471158f, -0.04124385f, -0.07838854f, -0.09294234f, 0.14095128f, 0.08224872f, 0.05551892f, 0.12069949f, 
    0.01738041f, 0.16129260f, 0.07996692f, 0.05121851f, 0.26194847f, 0.38114804f, -0.06547506f, -0.32006371f, 
    0.21474878f, 0.26848367f, 0.07256224f, 0.09139227f, 0.09778503f, 0.18036425f, -0.10094842f, 0.04134221f, 
    0.06130132f, 0.18161409f, 0.13988562f, 0.02229943f, 0.04592845f, 0.30999041f, 0.17410202f, 0.10096262f, 
    0.52202326f, -0.20184688f, -0.48005685f, -0.12049067f, -0.14169510f, 0.13905260f, 0.23115994f, 0.06332672f, 
    -0.05725901f, 0.12599835f, -0.21326868f, -0.03235374f, -0.00623494f, 0.09407686f, 0.00636279f, -0.04650887f, 
    -0.03665210f, -0.15609433f, 0.02764749f, 0.09148082f, 0.37788409f, 0.14223474f, 0.31496525f, -0.07199109f, 
    -0.15900725f, 0.03854465f, -0.14529023f, -0.11148902f, 0.09118699f, -0.27282599f, 0.16839521f, 0.03396509f, 
    -0.05797251f, 0.01636382f, 0.08462173f, 0.01477777f, 0.05597721f, -0.00498658f, 0.11457636f, -0.09570022f, 
    0.12831150f, 0.14786813f, 0.07355524f, 0.04876304f, -0.18824992f, -0.27372557f, -0.03084530f, -0.02937581f, 
    -0.00172572f, -0.02465860f, -0.07018663f, 0.04994212f, 0.09677777f, -0.18745568f, -0.04556563f, -0.08464548f, 
    0.14496461f, -0.10211860f, 0.16497791f, 0.06016035f, -0.16391654f, 0.15957682f, 0.60878628f, 0.45475313f, 
    0.19256835f, -0.19538760f, -0.09061699f, -0.21920836f, 0.15140657f, -0.18523189f, -0.01126743f, 0.15836011f, 
    -0.07714353f, 0.08035251f, 0.01609411f, -0.00548873f, 0.09644353f, -0.03964600f, -0.06677814f, -0.00258182f, 
    -0.28237137f, -0.06730585f, -0.22839613f, 0.26252875f, 0.09230442f, -0.02948654f, -0.17924184f, 0.16364878f, 
    -0.04463856f, -0.08227529f, -0.08690704f, 0.07179277f, -0.18460886f, 0.02084864f, -0.11220575f, 0.06083868f, 
    -0.01346383f, 0.14320086f, -0.09604347f, -0.07518397f, 0.19211929f, -0.14048147f, -0.12241482f, -0.11624492f, 
    0.17340313f, -0.19839683f, 0.03910910f, -0.10972372f, 0.02956648f, 0.08092470f, 0.01104272f, -0.05209379f, 
    -0.05488287f, 0.00669573f, -0.00074159f, 0.10117266f, 0.06624615f, 0.11987105f, 0.21193671f, -0.01457060f, 
    -0.15445299f, 0.03712867f, -0.07818960f, 0.10779480f, -0.03015798f, -0.18415703f, -0.00780334f, 0.00131706f, 
    -0.00027597f, -0.10502091f, 0.14649725f, 0.15473388f, 0.02206743f, 0.12403882f, 0.14760476f, 0.09773900f, 
    0.04813851f, 0.04573001f, 0.04082441f, 0.08968569f, 0.24801326f, -0.04142965f, 0.13552862f, -0.07092473f, 
    -0.31461197f, -0.00499479f, -0.00239058f, -0.06123197f, 0.13505220f, -0.00142776f, 0.01972286f, -0.00260724f, 
    0.02585185f, -0.10359229f, 0.11665054f, 0.17524901f, 0.07999168f, -0.05827978f, 0.08829511f, 0.25627139f, 
    -0.16153675f, -0.33217591f, -0.36151060f, -0.26452723f, -0.22680743f, 0.01595662f, 0.17376752f, 0.03829562f, 
    0.12887941f, 0.15350865f, 0.09411553f, -0.00147465f, -0.06952497f, 0.01712113f, -0.08809885f, -0.05345486f, 
    0.00957474f, -0.01374653f, -0.02129970f, -0.00556448f, -0.16491565f, 0.03813902f, 0.17203243f, 0.13175993f, 
    -0.03353375f, 0.00314492f, -0.10473458f, -0.13561045f, 0.00742350f, -0.08831495f, -0.00547409f, -0.10534276f, 
    -0.05735688f, 0.03495539f, 0.07513224f, -0.01992641f, 0.06702092f, 0.07047690f, 0.05879162f, -0.06601909f, 
    -0.01395853f, 0.14588867f, 0.22838067f, -0.03986009f, -0.22669427f, 0.06337853f, -0.09747134f, 0.00623959f, 
    0.06808273f, 0.01783085f, 0.00896345f, -0.11793946f, -0.05196951f, 0.19708481f, 0.14430714f, 0.08112882f, 
    0.13899417f, -0.01283118f, -0.04332871f, -0.23065703f, 0.07386012f, -0.05851594f, -0.09453484f, 0.10312303f, 
    -0.12225891f, -0.12501450f, -0.08253970f, -0.10770671f, -0.08253644f, 0.00150462f, 0.13336873f, 0.01706095f, 
    0.12323882f, -0.12751564f, -0.03461163f, -0.10184557f, 0.24835996f, 0.02575241f, 0.08421260f, 0.18759760f, 
    0.23561804f, -0.11294854f, -0.12981765f, -0.02426471f, -0.00009412f, 0.19918102f, 0.08641834f, 0.09877706f, 
    0.06172755f, 0.17265004f, -0.04636913f, -0.03424111f, -0.05714781f, 0.03079036f, -0.01786646f, -0.12200617f, 
    0.07678434f, -0.08581471f, 0.11117150f, 0.05424273f, -0.29558191f, 0.38001117f, 0.05887767f, -0.01888905f, 
    -0.03220848f, -0.17912266f, -0.09760793f, -0.01406410f, -0.14852227f, -0.10767834f, 0.01778569f, -0.07743505f, 
    -0.09918484f, -0.00976991f, -0.04290737f, -0.18448961f, -0.14844820f, 0.05241878f, -0.02535475f, -0.28803313f, 
    0.00282877f, -0.09666868f, -0.00223300f, -0.17352985f, 0.33291328f, 0.03875090f, -0.03604413f, 0.01800089f, 
    -0.01101593f, 0.06461252f, 0.04014207f, -0.08820432f, -0.02896221f, -0.08376466f, -0.09439534f, -0.09297170f, 
    -0.03951548f, -0.00850149f, 0.02893155f, 0.02211715f, 0.04199979f, -0.01888531f, 0.00858298f, -0.18981503f, 
    -0.14207159f, -0.04273330f, -0.01737799f, -0.09654287f, 0.07716972f, -0.09074475f, -0.02622060f, -0.10149765f, 
    -0.06834649f, 0.00137497f, 0.06681523f, 0.04140760f, -0.12918937f, -0.12191565f, -0.08937125f, -0.10132650f, 
    -0.21201687f, 0.00172100f, -0.49555764f, -0.10783573f, -0.10704745f, -0.19693691f, -0.05728056f, -0.10141445f, 
    -0.01989509f, -0.14520250f, 0.22914089f, 0.13209701f, 0.17163640f, 0.08838298f, 0.02573392f, -0.02155425f, 
    -0.03326042f, 0.10577019f, 0.07952055f, -0.17766568f, -0.06142376f, 0.08655050f, -0.05375699f, 0.28776184f, 
    -0.07983987f, 0.18278785f, -0.12820391f, 0.10131171f, -0.04701798f, 0.14467032f, 0.01960459f, 0.00771812f, 
    0.07786565f, -0.02187978f, -0.02762243f, 0.07423454f, 0.05192192f, 0.07630438f, -0.01642312f, 0.03324241f, 
    -0.18281621f, 0.15569888f, -0.07624053f, -0.01260272f, 0.04285119f, 0.10201890f, -0.20730118f, 0.11380395f, 
    -0.05120941f, -0.12633814f, -0.10268554f, -0.01376264f, 0.08349679f, 0.03686299f, 0.02254621f, 0.03335907f, 
    0.04578269f, 0.26737109f, -0.02669749f, 0.00904532f, -0.13220565f, 0.08340095f, -0.11097687f, -0.01118787f, 
    -0.00461612f, -0.02665260f, 0.04819186f, 0.14115459f, 0.02879919f, 0.11906691f, -0.05840348f, -0.01920780f, 
    0.00293394f, -0.04222491f, 0.03802030f, 0.11830295f, -0.00693309f, 0.01043428f, 0.02754906f, -0.14014180f, 
    0.52012867f, -0.21158472f, 0.19168131f, -0.09244414f, 0.12963982f, 0.15682647f, 0.11325920f, -0.08649499f, 
    -0.04589987f, 0.25545010f, 0.01178985f, 0.09789205f, 0.03903665f, 0.03949361f, 0.02766673f, 0.01223354f, 
    0.15349004f, -0.09810089f, 0.05880239f, 0.23360614f, 0.10805023f, 0.13385320f, 0.18702671f, 0.00072828f, 
    -0.03845518f, 0.07931618f, -0.03564791f, 0.16993779f, 0.02536849f, 0.08990984f, 0.10218107f, 0.03026579f, 
    0.09696622f, 0.11906931f, 0.00497623f, 0.05250391f, -0.00410552f, 0.03067459f, -0.17844667f, -0.36083519f, 
    -0.14727408f, -0.27391183f, -0.15700485f, -0.20160514f, -0.18859671f, 0.04975699f, -0.14223047f, -0.11865740f, 
    -0.02591694f, 0.05539146f, -0.05237333f, -0.01621671f, 0.04980750f, -0.06372364f, 0.03059527f, -0.00005060f, 
    0.07260789f, -0.12491178f, -0.03532390f, -0.12678170f, 0.20642005f, 0.39583284f, -0.02662740f, 0.05033714f, 
    0.47202510f, 0.05823318f, -0.08611175f, 0.08437111f, -0.20351066f, 0.03408475f, 0.04451162f, 0.04698220f, 
    -0.02336393f, -0.00527040f, 0.04782040f, -0.17052779f, -0.07547628f, -0.02731738f, -0.02099808f, -0.12433447f, 
    0.37052059f, -0.00325182f, 0.23036931f, 0.30366707f, 0.36387932f, 0.13444705f, 0.16639534f, 0.19222206f, 
    0.03965127f, 0.06511529f, 0.03485202f, 0.05725276f, 0.10628705f, -0.04874206f, 0.11037758f, -0.00763753f, 
    0.03695431f, 0.03512098f, 0.00634001f, -0.09837361f, -0.22893672f, -0.29050064f, -0.30294949f, -0.27575764f, 
    -0.37116534f, -0.01111258f, -0.07285912f, 0.06323142f, 0.05654031f, 0.02640138f, 0.01020198f, 0.11345795f, 
    0.03271237f, 0.07863137f, 0.04203568f, 0.03526223f, 0.01610420f, 0.05513041f, 0.03818495f, -0.02399566f, 
    -0.06876723f, -0.02076631f, -0.10774875f, 0.16675414f, 0.16673760f, -0.06896798f, 0.09131508f, 0.13953263f, 
    -0.01876685f, 0.06266110f, -0.01315466f, 0.07581539f, -0.00229737f, 0.02616795f, 0.07212882f, -0.04366310f, 
    0.00094014f, 0.01905458f, -0.00265459f, 0.20709337f, -0.00035257f, -0.12709962f, -0.05838631f, -0.12030233f, 
    -0.10526555f, 0.12576008f, 0.04524882f, 0.13310322f, -0.00115207f, 0.12577374f, 0.01262379f, 0.01206962f, 
    0.01119252f, -0.07560576f, 0.01683702f, 0.03029390f, -0.07139760f, 0.00816966f, -0.05858469f, -0.07975538f, 
    -0.05963852f, 0.23412675f, 0.01836378f, 0.00197896f, 0.40833545f, -0.01198924f, -0.01318969f, 0.08575303f, 
    -0.08498156f, -0.04791143f, -0.03266811f, -0.08634464f, -0.01934738f, 0.07733072f, 0.11845261f, 0.06902115f, 
    -0.02834676f, -0.09941310f, -0.06024071f, 0.06028471f, 0.67031229f, -0.45386115f, -0.09349813f, 0.19278944f, 
    -0.08468347f, 0.07812769f, 0.06354763f, 0.06131098f, 0.09480576f, 0.02126433f, -0.03520553f, 0.03271478f, 
    -0.00428861f, 0.02524778f, 0.11816732f, 0.15585241f, 0.01059275f, -0.02178834f, -0.10915919f, 0.16684248f, 
    -0.05612494f, 0.46916273f, 0.01841008f, 0.36819431f, -0.19319566f, -0.08886088f, 0.02087553f, -0.04466523f, 
    -0.12456083f, 0.02526630f, -0.05628184f, -0.02355298f, -0.03328902f, 0.21665354f, 0.00770500f, -0.05110040f, 
    0.12346673f, -0.17374109f, 0.05540298f, -0.06208562f, -0.09024848f, 0.20881818f, 0.24565180f, 0.15908392f, 
    0.32674748f, 0.00710598f, -0.12307328f, 0.15481293f, 0.05133901f, -0.06543545f, -0.04938962f, 0.14371541f, 
    -0.01752336f, -0.02128577f, -0.00080431f, -0.02769637f, 0.04745553f, 0.15408137f, 0.09142338f, 0.04221272f, 
    0.46953893f, -0.33027041f, 0.40637463f, -0.08292507f, 0.15399303f, 0.19668356f, 0.15882665f, 0.13381591f, 
    0.26538906f, 0.23097804f, -0.09866043f, 0.01241192f, -0.12401435f, -0.17320241f, 0.06244274f, 0.06768401f, 
    0.06379983f, -0.08702762f, -0.08372697f, -0.01008963f, -0.25014782f, -0.37347841f, 0.17952804f, -0.23909287f, 
    0.13541216f, -0.08849383f, 0.07423176f, -0.23850220f, -0.11538456f, -0.18996291f, -0.00853545f, -0.00984886f, 
    0.00709819f, 0.05681643f, 0.08801945f, -0.09268013f, -0.07335192f, -0.02555921f, 0.08153244f, -0.12591584f, 
    -0.17857809f, -0.09558284f, 0.15308672f, 0.02678190f, -0.12874939f, -0.12308381f, 0.05333428f, -0.25165147f, 
    0.04295072f, 0.05819122f, 0.00173337f, 0.06203158f, 0.01028351f, 0.10697397f, 0.01613074f, -0.13102853f, 
    -0.00112924f, -0.12996551f, -0.11835321f, 0.03360418f, -0.58465415f, -0.37570086f, 0.20206288f, -0.24276410f, 
    -0.11831792f, -0.07786384f, -0.06818895f, -0.11204613f, -0.06896161f, 0.04309941f, 0.02834584f, 0.03417350f, 
    0.14156835f, 0.04080883f, 0.05253463f, -0.11247025f, 0.00417221f, 0.14368644f, -0.03448901f, -0.07598320f, 
    -0.06284438f, 0.18379170f, -0.11191765f, 0.21430740f, 0.04956956f, -0.03407090f, 0.02100855f, 0.19190055f, 
    0.15862811f, 0.06377853f, -0.00962214f, 0.01185949f, 0.10855976f, 0.00889072f, -0.05684029f, -0.06826594f, 
    -0.03311852f, -0.01516683f, 0.15785299f, -0.24045181f, -0.16714321f, -0.06646871f, 0.00981542f, 0.01978335f, 
    0.11432787f, 0.00973474f, 0.05235380f, -0.01907642f, 0.02011414f, 0.04848370f, -0.01408725f, 0.02100383f, 
    -0.01200243f, 0.01380460f, 0.08896393f, -0.12993057f, -0.00146641f, 0.04308102f, 0.06719993f, 0.22987559f, 
    -0.05819188f, -0.37027872f, -0.38343635f, -0.08660004f, -0.04330556f, 0.01534124f, -0.13686466f, -0.03116219f, 
    -0.06038724f, -0.08505110f, 0.06864970f, 0.10472145f, 0.07255310f, -0.03507347f, 0.13992359f, -0.03877422f, 
    0.12205834f, -0.00922231f, -0.00196539f, 0.11156369f, -0.10108385f, 0.28652397f, -0.14423618f, 0.12573084f, 
    -0.04225146f, 0.11533893f, -0.08872951f, 0.07393175f, 0.18329683f, 0.06434049f, 0.05070043f, 0.01418146f, 
    0.09827884f, 0.05556270f, 0.00638419f, -0.06485119f, 0.07403179f, -0.06471538f, 0.07083070f, 0.08161857f, 
    0.31630185f, 0.12875399f, -0.30100247f, -0.04762418f, -0.21145600f, 0.03300501f, 0.10576704f, 0.06914878f, 
    0.08260984f, -0.09010454f, 0.05011971f, 0.08580819f, 0.10936967f, 0.04468891f, 0.00362334f, 0.00882808f, 
    0.00943361f, -0.02097376f, 0.04532804f, -0.03930189f, 0.15071145f, -0.38508800f, -0.42248613f, 0.05590533f, 
    0.20428267f, -0.09781324f, -0.06135503f, -0.09333092f, -0.15542148f, -0.11408447f, -0.10425056f, 0.09193213f, 
    0.02622648f, -0.00460562f, -0.04937557f, 0.00555902f, 0.01590904f, 0.08117457f, 0.16216527f, -0.02624620f, 
    0.09064111f, 0.27168152f, 0.19047251f, -0.02158432f, 0.01577517f, 0.14860915f, 0.08623795f, 0.09719837f, 
    0.08384389f, 0.05617193f, 0.03695836f, -0.04377085f, -0.03230046f, 0.08390802f, 0.13463193f, 0.06169514f, 
    -0.03095955f, -0.07065007f, -0.02510244f, 0.01250998f, -0.18918782f, -0.00971903f, -0.02702537f, -0.19407937f, 
    -0.07252058f, -0.02972711f, 0.09318877f, 0.02928734f, 0.06207665f, -0.05841440f, 0.01589559f, 0.12340208f, 
    0.15698391f, 0.11144052f, 0.00578739f, 0.01542327f, -0.04217465f, 0.07229201f, 0.04728791f, 0.08893104f, 
    0.13967313f, 0.27454710f, 0.15682489f, 0.07428812f, 0.06348161f, 0.10608401f, 0.07667501f, 0.15982993f, 
    0.06420541f, 0.10085618f, -0.11556619f, -0.00658979f, -0.02013632f, 0.05581820f, 0.03262870f, 0.04302102f, 
    -0.02229933f, -0.15156275f, 0.05740931f, 0.07703488f, -0.56761515f, 0.12896091f, -0.17237392f, 0.34217468f, 
    0.06533343f, -0.09668618f, -0.15657058f, -0.01267266f, -0.09318596f, -0.02098649f, 0.00199625f, -0.05203626f, 
    -0.11702655f, 0.10512482f, 0.05330002f, 0.09780184f, 0.06871572f, -0.00774500f, -0.02497546f, 0.08853052f, 
    0.45259270f, 0.11788186f, -0.06886110f, 0.12459185f, -0.12276551f, -0.08724248f, -0.06120684f, 0.06322023f, 
    -0.06825831f, 0.05832211f, 0.00472886f, 0.00552967f, -0.03536160f, 0.03146400f, 0.01089466f, -0.09902486f, 
    0.02305095f, -0.08323175f, 0.03916618f, 0.00447503f, 0.37512174f, 0.28552014f, 0.34691781f, -0.04490452f, 
    0.11268694f, -0.01845873f, -0.01020335f, 0.03236445f, 0.21680671f, 0.00812341f, 0.10521390f, 0.10612231f, 
    -0.06237881f, -0.11185687f, 0.10968515f, 0.09559273f, 0.00518897f, -0.19384167f, 0.09126177f, 0.11110516f, 
    0.23063457f, 0.14284760f, -0.01094690f, 0.08138333f, -0.11706191f, 0.11490899f, -0.04465367f, 0.05110885f, 
    -0.01560641f, -0.03206715f, 0.06125203f, 0.10622872f, -0.00891278f, 0.01681556f, 0.02893619f, 0.07174398f, 
    0.02208091f, 0.10739344f, -0.11303776f, 0.02096940f, -0.31806630f, -0.24341984f, 0.16677135f, 0.03327135f, 
    -0.09931533f, 0.04547522f, -0.02546632f, -0.07739426f, -0.21164767f, 0.09078412f, -0.03281668f, 0.13360952f, 
    0.02429879f, 0.18388221f, -0.02970636f, 0.14360465f, 0.06218554f, 0.03047950f, 0.02664680f, 0.16034782f, 
    -0.18244191f, -0.05043185f, 0.37283835f, 0.01662658f, -0.07681795f, -0.04806323f, 0.18898077f, 0.07285846f, 
    0.01367668f, 0.16365591f, -0.12852567f, 0.11630844f, -0.01536817f, 0.16901378f, 0.01148268f, 0.12896049f, 
    0.04056912f, -0.02835077f, -0.00871550f, -0.03789075f, -0.22621372f, -0.28382152f, -0.36229575f, -0.04270692f, 
    -0.31702480f, -0.00495464f, -0.13794775f, 0.07291401f, -0.12654373f, 0.20047900f, 0.03641601f, 0.02165235f, 
    -0.16370827f, 0.10450844f, -0.01003398f, -0.04098756f, 0.08598159f, 0.02662775f, -0.10776541f, 0.13940015f, 
    0.13892525f, 0.28757629f, 0.19752210f, -0.11429766f, -0.00179568f, -0.10389225f, 0.07557451f, 0.05214469f, 
    -0.01541294f, 0.19544314f, -0.01719368f, 0.03306727f, 0.16377744f, 0.03245051f, 0.03644639f, 0.00804981f, 
    0.09159336f, -0.01096276f, 0.08527508f, 0.07543734f, -0.07115627f, 0.33385801f, 0.15672459f, 0.02725413f, 
    -0.17765039f, 0.10876206f, 0.07719477f, 0.08638515f, -0.08169084f, 0.13773522f, -0.01851304f, -0.02128728f, 
    -0.07788560f, 0.05230887f, 0.10114151f, -0.01267179f, 0.06477958f, 0.06623954f, -0.10080449f, -0.05065767f, 
    -0.02272310f, 0.00210572f, 0.01607117f, 0.02968582f, 0.04668993f, -0.00628547f, -0.00155243f, -0.02860504f, 
    -0.00924687f, 0.02990014f, 0.03590347f, -0.04193825f, -0.02474790f, -0.02691467f, -0.03539561f, 0.00299274f, 
    0.02997438f, 0.02932260f, 0.03135096f, 0.01075713f, 0.02100512f, -0.03194242f, -0.02642677f, 0.02760836f, 
    0.03713788f, -0.06094005f, -0.02513185f, -0.05937482f, 0.03223865f, -0.03054905f, -0.01336688f, 0.02350820f, 
    -0.06312311f, 0.03627488f, -0.02485728f, -0.00390809f, -0.03273774f, 0.04341220f, 0.00509734f, 0.01753675f, 
    -0.02000696f, 0.00602819f, -0.02235067f, 0.01795315f, 0.03152185f, -0.06083691f, 0.03064112f, -0.02092383f, 
    -0.03585560f, -0.02520899f, -0.05844442f, 0.04135197f, -0.01494529f, 0.00323490f, -0.06375085f, 0.01847919f, 
    0.02748317f, -0.00102611f, 0.01480561f, 0.01894255f, -0.02419421f, -0.00389182f, 0.00294717f, 0.00906697f, 
    0.03416173f, 0.03799232f, 0.02767516f, -0.00803507f, -0.05785133f, 0.00831038f, 0.00072957f, -0.04381865f, 
    0.02391873f, -0.04944058f, -0.02807689f, -0.06171728f, -0.05269323f, 0.00657737f, 0.04880359f, 0.01236185f, 
    -0.01615389f, 0.00909307f, 0.02049739f, -0.03693641f, -0.02588488f, -0.00019165f, 0.02276578f, -0.03054604f, 
    -0.04563687f, -0.01338707f, -0.01226416f, 0.03156314f, -0.04267037f, -0.03878891f, 0.04554751f, 0.02543659f, 
    -0.02526493f, -0.06315880f, -0.04373243f, 0.05174460f, -0.03538243f, -0.01781216f, 0.01481488f, 0.02814948f, 
    -0.02733754f, 0.04966898f, -0.03085118f, 0.02968232f, -0.00714215f, -0.04470139f, -0.01657275f, -0.00525386f, 
    0.02614846f, 0.03833812f, -0.06936873f, 0.01213112f, 0.02550227f, 0.02913457f, 0.02556669f, 0.00570080f, 
    -0.05532319f, -0.03296283f, -0.01458849f, 0.02348987f, -0.07426930f, 0.01411646f, -0.02258284f, -0.00150059f, 
    -0.02941403f, -0.05692850f, -0.03902565f, 0.02669726f, -0.02825787f, -0.01126815f, 0.01968976f, -0.03562381f, 
    0.00749987f, -0.01153051f, -0.02895116f, 0.03788401f, 0.03713560f, -0.02300964f, 0.01022853f, -0.00668291f, 
    0.04953036f, -0.03933877f, -0.05507918f, -0.02394190f, -0.02241713f, -0.04549225f, 0.03192034f, 0.00089378f, 
    -0.00860443f, 0.00573655f, 0.02703540f, -0.00611114f, 0.00789591f, -0.04736353f, 0.03362829f, 0.04361086f, 
    0.04294638f, 0.03886489f, -0.04164799f, -0.06119060f, -0.01274017f, -0.03499666f, -0.01662937f, -0.00436814f, 
    0.00337952f, -0.05577955f, -0.05701447f, 0.04206903f, -0.03210974f, 0.00940451f, 0.03573421f, -0.05638094f, 
    -0.04783515f, 0.01176203f, 0.00941792f, 0.01473440f, 0.03530527f, -0.00673797f, 0.00890068f, 0.03838822f, 
    0.02744437f, -0.04228090f, -0.02418860f, 0.02060294f, 0.02576240f, -0.03320514f, -0.02149751f, -0.00109423f, 
    -0.00249081f, 0.02744628f, -0.01812270f, 0.00766019f, 0.04729338f, -0.04585749f, -0.01281583f, 0.00930113f, 
    0.03462837f, -0.00995401f, 0.01522020f, -0.05333632f, -0.06737144f, 0.02669640f, 0.02217673f, 0.02164074f, 
    -0.04043967f, -0.06267396f, -0.03869557f, 0.02785121f, -0.03752231f, -0.02941405f, -0.04008584f, -0.06251190f, 
    -0.00667466f, -0.01654240f, 0.03422323f, 0.04118012f, -0.00249005f, -0.00307042f, 0.00860981f, -0.05294120f, 
    -0.03130375f, 0.00789417f, -0.04604271f, 0.01548737f, -0.05293582f, -0.02693312f, 0.03476848f, -0.02789150f, 
    0.01301769f, -0.00551729f, -0.00249022f, -0.01061396f, 0.00642431f, 0.03126647f, -0.04003383f, -0.04680293f, 
    0.02249096f, -0.06280463f, -0.04988985f, 0.00757841f, 0.01182895f, -0.01598141f, -0.04301694f, -0.03754543f, 
    -0.06509624f, 0.03475074f, -0.04156546f, 0.01459162f, -0.01318036f, 0.01987865f, 0.01742410f, -0.01438798f, 
    0.03744897f, -0.03280335f, -0.03524047f, 0.03324655f, -0.00740632f, -0.02294971f, -0.07565004f, -0.02419495f, 
    -0.03744644f, 0.01863956f, -0.03284517f, -0.01381185f, -0.00417234f, -0.01192668f, -0.05448080f, 0.03706681f, 
    -0.06409924f, 0.00541023f, -0.04822539f, -0.03486723f, -0.00126574f, -0.02573724f, -0.04862207f, 0.01382264f, 
    -0.06295627f, 0.02533073f, -0.04563871f, 0.02087445f, -0.06521302f, -0.05219651f, -0.04343918f, 0.02683295f, 
    -0.03734061f, -0.05076593f, 0.02468261f, -0.06674287f, -0.03884003f, 0.02822568f, -0.06268209f, -0.01264273f, 
    -0.00339893f, 0.02420921f, -0.06255555f, -0.01694703f, -0.05042661f, -0.00010144f, -0.00777674f, -0.03139949f, 
    0.03452879f, -0.00933152f, -0.04890016f, -0.04344149f, -0.03785410f, -0.00229257f, -0.03641728f, -0.04794366f, 
    0.04150233f, 0.01844384f, 0.02200316f, -0.02932868f, 0.01114631f, -0.02842836f, 0.04246973f, 0.03748646f, 
    -0.16913559f, -0.23679666f, -0.32905492f, -0.33092031f, -0.06936529f, -0.01170113f, 0.03530431f, -0.04542537f, 
    -0.17031305f, -0.01626257f, 0.16301037f, -0.02849696f, 0.19858831f, 0.01151156f, 0.08356772f, 0.18899812f, 
    0.09520840f, -0.04989417f, -0.07700277f, -0.02585476f, 0.12745482f, 0.15040979f, 0.19205680f, 0.13466540f, 
    -0.06314172f, 0.01648291f, -0.08330920f, -0.06028886f, -0.09748675f, 0.04189708f, -0.07759971f, -0.03250557f, 
    -0.03329329f, 0.07975476f, 0.07656954f, -0.09775836f, -0.08352231f, -0.16380854f, 0.03574030f, 0.05541795f, 
    0.10637417f, 0.05287331f, 0.23891425f, 0.16573283f, 0.28130668f, 0.01364229f, 0.09535689f, 0.05545554f, 
    0.00163398f, 0.24344976f, 0.08751417f, 0.09670957f, -0.11535454f, -0.03305326f, 0.00396527f, -0.02181695f, 
    0.02843151f, 0.02265103f, -0.09951328f, -0.00655895f, -0.11622968f, -0.16512659f, -0.32849085f, -0.05355974f, 
    -0.18865068f, -0.01263575f, 0.00028982f, -0.04034319f, -0.02741878f, 0.00951120f, 0.01543701f, 0.03973741f, 
    0.08420312f, -0.11311777f, 0.03274118f, 0.04613663f, 0.02858648f, -0.06617676f, 0.05155379f, 0.13425398f, 
    -0.18610646f, -0.09881739f, 0.17363806f, 0.43407309f, 0.18941556f, -0.11663778f, 0.04216513f, 0.02284963f, 
    -0.00004981f, 0.03464095f, 0.00353739f, 0.07672974f, 0.02067901f, 0.04634489f, 0.09390147f, 0.09644891f, 
    0.17529887f, -0.11248580f, -0.10621718f, 0.02944503f, -0.04117651f, -0.08398782f, -0.14736104f, -0.04607126f, 
    -0.05876112f, 0.17428347f, 0.00462229f, 0.00977525f, 0.02003077f, 0.09063644f, 0.06523695f, -0.00590421f, 
    -0.10650863f, 0.01808636f, -0.04142962f, 0.18031992f, 0.02552908f, 0.13925049f, -0.10273055f, -0.01810413f, 
    0.00897890f, 0.13614365f, 0.20700367f, 0.19507621f, 0.38057429f, -0.05702228f, 0.12670366f, -0.04436215f, 
    0.01757277f, -0.00363680f, -0.04686798f, -0.01330277f, -0.09087580f, 0.00721371f, -0.02705186f, -0.02565839f, 
    0.03962236f, -0.03613192f, -0.09144199f, 0.03713101f, 0.52458298f, -0.11578394f, -0.00900189f, -0.03449210f, 
    -0.29263711f, 0.07740270f, -0.00632394f, -0.17821337f, 0.07353971f, -0.11783401f, -0.05243066f, -0.02964858f, 
    -0.08799114f, -0.03626820f, -0.08552735f, -0.12284907f, -0.10283554f, -0.01413288f, 0.02687063f, -0.00664973f, 
    -0.07260975f, 0.61108780f, 0.09021730f, -0.09046233f, -0.01496080f, 0.03028749f, 0.17187710f, -0.06416089f, 
    -0.08533213f, -0.12370548f, 0.10274558f, -0.05567578f, -0.06726407f, 0.04368541f, -0.03381036f, -0.10629956f, 
    -0.10193027f, -0.11370833f, -0.06938881f, -0.04798368f, -0.39848301f, -0.08940800f, 0.17398815f, 0.26496419f, 
    0.08771910f, 0.07127621f, 0.05053142f, 0.06873330f, -0.23429762f, -0.08163270f, -0.08351965f, 0.00374266f, 
    -0.16919722f, -0.03301135f, -0.02037224f, -0.12092789f, -0.02688251f, -0.00180205f, -0.05336938f, -0.01378171f, 
    0.10377490f, 0.23806757f, 0.17522106f, -0.08723469f, -0.00240972f, 0.10087968f, 0.05814821f, 0.10234851f, 
    0.04204011f, 0.24141496f, 0.05627985f, 0.01448642f, -0.04113197f, -0.11494210f, 0.04838040f, -0.08844621f, 
    -0.06763769f, 0.09910575f, -0.03966103f, -0.09361729f, -0.08440133f, -0.26560664f, -0.32421511f, 0.07138156f, 
    0.12240564f, -0.29556566f, 0.18968233f, -0.15502654f, -0.14328803f, 0.24780476f, -0.03129081f, 0.05626281f, 
    0.04699719f, -0.11512603f, 0.08785061f, -0.01060921f, -0.12806831f, -0.07108199f, -0.01153502f, 0.22174187f, 
    -0.14839414f, 0.01489572f, -0.09925622f, 0.01069326f, -0.05473850f, 0.18065886f, -0.08203329f, 0.01489351f, 
    0.07513368f, 0.01163162f, 0.08101387f, -0.00599082f, 0.00479705f, 0.14775132f, 0.16369401f, 0.05956589f, 
    0.02897188f, 0.07329087f, 0.07161935f, -0.03496886f, 0.08569042f, -0.06507590f, -0.19043010f, -0.12094501f, 
    0.11390188f, 0.06362145f, -0.00957970f, -0.05969578f, -0.24091569f, -0.03029881f, 0.06576009f, -0.05883516f, 
    0.16051343f, -0.02544093f, -0.04936304f, 0.01751000f, -0.13003103f, 0.12734859f, 0.07185898f, -0.07447924f, 
    0.20753312f, 0.13292633f, 0.27637127f, 0.18800907f, 0.27144805f, 0.07299251f, 0.14624378f, 0.06769653f, 
    0.20848103f, 0.09088109f, -0.09052786f, 0.00399068f, 0.06270377f, -0.03166830f, -0.02377485f, 0.01122656f, 
    -0.04612663f, 0.03440452f, -0.00667005f, 0.05370463f, -0.00430127f, 0.03140222f, 0.21692447f, 0.32404622f, 
    0.31516817f, 0.08177150f, 0.09138713f, 0.00765113f, 0.07275453f, 0.10892523f, 0.11668191f, 0.08285519f, 
    -0.04337408f, 0.00713609f, -0.03762520f, -0.00344363f, 0.10157807f, -0.08793307f, -0.04130687f, -0.02309008f, 
    0.04476259f, 0.03180579f, -0.05273644f, -0.02204697f, -0.04105880f, -0.02538141f, -0.02877728f, -0.04831908f, 
    -0.02613531f, 0.02902004f, 0.02607986f, -0.00164118f, -0.01878197f, 0.02939095f, 0.00634260f, -0.02261265f, 
    0.03464462f, -0.01881352f, 0.03686655f, -0.01100218f, 0.01623464f, -0.02395631f, -0.03110066f, -0.05436984f, 
    0.04468618f, -0.04471239f, 0.00751144f, 0.04492033f, -0.05388317f, -0.00883947f, 0.03424037f, -0.00951501f, 
    -0.04801914f, 0.00145535f, -0.02743213f, -0.03054985f, -0.00392054f, 0.02108141f, -0.03505029f, 0.05111078f, 
    0.02412882f, -0.00361501f, -0.00751783f, -0.04664069f, 0.03908323f, -0.04660437f, -0.05947780f, 0.02582948f, 
    -0.03892345f, -0.04881407f, -0.00659843f, 0.04518376f, -0.01997525f, 0.01290001f, 0.00053833f, -0.05797214f, 
    -0.03142809f, -0.04719146f, 0.03032869f, 0.03323691f, -0.00615584f, -0.00756719f, 0.02367293f, 0.01870226f, 
    -0.02738132f, 0.01151061f, -0.04569365f, -0.00951857f, 0.01058132f, -0.00357837f, -0.00090337f, -0.04932110f, 
    0.01551561f, 0.02489948f, -0.00926834f, -0.01778443f, 0.00893028f, 0.04337450f, 0.00909514f, -0.03073933f, 
    0.00040385f, 0.00513093f, -0.04337753f, -0.02811028f, 0.01130797f, -0.04019430f, 0.02127152f, 0.01820444f, 
    0.02969669f, -0.05773356f, 0.02730943f, -0.04145287f, 0.00794517f, -0.00399271f, 0.02171220f, 0.04609282f, 
    -0.01257705f, 0.00378699f, -0.04058071f, 0.02028096f, 0.00755873f, 0.02041746f, 0.05019684f, 0.01093301f, 
    -0.03508404f, 0.04032042f, -0.00725420f, 0.01831714f, -0.05025817f, -0.02980313f, -0.00597463f, -0.01140097f, 
    -0.00614579f, 0.00235312f, 0.02606070f, -0.05534397f, 0.00981949f, 0.00838559f, -0.01076805f, -0.04268344f, 
    -0.04792235f, -0.01429832f, -0.05849354f, -0.03126336f, -0.00975472f, -0.03987585f, -0.00511298f, -0.03716070f, 
    -0.00685490f, -0.04530451f, 0.02143541f, -0.06260946f, -0.00737587f, -0.02015795f, 0.03787725f, 0.04255319f, 
    0.00398401f, 0.02095591f, 0.00370204f, -0.02875255f, 0.02831305f, 0.00634592f, -0.01266740f, 0.02550701f, 
    -0.03157549f, 0.01582892f, 0.01367115f, -0.04462312f, -0.00268456f, 0.01981526f, -0.03511408f, -0.00379605f, 
    0.00408419f, 0.00282671f, -0.02735885f, -0.01421047f, -0.01334892f, -0.01504993f, 0.03225169f, 0.03474166f, 
    0.02000253f, -0.03213794f, 0.04542788f, -0.02365390f, -0.00201524f, 0.02098310f, -0.01571948f, -0.04921452f, 
    0.03338853f, -0.02141934f, -0.01667794f, -0.05932418f, -0.02612327f, -0.02859320f, 0.01076619f, -0.04536501f, 
    -0.01465525f, -0.04559823f, 0.01622899f, 0.00601334f, -0.05546688f, -0.01440197f, 0.00797830f, -0.02944706f, 
    -0.01517963f, -0.05876927f, 0.04465752f, -0.03642832f, -0.00745471f, 0.02753255f, -0.01757540f, -0.03958429f, 
    0.02148028f, 0.00655226f, 0.04238632f, 0.01968187f, 0.03455612f, -0.02664926f, 0.04238481f, -0.05334781f, 
    0.02899825f, 0.01496757f, -0.01479118f, 0.01774413f, -0.01149804f, -0.01303250f, -0.00529842f, 0.00714467f, 
    0.00316345f, 0.05370541f, -0.06235024f, 0.00910675f, 0.00314705f, 0.02231276f, 0.04121937f, -0.02365151f, 
    -0.02910287f, -0.02053086f, 0.01151719f, -0.05172416f, 0.01999753f, 0.02959567f, 0.00017139f, -0.03613432f, 
    0.04605380f, -0.02683385f, 0.03397851f, -0.01062008f, -0.03825112f, 0.01073857f, -0.00419826f, -0.04262267f, 
    0.02062355f, -0.01681489f, -0.01138228f, -0.01953555f, 0.01077680f, 0.03625190f, -0.04857400f, -0.03480022f, 
    -0.04715900f, -0.04726802f, 0.02658512f, -0.01499045f, -0.03866800f, -0.04573998f, 0.04524137f, 0.03437100f, 
    0.00338010f, 0.01231172f, -0.01386931f, -0.00821796f, -0.02697312f, -0.05286315f, 0.05240835f, 0.05033136f, 
    -0.03875523f, 0.02006890f, -0.00441123f, -0.04160409f, -0.06264821f, 0.00146015f, 0.04836585f, -0.02515648f, 
    0.03534062f, 0.00134937f, 0.03707835f, -0.02376519f, -0.05040726f, -0.05558670f, -0.00977766f, -0.04378135f, 
    0.00105148f, -0.02985824f, -0.02678690f, -0.01764322f, 0.00911502f, 0.04780243f, 0.03046795f, -0.04834063f, 
    0.00070202f, -0.04783202f, -0.05122537f, 0.04772613f, 0.02920062f, -0.04995388f, 0.02988613f, 0.00629391f, 
    0.03218957f, -0.02600071f, -0.03671911f, -0.01488914f, -0.03318765f, -0.02938860f, -0.02670241f, 0.01559852f, 
    0.04606349f, -0.00378536f, 0.01136196f, 0.03800010f, 0.01717062f, -0.00879542f, -0.00856096f, -0.05084449f, 
    -0.02510850f, 0.00640253f, 0.03918046f, 0.01257659f, -0.02177326f, 0.02463017f, 0.00692724f, 0.01268867f, 
    -0.01613761f, 0.02546016f, 0.01730681f, -0.06408493f, -0.03203754f, -0.02924682f, 0.03136854f, -0.04349998f, 
    0.16240804f, -0.03184000f, 0.03779388f, -0.20274611f, 0.10655358f, 0.04488837f, 0.07779163f, -0.08838447f, 
    -0.00614939f, 0.06538506f, -0.02632047f, 0.06062114f, 0.01473458f, 0.00034201f, -0.00721259f, 0.06170516f, 
    -0.08040330f, -0.14084157f, -0.09285210f, -0.16993217f, -0.18607457f, -0.04010900f, -0.25490952f, 0.04137510f, 
    0.12209506f, 0.05314561f, 0.22246128f, 0.08819298f, -0.14222026f, 0.13506596f, -0.10069045f, -0.01434361f, 
    -0.02993863f, 0.00540583f, -0.01212199f, -0.05126422f, 0.00441558f, 0.16855520f, -0.00998038f, -0.02752290f, 
    0.26054683f, 0.17914177f, 0.38778085f, 0.26825145f, -0.04897401f, -0.15044230f, -0.21329665f, -0.21866684f, 
    -0.10065180f, -0.16004461f, 0.03280926f, 0.09022877f, 0.02736303f, 0.13291790f, 0.03362931f, -0.10764757f, 
    -0.11800978f, -0.07687727f, -0.17207694f, -0.18844223f, 0.09368090f, 0.02322912f, -0.06374245f, -0.11308443f, 
    0.19940676f, -0.11858607f, -0.03330841f, 0.06612346f, -0.12802839f, -0.07092308f, -0.06921103f, 0.10759416f, 
    0.07701005f, -0.07550972f, -0.01363603f, 0.12555014f, 0.13695022f, 0.11146472f, 0.03297806f, -0.03686305f, 
    -0.07566945f, -0.10345848f, 0.00880489f, 0.16517243f, 0.09404366f, 0.00943075f, 0.03429879f, 0.05293676f, 
    -0.06897824f, 0.12199950f, -0.08106762f, 0.01205330f, 0.06486102f, -0.06025310f, -0.08424444f, 0.08549216f, 
    -0.06265161f, 0.10753117f, 0.19451958f, 0.23111449f, -0.05845691f, 0.01206782f, 0.14051640f, -0.06173620f, 
    0.10733779f, -0.02828216f, -0.00733901f, -0.00184517f, 0.03413662f, 0.04876362f, -0.00242814f, 0.09576230f, 
    -0.05497049f, 0.03751495f, -0.10770041f, -0.15319556f, -0.30012342f, -0.26750374f, -0.40851197f, -0.43177149f, 
    -0.14941210f, 0.10081134f, 0.26916888f, 0.17221025f, -0.03187654f, -0.01103639f, -0.06972609f, -0.02922605f, 
    0.05102109f, -0.05824609f, 0.04607055f, -0.06109466f, 0.05171065f, 0.03226033f, -0.03024540f, 0.01043562f, 
    0.02594557f, -0.05591031f, -0.02972519f, 0.06624876f, 0.25577420f, -0.28116104f, -0.06716740f, 0.14116938f, 
    0.04578898f, 0.01883665f, -0.03041260f, -0.10037696f, -0.03915239f, 0.06420293f, -0.01649423f, -0.03015902f, 
    0.02913377f, 0.00432417f, 0.03195626f, 0.14567542f, 0.17951192f, 0.05946047f, 0.09841289f, 0.34228680f, 
    0.01979204f, -0.16119638f, 0.17263611f, -0.04581029f, -0.30359593f, -0.12892410f, -0.01170200f, -0.01783179f, 
    -0.05550257f, -0.05513253f, 0.07625496f, 0.03808242f, 0.04018946f, 0.16780904f, 0.03552008f, 0.10535776f, 
    0.19639444f, 0.12891576f, -0.04952841f, 0.20132458f, -0.19554640f, -0.12176677f, -0.04842442f, 0.22965835f, 
    0.08180548f, -0.03382832f, 0.06404819f, 0.00009518f, -0.12154748f, 0.09968664f, 0.03038632f, -0.04376016f, 
    0.03690330f, 0.05559351f, 0.03159028f, 0.11073045f, 0.33025831f, 0.20945737f, 0.03872597f, 0.23975278f, 
    0.08815685f, 0.11503891f, 0.46788532f, 0.19431072f, 0.09074235f, -0.01100408f, -0.15419424f, -0.20528653f, 
    0.04593179f, 0.06202719f, 0.05145592f, -0.04328681f, 0.06371666f, -0.01882042f, 0.11282730f, -0.00548238f, 
    0.05423287f, -0.07029387f, -0.06583040f, 0.06254136f, -0.02848974f, 0.21038467f, -0.18310122f, -0.31632724f, 
    0.10551913f, -0.05034454f, 0.07474016f, 0.08543796f, -0.00649672f, -0.10948271f, -0.04128659f, -0.09169637f, 
    -0.17660886f, -0.10488813f, 0.00249721f, -0.08630241f, 0.07929233f, -0.17305714f, -0.04363130f, -0.11700024f, 
    0.09854443f, 0.04901436f, -0.06535228f, -0.00288142f, 0.10619106f, -0.03265546f, 0.10148852f, 0.05091699f, 
    0.07858329f, 0.11645610f, 0.12651610f, -0.07177548f, -0.13337517f, -0.16914351f, -0.09056573f, -0.00938351f, 
    -0.04999721f, -0.27098230f, -0.07267829f, -0.13255189f, 0.03495845f, 0.07661929f, 0.04440463f, -0.26022854f, 
    0.07911246f, 0.05689821f, -0.03417531f, -0.09822233f, 0.09225293f, 0.02166634f, 0.02636009f, -0.03349468f, 
    -0.02413352f, -0.03729198f, -0.01969050f, 0.09105710f, 0.24698335f, 0.02706211f, 0.06149480f, 0.03708954f, 
    -0.20998886f, 0.20093004f, 0.05838812f, 0.04077874f, -0.03821542f, 0.00424588f, -0.02037333f, 0.08207521f, 
    0.00885432f, 0.02290984f, -0.05664748f, -0.02813573f, -0.07321633f, -0.08866647f, -0.07502550f, -0.06828207f, 
    -0.10825225f, 0.00410775f, -0.14444014f, -0.16188659f, -0.03839125f, -0.05989823f, -0.02478197f, 0.13526586f, 
    0.11881956f, 0.01406960f, 0.05324724f, -0.09000529f, 0.08297903f, 0.06308019f, -0.02575336f, -0.05202565f, 
    -0.01244458f, -0.09605059f, -0.07985859f, 0.09894746f, 0.12424216f, 0.15478395f, 0.23397617f, 0.38712797f, 
    0.09101181f, 0.06430969f, 0.09867956f, 0.19900911f, 0.17415327f, 0.01820337f, -0.00495194f, -0.03698656f, 
    -0.03041990f, 0.04071759f, 0.05658150f, 0.05912770f, -0.03887704f, 0.03804903f, 0.06296819f, 0.00333713f, 
    0.02962135f, -0.14853881f, -0.01864623f, -0.09436633f, -0.51044476f, -0.00135559f, 0.03375837f, -0.04755777f, 
    0.05689106f, 0.05473548f, -0.01258368f, 0.23685277f, 0.08485911f, 0.05599452f, 0.05482101f, -0.05564175f, 
    -0.07367427f, 0.05591012f, 0.03902636f, -0.03549451f, 0.05719007f, 0.15712410f, 0.30798671f, -0.03296669f, 
    -0.60737491f, -0.31732768f, -0.60113108f, -0.10480625f, -0.34119841f, -0.14083119f, -0.15695831f, -0.05016188f, 
    -0.10275451f, -0.23735549f, -0.12289502f, -0.01290879f, -0.13053045f, -0.04551629f, -0.01509612f, -0.00816896f, 
    -0.00336181f, 0.04062875f, -0.02005394f, -0.02524778f, 0.40965483f, 0.21042614f, 0.15438071f, 0.10500536f, 
    0.25837389f, -0.11193260f, -0.05829864f, -0.01639796f, -0.02408011f, 0.07240327f, -0.01586464f, 0.08509556f, 
    -0.02570987f, -0.00453548f, 0.10496405f, 0.08233418f, 0.07209866f, 0.06170359f, -0.14273962f, -0.09852569f, 
    0.00637464f, 0.15528764f, 0.02341219f, -0.01904789f, 0.17116033f, 0.18481797f, -0.00199863f, -0.05576431f, 
    -0.14033261f, -0.00062841f, 0.00036477f, -0.06234940f, 0.06292663f, -0.00085784f, 0.03213900f, -0.07635751f, 
    -0.02434907f, 0.08721793f, 0.07208127f, 0.17379183f, -0.04333636f, -0.04294070f, 0.05165195f, 0.00864797f, 
    0.05803319f, -0.01917197f, 0.00074641f, 0.03852412f, 0.08456884f, 0.09898836f, 0.07655565f, 0.16982520f, 
    -0.19061597f, 0.00078442f, 0.01183865f, -0.06980430f, -0.10803994f, -0.09000744f, -0.11832425f, -0.06163014f, 
    -0.11462676f, -0.20856479f, 0.20644125f, 0.03468810f, -0.29962668f, 0.06164731f, -0.04488965f, -0.12321424f, 
    0.02559577f, -0.03963674f, 0.02967356f, 0.05662829f, -0.05179470f, -0.00448276f, -0.08634660f, -0.00261315f, 
    0.05834576f, -0.00998543f, -0.02895959f, 0.05902276f, -0.08833995f, -0.01183301f, 0.05462037f, 0.05008074f, 
    0.16997905f, -0.13622722f, -0.00098010f, 0.04705226f, 0.00802380f, 0.04043395f, 0.12213936f, 0.08634914f, 
    0.07744808f, 0.05609791f, 0.10295114f, 0.31331295f, 0.03995077f, -0.03398738f, 0.06558952f, -0.09699856f, 
    0.48290864f, 0.20815493f, -0.52681172f, 0.23160578f, -0.53207707f, 0.04362433f, 0.05245398f, -0.33766657f, 
    0.14399898f, -0.02302792f, 0.05288196f, -0.09513651f, -0.15029491f, -0.13346876f, -0.06077105f, 0.24556129f, 
    0.13493489f, 0.10571835f, 0.07608479f, 0.07457827f, -0.51418358f, -0.12914120f, -0.36659077f, 0.10825227f, 
    -0.31358942f, 0.17776559f, -0.00830089f, 0.14548765f, -0.16999866f, 0.12464950f, 0.05207762f, -0.06740618f, 
    0.01810055f, 0.04740535f, -0.10617919f, 0.25520188f, 0.17806211f, 0.08826538f, 0.10928641f, 0.23919921f, 
    -0.56101394f, -0.36328250f, -0.40398717f, -0.09537219f, -0.09562947f, -0.01227060f, -0.08195681f, -0.04683031f, 
    -0.02283320f, 0.02592878f, -0.12150107f, -0.18214874f, -0.03783886f, -0.07244895f, 0.03295987f, -0.01832492f, 
    0.05276973f, -0.06961562f, -0.00052949f, 0.06612267f, 0.28058520f, 0.17630851f, 0.54763269f, 0.03341841f, 
    0.10419157f, -0.11346040f, -0.06984391f, 0.05849841f, 0.02372674f, 0.10489299f, -0.02699558f, -0.05191872f, 
    -0.00217569f, -0.02761812f, 0.06026294f, 0.02080911f, 0.13541819f, -0.05750879f, -0.02963582f, 0.04434843f, 
    0.19599231f, 0.12390704f, 0.12585478f, 0.19662945f, 0.11671510f, 0.01417617f, 0.01587716f, -0.18262826f, 
    -0.11718849f, 0.14033580f, -0.05235330f, -0.00059659f, -0.06832507f, 0.03153106f, 0.00421360f, 0.16512327f, 
    0.03595106f, -0.11729549f, -0.03821250f, -0.11256501f, 0.48680574f, 0.21994178f, 0.17113751f, 0.17473136f, 
    0.25772500f, 0.04749507f, -0.06780460f, -0.04531686f, 0.11062142f, -0.02089483f, -0.06098469f, -0.03059640f, 
    -0.14244297f, 0.00005100f, 0.04639336f, 0.00852480f, 0.30821741f, 0.04142842f, 0.15927495f, 0.00441701f, 
    -0.03593174f, 0.20236531f, -0.06298263f, -0.09448231f, -0.12660567f, -0.06341760f, -0.14016291f, 0.01304691f, 
    0.04357927f, 0.02852415f, 0.07782037f, -0.02894532f, 0.09130054f, 0.06513043f, -0.05297878f, -0.13564749f, 
    0.00268794f, 0.14588755f, -0.05543687f, -0.07186490f, 0.16862501f, 0.20581010f, -0.27510762f, -0.12008722f, 
    -0.00569705f, 0.04944644f, -0.06603849f, -0.19229119f, 0.01761757f, 0.15538698f, -0.10796797f, 0.08053768f, 
    0.06710661f, 0.02055474f, -0.01553631f, -0.00825680f, 0.08439818f, -0.20022744f, 0.10080065f, 0.02098277f, 
    -0.01655636f, -0.24056858f, -0.00973684f, -0.13529456f, -0.05149271f, -0.01293290f, 0.21020697f, 0.16932938f, 
    -0.02232182f, 0.05497557f, 0.00130558f, -0.04317398f, 0.10046943f, 0.00204916f, -0.06353949f, 0.15302163f, 
    -0.01278992f, 0.00967579f, -0.01489689f, -0.07581654f, -0.17567554f, -0.47177702f, 0.09057543f, 0.28286827f, 
    -0.11222108f, -0.13613309f, 0.13165985f, 0.00119406f, -0.18309000f, 0.11442481f, 0.06321660f, -0.15969850f, 
    -0.10879706f, 0.16963261f, 0.04427323f, 0.13218902f, 0.02211107f, -0.04062545f, 0.07080553f, 0.00789639f, 
    -0.38593337f, 0.45829815f, 0.53511369f, 0.17176038f, -0.07646234f, -0.16192326f, -0.08837933f, -0.21177790f, 
    -0.03006412f, 0.22627397f, -0.03638989f, 0.09349941f, -0.05888084f, 0.05058440f, -0.05455818f, -0.02566054f, 
    -0.12604196f, 0.02115902f, -0.07055211f, -0.02378917f, -0.09603018f, -0.09444316f, -0.11005854f, -0.20869127f, 
    -0.02150277f, -0.09151100f, -0.04647831f, 0.06320098f, 0.02376144f, 0.00389724f, 0.06142778f, -0.03635447f, 
    0.00780650f, -0.08256020f, -0.11374822f, 0.08936607f, 0.14252785f, 0.03242192f, -0.00151506f, 0.11207046f, 
    -0.26012290f, -0.15880629f, -0.04094454f, 0.21087570f, -0.02154695f, -0.16584672f, -0.03545225f, 0.00531685f, 
    0.00606328f, -0.15583247f, 0.02737148f, 0.07062179f, 0.07709149f, 0.06152566f, -0.04105205f, 0.16434163f, 
    0.01970359f, 0.04280990f, 0.13301991f, 0.03613488f, -0.03625734f, 0.09546951f, 0.22922708f, 0.04139331f, 
    0.14149120f, 0.01791422f, -0.04247867f, -0.06158076f, -0.11644439f, -0.11519445f, -0.05972211f, 0.01115064f, 
    -0.08537664f, -0.00971012f, 0.05631119f, 0.10220847f, -0.04579439f, -0.05716648f, -0.10117470f, -0.16675662f, 
    -0.15755630f, 0.01251139f, 0.32793361f, 0.29876280f, -0.16406743f, -0.04807858f, 0.01259796f, -0.14245951f, 
    0.16494732f, -0.03957982f, -0.00859956f, 0.05299254f, 0.02785118f, -0.06753176f, -0.04105335f, -0.01849179f, 
    -0.03944698f, 0.10132543f, 0.18885426f, -0.06185925f, 0.19006619f, -0.21832800f, 0.09939208f, -0.11812179f, 
    0.06684252f, -0.01837843f, -0.01804138f, -0.07695011f, 0.02567182f, -0.02779474f, 0.01813792f, -0.00263140f, 
    0.02220102f, 0.01427295f, -0.13338432f, -0.02861150f, 0.09031117f, 0.13652726f, 0.07745279f, 0.02791519f, 
    -0.31499687f, -0.00348953f, -0.19030555f, 0.05590194f, -0.00938216f, 0.04511824f, 0.04449768f, -0.00900068f, 
    0.11908893f, -0.06233124f, -0.13589087f, 0.06216957f, 0.08789583f, 0.11409479f, 0.09137411f, 0.10902577f, 
    0.06404820f, 0.16886711f, 0.00101295f, 0.01523103f, -0.35883784f, -0.36504078f, -0.46552512f, 0.44198698f, 
    -0.12153137f, -0.08931896f, 0.09064557f, 0.02545861f, -0.26794273f, 0.00529914f, -0.11698749f, -0.11424953f, 
    0.01095119f, 0.12979032f, 0.04040578f, -0.00496933f, 0.08708735f, 0.12786661f, 0.16184677f, 0.18700764f, 
    -0.44213364f, 0.39769581f, 0.29496336f, 0.14587691f, 0.18908162f, -0.01240322f, -0.08446112f, -0.08779231f, 
    0.12069081f, 0.12166670f, 0.05327156f, 0.03987376f, 0.09819149f, 0.08952438f, -0.00607116f, -0.14715004f, 
    -0.12174604f, 0.14531752f, -0.00532014f, 0.01818320f, 0.22690211f, 0.06756682f, -0.25614247f, -0.22814830f, 
    0.11625080f, 0.02098340f, -0.00143512f, 0.07433291f, 0.40027931f, 0.02205339f, 0.00522303f, -0.03396022f, 
    -0.03259914f, -0.08318005f, -0.07272089f, -0.01208818f, -0.12327569f, 0.07383897f, 0.09577291f, 0.01282153f, 
    0.12067967f, -0.11363320f, -0.28675860f, 0.12079884f, 0.11136055f, 0.16263720f, 0.00700547f, 0.30066270f, 
    0.02048898f, -0.02619882f, 0.05775438f, -0.06125544f, -0.15331113f, 0.03150944f, 0.07032716f, 0.01669798f, 
    0.01504877f, 0.18367584f, 0.01246570f, 0.08317258f, 0.44635642f, -0.01374718f, -0.18742152f, -0.12954415f, 
    0.20900087f, 0.03867091f, 0.12790748f, 0.16581877f, -0.02450548f, -0.08621421f, -0.02875602f, -0.03474545f, 
    0.15673430f, -0.10856538f, -0.03280173f, 0.03639887f, -0.00982100f, 0.18275897f, 0.01925490f, -0.05050309f, 
    -0.08048927f, 0.12828149f, 0.14887394f, 0.18188678f, 0.07779745f, 0.13797945f, 0.01357678f, -0.14249077f, 
    0.35772607f, -0.06790019f, -0.09236026f, -0.05408767f, -0.04208298f, -0.07574697f, 0.13431351f, 0.00954663f, 
    -0.02789083f, 0.01126199f, 0.04709212f, 0.03230665f, 0.11643625f, -0.04325874f, -0.06281108f, 0.13612846f, 
    0.12676835f, -0.05633137f, 0.08283235f, 0.02773159f, 0.10670187f, -0.06840130f, 0.02857945f, 0.10593260f, 
    0.09235734f, 0.01355834f, -0.04472349f, 0.16326018f, 0.04559068f, 0.03176542f, 0.04107108f, 0.04605340f, 
    -0.04113589f, -0.06230677f, 0.02918729f, -0.00224277f, -0.01265569f, -0.00578289f, 0.02150373f, 0.00349206f, 
    0.03101015f, -0.02633857f, 0.04025807f, -0.04363381f, -0.05940768f, 0.04490256f, 0.01409349f, -0.00793556f, 
    0.01037032f, -0.05360919f, -0.02400546f, 0.04863412f, 0.03755409f, -0.03235258f, -0.05826749f, -0.04949630f, 
    -0.00529625f, -0.01170257f, -0.01953100f, 0.00341693f, 0.00470659f, -0.03892741f, -0.04915538f, 0.04253846f, 
    -0.04072860f, -0.03011281f, -0.03375344f, -0.04602086f, -0.03785152f, -0.03339056f, -0.01861098f, -0.00611973f, 
    -0.00111677f, -0.02795936f, -0.03897704f, 0.03634695f, -0.04770644f, 0.05509148f, 0.02145493f, -0.00126661f, 
    -0.05325522f, 0.03269278f, -0.00885404f, 0.01843242f, 0.04431942f, -0.04708500f, -0.01472769f, -0.01005659f, 
    -0.02003349f, -0.00175661f, -0.05281895f, 0.04541262f, -0.01546424f, -0.05812168f, -0.04026574f, -0.01191465f, 
    -0.04856807f, 0.00188765f, -0.01802844f, -0.04942231f, 0.04056951f, -0.01733109f, 0.03927537f, 0.00219818f, 
    -0.02623095f, -0.01877036f, -0.05368208f, -0.03696250f, -0.01771325f, 0.02927321f, -0.03891996f, -0.03428911f, 
    -0.05667357f, 0.04451396f, 0.04683391f, 0.02499240f, -0.01321832f, 0.04083517f, -0.03392178f, -0.00278585f, 
    0.00088156f, 0.01976425f, 0.01430252f, -0.00265828f, -0.00845904f, 0.02633503f, 0.02539999f, -0.02649163f, 
    -0.02757391f, -0.02899237f, -0.00433563f, -0.04096982f, -0.03195455f, 0.03352299f, -0.05907584f, -0.00721036f, 
    -0.04491596f, 0.02389318f, 0.03258390f, -0.02871194f, -0.05479114f, 0.02349489f, -0.04756420f, -0.05248874f, 
    0.02376680f, 0.01083679f, -0.02155947f, 0.03904505f, -0.00489652f, 0.00060835f, 0.02647229f, 0.04585613f, 
    -0.04824532f, 0.00735724f, 0.02349889f, -0.02219591f, -0.01211533f, 0.04518759f, -0.01281021f, 0.01192033f, 
    0.03535977f, -0.01340754f, -0.02546992f, 0.04321035f, -0.03779583f, -0.04148421f, -0.02259371f, -0.03189921f, 
    -0.02374431f, 0.00896257f, 0.01935348f, -0.01859436f, -0.05677311f, 0.04332963f, -0.02122335f, -0.00296349f, 
    -0.00308315f, -0.02837788f, -0.00857041f, 0.03420704f, -0.03182258f, 0.01947217f, 0.03836653f, -0.05326058f, 
    0.04037896f, 0.00655458f, -0.02336050f, -0.04467114f, -0.05150645f, -0.01154871f, 0.04692553f, 0.03848018f, 
    0.05825556f, -0.04637907f, 0.05367586f, 0.03851921f, 0.01586298f, -0.04652526f, -0.02670280f, -0.01222526f, 
    -0.04509738f, 0.03323471f, 0.02772423f, -0.04940421f, 0.04082756f, 0.03190535f, 0.01612953f, -0.05164656f, 
    0.02822561f, 0.00435902f, 0.02691331f, -0.00269861f, -0.01764474f, -0.03425502f, -0.04151360f, 0.04687675f, 
    0.03736581f, -0.05620454f, 0.02275202f, -0.06011897f, -0.00794172f, 0.04710540f, 0.00260388f, 0.00161412f, 
    -0.04024184f, 0.03272438f, -0.02601932f, -0.01826311f, 0.00515831f, -0.02460464f, 0.02958336f, -0.04882789f, 
    -0.05766882f, -0.00167681f, 0.00741230f, 0.04530044f, 0.01079375f, -0.02081456f, 0.01966413f, 0.02670794f, 
    -0.02448566f, 0.02696871f, -0.02447535f, 0.00204368f, -0.04760749f, -0.04810391f, -0.05030784f, -0.04289849f, 
    -0.01045520f, -0.00523835f, 0.01277841f, 0.00291326f, -0.03458367f, -0.02539859f, -0.02932149f, 0.00550094f, 
    0.02449139f, 0.00208815f, 0.03371221f, 0.00165968f, 0.01341482f, -0.00632320f, -0.02529055f, -0.04099543f, 
    -0.04497101f, 0.02710331f, -0.05069315f, -0.04629804f, 0.01777957f, -0.04113546f, -0.04328663f, 0.01846396f, 
    0.04728995f, -0.05124705f, -0.02734498f, 0.04416149f, -0.00746914f, 0.02191146f, 0.02921986f, 0.01454637f, 
    0.04239610f, -0.01617730f, -0.01587796f, -0.04331825f, 0.01042235f, 0.00816354f, 0.00275121f, 0.03989576f, 
    -0.03941233f, 0.01640396f, -0.04777045f, 0.02954810f, 0.03584944f, 0.00536463f, 0.04447501f, -0.03228253f, 
    0.01408906f, -0.00746860f, 0.00262702f, -0.02645274f, -0.01607949f, 0.05013819f, 0.04557884f, -0.01122089f, 
    0.00943528f, 0.04770309f, -0.02912647f, -0.02040839f, -0.01218108f, 0.02626774f, -0.00925843f, 0.03694894f, 
    0.03577590f, 0.03474423f, -0.04732780f, -0.02078594f, 0.02136041f, -0.04898453f, 0.04579490f, 0.03649996f, 
    0.00880944f, -0.05019710f, -0.03995644f, -0.04470951f, -0.04562096f, -0.01694224f, -0.03352369f, -0.03685342f, 
    -0.01034327f, -0.00220027f, 0.04379005f, 0.01543640f, -0.05193068f, 0.01632133f, -0.00201220f, -0.03700481f, 
    0.02034137f, -0.03983943f, 0.01561077f, 0.01969220f, 0.03320377f, -0.05968533f, 0.00475140f, -0.05717124f, 
    -0.01294446f, -0.03825173f, -0.01270806f, -0.01191314f, 0.04998410f, -0.00057711f, -0.04574504f, -0.01018473f, 
    0.01083496f, -0.05268899f, -0.03289349f, 0.01492560f, -0.01048331f, -0.02749854f, 0.05168286f, 0.00647805f, 
    0.04851660f, -0.04196879f, 0.03252066f, 0.04747445f, 0.04619775f, 0.02196325f, 0.03520197f, -0.04296573f, 
    0.05170064f, -0.02946386f, -0.05930619f, -0.02919992f, -0.01685652f, -0.05887303f, -0.05981380f, -0.04180897f, 
    0.00485508f, 0.00912819f, -0.00419753f, -0.02783117f, 0.04446340f, -0.02482177f, 0.03602040f, -0.00217530f, 
    -0.06094832f, -0.05354706f, -0.05675355f, -0.03622377f, -0.03364971f, 0.04574173f, -0.05959496f, 0.01476211f, 
    0.01463188f, -0.01682841f, -0.00863406f, 0.02956403f, -0.02686462f, 0.03183143f, -0.03572715f, -0.03584665f, 
    0.02015431f, -0.03895854f, -0.03947856f, 0.01815484f, 0.00133819f, 0.02937820f, 0.02372141f, -0.01757742f, 
    0.02806203f, 0.01821536f, 0.05002997f, -0.02080000f, -0.02620525f, -0.02292356f, -0.03867231f, -0.02045567f, 
    0.01277675f, -0.05916419f, 0.04091287f, -0.04209412f, -0.03992252f, 0.04085703f, -0.02725163f, -0.00922166f, 
    -0.04609574f, 0.00684887f, -0.03736627f, 0.03309662f, -0.01771269f, -0.01844708f, -0.00726604f, -0.00904685f, 
    0.03242114f, 0.00693647f, 0.03227760f, -0.00137033f, 0.02132997f, -0.04750878f, -0.04908264f, 0.04089420f, 
    0.03697308f, -0.06239433f, 0.03160563f, 0.04428224f, -0.01822868f, 0.04341428f, -0.01547560f, -0.06432269f, 
    -0.03829207f, 0.03838731f, -0.02244534f, 0.02891817f, 0.03532906f, 0.04966768f, 0.05602445f, -0.02942097f, 
    0.04791330f, -0.02533188f, 0.03266796f, 0.02552200f, 0.05022962f, -0.04063111f, 0.01880815f, 0.01164580f, 
    -0.05191454f, -0.02663533f, 0.01281508f, 0.01682162f, 0.00958479f, -0.05882241f, -0.04575713f, -0.04650870f, 
    -0.05994398f, -0.06517099f, -0.04241953f, 0.03411646f, -0.01525553f, 0.01726522f, 0.02583046f, 0.03354464f, 
    -0.02244207f, 0.04389834f, 0.00699571f, -0.03783994f, 0.01254751f, -0.02774915f, 0.01602371f, 0.01281233f, 
    -0.06687571f, -0.03806626f, -0.00924509f, 0.01166810f, -0.02918215f, 0.00838484f, 0.01033802f, 0.00361667f, 
    0.04520350f, -0.01499978f, -0.02485926f, -0.02918736f, 0.01795687f, -0.03451585f, -0.00465605f, -0.00413713f, 
    0.04961047f, 0.04179006f, 0.02442604f, -0.02154656f, -0.01019819f, 0.02308406f, -0.00481006f, 0.02347771f, 
    -0.03054096f, -0.01720022f, -0.04322550f, -0.03849967f, -0.03079959f, -0.01583506f, 0.03212444f, 0.03135754f, 
    0.00461839f, 0.01803035f, -0.04396586f, -0.03920776f, -0.00871744f, -0.01710080f, -0.02974891f, -0.01739458f, 
    -0.01587243f, -0.02294080f, 0.03470105f, 0.00215074f, 0.02186901f, 0.03526448f, 0.03274000f, 0.04431729f, 
    -0.03689863f, -0.03247732f, -0.05694907f, 0.01740713f, 0.03986635f, 0.00011536f, 0.00648000f, -0.00186209f, 
    -0.04439880f, -0.03419439f, -0.01091592f, -0.04259999f, -0.05178848f, -0.04659714f, 0.02396938f, -0.04380298f, 
    -0.03994420f, -0.00972363f, 0.03863779f, 0.02635088f, -0.06183277f, 0.00272805f, -0.01490100f, 0.02106052f, 
    -0.01938090f, -0.03239034f, -0.02898595f, -0.05646461f, -0.06938477f, 0.03246829f, 0.00438681f, 0.00619470f, 
    -0.01432087f, 0.00136031f, 0.03676912f, -0.00261591f, 0.05511193f, 0.01715478f, 0.02248831f, -0.04322236f, 
    -0.04533135f, 0.02106704f, -0.04194976f, -0.04844865f, -0.02191232f, 0.02330333f, 0.03387494f, -0.00150120f, 
    -0.03256031f, -0.02351828f, -0.02980891f, 0.02655574f, 0.03805346f, -0.01140121f, 0.01808553f, 0.00142497f, 
    0.05059873f, -0.00707167f, -0.01883147f, -0.00414943f, -0.00167824f, 0.04139659f, 0.01795753f, 0.03683880f, 
    0.04843211f, 0.04667880f, 0.00706986f, -0.04895349f, -0.05556679f, -0.03548853f, 0.04437174f, -0.02529326f, 
    -0.04782803f, -0.03246422f, 0.02577195f, -0.02745047f, -0.03501860f, 0.03376018f, 0.02210206f, -0.03017310f, 
    -0.05308857f, 0.04118384f, -0.04414373f, 0.04846293f, -0.01056576f, -0.01997580f, -0.02295077f, -0.05913675f, 
    -0.01514549f, -0.03926390f, -0.00508540f, 0.01792145f, 0.03713780f, -0.04810097f, -0.04819618f, 0.03575070f, 
    -0.01954873f, -0.02294891f, 0.02846990f, 0.00815612f, -0.00982325f, -0.01422329f, 0.01626828f, -0.02029954f, 
    0.04709826f, -0.01861382f, 0.01108144f, -0.03640159f, 0.04043255f, -0.03468529f, 0.03299720f, -0.05819312f, 
    -0.00757807f, -0.03634342f, 0.01987515f, 0.04053592f, -0.02851109f, -0.03379185f, 0.04075731f, 0.02785329f, 
    0.02071496f, 0.01885903f, -0.01942010f, -0.03474119f, 0.01524927f, -0.00077731f, 0.00195585f, -0.04763166f, 
    0.02243211f, -0.03649842f, -0.02293949f, -0.00780345f, -0.01410310f, 0.00244882f, -0.05339172f, -0.05905957f, 
    0.08171409f, -0.01661719f, -0.14669065f, -0.14605671f, 0.09755278f, -0.01990218f, 0.08050438f, -0.01073049f, 
    -0.04189337f, -0.03417123f, 0.13874337f, -0.00337390f, 0.07930455f, -0.05028904f, -0.01617398f, 0.23955134f, 
    -0.05279027f, -0.00282419f, -0.14562224f, -0.09795121f, -0.02663796f, 0.01892995f, 0.06569498f, 0.03476585f, 
    -0.22945076f, -0.01828882f, 0.11037293f, -0.11448351f, -0.06052778f, 0.10021021f, -0.02964621f, -0.04210380f, 
    -0.15622433f, -0.02965832f, 0.05735435f, 0.03089618f, -0.10973187f, -0.02140208f, 0.09399770f, 0.09921276f, 
    -0.08249670f, 0.12290432f, 0.07901999f, 0.08088018f, 0.07764971f, 0.03273068f, 0.03841612f, -0.17489822f, 
    -0.06785071f, 0.02582217f, 0.03510659f, 0.08590211f, -0.05153663f, 0.00912261f, 0.03453490f, -0.03028032f, 
    -0.00149100f, 0.04510436f, -0.10920671f, -0.04032712f, 0.10411786f, -0.01160230f, -0.17961289f, -0.03703398f, 
    0.22504213f, 0.06558612f, 0.03353510f, 0.03245518f, 0.02217796f, 0.04530892f, 0.02094852f, -0.03274147f, 
    -0.00670766f, -0.05330522f, -0.01067526f, 0.12290142f, 0.05684534f, 0.05528292f, -0.00840863f, 0.13594852f, 
    0.01043275f, 0.04318918f, 0.21663246f, 0.21920578f, 0.16004509f, 0.00919804f, 0.13615786f, 0.03269383f, 
    -0.03790966f, 0.14865534f, -0.06826336f, -0.06224240f, -0.02303952f, 0.08928118f, -0.03419070f, 0.01913454f, 
    0.13487594f, -0.12518556f, -0.00073832f, 0.07287949f, 0.05050911f, 0.12722248f, 0.04479314f, -0.05755401f, 
    0.08528723f, 0.13412032f, 0.01002826f, -0.09879746f, 0.03096995f, 0.06754171f, 0.05508504f, 0.01076937f, 
    -0.04755101f, -0.03627069f, -0.04807147f, 0.11765594f, -0.08644626f, -0.04155276f, -0.18443580f, -0.12781973f, 
    0.12506238f, -0.06120653f, 0.42023382f, 0.18574585f, 0.06218307f, 0.11163674f, 0.02493240f, -0.06972609f, 
    0.04930602f, -0.04619658f, 0.00661181f, 0.00370644f, -0.04918300f, -0.00684378f, -0.11805090f, -0.08423571f, 
    -0.01560120f, 0.00246782f, 0.09355606f, 0.02423631f, 0.44915843f, 0.05397682f, 0.05223018f, -0.03617683f, 
    -0.00678880f, 0.04336648f, -0.01606721f, -0.10816583f, 0.08624581f, -0.00243235f, -0.02711094f, -0.07167238f, 
    0.01170193f, 0.05448371f, -0.13025261f, -0.05420431f, 0.08683852f, 0.16942142f, 0.15066467f, 0.21867770f, 
    -0.27845117f, 0.01180779f, 0.15983139f, -0.18230216f, -0.11552498f, 0.09501867f, 0.11173069f, -0.01455320f, 
    0.01604707f, -0.01802164f, -0.02327466f, 0.00756876f, -0.02577069f, 0.05579029f, 0.06361867f, -0.06047596f, 
    0.04491093f, 0.11086798f, 0.07693800f, -0.06345070f, -0.27220032f, -0.21922925f, -0.00188073f, 0.10615826f, 
    -0.06881845f, -0.03120031f, 0.08650521f, 0.01750382f, -0.32284236f, -0.01296983f, -0.04839991f, 0.06859939f, 
    -0.06926957f, 0.06258173f, -0.01260165f, -0.06738380f, 0.12124582f, 0.16775982f, 0.06097170f, 0.14392097f, 
    -0.21050599f, 0.29588580f, -0.14693817f, 0.00121057f, 0.08730347f, 0.01541830f, -0.05510357f, -0.04145618f, 
    -0.01530862f, 0.19182259f, 0.07226414f, -0.02372775f, 0.05913681f, -0.00331070f, 0.08579296f, -0.06633238f, 
    0.03518301f, 0.11281677f, -0.12758075f, -0.00311720f, -0.04864406f, -0.02941920f, -0.20188282f, 0.02081282f, 
    0.17638288f, -0.10168692f, -0.07522814f, 0.02143621f, -0.03544795f, 0.02828546f, 0.04114389f, -0.00265354f, 
    -0.05370134f, -0.16746628f, 0.09736898f, -0.10976388f, 0.02885120f, -0.05494298f, -0.17429815f, 0.06301593f, 
    -0.20596479f, 0.04560550f, -0.22487336f, 0.02957744f, 0.01800623f, 0.19337969f, 0.04351232f, 0.10487329f, 
    -0.01877099f, 0.07810707f, 0.13555868f, -0.06434058f, -0.05425071f, -0.04248141f, 0.00712962f, 0.14005187f, 
    -0.01065917f, -0.03588683f, -0.08346821f, -0.10112819f, 0.31664136f, 0.19562572f, -0.35350835f, -0.05555659f, 
    0.31716597f, 0.02078488f, 0.01972401f, -0.02316556f, -0.11554581f, 0.06970928f, 0.12233919f, 0.00229287f, 
    0.05145540f, -0.09652626f, -0.00477313f, 0.13114190f, -0.03492446f, 0.10824496f, -0.09057106f, -0.15434965f, 
    0.11693758f, 0.01123488f, 0.37708223f, -0.06333079f, 0.30287889f, 0.07545204f, -0.01387469f, -0.00943589f, 
    0.00637874f, -0.03545791f, -0.02891307f, 0.01104858f, -0.12141830f, -0.12682337f, -0.05715964f, -0.07702735f, 
    -0.07383111f, -0.05221039f, -0.04158538f, -0.06988983f, 0.20574948f, 0.08201355f, 0.21202056f, 0.16607602f, 
    0.28794813f, 0.03844155f, 0.14791787f, 0.04739432f, 0.08159265f, 0.04859854f, 0.01748630f, 0.03179376f, 
    -0.03073486f, -0.02881949f, -0.12082436f, 0.02469206f, 0.22058219f, 0.00206552f, 0.14395589f, 0.14217763f, 
    -0.18923756f, -0.19934392f, 0.03863193f, -0.11989556f, -0.16118556f, -0.08715434f, -0.13050321f, 0.09887429f, 
    -0.08379162f, -0.08930427f, -0.00161048f, -0.06832974f, -0.16145617f, -0.08341780f, -0.13439192f, 0.02099032f, 
    -0.07651448f, 0.00412009f, 0.04685753f, 0.15007940f, 0.04527611f, -0.39766943f, -0.01147731f, 0.30335879f, 
    -0.12744001f, -0.05200093f, 0.05156277f, 0.04896833f, 0.09670166f, -0.01268272f, 0.08658228f, 0.05507834f, 
    0.04606425f, 0.25745496f, 0.02991895f, 0.17034581f, 0.07684417f, -0.01113231f, 0.13085867f, 0.22076522f, 
    -0.34205756f, 0.21312171f, 0.45311326f, -0.19789124f, -0.00786744f, -0.19441959f, 0.00964618f, -0.08750331f, 
    0.05897687f, 0.31947660f, 0.02640593f, 0.12374789f, -0.00995844f, 0.09822098f, 0.09493335f, 0.05849442f, 
    -0.06939610f, -0.04955358f, -0.02786680f, -0.00377763f, -0.16707952f, 0.08467366f, 0.08163590f, -0.10019086f, 
    -0.12628782f, -0.06571276f, -0.00986996f, -0.16221003f, -0.07102618f, -0.01661627f, -0.04937730f, -0.12369400f, 
    -0.10653084f, -0.03068360f, -0.03345606f, 0.09366484f, -0.04635971f, -0.04770313f, -0.07553031f, 0.16928846f, 
    -0.25914738f, -0.14100906f, -0.06456579f, 0.12325601f, -0.16185354f, -0.10752314f, -0.16518931f, -0.11367827f, 
    -0.05390765f, -0.22276089f, 0.04866541f, 0.14461280f, 0.06161780f, 0.19158772f, 0.13569953f, 0.07032089f, 
    0.14489372f, 0.11277051f, 0.04134378f, 0.00131503f, 0.07008751f, -0.08291805f, -0.01117615f, -0.07051533f, 
    -0.07923658f, -0.14723894f, -0.09641233f, -0.18840270f, -0.13107464f, -0.07076529f, 0.00174131f, -0.00426674f, 
    -0.13026161f, 0.00935531f, 0.13998069f, 0.04124361f, 0.17218424f, -0.02757373f, 0.13979195f, -0.00783743f, 
    -0.19925040f, 0.02667816f, -0.04854816f, 0.11147900f, 0.03140252f, -0.15143135f, 0.12576500f, -0.02553678f, 
    0.08096474f, 0.08470888f, 0.10037283f, -0.01298242f, -0.03042018f, 0.02408644f, 0.09124135f, 0.07859206f, 
    0.11423246f, 0.04018509f, 0.20100063f, -0.04441949f, -0.11029506f, 0.00163864f, 0.13711677f, -0.12352419f, 
    -0.12656766f, -0.00108938f, -0.10207454f, -0.14844726f, -0.01022956f, -0.07040273f, 0.12434515f, 0.03761853f, 
    0.04611590f, 0.04198772f, -0.00322656f, -0.00351788f, -0.02112221f, -0.14564036f, -0.10155403f, -0.20246240f, 
    0.18063429f, 0.20146143f, 0.00297750f, -0.16057466f, 0.06255322f, 0.10930165f, 0.07355656f, -0.04486321f, 
    0.02853519f, 0.05288475f, 0.17422424f, -0.05196142f, 0.08988581f, 0.04419559f, 0.06326953f, 0.11245629f, 
    -0.00210819f, 0.08893889f, -0.12166372f, -0.00244554f, -0.00908903f, -0.31221005f, -0.32966241f, 0.23840299f, 
    -0.14425315f, -0.18142249f, -0.09354222f, -0.13043897f, -0.15214512f, -0.11957654f, 0.13041821f, 0.05460325f, 
    0.09314322f, -0.07530918f, -0.16671714f, 0.16575955f, 0.04105551f, -0.22535093f, 0.08455660f, -0.03374855f, 
    -0.57547969f, -0.04471207f, 0.38685682f, -0.03714377f, 0.26231065f, -0.11999732f, -0.09413142f, -0.01679867f, 
    -0.01965614f, 0.12429151f, 0.13563935f, 0.11859577f, -0.05900688f, 0.03965162f, 0.11025663f, 0.02304362f, 
    -0.02764718f, 0.00026724f, 0.04106741f, -0.11801619f, 0.02739183f, -0.04096831f, -0.41047508f, -0.03135758f, 
    -0.00166044f, -0.11000374f, 0.11561818f, 0.16282476f, 0.05230568f, 0.22219548f, -0.13315727f, -0.09146627f, 
    -0.07972119f, 0.02509018f, -0.11750223f, 0.11070970f, 0.02481006f, -0.03141347f, 0.15814689f, 0.24687919f, 
    0.09078719f, -0.09362432f, -0.20134299f, -0.13861217f, 0.16073798f, 0.25405997f, -0.20953852f, 0.07420213f, 
    -0.05103267f, -0.06221012f, -0.01601324f, -0.06781491f, -0.03943013f, -0.00143199f, 0.16027598f, 0.03942200f, 
    0.09498093f, 0.09134950f, 0.09799975f, 0.15736605f, 0.00619890f, -0.16221914f, -0.08222952f, -0.28360945f, 
    -0.18858625f, 0.10274087f, 0.16223913f, 0.08625291f, -0.10503410f, -0.12367602f, -0.00256581f, -0.04450092f, 
    0.02354977f, -0.00951430f, -0.01505950f, 0.00740873f, -0.14038545f, 0.13706079f, 0.02159024f, 0.05971189f, 
    0.42389366f, -0.03709014f, -0.17143267f, 0.09977985f, 0.03802493f, 0.13701387f, 0.20851547f, -0.18619335f, 
    0.12189333f, 0.03400348f, 0.22898303f, 0.00752000f, 0.06149240f, 0.12703304f, 0.23854448f, 0.16836451f, 
    0.04343117f, 0.22835593f, 0.11327780f, 0.22420895f, -0.09007858f, -0.05514485f, -0.13430354f, 0.08475702f, 
    -0.07072284f, 0.05750600f, -0.00860034f, 0.10328554f, 0.12362090f, -0.19792601f, 0.11060771f, 0.06099573f, 
    0.11542708f, 0.13282095f, 0.10626714f, 0.08531105f, -0.09937017f, 0.05046558f, -0.11939369f, -0.12778386f, 
    -0.04430177f, -0.05608726f, -0.03105729f, -0.03052793f, 0.02321076f, 0.04132023f, 0.00175235f, 0.03285786f, 
    0.01231275f, 0.04873854f, 0.03537023f, 0.00616365f, 0.02487057f, 0.02504423f, -0.04315077f, -0.01816818f, 
    -0.01021440f, -0.02474365f, 0.04075556f, 0.00044923f, 0.04546963f, -0.04994706f, 0.00420088f, 0.04777493f, 
    -0.03939532f, -0.02447727f, 0.02067515f, -0.01022205f, -0.04304876f, 0.02116824f, -0.04503882f, 0.01121139f, 
    0.02108055f, 0.03054386f, 0.02328153f, -0.02009837f, -0.05812102f, -0.04501958f, -0.02205272f, 0.04738003f, 
    0.03709108f, 0.02459953f, -0.02686664f, 0.04519869f, -0.02491374f, 0.04744592f, -0.05138641f, 0.03249460f, 
    0.01411966f, 0.00582260f, 0.04459487f, 0.01733844f, 0.03500745f, 0.02476118f, -0.01322585f, 0.05173904f, 
    -0.04329307f, 0.04191326f, 0.01755006f, -0.02918976f, -0.02296728f, -0.02900428f, 0.00933302f, -0.05908730f, 
    0.00126601f, -0.00888930f, -0.01164532f, -0.01709091f, -0.04869330f, 0.02783406f, -0.01722836f, -0.05010461f, 
    -0.00055976f, -0.05211899f, -0.03869599f, 0.00358618f, -0.05791897f, -0.02952727f, 0.01938452f, 0.01366105f, 
    0.03804738f, 0.03458016f, -0.02576911f, -0.02827589f, -0.05787368f, -0.03988151f, 0.02445866f, 0.04335472f, 
    0.04666102f, -0.00059017f, -0.02871748f, 0.01467931f, 0.03102039f, -0.01043389f, -0.01249557f, -0.05318944f, 
    -0.00979123f, 0.02596781f, -0.03965593f, 0.04991345f, -0.01201802f, 0.01998584f, 0.04222346f, 0.03893987f, 
    -0.04639388f, 0.01319078f, -0.04366284f, -0.04311561f, 0.03450448f, -0.00479931f, -0.04977021f, 0.02195924f, 
    0.03951725f, -0.00067144f, -0.04064650f, 0.03118557f, -0.00874324f, -0.02244236f, -0.04323478f, 0.00668592f, 
    -0.05624798f, -0.00643553f, 0.04639348f, -0.01683653f, 0.02190177f, -0.03339593f, 0.01832117f, -0.01606533f, 
    -0.04521564f, 0.00520988f, 0.01586465f, -0.03141731f, -0.03471178f, 0.04442456f, -0.03647497f, -0.00505247f, 
    0.02497097f, 0.04211706f, -0.04192187f, -0.01725908f, -0.05587501f, -0.01934194f, -0.02640177f, -0.03436415f, 
    -0.00392238f, -0.00996670f, 0.03285684f, 0.04486280f, 0.03952156f, 0.03979140f, -0.03245560f, 0.03319236f, 
    -0.01292087f, -0.01731539f, 0.04673614f, 0.03388441f, 0.01959263f, 0.01340030f, 0.01352419f, -0.02075718f, 
    0.01544074f, 0.01741307f, 0.02137051f, -0.01743388f, 0.00531004f, -0.05328396f, -0.01393378f, -0.03172134f, 
    0.02237424f, -0.03848527f, -0.05549694f, 0.05034680f, -0.01886139f, -0.01737941f, -0.00861196f, 0.02387403f, 
    -0.00686532f, -0.01597937f, -0.01328396f, 0.02425848f, -0.03140840f, 0.03021813f, -0.00880577f, 0.01544537f, 
    -0.04622377f, -0.05252341f, 0.02353948f, -0.06015532f, -0.01986367f, 0.01393748f, 0.03075839f, -0.04706360f, 
    0.02836038f, -0.05964752f, 0.00450134f, -0.05279354f, -0.01316562f, -0.04455041f, -0.04288059f, -0.04940400f, 
    -0.00254309f, -0.01639489f, 0.01642295f, 0.01912356f, -0.01898953f, -0.05183446f, 0.02442821f, 0.00074815f, 
    0.00644961f, -0.02298649f, 0.00197708f, -0.01341439f, -0.00217320f, -0.03543668f, -0.03342412f, 0.04353690f, 
    -0.01499701f, -0.02022162f, 0.01875447f, -0.05981075f, -0.03709115f, 0.03480596f, -0.01114243f, -0.04620007f, 
    -0.05808839f, -0.00945025f, -0.03986515f, -0.00076633f, 0.03330934f, -0.02797384f, -0.03326378f, 0.03391013f, 
    -0.05085150f, -0.00137534f, 0.03816766f, -0.01676480f, -0.05980318f, -0.00561785f, -0.04482995f, -0.05762740f, 
    0.02923986f, 0.01979965f, -0.05979751f, -0.02505339f, 0.02908766f, 0.01042727f, -0.03199553f, -0.00387878f, 
    -0.05038242f, -0.03900343f, 0.04501645f, -0.04164368f, -0.02780987f, 0.02059990f, 0.01639926f, 0.03418192f, 
    -0.04799821f, -0.01687012f, 0.03804798f, 0.03619145f, -0.02693390f, -0.02823948f, -0.02012492f, -0.01033292f, 
    -0.01281035f, 0.02718240f, -0.04973292f, -0.01105815f, 0.00134419f, -0.03620252f, -0.05967836f, -0.01234693f, 
    -0.03310454f, 0.00498778f, -0.05515191f, -0.03886591f, 0.02078629f, 0.00889949f, 0.04500291f, 0.04359742f, 
    0.03206217f, 0.03417408f, -0.01757749f, -0.04757645f, -0.04303941f, 0.00644561f, -0.02752551f, -0.01235677f, 
    -0.00021300f, -0.04144704f, -0.00004586f, -0.03712062f, -0.03636222f, -0.04260765f, 0.00394104f, -0.02097102f, 
    0.02446652f, 0.01235091f, -0.02368243f, 0.00526369f, -0.05603990f, -0.01435834f, -0.02867395f, 0.02125569f, 
    -0.04207829f, -0.06123031f, -0.05580871f, 0.00424920f, 0.05243563f, -0.00325897f, 0.04748603f, -0.05667811f, 
    0.04829254f, 0.01677340f, 0.03203750f, -0.04006803f, -0.04928629f, -0.03323890f, 0.00465681f, 0.01186793f, 
    0.02842371f, -0.04507523f, 0.01006821f, 0.08680486f, -0.02803621f, -0.08204871f, 0.00577904f, -0.06823090f, 
    -0.02244706f, -0.04751693f, -0.08630244f, -0.04490719f, -0.16456078f, 0.00124191f, -0.00291085f, -0.24317536f, 
    0.20113948f, 0.02771688f, -0.02127501f, -0.00441917f, -0.09422550f, 0.11447880f, 0.12520878f, 0.17291483f, 
    0.18527396f, 0.20664208f, -0.09831757f, 0.01822718f, 0.17180137f, -0.02481096f, 0.04575694f, 0.11882619f, 
    0.05523271f, 0.00420257f, 0.05428949f, -0.07942578f, 0.10414441f, -0.11846232f, 0.04049111f, 0.06413029f, 
    -0.35660437f, 0.11886913f, -0.32071310f, -0.12281563f, -0.07908363f, 0.09502750f, 0.04216884f, 0.22490548f, 
    0.05188378f, 0.10377115f, -0.01657318f, -0.00336709f, -0.09065332f, -0.22508295f, -0.05650676f, 0.01166503f, 
    -0.02046219f, -0.09411009f, -0.04618544f, 0.05840900f, 0.05090354f, -0.12428441f, 0.04567910f, 0.06465723f, 
    -0.14028421f, 0.03003912f, -0.00991403f, -0.08761886f, 0.00850120f, -0.07433660f, -0.11353371f, -0.01873329f, 
    -0.00966994f, 0.07323612f, -0.01862014f, 0.05771575f, -0.00054967f, 0.06149901f, -0.11869135f, -0.26643339f, 
    0.14385171f, 0.19805409f, 0.01777006f, -0.14212063f, -0.03262818f, 0.00302181f, -0.03549413f, 0.10273389f, 
    -0.01385234f, -0.14489317f, 0.06908242f, 0.07366740f, -0.00877159f, -0.02305060f, 0.15245362f, 0.10831827f, 
    0.05808933f, 0.16469236f, -0.11304359f, -0.03249072f, 0.05652521f, 0.02760899f, -0.15268634f, -0.06482522f, 
    -0.10828378f, -0.15906213f, -0.00271885f, 0.08629892f, -0.02956373f, -0.08220899f, -0.05664749f, 0.09734724f, 
    -0.00769550f, -0.13745788f, 0.02322146f, -0.10864228f, 0.02514367f, 0.02412635f, 0.07596406f, 0.14137211f, 
    0.13757122f, 0.18201607f, -0.17842862f, -0.10082693f, 0.11974281f, 0.11140628f, 0.02211131f, -0.04820120f, 
    0.03746678f, 0.09986242f, 0.06906246f, 0.06775310f, 0.06512295f, 0.02344558f, 0.04016684f, -0.01054537f, 
    0.08535434f, 0.11238569f, 0.06979362f, 0.08314899f, -0.57613975f, 0.09826551f, 0.00815090f, -0.10577083f, 
    0.36045694f, 0.06612112f, 0.04940828f, -0.08284037f, -0.01472000f, -0.06044810f, -0.02980619f, 0.12405586f, 
    0.03519436f, 0.05112796f, 0.09732370f, 0.07763653f, -0.09276439f, -0.16701838f, 0.04253027f, -0.29127526f, 
    0.12488952f, 0.31975010f, -0.20416716f, 0.29742557f, -0.01570940f, -0.15962169f, -0.10272797f, 0.07182955f, 
    -0.04952735f, -0.02000416f, -0.01820188f, -0.10070274f, 0.07733672f, -0.11033983f, 0.03429148f, 0.08235792f, 
    0.00442330f, 0.10442889f, 0.15981022f, -0.01703065f, 0.28708887f, 0.38756102f, 0.16030724f, 0.09648104f, 
    -0.00874862f, 0.12657371f, -0.12058712f, 0.13281895f, 0.01422964f, 0.05213792f, 0.15637048f, 0.04737877f, 
    0.07895166f, 0.05643172f, 0.18130574f, 0.02604932f, -0.04286077f, -0.07991136f, 0.07645074f, 0.00005804f, 
    -0.25182435f, -0.04503582f, -0.15304507f, -0.04727614f, 0.07349821f, 0.09813892f, 0.10137118f, 0.08227149f, 
    0.01776567f, -0.10896429f, -0.03878938f, 0.00240287f, -0.06337351f, -0.04135336f, 0.01341331f, -0.00936905f, 
    -0.02973012f, -0.07756567f, -0.05123415f, 0.00258142f, 0.45112142f, -0.10134146f, 0.57540333f, -0.05554622f, 
    -0.16758355f, -0.05298512f, 0.28827944f, -0.04413759f, 0.01587634f, 0.11759807f, -0.02663971f, 0.15629080f, 
    0.07036356f, 0.08396283f, -0.01475543f, 0.04932413f, 0.06092435f, -0.10349058f, 0.00699258f, 0.02837089f, 
    0.06990533f, 0.09249651f, 0.26865077f, 0.01102700f, -0.06358029f, -0.15934692f, -0.08202250f, -0.20040737f, 
    0.00892949f, -0.04384929f, -0.26382759f, 0.06414552f, 0.05583603f, 0.05732647f, 0.05529590f, -0.03654867f, 
    0.00277390f, -0.05788103f, 0.08585008f, 0.10868110f, 0.26206768f, -0.27599677f, 0.26525259f, 0.27536088f, 
    -0.06919837f, -0.02429409f, 0.12074065f, -0.25221297f, 0.06939997f, 0.04404487f, -0.18720023f, -0.01015813f, 
    -0.03372906f, 0.10122588f, 0.02040397f, -0.07507288f, 0.07125264f, 0.04976111f, -0.02245214f, -0.00092071f, 
    0.01378089f, 0.25471622f, -0.29558080f, 0.25030383f, -0.24827814f, -0.10935125f, -0.13799255f, -0.05125054f, 
    0.02418742f, 0.06679873f, 0.02676836f, -0.01978451f, 0.02518560f, 0.01312098f, 0.05414551f, 0.07653735f, 
    0.01506271f, 0.26902106f, 0.16764826f, 0.12280996f, -0.03402044f, 0.08253514f, -0.03544511f, -0.23302665f, 
    -0.10990281f, 0.08074809f, -0.02365088f, -0.02500781f, -0.05624204f, -0.00016723f, 0.08344173f, 0.06512684f, 
    0.08329008f, -0.01932794f, 0.14648716f, 0.18410787f, -0.05992562f, -0.00475748f, -0.03493394f, -0.11394995f, 
    -0.01718143f, 0.10669277f, 0.09677844f, -0.09957928f, 0.00701916f, -0.02603473f, 0.03747267f, 0.08165514f, 
    -0.06695845f, -0.08546813f, 0.04162886f, -0.12015001f, -0.10027319f, -0.01242156f, -0.16929345f, 0.04007560f, 
    -0.00178144f, 0.12578522f, -0.12427761f, 0.02356044f, -0.05123795f, -0.33901784f, 0.04532853f, 0.18939878f, 
    -0.10012957f, -0.01653332f, 0.16129749f, 0.00860133f, 0.01123505f, 0.08942650f, 0.05368736f, 0.03768215f, 
    0.04060294f, 0.06604977f, -0.02185145f, 0.17513408f, 0.01038638f, 0.05053149f, 0.06900885f, 0.00779533f, 
    -0.07970882f, -0.10641239f, 0.16198634f, -0.03686379f, -0.22056204f, -0.17843853f, -0.19628440f, -0.32161456f, 
    -0.04824922f, 0.11673331f, 0.04347683f, 0.06744235f, 0.11499492f, 0.13344218f, 0.06107251f, 0.05883290f, 
    -0.04465300f, -0.00805410f, -0.09183891f, -0.03350214f, -0.05920628f, 0.07388671f, -0.01011983f, -0.01505876f, 
    0.12358453f, 0.00756937f, 0.01758954f, 0.03296060f, -0.05344625f, -0.10873994f, -0.04368291f, -0.10637537f, 
    -0.03902548f, -0.05990195f, -0.13958283f, 0.13432150f, -0.01957550f, -0.04548284f, -0.03723627f, 0.13033196f, 
    -0.17310935f, -0.23345578f, -0.00226780f, 0.10885678f, 0.01040933f, -0.08449484f, -0.12694216f, -0.03414851f, 
    0.04317134f, 0.05667080f, 0.08404072f, -0.00317427f, -0.00529010f, 0.12015205f, -0.03731806f, 0.04947167f, 
    -0.00782179f, -0.00214967f, 0.14059886f, 0.01467171f, -0.07815219f, 0.01622890f, -0.00469470f, -0.02339784f, 
    -0.03066762f, 0.04220435f, -0.14769970f, -0.08242368f, -0.09634651f, -0.12598331f, -0.10335936f, 0.04621157f, 
    -0.04209667f, -0.05089056f, 0.07023864f, 0.04715686f, -0.02383205f, -0.06140086f, -0.03001853f, -0.04702772f, 
    -0.20185731f, -0.22125047f, 0.09767946f, 0.22500068f, -0.20417702f, -0.09842744f, -0.03377044f, -0.00722944f, 
    0.12842497f, 0.03890326f, 0.06164579f, 0.05808350f, 0.13014491f, 0.01905351f, 0.05895294f, 0.03570939f, 
    0.03165710f, 0.11017634f, 0.13681751f, -0.09282295f, 0.08866660f, -0.21210080f, 0.04261211f, -0.10154577f, 
    -0.08339583f, 0.04400939f, 0.04299897f, -0.04359259f, 0.03788647f, 0.05952564f, 0.04277362f, -0.12520006f, 
    0.04032419f, 0.08822753f, -0.21334586f, 0.01392721f, 0.00814543f, 0.14149295f, 0.02028943f, 0.05317948f, 
    -0.30300775f, -0.21849886f, 0.18392557f, -0.07233667f, 0.24053299f, 0.12046821f, 0.07578366f, 0.10809867f, 
    0.20776953f, 0.11743601f, -0.04288293f, 0.17509562f, 0.13379987f, 0.16906333f, 0.02439998f, 0.07785718f, 
    0.02977292f, 0.13928996f, -0.04683475f, -0.11499546f, -0.27751327f, -0.38701451f, -0.33741555f, 0.41946602f, 
    -0.21230458f, 0.05678592f, 0.10874307f, -0.05848882f, -0.15026832f, 0.03915818f, 0.05009277f, -0.04632190f, 
    0.07726115f, 0.16124728f, 0.02581934f, 0.05474745f, 0.11492293f, -0.02440398f, 0.16748475f, 0.07399507f, 
    -0.04949457f, 0.35403684f, 0.03040805f, 0.05178604f, -0.07079114f, -0.16770345f, -0.03721584f, -0.09315947f, 
    0.00276003f, 0.03296442f, 0.04955074f, 0.04662412f, 0.09539586f, 0.19752464f, -0.04265357f, 0.04001916f, 
    -0.07072199f, 0.11873385f, 0.05963402f, 0.11359797f, 0.13667111f, 0.24412242f, -0.32080567f, -0.06559169f, 
    0.02473752f, 0.14370753f, -0.08434242f, 0.13237572f, 0.24469350f, -0.04732608f, -0.00515522f, -0.03720686f, 
    -0.07058626f, -0.12034816f, -0.04138367f, 0.00614761f, 0.00801259f, 0.03615219f, 0.10236857f, 0.16192579f, 
    0.10954991f, 0.08793176f, -0.13062713f, -0.03886008f, 0.06236405f, 0.17292921f, 0.00875991f, 0.09774037f, 
    0.06465664f, 0.00839862f, 0.06916791f, -0.04863942f, -0.05205318f, -0.05390026f, -0.12121782f, 0.04179734f, 
    0.06587344f, 0.18165958f, 0.03964061f, 0.03932142f, 0.33223483f, 0.24517275f, -0.05890911f, -0.05354728f, 
    0.22578181f, 0.03247599f, 0.10891661f, 0.06357653f, 0.04980427f, -0.02581564f, 0.04360436f, -0.00846781f, 
    -0.00131125f, -0.03097638f, -0.07696333f, 0.06750291f, -0.04832880f, 0.04674400f, -0.07793410f, 0.08023114f, 
    -0.10146242f, -0.28544337f, 0.22181846f, 0.01271090f, 0.14167401f, 0.20144200f, 0.07934862f, 0.00733026f, 
    0.24998817f, -0.06861753f, 0.06821211f, 0.07307146f, -0.01663383f, -0.05206871f, 0.11530286f, 0.01641890f, 
    -0.01457610f, 0.00258365f, 0.03036568f, 0.00798363f, 0.03968247f, -0.19825161f, -0.10146593f, 0.13741955f, 
    0.18667346f, 0.03573348f, -0.03640546f, 0.07365832f, 0.09912252f, -0.04033128f, 0.06211381f, 0.02272367f, 
    -0.01242729f, 0.10573372f, 0.02398321f, 0.01282234f, -0.00359909f, 0.10004201f, 0.06157431f, 0.14964186f, 
    0.07814106f, 0.14330466f, 0.17123030f, -0.03276028f, 0.04117776f, 0.00102911f, 0.07311893f, 0.05211912f, 
    -0.06164444f, 0.01026061f, 0.08813906f, -0.04460091f, -0.01449600f, 0.01964187f, -0.07812855f, 0.09351623f, 
    -0.05741733f, 0.08194776f, -0.15602534f, 0.00886081f, 0.03294168f, -0.35491359f, 0.04348705f, 0.07367113f, 
    -0.21353357f, -0.04997725f, 0.17812163f, -0.05103533f, -0.01065293f, 0.09261017f, 0.03391982f, 0.02314747f, 
    0.05263600f, 0.14714418f, -0.01611049f, 0.20073676f, -0.01852346f, 0.07843819f, 0.15773378f, 0.14418659f, 
    -0.29197693f, 0.02769822f, 0.27577215f, -0.12701808f, -0.19577299f, -0.17010100f, -0.15056685f, -0.23764966f, 
    -0.13392739f, 0.26074943f, 0.08416744f, 0.18188950f, -0.03503460f, 0.07903406f, 0.05747579f, -0.01343274f, 
    -0.11297149f, -0.03015035f, -0.04483468f, -0.04234457f, 0.04487792f, 0.29351079f, 0.19757724f, 0.13541812f, 
    0.21172324f, 0.07679795f, 0.06051167f, -0.03312384f, -0.08557028f, -0.06856468f, 0.04579352f, -0.14100586f, 
    -0.09827695f, -0.05997105f, -0.08930506f, 0.13140263f, 0.05777770f, -0.00352268f, -0.12599380f, 0.11806709f, 
    -0.16562986f, -0.21808191f, -0.04456386f, 0.08719140f, -0.01745601f, -0.06286195f, -0.04078665f, -0.14724900f, 
    0.02604326f, -0.01514087f, -0.07097661f, 0.03197689f, -0.01991668f, 0.09813948f, 0.04593577f, 0.01476406f, 
    0.02292307f, -0.04956704f, 0.13751480f, 0.03050042f, 0.05253785f, 0.09605409f, 0.03364912f, 0.10118960f, 
    0.01263932f, -0.04706511f, -0.08871724f, -0.13301836f, -0.14288048f, -0.06104439f, 0.04017028f, -0.05618760f, 
    -0.05047993f, -0.04332318f, 0.05958026f, 0.05051475f, -0.05434146f, -0.05876713f, -0.03629670f, -0.13538381f, 
    -0.18827444f, -0.15334542f, 0.08525123f, 0.11092091f, -0.17107220f, -0.10513717f, -0.02280319f, -0.04905847f, 
    0.08098880f, -0.01491195f, 0.07919554f, 0.11465342f, 0.06211879f, 0.02393896f, -0.01474703f, -0.00219769f, 
    0.03960746f, 0.01832889f, 0.11800279f, -0.16687980f, 0.27217382f, -0.03407709f, 0.12217015f, -0.12105744f, 
    -0.14857437f, 0.01399122f, 0.09634439f, -0.04922656f, 0.05532460f, -0.01219626f, 0.02210036f, -0.13714477f, 
    0.04916724f, 0.00763200f, -0.16459976f, -0.02953956f, 0.02543868f, 0.21722831f, -0.00601642f, 0.14026356f, 
    -0.31838959f, -0.14764570f, 0.23845743f, -0.24870072f, 0.28508806f, 0.20056286f, 0.04673750f, 0.07101939f, 
    0.12616856f, 0.05379718f, 0.02186184f, 0.14459671f, 0.11179508f, 0.16397195f, 0.05994025f, -0.00870133f, 
    0.02826469f, 0.12928888f, 0.00155149f, 0.01862852f, -0.27026293f, -0.46470761f, -0.39852056f, 0.13920212f, 
    -0.19164106f, 0.08288271f, 0.11955211f, -0.05104145f, -0.10171939f, 0.06032164f, -0.09802202f, 0.01527574f, 
    0.03430395f, 0.18847273f, -0.11979204f, -0.07011464f, 0.03210943f, -0.02161950f, 0.21552204f, 0.14633802f, 
    -0.18795392f, 0.25302851f, -0.01019465f, 0.00696704f, 0.07693900f, -0.16776374f, -0.07369781f, -0.04719016f, 
    0.00560968f, 0.09011697f, 0.08254880f, 0.12869917f, 0.16729814f, 0.09399691f, 0.14883547f, -0.05026960f, 
    -0.09140504f, 0.11995601f, 0.02249690f, 0.04192870f, 0.27790490f, 0.35185227f, -0.31467089f, -0.02284040f, 
    0.17795438f, -0.08063975f, -0.02284716f, 0.21473600f, 0.29526618f, 0.02342709f, 0.02083576f, -0.01438037f, 
    -0.08095410f, -0.14413108f, 0.02801129f, -0.00025306f, 0.10088462f, -0.10771710f, 0.03399387f, 0.12730953f, 
    0.14606239f, 0.04512386f, -0.12260283f, 0.04884605f, 0.12461057f, 0.16254148f, 0.00446992f, 0.20970574f, 
    -0.01065684f, 0.00169203f, 0.13144666f, 0.01110064f, -0.05310999f, -0.09673362f, -0.03563588f, 0.04806522f, 
    0.05339552f, 0.12166336f, 0.01384693f, 0.01931778f, 0.42225516f, 0.38156646f, -0.04117300f, -0.00580931f, 
    0.34905624f, 0.05229000f, 0.03870826f, 0.13606641f, 0.09537607f, -0.03213803f, 0.08565968f, 0.07624983f, 
    0.09122555f, -0.03472304f, 0.00275126f, 0.09856204f, -0.07248191f, -0.00808727f, -0.07953755f, 0.14602989f, 
    -0.00955171f, -0.16182528f, 0.12948163f, -0.03163282f, 0.17443658f, 0.17867042f, 0.07527721f, 0.00503765f, 
    0.19347124f, -0.03315044f, 0.11640176f, 0.04224029f, -0.15424934f, 0.00268964f, 0.02861574f, -0.01332553f, 
    -0.05273827f, 0.06879555f, -0.01677908f, 0.11720006f, 0.11545184f, -0.19838911f, -0.07367124f, 0.05263639f, 
    0.17910512f, -0.08227993f, 0.03702123f, 0.04712948f, 0.14583658f, -0.06574458f, 0.01295086f, 0.02883808f, 
    0.02527271f, 0.01455979f, -0.01712053f, 0.05973287f, 0.00132413f, 0.05025923f, 0.14982469f, 0.10206389f, 
    -0.06688320f, 0.17259821f, 0.04239544f, -0.01696641f, -0.10832363f, -0.10775339f, 0.31954601f, -0.01074874f, 
    0.02541460f, 0.05017192f, -0.02869553f, 0.01160286f, 0.00129013f, 0.07822632f, 0.06043127f, 0.17129304f, 
    -0.10294041f, 0.03329534f, -0.34614354f, -0.13017647f, -0.19742227f, -0.24047174f, -0.02013052f, -0.02587856f, 
    -0.08832572f, -0.09616257f, 0.22691973f, 0.01891251f, -0.07686020f, 0.01387123f, -0.09374915f, 0.03532991f, 
    -0.11786301f, 0.07009722f, -0.09796859f, 0.16224186f, 0.04580930f, 0.05469921f, 0.02805859f, -0.09045469f, 
    0.03833292f, -0.03519339f, 0.03179422f, 0.15233865f, -0.30018401f, 0.03736459f, 0.01380113f, -0.17907456f, 
    0.02061859f, -0.00812211f, 0.01990477f, -0.04377401f, -0.02215615f, 0.06806500f, -0.01786308f, -0.07466660f, 
    0.00227045f, -0.02296087f, -0.15850647f, 0.10022730f, -0.08410885f, -0.05710141f, 0.05980328f, 0.00696995f, 
    0.08325332f, -0.10107014f, 0.03871211f, 0.17159416f, -0.01789741f, -0.12377511f, -0.06128218f, 0.07128659f, 
    0.05269857f, -0.05828582f, 0.01892642f, 0.04623850f, 0.01735582f, -0.05215577f, -0.18900298f, 0.08668684f, 
    0.00305141f, -0.18814601f, -0.05486164f, 0.20546748f, 0.10220508f, 0.17672719f, -0.02815749f, -0.03914921f, 
    0.05875017f, 0.14479703f, 0.05526940f, -0.01556320f, -0.00071995f, 0.11592049f, -0.08303522f, 0.00712340f, 
    0.11193660f, 0.17507409f, 0.26859036f, -0.01198142f, -0.11283710f, 0.19430828f, 0.05845686f, 0.13562287f, 
    0.02353346f, 0.00126600f, -0.05914639f, 0.01652092f, -0.12462600f, -0.06376706f, 0.12115853f, 0.13759071f, 
    -0.04392166f, -0.05171797f, -0.02261642f, -0.06716670f, 0.14402357f, -0.08009420f, -0.12438126f, -0.32484853f, 
    -0.13624667f, -0.29130641f, 0.28809151f, 0.16734360f, -0.24988274f, 0.08455098f, -0.17872827f, 0.04579654f, 
    0.19269224f, 0.06910356f, 0.04642240f, 0.04775913f, 0.03793459f, -0.02831580f, -0.07573473f, -0.00609952f, 
    -0.04407882f, 0.12150279f, 0.04387823f, 0.03718048f, 0.20668107f, -0.09905627f, 0.02817439f, 0.04666420f, 
    0.00617544f, -0.04114564f, 0.03615648f, 0.14752701f, -0.23380300f, 0.15233913f, -0.12017635f, -0.08520517f, 
    0.19650914f, 0.06317030f, -0.05457947f, 0.01489150f, -0.01473110f, 0.19782944f, -0.07959937f, 0.13515991f, 
    0.01533790f, -0.72400826f, 0.25957400f, -0.26045033f, 0.32145345f, 0.01084197f, -0.03756968f, 0.21794102f, 
    0.24441224f, -0.01500663f, -0.19819799f, -0.04539146f, 0.17034164f, 0.06538010f, 0.08263609f, 0.06434809f, 
    0.10037292f, 0.06430215f, -0.12867244f, 0.06116512f, -0.23071831f, -0.15699384f, -0.31504583f, 0.03192064f, 
    -0.07839359f, -0.05683145f, 0.02551925f, -0.08954330f, 0.00520313f, 0.03293660f, 0.06362163f, -0.01083690f, 
    0.14269440f, 0.17141952f, 0.05887855f, 0.02930840f, 0.07735334f, -0.00694509f, 0.13522126f, 0.11521728f, 
    -0.04566405f, 0.30496314f, -0.40247890f, 0.25929922f, -0.18040277f, -0.00577471f, 0.10157853f, -0.16476925f, 
    -0.19262384f, -0.22735035f, 0.07728769f, 0.02847726f, 0.10904550f, 0.09524705f, -0.04718952f, 0.05134348f, 
    -0.01661965f, 0.04126239f, -0.02777573f, 0.12841450f, -0.01818573f, 0.20204085f, -0.46104756f, 0.03561990f, 
    -0.17447484f, 0.33511442f, -0.11825235f, 0.07439270f, 0.14919989f, -0.22152403f, 0.05939593f, -0.08928727f, 
    -0.05006367f, -0.10151035f, 0.01405123f, 0.02838973f, 0.04071784f, 0.01360164f, -0.02082270f, -0.22002827f, 
    -0.00900018f, 0.17407136f, -0.34075347f, -0.08024757f, -0.06566504f, -0.16321473f, 0.11991174f, 0.14835927f, 
    0.01997756f, -0.03903025f, 0.09428333f, -0.08681210f, -0.08019776f, -0.13960676f, -0.11900571f, -0.01744202f, 
    0.01546082f, 0.11624330f, -0.07431213f, -0.09532955f, 0.09803034f, 0.23711969f, -0.04347970f, -0.16704096f, 
    0.17829323f, -0.00406302f, 0.00680177f, 0.12433052f, 0.07472049f, -0.03631227f, -0.08313540f, 0.12293223f, 
    0.07526912f, -0.08515824f, 0.00339538f, 0.16840123f, 0.16907498f, 0.03173193f, -0.06966095f, -0.05347297f, 
    0.02616435f, -0.28492370f, 0.36575249f, -0.09254909f, 0.18843165f, 0.13830869f, -0.06321032f, 0.18659514f, 
    0.06220200f, 0.10365003f, -0.06279588f, 0.04022924f, -0.05464382f, -0.07675640f, 0.05157973f, -0.02514033f, 
    0.07263139f, 0.05746577f, -0.18919806f, -0.18920581f, 0.27402300f, -0.14096916f, -0.04155060f, 0.25777903f, 
    0.27539352f, 0.04120269f, 0.01480783f, -0.01949964f, 0.05685011f, 0.14063036f, 0.00773610f, 0.03952644f, 
    -0.01459927f, -0.07733975f, -0.09690902f, 0.08441883f, 0.10644001f, 0.17771518f, 0.02018032f, 0.04150821f, 
    0.13597053f, 0.10617696f, 0.04354701f, 0.18451191f, 0.22090241f, -0.13650574f, 0.05402467f, -0.06850827f, 
    0.05407815f, -0.10646126f, 0.05898124f, 0.12909496f, 0.02261889f, 0.15383999f, 0.06174322f, 0.02242156f, 
    -0.08639900f, -0.08218484f, -0.00435561f, -0.12563433f, -0.14816944f, -0.24042863f, 0.31731072f, 0.15945491f, 
    -0.28129426f, 0.06126516f, -0.01287522f, 0.04890546f, 0.07276711f, 0.05521283f, 0.11823194f, 0.02596103f, 
    0.04782716f, -0.00721128f, 0.06394772f, 0.16148338f, 0.06904830f, 0.07460886f, 0.24168761f, 0.14700440f, 
    -0.33148360f, -0.07533518f, -0.07407658f, -0.10119619f, -0.31708416f, -0.23183413f, -0.06744834f, -0.03072741f, 
    0.02310161f, 0.06531483f, -0.10111113f, -0.02859716f, -0.06304411f, 0.01761904f, -0.08038093f, -0.15941030f, 
    -0.04589045f, -0.08746883f, -0.19280531f, -0.08644193f, 0.45022395f, 0.22936277f, 0.11110796f, 0.15938865f, 
    0.12821642f, -0.08909389f, -0.11827287f, -0.05394505f, -0.08136105f, -0.00873037f, 0.03626930f, 0.00183511f, 
    -0.04306648f, -0.03789724f, 0.05863075f, 0.03356665f, -0.07293839f, -0.02413238f, -0.05213210f, -0.12500744f, 
    -0.05375431f, 0.04138678f, 0.25227916f, -0.03915564f, -0.10781826f, 0.05765571f, -0.15632041f, -0.07075246f, 
    0.10376319f, -0.17141794f, -0.11555558f, -0.13917899f, 0.02253502f, 0.02343276f, 0.03985347f, -0.08487401f, 
    0.10324798f, -0.05732292f, -0.01348311f, 0.00769079f, -0.03185240f, -0.04945320f, -0.10547571f, 0.04185145f, 
    -0.00122667f, -0.03249273f, -0.00507261f, -0.04332285f, 0.00717886f, -0.00014224f, -0.04701691f, -0.01197669f, 
    -0.12718219f, -0.12139793f, -0.00330854f, -0.02680682f, -0.02695367f, -0.00498504f, -0.11202378f, -0.05440684f, 
    0.12186800f, -0.08426371f, 0.10451165f, 0.04882020f, -0.13884386f, -0.00104479f, 0.08434996f, 0.00968038f, 
    0.10547155f, 0.08796573f, 0.00635032f, 0.07003144f, -0.05308848f, 0.05743765f, -0.08212619f, -0.17301261f, 
    0.07579649f, 0.10410707f, 0.04398167f, -0.04696426f, -0.45389390f, 0.09706721f, 0.14232093f, -0.13520414f, 
    0.09105534f, -0.15975744f, -0.14129922f, -0.02011316f, 0.11421040f, -0.10667206f, 0.00669567f, 0.14689434f, 
    -0.12447545f, -0.03977222f, -0.06563254f, 0.01110481f, -0.03102432f, 0.04404201f, 0.11763806f, -0.13445967f, 
    0.09173819f, 0.20928022f, -0.16755129f, -0.03496520f, -0.13558927f, 0.10543540f, 0.16726264f, -0.06597378f, 
    0.14720029f, 0.09254203f, -0.02709065f, 0.11375475f, 0.07203618f, -0.17499256f, 0.06586341f, 0.07939588f, 
    0.01429223f, 0.11159553f, 0.10758576f, -0.02352715f, 0.02044773f, -0.27861306f, 0.07822930f, 0.15205824f, 
    -0.29903442f, 0.02298380f, -0.03162048f, -0.01600555f, -0.04909033f, 0.05599475f, 0.00121111f, -0.18776405f, 
    -0.10496837f, 0.06584164f, -0.04132696f, 0.20682268f, -0.04345772f, -0.00270146f, -0.05252255f, 0.02187481f, 
    -0.74368656f, 0.07698711f, -0.23006134f, -0.06517199f, -0.11328564f, -0.15108910f, -0.12263354f, -0.10239097f, 
    0.04804909f, 0.01529736f, 0.09500020f, -0.02218509f, 0.05711894f, 0.17921823f, 0.00089154f, -0.16085100f, 
    -0.09047253f, 0.03840443f, 0.05618884f, -0.07968912f, 0.54407614f, 0.12943371f, 0.35466164f, 0.02903122f, 
    -0.01068977f, -0.05319305f, 0.05770291f, 0.02490732f, 0.04577510f, 0.16893201f, -0.02919474f, -0.01721132f, 
    0.14895269f, -0.03004540f, 0.05783031f, 0.03113609f, 0.02084620f, 0.06750783f, -0.15870227f, 0.16673839f, 
    0.14176069f, 0.17813903f, -0.03825713f, 0.16249456f, 0.00167531f, 0.09470959f, -0.16988082f, 0.01749708f, 
    -0.08533734f, -0.05725259f, 0.00984452f, 0.00345004f, -0.02893488f, 0.02361177f, 0.11902594f, 0.14990836f, 
    -0.05236669f, 0.08225553f, 0.04267592f, -0.04159112f, 0.75602859f, 0.16709939f, -0.07602262f, 0.23744857f, 
    0.19535990f, -0.06243813f, -0.11342248f, -0.09922480f, -0.03667576f, -0.02955391f, 0.01284451f, 0.11950423f, 
    -0.07871997f, 0.00249491f, -0.02443035f, 0.01166625f, 0.04899231f, -0.02164494f, 0.16114415f, -0.08187187f, 
    0.25470755f, -0.04837950f, 0.19698828f, -0.03573941f, 0.17825185f, 0.07090233f, 0.06452651f, -0.15851547f, 
    0.17302270f, -0.02685293f, -0.04112877f, -0.01997735f, 0.00937000f, 0.07393768f, 0.08869071f, 0.01798791f, 
    0.10529850f, 0.05933864f, 0.13478462f, 0.25767934f, 0.12490436f, 0.13266240f, 0.15284848f, 0.07758732f, 
    -0.04310815f, 0.11595106f, -0.05321296f, -0.09824102f, 0.12374209f, 0.03458396f, 0.01318776f, 0.09068871f, 
    0.11332851f, 0.00538574f, -0.11649143f, 0.00699655f, 0.06767577f, -0.12634113f, 0.05572674f, -0.12486269f, 
    -0.06221046f, 0.04077294f, -0.18647239f, -0.03796727f, 0.17854017f, -0.06471824f, -0.00988446f, -0.18149321f, 
    0.00557128f, -0.12950069f, 0.05156481f, 0.03024126f, 0.12141808f, 0.03225139f, -0.03640910f, -0.02872042f, 
    -0.08301530f, -0.12983643f, -0.08591893f, -0.09736063f, 0.11024214f, 0.23056470f, 0.19068447f, -0.10590059f, 
    -0.05069328f, 0.02919379f, 0.01432175f, -0.22209221f, 0.10715166f, 0.03104313f, 0.08217697f, 0.08700126f, 
    -0.05503820f, -0.19434525f, 0.08964925f, 0.05702041f, -0.00478925f, -0.02688121f, -0.05154562f, 0.12571424f, 
    0.25150204f, -0.18720430f, -0.29156190f, 0.01210479f, 0.01460071f, 0.18822707f, -0.08064596f, 0.03602683f, 
    0.02068974f, -0.10011103f, 0.05092852f, -0.09643058f, -0.00456781f, -0.03959885f, -0.03786457f, 0.03447586f, 
    -0.04707801f, 0.04169061f, 0.00529857f, 0.07471088f, -0.00968211f, -0.13330521f, -0.06761058f, 0.06724466f, 
    0.08356064f, 0.09921191f, 0.02728075f, -0.04413212f, -0.06603375f, -0.07118294f, 0.02053819f, 0.02240513f, 
    0.07813244f, -0.08313326f, -0.11293200f, -0.10119732f, -0.04501661f, 0.07254932f, 0.12053764f, -0.16921432f, 
    0.09505749f, 0.01049065f, 0.13416162f, 0.03841608f, -0.09749985f, 0.08807724f, -0.10020825f, -0.02458776f, 
    0.16499251f, 0.29934689f, 0.04986862f, -0.08853366f, -0.05733806f, 0.01210144f, 0.02538570f, -0.06082782f, 
    0.11143013f, -0.04588876f, -0.22667237f, -0.02605867f, -0.05590872f, -0.04367843f, -0.15875296f, -0.04934044f, 
    0.04276294f, 0.02830333f, -0.01790483f, -0.02409628f, -0.00916105f, -0.19568570f, 0.03966850f, -0.14953500f, 
    0.00677668f, -0.07671798f, -0.17334372f, 0.04709971f, 0.02043414f, -0.01536836f, -0.06860407f, 0.13482243f, 
    0.29604068f, -0.04725175f, 0.17677636f, -0.06152107f, 0.02665480f, 0.19712813f, -0.03227529f, 0.22414735f, 
    -0.05172437f, 0.14952105f, -0.00366749f, 0.09500182f, 0.04346121f, -0.01781896f, -0.06261630f, -0.03103908f, 
    -0.02557092f, 0.00172747f, -0.01319020f, 0.01760228f, 0.02506026f, 0.32944313f, -0.03250755f, 0.03386238f, 
    0.09248473f, 0.02106291f, -0.03073357f, 0.02346101f, -0.03061010f, 0.12765087f, -0.05470497f, -0.06968815f, 
    0.05161502f, 0.01125854f, -0.13101308f, -0.19490762f, -0.11869595f, 0.01113416f, 0.21298251f, 0.12379883f, 
    -0.22644554f, 0.04376786f, 0.30520085f, -0.22675267f, 0.20319583f, 0.02437422f, 0.00288007f, 0.05763310f, 
    0.02302696f, -0.07690571f, -0.05394045f, -0.07582531f, 0.03044034f, -0.06890731f, -0.02815386f, 0.07521443f, 
    -0.04639707f, 0.06739925f, 0.16968124f, -0.02622164f, -0.17319985f, 0.11476940f, 0.42075342f, -0.22022773f, 
    -0.06837414f, 0.08797511f, 0.04203688f, -0.11562019f, 0.14618869f, 0.01499411f, 0.06361272f, -0.00720541f, 
    -0.02914262f, 0.04592912f, 0.22642900f, -0.03754581f, 0.00599146f, -0.06882986f, -0.08643633f, 0.02413270f, 
    0.17950663f, 0.43131325f, -0.49856561f, 0.06880775f, -0.03744482f, 0.17628869f, -0.00706944f, 0.07570936f, 
    -0.07735378f, -0.25469190f, -0.03582472f, -0.05921455f, 0.03672575f, 0.12969831f, 0.02966725f, -0.03949031f, 
    -0.01711307f, 0.03858884f, -0.01545758f, -0.00227491f, -0.27350277f, -0.08137440f, -0.18749879f, 0.31683987f, 
    -0.06426641f, 0.19034629f, -0.06888682f, -0.09177558f, -0.26577324f, 0.04248543f, 0.09047893f, 0.20696954f, 
    0.07017834f, -0.02638187f, 0.12220246f, -0.04339987f, -0.00370090f, -0.00930806f, -0.30999047f, 0.02368045f, 
    -0.34460288f, 0.13161196f, -0.03473391f, -0.09899227f, -0.02274305f, 0.15084827f, 0.04927357f, -0.13039900f, 
    0.10096804f, -0.02656420f, 0.06919665f, 0.01687079f, 0.06143178f, -0.00273903f, -0.15285099f, 0.07587208f, 
    -0.08832915f, 0.04678658f, 0.03877643f, -0.16577479f, 0.10574208f, 0.10517400f, -0.13406168f, 0.11303514f, 
    0.12997736f, 0.01800155f, 0.01230063f, -0.13442519f, -0.10760066f, 0.10200486f, -0.00664928f, -0.03054638f, 
    -0.08417992f, -0.00307520f, -0.02948379f, 0.12034037f, -0.09697504f, -0.00501070f, -0.03329227f, -0.10432961f, 
    -0.01774272f, -0.05044039f, 0.30778563f, -0.05271522f, 0.07920960f, -0.06994462f, -0.06137721f, 0.15951838f, 
    -0.19102882f, 0.05286873f, 0.03990724f, 0.05384586f, -0.00295705f, -0.04978266f, -0.15621847f, 0.07933009f, 
    -0.06010212f, -0.01615589f, -0.01821199f, 0.12195361f, 0.14609712f, 0.06426701f, 0.28714070f, 0.14065035f, 
    0.09383174f, -0.04254473f, 0.05348862f, 0.01284564f, 0.04614388f, 0.32438973f, 0.07709114f, -0.02997304f, 
    0.01201701f, -0.00124162f, 0.00476170f, -0.06146518f, 0.08550736f, 0.02185669f, -0.03920638f, -0.03863328f, 
    0.01877414f, -0.01567317f, -0.01843051f, -0.00720813f, -0.05773034f, -0.02269926f, -0.00614586f, -0.03989523f, 
    0.01999875f, -0.00085822f, -0.00284899f, 0.03761285f, 0.00838750f, 0.02982338f, -0.00550576f, -0.00075898f, 
    -0.05875153f, -0.01172289f, -0.02327600f, -0.01623996f, 0.02355303f, 0.02838633f, -0.06167538f, 0.02608671f, 
    -0.01890213f, 0.01621341f, -0.01508424f, -0.06348415f, 0.02678200f, -0.04891016f, -0.04564746f, 0.04402282f, 
    -0.04532219f, 0.03612598f, 0.04251099f, -0.03452531f, 0.03057071f, 0.04036774f, -0.01863190f, -0.02422157f, 
    -0.00858016f, 0.04590997f, -0.02807662f, 0.03522335f, -0.02598530f, -0.00174315f, -0.00181302f, 0.01724881f, 
    -0.00219858f, -0.00674498f, 0.01414482f, 0.01294726f, 0.02276541f, 0.03940962f, -0.05460472f, -0.03148429f, 
    -0.02153284f, -0.03273994f, -0.04050138f, 0.03169663f, -0.05344860f, 0.04030564f, -0.04656434f, 0.03161040f, 
    -0.02566982f, 0.01899016f, 0.01182935f, -0.00724446f, -0.05221268f, 0.01333833f, 0.03127082f, -0.05310651f, 
    -0.01185143f, -0.00314671f, -0.00560110f, -0.04781546f, -0.02759038f, -0.00830166f, -0.05997592f, 0.02066538f, 
    -0.06035420f, -0.03700273f, -0.03933769f, -0.01558926f, 0.04271999f, 0.04604671f, -0.06226338f, 0.02098211f, 
    0.02433892f, -0.05276397f, 0.01907076f, 0.02028820f, 0.03321280f, 0.03079272f, 0.02803047f, -0.05278675f, 
    0.03828877f, -0.04662023f, 0.02497275f, 0.01913513f, 0.00002323f, -0.04618469f, -0.03085514f, 0.03173443f, 
    0.00522823f, -0.04593994f, -0.02710928f, 0.01133019f, 0.03454307f, -0.01369986f, -0.03664560f, -0.03840318f, 
    0.03595753f, -0.02149720f, -0.04649635f, -0.02940958f, -0.04091557f, -0.03427758f, -0.04364488f, 0.01971755f, 
    0.02053565f, -0.06108863f, -0.01225574f, 0.00891951f, 0.00573352f, -0.02436896f, -0.00938383f, 0.01305560f, 
    -0.05769432f, -0.04849787f, -0.05140419f, 0.03886496f, 0.03554687f, 0.04577740f, -0.01007894f, -0.04751943f, 
    0.02915799f, -0.05536465f, -0.02753584f, -0.02722603f, -0.01501513f, 0.00417987f, -0.03850828f, 0.02799021f, 
    -0.05412650f, -0.05899443f, 0.03614374f, -0.00356781f, 0.03910825f, 0.04533606f, 0.03859727f, 0.00160260f, 
    -0.03660816f, -0.00731393f, -0.00697026f, -0.02431940f, 0.02197193f, -0.04667764f, -0.03347440f, -0.01961649f, 
    0.01158953f, -0.00000578f, 0.03198965f, -0.01526961f, 0.01864399f, 0.04687306f, 0.02832204f, -0.06247809f, 
    -0.00578578f, -0.03467387f, -0.04538467f, 0.02208496f, 0.01850611f, -0.01482274f, 0.00882166f, -0.01749209f, 
    -0.02807806f, -0.03306906f, -0.04294215f, -0.05839608f, 0.03636916f, 0.00873361f, 0.03747400f, -0.01030149f, 
    -0.05362128f, -0.03058346f, 0.02665420f, -0.00544487f, 0.03338498f, -0.03505911f, -0.01456749f, -0.05842198f, 
    -0.04111969f, -0.05212365f, -0.04117896f, 0.03536389f, 0.00365403f, -0.05761204f, 0.02175856f, -0.06015952f, 
    -0.03368457f, 0.01897036f, -0.04980907f, 0.02246660f, -0.05182015f, 0.00931631f, 0.00072789f, -0.00227726f, 
    -0.04966712f, 0.01803882f, -0.02814220f, 0.04567517f, -0.00568364f, -0.01444137f, -0.03436272f, -0.01894059f, 
    0.00305342f, -0.05689386f, -0.01932377f, 0.01683390f, 0.02499058f, 0.03533512f, -0.01694142f, -0.05370014f, 
    -0.06064982f, -0.04814121f, -0.04876326f, -0.01326135f, -0.02927479f, 0.01832734f, 0.04232872f, -0.03342400f, 
    0.04401268f, 0.00388998f, -0.05671383f, -0.02502454f, 0.00268541f, -0.03646287f, -0.05417220f, 0.03791591f, 
    0.04440099f, 0.02997745f, -0.06091527f, -0.01454273f, 0.02660349f, 0.02975887f, 0.03846632f, 0.00603679f, 
    0.02831018f, 0.02826107f, -0.02160468f, 0.02000061f, -0.05687230f, -0.04658457f, -0.03454996f, -0.03010064f, 
    -0.06099872f, 0.00312492f, -0.01278946f, 0.02003173f, -0.00826691f, -0.02353145f, -0.00200028f, -0.01876149f, 
    0.04489750f, -0.00371841f, 0.02139446f, -0.00372864f, -0.03725991f, 0.04510727f, -0.05840709f, -0.06179626f, 
    0.01705914f, -0.03160014f, -0.04270727f, 0.01080109f, 0.02088771f, -0.02542073f, -0.06068969f, 0.00150209f, 
    0.04094188f, -0.00219819f, -0.00730160f, 0.03619005f, -0.01881730f, -0.02426007f, -0.06275189f, -0.06037090f, 
    0.03148312f, -0.04676726f, -0.00778400f, 0.03865001f, 0.02279820f, -0.02989264f, 0.00992384f, 0.00372610f, 
    0.03335055f, -0.04441525f, -0.05852742f, 0.02347645f, -0.01873112f, 0.00189495f, -0.02545009f, 0.02577897f, 
    -0.03635802f, -0.05541788f, 0.04313976f, 0.02197593f, -0.00411304f, 0.02928203f, -0.06197790f, -0.05245971f, 
    -0.02707658f, -0.00097966f, -0.02521802f, 0.02976039f, -0.00443648f, -0.00475683f, -0.04289588f, 0.02162734f, 
    0.01963964f, 0.01139146f, -0.23975748f, 0.23708776f, 0.08416331f, -0.10208385f, 0.24509881f, 0.08625767f, 
    0.11225884f, 0.00120159f, -0.03306957f, 0.07608716f, -0.02420133f, 0.07509499f, -0.03120483f, -0.08956066f, 
    -0.04785922f, 0.13193640f, -0.02234870f, 0.03367924f, -0.16424210f, -0.07514443f, -0.09000444f, -0.05132942f, 
    -0.37208474f, -0.00666048f, 0.01531124f, 0.00225752f, 0.09934431f, -0.01616799f, 0.13783401f, 0.01856493f, 
    0.00862284f, -0.11262786f, 0.03319125f, 0.15529616f, 0.03832655f, 0.03011705f, 0.01190135f, 0.02317433f, 
    0.12558353f, 0.17559323f, -0.43452051f, -0.18843265f, -0.29836825f, 0.16923651f, 0.12085008f, 0.03642559f, 
    -0.04256522f, 0.08378791f, 0.01853164f, -0.09298229f, -0.14590190f, 0.08218952f, 0.00929151f, -0.04036620f, 
    0.11163203f, 0.04768366f, -0.01122986f, 0.10184138f, 0.08608552f, -0.10872515f, 0.03164711f, 0.00546027f, 
    0.15900689f, 0.11878924f, 0.14284584f, 0.03467803f, 0.02304688f, 0.03659368f, 0.06964621f, -0.00481008f, 
    0.04118977f, 0.06955276f, 0.02136970f, -0.04065676f, -0.03113047f, 0.06222920f, -0.04714878f, -0.05861095f, 
    0.26138428f, 0.21688487f, 0.33542368f, -0.14049830f, -0.14906883f, 0.12217935f, 0.09141904f, 0.03481332f, 
    0.09897906f, 0.05573479f, 0.05698047f, -0.04735502f, -0.08533780f, 0.07438604f, -0.07001193f, -0.03511417f, 
    -0.06890845f, -0.11434107f, 0.09851737f, -0.20120490f, 0.11430456f, 0.27119336f, 0.22502324f, 0.03520691f, 
    0.09343664f, -0.04580732f, 0.07570897f, 0.02156233f, 0.02186862f, -0.08214694f, 0.02103581f, -0.02255911f, 
    0.08834609f, 0.08700139f, -0.01210862f, 0.03747573f, 0.05182122f, -0.01904492f, 0.03168344f, 0.08835331f, 
    0.35487786f, -0.08584224f, 0.12184885f, 0.02347602f, -0.35094932f, 0.07537709f, 0.00974366f, 0.11285684f, 
    0.04260585f, 0.12543501f, 0.12032592f, -0.00452448f, -0.02250409f, 0.02167403f, -0.05507743f, -0.08553244f, 
    -0.08161995f, -0.00346609f, 0.13917032f, -0.03047852f, -0.45643494f, 0.19235155f, 0.02173476f, 0.03769220f, 
    0.11783388f, -0.01241600f, 0.02898043f, 0.00843360f, 0.08570680f, 0.08930054f, -0.01448857f, 0.00491047f, 
    0.01491351f, 0.11597740f, -0.06973954f, -0.04379668f, 0.13891873f, 0.05979679f, 0.07974800f, 0.02825232f, 
    -0.10030915f, -0.55582035f, -0.07013587f, -0.14076893f, 0.21400878f, 0.06123336f, 0.09347112f, 0.21919996f, 
    0.17603557f, 0.14145482f, -0.04316098f, -0.06740527f, -0.03718178f, -0.14005412f, 0.03116638f, -0.01997996f, 
    -0.15631771f, 0.16059272f, -0.07267605f, -0.14966682f, 0.37495342f, -0.20787041f, -0.02981202f, -0.14654572f, 
    -0.17951620f, -0.10837046f, -0.04012321f, 0.05575030f, 0.03419993f, 0.06093035f, 0.06237996f, -0.01104023f, 
    0.01887198f, 0.09523544f, 0.14261149f, -0.13191561f, -0.16992238f, -0.08839582f, -0.01406808f, -0.08626591f, 
    -0.36080194f, 0.17515753f, -0.58222681f, 0.14950979f, -0.07048949f, 0.06227612f, 0.13449536f, 0.00186254f, 
    -0.01167943f, -0.08628717f, 0.06332412f, -0.03236826f, 0.03959339f, 0.18283635f, -0.11115605f, 0.00668298f, 
    0.06671722f, 0.18519817f, -0.01319490f, -0.03306004f, 0.09995468f, -0.03301414f, 0.14368245f, 0.04897164f, 
    -0.11578114f, 0.18866418f, -0.05653279f, -0.10967386f, 0.17724378f, -0.06748423f, 0.01603994f, 0.04405903f, 
    0.12840798f, -0.03028825f, 0.05655411f, -0.03233049f, -0.04966038f, 0.09705468f, -0.02368621f, 0.00163709f, 
    -0.07259918f, 0.22244397f, -0.04919809f, 0.08531535f, 0.02391507f, 0.01789771f, -0.12480620f, 0.24589464f, 
    0.00068586f, -0.00976756f, -0.07376062f, 0.06342346f, 0.06930538f, 0.04515912f, 0.07205071f, 0.05259600f, 
    0.03050250f, 0.15740061f, -0.07790171f, -0.00329943f, 0.10542892f, 0.00719857f, -0.53120238f, 0.07144338f, 
    -0.00993539f, 0.09361289f, 0.17845188f, 0.19194390f, 0.09716250f, 0.04214590f, 0.03929147f, 0.00165688f, 
    -0.03618979f, -0.09742378f, -0.02621439f, 0.03877060f, -0.00847746f, -0.02666404f, -0.11676853f, -0.04564524f, 
    0.21624102f, -0.10080779f, 0.44902924f, -0.33550337f, 0.14661625f, 0.00549944f, 0.02524326f, -0.09046988f, 
    -0.01606948f, 0.02747237f, 0.06272214f, -0.01466917f, -0.07079222f, -0.08339359f, 0.03140956f, 0.03929742f, 
    0.03227299f, -0.08765872f, 0.01481592f, 0.09167498f, 0.08227193f, 0.27338398f, 0.22264193f, -0.00557875f, 
    -0.07703204f, 0.02822386f, -0.07203511f, 0.04183486f, 0.01613992f, 0.04529718f, 0.00967875f, -0.05522818f, 
    -0.03304628f, 0.00735588f, -0.07900655f, 0.04896087f, -0.02096443f, 0.00253544f, 0.01705521f, -0.04260589f, 
    -0.00292617f, -0.19121198f, 0.00101657f, -0.02283876f, -0.10255616f, -0.01611437f, -0.07685588f, 0.07522912f, 
    -0.09508426f, -0.10194652f, 0.00756847f, 0.05070866f, -0.13073406f, 0.00345380f, 0.02631492f, -0.03300535f, 
    0.06065838f, -0.02195532f, 0.02267879f, 0.06497438f, -0.24887644f, -0.03092768f, -0.26846868f, 0.30836576f, 
    0.20429268f, 0.15814784f, -0.10300574f, 0.14020208f, 0.11448853f, -0.01079279f, 0.05783924f, 0.05312590f, 
    0.09255120f, 0.06776438f, -0.04158186f, -0.00077917f, 0.15730608f, 0.08514579f, -0.06348900f, 0.11433079f, 
    -0.36662447f, 0.36357224f, 0.14231890f, -0.19516858f, -0.21258041f, 0.01306174f, 0.07944475f, 0.14108495f, 
    0.05606147f, 0.04902027f, 0.05590872f, 0.04160177f, -0.02783426f, -0.07945005f, 0.01203994f, 0.00981732f, 
    -0.07836533f, -0.06109401f, -0.08191464f, -0.13806148f, 0.07077127f, 0.06161573f, 0.03459335f, -0.03170535f, 
    -0.05887499f, -0.13941884f, -0.03416687f, -0.04297392f, -0.12811588f, -0.00402730f, -0.08987550f, -0.02271101f, 
    -0.00558888f, -0.06328796f, -0.13380869f, 0.01496827f, -0.03259243f, -0.03716579f, -0.13444766f, -0.06983554f, 
    0.05333388f, 0.12052068f, -0.02791330f, -0.05189668f, -0.19961838f, -0.00813951f, -0.02955175f, 0.03504993f, 
    0.01166102f, -0.27746841f, -0.04321639f, 0.02192263f, 0.00048081f, 0.01380222f, 0.12344930f, -0.00326955f, 
    -0.03989686f, 0.20572113f, 0.03444709f, 0.02870935f, 0.09487455f, -0.06031100f, -0.00987261f, -0.15210979f, 
    -0.02633932f, -0.10465388f, 0.04109840f, -0.05211783f, -0.10286316f, -0.08669477f, -0.04433058f, 0.07213215f, 
    0.08134326f, -0.02423076f, 0.08157702f, -0.19200248f, 0.00349531f, -0.01827245f, 0.09527405f, 0.04516008f, 
    -0.09275315f, 0.38573739f, -0.19440132f, -0.04434808f, 0.02544256f, -0.09493537f, 0.16817354f, 0.01855683f, 
    0.00856221f, 0.08603310f, 0.07290704f, -0.00906708f, 0.01487262f, -0.01060193f, 0.03923127f, 0.08509187f, 
    0.13349050f, 0.01078139f, 0.01217148f, 0.08428074f, -0.65246928f, 0.05191905f, 0.09845191f, 0.07460070f, 
    0.24289389f, 0.04842690f, -0.17367135f, -0.13098709f, -0.05873489f, -0.12061825f, 0.10347302f, 0.08346948f, 
    -0.14165126f, -0.00487000f, 0.07088125f, 0.20218912f, 0.02530972f, -0.05062873f, 0.00114577f, -0.14886220f, 
    0.62956202f, 0.28596607f, -0.08361523f, 0.08968826f, -0.27802381f, -0.03899124f, -0.01826866f, -0.08287328f, 
    -0.11463840f, -0.05478375f, 0.09041091f, 0.00194942f, 0.11597678f, -0.00007722f, 0.09385592f, 0.11033028f, 
    0.14017555f, 0.10346590f, 0.00997820f, 0.08192702f, 0.35626751f, 0.28736052f, 0.02541749f, -0.01884039f, 
    -0.00528519f, -0.02769146f, -0.02717284f, -0.02085900f, 0.04683341f, 0.09155113f, 0.10271929f, -0.00466105f, 
    0.10388747f, -0.07118562f, 0.01781788f, 0.08489322f, -0.02686306f, -0.11697526f, 0.09026911f, -0.11079110f, 
    -0.24276979f, -0.22739281f, 0.54436827f, -0.03182351f, 0.10549600f, 0.09734134f, -0.05012478f, -0.08209523f, 
    0.03652857f, 0.07036343f, 0.20051092f, 0.16274825f, -0.06766767f, 0.05472187f, 0.14108120f, 0.13109623f, 
    0.06627799f, -0.23111559f, 0.02088073f, -0.04679840f, 0.28705409f, 0.03443170f, 0.07895587f, -0.26307291f, 
    0.16131270f, -0.04743024f, 0.02478931f, 0.02976791f, -0.13623193f, 0.13344923f, -0.04858581f, 0.02174843f, 
    -0.08556170f, 0.17937914f, -0.15179060f, 0.17022899f, 0.02250635f, -0.00832414f, 0.10326526f, 0.09387065f, 
    0.29995105f, -0.15604591f, 0.10779881f, -0.12313057f, 0.13321736f, -0.10467225f, 0.05991619f, -0.13014078f, 
    -0.05820362f, -0.02098640f, -0.06702974f, 0.13685048f, 0.02565711f, 0.12127148f, 0.05145635f, -0.14866410f, 
    0.04204376f, 0.02043395f, -0.04881107f, 0.01834445f, 0.05349982f, -0.18953481f, 0.09931976f, -0.04784800f, 
    -0.27122453f, -0.06028578f, 0.06034580f, -0.15552069f, 0.07768046f, 0.01489598f, 0.02508285f, 0.00121040f, 
    -0.05269999f, 0.06861072f, 0.03022313f, -0.11531027f, 0.10020637f, -0.06970008f, 0.08574149f, 0.14275733f, 
    0.20837782f, 0.32875922f, -0.49540937f, 0.14205600f, -0.21454163f, 0.00535764f, 0.18528579f, -0.16273296f, 
    -0.08030649f, 0.05719988f, 0.05966527f, 0.04409786f, 0.10184339f, 0.17926177f, 0.09955417f, 0.05518784f, 
    0.02411383f, 0.15818822f, 0.11589127f, 0.20336661f, -0.20501463f, 0.07555643f, -0.18693540f, -0.24666782f, 
    -0.40267977f, 0.16113587f, -0.05154439f, 0.00534155f, -0.01088213f, -0.16439345f, 0.01423138f, -0.06839543f, 
    0.09456912f, 0.12983902f, 0.09060809f, -0.00538890f, -0.05219933f, 0.09469187f, -0.07638902f, -0.05045624f, 
    -0.22295327f, -0.27213088f, -0.51437593f, 0.05992974f, -0.04594459f, -0.05155149f, -0.00624345f, -0.16562338f, 
    -0.09893463f, -0.02079587f, 0.07207573f, -0.06147638f, 0.04772075f, 0.02826172f, -0.01166537f, 0.17990100f, 
    -0.04200090f, -0.09484599f, -0.16806218f, -0.07577856f, 0.07157400f, 0.19469123f, 0.01799571f, -0.30202550f, 
    -0.01053016f, -0.07541036f, -0.04803018f, -0.07693733f, -0.07600724f, 0.02855490f, 0.15986274f, -0.04045104f, 
    -0.16326284f, 0.05432930f, 0.00540932f, 0.02306947f, 0.01279479f, 0.04724308f, 0.19894113f, 0.02744102f, 
    0.05194754f, 0.23571227f, -0.35604039f, -0.11496822f, 0.20038785f, 0.02082076f, 0.11289465f, -0.01266603f, 
    -0.11172000f, -0.09728245f, -0.16621347f, -0.08692438f, -0.09249242f, 0.05676520f, 0.09639121f, 0.11334059f, 
    0.06825832f, -0.01961479f, -0.01898156f, 0.04235888f, -0.33768329f, -0.27042246f, -0.27226463f, -0.00709980f, 
    0.10386232f, 0.07281449f, -0.05633395f, 0.02419250f, 0.06571303f, 0.01868106f, 0.15855622f, -0.03931393f, 
    -0.03603492f, -0.05869764f, 0.12454968f, 0.03708617f, 0.09793315f, -0.02046544f, -0.07069512f, 0.07351163f, 
    0.28494394f, 0.21660736f, 0.13281740f, -0.12920581f, 0.24165100f, 0.01249675f, 0.25088698f, 0.13790995f, 
    -0.00238493f, 0.14902501f, -0.00545384f, -0.08934780f, 0.05846985f, 0.13574123f, -0.03410836f, 0.01073953f, 
    0.00620423f, -0.00225465f, 0.11748736f, -0.01797094f, -0.39769998f, -0.00949072f, 0.06207499f, -0.19578950f, 
    -0.00939370f, 0.02479037f, 0.03306593f, -0.09868382f, 0.02053391f, 0.09972578f, 0.17607568f, 0.01190880f, 
    -0.05173005f, -0.09107667f, -0.03281677f, 0.22251399f, -0.12062015f, -0.13180102f, -0.26284224f, -0.14718869f, 
    0.27008536f, 0.01185401f, 0.24516383f, -0.04245462f, 0.08335968f, 0.17058720f, 0.11258192f, -0.00052363f, 
    -0.01940997f, -0.03825142f, 0.05186207f, 0.06415880f, 0.03836764f, 0.00289798f, 0.00717307f, 0.03187460f, 
    -0.04506797f, -0.08042554f, 0.07782657f, 0.12695587f, 0.35501739f, 0.07095282f, -0.05681626f, 0.01950853f, 
    -0.23481490f, -0.08539499f, -0.00322460f, 0.05802225f, 0.02789689f, 0.14563963f, -0.01457730f, 0.03362282f, 
    0.10876614f, 0.01146513f, -0.02877655f, 0.03811143f, 0.06703582f, 0.01796168f, 0.09515721f, 0.21666771f, 
    -0.24852034f, -0.24070890f, -0.09765089f, 0.04819066f, 0.21363835f, 0.07269128f, 0.20182453f, 0.03602300f, 
    0.10755185f, -0.04163273f, 0.08510649f, -0.05369615f, 0.00492813f, -0.06112536f, 0.13449079f, 0.00172943f, 
    0.07032898f, 0.09059343f, -0.07898674f, 0.17634529f, -0.05787399f, 0.11805292f, -0.08294477f, -0.26487815f, 
    0.07428531f, 0.18313704f, 0.18004814f, 0.15531757f, -0.21992800f, 0.10168912f, -0.09325041f, 0.02350233f, 
    -0.00518310f, 0.19710857f, 0.09618036f, -0.11309960f, 0.11373980f, 0.25111273f, 0.01633522f, 0.06565423f, 
    0.05328318f, -0.04887490f, -0.52898443f, -0.03345035f, -0.02730694f, 0.16793390f, 0.06324548f, 0.06928959f, 
    0.06466668f, 0.05536354f, -0.18590978f, 0.03523058f, 0.04888615f, 0.14123367f, 0.00862431f, -0.08446763f, 
    0.08192988f, 0.09609909f, -0.09517862f, 0.00665048f, -0.24640791f, -0.04520120f, 0.12779316f, -0.15185878f, 
    0.11918177f, -0.05887366f, -0.19438633f, -0.04322993f, -0.04701991f, -0.28077254f, 0.10247064f, -0.00886035f, 
    -0.10554960f, 0.00351497f, 0.12026285f, -0.05991402f, 0.13626339f, -0.08630875f, -0.09532244f, -0.16037872f, 
    -0.27886242f, -0.03634005f, -0.23087594f, 0.21166724f, -0.17403756f, -0.03447334f, 0.06517002f, 0.01460656f, 
    -0.09066975f, 0.06480286f, 0.00990680f, 0.13595393f, 0.07016788f, -0.07197654f, 0.02398424f, 0.02950726f, 
    0.07845167f, -0.09713970f, -0.09744611f, -0.01902678f, -0.10602925f, 0.03996901f, -0.30261105f, 0.16185792f, 
    0.15970621f, -0.08730795f, -0.20017782f, -0.16798139f, -0.03069401f, -0.17220348f, 0.09561504f, -0.02130161f, 
    -0.11591902f, -0.00226832f, -0.02156422f, 0.05592055f, 0.08049066f, 0.11631460f, -0.10814622f, -0.01395288f, 
    0.06620693f, 0.15898088f, 0.19233160f, -0.07804847f, 0.25674856f, 0.01044792f, -0.04060516f, 0.07527012f, 
    -0.08172531f, 0.01239951f, 0.10573032f, 0.06293730f, 0.01174223f, -0.13679899f, -0.05961259f, -0.07533164f, 
    0.02794897f, -0.01646954f, -0.15606165f, 0.04211588f, 0.29742360f, 0.30156118f, 0.20736587f, 0.11227623f, 
    0.23521620f, -0.26693153f, 0.08937243f, 0.07276268f, 0.10093240f, 0.17744516f, 0.02798747f, -0.05315227f, 
    -0.01516366f, -0.04264526f, -0.08758497f, 0.03441352f, 0.07569072f, 0.12336068f, 0.11725605f, 0.13546711f, 
    -0.16524692f, 0.08537938f, 0.07993913f, -0.04091386f, -0.06852643f, -0.01002367f, -0.21290879f, -0.06583174f, 
    -0.00760032f, -0.16692738f, 0.16740060f, 0.01635511f, 0.00541537f, 0.04806108f, 0.01236319f, 0.10619836f, 
    0.01401222f, 0.03671434f, 0.04434835f, -0.02178668f, 0.49485338f, 0.17771342f, 0.09531586f, -0.10304947f, 
    0.18002291f, 0.07721928f, 0.00126007f, 0.02712899f, 0.02527639f, 0.13261203f, -0.10226627f, 0.13787296f, 
    0.04598930f, -0.09536519f, 0.01348700f, 0.08224261f, 0.05292593f, 0.17747484f, -0.10458864f, 0.02854547f, 
    0.41465116f, -0.53382742f, 0.02517851f, -0.09598510f, 0.14263059f, -0.01214649f, -0.11005858f, -0.13640419f, 
    0.16762994f, -0.02635069f, 0.08887717f, -0.06422067f, 0.16541632f, 0.03562611f, 0.04594176f, 0.06137319f, 
    0.05618725f, -0.00430387f, 0.06796536f, 0.05764024f, -0.11168198f, 0.16614011f, 0.08798269f, 0.13110198f, 
    -0.02972349f, -0.05303659f, -0.12813699f, -0.05093225f, -0.01891706f, -0.16703278f, -0.01789725f, 0.03395700f, 
    -0.02667492f, 0.03441224f, 0.02338360f, 0.04653030f, -0.00648746f, -0.01432999f, 0.06009988f, 0.01546795f, 
    -0.18240948f, -0.16831440f, -0.21934658f, 0.18824546f, 0.01770437f, -0.03398914f, -0.11758070f, -0.15480769f, 
    -0.00837080f, 0.16910173f, 0.03852425f, 0.04640317f, -0.00226351f, -0.00148354f, 0.06250902f, -0.06421924f, 
    0.15595646f, 0.08589114f, 0.00948576f, 0.05722826f, -0.21061379f, -0.33319458f, -0.17497501f, 0.04982464f, 
    -0.06102553f, 0.03982663f, -0.02005035f, 0.00513028f, -0.03523521f, -0.05833060f, 0.04596245f, -0.03768137f, 
    0.11574158f, 0.00911246f, -0.04372159f, 0.06840216f, 0.15959685f, 0.07761665f, 0.11607017f, 0.15540206f, 
    -0.15266524f, -0.05753172f, -0.19732933f, 0.00409225f, 0.18267293f, 0.08546269f, -0.02046573f, 0.09201166f, 
    0.07231647f, 0.02641025f, -0.02730163f, -0.04922567f, -0.01829055f, 0.01646584f, 0.10912820f, 0.04188748f, 
    0.10039515f, 0.04076195f, -0.15746735f, 0.09047123f, 0.41633794f, 0.17220876f, -0.05169006f, 0.05428372f, 
    -0.11024711f, -0.11654060f, -0.04974237f, 0.02452979f, -0.08593212f, -0.03842952f, 0.09809814f, -0.11383507f, 
    0.00976820f, -0.01212623f, 0.04823148f, -0.04632139f, -0.08388077f, 0.01181680f, 0.09070916f, 0.07182702f, 
    0.02399370f, 0.15863901f, 0.24667589f, -0.05951580f, 0.14881827f, 0.05814516f, -0.08842549f, -0.06291288f, 
    0.05871078f, 0.07593264f, 0.05592857f, 0.06274119f, 0.05852601f, -0.01334003f, -0.02488520f, 0.01680098f, 
    0.10992901f, -0.10993925f, 0.09676059f, 0.10912559f, -0.18795449f, 0.10917923f, 0.08525564f, 0.00436663f, 
    0.05838455f, 0.15968189f, -0.00182140f, -0.12829627f, 0.34409142f, -0.07968089f, 0.04908540f, 0.01569141f, 
    -0.10885686f, -0.00997715f, 0.05251139f, -0.01321770f, 0.08425741f, -0.02411340f, 0.06449689f, -0.09359922f, 
    0.52993453f, -0.12202803f, 0.04475376f, -0.20162618f, -0.21001279f, -0.04763782f, -0.10692324f, -0.09540337f, 
    -0.12881988f, -0.27756643f, -0.04361939f, -0.14130566f, -0.05335531f, -0.00634554f, 0.08367229f, 0.13608353f, 
    0.01019020f, -0.01326339f, 0.10400251f, -0.06390951f, -0.38337526f, 0.12897825f, -0.31850752f, 0.20649678f, 
    -0.13485117f, 0.11012523f, -0.14356831f, 0.02200815f, -0.23103486f, -0.01021292f, -0.01053915f, 0.02125277f, 
    0.04148361f, 0.05012420f, -0.09720957f, 0.07302372f, -0.01879534f, 0.13935755f, 0.02208398f, 0.05585826f, 
    -0.13254781f, -0.03081275f, -0.06991534f, -0.15617378f, -0.01008610f, 0.06002759f, 0.07887630f, 0.05227855f, 
    0.03395374f, -0.02668313f, 0.10972505f, -0.11051121f, -0.00213609f, -0.00817474f, -0.03484267f, 0.13844372f, 
    0.05517175f, 0.12123223f, 0.15687428f, -0.03263899f, -0.27894646f, 0.32689351f, 0.38799250f, -0.07627378f, 
    0.07535951f, -0.23397759f, -0.10127801f, -0.09321986f, -0.03512680f, -0.00322335f, 0.10296085f, -0.00493917f, 
    -0.07504157f, 0.12162016f, 0.02897723f, 0.04643742f, 0.02995380f, -0.07458887f, 0.02508414f, -0.04409920f, 
    0.05738252f, -0.20537813f, 0.04209704f, 0.12475345f, -0.07682653f, 0.03527230f, 0.17808940f, 0.09817359f, 
    -0.01005980f, 0.15184534f, 0.05752034f, 0.05989069f, 0.17979720f, 0.04995450f, -0.10570294f, 0.09411760f, 
    0.09774872f, -0.00573063f, 0.09407637f, 0.01854492f, -0.02732192f, -0.18889058f, -0.07942567f, 0.09362647f, 
    0.00751918f, 0.02976463f, -0.02867691f, 0.12169265f, 0.05713498f, 0.22283791f, -0.02231289f, 0.08142077f, 
    0.04542967f, 0.08951619f, 0.00158034f, -0.18040402f, -0.08377296f, 0.04853071f, -0.10019378f, 0.01597920f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01239058f, 0.01088292f, -0.00406529f, 0.03167153f, 0.00479405f, 0.03478242f, 0.00120834f, 0.04461481f, 
    0.07743104f, -0.02633523f, 0.02892300f, 0.00792370f, 0.03259086f, -0.11986880f, -0.02625792f, 0.00866660f, 
    -0.05985117f, 0.09429152f, 0.03313225f, -0.01656663f, -0.00420410f, -0.06328893f, 0.17894617f, 0.03607677f, 
    -0.04095527f, 0.05540805f, 0.18590164f, 0.00241114f, 0.11317250f, 0.01648334f, 0.11838391f, 0.07297956f, 
    0.06053584f, 0.00966478f, 0.00519439f, 0.13004911f, 0.04822384f, 0.10882019f, -0.15381964f, 0.12131223f, 
    -0.05544341f, 0.01064191f, -0.06713320f, -0.00889887f, -0.03533132f, -0.00373269f, 0.16159698f, 0.14327948f, 
    0.04835423f, -0.05954251f, 0.04170345f, 0.18020043f, -0.05928928f, -0.00098493f, 0.13176148f, 0.16989148f, 
    -0.01519049f, 0.15504299f, 0.02731127f, 0.02053926f, -0.07976751f, 0.17976566f, -0.06052239f, 0.15910009f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.06152999f, -0.15650599f, 0.08279003f, 0.04034933f, 0.00878650f, 0.09155644f, 0.09594018f, 0.02673920f, 
    0.03205987f, 0.11269782f, 0.10855447f, -0.04143555f, -0.06768347f, -0.07940727f, 0.03341268f, 0.13215043f, 
    -0.08417125f, 0.23833883f, 0.07499997f, -0.02872670f, 0.05379258f, -0.06262820f, 0.21379165f, 0.04098712f, 
    -0.09818503f, -0.12022689f, 0.20950796f, 0.18753549f, 0.17386593f, 0.01527842f, 0.04886545f, 0.05095569f, 
    -0.19123404f, -0.10442472f, 0.08511044f, 0.15660207f, 0.03401647f, -0.01240248f, -0.35695976f, -0.03559587f, 
    -0.06667322f, -0.16111778f, 0.01548949f, 0.13313520f, -0.11458064f, 0.26331261f, -0.22985241f, 0.31812170f, 
    -0.02264421f, -0.02881053f, 0.13582318f, 0.27600682f, 0.02818610f, -0.09183273f, 0.25575289f, 0.25259450f, 
    0.12594561f, 0.17921580f, -0.07769442f, -0.04993961f, -0.08966626f, 0.10594199f, -0.23648061f, 0.17359763f, 
    -0.06849732f, -0.06764310f, -0.03211463f, -0.20436847f, 0.05213509f, 0.03840189f, 0.00243217f, -0.09305710f, 
    -0.24208882f, 0.01470327f, 0.11305711f, 0.10290072f, -0.07971114f, -0.01823427f, 0.16761881f, 0.13920060f, 
    0.03632519f, 0.25772703f, 0.11396372f, -0.03719246f, -0.02687295f, -0.03838801f, 0.10963807f, 0.12139673f, 
    -0.07683389f, -0.04406928f, -0.25927383f, 0.19137795f, 0.30774310f, -0.10110914f, -0.03882965f, 0.21438704f, 
    0.10120075f, 0.10945659f, 0.10107238f, 0.10246971f, 0.11120912f, 0.25986964f, -0.27854589f, 0.07391405f, 
    0.02126627f, 0.06754253f, -0.06918418f, 0.04297996f, -0.05082671f, 0.04477799f, 0.12791450f, -0.03866183f, 
    0.11821198f, 0.02124303f, 0.16206014f, 0.03258604f, -0.11084971f, 0.04358689f, -0.01560799f, 0.11133141f, 
    -0.41530529f, 0.12496901f, 0.18439823f, -0.00456901f, 0.04910970f, 0.14816490f, 0.00905569f, -0.00500223f, 
    0.09182847f, -0.12694418f, -0.09980267f, -0.07644959f, 0.07797575f, 0.07511617f, 0.01939274f, 0.09467129f, 
    -0.18667559f, -0.10530479f, -0.09709722f, -0.11523615f, -0.05724591f, -0.05732624f, 0.02621338f, 0.12601535f, 
    0.04646470f, -0.03327331f, -0.03608894f, -0.14240372f, -0.08208053f, -0.10021618f, -0.28516138f, 0.03549193f, 
    -0.07344563f, -0.03408368f, -0.13156959f, -0.01322681f, -0.13980921f, 0.05438268f, -0.20768976f, 0.08339377f, 
    0.14884688f, 0.03256944f, -0.05783074f, 0.10915483f, -0.19415323f, -0.08493879f, -0.12145697f, -0.11895948f, 
    -0.11048345f, 0.02451453f, 0.10935360f, -0.15174560f, 0.12286049f, -0.11939741f, -0.06598138f, 0.10268833f, 
    0.03554331f, -0.07907321f, 0.01187754f, 0.11224831f, -0.12179051f, -0.20306341f, 0.09019334f, -0.06183503f, 
    -0.08778048f, -0.11291638f, -0.08859731f, 0.11406243f, -0.06249153f, -0.10204577f, -0.11651271f, 0.17996435f, 
    -0.12085651f, 0.19727908f, -0.05083842f, -0.15642108f, -0.00003226f, 0.01244279f, 0.26558310f, 0.00271041f, 
    0.20402847f, -0.04281845f, 0.09437162f, -0.12412298f, 0.00932607f, 0.01500163f, -0.20759153f, 0.15912633f, 
    0.02043077f, -0.12474178f, -0.10008646f, -0.05825764f, 0.09106156f, 0.00314873f, -0.08455021f, 0.03609492f, 
    0.08272840f, 0.02988389f, 0.16775660f, -0.09143522f, 0.11423348f, -0.00489987f, 0.06066317f, -0.00881736f, 
    -0.02464599f, 0.06151851f, -0.05591356f, 0.14228971f, 0.19938961f, -0.10584104f, -0.02497896f, -0.04262322f, 
    -0.05398441f, 0.22679801f, -0.06050131f, 0.09929410f, -0.05856221f, 0.10447583f, 0.27001214f, 0.10306954f, 
    -0.04595456f, -0.02580153f, 0.11933547f, -0.29505336f, 0.09166860f, 0.13487758f, 0.02647315f, -0.01021444f, 
    -0.21398346f, 0.12308968f, 0.04249480f, 0.09899389f, -0.12592007f, -0.03079738f, 0.11547485f, -0.03921219f, 
    -0.00992046f, -0.02188183f, 0.02175400f, 0.00932671f, -0.09226350f, 0.02759013f, -0.04945263f, -0.10291851f, 
    -0.20240615f, -0.08403975f, 0.03979346f, 0.08699378f, -0.03441095f, -0.00389101f, -0.16734423f, -0.08698983f, 
    -0.02543931f, -0.14188875f, -0.07463366f, -0.09912538f, 0.00391072f, 0.06174852f, 0.08428044f, 0.06585225f, 
    -0.05147777f, -0.11628284f, -0.19200945f, -0.22965410f, 0.11386919f, 0.11453867f, 0.02965521f, -0.01015391f, 
    -0.13905510f, 0.10724467f, -0.11516625f, -0.26330566f, -0.24756639f, -0.02713854f, 0.13237877f, -0.14509618f, 
    -0.07216484f, -0.04710134f, -0.02692205f, -0.01635645f, 0.06097415f, -0.00498551f, 0.01650013f, -0.06133470f, 
    0.11942542f, -0.06026100f, -0.13258487f, 0.17772855f, -0.11310601f, 0.04353628f, 0.08419195f, -0.11959996f, 
    -0.32157516f, 0.02115280f, -0.08582749f, 0.02072495f, 0.04929388f, -0.11402910f, -0.20083988f, -0.19526136f, 
    0.06419287f, -0.10774403f, -0.10600245f, 0.07763898f, -0.03919570f, -0.02483403f, -0.04683146f, -0.09250852f, 
    -0.02019067f, 0.05308047f, 0.05994363f, -0.00359600f, 0.03483885f, -0.07799956f, -0.08479011f, -0.00923791f, 
    0.01594849f, -0.13971102f, 0.01718929f, -0.06038108f, -0.04139554f, 0.07408887f, -0.11916748f, 0.04932860f, 
    -0.02719846f, -0.10027134f, -0.04890042f, 0.02553880f, -0.00213950f, 0.03964444f, -0.11695576f, -0.01997414f, 
    -0.05546748f, -0.11612538f, 0.01752798f, -0.06266016f, 0.01898129f, -0.09744132f, -0.09637046f, -0.04581739f, 
    0.09191597f, 0.04235660f, 0.04953668f, -0.00448130f, 0.12133756f, 0.05350444f, 0.02077380f, 0.06920056f, 
    0.03315088f, 0.07124664f, -0.03098867f, -0.13028906f, 0.05143837f, -0.01633393f, 0.04228236f, -0.07189202f, 
    0.00468499f, 0.04531331f, 0.04331683f, -0.01068564f, -0.14828449f, -0.02648058f, -0.05642799f, -0.01331013f, 
    -0.00433113f, -0.15440589f, -0.09798188f, -0.21074718f, 0.06522116f, -0.10865724f, 0.08753686f, -0.30484805f, 
    -0.22871223f, -0.03962239f, 0.07045835f, -0.10500274f, -0.00155764f, 0.13415863f, 0.02203634f, 0.17788240f, 
    0.12309637f, -0.01693171f, 0.00332611f, -0.26009497f, 0.04815125f, 0.08028516f, 0.09625906f, 0.09185182f, 
    -0.00105671f, 0.12698109f, -0.06421239f, 0.36237159f, 0.16264561f, 0.11031892f, 0.21720910f, -0.05373662f, 
    0.15931807f, 0.03283603f, -0.01047947f, 0.08212435f, 0.23559447f, -0.07699506f, -0.21250431f, -0.15419644f, 
    -0.03889442f, 0.12971722f, 0.04021323f, 0.04007580f, 0.08859743f, 0.30100304f, 0.35123098f, 0.24258317f, 
    -0.01787057f, -0.08291906f, 0.10795695f, 0.19809698f, -0.04397051f, 0.04990653f, 0.00231340f, 0.17006087f, 
    0.16831721f, 0.19120817f, 0.02626414f, 0.01161898f, -0.13658948f, 0.27944991f, 0.10344923f, -0.20288067f, 
    0.07946710f, -0.16179818f, 0.01292734f, -0.24363115f, -0.08543865f, -0.02588837f, 0.19762474f, 0.08809886f, 
    -0.08708510f, -0.01835631f, -0.06424769f, -0.04306858f, -0.05204283f, 0.11817104f, 0.11835503f, 0.01035843f, 
    -0.05726516f, 0.21601950f, 0.09236818f, -0.13914031f, 0.07380804f, -0.00912058f, -0.05590764f, 0.00600482f, 
    0.01771954f, -0.10512698f, 0.03217054f, 0.01381957f, -0.21727963f, 0.05565129f, 0.07139919f, -0.09466989f, 
    -0.19249919f, 0.00543807f, 0.06315926f, 0.22512421f, -0.08418684f, -0.21579301f, 0.02956147f, -0.04084869f, 
    0.07949495f, 0.02381818f, 0.10242309f, 0.15111470f, 0.08930004f, 0.14359486f, -0.29660952f, 0.17023236f, 
    0.11231502f, 0.00486180f, 0.19794489f, -0.14447342f, -0.12635890f, -0.29227093f, 0.21068831f, 0.06449785f, 
    0.34918034f, -0.14084351f, 0.24838592f, -0.11138052f, -0.12488975f, -0.31956211f, 0.05034781f, 0.22108948f, 
    -0.04675254f, 0.14091738f, -0.10644516f, 0.29577067f, 0.13935497f, -0.06966271f, 0.22684352f, 0.22573563f, 
    0.29108888f, -0.03998109f, -0.11194950f, -0.00774875f, 0.11247220f, 0.00673882f, 0.23656762f, -0.04383187f, 
    -0.04127096f, 0.31840739f, 0.05419977f, 0.20763002f, 0.01359167f, 0.00092552f, 0.15453850f, 0.06824359f, 
    -0.06962571f, -0.28852144f, 0.23875149f, -0.02907602f, -0.00826705f, 0.01776397f, -0.04193754f, -0.06775726f, 
    -0.21125269f, -0.09390303f, -0.08362535f, 0.03085799f, -0.21954712f, -0.31362653f, 0.01447728f, -0.13591245f, 
    0.11687277f, 0.03310128f, 0.01421136f, 0.00920345f, -0.02355479f, 0.18248039f, -0.30838591f, 0.07694755f, 
    -0.01613241f, 0.11589071f, 0.05446162f, -0.25115266f, -0.11004484f, -0.20520107f, 0.11134999f, 0.13659997f, 
    0.30118710f, -0.20476803f, 0.15393637f, -0.02656263f, -0.18973255f, -0.38547114f, -0.07300808f, 0.24838972f, 
    0.06330755f, -0.09677219f, -0.08137222f, -0.08116541f, 0.00704685f, 0.03577597f, -0.11623497f, 0.19351159f, 
    0.10475378f, 0.11004137f, 0.11467588f, -0.02152252f, 0.02875562f, 0.05727855f, -0.10136141f, -0.15273429f, 
    0.00975521f, -0.09831312f, -0.00439691f, -0.32850596f, 0.10206058f, 0.11583810f, -0.34707826f, -0.00609530f, 
    0.06828504f, -0.14367785f, -0.03024783f, -0.18066250f, -0.00057859f, 0.06557003f, 0.24944046f, 0.15397231f, 
    0.05357170f, 0.00353813f, 0.11771461f, -0.08342391f, -0.10707939f, 0.01663722f, -0.32877156f, -0.04264579f, 
    0.08083977f, -0.22258885f, 0.05232056f, -0.22169659f, 0.01759037f, -0.04180601f, -0.26119930f, 0.02110083f, 
    0.07019928f, 0.02545796f, 0.09708387f, 0.11881357f, 0.05121163f, -0.11155503f, -0.06228218f, -0.08419908f, 
    -0.12081284f, -0.22828610f, -0.07675821f, -0.06304744f, 0.16496745f, -0.05510562f, -0.22998524f, -0.14304011f, 
    -0.00536314f, 0.29283878f, -0.11135637f, 0.09992071f, -0.00563581f, -0.10706329f, 0.41464558f, -0.22130942f, 
    0.08449905f, -0.12655371f, -0.06486063f, 0.10345152f, -0.02028063f, 0.19308943f, -0.11669536f, 0.22601214f, 
    0.07980128f, -0.41846243f, 0.01140490f, 0.08248395f, -0.10137526f, 0.07739466f, -0.04657636f, 0.08481620f, 
    -0.09946408f, 0.08919410f, 0.18413310f, -0.15343675f, -0.21905750f, -0.03791726f, -0.15186423f, 0.17995781f, 
    -0.05842388f, -0.03057609f, 0.07065934f, 0.07683956f, -0.12781447f, -0.39182714f, 0.30618262f, -0.24446709f, 
    -0.04917129f, 0.20943527f, 0.06058301f, 0.07948697f, -0.11592479f, 0.14539337f, 0.27782464f, 0.20721290f, 
    0.09755722f, 0.08455480f, 0.07090892f, -0.39179051f, 0.02680474f, 0.17437816f, 0.09194971f, -0.00997416f, 
    0.36401719f, 0.27346998f, 0.15065826f, 0.04123650f, 0.16775435f, -0.13133615f, 0.38658476f, -0.17594939f, 
    0.02814219f, 0.18833764f, -0.05024363f, 0.24449658f, 0.08899377f, 0.06921047f, -0.14648126f, 0.31872898f, 
    -0.27750751f, 0.09966938f, -0.09775730f, -0.08994476f, -0.08499140f, -0.17884997f, 0.30364043f, 0.02804316f, 
    -0.03702109f, 0.10310449f, 0.12068149f, 0.07365913f, 0.07042865f, -0.02476942f, -0.03708642f, -0.08987252f, 
    -0.11533628f, 0.10626345f, 0.20608279f, 0.04312725f, -0.11779194f, 0.09030726f, 0.09645598f, -0.30993822f, 
    -0.03994112f, -0.04132284f, 0.05364582f, -0.05805911f, 0.00613364f, 0.07089052f, 0.07373642f, 0.27942103f, 
    -0.20174183f, 0.00040984f, -0.04959768f, -0.27036193f, -0.03379553f, -0.06614968f, -0.36079034f, -0.00704630f, 
    -0.00827212f, -0.03477897f, -0.08178049f, 0.26338705f, 0.11197610f, -0.09512667f, 0.14555660f, 0.10178436f, 
    0.34375355f, -0.22751351f, 0.02130035f, -0.00376094f, 0.04180352f, 0.03142771f, -0.09536650f, 0.12637520f, 
    0.05753715f, 0.00950192f, -0.11462043f, -0.04149367f, 0.00689782f, -0.00633596f, -0.01539588f, -0.03894403f, 
    -0.11848398f, 0.11485276f, 0.08324081f, 0.00520430f, -0.08845362f, -0.05164891f, -0.06224959f, 0.06341559f, 
    -0.12472805f, -0.09261748f, -0.00732199f, -0.03100889f, -0.03253474f, -0.04986421f, -0.13379289f, 0.07735259f, 
    -0.11692053f, -0.01702282f, -0.12651753f, -0.09060930f, 0.05029530f, 0.04348952f, -0.16194677f, -0.09940629f, 
    -0.15096365f, 0.04260277f, 0.10992941f, -0.05417630f, -0.12079924f, -0.12992708f, -0.18683060f, -0.12947959f, 
    -0.01088484f, 0.03241215f, -0.05190963f, -0.11198230f, 0.08339663f, -0.05511095f, -0.02751848f, 0.04230867f, 
    -0.09397624f, -0.04142142f, -0.07064335f, -0.01814508f, -0.04353510f, -0.04889230f, -0.00244191f, -0.20462731f, 
    -0.07186741f, -0.00825865f, -0.04113571f, -0.01314011f, -0.07222547f, 0.04479199f, -0.05976290f, 0.04874150f, 
    0.01672453f, 0.21927093f, 0.03084703f, 0.36344379f, 0.05932026f, 0.10789870f, 0.31159446f, 0.26095566f, 
    0.36457747f, 0.05527142f, -0.11819915f, -0.00670550f, -0.03974135f, -0.03734315f, 0.19576791f, -0.07297245f, 
    0.09395491f, -0.02780677f, 0.09063922f, 0.25138071f, -0.02979048f, 0.01524223f, 0.16546805f, 0.00522608f, 
    -0.01569952f, -0.02655157f, 0.15270698f, -0.26369917f, 0.09140583f, 0.04340124f, -0.18441859f, -0.17002855f, 
    0.05946613f, -0.10575487f, 0.11546040f, -0.03362368f, 0.11174923f, 0.21032363f, -0.09087301f, 0.27656713f, 
    0.07512126f, 0.05891617f, 0.02389405f, 0.20625293f, -0.09802334f, -0.17233591f, -0.04955152f, -0.11605804f, 
    -0.09042592f, -0.02505172f, 0.05288934f, -0.06167122f, -0.00708225f, 0.09673588f, -0.05354886f, -0.05335090f, 
    -0.34464091f, 0.10912155f, 0.12485556f, -0.05747488f, -0.22272232f, -0.15542459f, -0.08599841f, 0.21998087f, 
    0.07513404f, -0.06110375f, -0.03292570f, 0.10412354f, 0.05607094f, -0.11713391f, 0.00211653f, 0.08125343f, 
    0.48000732f, 0.08418801f, -0.01094970f, 0.02026891f, -0.09843577f, -0.03072935f, -0.29992414f, -0.03964799f, 
    0.06674784f, -0.08489353f, 0.04340084f, 0.19205709f, 0.07385039f, 0.06203708f, 0.23326784f, 0.10802270f, 
    0.00822162f, -0.10756255f, 0.12157403f, -0.12021457f, 0.36742389f, -0.07479025f, 0.23085956f, 0.07201333f, 
    0.16537747f, -0.03485260f, 0.10636248f, 0.25145736f, -0.01806984f, 0.04137999f, 0.22232090f, -0.17430173f, 
    0.23319396f, -0.07891889f, -0.10085204f, 0.01975741f, -0.05854804f, 0.05753770f, 0.16356869f, -0.07449113f, 
    -0.00390448f, -0.06440773f, -0.07060391f, 0.13162173f, -0.06101432f, 0.21903712f, -0.01368501f, 0.07443158f, 
    -0.25692093f, -0.01428686f, -0.11460979f, -0.06015246f, -0.29334533f, 0.18807779f, -0.24126251f, -0.00447107f, 
    -0.07825305f, -0.26870915f, 0.06298903f, -0.12240134f, 0.08618084f, -0.00405653f, 0.18196170f, 0.05344782f, 
    -0.23206481f, -0.00823673f, -0.05932325f, -0.10115296f, -0.07989316f, -0.04025099f, 0.21245474f, 0.06925349f, 
    0.11243489f, 0.05488287f, 0.04835170f, -0.20005110f, -0.00621606f, 0.08801012f, 0.13518028f, -0.06329249f, 
    0.12154792f, 0.11432594f, -0.08146306f, 0.06056192f, -0.06024672f, -0.00254801f, 0.01828237f, 0.05604801f, 
    0.04824813f, -0.09864619f, 0.11934701f, 0.14021917f, 0.11929584f, 0.00051310f, -0.26783761f, -0.11111255f, 
    -0.34148738f, -0.08988202f, -0.02226160f, 0.18926154f, 0.01955450f, 0.10263861f, -0.00132853f, 0.16382925f, 
    0.02709275f, -0.02371444f, 0.23656507f, 0.17240326f, 0.04769006f, -0.20156591f, 0.21830764f, 0.29949033f, 
    0.43069282f, 0.14896055f, 0.04964585f, 0.03557229f, 0.10507622f, -0.19747578f, -0.07036691f, -0.13793127f, 
    0.05644549f, -0.02456730f, 0.00785471f, -0.01329270f, 0.10474418f, 0.05408165f, -0.07214163f, 0.24027006f, 
    -0.04012248f, 0.02172953f, 0.04370541f, -0.03991315f, 0.07885988f, -0.14610820f, -0.07019263f, -0.43330958f, 
    0.07793185f, 0.01713658f, -0.01412706f, 0.06856558f, 0.03163983f, 0.07209492f, 0.18933326f, 0.08210901f, 
    0.02058310f, 0.17930263f, 0.20933546f, -0.10975157f, -0.28112522f, -0.03806910f, 0.07331927f, -0.00220522f, 
    -0.26998556f, -0.02731706f, -0.05911862f, 0.22241683f, 0.08636577f, -0.25410816f, 0.21052524f, 0.11925446f, 
    -0.29340336f, -0.08309012f, 0.01599287f, -0.32931533f, -0.02326415f, 0.01796501f, 0.22878344f, -0.00823124f, 
    -0.08094867f, -0.08551881f, -0.04536827f, -0.12719670f, -0.05784588f, -0.02669514f, -0.04549386f, -0.02686734f, 
    0.03335164f, 0.11919297f, -0.08332403f, 0.10343356f, 0.07885473f, -0.20580930f, -0.31573489f, 0.29112446f, 
    -0.00224327f, -0.22613865f, 0.01583469f, -0.14565839f, -0.05635680f, 0.05125995f, 0.04328546f, -0.10060681f, 
    -0.16856253f, -0.03369815f, 0.05473361f, -0.09959251f, -0.13126396f, -0.05701274f, 0.19811900f, 0.03013186f, 
    0.11545464f, 0.10848439f, -0.07775407f, -0.09833264f, -0.07400621f, -0.09189703f, -0.00726647f, -0.03493441f, 
    0.05813317f, -0.10303726f, -0.02631282f, -0.00794676f, 0.32896799f, 0.09188110f, 0.21161087f, 0.00966312f, 
    0.33948907f, -0.01401159f, 0.05675048f, 0.18938598f, 0.02980061f, 0.36013442f, 0.07295705f, 0.12730852f, 
    -0.28795972f, -0.30433726f, 0.03403554f, -0.05894603f, 0.01736663f, 0.15315655f, -0.11532240f, 0.14583410f, 
    -0.00413023f, 0.01035172f, 0.17494294f, 0.21787642f, 0.02314182f, 0.09859195f, 0.17724490f, 0.18389499f, 
    0.15953983f, 0.11031068f, 0.02274277f, 0.02226377f, 0.00148382f, -0.00357211f, -0.03568035f, -0.08642661f, 
    0.06654927f, 0.06711711f, 0.00504762f, -0.09914718f, -0.00742574f, 0.08236161f, -0.02529759f, 0.10970116f, 
    0.11038445f, -0.05625676f, 0.05004033f, -0.06548307f, -0.11467258f, 0.09111661f, 0.08569916f, -0.08163738f, 
    0.00727753f, 0.00297803f, -0.05247892f, 0.03695488f, 0.04097843f, 0.07835829f, -0.09054159f, 0.07821795f, 
    0.04622006f, -0.11066256f, -0.12411763f, -0.07730993f, -0.01558248f, 0.10437579f, 0.04116276f, 0.02883250f, 
    0.13742383f, -0.09763963f, 0.08874957f, -0.00244526f, 0.05427894f, -0.12423699f, -0.07048499f, -0.10439139f, 
    -0.10394863f, 0.02884908f, 0.00546499f, -0.05271223f, 0.08108746f, 0.03867256f, 0.01141771f, -0.09137028f, 
    0.11277495f, 0.00408266f, -0.09356558f, -0.06008000f, 0.01984979f, 0.04939629f, 0.03840504f, -0.03160198f, 
    -0.02850494f, -0.04254640f, -0.08004738f, 0.10106038f, -0.14462975f, -0.10903416f, -0.05203934f, 0.00715991f, 
    -0.00632218f, 0.06367034f, 0.08542231f, 0.04303501f, -0.07178496f, 0.00195545f, -0.00733970f, -0.16596189f, 
    -0.05887187f, -0.02998698f, -0.06905161f, 0.06700640f, 0.08400217f, -0.05553785f, -0.11100998f, -0.04081858f, 
    0.11660542f, -0.06951231f, 0.08912611f, 0.00510283f, -0.04912547f, 0.04228595f, 0.03504171f, -0.08083083f, 
    0.11150937f, 0.08115557f, 0.09076159f, -0.00598064f, -0.25497183f, 0.12964803f, -0.06980167f, -0.14795871f, 
    -0.05023254f, 0.03045502f, -0.04793976f, -0.22784263f, -0.19363727f, -0.09080183f, -0.02221681f, -0.09659541f, 
    -0.18801193f, 0.06464721f, -0.05794612f, 0.05273733f, 0.07689112f, -0.00202548f, -0.03003508f, -0.21105751f, 
    -0.04868251f, 0.10631979f, -0.25385892f, -0.07741193f, 0.06601860f, -0.00603660f, 0.00005811f, -0.12831324f, 
    -0.08954423f, 0.09800675f, -0.03024376f, -0.03202707f, 0.02500963f, -0.22883874f, 0.02116928f, 0.05203712f, 
    -0.00321540f, 0.05565930f, 0.07780564f, 0.01147369f, -0.07076861f, -0.08955078f, -0.02274203f, -0.00914212f, 
    0.00774664f, 0.08922809f, 0.01889910f, -0.06301089f, -0.12253179f, 0.21946497f, -0.05537857f, -0.27225831f, 
    0.02150479f, -0.11591162f, 0.10326606f, 0.04821960f, 0.07352896f, 0.09881020f, 0.08506294f, 0.08692184f, 
    0.08255664f, 0.21666178f, -0.01323372f, -0.37345141f, -0.21042427f, -0.02324696f, -0.11252903f, -0.06900968f, 
    -0.34204409f, 0.01099856f, -0.08252461f, -0.23876761f, 0.19243903f, -0.24470209f, 0.05425259f, 0.13003136f, 
    0.07623221f, -0.06420530f, 0.07376896f, 0.11869758f, -0.01824591f, -0.10092146f, 0.11545736f, -0.07206769f, 
    0.02450811f, -0.04563569f, 0.02115612f, -0.14448284f, 0.10520233f, 0.01613877f, 0.06441083f, 0.09663631f, 
    -0.18091962f, 0.10672932f, 0.14164607f, 0.10520305f, 0.19079815f, -0.21654801f, 0.24154575f, 0.00268817f, 
    -0.07207254f, -0.02900104f, -0.11550052f, -0.02478741f, -0.01464648f, -0.07995220f, -0.07075285f, -0.02667067f, 
    0.03892283f, 0.06844062f, -0.04096219f, 0.02447896f, 0.06597833f, -0.10676636f, -0.01086848f, -0.10016400f, 
    -0.08113071f, -0.08096654f, 0.06912507f, -0.07168199f, -0.07461759f, -0.03390655f, 0.02870806f, -0.00008467f, 
    0.09319691f, -0.05399822f, -0.03904188f, 0.01112425f, -0.01869549f, -0.08250390f, -0.16519843f, -0.03718728f, 
    -0.13354976f, 0.05170394f, -0.06690989f, -0.09860814f, 0.02962704f, 0.13221712f, 0.09444037f, -0.08819462f, 
    -0.17753723f, -0.02075374f, 0.10795461f, -0.01460986f, 0.06520808f, -0.11226992f, 0.12184834f, -0.00771074f, 
    0.05306724f, 0.04635412f, -0.11960552f, 0.04828860f, -0.09628700f, 0.09599756f, 0.11319765f, -0.12564582f, 
    0.03579780f, 0.11960258f, -0.03440149f, 0.08168325f, -0.06880189f, 0.01270876f, -0.10723649f, 0.13831803f, 
    -0.11816926f, 0.00165472f, 0.06904811f, 0.20456912f, -0.03358429f, -0.09132767f, 0.21599461f, -0.13249715f, 
    0.17770423f, -0.02044614f, -0.01531804f, -0.02356759f, -0.04235357f, -0.29274198f, 0.01405888f, 0.13080448f, 
    0.03765799f, -0.38474810f, 0.11927827f, 0.29788730f, 0.08929402f, 0.03597863f, 0.02617353f, 0.02652434f, 
    -0.03457507f, -0.12237985f, -0.13053904f, -0.28852132f, 0.31954387f, -0.03686215f, 0.02524881f, -0.08277036f, 
    0.26086891f, -0.03151704f, 0.10644171f, -0.10395249f, 0.03076310f, 0.30867863f, 0.01244871f, 0.18054862f, 
    0.00928513f, -0.06056290f, -0.02917706f, -0.09064013f, 0.01955284f, -0.10389764f, 0.06544840f, 0.19627522f, 
    -0.10964130f, -0.03495683f, 0.01268724f, 0.09761483f, 0.10161960f, 0.13930158f, -0.01150736f, 0.09269392f, 
    -0.20353575f, 0.26716003f, 0.01200087f, -0.06554319f, 0.11201352f, 0.00869749f, -0.10720064f, -0.17304644f, 
    -0.01278080f, 0.12362795f, 0.09533660f, 0.03508765f, 0.03636116f, -0.12397532f, 0.14008255f, 0.24985181f, 
    0.17193069f, 0.06132755f, -0.11765812f, 0.05443348f, -0.06161058f, 0.09452664f, -0.35155600f, -0.05716805f, 
    -0.01089007f, -0.42739350f, -0.02036014f, 0.08450645f, -0.07568349f, 0.04438533f, 0.18613559f, 0.00624660f, 
    -0.05353689f, -0.12847912f, -0.01887271f, -0.14687225f, 0.18356314f, 0.09509215f, -0.02610609f, -0.11941857f, 
    0.32410657f, -0.10539445f, 0.12304248f, 0.28392169f, 0.00731822f, 0.00287322f, 0.40354931f, 0.15139359f, 
    0.03212867f, 0.23449488f, 0.10464112f, 0.00269987f, 0.08071594f, -0.10095819f, 0.22886625f, -0.23489363f, 
    0.05549411f, 0.02911232f, -0.11956293f, -0.14265588f, 0.01205713f, 0.18732420f, 0.07717182f, -0.11240601f, 
    0.12666945f, 0.05871350f, 0.00598952f, 0.09474577f, -0.11511359f, 0.20359850f, 0.05646024f, 0.09047473f, 
    0.01513110f, -0.06048512f, 0.03646657f, 0.03350187f, -0.03522231f, 0.07348891f, 0.04126811f, 0.42543536f, 
    -0.10124514f, -0.08022325f, -0.07443312f, -0.04430623f, -0.04649761f, 0.00800095f, 0.00740495f, 0.03221545f, 
    -0.06589463f, -0.34344321f, 0.03937529f, -0.10156816f, 0.09651843f, 0.09784097f, 0.11689354f, 0.09213467f, 
    -0.03825705f, 0.11294372f, 0.19897763f, 0.00211847f, -0.15200996f, -0.06701481f, 0.01820270f, -0.18918118f, 
    -0.00179468f, -0.08696249f, 0.04549669f, 0.32552224f, 0.13885897f, 0.00529726f, -0.36360088f, 0.33965248f, 
    -0.32367542f, 0.00335891f, -0.06901898f, 0.09867861f, 0.05900024f, -0.14860502f, -0.11702543f, 0.21315871f, 
    0.05164414f, 0.10616928f, 0.03063123f, -0.01246075f, -0.05918265f, 0.08962585f, 0.12522537f, 0.09199607f, 
    0.32684857f, 0.23694639f, 0.08158886f, 0.11919431f, -0.00916162f, 0.14079759f, -0.23145701f, 0.12269130f, 
    0.11308774f, -0.06715551f, -0.05143301f, -0.06527594f, -0.02072652f, 0.10866462f, 0.12233815f, 0.40743628f, 
    0.20110345f, 0.04715926f, 0.08406585f, -0.01892920f, 0.12184738f, 0.00688529f, 0.11410864f, -0.04939661f, 
    0.01942954f, 0.16051036f, 0.10907124f, 0.11507934f, 0.02341461f, -0.04176764f, 0.06949212f, 0.04643779f, 
    0.08153896f, -0.54933614f, 0.04535972f, -0.22540540f, 0.04776942f, -0.07694173f, 0.14978024f, -0.03223173f, 
    0.25455749f, 0.08473932f, 0.01673918f, 0.24980953f, 0.20856144f, 0.19376153f, 0.29813340f, -0.10013161f, 
    -0.04815565f, -0.07850970f, -0.05566357f, -0.03056218f, 0.07430128f, 0.00912419f, -0.36839920f, 0.00812703f, 
    0.11134904f, -0.03962980f, -0.10644513f, 0.09917972f, -0.04333264f, 0.20494322f, -0.07925959f, 0.03493298f, 
    0.01954307f, -0.27309251f, 0.02794227f, 0.11416165f, -0.40964362f, 0.13052601f, -0.12385977f, 0.23555586f, 
    -0.01657452f, 0.05555803f, -0.00269389f, -0.06414779f, -0.08301655f, 0.04342458f, -0.20071274f, 0.26708958f, 
    0.11163788f, -0.06676620f, -0.09054069f, -0.12220053f, 0.10476143f, -0.07331017f, -0.05446551f, -0.18003732f, 
    -0.10394338f, 0.43157127f, 0.01834160f, 0.10692690f, -0.08030626f, 0.10088131f, -0.08663774f, 0.08429787f, 
    0.04214856f, -0.15768947f, 0.27205208f, 0.13686705f, 0.09929997f, 0.09226159f, 0.10028955f, 0.15552957f, 
    -0.07582246f, 0.07488372f, -0.07009644f, 0.11721899f, 0.07320873f, 0.11117854f, -0.26221418f, -0.02616218f, 
    0.15457490f, 0.14880455f, -0.02393523f, -0.00182263f, -0.00593389f, 0.00127274f, -0.03719686f, -0.07184582f, 
    -0.11479095f, -0.04609349f, -0.07825109f, 0.21198168f, -0.01304279f, -0.14668190f, 0.08871235f, -0.14160210f, 
    -0.22825867f, -0.01582949f, -0.03529435f, 0.08117703f, 0.06497992f, 0.30209547f, -0.27809986f, 0.20866331f, 
    0.10064526f, -0.03241592f, -0.11340861f, 0.09968222f, 0.05753060f, -0.02413781f, 0.04455430f, 0.30004400f, 
    0.05045074f, -0.10091761f, 0.02578497f, 0.04284373f, 0.00179465f, -0.20558025f, 0.37771070f, 0.03551709f, 
    0.01057519f, 0.24263079f, -0.09434544f, 0.06417832f, -0.11173835f, 0.13103567f, -0.02658491f, 0.01600869f, 
    0.07461571f, -0.26424232f, 0.03288620f, -0.05668612f, 0.12486557f, -0.06335453f, 0.28327405f, -0.14011323f, 
    0.21701573f, 0.10473542f, -0.00454116f, 0.10422173f, 0.02857504f, 0.27621469f, 0.14406435f, -0.07154817f, 
    -0.00346441f, -0.23880957f, 0.01000628f, -0.24111320f, 0.07383077f, 0.05861495f, -0.27290738f, 0.15723120f, 
    0.04409405f, 0.04559614f, -0.06034395f, 0.09335254f, 0.02084622f, 0.07475806f, 0.19801225f, -0.00537103f, 
    0.40703803f, 0.06853096f, 0.11300021f, -0.06077099f, -0.18892299f, -0.11328071f, -0.18316327f, 0.09555332f, 
    -0.11756203f, -0.15406378f, -0.08011273f, -0.08835862f, 0.01653331f, -0.03808583f, 0.09462030f, -0.01765920f, 
    -0.49828276f, 0.05681047f, 0.01391033f, 0.09411287f, 0.01825797f, 0.14788993f, -0.20239289f, 0.09594844f, 
    -0.06226255f, -0.00366100f, 0.01638150f, 0.04002627f, 0.11521351f, 0.10063519f, -0.11596981f, 0.11676567f, 
    -0.07305632f, 0.19270049f, 0.14989144f, 0.38665727f, -0.24852391f, 0.12108906f, -0.07693987f, 0.09127507f, 
    -0.34143230f, 0.04506014f, 0.01887092f, 0.03029966f, 0.31151873f, -0.07441553f, -0.31740502f, 0.16423465f, 
    -0.17950773f, 0.28109676f, -0.02828557f, 0.04891724f, -0.10885359f, 0.09685106f, 0.22164322f, 0.24708667f, 
    -0.10189328f, -0.08835956f, 0.07929230f, 0.23613933f, -0.01355912f, -0.01423952f, 0.02898706f, 0.10244004f, 
    0.01841021f, 0.13747382f, 0.08961925f, -0.05145242f, 0.02144025f, 0.32293186f, -0.02624295f, -0.15434529f, 
    0.12521280f, 0.13383956f, 0.03509870f, 0.18681090f, -0.14674234f, -0.05087573f, 0.06274282f, -0.09793362f, 
    0.02894495f, -0.09702889f, -0.09458441f, 0.04232073f, 0.03576401f, 0.23050508f, -0.01530661f, 0.26800364f, 
    -0.10133479f, 0.06024499f, -0.10350889f, -0.09961605f, -0.01888156f, 0.00328034f, 0.01843349f, 0.04556205f, 
    -0.07005481f, -0.21333231f, -0.14174645f, 0.19608398f, -0.01708135f, -0.00643362f, -0.12600675f, 0.14507180f, 
    0.11558751f, -0.04515237f, -0.02827452f, 0.06735907f, -0.20670937f, 0.09292834f, -0.20049226f, -0.06234424f, 
    0.23528481f, 0.28515178f, 0.06857113f, 0.27730924f, 0.04885741f, 0.14783424f, -0.15188059f, 0.03397150f, 
    -0.09481625f, -0.11654847f, 0.14927647f, 0.04425475f, 0.12368979f, -0.02022367f, -0.07190088f, -0.10773773f, 
    -0.21442714f, -0.17280327f, 0.18847583f, -0.03399834f, -0.12819640f, 0.16162981f, 0.12250487f, -0.03517492f, 
    0.03633422f, -0.02781621f, -0.02354932f, -0.12460869f, -0.04816169f, -0.07932292f, 0.04303404f, 0.06411799f, 
    0.06363022f, -0.04349151f, -0.04742642f, -0.09422919f, 0.00426404f, 0.00874543f, -0.10715058f, -0.06962877f, 
    0.04778549f, 0.04273383f, -0.03299098f, -0.02729430f, 0.06114742f, -0.11375476f, 0.02364267f, 0.01793867f, 
    -0.11839727f, -0.11129829f, -0.00602095f, -0.14445990f, -0.12099930f, -0.06909966f, 0.03771592f, -0.07809894f, 
    0.02136737f, 0.06475452f, -0.07339899f, -0.08598040f, -0.09632290f, -0.02133690f, -0.13288417f, -0.01682481f, 
    -0.03386968f, -0.09850025f, 0.07968872f, -0.10729817f, 0.01438732f, 0.05365400f, 0.05575339f, 0.02119305f, 
    0.00020768f, -0.04906962f, -0.04518123f, 0.00052719f, -0.09255208f, -0.04885441f, -0.05793903f, 0.06677270f, 
    0.02270254f, -0.02600467f, -0.02418001f, -0.05162287f, -0.10972416f, -0.10736150f, -0.08144555f, 0.02199470f, 
    0.07398736f, -0.13573121f, -0.03170000f, -0.11043660f, -0.03255449f, -0.06623183f, -0.07571042f, -0.10898389f, 
    0.02655218f, 0.06497616f, 0.00959989f, -0.06281762f, 0.11256950f, 0.03067354f, 0.06509910f, 0.00716246f, 
    -0.08281483f, 0.03524753f, -0.00374568f, -0.00962885f, 0.02866818f, -0.04867917f, 0.04725004f, 0.02316327f, 
    0.02883950f, -0.02403602f, -0.03763292f, 0.00577096f, -0.03300396f, 0.09523889f, -0.03027180f, -0.10528272f, 
    -0.04570186f, -0.03841437f, -0.01485839f, -0.09900360f, -0.12169345f, -0.04465361f, 0.05391753f, -0.12117384f, 
    0.01074400f, 0.04934125f, 0.08092898f, -0.12011717f, 0.04422711f, 0.05683005f, -0.15114036f, 0.04862722f, 
    -0.08389799f, -0.01338936f, -0.14157540f, -0.00334886f, 0.06896132f, 0.02128201f, -0.15657875f, -0.01870286f, 
    0.07355744f, -0.14430699f, -0.10400233f, 0.06162190f, -0.09655070f, -0.03170418f, -0.10476334f, 0.08848442f, 
    0.09508298f, 0.22129078f, 0.11673956f, 0.39309040f, 0.08019550f, -0.05725888f, 0.21019340f, 0.00354286f, 
    0.21736491f, 0.10478970f, -0.07585686f, -0.02043459f, 0.11617723f, 0.07205059f, 0.16586222f, 0.26575902f, 
    -0.01750134f, -0.31334928f, -0.10652403f, 0.14260124f, 0.07829212f, -0.08170124f, 0.05441402f, -0.01705632f, 
    -0.09430800f, 0.06037986f, -0.06279008f, 0.03120235f, -0.18370444f, 0.00709420f, -0.18853010f, -0.28419837f, 
    0.04932568f, -0.01305992f, -0.06447142f, -0.29812819f, 0.07624234f, 0.24544157f, -0.21206203f, 0.32826707f, 
    0.16784021f, 0.22573510f, -0.05621250f, 0.18626954f, -0.07037653f, -0.27600566f, -0.09368615f, 0.19942325f, 
    -0.10870864f, 0.12917672f, 0.02822803f, 0.18821672f, -0.06787364f, 0.06707137f, -0.17056297f, -0.03626805f, 
    -0.11896354f, -0.15112260f, -0.06245535f, 0.03023745f, -0.08674016f, -0.11316205f, 0.02799626f, -0.01097425f, 
    0.01243395f, 0.21457809f, 0.01537497f, 0.08745228f, 0.05358446f, -0.04493470f, 0.02916005f, 0.27974868f, 
    -0.03155328f, 0.06567448f, 0.05214699f, -0.12064563f, 0.05467611f, 0.11618878f, -0.07460361f, -0.05076358f, 
    0.09963378f, 0.13472989f, 0.04262561f, -0.07356050f, 0.06349485f, 0.04143788f, -0.20206280f, 0.10200414f, 
    -0.07871349f, 0.07436498f, -0.06751126f, 0.18394546f, 0.03380857f, -0.07698773f, -0.02571442f, 0.05608255f, 
    0.06019631f, 0.03904811f, -0.09395866f, 0.17377804f, 0.13279554f, -0.03778884f, 0.18598993f, 0.03606419f, 
    0.01336052f, 0.32458413f, 0.04850467f, -0.06201845f, 0.03267246f, 0.12333404f, -0.19818205f, -0.22566828f, 
    0.06601556f, 0.01555024f, -0.10499413f, -0.39760548f, -0.09719759f, 0.12702608f, -0.48363388f, -0.39635098f, 
    -0.28922522f, -0.26176280f, 0.03252655f, -0.10420857f, 0.07767831f, 0.31605715f, 0.10370748f, -0.22948171f, 
    0.10312518f, 0.10642418f, 0.02715378f, -0.14300606f, -0.07338010f, -0.06986499f, -0.08065020f, -0.04278610f, 
    -0.37601778f, -0.08774203f, -0.06635848f, 0.01331560f, 0.01563685f, 0.04869458f, -0.12585340f, 0.01793691f, 
    -0.07293846f, 0.02957246f, 0.03826836f, -0.03024749f, 0.04212766f, 0.04384241f, -0.12762401f, -0.09349054f, 
    0.10729164f, -0.17509529f, -0.21455902f, 0.13933614f, 0.04025637f, 0.04554659f, -0.20884605f, 0.14519186f, 
    -0.00078371f, -0.04684083f, -0.09765705f, -0.01018301f, 0.07066645f, -0.01895742f, 0.02099741f, 0.16313599f, 
    0.10523140f, 0.00817596f, 0.07348853f, -0.22522070f, 0.11695728f, -0.15604544f, -0.12019333f, -0.11157498f, 
    -0.06260136f, 0.00578679f, -0.07867365f, 0.08224066f, -0.04574108f, 0.17385489f, 0.15612945f, 0.05263742f, 
    -0.19843428f, -0.22595239f, 0.06562654f, -0.06245798f, 0.04176463f, 0.00504695f, -0.13237770f, -0.05388841f, 
    0.12290902f, -0.07176270f, 0.04982328f, 0.06011572f, 0.00012721f, -0.06565398f, 0.02027335f, -0.05893080f, 
    -0.20091906f, 0.04823554f, 0.10830470f, -0.10532327f, -0.10754466f, -0.08798654f, -0.05565120f, -0.13595600f, 
    0.10233311f, -0.05674255f, 0.10684934f, 0.07497693f, 0.04129241f, 0.05002694f, -0.16411686f, 0.07601167f, 
    0.03159025f, -0.10669658f, -0.11744492f, -0.14023876f, -0.12702963f, 0.04339994f, -0.06298876f, -0.19286834f, 
    -0.05340337f, 0.08040448f, 0.06194152f, -0.12574473f, -0.02756801f, 0.05531914f, 0.01386845f, -0.09516290f, 
    -0.12261652f, 0.04540952f, 0.03568668f, -0.07377262f, 0.03733432f, 0.06501859f, -0.05204045f, 0.05501737f, 
    0.05335465f, 0.11009729f, -0.16311830f, -0.10066212f, -0.06412729f, -0.07538316f, -0.06403817f, -0.19890967f, 
    -0.03396322f, -0.03503804f, -0.00298608f, 0.03540172f, -0.00078682f, 0.02904533f, 0.03703287f, 0.10213528f, 
    -0.11282566f, 0.11530934f, 0.00616224f, 0.27527288f, -0.03736687f, -0.01968778f, 0.10276118f, 0.31930903f, 
    0.39799812f, 0.05187367f, 0.04817759f, 0.05655887f, 0.08897358f, 0.08606387f, 0.07584731f, 0.07425673f, 
    -0.04168533f, 0.31390560f, -0.00310917f, 0.24454704f, -0.07533730f, -0.07882458f, 0.13467623f, -0.05871524f, 
    0.09263276f, -0.14669117f, 0.26289961f, 0.12611485f, 0.21474746f, -0.01238808f, -0.23485410f, 0.06465717f, 
    -0.10912471f, -0.09990880f, -0.01074391f, 0.06511324f, -0.07157483f, -0.03379027f, -0.38533819f, -0.03629909f, 
    0.28183010f, 0.14907321f, 0.08633524f, 0.04479631f, 0.09959798f, -0.04172555f, 0.12426858f, -0.08669668f, 
    0.10015324f, -0.06906831f, -0.01215834f, 0.10152952f, -0.06724231f, -0.01214512f, -0.08472471f, -0.15295577f, 
    -0.37117290f, 0.00980453f, 0.02237226f, -0.06257460f, -0.47474524f, 0.21694666f, -0.52796960f, 0.19496502f, 
    0.04551063f, 0.07786779f, -0.04292347f, 0.00854146f, -0.11580683f, 0.09572057f, -0.04665975f, -0.09262005f, 
    0.02734642f, 0.01654944f, 0.03962353f, 0.12051667f, -0.09879944f, 0.09095573f, 0.04888137f, -0.14875883f, 
    -0.08236451f, -0.01671071f, 0.09768441f, -0.07297034f, 0.07848608f, 0.07673219f, 0.05529686f, -0.01739465f, 
    0.09192275f, -0.10045099f, -0.16083281f, -0.05350089f, -0.13542219f, 0.05964443f, -0.01561427f, -0.08799729f, 
    -0.11053215f, -0.06917363f, 0.00618680f, -0.15300675f, -0.16385227f, -0.15465866f, -0.04893648f, 0.06790430f, 
    -0.14595303f, 0.07573396f, 0.01920137f, -0.14369708f, -0.08994751f, 0.01515412f, 0.04658061f, 0.11606231f, 
    -0.01158269f, -0.10379906f, -0.12879062f, -0.13707656f, 0.06932576f, -0.13026479f, -0.08468339f, -0.11230231f, 
    -0.03693037f, 0.05045157f, -0.15376695f, -0.01305112f, 0.01935269f, -0.14314824f, -0.11358579f, -0.05832604f, 
    -0.01457117f, 0.16712181f, -0.04498275f, -0.29507068f, 0.08641265f, -0.02324185f, 0.09868450f, -0.02085109f, 
    -0.00237287f, -0.08388829f, -0.04759747f, -0.11712539f, 0.09051649f, 0.19743000f, -0.11381060f, 0.17095909f, 
    -0.04710050f, 0.08711295f, 0.09601812f, -0.06831745f, 0.04855292f, 0.05679582f, -0.08445837f, 0.01530943f, 
    -0.11043509f, 0.00302911f, 0.28228799f, 0.20516187f, 0.21525449f, 0.00668717f, 0.25133842f, 0.17539504f, 
    0.02426309f, -0.08075835f, -0.11077145f, 0.28203556f, 0.28978288f, -0.20658489f, -0.08353882f, -0.13689597f, 
    0.12276474f, 0.12294827f, 0.01843669f, 0.07540502f, 0.07942628f, 0.29735646f, 0.21177399f, 0.10773709f, 
    0.05271673f, -0.09756281f, 0.09146668f, -0.13991618f, 0.03809722f, 0.03731846f, -0.08696568f, -0.00280082f, 
    -0.05125186f, 0.00744695f, 0.09688151f, -0.02608433f, -0.03115935f, 0.23269242f, 0.12382124f, -0.06879364f, 
    0.08290618f, -0.01179285f, 0.02085957f, -0.22064002f, 0.12768556f, 0.05947211f, -0.23822306f, 0.38298798f, 
    -0.01726567f, 0.12170602f, -0.05310187f, 0.04345195f, -0.04499482f, -0.07662517f, 0.21618539f, -0.06885262f, 
    -0.06285769f, 0.58083338f, -0.07061795f, 0.02103565f, -0.09871901f, -0.01500612f, 0.14640689f, 0.10437702f, 
    0.08394761f, 0.00777119f, 0.11739821f, 0.03601885f, 0.17681211f, 0.03202795f, 0.26459581f, -0.25675580f, 
    0.12705792f, 0.10297905f, -0.10118673f, 0.06733581f, -0.04227874f, -0.02388162f, 0.26801959f, -0.01073776f, 
    0.18203931f, -0.15992375f, 0.11532049f, 0.01748180f, 0.10688695f, 0.14268357f, -0.18744051f, -0.21915138f, 
    -0.08242951f, 0.00834237f, -0.07595711f, -0.01627883f, 0.01075357f, -0.19733766f, -0.05924547f, 0.09806552f, 
    0.01487090f, -0.08421497f, 0.09072433f, 0.00467672f, -0.30848196f, 0.04162690f, 0.08577700f, 0.41529608f, 
    -0.01009902f, 0.13828540f, 0.06315687f, 0.00848353f, 0.07459909f, -0.01813694f, 0.18785363f, 0.03161117f, 
    -0.07014530f, 0.09010861f, -0.09385943f, -0.03084588f, 0.08923544f, 0.01435856f, 0.37674358f, 0.01667140f, 
    -0.08099398f, 0.30143780f, -0.06100987f, 0.03014941f, -0.08756331f, -0.12652192f, 0.20484608f, 0.06073641f, 
    0.00480323f, 0.08024488f, -0.05666434f, 0.06559087f, 0.04297177f, 0.08316205f, -0.13538134f, 0.05675627f, 
    0.07048699f, -0.05653907f, 0.02245529f, -0.00823623f, -0.09502319f, 0.04790284f, 0.04862617f, 0.07867306f, 
    0.18882440f, -0.09772394f, 0.11167438f, 0.11992089f, -0.07010005f, 0.14853062f, -0.03098452f, -0.20975769f, 
    0.07856748f, 0.07264301f, 0.21625614f, -0.33666816f, -0.08861019f, -0.01510539f, -0.12779437f, -0.11854904f, 
    0.12455814f, 0.06555630f, 0.25325954f, -0.04411228f, -0.05378520f, -0.36857429f, 0.36243749f, 0.16579707f, 
    0.00262982f, 0.13313046f, 0.00411032f, -0.07816094f, -0.06414220f, -0.07704362f, 0.06352678f, 0.20326948f, 
    0.45952079f, 0.10107361f, -0.07114410f, -0.09800614f, 0.12025538f, -0.18604073f, -0.07782557f, -0.17032470f, 
    0.06475729f, -0.15099570f, -0.01119350f, 0.08236913f, -0.11311137f, -0.10318921f, -0.00731296f, 0.05372895f, 
    -0.05138616f, -0.29641467f, 0.12928915f, -0.29766485f, 0.20682015f, 0.11806720f, 0.30447474f, -0.13381881f, 
    0.39768493f, -0.03628600f, -0.02984758f, 0.15725842f, 0.08547311f, 0.24536818f, 0.42153910f, -0.28801891f, 
    0.19082879f, -0.14211130f, -0.11019988f, 0.15546525f, 0.04877852f, -0.02501711f, -0.00739280f, 0.05402766f, 
    -0.05774431f, -0.07830816f, 0.00919608f, 0.07560505f, 0.11253949f, 0.17832814f, -0.01411498f, 0.05191981f, 
    -0.08066777f, -0.22576441f, 0.01851793f, 0.04044015f, -0.42746630f, 0.25263920f, -0.10575691f, 0.01158937f, 
    0.07635030f, 0.04252613f, -0.12243029f, 0.27591926f, -0.08266318f, -0.07935873f, 0.00706143f, 0.06088398f, 
    0.20491602f, 0.05008591f, -0.12834984f, -0.03340509f, 0.05124841f, 0.09493773f, -0.40510049f, 0.13340877f, 
    -0.11176851f, -0.40692425f, -0.03819446f, 0.16065390f, 0.05679818f, -0.10152206f, 0.08672448f, -0.09247498f, 
    -0.05334784f, 0.00054464f, 0.13082343f, 0.11899563f, -0.19917247f, 0.02298456f, -0.18817653f, 0.18952866f, 
    -0.20588452f, -0.02564806f, 0.11560012f, 0.23369016f, -0.25085554f, -0.18067396f, -0.26173791f, 0.03009304f, 
    0.01503052f, 0.17478265f, -0.05212175f, 0.05290025f, 0.02951165f, 0.05561246f, 0.06582519f, 0.08058271f, 
    0.09489837f, 0.09974921f, -0.13625789f, 0.17219332f, 0.06454872f, 0.08023567f, 0.15752870f, -0.06018199f, 
    0.02822317f, 0.02559240f, 0.02984067f, 0.05068423f, -0.12282456f, 0.20280401f, -0.11845329f, 0.01527006f, 
    0.06308694f, -0.04006879f, -0.10740469f, -0.01263284f, -0.02668811f, -0.06938706f, 0.03408677f, 0.28652114f, 
    -0.19283482f, 0.10505970f, -0.02502501f, -0.04296618f, -0.11591993f, -0.00984420f, 0.13407710f, 0.07388616f, 
    -0.07243630f, 0.01405067f, -0.11912692f, -0.18355928f, -0.02710549f, -0.03593072f, 0.19124654f, -0.10315131f, 
    -0.02894239f, 0.20338245f, 0.05100890f, 0.01430511f, -0.15871906f, 0.00673406f, -0.17697865f, -0.26374349f, 
    0.20199169f, -0.08966745f, 0.05247490f, 0.05398058f, 0.30826578f, 0.34775829f, -0.00205540f, 0.41656396f, 
    -0.25595832f, 0.15925816f, -0.03836979f, -0.04478788f, -0.06682149f, -0.17356284f, -0.14656539f, -0.28429288f, 
    0.01901267f, -0.07738379f, -0.08853941f, 0.09677560f, 0.04572043f, 0.03344499f, -0.08101591f, -0.05652653f, 
    -0.15719235f, 0.09355509f, 0.18001221f, -0.11923599f, 0.02520315f, 0.11842775f, 0.02314289f, 0.21739095f, 
    -0.02519150f, -0.03630001f, 0.01609633f, 0.04425523f, -0.04806826f, 0.03964939f, 0.04177675f, -0.13044235f, 
    0.27991584f, 0.11380209f, 0.06947323f, -0.02786501f, 0.04861637f, 0.01006755f, -0.01287112f, 0.15645508f, 
    0.08467605f, 0.12595771f, -0.06531857f, 0.07364397f, -0.06171970f, -0.01911770f, -0.06859677f, -0.09807660f, 
    0.01813048f, -0.08680715f, 0.24981532f, 0.07284334f, -0.05018719f, -0.11511953f, 0.08862699f, -0.04140944f, 
    0.04709430f, 0.02322457f, 0.05135047f, 0.01384207f, -0.28457978f, -0.11489025f, -0.43733683f, 0.00590837f, 
    0.26213235f, -0.08928436f, 0.09314986f, 0.27618009f, 0.10307413f, 0.13888820f, -0.03583610f, 0.27684444f, 
    0.06145949f, 0.00851523f, 0.08877232f, 0.37483624f, -0.10874647f, -0.23570447f, 0.11062799f, 0.06234408f, 
    -0.09313146f, 0.02600848f, -0.14106171f, -0.05697241f, -0.33982244f, 0.03582802f, 0.02430435f, 0.27041352f, 
    0.01627125f, 0.05591487f, 0.01333883f, -0.16177489f, -0.08837276f, 0.04933443f, 0.05139572f, 0.06439374f, 
    0.17332758f, 0.07684632f, -0.00990855f, -0.11902797f, 0.05366869f, 0.13547119f, 0.02937648f, 0.03854319f, 
    -0.04539985f, 0.24013011f, 0.10178360f, -0.16119672f, 0.10408464f, 0.10956566f, 0.18842980f, 0.04387085f, 
    -0.04795421f, -0.07248116f, -0.08467899f, -0.03605103f, -0.02934434f, 0.00631207f, -0.05362026f, 0.25657988f, 
    -0.09577149f, -0.03116689f, -0.06433650f, 0.14353234f, 0.11075329f, -0.21054454f, 0.24366792f, -0.23909067f, 
    0.00667096f, 0.16300160f, 0.02114027f, -0.02660615f, 0.04783405f, 0.06809115f, 0.09763781f, -0.22391590f, 
    -0.07952656f, 0.10929440f, -0.01572542f, -0.27191952f, 0.03146631f, -0.11048323f, 0.03091918f, -0.00116801f, 
    -0.10160606f, 0.09002153f, 0.17694066f, -0.07000646f, 0.05314089f, -0.09214758f, 0.00372283f, 0.06984788f, 
    -0.03597666f, 0.14609876f, -0.01499462f, 0.20337480f, -0.06198730f, -0.05549684f, -0.01655407f, -0.29891375f, 
    0.30962270f, 0.05462048f, -0.09144297f, 0.09735967f, -0.00092316f, 0.08583467f, 0.32096484f, 0.07991417f, 
    0.05408224f, 0.33345237f, -0.00993192f, 0.20710550f, 0.12870347f, -0.08738718f, -0.02433107f, -0.00521114f, 
    -0.03680751f, -0.35689801f, -0.09392115f, 0.10041071f, 0.08719461f, -0.09508171f, 0.39917132f, -0.26867670f, 
    0.07137708f, 0.11709332f, 0.06338236f, -0.14061324f, -0.25942317f, -0.20410441f, 0.54340899f, -0.32551742f, 
    0.33122995f, -0.02401965f, -0.08941461f, 0.21779013f, 0.03254617f, 0.32242322f, 0.09016012f, 0.10542114f, 
    -0.07403756f, -0.12060834f, 0.18438408f, -0.12146653f, 0.01465357f, -0.13735464f, 0.02965926f, 0.05494457f, 
    0.30711642f, -0.26469156f, -0.05329841f, 0.09165847f, -0.23568392f, -0.17997578f, 0.42960778f, 0.03695751f, 
    0.03898973f, 0.05700981f, -0.01987903f, 0.04268691f, 0.08840406f, -0.02910048f, -0.04053833f, 0.03458355f, 
    0.27125621f, 0.00524350f, 0.07146177f, 0.10292695f, 0.09498231f, -0.27179727f, -0.15758564f, -0.08773279f, 
    -0.11830357f, -0.04922009f, 0.09328143f, 0.12512024f, 0.11260849f, -0.07089233f, 0.01024339f, 0.02129026f, 
    0.03917569f, -0.11575031f, 0.26171839f, -0.06616156f, 0.14651099f, 0.04095725f, 0.33258951f, 0.22641343f, 
    -0.11010615f, 0.09565907f, -0.01552590f, 0.05158526f, 0.13129485f, -0.00636701f, -0.07358465f, -0.04987730f, 
    -0.03802637f, -0.01354047f, 0.11591588f, -0.28952593f, 0.06635098f, 0.18605374f, 0.06031873f, 0.26840338f, 
    0.06580690f, -0.11084215f, -0.10289353f, 0.14368573f, 0.05442246f, 0.06774024f, 0.12280077f, 0.12851353f, 
    -0.12535912f, 0.23972563f, -0.17444919f, -0.01889801f, -0.11880790f, 0.22315761f, -0.49576986f, 0.09270726f, 
    -0.07082412f, 0.13932967f, 0.10241567f, 0.15700915f, -0.01030605f, 0.12080252f, -0.28066891f, 0.12681675f, 
    0.13790107f, -0.00420987f, -0.08609071f, 0.07817895f, -0.11889646f, -0.24692547f, 0.00714793f, -0.06802581f, 
    -0.06172851f, 0.15167281f, -0.10507198f, 0.07642616f, 0.06771931f, 0.01220939f, 0.27117831f, -0.09787607f, 
    0.08428598f, 0.05083499f, 0.15076926f, 0.13529147f, -0.11707181f, -0.10896095f, -0.07929248f, -0.22175533f, 
    -0.02153263f, 0.03807166f, 0.03858560f, -0.02888483f, -0.18956816f, 0.17315020f, 0.10565518f, 0.24123263f, 
    0.07027827f, -0.19332327f, 0.11373136f, -0.02828874f, -0.00986501f, -0.19697894f, 0.11736179f, -0.35736251f, 
    0.06846093f, -0.01942239f, 0.01590956f, -0.01184648f, 0.02723777f, -0.22293553f, -0.07879898f, 0.09566394f, 
    0.24324197f, 0.21621048f, 0.08964370f, 0.11131303f, -0.06619979f, -0.03051450f, -0.15471737f, 0.19714235f, 
    -0.05235640f, 0.09880427f, 0.04982063f, 0.04238255f, 0.10289030f, 0.06027515f, 0.18341884f, 0.11419694f, 
    0.19642606f, -0.12285673f, 0.01186594f, -0.09679368f, 0.09237382f, -0.21764861f, 0.03347303f, 0.07454620f, 
    -0.02790408f, -0.18200570f, -0.06068720f, 0.18040118f, -0.02313899f, 0.00220867f, 0.18955384f, 0.05898929f, 
    0.01921128f, -0.09455743f, 0.05439454f, -0.29134017f, 0.38438809f, -0.03956519f, 0.06484193f, -0.05083588f, 
    0.38558328f, -0.00412197f, -0.12081457f, 0.02567887f, 0.01761544f, 0.34338585f, 0.03740440f, 0.08242341f, 
    -0.08684624f, -0.08794471f, 0.00893509f, 0.04748786f, 0.07373741f, -0.09851866f, 0.03253840f, 0.09634078f, 
    -0.00472702f, 0.07288674f, 0.07152903f, 0.12663598f, -0.12377786f, 0.25120285f, -0.15978615f, -0.00224819f, 
    -0.34104282f, 0.23696028f, 0.13712001f, -0.03102174f, -0.03108159f, -0.15739588f, -0.25954083f, -0.08705706f, 
    -0.07699033f, 0.28524813f, -0.08885287f, 0.40247822f, -0.12786114f, -0.05233007f, -0.12220879f, -0.08066721f, 
    -0.01709902f, -0.05578903f, 0.06312945f, -0.08236902f, -0.04093892f, 0.20258537f, -0.11644751f, -0.03559234f, 
    0.07590684f, -0.05551551f, -0.10678336f, 0.14613159f, 0.00781671f, -0.02966319f, 0.20451714f, -0.09738551f, 
    -0.08750338f, 0.25586706f, 0.04606353f, 0.08062464f, -0.12545021f, 0.04425336f, -0.11539751f, 0.11225405f, 
    -0.08365767f, -0.01243027f, -0.10280476f, -0.17376618f, -0.01271196f, -0.01230853f, 0.28621635f, 0.29886767f, 
    0.23907454f, 0.25045648f, -0.00625401f, 0.00024128f, -0.06161496f, -0.13095887f, -0.04443663f, -0.17401558f, 
    0.04271280f, -0.09496939f, 0.11968111f, 0.07764512f, -0.09011397f, 0.12791526f, -0.12617250f, -0.04719595f, 
    -0.20483775f, -0.06663920f, -0.04813477f, -0.09927526f, -0.03518835f, 0.06614210f, 0.09503929f, 0.00739816f, 
    -0.06822322f, 0.00252951f, -0.11157675f, -0.20077448f, 0.10432074f, -0.10238359f, 0.07006127f, -0.11096141f, 
    0.15346685f, 0.10925925f, -0.00038379f, 0.08548635f, 0.07974337f, -0.23219460f, 0.14443034f, -0.20453252f, 
    -0.04878145f, -0.15627635f, -0.06488353f, -0.25557190f, 0.02461872f, 0.00822162f, 0.01741819f, 0.08224255f, 
    0.05308506f, 0.18738514f, 0.22246474f, -0.15675728f, -0.13760065f, 0.01369359f, 0.00903365f, 0.02576040f, 
    -0.17867020f, 0.08019304f, -0.07983196f, 0.00924245f, -0.08601760f, -0.02366926f, -0.02275847f, -0.17633338f, 
    -0.14223297f, 0.04496189f, 0.00703126f, -0.02263630f, -0.04918580f, -0.11094280f, -0.04407755f, 0.07864790f, 
    -0.08734111f, 0.06155748f, 0.09607285f, -0.52715081f, 0.06441684f, -0.06669801f, -0.12134595f, 0.12542467f, 
    -0.07918112f, -0.13232653f, -0.11531189f, -0.10477483f, 0.08700285f, -0.15380660f, 0.07670112f, -0.18897495f, 
    -0.09261951f, 0.02584613f, 0.12425625f, 0.15004773f, 0.03392952f, -0.09846574f, -0.08421554f, 0.04213387f, 
    0.10964943f, -0.05097818f, 0.01707016f, 0.09650151f, 0.11271193f, -0.10969207f, 0.05660220f, -0.18392584f, 
    0.09879266f, 0.12928563f, -0.01062952f, -0.19352877f, 0.07015970f, -0.10692599f, 0.02499403f, -0.00873163f, 
    -0.05829218f, 0.28913817f, 0.02173673f, 0.04981048f, -0.13612939f, -0.01732699f, 0.21541670f, 0.08388197f, 
    -0.05016592f, 0.10120260f, -0.04271501f, 0.00408619f, -0.14084192f, 0.05371770f, 0.05795848f, 0.16277163f, 
    -0.04135229f, -0.00500940f, 0.08997905f, -0.09681869f, 0.11258796f, -0.00174603f, -0.04092273f, -0.19332512f, 
    0.10562152f, 0.02361774f, 0.05132255f, -0.27229068f, 0.02234613f, -0.31144139f, -0.12973014f, 0.22128372f, 
    -0.06983462f, 0.12164526f, -0.08680259f, -0.02411976f, -0.02354659f, -0.05515259f, -0.28530547f, -0.10881586f, 
    -0.12175574f, 0.00352910f, 0.11717484f, -0.17515744f, 0.08122001f, 0.09801972f, -0.02486801f, 0.22015598f, 
    0.02573409f, 0.04596991f, -0.11512874f, -0.12079968f, -0.06419535f, 0.07926004f, -0.13640772f, 0.03986437f, 
    0.00190416f, -0.10691882f, -0.08203418f, 0.04847353f, 0.05160733f, 0.07363740f, 0.00279925f, -0.01514341f, 
    -0.12780306f, 0.06729543f, -0.20601745f, -0.03024483f, -0.01030196f, 0.06112570f, -0.12750469f, 0.14129794f, 
    -0.02874712f, 0.05852984f, -0.09223106f, 0.00502944f, 0.39883777f, 0.09818147f, -0.05736385f, 0.18375523f, 
    -0.03844044f, 0.20124258f, 0.08082221f, 0.10271277f, 0.11173267f, -0.13406830f, 0.20613216f, -0.11196823f, 
    0.05497402f, 0.09199470f, 0.06884409f, 0.05808517f, 0.02557771f, 0.18828960f, -0.16648060f, -0.20151089f, 
    -0.31576890f, 0.12834717f, 0.14428204f, -0.08014616f, 0.05181696f, 0.11757924f, -0.05828526f, -0.04996696f, 
    -0.04231559f, 0.25328547f, -0.12363409f, 0.22376615f, -0.06661630f, 0.01947797f, 0.32412595f, -0.04266615f, 
    -0.20080703f, 0.00199242f, -0.03397427f, -0.07982583f, 0.10553496f, 0.23026016f, 0.47185570f, 0.23205344f, 
    0.04230837f, 0.17460273f, 0.01923046f, -0.03140914f, -0.05254991f, -0.06790030f, -0.07780200f, -0.00410007f, 
    0.10980513f, 0.24088755f, -0.05298541f, 0.19602868f, -0.30030116f, 0.05467635f, -0.30420196f, -0.16907416f, 
    -0.03343954f, 0.02088676f, 0.01062133f, -0.06734930f, 0.16670290f, -0.02162660f, 0.19367361f, 0.13406348f, 
    -0.11841758f, 0.08592680f, -0.11397678f, 0.06197848f, -0.05572798f, 0.14256409f, -0.06578232f, -0.09812925f, 
    -0.09632222f, 0.05542090f, 0.11292856f, -0.41450661f, -0.07663473f, -0.13411045f, 0.05619766f, 0.08054608f, 
    0.18597817f, 0.10458641f, 0.15288229f, -0.05378506f, 0.04837710f, -0.20530203f, 0.56236070f, 0.12871131f, 
    0.03245008f, -0.13630387f, -0.11467335f, 0.04111797f, -0.06911397f, -0.05375232f, -0.24921626f, 0.15897217f, 
    -0.08521693f, 0.06954271f, -0.07074098f, 0.04180661f, 0.08981075f, -0.06204464f, -0.12170824f, -0.30442053f, 
    0.01374862f, 0.16155083f, 0.07357884f, 0.08485205f, 0.01771153f, 0.04637641f, 0.14880809f, 0.10283218f, 
    -0.10215527f, 0.25578523f, 0.05408126f, -0.20723954f, -0.13878544f, -0.01100429f, 0.22649626f, -0.14412227f, 
    0.12345391f, 0.12726271f, 0.08857648f, -0.02062643f, 0.05724831f, 0.08017084f, 0.18514031f, 0.19533683f, 
    -0.23402061f, -0.19681475f, -0.06038349f, -0.30731711f, 0.08525858f, 0.09463553f, 0.06416336f, -0.01717373f, 
    0.07294064f, -0.05286501f, 0.01966598f, 0.11678177f, -0.05249684f, -0.16217755f, -0.01237846f, 0.14441493f, 
    0.22561797f, 0.20586726f, -0.23359291f, 0.02341813f, -0.03128969f, 0.11296583f, -0.10608128f, 0.00583225f, 
    0.01790385f, 0.05194483f, -0.09356207f, -0.21100010f, -0.14427686f, -0.06876722f, -0.02349906f, 0.28484359f, 
    -0.24840513f, 0.05919212f, 0.02724067f, 0.06560788f, -0.04542144f, 0.17688337f, -0.18567355f, -0.01760515f, 
    -0.03455743f, 0.15187621f, -0.12797621f, -0.13523407f, -0.03396584f, 0.07171205f, 0.21794476f, -0.10123184f, 
    -0.09452493f, 0.08898684f, 0.15474769f, 0.15766439f, -0.23121369f, 0.06805763f, -0.10434996f, 0.09127761f, 
    -0.25465733f, 0.11642101f, -0.07861834f, 0.31594202f, 0.20224775f, -0.02878317f, -0.07222080f, 0.18224782f, 
    0.07848051f, 0.27079323f, 0.11317313f, -0.14806904f, -0.10775328f, 0.08445808f, 0.17307317f, -0.27976105f, 
    -0.02327005f, 0.09125666f, -0.03845169f, 0.02439012f, -0.09848607f, -0.00644918f, 0.00778698f, -0.04268623f, 
    0.21994695f, -0.02886760f, 0.24179493f, -0.07596651f, -0.11913849f, -0.01721119f, -0.13233270f, 0.30115125f, 
    -0.09848538f, 0.02609138f, 0.09015608f, 0.04675388f, -0.07113312f, 0.08571307f, -0.19502571f, -0.08592354f, 
    -0.09140937f, 0.06610195f, 0.11549920f, -0.08746019f, -0.00576118f, -0.11624585f, -0.17483346f, -0.19638525f, 
    -0.02830029f, -0.27528107f, 0.01699241f, 0.15909146f, -0.01548435f, 0.09960359f, 0.05073017f, -0.03120962f, 
    0.02290674f, 0.05188304f, 0.03685501f, -0.40649676f, -0.04482850f, 0.02930246f, 0.11653596f, -0.05984023f, 
    0.25009710f, -0.06130932f, -0.07737364f, -0.00936386f, -0.17693675f, 0.19274412f, 0.43110162f, 0.09125038f, 
    -0.35908508f, -0.37732738f, 0.08102404f, -0.21681300f, -0.04105778f, 0.01572685f, 0.23931988f, 0.18061778f, 
    0.00962494f, 0.02349751f, 0.04136609f, 0.04556526f, -0.07307532f, -0.02057678f, 0.19870862f, 0.28785816f, 
    0.19579865f, 0.29878482f, -0.09597114f, 0.10369442f, -0.02743699f, 0.06971535f, -0.00970161f, 0.00533482f, 
    -0.04302518f, 0.09567384f, 0.03575194f, 0.24237871f, -0.07954717f, -0.06609363f, -0.04591532f, 0.06857993f, 
    0.07584864f, -0.07185124f, 0.03817623f, -0.07637479f, -0.09200322f, -0.24377035f, 0.03512827f, 0.07345655f, 
    0.08285359f, 0.00187003f, 0.10400978f, 0.16325758f, -0.06437512f, -0.08798043f, -0.00826646f, -0.04008570f, 
    -0.09182414f, -0.20631932f, 0.01057480f, -0.22696745f, 0.40940490f, -0.04838812f, 0.00801664f, -0.07433974f, 
    0.35368666f, 0.10234545f, 0.05253921f, -0.08668205f, 0.17148599f, 0.44213817f, -0.21295515f, 0.17329110f, 
    -0.11259105f, 0.00919499f, 0.11411637f, 0.15868996f, -0.01361199f, -0.04576706f, -0.10117716f, 0.05373757f, 
    0.02830649f, -0.00068528f, -0.11716945f, 0.17364810f, -0.06300471f, 0.16393012f, 0.04188851f, -0.02454147f, 
    -0.23741737f, 0.21887635f, -0.04726140f, -0.02586718f, -0.15535402f, 0.24418668f, -0.42409396f, -0.00320826f, 
    0.01636405f, -0.02783130f, -0.09496140f, 0.29858050f, 0.07114053f, -0.11534113f, -0.00087286f, -0.01660269f, 
    -0.12212749f, 0.02461283f, 0.05610000f, -0.10173914f, 0.10462834f, -0.29520664f, 0.26336750f, 0.09662904f, 
    -0.12479603f, -0.25931886f, 0.04617213f, 0.10187129f, -0.05367159f, 0.00995091f, -0.04364319f, -0.10227594f, 
    -0.07273571f, 0.11144926f, -0.09586218f, -0.22820112f, 0.20870577f, 0.10359631f, -0.23844865f, -0.25217310f, 
    0.29391679f, 0.03562220f, -0.03297216f, -0.13405867f, -0.19399947f, 0.28144443f, 0.37186721f, 0.25956860f, 
    -0.11348623f, -0.03906801f, 0.01823710f, 0.04878286f, 0.01849798f, -0.27129576f, -0.06046994f, 0.06679299f, 
    0.00992493f, 0.07688755f, -0.01143968f, -0.06847673f, 0.10725564f, 0.04602560f, 0.06360506f, 0.09313332f, 
    0.34522331f, -0.01897503f, 0.10890648f, -0.02528984f, 0.11062609f, -0.08881304f, 0.11869914f, 0.03931898f, 
    0.05450261f, -0.09075461f, 0.08694771f, -0.19111478f, 0.10058898f, 0.08977162f, -0.36701983f, -0.19241144f, 
    0.18073778f, -0.09924261f, 0.01845135f, 0.11324552f, 0.02646552f, -0.15348937f, 0.06003676f, -0.25810879f, 
    -0.01012188f, 0.14671589f, -0.02850043f, -0.03337213f, 0.01303370f, -0.10516449f, 0.10084061f, -0.04093285f, 
    -0.03466544f, 0.02728199f, 0.05720200f, -0.03697787f, 0.22169130f, 0.05269809f, 0.07121531f, -0.11848873f, 
    -0.22883700f, -0.00304457f, -0.00002709f, -0.14931671f, -0.06614817f, -0.18503201f, 0.06319734f, -0.20263076f, 
    -0.04833210f, -0.22980016f, -0.11012756f, 0.15156651f, -0.03047995f, 0.11219805f, 0.16671072f, 0.03724272f, 
    0.02680176f, -0.00538297f, -0.04334426f, -0.03550799f, 0.02622645f, -0.40300488f, -0.03094165f, 0.10715672f, 
    -0.16844043f, 0.26424977f, -0.11804701f, 0.03137844f, -0.15378946f, 0.22430179f, -0.23384364f, 0.05584162f, 
    0.02791776f, -0.18112932f, 0.07451119f, 0.12809417f, 0.01280950f, 0.04021524f, 0.11425265f, 0.08547164f, 
    -0.27433324f, -0.07991988f, 0.01996526f, -0.00658229f, -0.11373178f, -0.16671832f, 0.10407460f, 0.15462914f, 
    0.07068394f, -0.15561271f, 0.09051775f, -0.01606163f, 0.11044770f, 0.09129723f, 0.09529516f, -0.05404140f, 
    0.08529139f, 0.08244447f, -0.04199544f, -0.09718315f, 0.13631426f, -0.01991551f, 0.01469903f, -0.18525755f, 
    0.17596342f, 0.11332346f, -0.08658703f, 0.04078606f, -0.00785217f, 0.30664119f, -0.40104514f, 0.31184584f, 
    -0.26231149f, 0.03650948f, 0.05488770f, 0.24537387f, -0.06885846f, -0.02029735f, -0.01236310f, 0.23003714f, 
    -0.11584040f, -0.06781229f, 0.14182286f, 0.08577531f, 0.04247108f, -0.12280379f, -0.03299364f, 0.06463434f, 
    0.11020511f, 0.21331052f, 0.04584775f, -0.01194839f, -0.06323338f, 0.06159704f, 0.03667252f, -0.06372999f, 
    0.09591024f, -0.08949518f, -0.08284755f, 0.02435522f, -0.07424031f, -0.02270514f, 0.07504338f, -0.01747757f, 
    -0.11970616f, -0.10744812f, 0.10564563f, -0.01820758f, -0.01873465f, -0.11506711f, -0.10130611f, -0.11850411f, 
    -0.03681344f, -0.05073287f, -0.07559885f, 0.04434628f, -0.08730564f, -0.07323883f, 0.01621741f, 0.11570184f, 
    0.07484548f, -0.11500904f, -0.00438363f, -0.09018449f, -0.09057928f, -0.04460070f, 0.02651639f, -0.11076505f, 
    -0.08317741f, 0.03709091f, -0.05603343f, -0.02535210f, -0.00729701f, 0.00063967f, 0.02427774f, -0.05667441f, 
    0.07900070f, 0.08430876f, -0.04505342f, -0.09562702f, -0.09977679f, -0.03764598f, -0.05383749f, -0.13372329f, 
    0.05409557f, -0.10789132f, -0.03256250f, -0.14736484f, -0.03382415f, -0.07813399f, 0.03740074f, -0.06859813f, 
    0.10354532f, -0.07242219f, -0.08901039f, -0.02228580f, -0.15160790f, -0.10958321f, 0.00427329f, -0.01327853f, 
    -0.00365785f, 0.05148081f, 0.06707145f, 0.13885833f, -0.09576460f, 0.08150451f, -0.11181185f, 0.12180984f, 
    0.03545461f, 0.01747252f, 0.01607893f, 0.04818396f, -0.10189149f, -0.03779848f, 0.13410956f, 0.06339376f, 
    0.09408623f, 0.29903293f, -0.07357346f, -0.05469160f, -0.00479932f, 0.03907305f, 0.02635173f, -0.07724211f, 
    0.02574422f, 0.03614782f, 0.14007649f, 0.05018071f, -0.22379395f, 0.11949234f, -0.06836022f, 0.00719366f, 
    -0.18149413f, -0.00208846f, 0.08966733f, -0.03287090f, -0.07730052f, -0.18325128f, -0.06890725f, -0.15038854f, 
    -0.15223929f, 0.02979488f, -0.11285508f, -0.19952609f, 0.01893540f, 0.09436171f, -0.23928300f, -0.17977028f, 
    0.06406856f, -0.05431598f, -0.13036446f, -0.05500709f, -0.00529908f, -0.03047913f, -0.00184036f, 0.05720445f, 
    0.13521606f, -0.08548021f, -0.10825345f, 0.06650364f, -0.00911045f, -0.04252661f, -0.22020325f, 0.15974690f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.20670384f, -0.04645839f, 0.03361160f, 0.19015102f, 0.07617808f, -0.06091155f, 0.06505799f, 0.08780143f, 
    0.10449678f, 0.10419188f, 0.06164707f, 0.13241218f, -0.00212414f, -0.11632252f, 0.14572334f, 0.00620428f, 
    0.16021830f, -0.02126150f, -0.10114825f, -0.07021112f, -0.05720802f, -0.08824996f, -0.00840613f, 0.14436193f, 
    0.17157029f, 0.09084549f, 0.13537750f, 0.10882371f, 0.22022682f, 0.04652748f, -0.07816363f, -0.14857383f, 
    -0.02037676f, -0.16401288f, -0.04599512f, -0.04561431f, 0.04658896f, -0.19574898f, 0.01811960f, 0.00057600f, 
    0.01145502f, -0.09754803f, 0.07421741f, 0.07785011f, 0.14707741f, -0.00680262f, -0.03119328f, 0.13076125f, 
    -0.04832853f, 0.03824378f, 0.06373803f, 0.10079652f, 0.14299136f, 0.07795249f, 0.05668318f, 0.00905200f, 
    0.19121511f, 0.13988411f, 0.13234022f, -0.01396750f, 0.14856203f, 0.02602698f, -0.13355765f, -0.02359911f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.52464980f, 0.18412000f, 0.00087083f, 0.13484305f, -0.21883477f, -0.01287200f, 0.13027549f, -0.22239290f, 
    -0.32071769f, 0.08476548f, 0.11066628f, 0.10056432f, -0.06179757f, -0.11657020f, -0.36866739f, -0.25849992f, 
    -0.58293235f, -0.27654561f, -0.03027410f, -0.04830463f, -0.10809268f, 0.01391214f, -0.04125090f, -0.07177223f, 
    -0.49286434f, -0.41420242f, 0.09373603f, -0.19817452f, 0.04159424f, 0.07573649f, 0.09839578f, 0.02162210f, 
    0.01113064f, 0.43351460f, 0.02264059f, -0.01460637f, -0.22958989f, -0.07815639f, 0.20097996f, 0.06905781f, 
    0.08570319f, -0.30829221f, -0.17262143f, 0.04436251f, -0.34776214f, 0.13410740f, -0.00004434f, -0.04003985f, 
    -0.12096131f, -0.20385794f, 0.19559912f, -0.24671780f, -0.59912473f, 0.12662508f, 0.24816075f, -0.34673217f, 
    0.07630078f, -0.25330886f, -0.41563097f, -0.11709952f, -0.10252836f, -0.41003248f, -0.09737659f, -0.02202713f, 
    -0.03418125f, 0.01666768f, -0.16974175f, 0.07021280f, 0.05345046f, 0.01173204f, 0.06322186f, -0.38429326f, 
    -0.42851543f, 0.06540608f, -0.02263163f, -0.37296548f, 0.01326305f, 0.03040236f, 0.16609918f, -0.11345947f, 
    0.27399591f, -0.17534879f, 0.06229927f, -0.03024490f, -0.03195029f, 0.05862716f, -0.08221203f, 0.27267313f, 
    0.04558036f, 0.03927928f, 0.04201799f, -0.42636129f, 0.09091152f, 0.11457939f, -0.07205486f, -0.04196515f, 
    -0.02674585f, 0.25195143f, 0.09190901f, 0.01334350f, 0.22163230f, -0.04796254f, 0.07499828f, -0.05076827f, 
    -0.17790474f, 0.00197812f, 0.25626841f, 0.12854657f, -0.05568245f, 0.03011510f, -0.72297186f, -0.03236372f, 
    0.16741578f, 0.04848757f, 0.07445104f, -0.03046078f, 0.01983439f, 0.22430740f, -0.22566883f, 0.23378341f, 
    0.28633663f, 0.17356817f, 0.00069017f, -0.36525559f, 0.14460717f, -0.11079509f, -0.03691592f, -0.04325429f, 
    0.12350773f, 0.20532687f, -0.14445694f, 0.03253021f, 0.04598320f, -0.01962423f, -0.13834244f, -0.02272764f, 
    0.21081318f, 0.20752089f, -0.29556158f, -0.15153186f, 0.01283701f, 0.02081560f, 0.12910467f, -0.06899610f, 
    -0.35086420f, 0.01980824f, -0.02742793f, -0.19749114f, 0.15648769f, -0.15643422f, 0.02500437f, -0.42753592f, 
    -0.08398765f, 0.15967643f, 0.23759669f, 0.14712289f, -0.19902743f, -0.04857526f, -0.13174947f, -0.02640346f, 
    -0.35893565f, -0.20955883f, -0.02860840f, -0.02352444f, 0.29819015f, -0.06729714f, 0.09982735f, 0.30964279f, 
    0.11046160f, -0.00378202f, -0.09153123f, 0.00846438f, 0.03003094f, 0.05547784f, -0.20934267f, 0.12324961f, 
    0.01363311f, 0.15263945f, -0.25161418f, 0.12529840f, 0.17926523f, 0.06368894f, -0.24346882f, -0.66061014f, 
    0.11814055f, -0.58412129f, 0.20380357f, -0.40338725f, -0.42948526f, -0.00208260f, -0.07523734f, 0.03486656f, 
    -0.28516805f, -0.14947663f, 0.08873037f, 0.10641491f, -0.36632186f, 0.01977451f, -0.03496946f, 0.19883181f, 
    0.15296753f, -0.53108275f, 0.05136236f, 0.09201600f, 0.01647470f, 0.05677215f, 0.10166543f, -0.15090673f, 
    -0.42731494f, -0.12276836f, -0.10439056f, 0.16899018f, -0.07334877f, -0.07531548f, -0.10851371f, 0.05128605f, 
    -0.22993818f, 0.24267259f, -0.23889738f, 0.03429820f, -0.28993148f, -0.00762843f, -0.07645757f, -0.09043334f, 
    -0.00947612f, -0.00215257f, -0.42843148f, -0.09464622f, -0.12115820f, -0.12148542f, 0.13728115f, 0.27045548f, 
    0.15293749f, 0.38319013f, -0.32962576f, -0.15148649f, 0.00158645f, 0.06547862f, 0.27980143f, -0.35106879f, 
    -0.07038679f, 0.06124626f, -0.14029609f, -0.33525166f, -0.24648865f, -0.03896868f, 0.09329942f, -0.11211795f, 
    -0.08598322f, -0.27781448f, -0.26694122f, 0.16260993f, -0.51588017f, -0.30928478f, -0.08248559f, -0.32164240f, 
    0.09990309f, 0.04456055f, -0.16917954f, -0.05252904f, -0.03281843f, -0.00128376f, 0.17805840f, 0.05742611f, 
    0.08344553f, -0.33922461f, 0.09763205f, -0.27955335f, 0.09138323f, -0.06421135f, -0.11983951f, 0.07452759f, 
    0.03897331f, -0.11823469f, -0.10154835f, -0.22974955f, 0.12951787f, -0.19587316f, -0.05484948f, -0.41702285f, 
    -0.37313291f, -0.46878460f, -0.08027478f, -0.28894579f, 0.02741797f, 0.14981845f, 0.07430109f, -0.00997650f, 
    0.11068443f, -0.38518783f, -0.13295300f, -0.07343493f, -0.03728430f, -0.00302326f, 0.02215030f, -0.08123111f, 
    0.11932584f, -0.38365471f, 0.08721109f, -0.45043084f, 0.28336638f, 0.04033905f, 0.22293067f, -0.37330627f, 
    0.10898043f, -0.06919461f, 0.11243922f, 0.05967745f, -0.07273602f, -0.11205109f, 0.13693643f, -0.01833675f, 
    -0.07122442f, 0.06957383f, -0.24576120f, 0.23514970f, -0.02119693f, -0.07082143f, 0.06816371f, -0.16373099f, 
    -0.01514173f, 0.12363628f, -0.16349518f, 0.13121751f, 0.09613509f, 0.04010590f, 0.10492045f, 0.01077036f, 
    -0.19241752f, -0.13310461f, 0.05986506f, -0.06357859f, -0.05795255f, 0.17798778f, -0.28780189f, 0.11999233f, 
    -0.03872348f, -0.01128915f, -0.01046389f, 0.00597978f, -0.00201779f, -0.07418379f, 0.20669098f, -0.12395433f, 
    0.11457780f, -0.09281768f, -0.30695888f, -0.20224474f, 0.09611177f, -0.01167939f, -0.12424868f, -0.04667848f, 
    0.21585114f, -0.36220068f, 0.02193307f, 0.09516084f, -0.14222546f, -0.26205274f, -0.05996198f, -0.30955565f, 
    0.04941199f, -0.22853915f, -0.03355829f, 0.26708934f, -0.06016281f, -0.07920159f, -0.45421648f, -0.17867859f, 
    -0.21523975f, 0.20542662f, -0.07761405f, -0.45311323f, -0.44937897f, 0.17912014f, 0.18228580f, -0.11863288f, 
    -0.02013887f, -0.06347209f, 0.07424705f, 0.18631645f, -0.46203867f, 0.30839756f, 0.10857235f, -0.04315012f, 
    0.22164218f, 0.06958710f, -0.29068467f, -0.15612544f, -0.16721325f, 0.09283128f, 0.21411011f, -0.14513448f, 
    -0.28762376f, -0.01353252f, -0.34257972f, -0.00174873f, -0.16031396f, -0.44490826f, 0.17107546f, 0.12364629f, 
    -0.26216027f, 0.21576366f, -0.08220918f, -0.04636499f, 0.09861752f, -0.05894966f, -0.02254812f, -0.54549044f, 
    0.05046723f, 0.17470485f, 0.00306255f, 0.23651610f, 0.05450218f, -0.74128914f, -0.01728464f, -0.15964906f, 
    -0.31572220f, -0.23489040f, 0.05157555f, -0.04490551f, -0.52159905f, -0.04024051f, -0.02460428f, -0.06430234f, 
    -0.55977112f, 0.26396015f, -0.34666470f, -0.06025290f, -0.00629307f, -0.14198487f, -0.06111743f, 0.15683334f, 
    -0.41320133f, 0.05590411f, -0.45789272f, -0.18124017f, -0.13568154f, -0.03664158f, -0.66226482f, 0.01458840f, 
    -0.45231876f, 0.17218339f, 0.19399668f, -0.18460247f, 0.26848006f, 0.07772135f, -0.01746663f, -0.05045958f, 
    -0.01052381f, -0.18000126f, -0.01238293f, -0.44793412f, -0.23268464f, -0.03434515f, -0.26765305f, 0.17395854f, 
    0.40966836f, -0.04232758f, 0.02173481f, 0.22951771f, 0.02511107f, -0.00465225f, -0.27931502f, 0.13779502f, 
    0.05794065f, -0.06306674f, -0.00513740f, -0.03847229f, 0.00488747f, -0.18463817f, -0.24064167f, -0.28776491f, 
    0.13048622f, 0.01996187f, -0.09506562f, 0.14879407f, -0.11250681f, -0.56270355f, -0.07113355f, -0.04460747f, 
    -0.20833212f, -0.11753783f, -0.31034049f, -0.08420344f, -0.24368353f, -0.06448144f, -0.55567282f, 0.17177254f, 
    0.17385730f, -0.26691860f, 0.08808047f, 0.14629489f, -0.42776880f, 0.09032861f, -0.11013960f, -0.19850859f, 
    0.14748853f, -0.12863030f, 0.04963535f, 0.12837952f, 0.01024588f, -0.14911368f, 0.26119310f, 0.08906033f, 
    0.13770448f, 0.04852800f, -0.32823631f, 0.04084487f, -0.24604051f, -0.15678786f, -0.04199862f, 0.12553401f, 
    -0.18600938f, -0.16753574f, -0.17103893f, -0.37297967f, -0.07499779f, -0.01683411f, -0.46386778f, -0.35029054f, 
    -0.37317497f, 0.05433438f, -0.44293347f, 0.30256441f, 0.07661611f, 0.13005774f, 0.08842790f, -0.30112869f, 
    -0.15067996f, -0.00078359f, -0.05335805f, -0.09122469f, -0.05029390f, -0.17259112f, 0.06706282f, 0.21554005f, 
    0.04710320f, 0.13946475f, -0.00109170f, 0.06634924f, -0.22399093f, -0.07887995f, -0.07659208f, 0.10403708f, 
    0.21546574f, -0.14755355f, 0.16732898f, -0.09069434f, -0.22994141f, -0.01672580f, -0.69428670f, 0.16819355f, 
    -0.09619537f, 0.19028680f, 0.06186835f, 0.25162533f, -0.09650461f, -0.41866764f, -0.13474901f, -0.09064568f, 
    0.21033338f, 0.13231565f, 0.25663412f, 0.07877158f, 0.13995802f, -0.06576955f, -0.18040873f, 0.15846740f, 
    -0.07222265f, 0.11878538f, 0.24106410f, 0.20608802f, -0.09237178f, 0.08913968f, 0.05956410f, -0.12752086f, 
    0.16176650f, -0.09598573f, 0.21122462f, 0.06026876f, -0.30608082f, 0.01885683f, 0.17968610f, 0.27247283f, 
    0.06159029f, -0.00381454f, 0.01519431f, 0.21295068f, 0.01382211f, -0.55297637f, -0.19588883f, 0.12065323f, 
    -0.01889472f, 0.03663517f, -0.08180527f, -0.09956847f, -0.57163131f, -0.12636028f, -0.29678509f, -0.41436294f, 
    0.18919827f, -0.08483018f, 0.06506819f, 0.08238586f, 0.23614462f, -0.15236349f, 0.08965554f, 0.09717759f, 
    -0.19551711f, -0.56867647f, -0.15085410f, -0.06509302f, -0.49806336f, -0.12490892f, 0.20053740f, 0.05940795f, 
    -0.10630643f, -0.34909317f, 0.13095830f, -0.14368849f, 0.05430537f, -0.05305590f, -0.08838732f, 0.02586676f, 
    -0.14717688f, -0.34223065f, -0.36525965f, -0.34104484f, 0.00892161f, -0.21540003f, -0.01610593f, -0.08711345f, 
    0.24204288f, -0.13625537f, -0.36698645f, -0.30678555f, -0.00508887f, 0.03794671f, 0.05778579f, 0.02176946f, 
    0.05037646f, -0.79177612f, -0.25762716f, 0.10963491f, -0.24649011f, -0.04449308f, -0.43659660f, -0.12171420f, 
    0.24177676f, -0.31356320f, 0.07861036f, 0.19542457f, -0.07208100f, 0.27848777f, 0.12468086f, -0.41736075f, 
    -0.17244104f, -0.37689337f, 0.02889033f, 0.02131215f, -0.42564499f, -0.07994094f, 0.05448334f, -0.16930884f, 
    0.02241893f, 0.05640357f, 0.09626792f, 0.01546747f, -0.08378720f, -0.13906683f, -0.07590643f, 0.06294277f, 
    0.27365381f, -0.12942141f, -0.24494034f, 0.01466615f, 0.22636110f, -0.03069849f, -0.11369573f, -0.10538567f, 
    -0.23730449f, 0.09854130f, 0.21085556f, -0.19006561f, 0.16221154f, -0.26932660f, -0.06009479f, 0.19813643f, 
    -0.12107182f, 0.06411286f, 0.10579216f, -0.10014407f, -0.40251434f, -0.11243212f, -0.08720277f, -0.30488718f, 
    -0.17549582f, -0.21295290f, 0.18404964f, -0.08127008f, -0.25174993f, -0.14747523f, -0.00667888f, -0.11086835f, 
    0.06600812f, -0.19287860f, -0.09550847f, 0.16321804f, -0.24477388f, -0.08486907f, 0.06241131f, -0.13505670f, 
    -0.03259395f, -0.35413769f, 0.42469117f, -0.24786770f, -0.08171354f, -0.09033763f, 0.24321970f, -0.01711433f, 
    -0.19955595f, 0.10922699f, 0.08780064f, -0.22211674f, -0.42570937f, -0.00091071f, 0.27174324f, 0.33437794f, 
    0.09051590f, -0.11870915f, -0.53881705f, 0.12429655f, -0.21133026f, -0.26268250f, -0.05444052f, 0.09692780f, 
    -0.47482425f, -0.33592540f, -0.75209171f, -0.10144363f, -0.46625069f, -0.19113064f, -0.04894683f, -0.68619120f, 
    -0.18668160f, 0.14545645f, 0.26018313f, -0.35621947f, -0.19363190f, 0.02946159f, -0.05015207f, 0.12497433f, 
    -0.23194203f, 0.21139446f, -0.25569192f, -0.36491102f, -0.28436393f, -0.27066147f, -0.16050081f, -0.15040235f, 
    -0.40388265f, 0.32111192f, -0.01661699f, 0.13784395f, -0.40469933f, -0.06172129f, -0.08603469f, -0.17502193f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.01051520f, -0.03129359f, 0.15422420f, -0.00831938f, -0.02187827f, -0.04453322f, -0.10252933f, -0.02804429f, 
    -0.15340589f, 0.10175820f, -0.06153207f, -0.09990834f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
