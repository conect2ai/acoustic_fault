#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.06773114f, 0.44409919f, -1.67555773f, -1.10200584f, -0.38514066f, 0.89744598f, -0.33200195f, 0.00778377f, 
    -1.06063807f, -0.23680127f, 0.31936795f, -0.35103551f, 0.43417668f, 0.11773621f, -0.04130333f, -0.04174140f, 
    -0.12162840f, -0.24215150f, -0.08364809f, 0.03942969f, 0.26476252f, 0.09348052f, 0.24294883f, -0.05879352f, 
    0.03987567f, -0.49542907f, 0.28931442f, -1.02506185f, -0.83407420f, -0.73563528f, 0.11436262f, -0.62732935f, 
    -0.12512082f, -0.51953864f, -0.17817162f, -0.98709238f, -0.25455800f, -0.89983648f, -0.44366166f, -0.67397743f, 
    -0.48544863f, 0.07021169f, 0.49101976f, -0.39504424f, -0.03272090f, -0.09034007f, 0.26565415f, -0.40766916f, 
    0.04385090f, 0.17288753f, 1.17462564f, 0.11841732f, 0.25746503f, 1.14191806f, 1.00927615f, 0.99370891f, 
    0.73666275f, -0.11442675f, 0.60031271f, -0.20359689f, -0.00764719f, 0.93452913f, 0.17955309f, 0.62044448f, 
    0.07637513f, 0.19162595f, 0.08544682f, 0.39721674f, -0.06033067f, -0.04468303f, 0.21450481f, 0.14474811f, 
    0.43871060f, 0.05167617f, 0.21706608f, 1.23634529f, 0.37581071f, 1.13657844f, 0.67621881f, -0.24304301f, 
    0.17690517f, -1.58752143f, 0.23851904f, 0.53370094f, 0.75357640f, -0.49664593f, -0.71563971f, -0.75364310f, 
    0.01706619f, 0.07806275f, -0.06933218f, -0.05103808f, -0.20881408f, -0.48461080f, 0.06008201f, 0.59226632f, 
    0.06795338f, 0.11204095f, 0.14003196f, 0.10088263f, -0.36413532f, 1.07486320f, 1.71181035f, 0.68536001f, 
    0.11026798f, 0.36907178f, 0.34354955f, -0.16630976f, 0.21050707f, -0.01052276f, -0.15172511f, 0.14285423f, 
    0.30426016f, 0.26410875f, -0.00881866f, 0.21792895f, 0.54132271f, 0.42408395f, -0.17248075f, 0.00669245f, 
    -0.36287117f, 0.28244945f, -0.03839612f, 0.07244174f, -0.27848789f, 0.29389924f, 1.06101418f, 0.97414261f, 
    -1.37597072f, -0.95807844f, 0.36620507f, -0.92628020f, -0.29616007f, -0.34785512f, -0.51309520f, 0.54558372f, 
    0.66844004f, -0.01288250f, 0.48038316f, 0.10740780f, 0.48156264f, 0.14863054f, 0.04498032f, 0.31253126f, 
    -0.18333314f, 0.40202537f, 0.31379569f, 0.12893654f, 0.42034912f, 0.55380267f, 1.88939893f, 0.77695698f, 
    0.90512490f, -0.75083029f, 0.43057629f, 0.62912023f, 0.02847563f, 0.45921174f, 0.44037732f, 0.74017340f, 
    -0.07624727f, 0.65073091f, -0.06852779f, 0.15413789f, 0.31704012f, 0.22643322f, 0.21635425f, -0.14025378f, 
    0.16911365f, 0.04518227f, -0.26257816f, 0.40149224f, -0.02084143f, 0.11763527f, -0.02748537f, -0.73347616f, 
    -1.57413161f, -1.11101949f, -0.76464623f, -0.19311310f, -0.56458348f, 0.86887622f, 0.83031291f, 0.60352743f, 
    0.32760510f, -0.00365421f, -0.12697554f, 0.10221055f, -0.10444928f, -0.52211630f, 0.23928873f, 0.14143637f, 
    -0.02124880f, 0.00697846f, 0.02856311f, -0.07393073f, -0.26591581f, -0.11937908f, -0.39436626f, -0.18794210f, 
    0.29213789f, 0.06509002f, -1.19608819f, -0.93533194f, -1.12342930f, 0.87767273f, 0.73265094f, 0.24817012f, 
    0.79328817f, 0.69595432f, -0.68877292f, -0.26089278f, 0.06585061f, -0.38871017f, -0.43930650f, 0.00751263f, 
    0.02418220f, 0.17275092f, -0.25455263f, -0.21164596f, 0.23748538f, -0.31392300f, -0.10669289f, -0.28302193f, 
    0.55164570f, -0.18784751f, -0.92577809f, 1.11629987f, 1.34853232f, -0.17607470f, -0.86195558f, 1.23945820f, 
    0.06906772f, 0.52619082f, 0.22565278f, 0.25448024f, 0.13767120f, 0.14184274f, 0.03562176f, -0.01278144f, 
    0.12818930f, 0.25421160f, -0.09097490f, 0.10572415f, -0.14984630f, 0.07478002f, 0.22486103f, -0.07643588f, 
    -0.04859297f, -0.24649854f, 1.24240494f, 1.11212397f, 1.10639656f, 0.84968722f, -0.12996076f, -0.28176671f, 
    0.32709828f, -1.18560040f, -0.74600053f, -0.30382875f, 0.38300601f, 0.31351626f, -0.46341106f, 0.33973366f, 
    -0.46262249f, 0.16639914f, -0.26112443f, 0.06683842f, 0.19848065f, -0.23638771f, -0.25184700f, 0.63466084f, 
    0.06102390f, 0.29744270f, 0.37544996f, -0.11893937f, 0.30951121f, -0.32020465f, 1.44742918f, 1.24015737f, 
    0.05542001f, 1.03764296f, 1.08725107f, 0.87732184f, 0.75578827f, -0.35065928f, -0.65755552f, -0.19964276f, 
    -0.25762287f, -0.24325058f, -0.38019261f, -0.35151094f, -0.00830540f, -0.08380762f, -0.14529003f, 0.52755874f, 
    0.03158673f, -0.00863035f, 0.16726333f, -0.24283174f, 0.56800973f, -1.07955837f, -0.09912533f, -0.31356487f, 
    0.28351247f, 0.54018104f, -1.43016183f, 0.78479153f, 0.80803925f, -0.68831986f, -0.39821088f, 0.13802117f, 
    -0.12899493f, -0.00680486f, -0.47389904f, 0.52880132f, 0.39732665f, 0.19805336f, -0.13893783f, 0.20898512f, 
    -0.72776842f, -0.30269039f, 0.18892235f, 0.39793724f, -0.26439089f, 0.61560744f, 1.15845227f, -0.29475158f, 
    0.83338428f, -0.40297720f, -1.30279040f, -0.29378003f, -0.91569972f, 0.16575217f, -0.06993511f, -0.16134699f, 
    0.08695840f, 0.74837130f, -0.03515565f, -0.14652041f, 0.27984402f, -0.02082876f, 0.41022554f, 0.03834812f, 
    0.18882135f, 0.26960227f, 0.25130716f, -0.29907253f, -0.23984729f, -0.02129639f, 1.60716736f, 0.62478191f, 
    -0.78001213f, 0.45200819f, 1.23975325f, 0.43037897f, 0.01195395f, -0.60944033f, 1.02038169f, 0.25909024f, 
    0.06878453f, 0.17489336f, -0.34853971f, -0.33597231f, -0.08526336f, -0.42171815f, -0.40271613f, -0.41322604f, 
    -0.31963208f, -0.24276008f, -0.01505167f, -0.13882059f, 0.24673478f, -0.04012003f, 0.09033579f, -0.31374174f, 
    -1.92068064f, -1.31610811f, 0.59003812f, 0.01391538f, -0.70799351f, 1.57855856f, 0.07553565f, -0.56771344f, 
    0.03132481f, 0.29189101f, 0.24332318f, -0.20336701f, 0.13960028f, 0.23467477f, -0.46242562f, 0.02136816f, 
    -0.43919376f, -0.57236385f, -0.08780128f, 0.15960351f, 0.07233070f, 0.23973525f, 0.09927596f, 0.28786197f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22311544f, 0.29527003f, 0.06391732f, 0.26822948f, 0.22204192f, 0.45191821f, 0.31788290f, 0.11875168f, 
    0.01959620f, 0.11985013f, 0.41578677f, 0.09166714f, 0.14610957f, 0.16172674f, 0.40856197f, 0.47330213f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.50227374f, -0.69551498f, 0.36831507f, -0.65359277f, -0.27630067f, -0.04211853f, 0.22335733f, -0.13329302f, 
    -0.05140450f, 0.04330656f, 0.01384616f, 0.19405407f, -0.04799085f, -0.16519688f, 0.01834120f, -0.20379461f, 
    0.13504480f, 0.02641230f, -0.07654675f, 0.06783007f, -0.18202427f, -0.01158830f, -0.16797104f, -0.15236548f, 
    -0.05195707f, 0.21141422f, -0.28081319f, 0.21033126f, -0.10131200f, -0.11154073f, -0.17145689f, -0.07216941f, 
    0.02428925f, 0.36649615f, 0.08276934f, -0.03642157f, 0.49003693f, -0.44306874f, -0.22750485f, 0.51860410f, 
    -0.09020310f, -0.15694122f, -0.18607144f, -0.03277964f, -0.07279097f, -0.06935976f, -0.00009673f, 0.06690918f, 
    -0.39289996f, 0.07278403f, -0.22915417f, 0.14626057f, -0.33135581f, -0.16179925f, 0.12803364f, -0.13442501f, 
    0.00185008f, -0.04240857f, -0.27819529f, 0.04570128f, -0.82123631f, 0.44004998f, 0.21447667f, -0.25920728f, 
    0.01572725f, 0.10634899f, -0.04728173f, 0.00722732f, -0.07388294f, -0.05388270f, 0.04639174f, -0.01443023f, 
    0.79250699f, -0.16318388f, 0.05501452f, -0.62902617f, -0.03615839f, -0.32696542f, -0.09570767f, 0.22384518f, 
    0.04787838f, 0.09064737f, -0.00316233f, 0.07217797f, -0.27135053f, 0.45836443f, -0.36277273f, -0.54437035f, 
    0.14072034f, -0.05528988f, 0.30467644f, 0.01853004f, -0.00638003f, 0.07299158f, -0.09801602f, 0.10877481f, 
    0.45158425f, 0.18911713f, -0.14281395f, -0.56619328f, 0.25352719f, -0.08717325f, 0.14631504f, -0.01946288f, 
    0.03135949f, -0.03400985f, 0.04152361f, 0.25845146f, 0.18206732f, -0.04451809f, -0.12589927f, 0.53666973f, 
    -0.06102783f, 0.05511808f, 0.13275428f, -0.03360820f, -0.06339221f, -0.18414529f, -0.20149073f, 0.02134953f, 
    0.20320962f, 0.27487195f, -0.15318102f, 0.26416817f, -0.39422989f, -0.07957545f, -0.16857086f, 0.23837860f, 
    -0.08107729f, 0.15674214f, -0.26693290f, -0.18797351f, -0.28779975f, 0.50855678f, 0.19516887f, 0.32311544f, 
    -0.10636834f, 0.23242044f, -0.04132532f, -0.16465943f, -0.25356382f, 0.04356206f, -0.10675117f, 0.09205465f, 
    0.42157355f, -0.22723417f, 0.00101093f, -0.01430392f, 0.01876561f, 0.06255863f, -0.01627259f, -0.18162344f, 
    -0.27062398f, -0.00011852f, -0.09552921f, -0.09975114f, 0.13499948f, 0.18337733f, 0.05143530f, 0.00410696f, 
    -0.24738081f, 0.12760724f, -0.09327871f, 0.13849400f, 0.18384059f, 0.00310091f, 0.16319184f, -0.09833028f, 
    0.22604600f, -0.00457389f, 0.39213300f, 0.32956865f, -0.09212999f, -0.07149763f, 0.08728656f, 0.12102017f, 
    0.04103771f, 0.07836293f, 0.10685246f, -0.14713490f, -0.81313688f, 0.17392004f, -0.20177424f, 0.03565110f, 
    -0.02667996f, -0.05488536f, -0.26208583f, -0.17222412f, -0.07753991f, 0.18310669f, -0.00493519f, -0.03678195f, 
    0.64753020f, -0.34095258f, 0.02882388f, -0.53016734f, -0.24367388f, 0.00824931f, 0.17533438f, -0.13308190f, 
    -0.07128509f, -0.06177782f, -0.09937263f, -0.11609564f, -0.24577759f, -0.05210251f, -0.18866885f, -0.49394616f, 
    -0.00808656f, -0.05530893f, -0.09452987f, -0.00552068f, 0.36751971f, -0.15682666f, 0.08763458f, -0.13540155f, 
    0.50305349f, -0.22669472f, 0.33743382f, 0.31703448f, -0.18219735f, 0.02675849f, -0.10434588f, 0.12809910f, 
    0.18635164f, -0.28090879f, -0.01234345f, 0.08848441f, 0.01028546f, 0.29471511f, 0.17871277f, 0.06475723f, 
    -0.18744481f, -0.24500294f, 0.19975843f, 0.20238294f, -0.01393730f, -0.20734392f, 0.20084763f, -0.02821507f, 
    0.10385155f, 0.19456081f, 0.12228122f, -0.04682769f, -0.27498761f, -0.10426863f, -0.04361715f, -0.36246556f, 
    0.01544177f, -0.19881268f, 0.27267453f, 0.13191117f, -0.46925274f, 0.03947560f, -0.04761811f, -0.21859692f, 
    -0.00746543f, 0.13221046f, 0.09314701f, 0.09248437f, 0.17133027f, 0.26376185f, 0.08444943f, 0.11224625f, 
    0.37402683f, 0.09599668f, 0.04753972f, -0.01825382f, 0.05112886f, -0.23649202f, 0.09331656f, 0.00631875f, 
    -0.10326622f, -0.05921197f, -0.01658858f, -0.02283099f, 0.35403612f, -0.04255267f, -0.02562708f, -0.08215343f, 
    0.00785283f, -0.20378320f, -0.19492418f, 0.14760514f, -0.00140827f, -0.00239371f, -0.16902210f, 0.01700939f, 
    -0.02785801f, -0.42538565f, -0.01784644f, -0.35304978f, 0.17909990f, -0.00741623f, -0.01054533f, 0.15248638f, 
    0.02694574f, -0.08334737f, 0.28078660f, -0.12277807f, -0.27655217f, -0.28782094f, -0.03018427f, 0.02616829f, 
    -0.34098154f, -0.04599392f, -0.01728027f, -0.11387840f, 0.06557953f, -0.05834994f, -0.03004656f, -0.14948012f, 
    0.22513936f, -0.02785049f, 0.13156764f, 0.15118097f, -0.21442385f, 0.05914474f, 0.01988869f, 0.02718143f, 
    0.00215572f, -0.10780763f, 0.05379369f, -0.17002441f, 0.40887308f, 0.01122950f, -0.08997646f, 0.25842926f, 
    0.16397911f, 0.16072996f, -0.03311697f, 0.13484253f, 0.23380709f, 0.33696824f, -0.07563518f, 0.01970425f, 
    -0.16011138f, -0.26671049f, 0.07237296f, -0.28362414f, -0.04251795f, 0.20512724f, 0.13252471f, -0.08592410f, 
    0.31584358f, 0.03399542f, 0.04814234f, 0.14979629f, 0.48324752f, -0.41920921f, -0.43665090f, -0.23182364f, 
    -0.02366616f, -0.10468399f, -0.04963637f, 0.01229137f, -0.17326325f, 0.00696953f, -0.09785870f, 0.10224078f, 
    0.23379405f, -0.30918187f, 0.01295234f, 0.22908075f, -0.07602685f, -0.19691251f, -0.09738430f, -0.10034312f, 
    -0.21192929f, -0.04460653f, -0.44734854f, -0.09817363f, 0.27400857f, -0.53216302f, -0.33012435f, 0.03766670f, 
    -0.00583033f, 0.11923783f, -0.15677638f, 0.10768014f, 0.02535139f, -0.15256011f, 0.04254961f, -0.07957500f, 
    -0.72500271f, -0.19205049f, -0.09968438f, -0.56008971f, 0.00559446f, -0.17599958f, 0.01324492f, -0.12396732f, 
    -0.11713390f, -0.19790983f, -0.03072556f, 0.01268939f, -0.66337687f, -0.23803210f, -0.39640939f, -0.43947306f, 
    0.05768218f, -0.30677342f, 0.02333580f, -0.38952184f, 0.07700024f, 0.18310291f, -0.14286126f, 0.09367628f, 
    0.22149785f, -0.22142793f, 0.04760878f, 0.15935962f, 0.11694576f, -0.03647846f, -0.11709963f, -0.04924992f, 
    -0.14464897f, -0.07197051f, -0.12311655f, 0.00949896f, -0.41081175f, 0.15407646f, -0.14664760f, -0.00860467f, 
    0.10683837f, 0.12233529f, -0.22098649f, -0.07954903f, -0.14123583f, -0.06988820f, 0.05264270f, -0.12233233f, 
    0.33945477f, -0.03354833f, -0.14105657f, 0.21111198f, -0.14351338f, 0.14958514f, 0.07827272f, -0.03707976f, 
    0.01693660f, -0.07775699f, -0.16320668f, -0.07052281f, -0.63131213f, -0.08405790f, -0.03973539f, -0.23947492f, 
    0.03806429f, 0.22140040f, 0.06451662f, -0.01353036f, -0.05298886f, -0.28386858f, -0.15586527f, -0.18185240f, 
    -0.20445478f, 0.19776349f, 0.03445123f, -0.04132088f, 0.14829403f, 0.09092557f, 0.23870416f, 0.12616372f, 
    -0.03310613f, -0.12196975f, 0.02093459f, 0.06942880f, 0.47039351f, 0.29754120f, 0.00089418f, 0.41410065f, 
    -0.28574404f, -0.25978345f, 0.13615425f, 0.14679807f, -0.07765106f, 0.16654481f, -0.11516822f, 0.17361064f, 
    0.21636641f, 0.38776696f, 0.14844862f, 0.46010736f, -0.09063125f, 0.03654690f, -0.00971623f, 0.18095079f, 
    -0.11357829f, 0.06320519f, 0.03468059f, -0.01344808f, 0.60949636f, -0.04480439f, 0.00815506f, -0.00347826f, 
    -0.30555660f, 0.21789497f, 0.12391631f, -0.04202031f, 0.14177874f, -0.12579305f, -0.07901520f, -0.17003652f, 
    -0.16285272f, 0.02838084f, -0.10966358f, -0.33509579f, 0.00146340f, 0.04025865f, 0.10230255f, -0.08522680f, 
    0.03287178f, 0.07916109f, -0.06145465f, -0.19589938f, -0.02879688f, -0.37333080f, -0.12769322f, 0.00440844f, 
    -0.05507642f, -0.10019159f, -0.03548299f, -0.09699244f, 0.13333608f, 0.04118435f, 0.29467636f, 0.12255854f, 
    -1.23917317f, 0.19868176f, -0.07480290f, 0.37893385f, 0.22295052f, -0.00135161f, -0.08852719f, 0.10793878f, 
    0.05297070f, -0.01607019f, -0.33192596f, -0.19702385f, -0.13175514f, 0.20151724f, -0.29226291f, -0.30145568f, 
    0.02346535f, 0.07522962f, 0.02738586f, -0.35235068f, 0.07988512f, 0.13340895f, -0.02098332f, 0.04941992f, 
    0.63270497f, -0.17576776f, -0.10396101f, -0.12750007f, 0.08781403f, -0.14725368f, 0.06449899f, 0.06876595f, 
    -0.04518425f, 0.22687875f, 0.06366403f, -0.02850412f, 1.27056623f, -0.25131831f, 0.19245370f, -0.13403508f, 
    -0.20551795f, -0.12800990f, -0.23305991f, -0.12595709f, 0.03482398f, -0.10335936f, 0.14471704f, 0.14207278f, 
    0.37856600f, 0.31843907f, 0.15781386f, -0.03898956f, -0.07646622f, 0.43359026f, 0.16213891f, 0.08281625f, 
    -0.17518824f, -0.02421777f, 0.06482219f, 0.00099489f, 0.12054076f, 0.12694836f, 0.05656773f, -0.05757439f, 
    -0.22837065f, -0.05673807f, 0.00781271f, 0.34848803f, -0.08885901f, 0.26100957f, -0.08667704f, 0.40210024f, 
    -0.29658559f, -0.25534907f, 0.09186349f, -0.05333314f, -0.04776468f, 0.02519902f, -0.01854772f, -0.16864499f, 
    -0.02006337f, -0.09613971f, -0.21089393f, 0.06024449f, -0.11456383f, -0.67915654f, -0.57127738f, 0.31453997f, 
    -0.00631092f, 0.08109384f, 0.04659265f, -0.23611329f, 0.16876689f, 0.17599364f, -0.04792455f, 0.06274898f, 
    -0.31334856f, -0.21642222f, 0.04738713f, 0.17989141f, 0.01678229f, -0.12734672f, 0.19434632f, 0.29337513f, 
    0.02998520f, 0.18623368f, -0.05413397f, 0.03601553f, 0.35669938f, -0.35349265f, 0.11089179f, 0.17453817f, 
    0.18148540f, -0.03800066f, 0.09112871f, 0.18030690f, 0.04892195f, -0.05126091f, -0.15574673f, -0.11165439f, 
    -1.35748208f, -0.55894023f, -0.55632514f, -0.35659888f, -0.06675983f, -0.18422614f, -0.00033159f, 0.22004038f, 
    -0.15781596f, 0.03276178f, -0.04053177f, 0.03575732f, 0.07740864f, -0.17331178f, -0.15036984f, -0.01011451f, 
    -0.35805398f, -0.29918358f, 0.07804177f, -0.00926536f, -0.14037900f, -0.15570816f, 0.03935077f, -0.12859175f, 
    -0.38749877f, 0.06656029f, -0.06846360f, -0.17602602f, -0.08284203f, 0.05086371f, -0.01677137f, -0.24507320f, 
    -0.13168007f, 0.08079745f, -0.13790767f, 0.06026961f, -1.27447915f, 0.59369302f, -0.07125565f, 0.27060229f, 
    0.20279148f, 0.06376030f, 0.06899601f, -0.07710801f, -0.15441641f, -0.06285553f, 0.04526404f, -0.18460234f, 
    -0.71667933f, -0.21751375f, -0.52133787f, 0.43587384f, 0.00686462f, 0.01477352f, -0.04039584f, 0.01797459f, 
    -0.01399319f, -0.04581222f, 0.16619207f, -0.29552880f, -0.57919484f, 0.28969505f, -0.38708216f, -0.22758344f, 
    -0.15586884f, -0.16758390f, 0.16454458f, -0.00995442f, -0.01838196f, -0.02646177f, 0.08698781f, -0.00397024f, 
    0.13604638f, 0.29295361f, 0.36735463f, 0.27582943f, -0.13318218f, -0.11718102f, -0.06713512f, 0.09362021f, 
    0.13977650f, 0.22195131f, -0.14834724f, -0.00391214f, 0.48281842f, -0.02299099f, -0.24342547f, -0.01475901f, 
    0.11274774f, 0.28858721f, -0.02097658f, -0.06275965f, 0.04210530f, 0.01539115f, -0.07090323f, -0.10826841f, 
    0.49235716f, 0.05103605f, -0.24914646f, -0.15951376f, -0.06578211f, 0.15661766f, 0.02398050f, -0.06784011f, 
    -0.02010851f, 0.04503168f, 0.12995832f, -0.09328327f, 0.37283808f, 0.16482729f, 0.21604787f, 0.15834314f, 
    0.00882962f, -0.05407920f, 0.15060459f, -0.05997282f, -0.04533850f, 0.09758897f, -0.10051505f, 0.21718293f, 
    0.00038031f, 0.24211314f, -0.48971316f, 0.24562690f, 0.04347383f, -0.10695157f, 0.01602461f, -0.15979773f, 
    -0.19818074f, -0.08300101f, 0.04294317f, -0.13679321f, 0.06974903f, -0.03225882f, 0.12981139f, 0.20593721f, 
    0.04173534f, -0.39736944f, 0.22234344f, 0.21049064f, -0.07113985f, 0.01706201f, 0.13175252f, 0.28890797f, 
    0.11915609f, -0.02627824f, -0.13466978f, 0.02597365f, -0.24113929f, -0.18183383f, 0.09379857f, 0.03401206f, 
    -0.05574209f, 0.06436616f, -0.20940951f, -0.02033781f, 0.00285586f, -0.04787833f, 0.36133730f, 0.26037019f, 
    -0.09955186f, 0.27238521f, 0.04470064f, -0.22009365f, 0.21175493f, 0.17108339f, -0.06228732f, 0.12568580f, 
    -0.08610652f, 0.07360247f, -0.12732342f, -0.09053478f, -0.10651519f, 0.09600691f, 0.17284817f, 0.15804575f, 
    0.04663852f, -0.12754644f, -0.10198192f, 0.17705344f, 0.14554401f, -0.29419458f, 0.29900879f, -0.22189669f, 
    -0.09515736f, -0.01948623f, -0.05427286f, -0.34243056f, 0.06196973f, -0.18342967f, -0.10214899f, -0.18802093f, 
    -0.33899090f, -0.42891338f, -0.23057666f, -0.25742909f, 0.19870733f, 0.04327375f, -0.30077118f, -0.00963445f, 
    0.20088047f, 0.08656603f, 0.13744842f, 0.12468800f, -0.59512663f, -0.04925279f, 0.03877645f, 0.51030076f, 
    -0.09012041f, 0.03165403f, 0.12697475f, 0.19451964f, 0.04294435f, 0.11483943f, 0.18285991f, 0.06005270f, 
    -0.73118520f, -0.44083682f, 0.06060385f, 0.39543715f, 0.04704278f, -0.01301527f, 0.01675914f, -0.05910675f, 
    -0.02239762f, 0.08575889f, 0.02456600f, -0.08784806f, -0.54489702f, 0.34760854f, -0.13644290f, -0.08131085f, 
    0.11181585f, 0.29508993f, 0.06816832f, 0.12420795f, -0.13673598f, 0.24147747f, 0.04689385f, -0.07733522f, 
    -0.39176273f, 0.17874876f, 0.52353084f, -0.02206796f, 0.03830205f, -0.00355848f, 0.06232144f, -0.01543606f, 
    0.24109052f, -0.02506707f, -0.18220603f, 0.08084003f, 0.25942528f, -0.05405466f, -0.14442933f, 0.19823952f, 
    -0.12596358f, 0.25284475f, 0.21560024f, -0.07375877f, -0.06793155f, -0.20238218f, 0.23664504f, -0.05363161f, 
    0.03594821f, 0.03986608f, -0.32085076f, 0.20202608f, -0.00889537f, -0.03048656f, -0.01525259f, -0.10098288f, 
    0.07650334f, -0.23843703f, 0.10843569f, 0.01912040f, -0.42275786f, -0.39480865f, 0.03571335f, 0.29709876f, 
    -0.15329050f, 0.23648950f, 0.16759787f, -0.40126440f, 0.10167550f, -0.04305477f, -0.10015878f, -0.39830875f, 
    0.42812851f, -0.18104920f, -0.09811470f, 0.09783203f, -0.14489147f, 0.05370671f, -0.11398610f, 0.17017978f, 
    -0.12037511f, -0.22802395f, -0.08009593f, 0.04836285f, -0.86319983f, 0.53962129f, -0.11686916f, -0.27454042f, 
    0.05474602f, -0.12311469f, 0.13652968f, 0.08421747f, -0.11158014f, -0.01080867f, -0.06053529f, 0.09496062f, 
    -0.25602990f, -0.13143435f, 0.23284338f, 0.19484565f, 0.02172152f, -0.10486741f, -0.25963560f, 0.33497173f, 
    0.35539275f, 0.23618281f, 0.00320018f, -0.23290876f, 0.38106236f, 0.16598633f, 0.19504248f, 0.14655209f, 
    0.27357870f, 0.49546364f, 0.16118523f, 0.26678836f, -0.07305461f, 0.06557062f, 0.12121881f, -0.26048473f, 
    -0.23912899f, 0.15282886f, 0.25858843f, -0.06731252f, 0.31942052f, 0.01065211f, 0.10098135f, 0.02483446f, 
    0.26133230f, 0.08343524f, 0.11387838f, 0.15008466f, 0.11694279f, -0.06648117f, -0.14121270f, -0.00145331f, 
    0.07897690f, -0.17038761f, -0.28245482f, 0.12603469f, 0.03596238f, 0.08434428f, -0.01864764f, 0.01534178f, 
    0.10373659f, -0.13920857f, 0.18032634f, 0.27744290f, 0.17079207f, 0.10949045f, -0.04448722f, -0.10230399f, 
    0.03618417f, 0.08972088f, 0.02245253f, 0.05014351f, -0.37285730f, 0.25822443f, -0.04923849f, 0.22990789f, 
    -0.21596357f, 0.06758880f, -0.00848308f, 0.00879835f, 0.06325385f, -0.02104235f, 0.04768598f, 0.14712138f, 
    0.31492841f, 0.10238471f, 0.28903767f, 0.06184814f, -0.04898908f, -0.06378178f, 0.06645960f, -0.07721286f, 
    -0.10592502f, -0.09810028f, -0.12210199f, -0.11658122f, -0.28721058f, -0.60182470f, -0.47007549f, -0.06497321f, 
    0.09849937f, 0.10948511f, -0.36312038f, -0.24951819f, 0.16909550f, -0.04723483f, -0.16608146f, -0.00358848f, 
    0.38701791f, -0.04791857f, -0.31482890f, -0.15685847f, 0.06794386f, 0.26807272f, -0.26861036f, -0.18821810f, 
    -0.05417540f, -0.07173555f, -0.12884939f, -0.05327664f, -0.35840315f, 0.13741988f, 0.07859351f, -0.15582192f, 
    0.05664470f, -0.15617199f, -0.08613083f, 0.14193475f, 0.03633437f, 0.12720624f, 0.22288644f, 0.14139049f, 
    -0.06568416f, 0.00792542f, -0.05284084f, 0.30133542f, -0.06748385f, 0.10781382f, 0.10040089f, -0.11671866f, 
    -0.13630728f, -0.14236045f, -0.03693245f, 0.18578801f, -0.14074573f, 0.31561691f, 0.49086446f, -0.41101116f, 
    -0.21141334f, -0.14344181f, -0.05614562f, -0.00531872f, 0.15831891f, -0.15113617f, -0.28372279f, -0.27840456f, 
    -0.48472250f, -0.23999868f, 0.12816878f, 0.03033329f, -0.05584739f, -0.01464990f, 0.01857551f, -0.30938810f, 
    0.02539222f, -0.16174829f, 0.04799250f, -0.00397738f, 0.03312891f, 0.23064978f, 0.31227320f, -0.10744206f, 
    -0.13283308f, -0.19302495f, -0.02047774f, 0.15037051f, 0.03759500f, -0.09892832f, 0.38638592f, 0.24021791f, 
    -0.03658260f, -0.19847170f, -0.22334154f, -0.50922531f, 0.02751626f, -0.01693921f, -0.10831726f, 0.01873196f, 
    -0.09766773f, -0.14190111f, -0.11599747f, 0.00479157f, -1.04810238f, -0.06114663f, -0.10296924f, -0.35250342f, 
    -0.01274373f, -0.03736411f, 0.15565917f, 0.17403425f, 0.06718165f, -0.17581864f, 0.02105527f, -0.18224233f, 
    0.22601773f, -0.31839520f, -0.55050302f, 0.22430660f, 0.22370741f, 0.08935141f, -0.12222246f, -0.07399660f, 
    -0.08924681f, -0.12752470f, -0.01162460f, 0.07925508f, -0.21525882f, -0.14727542f, -0.08173248f, 0.16348003f, 
    -0.28226161f, -0.29415798f, -0.10424101f, -0.01813671f, 0.14045118f, -0.09399006f, -0.20304771f, 0.15794198f, 
    -0.31699809f, -0.26308775f, -0.06716243f, -0.36522958f, -0.22760883f, 0.06074616f, 0.03505553f, -0.01879887f, 
    0.03160305f, -0.14737977f, -0.03921722f, -0.28019267f, -0.45481777f, 0.49278319f, 0.14172980f, -0.13399956f, 
    0.03217234f, 0.14030203f, 0.18335102f, 0.01662120f, -0.07433366f, -0.17407990f, 0.07577438f, -0.04655457f, 
    0.38528568f, 0.14912105f, 0.12975675f, -0.32314423f, 0.13027664f, -0.11782149f, 0.04134690f, 0.15638812f, 
    0.10480072f, 0.38707933f, -0.08349122f, -0.20258111f, -0.18867205f, -0.13897438f, -0.30258113f, 0.44911605f, 
    -0.09932179f, -0.09454320f, -0.03179802f, 0.00684965f, -0.20213504f, -0.14650902f, -0.28061569f, -0.19585350f, 
    -0.98165256f, 0.43092117f, 0.31936631f, 0.44227833f, -0.21204588f, 0.03523807f, -0.10360812f, -0.09188016f, 
    0.01323899f, 0.06349596f, -0.10059825f, -0.06895395f, -0.50887537f, -0.30609351f, -0.22508734f, -0.54583889f, 
    0.11733733f, 0.21258983f, 0.01940114f, 0.04948920f, -0.03419702f, -0.06408571f, 0.17788073f, 0.14305441f, 
    -0.11441144f, -0.13751332f, -0.07932302f, 0.05257756f, -0.15264416f, -0.13811988f, 0.09635086f, -0.25611791f, 
    0.03893972f, 0.05579051f, 0.06921299f, 0.00683831f, 0.78377891f, -0.57355034f, 0.20721282f, -0.00583873f, 
    0.14468206f, 0.14186390f, 0.19037111f, -0.17121002f, 0.12376419f, -0.12829581f, 0.19957389f, -0.13324545f, 
    -0.00562738f, 0.26567382f, 0.17901812f, -0.38898474f, 0.01947789f, 0.09808096f, 0.07586649f, 0.04259809f, 
    0.07032828f, 0.10504386f, 0.11265722f, 0.01477374f, -0.06216787f, -0.26476744f, 0.13718851f, -0.28510842f, 
    0.01779402f, -0.02557361f, -0.05949073f, 0.13383880f, -0.12389167f, -0.07723303f, 0.05752394f, 0.22885889f, 
    -0.18961950f, 0.07914762f, 0.12196372f, -0.19725806f, 0.06149967f, -0.01654192f, 0.04773595f, 0.02060201f, 
    0.00299615f, 0.20402411f, -0.13836591f, 0.05430121f, 0.13908008f, 0.17041214f, 0.31359115f, 0.22610916f, 
    0.10185862f, 0.10201765f, 0.00200074f, -0.03585567f, -0.03893480f, -0.02239636f, -0.19945951f, -0.02472355f, 
    -0.64695334f, 0.20990533f, 0.23796648f, -0.16427763f, -0.01670163f, -0.02072820f, 0.08810664f, 0.00022949f, 
    0.05552240f, 0.04374541f, 0.09067710f, 0.09088568f, 0.46254623f, -0.35348639f, 0.00430067f, 0.10598235f, 
    0.05371942f, 0.01359788f, 0.02115916f, -0.24543619f, 0.05230701f, 0.03261101f, 0.22297452f, -0.00102610f, 
    -0.38537094f, 0.43717366f, 0.10566282f, 0.22912401f, -0.17164333f, -0.03328817f, -0.22297092f, 0.16930075f, 
    -0.08770873f, 0.11889187f, -0.21687880f, -0.02930105f, 0.31482038f, 0.27909553f, 0.12536703f, 0.58823550f, 
    0.06952517f, -0.04778778f, 0.01680652f, -0.17320430f, -0.10205107f, 0.24055146f, -0.08868074f, -0.09646685f, 
    -0.27763265f, 0.56952924f, -0.00925812f, -0.12468750f, -0.00378772f, -0.02341882f, 0.07132482f, 0.03305683f, 
    -0.07612087f, 0.20299970f, 0.06699521f, -0.12260962f, -0.00001514f, 0.09482414f, -0.52601433f, -0.55394340f, 
    -0.14454293f, 0.19409348f, -0.16102846f, -0.20636673f, -0.02385106f, 0.01649744f, 0.18637753f, 0.18267000f, 
    -0.19810735f, -0.39154989f, -0.16498978f, -0.25181884f, 0.31080922f, 0.15043239f, -0.03461109f, -0.01377874f, 
    -0.15358645f, 0.14346381f, 0.01675037f, -0.10121787f, -0.17314877f, 0.04039980f, -0.04128746f, 0.33732915f, 
    0.17424606f, -0.29741010f, -0.05366876f, -0.06053055f, -0.07531494f, 0.07263817f, 0.05569343f, -0.13176762f, 
    -0.43541005f, 0.02243092f, -0.17922460f, 0.04380314f, -0.19963017f, 0.17231278f, 0.04544097f, -0.09869067f, 
    -0.10224339f, -0.10397914f, -0.03074550f, -0.27629462f, 0.25356334f, 0.30416915f, 0.49275932f, 0.16491088f, 
    0.28979361f, 0.27927634f, 0.17121184f, -0.20036291f, -0.06373017f, 0.08185525f, 0.04622869f, -0.10890366f, 
    0.23621503f, 0.44585532f, 0.03001915f, 0.12216891f, 0.03350719f, -0.06016024f, 0.25861180f, -0.06829203f, 
    0.02599374f, 0.05045168f, -0.02973896f, -0.05522049f, 0.51366758f, 0.04530545f, 0.11109529f, -0.46617711f, 
    0.17869863f, -0.04750358f, -0.09151631f, -0.07366602f, -0.14821583f, -0.13245448f, -0.00231531f, -0.09559511f, 
    -0.09898601f, -0.61284924f, -0.33230299f, -0.03737456f, -0.09405526f, -0.14985533f, 0.09594229f, -0.07089327f, 
    -0.15113837f, -0.05776263f, -0.16105989f, 0.27284384f, -0.22412196f, 0.09786455f, 0.02883407f, -0.32833052f, 
    -0.12082084f, -0.01130161f, -0.12643865f, -0.18772766f, 0.03922611f, -0.05712872f, 0.11904319f, -0.17214011f, 
    0.67675030f, 0.57602894f, -0.18707392f, 0.10895088f, 0.03046871f, 0.00195982f, -0.24516617f, 0.08391508f, 
    -0.19672823f, -0.06564717f, 0.04440868f, -0.26755822f, -0.49550033f, 0.20043528f, -0.09208511f, 0.07181727f, 
    -0.19121766f, -0.27736947f, -0.19076793f, 0.10611146f, -0.14440718f, -0.16597447f, -0.01724625f, -0.03440826f, 
    -0.85063976f, 0.21930061f, -0.31235069f, 0.04023197f, -0.18104212f, 0.04344623f, -0.22577359f, -0.10489604f, 
    -0.14145665f, -0.09975045f, -0.06452873f, -0.17823358f, 0.42879596f, -0.21467520f, 0.43812671f, -0.20597485f, 
    -0.06924643f, -0.05557689f, -0.20469888f, 0.09179579f, -0.01875326f, 0.03100737f, -0.31240004f, -0.12767410f, 
    -0.11271136f, 0.62978047f, -0.39929816f, -0.53440195f, -0.16058350f, -0.02040226f, -0.35381153f, 0.03428190f, 
    0.12761351f, -0.04696857f, -0.04858032f, 0.06573623f, -0.52073675f, -0.13542385f, -0.20926817f, -0.63970417f, 
    0.23391692f, 0.08750762f, -0.33970043f, 0.23849578f, 0.07438639f, -0.31824699f, 0.19514340f, -0.51459122f, 
    0.26882160f, -0.18437642f, 0.09770919f, 0.19122389f, 0.02419027f, 0.09639040f, 0.06829363f, -0.19601531f, 
    0.07744280f, -0.05173937f, 0.16289340f, 0.09079741f, -0.34261307f, -0.11234533f, 0.03885750f, 0.03876288f, 
    0.21367891f, 0.03716986f, -0.09503970f, -0.02094124f, 0.19662654f, 0.12539423f, -0.33490634f, -0.16514042f, 
    0.27905974f, -0.15479670f, -0.02281146f, 0.00959112f, -0.09357759f, -0.22978660f, -0.18484919f, 0.06332380f, 
    -0.14639807f, -0.05320330f, 0.04164209f, 0.02083128f, 0.50313395f, 0.11867508f, -0.33085939f, -0.45987552f, 
    -0.09009489f, -0.07124663f, 0.06533670f, -0.05051993f, 0.10529736f, -0.01381704f, 0.03615591f, 0.35117358f, 
    0.46578771f, 0.36101362f, -0.09661088f, 0.16957495f, 0.00708888f, -0.06744379f, -0.07318981f, -0.15153912f, 
    -0.06901496f, -0.01746212f, 0.01074529f, 0.20174164f, -0.51057798f, -0.08784153f, 0.44337580f, -0.17993593f, 
    -0.08539423f, -0.01611961f, -0.27110121f, -0.13448752f, 0.06445910f, -0.15202890f, -0.18318236f, -0.14826359f, 
    0.10355191f, 0.29592472f, 0.04274748f, 0.22603238f, -0.24317583f, 0.28376842f, -0.14966397f, 0.13884926f, 
    -0.04233075f, -0.04292217f, -0.08181199f, -0.15139487f, -0.02789576f, -0.43534201f, 0.07273538f, 0.03849169f, 
    -0.05852624f, -0.16362846f, -0.15859282f, -0.13005726f, 0.07990051f, -0.08828247f, -0.25897491f, 0.11605845f, 
    -0.12417819f, -0.27034956f, -0.30961937f, 0.33935598f, 0.12713283f, 0.11123599f, 0.02550408f, -0.24012576f, 
    -0.10916981f, -0.09794245f, 0.18053778f, 0.26608577f, 0.70285648f, 0.14444062f, 0.07081774f, 0.26739296f, 
    -0.16295531f, -0.20358485f, -0.07107716f, -0.07959551f, 0.11634936f, -0.24118800f, -0.19552165f, -0.40653923f, 
    -0.56230050f, 0.22527510f, 0.03349952f, -0.17167035f, -0.27995786f, 0.05381766f, 0.13810652f, -0.09975889f, 
    0.01918562f, 0.16440555f, 0.23934123f, 0.31736910f, 0.24917144f, -0.31005755f, -0.54514349f, -0.18428645f, 
    0.10852297f, -0.29923815f, -0.17876448f, -0.06699194f, 0.20744312f, 0.14157581f, 0.23098578f, -0.05503895f, 
    0.07051877f, -0.09598648f, 0.01545738f, 0.23436868f, 0.11783659f, -0.06145140f, -0.07385519f, -0.12510359f, 
    -0.25270554f, 0.10965458f, -0.12403589f, 0.01479619f, -0.21101874f, 0.16966426f, -0.04540674f, -0.11567828f, 
    0.32185858f, 0.06376156f, -0.04701779f, -0.24570301f, 0.09784176f, -0.01623103f, -0.30950481f, 0.04000304f, 
    -0.51721340f, 0.14453974f, 0.55499452f, 0.13576305f, 0.10787778f, 0.05750807f, -0.09786306f, 0.12461189f, 
    0.08882079f, 0.13708162f, 0.18920951f, 0.21018736f, -0.01067380f, -0.19104919f, -0.00265485f, -0.08026882f, 
    0.05744708f, 0.13123484f, 0.02761908f, -0.24691461f, -0.43041524f, 0.13266441f, -0.00150955f, 0.16322853f, 
    -0.49945599f, 0.74779958f, -0.72249663f, -0.52451873f, 0.22417621f, -0.03894918f, 0.05736366f, -0.03246009f, 
    -0.06960618f, 0.07191819f, 0.03768934f, -0.10896842f, 0.34335500f, 0.00862950f, 0.22845043f, -0.46194616f, 
    -0.08622397f, 0.11642328f, 0.06460288f, -0.39243469f, -0.06382467f, -0.20016792f, -0.08359750f, -0.06173531f, 
    0.04012875f, 0.08786138f, 0.32158291f, 0.00260359f, 0.02971943f, 0.15841053f, -0.24308968f, 0.23713069f, 
    -0.15951066f, -0.03488754f, -0.16528486f, -0.22170372f, 0.45828101f, -0.08004268f, 0.34909794f, -0.46259251f, 
    0.16263057f, -0.21528320f, -0.05618949f, 0.09192064f, -0.22640409f, 0.05162282f, 0.00594373f, -0.12087168f, 
    0.32346341f, 0.29059228f, 0.17004150f, 0.14373212f, -0.04869177f, 0.14444298f, 0.01066733f, -0.01431484f, 
    -0.17913359f, -0.04728750f, -0.05850833f, -0.08921094f, 0.15103616f, -0.45611572f, -0.29897341f, 0.02948914f, 
    0.14702341f, 0.16356139f, 0.07793156f, 0.01360279f, -0.03352661f, 0.14587089f, -0.15407808f, -0.10589368f, 
    -0.18358921f, 0.04658653f, 0.38067690f, -0.16786160f, 0.11197766f, -0.29441190f, -0.13029455f, 0.17180085f, 
    0.41922948f, 0.12385087f, -0.00343165f, 0.11204246f, -0.16217114f, -0.15466404f, 0.27466261f, -0.18067269f, 
    0.00923104f, -0.19317342f, -0.10624895f, 0.05469792f, 0.21395060f, -0.12861779f, -0.15208632f, 0.09104684f, 
    -0.35431489f, 0.12588128f, 0.08017164f, -0.38356909f, -0.03587000f, -0.00327742f, -0.10780094f, 0.02812431f, 
    -0.08963291f, -0.02245483f, 0.17536770f, -0.02072901f, -0.06694929f, -0.32868141f, -0.08399193f, 0.13518547f, 
    0.13374411f, 0.15854284f, -0.01671269f, -0.26218316f, -0.33882692f, 0.07424571f, 0.05088684f, 0.20139682f, 
    0.48997232f, 0.03486755f, -0.39438686f, 0.06745174f, 0.01624908f, -0.07737804f, -0.09963597f, 0.31826544f, 
    0.12150959f, -0.00425780f, 0.13521260f, 0.00490734f, -0.24814579f, -0.20620619f, 0.18455155f, -0.35284087f, 
    -0.06172737f, -0.26816776f, 0.18193139f, 0.03556136f, -0.09291042f, 0.06181742f, -0.22419053f, -0.10708727f, 
    -0.88563144f, 0.76649481f, 0.05121431f, -0.51003635f, 0.08033463f, 0.03462760f, -0.10557478f, -0.10869756f, 
    -0.01715077f, 0.03813453f, 0.37357584f, 0.08078033f, -0.43196127f, -0.27322650f, -0.08512043f, 0.15966584f, 
    -0.08024319f, -0.05641777f, -0.00946038f, 0.01380442f, -0.04298280f, 0.19125174f, 0.05087947f, -0.03953002f, 
    -0.27819002f, -0.33363050f, 0.10706571f, 0.06762740f, 0.18972634f, 0.19260330f, 0.07338791f, 0.04948110f, 
    0.16839471f, -0.04847268f, -0.08374216f, -0.09382971f, -0.09814700f, -0.02913547f, 0.13863324f, 0.21436520f, 
    -0.06975863f, 0.25274664f, -0.19100378f, -0.01284888f, 0.14129804f, -0.15002942f, 0.10750771f, -0.45556208f, 
    -0.43775740f, 0.02835548f, -0.18581921f, -0.15557227f, 0.19318646f, -0.02315501f, 0.11825236f, 0.17031138f, 
    -0.01085492f, -0.03637215f, 0.39531296f, 0.13476884f, -1.10077620f, -0.20137703f, 0.05827209f, 0.02722660f, 
    0.20983820f, -0.18357867f, 0.22945991f, 0.05320480f, -0.00716121f, 0.05075079f, -0.24819255f, 0.16009603f, 
    -1.34186530f, -0.46425444f, -0.29008332f, -0.29548985f, 0.10136806f, -0.32468885f, -0.28414240f, -0.12766714f, 
    0.02351643f, -0.08885954f, 0.21911660f, 0.02691585f, -0.28043473f, 0.08444902f, -0.12582298f, 0.14843419f, 
    0.27731332f, 0.05308957f, 0.05149411f, 0.05099452f, 0.00501351f, 0.30060112f, 0.17008528f, 0.29765940f, 
    -1.07267904f, -0.96618229f, 0.14844400f, 0.35350311f, -0.10483294f, 0.19910304f, 0.21450689f, -0.12558274f, 
    0.24719949f, 0.10223681f, 0.13203794f, 0.16474558f, 0.72533596f, 0.12174139f, 0.17832337f, -0.47929260f, 
    -0.14856842f, 0.00012673f, -0.12817447f, -0.15787251f, 0.00194991f, -0.45493793f, 0.00233685f, -0.13777226f, 
    0.10721251f, -0.04469328f, -0.05790479f, 0.04698441f, -0.35840079f, 0.10580404f, 0.05119991f, 0.13166463f, 
    0.17642330f, -0.14508969f, -0.03575726f, -0.15454909f, -0.01615483f, -0.04381624f, -0.18027976f, -0.05447508f, 
    0.07512261f, 0.03576982f, -0.41407263f, 0.16755611f, -0.19164337f, 0.03862103f, -0.26905736f, 0.01833231f, 
    -0.47470582f, -0.15222912f, -0.00084817f, -0.54829139f, 0.11833233f, -0.02748030f, 0.16400377f, 0.02833099f, 
    0.11550595f, 0.17849669f, -0.01938228f, 0.10061374f, 0.33227053f, -0.36972865f, -0.52530181f, -0.23572887f, 
    0.33106887f, -0.42216605f, -0.01450040f, 0.10308704f, 0.16197877f, 0.01212820f, -0.17899054f, 0.01005508f, 
    -0.29740569f, -0.27520162f, 0.31248501f, -0.33978739f, 0.11395450f, 0.14135747f, 0.18108481f, 0.01200157f, 
    -0.17429569f, 0.23189250f, 0.05785338f, 0.23476750f, -0.50520611f, -0.12422995f, 0.46480009f, 0.03669785f, 
    0.25733611f, 0.08830104f, -0.33774495f, 0.29954860f, 0.05615805f, 0.13871592f, 0.08352931f, 0.16277397f, 
    -0.60171086f, -0.80899000f, -0.09302371f, 0.11215580f, 0.11193183f, 0.06671211f, 0.23808268f, 0.00515507f, 
    0.18852864f, -0.09856890f, -0.19682540f, 0.15846318f, 0.35717368f, 0.03687291f, -0.24615580f, 0.30782372f, 
    -0.07391711f, 0.18225625f, -0.04769036f, 0.00138832f, 0.17679518f, 0.08915678f, -0.11384398f, -0.02808455f, 
    0.14901817f, -0.58485919f, -0.11457702f, 0.12062719f, 0.34814760f, -0.11659030f, -0.01462423f, -0.07080545f, 
    -0.22709917f, 0.02144652f, -0.16565792f, 0.24696989f, -0.15905710f, -0.12425279f, -0.23921137f, 0.01824176f, 
    -0.31015563f, 0.20295535f, -0.02754669f, -0.59011054f, 0.23556612f, -0.17826405f, 0.22287294f, -0.01282907f, 
    0.00434720f, -0.85913038f, 0.17555447f, -0.19297729f, -0.19199397f, 0.00490819f, 0.07111328f, -0.08169718f, 
    -0.19965462f, 0.01046322f, -0.33152649f, -0.10539176f, 0.55942118f, -0.06627434f, -0.05782057f, -0.71366072f, 
    -0.06184701f, -0.23496984f, -0.05428619f, 0.37861359f, -0.13234203f, -0.11282317f, 0.01374584f, 0.07676452f, 
    -0.17157607f, 0.15487301f, 0.05809578f, 0.04968840f, -0.16586629f, 0.07830559f, -0.16853766f, -0.11511832f, 
    0.02798017f, -0.16972531f, -0.12072379f, -0.05825819f, 0.55802423f, -0.27781168f, -0.04850371f, 0.28283024f, 
    -0.20934787f, 0.07699054f, -0.06751087f, -0.02756414f, 0.13627453f, -0.12308513f, -0.04246062f, -0.01699405f, 
    0.11790039f, -0.08217489f, -0.10701952f, 0.04366536f, 0.03207975f, -0.03392534f, -0.00537750f, 0.03664889f, 
    0.03671005f, -0.00998974f, 0.06808931f, 0.12393457f, -0.45631889f, 0.22433710f, 0.10275953f, -0.23853095f, 
    -0.04873799f, -0.22647165f, 0.10492033f, -0.13891286f, 0.15014935f, 0.12279849f, 0.14271915f, -0.24003097f, 
    -0.28087196f, 0.03673856f, -0.25565895f, 0.03007688f, -0.08546621f, -0.01150492f, 0.26250863f, 0.14025602f, 
    -0.08733231f, -0.10901166f, -0.13062556f, -0.09616778f, -0.06581529f, 0.52738875f, -0.06820728f, -0.21057647f, 
    0.07789671f, -0.02966255f, -0.12980987f, -0.03532523f, -0.05869092f, 0.26096562f, 0.05937431f, 0.05163027f, 
    1.07483077f, -0.21101987f, -0.62683523f, -0.07505031f, 0.02607263f, -0.13272983f, -0.04028118f, -0.07372712f, 
    -0.04806710f, 0.12856553f, 0.11967881f, -0.03383927f, -0.66268635f, -0.39878118f, -0.31722382f, -0.23495373f, 
    0.24806902f, -0.10619716f, 0.10662352f, 0.16075835f, -0.06586920f, 0.02781443f, -0.05288411f, 0.05305305f, 
    0.19300325f, -0.07371128f, -0.21592188f, 0.08116055f, 0.14807783f, -0.06540136f, -0.14029181f, 0.34674197f, 
    -0.33341205f, -0.09949489f, -0.19368386f, -0.31315711f, 0.19745554f, 0.44209886f, -0.46847424f, 0.04352802f, 
    0.09006666f, 0.02412814f, 0.05645643f, -0.14131118f, 0.09062654f, 0.16413698f, 0.10344862f, 0.10875407f, 
    -0.24193294f, 0.00896452f, 0.17874083f, 0.33344045f, 0.19321574f, 0.16739364f, 0.09484800f, -0.00138664f, 
    0.29090524f, 0.09090012f, 0.25764447f, 0.06251932f, -0.16131124f, 0.29556069f, 0.07523512f, 0.28722176f, 
    0.24286927f, -0.16799958f, 0.02959137f, -0.03215525f, 0.05092790f, -0.05257584f, 0.13987353f, -0.02546808f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.21251380f, -0.01981830f, -0.12352598f, 0.04143529f, 0.07950017f, 0.09269666f, -0.02794062f, -0.12885104f, 
    -0.12030692f, 0.01840674f, 0.30362773f, 0.02748281f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
