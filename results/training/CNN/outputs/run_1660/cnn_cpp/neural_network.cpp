#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.52297187f, -0.42279086f, -0.23219782f, -0.01405477f, 0.02000730f, -0.00193236f, 0.66288841f, -0.76978117f, 
    -0.49130026f, 0.11808801f, -0.16020198f, -0.12348921f, -0.70523733f, -0.85993469f, -1.02825844f, 0.57248145f, 
    -0.17943729f, 0.14690183f, -0.16817603f, 0.47780800f, -0.89440250f, -0.01352358f, -0.26967633f, -0.30653909f, 
    -0.46109310f, -0.37695330f, -0.90300256f, -0.46222788f, -1.03582537f, -0.53280813f, -0.15876020f, 0.36363918f, 
    0.43763822f, -0.66324341f, -0.96529257f, 0.68741298f, -0.96375918f, -0.13016810f, -0.58981794f, 0.15710880f, 
    -0.42296788f, -0.83604789f, -0.40454641f, -0.54836434f, -0.25400457f, 0.46600890f, 0.85142964f, -0.12483869f, 
    -0.65044874f, 0.34540185f, -0.54053551f, 0.05854330f, 0.22113854f, 0.15490752f, -0.73017669f, -0.89599222f, 
    -0.08158401f, -0.71234190f, -0.76126963f, -0.72166985f, -0.00142999f, -0.10554919f, -0.50869215f, -0.32414940f, 
    0.16406439f, 0.18634900f, -0.61053181f, -0.31371132f, -0.00948924f, 0.31798732f, 0.49733213f, 0.19714715f, 
    0.26378134f, 0.24634254f, 0.25537255f, 0.59318578f, 0.76148874f, 0.23294841f, -0.19369423f, -0.01574376f, 
    -0.47385737f, -0.94367260f, -0.62712944f, 0.19740507f, 0.09926533f, 0.55739689f, -0.33712196f, -0.03126585f, 
    0.41669887f, 0.12850903f, 0.44182950f, 0.72146446f, -0.67229599f, -0.08637724f, 0.07377765f, -0.18680379f, 
    -0.64710057f, 0.44779268f, 0.15300380f, -0.87693852f, -0.90878338f, -0.04375681f, -0.05204423f, -0.26731297f, 
    -0.66579467f, 0.49843544f, -0.10404256f, 0.38611823f, -0.71068138f, -0.85413122f, -0.83407313f, 0.45901045f, 
    0.56908607f, 0.09711541f, 0.22664525f, 0.27228096f, 0.25325012f, -0.26846561f, 0.54593796f, -0.20130835f, 
    -0.44225597f, 0.53291392f, -0.20029151f, 0.68381262f, -0.27506703f, -0.48200488f, 0.26653659f, 0.20369408f, 
    0.27077532f, 0.10125015f, 0.03681102f, -0.35293999f, -0.21691649f, 0.07372998f, 0.51060724f, -0.11385354f, 
    -0.41931108f, 0.28083792f, -0.27533653f, 0.02736226f, -0.58736712f, 0.13019298f, 0.55347210f, 0.30670065f, 
    -0.31522563f, 0.08649454f, -0.58397698f, 0.55123252f, -0.11789974f, -0.61676973f, 0.47276291f, -0.05403210f, 
    0.35033122f, -0.37794116f, 1.17477500f, 0.71377081f, -0.98556244f, -0.18372265f, 0.01839819f, -0.01470655f, 
    0.10613402f, -0.08947433f, -0.16439120f, -0.64729685f, -0.82587504f, -0.09045060f, -0.31619471f, -0.10095060f, 
    0.48841611f, -0.33725658f, -0.40650424f, 0.60300702f, 0.32849547f, 0.36005172f, 0.41771579f, -0.37750050f, 
    0.49273837f, -0.02307442f, -0.36115664f, -0.27512157f, 0.89726812f, -0.49512836f, -0.41278303f, -0.64761662f, 
    0.79833794f, -0.73286098f, -0.29206282f, 0.26157877f, -0.32609567f, 0.67081696f, -0.01722399f, -0.30423391f, 
    0.20286494f, 0.32024568f, -0.44869620f, 0.33658683f, -0.06582384f, -0.16077238f, 0.22514851f, -1.08260310f, 
    -0.91401941f, 1.05745494f, 1.02451253f, 0.14782901f, -0.30659658f, -0.37204373f, -0.14669676f, 0.08730159f, 
    1.17016780f, -1.22102034f, -0.61884171f, -0.56047493f, 0.04024016f, -0.11489467f, -0.22454385f, 0.48029765f, 
    -1.46688294f, 1.17210555f, -0.58568263f, 0.71850413f, -0.13800327f, -0.14787143f, -0.16618238f, 0.07909246f, 
    0.16059326f, -0.72764814f, 0.49654490f, -0.54049253f, -0.53956038f, 0.26255885f, 0.39577836f, -0.02905063f, 
    0.38175923f, 0.10358433f, 0.62390018f, -0.37766847f, 0.18816064f, -0.59980261f, -0.06831353f, 0.43729270f, 
    -0.24669585f, 0.27519098f, 0.15720941f, 1.43554056f, -1.01255965f, -1.05738211f, 0.28834856f, 0.70020998f, 
    -0.56228673f, 0.27831802f, -0.08279390f, -0.02728576f, -1.47979009f, 0.13435386f, 1.11294258f, -0.06760517f, 
    0.74595755f, -0.42667955f, -0.04973073f, -0.00047756f, -0.06751145f, 0.60196668f, -0.68771458f, 0.60025334f, 
    -0.64089298f, -0.84185195f, -0.69756657f, -0.34502399f, -0.57266957f, -0.53624439f, 0.80737436f, -0.68480176f, 
    -0.52086478f, 0.38445961f, -0.05840479f, -0.42468029f, -0.44590124f, 0.21936853f, 0.61912805f, 0.61301172f, 
    0.88853544f, -0.57156479f, -0.35970086f, -0.99819034f, -0.88152897f, -0.13393053f, -0.49747545f, -0.31331417f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.27041373f, 0.25809965f, -0.09879071f, 0.26902625f, -0.32477733f, 0.19099197f, -0.26959452f, 0.13355495f, 
    -0.20497158f, 0.20685427f, 0.22388738f, 0.14942016f, 0.17300683f, 0.22309767f, -0.14627038f, 0.14441806f, 
    0.26600924f, 0.42535305f, -0.07766506f, -0.26157758f, 0.07382278f, 0.38180241f, 0.06321888f, 0.07478443f, 
    -0.05366601f, 0.32693961f, 0.35075778f, 0.26827598f, 0.06355982f, -0.23299989f, 0.26829982f, -0.12521955f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.29353368f, 0.06170163f, 0.05068974f, -0.28902489f, -0.10207445f, 0.09077857f, 0.10048781f, -0.15384430f, 
    0.03083571f, -0.03437029f, 0.03308810f, 0.00325231f, -0.06071123f, -0.02434735f, 0.12428830f, -0.02297343f, 
    -0.05173794f, -0.14105336f, -0.01951794f, -0.01891952f, 0.23980072f, 0.30941054f, 0.05848257f, -0.39501771f, 
    -0.21049571f, 0.03828740f, 0.08768054f, -0.25314385f, -0.03481563f, 0.07003156f, 0.03255461f, -0.00946452f, 
    0.04636812f, -0.00497121f, -0.05003977f, -0.02267397f, -0.05419232f, 0.01868243f, 0.08255891f, -0.03354106f, 
    0.10859206f, 0.24946550f, 0.19386242f, -0.11816563f, -0.23657453f, -0.18401556f, -0.01197527f, -0.16355880f, 
    -0.15232417f, 0.02519551f, -0.04920207f, -0.00047480f, -0.05201944f, -0.04026076f, -0.01149158f, 0.04542491f, 
    0.03780029f, 0.08816382f, -0.08634628f, 0.17837200f, 0.22983414f, 0.10516552f, 0.14247210f, -0.10684771f, 
    -0.04708897f, 0.12339302f, 0.12016523f, 0.17342107f, -0.11156485f, -0.01773942f, -0.02775097f, 0.01276586f, 
    0.01229429f, -0.02862442f, 0.01889382f, 0.00448601f, 0.06868284f, -0.03432969f, -0.00505704f, -0.09287457f, 
    0.35600904f, 0.33173844f, 0.06286226f, -0.20756660f, 0.04819847f, 0.07103408f, 0.26759523f, 0.12464064f, 
    0.03873981f, 0.09303976f, -0.02896380f, -0.01994350f, -0.00442178f, -0.06216289f, 0.01037475f, -0.10875528f, 
    -0.15639472f, -0.05174422f, -0.10165900f, 0.09621655f, -0.15752031f, -0.10657576f, -0.19753626f, 0.02623479f, 
    -0.11105032f, 0.05810735f, -0.07732194f, -0.18591094f, 0.01582935f, 0.03158053f, 0.00482190f, 0.05141433f, 
    0.00109036f, -0.01578685f, -0.04790606f, -0.04581596f, 0.01349166f, -0.25212845f, -0.17504363f, -0.10918688f, 
    0.50055146f, 0.32522905f, 0.13883264f, -0.42495003f, 0.00731944f, 0.20030861f, 0.23949815f, 0.26841033f, 
    0.00430238f, 0.08374831f, 0.00895746f, -0.03665673f, -0.04881486f, -0.05595179f, -0.07060906f, -0.03756132f, 
    -0.06413811f, -0.18358587f, 0.09753022f, 0.02807048f, 0.09834339f, 0.10831469f, 0.12612794f, -0.02820172f, 
    -0.03562498f, -0.07516880f, 0.01711787f, -0.03730670f, 0.01400532f, -0.03200911f, 0.18791185f, 0.17249304f, 
    -0.06060470f, -0.02238331f, -0.01522721f, 0.00471053f, -0.07306782f, -0.01881352f, -0.07329486f, -0.01535268f, 
    -0.02218748f, -0.09514664f, -0.19728769f, -0.04990702f, -0.07042907f, 0.02769454f, 0.06459372f, 0.03230190f, 
    0.10573985f, 0.05462789f, 0.13354984f, -0.00730571f, 0.03687401f, 0.08555540f, 0.08350097f, -0.08232015f, 
    -0.04527175f, 0.09548039f, 0.00297008f, 0.03731203f, 0.38490990f, 0.29224786f, -0.09396445f, -0.16653325f, 
    -0.00959354f, 0.03415005f, 0.05607232f, 0.11144372f, -0.09815446f, -0.05281202f, -0.08627108f, -0.18875772f, 
    -0.06328582f, 0.01360241f, -0.04386459f, -0.02069419f, 0.06696386f, -0.02325501f, -0.00489949f, 0.00070413f, 
    -0.61989093f, -0.46888334f, -0.19796164f, 0.11163235f, -0.71506810f, 0.10746606f, -0.03396720f, -0.12461007f, 
    -0.09514627f, 0.03699630f, -0.03204232f, -0.00845514f, -0.15632762f, -0.05596578f, 0.08078197f, -0.17212728f, 
    0.04144426f, -0.31283450f, -0.09700548f, -0.19568208f, 0.40412623f, 0.36708227f, 0.01646513f, -0.49063408f, 
    -0.15410310f, 0.00240519f, 0.05124075f, 0.11195798f, 0.02874528f, -0.05559511f, 0.10154316f, -0.11018022f, 
    -0.04589961f, 0.02197658f, 0.06926551f, -0.00138212f, -0.02300206f, -0.05938150f, 0.05528833f, -0.00931749f, 
    0.30394366f, 0.27129823f, -0.29193687f, 0.01674084f, 0.12764822f, 0.13883181f, 0.11183112f, 0.13100801f, 
    -0.10682902f, -0.26975414f, -0.02774031f, -0.01900704f, -0.05002481f, 0.00418273f, 0.01444241f, 0.00626021f, 
    0.08782355f, 0.02445344f, 0.00157907f, 0.06590141f, -0.07154205f, -0.21418267f, 0.22460429f, -0.00435354f, 
    -0.20225923f, -0.13439246f, 0.07516441f, -0.23563202f, 0.01543867f, -0.16243531f, -0.09484799f, -0.04195625f, 
    -0.04625723f, 0.01040241f, -0.00291689f, -0.24642293f, -0.06123072f, -0.27224380f, -0.14350380f, -0.14505142f, 
    -0.01151528f, 0.00678249f, -0.06052827f, 0.00820023f, -0.01552842f, 0.09285937f, -0.04901805f, 0.00103260f, 
    0.10671463f, 0.01282084f, 0.04464822f, 0.08947511f, 0.00693358f, 0.02475230f, -0.01579733f, -0.18820141f, 
    -0.12178724f, -0.08767925f, -0.00084661f, -0.03145511f, 0.20861438f, 0.19734912f, 0.04541629f, -0.05687692f, 
    -0.02501369f, -0.10560126f, 0.01928858f, 0.08903129f, -0.23110241f, -0.04426243f, 0.12661925f, -0.03626560f, 
    -0.00213806f, -0.03184551f, 0.00182074f, -0.03583254f, -0.01010830f, -0.13742061f, -0.08344844f, 0.01433391f, 
    0.16910389f, 0.12024602f, -0.21410045f, -0.00969318f, -0.06423759f, -0.01311584f, 0.04157798f, 0.02758479f, 
    -0.13519377f, -0.19664344f, -0.02918345f, -0.21542050f, -0.11978025f, -0.04359103f, -0.00096921f, -0.13550274f, 
    -0.07662486f, -0.11321677f, 0.06321763f, -0.05481342f, -0.81447595f, -0.15266038f, 0.20313810f, 0.02248597f, 
    -0.12473266f, -0.02262363f, -0.17620695f, -0.08371008f, -0.01048971f, -0.03495965f, 0.06067223f, 0.03864107f, 
    -0.02572442f, 0.04423548f, 0.02412565f, -0.01007219f, 0.09910241f, -0.01405099f, -0.29599413f, -0.06869792f, 
    0.34402412f, 0.18983121f, -0.00014486f, -0.27322862f, -0.08596011f, 0.24263535f, 0.14101906f, 0.07223441f, 
    -0.06265426f, 0.00813889f, 0.04051084f, 0.02565945f, 0.01312955f, 0.00957259f, 0.08782930f, -0.05243729f, 
    -0.02680263f, -0.04928877f, -0.02188891f, 0.09292154f, -0.06234653f, -0.03483320f, -0.07113127f, -0.07282981f, 
    -0.05777197f, 0.03044034f, 0.08047616f, 0.08084053f, 0.06157003f, 0.04873569f, 0.07800706f, 0.10873705f, 
    -0.00556192f, 0.04980517f, 0.10065810f, -0.05466755f, -0.16934156f, -0.11524802f, 0.06505403f, -0.03685667f, 
    0.02804953f, 0.17243220f, 0.06581897f, -0.18871817f, -0.23882090f, 0.05427898f, -0.10521357f, 0.06337898f, 
    -0.14893617f, 0.09655444f, -0.13663077f, 0.01721901f, -0.04189097f, -0.03866380f, -0.08682795f, -0.16920277f, 
    -0.14053048f, -0.11846301f, -0.00092119f, 0.24432655f, -0.20834106f, -0.17629513f, -0.17294809f, 0.16184266f, 
    -0.04685123f, -0.12700288f, -0.02744812f, 0.01730471f, 0.00786139f, 0.05782185f, -0.15966925f, 0.05181822f, 
    -0.04771636f, -0.06545651f, -0.05429969f, -0.14167489f, -0.11733932f, -0.06434497f, -0.11219098f, -0.01392815f, 
    0.43592227f, -0.38454607f, -1.01293564f, 0.06769910f, -0.03124041f, 0.20788200f, 0.05361873f, 0.06465609f, 
    -0.17092811f, 0.10483395f, 0.10491160f, 0.10179999f, -0.09388630f, 0.01732358f, 0.06966822f, 0.02538611f, 
    0.11694000f, 0.05988093f, 0.02196237f, 0.02382534f, 0.01829237f, 0.25880095f, 0.06534716f, -0.14592436f, 
    -0.60855377f, 0.09727320f, -0.16997004f, 0.08114785f, -0.07627212f, 0.05110258f, -0.02685524f, -0.06122436f, 
    -0.01913147f, 0.09701647f, 0.09462421f, -0.07209918f, -0.01818604f, 0.02057982f, -0.19576795f, -0.10453934f, 
    0.01579095f, 0.14956607f, -0.35296965f, -0.16487043f, 0.10599870f, -0.14948314f, 0.16154927f, 0.07894710f, 
    -0.08768138f, -0.11072006f, -0.07121783f, -0.04778604f, 0.10181449f, 0.02665217f, 0.14430763f, -0.11181543f, 
    0.05857284f, 0.02228105f, -0.15493277f, -0.02120553f, 0.05134968f, 0.00739703f, 0.08346366f, 0.01543648f, 
    -0.02574026f, 0.00113582f, -0.02557613f, 0.02757724f, -0.01578098f, -0.20006487f, -0.07315778f, -0.10493678f, 
    -0.02490312f, -0.02007820f, 0.02595550f, -0.04486960f, 0.03283180f, -0.06308617f, -0.06923982f, -0.00968402f, 
    -0.23649815f, -0.13766626f, 0.04075376f, -0.01249314f, 0.01138689f, -0.18566720f, 0.00479785f, -0.06196634f, 
    -0.05908421f, -0.02670713f, -0.12084553f, 0.03269624f, -0.08656308f, 0.01943554f, 0.00934292f, -0.04922598f, 
    -0.07131811f, -0.06939691f, -0.12855251f, -0.08766485f, 0.01972743f, 0.07173624f, -0.91155189f, 0.19122888f, 
    -0.00662314f, 0.03979074f, -0.02804923f, -0.06522699f, -0.02447934f, -0.01801123f, -0.10187224f, 0.04688341f, 
    -0.30304992f, 0.02264827f, -0.07610475f, -0.07860598f, 0.05378739f, -0.11227006f, -0.06158652f, 0.00275693f, 
    0.29064342f, -0.00441340f, 0.12087470f, -0.60982829f, 0.06022659f, -0.49920395f, -0.07645220f, 0.23488531f, 
    0.12995227f, -0.13247880f, -0.06497177f, -0.20340814f, -0.26667380f, -0.10935289f, -0.21916150f, 0.00527687f, 
    -0.07758405f, -0.00580163f, -0.08713928f, 0.09438291f, 0.07530770f, 0.32974592f, 0.16926283f, -0.53950655f, 
    0.13716988f, 0.01607800f, -0.13890427f, 0.06802931f, -0.15567489f, 0.04039161f, -0.02935820f, -0.04230234f, 
    -0.01196398f, 0.06644590f, 0.02614938f, 0.00966444f, -0.07427062f, 0.11818241f, 0.10220256f, 0.11921656f, 
    0.04118133f, 0.10806866f, -0.16431467f, 0.04686873f, -0.06031487f, 0.02311660f, 0.10757263f, -0.09630169f, 
    -0.23929009f, -0.13905181f, -0.00160386f, -0.17497393f, -0.00392783f, 0.01385816f, 0.03380303f, -0.06885875f, 
    0.04799543f, -0.17445400f, -0.03570121f, -0.05200234f, -0.17459658f, 0.36759833f, 0.05805103f, -0.04573002f, 
    -0.18446967f, -0.03798128f, -0.10566418f, -0.06732942f, 0.09388477f, 0.07895468f, -0.01113321f, -0.06929706f, 
    0.01674440f, 0.04631770f, 0.07197680f, 0.07198464f, 0.04529099f, 0.14595945f, 0.06010590f, 0.04907336f, 
    -0.12864763f, 0.13080075f, -0.19819331f, -0.25789446f, 0.01997041f, 0.14029473f, 0.01745967f, 0.25177726f, 
    0.14868087f, 0.03162506f, 0.02300175f, 0.01822463f, 0.01885742f, -0.11272889f, -0.02283239f, 0.15440762f, 
    0.08866662f, 0.06462187f, -0.07506290f, -0.03932975f, -0.21471079f, 0.07164660f, -0.13587162f, -0.03126888f, 
    -0.02531441f, -0.01983077f, -0.21703468f, -0.10334002f, -0.00563754f, -0.05926965f, 0.01282488f, 0.03310996f, 
    0.02228216f, 0.11690232f, 0.13109396f, 0.02927275f, -0.03333268f, 0.04860912f, -0.00649118f, -0.03013434f, 
    -0.31145817f, 0.23388603f, 0.09737243f, 0.03613807f, -0.21781866f, 0.18143974f, 0.08449792f, -0.01679990f, 
    -0.02531905f, -0.08588342f, 0.03274130f, -0.00275855f, -0.05356964f, -0.01420660f, 0.08335441f, -0.35345584f, 
    -0.35037309f, -0.20344050f, -0.01730080f, -0.07727114f, -0.35547009f, 0.05802527f, 0.16581298f, 0.03398680f, 
    -0.12753691f, 0.02194142f, 0.00927308f, 0.30840492f, -0.01120772f, 0.04039652f, 0.05181596f, -0.05376279f, 
    0.00924848f, -0.15615571f, -0.11162734f, 0.20015062f, 0.11698646f, 0.02896589f, -0.05289446f, -0.05571912f, 
    0.15663414f, 0.28706867f, 0.18031812f, 0.42989409f, 0.08392643f, 0.28521001f, -0.10279315f, -0.07033233f, 
    0.05898836f, 0.12062636f, 0.04607874f, 0.03464561f, 0.04115006f, -0.11482038f, -0.03227217f, -0.07578277f, 
    0.06668308f, 0.02141991f, -0.13231237f, 0.12258177f, 0.13123229f, 0.02170598f, 0.02791042f, -0.08329858f, 
    -0.09565541f, -0.16682832f, -0.11014324f, -0.27684385f, 0.08874007f, -0.03197013f, 0.05948950f, -0.10149900f, 
    0.04975649f, 0.02650522f, 0.04141837f, -0.05185888f, 0.06436298f, -0.13610549f, 0.08236961f, 0.04943345f, 
    -0.11364441f, 0.22958057f, 0.08983301f, 0.19435598f, 0.38249961f, -0.09064852f, -0.07647257f, -0.08398709f, 
    0.13882384f, 0.05751827f, -0.00303244f, 0.00081524f, 0.01742851f, -0.02441821f, 0.06068296f, 0.00727233f, 
    0.05836466f, 0.16798818f, -0.14373493f, 0.02480012f, -0.16314960f, -0.06368124f, -0.05393182f, -0.03642958f, 
    0.03264357f, -0.00368685f, 0.01582272f, -0.07291029f, 0.08269247f, 0.17125949f, 0.01565022f, 0.14740898f, 
    0.01611958f, 0.13984965f, 0.04558899f, -0.05335763f, -0.02969547f, -0.05310363f, 0.09736962f, 0.01449684f, 
    0.25801855f, 0.05650765f, 0.12775993f, 0.25061819f, 0.14788751f, -0.05660279f, -0.06468160f, 0.00611934f, 
    -0.04854472f, 0.01146963f, -0.03059164f, 0.02890486f, -0.04004090f, -0.05529015f, 0.08383521f, -0.06908411f, 
    -0.15536876f, -0.17656350f, -0.03802581f, -0.12051116f, -0.13245602f, -0.09818966f, -0.05480727f, -0.04780536f, 
    0.05896510f, -0.00202713f, 0.17244945f, 0.26012000f, 0.15685618f, 0.09832978f, -0.00073406f, 0.00813500f, 
    0.04783960f, -0.00408021f, -0.07230053f, -0.02887059f, -0.04287829f, -0.00063240f, -0.01151281f, -0.02693530f, 
    0.22600842f, -0.13059430f, -0.08593128f, -0.00711990f, -0.24709612f, 0.10285506f, -0.07872909f, -0.11500687f, 
    0.00055409f, -0.00814401f, -0.07409611f, 0.07065473f, 0.07965898f, 0.06820782f, -0.11243109f, -0.11451109f, 
    0.24425121f, 0.01445445f, 0.19638091f, 0.14597951f, -0.32836640f, 0.12385421f, -0.06442091f, 0.18498820f, 
    0.09954952f, -0.03603381f, 0.01197403f, 0.18608338f, 0.07047915f, -0.01427702f, -0.07254773f, -0.03050377f, 
    0.01285752f, -0.02131514f, -0.06170159f, -0.01098774f, 0.01079137f, 0.03443358f, -0.09654725f, -0.02197433f, 
    0.12761812f, -0.22641501f, -0.19514632f, 0.00538030f, -0.07714522f, -0.01613815f, 0.07760105f, 0.09803659f, 
    -0.04615981f, -0.21756862f, -0.06741690f, 0.02746687f, 0.00083459f, 0.02104875f, 0.01159870f, 0.00447751f, 
    -0.00707242f, -0.05095203f, 0.02136994f, -0.01995455f, 0.04104721f, -0.21281733f, 0.27617642f, -0.30021322f, 
    0.04395716f, -0.01495488f, -0.07422315f, -0.10425154f, -0.22398934f, 0.25107011f, 0.02882157f, -0.02485012f, 
    -0.01577884f, -0.00676139f, 0.03380322f, 0.19981544f, -0.02665130f, -0.00500920f, 0.15624534f, -0.12929215f, 
    0.14711504f, 0.05884431f, 0.06551675f, 0.04158735f, 0.10709366f, 0.00208673f, -0.06831445f, -0.07769295f, 
    -0.04217662f, -0.07839663f, -0.02628801f, 0.02534205f, -0.00760267f, 0.00426091f, -0.03465553f, 0.04775277f, 
    0.09688222f, -0.06486308f, -0.01086318f, -0.05545498f, -0.21635856f, 0.02023507f, -0.09040909f, -0.03766683f, 
    0.00500644f, -0.03959625f, 0.01147442f, 0.08785194f, 0.09260304f, 0.02375842f, 0.02270461f, 0.07845411f, 
    0.01589052f, 0.07140088f, -0.00943237f, -0.05407927f, -0.02075381f, 0.00245230f, 0.01382007f, 0.02858982f, 
    -0.13863553f, -0.09559911f, -0.16854133f, 0.01567815f, -0.00672327f, 0.05562085f, 0.00077237f, 0.03728428f, 
    0.22190700f, -0.12631315f, -0.15673886f, 0.06632891f, -0.03847264f, 0.05543386f, -0.06151566f, -0.01066348f, 
    0.03986953f, 0.04711223f, -0.00178630f, 0.00376939f, 0.38764930f, -0.26262939f, 0.19764698f, -0.17107201f, 
    0.11850880f, 0.00898184f, -0.01489389f, -0.13409145f, 0.01867171f, 0.01056748f, 0.01493857f, -0.08337566f, 
    0.00501245f, -0.03081343f, 0.03378201f, 0.04237032f, 0.23508602f, -0.07737116f, 0.20340578f, 0.05522838f, 
    -0.08965348f, 0.25789857f, 0.08675335f, 0.04604021f, -0.02659081f, 0.09429599f, -0.02702081f, 0.14403532f, 
    -0.04746356f, 0.02530979f, -0.04317996f, 0.01032385f, -0.00008949f, 0.01197155f, 0.02335491f, 0.03633691f, 
    0.02780322f, -0.01719129f, -0.22561462f, 0.00936777f, 0.38339096f, 0.20610197f, 0.03230325f, 0.17918950f, 
    0.19631097f, -0.08047732f, -0.07478081f, -0.01088941f, -0.06273501f, -0.07309233f, -0.06836993f, -0.02393319f, 
    -0.04233038f, -0.01698422f, 0.03064346f, 0.02083913f, 0.06582331f, 0.17596279f, 0.04117093f, -0.07750205f, 
    0.20669404f, 0.07950021f, -0.29444599f, -0.09223056f, -0.20501579f, -0.23567463f, -0.02342942f, -0.18193862f, 
    0.16746794f, 0.20497264f, 0.01911619f, 0.02198886f, -0.07037137f, 0.00424428f, -0.07165950f, 0.03458127f, 
    -0.20667432f, -0.18345508f, 0.02545069f, 0.16871338f, 0.27616930f, 0.12014911f, -0.00272759f, 0.12055478f, 
    -0.08452830f, -0.06958419f, -0.00758092f, -0.04158004f, 0.05909719f, -0.10193923f, 0.03608810f, 0.07742936f, 
    0.00076668f, 0.02283226f, -0.00130444f, 0.11722460f, -0.05628556f, 0.04564994f, 0.12002429f, -0.06851481f, 
    0.95610636f, -0.45109281f, -0.00825053f, 0.10482741f, -0.24076833f, 0.02636666f, -0.10128409f, -0.02784212f, 
    0.01339745f, -0.19558421f, 0.24387385f, -0.36295143f, -0.02319866f, -0.28686455f, -0.18453169f, 0.10265694f, 
    -0.08960994f, -0.18811685f, 0.04548646f, -0.05516875f, -0.52248633f, -0.42228684f, 0.20397142f, 0.16234195f, 
    -0.44683576f, 0.14675617f, 0.03627489f, -0.29996750f, -0.11489633f, 0.19604515f, -0.10910518f, 0.11227062f, 
    -0.01597296f, 0.11192445f, -0.04495156f, -0.04470827f, 0.02651783f, -0.10493103f, -0.03309111f, -0.02071049f, 
    -1.04248285f, 0.13538462f, 0.09243187f, 0.18571568f, 0.20094816f, 0.17732763f, 0.06696738f, 0.01157215f, 
    -0.03190426f, -0.21919315f, -0.13526762f, -0.04003550f, -0.05298283f, -0.06342129f, -0.06239809f, 0.01260200f, 
    0.06639057f, -0.17569338f, -0.02880118f, -0.03989340f, -0.39263242f, -0.46605062f, -0.02287167f, -0.08820160f, 
    -0.03308832f, -0.00609664f, 0.09245031f, 0.03396439f, 0.02613470f, 0.06666317f, 0.17329274f, 0.12894693f, 
    -0.06828349f, 0.09115937f, -0.02415754f, -0.07262339f, 0.00289326f, -0.02291799f, 0.07558752f, 0.07225727f, 
    0.14406732f, 0.06619155f, 0.09057545f, -0.01456407f, 0.07668526f, -0.03581786f, 0.06388265f, 0.04253841f, 
    -0.08208081f, 0.11441169f, -0.02189481f, -0.05322298f, 0.11489463f, 0.18611565f, -0.04829039f, 0.03624683f, 
    0.06665114f, 0.07896207f, 0.01194214f, 0.02546312f, 0.92050302f, -0.02064877f, -0.43007249f, 0.03555492f, 
    -0.37739155f, -0.04511052f, 0.06992454f, 0.02104462f, 0.00316453f, -0.05456366f, 0.13438345f, 0.05730593f, 
    0.19621648f, -0.01466522f, 0.03672175f, -0.00990011f, -0.06552371f, -0.08285201f, -0.02883350f, 0.05886368f, 
    -0.21648085f, -0.58245826f, 0.17680307f, -0.45277590f, 0.47605827f, 0.07615384f, 0.19249122f, 0.06033464f, 
    0.15291221f, 0.01386219f, 0.04553979f, -0.00952914f, 0.01328453f, -0.00720584f, -0.03845046f, 0.08963457f, 
    -0.09822406f, 0.15272382f, 0.06028238f, -0.39390850f, -0.27387643f, 0.02999490f, -0.61249638f, -0.40030181f, 
    -0.22009872f, -0.02185448f, -0.05639350f, -0.31414899f, -0.06323493f, -0.05964579f, -0.05994181f, 0.00533742f, 
    -0.00112050f, 0.02507123f, -0.02002432f, -0.07563090f, -0.16663706f, -0.35191640f, -0.35525736f, -0.38541877f, 
    0.41075990f, -0.14399466f, -0.27021399f, 0.09796236f, -0.26370066f, 0.19230981f, 0.18583047f, 0.16258654f, 
    -0.13492204f, -0.02754449f, 0.04355094f, -0.00031638f, 0.09892271f, 0.05876653f, -0.05588587f, -0.06830662f, 
    0.11880193f, 0.02727418f, 0.12026197f, 0.13576980f, -0.26901293f, 0.01569598f, -0.24897519f, -0.24752811f, 
    -0.70643789f, -0.08018323f, -0.17784545f, -0.12201553f, -0.20613539f, -0.02355177f, -0.07656227f, 0.01009376f, 
    -0.02312839f, 0.05166350f, -0.00474849f, -0.05776008f, 0.03195304f, -0.23775069f, -0.06078536f, -0.03412849f, 
    -0.10044018f, 0.15900733f, 0.17239475f, 0.12153389f, 0.38208103f, 0.04845731f, 0.07064473f, -0.01697896f, 
    0.19367783f, -0.13538350f, 0.00251693f, 0.04942194f, 0.12357454f, 0.09226314f, 0.02319312f, 0.05270812f, 
    -0.01729679f, -0.05869846f, 0.00641993f, 0.11148500f, -0.57099771f, -0.52402407f, -0.28758973f, -0.27705759f, 
    -0.49577078f, 0.19279057f, 0.20199212f, -0.03184224f, 0.00914819f, -0.08848970f, 0.00533882f, 0.05304611f, 
    -0.04301473f, 0.03000109f, -0.11865380f, 0.00664483f, 0.00811171f, 0.00764147f, -0.08523549f, 0.12215793f, 
    0.13011801f, -0.36315355f, 0.09411782f, 0.24708337f, -0.17700517f, 0.04006781f, 0.04157924f, 0.07052498f, 
    -0.01633263f, 0.08028448f, -0.05890632f, -0.01393170f, -0.03028311f, -0.02904964f, -0.02998818f, 0.23265032f, 
    0.09930073f, 0.15171997f, 0.14860860f, 0.16763276f, 0.13971367f, 0.20749621f, 0.32868892f, 0.33444026f, 
    0.39003092f, -0.19216466f, -0.01566250f, -0.02315634f, -0.14407547f, 0.03001804f, 0.01705552f, 0.00918925f, 
    0.06861532f, -0.09513332f, 0.10810798f, -0.03749898f, 0.04188735f, 0.04727058f, -0.03163868f, -0.08349356f, 
    -0.40044853f, -0.76413268f, -0.13327788f, 0.50018328f, -0.35692084f, -0.09559613f, 0.01729483f, -0.07822850f, 
    0.10512756f, -0.09910547f, -0.04326230f, -0.04660728f, -0.02231663f, -0.03750725f, -0.03336195f, -0.04107080f, 
    0.03774256f, -0.08973406f, -0.05830570f, 0.08522887f, -0.10341232f, -0.21484269f, 0.20498487f, -0.16157568f, 
    0.18537265f, 0.05311961f, -0.12758175f, -0.07957619f, -0.09738776f, 0.07620423f, 0.03365764f, -0.00958903f, 
    0.04608865f, 0.01977911f, -0.01274679f, 0.10149181f, -0.21103439f, -0.33758241f, 0.03279388f, 0.01331137f, 
    -0.33811322f, -0.66335994f, -0.26622832f, 0.00575954f, -0.60034657f, -0.07008511f, 0.12202098f, 0.00813866f, 
    0.21779308f, 0.00177213f, -0.06732297f, -0.01995129f, -0.01027974f, 0.01528471f, -0.09181618f, -0.07415728f, 
    0.00304389f, 0.00043601f, -0.24354313f, -0.01001162f, 0.01727900f, 0.02387116f, -0.06408776f, 0.00875242f, 
    0.08765879f, -0.01466315f, -0.01516816f, -0.17933102f, -0.03163561f, -0.12010468f, -0.01439137f, -0.15840958f, 
    -0.03606590f, 0.05210640f, -0.08095254f, 0.04556913f, -0.02057252f, 0.00655531f, -0.10712588f, -0.02304855f, 
    -0.17590640f, -0.14548931f, -0.36637905f, -0.28796595f, 0.10450007f, 0.02089172f, -0.06506872f, 0.02487932f, 
    0.05055652f, 0.00199976f, -0.08833621f, -0.05990406f, 0.10386103f, -0.02246323f, -0.07381513f, 0.05043290f, 
    0.15662195f, 0.05203200f, 0.06766129f, 0.01384094f, 0.18107589f, -0.08949902f, 0.14682092f, 0.19013181f, 
    0.07517844f, -0.02016865f, -0.05865270f, 0.02275802f, 0.07534437f, 0.00201266f, 0.06623184f, 0.07364920f, 
    0.03652575f, 0.00141589f, 0.05261481f, 0.06959680f, -0.11418184f, -0.06964125f, 0.03958345f, 0.00536142f, 
    -0.05026197f, -0.22778498f, 0.13596095f, -0.37203777f, 0.07305354f, -0.14680263f, -0.07513587f, -0.05135015f, 
    0.00696236f, 0.02610025f, -0.00639095f, 0.06601745f, -0.06876319f, 0.08552096f, 0.09750066f, 0.10764567f, 
    -0.15530078f, -0.04104814f, 0.05464505f, 0.02116098f, -0.02142357f, -0.40452480f, 0.15759200f, 0.31632915f, 
    -0.01608712f, 0.00521560f, -0.01218757f, -0.04820043f, 0.17994948f, -0.05563385f, 0.02274234f, 0.01406634f, 
    0.00761739f, -0.03102700f, 0.01468495f, -0.01636823f, 0.01386035f, -0.00200017f, -0.04905878f, -0.04200579f, 
    0.00209393f, 0.04815461f, 0.46314934f, 0.14605071f, 0.18034832f, -0.07910172f, -0.05930928f, 0.06295718f, 
    0.15598588f, -0.20611940f, 0.07249017f, -0.04027474f, 0.01317819f, -0.04965628f, 0.06508534f, 0.00115541f, 
    -0.01591435f, 0.04955899f, 0.04465371f, -0.04501346f, 0.17811762f, -0.23039083f, -0.16106828f, -0.26454344f, 
    0.21698046f, 0.07890593f, 0.02886414f, 0.00501720f, -0.20035520f, 0.02375850f, 0.05146322f, 0.09192994f, 
    -0.04842899f, 0.12347853f, -0.13233337f, 0.21388872f, -0.14853695f, -0.12043671f, 0.09011526f, 0.13855056f, 
    -0.16373713f, 0.00209214f, 0.01828125f, -0.11544813f, 0.15127526f, 0.02354191f, -0.15752962f, -0.02765137f, 
    0.03587572f, 0.09876144f, 0.02797476f, -0.05702125f, 0.07103176f, -0.14889079f, 0.02762924f, -0.08243152f, 
    -0.30381989f, -0.09512500f, -0.02413451f, -0.03994569f, 0.07690223f, -0.08879126f, -0.15654325f, 0.00202812f, 
    0.07864348f, -0.04639162f, -0.15556926f, -0.17814128f, -0.08415876f, -0.08775051f, 0.13301095f, -0.00264757f, 
    -0.02067898f, 0.00880223f, -0.04332977f, 0.02114226f, -0.02025075f, -0.03069812f, 0.05577406f, -0.06940128f, 
    0.12011845f, -0.11023100f, 0.05142936f, 0.08337339f, 0.05659795f, 0.07624183f, -0.20735468f, -0.16229658f, 
    0.14905904f, -0.20710066f, 0.09193387f, 0.23534131f, -0.00806958f, 0.01011208f, -0.03042741f, 0.05917571f, 
    0.01199820f, -0.09836064f, 0.14254405f, -0.02327090f, -0.09032223f, -0.02208046f, 0.27512035f, -0.38890067f, 
    0.04033589f, 0.02492177f, 0.09186044f, -0.06174725f, 0.04478012f, 0.08577541f, 0.01842026f, -0.01253412f, 
    0.02038385f, 0.03020468f, -0.04383165f, 0.08785795f, -0.02770629f, -0.21245711f, -0.01415811f, -0.03485459f, 
    -0.17208858f, 0.04525727f, 0.18814841f, 0.14643554f, 0.12481361f, 0.09681366f, 0.10022593f, -0.02976404f, 
    0.16343038f, -0.10409454f, -0.01057188f, 0.03224714f, 0.03510975f, 0.03592554f, -0.02210354f, -0.01650437f, 
    0.04532593f, -0.03879636f, 0.05697787f, -0.03825718f, -0.41830486f, -0.34427926f, -0.33536860f, -0.47980434f, 
    0.03835467f, -0.00379664f, -0.01277431f, 0.03082515f, 0.03442448f, 0.01621115f, 0.02845042f, 0.04246855f, 
    -0.05963021f, 0.04759469f, 0.03185593f, -0.04608971f, -0.17159808f, 0.30052626f, 0.05961642f, -0.04309969f, 
    -0.18188743f, 0.04466164f, -0.07536918f, 0.17803958f, -0.35718930f, -0.00003776f, 0.15999858f, -0.16209622f, 
    -0.03613213f, 0.16084595f, 0.05052774f, -0.05665483f, -0.04556598f, 0.02574981f, 0.01705225f, 0.02765299f, 
    0.16446590f, -0.21421942f, 0.04689257f, 0.06127166f, -0.07366497f, 0.00986964f, 0.03567354f, -0.13627486f, 
    0.07141327f, 0.06197263f, -0.06483989f, -0.04695050f, 0.04928162f, 0.06579348f, 0.02964394f, -0.01505012f, 
    -0.08084463f, 0.07116427f, -0.02196317f, -0.00346134f, -0.06056946f, -0.19421937f, 0.12131860f, -0.00584812f, 
    -0.47877795f, -0.19823131f, 1.06569982f, 0.07783855f, 0.12060626f, -0.18164848f, -0.19294676f, 0.06494083f, 
    -0.06338901f, -0.04496898f, 0.05913319f, -0.04417278f, 0.01654263f, -0.11150593f, 0.06938098f, 0.01839539f, 
    0.07135813f, 0.08040652f, 0.10580326f, -0.13956439f, -0.00805792f, -0.98295265f, 0.16854174f, -0.15982555f, 
    -0.28288585f, 0.28495455f, -0.06791812f, -0.14102794f, -0.23449573f, -0.11157863f, -0.06068335f, -0.01358909f, 
    -0.02706693f, -0.14466651f, 0.01022081f, 0.04963022f, 0.01725343f, -0.19844809f, 0.07310323f, 0.09649338f, 
    0.65017486f, -0.43758410f, -0.01488792f, 0.55870771f, -0.16485856f, 0.25766724f, -0.24004984f, -0.18959005f, 
    -0.05124220f, -0.18502922f, -0.11434986f, 0.13756324f, 0.03552422f, 0.06954714f, 0.07113049f, 0.01541705f, 
    -0.03063015f, -0.08587908f, 0.09467698f, -0.03525576f, 0.13609898f, 0.22288866f, 0.08388028f, 0.05787253f, 
    0.10750703f, -0.03521948f, 0.04972027f, -0.00957151f, -0.18996079f, -0.04163993f, 0.04338867f, -0.05492992f, 
    0.00283340f, 0.09083248f, 0.09532895f, 0.04490912f, -0.01805272f, 0.03317058f, 0.03976206f, -0.02636592f, 
    -0.16384405f, 0.14095567f, -0.07784677f, 0.04236473f, 0.11862274f, -0.17363808f, 0.03065784f, 0.00705409f, 
    -0.01716816f, 0.01471188f, 0.10910592f, 0.04570202f, -0.12508282f, 0.02845868f, -0.08564592f, 0.00929038f, 
    -0.07216330f, 0.04810326f, -0.04650356f, -0.00407659f, -0.20916936f, 0.26876453f, 0.25909707f, -0.19438091f, 
    -0.03095818f, -0.08091729f, -0.14399850f, -0.09511238f, -0.06936704f, -0.18073781f, -0.03764257f, -0.10246560f, 
    0.08304238f, -0.00396811f, -0.04376100f, 0.02568011f, 0.01561213f, -0.12765317f, 0.13868588f, -0.12588023f, 
    0.81887573f, 0.05992327f, -0.24881098f, 0.08402833f, 0.53138363f, 0.02361779f, 0.00541499f, -0.25186986f, 
    0.01296005f, 0.19539389f, -0.19133230f, 0.07911400f, 0.10606557f, -0.05599824f, -0.24338484f, 0.06422026f, 
    -0.01022833f, 0.02532010f, 0.03872756f, -0.03335098f, -0.67654145f, -0.03504444f, 0.00234371f, 0.03304854f, 
    -0.31355169f, -0.13258810f, -0.15755959f, -0.01682163f, -0.08019253f, -0.06260654f, 0.05454877f, 0.00201770f, 
    -0.01623252f, -0.01080210f, -0.02139916f, -0.13662408f, 0.03045283f, 0.20933506f, 0.05320625f, 0.03010685f, 
    -0.14479838f, 0.13984939f, -0.11679448f, 0.08116762f, -0.00651883f, 0.13053949f, -0.16787528f, -0.21378753f, 
    -0.18146530f, -0.23099029f, 0.05182829f, 0.03642847f, 0.08966021f, 0.03207752f, -0.05079411f, 0.00098646f, 
    0.09415451f, 0.01194682f, 0.17891429f, -0.06298537f, -0.38756552f, -0.45818165f, 0.60584748f, -0.20653638f, 
    -0.02905453f, -0.07414658f, 0.07596597f, -0.28228664f, -0.07901403f, -0.14572266f, 0.02581171f, -0.01916466f, 
    0.02734944f, 0.00334797f, -0.03867402f, -0.01642141f, -0.21218443f, 0.11177132f, -0.08159727f, 0.07967905f, 
    -0.07337363f, -0.03306375f, -0.00436308f, -0.21932535f, 0.16414693f, 0.02731727f, 0.03071335f, 0.02646855f, 
    -0.00797421f, 0.00222025f, 0.01946966f, 0.02101873f, 0.11433688f, -0.03470165f, 0.08246233f, -0.12354214f, 
    0.01757398f, -0.01199872f, 0.07855128f, -0.10923748f, 0.11680329f, -0.11617917f, -0.20957930f, 0.05139335f, 
    0.29930049f, 0.00773802f, 0.13367972f, 0.06780277f, 0.01108950f, 0.10307725f, 0.02178741f, -0.11249756f, 
    0.03420627f, -0.01843271f, 0.04830069f, -0.17195278f, -0.11426283f, -0.04483703f, -0.14335856f, -0.03756660f, 
    0.19172229f, -0.24806128f, -0.17141591f, -0.01548416f, 0.22218460f, 0.06249857f, 0.08455498f, -0.04268862f, 
    0.11329738f, 0.03058899f, 0.08258834f, -0.07303373f, -0.03390960f, -0.05242218f, 0.03364248f, 0.08845142f, 
    -0.06610583f, 0.07012624f, 0.05788232f, -0.05727612f, -0.13449508f, 0.24193959f, -0.22097169f, -0.03992867f, 
    0.16578273f, 0.11140435f, 0.02563826f, -0.09509668f, -0.07708123f, -0.00863301f, -0.09573622f, 0.11069543f, 
    0.01946335f, -0.02221473f, 0.12303289f, -0.10050881f, 0.04444898f, -0.10707700f, -0.03090675f, -0.07873453f, 
    0.18515341f, -0.08925141f, -0.23199289f, -0.02272752f, 0.24052148f, -0.00169944f, 0.14073487f, -0.04116908f, 
    -0.09892967f, 0.15612811f, -0.13795005f, 0.02652295f, -0.18853380f, 0.01852385f, -0.00124757f, -0.06398316f, 
    -0.05225453f, 0.06855565f, 0.08834910f, 0.00609712f, -0.83203530f, 0.05872351f, 0.50678045f, 0.30472538f, 
    0.13562061f, -0.15597042f, -0.08271593f, -0.12792300f, 0.12077513f, -0.10094704f, -0.06266361f, -0.03016295f, 
    -0.01515212f, -0.05202767f, 0.15173507f, -0.09737333f, 0.09300328f, -0.03308899f, 0.13326305f, -0.14451991f, 
    -0.14036131f, -0.04167896f, -0.21427488f, -0.04824704f, 0.24147473f, -0.00947283f, 0.07970975f, -0.03677718f, 
    0.04595552f, -0.03446771f, -0.08103965f, -0.00698390f, -0.01609552f, -0.03718187f, -0.05395600f, -0.04592799f, 
    -0.03594390f, 0.15981045f, -0.21211094f, 0.05411213f, 0.09653534f, -0.05932812f, -0.19973901f, -0.22495320f, 
    0.12370251f, 0.10345550f, -0.01435819f, 0.06178287f, 0.02283636f, 0.06725612f, 0.05908677f, -0.18796732f, 
    -0.06735899f, -0.03008897f, 0.02980740f, 0.11600564f, -0.07053107f, -0.12788138f, -0.10387842f, 0.03107613f, 
    -0.54142487f, -0.18071932f, -0.45933551f, 0.13423648f, -0.36797166f, 0.33924702f, 0.17385404f, 0.16237140f, 
    0.15333132f, 0.06533095f, -0.15347432f, -0.19930664f, 0.10815977f, -0.08775178f, -0.10776769f, -0.01518248f, 
    -0.11554275f, -0.17806590f, 0.11747058f, -0.06635974f, -0.25513768f, 0.17812967f, -0.17806451f, -0.11854570f, 
    0.33744758f, 0.10444361f, -0.05350230f, -0.03790547f, -0.00181508f, -0.08720643f, -0.20208929f, 0.04102761f, 
    -0.12838660f, 0.07407216f, 0.01429014f, -0.07821830f, -0.02669944f, -0.05459904f, 0.07607330f, 0.00050794f, 
    -0.03662995f, 0.13524812f, 0.69275957f, 0.17352605f, 0.28884834f, 0.01003722f, -0.17928009f, -0.26193118f, 
    -0.11284218f, -0.15446489f, 0.00483306f, -0.03240691f, 0.06305362f, 0.05694202f, 0.04415994f, -0.16959555f, 
    -0.04168463f, 0.20703571f, -0.03608444f, -0.00654789f, -0.13281924f, -0.08398315f, -0.22030988f, -0.11658210f, 
    0.40726787f, 0.16841432f, 0.09171498f, -0.05609709f, 0.02864565f, -0.00383359f, -0.10517201f, 0.08843797f, 
    -0.08424190f, 0.13108315f, -0.04010509f, 0.03710675f, -0.04408144f, 0.12902118f, 0.07571745f, 0.02784765f, 
    -0.37401512f, 0.12278405f, -0.19611198f, 0.00314875f, 0.39042425f, 0.21510424f, 0.02477318f, 0.03846113f, 
    -0.12786889f, -0.01368923f, -0.12096749f, 0.07064832f, 0.08526333f, 0.07311561f, 0.04486622f, -0.00166264f, 
    -0.02163205f, -0.00586134f, 0.00541478f, 0.07323746f, 0.09630185f, -0.13320898f, -0.19027127f, -0.13595013f, 
    -0.18917140f, -0.01831258f, -0.05617477f, 0.02574591f, 0.02985064f, 0.02503299f, -0.11352992f, -0.10636970f, 
    0.10138236f, -0.26646367f, -0.01447347f, -0.24447082f, -0.04159697f, -0.21361372f, 0.12378671f, 0.12512797f, 
    -0.13517210f, -0.65047878f, 0.03317783f, -0.36728656f, -0.28925285f, 0.16507502f, -0.00236706f, 0.11175455f, 
    -0.10863122f, 0.03536840f, 0.11252707f, 0.04379193f, -0.05579775f, 0.04337606f, 0.14432113f, 0.05273355f, 
    0.16772489f, 0.13541470f, -0.19293424f, -0.26595512f, -0.09564631f, -0.03415371f, -0.38285527f, -0.04856550f, 
    0.05780222f, 0.17132029f, -0.02090490f, 0.12446918f, 0.15204515f, 0.11052512f, 0.01695443f, -0.06654745f, 
    -0.11919887f, 0.03733829f, -0.11131042f, 0.15189423f, -0.08493661f, 0.13726002f, -0.19266173f, 0.03968031f, 
    -0.20518640f, -0.19340295f, -0.24749658f, -0.08070219f, 0.21173535f, 0.08218665f, 0.08564197f, 0.01136887f, 
    -0.09821570f, 0.03187853f, -0.01011259f, -0.04054784f, -0.07893310f, 0.02659195f, -0.16220248f, -0.03125357f, 
    -0.02267888f, 0.18384001f, 0.06528597f, 0.00203353f, 0.28017473f, 0.15155785f, 0.71473402f, -0.57672238f, 
    -0.01614243f, -0.40226480f, -0.06199374f, -0.06107216f, -0.06527172f, -0.12526838f, 0.00851142f, -0.09622613f, 
    0.10895596f, 0.07861412f, 0.02832106f, -0.07970177f, -0.13027574f, -0.11088771f, 0.10156547f, -0.00191259f, 
    -0.09488015f, -0.07290309f, -0.11000827f, -0.00349520f, 0.29252493f, -0.00829069f, -0.00796504f, -0.06853516f, 
    -0.05563822f, -0.02504782f, 0.02153037f, 0.02583335f, 0.07914673f, 0.09366039f, 0.09050851f, 0.01248081f, 
    -0.02764598f, 0.10154874f, -0.04072881f, 0.07930900f, -0.95868111f, -0.59014744f, -0.16758798f, -0.11887149f, 
    -0.21117637f, -0.01794393f, 0.06450406f, -0.00515453f, 0.10112065f, 0.03070605f, 0.08606465f, 0.20224847f, 
    0.15715112f, -0.01151768f, -0.12369762f, -0.11777926f, 0.05951539f, 0.25990200f, -0.36545539f, -0.28682807f, 
    -0.17685319f, 0.11672142f, -0.30716610f, 0.23995087f, 0.13198270f, -0.20942378f, -0.20694230f, 0.36640352f, 
    0.04922329f, -0.06027459f, -0.01633081f, 0.04417710f, 0.08874594f, -0.13559233f, -0.16185312f, -0.04572464f, 
    0.13809271f, -0.09093063f, 0.15833868f, -0.24325126f, -0.79700798f, -0.00722529f, -0.54712856f, 0.20857307f, 
    -0.27588782f, -0.00304919f, -0.20644709f, -0.09147633f, -0.07925796f, -0.22633098f, -0.09492214f, -0.00288338f, 
    0.06661640f, -0.07134536f, -0.07179610f, -0.00432861f, 0.07448597f, -0.03042871f, 0.04642184f, -0.15960258f, 
    -0.04541241f, 1.08416319f, -0.31798530f, 0.06461957f, 0.28541175f, 0.40832913f, 0.21907116f, 0.13444196f, 
    -0.06093797f, 0.20888555f, -0.22595157f, -0.07728425f, 0.07450224f, 0.05688247f, 0.19174537f, -0.05068634f, 
    0.01553357f, -0.01113310f, 0.03720662f, -0.00163749f, -0.03728833f, -0.10829321f, 0.07677372f, 0.29550314f, 
    0.65355164f, 0.03932155f, 0.10330293f, -0.14685167f, -0.07517973f, -0.11256056f, 0.12107198f, 0.00268905f, 
    -0.00321808f, -0.09034471f, -0.12884797f, -0.01964090f, -0.14965230f, 0.07832308f, 0.01958341f, -0.17605057f, 
    0.55690283f, -0.05249655f, -0.19571699f, 0.13187656f, 0.25713074f, 0.16072834f, 0.20352943f, -0.08758198f, 
    -0.31609651f, -0.15488540f, -0.21299748f, -0.07049886f, -0.02712383f, 0.06453365f, -0.00582815f, -0.20667875f, 
    -0.18793321f, 0.12368663f, 0.10695335f, -0.11666829f, 0.32409856f, -0.13158305f, -0.30955774f, -0.01717862f, 
    0.13466021f, 0.04592961f, -0.08496530f, 0.00985016f, -0.29164279f, -0.13594238f, -0.18405755f, -0.12417782f, 
    -0.04464017f, 0.07073433f, -0.00563098f, 0.15758167f, 0.04719472f, -0.00292907f, -0.00418175f, -0.13149899f, 
    -0.65142322f, -0.16161367f, -0.09932926f, 0.11597463f, -0.41432348f, -0.09158476f, -0.13382664f, 0.12823611f, 
    -0.08413669f, -0.27874112f, -0.06254739f, 0.04221401f, -0.14985237f, -0.15145129f, -0.02982624f, -0.06154345f, 
    -0.00161243f, 0.09841704f, 0.09105191f, -0.20881556f, -0.68171018f, 0.37295949f, -0.32981315f, 0.27450377f, 
    0.47030175f, 0.05783084f, -0.21240872f, 0.11256978f, -0.26555878f, -0.07768010f, -0.03215253f, 0.03145730f, 
    0.02231705f, 0.01303582f, -0.01616357f, 0.20273072f, 0.05601464f, 0.06232755f, -0.08810262f, -0.18951789f, 
    0.65736586f, 1.28364193f, 0.20246099f, -0.76166177f, 0.28861701f, 0.17861663f, 0.10592007f, -0.20649347f, 
    -0.48897293f, -0.16875260f, -0.07165648f, -0.11032157f, 0.08894089f, -0.24750474f, 0.09604845f, -0.05917695f, 
    -0.06375592f, -0.15738352f, 0.10331327f, 0.09221686f, -0.35956287f, -0.12079870f, 0.15057890f, 0.17029501f, 
    0.20792645f, -0.22519378f, 0.02601404f, 0.20355941f, 0.01479754f, 0.05817580f, 0.05204875f, 0.08064109f, 
    -0.03339237f, -0.05223961f, 0.08721028f, 0.04229331f, -0.02878964f, 0.11632194f, -0.04977470f, -0.14301002f, 
    -0.33304420f, 0.03979306f, -0.23733076f, 0.11458162f, 0.17622899f, 0.02708425f, -0.05529746f, 0.11179127f, 
    -0.03797242f, 0.11862562f, 0.01432682f, 0.05363845f, -0.17687781f, -0.23387541f, -0.16865824f, -0.07416472f, 
    -0.08619525f, 0.09461696f, -0.00503174f, -0.11516654f, -0.15793909f, -0.41004086f, 0.11490743f, 0.14767852f, 
    0.52017373f, -0.19938548f, 0.12594195f, 0.00742461f, 0.19273932f, 0.00470788f, 0.12572077f, 0.09945145f, 
    -0.07791266f, -0.11122245f, 0.13664454f, -0.00063655f, 0.05910157f, 0.00365121f, 0.07191904f, 0.05992480f, 
    0.02327238f, -0.04015928f, 0.08506416f, 0.07735082f, -0.08070673f, -0.16153137f, -0.14635313f, -0.15411231f, 
    -0.17193273f, -0.19626963f, -0.12870950f, 0.02530277f, -0.12756950f, -0.01564661f, -0.20274299f, -0.04381572f, 
    -0.01347995f, 0.03223141f, 0.00889398f, 0.07256240f, 0.04838388f, 0.18022442f, 0.33645111f, 0.26341322f, 
    0.15609692f, -0.03773097f, -0.01095035f, -0.01417617f, 0.08419529f, 0.18241145f, -0.01990516f, -0.02217659f, 
    -0.03951377f, -0.01960083f, -0.04315650f, -0.02742692f, -0.01729150f, -0.17906010f, -0.10450091f, -0.09332561f, 
    -0.18417156f, 0.02325913f, -0.04263023f, 0.09507269f, -0.02353472f, 0.01147197f, -0.03693012f, -0.07468177f, 
    -0.07038974f, 0.00064410f, -0.03448141f, 0.03915669f, -0.00803535f, 0.06198942f, -0.06623091f, -0.13354686f, 
    0.10137857f, 0.12591022f, -0.07792683f, 0.42064238f, -0.08725927f, -0.16117303f, 0.04109346f, -0.01103104f, 
    0.02237171f, -0.27445030f, -0.02616698f, -0.05023462f, 0.01515912f, -0.25783843f, -0.07839632f, -0.07780074f, 
    0.02053415f, 0.03786340f, 0.07773843f, -0.13358794f, -0.03024582f, 0.01986483f, 0.03573545f, -0.03930184f, 
    -0.15061356f, -0.15262686f, 0.17778832f, 0.13795362f, 0.08148066f, -0.14109196f, 0.04932592f, 0.03120193f, 
    -0.03795893f, -0.05734627f, -0.00919499f, 0.02115866f, 0.08985279f, 0.06198306f, 0.02299633f, 0.12320066f, 
    0.11741494f, -0.06043988f, -0.02206450f, 0.07757065f, 0.05307965f, -0.05170609f, -0.18491678f, 0.01528422f, 
    0.03828663f, 0.03670115f, 0.01913612f, 0.03521198f, -0.11783485f, 0.05831792f, 0.11045453f, 0.03259946f, 
    0.03626308f, -0.07227688f, 0.05468522f, -0.02003518f, -0.10585420f, -0.03755950f, -0.15987353f, -0.00705367f, 
    -0.04666190f, -0.00305204f, 0.21267731f, 0.17727605f, 0.16167502f, -0.14398314f, -0.02292060f, -0.11221609f, 
    -0.18225804f, 0.05882346f, 0.00025277f, 0.03124033f, -0.01669139f, 0.13598791f, 0.04367090f, 0.01434923f, 
    0.01258467f, -0.11335278f, 0.01784453f, -0.00554010f, 0.00037039f, 0.10062633f, 0.08217356f, 0.12184768f, 
    0.08215369f, 0.03639239f, 0.05617778f, -0.10447945f, -0.13323043f, 0.14004630f, 0.09588028f, -0.04022432f, 
    0.04135828f, -0.06289939f, -0.00036385f, -0.00771538f, -0.14647663f, -0.11281719f, -0.20276551f, -0.17255272f, 
    0.17184758f, 0.14853457f, 0.06989708f, -0.18379430f, -0.20584214f, 0.12571611f, 0.06394759f, 0.01678295f, 
    0.09913304f, 0.12995391f, 0.12445159f, 0.08288309f, 0.03596826f, -0.05281829f, -0.06225924f, -0.08284290f, 
    -0.03537223f, -0.05560630f, -0.06351247f, 0.15930763f, 0.08204444f, -0.14662623f, 0.13233107f, 0.18704045f, 
    0.13030832f, -0.16021076f, -0.19056983f, -0.03647310f, -0.12981811f, 0.02399173f, 0.00014334f, -0.09247760f, 
    0.00023140f, -0.03814539f, 0.05559200f, 0.01526341f, -0.05166295f, 0.04873529f, -0.10224264f, -0.04628446f, 
    -0.17381540f, 0.00586899f, -0.49675375f, -0.12163229f, 0.05130750f, 0.09536695f, -0.03335301f, 0.04805809f, 
    -0.04507131f, 0.03067792f, -0.02358629f, 0.09069695f, 0.04150069f, -0.23942193f, -0.05340553f, 0.15603524f, 
    -0.25205949f, 0.08007476f, -0.15006828f, -0.01045625f, 0.20795637f, 0.24958484f, 0.16424049f, 0.38621902f, 
    0.11726517f, -0.06460414f, -0.08400266f, -0.08396395f, -0.16098040f, 0.03711876f, -0.05611758f, 0.04260041f, 
    0.02945165f, 0.02331975f, 0.00320182f, 0.03517583f, -0.02389007f, -0.05740187f, -0.01105860f, -0.05182897f, 
    0.18306065f, -0.09237122f, 0.17951964f, 0.14677611f, 0.09875310f, -0.08045653f, -0.10440893f, -0.08055633f, 
    -0.02150821f, 0.00353816f, 0.13721682f, -0.09396361f, -0.02423861f, -0.00762777f, 0.05785628f, 0.07145429f, 
    0.03181028f, 0.14808629f, 0.00587567f, -0.01573442f, -0.14298441f, 0.03429684f, -0.19838829f, -0.14939530f, 
    -0.35165215f, 0.04972542f, -0.26800445f, 0.03676022f, 0.19636212f, -0.00348330f, -0.03706999f, -0.02368418f, 
    0.04835331f, 0.06496330f, -0.01552368f, -0.15638718f, 0.17116973f, 0.00026906f, -0.44148266f, 0.10709035f, 
    0.01744245f, 0.09062999f, -0.06578043f, 0.03777875f, 0.04255517f, 0.08503776f, 0.20185937f, 0.05513879f, 
    0.05364367f, 0.08951861f, 0.07292739f, 0.08688722f, -0.09350261f, 0.00109512f, 0.03494405f, 0.08593211f, 
    -0.33756614f, -0.02804091f, 0.02067084f, -0.06629834f, 0.03951545f, 0.06834108f, 0.20360257f, 0.05376085f, 
    0.08053482f, 0.10696188f, 0.08216003f, -0.14332712f, -0.13449423f, 0.11537793f, -0.03953406f, -0.00605774f, 
    0.05699806f, 0.03840677f, 0.04954499f, 0.01778032f, -0.08264680f, -0.05810394f, -0.13767859f, -0.15248516f, 
    0.10402003f, 0.17880951f, 0.09767570f, -0.02755378f, -0.11408533f, 0.04685988f, -0.11965805f, -0.13347514f, 
    -0.15528420f, 0.14891838f, 0.08146527f, -0.03214427f, 0.03076226f, 0.04746541f, 0.09510447f, 0.04021691f, 
    -0.02733549f, -0.21180102f, -0.19386755f, -0.01433963f, 0.33882490f, 0.02719401f, -0.54007357f, 0.31209123f, 
    0.18795699f, 0.02226294f, 0.04839848f, -0.01730668f, 0.05808388f, 0.02148291f, 0.14206965f, -0.11005277f, 
    0.02700134f, 0.00364327f, 0.02333718f, -0.07565114f, 0.11502367f, -0.01544621f, -0.25790626f, 0.00765736f, 
    0.07038654f, 0.04738785f, 0.18080090f, 0.05684320f, 0.06645468f, -0.17479260f, -0.04636112f, -0.20664860f, 
    -0.07669397f, -0.10297262f, 0.03014265f, -0.01974314f, 0.00174220f, -0.00189194f, -0.01245746f, 0.00457402f, 
    -0.01560301f, -0.10890829f, 0.06102253f, -0.02836444f, 0.01297348f, 0.03646470f, -0.02270446f, -0.04624541f, 
    -0.01776579f, 0.05798351f, 0.03216635f, 0.06496371f, 0.11275399f, 0.07580824f, 0.15226285f, 0.10517927f, 
    0.05141420f, 0.02138453f, 0.09417055f, 0.08421329f, 0.14351091f, -0.25468904f, -0.02181308f, 0.18526900f, 
    -0.01242453f, 0.05278156f, 0.10558514f, -0.16742957f, 0.02469763f, -0.03510017f, 0.04335997f, -0.04790068f, 
    -0.18070976f, -0.18491608f, 0.02832724f, -0.06919383f, -0.04265758f, 0.04336971f, 0.07686896f, 0.00520917f, 
    0.08828197f, 0.09229056f, -0.22116414f, -0.08348530f, 0.02152318f, -0.15004288f, -0.04112046f, -0.12913375f, 
    -0.09112322f, 0.18893370f, -0.04262042f, 0.02062487f, -0.00031147f, 0.03110605f, 0.05735943f, -0.01010555f, 
    -0.01351772f, 0.01803346f, 0.03985186f, -0.10190611f, -0.04289450f, -0.08146332f, -0.10147987f, 0.03105650f, 
    -0.47580671f, -0.29372585f, 0.33836758f, -0.06623916f, -0.05083793f, -0.22610100f, 0.03705727f, -0.23027876f, 
    0.06682071f, 0.16305543f, -0.04116759f, 0.07328747f, -0.08236882f, 0.08404502f, 0.04002898f, -0.06398470f, 
    0.09553504f, 0.01951343f, 0.00914941f, -0.00899266f, -0.03452645f, 0.22958432f, 0.28723350f, -0.01265750f, 
    0.06210105f, -0.09003080f, 0.14846773f, -0.04012323f, 0.19394049f, -0.15131889f, 0.02544710f, -0.01880359f, 
    0.01569691f, -0.12912564f, -0.05605009f, -0.17771043f, -0.02071624f, -0.05433868f, 0.06653843f, -0.08770847f, 
    0.58258969f, -0.29410508f, 0.03867930f, 0.09592844f, -0.26156241f, -0.17288055f, -0.43311629f, -0.16689794f, 
    -0.03215617f, -0.14929354f, 0.19409671f, -0.02115241f, -0.00797888f, 0.04096239f, 0.13881354f, 0.12948364f, 
    -0.00287129f, 0.02306131f, -0.19703591f, -0.04964150f, -0.00297219f, 0.02374309f, 0.02194904f, -0.02482690f, 
    0.05048996f, -0.03986483f, -0.02098043f, 0.00699193f, 0.10370375f, -0.09321416f, 0.14062075f, -0.01659391f, 
    0.04705602f, -0.13696158f, 0.03865355f, -0.00457620f, -0.10934543f, -0.03236889f, -0.09457371f, -0.04107185f, 
    0.03859201f, -0.11720397f, -0.04800782f, -0.12129871f, 0.09236418f, 0.09645178f, -0.03004864f, 0.04109735f, 
    -0.08355962f, -0.03498811f, -0.02962068f, -0.02972474f, 0.01823266f, -0.20187907f, -0.01872772f, -0.09906882f, 
    -0.12243007f, -0.14756611f, -0.12864144f, -0.03304278f, 0.07456147f, -0.45163804f, 0.25568911f, -0.00443770f, 
    -0.05554903f, 0.04137763f, 0.04267557f, 0.01488726f, -0.18686473f, -0.19963413f, -0.11598550f, -0.13698007f, 
    -0.04522403f, 0.12521859f, -0.08004616f, -0.15098165f, -0.05341620f, -0.05962819f, -0.04472016f, -0.17224640f, 
    -0.17565610f, -1.35595119f, -0.28371206f, 0.46004796f, -0.55093265f, -0.00843547f, -0.12423038f, -0.00700785f, 
    -0.38551256f, -0.04428341f, -0.01242423f, -0.14262587f, -0.13137719f, 0.04658535f, -0.04378780f, -0.13053086f, 
    -0.14607942f, -0.03211502f, -0.30646956f, 0.09111529f, 0.31089768f, 0.15286106f, 0.04928388f, 0.00049948f, 
    0.26208892f, 0.10926947f, 0.25077555f, 0.05047697f, 0.18451533f, 0.12144154f, -0.00232364f, -0.02404698f, 
    0.02476075f, 0.04925800f, 0.02373495f, 0.12333773f, 0.12311555f, -0.11996011f, 0.20612890f, 0.36970657f, 
    0.22191726f, -0.09287333f, 0.25625274f, -0.31506401f, -0.03695818f, 0.17885926f, -0.13088810f, -0.00678711f, 
    -0.04645674f, -0.05759841f, 0.00136889f, -0.14146282f, -0.02663016f, 0.06493662f, 0.00300802f, 0.02305789f, 
    -0.09612423f, -0.03183834f, -0.17170596f, -0.18612291f, 0.08389262f, 0.27115464f, 0.10395583f, 0.13164271f, 
    0.12462285f, 0.28208882f, 0.15399000f, 0.07915772f, 0.02643126f, 0.38122675f, -0.04402726f, -0.04429109f, 
    0.02030647f, -0.01162327f, -0.05500336f, -0.04296631f, 0.10502283f, -0.02353791f, 0.07497324f, 0.23802418f, 
    -0.08361591f, 0.03132117f, -0.05791191f, 0.13415085f, -0.06474207f, -0.08330226f, 0.07553031f, 0.05871233f, 
    -0.11002479f, 0.02691615f, 0.05988118f, -0.07343206f, -0.01344606f, 0.13007616f, 0.02823440f, -0.14882481f, 
    -0.12799062f, -0.06068498f, -0.02511312f, -0.16182667f, 0.10059310f, 0.10040347f, 0.22397268f, 0.01040773f, 
    -0.09914830f, 0.04174921f, 0.13314523f, 0.03996790f, -0.04616205f, 0.00654771f, 0.00751652f, -0.03199257f, 
    0.02828250f, 0.02708191f, 0.02511921f, 0.03047173f, 0.04750330f, -0.03286551f, -0.06910853f, 0.11765081f, 
    0.21663474f, 0.10455684f, 0.05733362f, -0.14442003f, 0.32687005f, -0.09564681f, -0.13739893f, -0.07965351f, 
    0.08435027f, -0.03023657f, 0.03904836f, 0.01146404f, 0.05688198f, 0.02540960f, -0.04423346f, 0.14255558f, 
    -0.06760687f, -0.39178649f, -0.15941793f, -0.69936460f, 0.08614281f, -0.06552210f, 0.00201349f, -0.07822277f, 
    -0.15118065f, 0.06791236f, -0.17895442f, -0.25223061f, -0.06498540f, 0.21802771f, 0.03973737f, 0.02894444f, 
    -0.06883471f, 0.16210310f, 0.04330328f, -0.09966337f, -0.13720718f, -0.04211031f, -0.06144045f, 0.21489333f, 
    -0.35099074f, 0.02376301f, 0.22894999f, -0.16680960f, -0.12089494f, 0.05763562f, -0.03259752f, 0.06497112f, 
    0.11652330f, -0.17079963f, 0.02674081f, -0.05417426f, -0.02866384f, 0.13549778f, 0.08398942f, 0.11091929f, 
    -0.03651553f, -0.20416333f, -0.14267740f, -0.18755302f, 0.08002867f, -0.03815797f, -0.30846116f, -0.03999592f, 
    0.17987527f, 0.15986969f, -0.04962456f, 0.14262539f, -0.11629856f, -0.06071166f, -0.04938198f, -0.04562550f, 
    -0.07130022f, -0.02467698f, -0.06666954f, 0.03885868f, 0.04614803f, 0.35247838f, -0.06226352f, -0.08119095f, 
    0.01841826f, -0.12904935f, 0.22597395f, 0.10147330f, -0.38728005f, 0.23124303f, 0.07043632f, 0.14308001f, 
    -0.02932340f, -0.16423211f, 0.04786071f, -0.03251706f, 0.02543068f, 0.05086546f, 0.08030483f, 0.00251580f, 
    0.03210734f, -0.08644206f, -0.09425898f, -0.08777592f, 0.08972593f, 0.00367357f, 0.04949307f, 0.11599905f, 
    -0.11673983f, -0.03420726f, -0.09945504f, 0.13931561f, 0.03585806f, -0.18359008f, -0.09458266f, -0.15664563f, 
    -0.05802311f, -0.04888435f, 0.01034212f, 0.01715457f, 0.15250486f, 0.06924553f, -0.02559368f, 0.07285675f, 
    -0.08627238f, -0.07171112f, -0.13929996f, -0.01556198f, 0.10513597f, -0.01558626f, 0.02467292f, -0.06416103f, 
    -0.01541109f, -0.06678598f, 0.09419604f, 0.01675112f, -0.12091581f, 0.16171086f, 0.07426390f, -0.07501411f, 
    0.11442821f, 0.23609309f, 0.14410198f, -0.11793317f, -0.27466697f, -0.12808467f, 0.04257983f, -0.12661423f, 
    -0.30512843f, 0.06789360f, 0.05659653f, -0.08127690f, 0.15860844f, -0.03801049f, 0.09942086f, 0.09456331f, 
    0.03035486f, -0.06789155f, -0.01480925f, 0.01055319f, 0.00562153f, 0.05001060f, 0.02110414f, 0.10783144f, 
    0.51243716f, 0.08190022f, -0.53209168f, 0.12824763f, 0.19626079f, -0.08251932f, 0.12528248f, 0.15941522f, 
    -0.20681201f, -0.02981540f, -0.01787775f, -0.18063495f, 0.02847360f, 0.06802551f, -0.01741299f, 0.17424844f, 
    -0.17109957f, -0.13537078f, -0.04496934f, 0.00726581f, -0.02224333f, -0.05846398f, 0.18769135f, -0.19576001f, 
    -0.28051379f, 0.05613199f, 0.13501665f, -0.04782717f, -0.02408808f, 0.00473208f, 0.13019645f, 0.01427916f, 
    -0.08473337f, 0.03929354f, 0.05056325f, -0.02670139f, -0.02360717f, 0.00611193f, 0.09483413f, 0.08888666f, 
    -0.48209229f, -0.14161609f, -0.15155387f, -0.24969485f, -0.10788872f, -0.00500991f, 0.07455127f, -0.06566998f, 
    0.09284996f, 0.19352040f, 0.04399544f, 0.04470173f, -0.06569012f, -0.01577574f, -0.06928261f, -0.03921762f, 
    0.00206483f, 0.05799112f, -0.08308826f, 0.04088305f, -0.01335237f, 0.41930956f, -0.27841306f, 0.28678623f, 
    0.10568102f, 0.12819998f, -0.07282060f, 0.01926165f, -0.04580558f, -0.07774593f, 0.03837186f, 0.03292567f, 
    -0.15181345f, 0.10830575f, 0.04840532f, -0.01960470f, -0.14401202f, 0.24347635f, 0.02878766f, -0.17714494f, 
    -0.01785822f, -0.12644753f, -0.18181413f, 0.05878224f, 0.10807233f, -0.12531425f, 0.05422219f, 0.02554594f, 
    -0.00277186f, -0.01021187f, -0.00736448f, -0.18147805f, 0.13138656f, 0.04208462f, 0.10713971f, -0.10668354f, 
    0.04209598f, -0.13260491f, -0.06987230f, 0.11917043f, 0.16106150f, -0.06641371f, 0.18349986f, -0.04351383f, 
    -0.00307315f, -0.02016381f, -0.01792378f, 0.02792673f, 0.16074774f, -0.09596039f, -0.02705454f, -0.10347376f, 
    0.09403643f, -0.03451441f, 0.02956314f, 0.05496383f, 0.06607872f, 0.03979386f, 0.11364201f, 0.16930425f, 
    -0.04252173f, 0.09477919f, 0.10754114f, -0.24574217f, 0.01402717f, -0.05050866f, 0.14604665f, 0.08727115f, 
    -0.08153639f, 0.05644143f, 0.15203542f, -0.02798591f, -0.00791993f, -0.01450186f, 0.05010892f, 0.04261583f, 
    0.03842222f, -0.02226413f, 0.07597020f, 0.11794366f, -0.96448505f, -0.01774793f, -0.19459298f, 0.49121726f, 
    -0.26714635f, 0.17361276f, -0.20060466f, 0.02897568f, -0.03787957f, 0.13356315f, -0.08656447f, 0.10125593f, 
    -0.05174262f, -0.03175714f, -0.06443048f, 0.00696247f, -0.26755646f, 0.38556945f, -0.07462235f, -0.04245115f, 
    -0.02746356f, -0.07898093f, 0.01473607f, -0.02864809f, -0.08007603f, -0.06011550f, 0.15075052f, 0.10458314f, 
    0.01056772f, 0.01779125f, 0.07375205f, -0.01181399f, 0.01145032f, 0.03959057f, -0.03713612f, -0.03394714f, 
    -0.01746055f, -0.04542137f, 0.11040916f, -0.01768352f, -0.28785264f, -0.17224222f, -0.08059280f, -0.11599270f, 
    0.07907308f, 0.06636713f, 0.05298078f, -0.07669698f, -0.00119295f, -0.02721586f, 0.06709135f, -0.11752448f, 
    -0.02245070f, 0.03664051f, -0.05141730f, -0.11539676f, -0.05946704f, 0.02900548f, 0.04313102f, -0.01998515f, 
    0.15118347f, -0.03471422f, 0.21170303f, -0.09849613f, 0.06268208f, 0.15985923f, -0.01156130f, 0.03061617f, 
    -0.03116364f, 0.03776334f, 0.02238225f, -0.06448933f, 0.11910149f, 0.04598943f, 0.01991753f, -0.14471355f, 
    -0.03654450f, 0.12676729f, 0.18257928f, -0.24089363f, -0.05491241f, -0.00059934f, -0.27464458f, -0.25930476f, 
    0.21595110f, 0.11095677f, 0.08151814f, -0.02659434f, -0.05478182f, -0.01566477f, 0.09062473f, -0.10113312f, 
    -0.09862331f, 0.00693690f, 0.05957763f, 0.03311076f, 0.17392388f, 0.03682900f, -0.05472478f, 0.00508447f, 
    -0.43653935f, 0.10179272f, -0.58013618f, -0.70462584f, -0.13888913f, -0.06907196f, -0.05256849f, 0.01927173f, 
    -0.24254435f, -0.06529366f, -0.15916312f, 0.21939744f, -0.21298903f, 0.01185399f, 0.12948099f, -0.13641576f, 
    -0.15227646f, 0.01523637f, -0.07777154f, -0.04269592f, 0.64659369f, 0.45153341f, -0.25281641f, -0.06170488f, 
    -0.13392882f, -0.05591071f, -0.02497440f, 0.04137735f, -0.21179697f, 0.28330675f, 0.04064033f, -0.11284048f, 
    0.01674608f, 0.03405859f, 0.07177103f, 0.10577232f, 0.05404019f, -0.07693704f, -0.12728040f, 0.26908195f, 
    -1.05748451f, 0.56678140f, 0.10587545f, -0.36615399f, -0.17793940f, -0.15217914f, 0.16421743f, 0.03985768f, 
    0.18053710f, 0.09336921f, 0.06011341f, -0.00226801f, -0.04565655f, -0.08489399f, -0.04061730f, 0.00568285f, 
    -0.13396004f, 0.00730621f, 0.09527352f, 0.13595735f, -0.02605065f, 0.27144137f, -0.18652754f, 0.19507052f, 
    0.01255995f, 0.00976367f, -0.09233572f, 0.02189395f, -0.00114663f, 0.14019708f, -0.12074380f, -0.04734030f, 
    -0.12855724f, 0.05826859f, -0.15244976f, 0.09277258f, 0.08142156f, 0.06909543f, -0.08518378f, 0.00318247f, 
    0.04493829f, -0.28780878f, -0.11922698f, 0.13169107f, -0.02476651f, 0.21695717f, -0.08652730f, -0.04308544f, 
    0.02133191f, 0.10929476f, 0.04280685f, 0.08983970f, 0.05318420f, -0.11175688f, 0.10700709f, 0.01279947f, 
    0.00407558f, -0.02331845f, -0.07002054f, 0.10589004f, -0.17948356f, 0.01605199f, 0.05939828f, -0.51247567f, 
    0.12460372f, 0.08407705f, 0.00591257f, 0.00155524f, -0.14434196f, 0.02053471f, 0.10373495f, -0.05707289f, 
    -0.06223961f, -0.16998488f, -0.03834473f, 0.10433204f, 0.03561433f, 0.14536779f, 0.08611948f, 0.08937046f, 
    -0.97911674f, 0.11522191f, 0.00068574f, 0.29598209f, -0.54592490f, 0.14327168f, -0.52317488f, -0.22552764f, 
    0.26893559f, -0.16217665f, 0.19384454f, 0.00636825f, -0.17979200f, 0.09589176f, 0.23009446f, 0.05043118f, 
    0.11226154f, -0.12706420f, 0.09283438f, 0.17884961f, 0.20849437f, -0.05452574f, 0.30855119f, 0.30552810f, 
    -0.32949308f, 0.02332086f, -0.00856136f, -0.06360628f, 0.06209277f, 0.00199728f, 0.02619186f, 0.04535931f, 
    0.02813729f, -0.03613267f, -0.02299049f, -0.16814460f, 0.07826474f, -0.05679723f, -0.12961738f, -0.12779415f, 
    -0.02575572f, 0.01613037f, 0.21750189f, -0.10592408f, 0.19226757f, -0.18068050f, 0.00331699f, -0.16581635f, 
    0.10895661f, 0.12648238f, 0.04607664f, 0.03247105f, -0.04362076f, -0.06669963f, -0.01788354f, 0.08621863f, 
    -0.14667040f, -0.03629807f, 0.04330803f, 0.29399493f, 0.47359821f, 0.11831748f, -0.12243128f, -0.15208361f, 
    0.15476570f, 0.01436604f, 0.01872798f, 0.00789260f, 0.06445739f, 0.03272818f, 0.06859675f, 0.07791766f, 
    0.03725198f, -0.07086151f, -0.03436749f, -0.08809288f, -0.10368093f, -0.01952290f, -0.05726760f, -0.09349124f, 
    -0.25774270f, -0.07810616f, 0.30916700f, 0.14904870f, 0.31482399f, 0.00336739f, -0.13292371f, -0.03581756f, 
    -0.12604403f, 0.00469648f, 0.01802288f, -0.00330375f, 0.03042217f, -0.20275120f, 0.02565775f, -0.01131579f, 
    0.13485244f, 0.00516175f, 0.13278031f, -0.09362255f, -0.27585265f, -0.90132213f, -0.66777062f, -0.11104128f, 
    0.18595918f, 0.05817995f, 0.06408456f, -0.00155449f, 0.00574308f, -0.51110035f, 0.05813160f, -0.01538317f, 
    -0.06736831f, -0.09660919f, 0.04884354f, 0.02970232f, 0.01203711f, 0.09695631f, 0.07684795f, 0.13751237f, 
    -0.15916419f, -0.26819804f, -0.13067470f, 0.04934441f, 0.03142095f, -0.05944139f, 0.05136681f, -0.14321169f, 
    0.13354796f, -0.02442806f, -0.04505947f, -0.02132713f, 0.03978841f, -0.01065085f, 0.02446102f, -0.02905253f, 
    0.09909607f, 0.24601059f, 0.10603514f, -0.10710962f, -0.11737781f, 0.19565804f, -0.05256385f, 0.02655872f, 
    0.45054284f, -0.10221213f, 0.07762209f, 0.07011918f, -0.05184736f, 0.06098597f, -0.00251538f, 0.00262933f, 
    -0.07173843f, 0.15841101f, -0.04387070f, -0.01871718f, -0.00427592f, -0.09335201f, 0.16312645f, 0.01152281f, 
    -0.22889698f, -0.50161898f, -1.08735335f, -0.29403329f, -0.15645932f, -0.07527156f, -0.19741634f, -0.22354203f, 
    -0.15734477f, -0.27287114f, -0.04073134f, 0.03155299f, -0.06488798f, 0.05288462f, -0.10019253f, -0.01842469f, 
    -0.10123661f, 0.12668729f, 0.09100342f, 0.03323286f, 0.26649746f, -0.10424998f, -0.04725796f, 0.03475593f, 
    0.06110845f, -0.02193282f, -0.02251055f, 0.33131900f, 0.05573531f, -0.05206090f, 0.01928427f, 0.00015913f, 
    -0.08288659f, -0.16827537f, 0.02321081f, -0.06897655f, -0.05486820f, 0.10013229f, -0.10174062f, -0.01979732f, 
    -0.58723551f, -0.50597185f, -0.85162294f, -0.34013984f, 0.00899723f, -0.38733017f, -0.08356300f, -0.12113784f, 
    -0.28720137f, -0.33954778f, 0.00553484f, -0.00044783f, -0.00129305f, -0.03104378f, 0.00145915f, -0.02252194f, 
    -0.00116117f, 0.00961706f, 0.20648137f, 0.04003789f, 0.01344931f, -0.05113321f, 0.04646781f, -0.09676891f, 
    0.11379217f, -0.12610412f, 0.04278605f, -0.04406033f, -0.03816150f, -0.00761268f, 0.00588698f, -0.05213252f, 
    -0.07505357f, -0.05706009f, 0.02157471f, -0.03272801f, -0.05419935f, -0.02200372f, 0.10098334f, -0.19927372f, 
    -0.01196887f, 0.01266900f, 0.14627920f, -0.07592782f, -0.07703301f, -0.03671585f, -0.05331526f, -0.05394055f, 
    -0.05927232f, -0.00481243f, -0.03859966f, -0.02355114f, -0.04324627f, -0.06196847f, -0.12837474f, 0.00183939f, 
    -0.07982948f, 0.01891542f, -0.08046035f, 0.06436598f, -0.46851817f, 0.09363213f, 0.48595551f, 0.01825710f, 
    -0.04768054f, -0.16486792f, -0.14429963f, -0.06107574f, -0.16062796f, 0.16773164f, -0.02759659f, 0.19124553f, 
    0.03639564f, 0.00655394f, -0.00243950f, 0.01085658f, 0.01535684f, -0.01775835f, -0.04806511f, -0.00802549f, 
    0.19402319f, 0.09240046f, 0.03263401f, -0.19725040f, 0.05237035f, 0.04161629f, 0.06334788f, 0.07387905f, 
    0.06990957f, -0.22882643f, -0.03375700f, -0.02957085f, -0.02799098f, 0.03435201f, -0.02543551f, 0.02780356f, 
    0.06872256f, 0.09232978f, -0.20259416f, 0.03345518f, -0.83774173f, -0.30955923f, 0.44787881f, -0.17339680f, 
    -0.41241390f, -0.24243833f, -0.16997783f, -0.06760380f, -0.10952740f, -0.17593803f, -0.08461748f, 0.04828945f, 
    -0.00228620f, -0.00685529f, -0.00951644f, 0.00601625f, -0.01093244f, 0.04079557f, 0.03697042f, -0.04343653f, 
    -0.60319650f, 0.52269572f, 0.47022524f, -0.04993633f, 0.08784118f, -0.09675688f, -0.15085725f, -0.11311086f, 
    -0.18084221f, 0.32624978f, -0.10081474f, 0.18046840f, 0.05489141f, 0.05622577f, 0.05236338f, -0.00485642f, 
    -0.04969313f, -0.00600610f, -0.03442344f, -0.03043314f, 0.08004989f, -0.07276744f, -0.07756545f, -0.01537596f, 
    -0.12592524f, 0.09461905f, -0.03615330f, 0.15298390f, 0.10941496f, -0.02212960f, 0.10664303f, 0.02724913f, 
    0.09108396f, 0.00126216f, 0.02514119f, 0.06065233f, 0.07774415f, 0.01777777f, 0.05693278f, -0.00143563f, 
    0.05492271f, -0.21412097f, -0.12614882f, -0.04201526f, 0.12243461f, -0.01772072f, 0.02778126f, 0.03519552f, 
    0.03271422f, 0.00275983f, -0.08870634f, -0.08951759f, -0.19769016f, -0.05210726f, -0.06113045f, -0.06958659f, 
    -0.14062399f, -0.05429706f, -0.06350800f, -0.04571694f, -0.22753306f, -0.03709069f, 0.12085190f, 0.08025289f, 
    0.11059554f, -0.09411141f, 0.02331550f, -0.08792126f, -0.11372451f, -0.11987798f, -0.06114430f, -0.09605564f, 
    -0.13736522f, 0.01950647f, 0.03552533f, 0.02841185f, -0.03563760f, 0.10821446f, -0.02714287f, -0.21284442f, 
    -0.18469229f, 0.04758377f, 0.28134736f, 0.03900394f, -0.05793982f, -0.03779676f, -0.14653850f, -0.07956585f, 
    -0.03057940f, -0.08254184f, 0.03576292f, -0.01294711f, 0.02545250f, 0.02310487f, 0.03005370f, 0.03214375f, 
    -0.02176837f, 0.09984411f, -0.11959362f, -0.03851997f, 0.01674423f, -0.30265152f, -0.36345038f, -0.24506377f, 
    0.29691833f, -0.01520843f, 0.13546006f, 0.14821616f, 0.03821714f, 0.09922209f, -0.03298172f, -0.01543735f, 
    0.03548123f, -0.01595539f, 0.03201599f, -0.00337986f, -0.13554256f, -0.19225736f, 0.22005084f, 0.01843024f, 
    -0.69596565f, -0.50100708f, -0.26658735f, 0.11712047f, -0.18880910f, -0.20391653f, -0.08976699f, -0.08277343f, 
    -0.09181345f, -0.28800124f, 0.04912531f, -0.00616028f, 0.01495331f, -0.05580677f, 0.05222497f, -0.02748045f, 
    -0.02451962f, 0.03001423f, 0.12217218f, -0.12917602f, -0.10593237f, 0.10087188f, 0.03482721f, -0.05458962f, 
    0.03047242f, 0.00421361f, 0.01910101f, -0.05409295f, -0.11571109f, -0.04776795f, -0.02080244f, -0.05419543f, 
    -0.02736765f, -0.10082763f, -0.08048353f, -0.01030052f, -0.03387414f, -0.35681888f, -0.00912574f, 0.11003494f, 
    -0.25560090f, -0.16142872f, -0.02873703f, 0.46164864f, -0.27452710f, -0.09014093f, 0.29948887f, -0.00855250f, 
    -0.04973185f, -0.23705743f, 0.10797340f, 0.07356752f, 0.04692381f, 0.06813458f, 0.06173903f, 0.07308931f, 
    0.04772155f, 0.14345831f, 0.14096321f, 0.03389854f, 0.16686273f, 0.01159412f, 0.00766569f, -0.03215995f, 
    -0.09426784f, 0.09808995f, 0.02951506f, 0.06624550f, -0.07559425f, -0.04545797f, -0.01612673f, 0.04945033f, 
    -0.06972931f, -0.02738751f, -0.02280049f, 0.00887026f, 0.05572924f, 0.00566936f, -0.16553211f, 0.03403859f, 
    -0.48526004f, 0.12744749f, 0.15956613f, -0.04944555f, 0.54934442f, -0.10513947f, -0.19048804f, -0.09611988f, 
    0.07508435f, 0.13777812f, 0.09937887f, 0.21325122f, 0.24643232f, 0.21843006f, -0.14095064f, 0.04320580f, 
    0.07310078f, 0.09756928f, 0.00357258f, 0.09011345f, 0.30651453f, -0.47609052f, -1.76874518f, -0.53832424f, 
    -0.02489356f, -0.15990272f, 0.12430431f, 0.02472405f, 0.24228245f, -0.33523503f, 0.08183801f, -0.06678613f, 
    -0.08925334f, -0.01966928f, -0.01802735f, -0.05438149f, 0.02438929f, 0.08888796f, 0.03484925f, -0.01495685f, 
    -0.98698902f, 0.00331946f, 0.65278405f, -0.10095336f, -0.08526684f, 0.07006887f, -0.21403420f, 0.04287769f, 
    -0.04407786f, 0.25811771f, 0.12295131f, 0.13667636f, -0.05562800f, 0.07162896f, 0.03125958f, 0.00322384f, 
    0.05402016f, 0.06372289f, -0.07053557f, 0.03633557f, -0.22221166f, 0.19518678f, 0.23035669f, -0.04725093f, 
    0.20134379f, -0.16293667f, -0.00438733f, -0.09287722f, 0.02128817f, 0.17082538f, 0.09087362f, 0.12194426f, 
    0.04602920f, 0.02750497f, 0.00917675f, -0.01685683f, -0.05666121f, -0.03562305f, 0.01089275f, -0.02967073f, 
    0.09955271f, 0.10396123f, -0.18695962f, -0.18924332f, 0.12262134f, -0.06226111f, -0.06174360f, 0.17369494f, 
    0.09153419f, 0.16224244f, -0.07792862f, 0.05486151f, 0.01338511f, -0.06365449f, 0.01984793f, 0.00148494f, 
    0.06584130f, -0.06169670f, 0.01529607f, 0.02470017f, -0.16043948f, 0.48155770f, 0.02313136f, 0.09535489f, 
    0.12521736f, 0.06620190f, 0.02998541f, -0.13624595f, 0.01488786f, -0.05741978f, 0.15875348f, 0.03499438f, 
    0.08714644f, 0.05222235f, 0.15637551f, 0.11505233f, -0.00463806f, -0.03767795f, -0.06909114f, -0.07023778f, 
    -0.58125377f, -0.69336569f, 0.17271192f, -0.15811035f, 0.25321263f, -0.34307411f, 0.07875970f, -0.06895263f, 
    -0.14967853f, 0.14830732f, 0.05612329f, 0.05461885f, 0.17499030f, 0.04982966f, -0.20770063f, -0.04601707f, 
    0.04314162f, -0.10083811f, 0.12682094f, 0.12172130f, -0.47885653f, -0.61166525f, -0.63764954f, -0.07410935f, 
    0.02812766f, -0.12188878f, 0.13888070f, 0.01621015f, -0.11982834f, -0.23986624f, -0.04506519f, -0.04008919f, 
    -0.02606941f, 0.06865706f, 0.03757224f, -0.00580595f, -0.01781427f, 0.17745110f, 0.22369201f, 0.08974470f, 
    -0.19984402f, 0.33239707f, -0.30392346f, 0.04935861f, 0.02761972f, 0.10554289f, 0.06223859f, -0.10042977f, 
    0.09822792f, -0.27162060f, -0.06005554f, 0.10150021f, -0.08170790f, 0.10071746f, 0.07120934f, 0.01622370f, 
    0.02181263f, 0.18734798f, -0.32742482f, -0.03538156f, 0.10299841f, -0.76757056f, -0.74633735f, -0.16712265f, 
    -0.07119525f, -0.07247854f, 0.04932637f, 0.17708875f, 0.06700526f, -0.52667338f, 0.02925163f, -0.01273833f, 
    0.01507020f, 0.02344529f, 0.03762723f, -0.02904544f, -0.02315952f, 0.18923210f, -0.01011137f, 0.00729407f, 
    0.18869328f, -0.61427981f, 0.12963825f, -0.33138484f, -0.26937154f, -0.09115925f, -0.06524400f, -0.14431816f, 
    0.15640464f, -0.04871503f, -0.00668865f, 0.06622485f, -0.14574122f, -0.00042115f, 0.04740891f, -0.10855609f, 
    -0.03168839f, -0.09617861f, 0.06329741f, 0.01049850f, -0.55946189f, -0.52229410f, 0.18478000f, 0.32578367f, 
    0.00186001f, -0.03133767f, 0.10401142f, -0.08893271f, 0.05941092f, 0.03033894f, 0.03468873f, -0.07081062f, 
    -0.02586396f, -0.05301600f, -0.04118127f, -0.04486382f, -0.00570838f, -0.15068914f, 0.06660557f, -0.13149363f, 
    -0.41223848f, -0.21456732f, 0.15365537f, -0.07674920f, -0.11966672f, 0.02977138f, -0.14821966f, 0.02594316f, 
    0.00965296f, -0.08181427f, -0.03456146f, -0.05552616f, -0.06961061f, -0.09617624f, -0.07382953f, 0.09206600f, 
    0.15357320f, -0.01896496f, 0.02322774f, 0.01440661f, 0.31198734f, -0.49743783f, -0.46175814f, -0.31462887f, 
    -0.14843169f, 0.29117817f, 0.12782431f, 0.06700536f, 0.07355105f, -0.06174022f, 0.02393338f, 0.01297997f, 
    0.02226944f, -0.00746637f, -0.02198306f, -0.07934682f, -0.08523200f, 0.04260528f, -0.03438365f, 0.01126629f, 
    0.17570798f, -0.39278245f, 0.23731461f, -0.43707636f, -0.19949123f, -0.07793906f, 0.12007713f, -0.14712811f, 
    0.19361439f, 0.13550864f, 0.01772205f, -0.00186663f, -0.02673086f, -0.11965794f, -0.01328291f, 0.00313564f, 
    0.05868779f, -0.00875584f, 0.18578404f, -0.09275313f, -0.05308092f, 0.11318058f, 0.07033548f, 0.02446413f, 
    -0.09212407f, -0.04228917f, 0.03283424f, -0.02475437f, -0.00794173f, -0.04409765f, 0.03792476f, 0.01470213f, 
    0.01695571f, 0.01217827f, -0.04054274f, -0.02671073f, -0.15591821f, 0.00489129f, -0.04391904f, 0.05402364f, 
    0.18694435f, -0.30962193f, -0.04601210f, 0.30490094f, -0.12734652f, -0.04255692f, 0.10471198f, -0.09947761f, 
    0.21396343f, 0.13253744f, -0.02913549f, -0.00155551f, -0.07140724f, -0.16817641f, 0.01552214f, -0.03859681f, 
    0.01578085f, -0.08941685f, 0.23695368f, -0.18505119f, 0.02105967f, -0.08258098f, -0.17803834f, 0.08344641f, 
    -0.13659568f, 0.10114697f, -0.00696435f, 0.12055214f, 0.00051043f, 0.04591146f, -0.08739214f, -0.03917141f, 
    0.10551783f, -0.00690160f, -0.02167165f, -0.01831336f, 0.03558769f, -0.03221300f, -0.08958884f, -0.07702922f, 
    0.01285555f, 0.07462618f, 0.00536332f, 0.02956484f, -0.09363356f, -0.01063116f, 0.06245206f, 0.03079866f, 
    -0.02368514f, -0.02585238f, -0.03299867f, 0.02310711f, 0.01825167f, -0.08860695f, -0.06195916f, 0.05130757f, 
    -0.00557103f, -0.02245088f, 0.02381522f, 0.01298360f, 0.59586656f, -0.19990623f, -0.42718616f, -0.33948779f, 
    -0.20801112f, -0.00651581f, -0.03872212f, -0.27844951f, -0.06655810f, -0.15051378f, 0.00675316f, -0.04401514f, 
    0.13878651f, -0.06141365f, 0.01110083f, 0.02300220f, 0.01825472f, -0.00669688f, -0.02913830f, 0.05046495f, 
    -0.30767375f, 0.23423928f, 0.06970931f, 0.05650075f, -0.08208536f, -0.23700437f, -0.08314548f, 0.01823839f, 
    -0.00889380f, 0.00352706f, 0.07951232f, -0.00104342f, 0.04039302f, -0.00300966f, -0.02992476f, -0.11090665f, 
    -0.37267756f, -0.09238651f, -0.16665253f, 0.08968742f, 0.54012471f, -0.58140397f, -0.18520641f, -0.30361947f, 
    -0.08484127f, -0.02294007f, 0.19281159f, -0.24334568f, 0.10564923f, -0.03716942f, 0.02596042f, 0.05950084f, 
    0.03429903f, -0.02002099f, 0.05997911f, -0.00674039f, 0.00944453f, -0.06698570f, 0.04434530f, 0.03902249f, 
    0.51441622f, -0.26088867f, -0.28215241f, -0.20139103f, -0.22493090f, -0.06121326f, -0.06761324f, -0.00792107f, 
    0.05035457f, 0.00694776f, -0.04077893f, -0.10353646f, 0.10005525f, -0.00606826f, 0.00115552f, -0.02501482f, 
    0.07022481f, -0.00698911f, 0.07305214f, 0.03133143f, -0.05618487f, 0.07109651f, 0.12513974f, 0.00032898f, 
    -0.18247287f, -0.13654196f, 0.12041346f, -0.06324659f, 0.01195061f, -0.06174790f, -0.01231175f, 0.00488439f, 
    -0.03569438f, -0.12890054f, -0.08045073f, -0.10512640f, -0.01398126f, -0.10622164f, -0.04695310f, -0.16984738f, 
    0.01052573f, 0.13249207f, 0.03547470f, -0.02205102f, -0.07321044f, -0.00251939f, 0.02085675f, 0.03575556f, 
    0.03104618f, -0.05602644f, 0.03124389f, -0.00658716f, 0.03559699f, -0.04785934f, -0.12151289f, -0.07107127f, 
    -0.11352555f, 0.07715782f, 0.03161955f, 0.06247045f, -0.12300995f, -0.20983320f, -0.08005665f, 0.11008378f, 
    -0.03942592f, 0.12592740f, 0.06443755f, 0.08525441f, -0.02039248f, 0.04861069f, 0.08262476f, 0.02893599f, 
    0.05641448f, -0.00938730f, 0.02308493f, 0.03538435f, 0.03568792f, -0.02868992f, -0.10087939f, -0.05139250f, 
    0.14500906f, -0.16442679f, 0.09747708f, -0.21563879f, 0.07904308f, -0.11765049f, 0.09387663f, 0.01920500f, 
    0.00841808f, -0.05016517f, 0.02514981f, -0.10982212f, 0.01486831f, 0.02488170f, -0.03874636f, 0.03153912f, 
    -0.03139808f, -0.02694073f, 0.04924313f, 0.02786232f, -0.01009593f, 0.11203112f, -0.18064179f, 0.04152152f, 
    -0.34952071f, -0.03986027f, 0.11289914f, -0.21994926f, -0.10116764f, -0.13057445f, -0.00386345f, 0.01612034f, 
    0.04361715f, -0.01787140f, -0.03053768f, -0.11581822f, -0.07006125f, 0.09511010f, -0.11198916f, -0.08422883f, 
    0.11793547f, -0.31830969f, -0.36061403f, -0.22612992f, -0.17857867f, -0.05192588f, 0.11075676f, 0.01409718f, 
    0.27411604f, -0.00665594f, -0.04023402f, 0.04404352f, -0.05035174f, -0.07033069f, 0.00723519f, -0.06040591f, 
    0.02539613f, -0.00693208f, -0.03198655f, -0.11867428f, 0.04264883f, 0.04893948f, 0.02225821f, 0.05396799f, 
    -0.06038086f, -0.00919364f, 0.05947972f, -0.00560063f, 0.01731915f, -0.00742756f, 0.06895477f, 0.01641139f, 
    0.03182124f, 0.02536534f, 0.02726551f, -0.15015766f, -0.12045182f, -0.17152187f, 0.08075497f, 0.03315783f, 
    -0.41850328f, -0.51585734f, 0.64399058f, -0.17880744f, 0.29755065f, 0.13243102f, -0.26580310f, 0.15077342f, 
    -0.20934296f, -0.07751214f, -0.02162429f, 0.02735538f, -0.03542951f, 0.09942574f, -0.06099650f, 0.01465924f, 
    -0.01435167f, 0.11669489f, -0.09205975f, -0.15549010f, -0.01569149f, 0.08017510f, 0.16551848f, -0.04133377f, 
    0.00951017f, -0.02790518f, -0.00292647f, -0.01777245f, -0.07344627f, -0.07082214f, 0.04105157f, -0.07460433f, 
    -0.00086381f, -0.06989381f, -0.06599802f, -0.11043455f, -0.03458416f, -0.08268742f, 0.09031615f, -0.02060400f, 
    0.25032848f, -0.73435384f, -0.23893614f, -0.15276051f, -0.01612898f, 0.13004842f, -0.00882447f, 0.27410609f, 
    0.23245454f, 0.05275110f, -0.04613526f, 0.10038978f, 0.02040882f, -0.01656722f, -0.02442331f, -0.04854464f, 
    0.05693056f, -0.09029353f, 0.18966001f, 0.19089325f, -0.90301794f, 0.12922306f, -0.19970322f, 0.25558114f, 
    0.47192198f, 0.09346198f, -0.08488658f, 0.16019973f, -0.10591792f, -0.00901703f, 0.05751427f, -0.01130308f, 
    -0.01199051f, -0.05000158f, -0.03297865f, 0.01479931f, -0.03875031f, -0.11341681f, -0.23471408f, 0.06800735f, 
    1.17864811f, -0.45990962f, 0.42826748f, -0.72245383f, -0.35195541f, -0.28338960f, 0.17196856f, -0.05566845f, 
    -0.06366254f, -0.28327137f, 0.02158166f, -0.14386803f, 0.08383984f, 0.09500469f, -0.00390082f, -0.00822216f, 
    -0.08466522f, 0.02871688f, -0.01505466f, -0.04476463f, 0.48067737f, 0.07779205f, -0.30320698f, -0.01612432f, 
    -0.33916095f, 0.02450612f, -0.13185991f, -0.09917436f, -0.21680714f, 0.04655666f, -0.07039891f, -0.09697947f, 
    0.05277161f, -0.02492504f, -0.08077204f, 0.01702126f, -0.05009144f, 0.04003959f, -0.08740728f, -0.09439965f, 
    0.02109000f, -0.02757685f, -0.13967609f, -0.04387594f, -0.09880686f, -0.04662977f, -0.05559564f, 0.04281656f, 
    -0.02602852f, -0.07513726f, -0.00927099f, 0.04202922f, -0.02753491f, 0.04403518f, -0.07800858f, -0.04155780f, 
    -0.09955387f, 0.03686548f, -0.02333387f, 0.02708999f, -0.46666941f, -0.24647216f, 0.55965120f, -0.21140037f, 
    0.24514970f, -0.09927019f, -0.11205736f, 0.14740352f, 0.03732051f, 0.01014208f, -0.09145098f, 0.06232425f, 
    0.02643411f, 0.15692008f, 0.04528778f, -0.08510874f, 0.03968791f, 0.00668288f, 0.01744669f, -0.03336017f, 
    0.53134179f, 0.68656701f, -0.71039867f, -0.25736228f, -0.84398520f, 0.12175965f, 0.12153932f, 0.04846009f, 
    -0.00577314f, 0.06971183f, -0.08172884f, 0.05983566f, 0.00838218f, -0.03610978f, -0.08179638f, -0.11915777f, 
    0.02897692f, -0.05154208f, -0.08384006f, -0.16319571f, -0.11804708f, -0.19798918f, 0.33289576f, 0.25695941f, 
    0.14529704f, 0.03044690f, 0.05893195f, 0.04047188f, -0.10988691f, 0.10960089f, 0.00130029f, -0.00998246f, 
    0.00245538f, 0.00744176f, 0.02316645f, 0.21537210f, 0.15757121f, 0.02857001f, 0.10033030f, 0.02592823f, 
    -0.46969327f, -0.14711478f, 0.39115694f, -0.19559439f, 0.27131805f, -0.36168292f, 0.17717588f, 0.11667456f, 
    0.12012058f, 0.11486816f, -0.04886277f, 0.00324909f, 0.00582585f, -0.01387777f, -0.00426363f, 0.06662577f, 
    -0.02889891f, -0.05242150f, -0.13162349f, 0.01916552f, -0.55217218f, 0.02161872f, 0.19916861f, 0.07235570f, 
    -0.02327756f, 0.08422062f, -0.01545830f, -0.06326735f, -0.01644856f, 0.10718526f, 0.04527443f, 0.03333116f, 
    0.04539837f, 0.02276337f, 0.03175613f, 0.12057342f, 0.17080554f, -0.12348417f, -0.08298787f, -0.09852835f, 
    0.22697435f, -0.12901743f, -0.33507615f, -0.16865188f, 0.32400030f, 0.13230021f, 0.15060261f, 0.17191559f, 
    0.06879978f, 0.12565702f, -0.05017326f, -0.03009971f, -0.09212020f, 0.03169003f, 0.09551609f, 0.03765507f, 
    0.07995415f, 0.10529593f, -0.08493645f, 0.18604188f, 0.29245713f, -0.01154596f, -0.01095315f, -0.16024263f, 
    -0.12721503f, 0.10532814f, -0.15798692f, -0.13958466f, 0.01716317f, -0.07286099f, -0.06441167f, 0.05611169f, 
    0.06026828f, -0.00585256f, 0.07912920f, 0.04411060f, 0.05998861f, 0.14260213f, 0.00503145f, 0.01970237f, 
    0.14249919f, 0.05082726f, -0.17050590f, 0.12570095f, 0.08751670f, 0.08707900f, 0.07898019f, 0.16757870f, 
    0.07166667f, -0.01303731f, 0.03229836f, 0.01202725f, 0.02663161f, 0.03953054f, 0.07162128f, -0.28943709f, 
    -0.05608995f, -0.05817539f, -0.12887491f, -0.37833157f, 0.24093859f, -0.24750568f, -0.65078354f, -0.07981692f, 
    0.26230639f, 0.03210244f, 0.21369845f, 0.28875449f, 0.18161263f, -0.00142444f, 0.01909956f, -0.08174357f, 
    -0.10279299f, 0.02703486f, -0.03916340f, 0.11980838f, -0.02279493f, -0.01355353f, 0.02573539f, -0.05330778f, 
    0.10597800f, -0.12178089f, -0.50292313f, -0.49501854f, -0.21937235f, -0.12472192f, -0.17245772f, 0.08940333f, 
    -0.14908275f, -0.34177026f, 0.04643559f, -0.01286824f, -0.00981417f, 0.05175855f, 0.06625547f, 0.07188948f, 
    0.01331143f, 0.10707597f, -0.05105657f, -0.37356961f, -0.27749482f, 0.12485892f, 0.09677207f, 0.13507430f, 
    -0.13255388f, -0.09846070f, 0.04724528f, -0.08705322f, 0.04928811f, -0.02170219f, -0.03549090f, 0.09347939f, 
    0.05583274f, 0.06427224f, 0.04890221f, 0.05530103f, 0.13811786f, 0.12172090f, 0.13788438f, 0.11913396f, 
    -0.01263580f, -0.22374801f, -0.63607407f, -0.44034952f, -0.18754156f, -0.20400260f, -0.32380801f, -0.06815934f, 
    -0.07671093f, -0.27542806f, -0.01236084f, 0.01324284f, 0.00091283f, 0.05108167f, 0.05108101f, 0.08749750f, 
    -0.00120482f, 0.07603728f, -0.04046279f, -0.08973157f, 0.22871880f, 0.02508135f, -0.07810363f, -0.01493356f, 
    -0.07002723f, -0.05121861f, -0.05886574f, -0.14458849f, -0.08180089f, -0.10868160f, -0.03041622f, 0.00462220f, 
    0.07881339f, -0.05627076f, 0.00632934f, 0.00988425f, 0.14419338f, 0.13627623f, 0.23520637f, 0.15492764f, 
    -0.32139397f, 0.09405879f, 0.14368121f, -0.03897300f, -0.28508472f, -0.14725257f, -0.05014522f, -0.04126249f, 
    0.05208343f, -0.04634473f, -0.17178775f, 0.03956617f, 0.03658275f, 0.09004427f, 0.10558097f, 0.04866017f, 
    -0.01025258f, 0.01390539f, -0.02249789f, -0.01317505f, -0.02003732f, -0.07603372f, -0.57742119f, 0.03735639f, 
    -0.07515669f, -0.12113535f, 0.16359910f, 0.11997061f, 0.11785338f, 0.05810549f, 0.12518369f, -0.06751675f, 
    -0.03216532f, -0.07299726f, -0.01265888f, -0.02980426f, 0.09161064f, -0.05447447f, 0.01694231f, -0.01963712f, 
    -0.67361814f, -0.11243761f, 0.16800156f, 0.07843522f, 0.00262427f, -0.02808244f, 0.13401240f, -0.01858943f, 
    0.10749546f, 0.02091844f, -0.03889757f, 0.03573799f, 0.10998490f, -0.05149128f, 0.09077905f, 0.01028424f, 
    0.20375042f, -0.02266206f, 0.15017064f, 0.01924561f, -0.04423635f, -0.49457642f, -0.75155216f, -0.28721803f, 
    0.07770263f, -0.00176146f, -0.16744536f, 0.12968791f, 0.11272128f, 0.11667979f, -0.09501597f, -0.07978456f, 
    -0.03485249f, -0.04162726f, -0.01046793f, 0.06689690f, 0.04107519f, 0.05219160f, -0.01068917f, 0.10715155f, 
    -0.13287732f, -0.49617529f, -0.56271893f, -0.19203126f, -0.01680828f, -0.14382833f, 0.09557716f, 0.12947872f, 
    0.11274446f, 0.15813866f, 0.12287750f, -0.06219222f, -0.02689478f, -0.11555874f, -0.08932648f, -0.00069475f, 
    0.00566202f, 0.00184119f, 0.02834212f, -0.01460267f, 0.25668356f, 0.11935490f, 0.08675132f, -0.05881915f, 
    0.06739912f, 0.03598316f, 0.22579707f, 0.05535307f, 0.09904566f, -0.18642379f, -0.19679326f, 0.00407675f, 
    0.09436043f, 0.00109093f, 0.08473545f, -0.07510957f, -0.09395901f, 0.00662315f, 0.08050087f, 0.13360001f, 
    -0.19757313f, -0.05537398f, 0.03594856f, 0.01990759f, -0.25404063f, -0.10442138f, -0.07069977f, -0.04686266f, 
    -0.01554538f, -0.02265286f, -0.04498593f, 0.08713995f, -0.09965951f, 0.04300691f, 0.08385646f, 0.14523686f, 
    0.21227215f, 0.16579345f, 0.10807607f, 0.10520754f, 0.31698710f, -0.08205713f, -0.11716251f, 0.10622264f, 
    -0.13477653f, -0.10734523f, -0.10692375f, -0.20626503f, -0.05730775f, -0.00597232f, -0.05176237f, -0.01579463f, 
    -0.03924837f, -0.10271583f, -0.00512412f, -0.05128765f, 0.12055340f, 0.08171999f, 0.24306272f, 0.09583123f, 
    -0.05064189f, -0.20053940f, -0.17495085f, 0.03156154f, 0.06202042f, 0.00390341f, -0.09034849f, 0.00504354f, 
    0.06776921f, 0.16779768f, -0.11148958f, 0.07073463f, -0.01377353f, -0.04775161f, 0.00948077f, -0.03502996f, 
    0.10105056f, 0.16490927f, 0.01596833f, 0.14832169f, 0.44554651f, 0.36640725f, 0.19869880f, 0.03980743f, 
    -0.21818125f, -0.00954459f, 0.00285387f, -0.04582849f, 0.01307396f, -0.25502327f, -0.03447266f, 0.01312722f, 
    0.06483299f, -0.04694838f, -0.00742023f, 0.01136332f, -0.02469048f, -0.12509346f, 0.10813074f, -0.06661719f, 
    0.07257283f, -0.44984967f, -0.72254717f, -0.40887406f, 0.16268976f, 0.01687473f, -0.06348184f, 0.14154769f, 
    0.01695119f, 0.01512465f, -0.09941223f, -0.09531473f, -0.07120848f, 0.05639788f, 0.03169687f, 0.02432734f, 
    -0.04424340f, 0.05515802f, 0.01216777f, 0.16199656f, -0.56974906f, 0.08806276f, 0.15678349f, -0.02558896f, 
    -0.18679951f, -0.02485469f, -0.11496086f, -0.00353446f, -0.02751409f, -0.09495585f, -0.10703143f, -0.10258532f, 
    -0.01719479f, -0.05403343f, -0.05054400f, 0.03016271f, 0.04053073f, -0.02902950f, -0.11899211f, 0.02626519f, 
    0.39879465f, -0.49074420f, -0.02081345f, 0.26539123f, 0.15541755f, 0.09676319f, 0.31505880f, -0.06528977f, 
    -0.05456081f, 0.06340790f, 0.04541745f, 0.03113605f, 0.10009744f, 0.06754783f, 0.09685569f, 0.07900338f, 
    -0.01217795f, -0.11102533f, -0.21141025f, -0.17540132f, -0.32029912f, -0.02575716f, 0.17083198f, 0.04915279f, 
    0.04585799f, -0.02748366f, -0.02374215f, 0.01827803f, 0.05283053f, 0.03144803f, -0.04436058f, -0.06256680f, 
    0.08051318f, 0.09404947f, 0.06005559f, 0.01800280f, 0.05442080f, 0.07223594f, 0.01776560f, 0.12062076f, 
    -0.19347154f, -0.50485623f, -0.10230143f, 0.07669437f, 0.24938719f, -0.27652282f, 0.03535567f, 0.09393096f, 
    -0.04179905f, -0.01593822f, -0.02942343f, -0.11620977f, -0.09290283f, -0.08199509f, -0.11715567f, -0.09602165f, 
    -0.14262612f, -0.04700268f, -0.16156772f, -0.17256042f, -0.27239481f, -0.65387785f, -0.26582736f, 0.00178092f, 
    0.18866503f, 0.01368239f, -0.04083420f, -0.07307046f, 0.06759552f, -0.27175540f, -0.03449307f, -0.05067479f, 
    0.10667348f, 0.01279811f, 0.07541281f, 0.05512485f, -0.01945404f, -0.03906368f, -0.13410728f, -0.07129518f, 
    0.44616452f, -0.56614918f, -0.64343518f, -0.17165515f, -0.12517089f, 0.00151856f, -0.10012874f, 0.09400745f, 
    0.07233808f, 0.15558478f, 0.01617030f, 0.09305404f, -0.05858070f, -0.04076559f, -0.00718812f, -0.03474475f, 
    0.16597022f, 0.04120774f, -0.13902155f, 0.08125568f, 0.18800797f, -0.19955197f, -0.21845549f, -0.03499230f, 
    0.03328519f, -0.14648184f, 0.12651499f, -0.00117229f, 0.08326802f, 0.03667245f, 0.08604629f, -0.06434729f, 
    -0.15121552f, -0.08062621f, -0.10017557f, 0.06023338f, 0.09604686f, -0.02454736f, 0.16447738f, -0.06612020f, 
    0.17345637f, 0.15150398f, -0.00242879f, 0.10668081f, -0.06809656f, 0.01371066f, 0.02906913f, -0.08555517f, 
    -0.08402039f, 0.08296698f, 0.15005556f, -0.00888854f, 0.00188376f, 0.06930109f, 0.00643930f, -0.01192162f, 
    0.11830455f, 0.05555710f, 0.13632005f, 0.05187878f, -0.28098074f, -0.49637669f, -0.10996564f, 0.14207442f, 
    0.21083207f, 0.02873852f, 0.09637172f, 0.06208444f, 0.00432918f, 0.13260669f, -0.01325009f, 0.03801798f, 
    -0.02010821f, -0.04707289f, 0.06056025f, -0.09145199f, 0.00929593f, 0.02730828f, -0.05042270f, 0.05057701f, 
    0.28703266f, 0.28123587f, -0.22122787f, -0.31573272f, -0.57267511f, -0.18490134f, 0.13667831f, -0.10363059f, 
    0.10029496f, -0.14676203f, 0.10149179f, 0.18951951f, 0.16944245f, 0.14626278f, 0.16747665f, -0.05864574f, 
    -0.04343210f, -0.01501671f, -0.04897517f, 0.04732894f, 0.59924895f, -0.12518956f, 0.27075624f, -0.03277040f, 
    -0.33159617f, 0.08164329f, -0.17370258f, -0.17263705f, -0.03864722f, 0.02635852f, -0.00571794f, -0.04589624f, 
    -0.02672993f, -0.04260854f, -0.03024070f, 0.07435765f, 0.01492418f, -0.08015019f, -0.26153460f, -0.40972507f, 
    0.10712395f, -0.49862728f, -0.19368792f, 0.21548177f, 0.09921085f, 0.09757838f, -0.05698909f, 0.05134131f, 
    -0.01018822f, 0.10136957f, -0.01731616f, -0.01493045f, -0.02653939f, 0.04266614f, -0.02212115f, -0.00791158f, 
    0.10064445f, 0.13748334f, 0.11226378f, -0.01972273f, -0.68522358f, -0.00720266f, 0.22618659f, 0.14721155f, 
    -0.10123534f, 0.11416285f, -0.13756314f, -0.03767726f, -0.17326911f, -0.25863707f, -0.03188240f, -0.03984787f, 
    -0.01856784f, -0.09844076f, -0.03231655f, 0.05360228f, -0.05406579f, -0.07633644f, -0.14677100f, -0.34944424f, 
    0.11218768f, 0.12379101f, 0.30575082f, 0.38762802f, -0.56449950f, 0.12851174f, -0.05491350f, -0.11293129f, 
    0.03780916f, 0.16571225f, 0.07303683f, -0.02257857f, -0.00050858f, -0.01667684f, 0.03232230f, 0.09450600f, 
    -0.02920586f, -0.00611382f, 0.04645345f, 0.01178430f, 0.23475194f, 0.08032934f, -0.19925037f, 0.05692755f, 
    -0.16036464f, -0.10205779f, -0.10891873f, 0.18141016f, 0.06681757f, 0.22417232f, -0.07079927f, 0.00979366f, 
    -0.01460337f, -0.09515995f, -0.09352987f, 0.01271736f, 0.01013675f, 0.00674703f, 0.17259321f, -0.21700671f, 
    0.07899643f, -0.28969193f, -0.21293426f, 0.17291287f, -0.20272207f, 0.02847012f, -0.00811406f, 0.11949632f, 
    -0.01202804f, 0.05988097f, 0.05024665f, 0.00139627f, 0.00780675f, 0.05771666f, 0.05261737f, -0.04280757f, 
    0.17759442f, 0.20624824f, 0.07814293f, 0.37963453f, 0.01461796f, 0.11579856f, -0.14250177f, 0.36191368f, 
    -0.55776149f, 0.06486448f, -0.08467268f, -0.16462980f, 0.03061592f, -0.06309919f, -0.00737946f, -0.00293905f, 
    0.00427915f, 0.05686716f, 0.02082125f, 0.06653646f, 0.06911509f, 0.08580069f, 0.05364726f, 0.00854297f, 
    -0.10792409f, -0.31232676f, -0.12761059f, 0.16948079f, -0.38521457f, -0.24012750f, 0.11005527f, -0.12620588f, 
    -0.09476890f, 0.13377300f, 0.10075604f, -0.03218834f, 0.04916706f, -0.01523083f, -0.08140671f, -0.13200858f, 
    -0.00025727f, 0.22864585f, 0.25098670f, 0.05350387f, -0.05084307f, 0.37107772f, -0.23451596f, -0.32354793f, 
    0.01126554f, 0.13013664f, 0.15113984f, 0.22169778f, 0.15170892f, 0.12363883f, 0.11950190f, -0.03931978f, 
    -0.10166050f, 0.09277447f, 0.01140430f, 0.14598405f, 0.02248807f, -0.21357010f, -0.05886748f, -0.01519547f, 
    -0.47248125f, -0.36657625f, 0.23596688f, 0.37138915f, -0.54737347f, 0.03043692f, -0.39162496f, 0.02369115f, 
    0.02706505f, 0.25550607f, 0.04914685f, -0.01740853f, 0.11669227f, 0.01833915f, -0.05087056f, -0.02241481f, 
    0.06167427f, 0.06461390f, 0.18089391f, 0.10196831f, -0.00720494f, 0.15273590f, 0.01993613f, 0.12796088f, 
    0.01575854f, 0.05594224f, -0.05976390f, 0.10971169f, 0.02565105f, 0.00863469f, 0.09452908f, -0.02454124f, 
    -0.00831527f, -0.12793796f, -0.11412314f, 0.09942011f, -0.04479609f, -0.12998801f, 0.06345517f, -0.14235820f, 
    -0.16316721f, -0.02681066f, 0.03884123f, 0.02286007f, 0.31748191f, -0.06129269f, 0.05886044f, 0.01997555f, 
    0.03532027f, -0.08803312f, 0.04520070f, 0.09605430f, 0.08727138f, -0.12221875f, -0.24856514f, 0.17609426f, 
    0.06524980f, 0.00816103f, -0.05731058f, 0.13387655f, -0.27068675f, -0.01169074f, -0.00452010f, 0.16936134f, 
    -0.01807529f, -0.04118137f, 0.09439478f, -0.43058077f, -0.13137229f, -0.13348432f, 0.02791651f, -0.10693375f, 
    0.04985167f, 0.09028272f, 0.08378857f, 0.04582860f, 0.00855631f, 0.00900024f, -0.02218467f, -0.04261781f, 
    -0.26563311f, 0.31414956f, -0.11834365f, -0.47239125f, -0.09820025f, 0.15063189f, -0.06062109f, 0.03263080f, 
    0.05446556f, 0.04878191f, 0.10136419f, -0.02830109f, -0.05819909f, 0.05468480f, 0.05732791f, 0.02250334f, 
    0.02022701f, -0.00542994f, -0.11173197f, -0.08483797f, -0.18262175f, -0.26000962f, 0.07094723f, 0.21184584f, 
    -0.39420834f, -0.15138276f, 0.02220026f, -0.02991906f, 0.01183437f, 0.09079207f, 0.01632458f, -0.05937089f, 
    0.01974571f, 0.02046861f, -0.00920162f, 0.05764230f, -0.02206533f, -0.00422537f, 0.04363837f, -0.08007677f, 
    0.26677644f, 0.15394881f, 0.37015241f, 0.27739117f, -0.32580268f, 0.01516827f, -0.06728805f, -0.50042361f, 
    -0.19502708f, -0.26007771f, 0.06835403f, 0.01731247f, 0.11521025f, 0.17597270f, 0.09414643f, 0.05388544f, 
    -0.02901927f, -0.01184122f, -0.00012170f, 0.01377907f, -0.25683257f, -0.27771932f, -0.11912359f, -0.06807179f, 
    0.18675272f, -0.07624906f, 0.10174654f, 0.07736544f, -0.09973470f, -0.02965723f, 0.07322985f, 0.03107299f, 
    0.02589074f, -0.07117522f, -0.09094866f, 0.08085010f, 0.22425526f, -0.18485942f, -0.00088914f, 0.03424460f, 
    -0.20216568f, -0.16658922f, -0.14737554f, -0.07230932f, -0.15292272f, 0.09926180f, 0.27052620f, 0.17539342f, 
    0.00762785f, -0.03595153f, 0.01516230f, -0.06564458f, -0.17437060f, 0.06357139f, 0.02964358f, 0.14163178f, 
    -0.24526109f, 0.10672033f, -0.16186959f, 0.01504532f, 0.08080681f, 0.06086436f, 0.09996532f, 0.07333228f, 
    -0.10139577f, -0.09729177f, 0.01418911f, -0.00169396f, 0.03885478f, 0.00081687f, -0.09012940f, 0.00006051f, 
    -0.00241913f, -0.07750154f, -0.08103155f, 0.04145618f, 0.00146275f, 0.03185132f, -0.05559363f, -0.12447356f, 
    0.15489098f, 0.09079493f, 0.14728817f, -0.02855584f, -0.06272432f, -0.09789898f, 0.13558209f, -0.24724841f, 
    -0.11849265f, 0.06147328f, -0.05399119f, 0.04741568f, 0.13296153f, -0.04149605f, 0.03033656f, 0.03062189f, 
    -0.06867455f, 0.03618684f, -0.12812415f, -0.17745292f, -0.35061237f, 0.27072147f, -1.02522016f, 0.15342759f, 
    0.01866407f, 0.04914838f, 0.04488888f, 0.24239677f, -0.03894528f, 0.13086998f, 0.05533695f, -0.03658777f, 
    0.03758260f, -0.00306420f, -0.10605473f, 0.07083630f, 0.01569658f, -0.00904258f, 0.14458284f, 0.05208803f, 
    -0.02066341f, -0.15771030f, 0.50288761f, 0.08642200f, -0.63822645f, 0.04889852f, -0.10914802f, -0.06616570f, 
    0.13411088f, 0.30673942f, 0.00784063f, -0.03290845f, -0.01628861f, -0.03040400f, -0.08523575f, -0.01422692f, 
    0.03436139f, 0.04043820f, -0.07726847f, -0.07082230f, -0.20112993f, -0.16150673f, -0.46170619f, -0.17879690f, 
    0.10289131f, -0.00977577f, 0.08131376f, 0.28504956f, 0.00610229f, -0.03430552f, -0.03753308f, -0.01801445f, 
    0.03264310f, 0.04725800f, -0.07923744f, 0.05478320f, 0.15782611f, -0.06344359f, -0.03561177f, 0.07711336f, 
    0.16745779f, -0.55463755f, -0.10995056f, -0.80496210f, 0.28921029f, 0.11993788f, -0.14730193f, -0.03656011f, 
    0.10651630f, 0.02977373f, -0.12298683f, -0.04992551f, 0.05703412f, -0.05041122f, 0.00273672f, -0.03880776f, 
    0.07276372f, 0.00106464f, -0.13208735f, 0.06095589f, 0.12169279f, -0.11586989f, 0.11003077f, -0.14054671f, 
    0.18104924f, -0.12889406f, 0.07398798f, 0.16622621f, 0.09381288f, 0.09975013f, 0.01179758f, 0.10891358f, 
    0.13276581f, -0.14714968f, 0.00777244f, 0.04728510f, 0.00034780f, 0.05387937f, -0.13894847f, -0.00152599f, 
    0.15383936f, -0.09425221f, 0.12097470f, 0.39144871f, -0.51773888f, -0.20110527f, -0.07258349f, -0.46099266f, 
    0.11022579f, -0.37160242f, 0.04730086f, -0.01902127f, 0.15109126f, 0.10085189f, 0.02582750f, 0.12076908f, 
    0.09522554f, 0.01668975f, 0.01679808f, 0.16664188f, -0.84767771f, 0.84509301f, -0.54298455f, -0.28188813f, 
    -0.58387381f, -0.06874041f, -0.29141819f, -0.07201198f, -0.19689988f, 0.09337307f, -0.03310724f, 0.08281689f, 
    -0.04442319f, -0.05530771f, 0.00741047f, -0.08143321f, 0.01312584f, 0.09614846f, -0.00362061f, -0.04452635f, 
    -0.71840930f, -0.23839718f, -0.23620021f, -0.23664135f, -0.05816606f, -0.31831104f, 0.18902551f, -0.29643205f, 
    -0.31130713f, 0.06569888f, 0.21158175f, -0.07099821f, 0.10409705f, -0.09002813f, -0.01652868f, 0.12636054f, 
    0.01916883f, -0.02678622f, -0.01215683f, -0.15913351f, -0.22927617f, 0.21555097f, 0.20306909f, 0.00177780f, 
    -0.19845308f, 0.18777631f, -0.29216304f, -0.12641366f, -0.08800263f, 0.02408431f, -0.04611170f, -0.00251466f, 
    0.11710113f, 0.01767365f, 0.02596674f, 0.02266771f, -0.10164411f, -0.08228417f, 0.06986111f, -0.03172349f, 
    -0.13310033f, 0.03394482f, 0.19156815f, 0.03079252f, 0.04052094f, 0.24774648f, 0.01359024f, 0.06521224f, 
    -0.07343110f, -0.16353168f, 0.12595581f, -0.15298963f, 0.01963212f, -0.04181462f, -0.02376310f, 0.09477321f, 
    -0.07565755f, -0.16296598f, 0.01132804f, -0.03799561f, 0.17374285f, -0.28868183f, 0.44354004f, -0.54398584f, 
    -0.43244404f, -0.05452576f, -0.11573943f, -0.12839559f, 0.02047687f, 0.13186051f, 0.05537290f, 0.16053917f, 
    -0.05581514f, 0.09828255f, -0.20410529f, -0.02333684f, -0.00651124f, -0.05463260f, -0.06037987f, 0.03413068f, 
    -1.46696055f, -0.34924325f, -0.34630910f, 0.57212418f, -0.28778034f, -0.30287483f, 0.26578075f, -0.58603591f, 
    0.07249615f, 0.00550939f, 0.02476038f, -0.10944828f, -0.08459686f, -0.22469656f, 0.02314046f, 0.15010193f, 
    -0.04158355f, -0.16214143f, -0.12281619f, -0.03932228f, 0.23571648f, -0.68637735f, -0.62529099f, 0.12522586f, 
    -0.03033798f, 0.12711184f, 0.00158863f, 0.14395171f, 0.08724964f, 0.04625151f, 0.01497137f, 0.01317297f, 
    -0.02987895f, 0.00296175f, -0.06489270f, -0.06357343f, 0.04792177f, -0.00497468f, 0.05608616f, 0.21021757f, 
    -0.04599544f, 0.02007249f, 0.43108451f, -0.24336138f, -0.21668695f, -0.19684497f, 0.01337553f, 0.09478070f, 
    -0.12304159f, 0.03099044f, -0.06721433f, -0.00773373f, -0.07217554f, 0.02952857f, 0.00833517f, -0.03915177f, 
    -0.09322460f, 0.01375928f, -0.18547229f, -0.15774077f, 0.33188865f, -0.06163760f, -0.61605573f, 0.22126538f, 
    0.02757274f, -0.08031224f, 0.05783978f, 0.21223018f, -0.11990400f, 0.20499367f, -0.02351392f, 0.00455805f, 
    -0.06118665f, -0.01053341f, 0.03344945f, 0.02758854f, 0.15932147f, 0.09263097f, -0.00810780f, 0.03562601f, 
    -0.24146391f, -0.00679611f, -0.07905528f, 0.19394042f, 0.10214338f, -0.04656117f, -0.08682563f, -0.05487478f, 
    0.01298860f, 0.07779824f, -0.05954775f, -0.04359863f, -0.18732747f, -0.00517311f, -0.10299363f, -0.06125401f, 
    -0.12587163f, 0.10749826f, -0.12539645f, 0.05892211f, -0.17704929f, 0.04860362f, -0.34028193f, 0.07334835f, 
    0.00757918f, -0.04483417f, -0.09958320f, 0.18460856f, -0.14809930f, 0.01067503f, -0.03758106f, 0.16651835f, 
    0.04672395f, 0.11869945f, -0.02492562f, 0.15243998f, -0.10642990f, -0.04754987f, 0.00702238f, 0.00761652f, 
    0.09083861f, -0.04484779f, -0.12286115f, -0.02989693f, -0.07168546f, -0.04976384f, 0.06804506f, 0.14864965f, 
    -0.03877949f, -0.08917598f, 0.03286815f, 0.00320664f, -0.02787381f, -0.00781062f, -0.07576513f, -0.04418900f, 
    -0.10113034f, -0.15199393f, -0.24547184f, -0.17008591f, -0.36622989f, -0.11811068f, 0.04797405f, -0.06680286f, 
    0.07945071f, -0.03850675f, -0.00629314f, -0.13388713f, 0.13173680f, -0.06262868f, -0.04284621f, 0.12889454f, 
    -0.00403118f, -0.05802608f, -0.16408734f, 0.07183541f, -0.00959693f, -0.02811543f, -0.04672239f, -0.05549523f, 
    -0.18574852f, 0.05126335f, -0.44661799f, -0.21416438f, 0.13967203f, -0.05841634f, -0.07268766f, 0.24068452f, 
    -0.01887923f, 0.05098374f, -0.04161339f, 0.13132633f, 0.06437249f, -0.03828534f, -0.03643665f, 0.03725230f, 
    -0.16873136f, -0.15316397f, -0.08551413f, -0.14389074f, -0.19333281f, -0.50387293f, 0.13257268f, 0.12481866f, 
    -0.29877555f, -0.05539231f, 0.02359354f, 0.14426205f, 0.05431391f, -0.11645181f, -0.11130340f, -0.08701626f, 
    -0.01286087f, -0.07437039f, -0.10221583f, 0.05610712f, 0.03197744f, 0.18391387f, 0.14946912f, 0.18276052f, 
    -0.44799364f, 0.21108477f, -0.65035927f, -0.01079809f, 0.04898848f, 0.01943377f, -0.08008654f, -0.14577886f, 
    -0.00235824f, 0.12872553f, -0.07528871f, 0.11162651f, 0.00885312f, 0.00875659f, -0.00576813f, 0.07662122f, 
    -0.06092133f, -0.17549396f, -0.03238888f, -0.17990258f, -0.32348269f, -0.19932412f, 0.16755973f, -0.15674676f, 
    0.05371494f, -0.11002201f, 0.04319484f, 0.05775988f, 0.07758341f, 0.11893042f, -0.04351973f, 0.13525288f, 
    -0.00606161f, 0.08802223f, 0.00523252f, 0.13784660f, 0.15493988f, 0.15354711f, 0.20665982f, 0.16070610f, 
    0.01686629f, -0.45922008f, 0.01454562f, 0.02231215f, -0.69194156f, 0.03674066f, -0.17602147f, -0.07420411f, 
    -0.08557279f, -0.10329283f, 0.01276716f, 0.03208815f, -0.14440294f, -0.03471140f, 0.03062063f, 0.08863994f, 
    0.08180354f, 0.00693331f, 0.01065298f, -0.28466788f, 0.12307069f, 0.11717357f, 0.13885172f, -0.03088562f, 
    0.07408599f, 0.02407383f, 0.00604253f, 0.01599423f, -0.06817482f, 0.07755846f, -0.16753970f, 0.12709132f, 
    -0.01999562f, -0.01613304f, -0.03085344f, 0.04498667f, 0.07977315f, -0.03140339f, 0.06775969f, 0.02265916f, 
    -0.11023323f, 0.22348022f, 0.21356060f, 0.04276249f, -0.09275900f, 0.06967089f, 0.18864931f, 0.11044186f, 
    0.07280893f, 0.09525788f, 0.00608483f, -0.19943354f, 0.03891855f, -0.01052757f, -0.13122979f, -0.25596699f, 
    0.09906068f, 0.15314552f, 0.02935497f, -0.04983526f, -0.41465837f, 0.07714171f, -0.09134854f, 0.09290147f, 
    0.33552223f, -0.02008542f, 0.06603493f, -0.02757663f, -0.17376521f, 0.04208301f, -0.30930477f, 0.08576178f, 
    0.02427703f, 0.06986561f, 0.10470257f, 0.07660906f, -0.01285360f, -0.16666332f, 0.05733730f, 0.10273968f, 
    -0.03371850f, 0.07000065f, -0.06849149f, -0.07669291f, 0.00321864f, 0.03782080f, -0.03095780f, -0.19479965f, 
    -0.01015446f, 0.01989640f, -0.08982659f, 0.15135571f, -0.04179845f, -0.09095024f, -0.12111057f, 0.05466093f, 
    0.02215267f, -0.06352935f, 0.09930030f, -0.01422013f, 0.03440887f, -0.22241670f, 0.13531297f, 0.27500585f, 
    0.17194073f, -0.02394923f, -0.07404182f, 0.19248757f, -0.00698225f, -0.07331250f, 0.05691565f, -0.06032646f, 
    -0.28195438f, 0.12099703f, 0.03156352f, -0.07571741f, -0.02867933f, 0.16475523f, -0.18072116f, 0.00189097f, 
    -0.34766406f, -0.69321287f, -0.09503666f, -0.24146809f, -0.43811351f, 0.09365151f, -0.20734628f, -0.13899392f, 
    0.05678047f, -0.09099422f, -0.07815409f, 0.03161028f, 0.11517449f, -0.02018245f, -0.23743810f, -0.05786708f, 
    0.16166347f, 0.04282119f, 0.26839891f, 0.07827019f, -0.47401467f, 0.01016917f, 0.08325042f, 0.07902036f, 
    0.05009350f, 0.00051810f, 0.08926965f, 0.08380456f, 0.03269963f, 0.10356638f, -0.01398229f, 0.10819976f, 
    0.01236516f, 0.11593073f, -0.09082179f, 0.02400480f, 0.18184812f, 0.10948962f, 0.17192379f, 0.29108372f, 
    0.00097028f, 0.04332152f, -0.13206981f, 0.23301026f, 0.23886499f, 0.00724430f, 0.03640846f, 0.13442108f, 
    -0.00063662f, -0.04921919f, 0.05220602f, -0.02706559f, 0.08345408f, 0.08372395f, 0.03673159f, 0.01252880f, 
    0.11309927f, 0.13500097f, 0.04614919f, 0.21405481f, -0.05108714f, -0.57464141f, 0.05310896f, -0.10335393f, 
    0.05169681f, -0.33242789f, -0.15178728f, 0.16035783f, 0.01116326f, -0.01319225f, -0.11049842f, 0.07825872f, 
    -0.02382871f, 0.07715072f, 0.10153193f, 0.05637743f, -0.15804589f, -0.04216206f, -0.03413999f, -0.08549896f, 
    -0.26621413f, 0.02894684f, -0.59420437f, 0.15656114f, 0.10105317f, -0.08395249f, -0.01679788f, -0.05867036f, 
    -0.06078229f, 0.01013073f, -0.00579743f, -0.04100931f, -0.09000317f, -0.05388514f, -0.02935166f, 0.02336917f, 
    -0.04870491f, -0.04195628f, -0.02841916f, -0.02684569f, -0.07670900f, -0.52994657f, -0.15466797f, 0.23862579f, 
    -0.32877761f, -0.05085162f, -0.15841712f, -0.10026942f, -0.03038672f, -0.11463851f, -0.11778753f, 0.01616212f, 
    -0.18859662f, 0.00920307f, 0.04137392f, 0.11980803f, -0.19692750f, -0.14202277f, 0.08480825f, 0.19791296f, 
    -0.21933438f, 0.33389205f, 0.22494115f, 0.26680046f, 0.04964639f, 0.15755202f, -0.02989900f, -0.16936219f, 
    -0.04042967f, -0.06952488f, -0.19020152f, 0.06119626f, -0.06598593f, 0.05257094f, 0.00853202f, -0.03120230f, 
    -0.05936459f, 0.08477505f, -0.25629398f, -0.01908124f, 0.07132006f, -0.18362176f, 0.05841580f, 0.16721672f, 
    -0.24547295f, -0.05137997f, -0.20606689f, -0.08083377f, 0.03530235f, 0.11657677f, -0.11423366f, 0.03277196f, 
    -0.03314773f, -0.00524153f, 0.10827628f, 0.01043562f, -0.00679897f, 0.02212972f, 0.08557287f, 0.10376623f, 
    -0.24935134f, 0.42177492f, -0.06815349f, -0.04673183f, 0.07199018f, 0.19181594f, -0.06609507f, 0.00432084f, 
    -0.00225043f, -0.01184116f, -0.19897799f, 0.03962639f, -0.13309427f, -0.22081383f, -0.25047439f, -0.07638510f, 
    -0.13834284f, -0.03287625f, -0.00884839f, -0.18583848f, -0.10301052f, -0.07769714f, -0.42001840f, 0.04383387f, 
    -0.08733937f, -0.12648548f, 0.02443272f, 0.42862827f, -0.08753187f, -0.22980480f, -0.01174884f, -0.00391139f, 
    -0.08864381f, 0.16290808f, -0.05018676f, -0.07472786f, -0.13007478f, 0.24325244f, -0.07479940f, 0.07727372f, 
    0.62451667f, -0.06228075f, 0.05304196f, 0.13668577f, 0.17513242f, 0.04436365f, 0.21136349f, 0.28176492f, 
    0.29631919f, 0.10791384f, -0.15185766f, 0.17538956f, 0.05527732f, -0.22259727f, -0.09355697f, -0.03662857f, 
    0.01703682f, 0.05603547f, 0.28579050f, -0.03739850f, 0.15869553f, -0.16897441f, 0.28881526f, -0.04761831f, 
    -0.10417324f, -0.06844665f, 0.11552940f, 0.12341255f, 0.23867863f, -0.04683286f, -0.07053164f, -0.03992680f, 
    -0.10509834f, -0.18376464f, -0.05787060f, -0.04188674f, 0.10478755f, 0.18215060f, 0.19016755f, 0.04217140f, 
    -0.48370352f, -0.29130802f, -0.01018391f, -0.10350306f, -0.03071851f, 0.00553566f, -0.09649093f, -0.07682651f, 
    0.17000049f, 0.03060660f, -0.25055444f, -0.09100854f, 0.01644564f, -0.00506112f, 0.09166477f, 0.12469070f, 
    0.09467139f, -0.09832376f, 0.18855153f, 0.04761223f, -0.17685151f, 0.44110489f, 0.01004944f, 0.26962307f, 
    0.20082612f, 0.06063990f, -0.15615739f, 0.00853779f, 0.09539802f, 0.21124113f, -0.16369556f, -0.13494311f, 
    -0.02216247f, 0.02156594f, 0.07677834f, -0.05680841f, -0.06396221f, -0.00799173f, 0.17785297f, 0.10083959f, 
    0.70066267f, -0.22386326f, 0.58290559f, -0.28918108f, -0.00473164f, 0.11451869f, -0.43391934f, 0.14746596f, 
    -0.13231027f, 0.05047566f, -0.16216885f, 0.04982176f, -0.04505532f, 0.06099181f, 0.09414225f, -0.05429616f, 
    -0.07103097f, -0.03527561f, -0.07629132f, -0.06611406f, -0.34565407f, -0.00522331f, -0.35452318f, 0.06165553f, 
    0.05624678f, -0.03115094f, -0.06656501f, 0.09522123f, 0.09413761f, -0.05615044f, 0.02408909f, 0.11530205f, 
    0.00857717f, 0.05021043f, 0.00744422f, 0.06411362f, -0.22905432f, -0.26081473f, -0.10643544f, -0.24560456f, 
    -0.43315643f, 0.18193406f, -0.22604358f, 0.03488664f, 0.04411491f, 0.09825793f, -0.03534295f, -0.06673559f, 
    0.21792801f, 0.20363452f, 0.02248361f, -0.12498431f, 0.04671692f, 0.07926486f, -0.02700013f, -0.09293498f, 
    0.17261362f, -0.36285409f, 0.14973596f, 0.05909996f, 0.07113776f, -0.00142689f, -0.38260800f, -0.00644278f, 
    -0.03778371f, -0.03188071f, -0.31565198f, 0.18577935f, -0.29281998f, -0.03995420f, 0.02647103f, 0.03533068f, 
    -0.05466922f, 0.00772313f, -0.01512267f, 0.07451786f, -0.27107352f, 0.00656327f, -0.33089381f, -0.15326068f, 
    0.11460567f, -0.00835390f, -0.08881608f, 0.02472933f, -0.40356863f, -0.08175943f, 0.01285639f, -0.10868657f, 
    -0.07556078f, 0.01444625f, -0.00304319f, 0.07584627f, 0.20681937f, 0.15391569f, -0.12009530f, 0.03430364f, 
    -0.03723786f, 0.09019180f, 0.13862431f, 0.01477329f, 0.01216246f, -0.27775431f, -0.06468847f, 0.06395066f, 
    0.11478283f, -0.20809877f, -0.40247169f, -0.05149998f, -0.07238616f, -0.16571826f, 0.07425015f, -0.00580370f, 
    0.03378163f, 0.09485672f, -0.02495976f, 0.04433661f, -0.11905362f, -0.04817705f, 0.16974811f, 0.03100199f, 
    -0.24702460f, -0.35444012f, -0.16168082f, -0.19934569f, 0.09247422f, 0.05541387f, 0.04947257f, 0.02566179f, 
    -0.01612235f, 0.08691456f, 0.01219001f, 0.08755337f, 0.12601213f, -0.03239688f, 0.07883599f, 0.21215205f, 
    -0.06708248f, -0.00123774f, 0.19429141f, 0.07859679f, 0.17651674f, 0.01909494f, -0.04879031f, -0.14492330f, 
    -0.35351360f, 0.06095725f, -0.05253416f, -0.03394667f, 0.07566901f, -0.04387307f, 0.00957889f, -0.03100932f, 
    0.06574757f, 0.06308061f, 0.04684057f, 0.07563808f, 0.03564418f, 0.04250328f, 0.07457266f, 0.03753675f, 
    -0.16069891f, -0.31184119f, -0.23606241f, -0.29033610f, -0.01604198f, -0.09468999f, -0.32802662f, 0.13286328f, 
    -0.12795566f, -0.01799837f, 0.02086721f, 0.03423387f, 0.07212388f, -0.06510387f, -0.06954768f, 0.07946430f, 
    -0.01228065f, -0.11420283f, -0.01830911f, 0.14089815f, 0.37787756f, 0.15160866f, 0.30192128f, 0.26171368f, 
    -0.04467532f, -0.01711765f, 0.20373414f, -0.11541600f, -0.02174661f, 0.07083390f, -0.18037148f, 0.07866866f, 
    0.00416840f, 0.10017113f, 0.03014159f, 0.00746135f, 0.05481133f, -0.11346185f, -0.01956073f, 0.14527349f, 
    0.09086976f, -0.24197437f, -0.16549060f, -0.29678851f, -0.02194748f, 0.01740455f, -0.16070648f, 0.07053555f, 
    -0.18495418f, -0.08120774f, -0.00835046f, 0.03218329f, 0.09805551f, -0.05215364f, -0.10138799f, 0.02230559f, 
    -0.07660254f, 0.02719282f, -0.01026932f, -0.02398776f, 0.05853628f, -0.02192238f, -0.03918579f, -0.06228001f, 
    0.10978577f, 0.01807114f, 0.05138297f, -0.02598324f, -0.08128360f, -0.20950992f, 0.02473944f, 0.08021270f, 
    0.04247154f, -0.00245210f, 0.01033020f, 0.00085114f, -0.15026984f, -0.05807806f, -0.26809821f, 0.00251572f, 
    -0.35928300f, -0.19581518f, -0.30522308f, -0.13336475f, 0.03886239f, 0.03814872f, 0.06158488f, 0.01186594f, 
    -0.12658846f, -0.07319408f, -0.11227086f, -0.07757285f, 0.05435731f, 0.12674949f, -0.06100350f, 0.02346775f, 
    0.04971300f, 0.06642874f, -0.06573960f, -0.11563230f, -0.21325110f, -0.00965069f, -0.31731275f, 0.22160140f, 
    -0.22238939f, 0.13105494f, -0.08932536f, -0.00512058f, -0.10577764f, -0.09107164f, -0.03665388f, -0.01842907f, 
    -0.05527157f, -0.01535076f, -0.11447817f, 0.03656421f, -0.09643652f, -0.01199145f, -0.03367285f, 0.00278290f, 
    0.34429571f, -0.29226190f, 0.20772557f, 0.42339027f, 0.30567101f, -0.03897580f, 0.23319316f, -0.16608910f, 
    0.19349104f, 0.15611808f, 0.06936748f, 0.19897923f, -0.03474903f, 0.10225917f, 0.07925670f, -0.11301004f, 
    0.10551548f, 0.07288652f, 0.10159870f, -0.05954601f, -0.09131781f, -0.20640323f, -0.24166249f, 0.20234123f, 
    -0.28406468f, -0.08713090f, -0.43032134f, -0.03714400f, -0.28166956f, 0.02553375f, 0.02552012f, -0.04783336f, 
    -0.00148101f, -0.09317140f, -0.14120767f, 0.01348686f, -0.07426475f, 0.01955090f, -0.04183065f, -0.06825503f, 
    -0.41527915f, -0.13297731f, -0.50743032f, 0.21019179f, -0.28432098f, -0.00900327f, -0.08777144f, -0.01332522f, 
    0.01713855f, 0.01436342f, -0.02529678f, -0.11023022f, -0.06395776f, -0.20494254f, -0.04198188f, 0.03727453f, 
    -0.04408510f, -0.08639538f, -0.06460285f, 0.00022757f, -0.13998407f, 0.22867894f, -0.04694506f, 0.19246623f, 
    0.07859734f, -0.14485736f, 0.03442516f, -0.12352779f, 0.18791111f, 0.15763970f, 0.05902967f, 0.03737409f, 
    0.08289846f, -0.09787981f, 0.04113422f, 0.03871464f, -0.14933547f, 0.12980732f, 0.05821729f, 0.05170476f, 
    0.29785612f, 0.24426745f, 0.34392443f, -0.10431880f, -0.22124717f, -0.01696880f, 0.14426354f, 0.07798748f, 
    -0.07103873f, -0.00163903f, -0.12524517f, 0.03471709f, 0.03641394f, 0.09123271f, 0.02852706f, -0.15637319f, 
    0.03113564f, 0.11826608f, 0.02653395f, -0.20263939f, -0.11486255f, 0.02632434f, -0.24555983f, 0.11962980f, 
    -0.00314428f, -0.08626352f, -0.16956337f, 0.02527978f, -0.09415261f, -0.15589732f, 0.00904919f, 0.12380849f, 
    -0.04896007f, -0.03420637f, -0.07742973f, -0.03142175f, -0.16230117f, -0.06736462f, -0.24486497f, -0.11883844f, 
    -0.26088527f, -0.11738416f, -0.10152687f, 0.29427254f, 0.03858228f, -0.09291086f, -0.04468147f, 0.04303106f, 
    -0.04489861f, 0.06678203f, -0.05347902f, -0.03170200f, -0.15405752f, -0.05758866f, -0.02798958f, -0.00709006f, 
    -0.09533346f, -0.04811943f, -0.06075070f, -0.20583083f, 0.44907689f, 0.10913260f, 0.53350466f, -0.17263754f, 
    0.04259720f, 0.09751199f, -0.02527729f, -0.04895540f, 0.07093021f, -0.04454426f, -0.10766695f, -0.00196504f, 
    0.04708740f, -0.00536936f, -0.07680546f, -0.03106474f, 0.09754072f, 0.03885968f, -0.10486203f, 0.23166710f, 
    0.10461471f, -0.06754351f, -0.06483578f, -0.06504676f, -0.32894960f, -0.09299750f, -0.28370157f, -0.01147498f, 
    -0.13383503f, 0.03484422f, 0.02347494f, 0.15482077f, 0.17671652f, -0.05169557f, -0.11834980f, 0.06495374f, 
    -0.06548318f, 0.10165957f, 0.07192677f, -0.03079171f, 0.40034762f, -0.22664566f, 0.16297086f, -0.02250101f, 
    -0.35603711f, 0.02583631f, -0.08051672f, -0.01731576f, 0.01104802f, -0.07905839f, -0.02964586f, -0.02349695f, 
    0.01458032f, -0.06811513f, -0.16468324f, 0.15539941f, 0.14047332f, 0.09938075f, -0.05660566f, -0.15682231f, 
    -0.28833893f, -0.00924528f, -0.47093236f, 0.29921377f, 0.20225225f, -0.08914305f, 0.07449822f, 0.03620287f, 
    0.16883054f, -0.16898769f, -0.07207169f, 0.05919327f, -0.01044857f, -0.05740783f, 0.11322165f, 0.22355442f, 
    -0.00795038f, 0.10115883f, 0.21061677f, 0.20564300f, 0.04153640f, 0.11043142f, -0.04059131f, 0.19533707f, 
    -0.08540756f, -0.10141445f, 0.13360912f, 0.06630381f, 0.13653670f, 0.01528976f, -0.16977283f, -0.01236252f, 
    0.03641905f, 0.06307463f, -0.04540147f, 0.03022624f, -0.03499373f, -0.01497856f, -0.13928711f, -0.05452137f, 
    -1.06515336f, 0.32198155f, -0.75508034f, 0.28591660f, -0.63709050f, 0.22394621f, 0.14270233f, 0.07633346f, 
    -0.00243862f, 0.09616068f, -0.25799939f, -0.17260152f, 0.10001480f, 0.09786116f, 0.00164149f, 0.05261993f, 
    -0.03754034f, 0.03663951f, -0.05321695f, 0.16669950f, 0.43075332f, -0.93328625f, 0.65233362f, -0.25765845f, 
    0.18640040f, 0.04164521f, -0.25468907f, -0.23776171f, 0.36538094f, -0.07403800f, 0.10639984f, 0.03350375f, 
    -0.06712302f, 0.11518832f, 0.01001812f, -0.01572291f, 0.13488145f, 0.06539252f, 0.23186913f, -0.08445812f, 
    -0.92428273f, -0.36738747f, -0.15534203f, 0.16632800f, 0.37361440f, 0.12097197f, -0.05610547f, -0.07814779f, 
    0.03044208f, 0.18743905f, -0.08366042f, 0.01638749f, -0.27601594f, -0.00791963f, -0.01221758f, 0.09172001f, 
    -0.14390613f, -0.04077405f, 0.06682381f, 0.03334961f, 0.01709029f, -0.14706860f, -0.14094162f, 0.01039042f, 
    0.15231074f, 0.12706114f, 0.20335382f, -0.09090385f, 0.06260198f, -0.07358979f, -0.07375652f, 0.11724108f, 
    0.06135809f, -0.06728929f, 0.03127203f, 0.00633815f, -0.03149974f, -0.10649084f, -0.10798366f, -0.07461339f, 
    0.26756278f, 0.09372952f, 0.16226213f, 0.21978238f, -0.08957426f, 0.00567225f, 0.18814075f, -0.01729017f, 
    0.17162092f, -0.27627516f, -0.14724346f, -0.01384945f, 0.10858384f, 0.00176533f, 0.04564739f, 0.07811792f, 
    -0.06496461f, 0.07369132f, -0.02601339f, -0.07753209f, -0.84325480f, -0.15494220f, -0.48115748f, 0.51658911f, 
    -0.14375906f, -0.09473926f, 0.20921041f, 0.04850081f, 0.37324014f, 0.00923862f, -0.11014422f, -0.00263193f, 
    -0.07146806f, 0.03423019f, -0.00976493f, -0.01432262f, 0.01895232f, 0.08912962f, -0.07823719f, 0.08620960f, 
    -1.00512230f, -0.52863854f, -0.41805395f, 0.13981737f, 0.60599595f, 0.12300771f, 0.17557648f, 0.24046670f, 
    -0.39878535f, 0.21535973f, -0.10072614f, 0.22519898f, 0.05568306f, 0.04983370f, 0.03243450f, -0.06428068f, 
    0.06177855f, 0.18205686f, 0.13377385f, 0.08081790f, 0.17700654f, -0.09513021f, 0.14757758f, 0.04545580f, 
    -0.05736918f, 0.07900096f, -0.26407671f, 0.18934569f, -0.04890917f, -0.25582325f, -0.07495856f, 0.01492252f, 
    0.02028701f, 0.00355599f, 0.05076627f, 0.03470524f, -0.15473242f, 0.11326163f, 0.04316870f, -0.12450244f, 
    -0.17523971f, -0.09203646f, 0.02855718f, 0.35948777f, -0.14717236f, -0.12181863f, -0.10257041f, 0.12746362f, 
    0.18557353f, -0.00863434f, 0.01102185f, -0.00419966f, -0.10422487f, -0.11946885f, 0.15137284f, 0.04462561f, 
    -0.09430889f, 0.15777938f, 0.05711612f, -0.36589980f, 0.49676198f, -0.32214782f, 0.38344759f, 0.10393768f, 
    -0.04349747f, -0.04088121f, -0.17633206f, -0.34333706f, 0.08678272f, -0.09872842f, -0.08388222f, 0.05445623f, 
    0.06896120f, -0.01951959f, -0.03325775f, -0.03910234f, -0.03452157f, -0.03907720f, 0.16924070f, 0.04722206f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18275411f, 0.11361877f, 0.05452340f, -0.13274492f, -0.08860724f, 0.05456362f, 0.06400954f, -0.08896961f, 
    0.01114955f, 0.07909922f, -0.02883146f, -0.04594707f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
