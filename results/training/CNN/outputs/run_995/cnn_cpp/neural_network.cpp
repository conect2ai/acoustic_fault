#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.10765576f, 0.11886459f, 0.42100966f, 0.14971264f, -0.06113391f, 0.16404134f, 0.39080164f, 0.05014332f, 
    -0.11378291f, -0.21189862f, -0.03811827f, -0.09159355f, 0.01196117f, 0.24563216f, 0.29626176f, -0.14350352f, 
    -0.25047702f, -0.02863033f, -0.17211629f, 0.15192629f, 0.20943856f, 0.33007437f, 0.37069723f, -0.39547002f, 
    -0.68611687f, -0.93341386f, -0.61282873f, 0.35654038f, 0.32089597f, 0.10645013f, 1.04612613f, 0.21024129f, 
    -0.60718721f, 0.26533347f, 0.89933532f, 0.48347721f, -0.40015385f, 0.24412034f, -0.44276524f, -0.44868720f, 
    -0.11820029f, -0.01942951f, -0.19491991f, -0.19201028f, -0.03781221f, -0.15389788f, -0.04948341f, -0.03294619f, 
    0.35353020f, -0.14143918f, -0.69217056f, -0.81797427f, -0.80536336f, 0.46730310f, 0.27599972f, 0.58448899f, 
    0.18047543f, -0.32905531f, -0.22320884f, 0.69673276f, -0.14438671f, -0.48039261f, -0.52109516f, 0.03548061f, 
    0.38340151f, -0.06888399f, -0.07664743f, -0.39366287f, -0.25499400f, -0.84751785f, -0.39897934f, -0.45159549f, 
    -0.69022155f, -0.69285053f, -0.77815998f, -1.73005915f, -0.27238432f, -0.83000284f, -1.43430686f, -1.02296317f, 
    0.59573382f, 0.16120845f, -0.31668144f, 0.12062513f, 0.57832032f, -0.27143803f, -0.60675603f, -0.33142862f, 
    -0.37639907f, -0.20045325f, 0.17425540f, 0.17905870f, -0.04076952f, 0.14139871f, -0.03218781f, -0.14545973f, 
    -0.10124297f, 0.06060504f, -0.28099614f, -0.33642089f, -1.63519323f, 0.67485291f, 0.52624798f, -1.03560865f, 
    -0.12759642f, -0.35549760f, 0.42255223f, 0.72731727f, 1.02504683f, 0.53888202f, -0.41051808f, -0.24407630f, 
    -0.15480202f, -0.24295507f, 0.14467798f, 0.17469281f, -0.20974411f, -0.33000001f, 0.04978496f, 0.14306514f, 
    -0.15222402f, 0.05559441f, 0.42657772f, -0.24812686f, 0.00407175f, -0.05403913f, -0.60140097f, -0.49374524f, 
    -0.69687301f, -0.63216817f, -0.11151826f, -0.21615979f, 0.23132153f, -0.21629141f, -0.48500985f, 0.07213815f, 
    0.20976417f, 0.52088046f, 0.92112815f, 0.21403016f, 0.11302818f, -0.18692790f, 0.30721346f, 0.05430808f, 
    -0.11704648f, 0.09735893f, -0.04359610f, 0.12050407f, 0.23905180f, -0.26105365f, -0.16051482f, -0.69911265f, 
    0.13498414f, 1.11988378f, 0.61049181f, -0.36372328f, -1.02730882f, -0.77392220f, 0.51651019f, -0.16455679f, 
    0.29764384f, -0.18714145f, 0.50061655f, 0.57748878f, -0.44757622f, -0.51634556f, -0.02392355f, 0.00634497f, 
    0.19838341f, -0.13622108f, 0.38601023f, -0.22937797f, -0.07117635f, 0.33894461f, 0.35810629f, -0.61866874f, 
    -1.23536491f, -1.17628193f, -0.32518595f, 0.46467414f, -0.84826058f, -0.75532305f, -1.18497634f, -0.96614635f, 
    -0.73699135f, -0.25466254f, -0.12489494f, 0.46037301f, -0.17495443f, -0.56506908f, -0.10358672f, -0.48134911f, 
    -0.40991423f, -0.05658655f, 0.19813262f, 0.26194730f, -0.46329993f, -0.36247560f, 0.05313199f, -0.07378750f, 
    -0.90062290f, -0.10886132f, -0.92139804f, -0.50182974f, 0.37526315f, 0.53922397f, 0.74461216f, 0.77832222f, 
    -0.35790196f, -0.33154377f, 0.32312134f, 0.43436298f, 0.19327179f, -0.09333726f, -0.16724899f, 0.09416679f, 
    -0.04506972f, 0.02543554f, -0.30660442f, -0.21743508f, -0.03492093f, -0.32075712f, -0.48187262f, 0.31992471f, 
    -0.01067372f, 0.44473213f, 0.34047201f, 0.21092251f, 0.00110924f, -0.49206603f, -0.17073686f, 0.37756041f, 
    0.31806642f, -0.01156226f, 0.16221936f, 0.07802284f, 0.03833744f, -0.04918085f, 0.16713804f, 0.32970491f, 
    0.20214295f, 0.35097435f, -0.11112113f, -0.24074796f, 0.42517495f, -0.27859357f, -0.13836527f, 0.26448858f, 
    0.33876136f, 0.01293068f, 0.64156628f, 1.21621585f, 0.88411385f, 0.25838691f, 0.04869251f, -0.36328790f, 
    -0.49575844f, -0.29649740f, -0.08503338f, -0.27905574f, -0.22200868f, -0.26882678f, -0.11480238f, -0.15150185f, 
    -0.62501353f, -0.11730613f, 0.35412136f, 0.00283697f, -0.18706656f, -0.12366160f, 0.00702915f, 0.03747252f, 
    -0.15690485f, -0.16697398f, -0.38455355f, -1.13153291f, -0.41482297f, -0.71150154f, 0.17775242f, 0.47117087f, 
    -0.87665904f, -0.28054887f, -0.23460227f, -0.42892483f, -0.06742806f, 0.13151869f, -0.82425821f, -0.14068344f, 
    0.86174756f, -0.61684591f, 0.05166285f, -0.04494321f, -0.55267692f, -0.55524737f, -0.78591561f, 0.14347769f, 
    0.12730592f, 0.30029589f, 0.38935757f, 0.21616039f, 1.32694781f, -1.41127515f, -1.49632812f, -1.09295917f, 
    -1.37181282f, 1.03287733f, 0.26300156f, 0.56521577f, 0.42779639f, 0.25966534f, 0.44522482f, -0.10064605f, 
    -0.39481884f, -0.33777380f, -0.01781229f, -0.52910072f, -0.23913535f, 0.33114824f, -0.41272989f, -0.57873201f, 
    -0.20227103f, -0.24027680f, -0.04846800f, 0.21774291f, 0.25804320f, 0.20402783f, -0.15711120f, 0.81871253f, 
    -1.15471470f, -0.77711254f, 0.81663609f, 0.20380257f, -0.68203676f, -0.60406148f, 0.60690099f, 0.28562918f, 
    -0.19005066f, -0.02362079f, 0.30313843f, -0.01352317f, 0.17118728f, 0.02211925f, 0.07763220f, 0.19058304f, 
    -0.50173259f, 0.03644929f, 0.05975636f, 0.20136628f, -0.15884034f, 0.28152168f, 0.51122898f, 1.01270604f, 
    0.39487976f, 0.05579318f, -0.41862911f, -0.81964713f, -0.61684483f, 0.06414309f, 0.16652863f, -0.38465643f, 
    -0.26583633f, 0.12945104f, 0.23054153f, 0.82413846f, -0.66354263f, 0.14187165f, 0.03224414f, -0.04008736f, 
    0.38263813f, -0.09499743f, -0.07817202f, 0.16100673f, 0.11126032f, -0.24479242f, 0.46789533f, -0.66875458f, 
    0.74090445f, 0.52873379f, 0.10831524f, -0.33843893f, -0.46665379f, -0.13403501f, -0.52049291f, -0.50394529f, 
    -0.38917714f, 0.42091548f, -0.30328315f, 0.70576310f, -0.17853415f, 0.11612476f, -0.19721305f, -0.19807607f, 
    -0.38034725f, 0.24563235f, 0.67674696f, -0.27939388f, -0.07910148f, -0.08928604f, 0.00131359f, -0.04497324f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.38865551f, 0.52544248f, -0.11521681f, -0.39763680f, 0.47468543f, 0.52794987f, 0.41369289f, 0.16563210f, 
    0.27777568f, 0.41605979f, 0.36005938f, 0.08370927f, 0.42368737f, 0.63383955f, 0.72933984f, 0.34894705f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.27830258f, -0.44727474f, -0.13983330f, 0.07164116f, 0.02970850f, -0.01976637f, 0.05944616f, -0.00129880f, 
    0.12256929f, 0.11639814f, 0.14893405f, -0.02709748f, 0.62537652f, 0.12027258f, 0.05383357f, -0.26683813f, 
    -0.07568494f, -0.06066544f, 0.12610273f, 0.08381428f, -0.13803583f, 0.10515177f, 0.04878575f, -0.15048204f, 
    0.13128881f, 0.07686660f, -0.16175562f, -0.05905406f, -0.08329894f, -0.00711951f, 0.02097088f, -0.00087154f, 
    -0.16306324f, 0.01777519f, 0.22968766f, 0.31730789f, 0.44549218f, 0.36856219f, -0.15889929f, -0.23115885f, 
    0.20732507f, 0.40720412f, 0.03214814f, 0.30511153f, 0.01495761f, 0.14561373f, 0.05403319f, -0.00659079f, 
    -1.30834281f, -0.59643245f, 0.49622288f, -0.17404330f, 0.00654588f, 0.08810160f, 0.06585366f, 0.13829513f, 
    -0.06409378f, -0.13864478f, -0.01330337f, -0.27019295f, 0.52922523f, 0.17076665f, -0.00402711f, -0.00929223f, 
    -0.02583476f, 0.09532911f, -0.20119317f, -0.15055431f, 0.01437831f, 0.06436472f, -0.08490685f, 0.08962519f, 
    -0.33223087f, 0.36283118f, 0.41284314f, -0.54058099f, 0.15999778f, -0.10619565f, -0.18772250f, 0.14076211f, 
    0.07371073f, -0.07300667f, -0.00085722f, -0.01834080f, 0.70353353f, 0.34049901f, -0.20709527f, -0.25519943f, 
    0.22122493f, 0.04337616f, 0.05625530f, -0.27496001f, -0.06681969f, -0.18612406f, -0.04056282f, -0.06589067f, 
    0.12984411f, -0.13322751f, -0.39375666f, 0.17663367f, 0.05092887f, 0.15285982f, 0.02320026f, 0.02408849f, 
    -0.03023303f, -0.25776896f, -0.14438497f, 0.02036928f, 0.00962086f, -0.06007145f, 0.09499506f, 0.01585212f, 
    -0.07082541f, -0.10541208f, 0.04527568f, 0.04877857f, -0.42936209f, -0.10565773f, -0.20793539f, -0.17804706f, 
    -0.87731272f, 0.23468627f, -0.03946414f, 0.22542611f, -0.00604117f, -0.03421596f, 0.01025260f, 0.15304534f, 
    -0.02104353f, 0.01002178f, 0.05122729f, 0.09662585f, 0.30020389f, 0.47610623f, 0.22869235f, -0.47875601f, 
    0.06624602f, 0.16890313f, -0.03229854f, -0.13139455f, -0.07391682f, -0.19205512f, -0.12037798f, -0.27521238f, 
    0.23419841f, -0.37110618f, -0.36740738f, -0.02975908f, 0.23037775f, 0.12056480f, -0.37518504f, -0.27798903f, 
    -0.14587818f, -0.06567602f, -0.26529825f, 0.02248337f, 0.13833313f, -0.34461752f, -0.62505150f, -0.09969037f, 
    -0.24006024f, 0.11927222f, -0.07283875f, -0.16173607f, -0.11773293f, -0.17135680f, -0.05486510f, -0.03961456f, 
    -0.07242236f, -0.06655990f, 0.05966252f, -0.05744013f, -0.20717049f, -0.27181000f, -0.16013853f, -0.18491757f, 
    -0.10260796f, -0.02139643f, -0.10009740f, -0.09869340f, 0.28504622f, 0.10862798f, -0.25484589f, -0.16274121f, 
    -0.24335563f, -0.30210227f, -0.15008792f, -0.23162755f, -0.00255237f, -0.01907415f, -0.01095440f, -0.17559360f, 
    0.36638674f, 0.20110968f, -0.00242460f, 0.17957765f, -0.10904478f, -0.13381535f, -0.15744901f, 0.03033384f, 
    -0.14403474f, 0.01332891f, 0.10292570f, -0.00270101f, 0.59151101f, 0.44971654f, -0.09557987f, -0.01512388f, 
    -0.06342290f, -0.00311185f, 0.02408745f, -0.09634069f, -0.06847683f, -0.03052992f, -0.15052997f, 0.17512652f, 
    -0.33432418f, 0.13448802f, -0.09744627f, 0.02653607f, 0.04826637f, 0.00761670f, -0.13756399f, 0.03338457f, 
    -0.26027605f, -0.45318389f, -0.39880255f, -0.65298158f, 0.39263204f, 0.56046599f, 0.27991226f, 0.04194880f, 
    0.07763728f, -0.10038605f, -0.40805361f, -0.26412722f, -0.02360455f, 0.03307229f, -0.15079993f, -0.26258153f, 
    -0.79031730f, 0.16913562f, 0.27719125f, -0.06396263f, 0.03338635f, 0.06692646f, -0.11700172f, -0.13174769f, 
    0.00898105f, 0.24673536f, -0.23178628f, 0.06414992f, -0.24803360f, -0.20893638f, 0.20065981f, 0.03438341f, 
    -0.00943866f, 0.22915174f, 0.17399070f, 0.07306696f, -0.15094461f, -0.08248038f, 0.09253616f, 0.05538632f, 
    -0.68420196f, 0.55701756f, -0.19873254f, 0.07721972f, 0.12921050f, -0.10519107f, 0.06819868f, -0.21589302f, 
    0.00503915f, -0.08729767f, -0.00502469f, 0.02236102f, -0.11679702f, -0.03176494f, -0.06814293f, 0.45396048f, 
    0.10467035f, -0.02067400f, 0.20490637f, -0.12364924f, 0.10881382f, -0.02198112f, 0.02698319f, 0.08933350f, 
    0.01616303f, -0.98073757f, -0.01980189f, -0.04553464f, -0.07212549f, 0.12217139f, 0.12256261f, -0.08976412f, 
    0.12673372f, -0.12711675f, 0.01485521f, 0.17304766f, 0.09588818f, 0.07266887f, 0.05259153f, 0.10159904f, 
    -0.10424198f, 0.00489260f, 0.19922826f, -0.01167791f, 0.23363943f, 0.19002309f, -0.02520601f, -0.01944210f, 
    0.35246411f, 0.39258313f, 0.02934274f, 0.08454038f, -0.07157997f, -0.00330817f, -0.05739612f, 0.04454510f, 
    -0.03805187f, -0.00760311f, -0.01671617f, 0.00822810f, -0.36993405f, -0.34111449f, 0.34211707f, 0.05236447f, 
    0.15297404f, -0.00350399f, 0.42392305f, -0.07748324f, 0.10751181f, -0.13124441f, 0.17156991f, -0.19669008f, 
    0.61673617f, -0.08086456f, -0.52228242f, -0.60967290f, -0.11625147f, 0.17378220f, 0.17026228f, -0.00254970f, 
    0.26866889f, 0.02768857f, -0.19694313f, -0.01252493f, 0.45134783f, -0.47686139f, 0.14083198f, -0.04053807f, 
    0.19592315f, 0.10708952f, -0.23774500f, 0.26004958f, -0.07553408f, -0.20859599f, 0.03242974f, -0.18017842f, 
    0.07042230f, -0.11194766f, 0.00973587f, -0.12600410f, 0.05193178f, -0.02087704f, -0.16583264f, -0.19711560f, 
    -0.03621492f, -0.13494553f, 0.03628931f, 0.05738151f, 0.00737085f, 0.02096366f, -0.15493868f, -0.40902278f, 
    -0.42344499f, -0.01952437f, -0.22843249f, -0.04178279f, -0.15541522f, 0.05026506f, 0.12482923f, 0.15790853f, 
    -0.14100450f, 0.12172345f, -0.04194203f, -0.19878830f, 0.02055292f, -0.15992582f, 0.08723906f, 0.01683704f, 
    0.00732375f, 0.00781550f, 0.02263077f, 0.22125813f, -0.14687991f, -0.47138530f, -0.09752312f, 0.30919155f, 
    0.14981999f, -0.09774623f, -0.03886107f, -0.00797815f, 0.01855529f, -0.14670697f, 0.09703853f, 0.07686090f, 
    -0.06358497f, -0.24863985f, 0.37993947f, 0.04054551f, 0.00369616f, 0.03236225f, 0.03170828f, -0.02642257f, 
    0.11684638f, 0.17406240f, -0.04602287f, 0.09483249f, -0.08548635f, 0.71498030f, 0.77780819f, 0.71345472f, 
    -0.25198522f, -0.16492659f, 0.02069767f, -0.09620539f, 0.04363007f, 0.07844304f, -0.08278386f, 0.03124307f, 
    0.18702672f, 0.14629790f, -0.10295689f, 0.23150724f, 0.07975905f, 0.13609949f, -0.08585031f, -0.01333574f, 
    -0.08465166f, -0.02602650f, -0.07772327f, 0.10229678f, -0.12770973f, -0.18971963f, 0.09310780f, 0.24052583f, 
    -0.28735748f, -0.33207184f, 0.49099985f, -0.27117878f, 0.12225723f, -0.02786132f, 0.07057289f, -0.03514646f, 
    -0.74607646f, 0.27328244f, -0.58810145f, -0.08531715f, -0.04691613f, 0.07126494f, 0.01267987f, 0.37419769f, 
    -0.09927982f, -0.02605722f, 0.21660639f, -0.14001760f, -0.49860865f, -1.02234125f, -0.57776248f, -0.25992054f, 
    0.05996620f, 0.06403522f, 0.36547208f, 0.08274964f, -0.04351920f, -0.04115059f, 0.00473463f, -0.10655775f, 
    0.28315178f, -0.30024111f, 0.46008235f, -0.07839042f, -0.01429511f, -0.10547408f, 0.15087162f, 0.03419168f, 
    0.09416393f, -0.20558144f, 0.05104581f, -0.06395585f, -0.26880744f, -0.06304974f, 0.02257990f, -0.03185686f, 
    -0.00167185f, -0.06591201f, -0.00571711f, -0.03236060f, -0.15380976f, -0.10854091f, 0.08522655f, 0.04306054f, 
    -0.56578857f, 0.38601729f, 0.40636927f, -0.63997257f, 0.05908909f, -0.09347839f, -0.03948077f, 0.12489047f, 
    0.07908704f, -0.02378709f, 0.00423154f, 0.00977729f, 0.12689023f, -0.75780541f, -0.19719985f, -0.21110496f, 
    0.18073575f, 0.01632089f, -0.05596373f, -0.13183302f, -0.11681762f, -0.30557159f, 0.00162257f, -0.02688977f, 
    -0.60813075f, 1.08431780f, 0.42694330f, -0.66123646f, -0.13600823f, -0.06189538f, 0.09344474f, -0.42699513f, 
    -0.10610420f, 0.13073376f, -0.12978469f, 0.01316915f, 0.15653135f, 0.08780270f, 0.40223861f, 0.10878905f, 
    0.20761013f, 0.00431837f, -0.44227314f, 0.49472114f, 0.19037786f, -0.16407953f, 0.09940425f, 0.09195823f, 
    -0.22675365f, -0.24179171f, 0.08367240f, 0.00554247f, -0.29950571f, 0.05121942f, -0.15523812f, 0.21599574f, 
    0.07853620f, -0.08320706f, 0.01030480f, -0.00185973f, 0.04840800f, 0.05469452f, 0.09521136f, -0.52977079f, 
    0.46492577f, -0.05098220f, -0.37590235f, -0.13831244f, -0.07220220f, 0.26919663f, 0.00276444f, -0.08609130f, 
    -0.95211065f, -0.43812373f, -0.20879559f, -0.08656666f, -0.04403749f, 0.23852250f, -0.23435539f, -0.08226676f, 
    0.08322597f, -0.19394085f, -0.05915273f, -0.02333389f, -0.89173520f, -0.15210254f, -0.19292118f, -0.90303391f, 
    0.17078148f, 0.54231817f, -0.03268101f, -0.04940393f, -0.11171516f, -0.03376886f, 0.00036954f, -0.14442785f, 
    0.06397140f, 0.06870626f, -0.33244208f, 0.05259513f, 0.03678409f, -0.04526538f, -0.11971715f, -0.08430120f, 
    -0.05463450f, 0.13918023f, 0.00806481f, -0.06528814f, 0.64597332f, -0.46691865f, 0.06502759f, 0.47781065f, 
    0.27969360f, -0.00121011f, 0.18821423f, -0.18549028f, -0.00818422f, 0.03609595f, 0.21074274f, 0.29081148f, 
    2.04660988f, 0.09728633f, 0.03007277f, -0.19061165f, 0.27470478f, 0.21072975f, -0.09751064f, 0.04146101f, 
    -0.20950694f, -0.19838494f, -0.03037506f, 0.08679066f, -0.16353174f, -0.50548232f, -0.30485782f, 0.41278580f, 
    -0.01664220f, 0.17513157f, 0.17684126f, 0.15666793f, 0.02968355f, -0.05583974f, 0.23473631f, -0.20851615f, 
    -0.02529480f, -0.05278958f, -0.20773616f, -0.10333186f, 0.07387143f, -0.14984690f, 0.00094054f, -0.16272978f, 
    -0.15632720f, 0.00465884f, -0.02716566f, -0.06188860f, -0.11979807f, 0.05755512f, -0.24823080f, 0.17794058f, 
    0.17840059f, -0.05083962f, 0.03163571f, 0.14231546f, -0.15733352f, -0.06729318f, -0.17670920f, -0.09716378f, 
    -0.09831282f, 0.23478459f, -0.46971315f, 0.16855174f, 0.33224726f, -0.23598903f, 0.14019901f, -0.18471508f, 
    -0.15564108f, -0.07589091f, -0.13211767f, -0.14996496f, -0.26266077f, -0.04753613f, -0.01504450f, -0.05928865f, 
    0.02753700f, -0.49373510f, -0.09010682f, -0.08833810f, 0.03642621f, -0.02975676f, -0.10189153f, -0.11319269f, 
    -0.36357781f, -0.23467192f, 0.93142045f, 0.24238139f, -0.28312165f, 0.00360410f, -0.03567357f, 0.10279320f, 
    0.05890965f, 0.31343386f, -0.02656141f, 0.27737615f, 0.22849509f, -0.07059811f, -0.30548716f, 0.00519913f, 
    -0.00079549f, 0.04414922f, -0.01844544f, -0.09759156f, -0.17897746f, -0.01526786f, -0.03656250f, -0.02837840f, 
    -0.56627607f, -0.02638207f, 0.09497795f, 0.49711630f, 0.19468284f, 0.00122225f, 0.02984029f, -0.17511904f, 
    -0.08627759f, 0.02060285f, 0.08290414f, 0.14509420f, -0.33370903f, -0.25107315f, -0.06761456f, 0.50447237f, 
    0.00483245f, 0.06897919f, -0.26037267f, -0.12745464f, -0.23930614f, -0.12779605f, -0.01317638f, 0.02848844f, 
    0.22431752f, -0.51629817f, 0.57125050f, -0.19626483f, -0.03134707f, 0.24452823f, -0.34145358f, -0.20036250f, 
    -0.07661071f, 0.10526443f, 0.04760754f, -0.36072114f, 0.07152700f, -0.08060686f, 0.39544460f, -0.16025232f, 
    0.06945806f, -0.06089241f, 0.00089631f, -0.16835508f, 0.07761158f, -0.21164347f, 0.13880822f, -0.15591927f, 
    -0.18264997f, -0.08884031f, -0.09319818f, -0.01954750f, 0.08198380f, 0.08549244f, 0.05095672f, -0.06242517f, 
    0.19828008f, 0.02151379f, 0.09474242f, 0.11373292f, 0.59369290f, 0.04699668f, -0.57740015f, -0.06166246f, 
    -0.06839685f, 0.02178487f, 0.20510358f, -0.17978474f, -0.17480232f, -0.16847625f, -0.15095070f, -0.34055719f, 
    0.11388579f, -0.03995782f, -0.04981510f, 0.10715574f, -0.15884881f, 0.00588202f, 0.06045194f, -0.06710712f, 
    0.31114551f, 0.15490803f, 0.06591400f, 0.40743107f, -0.36449307f, -0.12229984f, 0.09636724f, 0.28514025f, 
    -0.02932932f, -0.01796085f, -0.20354265f, -0.03560928f, 0.04784004f, 0.06234775f, 0.02296174f, 0.32341123f, 
    -0.21634473f, -0.43097967f, -0.62260151f, -0.39853787f, 0.02739263f, -0.23226698f, 0.20491663f, 0.11672649f, 
    -0.11421256f, -0.25326043f, 0.27193210f, -0.22297652f, 0.23303106f, 0.27583686f, 0.20350207f, -0.15566546f, 
    -0.19542274f, -0.24338028f, 0.03181814f, 0.06254896f, 0.06329340f, 0.02418184f, -0.03007800f, 0.11160073f, 
    0.00730011f, -0.18143485f, 0.22754917f, 0.13046451f, -0.38035586f, 0.05235130f, -0.12386093f, 0.14158076f, 
    -0.21007878f, 0.00970208f, -0.11170603f, -0.01396748f, 0.06202560f, 0.13055331f, 0.34027943f, 0.13059437f, 
    -0.26011384f, 0.11602429f, -0.28465912f, 0.05188961f, -0.07933411f, 0.06749492f, -0.08337636f, 0.03110689f, 
    0.11419024f, -0.22088529f, -0.00991255f, -0.03612228f, -0.06956417f, -0.08171258f, -0.03763015f, -0.10844518f, 
    -0.09178895f, 0.06137217f, -0.00303114f, -0.32881755f, 0.12229847f, -0.00139294f, 0.01212583f, -0.04932652f, 
    0.22245751f, 0.13256112f, -0.02915237f, 0.00234387f, -0.09891284f, -0.01089601f, 0.01398083f, -0.14550199f, 
    0.65668482f, -0.09041697f, -0.64725929f, 0.29871795f, 0.09363636f, -0.04634410f, 0.15368512f, -0.03101059f, 
    0.13779439f, 0.03536261f, 0.10864516f, -0.03045938f, 0.00216578f, 0.22093412f, 0.19396974f, 0.32539636f, 
    -0.15777445f, 0.04366565f, -0.19640049f, -0.02460984f, -0.15455136f, -0.05824580f, -0.02978829f, -0.05464976f, 
    -0.08966047f, 0.24223511f, 0.23547241f, 0.23018783f, -0.04154211f, -0.17674479f, -0.08433402f, -0.00956281f, 
    -0.15860997f, -0.17004956f, -0.25433722f, 0.03739550f, -0.13579299f, 0.32071266f, -0.55827469f, 0.06613020f, 
    0.10457572f, -0.18853706f, -0.28999299f, -0.58321846f, -0.20299071f, 0.10914876f, 0.08822663f, -0.18340643f, 
    -0.07998139f, -0.04188325f, -0.06728505f, 0.08047123f, -0.09798071f, 0.24180962f, 0.03978466f, -0.02314365f, 
    0.16044335f, -0.06111055f, -0.15169020f, -0.24089892f, -0.13876191f, 0.28337565f, 0.03544245f, 0.58677411f, 
    0.03126775f, 0.32649067f, -0.11718308f, 0.23981728f, 0.10552841f, -0.03314714f, -0.20061664f, 0.02252409f, 
    -0.13971172f, -0.38521209f, -0.20006564f, 0.26568687f, 0.03634234f, 0.07010607f, -0.02901051f, -0.09920300f, 
    -0.11112554f, 0.11211231f, -0.29806104f, -0.03874395f, -0.85869426f, -0.63236046f, 0.26259202f, 0.13709211f, 
    0.00177163f, -0.00154978f, -0.09145217f, 0.13329943f, 0.18736736f, 0.00037526f, 0.08464465f, 0.31790000f, 
    -0.41281372f, -0.06957277f, 0.24784765f, -0.38135996f, 0.04192027f, -0.00805803f, 0.06306354f, 0.06647130f, 
    -0.06982833f, -0.14760597f, -0.67518890f, -0.33855507f, -0.63376665f, 0.13744849f, -0.15988445f, -0.45531490f, 
    -0.05808423f, -0.08388262f, 0.24243030f, -0.03658232f, -0.12502681f, -0.18982568f, -0.08071277f, -0.16635126f, 
    -0.92710078f, -0.13864657f, -0.39103276f, 0.14346625f, -0.01357409f, -0.08869661f, -0.04227141f, 0.18885076f, 
    0.28463969f, 0.16139711f, -0.32944468f, 0.09325558f, -0.06703205f, 0.07879644f, -0.36521474f, -0.29027271f, 
    0.39436027f, 0.11810887f, -0.07111173f, -0.04726684f, 0.09449877f, 0.09290983f, -0.09220135f, -0.07596800f, 
    0.70403492f, -0.36276400f, 0.16436225f, -0.07100278f, -0.36988935f, 0.13904373f, 0.21003801f, 0.04610994f, 
    0.03100232f, 0.07839329f, -0.02082199f, 0.11257450f, 0.25293720f, 0.48038787f, 0.58408511f, -0.17726935f, 
    0.24373409f, 0.11440377f, 0.03924036f, 0.10750464f, 0.13185023f, -0.05239595f, 0.03817585f, 0.17979349f, 
    -0.21339996f, 0.68860036f, -0.34442651f, -0.35498738f, -0.03903893f, 0.04665205f, -0.10435769f, 0.08980348f, 
    0.27866101f, -0.21325335f, -0.03699107f, 0.35777244f, -0.24804562f, -0.32330537f, -0.09519548f, 0.06183053f, 
    0.14301440f, 0.16191156f, -0.30245417f, 0.15344383f, 0.06912614f, -0.11429532f, -0.09004702f, 0.33881047f, 
    -0.05014869f, -0.61246449f, -0.13909505f, 0.20134272f, 0.11357094f, 0.12469821f, 0.10168448f, 0.09706598f, 
    -0.02351869f, -0.06918715f, -0.03666306f, -0.21450235f, -0.14406829f, 0.13343942f, 0.19090687f, -0.00229157f, 
    0.00818082f, 0.15622051f, 0.02849173f, 0.07182114f, 0.14906305f, 0.18988466f, -0.13496795f, 0.19052203f, 
    0.08260588f, -0.38468462f, -0.30922326f, -0.38541746f, -0.11121990f, 0.04047753f, -0.08201296f, 0.01117142f, 
    0.18728939f, -0.09057290f, 0.09102951f, -0.15108635f, -0.25549003f, 0.33481228f, -0.21509291f, -0.63208544f, 
    0.07604785f, -0.04309415f, 0.14507033f, 0.08355734f, 0.23464489f, -0.01743110f, -0.08499006f, 0.21246885f, 
    0.05995804f, -0.01138923f, -0.31540248f, 0.26623940f, -0.07052803f, -0.03129378f, 0.16943991f, 0.07108775f, 
    0.04466688f, 0.17070302f, 0.05215944f, 0.04314364f, -0.13376020f, 0.09777568f, 0.09298051f, 0.12632507f, 
    0.21785627f, -0.13583878f, 0.03833479f, 0.11819255f, 0.04768171f, -0.13923946f, -0.04687307f, -0.03544383f, 
    0.28505397f, 0.01562429f, -0.04874574f, 0.08211702f, -0.00856448f, -0.00995493f, 0.09441464f, 0.01472202f, 
    -0.01636599f, -0.25604397f, -0.08125599f, -0.18390463f, 0.04691812f, -0.23909363f, 0.92058748f, 0.18367358f, 
    -0.07093212f, -0.11347939f, -0.11725429f, 0.25286961f, 0.25168827f, 0.20066920f, 0.18668136f, 0.01534800f, 
    -0.25608486f, 0.19480737f, -0.21752742f, -0.09523011f, -0.00241577f, 0.05541457f, 0.16342080f, 0.01879939f, 
    0.09210342f, 0.19430840f, 0.38625956f, 0.25377321f, -1.53205633f, -0.80528742f, 0.02677363f, 0.16359577f, 
    -0.12963915f, 0.06644936f, -0.12065315f, -0.03585903f, -0.01035048f, -0.03739111f, 0.08942575f, -0.09866191f, 
    0.04235655f, -0.19266382f, 0.12786449f, 0.48851496f, -0.19871086f, -0.11103733f, -0.08816037f, 0.17394787f, 
    -0.04703187f, -0.21193828f, 0.32681647f, 0.10227682f, 0.09841846f, 0.37254086f, -0.06195021f, -0.26670924f, 
    -0.31894025f, -0.17770687f, -0.48309326f, -0.38528115f, 0.05925873f, 0.04351149f, 0.01710080f, 0.06722803f, 
    -0.39311257f, -0.29580146f, -0.28862521f, 0.11280909f, -0.00128474f, 0.19785194f, 0.05382155f, 0.13424185f, 
    0.05573398f, 0.06052051f, -0.11093676f, 0.12206517f, -1.70850670f, -1.02244318f, -0.96018964f, 0.23107745f, 
    -0.28194305f, -0.13998397f, 0.11412557f, -0.47602144f, 0.03194971f, 0.04818483f, -0.09606539f, 0.05637392f, 
    -0.66127622f, 0.57144111f, 0.32525232f, -0.31294307f, -0.17974384f, -0.18119684f, -0.11044748f, -0.05291248f, 
    -0.32557577f, 0.24900298f, -0.06235064f, -0.04962910f, 0.20390333f, 0.03136103f, -0.10434229f, 0.01272455f, 
    -0.07498401f, -0.11988477f, 0.13353677f, 0.04156078f, -0.24869126f, -0.47603863f, -0.02170001f, -0.07299682f, 
    -0.05523594f, -0.40462801f, -0.39396593f, -0.58497173f, -0.00499556f, 0.15505475f, 0.15234271f, -0.21761583f, 
    -0.06073536f, 0.07807488f, 0.00006948f, 0.09771398f, -0.38152587f, -0.67604172f, -0.02722299f, -0.62653303f, 
    -0.18425946f, -0.57445592f, -0.13138907f, -0.25345579f, -0.03104795f, 0.09886568f, -0.12465645f, -0.01608654f, 
    -0.31672353f, 1.05945599f, -0.01962114f, 0.47892815f, 0.04303427f, -0.14459836f, -0.11350771f, 0.16803703f, 
    0.07426409f, 0.11349962f, 0.22933285f, -0.00910891f, 0.64681298f, -0.09523484f, 0.12982491f, 0.02248504f, 
    0.38014486f, -0.50289553f, 0.44189444f, 0.25555238f, -0.20436282f, 0.17375082f, -0.06177135f, -0.08815335f, 
    0.25686359f, -0.12347265f, -0.30702472f, -0.20444004f, -0.07872500f, 0.03987964f, 0.43946034f, -0.01168303f, 
    -0.02294421f, -0.19441639f, -0.17524883f, -0.01426492f, -0.62029535f, -0.55124801f, -0.15427722f, -0.00689664f, 
    0.22089504f, 0.37860391f, 0.26144609f, -0.23780455f, 0.10533030f, -0.01233827f, 0.04816313f, 0.19476202f, 
    -0.05323275f, 0.04547308f, -0.01847828f, -0.15082365f, 0.02313015f, 0.03190616f, 0.00203901f, -0.08700328f, 
    0.19443822f, 0.03066745f, 0.03047637f, -0.06234863f, 0.65258455f, 0.13854948f, 0.22534478f, -0.57529253f, 
    -0.06491134f, 0.21004240f, -0.19257559f, 0.05634117f, -0.04424117f, 0.13489838f, -0.11397126f, -0.18044490f, 
    0.75393182f, -1.07094502f, 0.02453786f, -0.07454444f, 0.06768987f, -0.12100678f, -0.06157183f, 0.03838984f, 
    0.16450550f, 0.15310961f, 0.11126331f, 0.00468265f, 0.39997286f, -1.03640115f, -0.86587787f, -0.89292586f, 
    -0.00865649f, 0.09032407f, -0.12394711f, 0.44708851f, 0.12607659f, -0.00037826f, -0.02045447f, 0.09453513f, 
    0.67861491f, 0.11575180f, -0.18064779f, 0.16249824f, 0.01591310f, 0.18185946f, 0.01281774f, -0.04048760f, 
    -0.15929618f, -0.15985313f, 0.19045027f, -0.02953999f, -0.45545933f, -0.08911227f, -0.08947913f, 0.03368502f, 
    0.08916466f, 0.03106079f, -0.01925026f, -0.12680037f, -0.00011123f, 0.25070554f, 0.00399103f, 0.03539753f, 
    0.19400612f, -0.45870098f, 0.41487592f, -0.29803443f, -0.14239496f, 0.14227165f, -0.18694396f, -0.17347804f, 
    0.01206207f, 0.10623363f, -0.07710424f, -0.12263937f, -0.69418329f, -1.24040699f, 0.76572829f, -0.03371519f, 
    -0.00037886f, -0.00405681f, 0.09645499f, 0.33483252f, -0.12651014f, -0.14083475f, -0.22328582f, -0.06576899f, 
    0.13289277f, 0.40359390f, -0.26479420f, 0.15107994f, -0.02489579f, -0.17248215f, 0.09085835f, 0.01806763f, 
    0.22949608f, 0.06573205f, -0.12360578f, 0.00357036f, 0.06526385f, 0.05812327f, -0.08877248f, 0.00562908f, 
    -0.06534667f, 0.04808216f, 0.04479166f, -0.18280382f, -0.39727890f, -0.06507839f, -0.08661956f, -0.08327098f, 
    0.17742674f, 0.05613060f, -0.17869726f, -0.10204055f, 0.06825684f, -0.05245244f, -0.10000545f, -0.12918851f, 
    0.14033796f, 0.00374577f, 0.01639028f, -0.00739583f, 0.60984874f, -0.60208070f, -0.17402083f, 0.77214026f, 
    -0.05338905f, -0.02098358f, -0.06667991f, 0.01456458f, -0.14937100f, 0.16296914f, -0.08032861f, 0.09796599f, 
    -0.58922011f, -1.58446085f, -0.96645892f, -0.66964203f, -0.15654083f, -0.11149020f, 0.37066633f, -0.08311802f, 
    -0.00579457f, 0.04472964f, 0.00510315f, -0.04233921f, -0.26938120f, -0.16482234f, 0.53649205f, -0.19489264f, 
    -0.52667695f, 0.20870392f, -0.04595971f, 0.20783107f, 0.17314938f, 0.00975690f, -0.01383699f, -0.03682648f, 
    -0.22311157f, -0.00735363f, -0.17602894f, 0.00245756f, -0.14449574f, -0.10273823f, -0.03854360f, -0.15865324f, 
    -0.01570250f, -0.00203071f, 0.02667995f, 0.01363608f, -0.01226968f, 0.20580788f, -0.53676254f, 0.10755054f, 
    0.24478996f, -0.13864641f, 0.27869207f, 0.03733394f, -0.44349584f, 0.12126872f, 0.00734119f, 0.04223277f, 
    -0.62527055f, 0.25340825f, 0.11815295f, -0.13393131f, -0.01881101f, -0.03050811f, -0.09970698f, -0.13469055f, 
    -0.34587249f, -0.06128660f, -0.02540598f, 0.15699580f, -0.30113414f, -0.03285056f, -0.59342086f, -0.17000607f, 
    -0.07785194f, -0.09597108f, -0.09440619f, 0.02545739f, 0.18938607f, -0.02586302f, 0.18010719f, -0.06092998f, 
    0.05925333f, -0.19266728f, 0.01554948f, -0.20410727f, 0.08596270f, 0.00192431f, 0.20901701f, 0.11311537f, 
    -0.22494449f, -0.17521515f, -0.13029520f, -0.74704236f, -0.22509754f, -1.10152149f, -1.22956717f, -0.07668928f, 
    -0.01663470f, 0.23059990f, 0.36651278f, 0.11864327f, -0.15864320f, -0.10571716f, -0.09900564f, -0.19532685f, 
    0.26912636f, 0.08970866f, -0.37067264f, -0.26825866f, -0.07739431f, 0.01641427f, -0.06421725f, 0.10705502f, 
    0.14912689f, -0.03409145f, 0.13990012f, 0.05886987f, -0.21609519f, -0.40194514f, -0.00602192f, 0.14525488f, 
    -0.21310805f, -0.04340227f, 0.12730594f, 0.18932348f, -0.29063261f, -0.09457701f, -0.06489003f, -0.05783584f, 
    1.07168603f, -0.19731709f, -0.03724455f, -0.35270113f, 0.04062985f, -0.30067101f, 0.05713017f, -0.63214654f, 
    0.02538184f, 0.19953936f, 0.22852908f, 0.17259839f, 0.47391680f, -0.56850535f, -0.63223016f, -0.26944619f, 
    -0.41071683f, 0.12416411f, 0.25637901f, -0.27508974f, 0.10188696f, -0.05238118f, 0.15645060f, -0.04333865f, 
    0.10612341f, -0.29083884f, -0.26352766f, -0.06631007f, -0.26342365f, 0.22367090f, 0.11871296f, 0.14880949f, 
    0.18713360f, -0.05427174f, 0.04261954f, -0.17027630f, -0.35477254f, 0.06414349f, 0.03369048f, 0.02284137f, 
    -0.03017234f, 0.06672571f, -0.08584005f, 0.07212895f, 0.23841700f, 0.02689474f, 0.18553132f, 0.07740506f, 
    -0.53390604f, 0.51613754f, 0.23612212f, 0.08035257f, -0.09280094f, -0.20043024f, -0.22237791f, -0.18958347f, 
    -0.26031011f, -0.10323670f, -0.12455890f, -0.00563306f, -0.01584784f, -0.24721865f, -0.69685882f, -0.46738750f, 
    0.33202937f, 0.28941295f, -0.08115133f, 0.39146209f, 0.25839540f, 0.08103524f, 0.06281068f, 0.26822564f, 
    -0.45322293f, -0.79395092f, 0.17921601f, 0.29955634f, 0.15665561f, 0.18880492f, 0.12144565f, 0.06585801f, 
    0.04014238f, 0.06355649f, 0.16655903f, 0.09807322f, -0.31640249f, -0.51153082f, 0.38561365f, 0.30446994f, 
    0.00277789f, 0.20745327f, 0.09272475f, 0.19365235f, 0.17042832f, -0.01801410f, 0.04449003f, -0.05108822f, 
    -0.29790717f, 0.14601147f, 0.12802377f, 0.18574496f, 0.11743432f, -0.14231960f, -0.11947788f, 0.12238946f, 
    0.02326055f, 0.07087834f, 0.30258262f, 0.15401895f, 0.42016149f, 0.09374771f, -0.15894450f, -0.04903625f, 
    0.20531337f, 0.30580646f, -0.01526676f, 0.01928199f, -0.30020466f, -0.07116716f, -0.12328681f, -0.41160011f, 
    0.15083563f, -0.12176336f, 0.01058211f, -0.32108325f, 0.14175051f, 0.21075895f, 0.10635486f, -0.00313332f, 
    0.41832125f, 0.02860938f, -0.04005215f, 0.12935573f, -0.00557653f, -0.15488802f, -0.34256616f, 0.46212423f, 
    -0.14988291f, 0.34261632f, -0.22780630f, -0.14836454f, 0.01810224f, -0.01793268f, -0.16783988f, -0.14620022f, 
    0.24629678f, -0.36291006f, 0.52638012f, 0.50392371f, 0.09691940f, 0.11313136f, -0.06406815f, -0.09052896f, 
    -0.03883938f, 0.23170835f, 0.28359544f, 0.09707489f, -0.02516904f, -0.38171211f, 0.09091334f, -0.42465898f, 
    -0.24497364f, -0.14336832f, -0.03070768f, -0.01472892f, 0.16819113f, -0.00754657f, 0.16469969f, 0.11930280f, 
    -0.79607826f, 0.59944248f, -0.08662447f, 0.36004856f, -0.00765557f, -0.17636248f, -0.28541824f, -0.25084773f, 
    0.09364862f, 0.01052536f, 0.13738348f, -0.04737280f, -0.07337862f, 0.43682206f, 0.06703274f, 0.10019742f, 
    -0.10334838f, -0.16346221f, -0.18885334f, -0.00151257f, -0.06812482f, 0.09442288f, -0.09715351f, -0.02812386f, 
    -0.08728555f, -1.12687349f, -0.20045461f, 0.44462723f, 0.16774525f, 0.16953805f, 0.26172996f, -0.10550750f, 
    -0.24056277f, -0.04714765f, -0.28344074f, -0.09793878f, -0.70566219f, -0.28607318f, 0.47367847f, -0.37399051f, 
    -0.20722167f, -0.22247292f, -0.12163837f, 0.33071229f, -0.00280484f, 0.09232263f, 0.14475684f, 0.04247502f, 
    0.22058876f, 0.05397380f, 0.43014398f, 0.36785400f, 0.15994102f, -0.10322840f, -0.39606008f, -0.29965293f, 
    -0.18377650f, 0.29118872f, -0.09190685f, 0.00147166f, -0.29722911f, 0.08364398f, -0.26002404f, -0.18896954f, 
    0.06724085f, 0.01685377f, 0.14523585f, 0.13070029f, 0.07620822f, 0.02413065f, 0.19148833f, 0.02555073f, 
    -0.35978881f, -0.22166352f, -0.49006093f, 0.36459053f, 0.06164959f, 0.17830950f, 0.28746748f, 0.06567795f, 
    -0.03069838f, 0.06181663f, 0.08828394f, -0.00222231f, -0.26180592f, 0.00040618f, -0.18172729f, 0.31791210f, 
    0.15529899f, -0.20827378f, -0.12183209f, 0.03260342f, -0.15161076f, -0.16437580f, 0.07703435f, -0.16969234f, 
    0.58779204f, -0.23115700f, 0.89202768f, -1.05509365f, -0.00827891f, -0.47433981f, -0.07837237f, -0.03219676f, 
    -0.30547014f, -0.02020268f, 0.08857395f, -0.02697006f, 0.03183196f, 0.32326716f, -0.08212069f, -0.95061255f, 
    -0.81180811f, -0.09232317f, -0.12169057f, -0.15752257f, 0.29130328f, 0.07437022f, -0.33655140f, -0.11906780f, 
    -0.27979666f, 0.59434718f, -0.94266456f, 0.19839433f, 0.37361342f, -0.14325377f, 0.28499106f, 0.04798594f, 
    0.18899450f, -0.06670341f, -0.18438691f, -0.00084121f, 0.29607818f, 0.22210501f, -0.65005046f, -0.32692742f, 
    -0.13024594f, -0.01287141f, 0.17759264f, 0.29363158f, 0.04554844f, -0.15819126f, -0.07184740f, -0.03156057f, 
    -0.17409439f, -0.38329232f, -0.04586890f, -0.49865720f, -0.52524668f, -0.48720875f, -0.00920172f, 0.16402829f, 
    -0.21888214f, -0.06065533f, -0.22066395f, -0.27006420f, -0.47709453f, -0.11389486f, 0.21405712f, 0.28234500f, 
    0.31584904f, -0.24460527f, 0.05928179f, -0.36957905f, -0.11494322f, 0.20650783f, -0.02071699f, 0.12051477f, 
    -0.26882493f, 0.45213783f, -0.16889027f, 0.06166304f, -0.10346514f, 0.21908183f, -0.05049637f, 0.15859661f, 
    -0.14823911f, -0.31830820f, -0.38805610f, -0.71601599f, 0.00916698f, -0.63934386f, -0.23002362f, 0.07982517f, 
    0.09320796f, -0.28185698f, 0.03264800f, 0.28276473f, -0.16132478f, 0.26981667f, -0.09932291f, -0.51664519f, 
    0.91334212f, -0.00320249f, 0.53894198f, -0.55315226f, -0.18047382f, -0.04103984f, 0.25706667f, 0.20195998f, 
    -0.05082230f, 0.17168605f, -0.39189336f, -0.11015020f, -0.42259830f, 0.18739112f, -0.05118383f, 0.23908958f, 
    0.18794723f, 0.13174599f, -0.12078133f, 0.13651749f, -0.00023283f, -0.10334117f, -0.08955958f, 0.06372650f, 
    -0.80508453f, 0.47260299f, -0.39446637f, -0.00151790f, -0.25987470f, 0.05460493f, -0.05880752f, -0.20022209f, 
    0.27322096f, 0.23911060f, 0.01791056f, 0.02182186f, -0.46006823f, -0.33831435f, -0.40504497f, 0.22707801f, 
    -0.11665609f, 0.15972744f, -0.23510715f, 0.02522946f, -0.00424932f, 0.10737200f, 0.00721904f, -0.08504093f, 
    0.25368491f, -0.26112932f, 0.18465982f, -0.14888524f, 0.10508427f, -0.03200186f, -0.20341116f, 0.22112797f, 
    0.02042324f, 0.07717478f, 0.01649795f, -0.23085648f, -0.10718670f, -0.53077096f, 0.12829345f, -0.18998124f, 
    -0.01899496f, 0.06658912f, -0.07431064f, 0.08283141f, 0.04018342f, 0.28957170f, 0.09815662f, 0.13380957f, 
    0.08964810f, -0.30095014f, -0.45764196f, -0.19898410f, -0.52675253f, -0.14413916f, 0.02342243f, -0.31863961f, 
    -0.24544458f, -0.11149374f, -0.24084155f, 0.02176934f, -0.21382192f, 0.83472115f, -0.40939987f, 0.12541725f, 
    -0.29181492f, 0.13340993f, 0.21473019f, -0.01352870f, -0.04551392f, 0.50918239f, 0.04233830f, 0.44858930f, 
    -0.01557428f, 0.37229967f, -0.67344266f, 0.38997960f, -0.11360937f, 0.03150212f, -0.16402996f, 0.11953802f, 
    0.16908434f, 0.03197666f, -0.01657962f, -0.22465478f, 0.16854486f, 0.22464719f, 0.03774129f, 0.40151474f, 
    -0.06670059f, -0.46242690f, 0.36619857f, -0.02347932f, -0.27543160f, 0.11587062f, -0.22143687f, 0.45823225f, 
    0.07589120f, 0.15230305f, -0.02162091f, -0.08748787f, 0.09257320f, 0.14668730f, 0.36502281f, -0.24054407f, 
    -0.06309480f, 0.30038309f, 0.08486931f, 0.29903126f, -0.16326839f, -0.86568046f, 0.73854798f, 0.04303886f, 
    -0.08899079f, 0.15959631f, 0.28066748f, -0.06404760f, 0.02471882f, -0.06045804f, 0.00672643f, -0.20573644f, 
    0.17057171f, 0.21614182f, 0.00423823f, -0.06946187f, 0.02439136f, 0.05109067f, -0.00139418f, 0.03772761f, 
    -0.03411947f, -0.12163223f, 0.05881678f, 0.02656041f, -0.73381418f, 0.13970867f, -0.29216251f, 0.42909026f, 
    0.17281379f, -0.32294714f, 0.08099808f, -0.23645678f, -0.05231218f, -0.12069102f, 0.12077986f, -0.11576304f, 
    -0.46873596f, 0.43756536f, -0.74460119f, 0.10641927f, 0.24536084f, -0.18890126f, 0.01724882f, -0.03251903f, 
    0.32086492f, 0.24899955f, 0.41318977f, 0.33521616f, -0.03850319f, 0.55085146f, -0.18962105f, -0.88611758f, 
    -0.24767548f, 0.22094479f, 0.27406362f, -0.15042336f, 0.03926182f, 0.09632560f, 0.06330611f, -0.07795889f, 
    -0.12881058f, -0.69232666f, 0.20889407f, -0.57047468f, 0.07765171f, 0.21442221f, 0.02361149f, -0.29365942f, 
    -0.17018269f, 0.04975578f, 0.16150080f, -0.06283434f, -0.00787186f, -0.41464865f, 0.31293619f, -0.11325812f, 
    -0.00729139f, -0.04570635f, -0.08864932f, -0.03173502f, 0.17863871f, -0.31529588f, -0.26297116f, -0.04036871f, 
    0.26556143f, 0.00987005f, 0.14500859f, 0.19466552f, 0.20407000f, -0.27917179f, -0.11445849f, 0.21773341f, 
    -0.13953923f, -0.05676448f, -0.00347275f, 0.03475686f, -0.20369731f, -0.87726426f, -0.02392130f, 0.10548794f, 
    0.03228213f, -0.08271103f, -0.33791888f, -0.28623176f, -0.07936060f, 0.17846546f, 0.06720550f, -0.06461963f, 
    -0.80627477f, 0.39733252f, 0.19882727f, 0.19977364f, 0.02460818f, -0.24017560f, -0.01143822f, -0.06975597f, 
    -0.12435708f, 0.38065985f, 0.33775154f, 0.01272971f, 0.24884471f, -0.08838641f, -0.01979237f, -0.10199302f, 
    0.02068613f, 0.00324874f, -0.00349339f, 0.03799123f, -0.05356041f, 0.00221850f, -0.05912114f, -0.18999045f, 
    0.62442678f, 0.09774660f, 0.50953406f, -0.62494898f, -0.07470523f, -0.08688977f, -0.20477031f, -0.05015797f, 
    -0.21659566f, 0.00656931f, 0.01897766f, -0.21567166f, -0.05229572f, -0.31813306f, 0.30507666f, -0.13864057f, 
    0.10350189f, -0.35616979f, -0.11316495f, 0.19006547f, 0.11579888f, -0.02355287f, 0.14304402f, -0.01322475f, 
    -0.75411427f, -0.22813725f, -0.00665543f, 0.17896719f, 0.03560573f, 0.01878510f, -0.01397201f, 0.33192715f, 
    -0.48922214f, -0.19768298f, -0.06874625f, -0.04240818f, -1.11010444f, 0.97598499f, 0.26371530f, 0.30353242f, 
    -0.06291292f, 0.14519288f, 0.30656570f, -0.28672376f, -0.18732734f, -0.11468431f, 0.00652564f, 0.24249506f, 
    0.61380559f, -0.15728164f, 0.89786905f, -0.29973042f, 0.26155454f, 0.08393348f, -0.12272491f, 0.10131289f, 
    -0.31229362f, -0.12858909f, 0.00231240f, -0.08072734f, 0.24536319f, -0.29053783f, 0.86966890f, -0.03748066f, 
    -0.14165367f, -0.23237167f, -0.08862041f, -0.01798740f, 0.20033613f, 0.30417973f, -0.06846526f, 0.31955642f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.38405320f, 0.24925652f, 0.02668346f, -0.27401894f, -0.16490352f, 0.16038516f, 0.06408601f, -0.34335479f, 
    0.08452237f, 0.12953852f, 0.00660386f, 0.04385464f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
