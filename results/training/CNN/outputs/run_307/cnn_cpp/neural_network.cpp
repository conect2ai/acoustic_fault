#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.44140753f, 0.69602913f, 0.69963145f, 0.07002556f, 0.52757829f, -1.14065111f, 0.37911791f, -0.39683869f, 
    -0.64301246f, -0.36651856f, 0.30681056f, 0.02870928f, 0.11633137f, -0.03080482f, -0.06382939f, 0.09902883f, 
    -0.09298702f, 0.02809159f, -0.26397279f, -0.13959435f, 0.10151320f, 0.10268268f, 0.14150798f, 0.02653376f, 
    -0.05156842f, -0.10643451f, 0.36940834f, 0.01766245f, 0.19868597f, 0.35692763f, -0.06921558f, -0.41923669f, 
    -0.66346067f, -0.12781392f, 0.17689152f, -0.17007993f, -0.20039463f, -0.26226830f, -0.28279170f, -0.14453562f, 
    -0.40729949f, -0.27373078f, 0.30744305f, 0.17753400f, -0.20884784f, 0.09729797f, -0.36224729f, -0.41848165f, 
    -0.16108027f, -0.36465865f, -0.69533449f, -0.61598092f, 0.26784152f, 0.30959660f, 0.47145644f, 0.52303392f, 
    0.69660944f, 0.07523037f, 0.08704989f, -0.28958544f, -0.04171934f, -0.13650236f, 0.19733143f, -0.22104815f, 
    -0.08076075f, 0.09503962f, -0.12274759f, -0.43045732f, 0.11098287f, 0.23683894f, 0.16100729f, 0.38093394f, 
    0.31911615f, -0.24784215f, 0.40597081f, -0.14125715f, 0.49261659f, -0.39417472f, -0.16225135f, -0.51396692f, 
    0.08473739f, 0.04231004f, -0.39479280f, 0.55350709f, 0.43340087f, -0.14926694f, 0.07086547f, -0.00145436f, 
    -0.32456875f, 0.28215769f, 0.46256885f, 0.36292759f, -0.01644897f, 0.08286616f, -0.28747675f, -0.40399382f, 
    -0.34023762f, 0.08538345f, 0.01482554f, -0.13126068f, 0.32098827f, -0.52163720f, -0.27152774f, 0.39988852f, 
    0.34511757f, -0.76155138f, -0.24407627f, 0.36303270f, -0.79181558f, 0.29274079f, -0.16649105f, 0.24089000f, 
    -0.21795455f, -0.18707110f, 0.03969510f, -0.36948287f, -0.34567055f, 0.11664779f, 0.31581908f, -0.52273107f, 
    -0.31683031f, -0.33485627f, -0.42102382f, -0.02395208f, 0.13271306f, 0.73207557f, 0.00633635f, -0.75267392f, 
    -0.71319389f, 0.33800766f, 0.76966536f, -0.34518456f, 0.03003365f, 0.33645943f, 0.33226889f, 0.05107172f, 
    0.25411963f, 0.14461122f, 0.23008980f, -0.05961168f, -0.29269570f, -0.16335392f, -0.04910012f, 0.12588331f, 
    0.15634115f, 0.39315850f, 0.14094320f, -0.21371600f, -0.00972465f, -0.00592559f, -0.61573946f, -0.70279467f, 
    -0.55595726f, 0.10694774f, 0.44025636f, -0.09413550f, -0.59887975f, -0.33629087f, 0.03463108f, -0.07514630f, 
    0.42271057f, 0.11996252f, 0.21649456f, 0.08388208f, 0.07104494f, -0.11047738f, -0.02338992f, 0.19228576f, 
    0.24189964f, 0.38883260f, 0.09326758f, 0.32146251f, -0.18112707f, 0.27109650f, 0.09554724f, -0.29013604f, 
    -0.98660636f, 0.42414802f, -0.14579964f, -0.10479470f, 0.44442883f, -0.50397158f, 0.56211203f, -0.15055944f, 
    -0.54494262f, -0.04053086f, -0.42146000f, -0.31196049f, -0.16295771f, -0.20379402f, 0.11438446f, 0.41923314f, 
    -0.14288412f, -0.00861997f, -0.07830140f, -0.19626497f, 0.26158214f, 0.24349307f, 0.04579842f, -0.23066653f, 
    0.79750818f, 0.74427700f, -0.85001528f, 0.43069381f, -0.64423102f, 0.49790773f, 0.47704476f, 0.29927820f, 
    0.21992607f, 0.20476824f, 0.12140542f, -0.16020480f, -0.12742651f, -0.13626426f, -0.06468964f, 0.20409223f, 
    -0.34240273f, -0.01783607f, -0.26909083f, 0.22341514f, -0.14630008f, -0.46347767f, 0.08803932f, 0.03882806f, 
    -0.16443530f, 0.51445830f, -0.66842091f, -0.50210035f, -0.54243702f, 0.44211453f, 0.37671012f, -0.53823286f, 
    -0.58752424f, -0.09341415f, 0.21587598f, -0.39794818f, 0.37302658f, 0.34452116f, 0.11585387f, 0.06461558f, 
    -0.25378391f, 0.06211285f, 0.02776406f, -0.16180155f, -0.11006550f, 0.18846622f, 0.06000106f, 0.14287099f, 
    0.40132192f, -0.40041849f, -0.40271661f, 0.32617521f, -0.60528517f, -0.29638499f, 0.32547441f, -0.26476604f, 
    0.79480958f, 0.83180106f, 0.45344439f, 0.57920909f, 0.10254432f, -0.21608147f, -0.10835724f, -0.47125906f, 
    0.16188717f, -0.11573534f, -0.04638201f, -0.12337666f, 0.18716590f, -0.04806295f, -0.02587895f, 0.01551633f, 
    0.04180049f, 0.06421255f, -0.21540400f, -0.00068367f, 0.18584332f, 0.93101072f, 0.55985653f, 0.07294112f, 
    0.55412620f, -0.23683131f, 0.12254433f, 0.34026626f, -0.30981603f, -0.50290740f, 0.14374636f, -0.42252856f, 
    0.01609286f, -0.03205010f, 0.24348974f, 0.24589159f, 0.09479462f, -0.14802577f, 0.06872255f, -0.22375272f, 
    -0.28210396f, 0.09028827f, -0.17188619f, -0.29867458f, -0.19384973f, 0.00517733f, -0.72078699f, -0.68803644f, 
    -0.57189208f, 0.51367718f, 0.04573388f, 0.16316025f, 0.54143155f, 0.23336008f, -0.29883873f, 0.02871995f, 
    -0.00739050f, -0.12922564f, 0.03420279f, 0.17112002f, -0.07053487f, 0.13100791f, 0.43433243f, -0.29126278f, 
    0.07439259f, 0.07406127f, -0.20072910f, -0.11314920f, 0.39307630f, -0.72137499f, 0.04172417f, 0.46934101f, 
    -0.00399460f, -0.18752545f, 0.15572542f, -0.06583763f, -0.48256147f, -0.29100206f, 0.64421624f, -0.42722800f, 
    0.06665630f, -0.02748840f, -0.22277330f, 0.20251717f, -0.59291536f, -0.39397931f, 0.42403147f, -0.66137201f, 
    -0.26385438f, 0.24124704f, 0.12073115f, 0.17361923f, -0.03212256f, -0.16287817f, -0.45185557f, -0.52974373f, 
    -0.52808976f, -0.30867904f, -0.21511798f, 0.30468911f, -0.11836267f, -0.49002972f, 0.60248518f, 0.18888679f, 
    0.20793632f, -0.37802154f, -0.10733244f, -0.19154240f, -0.49479595f, -0.31355226f, -0.18032329f, -0.21000817f, 
    0.15187034f, 0.08752822f, 0.19196792f, 0.21581274f, -0.18262614f, 0.13548866f, 0.16067177f, 0.92421150f, 
    0.41049749f, -0.31897086f, 0.50617599f, 0.04219256f, 0.28097096f, 0.44053361f, -0.54885399f, 0.06927504f, 
    0.50810295f, 0.19953130f, 0.10928802f, -0.00434309f, 0.04615395f, -0.44030318f, 0.00686934f, -0.28186974f, 
    0.00873921f, -0.16493477f, 0.18795042f, 0.04511932f, -0.23867191f, 0.39930779f, -0.13037889f, 0.27865836f, 
    0.88989401f, 0.16251780f, 0.17883047f, 0.87423992f, 0.39169693f, 0.50481802f, 0.34096986f, 0.44563442f, 
    -0.25431651f, 0.19135867f, -0.09720606f, -0.55732530f, -0.27746809f, 0.05951368f, -0.02634796f, 0.03337125f, 
    -0.05831163f, 0.09163353f, -0.20503569f, 0.16759424f, -0.36714360f, -0.02735510f, -0.32281110f, 0.10683990f, 
    -0.26569349f, 0.28353533f, 0.77163094f, 0.38320297f, -0.37365091f, 0.50595129f, -0.52152467f, -0.83502597f, 
    -0.47977084f, -0.40463170f, -0.10196462f, -0.01231821f, 0.32896358f, 0.12755905f, 0.51088351f, -0.13888283f, 
    0.00863593f, 0.07953018f, -0.06266470f, -0.20902804f, 0.25921932f, -0.24839066f, 0.16868722f, 0.23966874f, 
    -0.27575245f, 0.35388815f, -0.68426043f, 0.62103653f, -0.19544564f, -0.02351314f, -0.20924096f, 0.37522835f, 
    0.15887187f, -0.63175023f, 0.45240068f, -0.38164034f, 0.33357587f, 0.15022522f, -0.01688466f, 0.02295491f, 
    0.14486039f, -0.15112264f, 0.03332774f, 0.57409960f, 0.07811788f, -0.10943199f, 0.39540601f, -0.26989192f, 
    -0.40252039f, -0.24143302f, 0.16997015f, 0.19968376f, -0.76490414f, -0.73110938f, -0.37751207f, 0.37805164f, 
    -0.40133050f, 0.10622876f, -0.08029316f, -0.31801838f, 0.50935799f, 0.18610935f, -0.01459181f, 0.27250689f, 
    -0.17282553f, 0.24750730f, -0.05222520f, 0.24500494f, 0.18425520f, -0.15335873f, -0.03745616f, -0.21236153f, 
    -0.43011290f, -0.16946055f, 0.33692890f, 0.10984879f, 0.95751810f, 0.63236618f, 0.91912901f, -0.16771512f, 
    -0.79434568f, -0.19128190f, -0.48230967f, 0.04485761f, 0.05945015f, 0.58014351f, 0.25867614f, 0.16020319f, 
    -0.21417971f, -0.00671137f, -0.02665723f, -0.33413368f, -0.05051791f, 0.00695604f, -0.15817316f, -0.24723890f, 
    -0.02532665f, -0.06868869f, -0.07869446f, 0.33907828f, 0.16214746f, -0.04986367f, -0.49456656f, 0.79432881f, 
    0.24204205f, 0.17943062f, 0.75120544f, 0.20276564f, -0.33459911f, 0.00806914f, -0.01345382f, 0.35687599f, 
    0.16890538f, -0.13065399f, 0.42506763f, 0.14915811f, 0.27071819f, -0.26174852f, 0.04985468f, -0.16138390f, 
    0.32287639f, -0.05413257f, 0.33963886f, -0.21316275f, -0.17386979f, 0.40805313f, -0.20411295f, 0.75044912f, 
    0.37643966f, -0.87484801f, -0.55629164f, -0.37570798f, 0.18489474f, -0.44205725f, -0.26398379f, -0.50184256f, 
    0.04561776f, 0.32779995f, -0.04087678f, 0.01574831f, 0.21836160f, 0.12729466f, 0.04936511f, -0.05338167f, 
    0.16873540f, 0.23324826f, 0.12730049f, 0.10453145f, 0.08994749f, 0.24825278f, 0.09674606f, 0.06580528f, 
    0.37552840f, -0.30188775f, -0.13038111f, 0.15608619f, -0.22824526f, -0.82946587f, -0.20778850f, -0.51691198f, 
    -0.61799753f, -0.40061790f, 0.46809113f, 0.32686079f, 0.25106972f, -0.25634542f, 0.12474500f, -0.32252789f, 
    -0.01281039f, 0.13413438f, 0.27683628f, -0.27929744f, 0.16006348f, 0.08850047f, 0.00813083f, -0.17932586f, 
    0.98971063f, 0.49596813f, -0.29836497f, -0.79289365f, -0.68931067f, 0.22716995f, -0.19286856f, -0.37806264f, 
    -0.27997199f, -0.28769279f, 0.25523782f, 0.09133293f, 0.18418792f, -0.06669690f, -0.09559851f, -0.08570244f, 
    0.02746335f, -0.12162882f, -0.16813943f, -0.04699006f, 0.10998518f, 0.19336976f, -0.05143896f, -0.11869904f, 
    0.29448348f, -1.07344079f, 0.03457560f, -0.73870558f, 0.48189607f, -0.44870341f, 0.28190655f, 0.51106620f, 
    -0.41177043f, 0.24579699f, 0.02052219f, -0.18838423f, 0.24386458f, 0.37957349f, 0.00805499f, 0.30306709f, 
    0.17163773f, 0.13232467f, 0.22242804f, -0.05395047f, -0.21888147f, -0.12557055f, 0.17150816f, -0.32690752f, 
    -0.04380379f, 0.08504481f, 0.73012149f, 0.22671987f, -0.52331394f, 0.38976482f, 0.94361448f, -0.26072997f, 
    -0.37856627f, -0.21011050f, 0.39989361f, 0.30333048f, -0.15414448f, -0.26826102f, 0.28601968f, 0.31789118f, 
    0.10408247f, 0.13650942f, 0.19841373f, -0.09015884f, -0.27200314f, -0.25671804f, 0.44110608f, -0.05469393f, 
    0.19437592f, 0.15345591f, 0.16069555f, 0.15916339f, -0.37707931f, -0.76195610f, -0.48198935f, 0.00485810f, 
    0.63513809f, -0.35407653f, 0.36511162f, 0.18989022f, -0.34957197f, -0.54414195f, 0.27918530f, 0.22457731f, 
    0.09948183f, -0.00636375f, -0.01279001f, -0.37623686f, -0.16459030f, 0.24630541f, -0.09658112f, -0.29445335f, 
    0.01494167f, -0.00366026f, -0.34019154f, 0.15870848f, 0.52437961f, 0.48990300f, 0.37906700f, 0.77904111f, 
    0.01891230f, -0.18968052f, -0.27626622f, 0.38025826f, 0.26958513f, 0.41223186f, -0.32088244f, 0.01290947f, 
    -0.29952705f, -0.41494897f, -0.05338431f, -0.29095781f, -0.11063778f, -0.13737394f, -0.37250042f, 0.01819138f, 
    0.08198678f, -0.10102075f, 0.11252639f, 0.13851048f, -0.06570490f, -0.84660053f, 0.08715323f, 0.06961177f, 
    -0.76448584f, -0.47475824f, 0.42051616f, 0.33735201f, 0.41540340f, 0.55065644f, 0.02443296f, 0.25105506f, 
    -0.10961072f, -0.28934342f, 0.18407378f, 0.06008586f, 0.36088756f, -0.16947368f, -0.40823594f, -0.22251263f, 
    0.19572330f, -0.27729824f, -0.25735494f, 0.06900695f, -0.21358946f, 0.15210585f, -0.56881309f, 0.08263908f, 
    0.74983692f, 0.26469657f, -0.60998350f, -0.59363842f, -0.08520836f, -0.34458503f, 0.33189979f, 0.08828814f, 
    0.25978550f, 0.22815822f, -0.17725790f, -0.28816614f, 0.23042341f, 0.05142832f, 0.07422784f, -0.01421514f, 
    0.18198019f, 0.44122547f, 0.23532294f, 0.10560711f, 0.18390812f, -0.04203772f, 0.00889158f, 0.23391214f, 
    0.18657030f, -0.67049831f, -0.87073195f, -0.63104242f, -0.42788276f, -0.03720058f, 0.07434890f, -0.04963024f, 
    -0.50296873f, -0.06188708f, 0.15176281f, 0.00370003f, 0.08543964f, 0.12642290f, -0.13234264f, 0.27545470f, 
    0.08346917f, 0.23346162f, 0.25016132f, -0.32793763f, -0.01327412f, -0.01904847f, -0.11452471f, -0.12991531f, 
    -0.13046931f, -0.32377306f, -0.20635980f, -0.38650331f, -0.30960920f, -0.08317375f, -0.08520202f, 0.31439793f, 
    -0.02067538f, -0.09528331f, -0.56858522f, -0.11686318f, -0.26088312f, -0.04552400f, -0.73257875f, -0.33257368f, 
    -0.15647081f, 0.25164929f, 0.15386435f, 0.06493236f, -0.00420510f, 0.34804150f, -0.44542071f, 0.40021709f, 
    0.41863135f, -0.11910261f, 0.29716301f, -0.39072970f, -0.64658773f, -0.50153810f, 0.30578336f, 0.46966171f, 
    -0.26191998f, -0.03767527f, 0.42737758f, 0.57540381f, -0.31522146f, -0.27955201f, -0.04302699f, 0.25138047f, 
    0.00835580f, 0.33996466f, -0.11528233f, 0.02543805f, 0.44738975f, -0.12323885f, 0.15264268f, 0.04229926f, 
    0.38055456f, -0.20808768f, 0.66579008f, 0.24461935f, 0.45135921f, -0.61741537f, -0.17110814f, 0.53603208f, 
    -0.20184299f, -0.07379409f, -0.84883964f, -0.04802240f, 0.13202421f, 0.28343412f, 0.14134924f, 0.35569420f, 
    0.12767009f, 0.27690241f, -0.06482603f, -0.22147030f, 0.09352904f, -0.45620069f, 0.14462683f, 0.26058984f, 
    -0.12692149f, 0.14868763f, 0.27733985f, 0.74594593f, -0.95221543f, -0.51790637f, 0.74341029f, -0.00105357f, 
    -0.67985511f, 0.80473566f, -0.32491046f, 0.39005861f, 0.36720240f, -0.14824584f, 0.14297788f, -0.37273684f, 
    0.14064655f, 0.13590287f, -0.08700757f, -0.01837674f, -0.29850829f, 0.33939606f, 0.07502851f, 0.04547937f, 
    0.04470037f, 0.15230857f, -0.12070608f, -0.22194448f, -0.08747431f, -0.72853827f, -0.11985005f, 0.82064253f, 
    0.37871215f, -0.79414928f, -0.22535917f, 0.03601710f, -0.67660791f, 0.24824764f, -0.05846998f, 0.62143898f, 
    -0.38221434f, 0.05629455f, -0.16772527f, 0.17104571f, 0.25038052f, -0.04267920f, -0.14667176f, 0.00024298f, 
    -0.16879492f, 0.04104704f, 0.14985555f, 0.44860411f, -0.26020247f, 0.13588496f, -0.77540946f, 0.82011193f, 
    -0.24595354f, -0.19746888f, 0.47845328f, -0.40970108f, 0.44906098f, 0.13804713f, 0.45222282f, 0.09601144f, 
    -0.16027245f, -0.05702572f, 0.19174518f, -0.19673598f, -0.14914468f, -0.26799980f, -0.09158272f, -0.49090418f, 
    -0.00955204f, -0.38067612f, -0.09842645f, 0.27246532f, -0.01576541f, -0.04348828f, 0.32550129f, 0.35312635f, 
    0.80315799f, 0.76353711f, 0.30150729f, 0.38675988f, 0.35438392f, -0.73766512f, -0.18803532f, 0.03020428f, 
    0.06807610f, 0.06130764f, 0.16458283f, 0.25244564f, 0.02805551f, -0.35384259f, -0.05678041f, 0.15617667f, 
    -0.06753809f, 0.14697070f, -0.18274814f, 0.21367987f, 0.19888338f, -0.11518883f, 0.09107163f, -0.01411123f, 
    -0.03002786f, 0.03600413f, 0.52248186f, -0.66253531f, 0.47228190f, 0.56649834f, -0.63895124f, -0.52360755f, 
    -0.58114195f, -0.13315548f, 0.32201260f, -0.14107217f, 0.12004475f, 0.45225289f, 0.16560332f, 0.11910591f, 
    -0.45030823f, 0.07264653f, 0.01846888f, 0.05605117f, 0.12634414f, 0.41613603f, -0.20681712f, -0.00877169f, 
    -1.01044548f, 0.98373896f, -0.06491724f, -0.64768183f, -0.66418791f, 0.78666496f, 0.35703287f, -0.32116976f, 
    0.22124158f, 0.34238124f, -0.43263039f, -0.37305412f, -0.41000643f, -0.04800088f, -0.29100323f, -0.05055609f, 
    -0.05105186f, -0.16426946f, -0.05599336f, -0.10522134f, -0.14852813f, -0.11057541f, 0.07920516f, 0.12381321f, 
    0.16866472f, -1.03675544f, 0.60506529f, 0.48750925f, -0.59997225f, -0.23535436f, 0.65030962f, 0.62968427f, 
    -0.65427512f, 0.24523017f, 0.39191315f, 0.31879997f, 0.02073868f, 0.23982441f, -0.27688608f, -0.27576667f, 
    0.05039382f, 0.21286812f, 0.34468207f, -0.04926377f, -0.33364323f, -0.09084367f, -0.39765474f, 0.26805812f, 
    0.07877921f, -0.18192419f, 0.73351055f, -0.48495191f, 0.11133399f, 0.19974402f, 0.00594863f, 0.70972258f, 
    0.39567727f, 0.34752107f, 0.65594465f, 0.35486448f, -0.34527335f, 0.43106809f, -0.44917947f, 0.43396074f, 
    -0.05167389f, 0.10420632f, -0.21297027f, -0.06539489f, 0.29955021f, 0.12069804f, 0.23898880f, -0.05107768f, 
    -0.07063278f, -0.00808475f, 0.02845790f, -0.08200018f, -1.02799308f, -0.55264848f, -0.06602357f, -0.47235760f, 
    -0.30657935f, 0.62857091f, 0.74084586f, 0.28572538f, 0.11916934f, 0.19016500f, -0.00123181f, -0.39025667f, 
    -0.13837096f, -0.13701615f, 0.14007363f, 0.09655629f, -0.19070926f, -0.22408810f, -0.02864925f, 0.01316173f, 
    -0.01134052f, 0.29703465f, 0.07414511f, 0.02773721f, 1.08705807f, 0.63934416f, -0.32795274f, 0.18225686f, 
    -0.55456048f, -0.33967602f, -0.45891038f, 0.15117566f, 0.26055405f, 0.25527784f, -0.01817582f, -0.19007923f, 
    -0.05452804f, -0.19277482f, 0.25937393f, -0.16428316f, -0.23844086f, -0.21191327f, -0.31854275f, 0.11683392f, 
    -0.02701425f, 0.14792936f, -0.09606068f, -0.13279830f, -0.27334943f, -0.74627829f, -0.31253782f, 0.42600515f, 
    -0.24048992f, -0.67278850f, -0.48734608f, -0.75535923f, 0.16878705f, -0.33224815f, -0.28393909f, -0.45835444f, 
    -0.12479211f, 0.06884379f, -0.00232266f, 0.13203117f, -0.45525596f, -0.25427118f, -0.06653171f, -0.03949209f, 
    -0.19970655f, 0.36228210f, -0.02320684f, -0.16088179f, 0.28233898f, 0.16872917f, -0.28621155f, -0.90443021f, 
    -0.66198486f, -0.06898418f, -0.47501585f, 0.30195290f, 0.70066714f, 0.18032129f, -0.23188663f, 0.59850532f, 
    0.00384775f, -0.48005593f, -0.35398567f, 0.06965717f, -0.21445060f, -0.00766303f, -0.06642102f, 0.13198215f, 
    -0.11637601f, -0.26482603f, 0.09362107f, -0.23958738f, 0.14789338f, -0.27761343f, 0.22349703f, -0.32593548f, 
    0.34308919f, -0.48920175f, -0.16290876f, -0.65135509f, 0.25233057f, -0.56104541f, -0.21106072f, -0.11896473f, 
    -0.41195709f, -0.28579709f, 0.23700066f, 0.05367354f, 0.07351391f, 0.01133445f, 0.07683577f, 0.32138854f, 
    -0.14519544f, 0.23468781f, -0.00666132f, 0.00137481f, -0.27004570f, 0.16680257f, -0.19115749f, -0.15100104f, 
    0.76114494f, 0.87906516f, 0.87214404f, 0.34903523f, 0.10258655f, -0.61915231f, 0.66041309f, -0.36947256f, 
    -0.60695761f, 0.17893593f, 0.21062648f, 0.18280540f, -0.26688147f, -0.00707499f, 0.32687736f, -0.16042712f, 
    0.09639689f, -0.00393586f, 0.17306425f, 0.11521371f, -0.00861041f, -0.05355740f, -0.00621730f, 0.18697736f, 
    0.25736248f, -0.60692507f, -0.74834794f, -0.08162149f, -0.24782099f, -0.42627451f, -0.41038483f, 0.42758918f, 
    0.72405547f, -0.84363043f, -0.15962192f, 0.22135536f, 0.32136670f, 0.11217604f, 0.29154238f, 0.15694997f, 
    -0.23080942f, -0.21912198f, -0.36236191f, -0.05547210f, -0.41605774f, -0.04270559f, -0.04155856f, 0.16034783f, 
    0.10890740f, 0.13238685f, 0.43565491f, -0.20611224f, -0.46062255f, 0.85218441f, 0.29588413f, -0.12353130f, 
    -0.37955824f, -0.19382890f, 0.28653446f, -0.03913515f, -0.02600235f, 0.16143706f, 0.10649723f, 0.33327970f, 
    -0.46539319f, 0.04133658f, 0.11011796f, 0.34235120f, -0.30502340f, -0.28004885f, -0.48142827f, -0.39707142f, 
    -0.30828467f, -0.11143340f, -0.17444286f, -1.08505511f, -0.05036155f, -0.35906762f, 0.28003412f, -0.05355412f, 
    0.60042739f, 0.71877134f, -0.02539634f, 0.28022832f, -0.09348436f, 0.35018587f, -0.17232832f, 0.13114174f, 
    -0.32195842f, 0.38555998f, 0.19644655f, -0.00178501f, -0.06249340f, 0.14957196f, 0.08258805f, -0.03612357f, 
    -0.12081445f, 0.22490211f, 0.25828350f, 0.10493712f, -0.21940628f, 0.59786016f, 0.11892255f, 0.31218219f, 
    -0.69898963f, -0.82471913f, -0.32288575f, -0.64994001f, -0.03390699f, -0.52067822f, 0.48964402f, 0.47526562f, 
    0.00527028f, -0.23074792f, -0.21471210f, -0.26417711f, -0.07084139f, 0.20690529f, -0.07499623f, -0.28358749f, 
    -0.00469645f, 0.11051700f, -0.05646124f, 0.14947315f, 0.20277670f, -0.18697414f, -0.79423940f, 0.58617008f, 
    0.90849763f, 0.49680546f, 0.06725766f, 0.87842894f, 0.50653124f, -0.20564531f, 0.44030669f, 0.00326194f, 
    0.12891355f, 0.30280954f, 0.05495998f, 0.08654504f, -0.58759272f, 0.10591992f, 0.05294831f, -0.21957873f, 
    -0.23417684f, -0.12613621f, 0.11612801f, -0.12217112f, 0.10492068f, 0.11785366f, 0.02492759f, -0.84264451f, 
    -0.55013174f, -0.48975083f, -0.53201258f, 0.43181556f, -0.04287409f, 0.38128719f, 0.56869131f, 0.09811857f, 
    -0.08064450f, -0.42528749f, -0.30990228f, -0.05325869f, -0.06263503f, 0.10156729f, 0.16255178f, -0.13105322f, 
    0.20573707f, -0.08494193f, 0.20337439f, -0.07300538f, -0.03126539f, -0.43278378f, -0.04866173f, 0.76898438f, 
    0.23740132f, 0.39629370f, 0.15606138f, -0.07082482f, 0.62464345f, -0.20326063f, 0.04889764f, -0.04271394f, 
    -0.11113105f, -0.50094014f, -0.46642232f, -0.30518642f, -0.32083398f, -0.13712277f, -0.46554491f, 0.24561341f, 
    0.14939308f, -0.32457930f, 0.01834289f, 0.58545160f, -0.17755733f, -0.22935927f, 0.18750493f, 0.08415559f, 
    0.91797286f, 0.55175066f, 0.55588442f, 0.12940142f, 0.59761828f, 0.14714381f, 0.30009264f, 0.14508483f, 
    0.36053231f, -0.35000226f, -0.14160006f, 0.02330551f, -0.22352315f, 0.23942655f, 0.06987308f, 0.31184781f, 
    0.08129069f, -0.22417286f, -0.16862309f, 0.26262555f, -0.06133673f, 0.25111407f, 0.47365063f, 0.25359344f, 
    0.09209453f, 0.72443372f, 0.82456285f, -0.24620691f, -0.17235230f, 0.41832161f, 0.29771766f, 0.24516611f, 
    -0.42900988f, -0.01120476f, 0.38756981f, -0.04550076f, -0.36645883f, -0.08367109f, -0.08892584f, 0.11770017f, 
    0.19525456f, 0.37726825f, -0.03138134f, 0.17849402f, 0.10013596f, -0.35935917f, 0.35044628f, -0.01737331f, 
    -0.42948836f, -0.14948943f, -0.24252519f, -0.23291720f, -0.76986212f, 0.40981182f, 0.11470357f, -0.72077549f, 
    0.01044788f, -0.02012005f, -0.08964050f, -0.55622345f, 0.28549066f, -0.08974254f, -0.00298408f, -0.12224766f, 
    0.36485970f, 0.35634786f, 0.27068704f, 0.04061138f, -0.11153666f, 0.11609391f, -0.40153518f, 0.08364730f, 
    0.06766997f, -0.04340864f, 0.39486319f, 0.97339815f, 0.60675341f, 0.73693836f, 0.90630025f, 0.90770364f, 
    -0.45453998f, -0.16597475f, -0.34954169f, 0.31814259f, -0.02130268f, 0.01746619f, -0.32302102f, -0.09565163f, 
    -0.06853949f, -0.23027448f, 0.09198682f, 0.27044410f, 0.05114158f, 0.10152773f, 0.21371970f, 0.44585997f, 
    0.32138860f, 0.01228618f, -0.02167549f, -0.01801667f, -0.94969326f, 0.62855786f, -0.17942876f, -0.66753447f, 
    0.78751242f, -0.55330813f, 0.11644681f, 0.08176310f, -0.87177086f, -0.31888294f, 0.15860426f, 0.32644200f, 
    0.38663286f, -0.07304454f, 0.14195986f, 0.19409367f, 0.12834589f, 0.00913820f, 0.35686344f, 0.12066875f, 
    0.05500424f, -0.01033768f, 0.08069737f, 0.13355260f, 0.21156004f, 0.04340943f, 0.07241186f, 0.40848163f, 
    0.09457258f, 0.41740820f, 0.50644439f, 0.55241358f, 0.16201186f, 0.14847516f, 0.60019547f, -0.01553987f, 
    -0.42593309f, -0.35659191f, -0.03560425f, 0.15321188f, 0.04822605f, 0.19942765f, -0.31764868f, -0.11618937f, 
    -0.01259101f, 0.44534180f, 0.05396082f, -0.24758953f, 0.20006771f, -0.22432205f, -0.69526875f, 1.05937505f, 
    0.49212354f, -0.36360985f, 0.84811336f, 0.53519481f, -0.18718347f, -0.70063531f, 0.10506583f, -0.49458790f, 
    -0.18679699f, -0.17070010f, 0.27464134f, 0.20937473f, -0.14458026f, -0.09996318f, 0.26961184f, 0.03473610f, 
    -0.07290851f, 0.01626661f, -0.20266053f, -0.06110679f, -0.22581019f, 0.03522453f, -0.22783491f, -0.42695770f, 
    -0.09006298f, -0.02383160f, 0.49047866f, 0.50623494f, -0.61993867f, 0.05979953f, 0.29936904f, -0.45091373f, 
    -0.40390971f, -0.05631921f, -0.20353058f, -0.18564996f, 0.41993299f, 0.50333124f, 0.24252297f, 0.32475859f, 
    0.05080902f, 0.27161208f, 0.09591450f, 0.25111157f, -0.23671764f, -0.04502499f, 0.01444415f, 0.00012315f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.27271342f, 0.14119048f, 0.03652787f, 0.06988034f, 0.19434164f, 0.15811457f, 0.21202718f, 0.04807791f, 
    0.02581825f, 0.21753703f, 0.14333040f, 0.01122459f, 0.10494932f, 0.07411398f, 0.14549419f, 0.09227682f, 
    0.08079484f, 0.08315555f, 0.08487320f, 0.26533818f, 0.27516365f, 0.03486120f, 0.18556061f, 0.21630973f, 
    0.07516317f, 0.26658133f, 0.21362075f, 0.19597763f, 0.15690495f, 0.17712571f, 0.31205323f, 0.04014299f, 
    -0.04424870f, 0.14826074f, 0.23063761f, -0.04809687f, 0.32763845f, 0.11121648f, 0.21044110f, 0.05126005f, 
    0.00691803f, -0.14356241f, 0.19526832f, 0.25013867f, 0.22696407f, 0.07107566f, 0.05937444f, 0.25464490f, 
    0.24130949f, 0.27890679f, -0.08496600f, 0.17861450f, 0.11275218f, 0.20351060f, -0.07686011f, 0.01787285f, 
    0.19225407f, 0.10117032f, 0.16568428f, 0.01395534f, 0.40983796f, 0.02032841f, -0.13686691f, 0.13708903f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04354658f, -0.08440568f, -0.04731379f, -0.04996677f, -0.06761132f, -0.11504214f, -0.00186175f, -0.10272186f, 
    0.02462779f, -0.06221427f, -0.01115703f, -0.06389105f, 0.01088706f, -0.11273704f, 0.11034225f, 0.08345821f, 
    0.00000048f, -0.04210926f, 0.07748692f, 0.00683962f, 0.03670399f, 0.03057015f, -0.02952611f, -0.04254462f, 
    -0.18118784f, 0.07010704f, 0.18962212f, 0.04693517f, -0.07818672f, 0.07652313f, -0.02358302f, -0.05890508f, 
    -0.02658444f, 0.04493162f, -0.12977809f, -0.10886037f, 0.29909629f, 0.04500683f, -0.08559678f, -0.17027822f, 
    -0.06355897f, -0.06066882f, 0.00706056f, -0.00376190f, 0.02666864f, 0.01415567f, 0.00105357f, 0.01321149f, 
    0.04415667f, -0.19006017f, -0.01279458f, 0.05042402f, -0.14815721f, 0.02072729f, -0.04125717f, -0.02736680f, 
    0.01339400f, 0.09405502f, -0.01381579f, 0.03040380f, 0.16303726f, -0.18746918f, 0.06901202f, -0.23652302f, 
    0.11625788f, 0.01389342f, 0.07056684f, -0.09472733f, 0.05596016f, -0.02499986f, 0.03598754f, 0.07921769f, 
    -0.14237939f, -0.25104377f, -0.02951946f, 0.09104346f, -0.03380672f, -0.04203857f, 0.10630284f, 0.07570852f, 
    0.02065049f, -0.11271520f, -0.04309658f, -0.03851411f, -0.14476962f, -0.01835700f, 0.15812996f, -0.08520117f, 
    -0.04581971f, 0.05174710f, -0.01046795f, -0.03982225f, -0.15955211f, 0.07277916f, 0.06694946f, -0.17701241f, 
    -0.01371325f, 0.05852669f, 0.00113213f, -0.05928852f, -0.14488754f, 0.02242119f, -0.03326080f, 0.08996695f, 
    -0.06707207f, 0.04471739f, -0.05016918f, -0.06323954f, 0.14121696f, -0.24784617f, 0.14847074f, -0.29414490f, 
    0.03037160f, -0.02139519f, 0.10037205f, 0.00813114f, -0.21995427f, -0.00757810f, -0.04828717f, -0.06070884f, 
    -0.00456870f, 0.27976766f, 0.05072159f, -0.17346820f, 0.06362408f, 0.05223309f, 0.03019889f, -0.09674806f, 
    -0.05836351f, 0.01615504f, -0.06566829f, 0.07043802f, -0.06597553f, -0.06591095f, -0.02719174f, 0.24114127f, 
    -0.11146908f, -0.05154376f, 0.10171533f, 0.01155840f, 0.04527671f, 0.05151257f, 0.04724031f, -0.08081076f, 
    0.25502583f, -0.00410797f, -0.20076720f, -0.27535465f, 0.06729849f, -0.12058476f, 0.13570608f, -0.03955786f, 
    0.02118316f, -0.03286740f, -0.02705436f, 0.02871597f, -0.06885565f, 0.02567968f, -0.05873573f, 0.05770255f, 
    0.02507727f, -0.05158358f, 0.06198369f, 0.07385454f, 0.02630137f, 0.04160152f, 0.08468472f, 0.02507602f, 
    0.08365238f, -0.00885671f, -0.12848943f, -0.01439574f, 0.12548350f, -0.06353820f, 0.06865662f, 0.08324603f, 
    -0.01921908f, -0.02099349f, -0.01415527f, -0.03044805f, -0.02697583f, 0.04534996f, 0.06491293f, 0.16686712f, 
    -0.17112783f, 0.00454923f, -0.10445222f, 0.12793931f, -0.01403084f, 0.14537640f, -0.08578040f, -0.09262314f, 
    0.04136598f, 0.02322740f, -0.07998135f, 0.22455025f, -0.20801519f, -0.02907165f, 0.04298301f, 0.09617203f, 
    -0.06767502f, -0.02965434f, 0.04172566f, -0.19921051f, 0.02101948f, 0.09819918f, 0.17708327f, -0.28820181f, 
    -0.00613948f, 0.01735591f, -0.04355508f, 0.17282850f, -0.01622627f, -0.03486156f, 0.03652087f, -0.06793804f, 
    0.01454611f, 0.01071294f, -0.06322069f, -0.04169049f, -0.09633081f, -0.09115241f, 0.11919264f, -0.10592264f, 
    0.00397831f, 0.01227419f, 0.02424349f, -0.05767437f, -0.21430582f, -0.17633907f, 0.07602590f, -0.01097196f, 
    0.04155686f, -0.01980852f, -0.06705476f, -0.02424449f, -0.11399364f, -0.04416433f, -0.00724265f, -0.08476250f, 
    0.00171469f, 0.01130106f, -0.07058722f, 0.03566695f, -0.04890282f, -0.06811047f, -0.01509207f, -0.06205114f, 
    -0.06241557f, -0.03730866f, 0.02690748f, 0.01481046f, -0.18628052f, -0.09075151f, -0.04439485f, 0.05656654f, 
    -0.06421078f, -0.06575976f, 0.08787022f, -0.02533971f, 0.02568511f, 0.06806128f, -0.01474532f, 0.03211582f, 
    -0.38395643f, 0.25414565f, 0.12758580f, -0.09124786f, 0.02691210f, 0.09691869f, -0.00923986f, 0.02893040f, 
    -0.07311195f, -0.11207964f, -0.08189213f, -0.06690221f, 0.09525109f, 0.03516550f, 0.09476927f, -0.17456765f, 
    -0.04136746f, -0.09457831f, -0.03198317f, 0.01194621f, 0.06258871f, -0.10331616f, -0.10699942f, -0.04849318f, 
    -0.32722852f, -0.00375800f, 0.12930550f, -0.17093012f, -0.11496110f, 0.00123120f, 0.07923245f, 0.04769031f, 
    0.00425302f, -0.11902011f, -0.02512766f, 0.06685024f, 0.38702539f, 0.12807055f, -0.00774553f, -0.06859995f, 
    -0.02792962f, -0.01461485f, 0.04363434f, -0.00345834f, 0.19250986f, -0.06137636f, -0.12952015f, 0.02365206f, 
    0.06199150f, 0.08984266f, 0.17375618f, 0.15360071f, 0.05081378f, -0.00686077f, -0.02965420f, -0.01076321f, 
    -0.05310652f, 0.07344384f, 0.17627786f, -0.15186349f, 0.20077722f, -0.25296003f, -0.06422343f, -0.16676812f, 
    0.00115296f, -0.03516462f, 0.06910620f, -0.08635667f, 0.05003233f, -0.08358687f, 0.02504371f, -0.00464135f, 
    0.10308608f, -0.02299068f, -0.08882717f, 0.30246115f, -0.20503421f, -0.08559883f, -0.05771140f, -0.02490976f, 
    -0.01163357f, -0.10868669f, 0.01330487f, 0.00789277f, 0.12742582f, -0.01375093f, 0.07832151f, -0.16906013f, 
    -0.01852896f, 0.03140391f, 0.00879931f, 0.09288500f, 0.06900619f, -0.03740408f, -0.06075108f, 0.00132612f, 
    -0.04755167f, 0.04969085f, -0.07907589f, 0.20469175f, -0.06560204f, 0.03352125f, -0.02213282f, -0.01280018f, 
    0.06967124f, 0.10198834f, 0.01035525f, -0.02029414f, -0.36921132f, 0.01536784f, 0.00973985f, -0.16085975f, 
    -0.00558672f, 0.01020582f, 0.02314153f, 0.00208670f, -0.05575912f, -0.03636771f, 0.07131623f, -0.00133819f, 
    0.03977585f, -0.01092140f, -0.04458048f, -0.16250303f, 0.02087747f, 0.04496902f, 0.00171651f, -0.02366163f, 
    -0.10098644f, 0.02315918f, -0.04381568f, -0.02578913f, 0.11165113f, -0.03305763f, 0.01674043f, -0.17782761f, 
    -0.06075405f, 0.18983085f, 0.06800716f, -0.06240450f, -0.08964967f, 0.04018865f, 0.08766293f, 0.06489763f, 
    -0.08470657f, -0.04169462f, 0.09627065f, -0.26171339f, -0.08363570f, -0.01110299f, 0.03505068f, -0.09662177f, 
    -0.09018934f, 0.07443834f, -0.01903445f, 0.01996138f, 0.02047570f, -0.11752290f, 0.08582853f, 0.25687048f, 
    -0.11116686f, 0.03207203f, -0.00385930f, -0.00946590f, -0.02550418f, -0.01134924f, 0.02402263f, 0.03523969f, 
    0.12590860f, -0.15731038f, -0.13951194f, 0.16138491f, -0.04816169f, -0.04202927f, -0.07812540f, -0.03682524f, 
    -0.09058364f, -0.01821822f, 0.13092236f, 0.03737386f, 0.10788353f, -0.05975084f, 0.04018248f, 0.00073648f, 
    0.03563162f, -0.03891349f, -0.03121531f, -0.03290022f, -0.14618151f, 0.09963288f, -0.04317440f, 0.01683856f, 
    0.02329816f, 0.03676556f, -0.09091492f, 0.18320774f, -0.11387851f, -0.04278217f, -0.00573685f, 0.07509134f, 
    -0.04577117f, 0.03241877f, -0.08300458f, 0.06390662f, -0.12526929f, 0.17031233f, 0.02952074f, 0.04747022f, 
    -0.10626055f, -0.00220383f, -0.12665001f, -0.02715100f, -0.00257147f, -0.00121158f, 0.08276198f, -0.01815050f, 
    0.52594072f, 0.06845370f, 0.10066754f, -0.11641402f, 0.00993037f, -0.00077150f, 0.07497738f, -0.00167266f, 
    -0.00485386f, -0.01620183f, 0.00688638f, 0.06050482f, 0.42593890f, -0.04780971f, 0.08532437f, -0.11981856f, 
    0.00064000f, 0.01459953f, 0.03249667f, -0.04614491f, 0.09088292f, 0.06774694f, -0.04074996f, 0.00645156f, 
    0.19487472f, -0.04057647f, -0.21692947f, 0.07512040f, 0.06611696f, -0.17307858f, -0.03703166f, -0.03207686f, 
    0.00361207f, 0.05717767f, 0.11681566f, -0.02804608f, -0.16285905f, 0.14271364f, -0.08645667f, -0.14986297f, 
    -0.01523456f, 0.02216227f, 0.01780368f, 0.00095697f, 0.01365160f, -0.01734046f, -0.01186585f, -0.00388061f, 
    -0.11277604f, -0.09701840f, -0.05034789f, -0.14020550f, -0.04639342f, -0.09136872f, -0.04895892f, -0.01217203f, 
    -0.01809707f, -0.01458738f, 0.03098265f, 0.05782668f, -0.41447368f, -0.03730377f, -0.23382442f, 0.28343740f, 
    0.04044284f, 0.06511112f, -0.02978411f, -0.08334104f, 0.06888440f, 0.04492551f, -0.11977004f, 0.00881898f, 
    0.04049822f, 0.12149570f, 0.13255636f, -0.14376730f, 0.08277490f, 0.05764475f, -0.01097151f, 0.08599789f, 
    0.00934871f, -0.03949609f, -0.07318971f, 0.00966760f, -0.05968837f, 0.02620714f, -0.09880339f, -0.03372769f, 
    -0.01676388f, -0.02732291f, 0.05816564f, 0.03048281f, -0.03756361f, 0.01481293f, -0.09373681f, -0.07112222f, 
    0.09796077f, 0.08022303f, 0.06041579f, -0.07917463f, -0.13689245f, -0.05751056f, -0.01448164f, 0.08746877f, 
    0.03493016f, -0.09068932f, -0.10906161f, -0.03029224f, -0.39435649f, -0.02100437f, -0.00075675f, 0.03835115f, 
    -0.00704749f, 0.06522432f, -0.06774968f, 0.03054600f, 0.10545140f, 0.05077042f, 0.00817904f, 0.08290969f, 
    0.08988193f, -0.04676877f, -0.04255123f, 0.34170997f, -0.07989126f, 0.06692111f, 0.00920945f, 0.05331374f, 
    0.13437839f, 0.11579848f, -0.13751791f, 0.02770798f, 0.42005843f, -0.00817761f, 0.06274027f, -0.08573164f, 
    0.02527197f, 0.03682156f, -0.13601321f, -0.04225466f, 0.04204231f, 0.02924125f, -0.03524122f, -0.06431367f, 
    -0.32669547f, 0.00738345f, -0.02344248f, 0.13456325f, -0.01200690f, 0.01476223f, -0.04797223f, -0.09987237f, 
    0.03639352f, 0.13301185f, -0.06762158f, -0.04688029f, -0.28676167f, 0.22070144f, -0.09636270f, 0.21035194f, 
    -0.09135885f, -0.03694544f, 0.09327734f, -0.05527119f, -0.07156535f, -0.05886299f, -0.02919943f, 0.02228545f, 
    0.12501633f, 0.00933191f, -0.09178884f, -0.19187051f, 0.08916280f, 0.01610956f, 0.13483272f, 0.07678396f, 
    0.04008245f, 0.01455988f, 0.03429885f, 0.07398828f, 0.08823699f, -0.07866673f, -0.02368505f, 0.08897283f, 
    -0.08885272f, -0.09956033f, 0.00937083f, 0.05570041f, -0.20841983f, -0.00284467f, -0.16714001f, 0.01750336f, 
    0.18697795f, 0.02980492f, -0.04191707f, -0.13382505f, -0.08025434f, -0.07723323f, -0.08462397f, 0.04553403f, 
    0.05068912f, -0.03555907f, -0.09445363f, -0.11242173f, 0.07104603f, -0.07931811f, 0.15672538f, -0.15935071f, 
    -0.20501797f, 0.04585600f, 0.06713533f, 0.01225146f, 0.10963971f, 0.01690165f, 0.08247803f, -0.03511054f, 
    -0.12348721f, -0.07822882f, 0.00027689f, 0.18996060f, -0.01702728f, -0.07996538f, 0.07140001f, -0.10174728f, 
    0.02646034f, 0.07920018f, -0.00823444f, -0.08512267f, 0.23922510f, 0.05565665f, -0.06053044f, 0.11546298f, 
    -0.16192961f, -0.03977944f, -0.00582173f, 0.01694816f, 0.04314148f, 0.02064594f, -0.04194744f, -0.04213174f, 
    -0.43645224f, -0.05744294f, 0.05438921f, 0.02722730f, 0.05322538f, -0.01038238f, -0.06115139f, 0.03029140f, 
    0.01848491f, -0.01824727f, -0.10311329f, -0.06437231f, -0.06354798f, -0.01318787f, 0.16817474f, 0.09166498f, 
    -0.04186045f, 0.07750820f, 0.02853577f, -0.05277412f, -0.00339484f, 0.04366377f, 0.00920859f, -0.00675216f, 
    -0.25923708f, -0.07989304f, 0.20371127f, -0.15993187f, -0.07909726f, -0.04749984f, 0.06615364f, -0.07520787f, 
    0.12509589f, -0.07608321f, -0.10226668f, 0.02766016f, -0.01204304f, 0.18620175f, -0.14255188f, 0.11225879f, 
    -0.11106036f, 0.03731450f, -0.04012656f, 0.01333912f, 0.00334652f, -0.02587520f, 0.01244552f, 0.02923567f, 
    -0.20176840f, 0.12540413f, -0.06071324f, -0.20453104f, 0.05416252f, 0.02793919f, 0.05665001f, -0.01676771f, 
    0.03252559f, -0.00297311f, 0.00868593f, -0.01902755f, 0.03487326f, -0.07339046f, -0.19020930f, -0.14904970f, 
    0.05480399f, -0.08953854f, -0.06237902f, 0.01715329f, -0.10205475f, -0.11594084f, -0.03786208f, -0.06573901f, 
    0.06784042f, 0.09577148f, -0.14594975f, 0.10583370f, -0.01158028f, 0.10203739f, -0.00282312f, -0.06339490f, 
    0.03168048f, 0.17387792f, -0.07910819f, 0.06323005f, -0.10948893f, -0.02082466f, -0.05448735f, -0.12751774f, 
    0.00651763f, 0.01773017f, -0.04960147f, -0.05564844f, 0.09924010f, -0.10448580f, 0.00701888f, 0.02870310f, 
    -0.01266370f, -0.16732153f, 0.06228117f, 0.21396315f, -0.01859869f, 0.03612118f, -0.14821306f, 0.07219099f, 
    -0.06403048f, -0.13531509f, -0.06709865f, -0.07800495f, 0.06610852f, -0.24653514f, 0.16607387f, -0.22786646f, 
    -0.07768819f, -0.01143161f, -0.06986967f, 0.06803203f, -0.08393244f, 0.00005957f, 0.00870781f, -0.06845765f, 
    0.17227164f, 0.09390900f, -0.09927412f, -0.14329146f, 0.02084146f, 0.05531822f, 0.00165522f, 0.01170133f, 
    -0.00235831f, 0.00317840f, 0.08185743f, 0.04603368f, -0.12238647f, 0.05428196f, 0.05328383f, 0.06453122f, 
    -0.01879305f, 0.08048369f, -0.01947944f, -0.05936302f, 0.26142463f, 0.13365597f, -0.16349661f, -0.00874476f, 
    0.23484598f, -0.34705177f, 0.13100874f, 0.03988061f, -0.07987457f, -0.08944060f, 0.00061804f, 0.01879358f, 
    0.01844296f, -0.04601545f, -0.08650777f, 0.23039015f, 0.16616763f, -0.11206575f, 0.14805010f, -0.20019734f, 
    -0.10609888f, -0.01356140f, 0.01687859f, -0.00157631f, 0.06914234f, -0.14434515f, 0.05548134f, -0.08182228f, 
    0.25696102f, -0.02683822f, 0.02334740f, -0.04690111f, 0.00249447f, 0.02370023f, -0.13825758f, 0.10057560f, 
    0.12901011f, -0.02015414f, 0.01956132f, 0.01657037f, 0.21187791f, 0.13161708f, -0.04656785f, 0.00338066f, 
    -0.06486761f, -0.00073430f, -0.01491958f, 0.02575587f, 0.00522978f, -0.08315785f, -0.01269666f, 0.03656801f, 
    -0.02723025f, -0.13626842f, 0.06459972f, -0.24995218f, 0.15835005f, 0.02654621f, -0.04614668f, 0.07525709f, 
    0.04888534f, 0.02030941f, 0.03075066f, -0.00939675f, -0.08589737f, 0.02304592f, -0.18651514f, 0.06457815f, 
    -0.12904391f, -0.00525537f, 0.09808450f, -0.05127562f, -0.11725816f, -0.08344556f, -0.05735754f, -0.04925155f, 
    -0.09577936f, -0.02930872f, -0.05079958f, -0.08627593f, -0.05515038f, 0.09422004f, -0.04448924f, 0.11835856f, 
    0.07239950f, -0.03822073f, -0.14251409f, 0.01074370f, 0.25040311f, -0.13442113f, 0.07033133f, 0.00390791f, 
    0.00536548f, -0.05541871f, 0.02560251f, -0.01336923f, -0.11978624f, -0.04871131f, 0.00276948f, 0.17348784f, 
    0.14417587f, -0.07772786f, 0.11517347f, 0.20928381f, -0.03757972f, 0.07928652f, 0.02651067f, -0.00075908f, 
    0.05130273f, 0.05889820f, -0.04134765f, 0.06704342f, 0.05996936f, -0.00226179f, 0.03464662f, -0.06288618f, 
    0.05808569f, -0.06396641f, 0.15348272f, -0.03314250f, 0.11717384f, 0.02658183f, 0.01768684f, -0.00225189f, 
    -0.26801655f, -0.03161307f, 0.00490006f, -0.02874769f, 0.10420965f, 0.02012027f, -0.05102742f, 0.18310669f, 
    0.01398914f, 0.00232573f, 0.05080877f, 0.06065386f, 0.40447083f, -0.11212240f, 0.07394016f, -0.12142772f, 
    -0.05174630f, 0.04597085f, -0.01952775f, 0.04465059f, 0.02712776f, -0.09862330f, 0.11750001f, 0.06389479f, 
    0.02811309f, 0.07139461f, -0.00776084f, 0.02052129f, -0.10518350f, -0.00864998f, -0.05176967f, -0.01418565f, 
    -0.07280114f, 0.00071039f, 0.06738386f, -0.01673543f, 0.05388574f, 0.02487295f, 0.05951554f, -0.14013761f, 
    -0.19045563f, 0.09201416f, 0.02339546f, 0.01768094f, -0.20105059f, -0.06895576f, 0.03152222f, -0.00927042f, 
    -0.36139512f, -0.01336595f, -0.19349271f, -0.13869232f, -0.00432508f, -0.02120501f, -0.00532316f, -0.01034021f, 
    0.13710447f, 0.18103030f, 0.04707856f, 0.08607589f, -0.03069830f, -0.26256454f, 0.00328638f, -0.23166241f, 
    0.05622284f, -0.06248781f, 0.06845172f, 0.02648739f, -0.03479557f, 0.08903091f, 0.03610532f, -0.03910974f, 
    0.29419157f, -0.10591301f, -0.03605982f, -0.21511471f, 0.00448860f, -0.01925009f, -0.08080078f, -0.02410224f, 
    -0.09944040f, 0.01884267f, 0.01023426f, -0.07665372f, -0.18235114f, 0.02033445f, -0.12899178f, 0.00434431f, 
    0.09659965f, 0.02840603f, -0.08927558f, 0.11278661f, -0.04893186f, -0.08746894f, 0.06544143f, -0.00912279f, 
    0.09322662f, -0.04848208f, -0.00623059f, 0.04224057f, -0.12806089f, 0.01418377f, 0.01687674f, 0.02997664f, 
    -0.06651777f, -0.07449358f, -0.23874487f, 0.13748819f, 0.02177107f, -0.07666144f, 0.10863565f, -0.12291752f, 
    -0.00670670f, -0.00219151f, -0.05944202f, -0.03088698f, -0.09542486f, 0.00275338f, 0.06226315f, -0.07731551f, 
    0.08317237f, 0.11148209f, 0.08665555f, 0.25524694f, -0.05596492f, -0.00701050f, 0.08098164f, 0.05400864f, 
    0.00895597f, -0.06252827f, -0.08651549f, -0.05692756f, -0.31710798f, 0.06361728f, -0.10772225f, -0.12083646f, 
    0.02291662f, -0.03738346f, 0.05852598f, 0.00847533f, -0.07048931f, 0.10984489f, 0.06243179f, -0.00694118f, 
    -0.46895003f, -0.09222169f, -0.31080738f, 0.03706133f, 0.09182387f, -0.06043942f, -0.00805775f, 0.05216371f, 
    -0.03387037f, 0.01823828f, -0.01022550f, 0.02851132f, 0.26230574f, -0.05337329f, -0.00558120f, -0.18639091f, 
    -0.02486675f, 0.07032600f, 0.03315826f, -0.02086507f, -0.10634956f, 0.06480753f, 0.10379104f, 0.03071763f, 
    -0.13395071f, -0.10676084f, -0.11418164f, -0.09632795f, 0.00096247f, 0.01444992f, -0.10472459f, 0.12959200f, 
    0.06568247f, 0.00959165f, 0.00359718f, 0.07662076f, -0.01799545f, -0.09360650f, -0.06615496f, -0.20402683f, 
    -0.07373555f, -0.13368194f, -0.04851688f, -0.07482389f, 0.05725067f, 0.02068593f, 0.00471888f, 0.08841304f, 
    0.17392598f, 0.13131121f, -0.04562082f, -0.05487240f, -0.05838680f, 0.04403330f, -0.00366516f, 0.04882617f, 
    0.04070457f, -0.01879768f, -0.05276670f, 0.07492265f, 0.45072308f, -0.29765606f, -0.17324808f, 0.00253594f, 
    -0.09822571f, -0.02643439f, 0.00128026f, -0.08344376f, -0.06623024f, 0.17353328f, -0.13074920f, 0.08903352f, 
    -0.30453721f, -0.15288930f, -0.07232267f, 0.13611344f, 0.04573862f, 0.03020535f, -0.00084611f, 0.16660565f, 
    0.01127273f, -0.05380976f, 0.00126721f, 0.13274503f, -0.15628551f, 0.11391534f, 0.00788333f, -0.05956255f, 
    0.02513173f, 0.05758738f, -0.01500972f, -0.00735653f, -0.08311411f, -0.18675728f, 0.04107863f, -0.12434087f, 
    0.09849260f, 0.07338296f, 0.12554254f, 0.00148153f, -0.14265230f, 0.02275748f, 0.02241275f, 0.00806100f, 
    -0.02847425f, -0.02772722f, 0.12929034f, -0.06086767f, -0.21096288f, -0.08406754f, -0.24657731f, -0.05351511f, 
    -0.04833270f, -0.01855185f, 0.07165258f, -0.01946205f, -0.07742795f, 0.00063263f, -0.19947295f, 0.11752243f, 
    -0.70598215f, -0.08894626f, -0.03464266f, -0.12162463f, 0.03895847f, -0.06450482f, -0.06015898f, -0.11500449f, 
    0.07616854f, 0.08168036f, -0.11984791f, -0.09961993f, -0.59560943f, -0.15841955f, -0.01152635f, 0.00703006f, 
    -0.07039212f, -0.03986332f, -0.05561989f, -0.13169305f, 0.03107038f, -0.15117195f, 0.02074326f, -0.03715844f, 
    0.41514122f, -0.07518049f, 0.17944787f, -0.01383293f, 0.06690634f, 0.00686958f, -0.02709925f, 0.05579400f, 
    0.00566236f, 0.04836626f, -0.12058702f, 0.00897988f, 0.20615138f, -0.22730142f, -0.10796335f, 0.02231303f, 
    -0.09786414f, 0.04806562f, -0.08382500f, 0.05798651f, 0.10482291f, -0.09453695f, -0.03035294f, 0.08112764f, 
    0.17892581f, -0.08929734f, 0.00914786f, 0.02317207f, -0.04299119f, -0.01610478f, -0.02435138f, 0.02530798f, 
    -0.09154572f, -0.04982114f, -0.15438278f, 0.04092932f, -0.19601147f, 0.02995772f, 0.02858436f, -0.02709190f, 
    -0.10605137f, 0.03130202f, -0.06812211f, 0.04500897f, -0.01124904f, 0.01836117f, 0.01868148f, 0.04085264f, 
    0.16134988f, 0.06852721f, -0.25324565f, -0.02032045f, -0.00989417f, -0.04283862f, 0.01184396f, -0.00380974f, 
    -0.00975646f, 0.00385208f, -0.08156789f, -0.02958255f, -0.11882117f, -0.06663233f, -0.04101970f, -0.07841930f, 
    -0.01732572f, 0.00766654f, 0.09834869f, -0.01351489f, 0.08020019f, 0.03839596f, -0.06643909f, 0.04576739f, 
    0.11556522f, 0.10834529f, -0.00000712f, 0.10434101f, -0.09143340f, 0.04506696f, 0.03712503f, 0.01517692f, 
    0.06764147f, 0.05846057f, 0.04722515f, 0.08087062f, 0.08400646f, 0.05412180f, -0.15468752f, 0.09790322f, 
    -0.05311190f, -0.03327214f, -0.08529422f, 0.03912365f, -0.04321191f, -0.04847145f, -0.12808748f, -0.04173718f, 
    0.02221127f, -0.06156996f, -0.09713182f, 0.18167412f, 0.11753076f, -0.05726228f, -0.18865526f, 0.01245693f, 
    0.02939819f, -0.14080237f, 0.02395136f, -0.09582225f, -0.13744122f, 0.14144576f, -0.11334283f, -0.07010306f, 
    0.00982261f, 0.02465312f, 0.02455938f, -0.00915444f, -0.00682551f, 0.03614226f, -0.11503904f, 0.13035239f, 
    -0.08358512f, -0.42443386f, -0.46600130f, -0.04082414f, -0.03048416f, 0.05718640f, 0.03459403f, 0.11490211f, 
    0.03078738f, -0.01109546f, 0.12215782f, -0.00980731f, 0.10781526f, 0.07973420f, 0.03173389f, 0.23779002f, 
    0.05077104f, 0.15213932f, -0.01396030f, 0.15319948f, -0.05084442f, -0.08851217f, 0.11036902f, -0.13877939f, 
    0.01216726f, -0.00246598f, 0.02003663f, -0.11224462f, 0.10448379f, -0.01460390f, -0.14711006f, 0.10281462f, 
    0.09822606f, 0.11180473f, -0.03150651f, -0.10054164f, 0.07315871f, 0.05608673f, 0.06658252f, 0.09389427f, 
    -0.06840125f, 0.00695311f, 0.03145406f, -0.00489219f, 0.08839017f, -0.03195427f, -0.04657233f, -0.00072273f, 
    0.17573680f, 0.05703221f, 0.12931766f, 0.23813401f, -0.08565673f, -0.07456595f, 0.09325638f, -0.01261531f, 
    -0.15244201f, 0.05262561f, 0.04356732f, 0.09580860f, 0.27970141f, -0.08576365f, -0.03532539f, -0.14863986f, 
    -0.07072637f, -0.15060550f, 0.00007353f, -0.00271031f, -0.13640654f, -0.06798612f, -0.01510742f, -0.10598490f, 
    0.06519134f, 0.04870430f, -0.04487219f, -0.01617669f, 0.03527883f, 0.11662576f, -0.05450318f, 0.09132325f, 
    -0.11442737f, 0.02399476f, 0.12132154f, -0.06963227f, 0.25553694f, -0.06067105f, 0.11081482f, 0.39422712f, 
    -0.03989843f, -0.01849035f, 0.06355895f, 0.02659974f, 0.02154367f, -0.02583994f, -0.03714276f, -0.01192656f, 
    0.09774194f, 0.10614903f, -0.07346434f, -0.31652236f, -0.01995569f, 0.07158761f, 0.08101529f, -0.02458686f, 
    0.02338392f, 0.17937344f, 0.06236511f, 0.01919197f, 0.18485887f, -0.01467635f, 0.05125692f, 0.02882537f, 
    0.05129825f, -0.02453137f, -0.05121872f, 0.03070306f, 0.16292836f, 0.08161448f, -0.06954695f, 0.10342695f, 
    0.17855424f, 0.03503018f, -0.16646580f, -0.11613035f, -0.06700363f, 0.04136527f, -0.01279355f, -0.09718680f, 
    -0.00965325f, -0.03416219f, 0.06012553f, -0.02318379f, 0.00482840f, 0.07440610f, -0.03862214f, 0.10832801f, 
    0.00844765f, 0.05417379f, -0.07907942f, -0.03741825f, 0.04533643f, 0.06055046f, -0.05843959f, 0.12846337f, 
    0.30928984f, 0.04764591f, -0.25946289f, 0.05230926f, 0.16883361f, 0.06806619f, -0.06162428f, -0.08363296f, 
    -0.10038257f, -0.06482159f, -0.03156944f, -0.04607206f, -0.03187373f, -0.19244905f, -0.00947351f, -0.00219559f, 
    0.01662065f, -0.01007604f, 0.04247463f, -0.09261506f, -0.06128910f, -0.03549502f, -0.00967850f, -0.02428997f, 
    0.20421179f, -0.08701196f, 0.05902912f, 0.09981805f, -0.11905157f, -0.09395849f, -0.09522807f, -0.01003679f, 
    0.07707008f, -0.05476055f, -0.01127694f, -0.01031321f, 0.01809794f, -0.01241383f, 0.04430899f, 0.04446251f, 
    0.00993145f, 0.03925969f, -0.02929189f, 0.12628743f, 0.03143718f, 0.00840581f, -0.00939535f, -0.12015112f, 
    0.36945474f, -0.03556452f, -0.05854506f, 0.04725328f, 0.02963248f, 0.04434389f, 0.01554245f, 0.00736978f, 
    -0.06486642f, 0.03971595f, -0.01784850f, -0.08224398f, -0.07740662f, 0.03610761f, 0.03792505f, 0.03010822f, 
    -0.00276845f, -0.05285158f, 0.08335631f, -0.07658215f, -0.04503500f, -0.09770856f, -0.03781157f, -0.05701454f, 
    -0.00194119f, -0.12110355f, -0.06986861f, 0.06008598f, -0.05925999f, -0.06361903f, -0.05576446f, 0.01057627f, 
    -0.07462646f, -0.04701548f, 0.00370837f, -0.02860760f, -0.50632727f, -0.12920421f, 0.00243743f, -0.14425296f, 
    -0.11822534f, 0.01536908f, -0.18382724f, -0.03830084f, 0.02773418f, -0.02136047f, 0.01453125f, -0.10971875f, 
    0.25472116f, -0.11532526f, 0.00628413f, -0.12084104f, 0.00790285f, -0.04040506f, 0.08733094f, 0.14528769f, 
    -0.01784855f, -0.00486344f, 0.10590024f, -0.07364228f, -0.47149730f, -0.13445717f, 0.08312330f, -0.20030501f, 
    -0.02992508f, 0.14069439f, -0.04184462f, -0.02678228f, -0.03655369f, -0.02138592f, -0.13585453f, -0.02489772f, 
    0.10076245f, 0.07241388f, -0.04073320f, 0.12274114f, -0.06450537f, 0.01454879f, 0.05331433f, 0.03274182f, 
    -0.06237727f, -0.00449371f, 0.07312484f, 0.00874502f, 0.01766955f, -0.02713303f, -0.03196635f, 0.03502126f, 
    -0.00304971f, 0.02736292f, -0.06887635f, 0.01648182f, -0.03320743f, -0.03757234f, -0.07204860f, -0.05876236f, 
    0.04117130f, 0.19074829f, 0.06921808f, 0.32700649f, -0.11164109f, -0.06543338f, 0.05506874f, 0.04159690f, 
    -0.07391472f, 0.00770426f, -0.04060794f, 0.01277493f, 0.21617442f, -0.07514202f, -0.11205491f, -0.25104466f, 
    -0.02998672f, -0.00686493f, 0.04073924f, 0.00381282f, 0.02232282f, 0.09292983f, -0.01930155f, 0.00794771f, 
    -0.01402299f, -0.10962625f, 0.04425732f, 0.11055411f, -0.00587981f, -0.04720218f, -0.06799858f, -0.00233002f, 
    -0.03438878f, 0.00381478f, 0.02188840f, 0.09648220f, 0.19616015f, -0.00324467f, 0.07188486f, -0.17740914f, 
    0.00460441f, -0.02746904f, 0.05555680f, 0.07522023f, -0.08813037f, 0.08109856f, 0.07209465f, 0.00748089f, 
    -0.16679430f, 0.01812473f, 0.03120322f, -0.10150204f, 0.10529283f, -0.06669197f, -0.09965232f, 0.11333820f, 
    0.00997815f, -0.03143972f, 0.10719664f, -0.06474752f, -0.13048647f, 0.12502183f, -0.19622475f, 0.03505508f, 
    0.14125161f, 0.09914661f, 0.02681303f, -0.06459145f, -0.09481417f, 0.04061684f, -0.05070736f, -0.08664469f, 
    0.11746550f, 0.01763292f, -0.04223703f, -0.01622018f, -0.01667873f, -0.06095973f, 0.01368849f, -0.03264579f, 
    -0.16155504f, 0.06419612f, -0.06179088f, -0.01714343f, 0.35736114f, -0.16755371f, 0.01890047f, -0.05778759f, 
    -0.00809165f, -0.06427944f, -0.04155114f, -0.03366800f, -0.03477213f, 0.03762844f, -0.01145378f, 0.02675296f, 
    -0.17013012f, 0.11305933f, 0.03654066f, -0.05705158f, -0.15326507f, 0.13590644f, 0.01466915f, 0.06770082f, 
    0.00044642f, 0.02763532f, 0.01645507f, 0.01668508f, 0.18533388f, -0.08273640f, 0.04270596f, 0.02416592f, 
    -0.04017672f, 0.04473602f, 0.06779037f, 0.02053818f, 0.06351382f, -0.01500723f, -0.00201350f, -0.02874854f, 
    -0.07137437f, 0.05359086f, -0.18572406f, -0.28013724f, 0.02452303f, 0.08249132f, 0.00213705f, 0.01356087f, 
    -0.06161760f, -0.06069659f, -0.03980411f, -0.09806618f, -0.37501684f, 0.07613055f, -0.06163369f, -0.13130693f, 
    0.05542162f, 0.03631172f, 0.06451532f, -0.05409375f, -0.11668491f, 0.05345149f, -0.01938566f, -0.08362715f, 
    -0.23750971f, -0.11506981f, 0.05150750f, -0.23635541f, 0.01547141f, -0.09138305f, 0.07263985f, -0.04150228f, 
    -0.00468446f, -0.00993062f, -0.02875265f, -0.01194897f, 0.17429160f, 0.02687697f, -0.01579927f, -0.02585433f, 
    0.05399665f, -0.11750202f, -0.05654747f, 0.08030455f, -0.03737446f, -0.05833824f, -0.21285021f, 0.00033590f, 
    -0.00398197f, -0.14740478f, 0.01035994f, -0.04152253f, 0.13876221f, -0.05895656f, 0.00853540f, -0.05947530f, 
    0.03206179f, -0.00707753f, -0.02219851f, -0.09101542f, -0.19064853f, 0.09149400f, 0.05031571f, 0.08838726f, 
    0.02122309f, -0.07159792f, -0.06259990f, 0.02566103f, -0.07147446f, 0.09474819f, -0.06655496f, -0.01269316f, 
    -0.05599999f, 0.06385564f, -0.07702733f, -0.01553574f, 0.03024954f, 0.02046609f, 0.02854707f, 0.02040007f, 
    -0.01356740f, 0.00609978f, 0.04216890f, -0.10496197f, 0.26019537f, 0.11802971f, 0.02510508f, 0.12960050f, 
    -0.03054215f, -0.13529347f, -0.06338265f, 0.07141108f, -0.05037365f, 0.07115512f, -0.00715107f, -0.08862709f, 
    0.13894871f, -0.13588478f, -0.03552793f, -0.05297581f, -0.10135762f, -0.02557574f, -0.05683130f, 0.03587319f, 
    -0.02893136f, -0.03304461f, -0.00216681f, 0.05204216f, -0.39009741f, 0.05846161f, -0.15081531f, -0.05653832f, 
    -0.05421916f, -0.12511307f, -0.00600188f, 0.00237708f, -0.02090167f, -0.00680432f, 0.00994054f, -0.04488953f, 
    -0.15551364f, -0.01521035f, -0.04070974f, 0.05521169f, -0.05295138f, -0.02717183f, -0.00329832f, -0.08652219f, 
    -0.00219518f, -0.00683409f, -0.01521622f, 0.07084303f, 0.06369774f, 0.00808823f, 0.17849563f, -0.06193073f, 
    -0.02867364f, -0.02514884f, 0.02821014f, -0.01254566f, 0.00584718f, -0.05582217f, 0.09823680f, -0.06329687f, 
    -0.24057013f, -0.02030100f, 0.02764321f, -0.17851010f, 0.00550153f, -0.02611258f, 0.06776506f, 0.00593044f, 
    -0.06065965f, 0.00918058f, -0.12497074f, -0.01119866f, 0.19076085f, -0.21222772f, 0.04852516f, -0.13852565f, 
    -0.07623476f, 0.05423021f, 0.04971582f, 0.03988274f, -0.01695279f, -0.01322335f, 0.02413146f, -0.01776842f, 
    0.31518129f, -0.14671862f, -0.05426480f, -0.06478699f, -0.12572184f, 0.07980508f, -0.09231103f, -0.01853483f, 
    -0.07175058f, -0.07948118f, 0.04064475f, -0.10689034f, 0.01781815f, 0.08460413f, -0.06836981f, 0.02936323f, 
    -0.01202256f, 0.04997709f, -0.11383317f, 0.04642085f, -0.11111159f, 0.08199883f, 0.06558290f, -0.00860932f, 
    0.04369790f, 0.00628893f, 0.01061449f, -0.01375214f, 0.06839419f, 0.04162559f, -0.03699408f, 0.00820961f, 
    0.01478270f, 0.04448345f, -0.07990025f, 0.09260307f, 0.15632594f, -0.08873060f, -0.07490644f, -0.33756980f, 
    -0.02025471f, 0.06309782f, -0.00263021f, 0.03715553f, 0.00717887f, -0.10114407f, -0.04762376f, -0.05438905f, 
    0.25207093f, 0.05214725f, -0.06929921f, 0.05838435f, 0.13281222f, 0.08401015f, 0.03051005f, 0.06523680f, 
    -0.04453713f, 0.10364804f, 0.11047931f, -0.04846487f, 0.40182388f, -0.03779064f, 0.10923734f, -0.07455309f, 
    0.03119604f, 0.10045489f, 0.03926183f, 0.07171846f, -0.02868679f, 0.06824630f, 0.00112279f, -0.07804482f, 
    0.01432754f, 0.02872191f, 0.00145122f, -0.01044347f, -0.03310743f, -0.00860338f, 0.04617788f, 0.06927386f, 
    -0.08534474f, -0.07663306f, 0.13251078f, -0.06909917f, 0.29826397f, -0.05264468f, 0.10708556f, 0.19071108f, 
    -0.10961946f, -0.11359271f, 0.00001542f, 0.05866967f, 0.01542227f, -0.01211395f, 0.09591039f, 0.03184076f, 
    0.05079867f, -0.06637625f, 0.00740465f, -0.06455562f, -0.07712001f, -0.05925164f, 0.05419562f, 0.00806661f, 
    -0.07557783f, 0.04820868f, -0.02302250f, -0.04748929f, -0.12226783f, -0.07453100f, -0.35567701f, -0.27816734f, 
    0.02007841f, 0.01737163f, -0.01364315f, 0.01931266f, 0.05836902f, 0.08903698f, -0.05843192f, 0.01304635f, 
    0.25896481f, -0.07080263f, 0.16053057f, 0.14593914f, -0.13329139f, -0.09853242f, 0.00834910f, 0.03605833f, 
    0.00313262f, -0.04107964f, 0.01554617f, -0.04569367f, -0.32590100f, 0.02054679f, -0.06605617f, -0.22618733f, 
    0.00240693f, -0.01559976f, 0.00755256f, -0.01723675f, 0.00354769f, -0.04229677f, -0.04110193f, -0.09910215f, 
    0.06604811f, 0.07850510f, -0.04583447f, 0.00125049f, 0.08042185f, 0.01869584f, -0.00239100f, 0.00599357f, 
    -0.06823386f, -0.03151658f, -0.02329414f, -0.04579996f, 0.34790868f, 0.03798230f, -0.11681571f, -0.07990929f, 
    -0.05938120f, -0.10194232f, -0.07329258f, -0.03280275f, 0.07588752f, -0.02510351f, -0.02851726f, -0.13956636f, 
    -0.10851027f, -0.18440004f, -0.10801649f, 0.01842606f, 0.03894875f, 0.05752764f, -0.04659312f, 0.01850242f, 
    -0.07687963f, 0.15515938f, -0.06270268f, -0.12527709f, 0.18122743f, 0.08952843f, 0.07404523f, -0.03787141f, 
    -0.01999734f, -0.08296579f, -0.13395163f, 0.05694081f, -0.03354139f, -0.05406168f, -0.02910069f, -0.08548558f, 
    -0.05444328f, -0.04240549f, -0.14653032f, -0.20488489f, 0.04384713f, -0.03376267f, -0.04441217f, -0.06575847f, 
    0.00145581f, 0.02057528f, 0.01535865f, -0.02244222f, 0.20462614f, -0.02924316f, 0.01998421f, 0.03051870f, 
    -0.00433064f, 0.06378008f, -0.00370784f, 0.03856615f, 0.06393445f, 0.02533974f, 0.01278031f, 0.00267710f, 
    -0.09287323f, 0.13664900f, 0.03650323f, 0.31675223f, -0.13841881f, -0.06108942f, 0.00506696f, 0.06445097f, 
    -0.02754502f, -0.04785728f, -0.04931214f, -0.01044411f, -0.27685609f, 0.01677626f, 0.05348305f, -0.11926178f, 
    0.05974674f, -0.03487908f, -0.03448282f, 0.04340870f, 0.02843531f, -0.13507226f, -0.04376835f, 0.01265138f, 
    -0.03198487f, 0.01669293f, -0.06052258f, -0.06473343f, 0.13680066f, -0.05297114f, 0.04086852f, -0.06148083f, 
    -0.09987280f, 0.02432457f, 0.03481159f, -0.06022297f, 0.10715824f, -0.25990465f, 0.09957592f, -0.17754193f, 
    0.09848725f, -0.03914985f, 0.06458898f, -0.00694649f, -0.00655893f, -0.05608029f, 0.02750509f, -0.05068228f, 
    0.35486463f, -0.15754054f, -0.16042709f, -0.13263629f, -0.05266621f, -0.07210284f, 0.02151914f, -0.05847231f, 
    0.05201605f, 0.10690299f, 0.03437246f, -0.06635697f, -0.11425899f, 0.00998661f, -0.12263042f, 0.03188524f, 
    0.12716384f, 0.02246499f, -0.04667407f, -0.03289655f, 0.04725010f, -0.04542274f, 0.04287319f, -0.01254238f, 
    0.13065091f, -0.05403343f, -0.12763961f, -0.08651144f, 0.09400087f, 0.00296146f, -0.02810384f, -0.11110606f, 
    -0.08040924f, -0.00203660f, -0.02128202f, -0.07147829f, 0.03832007f, 0.02375101f, 0.06960984f, -0.06354079f, 
    0.03401776f, -0.05961594f, 0.15544140f, -0.03451335f, 0.08979921f, 0.03425726f, 0.05658356f, -0.05851278f, 
    0.09951143f, -0.12597384f, -0.03488214f, -0.00715571f, 0.09395957f, 0.08780613f, 0.06354362f, -0.12350632f, 
    -0.05566040f, 0.03198418f, 0.01213175f, 0.00805867f, 0.16553642f, 0.01646003f, -0.12570851f, -0.05933513f, 
    0.06789119f, 0.02560328f, -0.06248334f, -0.01309642f, -0.03587450f, -0.08036175f, 0.01192803f, 0.00037726f, 
    -0.40344018f, 0.13173008f, 0.19516806f, 0.11333041f, 0.07675587f, 0.09932109f, 0.02317806f, 0.05015114f, 
    -0.10033268f, 0.06859469f, -0.03664573f, -0.09613074f, 0.21409471f, 0.06289898f, -0.06847110f, 0.15424693f, 
    -0.01902797f, 0.09157151f, 0.04902618f, -0.07409352f, -0.07692753f, 0.03928686f, -0.00631792f, 0.02505513f, 
    -0.31318676f, 0.06853160f, 0.02233014f, 0.13612545f, -0.03925135f, -0.08086315f, -0.05262961f, 0.06016552f, 
    -0.07655978f, 0.01874442f, 0.08141957f, -0.04241393f, 0.01298682f, 0.01342293f, -0.04230627f, -0.08541100f, 
    -0.06463811f, 0.09497954f, -0.03672740f, 0.07383205f, 0.05581599f, -0.00418596f, 0.02130917f, -0.01561844f, 
    0.14282699f, 0.06217369f, 0.14108028f, 0.13868755f, 0.03439515f, 0.06705786f, 0.10203064f, -0.05940062f, 
    -0.02284555f, -0.03648459f, 0.01956050f, -0.03476800f, 0.02165556f, 0.10357361f, -0.09589461f, 0.04474589f, 
    -0.04918591f, 0.02265063f, 0.01476393f, -0.08037792f, -0.05309563f, -0.03030130f, 0.04403307f, -0.06630835f, 
    0.06980558f, 0.09708715f, -0.04440251f, 0.06644951f, -0.12792882f, -0.02074134f, 0.03150545f, -0.04429888f, 
    -0.08373016f, -0.03097960f, 0.01917834f, -0.05988114f, 0.19852412f, -0.08152336f, 0.10738535f, 0.10597044f, 
    -0.07648993f, -0.04273934f, -0.04830112f, 0.04221728f, -0.04301229f, -0.07600355f, 0.02421962f, -0.01494472f, 
    0.09932963f, -0.07654063f, -0.09802932f, -0.07594849f, -0.05962174f, 0.02677522f, 0.03462068f, 0.05273065f, 
    -0.00750028f, 0.01588858f, 0.09376849f, 0.03098610f, 0.02675825f, 0.23069452f, 0.01077741f, 0.19293523f, 
    0.03622129f, 0.13157821f, -0.02147390f, 0.04420953f, -0.08755486f, 0.03090405f, 0.09465794f, -0.01192262f, 
    -0.37563857f, 0.09307603f, -0.12907003f, -0.17731860f, -0.05635446f, -0.02138641f, 0.03346319f, 0.02763217f, 
    -0.04911162f, -0.09470905f, -0.08135300f, 0.03026509f, -0.16137783f, -0.42039201f, -0.09404989f, 0.10702423f, 
    -0.05844162f, -0.07663344f, 0.02327464f, 0.06364644f, 0.04556004f, 0.08028001f, 0.00619103f, 0.03074425f, 
    -0.04361302f, 0.03875196f, -0.00511011f, -0.10094870f, -0.07227570f, -0.02063628f, -0.01959873f, -0.05495946f, 
    -0.04632314f, 0.02581600f, -0.07809159f, 0.09221845f, -0.00490755f, 0.10514435f, 0.08889255f, -0.08143049f, 
    -0.04209800f, -0.04186269f, -0.11258269f, 0.03412240f, 0.06978695f, 0.05520530f, 0.01661485f, 0.10174026f, 
    0.08595370f, 0.04727064f, -0.01548867f, 0.02546614f, -0.03563472f, -0.01600973f, 0.08972897f, 0.03334609f, 
    0.02397975f, -0.01149068f, 0.01236373f, 0.00942041f, -0.10527156f, -0.13805081f, -0.26546201f, -0.09230648f, 
    0.00737823f, -0.00390958f, -0.04717173f, -0.01489926f, 0.08520361f, 0.00647256f, 0.01591085f, 0.02256411f, 
    -0.21240662f, -0.33393264f, -0.08186933f, 0.08313054f, -0.11079531f, -0.02646426f, 0.01696068f, -0.04427090f, 
    0.12974393f, -0.08113745f, 0.11535475f, -0.07291361f, 0.14619319f, -0.10348070f, -0.02179987f, 0.15873669f, 
    0.02653242f, 0.01779140f, 0.03577457f, -0.00843047f, 0.07095186f, -0.06048724f, -0.10221073f, -0.05812271f, 
    0.26642689f, 0.24570863f, 0.01432628f, -0.06297008f, 0.00518175f, -0.05176715f, 0.01667250f, -0.00895895f, 
    -0.02237311f, -0.09422078f, -0.03361386f, 0.04041281f, 0.09452002f, 0.11637884f, 0.04983575f, 0.13844538f, 
    -0.09372576f, 0.04497323f, -0.00372704f, -0.08688121f, -0.08155010f, 0.05643661f, -0.05478831f, 0.02169362f, 
    -0.21394645f, -0.21542990f, -0.33120984f, 0.00861736f, -0.07795214f, -0.01164189f, 0.14861980f, -0.00466560f, 
    -0.02270783f, 0.03653409f, -0.05112885f, 0.00018073f, -0.21179517f, -0.19576991f, -0.11504972f, 0.02017295f, 
    0.11525955f, 0.03874910f, 0.00403698f, -0.03390935f, 0.02796763f, 0.00268104f, 0.03291940f, -0.06907158f, 
    0.06356937f, 0.19954488f, 0.07424597f, -0.04909461f, -0.00739538f, 0.02532857f, 0.07048653f, 0.10938986f, 
    0.04609382f, -0.01148595f, -0.02098796f, -0.06845229f, 0.15817682f, 0.02272109f, 0.05470649f, 0.16957793f, 
    -0.04041969f, 0.07984144f, -0.07846504f, 0.08381525f, 0.06562889f, 0.04655441f, -0.07625011f, 0.00367762f, 
    0.04783563f, -0.14542942f, 0.02793631f, 0.04357258f, -0.06070421f, -0.03404588f, -0.00590335f, 0.10266174f, 
    0.01369719f, 0.07536300f, -0.11975527f, -0.08003151f, 0.00252826f, 0.18306339f, -0.13786222f, -0.15752073f, 
    -0.05818419f, -0.00502250f, 0.07824723f, 0.05708807f, -0.07426978f, -0.06308949f, -0.08171003f, 0.02913721f, 
    0.21654062f, 0.02709787f, -0.04643909f, -0.02553972f, 0.00643475f, -0.00946479f, -0.09543432f, -0.21225560f, 
    0.02567283f, -0.07273800f, -0.01022152f, -0.05103426f, 0.01656835f, -0.01539827f, -0.15679324f, 0.19250500f, 
    -0.00787126f, 0.05877633f, -0.04554030f, -0.06005502f, 0.00842212f, -0.01642957f, -0.00099282f, 0.04200174f, 
    -0.05628650f, -0.33056244f, -0.21410556f, 0.05867205f, -0.02900126f, -0.07382322f, 0.05729314f, -0.04815549f, 
    -0.04346680f, 0.02175774f, -0.03957290f, 0.03090237f, -0.10409757f, -0.00607441f, 0.02300282f, -0.10801970f, 
    0.05859705f, -0.00903190f, 0.04641258f, -0.04756897f, -0.01506176f, -0.01788580f, 0.05283521f, -0.02916408f, 
    -0.29871798f, 0.24074154f, 0.01652434f, 0.07590800f, 0.03608279f, 0.00147976f, -0.05032221f, 0.06133344f, 
    -0.04129702f, -0.08336066f, 0.03175106f, 0.00803996f, -0.03111931f, -0.10210739f, 0.03589093f, -0.11099362f, 
    -0.21964516f, 0.03947077f, 0.01334136f, 0.07520179f, 0.06147056f, -0.00441667f, -0.06286267f, 0.13085967f, 
    0.05430226f, -0.04022728f, 0.00379562f, -0.08393797f, -0.03081906f, 0.03127747f, 0.12025280f, 0.15254661f, 
    -0.06991635f, -0.03411587f, -0.00728022f, 0.04002415f, -0.09390282f, -0.02797753f, -0.06714882f, -0.07887903f, 
    -0.10233234f, -0.01412412f, -0.02998515f, 0.03973467f, 0.06506929f, -0.13281083f, -0.04118925f, 0.03915726f, 
    0.13160807f, -0.32261643f, 0.05697752f, 0.14596970f, -0.01293985f, -0.06140929f, 0.01503386f, 0.01381289f, 
    -0.02136880f, -0.01689330f, -0.06582586f, 0.00356551f, -0.03254902f, 0.04550935f, 0.12274189f, 0.04453888f, 
    -0.01260754f, -0.00769601f, 0.03382486f, 0.01132490f, 0.02958019f, -0.05574103f, 0.03120378f, 0.03766921f, 
    -0.06953074f, 0.05214942f, 0.18429600f, 0.17601992f, 0.06648660f, 0.04575396f, 0.00660897f, 0.01682329f, 
    0.01507194f, 0.00593699f, -0.03955383f, -0.07305370f, 0.21577610f, -0.00586444f, 0.01965528f, -0.09039417f, 
    0.08311609f, 0.08060957f, -0.06027720f, 0.00887350f, 0.01562776f, 0.07572933f, 0.06671271f, 0.03352338f, 
    -0.08693923f, -0.32557270f, 0.04630499f, 0.22924110f, -0.02590680f, -0.06959189f, -0.05081982f, -0.02228308f, 
    0.11412347f, 0.03086186f, -0.04259710f, 0.05231615f, 0.07611057f, -0.01346425f, 0.15926421f, 0.13936557f, 
    0.03197162f, -0.01148961f, -0.01752408f, -0.00053297f, -0.05681979f, -0.03127863f, -0.04389766f, 0.03986478f, 
    -0.03187284f, 0.19808143f, 0.09930263f, -0.13980912f, -0.03817766f, 0.01235176f, 0.01299877f, 0.04106174f, 
    -0.04672660f, -0.07831577f, -0.00356463f, 0.00617229f, 0.07796436f, 0.17312543f, 0.12441432f, -0.16105713f, 
    -0.07197271f, -0.05026386f, -0.02512085f, 0.07105085f, 0.04705685f, -0.02641646f, -0.03936525f, 0.05866522f, 
    -0.10169048f, -0.11591177f, -0.17621756f, -0.10631493f, -0.01480759f, -0.03787927f, -0.11687084f, -0.10988968f, 
    -0.05803786f, 0.00196498f, 0.10568106f, -0.01255232f, 0.11471584f, -0.17956708f, -0.02171967f, 0.00308506f, 
    -0.07935479f, -0.03582083f, -0.00153603f, -0.02582761f, -0.12810501f, 0.06262896f, 0.01453707f, -0.06082157f, 
    0.20306630f, -0.21769008f, -0.13645367f, -0.06973784f, -0.01868083f, 0.15098126f, -0.03839059f, 0.08656111f, 
    0.01854183f, 0.00097039f, -0.02408815f, 0.00301199f, 0.16803306f, 0.13892148f, 0.11179236f, -0.08226203f, 
    -0.07339536f, -0.03241165f, -0.03731373f, -0.06207464f, -0.05580173f, 0.00646566f, -0.02642016f, 0.05155574f, 
    0.09848700f, -0.13499470f, 0.01656665f, -0.04650150f, -0.05410233f, -0.01988463f, 0.04053952f, -0.07362900f, 
    -0.09568071f, -0.05352353f, -0.03537241f, -0.05652532f, 0.16885480f, -0.10739515f, -0.04323722f, 0.01631087f, 
    -0.05675057f, 0.10199713f, -0.02225476f, 0.06258722f, -0.01728816f, 0.04459202f, -0.02018424f, 0.00413530f, 
    -0.51558679f, -0.03505547f, -0.04021271f, 0.08147106f, -0.07133248f, -0.06706608f, 0.01035456f, -0.02698214f, 
    -0.03614878f, -0.01606528f, 0.04132403f, -0.07996774f, 0.20888436f, 0.05368793f, 0.10888763f, -0.10575313f, 
    -0.02256046f, -0.07238870f, -0.02348203f, -0.01472814f, 0.02475630f, 0.03748034f, 0.02122146f, 0.05977574f, 
    0.15892074f, -0.00555872f, 0.15346548f, 0.21716742f, 0.02338722f, 0.04396260f, 0.21977372f, 0.01828166f, 
    0.04949083f, 0.03768405f, -0.03159735f, -0.00933336f, -0.08286598f, 0.05293583f, -0.07844743f, -0.05746865f, 
    0.07893777f, -0.08339575f, -0.01639594f, 0.04092158f, 0.02149062f, -0.11851994f, -0.00414447f, -0.02579592f, 
    -0.05470894f, 0.13513562f, -0.08105695f, 0.10578755f, 0.02338087f, 0.04445987f, 0.03579978f, 0.00118110f, 
    -0.12012917f, 0.04459072f, -0.02715084f, -0.06881411f, -0.25643420f, -0.02613926f, 0.03067557f, -0.05644188f, 
    -0.01175472f, 0.09712992f, 0.05655488f, -0.01109242f, -0.02908705f, 0.02504725f, -0.13850389f, 0.03838327f, 
    -0.01345254f, -0.12859723f, -0.05762265f, -0.06974147f, -0.13931909f, 0.05359213f, 0.00956783f, 0.04928468f, 
    -0.05131432f, 0.07488692f, 0.01525508f, 0.00111776f, -0.16765361f, -0.27371886f, -0.20417425f, 0.05896726f, 
    -0.05888892f, -0.00691923f, 0.00276760f, 0.05213832f, 0.07816646f, 0.01089180f, -0.01883183f, 0.03915922f, 
    -0.39893603f, -0.36852068f, -0.17023511f, -0.23712949f, -0.05417009f, -0.05786830f, -0.00137430f, 0.05320478f, 
    -0.07865350f, -0.09182931f, -0.03950394f, -0.09660027f, 0.05656625f, -0.04344966f, -0.10704276f, 0.01017417f, 
    -0.12375117f, 0.01345212f, -0.10309968f, -0.00445534f, 0.03373693f, -0.08662200f, -0.02825391f, 0.04029883f, 
    0.20270050f, 0.05619425f, 0.04900366f, -0.09872626f, -0.06146645f, -0.02832439f, 0.01768857f, -0.06701771f, 
    -0.00721058f, -0.16788375f, -0.10460945f, -0.09273440f, -0.29003111f, -0.38760254f, -0.24802123f, 0.10709643f, 
    -0.04417872f, 0.09698058f, -0.00502707f, -0.15622607f, 0.00942083f, -0.01138355f, -0.01236755f, -0.03895341f, 
    -0.09667467f, 0.08891857f, 0.20497596f, -0.00391472f, 0.07085112f, 0.00724446f, -0.04263045f, -0.00937182f, 
    -0.00952068f, 0.03945179f, -0.08230640f, -0.00956936f, -0.49470299f, -0.07163616f, -0.18061073f, -0.05527030f, 
    -0.15364727f, -0.04847890f, -0.03395402f, -0.00154444f, 0.01025310f, -0.04949205f, 0.00880269f, -0.07186085f, 
    0.68381643f, 0.02980383f, 0.04791916f, 0.10160248f, 0.04181932f, 0.05828894f, -0.04536764f, 0.04169289f, 
    -0.03299847f, -0.03896143f, -0.01950657f, 0.05534262f, -0.33218047f, 0.00992064f, 0.23798677f, 0.11416905f, 
    0.00643767f, 0.05136123f, 0.07219970f, -0.06750944f, -0.01503944f, -0.16317870f, -0.03498873f, -0.05370262f, 
    -0.44389167f, 0.02711312f, 0.20879343f, 0.24302515f, -0.07861420f, -0.05252020f, 0.01607100f, -0.07544731f, 
    -0.01218121f, -0.03904588f, -0.09133948f, 0.04048732f, -0.02252627f, -0.03400194f, -0.00533956f, 0.01078521f, 
    -0.05678529f, 0.07351954f, 0.01869676f, 0.08909547f, 0.01819961f, 0.01179579f, 0.04188816f, 0.09902509f, 
    -0.26078716f, 0.14638890f, -0.18376075f, -0.39357904f, -0.12066060f, -0.07069990f, -0.03958107f, 0.13016993f, 
    -0.00018467f, -0.12231489f, 0.02692667f, -0.12403074f, -0.03671807f, -0.14367417f, 0.03101116f, 0.11282371f, 
    -0.06842500f, -0.03208348f, 0.01033579f, -0.01212032f, -0.11577141f, 0.09334134f, 0.06027000f, 0.07862559f, 
    -0.14482646f, -0.15362680f, 0.03703457f, -0.00305703f, 0.06442210f, -0.12076418f, -0.03456934f, -0.02186439f, 
    0.04750026f, -0.03097305f, 0.06099678f, -0.00498617f, -0.02935906f, -0.23604819f, -0.13291316f, 0.07220304f, 
    0.03369175f, -0.05026556f, 0.04925976f, -0.08148943f, -0.05512539f, -0.05079577f, -0.05744691f, -0.03712439f, 
    -0.14051554f, 0.00330576f, -0.10469040f, 0.08853697f, 0.14098443f, 0.12383610f, -0.04460551f, 0.07429007f, 
    0.15581447f, -0.11532222f, -0.02552996f, -0.15067188f, -0.03067064f, 0.04827064f, -0.08295702f, -0.07571679f, 
    0.08267879f, 0.02904588f, -0.03277626f, -0.09997851f, -0.01501976f, 0.00152207f, 0.10728347f, 0.07705856f, 
    -0.06205358f, -0.08489452f, -0.14388657f, 0.07823254f, 0.10620411f, -0.00495365f, -0.04386835f, -0.03707291f, 
    -0.12169980f, -0.03722500f, 0.03247654f, -0.12010253f, -0.09168170f, -0.03755154f, -0.04566854f, 0.15816909f, 
    0.03602498f, -0.03679908f, -0.11854439f, 0.03557795f, -0.03431414f, -0.00856091f, -0.15234600f, 0.03483358f, 
    -0.14145131f, -0.05929469f, 0.02878253f, 0.11877774f, -0.07858442f, 0.06297249f, 0.02931766f, -0.07990259f, 
    0.03238921f, -0.03337721f, 0.11338794f, 0.09478153f, 0.06689149f, 0.17266466f, -0.18705314f, -0.35233063f, 
    -0.00940743f, 0.05199143f, 0.12758282f, 0.11024453f, 0.01462481f, -0.06931578f, -0.00642577f, 0.14974859f, 
    -0.14622544f, -0.11903957f, 0.07147641f, 0.16715454f, 0.02439645f, -0.11220898f, 0.05912663f, -0.05798838f, 
    -0.02573742f, 0.04136695f, -0.03686745f, -0.00373038f, -0.09252572f, 0.08772470f, 0.04575593f, -0.06882419f, 
    -0.09904207f, 0.05673123f, -0.09809573f, 0.03545030f, 0.08520418f, -0.12688667f, -0.17902303f, 0.11677386f, 
    -0.04903217f, 0.13560387f, -0.07069873f, 0.14955448f, 0.05566959f, 0.05909429f, 0.00359357f, 0.06392509f, 
    -0.10959371f, -0.04354692f, 0.13219085f, -0.10618294f, 0.00008967f, -0.02492411f, -0.04477616f, -0.13281250f, 
    -0.00382059f, 0.05429099f, 0.12920068f, -0.04658664f, -0.08295351f, -0.15839811f, -0.06771831f, -0.07278850f, 
    0.20749588f, 0.09727716f, -0.07121404f, -0.01018217f, -0.03808436f, -0.02415440f, 0.01330333f, 0.11530306f, 
    -0.05798769f, 0.01679919f, 0.05290645f, 0.12870614f, -0.26615077f, -0.16673651f, 0.08941122f, 0.13989644f, 
    -0.20058958f, 0.05052111f, -0.02053434f, -0.12509032f, -0.03144075f, 0.05023332f, 0.05443359f, -0.06860397f, 
    -0.09314257f, 0.03798140f, 0.02096319f, -0.28306970f, 0.07472848f, 0.08475776f, 0.12172303f, 0.03467969f, 
    0.07777672f, 0.12136809f, -0.12092178f, 0.08341640f, 0.06346934f, 0.05646234f, -0.04457364f, 0.10925054f, 
    0.06793348f, -0.15291815f, 0.09304148f, 0.11857429f, 0.13324416f, -0.06317403f, -0.01561878f, -0.11799296f, 
    -0.24392945f, -0.26153582f, 0.05130498f, -0.12933166f, -0.00341084f, 0.05299199f, 0.00884952f, 0.03188834f, 
    0.11857716f, 0.07370062f, 0.01764474f, -0.04180047f, -0.18904601f, 0.15823945f, 0.01731471f, -0.24605620f, 
    0.11407095f, -0.10834232f, -0.10396165f, -0.01687393f, 0.03488357f, -0.16514325f, 0.00436876f, -0.06177340f, 
    0.00123323f, -0.11215176f, 0.08505993f, -0.07006458f, -0.03322163f, -0.08670594f, 0.08113804f, -0.20440720f, 
    -0.02208669f, -0.01924794f, 0.01668746f, -0.04300806f, -0.08535342f, 0.01438880f, 0.07114806f, 0.10177020f, 
    -0.03990883f, 0.02841287f, 0.05218107f, -0.10096359f, -0.01299543f, -0.03625747f, 0.10119146f, -0.08494158f, 
    -0.09840526f, -0.08698833f, 0.03343531f, 0.02601958f, -0.08151955f, 0.13768280f, 0.07389386f, 0.03450349f, 
    -0.03835084f, 0.00483928f, 0.04860684f, -0.02188185f, -0.18330964f, -0.03608981f, 0.15178172f, -0.08041524f, 
    0.03889690f, 0.05810500f, -0.01562384f, -0.11523516f, 0.01042536f, 0.02685362f, -0.07069214f, 0.01358902f, 
    0.24616389f, -0.16713233f, 0.02840794f, 0.17552778f, -0.16625470f, 0.06925150f, 0.03764503f, -0.01172544f, 
    0.05029654f, 0.10831516f, -0.15651520f, -0.01598962f, -0.10032827f, 0.08719881f, -0.18662947f, 0.05770917f, 
    -0.03485706f, 0.09740117f, 0.05617914f, -0.05344785f, 0.06154285f, 0.07523534f, 0.02491745f, -0.00583065f, 
    0.06842753f, -0.09737489f, 0.24823663f, 0.10246486f, -0.05493215f, -0.01325557f, 0.03700252f, 0.03640556f, 
    0.09807377f, 0.04403022f, 0.02030690f, 0.00916567f, 0.27201003f, 0.13009505f, 0.00664766f, 0.09544218f, 
    -0.03093164f, 0.00397822f, -0.05913086f, 0.03425235f, -0.00009124f, -0.05257932f, -0.02306961f, 0.02392774f, 
    -0.00632439f, -0.05408197f, -0.09053919f, -0.11838764f, -0.06877670f, -0.00663888f, -0.05284544f, -0.04310666f, 
    -0.09494856f, -0.10306370f, -0.06128785f, -0.08482369f, 0.13556258f, 0.15472363f, 0.17938186f, 0.00663682f, 
    -0.04629822f, -0.03031808f, 0.07007027f, 0.00766609f, 0.07178591f, 0.02099265f, 0.06046895f, 0.04378970f, 
    -0.12330488f, -0.00410506f, 0.15079987f, 0.16917863f, 0.05467368f, -0.13556553f, -0.02720619f, 0.07572649f, 
    -0.17904587f, -0.11551601f, 0.09431997f, 0.00898144f, 0.04785385f, -0.06498353f, 0.10729580f, 0.17465687f, 
    0.06472199f, 0.00817421f, -0.00605424f, 0.10012808f, 0.02996574f, -0.09541892f, 0.01563502f, 0.07862540f, 
    -0.19517535f, -0.06062387f, 0.10555799f, -0.15335266f, 0.13303845f, -0.03555273f, -0.13083251f, -0.05141752f, 
    0.04946631f, -0.01129417f, 0.03527505f, -0.13367850f, -0.22936441f, 0.39951596f, -0.05168965f, 0.03560897f, 
    0.06143984f, 0.00781133f, -0.04236837f, -0.12772289f, -0.05590939f, 0.01461180f, 0.03038205f, -0.03131001f, 
    -0.20074418f, -0.02586137f, 0.18399504f, 0.07796299f, 0.04349241f, -0.00208619f, -0.08769614f, -0.09676673f, 
    -0.07407904f, 0.16500114f, -0.14208508f, -0.00126563f, -0.13996549f, -0.00056546f, -0.07772003f, -0.20090936f, 
    0.05354664f, -0.01845169f, -0.15880798f, 0.11038020f, 0.02994670f, -0.01938479f, 0.01781628f, 0.02383773f, 
    -0.24793020f, 0.09874573f, -0.00165777f, -0.01490885f, -0.00788090f, -0.05766066f, -0.07274128f, 0.03200547f, 
    0.02461516f, -0.17220850f, -0.05102037f, 0.08237096f, -0.21106856f, 0.12758549f, 0.03569879f, -0.24913874f, 
    0.15309790f, -0.10023047f, -0.09852511f, 0.02466718f, 0.01507234f, 0.00429219f, -0.05760132f, 0.00297518f, 
    0.23575866f, -0.11222128f, 0.00022776f, 0.13416764f, 0.03755167f, -0.10514836f, 0.06994891f, 0.07396843f, 
    0.00152852f, 0.11950514f, -0.03324328f, 0.08293105f, -0.05632049f, 0.43024048f, -0.01253415f, -0.12429858f, 
    -0.01219298f, 0.00414620f, 0.08327504f, -0.02798961f, -0.12096900f, 0.15224518f, -0.04431950f, 0.03491688f, 
    -0.37129524f, 0.15277945f, 0.01409454f, 0.06171048f, 0.03032521f, -0.00175719f, 0.08993050f, -0.07176933f, 
    0.07797816f, 0.02322887f, -0.04871086f, -0.03714292f, -0.60148787f, 0.07817978f, 0.05273911f, 0.07595425f, 
    0.08605088f, 0.06521194f, -0.03818887f, 0.08463198f, -0.05765615f, 0.07763106f, 0.06283382f, 0.13790217f, 
    0.06318010f, -0.28714636f, 0.09203944f, -0.00615994f, -0.13479072f, -0.03806723f, 0.05685883f, -0.18521124f, 
    0.05010772f, 0.08941408f, 0.04662341f, -0.01885448f, 0.28819907f, -0.12559314f, 0.11298409f, -0.22003363f, 
    0.03732052f, 0.03398519f, 0.00350315f, 0.10120939f, -0.01939173f, -0.15243295f, -0.05340451f, 0.06339663f, 
    -0.84374464f, -0.02900332f, 0.07260987f, 0.18253724f, 0.07680365f, 0.04135301f, -0.01856189f, 0.07608823f, 
    -0.11404523f, 0.02630756f, 0.13556363f, 0.04638938f, 0.20551388f, 0.03441334f, 0.08575697f, -0.04327109f, 
    0.06203318f, 0.05218714f, 0.08602087f, 0.00957664f, 0.07430538f, 0.04868449f, 0.05710799f, -0.00241060f, 
    -0.39545369f, 0.00437256f, 0.17370033f, 0.01449556f, 0.01280663f, 0.00208069f, -0.05004936f, 0.04529081f, 
    0.06301221f, -0.06590597f, -0.00751415f, -0.09929659f, -0.20294552f, 0.04725449f, 0.05480346f, -0.12167502f, 
    0.09496761f, 0.02223462f, 0.04128586f, 0.03897131f, -0.14713147f, -0.05099769f, -0.02934458f, 0.06261901f, 
    0.11015285f, 0.01106859f, -0.11702374f, -0.00993520f, -0.15365054f, 0.04695236f, 0.09582739f, 0.01497169f, 
    -0.00105642f, 0.03800542f, -0.05771412f, 0.10578462f, -0.25482661f, -0.02161260f, 0.02357423f, -0.10204099f, 
    0.00704542f, 0.05366760f, -0.02811226f, 0.00082449f, -0.04213320f, -0.05743565f, 0.02879779f, -0.04480242f, 
    -0.19932990f, -0.30201584f, 0.19104598f, 0.00509178f, 0.05331542f, 0.08159047f, 0.11115476f, 0.04745158f, 
    0.09898136f, -0.03566162f, -0.11884132f, 0.05073581f, -0.38608238f, 0.20349088f, -0.11423743f, -0.08271211f, 
    -0.03073304f, -0.10827848f, 0.04088905f, 0.06273403f, -0.06698897f, -0.02052737f, -0.01962501f, 0.07437227f, 
    -0.30388770f, 0.02246763f, 0.17165977f, 0.22597884f, -0.07990775f, 0.01188390f, 0.04240435f, -0.00009751f, 
    -0.05257996f, 0.00395722f, -0.00012069f, 0.00832796f, 0.13852215f, 0.09078960f, 0.21497168f, 0.07744989f, 
    0.04994800f, -0.05052644f, 0.07717947f, -0.09222555f, -0.01573897f, 0.11068440f, 0.11301838f, 0.10702107f, 
    0.13486637f, 0.10962319f, 0.02692467f, -0.00869077f, -0.08657039f, -0.12483068f, -0.03990981f, 0.05386770f, 
    0.09253458f, 0.02515302f, 0.00837026f, 0.01827553f, 0.00940848f, -0.14497188f, -0.02593027f, 0.01596641f, 
    -0.03104099f, -0.08181434f, 0.03045562f, 0.11740779f, -0.03691927f, -0.07545305f, -0.02781957f, 0.01176082f, 
    -0.14241202f, 0.10966808f, 0.05527250f, 0.01570571f, 0.11625690f, -0.02832966f, -0.02033124f, 0.01536456f, 
    0.04861344f, -0.02539039f, -0.09398659f, -0.02441903f, 0.13513795f, 0.03877279f, 0.10337827f, 0.21478438f, 
    -0.04173211f, 0.08190264f, 0.00062093f, 0.00961210f, 0.10017353f, 0.00486177f, -0.06347758f, -0.08549575f, 
    -0.07688557f, 0.15396000f, 0.06308395f, 0.15987308f, -0.03014439f, -0.10960981f, -0.04843558f, 0.02722731f, 
    0.03577000f, -0.13251418f, -0.10098127f, -0.01430907f, -0.09651892f, 0.03128007f, -0.17885038f, 0.11074171f, 
    -0.09050238f, -0.02158806f, 0.04401245f, 0.12808366f, -0.01633044f, -0.10699654f, 0.07190716f, -0.06433749f, 
    0.07838733f, 0.32603619f, -0.17693749f, -0.18252873f, -0.03896763f, 0.07767163f, 0.05092856f, 0.13381624f, 
    -0.00114957f, -0.02435670f, -0.04340173f, -0.01586725f, -0.15247236f, 0.02870688f, 0.01429900f, 0.12666813f, 
    0.03977491f, -0.02139645f, 0.01856484f, 0.02528055f, -0.04838644f, 0.02810255f, 0.03324030f, -0.03031547f, 
    0.12927526f, 0.01800289f, -0.02584039f, 0.28206676f, -0.08340511f, -0.11929990f, -0.02641312f, 0.02370598f, 
    0.01348971f, 0.08301505f, 0.01471854f, 0.12123019f, -0.00126532f, 0.06290015f, 0.03664454f, 0.05186736f, 
    -0.01403119f, 0.03705592f, 0.03464498f, 0.00055195f, 0.02632779f, 0.06986227f, 0.03243244f, -0.03099492f, 
    -0.25527680f, 0.10709293f, 0.05256195f, -0.07936382f, 0.10821244f, 0.06971251f, 0.08134454f, 0.06361938f, 
    0.06978818f, 0.07711741f, 0.09152123f, 0.07823690f, 0.01326336f, -0.06188419f, 0.00307690f, -0.07801157f, 
    0.17425257f, -0.04088166f, -0.02346240f, -0.25634962f, -0.10605311f, 0.15525766f, -0.05912746f, -0.02929692f, 
    0.03712932f, 0.16325276f, -0.05716472f, -0.12043189f, -0.10641615f, 0.15643205f, -0.06516967f, -0.06122332f, 
    -0.16478889f, -0.04758168f, 0.08448803f, -0.06884977f, -0.05795964f, 0.00134077f, -0.07060621f, -0.03076372f, 
    -0.08971293f, -0.09267927f, -0.09742294f, 0.09222145f, 0.12737365f, -0.00034412f, -0.01871500f, 0.00497022f, 
    -0.10316111f, -0.21527806f, 0.01019327f, -0.01172322f, -0.02375774f, -0.00005844f, -0.04089011f, -0.12810504f, 
    -0.09360009f, 0.18577409f, 0.02512332f, 0.18717560f, -0.28480089f, -0.13259026f, -0.23210150f, 0.18060429f, 
    0.11698225f, 0.01259024f, 0.13452311f, 0.01946484f, 0.04614842f, -0.05297116f, -0.02329869f, -0.09072632f, 
    0.33381546f, 0.24727751f, -0.02558425f, -0.10330521f, 0.08656992f, -0.06532542f, -0.02873230f, -0.12717143f, 
    -0.10321864f, 0.01310983f, -0.12905288f, -0.06534798f, -0.20340765f, -0.14651339f, -0.07639657f, 0.03555554f, 
    0.12571907f, -0.04861235f, 0.01415862f, 0.03848493f, 0.12560867f, 0.12817335f, 0.13773860f, -0.04394901f, 
    -0.05764057f, 0.06373103f, -0.01474824f, -0.20713736f, -0.03713561f, -0.07716722f, 0.03262631f, -0.18820524f, 
    0.05973551f, 0.06784192f, -0.12134133f, -0.03511853f, -0.08707719f, 0.03216355f, 0.24989782f, 0.23433742f, 
    0.13932723f, -0.10322521f, -0.06495438f, -0.13643034f, -0.01955770f, 0.06012846f, -0.01319132f, -0.09835926f, 
    0.05491197f, -0.19840513f, -0.22657026f, -0.08834246f, 0.08702243f, 0.11684038f, -0.12998934f, -0.00580374f, 
    -0.00573703f, -0.00988096f, 0.05446840f, 0.17696717f, -0.20667173f, 0.02259788f, -0.04525481f, 0.17295167f, 
    0.14805779f, -0.06943488f, -0.07810466f, 0.12548213f, -0.15031433f, -0.12087449f, 0.02689509f, -0.39380106f, 
    0.13389598f, -0.10218549f, -0.12152128f, 0.03291212f, 0.02112790f, 0.06044924f, 0.05767011f, -0.09057791f, 
    -0.01013858f, -0.01924992f, -0.13309899f, -0.11410227f, -0.00421416f, -0.14469591f, 0.11506322f, -0.00818144f, 
    -0.05305038f, -0.00908951f, -0.01242841f, -0.02665511f, 0.18460090f, -0.13421650f, -0.06352719f, -0.05240974f, 
    0.06475976f, 0.14230123f, 0.18199350f, -0.04613890f, 0.18484367f, -0.02569593f, -0.09379350f, -0.07933746f, 
    -0.01927664f, 0.08275960f, -0.07169799f, 0.10535043f, -0.00062775f, 0.14236738f, 0.12050729f, 0.20131008f, 
    -0.14834666f, -0.13599089f, 0.00024921f, 0.01161992f, -0.11909255f, -0.16722870f, 0.00489451f, 0.16251068f, 
    -0.08466811f, 0.03016039f, 0.00148947f, -0.02352725f, -0.09140395f, 0.06255587f, -0.10807027f, -0.13323984f, 
    0.02508977f, -0.05303584f, 0.15832737f, 0.03859604f, -0.31333467f, 0.04117176f, -0.08366179f, -0.16790742f, 
    0.04458798f, 0.10819302f, 0.00891379f, -0.02249286f, -0.01140837f, -0.04943394f, 0.02626122f, 0.06847892f, 
    0.15664481f, -0.04117119f, -0.10717590f, 0.07917751f, 0.02958918f, 0.08719392f, 0.01516806f, 0.02476383f, 
    -0.04563434f, -0.14179143f, -0.01519811f, -0.04910650f, -0.13129775f, 0.03934541f, -0.02550449f, 0.14555284f, 
    0.02314657f, 0.08774949f, -0.09671254f, 0.07728148f, 0.12343465f, 0.03127654f, -0.03856314f, 0.12748010f, 
    -0.13403447f, 0.06895147f, 0.12710056f, 0.13189603f, -0.04714840f, -0.11562915f, 0.06103467f, 0.07905959f, 
    0.03494980f, 0.04761905f, 0.05415021f, 0.00696571f, 0.09794031f, 0.06810081f, 0.00763638f, 0.13636623f, 
    -0.06379353f, -0.01745065f, 0.01099760f, -0.08216868f, -0.05295179f, -0.05520161f, 0.13584247f, 0.18016307f, 
    -0.05237147f, 0.12821308f, 0.03008602f, 0.15260696f, 0.02475795f, -0.09886293f, 0.00437940f, -0.03112113f, 
    0.04809754f, -0.05416025f, -0.01392842f, -0.05194562f, -0.48201665f, -0.09223339f, -0.00272108f, -0.07089826f, 
    -0.02470863f, 0.09883463f, -0.05675429f, -0.06937622f, 0.09060410f, -0.00239918f, 0.30427921f, 0.00815870f, 
    -0.02867815f, 0.06072785f, -0.01227417f, -0.32310364f, -0.06671318f, -0.06640913f, 0.07845664f, 0.01215461f, 
    0.10097771f, -0.04547456f, 0.13869768f, -0.00262307f, -0.22911303f, -0.04354931f, -0.00675326f, -0.08434137f, 
    -0.00024511f, 0.04710136f, -0.09358664f, 0.04429962f, -0.01910587f, 0.00630607f, 0.05425990f, 0.03200723f, 
    0.08765158f, -0.03282425f, -0.09409283f, -0.21022992f, -0.00741517f, 0.00060470f, -0.03957150f, 0.06988052f, 
    -0.00169194f, -0.00803397f, -0.06199193f, -0.02428463f, 0.03805031f, -0.24959925f, 0.03977380f, 0.00042571f, 
    0.08062891f, 0.02209458f, 0.05190426f, -0.28816420f, -0.04207703f, 0.09999333f, -0.14307682f, 0.03841311f, 
    0.00040966f, 0.02714354f, -0.00525752f, 0.05048149f, 0.00362329f, -0.02563313f, 0.05504064f, 0.05307014f, 
    0.12169180f, 0.09337211f, -0.00736107f, 0.15239234f, -0.06538176f, -0.19273001f, -0.09797362f, 0.14323370f, 
    0.13551284f, -0.16232073f, -0.06492001f, 0.09550828f, 0.02363095f, -0.00646590f, -0.11030145f, 0.05752029f, 
    0.20782307f, 0.00412064f, -0.07729813f, 0.02056074f, 0.12563209f, 0.15667595f, 0.04511879f, -0.01941518f, 
    0.08391929f, -0.12100949f, 0.00902879f, -0.22908871f, -0.03691342f, 0.02154560f, -0.06724453f, 0.01787469f, 
    0.12819625f, -0.09745805f, 0.05382898f, 0.02575464f, 0.02304475f, 0.07231343f, -0.10356666f, -0.03516146f, 
    -0.06111519f, 0.02132223f, 0.24672894f, 0.23972520f, -0.12827833f, 0.04090251f, 0.05711590f, 0.06581090f, 
    0.03670406f, -0.03206872f, 0.00492911f, -0.01226671f, -0.39148152f, -0.06475523f, -0.04808313f, 0.01265035f, 
    0.04387690f, -0.11560647f, -0.06480207f, -0.00642183f, 0.02611089f, -0.05018255f, -0.14193012f, -0.15902595f, 
    0.11741343f, 0.06778639f, -0.10729047f, -0.23791142f, 0.02851872f, -0.05616816f, 0.11441603f, -0.03262453f, 
    0.01201306f, 0.05024277f, -0.11610965f, 0.11498132f, -0.11021167f, -0.07956190f, -0.02360509f, 0.13014111f, 
    -0.14593340f, -0.02709366f, 0.03380848f, -0.09674168f, 0.10240041f, -0.11885285f, -0.02050681f, -0.18107285f, 
    -0.01530611f, -0.08679113f, 0.16751711f, 0.05304237f, 0.02580174f, 0.04499406f, 0.06888596f, 0.01958104f, 
    -0.09102950f, 0.02224487f, 0.00966523f, -0.02062612f, -0.06888697f, 0.09475648f, 0.11900599f, 0.13301131f, 
    -0.15102348f, 0.19018164f, -0.00139232f, 0.05215865f, -0.02023615f, -0.02511339f, 0.10118473f, -0.01039877f, 
    0.05937469f, 0.00940922f, 0.10098948f, 0.10149200f, 0.09751444f, 0.04584446f, -0.03182623f, -0.06316358f, 
    -0.03555936f, -0.04801814f, -0.00645464f, -0.10833059f, -0.30327511f, -0.06582242f, 0.12464292f, 0.08144130f, 
    0.11198278f, 0.01146553f, -0.01913938f, -0.03758673f, 0.13594863f, -0.22159433f, 0.01588404f, -0.03079568f, 
    -0.10852442f, 0.05298766f, 0.01659889f, -0.03167436f, 0.07293442f, 0.00136206f, -0.14089352f, -0.12810628f, 
    -0.07552990f, -0.10252613f, -0.06159989f, 0.13063291f, -0.30254564f, 0.01777763f, -0.27079269f, -0.09230475f, 
    0.15047742f, 0.05162271f, 0.12470546f, -0.10613492f, 0.07412636f, -0.03993484f, -0.21406157f, 0.07075113f, 
    0.19151905f, 0.09013959f, -0.06339453f, -0.00652574f, 0.01447482f, -0.10806724f, -0.10183055f, -0.00164859f, 
    -0.10018393f, 0.02344220f, -0.09119379f, -0.10437178f, -0.01512025f, -0.12030854f, -0.04215608f, 0.31536025f, 
    0.07997884f, -0.01566564f, 0.00529774f, 0.02865279f, -0.13165516f, -0.01818187f, 0.09363690f, -0.09456427f, 
    -0.17821109f, 0.06688922f, -0.39258146f, -0.03149735f, 0.08321913f, -0.00032793f, -0.09694254f, -0.08927396f, 
    0.09808882f, -0.19808061f, -0.04854274f, -0.02652369f, -0.21056238f, -0.13794018f, 0.07569795f, -0.02139907f, 
    0.07880107f, -0.06913553f, -0.15352891f, -0.05881695f, -0.02701871f, 0.05800114f, 0.04605377f, 0.01181840f, 
    0.01449086f, -0.04987471f, 0.03917030f, -0.02524557f, -0.07334003f, 0.10722259f, 0.05527049f, -0.00198340f, 
    -0.10788596f, -0.02036737f, 0.08657175f, 0.07508892f, -0.38594165f, -0.17665415f, -0.09986735f, -0.00660112f, 
    0.03314676f, 0.04639818f, 0.09122106f, 0.07577790f, -0.00200592f, 0.00482306f, 0.00150691f, 0.01606037f, 
    -0.09102187f, -0.13642652f, 0.06040438f, -0.25586036f, 0.07772063f, -0.05414289f, -0.02087668f, -0.17462859f, 
    -0.17298606f, -0.08346426f, 0.15725709f, 0.14290282f, -0.42416701f, 0.10819790f, 0.07444593f, -0.10933215f, 
    0.01540910f, 0.00227349f, 0.14807564f, -0.01771069f, 0.05079213f, -0.01440877f, 0.04186480f, -0.07457204f, 
    -0.04681007f, 0.23813841f, 0.13478570f, 0.17607962f, -0.17351751f, -0.08242280f, -0.15343975f, 0.10328925f, 
    0.03835421f, -0.10310175f, 0.06512988f, 0.11554857f, -0.13970171f, 0.15532118f, 0.12549134f, -0.28436121f, 
    0.06012822f, -0.08277156f, -0.01133958f, -0.00521610f, -0.09018107f, 0.03848288f, 0.05577302f, -0.14977203f, 
    0.07847663f, -0.08954173f, -0.48412582f, -0.09014026f, 0.12248071f, 0.03472519f, 0.03360977f, -0.06188035f, 
    0.08835378f, 0.04998992f, -0.19025849f, 0.12922645f, 0.17207421f, -0.23502135f, -0.00303722f, 0.10961162f, 
    -0.02546402f, -0.03092170f, -0.14059764f, 0.06825043f, 0.10164513f, -0.01614190f, -0.02032124f, -0.24595162f, 
    0.05626362f, 0.09671603f, 0.12194075f, 0.14000352f, -0.05069461f, 0.11193041f, 0.09828848f, -0.04560739f, 
    0.17008187f, 0.02996832f, -0.06015323f, 0.04305816f, 0.08550014f, -0.01407828f, 0.14127046f, 0.06649376f, 
    -0.05748085f, -0.08007273f, 0.05509330f, -0.12023870f, 0.03756027f, 0.07931478f, 0.06275863f, 0.11296074f, 
    -0.03114138f, -0.10404965f, 0.10988185f, -0.15219603f, 0.05764081f, -0.00664282f, -0.11547333f, 0.02270747f, 
    0.01239112f, 0.03471818f, -0.12006143f, 0.22014466f, -0.07852776f, 0.04701719f, 0.14293586f, -0.13075551f, 
    -0.04188120f, -0.14524060f, 0.04491296f, -0.02198307f, 0.08967448f, 0.10689460f, 0.04220763f, 0.22853038f, 
    -0.15522921f, -0.21655427f, 0.04602459f, 0.14523947f, -0.01113381f, 0.04395373f, -0.05638317f, 0.00599836f, 
    0.04378364f, 0.04608843f, 0.10398270f, 0.15470448f, 0.01974388f, 0.14099596f, 0.03175578f, -0.03953662f, 
    -0.03639246f, 0.04127288f, -0.07146913f, 0.05574070f, 0.04700710f, 0.05869795f, -0.14571156f, -0.05008243f, 
    -0.20021181f, -0.26642299f, 0.28177702f, 0.11200494f, 0.01672956f, -0.05769586f, 0.02439882f, -0.11467428f, 
    0.01145010f, 0.09965967f, -0.00624078f, 0.03846127f, 0.04016714f, -0.10911968f, -0.02054250f, -0.27470988f, 
    0.03810964f, -0.07364614f, 0.02118226f, 0.02699472f, 0.04656507f, 0.07478512f, 0.07466260f, 0.00436121f, 
    0.18236968f, 0.05568186f, -0.00962203f, -0.15210456f, 0.10053722f, 0.07593549f, 0.05750316f, 0.05314757f, 
    -0.09367133f, -0.08517273f, -0.06349277f, -0.03770941f, 0.09232844f, 0.12610696f, -0.00364704f, -0.11601938f, 
    0.00406198f, -0.02469133f, 0.02406658f, -0.08159795f, 0.02894641f, -0.04056124f, -0.12248866f, 0.07382318f, 
    0.38431996f, -0.29652864f, -0.12220071f, 0.12255193f, 0.03063720f, 0.01527075f, 0.01935364f, 0.06252998f, 
    0.01246373f, -0.12529114f, -0.04573081f, -0.07103475f, -0.14235155f, 0.05836518f, 0.02283801f, 0.25093594f, 
    0.01223516f, 0.08192731f, -0.05648400f, 0.04768146f, 0.13465273f, 0.03451736f, 0.04534224f, -0.05577862f, 
    0.14630182f, 0.01789671f, 0.09786747f, -0.26029283f, -0.02421726f, -0.01472974f, 0.06971977f, 0.00037124f, 
    0.16969113f, 0.08847678f, -0.11827268f, 0.18025668f, -0.18811342f, -0.07460277f, -0.03988129f, 0.07454635f, 
    0.04880701f, 0.02824082f, 0.11880986f, -0.03394842f, 0.07102288f, 0.02022345f, -0.01780780f, -0.03561309f, 
    -0.13562799f, -0.00991535f, -0.11070621f, -0.13001196f, 0.00144610f, 0.03445030f, -0.00057834f, -0.09813686f, 
    0.03369514f, -0.02641866f, -0.18388021f, -0.11557836f, -0.15307598f, -0.24043289f, -0.07096106f, -0.15508787f, 
    -0.03997045f, -0.01592322f, -0.06325702f, -0.12673284f, -0.09822143f, 0.09981538f, -0.08042128f, 0.12307981f, 
    -0.22262219f, 0.15370606f, -0.01441464f, 0.30708498f, -0.02781765f, 0.06972266f, 0.02281449f, 0.09120531f, 
    0.06486834f, -0.00560316f, 0.00514359f, -0.01490719f, -0.03031128f, -0.04337250f, 0.06211225f, -0.24581014f, 
    -0.04680609f, 0.02469085f, -0.06599608f, -0.11235165f, -0.07766068f, 0.03551598f, 0.05469009f, 0.06438608f, 
    -0.35374007f, -0.20799865f, -0.01100326f, 0.06718799f, 0.11841615f, -0.01938541f, 0.00825389f, 0.04519654f, 
    -0.01653163f, -0.05797714f, 0.03974666f, 0.11086851f, -0.03062001f, 0.02370863f, 0.01600476f, -0.16905779f, 
    -0.08963790f, 0.07934095f, 0.07410493f, 0.02174157f, 0.07544079f, 0.01950032f, -0.01515151f, 0.03087149f, 
    -0.09739874f, 0.01369410f, -0.17220652f, 0.06408079f, -0.11556656f, 0.03684121f, -0.00293699f, 0.00484729f, 
    0.00171745f, 0.03253840f, 0.02345521f, -0.14406319f, 0.20971069f, 0.10367453f, 0.04237385f, 0.01624200f, 
    -0.01375859f, -0.00006369f, -0.08031000f, -0.04916885f, -0.15796871f, 0.14343230f, 0.13919330f, 0.19590834f, 
    -0.12360639f, 0.04608193f, 0.04118292f, -0.36170048f, -0.14957829f, -0.04252432f, -0.08384506f, -0.09379923f, 
    -0.01974155f, 0.05290741f, 0.06573009f, 0.11543372f, -0.13510019f, 0.14476660f, 0.01163462f, 0.11939458f, 
    -0.05426233f, 0.00746612f, -0.04594709f, 0.00415790f, 0.02139567f, 0.09588415f, 0.06127353f, 0.04492452f, 
    -0.00613323f, -0.04591593f, 0.10834361f, -0.18319976f, -0.10060264f, 0.04522441f, 0.04135052f, 0.07517342f, 
    0.01654986f, 0.02934714f, 0.02401051f, 0.11830006f, -0.00399863f, 0.18279357f, -0.03867098f, -0.11335146f, 
    0.00348937f, 0.03844030f, -0.06759585f, 0.06757973f, -0.00446014f, -0.00035504f, -0.11694842f, -0.07776807f, 
    0.15654846f, -0.10063536f, -0.00306299f, 0.15270229f, 0.02696684f, 0.04387686f, -0.02713795f, -0.03092717f, 
    0.10773728f, 0.02523637f, -0.18879856f, -0.04662711f, -0.15363277f, 0.04065300f, -0.03552540f, -0.17264524f, 
    -0.07230980f, 0.04088544f, -0.10780337f, 0.02005583f, 0.02355479f, -0.00537073f, -0.12890479f, 0.03964755f, 
    -0.34436637f, 0.20993273f, -0.00009871f, 0.20208783f, 0.01397051f, -0.05729042f, -0.09023998f, 0.07698919f, 
    0.02904538f, 0.10282067f, -0.06217427f, -0.07069271f, 0.04448954f, -0.13512675f, -0.02003693f, 0.13252436f, 
    0.02073848f, -0.07565625f, 0.02935951f, -0.03210535f, 0.01545301f, 0.01702939f, 0.07920673f, -0.33724350f, 
    0.00757919f, -0.38011673f, -0.15539651f, 0.16377695f, 0.06628197f, 0.05061908f, 0.01978796f, -0.04283520f, 
    -0.03451638f, -0.09030867f, -0.13297004f, -0.07368661f, -0.07604615f, 0.00844033f, -0.01290481f, -0.08766055f, 
    0.06391037f, 0.06424267f, -0.06925143f, -0.00632818f, 0.06937364f, -0.09604304f, 0.02419713f, -0.01225247f, 
    0.00410551f, -0.16225252f, -0.31535652f, 0.25573120f, 0.06408853f, 0.09067395f, -0.05894727f, 0.03722766f, 
    0.01694271f, 0.00939872f, -0.03573622f, -0.08997055f, 0.11763439f, 0.01156539f, 0.17971577f, 0.07292424f, 
    -0.12968862f, 0.05203196f, -0.02574982f, -0.00348431f, -0.04741142f, 0.07848574f, -0.19079329f, -0.14823830f, 
    -0.07718889f, 0.05401925f, 0.19115728f, -0.14061889f, 0.08509552f, -0.02431233f, -0.00486638f, -0.01667492f, 
    -0.09442839f, -0.00484811f, 0.07610554f, -0.08035057f, 0.03344472f, -0.19742058f, -0.16410156f, -0.12902899f, 
    0.01500011f, -0.07520317f, 0.14766455f, 0.02522465f, -0.02739184f, -0.04213544f, -0.05755778f, 0.08326490f, 
    -0.12943998f, 0.17534417f, 0.08812491f, -0.20192738f, -0.07063013f, -0.04835704f, 0.00977539f, 0.01263584f, 
    -0.10440171f, 0.03556946f, 0.02547078f, 0.05540270f, -0.00927983f, -0.17130858f, -0.23173203f, 0.06980818f, 
    -0.06211173f, 0.10406662f, 0.00555718f, -0.02868704f, 0.03382215f, -0.10225654f, 0.09697593f, 0.06712545f, 
    0.16901380f, -0.06171506f, 0.10853623f, -0.19134878f, -0.03266509f, 0.08052455f, 0.04516770f, -0.09739406f, 
    -0.10306684f, 0.03841210f, -0.07886724f, -0.30203849f, -0.07012402f, -0.20911910f, -0.10138628f, 0.27044556f, 
    0.02831741f, -0.04524473f, 0.09323164f, -0.07053229f, 0.10587183f, -0.13823685f, 0.05836114f, 0.08215035f, 
    -0.08607420f, -0.05533918f, -0.04356521f, -0.05359708f, -0.08099621f, -0.07918277f, 0.08352700f, -0.17704321f, 
    0.05913613f, 0.00869830f, 0.00279189f, 0.10257172f, -0.17662978f, 0.00698381f, -0.17017262f, 0.05549299f, 
    -0.09665956f, 0.04431115f, 0.02246076f, 0.05821672f, -0.12876059f, 0.00291935f, 0.00250256f, -0.16127862f, 
    0.06712864f, 0.12709476f, -0.21703376f, 0.11411401f, 0.00553909f, 0.01874116f, -0.08187371f, 0.00991994f, 
    -0.12060088f, 0.03847478f, 0.02564258f, -0.02789298f, 0.40999913f, -0.07258830f, 0.15600877f, -0.20716596f, 
    -0.09720559f, 0.10677376f, 0.04939869f, -0.02626012f, -0.02865725f, 0.02310891f, 0.11828287f, 0.02233393f, 
    0.25203890f, 0.13112980f, -0.15717287f, -0.00133112f, -0.00322804f, 0.07735417f, 0.01569026f, 0.04151540f, 
    0.05752603f, 0.01443187f, 0.06464271f, -0.13403852f, 0.00852629f, -0.09004489f, 0.02601874f, 0.31342006f, 
    0.01482472f, 0.18968633f, 0.11680811f, -0.02630346f, -0.02435196f, 0.06708339f, 0.02027548f, 0.21514924f, 
    0.11798783f, 0.04701694f, 0.03211303f, -0.14753930f, -0.05696862f, 0.00064115f, -0.04842312f, 0.00286669f, 
    0.05881684f, -0.04704232f, -0.02989425f, -0.05013928f, 0.22742204f, -0.05044701f, 0.21326782f, -0.10314132f, 
    0.03119018f, -0.06840539f, -0.05415823f, 0.00600053f, -0.03186036f, 0.00416849f, 0.08031580f, -0.10781229f, 
    0.12698935f, -0.08259535f, -0.12381906f, 0.15555881f, -0.21091326f, 0.04271645f, 0.02743637f, 0.03360492f, 
    -0.07964712f, -0.01434609f, -0.03387647f, 0.03458949f, 0.18693520f, -0.31008467f, -0.24170665f, 0.15946312f, 
    -0.08705765f, -0.01271614f, 0.03331225f, 0.09751657f, -0.07185390f, 0.15360291f, -0.06455536f, 0.15158102f, 
    -0.17305985f, -0.10408187f, 0.02143661f, 0.04231270f, -0.05695099f, -0.03104054f, 0.04273447f, 0.08170528f, 
    -0.04939674f, 0.02721855f, -0.01671460f, -0.03368198f, 0.09149934f, -0.18821155f, 0.12907450f, -0.24648538f, 
    0.05448760f, -0.01092845f, -0.03136981f, -0.15673256f, -0.07138242f, -0.00603789f, 0.14077483f, -0.01616643f, 
    -0.47751153f, 0.08915902f, -0.01591816f, 0.16018111f, 0.03070589f, 0.12311213f, 0.03069182f, 0.06049822f, 
    0.04969662f, -0.07840174f, 0.07280124f, 0.06137291f, -0.25930992f, -0.05999114f, -0.01107294f, -0.15913033f, 
    0.00203494f, -0.12362009f, -0.00687237f, 0.01240815f, 0.00460455f, 0.04793427f, 0.05143716f, -0.01435062f, 
    0.03922888f, -0.14114299f, -0.14405258f, -0.25669357f, -0.05399295f, 0.05139304f, -0.01381885f, 0.01239548f, 
    0.03169394f, 0.10449031f, 0.15224062f, 0.20938563f, 0.18678948f, 0.06079071f, 0.12618881f, 0.19334468f, 
    -0.06639941f, -0.03421295f, -0.02803481f, 0.03789216f, -0.01007445f, -0.09259140f, 0.10620492f, 0.13483532f, 
    0.04691039f, 0.13465439f, 0.08615842f, -0.08162671f, 0.04279363f, -0.09845700f, -0.05152557f, -0.01246256f, 
    -0.05342356f, -0.03274100f, -0.07257391f, 0.01185021f, 0.05827641f, -0.10501980f, -0.03087005f, -0.10087278f, 
    -0.08874886f, 0.01271311f, 0.03974753f, -0.12056828f, 0.04563484f, -0.04951988f, 0.09055536f, -0.00112820f, 
    0.18157381f, 0.20462871f, 0.06968150f, -0.23247062f, -0.10465864f, 0.08221550f, -0.01838886f, 0.06570683f, 
    0.06717926f, 0.03067494f, -0.08312373f, -0.13497536f, 0.16371705f, -0.21018340f, -0.01374435f, 0.13713746f, 
    -0.02243962f, 0.05146639f, -0.02015892f, -0.06925699f, 0.01474333f, 0.07863271f, -0.12096211f, -0.00029897f, 
    -0.01395625f, -0.10307403f, 0.08017972f, -0.08245606f, 0.12975156f, 0.04612586f, 0.06869301f, -0.07768561f, 
    -0.04199485f, -0.01878121f, -0.11066134f, -0.02282043f, 0.35941145f, -0.45354578f, 0.08848848f, -0.03579609f, 
    -0.02073896f, 0.03347637f, 0.04634440f, 0.01840623f, 0.16064705f, 0.04582652f, 0.03005441f, 0.15211439f, 
    -0.43558601f, -0.11441334f, -0.13839176f, -0.20246564f, -0.14369968f, -0.01483658f, 0.01718589f, -0.03273889f, 
    -0.08222105f, -0.01387533f, 0.08737157f, 0.04507033f, -0.14144014f, 0.13738221f, 0.03377939f, 0.00875555f, 
    -0.13409157f, -0.01019626f, 0.01892197f, 0.05696758f, -0.03633329f, -0.00280967f, 0.15049262f, 0.06107942f, 
    -0.28392732f, 0.12842372f, 0.09062431f, -0.07614326f, -0.03102923f, -0.09023695f, -0.09173290f, -0.01207087f, 
    -0.06934214f, 0.09295167f, 0.06664992f, -0.00240132f, -0.32451183f, 0.17989434f, -0.13970020f, 0.08533026f, 
    -0.02000809f, 0.17419170f, 0.01622611f, 0.17072895f, 0.01709168f, 0.05068464f, -0.00034956f, -0.08695481f, 
    -0.12653722f, 0.10432785f, -0.16645525f, 0.20028883f, -0.05563426f, -0.02131580f, 0.03680836f, -0.01583924f, 
    0.01017517f, 0.01745214f, 0.07577228f, -0.12921587f, -0.03754266f, 0.28857213f, 0.18512827f, -0.41524950f, 
    -0.03071740f, 0.14672193f, 0.04503235f, -0.03000769f, -0.12749276f, 0.00482789f, 0.03217376f, -0.08711789f, 
    -0.16245374f, -0.05779606f, -0.15465002f, 0.06640734f, -0.07321714f, 0.05289753f, 0.00337839f, 0.00832365f, 
    -0.13414098f, -0.08735532f, -0.12849900f, -0.06495366f, 0.06546221f, -0.11850996f, 0.10706108f, 0.02509974f, 
    -0.01362072f, -0.05014361f, 0.05916847f, 0.06563858f, -0.26231620f, -0.08001951f, 0.10640418f, 0.01513942f, 
    0.11222598f, 0.09227795f, 0.00621932f, -0.10391271f, -0.00902977f, -0.04873469f, 0.06342887f, 0.05741024f, 
    -0.01650278f, 0.12847392f, -0.06396022f, -0.00407925f, 0.10443608f, 0.04456817f, 0.11642537f, -0.00429669f, 
    -0.00408263f, 0.06346069f, 0.05337704f, -0.02850413f, -0.04052741f, 0.01208621f, -0.00556975f, -0.12644938f, 
    0.12948985f, -0.49632972f, 0.14682254f, 0.03845790f, -0.04306655f, -0.09136819f, -0.06054418f, -0.06066986f, 
    -0.08356731f, -0.03917230f, 0.00129711f, -0.03594873f, -0.06533107f, 0.01468890f, -0.00155749f, 0.08038183f, 
    -0.00754928f, -0.07984874f, 0.00109040f, -0.01218523f, -0.02630172f, -0.06759638f, -0.04867993f, 0.00946657f, 
    -0.14118585f, -0.19536699f, 0.01745139f, -0.12434242f, 0.04255970f, 0.03278624f, -0.00218774f, -0.08222684f, 
    -0.01988391f, -0.00000837f, 0.04746687f, 0.02572480f, -0.08420559f, 0.07359972f, -0.08227137f, 0.03503866f, 
    0.03044656f, -0.02459052f, 0.01421450f, 0.05445639f, -0.01336795f, 0.01643217f, -0.02618320f, 0.00938234f, 
    0.16962941f, 0.02209258f, 0.11268161f, -0.02232132f, -0.02943826f, -0.07403734f, 0.00519075f, -0.03971532f, 
    -0.01813616f, -0.03531232f, -0.08722372f, -0.04688290f, 0.07981611f, 0.12092632f, -0.21820512f, 0.00253709f, 
    -0.02612686f, 0.02617377f, -0.06655931f, -0.07625941f, -0.06140401f, 0.02166643f, -0.02588578f, -0.03044883f, 
    -0.16223289f, 0.02811919f, 0.08501058f, 0.00985854f, 0.04203110f, -0.00250428f, -0.03232311f, -0.06953294f, 
    -0.00209303f, 0.02614131f, -0.05213922f, -0.03188444f, 0.08247171f, 0.14987126f, 0.08573552f, 0.16641934f, 
    0.12714292f, -0.03134065f, 0.02269901f, 0.07305044f, -0.09200554f, -0.03314334f, 0.01050364f, -0.10971258f, 
    -0.35018295f, 0.03402033f, 0.04552459f, -0.12572105f, -0.18872255f, -0.07627936f, -0.01792165f, -0.00990857f, 
    0.01672192f, -0.04098483f, 0.01911321f, -0.05305489f, 0.08330251f, 0.02601150f, -0.00441214f, 0.06132504f, 
    -0.15843090f, 0.03058382f, -0.11614845f, -0.09596390f, -0.07442315f, -0.01809490f, -0.02912018f, -0.04857436f, 
    -0.11342679f, -0.06724446f, 0.04521659f, -0.01829015f, 0.00417763f, -0.00641575f, -0.02895503f, -0.07655791f, 
    -0.03538259f, 0.01192270f, -0.00441235f, -0.03455028f, 0.11223901f, 0.06027146f, 0.02796508f, -0.11553176f, 
    -0.00960155f, 0.02261249f, -0.01731654f, -0.06977321f, -0.02413160f, -0.01645516f, -0.05611986f, -0.08439523f, 
    0.17629094f, 0.15258197f, 0.02947763f, 0.13990512f, 0.04673588f, 0.00751221f, 0.06801220f, -0.09226056f, 
    0.01608493f, 0.04027072f, 0.06653638f, 0.00384727f, 0.16524228f, -0.05809792f, 0.06497311f, 0.11194018f, 
    0.09466220f, -0.01367965f, 0.02304298f, -0.09872622f, -0.12509592f, 0.01682523f, -0.09526332f, 0.02341337f, 
    -0.07305437f, 0.20761545f, 0.09819054f, 0.13008493f, 0.06172411f, 0.08634756f, 0.02950514f, -0.05078067f, 
    -0.04107296f, -0.06628009f, 0.05302466f, -0.04915752f, -0.34422043f, 0.12791175f, -0.03465587f, -0.00522601f, 
    -0.13358201f, 0.00681042f, -0.05705212f, -0.01384469f, -0.08775664f, -0.02646540f, -0.07182588f, -0.06559322f, 
    -0.10847041f, 0.06312365f, -0.07175384f, -0.10984445f, -0.13887359f, -0.00647143f, 0.00333125f, -0.01942828f, 
    -0.00708044f, 0.01465810f, -0.06761961f, -0.04413400f, -0.01447853f, -0.12639755f, -0.04010205f, 0.08393165f, 
    0.00849272f, -0.15357500f, -0.06951978f, 0.02823162f, -0.11801640f, 0.02097877f, 0.05872009f, -0.04065390f, 
    -0.18537641f, 0.06248637f, -0.01060053f, -0.05692495f, 0.05812588f, -0.05792310f, 0.12764163f, 0.02250361f, 
    -0.04645694f, -0.04235056f, -0.01311055f, -0.02114506f, -0.04398225f, -0.00560036f, 0.08342632f, 0.01697535f, 
    -0.05672444f, -0.03237654f, -0.02196929f, -0.00958574f, -0.05362900f, -0.02723053f, -0.04541418f, -0.00885431f, 
    -0.22619747f, -0.04664419f, -0.12915112f, -0.18569046f, 0.04996710f, -0.03126211f, 0.00397946f, -0.01524809f, 
    -0.06811564f, 0.04699042f, -0.05039594f, -0.02216466f, 0.07339158f, 0.05546649f, 0.01685590f, -0.05285234f, 
    0.00036130f, 0.02546107f, -0.03582339f, -0.04407263f, -0.00937908f, -0.01736907f, -0.09965008f, 0.04755584f, 
    0.28352195f, 0.02390072f, 0.09717973f, 0.14214246f, 0.02137851f, -0.01718166f, -0.02385000f, -0.06577313f, 
    -0.03309323f, -0.10965443f, -0.03099832f, -0.05194933f, 0.02931511f, 0.05515917f, 0.00122026f, 0.12395081f, 
    -0.08313334f, -0.02786536f, -0.12634228f, -0.03607753f, -0.02327622f, -0.00276624f, -0.03037360f, -0.02143584f, 
    -0.11772608f, 0.04478170f, -0.22922422f, 0.08960067f, -0.09135072f, -0.06403791f, -0.03295965f, 0.03796529f, 
    0.01722914f, 0.04589413f, 0.06974948f, -0.05154552f, -0.08931318f, 0.01383301f, 0.12212456f, -0.01038734f, 
    0.06030729f, -0.12842670f, -0.01874583f, 0.02873104f, -0.10231763f, 0.10323332f, -0.00473953f, -0.03803657f, 
    -0.16231355f, 0.09275234f, -0.11257071f, -0.08616067f, 0.08395848f, 0.01115373f, -0.14507698f, 0.01266203f, 
    -0.09633084f, -0.05132241f, 0.03099064f, -0.03688371f, 0.24798155f, 0.08643151f, 0.04787922f, 0.04835495f, 
    -0.05762409f, 0.01252642f, -0.00258680f, 0.04837279f, 0.03814632f, -0.00072535f, -0.01638142f, 0.01063643f, 
    0.01324027f, -0.00235121f, -0.11211916f, -0.26736096f, 0.03213403f, 0.08366895f, -0.03737660f, -0.08494110f, 
    0.00663854f, 0.01152215f, 0.01389593f, -0.09900169f, 0.03685031f, 0.13303682f, 0.09419731f, 0.11605921f, 
    0.09950800f, 0.06221802f, -0.00632770f, 0.00778288f, 0.06300659f, -0.12574333f, -0.05885411f, -0.02808623f, 
    0.20621507f, -0.09489549f, 0.07056213f, 0.03319063f, 0.07176139f, -0.00417931f, -0.04552056f, -0.06900410f, 
    -0.06555530f, -0.00822193f, 0.03500751f, -0.06063391f, 0.11521252f, 0.12522991f, 0.08490792f, 0.17798026f, 
    0.07816121f, -0.01530805f, -0.01694793f, -0.02017942f, -0.07996627f, -0.03085395f, -0.06017117f, -0.12745984f, 
    0.15484144f, 0.08716372f, 0.12798600f, 0.07783079f, 0.09632595f, -0.01333037f, 0.01319936f, 0.02233193f, 
    0.00448628f, 0.06536040f, 0.02257027f, -0.02174672f, -0.12350249f, 0.22769594f, -0.05870889f, 0.12545367f, 
    0.01410231f, -0.01376460f, -0.05960270f, -0.01065355f, 0.07524747f, -0.03168381f, 0.05564481f, -0.00903724f, 
    -0.22908658f, -0.12016480f, -0.15032440f, -0.05664842f, -0.00996359f, -0.06849894f, 0.02262341f, -0.00622738f, 
    -0.04212393f, 0.00535348f, -0.01469586f, -0.00484497f, 0.14268713f, 0.12878695f, -0.05941569f, -0.19435462f, 
    -0.09885184f, -0.04160162f, -0.05802562f, -0.00100960f, -0.04584330f, -0.00766480f, -0.13422227f, -0.09275132f, 
    0.15653783f, -0.07946013f, 0.07399888f, -0.08446175f, -0.09418131f, -0.00626504f, -0.05567729f, 0.02972236f, 
    -0.02278621f, 0.02031363f, -0.00303919f, -0.05105222f, -0.06066217f, -0.07084405f, -0.15679680f, -0.05982294f, 
    -0.05383401f, -0.05859649f, -0.01821472f, 0.02102006f, -0.04392236f, 0.01939183f, -0.09420684f, -0.01083164f, 
    -0.13323744f, -0.01835738f, -0.13370030f, -0.11970141f, -0.02122711f, -0.01485661f, -0.04048317f, -0.08524729f, 
    -0.12457694f, 0.04273479f, -0.01999837f, -0.00727080f, 0.07777894f, -0.02036394f, 0.03058970f, 0.13653554f, 
    -0.06217589f, -0.14012298f, 0.07906904f, -0.06735532f, 0.00847497f, -0.02732212f, -0.02646824f, -0.02945421f, 
    -0.03943563f, 0.12586610f, 0.00814010f, 0.12938716f, 0.10272568f, -0.05720465f, 0.00089414f, 0.02114570f, 
    0.05434131f, -0.01748561f, 0.07687111f, 0.05125254f, 0.14322513f, 0.16476385f, 0.12386815f, 0.06187836f, 
    0.07975916f, 0.02724686f, 0.05239692f, 0.07173836f, 0.02518330f, 0.02306301f, 0.03290437f, -0.06534802f, 
    -0.08160132f, 0.00609673f, -0.04570571f, -0.03062197f, -0.12443517f, 0.03053198f, -0.01127492f, 0.02392583f, 
    -0.02563946f, -0.05452766f, -0.03010462f, -0.08293260f, 0.15587695f, 0.09177784f, 0.20967329f, 0.13775973f, 
    0.02930891f, 0.08196574f, -0.01058503f, 0.07445706f, -0.04332479f, 0.11787623f, 0.03827100f, -0.06294902f, 
    -0.13158569f, 0.11844318f, -0.16527978f, -0.10528576f, 0.00069555f, 0.05277552f, -0.08069532f, -0.05304302f, 
    -0.07250682f, -0.01230040f, 0.07146268f, -0.03167595f, 0.17849517f, 0.03990113f, 0.04525201f, 0.13360220f, 
    0.11995453f, -0.03488347f, 0.06178724f, -0.05055914f, 0.04292166f, -0.01310668f, -0.06765053f, -0.02386313f, 
    0.03736941f, 0.19531780f, 0.17903592f, 0.10617732f, 0.01519930f, 0.14573400f, -0.01546879f, 0.02273866f, 
    -0.12042791f, 0.09753958f, 0.00837553f, -0.03065362f, 0.11675116f, 0.12926926f, -0.00153816f, 0.23860526f, 
    0.01015858f, -0.06207520f, 0.01837947f, 0.05185527f, -0.05282651f, 0.02361206f, -0.03274629f, -0.06242126f, 
    0.02602974f, -0.26077020f, -0.06599454f, -0.12745692f, -0.02985798f, -0.01699284f, 0.00177016f, 0.01358797f, 
    -0.08491492f, -0.07423961f, -0.03146971f, -0.00781771f, 0.22557387f, -0.01825185f, 0.21576375f, 0.07220450f, 
    0.02896542f, 0.06368086f, -0.03945575f, -0.06127490f, 0.01561053f, -0.06101542f, -0.02458052f, 0.03227210f, 
    -0.01644220f, 0.17259862f, -0.13064350f, -0.18462370f, -0.06550178f, 0.08263557f, -0.03658813f, -0.07257301f, 
    -0.13708320f, -0.03810346f, -0.05056997f, -0.11791860f, -0.03432986f, -0.02077573f, 0.06924646f, -0.04882031f, 
    0.04810624f, -0.08215887f, 0.00943062f, 0.05713930f, -0.08672992f, -0.00920017f, 0.10389708f, -0.06974337f, 
    0.09421104f, -0.10622533f, 0.07780171f, 0.02887552f, -0.03208946f, -0.13122699f, -0.04376369f, -0.04583528f, 
    0.00392328f, 0.05200572f, 0.04554855f, -0.07344232f, 0.06387894f, -0.12380933f, -0.01490811f, -0.16865516f, 
    -0.04323844f, -0.04338818f, -0.08292715f, -0.12603068f, 0.00353259f, -0.00842966f, -0.09111339f, -0.05748647f, 
    0.09998387f, 0.18496193f, 0.08103043f, 0.18842258f, 0.05830203f, 0.07494553f, 0.07826040f, -0.07061943f, 
    -0.08012217f, -0.02792274f, 0.03112894f, -0.04107828f, 0.05842737f, 0.07260960f, -0.12244602f, -0.11042579f, 
    -0.07790694f, -0.07158095f, 0.01733087f, -0.03451997f, -0.03155156f, -0.00901449f, 0.01170092f, 0.03258383f, 
    -0.09921148f, -0.16961367f, -0.05278490f, -0.05815784f, -0.06035671f, 0.04902640f, -0.06458084f, -0.06413745f, 
    -0.02172436f, 0.00014115f, -0.02002057f, -0.05977469f, -0.24331304f, 0.08951081f, 0.03399628f, 0.01788517f, 
    -0.01297637f, 0.08385835f, -0.08773275f, -0.01656467f, -0.03248793f, 0.01613435f, 0.03084107f, 0.01403302f, 
    0.11520897f, 0.00703805f, 0.13466595f, -0.09706868f, -0.00062720f, -0.04609364f, -0.07890658f, -0.06252701f, 
    0.05108757f, -0.00981739f, 0.02337317f, -0.02741063f, -0.23205920f, -0.05212539f, -0.12889655f, -0.15797943f, 
    -0.06007925f, 0.04336871f, -0.06508202f, -0.06265686f, -0.04035436f, -0.04547524f, 0.01851743f, -0.06701665f, 
    0.13162419f, -0.14561522f, 0.10086919f, 0.13807027f, -0.01099482f, -0.11511445f, -0.06562648f, -0.05196293f, 
    0.00706740f, -0.10152134f, -0.05279488f, -0.05224380f, 0.04847706f, -0.01293918f, -0.03935695f, -0.05104758f, 
    0.00852312f, -0.02497861f, -0.02297086f, -0.01779101f, 0.08215044f, -0.01564176f, 0.02330038f, 0.08984052f, 
    -0.39591640f, 0.15444349f, 0.13001762f, 0.18475778f, 0.07869211f, 0.02165678f, 0.00112691f, -0.01228918f, 
    -0.04026886f, -0.02043214f, 0.09442678f, -0.08230166f, 0.15108815f, -0.22879973f, 0.06258789f, -0.08346648f, 
    -0.08362390f, -0.02584232f, -0.00770113f, -0.11727129f, 0.08016489f, 0.01103978f, -0.08968146f, -0.02512049f, 
    -0.13888749f, -0.02038976f, -0.06901225f, -0.05488921f, 0.01902555f, -0.02706645f, -0.02328457f, -0.00125433f, 
    0.05065931f, 0.09706269f, 0.05787404f, 0.04620370f, -0.09608415f, -0.03015198f, -0.06378137f, -0.03552786f, 
    -0.03137371f, 0.00682626f, -0.11517896f, 0.03438953f, -0.00387414f, -0.02666532f, 0.07720460f, -0.18686722f, 
    0.07002958f, -0.02793673f, 0.12140575f, 0.08771586f, -0.06078302f, -0.05531437f, 0.03896812f, -0.00489133f, 
    0.03806053f, -0.10142488f, -0.02958504f, 0.05186855f, 0.04643695f, 0.14734690f, -0.07533555f, 0.07311422f, 
    -0.02310134f, -0.03039674f, -0.03007234f, -0.08475845f, 0.05457998f, 0.02086937f, -0.05533229f, 0.10106645f, 
    -0.08647759f, 0.00802447f, -0.17969957f, -0.13023835f, -0.00923051f, -0.06788768f, -0.01417710f, -0.07986867f, 
    -0.02273826f, -0.09855549f, 0.06918112f, -0.06606667f, -0.02862937f, 0.14825924f, 0.08939971f, 0.04990002f, 
    -0.10427285f, 0.07576460f, -0.01204925f, 0.07149745f, 0.04079798f, 0.01846734f, 0.03648451f, 0.04202961f, 
    -0.25734195f, 0.02830615f, 0.16594282f, -0.10549053f, -0.04863719f, -0.00398587f, 0.00443852f, 0.08240036f, 
    0.05323862f, 0.03799596f, 0.02793958f, 0.11407338f, -0.28135878f, 0.12101332f, 0.06759081f, -0.34344587f, 
    -0.12841552f, -0.10772113f, 0.04202957f, 0.01800081f, -0.01728339f, -0.06897537f, -0.04529038f, 0.07232186f, 
    0.10121198f, 0.08217690f, -0.11221004f, 0.03065594f, 0.10053458f, -0.07170637f, -0.09117214f, -0.07523545f, 
    -0.01398213f, -0.02129441f, -0.09477398f, 0.01286815f, -0.17970671f, 0.15786418f, 0.01416726f, -0.06384747f, 
    -0.12690856f, -0.00893018f, -0.03065531f, 0.04360477f, 0.00166331f, 0.01307130f, -0.07534081f, 0.06594282f, 
    0.11931867f, 0.06639424f, -0.01473480f, 0.12975687f, -0.10410660f, -0.05157863f, 0.02721041f, -0.09816305f, 
    -0.00481844f, 0.01052783f, -0.05586335f, -0.10885113f, 0.10349333f, -0.00419454f, 0.07641791f, 0.10234214f, 
    0.04060344f, -0.02271812f, -0.07201427f, -0.07889021f, 0.01067064f, 0.03025792f, 0.04402124f, 0.02963836f, 
    -0.03454989f, 0.14522767f, 0.02788159f, 0.07541569f, -0.04196151f, 0.02889526f, -0.11987210f, 0.07493292f, 
    -0.04442150f, -0.06957825f, 0.03634088f, -0.06964689f, -0.14015533f, -0.28427562f, -0.03808383f, -0.15570623f, 
    0.02199003f, -0.01782689f, 0.06979690f, 0.03966065f, 0.01374597f, 0.05633999f, 0.05205363f, -0.24421822f, 
    -0.10938220f, -0.07775695f, 0.18077661f, 0.07061908f, -0.00011781f, 0.07725602f, 0.00148720f, 0.03140160f, 
    0.00828377f, -0.01260337f, 0.02465807f, -0.06246641f, 0.10964776f, 0.00547778f, -0.09259360f, 0.11891369f, 
    0.10476243f, 0.02545413f, -0.02301767f, -0.05571648f, -0.01170776f, 0.00083027f, 0.05811773f, 0.01407089f, 
    0.16245212f, 0.12681809f, 0.05176934f, 0.10479620f, 0.00163676f, -0.06139411f, -0.03687157f, -0.11849096f, 
    0.08577421f, -0.00231388f, -0.08236154f, 0.00416910f, -0.18203197f, -0.07919841f, -0.22706017f, -0.21523841f, 
    0.03018957f, 0.05927397f, -0.08953641f, -0.05189683f, 0.01251308f, 0.04945797f, 0.09517292f, 0.00333656f, 
    0.13621588f, -0.09191104f, -0.07128467f, -0.05474671f, -0.07638414f, -0.01504065f, -0.13273737f, -0.00830214f, 
    0.03310388f, 0.03280646f, 0.14435327f, 0.05499016f, -0.27782741f, 0.13362919f, -0.08857809f, -0.03423472f, 
    -0.06604242f, 0.00439891f, -0.05538467f, -0.09356796f, -0.04260067f, 0.00085597f, -0.03027918f, 0.07127518f, 
    0.16182207f, 0.00740500f, -0.13251045f, -0.03972012f, 0.08602765f, -0.00362498f, 0.02810663f, -0.05022813f, 
    0.01309555f, -0.11739399f, -0.01240989f, 0.07769950f, 0.06161982f, -0.05672314f, 0.13490757f, 0.08853752f, 
    0.01548942f, 0.03526057f, -0.05126124f, -0.06547862f, 0.02167673f, -0.02514466f, 0.05324921f, 0.09982175f, 
    0.27736425f, 0.12591790f, -0.21587341f, -0.16241072f, -0.02865685f, -0.07395750f, -0.04050434f, -0.03408967f, 
    -0.04091541f, -0.00800170f, 0.02684125f, 0.04397758f, -0.17962091f, -0.11759530f, -0.25135961f, -0.23728880f, 
    0.00430972f, -0.00202112f, -0.06977676f, 0.02909072f, -0.01759703f, 0.03251095f, 0.04646780f, -0.01584889f, 
    0.07999072f, 0.26742592f, -0.23932648f, -0.09971247f, -0.07786215f, 0.00186503f, -0.07506362f, -0.02308484f, 
    0.10794584f, 0.02864890f, -0.01723923f, 0.05660476f, -0.02221798f, -0.11770932f, 0.02866196f, 0.00976298f, 
    -0.07659686f, -0.07701598f, -0.09277855f, 0.01027594f, 0.04162785f, 0.01391460f, 0.09786513f, -0.01810529f, 
    -0.10417359f, -0.13871250f, -0.00070491f, 0.04180376f, 0.02389077f, -0.02775883f, -0.02671987f, 0.01322243f, 
    0.03998274f, -0.04109553f, -0.08066455f, 0.03261780f, -0.13332674f, 0.11071394f, 0.02600587f, -0.13574436f, 
    -0.03017575f, 0.06360138f, -0.07395316f, -0.01931823f, 0.04820336f, 0.00130351f, 0.02151007f, -0.10006340f, 
    -0.00978747f, -0.11920102f, 0.06664810f, 0.06149354f, 0.10471737f, -0.10218985f, 0.00167141f, -0.08445767f, 
    0.03117071f, 0.00373739f, -0.09527378f, -0.02568634f, 0.04633287f, -0.03299592f, 0.11095420f, 0.04452541f, 
    0.01994774f, -0.02317088f, -0.01186766f, -0.05510348f, -0.02103908f, -0.02775470f, -0.07558961f, 0.00532725f, 
    0.05556728f, -0.27014351f, 0.03384686f, -0.14670660f, 0.01711289f, -0.04223100f, -0.00476749f, -0.01690609f, 
    0.08335926f, 0.02515005f, -0.05450216f, 0.07465941f, -0.09649290f, 0.11801078f, -0.17337316f, -0.24575458f, 
    0.01458923f, 0.12361446f, -0.12745568f, -0.00731869f, 0.08626009f, 0.01583485f, 0.06473363f, -0.03393566f, 
    -0.05569980f, -0.06344161f, 0.02592769f, -0.15533967f, -0.00693871f, -0.00429717f, 0.01739795f, 0.02958619f, 
    0.07894652f, -0.02025726f, 0.00957598f, -0.15389898f, 0.08978929f, 0.15424658f, -0.12464660f, 0.09175935f, 
    0.00005381f, -0.05323045f, 0.07376733f, -0.00789476f, -0.04778515f, -0.03485861f, -0.04943093f, 0.05721475f, 
    0.10752310f, 0.18443225f, -0.21890551f, 0.04035783f, 0.05463159f, 0.01298033f, 0.06745821f, -0.06155942f, 
    0.12399068f, -0.02191433f, 0.05550291f, 0.00275970f, -0.02014283f, 0.16616088f, 0.00881894f, -0.03753314f, 
    0.05390984f, -0.08566520f, -0.16257900f, 0.06097553f, 0.05012449f, -0.06784523f, 0.08016931f, -0.13561212f, 
    -0.26138091f, -0.00120473f, -0.12574196f, -0.15082011f, 0.03059866f, -0.02326526f, 0.08804829f, -0.16997084f, 
    0.04200022f, -0.05538437f, 0.02758720f, 0.06770416f, -0.00004167f, 0.00913587f, 0.11845412f, -0.00544450f, 
    -0.02037863f, -0.06414572f, -0.05350928f, -0.18501815f, -0.00956277f, -0.01242300f, 0.06354374f, -0.15847355f, 
    0.11408887f, -0.04616282f, -0.06100205f, 0.16593757f, 0.06524248f, 0.02846858f, -0.05586516f, -0.06046039f, 
    0.02451663f, 0.06178838f, 0.01547612f, -0.06031135f, 0.19598393f, -0.15707903f, -0.16202486f, -0.16691497f, 
    0.00092322f, -0.10047154f, 0.04930121f, 0.01125075f, 0.08256611f, -0.03641356f, 0.02406796f, 0.02274396f, 
    0.02996934f, 0.10413374f, -0.15229759f, -0.03314050f, -0.02808141f, -0.02517390f, 0.01142852f, 0.02343130f, 
    0.08823491f, -0.07538382f, -0.04594347f, -0.04231713f, 0.15954626f, 0.07407759f, -0.10901199f, 0.13590701f, 
    0.02274400f, -0.04906936f, 0.10308010f, -0.02646629f, 0.09066939f, -0.10872544f, 0.06594240f, 0.06732481f, 
    0.22018152f, 0.10186833f, 0.01569169f, 0.05686362f, -0.04770758f, 0.05775096f, 0.03639843f, -0.01864591f, 
    0.00926753f, -0.03158078f, 0.05573069f, -0.02596727f, -0.16114244f, 0.04782239f, 0.10217125f, 0.00649828f, 
    -0.10623857f, -0.11316589f, 0.01890248f, 0.04824679f, -0.01373207f, -0.06550578f, -0.19440806f, 0.04479060f, 
    -0.05734036f, -0.00536138f, -0.10062663f, -0.13817298f, 0.07958180f, -0.05107037f, -0.08445802f, 0.06528662f, 
    0.06687463f, 0.07009659f, -0.11073668f, -0.09925328f, 0.03327822f, -0.08826926f, 0.12314365f, -0.17586797f, 
    -0.05150893f, -0.02234531f, -0.02094828f, 0.07100276f, 0.02018150f, -0.07660963f, 0.07088269f, -0.17071447f, 
    -0.03343657f, -0.09536251f, 0.24598676f, -0.03421544f, -0.00903084f, 0.02974451f, -0.09627705f, -0.06140847f, 
    -0.03894952f, -0.07863841f, 0.01563625f, -0.07688763f, -0.04975955f, -0.02006904f, -0.10059646f, -0.28015617f, 
    0.06678408f, -0.07908086f, -0.09850681f, -0.00624565f, 0.00155573f, -0.05601592f, 0.01704714f, -0.04389250f, 
    0.04273767f, -0.08319096f, -0.17145419f, 0.12222625f, 0.07362130f, 0.03106093f, -0.04215176f, -0.01406834f, 
    -0.03738215f, 0.02820495f, -0.02085744f, 0.05064872f, -0.01638488f, -0.12604845f, 0.07475965f, -0.13788910f, 
    0.12888752f, -0.00904735f, 0.06273305f, -0.09274965f, 0.04435452f, -0.01605660f, 0.08271443f, 0.12806125f, 
    -0.16034345f, -0.22706750f, 0.19734365f, 0.11758953f, -0.02708261f, -0.05619169f, 0.04313190f, -0.01188170f, 
    -0.06643350f, -0.07817982f, 0.15828046f, -0.04059167f, -0.02684022f, -0.08463242f, 0.03164624f, 0.02614278f, 
    -0.12292545f, -0.06306580f, -0.02784393f, -0.07304104f, -0.01980254f, -0.00484505f, -0.01340324f, 0.07880501f, 
    0.10516330f, -0.15406190f, -0.13129380f, -0.27430394f, 0.05413673f, -0.11342158f, -0.06107064f, 0.02350290f, 
    0.01828074f, -0.09801823f, 0.02882691f, 0.04606615f, 0.21474637f, -0.08471392f, 0.01162612f, 0.12560584f, 
    0.02425105f, -0.05736586f, -0.04835105f, -0.04481201f, 0.05864481f, 0.00093293f, -0.10549476f, -0.06468627f, 
    -0.17621161f, 0.08389054f, 0.18365827f, 0.01755062f, -0.09243897f, -0.00459855f, -0.12356806f, 0.06939248f, 
    -0.01185199f, -0.01550723f, 0.01248743f, -0.12056354f, 0.11870001f, 0.14931446f, 0.05158581f, -0.00413025f, 
    0.02540262f, 0.03281782f, 0.01365155f, 0.04005716f, 0.13754703f, -0.03760830f, -0.01319201f, -0.04841484f, 
    0.14976728f, -0.03450748f, -0.02999009f, 0.13787448f, 0.05174246f, 0.07658137f, 0.02976839f, -0.03689837f, 
    -0.03496021f, 0.07031754f, -0.05073920f, 0.05830677f, 0.07462266f, 0.11412212f, -0.06738130f, 0.10534627f, 
    0.04339088f, 0.02903335f, -0.05883334f, -0.10501319f, -0.01876730f, -0.02753161f, -0.03050206f, 0.03236671f, 
    -0.29107353f, -0.07938229f, -0.11585633f, -0.26943085f, -0.13944083f, 0.04163803f, 0.05490004f, -0.00159938f, 
    0.01419405f, 0.03298734f, -0.13316858f, 0.12182573f, -0.11351813f, -0.25008723f, 0.05464150f, 0.25892708f, 
    0.12751411f, -0.03815021f, 0.04011888f, 0.00873366f, 0.01459346f, 0.06446340f, 0.08752241f, 0.01498820f, 
    -0.04046070f, 0.09789783f, -0.03979233f, -0.03384392f, -0.07314590f, 0.06444834f, -0.01487410f, -0.09081897f, 
    0.01534233f, -0.00497623f, 0.07680773f, 0.09724688f, 0.23900628f, 0.02292725f, -0.04500331f, 0.09406222f, 
    -0.02682829f, -0.10898939f, -0.08715563f, 0.00949482f, -0.00456282f, -0.03709558f, -0.05944514f, -0.11532370f, 
    -0.09334146f, -0.09526007f, -0.04442738f, -0.00042633f, 0.16160855f, -0.13871352f, -0.23164301f, -0.00954216f, 
    0.11591366f, 0.07902398f, 0.02167226f, -0.11471883f, -0.12413757f, -0.08112963f, 0.03014208f, 0.08018734f, 
    0.05765148f, -0.04903086f, 0.00759820f, 0.00598596f, -0.02743070f, 0.08606566f, 0.09887265f, 0.06600565f, 
    0.13808134f, -0.23100208f, -0.01858952f, -0.33126622f, -0.12268834f, 0.00505678f, -0.03657302f, 0.04011368f, 
    0.05976218f, 0.02831408f, 0.06156666f, -0.10700706f, -0.17137671f, 0.02966454f, 0.07347821f, 0.00474331f, 
    -0.03500467f, 0.03481321f, -0.03588563f, 0.04021095f, -0.00582158f, 0.07595424f, 0.07460506f, 0.03875051f, 
    0.14583366f, 0.02995431f, -0.05885558f, 0.17644997f, 0.16489702f, -0.12458791f, -0.04297620f, -0.18652645f, 
    -0.11489535f, 0.01027014f, -0.04664524f, -0.02035522f, -0.06921117f, -0.05839399f, 0.17311728f, -0.07889111f, 
    -0.06784943f, 0.01761902f, 0.07260519f, 0.16250212f, 0.00881970f, -0.06444187f, 0.01664984f, -0.05390832f, 
    -0.26393083f, -0.01085234f, -0.08409686f, 0.01406740f, -0.04206168f, -0.16200165f, 0.17276081f, -0.00109945f, 
    0.04540909f, 0.06556520f, 0.10558147f, 0.02231397f, -0.11977438f, 0.47644967f, 0.15412658f, 0.14115071f, 
    0.08306338f, 0.10205804f, -0.08478186f, 0.08615880f, -0.04218870f, 0.01963766f, 0.00025384f, 0.01071428f, 
    -0.00250557f, -0.05211912f, 0.03106046f, 0.04117786f, -0.02616072f, -0.06081194f, 0.02483361f, -0.04596053f, 
    -0.06780129f, -0.01026592f, -0.04240884f, -0.03101230f, 0.58704591f, 0.00931983f, -0.26789260f, 0.07637782f, 
    0.08259267f, -0.09843696f, 0.03605808f, 0.17520566f, -0.11920137f, -0.01195630f, 0.11593156f, 0.08544776f, 
    -0.40539816f, 0.21862561f, 0.31907031f, -0.18099341f, -0.00406393f, 0.05036293f, 0.12358018f, 0.00821354f, 
    0.22322789f, 0.07914418f, 0.19507609f, 0.05348721f, -0.24946800f, 0.23224643f, -0.14607675f, 0.22345839f, 
    0.05766595f, 0.06472435f, -0.08140532f, -0.02883907f, 0.06267446f, -0.05327480f, -0.03303307f, 0.01019615f, 
    0.17242710f, -0.29095399f, -0.04857882f, 0.08118638f, 0.08059239f, 0.00707645f, -0.12732013f, 0.11009983f, 
    -0.13535863f, -0.01885075f, 0.05758860f, -0.10257211f, 0.08236367f, 0.04941087f, 0.07770836f, 0.09501653f, 
    0.10455837f, 0.07498620f, -0.10277671f, 0.15013821f, 0.06075796f, 0.02459783f, 0.13540643f, -0.00770231f, 
    -0.35802814f, -0.14334778f, 0.24057689f, -0.02205362f, -0.00090988f, -0.09165135f, 0.03959110f, 0.17108379f, 
    0.04135238f, -0.07168689f, -0.02746785f, 0.08539827f, -0.07134636f, -0.20441516f, 0.06344286f, -0.11189366f, 
    0.02024885f, 0.01008246f, 0.04004823f, -0.05782252f, 0.10653457f, 0.06108548f, -0.00154840f, 0.13357900f, 
    -0.19456887f, -0.13490036f, -0.02240802f, 0.01852164f, 0.06408039f, -0.04049652f, -0.07522982f, -0.05103971f, 
    -0.04323369f, 0.07188619f, 0.07157527f, 0.11814650f, -0.41238359f, 0.29008606f, 0.14134508f, -0.08914201f, 
    0.00958783f, -0.08332442f, 0.08041786f, -0.04171073f, 0.05138899f, 0.09971508f, -0.01087652f, -0.04661116f, 
    -0.09629158f, 0.14536110f, -0.29700914f, -0.07844893f, 0.07224418f, 0.03660974f, 0.04668029f, -0.03459162f, 
    0.09646845f, -0.14257228f, -0.01426110f, -0.04769528f, -0.04763953f, -0.23619880f, 0.14052382f, -0.38567814f, 
    0.00003206f, 0.07097610f, -0.12468489f, -0.03011751f, -0.01653230f, -0.00405605f, -0.05851902f, -0.07121835f, 
    -0.21524481f, -0.05841275f, 0.10127560f, 0.16975346f, -0.06379537f, -0.01844715f, 0.01512448f, -0.03177496f, 
    -0.18437459f, -0.10503251f, -0.02323761f, -0.08493177f, -0.13023694f, -0.03338560f, -0.07555520f, 0.10113586f, 
    0.03965023f, -0.03989010f, 0.01640531f, -0.01740048f, 0.01237215f, 0.07962210f, 0.05699037f, -0.01656822f, 
    0.31793940f, 0.06278360f, 0.23384027f, -0.03382291f, -0.06609520f, 0.02377252f, 0.12199067f, -0.07421301f, 
    -0.04328290f, -0.00504779f, -0.08061223f, 0.07807964f, 0.13533658f, 0.18004079f, -0.15710387f, -0.33173636f, 
    0.05160902f, -0.05434605f, 0.07695829f, -0.08540712f, 0.00117768f, 0.08590134f, -0.12574992f, 0.08865351f, 
    0.00819984f, -0.13901871f, 0.17325778f, -0.07128046f, -0.04395111f, 0.03433921f, -0.13567448f, 0.04450466f, 
    -0.10931281f, -0.11047044f, 0.00364890f, 0.04319386f, -0.11392301f, -0.01065840f, -0.06989916f, -0.02724577f, 
    -0.05473598f, 0.02251600f, -0.00536329f, 0.09870350f, 0.01790463f, 0.03620444f, -0.16090322f, 0.03982255f, 
    0.05068917f, 0.22365077f, 0.27918676f, 0.04910169f, 0.07943106f, 0.05293106f, -0.06372022f, -0.06739715f, 
    -0.04045679f, 0.01374518f, -0.00840269f, 0.05386971f, 0.06356376f, -0.31275797f, 0.03010824f, 0.22280574f, 
    -0.00733226f, 0.04883140f, 0.13415071f, -0.01167506f, -0.08367979f, 0.03474162f, -0.22337832f, 0.01404865f, 
    -0.36260265f, 0.17986375f, -0.10402797f, -0.05969448f, 0.02011426f, -0.00823585f, -0.07496342f, -0.04385122f, 
    -0.05347472f, -0.11049627f, 0.04949033f, 0.05818396f, -0.11768725f, 0.13493437f, 0.18050435f, 0.21528597f, 
    0.04593707f, -0.02135425f, -0.06154470f, 0.06555142f, 0.09047125f, 0.04517253f, -0.07534619f, 0.07031106f, 
    -0.07302607f, 0.04918677f, 0.05844239f, -0.02189538f, 0.09819449f, 0.00959019f, 0.01622470f, -0.13775027f, 
    0.07408693f, -0.01591760f, 0.05476217f, 0.06141933f, -0.20281400f, -0.08209315f, -0.03558432f, 0.00788673f, 
    -0.02889208f, -0.06738094f, 0.06527950f, 0.16211177f, 0.11930607f, -0.07418685f, 0.07837135f, -0.10880698f, 
    0.03482815f, -0.01806673f, 0.11026063f, -0.01930952f, -0.03205408f, 0.05372404f, -0.10196495f, -0.06196316f, 
    0.02099218f, -0.09369811f, 0.04839458f, -0.09053312f, -0.11095314f, -0.05131311f, 0.01589886f, 0.05051835f, 
    -0.02705297f, 0.03361742f, -0.07809615f, 0.07751048f, 0.07931960f, -0.01124062f, -0.09153261f, -0.05183987f, 
    0.11079718f, 0.00247665f, 0.00995639f, 0.02143002f, -0.04134237f, -0.01445852f, -0.01208473f, -0.07142343f, 
    -0.09072366f, 0.11979119f, -0.10958046f, 0.13218948f, -0.16017574f, -0.02934417f, 0.14396961f, -0.04969959f, 
    -0.01031488f, 0.01290585f, -0.01249812f, 0.00030268f, 0.02177760f, -0.12784347f, 0.04198061f, -0.02885272f, 
    0.08022931f, 0.13057783f, 0.04725640f, 0.02505411f, 0.00444222f, 0.14135662f, 0.09218091f, -0.09960839f, 
    -0.14569460f, -0.01024036f, 0.01085295f, 0.04368492f, -0.48764974f, -0.00358418f, -0.03097630f, -0.03878089f, 
    -0.01195788f, 0.05202566f, -0.00921738f, -0.02752604f, -0.02792559f, -0.05178425f, 0.06098172f, 0.16103196f, 
    -0.22029915f, -0.01577847f, 0.14626479f, -0.10500697f, -0.03836050f, 0.02455197f, -0.00999262f, -0.01203755f, 
    0.03880300f, -0.02653230f, 0.07828853f, -0.09852368f, 0.44250599f, 0.07137308f, -0.05222248f, -0.24151334f, 
    -0.02223349f, -0.01021198f, 0.01563166f, -0.03918963f, 0.08188638f, 0.08210985f, -0.06229808f, 0.10689285f, 
    -0.15834539f, 0.11934600f, -0.12720624f, -0.33035338f, 0.04955523f, 0.04599469f, -0.00699349f, 0.09088279f, 
    -0.06678639f, 0.07163024f, -0.04376841f, -0.02101526f, -0.25122634f, 0.14335693f, -0.14252892f, 0.07967588f, 
    -0.03044437f, 0.04064495f, 0.09497257f, 0.02757970f, -0.00946803f, 0.04258593f, 0.01759207f, 0.05499524f, 
    -0.11427020f, -0.23775125f, 0.19735982f, -0.10956775f, 0.03608062f, 0.00327105f, -0.09658250f, -0.00360074f, 
    0.05019714f, -0.01781864f, 0.10529925f, 0.14814213f, -0.10428121f, -0.17864756f, 0.03448106f, -0.12411814f, 
    0.11221708f, 0.05054230f, -0.06537659f, 0.07982089f, -0.05151101f, -0.01639557f, 0.01997059f, -0.08474506f, 
    0.07960221f, 0.21087673f, 0.02639494f, -0.02313508f, 0.06322721f, 0.03137663f, 0.06506693f, 0.00432915f, 
    0.00418405f, 0.07292337f, 0.09030414f, 0.00383863f, 0.14540221f, -0.01864606f, -0.17393076f, 0.08823599f, 
    -0.01075017f, 0.06073060f, 0.01181978f, 0.01062934f, -0.05502567f, 0.02088676f, 0.04830519f, -0.11691758f, 
    -0.07575761f, 0.15692572f, 0.21906215f, 0.00150965f, 0.01808132f, -0.02230185f, 0.11688563f, -0.06450424f, 
    0.04683317f, -0.06472510f, 0.06830847f, -0.03924138f, 0.13242091f, -0.05185980f, -0.08016871f, 0.00759780f, 
    0.06464894f, -0.05686487f, 0.09187381f, -0.15485001f, -0.03985949f, -0.00015826f, -0.04896052f, 0.06435136f, 
    -0.07422593f, 0.01096514f, 0.07739624f, -0.10656600f, 0.04965600f, -0.04811467f, 0.09293418f, -0.05453956f, 
    0.02339613f, 0.10125829f, -0.01873350f, 0.00815656f, -0.24549749f, -0.05391497f, 0.06769322f, -0.01808876f, 
    -0.03626403f, 0.01587397f, 0.00566595f, 0.09857892f, -0.02660492f, 0.00501106f, -0.10633273f, -0.00826514f, 
    -0.11862730f, -0.09616749f, 0.00818255f, -0.04634197f, 0.06735053f, -0.00553409f, -0.10774852f, -0.00397655f, 
    -0.03931800f, -0.03782760f, -0.04655945f, 0.00505778f, 0.04066967f, -0.08291159f, -0.06459697f, 0.18825640f, 
    -0.01549190f, -0.02732338f, -0.03248786f, 0.01267906f, -0.01127269f, 0.15370350f, 0.02981174f, 0.01285989f, 
    -0.24883652f, 0.11978351f, 0.05351809f, -0.00959262f, 0.03720573f, -0.08440610f, -0.02789036f, 0.06264141f, 
    0.02196657f, 0.05817150f, 0.03219709f, 0.07422604f, 0.10898975f, -0.05438192f, -0.22012170f, 0.18630789f, 
    0.08896813f, -0.03005149f, 0.06948216f, -0.03538621f, -0.03957488f, -0.01411581f, 0.01366440f, -0.07552024f, 
    0.02491509f, 0.15720759f, -0.01711472f, -0.13931045f, -0.10069862f, -0.03955359f, -0.05395223f, -0.04744333f, 
    -0.11181530f, 0.02950507f, 0.06396630f, -0.08935570f, 0.14244191f, -0.03440861f, -0.14851424f, -0.08411328f, 
    0.11751001f, -0.02328672f, -0.03755122f, -0.05761557f, -0.05759411f, 0.04370434f, -0.01916171f, 0.09079821f, 
    0.18617094f, -0.06556582f, -0.00990640f, -0.08958122f, 0.09902208f, -0.01845150f, 0.03159134f, 0.04234638f, 
    -0.00956915f, -0.14230508f, 0.06021566f, -0.04601475f, -0.04656271f, 0.12153679f, -0.10533075f, 0.04518354f, 
    0.14443150f, 0.05311092f, 0.02300296f, -0.15902856f, -0.10964195f, -0.02321403f, -0.06483209f, 0.04582897f, 
    -0.11913817f, -0.02670127f, -0.20296821f, -0.19549961f, 0.08544970f, 0.14376657f, -0.04156195f, -0.08254310f, 
    -0.04124603f, -0.11495312f, 0.03038546f, -0.04819555f, -0.14356607f, 0.11606447f, 0.13363163f, 0.08189563f, 
    0.07616725f, 0.11794838f, -0.14757180f, 0.03333791f, 0.06025494f, 0.03562063f, -0.00746124f, 0.02845846f, 
    -0.03491123f, -0.11680248f, -0.09566399f, 0.17997469f, -0.10691632f, -0.00564009f, 0.08557644f, -0.00025911f, 
    0.10148723f, -0.13453671f, 0.04832457f, 0.02796622f, -0.26496902f, -0.02739151f, -0.05866226f, -0.23973094f, 
    -0.00865524f, 0.02080884f, -0.06797903f, -0.05142180f, -0.10920820f, -0.13551006f, -0.08795864f, -0.16387710f, 
    0.37127528f, -0.38248360f, -0.12962326f, -0.13266978f, -0.03385489f, 0.04247141f, 0.03272431f, -0.00594105f, 
    0.03705985f, -0.10366280f, -0.07833375f, -0.06189112f, -0.04900379f, 0.08015011f, 0.02036967f, -0.16079098f, 
    0.08736755f, 0.16405801f, -0.03365596f, -0.15577616f, 0.02136140f, -0.09248914f, 0.04301256f, 0.00906497f, 
    -0.06024400f, -0.13990735f, -0.08699020f, -0.29139173f, -0.19404571f, 0.05902771f, -0.05484951f, 0.06751705f, 
    -0.06232490f, -0.06587654f, 0.02516773f, -0.07531413f, 0.20653844f, -0.06589418f, -0.20816113f, -0.13947350f, 
    -0.09519779f, -0.09193353f, 0.09062332f, -0.01780773f, 0.01995307f, -0.07111437f, -0.04437773f, -0.14278351f, 
    0.02641585f, 0.16775760f, -0.09986295f, -0.17175782f, 0.05689690f, 0.05119170f, 0.05428842f, 0.12423352f, 
    0.08642289f, -0.06144687f, 0.04017116f, 0.09698282f, -0.08116081f, -0.00391690f, 0.11993136f, -0.00620034f, 
    0.07986630f, -0.04266731f, -0.10357761f, -0.00624614f, -0.01654432f, -0.00835963f, -0.04410033f, -0.15270832f, 
    0.32426926f, 0.10820548f, -0.19204767f, -0.03749989f, -0.06266683f, -0.03529282f, 0.08336958f, -0.01240016f, 
    0.06356902f, 0.03453187f, 0.01510660f, 0.03644168f, -0.16794974f, 0.02326250f, 0.06209823f, 0.07253396f, 
    0.01580849f, -0.00849653f, 0.06222804f, -0.17632094f, -0.01075629f, -0.12567520f, 0.05252742f, 0.04648462f, 
    0.06133172f, 0.09087717f, 0.00420649f, -0.03941050f, 0.04082663f, 0.01181963f, -0.13276808f, 0.07401872f, 
    0.00266719f, 0.00520453f, -0.04607435f, -0.11293650f, -0.08474943f, -0.24588440f, -0.08709933f, 0.06331511f, 
    -0.00008693f, -0.04288544f, 0.01771194f, 0.10851251f, 0.07044457f, 0.02656156f, 0.06160721f, 0.05911751f, 
    0.31756464f, 0.15509002f, 0.03191575f, -0.09984954f, 0.09649473f, -0.00955055f, 0.05245047f, 0.03622850f, 
    0.10271369f, 0.09657519f, 0.17355198f, 0.11431370f, -0.06649904f, 0.04706656f, 0.08406363f, -0.02752868f, 
    -0.03027240f, 0.00725442f, 0.09271517f, -0.00607787f, -0.04191081f, 0.11247317f, -0.04185066f, 0.00047293f, 
    -0.38243696f, -0.12743971f, -0.13642457f, -0.10266294f, 0.00396809f, 0.06212943f, 0.04017461f, -0.14801781f, 
    0.12395877f, -0.10445338f, -0.10340527f, 0.00865488f, 0.10895877f, -0.03411139f, -0.06603998f, 0.01768813f, 
    -0.00162883f, -0.06271826f, 0.08524379f, -0.10595746f, 0.07440673f, 0.04659508f, 0.02869681f, -0.07117707f, 
    0.20260888f, -0.10676048f, -0.06130978f, -0.02711054f, -0.06263082f, -0.01969032f, -0.00176505f, 0.01245136f, 
    -0.05389304f, 0.09533067f, -0.09611726f, -0.04289098f, -0.50579548f, 0.05479448f, -0.01948869f, -0.18700927f, 
    0.06961608f, -0.07652462f, -0.06586572f, -0.08483019f, -0.03710227f, -0.07502837f, -0.09668595f, -0.09954125f, 
    0.09300226f, 0.06791054f, 0.03369125f, -0.09642072f, -0.16738880f, 0.11500257f, 0.00601800f, -0.03191961f, 
    0.00936689f, -0.02649926f, -0.00086517f, -0.08555558f, 0.05367354f, 0.23358828f, -0.07437337f, 0.20504661f, 
    0.02562219f, -0.03332449f, 0.08263912f, -0.01065742f, 0.02011305f, -0.06103031f, 0.01734981f, -0.14433070f, 
    0.15619041f, -0.05629354f, 0.00084582f, 0.08863562f, 0.02196754f, -0.08801533f, 0.02788935f, 0.03832131f, 
    0.14564782f, 0.03562417f, -0.11320478f, -0.00487853f, -0.30539304f, -0.29886150f, -0.17337865f, -0.05805277f, 
    0.06510038f, 0.03335990f, 0.05021453f, 0.00516607f, 0.17125140f, 0.06269532f, 0.05558582f, 0.02113935f, 
    -0.29937592f, -0.21137080f, -0.22700514f, -0.10346998f, 0.02093134f, -0.04311559f, -0.10225318f, -0.10207579f, 
    -0.07637157f, -0.01043297f, -0.12949845f, 0.07047591f, 0.19293132f, 0.16387223f, 0.02161581f, -0.18166383f, 
    0.12288115f, -0.01217627f, 0.08833347f, -0.00303267f, 0.00143493f, 0.09079470f, 0.08310033f, 0.07945906f, 
    -0.08021931f, -0.08941630f, -0.13626514f, -0.01223869f, -0.01274286f, 0.03728358f, -0.07175133f, 0.11912720f, 
    0.00728552f, 0.06360648f, 0.10283154f, -0.06008852f, 0.04679780f, -0.01152719f, -0.06598894f, -0.02087014f, 
    -0.02616668f, 0.08212294f, 0.03558818f, 0.02190102f, 0.03443535f, -0.03268730f, 0.03450466f, -0.00218021f, 
    -0.42551106f, -0.09254184f, 0.15344575f, 0.16583541f, 0.17366257f, 0.00954322f, 0.00490908f, -0.07060921f, 
    0.04439083f, -0.03035089f, -0.05668973f, 0.07376304f, -0.12701008f, 0.03051060f, 0.07690307f, 0.07577413f, 
    0.00008284f, 0.03605098f, -0.01000950f, 0.06664447f, 0.06133149f, 0.06252786f, 0.05290363f, 0.09046939f, 
    -0.10269965f, -0.03265113f, 0.01255416f, -0.03537934f, 0.04837774f, -0.08111273f, -0.00795833f, 0.01154235f, 
    0.07930586f, 0.10655390f, -0.05441029f, 0.07734208f, 0.17564929f, -0.04854977f, 0.04701265f, -0.02105952f, 
    0.10429668f, 0.00782379f, 0.03473875f, 0.01574608f, 0.00129340f, 0.03404235f, 0.09827137f, -0.02124150f, 
    -0.28573540f, -0.19218108f, 0.09740304f, -0.08806142f, 0.09427010f, -0.03995646f, -0.11647777f, -0.01747263f, 
    0.05252895f, -0.12432681f, -0.02947073f, 0.01288549f, 0.13050987f, 0.08265915f, -0.10478916f, 0.17484188f, 
    0.00463719f, -0.04162467f, -0.00050288f, -0.00668687f, 0.00212659f, 0.01178814f, 0.13536887f, 0.06787750f, 
    -0.05955303f, -0.17143191f, -0.11713535f, 0.09468950f, 0.00465327f, -0.01868253f, 0.05005358f, 0.16509202f, 
    0.02327809f, 0.09857985f, 0.01623286f, 0.16356663f, 0.08151309f, 0.01133469f, 0.09286366f, -0.12670267f, 
    -0.07086302f, -0.02639398f, 0.05170188f, 0.06264336f, -0.02263247f, -0.01836171f, -0.02458666f, -0.09544481f, 
    -0.35709217f, -0.15889768f, -0.16052483f, -0.11840559f, 0.04696604f, -0.02698009f, -0.04950472f, -0.03910386f, 
    0.01117773f, -0.03259820f, -0.10340334f, 0.06935431f, 0.16655087f, 0.00104538f, 0.05136039f, -0.10324771f, 
    -0.16858527f, -0.01676057f, -0.01459630f, -0.00372598f, -0.06122202f, 0.02336342f, -0.07600134f, 0.00772334f, 
    0.01246604f, 0.21493505f, 0.07431507f, 0.09739889f, 0.05447951f, -0.09699639f, 0.00757039f, 0.00739762f, 
    -0.00089535f, 0.10689782f, 0.04484520f, 0.13740513f, 0.04248650f, -0.07223630f, 0.00228092f, -0.08510543f, 
    0.07120490f, 0.11668269f, 0.01861107f, -0.02758914f, -0.00199928f, -0.01557208f, -0.01042526f, -0.11740946f, 
    0.05657868f, 0.06935431f, 0.04215619f, 0.01967159f, -0.08868866f, 0.01127202f, -0.05843888f, -0.00251729f, 
    0.13076472f, 0.00594812f, 0.09109168f, -0.13070591f, 0.04964219f, -0.05663256f, -0.06826069f, 0.01371299f, 
    0.03726006f, -0.01393263f, 0.02606621f, -0.07896459f, 0.01632624f, 0.13780507f, -0.04366267f, 0.20137431f, 
    -0.16405733f, -0.09864625f, -0.02884212f, 0.09156381f, 0.11604302f, -0.02389351f, -0.02167922f, -0.03699257f, 
    0.04390728f, 0.01045213f, 0.08094719f, 0.06217127f, -0.10422837f, -0.30609226f, -0.13715725f, 0.07782963f, 
    0.06526555f, 0.04342041f, 0.08706067f, 0.10233968f, 0.04232974f, -0.04684193f, -0.10530911f, -0.06304114f, 
    0.18856172f, -0.00842410f, -0.04891876f, 0.03333177f, 0.07678274f, -0.06742152f, 0.09634955f, -0.04639997f, 
    0.01132044f, -0.08326123f, -0.03313146f, 0.15811987f, -0.23237321f, 0.04113454f, 0.19284043f, 0.21581379f, 
    -0.04377079f, -0.07387297f, -0.05052028f, -0.03616253f, -0.01720646f, -0.11826577f, -0.11324179f, -0.12139311f, 
    -0.28910381f, -0.11467926f, -0.05400283f, -0.12099577f, 0.03736774f, 0.01346546f, 0.06383998f, -0.02517766f, 
    0.05123803f, 0.08454682f, 0.13597395f, 0.00660561f, -0.09584522f, -0.10580897f, -0.12669508f, 0.14961666f, 
    0.01323015f, -0.15527640f, 0.10230390f, 0.02806583f, 0.12996529f, 0.07305130f, 0.13751318f, -0.00765935f, 
    -0.26615587f, 0.01428623f, -0.13961558f, 0.06927139f, -0.06233545f, 0.03256473f, -0.04555852f, -0.02688070f, 
    -0.01243484f, -0.02573810f, -0.05053427f, -0.10961857f, -0.38744679f, 0.01741845f, -0.18336543f, 0.05631551f, 
    -0.03545881f, -0.12449167f, -0.07457978f, -0.11903811f, -0.02273541f, -0.06233631f, 0.13649997f, 0.02204239f, 
    -0.11889042f, -0.16587137f, -0.08955500f, 0.06628476f, 0.01154291f, 0.10626208f, 0.14190619f, 0.03788289f, 
    0.08564871f, -0.03551634f, -0.08152796f, 0.03307058f, 0.17643364f, 0.00604630f, 0.05887645f, -0.17499606f, 
    -0.12073935f, -0.06534825f, 0.04612761f, -0.01424908f, 0.05892562f, -0.09118409f, -0.07420589f, 0.02929107f, 
    -0.39687333f, -0.28670940f, 0.07192031f, 0.12430077f, 0.11506432f, 0.05116283f, -0.03813734f, -0.09640801f, 
    -0.02039621f, -0.00497029f, -0.14154609f, 0.02446255f, 0.02180895f, 0.12029912f, -0.10454094f, -0.00141013f, 
    0.07686219f, 0.13718721f, 0.04972158f, 0.02160772f, 0.00560924f, 0.02395731f, 0.01165922f, -0.11824704f, 
    0.29502493f, 0.10921385f, -0.00015658f, 0.04201686f, -0.15074164f, -0.08657306f, -0.04117654f, 0.02304827f, 
    0.06205030f, -0.04417558f, -0.06590725f, -0.05539029f, 0.06644047f, 0.03784105f, -0.00493638f, 0.03430716f, 
    0.06890119f, -0.04260460f, 0.06037161f, -0.06298739f, 0.01242993f, 0.01229084f, 0.05943497f, 0.04352732f, 
    -0.45593318f, -0.05326307f, -0.06350099f, -0.06622930f, -0.00393902f, 0.07466285f, -0.08362734f, -0.06700001f, 
    0.03949891f, 0.06442875f, -0.00907363f, 0.09107344f, 0.05205087f, 0.03987924f, -0.04229004f, -0.03117312f, 
    -0.02740400f, 0.10777725f, 0.00994270f, 0.02701976f, -0.02774141f, 0.00942887f, -0.02843350f, -0.05442973f, 
    -0.09345357f, -0.12546349f, -0.09665691f, -0.07031018f, 0.14949539f, -0.22173485f, -0.13726386f, -0.01622476f, 
    -0.00382918f, -0.18238811f, -0.00396753f, -0.07288879f, 0.14288749f, 0.04939893f, -0.00160946f, 0.13599916f, 
    -0.06650403f, 0.03341756f, 0.00174339f, 0.05262229f, 0.05004843f, -0.02008194f, -0.03320756f, 0.14762035f, 
    0.12413552f, 0.19725497f, 0.23794560f, -0.03584094f, 0.02785240f, 0.00165098f, -0.03458027f, 0.01762091f, 
    -0.03692868f, -0.01311188f, 0.07018900f, 0.04339620f, 0.06991912f, -0.00223587f, -0.14147262f, 0.08224367f, 
    -0.01099248f, -0.10597339f, -0.08384039f, 0.07705776f, -0.02658321f, 0.01365156f, 0.05547348f, -0.13650115f, 
    0.17663434f, -0.04055352f, 0.08488610f, -0.08709969f, -0.16216131f, -0.06627942f, 0.01564097f, -0.14748517f, 
    -0.00573079f, 0.02140935f, -0.08083552f, -0.06092853f, -0.33714071f, -0.10978319f, -0.05111209f, -0.14508219f, 
    0.00901093f, 0.03236951f, -0.05081408f, -0.05585090f, -0.06261249f, -0.07506762f, -0.03109037f, -0.05142137f, 
    -0.34465349f, -0.24680337f, -0.10588472f, -0.23556088f, 0.02960281f, 0.05359804f, 0.07646788f, -0.03864341f, 
    0.08701421f, 0.09677861f, 0.00355836f, 0.13251147f, -0.47075248f, -0.28118759f, -0.28965691f, -0.02193643f, 
    0.09067225f, -0.11173664f, 0.01313661f, -0.15457062f, 0.01918212f, 0.00332150f, 0.01732791f, -0.10020743f, 
    0.01646261f, -0.09010347f, 0.05906554f, 0.12423699f, 0.11148196f, 0.10463892f, 0.05035351f, 0.08641016f, 
    -0.01536086f, 0.07955275f, 0.02534211f, 0.17086607f, -0.44773442f, -0.21314722f, -0.00050204f, -0.27314124f, 
    0.10175914f, -0.08394031f, -0.01546010f, 0.06677678f, -0.00616853f, 0.10776465f, 0.04812677f, 0.08809526f, 
    0.22989060f, 0.12755866f, -0.09108596f, -0.08342680f, -0.00653064f, 0.08917916f, 0.07661974f, -0.02584897f, 
    0.03834664f, 0.11315835f, 0.10350006f, 0.20289455f, -0.02288764f, -0.03184964f, -0.19776121f, -0.07228955f, 
    0.08231301f, 0.00089031f, -0.02075928f, 0.00740887f, -0.09442587f, 0.01348527f, -0.12677458f, 0.12790842f, 
    -0.44349420f, -0.06097600f, -0.34375387f, -0.10576681f, 0.14604646f, -0.20580634f, -0.11431893f, 0.00496667f, 
    0.03649337f, 0.03366750f, 0.00443812f, -0.08682004f, -0.05451573f, 0.04058157f, -0.16954271f, 0.06715213f, 
    -0.06899207f, -0.03581183f, -0.08607230f, 0.09035541f, -0.09861004f, 0.09062222f, 0.07601537f, 0.02439510f, 
    0.16590188f, -0.02314602f, -0.24713613f, 0.08150572f, -0.10168931f, 0.02666150f, 0.02597961f, 0.06377285f, 
    0.03582962f, 0.04398962f, 0.05157691f, -0.06828976f, 0.23295805f, -0.00993839f, -0.13816012f, 0.00343731f, 
    0.05852163f, -0.01808122f, -0.01053425f, 0.03816579f, 0.06939004f, -0.00006530f, 0.06191889f, 0.01048213f, 
    -0.16053811f, -0.08864938f, 0.18475325f, -0.04886473f, -0.00943613f, -0.03289798f, -0.01950422f, -0.08070111f, 
    -0.01040348f, -0.09186267f, 0.03293426f, -0.07946105f, 0.11266229f, 0.07326787f, -0.00016541f, -0.06851539f, 
    -0.10968492f, -0.05863805f, 0.06557795f, 0.03095127f, -0.09016405f, 0.00864130f, -0.13281767f, -0.07169759f, 
    -0.26324102f, 0.12907429f, -0.15984561f, 0.01879846f, 0.15590173f, -0.02873437f, 0.03211780f, 0.00447169f, 
    -0.00421300f, 0.01334105f, -0.08740088f, 0.11138413f, 0.13266289f, -0.01363268f, -0.03519926f, 0.14808606f, 
    0.09503066f, 0.04688149f, -0.07339403f, -0.11724300f, -0.01142283f, 0.08911872f, -0.06367423f, 0.02439389f, 
    0.10404351f, 0.06198493f, 0.00279430f, 0.04377936f, -0.04326316f, -0.06274775f, 0.04191652f, 0.01036260f, 
    0.01960679f, -0.07604106f, -0.07922076f, -0.04100056f, -0.05090313f, -0.13553950f, 0.01251844f, -0.07616147f, 
    -0.12837712f, -0.01804883f, -0.03902962f, 0.03641516f, -0.04218622f, -0.06138860f, 0.07949326f, -0.11609405f, 
    -0.21453315f, -0.42578492f, -0.01684001f, 0.07291567f, 0.11958418f, -0.00632795f, -0.05333465f, 0.05879971f, 
    0.02942798f, 0.05670724f, -0.02095245f, -0.03600322f, 0.21506874f, -0.08833781f, -0.28259856f, 0.12880443f, 
    0.09584624f, -0.17553397f, 0.01571523f, 0.15744320f, -0.04461004f, 0.08683439f, -0.03207505f, 0.02457611f, 
    -0.37941602f, -0.02610259f, -0.02105446f, -0.05020772f, 0.01580934f, 0.00421305f, 0.05066609f, 0.09797866f, 
    -0.03061985f, 0.00873425f, 0.02662957f, -0.12448905f, 0.02817836f, -0.20851719f, -0.01578871f, -0.20677334f, 
    -0.03009091f, 0.02979025f, -0.03385962f, -0.02070082f, -0.07499079f, -0.04768543f, -0.05083418f, -0.03346920f, 
    0.08247366f, 0.02249706f, -0.11849666f, 0.02690861f, -0.11575848f, 0.01007039f, -0.11818636f, -0.11125632f, 
    -0.05152326f, 0.00763630f, 0.00414397f, -0.13242833f, 0.11281839f, -0.18584496f, 0.01180028f, -0.07796969f, 
    -0.05996037f, 0.07609817f, 0.05105764f, 0.00421479f, 0.14737721f, -0.02088733f, -0.04990061f, 0.04407068f, 
    0.19240020f, -0.07837438f, 0.05284354f, -0.14546725f, -0.07707872f, -0.09003621f, 0.01225092f, 0.00559870f, 
    0.01464623f, -0.11680990f, -0.06788732f, 0.04489751f, 0.16615878f, -0.13481134f, -0.01953457f, 0.00068838f, 
    0.12413675f, 0.05880874f, -0.10092472f, 0.02125638f, 0.01314033f, 0.01640651f, -0.02830329f, 0.03410624f, 
    -0.16424692f, -0.33464527f, 0.01704842f, -0.30198148f, 0.02142591f, -0.06488022f, 0.08723669f, -0.01459647f, 
    -0.05771307f, 0.02430644f, -0.01330025f, -0.06961827f, 0.19309436f, -0.01985987f, -0.30344638f, 0.23518512f, 
    0.03716610f, -0.04118469f, -0.00468361f, 0.07177047f, 0.10988170f, 0.02904875f, 0.09004008f, -0.01286659f, 
    0.17190942f, 0.04936633f, 0.01631403f, 0.16221680f, -0.03719774f, 0.04592936f, -0.06596658f, -0.03266124f, 
    0.02635647f, -0.08694186f, -0.02311026f, 0.00751878f, 0.16814739f, 0.07054001f, 0.01307575f, 0.12376612f, 
    0.06704208f, -0.05582020f, 0.03926161f, 0.00986033f, -0.04156825f, 0.03408640f, -0.00004215f, 0.04032249f, 
    0.43552786f, 0.06167962f, 0.01009174f, -0.23540550f, 0.06328713f, -0.12980847f, -0.15453826f, 0.03311066f, 
    0.02376164f, 0.13161992f, 0.15731576f, 0.11884211f, 0.11049422f, -0.15548289f, 0.06788276f, 0.16876173f, 
    -0.04385440f, -0.02319307f, -0.09664968f, -0.00635248f, 0.01722009f, -0.01917767f, -0.01213677f, 0.06126703f, 
    0.22528097f, -0.02566596f, -0.04514827f, 0.21700723f, -0.11864380f, 0.12412059f, -0.05227906f, 0.05213696f, 
    0.00428226f, 0.05179676f, 0.02182409f, -0.00819902f, -0.07482512f, 0.18009968f, -0.01226853f, 0.10455929f, 
    0.15928850f, -0.08021720f, 0.02515785f, 0.07435527f, 0.02475389f, 0.00945328f, -0.05146961f, -0.10376295f, 
    0.24755265f, -0.05669035f, -0.08153475f, 0.03818336f, 0.06829434f, -0.01076380f, -0.03603234f, -0.05124550f, 
    0.05424555f, 0.13946654f, 0.05425974f, 0.06127442f, 0.19277415f, -0.01104318f, -0.08340713f, -0.00926169f, 
    -0.04369003f, 0.00324255f, 0.09026778f, -0.05136351f, -0.02376855f, 0.04798915f, 0.02384613f, 0.01579415f, 
    0.06132957f, 0.11560460f, -0.08856197f, 0.11989493f, 0.11231694f, -0.06029486f, 0.11457674f, 0.10643048f, 
    0.02012737f, 0.03207066f, 0.03293978f, -0.01731334f, 0.07436920f, -0.03570883f, 0.03876535f, 0.08818848f, 
    -0.00089249f, -0.05444524f, -0.02869579f, -0.04595313f, 0.04990228f, 0.01132592f, 0.04584680f, 0.04132909f, 
    -0.04707174f, 0.14263384f, -0.10033070f, -0.27594069f, 0.06058347f, -0.05235537f, -0.00884951f, 0.10783363f, 
    0.00264360f, -0.04382270f, 0.12290118f, 0.04026906f, -0.28059348f, -0.00479506f, 0.06175457f, 0.08191848f, 
    0.02450944f, 0.01744970f, -0.07320771f, 0.04997396f, 0.02168995f, 0.01465772f, 0.03638904f, -0.03145092f, 
    0.14221010f, 0.08789893f, 0.03449947f, -0.09161734f, -0.03949619f, 0.11777077f, -0.02335016f, 0.03725506f, 
    -0.02485499f, -0.04509591f, 0.03817320f, 0.02457882f, -0.06987421f, 0.11516415f, 0.01529581f, -0.04550656f, 
    -0.05117296f, -0.00041921f, -0.02241014f, -0.14703980f, -0.12374292f, 0.10454833f, -0.11776696f, -0.17391558f, 
    -0.10096055f, 0.14222744f, -0.05448082f, 0.03875413f, -0.17990236f, -0.07833039f, 0.01427511f, -0.15319248f, 
    0.03430786f, -0.03437004f, -0.13557935f, -0.08328063f, 0.12254321f, -0.18314327f, 0.08043981f, 0.06175395f, 
    -0.01803301f, -0.00844231f, -0.05561885f, -0.02432897f, -0.07816020f, 0.10660186f, -0.00930875f, -0.13463753f, 
    0.19194351f, -0.21989922f, -0.11241939f, 0.02756035f, 0.00671523f, -0.03631482f, 0.06876030f, -0.01429236f, 
    0.11666049f, 0.04664715f, 0.03056272f, -0.06652440f, -0.14139958f, 0.16970615f, 0.02527376f, -0.04985665f, 
    0.23250650f, -0.05492955f, -0.02471321f, 0.02476103f, 0.15516685f, 0.05531699f, 0.01723790f, 0.06196170f, 
    -0.16557300f, 0.15532224f, -0.14121956f, -0.09363168f, 0.04550740f, -0.04824613f, -0.02304935f, 0.09909381f, 
    -0.04278940f, 0.02668050f, 0.03926181f, -0.07971628f, -0.18317305f, -0.06136664f, -0.05297279f, -0.05108408f, 
    0.07818553f, -0.10211717f, 0.03482467f, 0.11762998f, 0.02243455f, -0.09803876f, 0.07600163f, 0.01531078f, 
    0.29247889f, -0.09639019f, -0.15785222f, 0.00107380f, 0.06920417f, -0.01054439f, 0.00824871f, -0.06908852f, 
    0.01906037f, -0.03342746f, -0.01708255f, 0.01243347f, 0.24882686f, -0.19656451f, 0.10671004f, 0.11498223f, 
    0.08205693f, 0.01152375f, 0.09270360f, -0.03847616f, 0.06650904f, 0.00663924f, -0.09219953f, -0.01104839f, 
    -0.27131861f, -0.08885565f, -0.14526939f, 0.05327898f, -0.02994211f, 0.05487069f, -0.08327577f, 0.06183757f, 
    0.02421656f, 0.00816429f, -0.01153266f, 0.04747466f, 0.01653162f, -0.18140896f, -0.09483758f, 0.06623407f, 
    -0.08466915f, 0.06336387f, -0.12590583f, 0.05162048f, -0.03624932f, -0.04153015f, -0.15243386f, -0.05373046f, 
    -0.35786572f, -0.30624366f, -0.05784690f, -0.18437779f, -0.01368705f, 0.05422142f, -0.02324685f, 0.03224997f, 
    -0.03178150f, 0.02514827f, -0.13512780f, -0.03336727f, -0.10124998f, 0.14818852f, 0.06053379f, 0.00421696f, 
    0.03155643f, -0.07343889f, 0.04378856f, -0.07570473f, -0.01125082f, 0.06066700f, 0.11892623f, -0.17892443f, 
    0.08280987f, 0.27874827f, 0.00886437f, -0.07593304f, 0.08881338f, -0.01658736f, -0.04886815f, 0.08136919f, 
    0.01298269f, 0.01789658f, 0.12784630f, 0.05980677f, -0.29245773f, 0.11915605f, 0.03254281f, -0.10599115f, 
    -0.22002116f, -0.04563671f, -0.05506474f, -0.03950331f, 0.17852885f, 0.00503265f, 0.02147453f, 0.05802452f, 
    0.08660392f, -0.11798228f, -0.05344908f, 0.06706718f, -0.00531035f, -0.03616520f, 0.14159107f, 0.00527906f, 
    0.03876673f, -0.00495024f, -0.06191506f, -0.11352064f, 0.01732697f, 0.02961253f, -0.10367259f, -0.09132713f, 
    -0.06102858f, 0.11832127f, -0.05701834f, -0.07572680f, -0.02985369f, -0.06247666f, 0.01367634f, -0.11964732f, 
    0.46297148f, 0.05707698f, -0.26726002f, 0.07917924f, 0.04463324f, -0.12114514f, 0.03734885f, -0.03228955f, 
    -0.02587521f, 0.03092507f, 0.03183077f, -0.00523644f, -0.34744707f, 0.17523926f, 0.03113222f, 0.11685119f, 
    -0.01367439f, -0.05705890f, 0.11830644f, -0.01734290f, 0.00044950f, 0.02820352f, 0.09331021f, -0.03565175f, 
    -0.02045535f, 0.01313609f, -0.13488661f, -0.27013496f, 0.02959433f, 0.00426790f, 0.07077100f, 0.04776991f, 
    -0.00933669f, 0.06312294f, -0.03500644f, -0.01353929f, 0.03783478f, -0.17633316f, 0.07422009f, -0.01148849f, 
    -0.05747904f, 0.00024751f, -0.08209267f, 0.10876623f, -0.12069096f, 0.08896111f, 0.00986363f, -0.05094105f, 
    0.24897616f, 0.00048492f, -0.10947856f, -0.07905260f, -0.09577399f, -0.00693062f, -0.00051997f, -0.02708347f, 
    0.08052181f, -0.00819283f, 0.02073066f, 0.05051236f, -0.39691442f, -0.04925670f, -0.13635270f, -0.12098065f, 
    0.07808563f, -0.11441327f, 0.00995514f, -0.06215814f, 0.00687948f, 0.08045419f, -0.00325711f, 0.02738889f, 
    0.06079892f, -0.05713180f, 0.01414843f, 0.03924435f, 0.02246534f, -0.12684198f, -0.02740930f, -0.11844214f, 
    -0.14162536f, -0.01745965f, 0.12416582f, -0.01470711f, 0.07605439f, -0.01046834f, -0.06730452f, -0.25331867f, 
    0.01423906f, 0.02212970f, -0.03994330f, -0.03150777f, 0.01558523f, 0.02154208f, 0.00868992f, 0.01465202f, 
    0.18154772f, -0.15848155f, -0.04006237f, 0.01924257f, 0.01362703f, -0.03388377f, -0.04326700f, 0.05836601f, 
    -0.03243819f, -0.02027931f, -0.05456829f, -0.14755009f, 0.16835003f, 0.06062140f, -0.16072673f, 0.17740579f, 
    0.08952457f, 0.07904252f, 0.04793306f, -0.10987736f, -0.04843057f, 0.02840786f, 0.05826277f, -0.06514109f, 
    -0.21547382f, 0.10953765f, 0.05738528f, -0.20531395f, 0.02529279f, -0.00576938f, 0.05602854f, -0.05655789f, 
    -0.11626844f, -0.04271710f, 0.02016176f, -0.01521314f, 0.29478696f, 0.07018715f, -0.26121947f, -0.17835838f, 
    -0.07332836f, 0.00885341f, -0.05002778f, 0.00699920f, 0.02410028f, -0.09387714f, -0.05789990f, -0.00541170f, 
    -0.25315750f, 0.05397192f, 0.01355414f, 0.15556481f, -0.02778077f, 0.01315354f, 0.06812511f, 0.07234635f, 
    -0.11490378f, -0.14050147f, -0.10688948f, -0.10928277f, -0.06619928f, -0.26647973f, -0.07654668f, -0.10378241f, 
    -0.05806228f, 0.00932917f, 0.06028766f, -0.02612845f, -0.10256068f, -0.04940869f, 0.04378520f, -0.01194329f, 
    -0.23408990f, -0.08647279f, 0.03342431f, 0.46352133f, -0.04345151f, 0.03396693f, -0.02937869f, 0.03940554f, 
    0.07689401f, -0.20403369f, 0.04345870f, 0.11243244f, -0.17578746f, 0.04669507f, 0.07528359f, -0.06133702f, 
    0.09288995f, -0.02523578f, -0.07908718f, 0.01330199f, -0.04514793f, -0.13276115f, -0.05293302f, 0.04881207f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04245694f, -0.00779635f, -0.04525997f, 0.00386409f, 0.04729964f, -0.00200334f, 0.02753524f, -0.03001435f, 
    -0.02934689f, 0.00709377f, 0.09225363f, 0.03520600f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
