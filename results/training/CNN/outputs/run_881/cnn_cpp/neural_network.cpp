#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.53189391f, 0.23059002f, -0.42725801f, 0.24343894f, 0.71854377f, -0.00403436f, 0.09217819f, -0.08992731f, 
    -0.14320642f, -0.26827124f, 0.13000378f, 0.18822084f, -0.66828936f, 0.27188551f, -0.32952532f, -0.27325472f, 
    0.36034790f, 0.09943794f, 0.60926741f, 0.40427375f, 0.37701839f, 0.24268070f, -0.42911789f, 0.08632981f, 
    -0.15722774f, -0.13809182f, -0.29718959f, 0.61880565f, 0.51274961f, -0.29084685f, -0.42665327f, 0.10836074f, 
    -0.21267878f, 0.07689971f, 0.08562128f, -0.01466847f, 0.28859988f, -0.24882323f, 0.13103664f, -0.53239316f, 
    -0.60045218f, -0.55768418f, -0.04845036f, -0.06925299f, 0.22846077f, 0.42922682f, 0.45086601f, 0.51606578f, 
    -0.22139037f, 0.21558289f, -0.29989129f, 0.21529853f, 0.29638451f, 0.10474973f, -0.56530058f, -0.24105610f, 
    -0.08374890f, -0.36912641f, -0.24464442f, -0.26138097f, 0.29803258f, 0.14507829f, -0.23814262f, -0.37144637f, 
    -0.21225864f, 0.48531187f, 0.04744636f, -0.03002617f, 0.02641978f, 0.29916295f, 0.29825473f, 0.42264977f, 
    -0.61198896f, -0.09797601f, -0.65086460f, -0.24748228f, -0.01557888f, -0.31813428f, -0.13025653f, -0.08196073f, 
    -0.31239778f, 0.56434321f, 0.11486550f, 0.45258439f, -0.32426599f, -0.21329436f, 0.00042466f, -0.05012478f, 
    0.16048722f, -0.12823628f, 0.15642004f, 0.13569641f, -0.07464481f, -0.17637260f, 0.42103389f, 0.21295136f, 
    0.48321971f, -0.16484058f, -0.07988328f, -0.14786258f, -0.29536948f, 0.10659623f, -0.23475908f, 0.61395818f, 
    -0.42178711f, 0.20404585f, 0.13474463f, -0.06322812f, -0.20352867f, -0.02798085f, -0.01917602f, 0.69750416f, 
    -0.03205974f, -0.39810526f, -0.35468173f, 0.03136019f, -0.13513270f, -0.21684338f, -0.39822745f, -0.03482335f, 
    -0.29452708f, -0.22994901f, -0.33792633f, -0.20943631f, -0.17242399f, -0.12764575f, 0.44206041f, 0.30354142f, 
    0.34697595f, 0.33434775f, 0.49174944f, 0.33933920f, -0.13322297f, -0.11834408f, 0.01457724f, -0.56927508f, 
    -0.65429199f, -0.49265075f, 0.12183273f, 0.20152970f, 0.41301808f, 0.01979045f, -0.12680109f, 0.25835669f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16601492f, 0.05667157f, 0.22277558f, -0.37052357f, 0.07087597f, -0.17038974f, 0.03529713f, -0.05686545f, 
    -0.33701560f, -0.21322814f, -0.12102541f, -0.27524546f, -0.36952204f, 0.05945181f, -0.14945047f, 0.02705363f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.15676290f, -0.16073878f, -0.06292952f, -0.11482424f, -0.04994529f, 0.05654870f, -0.06921550f, 0.02172888f, 
    0.03996181f, 0.16162865f, -0.26466072f, -0.10025489f, -0.02654848f, 0.07659537f, 0.06574515f, -0.05545706f, 
    -0.09479430f, -0.00760821f, -0.16815546f, 0.14960925f, -0.07946213f, 0.09064110f, 0.12971705f, 0.01429809f, 
    0.05318775f, -0.08570002f, 0.06074810f, -0.24125694f, 0.26061994f, -0.06155989f, -0.05779666f, -0.16011469f, 
    -0.07227837f, 0.20521741f, 0.06529159f, 0.14667524f, 0.08799748f, 0.14807822f, 0.19164531f, -0.04525289f, 
    -0.10640948f, -0.14822629f, 0.03336630f, -0.07654267f, 0.08334675f, -0.01826621f, 0.16146366f, 0.00906165f, 
    0.09984551f, -0.12438534f, 0.12946525f, -0.13661580f, 0.02522752f, 0.18744150f, 0.18940611f, 0.05766349f, 
    0.03022046f, 0.07823179f, 0.06170525f, 0.00928600f, -0.13633391f, -0.11852718f, 0.11252164f, 0.27530527f, 
    0.06999667f, -0.14577614f, -0.19132683f, -0.10916771f, 0.03449583f, -0.06135867f, -0.01881834f, 0.07198019f, 
    -0.38991547f, 0.10085942f, 0.03420610f, 0.22254549f, -0.05214689f, -0.13712722f, -0.08756040f, -0.19951744f, 
    0.04898519f, -0.05069738f, 0.38925987f, -0.11983404f, -0.00955776f, -0.02389940f, 0.15996948f, -0.00992982f, 
    -0.03209752f, 0.00926752f, 0.12386432f, -0.20044835f, 0.19230029f, 0.05428132f, 0.07387447f, -0.06614946f, 
    -0.12354838f, 0.02155718f, -0.16344315f, 0.10133544f, -0.05263923f, -0.03975381f, -0.12144660f, -0.03230040f, 
    -0.07390925f, 0.14082810f, -0.01434304f, -0.09097185f, 0.09552716f, -0.05341627f, -0.32260162f, -0.12868975f, 
    -0.03905937f, 0.19943629f, -0.01417389f, 0.06084729f, -0.03615787f, -0.00790251f, -0.02957480f, 0.13759501f, 
    0.01901295f, -0.09511387f, -0.00395938f, -0.17904377f, -0.08598995f, -0.02112746f, -0.30531898f, -0.24255937f, 
    0.18567857f, -0.01501487f, 0.12263421f, 0.14758414f, -0.01282767f, -0.20648883f, 0.03478901f, 0.15809223f, 
    0.17895110f, 0.15070958f, -0.03934666f, -0.06925786f, 0.10403667f, 0.17568170f, -0.04374528f, -0.05094398f, 
    0.01470443f, -0.05723407f, 0.14042501f, 0.22014707f, -0.03147683f, 0.14730419f, -0.01706435f, 0.10018064f, 
    -0.02337768f, -0.09598073f, 0.10851364f, 0.14135166f, -0.04889289f, -0.03642863f, 0.03190277f, 0.04760600f, 
    0.04643361f, 0.02101777f, 0.13617155f, 0.09408215f, -0.12853546f, 0.08497931f, -0.11767823f, -0.00006372f, 
    0.09305070f, 0.08759873f, -0.10290078f, -0.01965381f, 0.12904733f, 0.03793371f, -0.09320795f, 0.07116596f, 
    -0.31346449f, 0.05771966f, 0.11048765f, 0.00197335f, 0.06222355f, -0.04115523f, 0.00253895f, -0.02303479f, 
    0.03956481f, -0.04610347f, 0.29702219f, 0.04318359f, 0.03963101f, -0.01175769f, 0.10746977f, 0.12596446f, 
    0.06906213f, -0.04339689f, -0.06782176f, -0.09917163f, 0.04335305f, -0.01354823f, -0.03356012f, 0.21097462f, 
    0.06611113f, -0.08534297f, 0.19642977f, -0.35135773f, -0.12700300f, 0.14299658f, 0.01058431f, 0.06415518f, 
    0.03818771f, -0.24354735f, -0.05628525f, 0.06124974f, 0.15637584f, 0.19375741f, -0.18102704f, -0.25684649f, 
    0.07389129f, -0.01750302f, 0.01791834f, -0.46994346f, -0.00629185f, -0.14481151f, 0.03231053f, -0.19058181f, 
    0.23861921f, 0.02997152f, -0.04780408f, -0.36011985f, 0.01472068f, -0.00760122f, -0.11355926f, -0.01133782f, 
    -0.04348487f, 0.18160729f, -0.06295274f, 0.08920176f, 0.25680634f, 0.07826912f, 0.14700982f, 0.10797776f, 
    0.03061114f, -0.04663973f, -0.09876832f, 0.06359849f, 0.07328343f, 0.06742152f, 0.14313309f, -0.08066183f, 
    -0.09005700f, -0.14457256f, 0.06853255f, 0.04665273f, -0.12558156f, -0.27878246f, 0.03751004f, 0.09178562f, 
    -0.14994858f, 0.03980707f, -0.25819609f, 0.17339444f, 0.03461102f, -0.05892770f, 0.14111556f, 0.08540457f, 
    0.05963427f, 0.10612018f, -0.13474020f, 0.06715117f, -0.14083177f, 0.15356719f, -0.29194087f, 0.01513744f, 
    -0.38465720f, 0.23163809f, 0.08196981f, 0.24846978f, 0.16662399f, 0.05041508f, -0.24651630f, -0.13937280f, 
    -0.06317346f, 0.04816554f, 0.21928008f, 0.06655148f, -0.09088120f, 0.03593924f, -0.09279992f, 0.04771071f, 
    -0.05220608f, 0.05289727f, -0.04732364f, 0.19554426f, 0.05791884f, -0.02163507f, 0.04208373f, 0.03115037f, 
    0.13426165f, -0.22162546f, 0.18548039f, -0.03546559f, 0.15501754f, 0.10722899f, -0.10000732f, 0.02375479f, 
    0.00447265f, -0.12630203f, -0.07558476f, 0.06120930f, -0.17997460f, 0.17274666f, 0.17630349f, -0.04014268f, 
    -0.01806422f, -0.00303944f, 0.02736875f, -0.44908121f, -0.37013525f, -0.00126976f, -0.05775836f, 0.08181144f, 
    -0.17892709f, 0.03878273f, -0.16665480f, 0.03148107f, -0.01546320f, -0.01093807f, 0.16398539f, 0.09861176f, 
    -0.00743041f, -0.12299690f, 0.12965126f, 0.00248999f, 0.06971673f, -0.32110724f, -0.30047584f, -0.04992075f, 
    0.07371646f, -0.18468037f, 0.03882852f, 0.05376991f, 0.02596538f, -0.10521727f, 0.05535329f, 0.04351594f, 
    -0.07716250f, -0.08767428f, -0.06871581f, 0.05357304f, 0.00854330f, -0.02464396f, 0.03565928f, 0.09229673f, 
    -0.06421825f, -0.08854291f, -0.00927137f, -0.07232768f, -0.16312236f, 0.17266354f, -0.22632916f, 0.01405712f, 
    0.15055396f, -0.18164252f, 0.17559884f, -0.04214495f, -0.19794326f, 0.11715779f, -0.11088927f, 0.02260335f, 
    -0.18951005f, -0.27843922f, -0.20794857f, -0.00139923f, 0.14624868f, 0.13571182f, 0.11213973f, 0.07516845f, 
    0.11305957f, -0.01847317f, 0.05048669f, 0.07641595f, 0.00914910f, 0.05680737f, -0.00126785f, -0.05685114f, 
    -0.12933771f, 0.12738158f, 0.07013248f, 0.12399015f, 0.08628730f, 0.05086480f, -0.07963236f, -0.17391540f, 
    -0.18299283f, -0.00848287f, 0.00496000f, 0.05563832f, 0.04148148f, 0.17385879f, -0.27635759f, -0.08675705f, 
    -0.01276330f, 0.15046848f, 0.09080347f, 0.18871205f, 0.01992034f, 0.11804535f, 0.05057020f, -0.10407422f, 
    0.03124279f, -0.00327943f, -0.02648941f, 0.05810430f, -0.00291579f, -0.01208134f, -0.39169437f, -0.04267615f, 
    -0.13422683f, 0.05472028f, 0.12312585f, -0.23643284f, 0.04739561f, -0.11100983f, 0.06557740f, 0.33746868f, 
    0.16349705f, -0.05928388f, 0.11382829f, 0.15688106f, 0.08602425f, -0.02277026f, 0.05329839f, -0.11107419f, 
    -0.07491929f, 0.19067898f, -0.01189235f, 0.07971133f, 0.02309243f, -0.08410832f, -0.08137231f, 0.02811651f, 
    -0.01793000f, -0.01790073f, -0.46732828f, -0.03304466f, 0.04258471f, -0.02091084f, -0.00502944f, -0.02871360f, 
    -0.08382355f, -0.09580905f, 0.20712872f, 0.12279647f, -0.09253167f, -0.09944128f, -0.06989706f, 0.01938690f, 
    -0.00734119f, -0.03682510f, -0.03695575f, -0.22597367f, 0.04771250f, -0.04822370f, -0.01742719f, -0.11739249f, 
    -0.02690989f, -0.06682540f, 0.04923372f, -0.04198491f, 0.09063169f, -0.09458687f, -0.37241879f, -0.29367819f, 
    -0.08817077f, 0.04276641f, -0.11231110f, -0.08574984f, -0.00467200f, -0.12680665f, -0.12703145f, 0.04115957f, 
    -0.03117100f, 0.02895728f, -0.00890663f, 0.18676509f, 0.03950230f, 0.08379442f, 0.03129257f, 0.03050337f, 
    0.22565107f, 0.11262731f, -0.11016370f, -0.14962760f, 0.09240294f, 0.01189572f, -0.11296681f, 0.21598703f, 
    0.00231332f, -0.09310161f, -0.03404636f, -0.07832077f, 0.10380738f, 0.01721365f, -0.03182585f, -0.08526395f, 
    0.04138026f, 0.12156960f, 0.33948582f, 0.25866827f, -0.07332242f, 0.18534945f, -0.02863491f, -0.13798681f, 
    -0.03841469f, 0.02595205f, -0.00516757f, -0.04489938f, -0.12074999f, 0.01197959f, 0.00995250f, -0.26164141f, 
    0.03620039f, 0.05208095f, -0.05020532f, -0.15031189f, -0.00725218f, -0.17260467f, -0.05686147f, 0.09703520f, 
    -0.02553486f, -0.15568896f, 0.06882005f, 0.14252645f, 0.08819300f, 0.19891918f, 0.14962642f, 0.04796006f, 
    -0.03946146f, -0.06262887f, 0.01222091f, -0.00041103f, 0.18835066f, 0.35766831f, -0.10632899f, 0.06468700f, 
    0.23443928f, 0.00645699f, 0.00340032f, 0.02402909f, 0.00063422f, 0.05576433f, -0.14101610f, 0.01398055f, 
    -0.09835798f, 0.06874660f, 0.03923399f, -0.11738241f, 0.06441236f, 0.03257824f, 0.00146087f, -0.30951169f, 
    -0.06761220f, -0.09108810f, 0.08066355f, 0.05505957f, 0.06181567f, 0.03436896f, 0.04703188f, 0.25109774f, 
    0.11485175f, 0.37387377f, 0.07835910f, 0.09284246f, -0.01261852f, 0.11080789f, 0.13481554f, 0.00596421f, 
    0.15698983f, -0.20117250f, -0.14537768f, -0.01507141f, 0.03927306f, -0.00336926f, -0.00374250f, -0.07082608f, 
    -0.08284012f, -0.16730022f, 0.01811150f, -0.14839405f, 0.04777454f, -0.05892810f, -0.04538199f, 0.04143564f, 
    -0.01190553f, 0.01948874f, -0.04841532f, 0.03030820f, 0.06629623f, 0.09150715f, 0.07587878f, 0.10999580f, 
    0.09028947f, 0.07898461f, 0.01144168f, 0.52110320f, 0.07439568f, -0.00047093f, -0.06879478f, -0.05765329f, 
    0.02966080f, 0.01737235f, -0.05520625f, 0.08412777f, -0.00422737f, 0.05401227f, 0.05890331f, 0.01296972f, 
    -0.04375412f, 0.12277218f, 0.08544666f, 0.06794607f, 0.03726266f, 0.24184182f, 0.31791610f, 0.06685358f, 
    0.10302727f, -0.16989312f, -0.09217525f, 0.02899528f, -0.00505293f, -0.11109420f, -0.14555867f, -0.07824314f, 
    -0.11634355f, -0.03424626f, -0.02197644f, 0.00599567f, -0.09646890f, -0.18860672f, -0.12255560f, -0.42609081f, 
    0.00762202f, 0.11642923f, -0.09914905f, 0.10883704f, 0.00344407f, -0.07794471f, -0.00861906f, -0.01385714f, 
    0.06988016f, -0.18499112f, -0.15652087f, 0.08665826f, -0.11818311f, 0.14708760f, 0.05638539f, 0.08095729f, 
    -0.20680757f, 0.11508521f, -0.13104704f, -0.06647740f, -0.04740304f, 0.02025274f, 0.03709115f, -0.04089890f, 
    -0.02151843f, -0.01981807f, 0.15695114f, 0.07520740f, -0.31817859f, 0.06367441f, 0.10333467f, 0.14126959f, 
    -0.12829229f, 0.00777698f, 0.01724760f, -0.00156629f, -0.41170102f, -0.09221616f, -0.04529273f, 0.05202139f, 
    0.12721357f, 0.07226222f, -0.03174017f, -0.15189993f, -0.24962394f, -0.34569287f, 0.08472172f, 0.02941436f, 
    0.12107186f, -0.22358921f, 0.02787956f, 0.06727413f, 0.02356154f, -0.09044866f, -0.08388930f, 0.04669169f, 
    -0.04532440f, -0.01762875f, 0.11640230f, -0.04662127f, 0.02954868f, -0.10556717f, 0.03395047f, 0.15893823f, 
    0.08396553f, -0.23177339f, -0.02653326f, -0.02586843f, 0.03042465f, 0.04894805f, -0.10755923f, 0.17919348f, 
    0.57122511f, -0.50122464f, 0.04562522f, 0.06036184f, -0.11742832f, 0.18250689f, -0.06410258f, -0.02065940f, 
    0.21304607f, 0.01226538f, 0.14168753f, -0.08625283f, -0.12826806f, 0.09074482f, -0.02683743f, -0.02475914f, 
    0.14462842f, -0.01709919f, 0.02867820f, -0.08450520f, -0.21344119f, -0.02439970f, 0.06239720f, 0.02619882f, 
    -0.04910450f, -0.01345256f, -0.15299034f, 0.02699320f, -0.00996692f, 0.11190299f, 0.11802556f, 0.03199834f, 
    -0.00941283f, 0.10879473f, 0.03056245f, 0.09344999f, 0.02462948f, -0.18892924f, 0.27446392f, -0.00714156f, 
    -0.10251971f, -0.01047696f, -0.09491068f, -0.00047445f, 0.42079380f, -0.03091803f, -0.14161572f, 0.01945635f, 
    -0.03342259f, -0.00301598f, 0.06413170f, 0.12383500f, -0.04281724f, 0.27008304f, -0.03550644f, -0.08806814f, 
    0.25368640f, 0.12168355f, 0.03346699f, -0.15933609f, 0.00283960f, 0.02294508f, -0.09831201f, 0.01572134f, 
    -0.03147956f, -0.05652959f, -0.11886112f, -0.04213480f, 0.11666548f, -0.02595208f, -0.11424951f, -0.03745874f, 
    0.26777160f, 0.05147795f, -0.20463653f, -0.18921904f, 0.19459876f, 0.02213679f, 0.00160310f, -0.06488352f, 
    -0.23361877f, -0.39984089f, 0.24375425f, 0.08150409f, 0.05577373f, -0.06377335f, -0.16105430f, 0.03891280f, 
    -0.14134909f, -0.08989784f, 0.16999532f, -0.26514602f, 0.15644427f, 0.16560511f, 0.00561743f, 0.16815285f, 
    0.02761205f, 0.03240423f, -0.07117330f, -0.05921391f, -0.07502647f, 0.10398185f, -0.07936832f, -0.16427147f, 
    -0.00170137f, -0.18281116f, -0.13977054f, -0.02423252f, -0.16402814f, -0.28103891f, -0.14797994f, -0.02733281f, 
    0.09501710f, -0.18484429f, 0.08259878f, -0.02981855f, -0.07602236f, -0.03614615f, -0.05656716f, 0.00001744f, 
    -0.33950245f, 0.02848029f, 0.03916712f, -0.11418349f, 0.05604610f, -0.07928447f, -0.07340570f, 0.11090310f, 
    0.00248166f, 0.19474013f, -0.00765761f, -0.03612647f, 0.06087088f, 0.00055893f, -0.14453335f, -0.26093882f, 
    -0.07087673f, 0.13462949f, 0.00823849f, 0.26175821f, 0.13935517f, 0.03150626f, -0.08501210f, 0.02063628f, 
    -0.04912079f, 0.36000201f, -0.12962542f, -0.09165633f, -0.04931841f, 0.04130844f, 0.05348149f, -0.01479499f, 
    -0.36912593f, -0.26221508f, 0.07114395f, 0.00121304f, 0.15445964f, 0.01119179f, -0.28846619f, 0.00271067f, 
    0.10750951f, -0.10404211f, 0.15650436f, -0.14754921f, -0.07593901f, 0.03640638f, -0.00084298f, 0.11949815f, 
    -0.11041763f, -0.17430738f, 0.45377937f, 0.16770685f, 0.02954522f, 0.05095158f, 0.00746225f, -0.00781352f, 
    0.03642909f, 0.05664825f, 0.02436655f, 0.20281863f, 0.09130499f, -0.24504215f, 0.11964248f, 0.06712644f, 
    0.01896597f, 0.04710647f, 0.00611826f, -0.11130366f, 0.00482558f, 0.02063788f, -0.28519234f, 0.13061963f, 
    -0.04848035f, -0.05604166f, -0.04473547f, 0.20777746f, -0.00187128f, 0.28539330f, -0.02536488f, -0.09838954f, 
    -0.13916281f, -0.19615340f, 0.09459248f, 0.05499013f, -0.09129924f, -0.11067459f, 0.01239388f, 0.24289103f, 
    -0.12345929f, 0.09071725f, -0.18162097f, 0.02037681f, -0.01465285f, -0.02764844f, -0.02851106f, 0.01930468f, 
    0.02675727f, -0.12339129f, 0.04621707f, 0.05004288f, 0.10281488f, -0.03727882f, -0.02924927f, -0.11810274f, 
    0.12166224f, 0.13701540f, 0.06552586f, -0.03915301f, -0.13439673f, -0.01764249f, -0.07872429f, -0.00219353f, 
    -0.01742199f, 0.17164665f, 0.11589909f, -0.06025980f, -0.10400028f, -0.08353432f, -0.14415663f, 0.11674254f, 
    -0.14787328f, 0.06376456f, 0.22668330f, -0.00630995f, 0.12199431f, -0.04500084f, 0.05631316f, 0.07422030f, 
    0.03535247f, 0.14358245f, -0.03184283f, -0.05239085f, 0.11286273f, -0.19393617f, 0.21350741f, 0.04900630f, 
    0.01399077f, 0.01365550f, -0.04482305f, 0.13678437f, -0.19636317f, -0.35076058f, 0.04573860f, 0.05390766f, 
    0.07857029f, 0.01903454f, -0.01768021f, -0.02127247f, -0.03989294f, -0.03340894f, 0.03390078f, -0.17255142f, 
    -0.10517617f, 0.04339333f, 0.06287157f, 0.01534553f, -0.01940642f, 0.10771322f, -0.04227804f, -0.06770167f, 
    -0.09651969f, -0.06414441f, -0.08588932f, -0.02470959f, -0.07221864f, -0.06406662f, -0.05826287f, -0.00699876f, 
    0.20983092f, 0.24282549f, 0.00257702f, 0.08318190f, 0.03317761f, -0.06333878f, 0.09324799f, -0.02041196f, 
    0.17747167f, 0.06557303f, 0.04560503f, -0.08315754f, 0.00163126f, -0.02191272f, 0.17686285f, 0.05087615f, 
    -0.17625475f, 0.03823657f, -0.05504660f, -0.20692825f, -0.15066646f, -0.09642769f, 0.03860024f, -0.01835845f, 
    0.10789492f, 0.11430582f, -0.15512247f, -0.22676173f, 0.08718859f, 0.21897735f, 0.02243046f, -0.05235427f, 
    -0.12485396f, -0.13958688f, 0.06511517f, -0.19668537f, -0.33340061f, -0.03488832f, -0.00927665f, 0.03469371f, 
    -0.05374743f, -0.14583334f, -0.07994001f, -0.03792605f, 0.16818111f, 0.01135565f, -0.01325537f, -0.11336659f, 
    0.10494751f, 0.07584113f, -0.06779261f, -0.08198361f, 0.00504076f, -0.04867685f, -0.31476241f, -0.04680099f, 
    -0.02603935f, 0.09722255f, 0.22288385f, 0.06898535f, 0.09957016f, 0.16699062f, 0.03246607f, 0.29341751f, 
    -0.04014703f, 0.08876323f, -0.06293231f, 0.15431306f, -0.01132203f, -0.02296284f, 0.07763245f, -0.26815811f, 
    0.16877946f, -0.02837789f, -0.20312704f, -0.08047064f, 0.02719224f, 0.15693207f, 0.09293641f, 0.09871206f, 
    -0.14961448f, -0.08042650f, -0.03336776f, 0.05666116f, 0.23577619f, -0.06264167f, -0.04424249f, -0.09207597f, 
    -0.00766761f, -0.12391890f, -0.30213913f, 0.01548668f, 0.06706625f, -0.06472924f, 0.05050635f, -0.01791844f, 
    -0.10087420f, -0.05901513f, 0.12110113f, -0.11666112f, -0.09847824f, 0.05381202f, 0.13740803f, -0.16598007f, 
    0.21263357f, 0.07959086f, 0.02914794f, 0.01769090f, -0.11079400f, -0.17721991f, -0.33212683f, 0.02735490f, 
    -0.08458706f, 0.17124532f, 0.11303954f, -0.08910465f, -0.02392309f, 0.06490942f, -0.13943261f, -0.10380910f, 
    0.08976444f, 0.14587891f, -0.05673729f, -0.08461034f, -0.12554395f, 0.10289104f, 0.18513960f, -0.26676366f, 
    0.00021863f, -0.08725775f, 0.06631248f, -0.12669118f, 0.05472140f, -0.21612523f, -0.06221736f, -0.05273342f, 
    0.10220525f, 0.07021997f, 0.09176689f, 0.01934706f, 0.10765597f, 0.05100118f, 0.04523860f, 0.33779889f, 
    0.40275776f, 0.10399444f, -0.05606601f, -0.10772875f, -0.07015871f, 0.00447121f, 0.11375092f, 0.06196072f, 
    -0.34605697f, 0.03594213f, -0.27288607f, 0.04574027f, 0.06624812f, 0.02588392f, 0.21360464f, -0.10097589f, 
    -0.04516069f, -0.18396801f, 0.19230939f, -0.00574125f, -0.00547276f, 0.11322585f, 0.09196991f, -0.13057144f, 
    0.00512257f, 0.00174166f, -0.08321543f, 0.07902193f, 0.19449991f, 0.03184455f, 0.14790174f, 0.16790509f, 
    0.09750855f, -0.01129033f, 0.22507612f, -0.18924014f, -0.08683144f, -0.27548483f, -0.05220050f, 0.09555361f, 
    0.13124856f, -0.13827614f, -0.10077084f, -0.10393806f, -0.14696783f, -0.19984700f, 0.17632896f, -0.07641558f, 
    0.03262472f, 0.16102144f, -0.01527893f, 0.00100752f, 0.13298400f, -0.05234857f, 0.03605093f, 0.31393209f, 
    -0.11158145f, 0.10140593f, -0.05693924f, 0.07036018f, -0.09637097f, 0.17304340f, 0.13099311f, 0.03476093f, 
    -0.11367051f, 0.01854503f, -0.03987289f, -0.05922162f, -0.12431083f, 0.12109713f, -0.08374814f, -0.21567486f, 
    -0.08432347f, -0.07778716f, 0.04391434f, -0.29198420f, 0.05356826f, -0.09461565f, -0.03213137f, 0.06634527f, 
    -0.21869321f, -0.24966975f, -0.07211506f, 0.04159138f, 0.01659534f, -0.04230363f, -0.08818144f, -0.09829742f, 
    0.02722138f, -0.33980727f, -0.09536286f, 0.20023942f, 0.13299628f, 0.17601106f, 0.01362952f, -0.14527340f, 
    0.00464909f, -0.01741821f, 0.22349116f, -0.06447624f, 0.11655845f, 0.03632933f, 0.05486191f, -0.10562126f, 
    -0.03468927f, 0.06618340f, -0.08374648f, -0.38280982f, 0.01903875f, -0.48624948f, 0.17525642f, 0.09124107f, 
    -0.00176070f, 0.10311660f, -0.06792033f, -0.14999834f, 0.09305001f, -0.31362548f, -0.23525909f, -0.05832615f, 
    0.06974268f, -0.10444092f, 0.08567661f, -0.04893158f, -0.15180740f, -0.01382564f, -0.18802272f, -0.12858972f, 
    -0.01034224f, 0.00270265f, -0.09715904f, 0.18301944f, 0.01397301f, -0.03419266f, 0.10343612f, 0.15127589f, 
    0.04969981f, 0.02402155f, 0.00231098f, -0.30694005f, 0.11010231f, 0.07811979f, 0.13873217f, -0.09378999f, 
    0.14115663f, -0.41048867f, 0.00089354f, 0.09488122f, -0.07885458f, 0.19579624f, 0.02124588f, 0.10095598f, 
    0.06118283f, 0.06304759f, -0.01895343f, -0.07362844f, -0.06518009f, -0.04005451f, 0.06047710f, -0.06199322f, 
    -0.00245515f, 0.04416986f, 0.05543306f, -0.01930585f, -0.02711102f, 0.02295485f, -0.03526930f, 0.03650501f, 
    0.05995226f, -0.04661402f, 0.04064028f, 0.01433338f, -0.07107835f, -0.01045169f, 0.00735966f, -0.08059357f, 
    -0.04856547f, -0.01969656f, -0.09345771f, 0.00600670f, 0.04810397f, -0.01891155f, -0.04570374f, 0.03657043f, 
    -0.01610352f, 0.07289659f, -0.04162247f, -0.04503227f, -0.08087038f, -0.09234773f, 0.00323811f, -0.05762471f, 
    0.02050779f, -0.07764035f, 0.00782441f, 0.00259644f, 0.00763975f, -0.09705411f, 0.02014004f, -0.02401539f, 
    -0.02935016f, -0.07473376f, 0.02587795f, -0.07852361f, 0.01952018f, -0.09495411f, 0.05910008f, -0.00214514f, 
    -0.07040711f, -0.04656891f, -0.04411695f, 0.04878343f, -0.09093013f, 0.02619037f, 0.01764565f, 0.04852676f, 
    -0.08501434f, -0.03030398f, 0.00868569f, -0.08528070f, 0.06005371f, 0.04901058f, 0.04223266f, -0.07263629f, 
    -0.00320969f, -0.00010494f, -0.06683723f, 0.06292730f, -0.06817813f, 0.00183673f, -0.08567846f, 0.06998944f, 
    -0.00278897f, -0.05167141f, -0.01410905f, -0.05748393f, 0.06062857f, 0.03956006f, 0.05355861f, -0.06558289f, 
    -0.00990572f, -0.08754670f, -0.03172820f, 0.01795621f, -0.04637637f, -0.09145819f, 0.00377041f, -0.00111424f, 
    0.00014062f, 0.03964087f, 0.03344576f, -0.05014055f, 0.05397682f, 0.00347474f, 0.06346407f, 0.04443879f, 
    0.02345510f, 0.05453958f, -0.04818229f, 0.03297055f, 0.02450214f, 0.03557750f, -0.06336118f, -0.08805147f, 
    -0.08515820f, -0.07335839f, 0.03259308f, -0.03623271f, -0.03910840f, 0.01755452f, 0.05631261f, 0.06624134f, 
    -0.03551285f, 0.01672272f, 0.02820189f, 0.03227698f, -0.05946937f, 0.02622267f, 0.01080328f, 0.04941301f, 
    0.07267562f, -0.09593997f, 0.02478975f, 0.03880240f, 0.00085335f, -0.01983177f, -0.02527114f, -0.06468692f, 
    0.05156356f, -0.05572789f, 0.00379257f, 0.01267908f, 0.06320538f, -0.08408325f, -0.04604391f, -0.07766911f, 
    0.42922354f, 0.22057712f, -0.05305443f, 0.03571883f, -0.00595829f, 0.04394018f, -0.12041645f, 0.15001148f, 
    0.02900395f, -0.15676917f, 0.12005770f, 0.05888940f, 0.00855468f, -0.08660489f, 0.12207431f, 0.02382063f, 
    -0.18968013f, 0.13879855f, 0.14067240f, -0.18641432f, 0.14080100f, -0.07538331f, 0.00119985f, 0.14316489f, 
    -0.13649923f, 0.00815309f, -0.04191729f, -0.12606817f, -0.10957183f, -0.16925198f, -0.16665450f, -0.02999760f, 
    -0.10417035f, -0.10921039f, 0.08798806f, -0.08325184f, 0.14774793f, 0.00448196f, 0.10303195f, -0.15114701f, 
    -0.01497337f, -0.03135629f, 0.02621285f, -0.06686625f, 0.04346000f, -0.25643104f, 0.00626119f, 0.16327135f, 
    -0.17429218f, 0.02037236f, 0.02024739f, -0.05619168f, 0.06371969f, 0.03029280f, -0.30641249f, -0.26561114f, 
    0.09390340f, 0.11594573f, 0.01447525f, -0.11863447f, 0.02822222f, 0.15219475f, -0.03683433f, -0.11356717f, 
    -0.19627412f, 0.11485644f, 0.02138183f, -0.07710850f, -0.12379600f, 0.04306114f, -0.03172746f, 0.07343931f, 
    0.09738245f, -0.06320268f, 0.13834362f, -0.01617374f, -0.00011783f, -0.07290988f, 0.01551142f, -0.05005269f, 
    0.08384820f, 0.16687922f, -0.10703073f, 0.18224540f, -0.32200733f, -0.09765550f, -0.12897006f, -0.00473641f, 
    -0.05297356f, 0.08109804f, -0.20758452f, -0.03762712f, -0.19017461f, 0.09578136f, -0.08367497f, -0.07279641f, 
    -0.16446219f, -0.17701621f, 0.05631847f, -0.25258517f, 0.03774972f, 0.02074384f, 0.13797219f, -0.00707135f, 
    -0.05743675f, -0.04655093f, -0.03781203f, -0.09448077f, 0.36869884f, 0.18630500f, 0.15987068f, -0.05372840f, 
    -0.05760831f, 0.15990859f, 0.09073760f, -0.04237829f, -0.04015147f, -0.23546413f, 0.01665948f, 0.26678473f, 
    0.06778270f, -0.03238475f, -0.19785778f, 0.09491575f, -0.09388145f, 0.05955349f, -0.13122003f, 0.06183962f, 
    0.00670652f, 0.11375245f, 0.03741740f, 0.13448931f, 0.22169916f, 0.07088485f, 0.10217814f, 0.15644354f, 
    0.03988289f, -0.16828130f, 0.02234454f, 0.11345860f, 0.07766271f, 0.10727188f, -0.05652523f, 0.02634089f, 
    -0.08677655f, -0.09632620f, -0.27976590f, -0.11711294f, -0.13279979f, -0.08765651f, -0.02884714f, 0.07431012f, 
    -0.02179110f, 0.13785622f, 0.09460711f, -0.41294312f, -0.02247612f, 0.00534301f, 0.15027070f, 0.03180524f, 
    0.13786328f, -0.17132705f, -0.14239603f, 0.24608998f, 0.01054489f, 0.07846583f, 0.06898487f, 0.07203398f, 
    0.06648816f, -0.01179201f, 0.03480209f, 0.23215593f, -0.18123986f, -0.02784718f, -0.10870603f, -0.02620201f, 
    0.07965930f, -0.28222707f, -0.06971682f, 0.00852931f, -0.11987876f, 0.03420642f, -0.18868683f, 0.13590972f, 
    0.01307318f, 0.17352006f, -0.15739872f, -0.08932635f, -0.03558283f, 0.23280518f, 0.17126000f, 0.20470351f, 
    -0.01501176f, 0.09019530f, 0.20785280f, 0.11767961f, 0.02602456f, 0.00186931f, 0.03999588f, -0.10153697f, 
    0.00512633f, 0.00377731f, 0.02354829f, -0.02542191f, -0.22691451f, 0.18999709f, -0.02974129f, 0.13543130f, 
    -0.11894397f, -0.14677417f, 0.08532131f, 0.03075134f, 0.19816086f, -0.02666796f, 0.09116438f, 0.10013893f, 
    -0.46491262f, 0.35307238f, -0.04985315f, 0.12533204f, -0.00175981f, 0.02986708f, -0.10872760f, 0.08014257f, 
    -0.18540253f, -0.18705790f, 0.07863840f, 0.06981423f, -0.12855896f, -0.03611130f, 0.14153123f, -0.08737731f, 
    0.00515646f, 0.10118041f, 0.09995530f, -0.08876883f, 0.18000917f, -0.15209594f, -0.00962489f, -0.02755413f, 
    0.19244988f, 0.07056788f, 0.03189364f, 0.31152481f, -0.07499060f, -0.19996552f, -0.01888027f, 0.14279114f, 
    0.08131739f, -0.05818113f, -0.13817371f, -0.01586975f, -0.13254663f, -0.23855074f, -0.00707753f, -0.01486924f, 
    0.27967855f, -0.02650216f, 0.08650427f, 0.08999545f, -0.21337181f, 0.04986642f, 0.00270832f, -0.38756797f, 
    0.07122794f, 0.00339043f, 0.01186463f, -0.18138157f, 0.13593525f, 0.05017761f, -0.10638203f, 0.04009172f, 
    0.29549199f, 0.04529221f, -0.05835739f, -0.17245446f, -0.05996511f, 0.12772153f, 0.07254404f, 0.07372110f, 
    -0.12814623f, -0.12199527f, 0.00439177f, 0.01261964f, -0.11392915f, 0.02436471f, -0.00359086f, -0.05505880f, 
    0.19657487f, 0.16509236f, -0.05732622f, -0.02678299f, 0.01505908f, 0.03701054f, 0.01461537f, 0.19343440f, 
    0.12102535f, 0.18570191f, 0.15504485f, -0.05236220f, 0.06922483f, -0.07062846f, -0.15516461f, 0.08125076f, 
    -0.02663091f, -0.08331732f, -0.24017598f, -0.17847885f, -0.04557750f, 0.14831820f, -0.08044678f, 0.14801061f, 
    -0.08665492f, -0.05968355f, 0.00531492f, 0.08397499f, -0.09147903f, -0.14926688f, 0.01639154f, -0.07304589f, 
    0.11449806f, -0.03644468f, -0.02726263f, -0.06403948f, 0.24763957f, -0.10933103f, 0.32242170f, -0.07773504f, 
    0.19862127f, -0.12933995f, -0.01729611f, -0.06025054f, 0.00266848f, -0.32281640f, 0.12044983f, 0.10162768f, 
    0.04987191f, 0.03101085f, -0.04395442f, 0.13707244f, -0.18481746f, -0.14859022f, 0.21239625f, -0.05913860f, 
    0.02911080f, 0.00410322f, 0.08384680f, -0.18528515f, 0.07574844f, -0.06043085f, 0.10408823f, 0.18003054f, 
    -0.12050470f, 0.14569493f, -0.11927909f, -0.00033153f, -0.15679483f, -0.04904330f, 0.00353495f, -0.12009698f, 
    -0.13684691f, 0.07222315f, -0.14325702f, -0.25689942f, 0.00106119f, 0.00543917f, 0.03794616f, -0.00216491f, 
    0.10682162f, -0.32185045f, 0.25140804f, 0.01525113f, 0.02064300f, 0.19768879f, -0.01943151f, 0.08468580f, 
    -0.06475759f, -0.03896801f, -0.30573478f, 0.02084004f, 0.04710100f, -0.09795655f, -0.14397708f, 0.03568123f, 
    -0.02266302f, -0.15680321f, 0.05211185f, 0.16655745f, 0.07415644f, 0.07821024f, 0.06799962f, -0.01834567f, 
    0.00264214f, 0.09088924f, -0.14258589f, 0.12366277f, 0.16663265f, -0.13416317f, 0.13988870f, -0.01127393f, 
    -0.07075138f, -0.00573943f, -0.05083042f, -0.03251575f, 0.06966243f, 0.08130956f, 0.11170089f, 0.29010382f, 
    -0.16704562f, -0.09918552f, -0.02495364f, -0.06540170f, -0.05014593f, -0.04858276f, -0.48640373f, -0.03534198f, 
    -0.03402054f, -0.00803013f, 0.01226817f, 0.12366855f, -0.02065188f, 0.04006259f, -0.21929464f, 0.09008829f, 
    -0.27116072f, -0.01133821f, -0.08626641f, 0.11647998f, -0.09120456f, 0.13959585f, 0.08093075f, 0.07766704f, 
    -0.32574385f, -0.35461855f, -0.00384019f, 0.10349466f, 0.17257471f, 0.03624654f, 0.00309237f, -0.01828220f, 
    -0.15686454f, -0.25057662f, -0.05105885f, -0.06711427f, 0.03288025f, 0.11397649f, 0.11699152f, -0.03526334f, 
    0.11875676f, 0.04604083f, 0.10867198f, 0.14097412f, 0.23931520f, 0.07255279f, -0.03284272f, 0.14230689f, 
    0.08622998f, 0.06697870f, 0.03698393f, 0.15247525f, 0.17350905f, 0.24977656f, -0.09158655f, -0.06324489f, 
    -0.13553795f, -0.12347818f, 0.05359308f, -0.03286835f, 0.09188291f, 0.10878074f, -0.11348389f, -0.02737585f, 
    0.19514367f, -0.14598221f, 0.05640131f, -0.06752696f, 0.19939879f, 0.13379583f, 0.28087267f, 0.08733571f, 
    0.00926093f, -0.13104688f, -0.04117401f, 0.15495814f, -0.01749584f, 0.03443889f, -0.01708660f, 0.02626705f, 
    0.07766764f, 0.19904709f, 0.02454416f, -0.14845513f, 0.10028458f, -0.01503166f, -0.04125781f, -0.14557286f, 
    -0.23200837f, -0.02084250f, -0.04053722f, -0.04833969f, -0.10621630f, -0.19760568f, -0.07386521f, -0.06167903f, 
    -0.24168736f, 0.12115374f, 0.11714717f, 0.02535470f, -0.18738218f, -0.11245657f, -0.01131459f, -0.03668356f, 
    0.06218342f, 0.16863851f, 0.10977829f, 0.15722111f, -0.00074639f, 0.15536746f, -0.02183039f, 0.03430924f, 
    -0.02327545f, -0.03160951f, -0.17527962f, 0.06800070f, 0.01917064f, 0.06637922f, 0.16312070f, 0.09936231f, 
    0.16517746f, 0.09423961f, -0.04237698f, -0.30736783f, -0.22751126f, -0.33149391f, -0.06969033f, 0.10516800f, 
    -0.01541348f, -0.00814160f, -0.09001520f, -0.04262953f, -0.32076779f, -0.06127048f, -0.29277983f, 0.00020678f, 
    0.01171989f, -0.09244152f, 0.13469258f, -0.12948261f, -0.05128991f, -0.00874443f, 0.02632466f, -0.08193473f, 
    0.06745060f, -0.00893313f, 0.08044732f, -0.03569245f, 0.12872648f, -0.11295286f, 0.08734138f, 0.03773963f, 
    0.09693047f, 0.21094316f, -0.13546526f, -0.03122543f, -0.09946070f, 0.01539847f, -0.15568037f, -0.38808978f, 
    -0.24039987f, -0.29492167f, 0.21036594f, 0.00587799f, 0.06139187f, -0.04212314f, -0.05565628f, 0.02561353f, 
    -0.09142590f, -0.06443840f, -0.06146846f, -0.07808682f, -0.05885585f, -0.04329724f, 0.03552004f, -0.04903318f, 
    0.01615194f, -0.08531839f, -0.05236188f, -0.02499293f, -0.02045671f, -0.07627491f, 0.00336413f, -0.04558592f, 
    0.01848285f, -0.01547812f, 0.00440857f, 0.01150767f, -0.02991572f, -0.05145515f, 0.03585973f, 0.07264936f, 
    0.05303482f, -0.07489252f, -0.02182277f, 0.02052999f, 0.04897308f, 0.05390614f, -0.01177644f, -0.00606573f, 
    -0.00200406f, -0.07060304f, 0.03561524f, -0.01012278f, -0.06622539f, -0.01924279f, -0.02716650f, 0.02551247f, 
    0.05895475f, -0.01237362f, 0.00841434f, 0.01060225f, -0.07864864f, 0.01048714f, -0.06852455f, -0.05739097f, 
    0.05540819f, -0.05975129f, 0.05486668f, 0.01647924f, -0.02479754f, -0.05164495f, 0.04992885f, -0.06916635f, 
    -0.06112399f, -0.08449186f, 0.00663322f, 0.02080789f, -0.06254883f, -0.04670906f, 0.01584686f, -0.00670296f, 
    0.01366815f, -0.02170982f, -0.02740309f, -0.08748700f, -0.04487828f, -0.04368075f, -0.01578745f, 0.04543330f, 
    -0.07194385f, 0.01713488f, 0.02393848f, -0.01405970f, 0.07430575f, -0.01690520f, 0.00799841f, -0.02600134f, 
    0.01983713f, -0.07594926f, -0.07099486f, -0.04512564f, 0.01144885f, -0.00556829f, -0.01723419f, 0.04988300f, 
    -0.00260176f, -0.02751449f, -0.01230160f, -0.00413305f, -0.02452695f, -0.00185362f, 0.03241330f, 0.00771442f, 
    -0.03502429f, 0.07107729f, -0.04315500f, 0.04521536f, -0.03094091f, 0.03579244f, 0.03956931f, -0.08124204f, 
    -0.00336169f, 0.04432780f, 0.06605206f, 0.07306767f, -0.07415864f, -0.06182447f, -0.01464473f, -0.05152623f, 
    0.00989258f, -0.01209035f, 0.07596778f, 0.04189064f, 0.02091835f, 0.02200848f, 0.01848271f, -0.06569552f, 
    0.06685121f, -0.04068006f, -0.08309720f, -0.02861019f, -0.04374945f, 0.04018696f, -0.04158479f, -0.08252564f, 
    -0.03948109f, 0.05178999f, 0.05653210f, -0.00666765f, -0.04425362f, -0.08048752f, 0.07227854f, 0.00535708f, 
    0.03657791f, 0.05790706f, -0.03388045f, 0.01946959f, -0.02914787f, -0.00700937f, 0.06010495f, -0.02909152f, 
    0.18144210f, 0.03446570f, -0.19072327f, 0.09425360f, 0.01594227f, -0.10295622f, 0.01152691f, -0.00416001f, 
    -0.09911411f, 0.10028784f, -0.16929349f, 0.06248898f, 0.07250807f, -0.01254500f, -0.01145858f, 0.01700314f, 
    0.01945907f, -0.02651449f, -0.04428761f, 0.19647875f, 0.17060117f, -0.02398465f, -0.05248240f, 0.14593138f, 
    0.13605948f, 0.04919223f, 0.12071019f, -0.13323371f, -0.04676122f, -0.12605810f, 0.02910672f, -0.06141897f, 
    -0.04547562f, -0.16640967f, -0.00698943f, 0.15174775f, 0.05209031f, -0.06111823f, -0.08287577f, 0.21523809f, 
    0.09181030f, -0.02664911f, 0.06507833f, 0.00721326f, -0.01261187f, 0.13254291f, 0.05429317f, -0.13185757f, 
    0.07249738f, 0.05303609f, -0.19211112f, 0.07798809f, -0.01170747f, 0.23896760f, -0.48872054f, -0.22984302f, 
    -0.00259421f, 0.12953065f, 0.08084760f, 0.11092675f, 0.03038489f, 0.04543113f, -0.02896422f, 0.10019269f, 
    -0.04209607f, 0.01876684f, 0.11118722f, 0.06910730f, -0.01238820f, 0.05399287f, -0.00605155f, 0.19574063f, 
    0.07649432f, -0.33881730f, 0.09123510f, -0.15428151f, -0.03127496f, 0.09546307f, -0.05692461f, 0.10831392f, 
    -0.21394274f, 0.05326232f, -0.12963596f, 0.15906991f, -0.17547470f, 0.19701834f, 0.07135579f, 0.02898332f, 
    0.01892779f, -0.03100650f, -0.15919729f, -0.09963069f, 0.00468872f, 0.07259708f, -0.12708674f, 0.06507959f, 
    -0.00604334f, -0.14628592f, 0.10397093f, -0.19717500f, -0.21071331f, -0.09581466f, 0.07837357f, 0.18099089f, 
    0.00893805f, -0.03712500f, -0.09518391f, -0.06178020f, -0.25443313f, -0.07874944f, 0.06243371f, 0.03900111f, 
    -0.19177434f, -0.07499476f, 0.11712909f, 0.20822750f, 0.13542292f, -0.17799285f, -0.16034400f, 0.00347060f, 
    0.18654197f, -0.08911791f, 0.17997372f, -0.09306692f, -0.04943258f, 0.16401835f, 0.32645392f, 0.27952039f, 
    -0.08950401f, -0.03527911f, -0.20981939f, -0.37655458f, 0.14599012f, -0.01533396f, 0.28197917f, -0.12563629f, 
    0.13030654f, 0.06327994f, 0.08287917f, 0.03251702f, -0.03887744f, -0.14990410f, -0.05138570f, -0.03597455f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.03649808f, 0.09986240f, 0.11097058f, -0.13801630f, 0.02865810f, 0.03208016f, -0.07745285f, 0.06985308f, 
    0.22198769f, 0.05740729f, 0.00943925f, 0.08633631f, 0.08262218f, 0.06854914f, 0.05216338f, -0.00501168f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.18779758f, 0.22339877f, 0.17214690f, 0.05184952f, 0.11167025f, 0.42843235f, -0.05205475f, -0.13353485f, 
    0.19489186f, 0.02226741f, -0.20909238f, -0.22333571f, 0.22493346f, 0.07626185f, -0.09381304f, -0.39070439f, 
    0.09613859f, 0.18175961f, -0.42516756f, 0.34215581f, 0.13864984f, 0.08149046f, 0.29978827f, -0.05871619f, 
    -0.36721295f, -0.07936102f, 0.36026052f, 0.43829459f, 0.01303871f, -0.18907697f, 0.04080817f, -0.13139495f, 
    -0.26534948f, 0.30785412f, -0.18488725f, -0.45067504f, 0.35846502f, 0.06234293f, -0.06450692f, 0.17414193f, 
    -0.35135543f, -0.02064976f, 0.26084253f, -0.07300339f, 0.21178167f, -0.27385396f, -0.14666648f, 0.14437585f, 
    -0.05388418f, 0.39132425f, 0.23458622f, 0.18574150f, -0.08834387f, -0.02108950f, 0.28072077f, -0.06707373f, 
    0.11541207f, -0.08898834f, 0.25643656f, -0.50879216f, 0.03622762f, -0.43516108f, 0.09029827f, -0.11942962f, 
    0.01993312f, -0.19028357f, 0.27091143f, 0.02579521f, -0.01418999f, 0.32260549f, 0.23639393f, 0.35069567f, 
    -0.47760606f, -0.07196035f, -0.13171417f, 0.37649760f, 0.22857007f, -0.24031334f, 0.08042773f, -0.27276266f, 
    0.31390193f, -0.03363077f, 0.18557569f, -0.12534402f, 0.25995126f, 0.30375701f, -0.23191439f, -0.04265514f, 
    -0.27071646f, 0.14983982f, -0.20394611f, -0.00775433f, 0.36725295f, -0.40856642f, 0.17186366f, 0.24820933f, 
    0.20055427f, -0.02300135f, -0.23032171f, 0.51452339f, 0.48040131f, -0.20644134f, 0.44461569f, -0.28273866f, 
    -0.32061812f, 0.19213718f, 0.27509308f, -0.06616370f, -0.15667664f, 0.16606928f, 0.02862483f, 0.07057618f, 
    -0.36259431f, 0.34075671f, -0.14478619f, 0.28383657f, -0.09833034f, 0.17668314f, 0.18092695f, 0.38346320f, 
    0.05961299f, -0.14489177f, -0.28442457f, -0.24145120f, 0.06300355f, -0.42073557f, -0.19276643f, 0.11318607f, 
    -0.17125861f, -0.00878812f, 0.13940848f, 0.17698292f, 0.05782252f, 0.27946684f, -0.16220060f, -0.17027088f, 
    0.11756957f, -0.21489416f, 0.43457967f, -0.70177573f, -0.12760872f, -0.01819956f, -0.20880604f, 0.17183287f, 
    -0.23601118f, -0.20730108f, -0.17160827f, 0.13186169f, 0.12117559f, -0.10582286f, -0.12623173f, -0.05284873f, 
    -0.12095895f, 0.18850556f, -0.21007040f, -0.15377611f, -0.09130198f, 0.07198349f, -0.12835005f, -0.13380143f, 
    -0.03777394f, 0.38110441f, -0.34164411f, -0.38753125f, 0.11118659f, -0.03679463f, 0.08269820f, -0.06878003f, 
    -0.16643251f, 0.04275055f, 0.27114698f, 0.27802727f, 0.12406953f, 0.00975700f, -0.16029163f, -0.28038505f, 
    0.12330396f, -0.13333878f, 0.36806390f, 0.15564941f, -0.37385562f, 0.14459166f, -0.07299284f, 0.15435757f, 
    0.27318084f, 0.14615415f, 0.45467547f, -0.08086082f, -0.12668559f, -0.10421026f, -0.01889116f, -0.05778011f, 
    0.00475718f, 0.28600726f, -0.00533625f, -0.35689813f, -0.21228933f, 0.31542847f, 0.38011536f, 0.30167744f, 
    0.14926612f, -0.16682649f, -0.28383046f, -0.10886926f, -0.25882491f, 0.25705624f, 0.20643780f, -0.05275726f, 
    -0.40270481f, -0.08170279f, 0.27129704f, 0.38949198f, 0.02063047f, 0.03203689f, 0.16403536f, 0.36292639f, 
    0.08490427f, 0.13604163f, 0.00418863f, 0.26553237f, -0.23277703f, -0.01607413f, 0.25334719f, 0.15004307f, 
    -0.32203901f, 0.13989043f, 0.01660857f, 0.15639046f, 0.17926463f, -0.14622244f, 0.32235733f, -0.22980194f, 
    0.05957052f, -0.00821129f, -0.04935335f, 0.26494718f, -0.12196056f, 0.22292989f, 0.20757569f, 0.06137285f, 
    -0.24820435f, -0.18286178f, -0.03481039f, -0.18432078f, -0.05093640f, 0.20144707f, -0.14082453f, -0.05494866f, 
    0.19983885f, -0.20590472f, 0.16076326f, -0.02160677f, -0.24190274f, -0.21181750f, -0.00362563f, -0.19494769f, 
    0.26850250f, 0.02516402f, 0.18975607f, -0.16933621f, 0.22463132f, 0.00745662f, -0.32708055f, 0.23611137f, 
    -0.40179288f, 0.14168689f, -0.04872442f, 0.06223554f, 0.38173804f, -0.11461707f, 0.15276465f, -0.19522324f, 
    0.09689009f, 0.21310900f, 0.22422044f, 0.24738993f, -0.10489415f, -0.08502172f, -0.27373669f, -0.38761261f, 
    -0.18558992f, -0.19342546f, 0.15375505f, 0.19380814f, 0.29821396f, 0.43503395f, 0.20014995f, -0.17454450f, 
    -0.08008970f, -0.16104910f, 0.25196925f, -0.06061205f, -0.04271632f, -0.25682783f, 0.06724713f, -0.12533279f, 
    0.24510427f, -0.10567181f, -0.16906260f, 0.22018836f, -0.15475787f, 0.03321709f, -0.03095453f, -0.00424659f, 
    0.10170048f, -0.21317530f, -0.22056830f, 0.01893028f, -0.24078128f, -0.18215881f, -0.09088569f, -0.09396393f, 
    -0.04023087f, 0.19042967f, -0.01485635f, -0.13047332f, 0.13211447f, -0.20716186f, -0.13896862f, -0.03747948f, 
    -0.28553537f, 0.18199934f, -0.32919389f, -0.42758051f, 0.35807157f, 0.10630978f, 0.28674978f, -0.29689485f, 
    0.41493389f, 0.22918083f, 0.06217181f, -0.05999844f, 0.09890422f, -0.09079450f, 0.07769635f, 0.37333879f, 
    -0.29714474f, -0.14447927f, -0.03233867f, 0.06067105f, 0.45670620f, -0.10671552f, -0.37165684f, 0.54067600f, 
    0.24205086f, -0.07662177f, 0.09454000f, 0.09857592f, -0.11506075f, -0.11490477f, 0.09448415f, 0.22241619f, 
    0.12272568f, -0.03918450f, 0.13994947f, 0.04765876f, 0.24023059f, -0.28226304f, 0.31727928f, 0.31267273f, 
    -0.02607534f, 0.15875615f, 0.03948549f, 0.20882607f, 0.05614140f, -0.27482656f, -0.21854642f, 0.03552089f, 
    0.04461498f, -0.10216404f, 0.19909830f, 0.31511351f, -0.34665850f, 0.09884980f, -0.18057662f, 0.06623105f, 
    0.32604218f, 0.14911777f, 0.40691429f, -0.09673218f, -0.05512232f, 0.09597395f, -0.17357530f, 0.02680936f, 
    0.04925252f, -0.13910384f, -0.37138677f, -0.18910496f, -0.26506951f, 0.28268182f, 0.01316011f, -0.08887083f, 
    -0.30696163f, -0.10858613f, 0.12394483f, 0.25819629f, 0.60712761f, -0.13947704f, 0.07771485f, 0.07644934f, 
    0.13080162f, -0.01717019f, -0.10871332f, 0.32040760f, 0.03651994f, -0.25708261f, 0.10773646f, -0.08029959f, 
    -0.16161159f, 0.13093513f, 0.19563413f, -0.23244928f, -0.15424752f, -0.29548216f, -0.18803255f, -0.35141504f, 
    0.27030000f, -0.21287960f, 0.20047241f, 0.01471438f, 0.50329798f, -0.28908640f, -0.16777621f, -0.05985029f, 
    0.02542635f, 0.06694971f, 0.37432411f, 0.11941018f, -0.33145791f, 0.13892184f, -0.05368728f, 0.19519709f, 
    -0.26417789f, -0.29820228f, 0.13179418f, -0.11090237f, 0.41667637f, -0.19872859f, 0.05649132f, 0.42438585f, 
    0.29913080f, -0.05097656f, -0.10825092f, -0.03034211f, 0.02725783f, 0.18697110f, -0.14609812f, 0.32039145f, 
    0.19613495f, 0.01007628f, 0.01146558f, 0.05373949f, -0.24764250f, 0.36181459f, -0.13360070f, -0.12462948f, 
    0.10549041f, -0.12753621f, 0.25140968f, 0.07925441f, 0.23627579f, -0.25577903f, -0.01202353f, -0.02909213f, 
    0.24667268f, 0.15175219f, 0.27376708f, 0.44668427f, -0.25890049f, 0.01846211f, -0.28862599f, 0.14632203f, 
    -0.30942076f, 0.23801771f, -0.01971599f, -0.47621959f, -0.00029480f, -0.76106209f, 0.07065659f, -0.10334548f, 
    0.04134147f, 0.03626611f, -0.35509339f, -0.11369598f, -0.09432976f, 0.16353393f, -0.17642412f, -0.10332171f, 
    -0.22607601f, 0.08074355f, -0.05449673f, 0.27706584f, 0.31421846f, 0.13799068f, 0.03951775f, 0.28769192f, 
    0.50893867f, -0.00751767f, 0.27843326f, 0.31953600f, -0.01161393f, -0.11690216f, -0.33293411f, -0.26587203f, 
    0.05275689f, 0.00185563f, -0.20875937f, -0.45681334f, 0.24210779f, 0.22741592f, -0.14621052f, -0.23192652f, 
    -0.10716762f, 0.03141600f, -0.10634058f, -0.04323903f, 0.01887719f, -0.24652205f, 0.09986905f, -0.08092552f, 
    -0.18571547f, -0.10181472f, 0.01057410f, 0.22520328f, 0.08357403f, -0.23528157f, -0.06335673f, 0.30783007f, 
    -0.04268485f, -0.15569162f, 0.16874528f, 0.37747437f, 0.43080419f, -0.10237788f, -0.45108780f, 0.10097315f, 
    -0.19022757f, 0.11544313f, 0.18799362f, 0.00787759f, 0.27478516f, -0.09386875f, 0.16905119f, 0.22618966f, 
    0.26283231f, -0.12216941f, -0.09873649f, 0.37599227f, -0.08012192f, 0.15585290f, 0.20892768f, 0.43535504f, 
    -0.34792313f, 0.00391894f, -0.21310416f, 0.27037379f, -0.29870382f, -0.05101605f, 0.23862658f, -0.13875426f, 
    0.12580575f, 0.32309589f, 0.12101739f, -0.11588705f, -0.01068366f, 0.23865350f, 0.14884710f, -0.16412473f, 
    0.18755549f, -0.23728208f, 0.36333638f, -0.40466833f, -0.07871087f, -0.16758510f, 0.06145167f, -0.12439279f, 
    0.18865669f, 0.12364056f, 0.22804359f, -0.29668438f, -0.19325346f, 0.21297808f, 0.29025763f, -0.30094361f, 
    -0.24862032f, 0.18718685f, 0.19484684f, -0.30052802f, 0.47428393f, 0.14198439f, -0.12471263f, -0.08165617f, 
    0.31547078f, -0.03756025f, 0.10305163f, -0.26152828f, 0.19683196f, 0.23633757f, 0.37673470f, 0.23253696f, 
    -0.38361090f, 0.14739519f, -0.30462590f, 0.23834671f, 0.27290937f, -0.22730902f, -0.10938819f, -0.20403853f, 
    -0.20795241f, -0.08507790f, -0.24275076f, 0.20266053f, 0.40523103f, 0.38237235f, 0.47148439f, -0.00392490f, 
    -0.06069651f, 0.23354524f, -0.08153777f, 0.05194931f, -0.23175886f, 0.07039102f, -0.16587257f, -0.10889069f, 
    0.06858102f, 0.08188236f, -0.16431329f, 0.30996016f, 0.48990408f, -0.19719769f, -0.25577399f, -0.07243769f, 
    0.07399478f, 0.19392015f, 0.22350991f, -0.23375492f, -0.15441646f, 0.11608975f, -0.04934327f, 0.34061924f, 
    -0.19744895f, -0.36412501f, 0.25107944f, -0.18635255f, -0.04729788f, 0.15001035f, 0.19742349f, 0.14400132f, 
    -0.71809250f, -0.16680655f, -0.20608962f, -0.22531649f, 0.49378213f, -0.14541970f, 0.13737127f, 0.24789496f, 
    -0.05805926f, -0.07263818f, 0.13251355f, 0.37047762f, -0.08282382f, -0.08131822f, -0.46272203f, 0.24458589f, 
    0.32380047f, 0.23076604f, -0.24529444f, -0.03907841f, 0.20070325f, 0.09928440f, 0.03038456f, 0.23721425f, 
    -0.09626585f, 0.15464792f, 0.28337255f, 0.43721592f, 0.32567647f, -0.31336409f, -0.18243839f, -0.02234345f, 
    0.30987003f, 0.25133139f, 0.36395565f, -0.23342714f, 0.01079196f, 0.09309833f, -0.23027156f, 0.02331714f, 
    0.07251277f, 0.02462208f, -0.11135668f, -0.16325286f, -0.28630418f, -0.06635804f, 0.36150098f, 0.18730193f, 
    0.08095638f, -0.24139321f, 0.30865175f, -0.58702755f, 0.25211859f, -0.03620900f, 0.21025382f, -0.13264647f, 
    0.09964921f, 0.06847385f, 0.16127256f, -0.04052172f, -0.28616619f, -0.02084373f, 0.13719501f, 0.21851890f, 
    0.39588386f, -0.19390994f, 0.24357960f, 0.00393593f, -0.26706460f, 0.39519855f, 0.06551188f, -0.18364100f, 
    0.15969621f, -0.12693037f, 0.19502690f, -0.09382705f, 0.55172038f, -0.40518001f, -0.06273799f, 0.15134715f, 
    0.18798260f, 0.24837241f, 0.12224261f, 0.09296823f, -0.30371413f, 0.06869119f, -0.23476093f, -0.02257927f, 
    0.02048788f, -0.22126374f, -0.03841310f, -0.37001866f, 0.23896173f, -0.11268353f, -0.41016722f, 0.14051422f, 
    0.57271832f, -0.07460841f, 0.08768184f, 0.68221539f, 0.14351007f, 0.43229797f, 0.23341753f, 0.01330651f, 
    -0.01217694f, 0.06613453f, 0.35892326f, -0.41682059f, -0.04174442f, 0.20333412f, -0.05000453f, -0.04980863f, 
    0.35820198f, 0.12679492f, 0.09417921f, 0.13627277f, -0.07891449f, -0.38451841f, -0.02369729f, -0.04653794f, 
    0.13929690f, -0.21713534f, -0.27644515f, -0.51361090f, -0.00230672f, 0.43077785f, 0.03817825f, 0.29858291f, 
    -0.27102906f, -0.08994576f, -0.35081807f, 0.04329740f, 0.26069871f, 0.58284086f, -0.10658550f, -0.32325694f, 
    -0.35157979f, 0.04974269f, 0.05280369f, 0.35249981f, 0.29572406f, 0.12895663f, 0.15962832f, -0.20136024f, 
    -0.04096057f, 0.11837550f, -0.17249279f, -0.15302201f, -0.15381317f, 0.35257897f, -0.01470490f, 0.20102222f, 
    -0.20075394f, -0.16796060f, -0.01054714f, 0.14199930f, 0.04892386f, 0.23551260f, 0.53770828f, 0.29301628f, 
    0.10575981f, -0.16407913f, -0.26188996f, 0.12495767f, -0.11660461f, -0.25298423f, -0.18755800f, 0.19058476f, 
    0.26146486f, -0.19242504f, -0.19917233f, 0.37690958f, -0.15614098f, 0.19933899f, -0.35163236f, -0.34672153f, 
    -0.04582921f, -0.14163926f, 0.30350181f, 0.17248067f, -0.00443253f, 0.45392472f, 0.01401008f, 0.23495170f, 
    -0.32615891f, 0.30663106f, -0.25931257f, 0.16429345f, 0.13462400f, -0.18829784f, -0.06778584f, 0.22684826f, 
    -0.15643808f, 0.09489366f, 0.27464700f, -0.20515467f, -0.25125730f, -0.03697449f, 0.22777304f, 0.36369723f, 
    -0.01198851f, 0.15061390f, 0.10002562f, -0.10095420f, 0.34959221f, -0.51997274f, -0.01348671f, -0.07452453f, 
    -0.17287560f, -0.14001119f, 0.22218575f, -0.00389980f, -0.16858685f, 0.20478797f, -0.02092359f, 0.04612339f, 
    0.22935770f, -0.24784315f, 0.26819715f, 0.34310597f, 0.09197057f, -0.06412765f, -0.31832525f, 0.25533161f, 
    0.10364056f, -0.21530096f, -0.20394830f, 0.29525930f, -0.38170457f, 0.39968345f, -0.22782226f, 0.14127730f, 
    0.25399113f, 0.26103836f, 0.29633158f, -0.06181567f, -0.03943790f, 0.24667837f, 0.23557369f, -0.07977031f, 
    -0.14099634f, 0.19047789f, -0.28387442f, -0.27291992f, 0.40309712f, 0.10630180f, 0.19260445f, -0.18586189f, 
    -0.11275174f, 0.00738157f, 0.04361929f, -0.46073282f, 0.35553002f, -0.14101535f, 0.30693024f, 0.12160598f, 
    -0.06669432f, 0.04688692f, 0.26197308f, -0.21745090f, 0.17881173f, -0.12297463f, 0.10317349f, 0.12874943f, 
    -0.14584197f, -0.33594322f, -0.57071096f, -0.26389202f, -0.19998337f, 0.50916034f, 0.13722175f, 0.21953760f, 
    -0.04157726f, 0.07763981f, 0.25983122f, -0.21100524f, 0.17519958f, 0.35184503f, 0.21146134f, 0.15650578f, 
    -0.28774327f, 0.18991508f, 0.07671976f, 0.34099981f, -0.34890509f, 0.15096214f, 0.08809084f, 0.15605021f, 
    0.28882176f, 0.08896800f, -0.00470243f, -0.24309210f, -0.03811290f, -0.43715522f, 0.06891511f, 0.10934938f, 
    0.15782608f, -0.18836336f, 0.38374582f, 0.15483619f, 0.02716911f, 0.27558565f, -0.06381729f, 0.47457504f, 
    0.09047347f, -0.13541669f, -0.10776641f, 0.00128598f, -0.27865776f, -0.20237553f, -0.16167347f, 0.27738357f, 
    0.19035321f, 0.05156561f, 0.05389471f, -0.05330473f, 0.22220717f, 0.21145113f, -0.01203025f, -0.39314282f, 
    -0.26349753f, 0.15290797f, -0.06040747f, -0.20139405f, -0.13623394f, 0.44672549f, -0.20288502f, 0.14013264f, 
    0.17369054f, -0.07296325f, 0.43836364f, -0.07539500f, -0.37504172f, -0.24243554f, -0.42767340f, -0.31394646f, 
    0.67469251f, 0.25004882f, -0.12159834f, 0.33676267f, 0.05492136f, -0.39704397f, -0.14918119f, 0.32811764f, 
    0.13872927f, -0.14955863f, 0.38496107f, 0.33776423f, 0.03718448f, -0.00271627f, -0.04668008f, 0.22069407f, 
    -0.09440310f, -0.18204416f, -0.09913921f, -0.04742061f, -0.30278453f, 0.06557649f, -0.22631580f, 0.18540470f, 
    -0.08163938f, 0.05130646f, -0.43251556f, -0.11497908f, 0.38782638f, 0.12339084f, -0.08630940f, -0.04401596f, 
    0.05285227f, -0.22685465f, 0.08961938f, -0.15254885f, -0.34859750f, -0.26301900f, -0.00856629f, 0.30653217f, 
    -0.07472678f, -0.17002714f, 0.30613410f, -0.20035501f, 0.13094850f, 0.13012570f, -0.11492004f, 0.19170691f, 
    0.22601941f, -0.18221574f, -0.17204045f, 0.35861561f, -0.29438961f, -0.25403410f, 0.11701513f, 0.17022379f, 
    -0.23924264f, -0.17775765f, -0.16535614f, 0.16357137f, -0.23676427f, -0.22691038f, 0.14476222f, 0.01060979f, 
    -0.07215963f, 0.18062262f, -0.27153924f, -0.23235458f, 0.06362247f, -0.14306310f, 0.22804108f, -0.25977391f, 
    0.38215667f, 0.13086899f, -0.02547695f, -0.12325833f, -0.03737428f, -0.14280021f, 0.30764690f, 0.02789180f, 
    -0.01202264f, 0.19957124f, 0.26943046f, 0.16688676f, -0.06434982f, 0.13324612f, -0.21681443f, -0.44089302f, 
    0.42283708f, -0.01541395f, -0.08403900f, -0.03738917f, 0.12124725f, -0.60141110f, 0.05696841f, -0.23467585f, 
    0.53490061f, -0.07096258f, 0.01180373f, 0.26709190f, -0.03326229f, 0.15713651f, -0.08008966f, -0.01953111f, 
    -0.06686928f, 0.02315423f, 0.18536983f, -0.05560884f, -0.23508297f, -0.17368428f, -0.22158259f, -0.03802850f, 
    -0.14140901f, -0.24777229f, -0.16898179f, -0.01391102f, -0.19374917f, 0.35695228f, -0.04271835f, 0.32263911f, 
    0.12489680f, -0.05989670f, 0.10430024f, -0.26048303f, -0.12324432f, -0.47145846f, 0.03706833f, 0.06608435f, 
    0.04968332f, 0.11096470f, 0.34876937f, -0.04484120f, 0.19735657f, 0.25643685f, -0.23550846f, 0.11965260f, 
    0.40032962f, -0.17685190f, 0.15271032f, 0.49070585f, -0.07773798f, 0.18440573f, 0.02595549f, -0.22761412f, 
    -0.10958431f, 0.17149547f, -0.28342634f, -0.00747559f, 0.07365631f, 0.25210202f, -0.16294721f, -0.19110072f, 
    0.18209694f, 0.15147102f, -0.06556633f, -0.26014102f, 0.37175053f, -0.57967240f, 0.50009936f, 0.09441240f, 
    0.13298230f, -0.20961063f, 0.01909361f, -0.03178590f, -0.04872992f, -0.01492365f, 0.13750853f, -0.16471574f, 
    -0.21909383f, 0.18731278f, -0.06091332f, 0.35973206f, 0.33933416f, 0.03990814f, -0.27653804f, 0.23728420f, 
    -0.24633454f, 0.00911872f, 0.19744557f, -0.51674581f, 0.19128381f, -0.33560348f, -0.23226532f, 0.05472186f, 
    -0.09256171f, -0.12990393f, -0.65331280f, -0.46212444f, 0.08692258f, 0.07965226f, 0.07780930f, -0.17009364f, 
    0.28451702f, -0.16449884f, -0.41372398f, -0.09991850f, 0.14698501f, 0.24219316f, -0.06380933f, 0.41669437f, 
    -0.10314769f, -0.10597836f, -0.13199361f, 0.09185769f, -0.10239663f, -0.26783296f, -0.06194714f, -0.26035994f, 
    -0.14457777f, 0.11140892f, -0.15332420f, 0.17690776f, -0.25589654f, 0.18297440f, -0.09493843f, -0.08866923f, 
    0.02304999f, 0.31434157f, 0.17427933f, -0.45256835f, 0.14065377f, 0.18921678f, -0.15680081f, -0.24876252f, 
    0.31187826f, -0.01161485f, 0.11945039f, -0.43367490f, 0.30435154f, -0.31985447f, 0.10727999f, 0.12707897f, 
    0.05177367f, -0.21057668f, -0.24789420f, -0.01566479f, 0.02085978f, -0.22933552f, -0.03938848f, -0.02916810f, 
    -0.09823996f, -0.22530544f, -0.06623894f, -0.10472187f, 0.09388059f, -0.18264052f, -0.23556513f, -0.03918695f, 
    -0.05250585f, 0.03069561f, 0.22989769f, 0.22037216f, -0.15677893f, -0.22536075f, 0.40769294f, 0.31069282f, 
    -0.29839399f, 0.18849897f, 0.35099506f, -0.10165059f, -0.12407427f, 0.34572670f, -0.21773380f, -0.42420757f, 
    0.27695683f, 0.01546903f, 0.30073869f, -0.11331891f, -0.42018658f, 0.30036485f, 0.33786869f, -0.04758922f, 
    -0.11412693f, -0.08944588f, 0.30248231f, -0.03169404f, 0.41077864f, -0.11763427f, -0.20627035f, -0.19481450f, 
    -0.17775123f, 0.00421680f, -0.03856351f, -0.18651731f, -0.19639355f, -0.20144933f, -0.03278740f, -0.20078127f, 
    0.15533946f, 0.13401344f, -0.00610599f, -0.20410489f, 0.01726902f, 0.07821169f, -0.22146189f, 0.02378566f, 
    -0.35592982f, 0.22718279f, 0.06081207f, -0.16325869f, 0.13272220f, -0.15978186f, 0.25820625f, -0.37607801f, 
    0.21497829f, 0.00439185f, -0.21999103f, 0.10933014f, 0.12331413f, 0.32570544f, -0.11282326f, 0.24792917f, 
    0.11819234f, 0.35573596f, -0.01665018f, 0.17986992f, -0.08645459f, 0.21660960f, 0.18761428f, -0.11132812f, 
    0.01399388f, 0.12057400f, -0.35777640f, 0.21562427f, 0.14559351f, 0.04029813f, 0.10080320f, -0.29460692f, 
    0.11088774f, -0.19346817f, 0.01217610f, -0.05013570f, 0.04117830f, 0.33919314f, 0.45078021f, -0.03413052f, 
    -0.07890563f, 0.14989065f, -0.49083433f, -0.08916581f, -0.05051477f, -0.26756272f, -0.11361852f, 0.31890953f, 
    0.22019397f, 0.11841539f, 0.18159322f, -0.45485878f, 0.16796529f, -0.36538559f, -0.40461791f, 0.23656657f, 
    -0.00921473f, 0.12725849f, 0.34578860f, 0.11530311f, 0.29173106f, 0.01796963f, 0.06853010f, 0.09124218f, 
    -0.22899362f, 0.03157976f, 0.05578046f, 0.17305321f, 0.24139489f, -0.23437797f, -0.06295510f, -0.22014256f, 
    0.09977342f, 0.13082969f, 0.34800163f, 0.17384802f, -0.25976306f, 0.15321343f, -0.04053830f, 0.00107548f, 
    0.34776708f, 0.18948352f, 0.18922237f, -0.27049196f, -0.07726169f, 0.18972060f, 0.17591751f, 0.12961642f, 
    0.26136348f, -0.11517186f, -0.33522412f, 0.11730194f, -0.14716926f, -0.27400517f, -0.03567624f, -0.21341564f, 
    -0.57057303f, 0.21150506f, -0.26543516f, -0.07946198f, 0.25654116f, 0.25558084f, 0.30588257f, 0.04866481f, 
    0.56325907f, -0.24185467f, -0.09250951f, 0.14701468f, -0.42950866f, -0.34778681f, 0.18020046f, 0.32925597f, 
    0.11226086f, 0.34602913f, -0.31902072f, -0.23839350f, -0.12243678f, 0.12010267f, 0.29056045f, -0.11325144f, 
    -0.22427924f, -0.12701593f, 0.17424503f, -0.05563909f, -0.28726047f, 0.27326196f, 0.18281201f, 0.13715890f, 
    -0.23971003f, -0.02395085f, 0.00799873f, 0.26132452f, 0.44732922f, 0.13975875f, 0.34977478f, 0.30123901f, 
    -0.15442625f, 0.08461995f, -0.28114161f, 0.31603751f, -0.43394735f, -0.07767006f, 0.06070647f, 0.09443357f, 
    0.19630553f, -0.13293056f, -0.19285080f, 0.10162909f, 0.09714136f, -0.17043783f, 0.36758813f, 0.21590160f, 
    -0.47339201f, -0.00769044f, -0.40850246f, 0.31574720f, 0.01143057f, 0.07998397f, -0.12701562f, 0.07775330f, 
    -0.05523702f, 0.04346622f, -0.06199342f, -0.24943499f, -0.20601185f, -0.04043221f, -0.25458893f, -0.02959990f, 
    0.13332568f, -0.12743869f, -0.21417579f, -0.14328195f, 0.19480048f, 0.05389509f, -0.17772070f, -0.18673198f, 
    0.33689937f, 0.06394976f, -0.22226709f, -0.19799061f, -0.31445390f, -0.24516438f, 0.17443554f, -0.04119355f, 
    0.53757775f, -0.22343192f, 0.07474592f, 0.10556011f, 0.17516322f, 0.37833288f, -0.16446298f, -0.22328007f, 
    0.22888301f, 0.38383052f, -0.10198523f, -0.39856270f, -0.22452153f, 0.18281895f, 0.33819962f, 0.05037245f, 
    -0.01544148f, -0.23315288f, -0.22335380f, 0.00568087f, 0.05690535f, -0.15582083f, 0.15056458f, -0.06848007f, 
    -0.23273806f, -0.23683868f, 0.05611489f, 0.04493024f, -0.01847452f, -0.09923066f, -0.17946525f, -0.14524616f, 
    0.00314987f, -0.18923269f, -0.10525192f, -0.13025644f, -0.16105224f, 0.23538420f, 0.24686018f, -0.27684358f, 
    -0.01196219f, 0.18742266f, 0.39143461f, -0.39786580f, 0.39380896f, 0.09380515f, -0.52972859f, 0.24192885f, 
    -0.22552134f, -0.10155963f, 0.10453016f, -0.22981282f, 0.14566186f, -0.42189419f, -0.01460653f, 0.04196871f, 
    -0.17184219f, -0.45338115f, -0.16787009f, -0.17963234f, 0.26419339f, 0.09860019f, 0.17882074f, 0.28396526f, 
    -0.02246025f, -0.19005871f, -0.00763274f, -0.08011724f, 0.47365007f, 0.18879128f, 0.09303182f, 0.09663995f, 
    0.33778915f, -0.24315193f, 0.29390642f, 0.33359215f, -0.18655448f, -0.06127768f, -0.10116302f, -0.10068022f, 
    -0.16711213f, 0.09374603f, 0.27922663f, -0.23199862f, -0.03320981f, -0.02590323f, -0.06528714f, 0.29016858f, 
    0.20202018f, -0.12768786f, 0.47215119f, -0.16950060f, -0.47550964f, -0.09994537f, 0.08028719f, -0.07588441f, 
    -0.23757356f, -0.22196168f, 0.19358630f, -0.38427323f, 0.37243599f, 0.41421029f, -0.11791629f, 0.21638355f, 
    -0.28121114f, 0.17102608f, -0.00852710f, -0.01162579f, -0.17920084f, 0.17788398f, 0.30534169f, -0.02864541f, 
    0.12362154f, -0.09694695f, 0.26242134f, -0.50232249f, 0.24633081f, -0.31695268f, 0.23886475f, 0.00819588f, 
    -0.06317575f, 0.28123480f, -0.07244708f, 0.33346543f, 0.28873029f, -0.13946867f, -0.33071771f, -0.22592130f, 
    0.04108955f, 0.15694173f, 0.12500410f, -0.09069227f, -0.45609835f, 0.47584626f, -0.20570302f, 0.17694867f, 
    0.25184333f, 0.15033688f, 0.10056699f, -0.40248427f, 0.20793110f, -0.00902096f, -0.16885450f, -0.18254465f, 
    0.06956223f, 0.21934170f, 0.19774154f, -0.15215878f, 0.31859651f, -0.14212793f, -0.24034810f, 0.06181436f, 
    0.25358120f, 0.28896937f, -0.09760617f, 0.28838152f, -0.23344335f, -0.13223702f, -0.02266701f, 0.30988482f, 
    0.05098044f, 0.16083044f, 0.56717253f, -0.29663631f, 0.04143982f, 0.12673350f, 0.16986856f, -0.32821739f, 
    0.14800106f, -0.14502537f, -0.19548993f, 0.00259572f, -0.15028863f, -0.00798674f, 0.22389252f, 0.19902281f, 
    -0.65422344f, 0.15759739f, -0.07615780f, 0.42394382f, -0.09743959f, 0.19908439f, -0.14126664f, -0.10073316f, 
    0.17256753f, 0.28853890f, 0.12731461f, 0.00271646f, -0.20263383f, 0.09967745f, 0.32240605f, 0.23811342f, 
    0.38175014f, -0.14306426f, -0.23743753f, -0.18373822f, 0.12967716f, -0.17533095f, -0.19500867f, -0.35270131f, 
    0.38885242f, -0.06164482f, 0.03952055f, 0.33901212f, 0.08189721f, -0.19763878f, 0.36367992f, -0.49232635f, 
    0.10680304f, -0.22961456f, 0.12318950f, 0.07132762f, 0.15277813f, 0.04936589f, 0.05979223f, -0.60662460f, 
    0.31443766f, -0.00008186f, 0.19204873f, -0.04232977f, -0.13490239f, -0.41978619f, 0.20505673f, -0.18395023f, 
    0.49913746f, 0.09912583f, -0.31718072f, 0.05625824f, 0.10842430f, -0.51641756f, 0.08692455f, 0.40085760f, 
    -0.00351495f, -0.02364695f, 0.13903977f, -0.18223828f, 0.29762411f, 0.22945219f, 0.04121932f, 0.47918668f, 
    -0.34737334f, -0.01957157f, -0.17166075f, -0.09791208f, -0.02792261f, -0.25291106f, 0.19255187f, 0.27278304f, 
    0.11115526f, 0.29879475f, 0.14692156f, -0.25784102f, 0.02690834f, -0.10488930f, -0.03480593f, -0.10538925f, 
    0.12531647f, -0.06102491f, 0.25982779f, -0.06066542f, 0.22814682f, 0.12426367f, 0.20873067f, -0.16636166f, 
    0.45740953f, 0.16874963f, 0.22088739f, -0.41251412f, 0.19661830f, 0.12648578f, 0.07982656f, -0.16175081f, 
    -0.02047296f, -0.12776700f, -0.33641940f, -0.11962595f, 0.15913770f, -0.03929173f, -0.04646200f, -0.06381340f, 
    -0.37025097f, -0.23119625f, 0.17137820f, 0.06991473f, 0.10710996f, -0.35119274f, 0.15255527f, 0.36269945f, 
    0.11018393f, -0.08775860f, 0.39644870f, 0.08910780f, -0.52779627f, 0.14586553f, 0.04743353f, 0.04349059f, 
    -0.09298385f, -0.11405754f, 0.26258492f, 0.33740008f, 0.34757042f, 0.32170597f, -0.37958726f, 0.25412747f, 
    -0.29175118f, -0.22527494f, 0.15245266f, 0.22857693f, 0.22029503f, -0.19298328f, -0.25429589f, -0.16029389f, 
    0.26516268f, -0.07186544f, -0.38415331f, -0.11609535f, -0.25820455f, 0.38147292f, -0.13477837f, 0.08880641f, 
    0.22140448f, 0.13001832f, 0.42119667f, 0.36304805f, -0.25090504f, -0.05202830f, -0.23475897f, 0.13242656f, 
    -0.15253083f, -0.25193244f, 0.22747540f, -0.32230777f, -0.18200514f, 0.26461527f, -0.09596422f, -0.09014531f, 
    -0.16108830f, 0.05482825f, 0.24001838f, -0.01104400f, 0.37544748f, -0.12263130f, 0.16739830f, -0.19741158f, 
    0.38142183f, -0.05352230f, 0.45520350f, -0.26453355f, -0.50033820f, 0.03383179f, -0.26487947f, 0.26978680f, 
    0.20728491f, -0.11181308f, 0.04888614f, -0.16771482f, 0.14505172f, -0.44655374f, -0.10427108f, -0.17231399f, 
    -0.24526301f, 0.30964440f, -0.03782669f, -0.15670274f, 0.05549403f, 0.14477426f, -0.01482443f, -0.03302100f, 
    -0.39822647f, -0.24347079f, -0.04365551f, 0.30100554f, -0.20194121f, -0.02396831f, -0.11594634f, 0.20706476f, 
    0.13234015f, 0.35073197f, -0.21464926f, -0.31444094f, 0.15233383f, 0.00605637f, 0.25259131f, -0.25215936f, 
    -0.27472851f, -0.01792246f, 0.20757133f, -0.06165856f, 0.14359273f, 0.41785213f, -0.18589735f, -0.02127164f, 
    0.10901872f, 0.29700884f, -0.07018542f, 0.57002497f, -0.22350954f, 0.33132339f, 0.20807232f, -0.25626886f, 
    0.29872322f, 0.11563170f, -0.19099110f, -0.26795405f, -0.21055959f, -0.19807597f, 0.19494867f, -0.12830950f, 
    0.36322704f, 0.17983660f, 0.11736447f, -0.19498003f, -0.02882285f, -0.28664827f, -0.31452593f, -0.35422096f, 
    0.11769863f, 0.05223323f, 0.41612780f, 0.20737852f, 0.32806712f, 0.41923565f, 0.21186025f, -0.00745214f, 
    0.13315985f, -0.06693092f, 0.30567652f, 0.07840203f, 0.22198054f, -0.26324418f, 0.29815030f, 0.09192184f, 
    0.16509993f, 0.10189658f, 0.01452663f, 0.13984962f, -0.21051139f, -0.30006742f, 0.02088261f, -0.15757699f, 
    0.02163978f, -0.10181188f, 0.21483965f, 0.31823260f, 0.25755697f, -0.32743573f, -0.11971311f, -0.13330925f, 
    0.08436604f, -0.17000841f, 0.08111950f, 0.03649447f, -0.07214498f, 0.39663750f, -0.14837165f, -0.06825047f, 
    -0.07977195f, -0.14842576f, 0.11436174f, 0.18948604f, 0.26674676f, 0.18795659f, 0.36949602f, 0.06049887f, 
    -0.41480225f, -0.12908141f, -0.61671972f, 0.28755429f, 0.10850236f, -0.39422810f, -0.09463568f, 0.25041983f, 
    0.21303149f, 0.12689511f, 0.04525120f, -0.47425312f, -0.12951906f, 0.25728154f, -0.01542654f, 0.04508694f, 
    -0.05184580f, -0.16661471f, 0.12079605f, -0.22159931f, 0.21131940f, -0.31867242f, 0.03458532f, 0.25610045f, 
    -0.13614725f, -0.08074117f, 0.23119053f, 0.42616093f, 0.23270294f, 0.19380867f, -0.07693356f, -0.22229853f, 
    -0.34060013f, 0.21630487f, 0.26107761f, -0.57217920f, -0.12794155f, -0.24734585f, 0.01410513f, 0.41669968f, 
    -0.40034094f, 0.08886483f, 0.22076429f, -0.00809270f, 0.09871618f, 0.10872858f, 0.35485834f, -0.04838261f, 
    -0.17114520f, -0.15882523f, 0.14465012f, -0.22582211f, 0.09702375f, -0.24478076f, 0.10270159f, -0.24033633f, 
    -0.33849698f, 0.26312104f, -0.00928827f, -0.35989642f, 0.10185973f, 0.14061454f, -0.06479631f, -0.17776403f, 
    -0.10568392f, -0.08239908f, -0.23371343f, 0.08457107f, 0.02905934f, 0.32364491f, -0.02794856f, 0.27247369f, 
    -0.21182051f, 0.07061537f, 0.15655451f, -0.16148840f, -0.04431676f, -0.04030324f, 0.04808873f, 0.23527461f, 
    -0.15596645f, -0.04098636f, -0.12631045f, -0.44561532f, -0.33717039f, 0.45222300f, -0.23644459f, 0.35586128f, 
    -0.12436308f, 0.10582269f, 0.14129493f, 0.47189590f, -0.24699402f, -0.32203808f, -0.10267692f, 0.05763935f, 
    -0.37033761f, -0.10317153f, 0.10571889f, 0.20559829f, 0.31202942f, 0.44067198f, 0.13576655f, -0.18003689f, 
    0.10237353f, 0.18752754f, 0.20850253f, 0.31865677f, -0.17362286f, -0.06363079f, -0.22057086f, -0.42869985f, 
    0.14291076f, 0.01863619f, 0.20774396f, -0.36667341f, -0.14836615f, 0.50432986f, -0.22296062f, 0.09433080f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01688568f, -0.35729766f, 0.31275159f, -0.09425632f, 0.02889666f, -0.23682545f, -0.23775482f, 0.05111026f, 
    0.36369684f, -0.06540403f, 0.38820100f, 0.37766206f, -0.05350923f, -0.21441390f, 0.11109629f, -0.09320465f, 
    0.16990472f, 0.38946173f, 0.02861851f, 0.18007337f, 0.41924608f, -0.14267506f, -0.26510450f, -0.03772362f, 
    -0.19554602f, 0.11973981f, -0.26975164f, -0.33778128f, 0.16794206f, 0.38548988f, -0.12456121f, 0.21682376f, 
    0.39519772f, -0.29097098f, 0.12200174f, -0.04465510f, 0.22807701f, -0.12224482f, 0.41527930f, 0.09896835f, 
    -0.50717360f, -0.33532161f, -0.31270823f, 0.03359009f, -0.03088833f, -0.01901209f, -0.24802634f, 0.60129082f, 
    -0.12767205f, 0.20910375f, -0.19923434f, 0.29011068f, 0.11054228f, -0.05689720f, 0.08819725f, -0.16570678f, 
    0.37639493f, -0.39783701f, 0.29348585f, -0.11495977f, 0.10130403f, 0.33281219f, 0.03346748f, 0.54738188f, 
    0.01452793f, 0.20213971f, 0.06612208f, -0.27625927f, 0.46583357f, -0.00270137f, 0.21076731f, 0.02560812f, 
    -0.38868564f, 0.47276464f, -0.20934682f, 0.34560776f, -0.17875060f, 0.07653179f, 0.04038869f, -0.11959997f, 
    0.21161544f, -0.03450355f, 0.34191558f, -0.21744093f, 0.21863683f, 0.41160110f, 0.11370190f, 0.47158545f, 
    -0.13376470f, 0.23252364f, -0.18771857f, -0.12974308f, 0.23496062f, 0.09119464f, 0.12599653f, -0.18575354f, 
    0.04942935f, 0.16625975f, 0.08119570f, 0.31664655f, 0.14302208f, -0.01440773f, 0.33329365f, -0.06093600f, 
    0.11666421f, -0.15235788f, -0.17463720f, -0.00406570f, 0.19956234f, 0.05868647f, -0.15995337f, -0.20156236f, 
    0.02003786f, 0.33677861f, 0.38878754f, 0.01219645f, -0.23142284f, 0.23668705f, 0.23049872f, 0.05949228f, 
    0.22913125f, 0.06445447f, 0.34659961f, 0.36784777f, 0.50598228f, 0.02059809f, -0.35106015f, 0.21097651f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05204437f, -0.08231658f, 0.00157192f, 0.04255116f, -0.04041108f, -0.03523664f, 0.05639796f, -0.06742974f, 
    -0.00533621f, 0.01548801f, -0.04949800f, -0.08622595f, -0.02630888f, -0.00291021f, 0.05667630f, 0.04963750f, 
    -0.06386155f, -0.01775812f, -0.05579644f, 0.01404637f, -0.00878823f, -0.01229819f, -0.05025118f, -0.02541153f, 
    -0.00323948f, 0.03628647f, -0.08198784f, -0.08546739f, -0.06378898f, 0.06907646f, -0.04882694f, -0.03016711f, 
    -0.08835845f, 0.02737516f, -0.04488068f, 0.06105032f, 0.06349330f, 0.00359679f, -0.10258710f, 0.04776882f, 
    0.01695751f, 0.00335776f, 0.01599340f, 0.00765185f, -0.10353055f, -0.06630072f, -0.04441041f, -0.07510551f, 
    0.07995533f, -0.07694779f, -0.00161965f, -0.01182324f, 0.02488913f, 0.00993144f, 0.03237702f, 0.03038033f, 
    -0.00030802f, 0.07970475f, 0.04529746f, 0.02612263f, -0.08159862f, 0.00581588f, -0.08563118f, -0.01426673f, 
    0.05444573f, -0.02307691f, -0.01653088f, -0.03728157f, -0.01562861f, -0.08682188f, -0.09294333f, 0.05442848f, 
    -0.07910389f, 0.04214018f, -0.04395282f, -0.04355340f, -0.06266735f, -0.06288202f, 0.07787292f, -0.08650292f, 
    -0.04481172f, -0.01439978f, -0.07127447f, 0.04599503f, -0.05416131f, -0.01761171f, 0.04557710f, 0.01428816f, 
    0.04284142f, 0.06200537f, 0.04381504f, -0.06551903f, 0.00439940f, -0.03895701f, 0.04895185f, -0.03010596f, 
    -0.10302524f, 0.04884590f, -0.02401146f, -0.05952850f, -0.07808241f, 0.00905918f, -0.00003881f, 0.04880951f, 
    -0.00619592f, -0.03048513f, 0.06310370f, 0.00371346f, -0.06987312f, -0.03718057f, 0.01740377f, 0.04468052f, 
    -0.01823099f, -0.02841462f, 0.02288052f, -0.01374907f, 0.02276970f, 0.03531397f, 0.00032263f, 0.05878360f, 
    -0.07710340f, -0.09390000f, 0.01944422f, -0.05938503f, 0.00073962f, -0.03046176f, 0.00792940f, -0.02228634f, 
    -0.02505879f, 0.05199149f, 0.04713801f, -0.00733202f, 0.01520576f, -0.03346488f, 0.06868529f, -0.15660986f, 
    -0.02276231f, 0.05554804f, 0.03284242f, -0.12401365f, 0.02768320f, 0.00983732f, -0.08539151f, 0.03321978f, 
    -0.00719225f, -0.11209251f, 0.00253585f, -0.05917301f, 0.08490185f, 0.04053864f, -0.10298131f, -0.12198791f, 
    0.02815519f, -0.04181623f, 0.04793932f, -0.05070082f, 0.02910121f, -0.07411679f, 0.00655724f, -0.08458616f, 
    -0.07242618f, 0.11867831f, -0.13327999f, -0.00205639f, 0.03691331f, -0.06796547f, -0.00904051f, -0.06074468f, 
    -0.02160539f, -0.00539870f, -0.00947748f, 0.02791855f, 0.04912937f, -0.00175185f, -0.06540868f, 0.07195284f, 
    0.07124597f, -0.05899342f, 0.00929494f, -0.09367539f, -0.04617352f, -0.01403656f, 0.01495364f, -0.13193841f, 
    0.05344905f, 0.04409790f, -0.08729501f, -0.06528620f, 0.01537702f, -0.05055540f, 0.00924677f, -0.05974542f, 
    -0.04615629f, -0.02749050f, -0.06542039f, 0.04995847f, -0.03842343f, -0.08377061f, -0.08532663f, 0.05036144f, 
    -0.08839891f, 0.07175820f, -0.01346278f, -0.09431515f, 0.01011855f, -0.13786355f, -0.00057584f, -0.04825146f, 
    0.01861322f, -0.07742350f, -0.11313634f, 0.04204981f, -0.00522760f, -0.01959373f, -0.04377694f, 0.02362704f, 
    -0.06814066f, -0.01086131f, -0.07711320f, -0.00074599f, 0.04144857f, -0.03708259f, 0.07723759f, 0.02871631f, 
    -0.04164584f, -0.10679501f, -0.10731918f, 0.08264159f, -0.04002017f, -0.05992646f, -0.03950074f, -0.07855861f, 
    -0.04225487f, -0.04511826f, 0.01236263f, -0.11403152f, -0.06797581f, -0.05399384f, 0.06048108f, 0.02063001f, 
    0.04825293f, 0.03649255f, -0.04442221f, 0.06286681f, -0.01307810f, 0.06304352f, -0.00201268f, 0.00182832f, 
    -0.02350566f, -0.01958534f, 0.03374459f, 0.00081468f, -0.07325006f, 0.05688425f, -0.02699371f, -0.09008825f, 
    -0.08970416f, -0.12252611f, -0.00724977f, -0.04513486f, -0.01707132f, -0.19741966f, -0.07190885f, -0.02232148f, 
    0.03762431f, -0.05393942f, 0.01627465f, 0.06968829f, 0.10816047f, 0.20460875f, 0.14642070f, -0.08510683f, 
    -0.15960914f, 0.05786702f, 0.04732555f, 0.06014473f, 0.22641924f, -0.18948957f, -0.12264438f, 0.02777936f, 
    0.23223270f, -0.19255385f, 0.07445722f, -0.09808225f, -0.03629047f, -0.24346124f, -0.00346180f, 0.32889181f, 
    0.00472813f, -0.20810689f, 0.17404771f, -0.01496480f, -0.03009280f, -0.05760350f, 0.10360301f, -0.06412464f, 
    0.01990239f, -0.21203743f, -0.09894016f, 0.01105284f, 0.20500489f, -0.01670953f, -0.24957138f, 0.17861187f, 
    0.35770190f, 0.14845403f, 0.10480454f, 0.16379221f, -0.03574650f, -0.02304910f, 0.16554350f, -0.09923780f, 
    -0.03193723f, 0.32543847f, 0.26237833f, 0.01291842f, 0.11219977f, -0.00521183f, 0.04984888f, 0.29215091f, 
    0.23232111f, -0.11638429f, 0.00614814f, -0.16272438f, 0.29083881f, 0.01276059f, 0.60133284f, -0.08746595f, 
    -0.39322972f, 0.26958045f, -0.01652758f, -0.05367637f, -0.00997241f, 0.30236360f, 0.05647089f, 0.03123053f, 
    0.02837390f, -0.07651789f, 0.26130399f, -0.05060658f, 0.12016355f, 0.07486041f, 0.41912541f, -0.03830260f, 
    0.19239697f, 0.25926849f, 0.02423629f, -0.07757095f, -0.02440877f, -0.02503368f, -0.19691595f, -0.21865083f, 
    0.14247401f, 0.14111565f, -0.05947926f, 0.10916059f, -0.07939531f, 0.04616313f, 0.14163429f, -0.01064970f, 
    -0.15581797f, 0.30192965f, -0.00173583f, -0.07970200f, -0.01643384f, 0.38113862f, -0.09293785f, -0.22338176f, 
    0.08653890f, 0.11134548f, 0.10671464f, -0.01866029f, 0.11621978f, -0.09200250f, -0.03738195f, 0.06085122f, 
    0.22701761f, -0.08381131f, 0.13759083f, -0.02467518f, 0.16667800f, 0.41042319f, 0.05798551f, 0.16001965f, 
    -0.05800324f, -0.04906690f, -0.04377725f, 0.06059688f, -0.07150756f, -0.04507640f, -0.03788866f, 0.02934503f, 
    -0.04425672f, -0.01575918f, -0.03886161f, -0.03232750f, -0.02522896f, -0.02550191f, -0.05938309f, -0.07044058f, 
    0.00569303f, -0.04478808f, -0.01302536f, 0.06774286f, 0.01399523f, 0.00359681f, -0.08565835f, -0.07845713f, 
    -0.00130944f, 0.02844215f, -0.07357633f, 0.02982338f, -0.07339598f, -0.04505278f, -0.00069920f, 0.08303912f, 
    -0.03936895f, -0.00383507f, -0.05823461f, 0.03037148f, 0.02427739f, 0.03209509f, -0.00253895f, 0.04255051f, 
    -0.06504426f, -0.08195961f, -0.03202203f, 0.05108278f, -0.00718605f, -0.00780102f, -0.07597274f, -0.11260641f, 
    -0.01655987f, -0.09711468f, -0.05428831f, -0.05257040f, 0.00355935f, 0.05212388f, -0.11440243f, -0.10509340f, 
    -0.05184228f, -0.01178702f, 0.00187115f, -0.04010275f, 0.04558254f, -0.08258259f, -0.03567563f, -0.07422998f, 
    0.02374149f, -0.08813234f, 0.02923580f, -0.06284672f, -0.09750286f, -0.06196714f, -0.00458785f, -0.01485500f, 
    0.01627922f, 0.03335545f, -0.06154304f, -0.07008208f, -0.02204979f, -0.01647702f, -0.06186016f, 0.06326189f, 
    -0.06719889f, 0.03886572f, -0.08863726f, -0.09393250f, 0.00521014f, -0.08633245f, -0.03766226f, -0.08162790f, 
    -0.04257146f, 0.00332157f, 0.02806620f, 0.00822698f, -0.07508168f, 0.02646652f, -0.07823871f, -0.04652042f, 
    -0.02363157f, -0.01518777f, -0.10489650f, -0.06483193f, -0.07193396f, 0.00984687f, -0.00913677f, 0.04120848f, 
    0.06203117f, 0.01419078f, 0.05718083f, 0.05186330f, -0.08749881f, 0.03427736f, -0.08834370f, -0.03703598f, 
    0.05588143f, -0.03251934f, 0.02308969f, -0.08975685f, -0.09688358f, -0.06086379f, 0.02984516f, -0.09848781f, 
    -0.07682849f, 0.03745230f, -0.03999491f, 0.06950556f, 0.04529238f, 0.01419097f, 0.01843356f, 0.00025140f, 
    -0.08467180f, -0.10256618f, -0.06541595f, -0.07248079f, -0.10052843f, -0.09937939f, -0.05542275f, 0.02570006f, 
    -0.02306121f, 0.04803164f, -0.05120401f, -0.05754729f, -0.12454338f, -0.08000032f, 0.00583191f, -0.04259820f, 
    -0.06899273f, -0.00255403f, 0.06761564f, 0.02875023f, -0.04296320f, -0.12668774f, -0.01341298f, -0.00607993f, 
    0.05062104f, -0.07841927f, 0.00577471f, -0.00847791f, -0.06671163f, -0.01651792f, -0.12690067f, -0.02629333f, 
    -0.05654440f, 0.01135560f, 0.02814088f, -0.03397188f, -0.01245701f, -0.06773034f, -0.05510520f, -0.11769167f, 
    -0.06175531f, -0.08941879f, 0.00695434f, 0.00655366f, 0.02694257f, -0.12503248f, 0.07447922f, -0.09735297f, 
    0.01155648f, -0.05215066f, 0.02051598f, -0.07190090f, -0.04823412f, -0.02217519f, -0.05582014f, -0.03078758f, 
    -0.08119517f, -0.09603134f, -0.07667765f, -0.06561021f, -0.06906125f, -0.01708852f, -0.00131332f, -0.08546895f, 
    0.01138657f, 0.04392415f, -0.02432157f, 0.05206126f, -0.07170872f, -0.07370732f, 0.03238008f, -0.02576286f, 
    -0.03824660f, -0.09044708f, 0.01726845f, 0.02703070f, -0.00481005f, -0.08690567f, 0.01168576f, -0.00970652f, 
    0.02944580f, -0.01546276f, -0.07144667f, -0.12319682f, -0.06333169f, -0.01659931f, -0.08243568f, -0.03595065f, 
    -0.04568424f, -0.05230961f, -0.01542234f, -0.00921935f, -0.12760444f, -0.04490906f, 0.03495326f, -0.10366007f, 
    0.05438870f, 0.01385112f, 0.04169994f, 0.03357210f, 0.02636056f, -0.11573181f, -0.10943440f, -0.04240697f, 
    -0.01316226f, -0.06048240f, 0.06078956f, -0.00996092f, -0.06984772f, -0.01599022f, 0.02605185f, 0.03640008f, 
    -0.08049961f, -0.04033197f, -0.07064835f, 0.01342508f, 0.06024329f, -0.05539177f, -0.11457264f, -0.10164819f, 
    -0.05673590f, -0.02680678f, 0.07283017f, -0.10416795f, -0.13369533f, 0.04422311f, 0.01552893f, -0.06087832f, 
    -0.31094694f, -0.17476740f, 0.12532566f, 0.10456862f, 0.00076954f, -0.48933405f, -0.18076558f, -0.00131913f, 
    0.22157256f, 0.08002125f, 0.02815091f, 0.21837185f, 0.04066021f, 0.22491439f, 0.14078887f, 0.07426117f, 
    -0.14637992f, -0.06971297f, 0.28392711f, 0.00267950f, 0.24301741f, 0.14409152f, -0.05095638f, 0.12284593f, 
    -0.12680803f, -0.09719568f, 0.07013389f, 0.13652349f, -0.11113069f, -0.19516090f, -0.02236139f, -0.05874874f, 
    0.12409683f, -0.16483545f, -0.04421624f, -0.06503861f, -0.20738539f, -0.12306632f, 0.14690942f, -0.12342141f, 
    0.15715151f, -0.15899733f, -0.02485578f, 0.17624922f, 0.20613492f, 0.01881172f, -0.01660247f, 0.16078125f, 
    -0.14125749f, 0.15536012f, 0.08265731f, -0.09717967f, 0.19750503f, -0.04171875f, 0.08395556f, -0.24031065f, 
    0.17052424f, -0.02055470f, 0.21051989f, 0.03789130f, -0.07411964f, 0.13806602f, 0.04601304f, 0.24581890f, 
    0.09009784f, -0.05636235f, -0.01042319f, -0.26326239f, 0.12050813f, 0.13756834f, -0.04255831f, -0.00205261f, 
    -0.23138601f, 0.50593573f, 0.05620471f, -0.01855824f, -0.07784814f, 0.58949465f, -0.07407363f, -0.00501861f, 
    -0.00350938f, -0.34436023f, 0.15508473f, -0.01794977f, 0.12613401f, 0.00081202f, 0.38837278f, 0.04104938f, 
    0.16461971f, 0.07970452f, 0.06903907f, -0.19531670f, -0.01029134f, 0.06444705f, -0.01576654f, 0.09462167f, 
    0.04326207f, 0.12770243f, 0.13318717f, 0.03015781f, -0.21681869f, 0.18787841f, 0.07278870f, -0.20664549f, 
    -0.34707281f, 0.21067703f, 0.08269086f, -0.17854182f, -0.14119053f, 0.54675609f, -0.07579586f, -0.00620116f, 
    -0.11550447f, 0.08583456f, 0.07221107f, -0.05928032f, -0.16381675f, -0.21159714f, 0.17655967f, 0.11724552f, 
    0.01987028f, 0.03646355f, -0.16341566f, 0.31909204f, 0.01547948f, 0.16508958f, 0.10202459f, -0.15290979f, 
    0.03521957f, -0.00686422f, -0.00137046f, -0.02417125f, -0.03606521f, 0.03667606f, 0.07602990f, -0.00201486f, 
    0.03366641f, -0.07206587f, -0.04819345f, -0.02889701f, 0.06414393f, -0.07487967f, -0.01512028f, -0.02544568f, 
    0.00634579f, -0.01285866f, 0.06156311f, -0.04725580f, 0.01277039f, -0.05546577f, -0.08960598f, -0.06538270f, 
    0.03011692f, -0.02601828f, 0.04080945f, -0.10163744f, -0.08635859f, -0.06859346f, -0.08465984f, 0.00744079f, 
    0.01691556f, -0.05247726f, 0.06772146f, -0.09260619f, -0.06616683f, -0.08189593f, -0.04895686f, -0.01893241f, 
    0.02477238f, 0.01211101f, -0.07591517f, -0.02882770f, 0.06061781f, 0.00709560f, -0.04222780f, -0.06707770f, 
    -0.01431022f, 0.03078054f, -0.05353226f, -0.09293402f, -0.05916263f, -0.00031686f, -0.08006212f, 0.00929162f, 
    -0.03026410f, -0.08095603f, -0.05830411f, -0.02160049f, -0.09040047f, 0.00217484f, -0.09962861f, -0.01282415f, 
    0.06066182f, 0.07773135f, -0.09456759f, -0.08207782f, -0.04878101f, 0.00740791f, -0.03144017f, 0.02119348f, 
    0.07434443f, 0.02666828f, 0.03583296f, -0.08944558f, 0.07722507f, 0.05526803f, 0.02361407f, 0.03413764f, 
    0.06016105f, 0.04712194f, 0.02078798f, -0.09657314f, 0.00331124f, -0.10160354f, -0.04593830f, 0.03270929f, 
    -0.03976469f, 0.00121789f, -0.06607796f, -0.03800227f, 0.03927337f, 0.02915166f, -0.07224542f, 0.02347173f, 
    -0.02957330f, -0.05614298f, -0.01229143f, 0.04858420f, 0.02050675f, 0.01496449f, -0.00366101f, 0.03353563f, 
    -0.00380241f, -0.06482034f, -0.01611286f, 0.06743512f, 0.03971608f, -0.01861712f, 0.07225783f, -0.08091444f, 
    0.00063606f, 0.03560732f, 0.06570596f, -0.01673085f, -0.11032530f, -0.04081816f, 0.05662073f, -0.08760000f, 
    0.05207633f, -0.10663608f, 0.03468894f, 0.07185791f, -0.07354432f, 0.04924889f, -0.02724325f, 0.04450711f, 
    -0.07120048f, -0.04089612f, -0.08902287f, -0.06282660f, 0.01679279f, -0.00210822f, -0.07578887f, -0.03682937f, 
    -0.02443586f, 0.08730185f, -0.04658575f, 0.01095940f, -0.03867444f, -0.07912049f, 0.05948545f, -0.00550520f, 
    0.00556945f, 0.01987913f, 0.07177627f, 0.02298312f, 0.03469348f, -0.01130548f, -0.00409530f, 0.02484869f, 
    -0.07920677f, -0.03125941f, -0.04695843f, -0.07898489f, -0.03913194f, -0.06774473f, 0.07611296f, -0.02879895f, 
    0.00111346f, 0.02169655f, -0.08482916f, 0.01295113f, -0.04277666f, -0.00253988f, -0.04055184f, -0.08589452f, 
    0.02151239f, 0.01656082f, -0.09754252f, 0.05435162f, 0.03855557f, -0.06076528f, -0.05621430f, 0.01199938f, 
    -0.02917143f, 0.04181739f, -0.02732706f, -0.09159625f, -0.09279005f, -0.02289059f, -0.07764593f, -0.04333843f, 
    0.00809576f, -0.04782411f, -0.09549829f, 0.01724282f, -0.03761556f, -0.08983791f, -0.04261243f, -0.06878152f, 
    0.04031876f, 0.02916537f, -0.00887127f, 0.00718473f, 0.04730334f, 0.05544033f, 0.02388902f, -0.06148354f, 
    0.02234374f, -0.01743093f, -0.05821667f, -0.09513214f, 0.05418471f, -0.04500610f, -0.08759740f, -0.06923586f, 
    0.02604325f, -0.10840011f, -0.05737574f, -0.05517000f, 0.00937826f, 0.06127501f, 0.04456634f, 0.02407992f, 
    0.06363980f, 0.06512322f, -0.01140977f, -0.05924620f, -0.05141201f, 0.02547730f, -0.06154716f, -0.04962514f, 
    0.03507411f, 0.03935467f, -0.00259719f, -0.06418347f, 0.01581625f, -0.01814694f, -0.01853487f, 0.03641934f, 
    -0.08779186f, 0.03366316f, -0.08858977f, -0.04393247f, 0.05509068f, -0.03170288f, -0.02602515f, -0.07206187f, 
    -0.00003876f, -0.00469268f, -0.08923048f, -0.02315227f, -0.08351223f, -0.01867093f, 0.06507375f, 0.05846222f, 
    0.02688985f, -0.01221973f, -0.02148217f, 0.02071244f, -0.02377108f, -0.01306763f, -0.02485609f, -0.09545095f, 
    0.39306390f, -0.21405570f, -0.29513642f, -0.29166472f, -0.05813992f, -0.20904706f, -0.11204078f, -0.17613228f, 
    -0.11073840f, -0.00146635f, -0.01316674f, 0.22464921f, 0.36634392f, 0.01458108f, 0.09244464f, 0.07886764f, 
    0.05108317f, 0.16169631f, 0.16948573f, 0.07511102f, 0.03187417f, -0.42897496f, -0.15292674f, 0.19646971f, 
    -0.67462909f, -0.01771584f, -0.25916055f, -0.23986684f, 0.18369587f, -0.02190634f, -0.01431264f, 0.32178256f, 
    0.03034386f, -0.36070868f, 0.12378345f, 0.00608777f, 0.25855365f, -0.05977187f, 0.13673012f, -0.20755544f, 
    -0.43391395f, -0.08954757f, -0.11550208f, -0.24616657f, 0.20666659f, -0.07666045f, -0.11911412f, 0.20639300f, 
    -0.45551026f, 0.04672811f, 0.02013960f, 0.13822705f, -0.04820231f, -0.02027941f, 0.09423680f, 0.20289673f, 
    -0.10428867f, -0.55195343f, 0.06279690f, -0.00527191f, 0.09051631f, 0.06208924f, 0.09240203f, -0.15660833f, 
    0.05290058f, -0.08621288f, 0.09402185f, -0.03196242f, 0.27551842f, -0.10766048f, 0.39165813f, -0.05118946f, 
    -0.51749766f, 0.06137247f, -0.02244558f, 0.05995689f, 0.02514334f, 0.21176736f, 0.20417336f, -0.05015977f, 
    0.12668642f, 0.23515791f, 0.14904042f, -0.16339090f, -0.04910005f, 0.30554724f, -0.03014549f, 0.19773945f, 
    0.02233162f, -0.01305690f, -0.09969140f, 0.19479875f, 0.22262041f, -0.08167286f, -0.35499457f, -0.52637523f, 
    0.11967652f, 0.34340471f, -0.11489646f, 0.15434997f, -0.01978289f, 0.03677983f, 0.14251339f, 0.17484334f, 
    0.21443525f, -0.24763939f, -0.14930528f, 0.08046021f, 0.11098918f, -0.17355599f, -0.12179541f, -0.11747479f, 
    0.01596978f, 0.04453827f, 0.04225829f, 0.11225427f, 0.18038306f, 0.06599700f, 0.00807379f, 0.09412935f, 
    -0.03241704f, -0.07810424f, -0.24046339f, -0.15468483f, 0.19352373f, 0.27145270f, 0.12112240f, 0.31246036f, 
    -0.07815162f, -0.35209063f, 0.11395726f, 0.54077613f, -0.04851588f, 0.16217220f, -0.31691796f, 0.17611705f, 
    0.55275667f, -0.08499908f, -0.12916911f, 0.21670251f, -0.11897816f, -0.15717432f, -0.10907173f, 0.01849904f, 
    0.01315253f, 0.05513421f, 0.20033169f, -0.03470109f, 0.13281205f, 0.20110025f, 0.12970613f, 0.13183187f, 
    -0.03957956f, -0.09663498f, 0.01910262f, 0.00988258f, 0.16619259f, 0.08094878f, -0.11134210f, 0.35596377f, 
    0.01386322f, 0.16731447f, -0.25375667f, 0.23894237f, 0.11747894f, -0.19151671f, -0.15639108f, 0.13738674f, 
    0.01882895f, 0.09847836f, 0.06493208f, 0.33199623f, -0.09240098f, 0.04398125f, -0.12021230f, 0.25379458f, 
    -0.17033890f, -0.14262789f, -0.09145273f, -0.10858384f, 0.08331788f, 0.01113883f, -0.10384175f, -0.04225401f, 
    0.16030474f, -0.21911986f, 0.52457225f, 0.06686007f, -0.13927369f, 0.43667558f, 0.00736593f, 0.15889820f, 
    0.32671949f, -0.04374928f, 0.01674210f, 0.25796345f, 0.03214318f, 0.02157896f, 0.14099786f, 0.00188257f, 
    -0.00089530f, 0.06664481f, -0.02279717f, 0.22836448f, -0.06691764f, 0.29435581f, 0.04535747f, -0.09741005f, 
    0.04313954f, -0.22424528f, 0.04104618f, 0.09105628f, 0.07810155f, 0.10403414f, 0.30758595f, -0.02175601f, 
    -0.21745241f, -0.44169420f, -0.08501141f, 0.06468274f, -0.08123472f, 0.02519125f, 0.24475205f, -0.02479082f, 
    0.36044383f, -0.10418867f, 0.37407172f, -0.03265424f, 0.17528433f, -0.04212105f, -0.27231055f, 0.12424309f, 
    0.19519779f, 0.55244100f, -0.10863307f, 0.05540115f, 0.04177900f, -0.20464738f, 0.01476226f, -0.06809326f, 
    0.13181762f, 0.53367734f, -0.12199306f, -0.15784143f, 0.31010139f, 0.03094978f, 0.18839982f, -0.00937109f, 
    -0.00975704f, 0.27903810f, 0.52020413f, 0.68781680f, -0.04155568f, 0.01261158f, -0.17888634f, 0.08738414f, 
    -0.39270365f, -0.04403295f, 0.22599430f, 0.25665206f, -0.07825095f, -0.08686333f, 0.10781720f, 0.03700573f, 
    0.39881727f, -0.05202800f, 0.01805844f, 0.02315656f, -0.16008361f, 0.32989508f, 0.22611149f, -0.05119573f, 
    -0.14057520f, -0.14216815f, 0.14098363f, -0.07859500f, 0.30189791f, 0.41199335f, 0.08918148f, -0.16585781f, 
    0.14948504f, 0.16080235f, 0.23418228f, 0.26924580f, -0.17211409f, -0.24001314f, -0.02512281f, -0.41367128f, 
    0.22160564f, 0.18675186f, -0.23146965f, -0.00662944f, -0.49825856f, -0.24669211f, 0.23692627f, 0.32497394f, 
    -0.10156678f, -0.01344350f, 0.24824737f, -0.23091628f, -0.10368484f, 0.24050486f, -0.08363049f, 0.17415760f, 
    -0.15746908f, 0.14136215f, 0.11579467f, -0.03791764f, 0.29102147f, 0.07182118f, 0.11185577f, -0.44860059f, 
    0.22146705f, -0.08183072f, 0.15209945f, 0.04211008f, -0.11344401f, 0.28165692f, -0.01527704f, 0.52016342f, 
    0.47082779f, -0.15064761f, -0.23606506f, -0.09150846f, 0.10527447f, -0.01456350f, -0.04983085f, 0.13827994f, 
    0.16329513f, 0.13668941f, 0.01571971f, 0.07971372f, 0.00266425f, 0.00586923f, -0.36546540f, -0.10839050f, 
    0.14139952f, -0.37890875f, 0.02319093f, -0.01489804f, 0.22127138f, -0.25370231f, 0.59682733f, -0.04488332f, 
    0.29474688f, -0.21319300f, -0.01775559f, -0.44349509f, -0.22115320f, -0.02183400f, 0.19857329f, 0.06214726f, 
    -0.13084586f, -0.50585157f, -0.03996770f, 0.24604872f, 0.00373988f, -0.12001203f, -0.34439898f, -0.29049161f, 
    0.09115274f, 0.39378935f, 0.06921545f, -0.07443634f, -0.21705516f, 0.43459255f, 0.25797379f, -0.22398728f, 
    -0.27351528f, -0.34227920f, 0.07164992f, -0.20284840f, 0.10026908f, -0.16238174f, 0.16078280f, 0.13515717f, 
    0.10337004f, -0.13544244f, 0.47398415f, 0.27094895f, 0.05378354f, 0.08287778f, -0.16854244f, 0.09334870f, 
    -0.05783435f, 0.10338325f, -0.04281091f, -0.02972897f, 0.02623678f, 0.21227926f, 0.41877475f, -0.28491026f, 
    -0.24498896f, -0.02655751f, 0.02501720f, -0.17279586f, -0.17362402f, -0.16716294f, 0.11023542f, -0.05531434f, 
    0.14886636f, -0.04416882f, -0.14151879f, -0.04582819f, -0.05155917f, 0.11311564f, 0.13132580f, -0.06802985f, 
    0.03409372f, 0.12805977f, 0.31090388f, -0.14321478f, 0.05827370f, 0.19783382f, -0.09733998f, -0.13786882f, 
    -0.02356771f, 0.21622039f, -0.08850034f, 0.03992248f, 0.01963747f, 0.21016593f, 0.18632366f, 0.17516394f, 
    -0.50749338f, -0.03741877f, 0.16249341f, 0.11821783f, -0.20523170f, 0.38793370f, 0.11584651f, 0.08642583f, 
    0.27984726f, 0.07232906f, -0.11019522f, 0.06794634f, 0.00753637f, 0.20369649f, 0.10073461f, -0.00098517f, 
    0.17500582f, -0.22858100f, -0.12381779f, 0.06768465f, 0.04387567f, -0.07058521f, 0.13849159f, -0.15713349f, 
    0.14939666f, 0.00392753f, 0.11401596f, 0.32709920f, -0.07725146f, -0.10873946f, 0.16353872f, 0.16785061f, 
    -0.07268845f, -0.24574089f, 0.00369403f, 0.02961290f, 0.04088040f, -0.48721752f, 0.02190381f, -0.03719057f, 
    -0.07172016f, -0.01570896f, 0.11928005f, 0.10197333f, 0.11397500f, 0.15513328f, -0.17903553f, 0.07806337f, 
    0.15101604f, 0.01499124f, -0.03379364f, -0.05916065f, 0.01293641f, -0.09975161f, 0.27204475f, -0.26747423f, 
    -0.03312562f, -0.49629900f, -0.28198567f, -0.05434893f, 0.17532644f, -0.27799621f, -0.11482655f, 0.09599435f, 
    0.20040292f, -0.25070208f, 0.02700619f, 0.02596300f, 0.16462737f, -0.18462141f, 0.07825194f, 0.07422558f, 
    0.12756836f, 0.03208431f, 0.06250748f, 0.00237185f, -0.13497749f, 0.14805026f, 0.23530300f, 0.14852178f, 
    0.15307426f, -0.01562724f, 0.17513509f, -0.21343830f, -0.07540306f, -0.35266438f, -0.55695963f, 0.00264784f, 
    0.02221661f, -0.23422782f, -0.02210197f, 0.00528154f, 0.04174682f, 0.04637575f, 0.15176035f, 0.13465603f, 
    -0.01655482f, -0.07540259f, -0.17049758f, 0.03637511f, 0.15826894f, 0.04740798f, 0.07301845f, 0.04041899f, 
    0.08260270f, -0.07687589f, 0.15726952f, -0.07933495f, -0.11945900f, -0.11281288f, 0.06682063f, -0.08599795f, 
    -0.20224994f, -0.17607479f, -0.00978700f, -0.01932969f, -0.05318900f, 0.05908097f, -0.19132482f, -0.10516887f, 
    -0.11581358f, -0.08630035f, 0.03982032f, 0.13231093f, 0.00974081f, 0.22316739f, 0.20193784f, -0.20291081f, 
    -0.44036782f, -0.17422305f, 0.08881365f, -0.02591477f, 0.02676331f, 0.14884126f, -0.22734831f, 0.08184933f, 
    0.71381766f, 0.13807273f, 0.21254067f, -0.18937969f, -0.01499658f, -0.09259861f, 0.00060933f, 0.07229257f, 
    0.20839921f, 0.28843179f, 0.07922221f, 0.21242803f, -0.05808938f, 0.07506421f, 0.13859724f, -0.40002233f, 
    0.08798061f, -0.09624407f, -0.00810317f, -0.08028000f, -0.06862721f, -0.05691497f, 0.14896229f, 0.15710609f, 
    -0.22152725f, -0.60455883f, -0.06875741f, 0.06089102f, 0.00700434f, 0.01764139f, 0.12551890f, 0.03546539f, 
    0.06305493f, -0.06275618f, 0.33210948f, -0.10594455f, -0.04348206f, 0.13216694f, -0.09916204f, -0.01957773f, 
    0.14679737f, 0.27793324f, 0.06909026f, 0.01682289f, 0.18991977f, -0.03850102f, 0.18454327f, -0.01572874f, 
    -0.01202020f, -0.02277182f, 0.03349899f, -0.23726903f, -0.01990857f, -0.11530185f, 0.02185564f, 0.10131054f, 
    0.06171921f, 0.25345135f, 0.14472690f, 0.04425637f, 0.20060517f, 0.00433907f, -0.00484873f, -0.40909639f, 
    -0.18170130f, 0.06035935f, 0.02641669f, -0.12023146f, 0.07241706f, -0.05004811f, 0.25893924f, 0.16849747f, 
    0.21500538f, 0.12024029f, 0.20589045f, 0.04922681f, 0.07911609f, 0.22992623f, -0.37962070f, 0.08080310f, 
    0.00505876f, -0.12390287f, -0.02411855f, 0.01153927f, -0.05772743f, -0.06471905f, -0.19439858f, -0.05691060f, 
    -0.10189219f, -0.02818851f, -0.03483995f, -0.02873009f, -0.06234118f, 0.01935190f, -0.16958500f, -0.06574090f, 
    -0.00171742f, -0.00038620f, 0.16087839f, -0.06983875f, -0.11534765f, -0.02035118f, -0.06403089f, -0.03697129f, 
    0.06383436f, 0.10071430f, 0.04186774f, 0.02011563f, 0.05783620f, 0.05817233f, -0.04539653f, 0.03404631f, 
    -0.11801627f, -0.09683143f, -0.02810529f, 0.05896526f, -0.00542520f, -0.06693216f, -0.08973923f, -0.09161268f, 
    0.03369073f, -0.01890113f, 0.00870217f, -0.05056331f, -0.07506891f, 0.09083264f, -0.00321931f, -0.07885382f, 
    -0.00587923f, -0.14163466f, 0.05868897f, -0.09190271f, -0.07624451f, -0.12039342f, 0.01055726f, 0.01518744f, 
    -0.09019196f, -0.01125680f, 0.08228908f, 0.04344570f, -0.03828935f, -0.01020657f, -0.09155293f, -0.05130781f, 
    0.14031972f, 0.07381509f, 0.04829545f, 0.05481467f, -0.01588132f, -0.01414815f, -0.01744831f, 0.00137696f, 
    -0.10827753f, -0.02672382f, 0.01833435f, 0.03800119f, -0.02134895f, 0.01020525f, -0.06704751f, -0.06733990f, 
    -0.13480274f, -0.06106211f, -0.11697610f, 0.06672400f, -0.13741997f, 0.06777812f, -0.05938898f, -0.12575853f, 
    -0.01506310f, -0.01835188f, 0.07009421f, 0.01323342f, 0.04238393f, -0.01967492f, 0.07801559f, 0.01342720f, 
    -0.02090460f, -0.07165502f, -0.09490687f, -0.12144215f, 0.02026449f, -0.06841071f, -0.10331748f, 0.07063130f, 
    0.02766419f, 0.07577230f, 0.05369593f, -0.08579027f, -0.01647025f, -0.11138268f, -0.01648328f, -0.07356775f, 
    -0.01465289f, 0.09965687f, -0.16682915f, -0.06002650f, -0.08889654f, -0.04979163f, -0.03821936f, 0.05188251f, 
    -0.10695103f, 0.01662592f, -0.11602676f, 0.07398439f, -0.14601879f, -0.09148023f, -0.05591214f, -0.07724853f, 
    0.06137848f, -0.13594204f, 0.14618023f, 0.58941525f, 0.03671670f, 0.06617066f, -0.06969360f, 0.34152034f, 
    0.37284228f, 0.07407302f, -0.12251527f, 0.23798236f, 0.09036332f, 0.01188901f, -0.17714517f, 0.04130684f, 
    0.00810068f, 0.02078873f, 0.17798688f, 0.00850125f, -0.06631160f, 0.26568487f, 0.12467143f, 0.12633398f, 
    -0.19018218f, 0.06825960f, -0.08573794f, 0.18877751f, 0.07462045f, 0.00947975f, -0.15107849f, -0.06309976f, 
    -0.05105994f, 0.12386733f, -0.15250228f, 0.35092402f, 0.08173586f, 0.03126521f, -0.02231986f, 0.12422065f, 
    0.40088418f, 0.27805635f, 0.32045349f, 0.32401612f, -0.04539502f, -0.07426961f, -0.04491151f, 0.10485069f, 
    -0.43495199f, -0.12798572f, 0.03144735f, -0.15980859f, 0.20693065f, 0.16604051f, -0.13868049f, 0.11770376f, 
    0.10198361f, -0.08707458f, 0.35011673f, 0.26192212f, -0.23173825f, -0.12735775f, 0.13779238f, 0.16381721f, 
    -0.01579063f, 0.15584360f, -0.03083747f, -0.06258211f, -0.12992069f, 0.07741752f, -0.35626054f, 0.00438371f, 
    0.44866922f, -0.41505986f, 0.05256215f, 0.17113793f, 0.03757345f, 0.20225731f, 0.05645407f, 0.02536191f, 
    -0.09604023f, -0.00372852f, -0.19834851f, 0.16204321f, -0.04887202f, 0.03216366f, 0.15170848f, -0.05520478f, 
    0.08973331f, -0.30603126f, 0.04695309f, -0.16360138f, 0.08594879f, 0.06176659f, 0.07279529f, 0.17334448f, 
    0.13513151f, -0.15241975f, 0.49204329f, -0.03387806f, 0.12760201f, 0.33524352f, -0.17924312f, 0.20919538f, 
    -0.01612929f, -0.08057123f, 0.11787625f, 0.09772885f, -0.11054431f, -0.09645019f, 0.05875021f, 0.07539617f, 
    0.02705420f, 0.05351548f, -0.06770393f, -0.05760344f, 0.24527365f, -0.11134494f, 0.08752315f, -0.03832554f, 
    0.00959993f, 0.13716289f, 0.23317562f, 0.54612190f, -0.10092828f, 0.13593538f, 0.10481482f, 0.11303423f, 
    0.01388586f, -0.02011715f, -0.03171352f, -0.04081018f, 0.00649918f, 0.08348047f, 0.08155472f, -0.11023087f, 
    0.01652407f, 0.04651338f, 0.04932531f, -0.05160658f, 0.04661380f, 0.02480566f, -0.07318422f, 0.07393187f, 
    -0.04696608f, 0.04325503f, -0.09015013f, 0.03966352f, 0.01219595f, 0.02462967f, -0.02649346f, -0.08697615f, 
    0.02677662f, -0.08330384f, -0.04415044f, 0.00254636f, -0.00410026f, 0.00344308f, -0.04357855f, 0.03159417f, 
    -0.08012136f, -0.04950834f, -0.04938581f, -0.04204506f, 0.02099835f, -0.03291984f, 0.00079997f, 0.01943741f, 
    0.00375139f, -0.03201840f, -0.09314527f, 0.02530165f, -0.10616536f, 0.00302106f, -0.00937111f, 0.00569984f, 
    -0.12147154f, 0.01271325f, -0.09416765f, -0.08428020f, -0.13129291f, 0.02669417f, 0.06376185f, -0.05772777f, 
    0.01649364f, -0.06389529f, -0.04148767f, 0.01024484f, 0.02516474f, 0.04741121f, -0.04071051f, 0.04821551f, 
    -0.04167150f, 0.05289166f, -0.04449513f, 0.08321271f, -0.02196968f, -0.03953768f, -0.08205872f, -0.03967857f, 
    -0.05846501f, -0.02594280f, 0.04901022f, -0.00123609f, 0.07578205f, -0.06330949f, -0.06683812f, -0.02965958f, 
    -0.04093146f, 0.03926407f, -0.00220501f, -0.02690535f, 0.04073409f, -0.07539086f, 0.05904610f, -0.09659587f, 
    -0.04373963f, -0.07215758f, 0.01943660f, 0.03842298f, -0.04061780f, 0.05062422f, -0.00142520f, 0.01694568f, 
    -0.02535170f, -0.05603621f, -0.07546869f, 0.05275906f, 0.04901203f, -0.07700016f, -0.02794344f, -0.12519385f, 
    0.00507698f, 0.05652606f, -0.09408270f, -0.08445749f, -0.08242682f, -0.08054417f, 0.04267162f, -0.05890349f, 
    -0.03342291f, 0.02212143f, 0.02506008f, 0.00295301f, -0.00251392f, -0.00493365f, -0.01103594f, -0.06298593f, 
    -0.02751217f, -0.06968424f, -0.08835890f, 0.05949786f, 0.02656330f, -0.01491882f, -0.08783079f, -0.08242344f, 
    -0.19887103f, -0.03048403f, 0.07902760f, 0.33285421f, -0.14591482f, -0.20187326f, -0.02946166f, 0.34880912f, 
    -0.12651829f, -0.04848827f, -0.05330991f, -0.19725519f, 0.00454516f, 0.15534134f, 0.01417802f, 0.01017251f, 
    -0.01108397f, -0.23724565f, 0.06914313f, 0.01905128f, 0.06695441f, 0.35153607f, 0.28542718f, -0.02196541f, 
    0.11350966f, 0.00905978f, 0.04947826f, 0.27036023f, -0.18018392f, 0.24265857f, -0.07156341f, -0.16783462f, 
    0.07430937f, 0.20992120f, 0.09077240f, -0.05460052f, -0.52005148f, -0.00579837f, -0.02161495f, 0.21601757f, 
    -0.06167732f, 0.33210677f, 0.17168592f, -0.12040208f, 0.00219601f, 0.10648652f, 0.18088923f, -0.07032146f, 
    -0.07853335f, 0.13563409f, 0.36148167f, -0.14578038f, 0.12287811f, 0.08913837f, 0.21991271f, -0.11392915f, 
    -0.15323390f, -0.01841292f, 0.19074893f, 0.23446970f, -0.03843341f, 0.25160030f, 0.18054985f, 0.18968260f, 
    0.16529435f, 0.04552832f, -0.07349251f, 0.24811649f, 0.16208582f, 0.11739502f, -0.30396923f, 0.18669650f, 
    0.31140506f, 0.30978256f, -0.05717716f, -0.08296123f, -0.00541350f, -0.18132739f, -0.32757938f, 0.02547514f, 
    0.06246829f, -0.07130087f, -0.00965006f, 0.05859017f, -0.03025628f, -0.01642711f, 0.27410024f, -0.05070056f, 
    0.24103358f, 0.07495704f, -0.01792061f, 0.11803953f, -0.12767728f, 0.03728221f, 0.01223558f, 0.00714557f, 
    -0.01632569f, -0.57178527f, -0.08089462f, 0.12019012f, -0.13362730f, -0.05182122f, -0.19032060f, 0.05084007f, 
    0.22391997f, 0.47609073f, 0.21345894f, -0.13049172f, -0.05040519f, 0.29529700f, -0.06065997f, -0.05482547f, 
    -0.19494227f, 0.08251838f, -0.03424362f, -0.09985866f, 0.48140508f, -0.15751486f, 0.13157992f, 0.12868370f, 
    0.15609922f, -0.21895967f, -0.15100452f, 0.13848455f, -0.06885060f, 0.10166639f, -0.09228197f, -0.10191767f, 
    0.12643901f, 0.02529176f, -0.07392355f, 0.20719273f, -0.06979914f, -0.12960824f, -0.02648815f, 0.08402611f, 
    0.04080784f, 0.08184838f, 0.19066407f, 0.13329065f, 0.11601100f, -0.18402420f, 0.11065249f, -0.07035141f, 
    -0.08234722f, 0.01578694f, 0.31684545f, 0.06050402f, 0.00972070f, -0.63020086f, 0.07039247f, 0.03873468f, 
    -0.00366147f, 0.01843532f, -0.55739903f, -0.27077064f, 0.09290990f, -0.31962410f, -0.12875912f, -0.03254995f, 
    -0.03585639f, -0.46056229f, 0.04022511f, 0.29527724f, 0.11716644f, -0.07636467f, -0.10677235f, -0.23566470f, 
    0.07639045f, -0.08822590f, 0.09079434f, 0.29754671f, 0.28326777f, -0.39475012f, -0.64866698f, -0.06457621f, 
    -0.61841130f, 0.01570150f, 0.09690162f, -0.09381919f, 0.03693791f, -0.07108605f, -0.31043771f, 0.01346423f, 
    0.13097925f, 0.04112978f, 0.14333302f, -0.28142449f, -0.01119081f, -0.08041852f, -0.13716167f, -0.06607281f, 
    -0.41398400f, 0.13573498f, 0.16336560f, 0.01032997f, -0.00878526f, 0.10585126f, -0.11956943f, 0.18741949f, 
    -0.22889441f, -0.00950331f, -0.02934022f, 0.07984310f, 0.05356524f, 0.29684541f, 0.22551104f, 0.07267902f, 
    0.03605234f, 0.16412203f, -0.21696141f, 0.02899907f, -0.14871325f, 0.04082793f, -0.01054904f, 0.05287461f, 
    -0.20206481f, 0.13873111f, -0.00173747f, 0.18843541f, 0.26031387f, -0.07803282f, -0.05788583f, 0.23732381f, 
    -0.16113973f, 0.24122304f, 0.28909835f, 0.04612428f, 0.03044547f, 0.24193710f, 0.16605349f, 0.25417548f, 
    0.04911426f, 0.18616548f, -0.26275986f, 0.23751770f, 0.05106214f, -0.08841908f, -0.34211960f, -0.03606923f, 
    0.58760071f, -0.01483096f, -0.01508279f, 0.23428538f, 0.10819515f, 0.04938144f, 0.04629698f, 0.04037622f, 
    -0.18814377f, 0.08275590f, -0.23396076f, 0.22126633f, -0.02662219f, 0.27507153f, 0.06493508f, 0.13947827f, 
    0.20210981f, 0.11852822f, 0.11702442f, 0.22938538f, 0.16107531f, 0.09130486f, -0.02138831f, 0.05380768f, 
    0.08124535f, 0.03963239f, 0.10795633f, -0.23695385f, -0.07126077f, -0.37780210f, -0.03086367f, 0.04786229f, 
    -0.00639230f, 0.05081618f, -0.03226815f, -0.03034802f, 0.15781364f, -0.38271779f, -0.00918371f, -0.21015796f, 
    0.41387969f, 0.05283597f, -0.79574788f, -0.39850926f, 0.04849622f, 0.17764919f, -0.08103505f, 0.06770770f, 
    -0.11104310f, -0.29107690f, 0.01711035f, 0.11763798f, 0.29135478f, 0.29873654f, 0.18722902f, -0.41372672f, 
    -0.57770032f, -0.39436814f, -0.13180596f, 0.39263883f, -0.13074078f, -0.48268661f, 0.12298980f, -0.08686166f, 
    0.38969094f, 0.06946467f, 0.19466451f, -0.40617329f, -0.15504484f, -0.10796580f, -0.76603806f, 0.23537758f, 
    0.12309209f, 0.48445693f, 0.03994554f, -0.25601941f, 0.03923822f, -0.22537501f, -0.14255379f, -0.07435326f, 
    -0.33995196f, 0.02181611f, -0.01638138f, -0.34030166f, -0.44869801f, -0.10732672f, -0.13068284f, 0.08806564f, 
    0.17540865f, 0.19946876f, -0.07549033f, 0.02156693f, 0.03219879f, 0.37342775f, 0.23793915f, -0.04528499f, 
    0.01000270f, 0.13961156f, 0.20477028f, -0.31534123f, -0.17681660f, -0.01276313f, -0.16359098f, 0.04858010f, 
    -0.08635299f, -0.02944623f, 0.09010179f, -0.08483434f, 0.12376134f, -0.03226443f, 0.06922148f, 0.30602238f, 
    -0.13625740f, -0.08794580f, 0.39729410f, -0.49787110f, 0.09950761f, -0.03350334f, -0.14241783f, 0.12294910f, 
    0.16821772f, -0.28485990f, -0.03755941f, 0.13802816f, 0.14615734f, -0.56252992f, -0.16299352f, -0.34944969f, 
    0.18558931f, -0.19809344f, -0.02461364f, 0.15911344f, 0.17216805f, -0.12651916f, 0.04360925f, -0.26752910f, 
    0.14611095f, 0.08589307f, 0.11217351f, 0.43839043f, 0.01153767f, -0.25273162f, -0.01193177f, -0.25868621f, 
    -0.01181697f, -0.42284974f, 0.01192457f, -0.11747387f, 0.18786487f, -0.20331471f, -0.20112887f, -0.20221572f, 
    0.10804906f, 0.06336401f, -0.04889444f, 0.22695614f, -0.02297454f, 0.09519858f, -0.06541329f, 0.02073418f, 
    0.17516914f, 0.06741469f, 0.09488189f, -0.03755827f, 0.02945812f, -0.01171745f, -0.09646992f, 0.11582547f, 
    -0.45535260f, -0.24090216f, 0.00214205f, -0.01594256f, 0.02044287f, 0.28917462f, -0.09098393f, 0.00864794f, 
    -0.01685121f, -0.23828095f, 0.12186366f, -0.08041635f, 0.03687546f, 0.00645451f, 0.11603106f, -0.22395413f, 
    0.00958686f, -0.25540000f, -0.04152693f, -0.02750862f, 0.12148260f, 0.18251950f, 0.02858804f, 0.20978686f, 
    -0.06628571f, 0.11578718f, -0.12428875f, 0.00465237f, -0.02309083f, 0.03530915f, 0.16872631f, -0.14345571f, 
    0.18782659f, -0.39759484f, 0.07376329f, 0.16618100f, -0.02061778f, 0.28570673f, 0.00654168f, 0.01706834f, 
    0.20606013f, -0.04645764f, 0.07006443f, 0.09904581f, 0.06683742f, 0.10044901f, 0.26022711f, 0.04633319f, 
    -0.28069147f, 0.31057516f, -0.05208681f, 0.08224887f, 0.01111946f, 0.35745475f, -0.02159842f, -0.09662442f, 
    0.04858090f, -0.21550255f, 0.14917865f, -0.07235356f, 0.04647402f, 0.15076040f, 0.09896420f, -0.00264633f, 
    0.02507895f, 0.12330791f, -0.10036059f, 0.02482149f, -0.03379847f, 0.05327122f, 0.20898841f, -0.04026819f, 
    0.04733433f, 0.10745776f, -0.11527484f, -0.12843706f, 0.03158431f, 0.07295425f, 0.17542335f, -0.14980158f, 
    -0.52327263f, -0.05653831f, 0.03919246f, -0.01975445f, 0.07422202f, 0.38858831f, -0.05060865f, -0.08601010f, 
    -0.23032543f, 0.29350749f, 0.03703646f, -0.04113811f, -0.35287568f, 0.01918582f, 0.06943679f, 0.15516727f, 
    0.15019666f, 0.06322183f, -0.11638875f, 0.00569431f, 0.02308323f, -0.08349155f, -0.01309274f, -0.03679294f, 
    -0.03501702f, -0.33969188f, 0.00197465f, 0.26841140f, 0.05682423f, 0.19317646f, -0.11274667f, 0.36585870f, 
    0.08135977f, -0.05974343f, -0.24667697f, -0.08191712f, 0.12994282f, 0.16612135f, -0.01041963f, 0.01359913f, 
    0.01229042f, -0.19318306f, 0.12632093f, -0.03760364f, 0.12207630f, 0.19300853f, 0.18686326f, -0.11925844f, 
    -0.18462135f, 0.04689958f, -0.07459512f, 0.41313127f, -0.18878004f, 0.05948807f, -0.04319392f, -0.24015488f, 
    -0.07417353f, 0.20740265f, 0.01976978f, 0.05582688f, -0.10354697f, 0.21508701f, 0.06797031f, -0.01549695f, 
    -0.35927233f, 0.23796812f, 0.18195821f, 0.09319431f, -0.08348974f, 0.04244290f, 0.04693402f, 0.00891913f, 
    0.64455426f, 0.06367469f, 0.32739127f, -0.23020515f, -0.07684957f, 0.06134375f, 0.05939494f, 0.06631181f, 
    0.23127039f, 0.14475566f, 0.22057082f, 0.21780913f, -0.15033796f, 0.09304900f, 0.03691782f, -0.09876362f, 
    0.12304652f, -0.08323614f, -0.06765864f, 0.16186571f, -0.15611902f, 0.06471597f, 0.05326429f, 0.03208886f, 
    -0.05310918f, -0.07071435f, 0.03062454f, -0.01489245f, -0.00887275f, 0.24494515f, 0.04478851f, -0.01325358f, 
    0.04390487f, -0.07542242f, 0.13520876f, -0.02786475f, -0.14384365f, 0.06508183f, 0.02858238f, -0.20507155f, 
    0.12694143f, 0.05602323f, -0.05408986f, -0.12273547f, 0.02054252f, 0.03081385f, 0.10035760f, 0.41226330f, 
    -0.04520959f, -0.26320294f, 0.07447928f, -0.24661948f, 0.02908387f, -0.08764776f, -0.16137806f, 0.16498473f, 
    0.21201670f, 0.11010769f, 0.27794766f, -0.06852318f, 0.07090794f, 0.03758235f, 0.06069586f, -0.36272675f, 
    -0.24803703f, 0.00218555f, -0.06279759f, -0.14237405f, 0.39552557f, -0.28559738f, 0.15175317f, 0.08575751f, 
    0.23236831f, 0.01067064f, 0.08474892f, 0.35413301f, -0.04174060f, 0.11061774f, -0.16219318f, -0.20530061f, 
    0.20429569f, 0.15669246f, -0.08838776f, -0.15939100f, 0.11665776f, 0.01833827f, 0.02888515f, 0.06313160f, 
    -0.04271878f, -0.01773693f, -0.04701642f, 0.06212225f, 0.31808969f, 0.27782741f, 0.30549610f, 0.01679253f, 
    -0.19761744f, 0.00098197f, -0.05082127f, -0.06889186f, 0.22328457f, -0.15095218f, -0.12471741f, 0.12247472f, 
    0.13929839f, 0.09286775f, -0.15195780f, -0.17394285f, 0.07371063f, -0.20787331f, 0.07516878f, 0.27819929f, 
    0.04466684f, -0.21253669f, 0.28830299f, -0.00726788f, 0.05840411f, 0.11633638f, 0.26851222f, -0.00847226f, 
    -0.49711055f, -0.04662946f, -0.12762995f, -0.27868873f, 0.07570706f, -0.07295598f, -0.09050225f, -0.08888283f, 
    -0.36673072f, 0.33260632f, 0.32541567f, 0.15240343f, -0.01906852f, 0.04049891f, 0.05012399f, 0.15412030f, 
    -0.16289525f, 0.08577204f, -0.08517467f, 0.02207590f, 0.19714034f, -0.06665318f, 0.10966168f, 0.12574734f, 
    -0.05257187f, 0.10578865f, -0.08624528f, -0.49911419f, 0.26329505f, -0.06796569f, 0.28486890f, 0.01250448f, 
    -0.10932167f, 0.24247164f, 0.02125135f, -0.02727639f, -0.05287740f, 0.20910384f, 0.07679475f, 0.04181760f, 
    0.21200602f, 0.31191805f, 0.30904943f, -0.19923818f, -0.05635096f, 0.15759848f, 0.28783795f, 0.15853754f, 
    0.27844676f, 0.16929881f, -0.08449242f, 0.01629557f, 0.12280213f, -0.05500862f, -0.35441479f, -0.20501892f, 
    0.10627232f, -0.02520117f, -0.03015362f, 0.08058997f, -0.13351078f, -0.03302161f, 0.23487145f, 0.06922195f, 
    0.08640821f, -0.16196504f, 0.04982733f, -0.09118612f, 0.09628776f, -0.12821957f, -0.04672369f, 0.04394250f, 
    -0.14790700f, -0.38525361f, 0.09921044f, 0.15132396f, 0.45938292f, -0.18832709f, 0.02457700f, 0.00866912f, 
    0.17972481f, -0.06608489f, -0.07473143f, 0.07347501f, 0.18495770f, 0.33147055f, 0.00995774f, -0.00040118f, 
    0.22384134f, 0.06124633f, -0.03880147f, 0.09469061f, -0.10304165f, -0.00037830f, -0.12188657f, -0.07060594f, 
    0.39772573f, 0.02208906f, 0.01470405f, 0.05573356f, 0.00141450f, -0.09924473f, -0.08314583f, 0.07072344f, 
    0.14563760f, 0.07496736f, -0.06887379f, -0.07575111f, -0.03094264f, -0.04635024f, -0.05973897f, 0.07093135f, 
    -0.12440944f, 0.11045731f, 0.19764781f, 0.11924525f, 0.08143327f, -0.16260450f, 0.00769017f, 0.07263140f, 
    -0.03941157f, 0.18236923f, -0.24219669f, 0.30595127f, 0.16376734f, -0.21852332f, -0.09879118f, 0.20963070f, 
    0.56711113f, 0.15668729f, 0.09827345f, 0.06704312f, 0.01483050f, -0.06831290f, 0.08902689f, 0.13151725f, 
    -0.64330292f, 0.05013349f, -0.13164496f, 0.19157092f, 0.13294311f, -0.09878547f, -0.00754521f, 0.13318764f, 
    -0.06511757f, -0.24672176f, -0.18608217f, -0.00357939f, 0.08833929f, -0.03806227f, 0.05168734f, 0.08494802f, 
    0.00289331f, 0.13431789f, 0.03325818f, 0.00690015f, 0.06327434f, 0.04297532f, -0.30296740f, -0.05146026f, 
    0.48204675f, -0.15612939f, -0.02722182f, 0.03055825f, -0.05889430f, -0.11862525f, 0.09296481f, -0.03101595f, 
    0.07805242f, 0.09783782f, -0.20467107f, 0.13942504f, 0.02053644f, -0.05964338f, 0.06987898f, 0.06134957f, 
    -0.08685297f, -0.27956107f, -0.09689314f, -0.05028172f, -0.12498168f, 0.00526293f, 0.16917858f, 0.14490418f, 
    0.19800442f, 0.41671848f, 0.04410184f, 0.20182608f, 0.09231567f, 0.21361704f, -0.11132605f, 0.00664765f, 
    0.25306594f, -0.24225524f, -0.10244692f, 0.24920748f, 0.02154250f, -0.12170109f, 0.04829725f, 0.21980539f, 
    0.09569175f, -0.06115461f, 0.08731101f, 0.14760870f, -0.11582293f, 0.15136375f, 0.03799251f, 0.05958786f, 
    -0.11431423f, 0.12877317f, 0.12001986f, -0.24318743f, 0.04848285f, 0.00725182f, 0.30045193f, 0.27093953f, 
    0.04246967f, 0.07318828f, -0.10027152f, 0.04488881f, 0.06086457f, 0.05932086f, 0.03291495f, 0.02891339f, 
    -0.11564998f, -0.02918681f, -0.04797210f, 0.06447788f, -0.05225524f, 0.02650164f, -0.04152219f, 0.06697790f, 
    -0.01416535f, -0.09597928f, 0.04500936f, 0.01471398f, -0.10822656f, -0.08346735f, 0.02066509f, -0.05960061f, 
    -0.00717548f, -0.08971130f, -0.04423042f, -0.11487754f, -0.07468101f, 0.03019304f, -0.02079979f, 0.03308545f, 
    0.05830123f, 0.02436757f, 0.03887795f, -0.09647001f, -0.00412535f, -0.03175549f, 0.01428697f, -0.00843574f, 
    0.03498343f, 0.00542632f, -0.06620181f, -0.04453087f, -0.10528713f, -0.04385903f, -0.02163881f, -0.08646263f, 
    0.13933256f, -0.10565838f, -0.06058366f, -0.09097202f, -0.06322704f, -0.04419688f, -0.09960682f, -0.01572567f, 
    -0.09930702f, -0.04369235f, -0.06147445f, 0.06397091f, 0.03513459f, -0.02916963f, -0.08831926f, 0.04283079f, 
    -0.06576119f, -0.03534364f, 0.03838474f, 0.05037951f, -0.00601319f, 0.00621305f, -0.06101367f, 0.03229975f, 
    -0.06181196f, -0.07552964f, -0.04687957f, -0.01398741f, -0.07666548f, -0.05542170f, 0.03374841f, -0.04482330f, 
    -0.06273330f, -0.01334576f, -0.02326543f, 0.00734689f, -0.03819938f, -0.03510315f, 0.01140076f, -0.05427423f, 
    0.01783627f, -0.09603838f, 0.05512004f, -0.00094793f, 0.01595499f, 0.04728526f, -0.04232228f, -0.04916423f, 
    -0.05358312f, -0.01137392f, 0.00366000f, 0.06817066f, -0.10053718f, -0.03049714f, 0.05329708f, 0.02413864f, 
    0.00940514f, 0.02621167f, -0.02188702f, 0.04452309f, 0.04119892f, 0.00672718f, 0.09944902f, -0.02656389f, 
    -0.01861240f, 0.06726548f, 0.07281189f, -0.08944591f, -0.01140130f, -0.00400409f, -0.01176578f, -0.09729178f, 
    -0.06378942f, 0.02500578f, 0.00021801f, 0.03478570f, 0.04537565f, 0.04080993f, -0.05112886f, -0.03600468f, 
    0.06891023f, -0.05068506f, -0.00459524f, 0.20555693f, 0.19485399f, -0.13577265f, -0.48380452f, 0.38518086f, 
    -0.08079344f, 0.07884179f, 0.06673247f, 0.15179937f, 0.14381212f, 0.02377372f, -0.00040564f, 0.08224269f, 
    0.08892548f, -0.04773998f, -0.09421517f, 0.04237709f, 0.04621847f, -0.03656840f, 0.18197699f, 0.00258286f, 
    -0.24887429f, -0.16823119f, -0.39786980f, -0.07934905f, 0.13094583f, 0.07184142f, -0.23257579f, -0.21288465f, 
    0.05588176f, -0.06304377f, -0.04035150f, 0.17755254f, 0.09899592f, 0.22877510f, -0.09739181f, -0.46152380f, 
    -0.47438642f, 0.12575808f, -0.01922970f, 0.23068446f, 0.16360947f, -0.20020775f, 0.05612382f, 0.10478897f, 
    0.14386867f, -0.23730020f, 0.37838152f, -0.29138499f, -0.15276977f, -0.15751454f, -0.00396646f, 0.10625423f, 
    -0.02751552f, 0.30780730f, 0.31446540f, 0.08964511f, -0.25623173f, 0.20166324f, -0.09413056f, -0.53092879f, 
    0.03260033f, 0.05014868f, 0.17883556f, 0.38784206f, -0.26898745f, 0.09705212f, -0.29810235f, 0.13703130f, 
    -0.19267572f, -0.41620359f, 0.07920101f, -0.02046283f, -0.07267397f, 0.16076410f, 0.21131462f, -0.05766128f, 
    0.02230378f, 0.17720057f, 0.02990169f, 0.03878541f, -0.21527998f, 0.27046517f, 0.17271298f, -0.02774926f, 
    -0.05572348f, -0.11171094f, -0.02970776f, 0.33869994f, 0.15193032f, 0.07188656f, -0.14205326f, 0.15983666f, 
    0.03839749f, -0.09087676f, 0.21362890f, -0.33562732f, 0.01754093f, 0.03689241f, -0.15865506f, 0.41818953f, 
    0.06623936f, 0.41264352f, -0.01253902f, 0.10503893f, -0.01059818f, -0.44547999f, 0.09076784f, 0.11973559f, 
    0.36787128f, 0.26622266f, -0.17120987f, -0.16433682f, 0.22918853f, -0.17551520f, 0.06636997f, -0.17104355f, 
    0.05607254f, -0.01838606f, -0.32565165f, 0.59385943f, -0.07173935f, -0.21527284f, -0.16813789f, -0.12989852f, 
    0.27581871f, 0.17476188f, -0.11614004f, -0.05382241f, -0.17286755f, -0.06898137f, -0.04085449f, -0.09237354f, 
    0.37201947f, 0.00463288f, 0.06736491f, 0.06775925f, -0.00071420f, -0.07397262f, 0.02196225f, -0.08118869f, 
    0.04785785f, 0.18900467f, -0.06385250f, 0.06669080f, 0.02168072f, -0.01928422f, -0.06831702f, 0.14147329f, 
    -0.14325362f, 0.15837346f, 0.17027402f, -0.03199856f, 0.13105015f, -0.21036437f, 0.09688963f, 0.24752447f, 
    -0.03401046f, 0.16980238f, -0.03745573f, 0.34555587f, 0.05902771f, -0.16325417f, -0.05575414f, 0.13912357f, 
    0.48012617f, 0.17448173f, 0.26209953f, 0.05315816f, 0.04032336f, 0.00276877f, -0.09113602f, 0.03014149f, 
    -0.79163575f, 0.09344030f, -0.18775561f, 0.16861890f, 0.10180394f, -0.05331310f, 0.06574737f, 0.18665171f, 
    -0.02614853f, -0.32405862f, -0.11869612f, -0.04448549f, 0.10932469f, -0.03592156f, 0.09577660f, 0.07369937f, 
    -0.06588883f, 0.10732697f, 0.09180098f, -0.01046338f, 0.15370816f, 0.12817261f, -0.04458319f, 0.02417585f, 
    0.32656744f, -0.06954622f, 0.08196402f, 0.13787858f, -0.07438361f, -0.05276006f, 0.08054020f, -0.03909906f, 
    0.08305050f, 0.17689845f, -0.13331215f, 0.11546072f, 0.09149002f, -0.03376006f, 0.15546636f, 0.15837136f, 
    -0.04038050f, -0.25615516f, -0.09790379f, 0.00115071f, -0.02277249f, 0.11382468f, 0.06178484f, 0.00771180f, 
    0.21575700f, 0.33011350f, 0.00843725f, 0.26673707f, 0.14680892f, 0.30215827f, -0.07492582f, -0.01581189f, 
    0.44439897f, -0.45296901f, -0.16945666f, 0.21472006f, 0.03894827f, -0.06926437f, 0.06391805f, 0.33862638f, 
    0.16632295f, -0.31341094f, 0.03967706f, 0.16203825f, 0.20141630f, 0.25045884f, 0.00552030f, 0.09685580f, 
    -0.13770165f, -0.06713749f, 0.15054078f, -0.22335958f, -0.04134523f, 0.06153020f, 0.46625584f, 0.46699670f, 
    0.09725503f, -0.15136753f, -0.05702179f, -0.34503046f, 0.09669363f, -0.22633098f, -0.05910830f, -0.12232114f, 
    -0.03058215f, -0.06294788f, 0.01907150f, 0.13781643f, 0.20395514f, 0.19172667f, 0.12521046f, -0.06991197f, 
    0.05184456f, -0.04743031f, 0.01325408f, 0.02708773f, 0.00493063f, 0.09947079f, 0.02095515f, 0.13308686f, 
    -0.48453900f, -0.29803821f, -0.07269721f, 0.00991770f, -0.10440148f, 0.01929743f, 0.00075148f, 0.01298525f, 
    -0.02208143f, -0.16864319f, 0.38278303f, -0.04970242f, 0.04336112f, 0.08559669f, 0.26127464f, -0.04110654f, 
    -0.57281190f, 0.07652564f, 0.00355627f, -0.29225874f, 0.38282716f, 0.16726643f, -0.02217461f, 0.12229177f, 
    0.04402988f, 0.06547867f, 0.33656028f, 0.13508806f, -0.11873273f, -0.05278907f, 0.22405937f, -0.02897204f, 
    -0.06858107f, -0.33019835f, -0.11128008f, 0.18150271f, 0.14806910f, -0.01342455f, 0.04653868f, -0.01758653f, 
    0.20655413f, -0.06426834f, 0.10664631f, 0.18816097f, 0.02442752f, -0.00696290f, 0.21182442f, 0.07842255f, 
    -0.36188740f, 0.17771639f, -0.07015915f, -0.10677858f, -0.01046695f, 0.36970246f, -0.03392449f, -0.08144265f, 
    0.10571758f, 0.04207044f, 0.11415856f, -0.10772176f, -0.14659216f, 0.28140247f, -0.01292663f, 0.08756184f, 
    0.07951432f, 0.19580482f, 0.06554374f, 0.13040613f, 0.10684949f, 0.01219975f, -0.14118786f, -0.25509411f, 
    0.04264685f, -0.03917758f, -0.23661259f, -0.00228272f, -0.12929179f, 0.13523386f, 0.10699540f, 0.13859719f, 
    0.45890415f, -0.07060908f, 0.20233865f, -0.03408930f, 0.17621692f, 0.07453492f, -0.04064727f, 0.01946539f, 
    -0.10054517f, -0.04144915f, 0.02476552f, 0.06163581f, 0.20721906f, -0.09660099f, -0.05565401f, 0.07297078f, 
    0.10461761f, -0.10797586f, -0.29929721f, 0.07295924f, 0.09323216f, 0.26034594f, 0.06740656f, 0.14517559f, 
    0.11086407f, 0.44120747f, 0.08978041f, 0.06450467f, 0.36496884f, -0.07989993f, 0.05824166f, 0.26969245f, 
    -0.09582194f, -0.02120343f, 0.12041350f, 0.04515816f, 0.06465481f, 0.26636043f, 0.04124487f, 0.04507277f, 
    0.18211713f, 0.11461976f, 0.02754509f, -0.06527852f, -0.37829301f, 0.17419711f, 0.33632237f, 0.11453978f, 
    0.07758646f, 0.27021092f, -0.06949411f, -0.04032799f, 0.02156329f, 0.01086714f, 0.04883514f, 0.11433908f, 
    -0.09578178f, 0.08601083f, 0.40225217f, 0.06809430f, 0.00533804f, 0.18819319f, -0.17368291f, -0.18160768f, 
    -0.08002720f, 0.04630854f, 0.16134116f, -0.71763259f, 0.04018370f, 0.01617305f, 0.08385521f, -0.01193870f, 
    -0.49740523f, -0.13760836f, 0.10048017f, -0.11468776f, 0.02161413f, 0.22757414f, 0.10778264f, 0.13111344f, 
    -0.24982506f, -0.43570551f, 0.02441786f, 0.20014349f, -0.16532035f, -0.27340218f, 0.04407801f, -0.38396454f, 
    -0.06864602f, -0.00401170f, 0.28962162f, 0.05139461f, -0.14453153f, -0.05298455f, -0.00485163f, 0.03971326f, 
    0.13436116f, -0.84325254f, -0.02269837f, -0.32444099f, -0.06171191f, 0.18806405f, 0.12902556f, -0.09575871f, 
    -0.13689297f, 0.25930691f, -0.18812303f, 0.03834658f, 0.05665841f, -0.01968236f, -0.18783191f, 0.03217103f, 
    0.21713912f, 0.13376096f, 0.00323459f, 0.02488627f, -0.03201908f, 0.05782009f, -0.25407320f, -0.25362918f, 
    -0.16259475f, -0.12604541f, -0.21738401f, -0.09507330f, -0.25299555f, 0.13376111f, 0.17607768f, 0.18974206f, 
    0.31206435f, -0.47194999f, -0.01567274f, 0.06245136f, -0.20601144f, 0.14799169f, 0.31293663f, 0.26241922f, 
    -0.17546625f, -0.09575359f, -0.04985362f, -0.03513720f, 0.33940399f, -0.13477367f, 0.13443533f, -0.01479943f, 
    0.07580619f, -0.19374558f, -0.30113187f, 0.14376518f, -0.10280634f, -0.12265972f, 0.27397326f, -0.05796691f, 
    0.05065078f, 0.25124672f, 0.10309605f, 0.18703398f, 0.20384333f, 0.36576268f, 0.14225821f, -0.09584464f, 
    -0.39610586f, -0.08208212f, 0.09100350f, -0.14519867f, 0.03937623f, -0.13444607f, 0.05805427f, -0.08731433f, 
    0.09669044f, 0.08020099f, 0.07212098f, 0.06431194f, -0.05770133f, 0.21245095f, 0.24298194f, -0.22523011f, 
    0.13780835f, -0.13243215f, 0.19296712f, 0.08151949f, -0.06311828f, 0.17988077f, 0.06301443f, -0.34053901f, 
    -0.04611729f, 0.21630889f, -0.10771827f, 0.06400352f, 0.08648644f, 0.38362736f, -0.14529943f, 0.00300028f, 
    -0.10060213f, 0.05412255f, 0.12737831f, 0.42543814f, -0.23877980f, 0.29612845f, 0.39292040f, -0.11557038f, 
    0.29783663f, -0.05455512f, -0.17684126f, -0.06953463f, -0.17140430f, 0.08183007f, -0.14894898f, 0.09405354f, 
    0.33075774f, -0.04727309f, -0.08787479f, 0.03854326f, -0.02439251f, -0.03838652f, -0.00036020f, -0.19117165f, 
    0.02511929f, 0.02005737f, 0.14569037f, 0.40768045f, -0.27321219f, 0.07600962f, -0.36436304f, 0.25467169f, 
    0.13759057f, -0.23194706f, -0.01068497f, 0.04937761f, 0.00967049f, -0.18440875f, 0.17293222f, 0.04215265f, 
    0.03896334f, -0.01240813f, -0.04656342f, 0.27127564f, 0.02907002f, 0.04734508f, -0.22053014f, 0.03165156f, 
    0.05552682f, 0.08073903f, 0.03214404f, 0.19426157f, 0.18300101f, -0.08299675f, 0.24188319f, 0.19344737f, 
    -0.25386789f, -0.35772124f, 0.05526549f, -0.24448059f, 0.25623545f, -0.12438106f, 0.02275128f, 0.16002367f, 
    0.19956376f, 0.00060955f, 0.23109333f, 0.14742276f, 0.15344155f, -0.27001831f, 0.10272625f, -0.17152329f, 
    0.24300072f, -0.07280348f, -0.09644172f, 0.15946573f, -0.12953536f, 0.17304263f, 0.04099955f, 0.07001116f, 
    0.10651358f, 0.22049464f, -0.33228600f, -0.05225046f, 0.00446628f, -0.44568762f, -0.23742002f, -0.24289553f, 
    0.24208514f, 0.25294670f, 0.14171448f, -0.07201625f, -0.01474676f, 0.10692466f, -0.09132032f, 0.13415900f, 
    -0.00741251f, 0.02546217f, 0.15041338f, 0.08816617f, 0.05004461f, -0.02962757f, 0.17350036f, -0.01305105f, 
    -0.14499539f, 0.08608911f, 0.10556198f, -0.01724638f, 0.49311239f, -0.07830359f, -0.20843861f, 0.06444658f, 
    0.39931110f, -0.20977437f, -0.28599566f, -0.15240273f, 0.19067574f, -0.33873314f, 0.12624708f, 0.38306677f, 
    0.16484329f, -0.18694940f, 0.10296163f, 0.11649035f, -0.01377034f, -0.10279754f, 0.15040308f, 0.11999387f, 
    -0.20261250f, 0.05890337f, -0.05014866f, -0.20142101f, 0.06360085f, -0.18161194f, -0.17342040f, 0.11881072f, 
    -0.59975415f, 0.25806540f, 0.09919807f, 0.14292014f, 0.09405278f, -0.11459809f, -0.02287239f, -0.06603692f, 
    -0.14746882f, -0.03316334f, 0.03152947f, -0.09804687f, 0.18594100f, 0.08588382f, 0.00204025f, 0.68813908f, 
    -0.00848050f, 0.03946451f, -0.05033642f, -0.34980318f, 0.20551021f, -0.07564951f, 0.13893741f, -0.01695522f, 
    -0.15161778f, 0.48223275f, -0.04634801f, 0.21747857f, 0.01378728f, 0.01094794f, -0.07368550f, 0.02804107f, 
    0.09319671f, 0.27360591f, 0.17206003f, -0.14344014f, 0.14886777f, 0.06881721f, 0.48855865f, 0.10739118f, 
    0.11264762f, 0.00790969f, -0.08509383f, -0.04123751f, 0.17421581f, -0.01020530f, -0.28563184f, -0.11898565f, 
    0.02106931f, -0.11464731f, 0.07265951f, 0.32712379f, -0.02696437f, 0.06737440f, 0.04109426f, -0.02534331f, 
    -0.25072294f, 0.32645881f, -0.23177548f, 0.07835840f, 0.06223245f, -0.15250312f, -0.03529497f, 0.22428310f, 
    0.23060097f, -0.31803545f, 0.19676363f, 0.07124987f, 0.39238790f, -0.02952322f, -0.02628676f, -0.12026269f, 
    0.16554849f, 0.06281474f, -0.34973532f, -0.02553862f, 0.15190887f, 0.10120539f, 0.00155906f, 0.02708432f, 
    0.01981513f, -0.10390237f, -0.05437025f, -0.04445134f, 0.03488665f, 0.02987548f, -0.05984996f, -0.08177417f, 
    -0.04171641f, 0.06617007f, -0.02668332f, -0.06364058f, -0.07931840f, -0.06691321f, -0.08263146f, 0.03734074f, 
    0.02705831f, 0.05307823f, 0.03622982f, 0.08383100f, -0.06902771f, -0.08952919f, 0.05810641f, -0.04087995f, 
    0.01342606f, -0.04789382f, -0.00210540f, -0.00106154f, -0.07001053f, -0.00884520f, 0.06206646f, 0.04194224f, 
    -0.09846649f, -0.11081528f, 0.04368282f, -0.03196854f, -0.01012411f, 0.01925375f, -0.10598960f, -0.00658767f, 
    0.04418210f, 0.00141160f, -0.05075280f, -0.09059963f, 0.03155176f, 0.03323119f, -0.07392124f, 0.08217531f, 
    -0.04631714f, -0.09276389f, 0.02238228f, -0.09704164f, 0.03940205f, 0.02246327f, -0.08084638f, -0.10797746f, 
    -0.08421600f, 0.00747759f, -0.06044694f, 0.02882588f, -0.01902716f, -0.01573058f, -0.09356488f, 0.01104526f, 
    -0.08985290f, -0.08715202f, -0.09161462f, 0.02092296f, -0.06046234f, 0.01473115f, -0.00037183f, -0.08683727f, 
    -0.05121639f, 0.06970733f, 0.01976214f, -0.06356882f, -0.06459618f, 0.01232311f, -0.07458485f, -0.05104137f, 
    -0.02062382f, -0.04331471f, -0.08161567f, -0.06313002f, -0.00970679f, -0.08958407f, -0.00786907f, -0.11144689f, 
    -0.06513663f, 0.01637089f, 0.06721149f, -0.08059249f, 0.00046976f, 0.08464162f, 0.01454427f, -0.05625431f, 
    0.03423295f, -0.10574315f, 0.04224040f, 0.05543114f, -0.04511927f, -0.01937980f, -0.11626647f, -0.04901392f, 
    0.01546935f, 0.06704124f, -0.00579039f, -0.01705859f, 0.03592391f, 0.02751335f, -0.01977904f, 0.04283207f, 
    -0.05829184f, -0.02718251f, -0.03056846f, -0.06579417f, -0.04394564f, -0.07485617f, -0.00827995f, -0.02296747f, 
    -0.04864156f, 0.07536741f, -0.00502052f, -0.07207278f, -0.04283367f, 0.01556083f, -0.10289402f, -0.07108988f, 
    0.07185418f, -0.43664739f, -0.22767760f, -0.05439687f, 0.01229990f, -0.03688534f, -0.23780762f, -0.17176645f, 
    0.13721132f, -0.00039100f, -0.17271765f, 0.15230238f, 0.10508046f, 0.05366857f, -0.02443704f, -0.04467531f, 
    -0.00196022f, 0.02496895f, 0.10469436f, -0.06120920f, 0.07694363f, 0.04174696f, -0.05756827f, 0.09827978f, 
    -0.54232657f, 0.00944105f, 0.10549408f, 0.11634601f, 0.03039985f, 0.28591907f, 0.05731012f, 0.29816583f, 
    0.02566650f, 0.10962788f, 0.03836962f, 0.08474008f, -0.12453616f, 0.00726419f, 0.05189285f, 0.07837798f, 
    -0.32781425f, 0.07177265f, -0.06177303f, -0.16103642f, 0.04947628f, 0.13855481f, 0.20095649f, 0.04832155f, 
    0.04991884f, 0.18673548f, 0.04109741f, 0.12443893f, -0.14629273f, -0.08024330f, 0.29051968f, -0.07453065f, 
    -0.16451238f, -0.14445148f, 0.15395625f, 0.13683212f, 0.18500005f, 0.23610871f, 0.12202645f, -0.14891538f, 
    0.21554443f, -0.05160294f, -0.07026006f, 0.29656798f, 0.08692773f, -0.08718675f, 0.24718630f, -0.11467402f, 
    -0.08693772f, 0.16719598f, 0.07094173f, 0.03113964f, 0.02184820f, 0.03314000f, -0.05339452f, -0.12914969f, 
    0.05178700f, 0.03849282f, 0.24579251f, -0.06310795f, -0.12250539f, 0.07899547f, 0.18567878f, 0.03116464f, 
    0.09739684f, 0.10743856f, 0.09206581f, 0.17904891f, -0.06139420f, 0.02996084f, 0.02564660f, -0.10237668f, 
    0.13568868f, 0.13460080f, -0.06926560f, 0.06850071f, -0.18973568f, -0.02071114f, -0.07146030f, -0.16997808f, 
    0.45583448f, 0.01705237f, 0.14898980f, -0.21840660f, 0.04254508f, -0.05108089f, 0.01897950f, -0.01510888f, 
    -0.22680536f, 0.20887484f, -0.08578900f, -0.16778764f, 0.30764937f, -0.03439564f, -0.00759259f, 0.13699006f, 
    0.13327514f, -0.00875079f, 0.17139414f, 0.08759245f, -0.06098915f, 0.25516373f, -0.08589317f, 0.18992849f, 
    0.24772625f, 0.12076773f, 0.18865681f, 0.18266778f, -0.10899599f, 0.08286453f, 0.20882446f, 0.04829048f, 
    0.21068613f, 0.07318744f, -0.03600013f, -0.00969733f, -0.15265118f, -0.10953195f, -0.27761182f, 0.03900675f, 
    0.09266867f, 0.03869412f, 0.02040367f, 0.03147875f, -0.19743897f, 0.10714432f, -0.04144564f, 0.09044109f, 
    -0.03858894f, 0.05368403f, 0.21666014f, -0.00051915f, 0.17177971f, 0.14351392f, -0.03301553f, 0.46861127f, 
    -0.09742281f, 0.30926904f, -0.02484972f, 0.18561848f, 0.02058336f, -0.04049900f, -0.33728889f, 0.28795123f, 
    -0.04684376f, 0.16275540f, 0.26852131f, -0.21780717f, 0.11071270f, 0.02414370f, 0.02719524f, -0.27019972f, 
    -0.08378527f, -0.10206556f, -0.30964765f, 0.15734157f, 0.10663926f, 0.05694689f, -0.06481702f, 0.09134696f, 
    -0.09207117f, 0.16237286f, -0.02523910f, -0.06057540f, 0.06053399f, -0.26353529f, 0.04167854f, 0.22714318f, 
    -0.23618802f, 0.13898367f, 0.06516227f, -0.01384429f, -0.04620417f, 0.04391081f, 0.04423634f, -0.06583718f, 
    0.44381449f, -0.54784644f, -0.01764243f, -0.01302002f, 0.08242429f, 0.05804940f, 0.02435352f, 0.05177441f, 
    -0.26265001f, -0.13384682f, -0.58708084f, 0.20740364f, 0.08554922f, -0.19901361f, -0.36646724f, -0.12354878f, 
    -0.11891469f, -0.32795370f, 0.11085089f, 0.02394853f, -0.16054434f, -0.01727028f, 0.18786091f, 0.15722191f, 
    0.13099572f, 0.04012822f, 0.08453298f, 0.12642168f, 0.11954870f, 0.22514321f, -0.10870565f, -0.01942086f, 
    0.21351840f, -0.48488423f, -0.07760609f, 0.01669395f, -0.13413918f, -0.09825664f, 0.26184055f, 0.20918614f, 
    0.35834500f, -0.11750147f, -0.17301540f, 0.05676439f, -0.00099281f, 0.15618902f, -0.14984038f, 0.05673589f, 
    -0.35083821f, 0.03573875f, 0.08929852f, -0.01462200f, -0.17416199f, 0.10159034f, 0.14834507f, 0.23042187f, 
    0.01645330f, -0.28243196f, 0.08783419f, 0.23635851f, 0.09923510f, -0.03130795f, -0.22638454f, 0.34509462f, 
    0.49476406f, -0.07289650f, -0.15833722f, 0.20055713f, 0.01531323f, 0.08970665f, -0.05479997f, -0.03846197f, 
    0.03441353f, -0.13236156f, 0.08699381f, 0.07093583f, 0.02088634f, 0.16894315f, 0.05926475f, 0.15494847f, 
    -0.26509100f, -0.17211556f, -0.03839324f, 0.22052190f, 0.12046065f, 0.26283520f, -0.04515136f, 0.38207972f, 
    -0.06853719f, 0.06322895f, -0.09316778f, 0.18617551f, -0.02483588f, -0.09510081f, -0.20772319f, 0.05854014f, 
    -0.18118104f, 0.20031798f, 0.09706930f, 0.03527101f, 0.05773703f, -0.06200542f, 0.02090971f, 0.12729970f, 
    -0.26008657f, -0.12571400f, 0.14111182f, -0.07137873f, 0.05267420f, -0.01855329f, 0.04410437f, -0.03196146f, 
    0.06374920f, -0.01757622f, 0.40374002f, 0.27489433f, -0.12328720f, 0.22565189f, 0.10772438f, 0.05228795f, 
    0.15355636f, 0.08435249f, -0.16074429f, 0.09412593f, 0.03386273f, 0.13645974f, -0.21977818f, -0.01989673f, 
    0.20611739f, 0.04068359f, -0.06713860f, 0.15291384f, -0.03748706f, 0.11796239f, 0.16076718f, -0.03774869f, 
    -0.10293289f, -0.08456591f, -0.05828138f, 0.10433753f, -0.05390576f, -0.01820016f, 0.27162093f, -0.10495057f, 
    0.02250586f, -0.25956082f, 0.00238337f, -0.01664741f, -0.09658650f, 0.03388531f, 0.04039514f, 0.16451736f, 
    0.32635081f, 0.33357543f, 0.42123121f, -0.04572593f, 0.01137034f, 0.18657961f, -0.20302275f, 0.01099908f, 
    0.06979849f, 0.17754564f, 0.12861194f, 0.00210007f, -0.10535818f, 0.00158073f, 0.12179693f, 0.20748265f, 
    -0.17451747f, 0.39216700f, 0.03487712f, -0.07020410f, 0.17685747f, -0.04230317f, -0.04830140f, -0.10644437f, 
    -0.10791451f, 0.23620741f, 0.33322409f, 0.47865704f, -0.00891510f, 0.14210968f, 0.17971511f, 0.05261146f, 
    0.04205862f, -0.26555136f, 0.00869672f, -0.16252472f, 0.00545726f, 0.04652963f, -0.03945037f, -0.29177055f, 
    0.26608279f, -0.01266982f, -0.04274434f, 0.12722163f, -0.25380081f, -0.09545971f, -0.05493423f, 0.06615862f, 
    0.17454548f, 0.27707526f, -0.00327662f, 0.01741149f, 0.06226724f, -0.15063664f, -0.18127920f, 0.05531523f, 
    -0.10171137f, 0.07616919f, 0.27889594f, -0.26627833f, 0.11537470f, 0.08607418f, 0.09361413f, 0.56641042f, 
    -0.00118085f, 0.02302489f, 0.02003231f, -0.00621198f, 0.00392906f, -0.17702459f, 0.01869832f, 0.00447043f, 
    0.06577599f, -0.06037827f, -0.01042064f, -0.27843547f, -0.12766631f, -0.01026087f, -0.10391609f, 0.05818971f, 
    -0.19843160f, 0.09972105f, -0.19649310f, 0.38487151f, -0.05939117f, -0.18805365f, 0.18856481f, -0.03069011f, 
    -0.09403106f, -0.47982511f, -0.02657030f, 0.01380370f, 0.03097996f, 0.08847358f, 0.07528160f, 0.02309633f, 
    0.08543548f, -0.04815602f, -0.14318663f, -0.08936895f, 0.30769384f, -0.15408713f, 0.62393755f, -0.19458556f, 
    -0.09535963f, -0.12902322f, -0.07705712f, 0.02293482f, -0.02569642f, -0.18006425f, 0.07394458f, -0.07642688f, 
    0.04171052f, 0.04649113f, 0.11337824f, -0.01594231f, 0.23075294f, 0.11509232f, 0.02747599f, 0.03648607f, 
    -0.11862522f, 0.06687713f, 0.01404968f, -0.04954887f, -0.05291044f, 0.07905397f, 0.12631123f, -0.20611833f, 
    0.15530808f, 0.33482221f, -0.05898251f, 0.23859659f, 0.06487295f, -0.02213684f, 0.02777102f, -0.20685819f, 
    0.22717246f, -0.37470090f, -0.18455270f, -0.02207829f, 0.05177887f, -0.01345326f, 0.02118475f, 0.07006132f, 
    -0.27315894f, 0.21913779f, 0.11857381f, 0.01031191f, -0.10202640f, 0.29061744f, 0.07951256f, 0.17151263f, 
    0.09481049f, -0.01590682f, 0.37983176f, -0.25731674f, 0.09869525f, -0.07175965f, 0.15574110f, 0.24132571f, 
    -0.00590049f, -0.00893504f, -0.05479545f, -0.10505906f, 0.05420768f, 0.04645636f, 0.05666197f, -0.06182413f, 
    -0.04707528f, 0.03878812f, -0.00611601f, -0.08810122f, 0.05931802f, 0.04533622f, -0.04575228f, -0.06498135f, 
    -0.03312332f, -0.00827316f, 0.01319248f, 0.06238512f, -0.05747299f, 0.06630873f, -0.00074163f, -0.04683734f, 
    -0.08597561f, 0.06658909f, 0.06427278f, 0.04704101f, -0.06086633f, 0.01147283f, 0.02010472f, 0.07782748f, 
    0.00793828f, -0.11210000f, -0.06161799f, -0.01344235f, 0.05683884f, -0.00107120f, -0.01205702f, -0.05773078f, 
    0.07804920f, 0.06424467f, -0.05601294f, -0.03680470f, -0.05242585f, -0.06051609f, -0.02225258f, -0.04365806f, 
    0.09035473f, 0.06324840f, 0.02043845f, -0.00247129f, -0.06015233f, 0.04468351f, 0.04140631f, 0.06126915f, 
    -0.00236132f, 0.02124872f, 0.01597197f, -0.04488971f, 0.04343615f, -0.03652491f, -0.09685021f, -0.07562996f, 
    0.03989107f, -0.07786080f, 0.05468770f, 0.07584976f, 0.02196405f, -0.03536795f, -0.05035857f, -0.00555539f, 
    0.02378621f, 0.05728801f, 0.03149910f, -0.06410646f, 0.07976028f, -0.03591616f, -0.10625647f, 0.06333472f, 
    -0.09688861f, -0.01403474f, -0.10111717f, -0.09209572f, -0.08970311f, -0.04532783f, -0.02552988f, 0.01190473f, 
    -0.05286661f, -0.08877172f, -0.05329730f, -0.01500779f, -0.05649603f, 0.08279900f, 0.03900241f, 0.01924060f, 
    -0.01739540f, 0.01338722f, -0.02904454f, -0.09355686f, 0.04960540f, 0.03108483f, -0.06453848f, -0.10407674f, 
    -0.03375277f, 0.06845049f, 0.04281420f, -0.11102691f, -0.06019658f, -0.07125844f, -0.07301085f, 0.02097389f, 
    -0.07074716f, 0.05243334f, 0.06938518f, -0.01600408f, -0.00640848f, -0.08144157f, -0.04962882f, -0.09641232f, 
    0.02750893f, 0.02547976f, 0.05329888f, -0.01626693f, -0.08927979f, 0.07344437f, 0.02501523f, -0.08209766f, 
    -0.04541125f, 0.07119428f, 0.01604638f, -0.09770755f, -0.07761151f, -0.10805600f, 0.05617502f, 0.03109568f, 
    -0.02231009f, -0.02903614f, -0.05421246f, -0.11805867f, -0.07328186f, 0.08930203f, -0.04633344f, -0.04690987f, 
    0.02314072f, -0.03780812f, -0.03939530f, 0.03801344f, -0.10234425f, 0.00442726f, -0.12631750f, -0.07000425f, 
    0.06523468f, -0.06484369f, -0.02760512f, 0.06156175f, 0.01878407f, -0.05924638f, 0.03127531f, 0.01011469f, 
    -0.01157050f, -0.01604348f, 0.01494845f, -0.02467108f, -0.04082700f, -0.06625428f, -0.08624623f, -0.02843002f, 
    0.02452319f, -0.04752722f, 0.01313220f, 0.06751262f, -0.08345956f, -0.09051062f, -0.10132708f, 0.01014047f, 
    -0.02235701f, -0.05672090f, 0.11402959f, 0.02576841f, -0.04328832f, -0.05808486f, -0.07944831f, 0.04831517f, 
    -0.07318811f, 0.00565460f, -0.03556345f, 0.02465447f, -0.11735595f, -0.10087153f, 0.02071575f, -0.05423657f, 
    -0.02442621f, -0.07587299f, -0.13031046f, -0.07276325f, -0.04430462f, 0.03990055f, -0.09202451f, -0.05061476f, 
    -0.02289364f, -0.08406592f, 0.03526349f, -0.10661155f, 0.03951916f, 0.03777199f, 0.02419107f, 0.01350168f, 
    -0.06134801f, -0.01007138f, 0.01050599f, -0.11121830f, -0.10669157f, 0.00142165f, -0.08002271f, -0.04308142f, 
    0.01857533f, -0.10474360f, 0.00167880f, -0.08858248f, -0.01414267f, -0.07995895f, 0.03983418f, 0.08654346f, 
    -0.10843663f, -0.05730414f, -0.00643160f, 0.03112763f, -0.12357311f, -0.12416212f, -0.05923969f, -0.04924089f, 
    -0.07656483f, -0.07016513f, -0.03764760f, -0.04373296f, 0.01661060f, -0.01997693f, 0.04914064f, 0.04068298f, 
    0.04613638f, -0.04185956f, -0.04621740f, -0.01170124f, 0.03983148f, -0.02425981f, 0.02621788f, -0.05569672f, 
    -0.10827823f, -0.06761656f, -0.09185701f, 0.01178377f, -0.11174725f, -0.01556952f, 0.02952224f, 0.03090113f, 
    0.33588392f, -0.21162692f, -0.22381131f, 0.42397061f, 0.16063434f, 0.02294588f, -0.35437447f, 0.03765406f, 
    0.19353817f, 0.03981826f, -0.03168320f, 0.19481695f, 0.04025032f, -0.13108598f, -0.17019591f, -0.01707609f, 
    0.08855836f, -0.02630569f, 0.14393727f, 0.01855446f, -0.16178559f, -0.39416564f, -0.09118509f, 0.12388506f, 
    -0.20836781f, -0.15295950f, -0.29695266f, -0.52641320f, 0.19065736f, 0.29136795f, -0.33095872f, 0.53276163f, 
    -0.29993358f, -0.10984179f, 0.05563698f, 0.26822504f, 0.19005261f, 0.17081150f, -0.03197559f, -0.37082076f, 
    -0.32519627f, -0.17031789f, -0.03747615f, 0.16219765f, 0.14954677f, -0.03126918f, 0.02406851f, 0.02916743f, 
    0.47415304f, -0.23572251f, -0.11427917f, -0.15527943f, -0.22892147f, -0.07807964f, -0.14352326f, 0.24273196f, 
    -0.07791849f, -0.04956632f, 0.30742487f, 0.04899086f, -0.10803520f, 0.23230612f, -0.05309831f, -0.42494678f, 
    -0.09293573f, -0.00592671f, 0.24575561f, 0.25583541f, -0.26983082f, -0.17731076f, 0.45828378f, 0.06895302f, 
    -0.02475411f, -0.45643097f, 0.03645168f, 0.10491339f, 0.05654050f, 0.20898406f, 0.14050733f, -0.03595454f, 
    -0.16843319f, 0.28798613f, -0.12328830f, -0.04850560f, -0.24252214f, 0.25907007f, 0.26049927f, -0.09280191f, 
    -0.17230168f, -0.27292773f, -0.05291146f, 0.49987295f, 0.10502993f, -0.06009084f, 0.00222024f, -0.22878061f, 
    0.17647453f, -0.02218003f, 0.16645834f, -0.25931838f, 0.10490609f, 0.22022904f, -0.24897626f, 0.44060251f, 
    -0.12504975f, 0.10183066f, -0.25178176f, 0.20161930f, 0.07592569f, -0.46035749f, 0.23479643f, 0.04842279f, 
    0.40873089f, 0.48721984f, -0.17148332f, -0.19809686f, 0.32125655f, 0.00739340f, 0.21606319f, -0.04673904f, 
    -0.15418276f, -0.04374785f, 0.01725071f, 0.43132925f, -0.20644790f, -0.17790782f, -0.08721299f, 0.13686195f, 
    -0.10548063f, 0.04945631f, -0.11879981f, -0.10944561f, -0.00420685f, -0.07276767f, 0.03726009f, -0.03489932f, 
    0.06414799f, -0.00314653f, 0.05567080f, -0.04327269f, -0.06231232f, -0.03763650f, 0.00162610f, -0.05139506f, 
    -0.11982495f, -0.02034021f, -0.06225773f, 0.05372928f, -0.02430177f, -0.08064306f, 0.02854892f, 0.03407271f, 
    -0.06884848f, -0.05208062f, 0.00702903f, -0.09837010f, 0.04567393f, -0.06913310f, -0.10586184f, -0.07992327f, 
    -0.07978684f, 0.01573599f, 0.02081180f, -0.04386665f, -0.11042598f, 0.05126321f, -0.05329880f, -0.10276035f, 
    0.01078617f, -0.10794424f, -0.11629516f, -0.06061726f, -0.09547167f, -0.03272855f, -0.00094826f, -0.05040013f, 
    -0.02661368f, -0.06665476f, -0.03164396f, -0.01777282f, -0.04175748f, -0.04665360f, -0.08966310f, 0.04502121f, 
    -0.05301687f, -0.02163422f, -0.00506784f, 0.00739580f, -0.06127182f, -0.01477685f, 0.04491010f, -0.06509834f, 
    -0.02460143f, -0.06244028f, -0.11446136f, -0.08658417f, -0.04871202f, -0.04033364f, 0.04739933f, -0.05598279f, 
    0.01032655f, -0.03087426f, 0.01790617f, -0.03915231f, -0.03509863f, -0.03719376f, -0.10529164f, 0.07891497f, 
    -0.02561552f, 0.01127205f, -0.08199637f, -0.02089721f, 0.01549573f, -0.05723656f, -0.04047247f, -0.10669041f, 
    -0.07655685f, -0.05844485f, -0.02595798f, -0.00019915f, -0.02011240f, 0.06976017f, 0.03558337f, -0.07837278f, 
    -0.05377281f, -0.03055373f, 0.05291158f, -0.07883286f, -0.06539202f, -0.10557838f, -0.08079764f, -0.09627748f, 
    -0.07014723f, -0.01486237f, -0.10207938f, 0.02729562f, -0.04093222f, 0.06224874f, 0.05211814f, 0.00848990f, 
    0.05611983f, 0.00256196f, -0.04061596f, 0.02880293f, 0.03826042f, -0.05734095f, -0.08587512f, -0.04797741f, 
    -0.05770196f, 0.02484730f, -0.07576595f, -0.04120992f, -0.08920387f, 0.04310755f, -0.00792606f, 0.03066890f, 
    0.11036425f, -0.37789491f, -0.13167413f, 0.12957557f, 0.02984320f, 0.12741576f, -0.27989697f, -0.05380616f, 
    0.15886068f, 0.05722440f, -0.12105820f, 0.16103081f, -0.12484965f, -0.23336455f, -0.32601488f, 0.03875786f, 
    0.13464713f, 0.15127335f, 0.12893018f, 0.04782471f, -0.12455124f, -0.40253857f, -0.08270907f, 0.14510775f, 
    0.25873801f, -0.26864702f, -0.19330029f, -0.28052187f, 0.29173335f, 0.02194194f, -0.07945635f, 0.68128216f, 
    -0.02446418f, -0.16724667f, -0.02700086f, -0.00494090f, 0.23838745f, 0.01362061f, -0.53814310f, -0.36477703f, 
    -0.14185582f, -0.08589256f, -0.19359834f, 0.28923723f, 0.17770587f, -0.16042678f, -0.18969427f, 0.10030558f, 
    0.60598749f, -0.29160684f, -0.12700719f, 0.12300142f, -0.26962602f, -0.05881155f, -0.10363046f, 0.01456121f, 
    0.02952789f, 0.47444627f, 0.33231452f, -0.10315227f, -0.11490184f, 0.56350440f, -0.03682640f, -0.39226228f, 
    0.16739631f, -0.09025225f, 0.03875545f, 0.03545645f, 0.00282952f, 0.02531074f, 0.47199976f, -0.12391143f, 
    -0.48417169f, 0.00043981f, -0.01359043f, 0.11769412f, -0.01678781f, 0.29865792f, 0.20617522f, -0.06220767f, 
    -0.09244255f, -0.08453097f, -0.02248856f, 0.07999240f, -0.14795519f, 0.18906626f, -0.03026691f, -0.00654990f, 
    -0.45396721f, 0.03780531f, -0.01990920f, 0.21513243f, 0.11510844f, -0.07780360f, -0.11495715f, 0.31526652f, 
    0.24564607f, 0.35022610f, 0.31384322f, -0.16278589f, 0.26572824f, 0.10087582f, 0.12643765f, 0.15659164f, 
    -0.30564472f, 0.63314086f, -0.30960214f, 0.13249655f, 0.14461830f, -0.25287139f, -0.10305388f, 0.12538159f, 
    0.11476263f, 0.60302883f, -0.15437560f, -0.19183016f, 0.00501520f, 0.18554239f, 0.00713545f, -0.05005825f, 
    -0.15505515f, 0.23571180f, -0.09701459f, 0.17857035f, -0.11893684f, -0.10353872f, -0.08472864f, 0.07759500f, 
    0.08572385f, 0.03575471f, -0.25196022f, 0.05014694f, 0.08931389f, -0.30197942f, 0.23728332f, -0.24059930f, 
    -0.09396011f, 0.05966586f, -0.23594303f, 0.11580914f, 0.07656796f, -0.10184313f, -0.32939732f, -0.00186613f, 
    -0.03971763f, 0.03486707f, -0.05996525f, -0.05311834f, -0.29984957f, -0.26096863f, -0.02735696f, 0.19998118f, 
    0.05785739f, -0.29072088f, 0.15879202f, -0.28889048f, 0.06772722f, 0.10604694f, 0.00326671f, 0.50647855f, 
    -0.36636081f, -0.14078777f, 0.31911260f, 0.00961511f, 0.14922613f, 0.01372905f, -0.01965911f, -0.24908887f, 
    -0.12343237f, -0.09701745f, 0.03099612f, 0.22880563f, 0.31456423f, -0.13083792f, -0.11105095f, -0.40986073f, 
    0.76791799f, -0.23036917f, 0.01057783f, 0.21275745f, -0.07391388f, -0.12457458f, 0.18663821f, 0.12604256f, 
    -0.34833130f, 0.90846592f, -0.04581397f, 0.10731510f, 0.04194970f, -0.28234211f, 0.12070195f, -0.39874709f, 
    -0.38965809f, -0.03715318f, 0.16529460f, -0.10235903f, -0.23196575f, 0.06442429f, 0.49475810f, -0.02192448f, 
    -0.28911352f, -0.40612787f, 0.02331757f, -0.24154192f, 0.06299563f, 0.42930266f, 0.05537216f, -0.08006687f, 
    -0.40473062f, -0.03295257f, -0.23358491f, -0.14381003f, -0.31485999f, -0.08121916f, -0.11178239f, -0.04512570f, 
    -0.09665933f, 0.16071166f, -0.00571524f, 0.32269248f, -0.06693210f, -0.06482776f, -0.33979052f, 0.48578769f, 
    0.25548625f, 0.22268952f, -0.07761291f, -0.13882808f, 0.01705454f, 0.26512167f, 0.26734477f, 0.06510597f, 
    0.03582505f, -0.25760970f, -0.17113484f, -0.11190450f, -0.05145851f, 0.19293869f, 0.10203516f, 0.16326183f, 
    0.12674464f, 0.11597403f, -0.31995767f, 0.00326865f, 0.21299957f, 0.04700252f, -0.06418865f, 0.03073599f, 
    -0.43092281f, -0.18142350f, -0.16194566f, -0.16494948f, -0.38805333f, 0.19931774f, 0.21624660f, 0.13905051f, 
    -0.01539683f, 0.06970560f, -0.09578580f, 0.00406756f, -0.03306389f, 0.04278561f, 0.06683700f, -0.02664978f, 
    0.06259533f, -0.06500296f, -0.04708458f, -0.06578374f, -0.03098927f, 0.05531449f, 0.05436878f, -0.00562793f, 
    -0.00919825f, 0.00115941f, -0.02298141f, 0.02899614f, -0.00572041f, -0.02148948f, 0.02964395f, -0.00784113f, 
    0.03251278f, 0.03189918f, 0.02073500f, -0.05588125f, -0.01558245f, 0.00273243f, -0.00779858f, -0.05669990f, 
    -0.04689551f, -0.04693307f, -0.03447698f, -0.04984391f, -0.06801681f, 0.00440113f, -0.04508128f, -0.00121401f, 
    -0.05520017f, -0.07905377f, -0.07959823f, 0.04713511f, -0.08376285f, -0.04810914f, 0.00732664f, -0.08113598f, 
    -0.06084396f, -0.07637990f, 0.03140416f, -0.09416677f, 0.05486188f, -0.00179275f, -0.06893711f, -0.04759144f, 
    0.01558067f, -0.04582695f, 0.04966778f, -0.03514940f, 0.01313573f, -0.03334677f, -0.00507854f, -0.04071948f, 
    -0.04408360f, -0.08775201f, 0.00093024f, 0.00516462f, 0.03768283f, 0.01485704f, 0.03020456f, 0.01616733f, 
    -0.09692796f, -0.06953321f, 0.01327634f, 0.01662817f, -0.02060704f, 0.00601569f, -0.10431074f, -0.04206776f, 
    -0.07264386f, 0.05857661f, -0.09166697f, -0.05689168f, 0.04399165f, 0.03338800f, 0.01892027f, -0.06655066f, 
    0.03798262f, 0.00365555f, 0.00679096f, -0.06564019f, -0.00033747f, -0.07071217f, -0.08034609f, 0.02194658f, 
    0.01682799f, 0.08129726f, 0.00456027f, -0.08203283f, 0.03505861f, -0.08235575f, -0.04140397f, -0.01076411f, 
    -0.02736062f, 0.07930959f, 0.00967807f, -0.05458466f, 0.05254484f, 0.04768937f, -0.08568517f, -0.03747837f, 
    0.07178394f, 0.00717800f, -0.02355150f, 0.01650839f, 0.01692428f, -0.08891474f, 0.02043072f, -0.07098824f, 
    -0.07668895f, 0.06919787f, -0.02843872f, -0.03760071f, 0.01711857f, 0.08502872f, -0.05080190f, 0.01454124f, 
    0.02230687f, 0.36855927f, 0.06877737f, -0.11863943f, -0.12382782f, -0.12465689f, 0.08747178f, -0.17252319f, 
    -0.09311182f, -0.08210558f, 0.07400082f, 0.00011036f, 0.00660926f, -0.02428426f, 0.22097108f, -0.05689321f, 
    -0.09699824f, 0.05893151f, 0.00541327f, -0.01044342f, 0.36402795f, -0.14698243f, 0.04462573f, 0.05699089f, 
    -0.06317589f, -0.10764675f, 0.17333674f, -0.21379010f, 0.06082304f, -0.23304190f, -0.07226520f, -0.06890596f, 
    0.02423991f, -0.07072898f, -0.06407436f, 0.18407539f, 0.08840828f, 0.03056040f, 0.12323534f, 0.14548977f, 
    -0.25526416f, -0.17514414f, 0.15340212f, 0.03793873f, 0.14072356f, 0.10412224f, -0.14895965f, 0.09698150f, 
    -0.59102398f, 0.15027215f, -0.23811990f, 0.13624130f, -0.00286571f, 0.09402618f, -0.10984372f, -0.06840920f, 
    0.07658733f, -0.24355198f, -0.11866604f, -0.11869069f, 0.14902560f, -0.02389848f, -0.04320956f, 0.12868410f, 
    -0.08288544f, 0.11179446f, 0.20949048f, 0.12325818f, 0.05046454f, 0.08178765f, 0.06724010f, 0.22748365f, 
    -0.23549591f, 0.08112804f, -0.00597369f, 0.19622207f, -0.05505997f, 0.24909285f, 0.04138988f, 0.05486048f, 
    0.11471731f, 0.18035525f, -0.11547617f, 0.06257240f, 0.03570350f, 0.18877478f, 0.04521315f, 0.10946092f, 
    0.01947786f, -0.06176025f, -0.02269021f, 0.26014030f, 0.07578552f, 0.06046344f, 0.14192861f, -0.13544315f, 
    -0.05543042f, -0.01259562f, -0.11392246f, 0.23754705f, 0.05120261f, 0.16191483f, -0.06156522f, 0.15718181f, 
    0.21017580f, 0.01691379f, -0.16246749f, 0.09166284f, 0.08707318f, 0.11967373f, -0.09131454f, 0.12200847f, 
    0.23138331f, -0.29575264f, 0.01027031f, 0.18716362f, 0.11101612f, 0.10409126f, 0.14311184f, 0.23241423f, 
    -0.10356667f, -0.03061389f, -0.37740406f, -0.01531743f, 0.11211117f, 0.00263801f, 0.15961052f, 0.18904252f, 
    -0.18137285f, -0.31499246f, -0.05221626f, -0.25679559f, -0.00239365f, 0.07896816f, 0.22405148f, -0.09632432f, 
    0.07926761f, 0.05798930f, -0.13101909f, 0.10002138f, -0.07474010f, 0.01097681f, -0.12057126f, 0.06472090f, 
    0.03656707f, 0.02309434f, 0.21268447f, -0.01680887f, -0.05369175f, -0.25780219f, -0.07248616f, -0.04637179f, 
    0.03308282f, -0.18099324f, 0.03852994f, -0.10697039f, 0.04528106f, 0.12671734f, -0.01572563f, 0.35056874f, 
    0.22590399f, -0.09055776f, 0.07658660f, -0.13310839f, 0.11759156f, -0.03576517f, 0.19733626f, 0.11620033f, 
    -0.21848482f, -0.13441475f, -0.13118476f, -0.26245561f, -0.03270254f, 0.11030298f, -0.45796070f, 0.00899782f, 
    0.55669725f, 0.12726936f, -0.04765943f, 0.17204589f, 0.15277494f, 0.08214550f, 0.13913308f, -0.06660298f, 
    0.11284261f, 0.33960617f, 0.06161578f, 0.05351070f, -0.07491881f, 0.28305045f, 0.14363796f, 0.10676016f, 
    -0.23512894f, -0.09093939f, -0.02013650f, -0.44212607f, 0.37876663f, 0.07926036f, 0.36926672f, -0.05611541f, 
    -0.17551544f, -0.07158335f, -0.00333469f, -0.05146229f, -0.03801788f, -0.01856422f, 0.07353451f, 0.02362444f, 
    -0.03217122f, -0.14614111f, 0.38191012f, 0.00746417f, 0.07766394f, 0.08060431f, -0.12564732f, 0.14679781f, 
    0.03941692f, 0.35948256f, -0.05342831f, -0.20539427f, 0.13351224f, 0.02306663f, 0.00443174f, 0.01141408f, 
    0.15850107f, 0.37602022f, -0.18348561f, -0.09109642f, -0.04562674f, -0.05439816f, 0.26249552f, -0.16398239f, 
    -0.59466308f, 0.35845959f, 0.06823384f, -0.05202548f, 0.05408516f, 0.39080775f, -0.03795246f, -0.31719097f, 
    -0.33656371f, 0.14215486f, 0.13377894f, -0.02289319f, -0.37527233f, 0.07617708f, 0.09819301f, -0.04328031f, 
    0.08875984f, 0.11819727f, 0.38922504f, -0.10085666f, 0.07513319f, 0.40108028f, 0.03747157f, 0.01339460f, 
    0.08240367f, 0.21281230f, -0.01040654f, 0.28108829f, 0.29964599f, -0.00781628f, -0.03894114f, 0.20826167f, 
    0.15128280f, 0.03619690f, 0.04941776f, 0.16820197f, 0.04275703f, 0.11049765f, -0.10588139f, -0.05396654f, 
    0.00001591f, -0.14180961f, -0.06874526f, -0.06520505f, -0.03465939f, 0.23253390f, 0.19382349f, -0.00874450f, 
    -0.03169297f, -0.13563578f, -0.13000223f, -0.10443603f, 0.02237344f, 0.35521880f, -0.17084579f, -0.35106567f, 
    -0.04511235f, 0.06918468f, 0.35465854f, 0.29050082f, -0.09870486f, 0.18885434f, 0.32150185f, -0.31665692f, 
    -0.70542097f, -0.09860322f, 0.00938347f, 0.05736247f, -0.01981501f, 0.08305962f, 0.06716177f, 0.11174016f, 
    -0.35788950f, -0.16747978f, 0.25148088f, -0.18250310f, -0.01620078f, -0.06471844f, -0.03155397f, -0.06457230f, 
    -0.05355061f, 0.32498527f, 0.30043447f, 0.25547320f, -0.33140242f, -0.12829420f, 0.10911572f, -0.13123935f, 
    -0.03330311f, 0.02633840f, 0.19890083f, -0.17419687f, -0.35076973f, -0.12677851f, 0.06686644f, -0.03649264f, 
    0.43263215f, -0.38427642f, -0.02624588f, -0.06631822f, 0.04081094f, 0.58805168f, 0.13707209f, -0.01017063f, 
    -0.14296727f, 0.15931033f, -0.08496878f, -0.15158123f, -0.17993163f, 0.15921167f, 0.12464210f, -0.13020901f, 
    0.23604153f, -0.00854886f, 0.02655844f, -0.16876474f, 0.12148168f, 0.02102618f, 0.20816487f, 0.05194766f, 
    0.00384773f, -0.41791761f, 0.20128295f, -0.35546899f, -0.19067696f, 0.18647043f, 0.08027215f, 0.20433885f, 
    0.06043136f, -0.67253608f, 0.12770166f, -0.12213659f, -0.15152538f, -0.11390394f, 0.37949258f, -0.02441218f, 
    -0.09551731f, 0.21839999f, -0.01022999f, -0.08262193f, 0.50043130f, -0.26278603f, 0.11386345f, -0.07902244f, 
    -0.00043686f, -0.05244070f, 0.18685587f, 0.52552581f, -0.15219733f, -0.44515041f, 0.09294935f, -0.29775336f, 
    -0.01671758f, 0.05342820f, -0.04029609f, -0.04412386f, -0.09304169f, -0.08291539f, -0.08774936f, -0.05544498f, 
    -0.03668197f, 0.00637542f, -0.03692429f, -0.01791351f, -0.05099411f, -0.09058112f, 0.02916064f, -0.07062134f, 
    -0.02056371f, 0.04027103f, -0.01406764f, -0.05009618f, -0.08530874f, -0.09022571f, 0.01502729f, -0.01036454f, 
    -0.04074154f, 0.01352916f, 0.00366708f, -0.03283010f, -0.06994736f, 0.04538611f, 0.05659822f, 0.04980421f, 
    0.02672197f, -0.03914315f, -0.05787706f, -0.04166968f, -0.03127136f, 0.01936723f, 0.06331338f, -0.04026702f, 
    -0.03931226f, -0.04865141f, -0.03127375f, 0.04005524f, 0.02312104f, 0.02582422f, -0.00385966f, -0.06143771f, 
    0.03442119f, 0.07432520f, 0.07729769f, 0.01495449f, 0.02273921f, -0.03422633f, 0.00007017f, 0.02815122f, 
    -0.08228216f, -0.01831029f, 0.05119887f, -0.03212915f, -0.08015713f, -0.04741912f, -0.02296256f, 0.05355706f, 
    -0.04690113f, -0.01740569f, 0.03470133f, -0.05679966f, 0.01654192f, 0.03736592f, -0.04119944f, -0.07109565f, 
    -0.08991669f, -0.01659745f, -0.06414962f, -0.06228623f, 0.03162007f, -0.03923891f, -0.07125827f, 0.02404267f, 
    -0.09083754f, -0.03786983f, -0.03756147f, 0.05778869f, -0.00226149f, -0.00821217f, 0.05827511f, -0.01178941f, 
    0.04928145f, 0.07546762f, -0.08410510f, -0.05983552f, 0.03786252f, -0.01890774f, 0.02963091f, -0.03585543f, 
    0.06900138f, -0.02266119f, -0.01189965f, 0.03630261f, 0.06487807f, -0.08304357f, 0.05902458f, 0.02976919f, 
    -0.08466936f, -0.01987446f, -0.09402531f, 0.00468728f, -0.00124992f, 0.07877247f, 0.00431461f, 0.07237927f, 
    0.02291796f, -0.03036960f, -0.06653708f, -0.08643071f, 0.05206702f, 0.04863936f, -0.04718509f, 0.08142594f, 
    -0.02661517f, 0.08717601f, 0.00774995f, -0.03897495f, 0.00790936f, -0.03500150f, -0.03229705f, -0.06442192f, 
    -0.02463970f, -0.05820636f, 0.01503343f, 0.07725476f, 0.01375130f, -0.11263096f, -0.06546587f, -0.00369131f, 
    0.02228111f, -0.08486157f, -0.01395734f, -0.10809094f, 0.01215235f, 0.05608274f, -0.05432049f, 0.04187175f, 
    -0.02209431f, -0.05469000f, 0.09481370f, -0.00211893f, 0.06810882f, 0.04950442f, -0.05103448f, -0.07347509f, 
    -0.11019666f, 0.08083727f, 0.01107604f, 0.05777168f, 0.01372084f, -0.06417867f, -0.00530521f, 0.08498539f, 
    -0.02161425f, 0.02847972f, 0.01157076f, -0.02871226f, -0.07851610f, -0.01974098f, 0.03051696f, -0.02072115f, 
    -0.05229317f, -0.10079184f, -0.01119296f, -0.08837526f, 0.06383934f, 0.08192050f, -0.05248944f, 0.06206365f, 
    -0.05978533f, 0.00953574f, -0.07959629f, -0.07431488f, 0.02493887f, 0.01495599f, -0.03071130f, -0.08303098f, 
    -0.03532859f, -0.10415826f, 0.06140977f, -0.06900254f, 0.02449766f, -0.02786456f, -0.08487753f, 0.02723378f, 
    0.06999035f, -0.00681008f, -0.05164721f, -0.08607333f, -0.02251354f, -0.03871268f, -0.04582201f, -0.07323058f, 
    0.11599887f, 0.03842307f, 0.00994744f, -0.09499409f, -0.07204036f, -0.02215003f, -0.11433390f, 0.04641688f, 
    -0.08217718f, -0.12401676f, 0.04553592f, -0.04932614f, 0.05784605f, -0.11646976f, -0.05508230f, -0.04283679f, 
    -0.01154013f, 0.06233366f, -0.02805641f, -0.08290268f, -0.12011085f, 0.02877699f, -0.04978986f, 0.03928345f, 
    -0.05142406f, -0.11211543f, -0.05873451f, 0.04243806f, -0.07795569f, 0.03748530f, -0.07610434f, -0.01672001f, 
    -0.08562484f, -0.04473336f, -0.01972802f, -0.08806108f, 0.04143785f, -0.03034618f, -0.05065487f, -0.04885011f, 
    0.01181199f, 0.10022683f, -0.09239074f, -0.07241469f, -0.10754675f, -0.05437003f, -0.00624862f, 0.03883043f, 
    -0.06544051f, 0.01659286f, 0.12273360f, 0.02396873f, -0.06764691f, -0.10202141f, -0.00562125f, -0.01380609f, 
    -0.03903873f, -0.24249119f, 0.11888130f, 0.21760097f, 0.06647468f, -0.11951180f, -0.16018549f, 0.43029693f, 
    0.08792406f, -0.07458949f, -0.05730557f, 0.03726208f, 0.21604984f, 0.22893730f, 0.21043411f, 0.03448956f, 
    -0.13405366f, -0.26825941f, 0.06411378f, -0.01158830f, 0.30830991f, 0.07542270f, -0.02677304f, -0.03095908f, 
    -0.02467229f, -0.34664652f, -0.17738175f, 0.16391952f, -0.06406095f, -0.07784258f, -0.09496222f, -0.30705041f, 
    -0.06595482f, -0.11981802f, -0.07424210f, 0.04576103f, -0.21852030f, -0.02928985f, 0.29207247f, -0.16373923f, 
    -0.20589440f, 0.04162974f, -0.12207133f, 0.04586400f, -0.04821045f, -0.05770516f, 0.00206848f, 0.09393374f, 
    0.06814051f, 0.21435618f, 0.46606770f, -0.14686008f, 0.11539138f, -0.01865196f, -0.00944822f, -0.02492307f, 
    0.09690278f, 0.67641485f, 0.29911539f, 0.09684661f, -0.21321692f, -0.02709998f, 0.01189377f, 0.10136330f, 
    0.21282934f, -0.04899518f, -0.12822300f, -0.22342794f, 0.06339287f, -0.07930543f, -0.05415452f, 0.06946316f, 
    -0.09718976f, 0.20612799f, 0.00075416f, 0.06582451f, -0.04936750f, 0.02636833f, -0.13281810f, 0.08137245f, 
    0.21582280f, -0.07984718f, 0.28606763f, -0.18166332f, 0.18277588f, 0.01689443f, 0.43063536f, 0.08628295f, 
    0.29835311f, -0.04376671f, 0.00385394f, -0.12929673f, 0.00122413f, 0.08105385f, -0.01240700f, 0.03662643f, 
    -0.25362271f, -0.33796561f, 0.04206442f, -0.03294175f, -0.16015512f, -0.15758923f, -0.06262354f, 0.15601057f, 
    -0.08041129f, 0.21229219f, 0.12329999f, -0.03729643f, -0.04479454f, -0.00177595f, 0.03606400f, -0.19670253f, 
    0.00770102f, 0.11418997f, 0.09658210f, -0.03453539f, 0.39243418f, -0.24672191f, 0.01646107f, -0.16125156f, 
    0.20278181f, 0.01525605f, 0.11754043f, 0.36692524f, 0.11699118f, 0.35428229f, -0.40858164f, -0.19026367f, 
    -0.04716421f, -0.09763613f, -0.07937525f, 0.07687882f, -0.10448245f, -0.31675148f, -0.05275649f, 0.07232910f, 
    0.26604122f, 0.04691157f, 0.15553640f, -0.00332234f, 0.11983971f, 0.18845449f, 0.25721657f, -0.07838480f, 
    -0.07098394f, 0.17180164f, 0.26196527f, 0.00450955f, 0.17516667f, 0.03827500f, -0.07947242f, 0.03463955f, 
    -0.12037953f, 0.04066603f, -0.05921180f, 0.17010371f, -0.05258344f, -0.34351590f, 0.07793387f, 0.25416130f, 
    0.03999715f, 0.06791175f, -0.11657347f, 0.10802297f, 0.01077427f, -0.34642240f, 0.08958633f, 0.25160852f, 
    0.56602800f, 0.13346808f, 0.17671721f, -0.22414877f, 0.13017291f, 0.04264510f, -0.29817554f, -0.00837237f, 
    -0.62901121f, 0.19198719f, -0.01599052f, 0.09323242f, 0.19990800f, 0.03267018f, 0.14213730f, -0.05282140f, 
    0.04099037f, -0.22193561f, 0.01353627f, -0.01757702f, 0.17322779f, -0.04626374f, -0.05780957f, 0.49900645f, 
    -0.04175088f, 0.11239652f, 0.05397962f, -0.18705954f, 0.30273828f, 0.01677253f, 0.17257310f, -0.01345309f, 
    0.02729270f, 0.49828148f, 0.05304780f, 0.04727810f, 0.06643809f, 0.12406867f, 0.00662497f, 0.04373039f, 
    0.25120875f, -0.10359174f, 0.06426515f, -0.07650076f, 0.26966771f, -0.15410897f, 0.25506154f, 0.07237674f, 
    0.01055965f, 0.09954023f, -0.00069478f, -0.02028038f, -0.14282881f, 0.03144586f, -0.04088387f, 0.05085631f, 
    0.04146412f, 0.23390414f, -0.02167600f, 0.43802050f, -0.06119885f, 0.24905190f, -0.07060796f, -0.12386878f, 
    0.16292158f, -0.16288944f, -0.03340090f, 0.03803313f, -0.06881151f, 0.38716137f, -0.03049951f, 0.04472652f, 
    0.09351582f, -0.28025293f, 0.11345968f, 0.16634089f, 0.14223321f, -0.00338218f, -0.06479395f, 0.23588270f, 
    0.05210440f, -0.08164086f, -0.03410504f, -0.21294196f, 0.17354165f, 0.47756660f, 0.33513093f, 0.27017096f, 
    0.02699067f, 0.04148825f, 0.22109257f, 0.36820596f, 0.14565787f, -0.22697331f, -0.06379327f, 0.31352776f, 
    0.24877633f, 0.04238897f, 0.12520835f, 0.20658676f, 0.05238670f, 0.08944087f, -0.06939850f, 0.05178171f, 
    -0.12767394f, -0.18779017f, -0.22840554f, 0.00603342f, 0.15885520f, 0.04998706f, 0.00908720f, -0.10133330f, 
    -0.20473813f, -0.10561516f, -0.47216541f, -0.48233229f, 0.09298923f, 0.18792513f, -0.35500798f, -0.25584987f, 
    -0.04019351f, -0.20402043f, 0.01262325f, 0.37158406f, 0.13817914f, 0.17773122f, 0.41644895f, -0.28152958f, 
    -0.56225497f, -0.16700208f, -0.04197077f, 0.45029020f, 0.00814443f, -0.09185054f, -0.06052993f, 0.06165614f, 
    -0.00291076f, -0.09269064f, 0.39606249f, -0.42147982f, 0.03978325f, -0.14568898f, -0.44336402f, 0.05033494f, 
    0.23465580f, 0.15630026f, 0.22982435f, 0.14973661f, -0.22463186f, -0.22488318f, -0.13140137f, -0.10399870f, 
    0.05766197f, -0.06819086f, 0.10942546f, -0.16811049f, -0.59407252f, -0.17267969f, -0.07497218f, 0.06438362f, 
    0.28243089f, -0.38291174f, -0.05472459f, 0.17943980f, -0.03511085f, 0.31974056f, 0.14183915f, 0.04584760f, 
    -0.19164853f, -0.01328659f, 0.17267913f, -0.13663556f, -0.36400887f, 0.28454965f, 0.31650180f, 0.01667875f, 
    0.11412928f, -0.09233907f, 0.11098142f, -0.04963198f, 0.11761257f, -0.03445607f, 0.13172865f, 0.03656675f, 
    -0.06977613f, -0.22667606f, 0.44795290f, -0.36738798f, -0.04045922f, 0.11626258f, -0.11991381f, 0.22019936f, 
    0.13618110f, -0.39081052f, 0.13841896f, -0.00459958f, 0.11064412f, -0.46025929f, -0.00291861f, 0.05625185f, 
    -0.07899120f, 0.35464850f, -0.08938078f, -0.12096015f, 0.31428167f, -0.30971694f, 0.07016239f, -0.33074817f, 
    -0.01534803f, 0.15073673f, 0.17027190f, 0.62677097f, -0.10492212f, -0.33391529f, -0.31170666f, -0.19494139f, 
    0.17479974f, -0.11559758f, -0.23814635f, 0.14705195f, -0.02428591f, -0.05830575f, 0.15592755f, -0.18899210f, 
    0.22718035f, 0.08341483f, -0.35527784f, 0.01890126f, -0.31810695f, 0.07000653f, 0.08918006f, -0.06526165f, 
    0.08900063f, 0.14664906f, 0.00462429f, -0.03988253f, -0.00847944f, -0.29063702f, -0.15910290f, 0.14877526f, 
    -0.13415767f, 0.10248120f, 0.02685926f, -0.31267804f, 0.13385952f, 0.29155481f, -0.06520658f, 0.40174159f, 
    -0.16344717f, 0.20141557f, -0.02033403f, 0.11512219f, 0.22026639f, -0.21230482f, 0.07390001f, 0.16587195f, 
    -0.29766116f, 0.04378265f, 0.06772681f, -0.03226869f, -0.07628794f, -0.19442840f, 0.07288966f, -0.28720188f, 
    0.37518948f, 0.21081533f, -0.11629636f, 0.20575738f, -0.15781893f, 0.09574785f, -0.05509141f, 0.16122940f, 
    -0.25133929f, -0.29888844f, 0.11682638f, -0.07939091f, 0.33914897f, -0.10064719f, 0.07850794f, -0.20603965f, 
    -0.11311571f, 0.08929563f, -0.13304548f, -0.00280940f, 0.04782589f, -0.14545587f, 0.31712845f, -0.30545434f, 
    0.09567478f, -0.01718215f, -0.09751730f, 0.06305575f, 0.08004859f, 0.04653987f, 0.02645027f, -0.06380888f, 
    0.02408987f, 0.02119186f, -0.23129185f, -0.21455094f, 0.21179615f, -0.18912573f, 0.00988484f, -0.16938108f, 
    -0.18100901f, -0.25990418f, 0.07784804f, -0.03161614f, -0.37126997f, -0.00569011f, -0.05938323f, -0.47450274f, 
    0.16914101f, 0.19576721f, 0.13193327f, 0.31867135f, 0.04780875f, 0.01891711f, -0.32807192f, -0.08656689f, 
    0.40263531f, -0.28753012f, -0.25500897f, -0.00103602f, -0.21643648f, -0.23546338f, 0.06577294f, -0.20588893f, 
    0.05048537f, 0.05146943f, -0.16901901f, 0.02838735f, 0.18803063f, 0.08317203f, -0.08524910f, 0.21752718f, 
    -0.01026129f, -0.19954583f, 0.22680455f, 0.06901529f, -0.09711809f, 0.21044236f, 0.29622376f, 0.33189961f, 
    -0.04929530f, 0.01328850f, 0.02755305f, -0.04844474f, -0.10232771f, -0.01863467f, -0.07232278f, -0.07840463f, 
    0.01028733f, -0.08093113f, -0.03999054f, -0.06353252f, 0.01598585f, -0.14528956f, -0.04036135f, 0.04895622f, 
    0.03708104f, -0.04223962f, 0.02575292f, 0.00848423f, -0.02754599f, -0.04324978f, 0.01416905f, -0.01518908f, 
    0.11487862f, -0.06839792f, -0.16819760f, -0.02917700f, -0.05660459f, -0.01733319f, 0.06506330f, 0.04805994f, 
    0.02449415f, -0.08146951f, -0.03912247f, 0.07131954f, 0.01900366f, -0.10007177f, -0.10404106f, -0.00776472f, 
    -0.03042816f, -0.06694644f, -0.01057007f, -0.03188274f, -0.06496193f, -0.07406905f, -0.05625738f, -0.11579603f, 
    0.04610344f, 0.01898118f, 0.00168994f, 0.03529758f, -0.09093047f, -0.07804773f, -0.04224093f, 0.05618823f, 
    -0.06049551f, 0.08027020f, -0.06736827f, -0.10491870f, -0.00296745f, -0.09813938f, -0.10793061f, 0.04245646f, 
    -0.10879391f, 0.02218329f, -0.01196717f, -0.12021656f, -0.03270100f, 0.00405990f, 0.06676798f, -0.13141705f, 
    -0.09423650f, -0.14087431f, 0.04301841f, -0.06947676f, -0.05671092f, -0.08810861f, 0.07424500f, 0.00324841f, 
    -0.10026384f, 0.03843746f, 0.07098293f, -0.05944248f, -0.03807982f, -0.03497812f, -0.06483534f, -0.05024929f, 
    -0.00101428f, -0.07995274f, 0.07405110f, 0.06679197f, -0.03584339f, 0.01561972f, -0.06037071f, -0.06034092f, 
    0.07988994f, 0.12474892f, -0.02140671f, -0.11924434f, 0.01788401f, -0.02281284f, 0.03829144f, 0.04487095f, 
    -0.09298804f, 0.05091916f, -0.05870683f, 0.06255128f, -0.04298516f, -0.11678109f, -0.00941599f, -0.00344439f, 
    0.05828369f, 0.02940483f, 0.03753303f, -0.03811248f, 0.03314508f, -0.02492312f, -0.05788516f, -0.11330109f, 
    -0.08390085f, 0.04287064f, 0.01479110f, -0.10741659f, -0.11356828f, -0.06964400f, 0.04077231f, -0.00264361f, 
    -0.44623774f, 0.46288028f, 0.12495854f, -0.36737832f, -0.12103941f, -0.15448813f, -0.03356036f, -0.45819616f, 
    -0.15897568f, 0.07657213f, 0.27670979f, -0.19290799f, -0.16829789f, -0.04931905f, -0.08882765f, 0.05190050f, 
    0.01241645f, -0.08174768f, 0.23394930f, 0.05395137f, 0.08808649f, 0.18831415f, -0.11803082f, -0.03756015f, 
    0.36441410f, -0.05283160f, 0.07151479f, 0.09698123f, 0.01161242f, -0.14653873f, 0.27839783f, -0.70576245f, 
    -0.04708401f, 0.09905393f, -0.31080988f, -0.19349957f, -0.72016066f, -0.04484683f, 0.01263961f, -0.02305412f, 
    -0.55857903f, 0.10394813f, -0.19720860f, 0.26935360f, 0.07084323f, 0.05490599f, 0.53519231f, 0.04729661f, 
    1.02094436f, -0.34135741f, -0.28230295f, 0.13520351f, -0.16750677f, 0.10346209f, 0.06984565f, -0.50574797f, 
    -0.20372154f, 0.61267692f, -0.44237223f, -0.30178279f, -0.19001916f, -0.00181943f, -0.40573946f, 0.05224011f, 
    -0.02623746f, 0.06088285f, 0.21294129f, 0.31447312f, -0.21028456f, 0.15033148f, -0.44052464f, 0.07028889f, 
    -0.13613351f, 0.40269735f, -0.05888851f, -0.20134464f, 0.08613842f, 0.05448700f, -0.21578106f, -0.04781906f, 
    -0.05986561f, -0.15856501f, -0.29185757f, 0.26543781f, 0.07865749f, -0.36808795f, -0.03400298f, -0.16463597f, 
    -0.09907599f, -0.18440700f, 0.08515529f, 0.41913968f, -0.37995741f, -0.03054696f, -0.00233609f, 0.42878667f, 
    -0.57302278f, -0.38343656f, -0.36416298f, -0.08525435f, 0.02684479f, -0.09137170f, 0.09268402f, -0.32996660f, 
    -0.10142414f, 0.04272817f, -0.20318715f, -0.02815856f, -0.14293085f, 0.08623549f, 0.19205633f, 0.46686023f, 
    0.04146502f, 0.02371194f, -0.06962889f, 0.06046538f, -0.05294949f, 0.11037762f, -0.24065709f, -0.00744948f, 
    -0.33748138f, -0.00142466f, -0.36073104f, -0.12835267f, -0.01709507f, -0.29217744f, 0.08239426f, -0.52088457f, 
    0.26202178f, 0.10952304f, -0.01191051f, -0.44416910f, 0.16840197f, 0.08797557f, 0.21940412f, -0.07977740f, 
    -0.41897744f, 0.03233667f, 0.08144369f, -0.04824886f, 0.14961925f, 0.00621088f, 0.19339542f, 0.01676780f, 
    0.09082537f, 0.23236930f, -0.12866716f, -0.01236353f, 0.09580939f, -0.14708818f, 0.00887175f, -0.06498264f, 
    0.21966980f, 0.01791075f, -0.06741416f, -0.12496329f, 0.03921361f, 0.11428141f, 0.07387920f, 0.01334909f, 
    -0.01367527f, -0.05232523f, 0.50221366f, -0.19150907f, 0.10518897f, 0.43803111f, 0.24436074f, -0.18231204f, 
    -0.36501336f, -0.20022625f, -0.16540550f, -0.34642643f, 0.16909000f, 0.11738128f, 0.13628192f, 0.09660961f, 
    0.15603819f, 0.15906785f, 0.01134121f, 0.20342189f, -0.08577082f, 0.09856682f, 0.25489795f, 0.13044487f, 
    0.00088906f, -0.03937065f, -0.18718377f, 0.00046382f, 0.27988219f, 0.04061545f, 0.11272781f, -0.11720821f, 
    0.02988552f, -0.02581282f, 0.01562757f, -0.07781360f, 0.12668614f, 0.00057947f, 0.57501030f, -0.03489420f, 
    -0.32741988f, 0.11669869f, 0.06373666f, -0.03803085f, 0.08694030f, -0.01954022f, 0.06080768f, -0.00061278f, 
    0.16247097f, 0.33351243f, 0.34136620f, -0.03168380f, 0.10899625f, 0.29339305f, -0.06487570f, 0.00257537f, 
    0.26446521f, 0.31049940f, -0.00534269f, 0.03756024f, 0.12177902f, 0.03989170f, -0.14028706f, -0.27085108f, 
    -0.16521201f, -0.03464054f, -0.39363965f, -0.00079071f, -0.06717046f, -0.12468681f, 0.32836655f, 0.05490416f, 
    -0.16395478f, -0.11957408f, 0.03811534f, -0.06873269f, 0.18349046f, -0.04523116f, 0.03138296f, -0.08998449f, 
    -0.07517880f, -0.12972391f, 0.19800286f, 0.10000359f, 0.00264833f, 0.07105573f, 0.14518854f, 0.12853640f, 
    0.29696313f, -0.02763419f, -0.25340497f, -0.10122451f, 0.11568112f, -0.10390861f, -0.02187739f, 0.02157655f, 
    0.01091208f, -0.01460645f, -0.03473222f, 0.01018262f, -0.10465816f, -0.00492940f, 0.05724250f, -0.04750190f, 
    0.01800712f, 0.04375335f, 0.04444864f, -0.11057287f, -0.07529739f, -0.06242088f, 0.04333943f, 0.03146566f, 
    -0.07749685f, 0.03197415f, -0.01887472f, 0.08795837f, -0.09238532f, -0.00700164f, 0.02191258f, 0.03467157f, 
    -0.09717399f, -0.07516984f, -0.08564707f, 0.00412722f, 0.03468079f, -0.11217858f, -0.12028798f, 0.03502988f, 
    -0.09726264f, -0.06059666f, -0.05194367f, -0.05428893f, -0.08848975f, -0.06600580f, 0.10600670f, -0.05778415f, 
    -0.06747214f, -0.04040986f, -0.11824030f, 0.03964431f, -0.02879117f, 0.03618081f, 0.01603439f, -0.02084192f, 
    0.02739612f, 0.00242861f, -0.00658529f, 0.03065838f, 0.00924315f, 0.02601334f, -0.12632221f, 0.03265227f, 
    -0.05739840f, 0.12371298f, 0.00680413f, 0.00112568f, -0.02123419f, -0.04689103f, -0.07654091f, 0.01011003f, 
    0.04439579f, 0.00205894f, -0.10405528f, -0.08865897f, -0.01936706f, -0.12623139f, -0.02105463f, -0.06526314f, 
    -0.03148096f, 0.03388932f, 0.03231814f, -0.02143022f, 0.02470156f, 0.08738050f, -0.09784383f, -0.08297168f, 
    -0.00442245f, 0.04455838f, 0.06182379f, 0.04634599f, -0.10543081f, -0.07040853f, -0.00904044f, -0.02486418f, 
    -0.07527084f, 0.04894310f, -0.03819578f, 0.00556565f, 0.03162722f, 0.04758688f, -0.07603980f, 0.08177286f, 
    -0.07793737f, -0.05904428f, -0.08807307f, -0.01459008f, 0.00639980f, -0.07708282f, -0.05572202f, -0.05375306f, 
    -0.05970590f, -0.02284197f, 0.00759471f, -0.07424023f, -0.10736154f, 0.07503765f, -0.10462795f, 0.03264337f, 
    0.00743395f, 0.03601849f, -0.08188897f, 0.04696668f, 0.02907878f, -0.08021496f, -0.07669949f, -0.02062875f, 
    -0.03069277f, -0.09700794f, 0.02598135f, 0.00964580f, -0.04110980f, 0.07932407f, -0.05055166f, -0.10660777f, 
    0.02815462f, 0.24212284f, 0.06067690f, -0.11068087f, -0.00000483f, 0.18617669f, 0.30371657f, 0.07133812f, 
    -0.05380789f, -0.06310986f, 0.22557354f, 0.00806144f, 0.05170240f, -0.05782997f, 0.03185998f, -0.00488350f, 
    0.09256225f, 0.11055896f, -0.19726174f, 0.01274537f, 0.17379972f, -0.30112210f, -0.00421173f, -0.09262267f, 
    0.05510295f, 0.09365664f, -0.11597751f, -0.05631290f, -0.00035470f, -0.06366664f, 0.13959172f, -0.17291580f, 
    0.18577217f, -0.07066461f, 0.04548245f, -0.10707752f, 0.13421042f, 0.05078432f, 0.40387347f, 0.02990482f, 
    -0.24077727f, -0.28133798f, 0.00623905f, -0.35953084f, -0.11751543f, 0.13492022f, -0.20555297f, 0.04803834f, 
    -0.18275894f, 0.19587170f, -0.02669748f, -0.10995524f, 0.06650834f, 0.21955803f, -0.05780823f, 0.04573146f, 
    0.19552608f, 0.08697445f, -0.13188824f, -0.10989056f, 0.12333265f, -0.30271110f, 0.11601930f, 0.00444499f, 
    -0.45126125f, -0.02319985f, 0.19201747f, -0.40723357f, 0.04672328f, 0.02488324f, -0.07551654f, 0.23503438f, 
    -0.08954405f, -0.13456546f, 0.02200944f, 0.06457058f, 0.02590035f, 0.00570937f, 0.07200942f, 0.03572175f, 
    0.15578817f, 0.14682500f, 0.27452254f, 0.06211727f, -0.00651758f, 0.03275818f, -0.41963571f, 0.21594639f, 
    0.13772763f, 0.24792898f, -0.10279658f, -0.21147045f, 0.21170183f, -0.03518751f, 0.00820798f, -0.13016745f, 
    -0.05843060f, 0.03143622f, 0.00656191f, -0.00590474f, 0.02935358f, -0.03656469f, 0.21667868f, -0.03916908f, 
    -0.26898083f, -0.21795958f, 0.09152674f, -0.00846591f, 0.20861900f, 0.17023532f, 0.00163335f, -0.30612761f, 
    -0.34354416f, -0.05720285f, 0.14950991f, 0.22928651f, -0.20156845f, -0.06131248f, 0.16585450f, 0.11623273f, 
    0.23954436f, 0.01894241f, 0.03391835f, -0.03121628f, 0.07673685f, 0.03313752f, -0.11318995f, -0.10287192f, 
    -0.00445926f, 0.04890571f, -0.06545161f, 0.04965962f, -0.00351590f, 0.01171451f, 0.06827960f, -0.01090757f, 
    -0.08857606f, -0.03432344f, -0.10441989f, -0.05126774f, -0.03494396f, -0.11003211f, 0.03731153f, -0.07912578f, 
    -0.04912202f, 0.01562528f, 0.01208824f, 0.00650740f, 0.03733972f, -0.04597910f, -0.08837759f, -0.02961870f, 
    0.04227285f, -0.06732719f, -0.06920906f, -0.00406315f, -0.00080206f, -0.05055221f, -0.03573193f, 0.00245364f, 
    -0.09579074f, 0.00745114f, -0.02058406f, -0.05461972f, 0.05275146f, -0.05235854f, -0.06802169f, -0.00624175f, 
    0.08145426f, 0.04437282f, -0.05308954f, 0.00479257f, -0.06748882f, -0.12509862f, -0.09164988f, 0.03231805f, 
    -0.02567938f, -0.01892473f, -0.07810998f, 0.00802206f, -0.08851657f, -0.01044738f, -0.02130328f, -0.08658635f, 
    0.00167411f, -0.06088819f, -0.08838128f, 0.05211595f, -0.02504034f, -0.06192441f, -0.09386875f, 0.03974291f, 
    -0.03977174f, 0.06315053f, 0.00893278f, -0.06486557f, 0.01066667f, -0.10751917f, 0.02172654f, -0.11149366f, 
    -0.04836238f, 0.04100531f, 0.02844564f, -0.01234111f, -0.01343689f, -0.10582627f, -0.11435597f, 0.01370883f, 
    0.00660688f, -0.11509594f, 0.01293847f, 0.03395521f, -0.08941447f, -0.00247734f, -0.07378249f, -0.06349342f, 
    0.05241830f, -0.02923862f, 0.02314802f, -0.11201874f, 0.02766004f, 0.06289458f, 0.01042094f, 0.05009835f, 
    0.03588951f, -0.08338060f, -0.06399746f, -0.10756322f, 0.04421818f, -0.06897366f, -0.09323186f, -0.09512325f, 
    0.02764764f, -0.01338662f, -0.10696667f, 0.00399461f, 0.04112839f, -0.00807376f, 0.00686622f, 0.00968996f, 
    0.07345952f, -0.01255775f, -0.10017119f, 0.02566486f, -0.07125240f, -0.11000261f, -0.11814412f, -0.08875424f, 
    0.04865469f, -0.03353793f, 0.01234945f, -0.04308665f, -0.11743554f, -0.09488121f, -0.11500542f, -0.03273259f, 
    0.24998836f, -0.33553573f, -0.10574734f, 0.12579671f, 0.21485025f, 0.08322180f, -0.30666435f, 0.15764587f, 
    -0.09750465f, 0.08242016f, 0.07330193f, 0.15623802f, 0.23233041f, -0.10049474f, -0.14703439f, 0.08292327f, 
    0.10968483f, 0.14455676f, 0.07742223f, 0.03308936f, -0.26171497f, -0.22194292f, -0.01256641f, 0.10705663f, 
    -0.14429690f, -0.14771092f, -0.36456326f, -0.08191616f, 0.17115940f, 0.11005677f, -0.05912306f, 0.11041798f, 
    -0.12582581f, -0.26331797f, 0.18720701f, 0.03647392f, 0.25984770f, 0.11697608f, -0.17224273f, -0.35902473f, 
    -0.52217180f, 0.01348971f, -0.13966738f, 0.05878216f, 0.10810899f, -0.04376567f, -0.02872682f, 0.12700760f, 
    0.41595092f, -0.13347460f, -0.03229596f, -0.12495040f, -0.14052254f, -0.13598412f, 0.00770051f, 0.10492254f, 
    0.13469212f, 0.32310447f, 0.10959408f, 0.03448505f, -0.06880504f, 0.42355764f, 0.00366008f, -0.63761783f, 
    0.03448090f, 0.01573603f, 0.08489709f, -0.13544942f, -0.10919932f, 0.07595487f, 0.02661232f, -0.06279400f, 
    -0.31083807f, -0.34814781f, -0.06358308f, -0.01819373f, 0.03128907f, 0.15821432f, 0.21592918f, 0.03427914f, 
    -0.02754107f, 0.20628400f, 0.05205751f, 0.05659462f, -0.25738719f, 0.29717109f, -0.11548030f, 0.04091741f, 
    -0.18041268f, -0.01861117f, -0.07371650f, 0.23058294f, 0.24129324f, -0.05132715f, -0.03838720f, 0.19591880f, 
    -0.08035376f, 0.22635771f, 0.16317047f, -0.30158609f, 0.20884934f, 0.04947853f, 0.05793607f, 0.19785433f, 
    -0.44046894f, 0.22829372f, -0.10035665f, 0.22045062f, 0.22211279f, -0.25158712f, -0.02498682f, -0.16846645f, 
    -0.15034758f, 0.29980814f, -0.00107953f, 0.01494297f, -0.14432216f, 0.08592139f, 0.11386337f, -0.06289995f, 
    -0.12808158f, 0.12489644f, -0.10301381f, 0.04476968f, -0.01613228f, -0.04483656f, -0.19273885f, -0.07183777f, 
    -0.08179319f, 0.01610358f, -0.00835050f, 0.08064821f, -0.07643148f, -0.01328551f, 0.01715136f, 0.02721045f, 
    0.07240205f, -0.07950447f, -0.04674872f, -0.04386669f, -0.04586862f, 0.08387666f, -0.00064892f, 0.02138864f, 
    -0.09243835f, -0.07179430f, 0.08605294f, 0.06499847f, -0.06708398f, 0.05946605f, -0.05778148f, -0.06437785f, 
    -0.07945208f, -0.08147775f, -0.00287992f, -0.07135911f, -0.03762224f, -0.00597882f, -0.03486433f, -0.06666279f, 
    -0.09843772f, -0.02781064f, 0.00308939f, 0.03842510f, -0.03781606f, -0.05365085f, 0.02758754f, 0.01377595f, 
    -0.00522989f, -0.03461445f, -0.05924688f, -0.01267393f, 0.05135493f, -0.03541128f, -0.11340194f, -0.12133148f, 
    -0.05859255f, 0.09160166f, -0.03115911f, 0.04966236f, -0.04221419f, 0.06090091f, -0.06101770f, -0.04758262f, 
    0.06702790f, -0.06237091f, -0.02649353f, -0.07822920f, -0.05165131f, -0.04613556f, -0.02711492f, 0.00009671f, 
    -0.10149821f, -0.03484667f, -0.04043904f, 0.00616954f, -0.05669938f, -0.04544859f, -0.05345222f, -0.01177070f, 
    -0.03445097f, 0.03104046f, 0.01999355f, -0.04336007f, 0.05270191f, 0.08403420f, -0.05138001f, 0.04162677f, 
    -0.09507670f, -0.00778591f, -0.07886004f, -0.09905972f, 0.04701813f, -0.02294314f, 0.10262045f, -0.03828011f, 
    0.03266430f, -0.00924117f, -0.03906460f, 0.04268348f, -0.08638658f, -0.02215124f, 0.01334406f, -0.09292248f, 
    -0.06178897f, -0.06933063f, -0.00137404f, 0.00043518f, -0.03464252f, -0.00841758f, 0.04676326f, 0.05818937f, 
    -0.04722923f, -0.05240541f, -0.07403929f, 0.01831877f, 0.01450914f, 0.01956944f, 0.02684482f, -0.01920355f, 
    0.08350916f, 0.07504153f, 0.06007872f, 0.05172503f, 0.01274008f, 0.01706060f, 0.07449842f, -0.01501909f, 
    -0.04993688f, -0.02682253f, -0.03289830f, -0.06270386f, -0.10163245f, -0.03310635f, 0.08035943f, -0.03908726f, 
    -0.07870816f, -0.09220751f, -0.06909033f, 0.08477180f, -0.02700160f, 0.02595497f, -0.01273296f, -0.05343616f, 
    0.01655176f, 0.06503772f, 0.05087902f, -0.06401043f, 0.03129051f, -0.08238181f, 0.00372152f, 0.04449404f, 
    -0.10413105f, -0.05815167f, 0.00763526f, 0.01388191f, 0.01469146f, -0.06914920f, -0.09585024f, -0.05789237f, 
    0.04788183f, -0.00445002f, -0.10206274f, 0.02514260f, 0.01853244f, -0.02529554f, 0.00250642f, 0.05628338f, 
    -0.10344318f, 0.00143875f, 0.02901737f, 0.03848268f, -0.00123935f, -0.02019643f, 0.01888989f, -0.09826397f, 
    -0.09009179f, 0.00736967f, -0.06618574f, 0.07077157f, -0.06816807f, 0.03056694f, 0.02941953f, -0.00202910f, 
    0.03010470f, -0.12166347f, 0.05498852f, 0.00865509f, -0.10772571f, 0.06277888f, -0.04463532f, -0.01361393f, 
    -0.06235268f, -0.02367307f, -0.09351561f, -0.09085163f, -0.12896588f, 0.00253128f, 0.01617179f, -0.12827903f, 
    -0.00112813f, 0.07138059f, -0.08888694f, -0.07970375f, -0.03249234f, -0.02880118f, 0.05695338f, -0.10926496f, 
    -0.00537698f, -0.01345843f, -0.06179431f, -0.06457371f, -0.00905636f, -0.07807382f, -0.03305943f, -0.05527722f, 
    -0.12723349f, -0.01274307f, -0.06798070f, -0.00208768f, 0.07091578f, -0.04226535f, -0.01837666f, -0.00668952f, 
    0.03222794f, -0.00309342f, 0.01649397f, -0.02490665f, 0.03200616f, 0.02576562f, -0.08997225f, -0.09157163f, 
    0.05923488f, 0.04006591f, -0.05336962f, 0.04978830f, 0.05206473f, -0.04290287f, -0.03412488f, 0.00141879f, 
    0.04030666f, 0.01607856f, -0.00752686f, -0.00356615f, -0.10478484f, 0.02625145f, -0.10426514f, -0.09405893f, 
    0.02910747f, -0.07033172f, -0.06084872f, -0.07994029f, -0.01222356f, -0.08944770f, -0.08077904f, 0.00894257f, 
    -0.00231289f, 0.03093861f, 0.04958051f, -0.03854868f, -0.05460282f, 0.02581066f, -0.00385658f, 0.02913620f, 
    0.05128312f, -0.10400498f, -0.01518305f, -0.06059387f, -0.02941838f, -0.07863750f, -0.03996664f, 0.05229601f, 
    -0.01042913f, -0.08590071f, -0.02950589f, 0.04564676f, 0.00752669f, 0.06489974f, 0.01832576f, -0.01453241f, 
    -0.07727230f, 0.04136411f, 0.07128192f, 0.00943361f, -0.05048259f, -0.06939746f, 0.07134781f, -0.08413394f, 
    -0.01718510f, 0.05243210f, -0.03658525f, 0.02640576f, -0.08724549f, -0.05989515f, -0.07856801f, 0.01498588f, 
    0.07320288f, -0.00208013f, -0.02263860f, -0.02914562f, -0.03111110f, -0.06519317f, -0.01654390f, 0.07054786f, 
    -0.05749522f, -0.02899270f, -0.02829986f, 0.06902245f, -0.04285034f, -0.02362353f, -0.04353712f, 0.01137134f, 
    -0.07158986f, 0.01892721f, 0.03733890f, 0.02929340f, -0.00035323f, -0.06909099f, 0.01086369f, -0.06875905f, 
    0.03510549f, 0.03274709f, 0.01948786f, -0.05381149f, -0.00571871f, 0.06954963f, 0.05213042f, 0.06076938f, 
    -0.10101930f, 0.00697898f, 0.02490261f, -0.05593385f, 0.03990993f, -0.02592895f, -0.03743577f, -0.02440814f, 
    -0.07737088f, 0.02356544f, 0.02777573f, 0.05351591f, 0.07217214f, -0.03993447f, 0.07057145f, -0.02133660f, 
    -0.08653679f, -0.02034301f, 0.07142754f, 0.03540649f, -0.01682099f, -0.01489364f, -0.04971910f, -0.04749322f, 
    0.04504744f, 0.00593851f, 0.04178052f, 0.00520097f, 0.00532802f, -0.01867963f, -0.07121714f, 0.05704512f, 
    -0.04863560f, -0.08249521f, 0.04906851f, -0.05117273f, -0.00159224f, 0.08110712f, -0.06245137f, -0.08150414f, 
    -0.05775581f, 0.02324724f, -0.06273599f, 0.01272916f, -0.07915144f, -0.05568608f, -0.06613589f, 0.02047009f, 
    0.02819866f, -0.07541814f, -0.05568741f, 0.05135456f, -0.05997720f, -0.04092747f, 0.03492559f, -0.08771438f, 
    -0.02266957f, -0.04724687f, -0.01409514f, 0.02671118f, -0.00278798f, 0.00869732f, -0.00323060f, 0.05446690f, 
    0.05476194f, 0.05192924f, 0.25901872f, -0.05815420f, -0.12325706f, 0.04811076f, 0.08379453f, 0.35569972f, 
    0.27628881f, 0.08342913f, 0.15619490f, -0.04876506f, 0.24799666f, 0.09682688f, -0.03214775f, 0.03775897f, 
    -0.13845424f, -0.24223928f, -0.03952374f, -0.05343099f, 0.03075630f, 0.08906510f, -0.07923057f, -0.07215711f, 
    -0.52513903f, 0.05810174f, -0.04326011f, -0.03327467f, 0.00492651f, -0.01192593f, 0.09151634f, -0.36705959f, 
    -0.05794827f, -0.02115637f, 0.13549478f, 0.16339737f, -0.13618442f, -0.05793872f, 0.20694698f, 0.23960927f, 
    -0.10917704f, -0.03273609f, -0.08964469f, -0.34400591f, -0.04163527f, -0.02233021f, -0.39616489f, -0.11782055f, 
    0.20407343f, 0.13192180f, 0.20227431f, 0.05219563f, 0.36944947f, -0.04938416f, 0.01901239f, -0.02925953f, 
    -0.04718269f, 0.19949879f, 0.12379726f, 0.22206926f, 0.11056608f, -0.34643233f, 0.04158155f, 0.27894875f, 
    -0.07815009f, 0.07895666f, -0.13230091f, -0.62238115f, 0.04849444f, -0.23833796f, -0.25980294f, -0.13760914f, 
    0.05909873f, 0.12113921f, 0.07562967f, -0.02028710f, -0.07524384f, -0.36141378f, -0.15044257f, 0.08199455f, 
    -0.14239077f, 0.14118038f, 0.03851229f, -0.12438221f, -0.03350509f, 0.06586464f, 0.24147996f, 0.24560176f, 
    0.17696697f, 0.06544533f, 0.06243803f, -0.39011091f, 0.07520048f, 0.05714124f, 0.05981221f, -0.40998083f, 
    0.21297832f, -0.15694924f, -0.06100677f, 0.28179696f, -0.10900214f, 0.11719853f, -0.00514508f, 0.10538441f, 
    0.10993028f, -0.14590499f, 0.28239596f, -0.19237500f, -0.14860648f, 0.01205987f, -0.13412261f, 0.25591385f, 
    0.19686353f, 0.03575693f, 0.11311014f, 0.04097696f, 0.28473294f, -0.40450191f, -0.05492103f, -0.32938415f, 
    0.04249758f, 0.23525348f, 0.27870294f, -0.04070660f, 0.13924159f, 0.54963696f, -0.50913250f, 0.07182192f, 
    0.08081127f, 0.25203806f, 0.23406745f, -0.01953873f, -0.07744738f, -0.11658442f, 0.00268135f, 0.00345173f, 
    -0.13153027f, 0.01922051f, 0.47381061f, -0.02867213f, 0.15299907f, -0.23307918f, 0.02545341f, 0.04225149f, 
    0.00896700f, 0.13850279f, 0.09387437f, 0.02392294f, 0.19462432f, -0.54553670f, -0.16170326f, -0.09038175f, 
    0.19543481f, 0.01529209f, -0.26855800f, -0.27665427f, 0.08800752f, -0.19231352f, 0.01775361f, -0.31765652f, 
    0.02871472f, -0.42290699f, -0.01617998f, 0.12984763f, 0.29638103f, -0.08183590f, -0.11097117f, -0.22149877f, 
    0.04455078f, -0.46513653f, -0.05213485f, 0.28112504f, 0.03901776f, -0.19251934f, -0.26560107f, 0.06815311f, 
    -0.34256327f, -0.20049921f, -0.24458890f, -0.02884228f, 0.06344307f, 0.08962957f, -0.36519176f, 0.12785874f, 
    0.24464992f, -0.21776472f, 0.03112840f, -0.32645401f, 0.12174012f, -0.09683393f, -0.22984315f, -0.04257045f, 
    -0.37285918f, 0.04320122f, 0.25536299f, 0.28213248f, -0.05839524f, 0.12918614f, -0.32234976f, 0.11232094f, 
    -0.05443322f, 0.23586096f, -0.01851899f, 0.13574503f, -0.00479490f, 0.12009005f, 0.21069971f, 0.07129762f, 
    0.00931089f, 0.15061918f, -0.02829682f, 0.06820821f, 0.02134136f, 0.17781955f, -0.08715577f, 0.16399819f, 
    -0.24397986f, 0.04860221f, 0.04023184f, 0.42432019f, 0.29486990f, -0.01169791f, 0.02676564f, 0.08480515f, 
    -0.27645063f, 0.07084294f, 0.28738889f, 0.06399827f, 0.25926113f, 0.16488683f, 0.26965752f, 0.15574835f, 
    -0.14499643f, 0.11619671f, -0.16101816f, 0.18303487f, 0.06282966f, 0.02346249f, -0.10559574f, 0.08404479f, 
    0.45458725f, -0.04020443f, 0.13790908f, 0.39045393f, -0.01682348f, 0.33660841f, 0.06358171f, -0.18462631f, 
    -0.14326803f, 0.11824723f, -0.45308605f, 0.19467263f, 0.13377079f, 0.13290983f, 0.07890563f, -0.05606593f, 
    -0.17874300f, -0.14026399f, 0.23284236f, -0.01341625f, -0.24188855f, -0.30200738f, 0.03917044f, 0.01703927f, 
    0.10447902f, 0.08230098f, 0.23558564f, 0.07283530f, -0.16632077f, 0.02946359f, 0.07514409f, -0.01887300f, 
    -0.10531898f, 0.05240616f, -0.00138963f, -0.06913998f, 0.09390049f, 0.13928476f, 0.09162982f, -0.02330947f, 
    -0.03061528f, -0.00632594f, 0.04306010f, 0.18370180f, -0.20712735f, -0.30264670f, -0.08554839f, -0.00011237f, 
    0.20862861f, 0.04461218f, -0.26926875f, 0.03708201f, -0.07364409f, -0.42412460f, 0.02253953f, 0.24884684f, 
    0.67653936f, -0.18494171f, 0.02230697f, -0.25850073f, -0.04910417f, 0.17873387f, -0.27683789f, 0.03191748f, 
    -0.36809689f, 0.13094862f, -0.16678244f, 0.05777359f, 0.29526159f, 0.08793984f, -0.04657919f, -0.14287937f, 
    0.26612979f, -0.13693133f, -0.18584834f, -0.00220782f, 0.02322753f, 0.08330561f, 0.04910134f, 0.49846515f, 
    -0.12028218f, -0.05282204f, -0.02801847f, -0.28321782f, 0.30861810f, 0.17220393f, -0.19583111f, 0.17807534f, 
    0.13473898f, 0.28505474f, -0.00879025f, -0.04840136f, 0.06862134f, -0.22342329f, -0.07159526f, 0.03427008f, 
    0.09087845f, -0.30861279f, -0.00780963f, 0.05093482f, 0.26582125f, -0.04227655f, 0.11116356f, 0.15220398f, 
    0.05668457f, -0.02725083f, -0.08673088f, -0.39294493f, -0.18798250f, -0.04828037f, 0.09986300f, -0.06102600f, 
    0.18852599f, 0.02163867f, -0.12011303f, 0.30196938f, 0.07656986f, 0.02188157f, -0.04098066f, -0.15986657f, 
    -0.79082316f, -0.12141082f, 0.04877084f, 0.02182835f, -0.09602904f, 0.49572060f, -0.20312952f, -0.23921737f, 
    -0.16926770f, 0.00298179f, 0.19775026f, 0.14203604f, -0.46446717f, -0.02001457f, 0.13639356f, 0.15443762f, 
    0.06776617f, -0.05363134f, 0.11118156f, -0.01996063f, 0.05636520f, 0.21605060f, -0.00417252f, 0.10690961f, 
    0.05739500f, 0.30153215f, 0.10095371f, -0.20700181f, 0.09961826f, -0.05857862f, 0.18648103f, -0.06499743f, 
    -0.18486899f, 0.03929274f, 0.19385742f, -0.00036311f, 0.08078162f, -0.07277493f, -0.05810357f, -0.07664691f, 
    0.03233660f, 0.18584241f, 0.01987747f, 0.05788211f, 0.05038427f, -0.14443615f, 0.08080733f, 0.08001219f, 
    0.23227288f, -0.07128342f, 0.00885980f, -0.13404150f, 0.21339846f, -0.07982602f, -0.00727710f, -0.23018803f, 
    0.11858033f, -0.09682725f, 0.25559175f, -0.10468499f, 0.06933001f, 0.19505997f, 0.22938460f, -0.05038062f, 
    -0.36278126f, -0.21474232f, 0.05815358f, -0.13960721f, 0.23162015f, 0.03191492f, -0.33239350f, 0.12902893f, 
    -0.35714787f, 0.00257112f, 0.00128574f, 0.13421386f, 0.06891719f, 0.09008687f, -0.03549704f, -0.01635903f, 
    0.02936604f, -0.13433510f, -0.26508218f, 0.00729126f, 0.08032111f, 0.11907286f, 0.03713722f, -0.18487014f, 
    -0.27101091f, -0.05749777f, 0.10408269f, -0.25223058f, -0.00957957f, 0.15067199f, -0.05049606f, 0.04077506f, 
    -0.09825081f, -0.16642818f, -0.00714953f, -0.02741295f, 0.01058167f, 0.18914528f, 0.06524871f, -0.07347573f, 
    -0.02810231f, 0.24012452f, -0.01993497f, -0.00077402f, -0.01641174f, 0.25084162f, -0.12366556f, 0.22713479f, 
    0.09008477f, 0.08070468f, -0.03390432f, -0.05505505f, 0.23222511f, 0.02886416f, -0.04499160f, -0.23626617f, 
    -0.00926093f, 0.20576040f, -0.18391830f, 0.03046922f, 0.13212670f, 0.22767647f, 0.23493445f, 0.03119007f, 
    -0.46024650f, -0.09580278f, -0.11675811f, 0.16626202f, 0.05490818f, 0.05201777f, -0.09335385f, 0.18795846f, 
    -0.10823973f, -0.12523650f, 0.11784109f, 0.13890176f, -0.30181089f, 0.19119647f, 0.13013509f, -0.03405146f, 
    0.07393472f, 0.11302503f, -0.28517282f, -0.04950182f, 0.08277082f, -0.27415714f, 0.02331160f, -0.06518764f, 
    -0.00273826f, -0.00362462f, -0.21421500f, -0.10132273f, -0.02041033f, -0.52894002f, 0.32917926f, -0.62700427f, 
    -0.11957112f, 0.02374805f, 0.03768717f, -0.09366186f, -0.24144684f, 0.09357902f, 0.18218419f, -0.07599773f, 
    -0.08157972f, 0.20989001f, -0.08301448f, 0.09477636f, 0.13405679f, 0.03785706f, 0.05450661f, 0.01705689f, 
    -0.30504909f, 0.14535898f, 0.32282257f, 0.16988499f, -0.13316643f, 0.29762357f, -0.18635520f, -0.15501328f, 
    -0.02716473f, 0.04303052f, -0.04220727f, -0.17864484f, -0.12180627f, -0.21018457f, 0.13873069f, 0.09508732f, 
    0.51643407f, -0.09277943f, 0.30446261f, -0.03030496f, 0.06052471f, 0.33279827f, -0.07179771f, -0.05411210f, 
    -0.17112617f, 0.14964707f, -0.20330662f, 0.07480101f, -0.06785548f, 0.12013403f, 0.20628509f, -0.05196986f, 
    -0.02677869f, -0.47633919f, -0.21421082f, -0.15022895f, 0.09685287f, -0.13309290f, 0.10552614f, -0.01291487f, 
    -0.02126712f, -0.00113144f, 0.10715611f, 0.35713440f, 0.08639819f, 0.17072980f, 0.41472912f, 0.18670368f, 
    -0.03948525f, 0.20464250f, 0.05772468f, -0.07830307f, 0.06432392f, -0.04880674f, -0.09887351f, 0.04720043f, 
    0.18973252f, -0.07214099f, -0.21883461f, -0.06287377f, 0.32121256f, -0.00733675f, -0.18591934f, -0.04004649f, 
    0.10662677f, 0.25467294f, -0.06643083f, 0.08192272f, -0.28563735f, -0.01437443f, -0.02789693f, -0.02934446f, 
    -0.06466463f, -0.07850303f, -0.38587636f, 0.30195615f, -0.07388713f, -0.05705867f, 0.00824080f, -0.09003176f, 
    0.40568078f, -0.11441475f, -0.23439236f, 0.08857854f, -0.02237375f, 0.34663552f, -0.02133095f, -0.15184161f, 
    0.37695074f, -0.04494373f, -0.01434904f, 0.14182635f, -0.20416871f, 0.27661368f, 0.21883614f, 0.46819305f, 
    0.02470085f, -0.52953869f, -0.30660030f, -0.59428394f, 0.01006517f, -0.23712987f, 0.35430533f, 0.25438958f, 
    0.20268111f, 0.13537979f, 0.05183274f, -0.03804304f, 0.34602243f, -0.02635748f, -0.00501024f, 0.11711272f, 
    -0.15912142f, 0.00472294f, -0.04049135f, 0.17588620f, -0.00796021f, 0.24425052f, 0.03921567f, -0.00260747f, 
    0.13388211f, 0.15274133f, -0.02609548f, 0.02106850f, -0.64787287f, 0.18884674f, 0.24501884f, 0.09624458f, 
    0.16212313f, 0.25497565f, 0.02739181f, 0.18825121f, 0.11967273f, 0.16535783f, 0.02878765f, 0.33437231f, 
    -0.05365573f, 0.05453648f, 0.37383062f, -0.17872950f, -0.08665902f, 0.17093995f, -0.30142257f, -0.09530295f, 
    0.21748041f, 0.20563735f, 0.18576197f, -0.39441967f, 0.15846547f, 0.20394292f, 0.22163400f, -0.07488766f, 
    -0.61236626f, -0.12555762f, 0.13514936f, -0.09059200f, 0.09857294f, 0.23814528f, 0.06215768f, 0.19389360f, 
    -0.17220247f, -0.73649138f, 0.03216927f, 0.12828897f, -0.15172550f, 0.05166086f, 0.02767541f, -0.67700046f, 
    -0.10095686f, 0.09828384f, 0.20963451f, 0.19676787f, -0.06691411f, 0.07318858f, -0.02360348f, 0.17526975f, 
    0.19625776f, -0.49879327f, 0.01247852f, -0.22576900f, 0.02542621f, 0.33669248f, 0.14615865f, -0.13424946f, 
    -0.15928861f, 0.17142914f, -0.20665227f, 0.16802213f, 0.13213962f, 0.00823529f, -0.19389379f, -0.08393824f, 
    0.11747051f, 0.16311848f, 0.03293945f, 0.14744698f, -0.08342871f, 0.08385426f, -0.22937895f, -0.18752399f, 
    0.05645931f, 0.00819927f, 0.00901919f, -0.00628143f, -0.16967663f, 0.21627954f, 0.09457241f, 0.10684090f, 
    -0.15328909f, -0.20111482f, -0.06055479f, 0.05628235f, -0.18183304f, 0.26421326f, 0.24958383f, 0.02501019f, 
    -0.18178958f, 0.13059179f, 0.01468707f, 0.00818907f, -0.22376369f, 0.00383936f, 0.23255531f, 0.05550390f, 
    0.02637435f, -0.14189880f, -0.32676634f, 0.20086287f, -0.15943329f, -0.07008678f, 0.30453053f, -0.11440545f, 
    0.06651211f, -0.00927792f, -0.03039461f, -0.08530374f, -0.08345200f, 0.06255493f, -0.02563960f, -0.06871813f, 
    -0.09122614f, 0.07555430f, -0.07675682f, 0.00768426f, 0.05728198f, 0.02440162f, 0.01291529f, 0.06151634f, 
    -0.07374811f, 0.00468995f, -0.03306178f, -0.00950698f, 0.06525817f, 0.06257533f, -0.02330074f, -0.04617805f, 
    0.08404110f, -0.05829342f, 0.01719606f, -0.03017318f, -0.00412983f, 0.03329824f, 0.07739998f, -0.03577722f, 
    -0.01682474f, 0.02493424f, 0.06835842f, -0.06846587f, -0.08049905f, -0.07384935f, -0.03924170f, 0.06610482f, 
    -0.06511116f, 0.06149583f, 0.04021008f, -0.08437407f, 0.05320289f, -0.01214506f, -0.03154930f, -0.09216206f, 
    0.08066683f, -0.07537140f, -0.04156882f, 0.00886585f, -0.07999938f, -0.10640043f, -0.07943860f, -0.07306741f, 
    -0.06275152f, 0.04412703f, -0.06043636f, -0.06166285f, 0.03773331f, 0.06196199f, -0.07041976f, -0.07592949f, 
    -0.07027899f, -0.08107918f, 0.02176933f, -0.05533070f, -0.04582855f, -0.06153592f, -0.09777758f, 0.05222684f, 
    0.01990019f, -0.03472557f, 0.08189131f, 0.04268393f, 0.02712895f, 0.02338622f, -0.04430642f, -0.06076083f, 
    -0.06899044f, -0.00659532f, 0.07676359f, -0.06889084f, -0.09475681f, -0.06452864f, -0.03816510f, -0.07438987f, 
    -0.07418156f, -0.03959414f, -0.00373554f, -0.00320330f, -0.01354588f, -0.08141425f, -0.02192058f, 0.04526788f, 
    0.02300263f, -0.03727978f, 0.04991878f, -0.05263516f, 0.05999605f, 0.02925097f, -0.08741233f, 0.01949162f, 
    0.06246461f, 0.03469914f, -0.09322648f, 0.05713569f, -0.04348181f, -0.00935707f, 0.02060365f, -0.03023654f, 
    -0.04626799f, -0.05187139f, -0.01363338f, 0.02515459f, -0.03457211f, -0.07628175f, -0.10341333f, 0.00104826f, 
    -0.03593345f, 0.07048483f, -0.02374580f, 0.03561288f, -0.04533787f, 0.08257765f, -0.04178195f, 0.04663604f, 
    -0.06648555f, 0.00240392f, -0.05811876f, 0.03381953f, 0.05027482f, 0.03543362f, 0.03915281f, -0.08146366f, 
    -0.09608079f, 0.00720586f, -0.04500982f, -0.01975185f, -0.09946318f, -0.02976176f, -0.01151429f, -0.04900599f, 
    0.02397091f, 0.03287356f, 0.03028438f, -0.08050073f, -0.00168696f, -0.08244854f, -0.07459880f, 0.02814868f, 
    -0.01561276f, 0.06606979f, 0.05235208f, -0.09836892f, 0.03088284f, -0.08142775f, 0.04298634f, 0.02049487f, 
    -0.00748516f, -0.06060053f, -0.04389381f, -0.00995285f, -0.04756581f, 0.04236210f, 0.05141003f, -0.00907839f, 
    0.06643932f, -0.08300638f, -0.06947793f, 0.05192635f, -0.01347694f, 0.02344284f, -0.05773980f, -0.06441168f, 
    -0.03131103f, 0.02644884f, -0.06571224f, 0.02848799f, -0.03689720f, 0.02804236f, -0.03242405f, -0.06012171f, 
    -0.00329968f, 0.07551276f, -0.05771899f, -0.07115705f, 0.01037387f, -0.07163250f, 0.01598566f, -0.00872292f, 
    -0.04641194f, 0.05010900f, -0.06821528f, -0.07986855f, -0.08622736f, 0.01200886f, -0.09259132f, 0.07466931f, 
    -0.01526738f, -0.09801273f, -0.05151831f, -0.00247595f, 0.05571943f, 0.03838317f, -0.07459090f, -0.03435897f, 
    -0.00457545f, 0.01264812f, 0.06104391f, 0.05544669f, -0.06959771f, -0.03693292f, -0.00908073f, -0.07683231f, 
    0.05070647f, 0.06419897f, 0.00152229f, -0.04529909f, -0.01665819f, 0.05653642f, 0.04507232f, 0.07221495f, 
    -0.06717085f, -0.02034430f, -0.05137576f, -0.00388728f, 0.02489914f, 0.00508076f, 0.03845765f, 0.02067176f, 
    -0.03694879f, -0.05055363f, 0.02081959f, -0.00088257f, 0.00243997f, -0.02320765f, -0.03206509f, 0.07749856f, 
    -0.06615154f, -0.02038950f, -0.05192059f, -0.00330052f, -0.07583991f, 0.05109266f, -0.01921932f, 0.04959464f, 
    -0.07859267f, 0.02002412f, -0.00021167f, -0.04863536f, -0.01964807f, -0.08204661f, -0.05005231f, -0.01810390f, 
    0.01526102f, -0.05585105f, -0.07737199f, 0.05478458f, 0.00458933f, -0.08203259f, 0.01202039f, 0.02191122f, 
    -0.06647236f, 0.04012664f, 0.05081796f, -0.05706316f, -0.04759579f, -0.05384852f, -0.05823821f, 0.07711283f, 
    0.02022349f, -0.01224121f, 0.01730167f, -0.01171545f, 0.08452927f, -0.08638030f, 0.05643368f, 0.05628322f, 
    0.06299572f, -0.05657381f, -0.08067711f, -0.06156345f, -0.08162361f, -0.03575670f, -0.08168852f, 0.03497421f, 
    -0.06007870f, -0.01488638f, 0.02077831f, -0.03067009f, -0.02559210f, 0.04910168f, -0.07711941f, -0.00573520f, 
    -0.05605781f, -0.08647022f, -0.03423505f, -0.08481067f, -0.07244116f, 0.05553994f, -0.01123240f, -0.03025210f, 
    0.04765154f, -0.07650901f, -0.03931529f, 0.00403655f, -0.00353280f, 0.04566302f, 0.07163882f, 0.02182925f, 
    -0.04794919f, 0.05662173f, 0.01974729f, -0.05175129f, -0.03734335f, -0.09255585f, 0.06406876f, 0.01757818f, 
    0.02144679f, -0.06062867f, -0.04004550f, 0.03708130f, 0.04629512f, -0.07567555f, -0.07917824f, -0.07153559f, 
    -0.06024036f, -0.00546642f, 0.04138049f, -0.08278909f, 0.01251324f, -0.06630609f, 0.05970979f, 0.01167712f, 
    0.02020419f, 0.01305700f, -0.02037904f, -0.07803532f, -0.04418351f, -0.06534597f, 0.03565619f, -0.04733507f, 
    -0.00050689f, -0.04411639f, -0.07472335f, 0.08504518f, -0.06976920f, 0.03099520f, 0.05805713f, -0.01692243f, 
    0.04705194f, 0.00017195f, -0.03685439f, 0.06344331f, 0.06089408f, -0.04671995f, -0.06811648f, 0.06505857f, 
    0.00753700f, -0.08555926f, -0.02069620f, 0.05020085f, -0.02396923f, -0.05375114f, 0.04805537f, -0.04797111f, 
    -0.05652410f, -0.01803014f, 0.06178735f, 0.05895413f, 0.03117779f, 0.07122213f, 0.04320136f, -0.05374607f, 
    -0.06547805f, -0.00137632f, -0.05920495f, 0.06016290f, 0.05599079f, 0.06940711f, 0.04469996f, -0.05998026f, 
    -0.06839503f, -0.38130641f, 0.23084089f, 0.26843253f, -0.20220079f, -0.04817291f, -0.26960868f, -0.03570347f, 
    0.44847676f, 0.04520872f, 0.05090254f, 0.24446596f, -0.17348237f, -0.20596710f, -0.23912287f, 0.02491553f, 
    0.16561031f, 0.07424793f, 0.03882751f, -0.05520035f, -0.03614535f, 0.18187463f, -0.08361703f, 0.11833585f, 
    -0.30273566f, -0.14352314f, 0.19938886f, -0.09185535f, 0.03979931f, 0.05435071f, -0.12760916f, 0.59028482f, 
    0.00970972f, 0.03051777f, -0.17106639f, 0.22198153f, -0.07779231f, -0.29297462f, -0.04491102f, 0.24500518f, 
    0.21043779f, -0.12146107f, 0.01794062f, 0.34643072f, 0.19329287f, 0.18870114f, -0.11601140f, 0.24629292f, 
    -0.22806886f, -0.08653389f, -0.39773673f, 0.05880757f, 0.10369663f, 0.10683855f, 0.08914390f, -0.10732189f, 
    0.02133614f, -0.48938075f, 0.11668023f, 0.03906685f, 0.03366585f, 0.25888869f, 0.03369361f, 0.40078419f, 
    0.22071080f, 0.08061495f, -0.05494499f, -0.22199357f, 0.18660861f, 0.03892964f, 0.13019802f, -0.11056586f, 
    0.11733185f, -0.07567511f, 0.03840099f, 0.22540775f, -0.08659166f, 0.24141358f, 0.01803417f, -0.09791838f, 
    -0.15653430f, -0.32657543f, -0.18770815f, 0.06529490f, 0.20795719f, 0.05251768f, 0.39704210f, -0.00698048f, 
    -0.12882856f, -0.35083738f, 0.06072354f, -0.09133542f, -0.11452390f, -0.01922832f, 0.45494738f, -0.34296831f, 
    0.25655308f, 0.21605800f, 0.18213935f, 0.08452140f, 0.13617021f, 0.17765652f, -0.03294252f, -0.14172848f, 
    -0.11582680f, -0.18062578f, -0.18268164f, 0.03631197f, -0.00257342f, 0.10987374f, 0.08169141f, 0.22363280f, 
    0.04067479f, 0.45837542f, -0.04616651f, -0.09329320f, -0.14949112f, 0.14417967f, 0.02315339f, 0.01837723f, 
    -0.19744776f, 0.16595691f, 0.25044221f, 0.07985866f, -0.08448065f, 0.05521770f, 0.01878741f, 0.21297103f, 
    0.06720743f, 0.33807081f, -0.42076826f, 0.15604495f, 0.22144528f, 0.13682304f, 0.40181243f, 0.11039042f, 
    0.16554837f, 0.00492738f, -0.77829498f, 0.18027535f, -0.40726891f, 0.07386413f, -0.14350948f, 0.04456604f, 
    -0.00307954f, 0.06772919f, 0.17424013f, 0.00449052f, 0.07562004f, -0.09358094f, 0.16522823f, 0.12028322f, 
    0.00495932f, 0.13304894f, 0.03329268f, -0.18069690f, 0.22507113f, 0.29407766f, -0.25379279f, 0.20563768f, 
    -0.23222028f, 0.25208148f, 0.20530830f, 0.05519105f, -0.07656365f, 0.06443956f, 0.04244212f, 0.00492694f, 
    -0.34707016f, 0.21675509f, 0.14617604f, -0.04652141f, -0.11757644f, -0.17373474f, 0.14877589f, -0.21479878f, 
    -0.16253467f, -0.01296059f, 0.29831287f, 0.12680660f, -0.02684980f, -0.15977652f, 0.11057013f, 0.06504475f, 
    -0.25034603f, 0.19255511f, 0.20334736f, 0.15679927f, -0.43872517f, 0.05937238f, 0.11503334f, 0.04187996f, 
    0.07007406f, 0.00970330f, 0.01772761f, 0.08874850f, -0.40489990f, -0.14007416f, 0.54346472f, -0.23384406f, 
    0.19150552f, -0.13381369f, 0.07661175f, -0.14257182f, -0.00857987f, 0.11326123f, 0.10106594f, 0.05112854f, 
    -0.25316632f, -0.03012330f, 0.24889250f, -0.22217724f, -0.16077642f, -0.17384477f, -0.16493203f, -0.33479711f, 
    0.02540237f, -0.01244822f, 0.06461079f, -0.05016901f, -0.36344150f, -0.12308072f, -0.33265081f, -0.21347891f, 
    0.27859336f, -0.20794980f, 0.05869474f, -0.34236103f, -0.22079924f, 0.12213718f, -0.12321617f, -0.03636900f, 
    0.48169586f, -0.03709429f, -0.14306785f, -0.10817344f, -0.24861583f, -0.18450591f, 0.13867797f, -0.18681988f, 
    -0.05909110f, 0.04647629f, -0.36553323f, -0.37650409f, 0.49538296f, -0.29699689f, 0.15923974f, 0.00227647f, 
    0.19091441f, -0.24551073f, 0.51654947f, 0.12798144f, -0.58984160f, -0.38958681f, 0.17125468f, 0.03702689f, 
    -0.03066568f, -0.06559946f, -0.02375836f, -0.12935783f, -0.06450117f, -0.00083628f, 0.22008371f, 0.22605692f, 
    0.07251258f, 0.07594417f, -0.01811649f, 0.05250724f, 0.03969730f, 0.08174749f, 0.08386534f, -0.03342670f, 
    -0.11566918f, -0.04477757f, 0.28887197f, -0.03616987f, 0.04103160f, -0.30343774f, -0.13365778f, 0.04103134f, 
    0.22468287f, 0.00381326f, -0.17050019f, -0.24730945f, 0.00288951f, -0.15227015f, 0.06195230f, 0.15321949f, 
    0.02633729f, -0.09187046f, 0.20779227f, 0.05774365f, 0.00604263f, -0.08144930f, 0.34615880f, 0.11471890f, 
    -0.09566884f, -0.05360439f, 0.00015802f, -0.15974911f, -0.06880251f, -0.04844074f, -0.59120667f, -0.01143974f, 
    -0.21490885f, 0.26710013f, 0.10026322f, 0.13712046f, 0.17345211f, 0.10040452f, 0.06084813f, -0.03337873f, 
    0.07416251f, 0.27534509f, -0.02593972f, -0.00238714f, 0.00838635f, -0.16968079f, 0.08008427f, 0.34819648f, 
    -0.25630260f, -0.07182657f, -0.01253121f, -0.96841723f, 0.28545779f, 0.01697839f, 0.24205306f, -0.14770532f, 
    -0.00159899f, 0.06835952f, 0.05242235f, 0.04311028f, -0.04251575f, -0.14065801f, -0.04391902f, 0.06869645f, 
    0.07920597f, 0.07899558f, 0.16479842f, -0.22544748f, 0.08090530f, -0.02720803f, 0.11517937f, 0.09475074f, 
    0.14691152f, 0.22306120f, -0.08091375f, -0.32970807f, 0.07498728f, -0.03416963f, -0.11338235f, -0.35748339f, 
    0.25173157f, 0.16355667f, -0.00599800f, 0.14916252f, -0.09440037f, 0.07182883f, 0.26707351f, 0.00157418f, 
    -0.40058982f, 0.01433264f, 0.13565817f, -0.09693802f, 0.01197447f, 0.24115080f, -0.07311665f, -0.17104715f, 
    -0.23274373f, 0.00144201f, 0.21290722f, -0.03230898f, -0.02344389f, -0.13934493f, 0.04967126f, 0.06246756f, 
    0.16008183f, 0.06097388f, 0.37256572f, -0.05043194f, 0.13912240f, 0.49876818f, -0.00864136f, 0.15449482f, 
    -0.27580148f, -0.11690462f, 0.12172109f, 0.04802379f, 0.18715909f, -0.07785435f, -0.06832761f, -0.04006105f, 
    -0.09277574f, -0.04904520f, 0.05614036f, 0.05304188f, -0.23814222f, -0.09113804f, -0.09718654f, 0.05916393f, 
    -0.02064468f, -0.03756014f, 0.00101506f, -0.00672887f, -0.11501894f, 0.03692943f, 0.13705736f, 0.04469427f, 
    0.43039772f, -0.01647036f, -0.06616856f, -0.12266832f, 0.07755014f, 0.03413886f, 0.10529537f, -0.14133464f, 
    0.30494288f, -0.01973892f, 0.07975964f, -0.36533412f, 0.12646368f, 0.00327198f, 0.05447408f, -0.09295294f, 
    0.34053850f, -0.21833469f, -0.24822012f, 0.11817950f, 0.01562484f, 0.01420462f, -0.07138523f, 0.16338089f, 
    0.39026749f, -0.18994661f, 0.03158079f, 0.03352535f, -0.00991106f, 0.04026468f, -0.05487217f, -0.07162213f, 
    0.27715501f, 0.08011476f, -0.03447054f, 0.08894765f, -0.20237140f, 0.41779044f, 0.10309017f, 0.09362332f, 
    0.01595477f, -0.11149396f, -0.01081890f, -0.31110087f, -0.01046843f, 0.04262319f, 0.09176290f, -0.00351297f, 
    0.10374741f, 0.28588367f, -0.05284888f, -0.06424251f, 0.01522157f, 0.08184752f, 0.10576349f, 0.03765723f, 
    -0.08966748f, -0.21375525f, 0.17842051f, 0.11848493f, 0.10035737f, 0.16485395f, 0.24690910f, 0.04353695f, 
    -0.06292792f, 0.24861833f, 0.12498032f, -0.19720949f, 0.00547129f, 0.06691822f, 0.07694003f, -0.04790322f, 
    0.14413282f, 0.33782205f, 0.10625922f, -0.21884610f, 0.06950816f, -0.06251410f, 0.28987920f, -0.12550342f, 
    -0.45253941f, 0.37068313f, -0.06649385f, -0.09039784f, -0.15627110f, 0.23761296f, -0.04684358f, 0.09781823f, 
    -0.39408049f, 0.25000453f, 0.08856969f, -0.12253447f, -0.50795633f, 0.07729059f, 0.09127203f, -0.14297140f, 
    0.13498311f, 0.08938006f, 0.01918489f, 0.05460108f, 0.05141623f, -0.56126165f, -0.14335229f, -0.28494525f, 
    0.01989157f, -0.10504455f, -0.05166435f, 0.31576452f, -0.15497649f, -0.09750678f, -0.01713910f, 0.04865854f, 
    0.38098913f, 0.00206317f, -0.06922642f, 0.13883866f, -0.03360970f, -0.05929971f, 0.03169846f, 0.04531374f, 
    0.10475748f, -0.03027298f, 0.15051788f, -0.05082680f, 0.03822595f, -0.03630910f, -0.00143244f, -0.02971708f, 
    -0.34490809f, -0.09924097f, 0.11170448f, 0.28823498f, -0.05860588f, -0.19733337f, -0.03826403f, -0.37400943f, 
    -0.00213917f, 0.09886634f, -0.48404810f, 0.22677653f, 0.03634617f, -0.10076073f, -0.00890138f, 0.16085026f, 
    0.66104543f, 0.11700900f, 0.25818130f, 0.51620781f, -0.01701393f, 0.11704633f, 0.00818309f, 0.03700075f, 
    -0.38497984f, 0.04741221f, -0.11619318f, 0.03575545f, 0.04428875f, -0.05400340f, -0.07069724f, 0.08838581f, 
    0.20644222f, -0.18380496f, 0.03843710f, -0.10645721f, 0.14084543f, 0.05570760f, -0.05734414f, 0.03145620f, 
    -0.01743901f, 0.00977525f, -0.04769982f, 0.45212895f, -0.00554928f, 0.17130612f, -0.52782768f, 0.14558406f, 
    0.26777273f, -0.04522074f, -0.05171520f, 0.15270740f, -0.08324689f, 0.02007863f, -0.04372795f, 0.01755796f, 
    0.04068095f, -0.11122654f, -0.10791595f, 0.15823585f, -0.03078594f, 0.01756646f, 0.08928180f, -0.01526787f, 
    -0.08708495f, -0.11029255f, 0.08444948f, 0.12882961f, -0.01188150f, 0.02406221f, 0.35997453f, 0.43902692f, 
    -0.07011522f, -0.04037824f, 0.24436554f, 0.12424515f, 0.18108973f, 0.17951962f, -0.17440479f, -0.05268961f, 
    0.40892676f, -0.07336918f, 0.10434804f, 0.22370060f, 0.10507991f, -0.12359162f, -0.08031896f, -0.08613535f, 
    0.21427937f, 0.05063061f, -0.09778319f, 0.16371691f, -0.03548090f, 0.15374902f, 0.05103873f, 0.17450054f, 
    -0.02713002f, 0.08846284f, -0.01335329f, 0.11251599f, 0.01615110f, 0.00159943f, 0.18510924f, 0.22118962f, 
    0.01653720f, -0.27227819f, 0.08502878f, 0.30264860f, -0.29107392f, 0.07737437f, 0.13107893f, 0.15592305f, 
    0.47178051f, -0.08556309f, -0.10065621f, 0.09989267f, 0.07061646f, -0.01452413f, -0.00845884f, 0.00880955f, 
    -0.04704375f, -0.03782180f, -0.19841915f, -0.05074237f, 0.15599117f, -0.21571441f, -0.16508889f, 0.08076396f, 
    -0.52674639f, 0.30957896f, -0.08979817f, 0.04457527f, -0.11986464f, -0.27571142f, -0.13491546f, 0.33845338f, 
    -0.11320585f, 0.02222865f, -0.22821879f, 0.31936651f, 0.15912582f, -0.30461553f, -0.03699764f, 0.23461878f, 
    0.12550390f, 0.05310119f, 0.16863631f, 0.15273765f, -0.05304422f, -0.08061792f, -0.73114645f, -0.04318533f, 
    -0.69150060f, 0.16770422f, 0.11386281f, 0.00247346f, 0.19020313f, 0.05740431f, -0.21918488f, 0.10415665f, 
    0.22185986f, 0.09505485f, 0.16567415f, 0.10528475f, 0.06140901f, -0.13348447f, 0.00223411f, 0.43412313f, 
    -0.09656467f, 0.15267557f, -0.13317865f, -0.50969404f, 0.14090967f, -0.01205583f, 0.13219292f, 0.06405997f, 
    0.14509413f, -0.07955158f, 0.04718630f, 0.25445637f, -0.07468478f, 0.06608228f, -0.07181098f, 0.10354736f, 
    -0.00191367f, -0.21715175f, 0.10697701f, -0.07512581f, 0.09756318f, -0.13141096f, 0.37578374f, 0.13777100f, 
    -0.08495142f, -0.34874809f, 0.09026033f, -0.32467327f, 0.04514576f, -0.01515120f, 0.08550536f, 0.06834758f, 
    0.25194734f, 0.03559202f, 0.36443987f, 0.17006820f, 0.05932350f, 0.14846759f, -0.35325012f, 0.06565133f, 
    0.01211693f, 0.26545170f, -0.04516833f, 0.13525639f, -0.14806695f, -0.14526707f, -0.25440183f, -0.17194416f, 
    0.20776187f, -0.09801608f, -0.01224584f, 0.11901000f, 0.30040094f, -0.03705491f, -0.00098388f, 0.00562903f, 
    -0.15995160f, 0.21738674f, 0.31351337f, -0.04921041f, 0.05570906f, 0.43050995f, -0.01471585f, 0.20422556f, 
    -0.08730087f, -0.01996230f, -0.01940737f, 0.05205959f, -0.06144521f, -0.01364840f, 0.03331519f, 0.00232950f, 
    0.04675509f, 0.08332463f, 0.01153400f, 0.02915605f, 0.04773327f, 0.07010520f, 0.02146864f, 0.01595800f, 
    -0.03259309f, 0.04314779f, -0.01432560f, 0.04978641f, 0.05849673f, -0.00927295f, -0.07997681f, 0.01171711f, 
    -0.01954540f, 0.04086749f, 0.00676415f, 0.01854169f, -0.09342086f, -0.03799454f, 0.00099587f, 0.00165048f, 
    -0.07517997f, 0.00345068f, -0.00970434f, -0.03286014f, 0.02082718f, -0.10215081f, -0.00211570f, 0.00186022f, 
    -0.08125019f, -0.03436508f, -0.04332377f, 0.04913766f, -0.10809149f, -0.01612334f, -0.09265263f, -0.07319012f, 
    -0.04903074f, -0.04771426f, 0.03118155f, -0.00721767f, 0.05712571f, 0.06509477f, -0.08741575f, 0.02246753f, 
    -0.01771063f, 0.02938522f, 0.00206934f, 0.05325423f, -0.09902287f, -0.02486600f, -0.01536827f, -0.08707868f, 
    -0.08430943f, 0.01663840f, -0.07642284f, -0.04746835f, -0.07098281f, -0.09402794f, 0.04647696f, 0.03720662f, 
    -0.11065982f, 0.04911101f, -0.01634530f, 0.02866362f, 0.06419515f, 0.06329563f, -0.04855241f, 0.07781701f, 
    0.00073409f, -0.10207418f, 0.01146227f, 0.00038148f, 0.04932464f, -0.04176671f, -0.06987452f, -0.03467393f, 
    -0.00803281f, -0.06019366f, -0.06388539f, -0.04989089f, 0.02335789f, -0.06673001f, -0.08416112f, 0.07024071f, 
    0.00606393f, 0.06893885f, -0.05563242f, -0.04388347f, -0.05969665f, -0.01457809f, -0.05841526f, -0.06363445f, 
    -0.10624801f, 0.00980737f, 0.04364446f, -0.01606413f, 0.04771042f, -0.04629431f, 0.06879383f, 0.06476884f, 
    -0.07186614f, 0.05579059f, -0.04671852f, -0.04937182f, -0.02136856f, 0.00689662f, -0.03446281f, -0.04374170f, 
    -0.04502003f, 0.01579338f, -0.03220031f, -0.05884848f, -0.08258365f, 0.03829218f, -0.10399367f, 0.05464121f, 
    0.12966102f, -0.24159992f, 0.10585963f, 0.11259457f, 0.10724827f, 0.01233623f, -0.05631479f, 0.08272214f, 
    0.14871962f, -0.04068175f, 0.00767206f, 0.05083214f, 0.03663797f, 0.11270091f, -0.13435318f, 0.06132534f, 
    0.30260354f, 0.14470279f, -0.12643981f, -0.06303053f, -0.18925698f, 0.18563768f, 0.10403023f, 0.13324313f, 
    -0.41973040f, 0.22798346f, 0.00267993f, 0.41106135f, 0.02913849f, 0.20627700f, 0.05661745f, -0.16199057f, 
    -0.05142365f, 0.19842046f, -0.02201125f, -0.00595909f, 0.12887765f, -0.04754644f, -0.07251263f, 0.18469064f, 
    0.90478653f, 0.20936394f, 0.20776030f, -0.02639057f, 0.14786062f, 0.15182781f, 0.09696997f, -0.03147464f, 
    -0.21890096f, 0.03368174f, -0.15584493f, -0.10805546f, 0.12703681f, 0.02931873f, 0.13277568f, 0.20598897f, 
    0.22819215f, -0.52749372f, -0.06341382f, 0.06805991f, -0.06540771f, -0.12663023f, 0.12637825f, -0.11633956f, 
    -0.04839702f, -0.02251666f, 0.06189815f, 0.08339298f, 0.14877303f, 0.22656846f, -0.28593835f, 0.16451326f, 
    0.53183275f, -0.00504575f, -0.07415535f, 0.06414543f, 0.05921177f, -0.02124451f, 0.01136477f, 0.06403057f, 
    -0.05453307f, -0.14484979f, -0.24383536f, 0.26305297f, -0.11140388f, -0.18986213f, -0.35806167f, -0.12318015f, 
    -0.01743471f, -0.06092642f, 0.05172348f, 0.15214533f, -0.09039233f, 0.06327876f, 0.13968317f, 0.34740418f, 
    0.07385216f, 0.14131916f, 0.07975648f, -0.03342484f, 0.08790699f, 0.34344891f, 0.08869832f, -0.02839126f, 
    0.17677635f, -0.40247586f, 0.21762255f, 0.14430474f, 0.02521893f, 0.10928666f, 0.13549955f, -0.02785661f, 
    -0.27329335f, 0.10992784f, -0.11922918f, 0.01547209f, -0.35210133f, 0.19935873f, -0.05733981f, 0.15421441f, 
    0.01758879f, 0.07530304f, -0.12556843f, 0.11843378f, 0.04698581f, 0.11040174f, 0.45267826f, 0.12737928f, 
    0.10919214f, 0.22757424f, -0.21636268f, 0.14023235f, -0.12538511f, 0.00215779f, 0.32238427f, -0.06840921f, 
    -0.10172218f, -0.04131229f, -0.04504814f, -0.15750670f, 0.04213145f, 0.06473135f, 0.02344953f, -0.02137880f, 
    -0.06769092f, -0.03917791f, 0.04977401f, -0.05334116f, 0.02705060f, 0.11002802f, -0.01349262f, 0.08859961f, 
    0.26846349f, 0.15922737f, 0.16688195f, 0.00152107f, -0.02171515f, -0.00208954f, 0.13601260f, 0.26111132f, 
    -0.18819939f, 0.20818055f, 0.07212734f, 0.10418005f, -0.07031069f, -0.03320523f, -0.02998302f, 0.21058351f, 
    -0.10268950f, 0.09295934f, 0.14424846f, -0.15912265f, -0.01591508f, 0.11725736f, 0.06227555f, -0.35794568f, 
    0.12139856f, 0.04244895f, -0.13673259f, 0.21930641f, -0.03986668f, 0.02416381f, 0.11462311f, 0.10372005f, 
    -0.24033701f, 0.32683384f, -0.01952561f, -0.02988305f, 0.13524182f, -0.47577715f, 0.14557907f, 0.06710327f, 
    0.05969748f, 0.23549967f, -0.05012605f, 0.00108463f, 0.07858687f, 0.04892429f, 0.35434282f, -0.05325683f, 
    0.23592420f, -0.03535661f, -0.07886582f, -0.17476523f, -0.04661427f, -0.17324348f, -0.01709489f, 0.00588756f, 
    -0.00507583f, 0.09797922f, -0.27149683f, -0.03954668f, 0.19083883f, -0.19491789f, -0.14311963f, -0.00555178f, 
    0.01512042f, 0.04774613f, 0.09792969f, 0.11781720f, -0.21390238f, -0.13030189f, -0.05164720f, 0.12246396f, 
    0.03701423f, -0.10601701f, -0.10720828f, 0.16935277f, -0.13617899f, 0.08403270f, -0.13073392f, 0.03327404f, 
    0.45770770f, -0.42890275f, 0.01240449f, -0.05005720f, -0.13236532f, -0.02635397f, 0.13541305f, 0.13560732f, 
    0.13819486f, -0.12693977f, 0.00199115f, 0.18294112f, 0.27025509f, 0.04252433f, 0.03676078f, 0.07283828f, 
    -0.15927593f, -0.27257559f, 0.37851501f, -0.14899643f, -0.08235068f, 0.19889243f, 0.13912807f, 0.19558492f, 
    -0.03382054f, -0.06779245f, -0.06519458f, 0.03833525f, 0.02328322f, 0.01553257f, -0.03379029f, 0.02626928f, 
    -0.01859269f, 0.01515966f, -0.08420358f, -0.01245795f, 0.08337675f, 0.05278449f, 0.06935512f, -0.02712000f, 
    0.05302774f, -0.04271767f, -0.00155437f, 0.04885135f, -0.02199301f, 0.01127841f, -0.05827212f, -0.08202411f, 
    -0.06319017f, 0.04813121f, -0.00410888f, -0.05182509f, -0.07087754f, 0.05361514f, 0.03191987f, 0.02662115f, 
    0.05331627f, 0.04403871f, -0.06589829f, 0.03271912f, -0.05380820f, -0.02221026f, 0.08356889f, -0.06327961f, 
    -0.02670469f, -0.00258328f, -0.05428737f, -0.04939738f, -0.00133099f, 0.05887261f, -0.01925187f, -0.00486994f, 
    -0.05080746f, -0.03760031f, -0.04270181f, -0.02825698f, -0.02144420f, -0.03509779f, -0.08144136f, 0.04889891f, 
    -0.03739911f, -0.02429082f, -0.08647048f, -0.00492261f, 0.00260784f, -0.01005568f, -0.04416512f, -0.04362594f, 
    -0.04114290f, -0.07904867f, -0.08643212f, 0.07641885f, -0.03068438f, 0.01824172f, 0.06520697f, -0.02782990f, 
    0.02072744f, -0.05204919f, 0.07617448f, -0.07249339f, -0.04311163f, -0.04729693f, -0.07057527f, 0.03834304f, 
    -0.00661425f, -0.07588100f, 0.04583883f, -0.01301119f, -0.08490375f, 0.08071605f, 0.05784009f, -0.02400769f, 
    -0.05721485f, -0.08080870f, -0.05461007f, 0.01313997f, -0.08455969f, -0.08234899f, 0.08327083f, 0.00437699f, 
    -0.08718849f, 0.01773587f, 0.06016209f, -0.04186914f, 0.05102724f, 0.00102370f, 0.01680490f, -0.02203728f, 
    0.07035422f, 0.01388835f, -0.04208751f, -0.04291649f, -0.08005378f, -0.04035893f, -0.05930338f, 0.05953341f, 
    0.03172234f, -0.05595634f, 0.04633834f, 0.04354789f, -0.01135825f, -0.01441898f, 0.07463119f, 0.02686650f, 
    -0.05645442f, 0.05201329f, -0.04662419f, 0.05050811f, 0.05445954f, -0.02845451f, -0.02860180f, 0.08737300f, 
    -0.16255365f, -0.32425749f, 0.04175098f, 0.24192235f, -0.05874797f, -0.09850878f, -0.03670978f, 0.02567294f, 
    0.35767850f, 0.08269455f, -0.14542310f, 0.08904319f, -0.18591405f, 0.02840713f, -0.17161797f, 0.06048083f, 
    0.07189078f, -0.10968929f, 0.04185087f, 0.02968208f, 0.03623353f, 0.10091999f, 0.03997352f, 0.12120239f, 
    -0.03176973f, -0.23579063f, 0.22303164f, 0.20096110f, 0.01453857f, 0.13073282f, -0.17413913f, 0.33351055f, 
    0.00843591f, 0.24620424f, -0.10207442f, 0.06532349f, -0.05575534f, -0.25007510f, 0.02242159f, 0.23329735f, 
    0.29789501f, 0.15982965f, 0.17449503f, 0.13084860f, -0.16073127f, 0.03283213f, -0.29571301f, 0.04968753f, 
    0.11208065f, 0.06338287f, -0.05714510f, 0.09290296f, 0.11365381f, 0.15032150f, 0.13258277f, -0.01532804f, 
    0.17211868f, -0.03506842f, 0.11716903f, 0.10269651f, -0.00431940f, 0.05196066f, 0.14046523f, 0.36456969f, 
    0.09244607f, -0.01933915f, -0.08717066f, -0.27500769f, 0.13462253f, 0.11809178f, 0.19676332f, 0.01684197f, 
    0.29370007f, -0.11407091f, 0.09941332f, 0.03079041f, -0.00880912f, -0.07192402f, 0.00357268f, -0.06164349f, 
    -0.05008969f, -0.28369939f, -0.11824564f, 0.01292322f, 0.03248041f, -0.16399784f, 0.17994140f, -0.02562716f, 
    -0.10917319f, -0.17278729f, 0.08682573f, -0.47082832f, -0.24551900f, 0.01455909f, 0.16075972f, -0.00366686f, 
    0.37398362f, 0.09794115f, 0.16096465f, 0.18455034f, 0.13346027f, 0.12604031f, -0.12343198f, -0.11423816f, 
    0.32440859f, -0.19183809f, 0.08403998f, -0.01033775f, -0.19841023f, 0.23894666f, 0.04922274f, -0.14982302f, 
    -0.10409213f, 0.30084568f, -0.00144464f, -0.09702036f, -0.09995994f, -0.04788334f, 0.01106317f, 0.12995213f, 
    -0.07119078f, -0.01725384f, 0.60590625f, 0.12520152f, 0.02655094f, 0.16920219f, -0.06447387f, 0.10684139f, 
    0.04880966f, -0.00113628f, -0.03923474f, -0.06177191f, -0.03654710f, -0.01277084f, -0.03703367f, -0.05492301f, 
    -0.00250809f, 0.03285265f, 0.03460078f, -0.08221267f, -0.06785586f, -0.10622853f, -0.06798919f, -0.06326835f, 
    -0.04183576f, 0.03989737f, -0.00499458f, -0.01799354f, -0.08615778f, -0.01063560f, -0.03263409f, -0.08412270f, 
    0.06888200f, -0.00883867f, 0.02484641f, -0.04969320f, -0.02670873f, -0.03597030f, -0.07172565f, 0.07456396f, 
    -0.05706629f, 0.00771719f, -0.09169219f, -0.03963930f, -0.09243327f, -0.06053873f, -0.08511505f, -0.05379418f, 
    0.04731334f, -0.04787689f, -0.09485419f, -0.01195605f, -0.05229957f, -0.07849232f, 0.00862445f, -0.08629026f, 
    -0.07378767f, -0.03529856f, -0.05354762f, -0.04875368f, 0.01092409f, 0.00105361f, 0.02396202f, -0.08473387f, 
    0.05270070f, -0.05366547f, -0.01786715f, 0.06084539f, -0.03238510f, -0.02641297f, -0.11023709f, -0.02285675f, 
    0.04774458f, -0.07878998f, -0.07897171f, -0.00113984f, -0.10357103f, -0.10985288f, 0.05864133f, -0.09267480f, 
    0.02060335f, 0.01917775f, 0.04442880f, 0.00743144f, 0.07640947f, -0.02326231f, -0.09181269f, 0.00262766f, 
    -0.07413945f, 0.05136354f, -0.06273669f, 0.02989115f, -0.08918145f, 0.05716156f, -0.02906167f, -0.06840054f, 
    0.04287358f, -0.05027402f, 0.08390696f, -0.00359517f, -0.00321200f, -0.07688205f, -0.03323945f, -0.04206231f, 
    0.06716219f, -0.05544227f, -0.05799284f, 0.01977609f, -0.07145657f, 0.02275519f, -0.07694223f, 0.02152689f, 
    0.02632178f, -0.01816791f, -0.08469643f, 0.02014218f, -0.10876490f, -0.09930868f, -0.02444019f, 0.01863246f, 
    0.07885810f, 0.05253287f, -0.00312368f, -0.05798602f, -0.01515409f, 0.01010852f, 0.03046591f, -0.09902019f, 
    0.03970890f, 0.05630337f, 0.03601013f, -0.09142656f, 0.05110142f, -0.03866613f, -0.10339591f, -0.09897766f, 
    0.06712878f, -0.09510837f, 0.02746490f, -0.04805736f, 0.04962188f, -0.00019890f, 0.02348213f, -0.04263630f, 
    -0.03966327f, -0.02324686f, -0.05394167f, -0.00516665f, -0.01599159f, -0.00366055f, 0.01761484f, -0.08590668f, 
    -0.04101186f, 0.07248683f, 0.03175614f, -0.00756753f, -0.03658977f, 0.02594198f, -0.09685566f, -0.06674182f, 
    0.06071310f, -0.06234723f, -0.03216320f, -0.08146968f, -0.01175452f, 0.07247441f, -0.01985982f, -0.07843058f, 
    -0.06521641f, -0.04497799f, -0.03317390f, -0.06978928f, 0.03565599f, 0.04688739f, -0.09368911f, -0.08707964f, 
    -0.03408695f, 0.07976149f, 0.03339699f, -0.08550470f, 0.03214576f, 0.06865133f, -0.04258680f, -0.02713356f, 
    0.01362397f, -0.02882468f, -0.01724455f, -0.03920101f, -0.03132100f, 0.01635816f, -0.01793934f, 0.01111882f, 
    -0.06399687f, -0.01321242f, 0.02231502f, 0.04337876f, 0.03184302f, -0.02335046f, -0.04311323f, -0.08502074f, 
    -0.00137815f, -0.01036241f, 0.03047527f, 0.02403439f, 0.00545560f, -0.01166525f, -0.00735003f, -0.06526164f, 
    0.04238056f, 0.03198752f, 0.06636057f, 0.04288236f, -0.04901997f, -0.06575892f, -0.02826843f, -0.01678086f, 
    -0.04780109f, -0.00554663f, 0.04124405f, -0.09222469f, 0.03941782f, -0.06702188f, -0.06156082f, -0.01621157f, 
    0.02203326f, 0.01639039f, -0.00979990f, 0.04966512f, -0.02590820f, 0.04583409f, 0.06811160f, 0.04414386f, 
    -0.04534155f, 0.04961184f, -0.05835670f, 0.01367226f, -0.05485658f, -0.01686083f, -0.01575383f, 0.05315460f, 
    -0.03971770f, 0.06198207f, -0.05916423f, -0.06380876f, 0.01198089f, -0.05899839f, -0.01931640f, -0.00847665f, 
    -0.02685997f, -0.00987823f, 0.06200214f, -0.01405116f, -0.01478661f, -0.01790135f, -0.04051160f, 0.02943680f, 
    -0.05369014f, 0.06492071f, -0.01042500f, -0.07977632f, 0.01489335f, -0.01568766f, 0.02326963f, -0.06831010f, 
    0.20735955f, 0.00346976f, 0.28203461f, 0.02048989f, 0.23148295f, 0.30144835f, -0.09563839f, 0.00442169f, 
    -0.16054839f, -0.06562217f, 0.13878912f, 0.01436445f, 0.21903998f, -0.29528967f, -0.19990438f, 0.04034775f, 
    0.08962167f, -0.09582876f, -0.38329980f, 0.00754674f, -0.00283263f, 0.01440333f, -0.09393118f, -0.16026868f, 
    0.44565889f, 0.04945667f, -0.12046316f, -0.12719302f, 0.18346846f, 0.35853821f, 0.19794770f, -0.16282962f, 
    0.00456545f, -0.15924956f, 0.24090783f, 0.01351918f, 0.23523776f, 0.49417442f, 0.20381890f, -0.21865174f, 
    -0.47768465f, -0.38985240f, -0.45416588f, 0.29406583f, -0.31808412f, -0.12946931f, 0.21157895f, 0.16841899f, 
    0.90712255f, -0.19108431f, -0.07196627f, 0.05085887f, -0.11092739f, -0.08054177f, -0.08096790f, 0.15411684f, 
    0.25999233f, 0.32898605f, 0.07492038f, 0.08693385f, 0.17566423f, 0.01827047f, -0.08442890f, -0.19253461f, 
    0.17419459f, -0.03210136f, 0.06333403f, -0.31726426f, -0.34939545f, -0.03266017f, -0.02947043f, 0.02340472f, 
    -0.10904264f, 0.09801700f, -0.01044347f, 0.14297381f, -0.08737035f, -0.05494631f, 0.19797149f, -0.16467580f, 
    -0.02253803f, 0.07960226f, 0.26542282f, 0.08284821f, -0.35509637f, 0.27497923f, -0.29822797f, 0.04862631f, 
    -0.08070822f, 0.06633189f, 0.06300398f, 0.13731138f, 0.22964968f, 0.03171992f, 0.37415484f, 0.17562248f, 
    -0.15292536f, -0.03871945f, 0.21264575f, -0.36639586f, 0.25328434f, -0.02217131f, 0.21695112f, 0.07655394f, 
    -0.64039266f, -0.03386205f, 0.27016735f, 0.07234210f, 0.32250619f, -0.40015435f, 0.10289676f, 0.00460229f, 
    -0.10389684f, 0.43868113f, 0.01943319f, 0.07769474f, -0.26170608f, -0.06896932f, -0.08310164f, -0.29552874f, 
    0.12246275f, 0.36602291f, -0.02037872f, 0.10069712f, 0.03410658f, -0.52222544f, -0.56244195f, -0.37526613f, 
    -0.00716245f, -0.02171452f, 0.01420515f, 0.08405578f, 0.24386229f, -0.10451401f, 0.01143097f, 0.06814729f, 
    -0.58821118f, -0.06924000f, 0.13740399f, -0.10641182f, 0.27611497f, 0.19242333f, -0.05772930f, -0.05286724f, 
    -0.02480111f, -0.17402522f, 0.02450710f, -0.05351636f, 0.02717544f, 0.16927305f, 0.29671729f, -0.12229274f, 
    -0.31166786f, -0.11613669f, 0.15338546f, 0.29768035f, -0.28509706f, 0.02968030f, -0.24710399f, -0.68517190f, 
    -0.04708837f, -0.21100737f, 0.27266845f, 0.01016895f, -0.06832162f, 0.36571053f, 0.28852895f, -0.19460198f, 
    -0.47647235f, -0.19798833f, -0.00834855f, 0.08099870f, 0.23217839f, 0.48262450f, -0.00242560f, -0.08014078f, 
    0.75368041f, -0.06324571f, 0.30070227f, -0.28963473f, -0.01125282f, 0.11437231f, 0.09609652f, 0.09497625f, 
    0.18645848f, -0.16779393f, 0.00853130f, 0.09405851f, -0.01797981f, -0.28748083f, 0.18077926f, -0.22088659f, 
    0.09271405f, -0.08915856f, 0.25798672f, 0.31024101f, -0.07631835f, 0.02508875f, -0.31666338f, 0.25273126f, 
    -0.31554323f, -0.14386994f, -0.06499960f, -0.03076844f, -0.07915532f, 0.31910148f, -0.04129243f, -0.07343581f, 
    -0.02715060f, 0.06985608f, 0.01118316f, 0.01970783f, -0.16722913f, 0.22320198f, -0.10359379f, 0.10157815f, 
    0.23948009f, 0.26514384f, -0.01639941f, 0.10999811f, 0.22709167f, -0.06200241f, 0.17454903f, 0.03930020f, 
    -0.51673943f, -0.42387897f, -0.18177529f, -0.11030076f, -0.16824546f, 0.07509446f, 0.13002640f, 0.19705319f, 
    0.65450108f, 0.21860720f, 0.37317660f, -0.07580825f, 0.14753525f, 0.39193967f, -0.12981839f, -0.13980301f, 
    -0.05184114f, -0.13113159f, -0.02232477f, -0.06719176f, 0.19973747f, -0.21887331f, 0.25018010f, 0.09116928f, 
    0.10754691f, -0.03714359f, -0.52280504f, 0.25465974f, -0.09931484f, 0.24396434f, -0.23289444f, -0.28123456f, 
    -0.05167814f, 0.10282613f, 0.12863950f, 0.00581060f, -0.06271438f, -0.25094378f, -0.05274282f, -0.18641911f, 
    0.09193581f, -0.02909761f, 0.20356837f, 0.11536996f, -0.00685204f, 0.07108112f, 0.14839889f, 0.01413151f, 
    0.06567866f, -0.01291387f, 0.06797820f, -0.04276612f, 0.16325811f, 0.18844666f, 0.06524709f, 0.11037570f, 
    -0.13987924f, -0.27224326f, 0.02969694f, 0.25061116f, 0.02566392f, -0.29029191f, -0.02766825f, -0.52923656f, 
    0.03472906f, -0.06999274f, -0.24283628f, 0.05304435f, 0.09878148f, -0.03119248f, -0.09905872f, 0.10122466f, 
    0.62577188f, -0.15557624f, 0.12495214f, 0.31311494f, 0.27349830f, 0.06859928f, 0.02770439f, 0.15493214f, 
    -0.43720493f, 0.09244782f, -0.04780390f, -0.01322087f, -0.02758562f, 0.05057500f, -0.15555298f, -0.02069042f, 
    0.28112894f, -0.32548130f, -0.16858864f, -0.17699426f, 0.06988008f, -0.06211124f, -0.00313080f, 0.19735481f, 
    0.00290389f, 0.03364191f, 0.10645331f, 0.41003877f, 0.03827949f, 0.20754172f, -0.48626545f, 0.16544388f, 
    0.04527806f, 0.15127543f, -0.06626147f, 0.11265837f, -0.05287126f, 0.28013754f, 0.08525915f, 0.00182449f, 
    0.07649855f, -0.19916652f, -0.22936012f, 0.24411131f, 0.09702935f, -0.17419501f, 0.01525167f, 0.01763877f, 
    -0.07264363f, -0.07835078f, 0.03678641f, 0.21215056f, -0.07604934f, -0.11597713f, 0.15359190f, 0.34600917f, 
    -0.24880943f, 0.03608844f, 0.20299952f, 0.19567889f, 0.22647916f, 0.10215685f, -0.10370406f, -0.04954671f, 
    0.02434694f, 0.01202288f, 0.06972055f, 0.23793617f, -0.01940531f, 0.19059274f, -0.06305148f, -0.09479214f, 
    0.34537986f, -0.09189560f, -0.03953630f, 0.19830559f, -0.32971680f, 0.26286465f, 0.06133511f, 0.03506450f, 
    -0.10011014f, 0.14321956f, -0.30586261f, 0.11614422f, 0.02327087f, 0.02541657f, 0.10754487f, -0.07316276f, 
    0.05820582f, -0.11020719f, 0.00018435f, 0.01274214f, -0.02487544f, 0.03990485f, -0.04391231f, -0.08221260f, 
    -0.09963001f, 0.01307292f, 0.00791035f, 0.01292621f, 0.05370218f, 0.05355482f, -0.08466467f, 0.05341972f, 
    0.03957277f, 0.02062325f, -0.03397603f, -0.00333916f, -0.13535388f, 0.01085319f, -0.03334399f, -0.09140061f, 
    -0.08782934f, 0.06788896f, 0.02352400f, 0.04273391f, 0.02030788f, 0.00185435f, -0.05931564f, 0.06166718f, 
    -0.01077343f, 0.03982951f, 0.01707196f, -0.00538569f, -0.04136318f, -0.06310389f, -0.03623476f, -0.10688498f, 
    0.20563745f, 0.00745534f, -0.01233760f, 0.13281742f, -0.02136996f, 0.04770762f, 0.06631213f, 0.00808505f, 
    0.05612709f, -0.00263648f, -0.05226348f, -0.04444579f, -0.06572279f, -0.04985982f, 0.07220028f, -0.06242555f, 
    -0.10038064f, 0.02899087f, -0.00271542f, -0.03744382f, -0.04311281f, 0.07278851f, 0.08201941f, -0.10475951f, 
    -0.07877880f, 0.01602931f, -0.07914053f, -0.04374214f, -0.03252527f, -0.11834507f, -0.03412966f, -0.08861156f, 
    -0.02222285f, 0.03394148f, -0.03240888f, -0.01401621f, -0.04255003f, -0.03570772f, 0.05670425f, -0.03857211f, 
    -0.01144827f, -0.05542523f, 0.05280588f, -0.10961457f, -0.07239877f, -0.04006917f, -0.11448871f, -0.04309809f, 
    -0.08431230f, -0.07476681f, 0.01464825f, -0.09017751f, -0.01433398f, -0.06421647f, -0.03342329f, 0.05613360f, 
    0.08459505f, 0.08968649f, 0.02604984f, -0.00917576f, 0.01586932f, -0.05975121f, -0.00616682f, -0.10744400f, 
    -0.12379852f, 0.07671920f, 0.04291094f, -0.08300252f, -0.08211675f, -0.00954445f, -0.04342685f, 0.09183960f, 
    0.06489210f, 0.08622678f, -0.06717309f, -0.01604210f, -0.06216189f, 0.01978382f, -0.06411543f, -0.04129073f, 
    -0.05023010f, -0.02855996f, 0.02240442f, -0.07558836f, -0.11226284f, 0.02508716f, -0.01332107f, -0.10069394f, 
    0.10053191f, 0.10020728f, 0.12534678f, 0.29660082f, -0.39249662f, 0.04333614f, 0.14280215f, 0.27967617f, 
    0.20471491f, -0.02255478f, 0.15784584f, -0.34285071f, 0.12020243f, -0.40282390f, 0.06576486f, -0.02895558f, 
    -0.42006454f, -0.01788593f, -0.05505946f, -0.07024067f, 0.20688450f, -0.42727017f, -0.41900393f, -0.33238617f, 
    -0.28672633f, -0.23420613f, -0.51601607f, -0.54301983f, -0.14149003f, 0.71579891f, 0.01403318f, 0.16585314f, 
    0.10177744f, -0.26311794f, -0.05224966f, 0.31404138f, 0.05908135f, -0.35048229f, 0.34279230f, 0.12656938f, 
    -0.17463782f, -0.25699869f, -0.14583810f, 0.32257590f, -0.34092426f, -0.45403525f, -0.17342468f, 0.04243170f, 
    -0.25671202f, 0.23467052f, -0.05212216f, 0.07266899f, 0.13256156f, -0.16469622f, -0.37659711f, -0.05234350f, 
    -0.03484985f, 0.69008809f, 0.09188234f, -0.30226761f, 0.25724387f, 0.02590669f, -0.26923764f, 0.38568661f, 
    -0.23472732f, -0.05010288f, -0.17099898f, -0.32259083f, 0.03074539f, -0.28575668f, -0.10095921f, -0.10433614f, 
    0.47187573f, 0.43551216f, -0.07923888f, 0.13440199f, 0.04457787f, -0.47017607f, -0.24334404f, 0.06387202f, 
    0.14262430f, 0.19113758f, 0.31754437f, -0.48226920f, -0.04107669f, 0.05318674f, 0.39130026f, 0.18300174f, 
    -0.04127784f, -0.09521659f, 0.00098799f, -0.19274892f, 0.18949370f, 0.01448731f, -0.07305899f, 0.25222525f, 
    0.28212407f, -0.13280720f, 0.32139710f, 0.19374698f, -0.01952561f, -0.28253597f, -0.11696744f, -0.17993821f, 
    -1.10004997f, 0.20160092f, -0.11142644f, -0.08990069f, 0.09033344f, -0.73957014f, -0.13668357f, -0.02054219f, 
    0.04675679f, -0.44225124f, 0.05203995f, 0.15054978f, 0.34759942f, -0.09119891f, -0.17604932f, -0.25132003f, 
    0.14392479f, -0.00989917f, 0.42476636f, -0.03944932f, 0.17401336f, -0.04982463f, -0.59354627f, 0.05121079f, 
    -0.04134504f, -0.00081004f, 0.02752928f, -0.03475089f, -0.06001622f, 0.02257822f, -0.02294731f, -0.01740232f, 
    -0.02610087f, -0.02393269f, -0.01742038f, -0.09678008f, 0.01919503f, -0.01430133f, -0.05797572f, -0.01535890f, 
    -0.01880748f, -0.00208648f, -0.05702071f, 0.00934478f, -0.02223103f, -0.00029498f, -0.09990560f, -0.08355971f, 
    -0.05795398f, -0.01337240f, -0.01869744f, -0.02745129f, -0.06439722f, 0.00497751f, -0.05084511f, -0.02410093f, 
    0.04554176f, 0.00953602f, -0.04432955f, -0.06700604f, -0.09698022f, -0.03956874f, -0.02211207f, -0.09243111f, 
    0.00557921f, 0.04499566f, -0.05161939f, -0.07984772f, -0.07107321f, 0.01324535f, 0.02037390f, 0.07553045f, 
    -0.02265884f, 0.01990202f, 0.03963820f, -0.06822726f, 0.01282133f, 0.03642514f, -0.12362994f, 0.02904394f, 
    -0.06513020f, 0.03142043f, -0.07953430f, 0.05314120f, -0.01416990f, -0.09070764f, 0.00407670f, -0.06449014f, 
    -0.06964589f, -0.04087326f, -0.02270975f, 0.02173987f, -0.12352514f, 0.01188542f, -0.02275258f, -0.10617250f, 
    -0.05892022f, -0.11428376f, -0.02361686f, -0.07171813f, 0.03347651f, -0.05234973f, -0.05663593f, -0.01165505f, 
    -0.05116638f, 0.04301091f, -0.04866934f, -0.08284807f, -0.05839712f, -0.05439527f, 0.00488972f, -0.11377074f, 
    -0.00395956f, -0.05275219f, -0.05993895f, -0.02240035f, -0.01405431f, -0.05854833f, -0.01865935f, -0.02224317f, 
    -0.07116810f, -0.07178386f, 0.04851139f, -0.06384636f, 0.00941814f, 0.00452145f, -0.07183287f, 0.00868154f, 
    0.00472995f, 0.00551598f, -0.03969315f, -0.06745342f, -0.05257379f, 0.01955786f, -0.11866321f, -0.05075437f, 
    -0.02499077f, -0.08658047f, 0.03331248f, 0.04794441f, -0.01720019f, -0.01735540f, -0.06285759f, -0.06749957f, 
    -0.10465413f, 0.01854239f, -0.08368906f, -0.02921753f, 0.02675256f, -0.10741555f, -0.00813779f, 0.00879833f, 
    -0.09825926f, -0.07520256f, 0.06919515f, -0.07805303f, 0.02472428f, 0.01228378f, 0.04934549f, -0.10325136f, 
    0.00283620f, -0.00302475f, -0.02557465f, -0.06363647f, -0.06217601f, -0.05214438f, -0.09477970f, 0.03403131f, 
    -0.00293210f, -0.08776720f, -0.03041261f, -0.02499415f, -0.04344191f, -0.07636592f, 0.02409461f, -0.09304979f, 
    -0.08896017f, -0.07572839f, -0.07846055f, 0.01710989f, -0.04511705f, -0.07349991f, -0.04091464f, -0.00462952f, 
    0.00824162f, 0.02441405f, -0.08716210f, -0.01618395f, -0.03724834f, 0.04745900f, -0.02973186f, 0.06835359f, 
    -0.01407319f, 0.06884705f, -0.04078262f, -0.01651129f, -0.07518645f, 0.02790381f, -0.05595069f, 0.05251910f, 
    -0.05299946f, 0.06857785f, -0.04794158f, -0.03408539f, -0.03623753f, -0.05603854f, 0.02919277f, -0.08172197f, 
    0.00726366f, 0.05245779f, 0.04144153f, 0.06306148f, 0.06053730f, -0.04770650f, 0.00567022f, 0.00425338f, 
    -0.06817761f, -0.07065804f, -0.08109237f, -0.08363289f, -0.03899039f, -0.00646656f, -0.00049565f, 0.01641124f, 
    0.01781228f, -0.01235716f, 0.00412317f, 0.07185100f, 0.05875758f, 0.02489634f, 0.02825020f, 0.04153629f, 
    -0.03274339f, 0.05524243f, -0.07074659f, 0.01098103f, -0.08295829f, 0.06216947f, 0.03728833f, 0.02658978f, 
    -0.02167174f, -0.08648265f, 0.02125755f, -0.00600992f, 0.01437221f, 0.04423140f, -0.08717235f, 0.04456448f, 
    -0.00295313f, -0.08136592f, -0.04021816f, -0.02177360f, 0.01405534f, 0.07819792f, -0.03281249f, 0.01477399f, 
    -0.06133056f, 0.01500223f, 0.01471469f, 0.04945225f, 0.02207841f, 0.01865285f, -0.09490796f, -0.00696019f, 
    -0.08698894f, 0.02558612f, -0.03664712f, -0.10262398f, -0.02017033f, 0.05747641f, 0.04556154f, -0.03530010f, 
    0.07648476f, -0.04951109f, 0.07300479f, -0.06078235f, -0.08817720f, -0.09048393f, 0.05439467f, -0.00739138f, 
    0.07435407f, -0.34434301f, 0.07975991f, 0.02715524f, 0.39795011f, 0.16356128f, -0.23295303f, 0.22927579f, 
    -0.13649788f, -0.06682552f, -0.20470926f, 0.09856816f, 0.09573778f, 0.12243393f, -0.21003750f, 0.04888410f, 
    0.25959542f, 0.06632616f, -0.14407395f, 0.01589147f, -0.76266998f, 0.17710295f, 0.26141253f, 0.11121897f, 
    -0.20813610f, 0.05037572f, -0.22147378f, 0.18744320f, 0.09632932f, 0.51595408f, -0.16622218f, 0.15711711f, 
    0.04064462f, 0.10371583f, 0.24594036f, -0.24102215f, 0.08622418f, 0.30565080f, -0.00304151f, -0.51739115f, 
    0.24464083f, 0.13728563f, -0.05135083f, 0.03681951f, -0.00104479f, -0.01330102f, 0.13285176f, 0.22016835f, 
    0.11588106f, -0.16235638f, 0.13917032f, -0.17002548f, -0.20081402f, -0.05947717f, 0.12084955f, 0.13348086f, 
    0.09606640f, -0.57856828f, 0.24932760f, 0.22307833f, -0.33411595f, 0.23059641f, 0.14812210f, -0.96255416f, 
    0.55492347f, -0.09057148f, 0.00615447f, -0.07145186f, -0.01586528f, 0.04341196f, 0.20454179f, -0.12142969f, 
    0.08780047f, -0.28390428f, -0.02024248f, 0.04355035f, -0.06733219f, -0.02506267f, 0.21169005f, -0.05108865f, 
    -0.13537700f, -0.04806281f, 0.20025429f, 0.12528807f, -0.27129775f, 0.15058148f, -0.54412812f, -0.24324460f, 
    0.12872501f, 0.21466035f, 0.05223444f, -0.11550207f, -0.05200813f, 0.02295294f, 0.28586039f, -0.04480182f, 
    0.12589581f, 0.04865216f, 0.01046538f, -0.62246716f, 0.03369971f, -0.04831408f, 0.16005805f, 0.17784525f, 
    -0.07383878f, -0.08605453f, 0.25410795f, 0.00083298f, -0.03678000f, 0.20335627f, 0.22687112f, -0.27388874f, 
    -0.35064596f, 0.56102252f, -0.09027063f, -0.23746283f, -0.27507037f, -0.12138309f, 0.17337446f, 0.00038691f, 
    0.22825490f, 0.19313627f, 0.15733166f, 0.29710382f, -0.03118160f, -0.40983915f, 0.09381679f, -0.31300911f, 
    -0.29468623f, 0.17394251f, 0.06763309f, -0.22416686f, -0.15231542f, -0.14568008f, -0.16825224f, 0.16855520f, 
    0.04469644f, 0.01621463f, 0.12630257f, -0.25559217f, 0.15141241f, 0.06951166f, 0.11214925f, 0.03780771f, 
    -0.44993782f, -0.27671564f, 0.02545976f, -0.02011983f, 0.34512267f, 0.24840413f, 0.01901531f, -0.07924014f, 
    0.55061501f, 0.04411500f, -0.22602616f, -0.04033613f, 0.15347894f, -0.37085363f, 0.30414155f, 0.44073749f, 
    0.23911259f, -0.14451349f, 0.07830966f, -0.25231358f, -0.26217508f, -0.05797001f, 0.34491405f, -0.03410111f, 
    -0.41994402f, 0.00009554f, -0.42786050f, 0.08984317f, -0.18692707f, -0.24281888f, 0.12983994f, 0.19132586f, 
    -0.01769296f, 0.01766750f, 0.41341552f, 0.14931206f, 0.08100391f, -0.11475078f, 0.04610885f, -0.39428636f, 
    0.01839908f, 0.64410627f, 0.26052299f, 0.14200716f, 0.04089269f, 0.47345614f, -0.13205291f, 0.46621034f, 
    0.37848061f, -0.00579454f, -0.28002021f, -0.28701454f, 0.14598751f, -0.03695935f, 0.06007329f, 0.02589657f, 
    -0.17479712f, 0.63425112f, -0.04851884f, -0.11261157f, 0.05218608f, -0.28321391f, -0.09803592f, 0.00256464f, 
    0.10124741f, -0.03232303f, 0.36914149f, -0.22049049f, 0.02413088f, 0.15372360f, 0.43126592f, 0.16575053f, 
    0.18998568f, 0.16151229f, -0.03267276f, -0.08160727f, 0.13554420f, -0.07312359f, -0.92394036f, 0.22325997f, 
    0.37288469f, -0.05828819f, 0.20651323f, 0.02525349f, -0.23697202f, -0.34789303f, 0.12323903f, -0.18389457f, 
    -0.38403273f, 0.57302350f, -0.10724754f, -0.40335873f, -0.02619683f, -0.05769079f, -0.21556424f, 0.56390500f, 
    0.18730783f, -0.43509421f, 0.15647861f, -0.02291851f, 0.13497250f, -0.13671774f, -0.00328887f, -0.42116109f, 
    0.25014868f, -0.06949902f, 0.04228303f, 0.09506825f, 0.06493039f, -0.11870461f, -0.39218110f, -0.19121794f, 
    0.08732495f, 0.09960763f, 0.17264292f, -0.14141016f, 0.06970071f, -0.03140615f, 0.27508253f, -0.15683430f, 
    -0.18894668f, -0.01313237f, 0.31376350f, 0.00598569f, -0.07321329f, -0.11363192f, 0.18308151f, 0.00336363f, 
    0.12770735f, 0.22266474f, 0.01185058f, 0.06198089f, 0.01679470f, -0.10683960f, 0.18279780f, -0.08277913f, 
    0.17138109f, 0.01727957f, -0.02057804f, 0.09305370f, 0.01571557f, -0.07781639f, -0.07930949f, -0.17491318f, 
    0.20572814f, -0.05785986f, 0.01063816f, -0.24789500f, 0.00066007f, -0.04522919f, 0.13215829f, 0.17439216f, 
    0.71037632f, -0.23977415f, 0.13717608f, -0.29864594f, 0.04222933f, 0.14435233f, -0.16321148f, 0.12095781f, 
    -0.25014222f, 0.07418229f, -0.19026633f, -0.07525394f, 0.01768876f, 0.07964769f, -0.15213938f, -0.04217376f, 
    0.22173019f, -0.43022346f, -0.22182411f, -0.20192063f, 0.05087833f, -0.15478070f, 0.05331665f, 0.04923780f, 
    -0.47586852f, -0.05645064f, 0.24746689f, -0.12064569f, 0.11783834f, 0.13866620f, -0.12175617f, 0.17481370f, 
    0.13141081f, 0.22434545f, 0.07794613f, 0.05542617f, -0.06148347f, -0.00231776f, 0.09939258f, 0.04086715f, 
    0.19667931f, -0.00754321f, -0.01976371f, 0.09236298f, 0.13040456f, -0.06768942f, -0.54150862f, 0.09540398f, 
    0.00311108f, 0.20011498f, 0.04272585f, 0.02851858f, -0.00003136f, 0.05016355f, 0.02150152f, 0.18878172f, 
    -0.03314064f, 0.11863755f, -0.03816664f, 0.00897449f, 0.13914219f, 0.09355929f, 0.15947925f, 0.01589725f, 
    -0.33279112f, -0.35779005f, 0.07502674f, 0.14664117f, 0.01436401f, 0.24375059f, -0.03140721f, -0.26860553f, 
    -0.27100334f, -0.05863750f, 0.08631626f, 0.23704863f, -0.37396011f, 0.16914108f, 0.13398942f, 0.14755245f, 
    0.14126612f, -0.02381795f, -0.18987058f, -0.22304864f, 0.09954832f, -0.36537471f, 0.21692757f, 0.07526629f, 
    -0.09582735f, -0.01668916f, -0.08376166f, -0.05813848f, -0.00736020f, 0.00213776f, -0.03635541f, -0.06623570f, 
    -0.01313854f, 0.01220718f, -0.11526178f, -0.07966551f, -0.11555615f, -0.04012992f, -0.02991915f, -0.00896181f, 
    -0.08685348f, -0.08619902f, 0.04614988f, -0.02692916f, -0.05760264f, -0.04809180f, -0.11369828f, -0.09625433f, 
    0.00343552f, 0.03450555f, -0.07188581f, -0.00729039f, -0.00984260f, 0.06560586f, 0.04317467f, 0.06568430f, 
    -0.11196881f, -0.08524621f, -0.04746851f, -0.04191345f, -0.05968666f, -0.09458986f, 0.02005877f, 0.05493569f, 
    0.04956269f, -0.08948018f, 0.00075570f, 0.03525183f, -0.01213663f, 0.03445510f, -0.03805441f, -0.02600217f, 
    -0.03664048f, -0.00941017f, 0.03212499f, -0.06958477f, -0.03022838f, -0.04062200f, -0.09950011f, 0.02820656f, 
    -0.07556716f, 0.03551654f, 0.00973563f, -0.06734051f, 0.00894772f, -0.05961220f, -0.06893872f, -0.05222975f, 
    0.03465077f, 0.04061256f, -0.03963227f, -0.01961330f, -0.10197331f, 0.01133483f, -0.05303982f, -0.02497178f, 
    -0.07924396f, -0.07643695f, -0.03831873f, -0.06763336f, 0.06100092f, 0.02201379f, 0.02171458f, 0.04334348f, 
    -0.07445493f, -0.01023818f, -0.10223915f, 0.08445464f, -0.03010585f, 0.03060530f, 0.05362925f, -0.01085109f, 
    -0.08600865f, -0.05716556f, -0.05560097f, 0.02522053f, 0.01682044f, 0.07306539f, -0.05210753f, 0.00418490f, 
    -0.06841339f, -0.05043302f, -0.08904466f, -0.06146374f, -0.08566978f, -0.09291635f, 0.05356415f, -0.04186460f, 
    0.03736249f, 0.03474949f, 0.04959186f, 0.00039635f, -0.09827856f, -0.01879218f, -0.10084403f, -0.05620066f, 
    -0.08359715f, -0.06381986f, -0.05488582f, -0.01191648f, 0.00279525f, 0.04524329f, 0.05203840f, 0.02560322f, 
    -0.03279608f, -0.03834681f, -0.00360474f, 0.05016197f, -0.06525693f, 0.04493220f, -0.05618129f, 0.04650177f, 
    -0.10902897f, 0.42870903f, 0.11012083f, 0.21945609f, -0.04016199f, 0.16278662f, 0.21742825f, 0.32544512f, 
    -0.01392834f, -0.03317352f, 0.00105048f, -0.17663600f, -0.19318688f, 0.11990965f, -0.02578582f, 0.00630694f, 
    -0.04749002f, -0.17185561f, 0.14815281f, -0.08829025f, -0.03588223f, 0.29024988f, 0.22960496f, -0.17543778f, 
    0.07336766f, 0.40852779f, 0.33052728f, 0.15419129f, -0.04914312f, -0.07343307f, -0.10567672f, -0.09039950f, 
    0.10085128f, 0.39941964f, 0.00111640f, 0.06517246f, -0.07187019f, 0.12261203f, 0.06151395f, 0.29176047f, 
    0.11331627f, 0.13008316f, 0.18711191f, 0.20705134f, -0.22608261f, 0.13828835f, -0.43920705f, -0.12219298f, 
    -0.58795106f, 0.00096494f, 0.28847528f, -0.16339542f, 0.21534821f, 0.29249233f, -0.00693105f, -0.04753365f, 
    0.08243214f, -0.50773621f, 0.06139524f, 0.20423169f, -0.12492454f, -0.12182430f, 0.21866363f, 0.29131061f, 
    0.13455279f, 0.11304726f, 0.06732094f, -0.20187706f, 0.05079948f, 0.05111882f, -0.43768233f, 0.17345421f, 
    0.49578044f, -0.62595290f, -0.03244088f, -0.02373660f, 0.05928871f, -0.14334315f, -0.15914951f, -0.07374454f, 
    -0.07455729f, -0.14888902f, -0.04816377f, 0.12468589f, 0.06487515f, -0.05594313f, 0.09174702f, -0.06636310f, 
    0.19055355f, -0.10266359f, -0.09339371f, -0.72369987f, -0.02303132f, 0.02427008f, 0.15457661f, -0.44362754f, 
    0.10629038f, -0.13727687f, 0.12666117f, 0.13523883f, -0.11754312f, 0.08956727f, -0.18364757f, 0.16161290f, 
    0.53423107f, 0.51626700f, 0.27627939f, 0.04073489f, -0.11517126f, -0.02489268f, 0.05948409f, 0.14172770f, 
    0.34648156f, -0.11696354f, 0.02412139f, 0.02390654f, 0.04461143f, -0.10025518f, 0.25746980f, 0.00341198f, 
    0.18782467f, 0.04969194f, 0.16392033f, 0.09590423f, -0.07800974f, 0.05339246f, -0.00520949f, -0.01686720f, 
    0.17409869f, -0.46571895f, -0.01330252f, 0.13815609f, -0.04628613f, -0.10843557f, 0.00714164f, -0.10768351f, 
    0.18383786f, -0.02984902f, -0.30509752f, 0.00785323f, 0.03837019f, -0.12459087f, -0.16173577f, 0.05458065f, 
    0.05707190f, 0.18976724f, -0.05315780f, -0.08048679f, -0.40756413f, -0.16589898f, -0.18834750f, 0.10784905f, 
    -0.28415108f, -0.36847290f, 0.25611374f, -0.07283265f, -0.03819175f, 0.12129374f, -0.24092315f, 0.74035525f, 
    -0.44426814f, 0.15334380f, 0.00144470f, -0.00068921f, -0.01223260f, -0.22988866f, -0.22948107f, 0.10229123f, 
    -0.02154416f, 0.18682332f, 0.19907874f, -0.03722063f, 0.26810315f, 0.03647131f, -0.24882045f, -0.34487388f, 
    0.29114616f, 0.06456176f, -0.52614325f, 0.10054053f, 0.01395021f, 0.19337615f, 0.18256725f, 0.11764196f, 
    -0.28815845f, -0.11880764f, 0.01491311f, -0.03918171f, 0.19944820f, -0.29284656f, 0.01203499f, -0.29687029f, 
    -0.38863027f, 0.01111529f, 0.05654597f, -0.03138757f, 0.12239635f, 0.02842228f, 0.45786077f, -0.07434653f, 
    0.07610085f, -0.54811287f, 0.08564200f, 0.01806479f, -0.04176905f, 0.26192248f, -0.11305891f, -0.10321007f, 
    -0.18105799f, -0.06361007f, -0.53404367f, -0.06663859f, -0.03004055f, -0.17647685f, -0.18263073f, -0.03603698f, 
    -0.17958993f, -0.16261765f, -0.01600652f, 0.04327767f, -0.26831302f, 0.11613793f, 0.23897661f, -0.13550319f, 
    0.14602791f, 0.16137488f, -0.05470755f, 0.25193363f, 0.09058241f, 0.18130895f, -0.10907786f, 0.00715513f, 
    0.12334511f, -0.33291620f, -0.18163057f, 0.13666177f, 0.11944752f, 0.01174741f, 0.09793413f, -0.29064393f, 
    0.01311869f, 0.11949252f, -0.17017105f, 0.00918241f, 0.21071054f, 0.04090559f, -0.12777072f, 0.17570762f, 
    -0.34540087f, -0.05978012f, 0.04100458f, -0.10329791f, -0.02185056f, 0.25900358f, 0.10520481f, 0.31014696f, 
    0.02081986f, 0.01413754f, -0.08145146f, -0.09890296f, -0.05465973f, -0.10804942f, 0.04313255f, -0.03169336f, 
    0.04439853f, 0.06133410f, -0.09686159f, -0.08244851f, -0.08324135f, 0.00319076f, 0.06162727f, 0.07833152f, 
    0.02970476f, -0.13504162f, -0.03403004f, 0.01388337f, 0.07141824f, 0.04581568f, 0.01095138f, -0.15177229f, 
    0.05477183f, 0.06369030f, -0.02081282f, 0.04578135f, -0.05492839f, -0.03987016f, -0.07837404f, 0.00449503f, 
    -0.02506113f, -0.02550262f, -0.10712970f, -0.09738793f, 0.01352533f, -0.06848829f, -0.05180023f, -0.02020938f, 
    0.01735803f, -0.13188557f, -0.11182125f, -0.06186435f, -0.10275641f, 0.04218284f, 0.08582924f, -0.09755217f, 
    0.09806843f, 0.06186965f, -0.06408120f, -0.02030490f, -0.07778782f, -0.01038135f, 0.00455357f, -0.02650733f, 
    -0.01407870f, 0.11052471f, -0.09152696f, -0.10494788f, -0.01663241f, -0.16101144f, -0.00380695f, -0.03435214f, 
    -0.05133488f, -0.06703898f, -0.05310913f, -0.06310935f, -0.14834830f, -0.11150588f, -0.03974628f, -0.10772347f, 
    0.04796838f, 0.08757036f, -0.00662826f, -0.01832821f, -0.02509350f, 0.02903465f, 0.00666451f, -0.13427415f, 
    -0.00074064f, -0.12581077f, -0.01668496f, -0.06384557f, -0.02078506f, -0.14633442f, -0.00629417f, -0.08208158f, 
    -0.08203135f, -0.13501072f, 0.06726519f, 0.02390926f, 0.00815507f, -0.03928374f, 0.03358119f, 0.10152416f, 
    -0.01994633f, -0.10283621f, -0.09983758f, -0.10627825f, -0.09824833f, -0.07486963f, 0.07893671f, -0.01887709f, 
    -0.05690158f, -0.08175782f, 0.04809206f, -0.07663761f, 0.01161219f, -0.04237060f, 0.04556194f, -0.00196090f, 
    -0.01381662f, -0.04945524f, -0.00036030f, 0.00217370f, -0.05363463f, -0.04423549f, -0.11638919f, -0.01646100f, 
    0.01546743f, -0.11066850f, -0.11751218f, -0.07400299f, -0.10124177f, 0.02909669f, -0.02938325f, -0.14484723f, 
    0.19957362f, 0.34214684f, 0.14703673f, -0.15677597f, 0.07678286f, 0.26068881f, 0.16790280f, -0.21533948f, 
    -0.19327570f, -0.02395475f, 0.25541142f, 0.00881630f, -0.10800329f, -0.21620739f, 0.06735440f, 0.02779511f, 
    0.21469116f, 0.29157621f, -0.19519739f, -0.00465226f, 0.12345954f, -0.13578539f, 0.08782611f, 0.10734338f, 
    0.09762961f, -0.08845832f, 0.21612555f, -0.19024868f, 0.18225147f, -0.11550327f, 0.04766773f, -0.36883020f, 
    0.04845322f, 0.03985005f, -0.01030901f, 0.15702030f, 0.33898813f, 0.10408245f, 0.14574048f, 0.08592744f, 
    -0.02265409f, -0.12846711f, 0.16455872f, 0.22405718f, 0.03129073f, 0.30911234f, 0.07196496f, 0.18376267f, 
    -0.33026323f, -0.02776052f, -0.20552607f, 0.04878381f, -0.05023249f, 0.14087449f, 0.03629164f, 0.14106521f, 
    0.20528625f, -0.40222755f, -0.12824431f, -0.16784845f, 0.21791723f, 0.11262856f, -0.04218139f, -0.07107940f, 
    -0.02032566f, 0.07541994f, 0.15556379f, 0.31863520f, -0.01403556f, 0.13810997f, -0.23716213f, 0.22642526f, 
    0.03062070f, -0.20840745f, -0.06075075f, 0.29766023f, -0.04400170f, 0.00525322f, 0.26199979f, 0.10320754f, 
    0.13218831f, 0.20885834f, 0.04872743f, 0.15869156f, 0.08067988f, 0.15681320f, -0.24698427f, 0.12967493f, 
    -0.06587087f, -0.03858286f, -0.05684285f, 0.10446321f, 0.24190538f, 0.00172596f, 0.23820186f, -0.09892567f, 
    -0.23845474f, 0.00753985f, -0.07415283f, 0.12186192f, 0.39645877f, 0.15015602f, 0.06434808f, 0.15744685f, 
    -0.22716722f, -0.11039373f, -0.13877639f, 0.42041901f, 0.28246605f, -0.07290362f, -0.08618179f, 0.07056057f, 
    0.11550083f, -0.03600882f, 0.03398504f, 0.28806087f, -0.20904033f, 0.40663767f, 0.19283997f, 0.18850465f, 
    0.04558109f, 0.12937932f, -0.15349406f, -0.29818875f, 0.00030734f, -0.25856572f, -0.02126610f, 0.10400644f, 
    0.28171197f, -0.29621568f, -0.18748049f, -0.14505723f, -0.00806531f, -0.06048255f, -0.37663513f, -0.01000378f, 
    -0.05396515f, -0.01318260f, -0.04612552f, 0.12994538f, 0.38476837f, -0.11619394f, -0.14985535f, -0.06871874f, 
    -0.02340236f, 0.07944804f, -0.01999489f, -0.04101715f, -0.11533791f, -0.28343454f, -0.12929860f, -0.02003272f, 
    -0.15613140f, -0.10200645f, -0.14736226f, -0.31418297f, 0.18305227f, 0.07097676f, -0.07978378f, 0.14784531f, 
    -0.01073184f, -0.48041058f, 0.19733006f, 0.03090513f, 0.21852572f, 0.06101367f, 0.03735929f, -0.38157880f, 
    -0.54367936f, -0.16441278f, -0.24049507f, -0.09815746f, 0.23457259f, -0.04317620f, -0.02469192f, 0.31735954f, 
    -0.00317098f, -0.12352315f, 0.06394098f, 0.13098773f, -0.21864386f, -0.07738139f, 0.14333102f, 0.17971610f, 
    0.04755320f, -0.48983428f, 0.07935033f, 0.18481523f, 0.13087478f, 0.44766507f, 0.11721381f, -0.29699638f, 
    0.26344994f, 0.04018760f, 0.11480415f, -0.11683582f, 0.07029343f, -0.07779257f, 0.19943278f, -0.06242292f, 
    -0.42238146f, -0.13568842f, 0.03366141f, 0.17426813f, -0.02746890f, 0.04321194f, 0.13872854f, -0.03279185f, 
    -0.00277962f, 0.27980316f, 0.19604266f, -0.07806864f, -0.19682422f, 0.49385121f, 0.09214394f, 0.19282375f, 
    0.00257815f, -0.22309709f, 0.03493473f, 0.10085972f, 0.41644245f, -0.00909691f, -0.06452272f, -0.56554776f, 
    0.19536071f, 0.14020954f, -0.13667712f, -0.12469448f, -0.00878359f, -0.05179604f, 0.10878293f, 0.23412901f, 
    -0.23285143f, 0.06308665f, -0.13391213f, 0.04476691f, 0.25633609f, -0.15144441f, -0.27868155f, 0.25970694f, 
    -0.01614884f, 0.16608575f, 0.20598815f, -0.03266135f, 0.05173056f, 0.05103439f, 0.09189996f, -0.33778131f, 
    -0.04845031f, 0.09918997f, 0.05862432f, 0.26490456f, 0.14887106f, -0.04013073f, -0.33172521f, -0.01136799f, 
    0.11316098f, 0.05822180f, -0.65026104f, 0.30779508f, 0.10236050f, -0.07720076f, -0.02543046f, -0.02907930f, 
    -0.04290039f, 0.05074549f, -0.18929978f, -0.08801485f, -0.03967563f, -0.04327663f, 0.00564394f, 0.07074718f, 
    -0.08167632f, 0.08841895f, -0.11458179f, 0.00624641f, -0.33259714f, -0.04438453f, 0.08815390f, 0.02194189f, 
    0.25498688f, 0.37327874f, -0.12827867f, 0.07873063f, 0.01491740f, 0.41373968f, 0.26751140f, 0.46022674f, 
    -0.15329053f, 0.21636768f, 0.11692202f, 0.15080306f, -0.09897689f, -0.00915580f, -0.35979387f, -0.04168401f, 
    0.38157487f, 0.27897406f, 0.00902186f, 0.20469995f, -0.06800025f, -0.13771111f, 0.33075744f, -0.48189327f, 
    0.26675978f, -0.10108861f, -0.11797694f, 0.03464489f, -0.17517926f, -0.05177791f, 0.09414731f, 0.10354819f, 
    -0.48057666f, 0.12988983f, 0.13293719f, -0.01904739f, -0.37952763f, 0.09734356f, -0.00841181f, -0.50492179f, 
    0.11566519f, -0.05149040f, -0.04158602f, 0.21192493f, -0.11596687f, -0.10173746f, 0.22537738f, -0.05696871f, 
    0.28036401f, 0.25652564f, -0.06258281f, -0.54349452f, -0.04262570f, -0.01534331f, -0.04403784f, 0.09109693f, 
    0.00981438f, 0.24852224f, -0.28665218f, -0.02593706f, -0.08909991f, -0.24430764f, -0.38682896f, -0.41598472f, 
    -0.00276768f, 0.13393976f, 0.02480763f, 0.40603724f, -0.32159364f, 0.06727178f, -0.29223529f, 0.01751768f, 
    0.04384894f, -0.19722350f, -0.04154567f, -0.14638782f, -0.34968606f, 0.01379636f, 0.00580666f, 0.07408153f, 
    0.71518576f, -0.30074120f, -0.07016625f, -0.08929282f, -0.07780654f, -0.35439500f, 0.04759332f, 0.10572129f, 
    -0.02179764f, 0.03124239f, -0.23169987f, -0.09242163f, 0.44807118f, 0.04869809f, 0.00789009f, -0.02397504f, 
    0.00792596f, -0.51959819f, 0.24845347f, 0.15430312f, -0.05966143f, -0.13833727f, 0.28233865f, 0.06983727f, 
    -0.08717129f, -0.01455608f, 0.00643649f, 0.02341091f, 0.06829422f, -0.02665298f, -0.03628751f, -0.04583601f, 
    0.01609022f, 0.00606116f, 0.03573665f, 0.02322948f, -0.09373520f, 0.06853010f, 0.01335617f, -0.00629102f, 
    -0.05865620f, 0.01721717f, -0.06177290f, 0.06105943f, -0.01099780f, -0.02343022f, -0.08206774f, 0.01203052f, 
    -0.05478320f, 0.05963969f, -0.02240294f, 0.02661778f, -0.03314975f, -0.10109500f, -0.00543601f, -0.07250837f, 
    -0.06454911f, -0.07940673f, -0.02944531f, -0.01040624f, 0.07426229f, 0.06717411f, -0.06350686f, -0.02959657f, 
    0.01383042f, 0.02332020f, -0.06675191f, 0.02667872f, -0.04315618f, -0.07974674f, -0.08799567f, -0.01960922f, 
    0.07766586f, 0.02326864f, -0.00333971f, -0.05992541f, -0.01057287f, -0.09689627f, 0.04998711f, 0.02124692f, 
    0.01809269f, 0.03751493f, -0.09456063f, -0.06753878f, -0.08097236f, -0.08478571f, -0.02441517f, 0.02412293f, 
    -0.08882032f, -0.04737829f, 0.06000240f, -0.04178471f, -0.08589692f, -0.07521273f, 0.05730853f, -0.09461121f, 
    -0.01416056f, -0.01515665f, 0.02282168f, -0.00081711f, 0.06044357f, 0.05129812f, 0.07092409f, -0.08231398f, 
    -0.00503932f, -0.03851964f, 0.01119906f, -0.05581077f, 0.06169094f, -0.09238761f, -0.00492936f, -0.10309115f, 
    -0.03083565f, 0.06110448f, 0.08482158f, -0.00011640f, -0.13734619f, -0.07843352f, -0.00658548f, -0.00051024f, 
    -0.04273884f, 0.03634715f, 0.03632534f, 0.03659130f, 0.00619077f, -0.03825204f, -0.02067852f, -0.06447862f, 
    0.01828663f, -0.07947251f, 0.01190079f, -0.09829897f, -0.08447481f, 0.06734037f, -0.00228391f, -0.10286847f, 
    -0.05163911f, 0.04147571f, 0.00163425f, -0.08274562f, 0.03883054f, 0.07674088f, -0.02486939f, -0.06024226f, 
    0.07190616f, -0.08264811f, 0.05543223f, -0.00810948f, -0.01526813f, 0.03405515f, -0.10172602f, -0.05919089f, 
    -0.01011844f, 0.04223539f, 0.08347124f, -0.09100141f, 0.05921920f, 0.15700968f, 0.27115756f, -0.10996758f, 
    0.15359430f, -0.01290552f, 0.23615253f, 0.01515475f, -0.10907082f, -0.17971268f, 0.03930637f, -0.04804592f, 
    0.25907260f, 0.24455968f, -0.03238747f, -0.03551978f, 0.19254795f, 0.01113016f, -0.03176524f, -0.05597362f, 
    0.21789318f, -0.11168171f, 0.15576996f, 0.02038363f, 0.14817637f, -0.13959701f, 0.06481580f, -0.22953574f, 
    0.09090394f, 0.01792595f, -0.12212776f, -0.06721661f, 0.14517708f, 0.00885062f, 0.03263516f, 0.26246905f, 
    0.73619169f, -0.11180341f, -0.01345065f, 0.00880595f, -0.19777685f, 0.22185752f, -0.01125125f, 0.22731902f, 
    -0.45112976f, 0.01138074f, -0.30680779f, 0.10620652f, 0.10647359f, 0.18343353f, 0.02750630f, -0.03704978f, 
    0.37535205f, -0.22582969f, -0.30507267f, -0.04749312f, 0.04481062f, -0.09137490f, 0.01104961f, 0.11722542f, 
    -0.25245056f, 0.03493646f, 0.13970815f, 0.17130429f, 0.03688056f, 0.18231420f, -0.26304829f, 0.05677434f, 
    0.19907771f, -0.12459600f, 0.04759634f, 0.20006454f, 0.01858154f, -0.28186914f, 0.15179728f, 0.05053984f, 
    0.10461589f, -0.14370680f, -0.04744964f, 0.21913441f, 0.25107518f, -0.06636048f, -0.19598396f, 0.13122945f, 
    -0.09946726f, 0.03648356f, -0.00769440f, -0.03671958f, 0.00266350f, 0.00399081f, 0.38042688f, 0.22658712f, 
    0.05788374f, 0.19795778f, -0.08979816f, 0.22547133f, 0.41104323f, 0.06330232f, 0.18684821f, -0.07134935f, 
    -0.45916751f, -0.34566775f, 0.02425794f, 0.17269653f, 0.08287687f, 0.10055979f, 0.00215910f, -0.05554389f, 
    -0.16193847f, -0.01375184f, 0.04718901f, 0.21347106f, -0.65746266f, 0.40032941f, 0.07201440f, 0.04644976f, 
    0.03060533f, 0.23017891f, 0.16150311f, -0.43147531f, 0.09391832f, -0.22564232f, 0.10460477f, 0.15186664f, 
    -0.11179005f, -0.05134066f, -0.01626883f, -0.08451089f, 0.02388970f, -0.03647240f, 0.09305984f, -0.10571672f, 
    -0.06193008f, 0.02392893f, -0.06409305f, -0.07204090f, 0.01500104f, 0.00908888f, -0.00258965f, -0.06998774f, 
    -0.03105577f, -0.12003912f, 0.07122298f, -0.07328734f, -0.02482627f, -0.03270739f, 0.02117114f, 0.05384563f, 
    -0.06325676f, 0.07831647f, -0.03101156f, 0.07778329f, -0.09488702f, -0.11444130f, -0.09966073f, -0.04942249f, 
    0.02846215f, 0.00979267f, -0.04104391f, -0.04731608f, -0.05502219f, -0.09713251f, 0.04009416f, 0.02968651f, 
    0.09789584f, 0.05615361f, -0.02486404f, -0.02190918f, 0.11859850f, 0.01799249f, -0.04010605f, -0.08746275f, 
    -0.02986921f, -0.01000351f, -0.11705715f, -0.02650746f, -0.06775708f, -0.04389440f, -0.00212026f, 0.03667437f, 
    -0.09655624f, -0.12602234f, -0.14200112f, 0.01144849f, 0.02177116f, -0.05330183f, -0.08168609f, 0.07534382f, 
    0.04682789f, -0.07751819f, -0.08281057f, -0.02525238f, -0.08973423f, 0.01614835f, 0.01187440f, -0.05661591f, 
    0.01828705f, -0.07069565f, 0.07084346f, -0.05397411f, -0.04347984f, 0.01153451f, -0.08729038f, 0.04811562f, 
    -0.11087915f, -0.03847510f, 0.04900631f, -0.08689387f, -0.08684351f, -0.06948653f, -0.04844442f, -0.10227776f, 
    0.07351243f, -0.08259308f, -0.04588108f, 0.03734218f, -0.12521362f, -0.06174054f, -0.10904503f, 0.03815461f, 
    0.07985230f, 0.03057716f, -0.03382472f, 0.03859141f, -0.12419601f, -0.01784557f, -0.09945242f, -0.09157024f, 
    -0.04052580f, -0.04579216f, 0.06978776f, -0.05187479f, -0.05164457f, 0.05483777f, -0.03185868f, 0.04377310f, 
    0.05217967f, -0.05224159f, 0.03939338f, -0.02268058f, 0.02751273f, -0.03086855f, -0.00314869f, 0.07889584f, 
    -0.07079805f, -0.07787723f, 0.00876959f, -0.09516020f, 0.01337925f, 0.02855167f, -0.05554512f, -0.06180171f, 
    -0.05515510f, -0.02523258f, -0.11768235f, -0.01270427f, -0.01622448f, -0.09779150f, -0.02960446f, 0.01145355f, 
    0.01792833f, 0.03247207f, -0.03771642f, -0.11225136f, -0.09224960f, 0.06657182f, -0.11534016f, -0.06419433f, 
    -0.08812574f, 0.02938776f, -0.04997993f, -0.07478226f, -0.12253141f, 0.06020750f, -0.02765366f, -0.11136843f, 
    0.13675584f, -0.01476023f, -0.06114653f, -0.01761624f, -0.08559518f, -0.05291319f, 0.01686800f, 0.02433148f, 
    -0.08492600f, -0.11546170f, 0.01418864f, -0.08674236f, -0.09053954f, -0.06662448f, 0.03176409f, -0.07699291f, 
    0.10305636f, -0.08987009f, -0.06721738f, 0.00273729f, -0.09656987f, -0.09722684f, -0.03300004f, 0.02071175f, 
    0.10587202f, -0.03667511f, 0.04877962f, -0.09702054f, -0.10784688f, 0.03726427f, 0.00440021f, -0.08231483f, 
    -0.06949048f, 0.00377346f, -0.01902871f, 0.00179483f, -0.01874879f, -0.10263030f, -0.10058210f, -0.05800584f, 
    0.01826050f, 0.06227928f, -0.03592495f, -0.01641076f, 0.00050954f, -0.01690689f, -0.08194339f, -0.02288746f, 
    0.04146221f, 0.02250800f, -0.08660640f, 0.02859326f, -0.06975539f, 0.03533237f, -0.07626331f, -0.07355450f, 
    0.03890315f, -0.04579164f, -0.07612889f, -0.10314350f, -0.03273295f, -0.10210091f, 0.02104056f, -0.01347861f, 
    0.01586976f, -0.08866614f, -0.03052627f, -0.07855514f, -0.11796847f, 0.06246470f, 0.05866195f, -0.05332514f, 
    -0.00957836f, -0.06363622f, 0.00387349f, -0.02774063f, 0.03521358f, -0.11641516f, -0.05185901f, -0.12968928f, 
    -0.12515000f, 0.00458978f, -0.08886210f, -0.02235635f, -0.12006634f, 0.02242049f, -0.04460068f, 0.06151783f, 
    0.05557425f, 0.04970206f, -0.10068907f, -0.03353034f, -0.05177498f, -0.14873073f, -0.04805402f, -0.11328468f, 
    0.01776214f, -0.04589444f, -0.04000561f, 0.03506671f, 0.04759449f, 0.01821962f, 0.03747800f, -0.00677576f, 
    -0.16980156f, -0.07796095f, 0.19432884f, -0.00327394f, 0.29883614f, 0.34003246f, 0.10585062f, -0.02828886f, 
    -0.02529378f, -0.04247108f, 0.01926429f, -0.19288690f, -0.03838769f, 0.23598325f, 0.06355013f, 0.04440639f, 
    0.20166434f, -0.10716823f, -0.05701345f, 0.01511121f, -0.03693037f, 0.35097590f, 0.17961688f, -0.24860613f, 
    0.34000948f, 0.00721999f, 0.39438355f, 0.20844045f, -0.08730491f, 0.18247204f, -0.04727987f, -0.31181565f, 
    0.03306484f, 0.15274808f, 0.15019809f, -0.27377054f, -0.18521607f, 0.30721623f, 0.17425235f, 0.12442384f, 
    -0.21271244f, -0.12271267f, -0.09907162f, -0.59438407f, -0.25574106f, 0.40417016f, 0.25525793f, 0.12854344f, 
    1.00411952f, 0.06796791f, 0.25956562f, -0.08182165f, -0.00742253f, 0.22464553f, 0.14150433f, -0.08431951f, 
    0.08396251f, 0.37570924f, 0.11727862f, 0.17689262f, -0.01758942f, 0.17175157f, 0.20849849f, 0.03444171f, 
    0.56752759f, 0.05602812f, -0.14781311f, 0.11786477f, 0.04348162f, -0.11147429f, 0.13096680f, 0.00983288f, 
    -0.16758810f, 0.00837939f, 0.00841873f, 0.01174988f, -0.01745090f, -0.57341659f, -0.21289985f, 0.06683140f, 
    0.03242654f, -0.19132166f, 0.25961587f, 0.03616473f, 0.21568881f, -0.03151165f, 0.02032561f, -0.17865725f, 
    0.28629196f, 0.16429210f, 0.00078734f, 0.02392359f, -0.11288869f, -0.00505810f, 0.38065934f, 0.13550413f, 
    -0.29867843f, -0.47873217f, -0.23998107f, -0.15115285f, 0.07669009f, -0.61910284f, 0.07574748f, -0.10717670f, 
    -0.57642263f, 0.26521018f, 0.22331290f, -0.17070363f, 0.01844175f, 0.47610837f, 0.40718612f, -0.12519710f, 
    0.18504976f, 0.20047450f, 0.13384631f, -0.03106220f, -0.28688765f, -0.04627291f, 0.25437090f, 0.11645000f, 
    0.19276683f, -0.07006259f, 0.52853262f, 0.33188203f, 0.00827760f, -0.01933922f, -0.61097330f, -0.31220713f, 
    0.08918712f, -0.13104795f, 0.12461719f, 0.10624554f, 0.18614963f, 0.07688344f, -0.40117586f, 0.12794437f, 
    -0.19588350f, 0.07407816f, 0.03421765f, 0.00481890f, 0.20255470f, -0.19739056f, -0.10235150f, -0.03080560f, 
    0.17553914f, 0.04363261f, -0.20941833f, -0.00272431f, -0.10366827f, 0.08813138f, 0.10635576f, -0.13210738f, 
    -0.07013534f, 0.16184367f, -0.26845074f, 0.07871704f, 0.12957248f, 0.21107897f, 0.01146483f, -0.29525089f, 
    0.05369477f, -0.18882151f, 0.02520889f, -0.00832896f, 0.05912255f, 0.26206729f, 0.01581353f, -0.27612442f, 
    -0.33458826f, 0.01486735f, -0.13864328f, 0.12564652f, 0.01016303f, -0.06340709f, 0.22970799f, 0.16352625f, 
    0.53754044f, -0.12756182f, 0.09831207f, -0.13037789f, -0.06934866f, -0.01750954f, -0.06178305f, 0.17722505f, 
    0.18467928f, -0.14121789f, 0.05911268f, 0.13006990f, 0.04957421f, 0.22128192f, 0.01183468f, -0.44496122f, 
    0.15459466f, 0.01578769f, 0.00328078f, 0.25644261f, -0.08385621f, 0.00679116f, -0.29859224f, 0.01300477f, 
    0.01475362f, -0.02522998f, -0.00701222f, 0.12275992f, 0.00638774f, -0.07984497f, 0.10913739f, -0.10133169f, 
    -0.10781689f, 0.21778090f, 0.12614352f, 0.02862466f, -0.49130917f, 0.13671969f, -0.03918067f, 0.05790129f, 
    0.00182064f, 0.01246429f, 0.02812546f, 0.03704607f, 0.32172793f, -0.02248642f, 0.22982915f, -0.01968562f, 
    -0.24330327f, -0.17491899f, 0.22302841f, -0.41552576f, 0.14081135f, 0.00586420f, 0.14677334f, 0.09578166f, 
    -0.31587502f, 0.05970467f, 0.18683821f, 0.08619031f, 0.12992941f, -0.25508505f, 0.08000364f, -0.19255765f, 
    -0.24073312f, 0.31081927f, 0.08344196f, 0.03589616f, -0.04905979f, 0.02672268f, 0.01779468f, -0.20329031f, 
    0.01210833f, 0.30663618f, -0.15321581f, 0.17597921f, 0.13263787f, -0.56071079f, -0.29123536f, -0.23672363f, 
    0.07292422f, 0.09833028f, 0.08649860f, 0.09239989f, 0.02554582f, 0.36704940f, 0.19507714f, 0.26584163f, 
    -0.04042121f, 0.02093521f, 0.05572546f, -0.00141549f, -0.01116852f, -0.21915531f, -0.00583731f, 0.06347407f, 
    0.07039943f, 0.11305055f, -0.08936065f, 0.00269013f, 0.06498735f, -0.23127492f, 0.00672513f, 0.03559053f, 
    0.16999611f, 0.14312246f, -0.11598682f, -0.16782434f, 0.04924781f, -0.19152834f, -0.04709101f, 0.15452373f, 
    0.10451473f, -0.13606659f, 0.03089775f, 0.06545620f, 0.24611703f, 0.16604406f, 0.02895896f, 0.04779945f, 
    -0.29361558f, -0.10176634f, -0.00579986f, 0.16084588f, -0.08358949f, -0.16175304f, -0.61220586f, 0.11513958f, 
    0.23258531f, 0.12883626f, 0.00278448f, 0.00420353f, 0.02913982f, 0.09059168f, -0.14173108f, 0.18131931f, 
    0.15841044f, -0.04961280f, 0.17662913f, -0.03930287f, 0.18111551f, 0.09130573f, 0.11773393f, 0.06279443f, 
    -0.04994567f, 0.05580246f, 0.02548855f, -0.23589551f, 0.12346542f, -0.00567869f, 0.11498406f, 0.05951235f, 
    -0.02941574f, -0.29156205f, 0.02023964f, 0.28991467f, 0.02291284f, 0.07806850f, 0.16499060f, 0.04302501f, 
    0.09559052f, 0.13901366f, 0.14279763f, 0.03661760f, -0.08544367f, 0.07211513f, -0.01499077f, 0.05778240f, 
    -0.16770889f, -0.02439445f, 0.00305869f, -0.02653918f, 0.26870325f, -0.06083870f, -0.01648812f, -0.19564660f, 
    -0.05336097f, 0.12278651f, 0.07459343f, -0.08106610f, 0.28815290f, -0.10128802f, 0.12295543f, 0.16841914f, 
    -0.18540198f, 0.43902528f, -0.06529207f, 0.01628663f, 0.21787627f, -0.39383158f, -0.25953770f, -0.31337410f, 
    -0.21209866f, -0.04716331f, -0.04366314f, 0.14440057f, -0.11017032f, 0.06114971f, 0.12068091f, 0.00177656f, 
    0.13532577f, 0.16559491f, 0.13819192f, -0.09626558f, -0.02817590f, 0.12233899f, -0.29705861f, 0.14426892f, 
    0.12257997f, -0.13450447f, -0.09646569f, 0.40759188f, 0.21541671f, 0.14870742f, -0.23112056f, 0.38121253f, 
    -0.07268444f, -0.05171175f, -0.19585791f, 0.07383096f, 0.15037602f, 0.11285747f, -0.24120097f, -0.02604303f, 
    -0.04426042f, -0.24413274f, -0.01019727f, 0.00631663f, -0.11261609f, 0.42134237f, 0.07069997f, -0.07390856f, 
    -0.14369141f, 0.07968926f, -0.14409494f, 0.23619616f, 0.02061426f, 0.59816289f, -0.07256557f, -0.04473404f, 
    -0.18073259f, 0.09097778f, 0.18585554f, 0.09280076f, -0.10197183f, 0.14789842f, 0.09439570f, -0.16812645f, 
    -0.50278091f, 0.13751827f, -0.19349366f, 0.13257374f, -0.29899427f, 0.03620486f, 0.24994902f, 0.02005445f, 
    0.50003099f, -0.21451719f, 0.29234451f, -0.18640544f, 0.02765639f, -0.10068250f, 0.02081437f, -0.02384847f, 
    -0.02507413f, 0.12746033f, 0.20029677f, 0.37646714f, -0.15577668f, 0.12481482f, -0.02956886f, -0.02318951f, 
    0.33792681f, 0.01443561f, -0.10446642f, 0.21171430f, -0.24825214f, -0.10797311f, -0.07108174f, -0.12266241f, 
    0.32792377f, 0.13520144f, 0.06295057f, 0.00217928f, -0.02721453f, 0.03617722f, 0.02899868f, 0.01220927f, 
    -0.25645840f, -0.12990312f, 0.23805921f, -0.16183841f, -0.54105908f, 0.07268351f, 0.22178020f, -0.15830076f, 
    0.09888938f, 0.06281818f, 0.10402966f, -0.15383238f, -0.01230690f, -0.01449911f, 0.23408173f, 0.04418124f, 
    0.04824147f, -0.42885506f, 0.23570353f, -0.42880762f, -0.07608309f, -0.01592167f, 0.02481887f, 0.12917289f, 
    0.02016993f, 0.15423782f, 0.29343981f, -0.18103865f, 0.00216870f, 0.11796746f, 0.16817994f, 0.09071595f, 
    0.17647250f, 0.51860940f, -0.07015950f, -0.19958004f, 0.30630347f, -0.37355903f, 0.02179657f, -0.29987678f, 
    0.11391404f, 0.05962127f, 0.07147526f, 0.40593839f, -0.12798212f, -0.22674233f, -0.28230965f, -0.25633347f, 
    0.03920049f, -0.03109829f, 0.05879107f, -0.04927533f, -0.00673498f, -0.00183649f, -0.02318324f, -0.05742579f, 
    -0.00613011f, 0.08651640f, -0.08617905f, -0.05605001f, 0.07587220f, 0.00953330f, -0.06483931f, -0.05059824f, 
    -0.00812134f, -0.00091646f, -0.00274451f, 0.02497765f, 0.07426520f, -0.01193166f, -0.06257414f, -0.08432777f, 
    -0.03793025f, 0.03305161f, 0.02471500f, 0.08818420f, -0.02664575f, 0.00126216f, -0.06327969f, -0.04114001f, 
    -0.06126542f, -0.00741151f, -0.00016452f, -0.06304775f, -0.04856493f, -0.04565669f, -0.07206471f, 0.05189057f, 
    -0.05184347f, 0.00499882f, 0.01595963f, -0.02358468f, -0.04092154f, -0.05091023f, 0.01005802f, -0.07564527f, 
    -0.05991712f, -0.08492904f, -0.07255462f, 0.03069992f, -0.05788177f, 0.00733533f, 0.04350228f, 0.01421532f, 
    0.08050569f, 0.00827555f, 0.00955342f, -0.00258238f, -0.06929812f, -0.08473901f, -0.03101249f, 0.04843017f, 
    -0.02936953f, -0.01399139f, -0.05056134f, 0.00390355f, 0.02905777f, 0.01552490f, -0.03473854f, -0.01885494f, 
    -0.08012585f, -0.05284518f, 0.04629898f, -0.06752650f, 0.03653514f, 0.03308664f, -0.07275945f, -0.03432223f, 
    -0.07398605f, -0.08788259f, 0.04803596f, 0.02117641f, 0.02949588f, -0.05170549f, 0.01193220f, 0.05346728f, 
    0.04999898f, -0.05367361f, -0.04531485f, 0.00194835f, 0.01871365f, 0.06195349f, 0.00701675f, -0.01425296f, 
    0.04382854f, 0.00180626f, 0.08106792f, -0.02624774f, -0.08238754f, -0.01149666f, -0.05750903f, 0.03318940f, 
    0.04951093f, -0.03879697f, -0.01139278f, -0.07236680f, -0.00248714f, -0.04102625f, -0.04032845f, -0.05614866f, 
    -0.06756776f, -0.03668775f, 0.05312911f, 0.08404845f, 0.01417799f, 0.01210051f, -0.07016328f, -0.06217818f, 
    0.06984036f, -0.06371872f, -0.02106196f, 0.02397949f, -0.04635890f, 0.02850281f, -0.00865039f, 0.01192505f, 
    -0.13692239f, -0.03994347f, -0.10085116f, -0.01488420f, -0.05192719f, -0.05702933f, 0.05633530f, -0.06099848f, 
    -0.03527079f, -0.00189115f, -0.00044867f, -0.01345185f, -0.05747323f, -0.02752345f, 0.07869764f, -0.00566914f, 
    -0.11245409f, -0.00093035f, -0.03758129f, 0.01655120f, -0.04091609f, -0.08338853f, -0.05072955f, -0.07229827f, 
    0.03503149f, 0.01550781f, 0.04162734f, -0.01052139f, -0.02345845f, -0.10198005f, 0.05709649f, -0.07053610f, 
    0.00334855f, 0.04181382f, -0.01563380f, 0.03314316f, -0.15530632f, -0.00639211f, 0.05533024f, 0.06665146f, 
    -0.06327804f, -0.04182828f, -0.02059413f, -0.00176312f, 0.00333571f, 0.01749694f, 0.02692965f, -0.10447643f, 
    0.03045630f, -0.00739848f, 0.00558075f, -0.05431277f, -0.12099956f, -0.00267329f, -0.01668171f, -0.10498265f, 
    -0.01072962f, 0.04450475f, 0.03477811f, 0.05014494f, -0.09022781f, 0.08971474f, -0.09262454f, -0.00206938f, 
    0.07914978f, 0.00274264f, 0.00440770f, 0.10989193f, -0.09767556f, -0.12111846f, 0.01448525f, -0.06587794f, 
    -0.04053250f, -0.04263578f, 0.01559452f, -0.09491985f, 0.03077665f, -0.05707379f, -0.06316917f, 0.01020037f, 
    -0.05859355f, -0.00346650f, -0.01593515f, -0.00655332f, 0.07905273f, 0.03154304f, -0.01274035f, -0.06934042f, 
    -0.09856415f, 0.06295285f, 0.08056023f, -0.01267316f, 0.01577649f, 0.06608891f, -0.07937416f, 0.05655359f, 
    0.04132448f, 0.00784947f, -0.10556597f, -0.00512174f, -0.14226532f, 0.04322801f, -0.10201402f, 0.00380221f, 
    -0.02188626f, 0.10585006f, -0.03310201f, -0.09955482f, -0.11292171f, -0.01670985f, 0.03055384f, 0.05514076f, 
    -0.01663603f, -0.05911988f, -0.10981194f, -0.01269195f, -0.07077779f, -0.10450141f, 0.04686337f, -0.03362806f, 
    -0.10654516f, -0.15737122f, -0.02381782f, -0.11089636f, 0.01748651f, -0.04955160f, -0.10553937f, -0.16103107f, 
    -0.00423546f, -0.22619008f, -0.29943091f, -0.14407627f, -0.14396510f, -0.71939182f, 0.13317586f, -0.53606468f, 
    -0.17616686f, -0.06978633f, -0.07151187f, -0.26658517f, 0.01923320f, 0.16629793f, 0.31270453f, -0.05542618f, 
    -0.10685391f, 0.10116163f, -0.00495507f, 0.05464422f, 0.01492574f, 0.22560161f, 0.09323238f, -0.04709432f, 
    -0.06901699f, 0.23206113f, 0.16850466f, 0.31411439f, -0.14923619f, 0.26315340f, -0.12545951f, -0.16983232f, 
    -0.03719126f, -0.03478782f, -0.12169430f, -0.22217451f, -0.27948835f, -0.04745836f, 0.34271881f, 0.15933765f, 
    -0.17357427f, 0.16066290f, 0.17890988f, -0.54130191f, 0.06822287f, 0.21951084f, 0.23161112f, -0.16945161f, 
    0.13979918f, 0.29028815f, 0.00804168f, 0.15852244f, -0.05071302f, 0.12216088f, 0.31069514f, -0.13977697f, 
    -0.15762068f, -0.31464651f, -0.37760535f, -0.05290873f, 0.02505704f, 0.12142675f, -0.03283577f, -0.03832790f, 
    0.03760925f, -0.03090216f, 0.11927550f, 0.33326435f, 0.20561859f, 0.03613218f, 0.13322574f, 0.23295444f, 
    -0.00936888f, 0.25739959f, -0.04532728f, -0.26020077f, 0.04598173f, -0.55409884f, -0.30533642f, -0.11096866f, 
    0.15063936f, 0.07195792f, -0.11909503f, -0.00277214f, 0.13841210f, -0.06898430f, 0.11109548f, 0.03151072f, 
    0.12441652f, 0.13346437f, -0.01949285f, 0.17371689f, -0.32326442f, 0.03378410f, -0.37293327f, 0.17871854f, 
    -0.32425690f, -0.34523371f, -0.37747264f, 0.20186041f, -0.17338368f, -0.08399727f, -0.13287021f, 0.07068463f, 
    0.64303267f, -0.03525729f, -0.23054194f, 0.03396709f, -0.05861591f, 0.27186468f, -0.22677033f, -0.12647358f, 
    -0.04883021f, -0.17138641f, -0.09008487f, 0.06774867f, -0.10078012f, 0.13942875f, 0.05854788f, 0.36911121f, 
    0.10452653f, -0.68740606f, -0.33300364f, -0.41366905f, 0.12490057f, -0.16868247f, -0.07887939f, 0.09634119f, 
    0.01228498f, 0.02244360f, 0.01446332f, -0.02723791f, 0.03258994f, -0.01409478f, -0.05589857f, -0.08178341f, 
    -0.08636814f, 0.06672853f, 0.05945133f, -0.06077681f, -0.02907359f, 0.02046243f, -0.02416159f, -0.04273206f, 
    -0.02149754f, -0.05561493f, -0.01422415f, 0.08460566f, 0.07001761f, -0.03122871f, -0.03138774f, -0.06311300f, 
    0.01831433f, -0.04065188f, 0.03705414f, -0.07983703f, -0.09276416f, 0.02148258f, -0.06929017f, -0.05389067f, 
    0.06931015f, 0.04566178f, -0.06341705f, -0.09633734f, -0.02686735f, 0.04444500f, 0.03625235f, -0.07342263f, 
    -0.02113548f, 0.08368934f, -0.01973118f, -0.07435004f, 0.01628164f, -0.09183720f, -0.08031272f, 0.04802821f, 
    0.03714941f, -0.00935796f, -0.09514146f, -0.05485327f, -0.09248408f, 0.05299977f, -0.06657910f, -0.09231275f, 
    0.02606644f, 0.02331612f, 0.05470916f, -0.03894402f, -0.00670487f, -0.04740164f, -0.04569378f, -0.04586427f, 
    -0.04416686f, -0.04249720f, -0.09318683f, -0.07322667f, -0.09568618f, 0.05767794f, 0.02527394f, -0.01134631f, 
    -0.04688939f, -0.09619646f, -0.06954166f, -0.04425466f, -0.08279593f, 0.07033727f, -0.08535208f, -0.02441141f, 
    -0.01048473f, 0.05925581f, -0.00010727f, -0.04855740f, -0.04211491f, -0.08508462f, 0.01802960f, -0.03565436f, 
    0.05154652f, 0.07452088f, -0.00715676f, -0.04026074f, -0.00123675f, -0.00123503f, -0.05617382f, 0.02631739f, 
    -0.01929144f, -0.00692320f, -0.08751692f, -0.00119065f, 0.05927530f, -0.00463273f, -0.01152842f, 0.03598827f, 
    -0.00623646f, 0.01902823f, -0.08389850f, -0.00419757f, 0.01994620f, -0.06180091f, 0.06741945f, 0.04948466f, 
    -0.05309485f, -0.09609375f, -0.06469125f, -0.00932208f, 0.03353039f, 0.06634963f, 0.06625624f, -0.09433643f, 
    0.03673688f, 0.04622882f, 0.05292450f, 0.02120282f, -0.06443821f, 0.03767370f, 0.04370197f, -0.04904799f, 
    0.03663779f, -0.00494608f, -0.07056417f, -0.01282664f, 0.01826408f, -0.07732611f, -0.02816941f, -0.02266709f, 
    0.01717273f, 0.08104662f, -0.10311523f, 0.01612932f, 0.03682087f, -0.03544194f, -0.10222118f, -0.07544410f, 
    -0.06383175f, -0.03541140f, -0.03582858f, -0.02197325f, -0.04255379f, -0.07690854f, -0.05318486f, 0.00655974f, 
    -0.09251953f, -0.04006944f, 0.04030779f, -0.03506540f, 0.04506811f, 0.05408198f, 0.05143390f, -0.07316392f, 
    -0.05925492f, 0.02388146f, -0.08929788f, -0.09795056f, -0.03794671f, -0.11000059f, -0.09103589f, -0.01884484f, 
    0.06497011f, -0.02986499f, -0.11946557f, 0.07742736f, -0.03478274f, -0.09205449f, -0.11553918f, 0.04659977f, 
    0.02667844f, -0.08395575f, -0.07313065f, -0.00944350f, 0.04685220f, -0.09627947f, 0.03254823f, -0.09305400f, 
    0.02169864f, 0.01412358f, -0.07002328f, -0.00334160f, -0.07486888f, -0.05158945f, -0.08324321f, -0.03904365f, 
    0.03877509f, 0.03150289f, -0.03071690f, 0.01031469f, 0.04035596f, -0.10870068f, -0.10004947f, 0.05446547f, 
    -0.03953133f, -0.06574488f, -0.01711449f, 0.05057735f, 0.07914181f, -0.00034064f, -0.09372998f, -0.04961131f, 
    -0.11537799f, 0.05649735f, -0.04199113f, -0.09241930f, -0.09150145f, -0.11836005f, -0.09450696f, -0.00574165f, 
    -0.11767706f, 0.07778430f, 0.00683558f, -0.09189185f, -0.02370327f, 0.05593071f, -0.04424412f, -0.03853174f, 
    0.01136036f, -0.05783638f, -0.06399712f, 0.03640944f, -0.02897499f, -0.05666693f, -0.11012515f, 0.03550906f, 
    0.03870329f, 0.02838975f, -0.07124244f, -0.04053642f, -0.10308498f, 0.02310967f, -0.01303608f, 0.04821377f, 
    -0.06822418f, -0.00325868f, 0.02220548f, -0.06198462f, 0.02633409f, -0.08905762f, 0.01069425f, -0.09752664f, 
    0.05449696f, -0.06812247f, 0.01726519f, 0.05095666f, -0.07838392f, -0.07366452f, -0.03209980f, 0.04946367f, 
    -0.06071627f, -0.01301489f, -0.04971304f, -0.00717388f, -0.03803689f, -0.03664048f, -0.00189917f, -0.03892076f, 
    0.07047870f, -0.06889902f, 0.00302342f, -0.05148649f, 0.04254443f, 0.05275056f, -0.01297015f, -0.07192647f, 
    -0.06325066f, 0.01667406f, -0.03279114f, 0.05040993f, -0.06896206f, 0.03054053f, -0.01712014f, 0.03531533f, 
    -0.02470823f, 0.07084049f, -0.05988114f, 0.02836634f, 0.03443998f, -0.03187402f, -0.07958244f, 0.03535100f, 
    -0.00853839f, -0.01809030f, -0.06234020f, -0.07534187f, -0.03307214f, 0.07344074f, 0.02890801f, 0.02432015f, 
    0.04310625f, 0.00058276f, 0.07056466f, -0.00508428f, -0.07906717f, -0.07453558f, -0.02911057f, -0.01564097f, 
    0.01316172f, -0.10627102f, 0.05980936f, -0.08888265f, 0.04647638f, 0.00255135f, 0.04930829f, 0.04016121f, 
    -0.02447012f, -0.01874459f, 0.01076879f, 0.05155821f, 0.02226492f, 0.05499515f, -0.06542727f, -0.05837878f, 
    0.07560863f, 0.01286437f, -0.02601983f, 0.04521613f, 0.04974777f, 0.03963710f, 0.03377835f, 0.04072917f, 
    0.05558384f, -0.04878708f, 0.06720866f, 0.06408000f, -0.00964905f, -0.03560529f, 0.03034786f, 0.07946207f, 
    -0.01501889f, 0.06319167f, 0.00671300f, -0.07359304f, 0.00339335f, 0.01387729f, -0.07781657f, -0.03843739f, 
    -0.03747214f, -0.03435565f, -0.07613901f, 0.05256732f, -0.00832212f, -0.01646505f, -0.05840122f, -0.04231851f, 
    0.00758056f, -0.06411731f, -0.02913318f, 0.02571035f, -0.06448352f, -0.05397679f, -0.00370835f, -0.06857611f, 
    -0.00392990f, -0.00978154f, 0.04042369f, 0.02447199f, -0.01200387f, 0.02524430f, 0.06847517f, 0.06943306f, 
    0.03042459f, 0.06842430f, -0.10709596f, -0.04482348f, -0.08320434f, -0.07290238f, -0.03703076f, 0.02985386f, 
    -0.07657193f, -0.09170251f, -0.01086020f, 0.02866026f, -0.10141667f, -0.06564158f, -0.06231812f, 0.06451704f, 
    -0.05965813f, 0.15691465f, 0.14951339f, 0.38333663f, 0.21443297f, 0.44615546f, 0.10475440f, 0.22772695f, 
    0.14853849f, 0.06704579f, -0.00375115f, 0.04940516f, -0.21697643f, -0.22789864f, -0.21937059f, 0.00089972f, 
    0.27987474f, -0.04538055f, -0.33321705f, -0.05364952f, -0.41600025f, 0.13142659f, 0.14090513f, -0.06620307f, 
    -0.04761980f, 0.26618981f, 0.17143703f, 0.15558651f, 0.07152596f, 0.37124768f, -0.06245003f, -0.01212012f, 
    0.02341405f, 0.33410737f, 0.04304405f, 0.14777252f, 0.10441907f, 0.09192901f, 0.02858875f, 0.08381034f, 
    0.53706694f, -0.03950479f, 0.12088522f, 0.01876056f, -0.31230140f, 0.08982006f, 0.10055052f, 0.05382565f, 
    0.16918525f, -0.12201682f, -0.05049460f, -0.29038638f, 0.04606447f, 0.11040848f, -0.31592911f, 0.07286835f, 
    0.26315421f, -0.24599357f, 0.07464980f, 0.11143677f, -0.05845778f, 0.06958213f, 0.00384745f, -0.04341647f, 
    -0.07059380f, -0.05443439f, 0.01131213f, -0.26938927f, -0.27104086f, -0.00943546f, -0.29562441f, -0.04891235f, 
    0.66639137f, -0.42172554f, 0.07059381f, 0.16931286f, 0.04318902f, 0.02370771f, 0.19160734f, -0.06658585f, 
    -0.17861520f, -0.12468909f, -0.06567325f, 0.09337255f, 0.00581103f, -0.06527286f, -0.40033934f, -0.16354685f, 
    -0.04333683f, -0.19166081f, -0.05587570f, -0.54499435f, 0.06725778f, 0.07374018f, 0.50926566f, 0.04454629f, 
    0.06988579f, 0.00177382f, 0.19380228f, -0.30596471f, 0.18402120f, 0.07256573f, -0.06681465f, -0.06321678f, 
    0.07039969f, -0.25374609f, 0.38813543f, 0.08491571f, -0.00374661f, -0.08152693f, 0.37616271f, -0.02523696f, 
    -0.24829948f, 0.31709990f, -0.09732743f, -0.02763219f, 0.00303769f, -0.13316797f, 0.09140166f, -0.11035772f, 
    -0.03247381f, 0.20997377f, 0.45382586f, 0.26617748f, -0.16032928f, -0.31191427f, 0.13428569f, -0.13591376f, 
    -0.10493908f, 0.52847070f, 0.20728670f, 0.17721987f, 0.08101797f, 0.21865423f, 0.49796796f, 0.07112941f, 
    -0.25615457f, 0.00442878f, 0.30938068f, -0.22012235f, -0.13555703f, -0.13067088f, 0.13849333f, 0.05327295f, 
    0.02160274f, -0.02984630f, -0.21834461f, -0.04773830f, 0.24408785f, 0.01738151f, 0.19624619f, -0.22230232f, 
    0.28273237f, 0.21304989f, 0.16738482f, -0.16414475f, -0.06667675f, 0.00632398f, 0.05718485f, -0.28887430f, 
    0.15987913f, 0.03435676f, 0.15383577f, -0.00862728f, -0.02942784f, 0.09282644f, 0.25585553f, 0.18038586f, 
    -0.16895166f, -0.40525180f, -0.00822150f, -0.10610712f, -0.18032743f, 0.24889630f, -0.26692167f, 0.02996653f, 
    -0.14877892f, 0.05921119f, 0.08212768f, -0.16586764f, 0.21758030f, 0.32546329f, -0.19118369f, -0.01481783f, 
    0.12751149f, -0.10039086f, -0.07781155f, -0.13007852f, -0.01183668f, -0.40934277f, 0.05292013f, 0.32971454f, 
    -0.19665967f, -0.04286654f, 0.17973837f, -0.10649176f, -0.10009552f, -0.03028764f, -0.05709994f, 0.32883456f, 
    0.05331922f, 0.03847357f, -0.03468988f, 0.03215001f, -0.06873538f, 0.03895202f, -0.01652219f, -0.04264038f, 
    0.12018527f, 0.11960594f, 0.16420767f, -0.05567492f, 0.07863535f, -0.04251164f, -0.10487279f, 0.19849098f, 
    0.21419755f, 0.15371230f, -0.09142633f, -0.16490929f, 0.20423421f, 0.02553861f, 0.03467913f, -0.31234762f, 
    -0.21657203f, -0.35809165f, 0.02389438f, 0.04009006f, 0.02434950f, 0.11598017f, 0.19461712f, 0.20174915f, 
    -0.11260574f, -0.00739011f, 0.08214721f, -0.00098350f, 0.12363794f, 0.17912948f, -0.00839742f, -0.28701767f, 
    -0.15908937f, -0.41072869f, 0.09845573f, 0.24104109f, 0.02329861f, -0.10197219f, 0.25238246f, 0.12117715f, 
    0.22499517f, -0.01473744f, -0.02196613f, 0.00156170f, 0.02699302f, -0.11879522f, -0.05574125f, -0.07020411f, 
    -0.05460402f, 0.00210098f, -0.08528838f, 0.04600245f, 0.06468247f, -0.04641793f, -0.10760570f, 0.05597687f, 
    0.01611314f, -0.01197619f, -0.00974328f, -0.01089017f, -0.02455486f, -0.04885938f, -0.04626090f, 0.02850917f, 
    -0.02300690f, -0.07563265f, -0.02273822f, -0.09085573f, 0.03933186f, 0.00476462f, -0.00338556f, 0.06023941f, 
    -0.00568383f, 0.01744189f, -0.05333254f, -0.02719074f, -0.06825087f, -0.06137490f, -0.03759385f, 0.02258261f, 
    0.00198979f, -0.06753919f, 0.03130635f, -0.04399157f, -0.03059390f, -0.04906532f, 0.05153989f, 0.06880676f, 
    0.03557278f, -0.05764464f, 0.03624404f, -0.05108253f, -0.06185591f, 0.07536945f, -0.03920842f, -0.08084238f, 
    0.03708766f, -0.02471297f, -0.05785916f, -0.06365914f, 0.00778565f, -0.05134908f, 0.04630553f, 0.03447631f, 
    -0.08491469f, -0.03024586f, -0.04510164f, -0.07184995f, 0.05530334f, 0.07493901f, -0.08831394f, -0.07107189f, 
    -0.03153777f, 0.07449289f, 0.02565888f, -0.00298174f, 0.07258166f, -0.02337115f, 0.04962520f, 0.00156175f, 
    -0.09487990f, -0.05634702f, -0.07837626f, 0.06539334f, 0.05027693f, -0.01403571f, -0.06405659f, -0.00373808f, 
    0.00775714f, -0.08462233f, 0.00219279f, -0.07365397f, 0.04810089f, 0.00507757f, -0.02918426f, -0.05707191f, 
    -0.05000374f, -0.04458740f, 0.05663092f, 0.06230081f, -0.06686829f, -0.02132361f, -0.03635907f, -0.03770766f, 
    0.02794034f, -0.09174808f, -0.07647368f, -0.09672383f, -0.09936941f, 0.03808650f, -0.04909965f, 0.05004274f, 
    0.00830972f, 0.08102446f, -0.02535727f, -0.00933792f, 0.00618021f, 0.06981692f, 0.04429014f, -0.03134589f, 
    -0.00533899f, -0.02865572f, 0.07673828f, -0.07635341f, -0.05508647f, 0.06416121f, 0.06298647f, 0.00081475f, 
    0.03965553f, -0.07464803f, 0.00464436f, 0.07899589f, -0.08491662f, -0.07868609f, -0.04190042f, -0.06605908f, 
    -0.07022978f, -0.01961215f, 0.08091325f, -0.25312629f, -0.09237389f, -0.18468861f, -0.00897032f, -0.40518895f, 
    0.19482864f, -0.00921701f, 0.24130036f, 0.14938731f, -0.09422000f, -0.06057458f, 0.07887175f, -0.06019218f, 
    0.14178544f, 0.21384045f, 0.14504276f, 0.04744203f, 0.14928003f, -0.03760640f, 0.06120280f, 0.09494288f, 
    -0.33702686f, -0.10014074f, 0.32052511f, 0.05840078f, -0.05716165f, -0.34319431f, -0.03667884f, -0.47879124f, 
    -0.03138538f, -0.05697007f, -0.14234319f, -0.00967423f, 0.04258560f, -0.11861323f, 0.02247664f, 0.24275735f, 
    0.63603932f, -0.20118998f, 0.08174501f, 0.09093241f, 0.08781823f, 0.33955148f, -0.10048269f, 0.13805307f, 
    -0.31524172f, -0.07227825f, -0.39818957f, 0.20128334f, 0.02551933f, 0.05698119f, 0.16028145f, -0.14219926f, 
    0.23202333f, -0.47644371f, -0.17474404f, -0.09779321f, 0.07424878f, 0.05092709f, -0.07467787f, 0.10839811f, 
    0.01200270f, 0.00167623f, 0.19509831f, 0.19795729f, 0.16351160f, 0.16240890f, -0.07458662f, 0.07292399f, 
    -0.01935668f, 0.01450012f, 0.00693964f, 0.00930656f, -0.01734784f, -0.08734484f, -0.07377411f, -0.02893968f, 
    0.06719369f, -0.18039633f, -0.08938616f, 0.11350141f, 0.24802013f, 0.02564023f, -0.05300573f, 0.08238621f, 
    -0.01716154f, -0.01863652f, -0.09382792f, 0.07674943f, -0.14974685f, 0.05286219f, 0.39057186f, -0.01185936f, 
    -0.12918988f, 0.15378393f, -0.21884628f, 0.23420265f, 0.08682229f, 0.11226438f, 0.06446906f, -0.22107309f, 
    0.02792046f, -0.33147427f, 0.00341886f, 0.10748391f, 0.12230168f, 0.20951502f, -0.14503117f, -0.00960431f, 
    -0.07188170f, 0.14795828f, 0.04769279f, 0.05420496f, -0.47292027f, 0.35159850f, 0.03626153f, 0.20527868f, 
    -0.12902544f, -0.07353166f, -0.13393249f, -0.44420731f, 0.02568690f, -0.08748980f, 0.14552352f, 0.27379486f, 
    0.13910852f, -0.03198095f, -0.03371832f, 0.17210625f, -0.08788786f, 0.08713619f, 0.07109468f, 0.18080801f, 
    0.15821093f, 0.06489253f, 0.10107832f, -0.02774211f, 0.19674520f, -0.18567644f, 0.08093125f, 0.04036846f, 
    -0.07972039f, 0.19074498f, 0.20688207f, -0.06916066f, 0.15574060f, -0.39635184f, -0.15984602f, 0.02243681f, 
    -0.44988444f, 0.35553727f, -0.12111963f, -0.08438838f, -0.05866967f, -0.19452451f, 0.10424180f, 0.30695733f, 
    -0.12680973f, -0.15257686f, -0.09355208f, 0.20992914f, 0.24794212f, 0.03413744f, 0.11298791f, 0.04457057f, 
    -0.04841736f, -0.00960784f, 0.02445327f, 0.16121963f, -0.03216325f, -0.20514677f, -0.52653891f, -0.02525135f, 
    -0.67224544f, 0.16447005f, 0.06089281f, -0.07671252f, 0.11374112f, 0.12499861f, -0.27157104f, 0.09160925f, 
    0.05115265f, -0.08187472f, 0.04395568f, -0.16939734f, 0.26712236f, -0.19919895f, -0.08608256f, 0.05177814f, 
    -0.26587790f, 0.03190620f, 0.02399998f, -0.31261641f, 0.04675082f, 0.09551865f, 0.21340923f, -0.03554703f, 
    0.05202754f, -0.10814948f, -0.01316809f, 0.03748180f, -0.07572845f, -0.02361326f, 0.00585360f, 0.11191523f, 
    0.16147633f, 0.11925948f, -0.08442283f, 0.02995562f, -0.06804825f, -0.06505784f, -0.09773500f, 0.13700031f, 
    -0.05544456f, -0.07645247f, -0.09479948f, -0.09800747f, 0.25693971f, 0.03383905f, -0.26382622f, -0.02484291f, 
    0.03303619f, 0.10199947f, 0.16955924f, 0.12537952f, 0.04957983f, 0.12301755f, -0.02207547f, 0.10245638f, 
    0.50710070f, -0.30611175f, -0.11257413f, 0.22289610f, 0.02967469f, -0.52463526f, -0.14975500f, -0.13001269f, 
    0.36963037f, -0.29734260f, 0.06007968f, 0.24929775f, 0.14158995f, 0.14534673f, -0.04575519f, 0.01223568f, 
    0.00566586f, 0.11812039f, 0.16868980f, -0.04198418f, 0.10122339f, 0.34271300f, 0.19173190f, 0.17841125f, 
    -0.05952051f, 0.07213414f, -0.01965409f, -0.13501048f, 0.04108378f, 0.05453185f, 0.11411015f, -0.03555989f, 
    -0.13372384f, 0.06657516f, 0.20840964f, -0.01688517f, 0.31414440f, -0.13072930f, 0.19375117f, -0.04464086f, 
    -0.01031085f, 0.03422428f, 0.00892729f, -0.00900711f, -0.07563704f, -0.41571653f, -0.03422026f, 0.02826632f, 
    0.03288964f, 0.08097745f, -0.11357624f, -0.12739584f, -0.08310523f, -0.05198966f, 0.06139373f, -0.21132919f, 
    0.12076722f, -0.50054222f, 0.17167650f, 0.09586938f, 0.30331984f, 0.13708815f, 0.16859412f, -0.22553979f, 
    -0.51659060f, -0.44989541f, -0.09002023f, 0.22315361f, 0.28499195f, -0.13411143f, -0.14886142f, -0.02993891f, 
    0.74575490f, 0.00946224f, 0.24631897f, -0.00380884f, 0.00996087f, 0.10244071f, -0.17812587f, 0.12804449f, 
    0.12629957f, 0.03674144f, 0.18175429f, -0.14938219f, 0.11691621f, -0.29351652f, -0.03720221f, -0.33334842f, 
    -0.22772862f, 0.01312653f, 0.23383661f, 0.16606008f, -0.02047921f, 0.12038081f, -0.10930978f, 0.26331952f, 
    -0.48629159f, -0.09296911f, -0.06013393f, 0.02045503f, 0.06481479f, 0.26224741f, 0.17345686f, 0.00231344f, 
    0.15678772f, 0.20936196f, 0.20075513f, -0.14618404f, 0.00628955f, 0.26665685f, -0.37507108f, 0.15017360f, 
    0.00548511f, 0.30429691f, 0.08929103f, 0.36668885f, 0.32864574f, -0.00215891f, -0.15971182f, -0.04222325f, 
    -0.26664785f, 0.13427255f, 0.09711921f, -0.02369845f, 0.03134852f, 0.18673785f, 0.15195049f, 0.21102914f, 
    -0.24239472f, 0.16089463f, -0.02175740f, 0.13933013f, 0.23957796f, 0.12454527f, -0.33802229f, -0.13888136f, 
    -0.12941940f, -0.04079616f, 0.03973209f, 0.17296372f, 0.04761939f, 0.08717945f, 0.05206562f, -0.05659989f, 
    0.00600249f, 0.13733244f, -0.35421842f, 0.14847393f, 0.11204888f, 0.26989824f, -0.22346598f, 0.12222812f, 
    0.38478351f, 0.29329383f, -0.15596707f, -0.15338922f, -0.06078003f, -0.24314742f, -0.06234973f, -0.09988490f, 
    -0.11885643f, -0.02123077f, 0.20508543f, 0.16037409f, 0.17918830f, 0.00905011f, 0.14382213f, -0.03102324f, 
    0.08837207f, 0.23729093f, -0.00652134f, 0.03836476f, -0.00743971f, -0.12249939f, -0.11629933f, 0.25956827f, 
    -0.19264142f, 0.02801118f, -0.06498234f, -0.06982119f, 0.11303161f, -0.27999067f, -0.02486176f, -0.30235845f, 
    -0.09113685f, -0.29380181f, -0.10157260f, 0.27615014f, 0.35354546f, 0.05091899f, -0.08237424f, -0.20152090f, 
    -0.42316613f, -0.06161784f, 0.02875427f, 0.02501504f, 0.32024238f, -0.14176431f, 0.06575254f, 0.07541559f, 
    -0.74285680f, 0.07576219f, -0.22019696f, 0.12446096f, -0.12706535f, -0.09251386f, -0.00585657f, 0.09718974f, 
    0.02063589f, -0.28454691f, -0.22515298f, -0.15082884f, 0.14622656f, -0.02831371f, -0.12535457f, -0.31540915f, 
    -0.18857129f, 0.07808616f, 0.21831283f, 0.20282239f, -0.03298930f, 0.08387610f, -0.33714631f, 0.13253485f, 
    -0.17614059f, -0.27573782f, 0.04681992f, 0.10269041f, 0.04905942f, 0.22507158f, 0.23256692f, -0.01587806f, 
    0.10931142f, 0.25094974f, -0.15633212f, -0.06515966f, -0.06438866f, 0.21297342f, -0.07690288f, 0.15455966f, 
    -0.06638621f, -0.27931511f, -0.07641970f, 0.23110157f, 0.17835853f, -0.08342545f, -0.26942560f, -0.15592313f, 
    -0.27709797f, 0.18255432f, 0.13849318f, 0.12307024f, 0.20556374f, 0.29896912f, -0.01022425f, 0.31822520f, 
    0.12107664f, -0.09660863f, -0.23803566f, 0.32281020f, 0.19615802f, -0.17617241f, -0.15085959f, 0.33739954f, 
    0.09408997f, -0.43442681f, -0.01833642f, 0.26485872f, 0.32517520f, 0.17244355f, 0.05248085f, -0.04208363f, 
    -0.21512069f, -0.02007801f, -0.65747589f, 0.19140036f, -0.00917346f, 0.06032233f, 0.27410287f, 0.31969386f, 
    0.04147672f, -0.09487721f, 0.11980823f, -0.29321542f, 0.05224894f, -0.09243745f, 0.14173917f, 0.05801900f, 
    -0.51027304f, 0.01243247f, 0.20654692f, -0.16581707f, 0.22019723f, -0.08227544f, 0.24434566f, -0.02063070f, 
    -0.05171998f, 0.14788772f, -0.17186804f, -0.06459480f, 0.17032392f, -0.11350423f, 0.03815591f, -0.21519674f, 
    0.03508089f, -0.05925380f, -0.14761767f, -0.04978083f, -0.08534840f, -0.09819890f, 0.06102204f, -0.34388545f, 
    0.07017993f, -0.21383023f, 0.33429623f, -0.21963890f, -0.03147586f, 0.30669653f, 0.36176434f, -0.08930421f, 
    0.02356387f, -0.12759975f, -0.08688359f, -0.16794127f, 0.13806660f, 0.11349978f, -0.17409496f, -0.05062559f, 
    0.57024801f, 0.22445489f, 0.15502281f, -0.00705340f, 0.10269903f, 0.00440726f, 0.09234284f, 0.06487008f, 
    -0.00275868f, 0.09500417f, -0.08609003f, -0.00342867f, 0.35188612f, -0.30069447f, 0.03448847f, 0.00817286f, 
    -0.14506978f, 0.05720077f, 0.12212623f, -0.00568158f, 0.19159898f, -0.04314083f, 0.28502858f, 0.13760531f, 
    -0.35625398f, 0.14715770f, -0.07238542f, 0.09970545f, 0.07504860f, -0.12812661f, -0.04489714f, 0.10450082f, 
    0.15335451f, 0.25824374f, 0.36032575f, -0.15649828f, -0.02971991f, 0.17485282f, -0.09109438f, 0.23407024f, 
    0.22290090f, 0.39336386f, 0.05024263f, -0.01600556f, 0.23822826f, 0.04308808f, 0.02764420f, 0.02640680f, 
    -0.40326729f, -0.18208773f, -0.40242809f, 0.23055105f, -0.03306616f, -0.06649073f, 0.30954400f, 0.12524167f, 
    -0.66723520f, -0.18876399f, 0.13002469f, 0.04684754f, 0.24170052f, -0.01533477f, -0.26430258f, -0.32734525f, 
    -0.23036382f, -0.25396040f, 0.18513423f, 0.25258073f, -0.20883584f, 0.04958068f, -0.02100013f, 0.03677760f, 
    0.34784693f, -0.08552841f, -0.36807594f, -0.30890420f, 0.25656065f, 0.26876575f, -0.26249388f, -0.08123731f, 
    0.01589754f, -0.05219499f, -0.09442302f, -0.07131472f, -0.02599734f, -0.04875985f, -0.00297504f, -0.05407147f, 
    0.05987683f, 0.03147426f, 0.03006054f, 0.02258979f, -0.11165002f, 0.01220958f, -0.10146893f, -0.05018953f, 
    -0.03198078f, -0.00315999f, 0.00667176f, 0.05748202f, -0.04045650f, -0.06452772f, -0.09934860f, -0.02581366f, 
    0.04322304f, -0.02949019f, -0.10908382f, 0.02935207f, 0.04871915f, -0.06885339f, 0.04406144f, 0.00241962f, 
    -0.01984603f, -0.07237629f, -0.08634080f, 0.07909299f, -0.03071631f, 0.01094971f, 0.00722575f, -0.06832652f, 
    0.02933585f, 0.05645286f, 0.00567597f, -0.01743171f, -0.02306212f, -0.08340643f, 0.01360342f, -0.03601522f, 
    -0.10571910f, -0.10358234f, -0.07160170f, 0.04093175f, -0.03504706f, -0.01057371f, -0.02794995f, -0.06100292f, 
    -0.00543289f, 0.02271152f, -0.09212169f, -0.06539304f, -0.11924416f, -0.00754919f, -0.04687501f, -0.06417925f, 
    -0.02842025f, -0.07410947f, 0.00883315f, -0.02382452f, -0.07726976f, 0.03681264f, -0.06053926f, -0.05840161f, 
    0.02240290f, 0.03506919f, 0.02966066f, -0.00590214f, -0.03638427f, -0.06426430f, -0.00991155f, 0.01033884f, 
    -0.11252695f, 0.04057783f, -0.00235707f, -0.01662295f, -0.08853669f, 0.06737515f, -0.00535031f, -0.09715022f, 
    0.02323757f, 0.00964117f, 0.00434928f, -0.02447383f, -0.07101977f, -0.03576574f, -0.09846052f, -0.02562869f, 
    0.04770831f, 0.02892988f, -0.02943457f, -0.07152185f, -0.03467333f, -0.01454607f, -0.11420198f, 0.05389214f, 
    -0.09097776f, -0.00535271f, -0.07046671f, 0.00010220f, -0.07631166f, -0.10670717f, -0.04224506f, 0.04840462f, 
    0.07620768f, -0.04925187f, -0.09225085f, -0.01843350f, 0.02981474f, -0.09491739f, 0.05886221f, -0.06157093f, 
    0.03756817f, -0.07877372f, -0.04692849f, 0.03836798f, 0.03821182f, 0.05528821f, -0.09454305f, -0.05910997f, 
    -0.04007180f, 0.06649585f, 0.20352037f, -0.29746816f, 0.07751258f, 0.23420440f, 0.27119708f, -0.07437398f, 
    -0.34515810f, 0.02499949f, 0.26342589f, -0.03199054f, -0.12679797f, -0.14489929f, 0.12646015f, -0.06334362f, 
    0.00771393f, 0.21861492f, -0.04237675f, 0.04247282f, -0.02988594f, -0.51543492f, -0.06808615f, -0.14222112f, 
    0.28842068f, -0.21757799f, -0.01344835f, -0.30040428f, 0.07884755f, 0.07692946f, -0.04074963f, -0.14162664f, 
    0.26979038f, -0.04560287f, 0.28645653f, -0.18090394f, 0.21672189f, 0.10416358f, 0.12230723f, -0.07181994f, 
    -0.00388531f, -0.45236692f, -0.17045803f, -0.37065434f, -0.13368782f, -0.03003928f, -0.38150749f, 0.10556988f, 
    0.04666477f, -0.01324333f, -0.15001206f, 0.17154983f, 0.09967151f, 0.16096367f, -0.18563277f, 0.07421074f, 
    0.23288494f, -0.11075113f, -0.02574361f, -0.14321387f, 0.14870964f, -0.03416282f, -0.02661886f, -0.05726264f, 
    -0.33251429f, -0.06853979f, 0.00006247f, -0.23353177f, 0.07911499f, 0.04873871f, 0.07479043f, 0.07997946f, 
    -0.23520900f, -0.04904951f, -0.07631022f, 0.11959796f, -0.06434887f, -0.14147502f, 0.12775779f, 0.12452653f, 
    0.04681883f, 0.02181526f, 0.14457853f, -0.04961649f, 0.19045563f, 0.12169995f, -0.49282607f, 0.12499334f, 
    -0.06249145f, 0.34369642f, 0.08074779f, -0.01480911f, 0.10905901f, -0.08798219f, -0.06393187f, -0.20492812f, 
    0.08476952f, 0.20791171f, -0.07074708f, 0.15853460f, 0.16591649f, -0.00430561f, 0.35458943f, 0.00380510f, 
    -0.46340036f, -0.18908794f, -0.15953363f, 0.05317387f, 0.19232406f, 0.11837915f, -0.02926237f, -0.28375882f, 
    -0.44371581f, 0.18834002f, 0.03240894f, 0.12120550f, -0.43436822f, 0.23183802f, 0.18747103f, -0.00672110f, 
    0.09525283f, 0.06916070f, 0.08568588f, -0.19944973f, 0.11793847f, -0.12929015f, 0.14384833f, 0.02578375f, 
    -0.10051632f, -0.00688221f, 0.02322960f, -0.01198271f, -0.06565419f, 0.02811446f, -0.02690684f, -0.06698025f, 
    -0.09562053f, 0.06465862f, -0.10385554f, -0.02672003f, -0.10589316f, 0.00649153f, -0.10761348f, 0.07789603f, 
    -0.10028385f, 0.00471021f, 0.04688752f, 0.00844743f, -0.05324386f, 0.07002773f, -0.12681316f, 0.03662642f, 
    0.03516385f, -0.01090438f, -0.13928652f, -0.04483584f, -0.01943337f, 0.00618603f, -0.10441636f, 0.02690732f, 
    0.00186477f, 0.02399152f, -0.08283908f, -0.01471771f, -0.05044765f, 0.02406923f, 0.00553821f, -0.08263160f, 
    0.03365847f, -0.04543286f, -0.02024781f, -0.00126218f, -0.03423663f, -0.04342097f, -0.06231968f, -0.07561311f, 
    -0.08245526f, -0.00982859f, 0.00192514f, 0.00592247f, -0.02323293f, 0.06352267f, 0.01942815f, -0.04995422f, 
    0.00210080f, -0.10032536f, -0.06825054f, -0.01161631f, -0.01459104f, -0.05233867f, -0.08098249f, -0.02536927f, 
    -0.02395008f, -0.06820300f, 0.04655969f, -0.00923826f, -0.03296595f, 0.00820918f, -0.07752644f, -0.05831236f, 
    -0.08225372f, -0.00671884f, 0.03588938f, -0.11516295f, 0.00555769f, 0.04110373f, 0.02205580f, 0.03335218f, 
    0.02899212f, -0.09844527f, -0.05853607f, 0.03075092f, 0.04909653f, -0.00789505f, -0.06916222f, -0.01496301f, 
    -0.10292988f, -0.00283333f, -0.00806668f, -0.07590023f, -0.10304438f, 0.01304766f, 0.02786995f, 0.01288140f, 
    0.00837472f, -0.13399228f, 0.01539454f, -0.09248927f, -0.06638871f, -0.11387755f, -0.05172810f, 0.01028632f, 
    0.06613252f, 0.02699738f, 0.01509237f, -0.10932872f, -0.07871898f, -0.02020979f, -0.02186176f, 0.04482421f, 
    -0.03070480f, -0.00253483f, -0.11467688f, -0.03830106f, -0.03354248f, -0.06869771f, -0.00005161f, -0.02524117f, 
    -0.08107947f, -0.03544432f, 0.00486425f, -0.02347512f, -0.07632750f, -0.06302478f, -0.03080914f, -0.04614849f, 
    -0.04105751f, 0.00619498f, 0.06291814f, 0.03948224f, -0.06082578f, -0.00752045f, 0.00923455f, -0.10050961f, 
    -0.04996876f, -0.06680136f, -0.05439761f, -0.01805465f, -0.11290918f, -0.11608802f, 0.01035306f, -0.01388311f, 
    -0.08180463f, -0.04461757f, 0.05919427f, 0.02893745f, -0.09499525f, -0.01637698f, -0.13459376f, 0.04215240f, 
    -0.07514668f, -0.00464481f, -0.02905155f, -0.11045729f, -0.00914192f, 0.06357600f, -0.09632438f, -0.05284210f, 
    -0.07542808f, -0.10344226f, 0.08489819f, 0.02498996f, -0.09218208f, 0.05737680f, -0.06995235f, 0.02598170f, 
    -0.04497881f, -0.12067103f, -0.11137871f, -0.03143175f, -0.00341364f, -0.08506571f, 0.04220828f, 0.01064292f, 
    -0.06045245f, 0.00742215f, -0.00293178f, -0.07355136f, -0.10834931f, -0.05287170f, -0.02053697f, -0.01376930f, 
    -0.06533024f, 0.04528815f, 0.04160097f, -0.06375274f, -0.04682155f, -0.03827626f, -0.10011917f, -0.01826247f, 
    0.03895923f, -0.06265599f, -0.07281379f, -0.02202968f, -0.00476946f, -0.06056631f, 0.00036554f, -0.03033756f, 
    -0.00995917f, -0.11057892f, -0.06550667f, 0.01449201f, 0.07221187f, -0.02357018f, -0.05631975f, 0.04955079f, 
    -0.08506806f, -0.04389903f, -0.04569298f, 0.00474640f, -0.10154815f, -0.06697921f, -0.00680868f, -0.07994352f, 
    0.02500557f, -0.07412924f, -0.01968858f, 0.01181586f, -0.03725152f, -0.08698810f, -0.08803768f, -0.04445327f, 
    -0.04776562f, -0.01539993f, -0.08775520f, -0.06212141f, -0.03831183f, -0.04059941f, -0.11641670f, -0.02742255f, 
    -0.04353792f, 0.00745908f, 0.03489251f, 0.01719651f, 0.00224788f, -0.08208504f, -0.11359791f, 0.00911769f, 
    -0.03314131f, 0.06268165f, 0.02100134f, 0.03704450f, 0.05261054f, 0.02969798f, -0.01349703f, 0.03305577f, 
    -0.03160030f, -0.10305490f, -0.02822547f, -0.10122254f, 0.02596184f, 0.02358242f, 0.03315301f, -0.07145599f, 
    -0.01912361f, -0.01056182f, -0.05883886f, -0.04806905f, -0.04583850f, 0.03891547f, -0.07208246f, -0.05766491f, 
    -0.09080272f, 0.01957204f, -0.03098955f, -0.07893804f, -0.07172343f, 0.01515609f, -0.02980617f, 0.01861005f, 
    -0.05593759f, -0.01763420f, -0.04764086f, 0.01261412f, -0.01506017f, -0.08573011f, 0.04186162f, 0.00738121f, 
    0.08260080f, -0.04458605f, -0.05939577f, -0.04239100f, -0.09225833f, 0.07568814f, -0.09592704f, 0.04781686f, 
    -0.00853221f, 0.05934129f, 0.04214199f, -0.05306025f, -0.00558609f, -0.01328164f, 0.04360582f, -0.02063959f, 
    -0.05754995f, -0.04229325f, 0.02811279f, -0.00822109f, -0.10675704f, 0.01815956f, 0.03006054f, 0.06359464f, 
    0.03079903f, -0.00664354f, -0.09415764f, -0.05290421f, 0.02599024f, 0.07188200f, 0.00893589f, -0.05075882f, 
    -0.05920855f, 0.03383536f, -0.04617856f, -0.02319822f, 0.01340104f, -0.00943228f, 0.06663211f, -0.04441002f, 
    -0.08791146f, -0.02827483f, 0.04443955f, 0.01957382f, 0.01625784f, -0.01951113f, 0.03628156f, -0.07371683f, 
    0.00454169f, -0.03418283f, -0.06946670f, -0.07215949f, -0.06161769f, 0.04587732f, 0.04552346f, 0.01584194f, 
    0.00310557f, -0.05276056f, -0.03071913f, -0.00385560f, -0.02314251f, -0.08069033f, -0.07565787f, -0.08446726f, 
    0.06445979f, 0.06602167f, -0.08184420f, 0.02399354f, -0.08817991f, 0.06984700f, -0.05373242f, 0.04835993f, 
    0.00983454f, -0.00918147f, 0.01845203f, -0.00237062f, -0.03793930f, 0.07282545f, -0.05745662f, -0.08332871f, 
    -0.02367257f, -0.02815611f, -0.08673922f, -0.02924277f, -0.03243882f, -0.03011075f, 0.01405946f, -0.05022538f, 
    0.04857734f, 0.06604546f, 0.05212526f, -0.06419639f, -0.05783423f, 0.06976651f, 0.07393521f, 0.03292955f, 
    -0.00405933f, -0.04606459f, -0.00775236f, 0.06492447f, 0.07176041f, 0.04266630f, -0.01653688f, -0.07148791f, 
    -0.06032199f, 0.10426775f, -0.13559276f, 0.20083401f, 0.24750631f, -0.38624519f, 0.04361890f, 0.25900668f, 
    -0.09734224f, 0.03807433f, -0.24516448f, 0.12308229f, -0.03232321f, 0.28486490f, -0.00009154f, -0.01151045f, 
    -0.05741189f, 0.03558042f, 0.15345852f, 0.01249018f, -0.36459285f, -0.04260841f, 0.16938920f, 0.21130769f, 
    -0.09155603f, 0.03307851f, -0.40889347f, 0.13425519f, -0.03781595f, 0.09253520f, -0.13237211f, -0.23699313f, 
    -0.20611298f, -0.06811383f, 0.27662954f, -0.10764150f, -0.03079156f, 0.12940638f, 0.12678505f, -0.52795666f, 
    0.36057621f, 0.10138150f, 0.01960488f, 0.11209546f, 0.28936461f, -0.44150278f, 0.02836759f, -0.42657781f, 
    0.15522826f, -0.08322715f, 0.41499349f, -0.10753505f, -0.10710644f, -0.32175717f, -0.04063954f, 0.09778263f, 
    -0.17964491f, 0.48817825f, 0.23664813f, 0.00498031f, -0.30022126f, -0.16030794f, 0.07217384f, -0.56652808f, 
    -0.29018870f, 0.19432989f, 0.09752508f, 0.03383220f, -0.25921565f, -0.07630927f, 0.40161139f, -0.15450364f, 
    0.22902542f, 0.08238588f, -0.00998977f, -0.33588725f, -0.07954915f, 0.30269647f, 0.22148609f, 0.00430679f, 
    -0.19034089f, 0.22206382f, -0.21671015f, -0.23381759f, -0.19526997f, -0.16525234f, -0.16935803f, -0.14811805f, 
    0.09594840f, 0.24647470f, 0.01235213f, 0.27093649f, -0.14014107f, 0.01870786f, -0.33236027f, 0.51344305f, 
    0.02105423f, 0.08678409f, 0.26929131f, -0.35625726f, -0.41325554f, 0.19235064f, 0.08572641f, 0.26400134f, 
    0.04533095f, -0.32833883f, -0.07708661f, -0.13338856f, -0.39757535f, 0.00637559f, 0.23806915f, -0.04635859f, 
    0.00490801f, 0.16905348f, -0.19180153f, -0.05754840f, 0.22262900f, -0.16733322f, 0.00027126f, -0.08178520f, 
    0.08776828f, -0.20233555f, -0.12703048f, 0.02612058f, -0.21579233f, -0.05221303f, 0.38226512f, -0.27854973f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.04937117f, -0.04472015f, 0.23091407f, 0.02366899f, 0.00044287f, 0.15122692f, -0.01306769f, 0.06357560f, 
    0.13615167f, 0.01380887f, 0.02506478f, 0.04097346f, 0.18944365f, -0.11824346f, -0.06616555f, -0.09606812f, 
    0.03624478f, 0.11251819f, -0.04210955f, 0.33859384f, -0.03633619f, 0.03227436f, -0.00284950f, 0.01067363f, 
    0.03636428f, 0.02535326f, 0.13207698f, -0.21293305f, -0.13062431f, 0.12307336f, -0.04134362f, 0.06433684f, 
    -0.12394371f, -0.08339810f, 0.29823869f, 0.00496467f, -0.09928286f, 0.00819993f, -0.00295717f, 0.17357238f, 
    -0.15672351f, -0.03662672f, 0.14366175f, 0.32450509f, -0.00803957f, -0.08891050f, -0.07426579f, -0.02416027f, 
    0.12309118f, 0.08451391f, -0.01184765f, 0.03061123f, -0.41763541f, 0.28267920f, -0.01765445f, 0.20087034f, 
    -0.08631241f, 0.20758936f, -0.00869269f, -0.03909526f, -0.04374977f, -0.03767784f, 0.17817239f, 0.15288772f, 
    0.19699758f, 0.08344261f, -0.01379596f, -0.00123524f, 0.06874979f, -0.03691537f, 0.13848257f, -0.23426662f, 
    0.19787323f, 0.31075290f, -0.00255519f, 0.15611020f, 0.06884618f, -0.04340042f, -0.25474107f, -0.04454719f, 
    0.12051462f, -0.01257514f, -0.06509887f, 0.17048441f, 0.01458555f, 0.06322861f, -0.12755871f, 0.11772299f, 
    -0.09597991f, 0.00073878f, 0.18667269f, 0.14331895f, 0.22408287f, -0.11245275f, -0.14315081f, -0.14008079f, 
    0.00248568f, 0.11415756f, 0.34005156f, -0.25081545f, 0.01351958f, 0.20837685f, 0.05877709f, -0.09076057f, 
    0.03316075f, 0.03365223f, 0.16664109f, 0.02163205f, -0.04442094f, -0.04801047f, 0.10598048f, 0.02860830f, 
    -0.09134657f, -0.09322748f, -0.03997098f, 0.05736255f, 0.00381309f, 0.13930601f, 0.03655944f, 0.09836920f, 
    0.10314199f, 0.17696254f, -0.04782700f, 0.23577915f, 0.04462973f, -0.07047538f, -0.08945598f, -0.25322959f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.07376169f, 0.03662236f, -0.21482642f, 0.00233313f, -0.00576782f, -0.09558436f, 0.01215945f, 0.03542955f, 
    -0.28893727f, 0.00443184f, 0.28441098f, -0.00005450f, -0.08989298f, -0.05242794f, 0.13577288f, -0.02348901f, 
    0.00089032f, -0.08177870f, -0.43414110f, -0.29709354f, -0.04151721f, -0.44355085f, 0.17665084f, 0.00141472f, 
    0.00538348f, 0.15316468f, -0.47185451f, -0.47658566f, 0.04205861f, -0.32592934f, -0.01870496f, -0.21922188f, 
    0.16644612f, -0.02650711f, 0.04465427f, -0.03833580f, -0.03436705f, -0.56643629f, -0.00542781f, -0.11481542f, 
    -0.26851937f, -0.05659874f, -0.14220490f, 0.06505266f, -0.47411817f, -0.01581361f, 0.01051552f, 0.00532356f, 
    0.06836660f, -0.25014970f, -0.17427747f, -0.03885360f, 0.43954462f, -0.51381272f, -0.03508804f, 0.06165828f, 
    -0.06472381f, -0.07522120f, 0.06351782f, -0.00291101f, -0.07910959f, 0.27853841f, -0.02608467f, 0.22321528f, 
    -0.12425476f, 0.09642254f, -0.22072001f, 0.02218938f, -0.01236344f, -0.08300178f, 0.11273645f, -1.07325292f, 
    0.14187123f, 0.04537284f, 0.20029794f, 0.28200457f, -0.07311647f, 0.08439622f, 0.17634784f, 0.03929247f, 
    0.27169737f, -0.05337477f, -0.01771829f, -0.21315612f, -0.78541082f, 0.09546179f, 0.03662754f, 0.28453603f, 
    0.05541455f, 0.04557089f, -0.20586053f, -0.41581759f, 0.10813229f, -0.06213102f, 0.37302715f, -0.06595557f, 
    -0.06919011f, 0.02221834f, -0.24751371f, 0.41256252f, 0.01130956f, 0.20223397f, -0.11357632f, -0.02978087f, 
    -0.07603061f, -0.11317918f, 0.23466153f, -0.06764719f, 0.06005722f, 0.00665057f, 0.28513938f, 0.04045253f, 
    0.03211121f, -0.00552262f, 0.20673598f, 0.11712018f, 0.01930610f, 0.13126269f, 0.18959911f, -0.24568270f, 
    -0.21163368f, -0.41050777f, -0.00130191f, 0.04258594f, 0.01785555f, -0.04187115f, 0.03523871f, -0.27950266f, 
    0.01875602f, 0.01024265f, 0.06724229f, -0.10007107f, -0.02007028f, 0.15341425f, -0.08409076f, -0.01416523f, 
    -0.62995994f, 0.18882117f, 0.24652566f, 0.00416110f, 0.01101174f, 0.07236991f, 0.09777283f, 0.00152028f, 
    0.19266325f, -0.06125793f, -0.15680642f, 0.15890896f, 0.13449517f, -0.12833430f, -0.14865346f, 0.04043612f, 
    -0.11762746f, -0.15047733f, -0.03439004f, -0.21752381f, 0.07829723f, -0.02050644f, 0.04249388f, -0.01055314f, 
    -0.40277699f, -0.12976141f, -0.01434293f, -0.04564353f, -0.09316141f, -0.26715654f, -0.03359644f, -0.14814268f, 
    0.37372756f, -0.05692423f, 0.05916730f, -0.20422958f, 0.21198741f, -0.05256118f, 0.00815600f, 0.14115068f, 
    0.10082772f, 0.43725827f, -0.59005237f, -0.13893469f, 0.01191049f, -0.06272946f, 0.05905811f, 0.01498997f, 
    -0.04113931f, -0.33668137f, -0.00715666f, 0.05703967f, 0.07243460f, -0.44739509f, -0.00839945f, 0.09493538f, 
    -0.09579507f, 0.25794795f, -0.27859944f, -0.00174937f, -0.04865129f, 0.04488408f, 0.06907592f, 0.58669728f, 
    -0.22080106f, -0.01470117f, 0.10317011f, -0.11572355f, 0.01183435f, -0.04820881f, -0.05240847f, 0.07737410f, 
    0.13133077f, 0.03942624f, -0.06076742f, 0.19579777f, 0.09935669f, 0.19339639f, 0.06012263f, -0.46184373f, 
    -0.06623562f, 0.08418426f, -0.07397739f, -0.09759560f, 0.07097606f, 0.02804893f, -0.07107383f, -0.14814351f, 
    0.00904613f, -0.00807534f, -0.65144622f, -0.11447550f, 0.03191441f, 0.02399953f, -0.06479208f, 0.02399927f, 
    0.12696303f, -0.03564058f, -0.15320167f, 0.00773945f, -0.08235565f, 0.08221545f, 0.25667790f, -0.04980002f, 
    0.05135262f, -0.09078263f, -0.00316839f, 0.14662136f, 0.05176793f, 0.14284486f, -0.32807019f, 0.07899410f, 
    -0.33342895f, 0.12068366f, 0.02173184f, -0.23091435f, -0.05046816f, -0.06028041f, -0.06456140f, 0.51203507f, 
    0.02226020f, 0.03241827f, 0.03828101f, 0.01089984f, 0.04783340f, -0.11213575f, -0.06041605f, 0.05613020f, 
    -0.09779977f, -0.41427007f, 0.02903280f, 0.18015735f, 0.01060006f, 0.11661956f, -0.80496830f, -0.05997359f, 
    -0.11701036f, -0.08701751f, 0.32725781f, -0.13601108f, -0.25139880f, 0.09052101f, -0.25110149f, 0.00563907f, 
    -0.17359777f, -0.22950375f, -0.15857020f, -0.81568301f, 0.15324494f, 0.03799884f, -0.07756764f, -0.33693305f, 
    -0.19152965f, -0.63568127f, -0.00956125f, -0.10700434f, 0.05219646f, 0.08567424f, 0.02247306f, 0.40690809f, 
    0.34354109f, 0.00611316f, 0.04161458f, 0.19888324f, -0.68033862f, 0.05855534f, 0.04896519f, -0.07057623f, 
    -0.17478146f, -0.36796111f, -0.36787182f, 0.08782074f, 0.20414180f, 0.23299900f, -0.08446498f, 0.17645317f, 
    0.02745868f, 0.12037117f, 0.00072348f, -0.04342389f, -0.02613780f, -0.08110476f, 0.07426643f, 0.12861402f, 
    0.18022591f, 0.09027363f, -0.79129201f, -0.08688372f, -0.05941997f, -0.04512690f, -0.49668992f, -0.38489467f, 
    0.18464278f, 0.19596870f, -0.43412223f, -0.36266518f, 0.04288575f, -0.74046630f, 0.15705167f, -0.01737461f, 
    -0.22027431f, 0.01430890f, -0.04976816f, 0.28948036f, -0.00966284f, -0.24941142f, -0.09895600f, -0.02924583f, 
    -0.03173371f, 0.06421096f, -0.43732411f, -0.01411938f, 0.18379918f, -0.03248142f, 0.29704213f, -0.30587998f, 
    0.06874439f, 0.12847669f, 0.13868676f, 0.01089382f, -0.02132408f, 0.06299307f, -0.08405662f, -0.01735474f, 
    0.18206288f, 0.07999548f, 0.23420568f, -0.12344617f, 0.07076371f, 0.03082984f, 0.02477542f, 0.00839566f, 
    0.02357342f, -0.07963994f, -0.51713371f, 0.22490752f, -0.03363649f, -0.08716892f, -0.12282697f, 0.12668027f, 
    -0.07216430f, 0.16791156f, 0.01864305f, 0.32859659f, 0.00117814f, -0.01475149f, 0.05030375f, -0.34800884f, 
    -0.03325146f, 0.05012696f, -0.68325865f, -0.03395506f, 0.00916803f, -0.45431903f, -0.04043628f, -0.03131241f, 
    -0.21425566f, 0.11119057f, -0.23207049f, -0.02337460f, -0.19127260f, 0.08131146f, 0.17464857f, 0.04064118f, 
    -0.09992644f, 0.21063472f, 0.34423271f, -0.14731978f, 0.04497252f, -0.56821960f, 0.08636007f, 0.02056599f, 
    0.18742560f, 0.00103646f, -0.17195852f, 0.08213765f, 0.20466241f, -0.61434370f, 0.03132525f, -0.12253208f, 
    0.08855975f, 0.12390999f, -0.17330174f, -0.04793451f, 0.07590220f, 0.17471170f, -0.06417949f, 0.11661013f, 
    -0.09862444f, 0.05603838f, -0.22343451f, -0.43434680f, 0.08082341f, 0.06342049f, -0.04684066f, -0.72955924f, 
    -0.40347347f, 0.08113055f, -0.32915482f, -0.09361885f, 0.09712581f, -0.41139421f, -0.09472141f, -0.28836888f, 
    0.04178692f, 0.11189336f, -0.11158608f, -0.00671823f, 0.04544958f, -0.51480222f, 0.16998066f, -0.43225768f, 
    -0.13777761f, -0.33678821f, 0.17063482f, 0.00441275f, -0.08394778f, -0.05583718f, 0.07407805f, -0.37760198f, 
    -0.47335991f, 0.03642419f, 0.13102570f, 0.06948397f, 0.06252293f, 0.09736417f, -0.22199194f, 0.06672995f, 
    -0.10472284f, -0.05207200f, 0.01425956f, 0.18678498f, -0.01908665f, 0.15979297f, 0.00917383f, -0.71678394f, 
    -0.11234047f, -0.03219571f, 0.20328894f, -0.00226228f, -0.13725799f, -0.08259127f, -0.01863834f, -0.05526915f, 
    0.00306693f, 0.07916047f, -0.04319657f, -0.20132902f, 0.07622480f, -0.06470147f, -0.03618002f, -0.06760534f, 
    0.14627077f, 0.22745031f, 0.08066776f, 0.17217727f, 0.06908085f, 0.07210761f, -0.08732083f, -0.08727185f, 
    0.04580829f, -0.05705906f, 0.19626191f, -0.22753778f, 0.05727603f, -0.24016194f, 0.00790633f, 0.05549872f, 
    0.13971147f, -0.53209817f, -0.00996271f, -0.12135635f, -0.08805910f, 0.07708336f, 0.05564611f, 0.33402368f, 
    0.05720363f, -0.00289144f, 0.15189366f, 0.03277753f, -0.02347748f, 0.13658194f, -0.00662921f, -0.05386705f, 
    0.16148922f, 0.16521762f, 0.36904839f, 0.06985682f, 0.04945022f, 0.00256486f, -0.04405300f, -0.07500597f, 
    -0.16109824f, 0.37327176f, -0.35247546f, -0.00326001f, -0.25073779f, 0.00114455f, 0.05379069f, -0.01648307f, 
    0.26297873f, 0.10527638f, 0.01595864f, 0.02299622f, -0.23242411f, 0.04411719f, -0.08934131f, 0.06337824f, 
    0.09687750f, 0.09617893f, 0.10286942f, 0.03113824f, 0.04739920f, 0.32594612f, 0.05216090f, 0.43486133f, 
    0.54915595f, -0.00232932f, 0.06630648f, 0.12262118f, -0.33368349f, -0.05640008f, 0.02757878f, 0.20015976f, 
    0.09090821f, -0.24858107f, -0.05968651f, 0.10374555f, 0.16034971f, -0.18047544f, -0.04704473f, -0.14751585f, 
    0.01407879f, 0.15419714f, 0.00536633f, -0.04422863f, -0.07366958f, -0.14273939f, 0.13991414f, -0.15351346f, 
    -0.02538536f, -0.25653404f, -0.12858610f, -0.02852705f, -0.01531640f, 0.00181866f, 0.16899993f, -0.69585156f, 
    0.07078700f, -0.04133487f, 0.05130875f, 0.21696256f, 0.06666538f, -0.13529889f, -0.04113706f, -0.02565021f, 
    0.05561863f, -0.00245096f, -0.04611978f, -0.48521096f, 0.07491989f, 0.03871126f, -0.00445269f, -0.65834486f, 
    0.06721582f, -0.06337196f, -0.49401104f, -0.04903546f, -0.23338960f, -0.01758210f, -0.38895485f, 0.26517454f, 
    0.02596267f, -0.02503202f, 0.18084364f, -0.51202846f, -0.04660270f, -0.09518375f, -0.01502392f, 0.02310324f, 
    0.23490602f, -0.22700889f, 0.07379001f, -0.64469981f, -0.03410453f, -0.00746955f, -0.56925184f, -0.03546722f, 
    0.03307995f, 0.01620505f, -0.47447467f, -0.35996485f, 0.07927887f, 0.00613842f, 0.18730314f, 0.13658030f, 
    0.14032051f, -0.38274458f, -0.03396324f, -0.08766518f, 0.03991219f, -0.07816154f, -0.04281856f, 0.00070406f, 
    -0.04607992f, -0.05866202f, -0.01295521f, -0.03406757f, -0.04655189f, 0.16710141f, 0.04965720f, 0.04602931f, 
    -0.03881009f, -0.21816958f, 0.01804336f, -0.17192195f, -0.46543440f, -0.02569554f, -0.06079485f, 0.04424203f, 
    0.11262732f, -0.64375752f, 0.37807414f, 0.09279244f, -0.45028913f, 0.02372042f, 0.09250645f, 0.00067125f, 
    -0.05342535f, 0.15432243f, 0.06589776f, 0.12669583f, -0.22566761f, 0.10755292f, 0.05769508f, 0.08688023f, 
    0.26839283f, 0.08355714f, 0.13317417f, -0.02038118f, -0.06768043f, 0.01236004f, -0.08041387f, -0.28119099f, 
    -0.28242168f, -0.00253258f, 0.03164151f, 0.05851086f, 0.21124734f, 0.04830978f, 0.07046899f, -0.14522158f, 
    0.18076199f, 0.11008149f, 0.30076677f, -0.14754990f, -0.88429338f, -0.00718099f, 0.02759699f, -0.07249643f, 
    -0.11335064f, -0.25605860f, -0.07700714f, 0.03219024f, -0.03325640f, -0.14773743f, -0.47819200f, 0.11268326f, 
    0.07298618f, 0.10868901f, 0.25772154f, -0.01467737f, 0.03271007f, -0.04853236f, 0.09640920f, -0.02407489f, 
    0.03564723f, 0.17570080f, 0.01996472f, -0.34010777f, 0.05233862f, 0.15272817f, 0.02587908f, 0.02479770f, 
    0.02994374f, 0.03612172f, 0.06732455f, -0.33113632f, -0.04761240f, 0.07210372f, -0.02373297f, 0.21375051f, 
    0.05658640f, -0.06584776f, 0.09261517f, 0.32055050f, 0.08940858f, 0.07329381f, -0.26035982f, 0.37885487f, 
    0.05112052f, -0.06979706f, 0.31889987f, -0.41135556f, 0.05660797f, 0.01731686f, 0.03801711f, -0.01886310f, 
    -0.23454067f, 0.07529265f, -0.48681250f, -0.01953711f, -0.03153913f, -0.04804552f, 0.11381725f, 0.05059477f, 
    0.02509337f, -0.05941134f, 0.24675535f, -0.23292866f, -0.04839583f, 0.15517449f, -0.22184642f, -0.45315722f, 
    0.06912491f, -0.05942822f, 0.08123133f, -0.32593724f, -0.08218757f, 0.02353682f, -0.00622651f, -0.35490435f, 
    -0.00815011f, -0.08882894f, -0.04276011f, -0.10081644f, 0.02013704f, -0.16822019f, -0.00306989f, -0.02118400f, 
    0.28879946f, -0.72899699f, -0.62932742f, 0.06014731f, 0.10036797f, 0.01511132f, -0.40954858f, -0.05834352f, 
    -0.31650922f, 0.06732883f, -0.43016669f, 0.05777677f, 0.06855416f, -0.01524402f, 0.05072165f, -0.00010531f, 
    -0.55485606f, 0.10400466f, 0.16141434f, -0.06859633f, 0.09039679f, -0.18193728f, -0.05400903f, 0.01165893f, 
    -0.32701722f, -0.28727874f, 0.19102700f, 0.03379389f, -0.02584457f, -0.59325361f, 0.02877603f, -0.64085937f, 
    -0.45557907f, 0.06786094f, 0.13521428f, 0.08145070f, -0.54568821f, -0.00205496f, -0.06697854f, -0.26029250f, 
    0.05372680f, -0.67921466f, -0.08740169f, -0.05617643f, -0.35127020f, 0.12082642f, 0.01783036f, 0.15188207f, 
    -0.05072414f, -0.06518357f, -0.01547966f, 0.00836076f, 0.04528809f, -0.43739229f, 0.31675613f, -0.14930463f, 
    0.12059461f, 0.27769196f, -0.29882196f, -0.02231172f, -0.05798092f, 0.01457311f, -0.36797708f, -0.66343349f, 
    -0.12387014f, -0.34042722f, 0.06221930f, -0.49119833f, -0.05550959f, 0.06765966f, 0.05282487f, -0.00798453f, 
    -0.40518448f, -0.06556281f, -0.00096215f, -0.01243299f, 0.19206516f, 0.17952140f, -0.05285823f, -0.72713161f, 
    -0.02481245f, 0.02993988f, 0.07225101f, -1.06866431f, 0.21404396f, -0.04996661f, -0.12588422f, -0.61352879f, 
    0.01714217f, 0.22365418f, 0.09505976f, 0.14078678f, -0.07290357f, 0.18163028f, -0.04646331f, -0.07008281f, 
    -0.24536966f, -0.03749534f, 0.03607400f, 0.05309872f, -0.08216346f, -0.02765122f, 0.08128849f, -0.04528812f, 
    -0.11953261f, -0.06701455f, 0.12445599f, 0.07416559f, -0.08684573f, 0.22381912f, 0.12645657f, 0.26965427f, 
    0.25028318f, 0.17114115f, -0.05426738f, 0.24798645f, -0.01070841f, 0.02748800f, -0.06636247f, -0.52596730f, 
    -0.02076625f, -0.04072360f, -0.01842867f, -0.01216483f, 0.09003749f, -0.24524027f, 0.01741849f, 0.03582449f, 
    0.18261360f, -0.00701962f, 0.02652920f, 0.11930340f, -0.23122650f, -0.08106054f, 0.01086019f, -0.09413096f, 
    0.20180300f, -0.18941800f, 0.02088535f, -0.21062049f, -0.13927749f, 0.17492002f, 0.01658167f, 0.03329164f, 
    -0.05725842f, 0.09305476f, -0.01330781f, 0.14114821f, 0.06532498f, 0.00034717f, 0.02227531f, 0.17307596f, 
    0.15266740f, 0.04535817f, 0.07541122f, 0.07016564f, 0.05316362f, 0.19518374f, -0.02083298f, -0.02232297f, 
    0.24571668f, -0.07822321f, -0.11917924f, -0.31790492f, -0.00042567f, 0.06850416f, -0.08257394f, 0.22923362f, 
    0.07795774f, 0.13947619f, 0.48636976f, -0.08663217f, 0.13520165f, 0.01950132f, -0.06380270f, -0.17293574f, 
    -0.00600839f, -0.20097965f, -0.02270407f, 0.02459811f, 0.04182418f, 0.28302649f, -0.39080268f, 0.04183490f, 
    -0.36931574f, 0.03807366f, 0.05971364f, -0.03828223f, 0.03634219f, -0.06599105f, -0.07693205f, 0.32460815f, 
    0.02297008f, -0.58983916f, -0.03687150f, 0.00195858f, -0.01737237f, 0.01817161f, 0.20890273f, -0.02968445f, 
    0.12978770f, -0.01282153f, -0.00181195f, -0.24747647f, -0.25586963f, -0.28462806f, -0.05057711f, -0.06089078f, 
    -0.05393764f, -0.02313112f, 0.00497765f, -0.27242646f, -0.25904945f, 0.07484197f, -0.12255203f, 0.14192674f, 
    -0.05419483f, -0.26394534f, -0.59081084f, 0.31442064f, -0.07549936f, -0.34371260f, -0.07682347f, -0.10839849f, 
    0.22043310f, -0.31922221f, -0.16069923f, 0.05790903f, -0.04318827f, -0.04282811f, 0.23004474f, 0.06829613f, 
    0.03724917f, -0.03360093f, 0.00191806f, -0.23978345f, -0.02799914f, -0.19073828f, 0.11000670f, -0.61044788f, 
    -0.20367339f, 0.41595042f, 0.06504004f, -0.60440665f, -0.04012834f, -0.06149105f, -0.03799200f, 0.08946118f, 
    0.03580255f, 0.02212328f, 0.14111587f, 0.00600605f, -0.07801028f, 0.22040290f, -0.10289823f, 0.01460454f, 
    -0.23938638f, -0.04567836f, 0.17004530f, -0.42533541f, 0.06726324f, -0.04272756f, -0.06209599f, 0.00048292f, 
    0.23732737f, -0.22880384f, -0.26169458f, -0.01600190f, 0.25726140f, 0.14196414f, -0.57647943f, 0.03844423f, 
    0.04372282f, -0.56626201f, 0.12066397f, -0.01046484f, -0.35232300f, -0.05274526f, 0.01247467f, -0.03042467f, 
    -0.06548357f, 0.06449555f, -0.77664208f, -0.01921092f, -0.04763718f, -0.42567989f, -0.02773847f, 0.24259494f, 
    -0.56431949f, -0.06603874f, -0.17749254f, 0.12393060f, -0.03193508f, -0.01082465f, -0.03068027f, 0.23336394f, 
    0.06854571f, -0.08183900f, -0.18148574f, -0.11173923f, 0.10591605f, -0.13623820f, 0.06686803f, 0.04808700f, 
    -0.05728655f, -0.20542319f, 0.10532703f, -0.06315801f, -0.00703112f, 0.43338490f, -0.28250486f, 0.15465797f, 
    -0.13491827f, -0.40038812f, 0.18067412f, 0.01382596f, -0.00549534f, 0.04136251f, -0.10248536f, -0.00088063f, 
    0.18710290f, 0.04821194f, -0.34045219f, -0.12115791f, 0.05050850f, -0.21946439f, 0.02416767f, -0.03520554f, 
    -0.02214807f, -0.02200246f, -0.06262752f, -0.11779455f, 0.21351218f, -0.23506844f, 0.08957170f, 0.09346930f, 
    0.04048919f, -0.08108565f, 0.10206822f, 0.27246138f, -0.10634002f, 0.00127947f, 0.11160222f, -0.16491246f, 
    0.03322510f, -0.83799732f, -0.12091808f, 0.31169176f, -0.03493330f, -0.70463985f, -0.05412683f, 0.02864340f, 
    0.11968049f, -0.04621868f, -0.22794436f, 0.25726524f, 0.03533069f, 0.07192264f, -0.03022911f, -0.03011614f, 
    -0.03607499f, 0.04257277f, -0.43901199f, 0.03011633f, -0.04380312f, -0.52555788f, -0.07534337f, 0.18091029f, 
    -0.51712656f, 0.04638011f, -0.01357013f, 0.01584484f, -0.03784758f, -0.02777665f, -0.01755094f, -0.46071088f, 
    0.03289989f, -0.05594368f, 0.02883141f, 0.00260947f, -0.05735725f, 0.03688336f, 0.03642129f, -0.01156755f, 
    0.16001256f, -0.11812492f, -0.34774870f, -0.32784998f, -0.12667616f, 0.02500827f, -0.02410680f, 0.01632715f, 
    -0.48129123f, 0.05319329f, -0.36751479f, 0.06800570f, -0.08323640f, 0.16900098f, 0.03480355f, -0.04633509f, 
    -0.36625233f, 0.07377899f, -0.01324621f, 0.37455219f, -0.37127015f, 0.16629010f, -0.05813076f, -0.14021666f, 
    -0.11575273f, -0.01618348f, 0.07306194f, 0.00027221f, 0.04612502f, -0.27375615f, -0.04519812f, -0.16620325f, 
    -0.30320257f, -0.08194595f, 0.01309206f, 0.09125970f, -0.11085186f, 0.05947379f, 0.03411963f, 0.01709436f, 
    0.16784593f, -0.63294083f, -0.22432892f, 0.02291777f, -0.22855248f, 0.01377061f, -0.05909449f, 0.17178017f, 
    0.00088326f, -0.07569313f, 0.01827849f, -0.00903678f, -0.00073194f, 0.08798115f, 0.15439121f, 0.16525529f, 
    0.06045034f, -0.14447083f, 0.35262531f, 0.03554062f, 0.01679818f, 0.06251104f, -0.05300801f, 0.11113232f, 
    0.15282418f, 0.04817881f, -0.02788125f, 0.16397242f, 0.00510638f, 0.05711401f, -0.06849673f, 0.05550436f, 
    -0.22147320f, -0.11418583f, -0.01626009f, -0.35978621f, -0.53618801f, -0.00460750f, 0.00863052f, 0.61748868f, 
    0.01722703f, 0.02940723f, 0.36609730f, 0.07828987f, 0.14530437f, -0.00542643f, -0.15955321f, -0.14565460f, 
    -0.04716832f, 0.00731094f, -0.01635344f, 0.41725090f, -0.08308828f, 0.08897475f, -0.07902109f, 0.05271183f, 
    -0.74806482f, -0.29189789f, 0.04117774f, -0.61724502f, -0.07903520f, -0.05378172f, -0.34075528f, 0.05211386f, 
    -0.12090390f, 0.01517729f, -0.08371380f, 0.00266936f, 0.07124165f, 0.00224388f, 0.19385645f, 0.08443140f, 
    0.12689193f, 0.04855505f, -0.04993807f, 0.13042076f, -0.03793412f, -0.05789149f, -0.07474779f, 0.07148569f, 
    -0.00563466f, -0.03053891f, -0.02492353f, -0.06080042f, -0.09179771f, -0.18426761f, -0.05667566f, -0.04290245f, 
    0.06067409f, 0.16337994f, -0.21875542f, 0.11033585f, 0.19746450f, 0.04559555f, -0.03554326f, 0.00091402f, 
    -0.14165092f, -0.37527987f, -0.01190321f, 0.16429946f, 0.15067945f, -0.20571116f, -0.18089752f, 0.00542551f, 
    0.18516693f, -0.25391316f, 0.02109079f, -0.06531388f, 0.04982401f, -0.92304265f, -0.06603265f, 0.19587167f, 
    -0.07680564f, 0.11503167f, 0.16431135f, -0.01117811f, 0.01717092f, 0.18280829f, -0.05283162f, 0.23835665f, 
    0.10802806f, 0.01859770f, -0.60135770f, 0.22748400f, 0.06704828f, -0.08004112f, 0.06192763f, 0.13738388f, 
    -0.64892727f, 0.14499168f, 0.06710247f, -0.01582419f, -0.44252348f, 0.01205421f, 0.05976428f, -0.01987648f, 
    -0.01275241f, 0.23664254f, 0.02328846f, -0.02630003f, -0.04439357f, -0.05306799f, -0.71011442f, -0.27123305f, 
    -0.11007327f, -0.32608616f, -0.03611977f, -0.04988373f, -0.04638383f, 0.00596383f, 0.05181388f, 0.03467464f, 
    -0.02717571f, 0.12064566f, -0.10383029f, -0.05935352f, 0.06211051f, -0.05140506f, -0.58824378f, -0.08538418f, 
    0.04924018f, 0.00032963f, 0.05066899f, 0.28062057f, 0.18271719f, -0.60276937f, 0.04116132f, -0.75224566f, 
    0.03390086f, 0.01765617f, 0.33554730f, -0.46338338f, -0.23118302f, 0.00909790f, -0.20613959f, -0.01307116f, 
    0.01245698f, -0.12997186f, 0.24101855f, -0.48862597f, -0.00720248f, -0.22162391f, 0.00968562f, 0.01859629f, 
    0.28762376f, 0.27393630f, 0.09445340f, 0.28420576f, 0.04020426f, 0.04131758f, -0.10096525f, 0.01296664f, 
    -0.11034561f, -0.06997413f, 0.10915328f, -0.25108448f, -0.02382465f, -0.22846030f, -0.24763516f, 0.07841438f, 
    -0.30358768f, 0.12158094f, -0.00573443f, 0.11757699f, -0.01753348f, 0.07711486f, -0.02403469f, -0.08595343f, 
    -0.00556854f, -0.02005965f, -0.15364884f, 0.05854231f, 0.03289391f, -0.25769454f, -0.00771178f, 0.06576015f, 
    0.01583028f, -0.08161914f, -0.18988241f, 0.05179653f, 0.08498693f, -0.04476459f, 0.08300843f, -0.04169881f, 
    0.25837332f, 0.15346843f, 0.34607166f, -0.26058409f, 0.21264012f, 0.17672828f, -0.04092382f, 0.07510803f, 
    0.20540673f, -0.00012017f, 0.07122470f, -0.00101601f, 0.19564457f, -0.04820874f, 0.00205721f, 0.08358555f, 
    -0.18827873f, 0.02206085f, -0.41577062f, -0.08140010f, 0.03152690f, -0.06377592f, 0.05385160f, -0.42025843f, 
    -0.52385747f, 0.00149517f, 0.06662913f, -0.28493634f, 0.33537555f, -0.05184466f, -0.09510128f, 0.17568921f, 
    -0.11925186f, 0.21845825f, 0.04120197f, 0.07487176f, 0.15093984f, -0.01571199f, -0.05170845f, 0.11126087f, 
    -0.05339803f, -0.01565937f, 0.04114712f, -0.07676940f, -0.08041546f, 0.08824755f, 0.05208017f, -0.41824088f, 
    0.05035603f, -0.46560901f, -0.29680833f, -0.04384137f, -0.02613920f, -0.09676445f, -0.63962317f, 0.01314839f, 
    -0.06724587f, -0.17676932f, 0.09774003f, -0.05756309f, -0.05698707f, -0.08587602f, -0.00281944f, -0.00213647f, 
    -0.26365691f, 0.06087459f, -0.07324643f, -0.01330907f, 0.21786778f, 0.09023062f, -0.12441295f, -0.21097644f, 
    -0.06859633f, 0.06399173f, -0.32217300f, -0.21853542f, -0.06849854f, -0.06012120f, 0.26358706f, -0.32774282f, 
    0.02050042f, 0.07123121f, 0.05074297f, 0.30505791f, -0.00038405f, -0.07295348f, -0.04363398f, 0.08137146f, 
    -0.19639593f, 0.08649523f, 0.08171296f, 0.15797640f, 0.04947957f, -0.03567183f, -0.69584483f, 0.04660114f, 
    0.04486687f, -0.06084496f, -0.03258293f, 0.10960776f, -0.01061259f, -0.16272163f, 0.11384627f, 0.09103125f, 
    0.28956282f, 0.07200509f, 0.00434888f, -0.07946932f, 0.06872683f, 0.02271218f, -0.00046877f, -0.38676384f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.00370631f, 0.13253978f, -0.00449163f, -0.09847217f, -0.08950133f, 0.15200746f, -0.02035150f, -0.27021763f, 
    -0.14043704f, 0.09145471f, 0.20282792f, -0.14422776f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
