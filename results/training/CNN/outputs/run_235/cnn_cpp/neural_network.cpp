#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.37368125f, -0.87679416f, -0.97335613f, -0.73959589f, 0.53990185f, -0.39812279f, -1.38484716f, -0.31125572f, 
    -0.47920021f, -0.05045310f, -0.98877001f, -0.27446938f, -0.11299180f, -0.64260411f, -0.60002720f, 0.27334437f, 
    -0.69525540f, -0.08149545f, -0.02108960f, -0.51680082f, 0.11339026f, -0.06682768f, 0.11737193f, 0.00966961f, 
    0.02311348f, 1.10752630f, -0.91557682f, -1.26436901f, 1.32156026f, 0.80296612f, -0.50325799f, 0.41134480f, 
    -0.20666970f, 0.01047877f, 0.32546189f, -0.14210317f, -0.24314167f, 0.26872703f, -0.34865880f, -0.01438833f, 
    -0.09199707f, -0.25545636f, -0.10496707f, 0.07186269f, -0.05675426f, 0.02938886f, 0.06038325f, -0.09217471f, 
    -0.16090932f, -0.36033684f, 0.76545608f, -0.36005029f, 0.44692144f, 1.36418498f, -0.09857736f, 0.75795150f, 
    0.66235745f, 0.50784236f, 0.21643281f, 0.02539964f, -0.09793952f, 0.52234966f, 0.69603568f, -0.45724261f, 
    -0.38817289f, -0.08040055f, 0.28890666f, 0.90678990f, 0.21528494f, 0.16494994f, -0.07351305f, -0.02341011f, 
    -0.19092178f, 0.50703150f, 0.20843384f, -0.65967196f, 1.20886374f, 1.65393054f, 0.43144420f, 0.55601978f, 
    0.57651412f, -0.42254436f, 0.55300039f, 0.01961043f, 0.19708903f, 0.21081594f, -0.27122292f, -0.42738652f, 
    -0.41799843f, -0.22954246f, -0.17894083f, -0.56612313f, 0.30459470f, -0.43325847f, -0.39901727f, -0.01471570f, 
    -0.10919305f, -0.21070433f, 0.29667857f, 0.14170758f, -1.31388950f, 0.70342189f, -0.65663970f, -0.13606729f, 
    -1.13842046f, 1.18972051f, 0.49122974f, -0.30870181f, 1.15074003f, 0.34657368f, 0.22449026f, 0.32290778f, 
    0.17652173f, 0.33603245f, -0.18946847f, 0.16377491f, 0.16970226f, -0.14889953f, 0.16320904f, -0.39779955f, 
    -0.28713158f, 0.01966481f, 0.47548783f, 0.09797130f, 0.41284797f, 0.44288594f, 0.72392642f, -1.03862751f, 
    -1.25266731f, -0.97358912f, 1.00889981f, -0.50552613f, -0.32196662f, -0.16571285f, -0.36692172f, 0.37156156f, 
    0.03358296f, 1.01717985f, 0.52775514f, -0.21242581f, -0.06823964f, 0.20364340f, 0.43224004f, 0.35295945f, 
    -0.10512656f, -0.16759034f, -0.02702867f, 0.22559555f, 0.01794814f, 0.71346104f, -1.02298534f, 1.31009007f, 
    -0.66710174f, 0.51881152f, 0.04974024f, 0.61297482f, -0.64310956f, -1.32710218f, -0.37739313f, -0.85365462f, 
    -0.49642399f, -0.17439272f, -0.31337881f, -0.04534759f, -0.78511441f, -0.48539084f, -0.22040138f, -0.03469501f, 
    -0.43129447f, -0.14778851f, -0.21910539f, -0.13962771f, -0.04420355f, 0.06212141f, 0.10207748f, 1.32129109f, 
    1.00737786f, 0.85226214f, -0.24757014f, 0.15085627f, 0.27524638f, -0.92008644f, -0.72551703f, -0.79694146f, 
    -0.50296015f, -0.09580673f, 0.22839196f, -0.03699542f, 0.08133306f, -0.15139243f, 0.24293865f, -0.15802665f, 
    -0.19294466f, 0.44172621f, -0.21846212f, 0.47917601f, 0.57829565f, 0.67720407f, -0.36223197f, 0.34280810f, 
    -1.05470419f, -1.71384883f, -1.09128594f, -0.66027659f, -0.60478073f, -0.27919936f, 0.50327307f, 0.94856805f, 
    -0.47715795f, 0.65765846f, 0.12090570f, -0.01614812f, 0.16396698f, 0.15574595f, 0.16548432f, -0.33357805f, 
    0.39906237f, 0.05473490f, 0.22234429f, -0.00219955f, 0.05343918f, 0.14371924f, 0.15711254f, 0.23706301f, 
    0.24137080f, 1.16132343f, -1.20440078f, 0.41059303f, 0.51955813f, 0.97627854f, 1.04774797f, 0.88254422f, 
    0.80357742f, 0.64593399f, 0.46707025f, -0.39307004f, 0.58476603f, -0.68024874f, 0.33487320f, 0.02335115f, 
    0.13522361f, -0.30737504f, -0.27479485f, -0.06621613f, -0.09992015f, -0.08002795f, -0.08177679f, 0.26947075f, 
    0.14494286f, -0.18795668f, 1.16334319f, 0.71777982f, 0.22134858f, 1.18363297f, -0.42310396f, 0.85948783f, 
    0.37826535f, -0.17969286f, -0.41724405f, 0.54239374f, -0.55762118f, -0.07576822f, -0.15676303f, 0.26000467f, 
    -0.21824893f, -0.38678187f, 0.14972295f, 0.16588174f, 0.17226337f, 0.18083088f, -0.15620328f, 0.11358823f, 
    -0.78271878f, -0.44308662f, -0.66684693f, -0.89966303f, -0.51753151f, 0.28334153f, 0.19627835f, 0.16470239f, 
    -1.05529523f, 0.18906716f, 0.71789420f, -0.09024610f, -1.11083949f, 0.15280625f, 0.27598435f, 0.04667272f, 
    0.85795742f, -0.15787295f, -0.74331808f, 0.26097217f, 0.80936712f, -0.31111738f, -0.01221057f, 0.23298085f, 
    0.05443746f, -0.14829214f, 0.03894792f, -0.45688516f, 0.35123914f, 0.56552362f, 1.57901216f, 1.44532502f, 
    -0.74560684f, -0.25450686f, 0.16622938f, -1.06919456f, -0.35125789f, 0.16141619f, 0.41869926f, 0.42755827f, 
    0.30331737f, 0.40763867f, 0.22386186f, -0.03444837f, 0.10318514f, 0.13958159f, 0.09271698f, 0.04386576f, 
    -0.18823695f, 0.23983079f, 0.00418199f, 0.03143723f, 0.16525790f, 0.61030859f, -0.20922112f, -1.23594236f, 
    -1.02547061f, -0.71483451f, 0.61301023f, 1.01557338f, 0.55306637f, 0.93627220f, 0.72717500f, -0.43656191f, 
    -0.08517645f, -0.73059344f, -0.41826665f, -0.12203898f, -0.25563797f, -0.12514038f, 0.04889961f, 0.23519568f, 
    -0.11840831f, -0.17868015f, -0.10368127f, -0.08354104f, -0.46885723f, -0.04246754f, 0.23924740f, -0.72991174f, 
    0.74932790f, 1.16496849f, 1.38374531f, -1.35939884f, -0.62486362f, -0.91402376f, -0.81363076f, -0.02683410f, 
    0.56298071f, 0.42284885f, 0.21431775f, 0.27818301f, -0.10478415f, 0.02897736f, 0.52083820f, 0.30998927f, 
    -0.00897726f, 0.16686249f, 0.13704959f, 0.08142102f, -0.01637713f, -0.08425586f, -0.10281157f, 2.05463147f, 
    0.36285686f, 0.30757773f, 0.06491892f, -0.58653229f, -0.16917104f, -0.84377110f, 0.81178617f, 0.70958751f, 
    0.18430419f, -0.56827021f, -0.30402926f, 0.01102724f, -0.78053868f, -0.39193782f, -0.12814730f, 0.29799965f, 
    0.10600411f, -0.18703832f, -0.03260043f, 0.13867603f, 0.19489679f, 0.47148380f, -0.11350895f, -0.41346323f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.32700384f, 0.09924114f, -0.04906964f, 0.44263044f, 0.08627708f, 0.36249551f, -0.02897829f, 0.25334322f, 
    0.32738730f, -0.04556078f, 0.01930713f, 0.61569536f, 0.24134693f, 0.09519260f, 0.37541538f, 0.38123655f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02538640f, -0.76208377f, 0.29688773f, -0.02818477f, 0.18063568f, 0.02844404f, 0.00195827f, -0.07736000f, 
    -0.14542603f, -0.19527763f, 0.11717706f, 0.08384424f, 0.12882201f, 0.04606567f, 0.06574062f, 0.47276202f, 
    0.05410316f, 0.27673960f, 0.08226252f, 0.04590105f, -0.20442039f, 0.05615662f, 0.01876727f, -0.08977306f, 
    -0.01094567f, 0.40111077f, -0.64627784f, 0.36430338f, -0.04198943f, 0.21444982f, 0.09146602f, -0.06182345f, 
    0.08239072f, 0.11417717f, -0.17190769f, 0.14251870f, -0.55248010f, 0.04182879f, 0.25423330f, 0.07633246f, 
    -0.40504849f, -0.18665536f, 0.15681230f, -0.27481681f, -0.02680645f, -0.04290831f, 0.03548572f, 0.05532340f, 
    0.72259569f, 0.14407168f, -0.14537659f, -0.29533175f, -0.09540338f, -0.01732097f, -0.08200356f, 0.08145901f, 
    0.01454759f, 0.00215462f, -0.26100239f, 0.08530346f, -0.39225441f, -0.25697845f, 0.29897794f, -0.47882649f, 
    -0.04597702f, -0.05556535f, 0.14159255f, -0.08520400f, -0.07156858f, -0.03302778f, -0.03595281f, 0.09141207f, 
    -0.20220056f, 0.29288432f, 0.03760238f, -0.05500430f, 0.07000366f, -0.03979043f, -0.01209680f, -0.11664256f, 
    0.10986128f, 0.06902453f, 0.01018622f, -0.09841833f, -0.02618979f, 0.11793673f, 0.20658833f, -0.46553317f, 
    -0.13231784f, -0.00341329f, -0.06341110f, 0.11120063f, 0.00387556f, -0.17988928f, -0.07382886f, -0.11950974f, 
    -0.53335214f, 0.15008479f, -0.05050821f, -0.48500270f, 0.28641590f, -0.05658616f, -0.02238733f, 0.28361198f, 
    0.16440156f, -0.03696278f, -0.09502582f, 0.15754601f, 0.20729259f, 0.09761198f, -0.11416820f, 0.26905629f, 
    -0.16960019f, 0.19815983f, -0.10410161f, -0.01708023f, -0.01921404f, 0.08768791f, 0.22341439f, -0.30759853f, 
    0.08243883f, 0.18944815f, -0.23344001f, 0.35824364f, -0.34993383f, 0.04244841f, -0.01985196f, 0.01052748f, 
    0.04328845f, -0.04747710f, -0.23747811f, 0.06576021f, -0.61094481f, 0.23562063f, -0.31731299f, 0.01360709f, 
    0.06574426f, -0.01944835f, -0.05226066f, -0.03338713f, -0.19393791f, -0.05897103f, -0.05850378f, -0.14544316f, 
    0.00522821f, 0.31948173f, -0.36997622f, 0.50301582f, -0.23251401f, -0.33665809f, 0.10944837f, -0.03795464f, 
    -0.25748768f, 0.21251294f, 0.02018161f, 0.14757237f, 0.19098940f, 0.05091813f, 0.11384544f, -0.63796192f, 
    0.11203922f, 0.06202598f, 0.22555645f, -0.23869385f, -0.02741162f, 0.07103498f, 0.03996482f, 0.17314205f, 
    0.42185727f, -0.28144109f, -0.14271018f, 0.30409342f, -0.31172231f, -0.03582004f, 0.01704512f, -0.18719700f, 
    -0.12365831f, -0.02962446f, -0.04903625f, -0.08671716f, 0.41319442f, -0.36239547f, -0.05612910f, 0.32481471f, 
    -0.25614119f, -0.02088851f, -0.23733187f, -0.01147186f, -0.21880665f, 0.11520854f, -0.06372167f, -0.08948709f, 
    0.01794430f, -0.28884521f, 0.44720501f, -0.80015665f, -0.00132644f, 0.10765378f, 0.02688317f, 0.06291840f, 
    0.07298551f, -0.26121777f, -0.33810240f, 0.04777595f, 0.28272444f, -0.74883497f, -0.26242739f, -0.03410770f, 
    -0.16877699f, -0.01472226f, -0.26266304f, 0.15197378f, -0.05010081f, 0.20504841f, -0.17589515f, 0.08205561f, 
    0.11092328f, 0.02793953f, 0.07075530f, 0.43891189f, -0.06963122f, 0.15263517f, -0.20097539f, -0.13700502f, 
    0.16722460f, -0.30971739f, 0.05628571f, -0.12684722f, 0.27822709f, 0.28470913f, 0.09148826f, 0.18098514f, 
    0.13532574f, 0.26105011f, 0.01549613f, -0.13671705f, -0.26377508f, -0.15067418f, 0.02877906f, 0.08751398f, 
    -0.89446801f, -0.11628313f, -0.20806809f, -0.20439437f, 0.20722836f, -0.19263417f, -0.05008990f, 0.06889746f, 
    0.11317779f, -0.00583675f, -0.01640399f, 0.03220988f, 0.19245866f, -0.66634494f, 0.02532102f, -0.33425570f, 
    0.07270703f, 0.07580174f, 0.14274354f, 0.21756074f, -0.05096070f, 0.07408462f, 0.20610023f, -0.17349029f, 
    0.04596263f, -0.78624761f, -1.00015140f, -0.22278395f, 0.00286010f, 0.14697282f, 0.00102336f, 0.02071495f, 
    0.01478948f, -0.02413154f, -0.01993433f, -0.31382316f, 0.01239142f, -0.13577817f, 0.19520128f, 0.33713374f, 
    -0.07938606f, -0.11088565f, 0.12096434f, -0.07390502f, 0.06561010f, 0.00513425f, 0.07924150f, 0.13615526f, 
    0.61418712f, -0.05928795f, -0.07105064f, 0.18755993f, -0.10626560f, -0.03973067f, 0.14892128f, 0.09388527f, 
    0.06701483f, -0.15936112f, -0.18812554f, 0.02318075f, 0.87812412f, -0.13426571f, 0.15798827f, 0.14378792f, 
    0.05032273f, 0.16967832f, -0.05526529f, -0.05005022f, 0.09831339f, -0.05599590f, -0.16788732f, -0.04186862f, 
    0.28176317f, -0.00520405f, 0.26157156f, 0.26533359f, 0.07473129f, -0.22618777f, -0.07706030f, -0.11559126f, 
    -0.12175660f, 0.03224460f, 0.15317950f, -0.17786521f, -0.33961916f, 0.06985532f, -0.29680589f, 0.13123482f, 
    0.04637627f, -0.07487020f, -0.17988779f, 0.08548063f, -0.00518931f, -0.27188817f, 0.16916507f, 0.10225082f, 
    0.01773280f, 0.17229740f, 0.10490272f, -0.07101394f, -0.15214002f, -0.12446044f, 0.07004959f, -0.16403556f, 
    0.17460544f, -0.14187057f, 0.09606639f, -0.06543612f, 0.28960463f, -0.54417610f, 0.11556961f, -0.39020962f, 
    0.30132473f, -0.22449513f, -0.12201727f, 0.06432536f, -0.10358174f, 0.08994375f, -0.03507915f, -0.14752555f, 
    -0.37931317f, -0.29181108f, 0.10605849f, 0.18694545f, 0.00556148f, -0.07772626f, -0.02893287f, 0.18164323f, 
    0.00080444f, -0.00174728f, 0.11171262f, -0.01582537f, 0.15373005f, -0.15909244f, 0.01912890f, 0.15010837f, 
    -0.19944231f, -0.20809498f, -0.00587051f, 0.04755166f, 0.12015048f, -0.07466393f, 0.02366610f, -0.10987991f, 
    -1.31216431f, -0.23194088f, -0.21790889f, -0.40629768f, 0.04079979f, 0.08764354f, -0.17147009f, -0.12794068f, 
    0.09964032f, 0.34445277f, -0.02616843f, 0.10853874f, 0.61165124f, -0.37912151f, 0.08201758f, -0.15480798f, 
    0.05197091f, 0.10541338f, -0.05071297f, -0.11998679f, -0.03963023f, 0.00010986f, -0.26305118f, 0.06714430f, 
    -0.22998068f, 0.02741996f, -0.03602508f, 0.03726146f, -0.22172271f, 0.04470292f, -0.03084486f, 0.10069793f, 
    -0.03368156f, -0.05356455f, -0.15206492f, 0.00239589f, 0.59235877f, -0.06197867f, -0.18152097f, -0.01327820f, 
    -0.26561141f, -0.03539575f, -0.02802685f, -0.12528172f, -0.15623251f, 0.19604848f, 0.10596065f, -0.04787929f, 
    0.65939516f, 0.46631724f, -0.00645132f, -0.01524803f, 0.01414234f, 0.00107093f, -0.10535674f, 0.17283057f, 
    -0.09219254f, 0.09924531f, 0.22305982f, -0.03418921f, -0.95736915f, 0.08777563f, -0.07193236f, -0.41374198f, 
    0.22064719f, -0.16517755f, 0.11621531f, 0.00806000f, -0.32279119f, -0.00428422f, 0.06825782f, 0.10277712f, 
    -0.14559017f, -0.39090359f, -0.22658531f, -0.50127292f, 0.07773616f, -0.10997530f, -0.07316271f, -0.06433952f, 
    -0.22760890f, 0.19048458f, -0.12763244f, 0.11717815f, -0.53334332f, -0.13402233f, -0.00686231f, -0.38553217f, 
    0.10497953f, 0.04768804f, 0.01709513f, -0.20423704f, -0.05650831f, 0.03232981f, 0.02938367f, 0.00611644f, 
    0.72788662f, -0.00794163f, 0.15838502f, 0.47026500f, -0.34137142f, -0.19854277f, -0.17174420f, 0.06579947f, 
    -0.08123295f, -0.17898974f, -0.01129138f, -0.03255988f, -0.17356059f, 0.03732261f, 0.11866603f, -0.10396925f, 
    0.09894196f, 0.04343038f, -0.16743249f, 0.00996237f, 0.00476257f, 0.08954163f, 0.25927192f, -0.11161804f, 
    0.05781147f, -0.36239502f, 0.03899091f, -0.49076882f, -0.05544202f, -0.03794135f, -0.07657170f, -0.07994418f, 
    -0.08829519f, 0.10250730f, 0.01843025f, -0.02767545f, 0.50274062f, 0.00368114f, -0.37256086f, 0.04626668f, 
    -0.13671523f, -0.04341757f, 0.12949440f, -0.00049223f, -0.00093254f, -0.04667474f, -0.01462735f, 0.07257335f, 
    -0.06869517f, 0.01790522f, -0.28107542f, -0.13358162f, -0.03657030f, 0.46285489f, -0.00054201f, 0.03572477f, 
    -0.13003312f, -0.06014728f, -0.34457734f, -0.15749522f, 0.04238524f, 0.20837218f, 0.20827983f, 0.48298740f, 
    -0.10859145f, -0.12915123f, 0.15524861f, 0.25054729f, -0.13385104f, -0.16483030f, -0.01958495f, -0.03664460f, 
    0.63123047f, 0.10844234f, -0.16845150f, 0.15233169f, -0.00006830f, 0.07002701f, -0.16771665f, -0.17186250f, 
    -0.20005216f, -0.05214731f, -0.19066624f, -0.01847200f, -0.34973875f, 0.13013564f, -0.09610911f, 0.21591571f, 
    0.13146220f, -0.14648688f, 0.14817528f, 0.13533704f, 0.03775404f, -0.03720935f, -0.07776278f, -0.11664665f, 
    0.20554529f, 0.07833651f, 0.00170086f, 0.48089558f, -0.25245336f, -0.06974445f, 0.11282164f, -0.10586973f, 
    0.08943965f, 0.06577845f, 0.06888654f, -0.03844888f, 0.42672145f, 0.19480087f, 0.21885523f, 0.20523028f, 
    -0.03466470f, 0.12494928f, 0.20183617f, -0.11755100f, 0.18299833f, 0.06025291f, 0.14187077f, -0.13856687f, 
    0.15903293f, -0.29189166f, -0.27462092f, -0.02910801f, 0.09985945f, -0.36516827f, -0.00626411f, 0.13245976f, 
    -0.06509076f, -0.05951802f, -0.02802291f, -0.12303916f, -0.72901142f, -0.47298402f, -0.64142829f, 0.01111420f, 
    0.02099400f, -0.17423604f, 0.06233479f, -0.08264596f, 0.06101688f, 0.05411826f, -0.05805722f, 0.03643491f, 
    -0.05512519f, 0.26308715f, -0.09404981f, -0.23541556f, -0.03838057f, 0.10326269f, 0.00236181f, -0.01995960f, 
    0.02140876f, -0.19994880f, -0.01343272f, 0.03047446f, 0.08235472f, -0.05248635f, -0.11871155f, 0.06756447f, 
    -0.27204660f, -0.05651855f, -0.14668256f, 0.09140328f, 0.10151985f, 0.02300688f, -0.21497013f, 0.05731206f, 
    1.22457922f, 0.35391232f, -0.28446382f, 0.28803799f, 0.08551800f, 0.01891819f, 0.00851824f, 0.35389543f, 
    -0.18310341f, 0.18121862f, -0.08411561f, -0.12295660f, 0.31956434f, -0.58704191f, -0.18308946f, 0.05210321f, 
    0.02535221f, 0.07167714f, 0.01290960f, 0.05527768f, -0.22836372f, -0.03768513f, -0.10284393f, -0.12496757f, 
    0.60552478f, -0.27798566f, 0.05862768f, -0.47639433f, -0.39840177f, -0.16123281f, 0.06455316f, -0.02444082f, 
    -0.16172282f, -0.15877803f, 0.11080344f, -0.00392408f, -0.69097942f, 0.22249605f, -0.74974048f, -0.19717607f, 
    0.00764213f, -0.02814944f, -0.14849801f, -0.12813769f, -0.01205216f, 0.06996968f, 0.13189644f, 0.05979306f, 
    -0.18988599f, -0.33699954f, -0.31948879f, 0.39507124f, -0.13108067f, -0.00714737f, 0.08776079f, -0.09252575f, 
    0.06907954f, -0.04268386f, 0.07742059f, 0.15007722f, -0.21076755f, 0.26054671f, 0.47342941f, 0.10052312f, 
    -0.23431653f, -0.12403652f, 0.14477409f, -0.09065768f, 0.02922831f, -0.01794327f, -0.02498441f, -0.02216793f, 
    -0.84640145f, -0.23031883f, -0.21627271f, 0.25845912f, 0.05526650f, 0.22153759f, 0.19744407f, 0.03235183f, 
    0.01551745f, 0.01056164f, -0.09970601f, 0.05787973f, -0.22391261f, -0.18155667f, -0.05624847f, -0.00390518f, 
    -0.25738999f, 0.09182057f, -0.03760152f, -0.06738852f, -0.19895455f, 0.01991839f, -0.05969103f, 0.08818177f, 
    -0.56716985f, 0.04097977f, 0.22981055f, 0.59840113f, 0.24719369f, 0.22629583f, 0.04616588f, -0.12029100f, 
    -0.15090095f, 0.01644861f, -0.02458350f, -0.10574295f, 0.00712783f, -0.30545926f, 0.01863812f, -0.26103294f, 
    0.10483577f, 0.24167478f, -0.15940240f, 0.14347878f, 0.08453277f, 0.06611547f, -0.40590560f, 0.07432137f, 
    0.14515278f, -0.12392177f, -0.19496778f, 0.37989837f, -0.13648486f, -0.24817647f, 0.06639495f, 0.01578003f, 
    -0.37210053f, -0.05896576f, 0.06593245f, -0.15019462f, 0.18387510f, 0.13272096f, -0.42027885f, 0.00384009f, 
    -0.11508521f, 0.04224557f, -0.00093037f, 0.01426234f, -0.05809897f, -0.06553341f, 0.11888194f, -0.01725789f, 
    -0.28902549f, 0.26455030f, -0.00729225f, -0.15351446f, -0.12614918f, -0.32262471f, -0.20219901f, 0.16677733f, 
    -0.18931364f, 0.01806304f, -0.10804087f, 0.03021311f, 0.43241102f, 0.30319989f, 0.00094204f, 0.18220015f, 
    -0.00471376f, -0.12454093f, 0.08008084f, 0.15129969f, 0.01584165f, -0.04357665f, -0.10188015f, 0.11726771f, 
    0.36335140f, -0.10866740f, -0.02909648f, -0.08449470f, 0.13374594f, 0.10076821f, -0.05394325f, -0.06628951f, 
    -0.03087048f, -0.04903384f, -0.03480038f, -0.06159728f, 0.14703700f, -0.05903223f, -0.15499824f, 0.20525560f, 
    -0.15268685f, 0.06827071f, 0.19698061f, -0.01658673f, -0.09296340f, 0.17169122f, 0.06279242f, 0.00723194f, 
    0.23261432f, 0.42561352f, 0.14264958f, -0.53611237f, -0.04833261f, 0.18818679f, 0.13552853f, 0.01019621f, 
    0.02632418f, -0.12129062f, -0.06990264f, 0.15706179f, -0.22958009f, 0.07952828f, 0.50970906f, 0.04872341f, 
    -0.10591005f, 0.00949840f, -0.00046459f, -0.12170147f, 0.23646437f, -0.22587952f, 0.14732946f, -0.00964879f, 
    -0.55663782f, 0.10514711f, -0.05564906f, 0.11800674f, 0.18047981f, 0.05667029f, -0.07678152f, 0.10161918f, 
    -0.04656895f, 0.07860348f, -0.01690467f, -0.00163897f, -0.82943857f, 0.13666597f, -0.11247219f, -0.01780944f, 
    0.20254657f, -0.03593431f, 0.15448575f, 0.00048283f, 0.05096101f, -0.00983212f, -0.00100017f, -0.07317290f, 
    -0.11484358f, 0.15441400f, -0.05814305f, -0.04620636f, 0.06106853f, 0.45654503f, 0.29597768f, 0.17647581f, 
    -0.10976566f, 0.07095604f, 0.02206969f, 0.31114703f, -0.19676463f, 0.00351815f, -0.08214606f, -0.22552940f, 
    0.02045458f, 0.01674084f, -0.12255399f, -0.16758943f, -0.17509526f, -0.14733845f, -0.01969013f, 0.12078043f, 
    -0.72764188f, -0.37396076f, 0.07215359f, -0.21975468f, -0.22410780f, 0.00388345f, -0.25396290f, 0.08510847f, 
    0.09538217f, -0.19103369f, -0.29344910f, 0.01193694f, -0.68884391f, 0.03615392f, 0.16380459f, 0.36910695f, 
    -0.05962315f, 0.06199681f, 0.13427003f, 0.02803045f, -0.07995451f, 0.11160903f, 0.23378320f, 0.15888457f, 
    -0.52704680f, -0.19734719f, 0.31784317f, 0.24577343f, -0.10976791f, -0.03603142f, -0.08785164f, -0.12640098f, 
    0.28260407f, 0.05793250f, -0.21954110f, -0.10263298f, 0.04252544f, -0.19258045f, 0.14362241f, -0.14620721f, 
    -0.14641254f, 0.05658122f, -0.00000919f, -0.13299252f, 0.08932706f, 0.16517816f, -0.01374263f, 0.13787910f, 
    0.22776127f, 0.03066265f, -0.01015564f, -0.03742948f, 0.22599958f, 0.17795981f, -0.06577682f, 0.24100503f, 
    0.12608172f, 0.03584590f, 0.12398459f, -0.32783195f, -0.43523672f, -0.02547609f, 0.00789073f, -0.56496936f, 
    -0.02652660f, -0.42969033f, -0.28896293f, -0.11557640f, 0.17452595f, -0.10769740f, 0.12916279f, -0.05164427f, 
    0.15710293f, 0.20484439f, 0.36439037f, -0.00427638f, 0.14963318f, 0.13281630f, 0.18375961f, 0.07650304f, 
    0.04347374f, 0.03783740f, 0.39143229f, 0.30569586f, -0.09374484f, -0.39359373f, -0.11319775f, 0.17007519f, 
    -0.01715088f, 0.26297593f, -0.03639065f, 0.21900459f, 0.12113394f, -0.06190300f, -0.04274033f, -0.24262105f, 
    -0.47876042f, -0.06783143f, -0.18007840f, -0.26095998f, -0.05458101f, 0.07435869f, 0.14729410f, -0.30402035f, 
    -0.00609388f, -0.00187248f, -0.00708369f, 0.06402748f, -0.29501757f, 0.08961669f, -0.07003687f, 0.06889601f, 
    -0.00791136f, -0.06007859f, -0.28162667f, -0.04822610f, 0.04037116f, -0.26554793f, 0.17009495f, 0.00849472f, 
    -0.17874043f, -0.15428808f, 0.51498932f, 0.48667821f, -0.31582558f, -0.07761490f, 0.18796836f, -0.00900028f, 
    -0.15947556f, -0.09103196f, -0.17031521f, 0.01550141f, -0.08875042f, 0.02912970f, 0.28685874f, 0.31138939f, 
    0.00418635f, -0.22633456f, 0.12155209f, 0.01766401f, -0.00441198f, 0.13108271f, -0.06070332f, 0.06871111f, 
    -1.09803212f, -0.17347820f, -0.61036718f, 0.06899480f, 0.10130000f, 0.11333717f, 0.03471409f, -0.04686091f, 
    -0.17048518f, 0.00944924f, 0.01325689f, 0.15211575f, -0.61263293f, 0.27241185f, 0.36024207f, -0.02042433f, 
    -0.00951566f, -0.11727575f, -0.01114092f, -0.13017373f, 0.11643816f, -0.15602267f, -0.29687575f, 0.04424628f, 
    0.26479998f, 0.17379622f, 0.27359599f, -0.23384447f, 0.18006501f, -0.18428499f, -0.17357792f, 0.11181092f, 
    -0.10767268f, -0.03808731f, -0.01446100f, -0.16540726f, -0.06329085f, -0.35876465f, -0.20594221f, 0.13416338f, 
    0.05618846f, -0.16415220f, -0.00236896f, -0.00516183f, 0.07064204f, 0.18597934f, 0.14362483f, 0.05127795f, 
    0.09834399f, 0.10004155f, -0.01377959f, 0.07604354f, 0.01920032f, 0.12910755f, 0.03627782f, -0.00259015f, 
    -0.01389780f, -0.07934721f, 0.13582171f, 0.14227521f, 0.48474115f, -0.14568974f, -0.42269796f, -0.26326984f, 
    -0.01017803f, 0.08353395f, -0.33735701f, -0.08447162f, -0.02789586f, -0.07418179f, -0.36845544f, -0.05445711f, 
    0.11369049f, 0.21101816f, -0.12189813f, -0.37333110f, -0.01503852f, 0.06155869f, 0.16030355f, 0.06938400f, 
    -0.03722925f, 0.05729513f, 0.25144309f, 0.47151285f, 0.38627720f, -0.14645875f, 0.00235808f, -0.02475387f, 
    0.07505733f, -0.07218075f, 0.01372463f, -0.03381100f, -0.12013131f, -0.02397191f, 0.11532526f, -0.04815026f, 
    -0.38571373f, -0.17654100f, -0.46961278f, -0.60922873f, -0.17193742f, -0.06527668f, -0.18620063f, 0.02110904f, 
    0.07795688f, -0.03222396f, -0.06078015f, 0.16145523f, 0.31627429f, 0.12012715f, 0.16393413f, -0.20429258f, 
    -0.09447172f, 0.29786903f, 0.16021559f, 0.19227760f, 0.04124698f, 0.12273032f, 0.09928947f, 0.05495103f, 
    0.13810259f, -0.41969627f, 0.18226975f, -0.51348066f, -0.01022048f, -0.01673973f, 0.04540053f, -0.08192904f, 
    -0.01096479f, 0.12630405f, -0.15690851f, -0.06370573f, 0.35260555f, -0.06738821f, 0.00132609f, -0.14974579f, 
    -0.27438244f, -0.29972473f, 0.07055654f, 0.10065895f, 0.12139910f, 0.09228839f, 0.16168824f, 0.28738678f, 
    0.17203690f, 0.00005990f, 0.32030028f, 0.28551593f, -0.17425534f, 0.08650375f, -0.03436733f, -0.03358764f, 
    -0.27033761f, 0.16980098f, -0.11112878f, 0.13383625f, 0.45746437f, -0.22729313f, -0.31493467f, 0.49271327f, 
    0.04775597f, 0.03031274f, -0.10102884f, -0.17123128f, -0.01020849f, -0.00867230f, -0.32314867f, -0.00831209f, 
    0.07885323f, -0.17421597f, 0.16377084f, 0.23265724f, -0.01985948f, 0.05194832f, 0.02212789f, -0.08221178f, 
    0.37192029f, 0.16611619f, -0.03484124f, 0.13142587f, -0.12791505f, 0.19308053f, -0.60167539f, 0.12285319f, 
    -0.21883494f, 0.30259883f, -0.19075269f, 0.37135229f, -0.04011227f, -0.03507086f, -0.13540880f, -0.08867968f, 
    -0.34703103f, -0.53719056f, -0.33171633f, -0.53358853f, -0.05514939f, 0.09652346f, 0.14874330f, -0.20263387f, 
    0.03902295f, -0.01113447f, 0.00637235f, 0.04865307f, 0.08357177f, -0.58743709f, 0.35743499f, 0.00621140f, 
    -0.24284229f, -0.20377626f, 0.03151697f, 0.22515920f, -0.10083278f, -0.07344604f, 0.13907476f, 0.10118720f, 
    0.34318960f, 0.22468482f, 0.09440762f, -0.14975204f, -0.44668800f, 0.02628814f, 0.08340669f, 0.14521678f, 
    -0.09337686f, -0.01774498f, -0.10595754f, 0.10788595f, 0.12406148f, -0.03081316f, -0.03103125f, -0.17422652f, 
    0.11163791f, 0.23586641f, 0.07125719f, 0.01114883f, 0.00590123f, -0.09784856f, -0.32045174f, -0.09930576f, 
    -0.00409290f, 0.09072256f, 0.34487322f, -0.47127080f, 0.12162969f, -0.04516308f, -0.04883434f, -0.00696602f, 
    -0.01299389f, 0.09282499f, -0.04551740f, -0.36178896f, -0.87013489f, -0.08998978f, -0.34311450f, 0.10451631f, 
    0.09170020f, -0.10043269f, 0.02878128f, -0.13835353f, 0.10164338f, -0.01701405f, 0.21973801f, 0.19481038f, 
    0.58965850f, 0.38766888f, 0.12364382f, -0.29127654f, -0.02868919f, 0.11169126f, -0.11718127f, -0.15946645f, 
    -0.07731900f, -0.17156558f, -0.19101508f, -0.09050382f, -0.72760051f, 0.10907550f, 0.06147682f, 0.21431807f, 
    0.10997978f, 0.13628499f, 0.00326297f, 0.10334066f, -0.12185599f, -0.02763869f, -0.01120156f, 0.13215928f, 
    0.30101466f, 0.29540783f, 0.22928658f, 0.63383991f, -0.04319706f, -0.02677261f, -0.16890131f, -0.16186084f, 
    -0.13120522f, -0.10745970f, 0.04471581f, -0.16678427f, 0.02489607f, 0.51383328f, 0.09256302f, -0.37186161f, 
    0.03643760f, -0.03480854f, -0.02282455f, -0.11550535f, -0.21237890f, -0.17538874f, -0.35646558f, -0.33520812f, 
    -0.11901055f, 0.34968409f, 0.16046067f, -0.17654933f, -0.06396218f, -0.22171059f, 0.15101455f, -0.12200982f, 
    -0.01763308f, 0.06039656f, 0.09129149f, 0.03825476f, -0.43065667f, -0.27119321f, -0.20713532f, -0.59557652f, 
    0.11984422f, 0.14708230f, -0.05548862f, -0.24007481f, -0.09996159f, -0.06595232f, -0.29531926f, -0.23630653f, 
    -0.12931396f, 0.30556408f, -0.05008524f, 0.22991884f, 0.04698788f, -0.26933444f, 0.19438025f, 0.12159455f, 
    -0.02449967f, 0.13900733f, 0.06773167f, -0.08501641f, -0.04635364f, 0.53365910f, -0.18435961f, 0.22421405f, 
    0.19842753f, -0.00449341f, -0.05520516f, 0.12228762f, -0.08608227f, -0.00197056f, -0.00481561f, -0.11810846f, 
    -0.46176499f, 0.28302997f, 0.28322330f, 0.35824487f, -0.10090778f, -0.39893931f, 0.03612076f, -0.14384528f, 
    -0.09508963f, 0.10515235f, 0.09916272f, 0.09511394f, -0.61982393f, -0.09537861f, -0.35482189f, 0.13660361f, 
    0.05426688f, -0.34061670f, -0.14717864f, 0.07130270f, -0.17258388f, 0.01952115f, 0.05685748f, 0.01910898f, 
    0.37239692f, 0.28540319f, 0.41703299f, 0.32668293f, 0.28385338f, 0.02559685f, 0.23266628f, -0.09395044f, 
    -0.01038173f, 0.17042057f, 0.02068696f, -0.16158131f, -0.53938866f, -0.15300696f, -0.06818040f, -0.05921850f, 
    -0.41816744f, -0.04299176f, -0.11146273f, -0.17119814f, -0.01053440f, 0.03487808f, -0.21489649f, -0.17436711f, 
    -0.42980254f, 0.09958744f, 0.10155974f, -0.04352658f, -0.31518680f, 0.02354335f, 0.07771475f, -0.04358105f, 
    0.00120195f, 0.02627513f, -0.28077433f, -0.20064473f, 0.36906520f, -0.67788070f, 0.16563348f, -0.01746826f, 
    0.15792057f, 0.16217279f, -0.05808848f, -0.09207074f, -0.07058947f, 0.02392407f, -0.02514651f, -0.10364171f, 
    0.42534217f, -0.32691780f, -0.24157681f, 0.03171711f, 0.06976095f, 0.00159841f, 0.00213531f, 0.04154646f, 
    0.00264401f, 0.07163853f, -0.08173552f, -0.14270122f, 0.01133067f, 0.24357206f, 0.22512381f, 0.09334062f, 
    0.02745233f, 0.08359638f, 0.10238115f, -0.22584340f, 0.16467193f, 0.13786511f, -0.00757077f, -0.08209081f, 
    0.13673335f, -0.23809174f, -0.24629097f, -0.07795706f, -0.02219149f, 0.00361046f, -0.00955582f, -0.12889889f, 
    -0.14871167f, 0.01172390f, -0.08050283f, -0.04419813f, 0.13102265f, 0.13932687f, -0.07315487f, -0.01674763f, 
    -0.06269312f, -0.04199486f, -0.13295621f, -0.03450466f, -0.23360811f, 0.01133524f, -0.06511027f, -0.12128241f, 
    -0.39961255f, -0.00965551f, -0.33193594f, -0.32594198f, -0.09497179f, -0.02216436f, -0.16958265f, 0.24058127f, 
    0.22114767f, -0.22628613f, -0.06414744f, -0.22155890f, -0.25637457f, 0.10633108f, 0.09281839f, -0.25469700f, 
    -0.26751405f, -0.20955257f, -0.05336008f, 0.20308062f, 0.01013687f, -0.23249993f, 0.05215191f, -0.18615672f, 
    0.45243037f, -0.06204257f, 0.32147470f, 0.11164313f, 0.19526213f, -0.10881907f, -0.04580525f, -0.40181568f, 
    0.08185076f, -0.01899467f, 0.28068641f, 0.11981872f, 0.18996456f, -0.05528467f, 0.08979034f, 0.22099417f, 
    0.28106362f, -0.15527415f, -0.13988131f, 0.05564385f, 0.02902923f, -0.09171294f, 0.09416769f, -0.16380921f, 
    0.12288736f, 0.10267001f, -0.03904834f, 0.21118389f, -0.05130241f, -0.14264953f, 0.00515888f, 0.05355814f, 
    0.03882637f, -0.22137414f, 0.22909772f, 0.07053130f, -0.04123886f, 0.76163858f, -0.25194359f, -0.11971965f, 
    -0.29232964f, 0.03946167f, -0.22054404f, -0.16797127f, 0.03336126f, -0.21427815f, 0.24782325f, 0.19724593f, 
    0.08794060f, -0.19702515f, -0.58018970f, -0.03132066f, 0.08821169f, -0.09967989f, -0.42836916f, -0.17697093f, 
    0.15638149f, 0.09754474f, 0.18124448f, -0.36958301f, -0.16049623f, 0.20937318f, -0.46713692f, 0.07807907f, 
    -0.06064287f, 0.16330762f, 0.10412031f, -0.08789239f, 0.26267233f, 0.07428081f, -0.10913694f, -0.00847146f, 
    -0.46419051f, -0.10353203f, 0.43283242f, -0.09734315f, -0.12210337f, 0.07177026f, -0.10415108f, -0.29339871f, 
    -0.01286570f, 0.01456047f, 0.09687049f, 0.00572897f, 0.36253342f, 0.12686090f, 0.12033077f, 0.28147724f, 
    -0.16657755f, -0.11276638f, -0.10888768f, -0.31059471f, -0.22749087f, -0.10885809f, -0.25395259f, -0.03187605f, 
    0.25699067f, -0.04131206f, -0.02219318f, 0.10710514f, 0.10319045f, -0.34342325f, -0.38353673f, -0.08634073f, 
    -0.02246240f, -0.04552230f, 0.13805443f, -0.44846454f, -0.16413240f, -0.30492440f, 0.18064691f, -0.27952370f, 
    0.11778546f, 0.04068631f, 0.02543296f, 0.00838396f, 0.12911597f, 0.04625244f, 0.14026947f, 0.20295902f, 
    0.22069237f, -0.72650826f, -0.16415387f, 0.11943845f, 0.00501891f, -0.05073766f, -0.00803636f, -0.02356698f, 
    -0.01419451f, -0.05969347f, 0.13084027f, 0.23692364f, 0.08514723f, 0.53427917f, -0.20661579f, 0.14529808f, 
    -0.32136273f, 0.11576515f, -0.24964860f, 0.04948235f, -0.10407966f, -0.14433818f, -0.26709321f, -0.15278409f, 
    -0.32560381f, -0.14401633f, -0.09017493f, -0.06069268f, -0.08421621f, -0.13379893f, -0.17080748f, -0.13243726f, 
    0.04162998f, 0.05233207f, 0.08937041f, 0.08950544f, -0.19965652f, -0.02696137f, 0.07877757f, -0.18170291f, 
    0.21192156f, 0.02123776f, -0.01005076f, -0.01376778f, 0.26292887f, 0.02510260f, 0.33188826f, 0.02573313f, 
    -0.08573411f, 0.35451877f, -0.08879165f, 0.28954467f, -0.00765106f, 0.18718828f, 0.14258529f, -0.20457274f, 
    -0.02563192f, 0.22219913f, -0.06461893f, 0.38854808f, -1.17100191f, 0.18750903f, -0.02578594f, 0.00445568f, 
    0.11722066f, 0.12918815f, 0.10481545f, -0.06656773f, -0.12237284f, -0.09256605f, 0.08493692f, 0.18690559f, 
    0.14119695f, 0.05441609f, -0.37363905f, 0.13184327f, 0.22018425f, 0.04749268f, 0.13357013f, 0.10073370f, 
    -0.14932457f, 0.03963066f, -0.43084538f, -0.09214883f, -0.23632008f, -0.04014245f, 0.06284428f, -0.23658809f, 
    0.28340486f, -0.00979444f, -0.25897646f, -0.15103176f, -0.02030033f, 0.22200973f, -0.04430462f, 0.08517851f, 
    -0.76932693f, -0.49744335f, 0.28901660f, 0.16068697f, 0.17946652f, -0.04310421f, 0.01783236f, 0.02003297f, 
    0.11273645f, -0.13256493f, 0.10316319f, -0.17982896f, -0.24073979f, 0.14044602f, 0.66289216f, -0.11127990f, 
    0.01087104f, -0.16170290f, 0.03111282f, 0.00793927f, 0.16784906f, -0.09158470f, -0.16540490f, 0.05482983f, 
    -0.27044326f, -0.28060961f, -0.05294753f, -0.38008389f, 0.11902762f, -0.12549135f, -0.05493069f, 0.06885901f, 
    -0.09920929f, -0.10648482f, -0.00041738f, 0.00780403f, -0.13810183f, 0.12194452f, 0.09120659f, -0.60382771f, 
    -0.08143365f, 0.20856571f, -0.10343670f, -0.11670115f, -0.47171053f, -0.08507064f, -0.09295978f, 0.03905296f, 
    -0.02647324f, -0.11968992f, -0.27252227f, -0.21950863f, -0.05006531f, -0.14430581f, -0.13863990f, 0.02467774f, 
    -0.21008600f, 0.01013947f, 0.02730103f, -0.06440387f, 0.33720544f, 0.49886736f, -0.47448850f, -0.04035779f, 
    0.03566730f, -0.07071736f, -0.06181057f, -0.00830220f, -0.06737344f, 0.09734497f, 0.22553121f, 0.09855381f, 
    -0.74506289f, 0.18236229f, -0.16744854f, 0.02516384f, 0.07457487f, -0.03443188f, 0.10542569f, 0.05922749f, 
    0.24542339f, 0.14751038f, -0.01625517f, 0.24160582f, 0.55908865f, -0.46294692f, -0.11767442f, 0.19272956f, 
    -0.25371078f, 0.03348739f, 0.18382521f, 0.12485227f, 0.13763329f, 0.14267485f, -0.13653140f, -0.14371195f, 
    0.00682194f, 0.47538906f, 0.18937916f, -0.45048764f, -0.06734650f, 0.19108766f, -0.17927960f, 0.04297809f, 
    -0.12506402f, 0.01558849f, -0.03947303f, -0.10267039f, -0.42296389f, 0.09392528f, 0.24200857f, 0.24677643f, 
    0.21312334f, 0.01814342f, 0.02266632f, 0.30191574f, 0.27878743f, -0.13573976f, 0.18703189f, 0.01089939f, 
    -0.42043042f, 0.23622683f, 0.00535516f, -0.66789991f, -0.11234515f, -0.07503845f, -0.06862957f, -0.06795935f, 
    0.08777813f, 0.10649094f, 0.10067084f, -0.19361690f, 0.28174791f, 0.55381119f, -0.07266460f, 0.20670044f, 
    -0.10658637f, -0.01394260f, -0.05577554f, 0.12333270f, -0.12245476f, -0.08660479f, -0.06723605f, -0.05210318f, 
    0.01911543f, 0.24307519f, 0.19979765f, -0.07458036f, 0.04209351f, 0.05376558f, 0.16135876f, 0.02336645f, 
    0.01650955f, -0.09084107f, 0.11761314f, -0.17758244f, -0.16022091f, -0.51208043f, -0.19236273f, 0.35030583f, 
    0.11562309f, 0.05793846f, -0.05258261f, 0.25592279f, -0.02047351f, -0.04098551f, -0.09750808f, 0.10335527f, 
    -0.48724526f, -0.27897137f, -0.28217369f, -0.34211749f, -0.10177932f, 0.07631800f, -0.09743445f, 0.00831403f, 
    0.15542530f, 0.01348945f, 0.35108653f, 0.20399992f, -1.15385544f, 0.51922315f, -0.24959372f, -0.61365211f, 
    0.16672240f, 0.08290438f, -0.01640261f, -0.04610780f, 0.22280182f, -0.07083464f, -0.18984804f, -0.07625228f, 
    -0.01725494f, 0.05697675f, -0.07392066f, 0.18538903f, -0.26563278f, 0.00962356f, 0.11126551f, 0.13596646f, 
    0.18088163f, 0.05300092f, 0.26063567f, 0.06379273f, -0.19883852f, -0.03950724f, -0.06532408f, 0.02880834f, 
    0.01866093f, 0.14136901f, -0.14824016f, -0.02783831f, 0.00935778f, 0.22114061f, 0.11843822f, -0.04911996f, 
    -0.23258901f, 0.22624466f, 0.23964660f, 0.00528711f, 0.02280546f, 0.02510799f, -0.11980139f, 0.14894420f, 
    0.13931876f, -0.12504382f, -0.07297022f, -0.30773893f, -0.26164311f, -0.20108309f, -0.05088724f, -0.28842625f, 
    0.31529090f, -0.08269944f, -0.01067946f, 0.16647941f, 0.03897989f, 0.25781313f, 0.01661378f, 0.23625320f, 
    0.39096805f, 0.25050724f, -0.05164446f, -0.01278214f, -0.07435673f, 0.16005099f, -0.02673651f, -0.08995210f, 
    0.19806409f, 0.04851501f, 0.02035722f, 0.11464602f, -0.08021331f, 0.03594726f, 0.02760136f, -0.06641567f, 
    -0.11970655f, 0.26744425f, 0.05380938f, 0.02319005f, 0.16026276f, -0.13106003f, -0.17286743f, -0.15434380f, 
    -0.98028153f, -0.88008285f, -0.44118479f, -0.36574835f, 0.12041581f, -0.26689583f, -0.48281085f, -0.24008237f, 
    0.17330705f, -0.38612497f, -0.13561991f, -0.08114394f, 0.46348572f, 0.34780389f, -0.09256758f, -0.19944394f, 
    0.30460802f, 0.15719807f, 0.02409841f, 0.32815346f, -0.15981531f, 0.05988812f, 0.30532104f, -0.02958219f, 
    -0.68889511f, -0.51759601f, 0.12805316f, 0.27101243f, 0.24698234f, -0.11061870f, 0.07858241f, -0.06346776f, 
    -0.02882307f, 0.30430707f, 0.17733765f, -0.01109892f, 0.23198181f, -0.10077848f, -0.01691326f, -0.16216481f, 
    -0.31037790f, 0.12704541f, 0.00186561f, -0.13671789f, 0.07277451f, -0.21128941f, -0.20598632f, -0.30329743f, 
    0.42473972f, 0.17289697f, -0.12998621f, -0.38309041f, -0.04391194f, 0.07661974f, 0.01661953f, 0.22729142f, 
    -0.14822550f, -0.04181662f, 0.16710338f, 0.12560759f, -1.29121363f, -0.48202142f, 0.10519686f, -0.08000823f, 
    0.05987837f, 0.02103223f, 0.23488517f, -0.34683892f, 0.07224306f, 0.07065731f, -0.11032446f, 0.22564641f, 
    0.08969887f, 0.40289024f, -0.21975030f, -0.07000421f, 0.04594292f, -0.81473494f, 0.03739114f, -0.12067738f, 
    0.08020178f, 0.13457030f, 0.05487583f, 0.00975328f, -0.28339380f, 0.07171457f, 0.29081342f, 0.11744476f, 
    0.41181213f, -0.23677251f, 0.20484558f, -0.26794913f, 0.27260956f, 0.16959096f, 0.03076037f, 0.11162735f, 
    -0.54743600f, -0.42092955f, 0.30358073f, -0.39913645f, 0.16179875f, 0.18923536f, 0.05357249f, -0.04040767f, 
    -0.06746565f, -0.06999711f, -0.39866233f, -0.27452907f, 0.21725738f, -0.25141564f, 0.21484898f, -0.14533995f, 
    -0.14380585f, -0.04195496f, -0.13946511f, 0.21735278f, -0.07058484f, -0.08408777f, -0.06508018f, -0.03016431f, 
    -0.05013913f, -0.16828978f, 0.05086572f, 0.09889105f, 0.03107431f, 0.09214353f, -0.03530842f, 0.06335370f, 
    -0.02595403f, 0.15922843f, -0.11661084f, 0.10391615f, 0.22339749f, -0.50998777f, -0.15767016f, 0.19844201f, 
    0.06170618f, 0.12146272f, -0.06357381f, -0.02892703f, -0.06970851f, 0.07695046f, -0.17586266f, 0.04242786f, 
    -0.32282248f, 0.09804591f, -0.28844976f, -0.04815927f, -0.03665768f, 0.06541330f, -0.13911587f, -0.06370167f, 
    0.04180408f, -0.09083930f, 0.18023948f, 0.19272740f, 0.73169374f, -0.10068422f, -0.50011301f, 0.28157523f, 
    -0.01769039f, -0.13355847f, -0.06118836f, -0.02857726f, 0.25637347f, -0.02067531f, 0.07098201f, -0.06744567f, 
    -0.12768599f, 0.29341733f, -0.01888486f, 0.03116311f, -0.24274744f, -0.09306220f, 0.08626812f, -0.11951838f, 
    0.09612998f, 0.17422497f, 0.16022170f, -0.30020979f, -0.77112514f, -0.64907831f, -0.27803770f, -0.38306284f, 
    0.01347422f, 0.06916989f, 0.09228645f, 0.25919613f, -0.07670118f, 0.12617119f, -0.00098032f, -0.03437182f, 
    0.06714272f, -0.50531250f, 0.27458495f, -0.22706045f, 0.13709831f, 0.14317030f, 0.00448697f, -0.03899216f, 
    0.24222822f, -0.26332703f, -0.00260190f, 0.00777553f, -0.52467179f, 0.50169313f, 0.25742820f, -0.20969157f, 
    -0.32382455f, 0.07357831f, 0.01036891f, -0.05613038f, 0.09003531f, -0.00184381f, -0.00753333f, -0.16674668f, 
    0.85353065f, 0.06509136f, 0.13606031f, 0.17729959f, 0.24355017f, -0.28103763f, 0.02864691f, -0.02593553f, 
    -0.00974003f, 0.03570144f, 0.11089054f, 0.24602588f, -0.29790476f, -0.02031638f, -0.14047192f, 0.07326562f, 
    0.01724395f, -0.22109380f, -0.03420034f, -0.05371805f, -0.12808770f, 0.11465089f, 0.07509463f, -0.19417198f, 
    -0.24703467f, 0.04494737f, -0.44583142f, 0.17549443f, 0.16699131f, -0.02827704f, 0.16922314f, 0.16270584f, 
    -0.07354921f, -0.11555596f, -0.26389483f, -0.16659755f, -0.12843193f, 0.71408403f, 0.00890920f, -0.38514116f, 
    0.13318834f, 0.12777209f, -0.06567551f, 0.11531899f, -0.12909812f, -0.21416607f, 0.08600235f, -0.14848451f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19063057f, 0.14356948f, -0.09361473f, -0.07207898f, 0.00651054f, 0.08615951f, -0.03990817f, -0.18299784f, 
    -0.06040444f, 0.10333895f, 0.31067532f, -0.00746841f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
