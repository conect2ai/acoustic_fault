#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.15778519f, 0.29045981f, 0.22497453f, 0.20113984f, 0.22834055f, 0.19609050f, -0.02004005f, 0.03595484f, 
    0.20639291f, -0.16934818f, 0.11046164f, -0.01705092f, -0.15407008f, 0.19469705f, 0.00108641f, 0.23106809f, 
    -0.16738556f, 0.22283864f, -0.14985614f, -0.03423887f, -0.19980742f, 0.14871995f, 0.24606964f, -0.13514452f, 
    -0.05779553f, 0.16594172f, 0.26740277f, -0.29928976f, 0.10975464f, -0.16333205f, -0.06000765f, -0.31881666f, 
    0.06924805f, -0.33962774f, -0.18362834f, 0.40592244f, -0.22747192f, 0.17136955f, 0.28131214f, 0.03928656f, 
    -0.19231580f, 0.04386012f, 0.26579541f, -0.18982345f, -0.26946014f, -0.08444148f, 0.08114631f, 0.03432735f, 
    0.27841651f, 0.15928979f, 0.60518706f, -0.13856916f, 0.02766944f, -0.59948498f, -0.43614846f, 0.17715731f, 
    0.16530716f, 0.39342728f, -0.15606982f, -0.25483370f, -0.24742548f, -0.26623964f, 0.30623409f, -0.09067204f, 
    -0.11255886f, 0.14207856f, -0.09005098f, -0.19502734f, -0.03150106f, -0.06809746f, 0.10089641f, -0.32692304f, 
    -0.50574368f, -0.53272474f, -0.29167157f, 0.33568299f, -0.82017827f, 0.11378568f, 0.06365829f, 0.49300557f, 
    -0.69310248f, -0.04572982f, 0.41537699f, 0.12542069f, -0.14906086f, -0.16999002f, -0.11342447f, 0.38898739f, 
    -0.36459383f, -0.15071525f, 0.02090494f, 0.03936561f, 0.23559497f, -0.00631227f, -0.29704708f, -0.06678530f, 
    -0.22342336f, 0.11820573f, 0.03529538f, 0.10158217f, 0.58701617f, 0.17099544f, 0.16931476f, -0.07121495f, 
    -0.10353503f, -0.34302244f, 0.27158144f, 0.34354034f, -0.22527628f, 0.05424263f, -0.25941712f, 0.36451933f, 
    -0.13528936f, 0.15598936f, -0.18467492f, 0.15248471f, -0.13091308f, -0.30075726f, -0.13606070f, 0.05749588f, 
    0.20149681f, 0.10611179f, 0.31121132f, -0.20871414f, -0.34523490f, -0.31635922f, 0.01015250f, -0.30512843f, 
    -0.11292358f, -0.66317576f, -0.42544636f, -0.57795542f, -0.49495047f, -0.62436628f, -0.74508911f, -0.05353032f, 
    0.13269654f, -0.03016843f, -0.38250557f, -0.15459153f, 0.17029205f, -0.38658282f, 0.05943345f, 0.04865664f, 
    -0.19728716f, -0.14479852f, 0.16429663f, -0.26202139f, -0.13567279f, 0.20422584f, -0.29011461f, -0.20582995f, 
    0.11658364f, 0.29885998f, 0.27274317f, -0.10835107f, 0.12170132f, 0.29734397f, 0.01568625f, 0.08739628f, 
    -0.07646286f, -0.12797573f, 0.08588135f, -0.13991283f, 0.29463449f, -0.09475203f, -0.21390471f, -0.02475885f, 
    -0.13603434f, 0.02260536f, 0.12766999f, 0.24405287f, -0.15065718f, 0.06975208f, -0.04676411f, -0.28021851f, 
    -0.19380535f, 0.08003180f, 0.32474926f, 0.36782697f, -0.12491596f, -0.60893685f, -0.38142303f, -0.06678573f, 
    -0.06442109f, 0.10991751f, 0.02316581f, -0.06833576f, -0.00593270f, 0.37112328f, -0.22663553f, -0.01652680f, 
    0.11564007f, 0.19148751f, 0.22261183f, 0.19836244f, 0.14621137f, -0.15781993f, -0.09051685f, 0.08240870f, 
    -1.13136137f, -0.04198664f, -0.62673271f, -0.00656789f, 0.55254680f, -0.36771375f, 0.20503145f, 0.11343864f, 
    0.40858760f, 0.40489566f, 0.28391409f, 0.19122437f, -0.16818473f, 0.37272173f, 0.01440337f, -0.10379095f, 
    -0.04297045f, 0.09311280f, -0.03672164f, -0.24476227f, 0.08121600f, -0.02977328f, 0.08018962f, 0.17753753f, 
    -0.21980254f, -0.83839285f, -0.50145549f, -0.22420146f, 0.34593382f, 0.41812912f, 0.51070666f, 0.16053756f, 
    -0.08145860f, -0.20720762f, -0.22774024f, 0.10502304f, 0.21809556f, 0.42704454f, -0.27119488f, -0.12645069f, 
    -0.38058385f, -0.06403910f, 0.08568871f, 0.00333924f, 0.13091275f, 0.16128048f, 0.23916352f, -0.03063414f, 
    0.00812219f, -0.09556837f, -0.37973675f, 0.48820949f, -0.23693551f, 0.30077878f, -0.19523567f, -0.50178409f, 
    0.05423510f, 0.39257765f, 0.24476579f, -0.03085738f, -0.43056342f, 0.31346673f, -0.08297132f, 0.56547290f, 
    -0.23892908f, -0.03601204f, -0.06517056f, -0.22026964f, -0.27094662f, 0.26170573f, 0.03004912f, -0.19077775f, 
    -0.09707529f, 0.38790867f, -0.22669779f, -0.95942593f, 0.26660457f, 0.30350560f, -0.16265185f, 0.02677310f, 
    0.04767310f, 0.15488143f, 0.16881055f, 0.36980674f, 0.07109282f, -0.21754235f, -0.09080987f, -0.05324056f, 
    0.34930053f, -0.28319088f, 0.34256330f, -0.20823076f, -0.31865817f, -0.23022486f, 0.12701105f, -0.19405085f, 
    0.26100037f, 0.27229035f, -0.08885354f, 0.14219147f, -0.52137470f, -0.14847314f, -0.06589115f, -1.01441145f, 
    -0.72408384f, 0.23140801f, 0.23442474f, 0.30879635f, 0.34429148f, 0.30504677f, 0.08235034f, -0.04345807f, 
    0.12011594f, -0.23592089f, -0.21257457f, 0.11643927f, -0.16499189f, 0.13378954f, 0.04538750f, 0.02336781f, 
    -0.12306509f, -0.02955608f, -0.20865059f, -0.13911919f, -0.13498563f, 0.21143319f, 0.46645442f, 0.28232101f, 
    -0.41869983f, -0.49002424f, -0.34058747f, 0.10722330f, 0.36844721f, -0.10387733f, 0.16622525f, -0.35542011f, 
    -0.00210067f, 0.18336721f, -0.32434243f, 0.43642968f, -0.09376716f, 0.40901312f, -0.06196585f, -0.26665756f, 
    0.00412317f, 0.13498154f, 0.01188075f, -0.22679086f, 0.07488549f, -0.19904651f, -0.72572160f, -0.11762790f, 
    0.45560062f, -0.51574349f, -0.24187286f, -0.02698376f, 0.09546334f, 0.41693944f, -0.00103075f, 0.38347539f, 
    -0.44990802f, 0.03512448f, -0.19647586f, 0.13792191f, 0.09729470f, 0.19000708f, 0.24562916f, 0.11368811f, 
    -0.03534124f, -0.04990579f, -0.08278643f, 0.20405529f, -0.07741509f, -0.36328816f, 0.03039517f, -0.25391394f, 
    0.32894453f, -0.05950603f, 0.08270463f, -0.06620899f, -0.44819260f, 0.39816338f, 0.21477596f, 0.11685316f, 
    -0.16528399f, -0.33970568f, 0.44641265f, 0.29838708f, -0.17493500f, -0.30636165f, -0.17997620f, 0.13497898f, 
    0.03855912f, 0.17321287f, -0.13086511f, 0.14409326f, 0.27200145f, 0.00163601f, -0.24456370f, -0.21895207f, 
    -0.17695571f, -0.61895287f, 0.00356453f, -0.03565436f, -0.09417171f, 0.06529938f, -0.16308904f, 0.00682050f, 
    0.24208546f, 0.02641924f, -0.13982226f, -0.33102947f, -0.30819318f, 0.25827131f, 0.32939026f, -0.12834658f, 
    0.26608986f, -0.24701412f, -0.15526609f, 0.17067660f, 0.20431563f, 0.10559411f, 0.28165126f, 0.03881906f, 
    -0.27681684f, 0.61536282f, 0.10162176f, -0.25547808f, -0.32590938f, -0.05665001f, 0.36014411f, 0.36641967f, 
    0.05709558f, 0.01548933f, -0.76797044f, -0.20593373f, -0.18094313f, 0.08235880f, 0.11644253f, -0.10701784f, 
    -0.17933014f, -0.24873488f, 0.33019224f, -0.19384080f, 0.09106241f, 0.26651627f, -0.17477158f, -0.20346129f, 
    -0.09364829f, 0.11966679f, -0.38201079f, -0.16010688f, 0.19083491f, 0.11311087f, 0.30944139f, 0.08209304f, 
    0.17191856f, 0.25812387f, 0.08725255f, 0.07637706f, -0.19912915f, -0.20163926f, 0.27146181f, -0.10379452f, 
    0.09517247f, -0.26706290f, -0.29075485f, 0.33060706f, 0.27820098f, -0.11065619f, -0.27587441f, -0.38055614f, 
    0.18946187f, 0.46485299f, -0.03648457f, -0.66746593f, 0.14344153f, 0.55709851f, 0.24537939f, 0.11310407f, 
    0.17584628f, -0.55985922f, -0.18592118f, -0.03302065f, 0.30992469f, -0.18097261f, -0.47017783f, -0.03984418f, 
    0.37157828f, 0.28588101f, -0.11429515f, -0.17006643f, -0.09175717f, 0.05967906f, 0.17574692f, -0.05872777f, 
    -0.05203837f, -0.28409943f, 0.18036102f, -0.09572697f, -0.49253678f, -0.68295527f, -0.40740559f, -0.24448612f, 
    -0.23990135f, -0.42839280f, -0.36486873f, -0.38048637f, -0.47698009f, -0.16844073f, 0.23274270f, -0.07140551f, 
    -0.16067430f, -0.02753073f, -0.50175744f, -0.00867492f, -0.13553745f, 0.05643901f, 0.03856723f, 0.14579344f, 
    -0.29888028f, -0.29559657f, -0.40105030f, -0.27673221f, -0.01576160f, 0.54808325f, 0.74175555f, -0.13274580f, 
    -0.45407179f, -0.67312235f, -0.39195621f, -0.08048446f, 0.24910149f, 0.05464599f, -0.04448769f, -0.21923979f, 
    -0.08954789f, 0.28932369f, 0.60902476f, -0.04817110f, 0.12217993f, -0.15733841f, -0.34803057f, 0.25186709f, 
    -0.44608256f, 0.29502288f, 0.02272470f, -0.09394854f, 0.36885649f, -0.07559697f, -0.73874271f, -0.41977414f, 
    0.05036972f, 0.85897839f, 0.84709018f, -0.28446457f, -0.52255607f, -0.57873452f, -0.26215541f, 0.02879694f, 
    -0.06474125f, 0.09608548f, -0.45674634f, 0.06610668f, -0.22425212f, 0.14293809f, 0.00171249f, 0.05860416f, 
    0.01192578f, -0.04564897f, -0.12737587f, 0.26932412f, -0.02137253f, 0.09567261f, 0.07480589f, 0.14284764f, 
    0.46921134f, -0.11829669f, -0.12114679f, -0.28074294f, -0.54823136f, -0.40026340f, -0.16898772f, -0.58255333f, 
    -0.66107208f, 0.11714116f, -0.31951141f, 0.36166269f, 0.00802145f, 0.10919487f, 0.18236277f, -0.17309259f, 
    -0.08166002f, -0.00196586f, 0.00421183f, -0.34660038f, -0.07306557f, 0.14228357f, 0.18849857f, 0.11216708f, 
    0.31021520f, -0.93712348f, -0.33286780f, 0.20425588f, 0.43810758f, 0.46359959f, 0.67201209f, 0.11019021f, 
    -0.30874345f, -0.45510882f, -0.31334919f, -0.44618458f, -0.09322092f, 0.07115369f, 0.26496574f, 0.24921490f, 
    0.08638500f, -0.18644923f, 0.06077976f, 0.02604199f, -0.19588366f, -0.30586255f, 0.20769590f, 0.28957677f, 
    -0.14009105f, -0.45746297f, 0.09113202f, -0.05055417f, -0.07068549f, 0.17618801f, -0.00707192f, 0.01089704f, 
    -0.20558584f, 0.22791646f, 0.39780164f, 0.29315382f, -0.09633175f, 0.02315743f, -0.05421749f, -0.07788528f, 
    -0.23997325f, -0.02097380f, 0.14268182f, -0.11613896f, -0.36074540f, 0.14305669f, 0.33526096f, 0.22525041f, 
    0.00598818f, 0.26815200f, 0.02449064f, -0.08515794f, 0.02996602f, -0.04951771f, 0.26659605f, 0.36153704f, 
    -0.12790069f, -0.08065139f, -0.03890899f, 0.23463689f, -0.05186856f, 0.13826209f, -0.09353363f, 0.21157102f, 
    -0.02080315f, 0.22813731f, -0.22023951f, -0.15411560f, 0.11139708f, -0.38705453f, -0.30109465f, 0.31335449f, 
    0.06260920f, 0.13874537f, 0.12100480f, 0.18067634f, 0.88861799f, 0.20691626f, -0.47235021f, 0.25190467f, 
    -0.33588332f, -0.39033738f, -0.04103116f, -0.01062602f, -0.07728461f, -0.09613573f, 0.17955397f, 0.35022742f, 
    -0.21827106f, -0.15587427f, -0.23393057f, -0.00048907f, 0.21585512f, 0.34324139f, -0.18958245f, -0.08544967f, 
    0.09352896f, -0.15524878f, -0.08033269f, 0.07424147f, 0.01517615f, 0.45383129f, 0.02030886f, 0.34726775f, 
    -0.56005895f, -0.64413500f, -0.57379478f, -0.24244419f, 0.13525341f, 0.32624429f, 0.34151733f, 0.21459015f, 
    -0.04251599f, 0.26495069f, -0.37399659f, 0.10222419f, 0.13761346f, 0.07881389f, -0.02532204f, -0.24328707f, 
    -0.09603351f, -0.01920999f, 0.19043145f, -0.18785924f, 0.14569362f, -0.52668655f, -0.58189201f, 0.21639051f, 
    -0.03054490f, 0.05046389f, 0.25205350f, 0.57196927f, -0.46906617f, -0.12005807f, 0.45336294f, 0.06678253f, 
    -0.13725717f, -0.08976267f, 0.03253238f, -0.43011025f, -0.25242686f, -0.27611566f, -0.07533729f, 0.43073773f, 
    0.19750243f, 0.04674315f, -0.26399609f, 0.25977430f, 0.17342252f, -0.03637578f, -0.43526906f, -0.57664496f, 
    -0.28689897f, 0.01327184f, -0.32995230f, -0.90987104f, -0.90369290f, -0.56753588f, -0.28015462f, -0.67674601f, 
    0.51228070f, 0.00095203f, -0.09247923f, 0.08728303f, 0.29499200f, -0.04144022f, 0.04953360f, 0.09512147f, 
    -0.08051617f, -0.11622323f, -0.08783783f, 0.26359430f, -0.05018463f, 0.23414993f, 0.31249434f, -0.43437594f, 
    0.44027248f, -0.32889512f, -0.15089233f, 0.00545557f, -0.30885315f, -0.11463410f, -0.00685388f, 0.12431585f, 
    0.06722096f, 0.22336204f, 0.20992869f, 0.21947050f, 0.06011402f, -0.17758419f, 0.18615016f, -0.08745462f, 
    -0.03456056f, -0.04609661f, -0.22205359f, -0.18562342f, -0.15778598f, -0.33330229f, -0.23778076f, -0.28449038f, 
    -0.23365791f, 0.20153844f, 0.29455352f, -0.36500758f, -0.91075492f, -0.02932622f, 0.18826100f, -0.03167449f, 
    0.15823239f, -0.40587008f, 0.36012408f, -0.15079193f, 0.32319161f, 0.19226214f, 0.21505702f, 0.01832737f, 
    -0.01691341f, -0.17013238f, -0.37164870f, -0.24708897f, -0.06046944f, -0.13982850f, 0.54266840f, -0.13197890f, 
    -0.17926563f, 0.42654034f, 0.45917210f, -0.14952835f, -0.07657114f, 0.21173318f, -0.32121491f, -0.31638503f, 
    -0.06760391f, -0.14123841f, 0.07480521f, -0.13083732f, -0.18175365f, 0.10012922f, 0.36573011f, 0.04243524f, 
    -0.20880508f, 0.16536008f, 0.12464253f, 0.11098124f, -0.44280079f, -0.28787383f, 0.17188166f, 0.14570881f, 
    0.39378619f, -0.21999185f, -0.07286648f, 0.05904936f, -0.39864343f, -0.12998991f, -0.00564935f, 0.23459391f, 
    0.30163589f, 0.08138055f, -0.14738254f, 0.49963614f, -0.17885822f, 0.11566520f, -0.19230741f, -0.38852322f, 
    -0.22586855f, 0.06671593f, -0.02956958f, 0.24037753f, -0.21492232f, -0.04034407f, -0.35692939f, -0.14737093f, 
    0.16186170f, -0.37217799f, -0.26885021f, -0.23131242f, -0.16675855f, 0.24906689f, 0.37010023f, 0.30723619f, 
    0.37768713f, 0.29834834f, 0.13278183f, 0.21925758f, -0.06327768f, 0.14139590f, 0.10218231f, 0.16208543f, 
    -0.16404493f, -0.27665311f, -0.10449146f, 0.03693121f, -0.04878604f, 0.03613167f, -0.27021161f, -0.03095150f, 
    0.19547369f, -0.11276448f, 0.09781709f, -0.22800092f, 0.57158339f, 0.37775588f, -0.47923204f, -0.39980775f, 
    -0.48558125f, -0.15282010f, 0.05670663f, 0.27578229f, 0.41814500f, 0.11821584f, 0.09291361f, -0.17952003f, 
    -0.04521012f, -0.09472705f, -0.28132409f, 0.12286998f, -0.05641850f, -0.25406885f, 0.27449045f, -0.08530340f, 
    0.02410489f, 0.19013444f, 0.07856164f, -0.32768866f, 0.38853469f, 0.94984156f, 0.65927202f, -0.25785726f, 
    -0.29379985f, 0.08034842f, 0.07881130f, -0.34852743f, -0.07025120f, 0.22701131f, -0.49390817f, 0.14458455f, 
    0.08269507f, -0.14600100f, -0.32490069f, -0.07786119f, 0.07079186f, 0.19232693f, 0.11453236f, -0.23644824f, 
    0.05702340f, -0.08088118f, -0.05588630f, -0.11325289f, 0.14194208f, -0.18103892f, -0.03834876f, -0.47930709f, 
    -0.86330187f, -0.47502849f, 0.06049376f, 0.10516843f, 0.06983372f, 0.57906538f, -0.21296103f, -0.16141994f, 
    -0.60653764f, -0.36487341f, -0.44716212f, 0.03175190f, 0.11912712f, 0.00062743f, -0.08388025f, 0.03415469f, 
    0.12479086f, 0.04389341f, -0.02733905f, -0.10089089f, -0.17986098f, -0.40981773f, -0.41824082f, 0.54026842f, 
    -0.32042760f, -0.09498908f, -0.22995995f, -0.15997893f, 0.00968134f, 0.01004751f, -0.48615423f, -0.15705259f, 
    -0.23267961f, 0.23273769f, 0.04583677f, 0.21927474f, 0.10065128f, 0.16831803f, -0.10224561f, 0.18205540f, 
    0.11550420f, -0.13142937f, -0.25448897f, -0.32802442f, -0.21508351f, -0.08798914f, -0.14479621f, -0.22532502f, 
    0.10052403f, -0.10029344f, 0.11567707f, -0.06860647f, 0.04643415f, -0.08121878f, 0.34706441f, -0.53146446f, 
    -0.20816012f, 0.39154416f, 0.25150412f, -0.12251395f, 0.17423840f, 0.03762472f, -0.08863471f, -0.11640111f, 
    -0.37559643f, 0.21287368f, 0.17533363f, -0.34572804f, 0.24674767f, 0.16966042f, 0.08510457f, -0.02294410f, 
    -0.27237684f, -0.57897198f, -0.46169192f, -0.28316379f, 0.03798639f, 0.33111596f, 0.40658990f, 0.13089825f, 
    0.39293775f, 0.43047452f, 0.22023796f, -0.09456198f, -0.11051234f, -0.28544953f, 0.02198371f, -0.09386503f, 
    -0.01830716f, 0.09388888f, -0.03459681f, -0.19405764f, -0.27932909f, -0.02048155f, 0.31211627f, -0.08283026f, 
    0.06158573f, 0.23523273f, 0.53417408f, -0.42110226f, -1.04330087f, -0.82603240f, -0.74717444f, 0.72694755f, 
    0.59467429f, 0.70021671f, -0.08966550f, -0.28005591f, -0.13660274f, -0.10699787f, -0.53962946f, -0.33883169f, 
    -0.27595207f, -0.37211257f, -0.16339058f, 0.10302689f, -0.07491693f, -0.38098171f, 0.06748109f, 0.10272693f, 
    -0.06806479f, 0.00997243f, 0.00393579f, -0.09130525f, -0.00161180f, -0.07521869f, -0.26033500f, 0.14583510f, 
    0.31539527f, -0.11974790f, 0.06643593f, 0.08646327f, 0.09029029f, 0.09138309f, 0.24228732f, 0.00606893f, 
    -0.45351255f, -0.18412565f, -0.44002178f, 0.38015732f, -0.55779129f, 0.17302667f, -0.17054287f, 0.22885691f, 
    0.19059916f, 0.15453714f, 0.20684917f, 0.26081461f, -0.36048242f, -0.34372246f, -0.41386455f, -0.21843204f, 
    0.03240036f, 0.16775784f, -0.16844191f, -0.23576549f, -0.31207919f, 0.34796357f, 0.00127133f, 0.18576014f, 
    -0.19036952f, 0.03603182f, -0.32716158f, -0.21635902f, -0.42354661f, -0.18124345f, -0.04468032f, -0.63455856f, 
    0.05662730f, 0.21878152f, 0.29648066f, 0.30945814f, 0.06176751f, 0.67381537f, 0.11795703f, -0.43176717f, 
    0.10483485f, -0.38102344f, 0.59388447f, 0.64953780f, -0.00457495f, -0.23470677f, -0.12540637f, -0.29525766f, 
    -0.17483179f, -0.08796021f, -0.07755287f, -0.19736239f, 0.16761225f, -0.23667113f, -0.10408783f, 0.03783414f, 
    0.02721539f, 0.03982558f, -0.04806823f, -0.03528876f, 0.09021573f, 0.03736831f, -0.38931042f, -0.47740906f, 
    -0.50426328f, -0.53743207f, -0.52612579f, 0.52248925f, -0.02451866f, -0.04875586f, 0.18980145f, 0.42199317f, 
    0.20016654f, 0.14264315f, -0.20185994f, 0.26915964f, -0.36798590f, -0.05260943f, 0.05927818f, -0.14161313f, 
    0.29249072f, 0.10917978f, -0.07697989f, 0.09437517f, 0.12195496f, -0.22102620f, -0.41631833f, 0.43281442f, 
    -0.14985237f, -0.64587015f, -0.78277016f, -0.49728468f, -0.36117935f, -0.21764822f, 0.34944722f, -0.01851951f, 
    0.15494825f, 0.32652298f, 0.14363676f, 0.43468320f, -0.03100152f, 0.00727427f, 0.16931781f, 0.00499321f, 
    -0.28064778f, 0.01622490f, 0.07343266f, 0.19691303f, -0.14354013f, -0.32287118f, 0.01420793f, 0.04991579f, 
    -0.66454792f, -0.75026131f, -0.35612381f, 0.16481261f, -0.50095713f, 0.59682101f, -0.05961481f, 0.15189941f, 
    0.31990883f, 0.61725509f, -0.02626457f, -0.16379400f, 0.26594290f, 0.05146360f, 0.12286510f, -0.02536508f, 
    0.07183928f, -0.08505417f, -0.15438136f, 0.08428998f, -0.05704807f, -0.02096145f, -0.00713077f, -0.02129837f, 
    0.03310667f, -0.01652402f, -0.20552041f, 0.10113537f, 0.41501755f, -0.17448945f, -0.11411681f, -0.76841706f, 
    0.25720739f, 0.08472425f, 0.35226294f, 0.08965804f, 0.13455653f, -0.38432625f, -0.23904657f, 0.28299513f, 
    -0.25875565f, 0.02975227f, -0.17125630f, -0.08399883f, 0.40254506f, -0.23604882f, 0.14506903f, -0.09358062f, 
    0.19864219f, -0.07814419f, -0.92742258f, -0.65153897f, -0.44134077f, -0.69270957f, -0.39622414f, 0.06139971f, 
    0.18307419f, -0.53447849f, -0.34939271f, 0.81387228f, -0.03399048f, -0.29556006f, -0.39892778f, -0.19970630f, 
    -0.12011084f, 0.14079522f, 0.45285463f, -0.13907680f, -0.15056454f, -0.21271840f, -0.03474946f, -0.33442518f, 
    -0.06747440f, -0.03177222f, -0.01270084f, 1.10736775f, 0.30478418f, -0.39320827f, -0.37309590f, -0.68449455f, 
    0.02217380f, 0.03284930f, 0.05410697f, 0.03388620f, 0.13953495f, -0.06754445f, 0.19775946f, 0.21182065f, 
    -0.37480667f, -0.15173835f, 0.13026230f, -0.19412872f, -0.07255842f, 0.00498893f, -0.25571409f, -0.36419776f, 
    -0.30016693f, -0.24360259f, 0.01092081f, -0.14610891f, 0.77297503f, -0.41013008f, -0.16430598f, 0.56266147f, 
    -0.69945800f, 0.18915910f, 0.24687292f, 0.27699167f, -0.09749267f, -0.36589974f, 0.00135750f, -0.02899260f, 
    0.20275518f, -0.25160077f, -0.01463348f, 0.02939205f, 0.07447768f, -0.17820448f, 0.00714949f, 0.21435753f, 
    0.04149394f, 0.05318308f, -0.21943282f, -0.26461661f, 0.10843946f, -0.35275140f, 1.07955968f, 0.49708113f, 
    -0.78042704f, -0.38129798f, -0.73497540f, 0.47924373f, -0.30076709f, -0.69093961f, -0.52008766f, 0.20772730f, 
    -0.04978118f, -0.51271778f, -0.17896444f, 0.29554939f, -0.13708755f, -0.05029536f, 0.05786085f, -0.13957699f, 
    -0.16600849f, 0.12726852f, -0.16142631f, -0.18487155f, -0.34974551f, -0.41840994f, -1.24341488f, -0.61653608f, 
    0.59205103f, -0.35384974f, -0.41964170f, -0.02472524f, 0.49355549f, 0.47469029f, -0.01324902f, -0.06412143f, 
    0.18232428f, 0.13105741f, -0.03065106f, 0.47015157f, -0.25687832f, 0.15372224f, -0.08024277f, -0.11520565f, 
    0.01761634f, 0.08027414f, 0.03372341f, 0.12285253f, 0.22432408f, -0.12325684f, -0.08115143f, 0.36152869f, 
    0.09071968f, -0.16402039f, -0.12723447f, 0.09603683f, 0.12903392f, -0.05936170f, -0.21874617f, -0.27951464f, 
    0.11353033f, -0.19422685f, 0.00953687f, 0.09746454f, -0.16734886f, 0.01855634f, -0.12896076f, 0.22802351f, 
    0.04666608f, 0.04405291f, -0.09214159f, -0.01151049f, -0.27309906f, -0.43331996f, 0.16938449f, 0.16458061f, 
    0.35945445f, 0.17329763f, -0.48194438f, -0.38008320f, -0.90948153f, -0.15531418f, 0.17017524f, 0.38664281f, 
    0.17484540f, 0.33753416f, -0.20574722f, -0.14750309f, -0.24266794f, 0.18862410f, -0.05636592f, 0.15384541f, 
    0.12310690f, 0.37296429f, -0.27613726f, -0.06518108f, -0.20849897f, 0.06330896f, -0.13857257f, 0.01866541f, 
    0.18932442f, 0.35706183f, 0.53809220f, 0.40299106f, -0.36056608f, 0.19299215f, -0.30724910f, -0.04052238f, 
    0.19836585f, -0.03853060f, -0.15630142f, -0.25510558f, -0.17377457f, 0.24948674f, -0.17589189f, -0.30496311f, 
    0.03542591f, -0.18619919f, 0.07361063f, -0.02338639f, -0.05817373f, 0.15600817f, -0.28320968f, -0.31888035f, 
    0.13415216f, -0.29505736f, -0.65033668f, -0.13236859f, -0.01883521f, -0.40230870f, -0.52483344f, 0.27292761f, 
    0.52494204f, -0.30824646f, 0.32650197f, 0.41862553f, -0.11442795f, 0.52805656f, 0.04832284f, -0.28640893f, 
    -0.35698134f, 0.04994345f, -0.16997983f, -0.20347361f, -0.20281915f, 0.12937601f, 0.09284665f, 0.21211660f, 
    0.11904013f, 0.23357593f, -0.16755301f, -0.49215561f, -0.74253190f, -0.47713140f, -0.18308717f, -0.19732177f, 
    0.03205443f, -0.35528940f, -0.05804462f, -0.54094708f, -0.71315277f, -0.08666836f, -0.06597233f, -0.06412170f, 
    0.59206349f, -0.52623761f, 0.27951595f, -0.29438734f, -0.33501816f, 0.25083891f, 0.06224959f, -0.01304761f, 
    0.12102751f, 0.11754537f, -0.15864979f, 0.03258680f, -0.42065978f, -0.58217090f, -0.76031965f, -0.52345490f, 
    -0.49234438f, 0.07266944f, 0.27579623f, 0.22197427f, -0.36579832f, -0.37310410f, 0.19749855f, 0.32097813f, 
    -0.09288586f, -0.20649987f, 0.24951684f, -0.37828320f, -0.32400605f, -0.22660771f, -0.30217963f, -0.16450031f, 
    -0.27667034f, -0.27367726f, 0.16272429f, 0.15093945f, -0.15547220f, -0.54841703f, -0.14974569f, 0.43664348f, 
    -0.67818284f, -0.79368043f, 0.53270048f, 0.22380833f, 0.01476965f, -0.22726408f, -0.17562871f, 0.07856677f, 
    -0.03460763f, 0.18213798f, -0.07669710f, 0.16740707f, -0.03905766f, -0.37948990f, -0.22481009f, 0.20812117f, 
    -0.12467105f, 0.25741592f, 0.41695106f, 0.31787762f, -0.07455672f, -0.02638001f, 0.19726945f, -0.46255925f, 
    0.06941556f, 0.19099042f, 0.32792780f, -0.22397825f, -0.44561711f, -0.45134887f, -0.49403927f, 0.24297573f, 
    -0.05148972f, -0.17069863f, 0.29349276f, 0.37094641f, 0.29319209f, 0.13186114f, 0.07316881f, -0.26783925f, 
    0.09707361f, -0.09040187f, -0.17898674f, 0.03456957f, 0.13725904f, -0.15906107f, -0.29694095f, -0.54570341f, 
    0.32282618f, 0.25213641f, 0.06680473f, 0.18531880f, -0.02893783f, 0.09355026f, 0.14048912f, 0.12501186f, 
    -0.09392947f, -0.32011843f, -0.14007214f, 0.11723383f, 0.12540673f, 0.04391241f, 0.06867561f, 0.16133918f, 
    0.14741725f, 0.07193536f, -0.17237425f, 0.07122782f, -0.10568406f, 0.04782491f, -0.36003387f, -0.14797314f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.20913215f, 0.00689234f, 0.11596115f, 0.33421931f, 0.13347690f, -0.29837817f, -0.02146542f, 0.06240612f, 
    0.18800652f, 0.17829663f, 0.12532784f, 0.18785472f, -0.00153647f, 0.28038812f, 0.03543049f, 0.14485833f, 
    -0.06957512f, 0.07115231f, 0.07302417f, 0.20280398f, -0.47927257f, 0.19051141f, 0.11276343f, 0.14666444f, 
    0.05766781f, -0.16739199f, -0.01862973f, 0.15659134f, 0.01219837f, 0.05876478f, 0.01694429f, -0.12453918f, 
    -0.05146256f, 0.06830574f, -0.16065001f, -0.15254167f, 0.17170127f, 0.52128047f, -0.35464054f, -0.21197169f, 
    -0.04956968f, -0.12165833f, -0.35648289f, 0.20220408f, -0.25538415f, 0.20779252f, -0.15277283f, 0.42940661f, 
    0.00307573f, 0.22025263f, -0.12099611f, 0.16555491f, 0.15250367f, -0.06683180f, -0.09304577f, 0.04292195f, 
    0.13604757f, 0.03825464f, 0.07376789f, -0.21179858f, -0.16097714f, -0.09246397f, -0.00616599f, 0.04367140f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.06418286f, -0.03765867f, 0.03495482f, 0.02375286f, 0.01864348f, 0.00046963f, 0.02821122f, 0.03651638f, 
    -0.04301489f, 0.04410272f, -0.05270052f, -0.00988934f, 0.07160495f, 0.04200075f, -0.01476929f, 0.01131656f, 
    -0.06249891f, -0.03626167f, -0.11976707f, -0.16683130f, 0.00973765f, 0.01079209f, -0.05768776f, 0.00705552f, 
    -0.14360972f, -0.31255758f, -0.03271711f, -0.03361839f, 0.03914098f, 0.05676596f, -0.16773039f, 0.00340439f, 
    0.10910030f, 0.05509283f, 0.01347841f, 0.03702016f, -0.16951250f, -0.26481950f, -0.00415484f, -0.19781972f, 
    -0.09814931f, -0.02668818f, 0.05291822f, 0.01575511f, -0.02201577f, -0.09416272f, -0.02380555f, 0.04185669f, 
    -0.47519344f, -0.47231147f, -0.04875549f, 0.10748950f, 0.02511522f, 0.01032180f, -0.01594451f, 0.01377877f, 
    0.05346257f, -0.00317933f, -0.06852155f, -0.02051824f, 0.26099157f, 0.33081257f, -0.12570959f, -0.15989134f, 
    0.15042160f, 0.07128122f, 0.05020219f, 0.02310545f, 0.00187448f, 0.01658439f, 0.00388401f, 0.06113049f, 
    -0.24904990f, -0.08359945f, -0.02168366f, -0.04461818f, 0.02641115f, 0.02143079f, 0.03983228f, 0.01937589f, 
    0.02259443f, -0.03972992f, 0.06903917f, -0.06676176f, 0.10185359f, 0.23002231f, 0.02423309f, -0.10013255f, 
    -0.14803608f, -0.04999742f, 0.09509409f, 0.13028817f, 0.04594061f, -0.01078650f, 0.02860943f, -0.03741675f, 
    0.00084957f, 0.21060644f, 0.10876944f, 0.01739988f, 0.06876602f, 0.07880299f, 0.05261978f, 0.02031389f, 
    0.00484170f, -0.00059598f, -0.15022916f, -0.04707113f, 0.16254589f, 0.17319569f, 0.10457242f, -0.04572158f, 
    -0.04044979f, 0.02357104f, 0.03540492f, -0.06059666f, -0.11211628f, -0.23871002f, 0.02458805f, -0.10548083f, 
    -0.22403951f, -0.33088824f, 0.06645918f, 0.02524229f, 0.00966158f, -0.05204133f, 0.02485481f, 0.03353597f, 
    -0.02365717f, -0.08252774f, -0.11235018f, 0.10348672f, -0.37796310f, -0.11006067f, 0.13575077f, -0.34661868f, 
    -0.08846582f, -0.04590670f, 0.06471501f, -0.04608038f, -0.12245864f, 0.03725231f, -0.17033729f, -0.11946369f, 
    -0.04558700f, -0.09419428f, 0.02360690f, 0.00642028f, 0.15737364f, 0.24230605f, -0.08016773f, 0.06265563f, 
    0.04528771f, 0.02693382f, -0.03431449f, -0.01237414f, -0.43393067f, -0.23829903f, 0.17452373f, 0.13487783f, 
    0.00391907f, 0.04130331f, -0.10438641f, -0.07606953f, 0.01659291f, -0.11268354f, -0.10293934f, -0.20565495f, 
    -0.02117358f, 0.00982696f, 0.16583191f, -0.01602081f, 0.02827506f, 0.11027580f, -0.01773038f, 0.05667537f, 
    -0.04729645f, 0.08267077f, -0.03299654f, -0.01019319f, -0.30868813f, -0.15092517f, 0.06059114f, 0.00359696f, 
    -0.01087343f, -0.19343208f, -0.14880197f, -0.03698369f, -0.13826007f, 0.06328312f, 0.05083640f, -0.02986881f, 
    0.19252183f, 0.04358194f, 0.10356271f, -0.07824944f, 0.05405031f, 0.10869863f, -0.02044875f, -0.01770077f, 
    -0.05823182f, 0.01457832f, -0.02109234f, 0.00464813f, -0.15763965f, -0.47328761f, -0.50814688f, 0.06328536f, 
    0.02748122f, 0.02307606f, 0.01299456f, -0.01457444f, 0.00119507f, 0.02675921f, 0.01749498f, -0.11600788f, 
    -0.14982562f, -0.16006134f, -0.02079564f, 0.03926323f, 0.01012991f, -0.03094910f, 0.07113601f, -0.00489934f, 
    0.11300377f, -0.15471348f, 0.04403893f, 0.05923223f, -0.33467737f, 0.06527460f, 0.05605376f, -0.33080968f, 
    0.08313051f, -0.10307801f, 0.01697617f, 0.07283341f, 0.03910941f, 0.01254782f, -0.00867214f, 0.04011971f, 
    0.32178810f, 0.20780233f, 0.01848094f, -0.16897836f, 0.19140497f, 0.10889708f, 0.12342758f, 0.15886608f, 
    -0.03024418f, -0.06290708f, -0.03917022f, -0.06127884f, 0.04185371f, -0.24922557f, 0.02096314f, 0.08232598f, 
    -0.00282402f, -0.16989607f, -0.07968476f, -0.23248781f, -0.04117798f, -0.11310432f, -0.14264035f, -0.02093739f, 
    0.38177267f, 0.25411353f, -0.00880183f, -0.37730268f, 0.09848260f, 0.00794960f, -0.00442349f, -0.20451002f, 
    -0.03788655f, -0.04022189f, -0.03375371f, -0.02877260f, 0.13112755f, -0.01352708f, -0.09533597f, -0.22308241f, 
    0.06488242f, -0.13202269f, 0.03430830f, 0.06016095f, -0.02907006f, 0.05483813f, -0.06529812f, -0.00045634f, 
    0.45883390f, -0.36567312f, -0.00947756f, -0.06790545f, -0.01861943f, -0.02497577f, 0.13025492f, -0.09897069f, 
    -0.06436118f, 0.08128442f, -0.02930701f, 0.17397055f, -0.04835834f, 0.02437910f, 0.09518488f, 0.05963639f, 
    -0.25462106f, 0.02115277f, 0.01013154f, -0.01366409f, -0.03153862f, -0.02436814f, -0.00266768f, -0.08435757f, 
    -0.01303392f, 0.02197984f, -0.01668871f, 0.03567615f, -0.02639111f, 0.02303731f, 0.05778490f, -0.05584370f, 
    -0.10685032f, -0.10559133f, -0.07803675f, -0.15456870f, -0.31768644f, -0.20067839f, -0.55285352f, 0.08977883f, 
    0.09982455f, -0.04368265f, -0.11381007f, 0.04344880f, -0.01784670f, -0.03540107f, 0.02813716f, 0.03910997f, 
    0.05196441f, 0.09128302f, 0.16980405f, -0.18752249f, -0.07619829f, 0.06784058f, -0.08845250f, 0.04661458f, 
    -0.05009807f, -0.11651102f, -0.04457968f, -0.01134116f, 0.30842006f, 0.03112368f, 0.01987831f, -0.02961443f, 
    -0.12012014f, -0.23190856f, 0.12299228f, -0.06717039f, 0.08456683f, -0.09596729f, -0.18514420f, -0.07951129f, 
    0.21729729f, 0.14707929f, -0.02539620f, -0.33915174f, 0.03060266f, 0.05422299f, -0.04446695f, -0.04453153f, 
    0.03924329f, -0.02839280f, -0.02967934f, -0.04130251f, 0.07228691f, 0.08803923f, 0.08466699f, 0.11106180f, 
    0.00733524f, 0.02913613f, -0.00360894f, 0.08007191f, 0.03837997f, 0.10658863f, -0.03285866f, 0.15233316f, 
    0.28310853f, -0.58229637f, -0.06231682f, -0.15383084f, 0.01955399f, 0.04848153f, -0.14630926f, 0.04032421f, 
    -0.06592628f, 0.02848899f, 0.00575855f, -0.00093705f, -0.01455904f, 0.12973960f, 0.05326103f, -0.11035232f, 
    0.10181057f, -0.04085442f, -0.15303680f, -0.22187395f, -0.02618266f, -0.03415666f, -0.00453842f, 0.05805947f, 
    -0.24207856f, -0.06551056f, -0.13099749f, 0.05391992f, 0.04384944f, 0.07699244f, 0.05990686f, 0.05080282f, 
    0.16949418f, 0.19384748f, -0.08610322f, 0.03157832f, -0.15573682f, -0.11222720f, -0.02250595f, 0.04313213f, 
    0.02058910f, 0.02917459f, 0.03053109f, 0.05122586f, -0.05903662f, -0.03148824f, 0.02584141f, -0.01383620f, 
    -0.17151919f, -0.17700145f, -0.15765293f, -0.02960352f, -0.00146732f, 0.04999360f, -0.03538924f, -0.00105861f, 
    -0.03374248f, -0.15894279f, -0.27256683f, -0.17076953f, -0.51058859f, -0.33857080f, -0.77524000f, 0.14986157f, 
    0.02855420f, 0.01738168f, -0.06260676f, -0.00075742f, -0.01392570f, 0.01571446f, -0.06316179f, 0.01418273f, 
    0.33012378f, 0.03226105f, -0.01885077f, 0.02722259f, 0.04281714f, 0.11418211f, 0.18066590f, -0.00121280f, 
    -0.06506298f, -0.03499868f, 0.00877566f, 0.08530961f, 0.10925309f, -0.02503587f, -0.05042493f, 0.02881209f, 
    0.00227932f, 0.00431576f, 0.01016361f, -0.02978371f, 0.08813273f, 0.26725447f, 0.07402691f, 0.09109087f, 
    -0.36172652f, 0.03485974f, 0.07886427f, 0.13004169f, -0.06334955f, -0.01767996f, 0.05734513f, -0.00336225f, 
    -0.04328558f, -0.05997973f, -0.03029204f, -0.01968846f, 0.13215424f, 0.02880884f, 0.00184314f, -0.04429480f, 
    -0.09626047f, 0.13630706f, 0.07623095f, 0.01630211f, -0.06034770f, 0.07418711f, -0.13614900f, -0.15530360f, 
    0.29185626f, -0.09204533f, -0.46766949f, 0.04474151f, 0.08228166f, 0.07812297f, -0.28045258f, -0.13139050f, 
    -0.03402656f, -0.10758384f, -0.22105014f, 0.05544472f, -0.02714198f, -0.03253289f, -0.07457918f, -0.06648948f, 
    -0.12579659f, -0.01789211f, 0.03564976f, 0.03803584f, -0.07975930f, -0.10532724f, 0.01455387f, -0.18937728f, 
    0.18209444f, 0.16889773f, 0.00414154f, -0.04580477f, 0.17768544f, 0.20018838f, -0.10045054f, -0.38638878f, 
    -0.12309149f, -0.29419652f, -0.08368614f, -0.06259648f, -0.23514540f, -0.29339081f, -0.57751065f, 0.19330406f, 
    0.04970734f, 0.01609919f, 0.01734719f, 0.05460746f, -0.01572594f, -0.04507880f, 0.02816662f, -0.03036276f, 
    0.30617395f, 0.01547738f, -0.10981349f, -0.04649498f, 0.07619413f, 0.19837177f, 0.01793228f, -0.06566224f, 
    0.08156312f, 0.09918173f, 0.06162345f, 0.00243632f, 0.21336386f, 0.15991478f, -0.01551429f, -0.01428214f, 
    0.10180887f, 0.01288308f, -0.17240644f, -0.06689456f, -0.10683458f, -0.03530252f, 0.09103945f, 0.00160913f, 
    0.24092495f, 0.05659637f, 0.15344603f, -0.01296325f, 0.08914693f, 0.07002293f, 0.05525373f, -0.04667457f, 
    0.10474012f, -0.00502108f, -0.07639331f, -0.04854414f, -0.36303198f, 0.15482029f, 0.23624891f, -0.45935690f, 
    -0.10248704f, 0.00149673f, 0.05557175f, -0.07961307f, -0.00925729f, 0.01580526f, -0.06117200f, -0.10062583f, 
    0.26371768f, 0.18656038f, 0.01518246f, -0.12590185f, 0.15587285f, 0.26249561f, 0.12945470f, 0.13735253f, 
    -0.07248029f, 0.06386767f, 0.09129702f, -0.09311619f, -0.40689936f, -0.33350915f, -0.26019001f, 0.15266728f, 
    -0.01746389f, 0.01210607f, -0.03086276f, -0.03573713f, -0.18785435f, -0.00418098f, -0.07430447f, 0.14294605f, 
    -0.03207327f, -0.06901918f, 0.02712138f, -0.03175956f, -0.07215298f, 0.02502163f, -0.04647779f, 0.03506245f, 
    -0.16587745f, -0.10997730f, -0.16342385f, -0.14068268f, 0.01980127f, -0.06627936f, -0.07069413f, 0.02940380f, 
    -0.21246515f, 0.02911151f, -0.06478358f, -0.06306088f, -0.06327900f, 0.04388287f, 0.04191661f, -0.07417957f, 
    0.11302627f, -0.03033193f, 0.05327464f, -0.02313221f, 0.11108480f, 0.13944325f, 0.04383525f, 0.03936599f, 
    -0.11900737f, -0.00961450f, -0.06335763f, 0.12266013f, -0.09439453f, 0.00260781f, -0.25991482f, 0.02742679f, 
    0.05057903f, 0.02918077f, -0.03992384f, 0.06894664f, -0.03790298f, -0.18181345f, 0.01174422f, -0.00701024f, 
    -0.13788611f, -0.20441927f, 0.04053368f, 0.07814367f, 0.04246322f, 0.05143758f, -0.10938057f, -0.01087073f, 
    -0.03342393f, -0.01627347f, 0.10213089f, -0.23062861f, -0.56486928f, -0.15712644f, -0.04113426f, 0.37339154f, 
    0.07300063f, 0.01226080f, 0.01085562f, -0.00395984f, 0.02603522f, -0.00691815f, 0.01264827f, 0.08656923f, 
    -0.11484741f, -0.20458542f, -0.13803981f, -0.11293424f, 0.00021351f, 0.03004427f, -0.02724134f, -0.08354430f, 
    -0.16073683f, -0.05935337f, 0.06581233f, -0.02307668f, 0.34787300f, 0.06387708f, -0.10850699f, -0.22723988f, 
    0.11794955f, 0.17151034f, 0.25950152f, 0.17229755f, -0.03713524f, -0.01669396f, 0.00602944f, -0.03690179f, 
    0.31767431f, 0.07663520f, -0.13235942f, -0.06137156f, 0.15521491f, 0.06473182f, -0.15059027f, -0.10451891f, 
    -0.08022230f, -0.16957770f, -0.15385215f, -0.01862912f, 0.17321444f, -0.12429124f, -0.19900995f, -0.10167050f, 
    0.10251044f, 0.12595938f, 0.00698995f, -0.06787267f, -0.05467510f, -0.05470448f, -0.06628103f, 0.04309480f, 
    0.20915176f, 0.15114433f, 0.08521855f, -0.31343699f, -0.03990202f, -0.05831604f, -0.01059937f, -0.08302453f, 
    -0.03616183f, 0.01599681f, 0.02717527f, -0.01975250f, -0.04846361f, -0.06357026f, 0.04056063f, 0.06630588f, 
    0.00305938f, 0.03704118f, 0.00915529f, 0.05850464f, -0.05598643f, 0.10815660f, -0.10740567f, -0.05313782f, 
    0.11961220f, 0.05351532f, 0.11206933f, 0.17387776f, -0.04657181f, 0.00788322f, -0.00411727f, 0.03115547f, 
    -0.04533760f, 0.10057365f, 0.00551014f, 0.01214998f, -0.11466659f, 0.01023955f, 0.00932590f, -0.08638462f, 
    -0.00223211f, -0.10626218f, 0.12408374f, 0.08255393f, -0.08098832f, 0.08424815f, -0.03623220f, 0.06459180f, 
    0.31895301f, -0.23765211f, 0.03899493f, -0.00386155f, 0.02298770f, -0.02429911f, -0.14015290f, -0.04370447f, 
    -0.33192915f, -0.25865141f, -0.12210641f, -0.12633473f, -0.12392046f, 0.24356155f, 0.04275924f, -0.03010855f, 
    -0.02459457f, 0.07306075f, 0.01149266f, -0.15956721f, 0.05543399f, 0.09040634f, 0.05009096f, 0.05470546f, 
    0.49124721f, 0.10190052f, 0.14295684f, 0.00617951f, -0.04489445f, -0.05394980f, -0.00628399f, 0.03953561f, 
    -0.02244432f, 0.03161000f, -0.01940614f, -0.04891720f, -0.00888673f, 0.09848873f, 0.04944642f, 0.06884030f, 
    -0.31990367f, 0.14145945f, -0.27920482f, -0.07324378f, -0.02566074f, 0.04880703f, -0.04140029f, 0.10583640f, 
    -0.00290982f, -0.05686092f, 0.06819311f, 0.16701496f, -0.02920076f, 0.01876362f, -0.06206589f, 0.00670122f, 
    -0.01009524f, 0.08589020f, -0.05987982f, -0.03997513f, -0.05681280f, 0.11873597f, -0.14254773f, 0.03056360f, 
    0.02430246f, -0.13670050f, 0.09772856f, 0.02130537f, -0.05821450f, -0.02424180f, -0.03032142f, 0.06207354f, 
    -0.34928310f, -0.16355015f, 0.01777164f, -0.09845311f, -0.07765245f, 0.05940135f, 0.04442905f, 0.04540309f, 
    0.06604540f, -0.06959307f, -0.00902892f, 0.05592684f, -0.04932769f, -0.07172403f, -0.15245017f, 0.10301673f, 
    0.12093136f, -0.05666771f, 0.07909898f, 0.01679240f, 0.01620956f, 0.01553708f, 0.00344782f, 0.09391449f, 
    -0.32102334f, -0.22989804f, 0.13562620f, -0.10482553f, 0.01629011f, 0.01010239f, 0.07162112f, 0.01109229f, 
    0.20780909f, -0.09452735f, -0.07951723f, 0.13121092f, -0.24956048f, -0.01055158f, 0.13404375f, 0.05387022f, 
    0.01410085f, -0.01859033f, 0.04064824f, 0.01082118f, 0.00643022f, 0.01560835f, 0.10693449f, 0.11342225f, 
    -0.02176403f, 0.07551429f, -0.04357926f, -0.13852195f, -0.10002137f, 0.01798018f, -0.12806208f, -0.25986999f, 
    -0.04234473f, 0.02839689f, 0.04840913f, -0.05338228f, 0.09012292f, -0.17897744f, 0.14994965f, -0.04891595f, 
    0.01411717f, 0.01633286f, 0.06525277f, -0.04519721f, 0.16594207f, 0.15959182f, -0.23476848f, 0.09377730f, 
    -0.21107268f, 0.05121350f, -0.00693264f, -0.04987452f, 0.13604705f, 0.06075770f, -0.26561642f, -0.06869961f, 
    -0.00768201f, 0.02609924f, -0.08050963f, 0.03655782f, -0.13585825f, -0.08573546f, 0.07344176f, -0.11614652f, 
    -0.08970086f, 0.03449684f, -0.05650920f, 0.05356101f, 0.04549681f, 0.04307605f, -0.04826599f, 0.14711617f, 
    -0.14739755f, 0.23091075f, 0.22067010f, -0.00867752f, -0.09074741f, -0.06526770f, -0.09088318f, 0.16392705f, 
    -0.12371602f, -0.02058252f, 0.08384074f, -0.14516763f, 0.62860900f, -0.14368939f, 0.21423621f, 0.22577511f, 
    -0.01165068f, -0.07706945f, 0.00611044f, -0.00588906f, 0.02045403f, -0.01949807f, -0.05422330f, 0.03632534f, 
    -0.08264548f, 0.09354834f, 0.05708604f, 0.04795693f, -0.01046851f, 0.00426242f, 0.04550359f, -0.05063331f, 
    0.20060332f, 0.17143703f, 0.09643717f, -0.25077310f, -0.10358281f, 0.16973825f, -0.21645917f, 0.14040422f, 
    -0.03440645f, -0.04465574f, 0.00416354f, 0.01028288f, 0.08792282f, 0.07412226f, 0.12674485f, -0.09951176f, 
    0.14897536f, 0.11677887f, 0.06958554f, 0.04879732f, -0.16126098f, -0.01156395f, -0.01523719f, -0.16579577f, 
    0.08635162f, -0.00812624f, -0.04204775f, -0.01243396f, 0.19296733f, -0.35128194f, 0.08520056f, -0.14730987f, 
    0.00858184f, 0.00815814f, 0.01415419f, 0.01892867f, 0.04023843f, -0.12810113f, -0.00220891f, 0.07606845f, 
    -0.39227766f, -0.08818591f, -0.54168683f, -0.23803608f, -0.08479422f, -0.00175001f, 0.16690747f, 0.09046077f, 
    -0.01254161f, 0.07690661f, -0.02036759f, 0.02142894f, 0.02426783f, -0.11368151f, -0.12990369f, -0.15632814f, 
    -0.23403317f, -0.06904472f, 0.02911351f, -0.01553468f, -0.06419835f, 0.03425870f, -0.01662492f, 0.06436677f, 
    0.27974188f, -0.14057672f, 0.20573813f, 0.12503822f, 0.03566040f, -0.12822248f, 0.08041634f, -0.06164095f, 
    0.24586082f, -0.04760250f, 0.08569159f, -0.28395107f, -0.06552354f, 0.02187409f, 0.05794714f, 0.00998258f, 
    0.08184509f, 0.09069853f, -0.07100655f, 0.03539016f, -0.06006385f, -0.02128753f, 0.01973550f, -0.06441542f, 
    0.06168802f, -0.05432434f, 0.03757402f, 0.13954000f, 0.00698103f, -0.02800811f, 0.05923126f, 0.03453336f, 
    -0.08435070f, 0.04205634f, 0.02176988f, 0.01317643f, 0.17069829f, 0.03239713f, 0.00971177f, -0.07343800f, 
    0.07270492f, -0.07307132f, -0.11140522f, -0.11059894f, -0.03247940f, -0.07947457f, 0.06938592f, 0.10266057f, 
    -0.26347756f, -0.08067575f, 0.10500941f, -0.21596137f, 0.17485636f, 0.08792055f, -0.13505726f, -0.07233077f, 
    0.01384925f, -0.06504858f, 0.00595435f, 0.05800965f, 0.20418970f, 0.08054354f, -0.19969863f, -0.26470903f, 
    -0.02451990f, 0.12857591f, -0.05227290f, -0.04355835f, -0.05484107f, 0.04173299f, 0.12883112f, -0.02139837f, 
    -0.24374339f, 0.25027207f, 0.00599454f, 0.08279739f, -0.14809403f, 0.06178340f, 0.03541792f, -0.00952843f, 
    -0.06665553f, 0.01698735f, 0.00420000f, 0.03313288f, -0.18166499f, -0.15786630f, -0.05082841f, -0.00790116f, 
    0.02744387f, 0.00963054f, 0.00804027f, 0.01309381f, -0.15118054f, -0.20314561f, -0.07467805f, -0.00331286f, 
    -0.33775690f, -0.21375418f, 0.04332836f, -0.59979153f, 0.00395686f, 0.00775894f, -0.04184439f, 0.01050296f, 
    -0.02585657f, -0.09783944f, 0.06495699f, -0.08925205f, 0.08777555f, 0.05396019f, -0.04805043f, -0.07701147f, 
    -0.03594461f, -0.18756069f, 0.05944063f, 0.04826538f, -0.08594640f, 0.03611619f, 0.00387088f, 0.03614961f, 
    -0.05736713f, -0.03288059f, 0.07636406f, 0.00385396f, -0.01539187f, 0.07340071f, -0.02886214f, -0.04454920f, 
    0.01335721f, -0.27167079f, -0.23539419f, -0.21125193f, 0.18868400f, 0.01810032f, 0.10890693f, 0.11609869f, 
    -0.06330650f, -0.00105091f, 0.01390168f, 0.02874994f, -0.01662626f, -0.04300943f, -0.01413032f, 0.18184006f, 
    0.04757338f, 0.04361665f, 0.12928721f, -0.13268262f, 0.02933897f, 0.03871419f, 0.00409919f, -0.05535500f, 
    -0.08762521f, 0.06360981f, -0.10361206f, -0.00799497f, 0.26018932f, 0.03658325f, 0.12433979f, 0.21026224f, 
    -0.04061274f, -0.13557673f, 0.10344733f, -0.05897922f, -0.00133920f, 0.00712695f, -0.04873901f, 0.13922788f, 
    0.03033619f, 0.07677902f, 0.03471348f, 0.10992509f, -0.14053147f, 0.00253883f, -0.19097832f, -0.10887103f, 
    -0.04437118f, -0.08447835f, 0.00747758f, -0.20597209f, 0.00286280f, -0.08026326f, 0.00089728f, -0.12138578f, 
    -0.05003595f, 0.02647304f, 0.05130940f, 0.01082644f, -0.03559777f, -0.24981813f, 0.03548492f, 0.04917689f, 
    0.16514549f, -0.05964563f, 0.06647106f, -0.04000442f, -0.00120213f, 0.01010454f, -0.05719265f, 0.12592354f, 
    -0.02165414f, -0.13036408f, 0.19272281f, -0.19826940f, -0.20625348f, 0.11775389f, 0.04686734f, -0.01693658f, 
    -0.07671036f, -0.05798740f, 0.02031169f, 0.02760285f, 0.02202173f, -0.06326792f, -0.16077390f, 0.15365300f, 
    0.44860566f, 0.16604653f, 0.01339693f, -0.28185970f, -0.06898020f, -0.02230879f, 0.06178365f, 0.00603450f, 
    0.04117953f, 0.00203170f, -0.28895950f, 0.01253899f, 0.01887337f, 0.09694684f, -0.08692545f, 0.05862079f, 
    0.21002372f, 0.08664607f, -0.02898678f, 0.08292532f, -0.03060507f, -0.01637279f, -0.06885121f, 0.02484702f, 
    0.07482708f, -0.08061183f, -0.02444866f, 0.04438683f, -0.08764128f, 0.03804001f, 0.16186081f, 0.25434834f, 
    0.04364132f, -0.01117149f, -0.17380847f, -0.11365376f, 0.66738647f, -0.02498749f, 0.13566206f, 0.21826877f, 
    -0.05945043f, -0.05116036f, 0.00240631f, 0.00023324f, -0.05296223f, 0.03268038f, 0.03924637f, 0.07963241f, 
    0.08105236f, 0.07051179f, -0.18367502f, -0.02197217f, -0.08646123f, 0.05551695f, -0.06062379f, -0.15515500f, 
    -0.12954372f, -0.16834731f, -0.07292344f, -0.10547338f, -0.02893720f, -0.23256937f, -0.03958579f, 0.01290475f, 
    0.14250708f, 0.17282251f, -0.02026204f, -0.17934671f, 0.09008442f, -0.09552076f, -0.01179830f, 0.03268640f, 
    0.08283744f, 0.07690683f, -0.10873113f, -0.11175728f, -0.00544754f, -0.02929764f, -0.01401932f, -0.10369395f, 
    -0.02881293f, -0.10099500f, 0.12924846f, -0.18012434f, -0.21424943f, 0.09168079f, 0.03835370f, -0.12825797f, 
    0.11563190f, 0.04602151f, -0.05449610f, -0.01860891f, -0.01419874f, 0.01847744f, -0.02284460f, 0.13432620f, 
    0.43561405f, 0.05432646f, 0.15953225f, 0.05901644f, 0.04094492f, 0.00722564f, -0.27350357f, -0.20192900f, 
    0.06951992f, 0.00888495f, -0.05050709f, -0.14037228f, 0.35440063f, -0.13706309f, 0.07779285f, -0.23490909f, 
    -0.00233052f, -0.01398465f, 0.01081643f, -0.07981076f, -0.09558513f, -0.10498749f, -0.11258180f, -0.07324227f, 
    0.40182900f, -0.03142524f, -0.07448293f, -0.03403361f, 0.01256533f, -0.08648726f, -0.11981347f, -0.05400775f, 
    0.25375509f, -0.09371589f, 0.26709530f, -0.02942088f, 0.00652521f, -0.51499766f, 0.25410372f, -0.59969044f, 
    0.06812524f, -0.13517994f, -0.09133215f, 0.18365195f, 0.00067626f, -0.05941415f, -0.12954347f, -0.05636868f, 
    -0.08422589f, -0.20538577f, -0.15250845f, -0.03336969f, -0.05301971f, 0.01031751f, 0.07046483f, 0.01365569f, 
    -0.09170895f, -0.03570572f, 0.05708699f, 0.00763161f, 0.12039497f, 0.02291524f, 0.03852499f, 0.07513680f, 
    0.07671034f, -0.02609498f, -0.06554568f, -0.06457687f, 0.26216140f, -0.03915541f, -0.00106539f, 0.08055490f, 
    0.20736134f, -0.04807265f, 0.13517064f, -0.19066817f, 0.01883335f, 0.07057776f, -0.07067629f, -0.15965521f, 
    0.02257887f, 0.01015975f, -0.12286295f, -0.08893839f, 0.29473570f, 0.17568564f, 0.15470707f, 0.14974803f, 
    0.01846045f, -0.04449434f, -0.00974551f, 0.00710271f, 0.06265324f, 0.07209548f, 0.01852513f, 0.01640850f, 
    0.05543569f, 0.10438070f, -0.32025224f, -0.30624023f, -0.05902381f, -0.09022715f, 0.03703976f, 0.12887545f, 
    -0.10190047f, 0.05331107f, -0.10547668f, 0.00781037f, 0.00538416f, 0.06905860f, 0.23594573f, 0.18979128f, 
    -0.11003198f, -0.07614987f, 0.10993129f, -0.26186302f, -0.01249745f, -0.02657645f, 0.00805450f, -0.01219213f, 
    -0.02331609f, -0.04160500f, 0.06310315f, -0.12595358f, 0.13704027f, 0.24089646f, 0.14203434f, 0.19614282f, 
    0.15317856f, 0.08237903f, -0.03837752f, 0.00925397f, -0.09152753f, 0.11459602f, 0.21916792f, -0.05971173f, 
    -0.04716131f, 0.03458299f, -0.15431361f, 0.16625738f, -0.18531591f, 0.04744241f, 0.05029612f, 0.02965646f, 
    -0.18130846f, 0.14449841f, -0.18152182f, 0.04940143f, -0.02296672f, 0.04275766f, 0.01269871f, 0.10398775f, 
    -0.03573791f, 0.07034826f, 0.12475923f, -0.03741924f, -0.00826782f, 0.07375672f, 0.07950436f, 0.05042360f, 
    -0.00150623f, 0.01277967f, -0.07279917f, 0.05911864f, 0.11747433f, 0.01913746f, -0.03741612f, 0.01340872f, 
    -0.08811820f, -0.04093437f, -0.09749078f, -0.04711758f, -0.07287940f, -0.02228200f, 0.03106751f, 0.04774244f, 
    -0.09050963f, -0.04570929f, -0.06818697f, 0.00499948f, -0.26581371f, -0.07554699f, -0.04996163f, 0.03974504f, 
    -0.04851898f, -0.04122719f, -0.13249458f, -0.21774551f, 0.05002764f, -0.10394723f, 0.03453553f, -0.01051969f, 
    -0.00845074f, 0.08704096f, 0.01435079f, 0.09189469f, -0.07425893f, 0.00698136f, 0.00931355f, -0.10036860f, 
    0.05931602f, 0.09501553f, 0.17144205f, 0.07953972f, 0.15803950f, 0.10486683f, -0.15692863f, 0.36358166f, 
    -0.03749667f, 0.02492446f, 0.08221102f, -0.06456644f, 0.02316330f, 0.03812020f, 0.11919345f, -0.06581262f, 
    -0.01787193f, -0.18124363f, -0.23375617f, -0.20005372f, -0.03494149f, -0.02417465f, 0.04552693f, -0.06096856f, 
    -0.04361429f, -0.05750660f, -0.02254556f, 0.27701226f, -0.87638903f, -0.39826921f, -0.36225146f, -0.51357180f, 
    0.03716666f, 0.01208205f, -0.14018846f, -0.12383533f, -0.04028879f, -0.04963613f, -0.00731523f, 0.00460024f, 
    -0.06217374f, -0.12388378f, -0.25483254f, 0.05885477f, 0.00632180f, -0.00257280f, 0.01384945f, 0.03860239f, 
    -0.06268677f, 0.00443928f, 0.04095331f, -0.03749434f, -0.07519919f, 0.02813267f, -0.07704111f, 0.00462414f, 
    0.04671265f, -0.02588469f, -0.12848298f, 0.10400880f, -0.00055574f, 0.00250625f, -0.01917668f, -0.06192443f, 
    0.03423055f, 0.02405492f, 0.03314423f, 0.07489625f, 0.01524839f, 0.00005451f, 0.02017103f, 0.04176228f, 
    -0.11226641f, -0.03645069f, -0.02749243f, 0.11798000f, -0.00465015f, -0.01302767f, -0.08823676f, 0.03498606f, 
    0.06340944f, -0.09941947f, 0.00421733f, 0.11744954f, 0.03081818f, 0.04660680f, 0.03983929f, -0.11573876f, 
    0.03611310f, -0.04274818f, -0.13116460f, 0.19713891f, -0.03104249f, 0.04972971f, 0.06674058f, -0.03399515f, 
    -0.00224360f, -0.01459046f, 0.03780394f, 0.10411562f, 0.16627277f, -0.29481560f, -0.21261266f, 0.25399515f, 
    0.08413754f, 0.08642862f, -0.05844301f, 0.01134292f, -0.05103942f, -0.06903852f, 0.01828718f, 0.03486621f, 
    0.14364769f, 0.45425841f, 0.02879715f, 0.27275416f, -0.05004896f, 0.03037995f, 0.08002414f, 0.07126711f, 
    0.10155968f, 0.07545076f, 0.04918205f, 0.06254647f, 0.06691266f, -0.09819062f, 0.11075496f, -0.04904155f, 
    -0.01329307f, 0.01027353f, -0.03471125f, -0.00506279f, 0.02213898f, 0.06033597f, -0.06008084f, 0.02740991f, 
    0.22127663f, -0.07324281f, 0.02345213f, 0.12889861f, 0.04922125f, 0.08778840f, -0.12458213f, 0.01001635f, 
    0.10282996f, 0.03885268f, -0.00565926f, 0.08504534f, 0.06338143f, -0.01438343f, -0.22515619f, 0.03050932f, 
    -0.01296024f, 0.06148982f, -0.00109956f, 0.01875551f, -0.01231363f, -0.16779420f, 0.04799889f, 0.04880538f, 
    -0.03433321f, -0.06771367f, 0.05231519f, 0.17325650f, -0.07653414f, 0.06264471f, 0.09636378f, -0.23596652f, 
    0.01130897f, 0.02525961f, -0.05432164f, -0.04946986f, -0.13797720f, 0.12800324f, -0.17456602f, -0.35683054f, 
    0.00515054f, -0.06592541f, 0.00562159f, 0.03213026f, -0.04062328f, 0.03034548f, 0.01784172f, -0.12072643f, 
    -0.06014069f, 0.01683512f, -0.10761788f, 0.02296584f, -0.01186256f, -0.04166659f, 0.00362431f, 0.00374159f, 
    -0.13204914f, -0.00400589f, 0.06282154f, -0.28559858f, 0.15334883f, 0.21617876f, -0.28736079f, 0.04092889f, 
    0.07042117f, 0.04535025f, -0.07919470f, 0.08097068f, -0.06740902f, 0.08902072f, 0.01215580f, -0.07351541f, 
    -0.54035228f, -0.16508262f, -0.22816648f, -0.17804976f, 0.08422080f, 0.09865041f, -0.02783755f, -0.02123520f, 
    0.01399017f, -0.01015156f, 0.00851742f, 0.04711416f, -0.39538285f, -0.20455566f, -0.10307375f, 0.12560463f, 
    -0.10571081f, 0.06063038f, -0.12910709f, -0.13308607f, -0.00862684f, -0.17940070f, -0.01952496f, -0.01450899f, 
    -0.09376211f, 0.07390928f, -0.44884077f, 0.06138402f, -0.22987922f, -0.31054634f, -0.02295411f, 0.19225280f, 
    0.02587218f, -0.00159978f, -0.00848854f, 0.01536372f, -0.42566320f, -0.12158152f, -0.10955005f, -0.21328533f, 
    0.03673435f, 0.04593090f, -0.06678500f, -0.23916608f, -0.00700918f, -0.01701673f, -0.00204728f, -0.04291715f, 
    0.02284057f, -0.05841057f, 0.17706241f, 0.07454603f, 0.12054212f, -0.05649623f, 0.02248553f, -0.15746091f, 
    0.04920398f, 0.00838789f, 0.06406018f, -0.12101824f, -0.09365409f, -0.02099814f, -0.03780554f, 0.04052353f, 
    0.20145164f, 0.00071708f, -0.09180764f, -0.00019560f, 0.01159239f, -0.02593957f, 0.00730956f, 0.00362628f, 
    -0.05147624f, -0.17638129f, -0.08273782f, 0.05607949f, 0.06447479f, -0.01082916f, -0.02134532f, 0.07450350f, 
    -0.01166013f, -0.12195000f, 0.07597509f, 0.01579649f, -0.15070702f, -0.23690017f, 0.38712186f, -0.15160587f, 
    -0.01936623f, 0.07670417f, 0.00097636f, -0.02091236f, 0.05564243f, -0.03478999f, 0.12601924f, -0.04908822f, 
    -0.06942549f, -0.12461032f, -0.04375115f, -0.06713087f, 0.05777285f, 0.01821052f, -0.23127623f, 0.02201115f, 
    0.09606269f, -0.09263896f, 0.09177060f, 0.09160533f, 0.07674727f, -0.04625976f, 0.27566695f, -0.03192822f, 
    -0.01034714f, -0.04633304f, -0.07304951f, 0.06770948f, 0.05261695f, -0.09093895f, 0.19383493f, -0.33792374f, 
    -0.77486664f, -0.44079420f, -0.46972674f, -0.20942280f, -0.05498341f, -0.00044518f, -0.07107630f, -0.01051715f, 
    -0.02844074f, 0.01587148f, -0.01895012f, -0.03415228f, 0.13077015f, 0.02268798f, -0.04162334f, 0.07305408f, 
    -0.03156120f, 0.02443811f, -0.03613140f, -0.17463709f, 0.14717786f, 0.06446732f, 0.20191990f, 0.14783113f, 
    0.08647991f, -0.05973963f, -0.03989117f, -0.22354315f, -0.05846204f, -0.08412758f, 0.15060730f, -0.25938076f, 
    -0.08554494f, 0.07775444f, -0.01957016f, 0.07279720f, -0.31894928f, -0.14314580f, 0.14602658f, 0.05182927f, 
    -0.18180792f, 0.01670495f, 0.13113594f, -0.16274828f, 0.01054135f, -0.04630704f, -0.00168097f, 0.01863639f, 
    0.00666069f, -0.22903930f, 0.07671198f, -0.00827010f, -0.02383242f, -0.08210816f, 0.04751450f, -0.07385656f, 
    0.02541465f, 0.09732664f, 0.08628093f, -0.02588282f, -0.23499502f, -0.02933688f, -0.22128986f, -0.01838201f, 
    -0.04099216f, -0.02731463f, 0.01159250f, 0.09397379f, -0.08260715f, -0.14270405f, 0.17202365f, -0.14371355f, 
    -0.10265367f, 0.23683868f, 0.05253894f, 0.01637526f, -0.06555564f, 0.02591405f, -0.03230273f, 0.03118906f, 
    0.02463863f, -0.11884972f, 0.01882790f, -0.07178742f, -0.21410888f, -0.08818593f, 0.33469605f, -0.05720482f, 
    0.03998577f, -0.03456229f, 0.00064698f, -0.03462566f, -0.00259496f, 0.03895416f, -0.05865151f, 0.08601137f, 
    -0.28989455f, 0.02206045f, 0.36142686f, 0.09776628f, 0.14970922f, -0.01023844f, 0.05269078f, 0.05103914f, 
    0.04782563f, 0.01410362f, 0.01903537f, -0.05915752f, -0.07209729f, -0.04160612f, 0.00643784f, -0.07727447f, 
    -0.03611205f, -0.09517306f, -0.02213849f, -0.02547588f, 0.22052294f, -0.00683811f, 0.01046204f, -0.00475780f, 
    -0.01126022f, -0.11038120f, 0.02367094f, 0.01402084f, 0.10513932f, -0.10636013f, 0.06588575f, 0.02861848f, 
    -0.01795281f, -0.12145921f, 0.18790223f, -0.10216547f, -0.22915252f, -0.19448864f, 0.11258702f, 0.16171511f, 
    -0.00639033f, 0.00181517f, -0.09002113f, -0.01704862f, -0.01775540f, -0.17862079f, -0.22420073f, -0.13828200f, 
    -0.44294786f, 0.51769429f, 0.68595576f, -0.20678560f, -0.12255416f, -0.10661237f, -0.04969913f, -0.05796716f, 
    0.04277887f, -0.09435474f, -0.05330122f, -0.14120492f, -0.04687767f, -0.07559887f, -0.09304214f, -0.08614156f, 
    0.02022456f, -0.02596512f, 0.01279352f, 0.03143509f, 0.04561415f, -0.07444197f, 0.00125769f, 0.05200196f, 
    -0.10537216f, -0.12333947f, 0.17805788f, -0.06589442f, 0.03460555f, -0.09699146f, 0.01540652f, -0.04600605f, 
    -0.07637774f, -0.24101163f, -0.07799393f, -0.06065611f, -0.15769930f, -0.03122346f, -0.02117675f, -0.31992084f, 
    0.00888250f, -0.07110070f, -0.04209906f, 0.02850545f, -0.03363585f, 0.01209608f, 0.06492149f, -0.06858777f, 
    -0.12706651f, 0.24715503f, 0.16754512f, 0.26225471f, -0.02795806f, -0.09404999f, 0.02460896f, 0.17039336f, 
    0.09065480f, -0.07081543f, 0.13426492f, -0.00061494f, -0.01977817f, 0.13893217f, 0.02130886f, 0.11215699f, 
    -0.09531883f, 0.07906418f, 0.15009785f, -0.04024398f, 0.02169750f, 0.09713902f, 0.02048139f, 0.02432155f, 
    -0.01165793f, 0.03309090f, 0.20389304f, 0.28705484f, -0.02768807f, 0.05436784f, 0.05414873f, -0.03007512f, 
    -0.08996996f, 0.06938322f, 0.06303619f, 0.16285767f, -0.24943182f, 0.13649151f, -0.23084980f, 0.16105206f, 
    0.02530109f, 0.06142973f, -0.05883821f, -0.03933044f, 0.00370419f, 0.09288980f, -0.20672587f, 0.15540710f, 
    0.07647486f, 0.04500057f, 0.49634585f, 0.36449632f, -0.01563201f, 0.05688086f, -0.05588982f, 0.11608555f, 
    0.01395702f, 0.01724087f, -0.08363318f, 0.07093864f, -0.15845382f, 0.12861077f, 0.11833350f, -0.00684395f, 
    0.00189742f, -0.03811451f, -0.02625622f, -0.20125268f, -0.00315159f, 0.12558636f, 0.15395595f, 0.14074603f, 
    -0.20046583f, 0.09378578f, -0.03415434f, 0.04963804f, -0.02564961f, -0.02883485f, -0.08593087f, 0.00056280f, 
    0.09702959f, 0.01051543f, 0.03972081f, 0.03510173f, 0.13876213f, -0.08331771f, 0.32155660f, -0.40282840f, 
    0.27700618f, -0.08605241f, -0.14311008f, -0.14180297f, 0.02713376f, 0.05817279f, -0.15056999f, 0.00611518f, 
    0.28803581f, 0.09827513f, 0.13157970f, 0.04776385f, -0.09157395f, -0.01585356f, 0.10422538f, -0.12836860f, 
    0.05138403f, 0.02854265f, 0.07750126f, -0.03064458f, -0.05207562f, -0.04070480f, 0.07940637f, -0.15924788f, 
    0.01192746f, 0.04287081f, -0.00159689f, -0.05558366f, 0.02749120f, -0.01564371f, 0.02465808f, -0.11074515f, 
    0.00306316f, 0.29249334f, 0.13704996f, -0.05211165f, 0.01662528f, 0.12563886f, -0.07748521f, 0.02533982f, 
    0.00988132f, 0.03734474f, 0.16304067f, 0.06510101f, 0.06038669f, -0.16806123f, 0.14807343f, -0.02215913f, 
    -0.03391018f, -0.04814470f, 0.04438018f, 0.03633454f, -0.03933434f, -0.04634557f, 0.03791450f, -0.07177547f, 
    0.28465426f, 0.13705006f, 0.08824310f, 0.27259833f, 0.04990864f, -0.03952799f, 0.05782866f, 0.10895933f, 
    0.11441021f, -0.00488156f, 0.04655303f, 0.05844991f, -0.53315830f, -0.27720731f, 0.26517448f, -0.12606567f, 
    0.01821565f, -0.07066365f, 0.19488226f, -0.06239940f, 0.04166762f, -0.02972478f, 0.02054442f, -0.00977192f, 
    -0.08250365f, 0.23071280f, 0.40633479f, -0.05956256f, -0.17344075f, -0.16184604f, 0.08817946f, 0.01922990f, 
    -0.23956741f, -0.00346765f, -0.14757377f, -0.05406762f, 0.16993342f, -0.06603770f, 0.14405400f, 0.17194708f, 
    0.03348765f, -0.08867587f, -0.20701985f, 0.16832398f, 0.01585600f, -0.01074520f, -0.04200501f, -0.09023508f, 
    -0.09060330f, -0.10614110f, -0.12852161f, 0.17280464f, -0.05430132f, 0.03882673f, -0.09372828f, -0.21981974f, 
    -0.05635668f, -0.07953864f, -0.04367073f, -0.05018467f, 0.05864256f, -0.02522103f, -0.11416946f, 0.03740791f, 
    0.02700341f, -0.00980256f, 0.02573623f, 0.02932880f, 0.00413603f, 0.03350781f, 0.05317708f, -0.01043629f, 
    -0.55441427f, -0.18138972f, 0.00366928f, -0.08575666f, -0.11776364f, -0.09230963f, -0.20728152f, -0.05880246f, 
    -0.15950872f, 0.04746352f, 0.12532648f, 0.02673581f, -0.04742154f, -0.09817407f, 0.03623376f, 0.20028514f, 
    0.00124436f, 0.01883843f, 0.05380894f, -0.04540865f, 0.08195692f, -0.04563237f, -0.02991007f, 0.00262108f, 
    -0.04818821f, 0.05932088f, 0.00252163f, 0.14071313f, 0.07359991f, 0.12906897f, -0.03722854f, 0.00241226f, 
    0.02641153f, 0.00987456f, 0.06227366f, -0.05663943f, -0.32790884f, 0.57814318f, -0.29543698f, 0.22449447f, 
    -0.07050362f, -0.07653441f, 0.01279990f, -0.06258021f, -0.03262568f, 0.08857008f, -0.12880184f, -0.18201022f, 
    -0.15070978f, 0.22169933f, -0.10149606f, -0.30926967f, -0.06910441f, -0.00177616f, -0.22963531f, 0.07209277f, 
    -0.09144961f, -0.15823470f, 0.03244036f, -0.06910249f, -0.04965834f, -0.23517039f, 0.05609500f, 0.15271142f, 
    0.07710852f, 0.08961676f, -0.01901056f, 0.06960209f, -0.00986622f, -0.06214020f, -0.07375498f, -0.08793863f, 
    -0.02602975f, 0.21733502f, -0.12232592f, -0.37748706f, 0.09771905f, -0.09296023f, -0.02640111f, 0.05402713f, 
    0.02384564f, -0.08543225f, -0.03672748f, -0.01307188f, 0.01101023f, -0.09513415f, 0.09382808f, 0.02418613f, 
    0.02551500f, 0.09662316f, 0.02482130f, -0.01478945f, 0.14526320f, -0.24946374f, 0.04671830f, -0.04522101f, 
    0.47641179f, -0.03836993f, -0.22531022f, -0.29056394f, 0.02786086f, 0.00401025f, 0.05852509f, -0.23526932f, 
    -0.26985061f, -0.02939537f, -0.06033808f, -0.11813162f, -0.43291268f, 0.28517312f, -0.31784514f, -0.58020067f, 
    0.14641194f, 0.09383522f, -0.02899048f, -0.00738223f, -0.15826508f, 0.00427433f, -0.07300027f, 0.00106226f, 
    0.15413700f, 0.16022843f, 0.04674722f, -0.52914828f, -0.07983851f, -0.15464860f, -0.05009593f, -0.01868140f, 
    -0.11781523f, 0.01703868f, -0.04258112f, 0.05129594f, 0.45872143f, 0.16184370f, -0.02511236f, 0.04054309f, 
    -0.12967004f, 0.09706257f, -0.17270321f, 0.01234511f, -0.14182031f, 0.02167726f, 0.09964156f, -0.01417896f, 
    0.44757706f, -0.14219534f, 0.05809435f, 0.19822231f, 0.05714881f, 0.01649552f, 0.04210153f, -0.05039621f, 
    0.01621308f, 0.06326096f, 0.06921887f, 0.07130299f, 0.10339484f, -0.14333832f, -0.04891717f, -0.02999606f, 
    -0.14158495f, -0.25810426f, -0.04628176f, -0.04987363f, -0.09541556f, 0.06845619f, -0.27460042f, 0.16200875f, 
    0.65963244f, 0.06052727f, -0.10033028f, 0.10275211f, 0.01710766f, 0.02526183f, 0.01092333f, -0.01442027f, 
    -0.05549626f, -0.07993982f, -0.01657120f, 0.09551767f, 0.34140575f, -0.12694392f, -0.01931406f, -0.16728504f, 
    -0.03602053f, -0.06347898f, -0.00958529f, 0.03842981f, -0.07537486f, 0.00384986f, -0.09205878f, 0.06254281f, 
    -0.06405883f, -0.01559274f, 0.07348537f, -0.01771126f, 0.02656863f, 0.01036313f, -0.09601203f, -0.11858917f, 
    -0.03717043f, 0.05915247f, -0.04134959f, 0.05096776f, 0.14065070f, 0.13869832f, 0.17137964f, 0.23082413f, 
    0.02645483f, 0.07780169f, 0.07578015f, -0.03589745f, -0.01064342f, -0.00608506f, 0.02800434f, -0.21670459f, 
    -0.34119469f, 0.24867526f, -0.21033591f, -0.40903974f, 0.21187285f, 0.09093846f, 0.02870238f, -0.02423418f, 
    -0.08087070f, -0.14621024f, 0.02810638f, -0.05726486f, 0.02368819f, 0.42459300f, 0.22172149f, -0.33772206f, 
    -0.39932871f, -0.00695659f, 0.00657949f, -0.24356461f, -0.05455039f, -0.16459423f, 0.03218102f, -0.00365684f, 
    -0.14132529f, -0.12921137f, -0.12662686f, 0.10117905f, 0.09390371f, 0.07362998f, -0.00489881f, -0.02571403f, 
    0.00751429f, 0.05439418f, 0.00565818f, -0.03207646f, -0.07220613f, 0.06953467f, 0.03767701f, 0.21942300f, 
    -0.15356681f, -0.01159489f, -0.03971415f, 0.04785142f, 0.01496860f, -0.16990535f, 0.18071735f, -0.06936903f, 
    0.00158111f, 0.32313016f, -0.29936364f, 0.12124830f, 0.02269151f, -0.08755744f, 0.02558475f, 0.11191068f, 
    -0.01764405f, 0.07752497f, 0.00014888f, 0.13514552f, 0.04265476f, -0.04304872f, 0.00439877f, 0.14596894f, 
    -0.00728622f, 0.12556259f, -0.05533822f, -0.05816364f, -0.01132549f, -0.02501407f, -0.01720552f, -0.13333163f, 
    -0.46003404f, 0.62640548f, -0.47485945f, 0.11776435f, 0.01043319f, 0.03961565f, -0.08100518f, -0.10224114f, 
    -0.18721785f, -0.08569148f, -0.19379942f, 0.01207968f, 0.11544653f, 0.00584058f, -0.06048092f, -0.03331671f, 
    0.06178219f, -0.01408878f, 0.05431018f, -0.24604766f, 0.12127370f, 0.00622856f, -0.02773811f, 0.06371072f, 
    -0.08819266f, 0.11054953f, -0.05824281f, -0.15452135f, 0.02326496f, -0.08974504f, -0.22453859f, -0.01624218f, 
    -0.21861501f, -0.11788882f, 0.11114866f, -0.20143919f, -0.20753370f, 0.14943512f, 0.44719326f, -0.11988585f, 
    -0.27180156f, 0.03740329f, -0.16897127f, -0.03514801f, 0.12329680f, 0.00524828f, -0.10230052f, -0.07460783f, 
    0.34652954f, 0.04913409f, -0.05522797f, -0.04296369f, 0.01058003f, 0.05144811f, -0.18513851f, -0.15567455f, 
    0.01762668f, -0.01443544f, -0.09641314f, 0.03072258f, -0.41314074f, 0.05322689f, -0.16834167f, -0.08115650f, 
    0.15008323f, 0.08970229f, 0.03450039f, -0.02482060f, 0.00556893f, -0.08805872f, 0.11390762f, -0.02824554f, 
    0.07537708f, -0.14298588f, -0.02862640f, 0.01962014f, 0.05555970f, 0.11314998f, 0.00904148f, 0.13351755f, 
    0.12644337f, -0.04109858f, -0.01409379f, -0.21090242f, 0.10153361f, -0.03814755f, -0.01572562f, -0.02137960f, 
    0.15441428f, 0.06477156f, 0.01099483f, 0.03075155f, -0.09704407f, 0.01883378f, 0.07713639f, -0.00627366f, 
    0.24844359f, -0.05756167f, 0.21883881f, 0.20294088f, 0.09453418f, 0.01656835f, 0.05826078f, -0.07298230f, 
    -0.02328109f, 0.17184989f, -0.03571825f, -0.03541573f, -0.07272250f, -0.34904447f, 0.08376569f, 0.23390853f, 
    -0.26931643f, -0.08131424f, 0.01248736f, -0.08800138f, 0.08900773f, 0.10611769f, 0.00254006f, -0.02992078f, 
    0.18243504f, -0.07777593f, -0.48380786f, -0.13764662f, 0.10900009f, 0.11205156f, 0.09989191f, 0.19087498f, 
    0.01603208f, 0.10925119f, -0.03934896f, 0.01764572f, -0.23529516f, -0.07218228f, -0.01220484f, -0.30185813f, 
    0.22926384f, 0.23187722f, 0.15751572f, 0.05619832f, -0.07481219f, -0.02489944f, -0.06368654f, -0.10050655f, 
    -0.07545345f, 0.14627668f, -0.10395888f, 0.31325617f, 0.12208164f, 0.18846908f, -0.15820763f, -0.10646364f, 
    -0.16725440f, -0.08426074f, 0.02713284f, -0.04559006f, -0.39294806f, -0.18301603f, 0.49673033f, 0.08767794f, 
    -0.14642045f, -0.18667053f, -0.14538142f, -0.07622791f, -0.19375549f, 0.11542925f, -0.04756132f, 0.01305693f, 
    0.18852097f, 0.00757954f, -0.12126473f, 0.12909196f, 0.06059982f, -0.02629024f, 0.05553467f, 0.03091264f, 
    -0.02789297f, 0.01753489f, 0.07891894f, 0.05999447f, -0.34974518f, -0.07629556f, -0.10505018f, 0.22841118f, 
    0.01334081f, 0.11079088f, 0.18605968f, 0.05432207f, -0.04066421f, 0.11922689f, -0.12722081f, 0.08150585f, 
    -0.21233250f, -0.03646139f, -0.37885100f, -0.28138462f, 0.00002161f, 0.14643618f, 0.01830121f, 0.00298694f, 
    0.11303740f, -0.38892657f, 0.05483703f, -0.04009698f, 0.18434776f, 0.19597769f, -0.10548100f, -0.37318954f, 
    0.28361192f, 0.03040247f, 0.07840887f, 0.11384612f, -0.29798442f, 0.05228252f, 0.08311306f, 0.02578625f, 
    -0.02842399f, 0.14323376f, 0.04147234f, 0.29940972f, 0.08304285f, 0.00919384f, 0.10235851f, 0.03072564f, 
    0.03610466f, 0.06840356f, 0.04365873f, 0.14693257f, -0.05154909f, 0.01951375f, -0.01902657f, 0.09109085f, 
    0.02624496f, -0.06707756f, 0.04148087f, -0.18412769f, -0.04232626f, 0.23098007f, 0.08318568f, 0.04321849f, 
    0.02614155f, -0.13023943f, -0.09136833f, 0.17359892f, 0.04217676f, -0.06594919f, 0.05873021f, -0.19641961f, 
    0.04167562f, 0.06791583f, 0.06381094f, -0.00963052f, -0.12930019f, 0.10212560f, -0.16780938f, 0.19648549f, 
    0.21396539f, 0.17485054f, -0.01011549f, 0.08491836f, -0.11684848f, -0.02957113f, 0.07743970f, -0.11669814f, 
    0.00421196f, -0.26599014f, 0.03247695f, 0.13179332f, 0.03969995f, 0.04629827f, 0.01646119f, -0.04094215f, 
    -0.02888916f, -0.02099894f, 0.02713771f, 0.03868639f, -0.09358056f, -0.07169899f, -0.08491285f, 0.23418209f, 
    -0.05846372f, 0.02543533f, -0.05933353f, -0.05027883f, -0.05379234f, -0.06228694f, -0.02668947f, 0.08185624f, 
    -0.28476557f, -0.23121259f, 0.04596996f, -0.14963385f, 0.18924847f, -0.00550532f, 0.06145718f, 0.01141091f, 
    -0.17809534f, 0.02958968f, -0.03664625f, 0.00183023f, 0.01334933f, -0.32399213f, 0.00818197f, -0.44742596f, 
    0.02194147f, -0.28128219f, -0.10595221f, 0.11887991f, -0.01989083f, 0.00295931f, -0.16085920f, -0.11145185f, 
    -0.00851271f, -0.14646877f, -0.06150753f, 0.17199370f, 0.07725909f, -0.07699687f, -0.02972243f, -0.19989352f, 
    -0.02445723f, 0.05960329f, -0.02418394f, 0.12376828f, -0.48873937f, 0.05461424f, 0.01337784f, 0.15024635f, 
    -0.10661054f, 0.01983138f, 0.01190249f, -0.09087630f, 0.00018154f, 0.07012716f, 0.09603789f, -0.03285702f, 
    -0.65139371f, 0.04851516f, -0.05170884f, 0.21002588f, 0.04281786f, -0.12668557f, -0.06621134f, -0.00505958f, 
    -0.07040104f, -0.02514919f, -0.15304765f, -0.10634318f, 0.21489644f, -0.24618471f, 0.17775978f, 0.02928810f, 
    -0.05731592f, -0.02085656f, 0.01812562f, 0.06053078f, -0.05719682f, -0.02605563f, -0.03872973f, 0.09021302f, 
    0.20649490f, 0.16013096f, 0.16854228f, 0.12857860f, 0.10832471f, 0.09662416f, -0.24265514f, -0.03180890f, 
    -0.00985824f, 0.15772600f, -0.02607476f, -0.15074643f, -0.31608728f, 0.16385920f, 0.06246266f, 0.19423574f, 
    -0.11537104f, -0.40272057f, 0.32797971f, -0.20914875f, -0.22380057f, 0.18297592f, -0.13771456f, 0.03780989f, 
    0.00913015f, -0.26142776f, 0.05002993f, 0.27989084f, -0.05419641f, -0.07006799f, -0.01738488f, -0.21961902f, 
    -0.09526618f, 0.06483752f, 0.09559830f, -0.03270244f, 0.15612358f, 0.00669837f, 0.32613179f, -0.23671947f, 
    -0.22998418f, -0.03626985f, -0.08563411f, -0.04658090f, 0.11263294f, 0.14261900f, 0.15868869f, -0.03901502f, 
    0.28080472f, -0.07324574f, -0.02538037f, 0.06201839f, 0.08239776f, 0.08690211f, -0.05276544f, 0.01050089f, 
    -0.02357033f, 0.04888052f, -0.00484006f, 0.07311504f, -0.13402891f, -0.06884175f, -0.17339681f, 0.05211348f, 
    -0.00171625f, 0.04100301f, -0.13974057f, 0.04075609f, 0.02098449f, -0.05771793f, 0.01881191f, -0.04601291f, 
    -0.10664432f, -0.07448153f, 0.01654619f, 0.23793475f, 0.07334401f, -0.01660747f, 0.15490699f, -0.08216265f, 
    -0.03422282f, -0.00994461f, 0.05141808f, 0.02703178f, 0.11123455f, -0.09966099f, 0.24748537f, 0.34585291f, 
    0.00102995f, 0.02128348f, -0.18667302f, 0.03209351f, 0.03138668f, -0.04813054f, 0.22507833f, -0.01310328f, 
    -0.08694950f, -0.09587529f, -0.12836660f, 0.23605746f, -0.11067297f, -0.02573386f, -0.04787224f, -0.04224795f, 
    -0.04314429f, -0.09861350f, -0.01768862f, 0.01951461f, 0.32753134f, 0.34056976f, 0.02329176f, -0.03752639f, 
    0.04285533f, 0.22227746f, 0.07895631f, -0.14724907f, -0.09170562f, 0.01651654f, 0.02388575f, 0.11454403f, 
    0.06115336f, 0.06793006f, 0.02844928f, 0.03320303f, 0.14829117f, 0.05738816f, 0.08556561f, 0.01232675f, 
    0.09488383f, -0.01192261f, 0.03752771f, 0.07865303f, 0.09816700f, 0.15771061f, 0.11889681f, 0.07310341f, 
    -0.05686120f, -0.09475482f, -0.08942381f, 0.27827254f, -0.04430340f, -0.01160239f, -0.01319379f, -0.11277344f, 
    -0.12919618f, 0.10892871f, -0.06875887f, -0.16615763f, -0.00387322f, -0.10850314f, 0.08553253f, -0.08276280f, 
    0.00555986f, -0.03226884f, -0.03127237f, 0.23098347f, -0.15102537f, -0.46202192f, 0.07326596f, -0.60920835f, 
    -0.00288206f, -0.01583498f, -0.05898268f, 0.08773266f, 0.00961381f, -0.18257011f, 0.05322163f, -0.06104602f, 
    -0.11127722f, -0.17131804f, -0.24868813f, -0.20469950f, 0.12530969f, -0.05486308f, 0.08737576f, -0.03342938f, 
    0.04767228f, 0.03798481f, -0.01324491f, -0.06169124f, 0.05431397f, 0.10327624f, 0.17148949f, 0.10098370f, 
    -0.05397701f, -0.06378517f, 0.12162623f, 0.07141703f, -0.01597442f, 0.00612120f, 0.02735240f, -0.05815615f, 
    0.11149136f, -0.03661318f, 0.03225762f, -0.09897454f, 0.10536057f, -0.00110874f, 0.00819411f, -0.00824300f, 
    0.01772477f, -0.01754233f, -0.14687540f, 0.01856130f, -0.08486123f, 0.00926916f, 0.14435054f, 0.14603053f, 
    -0.00935943f, -0.12452239f, -0.07865226f, 0.00646917f, -0.06593703f, -0.05257664f, -0.05796560f, 0.02130153f, 
    -0.23375563f, 0.01824451f, -0.08404608f, 0.04083645f, 0.00800319f, -0.00521525f, 0.00148094f, -0.03148715f, 
    0.11364181f, 0.01888786f, -0.07150279f, 0.01518732f, 0.18674919f, -0.26036602f, -0.14026245f, -0.01378229f, 
    -0.00843381f, -0.09683550f, -0.07829254f, -0.09407062f, 0.10334627f, 0.08938165f, -0.15075701f, -0.07809802f, 
    -0.27502492f, -0.12972064f, -0.02919084f, -0.04789222f, 0.08092745f, 0.05221182f, -0.08646359f, 0.02832684f, 
    -0.23393218f, 0.05471492f, -0.07287179f, -0.15509008f, 0.14707650f, -0.20030127f, -0.04681348f, 0.01867456f, 
    -0.01087566f, -0.10650364f, 0.04026216f, -0.02413756f, -0.05662829f, -0.25854492f, -0.10046796f, -0.23249362f, 
    -0.18353492f, 0.02741458f, -0.01039219f, 0.05288480f, -0.05038276f, -0.16481823f, 0.01068505f, 0.02094156f, 
    -0.09802870f, -0.10997828f, 0.01711352f, 0.06760362f, -0.00527809f, 0.21932314f, -0.25605842f, -0.11082184f, 
    0.02081160f, -0.08826659f, -0.17463621f, 0.03352099f, -0.05262779f, -0.07167444f, 0.02445234f, -0.10327266f, 
    -0.26112434f, 0.02608697f, 0.00158522f, -0.02407683f, -0.18769097f, -0.05281417f, -0.01557285f, -0.23319924f, 
    -0.05252237f, -0.04160145f, 0.09545580f, 0.03677269f, 0.06809498f, -0.13066372f, -0.08085764f, 0.03472758f, 
    0.06702024f, -0.10843483f, 0.04034035f, -0.05840635f, 0.11591998f, -0.21255951f, -0.08818662f, -0.46178013f, 
    -0.07608157f, -0.05079874f, -0.16544989f, -0.12746957f, -0.20389202f, -0.02647986f, 0.04692567f, -0.04788014f, 
    0.08331560f, -0.00303413f, -0.02544073f, 0.07559688f, -0.20501262f, -0.05278070f, -0.15183987f, -0.14926217f, 
    0.04704433f, 0.04739443f, -0.05388718f, -0.00685929f, 0.05575919f, 0.03669979f, 0.00756562f, -0.05453530f, 
    0.12331719f, -0.07826634f, -0.03894283f, -0.06400496f, 0.00373758f, -0.02595273f, 0.06421281f, 0.09273639f, 
    -0.43248057f, -0.12848742f, -0.13467848f, 0.01350046f, -0.25208306f, -0.29248479f, -0.16803479f, 0.17641318f, 
    -0.06788252f, 0.08417945f, -0.07105781f, -0.02486756f, -0.04848627f, -0.07019132f, -0.09959196f, 0.14316161f, 
    0.00235757f, 0.06724434f, 0.16336672f, 0.11322199f, -0.05500739f, -0.05436450f, -0.01263469f, 0.11019533f, 
    0.00322463f, 0.01156791f, 0.02349236f, 0.09462964f, -0.16606842f, 0.00823077f, -0.13898003f, 0.03329966f, 
    0.02421503f, 0.12020174f, -0.24381085f, -0.02008462f, -0.05561235f, 0.12320417f, -0.03710571f, -0.07751004f, 
    -0.16070873f, -0.21169916f, 0.56741959f, 0.21007249f, 0.04168569f, 0.08223998f, -0.17928796f, -0.00343953f, 
    -0.06559800f, -0.03526374f, 0.00020105f, -0.00926947f, -0.03343923f, 0.29943928f, 0.16089725f, 0.23489608f, 
    -0.03898660f, 0.10730708f, -0.06412140f, 0.18358144f, 0.03015568f, -0.04380884f, 0.00574456f, -0.12390913f, 
    -0.19026789f, -0.20341213f, 0.12181977f, -0.25671041f, -0.06229514f, 0.18147090f, -0.11447381f, 0.09431738f, 
    -0.15226303f, 0.05121290f, -0.03613990f, 0.05210459f, 0.08349880f, 0.06098289f, 0.05383256f, 0.09011908f, 
    0.01553505f, -0.07432867f, 0.09848364f, 0.00904214f, 0.00530832f, -0.08127052f, -0.18817389f, -0.04533374f, 
    0.07261715f, 0.06894717f, 0.02976953f, 0.12260704f, 0.06810902f, 0.02460915f, 0.01579027f, 0.02957051f, 
    0.02258817f, -0.19387922f, -0.21025731f, 0.03048350f, 0.39186478f, 0.03421680f, -0.08354137f, 0.11447199f, 
    -0.02271678f, -0.08964900f, 0.15487908f, -0.17748880f, 0.05718539f, -0.02136648f, -0.03037916f, -0.13785508f, 
    -0.16078475f, 0.05330971f, -0.08582996f, 0.24451153f, -0.15904501f, 0.08640860f, 0.01403222f, -0.01743539f, 
    0.10797357f, 0.03217147f, -0.04218557f, -0.12106182f, -0.00492521f, 0.14173175f, -0.05887348f, 0.19743624f, 
    -0.17258167f, -0.00127431f, 0.06879715f, -0.06535675f, -0.10955862f, -0.05300380f, -0.16848731f, -0.04786050f, 
    0.05450667f, 0.21010193f, 0.31166944f, 0.23346362f, -0.14695092f, -0.05475045f, 0.03834802f, 0.11051633f, 
    0.04583859f, -0.02540006f, 0.00937012f, -0.02188311f, 0.07787367f, -0.02389556f, 0.01671635f, 0.08466087f, 
    0.00951053f, -0.00713193f, 0.04811098f, -0.07147387f, 0.20906609f, 0.14007947f, 0.17184368f, 0.15013239f, 
    -0.06785291f, 0.38289377f, 0.19136454f, 0.31746417f, -0.06218088f, -0.06308451f, -0.06429756f, 0.03663172f, 
    0.08609188f, -0.13394466f, -0.04848196f, -0.03357389f, -0.02848763f, 0.19343284f, 0.01897819f, 0.19644648f, 
    -0.27362815f, 0.18845682f, -0.03447102f, 0.01578498f, 0.00981623f, -0.02542914f, -0.04629736f, -0.10718732f, 
    0.05012865f, -0.00889205f, 0.01457698f, -0.14530091f, 0.04152493f, -0.02286542f, 0.10923443f, 0.04155713f, 
    0.10729115f, -0.05255853f, 0.20460112f, 0.11936952f, 0.13807367f, 0.06981239f, -0.04078015f, -0.06119293f, 
    0.08439773f, 0.03772167f, -0.01608913f, 0.04186026f, -0.02392387f, 0.05364750f, -0.16921066f, 0.09622917f, 
    -0.06569389f, -0.01371972f, 0.04696957f, -0.19471404f, 0.06396836f, 0.00205565f, 0.00384342f, 0.17698874f, 
    0.09023083f, -0.05045214f, -0.05532755f, -0.15947178f, 0.06810768f, 0.10376254f, -0.32965288f, -0.17774999f, 
    0.05383708f, 0.04395667f, 0.06380264f, 0.00411603f, 0.05705007f, -0.03615165f, 0.06384865f, -0.08205405f, 
    -0.34778953f, -0.00092715f, 0.06053210f, -0.08113658f, -0.10749872f, 0.16242079f, -0.09171193f, -0.11853966f, 
    -0.01092226f, 0.02038249f, 0.00271793f, 0.15512595f, 0.11765219f, 0.11654235f, 0.10782690f, 0.05726328f, 
    0.08535800f, -0.01441571f, -0.03698181f, -0.00666746f, 0.15342189f, 0.00651352f, 0.08447659f, 0.02548679f, 
    -0.10164323f, 0.12581582f, -0.20879339f, 0.20791456f, 0.07845196f, 0.03799434f, 0.05463344f, -0.09710789f, 
    0.03989140f, 0.12604021f, -0.08540477f, -0.05859506f, 0.12309471f, -0.07549188f, 0.04461664f, 0.12251657f, 
    0.05380019f, 0.06356065f, 0.07128464f, 0.09546100f, 0.11641212f, 0.04861583f, -0.04444581f, -0.23220433f, 
    -0.26385227f, -0.08556906f, 0.21452364f, 0.14170179f, 0.08174056f, 0.06412483f, -0.06123878f, -0.10744059f, 
    0.00547055f, 0.06629811f, -0.04319211f, 0.03922854f, 0.10423878f, 0.07727009f, 0.01831300f, 0.06578176f, 
    0.04077094f, 0.03617435f, 0.02437302f, 0.02542965f, 0.01089195f, -0.03558654f, -0.20526159f, -0.31720275f, 
    0.00454241f, 0.28223994f, 0.04508048f, 0.23501065f, -0.02708952f, 0.06060102f, -0.10453593f, -0.12395827f, 
    -0.14708902f, -0.15088801f, -0.01144382f, -0.03884461f, -0.29365873f, 0.16460426f, 0.03407906f, -0.33492234f, 
    0.09401467f, 0.05073017f, 0.04597162f, 0.02688312f, -0.03483937f, 0.01294880f, 0.04197489f, 0.09846574f, 
    -0.07600547f, 0.15473378f, 0.08306620f, 0.06497902f, -0.03663351f, -0.11941066f, 0.00894692f, 0.06699868f, 
    0.04390162f, -0.02033562f, -0.22759220f, 0.07534614f, 0.03998125f, -0.06067055f, 0.07951619f, 0.03103670f, 
    -0.05597086f, -0.08578894f, -0.13888696f, -0.01435577f, 0.06814811f, -0.04564817f, -0.06146691f, -0.05584034f, 
    0.26318997f, 0.21919544f, -0.08080931f, 0.04156342f, -0.09258808f, -0.01468575f, 0.13637589f, 0.06921538f, 
    0.08858736f, -0.09331615f, -0.08739778f, 0.10999027f, -0.08349868f, -0.19736336f, -0.13665986f, -0.17726780f, 
    -0.13465178f, -0.06423846f, 0.12976393f, -0.01687893f, -0.17286019f, -0.10513284f, 0.02672565f, -0.05167688f, 
    -0.14465433f, -0.03103922f, -0.02103172f, 0.12960818f, -0.04081953f, -0.05576287f, -0.02297773f, -0.06768180f, 
    -0.04971207f, -0.01574483f, -0.00024885f, 0.12570707f, -0.03943745f, -0.12466387f, -0.17486851f, -0.09117547f, 
    0.05331355f, -0.05593343f, -0.06825644f, -0.05489440f, 0.03522335f, 0.01529239f, 0.06810035f, 0.09924059f, 
    0.05608444f, -0.04270396f, 0.06319058f, -0.10159442f, 0.04550562f, 0.06736775f, 0.00710385f, -0.03754118f, 
    -0.01491068f, -0.08232900f, -0.15560935f, -0.02706087f, 0.21770084f, 0.26105845f, -0.27303323f, 0.27277339f, 
    0.17987914f, -0.07054216f, -0.05724058f, -0.03882920f, 0.05855912f, 0.00697807f, 0.08185989f, 0.00471005f, 
    0.07932940f, -0.06689695f, 0.04449891f, -0.12028550f, -0.09073299f, -0.16798943f, -0.00425609f, -0.13054574f, 
    -0.01237068f, -0.01667626f, 0.00408231f, 0.01153944f, 0.07093438f, -0.06794723f, 0.02554711f, 0.00740949f, 
    0.05554787f, 0.06535992f, -0.09460128f, -0.03545491f, -0.04533050f, 0.12399393f, -0.00309682f, -0.08675074f, 
    -0.46664649f, -0.00083406f, -0.11010381f, -0.11117671f, 0.01466006f, -0.08724895f, 0.00916404f, 0.19352770f, 
    -0.00325573f, 0.04869348f, -0.03029614f, 0.11061026f, 0.18235469f, 0.08373321f, -0.28461942f, -0.04158003f, 
    0.05131429f, 0.02646817f, 0.02095293f, -0.00723183f, 0.12907957f, -0.07639374f, -0.05422959f, 0.05774837f, 
    0.19066785f, 0.18331005f, -0.03230870f, 0.10712364f, -0.10931905f, -0.00080333f, 0.01930285f, -0.20178759f, 
    -0.03535924f, -0.21407320f, -0.02854434f, -0.13777815f, -0.03399258f, -0.01742599f, 0.19822694f, 0.08620315f, 
    -0.10512371f, -0.07361951f, -0.17892802f, -0.02597664f, 0.01919836f, 0.01873235f, 0.00823270f, 0.00031563f, 
    0.11557633f, 0.05987591f, 0.09361343f, 0.12283561f, -0.15507333f, -0.18064605f, -0.03059961f, -0.04664089f, 
    -0.01880015f, 0.10850203f, 0.05864230f, 0.00189095f, -0.02754286f, 0.14339961f, -0.09962615f, -0.00174831f, 
    -0.03213041f, -0.13276367f, 0.00081024f, -0.25035906f, 0.05800524f, -0.02256859f, 0.01793189f, 0.00894481f, 
    0.03238517f, 0.10988946f, 0.21127540f, 0.11007603f, -0.13822944f, 0.06359033f, -0.05767256f, 0.10074357f, 
    0.10072187f, -0.04768226f, -0.00938314f, 0.07421694f, 0.00032967f, 0.00940923f, -0.02057215f, -0.00345660f, 
    0.10061159f, -0.01526566f, 0.01835690f, 0.04481955f, -0.13101020f, -0.16887289f, 0.04116581f, 0.13812730f, 
    -0.09781980f, -0.15369067f, -0.05957952f, -0.02731886f, -0.00989065f, -0.01909093f, -0.06632870f, -0.09569358f, 
    0.12605532f, -0.12314543f, -0.02733771f, -0.02689249f, 0.17804886f, -0.06715887f, -0.06345235f, -0.11691422f, 
    0.00318408f, 0.34924427f, -0.05950659f, -0.12979174f, -0.08103444f, -0.13624819f, 0.01537790f, 0.00149628f, 
    0.01975465f, -0.03659857f, -0.11149571f, -0.04657628f, -0.02588797f, 0.08352762f, 0.09429832f, 0.02984068f, 
    0.13556670f, -0.10597765f, 0.01266886f, -0.23815766f, 0.53327495f, -0.36065876f, 0.25779286f, 0.08707277f, 
    0.11524214f, -0.01086221f, -0.02851683f, -0.10969112f, -0.02782507f, 0.09452305f, -0.02582115f, 0.06727934f, 
    -0.18587993f, -0.20604804f, -0.14034499f, 0.30236581f, -0.02102432f, -0.01775414f, 0.03218472f, 0.01522469f, 
    0.06549611f, 0.13793032f, -0.01329859f, -0.02439224f, 0.10006210f, 0.21851182f, 0.12442344f, -0.00942296f, 
    0.22801876f, 0.08482062f, 0.11082640f, 0.01244706f, -0.00366158f, -0.02180291f, 0.05039621f, 0.09486330f, 
    -0.15695995f, -0.06058076f, 0.13818033f, 0.09301539f, -0.01492631f, -0.01785169f, -0.04829443f, 0.01762681f, 
    -0.03871936f, -0.02640311f, 0.10571305f, -0.02695459f, 0.13151707f, -0.21028812f, 0.09978187f, -0.03671968f, 
    -0.07962696f, 0.22426319f, 0.11072472f, 0.08777342f, 0.14150305f, 0.12085810f, 0.04098263f, 0.02048695f, 
    -0.35503703f, -0.08129971f, 0.07723577f, 0.12408413f, -0.01354878f, -0.11073608f, 0.01741517f, 0.01484897f, 
    -0.09972120f, -0.04046989f, 0.11794691f, -0.09059037f, 0.06862744f, 0.07843182f, 0.10463343f, 0.08229522f, 
    -0.20025046f, 0.04919731f, -0.05891519f, -0.00027320f, 0.09728896f, 0.04167835f, 0.09425785f, -0.12803119f, 
    0.15627688f, -0.02202651f, -0.24538963f, 0.36881146f, 0.01165001f, -0.08844797f, -0.01002480f, -0.09990522f, 
    -0.12953594f, 0.03743559f, -0.01953045f, -0.29938188f, -0.20049813f, -0.06110317f, -0.11103582f, 0.15790366f, 
    0.13454446f, -0.08464154f, 0.00284575f, 0.03603506f, 0.12798485f, 0.05522270f, -0.07065862f, 0.09257686f, 
    -0.12999444f, -0.14439619f, -0.22813241f, -0.15706845f, 0.07778118f, -0.00513666f, -0.00458686f, 0.09294129f, 
    -0.09615803f, -0.22168425f, -0.08864739f, -0.01525198f, 0.00119921f, -0.01347177f, -0.21241194f, 0.18049867f, 
    0.16887042f, -0.01459189f, -0.03585008f, 0.15534690f, -0.00094171f, -0.11779243f, 0.25231618f, -0.20066789f, 
    0.01640088f, -0.07865240f, -0.05307443f, 0.05060237f, 0.11896147f, -0.19272593f, 0.10815308f, 0.14733459f, 
    -0.05705469f, -0.04585958f, 0.11521818f, -0.03353249f, -0.01071933f, 0.03383481f, -0.27611336f, 0.30616987f, 
    0.06699990f, -0.05341515f, 0.05657742f, 0.01776230f, 0.03894744f, 0.05864426f, 0.23682947f, -0.00116993f, 
    0.12365680f, -0.16856976f, -0.08980406f, 0.10461897f, 0.14783628f, -0.05805947f, 0.07094749f, 0.16020681f, 
    0.08814614f, 0.06335982f, -0.02775046f, 0.01768813f, -0.18360130f, 0.15960151f, -0.60055035f, -0.17797658f, 
    0.00409387f, 0.05015359f, 0.00068651f, -0.01646940f, 0.02588807f, 0.01199433f, 0.01425426f, 0.07574902f, 
    0.21158713f, -0.20709017f, 0.16255574f, 0.07515332f, -0.04184967f, -0.01073091f, -0.07571153f, 0.06841069f, 
    -0.01386458f, -0.09915400f, -0.02709912f, 0.15606222f, -0.22082284f, -0.41719601f, 0.50867075f, 0.09421199f, 
    0.05693575f, -0.00884490f, -0.04923758f, 0.05912162f, -0.00315707f, -0.08461781f, -0.07699496f, 0.06191435f, 
    0.05009839f, 0.05031662f, 0.09149052f, 0.03284889f, 0.02976160f, 0.03313217f, -0.10790407f, -0.13548116f, 
    0.00533891f, 0.01171724f, -0.04951237f, 0.05856279f, 0.05581590f, 0.11853293f, -0.08581076f, -0.09939767f, 
    0.04085612f, -0.00756484f, 0.02754328f, -0.07104071f, -0.03603743f, 0.22682165f, 0.02733875f, -0.13658874f, 
    0.12475640f, -0.07149969f, 0.44971406f, -0.18641596f, 0.02026495f, 0.11218731f, 0.09894606f, 0.01751155f, 
    0.14754471f, -0.04495461f, 0.05530950f, -0.00854454f, 0.08441404f, 0.14555365f, -0.07826249f, -0.10015371f, 
    0.10385917f, 0.00699505f, 0.09826940f, -0.14816320f, 0.05924409f, -0.00845223f, -0.00913584f, 0.05342563f, 
    0.03218593f, 0.01442391f, -0.19550370f, -0.21045220f, -0.09685096f, -0.01194205f, -0.04051521f, -0.01447223f, 
    -0.08364185f, -0.00226543f, -0.25729349f, -0.05421136f, 0.00289118f, -0.04686637f, -0.00717554f, -0.04308322f, 
    -0.18551932f, -0.17629281f, -0.03317124f, -0.00165543f, 0.01905530f, -0.02195672f, 0.06727143f, 0.07201414f, 
    -0.16316286f, 0.04811050f, 0.14070445f, -0.16230680f, -0.03452056f, 0.06299637f, -0.06256357f, -0.01044638f, 
    0.21091016f, 0.05532045f, -0.00349494f, 0.15578464f, -0.28371102f, -0.00123497f, -0.23698422f, 0.17238747f, 
    0.01203560f, 0.08730693f, -0.14409648f, 0.11303914f, -0.03345969f, 0.08829726f, -0.03831453f, 0.07947695f, 
    -0.00177353f, 0.04291327f, -0.00493595f, 0.03259689f, 0.00810937f, -0.14226305f, 0.05452733f, 0.14418548f, 
    -0.09585476f, 0.07328846f, 0.02586214f, -0.01061270f, -0.39195466f, -0.15628681f, 0.11578710f, 0.06659056f, 
    0.05487539f, -0.09452805f, 0.10906176f, 0.08663378f, 0.10434543f, 0.27049339f, -0.08086871f, 0.10224202f, 
    0.27331898f, 0.01131351f, 0.13035424f, 0.03918922f, 0.26648825f, 0.19636269f, 0.17722458f, -0.12213857f, 
    0.09530222f, 0.01052646f, 0.01296276f, 0.04270779f, 0.00526595f, 0.12256537f, -0.04304255f, -0.01625261f, 
    0.02987925f, 0.00830506f, -0.00001779f, 0.05942591f, -0.17090325f, -0.30227128f, -0.16817515f, -0.02441905f, 
    -0.10819281f, 0.12342872f, -0.40521184f, 0.06865349f, -0.02226522f, 0.08225080f, -0.01071240f, -0.00181659f, 
    -0.05883439f, 0.03050185f, -0.10039558f, -0.02558206f, -0.07922222f, -0.20606841f, 0.02539172f, -0.17124322f, 
    0.21741173f, 0.19893070f, -0.10519167f, 0.05929737f, -0.02571021f, 0.05464235f, 0.03770137f, 0.02339217f, 
    0.11952552f, -0.04612929f, -0.20424107f, -0.05338336f, -0.01392025f, 0.00401206f, 0.01314530f, 0.08115196f, 
    -0.31501910f, -0.24189383f, -0.12211680f, -0.10655437f, -0.16558860f, -0.04407291f, -0.06148273f, 0.08763775f, 
    0.00934133f, 0.01196120f, -0.07203854f, -0.05743381f, 0.08057507f, -0.11201727f, 0.14587902f, -0.12441140f, 
    0.28999957f, -0.13765731f, -0.10554940f, 0.17014195f, -0.06006984f, 0.05665123f, -0.00098263f, -0.09621588f, 
    0.27810332f, -0.04086207f, 0.08463883f, 0.30144435f, 0.26789600f, 0.06526996f, -0.36932003f, -0.34223518f, 
    0.03128263f, 0.14609569f, -0.09505651f, 0.07866322f, 0.09159870f, -0.09341392f, 0.07292594f, 0.03036724f, 
    0.02711340f, 0.09792875f, 0.05960078f, -0.16738561f, -0.07370540f, -0.40372059f, -0.12150358f, 0.16931516f, 
    -0.02469727f, -0.05155357f, -0.11300675f, -0.15666062f, 0.06411912f, 0.02790454f, -0.03637651f, -0.08939680f, 
    0.01972272f, 0.02264962f, 0.02216540f, -0.08882730f, -0.17677186f, -0.09578931f, 0.02600044f, -0.17336032f, 
    -0.05480136f, 0.00288077f, 0.07193522f, -0.20818754f, -0.03668002f, -0.07012646f, 0.01879484f, 0.06312307f, 
    -0.01907197f, 0.08743589f, -0.09147939f, 0.17565544f, -0.07363940f, -0.25428018f, 0.05379610f, 0.00280459f, 
    -0.01024724f, 0.00317721f, -0.02830765f, -0.06688048f, 0.10462929f, -0.13974640f, 0.17033871f, 0.03929064f, 
    -0.08787651f, 0.03032178f, -0.23327252f, -0.45054293f, -0.09721078f, -0.03687327f, -0.00570202f, 0.05014948f, 
    0.04287702f, -0.07768064f, 0.18790880f, -0.15084912f, -0.15964831f, -0.10011847f, 0.17725280f, -0.00972910f, 
    -0.29293972f, 0.02339991f, -0.00463017f, -0.08948584f, 0.10126250f, -0.05957749f, 0.21707024f, 0.22994992f, 
    -0.18235083f, -0.07216424f, 0.18081684f, -0.36381155f, -0.03774484f, 0.02410046f, -0.00758899f, 0.02963928f, 
    0.12298854f, 0.11481028f, 0.12365518f, 0.04224169f, 0.04864763f, 0.12100545f, -0.53379077f, -0.28370187f, 
    0.00101750f, -0.03301248f, 0.00139546f, -0.07233735f, 0.21635620f, -0.10449444f, -0.15466511f, -0.06053406f, 
    -0.29324880f, -0.21142037f, -0.01288960f, -0.26818836f, -0.00929285f, 0.00725691f, -0.06527811f, 0.02698332f, 
    -0.00777791f, 0.03368808f, 0.09742402f, -0.07751776f, 0.13194406f, -0.01180820f, -0.07995689f, -0.04530640f, 
    0.09785321f, -0.01081539f, -0.02217841f, 0.14830580f, -0.06054688f, 0.03879837f, 0.00862801f, 0.04560952f, 
    -0.63605547f, -0.65306193f, -0.04622393f, -0.07996931f, 0.00841172f, 0.00792628f, -0.15630026f, 0.12747611f, 
    0.01757560f, -0.03342458f, -0.05600293f, -0.01161707f, 0.14379944f, -0.19856092f, 0.06055632f, 0.36445192f, 
    0.13342924f, -0.02739246f, -0.10461548f, 0.14069559f, 0.16913718f, -0.04154722f, 0.14998803f, -0.02518950f, 
    -0.20286810f, 0.14027317f, -0.00176959f, -0.19550453f, -0.05215453f, -0.01893076f, 0.01290671f, 0.18349046f, 
    -0.02455282f, -0.10964882f, -0.02685889f, 0.02002938f, 0.31295413f, -0.01434252f, -0.29037094f, -0.01067499f, 
    -0.05528576f, 0.11534348f, 0.01972530f, 0.09791259f, 0.27000681f, -0.28534040f, -0.23545344f, -0.25795949f, 
    -0.04639183f, -0.13834603f, -0.21386278f, 0.14683858f, 0.03306574f, 0.00952371f, 0.07729207f, 0.03490588f, 
    -0.08830873f, 0.18199521f, -0.03392798f, 0.09779963f, -0.32089129f, 0.44927320f, -0.08208742f, 0.19171920f, 
    -0.09593862f, -0.15584210f, 0.05422589f, -0.08363999f, -0.08968695f, -0.03684399f, -0.04384373f, -0.06380033f, 
    -0.25367430f, -0.03160807f, -0.24712722f, 0.05297566f, 0.14753523f, -0.05582513f, 0.00646993f, 0.03347153f, 
    0.15112272f, 0.07183634f, -0.07514104f, 0.00279692f, -0.09779924f, -0.05679436f, -0.01704353f, -0.12052147f, 
    -0.10391416f, -0.01412107f, -0.09396479f, 0.04330336f, -0.03156834f, -0.10406594f, -0.03917447f, -0.06624955f, 
    0.30081475f, -0.09178782f, -0.37952229f, 0.00921269f, 0.00672376f, 0.05523876f, -0.11322097f, 0.25836417f, 
    0.04339005f, -0.18303385f, -0.06899375f, 0.23243292f, -0.21641016f, -0.22891618f, -0.26571429f, 0.02755169f, 
    0.00359079f, 0.05809255f, 0.00479514f, 0.02478131f, -0.03973921f, 0.00947699f, -0.08184178f, -0.14949122f, 
    -0.49793947f, -0.32960975f, 0.12207511f, 0.00124660f, 0.03642566f, -0.04017122f, -0.00773464f, -0.10881917f, 
    0.16983156f, 0.02299383f, 0.13358775f, -0.08080687f, 0.08212616f, 0.23657520f, -0.03730200f, -0.08736562f, 
    0.20505171f, 0.03499090f, 0.10596438f, -0.07419724f, 0.01682869f, 0.09683714f, 0.03614697f, 0.14423957f, 
    0.02372891f, 0.12124028f, -0.15225519f, -0.13155754f, -0.03647519f, 0.05963887f, -0.02698670f, -0.12779976f, 
    0.08539644f, -0.08439282f, -0.03939252f, -0.09769282f, -0.16192459f, 0.04037822f, -0.21140100f, -0.30163458f, 
    0.16426760f, -0.05131766f, 0.27823561f, -0.00252481f, 0.16970199f, 0.10649382f, -0.02078799f, -0.05921072f, 
    0.00021218f, -0.01898392f, 0.20956877f, -0.20238328f, 0.00009088f, -0.18715453f, 0.06675047f, -0.02602016f, 
    -0.05319646f, -0.06612397f, -0.06878177f, -0.10444432f, -0.11743474f, -0.10625575f, 0.08907478f, 0.02593745f, 
    -0.06497950f, -0.03206423f, -0.09309751f, -0.03235257f, 0.12183458f, -0.02092133f, 0.07025635f, -0.26718751f, 
    -0.09348654f, -0.02572837f, 0.02125647f, 0.00389681f, 0.05668325f, 0.02825942f, -0.09490843f, -0.01133394f, 
    -0.08171105f, -0.10238046f, -0.13281195f, -0.15512706f, 0.07016107f, -0.02259884f, 0.04501797f, -0.03240223f, 
    -0.10636164f, -0.06162689f, 0.00085052f, -0.01565941f, 0.02347453f, -0.03173723f, -0.09933172f, -0.02859167f, 
    0.05704341f, 0.21889801f, -0.00659895f, -0.07471680f, -0.00619205f, -0.02617018f, 0.07488745f, 0.00859951f, 
    0.02412208f, 0.10306656f, 0.01871452f, 0.12560980f, -0.09520565f, 0.02244351f, -0.28025818f, -0.26714170f, 
    -0.03316325f, 0.00853504f, -0.02816253f, 0.21807453f, -0.07041158f, 0.04174836f, -0.03859230f, 0.05216627f, 
    0.03875834f, 0.08780063f, -0.11484843f, -0.27058813f, 0.01223662f, 0.04194038f, -0.00418046f, 0.01286183f, 
    -0.02699457f, -0.02716212f, 0.05667640f, -0.24210839f, -0.52713341f, -0.76361036f, -0.57004762f, -0.20872669f, 
    -0.04200181f, -0.21998769f, -0.06244418f, -0.36095405f, 0.01428902f, -0.01411192f, -0.03602720f, -0.01285093f, 
    0.03469692f, 0.05052164f, -0.10750114f, -0.00491334f, 0.03475909f, 0.05434107f, -0.02738207f, -0.01184500f, 
    -0.01272442f, -0.11139074f, -0.01539391f, 0.07660952f, -0.20055948f, -0.26692265f, -0.08517820f, 0.29538816f, 
    0.02260303f, 0.15037611f, 0.07330564f, -0.16764039f, -0.01957515f, -0.10743549f, 0.04468552f, 0.05248868f, 
    -0.25671384f, 0.09654155f, 0.28908369f, 0.02100749f, -0.02810357f, -0.00624828f, -0.03440354f, 0.08216377f, 
    0.15731150f, 0.16128300f, 0.09984600f, -0.03772673f, -0.30832195f, 0.06129879f, 0.38664281f, 0.05004332f, 
    -0.09576720f, 0.01914005f, -0.03444258f, -0.13874397f, -0.09700302f, 0.01000248f, -0.23336034f, 0.08921307f, 
    -0.14639597f, 0.24248266f, 0.11368397f, -0.08751307f, -0.06490920f, -0.00974488f, -0.01535876f, 0.10775392f, 
    0.07498443f, -0.10609400f, 0.03460643f, 0.03086935f, 0.05914747f, 0.00184611f, 0.20518649f, -0.09991729f, 
    0.03785437f, 0.00232049f, -0.05200991f, 0.07657705f, -0.09071831f, -0.00639328f, 0.15486616f, 0.05349821f, 
    -0.03291114f, 0.14262448f, 0.24665304f, 0.24762265f, -0.04095727f, 0.03136123f, 0.02059720f, 0.13245796f, 
    0.04500877f, 0.12386020f, -0.12733817f, 0.10497835f, 0.31231835f, -0.07198076f, -0.06606678f, -0.03556312f, 
    -0.08311628f, 0.01320698f, 0.16016327f, 0.15804085f, -0.01227855f, -0.00121910f, 0.15863270f, 0.05514532f, 
    0.07432113f, -0.07365593f, -0.00276128f, 0.07684505f, 0.00717620f, 0.09129876f, 0.17818847f, 0.14339870f, 
    -0.00053317f, 0.04989587f, 0.05059675f, 0.07285560f, -0.02725622f, 0.02492851f, 0.17475396f, -0.18248247f, 
    0.01198435f, 0.11893672f, 0.11288415f, -0.08657075f, -0.04958530f, 0.00718240f, -0.05502310f, -0.00127020f, 
    -0.24590591f, -0.12377106f, -0.23810405f, -0.04741114f, 0.07581963f, 0.00330835f, -0.07953469f, -0.14813715f, 
    0.01184233f, -0.09572336f, 0.07078006f, -0.01733650f, -0.45270252f, -0.04832961f, 0.33785430f, -0.18034960f, 
    0.09771588f, -0.04118878f, 0.00774637f, -0.07880888f, 0.01422235f, 0.06773502f, -0.06655461f, 0.12655160f, 
    -0.06932882f, 0.11871409f, -0.00009276f, 0.05953262f, -0.00811704f, 0.02825963f, -0.10134561f, 0.03304394f, 
    -0.07874002f, 0.02233616f, -0.20626178f, 0.07880039f, -0.09841788f, -0.14301547f, -0.13340801f, 0.29535201f, 
    -0.01730610f, 0.10839850f, 0.03393674f, 0.10251636f, 0.01678036f, -0.10910914f, 0.06895810f, 0.07926647f, 
    -0.32628793f, -0.43809217f, -0.31743842f, -0.08954953f, -0.20381509f, -0.02645380f, 0.16491774f, -0.12095012f, 
    -0.03111598f, 0.03513947f, 0.02407500f, -0.01516666f, 0.67865884f, 0.26871228f, -0.26808912f, -0.20609255f, 
    0.04574947f, -0.06293771f, 0.16681774f, 0.10389324f, -0.01098426f, 0.01778022f, 0.03539175f, -0.02279638f, 
    -0.19981995f, -0.66192967f, -0.58459377f, 0.34653419f, 0.01359976f, -0.13689330f, -0.08650704f, -0.04847966f, 
    -0.01050552f, 0.01977181f, 0.05516810f, 0.01807862f, -0.41932371f, -0.54773176f, -0.29159772f, -0.26730001f, 
    0.07003399f, -0.01080474f, 0.06425727f, -0.16305536f, 0.00277394f, 0.00576345f, -0.03770063f, 0.00726254f, 
    -0.26522306f, -0.00448520f, 0.04819183f, 0.07430500f, 0.17447430f, 0.06299764f, -0.07336538f, 0.13111985f, 
    0.03540133f, -0.04255341f, 0.11100045f, 0.03966741f, -0.10474434f, -0.11497075f, 0.02253518f, 0.02678163f, 
    -0.15872313f, -0.23466131f, -0.01350716f, 0.05732983f, -0.02133618f, -0.02748499f, -0.10516205f, -0.08019428f, 
    0.04604871f, -0.07111685f, 0.02846704f, 0.02156134f, 0.06595299f, -0.06159793f, -0.02659706f, 0.11797142f, 
    -0.08284191f, 0.08253767f, -0.00724395f, -0.01531239f, 0.02811659f, -0.21336849f, -0.32412478f, -0.27936789f, 
    -0.00190620f, 0.11873030f, 0.19028564f, 0.10727295f, -0.03516235f, 0.06400594f, -0.12566952f, 0.06277646f, 
    0.23471737f, -0.15227994f, -0.25873768f, -0.16122280f, -0.17128797f, -0.06111887f, 0.29500324f, -0.01385989f, 
    -0.00679445f, 0.05352134f, -0.17846316f, -0.16385248f, -0.03320427f, -0.12301504f, 0.20790444f, 0.15176487f, 
    -0.01936633f, -0.11650102f, -0.10638878f, 0.04892991f, -0.17754556f, 0.05178802f, 0.04009987f, -0.03031116f, 
    -0.69603944f, -0.69182134f, -0.63378048f, -0.26873109f, -0.29444417f, -0.29443184f, -0.36457255f, -0.41715959f, 
    -0.02995851f, -0.04161847f, 0.00306575f, -0.03054879f, -0.02826435f, 0.05874076f, 0.05430987f, -0.11248357f, 
    -0.06538444f, -0.01095994f, 0.03406911f, 0.10462865f, 0.19450708f, 0.20579877f, -0.01324056f, -0.05456494f, 
    0.20994809f, 0.13362856f, 0.15616436f, 0.00946548f, 0.00594992f, -0.03861207f, -0.15760791f, 0.02396076f, 
    0.03345973f, -0.08535862f, 0.04303953f, 0.03816205f, 0.16894491f, -0.03814093f, -0.25323704f, -0.02809330f, 
    -0.10315417f, 0.03128578f, 0.03969308f, 0.03655128f, -0.03479583f, 0.02738557f, -0.12483048f, -0.05452615f, 
    0.06492864f, 0.11035655f, 0.05901787f, 0.00539385f, 0.01027511f, -0.01114914f, -0.06011029f, 0.05633685f, 
    -0.01167903f, 0.15271249f, 0.14722861f, 0.16596042f, 0.02888685f, -0.02203359f, 0.05568957f, -0.09325760f, 
    -0.00023208f, 0.00538791f, -0.08004580f, 0.00731179f, 0.01185221f, 0.00911711f, -0.19769029f, -0.07595663f, 
    0.17993756f, 0.06362645f, -0.17029817f, 0.26595783f, -0.01556574f, -0.13074775f, 0.03901992f, 0.05071015f, 
    0.12242895f, 0.00626236f, 0.04145670f, -0.23913361f, -0.05026125f, -0.10583387f, 0.04211057f, -0.41068298f, 
    0.03812677f, 0.01300969f, 0.04437951f, -0.04230228f, 0.03561036f, 0.07217317f, 0.00517937f, -0.05881149f, 
    -0.30016696f, -0.35016602f, -0.09107749f, -0.10512596f, -0.14772117f, 0.07828837f, 0.03780362f, -0.07885965f, 
    0.03754720f, 0.08252048f, 0.06697088f, -0.03351489f, 0.05059692f, 0.08529302f, -0.02404816f, -0.01363432f, 
    0.02163615f, -0.01817959f, -0.03220624f, 0.02418351f, 0.03793962f, 0.00729699f, 0.04282497f, 0.10964637f, 
    0.11584382f, -0.11649290f, -0.09218694f, 0.05005634f, 0.00798605f, 0.02080362f, 0.03721353f, -0.00682943f, 
    0.01744618f, 0.13925342f, -0.06478352f, 0.05536980f, -0.09583295f, 0.02068146f, 0.04703910f, -0.13062671f, 
    -0.02245713f, -0.11068265f, -0.03115344f, 0.05829143f, 0.00453545f, 0.05975972f, 0.09266881f, 0.04289345f, 
    -0.72498089f, -0.16213524f, 0.00630849f, 0.21416587f, 0.04358252f, -0.05797308f, 0.03898656f, -0.02253259f, 
    0.05794160f, 0.05270501f, 0.14699203f, 0.07878519f, -0.06345264f, -0.06895512f, -0.03312071f, 0.03611859f, 
    -0.03090502f, -0.18788452f, 0.02290296f, -0.03539843f, 0.01035816f, 0.08606018f, -0.02296605f, -0.13924797f, 
    -0.36029139f, -0.48362544f, -0.24086830f, 0.11873422f, 0.03713420f, -0.35813421f, -0.11268522f, 0.11892062f, 
    0.00553394f, 0.17669776f, 0.01014206f, -0.03584863f, -0.07700349f, -0.02021374f, 0.23099643f, -0.14641519f, 
    0.00255409f, -0.02027414f, 0.01105563f, -0.05579918f, 0.07242042f, -0.05950664f, -0.01429383f, -0.03238820f, 
    -0.23725711f, 0.08786203f, 0.42519954f, 0.13709557f, -0.07022834f, 0.13123512f, -0.05680561f, 0.11978895f, 
    0.02869070f, 0.11507557f, -0.02165699f, 0.02153792f, 0.29991767f, 0.27126762f, -0.18858998f, -0.07368735f, 
    -0.10828265f, -0.05343389f, -0.07615434f, 0.04600824f, 0.10560552f, 0.00267080f, 0.01481833f, -0.06451054f, 
    -0.35169840f, 0.19856824f, 0.24184488f, 0.07163357f, -0.02141712f, -0.03283443f, -0.00109632f, 0.09329627f, 
    -0.02897005f, 0.08238455f, 0.06198816f, 0.13960524f, 0.03216323f, 0.07892384f, -0.11792960f, 0.31205338f, 
    -0.03056304f, -0.00032536f, 0.01835412f, 0.04296879f, 0.05536105f, -0.08260956f, 0.10108187f, -0.09448613f, 
    -0.65858471f, -0.62148923f, -0.42218712f, -0.12760746f, -0.20756929f, -0.05844220f, 0.18178913f, 0.04280816f, 
    -0.01834929f, 0.05565730f, 0.03873177f, -0.02354043f, 0.31730601f, 0.16672829f, -0.22391245f, -0.04347965f, 
    0.00868538f, -0.05565976f, 0.07906330f, 0.04360113f, 0.14726181f, 0.23731048f, 0.04891902f, 0.04250268f, 
    0.06588997f, 0.19578087f, 0.03712841f, -0.05701149f, -0.01817610f, -0.02254892f, 0.06462520f, -0.22117022f, 
    0.17332000f, -0.06528427f, 0.08254498f, 0.00210255f, 0.01733569f, -0.72999322f, -0.05438212f, -0.13587405f, 
    -0.05639633f, 0.14990367f, 0.08248132f, -0.13550338f, 0.02455618f, -0.04818398f, 0.07159607f, 0.12274167f, 
    -0.41266337f, -0.08793941f, 0.50796759f, -0.09533879f, -0.19141130f, 0.08167233f, -0.17567791f, -0.28519353f, 
    -0.05398814f, 0.01881979f, -0.01095441f, -0.03672277f, 0.04385511f, -0.07133991f, -0.02871719f, -0.03145033f, 
    0.02959099f, 0.00241984f, 0.10421585f, 0.12403650f, 0.01539782f, 0.00598173f, -0.19070736f, 0.11582115f, 
    0.21687938f, 0.18251331f, -0.16243348f, 0.23528065f, -0.09851439f, -0.00305688f, 0.25617483f, 0.15921719f, 
    0.08301987f, 0.05464226f, 0.04887455f, -0.04050725f, 0.00457929f, -0.03641801f, -0.15213238f, -0.26807964f, 
    0.02230317f, 0.05238992f, 0.07039307f, -0.01350330f, -0.04767343f, 0.03517084f, -0.08965639f, 0.01380399f, 
    0.07738580f, 0.10545172f, 0.24250232f, 0.33548287f, 0.03569216f, -0.01221203f, -0.13450423f, 0.02311190f, 
    0.00167468f, 0.05981121f, -0.09546421f, -0.00489258f, -0.57201576f, -0.65838617f, 0.03022574f, -0.11328969f, 
    0.05259520f, -0.01858169f, -0.15863454f, -0.23421928f, 0.00579321f, 0.01876794f, 0.01904133f, -0.03880103f, 
    -0.64851826f, 0.22029155f, 0.07628591f, -0.16265450f, -0.11229685f, 0.06092543f, -0.14985821f, -0.06725204f, 
    -0.05067993f, -0.03687816f, 0.15630767f, 0.04193955f, -0.36475062f, -0.03752746f, 0.04478184f, -0.16427498f, 
    -0.03406715f, -0.31402937f, -0.10645652f, -0.32186553f, -0.08293768f, -0.00792219f, -0.03561001f, 0.05130174f, 
    -0.11871928f, -0.22848600f, -0.27277884f, 0.16171886f, 0.19792478f, 0.06843397f, 0.13217859f, -0.03397917f, 
    0.04109972f, -0.04006369f, -0.02826750f, 0.08653274f, 0.01170522f, -0.00722963f, 0.06669614f, -0.10638523f, 
    -0.04855168f, 0.00464934f, 0.04051280f, 0.00065792f, 0.07397594f, 0.00912113f, -0.02689428f, 0.00263529f, 
    0.10178955f, 0.04147891f, 0.08538568f, -0.05741040f, -0.00528536f, -0.01872431f, -0.01485707f, -0.02465741f, 
    0.03004462f, -0.03483034f, 0.03335996f, 0.01245164f, -0.02754275f, 0.10150150f, 0.05726071f, -0.01313737f, 
    -0.07233102f, -0.07591746f, -0.17750260f, -0.16959383f, 0.02463153f, -0.02309993f, 0.02046647f, -0.03356197f, 
    -0.25274366f, 0.04652311f, -0.30689594f, 0.25945866f, -0.01780622f, 0.01543795f, 0.03924776f, 0.00972182f, 
    0.01123739f, 0.10211211f, -0.04233181f, 0.08801734f, -0.08523653f, -0.06977905f, -0.18493888f, 0.02906805f, 
    0.02619238f, -0.09227760f, 0.03251825f, -0.11061097f, -0.02286026f, 0.00988950f, 0.04062950f, -0.04804612f, 
    -0.06483032f, 0.06486528f, -0.13203171f, 0.11104095f, 0.02856603f, -0.05877234f, 0.04676429f, -0.03841608f, 
    0.02114125f, 0.01398289f, -0.10576551f, -0.00824870f, -0.41478202f, -0.30973792f, 0.06221105f, 0.50996649f, 
    0.05397598f, -0.09091832f, 0.00968143f, 0.13562056f, 0.00380969f, -0.02278787f, -0.08391409f, -0.07742117f, 
    0.13951553f, 0.00226914f, -0.05818540f, -0.07245579f, 0.04693497f, -0.01595538f, 0.00478757f, -0.01172933f, 
    -0.01835093f, 0.08316047f, -0.08644265f, -0.15046512f, 0.03339490f, -0.09535643f, 0.17049283f, -0.10156628f, 
    -0.11516864f, 0.03455218f, -0.05323019f, -0.05420163f, 0.03671732f, -0.00862401f, 0.03905569f, -0.02045570f, 
    0.56139290f, 0.08631882f, -0.19970024f, -0.32066914f, 0.05567485f, -0.01142349f, -0.01827469f, -0.10512447f, 
    0.02344274f, -0.00144671f, -0.06656435f, -0.10943498f, 0.18989109f, 0.08949728f, 0.02339689f, -0.12866034f, 
    -0.05837032f, 0.11375263f, 0.02143657f, 0.02591503f, -0.09214245f, -0.07445299f, 0.02034302f, 0.01510402f, 
    0.13723968f, 0.11190463f, -0.24224038f, -0.14296378f, 0.00559325f, 0.00267144f, -0.02328153f, -0.01635699f, 
    -0.16586673f, 0.03869835f, -0.00036280f, -0.01462677f, 0.22504170f, 0.09823878f, -0.24569716f, -0.08921820f, 
    -0.06953114f, 0.11587234f, 0.03045123f, -0.00209925f, -0.12196876f, -0.01410613f, 0.00312026f, -0.04590983f, 
    -0.16908731f, -0.64745218f, -0.11966697f, -0.07442267f, -0.04733604f, 0.12311192f, -0.06242725f, -0.00256684f, 
    0.11262441f, 0.01908708f, -0.09646054f, 0.04854145f, -0.06878701f, 0.08177862f, -0.13289851f, 0.12796582f, 
    -0.07583603f, 0.04745689f, 0.02919518f, -0.02096438f, -0.09096514f, -0.04989747f, 0.02567280f, -0.09509853f, 
    0.09250509f, -0.10143843f, -0.01409161f, 0.00129573f, -0.09216342f, 0.07946219f, -0.08311182f, -0.13409816f, 
    0.03066276f, -0.02572771f, -0.00436363f, -0.00474832f, 0.02943304f, 0.07831504f, -0.14942569f, 0.10414935f, 
    -0.11239067f, -0.00873945f, -0.02215450f, -0.14572760f, -0.18635169f, -0.05594008f, -0.04613047f, -0.12313145f, 
    0.22834654f, -0.33515540f, -0.16772056f, -0.28031772f, -0.05894266f, -0.09056718f, -0.03172604f, -0.08284697f, 
    -0.01203616f, 0.04065596f, -0.02538263f, 0.00488655f, -0.00366486f, 0.10191601f, 0.09003118f, 0.12276210f, 
    0.00408738f, 0.02593664f, 0.04646963f, -0.00418115f, -0.00123498f, -0.03542999f, 0.02749046f, -0.08019315f, 
    0.07117648f, 0.04229395f, -0.06199925f, -0.11516934f, 0.01339028f, 0.03718429f, -0.00342386f, -0.05400341f, 
    -0.01547677f, 0.00897454f, 0.00055050f, -0.20879531f, 0.10700382f, -0.26379710f, 0.00978371f, -0.24896848f, 
    -0.03047352f, -0.00091572f, -0.08511931f, -0.08057724f, -0.06481672f, 0.10657319f, 0.00478469f, -0.02512903f, 
    -0.17773588f, -0.27937454f, -0.13103394f, 0.02129200f, -0.05481995f, -0.07792275f, 0.08120276f, 0.21118802f, 
    -0.04804168f, -0.16643795f, -0.05921211f, 0.00975034f, -0.51062649f, 0.22120678f, -0.05438711f, 0.30287260f, 
    -0.05358334f, -0.03234754f, 0.03714607f, -0.01130110f, -0.07799406f, 0.03747797f, -0.03227055f, -0.02063773f, 
    0.26383930f, -0.68982738f, 0.19862698f, -0.05738678f, 0.07408297f, -0.07967156f, -0.19265160f, -0.09460755f, 
    0.01334136f, 0.03251254f, -0.02940614f, -0.04076409f, -0.49482399f, 0.33348042f, 0.00329983f, 0.27728006f, 
    0.02005600f, -0.05914965f, -0.03471574f, -0.01999297f, 0.01365658f, -0.03441296f, -0.01787220f, -0.07719193f, 
    0.04224996f, -0.06809225f, -0.08052995f, 0.06389594f, -0.00841689f, -0.00886231f, 0.14894456f, -0.02147410f, 
    -0.08514689f, 0.06722139f, -0.02484887f, 0.01406309f, 0.17182058f, -0.03384332f, 0.04755198f, -0.04466115f, 
    -0.10471936f, 0.01391863f, 0.03341914f, 0.07360221f, -0.00732510f, -0.00041248f, 0.02298307f, -0.05115975f, 
    0.03858141f, -0.01606696f, 0.11321176f, -0.12303875f, -0.06499185f, 0.04100468f, 0.04271295f, -0.02847191f, 
    0.04433890f, -0.02687716f, -0.05275850f, -0.10515683f, -0.10863864f, 0.08883602f, -0.17614408f, 0.01694639f, 
    0.02221684f, 0.00039866f, -0.10944280f, 0.04929560f, 0.06022718f, 0.07218903f, -0.01077649f, -0.00263478f, 
    -0.14318961f, -0.20906387f, 0.01131791f, 0.14988461f, -0.26711866f, 0.01709699f, -0.12870248f, -0.10369417f, 
    -0.05049711f, -0.10742369f, 0.01976243f, 0.09200723f, 0.24531864f, -0.03430894f, 0.00826028f, -0.18075009f, 
    -0.06755522f, 0.04008636f, -0.00036597f, 0.07634490f, -0.00980405f, -0.05128559f, -0.06975444f, -0.08970144f, 
    -0.53603905f, -0.48505938f, -0.13550621f, 0.55319655f, 0.01153697f, 0.07796188f, 0.03827167f, 0.08741956f, 
    -0.03353154f, 0.05743344f, -0.01429185f, -0.01468011f, 0.29382622f, -0.04002907f, -0.15960333f, 0.00177828f, 
    0.04534098f, 0.00561610f, 0.05100770f, -0.00634021f, 0.06989720f, -0.02522122f, -0.00693019f, -0.05900256f, 
    -0.10683272f, 0.20531446f, -0.18241026f, 0.32404327f, 0.05797773f, 0.06223246f, 0.14518367f, 0.06110891f, 
    0.01958478f, -0.01127929f, 0.11579790f, 0.12442935f, -0.20049478f, 0.09471629f, 0.04760158f, 0.02491754f, 
    -0.09642266f, -0.08653628f, -0.08647343f, 0.01900669f, 0.02759519f, -0.05680077f, 0.00942681f, -0.03262994f, 
    0.05760646f, 0.09392599f, 0.17005214f, 0.02755929f, 0.05700536f, -0.02666859f, -0.03943924f, -0.03218227f, 
    0.11176722f, -0.10959008f, 0.09782394f, -0.03439755f, 0.07932038f, 0.06733094f, 0.03087039f, -0.16596206f, 
    0.03662435f, 0.05168387f, 0.01638275f, 0.00920407f, 0.06910537f, -0.03009706f, -0.24573737f, -0.34198040f, 
    -0.13138762f, -0.05083255f, -0.03477945f, 0.02163328f, 0.00976081f, 0.06728578f, 0.12648790f, -0.03647127f, 
    -0.05140395f, -0.00250768f, 0.04671888f, -0.05208277f, -0.14355385f, 0.00952955f, 0.01269146f, -0.05317841f, 
    -0.01329636f, -0.01077282f, 0.00420877f, 0.00244300f, 0.05804566f, -0.00295011f, 0.06669744f, -0.05300657f, 
    -0.54034412f, 0.10143255f, -0.45645785f, -0.19495438f, 0.15318376f, -0.03733443f, 0.22894198f, 0.03129771f, 
    -0.02513565f, -0.08212844f, -0.10204922f, 0.04211717f, 0.02244466f, -0.01829633f, 0.14436965f, -0.04263486f, 
    0.02990027f, 0.06868705f, -0.01459123f, 0.07100756f, 0.06847118f, 0.03993505f, 0.09038176f, -0.02572424f, 
    0.01087271f, -0.04574960f, 0.15595613f, -0.06170864f, -0.01353468f, -0.00892527f, -0.06025543f, 0.01456382f, 
    0.05057690f, -0.03678162f, 0.00487980f, -0.08588333f, 0.25840172f, -0.04298048f, -0.10743211f, -0.18722636f, 
    0.07381216f, 0.05669659f, 0.04511224f, 0.04483530f, 0.06949612f, 0.09252993f, 0.05937757f, -0.15728098f, 
    -0.37818468f, 0.11947821f, -0.48133421f, -0.02310776f, -0.07447312f, -0.13919631f, 0.19959989f, -0.03211950f, 
    -0.01193832f, -0.04582887f, 0.08021419f, -0.01479109f, 0.07420061f, 0.01746960f, 0.00148458f, -0.09079513f, 
    0.04866733f, 0.01012242f, 0.07919806f, 0.02436163f, -0.05505986f, -0.00756230f, -0.04283214f, -0.09469792f, 
    0.44051719f, -0.42735469f, 0.22681080f, 0.09657938f, -0.06488473f, 0.03353196f, -0.07297737f, -0.01961663f, 
    -0.06227610f, -0.04350929f, 0.07689699f, 0.06007653f, 0.04689233f, 0.01481275f, 0.00638657f, 0.14891982f, 
    0.10021584f, 0.02655790f, 0.05491985f, 0.01934963f, 0.03093910f, 0.02900471f, 0.06726418f, -0.03253155f, 
    0.06800032f, -0.47863975f, -0.14487477f, -0.34747931f, 0.00246653f, -0.09541021f, -0.00910624f, 0.03782934f, 
    0.06058411f, 0.03693949f, 0.03825551f, 0.04880010f, -0.35458949f, -0.14368671f, -0.16681649f, -0.01251465f, 
    0.05675659f, -0.10701151f, 0.10928858f, -0.13617578f, -0.03515623f, 0.03278565f, 0.04792731f, 0.05177254f, 
    0.43324175f, -0.30611035f, -0.06635251f, -0.16115457f, -0.07272752f, 0.04861683f, -0.13085648f, 0.01092583f, 
    0.05869047f, 0.08024755f, 0.00532797f, 0.07695039f, 0.09469993f, -0.33489490f, 0.07866445f, -0.02839847f, 
    -0.06831411f, -0.00441668f, -0.08006352f, -0.05153545f, -0.05816722f, 0.03923038f, 0.02527925f, -0.14000273f, 
    0.09255253f, -0.43221006f, -0.25892097f, -0.25438029f, -0.07450274f, 0.00295819f, 0.00415201f, 0.13009146f, 
    0.03803227f, 0.00851265f, -0.01690923f, -0.02177040f, -0.19012901f, 0.11949667f, 0.00726449f, 0.09434184f, 
    -0.02122766f, -0.05787560f, -0.01256050f, 0.06061341f, -0.04123008f, 0.04658826f, 0.07511313f, -0.04520298f, 
    0.06630933f, 0.06115791f, 0.01648942f, 0.07120526f, -0.04724926f, -0.02536899f, 0.14225703f, -0.06994176f, 
    -0.23348342f, 0.07020051f, -0.19869947f, -0.01841635f, -0.40377700f, 0.45814416f, -0.33544961f, 0.36088508f, 
    0.02875714f, 0.07886556f, 0.14239518f, 0.06841389f, -0.02880412f, -0.00202485f, 0.04703079f, -0.06256076f, 
    0.25993723f, 0.21243414f, -0.02618001f, 0.12818767f, 0.02742182f, -0.10189796f, -0.30590871f, -0.03606181f, 
    0.08732859f, 0.04941709f, 0.05940469f, 0.01583503f, -0.03017979f, 0.08457074f, 0.10414886f, -0.01741249f, 
    -0.03155448f, -0.01709886f, -0.04575315f, 0.06683087f, -0.07048376f, 0.00302604f, 0.01662576f, 0.07206298f, 
    -0.25392589f, -0.06400525f, 0.01640680f, 0.05337257f, -0.05512586f, 0.12176771f, 0.11436284f, -0.08222273f, 
    -0.06332377f, 0.00529626f, -0.04201855f, -0.09987886f, -0.09876861f, 0.04190791f, -0.19754992f, -0.03679508f, 
    0.02413511f, -0.01005640f, -0.08379081f, -0.00569983f, 0.01450875f, -0.00851599f, 0.06458928f, 0.00436885f, 
    0.38604507f, -0.19488977f, -0.24653640f, -0.15831858f, -0.08145871f, 0.10057210f, -0.02459207f, 0.10163070f, 
    0.05516390f, -0.07663219f, 0.16776831f, -0.02019767f, -0.45012966f, -0.08498399f, -0.28584349f, -0.16824254f, 
    0.12459414f, -0.04581700f, 0.07003829f, 0.18122360f, 0.01606364f, -0.01682198f, -0.08424016f, 0.01949208f, 
    -0.13051312f, -0.02726918f, -0.36503795f, -0.15450710f, -0.01845493f, -0.28635564f, 0.04973366f, -0.02532205f, 
    0.08031586f, 0.06839202f, 0.03866266f, 0.00450425f, -0.03651740f, 0.15524448f, -0.27542701f, -0.23629706f, 
    -0.04929544f, 0.19555047f, -0.08763406f, 0.08587024f, 0.03822947f, -0.02641228f, 0.06019010f, 0.06235159f, 
    -0.18500480f, -0.34171778f, 0.15232353f, 0.02721486f, 0.01774596f, 0.15797734f, 0.10378350f, -0.06946598f, 
    0.01649010f, 0.05573167f, 0.09039868f, -0.03924337f, 0.08616851f, 0.11414260f, -0.04734426f, 0.02977761f, 
    -0.04531055f, -0.02388769f, 0.00274517f, -0.04517932f, -0.24197149f, -0.09058695f, -0.03745896f, -0.08214440f, 
    -0.10546300f, 0.03656805f, -0.01605057f, -0.13426389f, -0.01379656f, -0.06961790f, 0.01051927f, -0.01132642f, 
    0.00580703f, -0.03876548f, -0.05432731f, 0.06153239f, -0.12913324f, -0.01734222f, -0.06255209f, -0.03635539f, 
    0.06520807f, -0.03076263f, 0.02613268f, 0.08609670f, 0.07186544f, 0.07458047f, 0.10025587f, 0.06038988f, 
    -0.04925499f, -0.05998197f, 0.03704449f, 0.19889626f, -0.00632159f, 0.00786116f, 0.02694364f, 0.07352237f, 
    -0.05319155f, 0.10625094f, -0.12539509f, -0.28956524f, 0.41628677f, 0.03479126f, 0.04186141f, 0.09930008f, 
    -0.00333940f, 0.00610634f, -0.07595748f, 0.03439846f, 0.17970142f, 0.01001036f, -0.05174232f, 0.04290147f, 
    -0.39177588f, 0.16276886f, 0.16811708f, -0.01206943f, -0.05445619f, 0.10567665f, -0.07247638f, -0.10376457f, 
    -0.10097139f, -0.04174665f, -0.04011403f, 0.08078722f, -0.14785717f, -0.49284077f, -0.35451105f, -0.38198268f, 
    -0.04216113f, -0.06274248f, -0.11000244f, -0.18663169f, 0.02988203f, 0.03709654f, -0.00952886f, 0.04344305f, 
    0.00759156f, -0.02191823f, 0.02990265f, -0.18821712f, -0.05252229f, -0.01891910f, 0.00023838f, -0.07678432f, 
    -0.03546298f, 0.04111552f, 0.03847656f, 0.11578223f, 0.18565777f, 0.03455886f, -0.02415520f, -0.13710302f, 
    -0.05376414f, -0.14022948f, -0.09290652f, -0.19140483f, 0.03655511f, 0.07162219f, 0.08539066f, 0.05050792f, 
    0.20353250f, -0.18702039f, -0.31491646f, -0.28050268f, 0.00758259f, 0.02188868f, 0.11796378f, 0.02026825f, 
    0.11275790f, 0.07251792f, 0.02980825f, 0.02820979f, 0.06669888f, -0.02796679f, -0.11632794f, -0.15258554f, 
    -0.06017683f, -0.14713085f, 0.05602938f, 0.01946227f, 0.03920492f, 0.07299399f, 0.06004103f, 0.08549063f, 
    0.45973402f, 0.10850259f, 0.06558453f, -0.09461765f, -0.00870065f, 0.04905194f, -0.03190500f, -0.02746252f, 
    0.17439190f, 0.05467765f, 0.02129709f, -0.00584069f, 0.12947807f, -0.02457844f, -0.17571113f, -0.11128104f, 
    -0.01675470f, 0.00674423f, -0.00450020f, 0.02393828f, 0.05244087f, 0.11234624f, -0.02508133f, 0.05428351f, 
    -0.16294201f, -0.23706442f, -0.02772969f, 0.21499200f, 0.11422391f, 0.09716271f, 0.09328845f, 0.07195751f, 
    -0.16653949f, 0.00341463f, -0.06872137f, -0.20254529f, -0.30264485f, -0.04154001f, 0.09597070f, 0.14844419f, 
    -0.00400394f, 0.00455028f, -0.10456855f, 0.00460672f, -0.08721353f, -0.12580521f, 0.20616867f, -0.03569026f, 
    -0.15072340f, -0.11175795f, -0.10386295f, -0.02779757f, 0.14960951f, -0.08690103f, -0.02365595f, 0.18098612f, 
    0.00939396f, -0.01902572f, -0.03730028f, -0.10860387f, 0.04261232f, 0.15341346f, 0.07926361f, 0.04796375f, 
    -0.06196121f, 0.03793614f, 0.03591583f, 0.07042898f, -0.02077735f, -0.03406515f, -0.14235847f, 0.15395418f, 
    0.05442771f, -0.21265629f, -0.11376711f, -0.05877258f, 0.15234093f, 0.18909916f, 0.12911494f, -0.01966422f, 
    -0.04811377f, -0.00945728f, 0.01210827f, 0.07654701f, -0.57483602f, -0.00700062f, 0.20359729f, 0.01785306f, 
    -0.03178180f, 0.00375549f, -0.03353001f, -0.02006689f, -0.02327908f, 0.07663456f, 0.04011221f, 0.04185763f, 
    0.24922036f, 0.01686615f, -0.08680084f, -0.03888592f, -0.10044426f, -0.08514672f, 0.01339954f, 0.05396210f, 
    0.09867724f, -0.02444690f, 0.06129977f, 0.12596861f, 0.37555146f, -0.03023661f, 0.02770085f, -0.16688526f, 
    0.07836392f, -0.05581313f, -0.01097389f, -0.01420889f, -0.05490403f, -0.03496230f, 0.02995430f, -0.01510523f, 
    0.06520323f, -0.13897525f, -0.28328469f, -0.21820948f, -0.03245842f, -0.10557706f, -0.01770157f, -0.26964185f, 
    0.00053214f, -0.04105861f, -0.07113675f, -0.01978147f, -0.52304214f, -0.04082100f, 0.04993240f, 0.16814107f, 
    0.16735911f, 0.05581065f, -0.05083598f, 0.02773844f, -0.03893439f, -0.03886659f, 0.19491956f, 0.14068921f, 
    0.60194808f, 0.37565622f, 0.04999395f, -0.24927776f, -0.15025926f, -0.25796649f, -0.00955510f, -0.20353745f, 
    0.05633538f, 0.09996390f, -0.01048060f, 0.06610744f, -0.06234533f, -0.02080180f, 0.11145467f, 0.13395591f, 
    0.08247979f, -0.03132695f, 0.00990398f, -0.03910130f, 0.03393837f, 0.03891860f, 0.09594993f, 0.09760342f, 
    0.13321783f, -0.04688987f, -0.00938478f, -0.10819231f, 0.00840907f, -0.06182010f, -0.05289602f, -0.00703044f, 
    0.10093685f, -0.07433008f, 0.06917868f, 0.11230066f, -0.00048487f, -0.01586693f, -0.13178889f, -0.07397600f, 
    0.11974411f, 0.01671418f, 0.00658184f, -0.02324688f, 0.03946366f, 0.14780191f, 0.09398786f, 0.19172657f, 
    -0.03787869f, -0.06662338f, -0.10966787f, -0.10877561f, -0.03178663f, -0.03588570f, -0.04050049f, 0.04742211f, 
    0.07507633f, 0.15425843f, 0.04179600f, 0.13551022f, 0.00795464f, 0.01324943f, -0.06654032f, 0.10991340f, 
    -0.03731992f, -0.03795623f, 0.20425017f, 0.01278004f, -0.01270909f, -0.02692558f, -0.01597086f, -0.02270972f, 
    0.14154834f, 0.13535552f, -0.06793276f, 0.05409672f, 0.08661930f, -0.13698563f, -0.09934911f, 0.00269868f, 
    -0.01835175f, 0.05249698f, 0.16911569f, -0.05066605f, 0.06546722f, -0.02555100f, -0.03849653f, -0.02256618f, 
    -0.16221429f, -0.02397563f, -0.10841751f, 0.11295818f, 0.11797272f, -0.04253153f, 0.16008374f, -0.04624502f, 
    -0.01758945f, -0.50483531f, -0.24667434f, -0.20187248f, 0.12592891f, -0.09700882f, -0.00765550f, 0.10399736f, 
    0.05121436f, -0.00497442f, 0.06673413f, 0.07806461f, -0.03831370f, -0.07645255f, -0.08369557f, -0.05376938f, 
    -0.01250143f, 0.04132899f, 0.00033495f, -0.04072215f, -0.44023439f, -0.05016788f, -0.20515275f, -0.42181477f, 
    0.02208524f, -0.27388331f, -0.37622741f, -0.18062937f, 0.00967214f, -0.04874121f, -0.04138304f, 0.11670923f, 
    0.18303940f, 0.03142971f, 0.01619667f, -0.18819955f, -0.23314345f, 0.06846391f, 0.03254398f, -0.01670723f, 
    0.14829884f, -0.06386265f, -0.00076783f, -0.01010949f, 0.11928616f, 0.02118750f, 0.05319761f, 0.09406924f, 
    -0.11728460f, -0.00166337f, 0.05972583f, -0.00345130f, -0.17542320f, -0.07868826f, -0.08350354f, -0.03699405f, 
    0.01452876f, 0.08832513f, -0.24726695f, -0.34070191f, -0.10868985f, -0.00361331f, -0.09754176f, -0.14180836f, 
    -0.14014770f, -0.06861410f, -0.00784375f, -0.04381407f, 0.03479091f, 0.08057611f, 0.00559088f, 0.13050662f, 
    -0.27568519f, 0.08683715f, 0.07558707f, 0.09381930f, -0.00020553f, -0.05825482f, -0.02182322f, -0.07234724f, 
    -0.05412990f, 0.09297983f, 0.03577201f, 0.13582301f, -0.57037675f, 0.04052122f, 0.15800942f, 0.11064516f, 
    0.01028872f, -0.04678965f, -0.04152636f, 0.03735941f, 0.04630806f, -0.08956074f, 0.01925965f, -0.06598392f, 
    0.32348436f, -0.07481042f, -0.24238670f, 0.21203484f, 0.08296020f, 0.16452621f, 0.04414902f, -0.08843801f, 
    0.01620612f, -0.07518367f, -0.04158282f, -0.32340717f, -0.11398391f, -0.09821653f, -0.04972139f, 0.04710278f, 
    -0.04323433f, 0.00065687f, -0.04609074f, -0.01366102f, -0.08784997f, -0.06812218f, -0.14294252f, -0.15463260f, 
    0.01006986f, 0.05816305f, -0.11515423f, -0.07960261f, 0.00312052f, -0.00882922f, -0.06226194f, -0.09998514f, 
    -0.04811064f, 0.14185892f, 0.08448423f, 0.12817885f, -0.11820580f, -0.11114182f, -0.21621613f, -0.06182960f, 
    -0.04787187f, -0.09905453f, -0.05448614f, -0.05767018f, 0.06942698f, 0.17296453f, 0.07457671f, 0.09396076f, 
    -0.18855087f, -0.52407229f, 0.10715328f, 0.23953307f, -0.03757681f, 0.08650479f, -0.01591167f, 0.00211391f, 
    -0.04208129f, 0.02627134f, -0.01601174f, -0.01330602f, -0.03480589f, -0.00752999f, 0.00511207f, 0.02199544f, 
    -0.01778661f, -0.09790605f, 0.06409849f, -0.02788679f, 0.07055213f, 0.07534321f, 0.09714563f, 0.12284058f, 
    -0.18422866f, -0.40640122f, -0.40140846f, -0.20803533f, 0.22820763f, 0.16505362f, 0.16084768f, 0.14594555f, 
    0.09772341f, 0.16420636f, 0.09835404f, 0.17878617f, -0.46841452f, -0.04152994f, 0.28066325f, 0.07659829f, 
    -0.13572924f, -0.07412973f, -0.09725852f, -0.09892604f, -0.04668580f, 0.03285661f, 0.09324034f, -0.05873455f, 
    0.00865799f, -0.28801724f, -0.04578320f, 0.11411048f, 0.15519114f, 0.14288160f, 0.06936756f, 0.17122704f, 
    -0.17106213f, -0.05835874f, -0.09094434f, -0.12535991f, 0.02008523f, -0.27096632f, -0.12819411f, 0.14393608f, 
    -0.03187998f, 0.02642634f, 0.10240296f, 0.10662513f, -0.19414040f, -0.13649623f, 0.01267584f, -0.01226612f, 
    -0.23268907f, -0.17176272f, -0.32069504f, -0.03147163f, 0.02662100f, 0.03508191f, 0.14428297f, 0.04471223f, 
    0.12752777f, -0.03859251f, -0.10234911f, -0.12374541f, 0.18222995f, 0.22044449f, -0.13286580f, -0.06747762f, 
    0.05999079f, -0.02569773f, 0.04566091f, -0.01504624f, 0.05070875f, -0.07649821f, 0.09638941f, -0.00563762f, 
    -0.11003033f, -0.27153504f, -0.25973356f, -0.16541040f, -0.04808069f, 0.22608911f, 0.15053560f, -0.04511249f, 
    -0.02436892f, -0.00464553f, -0.04854220f, -0.03389030f, -0.48712137f, -0.11395074f, 0.05924511f, 0.14334711f, 
    0.01648187f, 0.04536255f, -0.04760707f, -0.01629153f, -0.08634273f, -0.08100771f, -0.13877745f, 0.01755146f, 
    -0.23155618f, -0.06743451f, -0.03062373f, 0.04223102f, -0.01628235f, 0.14641419f, -0.01601603f, -0.08183926f, 
    0.00484885f, 0.05712222f, -0.02186779f, 0.17334135f, -0.16344464f, 0.04634080f, -0.04747019f, -0.04142101f, 
    0.22834630f, 0.05185981f, -0.16320264f, -0.03267195f, 0.00288395f, 0.09593044f, 0.01953739f, 0.04249395f, 
    -0.07445698f, -0.22766764f, -0.16480555f, -0.13771224f, -0.13186112f, 0.12517093f, 0.05195338f, 0.18857561f, 
    0.07647622f, -0.01086631f, 0.04504377f, -0.03180353f, -0.12386383f, -0.12050813f, -0.05467002f, 0.03314469f, 
    -0.08382252f, -0.04143524f, 0.06685191f, 0.03696680f, 0.03264220f, -0.04010786f, 0.05476419f, -0.09079479f, 
    -0.46250552f, -0.12866694f, 0.22741616f, 0.16352831f, -0.02718303f, 0.03955562f, -0.06225178f, -0.14651188f, 
    0.06025470f, 0.06178591f, -0.05841457f, 0.09103369f, -0.18750264f, 0.05874716f, 0.16343720f, 0.21122675f, 
    -0.03275496f, -0.12841718f, -0.05077292f, -0.01666600f, -0.18001339f, -0.04292797f, -0.12302691f, -0.08273162f, 
    -0.35740232f, -0.01640338f, -0.00035879f, 0.37732428f, -0.10278826f, 0.16221011f, 0.03900011f, 0.05517823f, 
    0.06671621f, 0.03558904f, -0.09928615f, -0.04577429f, 0.32244909f, -0.47510999f, -0.49977127f, -0.09098800f, 
    -0.17111379f, 0.04357561f, -0.01137470f, -0.07565357f, -0.05683967f, -0.05482727f, 0.05591425f, -0.00276303f, 
    -0.47373143f, -0.49303746f, -0.26754412f, -0.11891454f, 0.03508413f, 0.22352244f, 0.05913293f, 0.05841655f, 
    0.08099687f, -0.05350523f, 0.02495582f, 0.05110689f, -0.24889791f, -0.53067487f, -0.28709185f, 0.18926874f, 
    -0.12370322f, 0.26427057f, 0.05861808f, 0.03773533f, -0.05294125f, 0.04612271f, -0.05831935f, -0.00308975f, 
    0.26176706f, -0.05192379f, 0.03232272f, -0.04889078f, 0.06806695f, 0.10179445f, -0.03921967f, -0.11568683f, 
    0.09117112f, 0.02462433f, -0.10403031f, -0.11290871f, -0.08250354f, -0.02735803f, -0.01016223f, -0.07609223f, 
    -0.01477264f, -0.01529751f, 0.04025722f, -0.04109941f, -0.04767727f, 0.02513992f, -0.00856478f, 0.13731234f, 
    -0.03089012f, -0.13233939f, -0.19477217f, 0.00614150f, 0.10510908f, 0.11821824f, 0.10482973f, 0.01822141f, 
    0.13661288f, 0.02462622f, 0.09402237f, -0.02518127f, 0.15059148f, 0.10005015f, -0.06740475f, -0.12569244f, 
    0.05396644f, -0.04459498f, -0.05974364f, -0.01968996f, 0.03654967f, -0.08129632f, -0.15278189f, -0.03498356f, 
    -0.02529370f, 0.16466616f, 0.00670725f, 0.01918588f, 0.07177723f, -0.15577684f, 0.03369969f, 0.09538622f, 
    0.00447946f, 0.09153704f, 0.10219582f, 0.24828796f, -0.36303934f, -0.17080054f, -0.04217982f, 0.10049594f, 
    0.17011970f, -0.02903119f, 0.04762027f, -0.07594395f, -0.01110219f, -0.11311233f, 0.00358358f, -0.14190750f, 
    -0.19055057f, 0.01740165f, -0.06176918f, -0.02384317f, 0.16036355f, 0.03168130f, 0.08285992f, -0.09240858f, 
    0.22989254f, 0.02293367f, -0.03570773f, 0.02584423f, -0.28926170f, 0.13328120f, 0.07035410f, -0.14607641f, 
    -0.24300975f, -0.09715338f, 0.11136190f, 0.19023353f, 0.07763451f, 0.11485837f, 0.03008453f, -0.04638516f, 
    -0.13947171f, 0.03273974f, 0.04063775f, 0.23632918f, 0.06203664f, 0.06902935f, 0.00589469f, -0.04624654f, 
    -0.01971298f, 0.01882024f, 0.03517896f, -0.03915948f, 0.17671956f, -0.12339400f, 0.02503784f, -0.08885121f, 
    0.09171093f, -0.05127974f, 0.05867493f, -0.03074742f, -0.03527725f, 0.03484257f, -0.04596788f, -0.04939310f, 
    0.12534325f, 0.09011918f, 0.41355652f, 0.51214588f, 0.14396115f, -0.14784265f, -0.13564466f, -0.23727319f, 
    -0.10017255f, -0.12611316f, -0.05483949f, 0.12583320f, -0.08917397f, -0.14860664f, 0.25357893f, 0.20159741f, 
    0.19621685f, 0.02855047f, -0.25849250f, -0.07294846f, 0.00616009f, -0.08961364f, 0.02348113f, 0.06221585f, 
    0.03407232f, 0.17342535f, -0.23208602f, 0.08546614f, 0.06786696f, -0.14600877f, -0.09448997f, -0.09932252f, 
    0.15940464f, -0.09999956f, 0.06117179f, 0.11492001f, -0.27956918f, 0.22755086f, -0.16546649f, 0.24766432f, 
    -0.10481883f, -0.03360216f, -0.11337236f, -0.11517092f, 0.08771395f, -0.15448572f, -0.01329909f, -0.19863573f, 
    0.00448080f, 0.15442446f, 0.26023737f, -0.28999054f, -0.11395238f, -0.15229107f, 0.04237919f, -0.07442576f, 
    0.02630641f, 0.04764188f, 0.08708055f, 0.04941081f, -0.18326811f, 0.24039277f, -0.51218885f, -0.16327547f, 
    -0.02562011f, -0.06736623f, 0.06462180f, -0.22770466f, 0.08425664f, 0.00646702f, -0.01332434f, 0.05539286f, 
    -0.11850678f, 0.13013253f, -0.19453192f, 0.18496007f, -0.20005547f, -0.07374591f, -0.17481831f, -0.11235977f, 
    0.23050353f, -0.02357446f, 0.01304420f, -0.07482366f, -0.33230931f, -0.00827141f, 0.00298861f, 0.03991523f, 
    0.09428312f, -0.08399038f, -0.08777658f, 0.04723078f, 0.18231511f, 0.00771344f, -0.13125484f, 0.08475457f, 
    -0.01599537f, 0.04398087f, -0.14799759f, 0.18480773f, -0.07320311f, -0.04954857f, -0.18495600f, 0.07994155f, 
    0.04718034f, -0.09394059f, 0.06610864f, 0.04158016f, 0.04615467f, -0.32223511f, -0.11114410f, 0.00870948f, 
    0.03364050f, -0.01094415f, 0.05392973f, -0.00978010f, 0.02489750f, 0.01777317f, -0.00321480f, -0.04300358f, 
    -0.05246423f, -0.04696852f, 0.13269830f, 0.18057293f, 0.02093208f, 0.07465030f, -0.03653591f, -0.00765184f, 
    -0.13558075f, -0.00703640f, 0.08451279f, 0.02673644f, -0.07598455f, -0.26916060f, 0.02050402f, -0.02068030f, 
    0.00525960f, 0.08050570f, 0.04770546f, -0.08950619f, -0.09058207f, -0.01475518f, -0.03018748f, 0.05675262f, 
    -0.28557765f, -0.08849326f, 0.21863025f, -0.11423264f, -0.03910586f, -0.16766869f, 0.02168286f, 0.20339781f, 
    0.09617374f, 0.10265404f, 0.03773773f, 0.03498679f, -0.35358393f, 0.46104416f, -0.23800737f, -0.31676710f, 
    -0.07934389f, -0.25257742f, 0.09732610f, -0.08503411f, 0.15073527f, 0.03970822f, -0.03316842f, 0.02356660f, 
    -0.44692510f, -1.02346599f, -0.09552123f, -0.04131514f, 0.11828394f, 0.09672433f, -0.00281041f, 0.02928107f, 
    -0.06527570f, -0.02889939f, 0.06590209f, -0.13451470f, 0.14331675f, -0.02273771f, -0.23471572f, -0.07656791f, 
    -0.00296120f, -0.08068297f, 0.03583205f, 0.13556680f, -0.02658226f, 0.06254546f, -0.02813241f, -0.04827923f, 
    -0.05298398f, 0.03716491f, -0.05630214f, 0.06834977f, 0.03258191f, 0.01113597f, -0.17087002f, 0.16197547f, 
    0.05184170f, -0.01184638f, 0.05860278f, 0.04943052f, 0.05516623f, -0.00968484f, 0.06816979f, 0.08636396f, 
    0.14413787f, 0.05749772f, 0.08685842f, -0.07149246f, 0.09120236f, 0.05416081f, -0.10941623f, -0.02087689f, 
    0.01649982f, -0.05520231f, 0.14828892f, 0.03190226f, -0.05859376f, -0.07204350f, -0.07273739f, -0.18387303f, 
    0.12543215f, -0.03478833f, -0.03176084f, -0.20413521f, -0.29206368f, 0.21408391f, -0.46152359f, 0.11570051f, 
    0.02985350f, -0.09771458f, 0.18990980f, -0.05493555f, -0.00236452f, -0.05825511f, -0.10887545f, -0.08203217f, 
    -0.01475581f, 0.27759111f, -0.23394728f, 0.11251473f, -0.08995268f, 0.02418983f, 0.02058025f, 0.13250028f, 
    0.07660649f, -0.04143848f, -0.03579102f, 0.08681447f, -0.10538794f, -0.21175721f, 0.02209255f, -0.06763092f, 
    -0.09404066f, 0.18298298f, -0.23642367f, 0.01137762f, -0.00302317f, -0.28857863f, -0.16980195f, 0.01301949f, 
    -0.06536058f, -0.11165393f, -0.00501045f, -0.03631991f, 0.18593098f, -0.36920121f, 0.15771222f, 0.28484118f, 
    -0.02345242f, -0.02357793f, 0.02382741f, -0.06000095f, -0.18717945f, 0.16970341f, 0.18389897f, 0.07967002f, 
    0.00695026f, -0.06037428f, -0.08928405f, -0.05674633f, -0.00086877f, 0.11298507f, 0.05006987f, 0.08529086f, 
    0.17649832f, 0.42733347f, -0.24076024f, -0.21072355f, -0.10563863f, -0.17823207f, 0.05765923f, 0.08367161f, 
    0.04898827f, 0.02093121f, 0.13814555f, -0.02716465f, 0.12178214f, 0.01639500f, -0.10229052f, 0.02006273f, 
    0.08394949f, -0.15701760f, 0.05869772f, -0.03750754f, 0.10431975f, -0.11028343f, -0.09062368f, -0.00539244f, 
    0.00911130f, -0.08616097f, 0.16587763f, -0.04667899f, -0.02313753f, -0.02983682f, -0.05857728f, -0.06825212f, 
    0.06085304f, 0.06830289f, 0.10381371f, 0.10165036f, -0.17046121f, -0.17258175f, 0.22222795f, 0.34933963f, 
    0.02672431f, 0.10289158f, -0.05424743f, 0.05688389f, 0.04523405f, 0.03378135f, 0.01719566f, -0.05567636f, 
    -0.07339180f, 0.05606641f, 0.09518838f, -0.44381422f, -0.00360900f, -0.19209871f, 0.10339835f, -0.05858266f, 
    -0.18864237f, 0.11734936f, -0.11453369f, -0.06741374f, -0.06314186f, -0.12435564f, -0.30723852f, 0.13640824f, 
    0.05436715f, 0.04334432f, 0.13524628f, 0.02754997f, -0.07552937f, -0.05620610f, 0.02303373f, -0.11710896f, 
    -0.00038667f, -0.25671598f, -0.07941570f, 0.07726251f, 0.11184212f, -0.05732102f, 0.06959470f, 0.04489939f, 
    0.04862079f, -0.01996415f, 0.08328845f, 0.21016268f, 0.18628541f, 0.05591004f, 0.21594819f, -0.03893834f, 
    -0.05017363f, -0.02325702f, -0.03373886f, 0.02065194f, 0.07115901f, 0.08186362f, -0.05537780f, 0.06831099f, 
    0.03286166f, -0.08479901f, 0.16166738f, -0.07771859f, -0.01585426f, 0.04155525f, -0.11042126f, -0.22239296f, 
    0.02610939f, 0.02947220f, -0.24370264f, -0.01314321f, 0.23577298f, 0.25273016f, 0.20079277f, 0.43322104f, 
    0.03549642f, -0.10455283f, -0.04678829f, -0.02456174f, -0.08678766f, 0.01308697f, 0.06214470f, -0.16262659f, 
    0.27989677f, -0.19303904f, 0.05154683f, -0.51461083f, 0.09732274f, -0.01644910f, -0.04936958f, 0.06914380f, 
    -0.03615279f, 0.00985344f, 0.04514293f, -0.00415388f, 0.10305548f, -0.03279200f, 0.10143561f, 0.01136906f, 
    0.03241076f, 0.01136948f, 0.04533231f, -0.03359355f, 0.04679025f, 0.01114839f, -0.20294492f, -0.05833893f, 
    0.04461198f, -0.19754268f, 0.24241967f, -0.16662322f, -0.23971352f, 0.10236859f, -0.11030225f, -0.04602698f, 
    0.01055569f, 0.00242525f, -0.12352163f, 0.02252826f, -0.11896586f, -0.11459742f, 0.06895974f, -0.15937024f, 
    0.01495387f, -0.03363936f, -0.01711746f, 0.08145238f, -0.03686019f, 0.12160590f, 0.00265803f, -0.01657536f, 
    0.07477397f, 0.01653781f, 0.15958935f, -0.27427235f, -0.15047663f, -0.14242017f, -0.01549633f, -0.14597657f, 
    0.15872516f, -0.06865152f, -0.04005954f, 0.11787173f, -0.19040653f, 0.36546269f, 0.48542285f, -0.40485111f, 
    -0.02601066f, -0.26449591f, 0.07894362f, -0.08715178f, -0.11872931f, 0.05644048f, 0.01617251f, -0.00452958f, 
    0.40185785f, 0.23006241f, 0.08436107f, 0.08714094f, -0.10843471f, -0.02332834f, -0.16491295f, -0.13883978f, 
    0.03702664f, 0.02655728f, 0.06965236f, 0.05474042f, 0.18145794f, -0.48245764f, 0.06273180f, -0.14556891f, 
    -0.02559987f, 0.08647115f, -0.04314888f, -0.15429105f, 0.09071658f, -0.03693520f, 0.06086981f, 0.00691483f, 
    -0.18830623f, -0.08204911f, 0.20095275f, -0.04373563f, -0.05698888f, 0.02591550f, -0.06667235f, -0.03530328f, 
    0.09402514f, 0.03100250f, 0.04467180f, -0.02088821f, -0.01497861f, 0.14749241f, 0.35616243f, -0.22349796f, 
    0.04947065f, -0.00122049f, -0.00381454f, 0.04209412f, -0.07832107f, 0.04116512f, 0.14418626f, 0.10737804f, 
    -0.16461448f, -0.08237536f, 0.02126019f, -0.20626128f, 0.07825951f, -0.07749160f, -0.08902833f, 0.15814163f, 
    -0.00825970f, -0.06672950f, -0.09007745f, 0.10568957f, -0.44052050f, 0.22014964f, -0.27090639f, -0.40330237f, 
    -0.01088495f, -0.01034490f, 0.14795671f, 0.03818906f, 0.08104217f, 0.10079966f, -0.06136643f, 0.01837025f, 
    -0.30753487f, 0.37581396f, -0.50315374f, 0.38079879f, 0.07660242f, -0.18249039f, -0.15556848f, 0.06881423f, 
    0.09374969f, -0.09526695f, 0.00427494f, 0.06188378f, 0.05530329f, -0.07642186f, -0.06820834f, -0.06879274f, 
    0.08631238f, -0.07638378f, 0.16483037f, -0.02253294f, -0.01926121f, 0.00710824f, -0.11382694f, 0.04110532f, 
    0.04388764f, 0.03954505f, -0.06616997f, -0.18648496f, 0.03652845f, -0.20398955f, -0.00674562f, -0.21484286f, 
    -0.03188539f, 0.06700596f, 0.01480640f, -0.05106372f, -0.39129433f, -0.05386213f, -0.34219760f, 0.07800476f, 
    0.10408847f, -0.00195878f, 0.15135165f, -0.01435620f, -0.01023057f, -0.00361890f, -0.06219875f, 0.04244613f, 
    -0.17577817f, 0.17156722f, 0.13479030f, -0.28444222f, -0.10759205f, 0.04664714f, -0.11958236f, -0.12486043f, 
    -0.07508296f, 0.05333897f, -0.04126635f, 0.05361354f, -0.47107562f, -0.06384342f, -0.21765310f, -0.02969797f, 
    -0.32088733f, -0.00325094f, -0.03225834f, 0.23239663f, 0.08029098f, 0.00004314f, 0.01346697f, -0.00480092f, 
    -0.10731338f, -0.00583008f, 0.08339506f, -0.19962329f, 0.07539022f, -0.03283945f, -0.11696564f, 0.02793081f, 
    -0.08365583f, -0.00957069f, 0.04615670f, 0.02961234f, -0.04476074f, 0.23668562f, -0.22588295f, -0.36793980f, 
    -0.15527327f, 0.03527341f, -0.16776671f, 0.07875291f, 0.11423033f, -0.13633040f, 0.08594818f, -0.01758991f, 
    0.40059865f, -0.08978111f, -0.10139797f, -0.16188182f, 0.06270416f, 0.04139124f, 0.04912328f, 0.03582844f, 
    -0.00300798f, 0.02882346f, -0.01119878f, -0.03056884f, -0.15614973f, -0.04107926f, -0.08499628f, 0.34241477f, 
    0.10640607f, 0.04981994f, -0.00524940f, -0.00300394f, 0.13250624f, 0.04440382f, 0.06279712f, 0.12647435f, 
    -0.18076140f, -0.22257592f, -0.40458310f, -0.30822000f, -0.23816851f, -0.13824666f, 0.04268353f, -0.13231184f, 
    -0.01294417f, 0.08579320f, -0.07364587f, 0.10916210f, -0.06781493f, -0.17693833f, -0.10470421f, 0.19281387f, 
    0.06538841f, 0.02468223f, 0.19470334f, -0.15349019f, 0.05725871f, 0.10280812f, 0.10507708f, 0.16598906f, 
    0.11777406f, -0.14689502f, 0.13497266f, 0.15889007f, 0.06583052f, -0.11586934f, -0.06779288f, 0.09904236f, 
    -0.16384616f, -0.34914938f, -0.38438982f, -0.28358188f, -0.48251483f, 0.13160302f, 0.01271337f, 0.05291800f, 
    -0.06857096f, 0.10034250f, -0.02814009f, 0.31288901f, 0.06678595f, -0.15987803f, 0.17590627f, 0.05400781f, 
    -0.11559321f, -0.03257300f, 0.25573710f, 0.10274668f, -0.03858215f, -0.22220753f, 0.03748231f, 0.09007957f, 
    -0.12264221f, 0.04232110f, -0.08057276f, -0.09692656f, -0.06777358f, -0.60577738f, -0.14138263f, -0.14879836f, 
    -0.14370981f, 0.09502277f, 0.11592909f, 0.05559316f, 0.14228478f, 0.05664933f, 0.03462478f, -0.00660367f, 
    -0.27088094f, -0.12730893f, 0.24031442f, -0.37562343f, -0.24349199f, 0.00983172f, 0.05471381f, -0.10317434f, 
    0.11619276f, 0.05512950f, 0.11340980f, 0.09946591f, -0.32160971f, -0.00187209f, -0.24698746f, -0.02825225f, 
    -0.02024121f, -0.03904555f, -0.06530605f, -0.09547920f, -0.10181954f, 0.02217559f, 0.05648351f, -0.02197941f, 
    -0.15601899f, 0.28161165f, 0.10457979f, -0.23353273f, -0.06295650f, 0.12132814f, -0.14093930f, 0.05269982f, 
    0.07143820f, 0.02875962f, 0.02273985f, -0.05310354f, -0.14286897f, -0.23034745f, -0.03342453f, 0.05096325f, 
    -0.01072209f, 0.11859714f, 0.01807784f, 0.12605649f, -0.02160495f, -0.01613171f, -0.03419748f, -0.02865183f, 
    -0.08801135f, 0.26553401f, 0.40719286f, -0.10298271f, 0.04070446f, 0.17371257f, 0.31179288f, 0.18411416f, 
    0.12327166f, -0.06454626f, 0.11084004f, -0.16735236f, 0.29152906f, 0.40075967f, 0.14901726f, -0.40488178f, 
    -0.01716196f, 0.04047234f, 0.15364440f, 0.18713084f, -0.01969855f, 0.18398149f, -0.10962733f, 0.12075042f, 
    0.14774887f, -0.22543123f, 0.09206848f, -0.04341712f, 0.06948823f, -0.16843092f, -0.14662462f, -0.08077592f, 
    0.01658671f, -0.09624736f, -0.22898017f, -0.22737533f, 0.04664540f, 0.01014186f, 0.34762862f, 0.13041480f, 
    -0.13213892f, 0.02371288f, 0.08028432f, -0.02026996f, -0.15015005f, 0.04776188f, 0.09178074f, 0.09750341f, 
    0.18466707f, -0.06318448f, 0.16435251f, -0.00333131f, -0.08889531f, -0.08852417f, 0.14427966f, 0.11164430f, 
    -0.13906270f, 0.06296540f, 0.04305621f, -0.05973052f, -0.11447575f, -0.00445757f, 0.27643400f, -0.01942917f, 
    -0.12589023f, 0.04782322f, 0.03727053f, 0.04553827f, -0.04396651f, 0.02435977f, -0.11795804f, 0.04935427f, 
    -0.16191782f, 0.20114861f, -0.07615039f, 0.05951810f, 0.05328796f, -0.11520319f, 0.01986202f, 0.14890184f, 
    -0.03467668f, 0.05993273f, -0.05664584f, -0.08773861f, 0.01887968f, 0.20748307f, -0.03564794f, 0.05137259f, 
    -0.11102464f, -0.10745831f, -0.08178502f, 0.14267683f, 0.07467264f, -0.07078001f, -0.06107426f, 0.04017313f, 
    -0.33177847f, -0.10161028f, 0.09095266f, -0.06027570f, -0.04303835f, 0.04168428f, -0.08304603f, -0.07860760f, 
    0.14140362f, 0.07888796f, -0.08196732f, 0.14981210f, -0.31672546f, 0.13955590f, 0.04259226f, 0.16006134f, 
    -0.26976469f, -0.03092264f, 0.10547768f, -0.07566199f, 0.08229022f, 0.06571820f, -0.12233426f, -0.15002662f, 
    -0.17727095f, -0.05759436f, -0.33066243f, -0.09685497f, 0.10220470f, -0.02010864f, -0.16716421f, -0.05618638f, 
    0.03011491f, 0.07358707f, -0.01771158f, -0.09627363f, 0.06194758f, -0.03940072f, 0.01649561f, -0.02430839f, 
    -0.03012230f, 0.00887586f, 0.14402294f, 0.00438946f, -0.04168984f, 0.11016700f, -0.16346216f, 0.02445085f, 
    -0.51255101f, 0.11693696f, -0.31637898f, 0.37838873f, -0.02463331f, 0.18918763f, -0.02801068f, 0.04575477f, 
    -0.02874105f, -0.05445174f, 0.04791018f, 0.07649645f, 0.00025420f, -0.26899147f, 0.05049830f, 0.07621390f, 
    -0.03152167f, 0.00971931f, 0.03282488f, -0.07446725f, 0.07308510f, 0.01215972f, 0.05587342f, 0.05967876f, 
    -0.16932100f, 0.22505757f, 0.01286752f, 0.02048563f, 0.04070780f, 0.08305419f, -0.13254993f, 0.09983078f, 
    -0.02961023f, 0.05220692f, -0.00893691f, 0.13345657f, -0.10441348f, 0.01654984f, -0.11916871f, -0.11346823f, 
    -0.06424304f, -0.02399135f, 0.14604568f, -0.06052232f, 0.01154784f, 0.08956506f, 0.06817145f, 0.22481996f, 
    -0.04932839f, 0.17052007f, -0.33328474f, -0.06454758f, -0.01650973f, 0.07147221f, 0.04138558f, -0.15456209f, 
    -0.01025461f, 0.17510718f, 0.09629491f, 0.10567148f, -0.19299246f, -0.03061129f, 0.08028300f, -0.06763705f, 
    -0.14551720f, -0.09826653f, 0.12096208f, -0.02421808f, 0.02134805f, 0.16181187f, 0.10530163f, 0.04060159f, 
    -0.26765165f, 0.14369603f, -0.12100445f, -0.17644235f, 0.06649592f, 0.08731195f, 0.31716961f, -0.12422508f, 
    -0.04646428f, 0.14376426f, 0.02565803f, 0.16351534f, -0.17337210f, 0.03624205f, 0.25696540f, -0.03302545f, 
    0.14230531f, -0.10323937f, 0.05902765f, -0.12215310f, 0.04996650f, 0.01565316f, -0.19276735f, 0.05551937f, 
    -0.31820425f, 0.03464561f, -0.29498988f, 0.06085320f, 0.02820021f, -0.00421725f, -0.01653990f, -0.10673679f, 
    -0.06699637f, 0.12083175f, 0.03653485f, 0.15523058f, 0.00148248f, 0.05624376f, -0.08527727f, -0.14442399f, 
    0.00101922f, -0.08588639f, 0.09895886f, 0.04540093f, -0.09465346f, -0.14659262f, -0.42805853f, -0.29614660f, 
    0.18196982f, -0.06776184f, 0.22958097f, 0.21409911f, 0.00064267f, -0.00420263f, -0.01498829f, -0.00264802f, 
    -0.19310190f, -0.10403090f, -0.19403563f, 0.12079231f, -0.14406477f, -0.03198352f, -0.36768657f, 0.05090296f, 
    -0.00977273f, 0.06009825f, 0.00110377f, -0.05813988f, 0.00149154f, 0.07985201f, -0.03114093f, 0.01728384f, 
    -0.13649261f, 0.23738801f, 0.06480544f, 0.10860424f, 0.05728917f, -0.15814999f, -0.04333951f, -0.02512412f, 
    -0.09293048f, -0.10907125f, -0.04661873f, -0.06851555f, -0.27775943f, -0.15270098f, -0.23967259f, -0.35292441f, 
    -0.10205200f, -0.07129139f, -0.03481970f, -0.19784114f, 0.09597079f, -0.07205692f, -0.14167598f, 0.11704651f, 
    -0.03049826f, 0.08297856f, -0.03806856f, -0.04820035f, -0.17052284f, -0.05775119f, 0.10566886f, -0.01169812f, 
    0.02636598f, 0.10576262f, -0.04927744f, 0.08293771f, 0.06554206f, 0.21030051f, -0.11921830f, -0.00181505f, 
    -0.08006790f, -0.13366733f, -0.05379041f, 0.01397580f, -0.03124012f, 0.02906577f, 0.05703679f, 0.02190046f, 
    -0.11636430f, -0.05304454f, -0.04385043f, 0.05289825f, -0.04916394f, -0.00607639f, -0.13106878f, -0.11382057f, 
    0.05688694f, 0.08198369f, -0.01590272f, -0.19574806f, -0.25392297f, 0.22446026f, -0.05324059f, 0.07188207f, 
    0.01200423f, -0.10995927f, -0.08490536f, 0.18920587f, -0.26741543f, -0.16459681f, -0.09766401f, -0.26297498f, 
    -0.20200479f, -0.00080279f, 0.06701587f, -0.04686404f, -0.02183564f, 0.06177175f, -0.06712427f, 0.05080262f, 
    0.05784596f, 0.12884656f, -0.08376700f, 0.12794414f, -0.14846453f, 0.11099903f, -0.06174126f, -0.05886986f, 
    -0.13575490f, -0.05858510f, 0.06149938f, -0.15023991f, 0.03099465f, 0.12138172f, 0.02509249f, 0.07279380f, 
    -0.00021798f, -0.39415857f, -0.10000096f, 0.15108797f, 0.05772425f, 0.02229069f, -0.04616188f, 0.00072299f, 
    -0.00770698f, -0.04535970f, -0.35788637f, -0.15975204f, 0.10779908f, 0.03267543f, 0.05546601f, -0.02552719f, 
    -0.14087956f, -0.10079242f, 0.07482880f, -0.01425309f, 0.04084079f, 0.04138045f, 0.05865325f, 0.09034649f, 
    -0.06382512f, 0.28606483f, -0.07439913f, -0.17366128f, -0.01829114f, 0.07445120f, 0.06484464f, -0.01373041f, 
    -0.02920550f, 0.26526669f, 0.14031488f, 0.11136428f, 0.04775552f, -0.24569269f, 0.17056637f, 0.00663177f, 
    -0.03275353f, -0.00057634f, -0.01819581f, -0.12639762f, 0.07528258f, 0.09510597f, -0.23357542f, 0.08034952f, 
    -0.12338156f, 0.12894174f, -0.14372115f, 0.06013876f, 0.16659965f, -0.36017016f, 0.07204462f, -0.07943338f, 
    -0.22573331f, 0.13784060f, -0.31583461f, -0.38363668f, -0.08380328f, -0.07990929f, 0.15640469f, 0.19634004f, 
    -0.05031344f, 0.05687198f, -0.04970789f, 0.03963659f, 0.09403962f, -0.02409737f, 0.03913105f, -0.08147828f, 
    -0.36313230f, 0.11821416f, 0.15561102f, 0.08944663f, 0.04448102f, 0.06178471f, -0.16638744f, 0.00319531f, 
    -0.19687447f, 0.10674000f, 0.07479224f, -0.15971377f, -0.22830911f, 0.08646592f, 0.19159865f, 0.05211537f, 
    -0.08897071f, 0.10935193f, 0.08013389f, -0.07880982f, 0.01346352f, 0.15298136f, 0.18814220f, -0.01497848f, 
    -0.21995042f, -0.03143841f, -0.18623903f, 0.00494974f, -0.02578292f, -0.23099293f, 0.10036081f, 0.02996855f, 
    -0.05770004f, 0.00996001f, 0.05013000f, -0.11887512f, -0.07134430f, 0.05385160f, -0.04702335f, 0.03807781f, 
    0.00641644f, -0.08966645f, -0.16503906f, 0.08483728f, -0.14821692f, -0.31768668f, -0.25348723f, -0.24296427f, 
    -0.23756184f, 0.15217566f, 0.31532127f, -0.02778697f, -0.02231460f, 0.20171924f, -0.04895076f, 0.06151510f, 
    -0.14350538f, -0.09962830f, 0.14194517f, -0.12497091f, 0.37976873f, -0.40176070f, 0.27634302f, 0.17445551f, 
    -0.22203539f, -0.06603204f, 0.11311261f, 0.04430638f, -0.12022537f, -0.15069582f, -0.13762927f, -0.12287425f, 
    0.36823148f, 0.29877996f, 0.18182638f, -0.22272415f, 0.03539623f, -0.17337185f, 0.04339851f, 0.19334365f, 
    -0.10516457f, 0.10467541f, -0.09864831f, 0.11346418f, -0.07440007f, 0.12051870f, -0.29344609f, 0.15050811f, 
    -0.06915358f, -0.07899307f, 0.02301995f, -0.01417442f, -0.09441114f, -0.11969480f, 0.12526028f, -0.24576828f, 
    -0.02542498f, 0.03514795f, -0.03152494f, 0.03467058f, -0.00812489f, 0.08010975f, 0.09520874f, -0.03144942f, 
    0.03781228f, 0.00546637f, -0.03953766f, -0.04221607f, -0.03527419f, -0.11888199f, -0.06866806f, 0.01930820f, 
    -0.20340993f, -0.03234218f, -0.10086736f, 0.04722226f, 0.00835867f, -0.11210571f, -0.02685746f, 0.10550518f, 
    0.11883574f, 0.01524847f, 0.20082749f, -0.21697325f, 0.06348750f, -0.01764521f, -0.02343651f, -0.07316829f, 
    -0.20257995f, -0.11091595f, 0.09291171f, 0.02629959f, -0.15811960f, 0.30096722f, -0.12312333f, 0.26319426f, 
    -0.05758965f, -0.15537265f, -0.10358905f, 0.14708401f, 0.03561926f, 0.12110430f, -0.08571089f, 0.04320604f, 
    -0.06691033f, -0.02273747f, -0.06299373f, 0.08650050f, -0.07808882f, 0.05278595f, -0.19376530f, 0.15696743f, 
    0.12828644f, 0.11949635f, 0.00292103f, -0.11944631f, 0.33232868f, -0.18989530f, 0.30277547f, 0.14546354f, 
    0.02066152f, -0.07091361f, 0.11518510f, 0.08950566f, -0.11016987f, 0.09316846f, 0.03946358f, 0.01607958f, 
    -0.29899451f, 0.08364839f, -0.19166328f, 0.07893710f, -0.02323162f, -0.13513859f, -0.04342100f, 0.10783767f, 
    -0.13315368f, -0.03921324f, -0.02416145f, 0.10925963f, 0.20060267f, -0.20480511f, -0.00444174f, -0.38835210f, 
    -0.15361372f, -0.25012550f, 0.00655580f, 0.01835122f, -0.07989167f, -0.00207897f, -0.14739618f, -0.11041090f, 
    0.20229009f, 0.07848458f, 0.06216560f, -0.04951043f, 0.01463419f, 0.04092180f, -0.05444265f, 0.01686123f, 
    -0.07046494f, -0.12807794f, 0.04584887f, -0.12114339f, 0.06937595f, 0.07096381f, 0.03152658f, 0.14452535f, 
    0.05406695f, -0.03134936f, 0.01006305f, 0.03170945f, 0.00682042f, -0.03149261f, -0.07331257f, -0.14286678f, 
    -0.15483150f, 0.10247496f, 0.19558081f, -0.32544374f, 0.00094250f, 0.11361296f, 0.07296217f, 0.07612200f, 
    -0.03522705f, 0.09805444f, 0.13745800f, -0.05788800f, 0.16962872f, -0.03243485f, 0.04139528f, 0.09708473f, 
    0.00210775f, -0.06446375f, -0.09096120f, 0.17000595f, -0.11202103f, 0.05643043f, -0.04620060f, -0.02849672f, 
    0.27710813f, 0.07279819f, 0.17190316f, 0.05874531f, -0.07505286f, 0.12824945f, -0.00449376f, 0.11432900f, 
    -0.17718251f, -0.06886869f, 0.17070453f, -0.09052123f, -0.13095447f, -0.43840748f, -0.09919712f, -0.07080101f, 
    -0.14651681f, -0.28720614f, -0.20864367f, -0.17078678f, 0.05141987f, 0.03721181f, -0.05099989f, -0.10055410f, 
    -0.01449892f, 0.17036387f, -0.21100660f, -0.08188544f, 0.03956848f, 0.04504307f, 0.04488894f, -0.01880664f, 
    0.01301442f, -0.14505565f, 0.00827282f, -0.08878405f, 0.09605042f, 0.22138724f, 0.02303415f, 0.04870157f, 
    0.03949455f, -0.03332444f, -0.11701667f, -0.01114167f, -0.05813751f, -0.05485251f, -0.08060364f, -0.12426914f, 
    -0.30904019f, -0.34623712f, -0.41389212f, 0.05559266f, 0.07439850f, 0.11787034f, 0.00805764f, 0.07697203f, 
    0.06192719f, 0.16127059f, 0.04565740f, -0.02020874f, -0.28846776f, -0.03992441f, -0.23604919f, 0.04316048f, 
    -0.02030984f, -0.00953462f, 0.06991944f, 0.03345036f, -0.08991862f, -0.10655116f, -0.01833082f, -0.24243011f, 
    0.23466566f, -0.42996842f, 0.08283178f, -0.09864791f, 0.02058635f, -0.01831505f, 0.01182994f, 0.04704300f, 
    -0.11892983f, 0.25817832f, 0.24130379f, 0.16005570f, -0.04594562f, -0.30915570f, 0.12374023f, -0.16404952f, 
    0.06848054f, -0.05403635f, 0.02685521f, -0.00915521f, 0.11397685f, -0.12888466f, -0.03300117f, -0.05298250f, 
    0.02282527f, -0.02556227f, -0.10919823f, -0.50477797f, -0.03721562f, -0.05942539f, 0.09660997f, 0.04632949f, 
    0.00293189f, 0.13902070f, 0.09215987f, -0.06394365f, 0.00744178f, 0.05840598f, 0.24610490f, -0.24513775f, 
    0.03793802f, 0.09219918f, 0.00603005f, -0.02247464f, -0.05120267f, 0.06301611f, -0.00325638f, 0.05523708f, 
    0.09452498f, 0.12611890f, 0.06916834f, -0.32121328f, -0.15367351f, 0.14580601f, 0.24367143f, -0.05077906f, 
    -0.03336381f, -0.07499350f, -0.01223357f, -0.03666393f, 0.28307810f, 0.00922547f, -0.01286350f, -0.00895150f, 
    0.05741794f, 0.22416256f, 0.09137974f, 0.01468151f, -0.01826112f, 0.08197671f, 0.20314357f, -0.14250389f, 
    0.09771821f, -0.04248964f, 0.23141068f, -0.02344583f, 0.13332260f, 0.02932896f, 0.13653159f, -0.02190205f, 
    0.00834049f, 0.01594150f, -0.16645969f, 0.05797054f, -0.03199869f, 0.10127551f, 0.14936873f, -0.15695257f, 
    -0.05146825f, 0.12069461f, -0.11764219f, -0.00342949f, -0.03539801f, 0.09938075f, 0.12268942f, 0.07177745f, 
    -0.07859768f, -0.03605611f, -0.05341107f, -0.12455884f, 0.10553399f, -0.00432403f, 0.13111304f, -0.07272793f, 
    0.08515552f, 0.10894543f, -0.04215821f, 0.03556896f, 0.16827330f, 0.03174005f, 0.05273064f, -0.11476442f, 
    0.16471779f, -0.00579133f, 0.21742098f, 0.04848987f, 0.08299119f, 0.08928909f, 0.01090514f, 0.01884625f, 
    -0.03291658f, -0.26895681f, -0.04006064f, -0.09375824f, -0.04791648f, -0.15449858f, -0.03584041f, -0.03580024f, 
    0.00065355f, 0.05261454f, 0.01303256f, -0.09765039f, 0.29067054f, -0.44336194f, 0.40464085f, -0.09480880f, 
    0.01456781f, 0.08726340f, -0.00941724f, 0.06480683f, -0.09179986f, -0.03186610f, 0.02992198f, 0.17912799f, 
    -0.24585478f, 0.08255640f, -0.28603756f, 0.07302807f, -0.10629655f, -0.04870159f, -0.19176047f, -0.11075400f, 
    -0.04330368f, -0.02077407f, -0.01432482f, -0.04594604f, 0.24299744f, -0.15976663f, 0.47452411f, -0.06636841f, 
    -0.12210018f, -0.02818673f, -0.22576052f, 0.05859718f, 0.02509611f, 0.00066283f, -0.01292624f, 0.05182926f, 
    -0.38165617f, 0.06073264f, -0.01286928f, 0.19287120f, 0.07845837f, -0.06386238f, 0.00040504f, 0.14098367f, 
    -0.22540806f, -0.09156057f, -0.06699000f, 0.13846911f, -0.09737616f, -0.04184436f, -0.16340953f, 0.01513286f, 
    -0.00170312f, 0.00488555f, -0.01056905f, 0.08696554f, -0.11728125f, -0.13912201f, -0.18833290f, -0.39528763f, 
    -0.02478231f, 0.15911980f, -0.19093996f, 0.02914640f, 0.01075194f, 0.01070643f, -0.03365653f, -0.00602327f, 
    -0.16453135f, -0.06708974f, 0.03469870f, -0.03947597f, 0.38357934f, 0.06923245f, 0.59437352f, -0.04565441f, 
    0.02167992f, 0.05991265f, -0.09848996f, 0.11751372f, -0.10557704f, 0.04582684f, -0.02941841f, -0.04747792f, 
    0.22393322f, -0.19772050f, 0.32645842f, 0.19729508f, 0.11321808f, -0.06795928f, 0.11583637f, 0.00005615f, 
    -0.15003772f, 0.06453045f, 0.06173638f, -0.11661445f, -0.31725657f, 0.16220269f, -0.42696872f, 0.32435691f, 
    0.26857093f, 0.03472335f, 0.00154256f, -0.21263368f, 0.02099372f, 0.06993078f, -0.11848833f, 0.19150694f, 
    -0.00044861f, -0.24333878f, -0.03921063f, 0.03568076f, -0.06329364f, -0.20489736f, -0.22265099f, -0.22777046f, 
    -0.05243681f, -0.10220580f, -0.07947527f, -0.10363016f, 0.01591633f, -0.11093659f, -0.04709965f, -0.15791297f, 
    0.04685710f, 0.06418024f, -0.12060160f, 0.00954809f, 0.01739225f, 0.02581977f, 0.12771590f, 0.00951209f, 
    -0.47824606f, -0.35058641f, 0.33354780f, 0.18450688f, 0.04559362f, 0.05722420f, 0.18566890f, 0.02272125f, 
    0.03284974f, 0.07502747f, -0.11639612f, 0.22004701f, 0.47133696f, 0.00259379f, 0.16659410f, -0.05555280f, 
    0.16003150f, 0.07008452f, -0.05943309f, 0.16805077f, -0.10677250f, -0.00045262f, 0.11691358f, -0.13589515f, 
    -0.20528983f, 0.21291575f, -0.27720493f, 0.09218287f, 0.05738493f, 0.02443335f, -0.05044151f, -0.03770139f, 
    -0.03025557f, 0.14066890f, 0.11225525f, 0.19775300f, -0.19766828f, 0.06278074f, -0.24046308f, -0.03142630f, 
    0.05047304f, -0.03400240f, 0.13190462f, 0.00013767f, -0.00030846f, 0.10364875f, 0.07826263f, -0.05043436f, 
    0.04047739f, -0.22649311f, 0.13270180f, -0.03623138f, -0.10623766f, 0.02689802f, -0.04915996f, 0.11404477f, 
    -0.18117511f, -0.10287380f, 0.03198336f, -0.12853046f, 0.30958399f, -0.04804991f, 0.18609828f, 0.23227695f, 
    -0.13188785f, 0.10062173f, -0.15623136f, 0.05485960f, -0.13952304f, 0.09268985f, -0.04315347f, -0.00394515f, 
    -0.14039245f, 0.04917527f, 0.40359312f, -0.17819856f, 0.03036596f, 0.05543173f, 0.14571427f, 0.01885138f, 
    0.01027625f, 0.09472856f, 0.11132158f, 0.17772542f, -0.25207272f, -0.05608642f, -0.06056548f, 0.15196107f, 
    -0.02769022f, 0.03962265f, -0.03766437f, 0.06181306f, -0.09844952f, 0.09777521f, -0.00293291f, 0.13461457f, 
    -0.01337801f, 0.16106094f, -0.12593649f, 0.22110248f, -0.02172858f, -0.00906948f, 0.05600665f, -0.14315592f, 
    0.00712098f, -0.00736497f, 0.02864796f, 0.07611162f, -0.23751581f, -0.27805096f, -0.13751155f, 0.12069396f, 
    0.08145999f, -0.01807889f, -0.06095059f, 0.03413783f, -0.15894735f, -0.08840733f, 0.10357650f, 0.05375780f, 
    -0.49405801f, 0.04554448f, -0.18738662f, -0.17139341f, -0.00771540f, 0.09776347f, -0.01152571f, 0.07284697f, 
    -0.10071467f, 0.11966120f, 0.14744927f, 0.08542689f, -0.08734544f, -0.00772476f, -0.04892663f, -0.11188976f, 
    -0.01681525f, 0.08404536f, -0.17087476f, 0.06052056f, -0.18364397f, -0.02171003f, -0.06023008f, -0.22857195f, 
    -0.21219940f, 0.08071785f, -0.25847372f, 0.03288095f, -0.02859177f, -0.32660583f, -0.10883957f, -0.06016210f, 
    -0.01202404f, -0.00897377f, -0.03910415f, 0.00838329f, -0.33603820f, 0.09793780f, -0.20419995f, 0.13152175f, 
    -0.01405839f, 0.05235806f, -0.05333927f, 0.03146023f, -0.12940711f, -0.03897264f, 0.02996470f, 0.10532383f, 
    0.14833213f, 0.11162549f, -0.40027040f, -0.04344141f, -0.06794555f, -0.05392469f, 0.03497535f, 0.01122755f, 
    -0.03088597f, 0.01827923f, 0.09160182f, -0.03643312f, -0.20512055f, -0.26838043f, 0.20743622f, -0.36089939f, 
    -0.11161935f, -0.07574678f, 0.01986178f, 0.00298412f, -0.01970846f, -0.00125919f, -0.09549825f, -0.15129423f, 
    -0.21039799f, 0.05127560f, -0.13794398f, 0.11114992f, 0.09989766f, -0.14848873f, 0.06354766f, 0.08487843f, 
    0.02686113f, -0.06780983f, -0.04183679f, -0.11471479f, 0.31403044f, 0.28712055f, 0.07722045f, 0.18505526f, 
    -0.05599734f, -0.06256844f, 0.10976780f, 0.19081604f, 0.02543510f, 0.01932619f, -0.15353346f, 0.09928005f, 
    -0.30213106f, 0.44492224f, -0.33643320f, -0.19621377f, -0.15720735f, -0.02608467f, 0.17884938f, 0.02437437f, 
    0.04048280f, 0.16053532f, 0.09255590f, 0.02102270f, -0.08906802f, 0.00146245f, 0.25773242f, 0.06456576f, 
    0.04103160f, 0.04251141f, 0.03406610f, 0.09149960f, -0.10809313f, 0.14767942f, 0.10641474f, 0.03926615f, 
    -0.15691811f, 0.00190714f, 0.11297618f, 0.05470685f, 0.01273827f, -0.08006684f, 0.26569617f, 0.29597664f, 
    -0.07427784f, 0.03780598f, -0.02731883f, 0.05907438f, -0.23571435f, 0.19581351f, 0.07676053f, -0.06986722f, 
    -0.18707587f, 0.13170956f, -0.22616291f, 0.01314368f, 0.12734114f, 0.07532378f, 0.14227171f, 0.01192403f, 
    -0.11485518f, -0.17713590f, 0.13532518f, 0.13068785f, -0.04393386f, 0.08737104f, 0.16874816f, -0.08200800f, 
    -0.11888619f, -0.04198656f, -0.14854164f, -0.07448673f, 0.04006520f, 0.23476788f, 0.26891011f, 0.08778657f, 
    0.06738807f, 0.09674461f, 0.03369191f, 0.01911702f, -0.24306434f, 0.08509931f, -0.04595330f, -0.02521357f, 
    -0.03272119f, 0.02422978f, 0.07217980f, -0.13862388f, -0.08163732f, -0.14251514f, 0.02179901f, 0.08148865f, 
    -0.21563469f, -0.07234246f, -0.04484124f, -0.00830289f, 0.40401778f, 0.06806461f, 0.39946479f, -0.21487735f, 
    0.01226616f, 0.00310741f, -0.05968108f, 0.04764633f, -0.02295836f, 0.02189226f, 0.00348951f, -0.02785684f, 
    -0.25274858f, 0.05402724f, -0.00248784f, -0.02284005f, 0.10556725f, -0.15352900f, 0.10810935f, -0.01673199f, 
    0.02168049f, 0.04555598f, -0.04715220f, -0.09681538f, 0.11703785f, -0.43576083f, 0.25937647f, -0.04065751f, 
    -0.03293480f, -0.19063543f, -0.26669562f, -0.03564386f, 0.06190441f, -0.03792958f, 0.01105665f, -0.06789328f, 
    -0.38636842f, -0.35582486f, 0.04486940f, -0.01106555f, -0.16348705f, -0.17417055f, -0.05276721f, 0.09723817f, 
    -0.09701920f, 0.04033939f, -0.03754994f, 0.00376231f, -0.26323339f, -0.10968797f, 0.12830861f, -0.07748012f, 
    0.05351144f, 0.03757060f, 0.19617829f, -0.31911758f, 0.01209176f, -0.09310139f, -0.09419490f, -0.08840957f, 
    -0.09537236f, 0.07594667f, 0.06660132f, -0.07880054f, -0.16560562f, -0.09242975f, -0.10865108f, -0.07363406f, 
    -0.00408725f, 0.12537991f, 0.11595774f, 0.10625079f, 0.01506831f, -0.09575244f, -0.10719358f, -0.21301903f, 
    0.05990717f, 0.15242021f, 0.07235174f, 0.13121901f, -0.01548474f, 0.10966363f, 0.14421847f, -0.07829013f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13825214f, 0.08500339f, 0.06255279f, -0.07270326f, -0.09556680f, 0.05700558f, 0.04638744f, -0.11627567f, 
    0.04515949f, -0.00831169f, 0.06164916f, -0.04293224f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
