#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.27696031f, 0.24398373f, -0.91808552f, -0.00274601f, -0.73340827f, -0.50427258f, -0.45332813f, -0.44961885f, 
    -0.25579008f, -0.19492367f, 0.52187037f, 0.79350030f, 0.77067459f, 0.32247770f, 0.56553501f, -0.03779837f, 
    0.53076446f, -0.25211897f, 1.01604760f, 0.22802016f, -0.38540000f, -0.45060694f, -0.67608875f, 0.36028260f, 
    0.23429684f, 0.10306833f, 0.62944251f, 1.03644359f, -0.22285946f, 0.86309755f, -0.45225194f, -0.21571451f, 
    -0.60647982f, 0.07827776f, -0.13757260f, 0.21382841f, 0.67949289f, 0.80068868f, -0.74690700f, 0.38605902f, 
    -0.16958238f, 0.45133376f, -0.52238059f, -0.07505361f, 0.27714181f, 0.86712033f, 0.15722427f, -0.57426643f, 
    0.67363727f, 0.02549628f, -0.51258135f, 0.28878766f, 0.11357532f, 0.40006754f, -0.56041718f, 0.10573941f, 
    0.78639638f, -1.00407398f, -0.72096860f, -0.63409567f, 0.03549020f, 0.33689657f, 0.23035699f, 0.94894183f, 
    0.37694585f, 0.67806232f, 0.36840853f, -0.97166240f, 0.15666378f, 0.50631756f, -0.25327647f, -0.31996560f, 
    -0.15805165f, 0.65339690f, -0.47895530f, 0.72449720f, -0.38310400f, 0.38564849f, 0.37804997f, -0.49519044f, 
    0.11352617f, -0.10253704f, 1.26825523f, -0.74591291f, 0.69587761f, 0.45968071f, -0.37154803f, 0.28221944f, 
    -0.01588456f, -0.32122239f, -0.27208689f, -0.64771372f, 0.75831997f, -0.69943064f, -1.01480138f, -0.44029385f, 
    -0.30671671f, 0.29160249f, -0.55931932f, -0.87915838f, -0.79724771f, -0.55910504f, 0.57755274f, -0.50140661f, 
    -0.55180508f, 0.61415857f, 0.33205801f, -0.30089891f, -0.97139239f, -0.50693148f, 1.15879405f, 0.81538349f, 
    0.34649420f, -0.35989213f, 0.28026384f, -0.04246030f, 0.27436045f, -0.93701690f, 0.93363005f, 0.46493101f, 
    -0.06879454f, -0.50369585f, -0.56256711f, -0.37131363f, 0.53858256f, -0.56037068f, 0.86729944f, -1.10023260f, 
    0.73222911f, 0.62303334f, 0.43149516f, 0.52584463f, -0.01976717f, -0.00685022f, -0.20785487f, -0.59689832f, 
    -1.32633209f, 0.14152366f, 0.67200822f, 0.37701544f, 0.66725445f, 0.15978219f, -0.08117779f, -0.25463641f, 
    -1.05680668f, 1.08612764f, -0.37827864f, -0.61821741f, 0.74083769f, -0.14557315f, -0.33261022f, 0.27954885f, 
    0.33825767f, -0.34085149f, -0.64377582f, -0.77212858f, -0.63872749f, 0.22296087f, 0.52107525f, -0.67750847f, 
    -0.27040517f, -0.32961935f, 0.78889239f, 0.64030808f, -1.00891459f, -0.52944595f, 0.52362096f, 0.48092413f, 
    -0.12958796f, -0.04977774f, 0.05321080f, -1.01117849f, 1.12082720f, 0.68213069f, 0.58870983f, 0.09582938f, 
    -0.71859282f, -0.23101506f, -0.38253212f, 0.00408380f, -0.60717463f, 0.39608374f, -0.39004427f, 0.54507524f, 
    0.36491776f, 0.77796870f, 0.32996136f, -0.26482332f, -0.68163550f, 1.02753079f, -0.57859117f, -0.53561968f, 
    -0.12378857f, -0.84109885f, -0.78398246f, -0.25477931f, 0.34161776f, 0.13706262f, 0.11658593f, 0.60649371f, 
    -0.26928428f, -0.29924449f, -0.25414953f, 0.51344335f, -0.19300073f, 0.54563749f, 0.55087501f, -0.59203237f, 
    -0.64254689f, -0.24120198f, 0.24127220f, 0.98833472f, 0.54731292f, -0.26454604f, 0.13842544f, 0.24045932f, 
    1.11928546f, 0.67457640f, 0.39177832f, -0.73933148f, -0.17901275f, -0.13337201f, -0.17469549f, 0.08644626f, 
    0.26466635f, 0.87210941f, 0.92261767f, 0.84149259f, 0.32157582f, -0.34151849f, -0.19743945f, -0.07555588f, 
    0.42607298f, 0.31476289f, -0.13785470f, 0.68064368f, 0.65775204f, -0.11616882f, -0.52624953f, 0.79302698f, 
    -0.50336856f, -0.04362797f, -0.47989944f, 0.53241611f, 0.40519211f, 0.84829688f, 0.83996266f, -0.49448082f, 
    -0.40345931f, -0.28973013f, 0.04260943f, -0.35931152f, -0.59149057f, -0.89587790f, 0.58389330f, -0.79914260f, 
    0.47065571f, 0.14741991f, 0.35129133f, -0.03382656f, 0.07123145f, 0.59689903f, 0.29823628f, 0.96056110f, 
    -0.28205833f, 0.16288754f, -0.08237474f, -0.51363087f, 0.11170822f, -0.52683020f, 0.99571270f, 0.44410872f, 
    0.21350615f, -0.42425331f, -0.27729064f, -0.67100555f, -0.27500254f, -0.25795832f, 0.38010022f, -0.81739861f, 
    -0.40121204f, -0.76545620f, -0.45047867f, -0.52867395f, -0.88525522f, -0.35721126f, 0.40005109f, 0.28889292f, 
    0.79026657f, 0.66403508f, -0.32753333f, 0.78355706f, 0.33799547f, 0.33390158f, -0.58460349f, -0.03570864f, 
    -0.31802428f, -0.05353989f, 0.77976990f, -0.64577878f, -0.73785627f, -0.69859862f, 0.62795401f, -0.36339286f, 
    0.61779761f, -0.59572726f, 0.90019745f, -1.26500714f, -0.13593790f, -0.69483960f, 0.34681925f, -0.16482502f, 
    0.18621954f, 0.20283823f, -0.14677592f, -0.80383724f, -0.63342172f, -0.42681864f, -0.68884748f, -0.01948903f, 
    0.70798504f, -0.09610927f, -0.09547306f, 0.35476708f, -0.52302498f, 0.57731879f, 0.11376343f, -0.67281753f, 
    0.39474902f, -0.95373321f, -0.10985960f, 0.09444518f, 0.55775768f, -0.84771901f, 0.40605101f, 0.51216501f, 
    0.51515675f, 0.69756752f, 0.58374697f, -0.17363727f, -0.36926946f, -0.53566039f, 0.49708605f, 0.48623616f, 
    0.94502056f, -0.42028248f, -0.46170399f, 0.36441201f, 0.76061869f, 0.81062049f, -0.58383387f, -0.66261715f, 
    -0.79649597f, -0.66578990f, 0.34454420f, 0.71741575f, 0.35084721f, -0.04772653f, -0.44277230f, -0.31683373f, 
    -0.59244365f, -0.49725533f, -0.77560908f, 0.84628701f, 0.37063849f, -0.38474867f, -0.34109485f, -0.39680335f, 
    0.60786045f, 0.04400793f, -1.05420458f, -0.74436158f, 0.51036167f, -0.72139335f, 0.35622552f, -0.02534826f, 
    -0.00609641f, -0.14879896f, -0.34206194f, -0.80972075f, -0.05200932f, -0.68446815f, -0.76069176f, -0.43327057f, 
    0.41284472f, 0.46511886f, -0.16165997f, -0.04914698f, -0.81246895f, -0.64585721f, 0.58170545f, 0.88333827f, 
    -0.55693322f, -0.46878162f, -0.27617213f, 0.28504050f, -1.15382659f, 0.72850657f, -0.43019426f, -0.09854975f, 
    0.93676490f, 0.37165520f, 0.17072465f, -0.20433633f, 0.38417128f, 0.28408951f, 0.66571867f, 0.96326560f, 
    -0.59349364f, 0.68631405f, -0.29361522f, 0.32494456f, -0.37929782f, -0.22987908f, -0.70834923f, 0.19252898f, 
    0.79668468f, -0.50935036f, 0.88432866f, -0.34418684f, 0.07750701f, 0.74178463f, 0.21108200f, -0.15277663f, 
    -1.11599278f, -0.48288396f, 0.57730198f, 0.23979421f, 0.36825210f, -0.60301059f, 0.26810384f, -0.57711160f, 
    -0.54291773f, -0.38155276f, 0.30004206f, -0.42719087f, 0.48600724f, 0.78640038f, -0.48586705f, -0.18901038f, 
    -0.12133056f, -0.38652658f, 0.84868580f, -0.31230241f, -0.59597445f, 0.19886155f, 0.47906598f, 0.59873343f, 
    0.00718878f, -0.21525750f, 0.56650758f, -0.38231567f, -0.62512171f, -0.57337338f, 0.52442235f, 0.16163932f, 
    0.56493634f, 0.79923058f, -0.27046162f, -0.16050248f, -0.75768775f, 0.24649708f, -0.70692289f, -0.75788200f, 
    0.38237944f, 0.27848026f, -0.44026327f, -0.27869698f, -0.61623412f, 0.60789627f, 0.18535557f, -1.09865701f, 
    0.09532457f, 0.49440610f, -0.22998917f, -0.38413951f, 0.40260160f, -0.60847133f, 0.84507167f, 0.90494782f, 
    0.05362968f, -0.25287473f, 0.62289596f, -0.29473680f, 0.08053093f, 0.38315192f, -0.45280084f, -0.27961716f, 
    -0.94648272f, -0.80970079f, 0.12168479f, 0.74212736f, 0.68061393f, -0.54708451f, 0.44920093f, 0.47895917f, 
    0.98281050f, -1.09131730f, -0.62822062f, 0.16009150f, -0.30073830f, 0.58017546f, -0.27027655f, 0.55429560f, 
    0.63725346f, 0.67444932f, -0.30203855f, 0.23417950f, 0.00011416f, 0.54078692f, 0.40981379f, -0.28555313f, 
    -0.35082224f, 0.94770861f, -0.17805481f, -1.02455497f, -0.56771559f, 0.81968057f, 0.67141610f, 0.04431775f, 
    -0.41969648f, 0.38377136f, 0.83243424f, 0.62787777f, 0.55634552f, -0.22924288f, 0.51581514f, 0.31806549f, 
    -0.29770330f, -0.20216553f, -0.55139452f, 0.79278082f, -0.05430910f, -0.81063443f, 0.71307486f, -0.39670449f, 
    0.45735177f, -0.42444852f, -0.01022527f, -0.51182592f, -0.02588748f, 0.81660318f, -0.64218241f, 0.55131745f, 
    0.14696935f, 0.00905878f, -0.52347773f, -0.47791523f, -0.02882085f, 0.65045440f, -0.42420521f, 0.63672644f, 
    -0.20140542f, 0.03366203f, -0.40940130f, 0.20063187f, 0.64874750f, 0.02024801f, 0.71581131f, -1.23815143f, 
    0.76522630f, -0.64819825f, 0.64833111f, 0.42924398f, 0.08903816f, 0.17419061f, -0.00350690f, 0.50957692f, 
    0.83123708f, 0.34729519f, 0.49126008f, 0.53876263f, 0.65600270f, -0.15521754f, -0.00978446f, 0.33340248f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06773449f, 0.07349366f, 0.06172305f, 0.08374774f, 0.20227210f, 0.23130003f, -0.09306823f, 0.03568156f, 
    0.11297087f, 0.12053531f, 0.09092714f, 0.06138520f, 0.15968139f, -0.11149164f, 0.30572823f, 0.12624295f, 
    0.03283301f, -0.15962906f, 0.23541407f, -0.17135733f, -0.08556167f, 0.03023391f, 0.03740076f, 0.10375592f, 
    -0.00003223f, 0.34713134f, -0.06889070f, 0.18081965f, 0.13992874f, 0.19853179f, -0.14955793f, -0.08556705f, 
    0.11511466f, -0.12009321f, 0.19410042f, 0.23943332f, 0.22510706f, -0.07824684f, -0.10069749f, -0.12070971f, 
    -0.13259956f, 0.08361918f, 0.26997840f, 0.05345634f, 0.16498284f, 0.25608248f, -0.10368957f, 0.00101766f, 
    0.24239947f, 0.19955523f, -0.08561954f, 0.27278459f, 0.24996598f, 0.13646060f, -0.00835963f, -0.12547903f, 
    0.24319275f, 0.09063909f, 0.08368926f, -0.20794994f, 0.13509418f, 0.18399100f, 0.06362690f, 0.27771369f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.07366162f, -0.23569784f, 0.12776782f, 0.15572257f, 0.14019878f, -0.01401582f, -0.02443990f, 0.01583426f, 
    -0.03585708f, 0.02045071f, 0.05735542f, 0.02768510f, -0.01040598f, 0.06085879f, -0.04274995f, 0.02123747f, 
    -0.03954267f, -0.00238727f, -0.14325190f, -0.08718637f, -0.27641046f, 0.01586923f, 0.07623611f, 0.07841794f, 
    0.06869862f, 0.04420149f, -0.14067245f, 0.09746367f, -0.12254915f, -0.03065075f, -0.00364500f, -0.03916741f, 
    0.09103392f, 0.00890621f, 0.00565103f, -0.00093770f, -0.08436804f, -0.08233750f, 0.01047903f, 0.03056034f, 
    0.01958224f, -0.11010025f, 0.02195294f, -0.11505797f, -0.00130085f, 0.00617572f, 0.00972111f, -0.11527327f, 
    0.02615977f, -0.07886980f, -0.09062642f, -0.00045010f, 0.02651473f, 0.03863829f, 0.03278521f, 0.01359864f, 
    -0.04526486f, -0.02482639f, 0.05853549f, 0.00231259f, 0.21657622f, -0.01090439f, 0.05767658f, -0.01445057f, 
    -0.10432658f, -0.04546430f, -0.11565232f, -0.00710078f, 0.02326793f, -0.02222118f, -0.04431890f, 0.01652370f, 
    -0.04603657f, 0.02568599f, -0.00726079f, -0.04840558f, -0.06213622f, 0.04569903f, 0.10212693f, -0.01600847f, 
    0.07016818f, -0.03819140f, -0.00975133f, -0.12240577f, 0.12101653f, -0.05301415f, -0.02152672f, 0.02291753f, 
    0.02733999f, -0.03073948f, 0.03414263f, 0.04415549f, -0.06588439f, 0.02739239f, -0.01866191f, 0.03698784f, 
    0.01818429f, -0.04786503f, -0.11632272f, 0.10350171f, -0.04394193f, -0.13786981f, -0.00526513f, -0.05350309f, 
    0.18144569f, -0.12211058f, 0.00986574f, -0.04501165f, 0.04618796f, 0.00187703f, -0.02866361f, -0.00878040f, 
    0.02037546f, 0.04387280f, -0.04199450f, 0.07789152f, 0.03758110f, 0.04303257f, -0.03709698f, -0.01740292f, 
    -0.14943306f, -0.06448795f, -0.09248295f, 0.01822063f, 0.08552908f, 0.01258260f, 0.04280693f, -0.04850870f, 
    0.02739768f, 0.02569262f, -0.00154883f, 0.04746684f, -0.01842420f, -0.02864294f, 0.00478113f, -0.00156872f, 
    0.04750768f, 0.00265870f, 0.11769706f, 0.02073693f, 0.18006991f, -0.12010843f, 0.09228021f, -0.14956436f, 
    -0.03812329f, -0.19100645f, 0.00580170f, -0.06196445f, 0.00436796f, 0.08010882f, -0.02004073f, -0.05046178f, 
    0.00021707f, 0.01020747f, 0.00503008f, 0.08647160f, -0.00294884f, 0.04411840f, 0.03730169f, 0.04301945f, 
    0.18680525f, -0.20417358f, 0.05836747f, -0.04971246f, -0.04316169f, -0.07786965f, 0.05375518f, 0.03117705f, 
    -0.13130951f, 0.00912056f, -0.01381374f, 0.06667133f, -0.00705088f, 0.05323625f, 0.05524872f, 0.07262712f, 
    0.00648044f, 0.02432945f, -0.10477941f, -0.09640098f, 0.31890157f, 0.04625966f, 0.12611812f, -0.18088712f, 
    0.22358707f, -0.12867588f, -0.04091653f, 0.08058675f, -0.03422565f, -0.08236510f, -0.04217672f, 0.08233081f, 
    -0.11268432f, 0.04415727f, 0.08827577f, 0.01760461f, 0.04866978f, 0.07721618f, -0.02122305f, -0.01338929f, 
    -0.01537954f, -0.23409429f, -0.18016234f, 0.16535720f, -0.17890134f, 0.00895819f, -0.07061789f, 0.05039281f, 
    0.07657976f, 0.02154459f, -0.04806146f, 0.05527501f, -0.01329471f, -0.12877814f, -0.01954943f, -0.01270640f, 
    -0.01263214f, 0.03957932f, -0.06000169f, -0.01267703f, -0.11741594f, -0.37505975f, -0.06376104f, 0.01557407f, 
    -0.10651086f, -0.01582985f, -0.02643342f, 0.02734651f, 0.04973941f, -0.01171949f, -0.01894123f, 0.03501165f, 
    0.01422348f, 0.02275336f, 0.08560244f, 0.04837753f, 0.07393177f, 0.04024655f, 0.08156151f, -0.02570407f, 
    -0.29690820f, -0.21362597f, 0.27085319f, 0.02059722f, -0.22261804f, -0.05084923f, -0.08341520f, 0.01629889f, 
    0.01804730f, -0.09544855f, -0.07109462f, 0.04909534f, 0.11049388f, -0.06600386f, -0.06957480f, -0.00671543f, 
    0.06609183f, 0.03599159f, -0.03456163f, 0.05549227f, -0.32536238f, 0.19822489f, 0.16849044f, 0.04340784f, 
    0.07648034f, 0.08172508f, -0.03610014f, 0.01574402f, -0.05135220f, 0.00735752f, -0.01279238f, 0.05351547f, 
    -0.09308740f, -0.00645495f, -0.06643414f, -0.03650120f, -0.04266921f, -0.00766106f, 0.03436213f, -0.11736602f, 
    0.03128275f, 0.08383789f, 0.00768927f, -0.03280276f, -0.16987658f, 0.02468105f, -0.04341128f, 0.01939941f, 
    -0.03089500f, -0.06774415f, -0.04846159f, 0.00334690f, -0.13373736f, -0.04644537f, 0.03411323f, -0.00663428f, 
    0.01371310f, 0.02015248f, -0.05276590f, -0.02721155f, -0.17682503f, 0.14496937f, 0.13916636f, -0.17638634f, 
    -0.32027999f, 0.10600031f, 0.04606517f, -0.00659568f, 0.05218660f, -0.02320081f, 0.01708168f, -0.01114572f, 
    0.01287471f, 0.01131298f, -0.06815379f, 0.02121140f, 0.05229808f, -0.02684159f, 0.03372578f, 0.02495736f, 
    0.33752263f, 0.04471799f, 0.03639780f, -0.07679854f, 0.10139793f, 0.09368969f, -0.02953265f, -0.01020801f, 
    -0.03040971f, 0.00377576f, 0.02508956f, -0.03565562f, -0.06349212f, -0.04495074f, 0.11616681f, -0.12694401f, 
    -0.01142056f, 0.11519709f, 0.03952197f, -0.04945412f, -0.15089567f, 0.14370136f, -0.13692342f, -0.07983903f, 
    -0.24774224f, 0.00764795f, 0.05031157f, -0.05933432f, -0.04768778f, -0.01327045f, 0.07071650f, -0.03182574f, 
    0.11074848f, -0.01796347f, -0.02898111f, 0.00984227f, 0.00915411f, -0.03107716f, -0.00726884f, -0.01807045f, 
    -0.23523860f, 0.06993107f, 0.07551550f, -0.19602443f, 0.22552972f, -0.06360600f, -0.03883432f, -0.05795718f, 
    0.00110488f, -0.02211183f, -0.03581421f, -0.00773829f, 0.01843372f, -0.00812243f, 0.02408141f, -0.06166238f, 
    0.00789301f, -0.06169685f, -0.03923798f, -0.07533351f, 0.16825050f, 0.10617455f, 0.16748202f, -0.00090694f, 
    0.19998233f, -0.11823857f, -0.20810562f, 0.05184214f, -0.07409225f, 0.00645087f, 0.02973912f, 0.06480767f, 
    -0.09013581f, 0.12569277f, -0.05202382f, -0.00822187f, -0.05973480f, 0.09604081f, -0.08601758f, -0.09195579f, 
    0.18818884f, 0.05865961f, 0.16929655f, -0.10702381f, -0.07804974f, -0.00267482f, 0.02288149f, 0.11836068f, 
    0.01984456f, -0.07370990f, -0.12579912f, -0.03810569f, 0.04157930f, -0.10539231f, 0.01322901f, -0.05149490f, 
    0.11229327f, -0.03902974f, 0.08356697f, -0.08897448f, 0.02450488f, -0.47578576f, 0.26612833f, 0.09151386f, 
    0.06115530f, 0.03625557f, 0.04551365f, 0.01409611f, 0.01685939f, 0.03119077f, -0.10778857f, 0.01446431f, 
    0.01678014f, 0.07119019f, -0.02878126f, -0.01392546f, 0.06353394f, 0.00344837f, 0.13006024f, -0.09252785f, 
    0.01597477f, -0.00068100f, 0.03019211f, -0.19299090f, 0.08426470f, 0.00392827f, -0.05417227f, -0.05477804f, 
    -0.05067225f, -0.04701647f, 0.02135074f, -0.03881846f, 0.03448810f, 0.00496071f, 0.01934209f, -0.02333595f, 
    -0.00292973f, 0.01164044f, -0.07379174f, 0.00832929f, -0.02266769f, 0.20289890f, 0.11477486f, -0.16539419f, 
    -0.21763922f, 0.06719567f, 0.04956993f, -0.02638997f, 0.04428665f, -0.05516030f, 0.05423380f, -0.00734489f, 
    -0.01751146f, -0.00803413f, 0.00197331f, 0.00137649f, 0.03140687f, 0.04304962f, -0.00036027f, 0.02601465f, 
    0.14645767f, 0.13863398f, -0.05809760f, -0.16530415f, 0.05438685f, -0.10133906f, -0.11804692f, -0.11061440f, 
    0.08035970f, 0.03837103f, -0.00492746f, 0.03888562f, 0.00815256f, -0.02990367f, 0.01647124f, -0.03024389f, 
    0.03278072f, -0.01264001f, 0.07786604f, -0.02455699f, 0.10063937f, 0.02749845f, 0.05383620f, -0.18081997f, 
    0.04375036f, -0.08513388f, -0.09673465f, -0.01623729f, -0.01736094f, -0.00316442f, -0.01871788f, -0.02675890f, 
    -0.08582575f, 0.02688476f, -0.04594843f, -0.00017380f, 0.02211637f, 0.03566306f, -0.00040515f, 0.00391907f, 
    -0.12254551f, 0.16550788f, 0.05058089f, 0.21350572f, 0.21907277f, -0.04864225f, -0.08934628f, -0.02019569f, 
    -0.00719165f, -0.00922908f, -0.00345111f, -0.07935629f, 0.02750158f, -0.03935090f, -0.01660631f, 0.14269070f, 
    0.01771709f, -0.15223455f, 0.04838525f, 0.08552297f, 0.04124105f, -0.03908076f, 0.03227480f, 0.01837212f, 
    -0.10559414f, -0.02104234f, -0.15835516f, 0.01606955f, -0.00171026f, 0.00554788f, -0.03229452f, 0.06234103f, 
    -0.07171254f, 0.06739108f, -0.09090916f, 0.03903620f, -0.00759432f, 0.01071207f, -0.03647938f, -0.01570484f, 
    -0.15107282f, -0.09551996f, -0.10264602f, 0.12510738f, -0.17753994f, 0.01344796f, -0.09892150f, 0.01855119f, 
    0.10095377f, -0.07790957f, 0.01518222f, -0.04291302f, -0.09886362f, -0.01444892f, 0.04066770f, -0.03544901f, 
    0.00829642f, -0.01412387f, 0.02614338f, 0.04360265f, 0.17522356f, 0.00575458f, -0.06559066f, 0.04479293f, 
    0.04275545f, -0.05032950f, -0.10585017f, -0.00213420f, 0.00603583f, -0.02833940f, 0.00703674f, 0.02660894f, 
    0.03794139f, -0.00530072f, -0.05324298f, 0.09992212f, -0.04662522f, -0.00500372f, 0.00240692f, -0.06290674f, 
    0.13102038f, 0.11684371f, 0.06750618f, 0.00255890f, 0.05746178f, -0.06652662f, -0.08191430f, -0.03810627f, 
    0.08984523f, 0.05808838f, 0.01728703f, -0.03630625f, 0.04958881f, -0.03760403f, -0.04314317f, 0.00387390f, 
    0.00652611f, -0.00564671f, 0.05670245f, -0.00620629f, -0.16170464f, -0.42162862f, -0.04850350f, 0.06775130f, 
    -0.08557161f, 0.03743361f, -0.05201528f, 0.05869347f, 0.03483108f, 0.02511327f, -0.03956836f, 0.02170363f, 
    -0.12370011f, -0.04809415f, -0.02259684f, 0.02308162f, 0.01795820f, 0.05149027f, 0.04513171f, -0.01465595f, 
    0.15214939f, 0.04449640f, -0.02226332f, -0.07078250f, 0.18771438f, -0.04533343f, -0.03468730f, -0.01330671f, 
    0.04487341f, -0.04271707f, 0.03472916f, -0.01231707f, -0.11515339f, -0.01359909f, -0.01770228f, 0.02837995f, 
    0.07795421f, -0.02247036f, -0.04838397f, 0.05743182f, 0.06071504f, 0.02285057f, 0.11176070f, -0.17155543f, 
    0.23128261f, -0.05667642f, -0.03997758f, -0.10886228f, -0.07173410f, 0.05336231f, -0.10919664f, -0.10028241f, 
    0.06709845f, -0.00457426f, 0.07623681f, -0.08591650f, 0.03114366f, -0.08649185f, 0.01877953f, -0.10585213f, 
    0.05873485f, -0.34999040f, 0.14755757f, 0.15807490f, -0.23128769f, -0.08520473f, -0.09092057f, -0.04211676f, 
    -0.04919045f, 0.02632297f, 0.03038949f, 0.06717403f, -0.04156791f, -0.02765194f, 0.03053021f, -0.02169864f, 
    -0.06776928f, 0.01552567f, 0.05544295f, 0.04748508f, -0.18091521f, 0.14897430f, -0.17665945f, 0.02890828f, 
    -0.12938713f, 0.05518682f, -0.02837821f, -0.08201370f, 0.09732016f, -0.03622422f, 0.07879865f, 0.02380756f, 
    0.01319426f, 0.02431188f, 0.02171762f, 0.04207599f, -0.07358404f, 0.01219469f, 0.06620038f, 0.01466709f, 
    -0.09066607f, -0.15304618f, 0.07771745f, -0.04637337f, 0.02360031f, -0.04092028f, -0.02933033f, -0.00807549f, 
    -0.00653522f, 0.05235326f, 0.02780405f, 0.03438829f, -0.08038936f, -0.01465567f, -0.01253751f, -0.08144107f, 
    -0.06329788f, 0.10742746f, 0.00369816f, -0.05986853f, 0.11073599f, 0.13043484f, 0.24186793f, 0.09509942f, 
    0.09856337f, 0.03304736f, -0.01399926f, 0.06851679f, 0.03364119f, 0.02614681f, 0.02353898f, -0.05274507f, 
    0.02088846f, -0.07823913f, -0.00705332f, 0.13179766f, 0.05131220f, -0.10772702f, 0.08188147f, 0.04721043f, 
    -0.08938970f, 0.12597871f, -0.16485383f, 0.06701991f, 0.09509965f, -0.01253970f, -0.01214774f, -0.04298501f, 
    -0.01844134f, -0.03971871f, 0.02892161f, -0.08019041f, 0.09380465f, 0.06943192f, -0.00971273f, -0.02344608f, 
    -0.02177268f, -0.04573996f, -0.00054889f, 0.01627660f, 0.08336566f, 0.14640404f, 0.05579620f, -0.15409987f, 
    -0.36113766f, 0.06984650f, 0.05544895f, -0.03247504f, 0.05807891f, -0.04981227f, 0.01691470f, 0.01915512f, 
    0.01686738f, 0.02342841f, 0.02177386f, 0.04818448f, 0.05834286f, -0.00088801f, 0.08218795f, -0.01880608f, 
    0.33911288f, -0.07587294f, 0.00260389f, -0.07313251f, -0.15360497f, -0.02597655f, -0.00468872f, -0.04879312f, 
    -0.03703032f, -0.07408115f, 0.05894928f, 0.02618531f, -0.02675309f, 0.07097042f, 0.01541662f, 0.05179545f, 
    -0.02343313f, 0.01889671f, -0.09578222f, -0.05038859f, 0.27239105f, -0.27604777f, -0.04892323f, -0.09028383f, 
    -0.34962502f, 0.04418113f, 0.06786753f, 0.10102592f, 0.01110298f, -0.05395107f, -0.01291649f, -0.09083608f, 
    -0.04349919f, 0.04097013f, 0.07033716f, 0.09084796f, 0.00392739f, 0.14221534f, 0.01074017f, 0.01294870f, 
    -0.15761033f, -0.52932596f, -0.00854370f, 0.13678472f, -0.14016394f, -0.07962245f, -0.06340153f, 0.00728547f, 
    -0.03242575f, -0.01036722f, -0.01978701f, 0.02461427f, -0.06401271f, -0.10385644f, -0.04453683f, 0.06385449f, 
    0.07765463f, -0.04137235f, 0.06536364f, -0.00510399f, -0.02158776f, 0.07431025f, 0.08183026f, -0.02939284f, 
    -0.06309871f, -0.05112397f, -0.05458689f, 0.07162959f, -0.13478459f, -0.04633512f, 0.05931227f, 0.04927457f, 
    -0.03007508f, -0.02463852f, 0.02968081f, -0.08639257f, 0.02182170f, 0.04208678f, -0.09003058f, 0.03565937f, 
    0.35803062f, 0.13515066f, 0.11940116f, -0.23570676f, 0.01047411f, 0.08642546f, -0.03151995f, -0.01446246f, 
    0.07022087f, -0.06022079f, 0.03747739f, -0.02460844f, -0.05839740f, 0.02608689f, 0.08208437f, 0.03832120f, 
    -0.00131391f, -0.02601335f, 0.03157968f, -0.03883860f, 0.03255215f, 0.06621065f, 0.01816729f, -0.06270733f, 
    0.05335261f, -0.13145150f, -0.05974416f, -0.00899809f, 0.00040951f, 0.04991505f, -0.01116819f, -0.02691315f, 
    -0.00573981f, -0.09784276f, 0.00323573f, -0.00297956f, -0.02834222f, 0.00775245f, -0.04714929f, -0.02993454f, 
    -0.20928420f, -0.16901551f, 0.09593137f, 0.13135242f, -0.06522226f, 0.06490778f, 0.03948332f, 0.00627704f, 
    0.07103603f, -0.01435020f, 0.02492884f, 0.12106923f, -0.01960188f, 0.03138072f, 0.05906329f, 0.09513327f, 
    0.04669477f, -0.01824632f, -0.05158987f, -0.16505207f, 0.08236708f, 0.02849601f, -0.09081889f, -0.12386641f, 
    -0.36558929f, 0.04830185f, 0.02620628f, 0.02257667f, 0.00739447f, -0.01927346f, 0.07579114f, -0.05828286f, 
    0.16577612f, 0.01441342f, -0.04136248f, -0.01832696f, 0.04980049f, -0.01188312f, -0.06798618f, 0.09116723f, 
    -0.15544720f, 0.09246232f, 0.00106489f, 0.08482442f, -0.00826494f, -0.00582083f, 0.03277951f, -0.05660771f, 
    0.08581751f, -0.06802831f, 0.06915172f, -0.01539661f, -0.01102531f, 0.03003076f, -0.02819075f, 0.02549217f, 
    -0.02096439f, -0.04174640f, 0.08971572f, 0.09342246f, -0.05197907f, 0.00843736f, 0.10670055f, -0.02766403f, 
    0.12647137f, -0.04851808f, -0.06082206f, 0.05641325f, -0.05274048f, -0.01475443f, -0.09320290f, -0.00021273f, 
    0.00829932f, -0.02101073f, 0.04602239f, -0.08324134f, 0.06783984f, 0.00133416f, -0.07812328f, -0.19208409f, 
    -0.22190139f, 0.04415637f, -0.02170550f, 0.07908517f, 0.03559164f, -0.07194730f, -0.03118153f, -0.07460885f, 
    -0.04729554f, 0.05791651f, -0.00049560f, 0.00552147f, 0.09110468f, 0.00092026f, 0.08148390f, 0.00315250f, 
    -0.03809963f, -0.00707547f, -0.02964904f, -0.00729475f, 0.02556323f, -0.22413789f, -0.07919274f, 0.07551814f, 
    -0.15235363f, -0.06333315f, -0.05161147f, -0.06969499f, -0.00502154f, 0.05074574f, -0.00178461f, -0.05404986f, 
    0.02466795f, -0.02469866f, -0.00215522f, -0.00927382f, -0.03627444f, -0.01285670f, 0.06689464f, -0.01528513f, 
    -0.09633069f, 0.01103440f, -0.08261833f, 0.02171360f, 0.12964557f, 0.00255155f, -0.06045425f, -0.09084398f, 
    -0.00796744f, -0.09172581f, 0.07660372f, 0.02923790f, 0.12067775f, -0.00414032f, 0.08415841f, -0.03301641f, 
    0.00810144f, 0.01408762f, 0.01582312f, -0.00234438f, -0.30270359f, 0.05424054f, 0.04331822f, 0.21749738f, 
    0.22030020f, 0.02644202f, -0.02763069f, 0.03735943f, -0.01647631f, -0.02970905f, 0.05151750f, -0.04016104f, 
    0.01865711f, -0.00852099f, 0.00998676f, -0.05389263f, 0.03223690f, -0.05178476f, 0.01061638f, 0.05408895f, 
    -0.35352629f, 0.04823197f, -0.07780878f, 0.01453560f, -0.12244651f, -0.06729934f, 0.00318150f, -0.01164521f, 
    -0.00498740f, -0.03840399f, -0.00079465f, -0.09974845f, 0.02392404f, 0.06194843f, 0.06433327f, -0.07700619f, 
    -0.05781937f, 0.01622157f, 0.04937682f, -0.13493399f, -0.25039065f, 0.02797367f, 0.14584349f, -0.02003253f, 
    0.12323413f, -0.10694654f, 0.07057744f, 0.07928979f, 0.03838717f, 0.06091036f, 0.04470327f, -0.10654988f, 
    0.07654766f, 0.01103449f, 0.04888587f, -0.00107373f, -0.17545421f, 0.05501642f, -0.13541730f, -0.12037891f, 
    0.05838343f, 0.00539001f, 0.07318597f, -0.16337039f, 0.13341844f, -0.14764811f, 0.00463090f, 0.02635057f, 
    0.02288793f, -0.02404767f, -0.10488955f, 0.02004362f, 0.01162483f, -0.01311817f, 0.03651719f, -0.04014780f, 
    0.01182753f, -0.00391154f, -0.06810065f, -0.00108437f, -0.33585837f, 0.23942325f, -0.01376871f, -0.08948064f, 
    0.14863405f, -0.01530503f, 0.02406445f, -0.01512598f, -0.03038931f, 0.01108459f, -0.02189904f, -0.01491465f, 
    0.06529743f, 0.01742232f, 0.01462767f, 0.05992489f, -0.01748758f, -0.03284938f, -0.06360485f, -0.05061796f, 
    0.17982918f, 0.09243870f, -0.01903920f, -0.04711487f, 0.17044255f, -0.17434022f, -0.11300340f, -0.08186690f, 
    0.03905366f, 0.00614447f, 0.00389166f, 0.05412753f, 0.05090697f, -0.10507703f, -0.02238671f, 0.07048707f, 
    0.02075557f, -0.08672065f, 0.00471557f, 0.00034595f, 0.37937492f, -0.13440435f, 0.10453841f, 0.03050583f, 
    0.05439663f, -0.02071353f, 0.07258946f, -0.03494810f, 0.03825225f, -0.00091404f, -0.08689500f, -0.14711457f, 
    0.05568416f, 0.02396014f, -0.01049284f, 0.07821362f, 0.07619490f, 0.07092579f, -0.05207905f, 0.04025239f, 
    0.19206433f, 0.01143247f, 0.01605630f, -0.04378897f, 0.15929283f, -0.03595741f, -0.08711830f, 0.03844950f, 
    -0.05105928f, -0.06771743f, 0.06905481f, 0.00358151f, -0.02933994f, 0.06671064f, 0.01392598f, 0.02036041f, 
    0.00869666f, -0.00019560f, -0.11234836f, 0.00866134f, 0.13799825f, -0.07767861f, -0.00902570f, 0.04395958f, 
    -0.19399615f, -0.10620931f, -0.08268686f, -0.01438067f, 0.03849139f, -0.10376642f, -0.01454036f, 0.10094393f, 
    -0.01041465f, 0.00160691f, -0.03974622f, -0.00057580f, -0.11180073f, 0.02204050f, 0.01708304f, -0.06421980f, 
    0.10200830f, -0.03672163f, -0.07169443f, 0.03236479f, -0.36021897f, -0.03918929f, -0.03540638f, 0.04685034f, 
    0.00925552f, -0.01537342f, 0.07220401f, 0.03527686f, -0.06112718f, 0.00816436f, 0.06967548f, -0.10245334f, 
    -0.05016319f, 0.00757741f, -0.01269755f, 0.09113925f, 0.01137539f, -0.04004163f, -0.04485781f, -0.08208592f, 
    0.16064784f, -0.01622998f, -0.06547178f, 0.05030087f, 0.00248501f, -0.03532380f, 0.03101293f, -0.01857994f, 
    -0.02120772f, 0.04724137f, 0.03816234f, 0.01572159f, 0.05377205f, -0.02087509f, -0.10463417f, 0.05870039f, 
    -0.21114263f, -0.18320496f, -0.12678432f, -0.42019245f, 0.10928815f, -0.02290490f, -0.05724208f, 0.08700971f, 
    0.04029169f, -0.09721989f, -0.05781398f, -0.14138357f, 0.00278188f, -0.09615236f, -0.08874427f, -0.13888693f, 
    0.02603485f, -0.15480810f, 0.06647208f, -0.09291991f, 0.02416288f, 0.13867097f, 0.04720582f, 0.00502289f, 
    0.07370801f, -0.03373465f, 0.01696018f, -0.04102206f, -0.01540908f, 0.11443283f, 0.00667963f, 0.06052839f, 
    -0.05084556f, -0.05425945f, -0.02620295f, -0.03452997f, 0.02089074f, 0.04384974f, -0.03863497f, 0.02913423f, 
    0.06298303f, -0.08136504f, 0.09162208f, 0.04196258f, 0.03559977f, 0.01630125f, -0.06115628f, 0.05231914f, 
    -0.00438739f, -0.02981228f, 0.04230776f, -0.00400754f, -0.03430210f, 0.03806506f, -0.00905016f, -0.00975776f, 
    -0.08982109f, 0.01650670f, -0.03722114f, -0.07228326f, 0.13430700f, -0.10369147f, 0.01384179f, 0.03115737f, 
    -0.00788649f, 0.03403939f, -0.05046495f, -0.01331628f, -0.00716104f, -0.04813261f, 0.13252594f, 0.03370244f, 
    0.08107182f, -0.03424378f, 0.05172568f, -0.02699624f, 0.00397598f, -0.15753148f, -0.03756973f, -0.00652489f, 
    0.06124511f, -0.06649366f, 0.06536273f, 0.00587857f, 0.14011265f, -0.04867346f, -0.09769638f, -0.01998194f, 
    0.04832110f, -0.06165003f, 0.02498623f, -0.01064129f, 0.03334292f, 0.04545057f, -0.04264434f, -0.02744285f, 
    0.04852599f, 0.07893649f, 0.07367191f, -0.10691738f, 0.08806545f, -0.27632228f, 0.10586667f, -0.04604199f, 
    -0.01021022f, 0.03833698f, -0.13058309f, 0.00834008f, -0.01797188f, -0.03015184f, -0.03217437f, 0.00240439f, 
    -0.07409331f, -0.00519846f, 0.03307997f, -0.01884407f, -0.00236306f, -0.09687489f, 0.07729424f, -0.03998791f, 
    -0.30605933f, -0.15422228f, -0.01665199f, -0.10739970f, -0.30762047f, -0.00932970f, 0.03425539f, 0.03776215f, 
    0.01976680f, 0.04174740f, -0.07639279f, 0.01622952f, 0.07862671f, 0.06191909f, -0.00303692f, -0.07268826f, 
    -0.01827452f, -0.10522198f, -0.12598495f, 0.01978977f, 0.01489741f, 0.18725948f, 0.16265604f, 0.11339857f, 
    0.11740387f, -0.06236935f, -0.08351386f, 0.08447142f, 0.02675063f, 0.00665389f, -0.06328642f, -0.01142331f, 
    0.10033202f, 0.09152119f, -0.06747559f, -0.03557856f, -0.01829636f, -0.04050495f, -0.02772570f, 0.04130270f, 
    -0.05705114f, 0.08486512f, 0.08546946f, -0.01189160f, 0.19115475f, 0.03728320f, -0.05522877f, 0.04600721f, 
    -0.03386503f, -0.00661832f, 0.04490756f, 0.03015147f, -0.03778059f, -0.01908537f, 0.01237887f, -0.06989353f, 
    0.03564016f, -0.01527053f, 0.03939335f, 0.06456155f, -0.18522772f, -0.13606156f, -0.02062757f, -0.06951825f, 
    0.11367212f, -0.07730053f, -0.08438917f, -0.05996129f, -0.06878642f, 0.01702951f, 0.09214242f, 0.03612467f, 
    -0.01935373f, 0.04172150f, 0.07383668f, -0.03848734f, 0.02857376f, -0.03820534f, -0.02915152f, 0.01204122f, 
    -0.35688958f, 0.07712943f, 0.02238024f, -0.09052674f, -0.34777385f, -0.03840687f, 0.04101976f, -0.02140838f, 
    0.00353907f, 0.01793926f, -0.09688993f, -0.00630931f, 0.02683463f, 0.01224562f, 0.06515547f, -0.03413672f, 
    -0.03991431f, -0.10031120f, -0.09835799f, 0.09012984f, 0.02571077f, 0.10618743f, -0.21179499f, -0.00222259f, 
    -0.10039947f, 0.13901949f, -0.00879505f, -0.05134201f, 0.03316507f, 0.04872125f, 0.00022449f, -0.08205438f, 
    -0.03104489f, 0.04411723f, -0.08770552f, 0.00972816f, 0.11583453f, -0.12747368f, -0.01957619f, -0.03248508f, 
    -0.39535466f, 0.07382287f, 0.01839592f, 0.02619091f, -0.06366395f, -0.01666193f, 0.04043968f, 0.00578444f, 
    0.05978924f, 0.01680129f, -0.06989691f, -0.01697274f, -0.07155359f, -0.05942949f, 0.06890909f, 0.04857464f, 
    -0.01084329f, -0.04690058f, 0.11248820f, -0.02242110f, -0.12433191f, -0.18794201f, -0.37951228f, -0.06922901f, 
    0.03332799f, 0.05950746f, 0.09807888f, 0.01661937f, -0.11676145f, 0.09484926f, 0.02302970f, 0.04288194f, 
    0.03067885f, -0.08718590f, -0.00300642f, -0.08590636f, -0.06158327f, 0.00558512f, -0.18518043f, 0.06924801f, 
    0.19275968f, -0.12184941f, 0.03394433f, 0.01985462f, -0.03484798f, -0.02730505f, 0.03309445f, 0.03436849f, 
    0.00191759f, 0.09858258f, 0.10354599f, 0.03652367f, 0.06872172f, -0.03235113f, -0.00319412f, 0.04119410f, 
    0.05213613f, 0.03308330f, 0.02800936f, 0.02156124f, 0.18144189f, 0.01447008f, -0.14364211f, 0.06972521f, 
    -0.26347670f, -0.07476079f, 0.09526318f, -0.00889326f, -0.01416876f, 0.07477666f, 0.02277915f, 0.03049808f, 
    -0.05146560f, 0.09251849f, 0.00609333f, 0.05667463f, 0.14415121f, 0.02331398f, -0.03187855f, -0.03129724f, 
    -0.29132459f, 0.14253642f, -0.11789884f, -0.33384866f, 0.08644064f, 0.02335481f, 0.07364176f, -0.04316515f, 
    0.03477369f, 0.04913475f, 0.01458758f, -0.06925365f, 0.06490465f, 0.03030747f, 0.02154206f, 0.01346043f, 
    -0.03870277f, 0.03843693f, -0.01595107f, -0.02552641f, -0.03154602f, -0.23725249f, 0.00629615f, -0.03318624f, 
    -0.11089935f, -0.03990019f, -0.03821431f, -0.09352384f, 0.01843627f, 0.03276312f, 0.04785253f, 0.02079778f, 
    -0.00283559f, 0.05791904f, -0.05417556f, -0.01847766f, 0.00240157f, -0.07098486f, 0.02246724f, -0.03904295f, 
    0.29527467f, -0.07887021f, 0.07383899f, -0.13514468f, -0.07857362f, -0.05444121f, -0.01052238f, -0.02123306f, 
    0.01718620f, -0.03121461f, -0.01178988f, 0.01034852f, -0.07240366f, 0.10694721f, 0.06272862f, -0.02682186f, 
    0.00930668f, 0.05458871f, 0.00637965f, 0.01428216f, -0.21736695f, -0.14759822f, -0.06134570f, -0.05756434f, 
    0.11192903f, -0.00323878f, 0.01412374f, 0.04326613f, -0.09270883f, -0.01914782f, -0.06444535f, -0.02825070f, 
    0.12880498f, -0.11059456f, -0.04384359f, 0.08537241f, -0.11781459f, -0.04087705f, 0.03605315f, -0.02973627f, 
    -0.18330301f, 0.07583234f, -0.11737955f, 0.00580338f, 0.03180555f, -0.01678062f, -0.00191812f, -0.16038221f, 
    0.03764341f, -0.02156174f, 0.14407897f, -0.01735885f, -0.09786289f, -0.01394737f, 0.06682851f, -0.05158436f, 
    0.06424999f, 0.00642463f, 0.01360483f, 0.07804937f, 0.09961844f, -0.13673149f, 0.09548999f, -0.28782830f, 
    -0.00583828f, 0.08058280f, -0.01901746f, 0.01481568f, -0.02617307f, -0.06727571f, -0.00272793f, -0.01220995f, 
    0.05015028f, -0.06135340f, 0.03089484f, -0.05560470f, -0.06810705f, -0.15214740f, -0.11369679f, -0.00336833f, 
    -0.01513748f, 0.04699918f, 0.00149508f, -0.08471546f, 0.06167856f, 0.04513477f, -0.10814656f, 0.02272722f, 
    0.06559893f, 0.01431436f, -0.13367170f, 0.00350075f, -0.01585208f, -0.09039092f, 0.01324944f, -0.02653177f, 
    0.00452384f, 0.10662245f, 0.02895529f, -0.09556751f, 0.05789058f, 0.03720376f, -0.11611924f, 0.00160721f, 
    -0.12177198f, 0.01172837f, 0.01732016f, 0.00712044f, 0.00489972f, 0.02864354f, -0.01355895f, 0.04519751f, 
    -0.01969240f, 0.04219119f, -0.03409446f, 0.07845510f, 0.03480239f, -0.02124718f, -0.03238273f, 0.04835594f, 
    0.28685835f, -0.00290078f, 0.03037821f, 0.15257920f, -0.00808958f, 0.04153595f, -0.11528057f, 0.01141813f, 
    0.00572304f, -0.01893541f, -0.05497324f, -0.01395225f, -0.04784293f, 0.11797516f, -0.02337295f, 0.11677869f, 
    -0.05860655f, -0.02324977f, -0.05402420f, -0.01277385f, 0.07773586f, 0.08919810f, 0.11238185f, 0.03543261f, 
    0.15488322f, -0.07939820f, -0.00044835f, 0.00152217f, -0.01268910f, 0.03932530f, 0.03393296f, -0.02276317f, 
    0.10122344f, 0.02240370f, 0.06405883f, -0.00303594f, 0.03550768f, -0.05399467f, -0.04379282f, 0.00324243f, 
    0.12247517f, 0.09912700f, -0.09378660f, -0.00909553f, 0.07380889f, 0.02660047f, 0.02568330f, 0.02981437f, 
    -0.05406771f, 0.08602352f, -0.00946647f, -0.03559855f, -0.00680669f, -0.05074021f, 0.00815984f, 0.00490565f, 
    0.03301474f, 0.07902908f, 0.04655949f, -0.11112092f, 0.08865459f, 0.08084135f, 0.11768500f, -0.07901693f, 
    0.19007656f, -0.15216947f, 0.01268657f, 0.02314419f, -0.00621199f, 0.01727662f, 0.00188518f, -0.07565981f, 
    0.14294697f, -0.07843034f, 0.01731054f, -0.03878906f, -0.03840783f, -0.06714817f, 0.02548106f, 0.16215701f, 
    -0.08347706f, -0.00236445f, -0.04194102f, 0.10018136f, -0.11594543f, -0.01024126f, 0.01371610f, -0.02754817f, 
    0.03045491f, -0.00836293f, -0.00978499f, -0.04118881f, -0.06514334f, 0.03033651f, -0.01120680f, -0.00344695f, 
    -0.02259592f, -0.04230160f, -0.08269738f, -0.07578331f, 0.11778837f, 0.19670776f, 0.04111673f, 0.06378423f, 
    0.13015984f, -0.01211923f, -0.06826335f, 0.00404161f, -0.02301922f, 0.09748810f, -0.00131696f, -0.08070653f, 
    -0.02958443f, -0.03007377f, -0.07785092f, 0.03122756f, 0.01018326f, -0.00814917f, -0.02865028f, 0.08572980f, 
    0.27057427f, -0.23105083f, 0.01916394f, 0.04786249f, 0.04561521f, -0.05298295f, -0.04967000f, 0.07771230f, 
    0.01668417f, -0.02619859f, 0.01096219f, -0.04203866f, -0.04336339f, -0.03756740f, 0.10348688f, -0.04975651f, 
    0.00251336f, -0.07181174f, -0.05127319f, -0.04264062f, 0.05390013f, 0.04944512f, -0.02310439f, -0.07234651f, 
    -0.00720966f, 0.01249835f, -0.07949741f, 0.09476615f, 0.01366861f, 0.04201896f, -0.03287046f, -0.10145550f, 
    0.08593537f, 0.05098290f, -0.03279648f, -0.04533357f, 0.12081285f, -0.09816208f, -0.09960642f, -0.04790167f, 
    0.15337206f, -0.08048493f, 0.13199411f, 0.04090612f, 0.11127532f, -0.00624892f, -0.00345465f, -0.08986607f, 
    0.02128229f, 0.00559620f, -0.01819577f, 0.01542651f, 0.01962286f, 0.02659728f, -0.06891663f, -0.01139118f, 
    -0.03057302f, 0.02105386f, 0.09130331f, -0.00811183f, -0.19439419f, -0.16329561f, -0.03171881f, -0.32081297f, 
    0.00918273f, 0.12064765f, -0.06615918f, -0.01673389f, 0.05894373f, -0.08113611f, 0.03865456f, 0.03791066f, 
    -0.05341103f, 0.07391415f, -0.14759806f, -0.05630223f, -0.01282475f, 0.03734906f, 0.02753144f, -0.08864491f, 
    0.20000635f, -0.32700834f, -0.04693550f, 0.01592338f, 0.07045023f, 0.00228337f, 0.05023893f, 0.00378585f, 
    0.02332191f, -0.03036534f, 0.03894038f, 0.04052953f, 0.03427581f, -0.02501184f, -0.01825312f, 0.07113158f, 
    -0.02322318f, -0.00187341f, -0.07505648f, -0.03611811f, 0.10952913f, 0.05506994f, 0.00973746f, -0.06413113f, 
    -0.17704795f, -0.01049958f, -0.03342545f, -0.04417719f, 0.01924675f, 0.03786827f, -0.02230802f, -0.07672141f, 
    -0.01888460f, -0.00484774f, -0.00868028f, 0.00712102f, -0.02781873f, -0.02260698f, 0.02474889f, -0.01803809f, 
    -0.06902388f, -0.04597829f, -0.09478466f, -0.11064933f, 0.01666467f, -0.02316307f, 0.03245974f, 0.00257497f, 
    -0.10444739f, 0.11559670f, 0.02000816f, 0.00956095f, 0.11186697f, -0.00331550f, 0.04960949f, -0.01387161f, 
    0.03154370f, -0.00164030f, -0.10191587f, 0.02671327f, -0.26180631f, 0.08155207f, -0.06725255f, -0.00571651f, 
    0.09666872f, -0.00994920f, 0.04984695f, -0.07684320f, -0.02483438f, 0.02187533f, 0.02106650f, 0.14235507f, 
    -0.02641916f, -0.04424572f, 0.01022797f, 0.01760543f, -0.05737806f, 0.12518871f, -0.00982276f, 0.00114192f, 
    -0.24645105f, 0.12743834f, 0.03848351f, 0.04157129f, -0.02352864f, -0.11087848f, -0.00731714f, -0.01898338f, 
    0.03839841f, -0.02278389f, -0.06689732f, 0.03738042f, -0.03721439f, -0.03662746f, -0.09827340f, -0.05548489f, 
    0.02394852f, 0.00951402f, -0.02328327f, 0.10863278f, 0.16944093f, 0.02630998f, -0.17795135f, 0.05224775f, 
    -0.16132830f, 0.02293251f, -0.06042170f, -0.08272550f, -0.04570712f, 0.06948833f, 0.05991983f, 0.05589150f, 
    -0.10763922f, -0.03660090f, 0.02729196f, 0.01205991f, 0.07806315f, -0.05755881f, -0.07228938f, -0.00008380f, 
    -0.20912142f, 0.02793671f, -0.06229125f, 0.03881782f, -0.09734003f, 0.06009930f, -0.06308914f, 0.06235919f, 
    0.00157959f, -0.00645120f, 0.00405563f, 0.03780344f, 0.00026188f, -0.05475874f, 0.04257835f, 0.04237671f, 
    0.02058214f, -0.06164111f, 0.04632687f, -0.08893858f, -0.03475667f, -0.01373429f, 0.08715436f, -0.00319074f, 
    -0.02475195f, -0.02771029f, 0.06066597f, 0.00407198f, 0.00267576f, 0.11519950f, 0.14960413f, -0.04630800f, 
    0.06281462f, 0.05090905f, -0.06733692f, -0.04660247f, 0.02036905f, -0.14275122f, 0.00035821f, -0.11299597f, 
    -0.09265158f, -0.02822869f, -0.06695690f, 0.01707932f, -0.09872658f, 0.06813103f, -0.00563211f, 0.01627900f, 
    0.11029058f, -0.00189506f, -0.04822098f, 0.00108299f, 0.07286447f, 0.09894142f, -0.02311121f, 0.02186406f, 
    -0.01882353f, -0.12876463f, -0.12794670f, -0.09190205f, 0.08034916f, -0.22074148f, -0.08126862f, -0.03664801f, 
    -0.26061228f, 0.05330556f, -0.01113689f, -0.02425242f, 0.09545887f, 0.04934803f, 0.00726312f, 0.05763698f, 
    -0.01695962f, -0.04158462f, -0.00700628f, -0.01240088f, 0.03910725f, -0.07158974f, 0.00180031f, -0.11914977f, 
    -0.04860885f, 0.09536742f, -0.13820338f, -0.05111000f, 0.01605546f, 0.03973667f, 0.13105685f, -0.03307391f, 
    0.02296628f, 0.01047705f, -0.02384854f, -0.03832772f, 0.00414146f, -0.03798681f, 0.05030160f, 0.10345769f, 
    0.00400709f, 0.01774153f, 0.03872551f, 0.03057371f, 0.04517266f, 0.11158469f, -0.07605144f, 0.02190955f, 
    0.22828595f, 0.05610976f, 0.00657458f, 0.05779051f, 0.04864025f, 0.03008622f, 0.01526257f, -0.02425461f, 
    -0.03492536f, 0.00496172f, -0.07725874f, 0.01756852f, 0.02066076f, 0.06900691f, -0.05916442f, 0.00109446f, 
    -0.45221213f, 0.22669539f, -0.06972639f, -0.05127880f, 0.07472072f, -0.22474755f, 0.04063453f, -0.00648437f, 
    -0.08544227f, 0.06280450f, 0.07879168f, -0.08335239f, 0.00609201f, -0.08047926f, -0.18654497f, -0.13448215f, 
    0.03853115f, 0.04119952f, -0.09500059f, 0.12479475f, 0.22837651f, -0.17624766f, -0.01269648f, -0.01534217f, 
    -0.17187162f, 0.04517196f, 0.07752212f, -0.05750275f, -0.00422347f, 0.05060002f, 0.10113709f, 0.05607121f, 
    0.03188524f, 0.02753024f, -0.11370333f, 0.04869545f, 0.11040416f, 0.00040569f, -0.01487235f, 0.10540961f, 
    -0.09673221f, 0.04505371f, -0.06392826f, -0.05536062f, -0.12920420f, 0.03275411f, -0.01036219f, -0.07081649f, 
    -0.04505742f, -0.01050930f, 0.02894947f, 0.06952725f, -0.04862627f, -0.02176965f, -0.03770555f, -0.00123239f, 
    -0.08266518f, 0.01880879f, -0.03465232f, 0.04236409f, 0.06265967f, -0.00267346f, -0.12055996f, -0.09039021f, 
    0.06789598f, -0.00013747f, 0.02466528f, 0.01289698f, 0.06197993f, -0.01465065f, 0.15817982f, -0.05001337f, 
    -0.02359937f, -0.01313595f, 0.01798997f, 0.02713453f, -0.03300037f, 0.04051794f, 0.04376576f, 0.18939447f, 
    0.28020903f, -0.31060985f, -0.01169842f, 0.00164955f, -0.02293431f, -0.10566007f, 0.04656368f, -0.02347534f, 
    0.09772853f, 0.00393386f, -0.01993932f, 0.02058323f, -0.05902011f, 0.00939387f, -0.07319982f, 0.11162723f, 
    0.03342031f, 0.02600657f, 0.02212986f, 0.06234379f, -0.25068614f, 0.13600467f, -0.02516958f, -0.00767763f, 
    -0.16037682f, -0.02133613f, 0.00391485f, -0.03155034f, 0.07840243f, 0.04598037f, 0.01399669f, 0.01312227f, 
    -0.01685502f, 0.09407634f, -0.05452592f, -0.03147388f, 0.02313120f, -0.02816398f, -0.02065339f, -0.05531266f, 
    -0.02371270f, 0.09550539f, -0.12220367f, -0.25986278f, -0.18864922f, 0.08191300f, 0.11496049f, -0.09416638f, 
    0.09586100f, -0.04247911f, -0.11061770f, -0.12925448f, -0.09002195f, 0.05824766f, -0.00034105f, 0.01386672f, 
    -0.06056515f, 0.02880998f, 0.00458610f, 0.02290042f, 0.15728961f, 0.14269644f, -0.18252769f, -0.12494729f, 
    -0.01865139f, -0.01784137f, 0.03481387f, 0.01583765f, -0.15378895f, 0.01470153f, -0.02423679f, 0.00101544f, 
    0.04469293f, 0.02201155f, 0.08548646f, 0.04627135f, -0.03257157f, 0.12260984f, 0.03420163f, -0.01111557f, 
    0.34749284f, 0.01724892f, -0.05091390f, 0.02464679f, -0.01954594f, 0.09885228f, 0.07019214f, -0.01041372f, 
    0.05358700f, 0.01953700f, 0.00572667f, -0.11279364f, 0.03248358f, -0.01880974f, 0.03592652f, 0.10945428f, 
    -0.07839551f, 0.03461594f, -0.05789936f, 0.14689882f, 0.25845790f, -0.18346304f, -0.17540890f, -0.16479988f, 
    0.04286755f, -0.04406905f, -0.06261825f, 0.00328628f, -0.00097297f, -0.00697805f, 0.00351339f, 0.01555854f, 
    -0.04382462f, -0.00249457f, 0.13160042f, 0.02134688f, -0.09636605f, -0.08231606f, -0.06839421f, 0.10641631f, 
    0.07302217f, 0.02034720f, 0.13700522f, 0.08409283f, 0.15545264f, -0.06147215f, -0.07247473f, -0.02732404f, 
    -0.00114865f, -0.00741172f, 0.02917449f, -0.04981969f, -0.01960249f, 0.07828689f, -0.03904486f, -0.06917385f, 
    -0.02292057f, 0.03240070f, 0.03374955f, 0.03927148f, 0.29493865f, -0.34324566f, 0.08133908f, -0.05177408f, 
    -0.06750156f, -0.11233156f, -0.07187703f, -0.11301053f, 0.00903076f, -0.00533958f, 0.01257981f, 0.04774015f, 
    -0.08688714f, -0.00917118f, 0.02235216f, -0.05640625f, -0.05932923f, 0.00026806f, 0.02965534f, 0.05027196f, 
    0.17580768f, 0.21220031f, 0.06741359f, 0.12200551f, 0.15647860f, -0.00481356f, -0.08814403f, 0.04814452f, 
    0.01549989f, 0.04842929f, -0.02360279f, 0.02735494f, -0.07864229f, 0.03912210f, -0.07112554f, -0.01733093f, 
    0.05085353f, 0.09118835f, -0.00043860f, -0.00752434f, 0.02303480f, -0.41650736f, 0.10834111f, -0.10415289f, 
    0.07549055f, 0.00918554f, -0.01657847f, -0.06105334f, -0.04854611f, -0.05267383f, 0.02559166f, 0.04065881f, 
    -0.01560193f, 0.00206202f, -0.15799031f, -0.04991060f, -0.05765057f, -0.06555444f, 0.08679916f, -0.06908634f, 
    -0.12318374f, -0.16897556f, 0.05679894f, -0.05286747f, 0.10518809f, 0.01109866f, -0.04962269f, -0.03234554f, 
    0.04613774f, -0.01406870f, 0.10656687f, -0.00170682f, 0.03449316f, -0.06503063f, 0.02636939f, 0.01463298f, 
    -0.02714765f, 0.01486130f, 0.03083892f, -0.07053103f, -0.01943263f, 0.00592151f, 0.06536008f, -0.01342194f, 
    0.02110073f, -0.04687947f, 0.04067025f, -0.04030003f, 0.01285166f, -0.04939183f, 0.07059061f, -0.05152130f, 
    0.00803512f, -0.02379156f, 0.00950772f, -0.02216401f, 0.05318468f, -0.02223354f, 0.00029454f, 0.10409243f, 
    0.03827139f, -0.12047085f, 0.01399361f, 0.07949609f, 0.06394541f, -0.03675815f, -0.04493761f, 0.02551524f, 
    -0.01486894f, -0.00373617f, 0.06933182f, -0.01950760f, -0.05046360f, -0.00716548f, -0.12571752f, 0.04155028f, 
    -0.10927521f, 0.05840468f, 0.02250773f, 0.00057585f, 0.10632977f, 0.24163689f, 0.12536055f, 0.04480259f, 
    0.16442932f, -0.03649819f, 0.05329208f, -0.01505553f, 0.03536411f, 0.06331494f, -0.02604134f, 0.03555126f, 
    0.03482771f, 0.05005574f, 0.01246281f, 0.02396294f, 0.03861884f, 0.05852916f, 0.02660789f, -0.05504141f, 
    -0.15724392f, -0.43473566f, -0.13295342f, -0.10183205f, -0.34384784f, 0.00339209f, -0.06039557f, 0.01616453f, 
    -0.06164293f, -0.04094120f, 0.01664669f, 0.00352451f, -0.00790576f, 0.00037308f, -0.00746838f, 0.04491572f, 
    -0.02737128f, 0.08354022f, -0.08174749f, -0.08614666f, 0.16950274f, 0.00512087f, -0.01681055f, -0.05840689f, 
    -0.01087287f, -0.09338708f, -0.05058394f, 0.01339749f, 0.02254242f, -0.02924799f, -0.02002339f, 0.00600639f, 
    0.00828268f, 0.04152556f, 0.02948631f, -0.00239093f, -0.03879369f, -0.15599746f, 0.03948340f, -0.00918708f, 
    -0.06296120f, 0.06887095f, -0.04798304f, -0.02946080f, -0.08928563f, 0.04742556f, -0.05120637f, 0.08018134f, 
    0.01647935f, 0.02321857f, -0.04358334f, 0.00808236f, 0.00932731f, -0.09295192f, -0.00303464f, -0.06546024f, 
    -0.01087102f, 0.02028492f, 0.04497250f, -0.02611138f, -0.29106081f, 0.15723000f, -0.02929236f, -0.12834091f, 
    0.05853765f, 0.04359753f, 0.07326560f, 0.00805827f, 0.07580942f, -0.08550601f, -0.07257197f, 0.04129159f, 
    -0.04235754f, -0.05154132f, -0.05661210f, -0.02152977f, 0.00041846f, 0.04506580f, 0.02000795f, -0.00875001f, 
    0.03158283f, -0.07761492f, 0.03788684f, -0.01146786f, -0.07671979f, 0.06371611f, -0.05500623f, 0.03596419f, 
    -0.01406002f, 0.01634885f, -0.04175445f, -0.00577100f, 0.04575773f, -0.01204082f, -0.01581266f, 0.00424606f, 
    0.01228052f, 0.01563440f, -0.07529510f, -0.03574853f, 0.03592238f, -0.07025202f, 0.03734766f, -0.09453888f, 
    -0.05053823f, 0.04815539f, -0.06542543f, 0.01114725f, 0.01296351f, 0.02640300f, -0.08160307f, 0.06767686f, 
    0.04712248f, -0.02225481f, -0.03884052f, 0.01146000f, -0.04981731f, 0.01481800f, -0.03768970f, 0.05360104f, 
    0.20570008f, 0.07316235f, -0.16981968f, -0.01891068f, -0.16277421f, 0.04287009f, 0.05529707f, -0.00834034f, 
    -0.00778157f, -0.00208192f, -0.01070357f, 0.00920804f, 0.00453452f, -0.08592472f, -0.03787848f, 0.03727678f, 
    0.09558943f, 0.00452374f, 0.05102313f, -0.09156998f, -0.21053727f, 0.09811254f, 0.01634851f, -0.04918880f, 
    0.14199387f, 0.05286598f, 0.02397306f, 0.02765746f, 0.03834421f, -0.04429214f, -0.00017797f, -0.01724499f, 
    0.00574246f, -0.05613932f, -0.01562805f, -0.00940025f, 0.05696038f, -0.12791456f, -0.13374004f, -0.01218526f, 
    -0.02822738f, 0.12949768f, 0.01293923f, -0.01017837f, 0.04694533f, 0.03474109f, -0.05055888f, 0.01826876f, 
    -0.03234600f, 0.06770759f, 0.03197252f, 0.00864868f, -0.00450454f, 0.05359382f, 0.01230369f, 0.03884976f, 
    -0.00434212f, 0.01312857f, -0.04273405f, -0.02561878f, 0.21589816f, -0.03409563f, 0.00015054f, -0.08571891f, 
    -0.03368946f, 0.05431844f, -0.04376630f, 0.11491074f, -0.08053072f, 0.03409068f, -0.01757194f, -0.05629124f, 
    0.01868873f, 0.01924854f, -0.02914207f, -0.02749538f, -0.08529844f, 0.06766502f, 0.02210290f, 0.01063395f, 
    0.02031324f, -0.19417131f, -0.19219372f, 0.01229972f, -0.22576764f, -0.04612138f, 0.01075161f, -0.03171412f, 
    0.09617319f, -0.07256061f, 0.02158361f, -0.02124470f, 0.00422739f, 0.02694790f, -0.06540164f, 0.00586680f, 
    0.05766075f, -0.00639583f, 0.00731238f, -0.02460895f, 0.09987920f, -0.29933113f, 0.10278527f, 0.00243391f, 
    -0.03234351f, -0.06324448f, -0.13122825f, -0.13899644f, 0.01863868f, 0.01883714f, -0.04942189f, -0.01176817f, 
    0.03955681f, -0.06392325f, 0.01493461f, -0.00536403f, 0.00513690f, 0.00318550f, 0.07508892f, 0.01668497f, 
    0.36108488f, -0.21843472f, -0.02913801f, 0.02496379f, -0.07724397f, -0.18317465f, 0.01486513f, 0.03508443f, 
    -0.03361414f, -0.06940812f, 0.03336395f, -0.03829530f, 0.01037186f, -0.06997802f, 0.03787517f, 0.03458782f, 
    -0.06429631f, 0.06164304f, 0.01141552f, 0.00947221f, 0.25462440f, -0.12167375f, -0.17197214f, -0.06357307f, 
    -0.07447747f, -0.03821695f, 0.03969720f, 0.10820229f, -0.02919846f, 0.00666981f, -0.08380016f, -0.00246925f, 
    0.03391267f, -0.03051822f, -0.02382412f, -0.04433205f, 0.01971155f, -0.02084906f, 0.04716945f, 0.04104214f, 
    -0.20719522f, 0.10022633f, 0.06471089f, -0.08209305f, 0.02958742f, 0.02006269f, 0.02275208f, 0.02285948f, 
    0.05329355f, 0.02334081f, -0.03574619f, -0.02137874f, 0.00869971f, -0.05937589f, 0.06430732f, -0.00330285f, 
    -0.04574211f, -0.03505494f, 0.00386907f, 0.05961132f, 0.08614687f, 0.00140098f, 0.16863459f, 0.00825508f, 
    0.13109180f, -0.15776967f, -0.07377362f, -0.09829620f, 0.02515948f, -0.03526521f, 0.08039144f, -0.06506843f, 
    -0.00028130f, -0.10864802f, 0.09737249f, 0.03082671f, -0.09733588f, -0.07340685f, 0.03864202f, 0.02952950f, 
    0.04424505f, 0.08001756f, -0.20512892f, -0.13977382f, -0.06682693f, 0.03913332f, 0.00815064f, 0.00689615f, 
    -0.13795118f, -0.03622427f, -0.00073989f, -0.00772261f, 0.02223085f, -0.05662569f, 0.02592231f, -0.03064417f, 
    0.03613565f, -0.02892219f, -0.03025249f, 0.07297790f, 0.32851833f, -0.11467755f, -0.22130151f, 0.19825232f, 
    -0.14623824f, -0.05748518f, -0.03376168f, 0.02938036f, 0.00870055f, 0.00748749f, 0.03088447f, 0.03729224f, 
    0.02631414f, 0.08599301f, -0.03549776f, -0.00475893f, -0.04439574f, -0.00436301f, -0.10091391f, 0.01592356f, 
    0.01751790f, 0.00582869f, -0.12196612f, 0.02413846f, -0.08502525f, 0.02419526f, -0.03809199f, 0.05415163f, 
    0.05497083f, 0.04973668f, 0.00387076f, -0.02649454f, 0.02944256f, -0.04289485f, 0.01243040f, 0.01138031f, 
    -0.05585970f, -0.05069467f, -0.00113039f, -0.02920895f, 0.18557139f, 0.06806991f, -0.17310716f, -0.04061619f, 
    -0.07596318f, 0.03676346f, 0.09150994f, 0.05092285f, -0.03119776f, 0.07156826f, -0.02145210f, 0.08597999f, 
    -0.03322610f, -0.02572521f, -0.03455620f, -0.03057026f, 0.02761720f, -0.00275162f, -0.06989887f, -0.01213600f, 
    0.07622743f, 0.09593529f, 0.17236999f, 0.08217908f, 0.07788166f, 0.01390490f, -0.08449681f, 0.04772054f, 
    0.04509144f, 0.04131793f, 0.02155756f, -0.03324191f, 0.04709124f, 0.04079457f, -0.01018315f, 0.06157233f, 
    -0.02841021f, -0.03090954f, -0.06633434f, -0.01384285f, -0.34881303f, -0.20950238f, -0.03802724f, -0.33708391f, 
    -0.21567583f, 0.02789347f, 0.08651151f, 0.03425663f, -0.01259991f, 0.00836882f, 0.01283109f, 0.05100191f, 
    0.01786098f, -0.12609862f, -0.04807751f, 0.10130808f, -0.00908340f, 0.10259052f, 0.02664820f, -0.05399275f, 
    -0.05649920f, 0.11197116f, 0.00832956f, -0.04583244f, -0.05111762f, 0.04416151f, 0.01464078f, 0.09053002f, 
    -0.04257763f, 0.02494533f, 0.01477634f, -0.01942653f, 0.02852175f, -0.02133100f, 0.00085286f, -0.01699374f, 
    -0.01967701f, -0.00818156f, 0.03853758f, -0.02467506f, 0.22771747f, 0.04601425f, 0.13040194f, 0.04853938f, 
    0.19152932f, -0.10784356f, -0.05282456f, -0.09206371f, 0.08093442f, 0.00703070f, 0.06293306f, -0.04306562f, 
    -0.01874808f, -0.04468651f, -0.05955914f, -0.03536890f, -0.04110440f, -0.02228770f, -0.00952095f, 0.02269341f, 
    -0.05832190f, 0.15659028f, -0.08681720f, -0.18244174f, 0.09208328f, 0.03501286f, 0.05752721f, 0.11533186f, 
    0.01002706f, -0.04499903f, -0.04030576f, 0.07379440f, -0.03019541f, -0.05780178f, -0.05471339f, 0.00552429f, 
    -0.00372354f, 0.00386672f, -0.03066049f, 0.02740753f, -0.04307707f, 0.02739571f, 0.05769327f, -0.03967958f, 
    0.03399001f, 0.02119018f, 0.07363562f, 0.04348444f, -0.02379128f, -0.06269380f, 0.01096890f, 0.05189797f, 
    -0.05364738f, -0.05416219f, 0.01148144f, -0.01857553f, -0.01775406f, -0.01692076f, -0.08814375f, -0.03665306f, 
    0.04927759f, 0.04515615f, -0.04139213f, -0.08995903f, -0.01836183f, 0.00974747f, -0.01639905f, -0.00413880f, 
    0.04660486f, -0.00529396f, -0.01492214f, -0.02808637f, -0.02443192f, 0.01901203f, -0.04708320f, -0.04007277f, 
    -0.01456946f, -0.05737566f, -0.07541077f, 0.05765216f, -0.07917992f, -0.15976116f, 0.06058132f, 0.01495483f, 
    0.01082920f, 0.05143248f, 0.12172062f, -0.01270669f, 0.00540660f, -0.01030135f, 0.00299924f, -0.00449101f, 
    -0.00210923f, -0.06876949f, -0.03736373f, -0.00145865f, 0.00563882f, 0.02924439f, -0.12505360f, -0.00358485f, 
    0.28946871f, -0.16789311f, -0.17458153f, 0.01280891f, -0.08430107f, -0.10996108f, 0.07812306f, 0.06643323f, 
    0.00438610f, 0.01048092f, 0.04253090f, -0.05529619f, -0.02035622f, -0.02720720f, -0.04257101f, 0.08443874f, 
    -0.02494428f, 0.00499695f, 0.06359633f, -0.03969977f, -0.12315229f, 0.02812141f, -0.05466449f, -0.09686910f, 
    0.04152877f, 0.01807257f, 0.00335973f, 0.02640794f, 0.03244366f, -0.07814837f, 0.02036984f, 0.01798799f, 
    0.00431163f, -0.03511936f, 0.02630305f, -0.03041843f, 0.00685179f, 0.01140023f, -0.04686140f, -0.01682373f, 
    -0.13681203f, 0.04305550f, -0.03061695f, -0.18726662f, 0.08359978f, 0.08182172f, 0.01978826f, 0.02256674f, 
    -0.04390053f, -0.06242908f, -0.07034069f, 0.06832252f, 0.00379932f, -0.06805519f, -0.05100690f, -0.00381190f, 
    0.02834918f, 0.03107556f, -0.01154253f, -0.03749707f, -0.05514333f, -0.19762012f, -0.03082328f, -0.21751910f, 
    -0.22611420f, -0.04261758f, -0.05894218f, -0.14080663f, 0.02249765f, -0.05324001f, 0.04804085f, 0.05198394f, 
    -0.06019206f, -0.07168679f, -0.02252765f, -0.10449791f, 0.03255222f, 0.07048810f, 0.02458735f, -0.04477815f, 
    0.13395695f, -0.11083379f, 0.05735734f, -0.02625749f, -0.05652267f, 0.01911784f, -0.09214244f, 0.03400422f, 
    0.03467823f, 0.07562836f, 0.00290786f, 0.03710506f, 0.00551356f, 0.03366618f, -0.05252187f, -0.03150970f, 
    -0.00830501f, -0.00683679f, -0.07518918f, -0.06134552f, -0.15037036f, -0.06869893f, -0.07658563f, -0.06790218f, 
    -0.19054966f, 0.03527749f, -0.02028788f, 0.03740669f, 0.05852807f, 0.10125116f, -0.01420929f, -0.03885250f, 
    0.10778416f, -0.04186504f, -0.01952238f, 0.05084510f, 0.02466510f, 0.01506050f, -0.01987843f, -0.02478614f, 
    0.22211070f, -0.10855258f, -0.00516638f, -0.15927242f, -0.08503196f, -0.08347312f, 0.00765338f, 0.03224910f, 
    0.02191804f, -0.03905126f, 0.01962576f, -0.06213656f, -0.02078079f, -0.05091491f, -0.03822452f, -0.00283824f, 
    0.03541657f, 0.01125008f, 0.09276450f, 0.00621877f, 0.31810901f, -0.03874710f, -0.13427928f, 0.13669829f, 
    -0.04837666f, -0.08537329f, -0.01526122f, -0.06828055f, -0.05277038f, -0.02433096f, 0.00310518f, 0.00750711f, 
    -0.00908067f, -0.03376240f, -0.04067225f, -0.03181216f, -0.01673302f, 0.00437172f, 0.03764109f, 0.03105976f, 
    0.08549625f, 0.05009684f, -0.15876824f, -0.11901182f, -0.16179326f, 0.05846839f, -0.00009473f, -0.07908349f, 
    -0.00330929f, -0.00355740f, -0.00144251f, -0.03539702f, -0.00314547f, -0.04195184f, -0.01888984f, -0.03010682f, 
    0.01799015f, -0.04973718f, 0.01391614f, -0.06895262f, 0.26356435f, 0.00876637f, 0.01775217f, -0.02689848f, 
    0.07046323f, 0.04413205f, -0.07901565f, 0.02792905f, 0.04263181f, 0.09534378f, -0.00822446f, 0.01989180f, 
    0.04735094f, 0.02505979f, -0.01212771f, -0.04368719f, -0.12056019f, -0.13135579f, -0.07627816f, -0.00598142f, 
    -0.02485032f, 0.10511915f, 0.02284379f, 0.00802080f, 0.06663133f, -0.05406883f, 0.07786991f, 0.04540919f, 
    -0.04082279f, -0.16439748f, -0.00070179f, 0.01453314f, 0.03996889f, 0.01394405f, 0.02425004f, 0.04673890f, 
    0.02029821f, -0.19248480f, 0.02829334f, -0.04725127f, 0.12918033f, -0.07898601f, 0.09061655f, 0.08908781f, 
    0.21764892f, -0.11543339f, -0.03916227f, -0.07914824f, 0.01502134f, 0.05563162f, 0.04693939f, -0.00986149f, 
    0.01717628f, 0.04008579f, 0.05635189f, -0.01029367f, -0.08351723f, 0.00491886f, -0.02772275f, -0.03759645f, 
    0.09405441f, 0.03784712f, 0.12398880f, 0.05334305f, 0.14764208f, 0.03252124f, -0.11253860f, -0.11284474f, 
    0.09490580f, 0.11125173f, 0.04127923f, 0.00691147f, 0.02107998f, 0.04161324f, 0.01742188f, -0.10967171f, 
    -0.02428796f, -0.03586739f, 0.02088730f, -0.03078701f, -0.15432774f, -0.09653486f, 0.00318935f, 0.11875403f, 
    -0.08222393f, -0.03146439f, -0.06096311f, -0.08766324f, -0.02006889f, -0.02055705f, -0.03825001f, -0.05635190f, 
    -0.04819423f, 0.03406391f, 0.04398601f, 0.00211019f, -0.01267882f, 0.03577800f, -0.00493097f, 0.03191024f, 
    0.16629174f, -0.21916659f, 0.02775846f, -0.12274799f, -0.23563625f, -0.06566371f, 0.05859510f, -0.15213344f, 
    -0.00068274f, -0.00839360f, -0.00282816f, 0.02234063f, 0.02988346f, -0.07336634f, -0.07561464f, 0.02410627f, 
    -0.02803306f, 0.03468696f, 0.07981648f, -0.02411987f, 0.09497876f, -0.18482113f, 0.15952572f, -0.01988128f, 
    0.08238810f, 0.02101642f, -0.12234597f, -0.03788154f, 0.04103844f, 0.05688491f, 0.03957625f, -0.01695582f, 
    -0.04431660f, 0.06747499f, 0.01155909f, -0.06978887f, -0.09643599f, 0.01078479f, -0.01254953f, -0.02114272f, 
    0.08069257f, 0.06063142f, -0.02961938f, -0.00921197f, 0.05779408f, 0.02661199f, 0.02381019f, -0.03067024f, 
    -0.01795624f, 0.01675609f, 0.00989523f, -0.01686142f, 0.01926575f, -0.05620771f, 0.04548328f, -0.01011351f, 
    -0.04573911f, -0.07122611f, -0.03980049f, -0.00707702f, 0.00637889f, 0.01209109f, -0.04344496f, -0.01804863f, 
    -0.00548825f, 0.05416883f, -0.03082745f, 0.01039800f, 0.00906427f, -0.08571128f, -0.05740090f, 0.01195668f, 
    0.01902675f, -0.01461210f, 0.01666347f, -0.02946812f, -0.02208114f, -0.06847473f, -0.03742103f, -0.08786318f, 
    0.36097285f, 0.04872247f, -0.11809403f, 0.01916443f, -0.16228539f, -0.08316755f, 0.07067237f, 0.03748073f, 
    -0.07884107f, -0.01043583f, 0.01220678f, -0.04090185f, 0.00422564f, -0.08493173f, 0.00875724f, -0.01212327f, 
    0.00641799f, -0.03935989f, 0.08984433f, -0.10948617f, 0.02506201f, -0.01243359f, 0.16024001f, 0.10071418f, 
    0.09842128f, -0.14141235f, -0.05954066f, -0.09367780f, 0.02260395f, 0.01449234f, -0.00297208f, -0.01178308f, 
    -0.06660617f, 0.02612452f, 0.06921244f, -0.03022114f, -0.00086343f, -0.06274628f, -0.00548458f, 0.03549291f, 
    0.17214459f, 0.05720834f, -0.13608332f, 0.09123685f, 0.02163113f, -0.03820539f, -0.01105524f, 0.04204591f, 
    0.04842202f, 0.05804354f, -0.01119069f, 0.02475558f, 0.00344889f, -0.00495098f, 0.00623640f, -0.02975020f, 
    -0.02244391f, -0.07162412f, -0.01639043f, -0.05069115f, -0.05881988f, -0.03222315f, -0.02621595f, -0.04512643f, 
    0.00364068f, 0.00439223f, 0.04708784f, 0.02252215f, -0.04865633f, 0.01666647f, -0.07871285f, 0.00419914f, 
    0.05938612f, 0.02832665f, -0.05667287f, -0.02485144f, -0.07779386f, 0.00290902f, -0.03724230f, -0.01425226f, 
    0.20683736f, 0.06192895f, 0.17025416f, -0.06378262f, -0.06866618f, -0.02716281f, 0.04916293f, 0.13093656f, 
    0.04301792f, -0.03696278f, 0.00012292f, -0.05541465f, 0.11362194f, -0.04386842f, -0.07626492f, 0.04289500f, 
    -0.11103885f, -0.00893114f, 0.05459492f, 0.00053834f, 0.08922432f, -0.06859094f, -0.04228232f, 0.05814689f, 
    -0.15599951f, -0.08597278f, 0.02678325f, -0.03474091f, 0.00568327f, -0.05216433f, 0.01748236f, 0.02325698f, 
    0.06154277f, -0.05982053f, -0.02594987f, 0.04425694f, -0.06421894f, -0.01966195f, -0.02208173f, -0.02517104f, 
    -0.03481004f, 0.01195809f, -0.27195036f, 0.00642872f, -0.05241666f, -0.01200529f, 0.04492707f, 0.01667943f, 
    -0.04931991f, 0.00870577f, 0.00487234f, 0.04507520f, -0.01055874f, 0.04194410f, 0.04628270f, -0.03885491f, 
    0.01153524f, -0.06389589f, -0.00239568f, 0.03653252f, 0.14944734f, 0.12296129f, -0.12417831f, 0.06592077f, 
    -0.05285051f, -0.06060048f, 0.04615027f, 0.03624520f, 0.00278311f, -0.02603414f, -0.04754322f, 0.06724030f, 
    0.03286584f, 0.02419111f, 0.00718760f, -0.01557782f, -0.00869404f, -0.07135759f, 0.04974330f, 0.06136634f, 
    0.25468141f, -0.05471314f, -0.07932682f, 0.16364701f, -0.21025059f, -0.14411984f, 0.00306824f, 0.01029349f, 
    -0.02998157f, 0.12672973f, -0.02400118f, 0.03779389f, 0.04221158f, 0.00896953f, -0.03085903f, -0.02269292f, 
    -0.14966635f, -0.02824434f, 0.05425892f, 0.00214704f, -0.00590161f, -0.02363830f, -0.08476626f, -0.06180284f, 
    -0.13205063f, 0.04876135f, -0.02566570f, 0.11105535f, -0.07255616f, 0.04998654f, -0.01791594f, 0.06669866f, 
    0.03122569f, -0.03660825f, -0.01278380f, -0.04723091f, -0.09403743f, 0.12295224f, 0.02870754f, -0.04909099f, 
    0.09161008f, -0.01217356f, 0.03420191f, -0.06613374f, 0.03464282f, 0.01742232f, -0.06951811f, 0.05833407f, 
    0.07293303f, -0.01241882f, 0.02181317f, -0.04664879f, 0.06550051f, 0.01425815f, -0.01150434f, -0.00100683f, 
    0.00860252f, -0.01752643f, -0.05089397f, -0.03169139f, 0.15920319f, -0.02113865f, -0.00293028f, 0.06595811f, 
    -0.12583888f, -0.02302837f, -0.05890786f, 0.06522278f, 0.04964865f, 0.08178946f, -0.01126539f, 0.00169553f, 
    -0.04522294f, 0.02367742f, -0.03986276f, -0.04132675f, -0.03164681f, -0.00552641f, 0.04006357f, -0.00530273f, 
    -0.09047275f, 0.01782337f, -0.07680065f, -0.15797256f, 0.06937128f, 0.08627383f, -0.00945143f, 0.05781936f, 
    0.05168541f, -0.03264559f, -0.09593516f, 0.05381815f, -0.00948124f, -0.01996641f, 0.03454839f, -0.06292941f, 
    -0.04335773f, -0.03074998f, -0.06941258f, -0.05551123f, -0.14190008f, 0.01785164f, 0.00882822f, 0.14701481f, 
    -0.10692096f, 0.07814334f, -0.04618013f, -0.01105248f, 0.14361309f, 0.08410902f, 0.00266658f, -0.03363310f, 
    0.00868902f, 0.02481805f, -0.01100401f, 0.07827238f, 0.07083713f, -0.01544107f, -0.05290584f, -0.05651231f, 
    0.02026644f, -0.03166929f, -0.01333822f, 0.02728133f, -0.07066313f, 0.02267613f, -0.01126211f, 0.05857954f, 
    -0.02440982f, 0.06649116f, -0.00830147f, 0.00991213f, 0.01146311f, 0.00954941f, -0.03286099f, -0.06544530f, 
    -0.01163006f, 0.06853516f, -0.07483042f, -0.06924012f, -0.07769392f, 0.08683335f, 0.04747662f, -0.10422420f, 
    0.00861107f, -0.07095104f, 0.08711498f, 0.02797236f, 0.03202496f, -0.07010183f, 0.00665752f, -0.05529828f, 
    0.06563801f, -0.05152293f, 0.00582658f, -0.00428487f, -0.00296189f, -0.01712095f, 0.03508181f, -0.01873881f, 
    0.23200986f, 0.04986756f, -0.01725303f, -0.10449802f, -0.01674592f, 0.00594239f, 0.02374307f, 0.02445085f, 
    0.01205655f, -0.00163863f, 0.02949506f, 0.02084077f, -0.06410865f, -0.06251949f, -0.04233013f, 0.03888452f, 
    0.03655083f, -0.01232703f, 0.07890812f, 0.00670904f, 0.08733084f, -0.07370894f, 0.10194466f, -0.06681041f, 
    -0.03331437f, 0.05569086f, -0.01679512f, 0.06553083f, -0.01381110f, 0.01658037f, -0.05690435f, 0.04969372f, 
    0.01691949f, 0.05094529f, -0.03757815f, -0.07840446f, -0.04970362f, -0.06153747f, -0.04016627f, -0.07421146f, 
    0.19803570f, 0.04717764f, 0.12696387f, 0.02018842f, 0.03324300f, -0.00201102f, 0.08589070f, -0.00365399f, 
    -0.05684765f, 0.05940958f, 0.04539640f, -0.01865142f, -0.06056181f, -0.02005355f, 0.08608208f, -0.00717306f, 
    0.05230357f, 0.01225081f, 0.01811603f, 0.05493461f, -0.33500442f, -0.21797140f, -0.04535494f, -0.11659043f, 
    -0.15729639f, -0.09758833f, -0.16853429f, 0.04631920f, -0.03738084f, -0.09533302f, -0.08338513f, -0.05350581f, 
    -0.01324040f, -0.03760535f, -0.04051422f, -0.02219803f, -0.01642679f, -0.01977722f, -0.00841737f, -0.03237443f, 
    0.15918398f, -0.15195149f, -0.08002581f, 0.03848414f, 0.04636165f, -0.05473082f, 0.05729237f, 0.00495024f, 
    0.02945227f, 0.01072496f, 0.03945084f, -0.01899727f, 0.01075356f, -0.07192921f, 0.01874561f, -0.03152031f, 
    0.02992971f, 0.00408735f, 0.02067454f, -0.01384737f, -0.09500632f, -0.08194955f, -0.09392983f, 0.10804725f, 
    0.09402545f, 0.01768084f, 0.13407965f, 0.03032932f, 0.08161522f, -0.00209501f, -0.00258058f, 0.01675458f, 
    -0.03551770f, -0.07460222f, -0.05464230f, 0.05324332f, 0.03760303f, 0.03288869f, 0.01726972f, -0.00372964f, 
    0.04216792f, -0.11075287f, -0.13202374f, 0.01067683f, 0.00314554f, -0.09339079f, -0.00674510f, 0.01096727f, 
    0.04122854f, 0.03464178f, 0.01589283f, 0.00844224f, -0.00812122f, 0.05520933f, 0.06179506f, -0.06295707f, 
    0.00162915f, 0.01265826f, -0.03345083f, 0.06644955f, 0.07135993f, 0.08569849f, -0.08751387f, 0.03146866f, 
    -0.01560590f, -0.00457222f, 0.00509890f, 0.00083646f, 0.08606397f, -0.07015818f, -0.05972854f, 0.02146017f, 
    0.01571938f, 0.02954178f, 0.01218101f, -0.04524595f, 0.01287787f, -0.00535884f, -0.03774447f, -0.06236060f, 
    -0.19689418f, 0.25593716f, 0.06897317f, 0.22000368f, 0.09732601f, 0.11378468f, 0.11270466f, 0.08111759f, 
    -0.02465640f, 0.05456257f, 0.02451987f, 0.00566029f, -0.03415405f, -0.02955830f, -0.16350339f, 0.04657293f, 
    -0.02143130f, 0.03711349f, -0.00741413f, 0.02409256f, -0.00155322f, -0.25334731f, -0.48271608f, 0.16925220f, 
    0.09894685f, -0.06104902f, 0.10284415f, -0.00632990f, 0.02855395f, -0.07670936f, 0.02659829f, -0.00269251f, 
    0.02421765f, -0.06328776f, -0.00428046f, -0.06547960f, 0.05162990f, 0.10061550f, -0.00188974f, -0.09367342f, 
    0.08018050f, 0.11946322f, -0.13349283f, 0.05253780f, -0.05276947f, -0.02537012f, 0.04091102f, -0.01193039f, 
    0.02436674f, -0.04901658f, 0.00526351f, -0.10497841f, -0.04247303f, 0.01989267f, -0.02649198f, -0.04419541f, 
    -0.00924828f, 0.00898379f, 0.00767010f, 0.00921892f, 0.31879702f, 0.19785760f, -0.11277447f, -0.02865078f, 
    -0.02048388f, -0.08255817f, 0.00559997f, 0.02054969f, 0.08279333f, 0.01378004f, -0.08351380f, -0.09779913f, 
    -0.04014765f, 0.05293893f, 0.00801271f, -0.10514314f, 0.01073974f, 0.01180701f, 0.02365669f, 0.04071507f, 
    -0.05191544f, 0.21597345f, 0.15611847f, 0.15020967f, 0.01922385f, 0.06127334f, 0.01038882f, 0.06284790f, 
    -0.05293755f, 0.06868817f, 0.01986665f, -0.02693065f, 0.00742342f, -0.01476817f, -0.09373026f, -0.06099766f, 
    0.02615497f, 0.05587461f, 0.06406556f, -0.03807104f, 0.12474457f, 0.16768637f, -0.10680098f, -0.04301481f, 
    0.06740400f, -0.01468042f, 0.01108147f, -0.01620498f, 0.07073044f, 0.02226556f, -0.05150225f, -0.00237635f, 
    0.00226564f, 0.00152463f, 0.03178736f, -0.03385662f, -0.05233940f, 0.05178867f, -0.00414383f, -0.03131117f, 
    -0.15318364f, -0.11506203f, 0.12170893f, -0.01041471f, 0.01980135f, 0.13218676f, -0.07314233f, -0.07375009f, 
    0.07922816f, -0.17349033f, 0.06457230f, 0.05341060f, -0.00109434f, -0.03501758f, -0.10968231f, -0.06583090f, 
    0.05073136f, -0.01844939f, -0.08763976f, -0.03312146f, 0.26699305f, 0.13570495f, 0.00915773f, 0.12114260f, 
    0.12226712f, 0.07946699f, 0.05481878f, 0.00890759f, 0.07114094f, 0.02555283f, -0.03654957f, 0.03959633f, 
    -0.10702833f, -0.07221122f, -0.07529661f, -0.10162262f, 0.01990618f, 0.00768132f, 0.06185900f, 0.02639440f, 
    -0.03840701f, -0.11868472f, -0.20601235f, -0.09347668f, -0.14946306f, -0.07564237f, 0.00231631f, -0.07316338f, 
    -0.02828910f, -0.02491124f, -0.01769164f, 0.04732922f, -0.01347640f, -0.02285172f, -0.01015511f, -0.00351031f, 
    -0.01941245f, -0.01827473f, -0.00469142f, 0.01795076f, 0.21679860f, -0.14977103f, 0.06305464f, -0.10142519f, 
    -0.08573175f, -0.06546932f, -0.12402689f, -0.09079150f, -0.05738557f, -0.01968935f, 0.00958273f, 0.00001899f, 
    0.04873521f, -0.01423285f, 0.00785447f, -0.03853275f, -0.01453072f, -0.04587806f, 0.01616566f, 0.04927614f, 
    -0.00291772f, 0.27540880f, 0.02174430f, -0.05574277f, -0.01959613f, -0.06059752f, 0.01445549f, -0.05926739f, 
    0.05849479f, -0.00407832f, 0.00223866f, 0.05381210f, -0.02352087f, 0.05492805f, -0.00613031f, -0.01369285f, 
    0.05902165f, -0.02247463f, 0.10684621f, 0.04274243f, 0.00875363f, -0.02745545f, -0.01471578f, 0.12396403f, 
    -0.04082361f, -0.10466344f, -0.08470893f, 0.07318259f, 0.00597192f, -0.02370609f, -0.13671364f, 0.04942555f, 
    -0.01727718f, 0.01147170f, 0.01523162f, 0.04390644f, 0.00978430f, 0.12550558f, 0.04309948f, 0.02429719f, 
    0.10653251f, -0.17675461f, -0.02656808f, -0.00928417f, -0.03731258f, -0.07589977f, -0.00701929f, 0.03677457f, 
    -0.03120007f, 0.01368578f, 0.02778867f, 0.03082560f, 0.00636118f, 0.02924955f, -0.02290941f, -0.00917415f, 
    -0.03184905f, -0.03810279f, 0.03046858f, 0.05105508f, 0.41566676f, 0.07152262f, -0.08620745f, 0.06380763f, 
    0.02274095f, 0.10362644f, -0.00481906f, -0.05103476f, 0.07612382f, -0.02308330f, 0.03738553f, 0.07115955f, 
    -0.02508491f, 0.00427565f, -0.04834352f, -0.05366804f, 0.05024318f, -0.04456513f, 0.08519293f, 0.01994150f, 
    -0.22847784f, 0.02761480f, 0.04524860f, -0.17767362f, -0.10111545f, -0.09242553f, -0.08406123f, 0.04360839f, 
    -0.04771134f, -0.07217774f, -0.03120058f, -0.02476750f, -0.01119499f, 0.00295853f, -0.00806624f, 0.03736394f, 
    0.06410187f, -0.01569937f, 0.04460618f, -0.01473967f, 0.13452107f, 0.16915898f, 0.17096141f, 0.16468212f, 
    0.10931069f, 0.02347709f, 0.04285574f, -0.03929621f, 0.00228585f, -0.00710115f, 0.00799029f, -0.00729256f, 
    -0.08474839f, -0.01886626f, -0.03874166f, 0.06587236f, -0.03204744f, 0.05884828f, 0.07247460f, 0.04521972f, 
    0.13555638f, -0.15795356f, -0.12946334f, 0.06491275f, -0.01229471f, -0.05353686f, -0.01345172f, 0.00059680f, 
    0.06645092f, 0.05737627f, 0.02837497f, 0.04817880f, -0.00618604f, 0.03246931f, 0.05393763f, 0.04345945f, 
    -0.01518081f, -0.03007963f, -0.00055695f, -0.03809602f, -0.06807586f, -0.02850777f, -0.00121987f, -0.07460119f, 
    -0.12160234f, -0.02152990f, -0.11678019f, 0.00166977f, -0.03982354f, 0.02443988f, -0.04634856f, -0.01172947f, 
    -0.00407790f, -0.03323719f, 0.09003702f, -0.00078112f, 0.00068137f, 0.01189157f, 0.04764187f, 0.01833083f, 
    -0.08305368f, -0.32464728f, -0.17448491f, -0.02327987f, 0.15304565f, 0.00253701f, 0.03297550f, 0.03681879f, 
    0.02659959f, -0.08135445f, 0.05700083f, -0.01036855f, 0.02784283f, -0.05238677f, -0.04060190f, 0.01634797f, 
    -0.00212690f, 0.03686660f, 0.01712572f, -0.01301634f, -0.06757351f, -0.38728777f, -0.23331283f, 0.08769307f, 
    0.02129453f, 0.04776062f, -0.04514536f, 0.04141686f, 0.02094259f, -0.07681309f, -0.00046064f, -0.02930030f, 
    -0.09375304f, -0.03297065f, -0.02320722f, 0.01518957f, 0.00236360f, 0.06729315f, -0.02760185f, -0.06113146f, 
    -0.27450407f, -0.42176220f, -0.00340862f, 0.10727984f, 0.14562534f, -0.06117527f, 0.00150646f, 0.03824160f, 
    -0.04044004f, -0.00627917f, -0.05851253f, -0.01596584f, 0.00858042f, 0.07205480f, 0.01236362f, -0.00030978f, 
    0.01517347f, -0.05429156f, 0.00206579f, 0.05187854f, 0.02586676f, -0.29792723f, -0.29631495f, 0.17173257f, 
    -0.03679769f, 0.01577351f, -0.00582101f, 0.01110437f, 0.01951750f, -0.04318598f, 0.01615087f, -0.02628293f, 
    -0.06583094f, -0.00156827f, -0.06562501f, -0.02691217f, 0.06765827f, 0.10099115f, -0.05132096f, -0.06812710f, 
    0.08318152f, 0.16168720f, 0.09295522f, 0.05949961f, 0.01092131f, -0.01013701f, -0.08330441f, -0.05413641f, 
    -0.01158561f, -0.08845348f, -0.05640076f, -0.07628504f, 0.01295671f, 0.01226627f, 0.04357092f, -0.04767168f, 
    0.01034824f, -0.03178518f, 0.04420607f, 0.00248444f, -0.22205301f, -0.03339370f, -0.21417150f, 0.04675450f, 
    0.03270517f, 0.00879440f, 0.00052709f, 0.08006180f, -0.01871754f, -0.03119406f, -0.03683306f, -0.05586530f, 
    0.07139109f, 0.01007504f, -0.02224952f, -0.00510731f, -0.05732030f, -0.00298090f, 0.01141624f, 0.04335580f, 
    -0.03957910f, -0.23201342f, -0.02301872f, -0.03132059f, 0.15234283f, 0.07918449f, 0.02751504f, 0.03663691f, 
    -0.06203362f, 0.00727379f, 0.00158864f, -0.04279656f, -0.06244974f, 0.05124534f, -0.08901834f, 0.03761460f, 
    0.03939378f, 0.06172229f, -0.02147214f, 0.04217268f, 0.02460465f, 0.15986218f, 0.00577326f, 0.04066712f, 
    -0.01742295f, -0.03110074f, 0.01762939f, -0.05166453f, 0.00090619f, -0.00488822f, -0.07081221f, -0.00377324f, 
    -0.01652877f, -0.00236548f, 0.04193751f, 0.06285746f, -0.00800093f, 0.11492960f, 0.02964480f, 0.03463733f, 
    -0.16885819f, -0.15728828f, -0.13677423f, 0.00039347f, -0.05956125f, -0.06823613f, -0.02852607f, -0.00098117f, 
    0.04222664f, 0.00654428f, -0.10693729f, -0.02688924f, 0.03484896f, 0.05797014f, 0.00191575f, 0.05749419f, 
    -0.06967006f, -0.00527781f, -0.03182339f, 0.09404858f, 0.00620829f, -0.06058696f, 0.03008907f, 0.13110304f, 
    0.09224607f, -0.09042572f, 0.08631980f, 0.04257632f, 0.03301901f, 0.04301160f, -0.04336877f, 0.06245508f, 
    0.03874357f, 0.04702090f, 0.10992212f, -0.01003123f, -0.03979488f, -0.02219163f, 0.04304722f, 0.02626443f, 
    -0.10534015f, 0.11833722f, 0.12985437f, 0.10518768f, -0.03770231f, -0.03269453f, 0.02349797f, -0.00584160f, 
    0.07142824f, 0.01813245f, 0.05144550f, 0.01260180f, -0.03610523f, -0.02271099f, -0.01006830f, -0.02076070f, 
    0.01601831f, 0.02308098f, 0.01605036f, 0.01005079f, 0.05829229f, -0.02648325f, 0.05194741f, 0.00220128f, 
    -0.03404764f, -0.06885372f, -0.06631599f, 0.00924016f, -0.05220003f, -0.04994603f, -0.09111867f, -0.03737219f, 
    -0.00743607f, 0.00605008f, 0.04733125f, -0.01934705f, 0.02042382f, 0.03536143f, -0.01473674f, 0.03220170f, 
    0.02872222f, 0.16241811f, 0.05185049f, 0.02458389f, 0.01648169f, 0.04740956f, 0.00533091f, 0.06149888f, 
    0.03456666f, -0.05074815f, -0.04663692f, -0.00297712f, -0.09844365f, 0.00703561f, -0.08944151f, 0.03168699f, 
    -0.03419673f, 0.00440073f, 0.02231094f, 0.03031533f, -0.47214425f, 0.02969981f, 0.12046798f, -0.13793354f, 
    -0.19067255f, -0.07605827f, -0.12902239f, 0.00240879f, -0.02038582f, -0.02297474f, -0.00892959f, -0.10208141f, 
    0.05402602f, -0.02089182f, -0.03199054f, -0.02606730f, 0.05684706f, -0.03504737f, 0.09816842f, 0.10406210f, 
    -0.23444293f, -0.24530293f, -0.00097479f, 0.17046082f, 0.15259188f, 0.01235267f, 0.01858050f, 0.02584665f, 
    -0.01552096f, -0.06727464f, -0.11647891f, -0.01278497f, -0.04966025f, -0.12173060f, 0.03920040f, -0.02089529f, 
    -0.09906173f, -0.07753944f, 0.06962579f, -0.18534882f, 0.00976162f, -0.04179640f, -0.04806427f, -0.05681898f, 
    -0.06170150f, -0.08226576f, -0.13456342f, 0.09418830f, 0.00363622f, -0.02596584f, -0.08317028f, 0.00892153f, 
    0.03759240f, -0.07501729f, 0.03412692f, -0.02597251f, -0.05170114f, 0.11057394f, 0.05735528f, 0.00786964f, 
    0.03512107f, 0.02383574f, -0.20943913f, -0.05543615f, -0.08669433f, -0.01984546f, -0.06603035f, 0.00216882f, 
    0.00833992f, -0.09057215f, -0.04818151f, 0.00520870f, -0.08392332f, -0.03857619f, 0.04088371f, -0.09420181f, 
    -0.02866025f, 0.03267938f, -0.07549008f, 0.02724410f, 0.17418188f, 0.10171041f, -0.15255804f, 0.07178503f, 
    -0.14394526f, -0.06700543f, 0.06703269f, -0.04562715f, -0.02491212f, -0.02094589f, -0.04551834f, -0.01321810f, 
    -0.05797955f, 0.01485817f, 0.04339524f, -0.01290497f, -0.00164326f, 0.04776977f, -0.04729507f, 0.03692165f, 
    -0.01666140f, 0.13063057f, 0.06216270f, 0.16033560f, 0.00727999f, -0.02106341f, 0.01542754f, -0.01184774f, 
    -0.02356614f, 0.06947733f, -0.03728783f, -0.02777133f, 0.00980622f, -0.07048165f, -0.04958891f, -0.04286488f, 
    0.01069462f, 0.05739526f, 0.02218851f, -0.07610272f, 0.03798804f, 0.01572831f, -0.09062420f, -0.02544707f, 
    -0.11917849f, 0.01329929f, -0.03704767f, 0.07084390f, -0.07522426f, 0.01378200f, -0.04140465f, 0.02617459f, 
    -0.00431329f, 0.05701966f, 0.01992851f, 0.04160991f, -0.04077816f, 0.00660540f, -0.01277412f, -0.01016863f, 
    -0.28653562f, 0.28305724f, 0.00221634f, -0.09182517f, -0.08043953f, -0.00120974f, -0.02602088f, 0.00409184f, 
    0.02002176f, -0.04349235f, 0.04445323f, 0.01337715f, -0.04185087f, 0.02445060f, -0.06516577f, -0.00435796f, 
    -0.05063076f, -0.06938259f, 0.08011823f, 0.00013379f, -0.28945318f, 0.03244369f, -0.07868106f, 0.05217907f, 
    0.10482529f, 0.04329975f, -0.01198055f, 0.00866290f, 0.01572154f, -0.02709419f, -0.03905028f, -0.00919290f, 
    0.07596666f, -0.03162185f, 0.08181997f, -0.02821496f, 0.03103312f, -0.04520374f, -0.02815504f, 0.03977582f, 
    -0.33322075f, 0.40836272f, 0.07291674f, 0.08194546f, -0.00268070f, 0.04012474f, 0.05287897f, -0.00116270f, 
    0.01573521f, -0.06610933f, -0.00169765f, -0.02876849f, -0.03407250f, 0.05435589f, -0.10045968f, -0.05887155f, 
    -0.03218742f, -0.13037562f, 0.05568477f, -0.00981179f, 0.04428961f, -0.01475648f, -0.15326357f, -0.01562621f, 
    -0.11147992f, -0.00513219f, -0.05447744f, 0.04013765f, -0.01177814f, 0.04431589f, -0.08281845f, -0.06800284f, 
    0.13780795f, -0.06038212f, 0.06100063f, 0.06680096f, -0.07674973f, 0.06620252f, -0.01540102f, 0.06985200f, 
    -0.04941580f, -0.04308321f, 0.08409391f, -0.02493447f, -0.05368306f, 0.00343245f, -0.05581390f, 0.03502613f, 
    0.01512667f, 0.00462244f, -0.03018937f, 0.01587442f, -0.00979343f, 0.00155590f, 0.01771777f, 0.01928375f, 
    -0.00763606f, 0.04025063f, 0.03015366f, -0.00113704f, -0.17319804f, 0.13723534f, -0.01301071f, -0.08252761f, 
    -0.01108242f, 0.01616937f, 0.06997654f, 0.00738673f, -0.01749641f, -0.01311793f, 0.03133776f, 0.01483055f, 
    -0.08608962f, -0.01738989f, 0.00593962f, -0.02201281f, 0.03179546f, -0.04119858f, 0.07073431f, -0.06060192f, 
    -0.06821233f, -0.12938242f, 0.08040498f, 0.08308849f, -0.00662963f, -0.02844678f, -0.04287268f, 0.02007012f, 
    0.02606415f, -0.00898359f, -0.02104703f, -0.05427909f, -0.00768557f, 0.03910213f, 0.06823581f, -0.00948566f, 
    0.02216816f, -0.16071053f, -0.04080541f, -0.12887347f, 0.10064567f, 0.04058650f, 0.12712276f, 0.14671418f, 
    0.05536101f, -0.01628110f, 0.07020988f, -0.00052650f, -0.04844179f, -0.04122584f, -0.08616444f, -0.02341524f, 
    -0.05671871f, -0.04749396f, 0.03785888f, -0.03259625f, 0.06516971f, 0.02205009f, 0.07912426f, -0.06979527f, 
    -0.20295329f, 0.18106297f, 0.04755268f, 0.04015131f, 0.05907288f, 0.01377078f, -0.00260833f, -0.00090748f, 
    0.03927580f, -0.01119560f, 0.00255406f, 0.00630481f, -0.00748954f, 0.01649589f, -0.04436509f, 0.05410352f, 
    0.00464189f, 0.03332046f, -0.00168628f, 0.00086567f, -0.15142830f, -0.23690599f, -0.00713519f, 0.00329740f, 
    0.06779116f, -0.02619619f, -0.01680013f, 0.04023021f, 0.05937715f, -0.05413694f, 0.03602149f, 0.09073003f, 
    -0.06152954f, 0.03740139f, 0.03261182f, 0.05886509f, 0.01637828f, -0.03761388f, 0.02801572f, 0.01689368f, 
    0.03069902f, -0.01246526f, 0.05956260f, 0.04056804f, -0.10535678f, -0.07305054f, -0.02732613f, 0.07673278f, 
    -0.07696018f, -0.02252140f, -0.06678487f, -0.02970774f, -0.03522388f, -0.01611247f, 0.09242953f, 0.00423073f, 
    0.04673664f, 0.08153890f, -0.04761816f, 0.03769904f, 0.16175386f, 0.08361719f, -0.14674658f, -0.06887167f, 
    0.02459199f, -0.02386325f, 0.02776448f, 0.02781793f, 0.06665333f, 0.05004185f, 0.06979299f, -0.06024350f, 
    -0.03230458f, -0.08446009f, -0.08251043f, -0.03734382f, 0.04006479f, 0.04074160f, 0.01668741f, -0.02149382f, 
    -0.05147424f, -0.06960589f, -0.13332701f, -0.07240766f, 0.02338122f, -0.06199316f, 0.01864962f, -0.03455845f, 
    0.00714590f, -0.03593949f, 0.00549268f, -0.01248215f, 0.03504761f, 0.02705250f, -0.00078441f, -0.03960440f, 
    0.03416420f, -0.04610473f, 0.00700977f, -0.06242608f, 0.05180821f, -0.19492538f, -0.00676655f, 0.00894705f, 
    -0.13244037f, -0.00801446f, -0.02648901f, 0.01228708f, -0.02893943f, 0.06076977f, -0.04715040f, 0.05131425f, 
    -0.05837465f, 0.07166118f, 0.01876932f, 0.00505037f, -0.02804351f, 0.01246442f, -0.02927657f, 0.01835697f, 
    -0.34835109f, -0.12043876f, -0.18364112f, -0.09855351f, -0.04936507f, -0.07393766f, 0.04150900f, -0.03941371f, 
    0.01027618f, -0.02625148f, -0.05798227f, 0.01262076f, 0.09032653f, 0.01616518f, 0.00231335f, -0.03643481f, 
    -0.09259370f, -0.07903678f, 0.02073111f, 0.05706237f, -0.05585355f, -0.00553025f, -0.02403686f, 0.12797399f, 
    0.03262623f, -0.03782698f, 0.02579525f, 0.02509364f, 0.00350705f, 0.10173637f, -0.05224302f, 0.01626602f, 
    -0.01707079f, 0.04615361f, 0.05002436f, 0.03652454f, -0.01201918f, 0.00372437f, -0.04484352f, 0.04212857f, 
    0.06350110f, 0.02491339f, -0.10952226f, 0.02133635f, -0.00778888f, -0.00020634f, 0.01006652f, -0.00717822f, 
    0.00527010f, 0.08097268f, -0.03734005f, -0.08220191f, -0.03186975f, 0.06700771f, -0.04500274f, -0.07506733f, 
    -0.00532080f, 0.00119572f, -0.01104577f, 0.06485590f, -0.25828269f, 0.10409617f, -0.13003097f, 0.12761411f, 
    0.05720398f, 0.01517084f, -0.02734340f, 0.08530233f, 0.01056869f, -0.02697432f, 0.01738896f, -0.02015847f, 
    -0.02956060f, 0.02006549f, -0.01173699f, 0.02668266f, -0.05716343f, 0.04253110f, 0.03478628f, -0.08986750f, 
    -0.10235336f, 0.16943614f, -0.01658841f, 0.09052216f, 0.01831112f, 0.03069067f, -0.01049912f, -0.04125011f, 
    0.08640160f, -0.05589977f, -0.01884840f, 0.03860420f, -0.04137609f, -0.02310534f, 0.05004402f, -0.01052092f, 
    0.01968343f, -0.07106793f, -0.01061030f, 0.01975899f, -0.23954462f, -0.44131771f, -0.06636230f, -0.08579333f, 
    -0.15640418f, -0.10828295f, -0.10981911f, -0.03571950f, 0.05582429f, -0.00976704f, -0.04652100f, -0.06100332f, 
    0.07171687f, -0.00215711f, 0.02431997f, 0.08114661f, -0.01724387f, -0.06244504f, -0.02025735f, 0.04998801f, 
    0.06688003f, 0.00004290f, -0.14063236f, 0.18193115f, -0.14033532f, -0.06615102f, -0.01972760f, 0.07192061f, 
    0.02566820f, -0.08788184f, 0.04250933f, 0.06734814f, 0.06141808f, -0.04215968f, 0.06318996f, 0.02441740f, 
    0.06020776f, 0.03266982f, 0.02723800f, 0.12323556f, 0.23199560f, 0.05060381f, -0.16005389f, -0.01051927f, 
    0.09232740f, -0.00342063f, 0.00561967f, 0.01340769f, 0.02263702f, 0.02192136f, 0.01252682f, -0.03264832f, 
    0.12857129f, -0.03838821f, 0.03558961f, 0.11264281f, -0.01654891f, -0.12092441f, 0.08021595f, -0.01691544f, 
    0.10249107f, -0.18185402f, -0.09248647f, 0.10607231f, -0.07059050f, -0.18133985f, -0.05048451f, -0.07651959f, 
    -0.16910198f, -0.02059172f, -0.01832445f, 0.09322281f, 0.04452372f, -0.03198204f, 0.02139042f, -0.11184722f, 
    0.09118959f, 0.10101143f, -0.02924957f, -0.00111651f, -0.16749334f, -0.07253807f, 0.14962018f, 0.11390731f, 
    -0.03530519f, -0.07393169f, 0.03513329f, 0.03703842f, -0.05809078f, 0.05431535f, 0.03570886f, -0.02744809f, 
    -0.05017023f, -0.08057284f, -0.03415431f, -0.02264310f, 0.01494021f, 0.02465622f, 0.01013468f, 0.06134250f, 
    0.18203211f, -0.15120447f, -0.09227096f, 0.07602017f, -0.16235882f, 0.03236960f, -0.00419580f, 0.02935095f, 
    -0.02220492f, 0.01736502f, -0.03336606f, 0.05517288f, 0.04087428f, -0.05568269f, -0.00330007f, 0.00770441f, 
    -0.05678057f, -0.04276041f, 0.01207857f, -0.04714363f, 0.01808873f, 0.08731541f, -0.04442656f, 0.02846262f, 
    -0.21720715f, -0.03906968f, 0.02590844f, -0.00073906f, -0.01162504f, -0.01930882f, -0.05124658f, -0.09066374f, 
    0.03901298f, 0.01731073f, 0.05786641f, -0.07641666f, -0.04516112f, 0.02620458f, -0.07407391f, 0.02476646f, 
    -0.16592789f, -0.14604476f, 0.10714136f, 0.15466268f, 0.05528777f, -0.03905572f, 0.03559434f, 0.00473930f, 
    -0.11714980f, -0.10189352f, 0.01015568f, -0.03401519f, -0.05540754f, -0.03233322f, 0.03989499f, -0.05447992f, 
    -0.08219048f, 0.05759404f, 0.03160813f, -0.03651704f, -0.10900471f, -0.08157983f, 0.16808577f, 0.01351253f, 
    0.01637238f, -0.03761336f, 0.00788834f, -0.05174530f, -0.06706352f, 0.08452252f, 0.04931182f, -0.02697411f, 
    -0.05333326f, -0.06617648f, -0.03393477f, -0.00550352f, -0.06276125f, -0.03327592f, -0.00880287f, -0.00136674f, 
    0.09933215f, -0.04797002f, -0.11418002f, 0.14573132f, -0.02719005f, 0.01270183f, -0.05375011f, -0.02723670f, 
    -0.02057935f, 0.02649748f, -0.13286509f, -0.05017355f, 0.06378967f, -0.07400044f, -0.05521350f, -0.02146186f, 
    0.01201237f, -0.09657566f, 0.01704030f, 0.06894203f, -0.03593895f, -0.11850437f, -0.08206455f, 0.03568531f, 
    -0.04061038f, 0.09530046f, 0.02558109f, 0.09964614f, 0.01844494f, 0.04115302f, 0.01783699f, -0.02289058f, 
    0.01742667f, -0.01830213f, 0.00860797f, 0.00525184f, 0.08912330f, -0.04764750f, 0.08919875f, 0.05551122f, 
    0.08468452f, -0.12057023f, 0.13022873f, 0.10302413f, 0.02462714f, 0.01012274f, 0.09790255f, -0.04612451f, 
    -0.03170320f, -0.02528996f, 0.06909794f, 0.03693360f, -0.02796902f, 0.02712986f, -0.01232201f, -0.00895338f, 
    -0.07554171f, 0.07004558f, 0.08103441f, 0.02271485f, 0.01134482f, 0.00817965f, 0.07191580f, -0.07238108f, 
    -0.00649854f, 0.01493772f, 0.02693433f, -0.00581812f, 0.05314434f, -0.05643275f, 0.02297618f, -0.07773695f, 
    0.03606082f, -0.05540560f, 0.09678825f, 0.00692429f, -0.06652455f, -0.00041987f, -0.06174610f, 0.04111753f, 
    0.06482332f, 0.51331455f, -0.22205524f, -0.55113155f, -0.06948806f, 0.04504061f, -0.00032796f, -0.02232159f, 
    0.02864791f, -0.05967598f, -0.03526324f, -0.09725526f, -0.14083248f, 0.05626525f, 0.01154484f, -0.04899821f, 
    -0.04570463f, -0.04234565f, -0.04427212f, 0.00045145f, 0.21876438f, 0.14463587f, 0.12777618f, -0.04265477f, 
    -0.15953378f, -0.18165728f, -0.01983559f, -0.03032586f, 0.00601308f, -0.02527823f, 0.03245810f, -0.04311090f, 
    0.04025614f, 0.05581954f, 0.10230452f, -0.10080674f, 0.00247169f, 0.09314059f, 0.06350637f, 0.05992964f, 
    -0.35609099f, 0.13283411f, -0.02734146f, -0.17839073f, -0.04663024f, 0.04728283f, 0.00337238f, -0.03087057f, 
    -0.02839586f, -0.01078235f, 0.04085593f, -0.07838059f, 0.04254520f, 0.02423152f, -0.00077809f, 0.00555809f, 
    0.02826581f, -0.08819072f, -0.03739935f, -0.03958535f, -0.37569502f, 0.03479863f, -0.08575934f, 0.04067201f, 
    0.19165252f, 0.01878850f, 0.02827721f, 0.00224025f, 0.05011341f, 0.07789192f, 0.00297316f, -0.06826092f, 
    -0.02833947f, 0.02529558f, 0.02301341f, 0.01352204f, 0.04261990f, -0.07336447f, 0.04885880f, -0.03532983f, 
    -0.01837986f, 0.05054068f, 0.18360099f, 0.01738815f, -0.08578406f, 0.06178516f, -0.00947396f, 0.08858758f, 
    -0.05294638f, -0.10020791f, 0.03473691f, -0.03771218f, -0.05623369f, -0.02425239f, 0.09230685f, 0.00571847f, 
    0.00499323f, 0.01741484f, -0.05185632f, -0.06255052f, -0.11810569f, -0.06566610f, -0.01304296f, 0.10969995f, 
    0.14059666f, 0.13367686f, -0.06663242f, -0.03315940f, 0.05916270f, 0.09292886f, -0.05104458f, -0.06436896f, 
    0.03701706f, -0.02008097f, 0.02297317f, 0.05185155f, 0.04111082f, -0.00977500f, 0.08411068f, -0.06499758f, 
    0.26368615f, -0.15742597f, -0.02210499f, -0.17126858f, -0.10093095f, 0.01749810f, -0.08521749f, -0.00194569f, 
    -0.07432535f, 0.00756014f, -0.00083612f, 0.02807410f, 0.00554151f, -0.06500293f, -0.02648849f, 0.07241011f, 
    0.01802489f, -0.00670384f, -0.01825643f, -0.05728437f, 0.13268220f, 0.38911104f, -0.11996813f, -0.18959253f, 
    -0.11592588f, -0.04412862f, 0.08415782f, 0.05469935f, 0.04111021f, 0.04119489f, -0.05679545f, 0.08782659f, 
    -0.08130263f, 0.00872515f, 0.00918193f, -0.15773034f, 0.10757390f, 0.03947274f, -0.02880369f, 0.03970553f, 
    0.17391104f, -0.16976680f, -0.11349621f, 0.11514440f, 0.07919390f, 0.02077383f, 0.05708246f, 0.04077892f, 
    -0.01602412f, -0.01639898f, 0.03510382f, -0.07722723f, 0.18046203f, 0.14463398f, -0.06888198f, -0.05611828f, 
    -0.03006131f, -0.10707834f, 0.07010446f, -0.04053534f, -0.04380091f, 0.01418508f, -0.03930074f, 0.20092544f, 
    -0.22411931f, -0.10942991f, -0.04103810f, 0.03196889f, 0.00799066f, -0.12158968f, 0.07867990f, -0.06606223f, 
    0.00951137f, 0.05571942f, -0.00212118f, 0.01505800f, 0.08942249f, 0.08151746f, -0.00895604f, 0.09868011f, 
    0.04673763f, -0.25847968f, 0.10881568f, 0.10050184f, -0.04069658f, -0.06796749f, 0.05294150f, 0.07943051f, 
    -0.07959575f, -0.04187653f, -0.00718181f, 0.02968693f, 0.02362336f, -0.05931015f, 0.07584266f, -0.13312589f, 
    -0.01306865f, -0.02431275f, 0.00505346f, -0.07398551f, -0.51546597f, 0.07995747f, 0.03479225f, 0.05809583f, 
    0.13038868f, 0.06039160f, -0.00047724f, 0.03555362f, 0.00546513f, 0.07646225f, -0.04674442f, 0.04107018f, 
    -0.01934769f, 0.08111811f, 0.02439071f, 0.06805438f, 0.04459687f, 0.09925793f, 0.01551622f, -0.11633742f, 
    -0.06411893f, -0.27184129f, 0.10793409f, 0.14069289f, 0.04009394f, -0.12020663f, 0.03564686f, 0.01046455f, 
    -0.06253342f, 0.02552210f, 0.03638019f, 0.06514994f, 0.02124898f, -0.14278309f, -0.02563474f, -0.02877072f, 
    0.06977190f, -0.06675435f, 0.02828380f, 0.00631307f, -0.24561812f, -0.04572606f, 0.10085027f, 0.06400333f, 
    0.05066207f, -0.05312978f, -0.02750181f, -0.02746844f, 0.09111627f, 0.04670103f, 0.03835238f, 0.02043813f, 
    0.01419190f, 0.02878910f, -0.02192332f, -0.05705389f, 0.03899888f, -0.04749312f, 0.01751992f, -0.01426065f, 
    0.30274814f, -0.11219615f, 0.02796373f, -0.07747980f, 0.11036208f, -0.11892062f, -0.08737943f, 0.08736391f, 
    0.00372486f, -0.01789748f, 0.03018622f, -0.00749768f, 0.10291839f, -0.03514999f, -0.01840201f, -0.06490099f, 
    -0.07583372f, -0.04703592f, -0.01966837f, 0.07970379f, -0.07698985f, 0.13081886f, 0.08178508f, -0.01153294f, 
    0.06111248f, 0.06630082f, 0.04429461f, -0.08204901f, 0.01425969f, 0.01001108f, 0.03158782f, -0.08069904f, 
    -0.01063909f, 0.10620122f, -0.07942591f, -0.07453528f, 0.06433126f, 0.01274333f, -0.05730847f, -0.03830888f, 
    -0.28955171f, -0.00638052f, -0.06231519f, -0.12774318f, 0.04585035f, 0.02745037f, -0.05482029f, -0.01621698f, 
    0.05788760f, 0.09322343f, 0.02040690f, -0.00766385f, 0.03548156f, 0.02339886f, -0.03500252f, -0.02748921f, 
    0.10525282f, 0.02573498f, 0.05313921f, -0.02630756f, 0.01868517f, 0.10130422f, 0.12187786f, -0.07140880f, 
    -0.02886538f, 0.04120826f, 0.04849003f, -0.02447508f, -0.03796330f, -0.01459297f, 0.12068029f, 0.02512723f, 
    0.06913935f, 0.02265355f, -0.02727016f, 0.06980272f, 0.00479277f, -0.01715993f, 0.03499223f, 0.02013772f, 
    -0.03218654f, -0.08360365f, 0.08695986f, 0.17900978f, -0.10680778f, -0.05657116f, 0.03119813f, 0.00434066f, 
    -0.03477718f, 0.01264616f, 0.06973217f, 0.09167890f, -0.03056637f, -0.04679684f, 0.00120518f, -0.01899223f, 
    0.12029213f, -0.00948793f, 0.02343176f, 0.09341259f, 0.03834293f, -0.02347714f, 0.18148902f, 0.07623243f, 
    -0.01314212f, 0.07454553f, 0.05478244f, -0.08433484f, 0.12393156f, 0.02908964f, 0.14761357f, 0.04579151f, 
    0.04569409f, 0.03340364f, 0.05508542f, 0.07034513f, -0.03093760f, -0.04919610f, 0.06066960f, 0.11240715f, 
    -0.03496674f, -0.04133540f, -0.10215387f, 0.10411713f, -0.05718485f, 0.10810769f, -0.03430604f, 0.07677623f, 
    -0.03062684f, 0.02169349f, 0.00289834f, -0.02332110f, 0.01747067f, -0.00489731f, 0.00943900f, 0.04032502f, 
    0.00244570f, -0.04706204f, -0.06054617f, -0.05057170f, 0.16121930f, -0.23524529f, -0.08872508f, 0.08207509f, 
    -0.15186439f, -0.15711190f, 0.06159691f, 0.27608326f, -0.07620485f, -0.06496962f, -0.01361348f, -0.11527158f, 
    0.06166472f, -0.03128769f, 0.08132070f, 0.02985536f, -0.05444290f, 0.04358640f, -0.06902675f, -0.00046376f, 
    -0.24895811f, 0.13431102f, -0.03705242f, -0.08105606f, -0.14514409f, 0.03715524f, 0.00714679f, 0.04169554f, 
    0.01994899f, -0.08545483f, -0.09867309f, -0.00224726f, 0.00406412f, -0.05665038f, -0.02928660f, -0.00145383f, 
    -0.02814910f, 0.01502301f, 0.02785171f, 0.00185174f, -0.06297976f, 0.04870395f, 0.02770439f, 0.10717101f, 
    0.10502332f, 0.01862072f, 0.05512192f, -0.03566745f, 0.05349305f, 0.06595873f, 0.01343243f, -0.01537010f, 
    -0.04289241f, -0.01017649f, -0.03621489f, 0.00355080f, -0.00699580f, -0.00525588f, 0.05770740f, -0.09800012f, 
    -0.26103386f, -0.03027979f, 0.15283825f, 0.02639495f, -0.08297812f, 0.03822920f, 0.05462084f, 0.00116518f, 
    -0.08545686f, -0.05627716f, 0.05542196f, -0.02659386f, -0.01991206f, 0.02273383f, 0.04597766f, -0.03892098f, 
    0.03880728f, -0.06278777f, -0.01317447f, -0.05311887f, 0.23984601f, 0.08938391f, -0.11426552f, 0.08056629f, 
    0.08790021f, 0.02711068f, -0.03062787f, 0.11812913f, 0.05760651f, 0.01097724f, -0.03524300f, -0.04950570f, 
    0.05127005f, 0.04867325f, 0.05325653f, -0.09045950f, 0.03188924f, -0.10030596f, -0.03814540f, -0.03582357f, 
    -0.17086272f, -0.37820914f, -0.07603467f, -0.04132119f, 0.10675308f, -0.09282577f, -0.02282004f, 0.01925382f, 
    -0.09358858f, 0.08629519f, 0.03477012f, 0.05357879f, -0.04290775f, -0.04858230f, -0.01669637f, 0.05841441f, 
    -0.15708244f, -0.10443988f, -0.00994144f, -0.07270055f, -0.56097287f, -0.16010879f, -0.10024150f, 0.09105056f, 
    0.18097916f, -0.04038507f, -0.00252842f, 0.03792518f, 0.04358162f, 0.07812881f, -0.02307389f, -0.11481020f, 
    0.13553321f, 0.03880394f, -0.00455603f, 0.01403221f, 0.10313055f, 0.03071311f, 0.11920410f, -0.00269575f, 
    -0.34441224f, -0.19706717f, -0.02791209f, 0.12855379f, 0.00269021f, 0.02618005f, -0.00107373f, 0.05006451f, 
    0.00855786f, 0.02508702f, 0.05705286f, -0.03866401f, 0.00558828f, 0.03413112f, -0.03400976f, 0.01774397f, 
    -0.03879964f, 0.08851018f, 0.12686448f, 0.15047565f, -0.23084059f, 0.09174658f, -0.22690444f, 0.18501502f, 
    0.03526720f, 0.04784797f, -0.05354538f, 0.06979093f, 0.04268078f, 0.07864684f, 0.02538288f, -0.00159374f, 
    -0.06644091f, -0.07301799f, -0.00960481f, -0.05025803f, -0.02641728f, 0.07211733f, 0.01088406f, 0.07375891f, 
    -0.07768503f, -0.07089750f, 0.05867240f, 0.15067689f, 0.03963617f, 0.08412082f, 0.04250261f, -0.00876805f, 
    0.04726604f, 0.04005453f, 0.09459402f, 0.06806798f, -0.05197202f, -0.04731495f, 0.01049035f, -0.09566994f, 
    -0.05873799f, 0.07259739f, 0.04365350f, 0.00723165f, -0.42642608f, 0.01888127f, 0.07023451f, 0.10430623f, 
    -0.05219159f, -0.00939949f, -0.07659524f, 0.00093521f, 0.05889975f, -0.06559569f, -0.04698623f, -0.03670898f, 
    -0.02605859f, 0.05665363f, 0.03030910f, -0.01723855f, -0.03563517f, 0.14786641f, 0.08093371f, 0.10287259f, 
    -0.04356483f, -0.03103272f, 0.00757334f, -0.03185187f, 0.10480516f, 0.08121057f, 0.00125345f, 0.07884651f, 
    -0.06604309f, -0.06087474f, 0.01196796f, -0.02435782f, 0.04957418f, 0.03437042f, -0.04222870f, -0.01686192f, 
    0.04971620f, -0.10283563f, 0.06321125f, -0.04213430f, -0.19248542f, 0.07389365f, 0.04336288f, -0.01775207f, 
    -0.00640728f, -0.02242890f, 0.05174519f, 0.04365573f, 0.01051112f, 0.02405619f, 0.03606214f, 0.01327222f, 
    -0.04633227f, -0.01970371f, 0.05277011f, -0.02112832f, 0.09346780f, -0.11671459f, 0.03689762f, 0.03290068f, 
    -0.41525248f, 0.07460173f, 0.08230464f, -0.00657515f, 0.12110724f, 0.06917989f, -0.09711286f, -0.01052217f, 
    -0.00743141f, -0.04685396f, -0.05083817f, 0.06165434f, -0.04753879f, 0.01881121f, 0.06671714f, 0.04581369f, 
    0.02362598f, -0.10642702f, 0.05957847f, -0.08287043f, -0.62109476f, 0.07415718f, -0.05311307f, 0.17611271f, 
    0.12590286f, 0.05378165f, -0.07006554f, 0.07827803f, 0.03817476f, 0.12316703f, 0.01952586f, -0.00650387f, 
    -0.05370497f, -0.00060936f, 0.02491863f, -0.00271527f, -0.06052136f, -0.02586909f, 0.09387231f, 0.01742771f, 
    -0.08883495f, -0.01717972f, 0.03595829f, 0.06555015f, 0.14258914f, -0.03076790f, 0.04639261f, 0.00869158f, 
    0.04705538f, 0.05699257f, -0.07848845f, -0.13723961f, 0.05054692f, 0.08601841f, -0.00860648f, -0.05221977f, 
    0.02657982f, -0.00509544f, -0.05001485f, -0.10938848f, 0.06314423f, -0.03457811f, -0.12490442f, -0.01603978f, 
    -0.09668411f, -0.00450221f, 0.00780606f, 0.05102646f, -0.03681380f, -0.04872327f, 0.00240303f, -0.00401592f, 
    -0.12410940f, 0.02752785f, 0.00597777f, 0.01348663f, -0.01872004f, 0.04234947f, -0.14409885f, 0.07410946f, 
    -0.24248293f, 0.09642497f, 0.00701718f, -0.02452309f, -0.00401031f, 0.02998627f, 0.04504900f, 0.07686149f, 
    -0.06533816f, -0.05434542f, -0.04243745f, 0.10888635f, 0.02251232f, -0.01829804f, -0.06005427f, -0.06039033f, 
    -0.12009665f, 0.07755913f, -0.13169819f, -0.02791933f, 0.01771209f, -0.15561485f, -0.03815162f, 0.05173840f, 
    0.08236133f, 0.09076755f, -0.07335865f, 0.00528121f, -0.02507539f, -0.03166805f, 0.05865370f, 0.07367288f, 
    -0.07057781f, -0.03316697f, 0.03395781f, -0.02563490f, 0.08506066f, -0.02479260f, 0.01619258f, -0.00502761f, 
    0.03539662f, 0.00642216f, 0.05328551f, 0.10742564f, -0.01338896f, 0.03573618f, 0.02785968f, 0.06602961f, 
    -0.06843236f, -0.04826987f, 0.00210739f, 0.03828130f, -0.03750756f, 0.01659952f, 0.01289862f, 0.02174058f, 
    -0.05649387f, -0.14790556f, -0.06460800f, -0.03007704f, 0.20909806f, 0.06104697f, -0.06249885f, -0.05751291f, 
    0.05582270f, -0.07070393f, -0.03825985f, 0.02258170f, 0.06653532f, 0.01249934f, -0.06933701f, 0.03299425f, 
    -0.02918646f, 0.00358387f, -0.04077959f, 0.01432598f, -0.01578996f, -0.05947199f, -0.00488361f, 0.00833139f, 
    0.16117527f, 0.04827792f, -0.14798985f, 0.01396107f, 0.07048814f, 0.11204121f, 0.01559549f, 0.04613954f, 
    -0.04712405f, -0.04479290f, -0.02617760f, 0.04942464f, -0.04278152f, -0.02395549f, -0.03298463f, -0.13218872f, 
    -0.11815264f, -0.02204279f, -0.02426730f, -0.09574260f, 0.13585991f, -0.14004681f, -0.12392442f, -0.02382528f, 
    -0.12716332f, 0.02348533f, -0.01536937f, -0.02478969f, -0.14605600f, -0.13215770f, -0.03345010f, 0.02827995f, 
    -0.02788286f, -0.05733490f, 0.00602815f, -0.05872811f, 0.04593607f, -0.04609661f, -0.04041030f, -0.08934297f, 
    0.01966422f, -0.10323281f, 0.04561251f, 0.08193645f, -0.17564212f, -0.01888867f, -0.00460825f, 0.00056721f, 
    -0.04578020f, 0.01756572f, 0.03059178f, -0.02851141f, 0.03516792f, 0.02356512f, -0.07177575f, 0.06604937f, 
    -0.00551564f, -0.00842640f, -0.04578568f, 0.06177368f, 0.27740282f, 0.04305501f, 0.01420995f, -0.13400103f, 
    -0.11990439f, -0.02282381f, 0.00199776f, -0.02032542f, -0.06248033f, -0.01276297f, -0.02298695f, -0.02597909f, 
    0.08527972f, 0.01486673f, 0.02677742f, 0.02095166f, -0.03606843f, 0.02495826f, -0.01059316f, -0.09383019f, 
    0.02726678f, 0.08169936f, 0.18912140f, -0.08809333f, 0.00785480f, -0.02641698f, 0.04593979f, 0.01017141f, 
    0.02112166f, 0.08235441f, 0.07735490f, -0.05355973f, 0.01520604f, -0.04001841f, 0.01766234f, 0.06819898f, 
    0.04626716f, -0.01419269f, -0.01157364f, 0.02676908f, -0.12192218f, -0.07136366f, -0.21016188f, 0.11814310f, 
    -0.16881697f, 0.07483852f, -0.03478253f, 0.12028467f, -0.16821840f, 0.06850504f, 0.05586712f, 0.02071278f, 
    -0.03784913f, 0.01447633f, 0.02798941f, 0.01826134f, -0.00223835f, -0.00157199f, -0.17715181f, -0.04351242f, 
    0.02320892f, -0.15222046f, -0.11489435f, 0.12722172f, -0.05854969f, 0.08675674f, -0.01943651f, 0.10632300f, 
    -0.00843350f, 0.06425887f, -0.04766658f, -0.03578201f, 0.01093401f, -0.04483135f, 0.07946416f, -0.00610803f, 
    0.01429295f, -0.04303879f, 0.10688185f, 0.05647719f, -0.18451172f, -0.11217940f, 0.11012320f, -0.02107275f, 
    0.00387073f, 0.03792399f, 0.01372843f, -0.08706206f, -0.00115986f, -0.02223375f, -0.00056071f, 0.07001780f, 
    0.02431678f, -0.02926834f, -0.03718424f, -0.05428846f, -0.06070682f, -0.03543374f, -0.03547287f, -0.04254667f, 
    -0.54966235f, 0.15013747f, 0.00922933f, -0.29265469f, -0.05337509f, 0.00586410f, 0.04632716f, 0.01828706f, 
    -0.03920340f, 0.04801162f, -0.04648793f, -0.03753071f, 0.09152060f, -0.04358135f, 0.00825285f, 0.00617307f, 
    0.05446854f, 0.03671548f, 0.01912132f, -0.11902300f, 0.01482237f, -0.02575613f, -0.04829329f, 0.06417444f, 
    0.07750298f, 0.04144039f, -0.07234766f, -0.01842637f, 0.09652530f, 0.02985880f, -0.03028776f, -0.01409997f, 
    0.04696343f, -0.01201357f, 0.05664247f, 0.02014711f, 0.03126952f, -0.03676654f, 0.00390414f, -0.03363892f, 
    0.04493204f, 0.04294758f, 0.02612859f, -0.15297188f, -0.07426326f, 0.07800393f, 0.01132720f, -0.05258728f, 
    0.02842939f, 0.13741553f, -0.00769673f, 0.06685156f, -0.03465177f, 0.09216943f, -0.10947431f, -0.07163487f, 
    -0.05645356f, -0.01895664f, -0.08710027f, -0.03384032f, -0.16125982f, -0.03113707f, 0.19559176f, 0.09476503f, 
    -0.17534301f, 0.06911460f, 0.03263061f, -0.04548899f, 0.07271717f, -0.02976517f, 0.03979672f, 0.01678484f, 
    -0.07308239f, 0.07466532f, 0.01815653f, -0.03279379f, 0.04108988f, 0.13009943f, -0.00947663f, 0.02465442f, 
    0.00298843f, 0.11176524f, 0.04701279f, 0.03236670f, 0.02651363f, -0.07862628f, -0.07078125f, -0.04409818f, 
    -0.00053423f, 0.08722252f, -0.02272159f, -0.13069965f, -0.08107766f, -0.00525472f, 0.03133910f, 0.10684890f, 
    -0.01443845f, -0.11880856f, -0.06939057f, 0.05939576f, 0.03765087f, 0.00319367f, 0.05381923f, 0.07956312f, 
    0.19334404f, -0.07460281f, -0.04188556f, 0.03913834f, 0.06021528f, 0.03183068f, -0.06840415f, -0.07156568f, 
    0.03400152f, 0.10316443f, 0.02189941f, 0.02001454f, -0.05073131f, -0.09016798f, -0.03231485f, 0.00899402f, 
    0.03663417f, 0.06932805f, 0.07325519f, -0.08759852f, -0.04956813f, 0.02810593f, 0.05219128f, -0.01738610f, 
    -0.10011441f, 0.08518934f, -0.02586135f, -0.04366623f, -0.00970009f, -0.01350506f, -0.10155218f, 0.01183255f, 
    -0.00491232f, -0.01501207f, 0.06298600f, 0.09276464f, 0.01276133f, 0.12162211f, 0.01004365f, 0.05853555f, 
    0.11010315f, 0.01146635f, -0.02106893f, 0.04240805f, 0.02544145f, 0.05748100f, 0.14224032f, 0.02071898f, 
    -0.05307944f, -0.01643663f, -0.06001591f, -0.02561254f, 0.03995964f, -0.16097164f, 0.12025984f, -0.02280008f, 
    0.19171701f, 0.09715615f, 0.01211945f, 0.05649702f, 0.06837463f, -0.03579437f, -0.11953194f, -0.01535127f, 
    -0.00756584f, -0.00409934f, 0.03275690f, -0.09282358f, 0.03683516f, 0.21644342f, 0.17787330f, 0.03486209f, 
    0.01607933f, 0.00004227f, -0.13625389f, -0.00871385f, 0.01480137f, -0.07214388f, -0.15148732f, 0.16161472f, 
    0.00342258f, 0.07839042f, 0.03917306f, -0.04506220f, 0.00616791f, -0.02591462f, 0.04568345f, -0.05209565f, 
    0.04351161f, 0.02972662f, 0.06274743f, -0.04699026f, 0.03386807f, 0.03223427f, 0.04063207f, -0.04724775f, 
    0.03341682f, 0.07870331f, 0.04924188f, -0.03924419f, -0.14021872f, 0.05018725f, -0.05864501f, -0.01408963f, 
    0.02573857f, 0.08637425f, 0.05408792f, -0.06268852f, -0.05392758f, -0.04661897f, -0.15240069f, 0.04600050f, 
    0.00722179f, 0.04369442f, 0.00490341f, -0.01069080f, 0.04439315f, 0.12436061f, 0.06691511f, 0.05048533f, 
    -0.14409250f, -0.01407156f, 0.02719999f, -0.02696159f, -0.00226506f, 0.02278496f, -0.00354762f, 0.01337420f, 
    0.08989225f, -0.14201610f, -0.03356651f, -0.01508501f, -0.06469170f, -0.04087858f, 0.04397871f, 0.03368394f, 
    0.16219442f, 0.07916024f, -0.05751561f, 0.06622378f, 0.22666785f, -0.00392369f, -0.15902424f, 0.01729305f, 
    0.05711947f, -0.00592434f, 0.06480327f, -0.07343534f, 0.07968315f, 0.10805698f, 0.14312308f, -0.05489886f, 
    0.07060493f, -0.01968840f, -0.10837758f, -0.09215286f, -0.31996471f, -0.18903200f, -0.13188073f, -0.03956583f, 
    0.03177633f, -0.00139103f, 0.07009394f, 0.07797044f, -0.01928352f, 0.12799466f, 0.02875137f, 0.09153915f, 
    0.06653122f, 0.06631923f, 0.02440225f, 0.06548320f, 0.04341313f, -0.06840634f, 0.00293567f, -0.02681411f, 
    -0.35760236f, -0.19074485f, 0.03075456f, 0.12773472f, -0.17705527f, 0.01296334f, 0.02743383f, -0.04554418f, 
    -0.10563567f, 0.06026725f, 0.01446065f, 0.04749920f, 0.08018234f, -0.04488923f, -0.00894564f, 0.00682151f, 
    0.09415544f, 0.01794890f, 0.01054341f, -0.02860136f, -0.06222434f, -0.01597410f, 0.09104842f, 0.12881443f, 
    -0.11891926f, -0.00250133f, -0.12563978f, -0.03659978f, 0.07102448f, -0.18574095f, -0.02477366f, -0.05920250f, 
    -0.03043243f, 0.04021463f, 0.15315935f, -0.07660074f, 0.07044788f, 0.03235075f, 0.07136586f, -0.15477152f, 
    -0.18560271f, 0.18690443f, 0.10484117f, 0.14328748f, -0.01587673f, -0.12098712f, 0.04966082f, -0.05437503f, 
    -0.03244025f, -0.02538662f, 0.03103773f, 0.01657120f, -0.03805775f, 0.04853433f, 0.00387556f, 0.00426707f, 
    -0.05030032f, 0.04137656f, 0.04884915f, -0.00265788f, -0.46087286f, -0.01166861f, -0.16248558f, -0.03113339f, 
    -0.18976155f, 0.07403363f, 0.01174367f, 0.10104237f, -0.09863675f, -0.11876746f, 0.00388554f, 0.02011756f, 
    -0.02453911f, -0.03310731f, -0.03015966f, 0.04977049f, 0.00505606f, 0.01357056f, -0.00000070f, -0.00495715f, 
    -0.16399375f, -0.19986629f, -0.05742459f, 0.14539289f, -0.04618395f, -0.10053688f, 0.05849149f, -0.00059657f, 
    -0.02772535f, 0.03363672f, 0.11470398f, 0.05891700f, 0.03702017f, 0.04475843f, -0.07253850f, -0.02283243f, 
    -0.10770866f, -0.12833919f, 0.00384337f, -0.01375521f, -0.10815827f, 0.22779644f, -0.14314355f, -0.24844368f, 
    0.08052634f, 0.06729634f, 0.19016397f, 0.04971388f, 0.04187888f, -0.03025594f, -0.03712699f, 0.01959497f, 
    -0.17907742f, -0.04632200f, 0.01216462f, -0.07175841f, -0.03179477f, 0.11158056f, -0.09877196f, -0.01226581f, 
    -0.04781489f, -0.07829859f, 0.04479814f, 0.05009215f, 0.08180764f, 0.00311568f, -0.01568949f, -0.04205864f, 
    -0.09384900f, 0.04897926f, 0.02175614f, 0.01730307f, 0.00927600f, -0.02023710f, -0.01825348f, 0.01278436f, 
    -0.00639790f, 0.01907881f, 0.08858889f, 0.03343080f, -0.27384570f, -0.18268152f, 0.26862365f, 0.23909608f, 
    -0.53005153f, -0.03533601f, -0.05110642f, 0.00860598f, -0.04102177f, -0.03503280f, -0.05246139f, 0.10921679f, 
    0.03425318f, -0.02797333f, 0.08992045f, -0.09107888f, -0.03289363f, 0.02654859f, 0.08188076f, 0.04197362f, 
    0.01483021f, 0.26341715f, 0.02246807f, -0.08239936f, -0.10159882f, 0.12583467f, -0.00143825f, 0.00931953f, 
    -0.03484325f, -0.01028410f, 0.09942240f, 0.00354971f, -0.17438999f, -0.01865734f, -0.02465242f, 0.11922506f, 
    0.01246252f, 0.15710664f, -0.04005428f, 0.00802783f, 0.03674915f, -0.09461555f, -0.15644011f, 0.12215371f, 
    0.15146363f, -0.03083873f, -0.15368445f, 0.07067102f, 0.06406821f, 0.11954268f, 0.04135987f, 0.03603150f, 
    0.08837633f, 0.02117301f, 0.04837104f, -0.09977217f, -0.04922806f, -0.12074751f, -0.03805624f, -0.10511425f, 
    -0.03248753f, 0.08833972f, -0.01751733f, 0.03719576f, -0.12276004f, -0.07215476f, 0.11313685f, 0.07425566f, 
    -0.04035573f, 0.05922834f, 0.03534317f, -0.14696282f, -0.04114921f, 0.09650427f, -0.03259164f, 0.06345222f, 
    -0.04292569f, -0.07339269f, 0.01524846f, 0.15573055f, -0.23785537f, 0.04362185f, -0.10040660f, -0.07713307f, 
    -0.01809282f, 0.01982158f, 0.04329172f, 0.05733084f, 0.00917218f, -0.15510993f, 0.04442003f, 0.03975642f, 
    0.04424467f, -0.11009256f, 0.00146371f, 0.01296820f, -0.02767346f, -0.04610781f, 0.11240805f, 0.03225724f, 
    0.06149457f, 0.08185906f, 0.08624172f, 0.02029998f, 0.11493205f, -0.00495003f, -0.07684774f, 0.03983207f, 
    -0.00467252f, 0.01993366f, -0.03022937f, -0.13631259f, 0.05273027f, 0.01648910f, 0.06540804f, -0.05611529f, 
    -0.12932989f, -0.02466530f, 0.03461875f, 0.01532702f, 0.06725131f, 0.00728113f, 0.05121727f, 0.07644558f, 
    -0.01551006f, 0.00689881f, 0.03359452f, 0.07268097f, -0.00782009f, -0.00438672f, -0.05748056f, -0.00998790f, 
    0.00027695f, 0.03778908f, 0.01224543f, 0.01033298f, -0.00167781f, 0.03061943f, 0.03445808f, 0.01841426f, 
    -0.05172150f, 0.02184762f, 0.09527896f, 0.01488626f, -0.10932857f, 0.01436094f, 0.00517123f, -0.02092805f, 
    0.02399617f, -0.02714248f, 0.00640100f, 0.08968306f, -0.03029777f, 0.01939445f, -0.04201442f, -0.13001421f, 
    -0.05692439f, 0.14375308f, -0.00636752f, -0.10583610f, -0.05990448f, -0.10033295f, 0.03888063f, 0.16636139f, 
    0.01467723f, 0.01119069f, 0.00123271f, 0.03605755f, 0.02197419f, -0.07235939f, 0.01042421f, 0.06529368f, 
    -0.04548110f, 0.03310016f, 0.13563427f, -0.04436303f, 0.00415649f, -0.02951970f, 0.07213304f, -0.13859974f, 
    -0.16782607f, -0.04048132f, -0.21066104f, -0.14515029f, -0.11812353f, 0.10538419f, -0.02634620f, 0.01159061f, 
    0.00338984f, -0.03915828f, -0.04472005f, 0.04746538f, 0.07616524f, -0.04873167f, -0.03094038f, 0.02450549f, 
    -0.10527112f, 0.01939689f, -0.06653780f, 0.01725572f, -0.01503516f, -0.03467018f, 0.08794908f, 0.01443301f, 
    -0.01376543f, -0.02145237f, 0.01024763f, -0.02962482f, 0.00092715f, 0.00337246f, -0.09672885f, 0.05256543f, 
    0.04292300f, 0.00546656f, 0.04792605f, -0.07564329f, -0.01104175f, 0.01621337f, -0.02304251f, -0.05453130f, 
    0.05055505f, 0.00442998f, -0.02844439f, 0.02435466f, 0.24243732f, -0.05538174f, -0.18218139f, 0.02618495f, 
    -0.05696991f, 0.04623423f, -0.06176338f, -0.08232987f, 0.02196305f, 0.10814266f, -0.02197819f, -0.02307464f, 
    -0.08893781f, -0.07740963f, 0.00915327f, 0.03281935f, -0.11380193f, -0.09436387f, -0.10350318f, -0.01483282f, 
    0.01710488f, 0.03893360f, 0.06754733f, -0.01388342f, -0.02103285f, 0.12965988f, -0.02367200f, 0.08777983f, 
    0.09441332f, 0.04452461f, 0.01394421f, -0.09452976f, -0.03683347f, -0.09881062f, -0.07465094f, -0.11997844f, 
    0.20785171f, 0.04931668f, 0.11897561f, -0.07652325f, -0.00247982f, -0.03649807f, 0.02545915f, -0.02179062f, 
    -0.12766959f, -0.02343230f, 0.03065653f, 0.01441780f, 0.05464231f, 0.00744141f, 0.11449241f, -0.01162175f, 
    0.04958981f, 0.01773587f, 0.04206032f, -0.00290864f, 0.02806147f, 0.11927556f, 0.05671263f, 0.07113596f, 
    0.05097801f, 0.04257055f, 0.07110260f, -0.04514607f, 0.03580169f, 0.04419995f, -0.03224961f, -0.04433912f, 
    -0.18141699f, 0.10817255f, -0.00745513f, 0.01566582f, -0.10154653f, 0.07268529f, -0.11078501f, -0.00234469f, 
    -0.31265900f, -0.11124261f, -0.04602116f, 0.06964422f, 0.08797825f, -0.00735619f, -0.06000451f, 0.01684633f, 
    0.03407564f, 0.02956144f, 0.02978574f, -0.12906049f, 0.01914641f, 0.02983719f, 0.04942036f, -0.06281766f, 
    -0.01869761f, -0.08892436f, -0.09674501f, -0.11285955f, -0.29116300f, -0.22934157f, -0.23331909f, -0.14505103f, 
    0.05810796f, 0.11051568f, 0.07434348f, 0.07694711f, 0.00837564f, -0.01262754f, -0.04089056f, 0.03675848f, 
    -0.03609365f, 0.01090856f, -0.01895749f, -0.02608855f, 0.04047637f, 0.01051772f, -0.11270680f, 0.13149887f, 
    0.04449574f, 0.07498959f, 0.02230944f, 0.07355376f, -0.10704067f, 0.00601803f, -0.04729952f, -0.01489373f, 
    0.02201932f, 0.00501918f, 0.02030274f, 0.02180705f, 0.08687045f, 0.04230408f, 0.01646710f, -0.01507476f, 
    -0.04673194f, -0.07012583f, 0.01630145f, -0.02247549f, -0.03808388f, 0.10846967f, 0.12782064f, 0.02965118f, 
    -0.26994896f, 0.02308583f, -0.00629317f, 0.01098646f, -0.04970258f, -0.06875652f, 0.12554143f, -0.04749029f, 
    -0.09065531f, -0.03206692f, -0.14044128f, -0.00807766f, 0.00491228f, 0.11109325f, 0.08124925f, -0.00134897f, 
    0.13013558f, 0.01143201f, 0.07507000f, 0.03445806f, -0.04454110f, -0.16648656f, -0.06233584f, -0.05006830f, 
    0.11574306f, 0.13355246f, 0.01692606f, -0.02053317f, -0.03700509f, 0.04652245f, 0.08080994f, -0.00646683f, 
    0.16216502f, 0.08673198f, -0.03933496f, 0.01913993f, -0.24463773f, 0.15119819f, -0.14331497f, -0.22691996f, 
    -0.06243887f, 0.12681982f, 0.08927710f, 0.12714019f, -0.05046957f, -0.05496827f, 0.03614262f, -0.00315510f, 
    -0.07046808f, -0.04620469f, 0.01380732f, 0.04061014f, -0.02174421f, 0.00912853f, 0.00817583f, -0.00747921f, 
    -0.33634678f, 0.02271753f, -0.20499675f, -0.17138761f, -0.04182657f, 0.03637360f, 0.08124523f, 0.01232859f, 
    0.04002452f, -0.06509884f, 0.02856082f, -0.06204155f, 0.10750554f, -0.11606335f, -0.02820401f, 0.01057173f, 
    0.09059150f, -0.13586351f, 0.01542963f, 0.04550581f, -0.26369557f, -0.14032447f, -0.20013009f, -0.14880754f, 
    -0.01514394f, 0.10578497f, 0.05209336f, -0.13370490f, 0.04858612f, 0.07598265f, 0.01699455f, 0.18218316f, 
    0.04724434f, -0.09595266f, -0.08315801f, -0.00909984f, -0.01765330f, -0.10195408f, -0.02294181f, -0.01869266f, 
    -0.04397899f, -0.04846058f, -0.05822643f, -0.01215715f, 0.18700114f, 0.01583360f, -0.09431092f, 0.00134211f, 
    0.02623595f, 0.10637678f, 0.02259608f, -0.02227172f, 0.06271455f, 0.16047671f, 0.10696114f, 0.06146979f, 
    0.06066402f, 0.03561782f, -0.24267226f, 0.06003395f, -0.18960470f, 0.11692072f, -0.33355317f, -0.14833267f, 
    0.09870569f, 0.01614136f, 0.11432970f, -0.06753790f, 0.01969650f, -0.04769876f, 0.11292301f, -0.05739532f, 
    0.12004338f, -0.00211938f, 0.07048506f, -0.05291045f, 0.11986943f, -0.15425161f, 0.00337279f, 0.02261802f, 
    -0.44707787f, -0.00090459f, 0.02807574f, 0.01423357f, -0.07769985f, -0.05520176f, -0.03402501f, 0.07671154f, 
    -0.04606432f, 0.00190845f, 0.15068308f, 0.04497862f, -0.00454844f, 0.00118203f, -0.01158441f, -0.06907523f, 
    -0.09735730f, 0.01132976f, -0.06087372f, 0.02579565f, 0.02894788f, -0.08687412f, 0.01085950f, 0.04473704f, 
    -0.25040546f, -0.13847160f, 0.02122721f, 0.00063883f, 0.00658083f, -0.03124166f, -0.02117444f, 0.04522438f, 
    0.10325626f, 0.09024093f, 0.03182114f, -0.07491097f, -0.05316851f, 0.03390741f, -0.00039111f, 0.04953976f, 
    0.10138764f, -0.21866077f, -0.07432941f, -0.05040324f, -0.11854666f, 0.08161667f, -0.06623197f, 0.01434371f, 
    0.11854734f, -0.06822637f, -0.00565149f, 0.05762877f, 0.04303185f, 0.04370327f, 0.05866395f, 0.05141653f, 
    -0.06354375f, 0.00153068f, -0.06440835f, -0.04955275f, -0.25448546f, 0.25323626f, -0.25155258f, -0.10519077f, 
    -0.00369199f, 0.06720451f, 0.04359125f, 0.04197863f, -0.11699457f, -0.04295501f, -0.09396479f, 0.02716514f, 
    -0.02234548f, -0.09964664f, -0.01163641f, -0.01872049f, 0.02699665f, 0.02548797f, 0.00831172f, -0.15331468f, 
    0.06226519f, 0.11040577f, -0.10090108f, -0.08935344f, -0.05775338f, 0.03158840f, 0.04346782f, 0.05114270f, 
    -0.01169428f, -0.04683188f, -0.00222974f, -0.01481025f, -0.07533088f, -0.08747042f, -0.07399742f, -0.01849854f, 
    0.00559909f, 0.04365775f, 0.08874567f, 0.02121903f, -0.09892187f, 0.00223221f, -0.03583712f, 0.12322322f, 
    -0.05562958f, -0.03879293f, -0.10696073f, -0.09491136f, 0.03274149f, 0.08451092f, 0.00833612f, 0.04829545f, 
    -0.02009046f, 0.04769951f, -0.04958128f, -0.03537864f, -0.02269996f, 0.00626134f, -0.03818402f, -0.05586980f, 
    -0.14856109f, -0.09316318f, 0.03931909f, -0.04016532f, 0.04441390f, -0.03330452f, -0.22753693f, 0.03396217f, 
    -0.03802073f, 0.01474132f, -0.02705897f, -0.06794253f, -0.17514172f, -0.00697635f, 0.00605444f, -0.00542261f, 
    0.02648772f, 0.00267738f, 0.00550960f, 0.02797237f, -0.08392322f, -0.07531417f, -0.06025713f, -0.03447749f, 
    0.10100642f, 0.08512457f, 0.02721378f, -0.02735723f, 0.05069748f, 0.11095755f, 0.02688330f, 0.00922198f, 
    0.01455524f, 0.04179775f, -0.04550875f, 0.02212069f, -0.04869591f, 0.06066320f, -0.20465378f, 0.05344467f, 
    0.10288530f, 0.01288726f, 0.00732925f, 0.17334345f, 0.03023205f, -0.02335780f, -0.03983935f, 0.02228496f, 
    -0.04441842f, 0.08430771f, 0.05810151f, 0.00076841f, 0.07193360f, -0.02608259f, -0.07519345f, -0.09143306f, 
    -0.02567131f, 0.03320783f, -0.01008961f, -0.00239193f, -0.21569176f, -0.10982235f, 0.12089993f, 0.07569777f, 
    -0.21625294f, 0.00468453f, 0.02604893f, -0.02517867f, 0.06953411f, -0.05864685f, -0.03264318f, -0.04967759f, 
    0.01358193f, -0.06664873f, -0.04820055f, -0.00587773f, 0.07213686f, 0.06587081f, 0.03929527f, 0.02861415f, 
    -0.50958276f, -0.13567775f, -0.01911626f, -0.03669585f, 0.17174497f, 0.05515951f, -0.00921702f, -0.06571277f, 
    0.02028177f, -0.04086382f, 0.03676238f, 0.07205559f, -0.05456996f, 0.04555226f, -0.06511880f, 0.10827278f, 
    0.11117467f, 0.01166656f, -0.20512249f, 0.02535211f, -0.07807645f, 0.07028784f, 0.20794028f, 0.25125936f, 
    0.02290079f, -0.03751788f, -0.16988747f, 0.01163906f, -0.07203819f, 0.19593801f, -0.00236024f, -0.14156599f, 
    -0.10970900f, -0.00323052f, -0.04324986f, 0.04765435f, 0.10840708f, -0.19308679f, 0.03479913f, 0.05564689f, 
    0.11766887f, 0.12928097f, -0.09741016f, 0.03944207f, -0.05412523f, 0.02438645f, 0.01058903f, -0.08463380f, 
    -0.05356208f, 0.07527278f, -0.06916848f, 0.01243873f, -0.03458875f, 0.01335192f, 0.02421132f, 0.03762957f, 
    0.00199000f, 0.06897940f, 0.07900905f, -0.06612180f, -0.10780789f, 0.01508889f, -0.06556775f, 0.00399614f, 
    0.09917596f, -0.01254255f, -0.00099246f, 0.01519095f, -0.02294484f, -0.01352821f, 0.03405832f, 0.06331924f, 
    0.00373207f, -0.05704759f, 0.00002691f, 0.02603513f, 0.04969489f, 0.04421403f, -0.03542286f, 0.02261815f, 
    0.08212943f, -0.04668995f, 0.04036761f, 0.03716822f, 0.00243063f, -0.08253062f, 0.05684130f, -0.05832914f, 
    -0.02910144f, 0.00825377f, -0.00334294f, 0.05922653f, 0.11494950f, 0.00081835f, 0.00027609f, -0.00274027f, 
    -0.03218703f, 0.10653479f, 0.04049544f, -0.01525886f, 0.08590478f, 0.07960763f, 0.06925690f, -0.15263098f, 
    -0.03766934f, -0.03588810f, 0.02139214f, -0.15502383f, -0.08703151f, -0.01911205f, 0.03682649f, 0.14917615f, 
    -0.04373273f, -0.07314065f, 0.02566444f, -0.08915169f, -0.09759786f, -0.01417561f, 0.05677043f, 0.02464193f, 
    0.05787076f, 0.15184169f, 0.13550273f, -0.09151515f, -0.09951384f, -0.09145148f, 0.06441730f, 0.01052899f, 
    -0.07304323f, 0.04962021f, -0.01399203f, 0.05321345f, -0.03872101f, 0.00563078f, -0.10016169f, 0.03007640f, 
    0.05126841f, -0.03880572f, 0.06391422f, 0.01703184f, -0.05181859f, 0.01459155f, 0.04252598f, 0.13857456f, 
    0.09155427f, 0.02212692f, -0.02614208f, 0.13521846f, 0.03331716f, 0.14404464f, -0.00598925f, -0.08399270f, 
    -0.01511478f, -0.02288063f, 0.09676871f, 0.00575088f, 0.07945756f, -0.04454543f, -0.02822071f, -0.12496947f, 
    -0.31042537f, 0.10569972f, 0.03645450f, 0.02998298f, -0.07880458f, -0.01994898f, -0.02207187f, -0.01020380f, 
    0.03466387f, -0.01266919f, 0.05665233f, -0.04002275f, 0.00909211f, -0.04283814f, -0.03868506f, -0.00707775f, 
    -0.02755033f, -0.05793012f, -0.01325506f, -0.00421278f, 0.14350657f, 0.06209516f, 0.07434488f, -0.02500446f, 
    -0.06665033f, 0.03162828f, 0.05437459f, 0.00834429f, -0.04937752f, -0.01160598f, 0.04311644f, -0.04843777f, 
    -0.03231346f, 0.04619305f, -0.05751922f, 0.06841492f, -0.03939537f, 0.05962689f, 0.12677278f, 0.05545127f, 
    0.02515837f, -0.13967669f, -0.12639441f, 0.15269147f, -0.02071310f, -0.02870632f, 0.04495609f, 0.05025742f, 
    0.02354034f, -0.01282659f, -0.01134632f, 0.05261730f, -0.06555624f, 0.01011707f, 0.03081102f, -0.01259567f, 
    -0.03683694f, 0.12600566f, -0.00178046f, 0.01767220f, 0.02596311f, 0.00520208f, -0.18515961f, 0.23831958f, 
    -0.06930180f, -0.04626193f, -0.06280296f, 0.00635263f, 0.10980671f, 0.00895895f, -0.00744929f, -0.02183779f, 
    -0.01121891f, 0.01002908f, 0.07083933f, -0.05263795f, -0.00875588f, -0.05781649f, -0.07099016f, -0.07859629f, 
    0.00930540f, 0.01061747f, 0.05542336f, -0.01182477f, 0.00485588f, 0.11410037f, 0.10680167f, -0.06257942f, 
    0.01464436f, 0.09167118f, -0.00692537f, 0.07631347f, 0.08864934f, 0.00787736f, -0.09437046f, -0.04494072f, 
    0.09566151f, -0.02039688f, 0.09805583f, -0.07935442f, -0.09419794f, 0.18788485f, 0.09182082f, 0.00432810f, 
    -0.05215232f, 0.04378187f, 0.00981811f, -0.00159162f, -0.05476981f, 0.02981710f, -0.00069544f, 0.00248943f, 
    0.00742331f, -0.01438576f, 0.00730193f, 0.07057589f, -0.06124889f, 0.00739705f, 0.04985797f, 0.01454858f, 
    -0.08741786f, 0.17739369f, -0.05349195f, 0.09570374f, -0.07138567f, -0.11114360f, 0.02316732f, -0.00733673f, 
    -0.01796020f, 0.01422199f, 0.05098448f, -0.01940858f, -0.00204495f, -0.01574077f, -0.00364994f, -0.03952356f, 
    -0.00427531f, -0.01174719f, -0.06042916f, -0.00799706f, -0.03116601f, -0.10345665f, -0.16902833f, 0.09256520f, 
    0.04931341f, -0.09169406f, 0.10045138f, -0.04262549f, -0.02859549f, 0.07959505f, -0.03909495f, 0.08637733f, 
    0.04099426f, -0.01205919f, -0.08706281f, -0.01370064f, 0.01521637f, 0.04585846f, -0.12182063f, 0.01766727f, 
    0.11954448f, -0.02863726f, -0.04832289f, -0.12002476f, -0.02324758f, 0.10850732f, -0.04013851f, 0.02165436f, 
    -0.03683424f, 0.04887173f, 0.02176165f, 0.00983176f, -0.07358242f, -0.02889785f, -0.10798785f, 0.00105749f, 
    -0.00967089f, -0.01852512f, 0.09442309f, -0.01437001f, -0.16865176f, 0.14910156f, -0.00551570f, 0.01975013f, 
    -0.07152996f, -0.00452587f, -0.04974479f, 0.10405025f, -0.01264357f, -0.06094321f, 0.00211552f, 0.07476385f, 
    -0.01912628f, -0.00749627f, -0.05118582f, -0.03651851f, -0.01338352f, 0.08690403f, 0.05904517f, 0.08653856f, 
    -0.02191539f, -0.08284913f, -0.12199680f, 0.11092686f, -0.05947672f, -0.03947918f, 0.08325852f, -0.08096559f, 
    -0.04898243f, -0.01763893f, -0.07741187f, 0.02190180f, 0.04144247f, 0.06944798f, 0.05864343f, -0.03683145f, 
    -0.04676702f, 0.01171385f, 0.01091708f, -0.05567249f, -0.05367423f, -0.04855179f, -0.09256322f, 0.23657615f, 
    -0.19489963f, 0.00922758f, 0.06072271f, 0.02338802f, 0.07127881f, 0.00932519f, -0.04507650f, 0.06388567f, 
    0.04919583f, 0.03490766f, 0.03353794f, 0.04816170f, -0.02195228f, 0.07741978f, -0.08439444f, -0.03460399f, 
    -0.02942730f, -0.00704545f, -0.16631058f, -0.31433466f, -0.04451711f, 0.10518885f, 0.03747160f, 0.07058794f, 
    -0.07771639f, 0.01827398f, -0.00614422f, 0.03257380f, -0.03171816f, -0.03022788f, -0.04400077f, 0.05807746f, 
    -0.12955733f, -0.00162988f, 0.12045777f, 0.02531045f, 0.12304673f, 0.08683524f, -0.08603755f, -0.15536925f, 
    0.02903957f, -0.03257281f, -0.00864064f, -0.05993782f, -0.09294999f, -0.16857673f, 0.03569118f, 0.01994619f, 
    -0.08486201f, -0.02639110f, 0.07658046f, -0.06677121f, -0.13976115f, 0.11260868f, -0.08207183f, 0.10662667f, 
    0.28946093f, -0.40520442f, -0.19493689f, 0.14785378f, 0.00889700f, -0.03565452f, -0.02047195f, 0.02693752f, 
    0.04171267f, 0.03950531f, 0.01404561f, 0.08475775f, 0.05479368f, -0.05380223f, 0.06502185f, -0.07106707f, 
    -0.06688792f, 0.03851201f, -0.09213945f, 0.08951163f, 0.05844416f, 0.06910647f, -0.04987744f, -0.20652859f, 
    0.12456686f, -0.05651641f, 0.05883312f, 0.11475240f, 0.00495823f, 0.09381878f, 0.03834949f, 0.02796600f, 
    0.07185883f, 0.01070240f, -0.18388528f, 0.07693383f, -0.05984286f, 0.08939283f, 0.03588489f, 0.04015721f, 
    0.18962985f, -0.19840114f, 0.02796957f, 0.04253467f, 0.29682648f, 0.04638750f, -0.04979255f, -0.02353399f, 
    0.01166826f, -0.01738196f, -0.11321320f, -0.03124777f, 0.04170728f, 0.00514371f, 0.03686409f, -0.04086457f, 
    -0.08431271f, 0.00689665f, -0.10113402f, -0.00995057f, 0.05187596f, -0.34106654f, -0.09862360f, -0.10377491f, 
    -0.02363685f, -0.04155758f, 0.04054109f, 0.02627390f, 0.01657575f, -0.00980837f, -0.08614173f, 0.05167742f, 
    -0.01898778f, 0.05037716f, 0.04024499f, -0.06758366f, -0.04999864f, -0.04108674f, -0.08881853f, 0.05990759f, 
    -0.22191910f, -0.10088407f, 0.09540343f, 0.11800145f, 0.11470771f, 0.04565910f, -0.03623120f, 0.09748288f, 
    -0.02143714f, -0.06231355f, -0.14257024f, 0.04750659f, 0.00185703f, 0.03411680f, -0.05687408f, 0.01255716f, 
    -0.01413203f, 0.12326533f, 0.14405100f, 0.03690680f, -0.12746710f, -0.13203460f, -0.04170990f, -0.33018541f, 
    0.14547820f, 0.04692992f, -0.11449765f, 0.02511695f, -0.01089348f, 0.02099528f, -0.01687540f, -0.10674904f, 
    0.03810149f, 0.04525312f, -0.06711619f, 0.09785291f, -0.04700443f, -0.09984331f, -0.03327049f, 0.13066252f, 
    -0.33972946f, 0.06439305f, -0.07041004f, 0.19984588f, -0.00803056f, 0.05009725f, 0.01733804f, 0.08109966f, 
    0.07471229f, -0.04929177f, -0.02098608f, -0.04903398f, -0.01110721f, -0.00302494f, -0.08967236f, 0.04392345f, 
    -0.00448400f, -0.05110850f, -0.06097466f, 0.00706426f, 0.24954103f, 0.05306791f, 0.01260835f, -0.00632904f, 
    0.16884193f, -0.01758180f, 0.04676702f, 0.05534137f, 0.10047366f, 0.03254487f, 0.01426388f, -0.01952306f, 
    -0.03147147f, -0.03667330f, -0.09052835f, 0.03615602f, 0.07939356f, -0.00806212f, 0.01267133f, 0.08446284f, 
    -0.02665626f, -0.27768430f, -0.01953977f, 0.06871432f, -0.05796159f, -0.02608180f, -0.01555583f, -0.02525583f, 
    -0.00132797f, -0.00309296f, -0.05708564f, 0.02650766f, 0.13661470f, 0.01164583f, 0.04880589f, 0.06533148f, 
    -0.02766693f, -0.12545386f, -0.00229344f, -0.07749565f, 0.00299199f, -0.09305749f, -0.17841835f, -0.20383415f, 
    0.06518257f, -0.00075473f, 0.10399976f, -0.05688350f, -0.08363406f, 0.03318876f, -0.02526186f, -0.11992053f, 
    -0.06956246f, 0.01893081f, -0.00214180f, 0.00886291f, -0.03885785f, 0.21126288f, 0.03796465f, 0.10014863f, 
    -0.12216165f, 0.05388340f, 0.09744600f, -0.03126472f, 0.02802267f, -0.00358272f, -0.01832553f, -0.01173875f, 
    0.02481219f, 0.01264486f, 0.00107244f, 0.08952095f, 0.03345744f, -0.00561439f, -0.05334933f, -0.01370612f, 
    -0.02442780f, -0.03751959f, -0.12544908f, -0.07134040f, 0.06136378f, -0.40181777f, -0.08001094f, -0.11921240f, 
    -0.08009330f, -0.00620335f, 0.04431429f, 0.00311528f, -0.02883202f, -0.02019261f, 0.04071238f, -0.04668937f, 
    0.04255467f, 0.14037801f, -0.00797528f, -0.07044914f, -0.00623769f, -0.09415141f, -0.14182405f, -0.00821061f, 
    -0.16094796f, 0.17280044f, 0.11727746f, 0.02835714f, -0.27332851f, 0.01994564f, 0.07384449f, -0.02313496f, 
    0.03184627f, 0.08005803f, -0.06227495f, 0.01861509f, 0.05109296f, 0.03148515f, -0.07980707f, 0.00670034f, 
    0.02259331f, -0.01581329f, -0.08236712f, -0.07165805f, -0.13925052f, 0.18530573f, -0.00530337f, 0.09579912f, 
    -0.13295329f, -0.06851043f, 0.03248534f, 0.01024051f, 0.00699282f, 0.02970288f, 0.01863836f, -0.01154286f, 
    0.02355845f, -0.04466343f, -0.02652061f, -0.01380914f, -0.06096478f, -0.02439721f, -0.07611874f, -0.01307585f, 
    -0.18474549f, 0.15419543f, -0.04902218f, 0.05409084f, -0.13798051f, 0.01861048f, 0.00147789f, 0.07603320f, 
    0.09509536f, 0.06917214f, -0.00542916f, -0.05417109f, -0.05351660f, 0.04008661f, 0.12337679f, 0.09147815f, 
    -0.00662838f, -0.15783869f, 0.10320026f, 0.02279368f, -0.12238549f, 0.26393744f, -0.04272922f, 0.00548237f, 
    -0.11562806f, -0.07039040f, -0.01452060f, 0.04721395f, 0.07360756f, -0.03915389f, 0.06141259f, 0.00018312f, 
    -0.01486980f, -0.00097467f, 0.01346768f, -0.02573061f, -0.00943018f, 0.07623173f, -0.07246625f, 0.09814329f, 
    0.29843682f, -0.06165367f, 0.01127753f, 0.00103379f, -0.11142850f, 0.00494280f, 0.11162110f, -0.01665206f, 
    -0.03713047f, -0.03761569f, 0.02041393f, -0.04336524f, 0.04377707f, -0.05647639f, -0.00823140f, -0.04657221f, 
    0.03308702f, 0.07066821f, -0.05064910f, 0.00295589f, -0.14932941f, 0.08378874f, 0.04455977f, 0.07235319f, 
    -0.09055201f, 0.04881835f, 0.00225327f, 0.00710621f, 0.01767770f, 0.01822874f, -0.04182115f, 0.00365254f, 
    -0.01796054f, 0.03700490f, 0.04417119f, 0.05230688f, 0.02695029f, -0.05914955f, 0.00452698f, 0.02295926f, 
    -0.10663651f, 0.21111746f, 0.05838683f, 0.00293093f, -0.35339132f, 0.06817903f, 0.16787089f, 0.01867694f, 
    0.08720670f, 0.09061926f, -0.09441817f, -0.01746174f, 0.10530929f, 0.05560696f, -0.03853773f, 0.04770251f, 
    -0.06685800f, 0.01974147f, 0.02415709f, -0.01220469f, -0.14791407f, -0.10919785f, -0.02828849f, -0.13987605f, 
    0.15857443f, -0.03512729f, 0.01128837f, -0.02319580f, -0.13965653f, -0.10276836f, -0.06219704f, -0.04482134f, 
    -0.03089496f, -0.04919259f, 0.08907922f, -0.03682351f, 0.00203771f, 0.05786293f, 0.07292905f, 0.04213439f, 
    -0.19008464f, 0.00522656f, -0.09301923f, 0.01217601f, -0.00567346f, -0.13295737f, 0.00425244f, -0.00542255f, 
    0.05528215f, 0.02488197f, -0.04199865f, -0.06742050f, -0.00164492f, 0.01896575f, 0.01364605f, 0.01596878f, 
    -0.07196778f, -0.02785795f, -0.09697549f, 0.03679834f, -0.10280563f, 0.14345013f, 0.07544570f, 0.00414045f, 
    -0.06416254f, -0.07208293f, -0.03404518f, 0.04952902f, 0.00437439f, 0.01587942f, 0.05189512f, -0.02901990f, 
    0.11036541f, -0.07759518f, 0.01079108f, -0.02180835f, 0.02062743f, -0.00081157f, 0.05741588f, 0.05348308f, 
    0.26871225f, 0.15249728f, 0.05990662f, -0.14008085f, 0.14461318f, -0.03392152f, -0.03068703f, -0.05183919f, 
    -0.03644377f, -0.03062622f, -0.00539752f, -0.05451618f, -0.01258316f, -0.04264925f, -0.00763336f, 0.03546870f, 
    0.05656352f, 0.04310977f, 0.06331326f, 0.07908343f, -0.17698552f, -0.06532618f, -0.02600327f, -0.20729339f, 
    0.06282540f, -0.00365764f, 0.00668237f, 0.06113005f, -0.04908317f, 0.04607758f, 0.04112347f, -0.05722607f, 
    -0.00250409f, 0.06834097f, 0.00726761f, -0.00960382f, 0.00986212f, -0.04511608f, 0.09833396f, -0.05857000f, 
    0.04809122f, 0.01575507f, 0.02714878f, 0.01373954f, 0.14243530f, 0.07937996f, -0.00406603f, 0.01285870f, 
    -0.01183603f, -0.12276144f, -0.06521093f, 0.00104593f, -0.10710005f, -0.06624797f, -0.04135983f, 0.02301112f, 
    0.03133547f, 0.10984186f, 0.08558559f, 0.02441702f, 0.14940991f, -0.30845961f, -0.08670603f, 0.02626914f, 
    -0.19633894f, -0.02832046f, 0.09409002f, -0.01522786f, 0.01823571f, 0.01751155f, -0.08587702f, -0.02810910f, 
    0.01911113f, 0.02400610f, 0.10883986f, 0.07897044f, -0.04556571f, -0.06102845f, -0.14793411f, -0.04874976f, 
    -0.09580366f, 0.26134413f, -0.05879106f, 0.12923397f, -0.05685089f, 0.06774861f, -0.04865694f, 0.01662517f, 
    0.05216698f, -0.08992290f, 0.01187244f, 0.04175600f, -0.01737679f, 0.04116594f, -0.04466372f, 0.05776198f, 
    0.02925565f, 0.03155620f, -0.01983229f, -0.11508659f, 0.02091762f, -0.23961657f, -0.03422384f, -0.19486591f, 
    0.05612615f, -0.00372174f, 0.01859510f, -0.02746520f, 0.00241006f, 0.01080337f, -0.04021611f, 0.08148377f, 
    0.07804259f, 0.05501986f, -0.04449884f, -0.01375787f, -0.00655157f, -0.03549824f, -0.07969998f, 0.03060793f, 
    0.20779783f, -0.07319884f, -0.00150542f, -0.13204037f, 0.17020763f, -0.12742224f, 0.06879639f, -0.04222137f, 
    -0.11082645f, -0.03763732f, -0.04545459f, 0.06840067f, -0.00357345f, 0.06974112f, 0.03169896f, 0.01854102f, 
    0.04284793f, -0.03481219f, -0.04686269f, -0.05463865f, -0.20445408f, -0.11064192f, -0.12951292f, -0.46765530f, 
    0.15423676f, 0.06082091f, -0.08759409f, 0.08711421f, -0.06672269f, -0.10605343f, -0.11255801f, -0.07787403f, 
    -0.03688842f, -0.01133868f, 0.05980384f, -0.04065131f, 0.00279777f, 0.05810692f, 0.13004605f, -0.00288123f, 
    0.03088220f, 0.10230305f, -0.12323905f, -0.17342235f, -0.01825591f, 0.04021629f, 0.06632686f, 0.00873098f, 
    -0.07925386f, 0.00496916f, 0.05295800f, -0.03884700f, -0.08953667f, -0.04862471f, 0.00994248f, -0.03709167f, 
    -0.04673759f, 0.09494451f, 0.03579552f, 0.01758616f, 0.15267718f, -0.17901155f, 0.05559216f, -0.16681735f, 
    0.16022347f, -0.04798414f, 0.01214536f, -0.07233822f, -0.12974912f, -0.13340205f, -0.02055836f, -0.01461949f, 
    -0.01959935f, 0.07216220f, -0.00503765f, 0.16770300f, -0.03131220f, 0.08101571f, -0.04668783f, 0.05122745f, 
    -0.06581890f, -0.13458973f, -0.01897032f, 0.09842193f, -0.03131373f, -0.02072470f, -0.02561743f, 0.02277154f, 
    0.01742594f, 0.01946921f, -0.05454715f, 0.00245542f, -0.02148229f, 0.04050321f, -0.00017893f, -0.09139148f, 
    -0.01980515f, 0.07664849f, 0.02664481f, 0.02782090f, 0.14866708f, 0.08370534f, 0.18949828f, 0.00100399f, 
    -0.17690313f, 0.09527405f, -0.05352700f, 0.00541113f, 0.01189891f, -0.01040945f, -0.00379994f, 0.00290318f, 
    -0.03556980f, 0.01625490f, 0.00516099f, 0.05147727f, 0.01080861f, -0.01277177f, -0.03584908f, -0.06840387f, 
    0.18501695f, -0.27619627f, 0.01583757f, 0.08095932f, -0.04092630f, 0.14639679f, 0.09429796f, -0.06436294f, 
    -0.10708870f, -0.05957698f, 0.07194841f, -0.03085961f, 0.08337437f, -0.00837022f, -0.03103641f, -0.06385747f, 
    -0.05635670f, 0.05017926f, 0.01257316f, -0.06447265f, -0.06178705f, -0.23954274f, 0.05664748f, -0.26650313f, 
    0.13474700f, -0.11442088f, -0.02503982f, 0.00989612f, 0.07144092f, -0.12908211f, -0.08224577f, 0.02539272f, 
    -0.09036138f, 0.07607847f, 0.07108469f, -0.02134096f, 0.05658245f, -0.01487143f, -0.08652771f, -0.00500767f, 
    -0.00414954f, -0.28028491f, -0.05172769f, -0.09346851f, -0.01519764f, 0.02335138f, 0.00163926f, 0.03944356f, 
    -0.10261025f, 0.00009589f, -0.03057472f, 0.01171700f, 0.04985515f, 0.05513821f, 0.07697748f, -0.02083187f, 
    -0.00883450f, -0.01139088f, 0.01223246f, -0.05797981f, -0.14479229f, 0.05586236f, 0.05646389f, 0.12434489f, 
    -0.02362399f, 0.04387449f, -0.05745003f, 0.03182660f, -0.09198005f, -0.03385936f, -0.02523916f, -0.02869277f, 
    0.07120134f, 0.00746355f, 0.00855500f, -0.01915399f, 0.00062151f, -0.00157046f, 0.04618375f, -0.04583535f, 
    0.08697130f, -0.02042441f, -0.00261191f, 0.00646107f, 0.14649685f, 0.06336340f, 0.07038393f, -0.05761623f, 
    -0.00150746f, 0.05627375f, -0.12949690f, -0.06260404f, 0.11654637f, -0.08196154f, -0.00825085f, -0.12808186f, 
    0.13581318f, 0.08335770f, -0.00210947f, -0.02184035f, 0.01792033f, 0.00920698f, 0.00940174f, -0.24037641f, 
    -0.03592817f, -0.00956332f, 0.04759116f, 0.11321510f, -0.07988035f, -0.02868014f, -0.03419464f, -0.13491482f, 
    -0.05702357f, -0.01700364f, 0.02775359f, 0.00946477f, -0.02877987f, 0.02649684f, 0.15190902f, 0.05784929f, 
    -0.13519053f, -0.00213028f, 0.10899947f, -0.20225562f, -0.00313670f, 0.01199386f, -0.10841917f, 0.08712588f, 
    -0.02622016f, -0.01239691f, -0.03236974f, 0.01294081f, -0.13170299f, -0.05935608f, 0.01701722f, 0.00418680f, 
    0.03444983f, -0.00280890f, 0.07216173f, 0.00051740f, 0.02536869f, 0.09639152f, 0.01895342f, -0.04360168f, 
    -0.02134781f, -0.01751154f, -0.05606883f, 0.04040727f, -0.01328494f, 0.10732598f, 0.02186403f, 0.09080970f, 
    -0.03035124f, -0.01734220f, 0.05231165f, -0.04343758f, -0.03747403f, -0.11204142f, 0.00263430f, -0.12496289f, 
    -0.36198592f, -0.00145893f, 0.00595816f, -0.15750259f, 0.01674974f, -0.03367744f, 0.00740257f, 0.07885753f, 
    -0.11162715f, 0.05922867f, 0.08201703f, -0.09794125f, -0.01687186f, 0.00551999f, 0.03017520f, 0.00166519f, 
    0.02146956f, -0.14489181f, 0.15652871f, -0.00281885f, -0.11450695f, 0.12821181f, -0.09334311f, 0.19035900f, 
    -0.10569838f, 0.09422461f, 0.04919600f, -0.02874047f, 0.07757463f, -0.01956266f, 0.02691865f, 0.04563040f, 
    -0.07829767f, 0.03316400f, -0.12372345f, 0.14981398f, 0.00293792f, 0.08515330f, 0.04297687f, -0.00714941f, 
    -0.22575356f, 0.03345860f, -0.07308243f, 0.11197177f, -0.03494607f, 0.07389931f, -0.01769494f, -0.00055058f, 
    0.02603990f, 0.01229023f, 0.07198184f, 0.03471418f, 0.03974637f, 0.00637341f, -0.02471454f, 0.04678312f, 
    0.04689569f, -0.04262220f, 0.03469336f, 0.01335427f, -0.26497996f, -0.15568526f, -0.00362719f, 0.09623615f, 
    0.12976851f, 0.12541918f, -0.05758038f, -0.02547212f, 0.02792822f, -0.07731353f, 0.00639677f, -0.08344248f, 
    0.10895219f, 0.00576525f, -0.12275106f, 0.06831747f, 0.02724050f, -0.12050027f, 0.01028525f, 0.03227995f, 
    -0.19046089f, 0.13859476f, 0.12284010f, 0.09868529f, -0.09762840f, 0.01275734f, -0.13710439f, 0.01307512f, 
    0.03750689f, -0.00828112f, -0.08621011f, -0.00724320f, -0.07582960f, 0.14208591f, 0.02489162f, 0.00112833f, 
    0.04400476f, -0.19191685f, 0.00474828f, -0.07655996f, -0.17015846f, -0.08658035f, -0.12245285f, -0.07767994f, 
    0.14503720f, -0.01816677f, -0.00518161f, 0.10882231f, 0.09419100f, 0.04615904f, -0.01086232f, -0.15550646f, 
    -0.03451087f, -0.03754133f, 0.01830382f, 0.02664380f, 0.00624222f, 0.02584743f, 0.02753663f, 0.01668259f, 
    -0.03701049f, 0.06547257f, -0.04958678f, 0.12965900f, -0.01361005f, -0.05195844f, 0.01551470f, 0.00353513f, 
    -0.00689478f, -0.05811303f, -0.02017682f, -0.01121385f, -0.04373471f, 0.04237027f, 0.00013869f, 0.03140840f, 
    -0.01728435f, 0.05377313f, -0.03633570f, -0.03711136f, 0.07660078f, 0.05342115f, 0.00392991f, 0.07472052f, 
    -0.02209608f, -0.00833828f, 0.00301588f, -0.06008203f, -0.10693349f, 0.02680041f, -0.04233182f, -0.01138286f, 
    -0.01676569f, -0.00872684f, -0.07894212f, 0.00861323f, -0.07216196f, -0.00585920f, -0.09038360f, 0.07049685f, 
    0.48988876f, -0.14105161f, 0.15554167f, 0.18492848f, 0.20800403f, 0.00268210f, 0.01498875f, -0.03781532f, 
    -0.03891907f, -0.03923529f, -0.04665198f, 0.01833014f, 0.11389643f, 0.03588758f, 0.09036966f, -0.05601438f, 
    0.00275745f, -0.04595891f, -0.08623979f, -0.07440738f, -0.21497454f, 0.09876388f, -0.04731054f, 0.14371732f, 
    -0.10187372f, -0.11176883f, -0.00577063f, -0.00740511f, 0.00403849f, -0.01279955f, -0.02965001f, 0.03674952f, 
    0.01155067f, -0.00967070f, 0.03720814f, -0.03835815f, -0.03687810f, -0.10209603f, -0.08614568f, -0.13552476f, 
    0.10807092f, 0.18458970f, 0.04189770f, 0.11359300f, 0.12270306f, -0.03527892f, 0.04557886f, -0.08956923f, 
    0.03683025f, -0.01360939f, -0.04758864f, 0.01592438f, -0.02280478f, 0.02583106f, -0.01691289f, 0.05194222f, 
    -0.03552914f, 0.02042773f, 0.01381041f, -0.06930922f, 0.02752284f, -0.04871156f, 0.01668584f, -0.09700735f, 
    -0.01158551f, 0.01182820f, -0.04328317f, 0.02320814f, -0.07381576f, -0.11976386f, 0.02244953f, -0.00523854f, 
    -0.08302869f, -0.03517669f, -0.06333819f, 0.03454816f, -0.00707603f, 0.02775224f, -0.00306609f, -0.02512442f, 
    -0.08345902f, 0.07975171f, -0.09897896f, -0.09226588f, -0.05352451f, 0.01003372f, 0.02442440f, -0.08615283f, 
    -0.01343732f, 0.01475617f, -0.04282319f, -0.05852104f, 0.02371013f, -0.02610999f, -0.02073066f, -0.04593111f, 
    -0.03378902f, 0.08231886f, 0.00032770f, 0.06979278f, -0.01492270f, -0.03161350f, -0.24339989f, 0.00360952f, 
    0.11163757f, -0.11066850f, -0.07401408f, -0.06368966f, -0.02363061f, 0.00380213f, -0.05765453f, -0.01660916f, 
    0.02641701f, 0.00122449f, -0.04096887f, 0.01193044f, -0.00097777f, -0.03122382f, -0.02129749f, 0.00396140f, 
    0.07653422f, 0.08076511f, 0.02492772f, -0.06027078f, -0.05597539f, -0.02297854f, -0.01285662f, -0.00860956f, 
    0.00704491f, -0.00758468f, -0.06953144f, 0.04172416f, -0.01019610f, 0.00990015f, 0.01945124f, 0.00644971f, 
    -0.04235354f, -0.03201291f, -0.02508522f, 0.04267245f, -0.16746783f, 0.09820580f, -0.05400627f, -0.03499952f, 
    -0.02611371f, -0.05388626f, 0.00068158f, -0.05632557f, -0.01673120f, -0.03650215f, -0.03395587f, -0.00703289f, 
    -0.05530731f, -0.04233521f, 0.00672467f, -0.02817442f, -0.03320104f, 0.06022846f, 0.00790151f, -0.00853361f, 
    0.06090184f, -0.22207150f, -0.01222473f, 0.00074371f, 0.02345501f, -0.00833616f, -0.11657936f, -0.04480498f, 
    0.00094320f, -0.04294537f, -0.03011081f, 0.01814642f, 0.02137383f, -0.02209731f, -0.00949638f, -0.04812955f, 
    0.02724950f, 0.01139674f, 0.05690936f, -0.01636142f, -0.22171590f, 0.03048582f, -0.28464592f, -0.14601721f, 
    -0.00388873f, -0.02562698f, -0.03584929f, -0.05367513f, 0.01173604f, -0.06058077f, -0.15280519f, 0.04559445f, 
    0.01177684f, -0.01804937f, 0.03918828f, -0.00072291f, -0.04559612f, 0.02041608f, -0.00992040f, 0.05451832f, 
    -0.08527461f, 0.07518329f, -0.01494226f, 0.00509953f, -0.11190432f, 0.01445431f, -0.05139857f, -0.06521194f, 
    0.04683126f, 0.02752040f, -0.02948999f, 0.00264837f, -0.01347901f, 0.00190348f, 0.03986245f, -0.02494297f, 
    -0.03317165f, -0.03886785f, 0.00136886f, 0.00530707f, -0.30262196f, 0.10946572f, 0.15578820f, -0.01752371f, 
    -0.04466170f, -0.04035569f, -0.11027661f, -0.03335877f, 0.02469368f, -0.04660834f, 0.01457463f, -0.02488724f, 
    0.01970191f, 0.01128912f, -0.08348212f, 0.06636755f, -0.01574296f, 0.01179708f, -0.01953150f, -0.04957389f, 
    0.09123527f, -0.03682925f, 0.02015723f, 0.08734032f, 0.17798664f, 0.01715571f, 0.02627424f, -0.02226734f, 
    0.02883617f, -0.02917028f, -0.06469125f, 0.05549817f, -0.01873330f, -0.03283557f, -0.00985176f, -0.03057405f, 
    -0.01226789f, 0.03118794f, -0.01633199f, 0.02125381f, -0.09644908f, 0.14719681f, 0.12510502f, 0.13028726f, 
    0.09759150f, 0.03320310f, 0.03205514f, -0.01724278f, -0.04144694f, -0.01569172f, -0.00854046f, 0.04987991f, 
    0.00776783f, -0.09026212f, -0.01424302f, -0.01907164f, -0.03846158f, 0.07365004f, 0.02651222f, -0.02452316f, 
    0.22406931f, 0.09308510f, 0.07473879f, -0.01574712f, 0.18337804f, 0.00311300f, 0.01502017f, -0.04149576f, 
    0.02386376f, -0.01831083f, -0.00494363f, -0.04407346f, 0.02863078f, 0.00993788f, 0.03030506f, 0.02916462f, 
    -0.04333985f, 0.03424299f, 0.07459237f, 0.02711358f, -0.05117021f, -0.05578092f, -0.00147430f, 0.05228620f, 
    0.03046821f, 0.06522307f, -0.09235449f, -0.00320689f, -0.00879523f, -0.00637903f, 0.01833837f, -0.00187025f, 
    -0.02103112f, -0.06979145f, -0.00738915f, 0.03393223f, 0.06628702f, -0.01673967f, 0.02950114f, -0.06954632f, 
    -0.14142418f, -0.08034375f, -0.10562304f, -0.04393716f, 0.04325023f, -0.09589936f, -0.03621144f, -0.01226800f, 
    -0.01209143f, -0.01779077f, -0.03766784f, -0.00082400f, -0.06249159f, 0.00244274f, -0.03628643f, 0.01479637f, 
    -0.03271250f, -0.01008324f, -0.04074141f, -0.00957067f, -0.01550597f, 0.05067676f, 0.15657839f, 0.08343199f, 
    0.14119829f, 0.05377242f, 0.05878900f, -0.05191426f, 0.04537208f, -0.09155588f, -0.01180932f, 0.01557100f, 
    0.07027687f, -0.03269082f, 0.00643069f, -0.06102221f, -0.06307530f, 0.01884624f, 0.01831476f, -0.02273201f, 
    0.04332174f, -0.13973355f, 0.11917862f, 0.06805991f, -0.02661222f, 0.03786391f, -0.04229065f, -0.05700386f, 
    0.00267869f, -0.02780696f, -0.00981413f, 0.06012166f, 0.00135381f, 0.01936548f, -0.08164836f, -0.01289796f, 
    -0.00115716f, -0.05636217f, -0.09050034f, 0.02093138f, 0.18475190f, 0.08444119f, 0.19149381f, 0.00748721f, 
    0.12000665f, 0.07512294f, 0.05971193f, -0.01498893f, 0.02044116f, 0.02757784f, -0.00773005f, 0.04538149f, 
    -0.02269363f, -0.01756078f, 0.01914377f, -0.03690278f, 0.00671783f, -0.03603423f, 0.01178816f, 0.02033756f, 
    -0.02871573f, 0.06751222f, -0.00619229f, -0.04530360f, 0.01679627f, 0.02068317f, 0.03884925f, 0.01784632f, 
    -0.04689554f, -0.03595552f, -0.01933433f, 0.04837044f, 0.00201513f, -0.06335609f, 0.00779383f, 0.04474609f, 
    0.00384672f, -0.04848323f, -0.04710788f, -0.01098126f, -0.08237050f, 0.00950713f, -0.08576532f, 0.14321783f, 
    -0.05621785f, 0.09750206f, -0.06349909f, -0.03989126f, -0.00420849f, -0.00589378f, -0.07308620f, 0.00638013f, 
    0.02322160f, -0.01750526f, -0.03318981f, 0.09100212f, 0.00002332f, 0.01579299f, -0.00916422f, -0.03343260f, 
    -0.00173589f, 0.01454117f, 0.06186235f, 0.00919406f, -0.11193252f, 0.02394829f, 0.01298109f, -0.00070873f, 
    0.01565955f, 0.03001407f, 0.01743843f, -0.00258828f, 0.00967339f, -0.01539532f, -0.06174874f, -0.03894090f, 
    -0.04923606f, -0.03065534f, -0.00568655f, -0.05065675f, 0.01877347f, 0.17056805f, -0.14123495f, 0.07985567f, 
    0.14957179f, -0.05353612f, 0.04102367f, -0.12430584f, -0.00087146f, 0.00246517f, -0.03833468f, 0.02864291f, 
    -0.03425844f, -0.01064076f, -0.03020732f, 0.01119888f, 0.05542835f, 0.05606920f, -0.03261891f, -0.04634833f, 
    -0.00814511f, 0.05829616f, 0.00460559f, -0.01776844f, -0.05124499f, -0.02847052f, -0.00020171f, -0.07838218f, 
    0.02733165f, -0.01328005f, 0.00128481f, 0.03056824f, 0.01282340f, 0.02244143f, -0.04705242f, -0.01931522f, 
    0.04252061f, 0.00123416f, -0.05066894f, 0.06709244f, 0.02697624f, -0.04610857f, 0.16750638f, 0.03596251f, 
    0.03174552f, 0.01796104f, 0.04751223f, -0.00866340f, -0.02888938f, -0.07003221f, -0.04187611f, 0.05318521f, 
    -0.01444462f, -0.00428288f, -0.05884485f, -0.07040280f, 0.02240966f, 0.01225639f, -0.04809844f, -0.04129392f, 
    -0.10159205f, -0.10457268f, -0.12825637f, -0.09743403f, -0.08616563f, -0.07094898f, -0.01327772f, -0.05027457f, 
    -0.00479000f, -0.02863908f, -0.04234302f, -0.04981964f, 0.05066352f, -0.04096224f, -0.00272529f, -0.05276673f, 
    0.05572176f, -0.03871250f, 0.02316703f, 0.02111327f, -0.15617463f, -0.03556648f, -0.13789804f, -0.12958622f, 
    -0.09879482f, -0.01443622f, -0.10696862f, -0.05411788f, -0.02318526f, -0.05756862f, -0.06803006f, -0.02338608f, 
    -0.00593949f, -0.06269720f, -0.05633257f, -0.02171972f, 0.03666607f, 0.00010597f, -0.01547241f, 0.02067585f, 
    0.04475695f, -0.00821786f, -0.13013670f, -0.11077212f, -0.19738798f, -0.04188747f, -0.05011118f, -0.02035435f, 
    -0.06430081f, -0.00358239f, 0.04204968f, -0.00441474f, -0.07597811f, 0.01900955f, -0.04601095f, 0.02563667f, 
    0.05600290f, 0.01060667f, -0.01464538f, 0.02752940f, 0.01464187f, 0.03965157f, -0.14772905f, -0.06066131f, 
    0.07418603f, -0.00198108f, -0.09191560f, 0.00115115f, -0.02425135f, -0.05389340f, -0.11375455f, 0.07723153f, 
    -0.00763276f, 0.03529220f, -0.07868920f, 0.03024380f, -0.08759528f, -0.06334800f, 0.00144534f, -0.01899758f, 
    0.10829426f, -0.02942371f, 0.14221090f, 0.01664579f, 0.17691125f, 0.01727929f, 0.04970801f, 0.01330323f, 
    -0.05872423f, 0.03650668f, -0.02983774f, 0.01044159f, -0.05558046f, -0.01542242f, -0.00290832f, -0.05705476f, 
    0.04203187f, 0.02845279f, 0.03703134f, -0.03264700f, 0.00274402f, -0.19686590f, -0.03274914f, -0.09952538f, 
    -0.04035158f, -0.00152510f, -0.02148601f, -0.00418873f, -0.00188084f, -0.09439643f, -0.03400122f, -0.00362011f, 
    -0.03497311f, 0.03251537f, 0.00377780f, 0.00143041f, -0.04788315f, -0.05749586f, -0.00785356f, -0.04118709f, 
    -0.16094682f, -0.01585467f, -0.14494981f, -0.00104384f, 0.05844389f, -0.08082443f, -0.03586208f, -0.09251668f, 
    0.00670234f, -0.04027311f, -0.04619345f, 0.02877383f, 0.04511407f, 0.03078440f, -0.05603860f, -0.00258038f, 
    0.00405363f, 0.02091224f, -0.00150214f, -0.03698499f, 0.02461123f, 0.10046113f, 0.11560745f, 0.04651963f, 
    0.11480313f, 0.06368680f, -0.02818422f, 0.00210577f, 0.00291415f, -0.02506442f, 0.04092423f, 0.02694755f, 
    -0.04280813f, -0.03979884f, -0.00398326f, -0.01833888f, 0.02361719f, 0.05000762f, 0.02796450f, -0.03408376f, 
    -0.02334117f, 0.02474083f, 0.00854017f, -0.12336430f, -0.07672045f, -0.10179015f, 0.01877532f, 0.01097854f, 
    -0.03052321f, -0.01329173f, 0.03909894f, 0.01925722f, -0.00500658f, 0.03154520f, -0.03589875f, -0.02453029f, 
    0.00655203f, -0.05946321f, -0.04765302f, -0.00800798f, 0.12075984f, 0.12123840f, 0.03768247f, -0.00420815f, 
    0.04493197f, 0.00218052f, -0.11713950f, -0.05494599f, -0.01854264f, -0.00773408f, 0.01880181f, 0.00137260f, 
    0.00963193f, -0.06580332f, -0.03224878f, 0.01989191f, 0.07075290f, -0.02010853f, -0.05716112f, -0.02387992f, 
    0.07692763f, 0.11143932f, 0.01165754f, -0.02898400f, 0.15034063f, -0.13009989f, 0.01703952f, -0.07089295f, 
    -0.00181399f, 0.01183689f, -0.07520449f, 0.05958084f, -0.07404454f, 0.03093054f, -0.02225585f, 0.02625795f, 
    -0.03285930f, 0.03784188f, -0.07179486f, -0.03240360f, 0.10967524f, -0.01492851f, 0.13834655f, 0.02977341f, 
    0.00085700f, 0.04938304f, 0.03658058f, -0.00231301f, -0.02220253f, -0.01965675f, -0.02896902f, 0.06314854f, 
    0.00125781f, 0.01553420f, 0.00558840f, -0.08833623f, 0.01591008f, -0.02184581f, 0.05566066f, -0.02750308f, 
    -0.01971565f, -0.13006063f, 0.03381374f, 0.03476818f, -0.03725135f, -0.00727687f, -0.07014541f, -0.07550873f, 
    0.01605054f, -0.00547989f, -0.03284749f, 0.02314577f, 0.00436572f, -0.03114658f, -0.07865251f, -0.00425904f, 
    -0.04627037f, -0.00078945f, -0.02329016f, -0.02597796f, 0.08059144f, -0.00654596f, 0.00600600f, -0.02871074f, 
    -0.09399718f, 0.06409274f, 0.00556517f, -0.01869630f, -0.06803387f, -0.01039344f, 0.01749573f, -0.06218389f, 
    0.03902546f, -0.00696541f, -0.08114313f, 0.03459208f, -0.04635062f, 0.01016567f, -0.04191756f, -0.03369686f, 
    -0.07006883f, -0.09671365f, -0.12525699f, -0.04709015f, -0.06467633f, 0.04786332f, 0.00172885f, 0.00925246f, 
    -0.01117121f, -0.04689927f, -0.08243936f, -0.00881488f, -0.06363159f, -0.01830443f, -0.05238578f, -0.09292366f, 
    0.09827999f, -0.02457239f, 0.04462630f, 0.05917655f, -0.02956356f, 0.12334672f, 0.20628683f, 0.07763096f, 
    0.10690421f, 0.07479694f, 0.10336059f, -0.01023859f, 0.02042655f, -0.03117286f, -0.03745280f, 0.05663434f, 
    0.08715139f, -0.00648279f, -0.04196959f, -0.00296174f, 0.00422861f, -0.01727521f, 0.04323030f, -0.00829599f, 
    -0.04970584f, 0.13374108f, 0.13490883f, 0.05767597f, 0.14569819f, -0.00735938f, 0.03697779f, 0.01562278f, 
    0.02611070f, 0.03267561f, -0.07807168f, -0.00786460f, 0.02854588f, -0.03921715f, -0.03231234f, 0.07326142f, 
    0.08333807f, 0.05927347f, 0.02644853f, 0.02862828f, 0.06906899f, 0.14156476f, 0.18829654f, 0.11796364f, 
    0.14818639f, 0.00234485f, 0.07084373f, -0.07184429f, 0.00831214f, -0.06971927f, -0.08208612f, 0.01576433f, 
    -0.09059753f, -0.03607212f, -0.04814355f, 0.04577028f, -0.03464587f, 0.07342412f, -0.02988883f, -0.05454342f, 
    0.14500999f, 0.06245765f, 0.06720155f, 0.02637940f, 0.13105662f, -0.06879795f, 0.00243152f, -0.01893879f, 
    -0.06974556f, -0.02120926f, -0.02395562f, 0.01474744f, -0.01100416f, -0.02449250f, -0.01495194f, -0.03590246f, 
    -0.04500759f, 0.02776424f, 0.00998134f, -0.01270523f, -0.07642408f, 0.13046318f, 0.20598912f, -0.00510531f, 
    0.13373196f, -0.03550069f, 0.06276616f, 0.05037574f, 0.03101143f, 0.03477190f, -0.05284280f, 0.02897087f, 
    -0.04871180f, -0.06186087f, -0.02793045f, -0.01250433f, 0.07529034f, 0.02425082f, 0.00448724f, 0.02600353f, 
    0.00488103f, -0.18950987f, 0.08439536f, 0.03947363f, -0.13948715f, 0.05201338f, -0.09174036f, -0.05429637f, 
    0.03389496f, 0.04311104f, -0.01851286f, 0.02326588f, -0.05154257f, 0.03356773f, -0.06104718f, -0.01551910f, 
    -0.04885383f, 0.00382607f, -0.02839690f, 0.00839816f, 0.10297870f, -0.14360632f, 0.05283598f, -0.03720956f, 
    -0.03327822f, -0.05641398f, -0.01209318f, 0.00091060f, -0.04587740f, -0.05718080f, -0.01584065f, -0.01845665f, 
    -0.05035047f, 0.01772231f, 0.00192467f, -0.01232555f, -0.01178449f, 0.00134064f, -0.01339747f, -0.01732361f, 
    0.19676173f, -0.30624995f, 0.12568311f, 0.02494966f, -0.04516686f, 0.04417293f, 0.01518894f, 0.05195128f, 
    -0.00250577f, 0.02416380f, -0.01629392f, -0.05570237f, 0.01376762f, 0.01502519f, 0.04186713f, -0.01380223f, 
    0.06917455f, 0.02283517f, 0.07698633f, -0.01993399f, 0.14238594f, 0.01184341f, 0.20166250f, 0.14186017f, 
    0.13149534f, -0.00924073f, 0.12099653f, -0.01166772f, 0.05897604f, 0.02955105f, 0.02542678f, 0.00906941f, 
    -0.05956212f, 0.00561765f, -0.00653235f, -0.09549525f, -0.01033870f, 0.08084258f, -0.03813304f, -0.03293227f, 
    0.07700495f, -0.17945872f, 0.08652096f, 0.00799786f, -0.01412973f, 0.00315401f, -0.00062383f, -0.02766745f, 
    -0.03128711f, 0.01300901f, 0.00440381f, -0.01004879f, -0.01627711f, 0.00611233f, -0.06279036f, -0.02961635f, 
    -0.00791619f, -0.01645376f, -0.01147679f, -0.01158941f, 0.00377424f, -0.07700332f, 0.09342168f, -0.04186665f, 
    -0.13603340f, 0.02391862f, -0.06707220f, -0.04347799f, -0.07338877f, 0.01048582f, -0.01225588f, 0.00619668f, 
    -0.02008600f, -0.01409466f, -0.06563347f, -0.08498506f, 0.02896786f, -0.03771365f, -0.01709862f, -0.05416694f, 
    0.04621456f, 0.05532673f, 0.01167397f, -0.03614644f, 0.03326466f, -0.10264015f, 0.02894440f, -0.04120569f, 
    -0.04685491f, -0.00463799f, -0.00113538f, 0.09552341f, 0.02384848f, 0.02935559f, -0.00939209f, 0.00009625f, 
    -0.02573527f, 0.00874056f, -0.02509679f, -0.03315123f, 0.10941370f, 0.03363999f, 0.02461358f, 0.07064085f, 
    0.10953715f, -0.05699762f, -0.02809397f, -0.05999914f, -0.03709549f, -0.00510032f, -0.02039817f, 0.04833839f, 
    -0.01485856f, -0.05267596f, -0.04787015f, -0.00560832f, -0.02518374f, 0.00460462f, 0.04184895f, -0.03735818f, 
    0.11368837f, -0.22463413f, 0.08294402f, 0.01670347f, -0.08192744f, -0.01537826f, -0.01320019f, -0.03335681f, 
    -0.05457533f, 0.05932495f, -0.01942931f, -0.00807362f, -0.03051918f, -0.00230492f, -0.02556821f, -0.07561922f, 
    0.07307034f, -0.02647983f, -0.01381307f, 0.01642994f, 0.01492607f, -0.12778798f, -0.03320259f, -0.03431522f, 
    -0.17571944f, -0.00107826f, -0.05652201f, -0.02000577f, -0.04532842f, -0.03529791f, -0.03092311f, 0.02626637f, 
    -0.03143207f, 0.00929450f, -0.08392299f, -0.01531484f, 0.05846376f, -0.03561090f, -0.00215164f, 0.01317527f, 
    0.07930176f, -0.03511083f, 0.11414549f, -0.04537158f, 0.04673559f, -0.02373994f, -0.00105793f, -0.11189146f, 
    -0.00673962f, 0.07140025f, -0.00029947f, 0.02289234f, 0.06349570f, -0.03561714f, -0.02698431f, -0.06991170f, 
    -0.02130165f, -0.01263163f, 0.09657229f, -0.04439031f, -0.19686671f, 0.06663382f, 0.12966023f, -0.02261595f, 
    0.03160438f, 0.03904590f, 0.02193508f, -0.07821183f, 0.10286867f, -0.04563785f, 0.02846138f, 0.00714164f, 
    0.05995648f, -0.00253212f, -0.01888899f, -0.06174405f, 0.00238391f, 0.08562060f, -0.03615033f, -0.01299972f, 
    -0.21039881f, 0.01112583f, -0.05962848f, -0.09313720f, -0.15971838f, 0.02198688f, -0.00132669f, -0.02627547f, 
    -0.03147830f, -0.04245976f, 0.01522477f, 0.02707910f, -0.03327052f, -0.03243272f, 0.01212660f, 0.00030015f, 
    -0.02651260f, 0.00408104f, -0.03511906f, -0.02877089f, 0.04393681f, 0.07351084f, 0.07292385f, -0.15969740f, 
    0.02613150f, -0.01111879f, 0.11196849f, 0.00613197f, -0.05512688f, 0.02915605f, -0.02239582f, 0.05643540f, 
    -0.01617804f, -0.08570111f, 0.03616447f, 0.00513834f, 0.01419002f, -0.00989547f, -0.03056136f, 0.02662549f, 
    0.00230082f, -0.26285291f, -0.11079866f, -0.10641096f, -0.15645976f, -0.04861084f, -0.03043140f, 0.05384784f, 
    -0.04385821f, -0.06737985f, -0.01785054f, -0.06639189f, -0.01224669f, 0.00728996f, 0.00828795f, 0.02208607f, 
    0.02830365f, -0.05553237f, -0.04722622f, -0.04737785f, 0.03973137f, 0.10150785f, -0.01245925f, -0.01626602f, 
    -0.00559762f, -0.07315995f, 0.05515716f, -0.00895652f, 0.08583146f, 0.00699112f, -0.02532306f, 0.07600520f, 
    -0.04548848f, 0.00486343f, 0.00212207f, 0.00518722f, -0.04937524f, 0.03625049f, -0.03083709f, 0.01361292f, 
    0.01610117f, 0.12770301f, 0.09157075f, 0.00800280f, -0.01234365f, -0.03658901f, -0.03956832f, -0.01642793f, 
    0.04148261f, 0.01130058f, -0.03139303f, 0.00168166f, 0.03038655f, 0.05623937f, -0.01897774f, 0.01787077f, 
    -0.01917781f, -0.02175274f, -0.05204502f, -0.02251651f, -0.02005081f, -0.08052918f, -0.12763792f, 0.03334707f, 
    0.06401276f, -0.03297226f, -0.01567829f, -0.03795110f, 0.02184961f, -0.02694801f, -0.03329872f, -0.05361024f, 
    -0.01107026f, 0.03411733f, -0.02693066f, -0.04999887f, -0.02311093f, -0.01923145f, -0.03988282f, -0.00917720f, 
    0.11103451f, -0.02938923f, -0.00687346f, -0.07024781f, 0.14209622f, -0.11024889f, 0.02366634f, 0.00031022f, 
    0.03164387f, -0.02825510f, 0.01465178f, 0.02037122f, -0.06100582f, 0.07148259f, -0.02122457f, -0.01072925f, 
    0.01510515f, -0.01248999f, -0.02532073f, -0.03250303f, -0.04126114f, 0.03312425f, 0.02898424f, -0.08879764f, 
    -0.12136780f, -0.03467321f, -0.09262840f, 0.03010913f, -0.07679415f, -0.07191113f, 0.05392445f, -0.03477361f, 
    -0.02937632f, -0.02108932f, -0.05800523f, 0.00747264f, 0.00724324f, -0.03252831f, -0.02716027f, 0.03765829f, 
    -0.09474375f, -0.02497398f, -0.12520616f, -0.09581951f, -0.25614330f, 0.03152839f, -0.01741771f, -0.10810649f, 
    0.08584721f, -0.04462387f, 0.05645598f, -0.01705413f, -0.00701004f, -0.10421217f, 0.07900859f, -0.02154197f, 
    0.01304818f, -0.08985738f, 0.08957953f, -0.11181884f, 0.19086953f, 0.12426362f, -0.02217182f, 0.06637745f, 
    0.12215886f, 0.00760055f, -0.03000664f, 0.02909971f, -0.01344222f, -0.02231360f, -0.03930139f, 0.00146713f, 
    -0.05700498f, 0.01856125f, -0.03876545f, 0.06892086f, -0.06347542f, 0.04451534f, 0.01550221f, 0.01598022f, 
    -0.05299179f, 0.04885970f, -0.11222129f, -0.11637596f, -0.10546876f, 0.04466701f, 0.00768880f, -0.03594572f, 
    0.03289239f, -0.02648694f, 0.10020021f, -0.01365634f, 0.02960388f, 0.04698783f, -0.03180319f, -0.01425605f, 
    0.02863597f, -0.02302918f, 0.02684199f, 0.03614818f, -0.11653647f, -0.04965699f, -0.07404070f, 0.01298206f, 
    0.03175950f, 0.02549107f, 0.01350417f, -0.06734844f, -0.10492709f, -0.07109114f, 0.04061119f, -0.00539453f, 
    0.05266330f, -0.05294276f, -0.00901433f, -0.01226171f, 0.12360396f, -0.00597700f, -0.01944955f, -0.05228012f, 
    0.04060066f, 0.01853498f, -0.09389139f, 0.00250660f, 0.01774435f, -0.01758761f, 0.03304205f, -0.09878318f, 
    0.00458686f, -0.01171587f, 0.05628566f, 0.02545910f, 0.03816499f, -0.08599828f, -0.01416412f, -0.01062235f, 
    -0.00401185f, -0.03528013f, 0.06693230f, -0.00179057f, 0.04786393f, 0.10788588f, -0.04001943f, 0.05852497f, 
    -0.10711680f, -0.07263644f, 0.05962956f, -0.00191862f, -0.05202181f, -0.00362396f, 0.04228634f, 0.06315445f, 
    0.05439777f, 0.03516621f, 0.00523996f, -0.01897894f, -0.00858919f, -0.02396547f, 0.07328144f, 0.01919418f, 
    -0.07848314f, -0.06082012f, -0.03721036f, -0.20500651f, -0.04928488f, 0.01430588f, -0.04238038f, 0.00541439f, 
    -0.01906652f, -0.09922152f, 0.05653488f, -0.00774401f, 0.02999709f, 0.01377441f, 0.04589232f, 0.04824427f, 
    -0.05010150f, 0.02708310f, -0.10892887f, -0.00632298f, -0.05022642f, 0.11630568f, -0.01791558f, 0.00614575f, 
    0.00848898f, 0.05540013f, 0.04801057f, -0.05473733f, -0.00887193f, -0.03526122f, 0.03350381f, -0.01068370f, 
    -0.02148499f, 0.03151222f, -0.05987984f, -0.11895116f, 0.06154118f, 0.02388093f, 0.04024100f, -0.11098940f, 
    0.00483355f, 0.08356638f, 0.00888639f, -0.03613073f, -0.01370780f, -0.01534709f, -0.00833243f, -0.10570597f, 
    0.06701891f, -0.05457928f, 0.02544241f, 0.02005992f, 0.04481655f, -0.03685099f, 0.01958028f, -0.05760390f, 
    0.02260838f, -0.03179961f, 0.02089886f, -0.04571287f, 0.09351515f, 0.15141055f, -0.14053333f, 0.09350815f, 
    0.01600026f, -0.03899961f, -0.06536421f, -0.12989649f, -0.02696051f, -0.05209298f, 0.04633364f, -0.02779118f, 
    0.04075156f, -0.02376631f, 0.00791214f, 0.05205535f, 0.00211252f, -0.03141718f, 0.08722669f, 0.01718117f, 
    -0.14467382f, -0.20528229f, 0.04812643f, -0.38029942f, -0.14748225f, -0.03371575f, -0.01865422f, 0.00974826f, 
    -0.01585428f, -0.01025456f, 0.02290392f, 0.03554213f, 0.02597864f, 0.07241730f, -0.00095724f, -0.02783423f, 
    -0.00899330f, 0.04995115f, -0.26144895f, -0.05252029f, -0.12596951f, -0.06877035f, 0.21290913f, -0.05105544f, 
    -0.12542446f, -0.07669786f, 0.05133109f, -0.00225259f, 0.01053834f, -0.00114948f, 0.02303012f, 0.07519980f, 
    -0.05584494f, 0.07610279f, -0.01801643f, 0.00568680f, 0.00147109f, -0.04984851f, -0.05246590f, -0.02341023f, 
    0.04655053f, -0.23010865f, 0.01945424f, -0.09770056f, 0.00104937f, -0.02060343f, -0.06829708f, -0.01724967f, 
    -0.05321736f, -0.01639680f, 0.01600050f, 0.00421523f, 0.03768169f, -0.00808662f, -0.01502091f, -0.03120280f, 
    -0.07911511f, 0.01102957f, 0.09360007f, 0.08340468f, -0.11897432f, -0.04437466f, -0.17599459f, -0.13895072f, 
    -0.01731566f, 0.00426288f, -0.03416505f, -0.04745059f, -0.03213611f, -0.06900025f, 0.10692544f, -0.05776564f, 
    0.00703971f, -0.03928117f, 0.06733165f, -0.04825139f, 0.01372004f, -0.03837948f, -0.02936844f, -0.02499520f, 
    0.05664524f, 0.14972505f, 0.03776309f, 0.05310530f, 0.03558729f, -0.03165147f, -0.04262224f, -0.02407980f, 
    -0.08617826f, -0.06650738f, 0.08670714f, -0.02894942f, 0.00234156f, -0.03905127f, 0.01461932f, -0.05981609f, 
    0.00474984f, 0.03440848f, 0.05324556f, -0.04355896f, -0.12062075f, -0.06418361f, 0.16928315f, 0.06141107f, 
    0.17408855f, -0.07306326f, -0.06761958f, 0.01449459f, -0.08787197f, -0.01359212f, 0.05156771f, -0.00591493f, 
    -0.06542237f, 0.00540489f, 0.01609245f, -0.01835371f, -0.00846288f, 0.02909923f, 0.00206050f, 0.04180471f, 
    0.01162968f, 0.10365087f, -0.07660591f, 0.10980152f, -0.01900477f, 0.00104254f, -0.02938643f, -0.11236321f, 
    -0.09212309f, 0.05106944f, 0.03095037f, 0.04930970f, -0.01557689f, 0.01365217f, -0.04336347f, 0.00985796f, 
    -0.02343134f, -0.06405199f, 0.02024449f, 0.01384405f, -0.19220074f, 0.06557894f, 0.04967427f, -0.26149148f, 
    -0.13984755f, 0.03493632f, 0.03812738f, 0.04103050f, -0.01872708f, -0.01706061f, -0.00633266f, -0.01627796f, 
    -0.18302673f, -0.05769742f, -0.00667208f, -0.05334532f, -0.00914439f, 0.03147760f, -0.06091077f, -0.09784582f, 
    -0.04562707f, 0.09312688f, -0.19047417f, 0.03243905f, -0.05662440f, -0.00250530f, -0.00763562f, -0.05160154f, 
    -0.04556327f, 0.01437289f, 0.01447343f, 0.02442828f, -0.05160571f, 0.00947294f, 0.01960628f, -0.03626185f, 
    -0.06856116f, -0.04045806f, 0.02312748f, -0.03180467f, -0.14977384f, -0.02213125f, -0.10625884f, 0.04482073f, 
    0.02308810f, 0.10852481f, -0.05646009f, -0.07390410f, 0.02355071f, 0.02939197f, 0.11691222f, 0.05816267f, 
    0.03951450f, -0.07819422f, 0.09328903f, -0.01634104f, 0.03049928f, -0.02845603f, 0.04364741f, -0.04024954f, 
    0.07761353f, 0.04764984f, 0.01051469f, 0.09818342f, 0.13769217f, -0.03566786f, -0.06186024f, -0.07528385f, 
    -0.07085710f, 0.00319551f, -0.12603603f, -0.01448582f, -0.05379506f, 0.01409999f, 0.12078018f, -0.00636521f, 
    -0.01513546f, 0.00680966f, -0.00999134f, 0.08203781f, -0.09831567f, 0.16112395f, -0.05230629f, -0.19236569f, 
    -0.19014882f, -0.13490030f, -0.00866250f, -0.06360664f, -0.04580245f, -0.10520166f, 0.07737980f, 0.04754531f, 
    0.04363835f, 0.04960881f, 0.03706890f, 0.01300882f, 0.04786093f, -0.15711686f, -0.00845306f, 0.05486775f, 
    0.03516554f, 0.08563239f, -0.10141398f, 0.04584596f, -0.02687772f, 0.04461258f, -0.07278013f, -0.06807337f, 
    0.00682427f, 0.03123632f, 0.01203879f, 0.00048249f, -0.02013208f, 0.04327795f, -0.03470372f, 0.06133402f, 
    -0.02658512f, -0.03304796f, -0.00253734f, 0.07871993f, 0.01563116f, -0.09192879f, 0.10839224f, 0.10822209f, 
    0.12383479f, -0.11476386f, 0.01269167f, 0.05602526f, -0.05082821f, 0.00109922f, -0.00715426f, -0.03036548f, 
    -0.07794287f, -0.07148613f, 0.04375716f, 0.03881949f, -0.03057132f, -0.01431410f, 0.04599880f, 0.01961101f, 
    0.00081849f, -0.18827161f, -0.12239792f, -0.02473744f, 0.11103792f, 0.05037367f, 0.01896010f, -0.05766279f, 
    -0.04163119f, -0.05379622f, 0.06499591f, 0.00992625f, 0.02798917f, 0.05776281f, 0.04017011f, -0.03131156f, 
    0.07031804f, 0.07539016f, 0.06470373f, 0.00378674f, 0.05018832f, 0.01439642f, -0.06208888f, 0.07678390f, 
    0.13847704f, 0.05171637f, 0.02664098f, -0.05785486f, -0.00731408f, -0.00429595f, -0.00731173f, -0.03516473f, 
    0.03950175f, -0.00275730f, 0.04055500f, -0.01154019f, 0.02959122f, 0.03082048f, 0.07189365f, 0.00639156f, 
    0.02243559f, -0.00298200f, 0.02852866f, -0.06741948f, 0.07757152f, 0.08404298f, 0.02222487f, -0.05152171f, 
    0.00053730f, 0.00627356f, -0.00532735f, 0.07915378f, -0.06925321f, -0.03397994f, -0.02874232f, -0.04215484f, 
    -0.03974217f, 0.06915073f, -0.06629100f, 0.00081849f, 0.01856953f, 0.00781326f, 0.08069737f, 0.02129885f, 
    0.08208951f, 0.00222091f, 0.01889087f, -0.02571318f, -0.04292179f, -0.01823347f, 0.03122896f, 0.02899783f, 
    -0.00411561f, -0.02381733f, 0.04662837f, -0.02145227f, 0.01627631f, 0.04128611f, 0.04166042f, -0.05147492f, 
    -0.15838268f, -0.19488767f, 0.13563171f, -0.03995669f, -0.06266420f, 0.07185683f, -0.01543114f, 0.04118106f, 
    -0.15843177f, -0.01282116f, -0.02155432f, 0.02959708f, 0.06467030f, 0.03439140f, 0.02047100f, -0.03712194f, 
    -0.03484815f, -0.03411205f, -0.05947448f, 0.05132512f, 0.03045310f, -0.04448089f, 0.02976124f, 0.08535794f, 
    0.09184191f, 0.02113890f, 0.02433377f, -0.03117265f, -0.05631391f, 0.00199162f, 0.00652383f, 0.03278613f, 
    0.03880433f, 0.00635327f, -0.01826517f, -0.04735457f, -0.00227842f, 0.07064037f, 0.03186170f, -0.05016111f, 
    -0.05656567f, -0.19109145f, -0.16961597f, 0.05993861f, 0.02281535f, 0.02624074f, 0.02975142f, -0.01042800f, 
    -0.08064491f, -0.03048267f, 0.05800916f, -0.02668429f, 0.05348362f, 0.02922926f, 0.09798822f, -0.02949722f, 
    0.09520356f, 0.00374404f, 0.03452053f, -0.05374109f, -0.15961546f, 0.03752188f, -0.01852466f, -0.13048373f, 
    -0.21325840f, 0.02513876f, 0.02044672f, -0.04852398f, -0.09185188f, -0.07967702f, -0.00545782f, 0.00212267f, 
    0.01840777f, 0.00540448f, 0.00447352f, -0.01816930f, -0.02980997f, -0.07529152f, -0.18061993f, -0.01697947f, 
    0.17947291f, 0.05934352f, -0.01443023f, 0.00766497f, 0.04229428f, -0.01936917f, 0.04482254f, -0.05843701f, 
    -0.02896852f, -0.07879768f, -0.01358004f, 0.01755130f, 0.00492785f, -0.07316960f, 0.02052318f, -0.07738931f, 
    -0.00713020f, -0.01285146f, 0.04909172f, -0.04722423f, -0.19661298f, 0.04021286f, -0.22041269f, -0.05801777f, 
    -0.08901975f, 0.04311039f, -0.07828284f, -0.09852246f, -0.05096180f, 0.00208030f, 0.03972735f, 0.00225758f, 
    -0.12464193f, 0.09319896f, -0.00657063f, 0.03656980f, 0.00836500f, -0.04934971f, 0.01221122f, 0.07299146f, 
    -0.10068461f, 0.16590461f, -0.00664296f, -0.14926304f, -0.12963413f, 0.01453645f, 0.01803482f, 0.01904020f, 
    0.01853982f, -0.01263750f, 0.05073170f, -0.00173457f, 0.01039623f, 0.00212332f, -0.02434941f, -0.07760673f, 
    0.03830935f, -0.08414029f, 0.04712460f, 0.04956357f, -0.17837499f, -0.09535129f, 0.17206183f, -0.04529885f, 
    0.07936760f, -0.01656423f, 0.00755304f, 0.05008559f, -0.07679987f, -0.04053752f, -0.01026387f, -0.03887805f, 
    0.04737941f, -0.01533558f, 0.04566226f, -0.01055746f, -0.05630766f, 0.02728407f, -0.13714546f, 0.03141325f, 
    -0.02843677f, 0.05061575f, -0.16005690f, -0.02162372f, -0.06152354f, -0.00627374f, -0.02304834f, -0.01411707f, 
    -0.06109687f, -0.03720906f, 0.04954796f, 0.03439236f, 0.02914346f, 0.04098252f, 0.01890428f, 0.02803468f, 
    0.00093541f, -0.11359836f, -0.00634193f, 0.01120930f, 0.12859522f, 0.07854975f, -0.04173857f, 0.03558707f, 
    0.10693608f, -0.11011113f, -0.01153786f, -0.02980584f, -0.01138660f, -0.04331408f, 0.00422313f, 0.00983079f, 
    -0.07291661f, -0.04668551f, 0.04126852f, 0.00488025f, 0.03726094f, 0.03874430f, 0.10055510f, 0.02113576f, 
    0.09683897f, -0.00410782f, -0.05977731f, -0.04990384f, 0.10336234f, 0.11952508f, -0.00005265f, 0.01191380f, 
    -0.00977120f, 0.03330768f, 0.00090708f, 0.01072554f, -0.11310819f, 0.06291375f, -0.07096171f, 0.03430796f, 
    -0.03424435f, 0.03567103f, 0.01201606f, -0.01549624f, -0.12170813f, -0.10837957f, 0.18998140f, 0.02935445f, 
    0.11439725f, -0.00970576f, -0.02542623f, -0.01126360f, -0.10628577f, 0.07273631f, -0.03587346f, -0.02600128f, 
    -0.13443965f, -0.03670555f, 0.05746996f, -0.02974408f, 0.01639104f, 0.02649390f, 0.01322487f, -0.00748850f, 
    -0.02829222f, -0.03664609f, 0.02508896f, -0.04770363f, -0.10386670f, -0.02464657f, -0.06428941f, 0.03424964f, 
    -0.05532665f, 0.09133264f, 0.03199400f, 0.01438437f, -0.00605541f, -0.14567605f, -0.04824813f, -0.04305739f, 
    -0.00381993f, -0.09241164f, 0.06442364f, -0.03613197f, -0.23804086f, 0.11648905f, 0.20502497f, -0.02226960f, 
    -0.03142766f, -0.06668914f, 0.03643456f, 0.00855428f, 0.00354298f, -0.06181169f, 0.01511371f, 0.02985367f, 
    -0.05285918f, 0.01495450f, 0.02027149f, -0.07594130f, 0.03243476f, -0.09824029f, -0.00575603f, -0.02601195f, 
    -0.16453357f, -0.04580459f, 0.08092775f, -0.19789194f, -0.10997077f, -0.01055895f, -0.04855549f, -0.02727146f, 
    0.02437456f, -0.09651671f, -0.01966801f, 0.00510392f, -0.03901245f, 0.05619209f, -0.01845345f, 0.01880946f, 
    0.02664295f, -0.05289584f, -0.28772911f, 0.01164629f, 0.02007027f, 0.02918299f, 0.09995805f, 0.00233020f, 
    -0.10143733f, -0.05491513f, -0.04383577f, 0.08543997f, -0.02352838f, 0.06587543f, 0.02338349f, -0.04501174f, 
    -0.00678581f, -0.10669471f, -0.00135618f, 0.03109745f, -0.09728831f, -0.10870431f, 0.04306896f, -0.05061439f, 
    0.03557978f, -0.00274896f, 0.02907594f, 0.09006984f, 0.09719040f, -0.08426686f, -0.03615060f, -0.06705146f, 
    -0.07087185f, 0.08439553f, -0.05275317f, 0.01112641f, 0.03423972f, 0.02114505f, -0.04086635f, 0.00165067f, 
    0.00205368f, -0.01020147f, 0.04607661f, 0.02910339f, -0.00995751f, -0.08369476f, -0.10665172f, 0.10093901f, 
    0.06550852f, 0.08401520f, 0.01851053f, -0.02607108f, 0.00187644f, -0.02522469f, 0.01647794f, 0.00996123f, 
    0.04061671f, 0.03981520f, -0.01320685f, 0.01751917f, 0.00155780f, 0.00149993f, 0.02660256f, -0.05640100f, 
    0.13121565f, -0.16895643f, -0.03946684f, 0.02608043f, -0.00060580f, -0.05758277f, 0.02875739f, -0.01943461f, 
    0.01390833f, 0.01162844f, 0.03643484f, 0.05865083f, 0.02358369f, 0.01992080f, 0.06013307f, 0.04519999f, 
    -0.02840072f, -0.01312570f, -0.00068042f, 0.03341913f, -0.12614465f, -0.01030310f, 0.11895601f, -0.06651863f, 
    0.01378579f, -0.07405733f, -0.06191632f, 0.00826319f, 0.01428669f, -0.10293881f, 0.00613872f, -0.02016374f, 
    -0.05772695f, 0.01058380f, 0.04688307f, -0.03527765f, 0.01854386f, -0.04716459f, -0.02109404f, -0.04062080f, 
    0.03275998f, -0.01960215f, 0.12130407f, -0.00511159f, 0.07445081f, -0.00366129f, -0.01811755f, 0.02746691f, 
    -0.04843951f, 0.03241032f, 0.00971840f, -0.00280160f, -0.02205620f, -0.06122196f, 0.03699686f, 0.02061223f, 
    -0.03104516f, 0.05747208f, -0.00299481f, -0.02478564f, 0.02361326f, 0.11524291f, -0.00746973f, -0.02044946f, 
    0.00948410f, 0.06259074f, -0.01920792f, -0.03629454f, -0.04113368f, -0.01100266f, -0.05159703f, -0.00264609f, 
    0.01627479f, 0.02311659f, 0.00008818f, 0.04270596f, -0.02821540f, -0.04185552f, -0.01624592f, -0.00419856f, 
    0.02642833f, 0.15536436f, -0.16056249f, -0.03268335f, -0.02195632f, 0.02605057f, 0.04485575f, -0.05117129f, 
    -0.03793316f, 0.05844739f, 0.05220359f, 0.06689619f, -0.00878495f, 0.07962700f, 0.03854360f, 0.02190251f, 
    0.02888919f, -0.02524570f, 0.02565497f, 0.08820435f, -0.14974762f, -0.10033199f, 0.09218417f, -0.17371458f, 
    -0.06425086f, 0.05617819f, 0.01945089f, 0.01331639f, 0.00740873f, -0.06335155f, -0.04585696f, 0.00841874f, 
    -0.05688062f, 0.02953667f, -0.03488085f, -0.04140705f, 0.02434238f, 0.04629672f, -0.15154180f, -0.01628996f, 
    -0.06576810f, -0.04694204f, 0.11631774f, -0.03205388f, 0.10169682f, -0.03325928f, -0.02288595f, -0.03646824f, 
    -0.03833051f, 0.04004911f, -0.05639841f, 0.05761681f, 0.01852850f, -0.06923460f, -0.03941221f, -0.05910292f, 
    -0.05584994f, -0.00351928f, -0.06953585f, -0.02396219f, 0.07399229f, -0.04077548f, 0.08640415f, -0.05468095f, 
    0.12869932f, 0.01071267f, 0.00234476f, -0.06276115f, 0.01506793f, -0.01045923f, -0.02607658f, -0.00064256f, 
    0.03578819f, -0.05332874f, 0.03921461f, -0.00706550f, -0.02846457f, 0.04976248f, -0.06606801f, 0.05371822f, 
    -0.08503690f, -0.02763211f, 0.11561656f, -0.14945519f, -0.02659225f, 0.02318508f, 0.01506266f, 0.13961875f, 
    0.07023413f, -0.05371913f, -0.06502388f, -0.00527214f, 0.08018353f, 0.06243961f, 0.00728198f, -0.04178914f, 
    -0.05836265f, 0.09267171f, -0.11621933f, 0.00598457f, -0.10523695f, 0.16120239f, -0.25028807f, -0.08087709f, 
    -0.09212848f, 0.09259687f, 0.03765379f, -0.02673598f, 0.02286414f, 0.00469950f, 0.01871834f, 0.03564489f, 
    0.07527199f, 0.01947977f, -0.02253646f, 0.09895081f, -0.09291761f, -0.07976682f, 0.03294440f, 0.01335286f, 
    0.03191585f, 0.12198244f, -0.05015157f, 0.05878011f, 0.02464143f, 0.02149316f, 0.03008091f, -0.03705602f, 
    -0.02304792f, -0.05539434f, 0.03231607f, -0.00809441f, -0.02181437f, -0.01321738f, 0.05271269f, -0.09722257f, 
    -0.01978728f, 0.00342618f, 0.04304209f, -0.07077994f, -0.03427149f, 0.19303772f, -0.05940761f, 0.02175532f, 
    -0.01069557f, -0.04551363f, -0.00091945f, 0.04892693f, -0.01381026f, -0.05755289f, 0.05533681f, 0.02770450f, 
    -0.03321024f, -0.06257784f, 0.01399727f, -0.00431333f, -0.02122766f, 0.00823750f, 0.00970000f, -0.02026056f, 
    0.14056715f, 0.00999383f, -0.06505106f, 0.10877824f, 0.11925801f, 0.07646030f, 0.06963395f, -0.03226920f, 
    -0.06777395f, -0.01234236f, 0.02238990f, 0.03347712f, -0.02110329f, -0.02418412f, -0.02324555f, -0.09361020f, 
    -0.04306901f, 0.03293857f, 0.06840278f, -0.05444894f, -0.02083810f, 0.12395481f, -0.01406692f, -0.08877002f, 
    -0.15623760f, -0.05528794f, 0.05737801f, -0.01811058f, 0.02438120f, -0.06652945f, 0.08322977f, -0.01102376f, 
    0.01378054f, -0.02676300f, 0.02008520f, -0.08388341f, 0.02223105f, -0.03808559f, 0.06149002f, -0.11387769f, 
    0.05608070f, -0.03409659f, -0.05353077f, 0.03748484f, -0.02207676f, -0.00750362f, -0.01533601f, -0.14188865f, 
    -0.03674779f, -0.03722434f, 0.03978075f, -0.01256566f, 0.04895666f, -0.10986935f, 0.03563250f, -0.07079379f, 
    0.01581181f, -0.09281613f, 0.12671365f, -0.05209687f, 0.13835567f, -0.05176611f, -0.04733567f, -0.09037182f, 
    0.02740210f, -0.00262905f, 0.04149801f, 0.03516515f, -0.07778571f, -0.03146221f, -0.01153727f, -0.00132735f, 
    0.03648284f, 0.05787038f, -0.04278284f, -0.01297499f, 0.02618576f, -0.00951927f, -0.01470936f, 0.00613504f, 
    -0.00271369f, -0.05517919f, 0.00624572f, -0.03818436f, 0.04869226f, 0.04962824f, -0.01246096f, -0.01248691f, 
    -0.03960900f, -0.01229765f, 0.05566145f, 0.01254452f, 0.05638987f, -0.01443830f, 0.00653952f, 0.01960570f, 
    0.03516310f, 0.05576161f, 0.03936181f, 0.01982177f, 0.16819108f, 0.06920215f, -0.02949349f, 0.05201170f, 
    0.09529129f, 0.01770077f, 0.03148621f, -0.09532362f, -0.02648730f, -0.02049094f, -0.02569546f, -0.01999110f, 
    -0.00749009f, -0.08824573f, -0.01987826f, -0.07557873f, 0.03305094f, 0.01402661f, 0.09221727f, 0.03765851f, 
    -0.17999731f, 0.08457501f, 0.13334395f, -0.11955792f, -0.00058129f, 0.01576996f, 0.07584114f, -0.09538586f, 
    -0.05404947f, 0.03074955f, -0.05918166f, -0.00094233f, 0.00923010f, 0.06911976f, 0.10024412f, 0.07601234f, 
    0.08003257f, 0.07021268f, 0.01343437f, 0.08666755f, -0.01656201f, -0.04013002f, 0.08163894f, -0.16298950f, 
    0.00859733f, 0.04279125f, 0.07644480f, -0.01720409f, -0.05243091f, -0.06344777f, -0.07372159f, 0.08357865f, 
    0.01638836f, 0.05256677f, -0.02958341f, -0.05032143f, 0.02731230f, -0.15837909f, 0.03897529f, -0.08778332f, 
    -0.16113690f, 0.00458935f, 0.06445496f, 0.04902107f, -0.16297847f, -0.07101692f, 0.05200083f, 0.09902860f, 
    -0.03253894f, 0.00348081f, -0.01861837f, -0.06782492f, -0.04809160f, -0.01792151f, -0.00660155f, 0.02806742f, 
    0.00927321f, -0.07790039f, 0.02316437f, -0.07011917f, 0.05704806f, -0.06738442f, -0.10569640f, -0.16470750f, 
    -0.30274644f, -0.01882370f, 0.07007885f, -0.07994507f, 0.02980033f, -0.05386483f, -0.09116311f, 0.01573011f, 
    -0.04310118f, 0.02941780f, 0.01868205f, -0.02065034f, 0.04078620f, 0.08453377f, 0.00775419f, 0.01688185f, 
    -0.21162334f, 0.05275770f, 0.15098123f, -0.02972107f, 0.09871052f, 0.00148882f, -0.01905456f, 0.05137896f, 
    0.00016029f, -0.07528117f, 0.05629223f, 0.00698147f, 0.02273317f, 0.02945952f, 0.05043241f, 0.00717316f, 
    0.02081882f, -0.00651384f, -0.07137735f, 0.03898728f, -0.16854466f, 0.25439540f, 0.15807684f, -0.01073117f, 
    -0.00601693f, 0.06268067f, 0.03909510f, 0.01222460f, 0.03687052f, -0.01645626f, 0.02071249f, -0.01507052f, 
    0.02149656f, -0.06337553f, 0.05438557f, 0.07706188f, 0.01586440f, 0.07558934f, -0.12233037f, -0.03295845f, 
    -0.04128059f, -0.00285348f, 0.08610748f, -0.20163982f, -0.06343061f, -0.07445219f, 0.09770529f, 0.00177289f, 
    0.04877155f, 0.08496809f, 0.01532501f, -0.08057883f, 0.05429829f, -0.12384710f, -0.06457691f, -0.02168045f, 
    -0.00042537f, 0.06185510f, 0.04088626f, 0.01472254f, 0.23692544f, 0.01601693f, 0.04601365f, -0.11956947f, 
    -0.26192957f, -0.02563289f, 0.04482934f, 0.04193918f, 0.02305030f, 0.06786897f, -0.00369446f, -0.03899556f, 
    -0.08946191f, -0.13427351f, 0.09479354f, 0.04680964f, 0.05221074f, -0.10947023f, -0.04687783f, -0.01701081f, 
    -0.16498357f, -0.08611046f, 0.13624020f, -0.28116164f, -0.03153554f, -0.07779227f, 0.08621585f, 0.06789268f, 
    0.06635492f, -0.00858135f, 0.04283290f, 0.00249866f, 0.00644173f, -0.02469030f, 0.06914904f, 0.00357700f, 
    0.01575303f, 0.01766547f, -0.01679965f, 0.03430782f, -0.27614614f, -0.03871794f, 0.21675150f, -0.18404292f, 
    0.14198467f, 0.04239097f, 0.09471592f, -0.02857865f, -0.02886132f, -0.04464842f, -0.03652030f, -0.04690368f, 
    0.01361428f, 0.00509251f, -0.04241610f, 0.03506359f, 0.00191317f, 0.04374252f, -0.15403135f, 0.07850220f, 
    0.09696849f, -0.08833417f, 0.02048350f, -0.08598281f, -0.00575540f, -0.09754138f, 0.01542841f, 0.01754578f, 
    0.03331687f, 0.00635479f, 0.01021939f, -0.01994411f, 0.01869877f, -0.05920015f, -0.01543189f, 0.05142070f, 
    0.14131793f, 0.00240185f, 0.05133901f, 0.02903552f, -0.28218281f, -0.23767789f, -0.10979001f, 0.17983752f, 
    0.08558674f, 0.03059396f, 0.01399016f, 0.06444264f, -0.03809654f, 0.01548809f, 0.01321052f, 0.09198804f, 
    0.05581830f, -0.04474387f, -0.11173639f, -0.03965228f, -0.00399099f, -0.00708402f, 0.05339153f, -0.03942750f, 
    0.11736280f, 0.09139527f, -0.14922941f, -0.19710748f, 0.19175939f, 0.09208609f, -0.05424093f, -0.01668009f, 
    -0.12060798f, 0.13655502f, 0.03814070f, 0.00100737f, -0.02483413f, 0.10672080f, -0.07490760f, -0.02807507f, 
    0.03017575f, -0.01359928f, -0.07132161f, -0.10162283f, -0.16349420f, -0.29464552f, 0.16382216f, -0.05754174f, 
    0.10386182f, -0.04088831f, 0.00863403f, -0.05390859f, -0.00872280f, 0.09457923f, -0.12837553f, -0.02207385f, 
    0.04832370f, -0.01249713f, -0.03798462f, 0.16304408f, 0.07516970f, -0.17135133f, -0.10026681f, -0.03494453f, 
    0.39122102f, -0.02739155f, -0.17714913f, -0.00302854f, -0.05907924f, 0.05810491f, 0.06915686f, 0.09974547f, 
    -0.01156703f, -0.03869684f, -0.02923338f, 0.06687462f, 0.04032633f, 0.03929627f, -0.06388354f, -0.01257689f, 
    0.04749307f, -0.08526015f, -0.04279185f, 0.02018248f, 0.43574437f, -0.00226052f, -0.18763007f, -0.03730354f, 
    0.11592478f, 0.11823204f, -0.06254128f, 0.00476338f, -0.01917402f, 0.07233071f, 0.07054012f, 0.01390755f, 
    0.04570045f, 0.04258891f, -0.01160979f, -0.07389615f, -0.01117538f, -0.01650690f, 0.06891518f, -0.03278489f, 
    0.47340259f, -0.48959741f, -0.00759182f, 0.00357977f, 0.01426139f, -0.05871409f, -0.01413103f, 0.06210413f, 
    0.10633303f, -0.03217601f, -0.01984127f, -0.00901267f, -0.01452165f, -0.02211369f, -0.03514310f, 0.06237290f, 
    0.01420061f, -0.03491145f, -0.03709314f, 0.07573285f, -0.06859257f, -0.04181215f, -0.13382563f, 0.12944975f, 
    -0.04239935f, -0.12990068f, 0.04075067f, 0.02492201f, -0.03027531f, 0.02007633f, -0.03661572f, 0.02782066f, 
    0.07247747f, 0.00836886f, 0.05397673f, 0.02260489f, -0.04911486f, 0.07205601f, 0.00466986f, 0.09324992f, 
    -0.09433483f, 0.04057603f, 0.13240832f, 0.04825259f, -0.05841551f, 0.03588749f, -0.02284726f, 0.01263484f, 
    0.05121015f, 0.02965279f, 0.01667550f, 0.00756639f, 0.02668727f, 0.06788002f, -0.04244810f, 0.01854966f, 
    -0.00819822f, 0.04201432f, -0.03639307f, 0.03139444f, -0.16013797f, -0.23488627f, 0.06808539f, -0.28974164f, 
    0.13350601f, -0.13253753f, -0.02541505f, -0.09081332f, 0.00775265f, 0.03006302f, 0.03236589f, -0.17946145f, 
    -0.04317025f, 0.04276348f, 0.04433252f, 0.03714450f, -0.02516397f, -0.02844934f, -0.12853776f, -0.05408152f, 
    -0.23695360f, -0.14232227f, -0.12061147f, -0.03295178f, 0.00149572f, -0.04394371f, 0.08333880f, 0.06198959f, 
    0.05236941f, 0.10734104f, -0.10903408f, -0.00145118f, 0.02138790f, -0.10410929f, 0.00009481f, -0.01068822f, 
    -0.02511777f, 0.01123789f, -0.02377044f, 0.00786428f, -0.16655837f, 0.18942249f, -0.01874118f, -0.05569440f, 
    -0.17296626f, 0.06681877f, 0.04114877f, -0.02516780f, -0.04759668f, 0.04776044f, -0.10683500f, 0.05638699f, 
    0.01283279f, -0.02345767f, 0.11061074f, 0.01878130f, 0.00453685f, -0.07509479f, 0.03572338f, -0.00049992f, 
    0.07830469f, -0.15733872f, -0.08866514f, 0.04408811f, -0.03313370f, -0.02265239f, 0.04769396f, 0.01748092f, 
    0.00017762f, -0.02811054f, -0.00406469f, 0.01329028f, -0.02337802f, -0.07736436f, -0.04950003f, 0.00978372f, 
    0.01242890f, -0.03652487f, 0.04523852f, 0.01380457f, 0.19733018f, -0.15560243f, -0.03750367f, 0.05905435f, 
    0.01227454f, 0.09007136f, 0.01959719f, -0.05375836f, -0.06039635f, 0.07822774f, -0.05213559f, 0.01825413f, 
    -0.02610111f, -0.00698002f, -0.04915155f, -0.02361973f, -0.00262353f, -0.06031456f, -0.02090871f, -0.00994893f, 
    -0.17820895f, -0.11049835f, 0.06899747f, -0.03239042f, -0.20842354f, 0.01294649f, 0.10795475f, 0.00304783f, 
    -0.05746004f, 0.00383687f, 0.00649025f, -0.02578540f, -0.04839763f, -0.07776193f, -0.03841206f, -0.10145751f, 
    -0.05796216f, 0.02747150f, 0.00934170f, -0.01550894f, 0.07015273f, 0.05293018f, 0.02478126f, -0.20862761f, 
    -0.13746868f, 0.04338633f, 0.07738960f, -0.03223776f, -0.03271173f, -0.01733944f, 0.00352116f, 0.02357079f, 
    -0.03441570f, -0.04400494f, -0.04334513f, -0.05084865f, 0.02420665f, -0.05594852f, 0.00224718f, -0.00709513f, 
    0.11052272f, -0.20114252f, 0.07464640f, 0.05247703f, -0.17341679f, 0.03558353f, 0.10431099f, -0.11007355f, 
    0.01292708f, -0.05843771f, -0.02891840f, 0.08941568f, 0.10531098f, 0.02911772f, -0.05999593f, 0.02557496f, 
    0.01203341f, -0.05881667f, -0.08970081f, -0.08723328f, 0.08717813f, 0.06501559f, -0.05444245f, -0.26930317f, 
    -0.16786937f, 0.03631901f, 0.01122196f, -0.08775045f, 0.04103704f, 0.07700165f, -0.06476863f, 0.01240878f, 
    0.05249829f, -0.06992074f, -0.00624183f, 0.08987916f, -0.00787645f, -0.03858020f, 0.00357072f, -0.03600685f, 
    0.05414553f, -0.21044898f, 0.02176150f, 0.04724376f, 0.11027277f, -0.01462959f, 0.03558811f, 0.00547055f, 
    -0.04084663f, 0.03630448f, 0.00026975f, 0.03712130f, -0.05279974f, 0.00774948f, 0.03191429f, -0.02845434f, 
    -0.04102095f, 0.03015269f, 0.07736070f, -0.01643568f, 0.09998208f, -0.17984597f, 0.09238875f, -0.04127822f, 
    -0.17577420f, -0.02520522f, 0.07649823f, -0.03699910f, 0.04986315f, -0.05466917f, -0.03815041f, 0.00990126f, 
    -0.07480714f, -0.03642289f, -0.01427934f, -0.05212886f, 0.06731457f, 0.04444357f, 0.06267408f, 0.02188913f, 
    -0.27209210f, 0.01078672f, 0.00486452f, -0.13557288f, -0.12635393f, -0.06307567f, 0.09564746f, -0.20110172f, 
    0.00052058f, -0.07713190f, 0.01738875f, -0.02847802f, -0.06328713f, -0.06147521f, 0.01451894f, -0.00257979f, 
    -0.04010585f, 0.08853719f, -0.05653398f, 0.04635377f, -0.07602638f, -0.14415690f, -0.04956615f, 0.18636090f, 
    0.10038242f, -0.02007912f, 0.03950077f, 0.05960027f, -0.03417896f, -0.04841516f, 0.04038943f, -0.04747541f, 
    -0.12967014f, -0.04579564f, -0.05264335f, 0.02137683f, -0.05044077f, 0.06074994f, 0.04408903f, 0.09843254f, 
    -0.37955040f, 0.19873787f, 0.05611916f, 0.04677932f, 0.00769233f, 0.05513960f, -0.01505086f, 0.07173017f, 
    0.02809000f, -0.10494000f, 0.02359449f, 0.04749474f, -0.00727393f, 0.01792628f, 0.03348657f, 0.04072205f, 
    -0.04616043f, 0.07609497f, -0.03322097f, 0.06645027f, 0.09810996f, -0.37697461f, 0.08988753f, 0.06275760f, 
    -0.15610795f, -0.05627034f, -0.00667525f, -0.11377510f, 0.00201956f, 0.02173666f, 0.00043211f, 0.12844896f, 
    0.08083945f, -0.07835306f, 0.03566581f, -0.00834697f, -0.01076473f, -0.02981082f, 0.01561336f, -0.01983104f, 
    -0.06791643f, -0.00342785f, -0.21213982f, 0.10923917f, -0.20792367f, -0.00185854f, 0.03842334f, -0.06644752f, 
    0.00607112f, 0.04716364f, -0.08605725f, 0.01996901f, 0.00441666f, 0.15988408f, 0.10722078f, -0.02696349f, 
    -0.03631553f, -0.01618066f, 0.01379535f, -0.03715606f, 0.11422724f, -0.10932525f, -0.05130272f, 0.08324406f, 
    -0.03810884f, 0.03865710f, -0.06793963f, 0.00821409f, 0.06554411f, -0.00632242f, -0.05034905f, 0.09022876f, 
    0.00340214f, -0.01979220f, 0.05125959f, 0.04876694f, -0.02213928f, 0.07479696f, 0.02053123f, 0.05434436f, 
    0.15005794f, -0.15218103f, 0.04411137f, -0.08915498f, 0.15131280f, -0.13775069f, -0.01008565f, 0.00945113f, 
    0.07794706f, 0.00904518f, -0.03788082f, -0.00838628f, -0.03408096f, 0.00319899f, -0.05949795f, 0.03972781f, 
    -0.04350046f, 0.04069724f, -0.01669862f, 0.09797107f, -0.08489502f, -0.18635635f, -0.01802775f, -0.00910088f, 
    0.06571262f, 0.03690823f, 0.01654179f, -0.00492980f, -0.02802240f, -0.01486893f, 0.00156390f, 0.05275809f, 
    0.01633281f, 0.06990621f, -0.05283590f, -0.04990200f, 0.00315596f, -0.09065989f, 0.01671648f, 0.03216873f, 
    0.26401353f, -0.09798103f, 0.26005569f, -0.21723253f, -0.22834079f, 0.07954022f, -0.03602425f, 0.06293435f, 
    -0.12593098f, -0.01642535f, 0.04104874f, 0.02420871f, 0.03095222f, -0.08365399f, 0.02273471f, -0.05730201f, 
    -0.00325632f, -0.08189137f, 0.11125124f, 0.06499489f, -0.05968203f, -0.10419005f, -0.11162843f, 0.12082332f, 
    0.00763827f, 0.04123106f, 0.02089769f, -0.04149208f, -0.01184550f, 0.09521488f, -0.04508660f, 0.01432302f, 
    -0.02098705f, 0.00789315f, -0.03099844f, -0.03533598f, -0.06384909f, 0.01598796f, -0.00691609f, 0.01354567f, 
    -0.17354956f, -0.14659981f, 0.18028829f, 0.06034974f, 0.02065770f, 0.12684056f, -0.06967285f, -0.01853181f, 
    0.02571832f, 0.11469571f, -0.03601468f, 0.04879180f, -0.10037053f, 0.08451930f, -0.00450100f, 0.01593891f, 
    -0.10826883f, 0.04720367f, -0.04960496f, 0.03012823f, 0.26241517f, -0.04334566f, -0.01868767f, 0.12089152f, 
    0.08666105f, 0.00821883f, 0.05654087f, -0.02355647f, -0.02061148f, -0.03694661f, -0.04326163f, -0.01694941f, 
    0.11089504f, 0.06247269f, 0.07484104f, 0.05667966f, -0.03967329f, 0.11103266f, -0.05988526f, -0.00280522f, 
    -0.02282388f, -0.10585030f, -0.11497787f, 0.01896638f, 0.05215425f, -0.08551157f, 0.07913077f, 0.00593488f, 
    -0.08189964f, -0.08128791f, 0.08372147f, -0.02910593f, -0.01981812f, -0.06889386f, -0.03114987f, -0.06437241f, 
    0.00948525f, -0.05190205f, 0.16709666f, 0.03812269f, -0.24415201f, 0.02198268f, -0.00362738f, 0.14733040f, 
    0.11393942f, 0.12948613f, -0.05591560f, -0.06529754f, 0.06123368f, 0.19846684f, -0.10404480f, 0.01377912f, 
    -0.09538335f, -0.03550451f, -0.08924706f, 0.04565151f, -0.09788310f, -0.01765803f, -0.02588389f, -0.06447501f, 
    0.30676544f, -0.35606030f, -0.06349065f, 0.00495574f, -0.04251578f, -0.05749638f, 0.02399060f, -0.02313134f, 
    0.10385182f, -0.01031874f, -0.08412386f, 0.05355341f, -0.02982596f, -0.01963544f, 0.00887099f, 0.00851568f, 
    0.04873914f, 0.06501304f, -0.04380434f, 0.06643367f, 0.00348506f, -0.17201173f, 0.05176899f, -0.04135305f, 
    -0.05855481f, -0.00498173f, 0.01703585f, -0.10071675f, 0.01205724f, 0.04204700f, 0.00203036f, -0.00234124f, 
    -0.01492873f, 0.00967058f, -0.09874860f, 0.01983288f, -0.02317836f, -0.00011982f, 0.01895929f, 0.04058282f, 
    0.01413551f, -0.24494183f, 0.22878098f, -0.17396714f, 0.17029190f, 0.01470286f, -0.02897177f, -0.00148382f, 
    0.00368516f, 0.03399976f, -0.08597556f, -0.10217565f, -0.11093594f, -0.10640937f, 0.12036473f, -0.08823940f, 
    -0.00443373f, -0.06252489f, -0.05567716f, 0.13066541f, 0.06908058f, 0.04950116f, -0.08855190f, -0.00671909f, 
    -0.01101998f, 0.06691720f, -0.03033391f, -0.03486401f, -0.04642254f, 0.06601066f, -0.00186052f, -0.06152941f, 
    0.03851732f, 0.12779701f, 0.07006367f, 0.04617688f, -0.15993880f, 0.03891433f, 0.05673000f, 0.00066773f, 
    0.15135397f, -0.05609346f, -0.00443846f, 0.07283660f, -0.04597602f, 0.01876980f, -0.01752226f, 0.06132413f, 
    -0.03931559f, 0.01304158f, 0.00553922f, 0.03362594f, 0.04771265f, 0.02266561f, 0.00858220f, 0.05775900f, 
    0.03389735f, -0.01369166f, -0.00403239f, 0.01898368f, 0.22626901f, -0.29218036f, 0.05818335f, -0.10798156f, 
    -0.03338322f, -0.04606977f, 0.03109032f, -0.01493055f, 0.12880181f, 0.05828664f, -0.00589213f, 0.02725961f, 
    0.07413262f, -0.12400192f, -0.01263515f, 0.03214154f, 0.06342993f, -0.04291148f, -0.00470773f, -0.09549031f, 
    -0.19374838f, 0.05988213f, -0.05547396f, 0.02482893f, -0.19944867f, 0.09668981f, 0.01094314f, -0.01829297f, 
    -0.01316815f, -0.11158679f, 0.08815487f, -0.03745901f, 0.08339733f, 0.01526355f, 0.09006393f, -0.05276481f, 
    -0.06525330f, -0.01995896f, 0.00416105f, -0.08145919f, 0.16398883f, 0.00111768f, -0.05342265f, 0.06931722f, 
    -0.07522703f, -0.10080384f, -0.00305182f, 0.02992184f, 0.01720274f, 0.05840559f, 0.06857322f, 0.04459607f, 
    0.07521009f, -0.01728586f, 0.00848961f, 0.05290611f, 0.04642963f, -0.02666343f, 0.09442864f, 0.07598585f, 
    0.27752629f, -0.26180786f, 0.01055358f, 0.11162120f, -0.02511614f, -0.04649732f, -0.01023792f, 0.08341363f, 
    0.06726104f, -0.01940307f, 0.08414471f, -0.02053769f, 0.11888496f, -0.04358941f, 0.01755246f, 0.08866815f, 
    0.05152158f, 0.08911721f, -0.02647012f, -0.00969932f, 0.11925539f, -0.17133720f, 0.04489576f, -0.01147930f, 
    -0.14112449f, 0.01979768f, 0.08534881f, -0.00987930f, -0.03865292f, -0.03634078f, -0.00627241f, -0.05374159f, 
    0.04948848f, 0.04146757f, -0.05882318f, 0.02872915f, -0.01269638f, -0.01398348f, -0.07484087f, -0.11727463f, 
    0.00313916f, -0.08490089f, 0.02294402f, 0.12250131f, -0.08419832f, -0.13693857f, -0.10811149f, -0.04016706f, 
    0.20578043f, -0.06162544f, -0.06734814f, 0.05833419f, 0.00673329f, -0.04308084f, -0.02005797f, -0.01127206f, 
    0.07315747f, -0.05556012f, 0.13379394f, -0.09908532f, -0.11296016f, -0.14220209f, 0.28519937f, -0.09699173f, 
    0.00375707f, -0.13033667f, -0.00397649f, 0.02766403f, 0.06049201f, -0.02516587f, 0.04864849f, 0.01328650f, 
    0.02922277f, -0.00813852f, -0.02822676f, -0.02991620f, 0.05586630f, 0.10190373f, 0.04067476f, -0.04103493f, 
    0.04033454f, 0.03391642f, 0.14719534f, -0.06444874f, 0.02006417f, -0.04341999f, 0.03969797f, 0.08791853f, 
    0.00081979f, -0.07654378f, 0.03191638f, -0.01185880f, -0.00610199f, -0.10374265f, 0.02579591f, 0.01623904f, 
    -0.03690073f, 0.02937180f, -0.11208147f, -0.05375520f, -0.39100540f, 0.11686134f, -0.07052136f, 0.12380524f, 
    -0.12160215f, 0.02377956f, 0.04744541f, -0.04452283f, 0.03380365f, -0.01026317f, -0.03938159f, 0.02348413f, 
    -0.04289606f, 0.04095320f, 0.02152192f, 0.00584740f, -0.04410685f, -0.00910770f, -0.08360435f, -0.05686938f, 
    -0.03803177f, -0.09519102f, 0.00315159f, 0.06773906f, -0.22979116f, 0.06804818f, 0.11007401f, 0.02656256f, 
    0.01115265f, -0.06934713f, -0.04920706f, 0.00550645f, -0.08576901f, -0.04407461f, -0.01809994f, 0.04499958f, 
    -0.03273934f, 0.01449873f, 0.00872115f, 0.01225964f, -0.09558459f, 0.36071473f, 0.10432426f, 0.10153364f, 
    -0.00589016f, -0.03158496f, -0.05224675f, 0.02385598f, 0.09901853f, -0.04521440f, -0.06684820f, 0.02761891f, 
    0.10365844f, 0.10811841f, 0.12890206f, 0.05050779f, -0.00202273f, 0.08550442f, -0.08159901f, 0.03111386f, 
    -0.10721328f, -0.01658614f, 0.11870289f, -0.09143490f, 0.08362801f, -0.03019495f, 0.00279404f, 0.05549254f, 
    0.04217073f, 0.00557594f, -0.00175334f, 0.05137006f, 0.00221715f, 0.03443177f, 0.03514737f, 0.00877036f, 
    0.03922919f, 0.03474756f, -0.02097451f, 0.08094452f, 0.06844280f, 0.02420540f, -0.06360021f, -0.31066155f, 
    -0.18850324f, 0.03155279f, 0.01978603f, -0.01671449f, -0.00454857f, -0.02995771f, -0.13345377f, 0.04995153f, 
    -0.00422101f, 0.09598340f, 0.08041693f, -0.08842500f, 0.11270027f, 0.00393484f, 0.17516766f, -0.02029433f, 
    0.09733506f, -0.20507129f, -0.10604474f, 0.09200512f, -0.21663864f, 0.07294536f, 0.02842651f, -0.07697067f, 
    -0.03738293f, -0.01718191f, -0.10448210f, 0.03164842f, -0.05337781f, 0.14348355f, -0.00556150f, -0.02451407f, 
    0.01141185f, -0.02971008f, 0.01537204f, 0.08963457f, 0.01057608f, -0.12825510f, 0.00590059f, -0.02858994f, 
    -0.09240783f, 0.04041421f, 0.04219546f, 0.04374466f, -0.05118658f, -0.16314521f, 0.03852665f, 0.02460839f, 
    -0.07948975f, -0.02277263f, -0.08316180f, 0.02753638f, -0.00961001f, -0.11013515f, -0.10982399f, -0.02779021f, 
    -0.21267574f, -0.16936821f, 0.10119765f, 0.02019695f, 0.06299520f, 0.02751598f, 0.05366136f, 0.07625473f, 
    0.01589704f, -0.03449583f, 0.08428358f, 0.01039061f, -0.03946353f, -0.05423435f, -0.07832974f, 0.00264776f, 
    -0.10426172f, -0.19469127f, -0.02200575f, 0.02924107f, -0.26175320f, -0.06968848f, -0.07618891f, -0.18546265f, 
    -0.08082234f, 0.02676411f, 0.08114570f, -0.08543765f, -0.00547271f, 0.02525618f, 0.00669542f, 0.01663230f, 
    -0.04681567f, -0.02958046f, 0.04989196f, -0.07555675f, 0.05716885f, 0.11115848f, 0.05567750f, 0.04981797f, 
    -0.20124772f, -0.08462459f, 0.02665547f, 0.01531366f, 0.14861611f, 0.05845305f, 0.06588221f, 0.04846935f, 
    -0.02041205f, -0.07041875f, -0.01092703f, -0.04120796f, -0.02910304f, 0.09253050f, 0.01844555f, 0.09029125f, 
    0.02016540f, 0.02985306f, 0.00149410f, 0.05506041f, -0.25227895f, -0.09816387f, 0.15796924f, -0.12762176f, 
    -0.27756754f, 0.07529345f, 0.00135637f, -0.00292056f, 0.00262908f, 0.06078565f, 0.04449907f, 0.06545203f, 
    0.03820767f, 0.04575329f, 0.06035766f, -0.00859131f, 0.02890477f, -0.06450233f, -0.06782789f, -0.05763728f, 
    -0.26051980f, -0.18267760f, -0.04025252f, -0.01981154f, 0.08671761f, 0.06603070f, 0.05998344f, -0.00829456f, 
    -0.00934662f, -0.09694399f, 0.00565104f, -0.00121408f, 0.00022019f, -0.01696245f, 0.00659851f, 0.02526522f, 
    -0.00892391f, 0.03234080f, 0.06477797f, -0.00115127f, -0.11136823f, -0.14689723f, -0.07854497f, 0.01389460f, 
    0.02247282f, 0.05487680f, 0.04145281f, 0.03688249f, 0.04311310f, 0.05967356f, 0.10898513f, -0.00691332f, 
    0.01196687f, 0.01604852f, 0.06774266f, 0.07951715f, -0.00855689f, -0.00743327f, 0.12168301f, 0.06950813f, 
    0.23752204f, 0.18286043f, 0.04604794f, -0.05537547f, 0.05784554f, -0.00200519f, -0.03276818f, 0.02447263f, 
    0.09512436f, 0.06316034f, -0.05499594f, 0.01296678f, 0.03826082f, 0.04671296f, -0.04861416f, 0.02443628f, 
    0.06408884f, -0.03461008f, -0.09866032f, 0.02785003f, -0.44697315f, -0.21188812f, 0.07812802f, -0.10449762f, 
    -0.17408037f, 0.06390611f, -0.03906900f, 0.02232638f, -0.06287455f, 0.04662156f, -0.01994734f, 0.00875815f, 
    -0.02353141f, 0.11463939f, 0.00771096f, 0.07042749f, -0.06838445f, -0.02718520f, -0.03987240f, -0.04720800f, 
    -0.03931108f, -0.03823264f, -0.07616580f, -0.02973960f, 0.05367861f, 0.04210420f, 0.00911460f, 0.03586933f, 
    0.00879353f, -0.01617555f, 0.07929980f, 0.07242721f, -0.05283964f, -0.00433502f, 0.06844344f, 0.01391926f, 
    0.04237886f, 0.02167921f, 0.05413178f, 0.04618966f, -0.20662281f, -0.06851730f, -0.15304805f, -0.00639080f, 
    -0.06076350f, 0.00427979f, -0.01920346f, -0.06095641f, -0.01082128f, 0.00806463f, 0.09512064f, 0.03171746f, 
    0.01273675f, -0.01708444f, 0.07510286f, 0.02582344f, -0.00917214f, -0.02652795f, 0.03599736f, 0.00027121f, 
    0.20260575f, 0.18358314f, 0.10243788f, 0.02667413f, -0.05729363f, 0.01296326f, -0.06532501f, 0.03360202f, 
    0.03475384f, -0.01458881f, -0.08796159f, 0.03190773f, 0.04872144f, -0.02935885f, 0.02409432f, 0.02424601f, 
    0.03733521f, -0.14660420f, -0.13522272f, 0.00847913f, 0.16871034f, 0.08163544f, -0.00622566f, 0.01762703f, 
    -0.10660718f, -0.00615145f, -0.08693389f, 0.03874582f, -0.04357494f, 0.00138549f, 0.03870700f, -0.05879958f, 
    -0.00730171f, 0.06456002f, -0.05219460f, -0.06100601f, 0.06081572f, 0.00728379f, 0.05326306f, 0.06272133f, 
    -0.15023462f, 0.16908388f, -0.14502399f, 0.13760555f, -0.04006232f, -0.05256882f, 0.02269683f, -0.06105106f, 
    0.00053682f, 0.06635881f, 0.01363900f, -0.04104167f, 0.05277605f, -0.06292890f, 0.00103828f, -0.05956367f, 
    -0.02200799f, -0.00132754f, 0.07298280f, 0.09072969f, -0.14062837f, 0.10354365f, -0.06049160f, -0.00752093f, 
    -0.01020484f, 0.03777573f, -0.03632944f, -0.02317901f, -0.04351476f, 0.03719698f, 0.00454507f, 0.02654595f, 
    0.00522436f, -0.05043004f, -0.00017116f, 0.04630714f, -0.03723903f, -0.06891585f, -0.04318184f, 0.03486125f, 
    -0.05082167f, -0.06019003f, 0.08071481f, 0.05006054f, 0.02851127f, -0.01197620f, -0.03005084f, -0.01403924f, 
    0.00586547f, -0.01546212f, 0.01731302f, 0.00213488f, 0.05369991f, -0.04426942f, 0.01224314f, -0.06498572f, 
    -0.00584420f, 0.05794984f, 0.05844630f, 0.07394436f, 0.11454885f, 0.13001622f, -0.03760381f, -0.00696826f, 
    -0.00832521f, -0.07304832f, -0.08387160f, 0.02136450f, 0.04641860f, 0.02043692f, 0.00987790f, -0.00175367f, 
    -0.04082626f, -0.05213970f, -0.09612563f, -0.04924526f, 0.02087944f, 0.11679804f, -0.05921124f, -0.02508400f, 
    -0.08862801f, -0.05035310f, -0.05896074f, 0.13730651f, 0.06218257f, -0.01402084f, -0.01223347f, -0.05884942f, 
    0.00293637f, 0.03552571f, -0.00865594f, 0.05047092f, 0.00716983f, -0.01956267f, 0.12096812f, 0.01465803f, 
    0.00706415f, -0.02607184f, -0.06377351f, -0.05187352f, 0.12588122f, -0.18320712f, -0.00064999f, 0.03672034f, 
    0.07518883f, -0.07250431f, -0.00691122f, -0.03674676f, 0.02051385f, -0.04777214f, 0.00552559f, 0.09302000f, 
    -0.04801489f, -0.01307411f, -0.02124968f, -0.13874124f, -0.04207992f, -0.12296254f, -0.13653757f, -0.03823192f, 
    -0.23172647f, -0.15866576f, 0.01274027f, 0.07134654f, 0.19036694f, 0.02918226f, 0.04260084f, 0.03256102f, 
    0.00149240f, -0.01740035f, -0.02743194f, 0.00149671f, 0.00199616f, -0.01450976f, 0.01261029f, -0.02699863f, 
    0.02528799f, 0.07386103f, 0.05747364f, -0.02083400f, -0.47022244f, 0.03603917f, -0.26719245f, -0.01496741f, 
    0.16239096f, 0.10367259f, -0.10750770f, -0.15927590f, -0.05051012f, 0.03833629f, 0.01960744f, -0.04769605f, 
    0.04916644f, -0.10439380f, 0.03645473f, -0.07610141f, -0.10461366f, -0.01658938f, -0.03253124f, -0.07032061f, 
    0.11497717f, -0.04136452f, 0.01711574f, -0.03636619f, 0.03103349f, -0.01850404f, -0.02338696f, -0.05810047f, 
    0.05189928f, -0.01183045f, -0.03853077f, 0.03359319f, -0.19164485f, 0.01657967f, 0.03886558f, -0.04933791f, 
    0.05623447f, 0.09837859f, 0.00199651f, 0.01783248f, 0.01334583f, -0.09048876f, 0.11923888f, -0.02206684f, 
    -0.00800473f, 0.09726823f, 0.00417588f, 0.07938781f, 0.03386532f, 0.05064113f, -0.03073641f, 0.01138535f, 
    0.02848350f, -0.01540687f, -0.05477276f, -0.05273566f, 0.04195460f, -0.25575760f, -0.06530677f, -0.02668947f, 
    -0.05509932f, -0.06608643f, -0.07404859f, -0.00480408f, 0.10762715f, 0.04831912f, 0.02216658f, -0.00762677f, 
    0.01677744f, -0.04078487f, 0.02313400f, 0.01002549f, 0.00600650f, 0.00541013f, 0.03733400f, 0.09098904f, 
    0.14408873f, 0.05418081f, 0.05968177f, 0.03262321f, 0.16517365f, 0.09345734f, -0.07474395f, -0.01536679f, 
    -0.03490769f, -0.09361221f, -0.05035244f, -0.00839866f, 0.04993384f, -0.03929479f, -0.00160856f, 0.02434525f, 
    -0.00621821f, -0.05625233f, -0.02377255f, -0.04542681f, -0.00930799f, -0.00221932f, -0.04227940f, 0.00040703f, 
    -0.46135259f, -0.21901785f, 0.13027489f, -0.07161265f, -0.09917119f, 0.04252864f, 0.03536283f, -0.02521263f, 
    -0.03339032f, -0.00437067f, 0.05538338f, 0.04118446f, 0.02132537f, 0.15040426f, 0.02505378f, 0.10649925f, 
    0.03659369f, 0.00969198f, -0.05447074f, -0.02559348f, -0.26241523f, -0.21382199f, -0.06302088f, -0.09293805f, 
    -0.08746999f, 0.04518029f, 0.00653704f, -0.06812724f, -0.06958460f, 0.05884494f, 0.02479340f, -0.01686568f, 
    0.04123871f, 0.08735001f, 0.00352199f, 0.01751945f, 0.02856717f, -0.00324785f, 0.02142552f, 0.00301719f, 
    -0.28546107f, -0.02875016f, -0.11460483f, -0.11101615f, -0.14010257f, 0.05207224f, 0.04508615f, -0.08566850f, 
    -0.02331514f, -0.03346511f, -0.01754133f, -0.00917215f, -0.06581935f, -0.02935039f, -0.01560713f, -0.06971773f, 
    -0.01832131f, 0.07558162f, 0.01100628f, 0.04730932f, -0.33661422f, -0.15255916f, 0.00306697f, -0.11995530f, 
    -0.16597210f, 0.06608430f, 0.02224115f, 0.00137389f, -0.10162371f, 0.05498719f, -0.01775684f, -0.03098119f, 
    0.02548818f, 0.06934818f, 0.00047513f, -0.07096082f, -0.04124595f, -0.03618908f, 0.05328640f, -0.01081023f, 
    -0.02389795f, 0.09494378f, -0.04392556f, -0.02203166f, -0.00615732f, 0.00279555f, 0.05735177f, 0.05217275f, 
    0.07780521f, 0.05583990f, -0.00616898f, 0.08351158f, -0.02471417f, 0.00947872f, -0.00428445f, 0.10045444f, 
    -0.00694664f, -0.04640734f, -0.10987887f, 0.06482321f, -0.28842092f, -0.14866579f, -0.05142419f, -0.10166733f, 
    -0.14377531f, -0.00047874f, 0.01673138f, -0.04828634f, -0.01966551f, 0.03811884f, 0.01446784f, -0.01631296f, 
    -0.04179269f, 0.05039565f, -0.00820763f, -0.00940016f, 0.00651710f, 0.01110299f, -0.05067174f, 0.01955783f, 
    -0.37129784f, -0.22987434f, 0.19887605f, -0.08380109f, -0.25818142f, 0.10522898f, -0.00948141f, 0.03068947f, 
    -0.00096904f, 0.00837231f, 0.02545541f, 0.06014852f, -0.04482175f, 0.03989537f, 0.02606546f, 0.02602724f, 
    -0.07818519f, -0.13050216f, -0.11006633f, -0.16932862f, 0.25160295f, 0.11277808f, -0.04125903f, -0.00496015f, 
    -0.06933312f, 0.01603400f, 0.02809757f, 0.08567683f, 0.02253694f, 0.04765958f, -0.10234214f, -0.03231769f, 
    0.01957659f, -0.03995894f, -0.03942474f, 0.00942742f, 0.00863407f, -0.21944341f, -0.11695808f, -0.00790315f, 
    -0.16507816f, -0.17197050f, -0.09722062f, -0.10094220f, -0.06693868f, 0.00863800f, 0.00854019f, -0.05397140f, 
    -0.04136921f, -0.05952428f, 0.04064647f, -0.07368970f, -0.01322200f, -0.05709077f, -0.01876839f, 0.01123304f, 
    -0.00135743f, 0.03637742f, 0.10597907f, -0.00574977f, 0.06505962f, 0.03202607f, -0.06983770f, -0.01103987f, 
    0.07528149f, 0.06391672f, 0.02802325f, -0.05346110f, -0.00899923f, -0.07842705f, -0.04034448f, 0.03004202f, 
    -0.14699286f, 0.02428127f, 0.03290843f, -0.04811485f, 0.10314621f, -0.08119337f, -0.04479475f, 0.07099859f, 
    -0.06220658f, -0.07318310f, -0.00845932f, 0.01537195f, -0.04472606f, 0.03531851f, 0.04563130f, -0.00170941f, 
    0.03103093f, 0.02525723f, 0.04354999f, -0.01746681f, 0.04743516f, -0.00694861f, 0.00398522f, 0.01986168f, 
    0.00715971f, -0.02311661f, 0.03184001f, 0.04673009f, 0.06608290f, 0.04533867f, -0.00078000f, -0.02852902f, 
    -0.00288131f, 0.01104549f, 0.04061976f, 0.05120905f, 0.04914384f, -0.00522912f, 0.00835187f, 0.05859304f, 
    0.00121219f, -0.01881078f, -0.01124967f, -0.00912462f, 0.04140583f, -0.02370291f, -0.09165457f, 0.06621397f, 
    0.09830928f, 0.08791725f, 0.01455657f, 0.07459903f, 0.07183230f, -0.00105389f, 0.01281557f, -0.02968314f, 
    0.03161533f, 0.02866656f, -0.01659537f, 0.02832977f, 0.03673613f, 0.00133832f, 0.05335940f, 0.04812653f, 
    0.01840284f, 0.03384190f, 0.00953868f, 0.01650202f, -0.05775635f, 0.01883434f, -0.17394805f, -0.11723145f, 
    -0.00902194f, -0.00071057f, 0.00634361f, -0.16342908f, 0.02164833f, -0.03386996f, -0.03937854f, 0.05149676f, 
    -0.12759340f, -0.08395178f, 0.06407481f, -0.05566476f, -0.03534198f, 0.10819869f, 0.00090875f, 0.03502976f, 
    -0.23789270f, 0.01259619f, -0.08402868f, -0.11487592f, -0.16972499f, 0.11686162f, -0.04516228f, -0.06190108f, 
    -0.00638498f, 0.00255812f, -0.09656779f, 0.05618983f, -0.02362787f, 0.06636890f, 0.00150832f, 0.04306519f, 
    0.06256139f, 0.10595643f, 0.00822232f, 0.08056111f, 0.25795555f, 0.03783017f, -0.03319162f, 0.05279607f, 
    -0.04755564f, -0.13043074f, -0.09534927f, -0.04832694f, 0.04519801f, -0.09509730f, -0.02209196f, 0.01902635f, 
    -0.09380199f, -0.08118764f, -0.09935220f, -0.12648575f, -0.01961947f, -0.06543631f, -0.14263389f, -0.10748890f, 
    0.19909053f, 0.14576320f, -0.12240981f, 0.15432747f, -0.08758226f, -0.02279256f, -0.10622565f, 0.06537215f, 
    0.00790026f, -0.04836702f, 0.02128269f, -0.03696536f, 0.03438462f, -0.09226609f, -0.00248427f, 0.04359090f, 
    -0.05092964f, 0.00529125f, 0.02932843f, -0.01866893f, 0.02056763f, -0.01997493f, 0.06309976f, -0.07613071f, 
    0.03164242f, 0.03743629f, -0.12984930f, 0.09517295f, 0.00124004f, 0.06598289f, -0.02608991f, 0.02381203f, 
    -0.01742051f, -0.02503101f, 0.03772179f, -0.03833454f, -0.03814855f, -0.09300081f, -0.01509137f, 0.01940672f, 
    0.23370191f, 0.19378714f, 0.10519651f, -0.09314738f, -0.05122415f, 0.08399554f, -0.02669992f, 0.07219557f, 
    0.05449095f, -0.02479521f, 0.00140440f, -0.04783032f, -0.01390610f, 0.04284848f, -0.04227972f, 0.10039661f, 
    0.06641363f, -0.06093244f, -0.10757458f, 0.08288270f, 0.22910932f, 0.12378492f, -0.13542826f, 0.14095511f, 
    -0.15269448f, -0.07794801f, -0.06308050f, 0.07596354f, 0.04570469f, -0.08910158f, -0.01561803f, -0.03562113f, 
    0.05740501f, -0.10728103f, -0.06306645f, -0.01935142f, 0.02285702f, -0.04779746f, 0.00609391f, -0.04934584f, 
    0.05383397f, -0.02147117f, -0.01930322f, 0.05731531f, 0.01823892f, -0.05961950f, 0.02144513f, -0.04481820f, 
    0.00892481f, 0.04155059f, 0.03808490f, 0.02553978f, 0.02852135f, -0.02189219f, 0.12207979f, 0.01755281f, 
    0.00712917f, 0.10579380f, -0.02336626f, -0.01800045f, -0.18494771f, -0.02495376f, -0.09980941f, -0.07615943f, 
    -0.04775544f, 0.01684712f, 0.03503938f, -0.00678632f, -0.00848468f, 0.02989647f, 0.01305391f, -0.00602310f, 
    -0.06534415f, 0.05268356f, 0.05138639f, 0.07148690f, -0.03689712f, 0.05736841f, 0.00705972f, 0.02490964f, 
    -0.08701444f, 0.05424071f, -0.16095364f, -0.07381016f, -0.00880739f, -0.02833186f, -0.01391497f, 0.01592937f, 
    0.04235059f, 0.06142201f, -0.00521414f, 0.06476511f, -0.01167761f, -0.08727324f, -0.04721670f, 0.08680929f, 
    -0.04277005f, 0.07627646f, -0.04173430f, 0.14631113f, 0.21306621f, 0.12247648f, 0.03852507f, 0.00970261f, 
    -0.04921000f, -0.05351461f, -0.03172425f, 0.01209907f, 0.06076087f, 0.06470747f, -0.01745842f, -0.04731243f, 
    -0.00590482f, -0.09207061f, -0.09507702f, -0.03991830f, -0.00886834f, -0.00704770f, -0.02174690f, -0.00559007f, 
    0.09451373f, -0.02311368f, 0.00451187f, -0.01741102f, 0.04019330f, -0.05083222f, -0.00803529f, -0.04733057f, 
    0.02109302f, -0.07180112f, 0.03246230f, 0.03669577f, 0.01441672f, -0.02680318f, -0.00099755f, -0.00257693f, 
    0.02043862f, 0.05188636f, -0.10111990f, 0.02295212f, -0.02911807f, 0.07528906f, -0.01655597f, 0.01662627f, 
    0.06221216f, 0.03372740f, 0.04257095f, 0.00033597f, 0.05846504f, 0.04499761f, -0.00132284f, -0.01265677f, 
    0.04308031f, 0.06436046f, 0.07156827f, 0.01693225f, 0.05879391f, 0.10745421f, 0.04142003f, 0.06122587f, 
    -0.10703777f, -0.13318719f, -0.11964517f, -0.02523318f, -0.02676499f, 0.01907109f, -0.01027285f, -0.05979646f, 
    -0.00270269f, -0.03631239f, 0.05273263f, -0.05335703f, -0.09109107f, -0.02861051f, -0.02645876f, 0.03154740f, 
    0.11229990f, 0.06710051f, 0.16338849f, 0.08175810f, 0.05043194f, 0.15260269f, 0.09847644f, -0.09583879f, 
    0.02381772f, 0.03744162f, 0.02170525f, 0.01903393f, -0.02318895f, -0.00460239f, -0.04614584f, 0.04963452f, 
    0.00117535f, 0.03438121f, 0.00336370f, 0.03641566f, 0.04308711f, -0.04830333f, -0.10452328f, 0.03158331f, 
    -0.11907830f, 0.14477783f, 0.00708965f, 0.00742792f, 0.11219371f, 0.00668234f, 0.06684050f, -0.01233592f, 
    0.01767556f, 0.02748215f, 0.03617622f, 0.00555177f, 0.01608855f, 0.04359724f, 0.08566334f, 0.02157357f, 
    0.02827305f, 0.05917804f, -0.06023752f, 0.05772049f, -0.31996098f, -0.05862029f, -0.06002618f, -0.08645909f, 
    0.02218105f, 0.08569761f, -0.00673664f, -0.02672920f, -0.00372136f, 0.02740922f, 0.04364941f, -0.00824935f, 
    0.00760614f, -0.01581125f, 0.03762936f, -0.02686987f, 0.00672700f, 0.12871028f, -0.00226205f, 0.05927339f, 
    0.02825297f, 0.03276484f, 0.04948537f, -0.05709901f, 0.07709721f, -0.01105009f, 0.11849259f, 0.05765791f, 
    0.03409896f, 0.00671180f, -0.00870362f, 0.01332067f, 0.01414436f, -0.02362927f, -0.00770550f, -0.03897747f, 
    0.10936133f, 0.07367393f, -0.04310094f, 0.08013310f, -0.04637762f, -0.14423008f, -0.07079857f, 0.05766673f, 
    0.08463062f, 0.02278516f, 0.09986585f, -0.03814122f, -0.01907580f, -0.14203016f, -0.01497178f, 0.03207234f, 
    0.06535868f, 0.03111746f, 0.12419570f, -0.00316303f, 0.02329186f, 0.01445313f, 0.01153154f, -0.04136739f, 
    -0.11860736f, -0.13056804f, -0.12339058f, -0.04329176f, 0.04051975f, 0.04348070f, -0.02547287f, 0.00682888f, 
    -0.03541090f, -0.00109386f, 0.00475213f, 0.00623667f, -0.08979397f, 0.03244413f, 0.02971947f, -0.01620477f, 
    0.05790453f, 0.08005340f, 0.04056781f, 0.07105348f, -0.02380935f, -0.16715261f, -0.03531243f, -0.00150722f, 
    0.15496400f, -0.04849394f, 0.06371846f, 0.05232770f, -0.02047895f, -0.09481830f, 0.02740784f, 0.00545909f, 
    0.02453420f, -0.04699700f, 0.03479145f, -0.06418756f, 0.00572448f, 0.02147729f, 0.00311834f, 0.04895889f, 
    -0.29451814f, -0.24932779f, -0.17801170f, -0.06896884f, -0.18113889f, 0.03301462f, 0.07245969f, -0.06006780f, 
    -0.09780312f, -0.03259673f, 0.01650134f, -0.06963623f, -0.04490887f, -0.03038516f, -0.02284691f, -0.00552130f, 
    -0.00856876f, 0.06372823f, -0.00977068f, -0.00273562f, -0.24396989f, -0.16850230f, -0.04568694f, 0.00354256f, 
    0.09398083f, -0.00127843f, 0.04441914f, -0.02238886f, -0.00889737f, 0.00467265f, 0.06926272f, -0.07758661f, 
    -0.10034976f, -0.09162451f, -0.01020210f, -0.02901943f, -0.03824716f, -0.08352241f, 0.06375227f, 0.06717172f, 
    -0.15343551f, -0.09281261f, 0.03916332f, -0.01476263f, 0.00382003f, 0.01378893f, -0.01314561f, -0.00747164f, 
    -0.02862993f, -0.02200433f, 0.07500679f, -0.00610535f, -0.02160871f, -0.05719969f, 0.03483124f, 0.05716498f, 
    -0.06352502f, -0.02637413f, 0.05100019f, -0.01929707f, -0.08442077f, -0.01538538f, -0.01047725f, -0.01776956f, 
    -0.11518675f, 0.03426475f, 0.04276568f, -0.03257608f, 0.02239155f, 0.03068977f, 0.02945819f, 0.04618877f, 
    0.05675496f, 0.00671867f, 0.00766415f, 0.07025095f, 0.11796898f, 0.01579370f, -0.03330810f, 0.05992696f, 
    -0.07143530f, -0.13889985f, 0.01859467f, -0.04736089f, 0.02673356f, -0.05240604f, 0.03252076f, 0.00865688f, 
    -0.02296657f, -0.03515001f, -0.02653031f, 0.02551207f, 0.04827841f, -0.04664028f, 0.00432007f, -0.01788121f, 
    -0.00764083f, 0.09527811f, -0.01240733f, 0.07952858f, -0.23052646f, -0.14323823f, -0.13386974f, -0.12135902f, 
    -0.04323218f, 0.03740579f, 0.01349472f, -0.07591944f, -0.00772838f, -0.01726190f, 0.03008644f, -0.08086306f, 
    -0.04196142f, -0.03116317f, 0.04136830f, 0.01457134f, 0.00202312f, 0.07081038f, 0.06326057f, 0.00430906f, 
    0.08002999f, 0.16186342f, -0.18413661f, 0.05435072f, 0.09873914f, 0.05155364f, -0.04774452f, 0.00872210f, 
    -0.05722543f, -0.08488171f, 0.01221976f, -0.01457276f, 0.07498808f, 0.01558202f, -0.02823192f, 0.07720561f, 
    0.05223798f, -0.03042916f, -0.00689339f, 0.08569755f, -0.09645390f, -0.23448749f, -0.08015389f, -0.14126101f, 
    -0.07437570f, 0.01492088f, 0.03834721f, -0.02163159f, 0.01727093f, 0.04096303f, -0.01234736f, -0.03031232f, 
    -0.01268114f, -0.00923618f, -0.05633902f, 0.05203414f, -0.03884984f, -0.02748915f, -0.05681216f, -0.01553837f, 
    0.02544811f, 0.24481843f, -0.04234652f, 0.01124315f, 0.08800851f, 0.09921876f, -0.03900132f, 0.04957765f, 
    0.05828556f, -0.02371778f, 0.05453919f, 0.09387450f, 0.00276512f, -0.04495328f, 0.00986625f, -0.03888032f, 
    -0.00046588f, -0.01644468f, -0.04694927f, 0.00396733f, 0.28207472f, 0.20460145f, -0.13960569f, -0.08939784f, 
    0.31003341f, 0.05581310f, -0.11534812f, -0.03623709f, 0.03827806f, -0.03390441f, 0.07303101f, -0.00565414f, 
    0.01817571f, 0.01314463f, -0.03265078f, 0.05477586f, -0.00843612f, 0.09195191f, -0.04488109f, -0.01502298f, 
    -0.04981685f, 0.18508805f, -0.04478506f, 0.07818731f, -0.07026007f, 0.12036855f, 0.00860395f, 0.01921922f, 
    -0.00417125f, -0.00428935f, 0.03764999f, -0.00365975f, 0.02153597f, 0.01745980f, 0.03151460f, -0.02289403f, 
    -0.01165424f, -0.02843349f, -0.07586946f, 0.04178530f, 0.12378339f, -0.10372981f, -0.00874654f, 0.03641200f, 
    0.01161966f, 0.11270015f, -0.07315536f, -0.04316800f, 0.03133771f, 0.03759181f, 0.00482561f, 0.00235971f, 
    -0.01712046f, 0.04923984f, 0.01618221f, -0.00331484f, -0.03498301f, -0.01646939f, -0.08697379f, -0.02590482f, 
    0.00856132f, -0.05281677f, -0.01011134f, 0.02837864f, 0.15459692f, -0.03085834f, -0.01487840f, 0.04986784f, 
    0.06830309f, 0.03143751f, 0.05022962f, 0.02041889f, -0.06897374f, 0.05985450f, 0.03533614f, 0.03822616f, 
    -0.01602461f, -0.08388600f, 0.08216346f, 0.08663333f, 0.33257088f, -0.13340028f, -0.14088196f, -0.23219389f, 
    -0.04915873f, 0.01280015f, -0.04179884f, -0.06964760f, 0.05630745f, 0.05389845f, 0.01849021f, 0.01930032f, 
    0.02638982f, -0.00231729f, 0.02516917f, -0.01908484f, -0.00907138f, -0.03929780f, 0.02383801f, -0.00096172f, 
    -0.02571311f, -0.30700541f, 0.01186530f, 0.06555764f, 0.02979264f, -0.00603776f, 0.04377190f, -0.01959127f, 
    0.08608468f, 0.02287540f, -0.02771038f, 0.04503307f, -0.01502956f, 0.00585945f, -0.00605528f, 0.03708024f, 
    -0.04768754f, 0.00404399f, -0.01084291f, -0.03944218f, -0.04609540f, -0.11166340f, -0.13878195f, 0.08592505f, 
    -0.12244137f, -0.00538955f, 0.01608881f, -0.02152273f, -0.02455146f, -0.06753867f, 0.00767727f, 0.01552184f, 
    0.00627330f, 0.02794068f, -0.11449790f, -0.01793814f, 0.00209588f, -0.04803026f, -0.12499893f, -0.12456788f, 
    -0.18107271f, -0.07804879f, -0.00747965f, -0.12918998f, 0.29558074f, -0.02417113f, -0.04175721f, 0.01217169f, 
    0.04287490f, -0.00125215f, -0.01497749f, -0.01392518f, -0.04876552f, 0.04285256f, 0.08984735f, 0.11085341f, 
    -0.02989480f, -0.00036900f, 0.07394505f, 0.06936533f, 0.18581188f, -0.02948738f, -0.02511306f, -0.03423997f, 
    -0.01104017f, -0.08280014f, 0.00130758f, 0.01359717f, -0.00957783f, -0.14830124f, -0.01028225f, -0.09746475f, 
    -0.06072063f, -0.01779961f, -0.08208316f, -0.00907551f, 0.01839490f, -0.00279281f, 0.00409328f, -0.05732242f, 
    -0.10956808f, -0.03858772f, 0.10905968f, 0.16311796f, 0.18356699f, -0.07329299f, 0.04067196f, 0.11078399f, 
    0.04673389f, -0.09173232f, 0.00918493f, -0.03159450f, 0.02663345f, 0.14627726f, -0.01427736f, 0.05289350f, 
    0.00776645f, -0.08270800f, -0.06529875f, -0.01377624f, 0.04575875f, -0.00035072f, 0.10633406f, 0.05567456f, 
    -0.13421407f, -0.05004321f, 0.02194949f, 0.03356937f, 0.06258274f, -0.14603567f, 0.06272943f, -0.03639808f, 
    0.01172720f, 0.02177449f, -0.01683475f, 0.06463333f, -0.01829825f, -0.02244064f, 0.05875488f, 0.07491997f, 
    -0.34950611f, -0.18613638f, -0.01530911f, -0.00619342f, -0.01947731f, 0.06215983f, -0.04534484f, 0.01330267f, 
    0.04215661f, 0.13687938f, -0.00652553f, -0.00846295f, -0.01357764f, 0.05154241f, 0.00525759f, 0.00574432f, 
    -0.01737852f, 0.00835293f, -0.08211274f, -0.05024496f, -0.29402876f, 0.03984013f, 0.01394988f, -0.11109750f, 
    -0.00204668f, -0.06358509f, 0.04144362f, 0.01787326f, 0.00536591f, -0.06576519f, -0.08768778f, -0.01864754f, 
    0.06263204f, -0.00929034f, -0.09248561f, -0.06129460f, -0.17783172f, -0.02174078f, -0.10882081f, -0.01540025f, 
    -0.20729247f, 0.08352571f, -0.11337224f, 0.04226483f, -0.12706679f, -0.01976960f, -0.05928908f, -0.03939734f, 
    0.04968619f, -0.08254804f, -0.08444917f, -0.08622663f, 0.01021317f, -0.01141486f, 0.01472398f, 0.00382916f, 
    0.03611625f, 0.00264772f, -0.02295978f, -0.04254093f, -0.02564911f, 0.14564593f, -0.03706391f, 0.04614174f, 
    -0.14359190f, 0.03819460f, -0.11978497f, -0.05668157f, -0.07454667f, -0.12848037f, 0.07184522f, 0.04132704f, 
    0.05970291f, 0.00760060f, -0.00358458f, 0.03845453f, 0.05687945f, -0.09091241f, 0.05716688f, -0.00354093f, 
    -0.19343837f, 0.25665459f, -0.02097543f, 0.11206763f, -0.18410166f, 0.07690717f, 0.07736330f, -0.02565182f, 
    0.03403648f, 0.01442573f, -0.03353155f, 0.03745460f, 0.01653241f, 0.01288031f, 0.05140319f, -0.07373075f, 
    0.05414401f, -0.03714462f, 0.01370203f, 0.02293198f, -0.08709818f, -0.19872876f, -0.12754677f, 0.14890324f, 
    -0.11164094f, -0.16961828f, 0.06671273f, 0.03347552f, -0.03633267f, -0.10988875f, 0.06688707f, -0.10993326f, 
    -0.02711523f, 0.12508097f, 0.02335841f, 0.11904839f, -0.01094551f, -0.10942462f, 0.01127508f, 0.09130791f, 
    -0.19332340f, -0.13057755f, -0.06428679f, -0.02616685f, -0.04724813f, 0.04876442f, 0.02918983f, 0.07628347f, 
    0.00062753f, -0.01037276f, -0.13185491f, 0.10724024f, 0.02877754f, -0.06516259f, -0.04291647f, -0.08411140f, 
    -0.08896463f, -0.03611499f, -0.06684547f, -0.04127545f, 0.03760650f, 0.07034058f, -0.14477324f, 0.00614058f, 
    0.18731117f, 0.08666620f, -0.13487324f, -0.01239062f, 0.04641480f, 0.01212569f, 0.02861687f, 0.03696032f, 
    -0.00894896f, -0.02082919f, -0.04455373f, 0.07963786f, -0.00652705f, 0.06344745f, -0.00552827f, 0.02304393f, 
    -0.18693237f, 0.17022356f, -0.00542427f, 0.00559933f, 0.05004124f, 0.05768388f, 0.01092539f, -0.00433672f, 
    -0.00458700f, -0.03267113f, -0.00525010f, 0.03295679f, -0.01860468f, -0.01656883f, 0.06834566f, -0.03554059f, 
    0.04098516f, 0.01349588f, -0.06452975f, -0.04257302f, -0.19423182f, 0.00054906f, -0.00505618f, -0.02244204f, 
    -0.03767816f, 0.02780625f, 0.05953639f, 0.03473504f, 0.05289826f, 0.01611980f, -0.06447879f, -0.04552360f, 
    0.06525902f, -0.06150799f, 0.00264216f, -0.03487558f, 0.01198469f, -0.00715341f, -0.10424688f, -0.00267995f, 
    0.26940772f, 0.28519201f, -0.21480519f, -0.10132823f, -0.01703748f, 0.01031511f, -0.00316735f, -0.02256985f, 
    0.07225069f, -0.00702890f, 0.08669549f, 0.06941459f, -0.03271627f, -0.05546254f, 0.09110313f, -0.00408708f, 
    -0.05556767f, 0.04431402f, -0.05004686f, 0.07071870f, 0.32166159f, 0.01092757f, -0.19255444f, -0.01664784f, 
    -0.04960086f, 0.08531647f, -0.01295892f, -0.02142338f, -0.00513148f, -0.00275001f, 0.10818652f, 0.06696800f, 
    0.01281912f, 0.00853719f, 0.02604110f, 0.04234278f, -0.02717540f, -0.00425115f, 0.02969945f, 0.03223600f, 
    -0.11949110f, -0.04303074f, 0.10651251f, -0.18360977f, -0.12069526f, 0.02810546f, 0.00186759f, -0.06345665f, 
    0.04293425f, 0.00867752f, 0.03230426f, -0.05640879f, 0.04361895f, -0.03356125f, 0.02960392f, -0.03342294f, 
    -0.04929407f, -0.05762712f, -0.04896442f, 0.04086222f, 0.25997680f, -0.23163275f, -0.09895783f, -0.03727748f, 
    -0.04558186f, -0.01842354f, -0.00728061f, 0.02541219f, -0.00120954f, -0.00900673f, 0.04872356f, -0.00842111f, 
    0.01166708f, -0.04088380f, -0.01113179f, 0.07322308f, 0.01258870f, -0.04454451f, 0.09081408f, 0.02056826f, 
    -0.35649166f, 0.30414206f, -0.02532946f, -0.00719313f, 0.21487014f, -0.02759248f, -0.01025950f, -0.01466248f, 
    -0.02259575f, 0.00877859f, -0.00158242f, 0.00475385f, 0.05346631f, 0.02963776f, 0.02604529f, -0.03088686f, 
    0.00058589f, 0.03022469f, -0.00643515f, -0.04040413f, 0.17593619f, -0.02475806f, -0.11628179f, -0.19750816f, 
    0.04276471f, -0.02887341f, -0.02558639f, 0.01853833f, 0.02414388f, 0.00110063f, 0.10099107f, -0.06967993f, 
    -0.02669156f, -0.01754608f, -0.01392019f, 0.02236946f, -0.03350044f, -0.02440521f, 0.03367557f, 0.06568471f, 
    0.33339310f, 0.25941166f, -0.22349527f, -0.07921230f, 0.03665554f, 0.00856784f, -0.00084121f, -0.07189143f, 
    0.01306182f, -0.01501194f, 0.01810117f, 0.02897296f, -0.08141562f, -0.00686159f, 0.00062051f, -0.01838703f, 
    0.00838942f, 0.07959863f, 0.00433348f, 0.02177862f, 0.02527455f, 0.10103001f, -0.13478437f, -0.15668847f, 
    -0.01807855f, -0.15397261f, -0.10671715f, -0.01469262f, -0.01957403f, -0.06603200f, 0.11035050f, 0.00068796f, 
    -0.07251579f, 0.03041243f, -0.03376501f, 0.07416492f, 0.00030980f, 0.03499054f, 0.06945051f, -0.08130714f, 
    -0.10496267f, -0.13545738f, -0.08690990f, -0.00424899f, -0.24260302f, 0.11937547f, 0.05769698f, 0.04380872f, 
    -0.01063544f, 0.02069063f, 0.01050758f, -0.01904199f, -0.00831618f, -0.01544103f, -0.03814084f, -0.08349742f, 
    0.01873794f, -0.04957185f, -0.05028591f, -0.01774867f, -0.14454912f, 0.33602664f, -0.01239143f, 0.00670748f, 
    0.01362969f, 0.09579913f, 0.04632960f, -0.04122492f, -0.03375695f, 0.01001161f, 0.03102593f, 0.02069087f, 
    0.05658676f, -0.13125092f, -0.03787152f, 0.06833001f, -0.01185410f, 0.04389178f, 0.00788349f, 0.03878948f, 
    -0.16368800f, 0.10633498f, 0.00073823f, -0.07429235f, 0.18169095f, 0.16922429f, -0.06016504f, 0.02404439f, 
    0.01018889f, -0.01963961f, -0.00107824f, 0.04976071f, 0.02196334f, -0.01366796f, 0.01180172f, -0.01233357f, 
    0.04099025f, 0.00218473f, -0.02586041f, -0.01612288f, -0.13011792f, 0.20201924f, 0.02253124f, -0.07236598f, 
    -0.00877722f, -0.05785941f, -0.10568210f, 0.01257668f, -0.10535279f, -0.03945768f, 0.02091490f, -0.02607920f, 
    0.01469994f, -0.04943253f, -0.00860135f, 0.00432898f, 0.02431524f, -0.06534589f, -0.00552401f, -0.00956684f, 
    0.01306929f, -0.03983569f, -0.07399683f, 0.05755341f, -0.05562286f, -0.06241693f, -0.02109028f, -0.02243706f, 
    0.02360732f, -0.02545487f, -0.00392412f, 0.01439701f, 0.05391471f, 0.05574821f, -0.04525475f, 0.03543813f, 
    0.05260804f, 0.01574998f, 0.07020929f, -0.02517118f, -0.42026895f, -0.22570898f, -0.04393625f, -0.13289328f, 
    -0.13736150f, -0.01694798f, 0.06071127f, 0.07306337f, 0.05346576f, -0.03763585f, -0.13574027f, 0.07024053f, 
    0.02780874f, 0.02235693f, 0.01100930f, -0.07017744f, 0.01648350f, -0.07885630f, -0.17407201f, 0.00296764f, 
    0.39731112f, -0.10853660f, -0.11872862f, -0.07331145f, -0.01643143f, 0.02056300f, 0.09218803f, -0.00484962f, 
    0.09655197f, 0.05891526f, 0.06999111f, -0.08369397f, 0.00228123f, -0.05364667f, 0.08182582f, 0.05194769f, 
    -0.13454033f, 0.01390131f, -0.00385384f, 0.02235555f, 0.05526672f, -0.05209718f, 0.10186239f, -0.07759447f, 
    -0.04134259f, -0.04160792f, -0.02895072f, -0.00225265f, -0.08517331f, -0.09772906f, -0.09787288f, -0.03524167f, 
    0.09268463f, -0.02761531f, -0.08261630f, -0.05215736f, -0.01199335f, -0.06642950f, -0.00457653f, 0.03384619f, 
    0.23591204f, -0.20931318f, 0.08160041f, -0.00105027f, -0.03828190f, 0.00512259f, 0.07206105f, 0.02114606f, 
    -0.02041473f, 0.02327144f, -0.03826790f, -0.11044882f, 0.02612284f, 0.06449440f, -0.09526430f, -0.12989736f, 
    -0.06377463f, 0.00949024f, -0.10472589f, -0.08767326f, 0.18421653f, 0.00465384f, -0.03214009f, -0.04432546f, 
    0.01797907f, -0.08573610f, -0.11534334f, -0.08331855f, -0.06458850f, -0.14350194f, 0.00323701f, -0.00449555f, 
    0.07286503f, 0.04031911f, -0.02700761f, -0.00544702f, -0.01176335f, -0.05090049f, 0.00380243f, -0.00241147f, 
    -0.11767878f, 0.09900723f, -0.11736993f, -0.19298604f, 0.13382807f, 0.00093190f, -0.04178225f, 0.08043871f, 
    -0.01075470f, -0.04103622f, -0.07816346f, 0.01618208f, -0.03620835f, -0.01273463f, 0.13823070f, 0.03882194f, 
    -0.08465613f, 0.02503738f, 0.10811941f, -0.00891168f, 0.24366590f, -0.18721080f, 0.02082879f, 0.09860519f, 
    -0.04815026f, 0.05572942f, 0.03612216f, 0.07778630f, -0.06549290f, 0.06180679f, -0.04378377f, -0.04245625f, 
    -0.01021933f, 0.01687891f, -0.06171315f, -0.07877115f, 0.00347044f, 0.01633101f, -0.09965540f, -0.07209230f, 
    -0.15247470f, -0.01041907f, 0.07022092f, 0.00130901f, 0.00539339f, -0.01985038f, 0.03257064f, -0.06516241f, 
    0.06446311f, 0.02607491f, -0.15405345f, 0.02505016f, 0.01081060f, 0.01858439f, -0.04628209f, -0.03048602f, 
    0.04593864f, -0.01561934f, -0.09359952f, -0.09152205f, 0.30203420f, 0.01909822f, -0.13515961f, -0.02183418f, 
    -0.02759821f, -0.02111015f, 0.02909586f, 0.00469407f, 0.02678946f, 0.00382778f, 0.01180508f, 0.00978263f, 
    0.03680007f, 0.00510856f, -0.00938741f, 0.03406326f, -0.00062503f, 0.02219841f, 0.00369634f, -0.04951920f, 
    0.17995252f, 0.14732830f, -0.08105420f, 0.08877886f, 0.03252371f, -0.07367434f, -0.03454010f, 0.00557951f, 
    0.05176813f, 0.06962863f, 0.02236326f, 0.04328705f, 0.03080419f, 0.07949189f, 0.00417974f, 0.08639212f, 
    -0.02109774f, -0.03957668f, 0.02110128f, -0.05673182f, 0.03288008f, -0.03881595f, -0.02980809f, -0.02975708f, 
    0.02570003f, -0.03920554f, -0.08435021f, -0.03771796f, -0.02802578f, -0.13629210f, -0.05505914f, -0.01179467f, 
    0.05358659f, 0.00046188f, -0.05186940f, 0.00309206f, -0.07315142f, 0.02009781f, -0.00517503f, -0.04250159f, 
    -0.29942968f, 0.12508056f, 0.04759041f, 0.01675769f, 0.00878006f, -0.01785044f, -0.02740202f, -0.04801461f, 
    0.06604688f, 0.04531126f, 0.01635099f, -0.01563521f, 0.05358942f, -0.05697899f, 0.06618436f, -0.02603064f, 
    0.01288988f, -0.06031761f, -0.03013113f, -0.01635923f, 0.02209090f, -0.00286257f, 0.01461309f, 0.03467266f, 
    -0.01159584f, -0.00512521f, 0.13205129f, 0.02605326f, 0.00252080f, 0.02745857f, -0.06169688f, 0.04321015f, 
    -0.03228742f, -0.05306637f, 0.05163587f, 0.07537607f, -0.00131953f, -0.03188327f, 0.04896998f, 0.00125060f, 
    -0.16240056f, 0.15559280f, -0.06371555f, -0.02761794f, 0.00410551f, 0.07143252f, 0.03663435f, 0.07904820f, 
    0.00276818f, 0.00156970f, -0.02599333f, 0.01143897f, -0.00171743f, -0.08603773f, 0.05571609f, -0.02249432f, 
    -0.04960683f, -0.10505106f, 0.00867683f, -0.05021203f, -0.18979919f, 0.14411359f, -0.04286649f, -0.15199237f, 
    0.13780257f, -0.01392040f, -0.04289479f, 0.01432311f, 0.00443792f, 0.08369466f, 0.01817063f, 0.00776716f, 
    0.01764828f, 0.01826276f, 0.03842368f, -0.00996530f, -0.01130008f, -0.01996111f, 0.02196600f, 0.02269468f, 
    -0.30992773f, 0.11298511f, -0.04131897f, 0.00834472f, 0.01755911f, -0.11174003f, -0.01603704f, -0.03072826f, 
    0.01135533f, -0.01884476f, -0.00828369f, -0.01638724f, -0.05268786f, -0.01087995f, -0.01088344f, -0.05334067f, 
    0.04809836f, 0.02136803f, 0.03195286f, 0.04598748f, -0.23698983f, -0.01135266f, 0.10354964f, -0.01685471f, 
    0.04102100f, -0.07660677f, 0.05735000f, -0.03641757f, 0.02261258f, 0.02145343f, 0.01016336f, -0.05998125f, 
    -0.00500393f, 0.03324056f, -0.02445868f, -0.04399427f, -0.09898713f, -0.07837187f, 0.00112762f, 0.05228106f, 
    -0.19060746f, 0.11598237f, 0.00153495f, 0.02460419f, 0.04560184f, -0.10955618f, 0.02525883f, 0.01626891f, 
    -0.12546714f, 0.00370183f, -0.00981783f, 0.03969505f, 0.01035688f, -0.14981401f, -0.06635611f, 0.05717932f, 
    0.03801123f, -0.03436251f, 0.09317417f, 0.01718175f, 0.14729513f, 0.03914376f, -0.12752308f, 0.05508732f, 
    0.02888182f, -0.04177215f, 0.15600775f, -0.02881402f, -0.02628294f, -0.01170540f, -0.03246842f, 0.08949316f, 
    -0.01072684f, 0.02445804f, 0.03624020f, -0.02858733f, 0.05338560f, 0.08545335f, -0.03306181f, 0.04326624f, 
    0.05707017f, -0.06562391f, -0.04379721f, 0.04427630f, -0.11993427f, 0.09042927f, 0.05560538f, 0.03969924f, 
    0.00210096f, 0.04924623f, 0.01684035f, 0.05673784f, 0.02546822f, -0.03602650f, 0.01619387f, -0.04622253f, 
    -0.05201666f, -0.03855730f, 0.02579696f, 0.04173634f, -0.24938628f, 0.17138608f, 0.06293361f, 0.09988409f, 
    -0.08081273f, 0.12012837f, 0.06751813f, 0.02826042f, 0.03203909f, 0.04350670f, 0.00839968f, -0.02373294f, 
    -0.02557377f, 0.03195469f, 0.01951774f, -0.04945316f, 0.06243431f, -0.03714236f, 0.00779247f, 0.00257514f, 
    0.07605010f, -0.04170145f, -0.21898822f, -0.16382337f, -0.23079951f, 0.01973730f, -0.03459692f, 0.03556882f, 
    0.02662324f, 0.04634055f, 0.09621251f, -0.00134902f, -0.01490085f, -0.03669069f, 0.04731058f, -0.08265384f, 
    -0.02547490f, -0.05398734f, -0.05732523f, 0.02574507f, 0.03406177f, 0.08214365f, -0.10412462f, 0.08920438f, 
    -0.06197730f, 0.09351265f, -0.02807988f, 0.00537246f, -0.07298179f, 0.00993265f, -0.04608417f, -0.00012067f, 
    0.05744194f, 0.00465907f, -0.03358712f, -0.06474696f, 0.05306007f, 0.01933832f, 0.07146130f, -0.04139068f, 
    -0.05200574f, -0.09567876f, -0.07895046f, 0.05106674f, -0.15825553f, 0.01115601f, 0.06853601f, -0.02020039f, 
    0.04411336f, -0.03831139f, 0.01139789f, -0.02117180f, 0.07202125f, 0.05052411f, -0.00187485f, -0.02624545f, 
    0.02958938f, -0.01368695f, -0.06648596f, -0.04247468f, 0.18317096f, -0.00494956f, -0.12551963f, 0.06176155f, 
    0.18756476f, 0.06673151f, -0.06145919f, 0.00184897f, 0.04321811f, 0.06361936f, 0.05724330f, -0.00408821f, 
    -0.00985557f, 0.00211881f, 0.02026710f, 0.02407994f, -0.02223440f, 0.09499431f, 0.03305783f, -0.02381864f, 
    -0.35488153f, 0.20034708f, -0.02016207f, 0.02254676f, 0.17786795f, 0.05619379f, -0.06513298f, 0.03169150f, 
    -0.00345662f, 0.12614927f, -0.05899133f, -0.03112337f, 0.08426610f, 0.01081583f, -0.00225664f, 0.04490514f, 
    0.03511563f, -0.04734468f, -0.05812289f, -0.07314321f, -0.08133623f, -0.29727066f, -0.10239569f, -0.06133585f, 
    -0.22903578f, 0.06040392f, 0.03843551f, 0.00916702f, -0.00110365f, 0.08236905f, -0.03397861f, -0.00952459f, 
    -0.02587312f, -0.04219905f, 0.06427795f, -0.06977684f, -0.04833553f, -0.01494133f, -0.11066431f, -0.04035914f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05072717f, 0.00021452f, -0.00734869f, -0.00700998f, -0.00651881f, -0.00843781f, 0.00519757f, -0.03753800f, 
    -0.00939009f, 0.02860346f, 0.02679397f, 0.00905294f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
