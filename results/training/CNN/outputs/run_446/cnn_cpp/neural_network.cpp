#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.10164740f, 0.48786107f, 0.32520986f, 0.30937397f, 0.38658971f, 0.46476671f, -0.38262221f, -0.33855125f, 
    0.13293432f, 0.42386287f, 0.59643644f, 0.65312976f, -0.59975559f, 0.01652265f, -0.42426792f, -0.11662765f, 
    -0.26572639f, -0.15565799f, -0.09876349f, -0.54867256f, -0.43777061f, 0.16738740f, -0.27876624f, -0.37657845f, 
    -0.26945186f, -0.48769906f, 0.09538519f, -0.62400144f, -0.44489413f, -0.26921493f, 0.11234806f, 0.70730329f, 
    -0.16342844f, -0.13199450f, -0.06002970f, -0.43449590f, -0.58642149f, -0.55362850f, -0.44488320f, -0.56665015f, 
    0.13974147f, 0.55963916f, 0.29964009f, 0.03553149f, 0.34143516f, -0.11208037f, -0.12963246f, -0.19213487f, 
    0.17770955f, -0.54757023f, 0.62829185f, -0.14883913f, -0.02476456f, 0.01055867f, 0.57402319f, 0.25285524f, 
    0.69818795f, 0.41969264f, -0.42725474f, 0.15211153f, 0.07401576f, 0.08095884f, 0.04381601f, -0.51732212f, 
    0.07416127f, -0.39578426f, 0.40231442f, 0.53424573f, 0.50641453f, 0.04402465f, -0.18862760f, -0.21016200f, 
    0.54588032f, 0.33337495f, 0.44776750f, -0.13269795f, -0.16425227f, -0.47407553f, 0.22621083f, 0.47430891f, 
    0.22470745f, -0.37884641f, -0.30929631f, 0.66743803f, -0.36354360f, -0.34979662f, 0.02019246f, 0.23302910f, 
    0.16410838f, 0.36085755f, 0.33655891f, -0.43541032f, -0.42155123f, 0.02520131f, 0.41785547f, 0.46830446f, 
    -0.22251806f, -0.04760711f, 0.16525470f, -0.17128927f, 0.07745322f, 0.13465260f, -0.20378806f, -0.87694633f, 
    0.27121115f, -0.11747550f, 0.12138012f, -0.05422353f, -0.11795231f, 0.75365967f, -0.55067462f, -0.00369058f, 
    -0.24148659f, -0.59704936f, -0.02699022f, -0.05039931f, 0.04041917f, 0.07461338f, -0.88299114f, -0.41337886f, 
    -0.53770924f, -0.33935308f, -0.04819140f, -0.17935070f, 0.23990518f, 0.08014318f, -0.21601065f, 0.30083340f, 
    1.00179493f, 0.44128248f, 0.22120957f, 0.14689773f, 0.30398023f, 0.32837230f, -0.01616531f, 0.15873933f, 
    0.43047220f, 0.02193493f, 0.81556469f, 0.07534433f, -0.44661537f, -0.22767273f, -0.18610984f, -0.18159918f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.37000957f, 0.24851352f, -0.11450785f, 0.26627341f, -0.19682856f, -0.29758996f, -0.07045721f, -0.34391955f, 
    0.03323738f, 0.13149260f, 0.01802681f, 0.14465360f, 0.11102525f, 0.07250238f, 0.02130672f, -0.41980404f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.04620895f, -0.06886267f, -0.07910330f, -0.02842939f, -0.05111440f, -0.06643636f, -0.03851427f, -0.00536652f, 
    -0.04090073f, -0.05712014f, -0.05005693f, 0.00837575f, -0.08312328f, 0.00907920f, -0.05851127f, 0.03494072f, 
    0.04826135f, 0.04588359f, 0.02598298f, -0.03838523f, -0.02667602f, -0.06931433f, -0.06861947f, 0.03973147f, 
    0.02159859f, -0.00880213f, -0.00006955f, -0.04413598f, -0.02646421f, -0.07510650f, -0.02062201f, 0.03648520f, 
    -0.06052799f, 0.06003004f, -0.04220156f, 0.04072136f, -0.05371870f, -0.00522779f, -0.07517990f, 0.00067782f, 
    -0.07973932f, 0.01949210f, 0.02715084f, 0.05530665f, -0.02546877f, 0.02560697f, -0.04041917f, 0.03918716f, 
    -0.00801485f, -0.01846549f, -0.00314606f, -0.08326606f, -0.07622857f, -0.07431941f, 0.04988075f, -0.01552663f, 
    -0.06228811f, 0.01342927f, 0.02380171f, 0.03059098f, -0.01468154f, 0.06082144f, 0.05840049f, -0.07560440f, 
    0.04668297f, -0.07608220f, 0.03198969f, -0.04008933f, -0.03571142f, -0.03937567f, -0.03498554f, 0.03022547f, 
    -0.02048288f, 0.03008137f, 0.04103134f, 0.06227034f, 0.02277810f, 0.07790004f, -0.03517311f, 0.00366435f, 
    -0.04513196f, -0.03004709f, -0.03637245f, 0.00079504f, -0.08421919f, -0.02247083f, -0.05906188f, 0.04804055f, 
    -0.02376111f, -0.07402755f, 0.07024074f, 0.04878789f, -0.03269407f, -0.00871634f, 0.01628230f, -0.06778205f, 
    -0.06448447f, -0.07164535f, 0.03863176f, -0.07179815f, 0.05688417f, 0.06072738f, -0.05662696f, -0.08546528f, 
    -0.06159902f, 0.03450185f, 0.04524761f, -0.07409805f, 0.00543728f, 0.04265626f, 0.06856872f, 0.03360854f, 
    -0.04007109f, 0.03918974f, -0.01038389f, -0.08811180f, -0.02110090f, -0.02034738f, 0.07578609f, 0.02287389f, 
    0.06212154f, 0.06960566f, -0.03896612f, 0.06852439f, -0.00716821f, -0.06478675f, -0.05814838f, 0.03538356f, 
    -0.04684457f, 0.02450817f, 0.06349266f, -0.07089623f, -0.07254989f, 0.00473047f, 0.02783722f, -0.08297879f, 
    0.04538302f, -0.00613232f, -0.08096108f, -0.01280393f, 0.02703055f, 0.01179752f, 0.03189619f, -0.07052900f, 
    -0.11934972f, -0.10404877f, -0.08555849f, 0.03946432f, 0.10838822f, -0.11809921f, -0.11782548f, 0.19571082f, 
    0.14651451f, -0.32400274f, 0.16185282f, 0.12742133f, 0.02355788f, 0.10047904f, 0.17128609f, -0.10580885f, 
    0.01323776f, 0.06955353f, 0.17320116f, 0.27168399f, 0.03445351f, -0.06483065f, -0.11344076f, 0.06006663f, 
    -0.07854794f, 0.11481944f, -0.20551220f, 0.33897012f, 0.23001480f, 0.19110556f, -0.02904740f, -0.06177193f, 
    0.10591098f, -0.04570042f, 0.09107173f, -0.02954425f, 0.02035311f, 0.12538897f, 0.05959648f, 0.04354081f, 
    -0.06303566f, 0.10515298f, -0.03062372f, 0.18174757f, -0.02140293f, 0.00518968f, 0.12831275f, 0.31176993f, 
    0.27918473f, -0.05416841f, -0.09759672f, 0.00683934f, -0.11281373f, 0.19076248f, -0.24664429f, -0.07490011f, 
    -0.15449297f, 0.08903211f, -0.06967650f, 0.04428774f, -0.08788718f, 0.13677573f, 0.05103643f, 0.38100222f, 
    0.07451747f, 0.06544850f, -0.00578331f, -0.16125232f, -0.01247832f, -0.06283380f, -0.02036045f, -0.04498058f, 
    -0.32144338f, -0.28304797f, 0.05102522f, -0.01009820f, -0.08853627f, 0.10868447f, 0.03921875f, -0.16929457f, 
    0.04889795f, -0.10404611f, 0.07763024f, -0.02078987f, -0.05084107f, -0.00464654f, -0.03279488f, -0.15957552f, 
    -0.04157126f, 0.07746207f, 0.01546514f, 0.17154062f, -0.17142312f, 0.07792368f, 0.20120050f, -0.16887756f, 
    0.12936354f, 0.09829410f, -0.00215226f, 0.12803090f, -0.23846610f, -0.22007190f, -0.07254843f, -0.13039003f, 
    -0.12200117f, 0.02061594f, -0.08397701f, -0.04511257f, -0.05631310f, -0.05957267f, 0.00582318f, -0.06417171f, 
    0.12575883f, 0.03440289f, -0.14706637f, -0.00963685f, -0.16015352f, 0.01312556f, 0.22216700f, 0.13645571f, 
    -0.00675371f, -0.05762395f, 0.02215745f, -0.01561143f, 0.08226386f, 0.02390072f, -0.23622628f, 0.09516449f, 
    -0.08381636f, 0.10015178f, -0.16177373f, -0.10026554f, 0.07520579f, 0.17160334f, 0.02278185f, -0.03343622f, 
    0.12260722f, -0.07970465f, 0.01687292f, 0.03919644f, 0.15858583f, -0.03092244f, -0.23462749f, -0.06254794f, 
    0.01762967f, 0.05036758f, 0.06079630f, -0.00217038f, -0.01224538f, -0.00265439f, -0.08166841f, -0.05377323f, 
    -0.06454276f, 0.03053783f, -0.06818746f, -0.06364264f, -0.04452292f, -0.05023512f, 0.03342909f, -0.03801943f, 
    -0.04437931f, 0.01953331f, 0.00417455f, -0.03995987f, -0.06486716f, -0.02953939f, -0.04016129f, 0.04088423f, 
    -0.00639117f, 0.02118080f, -0.09095592f, -0.08927289f, 0.00522627f, -0.05081460f, 0.01019744f, -0.05030438f, 
    0.00535093f, 0.06420013f, 0.00894590f, -0.04771957f, 0.05085297f, -0.04459589f, -0.01253682f, 0.03477737f, 
    0.02381885f, 0.06892508f, -0.06527536f, 0.07437644f, 0.03921831f, -0.08222557f, -0.05481753f, 0.06225836f, 
    -0.08371127f, 0.01804354f, -0.02397115f, -0.01796402f, 0.02000362f, 0.03043466f, 0.02182153f, 0.00352586f, 
    0.01846687f, -0.07940756f, -0.04512914f, 0.03130889f, 0.02806307f, 0.03064866f, -0.00263169f, -0.02707705f, 
    -0.05119886f, -0.06690713f, -0.01982599f, -0.04303922f, 0.05065472f, -0.07888459f, -0.06203074f, -0.02717743f, 
    -0.06017522f, -0.07948208f, -0.02207914f, -0.08253620f, 0.04651085f, -0.08017825f, 0.06019802f, -0.01803260f, 
    -0.01684447f, -0.08869295f, -0.04776223f, 0.00908688f, -0.00437140f, -0.05418983f, -0.08206502f, -0.05952714f, 
    0.03686906f, 0.00227939f, 0.07162746f, 0.00371852f, -0.08371766f, -0.01940114f, -0.08453248f, -0.07913134f, 
    -0.04359910f, 0.01453940f, -0.04263442f, -0.00885286f, 0.07375161f, -0.09021901f, -0.02163137f, 0.05643575f, 
    -0.04463330f, -0.02255564f, -0.00444021f, -0.01543013f, 0.01321957f, 0.06851624f, 0.02852025f, -0.04880388f, 
    -0.04900990f, 0.05104153f, 0.04049467f, -0.05857791f, -0.01258187f, 0.03950205f, -0.07408078f, -0.08599608f, 
    -0.07443184f, 0.03575996f, 0.07382135f, 0.05329411f, 0.06125154f, -0.07862294f, 0.02570121f, -0.01062082f, 
    -0.01455709f, -0.05216538f, -0.06702843f, 0.01671201f, -0.08997690f, -0.05426493f, 0.01312075f, -0.04803870f, 
    -0.02671342f, 0.02125586f, -0.05775471f, 0.06987876f, -0.04295486f, -0.03762886f, -0.08021452f, 0.03371073f, 
    0.06802376f, -0.06032970f, -0.02683906f, 0.06986706f, -0.00451723f, 0.04194491f, -0.03775073f, 0.01163965f, 
    -0.05655136f, 0.00339761f, 0.00396036f, 0.01050283f, -0.02718866f, 0.02608549f, -0.03631353f, -0.06600002f, 
    -0.09205981f, 0.04551334f, -0.04815341f, -0.04209116f, 0.06817886f, -0.06570540f, 0.02496087f, -0.01314455f, 
    -0.03925136f, -0.05357664f, 0.01467211f, 0.04269774f, -0.09023939f, 0.00368299f, -0.08185563f, 0.02595955f, 
    0.00242596f, -0.06237904f, 0.01698724f, -0.02704110f, 0.01458068f, -0.10318833f, -0.05916944f, 0.06356630f, 
    0.00793534f, -0.02530648f, -0.00137544f, -0.00025396f, -0.09037842f, -0.08158229f, -0.03528196f, 0.05707380f, 
    0.02012140f, -0.01646789f, -0.04202591f, -0.03382081f, -0.09837819f, -0.10550340f, -0.06740821f, -0.08209501f, 
    -0.07962757f, -0.06441701f, 0.05735127f, 0.01356854f, 0.06127287f, 0.03900379f, -0.02462509f, -0.06418537f, 
    0.05247434f, 0.06677113f, 0.06981628f, 0.01701673f, 0.07269736f, 0.03549451f, 0.00252196f, 0.00676781f, 
    -0.03141529f, 0.01053982f, -0.07091115f, 0.03833294f, -0.01194546f, -0.04250903f, 0.05227779f, 0.01661380f, 
    0.02288728f, -0.05260279f, 0.01419310f, -0.04399654f, 0.01714074f, -0.09776227f, -0.02411886f, 0.02881404f, 
    0.02229859f, 0.00563299f, -0.07567332f, -0.02777692f, 0.03400713f, -0.03246890f, 0.02265864f, -0.05782769f, 
    0.00959934f, 0.01670504f, -0.02795883f, 0.01184160f, -0.01640251f, 0.06251457f, -0.03133253f, -0.08518318f, 
    0.02315327f, 0.06011949f, -0.03774558f, -0.09536656f, -0.08678482f, -0.05709234f, -0.04467032f, 0.05976301f, 
    0.02948021f, -0.03566962f, -0.04660070f, -0.07591654f, -0.03535146f, -0.05290577f, -0.06814001f, 0.06283575f, 
    0.05735181f, -0.07270048f, 0.00304482f, 0.01950691f, 0.01558304f, -0.07903210f, -0.03009534f, -0.06090174f, 
    0.00310872f, 0.03550940f, -0.03289586f, 0.05309479f, -0.05668423f, -0.02432978f, -0.04808308f, 0.06074313f, 
    -0.01352343f, -0.07324020f, -0.00176336f, 0.05279859f, 0.05346351f, 0.05884737f, -0.04837912f, -0.03328311f, 
    0.02162373f, 0.05598257f, -0.07617959f, 0.05860224f, -0.02171068f, -0.02291204f, -0.04737280f, -0.03418554f, 
    -0.08644480f, 0.03920159f, -0.00563124f, -0.06487323f, 0.06139408f, 0.05842442f, -0.05249392f, 0.03968060f, 
    0.04707856f, -0.01303652f, 0.04472121f, 0.06083159f, 0.02145975f, -0.02196342f, 0.05663139f, -0.03506667f, 
    -0.02951111f, 0.05129419f, -0.03783401f, -0.09744143f, -0.07473265f, 0.02143967f, 0.00904874f, -0.00282621f, 
    -0.07251268f, -0.06816639f, -0.00598782f, -0.07224487f, -0.03682696f, 0.01032070f, -0.00625489f, -0.04333740f, 
    -0.03658752f, 0.04850367f, -0.01863698f, -0.08620390f, -0.01613388f, -0.06240809f, 0.04787698f, 0.01637469f, 
    0.04658800f, -0.00466089f, -0.07319012f, 0.00761594f, -0.06210334f, -0.00236492f, -0.04715128f, 0.02750552f, 
    -0.01352064f, -0.08980902f, -0.07003146f, -0.04197608f, -0.08479081f, -0.01209353f, -0.00105752f, -0.02987723f, 
    -0.07938464f, -0.01295060f, 0.06558122f, 0.03415314f, 0.04414740f, -0.07867603f, -0.03027947f, 0.01667896f, 
    0.00312036f, -0.01786442f, 0.03098405f, -0.05046594f, -0.08091722f, 0.02586286f, -0.01642705f, 0.00342315f, 
    -0.03483086f, 0.03586216f, -0.00530328f, -0.02008631f, -0.06653415f, 0.04788747f, 0.06389838f, 0.03433373f, 
    0.03402003f, -0.00820721f, -0.06174257f, 0.00461371f, -0.04926192f, -0.07121810f, 0.01006246f, 0.03688310f, 
    -0.07941405f, -0.05315860f, 0.06370059f, 0.01465039f, -0.02528712f, 0.00247902f, 0.04198488f, -0.08025309f, 
    0.04990290f, -0.06979062f, -0.06447474f, 0.02012140f, 0.04308741f, 0.05455340f, -0.10090279f, 0.03709993f, 
    -0.06472686f, -0.06720170f, -0.05981869f, -0.03015315f, 0.05244961f, -0.04423790f, 0.00910490f, -0.01630489f, 
    -0.08574252f, -0.04774320f, 0.03111124f, 0.00883457f, 0.03619808f, -0.08224338f, -0.04977605f, 0.00708470f, 
    -0.01562865f, -0.01131103f, 0.02146944f, -0.04270303f, 0.03280385f, 0.04308396f, 0.03094259f, 0.02843874f, 
    -0.01739623f, -0.05293412f, -0.04935291f, 0.00674750f, 0.03814634f, 0.04005238f, -0.01284612f, 0.02288980f, 
    -0.13395390f, 0.06710510f, -0.14629638f, 0.26282182f, 0.09496588f, 0.09495079f, 0.09688667f, 0.00348727f, 
    -0.10571492f, 0.00398091f, 0.11406896f, 0.23741980f, -0.00641956f, -0.02628926f, 0.08638083f, 0.03152073f, 
    0.07219718f, 0.10825939f, -0.03117461f, 0.22861543f, 0.16661917f, -0.02909040f, -0.01563034f, -0.04618556f, 
    -0.05125020f, 0.09955183f, 0.21811128f, -0.16062708f, 0.07931617f, 0.39692390f, 0.20748107f, -0.01932917f, 
    0.12105208f, -0.04285203f, 0.01244070f, 0.06502720f, -0.24414138f, -0.20269600f, -0.18075059f, 0.28272867f, 
    0.25232428f, -0.08874239f, -0.02933648f, -0.17500316f, -0.13342492f, 0.33784860f, -0.23091130f, 0.06486509f, 
    -0.09832670f, -0.09146409f, 0.14257033f, 0.10295864f, 0.04923370f, 0.22589108f, 0.00060923f, -0.09007169f, 
    -0.02594874f, -0.25493672f, 0.24193169f, -0.04398118f, 0.03446552f, -0.14321266f, 0.05703624f, 0.11349951f, 
    0.10498694f, 0.13314548f, 0.12892468f, 0.13986766f, 0.23986141f, 0.18311450f, -0.11360985f, 0.25180912f, 
    -0.11725727f, 0.10330840f, -0.08961634f, -0.13298321f, -0.02852255f, -0.03944782f, -0.22873788f, -0.15949972f, 
    0.03708252f, 0.01165484f, -0.30487403f, -0.21437506f, 0.12807439f, 0.08194996f, -0.06738823f, -0.08101073f, 
    -0.09838705f, -0.12022728f, -0.03790422f, -0.00516790f, 0.12870587f, -0.08503050f, -0.08349914f, 0.15528700f, 
    -0.05605818f, -0.06643137f, 0.04382299f, 0.06439890f, -0.07517500f, -0.03178430f, 0.00545019f, 0.15793900f, 
    -0.01961503f, 0.14410169f, 0.02272354f, -0.04953875f, 0.34453759f, 0.18454473f, 0.10577480f, -0.09347794f, 
    0.10526383f, -0.38462844f, 0.02005549f, 0.11589158f, 0.07609748f, 0.04314044f, -0.00492292f, 0.18292585f, 
    -0.00833459f, -0.13284998f, -0.08893275f, 0.21063994f, 0.03840378f, 0.21642135f, 0.05476118f, 0.00620113f, 
    -0.08599770f, 0.13691595f, -0.00326447f, 0.13692303f, -0.04422568f, -0.31864458f, -0.02165205f, 0.19024098f, 
    -0.24355905f, -0.00756391f, -0.06595936f, -0.19886951f, 0.34094587f, 0.06158898f, 0.15720129f, -0.27140817f, 
    0.16812652f, 0.21782002f, 0.03349724f, -0.04696327f, 0.11755054f, -0.29012144f, 0.22211792f, 0.27243513f, 
    0.06930059f, 0.11709949f, 0.06230063f, 0.15618780f, -0.12003303f, -0.06853221f, 0.00982428f, -0.06403086f, 
    0.22412033f, 0.07869963f, -0.12409852f, 0.06130688f, 0.15130316f, 0.04012309f, 0.04301423f, -0.11028079f, 
    0.17531857f, 0.16985248f, -0.14708959f, 0.18783426f, 0.05362369f, 0.24288961f, 0.12013379f, 0.06255147f, 
    -0.01730764f, 0.05581912f, -0.16139282f, -0.03705886f, 0.08970848f, 0.00966090f, -0.32062218f, 0.15497595f, 
    -0.08287524f, 0.11283698f, 0.02677848f, -0.05763863f, 0.00276241f, -0.08756921f, -0.14981718f, -0.21460935f, 
    0.18397678f, 0.16564125f, 0.20485625f, -0.07047347f, -0.03108134f, -0.12780562f, 0.03288737f, 0.17389743f, 
    0.11059048f, -0.09323199f, -0.08014343f, -0.10817932f, 0.07250538f, 0.06307549f, -0.09082489f, 0.16963595f, 
    0.13289541f, -0.53679705f, 0.08207453f, 0.01286286f, 0.08931507f, 0.07737608f, -0.09386510f, -0.04207433f, 
    0.07695732f, 0.01771608f, 0.18354554f, -0.15996966f, -0.07169012f, 0.02810527f, -0.05719933f, -0.03283344f, 
    0.02768452f, -0.31613129f, -0.50233793f, 0.02809081f, 0.05348493f, 0.09715972f, 0.04796649f, -0.05374136f, 
    0.11152495f, 0.24813347f, -0.05366229f, -0.38129792f, -0.23677036f, 0.07783886f, -0.06168859f, -0.07273568f, 
    0.00434408f, 0.03189741f, 0.07968619f, -0.27090669f, -0.03868844f, 0.08142170f, -0.10255793f, -0.02102767f, 
    -0.24228607f, -0.01757743f, 0.03313208f, 0.13304324f, -0.09652356f, -0.04354999f, -0.07979683f, -0.10813048f, 
    0.06664773f, -0.06847417f, -0.05499462f, 0.02008589f, 0.00567667f, -0.61977339f, -0.15798846f, 0.14269727f, 
    -0.04507783f, 0.03951347f, -0.08671597f, -0.03911867f, 0.02256498f, 0.01072191f, -0.06797265f, 0.32112539f, 
    0.26898783f, 0.01020409f, 0.06030999f, -0.15572408f, -0.06298779f, 0.14840341f, -0.08714879f, -0.13594364f, 
    0.07821269f, -0.07485034f, -0.12870595f, -0.22325733f, -0.09155537f, -0.07557007f, 0.15336132f, -0.02431392f, 
    0.03257047f, 0.05625331f, -0.14674021f, -0.00343114f, -0.03574146f, -0.01640499f, -0.09131243f, 0.09216270f, 
    0.09574329f, 0.15090162f, 0.22377269f, -0.26444986f, -0.01500400f, 0.08125023f, 0.05590121f, -0.16772342f, 
    -0.04635803f, -0.05484429f, -0.25388214f, -0.07400744f, -0.38918895f, -0.14720641f, 0.16377081f, 0.10764237f, 
    0.03569273f, 0.06692660f, 0.15536144f, 0.16396706f, -0.08355652f, -0.05282272f, 0.03992005f, 0.02600850f, 
    0.13481280f, 0.06988090f, -0.05065561f, -0.18549398f, 0.55264163f, 0.24238725f, 0.01635594f, 0.09865015f, 
    -0.05831496f, -0.06952257f, 0.04232816f, 0.07552256f, 0.05486877f, -0.03202492f, 0.01594688f, -0.30199477f, 
    0.21360180f, 0.11361302f, 0.12912442f, -0.07271849f, -0.13626723f, -0.12580228f, -0.34571856f, 0.03721920f, 
    0.09275364f, 0.04840020f, 0.09741586f, -0.06371753f, -0.09336512f, -0.01821002f, 0.22542718f, 0.35384333f, 
    0.16953021f, -0.11052901f, -0.04348713f, -0.04973352f, -0.04246653f, 0.18255778f, 0.10362323f, 0.02732987f, 
    -0.06649116f, 0.04215357f, 0.07726356f, 0.08895992f, -0.00736856f, -0.10677345f, -0.01070054f, -0.03332527f, 
    0.05747750f, -0.07569163f, 0.06480025f, 0.04532172f, -0.10718445f, 0.01269078f, 0.09397630f, -0.08432855f, 
    0.00451704f, -0.11154805f, 0.10640030f, -0.00395362f, 0.02693692f, 0.06037793f, 0.05793818f, -0.01291729f, 
    0.08048837f, -0.00244426f, 0.17849906f, -0.15773588f, 0.09050194f, -0.19405037f, 0.02682235f, -0.12285002f, 
    0.07609136f, 0.06666946f, 0.02030733f, 0.17722668f, -0.01828983f, -0.46067441f, -0.24034467f, 0.02420693f, 
    0.09085970f, -0.00465452f, -0.07448146f, -0.03653197f, -0.08594833f, -0.19923230f, -0.33635953f, 0.10168903f, 
    0.04014163f, 0.10893979f, 0.21339516f, -0.04094473f, -0.04366798f, -0.06932312f, 0.03055105f, -0.00034164f, 
    -0.14626189f, -0.01120016f, 0.00543942f, -0.00688321f, 0.07711610f, -0.00299288f, 0.01592295f, -0.06945458f, 
    -0.79336464f, 0.21244149f, -0.01660550f, -0.07530969f, -0.05271123f, -0.07995374f, -0.00933420f, -0.03781861f, 
    0.23586044f, -0.10771983f, 0.03031162f, -0.00622559f, -0.03822444f, -0.01895170f, 0.09927088f, 0.11996874f, 
    0.03953688f, 0.21079111f, 0.35244578f, 0.13253553f, 0.03218265f, 0.21702577f, -0.14546424f, -0.08696430f, 
    0.06913684f, 0.08414020f, -0.11746865f, -0.00883018f, -0.23117739f, -0.06973750f, -0.07339904f, -0.06590170f, 
    0.15457875f, 0.11324868f, 0.11101112f, -0.20131901f, -0.40347055f, -0.37058300f, 0.18123394f, 0.06287167f, 
    -0.06900445f, 0.02480267f, 0.02956819f, -0.02632671f, -0.23893052f, -0.20544633f, -0.21472688f, 0.23813373f, 
    0.24929696f, 0.05820796f, -0.15599638f, 0.08173285f, 0.05953271f, -0.45305258f, -0.07507081f, -0.20644031f, 
    -0.04998309f, 0.11590127f, -0.08708661f, -0.05670149f, -0.14920685f, -0.08100166f, 0.26361382f, 0.17221539f, 
    0.27338761f, -0.15334725f, -0.03411871f, 0.19584133f, 0.17238598f, -0.03265730f, 0.06199920f, -0.33041176f, 
    -0.24493907f, 0.00720801f, 0.06452724f, 0.01175222f, 0.04450956f, -0.01672764f, 0.00244548f, -0.06021759f, 
    0.39818347f, 0.27558795f, 0.14986807f, -0.11777157f, 0.03006540f, -0.03564666f, 0.00438203f, 0.16172767f, 
    0.03503009f, -0.20937209f, -0.08767549f, -0.08090941f, 0.17811489f, -0.10221034f, 0.10005424f, -0.09364238f, 
    -0.19310245f, -0.11769551f, -0.22738960f, -0.10533249f, -0.05504379f, 0.03419076f, 0.05632185f, -0.06708109f, 
    -0.09900526f, -0.00435171f, -0.01167712f, -0.11985397f, 0.02622228f, -0.05017135f, 0.00378346f, 0.20225391f, 
    0.12138277f, 0.02327909f, 0.03755390f, 0.13145663f, -0.01284891f, -0.11969524f, 0.22338112f, 0.04354026f, 
    0.06948104f, 0.05857675f, -0.05027287f, 0.06592304f, 0.13074946f, 0.14737824f, 0.16802461f, -0.33786571f, 
    -0.02685761f, -0.03030861f, -0.00640956f, 0.09639496f, -0.08934489f, -0.09696384f, 0.09986545f, -0.29511186f, 
    0.09361354f, -0.12494453f, -0.10335787f, -0.09806868f, 0.04008000f, 0.01605877f, -0.05341787f, -0.37189734f, 
    -0.01975057f, -0.02331511f, 0.04922808f, 0.08644196f, -0.06021072f, 0.15753806f, 0.03211851f, -0.00742450f, 
    0.39103118f, 0.29232758f, 0.04406759f, 0.06903102f, 0.02845115f, -0.20315944f, 0.06889581f, 0.20907544f, 
    0.07559559f, -0.35414234f, -0.28610143f, -0.00429442f, 0.13636540f, -0.11815509f, 0.07087321f, -0.01907137f, 
    -0.02770411f, 0.13620804f, 0.17556393f, -0.13439415f, 0.14825059f, 0.02013841f, 0.13712400f, 0.13012002f, 
    0.19558118f, 0.10799638f, 0.08017969f, -0.10735191f, -0.21076521f, -0.00004772f, -0.05396092f, 0.06767866f, 
    -0.02090965f, 0.06018739f, -0.04680405f, 0.04730393f, -0.06681892f, 0.06542157f, 0.40792415f, -0.14050724f, 
    0.01773060f, 0.06923284f, -0.02083153f, -0.00477845f, 0.09020450f, -0.19615328f, 0.18409210f, -0.14130571f, 
    -0.19291988f, 0.06577080f, 0.08205174f, 0.06443560f, 0.21346880f, -0.14360957f, 0.02882667f, 0.31225219f, 
    0.13785578f, 0.05174632f, -0.01133094f, 0.02917078f, -0.07635927f, 0.03792679f, 0.08768146f, -0.13063167f, 
    0.01749104f, -0.05765367f, -0.10840289f, -0.00504103f, -0.20224592f, -0.07554909f, 0.05856335f, -0.06211690f, 
    0.28998271f, -0.13437551f, -0.16130777f, 0.14952850f, -0.05118586f, 0.01404789f, 0.04318194f, 0.07046274f, 
    0.01953587f, 0.05401677f, -0.31106028f, 0.02983674f, 0.09983701f, -0.12233596f, -0.08541492f, 0.00296036f, 
    0.01227722f, 0.17184281f, -0.15055129f, 0.10104304f, -0.01095148f, 0.02869862f, -0.04430716f, -0.13154820f, 
    -0.03204868f, 0.05424257f, -0.07708541f, 0.06447480f, -0.20274107f, -0.21626776f, 0.11531056f, -0.17287360f, 
    -0.08962648f, 0.22849378f, 0.07037902f, 0.06860919f, -0.50394154f, -0.25307089f, -0.49050540f, 0.08938000f, 
    0.04440941f, 0.05448680f, 0.15706992f, -0.06386536f, 0.11418107f, -0.39171973f, 0.59849912f, -0.09812775f, 
    0.13270594f, -0.00996907f, 0.16043720f, 0.01344507f, -0.17096175f, -0.08128494f, 0.20074984f, 0.08473042f, 
    0.12888317f, -0.01516698f, -0.16235672f, -0.05302456f, 0.02812520f, -0.04015639f, 0.03739978f, 0.07536234f, 
    -0.08191773f, -0.32119647f, 0.01919831f, -0.10858037f, -0.15692246f, -0.02766235f, -0.23493960f, -0.12555611f, 
    -0.36842453f, -0.10501802f, 0.09029751f, 0.00669196f, 0.13417195f, 0.04379786f, -0.05421524f, 0.11086849f, 
    -0.02266429f, 0.15252858f, -0.51378089f, 0.23566315f, 0.20374195f, 0.04609308f, 0.06476661f, -0.04161445f, 
    -0.08152825f, -0.24058242f, -0.14386240f, 0.08511052f, -0.21474165f, -0.21765636f, 0.09381193f, -0.07392903f, 
    -0.04599940f, 0.04216060f, -0.12102737f, -0.12184723f, 0.13138793f, 0.12576884f, -0.02335070f, -0.11699914f, 
    0.04284810f, -0.02749958f, 0.09124815f, -0.10437791f, 0.05438361f, 0.16666093f, 0.12862481f, -0.00062482f, 
    -0.06517912f, 0.07167670f, 0.13798583f, 0.13465542f, -0.02234242f, 0.15554759f, 0.16371585f, 0.00272054f, 
    0.04630152f, -0.02550880f, -0.11926230f, -0.07342000f, 0.16913201f, -0.06385363f, -0.35080460f, -0.14349657f, 
    -0.08059219f, 0.16970396f, 0.17774673f, 0.12534289f, -0.00909238f, 0.12427139f, -0.16180444f, 0.34843454f, 
    0.13661437f, 0.00901156f, -0.09490569f, 0.13201202f, -0.35083154f, 0.07425498f, 0.09544221f, 0.01487543f, 
    -0.05489001f, -0.17190231f, 0.21697527f, 0.06218870f, -0.05526815f, 0.17396729f, 0.08474610f, 0.05661337f, 
    -0.08118546f, -0.07455163f, 0.10283552f, 0.05741523f, -0.04403264f, -0.08807293f, -0.01356694f, -0.03997594f, 
    0.05842441f, 0.00597448f, 0.22709657f, -0.28447127f, 0.16769207f, -0.07017031f, 0.07699069f, -0.06885473f, 
    0.08583833f, 0.20862442f, -0.01684136f, -0.21094856f, -0.27877015f, -0.03132868f, 0.01730709f, -0.03256489f, 
    -0.06594681f, -0.20947924f, -0.13197988f, 0.10308950f, 0.40097514f, -0.15332651f, 0.22662869f, 0.04938304f, 
    -0.14058693f, -0.10863429f, 0.01862449f, -0.09015222f, 0.01984090f, 0.32955638f, 0.19075772f, 0.04422104f, 
    0.10549381f, -0.22476593f, 0.05556517f, 0.09637593f, 0.03773901f, 0.13462079f, -0.17903264f, -0.08988949f, 
    0.05252137f, 0.08654979f, -0.14740589f, 0.07186067f, -0.06095023f, -0.01794214f, -0.05829086f, 0.24403419f, 
    -0.13333088f, -0.05785424f, 0.01334684f, -0.06804537f, 0.05086675f, -0.10947701f, 0.06641609f, -0.13503511f, 
    -0.08532494f, -0.14655051f, 0.01431788f, -0.11006381f, 0.13130292f, 0.10046335f, -0.02617551f, 0.12113363f, 
    -0.04944472f, -0.09166241f, -0.15119427f, -0.06323601f, -0.08515754f, 0.02793700f, -0.05531913f, 0.02652910f, 
    -0.07901372f, 0.03287842f, 0.22117357f, 0.31584084f, 0.00484398f, -0.00521949f, 0.02944185f, 0.05686737f, 
    -0.20925778f, -0.03674414f, 0.14075291f, -0.08970038f, 0.24303779f, 0.18163265f, 0.19182186f, -0.00637403f, 
    -0.00061995f, -0.10018264f, -0.02435204f, 0.07919074f, 0.12805597f, -0.06762661f, -0.09589531f, 0.01615158f, 
    0.04890341f, -0.05596977f, -0.01469562f, -0.02789315f, -0.05162152f, 0.42606956f, -0.08089086f, 0.22037382f, 
    0.14137374f, 0.05922446f, 0.07598617f, 0.13012485f, -0.05681276f, -0.19854487f, 0.14145589f, -0.02622071f, 
    -0.14112359f, -0.00863209f, 0.10104043f, -0.06489259f, -0.06677469f, -0.00127214f, -0.03891023f, 0.15301482f, 
    0.39290386f, -0.02217324f, 0.18032046f, -0.06139568f, 0.04406704f, 0.15477063f, 0.08075790f, 0.31567839f, 
    -0.01399512f, -0.10686783f, -0.03975134f, -0.15475883f, -0.01428909f, -0.06521083f, -0.15609095f, -0.01611782f, 
    -0.09227799f, 0.16462047f, -0.20263086f, -0.20535751f, -0.04401297f, -0.02319619f, 0.02951128f, 0.10069823f, 
    0.06045509f, -0.04756556f, -0.01645193f, -0.11997032f, 0.02144924f, -0.04153817f, 0.10616142f, 0.13434686f, 
    -0.02354738f, 0.17468089f, -0.08470561f, 0.10269993f, -0.29178509f, -0.22243898f, -0.20248277f, 0.05053508f, 
    0.08193891f, -0.12635030f, -0.02051104f, -0.06028603f, -0.18826509f, 0.18048759f, -0.03590078f, -0.07151245f, 
    -0.19678275f, -0.22679727f, -0.01442358f, -0.06762685f, -0.02462086f, 0.23575455f, 0.23024230f, 0.14771770f, 
    -0.08042242f, -0.04014966f, -0.25680187f, 0.04871918f, -0.07369664f, 0.10981842f, 0.02303660f, 0.00079165f, 
    0.08510923f, -0.02387841f, 0.01896479f, 0.00171975f, -0.05375422f, -0.03348581f, 0.01307944f, 0.34410477f, 
    0.28040180f, -0.05192506f, 0.04208318f, -0.07614843f, 0.01991160f, 0.05613278f, 0.01088421f, -0.05671926f, 
    -0.22245570f, -0.05051469f, -0.17934874f, 0.18806815f, 0.04137680f, 0.19387473f, 0.01054252f, -0.03663154f, 
    -0.19282423f, 0.01460334f, 0.08861002f, 0.17970426f, 0.15147424f, 0.11981984f, -0.07656565f, -0.16956484f, 
    0.00419873f, -0.05310022f, -0.13450992f, -0.11843598f, 0.18424733f, -0.08157423f, 0.12537278f, 0.19806445f, 
    -0.04194843f, 0.07111412f, -0.01600321f, 0.15022148f, -0.00182381f, 0.05051009f, -0.01348681f, -0.08146926f, 
    0.11800653f, 0.12074795f, 0.07592155f, 0.11525659f, 0.05804432f, -0.10920015f, -0.09387418f, 0.05831009f, 
    -0.05194351f, -0.04053483f, 0.02313573f, 0.07701898f, 0.07644121f, 0.11249708f, -0.10022090f, 0.05439072f, 
    0.22078317f, -0.13809626f, 0.03893423f, 0.00505168f, 0.06057007f, -0.00998294f, -0.61588383f, -0.21348032f, 
    -0.25377798f, 0.13931508f, 0.08757900f, 0.11017054f, 0.01053659f, -0.04393640f, 0.00379161f, 0.16263837f, 
    0.11530758f, -0.17256528f, 0.12299744f, 0.19138248f, -0.05309211f, 0.00059585f, 0.11665526f, 0.08599710f, 
    -0.35002664f, -0.23086934f, -0.03911836f, 0.18538658f, -0.13969883f, -0.02432827f, -0.05352337f, -0.02777251f, 
    0.15397581f, 0.23944351f, 0.16212705f, 0.13242598f, -0.17906608f, -0.03792515f, -0.20863831f, 0.02038669f, 
    -0.04085288f, 0.17235339f, 0.15150054f, -0.01478838f, 0.06503988f, 0.07997829f, 0.03558604f, -0.10380477f, 
    -0.00590553f, 0.00052618f, -0.12039113f, 0.05164289f, -0.01819635f, 0.10437015f, 0.04845665f, 0.04442477f, 
    0.09956693f, 0.09667638f, 0.15148582f, 0.00830195f, 0.37473056f, -0.26470047f, -0.03259229f, -0.00312390f, 
    -0.07968590f, 0.13241886f, -0.20768648f, -0.11690494f, 0.02600449f, -0.14017260f, -0.17589960f, 0.20973286f, 
    0.03552708f, 0.09555817f, -0.13434951f, 0.10276959f, -0.03033640f, -0.02180739f, -0.45561308f, 0.04824223f, 
    -0.20719343f, -0.13759325f, 0.19977485f, 0.02407854f, 0.27273363f, -0.16436982f, -0.08659481f, -0.35988149f, 
    -0.01105491f, -0.05052277f, 0.01869363f, 0.00634378f, -0.08778804f, 0.03174387f, 0.06535834f, 0.11781770f, 
    -0.30153725f, 0.05275397f, 0.00134708f, 0.09586503f, 0.01331493f, -0.02165700f, -0.00162189f, -0.00057166f, 
    0.09466293f, 0.44283485f, 0.21274164f, -0.22553524f, -0.07960456f, -0.11918585f, 0.03149443f, 0.08813086f, 
    0.00586706f, 0.11971583f, 0.37975106f, -0.15960331f, -0.07553583f, 0.05521255f, 0.09341379f, 0.13254763f, 
    0.01524610f, 0.01003622f, -0.00695155f, -0.37069723f, 0.05765020f, 0.27293494f, -0.01157684f, -0.15694220f, 
    0.11338247f, -0.20353857f, 0.02711077f, 0.13377072f, -0.24863808f, 0.03657258f, 0.25837231f, 0.00888131f, 
    0.04051825f, -0.00461333f, -0.08233870f, 0.05504146f, -0.01391017f, 0.04004579f, -0.01303935f, 0.05187618f, 
    0.04778564f, 0.22148965f, 0.13671267f, -0.07564818f, -0.07027142f, -0.15767497f, 0.12005883f, -0.21526228f, 
    -0.29700279f, 0.02321595f, 0.08488663f, 0.11227155f, -0.01431138f, 0.10028710f, -0.18784267f, -0.34818342f, 
    -0.13699491f, -0.00260232f, -0.11233822f, -0.03919125f, 0.10071881f, -0.08099791f, 0.03213895f, 0.04764157f, 
    0.40006351f, -0.01171146f, -0.31413683f, 0.17316265f, -0.04570729f, -0.15538482f, 0.00628654f, -0.00966375f, 
    -0.09213202f, -0.00587656f, 0.07481453f, -0.00989178f, 0.06615125f, 0.00470141f, -0.07842483f, 0.08131871f, 
    -0.12422094f, -0.00951551f, 0.04250941f, -0.20664771f, 0.24511434f, 0.08855097f, 0.06264995f, 0.06739050f, 
    -0.04465420f, -0.09882566f, -0.05146846f, -0.16020738f, -0.00616021f, -0.18042244f, -0.07825951f, 0.16444455f, 
    -0.06625196f, 0.04863113f, -0.00160526f, 0.12482640f, 0.10342350f, 0.09883018f, -0.39518169f, 0.16249338f, 
    0.13752367f, 0.00719531f, 0.16347042f, 0.02140820f, -0.11971856f, -0.13633594f, 0.04137638f, -0.06122433f, 
    -0.08754496f, -0.11035876f, -0.12680288f, 0.01567500f, 0.05408884f, 0.00315815f, 0.37233323f, 0.29642582f, 
    -0.16321930f, -0.03467735f, 0.07060996f, -0.09731498f, 0.07675850f, 0.00479252f, 0.09306832f, 0.14195891f, 
    -0.36700252f, -0.27970669f, -0.20259707f, -0.04161320f, -0.07226302f, -0.10848680f, -0.13926496f, -0.00660241f, 
    0.01046997f, -0.04070171f, -0.05770555f, -0.01416372f, -0.05319436f, -0.03539992f, 0.00595219f, 0.06375317f, 
    -0.01673161f, -0.05677076f, 0.01965235f, -0.02801793f, -0.00621948f, -0.07280183f, -0.03613443f, 0.04258487f, 
    -0.08930089f, -0.02904998f, -0.00112113f, -0.06940310f, -0.01738545f, -0.03940056f, -0.10244784f, -0.10886297f, 
    -0.06108292f, -0.04789172f, 0.02527844f, -0.02763982f, -0.05469824f, 0.00156185f, 0.02339792f, 0.04237906f, 
    -0.06545009f, -0.10103299f, -0.00694391f, -0.07274742f, -0.05226524f, -0.04296986f, 0.07330294f, -0.11461137f, 
    0.03003895f, -0.05921256f, -0.07555891f, -0.06252441f, -0.07537449f, -0.06610907f, 0.01934193f, -0.05570764f, 
    -0.12833373f, 0.02300288f, 0.07522114f, 0.01503071f, -0.01669967f, -0.01557583f, -0.04010621f, -0.01428050f, 
    -0.07708087f, 0.02147909f, -0.06923556f, -0.07198972f, 0.07815602f, 0.08294650f, -0.06084723f, -0.01790881f, 
    0.01305937f, -0.05491283f, 0.03379365f, -0.08315028f, 0.04019762f, -0.04733064f, 0.00906013f, -0.02096924f, 
    0.04719514f, -0.02527864f, -0.00981434f, 0.06490210f, -0.05245907f, -0.07672883f, -0.07505102f, 0.01074788f, 
    0.06122177f, -0.07582110f, -0.03414821f, 0.07793696f, -0.05942641f, -0.00606383f, -0.01652883f, 0.01757534f, 
    0.03285297f, -0.05840044f, -0.04302954f, -0.07595673f, -0.03756745f, -0.02686277f, 0.04858842f, -0.01302458f, 
    -0.03424418f, -0.09375689f, -0.01558707f, 0.05241921f, -0.08818021f, 0.01751984f, -0.00762904f, 0.02632562f, 
    -0.06087174f, 0.05100523f, -0.01974949f, -0.10089047f, -0.08363865f, -0.06214302f, 0.03616269f, -0.07933932f, 
    0.01281068f, -0.09420780f, -0.00442647f, 0.05342804f, -0.06660134f, -0.00454855f, 0.00717887f, 0.05177690f, 
    -0.09615753f, 0.02359435f, 0.00189523f, 0.02008055f, -0.05215340f, 0.05913899f, -0.05973255f, -0.04406578f, 
    0.01405459f, -0.04857597f, -0.06942222f, 0.04570206f, 0.06012431f, 0.01945189f, -0.01187470f, -0.01870619f, 
    0.02380472f, -0.07786493f, 0.04247363f, -0.10405394f, -0.02999750f, 0.05820903f, 0.05866218f, -0.02592934f, 
    -0.09060275f, -0.00759112f, 0.01435192f, 0.02177273f, -0.01870362f, 0.15484171f, 0.01460252f, 0.11907269f, 
    0.11086371f, -0.20807572f, 0.06512361f, 0.11472906f, 0.02727324f, 0.15024766f, 0.00268997f, 0.06302596f, 
    0.09343234f, 0.08156972f, -0.33247191f, -0.14835034f, 0.16862454f, -0.06367359f, 0.19818792f, -0.10886685f, 
    -0.01397323f, -0.08594695f, -0.03957672f, 0.03906133f, -0.10706776f, 0.04028374f, -0.07536386f, -0.26430088f, 
    -0.07561285f, -0.12747556f, 0.02124693f, -0.04033605f, 0.32599756f, 0.10496099f, 0.04211102f, -0.11561763f, 
    -0.07256221f, -0.03124086f, -0.06752677f, 0.01833505f, 0.11295655f, -0.05402079f, -0.02708395f, 0.07938956f, 
    -0.21991800f, 0.08828751f, 0.03553566f, -0.07393188f, 0.06584116f, -0.02901595f, -0.08373965f, -0.15903348f, 
    0.03417150f, 0.05706587f, 0.15055504f, 0.07605269f, -0.02042653f, 0.01612551f, -0.27590990f, 0.30182898f, 
    -0.02475543f, 0.04201262f, -0.05473591f, -0.02552944f, -0.08395731f, 0.04267666f, -0.13794398f, 0.12049732f, 
    -0.00351489f, 0.10961080f, 0.01307707f, 0.07019681f, 0.09237155f, 0.11641297f, -0.12791158f, 0.09314670f, 
    -0.14666136f, 0.33294904f, 0.03926104f, -0.14785561f, -0.08105281f, -0.06349593f, 0.01865621f, -0.12565784f, 
    0.01538159f, -0.05058431f, 0.34703910f, 0.07682338f, -0.05212047f, -0.21042915f, -0.17698763f, -0.03988454f, 
    0.00718062f, -0.09369583f, -0.18248698f, -0.31682438f, 0.15120079f, -0.35943669f, -0.08633500f, 0.06946637f, 
    -0.04528224f, -0.03032626f, 0.03418944f, 0.06375163f, 0.19242083f, 0.01605115f, 0.06132653f, 0.15480518f, 
    0.10951259f, -0.06174471f, 0.14361003f, -0.01696298f, -0.13696915f, 0.23144573f, -0.13659416f, -0.03165539f, 
    0.16690148f, 0.03615550f, -0.18288547f, 0.11686732f, -0.07894993f, 0.01417886f, 0.11831325f, -0.13350491f, 
    -0.15516636f, -0.21252891f, 0.19611926f, 0.14524017f, 0.09359169f, 0.05259728f, 0.00627407f, 0.32675010f, 
    -0.26335537f, 0.06993622f, 0.22164279f, 0.06907394f, -0.04320117f, -0.17005789f, 0.00666239f, -0.18926288f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.03543962f, 0.16740020f, 0.04391979f, 0.04225510f, -0.03370329f, 0.00456517f, 0.10311282f, 0.14591788f, 
    0.08466931f, 0.19698814f, -0.03882482f, -0.29515815f, 0.20846686f, 0.05250702f, 0.04404702f, -0.09181980f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.12803137f, -0.22758612f, 0.02942431f, -0.24140221f, -0.19176632f, -0.02078408f, 0.15899262f, -0.17430842f, 
    -0.11214468f, -0.16209301f, -0.07213831f, -0.17602873f, 0.04348904f, -0.14528170f, 0.18203586f, -0.04872799f, 
    -0.23863661f, 0.01583067f, -0.02902000f, 0.17177522f, 0.21288174f, 0.16845202f, -0.14663829f, 0.31107247f, 
    -0.00664931f, -0.00024124f, -0.14497155f, -0.43913326f, 0.02990065f, 0.24559246f, -0.16734913f, 0.25354624f, 
    0.10847568f, -0.16606876f, -0.03052670f, 0.10921291f, 0.14636269f, 0.17037904f, 0.45926318f, -0.11346029f, 
    -0.00393302f, 0.52251393f, 0.05123845f, 0.49737534f, -0.40047327f, 0.12284055f, -0.24549799f, -0.15540078f, 
    0.19310559f, 0.13824524f, 0.11043251f, 0.04987271f, 0.23733245f, 0.08510872f, 0.31835583f, -0.03701355f, 
    0.40430608f, 0.19134918f, -0.07457490f, 0.14506097f, -0.32705802f, 0.08968527f, 0.23273049f, -0.54216844f, 
    0.15679553f, 0.33434832f, 0.02645682f, 0.02412707f, -0.14085302f, -0.20961113f, -0.04364751f, 0.43076450f, 
    0.32402262f, 0.48788464f, 0.28457192f, -0.38806686f, -0.20541565f, -0.30794311f, -0.12095542f, -0.46515033f, 
    -0.20970757f, -0.00877544f, -0.14505151f, -0.08307000f, 0.14992456f, 0.23873681f, 0.44556895f, 0.21975538f, 
    0.08923560f, 0.32535499f, -0.31148109f, -0.22260605f, -0.31410208f, -0.13132870f, 0.04154624f, -0.40878248f, 
    0.12483559f, 0.69361657f, -0.06676468f, -0.17726141f, -0.00199700f, -0.08186599f, -0.34174076f, -0.35698789f, 
    0.28376973f, 0.26668009f, -0.08226689f, -0.17890006f, 0.21398909f, 0.12086297f, -0.04104206f, 0.03629616f, 
    -0.13196857f, -0.22632653f, 0.13671166f, 0.21516080f, -0.18837166f, 0.41870365f, -0.33080500f, 0.04422225f, 
    0.02456575f, -0.30459070f, 0.26653379f, 0.18657823f, 0.06561369f, 0.12872386f, 0.11435765f, -0.08144543f, 
    -0.19163591f, -0.29902202f, -0.00487328f, 0.11919291f, -0.23234694f, 0.17720892f, 0.14380959f, -0.55705059f, 
    0.44171676f, 0.35564667f, -0.45693883f, -0.41529405f, 0.21408172f, 0.09152035f, -0.07200022f, -0.38022536f, 
    -0.00492942f, -0.17825279f, -0.17377254f, -0.14498460f, 0.23145518f, 0.36676702f, 0.09603015f, -0.29927993f, 
    0.20163651f, -0.53830487f, -0.11077873f, 0.11587206f, -0.00013790f, 0.04248046f, -0.25535920f, 0.17167488f, 
    0.24376155f, -0.41454071f, 0.02811277f, -0.04173285f, 0.17637233f, -0.01725979f, -0.52015603f, -0.13881660f, 
    0.07311304f, 0.48866507f, 0.11318015f, 0.33410519f, 0.42593321f, 0.25254208f, -0.20596379f, 0.24345633f, 
    -0.00547704f, -0.30554256f, -0.21940942f, -0.04029319f, -0.09760602f, 0.04497350f, -0.23896179f, -0.10637803f, 
    -0.12353671f, 0.07413505f, 0.25306523f, -0.37464020f, 0.23204327f, 0.49981445f, 0.03116011f, 0.25315082f, 
    0.02138752f, 0.18627155f, 0.23842460f, 0.14842196f, 0.18768461f, 0.26811245f, 0.10877907f, 0.12672029f, 
    -0.07837339f, -0.17743868f, 0.08556099f, 0.28858766f, 0.32090417f, -0.41528746f, 0.04722702f, -0.14321540f, 
    -0.12693311f, -0.14769396f, -0.01899493f, 0.10142592f, 0.17006484f, -0.36804661f, 0.23231177f, 0.27716112f, 
    0.10221675f, -0.01549995f, 0.45967615f, -0.69195145f, 0.18869723f, -0.34720477f, 0.06103854f, 0.37791002f, 
    -0.14213881f, 0.18152362f, -0.14848062f, -0.09002031f, 0.02907732f, 0.30232620f, 0.12764004f, -0.35555488f, 
    -0.03752607f, 0.24642676f, 0.09221690f, 0.26871791f, -0.12347852f, 0.10023135f, 0.16974732f, -0.31971517f, 
    -0.06080541f, 0.43137136f, -0.17801562f, 0.06504958f, 0.12079250f, -0.27268600f, -0.13600139f, -0.43242225f, 
    0.26031408f, 0.47851539f, -0.10953567f, 0.01269263f, 0.06198882f, 0.26612520f, 0.04179408f, 0.19182967f, 
    -0.20885311f, 0.03326259f, -0.15766570f, -0.17164792f, -0.22757490f, 0.00453059f, 0.31107709f, 0.32083923f, 
    0.21985614f, 0.18380982f, -0.25618571f, -0.12254877f, -0.18497552f, 0.02105998f, -0.19552340f, 0.14965497f, 
    -0.02303769f, 0.01763209f, 0.04010873f, 0.14351124f, 0.04510144f, 0.38033661f, -0.21632197f, 0.21219121f, 
    -0.32878873f, -0.20072372f, -0.34166175f, 0.15046871f, 0.24635157f, 0.49676394f, -0.18842366f, 0.23827744f, 
    -0.13474125f, -0.30779520f, -0.09205573f, -0.11218667f, 0.00014685f, 0.11502023f, 0.28525802f, 0.13193452f, 
    -0.15295619f, 0.43976814f, -0.30142826f, -0.28899637f, 0.38060486f, 0.42073393f, 0.09221779f, 0.28115535f, 
    -0.02683396f, -0.05649047f, 0.13655522f, -0.15223801f, 0.11646917f, -0.12371727f, 0.08391892f, -0.21246779f, 
    -0.18411916f, 0.38320372f, 0.37821630f, 0.36057973f, 0.17097832f, -0.38163257f, -0.04498550f, -0.26355332f, 
    -0.01133972f, -0.35226488f, 0.04770368f, 0.08105040f, -0.09662779f, -0.27862176f, 0.10484117f, -0.04244603f, 
    0.14942457f, 0.49492276f, 0.53242302f, 0.07340082f, 0.07256697f, 0.17376909f, -0.13552496f, -0.10964268f, 
    0.15441281f, -0.05950000f, -0.05953625f, -0.10639041f, -0.15154305f, 0.13173597f, 0.49804881f, 0.17141046f, 
    0.28270480f, 0.10185373f, -0.20599629f, 0.20817046f, -0.16368902f, 0.00835466f, -0.01022131f, -0.11936620f, 
    -0.20731536f, 0.60664964f, -0.20103268f, -0.12180702f, -0.03886390f, -0.27546549f, 0.14520752f, -0.08443873f, 
    0.42545626f, 0.38888568f, -0.02187576f, 0.31705433f, -0.09731442f, -0.43657267f, 0.11024985f, -0.03033540f, 
    0.12868303f, -0.02012334f, 0.10861474f, -0.22059008f, 0.11752799f, -0.49375233f, 0.52964425f, -0.08001690f, 
    0.22846602f, -0.14609522f, 0.23232408f, -0.10431322f, 0.05088014f, 0.05029134f, 0.23084323f, 0.20829533f, 
    0.13337304f, -0.09318795f, 0.00611246f, 0.09857214f, 0.23360531f, -0.03495772f, 0.47722259f, 0.47770721f, 
    0.25209624f, -0.13679332f, 0.09670696f, -0.01084904f, -0.27589372f, -0.20002893f, 0.10567028f, -0.38001069f, 
    -0.22869527f, -0.28436747f, -0.18229091f, 0.21990567f, -0.15066387f, 0.14928304f, 0.15622048f, 0.17323942f, 
    -0.00008556f, 0.24397841f, -0.22486290f, -0.40975082f, 0.36200801f, 0.55358869f, -0.01984194f, 0.24108776f, 
    0.23559150f, -0.35441062f, 0.15352234f, 0.02097275f, 0.16057247f, 0.24140488f, 0.00111561f, 0.44547710f, 
    -0.10677411f, 0.39532593f, 0.15800919f, -0.14524817f, -0.51557630f, -0.05549361f, 0.02405861f, 0.47269940f, 
    0.14467146f, 0.18449080f, -0.23968011f, -0.03056846f, -0.01681174f, -0.00643410f, 0.30113375f, 0.43722710f, 
    -0.32949650f, 0.06923132f, -0.08675957f, 0.18421394f, 0.42962772f, -0.21086287f, 0.19213325f, -0.03278613f, 
    -0.06712684f, 0.29643536f, -0.15755464f, -0.06925312f, -0.02776703f, 0.00596278f, 0.13555703f, 0.12425488f, 
    0.18296972f, 0.15105432f, -0.06088080f, 0.09709916f, 0.02701452f, -0.35489798f, 0.11965665f, -0.41886210f, 
    -0.14079738f, 0.18299998f, 0.06409830f, -0.17867951f, 0.13187245f, 0.23632905f, -0.01546934f, -0.23424964f, 
    -0.23386034f, -0.05263938f, 0.21643563f, 0.37611082f, 0.18865307f, 0.21261348f, 0.07480858f, -0.04259109f, 
    -0.24107729f, 0.08769315f, 0.22563766f, 0.23330130f, 0.14208899f, -0.15474838f, -0.35976011f, 0.43947956f, 
    0.31661332f, 0.05351625f, -0.13008282f, -0.50148684f, 0.40387562f, -0.20076329f, 0.07734694f, 0.31742993f, 
    -0.13958381f, 0.16377762f, 0.07009768f, 0.08964334f, -0.26508760f, 0.23244517f, 0.11995181f, -0.06455370f, 
    -0.19623160f, -0.34731498f, 0.27617928f, 0.31166503f, 0.25902557f, -0.04965174f, 0.03668499f, 0.04287588f, 
    0.10135948f, 0.22841254f, -0.03021928f, 0.00758895f, 0.14065813f, -0.02257409f, -0.09592559f, 0.09146021f, 
    0.34573659f, -0.58035201f, 0.01492708f, -0.00763796f, 0.43354681f, -0.13382538f, 0.20297182f, 0.24040654f, 
    -0.25365174f, -0.20272674f, 0.20277533f, -0.22616120f, -0.05236727f, 0.34564784f, -0.11424080f, -0.02417255f, 
    0.27802438f, -0.63557565f, 0.25691485f, 0.62335658f, -0.21420965f, 0.21401638f, 0.15378396f, -0.27532533f, 
    -0.10572207f, -0.08960409f, 0.02870501f, -0.08344687f, 0.11347374f, -0.06113239f, -0.13565284f, 0.08937855f, 
    0.38262787f, -0.05399716f, 0.33624285f, -0.20210807f, 0.02221510f, 0.25433898f, -0.19393131f, -0.04126469f, 
    0.22487438f, -0.19692011f, -0.12539732f, -0.06452182f, -0.10810637f, -0.25990030f, 0.04161678f, 0.19531569f, 
    -0.11726149f, -0.25775045f, 0.20418105f, 0.14282809f, -0.16182625f, -0.14398769f, 0.20715111f, -0.05027550f, 
    -0.16960086f, 0.20605390f, -0.04968075f, 0.15425090f, -0.21648446f, 0.04015838f, 0.12829527f, -0.04506509f, 
    0.20863037f, 0.42780212f, -0.33868763f, 0.50344920f, -0.45561108f, -0.29467604f, 0.10212202f, 0.11455724f, 
    0.17964463f, 0.04116590f, -0.24083854f, -0.12356490f, 0.15598717f, -0.13968222f, -0.28092176f, 0.39610326f, 
    0.17662629f, 0.29018876f, -0.23194753f, -0.06052800f, -0.17940708f, 0.63448811f, 0.21118045f, 0.12742810f, 
    0.03866743f, 0.18648553f, -0.09424254f, 0.09413297f, -0.10685521f, -0.12670283f, 0.37411472f, 0.32790920f, 
    0.02390471f, -0.18379752f, -0.19773814f, -0.23981598f, 0.29219255f, -0.28830713f, 0.20860152f, 0.22345015f, 
    0.15842435f, -0.06128942f, 0.03332415f, 0.00673705f, -0.05316162f, -0.23335621f, -0.11983246f, -0.23185334f, 
    -0.04785201f, 0.02740995f, -0.04524200f, -0.24630974f, -0.18617521f, -0.14461043f, 0.03276333f, 0.15607397f, 
    -0.23282708f, -0.19628379f, -0.20639503f, -0.15268973f, -0.17365903f, -0.28064412f, -0.13717631f, -0.25282162f, 
    -0.19426736f, -0.28648552f, 0.19795838f, 0.20261560f, 0.13314489f, -0.13454705f, -0.16529825f, -0.15220083f, 
    -0.18882129f, 0.36549067f, 0.10001915f, -0.20510475f, -0.09547064f, 0.28565177f, 0.23056372f, 0.17063308f, 
    0.10438596f, -0.16988225f, -0.28687784f, 0.07190356f, 0.11536310f, -0.33562198f, 0.07543610f, -0.17971626f, 
    -0.17863138f, -0.09155536f, 0.11465989f, 0.05889953f, 0.05976626f, 0.15952884f, 0.00054742f, 0.33158764f, 
    0.25083062f, 0.18894881f, 0.50254291f, -0.23979591f, -0.26877734f, -0.36269048f, 0.21332461f, -0.09785260f, 
    -0.20608096f, 0.41475269f, 0.14549471f, -0.14001143f, -0.09302985f, 0.14047875f, -0.53683436f, -0.16466746f, 
    -0.05539107f, 0.19223994f, 0.38821563f, 0.14291221f, 0.29925719f, -0.17942861f, -0.14238821f, -0.05617265f, 
    0.09204566f, -0.17214581f, -0.03429076f, -0.22785808f, 0.17133693f, 0.25499752f, -0.00857737f, -0.40257242f, 
    0.51255488f, -0.28759176f, -0.05630969f, 0.01006012f, -0.02731771f, 0.11233528f, -0.05184118f, -0.29539007f, 
    0.01429793f, 0.12561832f, -0.10846689f, -0.00932131f, 0.04318431f, -0.22471201f, 0.05365988f, 0.18515296f, 
    -0.22892039f, -0.12542155f, 0.38892207f, -0.42543343f, 0.49058276f, 0.46658027f, -0.11326552f, 0.05337858f, 
    0.14021184f, -0.15631004f, -0.16027428f, -0.19638212f, 0.14533126f, 0.35415322f, 0.00111080f, -0.05416617f, 
    0.17792808f, -0.42377180f, -0.29199514f, -0.19858810f, 0.45861691f, 0.39080399f, -0.05299689f, 0.50276017f, 
    -0.03112781f, 0.12977569f, -0.02781281f, 0.12587464f, -0.14242303f, -0.19938445f, 0.48923346f, 0.09758084f, 
    0.25255483f, 0.20461492f, 0.04390251f, -0.17342891f, 0.16746503f, 0.28019387f, 0.22469974f, -0.25409678f, 
    0.16642192f, -0.26334274f, -0.09788431f, 0.03209236f, 0.10626800f, 0.26479512f, 0.32027757f, 0.49242213f, 
    -0.09672275f, 0.43390444f, -0.35299253f, -0.13670351f, -0.24181539f, 0.03392487f, -0.04063210f, 0.07263694f, 
    -0.17745683f, 0.04441373f, -0.22722498f, -0.07241271f, -0.07764306f, -0.28976479f, -0.20320554f, 0.39212817f, 
    -0.10773136f, -0.14922740f, 0.38992953f, -0.09219021f, 0.17572327f, 0.39385056f, 0.21883218f, 0.44338405f, 
    -0.01606941f, -0.21130694f, 0.03604559f, -0.00567345f, -0.10852988f, 0.30804017f, -0.17910735f, -0.49379376f, 
    0.01133110f, 0.24908312f, 0.37716153f, 0.18579991f, -0.25767192f, 0.47266799f, -0.02788525f, 0.25488916f, 
    -0.15345259f, 0.07970132f, -0.20743546f, 0.07591502f, 0.16942759f, -0.05267908f, -0.32029796f, 0.29673123f, 
    0.19000582f, 0.36366653f, -0.10560043f, -0.18475692f, -0.08739765f, 0.51949090f, 0.27259704f, -0.03133010f, 
    -0.19003409f, 0.17419147f, -0.12360062f, 0.15658163f, 0.05508590f, 0.15218958f, -0.41763499f, 0.34781116f, 
    -0.47632337f, 0.18984614f, 0.37259465f, 0.19601153f, -0.38017133f, 0.34239230f, -0.17898382f, -0.03136842f, 
    0.01781698f, -0.22289987f, -0.03915435f, 0.20344259f, 0.01825541f, 0.27797934f, 0.45055136f, -0.33640587f, 
    0.30222091f, 0.17097564f, 0.11011444f, -0.09354357f, -0.27813643f, -0.11697521f, -0.00401464f, 0.37064892f, 
    -0.09780100f, 0.16390629f, -0.20151895f, 0.10162523f, -0.24393836f, 0.24662271f, 0.44499695f, -0.51713526f, 
    -0.30718124f, -0.42689580f, 0.08933683f, -0.00923740f, -0.33911261f, 0.11176587f, 0.18557282f, -0.50868231f, 
    0.20720588f, -0.27372339f, -0.19848642f, -0.21635637f, -0.21725304f, -0.10576695f, -0.35132477f, 0.21235706f, 
    0.35445648f, 0.14635168f, 0.14127198f, -0.10310157f, 0.22897324f, 0.55019623f, 0.03316051f, 0.07338268f, 
    0.22397068f, 0.08743875f, 0.10672462f, -0.11638770f, 0.24528778f, -0.10295320f, -0.24370307f, -0.18901964f, 
    0.04582496f, -0.23726897f, -0.00792163f, -0.11614225f, 0.09598463f, -0.15468659f, -0.00584418f, -0.12021314f, 
    0.13561486f, -0.34554756f, 0.18569973f, -0.17191866f, 0.08386233f, 0.04995860f, -0.02844170f, 0.50816256f, 
    0.27527970f, -0.53399032f, -0.51846689f, 0.07922355f, 0.05750256f, -0.22089791f, -0.15549955f, 0.66056770f, 
    0.21341488f, -0.06595384f, -0.01247828f, -0.13635685f, -0.16553587f, 0.18751268f, 0.27416173f, 0.10354459f, 
    -0.36169660f, 0.14777735f, 0.13399440f, 0.05096165f, 0.28864965f, -0.38770527f, 0.00470845f, 0.31841063f, 
    0.02166312f, -0.34621525f, 0.13204308f, 0.00831713f, 0.03081073f, 0.25314218f, -0.14115061f, -0.35844296f, 
    0.43066245f, -0.08940551f, -0.04226152f, -0.28512913f, 0.23099452f, 0.14076735f, -0.03558872f, 0.35331947f, 
    0.02705821f, 0.38360742f, 0.06152920f, -0.06339419f, -0.00987376f, 0.28757805f, 0.18422361f, -0.44607088f, 
    -0.05579059f, 0.40908331f, 0.27749738f, 0.48434356f, -0.28106356f, -0.31665388f, 0.13342306f, -0.07243551f, 
    -0.07240628f, -0.04709905f, 0.13629615f, 0.19300145f, -0.09808861f, -0.07643471f, 0.39087322f, -0.18341325f, 
    0.44044280f, -0.38614294f, -0.02030036f, 0.30937183f, -0.04597601f, 0.21488498f, -0.04757468f, -0.46146724f, 
    0.13461767f, 0.31537580f, -0.07189535f, 0.03801036f, -0.04653963f, -0.14150877f, -0.09641885f, 0.26403564f, 
    -0.44933519f, 0.30559731f, 0.47251317f, -0.11431797f, 0.43247378f, 0.34355432f, -0.17012408f, -0.23017177f, 
    0.03112307f, 0.21973653f, -0.10899366f, -0.15497543f, 0.07377421f, 0.08658422f, -0.01454134f, 0.53466129f, 
    -0.17057788f, 0.14032821f, -0.23595378f, 0.08857539f, 0.30998880f, -0.06960263f, -0.17043906f, -0.45671901f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.20304537f, 0.46549541f, 0.03949571f, 0.19609857f, -0.00900556f, 0.10315708f, -0.07314211f, 0.20600925f, 
    0.46441483f, 0.07656847f, -0.21577638f, 0.23075153f, 0.02278551f, -0.07136977f, -0.53314668f, 0.04948574f, 
    0.42412245f, 0.24541189f, 0.34943867f, 0.48386237f, -0.46977159f, -0.03179949f, -0.13826311f, -0.96351123f, 
    0.05574774f, 0.38247678f, 0.10921334f, 0.50237346f, 0.26556778f, -0.10745194f, 0.46459508f, 0.00310075f, 
    0.43150461f, -0.29641888f, -0.10859359f, -0.22851689f, 0.33321449f, -0.01660065f, 0.26880613f, 0.12849702f, 
    0.15499334f, 0.17540917f, 0.00016902f, -0.16560274f, 0.22376785f, 0.11516599f, 0.06568196f, 0.50650740f, 
    0.07503353f, -0.14833303f, 0.01495271f, -0.09122109f, -0.03416843f, -0.21959342f, -0.10082067f, 0.02091259f, 
    -0.07341043f, 0.10430811f, -0.10135851f, 0.37574068f, -0.11678839f, 0.37976921f, 0.09417515f, -0.12934163f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.03479478f, -0.00343235f, 0.01156539f, -0.13540275f, 0.00817957f, 0.11883093f, -0.06764075f, -0.05890770f, 
    -0.09590317f, -0.06099391f, 0.10755437f, -0.06160332f, -0.11870771f, 0.02485028f, 0.06475659f, -0.16432881f, 
    0.07981076f, -0.09479631f, 0.03989476f, 0.09903646f, -0.12502415f, 0.00621539f, -0.16587578f, -0.14258717f, 
    -0.03533870f, 0.06273139f, 0.03902522f, -0.00816596f, 0.02655193f, -0.00626105f, -0.01895488f, 0.09222139f, 
    -0.01189329f, 0.03003297f, 0.06513384f, 0.00709766f, -0.02302875f, -0.09551394f, -0.07526137f, 0.06322543f, 
    0.10025249f, -0.16215067f, -0.12759055f, -0.04382405f, 0.10154720f, -0.12111115f, -0.06669482f, -0.07746214f, 
    0.06899975f, 0.07324286f, -0.04744634f, 0.01225556f, 0.04199759f, -0.14677101f, -0.05590292f, 0.04319929f, 
    0.10180961f, 0.10435639f, -0.09620519f, -0.08736724f, -0.04768261f, -0.00980392f, -0.03869872f, 0.08109207f, 
    0.06568675f, 0.04798990f, 0.04583545f, -0.06017556f, 0.05577534f, -0.03860611f, 0.10953897f, 0.10313995f, 
    -0.00229150f, -0.10830791f, -0.06380689f, -0.09997625f, -0.08255095f, -0.04731038f, 0.02757507f, -0.03772454f, 
    -0.06393834f, 0.07491592f, -0.01974311f, -0.08704932f, 0.02829431f, 0.01181370f, -0.10421317f, -0.02037555f, 
    -0.01775187f, 0.03660353f, 0.07604986f, -0.13660979f, 0.07865336f, 0.10107298f, -0.12439632f, 0.04811883f, 
    -0.04129770f, -0.10541105f, 0.08196384f, 0.10465969f, -0.11481631f, -0.08976986f, -0.02938700f, -0.08599053f, 
    -0.11207390f, 0.11188035f, 0.01897761f, -0.09152728f, 0.06057635f, -0.06426159f, -0.13329105f, 0.01389079f, 
    -0.03200178f, -0.05470005f, 0.07313804f, -0.11401170f, -0.12620892f, -0.07777826f, 0.03102654f, -0.05806402f, 
    0.01778625f, -0.04086746f, -0.13162811f, -0.12509447f, -0.01510716f, -0.02264876f, 0.02589039f, 0.01013162f, 
    -0.04876179f, -0.06730276f, -0.08082672f, -0.14182781f, -0.18629482f, -0.08533996f, -0.06074179f, 0.12886718f, 
    -0.01723755f, -0.09440296f, 0.22460060f, 0.09989738f, 0.26562175f, 0.16611940f, 0.16260271f, 0.01738524f, 
    -0.12408569f, 0.09932147f, -0.04406675f, -0.26107109f, 0.09637228f, -0.01384443f, -0.16760913f, -0.17431957f, 
    -0.27705294f, 0.02291057f, -0.08840519f, 0.35658643f, 0.05604848f, 0.31755179f, -0.14170295f, 0.35189676f, 
    0.06451523f, 0.16941434f, -0.01002313f, 0.04233387f, -0.14101659f, -0.32218963f, 0.09188178f, -0.01391379f, 
    0.10225027f, 0.01785465f, 0.11933144f, 0.35532960f, -0.08665548f, 0.26644382f, 0.07785467f, 0.06927665f, 
    -0.03550997f, 0.05036983f, 0.08239917f, -0.23564912f, -0.20887865f, -0.19080886f, 0.88169789f, -0.18561578f, 
    0.03944074f, -0.50020403f, 0.29148772f, -0.08875924f, 0.26116645f, -0.06020232f, 0.44337764f, 0.20420219f, 
    0.08127742f, 0.07454272f, -0.10067234f, -0.08655445f, -0.10200923f, -0.03693364f, 0.00596096f, 0.00451927f, 
    -0.14406715f, -0.04684270f, 0.06946503f, -0.08783935f, -0.06255745f, -0.12214175f, -0.14356290f, -0.00200976f, 
    0.05645185f, -0.05073909f, -0.03890622f, 0.02024171f, -0.05826728f, 0.02136318f, 0.02216844f, -0.02132483f, 
    0.06990112f, 0.09050123f, -0.05407711f, 0.09189583f, 0.01438393f, -0.11717782f, -0.07978856f, 0.01653023f, 
    0.02383176f, -0.11161535f, -0.02307731f, 0.02665435f, -0.07064009f, 0.08782551f, -0.06629796f, 0.03655705f, 
    -0.09571986f, 0.03970177f, -0.00360896f, -0.05880840f, 0.01759569f, -0.01828762f, 0.04730875f, 0.05027715f, 
    0.01605998f, -0.08465938f, -0.03456779f, -0.00180414f, -0.04945017f, -0.05165359f, -0.02679753f, -0.06064750f, 
    0.04586151f, -0.10174519f, 0.05387846f, 0.01233998f, 0.09459803f, 0.01885909f, -0.09824633f, -0.01615868f, 
    -0.01872739f, -0.12508318f, 0.07377944f, -0.07468904f, -0.01387392f, 0.06144444f, -0.05465946f, 0.04094798f, 
    -0.07777504f, -0.01957483f, 0.04109499f, 0.08714928f, -0.07154415f, -0.10870292f, -0.12928727f, -0.10872392f, 
    0.08258639f, 0.09186574f, -0.03460893f, -0.09768952f, -0.09841557f, 0.10329185f, -0.11559957f, 0.06069627f, 
    -0.10724644f, 0.06933096f, -0.04186609f, -0.03103118f, -0.07729360f, 0.08681615f, 0.06797002f, -0.05379974f, 
    -0.15586193f, -0.04986311f, 0.08923312f, -0.09789771f, -0.13398604f, -0.09078551f, -0.14678670f, 0.00405410f, 
    -0.00017095f, 0.05155442f, -0.08067700f, -0.06757922f, -0.14256087f, -0.02334288f, -0.12822637f, -0.04186661f, 
    -0.01900141f, -0.03149669f, -0.02549096f, -0.01335692f, 0.01130706f, -0.06318942f, -0.08868654f, 0.07308377f, 
    0.10583344f, 0.04050889f, -0.00702263f, 0.01876936f, -0.08253854f, 0.08654458f, 0.01966464f, 0.10397854f, 
    -0.07851848f, -0.00969066f, 0.05564817f, 0.21938649f, 0.09512635f, 0.02789445f, -0.10817751f, 0.07061610f, 
    0.58890635f, 0.11187395f, 0.14140189f, -0.09235511f, 0.12792085f, 0.12867397f, 0.18193716f, -0.02688874f, 
    -0.07025148f, -0.36862493f, -0.24757223f, 0.14031839f, 0.70735317f, 0.00271638f, 0.17492850f, -0.19407354f, 
    0.11676416f, -0.10874548f, 0.02669720f, -0.12388818f, 0.14629818f, 0.10398321f, -0.00932145f, 0.13850367f, 
    0.04480529f, 0.45636338f, 0.20146950f, 0.06888143f, 0.11810697f, -0.17222938f, -0.28239247f, 0.02924259f, 
    -0.06647298f, 0.02486986f, 0.32764292f, 0.25890291f, 0.41985995f, -0.22713439f, -0.10783615f, 0.02582398f, 
    0.04158708f, -0.00514303f, 0.22763017f, 0.00774079f, 0.28875285f, 0.06381336f, 0.20470726f, 0.18107474f, 
    0.00873331f, -0.01043336f, -0.10132746f, 0.14541918f, 0.08195172f, 0.25302625f, -0.12730204f, -0.00093318f, 
    -0.11959857f, -0.11586668f, 0.01323726f, 0.01290756f, -0.07807011f, -0.36344948f, -0.07217578f, 0.03770535f, 
    0.01842971f, 0.08626907f, 0.14831963f, 0.06399101f, -0.14059137f, 0.02780312f, -0.03661900f, 0.09643857f, 
    -0.00332026f, -0.01785215f, -0.06648500f, -0.22965437f, 0.25189885f, 0.12160432f, 0.01619328f, 0.11369411f, 
    0.09650238f, -0.06406048f, 0.05266397f, -0.25407237f, -0.17200850f, 0.09770793f, -0.25854328f, -0.08094843f, 
    0.03819663f, 0.26930356f, 0.12470520f, -0.00012372f, 0.06584245f, 0.19588943f, -0.24444053f, -0.02920647f, 
    -0.10497575f, -0.27446970f, -0.07827423f, -0.09944141f, 0.20978995f, 0.03060241f, 0.13587338f, 0.00860233f, 
    -0.11021842f, 0.44426641f, 0.01153678f, 0.25067800f, 0.22329658f, 0.02960650f, -0.68546867f, 0.40107849f, 
    0.11035603f, -0.05596714f, -0.36692044f, 0.04361767f, -0.23236237f, 0.25708577f, -0.02366418f, -0.50899494f, 
    0.05864120f, -0.00648825f, 0.06721395f, 0.01764740f, -0.03921363f, 0.05407734f, -0.09870006f, 0.10511734f, 
    0.03977216f, -0.03557751f, 0.09998606f, 0.05849935f, 0.03700018f, -0.00340205f, -0.12049159f, -0.02594523f, 
    -0.02689599f, -0.05204567f, -0.13010164f, 0.02662358f, -0.02873906f, 0.04530068f, -0.11101475f, 0.02091193f, 
    0.07972295f, -0.10076445f, -0.07219844f, -0.02741041f, -0.03543826f, -0.13075240f, -0.11555973f, -0.07977624f, 
    -0.08523687f, 0.05576805f, -0.07254266f, 0.09617984f, -0.12564830f, -0.01462413f, -0.06069716f, -0.11720149f, 
    0.11999333f, -0.07015894f, 0.08242691f, 0.01226477f, -0.10425531f, -0.00272232f, 0.03285807f, 0.07736310f, 
    -0.12274450f, 0.04170497f, -0.13938479f, -0.11455133f, 0.11243728f, 0.07718028f, -0.09860381f, 0.03556003f, 
    0.00292175f, -0.00731548f, -0.04920959f, 0.09945650f, 0.01139348f, -0.10674518f, 0.00112218f, -0.01853820f, 
    0.10052802f, 0.10059770f, 0.27778754f, -0.00202484f, 0.35678646f, 0.01817315f, -0.08949683f, 0.24395970f, 
    -0.46817586f, -0.11965241f, 0.26604176f, 0.19012640f, -0.01229346f, -0.41461113f, 0.16856140f, -0.13469879f, 
    0.02275746f, 0.26152366f, -0.10128142f, 0.03945075f, 0.68177736f, -0.29383031f, -0.45810372f, 0.03531276f, 
    0.26725829f, -0.13478294f, 0.39767644f, -0.11257295f, -0.13397929f, 0.08534879f, -0.22865163f, 0.02759210f, 
    -0.24121989f, 0.06577814f, 0.06460068f, 0.01651664f, -0.00901556f, 0.15766901f, -0.39322835f, 0.09183451f, 
    0.10390233f, -0.08124425f, 0.14733671f, 0.12656173f, -0.04638588f, 0.07521795f, -0.18090503f, -0.24698357f, 
    -0.01120482f, -0.03639809f, 0.24538086f, 0.41215450f, 0.66306543f, -0.19616932f, 0.33944055f, 0.11649261f, 
    0.09810953f, -0.34013712f, 0.07586788f, -0.10404898f, 0.20700432f, -0.32965049f, 0.33467031f, 0.06779928f, 
    0.03934591f, -0.16236992f, 0.04790293f, 0.16975239f, 0.11671358f, 0.01748138f, -0.01424327f, 0.05812028f, 
    -0.66622418f, 0.08520286f, 0.24172792f, 0.18270862f, 0.21499607f, 0.03907287f, 0.10912844f, -0.01413803f, 
    -0.07820304f, 0.05415479f, -0.51785070f, 0.05479352f, -0.50250721f, 0.07034380f, 0.26564255f, -0.21287549f, 
    0.49043724f, -0.46941641f, -0.28787687f, 0.24982481f, 0.17293139f, 0.24535060f, -0.16967557f, 0.17225124f, 
    0.22048965f, 0.31169432f, -0.16578349f, 0.09061287f, 0.16713168f, 0.17969126f, 0.15655255f, 0.05847110f, 
    0.09712937f, 0.23807551f, 0.08338383f, 0.35278633f, -0.19727117f, -0.03970031f, -0.01775182f, -0.14048250f, 
    -0.39542696f, 0.37075430f, -0.09434929f, -0.18084180f, 0.27655160f, -0.05267507f, 0.33806264f, -0.27606055f, 
    0.10113838f, 0.20591840f, 0.17895147f, -0.38253656f, 0.16598497f, 0.02372908f, 0.09868532f, 0.03045721f, 
    -0.00242496f, -0.06836694f, -0.11073544f, 0.03628121f, -0.10812025f, 0.02950953f, 0.00649302f, -0.08308529f, 
    -0.02914588f, 0.09757099f, -0.11288362f, -0.08844846f, -0.14490496f, -0.06422870f, 0.08462042f, -0.07502433f, 
    -0.13815388f, -0.09631899f, -0.05553357f, -0.04547422f, 0.05911555f, -0.02465568f, 0.06007262f, 0.01622811f, 
    -0.01640064f, -0.01320948f, -0.02986678f, -0.00502145f, 0.00860843f, -0.02091382f, 0.06542468f, -0.12888369f, 
    -0.06406563f, -0.01612986f, -0.00763382f, -0.08629386f, -0.12724407f, 0.02399259f, -0.06655157f, 0.05901912f, 
    -0.04482779f, -0.09265704f, -0.06209618f, -0.05411079f, -0.05858178f, 0.05244260f, 0.06531595f, -0.00337877f, 
    -0.08925679f, -0.04646368f, 0.00506570f, -0.07197729f, 0.09126513f, 0.02936505f, -0.06042923f, 0.00029119f, 
    -0.08658196f, -0.04967226f, -0.05417687f, -0.05600023f, 0.02928294f, 0.03203333f, 0.08381482f, -0.00532525f, 
    0.10026814f, 0.15214978f, -0.16168012f, -0.09168296f, 0.15491967f, -0.26073581f, 0.43183944f, -0.08928479f, 
    0.23440999f, 0.08903211f, -0.41826123f, 0.36464122f, -0.02132305f, -0.32661963f, -0.09909549f, 0.37459558f, 
    0.13027754f, -0.41819665f, 0.30975917f, -0.04781469f, -0.34898654f, -0.15707521f, 0.20064303f, -0.61972028f, 
    -0.28807619f, 0.26753551f, -0.28351668f, 0.13624960f, 0.01561263f, -0.09126053f, 0.29573685f, 0.00326700f, 
    0.24995652f, -0.18540391f, -0.04665398f, -0.15254515f, -0.08053702f, -0.06197586f, 0.29899788f, -0.10445550f, 
    -0.08312095f, 0.09657105f, -0.23058176f, -0.11709378f, -0.11924132f, 0.23650703f, 0.09747753f, 0.28753555f, 
    -0.20805511f, 0.09855899f, -0.06479756f, -0.02283243f, -0.32957080f, 0.04446767f, -0.17218733f, -0.13860510f, 
    0.06485385f, -0.25791082f, 0.11774547f, 0.42138997f, 0.05955102f, 0.16644110f, 0.08937991f, -0.22259930f, 
    -0.08992624f, 0.22947672f, -0.28959769f, -0.33951354f, 0.03983860f, -0.27798483f, -0.12137193f, 0.21515088f, 
    -0.38333634f, 0.28620729f, 0.24418798f, 0.42285725f, -0.03479147f, -0.18268655f, -0.04199076f, -0.13766579f, 
    -0.21205366f, 0.58492488f, -0.02718019f, 0.30555293f, 0.06912595f, -0.23324546f, -0.69468254f, -0.97318739f, 
    0.30029184f, 0.12256045f, -0.02802515f, 0.02497410f, -0.20888503f, 0.17511795f, 0.09427935f, 0.26776293f, 
    0.15070495f, 0.27507311f, 0.05079708f, 0.00634474f, -0.59650022f, 0.06727147f, -0.15275143f, 0.01269696f, 
    0.06148231f, -0.06246753f, -0.11149945f, 0.36323342f, -0.02451332f, 0.46897683f, 0.21421252f, -0.31525812f, 
    -0.41320089f, 0.56326151f, 0.13308458f, 0.04959607f, 0.47190323f, -0.14552416f, 0.42267549f, 0.27663103f, 
    -0.00378640f, 0.42746639f, 0.06846289f, -0.00140044f, -0.20174938f, -0.22769114f, 0.27896211f, -0.09949144f, 
    0.02569354f, -0.13024797f, -0.15660800f, -0.12911317f, 0.20078258f, -0.47146094f, 0.16869459f, 0.18133736f, 
    -0.04848271f, -0.17258362f, 0.67731935f, 0.21957116f, 0.18898049f, 0.37508750f, 0.14643751f, 0.06226805f, 
    -0.15315713f, -0.14743054f, -0.26402417f, 0.19496167f, 0.30250904f, -0.23997582f, 0.02440234f, 0.08334345f, 
    -0.06574515f, -0.00548624f, -0.19180395f, 0.16430539f, 0.05412808f, 0.24726522f, -0.02307623f, 0.21717075f, 
    -0.00700078f, 0.14086178f, -0.03475459f, -0.05086900f, -0.13585542f, -0.19641711f, -0.06158433f, 0.09887445f, 
    0.03845846f, 0.06335866f, 0.09078071f, 0.46780831f, -0.01316426f, 0.13497756f, -0.11643068f, -0.20244068f, 
    -0.50912738f, 0.32291973f, 0.29410741f, 0.09675105f, -0.05764210f, -0.23251395f, 0.21984328f, 0.12094548f, 
    0.13546832f, -0.11227628f, 0.01325512f, -0.08836019f, 0.05390386f, -0.13856803f, 0.35016325f, -0.02784367f, 
    -0.10160226f, -0.07810138f, 0.18513925f, 0.03701223f, -0.75968552f, 0.23322006f, -0.26552784f, 0.20911303f, 
    0.17061700f, 0.11243279f, 0.12089184f, 0.22365747f, 0.20855048f, -0.47229782f, 0.17674935f, -0.13562007f, 
    -0.17155284f, 0.38839319f, 0.23808025f, 0.03672031f, -0.24207860f, -0.02492979f, -0.27265102f, -0.91544598f, 
    -0.26988235f, 0.20866239f, -0.13841400f, 0.34842756f, -0.02150008f, 0.36132476f, -0.44659054f, 0.13945949f, 
    -0.13472717f, 0.10578194f, -0.18409227f, 0.11873763f, -0.07468568f, -0.20771009f, -0.16790409f, 0.04043996f, 
    -0.02532562f, 0.15047795f, -0.24508886f, 0.15588620f, -0.17191222f, 0.13605708f, 0.04579393f, 0.11483952f, 
    0.10200106f, -0.39806488f, 0.17519580f, -0.24208559f, -0.28238425f, -0.04718452f, 0.29101336f, -0.20206054f, 
    -0.03852725f, -0.31786889f, 0.28186801f, -0.13899557f, 0.21068877f, 0.00044739f, 0.29383829f, 0.35817471f, 
    0.09538203f, 0.03896440f, -0.15354836f, 0.02114563f, -0.03076094f, 0.09383757f, 0.03125461f, -0.04763987f, 
    -0.07784159f, -0.05009608f, -0.12697299f, -0.11101919f, -0.12696710f, -0.11410439f, -0.02545810f, 0.07874524f, 
    -0.12161830f, -0.12940064f, -0.09217685f, -0.00211053f, 0.02180489f, 0.08595698f, 0.08174835f, 0.04118716f, 
    -0.08199526f, -0.12989627f, 0.01815767f, 0.02568836f, -0.09224574f, 0.09368912f, 0.02128813f, -0.04859957f, 
    -0.12181711f, 0.08760405f, 0.01407915f, -0.04208459f, -0.08379193f, 0.01280492f, 0.06681027f, 0.09280783f, 
    -0.12249571f, 0.08365309f, -0.07311185f, -0.02470092f, 0.03709497f, -0.11547206f, -0.04922711f, 0.00451829f, 
    -0.10706595f, 0.00136794f, -0.08251718f, 0.08476916f, -0.06091836f, 0.08965212f, -0.07095037f, -0.01078146f, 
    -0.07079196f, -0.02586042f, 0.02386855f, -0.06326170f, -0.00317477f, 0.09113825f, 0.03673932f, -0.04180867f, 
    0.00557670f, -0.05708764f, 0.07570326f, 0.21753284f, 0.50329131f, 0.22978428f, -0.04694407f, -0.02497877f, 
    0.04245766f, -0.73039228f, 0.00314426f, 0.01088617f, -0.04173053f, -0.11845222f, 0.07206699f, 0.02939179f, 
    -0.08675062f, -0.23626344f, 0.03094566f, 0.28335720f, 0.35753378f, -0.00729208f, 0.07220514f, 0.03264595f, 
    0.25843653f, 0.03045417f, -0.11224898f, 0.30324805f, 0.16798961f, 0.00929468f, -0.02340916f, -0.14301363f, 
    -0.13669497f, -0.34128231f, 0.08157051f, 0.06967225f, 0.13075422f, 0.16972993f, 0.00399453f, -0.12358217f, 
    0.13123930f, 0.09939218f, 0.17725769f, 0.03523259f, -0.26930565f, 0.51115757f, -0.16697536f, 0.16694073f, 
    -0.04217788f, 0.17302454f, -0.17837417f, 0.22629623f, 0.11691941f, -0.25025681f, -0.27647772f, 0.02016516f, 
    0.06027630f, -0.47812808f, -0.07894861f, -0.30825302f, -0.09669124f, 0.08090057f, 0.36306459f, 0.42208019f, 
    -0.11884639f, -0.47820228f, 0.02176878f, 0.13102300f, 0.26431260f, -0.04134388f, 0.16337708f, -0.11779767f, 
    0.23270835f, -0.25754449f, 0.41227475f, -0.84949756f, 0.13037765f, 0.18177485f, 0.00641136f, 0.16291355f, 
    -0.26214087f, 0.18654637f, -0.94541067f, 0.30472371f, 0.15387629f, -0.13607427f, 0.34478667f, 0.24291769f, 
    0.07779984f, -1.29590952f, -0.07266274f, 0.05692922f, 0.06334413f, 0.14076522f, -0.11938701f, 0.06761458f, 
    -0.04297875f, 0.17825499f, -0.45268694f, -0.05456721f, 0.53276223f, -0.62574548f, -0.21860540f, -0.06666678f, 
    0.04248603f, 0.05809265f, -0.24979115f, 0.23972744f, -0.29254887f, -0.41839433f, -0.24600638f, -0.34626833f, 
    -0.27530450f, 0.16135268f, -0.14190428f, -0.22888769f, 0.04809049f, -0.30064365f, -0.29219779f, -0.11824944f, 
    -0.03491283f, -0.12446105f, -0.01472791f, -0.60173315f, 0.24320073f, -0.13778383f, -0.09206238f, 0.31834668f, 
    0.00887997f, 0.05722323f, -0.15697972f, -0.08072250f, 0.04686747f, 0.04436257f, 0.07673838f, -0.07924276f, 
    0.03676338f, 0.07585454f, 0.02797676f, -0.00813844f, -0.05000933f, -0.03150987f, 0.04550532f, 0.00846744f, 
    0.04915606f, -0.05043355f, -0.13967043f, -0.00287411f, 0.18453881f, -0.01761847f, 0.08957601f, 0.00720788f, 
    -0.08820599f, -0.05132652f, -0.05281167f, -0.07685720f, -0.03323632f, -0.03321332f, -0.05389768f, 0.02751997f, 
    -0.08925695f, -0.05837072f, -0.06570943f, 0.00670245f, -0.10725907f, 0.10847580f, 0.06248192f, -0.10359932f, 
    0.06751059f, -0.14144425f, -0.08887947f, -0.00972534f, -0.01385094f, 0.05011602f, -0.05207096f, 0.09493590f, 
    -0.14136972f, -0.10504045f, 0.00195028f, 0.08596358f, -0.06770795f, -0.12050463f, -0.09952107f, 0.04324853f, 
    0.05186740f, -0.07635320f, -0.11774611f, -0.05117238f, -0.00620973f, -0.05896575f, -0.06977833f, 0.04150605f, 
    0.08171900f, 0.08469126f, -0.01598576f, 0.10612131f, -0.04803683f, 0.01696943f, 0.01946473f, -0.13946430f, 
    -0.06586893f, -0.04092492f, -0.16794209f, -0.04458788f, 0.00157743f, 0.04901313f, -0.01767366f, 0.07613347f, 
    -0.04031346f, 0.03217083f, 0.03400466f, 0.03641066f, -0.01449507f, 0.07500901f, 0.05659217f, -0.11743395f, 
    -0.11743633f, 0.05315039f, -0.10512868f, 0.00443256f, -0.02184668f, 0.02973621f, -0.13273214f, -0.07480238f, 
    -0.09266053f, -0.12769786f, -0.02407737f, 0.07420936f, 0.07238502f, -0.15121186f, 0.04214224f, 0.05677024f, 
    0.05110253f, -0.04530909f, -0.07494973f, -0.03380810f, -0.08022744f, -0.21180044f, -0.13310646f, -0.01615288f, 
    -0.04185753f, 0.00029171f, 0.02397623f, -0.12778944f, -0.09934635f, -0.11079364f, -0.08974651f, 0.04564397f, 
    -0.09528576f, 0.07305543f, -0.06239863f, -0.12513162f, 0.08506912f, -0.05520853f, -0.04594307f, -0.13982394f, 
    -0.07025157f, 0.13311686f, 0.07553402f, 0.01313756f, -0.49681181f, -0.06271598f, -0.25132549f, 0.15991698f, 
    -0.11325799f, 0.52974170f, 0.26143378f, 0.07119996f, 0.19807377f, 0.21794944f, 0.14877348f, -0.01071924f, 
    -0.09849005f, 0.29752496f, 0.08296655f, -0.10441512f, 0.12305796f, -0.00894324f, -0.28975099f, -0.05014944f, 
    -0.10484079f, 0.03857703f, 0.14264616f, 0.18780936f, -0.02962823f, 0.25472444f, 0.03052275f, 0.29683670f, 
    0.22835304f, 0.22547814f, -0.05588065f, 0.02669882f, 0.05149550f, -0.20099321f, 0.02657471f, 0.02723036f, 
    0.03787658f, 0.18391880f, -0.08046644f, 0.08512668f, 0.13658257f, -0.14664620f, 0.31384227f, -0.06779135f, 
    0.01034854f, 0.15504020f, 0.14099838f, -0.14870007f, -0.13501355f, 0.10442887f, 0.56726593f, -0.03254516f, 
    0.06030456f, 0.18530937f, 0.21440838f, 0.11751571f, 0.06013729f, 0.08147567f, -0.11863835f, -0.02531864f, 
    0.06104004f, 0.19020875f, 0.19774456f, 0.04797998f, -0.22827230f, -0.01473772f, -0.03026667f, 0.03565115f, 
    0.23209676f, 0.22230147f, -0.06564146f, 0.07168756f, -0.12391806f, -0.63221204f, -0.02968634f, -0.08640555f, 
    0.14930083f, -0.02685605f, 0.31017688f, -0.22923706f, -0.03209400f, 0.14897376f, -0.06716523f, -0.52384818f, 
    -0.43327853f, 0.19232082f, 0.18851463f, -0.10252057f, 0.05191687f, 0.11124773f, -0.21017541f, 0.12220407f, 
    -0.00578006f, 0.20912071f, 0.06457614f, -0.01282037f, -0.11181463f, -0.02671300f, -0.21187280f, 0.14309937f, 
    0.09313336f, 0.00258196f, 0.18568972f, -0.21449159f, 0.12430589f, -0.01106474f, 0.08255226f, 0.14070165f, 
    0.28619361f, 0.13817970f, 0.19527936f, 0.11947320f, -0.01137522f, 0.21587890f, -0.66606635f, -0.10005426f, 
    -0.05873340f, -0.66987574f, -0.03393627f, 0.19201018f, -0.01761984f, 0.15883517f, -0.01373750f, -0.26829562f, 
    0.09365599f, 0.27995402f, -0.20310463f, 0.03687939f, 0.36664459f, 0.18303342f, 0.15897214f, -0.07697296f, 
    0.35693657f, -0.27691582f, -0.34349447f, 0.13293073f, -0.18466796f, -0.12627503f, -0.42151779f, 0.14411718f, 
    0.12577459f, -0.28486371f, 0.13699432f, -0.48185626f, -0.64279938f, 0.09479357f, 0.16755272f, -0.60969740f, 
    0.08098377f, 0.22608851f, -0.04607657f, -0.01417081f, 0.01066091f, -0.55642086f, 0.45633987f, -0.38093275f, 
    0.22750519f, -0.14763407f, 0.14121951f, -0.00033421f, 0.12126039f, 0.63131708f, 0.27681273f, 0.04011089f, 
    0.00691198f, 0.13160723f, 0.04049383f, -0.42314857f, 0.07272895f, -0.13410562f, 0.07188868f, 0.15064056f, 
    0.09834933f, 0.08057909f, -0.33286032f, 0.38488507f, -0.00772667f, -0.03606314f, -1.13500869f, 0.28853315f, 
    0.04437735f, 0.18502879f, -0.22694935f, 0.07182781f, -0.36442167f, 0.01710014f, -0.52355546f, -0.06322868f, 
    0.04041110f, -0.07601676f, -0.03010589f, -0.10392326f, -0.10817741f, -0.08699999f, -0.00687878f, -0.05405445f, 
    -0.08544914f, 0.05615914f, -0.12929322f, 0.02945088f, -0.05827400f, 0.00584652f, -0.09699269f, 0.07263370f, 
    -0.08965042f, 0.05897820f, -0.12418902f, 0.06395595f, -0.00599413f, -0.13276048f, -0.08092941f, -0.07816492f, 
    0.10275295f, 0.06030023f, -0.03392224f, -0.11549599f, -0.01362985f, -0.16096656f, 0.03831564f, 0.00016867f, 
    0.03712947f, 0.02574794f, 0.03064055f, 0.04301904f, -0.08703434f, 0.04223995f, -0.03501955f, 0.00517355f, 
    0.02886836f, -0.10142794f, -0.05495468f, 0.00104426f, 0.07743115f, -0.02637148f, -0.11304751f, 0.03243284f, 
    0.06673968f, -0.02920828f, 0.04580848f, 0.06537377f, -0.16329116f, 0.04238299f, 0.09819195f, 0.05807063f, 
    -0.04352340f, -0.11464268f, 0.00663730f, 0.08141804f, -0.02958742f, -0.03351280f, -0.01683099f, 0.03394882f, 
    0.07378231f, 0.20301545f, -0.23384500f, -0.28917670f, 0.11589489f, -0.22069216f, -0.31293762f, 0.06860917f, 
    -0.58565539f, -0.22107400f, -0.10604208f, 0.24825202f, -0.02989001f, -0.03757082f, -0.29207587f, -0.03985448f, 
    0.08080015f, 0.28858683f, 0.30069342f, 0.45134503f, 0.19549654f, -0.11923584f, -0.09668908f, -0.04829967f, 
    0.09027661f, 0.26623091f, -0.14047202f, 0.36145148f, -0.12982048f, -0.03334593f, 0.23617339f, 0.12520163f, 
    0.20038748f, -0.18007895f, -0.00136018f, 0.08211501f, -0.30263647f, 0.23001610f, 0.20284347f, 0.09002737f, 
    0.03614347f, 0.01125030f, -0.02378583f, 0.04687605f, -0.25124219f, 0.41702503f, 0.05357419f, 0.19680527f, 
    0.00409273f, 0.37489200f, -0.22787586f, 0.07153895f, 0.36127332f, -0.27389127f, -0.24170861f, 0.28504524f, 
    -0.02884328f, 0.37937653f, 0.07895546f, -0.10428723f, -0.36738607f, -0.07606101f, 0.38364717f, 0.21613358f, 
    0.08442116f, -0.07439795f, 0.23024362f, 0.03831242f, -0.00381422f, -0.31365386f, 0.29514170f, -0.05483626f, 
    0.15263674f, -0.20508732f, 0.38727877f, 0.22902672f, -0.19058418f, 0.41607240f, 0.24646468f, 0.20480083f, 
    -0.02068726f, 0.19102034f, 0.07584836f, -0.27425906f, 0.90280646f, -0.11471784f, 0.06805932f, 0.63095927f, 
    -0.21927875f, 0.02804732f, -0.07802879f, -0.24570227f, -0.06056252f, 0.13180119f, -0.12467220f, 0.00089197f, 
    -0.13005011f, -0.08146760f, 0.25312451f, -0.03694743f, -0.16332622f, -0.03513193f, -0.31541115f, 0.13571876f, 
    -0.03711820f, -0.13536000f, -0.13080537f, 0.17331806f, 0.01644006f, 0.43899855f, 0.04291602f, 0.15755427f, 
    -0.19925714f, 0.44135213f, 0.22810157f, 0.16876358f, 0.01449948f, -0.03836524f, 0.00349736f, 0.14305575f, 
    -0.06318824f, -0.92879921f, -0.05459292f, -0.16088133f, 0.15077507f, 0.05670383f, 0.43652391f, -0.15431659f, 
    0.07820681f, -0.07805239f, -0.00566421f, 0.01472843f, 0.02510372f, 0.11535881f, 0.01945766f, 0.02431265f, 
    -0.12091856f, -0.11298481f, -0.18940669f, -0.20166558f, -0.03459463f, 0.14971644f, -0.05850329f, -0.09955338f, 
    0.08599772f, 0.08405502f, -0.02117261f, 0.11905736f, 0.05247152f, 0.01346528f, -0.12714039f, -0.01244702f, 
    0.07761571f, -0.10218889f, 0.03748499f, -0.07783263f, -0.06160411f, 0.10821429f, -0.07047050f, -0.03093828f, 
    -0.09492713f, -0.09399299f, 0.05778623f, 0.07179976f, 0.10487576f, -0.08203313f, 0.11790159f, 0.00438854f, 
    -0.03165187f, -0.09999243f, 0.06906892f, 0.09460833f, -0.04083333f, 0.02695239f, -0.17744455f, -0.14977922f, 
    -0.03101801f, -0.11811651f, -0.08013968f, -0.09321618f, -0.05378484f, -0.08744273f, -0.03304790f, 0.01160341f, 
    -0.07031067f, -0.05166795f, -0.04273519f, -0.16089199f, -0.02317104f, 0.00522887f, -0.02708445f, -0.08195991f, 
    0.07893199f, 0.00359218f, 0.28084025f, 0.46114403f, 0.37176201f, 0.37098411f, -0.30490825f, -0.02509322f, 
    0.18975210f, -0.15213564f, -0.75356823f, -0.03894434f, 0.08115445f, -0.46903306f, -0.03425264f, -0.12729584f, 
    0.23952451f, -0.51815414f, 0.02792736f, 0.48849890f, -0.11077449f, 0.20503682f, 0.08875274f, -0.10160838f, 
    0.43762401f, 0.02442751f, -0.05277370f, 0.14983094f, 0.17357306f, -0.22828618f, -0.08480395f, 0.00436136f, 
    0.10239168f, 0.09132066f, 0.15287496f, 0.15804265f, 0.17747925f, -0.14571179f, 0.06291550f, -0.04939169f, 
    0.06303024f, -0.00342505f, 0.30661359f, -0.39931959f, 0.17552382f, -0.04221053f, -0.25543392f, 0.28041640f, 
    0.14067599f, -0.24394043f, -0.11898768f, 0.04365120f, 0.10187659f, 0.01955054f, -0.13405973f, -0.02003561f, 
    0.04940978f, 0.05828203f, 0.01189737f, -0.20788915f, 0.03011901f, 0.43457040f, 0.05520144f, 0.00925336f, 
    0.04665335f, 0.04878600f, -0.23280150f, -0.23385075f, 0.07841862f, -0.25083938f, 0.58702254f, 0.16921403f, 
    -0.15692368f, 0.06194038f, 0.63519132f, 0.54626501f, 0.01618836f, 0.43514881f, -0.04351574f, 0.30515409f, 
    -0.08646537f, 0.51123667f, 0.10113701f, -0.18202929f, 0.44642523f, -0.22811393f, 0.10741089f, 0.54713023f, 
    -0.09116285f, 0.00537463f, 0.11634783f, -0.19781151f, 0.03832982f, 0.12805238f, 0.34328082f, -0.11916260f, 
    0.14897817f, -0.05574465f, 0.11025030f, 0.08871765f, 0.05496522f, 0.33771077f, -0.19128516f, 0.07986807f, 
    0.14434797f, -0.00821206f, 0.06425510f, 0.34462881f, -0.14641459f, 0.02292070f, 0.08444318f, -0.20290831f, 
    -0.03138626f, 0.13545336f, 0.07865050f, 0.20102064f, -0.06303211f, 0.06821997f, 0.65007633f, 0.40142757f, 
    -0.04588366f, -0.02738724f, -0.07264466f, 0.19265732f, 0.04689544f, -0.40181988f, 0.11472175f, 0.04898563f, 
    0.06726295f, -0.03240396f, -0.09515792f, -0.07141878f, -0.01359954f, -0.10674617f, -0.11177377f, -0.12683760f, 
    -0.05825888f, 0.07714815f, -0.06400546f, 0.09855184f, -0.11772713f, 0.01113518f, 0.09109169f, -0.11323594f, 
    -0.08878749f, 0.01166155f, 0.02567556f, -0.01625611f, -0.06376339f, 0.07383987f, -0.06333002f, -0.09340736f, 
    0.09921501f, 0.06148855f, 0.09616166f, -0.07184796f, 0.02047225f, -0.14466400f, 0.08317056f, 0.04507076f, 
    0.10035641f, -0.08773407f, 0.09877814f, -0.07219103f, -0.07150167f, -0.02073653f, -0.09627516f, -0.04602269f, 
    0.05840205f, 0.08392639f, -0.05989790f, 0.05275868f, -0.15620846f, -0.07795835f, 0.04956511f, 0.03989959f, 
    -0.01856735f, -0.15594628f, -0.05133384f, -0.07563511f, -0.04108135f, -0.00864101f, -0.03502415f, -0.13595092f, 
    -0.01512186f, 0.02005081f, -0.13630404f, -0.05096606f, 0.03487223f, -0.05180956f, -0.11788765f, 0.03892149f, 
    -0.01879293f, 0.28247344f, -0.34127685f, -0.41560486f, -0.33978301f, -0.34134918f, 0.12533750f, 0.16023161f, 
    -0.44986883f, -0.01935113f, 0.33337307f, 0.35961595f, -0.09116972f, 0.08105145f, -0.19519180f, 0.18367065f, 
    0.11375076f, 0.63054067f, 0.31306812f, -0.20892748f, -0.15886149f, -0.11720551f, -0.32579255f, 0.24062499f, 
    -0.18935706f, 0.20911302f, 0.14454903f, 0.14095221f, -0.12433362f, -0.03663845f, 0.11432420f, 0.08544284f, 
    0.02838734f, -0.35316420f, 0.04703507f, 0.09636106f, -0.09974092f, 0.30458999f, 0.09723385f, 0.10249691f, 
    0.11585716f, 0.04612323f, -0.26073402f, -0.01023934f, -0.30767694f, 0.36595258f, 0.20165913f, 0.03249250f, 
    0.10070753f, 0.31110471f, 0.08695773f, 0.12045437f, -0.00708275f, -0.13321826f, 0.61521745f, 0.20499355f, 
    0.07537493f, 0.05603240f, 0.14393809f, 0.28020978f, -0.29663426f, -0.29787251f, 0.23730977f, 0.04703478f, 
    -0.06855659f, -0.01161719f, 0.27385217f, 0.11102225f, -0.77023935f, 0.00851270f, -0.14882118f, 0.09591575f, 
    0.47094500f, 0.34133965f, 0.13791394f, 0.18677655f, -0.05987920f, -0.14358385f, 0.14733841f, 0.04463942f, 
    -0.11172641f, 0.09970789f, 0.11369479f, -0.38116726f, 0.38265967f, 0.01880225f, -0.27258855f, -0.32327983f, 
    -0.53919572f, 0.06088093f, 0.02871056f, 0.05176410f, -0.08983465f, 0.34970820f, -0.22154427f, 0.23942453f, 
    0.08419307f, 0.17334339f, -0.07428622f, -0.01607917f, 0.15030302f, -0.11083211f, -0.09369407f, -0.02052408f, 
    0.04548389f, 0.10033097f, -0.13452964f, 0.06054722f, 0.21151710f, -0.16951162f, 0.14872672f, -0.06585516f, 
    0.15842429f, -0.07720634f, 0.12154768f, -0.04528979f, -0.19527008f, 0.23906747f, 0.42826980f, -0.10040642f, 
    0.11459731f, -0.57484496f, -0.00936478f, 0.19844805f, 0.09233075f, 0.19427750f, -0.00812605f, 0.01992630f, 
    -0.02988890f, 0.00781207f, -0.03852203f, 0.01439696f, 0.02977696f, -0.07088627f, -0.05082767f, -0.06194066f, 
    0.07935509f, -0.10313833f, -0.10372406f, 0.07806414f, -0.11203943f, 0.07384713f, -0.05690664f, -0.09086232f, 
    -0.10302185f, -0.07636689f, 0.03858939f, -0.02678159f, -0.13067576f, -0.07425082f, 0.09999478f, -0.09336780f, 
    -0.10563257f, -0.07667509f, 0.02208223f, -0.11873340f, -0.03897854f, 0.01942994f, -0.05095072f, 0.03822508f, 
    0.04167850f, 0.08297654f, -0.07492334f, 0.04186040f, -0.03543250f, -0.10025101f, -0.10262085f, 0.10136624f, 
    -0.08881254f, -0.08601533f, -0.14808522f, -0.10935116f, -0.00650044f, -0.02066996f, 0.07099181f, -0.08385805f, 
    -0.04231441f, 0.03116023f, -0.14680430f, 0.04560410f, -0.10017174f, 0.08453150f, -0.04138087f, 0.00374773f, 
    0.12250240f, 0.02356651f, -0.13719456f, 0.01609277f, 0.01656890f, -0.11215404f, 0.02384064f, 0.06319956f, 
    0.08126943f, -0.15159969f, 0.03159791f, 0.01157066f, -0.04343836f, -0.14673887f, -0.08774984f, -0.13965771f, 
    0.09104307f, -0.10106654f, -0.14016898f, -0.00495216f, -0.02386654f, 0.01789140f, 0.08140257f, -0.07596441f, 
    0.02624612f, 0.06630317f, 0.01707079f, -0.01498465f, -0.05903946f, -0.10762649f, -0.01533802f, -0.09931569f, 
    -0.13074850f, 0.09013396f, 0.09400596f, -0.02339898f, 0.00207704f, -0.08037078f, 0.01293178f, -0.07568891f, 
    -0.13841099f, -0.10511936f, 0.05884965f, -0.10001904f, 0.00465075f, 0.01084636f, -0.09868173f, -0.03554497f, 
    0.02471101f, 0.04871053f, 0.08995171f, 0.03157113f, -0.04355348f, 0.10398003f, 0.02284475f, 0.00961362f, 
    -0.04689180f, -0.00959626f, -0.09800635f, -0.00084628f, -0.10826320f, -0.05046180f, 0.05062354f, 0.00818726f, 
    -0.06971511f, 0.03085531f, -0.12774669f, -0.14819162f, -0.04166685f, -0.12832162f, 0.03963913f, 0.02739726f, 
    0.06109773f, -0.11467987f, -0.15931673f, -0.12410484f, 0.05020566f, -0.00731904f, -0.07829962f, -0.15567838f, 
    -0.17716785f, 0.03216324f, -0.16516051f, -0.01024957f, 0.03196730f, 0.16193983f, -0.15997304f, -0.01847190f, 
    -0.16135119f, -0.09244882f, -0.12920356f, 0.05049928f, 0.10509232f, -0.08186102f, -0.01225580f, 0.10525017f, 
    -0.01275557f, -0.17460023f, -0.04465998f, -0.06447709f, 0.04242128f, -0.17058316f, -0.09027703f, -0.04362610f, 
    0.02244342f, -0.11516243f, 0.07922662f, -0.10737933f, -0.11263568f, -0.12719151f, -0.06406747f, -0.09347835f, 
    0.04276435f, -0.05879529f, -0.05318989f, -0.12124804f, -0.10163885f, 0.09960052f, -0.15964432f, -0.04680437f, 
    0.00254677f, 0.09294653f, 0.01613979f, 0.02877307f, -0.17737889f, 0.02903405f, -0.04668510f, -0.15868081f, 
    0.12129977f, 0.02858356f, 0.06352548f, 0.03310135f, -0.09770808f, 0.02997732f, 0.01630485f, -0.07275680f, 
    0.07123198f, -0.15147431f, 0.41952622f, 0.43865767f, 0.13471305f, 0.41373503f, -0.01362122f, 0.23962277f, 
    0.78696465f, 0.38495025f, -0.26051009f, -0.24628282f, 0.08219318f, -0.17486127f, 0.31576025f, -0.02547016f, 
    0.09394996f, -0.45266917f, -0.20134129f, -0.00500482f, -0.30747989f, 0.32114157f, 0.41910580f, -0.60463631f, 
    -0.05136070f, -0.15074846f, 0.18812786f, -0.09519112f, 0.19449669f, 0.24211414f, -0.02674026f, 0.29723170f, 
    -0.00675453f, 0.25173655f, 0.17963408f, -0.09241378f, 0.41878113f, -0.37370753f, 0.08686519f, 0.08014552f, 
    -0.01359998f, 0.27013868f, 0.28301740f, 0.18991730f, 0.47484717f, -0.46695405f, -0.05473029f, 0.07373583f, 
    0.00179683f, -0.28501430f, 0.29270139f, -0.16652302f, -0.06922767f, 0.33182395f, 0.38827834f, -0.26455441f, 
    -0.00996092f, -0.01785716f, 0.05468362f, 0.12062693f, 0.57970208f, 0.41116688f, -0.29158610f, 0.07478801f, 
    -0.01717348f, 0.21479824f, -0.68056291f, -0.02239904f, 0.34767225f, -0.11418554f, 0.44288477f, 0.08795182f, 
    -0.28726420f, 0.00093157f, 0.20601781f, 0.12601179f, 0.22149482f, -0.27937332f, 0.07718094f, -0.14706588f, 
    -0.03672806f, -0.03700263f, -0.24957748f, -0.36926606f, -0.51025236f, -0.20962600f, 0.19189087f, -0.61669070f, 
    0.00395720f, -0.26919904f, -0.27884308f, 0.23341335f, 0.08653083f, 0.06083455f, 0.34374863f, 0.29922870f, 
    0.21143425f, -0.02047824f, -0.08930296f, -0.01342172f, -0.07095744f, -0.23190783f, 0.34720880f, -0.07142512f, 
    0.05569752f, 0.37333891f, 0.07556830f, 0.46939296f, -0.03310273f, 0.03233172f, 0.10812111f, -0.04951882f, 
    -0.21647699f, 0.08829631f, -0.23410310f, -0.08070930f, -0.36362407f, -0.13329037f, 0.80590594f, -0.09591386f, 
    -0.09012114f, 0.31830877f, 0.05898903f, -0.09741940f, 0.02988625f, -0.03189166f, 0.20639203f, 0.42461216f, 
    -0.10252130f, -0.04045464f, 0.10214167f, 0.11870005f, -0.18808107f, -0.11045378f, 0.21049124f, 0.02557983f, 
    0.40908161f, 0.29163933f, 0.14989300f, 0.07046785f, 0.12248485f, 0.31949934f, 0.07047907f, 0.09963698f, 
    -0.05430841f, -0.02474792f, 0.11480387f, -0.22715306f, 0.27721408f, -0.01920355f, -0.11091364f, -0.11226028f, 
    -0.25496480f, -0.02438613f, -0.17875400f, -0.26764122f, -0.01380857f, 0.05051852f, 0.04944306f, 0.13612199f, 
    0.10483685f, 0.18109003f, 0.06864492f, -0.12099702f, -0.04747242f, -0.17172381f, -0.00863159f, -0.09688725f, 
    -0.02147582f, 0.11201400f, 0.07619178f, 0.27321878f, 0.45195407f, 0.11486664f, 0.09844084f, -0.02039894f, 
    0.01285638f, 0.07392319f, 0.08955991f, 0.06966776f, -0.48383114f, -0.03235953f, 0.28539744f, 0.19997720f, 
    0.06082268f, -0.30672938f, 0.09932907f, 0.28597409f, -0.00395663f, 0.10744549f, 0.20675455f, 0.00449097f, 
    0.06062357f, -0.08667652f, -0.08675941f, -0.03296490f, -0.11486047f, -0.04828918f, 0.07747197f, -0.07896266f, 
    -0.04550470f, 0.02687986f, 0.02209261f, -0.16269423f, -0.09588407f, 0.03846199f, -0.11192555f, -0.08649708f, 
    -0.10872627f, 0.04738630f, -0.19294375f, 0.04533449f, -0.04703861f, -0.09259500f, -0.10780372f, -0.00223952f, 
    -0.09810831f, -0.14574590f, -0.07321265f, 0.07189685f, -0.03354305f, 0.05296671f, -0.19201516f, -0.04673322f, 
    -0.00641019f, -0.00054704f, -0.14949881f, -0.10602596f, -0.13489354f, 0.02540623f, 0.01155816f, 0.05354029f, 
    0.01559409f, -0.07910498f, -0.01413698f, 0.05570560f, 0.08715711f, 0.01407772f, -0.05968644f, -0.09669875f, 
    -0.19206035f, -0.15254763f, -0.10117881f, -0.15060352f, -0.01751897f, -0.14108355f, 0.12657224f, -0.03089157f, 
    0.01362610f, -0.12583502f, 0.06705000f, -0.07323335f, 0.06496830f, 0.04080958f, 0.05690655f, 0.06748276f, 
    0.06035993f, 0.26151407f, 0.28401315f, 0.01724879f, -0.08255522f, 0.48771575f, -0.72799844f, -0.04771011f, 
    -0.02092453f, -0.10839626f, 0.03790295f, 0.11471941f, 0.04918109f, -0.26404303f, -0.00297449f, -0.22025630f, 
    0.18705083f, 0.56326449f, 0.53064054f, -0.11545634f, -0.10145389f, 0.09618614f, -0.36270911f, 0.37061512f, 
    -0.01807027f, 0.39604360f, 0.46560529f, 0.21501637f, 0.05456514f, -0.15163067f, -0.12293416f, -0.13453780f, 
    -0.24811538f, -0.08562030f, -0.22602797f, -0.08870925f, 0.03532086f, 0.28299141f, 0.14094110f, 0.07995658f, 
    -0.09785490f, -0.01731185f, 0.12292221f, -0.55520934f, -0.33962873f, -0.14886633f, 0.09113366f, 0.05256437f, 
    0.41776732f, -0.02635991f, 0.15017083f, 0.18704261f, 0.42459360f, 0.16551562f, 0.18293656f, -0.09222550f, 
    0.05105072f, 0.03640037f, 0.33991814f, -0.09424725f, -0.09940087f, -0.19483741f, -0.07841167f, 0.14496219f, 
    0.10671492f, 0.12200672f, 0.49238226f, 0.06895814f, 0.22267716f, 0.28021514f, -0.25588956f, -0.13991347f, 
    -0.17032319f, -0.22370985f, -0.38546953f, -0.04512877f, -0.13924944f, -0.10646492f, 0.16740501f, 0.12016022f, 
    0.29986763f, -0.05107825f, 0.14652933f, -0.33444440f, -0.32319856f, 0.26999828f, 0.21974230f, -0.04790538f, 
    0.02060618f, 0.02432064f, 0.52958703f, 0.20963986f, -0.03505475f, -0.03995514f, -0.02346710f, 0.01090284f, 
    -0.10321898f, -0.20123327f, -0.15399364f, 0.07327176f, 0.32405517f, 0.37575769f, 0.26164398f, -0.03877113f, 
    -0.06680446f, 0.12088270f, 0.23942639f, -0.16497986f, -0.41220212f, -0.31375137f, -0.02859018f, 0.00489400f, 
    0.42457527f, -0.23929904f, -0.04495060f, -0.02809373f, 0.26947707f, 0.22973371f, 0.57196164f, -0.31720412f, 
    0.09702108f, -0.26065391f, 0.18216053f, -0.20402946f, 0.18525794f, -0.03007651f, 0.10679869f, -0.00400213f, 
    -0.04508723f, 0.03262865f, 0.01917119f, -0.03534504f, 0.01834340f, 0.18548153f, -0.32398310f, -0.10246611f, 
    -0.28280449f, -0.06179535f, -0.08381514f, 0.08458643f, -0.04228310f, 0.27201262f, 0.02440425f, -0.08327024f, 
    0.09613748f, 0.38586083f, 0.20984939f, -0.29791236f, 0.27987844f, -0.00699203f, -0.09753677f, 0.59891725f, 
    0.39034402f, 0.20823199f, -0.11677830f, 0.24140015f, -0.09649491f, 0.15473850f, -0.00534093f, 0.17258771f, 
    -0.11626939f, -0.21461801f, -0.04074971f, -0.03039777f, -0.17033906f, -0.03201789f, 0.02686839f, 0.00770119f, 
    -0.03999894f, 0.08922891f, -0.21277516f, -0.12300957f, -0.29423073f, 0.29523507f, 0.01892077f, 0.12407167f, 
    0.25442487f, 0.05047790f, -0.10247720f, -0.11578513f, 0.03169903f, 0.02362727f, -0.22606395f, 0.03536005f, 
    0.09632079f, -0.41337642f, 0.04727740f, -0.16263689f, -0.17433368f, 0.02734378f, 0.31695604f, 0.32767367f, 
    0.06289473f, 0.19117230f, 0.07471180f, -0.00329459f, 0.36700889f, 0.11004449f, -0.03648236f, 0.22218101f, 
    -0.07437720f, -0.12000141f, -0.29096726f, 0.11405173f, -0.11470730f, -0.30129302f, -0.01507633f, 0.01006425f, 
    0.15102009f, -0.26516810f, 0.01840268f, 0.22473302f, -0.04845262f, -0.01513496f, 0.04809228f, -0.44506842f, 
    -0.28830060f, 0.11807311f, 0.26302251f, -0.06563894f, 0.05405915f, -0.13692380f, 0.23648356f, -0.06534375f, 
    0.09154228f, -0.03213594f, 0.06891445f, -0.07370716f, 0.13526468f, 0.07450190f, -0.15260166f, 0.10933782f, 
    0.12263783f, -0.03801230f, 0.21393785f, -0.02992797f, 0.05208256f, -0.19664194f, 0.00709531f, 0.12145874f, 
    0.14099097f, 0.01056090f, 0.18622687f, -0.00149475f, 0.15525521f, 0.12457483f, 0.19178717f, -0.27055749f, 
    -0.09201242f, -0.01086719f, 0.07720907f, 0.15739842f, 0.17179736f, -0.00734316f, -0.08214343f, -0.18844302f, 
    -0.03523353f, 0.05196418f, 0.16475023f, 0.36449674f, 0.19150017f, 0.18386886f, 0.55741519f, -0.03768198f, 
    0.75893444f, -0.04204828f, 0.40803933f, -0.00403149f, -0.22682396f, -0.58825290f, 0.04568044f, 0.43585256f, 
    0.14456344f, -0.20656028f, 0.15576364f, -0.13352877f, -0.09709017f, 0.11578843f, 0.29107758f, -0.02711709f, 
    -0.15512747f, 0.14125118f, -0.31492838f, -0.15265195f, 0.13104510f, -0.20045401f, -0.04124209f, -0.27582666f, 
    -0.12055872f, -0.05413475f, 0.02321140f, -0.05164530f, 0.20721719f, 0.46034727f, -0.14647526f, -0.04077597f, 
    -0.10026427f, 0.04101847f, -0.17237556f, -0.12963863f, 0.38193873f, -0.33634073f, 0.03405388f, 0.25331828f, 
    -0.09541354f, -0.36846009f, 0.15439385f, 0.41049242f, 0.01941183f, 0.05527020f, -0.29825005f, 0.16653797f, 
    -0.01882131f, 0.05406172f, -0.32744938f, 0.24440774f, -0.05371279f, 0.23616359f, -0.34080046f, -0.09925541f, 
    -0.08673395f, 0.05082718f, -0.11212059f, -0.14194402f, -0.10505290f, -0.03196885f, -0.24384774f, 0.13954875f, 
    -0.38981095f, 0.19650395f, -0.18794015f, -0.04421664f, 0.06894837f, 0.21176620f, -0.26079342f, -0.11159600f, 
    0.13808602f, 0.12637803f, 0.29270113f, 0.19023216f, -0.61024892f, 0.06217730f, 0.02789660f, -0.43799591f, 
    0.33152476f, 0.22431085f, 0.15740374f, 0.42450613f, -0.01935567f, -0.09162759f, 0.37712833f, 0.04344149f, 
    0.30842596f, 0.08131169f, 0.09973464f, 0.07650357f, 0.04854174f, 0.01728892f, 0.47551462f, -0.09850350f, 
    -0.20743668f, 0.07811803f, -0.00252774f, -0.06928755f, -0.27308530f, 0.20263459f, 0.10485722f, 0.08454233f, 
    0.16420580f, 0.07081056f, -0.28023705f, 0.03113781f, -0.39809147f, -0.08969053f, 0.08844366f, -0.06152701f, 
    -0.21856885f, 0.86419702f, 0.10319602f, 0.12679818f, -0.37937814f, 0.03217213f, 0.06678294f, 0.17326608f, 
    -0.06829309f, 0.15149935f, 0.08205684f, 0.05483909f, -0.16519882f, -0.21936509f, -0.20403986f, 0.26641151f, 
    -0.04352962f, 0.39909983f, -0.11707848f, -0.00885501f, 0.00202435f, -0.64601827f, -0.09729357f, -0.34968063f, 
    -0.12403755f, -0.07569858f, -0.10528249f, 0.16704950f, 0.09605911f, 0.07605267f, -0.25376680f, -0.32551607f, 
    0.06858885f, -0.03715865f, -0.00716188f, -0.10480005f, 0.03899699f, 0.06075695f, -0.03158896f, 0.12516239f, 
    0.12035128f, 0.49374029f, 0.34665772f, 0.06050987f, -0.16811760f, -0.16651037f, -0.31460381f, 0.07090081f, 
    -0.00009455f, -0.11361399f, 0.19687569f, -0.16697027f, 0.17941886f, 0.12103310f, 0.08890729f, -0.07102701f, 
    0.08276329f, 0.37204313f, 0.17231704f, -0.10808161f, 0.28225935f, -0.02325056f, -0.22942892f, 0.29076043f, 
    -0.00479459f, -0.00672721f, -0.00396152f, 0.16451566f, -0.10538668f, 0.41913602f, 0.06402961f, -0.31884193f, 
    -0.05468586f, 0.19203196f, -0.19498067f, -0.01506524f, 0.48039562f, -0.06144826f, 0.20537083f, 0.05233052f, 
    -0.32465979f, -0.30684325f, 0.01334022f, 0.41402680f, -0.04166545f, 0.48996702f, -0.19182958f, 0.04701424f, 
    0.09068070f, 0.11403161f, 0.19168800f, 0.37912700f, 0.18868893f, -0.17986885f, -0.15860885f, 0.26943719f, 
    0.26107579f, 0.17276683f, 0.12960750f, 0.03047642f, -0.12289862f, -0.16970827f, 0.41620618f, -0.09805454f, 
    0.05800985f, -0.37358981f, -0.04330925f, 0.04976340f, 0.04486366f, 0.41049129f, 0.27181295f, -0.10799114f, 
    0.15181050f, 0.01089349f, -0.04031129f, 0.04621054f, -0.13830660f, 0.26794171f, -0.08688106f, 0.07497500f, 
    -0.02482958f, 0.19588548f, 0.01158803f, 0.27492604f, 0.06649678f, -0.10650045f, 0.50416553f, 0.30576354f, 
    0.11731477f, 0.57156128f, -0.11031695f, 0.13864055f, -0.15588684f, -0.14740345f, 0.20048921f, 0.05033595f, 
    0.11307062f, 0.20704488f, -0.14874823f, 0.16616866f, -0.15630522f, 0.00117851f, 0.17449228f, 0.13944533f, 
    0.31742808f, 0.20934612f, 0.14156227f, -0.24446033f, 0.19925225f, 0.19745758f, 0.13195412f, -0.03750093f, 
    -0.08739571f, -0.02146683f, -0.01399237f, -0.12566376f, -0.17463988f, 0.04257243f, -0.00679093f, -0.22977911f, 
    0.14712574f, 0.00150400f, -0.00246134f, -0.04767220f, 0.10994582f, 0.09946413f, 0.03808850f, 0.09305564f, 
    0.15747237f, 0.19821617f, -0.03679995f, 0.07003366f, -0.06402388f, -0.13602912f, 0.00254148f, -0.01485350f, 
    -0.00110569f, 0.21220714f, -0.05473340f, 0.37520778f, 0.33857429f, 0.01710128f, 0.24718465f, -0.09056211f, 
    -0.11540636f, -0.33469698f, -0.06385195f, -0.00562956f, -0.19033290f, -0.23935612f, 0.63088334f, 0.06570429f, 
    0.02486497f, 0.31620073f, -0.00740499f, 0.20794970f, -0.19914354f, 0.09719200f, 0.12410823f, 0.35671124f, 
    0.11581559f, -0.11535411f, -0.02586992f, -0.12972322f, -0.06680921f, -0.12736863f, -0.10429805f, 0.08742046f, 
    -0.12693322f, 0.10469300f, 0.09685565f, 0.04792967f, 0.01856241f, -0.04134578f, 0.01511933f, 0.06223319f, 
    0.04558229f, 0.03292283f, -0.09578677f, 0.09425896f, -0.09741485f, -0.03212693f, 0.04661650f, 0.12313666f, 
    0.09321981f, -0.06164532f, 0.10066479f, -0.12623018f, -0.08316468f, -0.05862611f, 0.09069474f, -0.01288809f, 
    -0.12374055f, -0.06442859f, -0.08983729f, 0.02998981f, 0.05403143f, 0.04017205f, 0.07044763f, -0.10292925f, 
    -0.00576651f, 0.10522538f, -0.11667122f, -0.10892142f, 0.04047620f, 0.10113817f, -0.04911858f, 0.00663420f, 
    0.03981511f, -0.03933275f, -0.11367247f, -0.09063040f, -0.08110970f, 0.04382634f, 0.06275278f, 0.11144723f, 
    -0.10046022f, -0.08944767f, -0.06307017f, 0.09154945f, -0.03018740f, -0.08170862f, 0.03247386f, 0.06126003f, 
    -0.11567630f, -0.04170746f, 0.29198554f, 0.25236416f, 0.21334277f, -0.00282373f, -0.09904522f, 0.14984046f, 
    0.34787801f, 0.21265391f, -0.05909762f, 0.05182233f, -0.13532121f, -0.53987330f, 0.08832124f, 0.06406803f, 
    0.14229013f, -0.04580320f, 0.05372116f, -0.00880148f, 0.17585969f, 0.33505228f, 0.01718646f, -0.06182861f, 
    -0.03442363f, 0.05374002f, 0.29551315f, -0.26898310f, -0.08107477f, -0.14841804f, -0.17523818f, -0.05567572f, 
    -0.03855737f, 0.26136547f, 0.09106112f, 0.07948525f, 0.22753993f, 0.37521264f, -0.22153458f, 0.05553557f, 
    -0.10002758f, 0.13606596f, 0.14702711f, -0.19227387f, 0.31356287f, -0.19573596f, 0.06264661f, 0.18908739f, 
    -0.00910659f, 0.27605459f, 0.15607771f, 0.27638251f, 0.23180598f, 0.25290272f, -1.04205418f, 0.20998211f, 
    0.09539397f, -0.11338140f, -0.06822227f, 0.10981059f, -0.12396414f, 0.33917868f, -0.18946700f, -0.23911825f, 
    0.07577114f, 0.11881077f, -0.08076748f, -0.02046977f, -0.05272882f, -0.00835018f, -0.05430637f, -0.07545286f, 
    -0.09755893f, 0.07261181f, -0.08089089f, 0.03604303f, -0.11119843f, 0.01129760f, -0.02473862f, 0.11709103f, 
    -0.09047835f, -0.08281413f, -0.04689541f, -0.02085276f, 0.01541050f, 0.02802947f, -0.03506099f, 0.00205442f, 
    0.04211205f, -0.01817298f, -0.03328310f, 0.09835857f, -0.08074011f, -0.08522584f, -0.01833886f, -0.02601705f, 
    0.08986482f, -0.11210093f, -0.02360173f, 0.02212137f, -0.01646008f, 0.06375821f, -0.06288496f, -0.03440346f, 
    0.00468907f, -0.07186890f, -0.02992593f, 0.02221891f, -0.03442743f, -0.09335141f, -0.08547401f, 0.01464543f, 
    0.01290874f, -0.00870261f, -0.09067464f, 0.10899337f, 0.03264506f, -0.05258329f, -0.10290632f, -0.00915609f, 
    0.12415096f, -0.10447709f, 0.08209842f, -0.11539881f, -0.11713505f, -0.07095204f, -0.04256259f, -0.08873406f, 
    -0.02367435f, -0.17015705f, 0.15547960f, 0.04074769f, 0.08477143f, 0.22309554f, -0.19257607f, 0.08349171f, 
    0.05922628f, 0.21888611f, -0.51865542f, -0.31357330f, 0.23980244f, -0.03986925f, 0.02173432f, -0.06615253f, 
    0.14215674f, -0.24309547f, -0.22951770f, -0.17346969f, -0.55091709f, 0.10241333f, 0.20813197f, -0.55524302f, 
    0.31533730f, -0.11408139f, 0.07958304f, 0.17820907f, 0.07709453f, 0.03257684f, 0.08121499f, 0.09464140f, 
    0.22603452f, 0.19940881f, -0.01501488f, 0.05619870f, 0.15930609f, -0.43804818f, 0.29392147f, 0.01898047f, 
    0.02432553f, 0.11565094f, 0.18340576f, -0.08354607f, 0.19795874f, -0.28205913f, -0.07900331f, 0.10019688f, 
    -0.04675644f, -0.09694892f, -0.12310290f, -0.51178986f, 0.06813419f, 0.18963532f, -0.16674031f, -0.30299768f, 
    -0.05064579f, 0.25709710f, 0.23330446f, 0.01695709f, 0.23382802f, 0.27086410f, -0.16537736f, -0.35927489f, 
    -0.10354012f, -0.13000032f, 0.26941675f, -0.14533053f, -0.39135626f, 0.02897274f, -0.12932721f, 0.20871754f, 
    -0.43311486f, 0.10016810f, 0.55043805f, -0.20246366f, 0.10159848f, -0.16001952f, 0.18888280f, -0.19259723f, 
    -0.53095055f, 0.47091827f, -0.08195669f, -0.06014808f, -0.59709179f, -0.34629303f, -0.23312120f, -0.08500265f, 
    -0.24374871f, -0.30710605f, 0.24948610f, 0.15616421f, -0.11971582f, 0.20367549f, -0.52972442f, 0.17991932f, 
    0.05523812f, 0.11458740f, -0.72276121f, -0.00996199f, 0.23722655f, 0.32286879f, -0.85475636f, 0.08238313f, 
    -0.00149160f, 0.10061355f, -0.84697139f, 0.21926478f, -0.20073135f, -0.47925103f, 0.00076464f, -0.93211114f, 
    0.23176500f, 0.18501233f, 0.00041097f, 0.10516184f, 0.28525200f, -0.69091129f, -0.29986703f, -0.17882870f, 
    -0.00570678f, 0.11700051f, 0.11610252f, -0.67412877f, 0.18929374f, -0.15357639f, 0.17766881f, 0.50050920f, 
    -0.06768212f, -0.01832890f, -0.06834750f, -0.07739981f, -0.09071006f, -0.01047723f, -0.12166695f, -0.11806042f, 
    0.01197842f, -0.11053669f, -0.00028300f, 0.01819662f, -0.10662237f, 0.04847576f, 0.02742267f, -0.10491847f, 
    0.00577162f, -0.09300125f, -0.08509000f, -0.07002563f, 0.09118292f, -0.02185249f, -0.10540881f, -0.11771497f, 
    -0.07082935f, -0.13307863f, 0.04566827f, 0.01298637f, 0.05048204f, 0.05849499f, -0.04527443f, 0.06876636f, 
    0.04873341f, -0.05732108f, -0.02389855f, 0.06822139f, 0.00166073f, 0.00086269f, -0.09990597f, 0.01296658f, 
    0.08069857f, -0.01642715f, 0.06662791f, -0.14937571f, -0.07289886f, 0.05827698f, 0.09761519f, 0.07290135f, 
    0.08183464f, -0.03656592f, 0.04214071f, 0.08195214f, -0.05102047f, -0.08363640f, -0.08700631f, 0.08557574f, 
    0.06144963f, 0.01174953f, -0.07404673f, -0.01259592f, -0.10014279f, 0.09657607f, 0.03628966f, -0.02627525f, 
    0.06129859f, 0.12723500f, 0.05517992f, -0.04988738f, -0.75280511f, -0.11908884f, -0.04613847f, 0.21187976f, 
    0.27521378f, 0.60520935f, 0.18369544f, -0.03073631f, 0.12443149f, -0.16979977f, 0.10339205f, 0.03261760f, 
    0.13895003f, 0.32653281f, 0.22060129f, -0.26715311f, -0.30532560f, 0.08918887f, -0.26342589f, 0.11289740f, 
    -0.49382350f, 0.29123771f, 0.06737585f, -0.20461127f, -0.02458151f, 0.02819402f, -0.13531716f, 0.08745702f, 
    0.19576578f, 0.23999384f, -0.02555688f, 0.09660180f, 0.20758069f, -0.16401304f, -0.12335507f, 0.09965473f, 
    -0.04467928f, 0.03041865f, -0.14216098f, -0.11233702f, 0.60352916f, -0.43126178f, 0.41759691f, -0.18750948f, 
    0.05382546f, -0.41217437f, 0.17942609f, -0.16630235f, -0.42893058f, 0.27929002f, -0.31415641f, 0.05812771f, 
    -0.06188146f, 0.58987570f, -0.01501615f, 0.50481784f, -0.08214226f, 0.11334701f, -0.57196730f, 0.00168247f, 
    0.11431454f, -0.03445617f, -0.12361149f, 0.04818923f, -0.13453870f, -0.05216932f, -0.02568515f, -0.06478994f, 
    0.03934968f, -0.14611302f, 0.04396417f, 0.07515399f, -0.14248861f, -0.05327500f, 0.06973587f, -0.11847948f, 
    0.03523152f, -0.10213119f, -0.07192038f, -0.06390419f, 0.05812008f, -0.04910427f, -0.09696635f, 0.08924665f, 
    -0.09965436f, -0.09504389f, 0.05581392f, 0.07949061f, -0.10255712f, 0.05904365f, 0.06063809f, 0.08168995f, 
    0.01598848f, -0.16736430f, -0.14614920f, 0.03327000f, 0.00121586f, 0.01407541f, 0.04350464f, -0.08605275f, 
    0.07995652f, -0.10482498f, -0.04946936f, 0.09972049f, -0.02625190f, -0.11302233f, 0.05915352f, 0.04006220f, 
    -0.01826309f, -0.00248557f, -0.11078080f, 0.09615517f, 0.03671968f, -0.09589126f, 0.03932758f, -0.11345334f, 
    0.00245906f, -0.05724958f, -0.12926081f, 0.04385120f, -0.07516348f, -0.09148733f, -0.12297347f, 0.06475017f, 
    0.03518058f, 0.10622442f, -0.08169676f, -0.13331030f, 0.02981576f, -0.10133326f, -0.14859433f, 0.00574956f, 
    -0.02450981f, -0.06421337f, 0.03543127f, 0.02868046f, -0.05941372f, 0.11862654f, -0.09193083f, -0.01537914f, 
    0.03361918f, -0.01705380f, -0.00826792f, -0.08120219f, 0.01928972f, 0.05262648f, -0.07973053f, 0.09282481f, 
    0.01501052f, 0.02667858f, -0.09960401f, 0.03884052f, -0.13018484f, -0.01744261f, -0.06510527f, -0.14202261f, 
    -0.03414937f, -0.05505912f, -0.03805749f, 0.09778871f, 0.09322237f, -0.00215566f, -0.06781331f, 0.03134814f, 
    0.05118281f, -0.05094682f, 0.08775510f, -0.15404579f, -0.02865503f, 0.01051368f, -0.00992001f, 0.07133918f, 
    -0.05575776f, 0.05181526f, 0.06170765f, -0.09194539f, -0.04735613f, -0.03742946f, 0.05570601f, -0.08841300f, 
    0.06528115f, -0.00849190f, -0.10670210f, 0.05953731f, -0.12234258f, -0.11090265f, 0.02684403f, -0.04555886f, 
    0.07122821f, 0.05978204f, 0.17304605f, 0.31055546f, -0.49074766f, -0.08209446f, -0.07611424f, 0.27175468f, 
    0.62509060f, 0.53061640f, -0.56107646f, -0.16455230f, 0.05199544f, -0.59018099f, -0.02957965f, -0.14136738f, 
    -0.06876226f, 0.10987407f, 0.01766389f, -0.24815777f, -0.30780438f, 0.02685272f, -0.38012663f, -0.95340854f, 
    -0.19602247f, 0.22732854f, -0.15706666f, -0.07435296f, 0.00256709f, 0.05409950f, -0.13588163f, 0.21825585f, 
    0.28459042f, 0.42987213f, 0.08517433f, 0.00960535f, -0.00839537f, -0.20597702f, -0.13585712f, 0.02160807f, 
    -0.16880983f, 0.20769951f, -0.04549978f, -0.12844074f, 0.59111273f, 0.09995873f, 0.16372454f, 0.26004428f, 
    0.04052223f, -0.14829449f, 0.09561692f, 0.02498368f, -0.38601863f, 0.06802536f, -0.73456818f, 0.10956685f, 
    -0.05005831f, -0.30411571f, -0.20177875f, 0.36375129f, -0.12962465f, 0.57641202f, -0.15365095f, -0.01722323f, 
    -0.05798087f, 0.09601107f, 0.06665517f, -0.05990832f, -0.32243788f, -0.23355237f, -0.17917824f, 0.04647517f, 
    -0.44726133f, 0.21655802f, 0.26990247f, 0.46297845f, -0.06033066f, -0.00627062f, -0.12713087f, -0.07521114f, 
    0.06838507f, 0.39348668f, 0.31471348f, 0.05052038f, -0.01820796f, 0.15505524f, -0.40021130f, 0.22367552f, 
    -0.14801832f, 0.41475168f, 0.35381159f, 0.13678309f, -0.06426542f, -0.01661378f, 0.11921422f, 0.11267895f, 
    0.00667322f, 0.02273209f, 0.06032979f, -0.08156009f, -0.19548741f, 0.12398379f, 0.17035112f, 0.06542727f, 
    -0.16538391f, 0.06913581f, 0.01748493f, -0.16696003f, -0.21258593f, 0.36646026f, 0.37239495f, -0.05371083f, 
    0.17022860f, 0.20974909f, 0.22778644f, 0.02589913f, -0.01407233f, 0.08062594f, 0.08910169f, 0.13525622f, 
    0.00460357f, 0.45949447f, 0.19545248f, 0.27739236f, -0.25645226f, -0.12332571f, -0.06574216f, -0.00113563f, 
    0.10301682f, -0.09463968f, 0.04192007f, -0.12892470f, 0.03483061f, -0.11579044f, 0.11324964f, 0.00131806f, 
    -0.03236454f, -0.02190440f, 0.00598796f, -0.12204173f, -0.08278307f, 0.01050930f, -0.10500900f, 0.09070157f, 
    -0.12695175f, 0.01400602f, 0.08077584f, 0.04540180f, 0.14693241f, 0.07035835f, 0.09700827f, 0.02581670f, 
    0.09156509f, -0.14468029f, -0.14698565f, -0.10221849f, -0.02314778f, -0.13574797f, -0.10290381f, 0.05245969f, 
    -0.11810711f, 0.04874406f, 0.07758523f, -0.06212914f, 0.07009673f, -0.10644376f, 0.01747681f, 0.08118101f, 
    -0.06318431f, -0.14738475f, 0.00288799f, -0.01540345f, -0.01199284f, 0.02042101f, -0.13041602f, -0.07560012f, 
    0.05400065f, 0.02632315f, -0.00003741f, 0.07897294f, -0.18764967f, -0.06025437f, 0.02512074f, 0.02188702f, 
    0.05448279f, 0.02865567f, 0.02310790f, -0.08939655f, -0.12914090f, 0.06598918f, 0.05979574f, -0.15929881f, 
    0.05150391f, 0.04246935f, -0.08843721f, 0.11816262f, 0.04453728f, 0.02711008f, -0.10528708f, 0.14114724f, 
    0.11467917f, 0.10346957f, -0.20426989f, -0.11454748f, 0.25590447f, 0.17676376f, -0.16510396f, -0.06094182f, 
    0.12253795f, -0.06017948f, 0.06896416f, 0.31201923f, -0.36055326f, 0.11792774f, -0.11677869f, -0.32097402f, 
    0.32933709f, 0.05702937f, 0.01849821f, 0.39933702f, 0.09784774f, 0.07524274f, 0.27339908f, 0.19773877f, 
    0.24630260f, 0.09868393f, -0.07542384f, 0.11140811f, -0.15244481f, -0.21065813f, 0.38720527f, 0.05268440f, 
    0.09649288f, 0.07795312f, -0.12529127f, 0.01506959f, -0.10034287f, 0.15384579f, 0.02738289f, 0.02444317f, 
    -0.06098603f, -0.19588226f, -0.20343086f, -0.12183694f, -0.05141715f, -0.09815245f, 0.51477504f, -0.15655798f, 
    -0.12312937f, 0.47072050f, 0.03262088f, -0.05127024f, -0.03021872f, 0.19977516f, 0.17500383f, 0.27065301f, 
    -0.02360296f, 0.28286088f, -0.29684025f, 0.03770390f, 0.22352661f, -0.25851423f, 0.23190878f, 0.13642257f, 
    -0.21031569f, -0.01334340f, 0.04789895f, 0.44269449f, -0.10388672f, -0.15087880f, -0.24709798f, 0.05876082f, 
    0.10086963f, 0.12008936f, 0.08262469f, 0.39500508f, 0.58713573f, -0.10662218f, -0.18533941f, 0.14829363f, 
    0.06655892f, 0.24396305f, 0.06655934f, -0.06226314f, 0.15359995f, 0.01343105f, 0.36699244f, -0.04625834f, 
    0.19375992f, 0.07539438f, 0.32601401f, -0.00053086f, -0.10137117f, 0.15913366f, -0.18176684f, 0.09294277f, 
    0.00201036f, -0.00691859f, 0.14778607f, -0.04110681f, 0.21579650f, 0.46262503f, 0.02126547f, -0.01092727f, 
    -0.07383992f, 0.37976834f, 0.02742261f, 0.32698900f, 0.42016074f, -0.16468118f, -0.02766661f, 0.60599494f, 
    -0.08367058f, 0.21272171f, -0.21257642f, 0.33911645f, -0.25585854f, 0.00087553f, 0.27929932f, 0.05186581f, 
    -0.06408268f, 0.02764069f, 0.01504872f, -0.08317818f, 0.01878242f, -0.10858590f, 0.00096571f, -0.04449852f, 
    -0.01577857f, -0.14428702f, 0.11667977f, -0.10501806f, -0.05740982f, 0.03106709f, 0.01499030f, -0.08770642f, 
    -0.06816509f, -0.16055676f, 0.05401092f, 0.11534464f, 0.06872202f, -0.02399306f, 0.02407866f, 0.05625443f, 
    0.07843545f, -0.11662336f, -0.05076470f, -0.02214861f, 0.06334570f, -0.02577696f, -0.01015716f, -0.08675013f, 
    -0.01566353f, -0.08806890f, -0.08642889f, -0.04988082f, -0.12162079f, -0.04909222f, 0.06526841f, 0.03829522f, 
    0.03023601f, -0.02317463f, -0.12887828f, -0.03801504f, -0.01343691f, 0.04780109f, -0.10451563f, -0.06627291f, 
    0.03930951f, 0.09259161f, -0.02439648f, 0.07285528f, 0.09242849f, -0.02469551f, 0.05738288f, 0.02927271f, 
    -0.07582137f, 0.05396905f, -0.13502443f, 0.06673934f, -0.00047355f, 0.06650567f, -0.11721184f, -0.03032153f, 
    -0.05417232f, 0.14419143f, 0.16855894f, 0.24689789f, 0.03038538f, 0.45675808f, 0.21626726f, 0.07391822f, 
    0.50298083f, -0.09024341f, -0.20391738f, 0.07838324f, -0.04486609f, -0.42976010f, 0.17753483f, 0.28346539f, 
    0.16432858f, -0.12780496f, 0.17953774f, -0.14898100f, -0.66458601f, 0.16086189f, 0.23121536f, -0.58529252f, 
    -0.08055978f, 0.16133308f, -0.05275968f, 0.23744978f, 0.28004909f, 0.08488055f, -0.04713527f, 0.04907758f, 
    0.01475025f, -0.34252778f, -0.16460854f, -0.04867890f, 0.16339169f, 0.10007711f, 0.13679491f, 0.05941449f, 
    -0.17410143f, 0.15054123f, -0.19709405f, 0.09486897f, -0.08117925f, -0.15932360f, -0.11815236f, 0.15873706f, 
    0.17192832f, -0.23802917f, 0.01284980f, 0.08507822f, -0.10556631f, -0.00470963f, -0.46526915f, -0.12085867f, 
    -0.06640665f, -0.54559183f, -0.02573543f, -0.15335025f, 0.19961284f, -0.11011234f, 0.07023054f, 0.28711385f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.11058187f, -0.02112063f, 0.21430777f, -0.09383848f, -0.04261467f, -0.06761473f, -0.15662540f, -0.02147510f, 
    0.10382487f, -0.15457608f, -0.13440709f, 0.41866478f, 0.12990718f, -0.16870077f, 0.21591927f, -0.13765493f, 
    0.16477026f, -0.21387178f, 0.04230435f, -0.08277543f, -0.12707981f, 0.00048050f, 0.01184159f, -0.08514099f, 
    0.09263796f, -0.27801722f, 0.00546408f, 0.17297159f, -0.02736538f, -0.07719430f, 0.15833375f, 0.05536479f, 
    -0.06508384f, 0.03352660f, -0.13630724f, 0.07433667f, 0.15199815f, 0.03188888f, -0.10754625f, 0.06491841f, 
    0.06155716f, -0.03327069f, 0.30799761f, -0.04789809f, 0.32922599f, 0.10063646f, 0.28292772f, 0.02554687f, 
    -0.12570296f, -0.10644919f, 0.06390168f, 0.22445673f, -0.11497401f, 0.05044184f, 0.08680262f, -0.10243824f, 
    -0.13214423f, 0.22565585f, 0.06341320f, -0.07803477f, 0.42955273f, 0.12781434f, -0.06372727f, 0.32311714f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.04739831f, 0.10509188f, 0.28020304f, -0.08835815f, -0.09297200f, -0.10743845f, -1.21887481f, -0.03223235f, 
    -0.64392883f, 0.03166952f, 0.11194451f, 0.01950162f, -0.99352962f, -0.43314067f, 0.45580739f, -0.09908902f, 
    -0.14750582f, -0.18690977f, -0.00185948f, 0.11955152f, 0.19218661f, 0.10396384f, -0.52207553f, 0.09246222f, 
    -0.12295202f, -0.21776840f, 0.13898872f, 0.06245432f, -0.35924229f, 0.10596602f, -0.17079461f, 0.29270318f, 
    0.04323236f, 0.03170807f, 0.10116082f, 0.11639109f, -0.31331223f, 0.01067913f, -0.00310591f, 0.23422258f, 
    0.22139166f, 0.13449521f, 0.01465314f, -0.98867810f, 0.21229172f, 0.01350414f, -0.15926158f, 0.02129892f, 
    0.12204300f, -0.22639930f, -0.03739344f, 0.12502605f, -0.89110821f, 0.03133716f, -0.25629586f, 0.01471114f, 
    -0.08179691f, 0.26827931f, -0.06633316f, -0.04278997f, 0.24734579f, -0.36478418f, 0.01982517f, 0.20561682f, 
    -0.02410990f, 0.01680268f, 0.04467217f, -0.02336628f, -0.09271391f, 0.00749287f, -0.83927393f, 0.01171764f, 
    0.13912673f, -0.14122996f, 0.00637335f, -0.19461165f, 0.13581432f, 0.41120118f, 0.15769042f, 0.04988933f, 
    0.35145026f, 0.62368727f, -0.03380657f, 0.08892220f, -0.21076770f, -0.04215918f, 0.42625564f, -0.07335389f, 
    0.26647303f, -0.31247362f, 0.12722568f, 0.31644428f, -0.37372023f, 0.05659084f, -0.11118974f, -0.41329041f, 
    0.03813161f, -0.00824590f, 0.06025682f, 0.06106010f, -0.11276303f, -0.26189932f, -0.04464184f, 0.19047721f, 
    0.09878724f, -0.07835004f, 0.00477831f, 0.14279541f, 0.10207940f, -0.18713577f, 0.00375849f, -0.00571650f, 
    -0.08433372f, 0.03078550f, -0.07974283f, 0.06486928f, -0.84740686f, -0.06080453f, -0.47887978f, -0.10695876f, 
    0.02873187f, -0.11691845f, -0.09561213f, -0.16749714f, 0.14235583f, 0.02125107f, 0.08373246f, 0.19592948f, 
    0.09456546f, -0.03514954f, -0.59882385f, -0.10477723f, -0.07603686f, -0.47337806f, 0.14262177f, -0.13211200f, 
    0.05943256f, -0.31856623f, 0.06887054f, -0.21896103f, 0.26966006f, -1.26139319f, -0.10483728f, -0.02725850f, 
    -0.59453726f, -0.31611231f, -0.11480629f, -0.03047121f, 0.17578743f, -0.05774413f, -0.02860011f, 0.12721847f, 
    0.26362610f, -0.51033956f, 0.03710805f, -0.26180518f, 0.09218565f, 0.03397857f, 0.35340661f, -0.52047521f, 
    -0.03358750f, -0.06670615f, -0.00208781f, -0.47094798f, -0.85228920f, -0.49735817f, -0.13808069f, 0.40651533f, 
    -0.01156526f, -0.04343752f, -0.06135197f, -0.50336975f, 0.39753890f, 0.13114072f, 0.20727974f, -0.23044388f, 
    -0.11811983f, 0.03820877f, 0.08730543f, -0.11144309f, -0.56555909f, -0.06662909f, 0.35081482f, -0.13120881f, 
    0.06792971f, -0.56166077f, 0.41909298f, 0.02533501f, -0.08666585f, 0.09501529f, -0.14442149f, -0.36513856f, 
    0.01802703f, 0.08449878f, 0.23879027f, -0.05995047f, -0.01944834f, 0.22329012f, -0.27272439f, 0.08239894f, 
    0.27616611f, -0.05004219f, -0.02907286f, -0.05684410f, 0.11375917f, 0.07809448f, 0.00930766f, 0.08009343f, 
    -0.00558442f, -0.64618903f, -0.03236278f, -0.08432785f, 0.15981036f, -0.28053263f, -0.15156856f, 0.04130299f, 
    0.15448797f, 0.16420105f, -0.13797566f, -0.19265500f, 0.17512010f, 0.08441450f, 0.01877598f, 0.10374671f, 
    0.08327657f, 0.07889851f, 0.04327274f, -0.16320026f, 0.06790016f, 0.20444520f, 0.01264547f, -1.12410033f, 
    -0.44044340f, -0.01909228f, -0.09954853f, -1.10300612f, -0.01166254f, 0.21843663f, 0.13942553f, 0.02074259f, 
    0.05847813f, -0.80500537f, -0.08890769f, -0.48074231f, -0.33198276f, -0.01800809f, -0.49015445f, 0.01561679f, 
    -0.01963707f, -0.21641780f, -0.01621546f, -0.04967204f, 0.14576840f, 0.06638934f, 0.05682788f, -0.65079540f, 
    0.11171095f, 0.03098197f, 0.13587405f, -0.03885676f, -0.11679395f, 0.03632239f, -0.83466136f, 0.09333189f, 
    -0.23436531f, -0.22306949f, 0.01821702f, -0.03888234f, -0.42984840f, -0.19018243f, 0.07736420f, 0.00149153f, 
    -0.37663740f, -0.32060698f, -0.08313955f, 0.10334390f, 0.19660060f, 0.06636419f, -0.68821836f, 0.04717579f, 
    -0.40734980f, 0.08124460f, -0.11061885f, -0.32991320f, 0.17539430f, -0.10232757f, -0.00809387f, 0.28563285f, 
    0.00217311f, 0.00219908f, -0.07773162f, 0.10970841f, 0.29006460f, 0.16306947f, 0.00088226f, 0.07873990f, 
    0.22019322f, -0.13984838f, 0.04196451f, -0.25618303f, -0.10839454f, -0.16617849f, -0.09654346f, 0.07773353f, 
    0.08884228f, -0.04522119f, -0.11375006f, -0.11386575f, -0.96454990f, -0.09546058f, 0.41892281f, -0.03429698f, 
    -0.07930743f, 0.09962213f, 0.05206082f, -0.02672317f, -0.05696489f, -0.09844816f, -0.08505833f, 0.02281607f, 
    -0.07399353f, -0.04881750f, -0.03118609f, 0.12069689f, -0.15197018f, 0.01523218f, -0.67064387f, -0.10098505f, 
    0.08805643f, 0.47665933f, -0.08854938f, 0.30303535f, 0.58368224f, -0.24402691f, -0.38128862f, -0.01384147f, 
    -0.13500324f, -0.68708599f, 0.00137906f, 0.02552525f, -0.02041579f, 0.07546231f, 0.31236655f, 0.07664904f, 
    -0.28711143f, -0.73023731f, -0.14253588f, 0.12134792f, -0.47320777f, 0.05406710f, -0.13661121f, -0.10988218f, 
    -0.12695533f, 0.11373351f, -0.09112385f, 0.28954917f, 0.22161315f, -0.13612077f, -0.13414624f, 0.01085206f, 
    0.10760922f, -0.36436909f, 0.10526305f, 0.22006015f, -0.03899078f, -0.00601092f, -0.15694809f, -0.11361603f, 
    0.11154925f, 0.04613140f, 0.00384820f, 0.26409751f, -0.20294075f, 0.01392112f, -0.06291865f, -0.06966463f, 
    -0.04753386f, 0.03107259f, -0.17512847f, -0.18227024f, 0.04200773f, -0.37504902f, -0.09017682f, 0.13653034f, 
    -0.01313815f, 0.07982334f, -0.31531000f, -0.06661226f, 0.03049318f, 0.24458680f, -0.31952086f, -0.02952542f, 
    -0.03384071f, -0.78038979f, 0.10422777f, 0.14663494f, -0.48222497f, -0.31474614f, -0.34724733f, 0.08950322f, 
    -0.13973469f, -1.00219703f, 0.02890749f, 0.03627719f, -0.00357075f, 0.07237229f, 0.00965023f, -0.06925945f, 
    -0.34774798f, -0.10781531f, -0.02594251f, -0.01952183f, -0.12425466f, -0.07617600f, -0.48054022f, -0.07116126f, 
    0.02505112f, -0.11476733f, 0.10794544f, 0.24227624f, -0.53053457f, 0.17691343f, 0.03760701f, -0.60145134f, 
    -0.40565407f, -0.70154154f, 0.09482577f, 0.09309002f, 0.12233376f, 0.29070932f, 0.01699909f, 0.18979840f, 
    0.05997660f, 0.17030817f, 0.02662496f, 0.10292625f, 0.50918341f, -0.11083261f, 0.28693986f, -0.04398735f, 
    -0.17788263f, 0.36058179f, -0.16125491f, -0.08783273f, 0.09845238f, 0.16642694f, -0.02351568f, -0.02646297f, 
    -0.10251226f, -0.05792097f, 0.12746888f, -0.03459996f, -0.12960835f, 0.09553046f, -0.06698130f, -0.00695801f, 
    0.12019014f, 0.31531850f, -0.00669275f, -0.62073237f, -0.14224550f, 0.17358460f, 0.02600164f, -0.03351450f, 
    -0.19340478f, 0.38935187f, -0.10125767f, -0.01047757f, 0.08037575f, -0.38810229f, -0.11665822f, -0.05623266f, 
    -0.17073767f, 0.03551272f, 0.05195423f, 0.23748904f, 0.04920262f, -0.04072854f, -0.26845866f, 0.14425972f, 
    -0.11015265f, 0.03595526f, -0.13260996f, 0.11267646f, -0.04699493f, -0.06332055f, -0.01721110f, -0.51103908f, 
    -0.04144379f, 0.11673392f, -0.35565206f, 0.62457430f, -0.37744942f, -0.68128204f, -0.18357836f, 0.06497815f, 
    0.01431686f, 0.03162098f, -0.01089814f, 0.07331260f, 0.79900622f, -0.10487548f, -0.24530214f, -0.01093226f, 
    -0.16551518f, -0.48903549f, -0.79433346f, -0.09837479f, 0.03349340f, -0.58801067f, -0.02158507f, -0.06555256f, 
    0.03995563f, 0.04600740f, -0.25952110f, 0.02474804f, -0.00915310f, 0.01904811f, 0.12064391f, -0.07765064f, 
    0.43216032f, 0.36401299f, -0.04831803f, -0.07750206f, -0.19334911f, -0.16896695f, -0.48268482f, 0.02670365f, 
    0.34312108f, -0.79407567f, 0.05526578f, 0.01188125f, -0.73621249f, 0.11251348f, -0.14616437f, -0.08224011f, 
    -0.18311778f, 0.22525935f, 0.00776771f, 0.19697189f, 0.15523413f, -0.06137763f, -0.11442900f, -0.26008517f, 
    -0.06074538f, -0.05128032f, -0.04467869f, -0.08531815f, -0.49816409f, -0.32983631f, -0.09831341f, 0.18794236f, 
    0.23332228f, -0.02982593f, 0.19765390f, 0.24504252f, -0.97338217f, 0.01905873f, 0.08854084f, -0.72184825f, 
    -0.06447189f, 0.22631010f, 0.10119019f, -0.15703855f, 0.55200958f, 0.03431737f, -0.40321851f, 0.07242490f, 
    -0.10379080f, -0.56882435f, -0.32223511f, 0.05867398f, -0.52757972f, 0.12293696f, 0.10942090f, 0.16975385f, 
    0.12557082f, 0.01934121f, 0.04525754f, -0.13004632f, -0.11967512f, 0.09092925f, -0.03526661f, -0.03901460f, 
    -0.54082900f, -0.06880916f, -0.05574956f, 0.09210429f, -0.57022482f, 0.06813560f, -0.03216955f, 0.04537270f, 
    -0.24228811f, 0.02091191f, 0.02070150f, -0.04942556f, 0.11332272f, 0.21485920f, 0.04699098f, -0.11196236f, 
    0.10703516f, 0.14065714f, -0.07104109f, -0.27606669f, -0.09868073f, -0.11155682f, -0.17056732f, 0.23537213f, 
    -0.06334788f, -0.04904629f, -0.08757741f, 0.07341785f, 0.07756902f, 0.20229219f, 0.15408650f, 0.12207431f, 
    -0.29825294f, -0.11836469f, -0.05823672f, 0.20991765f, -0.21616936f, 0.15674908f, -0.46539652f, -0.07017674f, 
    -0.00742677f, 0.17850536f, -0.05437964f, -0.33905196f, 0.28628290f, 0.00977498f, 0.25513744f, 0.02945404f, 
    -0.16877641f, 0.27499938f, 0.08014849f, 0.06408865f, -0.22262426f, -0.05762468f, -0.03398018f, 0.06552210f, 
    0.04960870f, -0.12780637f, 0.10329973f, 0.03816883f, -0.10220190f, -0.44366509f, 0.02730944f, 0.10785040f, 
    -0.21178709f, -0.08210947f, -0.05114876f, 0.37175426f, 0.02509140f, 0.13027041f, -0.09902184f, -0.01340178f, 
    0.29369074f, -0.02342100f, 0.10885706f, 0.11272114f, -0.15606897f, -0.19832467f, 0.24751820f, 0.05742889f, 
    0.34473255f, 0.03258947f, -0.01967233f, -0.38036543f, 0.27966458f, 0.02869681f, 0.36227471f, -0.26899776f, 
    0.06783674f, -0.10187244f, 0.09846450f, -0.71386260f, 0.34175819f, -0.01022021f, 0.04477200f, -0.51935112f, 
    -0.32266814f, 0.11346918f, -0.12058406f, -0.19013944f, 0.22161710f, -0.48178074f, 0.37186283f, -0.00085270f, 
    -0.07679945f, -0.41371027f, -0.01802430f, -0.70433545f, -0.33875719f, 0.05079229f, -0.52283031f, 0.10088342f, 
    0.02973983f, -1.03811944f, 0.03133856f, -0.04987190f, 0.11328660f, 0.15808901f, -0.08601484f, 0.16365613f, 
    0.05507921f, 0.05832640f, -0.02367239f, -0.00942468f, -0.08954710f, -0.04392419f, 0.25590092f, -0.14014541f, 
    0.23888630f, -0.38109383f, -0.05036612f, 0.01924385f, 0.35890543f, -0.35292852f, -0.21570866f, -0.13027355f, 
    0.30090684f, -0.03238373f, 0.07694740f, -0.04009447f, 0.11116401f, 0.07647403f, -0.17721388f, -0.04019038f, 
    0.24395193f, 0.12572177f, -0.03657521f, 0.04312000f, 0.02036627f, 0.07143429f, 0.13761668f, 0.01552288f, 
    -0.00707109f, 0.02358267f, 0.11081249f, -0.45001307f, -0.36724460f, 0.00541453f, -0.17771035f, -0.08665649f, 
    -0.27989754f, 0.19099747f, -0.05592162f, -0.20539480f, -0.17948191f, 0.13029996f, 0.01033706f, -0.09358682f, 
    -0.07272868f, 0.13642883f, 0.11618790f, -0.42767087f, -0.10952079f, -0.08193654f, 0.17157513f, 0.03745816f, 
    -0.04711495f, 0.24204290f, 0.11455012f, 0.00652928f, -0.07993758f, 0.21419203f, -0.11158238f, -0.24025656f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.24643348f, -0.04407582f, -0.19268434f, 0.02293750f, 0.00572392f, 0.09525803f, 0.06577317f, -0.46122694f, 
    -0.06072935f, -0.22497296f, 0.10293954f, 0.07849220f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
