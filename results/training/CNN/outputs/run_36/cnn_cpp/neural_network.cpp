#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.09297717f, 0.90995252f, 0.22894929f, 0.41303071f, -0.69487739f, 0.40983719f, -0.87376148f, 0.07835079f, 
    -0.48075274f, -0.69743121f, -1.32787621f, 0.41479841f, 0.55114144f, 0.64494675f, 0.49138209f, -0.53861129f, 
    -0.47745073f, -0.35778621f, -1.20691550f, 0.17881677f, -0.70350111f, 0.46719813f, 0.54131633f, -0.57212383f, 
    -0.33116063f, -0.24882874f, 0.08781561f, 0.97341955f, -0.30430230f, -1.04424965f, 0.79998904f, -0.15452529f, 
    -0.89203852f, -0.13687658f, -0.41603956f, -0.35142818f, -0.36885166f, -0.02138076f, 1.00447786f, -1.27881587f, 
    -0.38653564f, -0.18520387f, -0.08772442f, 0.51724654f, -0.41023460f, 1.00825179f, 1.11489010f, 0.30888221f, 
    -0.38292417f, 0.20868319f, 0.35907480f, 0.70834827f, 0.49143404f, -0.53361052f, -1.17685080f, 0.44770920f, 
    0.64452934f, 0.69832689f, -0.35077587f, -1.09377944f, 0.03532541f, -0.11399812f, 0.10742162f, 0.66362637f, 
    -0.44024429f, -0.65739101f, 0.77238053f, 0.90865618f, -0.19150037f, -0.13732879f, -0.39193329f, 0.39739966f, 
    1.10126209f, -0.76368046f, -0.29845741f, 0.12512152f, -0.64930224f, -0.72405511f, -0.50286543f, -0.09160829f, 
    0.54962790f, 1.17606866f, 1.09906876f, 0.43712780f, 0.10259404f, -0.32168317f, -0.95673537f, 0.38315964f, 
    -0.04046312f, 0.23743074f, 1.14362800f, -0.74313378f, -0.13330397f, 0.77033848f, -0.17183097f, 0.29996994f, 
    0.14666381f, 0.38811246f, -0.39154637f, 0.20877925f, -1.16689610f, -0.46225181f, -0.05044829f, 0.41493702f, 
    -0.93763566f, -0.64037144f, 0.48009256f, 0.00304570f, 0.64303809f, -1.00926280f, 0.85840845f, -0.78920305f, 
    0.66958880f, 0.65004122f, -0.15671201f, 0.25215110f, 0.37976000f, -0.01135461f, 0.66048408f, 0.68162805f, 
    -0.33401516f, 0.28936103f, 0.33981663f, 0.03367026f, -0.45197231f, -0.70327413f, 0.63867360f, 0.59297609f, 
    0.89325941f, 0.45943779f, -1.28569102f, 0.42063364f, 0.18101822f, 0.10142401f, 0.36921939f, -0.31171155f, 
    0.10420059f, 0.27239448f, -1.01376128f, 0.03545777f, 0.84353626f, 0.56725216f, 0.36388156f, -0.65873772f, 
    -0.40900573f, -0.68493879f, -0.34273496f, 0.32854030f, 0.81091070f, -0.74789685f, 0.16751818f, 0.86054957f, 
    0.15586732f, -0.74673265f, 1.16571558f, -0.55957216f, -0.81291908f, 0.72046030f, -0.75088549f, -0.14175098f, 
    -0.19115666f, -0.15459724f, -0.81005257f, -0.87312067f, -0.18694390f, -1.05293548f, -0.91553009f, -0.45051482f, 
    0.58954227f, 0.05059999f, 0.47898057f, -0.70692885f, -0.29492259f, -1.22381532f, -1.01670659f, 0.63372499f, 
    0.69366831f, 0.21044564f, -0.16034029f, 0.03099499f, -0.22405754f, -1.32275093f, 0.43578380f, -0.57551020f, 
    0.27832857f, 0.55982947f, 0.31382450f, -0.04256599f, -0.34089109f, -0.78775156f, -1.02705264f, -0.28366110f, 
    -0.76543289f, 0.40712312f, 0.49563801f, 0.45335189f, -0.23518717f, 0.23172824f, 0.73882109f, 0.79653585f, 
    0.33097216f, 0.79693621f, 0.45854703f, 0.55161440f, 0.11258349f, 0.55177516f, 0.37209231f, -1.32793331f, 
    1.04007375f, -0.04818542f, -0.36661127f, 0.84263700f, 0.47262433f, -0.28057501f, -0.07763309f, 0.40467513f, 
    -0.97288215f, -1.24920642f, -0.87429315f, 0.40112686f, 0.44137949f, 0.76850301f, -0.27862605f, -0.09434360f, 
    0.02676193f, 0.98515666f, 0.94248879f, 0.52143925f, 0.15720391f, 0.70086920f, -0.44153357f, -0.35911432f, 
    0.25457978f, -0.40578178f, -0.85290384f, 0.30702302f, 0.09232955f, 1.21658516f, 0.77579969f, 0.83951622f, 
    0.33007663f, -0.44664016f, -0.24553907f, -0.95244998f, 1.59961414f, -0.36431006f, 0.66438061f, -0.50959390f, 
    -0.30361128f, -0.04368915f, -0.17519099f, -0.46412873f, -0.37726766f, -1.19908166f, -0.64391947f, 0.02248728f, 
    0.83998251f, -0.22157802f, 0.38556397f, 0.14981633f, -0.46922052f, -0.39353934f, 0.64255714f, 0.87088311f, 
    -0.02957788f, 0.37690431f, -0.08331322f, -0.48765606f, -0.31064177f, 0.52076000f, 0.34343866f, 1.05582678f, 
    0.71737564f, -0.29444745f, 0.77756798f, 0.27567065f, -0.35540402f, 0.01934044f, -0.26003963f, 1.05664182f, 
    -0.32212639f, 1.34119022f, -0.95959461f, -0.54337090f, -0.79497635f, 0.31137130f, -0.13488565f, -0.29706579f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.07147152f, 0.11103088f, -0.15633930f, -0.02315321f, 0.15119979f, -0.10430298f, -0.19953735f, 0.15263724f, 
    -0.02529197f, -0.08012538f, 0.18067159f, 0.23690520f, 0.11032575f, 0.01320753f, 0.14831454f, -0.15265360f, 
    0.06109864f, -0.12215670f, 0.08735895f, 0.12975428f, 0.03898101f, 0.07948002f, 0.07196566f, -0.02589301f, 
    0.23663178f, 0.36589238f, 0.21188501f, -0.11141828f, 0.12979476f, 0.04023711f, 0.33814865f, 0.01600939f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03415829f, 0.09327903f, 0.18782707f, 0.10322002f, -0.01688168f, -0.03048543f, -0.08522179f, 0.06503687f, 
    -0.02823442f, 0.05469076f, -0.05963026f, -0.06423907f, 0.05860606f, -0.04870298f, -0.06416667f, 0.05592154f, 
    0.07478960f, -0.13767813f, -0.13100792f, 0.07733344f, -0.15804444f, 0.11220590f, 0.21696520f, 0.01174516f, 
    -0.35608101f, 0.08734283f, 0.03002413f, 0.03224988f, 0.09055165f, -0.04874608f, -0.00150932f, 0.00663347f, 
    -0.02546114f, -0.05422944f, -0.00368340f, 0.02229242f, 0.07170333f, 0.00360458f, -0.01686200f, 0.05777518f, 
    0.72956699f, 0.10558164f, 0.12650414f, -0.02219578f, -0.22920708f, 0.15902525f, -0.02730968f, -0.10890887f, 
    -0.04376949f, -0.03593312f, 0.14035888f, -0.13304940f, -0.15070033f, 0.08783118f, -0.00748282f, 0.04147365f, 
    0.04406113f, -0.01135892f, -0.02454687f, 0.03137932f, 0.06352860f, -0.49624676f, 0.22748424f, 0.17788611f, 
    0.28298792f, -0.08245421f, -0.10738465f, 0.03633735f, 0.04309922f, -0.08807760f, 0.03160899f, -0.01595105f, 
    0.05341011f, 0.01985210f, -0.04080748f, 0.03335044f, 0.05687354f, 0.01212050f, -0.02646717f, -0.00612779f, 
    -0.00623386f, -0.12721558f, -0.18984112f, 0.16784261f, -0.07012613f, -0.07830586f, 0.07195663f, -0.01144670f, 
    0.05462160f, -0.07260630f, 0.06622719f, 0.00419925f, 0.06061786f, -0.03035691f, -0.05030641f, 0.09755620f, 
    -0.01320798f, -0.05455984f, -0.08118883f, -0.01520351f, 0.08926112f, 0.20710626f, 0.04397562f, -0.13862631f, 
    0.37312141f, -0.07763122f, -0.03483215f, -0.01722483f, 0.03254959f, 0.04496367f, -0.10502144f, -0.02397908f, 
    0.01404134f, -0.02471719f, 0.08930983f, -0.08398597f, -0.06774256f, -0.05023187f, 0.00485117f, -0.04514091f, 
    -0.26852053f, -0.14144763f, 0.18794544f, 0.01167349f, -0.03063493f, 0.06576677f, -0.31801376f, 0.05507814f, 
    -0.20333445f, 0.07097992f, -0.03502278f, 0.11080679f, 0.01085463f, 0.11986126f, -0.15084176f, 0.01770550f, 
    -0.13772957f, 0.04943554f, -0.05259073f, -0.14429264f, -0.16275060f, 0.16644368f, 0.09857333f, 0.01805630f, 
    0.11273777f, -0.12594275f, -0.02760352f, 0.03992798f, -0.07986133f, -0.15157920f, 0.04601619f, 0.04796712f, 
    -0.02806547f, -0.02632382f, -0.00614059f, 0.02869913f, -0.00828149f, 0.03042344f, -0.10369603f, 0.04631748f, 
    0.10111488f, -0.54487187f, 0.39028254f, 0.20950677f, -0.06593876f, -0.00329380f, -0.08256275f, -0.02675556f, 
    0.07539441f, 0.02191037f, -0.25870124f, 0.13206621f, -0.04348020f, 0.09553457f, 0.01339489f, -0.01983780f, 
    -0.05720928f, -0.08289538f, -0.00088225f, -0.15707310f, 0.07108197f, 0.15634747f, 0.01614771f, -0.23257111f, 
    0.08388189f, -0.27480206f, -0.03284051f, 0.03311938f, 0.09906697f, -0.07490353f, 0.07820954f, 0.02254746f, 
    -0.01970523f, -0.03671930f, -0.11934052f, 0.13238396f, 0.01288147f, 0.11810828f, 0.03352735f, 0.00226555f, 
    0.30959424f, -0.29670277f, 0.03445729f, -0.04641020f, -0.06164056f, 0.03265443f, 0.00827875f, -0.05317274f, 
    0.05001602f, -0.09140011f, -0.13605109f, 0.06366049f, 0.08894431f, 0.00036727f, -0.01763136f, 0.10891394f, 
    -0.04782865f, -0.00069773f, -0.02689670f, 0.06676645f, -0.35684386f, -0.57652688f, 0.10855608f, 0.13094196f, 
    -0.33490217f, 0.01004823f, -0.12427585f, 0.09435298f, -0.04869399f, 0.01773010f, -0.12354314f, 0.05012178f, 
    0.06402195f, -0.01961730f, -0.00243346f, -0.24654768f, -0.04846731f, 0.00933946f, -0.07123099f, -0.00609262f, 
    0.17018874f, -0.13459043f, -0.12294344f, 0.02644430f, -0.28058371f, -0.02913317f, 0.11121064f, 0.09651342f, 
    -0.00760484f, -0.14454883f, 0.03885664f, 0.03020683f, 0.03382600f, -0.02503590f, 0.07129198f, -0.05375250f, 
    -0.13264127f, 0.01045410f, -0.09500895f, 0.02838050f, -0.02373399f, 0.01361271f, 0.05328137f, 0.00356262f, 
    0.27203310f, -0.09603345f, -0.17874593f, 0.02587827f, -0.01659749f, 0.09375473f, 0.07878989f, 0.04949338f, 
    0.00238566f, -0.10681143f, -0.01121295f, 0.11234788f, -0.02763734f, -0.16309194f, 0.04298655f, 0.08983420f, 
    -0.01572987f, -0.08620295f, 0.08931946f, -0.08407743f, -0.09913319f, -0.10095799f, -0.04805314f, 0.00645573f, 
    -0.05745944f, 0.03270565f, -0.05667081f, -0.07988080f, -0.04359100f, -0.00480810f, -0.01081594f, 0.02118125f, 
    -0.00119116f, -0.05845152f, -0.11471961f, 0.06055298f, -0.43620482f, 0.05173814f, -0.01676706f, 0.09863935f, 
    0.11595841f, -0.10526393f, -0.03910906f, -0.08870851f, -0.14459524f, 0.09048384f, 0.02238183f, 0.02746355f, 
    0.19114198f, 0.05780022f, -0.02768972f, -0.00814505f, -0.01593090f, -0.05312387f, 0.05073775f, -0.10700678f, 
    -0.18167675f, -0.01761984f, 0.00391820f, -0.04160909f, -0.16869628f, -0.05217064f, -0.06165700f, -0.01851046f, 
    0.11142486f, -0.03361290f, 0.01932854f, 0.16664998f, 0.11930593f, -0.10581034f, 0.03488163f, -0.07342263f, 
    0.03210175f, 0.08700135f, 0.04270837f, -0.02018302f, 0.31081927f, -0.10596484f, 0.14869817f, -0.01262223f, 
    0.13353366f, 0.12074649f, 0.05306451f, 0.00816841f, -0.12967053f, 0.06984887f, -0.04363058f, 0.09439009f, 
    -0.06756300f, -0.15005593f, 0.02547661f, -0.01365274f, -0.02714323f, 0.15497446f, 0.06072298f, -0.04474141f, 
    -0.29019529f, -0.67102075f, -0.10473550f, 0.09815117f, -0.12280908f, 0.05036475f, -0.05133347f, 0.00645287f, 
    0.09769052f, -0.00040285f, -0.03278767f, 0.02245419f, -0.07425788f, -0.04174423f, 0.00973717f, 0.05137151f, 
    0.07815783f, -0.00101016f, 0.05913673f, -0.07998721f, -0.29223692f, 0.40673941f, -0.10401280f, -0.15313107f, 
    -0.18578678f, 0.05014836f, 0.02748567f, -0.06013868f, 0.01588942f, 0.02252457f, 0.00126657f, 0.00494176f, 
    -0.03484739f, 0.09178618f, 0.00536736f, -0.04417229f, -0.01509742f, -0.02882130f, 0.01107926f, -0.09671303f, 
    -0.19030979f, -0.03907496f, -0.16948587f, 0.07164415f, -0.38869953f, -0.09130544f, 0.01310206f, -0.02086433f, 
    0.08640524f, 0.00824540f, 0.08277801f, -0.06574076f, -0.23483911f, -0.00670094f, 0.04792826f, -0.06503054f, 
    -0.04283122f, -0.05045847f, 0.04338442f, 0.11253066f, -0.45782465f, 0.18111360f, -0.21078341f, 0.03704062f, 
    -0.20605592f, -0.04114969f, -0.10266350f, -0.10500804f, 0.03232976f, -0.02923626f, -0.01145866f, -0.06139575f, 
    -0.09277076f, 0.07198342f, 0.07285387f, -0.05892139f, -0.11303773f, -0.04413107f, 0.10363272f, -0.00654082f, 
    -0.01029093f, -0.25435689f, -0.10530221f, -0.11244566f, 0.17041573f, -0.05215795f, -0.08780865f, 0.06940120f, 
    -0.04201424f, 0.04522391f, -0.04239489f, -0.04218405f, -0.03626855f, 0.07880984f, -0.00680877f, -0.02274419f, 
    -0.05696938f, -0.01722764f, -0.07992318f, 0.08835375f, 0.46471483f, 0.26233768f, 0.13876967f, -0.25016734f, 
    0.15977867f, 0.08354488f, 0.01238885f, -0.02577281f, 0.04196239f, -0.05312741f, 0.03513261f, -0.09925750f, 
    0.05712567f, -0.01938838f, 0.08374456f, 0.00634145f, 0.01346599f, 0.00044754f, 0.10848578f, -0.03228278f, 
    -0.04316414f, 0.15526770f, -0.09855062f, -0.24314249f, -0.42161635f, 0.14804651f, 0.06728906f, -0.09650486f, 
    0.03112050f, -0.07423083f, -0.01047655f, -0.02475690f, -0.02257494f, 0.04699502f, 0.00961843f, 0.05300073f, 
    -0.06296025f, 0.04609902f, -0.00210516f, 0.01231300f, 0.06355885f, 0.14360595f, 0.01560186f, -0.17765996f, 
    0.24228558f, -0.08136916f, -0.13659357f, -0.05978282f, 0.05173673f, 0.02632788f, -0.05537752f, 0.04305463f, 
    -0.01091068f, 0.00776369f, -0.02310000f, -0.02818404f, -0.01169083f, -0.02853971f, 0.01579890f, -0.00003871f, 
    0.31953388f, -0.02754703f, 0.23348930f, -0.11831711f, -0.12173555f, 0.00923822f, 0.12609738f, 0.06445342f, 
    -0.04325087f, -0.08560651f, -0.05772524f, -0.05410369f, -0.01654801f, 0.07217433f, 0.05487316f, 0.01963988f, 
    0.06337957f, -0.13512382f, 0.10122345f, -0.01550138f, 0.11689482f, 0.33558002f, 0.27608809f, -0.06230110f, 
    0.11044806f, -0.20434661f, -0.19464558f, 0.11682596f, -0.13509721f, 0.01924849f, 0.02026815f, 0.13508120f, 
    -0.03097678f, -0.01476253f, -0.06103024f, -0.07297192f, 0.01676361f, 0.11018642f, -0.13680799f, -0.19860889f, 
    -0.30042678f, -0.01332774f, -0.06803020f, -0.04153788f, -0.41832146f, 0.02936930f, 0.00362767f, 0.00383062f, 
    0.11234877f, -0.06874419f, -0.05366912f, 0.09380838f, -0.04386677f, -0.02144590f, 0.02311113f, 0.05885876f, 
    0.14309737f, 0.10516315f, -0.00105524f, 0.05877783f, -0.08288646f, 0.01836203f, 0.05680996f, 0.13026233f, 
    0.10507759f, -0.16436362f, -0.00069645f, -0.00788603f, -0.01704237f, 0.01463424f, -0.03211259f, -0.07571995f, 
    0.03616415f, -0.03132627f, -0.08143102f, -0.03763086f, -0.00467444f, 0.02894505f, -0.01246912f, 0.08129757f, 
    -0.01827543f, 0.12034007f, 0.05362929f, -0.10129604f, 0.30813658f, -0.18771663f, -0.13386597f, -0.02975328f, 
    -0.00586704f, 0.00112881f, 0.02667428f, -0.06914979f, -0.02028160f, -0.13230416f, -0.01198614f, 0.05827263f, 
    0.11446166f, -0.04614063f, -0.03335034f, -0.00753705f, 0.36309567f, -0.05036168f, -0.01176971f, 0.09762296f, 
    -0.22491102f, -0.29876620f, -0.17743517f, -0.03906011f, 0.04090318f, 0.05640756f, -0.08490667f, 0.09527861f, 
    -0.08564217f, -0.02910454f, -0.06650980f, -0.03737231f, -0.04416707f, 0.17899852f, 0.09697547f, 0.11182028f, 
    0.20482694f, -0.06570094f, -0.08753753f, 0.07708565f, 0.33713356f, -0.06208796f, -0.04935522f, -0.02971350f, 
    -0.01245423f, -0.00008187f, 0.09671666f, 0.03680543f, -0.00058390f, -0.06837340f, 0.03669843f, 0.00589174f, 
    -0.05510752f, 0.03491765f, 0.04476950f, -0.07510168f, 0.06224072f, 0.03843293f, -0.13848902f, 0.09583461f, 
    -0.28992689f, 0.02797601f, 0.02556411f, -0.06754007f, -0.15765619f, 0.00282131f, 0.07811020f, 0.12752913f, 
    -0.10831510f, -0.03617289f, 0.06072376f, -0.05039142f, 0.02378931f, 0.00694840f, 0.03263760f, -0.02542302f, 
    -0.59876174f, -0.00531203f, -0.22568293f, -0.05687069f, -0.01119890f, 0.11687392f, -0.07893269f, 0.01504619f, 
    0.16731168f, -0.00257652f, -0.01430853f, 0.10085793f, -0.02026841f, -0.20810036f, -0.01328566f, -0.03643214f, 
    -0.04402848f, -0.05645161f, 0.06760284f, -0.26456994f, 0.09429237f, -0.33720848f, -0.06319735f, -0.37962979f, 
    -0.13877240f, 0.06859785f, 0.00034071f, -0.10692848f, -0.08020673f, -0.03432785f, -0.15972824f, -0.02983535f, 
    -0.05081972f, -0.09028754f, -0.06413104f, -0.01093658f, 0.00589457f, -0.21469182f, 0.04548894f, 0.01370938f, 
    -0.62932694f, 0.02691000f, -0.13847490f, -0.06378381f, -0.32395869f, 0.01492611f, 0.01391255f, -0.05232138f, 
    -0.02662857f, -0.00462233f, -0.10551894f, -0.06452812f, -0.06238509f, 0.05165885f, -0.04631820f, -0.12417965f, 
    -0.01747634f, -0.00680614f, -0.11769947f, 0.09500508f, 0.27703819f, 0.08841362f, 0.13004549f, 0.08996791f, 
    0.04446882f, -0.22166759f, -0.07474799f, -0.02505625f, -0.01525229f, -0.04204466f, 0.00117487f, -0.00184314f, 
    -0.04874141f, 0.08928188f, -0.16945994f, 0.03454809f, 0.07656659f, 0.01935681f, -0.06197727f, -0.02626546f, 
    -0.33409756f, -0.29589680f, 0.02725217f, -0.07731817f, -0.16393100f, 0.10879160f, 0.06965610f, 0.13030000f, 
    -0.03456023f, 0.02085012f, -0.00867899f, -0.08207660f, -0.01450515f, -0.05618818f, -0.10625572f, -0.01038063f, 
    -0.10188771f, -0.08817149f, 0.06309898f, 0.08985504f, 0.24069345f, -0.45687893f, -0.05170701f, -0.06850575f, 
    -0.12763543f, 0.02338213f, 0.05482623f, -0.11243184f, 0.09285654f, 0.00203034f, 0.04267772f, 0.07732508f, 
    -0.08051306f, 0.03511034f, -0.04773696f, -0.00666969f, 0.11136917f, -0.14345901f, 0.09215744f, -0.05250785f, 
    0.15356249f, -0.32716656f, -0.01451385f, -0.28845087f, 0.00321698f, -0.04592821f, 0.01110756f, 0.14377122f, 
    -0.08300739f, -0.12358822f, 0.07693996f, -0.03923417f, 0.11027425f, -0.09316655f, 0.10956308f, -0.11309575f, 
    -0.06214075f, -0.25718993f, 0.01688348f, -0.19071320f, 0.21136691f, -0.17612559f, 0.17699473f, -0.02486496f, 
    0.13663550f, -0.08484973f, -0.16923003f, 0.03460497f, 0.00154085f, -0.02253739f, -0.12013038f, -0.00876500f, 
    0.10006730f, 0.03170222f, 0.04966228f, -0.06794479f, 0.02018329f, -0.06778302f, -0.10744703f, -0.01977881f, 
    0.25099036f, -0.22775476f, 0.23012736f, -0.02320565f, 0.04936841f, -0.05112468f, 0.01108608f, -0.06646326f, 
    0.01603813f, -0.04436330f, 0.04925383f, -0.11002608f, -0.03149806f, 0.03436298f, -0.14350627f, 0.09443499f, 
    0.01799558f, -0.07042716f, 0.07468690f, 0.07763163f, 0.35213962f, -0.32750240f, 0.01409493f, -0.09840416f, 
    0.00805489f, -0.05829750f, 0.07559901f, 0.06367428f, 0.12651071f, 0.10371365f, 0.02416491f, -0.05686631f, 
    0.09692891f, 0.04540007f, -0.01004687f, 0.03984125f, 0.03707877f, -0.04863663f, -0.06200336f, 0.07630762f, 
    -0.04751517f, 0.00484435f, 0.07817658f, 0.07208794f, 0.15189099f, -0.02855775f, -0.07802540f, -0.03876974f, 
    -0.07376998f, 0.09421098f, 0.02185774f, 0.04889978f, -0.08918635f, -0.11210920f, -0.04104216f, 0.00189741f, 
    -0.12514740f, 0.08187445f, 0.08441141f, 0.06360531f, -0.02680340f, 0.26384664f, -0.02306877f, 0.03911887f, 
    0.16832121f, 0.01140956f, 0.03737830f, -0.01528083f, 0.01399847f, 0.03031913f, -0.06431733f, -0.00344078f, 
    -0.11134498f, -0.06248757f, -0.04381690f, 0.00779748f, -0.04580655f, 0.10434608f, -0.09391454f, -0.03066667f, 
    0.07963768f, 0.10156107f, 0.05713696f, 0.06591948f, 0.21458794f, -0.12235285f, -0.14947422f, 0.07064251f, 
    -0.04638594f, 0.07291054f, 0.02803292f, -0.00601425f, 0.16152126f, 0.11144582f, -0.07602315f, 0.04302839f, 
    0.00798734f, 0.00607116f, 0.07178283f, 0.09870098f, -0.30916312f, -0.01801429f, -0.09940128f, -0.01701763f, 
    0.09673849f, -0.03723908f, -0.02371410f, -0.15123683f, 0.27460960f, -0.19094262f, 0.02519658f, -0.02032608f, 
    -0.07869046f, 0.09041183f, -0.24540058f, -0.07270296f, -0.05281711f, 0.01983388f, 0.11795895f, 0.06627637f, 
    0.04141780f, -0.23114981f, -0.00412278f, 0.01735893f, 0.00485343f, -0.03441002f, 0.02077493f, -0.04862036f, 
    0.03840161f, 0.13705739f, -0.02190228f, -0.08986052f, 0.02584354f, -0.04289956f, -0.10267325f, 0.13061793f, 
    0.08479427f, 0.00861358f, 0.00410000f, 0.10994013f, -0.16609228f, -0.04467822f, -0.43081740f, -0.43921083f, 
    0.10072692f, -0.06775080f, 0.01334665f, 0.00583858f, 0.08168915f, 0.13823864f, 0.12705502f, -0.07508090f, 
    0.07913569f, 0.07368347f, 0.08621988f, -0.00014069f, 0.00730057f, -0.09219995f, -0.17402862f, -0.00306909f, 
    -0.08702858f, -0.11222111f, -0.01567077f, -0.04118481f, -0.07685266f, 0.15373394f, 0.02606553f, 0.12232918f, 
    0.21816644f, -0.02483382f, -0.13795306f, -0.04291251f, 0.02534069f, 0.09681804f, -0.02709794f, 0.08518136f, 
    -0.08599273f, -0.26135683f, -0.13597599f, -0.20076491f, 0.36696881f, -0.14937466f, -0.11125532f, 0.05862664f, 
    -0.05683726f, -0.04349761f, 0.11262859f, -0.03034187f, 0.07991824f, 0.06706990f, 0.02073537f, -0.05225064f, 
    0.06633847f, -0.00236517f, 0.12681070f, -0.03132002f, -0.06598193f, 0.04817829f, -0.10829379f, 0.07729514f, 
    -0.10054050f, -0.12012391f, 0.03181590f, 0.13420264f, -0.22562844f, -0.05305332f, -0.03111394f, 0.02759078f, 
    0.10001091f, -0.06512412f, 0.02730342f, -0.11979013f, 0.06508848f, 0.04786000f, -0.08669302f, -0.04016590f, 
    0.00518692f, -0.04077274f, -0.08669261f, -0.07282272f, 0.39400396f, -0.01660721f, -0.01404630f, 0.12621856f, 
    -0.11613446f, -0.03190802f, 0.03685097f, -0.10026728f, 0.09359945f, -0.01343340f, -0.03098067f, -0.13308091f, 
    -0.04597709f, 0.11102360f, 0.05289049f, 0.05473533f, 0.00059248f, -0.04185584f, -0.18253191f, 0.00631111f, 
    0.14297812f, 0.37407261f, 0.16360216f, 0.00417293f, 0.18029946f, -0.09932861f, -0.02565280f, -0.00802613f, 
    -0.08703613f, -0.02662664f, 0.01898315f, 0.00328053f, -0.04510600f, -0.00186671f, -0.08045033f, -0.01506489f, 
    0.10971978f, 0.04541753f, -0.01965902f, -0.01282067f, -0.26460072f, 0.09278100f, -0.19036366f, -0.24325791f, 
    -0.07119723f, 0.00579847f, 0.18770574f, -0.06860131f, -0.02533582f, -0.03905370f, 0.00512627f, -0.05920137f, 
    0.04869817f, -0.07693367f, 0.06914251f, 0.02137894f, -0.01198254f, 0.10920602f, 0.04963658f, -0.02986447f, 
    0.21950479f, 0.10516061f, -0.11236156f, 0.01464964f, -0.33836755f, -0.01295170f, -0.03018253f, 0.02991827f, 
    -0.06875328f, 0.08971969f, 0.03911497f, -0.00024322f, -0.05962878f, -0.00541805f, 0.00537297f, -0.00527317f, 
    0.08916382f, -0.04899183f, 0.03655147f, -0.01953532f, 0.19936198f, 0.17383906f, 0.09988630f, 0.04885671f, 
    0.23654658f, -0.07254363f, -0.07062411f, 0.03532741f, 0.03278166f, 0.04552697f, 0.01391717f, -0.05127738f, 
    0.04903274f, 0.01528984f, 0.00825683f, -0.02852787f, 0.09537020f, 0.02315227f, 0.02039219f, 0.11331343f, 
    -0.30223131f, 0.15665835f, -0.07224412f, 0.07510258f, 0.00172359f, 0.00760690f, 0.06376366f, -0.02994652f, 
    -0.07742405f, 0.01308692f, 0.09812318f, 0.09486725f, -0.05891335f, -0.06599562f, 0.08466087f, 0.12613322f, 
    0.00750339f, -0.01327383f, 0.03175926f, 0.18153682f, -0.23071240f, -0.48226619f, -0.45884952f, -0.17677835f, 
    0.30606228f, -0.01525235f, 0.05513525f, 0.03361876f, -0.17345504f, -0.06763114f, 0.13922781f, 0.07859905f, 
    -0.03313131f, -0.08027145f, 0.00884489f, -0.02094676f, -0.02265302f, -0.05309959f, 0.07401025f, 0.02045907f, 
    0.38044739f, -0.07784807f, -0.38867280f, 0.11676978f, -0.13374715f, 0.00498737f, -0.00952122f, -0.03109381f, 
    -0.02568485f, 0.18543160f, -0.04283481f, -0.00230028f, -0.06517716f, 0.10114101f, -0.02797796f, 0.15505677f, 
    0.06791013f, -0.13179085f, -0.06527194f, -0.05168116f, 0.00404432f, 0.11131174f, -0.12093040f, -0.04100490f, 
    0.03658935f, -0.08716203f, 0.01854546f, 0.03274596f, -0.05917314f, 0.04036016f, -0.00340721f, -0.07276479f, 
    -0.03207279f, -0.03315249f, -0.03442581f, -0.04060067f, 0.00209277f, 0.07568367f, -0.04373460f, 0.00036861f, 
    0.12259966f, 0.34312856f, 0.07064440f, 0.05496769f, 0.21465306f, -0.00024222f, -0.01554259f, 0.07537901f, 
    0.00442871f, 0.08115935f, -0.02568026f, -0.02824122f, -0.00516242f, 0.06479029f, 0.01103757f, 0.09524230f, 
    0.06764334f, 0.08297317f, 0.02435893f, 0.01222971f, 0.06928726f, -0.01536093f, -0.12149043f, 0.03424944f, 
    -0.18836139f, 0.08713199f, -0.10321962f, 0.00174539f, 0.04069381f, -0.02068807f, 0.12269710f, -0.01179950f, 
    0.06802958f, 0.10114639f, -0.01722592f, -0.03125514f, 0.04662107f, -0.23322003f, -0.08625132f, -0.04545802f, 
    0.10860667f, -0.08046362f, 0.03500943f, -0.04488686f, -0.09337185f, 0.05041050f, -0.00659629f, -0.01870413f, 
    0.04320792f, 0.09811293f, -0.05730075f, -0.03169731f, 0.00692512f, 0.02760266f, -0.21655074f, 0.04644535f, 
    0.06502487f, 0.00817554f, -0.11897522f, 0.03972630f, 0.12910713f, -0.05992376f, 0.05599726f, 0.02374701f, 
    0.21179099f, -0.16323468f, -0.04201283f, -0.00925550f, 0.01727389f, 0.03268484f, 0.11407572f, 0.04606708f, 
    -0.01826094f, -0.09730999f, 0.05034767f, -0.06157355f, -0.08319690f, -0.11352210f, 0.00866341f, -0.05483463f, 
    0.36961395f, -0.08561596f, -0.07534358f, -0.13428015f, 0.08462006f, 0.09791387f, 0.01823578f, -0.19965573f, 
    0.09511944f, 0.05898919f, 0.03190615f, 0.03728985f, -0.01779500f, 0.07571424f, 0.06731535f, -0.02341880f, 
    -0.05532736f, 0.02742611f, 0.00345736f, -0.03118574f, 0.09023767f, -0.73516065f, 0.00343692f, -0.10705074f, 
    -0.25118190f, -0.03090747f, -0.17011294f, 0.04182492f, -0.02194361f, 0.08375880f, 0.01614469f, -0.07122616f, 
    -0.04726856f, -0.05419236f, -0.07984298f, 0.10244314f, -0.13517489f, 0.00562969f, -0.06230626f, -0.10420377f, 
    0.31403133f, 0.00175777f, -0.22256538f, -0.08191027f, -0.19883233f, -0.08480793f, 0.06040855f, 0.05781038f, 
    -0.04432229f, -0.01240069f, 0.03030004f, -0.07414670f, 0.01782174f, 0.03726856f, -0.02940885f, 0.00882493f, 
    0.05625797f, -0.07885274f, 0.09614386f, -0.11590284f, 0.07781646f, 0.05591537f, 0.14434740f, -0.12965065f, 
    0.10172564f, -0.01302598f, 0.00396048f, 0.20497963f, 0.04032437f, -0.07198862f, 0.00990929f, 0.05488600f, 
    0.12124185f, 0.07484183f, -0.03039298f, 0.02990793f, -0.07567271f, -0.02623208f, 0.05540834f, -0.07208750f, 
    0.27687484f, -0.07093947f, -0.19761275f, -0.25086889f, -0.24987213f, 0.04415547f, 0.07657881f, -0.04207537f, 
    0.09304650f, -0.09631532f, -0.03346277f, 0.07696314f, -0.06315589f, 0.01648879f, -0.03193730f, 0.02274158f, 
    0.04370900f, 0.02063671f, -0.00542061f, -0.15785193f, 0.01813912f, 0.05159103f, 0.25489414f, 0.04192660f, 
    -0.01001031f, -0.10712621f, -0.20888942f, -0.02098081f, 0.03726793f, 0.09682884f, -0.08326603f, 0.00221919f, 
    -0.01841480f, 0.09095506f, -0.11664227f, -0.07745595f, -0.17408556f, 0.05850345f, -0.08292603f, 0.00832478f, 
    -0.78045100f, -0.37987915f, 0.00389609f, -0.43289834f, -0.46983176f, 0.02153461f, -0.01315229f, -0.03831438f, 
    -0.04332147f, 0.06446398f, -0.10383976f, 0.10082750f, -0.07726400f, -0.07089222f, -0.05243161f, 0.07411066f, 
    -0.04647864f, 0.12726218f, -0.02992302f, -0.09475733f, 0.12415726f, 0.03147839f, -0.01966938f, -0.21490002f, 
    0.09284183f, 0.10489903f, 0.04960232f, 0.17656310f, -0.01977560f, -0.10181952f, 0.04622245f, 0.12097441f, 
    -0.02910686f, -0.14190969f, -0.07905445f, 0.03286311f, -0.01179187f, 0.08213097f, -0.07763103f, -0.05894853f, 
    -0.29533547f, 0.07827547f, 0.08681581f, -0.06655889f, -0.05061247f, -0.04450648f, 0.01730649f, 0.04978514f, 
    0.06075728f, 0.06877676f, -0.04245523f, -0.05036758f, -0.00131818f, -0.01685597f, -0.02386606f, -0.02780460f, 
    -0.04016793f, -0.06921363f, 0.02891260f, 0.02945600f, -0.07388810f, -0.24630168f, 0.07930640f, -0.22791964f, 
    -0.16184334f, -0.11648624f, 0.05879188f, 0.03052958f, 0.01392009f, -0.02655512f, 0.05919236f, -0.04807667f, 
    -0.01889688f, 0.04354630f, -0.02111007f, -0.04432398f, 0.05600401f, 0.05630452f, -0.01739301f, -0.05376913f, 
    0.38975492f, 0.11010449f, -0.08705659f, -0.05326360f, -0.02890015f, -0.00945882f, -0.05862296f, 0.08075617f, 
    0.05021242f, 0.01887982f, -0.03149376f, -0.02263808f, -0.12138849f, -0.04130603f, -0.01785335f, 0.02225560f, 
    0.01729987f, -0.06408779f, 0.08663117f, 0.10019070f, -0.00592196f, 0.00903928f, -0.17853516f, -0.08990339f, 
    -0.00116264f, 0.05386496f, -0.06043687f, 0.00860269f, 0.07866152f, -0.02748963f, -0.07113247f, -0.04606028f, 
    -0.07755405f, -0.04235355f, 0.01154865f, -0.07908849f, -0.07857921f, -0.13113768f, -0.07729243f, -0.09971508f, 
    -0.26537445f, 0.17502752f, -0.00455124f, -0.05594105f, 0.04422524f, 0.05725953f, 0.06139388f, 0.02121577f, 
    -0.06072360f, -0.03940445f, -0.05767142f, 0.04162664f, -0.04391723f, -0.13336225f, 0.05992735f, -0.04024399f, 
    0.02347541f, -0.09228897f, -0.20717919f, 0.05823779f, 0.13783990f, -0.03747256f, 0.13233706f, 0.08072685f, 
    -0.06801502f, -0.09032446f, 0.05086458f, 0.03544789f, -0.09440113f, -0.02638086f, -0.02743475f, -0.05784270f, 
    0.02669317f, 0.02994189f, -0.02547969f, 0.07168934f, -0.16942506f, -0.10268265f, 0.11980914f, -0.19121267f, 
    0.45050445f, -0.29512441f, 0.16284311f, -0.14632133f, -0.00676495f, -0.08910583f, 0.01446038f, -0.09815782f, 
    0.11751949f, 0.01838553f, 0.03897306f, -0.04658325f, 0.05387248f, -0.02228418f, 0.07411669f, -0.07163969f, 
    -0.01838484f, 0.10218693f, 0.15791251f, -0.11093382f, -0.02877567f, -0.09813445f, -0.25209746f, -0.30480310f, 
    -0.26754928f, -0.04446486f, -0.01989813f, -0.01212459f, -0.01803064f, -0.05129319f, -0.11274145f, -0.01337599f, 
    0.01612005f, 0.01777293f, 0.15645269f, -0.03653029f, -0.04353871f, 0.03521862f, 0.03455966f, -0.07813497f, 
    0.32260492f, -0.16381975f, -0.06050617f, -0.00814826f, -0.47304431f, -0.03847754f, 0.05063571f, -0.21606518f, 
    -0.03537679f, 0.13191716f, 0.00069266f, 0.02894561f, 0.07894795f, -0.09795923f, -0.11422104f, -0.09144099f, 
    -0.01119837f, 0.08702159f, 0.06781267f, -0.05926777f, 0.25145248f, -0.04763510f, -0.04646684f, 0.21944150f, 
    -0.12137031f, -0.12922397f, 0.07325400f, -0.01681825f, -0.08022336f, 0.05630698f, -0.02303621f, -0.02815324f, 
    0.05324730f, 0.01727707f, 0.00961032f, -0.03298934f, -0.08417004f, -0.06759201f, 0.00848524f, -0.04711340f, 
    0.28472975f, -0.05274547f, -0.04594419f, 0.01772403f, -0.05692269f, -0.07600409f, 0.04230298f, -0.03912477f, 
    -0.07036537f, 0.05133416f, 0.04367654f, -0.00935389f, 0.03589924f, -0.02912952f, -0.04835934f, 0.14173888f, 
    -0.08524451f, -0.07469873f, 0.06794143f, -0.02279875f, 0.52165014f, -0.19673009f, -0.05514014f, 0.14038058f, 
    -0.08003343f, -0.19908664f, 0.05128186f, -0.07913411f, -0.03558017f, 0.12516987f, 0.01063257f, 0.04185033f, 
    0.03424606f, -0.02625469f, -0.01109297f, 0.09692319f, -0.10424094f, -0.04785533f, 0.17772968f, 0.04348286f, 
    0.20083705f, -0.09065044f, 0.08346964f, -0.10756231f, -0.06003892f, -0.04000617f, -0.06922549f, 0.18139276f, 
    -0.03644355f, -0.05632918f, -0.02217430f, 0.05074778f, 0.10170805f, 0.05685169f, -0.03171133f, -0.01564735f, 
    -0.19902498f, -0.08409033f, 0.01148467f, -0.07036291f, 0.18876466f, 0.16082665f, -0.24189794f, -0.03531140f, 
    0.08731247f, 0.05560311f, 0.07636674f, -0.02587553f, 0.04090476f, 0.02188149f, 0.04817270f, 0.06573144f, 
    0.08735273f, -0.02108513f, -0.02832545f, 0.04072234f, -0.03416470f, -0.12061314f, -0.04540410f, 0.02291019f, 
    0.21851437f, 0.02644306f, 0.08516824f, 0.19771677f, 0.19943981f, -0.21266308f, -0.13303488f, -0.24247795f, 
    0.04170778f, 0.05449986f, 0.12789683f, -0.02382031f, -0.08229006f, -0.01558408f, -0.01636819f, -0.05311382f, 
    -0.08172631f, 0.01875861f, 0.01253712f, 0.03257173f, 0.12848972f, -0.06145776f, -0.02862880f, -0.17226617f, 
    0.09125295f, 0.05492540f, 0.05349867f, 0.08367634f, -0.01759791f, -0.03727479f, 0.04792831f, 0.04355319f, 
    0.01266935f, -0.06445127f, 0.01965540f, 0.01788439f, -0.08441966f, -0.06185020f, -0.12558441f, -0.06748300f, 
    0.29474691f, 0.12587678f, 0.18869279f, 0.03215956f, 0.21075590f, -0.02586603f, -0.19162959f, -0.05678795f, 
    0.09842096f, 0.09219909f, 0.03557800f, -0.00982749f, -0.03524668f, -0.05385485f, -0.03865782f, -0.03810303f, 
    -0.07707654f, -0.03964285f, -0.06818452f, -0.02768139f, 0.08654892f, 0.12469202f, -0.14477818f, -0.12907210f, 
    -0.06552897f, -0.03459543f, 0.00516783f, 0.14096533f, -0.13618115f, -0.00054986f, -0.21401887f, -0.08817005f, 
    -0.11049251f, 0.05294849f, -0.13252775f, 0.02847943f, -0.00093280f, 0.06442095f, 0.00390652f, 0.10177309f, 
    0.30811355f, -0.41399133f, 0.27275500f, 0.00841244f, 0.12991996f, -0.22975600f, -0.01655115f, -0.02839225f, 
    0.03601436f, 0.00832785f, 0.10035068f, -0.00784201f, 0.02698009f, -0.03435923f, -0.00045560f, 0.04705740f, 
    -0.06515631f, 0.05080685f, 0.03277875f, -0.00460435f, 0.04111255f, -0.02756755f, -0.06850150f, -0.02838695f, 
    -0.14190836f, 0.05426927f, 0.05167716f, 0.11504593f, -0.02305298f, 0.00138162f, 0.02720284f, 0.03880456f, 
    0.05568498f, 0.04250298f, -0.00811869f, -0.01066585f, 0.04812440f, 0.03978740f, 0.03798254f, 0.01041526f, 
    0.05247080f, 0.02069340f, -0.11592582f, -0.12585089f, 0.02634505f, 0.07119636f, -0.00852003f, 0.07474196f, 
    0.01737069f, -0.03635462f, -0.08189394f, -0.03569298f, -0.05241420f, -0.01120844f, -0.03530816f, -0.06477348f, 
    -0.02069634f, -0.00868557f, -0.15482484f, -0.00544449f, -0.49307570f, 0.18713422f, -0.25370103f, -0.18198666f, 
    0.01925160f, 0.04426578f, 0.19211484f, 0.00621644f, 0.04581120f, -0.28330323f, 0.01253537f, 0.01759850f, 
    -0.14709690f, 0.00807752f, 0.07517347f, -0.04284292f, 0.06411984f, 0.04928496f, 0.05257243f, -0.05269906f, 
    -0.18476638f, -0.36659330f, -0.24706131f, 0.19833463f, 0.11884291f, -0.15009284f, -0.02921604f, -0.01757647f, 
    0.03720835f, 0.01614654f, -0.04630690f, 0.00292233f, -0.06423558f, 0.07180111f, 0.04235769f, -0.04029470f, 
    0.00361827f, -0.01674815f, -0.00617548f, 0.07865857f, 0.09283591f, -0.16179551f, 0.06182782f, -0.06792814f, 
    -0.16171370f, -0.02760367f, -0.15223278f, 0.00256931f, 0.03954131f, 0.02287810f, -0.05758426f, -0.08323323f, 
    0.02043124f, -0.08793769f, 0.00386527f, 0.04142172f, 0.07778633f, 0.01209884f, 0.06415419f, 0.03364177f, 
    0.22681391f, 0.25978795f, -0.21062301f, 0.03503681f, 0.04853261f, -0.07503583f, -0.07761968f, 0.00936050f, 
    0.12692849f, -0.02163966f, -0.00712351f, -0.05497082f, -0.04611187f, 0.02619700f, 0.03053635f, -0.08037491f, 
    -0.06849167f, -0.00619869f, 0.13351516f, 0.01866517f, 0.03326467f, 0.04043273f, 0.09329861f, 0.06735779f, 
    0.08061752f, -0.07698001f, 0.09362414f, -0.02045395f, -0.06781757f, 0.03639090f, -0.01370529f, -0.00603457f, 
    -0.01805271f, 0.07536394f, 0.15323199f, -0.03076785f, 0.04426635f, 0.02073488f, -0.08971880f, -0.03499384f, 
    -0.37215078f, 0.45387265f, 0.13090885f, 0.20676264f, 0.19293492f, 0.09045041f, 0.06871417f, 0.08156981f, 
    -0.06582145f, 0.06375825f, -0.06019309f, -0.11696580f, 0.01075176f, 0.01536181f, -0.04184551f, -0.03181414f, 
    -0.06874538f, -0.11281789f, 0.10942241f, -0.04463533f, -0.52011961f, -0.69707388f, -0.19372003f, -0.05502117f, 
    0.14566432f, -0.11391625f, -0.00918446f, 0.03851968f, 0.05040581f, -0.03597727f, 0.00242546f, 0.03330795f, 
    -0.00373956f, -0.14064345f, 0.11170506f, -0.11604158f, -0.10531528f, -0.09503826f, -0.00515888f, -0.08195170f, 
    0.57237041f, 0.21891379f, 0.09841046f, 0.20932034f, -0.05166367f, 0.30240309f, -0.01722878f, -0.04610310f, 
    0.11799543f, -0.12714408f, 0.06738988f, 0.11756884f, -0.17942265f, -0.03540860f, -0.03661484f, -0.17269005f, 
    -0.00143490f, -0.07253232f, -0.03817298f, -0.09178779f, -0.02270921f, -0.00890594f, -0.20742619f, -0.05919892f, 
    -0.19987813f, 0.05573737f, -0.01348770f, 0.00684533f, -0.09671500f, -0.01396842f, -0.06112962f, 0.03699289f, 
    -0.04750071f, 0.09778310f, 0.00633468f, 0.03372993f, -0.05457585f, -0.02505965f, -0.09589680f, 0.00869102f, 
    0.13104102f, 0.11438794f, 0.17325729f, 0.15285881f, 0.00074343f, 0.05919165f, 0.14699943f, -0.01126317f, 
    -0.00274957f, -0.10197801f, -0.00184332f, -0.03927793f, -0.03964083f, 0.03872262f, -0.04286209f, 0.12288339f, 
    -0.02608045f, 0.05432151f, 0.07989342f, -0.02497667f, -0.09657232f, -0.59973228f, -0.32322156f, 0.13166848f, 
    0.11543123f, -0.01994048f, -0.00680153f, 0.04653011f, 0.07609396f, -0.07674471f, -0.08016919f, -0.00236601f, 
    -0.01760036f, -0.02868248f, 0.03187027f, 0.01993253f, 0.07431521f, 0.02557363f, -0.08683246f, 0.01278805f, 
    0.02801531f, 0.14709596f, -0.31468841f, 0.12961553f, -0.15509485f, -0.10254906f, 0.11491410f, -0.03094109f, 
    0.08085423f, -0.02848201f, 0.01745521f, 0.04907652f, -0.00611300f, -0.04247472f, 0.04902603f, 0.00109213f, 
    -0.03096256f, -0.01530545f, -0.13385987f, -0.03132845f, 0.03613903f, 0.12246472f, 0.06406324f, 0.16304772f, 
    -0.09081558f, -0.04561106f, 0.03172527f, -0.03176421f, -0.09021796f, -0.01392546f, 0.05043884f, 0.01910515f, 
    -0.02142647f, 0.07235724f, 0.03747587f, 0.04873792f, -0.10480057f, 0.11547019f, -0.02752047f, -0.01612103f, 
    -0.17628576f, 0.12123109f, 0.00553663f, 0.07406786f, 0.00933812f, 0.00182730f, -0.03846265f, -0.03464240f, 
    0.09658831f, -0.09695948f, -0.04839842f, -0.00062647f, -0.09808974f, 0.07773490f, 0.01606707f, 0.06238774f, 
    -0.11290275f, -0.07660284f, -0.03590189f, 0.04580193f, -0.44784054f, -0.12067617f, 0.02565702f, -0.08936694f, 
    0.00427062f, 0.06456207f, -0.00752779f, -0.02908541f, -0.02808166f, -0.07786997f, -0.03948255f, 0.07669137f, 
    0.07798500f, 0.02421909f, 0.02631143f, -0.01105702f, 0.00466170f, -0.14424352f, 0.07169155f, 0.05437877f, 
    0.10674923f, -0.64996535f, -0.36620864f, 0.24800946f, 0.08870474f, 0.08547738f, -0.01446581f, 0.07011881f, 
    -0.04678928f, -0.13317324f, 0.04689608f, 0.14317779f, -0.09097590f, -0.05827736f, -0.04168250f, 0.00586489f, 
    0.00584779f, 0.02898106f, -0.09434151f, -0.07440993f, -0.21784747f, -0.01544475f, 0.30952269f, 0.06801784f, 
    0.15546092f, 0.06169830f, 0.11527146f, 0.07981089f, -0.08576692f, -0.10927437f, -0.00363415f, 0.05306903f, 
    -0.13577682f, -0.04014959f, 0.15948078f, -0.10799713f, -0.00205803f, -0.16958563f, 0.07063229f, -0.05175247f, 
    -0.07751678f, 0.15089737f, -0.01276074f, -0.00108736f, 0.04710467f, 0.05351004f, -0.05846848f, -0.02424975f, 
    0.00610418f, -0.07414079f, -0.07399159f, 0.02815989f, -0.00723473f, 0.13751870f, 0.00430850f, -0.00936965f, 
    -0.06936330f, -0.05318564f, -0.03223798f, 0.02563210f, 0.18852471f, 0.41522163f, 0.00822742f, -0.06199570f, 
    0.08839024f, -0.01879570f, -0.00463985f, 0.07297767f, 0.06524489f, 0.05539926f, -0.09697414f, -0.05907970f, 
    0.04077234f, 0.03656026f, -0.05325794f, -0.01033744f, 0.02484397f, 0.02810218f, 0.20568413f, 0.12823166f, 
    -0.07512315f, 0.15193385f, 0.06999263f, 0.14585473f, -0.03489044f, -0.10114031f, -0.05276662f, -0.00015414f, 
    -0.01384321f, 0.03271894f, -0.07359380f, -0.08577194f, -0.05261195f, -0.11617737f, -0.02062151f, 0.02575028f, 
    0.04516070f, 0.05194604f, 0.06101516f, 0.06872408f, -0.06656197f, -0.00447547f, -0.02333073f, -0.06305122f, 
    -0.03177770f, -0.04989298f, -0.11913116f, 0.18346713f, -0.09165615f, 0.00080064f, -0.05620938f, 0.03598640f, 
    -0.07922419f, 0.01096638f, 0.04827660f, 0.01704857f, 0.02578165f, 0.06720841f, 0.12949581f, -0.01857661f, 
    0.23677655f, -0.01998748f, 0.22789505f, 0.00510110f, -0.03481571f, 0.00611145f, -0.01573870f, -0.13772386f, 
    -0.06863508f, -0.06202540f, -0.05034462f, 0.05645010f, -0.03755180f, -0.02180954f, 0.10463351f, -0.03184115f, 
    0.10708058f, -0.00138131f, 0.01341041f, 0.01657409f, 0.00072441f, -0.04596322f, 0.11011334f, -0.01347227f, 
    -0.01106540f, 0.01756849f, -0.19658038f, -0.01556092f, -0.04902125f, -0.05675155f, -0.04812099f, -0.06724520f, 
    -0.01636981f, -0.03964467f, 0.07765727f, 0.04687166f, 0.07326764f, 0.05959177f, 0.06479120f, -0.04083297f, 
    -0.17573175f, -0.65982211f, -0.18204461f, -0.05265783f, -0.28188482f, -0.14187789f, -0.14046876f, -0.02671097f, 
    0.10771336f, -0.06886607f, -0.07561988f, -0.06304242f, 0.00197454f, 0.05916849f, 0.09364875f, 0.03720884f, 
    -0.11689280f, -0.04070479f, -0.02989751f, -0.00870216f, -0.49668154f, 0.47422686f, 0.03515884f, -0.13386014f, 
    -0.28725868f, -0.02941719f, -0.10150354f, 0.00798865f, 0.12041672f, -0.02797954f, 0.00140850f, -0.01612172f, 
    -0.11702853f, 0.03123504f, -0.12728792f, -0.06392428f, -0.04449429f, -0.11924990f, 0.11771580f, -0.01621466f, 
    0.13735536f, -0.12752621f, -0.09706736f, -0.09572847f, -0.11538780f, -0.13024019f, -0.14463185f, 0.06481688f, 
    -0.05336902f, 0.03589976f, -0.16478688f, -0.00715585f, 0.05784703f, -0.06312155f, 0.04408563f, -0.04886984f, 
    -0.01720764f, 0.05249718f, 0.02117625f, 0.06739624f, -0.07845682f, -0.29010326f, -0.42818350f, 0.01917069f, 
    0.01279784f, -0.13546056f, -0.07162078f, -0.05932729f, 0.00648562f, -0.03995731f, -0.03712326f, 0.01713580f, 
    0.04122588f, 0.01467244f, -0.03290934f, 0.00855909f, -0.00075714f, -0.02289972f, 0.00718215f, 0.03149560f, 
    -0.35332477f, -0.01882266f, 0.00854712f, -0.17620674f, -0.28242359f, -0.01051870f, -0.14166568f, -0.05313797f, 
    0.02420554f, -0.07785317f, -0.05170402f, -0.15527059f, 0.00157771f, 0.02104049f, -0.00237275f, 0.05942376f, 
    0.04396944f, 0.00571253f, 0.01027690f, 0.05781012f, 0.57809526f, 0.33220991f, -0.11968148f, -0.00063399f, 
    -0.00284541f, 0.04765431f, 0.06798079f, -0.00284485f, 0.13512322f, 0.07021968f, -0.08339050f, -0.07881030f, 
    -0.11823224f, 0.04136839f, -0.01437949f, -0.07994027f, 0.07407828f, -0.06127208f, 0.08816991f, 0.08976977f, 
    -0.00875805f, 0.05052887f, -0.07022032f, 0.02139732f, 0.04634461f, -0.16656171f, -0.18113746f, 0.00142109f, 
    0.01398884f, 0.06299303f, -0.01726212f, -0.02073046f, 0.06824243f, 0.01495417f, -0.02129884f, -0.05871499f, 
    0.07103050f, 0.02028658f, 0.03303613f, 0.05626279f, -0.06978931f, -0.26110497f, 0.04183787f, 0.03949974f, 
    0.05988464f, 0.08136126f, -0.01435448f, 0.08050630f, -0.00824043f, -0.09212140f, 0.06649983f, -0.04440534f, 
    -0.02477146f, 0.08416153f, -0.05234293f, 0.08075342f, 0.07723992f, -0.00762727f, 0.00182332f, 0.01061725f, 
    -0.41232809f, -0.19835183f, -0.09624351f, -0.06909263f, -0.01252583f, -0.10318144f, -0.00036768f, -0.07751235f, 
    -0.02633087f, -0.04762898f, -0.01503279f, -0.00453753f, 0.07648723f, 0.07746855f, 0.00894771f, -0.02713317f, 
    -0.08036081f, -0.14277507f, 0.04789178f, 0.09319787f, -0.40832618f, 0.09225490f, -0.24408621f, 0.25821191f, 
    0.19082274f, 0.10823376f, 0.25726733f, 0.11714979f, 0.04412128f, 0.04771247f, -0.07580747f, 0.04656922f, 
    -0.00659254f, -0.14376096f, -0.06112496f, -0.00059418f, 0.05126963f, 0.03694684f, 0.11045553f, -0.06167992f, 
    0.24863373f, -0.12940037f, -0.11132052f, -0.01563605f, 0.06313840f, -0.03958805f, 0.06629009f, 0.20435061f, 
    0.07141607f, 0.03685487f, 0.03628846f, -0.09609337f, 0.16452684f, -0.05373304f, -0.06389014f, -0.08237328f, 
    -0.04866301f, 0.07568671f, -0.01986728f, 0.06334720f, -0.45556498f, -0.11185021f, -0.19706793f, 0.12231848f, 
    0.25258109f, -0.03134855f, 0.00066980f, -0.01693855f, 0.12488306f, -0.04905105f, 0.03520012f, -0.06010870f, 
    0.00509599f, 0.20371637f, 0.04999587f, 0.03076820f, 0.07558125f, 0.09793152f, 0.02772126f, 0.05672226f, 
    -0.09692381f, -0.11731280f, -0.09055676f, -0.17906401f, -0.07291157f, -0.02416774f, 0.05355674f, 0.03453285f, 
    0.00079533f, -0.01797481f, 0.09258997f, -0.03357043f, 0.01643717f, 0.08597310f, 0.10939073f, -0.01032522f, 
    0.12146616f, -0.00585706f, 0.15945746f, 0.07934670f, -0.06390839f, 0.26586023f, -0.02277936f, 0.21563095f, 
    -0.39006940f, -0.03197638f, -0.04745973f, 0.15810549f, 0.04947734f, -0.02548023f, -0.06530815f, -0.08440114f, 
    0.10498147f, 0.07767479f, 0.04744771f, -0.04819338f, -0.02800289f, 0.11981338f, -0.09575671f, 0.16274776f, 
    -0.15446870f, -0.26045701f, 0.00770774f, 0.07825041f, 0.07569109f, -0.00993062f, -0.05422812f, 0.08515902f, 
    -0.12624109f, -0.07671615f, 0.02161567f, 0.08442427f, 0.02116044f, -0.00786957f, 0.04051246f, -0.05266434f, 
    -0.05349847f, -0.01512720f, 0.07267235f, -0.07536714f, -0.27981892f, -0.52973253f, 0.12312169f, -0.03492707f, 
    0.02913537f, -0.14892547f, 0.00821390f, -0.00613284f, 0.01332034f, 0.02640462f, 0.09903439f, 0.04637557f, 
    -0.15272771f, -0.16312036f, -0.01154132f, 0.12583926f, -0.02757365f, -0.03389842f, -0.03597046f, 0.01403023f, 
    0.10168713f, 0.36562669f, -0.03945079f, -0.60606652f, -0.23643821f, -0.08407687f, 0.15550503f, -0.20765407f, 
    0.03574698f, -0.07734972f, -0.07156883f, -0.03555325f, -0.01071798f, 0.05765574f, 0.00557880f, -0.08583904f, 
    0.19589527f, 0.01301006f, -0.11621380f, 0.05227277f, 0.03983838f, 0.01056323f, -0.09518894f, 0.11900625f, 
    -0.08122060f, -0.00330342f, -0.03437493f, 0.15645410f, -0.10607263f, 0.04997836f, -0.01036850f, -0.10967823f, 
    0.11720413f, 0.02663616f, 0.14385840f, -0.02552559f, -0.00734826f, 0.19292785f, 0.05783354f, -0.05409302f, 
    0.07747768f, 0.18047954f, -0.01887465f, 0.25546086f, -0.28218508f, -0.07189182f, 0.03066366f, -0.09081381f, 
    0.01008316f, -0.25479108f, 0.08994256f, -0.18411709f, -0.00585708f, 0.10040402f, -0.04554763f, -0.07781342f, 
    0.12920450f, 0.12181159f, 0.07959720f, 0.27595240f, -0.40562567f, -0.10702666f, 0.24961726f, 0.14771615f, 
    -0.04618524f, -0.07399660f, 0.02185075f, -0.04553206f, 0.04077511f, 0.08627736f, 0.11053549f, -0.01113757f, 
    -0.04197324f, -0.01006343f, -0.03005416f, -0.16723871f, 0.04306649f, -0.05788733f, 0.10013824f, 0.06188187f, 
    -0.30352226f, 0.20498952f, -0.21516311f, -0.17290168f, -0.28275675f, -0.03033394f, -0.07860072f, -0.05191856f, 
    -0.34348944f, 0.05686618f, -0.03051458f, -0.09747510f, -0.07322328f, 0.03665286f, -0.00792929f, -0.02274814f, 
    -0.06845009f, -0.10677712f, -0.20208989f, -0.01127344f, -0.16519985f, 0.31258607f, 0.04453244f, 0.21731116f, 
    -0.13800332f, 0.06225608f, -0.15706278f, -0.15587170f, 0.08228686f, -0.15549432f, -0.02066516f, 0.05270184f, 
    -0.15180300f, 0.08679533f, 0.06277724f, 0.06706809f, -0.07748666f, -0.08290735f, 0.03974903f, 0.10113680f, 
    -0.57497853f, 0.15514566f, -0.02128920f, -0.26670539f, -0.04105006f, -0.08464206f, 0.00618863f, -0.05319701f, 
    0.00656406f, -0.00509358f, -0.03786257f, -0.06239661f, 0.14513026f, 0.03390301f, 0.01926989f, -0.01547928f, 
    0.02573968f, -0.00338226f, 0.02274486f, -0.20318651f, 0.10990719f, 0.05530180f, 0.10802873f, -0.02377983f, 
    -0.00572482f, 0.01031180f, -0.04720816f, 0.04079771f, -0.07355746f, 0.08003118f, 0.08099528f, -0.04658867f, 
    -0.03389111f, -0.02317993f, 0.02113834f, -0.00536257f, -0.03192036f, -0.06089504f, -0.03095007f, 0.09056191f, 
    -0.12506795f, -0.25630304f, 0.03305889f, -0.03005688f, 0.13985321f, -0.06441065f, 0.02311029f, -0.22964253f, 
    -0.10101824f, -0.02744654f, 0.04646425f, 0.01417914f, -0.01938513f, -0.01274393f, -0.00263008f, -0.09493869f, 
    -0.01563273f, -0.06518732f, -0.02300188f, -0.08459350f, -0.12417942f, -0.16359694f, -0.17099158f, -0.00024403f, 
    0.01307812f, -0.10067682f, -0.01038384f, 0.12327423f, -0.11373173f, -0.05719351f, -0.03345627f, 0.01685178f, 
    -0.03910995f, -0.00496727f, -0.02821865f, 0.01502860f, -0.05142342f, -0.10477195f, -0.09025127f, -0.07236592f, 
    -0.42739174f, 0.19465262f, 0.14453113f, -0.03798424f, -0.00296662f, 0.12766206f, -0.06174116f, 0.02889442f, 
    -0.00085151f, -0.09552433f, -0.06906188f, 0.09896593f, -0.17510849f, 0.04108939f, 0.04647340f, -0.09118418f, 
    -0.02969002f, -0.02839136f, -0.02906835f, 0.00573710f, -0.24071346f, 0.17894593f, 0.16262181f, -0.01722742f, 
    -0.28580806f, 0.04875095f, -0.01467588f, 0.11311585f, -0.16918802f, -0.06317670f, 0.03281236f, -0.02503511f, 
    0.01596603f, 0.03968995f, 0.05387543f, 0.00351604f, 0.01277968f, 0.06414546f, -0.09356254f, 0.02930834f, 
    0.05148758f, -0.05250790f, -0.06270135f, 0.10031265f, 0.13611944f, 0.08166513f, -0.04098587f, 0.03982267f, 
    0.10596299f, 0.00135846f, 0.18619357f, -0.02476003f, -0.06566586f, -0.02457250f, 0.07171377f, -0.17049854f, 
    -0.07389354f, 0.05473766f, 0.07960721f, 0.12526503f, 0.01045357f, -0.04564072f, -0.08441832f, 0.06610247f, 
    0.19482329f, 0.07870211f, -0.05837904f, 0.06444953f, -0.04970986f, 0.08697994f, 0.03474869f, -0.06980231f, 
    -0.00385326f, -0.00106992f, -0.07213994f, -0.08395582f, 0.02842059f, 0.02773008f, 0.07531349f, -0.10826427f, 
    -0.43371752f, -0.08692509f, -0.04048681f, -0.14447249f, 0.03744529f, 0.10151663f, -0.02677373f, 0.00553553f, 
    0.09092502f, 0.14262237f, -0.05417566f, 0.06352510f, 0.02870750f, -0.01950806f, -0.07318005f, 0.02297252f, 
    0.13713191f, -0.12289166f, 0.08284699f, -0.06403094f, -0.27763242f, 0.08058849f, -0.27977014f, -0.01488947f, 
    0.18855162f, 0.08705202f, 0.00717310f, 0.05946373f, 0.10663519f, 0.12230506f, -0.00664166f, 0.00265376f, 
    0.02715201f, -0.03082236f, -0.10037701f, -0.03175163f, 0.10500427f, -0.01219841f, 0.03604669f, -0.03043413f, 
    -0.12930715f, -0.12097283f, -0.20201743f, 0.03284837f, -0.00192758f, 0.05908539f, -0.01307708f, -0.15658301f, 
    0.13388021f, 0.03506202f, -0.02575600f, -0.05753321f, 0.17418897f, -0.05130364f, -0.03742559f, 0.10575917f, 
    0.05321625f, -0.09430417f, -0.04238545f, 0.00431566f, 0.01385776f, 0.08512713f, 0.03804851f, 0.02604386f, 
    -0.04724477f, 0.08830939f, -0.08102506f, 0.16973189f, -0.02702672f, -0.12440462f, -0.06611586f, -0.01615153f, 
    0.00121138f, -0.05757425f, -0.03027295f, -0.02162065f, 0.03756763f, -0.11085492f, 0.01021031f, -0.07405888f, 
    -0.60325158f, -0.00178434f, -0.03935372f, 0.17015749f, 0.25087082f, 0.01136075f, -0.07370105f, 0.07090413f, 
    0.11373850f, 0.09857288f, 0.09228839f, -0.00043763f, 0.05945512f, 0.00645550f, -0.02866308f, 0.02340999f, 
    -0.02160670f, 0.01613004f, 0.10724766f, -0.05594064f, -0.03695562f, 0.16743346f, 0.23887403f, -0.06135151f, 
    -0.12605534f, -0.03376175f, -0.02082392f, -0.02292210f, 0.08790854f, 0.07948809f, 0.13226932f, 0.02568467f, 
    -0.07175089f, -0.07625748f, 0.00098547f, 0.01584155f, -0.03641504f, -0.07293202f, -0.07828391f, 0.02672443f, 
    0.03969659f, 0.06684848f, -0.29764786f, 0.18474139f, 0.14938736f, 0.15272681f, 0.05750578f, 0.08717531f, 
    0.01907354f, -0.03128880f, -0.05739136f, 0.02135448f, 0.05404076f, -0.01995659f, -0.00596439f, -0.06594925f, 
    0.05983650f, -0.14420348f, 0.01397348f, -0.07121600f, 0.58997941f, 0.02549572f, -0.10043583f, -0.07466593f, 
    -0.15484256f, -0.04701424f, 0.07801230f, 0.09517252f, 0.04719472f, 0.04129780f, -0.04630321f, -0.10525104f, 
    -0.03136816f, -0.05479829f, -0.02837304f, 0.00882539f, 0.02397814f, 0.04563960f, 0.04961894f, 0.05856555f, 
    -0.66950113f, 0.17079118f, 0.04865103f, 0.08533450f, 0.09908905f, -0.04211263f, -0.05020645f, 0.06638280f, 
    0.13052030f, 0.10221642f, -0.03552079f, -0.04269414f, 0.00912581f, -0.00914366f, -0.01603853f, -0.18338118f, 
    -0.00684977f, 0.03593417f, 0.12406281f, -0.03704212f, -0.17127417f, 0.37437138f, -0.17400448f, -0.01806400f, 
    -0.07093092f, 0.00712876f, 0.01333331f, 0.07373243f, 0.04174514f, -0.01672500f, 0.01148305f, 0.13262618f, 
    0.01151525f, 0.05149224f, 0.02739242f, -0.00955337f, 0.00283374f, -0.14275679f, -0.05557376f, 0.01921176f, 
    -0.09809102f, 0.20322342f, 0.18687962f, 0.01484681f, -0.03682614f, -0.01015042f, -0.08260293f, 0.10447254f, 
    0.01225221f, 0.03163957f, 0.12137169f, 0.02972207f, -0.02631151f, -0.03140399f, 0.05108939f, -0.03196396f, 
    0.05681944f, -0.01363258f, -0.07155164f, 0.00482251f, -0.45129499f, -0.40106317f, 0.33148113f, 0.23481116f, 
    -0.08166793f, 0.02583580f, 0.03721283f, 0.00711969f, -0.11610220f, 0.00693448f, 0.19683312f, 0.01508021f, 
    -0.06658923f, -0.17912768f, 0.00156791f, 0.02993932f, -0.17631705f, 0.08706699f, 0.02901960f, 0.06630564f, 
    0.00634919f, 0.02626002f, 0.25940770f, 0.02691038f, -0.11269066f, 0.12696855f, -0.02939357f, 0.00189742f, 
    -0.00914562f, -0.08120957f, -0.06353814f, 0.05617341f, -0.19377299f, 0.02581897f, 0.03669018f, -0.06285013f, 
    0.01852998f, 0.12324992f, 0.21393763f, -0.17744213f, -0.08587220f, 0.38219389f, -0.13187446f, -0.00516240f, 
    -0.12483742f, 0.05405979f, -0.00169019f, 0.10578690f, -0.11740986f, 0.00061501f, -0.02583573f, -0.10294672f, 
    0.00041109f, -0.13547085f, -0.06557925f, 0.03489202f, -0.05740779f, 0.00153328f, 0.12606819f, 0.00264019f, 
    -0.43789127f, 0.05072099f, 0.12866238f, -0.20652370f, -0.17638738f, -0.00881747f, 0.10441881f, 0.22128786f, 
    -0.18175517f, -0.01810570f, -0.00636427f, -0.01647130f, 0.21168181f, -0.20047255f, -0.06050606f, -0.00961029f, 
    -0.05125287f, -0.10699269f, -0.04629954f, 0.13590887f, -0.00160831f, -0.08451858f, -0.27583367f, -0.08196551f, 
    0.10049108f, 0.04956797f, 0.06419810f, 0.04099774f, 0.09282237f, 0.00229533f, 0.13791579f, 0.07564858f, 
    -0.01031035f, 0.03860132f, -0.08099385f, -0.06264379f, 0.09855004f, -0.11674640f, 0.08523385f, -0.17332649f, 
    0.29455149f, 0.10001349f, -0.11142397f, 0.07418259f, 0.09663074f, -0.15434647f, -0.18991210f, -0.04593507f, 
    0.18044621f, 0.11715338f, -0.01287459f, -0.10674656f, -0.01121889f, 0.06750841f, 0.22630106f, -0.04805278f, 
    0.08657522f, 0.02421057f, -0.11067298f, -0.06856661f, 0.11359991f, 0.10212392f, -0.07115372f, 0.02767228f, 
    -0.09147591f, -0.10950326f, -0.02119735f, -0.07545719f, 0.01382023f, -0.02985931f, -0.08821354f, -0.14693974f, 
    0.04440566f, -0.00434223f, 0.06962148f, 0.02723427f, 0.08231203f, 0.05662314f, 0.05639968f, 0.08832663f, 
    -0.14132619f, -0.14152491f, 0.27642211f, 0.20212613f, -0.10196823f, -0.22739679f, -0.02619268f, 0.02956385f, 
    -0.07613364f, 0.03277586f, -0.06356598f, 0.19556023f, 0.13552533f, -0.06167545f, 0.20938420f, -0.13645554f, 
    0.00095798f, -0.02429551f, 0.13856998f, -0.00304704f, -0.04253142f, 0.36031491f, -0.14566980f, -0.14509808f, 
    0.13258696f, -0.05252752f, -0.02311420f, -0.15063199f, 0.03475401f, -0.15381627f, 0.10911042f, 0.07111442f, 
    0.07116906f, -0.05310580f, 0.05630863f, 0.05388776f, 0.06922045f, -0.06021478f, 0.09567929f, 0.04538783f, 
    0.13574412f, -0.10963769f, -0.17185412f, 0.00519261f, 0.32766891f, -0.09157373f, -0.20226653f, 0.01881099f, 
    0.09830911f, 0.19865240f, 0.00424592f, 0.01158596f, 0.00885567f, 0.04044167f, -0.13646498f, 0.06842838f, 
    -0.16307800f, -0.09270626f, -0.10072962f, -0.05750886f, 0.07783962f, 0.06377745f, 0.02574072f, 0.10684127f, 
    0.13291101f, 0.02305076f, -0.05058635f, 0.08807013f, -0.05187047f, 0.10962516f, -0.11034696f, -0.12291595f, 
    0.01319036f, 0.06057224f, 0.17231213f, -0.04284108f, 0.05050572f, -0.09830232f, 0.13737625f, 0.07008757f, 
    -0.16274802f, -0.03642749f, -0.01705274f, 0.09699044f, 0.07963796f, -0.05791117f, -0.05488796f, -0.04624354f, 
    -0.01382749f, 0.00868530f, 0.14045005f, 0.05930352f, 0.05415006f, -0.07325768f, 0.05028155f, 0.06334127f, 
    0.04125742f, -0.01124386f, 0.00275405f, -0.11746299f, -0.28210664f, 0.09794167f, -0.13090724f, 0.15813994f, 
    0.21463092f, 0.13428216f, 0.13173273f, -0.03329096f, 0.11175615f, 0.23660849f, 0.00739548f, 0.06827947f, 
    0.06596833f, -0.05151229f, 0.06904843f, -0.17329724f, 0.05374384f, -0.10680498f, 0.03876406f, -0.18009114f, 
    -0.01862417f, 0.13660194f, 0.08119300f, 0.03059138f, -0.14993754f, -0.04287288f, 0.04149275f, -0.05042895f, 
    0.00257425f, -0.03742640f, 0.01616706f, -0.09000118f, -0.13104294f, -0.00942965f, -0.15552253f, -0.00012280f, 
    -0.06212724f, -0.00651046f, 0.05547324f, 0.09650314f, 0.06706975f, 0.04449057f, -0.09705888f, -0.00415717f, 
    -0.35040617f, -0.19458216f, 0.03779630f, -0.05917793f, -0.04301622f, -0.04816379f, -0.00409593f, 0.06775913f, 
    0.16989137f, 0.13044071f, -0.00341595f, -0.10241262f, 0.03182103f, 0.13776651f, 0.11210980f, -0.07436445f, 
    -0.02233505f, 0.02690137f, 0.08398978f, 0.21920013f, -0.22044477f, -0.10595571f, 0.07823980f, 0.01668976f, 
    0.02732451f, -0.04956214f, -0.01051776f, -0.00461637f, -0.10303506f, 0.13456963f, 0.12462684f, 0.00590076f, 
    -0.06418762f, 0.18294288f, 0.03492694f, -0.01180140f, 0.21231422f, -0.08658545f, -0.09359048f, -0.08535789f, 
    -0.05579118f, -0.07346581f, -0.10914849f, -0.10512700f, 0.14269274f, 0.08373889f, -0.00371108f, 0.12545478f, 
    -0.15141012f, 0.01241476f, 0.01096539f, -0.06170179f, 0.04696511f, 0.13436851f, -0.20851624f, 0.05196661f, 
    -0.54875416f, -0.08751629f, -0.17043906f, -0.08126820f, 0.10348047f, 0.07657858f, 0.00836380f, 0.04887056f, 
    0.01459298f, 0.00088985f, 0.01510111f, -0.02186118f, 0.08915165f, 0.00737768f, 0.02337116f, 0.13329126f, 
    0.11215118f, -0.15511450f, -0.05873189f, -0.08892924f, 0.02091900f, -0.12913065f, 0.13371502f, -0.00579888f, 
    -0.03558390f, -0.12685056f, 0.00581210f, 0.03489273f, 0.09480437f, 0.01557107f, 0.14541964f, 0.09041379f, 
    0.01703622f, 0.11078450f, -0.14887041f, -0.12700637f, -0.11867245f, -0.15057643f, -0.06546301f, -0.05881534f, 
    -0.03726476f, 0.06641298f, -0.02425872f, 0.00117045f, 0.26341212f, 0.03561899f, 0.02043796f, -0.17633893f, 
    -0.05140483f, 0.03515210f, 0.00133448f, 0.04637764f, 0.10743823f, 0.19865911f, -0.01229011f, 0.11487880f, 
    0.05442873f, -0.03579345f, -0.47577879f, 0.04158336f, -0.41846240f, -0.11005219f, -0.15698747f, -0.15427405f, 
    0.04627287f, 0.16456409f, 0.00421657f, -0.02748381f, 0.04387314f, -0.10729969f, 0.11265291f, 0.06326084f, 
    -0.15785234f, 0.12150107f, -0.04120186f, 0.03534909f, 0.04664971f, -0.02098936f, -0.14496161f, -0.00124473f, 
    -0.31356090f, 0.11288685f, -0.17313546f, -0.16452138f, -0.22276659f, 0.08112014f, -0.03805373f, 0.02155959f, 
    0.00573324f, -0.08949077f, 0.03261435f, -0.01043886f, -0.05515354f, -0.11305021f, -0.07530768f, 0.03095673f, 
    -0.11218926f, -0.00493389f, -0.12209135f, -0.04057807f, -0.61773062f, -0.41665903f, -0.35049024f, -0.23972416f, 
    -0.16749142f, 0.18385164f, 0.02701747f, 0.07873621f, 0.04023352f, -0.18718986f, 0.03376602f, 0.04406791f, 
    -0.06598681f, -0.10334438f, -0.07080730f, -0.03128408f, -0.15246454f, 0.00585851f, -0.20868951f, -0.02701016f, 
    0.15891349f, 0.01546972f, 0.20407456f, 0.04226067f, 0.00821435f, 0.00347404f, 0.11117901f, 0.04908123f, 
    0.01522333f, 0.04166098f, 0.09803978f, -0.10676996f, -0.11923287f, 0.02807049f, 0.01469019f, 0.02098253f, 
    0.00668175f, 0.08702401f, 0.13190070f, 0.09861781f, -0.58828890f, -0.11980554f, -0.06233032f, 0.20135881f, 
    -0.04173429f, -0.03515105f, -0.03162519f, 0.01354590f, -0.16946432f, -0.01115611f, 0.18895829f, -0.04030245f, 
    -0.01518022f, 0.02677487f, -0.07104912f, -0.02676736f, -0.04241112f, 0.00308514f, -0.02098205f, -0.00382284f, 
    -0.51248556f, -0.03010496f, -0.32308885f, -0.15530857f, -0.01436735f, 0.17686838f, 0.14500886f, 0.10473262f, 
    0.02982662f, -0.08846995f, -0.03207603f, 0.06593530f, 0.04117297f, -0.09387240f, 0.00196432f, 0.13678658f, 
    0.02470559f, 0.02430184f, 0.03422824f, 0.09452581f, -0.00801270f, -0.19488257f, 0.00621255f, 0.07695007f, 
    0.07132490f, -0.04652301f, 0.05049209f, 0.01914551f, 0.03835999f, -0.13281679f, -0.11823066f, 0.02456632f, 
    0.02133331f, 0.02377208f, 0.00882861f, -0.03037988f, -0.07987165f, 0.06312008f, 0.06563582f, 0.01704269f, 
    -0.12392432f, 0.21662883f, 0.18899268f, -0.06134416f, -0.24631715f, 0.06772782f, -0.14178377f, 0.11034001f, 
    0.01643851f, -0.13028616f, 0.15142435f, -0.10926528f, -0.08221206f, -0.06532637f, -0.05580120f, 0.12010828f, 
    0.09153461f, 0.20049693f, 0.00313740f, 0.02100595f, -0.16255984f, -0.05127691f, 0.31395346f, 0.26175782f, 
    -0.54089463f, 0.07171430f, -0.00822399f, -0.03328546f, 0.09972171f, 0.12321676f, -0.11197200f, 0.06860495f, 
    0.04516500f, 0.02665045f, -0.03808774f, -0.07797776f, -0.14124988f, -0.09554137f, -0.01416336f, -0.00259152f, 
    -0.66411352f, -0.09927826f, -0.20860416f, -0.16328092f, -0.00131795f, 0.15356603f, 0.04098552f, 0.01072170f, 
    -0.07160882f, -0.09506420f, 0.01590898f, -0.12904452f, -0.01208229f, -0.02706381f, 0.03228332f, -0.00033640f, 
    0.01581653f, -0.05530608f, 0.02293735f, 0.12364496f, -0.02402738f, -0.07007886f, 0.09780200f, 0.06821147f, 
    -0.30402544f, 0.09902086f, -0.01796862f, -0.11765665f, -0.04885075f, -0.00644391f, -0.09907725f, 0.02590523f, 
    0.07815901f, -0.06732175f, 0.01201460f, 0.02562070f, -0.12918162f, -0.02241666f, 0.05163016f, 0.02800998f, 
    0.07808951f, -0.03639411f, 0.04542403f, 0.04599105f, -0.07021087f, -0.16017325f, 0.10492514f, -0.02242315f, 
    -0.05948858f, -0.03233936f, 0.01971222f, 0.14961448f, 0.13275318f, -0.00670555f, -0.03285079f, -0.02308847f, 
    -0.10147792f, 0.11112561f, 0.15474655f, -0.04514983f, -0.04287319f, 0.09502927f, -0.01405526f, 0.23264666f, 
    0.30101225f, -0.18771248f, 0.04101783f, -0.02126431f, 0.07700402f, 0.08288966f, -0.15810989f, -0.15103143f, 
    0.17886811f, 0.12887037f, 0.16013028f, -0.05032826f, 0.07067342f, -0.08137105f, -0.14468752f, -0.10611714f, 
    -0.29938060f, 0.33169448f, -0.21587847f, 0.00735685f, -0.21114333f, -0.23099762f, -0.01638711f, 0.08063543f, 
    0.05827667f, 0.07503563f, 0.12502265f, -0.00524300f, 0.04464744f, -0.09483963f, 0.13774902f, 0.09642503f, 
    -0.09890351f, -0.08760940f, -0.09618188f, -0.00341383f, 0.04324107f, -0.63947445f, -0.16808175f, -0.18798290f, 
    0.03011769f, 0.05122472f, 0.06449987f, -0.06949993f, 0.08658960f, -0.03231147f, -0.01996453f, 0.05560722f, 
    -0.01822590f, 0.15159830f, 0.06489038f, 0.09389073f, -0.00528148f, -0.05798132f, -0.12137067f, -0.00810698f, 
    0.09192082f, -0.06316555f, 0.07510880f, -0.02558723f, 0.21374118f, -0.15471025f, 0.06059323f, -0.18240622f, 
    -0.00322459f, 0.02083453f, 0.03325137f, 0.08923692f, -0.10240424f, 0.07278367f, 0.07590324f, 0.09321275f, 
    0.07506851f, 0.08604010f, -0.13879755f, 0.06465147f, -0.10564519f, -0.24077275f, -0.41568026f, -0.09694584f, 
    0.24194694f, -0.12335076f, 0.08615358f, -0.02939354f, 0.01428909f, 0.00598215f, 0.01340580f, 0.01486485f, 
    0.00506573f, 0.00527492f, 0.03078870f, -0.07273649f, 0.01843520f, 0.17173792f, -0.15461628f, 0.08925109f, 
    0.06434453f, 0.03206059f, -0.00452139f, -0.11303842f, -0.20404688f, 0.14028339f, 0.07263963f, 0.10017913f, 
    -0.08593249f, -0.02611623f, 0.01291761f, 0.05037040f, 0.00161303f, 0.01733704f, -0.04139983f, 0.00364588f, 
    -0.06577619f, 0.05301107f, 0.10976524f, 0.10613656f, -0.42528859f, 0.41252887f, 0.00578607f, 0.14624061f, 
    -0.07641608f, 0.04678884f, -0.04829838f, 0.03699149f, 0.10587522f, -0.03301063f, 0.05420949f, 0.00645113f, 
    0.02595320f, 0.04784198f, -0.08629803f, -0.05257992f, 0.06622817f, -0.02040166f, -0.04585445f, -0.07137264f, 
    0.35798067f, -0.23028955f, -0.02478945f, -0.07160822f, 0.36776370f, 0.06229701f, 0.05241321f, -0.01912976f, 
    0.13114464f, 0.03864592f, -0.02991593f, -0.00645800f, -0.05357647f, -0.07980829f, -0.26678008f, 0.03307714f, 
    0.10003041f, 0.09707554f, -0.00612195f, 0.09559360f, 0.05620003f, -0.34403661f, -0.07109295f, -0.04631580f, 
    0.17558978f, -0.12975049f, 0.08665302f, -0.02900743f, -0.09044714f, -0.01463194f, -0.00154411f, -0.01255388f, 
    0.03997758f, 0.02094503f, -0.10191020f, 0.09596480f, -0.08314221f, 0.00580860f, -0.12984198f, 0.00302755f, 
    -0.15526234f, -0.16024606f, -0.29560012f, -0.21576343f, 0.18217748f, -0.03371958f, 0.10151364f, -0.10482315f, 
    -0.06003032f, 0.04025277f, -0.02447369f, -0.20514542f, 0.00396390f, -0.07212012f, 0.03884289f, 0.06476324f, 
    0.08495530f, 0.19244018f, 0.09436398f, 0.07036242f, -0.11255319f, 0.28601155f, -0.03745480f, 0.09714568f, 
    -0.45463648f, 0.04644928f, 0.07272858f, -0.00855049f, 0.08523928f, -0.01738660f, 0.08122133f, 0.12454894f, 
    -0.03003683f, -0.02174110f, -0.08835077f, 0.00555024f, -0.17167772f, 0.04968615f, -0.05721248f, -0.05730310f, 
    0.08573863f, -0.24613607f, 0.01385133f, -0.11274694f, 0.39876312f, -0.02311957f, -0.01623351f, 0.02607310f, 
    0.06744007f, 0.05843735f, -0.07785710f, -0.01992405f, -0.07632237f, 0.00732043f, 0.06026317f, -0.07340071f, 
    -0.02904213f, 0.10981595f, -0.09993365f, 0.02542412f, 0.01002308f, -0.08124790f, -0.07837897f, -0.43096873f, 
    0.06023081f, -0.01757520f, 0.01174943f, -0.00874235f, -0.15087536f, -0.17176813f, 0.00920016f, -0.15125199f, 
    -0.06423320f, -0.01803216f, -0.07757735f, -0.00712405f, 0.01833417f, 0.03572517f, 0.14106284f, 0.06931986f, 
    0.47467777f, -0.14891973f, 0.17576119f, 0.17537819f, 0.16521670f, 0.03939435f, -0.00062537f, -0.02078065f, 
    -0.02954167f, -0.03753276f, -0.00883377f, -0.06371555f, 0.11653644f, 0.05218292f, 0.12612301f, -0.00510113f, 
    0.00377745f, -0.15535203f, -0.13103807f, -0.26787159f, 0.07131687f, -0.00442996f, 0.21593690f, -0.00994002f, 
    -0.15215781f, 0.07750504f, -0.14092064f, 0.07525186f, 0.06537364f, -0.06617741f, 0.00597623f, -0.13950790f, 
    -0.11163963f, 0.04856234f, 0.02972306f, 0.03624793f, 0.10225510f, -0.11516821f, 0.07292625f, 0.00017201f, 
    -0.20804863f, 0.31362021f, 0.05924274f, 0.14265297f, -0.12154460f, -0.02339574f, 0.03615765f, 0.09822166f, 
    0.05347346f, 0.09847775f, -0.10633153f, 0.04443443f, 0.05315740f, -0.12712710f, -0.11778217f, -0.01528577f, 
    0.06482836f, -0.01825294f, 0.03842741f, -0.12445670f, 0.17760372f, 0.01393099f, 0.13252997f, 0.05637040f, 
    -0.00276388f, 0.05005500f, -0.01116412f, 0.05746311f, -0.08659039f, -0.21827769f, 0.07882433f, -0.13782124f, 
    0.11647877f, -0.00740300f, 0.08122054f, 0.08565248f, 0.01430767f, 0.09384547f, 0.11227766f, 0.05346957f, 
    0.17109314f, -0.21820576f, -0.05805372f, -0.07992823f, -0.03828060f, 0.02405199f, 0.09057252f, 0.00972125f, 
    -0.10845103f, -0.11790850f, 0.06121078f, -0.06858208f, -0.11059698f, -0.03317096f, 0.06201410f, -0.07678171f, 
    -0.05975048f, 0.06490587f, -0.09978777f, 0.04323633f, -0.27005756f, -0.16016485f, -0.02155440f, 0.21524784f, 
    0.14638209f, 0.08430880f, 0.03439355f, 0.07507508f, 0.12963083f, -0.13457642f, -0.20345195f, 0.07549968f, 
    -0.14536305f, 0.03183104f, -0.08874723f, -0.00169148f, 0.04239092f, 0.19671081f, 0.15516229f, 0.11933412f, 
    -0.17584653f, 0.06648926f, -0.12393473f, -0.17805645f, 0.00293412f, -0.07441105f, 0.06234740f, 0.04960147f, 
    -0.12022897f, 0.03256014f, 0.05406841f, -0.10343903f, -0.22486690f, -0.03459138f, 0.00176041f, -0.10961321f, 
    0.00027829f, -0.01427723f, 0.07514030f, -0.03749937f, -0.53838712f, -0.08293912f, -0.01503962f, -0.24830678f, 
    0.10186604f, 0.05023325f, -0.01182373f, 0.06389473f, -0.08521686f, 0.00797344f, -0.04416082f, -0.12101999f, 
    0.11149070f, -0.01782819f, 0.01571683f, 0.10391805f, -0.05207664f, -0.06631269f, 0.04528925f, 0.15886056f, 
    0.40426409f, -0.07466955f, 0.10678003f, -0.03920950f, 0.04670855f, -0.07784702f, 0.01621393f, 0.00743636f, 
    -0.06485546f, -0.05224139f, 0.00812521f, -0.04600045f, 0.06386027f, 0.00237982f, 0.06275051f, -0.00006648f, 
    -0.03201993f, 0.12820986f, 0.04661696f, 0.03370158f, -0.03762446f, -0.13044202f, 0.04967647f, -0.22638167f, 
    -0.09218341f, -0.12647822f, 0.11236449f, 0.11559477f, -0.11777636f, 0.07194785f, 0.06697896f, -0.07352078f, 
    0.10452836f, 0.04010138f, 0.01723535f, -0.07184324f, 0.06727967f, 0.04373237f, 0.10270423f, 0.02383984f, 
    -0.43146735f, 0.07540911f, -0.21821302f, 0.32010782f, -0.04360803f, -0.20238966f, 0.03368012f, -0.06772859f, 
    0.05129666f, 0.03545389f, -0.08270509f, 0.10608768f, 0.04736352f, -0.06789560f, 0.06491649f, -0.07275786f, 
    -0.06869762f, -0.09551910f, -0.16637568f, -0.10511889f, -0.02153691f, -0.31791681f, 0.14064689f, 0.00788553f, 
    0.07936481f, 0.01965634f, -0.09727453f, 0.08310093f, -0.03184767f, 0.06002618f, -0.10328815f, 0.02779254f, 
    -0.03764128f, -0.03028432f, -0.07342921f, -0.04198683f, 0.00070722f, 0.09809744f, -0.04050101f, 0.02513025f, 
    -0.14536506f, -0.39060789f, -0.03020454f, -0.43097615f, 0.12401004f, -0.08408633f, 0.03108533f, -0.06465101f, 
    -0.02044504f, 0.01659350f, -0.04423547f, -0.01503397f, 0.02051190f, 0.12973768f, -0.04694805f, -0.03184752f, 
    0.03841353f, -0.10406912f, -0.04589702f, -0.06974836f, -0.29861480f, 0.14866808f, 0.03532937f, 0.12861581f, 
    -0.43695533f, 0.00787800f, -0.04002944f, 0.10401491f, 0.07039607f, 0.09535655f, -0.00008207f, -0.10947454f, 
    0.08762845f, -0.01619447f, 0.07726836f, 0.01222528f, -0.04087410f, -0.07313678f, -0.05736096f, -0.01701846f, 
    0.28406948f, -0.64414662f, -0.19880456f, 0.19958609f, -0.11693624f, -0.16201624f, 0.08987955f, -0.12831423f, 
    0.03202396f, 0.02743946f, -0.08645075f, 0.06060302f, 0.04997159f, 0.06819600f, 0.11204123f, 0.04232160f, 
    -0.03485567f, -0.08400402f, -0.05461054f, -0.07717241f, -0.06702638f, 0.13622460f, 0.06924555f, 0.15790254f, 
    0.16485298f, -0.04760803f, -0.03021845f, -0.03957368f, -0.01712224f, -0.00529561f, 0.06332471f, 0.02798957f, 
    0.07175432f, 0.07330560f, -0.07760369f, -0.01793544f, 0.01310934f, 0.11598458f, -0.03021820f, 0.01120788f, 
    0.34088525f, -0.05843182f, -0.16217928f, -0.30649191f, 0.02278453f, 0.01790189f, 0.05553258f, 0.01836161f, 
    -0.02576032f, -0.18969868f, -0.01716231f, 0.12122549f, 0.04604552f, -0.04725063f, 0.03042371f, -0.08605985f, 
    -0.05860925f, 0.08661797f, -0.19875020f, 0.12883985f, 0.27088344f, 0.04047499f, 0.01544879f, -0.14519566f, 
    -0.04910000f, 0.04617192f, 0.03194244f, 0.16674022f, 0.03102408f, 0.09253506f, -0.00784416f, 0.01557606f, 
    -0.10508249f, -0.10528789f, 0.11072770f, 0.00778445f, 0.12244730f, -0.02773518f, 0.12551798f, -0.14107504f, 
    -0.15788130f, 0.11494882f, 0.10022636f, 0.03621880f, -0.23882869f, 0.09088458f, -0.14417127f, 0.07540365f, 
    0.02182366f, 0.07617067f, -0.06477398f, -0.00176397f, -0.06662717f, 0.10953994f, -0.13482578f, 0.02919838f, 
    -0.04721981f, -0.08904805f, -0.06998112f, -0.08612256f, 0.01764661f, 0.34441090f, 0.14422841f, -0.10356612f, 
    -0.16450818f, 0.04764973f, -0.05856168f, 0.06784083f, 0.00536736f, 0.02863646f, -0.05902343f, 0.02845523f, 
    -0.14645489f, 0.07405774f, 0.02391616f, 0.19130880f, -0.13822103f, -0.04010160f, 0.13178313f, 0.02882783f, 
    0.18505839f, 0.24215272f, -0.09560744f, -0.15432781f, -0.07368364f, -0.04082466f, -0.04474114f, -0.03921394f, 
    -0.02562275f, -0.03494214f, 0.02474076f, 0.06004281f, -0.02284254f, 0.02863290f, -0.13856086f, 0.03367002f, 
    -0.00369359f, -0.02222169f, -0.06949235f, -0.05020364f, -0.05619697f, 0.03544854f, 0.12487940f, 0.12103980f, 
    0.17194270f, 0.08761717f, 0.15394221f, 0.00406903f, -0.03623905f, -0.09302580f, 0.01002440f, 0.00323906f, 
    0.01805544f, -0.02846586f, -0.10884915f, -0.01723165f, -0.02596016f, -0.04322435f, -0.07679515f, -0.01742509f, 
    -0.18480411f, 0.15844864f, 0.19470270f, 0.13790932f, 0.10889606f, 0.13465272f, 0.00894678f, 0.05865604f, 
    0.08174095f, 0.07323806f, -0.13315454f, -0.00845899f, 0.05470458f, 0.03546713f, -0.08629727f, 0.09022865f, 
    0.10756432f, 0.01845147f, 0.05949293f, 0.02756696f, -0.19662093f, 0.21594208f, -0.14151852f, 0.07004664f, 
    0.11518065f, -0.13764508f, 0.08611622f, -0.06374589f, -0.09450523f, -0.08896606f, -0.10282464f, 0.04185569f, 
    -0.04758206f, -0.05867436f, -0.16644301f, 0.08722863f, 0.02794273f, 0.07321441f, 0.01289453f, 0.03323654f, 
    0.17179398f, -0.28296709f, -0.07152212f, 0.02419139f, 0.09187379f, 0.00969227f, -0.11915335f, -0.05481570f, 
    -0.00200985f, 0.01418831f, -0.07088778f, 0.03280760f, -0.01261851f, -0.00223398f, -0.01703312f, -0.09662735f, 
    0.04994852f, 0.03243006f, -0.01579760f, 0.05058705f, -0.42922083f, -0.07301342f, -0.00799951f, -0.20335583f, 
    -0.25935602f, 0.01797711f, -0.00662775f, 0.02569739f, -0.03363157f, -0.10398725f, 0.04556393f, -0.06674929f, 
    -0.04180839f, -0.02136665f, -0.01362791f, -0.01652757f, 0.06967316f, 0.01811038f, 0.00425115f, 0.03734767f, 
    -0.05261729f, 0.14772949f, -0.14146510f, 0.26512179f, 0.05984199f, 0.14614876f, -0.07289390f, 0.04700863f, 
    -0.00704243f, -0.00859135f, -0.04886137f, 0.06896962f, 0.06565122f, -0.10260580f, 0.02778381f, 0.16531664f, 
    -0.01740962f, 0.04207247f, 0.01507737f, -0.01246724f, -0.14091279f, 0.10749978f, 0.06864143f, -0.10951971f, 
    0.08653486f, -0.13349132f, 0.08274842f, -0.09113947f, -0.06074137f, -0.03210255f, -0.04316934f, -0.02371505f, 
    -0.11864223f, -0.02129962f, -0.02456505f, -0.05427590f, 0.05385929f, -0.00279144f, -0.01801666f, 0.00898039f, 
    0.07129515f, 0.18218987f, -0.12708472f, 0.21191844f, 0.21983454f, -0.08740121f, 0.05960204f, -0.02435611f, 
    -0.07474995f, 0.01521647f, -0.12116854f, 0.02301043f, -0.07316186f, -0.02193124f, -0.11697271f, -0.02496989f, 
    0.09226677f, 0.06431056f, -0.10730787f, -0.12366068f, -0.46481764f, -0.02148311f, -0.26201668f, -0.19366874f, 
    -0.12958312f, -0.04887088f, -0.07508946f, -0.02895208f, 0.01837202f, -0.10628138f, -0.09195819f, -0.00357259f, 
    0.03374683f, 0.00820948f, -0.05661966f, 0.01428515f, -0.00322301f, 0.05600290f, -0.01258000f, 0.04613812f, 
    -0.20119427f, 0.04264715f, -0.19875243f, -0.04209026f, -0.09357857f, -0.12275208f, 0.05142726f, -0.11367808f, 
    0.05379970f, -0.08252136f, -0.03896049f, 0.06744067f, -0.10100187f, -0.03447707f, 0.01332985f, -0.05228734f, 
    -0.03238996f, 0.03639437f, -0.09188259f, -0.05233075f, 0.14356904f, 0.04941976f, 0.12849128f, 0.02347614f, 
    0.25421613f, -0.03934999f, 0.09012794f, -0.02134470f, 0.01282288f, 0.02121150f, -0.01337924f, -0.00089279f, 
    -0.17010459f, -0.00386503f, -0.10814882f, -0.09278792f, 0.04328267f, -0.04106700f, -0.05526353f, -0.05591343f, 
    0.17269845f, 0.02731080f, -0.11646102f, -0.20513524f, 0.01740682f, -0.22066674f, 0.10053758f, 0.04275447f, 
    0.03121360f, -0.00865359f, -0.00949251f, -0.01882323f, -0.05500402f, 0.06757230f, -0.00428774f, -0.02801382f, 
    0.03563660f, -0.00879965f, -0.06875881f, -0.09342800f, 0.15899527f, -0.20092839f, 0.06476854f, -0.09367009f, 
    -0.15149657f, -0.03532567f, -0.05026005f, 0.00024029f, -0.03244742f, -0.06326858f, -0.06834614f, -0.08179543f, 
    -0.01597248f, 0.01907264f, 0.00114009f, -0.04840128f, -0.03676124f, 0.01952321f, -0.03911072f, -0.05567363f, 
    -0.16130704f, 0.00090028f, -0.33474848f, -0.27798411f, -0.10975601f, 0.05651195f, -0.09846327f, -0.03419445f, 
    0.02629630f, -0.08481105f, -0.10752249f, -0.03328767f, -0.03794000f, -0.03817692f, -0.02961267f, 0.03898309f, 
    0.00838380f, -0.02751181f, 0.01331641f, 0.01636792f, 0.24686085f, -0.08133044f, 0.03473869f, -0.08459486f, 
    -0.17827798f, 0.07967871f, -0.01120497f, 0.01263672f, -0.18742825f, 0.10654444f, -0.02185343f, -0.02034079f, 
    0.03271755f, -0.03355362f, -0.08232239f, -0.11302067f, 0.10642073f, -0.06876121f, 0.09547959f, -0.07583383f, 
    0.03313685f, 0.11548856f, 0.28200680f, 0.01603849f, 0.07903647f, -0.04129824f, 0.04856144f, 0.01814087f, 
    0.01458172f, -0.05839550f, -0.01026538f, 0.06549420f, -0.08669338f, -0.00469649f, 0.01205778f, -0.13349456f, 
    -0.01451869f, 0.01194332f, 0.07111913f, -0.06393929f, -0.09100055f, -0.01129734f, 0.09313416f, 0.14153433f, 
    0.04672872f, 0.17022662f, -0.11530436f, -0.14738774f, 0.10440838f, 0.01003882f, -0.03785664f, -0.04796344f, 
    -0.04283001f, 0.00448320f, -0.12145225f, 0.01725083f, -0.13373303f, -0.02878182f, -0.04018695f, -0.01829568f, 
    0.07812913f, 0.01104587f, 0.12522462f, 0.03083542f, 0.11710261f, -0.06669282f, -0.04454248f, -0.04229561f, 
    -0.08748356f, 0.04687293f, 0.03085237f, -0.04326466f, -0.02856532f, -0.02081143f, -0.07534834f, -0.09575106f, 
    -0.04500009f, 0.03814511f, 0.13032523f, -0.05115516f, 0.19708875f, -0.00565202f, 0.25609076f, -0.07586838f, 
    0.04417288f, 0.08871561f, 0.02294084f, -0.10409099f, 0.02242999f, 0.04818416f, -0.03558880f, 0.04015925f, 
    -0.03826416f, 0.00198426f, -0.09237186f, -0.01555758f, -0.01935181f, -0.02701876f, 0.06941096f, -0.01049116f, 
    0.18763109f, -0.10953382f, 0.08676810f, -0.01823455f, 0.29383528f, -0.06558009f, 0.00226737f, -0.06005075f, 
    0.03850424f, 0.01519918f, -0.02266976f, 0.05610212f, -0.10527672f, 0.03705982f, -0.03589826f, 0.00596656f, 
    -0.05221416f, -0.01234029f, 0.02640861f, -0.08079088f, 0.22361191f, 0.03830980f, 0.24108644f, 0.03143768f, 
    0.17995784f, 0.06949632f, 0.08680896f, -0.11199091f, -0.05794327f, 0.03112386f, -0.07011070f, 0.05754797f, 
    -0.07993442f, -0.02605380f, -0.08721618f, 0.01481188f, 0.01886506f, -0.08138588f, 0.08280946f, -0.07929768f, 
    -0.25098309f, 0.19931617f, 0.09346181f, -0.08658735f, -0.14749575f, 0.00524901f, -0.06360502f, 0.06876343f, 
    -0.00212855f, -0.09446608f, 0.05935876f, 0.02160841f, 0.02998403f, -0.01574585f, -0.05629030f, 0.02663663f, 
    0.05058531f, -0.03898295f, 0.00763661f, -0.02749025f, 0.05823248f, -0.47804159f, 0.14614080f, 0.10806676f, 
    -0.19072261f, 0.17727199f, -0.09571360f, -0.07827017f, -0.04127971f, 0.13246106f, -0.02670235f, 0.05860132f, 
    -0.06924640f, 0.06630161f, -0.12420522f, -0.02833783f, 0.09676386f, -0.00730983f, -0.11157208f, 0.05275988f, 
    0.11475395f, 0.10326704f, 0.24156870f, 0.15093710f, 0.16506629f, 0.07163048f, 0.10996351f, 0.01174937f, 
    -0.01511058f, -0.04321072f, -0.06518058f, -0.02610877f, -0.02621749f, -0.00379741f, -0.08769815f, -0.06420815f, 
    0.04700783f, 0.00924965f, -0.00486609f, -0.01799347f, -0.12082918f, -0.14915165f, -0.24529502f, -0.09202477f, 
    -0.17820241f, -0.03235824f, -0.08992396f, 0.04238724f, -0.04283214f, -0.14534239f, -0.01137166f, -0.03711148f, 
    -0.06568920f, -0.01568205f, -0.06509250f, 0.01209163f, -0.00929612f, -0.09882414f, -0.02848962f, -0.08221316f, 
    0.01179447f, -0.04559693f, 0.02478702f, -0.01362729f, -0.17343409f, 0.01164365f, -0.14016220f, 0.02923804f, 
    -0.03761267f, -0.06665695f, -0.01897738f, 0.05818336f, 0.08644217f, -0.00430150f, 0.00191830f, 0.04095560f, 
    -0.04939752f, 0.02209937f, 0.00459119f, -0.01562670f, -0.45096010f, 0.23080330f, 0.03974964f, 0.05158626f, 
    -0.01547021f, 0.11095361f, -0.08415420f, -0.06331351f, 0.10140341f, -0.00833796f, 0.01670697f, 0.03436083f, 
    0.07192474f, -0.01469739f, 0.00047074f, 0.08153933f, -0.00243136f, -0.01620009f, -0.09900068f, -0.09732675f, 
    0.12759797f, 0.19020219f, 0.32050401f, 0.05581924f, 0.17232834f, -0.03653595f, 0.15956080f, -0.03614166f, 
    0.01528507f, -0.03441425f, -0.06960331f, 0.00302558f, -0.04286799f, -0.01573574f, -0.10033724f, -0.00865607f, 
    -0.10567573f, 0.02169930f, 0.10528831f, -0.09519338f, 0.07844008f, -0.36038041f, -0.05276233f, -0.03015628f, 
    -0.15284416f, -0.01951557f, -0.15280373f, -0.04851132f, -0.01571814f, -0.03961815f, -0.04147163f, 0.06959561f, 
    -0.03372130f, 0.06218921f, -0.02758033f, -0.04927883f, 0.09265131f, -0.07128225f, 0.05043104f, -0.00447577f, 
    0.11085108f, -0.41460446f, -0.03614779f, -0.11165401f, -0.21233158f, -0.03855852f, -0.07943515f, -0.04857421f, 
    -0.04750408f, -0.09798966f, 0.00625761f, -0.02345715f, -0.09305324f, 0.02072362f, -0.03399854f, 0.02913720f, 
    0.06974546f, -0.00771328f, -0.01331142f, -0.08407689f, 0.07657038f, -0.11635973f, -0.26490226f, 0.05900794f, 
    0.28807488f, -0.10081612f, -0.14441775f, -0.04270153f, -0.00426625f, -0.05312870f, -0.12671414f, 0.02808806f, 
    -0.05858079f, -0.01985796f, -0.08121412f, -0.04196479f, 0.00438908f, -0.02666138f, -0.04291682f, 0.09813610f, 
    -0.02947814f, 0.04229429f, -0.13027096f, -0.01165321f, 0.05066303f, -0.01700901f, 0.05406644f, -0.22585399f, 
    -0.03527471f, -0.01071046f, 0.03369854f, 0.05071509f, -0.00087497f, -0.08510933f, 0.01413508f, -0.08239008f, 
    0.05366009f, 0.02747012f, -0.00658742f, -0.05933399f, -0.03884463f, -0.00283967f, 0.20887850f, -0.07112735f, 
    0.12060461f, -0.07019974f, -0.09143353f, -0.02949965f, -0.01224460f, 0.03835618f, 0.02002901f, 0.00171954f, 
    -0.04942268f, -0.10304633f, 0.04993818f, -0.04615288f, -0.07859893f, 0.07523853f, 0.04080075f, -0.04008462f, 
    -0.13417056f, -0.19662920f, 0.08846412f, -0.06129475f, -0.10151569f, 0.03545165f, -0.16012757f, -0.07257553f, 
    -0.08150767f, 0.04386477f, 0.01551921f, -0.02801395f, -0.08811190f, -0.07469240f, 0.01346925f, 0.06171771f, 
    0.02244847f, -0.05888651f, 0.02326735f, -0.01098423f, -0.01260437f, 0.22380887f, 0.12553190f, 0.05048433f, 
    -0.30280659f, -0.05247341f, -0.01062637f, -0.05843313f, -0.05264581f, -0.07453000f, 0.07187133f, -0.05778799f, 
    0.08568165f, 0.03901878f, -0.03309418f, -0.04629114f, -0.01222271f, -0.10005848f, 0.11728805f, -0.10096282f, 
    -0.17740841f, -0.26044253f, -0.10120025f, -0.28894353f, 0.02684567f, 0.01631560f, -0.02062569f, -0.09356931f, 
    -0.04084025f, -0.03749612f, 0.10478672f, 0.05607155f, -0.04010315f, 0.15770282f, 0.00722196f, 0.09734810f, 
    0.02715619f, 0.06195465f, -0.20581490f, -0.05733799f, 0.12807630f, 0.12897903f, -0.19941662f, 0.03962184f, 
    0.13985002f, 0.18184087f, 0.05298945f, -0.01609989f, -0.08970402f, 0.02970188f, -0.06488995f, 0.03135180f, 
    -0.08449341f, 0.06538371f, -0.03655418f, -0.03167145f, -0.07442074f, 0.04207293f, 0.07461693f, -0.06303933f, 
    -0.21852429f, -0.41850984f, -0.12477998f, -0.36799350f, -0.47698194f, 0.06276152f, -0.11994214f, -0.10095585f, 
    0.02161356f, -0.01235725f, 0.17476510f, 0.05077337f, 0.04633271f, -0.06630866f, 0.17327636f, -0.04418076f, 
    -0.04039625f, -0.03378032f, -0.01658490f, -0.06293174f, 0.08768504f, 0.14670822f, 0.00690370f, -0.00784953f, 
    -0.05481260f, -0.14202058f, -0.09820100f, -0.00565946f, -0.06306827f, 0.05257437f, 0.04411150f, -0.07930171f, 
    -0.03508131f, -0.12967157f, -0.06735606f, -0.07240772f, -0.09246162f, -0.10574336f, 0.10479126f, -0.01438966f, 
    -0.21224640f, 0.13847350f, -0.06376223f, -0.11850922f, -0.19563051f, -0.14126532f, -0.03365273f, 0.03092623f, 
    -0.13832900f, -0.13692060f, 0.12085158f, 0.10386966f, 0.11560338f, 0.07809607f, 0.07121781f, -0.18477726f, 
    0.07501214f, -0.27969718f, 0.00236917f, -0.00444724f, 0.13649030f, -0.01041133f, -0.22920081f, 0.13842329f, 
    0.20854907f, 0.19704473f, 0.06266566f, -0.02183796f, -0.05880288f, -0.07022066f, -0.00900028f, -0.00591836f, 
    0.09034181f, 0.03478104f, 0.01993609f, -0.03107895f, 0.03210268f, 0.03589867f, 0.10872761f, -0.02175885f, 
    0.06470125f, 0.17042370f, 0.09589759f, 0.02954485f, -0.06199423f, -0.12385995f, -0.01016226f, -0.05650169f, 
    -0.09256193f, -0.12715910f, 0.08601107f, 0.05348219f, -0.01149449f, 0.10230916f, -0.05349171f, -0.17705113f, 
    0.03135395f, -0.09487466f, 0.11736952f, -0.04753859f, -0.00594946f, 0.18308210f, -0.02554532f, -0.17245334f, 
    -0.25603479f, -0.10110463f, 0.10326350f, 0.04772772f, -0.06685805f, -0.04538496f, 0.01123375f, -0.04150913f, 
    0.01785883f, -0.01836892f, -0.05142545f, -0.00670391f, -0.07591812f, -0.24919616f, 0.00520874f, -0.07370851f, 
    0.07696459f, -0.10046747f, 0.01577932f, -0.05400058f, 0.01085125f, 0.00596543f, 0.02704355f, -0.06923383f, 
    -0.04661828f, -0.13204318f, 0.12456171f, 0.03741715f, 0.01157634f, 0.04637302f, 0.01061575f, 0.05639038f, 
    0.09096906f, 0.06508428f, 0.01206033f, 0.03896711f, 0.04609070f, 0.01115427f, 0.00121086f, 0.15523641f, 
    0.11723627f, 0.13433224f, 0.00540689f, -0.01056795f, -0.04869772f, -0.10127287f, 0.02768371f, 0.04974756f, 
    -0.01965683f, 0.04840572f, 0.02545008f, -0.08387018f, -0.04655684f, 0.04951494f, 0.07068449f, -0.12069380f, 
    0.04044232f, 0.07451216f, -0.08784968f, -0.02825707f, 0.11821356f, 0.10447577f, -0.00415298f, -0.05372145f, 
    -0.01237003f, -0.01500923f, 0.13431899f, 0.14801110f, 0.06294227f, 0.11456796f, -0.03440688f, -0.05635655f, 
    0.02080839f, 0.08661047f, 0.07571442f, -0.05186420f, 0.04587597f, -0.07881071f, -0.00053123f, -0.05488969f, 
    0.01350243f, 0.11568104f, -0.09496070f, 0.04454086f, -0.15939140f, -0.00569077f, -0.01836808f, 0.02297910f, 
    -0.07019706f, 0.10129049f, 0.12422714f, 0.03753281f, -0.11741491f, 0.07066126f, -0.20048745f, 0.07003734f, 
    0.10232630f, -0.02427697f, -0.04346781f, 0.05984864f, -0.17752612f, -0.17290425f, 0.15569988f, 0.08084576f, 
    0.00067279f, -0.00961392f, 0.01079654f, -0.01838241f, -0.02977234f, 0.09423824f, 0.01890153f, 0.08440373f, 
    -0.04297936f, -0.20581405f, 0.06504668f, 0.01673953f, 0.02743497f, 0.14001027f, -0.48316494f, 0.03550240f, 
    -0.14358534f, 0.03918914f, -0.05249574f, -0.18348122f, -0.09254781f, -0.08692973f, 0.06142255f, 0.03483055f, 
    0.05395857f, 0.07562187f, 0.00979794f, 0.06936903f, -0.13307124f, -0.20935665f, 0.05633180f, -0.14536949f, 
    -0.15722007f, -0.10698294f, 0.06012107f, -0.28453812f, -0.15170591f, -0.05298943f, -0.11228406f, -0.04377273f, 
    -0.07016063f, -0.23555738f, 0.01898425f, 0.03285772f, 0.12371416f, 0.10789206f, -0.03143662f, 0.01371168f, 
    -0.03254441f, -0.00450833f, -0.41803396f, 0.03795518f, -0.20553136f, 0.00641959f, 0.13216725f, -0.00711820f, 
    0.07747506f, -0.06859934f, -0.09239762f, 0.08478167f, -0.10244796f, -0.01857404f, 0.01725197f, 0.00516860f, 
    -0.05009921f, 0.08684441f, 0.07028379f, -0.00917887f, -0.11171412f, 0.01793643f, -0.10736100f, 0.01537182f, 
    -0.26358843f, -0.14401658f, 0.17594843f, -0.09187355f, 0.01977667f, 0.05300141f, 0.07200127f, -0.01447320f, 
    -0.08373739f, -0.00500832f, 0.10796753f, -0.03287307f, -0.03573374f, 0.03627406f, 0.07887320f, -0.00809352f, 
    -0.00808364f, 0.09754649f, -0.16785870f, 0.02867703f, -0.20722266f, -0.23183620f, 0.32150331f, -0.16116260f, 
    -0.00603297f, 0.08656833f, 0.05921422f, 0.10530727f, -0.16284572f, -0.04618367f, 0.01578712f, 0.02113185f, 
    0.10411775f, 0.06448744f, 0.07691948f, 0.01483631f, -0.00647694f, 0.09037748f, -0.30029574f, 0.04245408f, 
    0.18103763f, 0.19496283f, -0.08324988f, 0.07685030f, 0.14206710f, 0.11093922f, -0.01824077f, -0.11545609f, 
    -0.05667048f, -0.00199237f, -0.10673302f, 0.08607794f, -0.04021031f, -0.03001222f, -0.06326818f, -0.01703701f, 
    0.00598301f, 0.05013970f, 0.07321472f, 0.08109418f, 0.02603901f, 0.04063169f, 0.06465313f, 0.14442666f, 
    0.23303410f, -0.18918031f, -0.03110493f, -0.12091943f, -0.18744683f, 0.12316667f, -0.01033833f, -0.03265696f, 
    0.06232676f, -0.09745664f, -0.13711157f, 0.04895434f, -0.10506705f, -0.03126654f, 0.15312439f, -0.07427369f, 
    -0.19093630f, -0.07124127f, 0.28674400f, -0.00351167f, 0.21840367f, -0.03911586f, -0.03862818f, 0.07352015f, 
    -0.06390508f, -0.03407122f, 0.05164842f, -0.06808842f, -0.03816320f, -0.16159338f, 0.02783850f, -0.03246547f, 
    0.03626570f, 0.04272996f, 0.03382383f, 0.05760165f, 0.17688341f, -0.01403532f, -0.16198294f, 0.17588633f, 
    0.16026634f, 0.06548953f, 0.05672395f, -0.08878702f, -0.09513942f, -0.00984670f, -0.18224864f, -0.01508497f, 
    -0.04777063f, -0.05831927f, 0.05287137f, -0.04590768f, 0.00365481f, 0.04146452f, 0.08822606f, -0.01407440f, 
    0.17529833f, 0.08544010f, 0.00335387f, 0.06735250f, 0.19188702f, -0.14185572f, -0.16354100f, -0.09814905f, 
    -0.07154001f, 0.05593062f, -0.12639149f, 0.00955419f, -0.11435685f, -0.01735899f, 0.07190254f, -0.02587232f, 
    0.06057410f, 0.05247603f, 0.02290084f, 0.03039247f, -0.34067103f, 0.14407317f, -0.16936043f, -0.06731155f, 
    -0.14377455f, 0.05455267f, -0.14132085f, -0.24264856f, -0.00838099f, -0.05607386f, 0.11302927f, -0.04578517f, 
    0.00263570f, -0.04292423f, 0.13188984f, -0.03489321f, 0.02342722f, -0.11277217f, 0.03178208f, -0.03903534f, 
    -0.22621171f, -0.03483968f, 0.23483810f, -0.00036058f, -0.03576470f, -0.10302189f, 0.08775565f, -0.02284701f, 
    -0.11028702f, -0.02665419f, 0.03793853f, 0.00028357f, -0.10906720f, 0.04445992f, 0.09823308f, 0.03092177f, 
    0.03188551f, -0.01359261f, 0.10699233f, -0.02267519f, 0.05158824f, -0.08591305f, 0.01067684f, -0.03946895f, 
    0.13309185f, -0.00395931f, 0.07167310f, -0.13037263f, 0.01690994f, -0.03095695f, -0.04450080f, 0.02464937f, 
    0.03719687f, -0.07686357f, 0.15675180f, -0.00000691f, -0.01833875f, 0.01155623f, 0.12002403f, -0.04260023f, 
    0.16721231f, 0.01141094f, -0.06023699f, 0.21653250f, 0.13772236f, 0.08827734f, 0.02549371f, -0.13887329f, 
    -0.10833119f, -0.02548358f, -0.00382103f, 0.02619003f, -0.05218974f, -0.05305963f, 0.07795564f, -0.05955758f, 
    -0.02347943f, 0.03480056f, 0.13321197f, -0.03947051f, -0.27388310f, -0.23684071f, -0.16072437f, -0.22231503f, 
    0.11091096f, 0.17516685f, 0.09972325f, -0.16222574f, -0.12362929f, -0.12300732f, 0.02759929f, 0.01079933f, 
    0.12464353f, -0.02936938f, -0.07849113f, -0.08009430f, 0.21134876f, 0.07721612f, -0.08995362f, -0.18952475f, 
    -0.19866700f, -0.05522947f, 0.07968628f, 0.03192375f, -0.08597726f, 0.03981355f, 0.13117039f, -0.11913868f, 
    0.03083998f, -0.10958862f, -0.12157996f, 0.14462881f, -0.05449611f, 0.08409624f, 0.07407456f, 0.05650120f, 
    0.00619879f, -0.17987610f, -0.19877362f, 0.00169182f, 0.43932530f, 0.00402632f, 0.00428665f, -0.08853145f, 
    0.09024621f, 0.11163499f, -0.03863070f, 0.02220093f, -0.06071132f, 0.21237478f, -0.08021919f, 0.01970239f, 
    0.13459568f, 0.09924038f, -0.05569228f, 0.04627925f, 0.01905512f, -0.00413733f, 0.04715897f, -0.09998014f, 
    0.06912215f, -0.52007729f, 0.03745991f, 0.27267078f, 0.15077250f, -0.00065891f, 0.01786021f, 0.19169551f, 
    0.03424443f, 0.04276526f, -0.17335428f, 0.07242141f, -0.05901625f, 0.13797672f, -0.07443848f, -0.02193689f, 
    0.01257631f, 0.06856875f, -0.02228366f, 0.00694413f, -0.27012151f, 0.38940299f, 0.20648906f, 0.02541300f, 
    -0.00295469f, 0.14304100f, 0.01425527f, -0.04055008f, -0.01842258f, 0.06876306f, -0.08391695f, -0.04295870f, 
    0.07850444f, -0.06181978f, 0.16759196f, 0.16402720f, 0.08151235f, 0.04457431f, -0.09777821f, -0.00458650f, 
    -0.03015764f, -0.27317607f, 0.41421676f, -0.16864757f, -0.03742788f, -0.02412730f, 0.00925274f, 0.01220139f, 
    -0.08244832f, 0.06583674f, 0.11878212f, -0.00616295f, 0.10995221f, -0.17270976f, -0.00942050f, -0.00432606f, 
    0.05588581f, 0.02431729f, 0.02442128f, 0.07509767f, 0.06195052f, -0.06321652f, 0.23229691f, -0.09286749f, 
    -0.43682197f, 0.07382242f, 0.09384622f, 0.04045315f, -0.14911044f, 0.07053187f, -0.07293768f, -0.05430041f, 
    0.02884340f, -0.20231858f, -0.00074282f, 0.00626161f, -0.06473684f, -0.02859830f, -0.04704707f, -0.10633834f, 
    -0.61154801f, 0.01170559f, -0.02720580f, -0.22011313f, 0.20568520f, -0.14145374f, -0.05207041f, 0.01723979f, 
    0.10826487f, 0.09898382f, 0.06521615f, -0.25148660f, 0.01255793f, 0.12295755f, 0.01093066f, 0.20764665f, 
    -0.09068168f, 0.00005523f, -0.13366652f, -0.18012114f, -0.61849874f, 0.12868921f, 0.09630767f, 0.10268607f, 
    -0.06392556f, 0.22665851f, 0.03366696f, -0.09052674f, 0.01123449f, 0.18412870f, -0.04644017f, 0.02494272f, 
    -0.06535986f, -0.04106230f, -0.01484876f, 0.02791212f, 0.02759374f, -0.02493302f, -0.09642379f, -0.04760248f, 
    -0.20313789f, 0.28378323f, -0.12527871f, -0.10207189f, -0.19089256f, 0.09833929f, 0.14736512f, -0.03578126f, 
    0.07939375f, 0.01837597f, -0.07718442f, -0.05719230f, -0.06825947f, -0.02632657f, 0.17754973f, 0.03673981f, 
    -0.00162066f, 0.03749111f, -0.14997448f, 0.07599647f, -0.17898010f, 0.13652582f, 0.21940708f, -0.36897999f, 
    -0.14652991f, 0.05998501f, 0.08450045f, -0.15230897f, -0.14188930f, 0.06535164f, -0.04107896f, -0.11661138f, 
    -0.06578915f, -0.06581285f, 0.08406245f, 0.02793377f, -0.01741148f, 0.18061145f, -0.10999878f, -0.01073699f, 
    0.35456273f, 0.30480659f, -0.09096504f, 0.32356107f, -0.22311056f, 0.09591945f, 0.10985772f, 0.17047434f, 
    0.10986239f, -0.12978883f, -0.09701195f, 0.08245818f, 0.10924760f, 0.02552762f, 0.03611751f, 0.03074378f, 
    0.09265820f, -0.01940983f, -0.03654804f, -0.04574483f, -0.06412091f, -0.01124752f, -0.11214512f, -0.01076344f, 
    0.04139440f, -0.03064460f, 0.04627265f, -0.05839159f, 0.01737119f, 0.00665590f, -0.04385942f, 0.02530483f, 
    0.02158618f, 0.03019301f, 0.01495786f, 0.13524754f, -0.11138175f, 0.03489361f, -0.02183214f, 0.01810255f, 
    -0.04869886f, -0.16825707f, -0.03258070f, 0.11576151f, -0.25029722f, 0.16834667f, 0.09009044f, -0.03337058f, 
    -0.01982411f, 0.00775499f, -0.10958849f, 0.03845728f, -0.08338954f, 0.13359402f, -0.00554310f, -0.00653485f, 
    0.07025095f, 0.00493381f, 0.00084886f, 0.14113194f, 0.02067774f, -0.20790999f, 0.08222561f, 0.01460090f, 
    0.02934472f, 0.05924048f, 0.01256214f, 0.01556468f, 0.07687952f, -0.00646614f, 0.02088021f, -0.02649694f, 
    0.04912259f, -0.03525272f, -0.06106064f, -0.01031760f, -0.01534943f, -0.03683906f, -0.02059244f, 0.12770060f, 
    0.19221255f, 0.05015709f, 0.05421237f, -0.33114854f, -0.44918308f, -0.02545655f, 0.02382654f, 0.02884607f, 
    0.04592731f, -0.04328488f, 0.07185177f, -0.05336609f, -0.09943297f, -0.13779040f, -0.07278622f, 0.03019827f, 
    0.07204075f, -0.24338165f, -0.02646645f, -0.07867119f, 0.15407600f, -0.20647702f, 0.15764219f, 0.09751379f, 
    -0.22892296f, 0.03463809f, 0.04754504f, 0.03706277f, 0.07180940f, 0.20377623f, 0.07711703f, 0.03031870f, 
    0.14024556f, -0.21021043f, 0.08170172f, -0.04721041f, 0.04814171f, -0.16715695f, -0.07394863f, -0.03759117f, 
    -0.32545042f, -0.13739614f, -0.14237575f, 0.19174282f, 0.24497861f, 0.02477907f, -0.09503433f, -0.10535783f, 
    -0.05543584f, 0.11537947f, 0.13033208f, 0.01570159f, -0.02621009f, -0.06392100f, -0.12426735f, -0.02826758f, 
    -0.08003167f, 0.02264990f, -0.00775689f, 0.03277007f, 0.26353297f, -0.34798381f, 0.17994502f, -0.08204106f, 
    0.18663469f, -0.06101817f, -0.01759554f, -0.04231226f, -0.00937560f, -0.10929908f, 0.00176209f, -0.13599081f, 
    -0.01521503f, -0.07262996f, -0.04168069f, 0.04472571f, 0.14826337f, 0.04920766f, 0.05842508f, 0.13886283f, 
    -0.08104955f, -0.06414595f, -0.14395390f, 0.18234536f, -0.00272318f, -0.08071268f, 0.01517305f, -0.01103798f, 
    -0.04962668f, 0.03752863f, -0.04836637f, 0.03244124f, -0.02074649f, -0.16776054f, -0.01622253f, 0.09010251f, 
    -0.02923909f, -0.01674454f, 0.27331939f, 0.05663019f, 0.04642885f, -0.23579302f, -0.08025863f, 0.13787392f, 
    -0.25852334f, -0.16923261f, 0.06693717f, -0.09216890f, 0.15854251f, -0.05468676f, -0.07754701f, 0.10026637f, 
    -0.00865022f, -0.08460655f, 0.05843647f, -0.05090153f, 0.06674871f, 0.02029289f, 0.04105646f, -0.05838519f, 
    0.37099695f, -0.13631399f, -0.15195011f, 0.18312018f, 0.09682118f, -0.05140889f, 0.05273546f, 0.02502901f, 
    -0.04947952f, 0.04782145f, -0.04170968f, 0.12043969f, 0.09080627f, 0.04296698f, 0.06624918f, 0.00902316f, 
    0.01053098f, -0.00089185f, 0.07811788f, 0.13899821f, 0.17086057f, -0.13304946f, -0.05998302f, 0.16746333f, 
    0.07943606f, -0.10707363f, -0.02815900f, -0.02849443f, 0.10491056f, 0.03598251f, -0.12252358f, 0.13533221f, 
    -0.01294255f, -0.06744577f, 0.06531662f, 0.10526063f, -0.00908082f, -0.08623753f, 0.16858330f, -0.01407813f, 
    0.07150536f, 0.11819415f, 0.06419670f, -0.09818249f, -0.08562042f, 0.09580916f, 0.02145088f, 0.00566252f, 
    -0.13117656f, -0.17267524f, 0.00381762f, 0.15364075f, 0.04946775f, -0.03393835f, 0.03561597f, -0.08691727f, 
    0.06225102f, -0.05852035f, 0.01038518f, 0.02296788f, 0.66066235f, -0.67589468f, 0.02608619f, -0.01936304f, 
    0.00067443f, -0.15458031f, -0.10267544f, 0.08195737f, 0.08257999f, -0.05668596f, -0.05756340f, 0.11732873f, 
    0.06212008f, 0.03521188f, 0.01543014f, 0.07726227f, -0.01961870f, 0.05529539f, -0.06565926f, 0.08605421f, 
    0.19089404f, -0.14491694f, -0.06631152f, 0.14056793f, -0.07077569f, 0.06881626f, -0.00823084f, -0.09386137f, 
    -0.01225672f, 0.08431993f, -0.08670957f, -0.06211961f, -0.02481211f, 0.03025867f, 0.10733477f, -0.07976142f, 
    -0.13644153f, 0.11574229f, 0.00943131f, 0.02532656f, -0.21213333f, 0.04886364f, 0.10063455f, -0.11894183f, 
    0.00138357f, 0.03763207f, 0.09020489f, -0.13376182f, 0.02441030f, -0.16039307f, -0.01374325f, 0.07943648f, 
    -0.03949171f, -0.01549237f, -0.06648155f, -0.02920781f, 0.00095629f, 0.04412496f, 0.10046726f, -0.00065678f, 
    -0.14627360f, -0.08623067f, -0.12598509f, -0.18304493f, 0.00267479f, 0.06336083f, -0.00409672f, 0.00240320f, 
    -0.03445855f, 0.11111942f, 0.06392593f, -0.02099784f, 0.03973828f, 0.08373276f, -0.07139356f, -0.17013626f, 
    -0.04319018f, -0.14889280f, 0.06513795f, -0.02891880f, -0.48410663f, -0.65177935f, 0.06938992f, -0.32853717f, 
    0.00173821f, -0.12540425f, 0.07664379f, 0.02009103f, 0.00006668f, -0.02216077f, -0.10998012f, -0.19698857f, 
    0.00734816f, 0.09825129f, 0.07129785f, 0.10594068f, 0.00300365f, -0.04972632f, -0.00273152f, 0.10211806f, 
    -0.23701811f, -0.30035263f, -0.23962446f, 0.18274665f, -0.00586333f, 0.07983762f, 0.01777425f, -0.07652063f, 
    -0.11412437f, 0.11244732f, 0.04512795f, 0.08428327f, 0.03244395f, 0.06394164f, 0.05383878f, -0.02703200f, 
    -0.13704064f, -0.08332146f, 0.00856738f, -0.14130437f, 0.22871213f, -0.27092677f, 0.19615780f, -0.21989116f, 
    0.12729289f, -0.01443696f, 0.04514792f, -0.18015382f, 0.00277738f, -0.02181492f, 0.04010406f, -0.10328216f, 
    0.01474176f, 0.07911593f, -0.09637983f, 0.00379345f, -0.09387575f, -0.06237213f, -0.16081478f, -0.07676039f, 
    0.18043068f, -0.35371786f, 0.15259266f, -0.00703665f, 0.07640420f, 0.02929171f, 0.03682237f, -0.09406875f, 
    -0.03328790f, -0.09143736f, -0.06001362f, -0.02306259f, -0.04253477f, -0.04890185f, 0.00212429f, -0.02811355f, 
    -0.01375009f, -0.01092033f, -0.03252464f, 0.03462350f, 0.13794485f, -0.13360010f, -0.00020487f, -0.47800982f, 
    -0.58734345f, -0.04974152f, 0.09200554f, -0.03006757f, -0.03863664f, -0.06754209f, -0.06330821f, 0.05672784f, 
    0.02998572f, 0.01066841f, -0.06965486f, -0.14355485f, 0.00547069f, 0.07495025f, 0.14131126f, 0.03275608f, 
    -0.44263121f, -0.12654433f, -0.13646172f, -0.16699907f, -0.18630064f, 0.11330525f, 0.08855248f, -0.01146142f, 
    -0.08960062f, 0.09199565f, 0.02908770f, -0.01552642f, -0.01823064f, -0.11816648f, 0.06251145f, -0.03993247f, 
    -0.03830950f, 0.11249329f, 0.05803632f, 0.08273987f, 0.25119555f, 0.13257623f, -0.06746691f, 0.02323266f, 
    0.02503206f, -0.10713617f, -0.10428128f, -0.01910149f, 0.10760197f, -0.00315987f, 0.02892400f, 0.11644004f, 
    0.00176498f, -0.07320508f, -0.07137236f, -0.09319062f, -0.10148776f, 0.07642580f, -0.05863401f, -0.01395459f, 
    0.12738520f, 0.08644597f, -0.20149581f, 0.20518582f, -0.05531778f, -0.14108329f, -0.17806967f, -0.08848570f, 
    -0.10119520f, 0.00207419f, -0.04961387f, -0.00143103f, 0.00180886f, -0.10477716f, -0.04003850f, -0.02865561f, 
    0.02521273f, -0.00619870f, -0.13736892f, -0.25303185f, -0.23445891f, -0.19579752f, -0.03915351f, 0.03029015f, 
    -0.09835838f, 0.08952570f, 0.02124805f, 0.04117439f, 0.05020304f, 0.03913808f, 0.10085229f, -0.05210983f, 
    -0.09648103f, -0.00110608f, 0.06541020f, 0.01641537f, -0.16775060f, -0.08024561f, 0.16360328f, 0.07298899f, 
    0.23051602f, 0.29259521f, 0.05671493f, 0.03704505f, -0.04963889f, 0.07703188f, 0.01935434f, -0.00402666f, 
    0.06774885f, -0.00495099f, -0.04462731f, 0.08221962f, 0.02239591f, 0.03406413f, 0.03961036f, 0.16863428f, 
    0.02271343f, 0.00254067f, -0.10674323f, 0.03028135f, -0.60847890f, -0.35828871f, -0.27943206f, 0.00182481f, 
    -0.15141274f, 0.13006365f, -0.05328972f, -0.09474289f, -0.10341137f, -0.01811782f, -0.01010744f, 0.03865457f, 
    -0.05907613f, 0.16434342f, -0.02375150f, 0.01196757f, 0.14907961f, 0.11386026f, -0.01284134f, 0.06710750f, 
    -0.15215239f, 0.21115614f, -0.39200324f, 0.17021973f, 0.32419389f, 0.06249383f, -0.14610705f, -0.00824546f, 
    -0.22533365f, 0.07969276f, -0.10094643f, -0.21649884f, 0.15382709f, -0.09259086f, 0.00040476f, -0.06200713f, 
    -0.10779292f, -0.05808246f, 0.04782093f, 0.01937421f, 0.05538339f, 0.21724495f, -0.10039769f, 0.03448848f, 
    -0.03687708f, -0.10640772f, 0.04271551f, 0.20710424f, 0.08563351f, -0.12619081f, 0.01146269f, 0.02998816f, 
    0.03009372f, -0.08697774f, 0.08242630f, -0.02142121f, 0.15717252f, 0.06993745f, 0.15611623f, -0.01988149f, 
    -0.21389051f, -0.14575613f, 0.17015542f, -0.02585432f, -0.00391295f, 0.12070169f, -0.04440477f, 0.11405075f, 
    -0.07236023f, 0.06302912f, 0.01866083f, -0.01589887f, 0.02102410f, -0.01111475f, 0.02147725f, -0.05213408f, 
    -0.00405439f, -0.20642422f, -0.06055849f, -0.04736544f, -0.51251650f, -0.40075743f, -0.08576675f, -0.20804353f, 
    -0.20495850f, 0.09125409f, -0.00031456f, -0.12510245f, -0.03002219f, 0.03845887f, 0.13469467f, 0.07147175f, 
    -0.01353418f, 0.09836444f, -0.02425362f, 0.01821628f, -0.01302424f, -0.02125566f, -0.05859778f, -0.12714705f, 
    -0.33896828f, -0.32103351f, 0.07103808f, -0.05811187f, 0.12467963f, 0.09916513f, 0.03105472f, 0.03938132f, 
    0.05145144f, 0.03026634f, 0.09357271f, -0.04040939f, 0.06762911f, 0.08269814f, 0.02414702f, -0.03524752f, 
    0.04039280f, 0.06183854f, 0.22755408f, 0.13032100f, 0.12105967f, 0.07124994f, -0.19556980f, -0.03156805f, 
    -0.14529593f, 0.02809093f, 0.09406944f, 0.09773197f, 0.08748547f, 0.10022557f, -0.02270344f, -0.02860154f, 
    0.09829578f, -0.11473234f, -0.05064022f, 0.07333466f, 0.08393957f, -0.16928865f, 0.01886329f, 0.02286575f, 
    -0.26329279f, -0.22384477f, -0.01756606f, -0.07754734f, 0.04214806f, -0.03210000f, 0.09023079f, 0.02349880f, 
    -0.02280287f, -0.03239040f, 0.11533991f, 0.00104626f, 0.01971149f, -0.04245879f, 0.12683171f, 0.07449553f, 
    0.03480868f, 0.11656609f, 0.09856818f, 0.21177021f, -0.35407811f, 0.12093953f, -0.21607207f, 0.01706169f, 
    -0.05264576f, 0.06391088f, 0.12515667f, -0.06576091f, -0.03639096f, 0.02294917f, -0.00320495f, 0.04569194f, 
    -0.09414838f, 0.01030272f, 0.08348351f, -0.02878490f, -0.03324223f, 0.12804841f, -0.05300179f, 0.09117369f, 
    -0.50064015f, -0.19492991f, 0.04680219f, -0.04257330f, 0.05740122f, 0.06003047f, 0.04283627f, 0.00837867f, 
    -0.05313722f, 0.05143158f, -0.07677690f, 0.00387896f, 0.01233762f, 0.15777563f, 0.09883053f, -0.01046501f, 
    0.05570081f, 0.16392794f, 0.11610596f, 0.02182670f, -0.10353672f, 0.22443295f, -0.12366866f, -0.15185648f, 
    -0.02883384f, 0.15410419f, 0.02422907f, -0.08188128f, 0.06242980f, -0.01129869f, -0.17677398f, 0.02348667f, 
    0.02371239f, 0.10167097f, 0.00535982f, -0.02245214f, 0.12360900f, 0.24019341f, -0.05742903f, 0.15823512f, 
    0.22548318f, 0.10849286f, -0.33371010f, 0.01368871f, -0.18762994f, -0.05317568f, -0.11067236f, 0.07006636f, 
    0.08730199f, 0.07790936f, 0.05552639f, -0.01244667f, -0.00297406f, -0.07854281f, -0.02979505f, 0.11288782f, 
    0.12314425f, 0.07388701f, 0.06438686f, 0.05173162f, -0.20817107f, -0.17225599f, -0.04545458f, 0.22192629f, 
    0.11305894f, -0.00399517f, 0.11715248f, -0.07635929f, 0.01279522f, -0.04419996f, -0.02071601f, 0.03217687f, 
    -0.03844763f, -0.08936370f, 0.14308864f, -0.03216241f, -0.05197085f, -0.13494977f, -0.17183070f, -0.08034325f, 
    0.28165424f, 0.32799751f, 0.05409448f, -0.17385466f, -0.03309562f, 0.15010093f, 0.11083606f, 0.12737669f, 
    0.05781835f, -0.03010614f, -0.11936389f, 0.03134940f, 0.00257482f, -0.02530738f, -0.06287616f, 0.09293438f, 
    0.09328162f, 0.00241354f, -0.24415512f, 0.08852535f, 0.13653000f, -0.03028461f, 0.09994886f, 0.09424688f, 
    0.06371580f, -0.00717629f, 0.10210686f, -0.05647521f, 0.08741838f, -0.10875817f, 0.04401831f, 0.09620880f, 
    -0.07704116f, 0.02717869f, 0.06021113f, -0.09155519f, 0.05664708f, 0.03862160f, -0.13651679f, 0.00489485f, 
    0.01062477f, 0.06872284f, 0.02449480f, -0.09006636f, 0.09125955f, 0.03698295f, -0.01206452f, -0.04835575f, 
    -0.01756760f, -0.01119510f, -0.12499592f, 0.01529917f, 0.01238719f, 0.00209116f, -0.01668298f, -0.03939119f, 
    0.05070875f, 0.04720552f, -0.04856135f, 0.07660993f, 0.02834515f, 0.05268892f, -0.01753872f, -0.12419947f, 
    0.00185989f, -0.02288537f, 0.05897888f, 0.06153429f, 0.05948746f, -0.00206430f, 0.02405209f, 0.01566752f, 
    -0.07232927f, 0.08126590f, -0.07482398f, -0.00334147f, 0.07736458f, 0.02520199f, -0.19518594f, 0.08918275f, 
    -0.53955442f, -0.37487739f, -0.14667910f, -0.21812141f, -0.04729137f, -0.01203365f, 0.04564024f, -0.09010784f, 
    -0.05884749f, -0.02518144f, 0.02502214f, -0.11282450f, -0.09165791f, -0.05123379f, -0.01181294f, 0.04277378f, 
    0.02775616f, 0.16127330f, 0.12137962f, 0.09181631f, -0.17091930f, -0.00938606f, -0.17450260f, 0.00566206f, 
    0.07649236f, -0.05918562f, 0.12836599f, -0.17154348f, 0.05521448f, 0.06415749f, 0.07425842f, 0.03534156f, 
    -0.00775159f, -0.00797030f, 0.20816146f, 0.04806566f, -0.01823298f, 0.16484611f, -0.08304592f, 0.07622664f, 
    0.22446139f, 0.07583175f, 0.04904609f, -0.01309767f, -0.05528285f, -0.19605111f, -0.18619348f, 0.06767309f, 
    0.06743354f, -0.08280428f, -0.01151968f, 0.04462954f, -0.00867913f, -0.05657058f, -0.05148498f, -0.01517290f, 
    0.05340355f, -0.01631590f, -0.09112443f, -0.07024527f, -0.65278679f, -0.49356937f, -0.12489500f, -0.16053237f, 
    -0.33261845f, 0.02553680f, 0.07112715f, -0.07600141f, -0.07671811f, 0.05013686f, 0.04318932f, -0.00078323f, 
    0.01584259f, 0.01173288f, -0.03394947f, 0.02494471f, -0.05236971f, 0.02308207f, 0.05230017f, 0.04034147f, 
    0.19024903f, 0.07138935f, -0.15264890f, -0.09000592f, -0.04088157f, 0.04539144f, -0.02627561f, -0.04672526f, 
    0.08630392f, -0.01025930f, 0.03185322f, 0.12609738f, -0.08402123f, 0.00224317f, 0.04631532f, -0.09835932f, 
    0.06274339f, 0.15258975f, 0.03111501f, 0.00870507f, -0.55023158f, -0.01457645f, -0.32926187f, 0.02881866f, 
    0.05839837f, 0.09232075f, -0.03823141f, -0.10337847f, 0.04746097f, -0.12266871f, 0.07870373f, 0.12737896f, 
    -0.06694759f, -0.07839992f, 0.09148227f, 0.01292112f, -0.06149478f, -0.10559253f, -0.03304248f, 0.10037176f, 
    0.26381001f, 0.03439550f, -0.13035221f, -0.00900733f, -0.18790704f, -0.08746266f, -0.11324798f, 0.01900024f, 
    0.05054326f, -0.03949103f, -0.01793527f, -0.07402230f, -0.10929074f, -0.03119875f, 0.01060417f, -0.02206350f, 
    -0.04653309f, -0.07027978f, -0.00764161f, -0.04330050f, -0.47863063f, 0.06233424f, -0.14700449f, -0.09569044f, 
    0.01126831f, 0.07279755f, 0.04365284f, -0.07679869f, 0.00901513f, 0.05700676f, 0.10846597f, -0.02727504f, 
    -0.01967135f, -0.07528077f, 0.10847133f, 0.03782263f, 0.03613107f, 0.04247853f, 0.05952546f, 0.10440858f, 
    -0.51047486f, -0.29864639f, -0.35399109f, -0.13349159f, -0.20970832f, 0.08231448f, 0.09031110f, -0.09889524f, 
    -0.03049465f, -0.04044048f, 0.03310873f, -0.06334110f, -0.05858794f, -0.04621313f, 0.06504715f, 0.05266968f, 
    0.00925435f, 0.11242036f, 0.03923457f, 0.04825146f, -0.28318495f, 0.16542050f, 0.36323661f, -0.13748726f, 
    -0.53652227f, 0.05414296f, -0.03277219f, -0.02810853f, -0.03572441f, 0.13251306f, -0.02687978f, 0.08381228f, 
    0.03752075f, 0.02482516f, 0.10399736f, 0.05156549f, 0.02572303f, -0.13549584f, -0.23546372f, -0.06462210f, 
    -0.15093732f, -0.09043179f, 0.08839849f, -0.18769670f, -0.27777216f, 0.11601079f, 0.14372209f, -0.00124531f, 
    -0.00571198f, -0.01662356f, 0.04384145f, -0.05131847f, 0.02474033f, -0.02768086f, -0.04985961f, -0.07208709f, 
    0.08120898f, 0.03799725f, 0.02040434f, 0.15001696f, -0.38883129f, -0.03859807f, 0.07282426f, -0.08483960f, 
    0.06523006f, -0.06869806f, 0.04025885f, 0.05476514f, 0.03283774f, -0.07453173f, -0.01549296f, -0.03392213f, 
    0.09257148f, -0.05860250f, -0.00515069f, -0.08189368f, -0.13576631f, -0.00830238f, -0.07365268f, 0.07626529f, 
    0.13004947f, -0.09754886f, 0.02183818f, -0.00741574f, -0.16997759f, -0.04996299f, 0.04494835f, -0.03908141f, 
    -0.11957639f, -0.12212978f, -0.18883638f, -0.04507868f, 0.06745734f, 0.13618495f, -0.03550938f, -0.05562819f, 
    -0.05431319f, -0.00395326f, -0.16711552f, 0.00895317f, 0.11384755f, -0.22011371f, -0.01408180f, 0.11642615f, 
    -0.08928013f, -0.00039497f, -0.11824381f, 0.03676376f, -0.11207689f, 0.03683126f, -0.01904096f, 0.00704642f, 
    0.00517120f, -0.11584938f, -0.06613825f, -0.10719307f, -0.01606826f, -0.07388489f, 0.00042539f, -0.06095162f, 
    0.26602545f, 0.08999278f, -0.03358314f, -0.03048388f, 0.27809158f, -0.02425529f, -0.01452474f, -0.05507648f, 
    0.15605578f, 0.01699650f, 0.03009367f, 0.01602465f, 0.00150480f, 0.05509900f, 0.06838650f, 0.15017127f, 
    -0.11152472f, -0.02861903f, 0.07039693f, 0.10705037f, 0.52577776f, 0.03767962f, -0.24501002f, -0.06555975f, 
    -0.13546318f, 0.05711779f, 0.08908305f, -0.01106840f, -0.00091785f, 0.16944350f, 0.17011631f, 0.12318590f, 
    0.09035423f, -0.06995434f, 0.10147074f, 0.00668962f, -0.14022139f, -0.09862088f, -0.10377160f, 0.09871200f, 
    -0.05408099f, -0.27374053f, -0.09277735f, 0.32520482f, 0.02251052f, -0.18423800f, 0.13585111f, 0.15548508f, 
    -0.08342381f, -0.11248187f, 0.13581239f, -0.15303454f, -0.15439923f, 0.11443666f, 0.10107145f, 0.14074735f, 
    0.05244311f, -0.07394411f, 0.09561612f, 0.16251399f, 0.07419121f, -0.33619955f, 0.11848252f, 0.08602341f, 
    -0.14144714f, 0.17439185f, 0.00680664f, 0.08715761f, -0.03971120f, 0.10624935f, -0.01378091f, -0.06616121f, 
    -0.04991292f, 0.06460646f, -0.05960741f, -0.08834162f, 0.03448677f, -0.05244295f, -0.06218385f, -0.10445030f, 
    0.05251334f, 0.10648494f, -0.22993991f, 0.01370878f, 0.07140736f, 0.13123071f, -0.11599821f, -0.00978272f, 
    0.10064375f, 0.03838219f, 0.09256338f, 0.12035171f, -0.03191880f, 0.01240208f, -0.02294554f, 0.06348130f, 
    0.11628496f, 0.06830388f, -0.07235611f, 0.08055691f, 0.49669027f, 0.11135165f, -0.43831462f, 0.06418431f, 
    -0.08242192f, -0.00056504f, 0.00103538f, -0.10746530f, -0.09268245f, 0.02402172f, 0.14208414f, 0.03175221f, 
    0.07463544f, 0.08191306f, 0.03720945f, 0.04153188f, 0.03122734f, -0.06995186f, -0.00444597f, 0.00740638f, 
    -0.21422912f, -0.28970933f, 0.01801011f, -0.01344401f, 0.04368564f, 0.16397837f, -0.09013942f, 0.03030462f, 
    0.05491335f, 0.14279497f, -0.04742059f, 0.05310832f, -0.09012501f, 0.01437294f, 0.02793487f, 0.05429304f, 
    0.05772621f, 0.00315921f, -0.05126836f, -0.10997382f, 0.05537402f, -0.02800267f, -0.17010398f, -0.00557504f, 
    0.20948228f, -0.01434823f, -0.04417691f, 0.08825026f, -0.12662201f, 0.02597026f, 0.11636422f, 0.07358776f, 
    -0.04248475f, -0.04873317f, -0.03117282f, 0.05972625f, -0.03359329f, 0.07905649f, -0.04560980f, -0.10294766f, 
    -0.36785656f, 0.25506392f, 0.01817378f, -0.09284433f, 0.21148652f, 0.17191361f, -0.15088652f, 0.00054252f, 
    0.03214876f, 0.22970958f, -0.03028350f, 0.10600790f, 0.09607758f, -0.04590181f, -0.05374234f, -0.01506434f, 
    0.05455060f, 0.03169494f, -0.20584428f, -0.16690113f, 0.12012215f, -0.23299074f, -0.16974550f, -0.16638781f, 
    -0.13283306f, 0.02157862f, 0.01936875f, -0.03425450f, 0.04819758f, 0.00309323f, 0.03396358f, -0.07992639f, 
    0.05970654f, 0.00630517f, 0.04593150f, 0.01823771f, 0.02374648f, -0.08654971f, -0.00738381f, -0.03486930f, 
    0.44903833f, -0.16539666f, -0.12758142f, -0.17288251f, -0.02058423f, 0.04498195f, -0.03774644f, -0.00086716f, 
    0.11246192f, -0.00590293f, 0.16968125f, -0.03936887f, -0.05668282f, 0.06607651f, 0.05345437f, 0.04874469f, 
    -0.03773962f, 0.01183148f, -0.00729753f, 0.03160267f, -0.01088928f, 0.36597943f, -0.04420929f, -0.17360817f, 
    -0.03355283f, 0.10374454f, 0.18066253f, 0.05448886f, 0.07796364f, 0.19689980f, -0.01940144f, 0.01864896f, 
    -0.12296554f, -0.09265824f, 0.10380080f, 0.13055982f, -0.08539844f, -0.15882379f, -0.07918479f, -0.00045802f, 
    0.08876385f, 0.05764560f, -0.05540978f, 0.03280410f, -0.03731398f, -0.04836000f, 0.05942016f, 0.07683939f, 
    -0.04443873f, -0.05026882f, -0.02042820f, -0.10245320f, -0.01145181f, 0.07845891f, -0.08296708f, 0.02041995f, 
    -0.04841717f, 0.11280087f, -0.07289318f, -0.12556194f, 0.03747831f, 0.00614721f, -0.10143422f, 0.00565484f, 
    -0.36241961f, -0.17064208f, -0.00478917f, -0.03389962f, -0.08107672f, 0.04943010f, -0.09785303f, -0.05289682f, 
    0.03188363f, -0.00797659f, 0.05889777f, -0.00180532f, 0.11943930f, 0.02596108f, -0.06314117f, -0.10045411f, 
    -0.22761747f, 0.13648345f, -0.09743246f, -0.21968055f, 0.05619978f, -0.10002360f, -0.04930501f, 0.09941810f, 
    -0.05979694f, -0.13228010f, 0.07512534f, -0.03814370f, -0.00994162f, 0.00413538f, 0.03514377f, 0.03029647f, 
    -0.10390203f, 0.03816389f, 0.19364478f, 0.02513458f, -0.02507800f, 0.17771578f, 0.02829596f, -0.02857365f, 
    -0.15040979f, -0.09079035f, -0.11119290f, -0.01778375f, -0.14535241f, 0.02504039f, -0.03186205f, -0.02637901f, 
    0.04343607f, -0.13783629f, 0.00014646f, 0.10984848f, 0.07412623f, -0.09310732f, 0.02742450f, 0.06724261f, 
    -0.50313771f, 0.41078171f, -0.05908155f, -0.14163046f, 0.12877843f, 0.07368267f, 0.02968369f, -0.01035929f, 
    -0.02570286f, 0.12494222f, 0.04313645f, -0.02176412f, 0.06830710f, 0.01867827f, 0.08989362f, -0.00881759f, 
    -0.04716485f, 0.00125140f, -0.03085110f, -0.03469419f, -0.37898016f, 0.38841838f, 0.06502088f, 0.01819238f, 
    0.06345078f, -0.14524476f, -0.06022704f, 0.01892745f, -0.14900441f, -0.07618071f, -0.01265031f, 0.03928001f, 
    0.05635950f, -0.03979743f, 0.04032017f, -0.02226156f, 0.03838450f, -0.01882270f, 0.02665053f, -0.00602675f, 
    -0.14528683f, -0.44388065f, -0.12713760f, -0.08545429f, -0.20658647f, 0.14891805f, 0.00276879f, 0.03721483f, 
    -0.02845917f, 0.05776526f, -0.00820192f, -0.08292399f, -0.02659274f, -0.01086730f, -0.00352138f, -0.00132730f, 
    -0.07849316f, -0.08841299f, -0.12638146f, -0.10094447f, -0.56098247f, 0.11262643f, -0.02334333f, -0.01493346f, 
    -0.03111140f, -0.07341769f, 0.01053316f, -0.12898509f, 0.06479960f, -0.00433988f, -0.23344842f, -0.04736751f, 
    0.01275418f, 0.05426773f, -0.07190296f, -0.11074407f, 0.04561436f, -0.06557500f, -0.11353348f, -0.01796402f, 
    0.05035845f, -0.01360119f, 0.05385086f, 0.00064959f, -0.02771953f, -0.00552195f, -0.02119130f, -0.00523377f, 
    -0.06743795f, -0.07709952f, 0.04900580f, -0.06006940f, 0.03430112f, 0.08027569f, -0.08589927f, -0.02687974f, 
    -0.05728862f, -0.05532133f, -0.09344966f, -0.04301905f, 0.30794302f, -0.09075087f, -0.22449645f, 0.00210838f, 
    -0.28278497f, 0.00564546f, -0.00858107f, 0.08754776f, -0.06142955f, 0.11232046f, 0.08755931f, 0.00791548f, 
    0.00709877f, 0.00176241f, -0.02474713f, -0.04493408f, -0.00014797f, 0.02391163f, -0.03901975f, 0.02134832f, 
    -0.35646921f, -0.40900183f, -0.08099061f, -0.08545469f, 0.01744914f, -0.01659529f, 0.10113290f, 0.01078620f, 
    0.08073877f, 0.03437699f, -0.14418080f, 0.14678052f, 0.07468212f, 0.05615177f, -0.09092972f, -0.04743660f, 
    -0.05871595f, -0.01226400f, -0.21385270f, -0.04587726f, -0.01389747f, -0.32264471f, -0.06820335f, 0.08790250f, 
    0.11116956f, -0.00429865f, 0.11260746f, -0.07339577f, -0.00228336f, -0.16769339f, 0.14922309f, 0.00895315f, 
    -0.04608814f, 0.09822123f, 0.05925365f, 0.03530667f, 0.02387918f, -0.08791357f, -0.02168102f, -0.00963495f, 
    0.02832615f, 0.07575657f, -0.01983197f, -0.10737322f, -0.06844752f, -0.03579982f, -0.09166765f, 0.08148032f, 
    -0.10560563f, -0.16498260f, -0.06020753f, -0.09277952f, 0.00744241f, -0.12467127f, -0.01271050f, -0.08084963f, 
    -0.11446707f, -0.04961506f, -0.01914916f, -0.02864901f, -0.13336837f, 0.05281009f, -0.08570234f, 0.03649135f, 
    0.06742313f, -0.08349856f, 0.05184780f, 0.03658989f, 0.03067339f, 0.00368587f, 0.03299605f, 0.00270413f, 
    -0.00743862f, 0.04299128f, -0.05638396f, 0.00454817f, -0.00872643f, -0.08032311f, 0.05127725f, 0.05024055f, 
    0.09442532f, -0.10037287f, -0.25007269f, -0.12687841f, -0.44247159f, -0.01178855f, 0.00449687f, -0.00412099f, 
    0.01978274f, 0.12030715f, 0.12368616f, -0.05454472f, 0.02269786f, -0.09131464f, 0.03484927f, -0.03024258f, 
    0.07054361f, -0.05537162f, -0.03291250f, 0.02912302f, 0.49796540f, 0.22277085f, -0.19481029f, -0.29594094f, 
    0.55626237f, 0.06794032f, -0.20452830f, -0.06506598f, 0.04477182f, 0.06565562f, 0.08570118f, -0.04605274f, 
    0.03083047f, 0.04186086f, -0.06981777f, 0.03024419f, 0.03734226f, 0.05503277f, 0.01837200f, 0.07787000f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06964193f, 0.01557279f, -0.06925842f, -0.04156520f, 0.04831858f, 0.02651304f, -0.01229198f, -0.03630725f, 
    -0.05052070f, -0.02676454f, 0.13129646f, 0.00457129f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
