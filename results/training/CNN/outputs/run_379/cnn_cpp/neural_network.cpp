#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.43082601f, 0.12209277f, -0.47039032f, 0.99347067f, -0.07885087f, 0.15422492f, -0.39313221f, -0.19728453f, 
    0.21277159f, -0.52628547f, -0.34568498f, -0.21925528f, -0.16537973f, -0.41085723f, -0.61535001f, -0.38369435f, 
    0.32549459f, 0.29007307f, -0.26352704f, -0.49458513f, 0.08746443f, -0.21516988f, -0.02489870f, -0.26984993f, 
    -0.45040441f, 0.44923463f, 0.96376896f, 0.78946334f, -0.02748309f, -1.29446769f, -0.97989094f, -0.68953133f, 
    0.25835085f, -0.12234371f, -0.17003314f, -0.18276681f, 0.26022455f, -0.27904353f, 0.19548678f, -0.01067013f, 
    -0.20860606f, 0.09038759f, 0.17246492f, 0.02233544f, -0.10123634f, 0.28635457f, 0.39731115f, -0.34145996f, 
    0.40915650f, -0.12554708f, -0.27985963f, -0.86796820f, 0.05430780f, -0.24615122f, -0.53095281f, 0.09004954f, 
    0.14257549f, 0.14602605f, -0.64283037f, -0.21109816f, 0.34005761f, 0.18141595f, -0.24470523f, 0.47568223f, 
    0.65143716f, 0.05419255f, -0.77829367f, -0.65401769f, -0.17266987f, 0.27396485f, 0.08591811f, 0.61524248f, 
    0.30936307f, 0.09393205f, 0.09313564f, -0.83378339f, -1.11019421f, -0.65510988f, 0.19856793f, -0.19660248f, 
    -0.82328117f, -0.41119957f, -0.16496807f, -0.36850023f, -0.07866480f, 0.54017121f, 0.52600169f, -0.32034069f, 
    -0.14019348f, -0.25484839f, 0.00766992f, 0.30230567f, -0.02396772f, -0.43715343f, -0.37634146f, -0.11089855f, 
    -0.32219681f, 0.03764271f, 0.38937187f, -0.05330525f, 0.93944800f, -0.15335301f, 0.17993213f, 0.78998202f, 
    1.04931629f, 0.92135924f, 0.33072552f, 0.45712641f, 0.39282531f, 0.29337141f, -0.54333723f, 0.42532533f, 
    0.10165754f, 0.39773890f, 0.40398416f, 0.14805184f, -0.12796582f, 0.15363014f, -0.29611740f, 0.26649058f, 
    -0.03993345f, 0.10334749f, -0.10002160f, -0.09600765f, 0.08434479f, -0.39266908f, -0.35106161f, -0.83282822f, 
    -0.34005648f, -0.82662100f, 0.29476225f, 0.76734525f, -0.97603345f, 0.03543537f, -0.12139381f, -0.29496214f, 
    0.13227116f, -0.05077937f, 0.41363257f, 0.31743950f, 0.10541455f, 0.18707205f, 0.00625179f, 0.16382259f, 
    0.01140108f, -0.05711396f, -0.08519216f, -0.15927523f, -0.28766608f, -0.02481004f, -0.73038918f, 0.00422955f, 
    0.57558811f, -0.54895705f, 0.02457686f, -0.13928333f, -0.19039738f, -0.21175054f, -0.94317865f, -0.70540607f, 
    -0.33421582f, 0.20357770f, 0.10803439f, 0.30163923f, 0.18581100f, -0.48995259f, -0.01128906f, 0.42900139f, 
    -0.36423165f, 0.69894147f, 0.17690693f, -0.07144228f, -0.08177239f, 0.03359614f, 0.07031535f, 1.07806742f, 
    0.98458630f, 0.59399980f, 1.13881457f, 1.10937154f, 0.32020217f, -0.21875557f, 0.09936813f, -0.15010323f, 
    -0.19934392f, -0.04525194f, -0.00600680f, -0.20582296f, 0.17976709f, 0.35890508f, 0.25026524f, -0.11042673f, 
    0.16693041f, 0.17452030f, 0.40568975f, 0.07272509f, -0.30327988f, 0.12812930f, 0.34207320f, 0.28537974f, 
    0.98136413f, 0.40759367f, -0.79525393f, 1.13779163f, 0.23843271f, 0.20004474f, 0.15164599f, -0.10418953f, 
    0.57100755f, 0.66018546f, -0.23395406f, -0.10374628f, 0.27400431f, -0.47635749f, 0.26242271f, -0.08603663f, 
    -0.10215657f, 0.11269484f, -0.24057107f, -0.13092165f, -0.18291885f, -0.40463516f, 0.21193896f, 0.21707542f, 
    -0.10047536f, -1.46308005f, 0.16828744f, 0.72947598f, -0.05183175f, 0.05274168f, 0.58457285f, 0.65271515f, 
    0.46518824f, 0.30695024f, 0.18197857f, 0.20553216f, -0.31913254f, 0.62548894f, -0.42277348f, -0.25210124f, 
    -0.09685806f, -0.37068084f, 0.19161837f, 0.03221920f, -0.10109632f, -0.11069121f, 0.27104130f, 0.14729176f, 
    0.30749136f, -0.04747783f, 0.44119272f, 0.57965887f, 1.20344472f, 0.24603410f, 0.05703108f, 0.58916134f, 
    -0.69207793f, 0.26369813f, -0.13347825f, 0.45981336f, 0.15141189f, 0.25421402f, -0.10253804f, -0.08410518f, 
    -0.17878895f, 0.27050802f, 0.23982044f, -0.28327519f, -0.46044618f, -0.07583516f, -0.03747169f, -0.15597914f, 
    0.45472407f, -0.31449518f, -0.04476914f, 1.04058099f, 0.44669735f, -0.51298362f, -0.37444529f, -0.28664929f, 
    0.89939451f, 0.57720441f, -0.16199939f, 0.68649423f, 0.57170427f, -0.31809434f, -0.16015287f, -0.29696709f, 
    -0.05338661f, -0.51253313f, 0.07650521f, 0.27479285f, 0.00890387f, -0.05523422f, -0.20623906f, -0.20574461f, 
    0.20164655f, -0.14146769f, 0.03646709f, 0.38187853f, 0.19190137f, 0.81468272f, -0.97209245f, -0.95596433f, 
    -0.53385061f, -0.28373542f, 0.48843277f, 0.67790395f, -0.23932552f, 0.19018906f, 0.25132135f, -0.17476687f, 
    0.17319322f, -0.18757722f, 0.31980872f, -0.25239390f, -0.29158160f, -0.04131528f, 0.13323388f, -0.15847078f, 
    0.01990823f, -0.11920419f, 0.30891889f, 0.07231161f, 0.20978764f, 0.23052683f, -1.23482406f, 0.49386334f, 
    0.98926967f, -0.13630085f, -0.93180132f, 1.27675045f, 0.26404920f, 0.23152725f, 0.03735574f, 0.40007618f, 
    0.15323624f, -0.03573376f, -0.31214118f, -0.02365986f, -0.35240859f, -0.11391480f, 0.03351299f, 0.33721721f, 
    -0.20337492f, 0.20952225f, -0.00718073f, -0.04055319f, 0.02896431f, -0.21636096f, 0.52467459f, 1.14289963f, 
    -0.91322672f, -0.30315739f, -0.17886567f, 0.40301779f, 0.14977354f, 0.26265347f, 0.67568779f, -0.59996146f, 
    0.10555187f, 0.24057131f, 0.26526529f, 0.19726931f, 0.08800092f, 0.30003056f, -0.54033357f, 0.11425892f, 
    -0.16359432f, 0.49174091f, 0.25951177f, -0.29650807f, 0.23423205f, -0.33422768f, 0.13416739f, -0.73572332f, 
    -0.53182381f, -0.78708506f, -0.39156234f, -0.20027705f, 0.23671907f, 0.97397590f, -0.13998893f, 0.10320888f, 
    0.75690794f, -0.61533469f, 0.00141294f, 0.25587112f, -0.03744705f, 0.24854636f, -0.39421326f, 0.00932418f, 
    0.24353085f, 0.25662613f, -0.39600331f, 0.06592026f, -0.00591688f, -0.14108224f, 0.10423651f, 0.26765424f, 
    1.19875658f, 0.86692411f, -0.16020133f, -0.66673106f, 0.34049526f, 0.24273847f, -0.97963309f, 0.08375397f, 
    -0.58178413f, 0.19832134f, 0.03224222f, 0.47619435f, 0.00846634f, 0.10030802f, -0.01150688f, 0.03227255f, 
    0.14327469f, -0.01275300f, 0.41166300f, 0.15721074f, 0.15375344f, 0.13042057f, -0.38456854f, -0.21932238f, 
    -0.00318669f, 1.46676946f, 0.40631953f, 0.81710935f, -0.58413053f, -0.93842691f, 0.14007170f, -0.72748744f, 
    0.23660760f, -0.23093927f, 0.40786916f, 0.47937933f, -0.14044812f, -0.37804580f, -0.05804594f, -0.32132670f, 
    -0.19314235f, -0.14265314f, -0.14238095f, -0.43243876f, -0.03705020f, 0.07358758f, 0.35196736f, -0.06187678f, 
    0.06576712f, -0.02001201f, -1.45678914f, 1.03024554f, -0.18013661f, -1.02236104f, -0.43547818f, 0.40982381f, 
    -0.30929112f, -0.15196419f, 0.65337473f, 0.14096719f, -0.29239890f, -0.22266944f, -0.47994983f, 0.38218182f, 
    -0.24822292f, -0.06725993f, 0.21131422f, -0.24139838f, -0.04005907f, -0.12505698f, -0.16387583f, 0.21056978f, 
    0.46955311f, 0.33753335f, 0.38328049f, -0.69564283f, -0.29787028f, 0.38045228f, 0.62435925f, 0.60463089f, 
    0.01043174f, 0.67897332f, 1.00798309f, -0.23537602f, 0.40487930f, 0.20704378f, -0.27845439f, 0.01888497f, 
    0.04897843f, -0.02212358f, -0.03945134f, -0.00801849f, -0.03805747f, -0.24411190f, -0.28621885f, 0.04011533f, 
    -0.49842143f, -0.81177580f, -0.27526811f, -0.24171034f, -0.58345246f, 1.14454913f, -0.50625914f, -0.64931166f, 
    1.09754884f, 0.63712674f, -0.49652314f, -1.13567007f, -0.05061539f, -0.31404600f, 0.14382523f, 0.19358537f, 
    -0.31485036f, -0.09116269f, -0.13399985f, -0.42589137f, 0.14181800f, -0.27091125f, -0.47029567f, -0.28019771f, 
    0.02325605f, -0.22278857f, -0.01101921f, -0.07445735f, -0.29675472f, -0.40711546f, -1.02851856f, -0.68517977f, 
    -0.75635833f, -0.36364591f, -0.27596247f, -0.30641198f, -0.04029553f, -0.32743141f, 0.36136153f, 0.24317268f, 
    0.21404782f, 0.23712975f, -0.32122037f, -0.33358219f, -0.00004480f, 0.35378686f, 0.45689917f, 0.33820927f, 
    -0.18976636f, 0.11082207f, -0.06288163f, -0.33213246f, -0.09750094f, -0.12909396f, 0.45768967f, -0.10909426f, 
    1.02853203f, 0.76366597f, 0.58150971f, -0.57794464f, -0.93789381f, -0.82243288f, -0.75476038f, -0.43386683f, 
    0.76294959f, 0.05795358f, 0.13278222f, 0.08390997f, 0.03885534f, -0.25697264f, 0.08063090f, -0.17651765f, 
    0.31890291f, 0.15894617f, 0.18946579f, 0.07417428f, -0.03532052f, 0.21111637f, 0.36229306f, -0.26307788f, 
    -0.30211717f, -0.47009575f, -0.18995056f, 0.10860293f, -0.87295496f, -0.60839015f, -0.72333121f, -0.44871056f, 
    -0.27953371f, -0.41356757f, -0.21114928f, -0.08570004f, -0.27615613f, -0.59560961f, -0.28859493f, -0.29424518f, 
    -0.08439936f, -0.13561180f, -0.16458967f, 0.12949857f, -0.17779297f, 0.12277035f, 0.46172428f, 0.38524660f, 
    0.30514276f, 0.36017036f, 0.71950722f, 1.14177251f, 1.06284189f, 0.36836955f, -0.24666075f, -0.09919298f, 
    0.17888054f, 0.34665036f, -0.20461674f, -0.36708337f, -0.54431456f, -0.45131907f, -0.23737279f, -0.07839101f, 
    -0.08862731f, -0.07562300f, 0.12388634f, 0.14490347f, 0.20527655f, 0.29862380f, -0.09996238f, -0.35744143f, 
    -0.11302753f, -0.31288466f, -1.25517058f, -0.90551221f, -0.28201643f, -0.48823661f, -0.43582055f, 1.02299821f, 
    0.78972834f, 0.08539785f, 0.56870848f, -0.04138933f, -0.10364158f, -0.21376868f, -0.25161424f, -0.44255880f, 
    -0.10780580f, 0.11901788f, -0.14410380f, -0.29453233f, 0.03053482f, -0.10483394f, -0.02124365f, 0.29477212f, 
    -0.11035180f, 0.27000937f, -0.27359244f, 0.97976023f, -0.11662712f, -0.88424146f, 0.42834809f, -0.59016633f, 
    0.29329693f, -0.35273317f, -0.78558940f, -0.06691518f, 0.25660068f, 0.23890285f, -0.00949726f, 0.12055716f, 
    0.17871872f, 0.22129504f, 0.10975025f, 0.15038909f, -0.03450437f, 0.22220437f, 0.34240499f, 0.34116450f, 
    -0.00461807f, -0.05156023f, 0.08866964f, -1.45358539f, 0.87352467f, -0.01791011f, -0.27460125f, -0.13389891f, 
    -0.19105613f, 0.89875382f, 0.13464433f, -0.09518202f, 0.29740813f, -0.44969875f, -0.01516225f, 0.33593163f, 
    -0.37042099f, 0.25365251f, 0.22397578f, 0.06876468f, -0.10304610f, -0.15195072f, -0.03767363f, 0.31747597f, 
    0.04805385f, 0.13521580f, -0.04318991f, 0.11381374f, -0.28753498f, -0.19374593f, -0.44593391f, 0.23520109f, 
    0.99394035f, 1.08543289f, 0.64746779f, -0.95034891f, 0.17807189f, -0.57001704f, -0.06530217f, 0.50510460f, 
    0.07654594f, 0.38891426f, 0.32929111f, -0.05863212f, -0.15487228f, 0.41331077f, 0.29883286f, -0.08193915f, 
    0.18380755f, -0.05537048f, -0.21171789f, -0.07055023f, 0.02818347f, 0.21718703f, -0.03730266f, -0.62861145f, 
    -0.72440588f, -0.32881764f, 0.85507834f, 0.28193614f, 0.53746027f, 0.44881171f, 0.66407847f, -0.07250004f, 
    -0.28745347f, -0.08820232f, -0.01093656f, -0.31783888f, -0.37410602f, -0.04436857f, 0.17908505f, 0.31020686f, 
    0.39910546f, 0.29132321f, -0.32367712f, -0.36502934f, -0.16860412f, 0.14581230f, 0.07587259f, 0.51074070f, 
    -1.07961094f, -1.00841951f, 0.27373630f, -0.02823974f, -0.65109086f, 0.85740191f, 0.68536139f, 0.25341016f, 
    -0.76218367f, -0.24226971f, -0.26415282f, -0.23734836f, -0.52312165f, 0.05531686f, 0.03083817f, -0.05290186f, 
    0.19016634f, 0.23375683f, -0.15378739f, 0.06035712f, -0.27266583f, -0.07267474f, -0.14669023f, -0.95972657f, 
    -0.94511425f, 0.37789536f, 0.56766027f, 0.01753019f, 0.34897232f, 0.31925994f, -0.64928055f, 0.39317021f, 
    0.30123934f, -0.32176715f, 0.43166462f, -0.27080658f, 0.64070648f, -0.20080942f, -0.66789275f, -0.14188612f, 
    -0.45927891f, -0.28580678f, -0.64429778f, 0.12657671f, 0.08926749f, -0.28816339f, 0.12468728f, -0.13403092f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17890857f, 0.27816373f, 0.20072082f, 0.19165471f, 0.15499759f, 0.48877251f, 0.33226171f, 0.30580208f, 
    0.26643941f, 0.17360465f, 0.16684061f, 0.03635532f, 0.23416148f, 0.17023788f, 0.12823236f, 0.21377064f, 
    0.23525202f, 0.19983706f, 0.23429030f, 0.20918225f, 0.10116588f, 0.40538445f, 0.32753298f, 0.14405918f, 
    0.19752884f, 0.16391827f, 0.25227323f, -0.03069436f, 0.20063272f, 0.10318244f, 0.14283784f, 0.05368455f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04922855f, 0.08946349f, -0.06217537f, 0.13454545f, 0.12216642f, 0.05506661f, 0.01350827f, -0.01584247f, 
    0.07100080f, 0.03640082f, -0.10090908f, 0.05195084f, -0.25829303f, 0.24105915f, -0.04990163f, 0.31741065f, 
    -0.06286137f, -0.00151240f, -0.21640101f, -0.14753503f, -0.13305335f, -0.07869455f, -0.09427806f, -0.01708099f, 
    -0.40451652f, -0.20673016f, 0.02561280f, 0.04874505f, 0.01122884f, 0.16330190f, 0.03619691f, -0.03158054f, 
    0.11027294f, 0.07021673f, 0.04967025f, 0.06911599f, -0.43822783f, -0.50096601f, -0.29207018f, 0.14823490f, 
    -0.06768561f, -0.03113152f, 0.01349703f, -0.01915009f, 0.02232435f, 0.16416243f, -0.04173383f, -0.05397402f, 
    0.28604713f, -0.24898408f, -0.12297035f, 0.19626492f, 0.04679437f, -0.05262197f, -0.05891149f, 0.03518903f, 
    -0.06151782f, 0.05795681f, 0.01102107f, -0.03754584f, 0.20938821f, -0.10228395f, 0.09789750f, -0.32998982f, 
    -0.10509619f, 0.06220958f, -0.02816839f, -0.09875407f, 0.12672259f, -0.00143187f, 0.04434542f, 0.01061216f, 
    -0.52810055f, 0.10284000f, -0.05393628f, -0.04122031f, 0.17002416f, 0.09746184f, 0.09788517f, -0.03848699f, 
    -0.08884614f, -0.21958143f, 0.04913379f, -0.07569904f, 0.31051871f, -0.05883092f, -0.01846997f, 0.11228172f, 
    -0.21157911f, -0.03788089f, 0.03912145f, 0.09631979f, 0.03087141f, -0.02883907f, -0.04184819f, -0.14915560f, 
    0.05098588f, 0.07069655f, -0.06900404f, 0.34420651f, -0.21738355f, 0.08771607f, -0.06872753f, 0.04207156f, 
    -0.11133047f, 0.07849748f, -0.03564607f, 0.02309938f, 0.26530412f, 0.03095602f, 0.16397947f, -0.01123894f, 
    -0.10879902f, 0.01622497f, -0.06567340f, -0.10488013f, -0.01540553f, -0.11420751f, 0.06512580f, -0.08159228f, 
    -0.22001891f, -0.10811548f, -0.05536396f, 0.03390428f, -0.26388645f, -0.11836477f, 0.05776005f, 0.08827373f, 
    0.04742827f, -0.01875021f, -0.03897243f, -0.14707392f, 0.22443306f, 0.06638705f, 0.05987695f, -0.01181080f, 
    0.09370688f, -0.05501445f, -0.02327867f, 0.05764199f, -0.09158357f, 0.20369878f, 0.03342609f, 0.11683752f, 
    -0.28098184f, -0.10695519f, -0.01284084f, -0.26906446f, 0.06404778f, -0.11321848f, 0.10957856f, -0.05567300f, 
    0.00435863f, -0.00333784f, -0.01170532f, 0.03173640f, -0.02513945f, 0.03079846f, -0.04873586f, 0.29209712f, 
    -0.05961941f, -0.00236030f, 0.09391571f, -0.01470200f, 0.08372394f, -0.06046004f, -0.12487294f, 0.00990401f, 
    0.07065025f, 0.09239363f, -0.07932039f, -0.37190196f, -0.34293503f, -0.03360404f, 0.02979174f, 0.02387662f, 
    -0.01397167f, 0.03291010f, -0.00615175f, 0.11868580f, 0.25662181f, 0.05820043f, 0.06944685f, -0.32500172f, 
    0.00005838f, -0.00831840f, -0.00171363f, 0.01498985f, 0.13724302f, -0.12385170f, -0.08799041f, 0.17945428f, 
    0.25686863f, -0.00863502f, 0.29561120f, -0.64308834f, -0.05939713f, -0.00943423f, 0.00145538f, 0.10020400f, 
    0.09697049f, -0.01953705f, -0.02539553f, 0.05927048f, 0.04111852f, -0.13139400f, 0.02690410f, -0.21675472f, 
    -0.03724863f, -0.13217622f, -0.17274849f, -0.02968630f, -0.25127649f, 0.00628130f, -0.09318102f, -0.09320366f, 
    0.37532121f, 0.01315138f, -0.10841149f, -0.18589710f, 0.07908473f, 0.05752084f, -0.02075303f, 0.04360385f, 
    0.04217244f, -0.04675516f, -0.02322192f, -0.12960893f, -0.52142030f, 0.14820729f, 0.06368627f, 0.12715265f, 
    -0.05533002f, 0.12112784f, 0.02797970f, -0.00647635f, -0.01087991f, -0.16836415f, 0.09430511f, -0.01090096f, 
    -0.19691132f, -0.10643933f, 0.44236171f, -0.00742877f, -0.02848163f, 0.08492372f, 0.12331623f, -0.14218058f, 
    -0.01427273f, -0.03963741f, 0.00712437f, -0.03827583f, -0.28891724f, -0.29745710f, 0.07308350f, -0.13143085f, 
    0.16300097f, -0.00661441f, 0.04626161f, -0.02212927f, -0.16595387f, 0.04253661f, -0.09860529f, -0.02154054f, 
    0.31169719f, 0.00272465f, 0.01790171f, 0.17680296f, -0.13889058f, -0.13922530f, -0.01200970f, -0.02793117f, 
    -0.00366956f, -0.07907724f, -0.07261286f, 0.00196951f, -0.27239746f, -0.37497339f, 0.18061961f, 0.22513555f, 
    -0.07259890f, -0.01055217f, 0.04734794f, 0.10275042f, 0.00189016f, -0.04750462f, -0.00980345f, 0.10936345f, 
    0.15150842f, -0.04933281f, 0.12592447f, 0.25129682f, -0.17420001f, 0.00452203f, 0.05718788f, -0.06499318f, 
    -0.06358805f, -0.00983430f, 0.01201721f, 0.05444358f, -0.20569555f, 0.36608845f, -0.02750177f, -0.42576405f, 
    -0.01855553f, 0.02921008f, 0.03967151f, -0.00271768f, -0.02549738f, 0.07905202f, -0.00147409f, 0.03025490f, 
    -0.35730541f, 0.03811598f, 0.05997223f, -0.09068634f, 0.02567883f, 0.00936351f, 0.09809516f, 0.08038440f, 
    -0.10226253f, -0.22000647f, 0.00130023f, 0.01760660f, 0.52465528f, 0.23114736f, 0.23854087f, -0.07231852f, 
    0.07774870f, -0.00980758f, -0.07541522f, 0.04581656f, 0.07012384f, -0.02646274f, -0.00762537f, -0.00478808f, 
    -0.51574159f, -0.24294920f, 0.10540040f, -0.09041274f, -0.14267573f, -0.05783315f, 0.10488344f, -0.00899911f, 
    0.09847621f, -0.08925506f, 0.06750937f, 0.00106699f, 0.23855054f, 0.04789009f, -0.17237081f, -0.26492095f, 
    0.24549715f, -0.10772179f, 0.04338371f, 0.03112582f, 0.03213613f, 0.01419250f, -0.09015721f, 0.12944011f, 
    0.31344473f, 0.07870715f, 0.13836487f, -0.48771051f, -0.03202249f, 0.04024514f, 0.07905661f, -0.20243050f, 
    -0.07548360f, 0.06348662f, -0.01135206f, -0.02833876f, -0.17570904f, 0.01081102f, -0.12758811f, 0.21393074f, 
    0.09366299f, -0.17200714f, 0.10497124f, 0.11695644f, -0.09118668f, -0.05564119f, 0.15285343f, -0.07614718f, 
    -0.11221343f, -0.24574891f, -0.57179958f, -0.03015822f, 0.12794417f, -0.04987969f, -0.10999299f, 0.11100189f, 
    -0.08966411f, -0.22867399f, -0.15597381f, -0.27590933f, -0.20932877f, -0.01390771f, -0.32715762f, -0.14270186f, 
    -0.02525479f, -0.02987477f, 0.07433818f, 0.09761088f, -0.05168457f, 0.05479743f, -0.01909117f, 0.09841307f, 
    -0.07858615f, -0.02794802f, -0.24968666f, 0.17851619f, -0.06556416f, -0.01774182f, -0.10306270f, 0.08757820f, 
    -0.18317820f, 0.01887103f, -0.25693193f, -0.11929891f, 0.15197873f, 0.08461077f, -0.18076818f, 0.16298524f, 
    0.04137612f, -0.07485569f, -0.02138654f, 0.12864204f, -0.01725471f, -0.36600143f, 0.19124046f, 0.19677231f, 
    0.46871585f, 0.01947436f, 0.10530538f, 0.13141125f, -0.09470197f, 0.18371910f, 0.01040959f, -0.01613692f, 
    0.03292467f, 0.04653903f, 0.06679350f, 0.02615587f, -0.14323862f, 0.01696040f, -0.13550517f, 0.10759423f, 
    0.03485191f, -0.03566796f, 0.20694846f, 0.26522046f, -0.04874916f, 0.13810684f, -0.04067713f, 0.04149473f, 
    -0.10907527f, 0.06628678f, -0.10572945f, 0.05716007f, -0.06565235f, 0.02577926f, -0.06835822f, -0.02813302f, 
    -0.06751750f, 0.01753815f, 0.17358296f, 0.02267337f, 0.21788003f, 0.07425780f, 0.13359758f, 0.31280112f, 
    -0.12599739f, 0.00741356f, -0.02407978f, 0.10459842f, -0.05291341f, 0.08585738f, -0.10581239f, 0.24565856f, 
    0.27340695f, -0.07685660f, 0.11618579f, 0.05622066f, 0.02796511f, -0.03363269f, 0.00573916f, -0.00324180f, 
    0.03347093f, -0.05935722f, 0.01674792f, 0.11170333f, -0.34812486f, 0.17002144f, -0.11516400f, 0.04821852f, 
    0.07366586f, 0.18065204f, 0.01060019f, -0.15433367f, -0.09432387f, -0.05524390f, -0.07189987f, -0.00582883f, 
    0.22196528f, 0.22266641f, 0.23643804f, 0.08305506f, -0.06424130f, -0.19992229f, 0.04454623f, -0.04999706f, 
    0.09272083f, -0.04126412f, 0.16766255f, -0.01098661f, 0.30028623f, -0.09462529f, 0.08567749f, -0.03748320f, 
    0.04953240f, 0.00460535f, -0.25437188f, -0.08802482f, 0.03369491f, -0.04004068f, -0.02548459f, -0.15277152f, 
    0.34670842f, -0.05896126f, 0.00853290f, -0.44545737f, -0.18558858f, 0.19240722f, -0.07273551f, 0.05092640f, 
    -0.08936502f, -0.10018050f, 0.03444415f, -0.01118109f, 0.00302761f, -0.20577335f, -0.08346191f, 0.26243168f, 
    -0.20369935f, 0.02306737f, 0.03631571f, -0.12960219f, 0.04754781f, -0.09221341f, -0.01011160f, -0.00401647f, 
    -0.14270221f, -0.29718587f, 0.22496986f, 0.11717836f, -0.04139356f, -0.21023202f, 0.04459837f, 0.14339772f, 
    0.06751255f, -0.02571100f, -0.08736821f, 0.08355501f, 0.12793374f, -0.03680443f, -0.05730785f, -0.26056969f, 
    0.15966806f, -0.12290138f, 0.08089795f, 0.10282115f, 0.04351577f, 0.07375405f, 0.07543936f, -0.15170023f, 
    0.23591946f, -0.14777493f, 0.17498258f, -0.21835350f, 0.05127981f, -0.08035895f, 0.05222922f, -0.00322337f, 
    -0.04436684f, 0.05510780f, -0.03362522f, 0.07503879f, 0.20475627f, 0.16645826f, -0.02246254f, 0.00524731f, 
    -0.05769611f, -0.10255592f, 0.04265500f, -0.03339872f, 0.08109905f, 0.00310609f, 0.07817573f, 0.02437785f, 
    -0.71072751f, -0.01449158f, -0.11556317f, -0.26800674f, 0.02945936f, -0.17447011f, -0.02925392f, 0.11469049f, 
    0.06864063f, 0.21447223f, -0.00951296f, -0.04187425f, 0.10137908f, 0.00808426f, -0.06892729f, 0.15372977f, 
    0.07324013f, 0.03480222f, -0.22998936f, -0.01374144f, -0.11856222f, 0.10621779f, 0.10067156f, -0.13084604f, 
    -0.13213177f, -0.03461909f, -0.19306286f, -0.41509628f, -0.13004427f, -0.14263955f, -0.01490335f, -0.07866994f, 
    -0.02039318f, -0.02018394f, -0.03598658f, -0.12095713f, 0.14769088f, 0.08111236f, 0.05653317f, 0.02156314f, 
    -0.02958219f, 0.09303805f, 0.22055331f, 0.12283225f, 0.17691350f, -0.08801378f, 0.11309759f, 0.09405868f, 
    -0.25688580f, -0.05079439f, 0.08933541f, 0.08109877f, -0.00000095f, 0.06964866f, 0.05391425f, 0.06553761f, 
    -0.01628851f, 0.15792863f, 0.04462416f, -0.05397776f, -0.01816081f, 0.01657300f, -0.25523397f, -0.54054552f, 
    0.06150002f, 0.07414221f, 0.08621021f, 0.14766064f, -0.10114631f, -0.11801540f, -0.04767884f, -0.16253939f, 
    0.34765768f, -0.04133007f, 0.11390992f, 0.22910333f, -0.04824812f, 0.09639903f, 0.00791921f, 0.10924703f, 
    -0.07911132f, -0.05465036f, 0.04537398f, -0.11118210f, 0.35904199f, -0.35961840f, -0.14255449f, -0.07342655f, 
    0.00148805f, -0.08723650f, -0.09425391f, 0.00024158f, 0.06559376f, -0.11225615f, 0.01947223f, -0.06567727f, 
    -0.14033660f, 0.14658475f, -0.20641515f, -0.55843073f, -0.06140742f, 0.01960728f, 0.05067240f, -0.00417817f, 
    0.12787119f, 0.22175643f, 0.09098008f, 0.12072156f, -0.31662932f, 0.09032971f, -0.16401516f, -0.29956391f, 
    0.07712650f, 0.10278405f, -0.07682753f, -0.00614098f, 0.04270935f, -0.10467256f, 0.01876477f, -0.10139592f, 
    0.25845125f, -0.20220204f, -0.09574042f, -0.01265526f, 0.01073393f, -0.02879221f, -0.17179382f, 0.01107925f, 
    -0.22929160f, 0.06091915f, -0.11130992f, 0.04851183f, -0.01113298f, -0.29107961f, 0.16143447f, -0.19808565f, 
    0.04627836f, -0.05934522f, -0.13264863f, 0.13733090f, 0.04661155f, 0.02438673f, 0.00060156f, -0.05668197f, 
    -0.10904789f, -0.14969300f, 0.15221965f, -0.40739605f, 0.06098472f, -0.11419604f, 0.02731701f, 0.15806529f, 
    0.12936261f, -0.05292211f, -0.02422777f, 0.03770339f, 0.23377813f, 0.21490809f, -0.17689788f, 0.11449867f, 
    -0.09996165f, 0.17060228f, 0.02841069f, 0.11927287f, -0.01648227f, -0.28934389f, -0.05852000f, -0.05652806f, 
    -0.34307557f, -0.08540726f, -0.17742833f, -0.04621045f, 0.01303152f, 0.10570238f, -0.03427288f, -0.10304625f, 
    0.06504347f, -0.00004321f, -0.09807163f, 0.06227456f, -0.61187214f, 0.08262885f, -0.10318147f, -0.29587898f, 
    -0.15107627f, 0.04180241f, 0.04510155f, -0.09231930f, -0.08166979f, -0.11813171f, -0.03781049f, 0.12909341f, 
    0.26787212f, 0.13320358f, -0.04916847f, -0.25803140f, -0.17062818f, -0.01303314f, -0.03941640f, 0.07044304f, 
    0.12864849f, -0.35367969f, -0.01510691f, -0.18411869f, 0.45997393f, -0.54746294f, -0.02215221f, -0.04117383f, 
    -0.08220420f, 0.06005725f, -0.17754814f, 0.05115000f, 0.02748573f, 0.04986207f, 0.13117945f, -0.15608807f, 
    -0.30860326f, 0.04493846f, 0.05202784f, -0.15059309f, 0.13238288f, 0.03959851f, -0.12324205f, 0.04833703f, 
    -0.03548762f, -0.10827619f, 0.02074120f, 0.05599184f, 0.37022072f, 0.03603494f, 0.06027131f, -0.26122981f, 
    -0.06155743f, -0.09153569f, -0.02624574f, 0.04155013f, -0.13411207f, -0.05761035f, -0.03341553f, -0.01993500f, 
    -0.00531240f, 0.12492440f, -0.38942069f, -0.25428852f, -0.05822665f, -0.15061474f, -0.01992080f, 0.04832233f, 
    0.05589963f, 0.03249073f, -0.04266652f, -0.01367735f, 0.16736898f, -0.00361474f, -0.05835466f, -0.00336591f, 
    0.08961874f, 0.01478739f, 0.00236404f, -0.06206659f, 0.09683021f, -0.01511628f, -0.01438977f, -0.07283314f, 
    0.17869335f, -0.19342679f, -0.04372668f, -0.07994987f, -0.02975696f, -0.00748101f, -0.03927581f, 0.10036482f, 
    -0.16206524f, 0.05598810f, 0.01241341f, -0.03111556f, 0.41191339f, -0.01205040f, -0.08730055f, 0.01000938f, 
    -0.09036336f, -0.04199827f, -0.03112244f, 0.01974550f, -0.03244488f, 0.05801418f, 0.06836637f, -0.03750912f, 
    0.01197481f, 0.22671148f, -0.13989082f, 0.03988894f, 0.03519165f, 0.17114869f, -0.05191741f, 0.05473579f, 
    -0.10589466f, 0.03132524f, -0.09541506f, -0.09786672f, 0.24338464f, -0.06486552f, 0.13262211f, 0.07522449f, 
    0.04534713f, -0.09637838f, 0.06859474f, -0.03516925f, 0.00478743f, 0.15732174f, 0.07035564f, 0.06593709f, 
    -0.24567637f, 0.20428292f, -0.19922657f, 0.16464069f, -0.08273984f, -0.08391266f, 0.00467722f, -0.00577343f, 
    -0.02137796f, 0.06798749f, 0.15725057f, -0.08641361f, 0.45103908f, 0.04972862f, -0.00688446f, -0.20005712f, 
    0.02953825f, -0.00845291f, 0.01087750f, 0.07507033f, 0.01030414f, -0.07293044f, 0.02819597f, -0.08176891f, 
    0.32832134f, 0.15493622f, -0.15046532f, -0.01142791f, -0.10446431f, -0.13812038f, 0.17273983f, -0.07117554f, 
    -0.08151328f, 0.01561778f, -0.07073522f, -0.08240689f, 0.30551204f, 0.09801513f, 0.20896778f, 0.21772206f, 
    -0.11158690f, -0.14598820f, -0.04517057f, 0.01795473f, 0.03726822f, 0.07758801f, -0.06097872f, -0.00429072f, 
    -0.21943516f, 0.03537235f, 0.11251476f, -0.38936603f, 0.04661613f, -0.13521853f, 0.15399563f, -0.09796210f, 
    -0.09088033f, -0.07764798f, 0.00667268f, -0.04485492f, -0.52746922f, 0.12887858f, 0.15217596f, -0.20496245f, 
    -0.10455051f, -0.11476360f, 0.10499756f, -0.01676949f, -0.03390035f, -0.06345951f, 0.08485761f, 0.08601163f, 
    0.16075853f, 0.18909071f, -0.07493822f, 0.15971561f, 0.01141578f, 0.14168294f, -0.09984763f, -0.11049365f, 
    -0.22964948f, 0.02697727f, 0.06627227f, 0.02471395f, 0.29044455f, -0.08223490f, -0.01662918f, 0.04184628f, 
    -0.01730592f, 0.04049628f, 0.10183401f, -0.09284266f, 0.08807075f, 0.09364190f, -0.06248926f, -0.05201124f, 
    0.06985544f, -0.27003369f, -0.17364392f, -0.35945696f, 0.09502596f, 0.07776871f, 0.07436679f, -0.09259883f, 
    0.03768916f, 0.08496550f, 0.00334687f, 0.04224571f, -0.07586773f, -0.31486177f, 0.13393451f, 0.10340770f, 
    -0.29471102f, -0.10091131f, 0.15663818f, -0.14274202f, -0.10623918f, -0.00191458f, -0.12469186f, -0.05705089f, 
    0.04576328f, 0.14856121f, -0.33572951f, 0.11945672f, 0.00010398f, 0.19659178f, -0.07988801f, -0.06866305f, 
    -0.04057064f, -0.08785167f, -0.05411577f, -0.18468580f, -0.25667748f, -0.24658641f, -0.34153226f, -0.45734495f, 
    -0.02921215f, -0.05959763f, -0.27061221f, -0.02791161f, 0.11852844f, 0.15485586f, 0.08227216f, -0.00555046f, 
    -0.13337690f, -0.16934793f, 0.07047428f, -0.01318215f, -0.00310950f, 0.03519672f, 0.02416828f, -0.28183147f, 
    0.01200965f, 0.09299317f, -0.03311740f, -0.02675952f, 0.45001686f, -0.04909781f, 0.23890764f, 0.37316340f, 
    -0.25464061f, -0.08016130f, 0.03576329f, 0.09191670f, 0.00437851f, 0.08064523f, 0.00381259f, 0.11492907f, 
    -0.16373020f, -0.25077718f, -0.00833167f, -0.37220249f, 0.07384402f, 0.03583036f, 0.00618716f, -0.11144765f, 
    -0.02311187f, -0.09239882f, -0.14418013f, -0.06266014f, 0.37108347f, 0.07175788f, -0.35730642f, -0.01856237f, 
    0.03090753f, 0.02566315f, -0.05741615f, 0.23130147f, 0.09688375f, 0.12373371f, 0.00441342f, -0.13979225f, 
    0.19493721f, -0.38306335f, 0.10751648f, -0.10961878f, 0.10743221f, -0.00765367f, -0.00280207f, 0.05126247f, 
    -0.17134868f, -0.17801046f, -0.12125833f, 0.06766856f, 0.07099678f, 0.26344648f, 0.15827221f, 0.23197027f, 
    -0.08621113f, -0.02897808f, 0.11220771f, 0.03467644f, -0.16822134f, -0.01776813f, -0.06089174f, -0.08133962f, 
    -0.28143415f, 0.01200841f, -0.03314324f, 0.17998859f, 0.03938571f, 0.09246138f, 0.19383670f, 0.00590838f, 
    0.05985445f, -0.01111816f, -0.10318895f, -0.05807763f, 0.49104884f, -0.23009665f, 0.01909311f, 0.00890077f, 
    -0.31900689f, -0.03972252f, -0.09747461f, -0.02965251f, 0.04359732f, 0.21921028f, 0.04031283f, -0.06556273f, 
    0.30601040f, 0.02853780f, -0.04738612f, 0.19107686f, 0.00497099f, 0.09246148f, 0.12819462f, 0.14019844f, 
    -0.00363840f, 0.20681265f, -0.03577964f, -0.04348078f, -0.02075617f, -0.15255432f, -0.06837022f, 0.08052260f, 
    -0.02807107f, 0.11998010f, 0.03663638f, 0.04744322f, -0.07938161f, 0.09502936f, -0.11891475f, 0.06487128f, 
    0.43295422f, 0.01550070f, 0.08871163f, -0.13851163f, -0.03322320f, -0.05172243f, -0.03928913f, 0.06741344f, 
    0.07207951f, 0.03545607f, 0.10075012f, -0.13548876f, 0.12458599f, 0.17006284f, 0.07214016f, 0.01506821f, 
    -0.05864042f, -0.20747928f, -0.03089378f, 0.02411236f, -0.07916997f, 0.16069716f, -0.02757890f, -0.11119982f, 
    -0.49631900f, -0.19788073f, -0.31493670f, -0.12128681f, 0.00827817f, -0.00547206f, -0.07813203f, -0.13567126f, 
    0.14335571f, -0.11660653f, -0.07424578f, 0.01084648f, -0.01207000f, 0.07740726f, 0.00136620f, 0.10649358f, 
    -0.12875856f, -0.05752747f, -0.04127060f, -0.03011828f, -0.04377126f, -0.05453645f, 0.04915295f, 0.12097529f, 
    0.11271439f, 0.13979243f, 0.14491805f, 0.00722197f, 0.13152428f, -0.03910855f, 0.00518155f, -0.05093631f, 
    0.05659314f, -0.04661648f, -0.12448280f, 0.07560596f, -0.60960311f, -0.49223113f, -0.17943698f, 0.11476874f, 
    -0.12201642f, -0.00664911f, 0.04228203f, -0.05194807f, -0.01934231f, -0.29318866f, 0.09382685f, -0.10226611f, 
    0.26675597f, -0.11304356f, -0.18205440f, -0.23932631f, -0.07878987f, 0.04653926f, 0.01364915f, -0.12879378f, 
    0.22525726f, -0.08331481f, 0.05635682f, 0.02390363f, -0.27484408f, 0.19382294f, 0.08242505f, -0.11269207f, 
    -0.06724793f, -0.18340115f, -0.01806518f, 0.10207592f, 0.03858505f, -0.20472537f, 0.06677795f, 0.04814633f, 
    -0.15685678f, -0.54947615f, -0.38089439f, 0.24697545f, 0.02037203f, -0.07534871f, 0.15235490f, 0.13856877f, 
    0.05019811f, 0.09648342f, -0.04310061f, -0.06803902f, -0.17682631f, -0.10064990f, -0.03736499f, -0.07031772f, 
    -0.08367634f, 0.07195413f, -0.11520141f, 0.01227771f, -0.17644252f, -0.02058031f, -0.09876646f, 0.12579733f, 
    -0.08703623f, -0.25311998f, 0.13130710f, 0.00426450f, -0.00008116f, 0.12220831f, 0.17696273f, 0.19749442f, 
    -0.12899446f, 0.04818355f, -0.02757656f, 0.05399409f, -0.48063573f, 0.30013713f, 0.02991921f, -0.01680014f, 
    0.06368807f, -0.02404757f, -0.07344548f, -0.04443861f, -0.14167865f, 0.03572650f, -0.14678331f, 0.01292710f, 
    0.24950340f, 0.14704892f, -0.03863934f, -0.00028319f, -0.12219141f, 0.06761815f, 0.09769617f, 0.02571239f, 
    -0.07964081f, -0.06447271f, 0.08823822f, -0.12658818f, -0.16641589f, 0.08347540f, -0.08127531f, -0.00090687f, 
    -0.19221509f, -0.07117186f, 0.06969858f, -0.20560877f, -0.14661448f, -0.04589666f, -0.07357059f, 0.15541966f, 
    0.05033191f, -0.06054669f, -0.24330899f, 0.30181918f, -0.17467411f, 0.05563913f, -0.01043174f, -0.01365602f, 
    0.00282931f, -0.14251070f, -0.03981718f, -0.01907295f, -0.12016939f, -0.33586410f, -0.39692694f, 0.05003767f, 
    -0.12487377f, 0.07164773f, -0.02126400f, 0.18469226f, -0.03100789f, 0.04604940f, 0.05109090f, -0.03915658f, 
    0.25202978f, 0.18496895f, 0.08518429f, -0.23693599f, -0.07680542f, 0.00651729f, 0.01400053f, 0.07970533f, 
    0.01939505f, -0.08540026f, -0.11097056f, -0.01753057f, -0.21120727f, -0.04270873f, 0.19888604f, -0.08254921f, 
    0.08761423f, -0.02129086f, 0.12090714f, -0.08193190f, 0.03217805f, 0.10592371f, -0.13165575f, 0.03776618f, 
    1.04224873f, 0.32601014f, 0.18376462f, 0.07595514f, -0.07801711f, 0.08542152f, -0.14776158f, -0.02371882f, 
    -0.06443506f, 0.05665396f, -0.06927529f, -0.16856268f, 0.06286036f, 0.02682849f, -0.08773533f, -0.15430506f, 
    -0.17664944f, -0.00144113f, -0.03230122f, -0.06570529f, -0.06012491f, 0.08922178f, -0.18823776f, 0.13779108f, 
    -0.15625955f, -0.17934401f, 0.14818165f, 0.31577829f, 0.07088205f, 0.10422241f, 0.03275153f, -0.08498573f, 
    -0.09598923f, 0.02945651f, 0.08364650f, -0.31209704f, 0.20471902f, 0.24465367f, 0.23369387f, 0.08905490f, 
    -0.03320621f, -0.14347038f, -0.02623892f, -0.08634271f, 0.00350655f, -0.01218970f, -0.12331521f, 0.01313146f, 
    -0.43906775f, -0.29274791f, -0.17594007f, 0.17096311f, -0.09748578f, -0.00598222f, 0.07816703f, -0.20204793f, 
    -0.05273362f, 0.04429641f, 0.14939797f, 0.05115841f, 0.16182859f, -0.16988090f, -0.02282628f, 0.06472597f, 
    -0.03931382f, -0.00650347f, 0.00019055f, -0.01688493f, -0.14686593f, 0.05801064f, -0.03583233f, -0.05263299f, 
    0.08892502f, 0.15134282f, 0.17849174f, -0.00477293f, 0.02594101f, 0.10914688f, -0.01573596f, 0.09911695f, 
    0.05003326f, -0.07953209f, 0.04923809f, -0.06917746f, -0.33959821f, 0.31279260f, 0.06419713f, -0.14488104f, 
    -0.03318581f, -0.02205809f, -0.07288700f, 0.11746341f, 0.03667659f, -0.06796319f, -0.16844723f, 0.07198639f, 
    0.59379625f, 0.08025702f, 0.07101718f, 0.08681968f, 0.02216058f, 0.10544395f, -0.01849990f, -0.15916230f, 
    -0.09818739f, -0.10417459f, 0.05485116f, 0.04177887f, -0.24683000f, 0.00938940f, -0.16843635f, -0.23536515f, 
    -0.08823188f, -0.01097629f, -0.05544203f, -0.09795987f, -0.02213800f, -0.04714842f, -0.00391097f, 0.09667289f, 
    -0.17535283f, 0.05460894f, 0.00217528f, 0.04509166f, -0.25125051f, 0.05277584f, 0.02635664f, -0.03335322f, 
    -0.00989530f, 0.09869225f, -0.14982674f, 0.06270841f, 0.06570225f, 0.06219392f, 0.11499362f, -0.14777073f, 
    0.11523276f, -0.07276763f, -0.01712205f, 0.01488287f, 0.03845474f, 0.00706086f, 0.17173141f, 0.09726188f, 
    0.11874419f, -0.00571906f, 0.04467126f, -0.19571276f, -0.01811094f, 0.03603598f, 0.01002204f, 0.05318435f, 
    0.07712979f, -0.02439808f, 0.07514349f, 0.24319334f, 0.06588001f, -0.69856477f, 0.19706167f, -0.07615709f, 
    -0.08658811f, -0.06216434f, 0.19720277f, -0.15108471f, 0.11761733f, -0.03301204f, 0.13240272f, -0.11439890f, 
    -0.49097916f, 0.01658541f, -0.00880771f, -0.14829054f, 0.16605528f, -0.03381461f, 0.00411755f, 0.17575565f, 
    -0.28579417f, 0.01145458f, 0.05790385f, 0.00938727f, -0.02706709f, -0.16082273f, 0.10997880f, -0.01749981f, 
    0.06241024f, 0.01422806f, -0.00694088f, 0.11682755f, 0.01336966f, 0.09285911f, -0.08780032f, -0.03987558f, 
    -0.07467402f, -0.08561399f, -0.23546454f, 0.10402706f, 0.02643528f, -0.04607077f, 0.18670483f, 0.06223635f, 
    -0.00123987f, -0.00577391f, -0.04781567f, 0.00691407f, -0.11644074f, 0.12019926f, 0.24763227f, 0.10779763f, 
    0.05365280f, -0.11462694f, 0.04054708f, 0.15133055f, 0.06733622f, 0.03708923f, -0.11286280f, 0.05481283f, 
    -0.19333507f, 0.08074656f, 0.12379373f, -0.16926150f, -0.12445097f, -0.05796812f, -0.03086997f, -0.09042228f, 
    -0.16132595f, -0.01624490f, -0.05546800f, 0.01682117f, 0.30580127f, 0.14164774f, 0.10129835f, 0.14410229f, 
    -0.08629745f, -0.02801823f, 0.05695426f, 0.02012029f, 0.08060974f, -0.00351031f, 0.06354441f, -0.24460292f, 
    0.08934488f, -0.09948114f, -0.19391440f, 0.22617726f, -0.00086853f, -0.00892158f, 0.05512960f, -0.10494028f, 
    -0.05962532f, -0.05245596f, -0.02297953f, -0.09598577f, 0.04098673f, 0.37993932f, -0.26065078f, -0.12999606f, 
    0.12124378f, -0.05104372f, 0.04717559f, 0.09170029f, 0.00667667f, 0.09959955f, -0.07788064f, -0.03659923f, 
    -0.12027223f, -0.04248939f, -0.11867931f, -0.12518051f, -0.16888370f, 0.15659100f, -0.26093990f, -0.00187954f, 
    -0.06111494f, 0.04299981f, 0.02331692f, 0.14011550f, -0.32601038f, -0.09538092f, 0.03547970f, 0.13141564f, 
    -0.09475388f, -0.17115761f, -0.08641208f, 0.04413405f, 0.02686569f, -0.08398817f, 0.09368282f, 0.03080079f, 
    0.00291092f, -0.27392384f, 0.00700010f, 0.06046301f, 0.00509253f, 0.01596122f, -0.09487983f, -0.08089370f, 
    0.03798190f, -0.07237235f, -0.06269592f, 0.12505664f, -0.63152599f, 0.10564093f, 0.01959056f, -0.07527381f, 
    0.00491333f, 0.11451855f, 0.15710157f, -0.02233581f, -0.05516473f, 0.12666109f, 0.02486398f, -0.10240558f, 
    0.16962814f, 0.02973560f, -0.43246290f, -0.16563331f, 0.01131824f, 0.13980858f, -0.21342312f, -0.18191199f, 
    -0.03456765f, 0.08341952f, 0.05911090f, -0.17358942f, -0.71169692f, -0.04974874f, 0.27526411f, 0.10696004f, 
    0.02446285f, -0.13778485f, -0.05313598f, -0.00352480f, -0.04765826f, 0.07809912f, -0.07095073f, -0.02281864f, 
    -0.35219747f, -0.43173668f, -0.14733931f, 0.10185625f, -0.17725597f, 0.04653320f, 0.08971520f, -0.02914498f, 
    0.10215083f, -0.09015737f, 0.02767038f, -0.20936680f, -0.25640374f, -0.26290441f, 0.35477722f, -0.10948954f, 
    0.01606847f, 0.14578074f, -0.06069983f, -0.09312426f, 0.08288395f, 0.07234845f, -0.03922192f, 0.04912665f, 
    0.80049628f, 0.04538252f, -0.08414486f, -0.01558094f, -0.02615345f, -0.04503030f, 0.02841974f, 0.04924314f, 
    0.12401866f, -0.09084570f, -0.01864244f, 0.00770312f, 0.01626816f, -0.03337352f, -0.13262364f, 0.07347646f, 
    0.06581740f, 0.01325872f, 0.25747934f, 0.14252117f, -0.04182224f, 0.17626789f, -0.07126193f, 0.01395728f, 
    0.11788636f, 0.04887177f, 0.00335338f, -0.08433942f, 0.00026538f, 0.09291731f, -0.08789088f, 0.03497298f, 
    -0.11688809f, -0.03261855f, 0.05805558f, 0.08841565f, 0.09676537f, -0.07932825f, 0.25697988f, 0.26617214f, 
    -0.03820415f, -0.03424338f, 0.06100322f, 0.12504934f, 0.07599953f, 0.07741527f, 0.09139521f, 0.06202253f, 
    -0.27917191f, -0.04664379f, 0.42734385f, 0.13524409f, 0.03442901f, -0.10499484f, -0.10882843f, -0.08081910f, 
    0.16583104f, -0.12104564f, -0.11516247f, -0.14979561f, -0.00797585f, -0.05625400f, 0.11247396f, 0.11214577f, 
    -0.01568308f, 0.01926637f, -0.00085352f, 0.07371914f, 0.01994743f, 0.05464753f, 0.08444241f, 0.04937037f, 
    0.11985824f, 0.16488516f, -0.12662199f, 0.07337605f, 0.05738578f, 0.07385469f, 0.13659371f, 0.08805417f, 
    0.02770946f, 0.00247621f, 0.07711416f, -0.00124978f, -0.96508759f, 0.03121398f, 0.16581869f, 0.22383702f, 
    0.13164712f, 0.09508041f, 0.01159745f, 0.12376621f, -0.16755341f, 0.06101587f, 0.13969560f, 0.05379485f, 
    -0.11826592f, 0.10298729f, 0.12183403f, 0.16703440f, -0.08502867f, -0.17206775f, 0.11232005f, -0.06570330f, 
    0.01476500f, -0.11839501f, -0.11358380f, -0.09144224f, -0.13616394f, -0.01197059f, 0.17102148f, 0.13593440f, 
    -0.09516991f, -0.07533967f, 0.07530244f, -0.03868894f, -0.04685193f, 0.05594633f, -0.18538739f, 0.07592905f, 
    -0.31853807f, -0.01790459f, -0.15826066f, -0.31444374f, -0.06709909f, -0.03488284f, 0.12163574f, -0.00647522f, 
    0.08109103f, 0.06085443f, -0.12647235f, -0.02877150f, -0.34607288f, -0.05847574f, 0.19448361f, 0.27189898f, 
    0.03085790f, -0.04392141f, 0.02142253f, -0.08452605f, 0.00287740f, 0.07795016f, 0.14754975f, 0.02703873f, 
    0.16309740f, -0.41172090f, -0.21117111f, 0.17709832f, -0.11226217f, 0.01572879f, 0.06371852f, -0.05427232f, 
    -0.05004036f, 0.01241192f, 0.12505184f, 0.13233435f, -0.17013197f, 0.32974848f, -0.00056520f, -0.29250550f, 
    -0.02723544f, -0.01638624f, -0.20580709f, 0.08160402f, 0.02825678f, -0.01199107f, -0.13371734f, 0.08194780f, 
    -0.00960134f, 0.19128576f, 0.34340319f, -0.17948946f, -0.08066392f, 0.15010056f, -0.02696572f, 0.09742174f, 
    0.00318854f, 0.03803774f, 0.11545486f, -0.10554539f, 0.13353157f, 0.09658603f, -0.13122150f, 0.05902805f, 
    -0.08412478f, -0.02614767f, -0.02832121f, 0.32346362f, 0.00962476f, -0.01102984f, 0.06245385f, -0.03994376f, 
    -0.43160596f, -0.17587432f, 0.07150519f, 0.17085356f, -0.04223666f, 0.05474732f, 0.13860060f, 0.10026426f, 
    0.05252207f, 0.17899755f, -0.06722976f, 0.09280447f, -0.41061527f, -0.00385274f, 0.02767439f, 0.02272562f, 
    0.15568244f, -0.03345450f, 0.06099734f, -0.08120491f, 0.06101035f, 0.07720525f, -0.09276419f, 0.22429870f, 
    -0.19500431f, 0.22851537f, 0.35297942f, -0.15911029f, 0.02335780f, 0.00456117f, -0.01585706f, -0.00797966f, 
    0.01156545f, 0.09044233f, -0.00398564f, 0.10112177f, -0.56629407f, -0.31216991f, -0.25020722f, 0.02640829f, 
    0.05827368f, 0.15756689f, -0.25170341f, -0.08103093f, 0.07749798f, -0.02869636f, 0.24104556f, 0.09683613f, 
    -0.02932685f, -0.30535877f, 0.02968169f, 0.24540116f, 0.00327072f, -0.15522510f, 0.00703434f, -0.03278475f, 
    -0.21142520f, 0.24079083f, 0.09804599f, 0.03061968f, 0.03113778f, 0.10655767f, 0.12530901f, -0.09972249f, 
    0.07986449f, 0.07972629f, 0.10584124f, -0.13706176f, -0.06658407f, 0.06965315f, 0.05480171f, 0.21609673f, 
    0.22036980f, 0.23518603f, 0.25715500f, -0.45085385f, -0.07044963f, 0.01233828f, 0.01406710f, -0.06392948f, 
    -0.07761788f, -0.00664831f, -0.12346013f, -0.09382737f, -0.40043548f, -0.28307942f, 0.14275578f, -0.03481754f, 
    0.08866279f, -0.11531707f, 0.09935766f, 0.03480597f, 0.13718510f, -0.13718781f, 0.07499959f, -0.06822246f, 
    -0.02642205f, -0.02330342f, 0.03945713f, 0.29318979f, 0.05770680f, 0.02005505f, 0.06297973f, -0.08303366f, 
    -0.03391155f, -0.07080647f, -0.17079233f, 0.07109978f, 0.31624717f, 0.03103251f, -0.20234755f, -0.16512540f, 
    -0.04466341f, 0.19567662f, 0.02122273f, -0.16114672f, -0.01058279f, -0.28821617f, -0.08857579f, 0.00468595f, 
    -0.33594680f, 0.06585462f, -0.16500446f, 0.13440257f, 0.10646197f, -0.15255314f, 0.02450342f, 0.04526878f, 
    0.12648249f, -0.01015907f, 0.00276997f, -0.02942710f, -0.33097273f, 0.29482520f, 0.15340301f, -0.14892672f, 
    0.01011642f, -0.14160986f, -0.10191853f, 0.13287805f, 0.04506519f, -0.06222615f, 0.13329302f, -0.20705523f, 
    0.20174135f, 0.10449705f, -0.06842094f, -0.02500729f, 0.09102418f, 0.03311121f, -0.10637395f, -0.16968840f, 
    -0.03305888f, -0.01992027f, -0.00715169f, 0.10488522f, -0.45892200f, -0.14609879f, -0.22039309f, -0.23989503f, 
    0.08822433f, 0.31633240f, 0.07427679f, -0.02529417f, 0.00754999f, -0.12537295f, 0.18587196f, -0.21586904f, 
    -0.08914326f, 0.13063526f, 0.13808613f, 0.01889817f, -0.13596396f, -0.04983126f, -0.13123153f, -0.03900351f, 
    -0.10769909f, 0.03328845f, -0.03917798f, 0.09090579f, 0.02738207f, -0.08040474f, -0.05241111f, 0.21245484f, 
    0.06387617f, -0.04432744f, -0.00367046f, 0.07437862f, 0.14226998f, -0.14298640f, -0.01602625f, -0.09280878f, 
    -0.00777280f, -0.21592897f, 0.10654522f, 0.39310730f, 0.07316063f, -0.03155004f, 0.12904455f, -0.19324601f, 
    -0.08204298f, -0.09748103f, -0.14063466f, 0.05837860f, -0.10434849f, 0.14311735f, 0.09361511f, -0.23499388f, 
    0.10987598f, 0.08509897f, -0.03035656f, -0.11565124f, -0.02529412f, -0.14540435f, -0.16095525f, 0.01313509f, 
    -0.26611587f, -0.27760574f, 0.13939402f, 0.23432843f, -0.01212654f, -0.08811440f, 0.05603820f, 0.02670448f, 
    -0.07281764f, -0.00731762f, -0.18134840f, -0.05385714f, -0.28446925f, -0.16863522f, -0.36205474f, 0.06341477f, 
    0.16986164f, 0.06666210f, -0.25883734f, 0.11005068f, 0.21153463f, -0.03707815f, 0.08382361f, -0.01504475f, 
    0.19075730f, 0.05492874f, 0.08625424f, 0.06645837f, -0.11206192f, 0.04397705f, 0.08156655f, 0.01451660f, 
    -0.16637053f, -0.01236652f, 0.09917557f, 0.33769083f, 0.18672526f, 0.05834275f, -0.02126209f, 0.14873798f, 
    -0.00845354f, 0.10897391f, 0.23029920f, -0.00703908f, -0.05253348f, -0.06492341f, 0.02792556f, -0.08711436f, 
    -0.07769769f, 0.09752256f, 0.05785038f, -0.22405507f, 0.04840502f, -0.09320712f, -0.00338149f, 0.08070026f, 
    0.22481360f, 0.22723052f, -0.06060053f, 0.10176045f, -0.38233802f, -0.00090376f, -0.48514819f, -0.20697124f, 
    0.10222322f, 0.06440469f, 0.03195373f, -0.01893019f, 0.12441386f, -0.06227259f, -0.15677412f, 0.03289000f, 
    0.03310927f, -0.19150467f, 0.27310312f, 0.05656614f, -0.10645737f, -0.10876242f, 0.00169945f, 0.04571601f, 
    -0.02777124f, 0.21830812f, 0.11838977f, 0.00607231f, -0.70135921f, -0.32755396f, -0.05837686f, 0.03530185f, 
    -0.01765136f, 0.05897370f, -0.05668754f, -0.12069695f, 0.08318462f, 0.07790440f, -0.09394278f, -0.00910555f, 
    -0.23552702f, 0.06423767f, 0.15231875f, -0.28792265f, 0.05002148f, 0.15226758f, -0.07801364f, 0.02633199f, 
    0.10259930f, 0.14098839f, 0.28593189f, 0.03730345f, 0.34809092f, 0.27295411f, -0.06467715f, -0.11041852f, 
    0.00374189f, 0.05301597f, -0.25904557f, -0.09031834f, 0.11025728f, -0.09280341f, 0.15311757f, -0.09550077f, 
    0.32078287f, 0.04340787f, 0.25054562f, -0.11416871f, 0.08535214f, 0.11558517f, -0.39593339f, -0.23894267f, 
    -0.13085632f, -0.09562950f, 0.00221932f, -0.08811474f, -0.55455077f, -0.05039934f, -0.12466495f, -0.15786693f, 
    0.11536342f, 0.05122099f, 0.04964138f, -0.11009664f, -0.11922640f, 0.14644270f, -0.05736693f, -0.32349262f, 
    0.12204451f, 0.22249220f, 0.06311620f, 0.03635408f, 0.02250186f, -0.04756754f, 0.10204677f, -0.16311923f, 
    0.00163708f, -0.00227367f, -0.02910565f, 0.21565121f, -0.37951580f, 0.05385679f, 0.24037299f, 0.20927711f, 
    0.10867034f, -0.07405450f, 0.10458247f, -0.04089477f, -0.00498691f, -0.10716082f, -0.12208246f, 0.04101124f, 
    0.11878128f, 0.19520181f, -0.12637697f, -0.11844349f, 0.03057531f, -0.09126669f, 0.02033151f, -0.21790650f, 
    -0.02044441f, -0.13852040f, 0.18305209f, -0.12544636f, 0.04176829f, 0.18496972f, -0.29319122f, -0.31298423f, 
    0.01136248f, 0.05895887f, 0.01976020f, -0.10818128f, 0.14053175f, 0.01090079f, -0.10597280f, -0.14236894f, 
    -0.10182560f, -0.20306656f, 0.30509523f, -0.15553179f, -0.22629310f, -0.05658475f, -0.02823255f, 0.10874724f, 
    -0.13040797f, -0.08529013f, -0.06603995f, -0.25888473f, 0.30638218f, -0.01678720f, -0.05719927f, 0.04977642f, 
    0.00394905f, 0.11387948f, -0.02940306f, -0.13459526f, -0.02845736f, -0.03785188f, -0.01246479f, -0.07516339f, 
    0.19203952f, -0.15307771f, -0.00140127f, -0.02762580f, 0.16553549f, 0.16835953f, -0.02878334f, -0.00512290f, 
    0.11881520f, -0.16888028f, -0.08327810f, 0.03507911f, -0.06949982f, 0.17032310f, 0.19358595f, -0.52327710f, 
    -0.19175291f, -0.02798667f, -0.05486727f, 0.08178677f, 0.21727920f, -0.11789545f, -0.03376172f, -0.17024532f, 
    -0.40184289f, 0.16265793f, 0.01728111f, -0.07573576f, -0.07723239f, 0.18386136f, -0.10942644f, 0.12088218f, 
    -0.03109823f, 0.05140436f, -0.02392997f, 0.12395588f, 0.39708176f, -0.60415024f, -0.04843646f, 0.05620180f, 
    -0.12528738f, 0.02338704f, -0.00319368f, -0.02813146f, 0.01004732f, 0.15887612f, -0.16629232f, 0.23002167f, 
    -0.14054331f, 0.32147312f, 0.12784690f, 0.19452168f, -0.01006551f, 0.12517388f, 0.11128355f, 0.14206022f, 
    0.01699488f, 0.10578011f, 0.17991383f, -0.02597741f, -0.31532040f, -0.00282769f, -0.13691348f, 0.23417129f, 
    -0.16091004f, 0.04265937f, 0.08618550f, 0.02084969f, 0.01672822f, 0.10225488f, 0.11247522f, 0.00870536f, 
    -0.12924078f, 0.09674622f, -0.28348815f, 0.34749025f, 0.05058658f, -0.02755735f, 0.02293120f, -0.07159332f, 
    0.17173076f, -0.05474039f, -0.06952485f, -0.12463846f, 0.71977592f, -0.37557486f, 0.34312484f, -0.17321698f, 
    0.05553959f, 0.12742066f, 0.10869475f, -0.10164516f, 0.01955614f, 0.02294543f, 0.12608115f, 0.06698670f, 
    -0.12374792f, -0.03062761f, 0.14305498f, 0.36319318f, -0.05337575f, 0.05379850f, 0.06181626f, 0.01242454f, 
    0.08048102f, -0.04309069f, 0.00060776f, -0.03994821f, -0.13474204f, -0.17140391f, -0.26174527f, -0.09494730f, 
    -0.02715089f, 0.09592977f, -0.07692830f, -0.05415991f, -0.13657902f, 0.06019315f, -0.15358926f, 0.32176378f, 
    0.31358474f, 0.09070379f, -0.15796867f, 0.15567568f, -0.01155319f, 0.10199094f, -0.06659848f, 0.10226681f, 
    -0.05669595f, -0.03669507f, 0.07501327f, -0.17110413f, -0.58453238f, 0.15843391f, -0.19824246f, 0.44160351f, 
    -0.01595897f, 0.21931116f, -0.00691374f, -0.03771503f, -0.15110770f, -0.09192484f, -0.00097871f, -0.02470647f, 
    -0.05154683f, 0.17146657f, 0.00423456f, 0.00095212f, -0.32491922f, 0.04456334f, -0.02098494f, -0.02680689f, 
    -0.18993825f, -0.04366092f, 0.00206813f, -0.21144252f, 0.14103362f, -0.58107507f, 0.10310386f, -0.01444304f, 
    -0.20657496f, 0.00215387f, 0.13016671f, 0.15295845f, 0.24643874f, -0.06839152f, 0.05916679f, 0.14907478f, 
    -0.07945616f, -0.09744132f, -0.09493838f, 0.22642992f, -0.00291993f, -0.08372270f, 0.02236364f, 0.12471962f, 
    -0.07201154f, 0.13894646f, -0.04636018f, 0.23343682f, -0.16558942f, -0.00001582f, -0.35626340f, -0.26728427f, 
    -0.01151528f, -0.03824138f, 0.05663025f, -0.14935374f, -0.26213315f, -0.04275222f, -0.01315103f, 0.00110919f, 
    0.30011082f, 0.17165825f, 0.03339687f, -0.59818310f, -0.12177662f, -0.05179952f, 0.15062873f, 0.02004425f, 
    0.08805916f, -0.07365117f, -0.02745545f, -0.05076087f, -0.24261364f, -0.02323831f, -0.32658598f, -0.22841232f, 
    -0.02802669f, 0.00439276f, -0.21727166f, -0.11956125f, 0.06922551f, 0.12382624f, -0.14460731f, 0.05669443f, 
    0.16848989f, 0.15758233f, 0.06782694f, -0.45539960f, -0.12645930f, 0.07832675f, 0.14843486f, 0.10753761f, 
    -0.06528261f, -0.17750353f, -0.01763632f, 0.01066120f, -0.04547582f, -0.19266255f, -0.10176637f, -0.34816805f, 
    0.06428166f, -0.01254898f, -0.08862901f, -0.20355499f, 0.05219893f, -0.03207731f, 0.21860768f, 0.16473973f, 
    -0.15666655f, -0.11866856f, -0.22273666f, 0.08769431f, 0.21657379f, 0.01726261f, 0.04597634f, 0.04334540f, 
    -0.03870424f, -0.14617881f, -0.07224493f, -0.08446983f, -0.03708310f, -0.14606516f, -0.02075504f, 0.07234777f, 
    0.00314769f, -0.12204983f, 0.12781873f, 0.00823551f, -0.20584090f, -0.02715916f, -0.01044710f, -0.05522673f, 
    -0.11240104f, -0.42105663f, -0.15141377f, -0.01274960f, 0.15808661f, 0.15498011f, -0.00323525f, 0.06958192f, 
    0.20778954f, -0.09513618f, -0.26938859f, -0.12076861f, -0.29617187f, -0.05101060f, -0.24933782f, 0.07583958f, 
    -0.07257658f, -0.04665000f, 0.09655668f, 0.07383092f, -0.07039616f, -0.01827922f, 0.05217506f, 0.00520805f, 
    -0.57108253f, -0.15653735f, -0.03604340f, 0.06255422f, 0.06778796f, -0.08235417f, 0.26987848f, 0.07716937f, 
    0.21988073f, -0.02198845f, 0.01277607f, 0.05853777f, 0.45631087f, -0.19087136f, 0.09882963f, 0.00619066f, 
    0.06713519f, -0.08235753f, 0.05551726f, -0.10519025f, 0.02617610f, 0.12479284f, 0.30382210f, 0.08104278f, 
    0.04620237f, 0.15407477f, 0.02287574f, 0.13282511f, -0.05997139f, 0.10673969f, -0.01533800f, -0.13071507f, 
    -0.14342828f, 0.01076080f, 0.15423405f, -0.11474337f, 0.13919334f, -0.15407449f, -0.05183750f, 0.03583530f, 
    0.02830585f, -0.06781168f, -0.04754541f, -0.09395351f, -0.13164592f, -0.05080889f, 0.03264507f, -0.11920121f, 
    0.27161837f, 0.05619708f, 0.13289838f, 0.16370402f, -0.04030723f, -0.00791648f, 0.03079378f, -0.01749129f, 
    0.01020651f, -0.16417375f, -0.00199754f, 0.14418983f, 0.18501571f, 0.07115334f, 0.20305760f, 0.12594113f, 
    -0.03890831f, 0.05367813f, -0.00230214f, -0.13951752f, 0.00048297f, 0.10582299f, 0.05648264f, -0.12870826f, 
    -0.14087449f, 0.18285351f, -0.00454125f, 0.00583303f, -0.02988269f, -0.02178723f, 0.06925347f, -0.12423296f, 
    -0.18083972f, 0.03365105f, -0.12932707f, -0.16438900f, -0.02872863f, 0.15480934f, 0.05699144f, 0.04839719f, 
    0.06691372f, -0.03637450f, 0.02532886f, -0.02669070f, -0.03737094f, 0.00634646f, -0.14536415f, -0.04958142f, 
    0.24960715f, -0.20872165f, 0.17575516f, 0.19160452f, 0.02068798f, -0.08342409f, -0.13181248f, -0.00740531f, 
    -0.05756830f, -0.03750727f, -0.06612685f, -0.11487374f, -0.41145462f, 0.13772273f, -0.10570136f, -0.20457943f, 
    -0.08130213f, -0.08201065f, 0.03797307f, -0.16878775f, 0.00215135f, -0.11182344f, 0.02396547f, -0.12206385f, 
    -0.42941925f, 0.13713719f, -0.06535861f, -0.24299332f, -0.02472877f, -0.02438292f, -0.14571805f, 0.01073003f, 
    -0.10195508f, -0.12849754f, -0.11808947f, -0.12388539f, 0.00090872f, 0.00065593f, 0.15267472f, -0.05959851f, 
    0.22155097f, -0.03983543f, -0.03577216f, 0.04928357f, -0.05717784f, 0.04576425f, 0.11214608f, -0.04353056f, 
    -0.16700280f, -0.18125366f, -0.18999553f, -0.32892230f, -0.01985936f, 0.00084999f, -0.00721011f, -0.12139553f, 
    -0.15321282f, -0.03623686f, -0.06791241f, -0.14313932f, -0.03493033f, 0.12989762f, -0.18217343f, -0.08840251f, 
    -0.06707420f, -0.02918689f, -0.06613505f, 0.04573520f, 0.01455951f, 0.17496227f, -0.03746589f, 0.00621131f, 
    -0.02026243f, 0.13099843f, 0.12654725f, 0.12782212f, 0.05485064f, -0.18936068f, -0.03516724f, 0.00352911f, 
    0.04517944f, -0.07242499f, -0.04253050f, -0.02522916f, 0.37639356f, -0.12754759f, 0.06655373f, -0.33150968f, 
    -0.04979891f, -0.04734354f, 0.00444925f, -0.05095198f, -0.03156501f, 0.11262114f, -0.09209549f, -0.08780766f, 
    0.05632315f, 0.11106235f, -0.06328704f, -0.04590693f, -0.08616520f, -0.13581701f, 0.04604236f, 0.10906781f, 
    0.05793507f, -0.05550237f, 0.09083154f, -0.06628558f, -0.07328334f, 0.15695591f, 0.20513320f, 0.05676337f, 
    0.08656457f, 0.08053830f, 0.02937991f, 0.02625655f, -0.02191981f, -0.02977221f, 0.03132737f, 0.02227713f, 
    -0.26299250f, 0.10609525f, -0.26413688f, 0.00771501f, -0.01056063f, -0.07039437f, -0.15421599f, 0.06999426f, 
    -0.09110805f, -0.04524294f, -0.01605096f, -0.03990590f, -0.26113883f, -0.13334033f, -0.22980826f, -0.18769701f, 
    -0.01489843f, -0.08152822f, -0.05483795f, 0.01948510f, -0.11535446f, 0.00456466f, 0.02437619f, -0.06566764f, 
    -0.05865951f, 0.17607269f, -0.00141774f, 0.17394294f, 0.17806451f, -0.07868925f, 0.00963560f, -0.05488181f, 
    -0.05868912f, 0.04350224f, 0.02845944f, -0.08170384f, 0.01260052f, -0.28709736f, -0.03191658f, -0.12279057f, 
    -0.02413352f, 0.05079324f, -0.03473005f, -0.14470373f, 0.02928315f, -0.14845967f, -0.11984222f, -0.08471021f, 
    -0.49890545f, 0.14496666f, -0.13395564f, 0.22408427f, 0.09042901f, -0.05748699f, -0.08827814f, -0.00327253f, 
    0.00293077f, -0.02901279f, 0.04276592f, -0.08307818f, 0.10858390f, 0.11371541f, 0.22304715f, 0.09399040f, 
    0.10830559f, 0.04867851f, 0.05654284f, -0.06458637f, -0.11954970f, -0.00063069f, -0.06180858f, -0.10726172f, 
    -0.02782995f, -0.14449155f, -0.23816973f, -0.01630893f, -0.12678637f, -0.18091460f, -0.11403363f, -0.09049950f, 
    -0.02803874f, -0.02760601f, -0.03140366f, -0.00446512f, 0.11152191f, 0.02253888f, 0.10841057f, 0.15820573f, 
    0.02680655f, -0.07033671f, -0.07694098f, -0.03290453f, -0.04868382f, 0.01701611f, -0.00880119f, -0.04758969f, 
    -0.21942684f, 0.25157511f, -0.09331104f, -0.23227881f, -0.06866608f, -0.00673739f, -0.09753907f, -0.23553538f, 
    -0.06704810f, -0.03215367f, 0.01957147f, 0.00145839f, 0.23613016f, 0.17628476f, 0.31482100f, 0.06155138f, 
    -0.00157630f, 0.12025429f, 0.14756855f, 0.08587075f, -0.04581363f, 0.20621803f, -0.07523777f, -0.05038982f, 
    0.26465869f, 0.03324301f, 0.15214077f, 0.33106172f, 0.09097155f, -0.14969482f, -0.15530509f, -0.14770739f, 
    -0.11248824f, -0.13606241f, -0.03663229f, -0.09269841f, 0.19543532f, -0.09904643f, 0.17912921f, 0.13544109f, 
    0.22247896f, -0.03167938f, -0.05640560f, 0.04252895f, -0.12327836f, 0.01729772f, -0.01344936f, 0.05650154f, 
    -0.45288107f, 0.28961298f, 0.08449516f, -0.11441074f, -0.12777705f, -0.06055345f, 0.00610473f, -0.12324540f, 
    -0.00152659f, -0.02519779f, 0.00020429f, -0.11193556f, 0.03676704f, 0.15126938f, -0.00921794f, 0.00431415f, 
    0.04130086f, -0.01585108f, 0.17548533f, -0.07317201f, 0.03515124f, 0.10326111f, 0.00363032f, -0.07007863f, 
    0.39597526f, 0.29973212f, -0.00460057f, 0.27546641f, 0.13464285f, -0.01530786f, 0.01442222f, -0.05712514f, 
    -0.03294191f, 0.10890266f, -0.11254060f, -0.00206551f, -0.25521865f, -0.09389266f, 0.17869894f, -0.15056618f, 
    0.03794322f, 0.03682889f, 0.01937813f, -0.04074930f, -0.04099935f, 0.04110650f, -0.11605305f, -0.03148670f, 
    -0.13748306f, -0.28733638f, 0.17617650f, -0.03595152f, -0.00086989f, -0.26500425f, -0.05734784f, 0.02798105f, 
    0.06415010f, -0.02125237f, -0.07300936f, -0.23184517f, 0.18326065f, -0.24131905f, -0.23730999f, -0.38772199f, 
    0.15274042f, -0.00503816f, 0.03751798f, 0.05185765f, 0.06322302f, -0.02255349f, 0.04611890f, -0.13988599f, 
    -0.09215135f, -0.10757759f, 0.09570633f, -0.33213437f, 0.08714311f, -0.05392781f, 0.12769216f, 0.03545370f, 
    0.17525288f, 0.10918187f, -0.00564018f, 0.09862711f, -0.39506847f, -0.12564349f, 0.16498710f, -0.23533359f, 
    0.02048680f, -0.05493101f, -0.04600651f, -0.20710729f, -0.05720978f, -0.12674895f, 0.01581422f, 0.15531382f, 
    0.19799381f, 0.02127892f, 0.18134780f, 0.05359288f, 0.09251123f, 0.01894703f, -0.04033150f, -0.08428593f, 
    0.06651349f, 0.07293051f, -0.10443236f, -0.17357711f, 0.15591760f, -0.00431651f, 0.00337689f, -0.20193446f, 
    0.05497441f, -0.09691225f, -0.09883724f, -0.15239748f, -0.05748786f, -0.03533849f, 0.21998569f, -0.18878305f, 
    -0.04793805f, -0.26604766f, -0.09324605f, -0.42781544f, 0.02335865f, 0.05325196f, 0.05836025f, -0.00941787f, 
    -0.00170561f, 0.13258304f, -0.09715142f, -0.15589921f, 0.01056081f, -0.18522841f, 0.12038359f, 0.23948935f, 
    0.16402164f, 0.01642025f, -0.05374920f, -0.08724376f, -0.08355673f, 0.17853284f, -0.01491297f, 0.12248053f, 
    0.13751441f, -0.05104675f, 0.07315973f, 0.21697165f, 0.15623210f, -0.10578705f, -0.12313912f, -0.15251268f, 
    -0.01094248f, -0.01561254f, -0.07754247f, -0.06730831f, 0.09532230f, -0.15641779f, 0.16577025f, 0.09419315f, 
    -0.07536413f, -0.12030371f, 0.06447923f, -0.09721371f, 0.03025008f, -0.06348736f, 0.07059455f, -0.12594683f, 
    0.14333080f, 0.05643211f, -0.07276705f, -0.05709087f, 0.14566641f, -0.12880279f, -0.10318513f, -0.12983042f, 
    0.08266658f, 0.07439013f, -0.09638164f, 0.04572936f, 0.31977177f, 0.08859248f, -0.08772656f, 0.12899213f, 
    -0.01255672f, 0.18148774f, 0.02181212f, 0.05769159f, 0.02896973f, -0.20286441f, 0.06392504f, 0.04871983f, 
    0.03856746f, 0.43956652f, -0.23372699f, 0.04290548f, 0.00349359f, -0.00180208f, -0.08839831f, -0.08093161f, 
    -0.15582398f, 0.02881341f, 0.01354130f, 0.06305380f, 0.14416091f, -0.24661177f, -0.00305663f, 0.05871493f, 
    -0.03178968f, -0.08116359f, -0.17622700f, -0.02830526f, 0.02134793f, -0.03357938f, 0.09219957f, 0.07541429f, 
    0.04764998f, 0.20960638f, -0.21228324f, 0.02693960f, 0.18565361f, -0.02012903f, -0.29596809f, 0.03065848f, 
    0.01333879f, -0.05674154f, 0.08686507f, -0.00581764f, 0.03848209f, 0.18098128f, 0.00115794f, 0.23717076f, 
    0.01782904f, 0.05523391f, -0.03479967f, 0.05820341f, -0.07206611f, 0.02934500f, 0.04057007f, -0.17049383f, 
    0.00562160f, 0.26167277f, -0.37756997f, -0.03202669f, -0.14406498f, -0.00384175f, -0.30070552f, 0.00630369f, 
    0.06203446f, 0.07040148f, 0.07503621f, 0.18395461f, 0.12793660f, 0.18210427f, -0.36142138f, -0.29401419f, 
    0.03860565f, 0.12464567f, -0.09331822f, -0.10450161f, 0.08174682f, -0.02428649f, -0.20213683f, -0.04445289f, 
    -0.15126570f, -0.07551027f, -0.03105766f, -0.10532373f, 0.10535118f, 0.05960051f, 0.11262155f, -0.06999037f, 
    0.06479958f, -0.10415183f, -0.05221625f, 0.06283001f, 0.25736019f, -0.13460498f, 0.15656666f, 0.08925893f, 
    -0.02307837f, -0.09582356f, -0.09321512f, -0.11427917f, 0.01692874f, -0.03722873f, 0.02103207f, -0.14460962f, 
    -0.07561904f, 0.02628284f, -0.16701305f, -0.04919107f, 0.21912476f, -0.07376592f, -0.20298840f, 0.05000833f, 
    0.15899779f, 0.11727713f, -0.05886763f, -0.03822849f, -0.35425645f, 0.07560290f, 0.24669512f, -0.08792775f, 
    -0.09002800f, 0.08634595f, -0.21259235f, 0.07296157f, 0.04775019f, -0.08051471f, 0.05807728f, 0.06360336f, 
    -0.38404307f, -0.21929242f, -0.20916502f, 0.03828474f, 0.14097732f, 0.04574381f, 0.02454653f, -0.13849509f, 
    0.05423473f, 0.05476667f, -0.00924749f, 0.06266646f, -0.23843275f, -0.04440141f, -0.22630540f, -0.37285504f, 
    -0.08149619f, 0.00191074f, 0.04164916f, -0.05428962f, 0.03927352f, -0.10735139f, -0.05468697f, -0.12686814f, 
    -0.06489690f, -0.04321461f, 0.12820253f, 0.27416173f, 0.10748059f, -0.17524782f, -0.08237777f, -0.00513827f, 
    0.10300385f, 0.09502885f, -0.03107355f, -0.08037202f, -0.20336387f, -0.06155854f, 0.26581740f, 0.19328400f, 
    -0.19369581f, -0.05243634f, -0.01035740f, 0.06243052f, 0.08424340f, -0.09939783f, -0.22515440f, 0.06550504f, 
    -0.01557725f, 0.22349988f, -0.24888186f, 0.03876759f, 0.03974280f, -0.01552888f, 0.03437714f, 0.00670099f, 
    0.03923260f, 0.09804237f, 0.09906435f, 0.10131540f, 0.19473016f, -0.08224389f, 0.09581001f, 0.06784103f, 
    -0.12463439f, 0.05628748f, -0.00496104f, -0.12623873f, 0.07362535f, 0.05114367f, -0.03111684f, -0.05599991f, 
    0.17631656f, -0.01783789f, -0.05401059f, 0.13038848f, -0.02671618f, -0.10132954f, -0.06670452f, 0.04052927f, 
    0.12390110f, -0.01088016f, 0.04702879f, 0.12537222f, -0.00846182f, 0.14054617f, -0.01570817f, 0.12110703f, 
    -0.24984904f, 0.23109968f, -0.16750720f, 0.04920987f, 0.00208723f, -0.03599099f, 0.09730590f, -0.08484071f, 
    -0.31948778f, 0.22008668f, -0.11562862f, -0.09401295f, 0.00634490f, -0.14112362f, -0.29170454f, 0.11792823f, 
    0.04844612f, 0.01623273f, -0.02849960f, -0.18911485f, 0.02294024f, -0.56551844f, 0.24408005f, 0.06399821f, 
    -0.03851140f, 0.01453595f, -0.03219268f, 0.00318745f, -0.04187756f, -0.13317901f, -0.06896791f, -0.13689594f, 
    -0.09614958f, -0.01345446f, 0.09055118f, 0.20100033f, -0.10053001f, -0.03340775f, -0.04694625f, -0.02519751f, 
    -0.16670503f, 0.13969563f, -0.01053755f, 0.10424921f, 0.36036670f, 0.04964131f, 0.33499277f, 0.05748000f, 
    0.11776080f, 0.05260037f, 0.00136789f, -0.19877087f, -0.04900680f, 0.01981900f, -0.01434836f, -0.07713366f, 
    0.12499432f, 0.03974430f, -0.11845114f, 0.03277450f, -0.04032740f, -0.01553414f, -0.10713572f, -0.11214416f, 
    0.07205324f, -0.00271812f, -0.11921804f, 0.17937705f, -0.11715677f, -0.11622462f, 0.06051810f, 0.23678061f, 
    -0.10711573f, 0.02032641f, -0.05196193f, -0.08959340f, 0.02687319f, 0.00627645f, 0.07219451f, -0.20405337f, 
    -0.18818009f, 0.56079322f, -0.69730115f, -0.21888256f, 0.20345758f, -0.02607237f, -0.10378642f, -0.02748970f, 
    -0.02989373f, -0.13803273f, -0.06050744f, 0.03646494f, -0.65409118f, -0.20900713f, 0.10642903f, 0.04547001f, 
    -0.01265466f, 0.02647623f, -0.06718261f, 0.05236919f, 0.05359541f, 0.03700902f, -0.12594964f, -0.07183544f, 
    0.26618055f, -0.12245946f, -0.25096595f, -0.14224459f, 0.01209290f, -0.05625986f, -0.00056999f, 0.10128394f, 
    0.23273683f, -0.00254920f, -0.19491960f, 0.02385690f, -0.38772777f, 0.21841151f, -0.24563004f, -0.38017395f, 
    0.14710712f, -0.03990630f, -0.05992084f, 0.05921686f, -0.21231435f, -0.03642915f, -0.00205644f, -0.21879420f, 
    -0.43200919f, 0.10002167f, 0.11546095f, -0.31945476f, 0.01767382f, -0.11128986f, 0.11401708f, -0.05603319f, 
    0.09409793f, 0.12356387f, 0.23809375f, 0.06080998f, 0.21599339f, -0.16019174f, 0.05510578f, 0.07389676f, 
    0.05965275f, 0.23190166f, -0.12217338f, 0.12134723f, -0.17555140f, 0.15872812f, 0.03173327f, 0.04869050f, 
    0.20408468f, 0.07332002f, 0.03332524f, -0.45379636f, 0.06576062f, 0.01946682f, 0.00838551f, 0.19296849f, 
    0.09516323f, 0.03046090f, 0.03148946f, -0.07753453f, -0.37551543f, 0.34353051f, 0.30320010f, -0.08766317f, 
    0.24380329f, -0.04163347f, 0.00076197f, 0.07821634f, 0.18079890f, 0.19338989f, -0.03540677f, 0.15664071f, 
    0.22981691f, -0.24812475f, 0.43304092f, 0.00522224f, -0.02214940f, -0.13577773f, -0.04360294f, 0.12452017f, 
    -0.17719610f, 0.06535114f, 0.01279791f, 0.00472427f, -0.16661522f, -0.15731196f, 0.04836075f, 0.15935716f, 
    0.08330445f, -0.02664315f, -0.03114031f, -0.05595499f, 0.03532463f, -0.00586326f, -0.11282220f, 0.11372209f, 
    -0.38300091f, -0.00940293f, 0.41772571f, 0.03668996f, 0.09216226f, 0.04652002f, 0.06866038f, 0.15938924f, 
    0.07914846f, -0.04447036f, 0.02151900f, -0.28727576f, 0.01002797f, -0.46539494f, 0.28490469f, -0.03024240f, 
    0.01288637f, -0.05948534f, -0.05569612f, -0.02434338f, 0.15019311f, 0.02069910f, -0.06090306f, 0.06171484f, 
    -0.14717390f, 0.25878653f, 0.04634064f, 0.09090718f, -0.04947012f, 0.05265638f, 0.06548117f, 0.04703035f, 
    -0.19584379f, 0.01736093f, -0.09815828f, -0.09270173f, 0.63755703f, 0.10211481f, 0.22219278f, 0.04337405f, 
    -0.04459290f, 0.09300771f, 0.21038911f, -0.03526118f, -0.06265393f, -0.02743745f, 0.06066870f, 0.02156377f, 
    -0.30475858f, -0.37213770f, 0.07963411f, 0.00956549f, -0.05161507f, -0.05298472f, -0.14410655f, 0.10400603f, 
    -0.07011196f, -0.10225380f, 0.14519490f, 0.14666025f, 0.26296416f, -0.08062938f, -0.15543905f, -0.00352529f, 
    -0.02377729f, -0.15425828f, 0.11402317f, -0.04533688f, 0.10424747f, 0.12639870f, 0.17649528f, 0.09183092f, 
    -0.43262458f, 0.13567047f, 0.05230524f, -0.27511418f, -0.08914430f, 0.08786810f, -0.10390265f, 0.04382186f, 
    0.09543564f, -0.07216223f, 0.16454324f, 0.00911225f, 0.09444791f, -0.32720831f, -0.10737933f, -0.08060111f, 
    0.07370806f, 0.11972125f, -0.00820331f, -0.03222993f, -0.16538745f, 0.07921787f, -0.19966283f, -0.06405051f, 
    -0.18360814f, 0.23804948f, -0.30231658f, -0.62417084f, -0.11016428f, -0.12963699f, -0.01669636f, 0.01989704f, 
    -0.05942219f, -0.01064316f, -0.06322151f, -0.04999046f, -0.02943596f, -0.10475507f, 0.00906826f, 0.02471095f, 
    -0.04066296f, -0.05331464f, 0.01775201f, -0.11348517f, 0.04528037f, -0.11503525f, 0.06120830f, 0.07201978f, 
    -0.31168202f, 0.14324178f, -0.07728662f, -0.10491131f, 0.17628519f, -0.00470995f, -0.06094269f, -0.16682753f, 
    -0.06068305f, -0.09658207f, -0.01482115f, -0.15643331f, -0.11593130f, -0.21343575f, -0.13204922f, 0.08941866f, 
    0.08087665f, 0.13441566f, -0.02379183f, 0.00709814f, -0.13336667f, 0.13135427f, -0.07892687f, -0.16584735f, 
    0.12800977f, -0.38484433f, 0.04933495f, -0.22258268f, -0.05350470f, 0.13824722f, -0.12191491f, -0.09480477f, 
    -0.17363718f, -0.22144113f, -0.01363938f, -0.10128580f, 0.73843199f, -0.42107421f, 0.14026371f, 0.00278662f, 
    -0.00095826f, -0.03831898f, 0.08137672f, 0.02033077f, -0.08253179f, -0.07494021f, 0.11759587f, 0.04790208f, 
    -0.10581377f, 0.64904183f, -0.27408841f, 0.23522042f, 0.09901225f, -0.15245786f, 0.05219759f, -0.06435133f, 
    -0.05708345f, 0.03823004f, -0.10197010f, -0.09773606f, -0.18182546f, -0.11008950f, 0.16116981f, -0.08503219f, 
    0.03842359f, 0.17309906f, 0.01614588f, 0.10743704f, -0.04508082f, -0.07699443f, -0.19643909f, 0.17603758f, 
    -0.02254290f, -0.04718556f, 0.01936412f, 0.16757549f, -0.16775383f, 0.02340041f, -0.09323274f, 0.32414016f, 
    -0.05673723f, 0.13424653f, 0.09547359f, 0.05552877f, -0.16507129f, -0.11720952f, -0.04951367f, -0.04279371f, 
    0.00456544f, -0.14846089f, -0.01964955f, -0.15865298f, 0.08292418f, 0.00132799f, 0.10503907f, 0.19026503f, 
    0.18787874f, 0.03638608f, 0.13250744f, -0.01457287f, -0.00036571f, -0.36387402f, -0.06646025f, 0.02349328f, 
    0.02063945f, -0.17077670f, -0.02732719f, 0.02708904f, -0.54103583f, 0.16985941f, 0.16485417f, 0.14297214f, 
    0.13734113f, -0.08053704f, -0.07671441f, -0.04456342f, 0.13076705f, 0.13932060f, -0.05372547f, 0.06824937f, 
    0.11896373f, -0.02336102f, -0.05601897f, 0.06622338f, -0.02827677f, 0.08529627f, 0.02873367f, -0.10268076f, 
    0.03100742f, 0.21602131f, -0.16033782f, 0.13738881f, 0.31538329f, 0.12436597f, 0.07816225f, -0.12289675f, 
    0.11295915f, 0.07616971f, 0.09834145f, -0.05684313f, -0.04864848f, -0.25488782f, 0.01788395f, 0.13990496f, 
    -0.27177414f, -0.16314653f, 0.02020078f, -0.16219383f, 0.01191531f, -0.10090076f, 0.00109774f, 0.05987368f, 
    0.06632126f, 0.15522586f, 0.13747194f, 0.07764649f, 0.15841280f, 0.00250517f, -0.10667045f, -0.01545500f, 
    -0.04919219f, 0.02272280f, 0.11503655f, 0.01990740f, 0.02113557f, -0.02284011f, 0.09963322f, -0.07084750f, 
    0.14072530f, 0.32506943f, -0.01472870f, -0.07461465f, 0.00915371f, 0.08003841f, 0.12258564f, 0.09941223f, 
    0.14110236f, 0.20221367f, 0.08644257f, 0.00940939f, -0.82680291f, -0.55558103f, -0.36743945f, -0.38398883f, 
    0.12058593f, -0.03335511f, 0.06911382f, 0.02539706f, 0.10418689f, 0.19260082f, 0.02040755f, 0.19043520f, 
    -0.45758885f, -0.49065033f, -0.16584778f, 0.07974435f, 0.17445520f, -0.02925340f, 0.11128186f, -0.02049739f, 
    0.11443789f, 0.00289451f, 0.02885257f, 0.15363640f, -0.01590522f, 0.27035648f, -0.16174342f, 0.01351922f, 
    -0.04192567f, -0.04812790f, -0.12410961f, -0.00974023f, 0.11721141f, -0.01408876f, 0.07853857f, 0.04772837f, 
    -0.67209667f, -0.34912097f, -0.08505322f, -0.01864929f, 0.23841301f, 0.00560577f, -0.02002806f, -0.18662921f, 
    -0.09611102f, -0.13029140f, 0.11124382f, 0.11614168f, -0.65217370f, -0.26377559f, -0.10938120f, 0.05868498f, 
    0.01721212f, 0.00555203f, 0.19344737f, -0.04116582f, 0.20654407f, -0.31720746f, 0.02557279f, -0.01749372f, 
    0.08802554f, 0.13045748f, 0.04964210f, -0.10983676f, -0.21575512f, 0.10902721f, -0.17923419f, -0.07337140f, 
    0.01003424f, -0.04066501f, -0.10907737f, -0.07412005f, 0.23723212f, -0.01731500f, -0.22007138f, -0.04581458f, 
    0.05173769f, -0.00022081f, -0.09346808f, 0.06230959f, -0.11073211f, 0.06767833f, -0.12687899f, -0.00289299f, 
    -0.34879223f, -0.44468391f, 0.12871695f, -0.05935435f, -0.22014430f, -0.06301891f, -0.11440824f, 0.02872090f, 
    0.07607706f, 0.03528600f, -0.01120170f, 0.12700906f, 0.36393917f, 0.08464152f, -0.08800267f, 0.03238937f, 
    -0.11387276f, -0.02654177f, 0.02643774f, 0.06954403f, -0.00920935f, 0.07498118f, 0.17145298f, -0.26026851f, 
    -0.35770959f, -0.57141864f, 0.07367609f, -0.05096099f, 0.21815956f, 0.06897032f, -0.08358779f, 0.03145077f, 
    0.11590793f, 0.06143066f, 0.07009302f, 0.15983456f, -0.88229895f, -0.20738533f, 0.16394898f, 0.18975359f, 
    0.27703059f, 0.01417353f, 0.10642228f, -0.02202005f, 0.14823867f, 0.00568523f, -0.22514728f, 0.13108933f, 
    -0.38044375f, 0.03561733f, -0.06449928f, 0.07494576f, 0.03148943f, 0.17184763f, -0.01093250f, -0.07321502f, 
    -0.05106138f, 0.17127493f, -0.03010910f, -0.00518181f, 0.04541531f, 0.23050097f, -0.26500523f, -0.09378678f, 
    0.07242357f, -0.08269873f, -0.18375295f, 0.05478482f, -0.05204903f, -0.19395894f, -0.09152945f, -0.02252119f, 
    -0.11781359f, -0.07554770f, -0.18924999f, -0.04680395f, 0.15628774f, -0.04183532f, 0.00251213f, 0.06142084f, 
    0.04461128f, -0.13675822f, -0.03890648f, -0.00475940f, 0.13982171f, 0.08457666f, 0.02302707f, -0.09352585f, 
    -0.00741429f, -0.04790740f, 0.00259286f, -0.05498051f, -0.04061214f, -0.08869611f, 0.16214512f, -0.09414703f, 
    0.17143261f, 0.23402414f, 0.06037299f, -0.21745118f, 0.04632085f, 0.06389631f, -0.03330031f, 0.12514231f, 
    -0.04856421f, 0.13561843f, 0.15579993f, 0.15435587f, 0.37400156f, 0.13039263f, 0.02790901f, 0.05199830f, 
    -0.04696171f, 0.24621807f, -0.04089105f, -0.03254214f, 0.07615502f, -0.05247654f, -0.03766961f, -0.11817752f, 
    -0.46953928f, -0.21588878f, -0.24923636f, -0.52634013f, 0.11745422f, -0.20176728f, -0.05204961f, 0.11501792f, 
    -0.01286096f, -0.15438256f, -0.15365788f, -0.01179947f, 0.38734454f, 0.07316700f, -0.00393744f, -0.27405286f, 
    -0.17597957f, -0.09594618f, -0.05390831f, -0.04987286f, 0.11411957f, -0.17745952f, -0.12944180f, -0.01989413f, 
    0.15760499f, 0.04467392f, -0.17045875f, 0.00059915f, 0.15933813f, 0.06395470f, -0.05953234f, 0.03457731f, 
    0.15024115f, 0.38045159f, 0.02544977f, 0.29413253f, -0.21025157f, -0.01034698f, -0.18590790f, 0.14158389f, 
    -0.06567367f, 0.01967033f, 0.03356965f, 0.02765997f, -0.02804154f, 0.12825367f, 0.05700778f, -0.08175652f, 
    -0.00012689f, 0.02567066f, -0.12610872f, 0.15527564f, 0.01107931f, 0.01847643f, 0.09677718f, 0.14258099f, 
    0.13178472f, 0.05213084f, 0.19541779f, 0.04639414f, 0.14182132f, -0.13008173f, -0.03368057f, 0.01801583f, 
    -0.10977402f, -0.05320448f, 0.05836293f, 0.10986719f, 0.00644021f, 0.00282826f, -0.06055277f, 0.01258290f, 
    -0.17190544f, -0.13318025f, 0.03528450f, -0.09295040f, 0.03287026f, 0.02166934f, -0.07658885f, -0.08130705f, 
    -0.00211742f, -0.13683997f, -0.10029627f, -0.14480823f, 0.28523490f, 0.12967928f, 0.00291244f, 0.23516290f, 
    -0.13998221f, -0.06484386f, 0.04030019f, 0.18689819f, -0.03695498f, -0.13613141f, -0.15732196f, -0.34367111f, 
    -0.07212432f, -0.16979890f, -0.05768402f, -0.36921164f, -0.02586925f, -0.02236267f, 0.08615364f, -0.22816496f, 
    -0.01367641f, -0.05356531f, 0.07565257f, -0.00479333f, 0.58889943f, 0.33936399f, -0.05614557f, -0.21066806f, 
    -0.07783247f, 0.13222155f, -0.22335954f, -0.04345632f, 0.15958251f, -0.05249696f, -0.03532633f, 0.07451172f, 
    -0.08447028f, 0.08746976f, 0.00965641f, 0.12263110f, 0.06974682f, 0.03247491f, -0.00538546f, -0.10384184f, 
    0.07327241f, -0.12895887f, 0.10980082f, -0.09627692f, -0.12380606f, 0.28504196f, -0.23749810f, -0.41920361f, 
    -0.01752651f, -0.02479926f, -0.00097926f, -0.10245927f, -0.09658632f, 0.02141794f, 0.10873513f, -0.18963526f, 
    -0.09079023f, -0.50312978f, -0.00718872f, -0.04064988f, -0.15680431f, 0.06165943f, -0.00720070f, -0.01965803f, 
    -0.09149021f, -0.11831802f, 0.01299802f, 0.09551782f, 0.32130471f, -0.08591313f, -0.18892112f, 0.04717461f, 
    0.04976149f, 0.09603816f, 0.02199554f, -0.15537079f, -0.15548901f, -0.05289645f, -0.08287120f, -0.02104193f, 
    -0.23736715f, 0.01618017f, -0.06497640f, 0.34846780f, -0.32832295f, 0.00695468f, -0.11340249f, -0.02860048f, 
    -0.03562466f, -0.14691953f, -0.02790787f, 0.05693639f, 0.22090530f, -0.21827550f, -0.17415014f, -0.02132317f, 
    0.18715505f, 0.06047202f, -0.03357175f, -0.02106771f, -0.04752843f, -0.04768730f, -0.09755158f, -0.10432994f, 
    -0.24521217f, -0.00271000f, -0.09876058f, -0.22791310f, 0.10448299f, -0.05525632f, 0.09734751f, 0.16549206f, 
    -0.00529271f, -0.02014940f, 0.00539198f, -0.06758494f, -0.49812633f, -0.06330592f, -0.02426575f, -0.12885560f, 
    -0.09330253f, 0.10879426f, -0.00541991f, 0.00221362f, -0.00356751f, 0.02648162f, -0.10191885f, -0.02014239f, 
    0.37843257f, -0.30448690f, 0.03813944f, -0.29679900f, -0.04516343f, 0.08192369f, 0.05585982f, 0.09250076f, 
    -0.02511740f, -0.01848901f, 0.05373610f, 0.08124153f, -0.14259331f, -0.31145260f, -0.06455896f, -0.17993079f, 
    -0.01892008f, -0.04893372f, 0.22118104f, 0.12337107f, -0.06742581f, 0.13497704f, 0.02935180f, -0.22209190f, 
    -0.14282578f, -0.01723559f, -0.04092349f, 0.08163535f, 0.04810988f, 0.12222021f, -0.00404317f, -0.06286389f, 
    -0.10368518f, 0.03729941f, -0.00464833f, -0.12141456f, -0.31848913f, 0.23399252f, -0.08259680f, -0.15960170f, 
    0.21583328f, -0.15599920f, 0.01916604f, 0.01842618f, 0.01759887f, 0.07285637f, 0.07035022f, 0.12047707f, 
    -0.34085709f, -0.36252213f, -0.04601579f, 0.15867010f, 0.27578431f, 0.11876510f, 0.01510593f, 0.01874379f, 
    -0.02234612f, 0.08162200f, -0.24362186f, -0.00179554f, 0.05349707f, 0.01944240f, -0.06541746f, 0.10879776f, 
    -0.02247908f, -0.01047398f, -0.03096882f, -0.02638704f, -0.03719387f, -0.08186790f, -0.00004265f, -0.06216171f, 
    0.27877712f, 0.16624048f, -0.12278024f, 0.30154246f, 0.28225350f, -0.03740038f, -0.07978066f, -0.02790312f, 
    0.09081155f, 0.14393835f, -0.02869909f, -0.07532508f, 0.54523897f, 0.06829415f, -0.00112625f, -0.17146856f, 
    -0.05505260f, -0.28883138f, -0.11360038f, 0.16963097f, 0.05497744f, 0.12871253f, 0.20541403f, 0.10037098f, 
    -0.09174624f, 0.00165399f, 0.00856091f, 0.03409037f, -0.11737117f, 0.07053471f, -0.05394927f, 0.01745658f, 
    0.00778913f, -0.01128674f, -0.05672361f, 0.08553851f, -0.64356142f, 0.16900259f, -0.16379753f, -0.21680425f, 
    -0.02602895f, -0.05314529f, -0.06278870f, 0.00798443f, -0.02199801f, 0.08726047f, 0.14010830f, 0.15776767f, 
    0.02597434f, -0.18345056f, -0.15100943f, 0.59044433f, 0.04200830f, 0.09047185f, 0.03507621f, 0.05465617f, 
    0.13389127f, 0.13107000f, 0.10298446f, 0.10637480f, 0.06244391f, 0.18527865f, -0.17819031f, 0.05121443f, 
    -0.14718859f, -0.21704996f, -0.02007582f, -0.11089155f, -0.08013424f, 0.04861277f, -0.04477011f, -0.02122067f, 
    0.27385110f, -0.04742282f, -0.27463287f, 0.19184166f, 0.19692306f, -0.06852786f, 0.01434858f, 0.03418900f, 
    -0.04004284f, -0.07501778f, -0.04495232f, 0.06874029f, -0.28886551f, 0.07120454f, -0.16824216f, 0.05345928f, 
    0.11781591f, -0.13621613f, -0.06206939f, -0.07174660f, 0.08514363f, 0.09258097f, 0.00622879f, 0.11212589f, 
    0.09394623f, -0.34670150f, -0.13968791f, -0.28312308f, -0.09027749f, 0.11129516f, -0.02089968f, 0.10117267f, 
    -0.05457187f, -0.00630381f, 0.00587945f, 0.09300152f, -0.27443197f, 0.35663706f, -0.08416487f, 0.08100328f, 
    0.03819916f, -0.18512440f, -0.04131012f, 0.04615628f, -0.00849001f, 0.01867906f, 0.09378766f, -0.24619421f, 
    0.29710439f, -0.04350098f, -0.16601942f, 0.32756451f, 0.00231421f, 0.08437351f, 0.00202157f, 0.06379398f, 
    -0.03791533f, -0.12824519f, 0.04129312f, -0.10911655f, -0.48273471f, 0.23030117f, 0.07988577f, -0.06859752f, 
    -0.13699166f, 0.09193072f, -0.16198653f, 0.14199492f, -0.12214755f, 0.01183132f, 0.03820147f, -0.04211479f, 
    0.27659148f, -0.10752691f, 0.23530751f, 0.42380372f, -0.06592111f, 0.04440236f, -0.04456055f, -0.04989159f, 
    -0.06030888f, -0.09671836f, 0.03878701f, -0.00982348f, -0.06161181f, -0.27231649f, -0.18442103f, 0.08994968f, 
    -0.03713742f, -0.04641255f, 0.12460131f, 0.00968939f, -0.15692858f, -0.06341247f, -0.10356633f, -0.01545871f, 
    -0.01751084f, 0.38759899f, -0.26750106f, 0.22134669f, 0.15347786f, -0.02742491f, -0.01789081f, -0.27035820f, 
    0.09898131f, 0.04850971f, 0.06443665f, 0.07029406f, -0.19014478f, -0.04661964f, 0.08157030f, -0.17725097f, 
    0.03770086f, 0.05400841f, 0.05415671f, 0.06305758f, 0.08578929f, 0.01184783f, -0.09368163f, 0.16224857f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.10637353f, 0.09306625f, -0.08884297f, 0.01527791f, 0.03916691f, 0.03198266f, 0.01434722f, -0.10571400f, 
    -0.04358791f, -0.03822044f, 0.15310766f, 0.02571050f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
