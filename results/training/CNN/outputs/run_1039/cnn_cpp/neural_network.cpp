#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.53303814f, -0.08444618f, 0.16123641f, -0.39888772f, -0.50366479f, 0.04452148f, -0.32274050f, -0.45696038f, 
    -0.66359270f, 0.07456421f, 0.27174193f, 0.24865553f, 0.26119986f, 0.40079606f, 0.27280253f, -0.32369027f, 
    -0.23127469f, -0.29126740f, -0.05094332f, -0.06605627f, 0.05041340f, 0.37522554f, -0.01193036f, -0.01099418f, 
    -0.00275910f, 0.45840773f, -0.37324277f, -0.59613532f, -0.01762912f, 0.33505434f, 0.11885575f, 0.31419498f, 
    0.24239545f, -0.14667915f, -0.29053584f, -0.22721191f, -0.43007606f, -0.20471831f, -0.04956326f, -0.06205555f, 
    -0.04469376f, 0.11564570f, 0.14064428f, 0.35536325f, -0.01731733f, 0.14630820f, -0.14143039f, -0.36726451f, 
    -0.55946171f, -0.33287093f, 0.15234807f, -0.59356880f, 0.18738066f, 0.44397154f, -0.38562742f, -0.40924641f, 
    -0.13217707f, -0.15523489f, 0.18952042f, -0.36150330f, 0.11793464f, 0.05628180f, -0.29878828f, -0.23848771f, 
    0.28934816f, -0.25714976f, 0.26404241f, -0.28798392f, -0.08469830f, -0.41327643f, -0.29935485f, -0.16610247f, 
    -0.21821280f, -0.32226476f, -0.27605096f, 0.65013087f, 0.37159097f, -0.23360643f, 0.27427307f, -0.00721600f, 
    0.13963856f, 0.09518859f, -0.17596444f, -0.38449699f, -0.10158134f, 0.37237591f, -0.43169954f, 0.14500494f, 
    -0.12573080f, -0.13556002f, -0.22549663f, 0.09064054f, 0.04203654f, 0.20476510f, -0.33773527f, 0.15850879f, 
    -0.05933348f, -0.12999275f, -0.22415414f, -0.28758666f, -0.48279947f, 0.50737464f, 0.59011412f, -0.45297331f, 
    -0.52624375f, -0.66113603f, 0.02011747f, 0.17560034f, 0.70872343f, 0.13162197f, -0.21182971f, 0.04687656f, 
    0.22423601f, 0.35727641f, -0.08530519f, 0.21129584f, -0.23695885f, -0.04636038f, -0.09062659f, -0.26615608f, 
    -0.18834339f, 0.15412824f, 0.30490625f, -0.09672176f, -0.05319718f, -0.39622262f, -0.50435716f, -0.22217290f, 
    0.53719044f, 0.01439992f, 0.15753385f, 0.10043764f, 0.60270995f, 0.10987533f, 0.22144011f, -0.16428076f, 
    -0.13113460f, -0.01901575f, 0.71919668f, -0.31799614f, -0.09657497f, 0.17041256f, -0.31400576f, 0.06602280f, 
    -0.10980672f, -0.10103754f, -0.25589010f, 0.14372526f, 0.39011085f, -0.13142918f, -0.62256432f, -0.82064563f, 
    -0.81668931f, -0.42006052f, -0.08606404f, 0.33681318f, -0.08664162f, 0.34640148f, 0.37290058f, 0.35674652f, 
    0.35847902f, 0.30281645f, 0.14040779f, 0.02980783f, 0.11591309f, 0.18079032f, -0.09059113f, -0.28874964f, 
    -0.14085889f, -0.13141699f, -0.19236813f, 0.01031812f, -0.07299037f, -0.01511409f, -0.05389327f, 0.36317971f, 
    -0.31616402f, -0.09708710f, 0.12197222f, 0.23773979f, -0.34865794f, 0.11439843f, -0.16380407f, 0.48322138f, 
    0.46187362f, -0.12563792f, 0.27978337f, -0.31214961f, 0.09239633f, 0.27763510f, -0.35434705f, 0.38323188f, 
    -0.26939359f, -0.06549165f, 0.12179603f, -0.26908174f, 0.26966619f, 0.05499974f, 0.17350066f, -0.13619412f, 
    0.09982732f, -0.25924021f, 0.53418928f, -0.27280775f, 0.19808842f, -0.32190251f, -0.13850693f, -0.18155861f, 
    0.15476260f, 0.10542933f, 0.21361126f, -0.22663355f, 0.03211286f, 0.32606611f, -0.23723897f, -0.09074795f, 
    -0.02333411f, 0.19212334f, -0.02294997f, 0.07827615f, -0.09246423f, 0.13103662f, 0.15834679f, 0.06532639f, 
    0.32619953f, -0.68518245f, -0.26004404f, 0.24006689f, -0.00410522f, 0.37658465f, -0.55554402f, -0.52632725f, 
    -0.50838792f, -0.25322950f, 0.25211897f, 0.07885354f, -0.36823252f, -0.15480727f, 0.34349254f, -0.50109231f, 
    -0.06230961f, -0.46911177f, 0.01853659f, -0.16973606f, -0.19260938f, -0.08427161f, -0.19424993f, -0.17854822f, 
    -0.26954296f, -0.25806746f, -0.49909502f, -0.27567112f, 0.39430350f, 0.16987370f, 0.43457356f, -0.07001771f, 
    0.22172035f, 0.10284565f, 0.40319160f, 0.11093588f, -0.05807064f, -0.20470038f, 0.04496758f, 0.11668339f, 
    -0.25002173f, 0.24249165f, -0.06420042f, 0.03488474f, -0.19381185f, 0.14744197f, -0.31938502f, -0.13215698f, 
    -0.09846159f, -0.21356857f, -0.27235571f, 0.81254148f, -0.34937298f, 0.28176400f, 0.12511149f, 0.50256938f, 
    -0.14620617f, -0.18077619f, 0.08532340f, -0.33455870f, -0.43654111f, -0.10036289f, 0.00440599f, 0.17022096f, 
    -0.19468877f, -0.11901977f, -0.11552767f, -0.07709341f, 0.20050722f, 0.10609344f, 0.07143355f, 0.03193492f, 
    -0.07612976f, -0.15552479f, 0.23903935f, -0.18671232f, 0.31469738f, 0.35214651f, 0.22101727f, 0.20764317f, 
    0.14742222f, 0.07025380f, 0.03055817f, 0.14680444f, 0.15845273f, 0.13639456f, 0.32433382f, 0.05073118f, 
    0.04402047f, -0.07189750f, -0.05260735f, 0.23515330f, 0.09512380f, -0.20057906f, 0.02076575f, -0.33199158f, 
    -0.06942791f, 0.16296411f, 0.09171007f, 0.10858051f, -0.03694188f, 0.11639494f, 0.55957055f, -0.23924416f, 
    -0.69662714f, -0.62229490f, 0.08374253f, 0.22942793f, -0.11549969f, 0.43059924f, -0.20379120f, -0.08073365f, 
    -0.06550732f, 0.06634321f, -0.03369037f, -0.01034549f, -0.07102098f, 0.13268432f, -0.40152779f, -0.21966274f, 
    0.18331948f, 0.07687590f, -0.09766528f, -0.29868704f, 0.28050697f, 0.33670026f, 0.27617976f, -0.22367363f, 
    0.01978577f, 0.53531170f, -0.24643742f, 0.51494396f, -0.32652560f, -0.20839798f, -0.02071726f, 0.15373726f, 
    0.15630057f, 0.20545831f, -0.40179613f, -0.19901481f, 0.48697275f, 0.02808130f, 0.13381587f, 0.18236549f, 
    0.21500826f, 0.22484380f, -0.09091121f, 0.07168753f, 0.03155768f, -0.02973120f, -0.39948943f, 0.26727572f, 
    0.26154360f, -0.51370054f, -0.38269445f, -0.54682225f, -0.22710527f, 0.14747633f, 0.13609342f, 0.61392277f, 
    -0.27144089f, 0.34012854f, -0.24861278f, 0.12434723f, 0.03152550f, -0.33052099f, 0.22609454f, 0.19184713f, 
    -0.17009215f, -0.00984930f, -0.25369585f, 0.00874938f, -0.16931668f, 0.12061132f, -0.25331256f, 0.33169034f, 
    0.26104048f, 0.35065028f, 0.48759460f, 0.15564676f, -0.56412655f, -0.80498922f, 0.03865727f, 0.16087115f, 
    -0.19800927f, 0.16900936f, 0.30450040f, -0.09031431f, 0.02146020f, -0.15119009f, 0.08280789f, 0.09897723f, 
    0.26310614f, 0.03836897f, -0.16599664f, -0.15963149f, 0.02168724f, 0.01275762f, 0.09633692f, 0.15140797f, 
    -0.10040866f, -0.65349406f, -0.31707266f, 0.07575605f, -0.04235758f, -0.18213005f, 0.19628407f, -0.33629209f, 
    -0.75810826f, -0.15677799f, 0.41668946f, 0.11177213f, -0.01684713f, 0.11353036f, 0.63321012f, -0.37156525f, 
    0.11934782f, -0.07640444f, -0.13773511f, -0.26358464f, -0.42643335f, -0.29935721f, 0.23327146f, -0.10275589f, 
    -0.06156622f, -0.01911196f, 0.79414111f, -0.05268429f, -0.54783106f, -0.17426206f, 0.00989174f, 0.21917726f, 
    0.47724757f, 0.60378617f, -0.43211082f, -0.54780424f, -0.48970935f, 0.29851571f, -0.23694168f, -0.08785368f, 
    -0.02510165f, -0.07638523f, -0.18128651f, 0.22253424f, 0.09396102f, -0.11086304f, 0.20157795f, -0.05982681f, 
    -0.30234334f, 0.25559339f, -0.17051739f, -0.60724729f, -0.44753858f, -0.51393580f, -0.59552056f, -0.39635688f, 
    0.41714156f, 0.22330128f, -0.36612338f, -0.13077421f, 0.30080017f, -0.24789697f, -0.36191049f, -0.28604388f, 
    -0.17367667f, -0.05229251f, 0.16222692f, 0.08898079f, -0.15586869f, -0.05933959f, 0.04718211f, -0.07572453f, 
    -0.08777450f, -0.02408512f, -0.01528923f, -0.17971095f, -0.26145795f, 0.08346603f, 0.19687712f, 0.52250451f, 
    0.26007548f, -0.17654450f, -0.23992199f, -0.23810934f, 0.12310770f, 0.35709977f, 0.27215248f, 0.15973070f, 
    -0.24684975f, 0.00621179f, 0.47895762f, -0.15611096f, -0.11984471f, -0.06842975f, -0.21894860f, -0.18521053f, 
    0.23267068f, -0.03801971f, -0.22201994f, 0.13483357f, 0.14232357f, -0.30240923f, 0.35115802f, 0.07133739f, 
    -0.23285693f, -0.06882405f, 0.00883741f, -0.42161372f, -0.31594077f, -0.05846808f, -0.36696476f, 0.23262119f, 
    0.32253292f, -0.22327964f, 0.12309336f, 0.01210748f, 0.09015038f, -0.21890116f, -0.08031326f, -0.28537235f, 
    -0.34766790f, 0.23739509f, 0.42338222f, 0.21065108f, 0.29972857f, 0.26353028f, 0.43210638f, -0.10811431f, 
    0.00377983f, -0.38886961f, -0.12631485f, -0.17308193f, 0.34168535f, 0.39733502f, 0.21959880f, 0.15828066f, 
    0.25899991f, -0.33330515f, 0.08818669f, -0.36189133f, -0.16717027f, 0.03954960f, -0.16063254f, 0.27967298f, 
    -0.17917918f, 0.16878027f, 0.11593416f, -0.07489213f, -0.23724686f, -0.36378291f, -0.12732196f, -0.57097787f, 
    -0.28901547f, -0.04463894f, 0.00074239f, 0.19151218f, 0.33871740f, 0.54135704f, 0.05266905f, -0.07816073f, 
    0.06943287f, 0.17503235f, 0.15238990f, -0.19199474f, -0.11256042f, 0.02120527f, -0.19949356f, -0.18498047f, 
    -0.10811571f, 0.15627639f, -0.31584293f, 0.21907838f, 0.12571928f, 0.07246371f, 0.20785686f, 0.01939324f, 
    0.32060796f, 0.33261049f, 0.33881128f, 0.07284814f, -0.17702584f, -0.56327730f, -0.45813829f, 0.25952220f, 
    0.22224557f, 0.11808311f, -0.02646972f, 0.20493361f, 0.10697629f, 0.38715932f, -0.40034547f, -0.12969288f, 
    0.21457273f, -0.14354512f, -0.21365994f, -0.12039880f, -0.11838857f, -0.31098863f, -0.15492749f, -0.44315875f, 
    0.14239076f, -0.85642254f, -0.31352016f, 0.55042011f, -0.52647942f, -0.37307271f, 0.28792882f, -0.05866131f, 
    0.27952576f, -0.14869258f, 0.30769610f, -0.16009218f, -0.25001201f, 0.00012943f, -0.13509688f, -0.36048624f, 
    0.04243109f, -0.00190950f, -0.08029891f, 0.38284707f, 0.19181503f, -0.22549945f, -0.01314483f, -0.00437378f, 
    -0.04395908f, -0.05473484f, -0.93014187f, -0.33185858f, 0.01336791f, 0.32369158f, -0.31743124f, 0.35742542f, 
    0.16159452f, 0.11242858f, 0.20258777f, 0.19909514f, -0.52339786f, -0.29061845f, 0.21494234f, 0.24919483f, 
    0.04423111f, 0.11780120f, 0.17510790f, -0.13789630f, -0.26989987f, -0.27940038f, 0.11422554f, 0.38826615f, 
    0.34010652f, -0.26678023f, -0.01344106f, -0.08483876f, 0.68789864f, 0.41528967f, -0.28518021f, -0.24686740f, 
    -0.25315884f, 0.06872503f, -0.36392754f, -0.30942580f, -0.65332246f, 0.47589326f, 0.31591943f, -0.22464107f, 
    -0.22738692f, 0.06997184f, 0.23433949f, 0.03999445f, -0.07548559f, -0.17261428f, -0.25503436f, -0.09414026f, 
    0.01069780f, -0.04177250f, -0.30269042f, -0.31569895f, -0.49918649f, -0.51408172f, -0.21228836f, 0.05395226f, 
    0.38141394f, -0.25237456f, -0.09298760f, -0.13267903f, -0.23276974f, 0.06845527f, -0.17989044f, -0.23839162f, 
    -0.14378899f, -0.02082616f, -0.31635225f, 0.19430326f, 0.08590396f, -0.27899340f, 0.12146189f, -0.04372204f, 
    0.09694906f, 0.24147642f, 0.23365463f, 0.07786196f, 0.20947985f, 0.28722066f, -0.25736538f, -0.35694203f, 
    -0.27881896f, -0.42800716f, -0.48414090f, -0.54488522f, -0.36178651f, -0.52703571f, -0.88755286f, 0.17210570f, 
    0.18716164f, 0.02323098f, 0.36072692f, 0.04465804f, 0.12326581f, 0.13943377f, 0.14178802f, 0.04593375f, 
    -0.09381714f, -0.25730446f, 0.11056840f, 0.18890013f, -0.05134522f, 0.12648487f, 0.73799497f, 0.92342138f, 
    0.25571874f, -0.67608637f, 0.04980691f, -0.07558790f, 0.06532332f, 0.26221043f, -0.39732906f, -0.59743226f, 
    -0.29760885f, -0.04965059f, 0.10826544f, 0.19775707f, -0.20163271f, -0.03315885f, 0.17626919f, -0.27732757f, 
    -0.29844901f, 0.27890739f, -0.07584488f, 0.20599739f, 0.13633189f, -0.04803097f, 0.21454881f, 0.43964347f, 
    -0.22747202f, -0.61900872f, 0.13874674f, 0.76401043f, 0.04337784f, 0.26979908f, -0.28033206f, -0.60027748f, 
    -0.60481638f, -0.07579890f, 0.05394921f, 0.15866402f, -0.36947867f, -0.23008460f, -0.00111275f, 0.12505962f, 
    -0.11230014f, 0.18891987f, -0.05767234f, 0.05348562f, 0.14024036f, -0.04905928f, -0.12888162f, 0.17453361f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.01832354f, -0.01977983f, -0.08877130f, 0.19963740f, 0.35212412f, -0.03830042f, 0.05417327f, 0.13276443f, 
    0.08812832f, -0.11599252f, -0.17563753f, 0.00392128f, -0.23820886f, 0.28917414f, -0.16827154f, 0.10504808f, 
    -0.00520828f, 0.05315752f, 0.22588444f, -0.27656496f, -0.04708378f, -0.13227862f, -0.00911766f, 0.13197690f, 
    -0.13184150f, -0.10283571f, -0.01518900f, 0.02166432f, -0.04539480f, 0.06640467f, 0.11897084f, 0.08723240f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.23822223f, 0.43307573f, 0.07054854f, 0.04440857f, -0.04063757f, 0.11516447f, 0.09626014f, -0.02479697f, 
    0.20741715f, 0.05594605f, -0.09004661f, -0.03200928f, -0.07811841f, -0.22877005f, 0.10007498f, -0.03550477f, 
    -0.07732629f, -0.01020991f, 0.11104136f, 0.18207136f, 0.08568388f, 0.10490178f, 0.09035917f, 0.25114223f, 
    0.24856107f, 0.05535606f, 0.26154345f, 0.06204418f, 0.14705494f, 0.13902554f, 0.00218649f, 0.13574916f, 
    0.07567076f, 0.02680439f, 0.15480290f, 0.13005982f, 0.06104399f, -0.29018652f, -0.03753690f, 0.08410348f, 
    0.01701114f, 0.03094658f, 0.10324638f, -0.03853048f, 0.04456222f, -0.00502126f, -0.10387640f, 0.04240425f, 
    -0.38364050f, 0.14400113f, -0.07810549f, -0.07012636f, 0.01582806f, -0.08250745f, -0.04981646f, 0.01397386f, 
    0.09063815f, 0.03314413f, -0.00412133f, 0.00569437f, 0.24072194f, -0.15528700f, -0.17705792f, 0.16292515f, 
    -0.04364063f, -0.00628896f, -0.17679165f, -0.02942453f, -0.03630899f, 0.03360837f, -0.00403450f, -0.01429821f, 
    0.26139170f, -0.04584202f, 0.12242252f, 0.03043826f, 0.05518000f, -0.04436796f, -0.11794253f, -0.08009790f, 
    -0.01812195f, -0.05333473f, 0.02874403f, 0.03083568f, 0.09272113f, -0.23505262f, 0.02696982f, -0.19621259f, 
    0.15804772f, -0.10865884f, -0.13541810f, -0.13313867f, -0.11824413f, -0.13220803f, 0.06035170f, -0.06910447f, 
    -0.20389719f, -0.09247780f, -0.03021893f, -0.06605930f, -0.08156586f, 0.07635839f, 0.03323094f, -0.09900069f, 
    0.05443932f, -0.03363483f, -0.30326807f, -0.18633898f, 0.01554946f, 0.18832684f, 0.27997139f, 0.14364953f, 
    0.12530023f, 0.14208028f, 0.03677792f, 0.06433024f, 0.08144362f, 0.09251738f, -0.00517384f, 0.19745924f, 
    -0.10909227f, -0.10182481f, -0.02325821f, 0.20276102f, -0.02919547f, -0.00927193f, 0.07486457f, 0.04983230f, 
    0.06483077f, 0.12399950f, 0.00058469f, 0.09146433f, 0.29716712f, -0.54718262f, -0.14477564f, -0.04776889f, 
    0.11612708f, 0.07507434f, 0.09186397f, 0.13105562f, -0.01929517f, -0.13265330f, -0.12063669f, -0.01189434f, 
    -0.22375658f, -0.24015044f, -0.09242315f, 0.16631630f, 0.12632950f, 0.13349986f, -0.02805899f, -0.06700533f, 
    0.04939298f, 0.01854789f, 0.06734091f, 0.01431871f, -0.05985805f, 0.01531907f, -0.16063012f, -0.24963027f, 
    0.00138110f, 0.00761050f, 0.01536655f, -0.04130080f, 0.03681867f, 0.10339072f, 0.03260491f, 0.08883982f, 
    0.35521835f, -0.33461004f, 0.09899954f, -0.22290878f, 0.11165087f, -0.07852338f, -0.05946804f, -0.03236271f, 
    0.12013999f, 0.07253329f, 0.06097998f, 0.03223933f, 0.07154560f, -0.16564067f, 0.05741490f, -0.15449096f, 
    0.05408065f, -0.05085559f, -0.05236448f, 0.24229467f, -0.05698605f, 0.08268688f, 0.03660873f, -0.05288456f, 
    -0.39004424f, -0.10559593f, -0.09356790f, 0.11921499f, 0.16226462f, 0.12761855f, -0.10848206f, 0.21864505f, 
    0.09578134f, 0.03654149f, -0.07645435f, -0.14360942f, 0.08509043f, 0.23937167f, 0.01715698f, -0.09582845f, 
    0.01748010f, 0.11564750f, 0.19611199f, 0.02728898f, 0.07663948f, -0.00270887f, 0.06394878f, 0.11125786f, 
    -0.06947760f, -0.02156883f, -0.14638828f, -0.19234715f, 0.07761831f, -0.08716314f, 0.02009465f, 0.13571756f, 
    0.04965901f, 0.08644685f, -0.06425227f, -0.08217662f, -0.09153347f, 0.11866654f, -0.04844383f, -0.10739455f, 
    0.06763312f, 0.01445606f, -0.05316387f, 0.19037090f, -0.01388370f, -0.11825623f, -0.01719204f, 0.06046590f, 
    -0.08508329f, -0.12887606f, 0.14131121f, 0.06816709f, -0.04841807f, 0.06121675f, -0.11620280f, -0.09040111f, 
    -0.10646410f, 0.06663024f, -0.07832714f, 0.10633943f, 0.13251197f, 0.18738329f, 0.02487584f, 0.22259846f, 
    -0.02726113f, 0.17364213f, 0.08168992f, -0.08250587f, -0.09543517f, -0.23257427f, -0.09469450f, -0.13758728f, 
    -0.01589891f, -0.10467430f, -0.05806728f, -0.25397909f, -0.05417364f, -0.10024684f, 0.25699052f, 0.04584003f, 
    0.20046227f, 0.03324707f, 0.00453128f, 0.12512143f, 0.01333504f, -0.00904255f, 0.14684176f, 0.02534779f, 
    0.05997105f, 0.06496631f, -0.00648230f, -0.19247882f, 0.02110451f, 0.01023172f, -0.08003046f, -0.08338554f, 
    -0.17909482f, -0.20312326f, -0.23929505f, 0.26626030f, -0.00811578f, -0.02940131f, -0.06484129f, -0.02405605f, 
    -0.00218737f, 0.05330261f, 0.07695990f, 0.05545484f, -0.26931468f, 0.08877830f, -0.06528054f, -0.18752524f, 
    -0.07875320f, -0.03330432f, 0.07339437f, -0.08906163f, 0.04107022f, -0.00035652f, -0.07807301f, 0.17042156f, 
    0.09552734f, -0.10443722f, -0.17272758f, 0.00832517f, 0.02106950f, 0.07430940f, -0.07928387f, -0.05175162f, 
    0.17230803f, -0.14955331f, -0.02328997f, -0.08199575f, 0.12104135f, 0.40703186f, 0.01019843f, 0.20867740f, 
    -0.02022744f, 0.09848486f, 0.04419842f, 0.10073224f, -0.10079467f, 0.08544362f, 0.14905322f, -0.04886104f, 
    0.05968726f, 0.06652544f, 0.30018023f, -0.04588386f, 0.05985187f, 0.04704142f, -0.00433043f, -0.03516769f, 
    -0.05718417f, -0.10935560f, 0.06747469f, 0.05777783f, 0.35586604f, 0.48581317f, 0.18377879f, 0.07518302f, 
    0.03650258f, -0.02449162f, 0.15546313f, 0.19586121f, -0.06766853f, 0.11206482f, -0.01213591f, -0.15958294f, 
    0.12469705f, 0.16736200f, -0.57722896f, 0.29287726f, 0.04239688f, -0.01358342f, 0.10291602f, 0.02102003f, 
    0.07918724f, -0.13226436f, 0.05861784f, -0.18702842f, 0.16367267f, -0.14427203f, 0.17297022f, -0.18891686f, 
    0.17332475f, 0.03333151f, 0.08575846f, 0.16699281f, 0.03157945f, 0.05538049f, -0.07956386f, -0.11230119f, 
    0.01669180f, 0.02145967f, 0.02167825f, 0.03093122f, -0.04220785f, -0.01902946f, -0.04464448f, 0.02159724f, 
    0.01241675f, -0.03254988f, -0.04553558f, -0.01938212f, 0.01221639f, 0.04127693f, 0.03750981f, 0.04128133f, 
    0.01519431f, -0.00417826f, 0.04023977f, -0.00303246f, 0.01417466f, -0.05176216f, -0.02927238f, -0.03861074f, 
    0.00417126f, 0.00026320f, -0.02358662f, 0.01422100f, -0.00832428f, -0.03429317f, -0.04109671f, 0.00667334f, 
    0.02798410f, 0.02003692f, -0.01913084f, 0.01129173f, -0.02486274f, 0.01369798f, -0.03116109f, 0.01989917f, 
    -0.03186948f, -0.00949916f, -0.05260148f, 0.04216571f, -0.05341075f, 0.00505138f, 0.03648656f, -0.02337284f, 
    0.01468890f, 0.03103087f, 0.00373001f, -0.03987617f, 0.01936142f, -0.01135213f, 0.03982825f, -0.04174882f, 
    -0.02584312f, 0.03864773f, 0.03774060f, 0.03593454f, -0.04408282f, -0.01969608f, -0.04145636f, -0.02661968f, 
    -0.04233516f, -0.04439598f, -0.00078297f, -0.04394172f, -0.02767226f, -0.02201956f, -0.04670490f, -0.01601339f, 
    -0.04117876f, 0.01733747f, -0.02094938f, 0.03741792f, 0.01444199f, -0.04939047f, -0.00940351f, -0.03088992f, 
    0.01571537f, -0.05234890f, -0.04713263f, -0.03225844f, 0.01078671f, -0.03576194f, -0.04572976f, 0.02588744f, 
    -0.00507019f, 0.00264995f, 0.02361528f, -0.02570591f, -0.05318044f, -0.03473300f, 0.01583837f, -0.05400646f, 
    0.01532357f, -0.04061102f, 0.03455260f, 0.03708185f, -0.01358232f, -0.00837157f, -0.01400698f, -0.02915762f, 
    0.02438894f, -0.03137558f, -0.02192141f, -0.04999290f, -0.01031078f, -0.04315653f, 0.03195606f, 0.00190523f, 
    -0.01382927f, -0.05092387f, -0.03834942f, 0.00052606f, -0.04498632f, -0.00077672f, -0.04789336f, 0.02890840f, 
    0.02770817f, 0.01953237f, -0.04095917f, -0.03749610f, -0.04674619f, 0.02032687f, -0.02364068f, -0.05055490f, 
    -0.00251552f, 0.02771265f, -0.03528912f, -0.00882075f, -0.00641294f, -0.00298631f, -0.02498875f, -0.01190536f, 
    0.02814751f, 0.03616816f, -0.02112665f, -0.00085499f, -0.05079672f, -0.03071281f, -0.00647083f, 0.02349573f, 
    -0.04223829f, -0.05154319f, -0.01742749f, 0.01076367f, 0.04410428f, 0.04441508f, -0.05130649f, 0.02221938f, 
    -0.02373060f, -0.01901047f, -0.01617626f, 0.03181602f, 0.01501096f, 0.01140099f, -0.00439947f, -0.03690143f, 
    -0.01913337f, 0.04356283f, 0.03309919f, -0.00347850f, -0.05061069f, -0.04929465f, -0.05186179f, 0.01710916f, 
    -0.04419192f, 0.01956637f, 0.04120924f, 0.00573040f, 0.00645602f, -0.03167646f, 0.01768548f, -0.00911734f, 
    0.04433171f, -0.02636525f, 0.01278574f, -0.01238888f, -0.02256158f, -0.01843971f, -0.02105077f, -0.05382675f, 
    -0.04744705f, -0.02355180f, 0.02427259f, 0.02734972f, -0.03363608f, -0.03729643f, -0.04209278f, 0.01225275f, 
    -0.03313207f, 0.01495706f, 0.03242460f, 0.02465649f, -0.04551348f, -0.00268480f, 0.03501239f, -0.00614521f, 
    -0.04989753f, 0.04492244f, -0.04963924f, 0.01397676f, 0.03095853f, 0.01367202f, -0.03523729f, 0.03976613f, 
    0.02375497f, 0.04007923f, -0.01937026f, -0.01394786f, -0.03913414f, 0.04175223f, -0.00787142f, 0.02109902f, 
    -0.05375385f, -0.04323099f, 0.03528686f, 0.01368145f, 0.01333764f, -0.02055250f, -0.00044279f, -0.00830667f, 
    -0.01109298f, -0.02523548f, 0.03210767f, 0.00653234f, 0.00030355f, 0.00014946f, 0.02097419f, -0.00111437f, 
    0.00887483f, -0.02274760f, -0.04745862f, -0.01738703f, 0.01317879f, -0.00230762f, -0.04084932f, 0.00059360f, 
    0.00507208f, 0.03312624f, -0.04213594f, -0.04838314f, 0.03489048f, -0.05293733f, 0.03128640f, -0.02034930f, 
    -0.00240541f, -0.02326220f, 0.02574681f, 0.03010310f, -0.01111738f, -0.01657679f, 0.02996529f, -0.00194456f, 
    0.03601572f, -0.01715920f, -0.04085248f, -0.00794382f, -0.02708906f, -0.04198724f, -0.01518095f, -0.00709666f, 
    -0.05510697f, 0.03326356f, 0.01262060f, -0.01472442f, 0.03596873f, -0.01066452f, -0.05523627f, 0.03478024f, 
    -0.04350766f, -0.03210574f, 0.02005253f, 0.03470338f, -0.01360983f, 0.00730139f, -0.05479245f, 0.03614803f, 
    0.02408557f, -0.03230343f, -0.02807159f, -0.04327574f, -0.04145379f, -0.04296590f, 0.02737157f, 0.03628001f, 
    -0.03730747f, 0.02472631f, -0.00605968f, 0.02419656f, 0.03119622f, 0.02879633f, -0.05602490f, 0.00357856f, 
    0.00725859f, 0.02471795f, 0.01552856f, 0.03135174f, 0.04331024f, -0.01251009f, -0.01044662f, -0.02724576f, 
    0.01452906f, -0.00737121f, 0.01032594f, 0.04138277f, -0.00021283f, 0.00450813f, 0.02555201f, -0.00781382f, 
    0.00281123f, -0.01653886f, 0.02954901f, -0.00743594f, -0.04465080f, -0.02721782f, -0.03424534f, 0.02349995f, 
    -0.04122213f, -0.03783280f, 0.00417059f, -0.03855370f, 0.03704275f, 0.03895234f, -0.04878888f, -0.01284076f, 
    0.01187990f, -0.05601318f, 0.02429808f, -0.03682979f, -0.04522356f, -0.01153446f, -0.02129811f, -0.02386459f, 
    0.00835934f, -0.05449005f, 0.02459983f, -0.01594425f, -0.02751873f, -0.04184649f, -0.01750537f, 0.01833202f, 
    0.03957384f, -0.02357833f, -0.01246718f, 0.03100176f, 0.00265118f, -0.04857288f, 0.02488688f, 0.01441822f, 
    0.02696670f, -0.02049889f, 0.01245631f, 0.00533246f, 0.03841392f, -0.00565826f, -0.04113054f, -0.02315276f, 
    -0.01112328f, 0.01482171f, -0.02550152f, -0.00756663f, -0.05185615f, -0.01941728f, -0.05016079f, 0.02531496f, 
    -0.02112468f, -0.02422708f, 0.01398902f, -0.00390051f, -0.04877461f, 0.02912563f, -0.04151320f, 0.00315303f, 
    -0.04739867f, -0.04369523f, 0.03127578f, -0.04184209f, -0.03149663f, -0.00411812f, -0.04900774f, 0.01357895f, 
    0.19100922f, 0.21205488f, 0.11734923f, -0.02678867f, 0.10658678f, 0.11458906f, 0.04470395f, -0.07644294f, 
    0.22340658f, -0.09179209f, -0.15226112f, -0.11261199f, -0.21022704f, -0.11299539f, 0.10270721f, -0.26878986f, 
    -0.06130041f, -0.05043266f, 0.00682768f, 0.04785397f, -0.09449162f, -0.00817905f, -0.04088696f, 0.00194164f, 
    0.17073143f, -0.07780919f, 0.12192077f, 0.17551495f, 0.24872568f, 0.06567010f, 0.02098490f, 0.00477741f, 
    0.26090351f, 0.00658371f, -0.01845603f, -0.00632124f, 0.25244904f, -0.19760868f, -0.01263477f, -0.11080019f, 
    0.12565941f, 0.06363530f, -0.09700634f, 0.01634026f, 0.07328335f, -0.06785705f, -0.09062564f, -0.14985096f, 
    -0.32927063f, 0.14799152f, -0.17573199f, 0.26747745f, 0.03458937f, 0.01428953f, 0.10156058f, 0.08408890f, 
    0.06223493f, 0.08686938f, 0.02203009f, -0.10191657f, -0.08121261f, -0.23601367f, -0.20417751f, 0.29864994f, 
    -0.07860922f, -0.19914144f, -0.00310683f, 0.12755908f, -0.10985582f, 0.14744958f, 0.08142846f, -0.01298755f, 
    0.11592274f, -0.03919855f, 0.33785599f, 0.23348995f, -0.00111693f, -0.07748198f, -0.02817507f, 0.02046063f, 
    0.09658562f, -0.07766268f, 0.02278690f, 0.13082650f, 0.05190280f, -0.38363478f, 0.08772784f, 0.17496462f, 
    0.05938375f, -0.13054138f, 0.02606774f, 0.09720688f, 0.10992979f, -0.05193948f, 0.08047310f, 0.03002473f, 
    -0.11639343f, -0.14786306f, 0.06117526f, 0.03753658f, -0.04381837f, 0.10988685f, 0.02608371f, 0.04860236f, 
    0.03164557f, 0.01394768f, -0.12124941f, 0.03456791f, -0.18837750f, -0.06435354f, 0.40748695f, 0.12084664f, 
    0.21049276f, 0.05139947f, 0.04740911f, 0.01325408f, 0.09927122f, -0.05748151f, -0.00215745f, 0.13126864f, 
    -0.25978872f, -0.43303189f, -0.13324666f, 0.21230149f, 0.00508343f, -0.01096763f, 0.00502932f, 0.01843882f, 
    0.10595504f, -0.04885722f, -0.00447681f, 0.05240399f, 0.11146154f, -0.45905945f, -0.15845348f, -0.10616048f, 
    -0.05997878f, 0.02067006f, -0.03999722f, 0.08431936f, -0.10418506f, -0.08172055f, -0.11983319f, -0.03958232f, 
    -0.36541107f, -0.34930003f, -0.06138369f, 0.14160961f, 0.07898492f, -0.05526310f, -0.06328569f, 0.12666076f, 
    0.18318711f, -0.05050464f, 0.03840113f, 0.05172489f, -0.07133094f, 0.25193286f, -0.08591010f, -0.17540891f, 
    0.17981018f, 0.06273928f, -0.04884261f, 0.05202147f, 0.05646190f, 0.16508935f, -0.06272674f, 0.29870114f, 
    0.00026022f, -0.27858788f, -0.02669305f, -0.26775831f, 0.09960698f, -0.19668311f, -0.04970864f, -0.00092203f, 
    0.16927145f, 0.10070839f, -0.08980645f, 0.11954139f, 0.22144198f, 0.15961103f, 0.04129758f, -0.27261969f, 
    0.04283568f, 0.06604104f, 0.00343289f, -0.07333200f, 0.01808411f, -0.15753727f, -0.04292379f, 0.14464797f, 
    -0.47604698f, -0.10544055f, -0.23783261f, 0.22415942f, 0.22874065f, 0.05412474f, -0.11124675f, 0.09369016f, 
    0.07669506f, 0.01648264f, 0.06842399f, -0.02050026f, 0.08456738f, -0.10981975f, 0.31624612f, 0.01801793f, 
    -0.00188245f, 0.17929025f, 0.00718646f, 0.10260746f, 0.09122238f, -0.16686504f, 0.05512460f, 0.10206696f, 
    -0.32210794f, 0.09223600f, -0.25983462f, -0.33557722f, -0.01351612f, 0.03143608f, -0.00452669f, 0.07849552f, 
    0.00313516f, 0.01218912f, 0.08267143f, -0.04141895f, -0.44589016f, 0.03438134f, 0.19941947f, -0.05083373f, 
    -0.00871080f, -0.05682404f, -0.03429204f, 0.13543102f, -0.00340021f, -0.12636109f, -0.07985651f, -0.00562572f, 
    -0.13498832f, -0.13735694f, -0.01685342f, 0.06369427f, 0.03576761f, -0.14088842f, -0.09495734f, 0.20458114f, 
    -0.04360530f, 0.10642809f, 0.00954455f, 0.17994882f, -0.02634327f, 0.07640044f, -0.10453084f, -0.08205466f, 
    -0.02419025f, 0.07625430f, 0.05721133f, -0.15992223f, 0.07866821f, -0.13607046f, -0.25758746f, -0.04998380f, 
    0.06416843f, -0.12377591f, -0.23042461f, -0.16800319f, -0.04158498f, -0.07201127f, 0.15337192f, -0.05591896f, 
    0.07286619f, 0.06411549f, 0.06080805f, 0.14492324f, -0.06505190f, -0.05568987f, 0.07120097f, 0.04782342f, 
    -0.09968535f, -0.03671902f, 0.06975179f, 0.01390913f, 0.18176262f, 0.01341268f, -0.01998391f, -0.10204109f, 
    -0.16284275f, -0.25367400f, -0.28827912f, 0.21500970f, 0.09738588f, -0.01220537f, -0.01306044f, -0.01302810f, 
    0.07831314f, -0.06605974f, 0.14774355f, 0.01512585f, -0.48643392f, -0.00754596f, -0.00325056f, 0.10953949f, 
    0.05900172f, -0.09064370f, -0.01977265f, -0.02815473f, -0.03904012f, 0.02318622f, -0.09124891f, 0.04353620f, 
    -0.09337551f, -0.23701337f, -0.14555101f, 0.20612554f, 0.07293531f, 0.01733893f, -0.01722450f, 0.06413843f, 
    0.21055470f, -0.09607286f, -0.11752118f, -0.09477770f, -0.06578250f, 0.28552935f, -0.07708789f, 0.15375304f, 
    0.09781010f, 0.01155205f, 0.00802474f, -0.19255945f, 0.03024963f, -0.07533526f, -0.00206854f, 0.04616704f, 
    -0.20668095f, -0.07115001f, 0.36107036f, 0.04965973f, 0.06662825f, 0.07220885f, 0.04185070f, 0.06654630f, 
    0.17865252f, -0.02055380f, -0.00970516f, 0.15848438f, 0.00759252f, 0.24653378f, 0.20760499f, 0.05955358f, 
    0.18053541f, 0.05034470f, 0.08630626f, -0.04076933f, -0.09418453f, 0.01350868f, 0.09088635f, -0.05326365f, 
    0.11717848f, 0.14409484f, -0.48279047f, 0.00129740f, 0.08284237f, 0.06531915f, -0.07651342f, -0.05890077f, 
    0.15750068f, -0.02180740f, 0.11769078f, -0.00771216f, 0.13693534f, 0.09740462f, 0.31650224f, -0.29668468f, 
    0.08106039f, 0.09889708f, 0.18893029f, 0.08561467f, 0.13385883f, -0.01296593f, -0.07043824f, 0.05682210f, 
    -0.11052746f, -0.12736785f, 0.03549266f, 0.22724712f, 0.05753613f, 0.08566678f, 0.09588437f, 0.10771179f, 
    -0.11108346f, 0.08604120f, 0.10274200f, 0.11006724f, 0.13027836f, 0.14843422f, -0.05370552f, 0.20957229f, 
    0.04134245f, -0.09049804f, -0.13696881f, 0.01590469f, -0.09731314f, -0.11949670f, 0.04479457f, 0.01210945f, 
    -0.12477510f, -0.03063736f, -0.11760043f, 0.20062360f, -0.14158149f, 0.03081941f, 0.05867701f, -0.04083237f, 
    -0.01952184f, 0.11730250f, -0.08307996f, -0.22039805f, 0.03997039f, 0.20041108f, 0.00370388f, -0.27333817f, 
    -0.11137544f, -0.05448060f, -0.11284331f, -0.06542065f, 0.13522977f, 0.07502525f, 0.10989429f, 0.07722382f, 
    0.17905810f, 0.19482289f, -0.21190608f, 0.05180993f, -0.01462339f, 0.08384527f, -0.10470288f, 0.01038632f, 
    0.06238669f, 0.01285648f, 0.29200923f, 0.23870768f, 0.42370868f, 0.06474070f, -0.11479352f, -0.30153322f, 
    -0.01058582f, 0.08287187f, -0.01738486f, -0.08096435f, -0.05294064f, -0.11483177f, -0.04028508f, 0.02528038f, 
    -0.02319225f, -0.34023491f, -0.12163785f, -0.15291935f, -0.00716336f, -0.11106332f, 0.00145236f, -0.05723071f, 
    0.10979879f, -0.03339352f, 0.00916070f, -0.01645720f, 0.19473577f, -0.12919906f, -0.05687441f, -0.20740943f, 
    0.14403506f, 0.05858061f, 0.01633449f, 0.03814889f, 0.03467724f, -0.00858280f, 0.19960167f, 0.04670707f, 
    0.07702281f, 0.05138297f, -0.07885977f, -0.04152887f, 0.08840284f, -0.17695782f, -0.02474410f, -0.00167139f, 
    0.08245125f, 0.06873667f, 0.06895202f, -0.03846907f, -0.16129832f, -0.27459347f, -0.15271594f, 0.19200182f, 
    -0.02411485f, -0.04259956f, 0.12591952f, 0.00237467f, -0.05292290f, 0.04797319f, -0.08778954f, 0.00122561f, 
    0.18173571f, 0.07573122f, 0.00523785f, -0.10779633f, 0.00373664f, 0.03035961f, -0.10719776f, -0.14412262f, 
    0.01063364f, -0.05592303f, 0.01234225f, -0.13406780f, 0.25079316f, 0.38660464f, 0.11176572f, -0.00169611f, 
    -0.06504683f, -0.08726727f, -0.00331297f, -0.10843720f, 0.07956316f, 0.01011410f, -0.01709090f, 0.04069846f, 
    0.08203702f, 0.22006242f, 0.14448404f, -0.04004007f, -0.03791110f, -0.04605527f, -0.05835090f, 0.01040251f, 
    0.11311604f, -0.01530739f, 0.07588203f, 0.06724413f, -0.34832159f, 0.14449853f, 0.18439800f, 0.23702316f, 
    -0.01503127f, 0.04251517f, 0.31918046f, -0.00528630f, 0.06254940f, 0.17460328f, -0.22502598f, 0.11753891f, 
    0.05648104f, -0.01464914f, 0.07927647f, -0.18006277f, -0.02895281f, 0.14822903f, 0.16171816f, 0.08146223f, 
    0.09966081f, -0.07250025f, 0.15965985f, 0.03553458f, -0.37636864f, 0.01392646f, 0.05529075f, 0.12485709f, 
    0.10241421f, 0.00151305f, -0.12117311f, -0.06271756f, 0.11097559f, 0.19036379f, -0.04988549f, 0.04630424f, 
    0.17395218f, 0.21149941f, 0.02338171f, -0.06118384f, -0.17790517f, 0.01140541f, 0.00028559f, -0.00556027f, 
    -0.02272648f, -0.05321803f, -0.00076299f, -0.07971569f, -0.04062241f, -0.24734388f, 0.01103123f, 0.16550809f, 
    -0.01308177f, 0.10850653f, -0.12656838f, 0.03540209f, -0.13977993f, 0.18617131f, 0.00706290f, -0.12806453f, 
    0.23556258f, 0.36190236f, 0.31552190f, 0.25754455f, -0.03433635f, -0.02249623f, 0.24215527f, -0.04101388f, 
    0.06136317f, -0.08611451f, 0.07482867f, 0.31556386f, 0.00208002f, -0.07209379f, -0.03974906f, 0.11727112f, 
    -0.09997171f, -0.03838860f, -0.03557905f, -0.03599382f, -0.03363599f, 0.03527951f, -0.00160442f, 0.00006651f, 
    0.39446256f, -0.12499342f, -0.03010449f, -0.07936415f, 0.02297016f, -0.03490606f, -0.03259197f, -0.12221394f, 
    0.06777068f, -0.03294798f, 0.05257897f, -0.13572372f, -0.08802922f, 0.04661091f, 0.22752957f, 0.12197134f, 
    0.19857100f, -0.03319863f, -0.01751277f, 0.30610916f, -0.02695003f, 0.03759006f, 0.20071205f, 0.06614668f, 
    0.00380155f, 0.12612686f, -0.08106115f, -0.10329700f, -0.06893954f, 0.11161762f, -0.06667168f, -0.10607664f, 
    -0.14712776f, 0.09187911f, -0.02008533f, -0.12333542f, 0.17990613f, 0.08243732f, -0.01158521f, -0.00748430f, 
    0.11001298f, 0.07570928f, 0.05092345f, 0.08363251f, 0.00798966f, -0.11214008f, 0.10271681f, 0.09632158f, 
    -0.02096601f, 0.08170722f, -0.05527592f, -0.16516978f, -0.04167129f, 0.05546983f, 0.04042682f, -0.07952079f, 
    0.16986905f, 0.01499702f, 0.08388382f, -0.03515505f, 0.05430242f, -0.16170228f, -0.22108819f, 0.15884747f, 
    -0.04303987f, -0.04863064f, -0.21540105f, 0.11499644f, -0.11536984f, -0.05791644f, -0.04691949f, 0.06195201f, 
    0.21790668f, 0.21772601f, -0.03850058f, 0.11464582f, -0.09398089f, 0.17725530f, -0.03236321f, 0.04606139f, 
    -0.18099129f, -0.03299353f, 0.17935225f, 0.10368356f, -0.10456842f, -0.17325570f, 0.05055575f, -0.00451989f, 
    0.05174157f, 0.05678990f, 0.17001262f, 0.24868399f, -0.02255818f, -0.12811668f, -0.00893838f, 0.04943277f, 
    -0.25653842f, -0.15603565f, -0.15637891f, 0.13488744f, -0.01853846f, -0.06017695f, -0.12920243f, -0.01870717f, 
    -0.01370353f, 0.04452850f, 0.00618524f, 0.03019719f, -0.15421343f, -0.19259094f, 0.09765916f, 0.20491467f, 
    -0.06439503f, 0.08427862f, -0.01982692f, -0.03993512f, 0.00551468f, 0.02342622f, -0.00208535f, 0.02982894f, 
    -0.09356532f, 0.21736668f, 0.22701508f, 0.01813795f, -0.14623339f, -0.08194000f, 0.16554098f, -0.06124699f, 
    0.03238907f, -0.00158364f, 0.00591674f, 0.00214679f, 0.07371782f, 0.22407593f, 0.34097022f, 0.09666708f, 
    0.01034691f, -0.03042801f, -0.05835670f, -0.02568447f, 0.00856712f, 0.03412203f, -0.06866769f, 0.06207682f, 
    -0.00063660f, 0.01813557f, -0.02412446f, 0.04169346f, -0.04251738f, 0.03758202f, -0.00905079f, -0.03429467f, 
    -0.04801822f, -0.01540841f, 0.01776808f, 0.00790969f, 0.02278228f, -0.01477900f, -0.01774227f, -0.01096953f, 
    0.00426121f, -0.03671155f, -0.01517254f, -0.01949999f, 0.00444040f, -0.01442702f, -0.03659453f, -0.02378188f, 
    -0.05003311f, -0.01076390f, -0.02584701f, -0.04130222f, -0.03487967f, -0.00240347f, -0.00571578f, -0.00324850f, 
    0.03079546f, 0.01693726f, -0.00997300f, 0.01432712f, -0.04264532f, 0.03763850f, -0.03765348f, -0.05542100f, 
    0.01821345f, -0.03658345f, 0.03538271f, -0.00511427f, -0.01423551f, -0.04992248f, -0.03266583f, 0.03111188f, 
    -0.05136467f, -0.05302960f, 0.02248297f, -0.00502273f, 0.04300505f, 0.00217497f, 0.01006648f, -0.03909460f, 
    -0.03010964f, -0.01801609f, 0.03077810f, 0.00498108f, 0.00021101f, -0.03008825f, 0.02055851f, 0.00256337f, 
    0.02289003f, 0.02408513f, 0.00986814f, -0.03294377f, -0.02997522f, -0.04162618f, -0.01282511f, 0.02919295f, 
    0.01664662f, -0.04452667f, 0.01831122f, 0.00405474f, -0.01869178f, 0.01173188f, -0.04299891f, -0.00322860f, 
    -0.03852889f, -0.01151686f, -0.04684408f, -0.02131186f, 0.01864050f, -0.02629511f, 0.03389217f, 0.00001606f, 
    0.03938651f, -0.00732104f, -0.04492498f, -0.04436051f, 0.02312868f, 0.01398841f, 0.02688436f, 0.01149914f, 
    0.03853451f, 0.01015565f, 0.02272384f, 0.03079799f, -0.03378287f, -0.00987350f, 0.02799008f, -0.00874451f, 
    -0.05476695f, 0.00530257f, -0.01047016f, -0.00364828f, -0.02055286f, -0.02131535f, -0.04010272f, -0.02027092f, 
    -0.03608287f, 0.00000196f, -0.04057385f, -0.02653376f, -0.03818675f, -0.04368026f, -0.00376969f, -0.00733543f, 
    -0.02729221f, 0.03277936f, -0.02477211f, -0.03532266f, 0.01034488f, -0.05498262f, -0.04537694f, 0.02709777f, 
    0.03496715f, -0.03209233f, -0.01642353f, -0.01549244f, 0.03797650f, 0.02441137f, 0.03966461f, 0.01159926f, 
    0.04064431f, 0.00706220f, 0.00667225f, -0.05771600f, 0.00529722f, -0.05531584f, -0.03063348f, 0.03795481f, 
    0.02058596f, 0.02496061f, 0.02273181f, -0.03817226f, -0.05533765f, 0.03878392f, -0.03406734f, -0.03527049f, 
    -0.02788372f, 0.00133617f, 0.04705707f, -0.00430515f, 0.03794896f, -0.02468819f, 0.04272238f, -0.03666040f, 
    0.00737075f, -0.02391842f, -0.02983256f, -0.00411933f, -0.04389036f, 0.00713477f, 0.02099447f, -0.00838598f, 
    0.03007366f, 0.01621300f, 0.00411570f, -0.02673600f, -0.02983494f, -0.03813349f, -0.03071531f, 0.02756544f, 
    0.03842037f, 0.00714667f, 0.00779231f, 0.03771659f, -0.04982397f, 0.01582954f, -0.00385802f, -0.05685205f, 
    -0.05325247f, -0.06144014f, -0.00817723f, 0.00533338f, 0.00753600f, 0.04123373f, 0.00283621f, -0.01133987f, 
    -0.03081469f, -0.04818319f, 0.02153675f, -0.05545938f, -0.05619076f, -0.00843814f, -0.00257113f, -0.03888974f, 
    -0.04565004f, 0.00802649f, -0.00216822f, -0.03581177f, 0.02302455f, -0.00906898f, 0.04031750f, -0.02908779f, 
    -0.02879331f, -0.02389489f, 0.02820642f, 0.03678767f, 0.02521588f, 0.03208213f, -0.04210985f, -0.00513812f, 
    0.01804322f, 0.04099317f, 0.03149786f, 0.00375764f, -0.01155100f, 0.03072265f, 0.04245942f, -0.04569655f, 
    -0.02850933f, 0.02387845f, -0.04561292f, -0.04350549f, 0.03834025f, -0.01797746f, 0.01525804f, -0.03107459f, 
    -0.01413038f, 0.03454771f, -0.01817039f, 0.01044577f, 0.02905220f, 0.02638818f, 0.00299034f, 0.00318941f, 
    0.01073342f, 0.02470680f, -0.03409776f, -0.00961957f, -0.02759779f, 0.00125880f, 0.02665816f, -0.02259356f, 
    -0.02416473f, -0.05486039f, 0.00318730f, -0.01944945f, 0.03407115f, -0.03050869f, -0.03776287f, -0.02832692f, 
    -0.02593982f, 0.00827538f, -0.00985902f, 0.03281629f, 0.01421189f, -0.04930918f, 0.03974316f, -0.01337630f, 
    0.02914337f, -0.02941915f, -0.04952808f, -0.01953803f, -0.05303570f, -0.04391183f, -0.04625161f, 0.01093479f, 
    0.00677848f, -0.01037298f, 0.03586407f, -0.04782718f, -0.01958252f, 0.00188470f, -0.03475257f, 0.00857566f, 
    0.02377844f, -0.01707511f, -0.01873831f, -0.04080628f, -0.01232332f, 0.01678751f, -0.03806452f, 0.02574815f, 
    -0.01911735f, -0.03516049f, -0.01145962f, -0.03844639f, 0.02941461f, 0.03545772f, 0.02915556f, -0.01577887f, 
    -0.00902903f, -0.02360971f, 0.04544823f, -0.02660330f, 0.02245113f, -0.02370604f, 0.00593957f, -0.05846388f, 
    0.02390603f, -0.05320346f, -0.02306484f, 0.03476503f, -0.03537854f, -0.03268638f, 0.04053119f, -0.01561395f, 
    -0.05572253f, -0.03532251f, 0.03807951f, 0.03691355f, -0.04466899f, 0.00554116f, 0.03598692f, -0.03916607f, 
    0.00311070f, -0.01305722f, -0.02956071f, 0.03695343f, -0.02776236f, 0.01663359f, 0.01042301f, 0.00871379f, 
    -0.03875063f, 0.00100291f, 0.00848111f, -0.04388630f, 0.01050868f, 0.01800477f, 0.03383712f, -0.05457506f, 
    -0.05733654f, -0.03075092f, -0.04929329f, 0.04756556f, -0.03510361f, -0.00435845f, 0.02876912f, 0.03478255f, 
    0.01129086f, -0.02213410f, -0.05483899f, -0.01318700f, 0.03746958f, 0.03063742f, -0.01837528f, -0.01578219f, 
    -0.05098996f, -0.03526203f, 0.00840851f, 0.00193916f, -0.00362349f, 0.02789558f, -0.01657753f, -0.00678312f, 
    0.03408807f, 0.02668132f, -0.01445625f, -0.05423999f, -0.00810936f, 0.03600238f, 0.00523384f, -0.01613682f, 
    -0.03350707f, 0.01411903f, -0.01266044f, 0.01640429f, -0.03604350f, -0.02650084f, 0.05485759f, 0.03172744f, 
    0.01138988f, 0.01507040f, 0.04175882f, -0.05413735f, -0.03163989f, 0.04169070f, 0.03017631f, -0.03259240f, 
    0.03707839f, -0.03872390f, -0.04209517f, -0.03701299f, -0.02509916f, -0.01410274f, 0.00525684f, -0.05239378f, 
    0.00259784f, 0.00801500f, 0.02656965f, -0.00507533f, -0.05162259f, -0.01501359f, -0.01222517f, -0.00916932f, 
    -0.05130649f, -0.02090389f, 0.00429606f, -0.00477448f, -0.05210537f, -0.01738277f, -0.03153639f, -0.05055416f, 
    -0.06266947f, 0.02000981f, -0.05428467f, -0.02105398f, -0.01319588f, 0.00974564f, 0.01762630f, 0.03967378f, 
    0.03073799f, -0.04900741f, -0.03900731f, -0.02319476f, -0.03800312f, -0.02924410f, 0.00333459f, -0.02443174f, 
    0.01385745f, -0.02165757f, 0.01807238f, 0.00344547f, -0.06088765f, 0.02427274f, -0.03134790f, -0.02955246f, 
    0.02898399f, 0.01102905f, 0.01726304f, 0.00406227f, 0.01778031f, 0.03637386f, 0.00933510f, 0.00186596f, 
    -0.05638513f, 0.03430363f, 0.00043075f, -0.02666684f, -0.01901606f, -0.00300096f, -0.04065181f, -0.02474027f, 
    0.02848961f, 0.03795421f, -0.02622918f, -0.02175992f, 0.03221894f, -0.02889298f, -0.05912573f, 0.01670909f, 
    -0.05000350f, -0.05082191f, -0.00057649f, 0.04615456f, -0.02890149f, -0.04575359f, 0.02243967f, 0.03546848f, 
    -0.00841920f, 0.00697213f, -0.00620515f, -0.06052539f, 0.01639021f, -0.00606404f, -0.01207454f, -0.04848370f, 
    -0.06063065f, -0.03680917f, -0.01703128f, 0.00281603f, 0.03782769f, 0.01241309f, -0.01280908f, -0.03296167f, 
    -0.03616307f, 0.02445193f, -0.04559033f, 0.02536423f, -0.02198777f, -0.01386177f, 0.01706928f, 0.03883746f, 
    -0.01834431f, 0.00271854f, -0.03899243f, -0.00616296f, -0.01307927f, 0.02370473f, 0.00604854f, 0.01889699f, 
    0.01178047f, 0.03481049f, 0.03055379f, 0.04512137f, -0.01211547f, 0.02144578f, -0.00935881f, 0.00268804f, 
    -0.04877088f, 0.00389358f, 0.00144322f, 0.03321843f, 0.02436434f, -0.02083478f, 0.03027768f, -0.02069238f, 
    0.00885097f, -0.03939029f, 0.03488372f, 0.03518246f, -0.04212667f, 0.01212698f, 0.03865351f, -0.02177518f, 
    -0.03420611f, 0.01300200f, 0.01991170f, 0.02997373f, -0.01910217f, 0.02659865f, -0.01001133f, 0.03017507f, 
    0.03378453f, -0.03914909f, -0.02115830f, 0.03010187f, 0.03230011f, -0.05236629f, 0.02659283f, 0.00096768f, 
    -0.04765603f, -0.01017108f, -0.05347715f, 0.02078060f, -0.06347405f, -0.00476640f, -0.05915908f, 0.03711134f, 
    -0.04843859f, -0.05649990f, 0.02788557f, -0.02405785f, -0.00014907f, -0.04033646f, -0.04143107f, -0.04258574f, 
    -0.04461484f, -0.03860187f, -0.01579843f, 0.03828293f, -0.04899378f, -0.02719761f, -0.03115487f, -0.05256445f, 
    -0.03877956f, -0.00834940f, -0.00596731f, 0.00042270f, -0.06267710f, 0.03044443f, -0.03674665f, -0.01367394f, 
    -0.02316082f, 0.01923815f, -0.02814545f, 0.00881256f, -0.04866799f, -0.03307883f, -0.01897606f, -0.00631973f, 
    0.03422487f, 0.02190078f, 0.01168950f, -0.00831497f, -0.01870283f, -0.00242492f, 0.03469501f, 0.01655953f, 
    -0.04127497f, -0.04990516f, -0.02449929f, -0.00327278f, -0.01438906f, -0.05734460f, 0.01622243f, 0.00589971f, 
    0.02061271f, -0.00439485f, -0.04242200f, -0.00511603f, -0.01377211f, -0.03888772f, -0.05941354f, -0.02336786f, 
    0.00442522f, 0.02360476f, 0.03115287f, -0.02035960f, -0.06107374f, -0.01911459f, 0.01861772f, -0.01447217f, 
    -0.01567356f, -0.03919116f, -0.02655214f, 0.02641518f, -0.02444957f, 0.03535658f, 0.02440798f, 0.01252797f, 
    0.02451473f, -0.05047878f, -0.04815685f, 0.00177226f, 0.01242984f, 0.02301908f, 0.04227027f, -0.04173540f, 
    0.02849101f, 0.03660062f, -0.05294609f, 0.01403826f, -0.04674755f, -0.02052925f, -0.03595458f, 0.02503231f, 
    -0.03486520f, -0.00963628f, -0.04676526f, -0.05589138f, -0.02354390f, 0.00203485f, -0.01745007f, -0.04703071f, 
    -0.05423307f, -0.01192188f, -0.04722623f, -0.02863429f, 0.00764905f, -0.03867144f, -0.01082637f, 0.03484709f, 
    -0.01621829f, -0.00776508f, 0.01810534f, -0.03258375f, -0.02404529f, -0.00330543f, 0.00671542f, 0.00366221f, 
    -0.03710358f, -0.02786004f, -0.04045535f, -0.00880985f, -0.05308794f, 0.01084842f, -0.05594425f, 0.01663421f, 
    -0.04199623f, -0.04803398f, -0.00202065f, 0.01660184f, -0.02417720f, -0.05768275f, 0.03481892f, -0.02388161f, 
    -0.00348599f, 0.03540279f, -0.02882709f, 0.01741820f, -0.00083485f, 0.01051617f, -0.01071017f, -0.05421547f, 
    -0.02317984f, -0.01777395f, -0.00751064f, 0.02961251f, 0.01581573f, -0.00702501f, -0.01053711f, 0.03101170f, 
    -0.05914596f, 0.01446886f, -0.01706333f, -0.00610008f, -0.01267625f, 0.00819714f, 0.04278953f, 0.03294214f, 
    0.01323283f, -0.03968831f, -0.04698289f, 0.01920373f, -0.01355275f, 0.00690667f, 0.02851449f, -0.01894820f, 
    -0.03240065f, -0.00055851f, -0.03986819f, -0.03769076f, -0.05832839f, -0.05629175f, -0.03454338f, -0.03704004f, 
    0.02101736f, -0.03243139f, -0.04595760f, 0.00564563f, -0.04328473f, -0.00984293f, 0.01279060f, 0.03527035f, 
    0.04877549f, -0.02599190f, -0.02833414f, 0.03249567f, -0.05574326f, 0.03238049f, 0.01571786f, 0.03065206f, 
    0.03030443f, 0.00257418f, 0.00379022f, 0.03299811f, 0.04237627f, -0.00003580f, -0.01316790f, -0.02378527f, 
    0.00222186f, -0.03990921f, -0.02387071f, 0.00275598f, -0.04202041f, -0.02214582f, 0.02175504f, 0.01491167f, 
    0.02937318f, 0.00527869f, -0.02422681f, -0.00305757f, -0.01186165f, -0.03824391f, 0.03878169f, -0.04718564f, 
    -0.04124538f, -0.03931729f, -0.05108196f, 0.03982010f, 0.00614072f, 0.03472656f, -0.05517962f, -0.02925181f, 
    0.03769634f, 0.02819864f, -0.04768060f, -0.05147113f, -0.03711546f, -0.03207544f, -0.05858108f, 0.03247640f, 
    0.11183841f, 0.19883938f, -0.02473876f, 0.00536334f, -0.15080161f, 0.03003260f, 0.08143838f, -0.01080004f, 
    0.11087848f, -0.10568979f, -0.04170458f, 0.05655560f, -0.01370589f, -0.18776180f, 0.01134812f, 0.03383850f, 
    0.06883665f, 0.12342450f, 0.02287215f, 0.01179696f, -0.00330307f, 0.05015634f, -0.02502592f, 0.24169698f, 
    -0.01469469f, 0.09343641f, 0.10918909f, -0.19777970f, -0.05591918f, -0.04637867f, -0.12339664f, 0.08478467f, 
    -0.07651784f, -0.05449438f, 0.12709905f, 0.33101130f, -0.22705424f, -0.26927850f, -0.07558118f, 0.19756640f, 
    0.04028788f, -0.00016112f, 0.06883994f, 0.02947073f, -0.04877152f, 0.06702433f, 0.06486993f, 0.06368730f, 
    -0.33090144f, -0.21448670f, 0.26541439f, -0.10525230f, -0.01913285f, -0.06244722f, 0.12312368f, 0.04936955f, 
    0.02409455f, -0.08165412f, -0.29508558f, -0.00160265f, -0.19740401f, -0.15799588f, -0.01633458f, 0.21327433f, 
    0.10873039f, 0.09032618f, 0.00310623f, 0.05597395f, -0.04973328f, 0.02759117f, -0.05898672f, 0.07779184f, 
    0.29184774f, 0.12739569f, 0.03495118f, 0.17111319f, 0.07083033f, 0.18042715f, 0.00254358f, 0.01841929f, 
    -0.05905275f, 0.04784126f, -0.13202658f, 0.01509804f, -0.14177352f, -0.03337898f, 0.05051978f, 0.09747281f, 
    -0.07363120f, 0.09212688f, -0.00936647f, 0.07111469f, -0.11329209f, 0.06208594f, -0.19543463f, -0.12648380f, 
    -0.03980017f, 0.02021639f, 0.11029152f, 0.05240619f, -0.18550958f, 0.04299951f, 0.07717799f, 0.00025814f, 
    0.04752319f, 0.08712978f, 0.03117814f, 0.01466177f, 0.21859720f, 0.23338845f, -0.00818637f, 0.03772668f, 
    -0.03410110f, 0.08878979f, -0.11093147f, 0.05852377f, -0.06720739f, -0.02386942f, 0.02315301f, -0.03433099f, 
    -0.23456642f, -0.04399052f, 0.05218202f, -0.03278233f, 0.03509805f, 0.09790271f, 0.09640048f, 0.05936367f, 
    -0.06738233f, 0.18698254f, 0.12787758f, 0.13218202f, 0.03470146f, -0.27351651f, -0.13300948f, -0.21700349f, 
    -0.00242550f, -0.00463245f, -0.01522229f, 0.13936874f, 0.06491716f, 0.09458996f, 0.05069139f, 0.08308690f, 
    -0.08524368f, -0.32365209f, -0.10354035f, -0.01365985f, 0.01441413f, 0.04169094f, 0.04945567f, 0.03535578f, 
    -0.01781505f, 0.06512133f, 0.03665972f, 0.03449308f, 0.12064859f, -0.23718655f, -0.07396775f, -0.36663085f, 
    -0.07344408f, -0.04146434f, -0.20136361f, -0.04703823f, -0.05687533f, -0.11278233f, 0.06120566f, -0.14452520f, 
    0.03714928f, 0.10260783f, -0.04214794f, 0.12215931f, -0.00562365f, -0.05524289f, 0.03138173f, -0.02910984f, 
    -0.15343253f, 0.06603541f, -0.01202497f, -0.01521641f, 0.05319397f, -0.13579257f, 0.12603295f, -0.08049249f, 
    -0.02372068f, 0.12174720f, 0.05168526f, 0.02960479f, -0.00006717f, 0.02097723f, 0.04024393f, -0.14607149f, 
    -0.07144676f, -0.16459565f, 0.07610185f, -0.04849169f, -0.17362705f, -0.06979298f, -0.05225791f, -0.02042364f, 
    0.05541858f, 0.08951490f, 0.04875706f, 0.05791619f, 0.05344972f, 0.37538427f, -0.16315876f, 0.04566044f, 
    -0.06793276f, -0.06574692f, 0.20757279f, -0.06567543f, 0.15808655f, -0.10054182f, -0.07714328f, 0.10550554f, 
    0.10947255f, -0.21674395f, -0.11010788f, -0.07529036f, 0.16862915f, -0.02803717f, -0.11575001f, 0.11238757f, 
    -0.05109172f, 0.11411501f, -0.15438710f, -0.14193878f, 0.16409925f, 0.04288256f, 0.06749228f, 0.00042519f, 
    0.05761063f, 0.13313419f, 0.11616927f, 0.11092553f, -0.00486290f, 0.08436855f, -0.05560339f, -0.01109616f, 
    -0.59884238f, -0.14618066f, 0.03531718f, 0.04070744f, -0.06747425f, 0.08429228f, 0.08446100f, 0.02024294f, 
    0.00639495f, 0.07906510f, 0.09662767f, 0.17115235f, 0.11633665f, 0.20336840f, 0.11415246f, 0.20558490f, 
    -0.01692567f, 0.10883125f, 0.07342651f, 0.00072845f, 0.07981700f, -0.02272796f, -0.00394245f, -0.06052905f, 
    -0.13145779f, -0.13068987f, 0.11641652f, -0.09810358f, 0.04579871f, 0.04878873f, -0.00312123f, 0.26589817f, 
    0.09996831f, -0.02006385f, -0.05027179f, 0.02340665f, -0.01643626f, 0.03968702f, 0.03398100f, 0.02635206f, 
    0.11845031f, 0.11605478f, 0.05799156f, 0.02039123f, -0.04185542f, -0.02132165f, -0.10487520f, -0.13293855f, 
    -0.18366994f, -0.26871395f, 0.13108440f, 0.01436748f, -0.00790179f, -0.02721453f, 0.00140967f, 0.05362662f, 
    -0.01157678f, -0.00145334f, -0.06613042f, 0.11302815f, 0.18407823f, 0.18333578f, 0.24145706f, -0.14344609f, 
    -0.10884430f, 0.01917175f, 0.08577180f, -0.01369842f, 0.08587418f, 0.10698169f, 0.02102392f, 0.07095148f, 
    0.11512308f, 0.08020157f, 0.16329965f, -0.05078383f, 0.03252299f, -0.05232314f, 0.13651620f, -0.05726634f, 
    0.08044577f, 0.03606644f, 0.01865458f, -0.06090516f, 0.26169491f, 0.18593368f, -0.03468122f, 0.10199676f, 
    -0.17242953f, -0.00250849f, -0.10006715f, -0.08653200f, 0.06371386f, -0.00816643f, 0.08198653f, -0.11203481f, 
    0.21451814f, 0.25232789f, 0.14295205f, -0.06444623f, 0.04634284f, 0.03218795f, 0.01804087f, -0.12702698f, 
    0.03597070f, 0.02143914f, 0.02806981f, -0.10747360f, 0.24796589f, 0.23741157f, -0.00656611f, -0.08708402f, 
    -0.13170160f, -0.09843691f, 0.14433661f, 0.26902354f, 0.05020950f, 0.06822199f, 0.04164054f, 0.01438839f, 
    0.40588179f, -0.03806917f, -0.14221366f, 0.02436578f, -0.04417462f, -0.04835001f, -0.03383509f, -0.03431386f, 
    0.04994760f, 0.12713954f, 0.01335403f, 0.00072943f, 0.03844190f, -0.17168994f, -0.06327265f, -0.01833922f, 
    -0.15633103f, -0.06240726f, 0.00286965f, 0.13595451f, -0.00326376f, 0.03689947f, 0.08312680f, 0.01730143f, 
    -0.20430471f, -0.22331481f, 0.06969998f, 0.04863363f, 0.04345117f, 0.02867834f, 0.08740237f, 0.13504028f, 
    -0.16705790f, -0.10760430f, -0.04288314f, 0.00197753f, 0.19668631f, 0.18453290f, -0.08037201f, -0.00356722f, 
    0.02144406f, 0.03715244f, 0.08757684f, 0.07879318f, 0.12237708f, 0.09466867f, 0.17863442f, -0.15023804f, 
    -0.13031395f, -0.00898017f, -0.07298424f, 0.06644751f, 0.10603388f, 0.15639237f, 0.18908450f, 0.13680437f, 
    -0.05882083f, 0.04892354f, -0.00277752f, -0.08372134f, 0.15737005f, 0.44745398f, 0.13580553f, 0.12364267f, 
    -0.05498637f, 0.02679412f, -0.05529963f, 0.02291216f, -0.11331564f, -0.01767896f, 0.16022582f, -0.04982650f, 
    0.29658508f, 0.01337882f, 0.13300331f, -0.08882284f, -0.06801503f, 0.02127065f, 0.07113408f, 0.09785016f, 
    0.16092846f, 0.07985373f, 0.04804787f, 0.03597022f, -0.06027177f, 0.03574575f, 0.16847071f, -0.08342306f, 
    0.08917715f, -0.11163797f, -0.00459184f, -0.11205441f, 0.12574962f, -0.15130058f, 0.09331892f, 0.04853770f, 
    -0.38456860f, -0.13308094f, -0.23479484f, -0.14942075f, 0.03001985f, -0.01387252f, 0.00326492f, -0.00787602f, 
    -0.09288382f, 0.01266422f, -0.00444546f, -0.02402556f, 0.01721539f, 0.21509573f, 0.11654738f, 0.04683515f, 
    -0.02695230f, -0.03721349f, 0.02832733f, 0.01197572f, 0.11254152f, 0.16267665f, -0.01113392f, 0.29122892f, 
    0.00730213f, 0.04474553f, -0.12691931f, -0.11197607f, 0.23379733f, -0.00284030f, -0.05608189f, -0.08730025f, 
    -0.03631430f, 0.04014542f, -0.02980410f, 0.01343219f, -0.10994522f, -0.09085906f, -0.13502580f, -0.01873262f, 
    0.08078894f, 0.06932335f, 0.15170470f, 0.14386357f, 0.10150946f, 0.08870978f, 0.09725627f, 0.02805124f, 
    -0.04437244f, 0.02802773f, -0.10111199f, -0.11029714f, -0.06805916f, -0.02096665f, -0.07266487f, -0.06800800f, 
    -0.08064923f, -0.20563550f, -0.06553423f, -0.19040351f, 0.03973730f, 0.58720070f, 0.23176569f, 0.27285516f, 
    -0.08956664f, -0.05232022f, -0.00918386f, -0.15830787f, -0.07218909f, -0.03767120f, -0.04450494f, -0.06228823f, 
    0.13191263f, 0.16118662f, 0.02863809f, 0.03817355f, -0.12402614f, -0.14124301f, -0.00342304f, -0.07544654f, 
    -0.03158971f, 0.05695760f, 0.05405701f, 0.08151795f, 0.26599884f, -0.04535162f, 0.12443088f, 0.21092062f, 
    0.16278854f, 0.01870328f, 0.20515895f, 0.18090019f, 0.10969688f, -0.05914539f, 0.12028912f, -0.07381552f, 
    -0.16273512f, 0.04547247f, -0.14920220f, -0.04119252f, -0.12422118f, 0.19086805f, 0.04303899f, -0.03007511f, 
    0.04267981f, 0.02965700f, -0.01571106f, -0.11626190f, -0.01141975f, 0.03847167f, -0.02209957f, 0.16959713f, 
    0.07708940f, 0.14691703f, 0.16345721f, -0.09254768f, 0.13869724f, -0.01764091f, 0.02667638f, 0.13554676f, 
    0.27662596f, 0.14109893f, 0.02032839f, -0.10369559f, -0.05134047f, -0.06818504f, 0.11524594f, -0.09402186f, 
    -0.03942078f, -0.08564740f, -0.01897664f, 0.01748767f, -0.09989347f, -0.08451205f, -0.02955666f, 0.06990768f, 
    0.13814057f, 0.06131954f, 0.01118778f, 0.13965452f, -0.02486318f, 0.02918928f, 0.01822120f, 0.00213342f, 
    0.53130192f, 0.19829929f, 0.35491756f, 0.28302282f, -0.01128642f, -0.03919356f, -0.00251641f, 0.05596816f, 
    0.03669456f, 0.00237499f, 0.14549598f, 0.20389906f, 0.22535041f, 0.00644141f, -0.02307781f, 0.00271549f, 
    0.01524154f, -0.07777176f, 0.12198003f, -0.08834457f, 0.02255828f, 0.12648761f, 0.13653742f, 0.04855314f, 
    0.30908749f, 0.30331004f, -0.02705813f, 0.09467685f, -0.15462779f, -0.10170715f, -0.18749203f, -0.06067597f, 
    -0.01932338f, -0.06493486f, -0.02567203f, -0.13687544f, -0.08309364f, -0.13339734f, -0.04271302f, -0.15750813f, 
    0.02246129f, -0.01908129f, -0.09537622f, 0.12378777f, -0.09438079f, 0.09879048f, 0.06970225f, 0.13129267f, 
    0.08531244f, -0.10138337f, -0.02936371f, 0.02739187f, -0.08458123f, -0.01903301f, -0.26521575f, -0.04955840f, 
    -0.06879713f, 0.00436247f, 0.10295226f, -0.13461986f, -0.04261510f, -0.07086779f, -0.02275500f, 0.10712606f, 
    -0.05796494f, -0.03460970f, -0.05090058f, 0.00704726f, 0.15686782f, 0.01401661f, 0.12656726f, 0.16834971f, 
    0.07285462f, 0.09284566f, 0.27934968f, -0.07857694f, -0.00928540f, 0.00730149f, 0.00061363f, -0.08760175f, 
    0.10893532f, 0.05110938f, 0.00817389f, -0.01156012f, 0.20346670f, -0.03911775f, 0.06183392f, 0.07411537f, 
    0.03716420f, 0.07828036f, -0.00762957f, 0.08227425f, -0.04765219f, 0.11621035f, 0.08987321f, -0.10506872f, 
    -0.34070221f, 0.10712706f, 0.11679088f, 0.02121997f, 0.08602767f, -0.02256542f, -0.06849954f, 0.02302136f, 
    -0.17487144f, -0.04969798f, -0.02164415f, 0.12190644f, -0.04073628f, -0.26356208f, 0.22166529f, -0.10112236f, 
    0.07737267f, 0.15066892f, 0.05941257f, 0.18941332f, 0.07022116f, 0.03658681f, -0.01647814f, 0.23567814f, 
    0.01609750f, 0.12527418f, -0.08770043f, 0.09543262f, 0.01202478f, -0.01576293f, 0.09581248f, 0.12894870f, 
    -0.01496531f, 0.00024381f, -0.08846428f, 0.03639781f, -0.15361062f, -0.23642179f, -0.04810403f, 0.09598302f, 
    0.01196328f, 0.15702172f, -0.08424190f, 0.02323920f, -0.03253255f, -0.09276587f, -0.05124424f, 0.11294360f, 
    0.24116351f, -0.09744330f, 0.44411293f, -0.04407929f, -0.05264385f, -0.07671657f, -0.00235434f, 0.03767607f, 
    -0.14403005f, -0.04037401f, -0.04268033f, 0.07643930f, 0.00760372f, 0.33202881f, -0.08400086f, 0.40463609f, 
    -0.02246915f, 0.03617328f, 0.03179944f, -0.00701530f, -0.08525059f, -0.10092212f, 0.05648471f, 0.09173936f, 
    0.01527226f, 0.03341337f, -0.04709321f, -0.38741091f, -0.25270614f, -0.01405332f, 0.04921078f, 0.09261104f, 
    -0.17473049f, 0.10267792f, 0.10388863f, 0.11122350f, 0.09185500f, -0.25196287f, 0.11883108f, 0.01247404f, 
    0.08475383f, 0.01273056f, 0.06577314f, -0.06014148f, 0.13291757f, 0.00093274f, 0.00582667f, 0.02428863f, 
    0.15745701f, 0.18845184f, 0.02363839f, -0.19642782f, 0.10937733f, 0.09534483f, 0.08790533f, 0.12038945f, 
    0.00360393f, 0.00739520f, 0.15909658f, -0.09068756f, -0.03730596f, -0.19594599f, -0.09673715f, 0.13004334f, 
    0.02548385f, -0.08718618f, 0.07150113f, -0.09676628f, -0.16518064f, -0.01592707f, -0.11375698f, 0.10708714f, 
    -0.13889246f, 0.36924076f, -0.00752245f, -0.14386539f, 0.03934133f, -0.08832946f, -0.11608081f, 0.02273614f, 
    0.00353072f, 0.00916731f, 0.09041494f, 0.08693186f, -0.01634444f, 0.45798549f, 0.07458217f, 0.06709386f, 
    -0.04804455f, -0.07132731f, -0.14904226f, -0.08305751f, 0.21983519f, -0.05670588f, 0.04571160f, 0.00238027f, 
    0.01766041f, 0.10998746f, 0.17983429f, -0.15868953f, -0.05345512f, -0.09364018f, -0.10502440f, -0.06537602f, 
    -0.07415918f, -0.00577431f, 0.05744153f, 0.04610844f, 0.06641550f, 0.30170223f, 0.00831087f, -0.03228042f, 
    0.04871404f, -0.00265791f, -0.04106489f, -0.11721317f, 0.03330630f, 0.17017964f, 0.12007146f, 0.09779821f, 
    0.02951695f, 0.01276753f, -0.11831456f, -0.14837442f, 0.03754996f, -0.06109109f, 0.03552872f, 0.29659054f, 
    -0.06270584f, 0.11653356f, 0.05581373f, 0.20979844f, 0.20539291f, 0.24093321f, -0.08676311f, -0.06174564f, 
    0.12920146f, 0.08930170f, 0.09398577f, 0.07001128f, 0.02641812f, 0.19203350f, -0.07872630f, 0.10348270f, 
    -0.03399674f, 0.06964006f, 0.13036734f, 0.10902100f, -0.03698524f, -0.03447624f, -0.18720713f, -0.03086129f, 
    0.09703291f, 0.02259325f, 0.02926023f, 0.03444968f, -0.18706214f, -0.36243927f, -0.21923360f, 0.08965986f, 
    0.11097593f, -0.01677095f, 0.06358108f, -0.06443624f, -0.06403821f, -0.02429039f, -0.01314977f, -0.03982101f, 
    -0.03140230f, 0.04784405f, -0.15907499f, -0.05246595f, -0.00132478f, -0.04592295f, -0.00995479f, -0.06499306f, 
    0.01429511f, 0.10951000f, -0.01792190f, 0.10835192f, -0.04015609f, 0.31099790f, 0.01693031f, -0.02334094f, 
    -0.13543263f, 0.02866362f, 0.40300596f, -0.00571893f, 0.19382182f, 0.02334320f, 0.28650045f, -0.01009466f, 
    0.05129743f, -0.24853583f, -0.05757020f, -0.14039841f, 0.00471053f, 0.13816452f, 0.02213950f, 0.00552105f, 
    0.00568440f, 0.01702810f, 0.12343401f, -0.00332517f, 0.01846205f, 0.07968283f, -0.08664516f, -0.04255480f, 
    0.04136415f, -0.06690169f, 0.09756112f, 0.24409768f, 0.07585902f, 0.16967665f, -0.09362356f, -0.11548001f, 
    0.08809339f, 0.09022422f, -0.11337911f, -0.15213786f, -0.18908486f, 0.18593335f, 0.07676164f, 0.04150201f, 
    0.06232727f, -0.02637419f, -0.05117960f, 0.06506711f, -0.10465219f, 0.30270478f, -0.19227187f, -0.07916927f, 
    -0.08405535f, -0.07091077f, 0.14305098f, 0.12467547f, -0.07491594f, 0.11775284f, -0.05068650f, -0.01828562f, 
    0.09666049f, -0.28894278f, 0.39573509f, -0.13331355f, 0.21654923f, -0.12073505f, 0.07860963f, -0.09436420f, 
    0.09932584f, 0.07605345f, 0.05174049f, 0.14173736f, 0.29464269f, 0.08637951f, -0.23260172f, -0.24186426f, 
    0.04258088f, 0.06357791f, -0.06211070f, -0.09265807f, -0.00181849f, 0.06626940f, 0.02175133f, -0.18281595f, 
    0.03742668f, -0.30451685f, -0.06974762f, 0.05223599f, -0.04392103f, 0.15415943f, 0.02104643f, -0.08492853f, 
    0.07883830f, 0.02476108f, 0.03197299f, -0.10900296f, -0.06438160f, -0.20756680f, -0.05801707f, 0.03759728f, 
    0.01245737f, -0.04620072f, -0.06301650f, 0.05382670f, 0.08308516f, 0.05495542f, 0.16857289f, -0.01129167f, 
    -0.03208330f, 0.10321321f, 0.22239898f, 0.12611212f, 0.00121234f, -0.19230182f, 0.01999460f, -0.07788863f, 
    -0.02433780f, -0.14217299f, -0.08207217f, 0.13569750f, 0.04854199f, -0.03278910f, 0.36048386f, -0.02438595f, 
    -0.20100424f, -0.02573835f, -0.03181373f, 0.05387516f, 0.15786393f, 0.11089300f, 0.13627960f, 0.10318261f, 
    -0.18722098f, 0.26523179f, -0.22399765f, 0.10227527f, 0.03202029f, -0.14263080f, 0.01772090f, 0.04499179f, 
    -0.02175365f, 0.03354369f, -0.01977283f, 0.03094319f, -0.03103681f, 0.05673844f, -0.03398881f, -0.10795950f, 
    -0.06231946f, 0.06209264f, 0.04466902f, 0.08471955f, 0.06122386f, -0.02642234f, -0.10242010f, -0.19508593f, 
    -0.04085342f, 0.13120863f, -0.07190650f, 0.14624320f, -0.16274121f, -0.04301968f, -0.05728901f, 0.14340647f, 
    0.04235205f, 0.14187159f, -0.02791912f, 0.06330450f, 0.09107354f, -0.37575623f, -0.01683263f, -0.03884221f, 
    -0.10977779f, 0.02402043f, 0.09671121f, 0.26315671f, -0.06912178f, 0.06087568f, -0.04395202f, -0.02611658f, 
    0.02146164f, -0.11743333f, -0.12832430f, 0.20476508f, 0.02239830f, 0.06900010f, 0.08157974f, 0.15902092f, 
    -0.03493721f, 0.05662455f, 0.00881540f, 0.03184935f, -0.04103300f, 0.13478036f, -0.17009591f, -0.22779638f, 
    0.07717178f, -0.12795173f, 0.07564832f, 0.17808519f, -0.10923753f, 0.04156458f, 0.00277926f, 0.10261576f, 
    -0.46062717f, 0.04749661f, -0.16889960f, 0.03112789f, 0.09990492f, -0.15383127f, 0.19275303f, 0.02986766f, 
    -0.04431683f, 0.11048396f, -0.03148862f, 0.03160509f, -0.08910447f, -0.49456590f, -0.16229564f, -0.03031694f, 
    0.03987445f, -0.06109906f, 0.04754078f, -0.05643694f, 0.00136449f, 0.11531147f, 0.14943013f, 0.04711374f, 
    0.18405552f, 0.06457841f, 0.10906295f, 0.24931537f, 0.19280304f, 0.14873363f, 0.13012217f, 0.14790982f, 
    0.04394459f, 0.05898042f, -0.02369295f, -0.03720935f, 0.06989928f, 0.14250588f, -0.10198116f, -0.09705596f, 
    -0.07638090f, -0.02600085f, 0.05945184f, 0.14127292f, -0.09828301f, -0.01775169f, -0.02087787f, -0.17750414f, 
    0.06702284f, -0.04244058f, 0.24015281f, 0.10807988f, 0.16326088f, -0.02149055f, 0.02100536f, 0.02042002f, 
    0.05213368f, 0.06854066f, 0.03797431f, 0.06078776f, -0.21315885f, 0.04496787f, 0.00338023f, 0.26844329f, 
    -0.09968302f, 0.02676342f, -0.00577537f, 0.02876280f, 0.02685451f, -0.03006640f, -0.02368796f, -0.10028292f, 
    0.04559543f, -0.46627623f, 0.29426390f, 0.05407925f, -0.05190633f, -0.07822461f, 0.03885760f, 0.12798224f, 
    0.17686899f, 0.10453261f, -0.11519790f, -0.08943483f, -0.13469128f, -0.30086660f, -0.17820895f, -0.12709580f, 
    0.07482280f, -0.02377730f, 0.02414960f, 0.02810514f, 0.04491264f, 0.17987210f, -0.01399717f, 0.05141538f, 
    0.06309595f, -0.24256454f, -0.45717308f, -0.04565313f, 0.05522124f, 0.12710023f, 0.10692656f, 0.11685614f, 
    0.05258387f, 0.04989322f, -0.12683591f, -0.16685511f, -0.23103268f, -0.13365033f, 0.07226437f, -0.04511970f, 
    -0.10196950f, -0.03113949f, -0.01977340f, 0.04712799f, -0.07555334f, 0.12034727f, 0.20050907f, -0.01591283f, 
    -0.18077360f, -0.09033477f, 0.04604937f, 0.05598038f, 0.04856978f, 0.21380286f, -0.09104137f, -0.16263522f, 
    0.00574778f, 0.10814777f, 0.03431650f, 0.00973355f, 0.25313413f, 0.41877997f, 0.22472847f, -0.05422411f, 
    -0.04570667f, 0.03351266f, -0.02441738f, 0.09392221f, 0.13015763f, 0.04474608f, -0.01304091f, -0.05603366f, 
    -0.08812612f, -0.15305094f, -0.13512792f, -0.25649542f, 0.04652742f, 0.05785868f, 0.16582543f, 0.03331275f, 
    -0.08734271f, 0.03024706f, -0.12507196f, 0.06465034f, -0.04162003f, 0.18851876f, 0.14289379f, 0.04990851f, 
    -0.10208186f, 0.06081192f, -0.17281596f, 0.07221727f, 0.03404635f, 0.01344448f, -0.04582740f, -0.04101053f, 
    -0.09704188f, -0.07249290f, 0.01552906f, 0.12534334f, 0.06565299f, -0.03284048f, -0.09896069f, -0.06232459f, 
    -0.01854440f, 0.02060541f, 0.12730099f, 0.11883765f, 0.24411605f, -0.26798576f, -0.07543193f, 0.31282923f, 
    0.27518222f, 0.13305764f, -0.18251790f, -0.11318057f, 0.02300570f, -0.09677855f, 0.03019220f, -0.01582026f, 
    -0.25985649f, 0.17617872f, -0.09639907f, -0.00879718f, 0.07463610f, 0.04493732f, -0.02557812f, 0.17296231f, 
    0.07984626f, 0.04263902f, -0.07707598f, -0.02960896f, 0.18980697f, -0.25987560f, 0.07280704f, 0.10394714f, 
    0.06456017f, 0.06474113f, 0.06048396f, -0.12009734f, 0.04869135f, -0.14333513f, 0.05802076f, 0.05381846f, 
    -0.27153063f, -0.02307894f, 0.22284250f, 0.20363308f, 0.32282880f, -0.08633844f, -0.15941599f, 0.02202684f, 
    -0.12747349f, 0.02927745f, 0.12058076f, 0.01391128f, 0.12942193f, 0.15597220f, 0.20768946f, -0.03989951f, 
    0.03691811f, 0.16339040f, 0.05025268f, 0.05731719f, 0.13206771f, -0.03137137f, 0.07870140f, 0.06596567f, 
    0.25234690f, 0.01351927f, -0.14954285f, 0.27344945f, -0.17319813f, 0.12972088f, -0.07089891f, 0.12627752f, 
    -0.03078196f, 0.09002187f, 0.12110805f, -0.04514708f, 0.25858316f, 0.14435422f, 0.03057030f, -0.05292023f, 
    0.28683153f, -0.00338686f, 0.03906653f, 0.02218606f, 0.00537996f, -0.01369469f, 0.00839024f, -0.07669115f, 
    -0.16966936f, 0.17106690f, 0.08808364f, 0.00950849f, -0.12040714f, -0.16108710f, -0.04994434f, 0.00262085f, 
    -0.03635657f, 0.05598905f, 0.06655569f, 0.09734909f, 0.15813547f, 0.22146142f, 0.26366657f, 0.07700895f, 
    -0.07597647f, 0.12693736f, 0.10842226f, -0.16422768f, -0.05582194f, -0.04216135f, 0.05913256f, 0.04933325f, 
    -0.07626603f, -0.26403990f, -0.20005934f, -0.01415173f, 0.01705241f, 0.02055596f, -0.09028406f, 0.09177076f, 
    0.05231513f, -0.09206218f, 0.07063267f, 0.00085907f, 0.01982939f, 0.02521164f, -0.22652698f, -0.07733926f, 
    -0.06186976f, 0.05542454f, 0.07782332f, 0.05497476f, 0.13406734f, 0.17679837f, 0.14956678f, 0.19054258f, 
    -0.06368085f, -0.23002897f, 0.25754440f, 0.12865174f, 0.00856766f, 0.13933320f, -0.07735684f, -0.05062937f, 
    0.00355881f, -0.01018185f, 0.04223474f, -0.09345231f, 0.22892508f, 0.21638741f, 0.15359010f, -0.17123763f, 
    0.20262593f, 0.00868620f, 0.19612475f, 0.06171683f, -0.03804876f, 0.06958409f, -0.11302960f, -0.06213246f, 
    -0.06794545f, -0.12831062f, 0.17078108f, -0.32735783f, 0.10366172f, -0.05202290f, -0.04475029f, 0.04746544f, 
    -0.04025666f, 0.10443886f, -0.03653196f, 0.00289276f, -0.03934967f, 0.34149089f, 0.14069441f, 0.14897215f, 
    0.08842555f, -0.06566308f, 0.00852828f, 0.02072651f, 0.00307513f, 0.01789109f, 0.08839602f, 0.06027472f, 
    0.25823271f, 0.35647702f, 0.07252242f, -0.22960372f, 0.11328167f, 0.09949160f, 0.13870385f, -0.18041463f, 
    0.08154092f, 0.04852833f, 0.02035929f, 0.07571300f, 0.23534431f, 0.17994496f, 0.07201350f, 0.21927361f, 
    0.09007126f, 0.13170663f, 0.06515741f, 0.16546577f, -0.00263905f, 0.00068608f, 0.06043160f, 0.04477584f, 
    0.02584052f, -0.02733416f, 0.02733178f, 0.47163609f, 0.11405310f, 0.08495048f, -0.13194574f, 0.01929374f, 
    0.06518658f, -0.03412493f, 0.08883091f, 0.03865201f, 0.08204374f, 0.46170437f, -0.14120778f, 0.12438618f, 
    0.04394678f, 0.05022428f, 0.14354409f, 0.09067235f, 0.02623153f, 0.00900866f, -0.01181353f, 0.05209046f, 
    -0.13136086f, -0.26187623f, 0.12543869f, 0.20725816f, 0.17675371f, 0.10454662f, 0.04527327f, 0.23257279f, 
    -0.13844521f, 0.02598326f, 0.04134618f, 0.01253800f, 0.14728701f, 0.12254713f, -0.17057250f, -0.08655536f, 
    0.02417358f, -0.08289274f, -0.18830439f, -0.03178350f, -0.10404015f, -0.19788234f, -0.03059725f, -0.42063215f, 
    0.02315388f, 0.01453792f, 0.01789905f, 0.19988385f, -0.01912025f, 0.09293764f, 0.12621398f, 0.05486121f, 
    -0.01217763f, 0.00300063f, -0.07752278f, -0.37236398f, 0.01842274f, 0.28273100f, -0.04637987f, -0.14071234f, 
    0.01364302f, 0.03018350f, -0.07318455f, -0.05546480f, -0.03422098f, -0.06784944f, 0.07144307f, 0.01015196f, 
    0.14132202f, 0.02527328f, -0.09914054f, -0.03292520f, -0.00095770f, 0.08278175f, -0.00768880f, 0.11853628f, 
    0.13777602f, 0.10743473f, 0.10130146f, -0.06321583f, 0.05677917f, 0.13903554f, -0.00619090f, -0.19626886f, 
    -0.03795716f, -0.00011086f, 0.02737737f, -0.15014428f, 0.11787025f, -0.06287229f, 0.07768141f, 0.00177804f, 
    -0.24939625f, -0.30424863f, -0.32712305f, -0.21072951f, -0.03108492f, 0.04289961f, 0.06477910f, 0.09380373f, 
    0.13577448f, -0.03639321f, -0.09874162f, -0.16446316f, -0.02743399f, 0.06267250f, 0.07092110f, -0.09973098f, 
    -0.03685102f, -0.10179976f, 0.12456817f, 0.05622658f, 0.18247187f, 0.10714664f, 0.18614718f, 0.31777769f, 
    0.11382473f, 0.06140622f, -0.10646862f, -0.04366394f, 0.19773759f, -0.01155389f, -0.07504974f, -0.05002540f, 
    0.04030627f, 0.01870176f, 0.06522918f, 0.06550403f, -0.05967608f, -0.09043289f, -0.03357581f, 0.10436416f, 
    0.04078933f, -0.02583331f, 0.12282080f, 0.12112772f, 0.11926191f, 0.05594743f, -0.08383103f, -0.02663828f, 
    0.11280824f, -0.06161571f, -0.10843626f, -0.19531184f, -0.02659823f, -0.05777489f, -0.10802472f, -0.13828424f, 
    -0.13640587f, -0.19916186f, -0.18539971f, -0.30266434f, 0.01231570f, 0.44956869f, 0.02265560f, 0.10921592f, 
    -0.12921326f, -0.09246308f, -0.07748178f, -0.17276800f, -0.03344218f, -0.01993718f, 0.01091835f, 0.01045177f, 
    0.13307990f, 0.26714283f, 0.16894056f, 0.00912438f, -0.00665831f, -0.05324851f, -0.03633833f, -0.00882034f, 
    0.06002761f, 0.07244379f, 0.05545459f, 0.23438086f, 0.01172877f, 0.12391912f, 0.12948397f, 0.39238054f, 
    0.15990752f, 0.07663502f, 0.18265826f, 0.14542764f, 0.03486827f, 0.04669771f, 0.00347357f, -0.00815221f, 
    -0.14602095f, -0.02447269f, -0.07142083f, -0.10404711f, 0.03883694f, 0.15417631f, 0.08479704f, 0.02820392f, 
    0.05290835f, -0.01060536f, -0.00211758f, -0.09588253f, -0.14218529f, -0.01115523f, -0.10907467f, 0.08279556f, 
    0.11109602f, 0.10020725f, 0.03699876f, -0.12553868f, 0.12547110f, -0.09664419f, -0.16315418f, 0.09780901f, 
    0.07661144f, 0.24248813f, -0.08540174f, -0.05756412f, 0.02112256f, 0.00364874f, -0.06590078f, 0.02717593f, 
    -0.03515773f, -0.08904865f, -0.01653081f, 0.02137822f, 0.02237583f, -0.18474746f, 0.18872952f, 0.22910643f, 
    0.19666687f, 0.14453159f, 0.01370006f, 0.15334338f, -0.07732816f, 0.00196755f, -0.02543112f, -0.19249853f, 
    0.42626664f, 0.31681812f, 0.22735395f, 0.09628151f, -0.07680593f, -0.00714717f, 0.05810149f, -0.02905007f, 
    0.08044603f, -0.13372752f, 0.25335181f, 0.17463259f, 0.13362895f, 0.10537522f, 0.11907709f, 0.14380215f, 
    0.01796093f, -0.08109556f, -0.05183932f, -0.07689992f, 0.05377388f, -0.00179188f, 0.00470675f, -0.04311963f, 
    0.29177529f, 0.09196144f, -0.03011435f, -0.14811511f, -0.10182456f, -0.10870791f, -0.03887271f, -0.07185069f, 
    0.06913084f, -0.01555003f, 0.08788340f, -0.03830813f, -0.19201322f, -0.07954226f, -0.00749450f, -0.05307133f, 
    0.04018989f, -0.08348659f, -0.06667083f, 0.20148276f, -0.06846657f, -0.00041877f, 0.10233460f, 0.14360029f, 
    0.06073081f, -0.10018404f, -0.05829842f, -0.03736944f, -0.05605443f, 0.03051998f, -0.20354438f, -0.11209590f, 
    -0.07973929f, -0.15019360f, -0.04077078f, -0.05969486f, 0.06554861f, -0.10605383f, 0.02021693f, -0.02933135f, 
    -0.16767414f, -0.01201673f, -0.00301192f, 0.08239425f, 0.26030967f, 0.11172182f, 0.11832840f, 0.11286844f, 
    -0.00303051f, 0.08952367f, -0.01396451f, -0.08770100f, -0.06323939f, 0.03566474f, -0.08283972f, -0.11021792f, 
    0.14043811f, -0.00080252f, -0.00874473f, -0.06972711f, 0.08077243f, -0.10654395f, -0.00735312f, 0.19649117f, 
    0.08511923f, -0.04506520f, -0.03446185f, 0.06143937f, -0.03004059f, 0.01124581f, -0.01893194f, -0.13775446f, 
    -0.24760678f, -0.02327368f, 0.03260335f, 0.03621959f, -0.02803788f, 0.03269387f, -0.00725352f, 0.01576794f, 
    -0.06862827f, 0.07086024f, -0.00021346f, 0.07333760f, -0.16592188f, -0.19995929f, 0.22850028f, -0.06097342f, 
    0.11768997f, -0.02232762f, 0.13230518f, 0.09871017f, -0.00813373f, -0.03317893f, -0.15369599f, 0.03733517f, 
    -0.02344728f, 0.02755887f, 0.03813158f, 0.21028787f, 0.04333641f, 0.05544110f, 0.09326040f, 0.08542079f, 
    0.04561790f, 0.00969857f, 0.00591437f, 0.05986903f, -0.19756481f, -0.12395415f, 0.11411633f, 0.21322301f, 
    0.01431624f, 0.10723401f, -0.04578951f, -0.14932109f, -0.07005958f, -0.01506114f, 0.02065103f, 0.05866906f, 
    -0.11349186f, 0.08162415f, 0.22288175f, -0.00525135f, 0.04062636f, -0.03868879f, -0.01261913f, -0.00628023f, 
    -0.11084570f, -0.01595290f, 0.02889391f, 0.07149794f, 0.05958247f, 0.30927700f, 0.10085639f, 0.09590958f, 
    -0.02269487f, 0.02805445f, 0.05060153f, -0.18883516f, 0.01094048f, -0.02996044f, -0.03726377f, 0.13600869f, 
    -0.02383670f, 0.00680164f, 0.04009144f, -0.02365908f, -0.01843812f, 0.01235479f, -0.01463971f, -0.00930270f, 
    -0.04406527f, 0.01229478f, 0.03592793f, -0.03513200f, 0.01417406f, -0.02150071f, 0.02867573f, -0.05893264f, 
    -0.03197980f, -0.04871026f, 0.01663149f, 0.04028729f, -0.05490577f, 0.02837577f, -0.02090112f, -0.04278810f, 
    -0.01484163f, -0.00751753f, 0.01766490f, 0.00385429f, -0.04316350f, -0.01936876f, 0.03173306f, 0.03734767f, 
    0.02443501f, 0.01410239f, -0.05929472f, 0.00952207f, -0.04149004f, -0.04055877f, 0.00264861f, -0.03050573f, 
    -0.00509008f, -0.00661002f, -0.02875539f, -0.04016200f, -0.05013385f, 0.02473343f, 0.02272567f, 0.02067408f, 
    -0.05005819f, 0.04007705f, 0.00133236f, -0.04012361f, -0.04392479f, 0.01461251f, 0.02851357f, 0.02946248f, 
    0.00578239f, -0.01025581f, -0.06076214f, 0.03857931f, -0.05006517f, -0.04809680f, -0.01605918f, -0.02173929f, 
    -0.01806322f, -0.02729660f, 0.01136348f, -0.06944573f, 0.01642074f, -0.00555202f, -0.00496373f, -0.01575393f, 
    -0.03871362f, 0.03586960f, -0.04436738f, -0.00740584f, 0.00053029f, -0.04612331f, -0.05000533f, 0.00118813f, 
    -0.01168355f, -0.00594988f, -0.04053562f, 0.02869694f, -0.01572784f, 0.02676556f, -0.00216694f, 0.01864034f, 
    0.01200924f, -0.07429732f, 0.01588907f, -0.04906791f, -0.05265778f, 0.00735420f, -0.06690919f, -0.01882824f, 
    -0.02666464f, -0.03678758f, 0.02989197f, -0.05409084f, -0.07157453f, -0.04450500f, -0.01860003f, 0.01234858f, 
    -0.02420665f, -0.02455526f, -0.02449154f, -0.04945125f, 0.03244923f, 0.00195543f, -0.05764693f, 0.03123259f, 
    -0.05672437f, 0.00292732f, -0.01005331f, -0.02673936f, -0.02497998f, 0.00132305f, 0.03367633f, 0.00146130f, 
    -0.00071512f, -0.03774545f, 0.04122254f, 0.01927440f, -0.02053826f, 0.02912518f, -0.00091893f, -0.06431442f, 
    0.00743741f, 0.03428889f, -0.04396527f, 0.03043902f, 0.01308064f, -0.01880019f, -0.03678052f, -0.03066518f, 
    -0.00471508f, 0.03389352f, 0.03436453f, -0.00673306f, -0.00374927f, -0.06318625f, -0.06389096f, 0.01552132f, 
    -0.02040230f, -0.03571363f, -0.03892753f, -0.00422191f, -0.06350578f, -0.06079291f, 0.01751004f, 0.00876213f, 
    -0.00694458f, -0.03280358f, 0.00726384f, -0.03405473f, -0.04905788f, -0.05440291f, 0.01980314f, -0.04054087f, 
    -0.03042104f, 0.02863697f, -0.00015396f, 0.00682056f, -0.02303266f, -0.02562509f, -0.05817534f, -0.00078601f, 
    -0.06704370f, -0.05300771f, 0.00183885f, 0.01558627f, -0.04953204f, -0.00819975f, -0.02213780f, -0.04417728f, 
    -0.05757354f, -0.07068699f, 0.00247848f, 0.03247644f, 0.01069150f, 0.03227099f, 0.03140903f, 0.00956466f, 
    0.03576701f, -0.00514697f, -0.04350271f, -0.00920560f, 0.03124212f, -0.04046810f, 0.00066519f, -0.01287387f, 
    -0.06028908f, 0.01072386f, 0.02438704f, -0.03250116f, 0.01242944f, -0.00316720f, -0.06083824f, -0.04810227f, 
    -0.04340964f, 0.02030203f, -0.06078733f, 0.00593345f, -0.00192234f, 0.02204334f, -0.02338610f, -0.00343756f, 
    -0.00714409f, 0.03129956f, 0.02587606f, 0.03999603f, -0.01028115f, 0.00027539f, -0.00653730f, -0.01745366f, 
    -0.02085773f, -0.06381371f, 0.01418769f, 0.03312776f, 0.01715062f, 0.02221481f, -0.05145694f, 0.02790364f, 
    -0.00584232f, -0.04377618f, -0.05616084f, -0.05034015f, 0.02343296f, 0.03258974f, -0.03223081f, 0.02038608f, 
    -0.02840178f, 0.00159219f, 0.02937786f, -0.04210028f, -0.05090291f, -0.03258084f, -0.02310495f, 0.00720017f, 
    -0.02387646f, -0.05211938f, -0.02135332f, -0.05179173f, -0.00767141f, -0.07535154f, 0.00605151f, 0.00030468f, 
    0.00747415f, -0.02997844f, 0.02055147f, 0.02095488f, 0.01594601f, -0.03822380f, 0.00574930f, -0.00325261f, 
    0.01075818f, 0.03952413f, 0.00794099f, 0.00388593f, -0.00070625f, -0.02200862f, -0.03137059f, -0.00488328f, 
    -0.04147081f, 0.03028733f, 0.00455830f, -0.00913129f, -0.03863579f, -0.01137672f, 0.00262719f, -0.01232561f, 
    -0.02770356f, -0.04976906f, -0.03818195f, 0.01992526f, 0.00523269f, 0.02450882f, -0.03631167f, -0.02994354f, 
    -0.04623267f, -0.04774775f, 0.00145054f, -0.03415535f, 0.02802865f, -0.04917151f, 0.01021077f, -0.01196713f, 
    0.03126142f, -0.05063131f, 0.02582727f, -0.00774558f, 0.03926675f, 0.00020989f, 0.02003672f, 0.00879836f, 
    -0.05675919f, 0.00642820f, -0.03210708f, -0.02142125f, -0.00645088f, -0.00718466f, 0.00421103f, 0.00354550f, 
    -0.04504197f, -0.03817228f, 0.01976059f, 0.03667858f, 0.03637091f, 0.01657886f, -0.02213113f, 0.01918667f, 
    -0.01058358f, 0.04547979f, 0.01318457f, -0.03691331f, 0.01054803f, 0.02290897f, -0.02737816f, -0.02656428f, 
    -0.04349144f, -0.02798666f, -0.04563836f, -0.04078687f, -0.04020366f, -0.00382450f, 0.02544875f, -0.05468925f, 
    0.04252488f, -0.02291849f, 0.00530794f, -0.01171929f, -0.05506526f, -0.03274553f, -0.06094108f, -0.05193882f, 
    -0.06125386f, 0.03205287f, -0.05034661f, -0.02990052f, -0.02091205f, 0.03992181f, -0.03996681f, -0.05545005f, 
    0.01717514f, 0.02596229f, -0.00498994f, -0.03545487f, -0.02922227f, 0.03850803f, -0.04954086f, 0.02908470f, 
    -0.02220388f, 0.04092908f, 0.01154858f, -0.00357704f, 0.00873296f, 0.01783903f, 0.00698316f, -0.01594972f, 
    0.01412421f, -0.04612133f, 0.01332191f, -0.02920357f, -0.01120092f, -0.01755957f, -0.01922806f, -0.02999165f, 
    0.01550959f, -0.01471416f, -0.01822757f, -0.04555489f, -0.02213984f, -0.02723294f, 0.00169675f, 0.00654549f, 
    0.00321645f, -0.02119488f, -0.04619896f, 0.02591302f, -0.00428559f, -0.03710502f, 0.01927770f, 0.01565000f, 
    -0.09237674f, -0.47693741f, -0.13063598f, 0.01090197f, 0.15704910f, -0.00397484f, -0.03633792f, 0.00995878f, 
    0.09340161f, 0.06335746f, -0.00578507f, 0.00977386f, 0.01430221f, 0.09179901f, 0.07568154f, 0.07269951f, 
    0.07626348f, 0.02026733f, 0.23433562f, 0.02726666f, 0.19334573f, 0.14450377f, -0.07607209f, -0.27123874f, 
    -0.02527608f, -0.11151496f, -0.22062539f, 0.00796598f, -0.00030913f, 0.00936868f, 0.08723632f, 0.01807255f, 
    0.11226214f, 0.03619542f, -0.09231786f, -0.09205271f, -0.21833861f, 0.24993762f, 0.11860583f, -0.13481583f, 
    0.06920649f, 0.09650685f, 0.01871683f, 0.01433862f, 0.01993033f, 0.00261025f, 0.00373104f, 0.00529578f, 
    0.45837054f, 0.21512491f, -0.15177968f, 0.29277256f, 0.10309928f, 0.07164133f, -0.12039461f, -0.00948370f, 
    0.05541172f, 0.04050494f, 0.12876430f, 0.22614202f, -0.15763888f, 0.06393230f, -0.08883713f, -0.09278363f, 
    -0.00143398f, 0.01754647f, 0.08048112f, 0.00469150f, 0.20504360f, -0.05160608f, 0.07540149f, 0.02909570f, 
    -0.01727126f, 0.12630513f, 0.07823446f, 0.09020673f, -0.01686735f, 0.05361931f, 0.08691229f, 0.14694612f, 
    0.13961357f, 0.13329746f, 0.05017325f, 0.09335263f, 0.00923976f, -0.07115220f, -0.06118338f, 0.10439997f, 
    0.07607867f, -0.04445900f, -0.01574400f, -0.05670457f, 0.21768095f, -0.04549411f, -0.08631370f, 0.22073330f, 
    0.06332273f, -0.09434910f, -0.07261381f, -0.05031137f, 0.18610574f, -0.01799896f, -0.13822387f, 0.07029015f, 
    0.03638842f, -0.02058318f, 0.11755868f, 0.07480340f, 0.00128161f, -0.25702322f, -0.10138087f, -0.12949322f, 
    -0.08404648f, -0.07981429f, -0.07461914f, -0.10948914f, -0.00164558f, 0.01716050f, 0.13645291f, 0.02634863f, 
    0.09767630f, -0.07273024f, -0.12953107f, -0.00641302f, -0.01045868f, -0.06412379f, -0.03916641f, 0.01621358f, 
    0.12562177f, 0.03672158f, 0.15751545f, -0.05130821f, -0.36512613f, 0.24047753f, 0.01741806f, 0.03607206f, 
    0.00329768f, -0.05043721f, 0.07093009f, -0.12031178f, -0.06398880f, -0.06801386f, -0.07646815f, 0.05956542f, 
    -0.12216403f, 0.04180628f, 0.04149789f, -0.17948307f, -0.02708094f, -0.13516037f, -0.05738450f, -0.02481091f, 
    -0.07523368f, -0.18223347f, -0.13934362f, -0.06758607f, -0.16885459f, 0.15900841f, 0.27069357f, 0.41952693f, 
    0.14751808f, -0.01822408f, 0.07245573f, 0.26996294f, 0.03960703f, 0.04476536f, -0.02325410f, 0.22017336f, 
    -0.22470143f, -0.08523371f, -0.03282807f, -0.13431157f, -0.20807657f, -0.03819798f, -0.05171973f, -0.03429927f, 
    -0.03495874f, -0.19746190f, -0.22568433f, -0.11032974f, 0.00132732f, 0.35316953f, -0.14443105f, 0.11996387f, 
    0.12987934f, 0.25775409f, 0.04691069f, -0.17433468f, 0.10678297f, 0.10655663f, 0.08312585f, 0.17426963f, 
    -0.07020316f, 0.11931797f, 0.03133502f, -0.08760614f, -0.02795010f, -0.00788375f, 0.08272692f, -0.06041013f, 
    -0.01259159f, 0.05318032f, -0.02140887f, -0.05246295f, 0.23353788f, -0.43877447f, 0.17002262f, 0.08356009f, 
    0.08518250f, 0.09228002f, -0.20987348f, 0.02336198f, 0.04895992f, -0.03952242f, 0.12554149f, 0.00926441f, 
    -0.34525931f, -0.05142677f, 0.11255946f, 0.00100801f, -0.09765085f, 0.01127936f, 0.10035336f, -0.09440294f, 
    0.11234764f, -0.04370572f, 0.08900738f, 0.19552819f, -0.07193611f, -0.07101404f, 0.09774028f, 0.17749180f, 
    -0.17531236f, 0.01310958f, 0.12393014f, -0.13853939f, 0.08227390f, -0.00424777f, 0.17797184f, 0.17021729f, 
    0.34419438f, -0.05151930f, -0.03782497f, -0.16874275f, 0.04306679f, -0.13489509f, -0.00772019f, 0.11459579f, 
    -0.02308968f, 0.02365149f, 0.11771994f, 0.04066979f, -0.26344976f, -0.41439354f, -0.22430876f, -0.18569311f, 
    0.09257358f, -0.10798914f, -0.17236389f, 0.11110065f, 0.10380480f, 0.23533171f, 0.01482541f, 0.13153903f, 
    -0.16996305f, 0.12280267f, -0.05575095f, 0.10080614f, 0.01075823f, 0.07161069f, 0.02586288f, -0.07130253f, 
    -0.06931873f, 0.15096828f, 0.11379116f, 0.04625403f, -0.15735440f, -0.08768590f, -0.16924943f, -0.05366979f, 
    0.03920753f, 0.00869823f, 0.07772678f, 0.10578883f, 0.09676337f, 0.08108163f, 0.18192965f, 0.09312522f, 
    0.13098286f, 0.20493591f, -0.10647002f, -0.08634476f, -0.01653337f, -0.01660949f, -0.01837085f, -0.01405019f, 
    -0.05224987f, -0.05684827f, -0.02976610f, -0.02496742f, 0.18378936f, -0.11282589f, -0.13651963f, 0.31457239f, 
    0.11125878f, 0.02084942f, -0.06132412f, 0.24085511f, 0.00132062f, 0.09857267f, 0.20223399f, 0.07343831f, 
    -0.22580113f, -0.04643350f, -0.00615687f, 0.13026878f, 0.01547653f, 0.00882191f, 0.12787439f, -0.06455701f, 
    0.11108788f, 0.10258632f, -0.11469238f, 0.24500105f, -0.02194879f, -0.01551571f, -0.01375915f, -0.18595263f, 
    0.15655975f, -0.01283270f, -0.08952848f, -0.16008531f, 0.09567426f, 0.09668447f, -0.07738066f, 0.15853025f, 
    0.14999077f, -0.17900264f, -0.19018261f, 0.07694510f, 0.03261518f, -0.07572318f, 0.07249201f, 0.10985050f, 
    0.10338438f, 0.05574324f, 0.05000401f, 0.17194778f, -0.34265196f, -0.45928133f, -0.11818527f, -0.01612136f, 
    0.17997125f, 0.22670686f, -0.11742476f, -0.30437630f, 0.09112397f, -0.05124351f, 0.08082419f, 0.05316587f, 
    -0.57850355f, -0.11673993f, 0.30160397f, -0.16681737f, 0.19017977f, 0.27977777f, -0.02918880f, -0.00012884f, 
    -0.01699089f, 0.02928933f, -0.00909187f, 0.15829349f, -0.16567034f, 0.24139889f, -0.09455302f, 0.00100057f, 
    0.05803560f, 0.03861614f, 0.00974133f, -0.13776197f, 0.06635015f, 0.04272376f, 0.05317723f, -0.03832173f, 
    0.19076602f, 0.16342036f, 0.05714665f, -0.18427213f, -0.05014762f, 0.02884525f, 0.03554579f, 0.20998538f, 
    -0.12004742f, -0.00806580f, 0.18479781f, 0.02913625f, 0.23765856f, 0.03091001f, -0.09002592f, 0.07502659f, 
    0.03872654f, 0.00346473f, 0.02528402f, -0.06392086f, 0.17398503f, -0.01213015f, -0.01193058f, -0.13630491f, 
    -0.05457157f, 0.23957841f, 0.09023065f, -0.15926343f, -0.00021587f, 0.12171531f, 0.00352137f, 0.11658043f, 
    -0.15220234f, -0.01763884f, 0.15385525f, -0.07779969f, -0.05467041f, -0.05315866f, -0.17215893f, 0.23138572f, 
    -0.06059819f, -0.05817559f, 0.09848069f, -0.10688283f, -0.05173859f, -0.02480644f, -0.03025745f, 0.08715587f, 
    0.16714807f, 0.25144321f, 0.14770080f, -0.00102680f, -0.20620653f, -0.06141418f, -0.12772900f, 0.00927768f, 
    0.12590937f, 0.12940307f, -0.08286221f, -0.01183852f, -0.17632921f, 0.35117796f, 0.27673888f, -0.05317353f, 
    -0.02583945f, 0.04167420f, -0.16825479f, -0.10504868f, 0.23577583f, -0.01429022f, 0.03549460f, 0.06362481f, 
    -0.24396786f, 0.25728035f, -0.08760998f, -0.10427785f, -0.03313003f, -0.04664484f, -0.08377669f, -0.03532101f, 
    -0.08810883f, 0.09107012f, 0.06718681f, 0.04389513f, -0.21185553f, 0.25554317f, 0.08993215f, -0.01792882f, 
    -0.13899522f, -0.13035387f, -0.00584975f, -0.04582970f, 0.04163961f, 0.13033701f, 0.21958467f, 0.12803841f, 
    -0.14600471f, -0.09546334f, -0.18586642f, -0.04087974f, -0.05024014f, 0.06026182f, 0.02978792f, 0.07129174f, 
    -0.00658025f, 0.02598221f, -0.03117779f, 0.11736178f, 0.13075319f, 0.35761106f, -0.17008109f, -0.09856475f, 
    0.02913636f, 0.24315083f, -0.01133680f, 0.14269862f, -0.00955174f, 0.10817906f, -0.08270013f, 0.00426385f, 
    0.01275468f, 0.07668182f, 0.06247218f, -0.06353861f, -0.06153790f, 0.07265674f, -0.05271826f, 0.05573005f, 
    -0.07659309f, 0.04363541f, -0.10479672f, -0.03061684f, -0.40749022f, -0.12051822f, -0.21926184f, 0.13417493f, 
    0.02115530f, -0.00781966f, -0.00853166f, -0.03725350f, -0.02319439f, -0.08556665f, 0.01164177f, 0.05198850f, 
    -0.04932590f, -0.15969370f, -0.13898982f, 0.04096021f, -0.15571417f, -0.08667677f, -0.02075404f, -0.17120336f, 
    -0.10322180f, 0.08857334f, 0.00860336f, 0.10844200f, 0.59681642f, 0.11935259f, -0.14988491f, 0.19510575f, 
    -0.03803263f, -0.10184092f, 0.20517731f, -0.07202573f, 0.24879919f, -0.01432977f, 0.29226771f, -0.02411501f, 
    0.00856221f, -0.05874571f, -0.08708687f, 0.02294292f, -0.00282423f, 0.12758052f, -0.13689975f, -0.06438101f, 
    0.02082470f, -0.08485427f, 0.08260771f, -0.11977258f, 0.30367789f, 0.06406036f, -0.18765704f, 0.13722359f, 
    -0.04439837f, 0.07692129f, 0.08592964f, 0.10374219f, 0.14185213f, 0.19732708f, 0.05394321f, 0.04300109f, 
    0.17563394f, -0.24934219f, -0.12776014f, -0.18898955f, -0.07995720f, 0.02512720f, 0.04329767f, -0.05567274f, 
    0.00188110f, 0.11907175f, 0.00089436f, 0.07683999f, -0.06273354f, 0.35102803f, -0.10813583f, -0.03702374f, 
    0.02396639f, -0.00153401f, 0.11464459f, 0.04725065f, -0.06387944f, 0.04347457f, -0.08064060f, 0.06345404f, 
    0.49428409f, -0.02146698f, 0.26112300f, 0.02741089f, 0.22327138f, -0.07326729f, -0.12014920f, -0.13512473f, 
    0.14416093f, 0.05355970f, 0.03706650f, 0.06185212f, 0.39410684f, 0.02265817f, -0.04798292f, 0.02980480f, 
    0.18252625f, 0.01643341f, -0.08933195f, -0.12516776f, -0.07186441f, 0.05526260f, 0.04958637f, 0.00468682f, 
    -0.18841563f, -0.29371071f, 0.04050243f, 0.15521148f, -0.08374002f, 0.11317355f, -0.05059498f, -0.09350350f, 
    -0.11127347f, -0.03814419f, -0.02327889f, 0.02974285f, 0.15595900f, -0.05857699f, 0.02393604f, -0.17213812f, 
    -0.03132556f, -0.07969719f, 0.17335610f, 0.05931027f, -0.01911099f, -0.06989291f, 0.08626738f, 0.06693554f, 
    0.17162769f, 0.02345886f, -0.00065005f, 0.11093873f, -0.01511626f, -0.13646941f, -0.08839087f, 0.03322533f, 
    0.08038857f, -0.05531200f, 0.11976933f, 0.05472682f, -0.00674163f, 0.07104767f, 0.31506485f, 0.06646674f, 
    -0.06872321f, -0.15369757f, 0.03233677f, -0.04144917f, 0.04519639f, 0.11205626f, 0.04861562f, 0.11790543f, 
    -0.14657640f, 0.16678482f, -0.17152958f, 0.12469196f, -0.14328815f, -0.00361406f, 0.07486928f, -0.06636389f, 
    0.08695379f, 0.06131178f, -0.05661730f, 0.07435741f, 0.16505511f, 0.26368710f, 0.12888359f, 0.10926533f, 
    0.07043773f, 0.02029046f, 0.07349849f, -0.05525948f, 0.04918622f, 0.04190461f, -0.03821579f, -0.10839485f, 
    -0.08240367f, 0.21272030f, 0.25898224f, -0.02007994f, -0.07026265f, 0.05972788f, -0.02216293f, 0.10201851f, 
    -0.05330677f, 0.24908447f, -0.02830317f, 0.11601087f, 0.17124535f, -0.29816034f, 0.22349614f, -0.17359447f, 
    -0.06398308f, 0.03295919f, 0.01223676f, 0.19801706f, 0.07059842f, 0.13129073f, 0.10376214f, 0.08755629f, 
    0.02965346f, 0.05651526f, -0.13388871f, 0.17809631f, 0.00050885f, 0.08253436f, 0.12036610f, 0.10788501f, 
    -0.00337353f, 0.03944892f, -0.05839186f, 0.05842865f, 0.04979758f, -0.03440345f, -0.20494759f, -0.05535977f, 
    0.07328877f, 0.12729774f, 0.13224177f, 0.07038565f, -0.02263888f, 0.15544462f, -0.01904397f, 0.05872878f, 
    -0.04362799f, -0.27961695f, -0.20852003f, 0.09911358f, 0.06555728f, -0.13650560f, 0.09295835f, -0.10282211f, 
    0.00977964f, 0.02453577f, -0.05323292f, -0.07993043f, 0.02938632f, -0.21741372f, -0.35580444f, 0.34620723f, 
    0.18521048f, -0.03125767f, 0.04478225f, -0.07952835f, 0.00058921f, 0.04898063f, 0.05336052f, 0.11271704f, 
    -0.19300076f, -0.09511861f, 0.07449502f, 0.03291667f, 0.06805604f, -0.12775868f, 0.03724841f, -0.12055586f, 
    0.07036980f, -0.08266754f, -0.11001609f, 0.04503717f, 0.07733193f, 0.20312059f, 0.07288564f, -0.02528933f, 
    -0.04605680f, 0.03271732f, 0.13206248f, 0.16996963f, -0.03489968f, 0.18720366f, 0.23741627f, 0.16110688f, 
    -0.05014762f, -0.24033074f, -0.07871784f, 0.16135085f, 0.11093156f, 0.02686541f, 0.18783623f, 0.09526633f, 
    0.15206464f, 0.12796906f, -0.01305257f, 0.08593182f, 0.39120615f, 0.27126738f, 0.22579125f, -0.14884737f, 
    -0.03580234f, 0.08579855f, -0.00936035f, 0.17285426f, 0.06819142f, 0.12454216f, 0.22034538f, 0.10227156f, 
    -0.06547605f, 0.00477273f, -0.10413030f, -0.02968216f, 0.08598414f, 0.11174053f, 0.19993918f, 0.09153917f, 
    0.14321308f, 0.23053356f, 0.27161786f, 0.07765321f, 0.17872377f, -0.15088376f, -0.00795841f, 0.17321180f, 
    0.03133910f, -0.11745612f, -0.07380611f, -0.00544941f, -0.14885648f, -0.04008726f, 0.10289542f, 0.09922969f, 
    -0.09808908f, -0.06675623f, 0.21312338f, -0.04694003f, -0.13893564f, -0.14981370f, -0.11009823f, -0.05980472f, 
    -0.03266134f, 0.07022369f, 0.18215014f, 0.10893757f, 0.20486082f, -0.00361291f, -0.00685774f, 0.17670323f, 
    0.11045578f, 0.09549949f, -0.08082669f, 0.06332183f, 0.16716664f, -0.05102356f, -0.04005371f, -0.01446551f, 
    0.07884420f, -0.06145754f, 0.04819164f, 0.03038195f, 0.24677193f, -0.10331556f, -0.02410089f, -0.08773616f, 
    -0.00732935f, -0.11666283f, -0.08526146f, -0.21152060f, -0.26115376f, -0.48722857f, 0.00581354f, 0.12251098f, 
    0.12578091f, -0.00516867f, 0.05331892f, -0.06346729f, 0.08556675f, 0.05252673f, 0.24801466f, -0.00380038f, 
    0.02467191f, 0.03201986f, 0.03212815f, 0.15447567f, 0.00882191f, -0.08331911f, -0.10339789f, -0.10136303f, 
    0.10269972f, -0.06870130f, 0.10168602f, 0.00266677f, 0.47053662f, 0.39581817f, 0.19794483f, -0.06196923f, 
    -0.11296572f, 0.00707888f, -0.06946407f, -0.03009607f, -0.07501691f, 0.00300529f, -0.01069085f, 0.06526799f, 
    0.21420668f, 0.17383651f, 0.18881388f, 0.10807135f, -0.01859235f, -0.06287611f, -0.10465723f, -0.03116247f, 
    0.01911285f, -0.10271059f, -0.04277499f, -0.20963103f, 0.01245393f, 0.06006578f, 0.20135109f, -0.22087418f, 
    0.15131262f, 0.04576055f, 0.16348606f, 0.18499295f, 0.14416166f, 0.13335864f, -0.07421562f, 0.16331345f, 
    0.05966644f, 0.08937091f, -0.08567644f, -0.00940843f, 0.06788557f, 0.04673420f, 0.12720646f, 0.01541559f, 
    0.17497446f, 0.04626346f, -0.07992250f, 0.02605849f, -0.04405798f, 0.04102406f, 0.16183035f, -0.11032757f, 
    0.07047369f, -0.06197181f, 0.12432522f, 0.02680324f, 0.18153158f, 0.01624042f, 0.14880972f, 0.02783676f, 
    0.22264397f, 0.15704614f, 0.00567351f, 0.00607167f, 0.14837672f, 0.02660067f, 0.04831459f, -0.10078967f, 
    0.00421470f, -0.11535686f, -0.04438248f, -0.13032807f, -0.06315084f, -0.30202252f, 0.11803105f, 0.11484881f, 
    0.08856960f, -0.00686427f, -0.05102582f, 0.13879496f, 0.03373343f, 0.11400719f, 0.05056748f, 0.03943880f, 
    0.29730573f, 0.12444492f, -0.05350861f, 0.16639762f, -0.10353575f, 0.11085544f, 0.03554393f, 0.19511150f, 
    -0.00902960f, 0.03665939f, 0.05148795f, 0.21553385f, -0.02839791f, 0.12574129f, 0.12234496f, 0.00905327f, 
    -0.09055475f, 0.05676522f, 0.05647605f, 0.12721807f, 0.03639081f, 0.03180961f, 0.09797397f, 0.18607207f, 
    0.32869449f, 0.47904345f, 0.02570326f, 0.17795353f, -0.05465922f, 0.02863128f, -0.08763259f, -0.04345774f, 
    0.01717412f, -0.15817617f, -0.11690511f, -0.02517683f, -0.13162288f, -0.02676385f, -0.06158630f, -0.12151416f, 
    0.12963489f, 0.05063961f, -0.02235039f, 0.09555720f, -0.02583006f, -0.02921223f, -0.19878295f, -0.13316657f, 
    0.28674388f, 0.02447440f, 0.02123698f, -0.04143654f, -0.04801702f, 0.18467972f, -0.03909053f, -0.13566521f, 
    0.09634013f, 0.24012159f, 0.13662532f, 0.05814489f, -0.10986874f, 0.00930178f, 0.03549855f, 0.15439147f, 
    0.05344270f, -0.04026052f, -0.10340960f, -0.05291126f, -0.07387696f, -0.02159272f, 0.04310433f, -0.02329227f, 
    0.28311193f, -0.06994535f, 0.15469320f, -0.04496280f, 0.14175990f, 0.04954460f, 0.15092896f, -0.07031561f, 
    0.14492807f, 0.04196964f, 0.21058293f, 0.05349479f, -0.20405950f, -0.13048083f, -0.22414833f, -0.03892616f, 
    0.00591705f, 0.08533254f, 0.02691877f, -0.00493937f, -0.04423923f, 0.03399080f, 0.15294430f, 0.20187351f, 
    -0.34426260f, 0.01658104f, -0.09201436f, 0.21353123f, 0.15067343f, 0.11623966f, -0.05432166f, -0.05497025f, 
    -0.09036815f, -0.17958534f, 0.13082148f, -0.04419402f, -0.23607084f, -0.16104949f, 0.01525829f, -0.06505486f, 
    0.18151331f, 0.16560806f, 0.10410534f, 0.00599376f, 0.07586527f, 0.02279034f, 0.04260577f, 0.13867258f, 
    -0.22483253f, -0.04387366f, 0.02406038f, -0.06586318f, 0.07263393f, 0.00957006f, -0.02732470f, 0.01204208f, 
    -0.04692451f, -0.08738974f, -0.00967461f, -0.10610770f, -0.09250139f, -0.08067126f, -0.05263707f, -0.06934118f, 
    -0.12489765f, 0.01142048f, -0.09130596f, -0.07123626f, 0.00890962f, -0.12003680f, -0.06307443f, -0.03542842f, 
    0.36715382f, -0.07988863f, 0.17492495f, -0.26650923f, -0.10669618f, 0.05319031f, -0.00544210f, -0.02474538f, 
    -0.07737873f, -0.05731393f, 0.00362996f, 0.03770527f, 0.10302909f, 0.17025252f, 0.24525613f, 0.02977159f, 
    0.01211427f, 0.15049513f, -0.00720517f, 0.00258796f, 0.01577231f, -0.11290117f, -0.01024702f, -0.00449518f, 
    -0.04096306f, 0.03643700f, -0.05599733f, -0.04764704f, -0.04148733f, 0.01440698f, 0.02276417f, -0.01962578f, 
    0.03927879f, -0.05442354f, -0.05594703f, 0.03355929f, 0.02601726f, 0.00947376f, -0.01810175f, 0.03780101f, 
    -0.03449606f, 0.02679881f, -0.04933945f, 0.03039391f, 0.02717362f, -0.04727976f, -0.00852465f, -0.02972898f, 
    -0.04463678f, 0.03940587f, -0.04602844f, -0.01928779f, -0.01265898f, -0.03788497f, -0.01217732f, -0.01026577f, 
    0.02956529f, 0.02547636f, -0.04030459f, -0.05262985f, -0.00219325f, 0.00241443f, 0.02117883f, -0.04164425f, 
    -0.05961760f, 0.03825719f, 0.03098394f, -0.03669984f, -0.01064541f, -0.03258020f, 0.00364317f, 0.02736310f, 
    0.03980634f, -0.05574794f, -0.00834515f, 0.02360460f, -0.01563396f, -0.00123418f, -0.00102523f, -0.02630629f, 
    0.00644874f, -0.00933612f, -0.02147616f, -0.00325857f, 0.01309141f, -0.03815958f, -0.05682582f, 0.02657458f, 
    -0.04938452f, 0.01672493f, 0.03856212f, 0.03020280f, 0.03333015f, -0.04964144f, -0.02242207f, 0.01591840f, 
    0.02953408f, -0.01647263f, -0.05713765f, 0.01804111f, 0.01013574f, 0.00106150f, 0.00344208f, -0.03860095f, 
    0.00721400f, -0.03105531f, 0.00005665f, 0.00919635f, -0.00026053f, 0.03875751f, -0.01561582f, -0.00236789f, 
    -0.01554710f, -0.03274381f, 0.01911475f, -0.00063065f, -0.02625688f, 0.00813958f, -0.03737273f, 0.01135252f, 
    0.01653027f, 0.03754153f, 0.03852589f, 0.01476863f, 0.02820153f, -0.01153614f, 0.03195399f, -0.02013327f, 
    0.03587636f, -0.03810709f, 0.00566623f, 0.02275859f, 0.04427260f, 0.04289943f, -0.01868336f, -0.03164795f, 
    0.03882204f, -0.03546532f, 0.00855100f, -0.05651737f, -0.03234513f, 0.02675343f, -0.04447306f, -0.00499972f, 
    0.03166971f, 0.03796631f, -0.00910448f, -0.03430037f, -0.03725561f, 0.01530314f, -0.04734459f, -0.01963227f, 
    -0.03787760f, 0.02168939f, 0.01231019f, 0.02135608f, 0.00772628f, -0.02783377f, 0.00966280f, 0.00075545f, 
    -0.02240200f, -0.01204936f, -0.01030474f, -0.03944695f, 0.02511321f, 0.00487390f, 0.01873280f, -0.05521429f, 
    0.01518788f, -0.01883356f, 0.01209792f, 0.01314709f, -0.01697950f, 0.03483218f, -0.06099411f, -0.05421850f, 
    -0.04419505f, -0.03929838f, -0.05762533f, -0.01487314f, 0.02072004f, 0.00285657f, 0.03718892f, -0.01516477f, 
    0.00042792f, 0.01130612f, -0.01728640f, -0.03002449f, 0.00720054f, -0.02958953f, -0.00020868f, -0.04966012f, 
    -0.01698198f, 0.00415947f, -0.05952303f, -0.01811315f, -0.02088399f, -0.05800173f, 0.03287882f, -0.05423028f, 
    0.03113389f, -0.02087358f, -0.02762004f, 0.03649217f, 0.02505520f, 0.03774814f, -0.04444233f, -0.01457762f, 
    -0.00295678f, 0.00809876f, -0.00679482f, -0.05009599f, -0.04756698f, -0.04950223f, 0.02573416f, -0.02876190f, 
    0.02703021f, -0.03144109f, -0.03289441f, -0.03296344f, 0.02467796f, -0.03857908f, 0.01239969f, -0.03522404f, 
    0.03455038f, -0.05688620f, -0.05028628f, 0.01920087f, 0.03759063f, 0.01316091f, -0.00616286f, 0.00669384f, 
    -0.01805946f, 0.01074345f, -0.02120306f, -0.01484143f, -0.03316037f, 0.03758800f, 0.00140861f, -0.04081910f, 
    -0.03888294f, -0.00874401f, -0.05686814f, 0.01145818f, 0.02004889f, -0.02140912f, 0.02025042f, 0.03268169f, 
    -0.03972695f, 0.00221907f, -0.05918732f, 0.03998484f, 0.02800575f, -0.00815383f, -0.01821341f, 0.00860429f, 
    -0.01590353f, -0.04010434f, 0.02505478f, 0.03493319f, -0.02378901f, -0.00361302f, -0.03552588f, 0.01455668f, 
    -0.04476056f, -0.00455781f, -0.00535734f, -0.02348188f, -0.05459245f, 0.01931716f, 0.02843599f, -0.04014704f, 
    0.02487642f, 0.00322279f, -0.03726693f, -0.04133642f, 0.00468280f, -0.00262503f, 0.00852931f, 0.03140589f, 
    -0.01262474f, -0.01462915f, 0.00377843f, 0.03469169f, 0.01926125f, 0.00965455f, 0.03308964f, -0.00868373f, 
    0.00565982f, 0.00287015f, 0.01140117f, 0.03827176f, 0.01730598f, -0.00895151f, -0.00297593f, 0.02843576f, 
    -0.04786193f, -0.03677234f, 0.01918123f, 0.00466696f, 0.01896733f, 0.01113611f, 0.02339207f, -0.01320864f, 
    -0.02268896f, 0.00308406f, -0.01947652f, -0.01985970f, -0.04376842f, 0.02126208f, 0.02373191f, -0.03158907f, 
    0.03248544f, -0.05314507f, -0.00119628f, 0.01907600f, -0.03741805f, 0.01034835f, -0.01313381f, 0.01506679f, 
    0.02537321f, 0.00342598f, -0.03989205f, 0.00770914f, 0.04406032f, 0.00337583f, -0.05139320f, 0.04083056f, 
    -0.04731774f, -0.01029879f, -0.03168617f, 0.00652264f, -0.05084337f, 0.02798348f, 0.03864252f, -0.02501594f, 
    -0.03841004f, -0.00508365f, 0.01160156f, -0.05021799f, 0.01469368f, 0.01843506f, 0.01320329f, -0.01481745f, 
    -0.01824107f, -0.05466296f, 0.03408326f, 0.00426303f, 0.04015319f, -0.01311007f, -0.00559938f, -0.05264178f, 
    -0.05668155f, 0.03797466f, -0.01443158f, 0.00078058f, 0.03594301f, 0.00677338f, 0.02776940f, 0.01500227f, 
    -0.01007715f, -0.00591152f, 0.01314685f, -0.02677091f, -0.01706578f, -0.05675254f, 0.00931402f, 0.02937044f, 
    -0.01210713f, -0.00397568f, -0.02766965f, -0.05826156f, 0.02063806f, -0.02695407f, -0.02418879f, -0.05029642f, 
    0.02283123f, -0.00106602f, -0.00303491f, -0.01424306f, 0.03522295f, -0.02495319f, -0.03711881f, -0.05138784f, 
    0.03620788f, 0.00214826f, 0.00648945f, -0.00753867f, -0.05927518f, -0.03062229f, -0.01645851f, -0.02347929f, 
    -0.04062184f, -0.01484100f, -0.03098564f, -0.04054865f, -0.01146047f, -0.05186802f, 0.01980072f, 0.03583850f, 
    0.03440307f, 0.00250848f, 0.01754384f, -0.01839165f, -0.02477176f, -0.02321880f, -0.00766889f, 0.00447761f, 
    0.25949323f, 0.01690768f, -0.06881602f, 0.16174448f, 0.10017638f, 0.03163499f, -0.13593033f, -0.00102589f, 
    -0.07227393f, -0.01113558f, 0.10706630f, 0.08998110f, 0.13701254f, -0.04527080f, 0.14428060f, 0.20803830f, 
    0.02218362f, 0.03363485f, -0.01618996f, -0.01395265f, 0.26261979f, 0.01296310f, -0.01359292f, 0.02475798f, 
    -0.24255994f, 0.03128645f, -0.05050896f, -0.04523861f, -0.19053537f, 0.00182677f, -0.09550199f, -0.14154309f, 
    -0.01626428f, 0.04139045f, -0.22081226f, 0.27455962f, -0.55661356f, 0.08841816f, 0.11569896f, -0.17662285f, 
    -0.10123828f, -0.14172050f, -0.19174193f, 0.01991205f, 0.17572735f, -0.04712870f, 0.22012728f, 0.15502584f, 
    0.30988953f, 0.09328039f, 0.11489356f, 0.16258946f, -0.14207102f, 0.08122510f, -0.12862200f, -0.10825091f, 
    0.03497083f, -0.06607150f, 0.11220704f, 0.06747318f, 0.07688350f, -0.25097388f, 0.01250475f, -0.01213616f, 
    -0.23049180f, -0.07577327f, 0.36279345f, -0.20482886f, -0.05470222f, -0.09502901f, 0.04445730f, -0.00057745f, 
    0.35223806f, 0.24283272f, 0.06774873f, 0.50005084f, -0.12811661f, 0.09703742f, 0.18000324f, -0.05612774f, 
    0.05511162f, 0.19898261f, 0.00576794f, 0.21551745f, -0.13912109f, -0.15796420f, -0.12480869f, -0.08416936f, 
    -0.12590396f, 0.00206793f, 0.03483751f, -0.14338538f, -0.06893051f, -0.02481086f, -0.32871214f, 0.11703721f, 
    -0.38227963f, -0.13700970f, -0.15329775f, -0.17024074f, 0.00440480f, 0.02179416f, -0.19090331f, -0.03317446f, 
    -0.02476395f, -0.21437395f, 0.05057810f, -0.47190571f, 0.05356887f, -0.04760379f, -0.27363560f, -0.12910146f, 
    0.01986303f, 0.02255962f, -0.23382466f, 0.04370324f, 0.05086498f, -0.01947859f, 0.06380227f, -0.05939284f, 
    0.01612791f, -0.12087671f, -0.35395280f, 0.03166350f, -0.07066647f, -0.01758081f, 0.14601347f, -0.08225807f, 
    0.00830784f, 0.31548181f, 0.20486563f, -0.05980147f, -0.48636311f, 0.38388255f, 0.03818941f, 0.09029786f, 
    -0.32873714f, -0.21476616f, -0.00699265f, -0.21265344f, 0.01750364f, 0.08065472f, 0.07558339f, -0.06608757f, 
    -0.36151326f, -0.54314893f, -0.13048188f, -0.14583133f, -0.12928011f, 0.10601464f, -0.02048412f, 0.08879568f, 
    -0.15122418f, 0.03994943f, -0.01619052f, -0.07209093f, 0.25917616f, -0.14917240f, -0.04784965f, 0.11386942f, 
    0.04999591f, -0.00765363f, -0.15582396f, -0.04082778f, -0.11978832f, 0.03087821f, -0.06333916f, -0.04833443f, 
    -0.57585996f, 0.04738200f, -0.01674265f, -0.07543506f, 0.03017384f, -0.20369457f, -0.08430776f, -0.01319581f, 
    0.07374004f, 0.08776126f, 0.03293278f, 0.00124713f, -0.01265177f, 0.23726864f, 0.01070405f, -0.07193000f, 
    0.06524199f, 0.15236901f, -0.02786102f, -0.20019303f, 0.07884401f, 0.01531961f, 0.02426557f, 0.06515991f, 
    -0.52871269f, -0.23866503f, 0.24935357f, -0.12829426f, 0.07802142f, -0.08578651f, -0.24652928f, -0.03473583f, 
    0.02247360f, 0.09634712f, 0.06236012f, 0.06291282f, 0.35983467f, -0.16268523f, 0.05921194f, 0.31207672f, 
    -0.09627946f, 0.12086527f, -0.03583428f, -0.03555322f, 0.21490113f, -0.13705583f, 0.15263538f, 0.07631169f, 
    0.22906730f, -0.04248740f, -0.01240704f, 0.08697496f, -0.14877556f, -0.04895350f, 0.06159923f, -0.17229430f, 
    0.15092386f, 0.00206485f, 0.00427892f, -0.05813162f, 0.26341656f, 0.04735894f, 0.45624360f, 0.48367974f, 
    -0.00346910f, 0.10908690f, 0.08562744f, -0.11975814f, 0.04383773f, 0.01023707f, -0.07666953f, 0.02165415f, 
    -0.25151381f, -0.13246752f, 0.06111426f, 0.00950478f, 0.01505951f, -0.16518147f, 0.02072063f, 0.03418097f, 
    -0.01762669f, -0.00296717f, -0.10154615f, 0.08246144f, 0.10052121f, -0.00060691f, -0.02311027f, -0.14927535f, 
    0.00005341f, -0.06309193f, -0.07546205f, 0.02658077f, -0.10621087f, -0.19483928f, -0.23483507f, -0.00400664f, 
    -0.13418196f, 0.20651211f, 0.05784149f, -0.08801540f, 0.01596242f, 0.20967796f, -0.04381243f, 0.15669242f, 
    0.16922799f, 0.20470719f, 0.01965160f, -0.00390213f, 0.20860404f, 0.08004878f, 0.01854230f, -0.03967027f, 
    0.14104879f, -0.06053969f, 0.14213935f, 0.01538432f, -0.09821885f, -0.14003296f, -0.05938997f, -0.15293387f, 
    -0.36644441f, -0.09534593f, 0.07273276f, -0.11566702f, -0.06485154f, 0.14488964f, -0.11535686f, -0.16875063f, 
    0.03132331f, 0.01754397f, -0.05595942f, 0.19491397f, 0.36422122f, 0.40758243f, -0.02538558f, 0.27831233f, 
    -0.11611295f, 0.10491752f, -0.10717872f, 0.09156422f, -0.00672001f, -0.06649770f, 0.19429347f, -0.06073368f, 
    0.14713570f, 0.10870124f, 0.38524154f, 0.23430750f, -0.06078308f, 0.10944122f, 0.06852587f, 0.04660885f, 
    0.05189365f, 0.05859556f, 0.00152275f, -0.00274473f, 0.05593986f, 0.04410565f, -0.05494675f, -0.20000850f, 
    0.10919376f, 0.01314402f, -0.22489513f, -0.06335054f, 0.09330035f, 0.10131550f, -0.03326339f, 0.19883661f, 
    0.13897148f, 0.12099789f, 0.00326730f, 0.09440897f, -0.12754397f, -0.01985540f, 0.15052135f, 0.06017428f, 
    0.12242371f, -0.04027891f, -0.12371807f, -0.08293260f, -0.05655648f, -0.18392460f, -0.18180847f, -0.05165152f, 
    -0.14693661f, 0.08936029f, 0.13367060f, -0.08895662f, 0.11052988f, 0.00504626f, 0.12536260f, 0.04885093f, 
    -0.11026114f, -0.20162842f, -0.04870397f, -0.02035325f, 0.13123277f, 0.06283715f, -0.11946423f, -0.15672596f, 
    -0.03209631f, -0.02644949f, -0.00492396f, -0.22145319f, 0.11956766f, 0.03611723f, -0.25575033f, 0.29241470f, 
    -0.19339360f, -0.01564139f, 0.06072100f, 0.05944083f, 0.06235529f, -0.10691158f, -0.01506089f, -0.15227051f, 
    0.11000092f, 0.20105116f, 0.01973987f, 0.24371435f, -0.00025998f, -0.05864324f, 0.10844343f, -0.03251868f, 
    0.12344901f, 0.04245266f, -0.06399224f, 0.14091890f, -0.10713194f, 0.05341550f, -0.04256894f, 0.27122107f, 
    0.11464032f, 0.03984197f, -0.04441909f, 0.12814157f, 0.19248709f, 0.15813129f, 0.10278168f, 0.32498935f, 
    0.00583337f, -0.04176050f, -0.08840541f, 0.29883125f, 0.06697958f, 0.04179887f, -0.00557833f, -0.00173123f, 
    0.12356829f, 0.09400634f, 0.01220129f, 0.18745409f, -0.01424433f, -0.08952962f, 0.12702255f, 0.13124679f, 
    0.05238122f, -0.03656986f, -0.13200453f, -0.15299635f, 0.01994888f, 0.09786545f, 0.05984737f, 0.03730824f, 
    0.02520031f, 0.16201983f, -0.09847052f, 0.19548197f, -0.16368881f, 0.08556309f, -0.10707878f, -0.20829922f, 
    0.03316046f, -0.04311916f, 0.14693977f, 0.13754523f, 0.31596556f, 0.08509530f, -0.12836678f, -0.27663749f, 
    -0.19890673f, -0.01715662f, 0.03490059f, -0.16779651f, -0.08154282f, 0.09831823f, 0.05292804f, -0.06659719f, 
    0.49635893f, -0.08021687f, 0.21446276f, 0.27802527f, -0.13289195f, -0.06639527f, -0.06461009f, -0.10078017f, 
    0.22679107f, 0.04192813f, -0.06347289f, 0.13833681f, 0.04116275f, -0.31430629f, -0.04671079f, -0.54682279f, 
    -0.18371364f, 0.01356287f, -0.01403962f, -0.25292140f, -0.17947105f, -0.08168857f, -0.00566070f, -0.09984539f, 
    -0.29863492f, -0.20625173f, -0.02660714f, -0.09983946f, -0.06852751f, 0.12633325f, -0.08997664f, -0.14978643f, 
    -0.25759655f, -0.17429696f, -0.23943663f, -0.57443225f, -0.01636006f, -0.03683557f, 0.07157531f, 0.18417802f, 
    0.07251545f, -0.02092281f, 0.05973339f, -0.09237095f, 0.10610516f, 0.06230207f, 0.04423096f, 0.19587746f, 
    0.04834408f, 0.20220159f, -0.02555504f, 0.05295668f, -0.20599413f, 0.01743888f, 0.09770487f, 0.07528252f, 
    0.14204812f, 0.22134137f, 0.16137131f, 0.11141683f, 0.05967569f, -0.01103042f, 0.18359965f, -0.05165076f, 
    0.12608700f, -0.02318376f, 0.14568432f, 0.09876995f, -0.12241514f, -0.10077662f, -0.08785725f, 0.04461779f, 
    -0.00384884f, -0.09457523f, 0.11474119f, -0.11743709f, 0.00585396f, 0.26034993f, -0.06405032f, 0.24996915f, 
    -0.03282302f, -0.13098453f, 0.02186215f, -0.08293167f, -0.30585852f, 0.26587725f, 0.05597598f, 0.09220650f, 
    -0.07084565f, 0.03062239f, -0.03323459f, -0.07168496f, -0.10815609f, 0.12567784f, -0.18706119f, 0.03557610f, 
    -0.00692738f, -0.29977435f, 0.21803443f, -0.35111511f, 0.03037654f, -0.01141909f, -0.12250914f, -0.08897579f, 
    0.01895460f, -0.10262647f, -0.05955404f, 0.15893692f, 0.04809508f, 0.03935613f, 0.25426945f, 0.12357695f, 
    -0.18700574f, -0.09846188f, -0.12074715f, -0.05149040f, -0.03484193f, 0.02684613f, 0.04022079f, -0.02646767f, 
    -0.38185126f, 0.00230877f, 0.07055776f, 0.21251248f, 0.05846369f, 0.06547511f, -0.01184350f, 0.05181518f, 
    -0.13894306f, -0.06623840f, -0.08199377f, -0.06703540f, 0.10949342f, -0.09545775f, 0.00488770f, 0.07109682f, 
    -0.07603157f, 0.05132060f, -0.02350002f, 0.10020266f, 0.10825616f, 0.05699247f, -0.10446113f, 0.14200991f, 
    -0.30478585f, 0.24947017f, -0.03860017f, 0.15633382f, 0.07106634f, -0.14022902f, 0.16336370f, -0.00942243f, 
    -0.02065639f, 0.03298959f, -0.01307221f, -0.00814720f, -0.30733255f, -0.12238776f, 0.03121514f, 0.12258972f, 
    -0.01566323f, -0.00581488f, 0.02778363f, 0.15526463f, 0.11473683f, 0.14172137f, 0.02766124f, 0.21638653f, 
    0.12129731f, -0.08517814f, 0.09774072f, -0.21992299f, -0.05018136f, -0.20137821f, -0.06129901f, -0.08074981f, 
    -0.11276755f, 0.11451150f, 0.01030603f, 0.24426499f, 0.02004744f, 0.12372851f, 0.03501420f, 0.32545716f, 
    0.11161663f, 0.02963176f, 0.13621219f, -0.00407280f, -0.18108271f, -0.26521736f, -0.19818951f, -0.17260884f, 
    -0.10966890f, 0.05149936f, -0.01812101f, -0.16114537f, -0.06765165f, 0.05820009f, 0.33300084f, 0.11910452f, 
    0.08189402f, 0.27651295f, 0.02538463f, 0.08492433f, 0.15471512f, 0.15528415f, -0.07749664f, -0.03812689f, 
    -0.03824265f, -0.11597564f, -0.01874877f, -0.26395500f, -0.11253615f, -0.00609868f, -0.08137237f, -0.31466368f, 
    -0.07133825f, -0.06505148f, -0.02631018f, -0.04664418f, -0.15510379f, 0.01119577f, -0.07151432f, -0.17049325f, 
    0.13514982f, 0.02818975f, 0.03234841f, 0.07819454f, -0.16416092f, -0.07382403f, -0.08722990f, 0.02616740f, 
    0.03586027f, -0.04351756f, -0.13446701f, 0.03612229f, 0.00711621f, 0.04913663f, 0.14118551f, 0.14548649f, 
    0.37568516f, 0.04255295f, -0.08236346f, -0.11982558f, -0.00204338f, 0.06232021f, -0.07305777f, -0.09258851f, 
    -0.00747510f, -0.16488546f, -0.01587665f, -0.02298452f, 0.24393459f, 0.27696466f, -0.00875821f, 0.46297741f, 
    -0.08165548f, 0.00436996f, 0.18237647f, 0.01835141f, 0.19111218f, -0.07844567f, -0.00515769f, 0.19975244f, 
    -0.21844740f, -0.19964679f, -0.02416015f, -0.02569829f, 0.02477247f, 0.01169021f, -0.09927060f, 0.06127263f, 
    -0.10303715f, -0.15231958f, 0.08029814f, 0.10607776f, 0.02425458f, 0.05850122f, 0.09503622f, 0.31437287f, 
    -0.00687231f, -0.05051490f, 0.12211073f, 0.15356822f, 0.09629316f, -0.05329681f, 0.05557976f, -0.16246770f, 
    -0.19509715f, 0.33251545f, 0.04836528f, 0.23247965f, 0.10785986f, 0.12394218f, -0.03052144f, 0.05926233f, 
    -0.09671357f, -0.31461686f, -0.09100874f, -0.33430544f, 0.07992468f, 0.12947591f, 0.49811593f, 0.05356891f, 
    0.20025049f, 0.07527705f, -0.00566452f, 0.18795010f, -0.00026908f, -0.08696657f, -0.05455192f, -0.09666398f, 
    0.00721043f, 0.03507690f, -0.05059925f, 0.02585832f, 0.01205540f, 0.01144243f, 0.00786715f, -0.04808833f, 
    0.00059629f, -0.00994829f, -0.01265879f, -0.00579241f, -0.01599020f, 0.00538950f, -0.01007993f, 0.03311955f, 
    -0.05057139f, -0.01736426f, -0.03447556f, -0.00209793f, -0.01996821f, -0.04431349f, 0.04229101f, -0.00355307f, 
    0.03597590f, -0.00441089f, -0.04876086f, -0.04772562f, -0.03457820f, -0.02794717f, 0.01174184f, 0.01846721f, 
    0.02074932f, -0.00856171f, 0.02856400f, 0.00809857f, -0.01422878f, 0.02735340f, -0.01165221f, -0.02751518f, 
    0.01777731f, -0.04096547f, -0.01631645f, -0.04688554f, -0.00651966f, 0.00632705f, -0.00195453f, -0.01018937f, 
    -0.00353979f, 0.01778801f, -0.03646493f, -0.00047401f, -0.01415608f, -0.05126729f, -0.00845680f, 0.02259719f, 
    -0.00826104f, -0.04638685f, -0.03652685f, -0.05478491f, -0.00275563f, 0.01168628f, -0.02351385f, 0.03699312f, 
    -0.04400985f, -0.05802681f, -0.01829762f, 0.01890901f, -0.00763844f, -0.01226894f, 0.01645941f, -0.00583262f, 
    0.01053905f, 0.02487276f, -0.02620686f, -0.02244671f, -0.05297489f, -0.02768138f, -0.04897813f, 0.03293316f, 
    0.01962395f, -0.04497417f, -0.03874581f, -0.05838991f, 0.03807502f, 0.01075421f, -0.01908872f, -0.05019175f, 
    -0.02391874f, 0.01657681f, -0.02704259f, -0.00822747f, 0.01875237f, -0.00137153f, 0.03369354f, 0.03661568f, 
    0.04626986f, -0.01093452f, 0.04303894f, -0.01036294f, -0.02169388f, 0.04244514f, 0.03341526f, 0.01969571f, 
    -0.01662867f, -0.05403304f, 0.02648471f, -0.06168851f, -0.05837142f, -0.03214421f, 0.03187232f, -0.04658772f, 
    -0.00279629f, -0.00731530f, -0.04972419f, 0.00955010f, -0.00635904f, -0.03824856f, -0.03620430f, 0.03719246f, 
    0.01670486f, -0.00743037f, -0.04384718f, -0.03626607f, 0.02040427f, 0.00865381f, 0.01128231f, -0.02443003f, 
    0.04342237f, 0.01786453f, 0.04608324f, 0.00275487f, -0.00993104f, -0.01869906f, 0.00908610f, -0.01635184f, 
    -0.02492451f, -0.03464955f, 0.01886296f, 0.00263572f, -0.02728254f, 0.03445013f, -0.01219393f, -0.02512550f, 
    0.05408840f, -0.01037550f, 0.00494309f, -0.02950908f, 0.02824008f, -0.05463848f, -0.02784697f, -0.04950728f, 
    0.02415010f, -0.03804084f, 0.03132317f, 0.02720588f, 0.02754840f, 0.01938131f, 0.00156678f, -0.02165346f, 
    0.03707348f, -0.06031087f, -0.00469110f, -0.04291366f, -0.00886005f, 0.04101176f, -0.03134596f, -0.04047521f, 
    -0.01108169f, 0.00324826f, -0.01295570f, 0.00209944f, -0.04402493f, 0.01997864f, -0.00778361f, -0.00043664f, 
    0.01449329f, -0.02028411f, 0.01343913f, 0.00734847f, 0.03389952f, -0.03246562f, -0.06059687f, 0.00906007f, 
    -0.04818889f, -0.01757831f, -0.03560635f, -0.03504122f, -0.05096334f, -0.04018309f, 0.01303357f, -0.05241549f, 
    -0.03940919f, -0.01818308f, 0.00552916f, -0.02396389f, 0.01372662f, 0.01769926f, 0.01868395f, 0.02230695f, 
    0.01657850f, 0.00849026f, -0.02743823f, 0.02993469f, -0.06076471f, 0.01773244f, -0.04759654f, 0.02933841f, 
    0.01753146f, -0.02836937f, -0.01437600f, -0.03650893f, -0.05018141f, -0.02485400f, 0.03502809f, -0.04765755f, 
    -0.04888239f, -0.01165055f, 0.00563012f, -0.00778471f, -0.03876406f, 0.00488464f, 0.00404883f, -0.01069429f, 
    0.03810581f, -0.04733615f, 0.00416383f, -0.04066955f, 0.03260962f, 0.01443307f, -0.05362689f, 0.02511817f, 
    -0.03946172f, -0.03639404f, 0.02260093f, 0.00052406f, -0.03957161f, 0.00224181f, 0.00192032f, 0.00458345f, 
    -0.03544942f, 0.01620378f, 0.01258622f, 0.01778200f, -0.05581127f, -0.01691136f, -0.04271390f, 0.01155365f, 
    -0.00069088f, 0.00905093f, -0.03962145f, -0.04136316f, -0.03634630f, -0.00904685f, -0.04362092f, -0.02508098f, 
    -0.00729499f, -0.05583261f, 0.03528660f, 0.00184586f, -0.03263989f, -0.05894131f, 0.00451851f, -0.03608411f, 
    -0.04742261f, -0.04774196f, -0.04517712f, 0.01675253f, 0.01005553f, 0.00663746f, 0.04642793f, 0.02755708f, 
    -0.03197959f, -0.01762276f, -0.00666765f, -0.00084839f, -0.00490166f, 0.04455037f, -0.03144350f, 0.00257333f, 
    -0.01339913f, -0.04114431f, 0.02206980f, -0.02744944f, 0.01755269f, -0.00137334f, 0.04388122f, 0.02086347f, 
    0.02676219f, -0.01692913f, 0.03752602f, 0.01150591f, -0.02348832f, 0.03294760f, 0.03726783f, 0.03900632f, 
    -0.01264720f, -0.00840493f, 0.03775809f, -0.04875387f, 0.00233700f, -0.05245916f, -0.04835413f, -0.01068009f, 
    -0.00936061f, 0.00934171f, -0.04190967f, -0.02056678f, -0.03710881f, -0.00665921f, -0.02605271f, 0.02189393f, 
    0.04969672f, 0.01908044f, 0.03760654f, 0.01945000f, -0.01685697f, 0.02173126f, -0.02274753f, -0.04539357f, 
    -0.01077222f, -0.05016000f, 0.01369247f, 0.02683469f, 0.03077925f, -0.00759556f, 0.02223227f, 0.01606300f, 
    -0.01677969f, 0.05597011f, -0.05516058f, -0.01907974f, 0.04591912f, -0.03172553f, 0.04346244f, 0.01688716f, 
    -0.03108492f, 0.03231072f, -0.03486462f, 0.01204867f, 0.00294673f, -0.01623184f, 0.02251144f, -0.00112160f, 
    -0.05314837f, -0.04356762f, 0.00481366f, -0.01869643f, 0.03176426f, -0.03098332f, 0.03454952f, 0.03022715f, 
    0.01515170f, -0.02055239f, -0.03304460f, -0.05572734f, -0.00773345f, -0.01224531f, 0.00470541f, -0.03289150f, 
    0.02754218f, -0.00893745f, 0.00098847f, 0.01214752f, -0.01672815f, 0.01067601f, -0.02849345f, -0.00645147f, 
    -0.00560477f, -0.02453758f, 0.01886308f, 0.00251508f, 0.02606639f, 0.04390498f, 0.02288543f, 0.02953770f, 
    -0.04258273f, -0.00898605f, 0.01589708f, 0.03611930f, -0.02008818f, -0.02599761f, -0.02588844f, -0.00729681f, 
    -0.01718293f, -0.12286830f, 0.09071815f, 0.04690286f, 0.13052249f, 0.00372742f, 0.03347011f, -0.15305887f, 
    0.05864783f, 0.06841427f, -0.05384427f, -0.07219175f, -0.08028012f, 0.40833229f, -0.04567190f, -0.11855445f, 
    -0.07081265f, -0.01115388f, 0.07764620f, 0.12811464f, -0.04125750f, 0.10309294f, -0.06860811f, -0.18066081f, 
    -0.00428277f, 0.05185081f, -0.08118448f, 0.34896550f, 0.14002249f, 0.03294874f, -0.01094088f, -0.03397721f, 
    0.26823369f, 0.03617169f, 0.05084919f, -0.06172743f, 0.14253496f, 0.08820458f, -0.02907994f, 0.07216176f, 
    -0.01825791f, 0.08599668f, 0.02979879f, -0.04959217f, 0.12161446f, 0.11144511f, -0.07465297f, -0.19010900f, 
    0.55940270f, 0.15297939f, -0.03212439f, 0.23130883f, 0.02271985f, 0.00637163f, 0.01172842f, 0.02466218f, 
    -0.12617597f, -0.06574325f, 0.03553703f, 0.03688562f, -0.22060080f, 0.28245589f, 0.05900024f, -0.21668938f, 
    0.02471913f, 0.01360138f, -0.08328217f, 0.22145145f, 0.04278953f, 0.20971505f, 0.06564081f, 0.02286197f, 
    -0.55567682f, 0.06254081f, 0.01436166f, 0.08142903f, 0.05671285f, -0.10332429f, 0.02942899f, 0.20053637f, 
    0.07780796f, -0.03198133f, -0.02665874f, -0.08259629f, 0.02451519f, -0.05953959f, -0.14892672f, 0.08777679f, 
    0.01936261f, -0.03614214f, 0.01175026f, 0.02099529f, -0.00977361f, 0.09063839f, 0.15959556f, 0.08151222f, 
    0.12995732f, -0.02678311f, -0.06988782f, -0.06140466f, 0.13502850f, 0.05117445f, 0.06289580f, 0.11384854f, 
    0.01583530f, 0.07931478f, 0.01631392f, 0.12010211f, -0.22485295f, -0.11497233f, 0.11695301f, 0.10697632f, 
    -0.00619310f, -0.01651419f, 0.10900962f, -0.16004276f, 0.15968154f, 0.06159763f, -0.00294188f, 0.19854279f, 
    -0.11591803f, -0.07536528f, -0.16612178f, -0.40567219f, 0.01611238f, 0.02376943f, -0.00687918f, 0.05558942f, 
    0.13640124f, -0.06798977f, -0.09765676f, 0.06895823f, -0.13485293f, 0.07251535f, 0.23470870f, 0.12238373f, 
    -0.03437695f, 0.15941218f, 0.05437277f, 0.16744605f, 0.06633423f, -0.00002692f, -0.10536713f, -0.09999383f, 
    -0.05676735f, 0.04162794f, -0.16690758f, -0.20610832f, -0.05029526f, 0.01822756f, -0.01731087f, 0.04826146f, 
    0.04418358f, 0.01335260f, 0.07407987f, -0.01590356f, -0.03982308f, 0.27871794f, 0.34385920f, 0.34472555f, 
    0.08338573f, -0.11434693f, 0.14288114f, 0.16993524f, 0.17230962f, 0.07217515f, 0.07781944f, 0.14306001f, 
    -0.07085456f, -0.04650581f, -0.09710091f, 0.02526007f, -0.08674918f, 0.07314771f, 0.03185079f, 0.03522454f, 
    -0.07140604f, 0.04595163f, 0.10536718f, 0.03010615f, 0.15636806f, 0.29963902f, 0.18732104f, 0.38839352f, 
    -0.07771450f, 0.02577413f, 0.04280950f, -0.00799328f, 0.08362391f, -0.07817936f, 0.00429050f, 0.15946046f, 
    0.04471537f, 0.04928903f, -0.23362358f, 0.18178819f, 0.02056327f, -0.06795923f, 0.16353700f, -0.03080034f, 
    -0.03248771f, 0.06929648f, -0.00487150f, -0.00338935f, -0.12715164f, -0.07080823f, 0.05652676f, -0.04153695f, 
    0.07655824f, -0.02589194f, -0.10582221f, 0.19227348f, 0.00435921f, 0.15028925f, -0.08166461f, 0.13168426f, 
    -0.50693351f, 0.29612726f, 0.30624205f, -0.00314849f, 0.01391657f, 0.09899316f, 0.04240663f, -0.02623678f, 
    -0.00864892f, -0.05603325f, 0.10249277f, -0.01770622f, -0.37806031f, -0.19338262f, -0.21410017f, 0.00884274f, 
    -0.05111160f, -0.14990434f, 0.03775742f, 0.04356710f, -0.02436193f, -0.00156062f, 0.06425653f, 0.05900690f, 
    0.20931078f, -0.00859840f, -0.16407081f, -0.19320954f, 0.12091527f, -0.06355064f, 0.06655263f, 0.01313817f, 
    -0.07779212f, 0.03836955f, 0.03971605f, 0.02783428f, -0.03958831f, 0.03088223f, 0.10431123f, -0.20197238f, 
    0.03713797f, -0.19302464f, 0.02163538f, -0.14766707f, -0.06877252f, 0.06046022f, 0.17861542f, 0.01134126f, 
    -0.03334820f, 0.11684453f, -0.14538357f, -0.04475938f, 0.04497151f, -0.06981896f, 0.12365966f, 0.00133479f, 
    -0.03376914f, 0.04282403f, 0.14623673f, -0.02365940f, -0.17461094f, 0.12813681f, -0.06026306f, -0.10278906f, 
    -0.05165304f, -0.03007861f, -0.06422516f, -0.01831396f, 0.09265144f, 0.13222922f, 0.18908167f, 0.07488050f, 
    0.12532453f, 0.09738569f, -0.27437624f, -0.11952373f, -0.03070844f, -0.03418099f, -0.01482275f, -0.07749330f, 
    -0.15015975f, 0.20113124f, 0.20764400f, -0.07123104f, -0.21860303f, -0.21524303f, 0.17687944f, 0.15722264f, 
    0.29582325f, -0.08372021f, 0.09159135f, 0.11294740f, -0.25995603f, -0.01254859f, 0.03370783f, -0.00879434f, 
    -0.02983669f, -0.04582460f, -0.29866880f, -0.10820079f, -0.03293703f, -0.06515840f, -0.04263885f, -0.03945538f, 
    -0.00185621f, 0.16549447f, -0.13134527f, 0.14083153f, 0.00975748f, 0.05008401f, 0.21164505f, 0.24228121f, 
    0.13852604f, 0.00713195f, 0.09065009f, -0.08403595f, 0.06370626f, -0.01698877f, 0.10063736f, 0.07825246f, 
    -0.22209366f, -0.12597917f, -0.08001835f, 0.24175332f, -0.03475789f, 0.01071044f, -0.02675621f, 0.05785235f, 
    0.02938283f, 0.05982963f, 0.11077128f, 0.15154345f, -0.30096918f, -0.12866408f, 0.22159055f, 0.24194978f, 
    0.12037755f, 0.04182520f, -0.09804921f, -0.06991556f, 0.04174956f, -0.05811338f, 0.03545600f, 0.00156515f, 
    -0.24190149f, -0.01156499f, 0.27394006f, -0.15092437f, -0.02045189f, 0.18909104f, -0.03150634f, 0.05432029f, 
    0.03729532f, 0.03860602f, 0.02493666f, 0.05583934f, -0.16283858f, 0.18523167f, 0.52350205f, 0.20946817f, 
    0.08518215f, 0.22395669f, -0.15628120f, -0.02077463f, -0.01065100f, -0.06122151f, -0.03308503f, -0.05813594f, 
    -0.02294558f, 0.14520927f, 0.10831078f, 0.11615231f, -0.09821135f, -0.00713357f, 0.12155057f, -0.12663192f, 
    0.01839842f, -0.01542182f, -0.18658853f, 0.08676850f, -0.30131632f, -0.11496124f, 0.10413557f, -0.12258876f, 
    -0.01006604f, 0.09094212f, -0.03505644f, 0.07455913f, 0.12362821f, 0.03133000f, 0.02147926f, 0.16401929f, 
    0.08140179f, 0.14230123f, 0.03627515f, 0.13744763f, 0.08806945f, 0.00964773f, 0.01762662f, 0.03791486f, 
    0.09452213f, 0.05415299f, 0.03377579f, 0.07022656f, 0.18782260f, -0.09451932f, -0.04748293f, -0.13002457f, 
    0.06213884f, 0.02571689f, -0.02111846f, 0.02160157f, -0.11485877f, -0.01045960f, 0.09440032f, 0.03372710f, 
    -0.27116969f, 0.06107065f, -0.04413833f, -0.18001534f, 0.28656679f, -0.01308491f, 0.29194185f, 0.05199807f, 
    -0.02950617f, 0.05362706f, 0.05792423f, 0.05289191f, -0.08048507f, 0.03803685f, -0.05266858f, 0.23863526f, 
    0.10154072f, -0.11565628f, 0.01849274f, 0.12226027f, 0.04066588f, 0.06897669f, 0.20838594f, 0.08911552f, 
    -0.04747153f, 0.19494756f, 0.26102901f, 0.14939897f, -0.05987101f, -0.16501588f, -0.09943380f, -0.03489789f, 
    0.03917379f, 0.04937065f, -0.04814719f, -0.00198901f, 0.23801760f, -0.06757083f, -0.21586445f, 0.21379088f, 
    0.31479529f, 0.06589556f, 0.05326854f, 0.25191733f, 0.05685402f, -0.10522307f, -0.03977354f, 0.02088717f, 
    0.18482035f, -0.00186693f, 0.07643597f, -0.01205983f, 0.09203698f, 0.04084862f, 0.26356849f, 0.30378982f, 
    0.09777737f, 0.08128742f, -0.06467580f, -0.02367072f, -0.12882181f, -0.17477423f, 0.06568424f, 0.25525331f, 
    0.15846522f, -0.03925902f, 0.14967526f, -0.07903799f, 0.09628135f, 0.17560890f, 0.12287405f, 0.21086596f, 
    -0.34327883f, -0.22616023f, -0.02366261f, 0.02858176f, 0.10922692f, -0.15569670f, -0.10385648f, 0.00816038f, 
    0.21959673f, 0.07081832f, 0.08147316f, 0.14052023f, 0.46769723f, -0.23483559f, -0.12133189f, -0.27851218f, 
    -0.04115506f, 0.08329079f, -0.01390451f, 0.08433517f, 0.00406045f, -0.02247299f, -0.02008716f, -0.00501458f, 
    -0.13640481f, -0.02220699f, -0.22816914f, -0.20868668f, 0.10399047f, -0.04285207f, 0.07128400f, 0.13309222f, 
    0.13606390f, 0.14838231f, 0.16714630f, 0.05599910f, -0.17670351f, 0.19165683f, 0.31505629f, -0.34657454f, 
    -0.03593775f, -0.08010119f, 0.12077976f, 0.24134623f, 0.02849088f, 0.15659839f, -0.07182647f, 0.00223340f, 
    -0.00916794f, -0.02284487f, -0.14959338f, 0.02320278f, 0.16655734f, 0.01181598f, 0.16336408f, -0.03051808f, 
    0.07132921f, 0.05745474f, -0.09371436f, 0.00534524f, 0.00141281f, 0.26211751f, 0.37754387f, -0.06221854f, 
    -0.10092431f, -0.10407171f, 0.15320680f, 0.25298503f, 0.09936027f, 0.00370111f, -0.02729224f, -0.08176227f, 
    0.02242054f, -0.00578652f, -0.16774161f, -0.09436672f, 0.00367162f, -0.01331428f, 0.02075794f, 0.01753842f, 
    0.12793645f, 0.05378950f, 0.03614398f, -0.09705488f, -0.11876298f, 0.14621495f, 0.04924129f, 0.33304486f, 
    -0.02783189f, -0.14678460f, 0.20357995f, -0.02912073f, 0.06208672f, 0.06439170f, -0.00559025f, 0.05336795f, 
    -0.18528971f, -0.11708746f, 0.25062326f, -0.14453825f, -0.00593012f, 0.22472297f, -0.03324171f, 0.18083653f, 
    -0.18692976f, -0.13249967f, -0.14324015f, 0.07587794f, -0.28088444f, 0.06972943f, 0.10912102f, 0.10351361f, 
    -0.11718850f, -0.07552259f, -0.11143374f, 0.13234042f, 0.01588871f, -0.04884415f, 0.02041889f, 0.00223807f, 
    -0.18937802f, 0.03403834f, -0.29904863f, -0.04588549f, 0.06717188f, -0.04857910f, 0.01840595f, -0.17425950f, 
    0.04926044f, 0.01279256f, 0.07345392f, -0.00959321f, -0.17837375f, 0.09855264f, 0.10155801f, 0.14501098f, 
    0.07630490f, -0.04590802f, 0.07680405f, -0.02998471f, -0.01779314f, -0.02671874f, -0.08954266f, -0.03924114f, 
    -0.02190737f, 0.09983616f, 0.07983851f, -0.12461851f, -0.04234741f, -0.01957921f, 0.08355655f, -0.02035181f, 
    0.08285326f, -0.00868988f, -0.00195075f, 0.19288284f, -0.17314777f, -0.09553766f, 0.03634327f, 0.04296264f, 
    0.04812720f, 0.04054610f, -0.07269961f, 0.02272336f, 0.05126213f, 0.09527265f, -0.03332318f, -0.09037959f, 
    0.13574962f, -0.14332867f, -0.24581109f, -0.19000582f, 0.06856519f, -0.07640046f, 0.00597763f, -0.25102437f, 
    -0.01172198f, 0.07762142f, 0.24411248f, 0.12715255f, -0.32491294f, -0.12434330f, 0.26115760f, 0.09881835f, 
    -0.08391882f, -0.14885710f, 0.11640090f, -0.13802773f, -0.03627704f, -0.03405440f, 0.01939179f, 0.12632839f, 
    -0.28457081f, -0.05864824f, -0.19341078f, 0.20201012f, 0.10649574f, -0.01329723f, 0.15225153f, -0.04801461f, 
    0.16883583f, -0.05734944f, 0.05030835f, -0.01657489f, 0.13597901f, 0.15761459f, -0.07818013f, 0.11561627f, 
    0.01914400f, -0.00324429f, 0.08948444f, -0.11580439f, 0.04836186f, -0.07657214f, -0.02044620f, 0.05850153f, 
    -0.21928991f, -0.03975168f, 0.18596943f, 0.36168009f, -0.08401076f, -0.06160073f, -0.09549789f, 0.04606675f, 
    0.03893756f, -0.08684465f, 0.02656145f, -0.02317040f, -0.02982673f, 0.21743648f, 0.37640312f, 0.15245438f, 
    -0.12466257f, -0.22202356f, -0.07603835f, 0.02340296f, -0.04674321f, -0.18649510f, -0.06453929f, -0.07942776f, 
    0.23113255f, 0.03244502f, -0.16872300f, -0.57590890f, -0.04104072f, 0.03267257f, -0.08923040f, 0.05098254f, 
    -0.00383183f, -0.08390831f, 0.11596652f, -0.09707262f, -0.05333484f, -0.18790878f, 0.41719317f, -0.29041862f, 
    -0.22304259f, 0.14175224f, -0.14523025f, 0.16344766f, -0.01821562f, -0.13163416f, -0.01080863f, -0.08493619f, 
    0.00375053f, 0.00888247f, -0.03480662f, -0.04885029f, 0.01323795f, -0.01044992f, 0.02074774f, 0.01038404f, 
    0.02821854f, 0.00495119f, 0.02088963f, 0.04680641f, 0.01942872f, 0.00893236f, -0.04422612f, 0.02926498f, 
    0.02786516f, -0.01080207f, 0.00681286f, -0.00337683f, -0.04819509f, 0.03683234f, -0.05018562f, -0.05677554f, 
    -0.02114708f, 0.01505887f, -0.03235985f, 0.02384804f, -0.03305290f, -0.02723519f, -0.01114900f, 0.02531511f, 
    0.04126154f, -0.04898690f, -0.00949050f, -0.02427726f, -0.05289621f, -0.05420978f, -0.05550480f, 0.03299860f, 
    -0.00369970f, -0.04715710f, -0.04050609f, 0.04224074f, -0.02415804f, 0.00482877f, -0.02549224f, -0.04475065f, 
    -0.01079605f, -0.01605497f, -0.02787176f, 0.02516269f, -0.04856687f, 0.00569742f, -0.03601477f, -0.01778340f, 
    0.01957840f, -0.01695754f, 0.01240674f, -0.04298581f, 0.02636857f, 0.00410720f, 0.01448506f, -0.05222204f, 
    -0.05515445f, -0.01884809f, -0.01168444f, 0.03144142f, -0.04445612f, -0.01955785f, -0.03175566f, -0.01646494f, 
    -0.03069404f, 0.02430488f, -0.00894300f, 0.00318475f, 0.03237697f, -0.03957256f, -0.01127548f, -0.04093855f, 
    0.04022453f, 0.03623634f, -0.03440460f, -0.05166303f, 0.04014716f, 0.00187399f, 0.02274536f, 0.03030981f, 
    -0.05313726f, 0.02170574f, 0.03066738f, -0.01597056f, -0.02993615f, 0.00775999f, -0.05567011f, -0.00993749f, 
    0.02247919f, 0.00541671f, -0.01685109f, -0.05724640f, 0.00613394f, -0.04307615f, 0.01619137f, -0.04029110f, 
    -0.01753944f, -0.02603359f, -0.00510724f, 0.02316377f, 0.04005893f, -0.02768148f, -0.04253853f, 0.02349302f, 
    -0.03610089f, 0.04258249f, -0.05321520f, 0.03057796f, 0.01731402f, 0.01488055f, -0.01432726f, -0.02997832f, 
    -0.03039555f, 0.00098871f, -0.01798097f, 0.03281088f, -0.02398503f, -0.05140585f, 0.00956065f, -0.05683565f, 
    0.02730037f, -0.00673207f, -0.04603063f, 0.04371813f, 0.03586205f, -0.02365096f, -0.02274636f, -0.03118874f, 
    0.02008581f, 0.01241825f, -0.04365276f, 0.03911074f, 0.00513704f, -0.00907423f, 0.01276688f, -0.04720756f, 
    -0.03927920f, 0.03043937f, -0.00055053f, -0.05089741f, 0.02617593f, -0.05419196f, -0.03319535f, 0.02458273f, 
    -0.01679541f, -0.00415279f, -0.03403561f, -0.02434761f, -0.02922232f, -0.04333642f, -0.01945187f, 0.02877541f, 
    0.01396962f, 0.02849481f, -0.01789303f, 0.01795396f, -0.01255213f, -0.03332232f, -0.03262096f, 0.02430549f, 
    0.02643051f, -0.01833970f, -0.01609552f, -0.01089914f, -0.02194388f, -0.00298401f, -0.03746755f, 0.03235998f, 
    -0.00809660f, -0.01559209f, -0.00942125f, -0.02885521f, -0.05213116f, -0.04938082f, -0.03767873f, 0.00232327f, 
    -0.02025571f, 0.01865735f, 0.01288066f, 0.00268561f, -0.02147705f, 0.02674372f, -0.00539910f, -0.00126598f, 
    -0.02826282f, -0.05386841f, 0.03370520f, -0.02232348f, -0.03080503f, 0.02154516f, 0.00768262f, 0.04041314f, 
    -0.04376111f, 0.02740683f, 0.00975757f, -0.04336989f, 0.01004386f, -0.03668671f, 0.02453190f, -0.05816209f, 
    0.03544639f, -0.01158970f, -0.05135962f, -0.00595041f, -0.04549238f, -0.02893576f, -0.00910489f, 0.03018093f, 
    -0.05745728f, -0.02065665f, -0.02277833f, 0.00802888f, -0.00569457f, 0.03407047f, -0.03945298f, -0.02158082f, 
    0.01736162f, 0.03274603f, 0.03411533f, 0.03534872f, -0.01973171f, 0.03063250f, -0.02760415f, -0.02171175f, 
    0.03525498f, -0.05391923f, 0.04132453f, -0.02998680f, 0.03352913f, -0.00286274f, 0.02949495f, -0.04462248f, 
    0.00512091f, 0.00816518f, -0.05430891f, -0.01197817f, 0.00424203f, 0.00703917f, 0.03920976f, -0.02833873f, 
    0.00360080f, 0.00075149f, 0.01113431f, -0.04327512f, -0.03512937f, -0.01087138f, -0.02309176f, -0.05664040f, 
    -0.02867442f, -0.03839884f, -0.02516975f, -0.00832298f, -0.05884960f, -0.02830466f, -0.01165160f, 0.00581246f, 
    -0.03861104f, -0.04113924f, 0.02987286f, -0.03996226f, -0.02523204f, -0.03292315f, 0.03260325f, 0.03264981f, 
    -0.00197361f, 0.01451771f, -0.04517641f, -0.04834444f, 0.03347585f, -0.01947115f, -0.04480587f, 0.00871960f, 
    -0.03259116f, 0.03598386f, -0.00069203f, -0.03101381f, -0.02339274f, 0.01123137f, 0.01030408f, 0.04030780f, 
    -0.03191753f, -0.04822179f, 0.03612522f, 0.00639762f, 0.04178137f, -0.01445793f, -0.00052320f, 0.01513628f, 
    0.01417706f, -0.00213024f, -0.05262537f, 0.02070651f, 0.01556103f, -0.04157105f, 0.01975363f, 0.03486677f, 
    -0.00031280f, -0.05635328f, -0.01948085f, 0.01567173f, -0.04885285f, 0.04240703f, 0.03966849f, -0.05606599f, 
    -0.00245144f, 0.00343863f, 0.00344330f, -0.03956541f, -0.04429080f, -0.02183355f, -0.01538433f, -0.00145037f, 
    0.01157551f, -0.00632060f, 0.01320665f, -0.02728712f, -0.02668565f, 0.00953327f, 0.01757996f, -0.00350831f, 
    -0.04451212f, 0.02658969f, -0.05095464f, 0.04194294f, -0.00823196f, 0.03238491f, -0.03918401f, -0.02712163f, 
    -0.04339571f, -0.02889817f, 0.02383332f, -0.00223432f, -0.04586502f, 0.00759763f, -0.01941563f, 0.02348029f, 
    -0.04175925f, 0.04278079f, -0.00700918f, 0.02213915f, 0.03738960f, -0.02030533f, 0.03226543f, -0.02718383f, 
    -0.00536115f, 0.01698412f, -0.03676543f, -0.02053608f, -0.01331078f, -0.04389740f, -0.05459036f, 0.01150243f, 
    0.04225400f, -0.01355386f, -0.01831802f, -0.02907656f, 0.00031717f, -0.03151426f, 0.00184473f, -0.04640227f, 
    0.02087327f, -0.03294009f, -0.01958464f, -0.02085753f, -0.04981832f, 0.02227710f, -0.00610794f, 0.01882133f, 
    0.02278249f, -0.03623418f, 0.00979568f, -0.02631507f, 0.03302437f, -0.04308285f, -0.00483790f, -0.01112695f, 
    -0.09378634f, -0.00781110f, 0.01925603f, 0.37173855f, 0.13167188f, -0.06012761f, 0.02733624f, -0.05005699f, 
    0.09998184f, -0.18479481f, -0.07589122f, 0.10559256f, 0.03057243f, 0.12531161f, -0.00438230f, 0.28542411f, 
    0.02853093f, 0.07158701f, -0.07710139f, -0.08887896f, 0.09220732f, -0.02148580f, 0.21467941f, 0.36620981f, 
    -0.17948984f, -0.12353221f, -0.09834424f, 0.13491935f, -0.00196687f, 0.01226983f, 0.02275051f, -0.04372114f, 
    -0.00623536f, 0.07943224f, -0.09790055f, 0.20699818f, 0.01939640f, 0.22568172f, 0.13414356f, -0.18492439f, 
    -0.05761369f, -0.04072409f, -0.11614691f, 0.02225844f, 0.10110893f, 0.04208506f, 0.25277162f, 0.21990301f, 
    0.00026257f, -0.13259171f, 0.03772561f, 0.03721580f, -0.14678310f, 0.22784293f, 0.07190990f, -0.09829253f, 
    0.10939907f, -0.00603145f, 0.08371916f, 0.14578682f, 0.36363506f, -0.18724205f, -0.07240744f, -0.11881693f, 
    -0.05199471f, 0.00397193f, 0.09421298f, -0.00833588f, -0.22265275f, -0.17914592f, -0.06704039f, 0.15008590f, 
    0.33392945f, -0.17034355f, -0.04952291f, 0.20305072f, -0.16636965f, -0.07701972f, 0.04537600f, -0.07067998f, 
    0.05133057f, 0.09962641f, 0.08733694f, 0.12729779f, 0.10442936f, -0.11489403f, 0.09638473f, -0.14036557f, 
    0.04587284f, 0.08475234f, 0.02174225f, 0.18533823f, -0.03612196f, -0.14249864f, -0.18675950f, -0.06166010f, 
    -0.01373138f, 0.04852705f, 0.08317522f, -0.00868883f, 0.06793228f, 0.05521740f, -0.09724669f, -0.12780641f, 
    -0.02224255f, -0.08241032f, -0.07868903f, -0.23240620f, -0.07067980f, -0.32433370f, -0.19883066f, 0.09251587f, 
    0.16209984f, 0.07584772f, -0.07795025f, -0.05513261f, -0.00482115f, 0.03907267f, 0.10895223f, -0.10924939f, 
    0.03196218f, 0.09105013f, -0.07533056f, 0.00942413f, -0.01440036f, 0.01000461f, 0.00075130f, -0.07696481f, 
    -0.02199877f, 0.07928041f, 0.09653281f, -0.05703354f, 0.27898332f, 0.46035340f, 0.19942664f, -0.06272593f, 
    -0.22727299f, -0.18319003f, -0.02935670f, 0.00876421f, 0.00083667f, -0.02251213f, 0.10140232f, 0.03722222f, 
    0.13489409f, 0.03617403f, 0.20572594f, 0.09571793f, -0.06003967f, 0.07306591f, -0.01191882f, 0.13059936f, 
    0.05411636f, 0.10708979f, 0.01974731f, -0.13515523f, -0.04119322f, -0.20512328f, 0.02335582f, 0.04720486f, 
    0.09275670f, -0.05979408f, -0.12824792f, -0.03081722f, -0.12219536f, 0.05933423f, -0.11331051f, 0.01104236f, 
    0.00378318f, 0.11893976f, 0.13358638f, 0.07747732f, 0.04322971f, 0.12107257f, 0.05466681f, 0.03675526f, 
    0.09232441f, -0.06252255f, -0.06114425f, 0.06705654f, -0.21383496f, -0.05860313f, 0.19668144f, -0.06368096f, 
    -0.04410478f, -0.06462647f, -0.00366429f, -0.02255873f, 0.05992361f, 0.13775159f, 0.12132806f, -0.05480631f, 
    -0.04255472f, -0.04371576f, 0.27968752f, 0.04223995f, -0.05434364f, 0.01415673f, -0.05899085f, -0.03083251f, 
    -0.03317432f, -0.08104416f, -0.05906040f, -0.14329651f, 0.17391194f, -0.23807517f, -0.03233761f, 0.41278768f, 
    0.00271059f, -0.00838370f, -0.01781798f, -0.01049481f, 0.12540352f, -0.02501398f, 0.02648855f, 0.01661123f, 
    0.37163916f, 0.28689703f, -0.04710602f, 0.33914137f, -0.03466691f, -0.08174706f, 0.14121346f, 0.01353484f, 
    -0.05839726f, 0.07346138f, 0.03195081f, 0.07097925f, 0.00376293f, -0.02361551f, 0.29087612f, 0.44710383f, 
    -0.10656973f, -0.06193588f, -0.03647644f, -0.01219251f, 0.06155308f, 0.07364708f, 0.03994570f, 0.14772865f, 
    0.12090479f, 0.24695881f, 0.10234079f, -0.01157091f, -0.05814137f, -0.07481513f, -0.03252346f, 0.03591996f, 
    0.10088834f, -0.07320879f, -0.18237112f, 0.16805749f, -0.00050557f, 0.10480820f, -0.04151870f, 0.14207105f, 
    0.09694806f, 0.06533772f, -0.05460808f, 0.23129441f, -0.12433297f, -0.16130137f, -0.13514258f, 0.02406465f, 
    0.04299654f, 0.00772986f, 0.03102458f, -0.21704903f, -0.09478327f, 0.32424363f, 0.00029276f, 0.13074255f, 
    0.00866438f, 0.19069569f, -0.04092960f, -0.11671633f, 0.16849346f, 0.07618111f, -0.13321120f, 0.10876191f, 
    0.20764349f, 0.06028840f, 0.03482470f, -0.00069585f, -0.21626675f, -0.04557348f, -0.09697755f, -0.10195502f, 
    -0.07966761f, -0.27619538f, 0.29512680f, -0.10408343f, -0.03482212f, 0.08278330f, 0.02761233f, -0.15172459f, 
    0.35418472f, 0.00246333f, 0.06888815f, 0.11692800f, 0.21678968f, 0.01105664f, -0.07904430f, 0.12030073f, 
    -0.13584323f, 0.02359555f, -0.11084226f, -0.09112313f, -0.09592777f, -0.04170404f, 0.10848093f, 0.14557680f, 
    0.13061416f, 0.15430547f, 0.23391806f, 0.21085422f, -0.00194729f, 0.11628304f, -0.05730544f, -0.04684575f, 
    -0.00722931f, -0.26959750f, 0.06128605f, -0.03958739f, 0.00239094f, 0.01132485f, 0.03472189f, 0.03187745f, 
    0.01299850f, 0.03018686f, -0.04731537f, 0.02778125f, 0.08735444f, -0.07532101f, 0.05472553f, 0.01257035f, 
    -0.05779660f, -0.01440981f, -0.02434354f, -0.03628607f, -0.00299543f, -0.11638089f, -0.13929400f, -0.05257368f, 
    0.03084468f, -0.03071679f, -0.05099699f, -0.10508972f, 0.02989920f, -0.11316477f, 0.12513044f, 0.15382825f, 
    -0.22313379f, 0.04100145f, 0.04925400f, 0.04148567f, 0.03970015f, -0.16606785f, -0.06447648f, -0.13043799f, 
    0.38926160f, 0.04168554f, 0.16832311f, -0.10147016f, -0.05429038f, -0.08139221f, -0.08314962f, -0.05258514f, 
    -0.08362596f, -0.16239634f, 0.08642726f, -0.17549320f, 0.16152981f, 0.23807947f, 0.15752903f, 0.15743132f, 
    -0.11897597f, -0.09168033f, -0.01312645f, 0.13520464f, -0.07959945f, -0.15243493f, -0.05022366f, -0.10209954f, 
    0.01952529f, 0.22522582f, 0.09744515f, -0.27153412f, -0.04000071f, -0.01725969f, -0.09397870f, -0.14178778f, 
    0.18307671f, -0.03435748f, -0.00720048f, 0.03628049f, -0.16453595f, -0.03996086f, 0.16691749f, -0.03612901f, 
    0.01254579f, 0.07800860f, 0.17445335f, 0.03193179f, 0.14500676f, 0.12183598f, 0.12201316f, 0.28573000f, 
    0.11107438f, 0.02008951f, -0.07720523f, 0.06840229f, 0.09685814f, 0.05161142f, 0.01590610f, -0.04013530f, 
    0.12825468f, 0.01425203f, 0.08133882f, 0.01482242f, 0.36443099f, -0.11975423f, 0.00634048f, -0.02139674f, 
    0.00827999f, 0.07001600f, 0.07365666f, -0.03741778f, 0.13262726f, 0.16473213f, -0.09537533f, 0.00484203f, 
    -0.03143831f, 0.33108261f, -0.22582731f, 0.06635382f, 0.05414857f, 0.00509059f, 0.07656941f, 0.01029209f, 
    0.02009529f, 0.03420547f, 0.05035650f, 0.08926838f, 0.07837053f, 0.23600654f, 0.08925284f, 0.04852020f, 
    -0.04800332f, -0.04921220f, -0.15639558f, 0.13368875f, -0.01367167f, 0.18280596f, 0.05956165f, 0.03979618f, 
    -0.04230943f, 0.35688701f, 0.43814519f, 0.13058010f, -0.10885403f, -0.13394167f, -0.08121766f, 0.06302118f, 
    0.06957079f, 0.05182667f, 0.11257407f, 0.04763725f, 0.07460292f, -0.01401843f, -0.11650483f, 0.09239381f, 
    0.11921627f, 0.04443341f, 0.00376838f, 0.04592724f, 0.02781949f, -0.12575538f, 0.05889707f, -0.13277085f, 
    -0.08168004f, -0.04524891f, -0.06557044f, 0.00985424f, -0.06398421f, 0.03219761f, 0.15946685f, 0.21830103f, 
    -0.11098851f, 0.02588827f, -0.02691051f, 0.07167584f, -0.30417249f, -0.11575504f, 0.03243190f, 0.05440661f, 
    0.09403357f, 0.05270996f, 0.12707530f, -0.15440509f, 0.09400319f, 0.10973676f, 0.06186942f, 0.14813729f, 
    -0.10803550f, 0.05543588f, 0.06131912f, 0.09392212f, -0.06428688f, -0.06716660f, -0.07254757f, 0.04334676f, 
    0.23924555f, 0.06185066f, 0.19218470f, 0.13890494f, 0.10785740f, -0.35979012f, -0.17090434f, -0.05181845f, 
    0.07311168f, 0.09335743f, 0.08804162f, 0.02362220f, 0.06966978f, -0.01558840f, -0.01506161f, 0.01854047f, 
    0.01503561f, -0.14108083f, -0.21397170f, -0.20820111f, -0.08339965f, 0.01615731f, -0.00617475f, 0.00673837f, 
    0.13910012f, -0.10465130f, -0.06487441f, -0.20354898f, 0.08237637f, 0.29392022f, -0.03994910f, -0.23924142f, 
    -0.11930235f, -0.09732515f, 0.19816510f, 0.08076644f, 0.10810557f, 0.17601380f, -0.04750117f, 0.11507042f, 
    0.13952903f, -0.23270272f, -0.07629905f, -0.01429331f, 0.02172776f, -0.05283760f, -0.02619667f, -0.10323597f, 
    0.03304045f, -0.00316403f, 0.03130733f, -0.02487973f, 0.10974989f, 0.26014608f, 0.14419234f, -0.00764391f, 
    -0.14825347f, -0.10653908f, 0.03187133f, 0.26959139f, 0.06872893f, 0.11607664f, -0.01751462f, -0.03272936f, 
    0.19060358f, -0.19612256f, -0.33894148f, -0.01803378f, -0.05720838f, 0.12165000f, 0.16991271f, 0.05549396f, 
    0.07935610f, 0.00192566f, -0.01014886f, -0.11016100f, -0.20577511f, 0.07945178f, -0.09204448f, -0.17717062f, 
    -0.03481762f, 0.00432373f, 0.05795772f, 0.04754512f, 0.01602144f, 0.09472928f, 0.01643605f, 0.07473010f, 
    -0.36840704f, 0.05500991f, 0.09716199f, -0.19317523f, 0.15045065f, -0.03847534f, 0.00004070f, 0.03248575f, 
    0.05275427f, 0.05524164f, -0.03683682f, 0.00533750f, -0.50767195f, -0.16682792f, -0.15300879f, -0.22000125f, 
    -0.11491449f, -0.00082506f, -0.06605751f, 0.07617794f, 0.00844772f, 0.03007849f, 0.02448247f, 0.06894776f, 
    -0.07106401f, -0.17217183f, -0.09200434f, -0.01512318f, 0.01591440f, 0.11564089f, 0.04767419f, -0.06565462f, 
    0.00921324f, 0.01242658f, -0.05736581f, -0.03770221f, 0.06234303f, 0.13030158f, 0.03915656f, 0.03446826f, 
    0.02821876f, 0.03503901f, 0.15168239f, -0.09646742f, 0.13168560f, -0.06915092f, -0.05002120f, -0.16499490f, 
    0.05333178f, 0.21622701f, 0.03748184f, -0.04508907f, 0.07866207f, -0.07711709f, 0.26600930f, 0.01849838f, 
    0.09634969f, 0.10144702f, 0.07509167f, 0.14051251f, -0.02535949f, 0.15708762f, 0.26800653f, -0.06440194f, 
    -0.01412811f, -0.08682039f, -0.15448403f, -0.09502625f, -0.04894588f, 0.04492755f, -0.02129912f, -0.08278795f, 
    0.08047845f, 0.05082933f, -0.33613428f, 0.03803041f, -0.07598786f, -0.14349245f, 0.12338094f, -0.00794381f, 
    0.04466282f, 0.19344175f, 0.00407305f, 0.05352426f, -0.43494394f, -0.22986092f, 0.01585097f, -0.04742564f, 
    -0.09723028f, -0.06589972f, -0.02591294f, 0.00925764f, 0.01517815f, -0.03493171f, 0.02678195f, 0.14298345f, 
    0.11184490f, 0.00726805f, -0.22603415f, 0.03287129f, -0.10677871f, -0.01413887f, -0.01565644f, -0.06823640f, 
    0.07506440f, -0.03831141f, -0.03391298f, -0.02047777f, 0.15780187f, -0.02805433f, -0.04564135f, 0.15847522f, 
    -0.04019228f, 0.02701146f, 0.02582645f, -0.09644748f, -0.00659397f, 0.03864595f, 0.00820358f, -0.01153665f, 
    -0.29040807f, -0.18110500f, 0.01777831f, 0.17356449f, 0.01373063f, 0.02513915f, -0.12491854f, 0.09733976f, 
    -0.02026368f, -0.05054837f, 0.08598438f, 0.06691980f, -0.05031460f, 0.20702970f, 0.02034462f, -0.08964568f, 
    0.11262959f, -0.09435081f, 0.09297219f, 0.02725783f, 0.03142989f, 0.04823354f, -0.04352143f, -0.08442387f, 
    0.25957003f, 0.12468904f, -0.25266019f, -0.22612619f, -0.06908706f, -0.00810822f, 0.08049998f, 0.03589415f, 
    -0.00546411f, -0.04586407f, -0.00590862f, -0.03927504f, -0.07458162f, -0.27935737f, 0.34366220f, -0.09781352f, 
    0.24508636f, 0.13107979f, -0.01157953f, 0.07051321f, -0.00308918f, 0.05127370f, -0.01903495f, -0.02664462f, 
    0.03486345f, -0.02037170f, -0.03347373f, -0.00582384f, 0.01524502f, 0.03570651f, 0.01301971f, 0.02558749f, 
    -0.05248484f, 0.00201913f, 0.01978913f, -0.01762197f, -0.03602275f, -0.00799420f, 0.04823320f, -0.04242829f, 
    -0.01933680f, 0.03830146f, 0.03298297f, -0.01667671f, -0.03590066f, 0.03955441f, -0.02654449f, -0.01498100f, 
    -0.04580275f, 0.03124194f, 0.04438050f, -0.00984169f, -0.01489498f, 0.02376643f, -0.02003547f, 0.01979637f, 
    -0.01523442f, -0.05711714f, -0.00796216f, -0.03941706f, -0.04192618f, 0.03140690f, 0.01887182f, -0.04648674f, 
    -0.02871887f, 0.00506237f, 0.03760423f, -0.03101882f, -0.02890095f, 0.00521302f, -0.01595838f, -0.00646939f, 
    -0.00517520f, -0.03726562f, -0.02683000f, -0.03158893f, 0.01453426f, -0.04221577f, -0.02667386f, -0.02509293f, 
    -0.02749539f, 0.01775659f, -0.00901103f, -0.01967803f, 0.03244450f, 0.02365778f, -0.05525388f, 0.03482999f, 
    -0.01819477f, -0.03574133f, -0.01768439f, -0.02299049f, -0.01109984f, -0.03958729f, 0.00764009f, 0.03802273f, 
    -0.01988125f, 0.03451967f, -0.04869959f, -0.00971169f, 0.02778165f, -0.02049664f, -0.05472737f, -0.05434243f, 
    -0.01446705f, 0.05111205f, 0.03935022f, -0.04064026f, 0.00622684f, -0.01788916f, 0.03591864f, -0.02941727f, 
    0.02150751f, -0.04406269f, 0.01683756f, -0.04132888f, 0.04216707f, -0.02522031f, -0.05095248f, -0.03874816f, 
    0.02444229f, -0.00364495f, -0.05619952f, -0.03059386f, -0.01939921f, 0.03339017f, 0.00749692f, 0.03441220f, 
    0.03222627f, 0.01088460f, -0.04951394f, -0.03878967f, 0.03160652f, -0.01167181f, 0.03874544f, 0.00262463f, 
    0.00989742f, 0.00833488f, -0.01375289f, 0.01697193f, 0.02276357f, -0.03335032f, 0.03391857f, 0.03170114f, 
    -0.00087518f, 0.01858499f, 0.01936510f, -0.01733544f, 0.04031746f, -0.04121545f, 0.00977572f, -0.01949994f, 
    0.00883713f, 0.00788074f, 0.00127989f, -0.03883507f, -0.05695621f, -0.04168785f, 0.01228275f, -0.01352373f, 
    0.01888786f, -0.04346454f, 0.00181097f, 0.02043316f, 0.01131589f, 0.03633954f, -0.00805558f, -0.03892395f, 
    0.01763383f, 0.00232187f, -0.02033084f, -0.01392851f, 0.03597710f, 0.00039046f, 0.02101585f, -0.02136271f, 
    0.00076928f, -0.04250721f, -0.01493445f, -0.00246375f, -0.00733151f, 0.03970508f, -0.04104439f, -0.02079230f, 
    -0.04849708f, -0.04780646f, -0.00101586f, -0.00555641f, 0.03328514f, -0.05600498f, 0.04338737f, -0.03029433f, 
    0.02238001f, -0.02016010f, -0.02150295f, 0.02613284f, 0.00094575f, -0.01946806f, -0.04819709f, -0.03383677f, 
    -0.00548390f, -0.03158716f, -0.05293548f, -0.03222235f, 0.03050034f, 0.02358460f, -0.03023049f, -0.02393239f, 
    -0.01061227f, 0.01811027f, 0.05073921f, -0.04704621f, -0.04860405f, -0.02716116f, 0.03938155f, 0.03621708f, 
    -0.05554466f, -0.04452613f, 0.04321522f, -0.02358065f, -0.03174577f, 0.00590269f, 0.01563688f, 0.02065495f, 
    -0.04421553f, -0.02731908f, 0.03363976f, -0.03849604f, -0.00760959f, -0.04851496f, -0.02951014f, -0.02549323f, 
    -0.00769284f, -0.00397739f, -0.00197168f, -0.01683627f, -0.04350451f, 0.04679504f, -0.04335941f, 0.00812276f, 
    0.00377903f, -0.00984692f, -0.04091619f, 0.02388605f, -0.03406916f, 0.00580660f, 0.01997636f, -0.02786211f, 
    -0.05415051f, -0.04256496f, 0.02566884f, 0.04202070f, -0.03216949f, -0.01378350f, -0.00069838f, 0.01962478f, 
    -0.04645829f, 0.03647671f, -0.00293674f, -0.01701873f, 0.03041477f, -0.03664681f, -0.03329587f, 0.00633238f, 
    -0.03122451f, -0.02835650f, -0.05603426f, -0.03251708f, -0.01178918f, 0.04240901f, -0.03188634f, 0.03086445f, 
    0.03255570f, 0.03914954f, 0.01847010f, 0.02584338f, -0.00086306f, -0.00152194f, -0.00307194f, -0.01607336f, 
    0.03745589f, 0.04131965f, -0.01658693f, 0.05586761f, 0.03842263f, 0.01094820f, -0.03908673f, 0.02639692f, 
    0.00000360f, -0.04898822f, -0.02914087f, 0.01550699f, -0.02802411f, 0.04525429f, 0.02345671f, -0.03314964f, 
    -0.01160568f, -0.03794395f, 0.00739851f, 0.02069803f, 0.02491761f, -0.00010245f, -0.03853505f, 0.04308021f, 
    0.05004815f, 0.02501632f, 0.02457250f, 0.00211166f, 0.03591520f, -0.02178662f, -0.01593514f, 0.02687434f, 
    -0.00618467f, -0.03581848f, -0.00988171f, 0.03060126f, 0.00619467f, 0.04335672f, 0.03393031f, 0.02625151f, 
    0.03040732f, -0.00609594f, -0.04589668f, -0.05268552f, -0.03600192f, -0.04398894f, -0.04324992f, -0.00017454f, 
    -0.04782262f, -0.03154581f, -0.02485286f, 0.03649212f, -0.02488359f, -0.00327801f, 0.00852016f, 0.00390310f, 
    0.01255029f, 0.01446941f, -0.05372448f, -0.02472054f, 0.03844206f, -0.02313522f, 0.00955928f, -0.03573067f, 
    -0.00598490f, -0.03447890f, -0.03224107f, 0.00103590f, -0.01594795f, 0.04440917f, -0.03917788f, 0.00218559f, 
    -0.03401324f, -0.04964476f, 0.01421580f, -0.01362315f, -0.00419825f, -0.00527788f, 0.05194334f, 0.03585077f, 
    -0.00961684f, 0.02666463f, -0.00252864f, 0.01231856f, -0.01893006f, -0.04401224f, -0.01605206f, 0.03125127f, 
    0.03645515f, -0.05506800f, 0.00204902f, 0.03079293f, 0.00448440f, -0.03145954f, -0.01291549f, -0.04021060f, 
    0.05055098f, -0.03406377f, 0.03587412f, -0.04043794f, -0.00492153f, 0.04590883f, 0.03649628f, 0.00920524f, 
    0.00191171f, -0.02232013f, 0.04105008f, 0.00006400f, -0.03670296f, -0.03625178f, -0.03536770f, -0.00320217f, 
    -0.04744903f, -0.04556814f, -0.05560232f, -0.02472986f, 0.02872930f, -0.03745040f, -0.02757716f, -0.01828747f, 
    -0.04116258f, 0.02512252f, -0.04247120f, 0.03867625f, -0.00272915f, -0.01798216f, -0.02392277f, 0.00546309f, 
    0.11818284f, 0.22714753f, 0.21915664f, -0.18225835f, 0.13439895f, 0.19079383f, 0.06263459f, 0.10588805f, 
    0.11538804f, 0.14171235f, 0.06105689f, -0.06527262f, -0.09892359f, -0.21272880f, 0.21539077f, -0.03431085f, 
    -0.04623637f, 0.01809387f, -0.10853030f, 0.07414271f, -0.06189533f, -0.11467850f, -0.00891823f, -0.04460822f, 
    0.23476250f, -0.07777144f, 0.06796020f, -0.00844993f, 0.08401021f, 0.07771562f, 0.08684882f, -0.13202187f, 
    0.07372733f, -0.01078242f, 0.00492454f, -0.10851078f, 0.23891823f, -0.03604609f, -0.05326779f, -0.17470713f, 
    0.12171230f, 0.04913677f, 0.06439214f, 0.05827239f, 0.16261718f, -0.01048369f, -0.10443942f, 0.02983404f, 
    -0.49137104f, 0.25762871f, -0.25173914f, 0.03831724f, 0.04641926f, -0.03558471f, -0.00243202f, 0.05942491f, 
    0.11267665f, 0.15241154f, 0.06416165f, -0.09645284f, 0.30701253f, -0.02748754f, -0.17149338f, 0.09854653f, 
    -0.10354159f, -0.06421870f, 0.00377523f, -0.18116212f, 0.00396043f, 0.11488017f, 0.01065238f, -0.17305301f, 
    0.30461982f, -0.20862702f, 0.11101519f, -0.21599683f, -0.07290795f, -0.04078527f, -0.00603203f, -0.13078661f, 
    0.18859719f, -0.08963092f, 0.00558469f, 0.04124682f, 0.12992445f, -0.17105231f, 0.12338328f, -0.14225416f, 
    0.07242943f, -0.08425356f, 0.05693898f, -0.08788037f, -0.04747494f, -0.18819249f, 0.16520786f, -0.18591972f, 
    -0.06810926f, -0.02182483f, 0.07735814f, 0.00882283f, -0.14188741f, 0.00079100f, 0.02656675f, -0.08574494f, 
    -0.03033652f, -0.02432207f, -0.02996408f, 0.00655890f, -0.05352688f, 0.10067698f, 0.26170790f, 0.03929592f, 
    0.03452743f, -0.02600102f, -0.03995946f, 0.03669209f, 0.11393620f, 0.00060596f, -0.12988207f, 0.03184684f, 
    0.22124223f, 0.10362699f, 0.11907580f, 0.21653037f, -0.11560636f, -0.05146550f, 0.01181872f, 0.02526568f, 
    0.07530409f, -0.00165168f, 0.00332570f, -0.01981110f, 0.27946752f, -0.24706194f, -0.04578606f, 0.05490670f, 
    0.07584759f, 0.06801246f, 0.00337611f, 0.03551604f, -0.02316080f, -0.01139204f, 0.12424319f, -0.04968872f, 
    0.15029190f, 0.07814384f, 0.18533127f, 0.12324930f, 0.02339537f, -0.02688250f, -0.06132796f, -0.03850031f, 
    0.13777579f, -0.11460188f, -0.05900357f, 0.08027700f, -0.24123597f, 0.35177425f, -0.35320941f, -0.24763070f, 
    -0.14000466f, 0.20657720f, 0.03645751f, -0.00063155f, 0.08916174f, 0.17683275f, -0.01876658f, 0.04933983f, 
    0.16461051f, -0.17216338f, 0.22394016f, -0.12114836f, 0.03287736f, -0.06948587f, -0.11187219f, 0.03771587f, 
    0.05974244f, -0.02476567f, 0.00135302f, 0.06240363f, 0.01534465f, -0.07807762f, -0.18887644f, -0.29961753f, 
    0.05029450f, -0.05650545f, -0.02152520f, -0.01621936f, 0.05047975f, 0.08558707f, -0.04430945f, 0.10111197f, 
    -0.17754936f, 0.08596091f, -0.06471560f, 0.17992383f, 0.15497436f, 0.14554109f, -0.11834213f, 0.21300718f, 
    0.12391222f, -0.01209918f, 0.04816443f, 0.02138168f, 0.12729852f, -0.12996650f, 0.26345879f, -0.08936226f, 
    0.06057253f, 0.25091669f, 0.11204790f, -0.01490748f, 0.02092629f, -0.01704250f, 0.08294603f, -0.05983995f, 
    -0.06502609f, -0.02178289f, -0.19120321f, -0.22550340f, 0.11692935f, 0.03244348f, 0.00559361f, 0.18515636f, 
    0.09951019f, 0.05575883f, 0.11614500f, -0.06721418f, -0.31041288f, 0.13617523f, 0.11018287f, -0.30325705f, 
    0.06317364f, -0.06590482f, -0.08878438f, 0.12470884f, 0.01571806f, -0.05664161f, -0.10003239f, -0.15156099f, 
    0.07899453f, -0.07708923f, 0.23637038f, 0.11061307f, 0.07400888f, -0.02142285f, 0.00711582f, 0.02152851f, 
    0.00099469f, -0.01768136f, -0.03265268f, 0.02167221f, -0.03215639f, 0.00086138f, -0.06887908f, 0.15305740f, 
    0.01034286f, 0.18653791f, 0.27002844f, -0.07445630f, 0.02599501f, -0.11038467f, -0.04979125f, 0.02598604f, 
    0.21824086f, 0.17931297f, 0.04699425f, 0.04251421f, 0.02485570f, -0.07284405f, 0.17509970f, -0.12797487f, 
    0.14981782f, -0.09786258f, -0.11980171f, 0.24408901f, 0.32145411f, -0.10647377f, 0.24159078f, -0.02347865f, 
    -0.07992122f, -0.02876462f, 0.00384013f, 0.04077413f, 0.10384224f, -0.01790431f, -0.05093305f, -0.01247998f, 
    -0.00733322f, 0.11029264f, -0.15164697f, 0.33293653f, 0.09325821f, -0.09484116f, 0.07769008f, 0.07887362f, 
    0.11378199f, 0.00254155f, 0.03244244f, 0.12251768f, -0.47152966f, 0.10986003f, -0.41176033f, -0.06475062f, 
    -0.08381048f, -0.11136316f, -0.07830036f, 0.09498286f, 0.15503335f, -0.04923455f, -0.11370606f, -0.03050084f, 
    0.20001639f, -0.20332050f, -0.25543573f, 0.10402726f, -0.05238039f, -0.01226656f, 0.07224760f, -0.04661826f, 
    0.07301534f, 0.11290563f, 0.11432418f, -0.12842335f, -0.09819131f, 0.14032415f, -0.23648818f, 0.06641786f, 
    0.08398147f, -0.03508171f, 0.09123050f, 0.07309396f, 0.04013588f, 0.04869437f, -0.01536661f, -0.00429551f, 
    -0.30750346f, -0.25882199f, 0.13517505f, -0.04031085f, 0.09538846f, 0.06284570f, 0.04968856f, 0.04255029f, 
    -0.04642409f, -0.00912120f, 0.01188467f, 0.13877384f, 0.02047938f, 0.46963373f, 0.03001263f, -0.07730254f, 
    0.16105095f, -0.02476404f, 0.15559085f, 0.05328084f, -0.07694516f, 0.03349485f, -0.05321657f, -0.04953718f, 
    0.02964205f, 0.45238858f, -0.49498788f, 0.33321574f, -0.02306179f, -0.04590769f, 0.15995640f, -0.03858303f, 
    0.05110393f, -0.00966493f, -0.01946916f, -0.03090239f, 0.22408038f, -0.00629254f, 0.11130141f, -0.40328440f, 
    0.25564912f, 0.07096668f, 0.31091735f, 0.04496989f, 0.06730586f, 0.03462045f, -0.00201122f, 0.04794025f, 
    0.11277841f, 0.08572027f, -0.07806109f, 0.01227552f, -0.00116525f, 0.00800564f, 0.08096189f, -0.07460669f, 
    -0.05807638f, -0.04899091f, -0.19166547f, -0.09906138f, -0.12407709f, 0.19395053f, -0.05146077f, 0.10581372f, 
    -0.02058283f, 0.10722057f, 0.17811377f, 0.08794727f, 0.16929720f, 0.13574810f, 0.09241658f, 0.32923651f, 
    -0.07769028f, 0.08070032f, -0.19220564f, 0.20354509f, -0.00186997f, -0.04786212f, -0.04704376f, -0.02787083f, 
    0.13326931f, 0.06001715f, 0.19344853f, 0.24439397f, -0.07457152f, -0.03273347f, 0.11298288f, 0.15973987f, 
    -0.02869495f, -0.00093636f, 0.01770601f, -0.07644188f, 0.10110686f, 0.29554832f, -0.01596140f, 0.09730571f, 
    0.63062716f, 0.21747309f, 0.03202116f, 0.38790873f, -0.04719371f, 0.03256267f, -0.01729080f, 0.03922256f, 
    -0.14560881f, -0.11628991f, 0.11138245f, 0.05373101f, 0.06336449f, 0.26612246f, 0.25130954f, -0.36077702f, 
    0.11144058f, 0.10004057f, -0.19166096f, 0.22501789f, -0.07244571f, -0.01561657f, 0.10024466f, 0.14239357f, 
    -0.16915385f, 0.28110424f, 0.29484561f, 0.15623814f, 0.00267352f, -0.02872579f, 0.06935709f, 0.21907766f, 
    -0.02304502f, 0.02093846f, 0.04019042f, -0.03035034f, 0.08715493f, 0.05055311f, -0.13892834f, -0.08135373f, 
    -0.14018629f, 0.02478273f, 0.04908039f, -0.02136900f, 0.00006103f, 0.05019011f, -0.00749156f, -0.02124903f, 
    0.06229949f, -0.00130966f, -0.05295385f, -0.08864432f, -0.03437105f, -0.01890969f, -0.04923621f, 0.07123194f, 
    0.00858785f, -0.08032548f, -0.03816126f, -0.09513795f, -0.10600690f, -0.04058449f, -0.11417609f, -0.03454427f, 
    -0.05569110f, 0.00810643f, 0.15163569f, -0.15561725f, 0.01442094f, 0.04062823f, 0.17344402f, 0.19158533f, 
    -0.12684017f, 0.09880450f, -0.13987575f, -0.39575610f, 0.01090409f, 0.07699656f, 0.03222502f, 0.16099295f, 
    0.31302753f, 0.12585500f, 0.18313909f, 0.14801233f, -0.24189867f, 0.02247177f, 0.22510418f, 0.18352045f, 
    0.02731160f, -0.00742860f, 0.15193939f, 0.05564554f, 0.09056894f, -0.00759437f, -0.04389521f, -0.07057214f, 
    0.01848975f, -0.07557096f, -0.09963215f, -0.27233285f, -0.00430579f, 0.04221693f, -0.06065316f, 0.06432943f, 
    -0.10635144f, -0.07912133f, 0.02161867f, -0.11952052f, -0.00768215f, 0.24357469f, 0.28131968f, 0.38301495f, 
    -0.16181959f, -0.19597043f, -0.04497676f, 0.10695884f, 0.02262648f, 0.06228796f, 0.17471655f, 0.07222441f, 
    0.01303354f, -0.13902353f, -0.06833699f, 0.08854837f, -0.02628228f, 0.06972807f, 0.02349165f, -0.07988309f, 
    -0.04354778f, -0.02831664f, -0.00351726f, -0.02578740f, 0.14353313f, 0.27556261f, 0.28129756f, 0.46234846f, 
    -0.15480766f, -0.07951220f, -0.08076851f, 0.22301389f, -0.02800298f, 0.15596963f, 0.07389214f, -0.03789553f, 
    0.24654864f, -0.00572434f, -0.14739604f, 0.00820749f, -0.06929681f, 0.03030373f, 0.21411823f, -0.01311679f, 
    -0.07057384f, 0.17010970f, -0.01432775f, -0.06080215f, -0.11210596f, 0.11603428f, -0.23106837f, -0.21346179f, 
    -0.05777706f, -0.00492838f, -0.01847780f, 0.08375280f, -0.01435763f, 0.11135443f, -0.20662749f, 0.03817311f, 
    -0.53848124f, 0.18707253f, 0.31765115f, 0.15911114f, 0.03130823f, 0.05253735f, 0.14415790f, -0.12833905f, 
    0.05323923f, -0.02539655f, 0.02015714f, -0.00244771f, -0.29006785f, -0.30283695f, -0.35454297f, 0.10384089f, 
    0.00770162f, 0.14374644f, 0.09366243f, 0.06365598f, -0.13016769f, -0.05640531f, 0.01354938f, 0.26276419f, 
    0.07227438f, -0.09530225f, -0.09663042f, -0.11056250f, 0.10388187f, 0.00183017f, 0.16142051f, -0.02429773f, 
    -0.12139771f, 0.06266196f, 0.00518248f, 0.07638648f, 0.13771540f, 0.15779185f, 0.09167136f, 0.02390854f, 
    0.05754701f, -0.08636960f, -0.01007410f, -0.10858914f, 0.06810416f, -0.03438495f, -0.01254055f, -0.13293481f, 
    -0.19682898f, 0.03735222f, -0.09546381f, -0.06430296f, 0.15450527f, 0.04022306f, 0.34369457f, 0.24710245f, 
    0.01397793f, 0.25649974f, 0.15575908f, 0.04510147f, -0.07516206f, 0.29093802f, -0.02180445f, -0.08522951f, 
    0.13135475f, -0.04516808f, -0.00667626f, -0.16423775f, -0.07881263f, 0.16416988f, 0.04108069f, -0.03757291f, 
    -0.05376043f, -0.03742795f, -0.24913716f, -0.20121251f, -0.13225409f, 0.02300971f, -0.04647451f, -0.08089199f, 
    0.02166045f, 0.17210269f, 0.18063352f, 0.05658827f, 0.08421633f, -0.16600013f, 0.24377446f, 0.15584296f, 
    0.29853952f, 0.08341095f, 0.02349938f, 0.18572637f, -0.23924679f, -0.12707403f, 0.07244086f, 0.17307976f, 
    0.31773955f, 0.14974675f, -0.16514128f, -0.09663860f, 0.02775272f, 0.07992608f, -0.02450070f, 0.01205066f, 
    -0.03027373f, 0.06005305f, -0.20610400f, 0.18049026f, 0.14516467f, -0.01083484f, 0.17078382f, 0.37022394f, 
    0.01334099f, 0.08728335f, 0.04227161f, 0.04065124f, 0.09875035f, 0.14715201f, 0.16205952f, 0.09030305f, 
    -0.03873867f, -0.11962165f, -0.23473307f, 0.04121481f, -0.10526263f, -0.00420200f, -0.21327284f, -0.03489266f, 
    -0.13093387f, -0.02672301f, 0.08484405f, 0.04711702f, -0.05278654f, -0.13970421f, 0.05593204f, 0.17204045f, 
    0.09780032f, 0.05176142f, -0.02401224f, 0.06487423f, 0.06693853f, -0.10162222f, -0.07567704f, -0.16974248f, 
    -0.27180427f, 0.02107954f, 0.38928524f, -0.13886400f, -0.03703005f, 0.07735250f, -0.20369078f, -0.00947914f, 
    -0.08926001f, -0.10321663f, -0.14181672f, -0.11666683f, -0.12166344f, 0.02107832f, 0.40113196f, 0.36425695f, 
    0.12013496f, 0.00358740f, -0.18292087f, 0.04148062f, -0.09072947f, -0.03744610f, -0.03666976f, -0.14596720f, 
    0.10510012f, 0.05210637f, 0.00720696f, 0.21711658f, -0.08227678f, 0.10316326f, 0.16543165f, 0.21418735f, 
    -0.06259616f, 0.13105632f, 0.04125343f, 0.02172632f, 0.20289342f, -0.00803727f, 0.01883712f, 0.01430427f, 
    0.03457116f, -0.00711720f, -0.07681262f, 0.03293490f, 0.01938055f, 0.01659736f, 0.09309851f, -0.02987375f, 
    0.05469561f, 0.20402119f, 0.18538329f, -0.17108150f, 0.07514866f, 0.03231666f, 0.13633566f, 0.17454146f, 
    -0.14737916f, -0.05140762f, -0.16267911f, -0.01704142f, -0.29991564f, 0.11481217f, 0.00763787f, 0.16240999f, 
    -0.10000871f, -0.10963548f, -0.05153583f, 0.04122763f, -0.14925458f, -0.11192867f, 0.11231648f, 0.00961644f, 
    0.04603507f, -0.12035859f, 0.34135750f, -0.21658278f, 0.05182382f, 0.00985528f, 0.14855658f, 0.02172601f, 
    0.15226020f, 0.08073202f, -0.13704136f, 0.18189764f, 0.01935706f, -0.14729111f, 0.00736532f, 0.24111654f, 
    0.19573200f, -0.12263620f, -0.00534807f, -0.10910753f, 0.11349637f, -0.18884955f, 0.12705526f, 0.14882767f, 
    0.04504672f, -0.22848208f, -0.42312372f, 0.00061093f, -0.02235313f, -0.10882419f, -0.07684287f, -0.20934480f, 
    -0.12220117f, 0.00227059f, -0.01238924f, 0.03275196f, 0.03155995f, 0.10229331f, -0.00927097f, 0.06317943f, 
    -0.00348647f, 0.00658357f, -0.08157232f, -0.03167009f, -0.10191844f, 0.05622701f, -0.02215132f, 0.25486282f, 
    -0.00214741f, -0.00891304f, -0.02745583f, 0.00981291f, -0.00524477f, -0.03403480f, 0.05547827f, -0.02162790f, 
    0.11560269f, 0.16295002f, 0.06657284f, -0.07443757f, 0.26587409f, 0.20274363f, -0.03535781f, -0.03011044f, 
    0.11464831f, 0.10360785f, 0.02813714f, 0.10804713f, -0.02356250f, 0.08959775f, -0.00689033f, -0.09210456f, 
    -0.10424828f, -0.08762150f, -0.05291230f, -0.08204782f, 0.03561457f, -0.01753636f, 0.02339527f, -0.20414090f, 
    -0.13042498f, -0.00786797f, -0.14807950f, 0.04957592f, 0.14160490f, 0.22159274f, 0.11313432f, -0.03052713f, 
    -0.19465996f, -0.10217728f, -0.15592122f, 0.09467533f, -0.04548819f, -0.02981103f, -0.02789382f, -0.11950260f, 
    -0.04657910f, 0.00931905f, -0.01131362f, 0.17842942f, -0.15532012f, -0.09447803f, -0.13824002f, -0.14981697f, 
    -0.13378531f, 0.15650176f, 0.07447805f, 0.10595906f, 0.20963345f, -0.32067618f, 0.13012023f, -0.00374330f, 
    0.06488741f, 0.10969251f, 0.11326473f, 0.10259027f, -0.01861390f, 0.05823047f, -0.00442633f, -0.18044677f, 
    -0.12197769f, 0.15111595f, -0.06951209f, 0.03850099f, -0.00596520f, 0.04751435f, 0.01524935f, 0.04182544f, 
    0.04740936f, 0.01152451f, -0.01401359f, 0.00186982f, -0.00506952f, -0.18235375f, 0.16693176f, 0.05603645f, 
    0.08672887f, 0.09005424f, 0.09517229f, -0.05191098f, 0.01715877f, -0.09211414f, 0.01642337f, 0.16209815f, 
    -0.11224797f, 0.02444840f, 0.41055980f, 0.05898646f, 0.10386214f, -0.05646806f, -0.26329216f, 0.02125341f, 
    -0.00653865f, -0.00838827f, 0.03243873f, 0.09885865f, 0.16930375f, 0.32459289f, -0.02854204f, 0.38164324f, 
    0.10910503f, -0.02201324f, 0.14102769f, 0.03348253f, 0.09212286f, 0.00016927f, 0.09562285f, 0.07549887f, 
    0.56961256f, -0.14868583f, 0.21250802f, 0.23786013f, -0.03786962f, 0.12823175f, -0.08668970f, 0.22458819f, 
    0.06888531f, 0.05038487f, 0.01402905f, 0.03483038f, 0.50775069f, 0.26430395f, 0.24464774f, 0.16246851f, 
    0.15991063f, 0.05467304f, 0.04066100f, 0.00204112f, 0.07679509f, 0.10780414f, 0.01959204f, -0.14207806f, 
    -0.10131677f, 0.23474573f, -0.01178021f, 0.01940875f, -0.13220213f, 0.01362707f, -0.14504974f, -0.17051493f, 
    0.00375412f, -0.08944473f, -0.05414755f, 0.06663837f, 0.10689174f, -0.00352849f, 0.03277285f, -0.00860945f, 
    -0.09706859f, 0.22040315f, 0.07564710f, 0.18993802f, -0.04100196f, 0.11960410f, 0.10547913f, 0.14640851f, 
    -0.09988081f, -0.02284239f, 0.03246406f, -0.13251561f, -0.12194230f, -0.02034789f, -0.22055735f, 0.08559249f, 
    -0.00066435f, -0.09303771f, 0.02169538f, -0.08924673f, 0.07670072f, -0.10105260f, -0.09696154f, 0.18813166f, 
    0.02486909f, 0.13973692f, 0.00033907f, -0.02227527f, -0.01716773f, -0.02387924f, 0.05546024f, 0.13799216f, 
    -0.10136728f, -0.08539442f, 0.35355285f, 0.01108832f, 0.13466738f, -0.00263742f, -0.06096199f, -0.05725031f, 
    -0.04905532f, -0.11671280f, 0.01758920f, 0.15777607f, 0.44097167f, 0.37830916f, 0.19104365f, -0.02674393f, 
    0.06800477f, 0.01269292f, 0.16635594f, -0.11935071f, 0.09179761f, 0.08416807f, 0.02244193f, -0.10459808f, 
    -0.12237568f, 0.21135707f, 0.14906490f, 0.11933626f, 0.09452111f, 0.06104307f, 0.01987099f, 0.02326052f, 
    0.07562663f, -0.05917348f, 0.03663734f, 0.08001310f, 0.09187680f, 0.12595239f, 0.22301811f, -0.13696818f, 
    0.03908607f, 0.11503624f, -0.02728295f, 0.13896929f, -0.04811004f, 0.15299308f, -0.11228182f, 0.13581231f, 
    0.18987556f, 0.27638009f, 0.07409666f, 0.13228491f, 0.03683434f, 0.11846076f, 0.19523086f, 0.03958922f, 
    0.05529065f, -0.05176413f, -0.04975608f, -0.04371772f, 0.20479618f, 0.03610137f, 0.02822204f, -0.02089810f, 
    -0.13996437f, 0.00075670f, 0.00520415f, 0.23178308f, 0.00724440f, 0.07204946f, -0.00751258f, 0.01077762f, 
    0.09646944f, -0.30301395f, 0.02516490f, 0.04820101f, -0.02953294f, -0.12503994f, -0.06616750f, 0.01106387f, 
    -0.02331422f, -0.00498044f, -0.03723951f, -0.15901990f, 0.20223510f, 0.05410415f, -0.29809302f, 0.06509946f, 
    -0.30877861f, 0.11916667f, 0.07352917f, 0.20783253f, 0.02664965f, -0.10524259f, 0.05073269f, -0.08766161f, 
    0.12981381f, -0.03525952f, 0.09860385f, 0.03484785f, 0.09714421f, 0.10545427f, 0.08912850f, 0.15178330f, 
    0.03336838f, 0.10231376f, -0.03850214f, -0.10380599f, 0.06701009f, 0.19603924f, 0.01835028f, -0.23747735f, 
    -0.07758606f, -0.04325210f, 0.15000731f, 0.06282523f, -0.21442968f, 0.10492726f, -0.01671043f, -0.38158754f, 
    0.21842162f, -0.02363152f, 0.24147016f, 0.03132026f, 0.11178290f, 0.05421725f, 0.06286521f, 0.11651462f, 
    0.21109855f, -0.14590263f, -0.05498215f, -0.21196906f, -0.30961627f, 0.05203692f, -0.06427947f, 0.00050740f, 
    -0.15139502f, -0.05067199f, -0.05527349f, 0.04333841f, -0.21059892f, -0.16789615f, -0.11670402f, -0.30697638f, 
    0.10915600f, -0.01233473f, -0.02442762f, 0.11531948f, 0.16886115f, 0.00311310f, 0.03919057f, 0.16249686f, 
    0.12124906f, 0.12076429f, -0.10630965f, 0.07195091f, -0.13721138f, -0.03898706f, -0.29588404f, 0.18807785f, 
    0.08532626f, -0.13397630f, 0.02367014f, -0.00347613f, 0.34290698f, 0.23133592f, 0.13823515f, -0.04163203f, 
    -0.11262119f, -0.33386481f, -0.30711219f, -0.10097457f, -0.01686452f, -0.03500652f, -0.03530089f, 0.00265798f, 
    -0.05122467f, -0.09801532f, -0.00701800f, -0.17834248f, 0.04926648f, -0.07573231f, 0.03712278f, 0.22366609f, 
    0.03339569f, 0.03574828f, -0.03452795f, -0.13408671f, 0.20804079f, 0.24405369f, 0.18931562f, 0.23288591f, 
    -0.05640542f, -0.05487921f, -0.00792783f, -0.03936270f, 0.21090139f, 0.12200532f, -0.04554745f, -0.02912944f, 
    0.03751398f, 0.15224579f, 0.14143020f, 0.22122800f, 0.25273448f, 0.32703081f, 0.33012959f, -0.12890925f, 
    0.01373265f, -0.01845746f, 0.02373608f, 0.16316463f, 0.02898639f, -0.17773859f, -0.10062514f, -0.09083185f, 
    -0.02659320f, -0.29025286f, -0.22077566f, -0.08532721f, 0.03131219f, -0.00226840f, -0.07140454f, -0.10260689f, 
    -0.00833167f, -0.17768328f, -0.28672072f, -0.00248645f, -0.17523487f, 0.04636322f, 0.04788762f, 0.01977924f, 
    -0.02908755f, 0.01146961f, -0.11990075f, -0.06136930f, -0.14031805f, -0.07193289f, -0.05873452f, -0.12626356f, 
    -0.12610431f, -0.01067740f, 0.01159363f, -0.01488359f, 0.01694967f, -0.04266057f, -0.06564787f, -0.01411928f, 
    -0.02827676f, 0.02298304f, 0.09961857f, 0.19738233f, 0.11814749f, -0.05448176f, 0.09589620f, 0.12000471f, 
    0.22476697f, 0.32713306f, 0.07343818f, 0.14636444f, 0.15763898f, 0.03999514f, -0.00155792f, 0.18705316f, 
    -0.30038148f, 0.02452241f, -0.11199094f, -0.21388070f, -0.09554196f, -0.03384544f, -0.10539177f, 0.02566716f, 
    0.02836576f, 0.07008475f, 0.09851989f, -0.00427860f, 0.21918078f, 0.00561763f, -0.15418687f, -0.09732111f, 
    0.14600201f, 0.16464078f, 0.28443384f, -0.11582270f, -0.00037248f, -0.11285016f, -0.03090942f, 0.23093404f, 
    -0.44895640f, 0.16024262f, 0.09217792f, 0.19273366f, 0.28608495f, 0.10025407f, -0.14908604f, 0.09371439f, 
    0.03106956f, 0.04909528f, 0.18206440f, 0.13922136f, 0.23867808f, 0.04198353f, 0.42502186f, 0.03169090f, 
    0.13895562f, 0.03748511f, 0.00791094f, 0.15249071f, -0.01174388f, -0.15098047f, 0.04190500f, 0.00378667f, 
    0.03184579f, -0.00982315f, -0.18754792f, -0.13094062f, -0.22248526f, 0.07690143f, -0.01710947f, 0.17542633f, 
    -0.07231250f, 0.11191187f, 0.15579268f, 0.17644152f, 0.32581055f, 0.30913228f, 0.17542887f, -0.10639703f, 
    0.12978016f, 0.10429414f, 0.31186533f, 0.01637837f, -0.08705349f, -0.12018912f, -0.07632931f, -0.16968054f, 
    0.07738973f, 0.22938941f, 0.04500246f, -0.15814202f, -0.03628012f, 0.00202261f, -0.00324792f, 0.07667641f, 
    -0.00302332f, 0.01026634f, 0.17651910f, 0.03391499f, -0.07045805f, -0.00273757f, 0.02149306f, -0.26234394f, 
    -0.10406350f, 0.10344101f, 0.08042083f, -0.06576471f, 0.02314271f, 0.22433046f, 0.10472334f, 0.15758891f, 
    -0.01466776f, -0.11199883f, -0.22140633f, -0.01785847f, -0.05807747f, -0.07509932f, -0.05804696f, -0.17361115f, 
    -0.02363543f, -0.16454673f, 0.13236509f, 0.03199382f, -0.19671857f, -0.13345967f, -0.21164374f, 0.00465213f, 
    -0.25946042f, 0.04866491f, 0.01191994f, 0.09571403f, 0.32861662f, 0.22623025f, 0.28571087f, 0.12058549f, 
    -0.18283713f, -0.16663410f, 0.04339376f, 0.09130071f, 0.10566247f, 0.00651089f, -0.08381274f, 0.04346924f, 
    -0.22215743f, -0.10762057f, 0.07409600f, -0.10989939f, 0.12722553f, 0.28078216f, 0.06228314f, -0.00506728f, 
    0.35674751f, 0.22019617f, 0.13195178f, 0.16265769f, 0.11187123f, 0.04268911f, -0.08708866f, -0.04126594f, 
    -0.22284797f, -0.25663939f, -0.14466423f, 0.03344526f, 0.13152869f, -0.09770974f, -0.04793449f, 0.10610336f, 
    0.16029286f, 0.08525961f, -0.01912087f, 0.08624095f, -0.27677488f, 0.22941799f, 0.16978243f, -0.09200497f, 
    0.08434100f, 0.10033920f, 0.10932244f, 0.06920715f, -0.08963124f, -0.03646456f, -0.02400318f, -0.02867687f, 
    0.21715906f, 0.19204736f, 0.23520586f, 0.08041112f, 0.09632792f, 0.10110822f, 0.21064097f, 0.06750279f, 
    0.02057503f, 0.02840071f, -0.00330522f, 0.12640452f, -0.03530080f, 0.00840865f, -0.01630125f, -0.00513951f, 
    0.08577792f, 0.12816183f, -0.06338643f, 0.00340137f, -0.23001368f, 0.02276280f, 0.00395742f, 0.14149430f, 
    -0.45060816f, -0.13051404f, 0.06310974f, 0.29685444f, 0.23646401f, 0.09466958f, -0.11963921f, 0.00100772f, 
    -0.02590139f, 0.11768570f, 0.03959033f, 0.17200309f, -0.03690451f, 0.33293739f, -0.14405654f, -0.19835375f, 
    -0.13606921f, 0.13663226f, 0.24018088f, -0.01940737f, 0.00157282f, 0.03621108f, 0.03188599f, 0.08901866f, 
    -0.27868217f, -0.24908733f, 0.00879520f, -0.14986865f, -0.13559157f, -0.28101662f, -0.08740373f, -0.07950198f, 
    -0.03444790f, -0.11220356f, -0.12609036f, -0.04515347f, 0.01460372f, 0.10905876f, 0.05798187f, -0.12614799f, 
    0.00591075f, 0.00104421f, 0.04391062f, -0.03947214f, 0.17399457f, 0.19208519f, 0.14295685f, 0.03780679f, 
    -0.13053250f, 0.03553898f, -0.06393286f, -0.24695575f, 0.00637687f, 0.04866974f, 0.05727882f, 0.04564348f, 
    0.02811813f, 0.16252099f, 0.04372763f, 0.07375512f, 0.27533680f, 0.20027331f, 0.07726730f, -0.15491417f, 
    0.09101932f, 0.05408968f, 0.03213504f, 0.15823057f, -0.03285531f, -0.03242361f, 0.14128479f, 0.11087147f, 
    0.02832161f, -0.21097493f, 0.10291112f, -0.10705882f, -0.03451781f, 0.17040628f, 0.14846116f, 0.05269570f, 
    0.04417020f, 0.14270142f, -0.04648567f, 0.14568035f, -0.24221654f, -0.03277419f, 0.25456759f, 0.23687473f, 
    -0.06766438f, -0.07361615f, 0.07488772f, 0.21250278f, -0.09534737f, 0.05851564f, 0.07228031f, 0.12596142f, 
    -0.32999128f, 0.41848001f, 0.21211725f, 0.14780658f, -0.19018899f, -0.03275873f, 0.00159511f, -0.02075398f, 
    -0.07589921f, 0.18767436f, 0.11834717f, 0.06219914f, 0.12112227f, 0.15210418f, -0.01549043f, 0.49293965f, 
    0.12703198f, 0.17707828f, 0.02910055f, 0.16610070f, 0.14123905f, -0.04641026f, -0.16307105f, 0.26136002f, 
    0.05240563f, 0.01868525f, -0.01812068f, 0.06585041f, 0.16018318f, 0.06299016f, 0.06878494f, 0.06373309f, 
    -0.13024020f, -0.03718662f, -0.01256055f, -0.05609338f, -0.03658588f, -0.22474396f, -0.24537233f, -0.03018714f, 
    0.05257022f, 0.15527435f, -0.01147535f, 0.06270918f, -0.07007489f, 0.03172130f, 0.19636717f, -0.05096148f, 
    -0.13548088f, -0.03662004f, -0.02778908f, 0.05547423f, 0.01460405f, 0.00545326f, -0.02315687f, -0.07475443f, 
    -0.06193710f, 0.03972195f, 0.11102067f, 0.03595504f, 0.00857489f, 0.26894873f, 0.04842225f, -0.04368999f, 
    -0.00632590f, 0.08305907f, -0.09592072f, -0.07772287f, -0.08426668f, 0.04301200f, -0.05370013f, 0.03658244f, 
    0.21996281f, -0.00049676f, 0.03331739f, 0.09073748f, -0.00431817f, -0.06079945f, 0.03487399f, 0.05286473f, 
    -0.19444641f, 0.02716417f, 0.01613021f, -0.10837673f, 0.54857379f, -0.12420915f, 0.18264228f, -0.30377823f, 
    0.12493810f, -0.04640110f, 0.15516891f, 0.20670335f, 0.15591213f, 0.02624445f, -0.11091456f, -0.11940618f, 
    -0.09359559f, 0.15072078f, -0.21619761f, 0.18313168f, 0.02943622f, 0.04630133f, 0.17845517f, 0.01118789f, 
    0.07138354f, 0.07670806f, -0.09683385f, -0.05620135f, 0.18271704f, 0.24861948f, -0.05157392f, -0.13891172f, 
    -0.00467551f, 0.04008629f, 0.28819317f, 0.03097927f, 0.23266575f, 0.04007204f, 0.18142439f, -0.03615811f, 
    0.37285507f, -0.11751293f, -0.00410786f, -0.14877367f, 0.01069140f, 0.13099250f, 0.29596409f, -0.17946583f, 
    -0.01822524f, -0.07008094f, 0.01939792f, -0.02591012f, -0.09895693f, 0.04148032f, 0.12076373f, 0.30093825f, 
    0.12351707f, -0.18895979f, 0.09947573f, -0.00558652f, 0.06969433f, 0.02738496f, 0.08853920f, 0.03009002f, 
    0.48996156f, -0.01311348f, 0.10671365f, 0.04452491f, 0.04581930f, -0.04697638f, 0.01152114f, 0.02284789f, 
    -0.00611117f, 0.02439967f, -0.16413194f, 0.16170354f, 0.26806569f, 0.27222610f, 0.38472834f, 0.12835032f, 
    -0.00759837f, 0.13001034f, 0.12007147f, -0.04362362f, 0.04611488f, 0.02329250f, 0.02808500f, 0.03473909f, 
    0.11706772f, 0.30039111f, -0.13751240f, 0.30238846f, 0.00578909f, 0.10102336f, -0.00461005f, 0.02812693f, 
    0.12648179f, -0.10225367f, -0.06936274f, -0.06638800f, -0.02511001f, -0.29090628f, -0.17729683f, -0.27314869f, 
    -0.02001903f, -0.05207033f, -0.24970947f, 0.17368285f, -0.15365340f, 0.01382227f, -0.24631152f, -0.05341203f, 
    0.15662359f, -0.05209291f, 0.11152873f, 0.10345850f, -0.03539592f, 0.02238582f, -0.07393818f, -0.06830360f, 
    0.03003371f, 0.03611380f, 0.10987392f, 0.04478002f, -0.29977372f, -0.00576973f, -0.01022913f, 0.24679749f, 
    0.01372347f, -0.02625334f, -0.03463729f, 0.11191022f, -0.11059995f, 0.04124128f, -0.04036199f, 0.09057552f, 
    0.17201269f, -0.02328361f, 0.21449508f, -0.11392780f, -0.02637155f, 0.06162986f, 0.01821391f, 0.00368901f, 
    0.05040226f, -0.01437759f, 0.09302342f, 0.11223952f, 0.17545740f, 0.11775182f, 0.22365835f, 0.09269626f, 
    -0.10134342f, 0.13265215f, 0.10682176f, -0.17936410f, -0.05460564f, 0.09971356f, 0.08108354f, 0.13698632f, 
    -0.60686588f, -0.13416339f, 0.35828429f, 0.25559813f, 0.07836685f, 0.00603229f, 0.04166434f, -0.08368047f, 
    -0.03728183f, -0.12353852f, -0.08348237f, 0.07503243f, 0.01444417f, -0.47725704f, -0.01029798f, -0.40048847f, 
    0.02905721f, 0.10732601f, -0.09158585f, -0.08005864f, 0.14581378f, 0.00655040f, 0.03085348f, 0.02288946f, 
    -0.02187892f, 0.13772321f, 0.03438644f, 0.17052205f, 0.00307831f, -0.04100310f, 0.11051965f, 0.03176850f, 
    -0.07096634f, -0.09513592f, -0.14534266f, -0.18570861f, -0.15316853f, -0.16246836f, -0.17582029f, -0.31876010f, 
    -0.20437720f, 0.03124417f, -0.11437794f, -0.22367311f, 0.02876003f, -0.14802702f, -0.09422474f, -0.04112242f, 
    0.59446114f, -0.38989699f, 0.29267693f, -0.54344863f, -0.00281281f, -0.00143843f, -0.04915342f, 0.00632073f, 
    -0.14325120f, -0.05312714f, -0.05530986f, 0.06795061f, -0.12615128f, -0.03778091f, -0.20660375f, 0.12278036f, 
    -0.19371474f, 0.06284000f, -0.06434347f, -0.00445455f, -0.03457789f, -0.03832828f, -0.01843753f, 0.03205682f, 
    0.23259999f, 0.17354597f, 0.09827876f, 0.10458389f, 0.00610028f, 0.11803372f, 0.06160879f, 0.04461671f, 
    -0.10993029f, -0.01091598f, -0.08806478f, -0.00687636f, 0.01914015f, 0.24298529f, -0.01279815f, -0.10796891f, 
    0.04866437f, -0.12891309f, -0.20623299f, 0.03203148f, 0.18153968f, -0.02577412f, -0.03273232f, -0.10588203f, 
    -0.24292491f, 0.17496438f, -0.15135700f, 0.32677275f, -0.08064658f, 0.11274533f, -0.11108874f, 0.02986850f, 
    -0.04403870f, -0.02766717f, 0.02350223f, -0.14572631f, 0.07089662f, -0.07214382f, -0.07947563f, 0.14370143f, 
    0.00374296f, -0.01192338f, 0.03552090f, -0.02697536f, 0.14895122f, -0.09462218f, 0.00608240f, -0.00553959f, 
    0.32266954f, 0.56398886f, -0.14214693f, 0.22406457f, -0.17804411f, -0.03382485f, -0.06480365f, -0.18420967f, 
    -0.06526213f, -0.11422641f, -0.22868568f, 0.11078630f, -0.10988808f, 0.42169717f, 0.35716146f, 0.14810860f, 
    -0.04703562f, 0.01384939f, -0.13225380f, -0.04141061f, -0.06392536f, 0.07478565f, 0.19224837f, -0.04876627f, 
    -0.04719831f, 0.29868230f, 0.25951216f, 0.38899305f, -0.02290091f, -0.13946952f, -0.10341793f, -0.14158222f, 
    -0.10198870f, 0.03456748f, -0.04069544f, 0.09114931f, -0.04004005f, 0.11381597f, -0.00803881f, 0.03022373f, 
    -0.05720772f, -0.20977505f, 0.15776297f, -0.06059835f, 0.00131860f, 0.06630622f, 0.17766288f, 0.21245013f, 
    -0.12455289f, -0.07370199f, -0.23438577f, -0.00230132f, -0.09916267f, 0.17998745f, 0.01510224f, 0.07672910f, 
    0.13140416f, 0.12899287f, 0.08704424f, -0.00828761f, -0.30646431f, -0.00889967f, -0.01918502f, 0.08714648f, 
    0.13316874f, 0.10495897f, 0.06246829f, 0.02912152f, 0.01910844f, 0.14550234f, -0.01862247f, 0.10949254f, 
    0.02292336f, 0.13623416f, -0.07441168f, 0.06779779f, -0.02647090f, 0.02913334f, 0.00486910f, -0.00700660f, 
    -0.02767183f, -0.04204000f, -0.25857610f, -0.11952645f, -0.44268835f, -0.17603073f, -0.15674113f, 0.10608874f, 
    0.09172434f, 0.11367136f, 0.10995319f, 0.15113178f, 0.06073737f, -0.03530174f, 0.03765924f, -0.05017730f, 
    -0.13280505f, -0.23131898f, -0.15142027f, 0.05544620f, -0.07372243f, 0.02178682f, 0.02888723f, -0.02950852f, 
    0.08253320f, 0.14898901f, 0.09431387f, 0.10749533f, 0.40158471f, 0.27392113f, 0.01899714f, 0.19557193f, 
    0.00215445f, -0.17265630f, 0.03511798f, -0.01055039f, 0.11416709f, 0.13694739f, -0.11827695f, -0.08013746f, 
    -0.00654373f, -0.08522718f, -0.09482083f, -0.01564677f, 0.02468059f, -0.08150508f, -0.15369318f, -0.09258571f, 
    -0.01057306f, 0.15574488f, 0.03884156f, 0.03637460f, 0.30302653f, 0.43946570f, 0.12444676f, 0.36751518f, 
    -0.21749969f, -0.01284002f, 0.05706558f, -0.04844033f, -0.01461329f, -0.09356071f, -0.11075575f, 0.25217625f, 
    -0.15404381f, -0.37011757f, -0.21070309f, 0.04495898f, 0.12200420f, 0.03188159f, 0.03489541f, 0.06160642f, 
    -0.03150085f, -0.01728135f, -0.00036370f, 0.18459657f, -0.16739246f, 0.11228333f, -0.06114950f, 0.19752489f, 
    0.01538735f, 0.12039438f, 0.02054379f, 0.15075812f, -0.04462088f, -0.06074151f, -0.06824443f, 0.13256009f, 
    -0.09884382f, 0.27498224f, 0.34303907f, -0.16630103f, 0.19922155f, -0.12215678f, -0.02929382f, 0.04411641f, 
    0.05141056f, -0.18290676f, -0.06368963f, -0.16757743f, -0.49871823f, -0.31539854f, 0.30423218f, 0.37318981f, 
    0.08632300f, -0.20360516f, -0.07774783f, -0.02466121f, -0.02888843f, 0.02985194f, -0.00190567f, -0.10959256f, 
    -0.20894654f, -0.19599277f, -0.03200558f, 0.07466859f, -0.00294035f, -0.02474079f, -0.07176639f, -0.01876812f, 
    -0.02866211f, 0.02705898f, -0.03547766f, 0.12328759f, 0.10907371f, -0.04898833f, 0.08665016f, -0.00559251f, 
    -0.03885088f, -0.01329251f, 0.17121863f, -0.04558417f, 0.00286872f, -0.12166303f, 0.10595449f, 0.16580001f, 
    0.08664398f, 0.30715132f, 0.09812182f, 0.01376774f, -0.00296310f, -0.18625100f, -0.05722687f, 0.07522357f, 
    0.02119089f, 0.02582672f, -0.09164570f, -0.01015091f, 0.19960181f, 0.18894957f, 0.34544924f, 0.06075910f, 
    -0.00611570f, 0.01602653f, 0.09082183f, -0.02938701f, 0.02394596f, 0.15726644f, -0.01861341f, 0.05971083f, 
    -0.11771499f, 0.07095397f, -0.31368312f, 0.10421167f, -0.12443354f, 0.06121225f, -0.00454138f, -0.09861437f, 
    -0.02981207f, 0.03085707f, 0.07621083f, 0.02988127f, -0.30466664f, 0.03258789f, 0.26174369f, 0.44093910f, 
    0.16358644f, -0.14558010f, -0.05477052f, -0.15173654f, -0.01362264f, -0.04697623f, -0.00544458f, -0.01445463f, 
    0.09498487f, 0.21949618f, 0.13754696f, 0.28045386f, -0.01718411f, 0.11102039f, 0.05614819f, 0.03077510f, 
    0.09028391f, 0.01168205f, -0.03443305f, 0.04158003f, 0.13051459f, -0.03458819f, 0.19841175f, 0.07576738f, 
    -0.01686033f, -0.08998418f, 0.05406353f, 0.04119521f, -0.04321424f, 0.02837191f, -0.12209010f, 0.16660003f, 
    -0.47849131f, -0.19394542f, -0.08056553f, 0.32749152f, -0.12737441f, 0.16890991f, 0.13444467f, 0.07510603f, 
    0.01465915f, -0.01532749f, 0.02430771f, 0.05425053f, -0.45627418f, -0.12960531f, 0.03250714f, 0.23911996f, 
    0.15196972f, -0.02485665f, 0.13434458f, -0.04231727f, -0.00719348f, 0.00998779f, 0.09066046f, -0.07486290f, 
    0.12175667f, -0.27466556f, -0.14234428f, -0.07428143f, -0.08679961f, 0.02165476f, 0.04532041f, 0.07433701f, 
    0.11421934f, -0.04693779f, -0.09469186f, -0.13121022f, -0.09324217f, -0.09305096f, 0.06199211f, 0.12611945f, 
    0.01029649f, 0.00905968f, 0.05084621f, 0.04529653f, 0.12446586f, -0.13638042f, -0.06847348f, -0.06670889f, 
    0.02041909f, -0.03360729f, 0.00271745f, 0.03538917f, 0.02248381f, 0.02902657f, 0.04080696f, -0.03604103f, 
    -0.00404273f, -0.03382536f, 0.03264582f, -0.04486680f, 0.02788224f, 0.00750577f, -0.00761056f, 0.01435898f, 
    0.00379944f, 0.02383213f, 0.02626150f, -0.01736071f, -0.01109327f, 0.01844225f, 0.04175987f, 0.03445383f, 
    0.03826329f, -0.03734765f, 0.03855541f, -0.05681992f, -0.02857739f, 0.05019798f, 0.02307588f, -0.00824437f, 
    0.01034094f, 0.03595057f, -0.01937323f, 0.05104518f, 0.01856357f, -0.05301206f, -0.06031026f, -0.03100900f, 
    0.01239634f, 0.03950527f, -0.03061676f, 0.01653443f, -0.04146733f, -0.01142342f, -0.01370431f, -0.05141015f, 
    0.02443445f, 0.02311545f, 0.02758468f, -0.03939078f, -0.04264155f, 0.00300556f, -0.04297812f, -0.02385921f, 
    0.02198419f, -0.05409963f, -0.04692042f, -0.03471291f, 0.00917874f, -0.01155180f, -0.00446617f, -0.04410829f, 
    -0.00344058f, 0.03629741f, -0.00100750f, 0.00211738f, -0.03263977f, -0.03390315f, 0.00271657f, 0.03009818f, 
    0.00706708f, 0.02341848f, 0.00952389f, 0.00162003f, 0.01378797f, -0.00319804f, 0.03818450f, -0.03464184f, 
    -0.03485883f, 0.00991966f, 0.02660756f, 0.00098582f, 0.02463612f, -0.03457480f, 0.03085103f, -0.04090002f, 
    -0.02718817f, 0.03347759f, -0.02356010f, -0.02220867f, -0.00215796f, -0.00109416f, 0.01296395f, -0.01220726f, 
    -0.03323744f, -0.02772557f, 0.03323809f, -0.01291338f, 0.03473417f, -0.03404156f, -0.05197325f, 0.02889530f, 
    0.04238954f, 0.03343900f, 0.00381873f, -0.00579351f, 0.00725714f, -0.01434125f, 0.04455259f, -0.06020068f, 
    0.02609835f, 0.00570301f, -0.05362580f, 0.05157056f, 0.00006002f, -0.01475507f, -0.02347460f, -0.02489857f, 
    0.00650638f, 0.04517310f, -0.03200228f, -0.01669660f, 0.01898195f, 0.02674858f, 0.04289630f, -0.01188830f, 
    0.00763722f, 0.01019228f, 0.03428049f, -0.05360717f, -0.01486068f, -0.02126685f, 0.03638823f, 0.03237335f, 
    -0.03912792f, 0.02783477f, -0.03662263f, -0.00598693f, -0.05432560f, -0.00618467f, 0.01270357f, -0.04796783f, 
    -0.00564520f, -0.01583942f, 0.04998836f, 0.00904937f, -0.04284936f, 0.04455734f, 0.01317760f, -0.03269308f, 
    0.02644443f, -0.02182859f, -0.02677829f, -0.04317194f, -0.00263855f, -0.03035092f, 0.02944246f, -0.05349196f, 
    0.03126564f, -0.02595955f, 0.01067256f, 0.03704375f, 0.01585947f, 0.02754939f, -0.02148061f, -0.05076186f, 
    0.00640014f, 0.02636683f, 0.00232233f, 0.01142690f, 0.00309797f, 0.01809386f, -0.04595961f, -0.03157054f, 
    0.03953971f, 0.02815022f, -0.02392591f, -0.00030587f, -0.00056625f, -0.00978557f, 0.02869595f, -0.02001612f, 
    -0.02667610f, -0.04214846f, -0.02458709f, -0.05711855f, 0.02068834f, -0.02934829f, -0.00051679f, -0.03244705f, 
    -0.00491376f, 0.03884211f, 0.00715515f, -0.04515796f, -0.04369853f, -0.05917666f, -0.04336100f, -0.01918685f, 
    0.01137430f, -0.05690540f, -0.03271875f, -0.02853639f, -0.05325208f, 0.01900097f, -0.02159004f, -0.00550512f, 
    -0.02479624f, -0.01126456f, -0.02535109f, 0.03989384f, -0.00901640f, -0.05636955f, -0.01456536f, 0.03885360f, 
    0.00567711f, -0.03508525f, 0.02101870f, -0.02019339f, -0.03484507f, -0.04649617f, 0.03236477f, -0.04787568f, 
    -0.02433464f, 0.03710965f, 0.01581095f, -0.03690504f, -0.03080433f, 0.02911696f, 0.04288454f, -0.00825817f, 
    -0.00797465f, 0.02056169f, -0.03907542f, 0.02120727f, -0.01999129f, 0.02273625f, -0.04664266f, 0.01276830f, 
    -0.02440881f, 0.01170713f, -0.03642703f, 0.02832106f, 0.01046910f, -0.00224208f, 0.01773871f, 0.04178230f, 
    0.02223426f, -0.01652091f, -0.04540636f, -0.00198442f, -0.04256296f, 0.02995915f, -0.04621757f, -0.04657299f, 
    -0.05688329f, 0.03735999f, -0.04274111f, 0.02304839f, 0.04091749f, 0.01868968f, -0.03257878f, -0.01794528f, 
    0.02808462f, 0.04267245f, 0.03392583f, 0.02002166f, 0.04561395f, -0.03405780f, -0.04335678f, -0.01580933f, 
    0.02539118f, -0.03285022f, -0.02318757f, -0.02283283f, -0.00133674f, 0.00218478f, -0.03335308f, 0.03567936f, 
    -0.00148340f, -0.04408251f, 0.02933093f, -0.02326353f, 0.02400893f, 0.02591122f, -0.03989152f, 0.03507026f, 
    -0.03938757f, 0.03514719f, 0.02212245f, 0.02138048f, -0.01212987f, -0.01917806f, 0.00848557f, -0.04385549f, 
    -0.03707148f, -0.00035608f, -0.00247866f, 0.00098456f, -0.00781987f, -0.05767391f, -0.02364181f, 0.01871547f, 
    -0.03954738f, 0.01175289f, 0.02374801f, -0.03255273f, 0.00124503f, -0.05604669f, -0.00608480f, 0.01324111f, 
    -0.03099465f, -0.00227722f, 0.00938202f, -0.01388833f, -0.01686804f, 0.00957044f, -0.01928843f, 0.00146112f, 
    0.02142355f, -0.00839255f, 0.03289343f, 0.01031550f, -0.00067940f, 0.00755546f, -0.03476503f, -0.02939197f, 
    -0.04413879f, -0.01137014f, -0.01328274f, 0.04511473f, -0.05416273f, -0.00637941f, -0.00263320f, -0.00635658f, 
    -0.01965667f, 0.01268969f, 0.00859340f, 0.00471817f, -0.03750532f, -0.02192887f, -0.03780477f, -0.00579525f, 
    0.01420716f, -0.01164355f, -0.01362719f, 0.01907598f, -0.03503682f, 0.00034567f, 0.04279799f, 0.00583136f, 
    -0.03475003f, 0.02652417f, 0.03073910f, -0.05291040f, 0.04708869f, -0.00701057f, -0.02017135f, -0.01325437f, 
    0.05411811f, -0.00000997f, -0.04309933f, 0.02696506f, 0.00630448f, -0.00883939f, 0.03494778f, 0.04334057f, 
    -0.00156108f, -0.00401133f, 0.03263402f, 0.00330058f, -0.03153987f, -0.01926470f, -0.04894528f, 0.02396905f, 
    0.01563241f, -0.03585150f, 0.00309593f, 0.02136089f, -0.02987334f, 0.02716518f, 0.02587880f, 0.00869400f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00874250f, -0.04411360f, 0.12831736f, 0.01802014f, 0.02580576f, 0.03521242f, -0.11150692f, 0.15572502f, 
    0.10024352f, -0.07600442f, 0.12140504f, 0.02238853f, 0.11466071f, 0.09595414f, 0.16503765f, 0.04376990f, 
    -0.06445377f, -0.11854612f, -0.01043022f, 0.10382080f, 0.10408669f, -0.03059303f, -0.02151810f, 0.16071774f, 
    0.04333686f, 0.12025867f, 0.05100023f, 0.09627673f, 0.14449464f, 0.15365085f, 0.16913673f, -0.05025940f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.12400077f, 0.05807863f, 0.39898491f, 0.14604604f, 0.13632283f, -0.11766150f, 0.05425114f, -0.20823310f, 
    -0.25175440f, -0.14515382f, 0.00445401f, -0.16567859f, 0.22653669f, -0.14557369f, 0.20654854f, -0.16759044f, 
    0.17559969f, 0.30559289f, 0.04733857f, 0.09106058f, 0.24856959f, -0.05647300f, 0.19720006f, 0.18606727f, 
    0.11568543f, 0.26935846f, 0.22830802f, -0.27089682f, -0.17809869f, 0.15786031f, 0.17365061f, -0.16618234f, 
    -0.20298390f, -0.09906298f, -0.12881872f, 0.16328286f, -0.16271491f, -0.02662645f, -0.27999285f, 0.29819533f, 
    0.23111607f, -0.11336026f, 0.26326448f, 0.15106583f, 0.39859396f, 0.25241175f, 0.17144799f, 0.15996405f, 
    -0.18086945f, -0.39716649f, 0.01223617f, 0.20874435f, 0.14538281f, 0.10852724f, -0.19828081f, -0.01227813f, 
    -0.09641662f, -0.03092948f, -0.14664234f, 0.03323448f, 0.27536204f, -0.13930084f, -0.01394174f, -0.09758663f, 
    0.31715557f, 0.03413492f, -0.07793228f, -0.00997796f, 0.16866033f, 0.17512350f, -0.05162381f, 0.04261725f, 
    -0.40064359f, 0.26046798f, -0.05016770f, 0.13385332f, -0.12101188f, -0.01721281f, -0.13433300f, -0.04128431f, 
    -0.08447248f, 0.65945244f, -0.14871168f, 0.23525025f, -0.22176248f, -0.16151078f, 0.30526605f, -0.14056391f, 
    -0.10167167f, -0.33320782f, 0.58776367f, 0.07117710f, -0.10254187f, -0.40909317f, -0.09062612f, -0.06081059f, 
    -0.16602667f, 0.09945851f, -0.46884808f, 0.12133037f, -0.02902212f, 0.13569376f, -0.06894793f, 0.22580680f, 
    0.34893316f, 0.07639644f, 0.29907545f, -0.06918271f, -0.07473473f, 0.08862109f, -0.14408800f, 0.11827008f, 
    0.03667761f, -0.06008494f, -0.00690875f, 0.02514722f, -0.08511512f, -0.13278520f, 0.10214297f, -0.21529253f, 
    -0.03211335f, -0.18092278f, 0.04003589f, 0.28048751f, -0.02285946f, -0.24608937f, 0.45693612f, -0.02631457f, 
    0.11039165f, 0.00122643f, 0.25639999f, -0.00244643f, 0.05923808f, 0.11474516f, 0.14160009f, 0.00867996f, 
    -0.44860470f, 0.24911676f, -0.18879458f, 0.02442167f, -0.24703960f, 0.09812435f, -0.09467865f, -0.04134727f, 
    -0.15048292f, 0.07626643f, 0.01158371f, 0.14223999f, 0.25162303f, 0.12079789f, 0.01361373f, 0.12044102f, 
    -0.09383868f, -0.23755036f, -0.04460166f, 0.18381380f, 0.07812860f, -0.25997990f, 0.35613009f, 0.13898458f, 
    -0.19154167f, 0.13559508f, -0.34409758f, 0.25679430f, -0.10937437f, -0.02697790f, 0.07668808f, 0.24516115f, 
    -0.37103152f, 0.03469305f, -0.02080165f, 0.10862760f, -0.11159802f, -0.21440671f, 0.28733242f, -0.00943192f, 
    -0.74506915f, 0.18487376f, 0.04505192f, 0.29160047f, 0.11653275f, 0.02246417f, 0.08291984f, 0.16465208f, 
    -0.05060452f, -0.13185473f, 0.22889750f, 0.08169372f, -0.02973148f, -0.08915823f, -0.52340895f, 0.00873531f, 
    0.09298023f, -0.06125577f, -0.07255455f, 0.22862206f, 0.08395492f, -0.10877487f, -0.06351063f, 0.16609016f, 
    0.39300355f, -0.33801019f, 0.06962490f, -0.09283388f, -0.10344671f, 0.26389417f, 0.07303078f, 0.13219732f, 
    -0.26332986f, -0.06832684f, -0.14055082f, 0.01641047f, -0.13667285f, -0.11912376f, 0.01754267f, 0.20816687f, 
    -0.14262015f, 0.29656306f, 0.14229344f, -0.37095433f, -0.36289647f, -0.03683773f, -0.10428418f, 0.04662471f, 
    -0.35560793f, 0.13712348f, -0.26983750f, 0.16003142f, -0.13191271f, 0.02419992f, 0.30374929f, 0.04030444f, 
    -0.07592180f, -0.00385222f, 0.13213991f, -0.16512446f, -0.17845483f, -0.45633850f, 0.08641498f, 0.14756176f, 
    0.09351327f, -0.15356337f, 0.02340067f, -0.01952462f, -0.01116981f, 0.01194667f, 0.19647671f, -0.23897693f, 
    0.02785009f, -0.13408473f, -0.38316607f, -0.15509090f, -0.21975252f, 0.09013518f, -0.11778490f, 0.11432750f, 
    0.29111478f, -0.01295007f, 0.56185782f, -0.18751287f, -0.16563207f, 0.12787750f, -0.25586322f, -0.04827736f, 
    0.23065861f, 0.14371417f, 0.13180672f, 0.11109632f, -0.19505385f, -0.10744279f, 0.09994148f, -0.07931649f, 
    -0.43114412f, -0.15530437f, -0.11947829f, 0.22127132f, 0.05388941f, 0.14319807f, -0.33379650f, 0.13147631f, 
    0.07734888f, 0.37332028f, 0.03737189f, -0.10832567f, 0.12565483f, -0.18980440f, 0.17083609f, -0.12800802f, 
    -0.01543243f, -0.02982828f, -0.00860590f, -0.17429684f, -0.03023326f, -0.13079031f, -0.17670609f, -0.16313897f, 
    -0.16325948f, 0.03799092f, -0.06430698f, 0.16410755f, -0.15753837f, 0.08797555f, -0.01662100f, 0.12051646f, 
    0.05902734f, -0.15557016f, -0.09304729f, 0.06165670f, -0.12802297f, -0.02001133f, -0.00018986f, -0.12154298f, 
    -0.05703441f, 0.10479626f, 0.04232339f, -0.13308193f, 0.04939871f, -0.04851210f, -0.08507599f, -0.02410506f, 
    -0.10462707f, 0.15384138f, 0.25039047f, 0.00140020f, -0.12922271f, -0.13940533f, -0.32490522f, 0.06656582f, 
    -0.14787218f, -0.28775775f, 0.07689068f, 0.09269650f, 0.34709233f, 0.09115685f, 0.15800294f, 0.02149196f, 
    0.24980977f, 0.04613088f, -0.08508353f, 0.28557241f, 0.14431730f, -0.06184002f, 0.24314751f, 0.16839612f, 
    -0.11869158f, -0.45844752f, 0.30569544f, -0.10855011f, -0.01532461f, 0.31725746f, 0.24827299f, 0.11601501f, 
    -0.06345706f, 0.09347718f, 0.03994415f, -0.13745695f, 0.00079220f, -0.03807386f, -0.01330830f, 0.27588937f, 
    -0.30739757f, 0.16565993f, -0.06340358f, -0.02376861f, -0.13780491f, -0.02015674f, 0.33710274f, 0.13500331f, 
    0.38640273f, -0.45326728f, 0.06196564f, -0.24749663f, -0.12888351f, 0.05712037f, 0.32896361f, -0.02162239f, 
    -0.15796013f, -0.06456570f, -0.34333760f, 0.28158551f, 0.16613479f, 0.49738687f, -0.23708308f, 0.10663407f, 
    0.36354887f, 0.14591603f, -0.01349193f, 0.06584260f, 0.06263580f, 0.04791664f, 0.21741830f, 0.15797526f, 
    -0.19875564f, -0.07221369f, -0.06255092f, -0.09955675f, -0.37628895f, 0.00893325f, 0.28517106f, -0.13128754f, 
    0.56171769f, -0.04188969f, -0.04366061f, -0.26478580f, 0.34951010f, 0.18090627f, 0.42340553f, -0.01106641f, 
    -0.00452407f, -0.07714219f, -0.14937471f, 0.36527818f, -0.13073058f, 0.30342230f, 0.06096300f, -0.14822507f, 
    -0.11053950f, 0.07759610f, 0.24245375f, -0.05083582f, 0.01903048f, -0.03058868f, -0.25783151f, 0.21550654f, 
    -0.25210300f, 0.27940172f, 0.13263607f, -0.07182586f, 0.30859903f, -0.01543995f, 0.27467960f, 0.17433774f, 
    0.05944477f, -0.10160027f, 0.09366234f, 0.08484703f, -0.11428302f, 0.13325834f, 0.03308570f, -0.28134215f, 
    0.14670694f, -0.00797538f, -0.17577516f, 0.10282401f, 0.11783007f, 0.10643422f, -0.14919809f, 0.13907504f, 
    0.12127202f, -0.04983321f, -0.14641261f, -0.14806654f, 0.09341339f, -0.13300079f, -0.03042825f, -0.27973089f, 
    -0.19853984f, 0.13635129f, -0.13556983f, -0.05417389f, 0.30487502f, -0.12243541f, -0.31496471f, 0.04028868f, 
    -0.08441034f, -0.05281508f, -0.04010563f, 0.16494100f, 0.05173766f, -0.10675291f, -0.22684775f, 0.21375594f, 
    0.07203683f, 0.04605446f, -0.02419323f, -0.08255338f, -0.09419616f, -0.25361866f, 0.06979955f, 0.03649689f, 
    -0.35455593f, 0.14415975f, -0.09519060f, 0.00616721f, 0.17399767f, -0.06183885f, 0.13446547f, -0.20495690f, 
    -0.12514392f, -0.13421346f, -0.19342895f, 0.04788436f, -0.17635715f, 0.01952211f, -0.05367371f, -0.13024735f, 
    -0.02538884f, -0.06913786f, 0.15748389f, -0.01223830f, 0.09992738f, -0.03389757f, 0.16050972f, 0.02046356f, 
    0.02798793f, -0.22638173f, -0.21244530f, -0.15052697f, -0.16374929f, 0.13279530f, 0.04323936f, 0.17606655f, 
    -0.16838060f, 0.12281474f, -0.07130723f, 0.02899191f, -0.14401996f, -0.13137215f, -0.11670010f, -0.15951429f, 
    -0.11517184f, 0.10150193f, -0.34477484f, 0.18000244f, 0.04758199f, 0.11183047f, 0.14627156f, -0.14688760f, 
    0.52615362f, 0.61927390f, -0.08660673f, 0.21998125f, -0.35996407f, -0.16876921f, 0.39885885f, 0.05303492f, 
    0.09755426f, -0.21219118f, 0.44046572f, -0.04112453f, -0.10477525f, -0.33270723f, 0.19964616f, -0.12013669f, 
    0.37312850f, -0.03951343f, 0.37837654f, -0.21798103f, -0.11239517f, -0.11594937f, 0.14275686f, -0.21571490f, 
    0.28302172f, -0.06527118f, -0.18653308f, 0.16213003f, -0.38946208f, 0.11452399f, -0.06553800f, 0.00957006f, 
    -0.16842829f, -0.05170965f, -0.13071430f, 0.04975026f, 0.29061097f, -0.13530828f, -0.01254134f, 0.19039853f, 
    0.14023316f, 0.29978043f, -0.06073144f, 0.25482240f, -0.02498387f, -0.19818661f, 0.19526868f, 0.12584127f, 
    -0.19984911f, -0.10055786f, -0.04279879f, 0.18716899f, 0.16409221f, 0.02758364f, -0.08594017f, 0.17853530f, 
    0.06291197f, -0.12180622f, 0.11697574f, -0.14974898f, -0.06086423f, -0.11421698f, 0.10498272f, -0.08752616f, 
    -0.11736962f, -0.03139500f, -0.10760602f, 0.46384814f, 0.10072409f, -0.10331540f, -0.11941414f, 0.15603925f, 
    0.06507270f, -0.40863785f, 0.35113981f, 0.12260612f, -0.00654214f, -0.14728691f, 0.23020402f, -0.15564285f, 
    0.06946765f, -0.10223953f, 0.05456766f, -0.27712971f, -0.15023397f, -0.00474681f, 0.19192360f, -0.14200456f, 
    0.29040605f, 0.36866254f, -0.03102643f, -0.13543011f, -0.44617340f, 0.35695016f, -0.22395118f, -0.09687544f, 
    0.00458603f, -0.10979738f, -0.10359886f, -0.25460270f, -0.07899446f, -0.14901297f, 0.08104771f, -0.10257134f, 
    -0.03685016f, 0.02637830f, -0.12123860f, 0.20045418f, 0.32424888f, -0.14924848f, 0.04927710f, -0.14874469f, 
    0.17851003f, 0.09219081f, 0.43333644f, 0.26427707f, -0.12928130f, 0.10810182f, -0.16048072f, 0.05878767f, 
    -0.26133630f, 0.18804199f, 0.27362683f, -0.16162699f, -0.06596228f, -0.11553532f, 0.07387885f, -0.09167317f, 
    0.04706692f, 0.38272676f, -0.00937678f, 0.11063017f, -0.11587047f, -0.10051261f, 0.17446956f, -0.06804743f, 
    0.03902140f, 0.22396350f, -0.27279732f, 0.11109566f, 0.23912099f, -0.37754962f, 0.23296651f, -0.09144183f, 
    -0.00641404f, 0.08549079f, -0.05924848f, -0.02589654f, 0.09257535f, 0.00479279f, 0.16812755f, 0.18049501f, 
    0.13568887f, 0.15268567f, 0.02258924f, -0.03545975f, 0.26178622f, 0.20046432f, -0.24196634f, 0.11995998f, 
    0.38542151f, -0.10749823f, 0.08998238f, -0.13433543f, -0.37169382f, -0.16024308f, -0.20143993f, -0.25749615f, 
    -0.05424740f, -0.17936482f, 0.08843919f, 0.22105777f, 0.32683918f, -0.18579076f, 0.19675232f, 0.01824232f, 
    0.30992275f, 0.05156597f, 0.14882837f, 0.20831443f, -0.02484568f, 0.14384334f, -0.18977515f, 0.16817544f, 
    0.40711728f, -0.36355022f, -0.26161918f, -0.11839324f, -0.13347378f, 0.02197223f, 0.22531080f, 0.05915151f, 
    -0.47493491f, 0.24661882f, 0.12656121f, -0.18774712f, 0.02642121f, 0.02715773f, 0.13389334f, 0.32726154f, 
    0.16530319f, 0.17626260f, 0.14825524f, -0.28868252f, -0.15081826f, -0.00233656f, 0.06774370f, 0.00284297f, 
    -0.11341666f, -0.13205300f, 0.38281545f, -0.08930837f, 0.16496594f, -0.11178108f, -0.20569386f, -0.00599410f, 
    0.03611534f, -0.10780111f, -0.13332491f, 0.15137300f, 0.34699020f, -0.08952985f, -0.09694739f, -0.10444464f, 
    -0.14584891f, 0.30854380f, -0.13349423f, 0.28659210f, 0.39605245f, -0.07992836f, 0.02895658f, 0.28197083f, 
    0.13648741f, 0.09674382f, 0.28261954f, -0.12772267f, 0.18042241f, -0.19049013f, -0.04489604f, -0.02493927f, 
    -0.25092918f, -0.02574247f, -0.50426793f, 0.00583816f, -0.01783744f, 0.01698995f, -0.06135521f, 0.04981700f, 
    0.33099991f, -0.15674512f, -0.11529315f, -0.04228042f, -0.01659241f, 0.06156010f, 0.28279150f, -0.14886987f, 
    -0.43969011f, -0.25938830f, 0.10629945f, 0.21898730f, 0.41120341f, -0.07679234f, -0.04043784f, 0.25792947f, 
    -0.07940828f, -0.31482249f, 0.36541048f, 0.17086297f, -0.02973385f, 0.33890262f, -0.16195987f, -0.02247147f, 
    0.05224959f, 0.12253648f, -0.20563890f, 0.16605462f, -0.13976790f, -0.08161396f, -0.33073938f, 0.14799280f, 
    0.15287806f, 0.00809460f, 0.25039774f, 0.06050746f, -0.25247550f, 0.15558487f, 0.11622283f, -0.06801380f, 
    -0.41578028f, 0.10058767f, 0.06054828f, -0.25070357f, -0.48440480f, 0.10542705f, 0.11037015f, 0.18549031f, 
    -0.05443232f, 0.47888049f, -0.07769250f, 0.05785955f, -0.18902275f, -0.09259333f, -0.19303031f, -0.04348160f, 
    0.21874976f, -0.10733135f, 0.16089037f, -0.26400399f, -0.04055663f, -0.09880853f, 0.09196348f, 0.13023724f, 
    -0.08712671f, 0.04371826f, -0.36399001f, 0.00612982f, -0.35090128f, 0.27126002f, 0.06188689f, 0.13144130f, 
    -0.18518426f, 0.32568857f, -0.03769798f, 0.25565085f, -0.08067995f, -0.07810847f, -0.27103949f, 0.37437257f, 
    0.17453851f, -0.05446246f, 0.32907757f, -0.11192238f, -0.04553881f, 0.16469666f, 0.48597044f, 0.12009583f, 
    -0.39707467f, 0.12226465f, -0.09709489f, -0.10423496f, 0.05259134f, -0.09240517f, 0.17349465f, -0.11613615f, 
    -0.03766118f, -0.09485638f, 0.03826962f, -0.08080829f, -0.20936640f, -0.34555900f, -0.06594713f, 0.05615924f, 
    -0.02930058f, -0.04751323f, 0.14195402f, 0.00290580f, -0.07326693f, 0.08486242f, 0.17521556f, 0.07110616f, 
    -0.13332787f, -0.08650770f, -0.36366829f, -0.18946904f, 0.08526083f, 0.22320177f, 0.15488219f, -0.13994545f, 
    -0.27285010f, 0.14094110f, -0.19794504f, -0.01743733f, 0.16411878f, -0.14247616f, -0.12331604f, 0.27880749f, 
    -0.18314943f, 0.28863388f, 0.32221884f, -0.12745194f, 0.07424407f, 0.24127415f, 0.05657251f, 0.00365961f, 
    -0.36668143f, -0.37600347f, -0.16071539f, 0.33744949f, -0.13035427f, -0.06456932f, 0.05066611f, -0.21219592f, 
    0.12266005f, -0.25890762f, 0.04812882f, 0.19122103f, 0.16996852f, 0.22318038f, 0.01958588f, 0.11747865f, 
    -0.33306110f, -0.08684687f, -0.09039576f, -0.13721962f, 0.10842489f, -0.06411611f, -0.12863752f, 0.21451016f, 
    0.06224413f, -0.07325003f, 0.18885374f, 0.04586605f, -0.07450219f, 0.19986273f, 0.01065101f, 0.10785711f, 
    0.20701486f, -0.35827824f, -0.10141218f, 0.24757458f, 0.09687369f, 0.08111736f, -0.04608956f, 0.23065399f, 
    -0.09136371f, -0.25852886f, 0.05163197f, -0.00307165f, -0.28320032f, 0.47446433f, 0.41745746f, -0.11824298f, 
    0.34837523f, -0.08080333f, 0.07751346f, -0.20774893f, -0.01784822f, 0.16700277f, 0.04140419f, -0.22760327f, 
    0.08625584f, 0.28400022f, -0.31872639f, 0.01421610f, -0.41097984f, 0.26516765f, 0.06902570f, -0.13272591f, 
    0.00434682f, -0.06218599f, -0.14792334f, -0.00213111f, -0.04500908f, -0.08320530f, -0.08969502f, 0.04992233f, 
    0.01359297f, -0.04587764f, 0.00672351f, 0.20938429f, 0.14390080f, -0.18909442f, -0.13640234f, -0.05632885f, 
    0.00787547f, 0.14826973f, -0.06696759f, 0.35646993f, 0.15434584f, 0.00111290f, -0.17011145f, 0.00564729f, 
    -0.08001047f, 0.09149944f, 0.35018256f, -0.00596726f, -0.23395424f, 0.10843746f, 0.08297861f, 0.09227386f, 
    -0.17300555f, 0.06900107f, 0.02608076f, 0.26795900f, 0.27332669f, -0.14142935f, 0.33904946f, -0.14796087f, 
    0.05310437f, -0.00656424f, -0.05263122f, -0.09507392f, -0.01152202f, 0.11916413f, 0.08023466f, 0.00106135f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.05643851f, 0.31411171f, -0.14962468f, 0.16884062f, 0.08789072f, 0.07813220f, 0.01449019f, -0.02315568f, 
    0.22922967f, 0.16217704f, 0.20667188f, 0.19340377f, -0.04920492f, 0.04721607f, -0.21849564f, -0.20079973f, 
    -0.06674165f, 0.06115406f, 0.16176440f, 0.06415265f, 0.16614811f, 0.13629779f, -0.06589343f, 0.12150788f, 
    0.21934648f, 0.02603142f, 0.13800584f, 0.03275063f, 0.24068519f, 0.04759404f, 0.08061417f, 0.16206700f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.26363879f, -0.44183818f, 0.18797381f, -0.09492149f, -0.07275975f, 0.06529366f, -0.35356587f, 0.20104508f, 
    -0.33637455f, 0.02696496f, -0.63063002f, 0.18183447f, 0.20264803f, -0.14416827f, -0.26156187f, 0.22983226f, 
    0.00012135f, 0.12039004f, -0.50920093f, 0.32353872f, -0.12601452f, 0.16145404f, -0.10974689f, -0.59483314f, 
    -0.10097713f, -0.36622122f, 0.12943575f, 0.21661383f, -0.21517958f, -0.54902923f, 0.34771723f, -0.50181746f, 
    -0.09306582f, 0.05739653f, -0.93979686f, 0.18372847f, 0.02406023f, -0.02858420f, 0.24202494f, 0.10328118f, 
    -0.27621019f, -0.15315869f, -0.14473698f, 0.39257923f, 0.29359031f, 0.22941215f, 0.20550279f, -0.05542982f, 
    -0.69359666f, 0.00604160f, -0.17567796f, 0.20204034f, 0.11620317f, 0.10833191f, -0.05594569f, -0.56018966f, 
    -0.15568446f, 0.33487931f, -0.38717923f, 0.11277350f, 0.12079170f, 0.14604047f, -0.00931016f, 0.17979908f, 
    0.14119571f, -0.01490853f, -0.42036062f, -0.13616090f, -0.20226985f, -0.55381078f, -0.34684038f, 0.12588999f, 
    -0.17963010f, 0.01647353f, 0.32373536f, 0.23610905f, 0.16325170f, 0.21258427f, -0.12450588f, 0.15469177f, 
    0.31100371f, -0.05100147f, -0.03609550f, -0.17914787f, 0.01662547f, 0.08357640f, -0.22465755f, 0.23015098f, 
    -0.12649316f, -0.50235283f, 0.05899246f, 0.19775429f, -0.18776390f, 0.23989247f, -0.87668920f, -0.11285776f, 
    -0.05920003f, -0.08837532f, 0.40515968f, 0.24596106f, 0.13484401f, -0.16719013f, -0.21665959f, -1.12455022f, 
    -0.59522069f, -0.15710928f, -0.05412876f, -0.08880030f, 0.05566664f, 0.08763940f, -0.45363134f, -0.02890269f, 
    0.29615569f, -0.31365097f, 0.08705997f, -0.02823799f, 0.17100543f, 0.13511556f, -0.34498316f, -0.24018477f, 
    -0.18995219f, -0.23036857f, 0.03020554f, -0.30994293f, 0.06901884f, -0.28592199f, -0.14414294f, 0.06298982f, 
    0.24726173f, -0.50248879f, 0.24686240f, -0.23392247f, 0.19704103f, 0.06213216f, 0.14077620f, -0.06518336f, 
    0.06691968f, 0.05019271f, -0.25913870f, -0.20751283f, 0.14886163f, -0.19841793f, 0.13988662f, -0.22960012f, 
    -0.00715623f, 0.27555701f, -0.13628888f, 0.07703246f, 0.17621346f, -0.21259274f, -0.25993562f, 0.04778673f, 
    -0.39439914f, 0.36492276f, 0.08232376f, -0.19421695f, -0.39066374f, -0.13855578f, 0.15065047f, 0.10076968f, 
    0.02874842f, 0.12565054f, -0.19780172f, -0.36685240f, 0.11468593f, -0.04560206f, 0.01189825f, 0.11355298f, 
    0.66971070f, -0.03691405f, -0.24579822f, 0.09673529f, -0.19846411f, 0.26509526f, -0.03812601f, -0.11799091f, 
    -0.47037268f, 0.09571058f, -0.14611343f, 0.16547167f, 0.25561431f, 0.03622281f, -0.21531582f, -0.01605048f, 
    -0.34158647f, 0.03930413f, 0.09886351f, -0.17582785f, 0.15179844f, -0.32992059f, 0.08673839f, -0.05898776f, 
    0.14821823f, 0.11846463f, -0.08091716f, -0.47421804f, -0.58843547f, -0.07959831f, 0.29014683f, 0.15542816f, 
    -0.10638428f, 0.09582796f, 0.25873467f, -0.17712691f, -0.39954901f, -0.32008231f, -0.09636000f, -0.11984871f, 
    -0.13168511f, -0.43589097f, 0.00398802f, -0.17261490f, -0.73844534f, -0.10617723f, 0.16780500f, -0.02108758f, 
    0.31217337f, -0.24110450f, 0.13889584f, -0.08636843f, 0.02137824f, 0.41459832f, -0.61602235f, 0.00824824f, 
    0.10909722f, -0.11002001f, 0.41383758f, 0.14166789f, -0.36829847f, 0.16678508f, 0.06529364f, -0.06363751f, 
    0.04527120f, -0.13681324f, -0.24093634f, -0.29673505f, -0.28978238f, -0.05479637f, -0.46161911f, -0.15569814f, 
    0.11358183f, -0.16724184f, -0.17166083f, -0.44284925f, 0.42432520f, -0.45208573f, 0.20896904f, 0.13308662f, 
    -0.33748883f, 0.27245247f, -0.33607653f, -0.33964199f, -0.16004741f, -0.80517715f, -0.36714247f, 0.17114267f, 
    -0.33700940f, 0.37471387f, 0.00008431f, 0.24840330f, -0.47924718f, 0.14464654f, -0.06091917f, -0.05886693f, 
    0.17661814f, 0.08088204f, -0.08412516f, -0.20608442f, -0.70722950f, 0.18103287f, -0.11610656f, -0.18112381f, 
    -0.39374533f, -0.68576545f, 0.21765217f, -0.18420506f, -0.01917619f, 0.11827172f, -0.35208842f, 0.14733493f, 
    0.23967311f, 0.11645001f, -0.91949290f, -0.08563513f, 0.20842846f, -0.28236967f, -0.39666861f, 0.17986883f, 
    0.07485741f, -0.04603669f, -0.26273459f, -0.36120605f, -0.11654834f, -0.21380217f, 0.15827362f, -0.63495028f, 
    0.20651291f, -0.08116083f, 0.12550353f, -0.25716794f, 0.18727884f, -0.38722682f, 0.16863000f, -0.08140810f, 
    -0.05608892f, 0.44246656f, 0.07477687f, -0.23251177f, -0.05772233f, -0.19603929f, 0.36372134f, 0.05094118f, 
    0.12718850f, 0.12288071f, 0.14169079f, -0.08939409f, -0.65150857f, -0.30156776f, -0.08364276f, -0.01162749f, 
    -0.46788219f, 0.08333974f, -0.21786197f, 0.49050564f, 0.09163564f, -0.13747075f, -0.27731377f, -0.66948670f, 
    0.11002859f, 0.03424036f, -0.16192870f, -0.39947709f, -0.27483642f, -0.42889923f, -0.23935294f, -0.19599909f, 
    -0.27232674f, 0.05393907f, 0.26784214f, 0.14198773f, -0.20029038f, 0.07242946f, -0.22978558f, -0.20351760f, 
    0.18392098f, -0.54361463f, 0.30768225f, -0.13584229f, 0.23580392f, 0.46978867f, -0.06078043f, -0.00311730f, 
    -0.06775052f, -0.05567817f, 0.12645559f, -0.45936221f, 0.10013285f, 0.36525115f, -0.43464378f, -0.77901900f, 
    -0.40775049f, -0.04122225f, 0.01360703f, 0.41828173f, 0.33883640f, 0.22919708f, -0.50907755f, -0.37815091f, 
    -0.29263481f, -0.09593351f, 0.12195410f, -0.33303544f, -0.26557079f, -0.39073271f, -0.08661155f, -0.01023652f, 
    0.34798256f, -0.37342626f, -0.20315188f, -0.28511521f, 0.24459387f, -0.09177666f, -0.27952152f, 0.07185285f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.02600919f, 0.15648557f, -0.02129243f, -0.17860454f, -0.09912301f, 0.19074850f, 0.15072605f, -0.24211101f, 
    0.05964667f, -0.11562337f, -0.15163723f, -0.17366238f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
