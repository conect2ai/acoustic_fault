#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.16145061f, -0.30884376f, -0.55573815f, -0.41600227f, -0.25286505f, -0.99431300f, 0.33291852f, 0.21254146f, 
    1.03431296f, -0.54680985f, 0.84459662f, -0.05266346f, -0.52437621f, 0.03000951f, -0.66429728f, 0.63589519f, 
    0.38960090f, 0.50629699f, 0.70903820f, 0.29822478f, 0.39216018f, 0.54378146f, 0.36598682f, 0.54536462f, 
    0.32778186f, 0.50443840f, -0.04455518f, -0.62130010f, -0.51996875f, -0.64852089f, 0.78138554f, -0.21897398f, 
    0.21888031f, -0.08072348f, 0.84647280f, -0.37477469f, -1.23259163f, -0.67180789f, 1.02441418f, 0.07392624f, 
    0.73132414f, 0.09569186f, 0.07459173f, 0.20202512f, 0.10425104f, -1.27424169f, -0.65711010f, -0.05141874f, 
    -0.08101369f, 0.16667241f, -0.46512291f, -0.21168679f, -0.29479927f, -0.52635771f, -0.33857787f, 0.28568587f, 
    0.41676354f, 0.33996677f, 0.28672111f, 0.73461223f, -0.30429906f, -0.60374552f, -0.55401170f, -0.30886003f, 
    -0.78733844f, -0.55559707f, 0.74311793f, 0.28989822f, 0.12426292f, -0.64727181f, -0.41670504f, -0.61732697f, 
    0.63473469f, -0.01797685f, -0.37643373f, 0.07803374f, 0.83882517f, -0.34426826f, -0.36724696f, 0.21760231f, 
    -0.20559889f, -1.25855494f, 0.81274539f, -0.60372633f, 0.44094592f, -0.00874903f, -0.77080756f, -0.10922695f, 
    -0.27197576f, -0.14117776f, 0.19140062f, -0.30201128f, -0.48131865f, 0.24125066f, 1.35121059f, -0.84265608f, 
    -0.06595880f, 0.15751545f, 0.11442358f, -0.28616911f, 0.06083378f, 0.57718235f, 0.76233685f, -1.20975947f, 
    -1.09749639f, -0.44157252f, -0.19844611f, -0.17150919f, 0.17803171f, -0.04564045f, 0.74825239f, -0.64893681f, 
    -0.18164958f, 0.15240024f, 0.03106924f, 0.07236513f, 0.93273032f, -0.46564856f, -0.39898083f, -0.33932391f, 
    -0.62923652f, -0.74253285f, -0.49319562f, -0.25416353f, -0.58315438f, -0.22792931f, 1.20935845f, -1.39761996f, 
    -0.64140165f, 0.18809059f, 0.24138248f, 0.51269132f, 0.06810624f, 0.25266036f, 0.17741123f, 1.13070607f, 
    0.37695247f, 0.28702369f, -0.61857677f, 0.33136737f, -0.54567480f, -0.06474005f, 0.04918478f, 0.30126947f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16715364f, -0.05236175f, 0.23443587f, -0.23641860f, 0.16074181f, 0.33764252f, 0.07834624f, -0.10386751f, 
    0.22572906f, 0.60959065f, -0.25056714f, -0.54858387f, 0.18990056f, -0.33686092f, 0.11848930f, 0.48570892f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.06914028f, 0.01714899f, -0.41902357f, 0.01698894f, 0.06002614f, -0.13822186f, 0.22693859f, 0.08535249f, 
    0.04291818f, -0.06771481f, 0.11375123f, -0.06334089f, 0.08456271f, 0.19911458f, -0.26577482f, 0.13743816f, 
    0.30669421f, 0.25196990f, 0.04336072f, 0.05574986f, 0.21425962f, 0.12806776f, -0.00075691f, -0.02616344f, 
    -0.05640639f, 0.06102882f, 0.08535188f, -0.48923814f, 0.39422232f, 0.04065038f, 0.10222584f, 0.19912714f, 
    -0.52730107f, -0.00914616f, -0.00364997f, 0.09505545f, -0.04288575f, 0.26358095f, 0.16084854f, 0.16992943f, 
    0.10294572f, -0.07444655f, -0.07324302f, 0.10810774f, 0.20835289f, -0.48392522f, -0.24738024f, 0.23074192f, 
    0.26175719f, -0.03705657f, 0.05342738f, -0.08027042f, -0.00066045f, 0.02540216f, -0.16594659f, -0.17716618f, 
    -0.20455678f, 0.27707711f, 0.01002546f, -0.10098980f, -0.05250272f, 0.04736199f, -0.53838921f, -0.14207175f, 
    0.00314804f, -0.10239669f, 0.07767223f, -0.01772711f, -0.04746007f, -0.39647233f, -0.42126191f, -0.39547211f, 
    0.11237828f, 0.00527850f, -0.00037415f, -0.00333785f, 0.10269439f, 0.18880507f, 0.04147188f, 0.27622369f, 
    -0.19393268f, -0.08455827f, 0.13946146f, 0.39300558f, 0.13125245f, -0.10692136f, 0.10844128f, -0.05489946f, 
    0.31026313f, 0.03114977f, 0.29357514f, 0.05608872f, 0.11292592f, 0.20545952f, -0.02812275f, 0.44324064f, 
    0.10503912f, 0.10350578f, 0.00897818f, -0.12673137f, -0.17391713f, -0.12800466f, 0.10586248f, 0.13249946f, 
    0.06098931f, 0.21110725f, -0.23466456f, 0.02903584f, 0.06336277f, 0.15575694f, 0.25435728f, 0.13398699f, 
    0.10116777f, 0.17092930f, -0.12069981f, -0.05046175f, 0.18283728f, -0.23748216f, -0.13115035f, -0.14849919f, 
    0.24780855f, 0.20411240f, 0.18190277f, 0.07113149f, -0.03933442f, -0.03744654f, 0.14430016f, -0.01937619f, 
    0.41639352f, -0.08968315f, 0.12833524f, 0.07964335f, -0.17101172f, -0.01882457f, 0.24796560f, -0.00086927f, 
    0.18993697f, 0.37339222f, 0.04073040f, 0.04286506f, -0.00017732f, 0.09684382f, 0.21687984f, 0.08788376f, 
    -0.07107116f, -0.03265549f, -0.08350180f, -0.09701020f, -0.08064608f, -0.07927012f, -0.04964064f, -0.00931187f, 
    0.00843655f, -0.05128235f, 0.00636874f, -0.07036685f, -0.08507072f, 0.01151728f, -0.01784168f, -0.01085600f, 
    -0.08831568f, -0.11156020f, -0.09629159f, -0.05845254f, 0.04721552f, 0.01305390f, -0.12149477f, 0.00348532f, 
    -0.03740132f, -0.04694598f, 0.03975438f, 0.04893647f, -0.05727556f, -0.06974822f, -0.02109949f, 0.02103390f, 
    -0.01254433f, 0.01192255f, 0.06777310f, 0.00267511f, -0.08271357f, -0.08866881f, 0.01923644f, -0.05771308f, 
    -0.03900852f, 0.03530350f, -0.02106166f, -0.07643146f, 0.03365633f, -0.09624649f, -0.00702339f, 0.00122344f, 
    0.00822925f, -0.11718093f, 0.00837460f, 0.05486787f, -0.04352557f, -0.11345568f, 0.03481824f, -0.10668381f, 
    0.00566075f, -0.00276843f, -0.00726996f, -0.02050404f, -0.01641396f, -0.09997346f, -0.10869929f, -0.08745659f, 
    0.02817876f, -0.01037065f, -0.03967050f, -0.05027066f, 0.03941739f, -0.05121546f, -0.03863770f, 0.04026327f, 
    0.02696183f, -0.06420552f, 0.01671087f, -0.05822574f, -0.02952447f, -0.10178635f, -0.11554725f, 0.03549925f, 
    -0.02059166f, 0.01847942f, -0.04497215f, 0.04626538f, -0.00420216f, -0.04349619f, -0.09391360f, 0.00848540f, 
    -0.09173068f, -0.04088587f, -0.05561111f, -0.06246337f, -0.04045956f, -0.04082821f, 0.03092960f, 0.01814728f, 
    0.02865823f, -0.02967730f, -0.07424178f, 0.01858442f, 0.01876699f, -0.05673874f, 0.00631371f, 0.00879472f, 
    0.01521168f, -0.00393088f, -0.01546090f, 0.02959344f, 0.01861086f, -0.08550722f, -0.06982933f, 0.03024184f, 
    -0.04299097f, -0.09409528f, 0.02291284f, -0.10072248f, -0.05282677f, -0.06558303f, 0.02924435f, -0.02499365f, 
    0.05889992f, 0.01093095f, -0.04472839f, -0.07908179f, -0.08392090f, -0.07672715f, -0.07930341f, -0.09277137f, 
    -0.00937750f, -0.08995987f, -0.11386625f, -0.02924602f, -0.08597812f, -0.11366091f, -0.06307171f, -0.12462496f, 
    -0.02764513f, -0.08720695f, 0.00047532f, -0.07846921f, -0.03841321f, 0.03634704f, 0.02444476f, -0.05055230f, 
    -0.13857625f, 0.23272975f, -0.17958029f, -0.19550088f, 0.07225617f, -0.04853664f, -0.06254048f, 0.01757554f, 
    0.22154096f, 0.12565701f, 0.26443285f, -0.11628003f, -0.02127828f, 0.23595507f, 0.03589619f, -0.10826151f, 
    -0.09998325f, -0.01213359f, 0.40276161f, 0.03390912f, 0.25028843f, 0.03253141f, -0.20929530f, -0.11490102f, 
    0.08714812f, -0.01830153f, 0.03703896f, -0.20062307f, -0.48045129f, -0.41719732f, 0.04442748f, -0.09784949f, 
    -0.16312523f, 0.08659871f, 0.10959817f, 0.02291551f, 0.23505028f, 0.13360690f, 0.11441385f, 0.02895763f, 
    -0.35671034f, -0.22037318f, 0.11422086f, 0.09115994f, -0.23233742f, -0.10856274f, -0.04799495f, -0.52728325f, 
    0.12978941f, -0.13215385f, -0.11111483f, 0.20290726f, 0.10119499f, -0.03361866f, 0.23140085f, 0.23615393f, 
    0.36034971f, -0.26416457f, -0.00386918f, 0.17849220f, -0.04681395f, 0.02724053f, 0.05179069f, 0.06541385f, 
    -0.16776527f, -0.58512163f, 0.07237546f, -0.17835605f, -0.00422941f, -0.05613145f, -0.07742458f, -0.01293593f, 
    0.27446896f, 0.10936114f, 0.18934193f, -0.01583343f, 0.13376592f, -0.10737599f, 0.15869482f, 0.04392681f, 
    0.28257415f, -0.80641609f, -0.60056973f, -0.44704947f, 0.00060443f, 0.28135049f, -0.06103318f, 0.02113345f, 
    -0.07479249f, -0.17595859f, 0.34726968f, 0.05380657f, -0.04015578f, -0.29433307f, -0.41354838f, -0.23861599f, 
    0.19553339f, 0.01095772f, -0.15169132f, -0.05949139f, -0.01867641f, 0.28389025f, -0.12027792f, -0.13443452f, 
    0.28614825f, 0.05642968f, 0.07707696f, 0.02110407f, 0.10851219f, 0.11481411f, 0.19474612f, 0.05026024f, 
    0.05600274f, -0.06092984f, 0.14580850f, 0.01867575f, -0.06327844f, -0.01006735f, -0.35106045f, 0.71356034f, 
    -0.06123737f, -0.14283276f, 0.01789618f, 0.11756571f, 0.11249892f, 0.52924395f, 0.50489837f, -0.20329820f, 
    0.20355205f, 0.03372106f, -0.09107689f, 0.09090721f, 0.00060110f, -0.01032979f, 0.10765953f, 0.39925435f, 
    -0.08124710f, 0.03551300f, 0.04715395f, 0.09923381f, 0.09933957f, 0.23012903f, -0.08597955f, 0.11456284f, 
    -0.21802726f, -0.15247092f, -0.07047872f, 0.06214808f, -0.03657827f, 0.11154759f, 0.05972971f, 0.00969118f, 
    -0.01589197f, 0.14751491f, -0.21363041f, -0.16693519f, 0.00533467f, 0.06902644f, -0.16196848f, 0.15949051f, 
    0.31937975f, -0.16726322f, 0.10376516f, 0.34567517f, -0.04851012f, -0.12841657f, -0.06995684f, -0.10556099f, 
    0.05868097f, -0.01332034f, 0.13588519f, 0.18446724f, -0.02935732f, -0.76331258f, -0.25620019f, -0.06512260f, 
    0.02066934f, -0.26663825f, -0.21831289f, -0.04965968f, 0.24551967f, -0.57055712f, -0.91610801f, -0.02462208f, 
    0.05639378f, 0.19772598f, 0.16428357f, -0.01629248f, -0.00295176f, 0.38895437f, -0.04350010f, -0.63833690f, 
    -0.08403540f, 0.05363284f, 0.34565610f, 0.04751780f, -0.02322697f, 0.14834400f, -0.20341332f, -0.24973084f, 
    0.11137973f, -0.09999285f, -0.08482460f, -0.08098234f, 0.09589470f, -0.07885884f, 0.44149241f, 0.07689975f, 
    -0.15359798f, -0.39056957f, -0.11130135f, -0.09512007f, 0.12981212f, -0.06579855f, -0.04794655f, -0.05847162f, 
    0.01122511f, 0.09334892f, -0.09164363f, 0.08106855f, 0.16387336f, -0.05628198f, 0.00844571f, 0.06806116f, 
    0.04327686f, -0.40954894f, -0.30397397f, -0.38830039f, 0.10421012f, 0.06323875f, 0.36251789f, 0.15160462f, 
    0.12080289f, -0.06148875f, -0.31489024f, 0.17790684f, -0.48257491f, -0.00504898f, 0.05043159f, -0.14672109f, 
    0.19222784f, -0.11411703f, -0.26988858f, -0.66843683f, 0.44178358f, -0.11237238f, -0.08821227f, -0.34667873f, 
    0.07734652f, 0.12213076f, -0.00158960f, 0.14708461f, 0.35904437f, 0.05457803f, 0.25103250f, -0.06189675f, 
    0.18164329f, -0.02743559f, 0.10724569f, 0.08043928f, 0.00226222f, 0.30892476f, -0.05568215f, -0.35204867f, 
    -0.31107002f, -0.25793174f, 0.10675058f, 0.16473910f, 0.02897326f, 0.11860999f, -0.32659352f, -0.52765518f, 
    -0.37414846f, -0.08890101f, 0.28285193f, -0.06677802f, 0.15630338f, -0.00337218f, 0.06086706f, 0.38901883f, 
    0.37384826f, 0.23925616f, 0.04114683f, -0.06079225f, -0.00543150f, -0.02682154f, 0.13909316f, 0.12521955f, 
    0.52520216f, 0.30882999f, 0.37643653f, -0.12717709f, -0.05560635f, 0.04589035f, -0.17679849f, -0.06174173f, 
    0.11501966f, 0.20684832f, 0.06676150f, -0.19609833f, 0.17782432f, -0.22555035f, 0.14054461f, -0.23173994f, 
    0.37064219f, -0.04670196f, -0.18913671f, 0.04295899f, -0.14388841f, -0.03326850f, -0.36173025f, -0.04224394f, 
    0.12229861f, -0.00711038f, 0.29693118f, -0.28227052f, -0.12299675f, -0.07458338f, -0.03413777f, 0.16552939f, 
    0.04588821f, 0.20985383f, -0.03559431f, 0.08902831f, -0.38526046f, -0.39649627f, -0.02474352f, -0.19356148f, 
    0.13818663f, 0.09663232f, 0.01783059f, 0.17366447f, 0.22571112f, -0.07276318f, -0.23663066f, 0.28596842f, 
    0.03305263f, -0.07958758f, 0.01050599f, 0.12506212f, -0.11511853f, -0.03574971f, -0.10620513f, -0.21854708f, 
    0.03241425f, -0.26658875f, -0.19013430f, -0.13479601f, -0.03972305f, -0.04659232f, 0.03885274f, -0.01455421f, 
    -0.22509441f, -0.06172866f, 0.06170031f, -0.01389835f, -0.20573975f, 0.43280318f, 0.09256108f, 0.05852071f, 
    -0.00734114f, 0.18747476f, -0.06423938f, -0.03566013f, 0.08495923f, -0.10724197f, -0.00523747f, 0.07790056f, 
    -0.18414426f, -0.10196320f, 0.29404190f, 0.01307812f, -0.18698624f, -0.08766306f, 0.21337554f, 0.33808687f, 
    -0.01998273f, -0.11186454f, -0.68736839f, 0.21569319f, -0.13507487f, -0.34578738f, 0.19602154f, 0.04290482f, 
    0.24216361f, 0.22285590f, -0.12662181f, -0.06398647f, -0.00677169f, -0.22168452f, -0.11223574f, 0.09336741f, 
    -0.02579660f, 0.11267614f, 0.01087958f, -0.08222882f, 0.14208557f, -0.54626501f, -0.36225709f, -0.11006943f, 
    0.12523314f, -0.03308177f, -0.02011799f, 0.05153736f, -0.05268518f, 0.02470862f, 0.37664497f, 0.36360139f, 
    -0.12874693f, -0.00607543f, 0.04207942f, 0.25232613f, -0.06295252f, 0.00160209f, 0.33659062f, 0.10801905f, 
    -0.63955021f, 0.01979673f, 0.07412069f, 0.00820930f, 0.04693314f, 0.12115151f, 0.11122324f, 0.29924512f, 
    -0.58245701f, -0.51749170f, -0.13735324f, -0.00550047f, -0.07613192f, 0.04828249f, -0.04680697f, 0.22011249f, 
    -0.23075257f, -0.23033658f, -0.16863032f, 0.23563562f, 0.26917738f, 0.00663501f, 0.06570987f, -0.16846512f, 
    -0.39981961f, -0.13743050f, -0.00234107f, -0.09619721f, 0.28244790f, -0.23164368f, -0.06873936f, -0.26401377f, 
    -0.49480245f, -0.32244772f, 0.17425020f, 0.03141691f, -0.01376512f, 0.13558903f, 0.11801182f, 0.15904373f, 
    0.19590256f, -0.12181022f, -0.13025020f, -0.06004976f, -0.21300183f, 0.25995618f, -0.12608352f, -0.19837832f, 
    0.25584111f, 0.20137949f, -0.36787602f, 0.15801226f, 0.14985596f, 0.00677803f, -0.00841140f, 0.15272206f, 
    0.38680667f, 0.00332114f, 0.07815420f, -0.05307548f, -0.03873160f, 0.07636219f, 0.08282726f, -0.05714560f, 
    0.09653068f, -0.08003228f, 0.18064293f, 0.13877997f, 0.05593749f, 0.24691370f, -0.27626631f, 0.03484807f, 
    -0.23403816f, 0.21968187f, 0.20878230f, 0.11654109f, 0.19381420f, 0.13409562f, 0.02249859f, -0.31055462f, 
    -0.05696762f, 0.03260836f, 0.19619590f, 0.04194494f, 0.15219112f, 0.11678640f, 0.28138569f, 0.18258454f, 
    -0.20330389f, 0.30768228f, 0.12043437f, 0.21777083f, 0.10704594f, 0.14375496f, 0.23789127f, 0.18738084f, 
    0.24106517f, 0.04617459f, 0.03923043f, -0.03427849f, 0.22131518f, 0.00276969f, 0.02646769f, 0.30647713f, 
    0.18059197f, 0.46991086f, -0.16124561f, 0.06882040f, -0.02286870f, 0.15559095f, 0.24320576f, 0.14728823f, 
    -0.33108708f, -0.02566887f, 0.08031932f, 0.50525808f, 0.15416339f, 0.04125939f, 0.02494841f, 0.06070068f, 
    0.33083096f, 0.24328078f, 0.15491782f, 0.18048656f, -0.01496396f, 0.17845014f, -0.06116993f, -0.12811287f, 
    -0.06534751f, 0.13806517f, 0.08420909f, -0.22565511f, -0.41237542f, -0.20027387f, -0.00286779f, 0.06550940f, 
    0.34221596f, 0.13861232f, 0.22593693f, -0.03256584f, -0.06576580f, 0.07116719f, -0.18205719f, 0.16434030f, 
    0.30436108f, 0.06722313f, 0.10281824f, 0.03335255f, 0.01366727f, -0.01196449f, -0.00093376f, 0.17899171f, 
    0.31204677f, -0.12264013f, -0.05060054f, -0.00335970f, -0.12199959f, 0.13322824f, -0.01699284f, -0.05717187f, 
    0.23743697f, 0.43530506f, 0.06711524f, -0.01685634f, -0.38153613f, 0.10050052f, 0.10107590f, -0.08964273f, 
    -0.09985576f, 0.01767691f, -0.14389800f, 0.20258377f, -0.38690120f, 0.15876116f, 0.14209692f, 0.01557369f, 
    0.13377362f, -0.06113769f, 0.18349878f, 0.14746983f, -0.01121583f, -0.03771648f, -0.03784310f, -0.44730535f, 
    0.08216888f, 0.01183365f, 0.14940622f, -0.02552533f, -0.13126025f, -0.15319116f, 0.19702749f, 0.09071975f, 
    -0.15190093f, -0.03660003f, 0.24608004f, -0.01784079f, 0.54777664f, 0.03916183f, -0.25102848f, -0.14969695f, 
    -0.10369176f, 0.08945280f, -0.00551723f, -0.04340295f, -0.15599123f, 0.37299815f, 0.10836796f, -0.14425597f, 
    -0.06645021f, 0.06457900f, 0.20022433f, -0.10402130f, 0.01851274f, 0.05400385f, 0.33273941f, -0.38633505f, 
    0.21179369f, -0.07246299f, -0.27261245f, -0.20995013f, -0.05293249f, -0.01650549f, -0.04019273f, 0.38104799f, 
    -0.23854256f, -0.49821860f, -0.09859253f, 0.06421560f, 0.03581344f, 0.10039394f, 0.03586173f, 0.11411466f, 
    0.11348382f, 0.08125133f, -0.32687986f, -0.02235606f, -0.13156086f, 0.13803151f, -0.00797990f, -0.01761546f, 
    -0.18600333f, 0.11648724f, 0.22189665f, -0.37861407f, -0.25902566f, 0.18317635f, 0.38934332f, 0.04591303f, 
    -0.01954648f, -0.07012606f, 0.25056726f, 0.39911672f, -0.64852041f, 0.10174497f, 0.07326338f, 0.10310104f, 
    0.00021272f, 0.13975558f, 0.11822662f, -0.18071720f, 0.49941748f, -0.39335006f, -0.36616576f, -0.21178421f, 
    -0.12222731f, 0.13591412f, -0.01145640f, 0.17205587f, -0.19175711f, -0.01990305f, 0.30051017f, -0.25552353f, 
    0.15220121f, -0.30037996f, 0.18544108f, 0.22500351f, 0.01249240f, 0.08874577f, 0.23082425f, 0.20828511f, 
    -0.22228448f, 0.09848327f, 0.02189873f, 0.06710577f, 0.09995922f, -0.04919168f, -0.17487678f, -0.27155113f, 
    -0.72085100f, -0.00377705f, 0.04397487f, -0.01451370f, 0.09086326f, 0.14813434f, -0.14123140f, -0.76456821f, 
    -0.29514739f, 0.47789207f, -0.09179544f, -0.23727138f, 0.05257797f, 0.17728767f, 0.16422141f, 0.06763194f, 
    0.28075355f, -0.02061542f, 0.00315692f, -0.21673948f, -0.02768762f, 0.05017209f, 0.29411468f, 0.19185714f, 
    0.34446833f, -0.08013128f, 0.01661818f, 0.06946131f, -0.09706952f, -0.04123368f, 0.19334288f, 0.23702213f, 
    0.25735378f, 0.17682569f, -0.22465758f, -0.05124369f, 0.01143678f, -0.05077011f, -0.23696077f, -0.21217062f, 
    -0.23354337f, -0.14630547f, -0.01634450f, -0.18642394f, 0.31144735f, -0.11982299f, 0.17705309f, 0.07169344f, 
    -0.36967438f, -0.12419165f, 0.17597049f, 0.18084551f, 0.00537917f, 0.00881076f, -0.07239471f, 0.18691425f, 
    -0.02842252f, -0.20645976f, -0.05860800f, 0.03224152f, -0.10063466f, 0.05897079f, 0.06871691f, -0.45098716f, 
    0.08883353f, -0.12721074f, 0.02751920f, -0.00286419f, -0.19299604f, 0.10165941f, -0.21477160f, -0.05578168f, 
    0.21357472f, 0.13919479f, 0.12072530f, 0.00708599f, -0.14965808f, -0.47817066f, -0.40846515f, 0.04223268f, 
    0.02439941f, -0.07112268f, 0.03921396f, -0.07167059f, -0.05866320f, -0.17776303f, -0.43961748f, -0.25261724f, 
    -0.51341265f, -0.34319887f, 0.22802578f, 0.10933119f, 0.22160318f, 0.24915878f, 0.13137008f, -0.29020774f, 
    -0.11610009f, 0.13571604f, 0.08491386f, 0.01072777f, 0.13215463f, 0.08566672f, 0.03472413f, -0.09576178f, 
    -0.15270507f, 0.07284261f, 0.11930610f, -0.14864202f, 0.08231686f, 0.13260856f, 0.35440528f, -0.12071639f, 
    0.06046196f, -0.01785615f, 0.25278002f, 0.25251320f, -0.41220722f, 0.03369712f, 0.09390346f, -0.00000414f, 
    0.12902533f, -0.01486041f, -0.11900674f, -0.19378279f, 0.05335110f, -0.10300478f, 0.00722183f, 0.02624841f, 
    0.24321610f, -0.12755340f, 0.04662651f, 0.22238648f, 0.11365171f, 0.34314275f, 0.16637520f, -0.39492872f, 
    0.07810074f, 0.08711223f, -0.02556480f, 0.04073094f, 0.17227113f, -0.10656820f, 0.04295205f, -0.22457257f, 
    -0.12803125f, 0.08542586f, 0.23736577f, 0.17237845f, 0.10058568f, -0.05520117f, 0.15723062f, -0.32717273f, 
    -0.07885069f, -0.02882316f, -0.00003430f, 0.03429391f, -0.06256790f, -0.01066590f, -0.10543889f, -0.06520276f, 
    -0.02921584f, 0.01426858f, 0.48841876f, -0.21865012f, 0.10625547f, -0.14954813f, 0.14960432f, 0.07686743f, 
    -0.15045503f, 0.12926191f, 0.12877271f, -0.17322007f, -0.08958703f, 0.31058607f, 0.06936286f, -0.00111626f, 
    0.30567732f, 0.17957501f, -0.13370898f, -0.03194205f, 0.19935772f, -0.13648629f, -0.02578681f, -0.25508282f, 
    0.12696101f, 0.07998030f, 0.01658357f, 0.13890781f, -0.31306297f, 0.33261988f, -0.16631329f, 0.20467803f, 
    0.04023702f, 0.05071386f, -0.21495630f, 0.10823146f, 0.02242833f, 0.06403644f, -0.31989709f, 0.23913679f, 
    0.15201773f, -0.39218804f, 0.03786125f, -0.04632362f, 0.15154660f, 0.31918219f, 0.05228112f, 0.12240981f, 
    0.05851597f, 0.16475753f, -0.04779234f, -0.03346126f, 0.07762040f, 0.13049328f, -0.15955830f, 0.11724338f, 
    -0.19185849f, -0.10153544f, -0.12635878f, -0.21027692f, -0.24007539f, -0.23859142f, -0.06029798f, 0.44957650f, 
    -0.16275375f, -0.05008527f, 0.07737373f, -0.08808343f, -0.11319149f, -0.18853232f, -0.16575241f, 0.17018433f, 
    -0.03881385f, -0.15783688f, 0.26023731f, 0.11393460f, -0.03164072f, 0.16034767f, -0.13208057f, 0.29795027f, 
    -0.02661421f, 0.09072831f, -0.27871540f, 0.12620941f, -0.26900557f, 0.06652192f, 0.01987338f, -0.06109122f, 
    -0.14935459f, -0.03329916f, -0.32296640f, -0.02300565f, 0.33159688f, -0.22386278f, -0.17322648f, -0.29327133f, 
    0.18172638f, 0.13800710f, 0.04877863f, -0.18416636f, 0.37227571f, 0.98391926f, -0.14574455f, 0.21736562f, 
    -0.13244167f, 0.18683112f, 0.09858057f, -0.30315140f, -0.03326021f, 0.40953457f, -0.43078977f, -0.03093485f, 
    -0.08065449f, -0.05492961f, 0.12438457f, 0.08981475f, 0.08842454f, -0.16016592f, -0.27936047f, 0.47147188f, 
    -0.02845391f, -0.11651045f, 0.04152581f, 0.19616593f, 0.25401446f, 0.01472149f, -0.31954744f, -0.47979346f, 
    -0.06201484f, -0.21339940f, 0.11903380f, 0.34345704f, -0.17495970f, -0.00131734f, 0.01755787f, -0.01330928f, 
    0.45575261f, 0.13834909f, -0.06427223f, 0.08314759f, 0.19898053f, -0.07153837f, 0.13095291f, -0.00863694f, 
    0.46704778f, 0.51044691f, 0.49513602f, 0.13849688f, 0.04948754f, -0.11857014f, 0.20620620f, 0.10147337f, 
    0.04730016f, 0.34823957f, 0.17167513f, 0.21633703f, -0.03700854f, 0.07093187f, -0.04618473f, 0.18715668f, 
    0.10885555f, -0.11365362f, 0.08967222f, -0.18908860f, -0.04857760f, 0.01823644f, -0.15720519f, -0.17220452f, 
    -0.00210187f, 0.11015714f, 0.09152288f, 0.34298718f, 0.20564666f, 0.50150204f, -0.14412658f, -0.22775176f, 
    -0.09021261f, 0.02964427f, 0.04248719f, 0.06163570f, -0.03735961f, -0.03829676f, -0.09627696f, -0.22267142f, 
    -0.04118095f, -0.04743116f, -0.13104829f, 0.23475039f, -0.01494525f, 0.22179560f, 0.03281721f, 0.23277144f, 
    -0.10053577f, 0.08564238f, -0.18863267f, -0.01979038f, 0.06526516f, 0.06837978f, 0.03924270f, -0.06956404f, 
    0.04543588f, -0.02600391f, 0.00086430f, -0.11201898f, 0.13094881f, 0.03999197f, -0.01301690f, 0.21963926f, 
    0.06322350f, 0.36750799f, -0.00096675f, 0.01746296f, -0.13969831f, 0.03954901f, -0.18328971f, -0.05268098f, 
    -0.26598707f, -0.14708613f, 0.07153159f, 0.11521201f, -0.25910783f, -0.04791774f, -0.09041961f, 0.16142876f, 
    -0.00992430f, 0.08752827f, -0.31985736f, -0.08941907f, -0.18796645f, 0.01602133f, -0.16544150f, -0.02944550f, 
    0.00059267f, -0.03780324f, 0.08920647f, -0.42289546f, 0.43693164f, -0.39114660f, -0.21854471f, -0.18270433f, 
    0.08634280f, 0.14793573f, 0.10625669f, 0.07511886f, -0.34120774f, -0.03214922f, -0.21586286f, 0.06789465f, 
    -0.17902566f, 0.01882813f, -0.22651806f, 0.00272477f, 0.05849066f, -0.02882121f, -0.02040107f, 0.23556733f, 
    -0.15045725f, -0.15838993f, -0.00363512f, 0.05590774f, 0.11217649f, 0.27135038f, 0.35237676f, 0.50422865f, 
    0.05030622f, 0.00004204f, 0.03793030f, 0.03500838f, 0.07670580f, 0.16375087f, -0.39688325f, 0.05820433f, 
    -0.09724738f, 0.23475318f, -0.11359052f, -0.12398711f, -0.05862011f, -0.21102062f, 0.25588551f, -0.30497235f, 
    -0.36581111f, -0.11449324f, -0.01395433f, -0.14318988f, -0.10525581f, 0.06538580f, 0.09339019f, 0.03698700f, 
    0.04496130f, 0.06004355f, 0.03588860f, -0.11401320f, -0.10398313f, -0.06728769f, 0.04768312f, -0.06320181f, 
    0.16143335f, -0.19119844f, -0.14203028f, 0.14091778f, 0.06058947f, 0.01841390f, -0.10844275f, -0.25539973f, 
    0.08521715f, 0.00914515f, 0.12403440f, -0.23020658f, 0.00922015f, -0.20754375f, -0.04723558f, 0.13782278f, 
    0.05318695f, 0.13775882f, 0.04949405f, -0.58046705f, -0.18969156f, 0.00986806f, -0.00648544f, 0.17760970f, 
    0.16750795f, -0.06732912f, 0.02645644f, -0.08778563f, 0.17289710f, -0.11655576f, -0.25457323f, -0.00901960f, 
    -0.07845263f, 0.28822717f, -0.02283780f, 0.14199647f, 0.23422620f, 0.59495068f, -0.01896979f, 0.21108466f, 
    0.19368750f, 0.09501816f, 0.22148216f, -0.01632364f, 0.09406353f, -0.04660942f, -0.33004645f, -0.34273204f, 
    0.04771801f, 0.00227496f, -0.05735183f, 0.04877112f, 0.02795208f, 0.11534041f, -0.15211292f, 0.04712791f, 
    0.29097173f, 0.51207465f, -0.00452475f, -0.04904622f, -0.07013693f, 0.27568665f, 0.09801999f, 0.00609996f, 
    0.62480265f, -0.64715195f, -0.31812978f, -0.18897070f, -0.19989109f, -0.04224534f, -0.24599139f, -0.01407696f, 
    -0.05875144f, -0.09468934f, 0.24456002f, -0.06650073f, 0.10241400f, 0.20418787f, 0.23476803f, -0.16403393f, 
    0.10703775f, -0.11824165f, -0.05448183f, -0.70171028f, -0.50762808f, -0.18983853f, 0.20136110f, 0.19615643f, 
    -0.00377494f, 0.05292044f, -0.00168867f, -0.52339953f, 0.33634308f, -0.53711492f, -0.19673732f, -0.31379917f, 
    -0.26148707f, -0.04056761f, 0.05371768f, 0.30780026f, 0.13290657f, 0.05950445f, -0.24427339f, -0.10718337f, 
    0.03564196f, -0.02252937f, 0.20283428f, 0.17823432f, 0.21744968f, 0.08717961f, -0.00349845f, -0.11123609f, 
    -0.11086116f, -0.11929491f, 0.06845876f, 0.00632147f, 0.09954020f, 0.05044057f, 1.16294432f, 0.22164834f, 
    -0.54511559f, 0.00022174f, -0.15572470f, 0.03723925f, 0.06384804f, 0.18964835f, -0.10802174f, -0.15768844f, 
    -0.11872090f, 0.05466487f, -0.26062351f, -0.03412081f, -0.11600533f, 0.00580240f, 0.15536284f, 0.12111967f, 
    -0.43230662f, 0.04381387f, -0.33090028f, 0.21476899f, -0.00084187f, -0.07561939f, 0.02284632f, 0.03864511f, 
    -0.06962331f, -0.43354356f, -0.28154069f, 0.16407156f, -0.15407395f, 0.00476525f, 0.03868215f, -0.01155146f, 
    -0.01306926f, 0.10621870f, 0.19671248f, 0.31599209f, 0.22526732f, -0.18697837f, -0.12965751f, 0.04514012f, 
    -0.03556037f, -0.02547446f, -0.00108799f, -0.51220840f, -0.40952364f, 0.37947133f, 0.22262704f, -0.03931257f, 
    0.05364345f, -0.10063906f, -0.11187297f, 0.02565849f, -0.18065435f, -0.12956011f, 0.03433510f, -0.17963111f, 
    -0.13696216f, 0.41124550f, 0.11097519f, 0.07003848f, 0.02518121f, 0.31815931f, -0.87249404f, -0.68301678f, 
    -0.07156339f, -0.02751501f, 0.04727623f, -0.00394051f, 0.05063297f, 0.01467989f, -0.14262868f, 0.45216578f, 
    0.12366077f, 0.04127458f, -0.03418969f, -0.04298367f, -0.02472281f, -0.19087635f, 0.41300291f, 0.15652753f, 
    -0.55755973f, 0.11329360f, -0.24362689f, -0.06838059f, -0.10616206f, 0.02540426f, -0.00296591f, -0.00668912f, 
    -0.10675839f, 0.11734276f, 0.28838247f, 0.33973563f, 0.02052020f, 0.03134371f, 0.15831013f, 0.04891853f, 
    0.30764335f, -0.01556707f, -0.10123298f, -0.10385168f, 0.06168110f, 0.06393486f, 0.04085131f, 0.18458925f, 
    0.14989686f, 0.10378209f, -0.30262524f, -0.03685227f, -0.01147780f, -0.01197255f, -0.11063612f, -0.00989368f, 
    -0.07838351f, 0.03114033f, 0.04459893f, -0.32854643f, -0.01339637f, -0.78336751f, -0.17213473f, 0.24558742f, 
    -0.14127848f, 0.09225520f, -0.20507258f, 0.29121959f, 0.33744973f, -0.01806173f, -0.28280941f, -0.15288685f, 
    0.05677744f, 0.04868139f, 0.02592662f, 0.03600321f, -0.04698908f, -0.74649227f, -0.43095684f, -0.02626602f, 
    -0.07299728f, -0.04726600f, -0.06642062f, -0.02866085f, -0.01391588f, 0.20988980f, -0.15514269f, 0.44132391f, 
    -0.58143401f, -0.27633485f, 0.24073827f, -0.01605150f, 0.08483640f, -0.11871827f, 0.01302454f, 0.54462516f, 
    -0.12582889f, -0.02069694f, -0.14776491f, -0.04040644f, 0.03790819f, 0.03883765f, 0.14706837f, -0.11401509f, 
    -0.19618648f, -0.18033038f, 0.49759024f, 0.13253465f, 0.19518989f, -0.01001748f, 0.01657927f, 0.20179300f, 
    0.25253737f, -0.22931147f, -0.25419697f, -0.05888998f, 0.19454840f, -0.13688278f, -0.20779908f, 0.06234629f, 
    0.01780504f, 0.02612571f, -0.14617480f, -0.03120997f, -0.12615664f, -0.24362469f, -0.17345351f, -0.05205541f, 
    0.26999906f, 0.19923553f, 0.08683566f, -0.96181232f, -0.00844805f, 0.29228067f, -0.00253881f, 0.15820880f, 
    -0.12610450f, -0.13749357f, -0.03016209f, 0.13335085f, 0.41486171f, -0.12235261f, -0.15389509f, 0.36279240f, 
    0.09533421f, -0.08248763f, -0.00482205f, -0.16994512f, 0.02671519f, -0.36860731f, 0.38163143f, 0.34824944f, 
    0.03389213f, -0.02747121f, 0.24890856f, 0.02951552f, 0.13566390f, 0.09441879f, -0.10290432f, -0.27110505f, 
    -0.39017957f, -0.06342535f, -0.04358877f, -0.02454397f, 0.09235105f, 0.00808783f, 0.08270556f, -0.19485347f, 
    0.12540948f, 0.18044336f, 0.11147235f, -0.11477620f, 0.04169113f, 0.15703686f, -0.10242388f, 0.17906801f, 
    0.05459109f, 0.14394656f, -0.26034173f, -0.15105352f, -0.05430602f, -0.02855986f, 0.15345335f, 0.19926280f, 
    0.17304510f, 0.33832750f, 0.38052362f, 0.34124094f, 0.22109103f, 0.14592314f, 0.13393378f, 0.17614301f, 
    0.25019032f, -0.04437043f, -0.15237314f, -0.36008370f, -0.13816461f, -0.17056957f, 0.13750829f, -0.22875662f, 
    0.25918156f, 0.20624007f, -0.01753932f, -0.81152296f, -0.14444271f, 0.33172196f, -0.08203898f, -0.05261569f, 
    -0.31903821f, 0.42043066f, -0.10450398f, -0.28758049f, -0.12237597f, -0.37152529f, -0.46148038f, -0.00954477f, 
    -0.05928732f, 0.13376185f, 0.12761514f, 0.34156552f, 0.28113243f, -0.43313652f, -0.34927025f, -0.12629823f, 
    0.06366668f, -0.08892765f, 0.15151629f, -0.00383638f, -0.04122475f, -0.07933295f, 0.06638022f, 0.26893622f, 
    0.26010364f, -0.01849663f, 0.04569548f, 0.14135402f, 0.13299578f, 0.21392232f, 0.08888727f, -0.28266570f, 
    0.12362579f, -0.16304204f, 0.04480553f, -0.01930618f, 0.06645989f, -0.05254084f, 0.13341658f, 0.20130837f, 
    0.20189422f, -0.04306534f, -0.25527665f, 0.26865426f, -0.17741565f, 0.18159579f, 0.07671042f, 0.05835336f, 
    -0.17320560f, -0.12207943f, 0.18010323f, -0.08227462f, 0.11630675f, -0.21368225f, 0.00132686f, -0.31481263f, 
    -0.16181827f, -0.05312328f, 0.24617444f, 0.20234962f, -0.03405362f, 0.06669708f, 0.03743795f, 0.05490771f, 
    -0.07916179f, -0.04098161f, 0.02897232f, -0.43405074f, -0.42448309f, -0.07212000f, 0.05441477f, 0.17354603f, 
    0.02114129f, 0.05147684f, -0.33565712f, -0.05498996f, 0.28950498f, -0.32743809f, -0.18649836f, 0.02193256f, 
    -0.04606993f, 0.20750381f, -0.01466998f, -0.16141067f, -0.25195840f, 0.23120400f, 0.04221204f, 0.21775673f, 
    0.07924502f, -0.02471339f, 0.18567057f, 0.12134485f, -0.05257735f, 0.16074447f, 0.18482682f, 0.07991387f, 
    -0.25646260f, 0.04974065f, 0.01240935f, 0.30692250f, 0.01905865f, -0.08143407f, -0.10548917f, -0.03099548f, 
    0.02001300f, 0.02839213f, -0.25174573f, 0.01154095f, 0.12458087f, 0.09078453f, 0.17023131f, 0.05030219f, 
    -0.26907969f, 0.48435566f, -0.11148509f, 0.16933388f, -0.10966293f, 0.16045637f, 0.16144788f, 0.14906503f, 
    -0.44101846f, 0.28936997f, 0.36400190f, -0.24268870f, 0.10821077f, -0.05370150f, -0.11928440f, -0.08829671f, 
    0.15109974f, 0.02547449f, -0.10718519f, -0.07674555f, -0.73937100f, 0.01827167f, -0.02625581f, 0.18173410f, 
    -0.12240731f, 0.17035614f, -0.10821009f, 0.21956787f, 0.23904450f, 0.17296815f, -0.24234372f, -0.13128041f, 
    0.03211771f, 0.17322561f, -0.01899505f, -0.16931516f, 0.18876939f, 0.02143082f, -0.23576166f, -0.00122392f, 
    -0.08230018f, 0.00287924f, -0.02677480f, -0.04164852f, 0.23009647f, 0.12355246f, 0.13623692f, 0.27617434f, 
    0.36237958f, 0.09451873f, 0.08288944f, -0.03170082f, -0.03275915f, 0.11493859f, -0.85829914f, 0.31605726f, 
    -0.06621541f, -0.00118125f, 0.07851904f, 0.06599083f, 0.16638432f, 0.05224019f, -0.04714872f, 0.09238802f, 
    0.14422671f, -0.17308447f, 0.08427759f, -0.01322456f, 0.08029076f, 0.02692520f, -0.01884425f, -0.11993729f, 
    -0.05508752f, 0.30861169f, 0.36512002f, -0.07101037f, 0.06632490f, 0.12844932f, 0.07974749f, -0.11845339f, 
    0.15227200f, -0.06571096f, -0.03546710f, 0.52140224f, -0.23637821f, 0.33335859f, 0.06739493f, 0.12167129f, 
    0.02621737f, 0.16279471f, -0.07840434f, -0.18945307f, -0.17051652f, -0.24394487f, -0.04240610f, -0.29327527f, 
    0.00146190f, -0.07838967f, -0.10629516f, 0.16239734f, 0.16281332f, 0.10437507f, -0.09019381f, 0.11623544f, 
    0.07623537f, 0.02725849f, -0.07943314f, -0.05839072f, 0.25442871f, 0.12153696f, 0.24980180f, -0.08612055f, 
    -0.10020227f, 0.19093244f, 0.01187830f, 0.13309084f, -0.10385304f, -0.05894617f, 0.08299223f, 0.03655193f, 
    0.17333603f, 0.09394443f, 0.06879337f, -0.00462709f, 0.09460490f, 0.28512928f, -0.03893995f, -0.25794035f, 
    0.08568749f, -0.07174690f, -0.05709566f, -0.06498449f, 0.24081463f, -0.03879001f, -0.19577798f, 0.04443711f, 
    -0.07121760f, -0.45169675f, -0.00059735f, 0.08920901f, -0.30024463f, -0.02161630f, -0.03292312f, 0.01105708f, 
    -0.04478117f, 0.01892609f, 0.50302964f, 0.08664937f, 0.02877603f, -0.25027147f, -0.00505272f, -0.11524056f, 
    0.04222557f, 0.19327696f, 0.19784115f, 0.35635102f, -0.02537087f, 0.12217282f, 0.21260212f, 0.19893312f, 
    0.10103551f, 0.05567222f, 0.13212268f, 0.15191783f, 0.40659177f, -0.07573425f, -0.23779915f, 0.17654368f, 
    -0.13519266f, 0.13514425f, 0.05910451f, 0.13012625f, -0.35653660f, -0.21271718f, 0.00060606f, 0.24712391f, 
    -0.10964842f, -0.12497413f, -0.08976261f, 0.01724790f, -0.52915806f, -0.23924731f, 0.17578898f, 0.29507264f, 
    -0.20627569f, 0.00632838f, -0.26469764f, -0.20630006f, 0.06029743f, -0.15570962f, 0.27417052f, 0.52103603f, 
    0.13254046f, 0.21123151f, 0.16228256f, -0.00904771f, 0.05874141f, -0.39075956f, -0.06520438f, -0.34372070f, 
    -0.00771753f, -0.05964588f, -0.25606892f, -0.37578854f, 0.04137671f, -0.09788481f, 0.07065317f, -0.29253906f, 
    -0.67396635f, 0.17786676f, -0.14882644f, 0.13881767f, -0.13986520f, -0.06916624f, 0.00669314f, 0.04919055f, 
    -0.15177575f, 0.43070582f, 0.13541058f, 0.11872479f, 0.04979475f, -0.17788151f, 0.18531671f, -0.01937160f, 
    -0.07840898f, -0.17244989f, -0.49007729f, -0.06313404f, -0.08756572f, -0.09881784f, -0.11412544f, 0.23362851f, 
    -0.11982693f, -0.15299961f, 0.25546753f, 0.18132228f, 0.16225648f, -0.05908134f, 0.00198067f, -0.05174999f, 
    -0.04263259f, 0.17676716f, 0.04067273f, -0.02111895f, 0.00553616f, 0.46601027f, -0.19303681f, -0.20214051f, 
    -0.19999479f, -0.14877786f, 0.22898918f, 0.07479354f, -0.65086442f, -0.60685134f, 0.22601216f, 0.02205877f, 
    0.18814267f, -0.27047604f, 0.02335679f, 0.04666788f, 0.09643527f, -0.03894619f, 0.05509637f, 0.28828809f, 
    -0.03677886f, 0.12969334f, -0.03685890f, -0.04151323f, 0.04803160f, 0.21393634f, -0.25556940f, 0.17453776f, 
    -0.10796826f, -0.08239324f, -0.09193093f, -0.19261245f, -0.19365244f, -0.04796527f, 0.25763327f, -0.06303814f, 
    0.03569598f, -0.04893715f, -0.16497245f, 0.01302492f, -0.11219545f, -0.14461671f, 0.06442314f, 0.37543994f, 
    -0.11031616f, -0.31704378f, 0.19165277f, 0.28638583f, 0.11182889f, 0.06878469f, 0.17180370f, -0.10298479f, 
    0.09779488f, -0.45014510f, -0.00169489f, -0.00426819f, 0.00770278f, 0.01839470f, 0.00436014f, -0.01322447f, 
    0.11478258f, 0.08294779f, -0.58644092f, -0.61796170f, 0.37301725f, -0.21068768f, -0.13340242f, -0.15225737f, 
    0.02358692f, -0.03744249f, 0.10992325f, -0.27477059f, -0.41654289f, 0.41691577f, -0.12842454f, -0.13052684f, 
    -0.30153474f, 0.10892320f, -0.08004688f, 0.04024072f, 0.28271317f, -0.07065815f, -0.42933437f, 0.11802627f, 
    -0.06372511f, -0.07609063f, -0.05011452f, -0.03587777f, -0.16834179f, 0.16664533f, 0.33391875f, -0.22827807f, 
    -0.15335800f, 0.03199364f, 0.13109675f, 0.08473288f, 0.06458248f, 0.19003512f, 0.14214408f, -0.04653421f, 
    -0.22882691f, 0.17440867f, 0.04843888f, 0.34370255f, -0.10614670f, -0.00146003f, 0.03614797f, 0.73435807f, 
    -0.12007972f, -0.02429467f, 0.26639438f, 0.02177547f, -0.05856896f, 0.01134715f, 0.14862014f, -0.19734332f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.22855715f, -0.10382130f, 0.15149221f, 0.34408054f, 0.13807876f, 0.11580252f, -0.09330867f, 0.11700867f, 
    -0.14007033f, -0.09614079f, 0.01360330f, 0.27998838f, 0.57931125f, 0.03225081f, -0.03420097f, 0.41089869f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.29544958f, 0.19425744f, 0.09987314f, -0.49587709f, -0.80564678f, 0.18097329f, -0.39427617f, -0.41646481f, 
    0.28382212f, -0.34949797f, -0.03775554f, -0.38385883f, 0.41810578f, -0.20707670f, 0.31945273f, 0.01252655f, 
    0.33359656f, -0.09895070f, -0.12897538f, -0.23212007f, 0.50950104f, 0.21959841f, -0.60325128f, -0.42489058f, 
    -0.15332104f, -0.17877381f, -0.20316853f, -0.00573451f, 0.40492770f, 0.32511377f, -0.27718604f, 1.21631455f, 
    0.06509812f, 0.16787754f, 0.07817099f, 0.29291424f, 0.02027440f, -0.08691400f, -0.14204799f, 0.55637938f, 
    -0.30906519f, 0.66864312f, -0.06901137f, 0.32302758f, -0.27616635f, 0.13593706f, 0.38134164f, -0.30014852f, 
    -0.11536700f, 0.10528490f, -0.14936036f, 0.01240092f, 0.09283853f, -0.03116499f, 0.08025105f, -0.23671827f, 
    -0.19666864f, 0.05856897f, -0.05841903f, -0.14574292f, -0.06036401f, -0.11865575f, -0.04294895f, -0.02616685f, 
    -0.04511652f, -0.22833820f, 0.22561415f, -0.25044641f, 0.22976275f, -0.06954989f, 0.13196607f, 0.28229967f, 
    -0.53249466f, -0.24104415f, 0.67666346f, 0.56497514f, 0.18297081f, 0.43865150f, -0.44077167f, 0.11849135f, 
    0.36420852f, 0.11592527f, 0.37553799f, 0.38422665f, 0.57827079f, -0.33974338f, 0.97428942f, 0.37982503f, 
    0.25708568f, 0.39346987f, -0.22319584f, -0.21901873f, -0.03055288f, -0.32839471f, 0.47277406f, -0.13182865f, 
    0.12983969f, 0.13444485f, -0.39211535f, -1.02351630f, 0.19310097f, 0.17709328f, -0.47609061f, -0.44882551f, 
    0.20627937f, 0.36787689f, 0.07347643f, -0.58902854f, 0.51508880f, -0.49148530f, 0.37280729f, -0.33903006f, 
    0.18734680f, 0.00249585f, 0.21481080f, 0.50070649f, 0.15415579f, -0.22475168f, -0.15105776f, -0.08057571f, 
    0.11363244f, 0.51776397f, 0.37173402f, 0.09139778f, -0.09806863f, -0.46578032f, 0.60859287f, 0.08903272f, 
    0.14010644f, -0.14261957f, -0.14335310f, 0.86853689f, 0.83174115f, -0.52574593f, 0.58782262f, 0.62282246f, 
    0.51990885f, 0.00848270f, 0.09062832f, 0.15797330f, 0.14484517f, -0.04003995f, 0.01060749f, -0.33322951f, 
    0.02374446f, -0.11317252f, 0.57111263f, 0.49950066f, 0.53354913f, -0.22579786f, 0.56619692f, -0.16127446f, 
    0.00470689f, -0.41901198f, 0.18316576f, 0.34800589f, -0.39582413f, 0.01935447f, 0.28877291f, 0.15747607f, 
    0.34434962f, 0.10599329f, -0.45880404f, 0.19042754f, -0.01246240f, -0.08807333f, -0.52805942f, 0.29528841f, 
    -0.18876036f, -0.68641323f, 0.44546372f, 0.37644851f, 0.35106218f, 0.10803609f, 0.19630572f, 0.06609667f, 
    -0.00960054f, -0.05655075f, 0.17106484f, -0.53902191f, 0.75051188f, 0.08108842f, 0.09850761f, -0.11382325f, 
    -0.75834322f, -0.17056516f, 0.48198655f, 0.48374847f, 0.08616352f, 0.08632357f, -0.04971610f, 0.50327194f, 
    -0.47789809f, 0.09181496f, 0.03869858f, 0.72098392f, 0.08383733f, 0.24204360f, 0.88366175f, 0.04768404f, 
    0.05646791f, 0.46723592f, -0.25036716f, -1.03151107f, 0.04236048f, 0.51235682f, -0.03050749f, 0.05200537f, 
    -0.07349660f, -0.18593977f, 0.10216612f, -0.34992585f, 0.60490793f, 0.29603946f, 0.35879081f, -0.40780714f, 
    -0.34741420f, 0.23251170f, 0.51144814f, -0.82944775f, 0.35888714f, 0.09872672f, -0.13001972f, -0.48398381f, 
    0.43812793f, 0.20644981f, -0.29499337f, 0.30917826f, 0.06467208f, -0.25447813f, -0.21908185f, 0.27659968f, 
    -0.05868406f, -0.50580120f, 0.37095159f, 0.08457633f, 0.04136699f, -0.09841292f, 0.46360740f, 0.67068619f, 
    0.22430885f, -0.12224762f, -0.32658446f, -0.14687786f, 0.24123856f, 0.30932978f, 0.52868927f, -0.21392976f, 
    0.30872110f, -0.32753465f, -0.94322985f, -0.17317849f, 0.17569718f, 0.27759412f, 0.10273459f, 0.52702558f, 
    -0.00276031f, -0.00041612f, -0.44089654f, 0.65363955f, -0.16923216f, -0.17991382f, 0.31516841f, 0.28180534f, 
    0.05062770f, -0.48794502f, 0.72629535f, 0.26715416f, 0.40530133f, -0.04767368f, -0.03227213f, -0.21099846f, 
    -0.16956130f, 0.07441208f, -0.02564475f, 0.22343349f, -0.11800906f, 0.01667664f, -0.17585197f, -0.04478765f, 
    -0.09097101f, 0.00978675f, 0.01918259f, 0.12891759f, -0.20537615f, -0.19358371f, -0.24239531f, -0.26066941f, 
    -0.21413684f, 0.12222714f, 0.31501001f, -0.41057596f, 0.25652727f, 0.27340415f, 0.82121503f, 0.33863816f, 
    -0.04566220f, 0.26398438f, -0.72238028f, -0.07248431f, 0.13697208f, 0.42758712f, 0.12839597f, -0.46961775f, 
    -0.11676410f, 0.12165209f, 0.04149637f, -0.02906841f, 0.41407195f, -0.19940709f, 0.92962086f, 0.31551829f, 
    0.14638785f, 0.10695260f, 0.34076017f, -0.40015298f, -0.20276450f, 0.18289839f, 0.34041783f, -0.48333421f, 
    0.33251905f, 0.02521856f, 0.15127039f, -0.25188822f, -0.16711472f, -0.03448921f, -0.55269164f, -0.19772020f, 
    -0.22176783f, -0.80220485f, -0.57094157f, -0.15248288f, -0.22260854f, 0.11007334f, -0.37851161f, -0.40508905f, 
    -0.22567697f, -0.00454440f, 0.27724627f, 0.08284658f, 0.27048415f, 0.48601624f, 0.46835738f, -0.39914197f, 
    0.51173949f, 0.52870834f, 0.01548053f, -0.14115745f, -0.31046045f, 0.47359812f, -0.42778960f, -0.09020726f, 
    -0.23643532f, -0.02765235f, 0.15134940f, -0.43325302f, 0.27516860f, 0.31373200f, -0.56359178f, -0.34140664f, 
    0.02447098f, 0.15370856f, 0.51532733f, 0.47305596f, -0.09722187f, 0.08543488f, 0.08653112f, 0.39111000f, 
    -0.33929855f, 0.04470074f, -0.61804950f, 0.51424068f, -0.28215393f, 0.28987694f, -0.11488460f, -0.03270058f, 
    0.19233179f, -0.08849851f, 0.19809888f, 0.22588916f, 0.24338245f, 0.00040673f, -0.04573001f, -0.09212399f, 
    0.20827696f, 0.24489053f, -0.12678148f, 0.65217155f, 0.28493133f, -0.09480103f, -0.54182059f, 0.06411330f, 
    0.23892820f, 0.00830193f, 0.48762402f, 0.32448652f, -0.20467512f, -0.40969095f, 0.06745140f, 0.56354672f, 
    -0.24869251f, 0.18154940f, 0.14037547f, 0.71242940f, -0.32711747f, 0.06165426f, 0.14845854f, -0.08824632f, 
    0.80421698f, 0.13313130f, -0.22297238f, 0.03605641f, 0.11339432f, 0.42432979f, -0.61807799f, 0.02443430f, 
    -0.15833764f, 0.23777884f, -0.01026341f, -0.01225268f, 0.12682725f, -0.22406702f, 0.16245832f, 0.22818656f, 
    0.01566172f, -0.09536362f, -0.05091878f, -0.22880945f, -0.10209700f, -0.03082269f, -0.12789546f, -0.23888001f, 
    0.13056318f, -0.05419882f, -0.24548051f, 0.04106666f, 0.15808643f, -0.09152371f, -0.27291825f, 0.36607188f, 
    -0.18561770f, 0.35750797f, 0.04546967f, -0.63635188f, 0.57807213f, 0.29588106f, 0.27532297f, -0.64466971f, 
    -0.12260254f, 0.25716305f, 0.12947439f, -0.74979639f, -0.04230933f, -0.21056093f, 0.55383176f, 0.56521654f, 
    0.06231094f, 0.07464869f, 0.71632314f, -0.82350218f, 0.18124959f, 0.30979705f, 0.15577954f, -0.93907386f, 
    0.05513010f, 0.03461563f, 0.09568177f, -0.11934302f, -0.22028705f, 0.20655024f, 0.82487947f, -0.08437402f, 
    -0.29659316f, -0.29084828f, 0.36112821f, -0.00657668f, -0.38991544f, 0.12525475f, 0.04950258f, 0.63569653f, 
    0.14146994f, 0.24105103f, -0.23685050f, 0.12104704f, -0.19436382f, 0.08785806f, -0.52895379f, -0.20633994f, 
    0.68166029f, 0.03611983f, -0.64269233f, 0.31658885f, 0.40353602f, 0.18901148f, 0.25668925f, 0.39990205f, 
    -0.19217980f, 0.17935175f, -0.24818951f, -0.18018192f, 0.04120925f, -0.17618328f, -0.04415241f, -0.24657747f, 
    -0.11196595f, -0.23951969f, 0.01008931f, -0.18177554f, -0.22349817f, 0.11068428f, -0.10430476f, 0.14848182f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.09336241f, 0.82666677f, 0.18728560f, -0.13421601f, 0.42768335f, -0.21329936f, 0.15446222f, 0.00591617f, 
    0.04080882f, -0.43468949f, 0.44762760f, 0.36844119f, -0.01550836f, 0.21659277f, 0.15035376f, 0.09646061f, 
    0.38250449f, -0.06998090f, 0.32821262f, -0.42585891f, -0.42555901f, -0.03961508f, 0.14617686f, -0.01673138f, 
    0.14471497f, 0.02805204f, -0.14877498f, 0.59991902f, -0.17526294f, -0.15319143f, 0.56882107f, -0.12470841f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.23476081f, -0.65275365f, 0.18045585f, -0.07113901f, 0.12974723f, 0.20980604f, -0.36210480f, 0.00003471f, 
    -0.02515774f, -0.07549563f, -0.62691468f, 0.13003609f, 0.36004385f, 0.21053925f, -0.34888729f, -0.26809222f, 
    -0.03401629f, 0.08932410f, 0.24933779f, 0.47793218f, -0.07849130f, 0.05195663f, -0.14166878f, -0.33784464f, 
    -0.47096407f, -0.42481324f, -0.00867218f, -0.00408205f, 0.35947400f, 0.54655504f, -0.79772663f, -0.02635293f, 
    -0.31062248f, -0.01410109f, -0.05874270f, 0.11349685f, 0.20879245f, 0.07429410f, 0.11873448f, 0.39032501f, 
    0.22105747f, 0.16900264f, 0.07433018f, 0.28461322f, -0.79292262f, 0.07901800f, 0.07584857f, -0.77919805f, 
    0.25837171f, -0.12483486f, -0.24346618f, 0.06463950f, -0.20593852f, -0.21973561f, 0.32664129f, -0.55694121f, 
    0.33778512f, 0.07624767f, 0.08549711f, -0.06494217f, 0.42189467f, -0.03484762f, -0.14911267f, 0.05856225f, 
    0.23081471f, 0.25124460f, 0.00805145f, -0.04316049f, 0.18428402f, -0.50992143f, 0.40837678f, -0.41300130f, 
    -1.05460525f, 0.28693730f, 0.28011915f, 0.28103432f, -0.47547609f, 0.23247558f, -0.07046277f, -0.00891071f, 
    0.56366843f, -0.15772499f, -0.07160221f, -1.10177362f, 0.03894959f, -0.34417278f, 0.20625934f, 0.52353793f, 
    -0.09857517f, -0.56127584f, -0.05798132f, 0.41270021f, -0.28150040f, -0.14016895f, -0.08477993f, 0.08603984f, 
    0.53971529f, -0.36949107f, -0.05281274f, -0.02372800f, -0.15242423f, -0.03541383f, 0.00201916f, -0.39717126f, 
    -0.00738855f, -1.23672187f, -0.12808700f, -0.37497208f, 0.24030949f, 0.25394785f, -0.72840697f, -0.06622972f, 
    0.05724316f, 0.15705127f, 0.35121417f, 0.11727807f, -0.94185138f, 0.29974315f, -0.06759720f, 0.24839438f, 
    -0.72996300f, 0.35404614f, 0.12318776f, 0.17553511f, 0.43741697f, -0.19433190f, -0.05853533f, 0.10741137f, 
    -0.39601889f, 0.01402205f, 0.21312366f, 0.14597028f, -0.44875649f, 0.22426893f, 0.34044820f, 0.29876974f, 
    -0.05355787f, 0.03739780f, -0.88921994f, 0.07932154f, 0.24244595f, 0.10387423f, -0.38081241f, 0.12608287f, 
    -1.25128067f, 0.03151526f, 0.14266354f, -0.16339736f, -0.20646100f, 0.17887400f, 0.29206088f, 0.04207059f, 
    0.10595398f, -0.45573601f, 0.10308588f, 0.01431946f, -0.24557729f, -0.07262094f, -0.06840317f, -0.12422577f, 
    -0.24519692f, 0.17739029f, -0.22477089f, 0.03805309f, -0.00283250f, 0.36291188f, -0.10099097f, -0.12967233f, 
    0.52751219f, 0.05365293f, -0.02998034f, 0.17339684f, -0.14721176f, 0.07659473f, 0.10148135f, 0.28024942f, 
    0.12896135f, 0.03283836f, 0.11328353f, 0.02160309f, -0.09970674f, -0.21913776f, -0.35489753f, -0.69988203f, 
    -0.02332130f, -0.32414043f, -0.09870041f, 0.02938895f, 0.09374709f, 0.08464934f, -0.14678462f, 0.10368009f, 
    -0.10150372f, 0.44519097f, -0.24558876f, -0.11965805f, 0.30316043f, -0.75140166f, -0.86528295f, -0.83783937f, 
    -1.48070610f, -0.84105808f, 0.34270558f, 0.54075819f, -0.74481463f, -0.80557692f, 0.13599753f, 0.38515601f, 
    0.14860211f, -0.04924532f, -0.19482434f, -0.44922933f, -0.05854497f, -0.04377233f, 0.36595950f, 0.18085928f, 
    -0.03488216f, -0.20068151f, -0.13364512f, -0.56379604f, -0.65790355f, 0.32716021f, 0.26421174f, -0.06959840f, 
    -0.33585373f, -0.22408241f, -0.07900175f, -0.08755198f, -0.08246445f, 0.06162767f, -1.09158802f, -0.14291954f, 
    0.61939919f, -0.26753742f, -0.36792010f, -0.30793256f, 0.53238851f, -0.73795700f, -0.40684047f, 0.04390160f, 
    0.10373919f, 0.09312667f, 0.01738796f, -0.77360600f, 0.12808944f, 0.38032663f, 0.18981664f, 0.33500847f, 
    0.13979109f, 0.39448631f, -0.13943976f, -1.02882802f, -0.19657497f, -0.08626065f, 0.17082100f, -0.01314611f, 
    -0.47563189f, 0.05772399f, 0.52687079f, 0.10396186f, -0.03632804f, 0.08178710f, -0.87582338f, 0.07563395f, 
    0.66231340f, -0.19997928f, 0.44081059f, -0.48778275f, -0.45067635f, -0.87559861f, 0.33845353f, -0.17090230f, 
    0.41000527f, 0.11978857f, -0.26264837f, -0.44580796f, 0.27907723f, -0.49319664f, -0.53713590f, 0.25735739f, 
    0.31804577f, 0.09723146f, 0.14277984f, 0.59121174f, -0.30813849f, -0.27854910f, 0.05674241f, -0.12504734f, 
    0.03564455f, 0.46911797f, -0.30970660f, -0.01049834f, 0.03334891f, -0.32868001f, -0.23952934f, -0.32540196f, 
    -0.59918225f, -0.65611506f, -0.32627457f, 0.00320382f, 0.54945272f, 0.29752010f, -0.31166750f, 0.19072251f, 
    -0.91185486f, -0.01180434f, 0.22967741f, -0.92159331f, -1.06153214f, 0.20525922f, 0.14054619f, -0.51199651f, 
    -0.15415131f, 0.31674686f, 0.12239185f, 0.08761867f, -1.04897976f, -0.04147915f, 0.22278187f, -0.16597530f, 
    0.65857816f, -0.33806157f, 0.02851488f, 0.06610461f, -0.79798114f, 0.55621111f, 0.45742401f, 0.54806811f, 
    0.01609678f, -0.82791317f, 0.04628856f, -0.53276360f, -0.75571030f, -0.29885733f, 0.20511194f, 0.30491930f, 
    0.17604449f, 0.11187813f, 0.29793364f, -0.21215537f, -0.34201500f, -0.74270201f, -0.58491915f, -0.08930878f, 
    -0.08561695f, -0.66066676f, -0.07608871f, 0.15472136f, 0.02575161f, -0.57765174f, 0.34696278f, -0.02635527f, 
    0.51269197f, 0.19813104f, -0.67593497f, -0.03891153f, -0.48977128f, -0.15892625f, 0.03182291f, 0.17699386f, 
    -0.61904824f, 0.04557465f, 0.20758754f, -0.54548258f, 0.07462104f, -0.30981985f, 0.45977613f, 0.34241882f, 
    0.31968439f, -0.07149882f, -1.13464701f, -0.86091769f, -0.51964569f, -0.04394843f, -0.07779564f, 0.39036041f, 
    0.32476914f, 0.20550677f, 0.02922529f, -0.19739571f, -1.08828068f, 0.26957890f, 0.06899655f, 0.05255048f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.58475184f, -0.04592571f, 0.01770343f, 0.12992010f, -0.27855161f, -0.07515272f, -0.01071720f, -0.39895177f, 
    0.33122444f, 0.46890822f, 0.05138592f, -0.03196868f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
