#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.39572135f, 0.90407735f, -0.69134009f, -0.00035725f, -0.96930796f, 0.45370218f, -0.25175381f, -0.22277607f, 
    -0.32726440f, -0.49893898f, 0.33799332f, 0.05947393f, 0.25780892f, 0.25625786f, -0.09085626f, 0.04905754f, 
    -0.42753124f, 0.02881298f, -0.03764953f, -0.21536951f, 0.13849883f, -0.03927808f, -0.01505135f, -0.14726983f, 
    -0.08666273f, 0.06298253f, 0.16324185f, 1.06105053f, -0.02495071f, -0.84365910f, -0.65796733f, -0.52870542f, 
    0.70666546f, 0.07173309f, 0.19464514f, 0.39401242f, -0.05425947f, 0.19591713f, 0.07272124f, 0.11305566f, 
    0.17628293f, 0.02676552f, 0.11068275f, -0.22184725f, 0.05860418f, 0.16458942f, 0.31854057f, -0.04385671f, 
    -0.01504168f, -0.19192085f, -0.25489533f, -0.39234141f, -0.62497032f, -0.58576012f, -0.41970882f, 0.53008461f, 
    0.56518489f, -0.55339980f, -0.15515672f, 0.10146192f, -0.24317493f, 0.20299682f, -0.38139957f, 0.13561936f, 
    -0.40467399f, -0.01546203f, 0.05803047f, 0.37722412f, 0.09803526f, -0.07262922f, 0.29795602f, 0.13733587f, 
    -0.50073218f, 0.00995227f, 0.05534660f, -0.11851142f, -0.51833516f, 0.34760737f, 0.65209597f, 0.56360596f, 
    -0.54136437f, -0.49543643f, -0.64112169f, -0.56218702f, -0.31418240f, -0.23046255f, 0.14260493f, 0.27732670f, 
    0.39164564f, 0.16197841f, 0.13656214f, 0.22456330f, 0.50892520f, -0.08700437f, 0.35382253f, 0.16476281f, 
    0.00028024f, 0.21831669f, 0.17738484f, -0.18972610f, 0.94567323f, 0.95995677f, 0.53953338f, 0.04280573f, 
    -0.72372293f, -0.26632354f, -0.10126068f, -0.18736009f, -0.14081013f, 0.19174758f, 0.16844691f, -0.05249432f, 
    -0.02426220f, 0.46317592f, -0.03279917f, -0.38747779f, -0.06935988f, 0.18665263f, 0.20011498f, -0.46932834f, 
    -0.19610195f, -0.01788944f, -0.07883756f, 0.00796642f, 0.08701216f, 1.00923216f, 0.67163408f, 0.42929474f, 
    0.70853114f, 0.82636595f, -0.05810000f, 0.33528507f, 0.26719013f, -0.07332661f, -0.42243576f, -0.36903259f, 
    -0.03657937f, -0.06845749f, 0.45976126f, 0.49640900f, -0.13760494f, -0.12054779f, 0.01110842f, 0.33500159f, 
    0.32225880f, -0.34665772f, -0.05120539f, -0.22395149f, -0.20556772f, -0.19318154f, 0.28074044f, -1.28185225f, 
    0.15728085f, 0.67201388f, -0.40562159f, 0.37140647f, 0.61854059f, 0.65284735f, -0.41931164f, -0.27728626f, 
    0.15304637f, -0.21942076f, -0.17696275f, 0.30748674f, 0.14212663f, -0.09583269f, 0.00197350f, -0.40155473f, 
    -0.05518883f, -0.38507432f, 0.21232067f, 0.34987551f, -0.03755961f, 0.18225263f, -0.10127451f, 0.31276482f, 
    -0.52638185f, 0.78525680f, 0.83208913f, -0.05361979f, -0.26525107f, 0.30707404f, 0.36139071f, 0.60570484f, 
    -0.37830395f, 0.13336642f, -0.20886511f, 0.13236970f, -0.23774108f, -0.17312358f, -0.56725371f, -0.37153059f, 
    -0.25146931f, -0.29936361f, 0.02538057f, -0.16549183f, 0.19701248f, -0.28918689f, -0.16096051f, 0.13796940f, 
    -0.69719034f, -1.00345862f, -0.48129669f, 0.05024800f, -0.59849930f, 0.26033804f, 0.96400309f, 0.46063727f, 
    -0.07018797f, 0.42216092f, -0.33057976f, -0.26609874f, -0.05445522f, -0.05188838f, -0.30634522f, -0.19626883f, 
    0.09648006f, 0.07274656f, -0.42712852f, -0.06794010f, -0.17952646f, -0.07467365f, 0.30807838f, -0.05618623f, 
    0.10909031f, -0.17775223f, -0.41880682f, 0.57524687f, -0.37671638f, -0.86059797f, -0.01913132f, -0.36993021f, 
    -0.52977955f, -0.38707620f, -0.08422821f, 0.06129703f, 0.74259043f, -0.24902251f, -0.21302795f, 0.43633956f, 
    -0.28911629f, -0.30349919f, -0.33414015f, -0.14508346f, 0.03792372f, 0.07508338f, 0.30278355f, 0.18735830f, 
    0.17516692f, 0.31160992f, -0.83105820f, -0.48832342f, 0.32192358f, 0.92212284f, -0.58569819f, 0.00313265f, 
    0.25657499f, 0.35888481f, -0.26242802f, 0.09311951f, 0.16611145f, 0.35015482f, 0.14199579f, 0.13431260f, 
    0.04820625f, -0.37640202f, 0.13760754f, 0.24637334f, 0.14141506f, -0.21339853f, 0.22802800f, -0.25800684f, 
    0.15620759f, -0.23018315f, 0.08697818f, 0.29411834f, 0.54053450f, 0.50883150f, 0.62030107f, 0.50272560f, 
    -0.03030039f, -0.44268167f, 0.15236367f, -0.38820344f, 0.71532500f, 0.54796422f, -0.33507994f, -0.12188453f, 
    -0.18398200f, 0.09749461f, 0.14377442f, 0.02141009f, 0.00779196f, 0.00117423f, 0.10002010f, 0.65849453f, 
    0.14212430f, -0.19863734f, 0.17042178f, 0.47240788f, 0.90867060f, -0.14380920f, -0.67591661f, 1.33546925f, 
    0.37706125f, 0.50577825f, 0.15389635f, -0.55737305f, 0.66503829f, -0.06906386f, -0.31636870f, -0.24058208f, 
    -0.14934258f, 0.38628948f, -0.04365505f, 0.22946340f, -0.07793882f, 0.18865876f, 0.00408997f, 0.13334993f, 
    0.22785087f, 0.11416391f, 0.00605834f, -0.25467759f, 0.08472458f, 0.77031273f, 0.36606711f, 0.60931873f, 
    0.35879791f, -0.13028547f, 0.87815779f, 0.22576831f, -0.82612371f, -0.40908882f, -0.60105395f, 0.29024366f, 
    0.48520914f, -0.06828479f, -0.07577538f, -0.32173264f, 0.14135349f, -0.01122131f, -0.17025380f, -0.03012425f, 
    -0.15797375f, 0.26578131f, 0.05639476f, 0.22017249f, 0.06261542f, -0.09225310f, 0.32842615f, -0.54637587f, 
    -0.47659627f, -0.64835745f, -0.58679473f, -0.31640881f, 0.27786028f, 0.18230508f, -0.05696473f, 0.43520927f, 
    0.14744192f, -0.21306968f, 0.13363358f, -0.14119159f, 0.06433824f, -0.14226760f, -0.13290228f, 0.04716115f, 
    0.09310028f, 0.24850290f, -0.29303250f, -0.12961754f, -0.38920838f, -0.31648615f, -0.28204846f, 0.76123559f, 
    0.62777954f, 0.76141155f, 0.09684175f, 0.81804454f, -0.39578697f, -0.50685567f, -0.21442196f, 0.34993190f, 
    -0.17889223f, 0.25831127f, -0.03574773f, 0.23116356f, 0.27536237f, -0.16176799f, -0.11577694f, 0.31499389f, 
    -0.15012194f, 0.07593531f, -0.03440121f, 0.45383608f, 0.09704985f, 0.21570197f, 0.28708851f, -0.03180056f, 
    0.04496371f, 0.02258037f, -0.46134686f, 0.41784534f, 0.36630508f, 0.15800753f, -0.23164716f, 0.40443859f, 
    0.32443154f, -0.53694624f, -0.58733940f, 0.07587669f, 0.43872765f, -0.38041082f, -0.11300551f, 0.25800231f, 
    0.01040796f, -0.43509635f, 0.33501998f, 0.40456209f, -0.08435918f, 0.57956797f, 0.00264275f, 0.27040493f, 
    -0.25552136f, 0.80344599f, -0.11697172f, -0.29135674f, 1.12822354f, 0.67089444f, -0.45635176f, 0.42384943f, 
    -0.17233635f, -0.21509466f, 0.38780636f, 0.04251555f, 0.24005120f, 0.24996687f, 0.18374392f, 0.13019413f, 
    0.07046564f, 0.17599286f, 0.25594702f, 0.10007790f, 0.00370277f, -0.08122350f, 0.06283229f, -0.24183972f, 
    -0.07251209f, 0.01384507f, 0.75099295f, 0.36159402f, 0.24055448f, 0.49897245f, 0.70176488f, 0.60197210f, 
    -0.17723621f, 0.43683404f, 0.44481137f, 0.40402246f, -0.55620795f, -0.37610918f, -0.41236466f, -0.37290248f, 
    -0.01103867f, -0.31494075f, -0.08087370f, -0.24473703f, -0.38450748f, -0.34819221f, 0.32525405f, 0.07513099f, 
    0.27014855f, 0.33586252f, 0.32267237f, 0.45823109f, -0.16573137f, 0.55471629f, 0.29346165f, 0.41911370f, 
    -0.46426710f, -0.98693520f, -0.45314270f, 0.01831098f, 0.04011880f, 0.13594423f, 0.29420602f, -0.27563941f, 
    0.17658426f, -0.17065524f, 0.02301690f, 0.05651672f, 0.13938850f, -0.21471168f, -0.33960319f, -0.15947618f, 
    -0.27227381f, -0.13033356f, -0.15508495f, -0.03389733f, 0.97405148f, 0.76253480f, -0.58170390f, 0.10890884f, 
    0.95860147f, 0.23388669f, 0.40509152f, -0.10230542f, 0.38790244f, 0.22189935f, -0.13322432f, -0.01806865f, 
    -0.10760602f, -0.27113762f, -0.22430322f, -0.06173356f, -0.22110477f, -0.40463075f, -0.23651966f, -0.01066206f, 
    -0.22817443f, -0.06129041f, 0.00726446f, -0.00349033f, 0.07048337f, -0.62511486f, 0.31354982f, 0.67022640f, 
    0.72563374f, 0.05648057f, -0.34255505f, 0.20315951f, -0.57709366f, 0.00372824f, -0.34495902f, 0.37549928f, 
    -0.27480799f, 0.21089622f, -0.19446172f, -0.24936780f, -0.23379667f, 0.23096468f, 0.36554193f, -0.16949205f, 
    -0.36104724f, -0.26884288f, -0.45496935f, -0.29631865f, -0.30476820f, -0.12907355f, -1.22005403f, 1.01725733f, 
    -0.59652656f, -0.86112624f, 0.21717858f, -0.29902962f, 0.77700472f, 0.58707392f, 0.21146025f, 0.14572573f, 
    -0.23648390f, 0.17086628f, -0.18735258f, -0.16194612f, -0.03149706f, -0.05781877f, -0.01373135f, -0.08939539f, 
    -0.11753424f, -0.35288423f, 0.03656731f, 0.23547098f, 0.31651762f, 0.25868237f, 0.18264228f, 0.89054114f, 
    -0.49753314f, -0.95540655f, -0.90461701f, 0.43035182f, -0.02838505f, -0.73588079f, 0.21690753f, -0.00260408f, 
    0.12438806f, -0.67835593f, 0.02893320f, 0.04171626f, -0.10857738f, -0.23263623f, 0.17781001f, -0.12951219f, 
    -0.13601027f, -0.04994822f, -0.06357121f, -0.06736547f, 0.29743478f, 0.12421162f, 0.20899954f, -0.07590038f, 
    -0.27982041f, -0.54695195f, -0.67958301f, -0.71541172f, -0.54122633f, -0.80323857f, 0.33750796f, 0.65327781f, 
    -0.19749452f, -0.15663528f, -0.22764722f, -0.03871126f, -0.02385813f, 0.06903986f, 0.02493629f, -0.19856651f, 
    -0.06765463f, -0.22893153f, 0.02563915f, -0.19721051f, 0.06294033f, 0.19191758f, -0.20529664f, -0.38043952f, 
    0.06761625f, -0.11793564f, -0.72402453f, -0.15213209f, 0.05123009f, 0.06618214f, -0.08098578f, 0.83179998f, 
    0.70634604f, 0.58480799f, 0.49767888f, -0.54367858f, -0.07102472f, -0.79393137f, -0.03035004f, 0.26939929f, 
    -0.02183405f, -0.16145749f, -0.35269046f, 0.42018783f, 0.02964364f, -0.29185686f, -0.31745982f, -0.09551466f, 
    -0.30833751f, -0.40089184f, -0.36713633f, -0.58958441f, -0.74981529f, -0.76619476f, -0.31513748f, 0.28239506f, 
    -0.56373823f, 0.41001868f, 0.47613004f, -0.30981296f, -0.34584254f, -0.37212384f, 0.08885451f, 0.07750223f, 
    -0.59758419f, 0.01113542f, 0.24668574f, -0.03094410f, -0.10761272f, 0.14796020f, -0.00715169f, -0.05241985f, 
    0.34626973f, -0.12552196f, 0.18594427f, -1.39076114f, -0.04470549f, -0.63530648f, -0.01663227f, -0.56839305f, 
    0.34450984f, 0.80196565f, -0.92331874f, 0.46422181f, 0.19210859f, 0.04903641f, -0.26648784f, 0.12135162f, 
    0.26153308f, 0.30325508f, -0.17596908f, -0.02201645f, -0.21507145f, -0.14965841f, -0.29672578f, 0.04673554f, 
    0.09479690f, -0.01336159f, -0.13415727f, -0.05295581f, 0.81291944f, -0.06269768f, -0.20395789f, -0.41790318f, 
    -0.49936804f, -0.43816274f, -1.01086891f, -0.56866002f, -0.26982787f, -0.59271640f, -0.00247489f, 0.01412585f, 
    0.66104066f, 0.02626133f, -0.25218278f, 0.05788231f, -0.07367443f, 0.03298057f, 0.21102288f, 0.40135354f, 
    -0.05426558f, 0.23099448f, 0.33005446f, -0.13674602f, 0.06514324f, -0.56829339f, -0.66949821f, -0.81658006f, 
    -0.13371164f, 0.41890329f, -0.35114264f, 0.70303410f, 0.38396463f, -0.79768825f, 0.60827333f, -0.05105165f, 
    0.22511776f, 0.51920539f, -0.10569389f, 0.13421601f, 0.20099182f, 0.34846249f, 0.36595505f, 0.32325006f, 
    -0.42310998f, 0.08365127f, -0.13704339f, -0.21493755f, -0.09792722f, -0.21339373f, 0.57436675f, 0.91513455f, 
    0.32993758f, 0.26100296f, 0.57280874f, 0.28270859f, -0.52869284f, -0.06841798f, -0.20894186f, -0.33801943f, 
    -0.14775722f, -0.08551481f, -0.20032482f, 0.06019506f, -0.20334205f, 0.10136414f, 0.13187462f, 0.05601932f, 
    -0.21099845f, 0.39533088f, 0.05257118f, 0.55318326f, -0.04948808f, -0.01746699f, 0.39805669f, 1.04438949f, 
    0.65094173f, -0.43036893f, -0.70929283f, -0.81255704f, -0.17505454f, 0.57889920f, 0.60130030f, 0.29735422f, 
    0.60659438f, 0.28588757f, 0.17688258f, -0.03475754f, -0.13527158f, 0.30943826f, 0.21459354f, 0.29223058f, 
    -0.26662159f, -0.12440213f, 0.09084581f, 0.15740025f, -0.05307619f, 0.08545385f, -0.03475114f, -0.18195029f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06482990f, 0.26142481f, 0.03455580f, 0.07987332f, 0.37574676f, 0.14788122f, 0.16038276f, 0.13545714f, 
    0.15831232f, 0.28990266f, 0.42325011f, 0.14102325f, 0.36616290f, 0.19198814f, -0.01964349f, 0.11864872f, 
    0.16339023f, 0.14907010f, 0.27849853f, 0.30277073f, 0.08511574f, 0.01527205f, 0.30590811f, 0.28454447f, 
    0.25593090f, 0.12996942f, 0.22671892f, 0.15164545f, 0.14151512f, 0.21062198f, 0.06707289f, 0.19846322f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05133572f, 0.01538719f, 0.04176621f, 0.03196665f, -0.01664201f, -0.00439267f, 0.04151964f, -0.01764942f, 
    -0.04242505f, -0.04586790f, 0.00799148f, 0.03212278f, -0.02668355f, -0.00654170f, 0.00372250f, -0.03988867f, 
    -0.05421212f, -0.03658969f, -0.04174627f, 0.02845533f, 0.00416169f, 0.00876936f, -0.04691342f, -0.03925578f, 
    0.04040461f, -0.05437578f, -0.01187128f, 0.02929065f, 0.04455437f, -0.05045008f, -0.03824430f, -0.00958022f, 
    0.00674368f, -0.00516888f, -0.01221000f, 0.03816923f, -0.02253811f, 0.04005953f, -0.02220924f, -0.05140736f, 
    -0.02604816f, 0.00508732f, 0.00375119f, 0.02546003f, -0.02541834f, -0.03749598f, 0.02301765f, -0.05180295f, 
    -0.03110806f, -0.03101324f, -0.05010436f, -0.04882297f, 0.02782849f, 0.03426067f, -0.01676420f, -0.03028143f, 
    -0.03007047f, -0.02940539f, 0.00825187f, -0.00145961f, 0.00577295f, -0.03298168f, -0.02348061f, 0.04199812f, 
    -0.03306044f, 0.00817318f, -0.01462336f, 0.03844557f, -0.02498931f, 0.03001488f, 0.01528769f, -0.02139925f, 
    -0.04569667f, -0.00242148f, 0.02277478f, -0.01136252f, -0.00611278f, -0.03739862f, -0.03217385f, 0.01265471f, 
    -0.00456775f, -0.03832627f, 0.02698265f, -0.03936514f, -0.05487459f, -0.03957422f, -0.00923373f, 0.02049002f, 
    -0.03611553f, -0.01026103f, -0.01223863f, 0.01486955f, -0.04041773f, -0.04161716f, 0.05068016f, 0.02193514f, 
    -0.02989310f, -0.05013021f, 0.02986082f, 0.01574297f, -0.01368052f, -0.01562321f, 0.03190443f, -0.00076074f, 
    -0.04419657f, -0.01832161f, 0.02985352f, 0.00500650f, -0.04716172f, 0.02012052f, 0.02216578f, 0.03201429f, 
    -0.01501384f, 0.03236433f, -0.04640053f, 0.00691669f, -0.03561138f, 0.00416706f, -0.00213281f, -0.03481608f, 
    -0.04653728f, -0.04486678f, 0.03102779f, 0.01988650f, 0.02666734f, 0.03555135f, -0.03549532f, 0.00514443f, 
    0.02327699f, 0.00978344f, 0.01808011f, -0.03025563f, 0.04128300f, 0.01523175f, -0.03505877f, 0.02056159f, 
    -0.00731296f, 0.01873605f, -0.05635023f, -0.03034996f, -0.05008842f, -0.03961482f, 0.04236535f, 0.01121522f, 
    -0.00869814f, -0.01244551f, -0.05150896f, 0.04094971f, -0.04172107f, 0.00414626f, 0.00690126f, -0.05464834f, 
    -0.02007898f, -0.02021558f, 0.00015453f, 0.03297398f, -0.03686039f, 0.00856215f, -0.04336565f, 0.04375521f, 
    -0.01679667f, -0.04085392f, 0.04163191f, -0.00921485f, 0.00553636f, -0.03199799f, -0.03378414f, -0.03347811f, 
    -0.01548823f, -0.02663964f, 0.00855314f, 0.02875389f, -0.03386699f, -0.01964119f, -0.00260898f, -0.05262529f, 
    0.03649443f, 0.03116503f, -0.02049214f, -0.05598471f, 0.01524806f, -0.04859218f, 0.02417948f, 0.02895947f, 
    -0.03547475f, -0.00569051f, -0.02642901f, -0.02489605f, -0.05616820f, -0.05049848f, -0.05216040f, 0.02476843f, 
    -0.00237992f, 0.03461062f, -0.03410239f, -0.01606847f, -0.04711127f, -0.01774373f, -0.03507374f, 0.04138700f, 
    0.01959272f, -0.03723097f, -0.05338197f, 0.03190757f, 0.00098518f, -0.00031350f, -0.03769389f, -0.03590824f, 
    -0.01706431f, -0.01391527f, -0.02539315f, 0.03434636f, 0.01352468f, 0.03449399f, -0.05584466f, -0.05292355f, 
    -0.04409764f, 0.04782949f, -0.04762673f, -0.00309675f, -0.04831685f, 0.04152957f, 0.01978412f, -0.01134508f, 
    -0.00356419f, 0.02735064f, 0.02172002f, -0.00360134f, 0.02517927f, 0.02848807f, -0.02586147f, -0.02307450f, 
    -0.03909910f, 0.03839882f, -0.03853011f, -0.02577708f, -0.04242584f, -0.05622360f, -0.00637354f, 0.01175720f, 
    -0.05202423f, -0.05029676f, -0.02193595f, 0.00744106f, 0.04465420f, -0.00405995f, 0.04459639f, -0.01928237f, 
    -0.04635495f, -0.03009793f, 0.04497959f, -0.04341361f, 0.00470554f, 0.02539975f, -0.02929630f, 0.03763497f, 
    -0.03965558f, -0.03159025f, -0.03435280f, -0.01457859f, 0.01382654f, -0.01313070f, -0.03745725f, 0.03925731f, 
    -0.02788362f, 0.02317068f, 0.00949542f, -0.03484989f, -0.01442395f, -0.04149273f, 0.02950076f, -0.01944643f, 
    -0.02748433f, -0.02160931f, 0.04444866f, -0.02211267f, 0.01486561f, -0.03306717f, -0.03194971f, 0.03057146f, 
    -0.01681157f, -0.05429245f, 0.00397492f, -0.03900792f, 0.01351945f, 0.01006061f, 0.04372224f, -0.05000778f, 
    0.03969358f, 0.02039472f, 0.01327418f, -0.04852849f, -0.01789409f, -0.00842084f, -0.04830896f, -0.03436669f, 
    -0.01212907f, 0.01621709f, 0.00516027f, -0.00511772f, 0.04335924f, 0.02486107f, -0.02680840f, -0.00690991f, 
    0.02849150f, -0.04758171f, 0.01964086f, -0.03412136f, -0.01808271f, 0.01631540f, -0.03441311f, 0.03153179f, 
    -0.04254762f, -0.01283136f, -0.00034798f, 0.04447879f, 0.00707715f, 0.01274061f, 0.03567984f, 0.02030098f, 
    -0.01604121f, -0.04529873f, -0.03552454f, 0.02660672f, 0.03071824f, 0.01615701f, 0.04395599f, -0.00454596f, 
    0.04483621f, 0.01400622f, -0.03815037f, 0.00340104f, 0.02944073f, -0.03685229f, -0.03540388f, -0.04288016f, 
    0.03034711f, 0.01900147f, 0.03084106f, 0.03616617f, -0.00388954f, 0.02067742f, 0.03926358f, -0.02946766f, 
    0.02672538f, -0.02241714f, -0.01052769f, 0.01780025f, -0.01878852f, 0.01958799f, 0.01049578f, 0.03336236f, 
    -0.04719295f, -0.04907235f, -0.03045559f, -0.03682726f, -0.03127434f, -0.02465281f, 0.01314534f, -0.03109957f, 
    -0.00423924f, -0.01231954f, -0.04821317f, -0.00811121f, 0.00178269f, -0.03556832f, 0.03501457f, 0.01803965f, 
    0.02515868f, -0.00621601f, -0.03599937f, -0.03799576f, -0.01945100f, -0.02260019f, -0.01191763f, 0.03018735f, 
    0.00101466f, 0.01492947f, 0.00280847f, 0.01951832f, -0.01188165f, 0.02470444f, -0.00336900f, 0.00943837f, 
    -0.00959150f, -0.01976207f, 0.02338075f, -0.02655478f, 0.03565271f, -0.04074841f, -0.04264713f, -0.03454831f, 
    -0.02669425f, -0.03767233f, 0.03326833f, -0.03313260f, 0.03428874f, 0.01400826f, -0.00499356f, -0.00657676f, 
    -0.02007241f, -0.00788232f, -0.02854410f, -0.02405404f, 0.03114361f, 0.03427261f, -0.04200387f, -0.01501237f, 
    -0.00754523f, -0.05000237f, -0.04022514f, -0.02706435f, 0.00592932f, 0.02202597f, 0.03531936f, -0.02721138f, 
    -0.04166156f, 0.04473882f, 0.02306759f, 0.03516282f, 0.02785466f, -0.03787557f, 0.02701673f, 0.01385603f, 
    0.04604685f, -0.04140445f, -0.01719981f, -0.03279708f, -0.01196438f, 0.01129200f, -0.03798522f, -0.04884474f, 
    0.04348792f, -0.02938196f, -0.03376238f, -0.01476345f, -0.04101431f, -0.02232070f, 0.01817782f, -0.04841134f, 
    -0.00990926f, -0.00908712f, -0.01780454f, 0.00898276f, 0.04227996f, -0.03208347f, 0.03087178f, -0.02353508f, 
    -0.03032685f, -0.04632567f, 0.03043143f, -0.04761184f, -0.01662564f, -0.02827378f, 0.00619290f, 0.04018920f, 
    -0.02008988f, 0.01952657f, -0.03963665f, 0.04830280f, 0.03535724f, 0.00404678f, -0.01633554f, 0.02361918f, 
    0.00094360f, -0.02418944f, 0.03542094f, 0.03877203f, 0.02190956f, -0.03294980f, -0.02914128f, -0.03176687f, 
    0.00296822f, -0.01141075f, -0.01793084f, -0.00214628f, -0.00255867f, -0.04092717f, -0.02678202f, -0.05023219f, 
    -0.01444155f, -0.00414979f, 0.01454867f, -0.00465458f, 0.01352058f, 0.01450719f, 0.00668094f, -0.04887706f, 
    -0.00239527f, -0.03595572f, 0.04463673f, 0.01328914f, -0.02798101f, -0.03632993f, 0.04891216f, -0.01189846f, 
    -0.05079712f, -0.03170236f, -0.02451949f, 0.02565195f, -0.01836265f, -0.03788545f, -0.01470125f, 0.01777319f, 
    -0.00178133f, -0.01793810f, -0.03616358f, 0.01038535f, -0.03109413f, -0.04957859f, -0.00004032f, 0.01175704f, 
    -0.02812408f, 0.00634816f, -0.02149213f, 0.04907915f, -0.01053913f, 0.04535516f, -0.03283193f, -0.04203738f, 
    0.00101813f, 0.01424736f, 0.01364025f, 0.02857403f, -0.04449184f, 0.02611348f, 0.04170027f, -0.02919735f, 
    -0.04894469f, 0.01255766f, -0.01188370f, -0.02164893f, 0.01544440f, -0.00468289f, 0.02611382f, -0.00885620f, 
    -0.01444454f, 0.03003865f, -0.03141867f, 0.03281867f, -0.00853288f, -0.04270972f, -0.01560593f, 0.03289305f, 
    -0.02048379f, -0.00404529f, -0.02341261f, 0.01857746f, -0.02746582f, -0.03888616f, 0.02501163f, -0.02677535f, 
    0.03884901f, 0.00861923f, -0.04513591f, -0.00748723f, 0.04197443f, -0.01229923f, 0.01239640f, -0.01431645f, 
    -0.03386963f, -0.03187623f, -0.03461304f, 0.04828672f, 0.01191330f, 0.02618173f, -0.00003427f, 0.00194683f, 
    -0.02940862f, -0.02314023f, -0.02205051f, -0.00381868f, -0.02233682f, -0.00631879f, -0.04481221f, 0.02896337f, 
    -0.03163711f, 0.01346014f, -0.03900724f, 0.03434012f, -0.03275702f, 0.00750840f, 0.04657952f, -0.04634439f, 
    -0.01523591f, -0.01498874f, 0.02112066f, -0.01700406f, -0.02986587f, -0.01259991f, 0.03096706f, 0.00151464f, 
    -0.00671584f, -0.04133189f, -0.04663378f, 0.02767568f, 0.02357958f, -0.03450323f, -0.00033782f, -0.03302828f, 
    -0.04129354f, 0.02832205f, -0.02095538f, -0.01062590f, 0.00605178f, 0.04932137f, 0.02840770f, -0.04054758f, 
    0.04585968f, -0.03665805f, -0.00467954f, 0.00312631f, -0.03493982f, 0.01433782f, 0.02999108f, 0.01812425f, 
    0.03696476f, -0.01619353f, 0.01173936f, 0.03778910f, -0.02610574f, -0.02054427f, 0.03880674f, 0.05006851f, 
    0.03489236f, -0.02361866f, 0.04468607f, -0.01510089f, 0.00059759f, 0.04445099f, -0.00106812f, 0.04072306f, 
    -0.01273664f, -0.02933445f, -0.04131606f, -0.00810226f, 0.02409569f, -0.01807800f, -0.01896363f, 0.00593633f, 
    0.01412444f, 0.00684839f, -0.01637956f, 0.05008760f, 0.01290447f, -0.00234549f, 0.04273598f, -0.00201023f, 
    0.04906609f, 0.03088202f, -0.01736717f, 0.01037715f, 0.03849667f, 0.04471077f, -0.04133658f, -0.04285686f, 
    0.03735957f, -0.04996349f, -0.03889572f, 0.04714202f, -0.02011823f, -0.02889687f, -0.00512847f, -0.02061369f, 
    0.00706614f, 0.01415733f, -0.00278316f, 0.01615337f, -0.02743311f, -0.00089547f, 0.01473657f, 0.01525453f, 
    0.02053798f, -0.02685150f, 0.04369032f, 0.02881837f, 0.02911434f, 0.03606218f, -0.03146910f, 0.03033654f, 
    -0.01417749f, -0.00158805f, -0.04563556f, 0.00616221f, -0.00365203f, -0.00908458f, -0.04470971f, -0.01446848f, 
    0.04223340f, 0.01062509f, -0.01647811f, -0.03261478f, -0.02094924f, -0.02989252f, -0.04913500f, 0.04988594f, 
    -0.04973114f, 0.02919766f, 0.03121698f, -0.01772295f, -0.00972505f, 0.00389763f, -0.02493462f, -0.04720919f, 
    0.00881313f, -0.04673615f, -0.01829777f, -0.04082425f, 0.03623122f, 0.01721443f, 0.04509005f, 0.05083585f, 
    -0.05080850f, -0.02989467f, 0.01733732f, -0.02671846f, 0.04767314f, -0.02280095f, 0.04366976f, 0.00707502f, 
    -0.02210508f, -0.00226321f, -0.04291416f, -0.02236548f, 0.01812986f, 0.03543653f, -0.00245733f, 0.04802189f, 
    0.03267729f, -0.01143997f, -0.02834307f, 0.04310239f, -0.02349983f, -0.02940258f, -0.01837259f, -0.02080799f, 
    0.02704234f, 0.00745521f, 0.02277416f, -0.03004462f, -0.01448006f, -0.03334815f, 0.02938959f, -0.02648619f, 
    -0.04702978f, 0.00299913f, 0.00511472f, 0.02213077f, -0.04212101f, -0.00423496f, -0.00646795f, -0.02589991f, 
    -0.04104951f, 0.03753053f, 0.00780446f, -0.02185982f, -0.02532526f, -0.01558417f, -0.01788750f, 0.04266055f, 
    0.02645614f, 0.02851935f, -0.02528952f, 0.03340535f, 0.00404849f, -0.02615474f, -0.02628268f, 0.00602114f, 
    0.31871554f, 0.13572210f, -0.02470707f, 0.32858434f, -0.10286491f, 0.09160738f, -0.09755199f, 0.14450151f, 
    -0.02934085f, -0.02599438f, 0.00577500f, 0.08726490f, -0.01660165f, 0.05534380f, -0.05675676f, 0.10456405f, 
    0.08693445f, 0.02018308f, 0.01863223f, 0.07091955f, 0.03746964f, 0.05049142f, 0.04443320f, -0.04490630f, 
    0.32527965f, 0.01147246f, -0.17475724f, 0.01405713f, -0.08867571f, 0.25439349f, 0.24497369f, -0.03480935f, 
    0.12836683f, 0.04564164f, -0.00422797f, -0.04306572f, 0.16888140f, 0.03575851f, 0.07377009f, 0.22567289f, 
    0.12300821f, 0.09025694f, 0.13276501f, -0.02756440f, -0.02240719f, 0.12621529f, 0.08740886f, 0.10426471f, 
    0.22627153f, -0.02790043f, -0.09253490f, -0.01669101f, -0.02042185f, -0.09882694f, -0.04463491f, -0.05501185f, 
    0.05855200f, 0.01644082f, 0.14128974f, 0.08109662f, -0.00690804f, -0.12505776f, 0.19785732f, -0.21569903f, 
    -0.21969034f, 0.10707187f, -0.08359432f, -0.04599362f, 0.06639526f, 0.02812692f, 0.13769194f, 0.01509972f, 
    -0.35831305f, -0.04271849f, 0.07057221f, -0.00673096f, 0.00030529f, 0.09806253f, 0.01461017f, -0.01068754f, 
    -0.02859848f, 0.02495644f, 0.01139547f, -0.05779696f, 0.08486664f, -0.10798144f, 0.15308931f, -0.10998778f, 
    0.01399712f, 0.02255423f, -0.06576005f, -0.00612657f, 0.02290753f, 0.07503828f, 0.09343772f, 0.02123974f, 
    -0.15775211f, 0.25265589f, -0.13934989f, -0.14903761f, 0.11805131f, 0.15092506f, 0.03439838f, -0.01007518f, 
    -0.13351701f, 0.05452086f, 0.05228092f, -0.06196198f, 0.23164940f, 0.17071995f, 0.05018707f, 0.58775330f, 
    -0.01568662f, 0.05137933f, 0.00326632f, 0.05723629f, 0.08214863f, 0.15408640f, -0.04199253f, 0.01289156f, 
    -0.25298658f, 0.16224705f, 0.15696016f, -0.13549142f, 0.11715177f, -0.00762528f, 0.00852233f, 0.19075893f, 
    0.02059173f, 0.06110660f, 0.09581844f, -0.01336257f, 0.05033657f, -0.20437418f, -0.09607582f, -0.08605106f, 
    0.01342914f, 0.12577678f, -0.10868645f, -0.00364680f, -0.03758095f, 0.06706089f, 0.12488651f, 0.02961907f, 
    0.20240226f, 0.15371747f, 0.13839066f, 0.02896299f, -0.11958043f, 0.02338788f, 0.05310249f, -0.13223641f, 
    0.19439822f, -0.01375717f, 0.06358160f, 0.02772125f, 0.09699382f, -0.26853067f, -0.00523457f, 0.40971240f, 
    -0.00950434f, -0.02884338f, -0.00532420f, -0.03270991f, 0.03138502f, -0.01337341f, -0.03490263f, 0.01500638f, 
    0.00689327f, 0.02541631f, -0.11003376f, 0.05846681f, 0.04582153f, 0.09121091f, -0.12685797f, -0.01442886f, 
    0.08503649f, 0.10873422f, 0.06525415f, 0.07258373f, 0.19852971f, 0.00857760f, -0.04019438f, -0.03678288f, 
    -0.08516187f, -0.07729375f, 0.02234128f, -0.02260950f, 0.01125783f, 0.05793918f, 0.02236973f, 0.01846790f, 
    0.26169032f, 0.24043694f, 0.15936692f, -0.17773871f, -0.01703370f, 0.03291989f, 0.03304956f, 0.11240204f, 
    0.03349093f, 0.00892466f, 0.01297265f, 0.07021414f, -0.17373167f, -0.10429167f, 0.10025648f, 0.06055018f, 
    -0.08250196f, -0.02775452f, 0.06910373f, 0.04257737f, -0.00230416f, -0.04070577f, -0.00382917f, 0.06301831f, 
    -0.03143855f, -0.20815694f, -0.04556220f, -0.03804619f, -0.14415090f, 0.01393518f, -0.01184228f, 0.09901609f, 
    -0.07803956f, 0.01799691f, 0.06399944f, -0.03573514f, 0.27129427f, 0.15810522f, -0.06908370f, 0.31902820f, 
    0.08935151f, -0.06882091f, 0.12701285f, -0.03375458f, 0.01780428f, -0.00540370f, -0.02441251f, 0.15876475f, 
    -0.27095738f, -0.00133961f, 0.07133075f, 0.10000607f, -0.06576321f, -0.01339937f, -0.03401365f, 0.00258818f, 
    -0.02769576f, -0.11387125f, 0.00452948f, 0.03391226f, -0.04639170f, 0.04519574f, 0.22870053f, -0.01978033f, 
    0.02803226f, 0.03690756f, 0.12105343f, -0.00328900f, 0.13071817f, 0.11392520f, -0.06452341f, 0.13186052f, 
    -0.36274400f, 0.30911005f, 0.20335254f, -0.09050662f, 0.02066150f, -0.11516740f, 0.10753807f, -0.00066267f, 
    -0.00106037f, 0.02219442f, -0.14205994f, 0.10793420f, 0.45287186f, 0.03330287f, 0.21132961f, 0.06406925f, 
    0.12284136f, -0.06564420f, 0.06095269f, 0.10020202f, -0.03848580f, 0.05134854f, 0.02070593f, -0.11535091f, 
    -0.13667293f, 0.00528572f, -0.05472802f, -0.01109742f, 0.12152874f, 0.22976787f, 0.12437149f, -0.03663057f, 
    0.06551158f, 0.11273317f, 0.09470408f, 0.05801223f, -0.24087183f, 0.07078523f, -0.02850522f, -0.17164622f, 
    -0.04727192f, -0.05797448f, 0.01571972f, -0.10417206f, 0.02146930f, -0.01218103f, -0.09861495f, 0.02719139f, 
    0.48679078f, 0.10087739f, -0.16498695f, -0.07899280f, 0.05430963f, 0.10471337f, 0.22393434f, -0.13083495f, 
    -0.02320969f, 0.09425595f, -0.06306930f, -0.09071312f, 0.10334580f, 0.35730645f, 0.10437753f, 0.04868962f, 
    -0.08866044f, 0.15953699f, 0.06279397f, 0.14582434f, 0.00199392f, 0.10211655f, 0.13226861f, -0.02181123f, 
    0.51519763f, 0.10747754f, 0.01809315f, 0.54667437f, -0.04542522f, -0.14425455f, -0.08726031f, 0.07768762f, 
    0.00329946f, -0.17605980f, -0.04593610f, 0.17261147f, -0.54495746f, 0.29805815f, 0.05504550f, -0.17924796f, 
    0.25037083f, 0.02503831f, 0.09520242f, 0.08982001f, -0.02129591f, -0.00811296f, -0.00209253f, 0.06949215f, 
    0.22712736f, -0.03300123f, 0.04118760f, 0.20778324f, -0.17206542f, -0.16827635f, -0.03900333f, 0.00969491f, 
    -0.00355539f, -0.02387768f, -0.02814613f, 0.24811752f, -0.22979699f, -0.30796650f, -0.20342697f, -0.09904872f, 
    0.16190536f, 0.02822297f, -0.09665342f, -0.02048895f, 0.00358932f, 0.07800634f, -0.03587685f, 0.00984397f, 
    -0.02737170f, 0.22708395f, -0.08677905f, -0.33653197f, -0.07378486f, -0.06982771f, -0.02999174f, -0.08117546f, 
    0.01526923f, -0.03077761f, 0.04305924f, -0.07364184f, 0.59201550f, -0.11550001f, -0.13378821f, 0.00322727f, 
    -0.09320257f, 0.19022247f, -0.07265967f, -0.01960439f, -0.05454481f, 0.04471115f, -0.02869810f, 0.02250554f, 
    -0.14371592f, 0.14675905f, 0.31578314f, 0.03005407f, -0.10114340f, -0.10617311f, 0.16810526f, -0.00610028f, 
    -0.02678619f, -0.13822511f, -0.09773152f, 0.22041059f, 0.02858372f, -0.15130362f, 0.00254714f, 0.33944300f, 
    0.01824105f, -0.22722137f, -0.11237033f, -0.04926310f, 0.01415325f, -0.05281390f, -0.14923511f, -0.18171872f, 
    0.09042644f, -0.00883961f, -0.02667476f, -0.11514831f, 0.03993912f, 0.05493970f, 0.02664132f, -0.13221312f, 
    -0.04592223f, -0.06533488f, 0.06314580f, 0.08247396f, 0.17193058f, 0.00531120f, -0.20529382f, 0.13687807f, 
    0.02155789f, 0.13761474f, -0.02711987f, -0.00968949f, 0.11076110f, -0.23102628f, 0.04674927f, -0.10768004f, 
    -0.21817431f, 0.20357484f, -0.07733262f, -0.26953611f, -0.12847155f, 0.01082762f, 0.01338997f, -0.06691825f, 
    0.13385817f, -0.08254911f, 0.03793927f, 0.07918235f, 0.15814297f, -0.00381434f, -0.19407058f, 0.06789568f, 
    0.18802841f, -0.13530384f, 0.06391698f, -0.10899679f, 0.08779451f, 0.02183130f, -0.01532629f, 0.05674954f, 
    -0.06895801f, 0.21058325f, 0.39188278f, 0.06363212f, 0.09137627f, 0.10191587f, 0.00324793f, 0.28896967f, 
    -0.11118327f, 0.05620608f, 0.01439495f, 0.06384727f, 0.19843815f, -0.11912738f, 0.22219266f, -0.08767253f, 
    0.06204580f, -0.08323047f, -0.11723987f, -0.10832094f, 0.06643274f, 0.00198452f, 0.02960292f, 0.16889982f, 
    0.22845104f, -0.11535786f, 0.10140395f, -0.07741467f, 0.08287279f, 0.01508247f, 0.07422991f, -0.01079468f, 
    -0.06733087f, 0.02151570f, -0.19480132f, -0.03643629f, -0.00736646f, -0.15444030f, 0.01120318f, 0.03129277f, 
    0.05758295f, -0.20323482f, -0.13851783f, -0.36702001f, -0.04046132f, 0.00354026f, -0.02172025f, -0.11727539f, 
    0.04908353f, 0.22562899f, 0.13159722f, 0.38966036f, 0.06916322f, -0.11860350f, 0.11474831f, -0.18387653f, 
    -0.06449310f, -0.15065427f, -0.00002412f, -0.06812391f, 0.16255392f, 0.21644495f, -0.13928983f, -0.03458846f, 
    -0.02678972f, -0.02492208f, -0.08054154f, 0.05393755f, -0.10571375f, 0.08301583f, -0.02460351f, 0.11106982f, 
    -0.14101012f, 0.16232324f, 0.12463494f, -0.07042147f, 0.07943457f, 0.08943848f, -0.01438064f, 0.12885669f, 
    -0.01941722f, 0.07846247f, 0.07828862f, 0.06734467f, 0.10870720f, 0.02725110f, -0.09774914f, 0.07004083f, 
    0.10550655f, 0.17270686f, -0.24716757f, -0.24401198f, 0.01967887f, -0.16804847f, 0.01062601f, -0.11606304f, 
    0.07128785f, 0.02475762f, -0.05658950f, 0.21009059f, 0.13626075f, 0.06586648f, -0.21538906f, 0.08481398f, 
    0.09702890f, -0.00250467f, -0.02812157f, 0.03021159f, 0.07630797f, -0.03147547f, -0.00313671f, 0.24180308f, 
    0.19988392f, -0.15486364f, 0.23104334f, -0.12596568f, -0.08641461f, -0.05966869f, -0.04628369f, -0.04641042f, 
    0.12233065f, -0.18898866f, -0.10170121f, -0.16632520f, 0.19197096f, -0.11412255f, -0.13368481f, -0.22941612f, 
    -0.08999575f, 0.08457039f, 0.05069463f, 0.01001223f, -0.00840450f, -0.20023730f, -0.05629751f, 0.14924690f, 
    0.04195344f, 0.06145882f, 0.08393908f, 0.03846708f, 0.05938162f, 0.11865553f, 0.03311259f, -0.00616527f, 
    0.25564837f, -0.05261360f, 0.06635495f, -0.07715728f, 0.03117430f, 0.02303601f, -0.03544626f, 0.14113346f, 
    -0.06873938f, 0.20238742f, 0.14508049f, -0.08440109f, -0.14067714f, -0.10510661f, -0.03506527f, 0.17849088f, 
    0.04488634f, 0.04699118f, 0.08183379f, -0.05179802f, -0.02932555f, 0.26026338f, -0.03898268f, 0.08068192f, 
    0.37942165f, 0.07433299f, 0.06868482f, 0.02694855f, 0.06274117f, -0.12328390f, -0.10285897f, 0.00329075f, 
    -0.10614341f, 0.02183225f, 0.03319611f, 0.03326737f, 0.12179507f, 0.16651368f, -0.22702233f, 0.29858083f, 
    0.01812709f, -0.04153816f, 0.05566948f, -0.03907960f, -0.09006304f, 0.09226096f, -0.01530352f, -0.08127290f, 
    -0.03667090f, 0.22384566f, 0.05294947f, 0.06573380f, -0.06140952f, 0.00323953f, 0.12457255f, 0.05294135f, 
    -0.09343819f, 0.07037769f, 0.03732074f, 0.19279867f, -0.12512557f, 0.15734024f, -0.02120723f, 0.01855030f, 
    -0.10967025f, 0.13775563f, 0.16294165f, 0.17845802f, -0.00811133f, -0.17652892f, 0.27177438f, 0.14503878f, 
    0.18252401f, 0.25294247f, -0.11331104f, 0.23883091f, 0.12467262f, -0.01152036f, 0.09717053f, 0.03431132f, 
    -0.09163059f, -0.02092179f, 0.07373890f, -0.04589182f, 0.77904069f, 0.00146708f, 0.16039260f, -0.12111136f, 
    0.10790771f, 0.16532092f, -0.10932428f, 0.01394896f, 0.09601551f, -0.04116846f, 0.04096065f, 0.25256479f, 
    -0.08879124f, 0.14055324f, 0.03837468f, 0.04414008f, -0.07371512f, 0.00749117f, -0.14531665f, -0.03806297f, 
    0.00529889f, -0.15777995f, -0.08397679f, -0.08403700f, -0.20083995f, 0.07571341f, 0.25179261f, 0.15592757f, 
    0.02352533f, -0.15378927f, 0.06115007f, -0.19565231f, -0.07816341f, 0.04471388f, -0.20196681f, -0.08243948f, 
    0.23064779f, 0.20736310f, -0.01131139f, -0.02948068f, 0.02605597f, -0.02896590f, -0.32579955f, -0.09503479f, 
    0.08000524f, -0.17010491f, -0.10937333f, 0.20491379f, -0.31260145f, -0.02136027f, -0.11879890f, -0.11123955f, 
    0.05089455f, 0.03041692f, 0.13493109f, 0.01681334f, 0.03190014f, 0.05584101f, -0.09921882f, 0.07020972f, 
    0.03597255f, 0.03130418f, -0.05018577f, -0.02939539f, 0.03637252f, -0.02580130f, 0.00965823f, 0.02355087f, 
    0.04184417f, -0.00148468f, 0.01544165f, -0.05783899f, 0.00978224f, 0.02362476f, -0.02857546f, 0.03384647f, 
    -0.00158129f, 0.02447111f, -0.02299885f, 0.00025615f, -0.04854989f, 0.02016679f, 0.02686490f, -0.03284445f, 
    0.02508148f, 0.02322941f, 0.00118900f, 0.02511561f, 0.03161241f, 0.03641224f, -0.05097657f, -0.04741419f, 
    0.01410419f, 0.01581186f, 0.03019119f, -0.05565747f, -0.03227113f, -0.00418248f, -0.04049681f, -0.05242051f, 
    -0.04706665f, 0.01875166f, 0.00329334f, 0.01344005f, 0.03730588f, -0.02767964f, -0.00271668f, -0.05569894f, 
    -0.02221324f, -0.03946364f, -0.02753019f, -0.03196663f, 0.03559900f, 0.02883789f, 0.02887493f, -0.02143731f, 
    -0.00716554f, 0.02663959f, -0.00675023f, -0.03123522f, 0.04157849f, -0.05784219f, -0.03073156f, 0.04217299f, 
    0.00862344f, -0.02295583f, -0.02964627f, -0.04217562f, -0.03063825f, -0.05250061f, 0.04264461f, -0.03440099f, 
    -0.04532550f, 0.03775544f, -0.04196771f, 0.03256367f, -0.05495439f, -0.02581582f, -0.01702266f, 0.04008124f, 
    -0.02711607f, -0.01397441f, -0.02706120f, 0.04045309f, -0.00784026f, 0.01430818f, -0.03051117f, -0.01692078f, 
    -0.03309410f, -0.03585333f, 0.00638671f, -0.04465200f, 0.03113665f, -0.05541015f, 0.02904001f, 0.00422770f, 
    0.03496191f, -0.01574546f, -0.01352614f, -0.00716889f, -0.00835828f, -0.03915905f, -0.00231547f, -0.04181511f, 
    -0.04739071f, -0.00797803f, 0.04232576f, -0.00570988f, 0.02091159f, 0.01394284f, -0.04496771f, 0.00345236f, 
    -0.02435217f, 0.03069831f, 0.03335635f, -0.04729575f, 0.03026999f, 0.00402841f, -0.01627590f, 0.02891900f, 
    0.03566699f, -0.00745932f, -0.01225692f, 0.03479947f, -0.03503428f, -0.00088125f, -0.04211064f, 0.00704175f, 
    0.02661035f, 0.00455872f, 0.01259267f, -0.02787264f, -0.00832314f, -0.00028564f, -0.03731772f, -0.00868348f, 
    -0.00985390f, 0.00944335f, 0.01905474f, 0.02924167f, 0.00377125f, -0.03106249f, 0.01216684f, 0.02647647f, 
    0.02822932f, -0.01097291f, -0.01678295f, 0.00889506f, -0.01961271f, 0.02379634f, 0.00559557f, 0.01119239f, 
    -0.04222474f, -0.01773851f, -0.02937232f, -0.01040311f, 0.00894620f, 0.00601357f, 0.00884326f, 0.03577558f, 
    -0.02753057f, 0.01154940f, -0.02515712f, -0.00098106f, -0.03619178f, -0.02836128f, -0.01085991f, -0.02764695f, 
    0.02604691f, 0.01496475f, 0.04769519f, -0.00567165f, -0.04406089f, -0.04918579f, 0.03451711f, -0.04524114f, 
    -0.02846172f, 0.02819604f, 0.03693549f, -0.00398416f, -0.01318033f, 0.03908450f, 0.04424434f, -0.01999481f, 
    -0.02201393f, -0.00940750f, -0.04200469f, -0.00907631f, -0.00075044f, 0.01561386f, -0.03272741f, 0.02397509f, 
    0.02428484f, -0.00764328f, 0.03818783f, -0.03030968f, 0.04344016f, -0.01397445f, 0.00528600f, -0.04233507f, 
    -0.01629761f, 0.01084074f, 0.02792127f, 0.00449913f, -0.03541730f, 0.02059098f, -0.05092279f, 0.00219133f, 
    -0.04456776f, -0.02102710f, -0.01363918f, -0.03035451f, -0.05611438f, 0.03596127f, 0.01323163f, -0.02569990f, 
    0.02399305f, -0.00017512f, -0.05436695f, -0.00495985f, -0.01546794f, -0.00096763f, -0.00664307f, 0.00530854f, 
    0.02545412f, -0.02556680f, -0.02647638f, -0.05263189f, 0.00924787f, -0.05134023f, 0.01677522f, 0.00169488f, 
    -0.05738146f, -0.04843196f, -0.00226026f, -0.00185444f, -0.05167119f, -0.00034213f, 0.02686053f, -0.05530776f, 
    0.01968905f, -0.01547837f, 0.02980737f, -0.03434346f, -0.01032254f, -0.02264662f, -0.04272384f, 0.03421412f, 
    -0.03317030f, -0.04091273f, -0.02598603f, -0.05477400f, 0.03610254f, -0.05378906f, -0.04945430f, -0.04082535f, 
    0.02634251f, 0.03684368f, -0.03069491f, 0.02121637f, 0.03283979f, -0.04839078f, -0.01597343f, 0.01046533f, 
    -0.05421608f, 0.01018869f, 0.01064127f, -0.03163941f, -0.00033914f, 0.00243809f, -0.04347041f, 0.00641810f, 
    0.02118077f, -0.00871964f, -0.02931091f, 0.00457394f, -0.04971005f, 0.02617729f, 0.01076198f, -0.03794165f, 
    -0.04920450f, 0.02053621f, 0.01858332f, 0.03794287f, 0.02267436f, 0.02307692f, -0.05744119f, 0.01068052f, 
    -0.01770872f, -0.05006035f, 0.00517905f, 0.00276725f, -0.04310607f, -0.02894559f, -0.02690427f, 0.01760471f, 
    0.01915437f, -0.03428544f, 0.02229716f, 0.01322313f, -0.03712075f, 0.01259062f, 0.04301981f, -0.03064551f, 
    0.01017651f, -0.00705525f, -0.01300559f, -0.03489422f, -0.05159241f, -0.00605834f, -0.02938037f, -0.00359247f, 
    -0.03453800f, 0.03433874f, 0.00084938f, -0.01582117f, -0.01087874f, 0.00037985f, 0.02745244f, 0.01384843f, 
    0.03139642f, -0.01381942f, -0.00314007f, -0.03124637f, -0.05699085f, -0.05555833f, -0.02185394f, 0.00190079f, 
    -0.04040773f, -0.03593826f, -0.02823697f, -0.03913532f, 0.02447955f, 0.00647750f, -0.04110399f, 0.01334665f, 
    -0.05649726f, -0.00458891f, -0.01094834f, -0.00003699f, 0.02391478f, -0.00085190f, -0.02979345f, 0.02123861f, 
    0.03647683f, 0.01965919f, 0.00730400f, -0.00629923f, -0.03066081f, -0.02887712f, 0.04310079f, -0.00083200f, 
    -0.00566898f, -0.01122734f, -0.01981667f, -0.03743803f, -0.02962957f, -0.03699462f, 0.03399963f, -0.03521036f, 
    0.02173869f, 0.03174180f, 0.01937140f, 0.01011230f, 0.02777010f, 0.02211491f, 0.02585868f, -0.04791329f, 
    0.02785924f, -0.02849323f, -0.03234188f, -0.02190985f, -0.00967528f, -0.05720904f, 0.02008599f, -0.00656872f, 
    -0.00828697f, 0.01407069f, -0.05706009f, -0.02139250f, 0.00077557f, 0.03177685f, 0.04026337f, 0.01184615f, 
    0.01410156f, 0.04041826f, -0.02249729f, 0.02510525f, 0.00824452f, -0.02054382f, -0.03309754f, 0.00163116f, 
    -0.01064917f, -0.04823580f, 0.01195604f, -0.00769391f, 0.02853743f, -0.00376207f, 0.01677417f, -0.03759269f, 
    0.03763181f, 0.00346716f, 0.00450950f, 0.02762883f, 0.00553138f, 0.00154453f, -0.05536673f, 0.01480404f, 
    -0.01791806f, -0.03997898f, -0.02969221f, 0.03843986f, -0.04932538f, -0.02248996f, 0.03188747f, 0.04011738f, 
    0.02836607f, 0.03673767f, -0.03182365f, 0.01494823f, 0.01810903f, -0.03190805f, -0.02712573f, 0.04277287f, 
    -0.01723779f, -0.04599624f, 0.03073852f, -0.01292644f, -0.01032837f, 0.02146052f, 0.02681524f, 0.01050986f, 
    0.03319381f, -0.01388940f, -0.00189888f, -0.00049437f, 0.01548846f, -0.01492107f, -0.04698312f, -0.00957286f, 
    0.03597401f, 0.02967253f, -0.01421961f, 0.03045567f, -0.01182531f, 0.01986760f, 0.00421743f, 0.01943900f, 
    -0.02854084f, 0.02684675f, 0.02369113f, 0.01832788f, -0.01900502f, -0.04463462f, 0.02090870f, -0.03754473f, 
    -0.00685432f, 0.00026532f, 0.00127845f, -0.00014455f, 0.01790097f, -0.01679785f, -0.05093057f, -0.00189724f, 
    0.02876249f, -0.05585537f, -0.02910861f, -0.02507808f, 0.04060245f, 0.00230769f, -0.03229083f, 0.00181530f, 
    -0.04502863f, -0.01048338f, -0.00728555f, 0.02310654f, 0.03609772f, 0.01390850f, 0.03682420f, 0.00720322f, 
    -0.00903019f, 0.01123034f, 0.00792957f, 0.01736020f, 0.00041154f, 0.02593792f, -0.01792323f, -0.02292324f, 
    0.01661200f, -0.01853352f, -0.02327294f, -0.05576598f, 0.00818382f, 0.01309237f, 0.02355278f, -0.04335900f, 
    -0.02660442f, -0.04323911f, -0.06035027f, -0.02538086f, 0.03665515f, -0.03565027f, -0.02586225f, 0.02695095f, 
    0.01769365f, 0.02636146f, -0.05535058f, 0.00555559f, -0.01063831f, 0.01734581f, 0.00215539f, 0.01809248f, 
    0.00089655f, 0.02103999f, 0.01765197f, -0.02624198f, 0.03151679f, 0.02241632f, -0.04075909f, -0.02954613f, 
    -0.00640461f, -0.02498297f, 0.03461373f, 0.02371886f, 0.02989421f, 0.02095530f, -0.03568170f, 0.01351810f, 
    -0.03395751f, -0.02181994f, 0.00302232f, 0.03896944f, 0.00940798f, 0.03341708f, -0.05266313f, 0.02860752f, 
    0.01777667f, 0.02079155f, -0.00876270f, -0.01477174f, -0.01188915f, 0.00443355f, -0.04451480f, 0.04107500f, 
    -0.03618041f, 0.02427465f, 0.00127351f, 0.02298326f, 0.01711177f, 0.03586421f, -0.03876446f, -0.01461514f, 
    -0.02479069f, -0.00078378f, 0.01672576f, -0.05728875f, 0.00417836f, -0.00333325f, -0.05632030f, -0.01558055f, 
    -0.00142996f, -0.04160636f, 0.02175970f, -0.03287678f, 0.04637848f, 0.03813156f, -0.01049074f, -0.05465928f, 
    -0.00895757f, -0.04800621f, 0.01807697f, -0.01263951f, -0.04423073f, 0.00825054f, -0.03998063f, -0.00867641f, 
    0.00785939f, -0.03257344f, -0.05460601f, -0.00769054f, -0.04783093f, -0.03906228f, 0.04053000f, -0.06079713f, 
    -0.06141184f, -0.05470102f, 0.02173063f, 0.03874986f, 0.01956976f, 0.00061005f, 0.03213688f, -0.02927043f, 
    0.02226718f, -0.05193920f, -0.03885825f, 0.00774618f, -0.03228757f, -0.02631476f, -0.04809396f, -0.05880974f, 
    -0.04906229f, -0.04117122f, -0.01091109f, 0.02399593f, 0.03020321f, -0.04505049f, -0.00798969f, -0.06055833f, 
    -0.03056666f, -0.06187660f, -0.02720744f, -0.05118952f, 0.02987369f, 0.01187108f, -0.05327023f, -0.04119314f, 
    -0.05430136f, 0.03998460f, -0.05916046f, 0.00367075f, 0.02516315f, -0.01013647f, 0.01590905f, -0.05148103f, 
    -0.03475977f, -0.03562186f, -0.03733697f, 0.03810453f, -0.02155443f, -0.03494086f, -0.00872731f, 0.02870104f, 
    0.02157640f, 0.00320907f, -0.02134490f, -0.02615932f, -0.00321118f, -0.02444040f, 0.03168337f, -0.03178714f, 
    -0.04996427f, 0.02273655f, 0.02725834f, 0.01185718f, -0.01906906f, -0.04987171f, -0.01622164f, 0.02996993f, 
    -0.05436972f, 0.00856631f, 0.01727114f, 0.00640211f, -0.02523880f, -0.03480498f, -0.03770189f, 0.03116837f, 
    -0.03645280f, 0.01242660f, -0.04216906f, -0.02741789f, -0.00890479f, 0.00159082f, -0.01357544f, -0.02466292f, 
    -0.02168007f, 0.01815258f, 0.00950582f, 0.03126419f, 0.01257222f, -0.03453063f, -0.05695245f, 0.01633950f, 
    -0.03652661f, -0.02070618f, -0.01573771f, 0.01648545f, -0.00851158f, -0.01968943f, 0.03823495f, 0.02252413f, 
    -0.04845631f, -0.05938132f, -0.04529540f, -0.00999496f, -0.04905444f, -0.05807478f, -0.00438445f, -0.05742375f, 
    -0.03515273f, -0.03919101f, -0.00339495f, 0.00292018f, -0.01848809f, 0.03463800f, -0.01029176f, 0.00324624f, 
    0.02004018f, -0.04762521f, 0.00318453f, 0.02972582f, 0.00663169f, -0.05062121f, -0.04401668f, -0.03716425f, 
    -0.04125672f, -0.03401162f, -0.00839007f, -0.04864147f, -0.04294324f, 0.02143308f, -0.05007306f, -0.03936799f, 
    0.01974982f, -0.05447735f, -0.00733152f, -0.00785034f, 0.01122478f, -0.04853574f, 0.03600862f, 0.03598399f, 
    0.02583504f, -0.00462375f, 0.01438975f, -0.04847307f, -0.00462555f, -0.01450452f, -0.03987154f, -0.00920958f, 
    -0.04768068f, 0.00831403f, 0.00471697f, 0.00410976f, 0.04006585f, -0.03673037f, 0.00910498f, 0.00060627f, 
    -0.04190546f, -0.05670032f, -0.03289565f, 0.01688020f, 0.04016397f, 0.00516931f, -0.04173573f, -0.00425963f, 
    -0.01607717f, -0.04427101f, -0.05646602f, -0.00244305f, 0.02506425f, 0.03078983f, -0.02646179f, -0.02269822f, 
    0.00798816f, -0.01055843f, -0.05203150f, -0.01192268f, 0.01373109f, -0.02160850f, -0.05507632f, -0.02335125f, 
    0.02903326f, 0.02903061f, -0.00246577f, -0.00211776f, -0.05247980f, -0.00208138f, -0.00917206f, 0.00655253f, 
    0.08940169f, -0.25594902f, -0.43067655f, -0.19463618f, 0.10919041f, 0.00846276f, -0.06501723f, -0.00006554f, 
    0.09548028f, 0.01665805f, 0.10393054f, 0.02664059f, -0.17367676f, -0.18960242f, -0.08663862f, -0.30880994f, 
    0.09858261f, -0.00594300f, -0.04637284f, 0.00682032f, -0.01625576f, -0.00511421f, -0.05209678f, 0.00708821f, 
    0.10729721f, -0.04955126f, 0.01321740f, 0.06085576f, -0.11181640f, -0.17523813f, 0.02102033f, 0.10985648f, 
    -0.06884325f, -0.09655056f, 0.08214003f, -0.15628047f, -0.25851849f, -0.24810229f, 0.06267826f, 0.21947147f, 
    -0.11934340f, -0.00253190f, -0.01868701f, -0.07482832f, 0.06111323f, -0.00825837f, 0.11305781f, 0.04020958f, 
    0.03312713f, -0.08958258f, -0.07701203f, 0.05525213f, 0.01959504f, 0.00837328f, -0.05783506f, -0.02173299f, 
    0.24170709f, -0.09164028f, 0.05587307f, 0.10176941f, 0.02452389f, -0.17142391f, 0.08484934f, 0.36061898f, 
    0.20292632f, -0.13177256f, -0.11755461f, 0.00489546f, 0.13679381f, 0.08702669f, 0.04326762f, 0.14055488f, 
    -0.34452796f, -0.22172362f, 0.06828219f, -0.04039694f, -0.03674036f, -0.02047841f, 0.04642650f, 0.11000736f, 
    0.10639502f, 0.06402881f, -0.09444616f, 0.17409436f, -0.19739823f, -0.14662607f, 0.02986681f, -0.00604711f, 
    0.13196689f, -0.02691547f, -0.11949478f, -0.00650828f, -0.03728475f, 0.09528496f, 0.05384175f, -0.22088818f, 
    -0.13305570f, -0.21659231f, 0.05147398f, 0.19185273f, -0.16272101f, -0.09832924f, 0.03318113f, 0.04694778f, 
    0.10903983f, -0.07619911f, -0.04768134f, -0.03765963f, 0.11696659f, -0.12958792f, -0.20446567f, -0.30599537f, 
    0.08758938f, 0.15653545f, 0.02621156f, 0.07741309f, 0.09411763f, -0.05626054f, -0.09605368f, 0.03796765f, 
    -0.08837628f, 0.04709215f, 0.06238921f, -0.03332820f, -0.19970733f, 0.09645494f, -0.08051963f, 0.05388115f, 
    -0.07779628f, -0.02234641f, 0.07288157f, 0.01658488f, 0.22351044f, -0.05099071f, 0.06031050f, 0.34732801f, 
    0.00508561f, -0.14927356f, -0.00934610f, 0.03193222f, 0.02646601f, 0.12631680f, 0.00287615f, -0.00076259f, 
    0.37997726f, -0.38614228f, 0.15933225f, 0.05140939f, -0.15135801f, -0.01413901f, -0.00582104f, 0.08329032f, 
    -0.01370106f, 0.07099964f, 0.05574414f, -0.10018452f, 0.19998111f, -0.12826222f, 0.05422489f, -0.02583931f, 
    -0.00705757f, -0.08656923f, -0.02682228f, -0.02060478f, 0.12996088f, -0.02598060f, -0.11662091f, 0.03573223f, 
    0.29791260f, 0.08855109f, 0.11624437f, 0.01538451f, -0.02847978f, 0.01526277f, -0.02206646f, 0.00147729f, 
    0.15390311f, 0.02931959f, 0.05148316f, -0.09162849f, 0.11524315f, -0.04103055f, -0.07449768f, 0.43230152f, 
    0.21119381f, -0.11933452f, -0.00983976f, 0.09238893f, 0.16849320f, 0.09377297f, -0.00182525f, -0.03310513f, 
    -0.01214158f, -0.05758271f, 0.07217039f, 0.04454710f, 0.09645484f, 0.08487959f, -0.06101668f, 0.05790841f, 
    -0.01827920f, 0.08397412f, 0.09005937f, 0.10096577f, 0.29752913f, -0.06657477f, -0.07426881f, 0.24542961f, 
    0.01489251f, 0.13738392f, -0.08390345f, -0.04336904f, 0.16250689f, -0.05998601f, 0.05470242f, -0.01399653f, 
    0.21114038f, -0.17380846f, 0.03232295f, 0.14497738f, 0.11563638f, 0.01211939f, 0.09276243f, 0.09287762f, 
    0.09395605f, -0.05586479f, 0.00780748f, 0.05409493f, -0.16489330f, -0.03783461f, 0.12584317f, 0.16634776f, 
    0.06222870f, 0.02322104f, -0.10540451f, 0.11603742f, 0.03042867f, -0.12217498f, 0.03084055f, -0.01107161f, 
    0.41816181f, -0.26888537f, -0.09420761f, 0.24007696f, 0.07865579f, -0.04067373f, -0.03829069f, -0.07701039f, 
    -0.04734965f, -0.02078735f, -0.11279225f, 0.07722402f, -0.04366462f, -0.18100606f, -0.20931752f, -0.05073004f, 
    0.17808330f, 0.11295520f, -0.08085262f, -0.04060080f, -0.12588134f, -0.04858998f, 0.05591528f, -0.03354768f, 
    0.03960941f, 0.47363752f, -0.16803247f, -0.01552318f, -0.08978552f, 0.18862221f, 0.01633619f, 0.00114465f, 
    0.08464092f, -0.01828547f, 0.13792105f, -0.06209718f, -0.21863833f, 0.03477672f, -0.08911457f, -0.13272387f, 
    0.09162627f, -0.18025628f, 0.02646752f, -0.05600455f, 0.06663721f, 0.06369715f, -0.01496506f, 0.04256007f, 
    0.04912569f, 0.20941316f, 0.17370550f, -0.02781826f, -0.03190079f, 0.05573464f, 0.04245384f, -0.02628944f, 
    -0.03578654f, -0.16792266f, -0.06251956f, -0.10886081f, -0.05234794f, 0.18748131f, 0.02069592f, 0.24547403f, 
    -0.06046601f, -0.07663283f, 0.04754196f, 0.23514466f, -0.02288260f, 0.23223177f, -0.01508245f, 0.09038515f, 
    -0.26013315f, -0.20306954f, 0.10215786f, -0.02189449f, -0.08534012f, -0.07250816f, 0.00716401f, -0.00449858f, 
    0.05292054f, -0.04795467f, 0.06006204f, -0.03972933f, 0.11553298f, 0.03131019f, -0.11715999f, -0.07392547f, 
    0.09918498f, 0.01037512f, 0.02730037f, 0.09146801f, 0.02490034f, -0.08028727f, -0.04344811f, -0.05548193f, 
    -0.03962529f, 0.05034295f, -0.14859232f, -0.05137707f, 0.07868648f, 0.11793038f, 0.15344387f, -0.00258126f, 
    0.17434211f, 0.32561645f, 0.15004669f, -0.00483194f, 0.29118907f, 0.31026390f, 0.03363222f, 0.21601482f, 
    -0.08329083f, -0.02424333f, 0.05444813f, 0.07069014f, -0.08437552f, -0.03887837f, 0.17008580f, -0.04346588f, 
    0.18212476f, 0.07101689f, 0.08234069f, 0.19477570f, -0.05570798f, 0.02902840f, -0.01134236f, -0.04099859f, 
    0.12650305f, 0.16149914f, 0.31021845f, 0.09710540f, 0.22360921f, 0.05442730f, -0.07872797f, -0.07985961f, 
    0.02484367f, -0.02157806f, -0.05808040f, -0.05917676f, -0.08151702f, 0.11278950f, 0.01534330f, 0.08541519f, 
    0.01665778f, -0.04730105f, 0.02580631f, 0.00498175f, -0.05906615f, 0.01428142f, -0.05835450f, -0.04400092f, 
    0.03439571f, 0.02047078f, -0.00108873f, 0.01740940f, 0.01955258f, -0.03441257f, -0.03774516f, -0.01261278f, 
    -0.03424625f, 0.03247957f, 0.04116476f, 0.02701039f, 0.04074061f, 0.00491756f, -0.04603263f, -0.01482524f, 
    0.03747844f, -0.02153737f, -0.05536913f, -0.03995229f, 0.02554937f, 0.03766831f, -0.01778990f, 0.00367560f, 
    -0.03373744f, -0.05732312f, -0.03136203f, -0.02090402f, 0.04068385f, -0.03589007f, -0.01155251f, -0.05424098f, 
    0.00029840f, -0.00266515f, -0.04314428f, -0.03666278f, 0.00240234f, 0.02950802f, 0.01370676f, 0.01436561f, 
    0.03991279f, 0.04187510f, 0.01001950f, -0.05675955f, 0.03644519f, 0.00952592f, 0.03409687f, 0.03619075f, 
    0.01221009f, 0.03809635f, -0.04004203f, 0.00804590f, -0.00450063f, -0.02234752f, -0.04697917f, -0.01636381f, 
    -0.03128234f, 0.00787799f, -0.01569327f, -0.01947192f, -0.01536761f, 0.02492693f, 0.04001150f, 0.01707334f, 
    -0.01378295f, 0.02092328f, 0.02695714f, 0.00874109f, -0.04767035f, -0.03014581f, 0.01490796f, 0.02459670f, 
    -0.02930400f, 0.01100156f, 0.04146718f, -0.02567592f, -0.00972283f, -0.04413548f, 0.02442121f, 0.00931057f, 
    -0.01913784f, 0.04826785f, -0.02747734f, 0.03187032f, -0.03996242f, 0.01434897f, -0.00855985f, -0.03282757f, 
    -0.05109866f, -0.04717741f, 0.03498252f, 0.01466944f, 0.00329839f, -0.00183726f, 0.00998759f, -0.04209088f, 
    -0.03159094f, 0.02510094f, -0.00587256f, 0.02957551f, 0.03824114f, -0.04515526f, 0.04040384f, 0.01669667f, 
    0.03178053f, -0.05298636f, 0.00951605f, -0.05668265f, -0.01460925f, 0.03488779f, -0.02610058f, 0.03797052f, 
    -0.04874214f, 0.01718046f, 0.03986534f, 0.01525085f, -0.05381180f, -0.01823032f, -0.02816540f, -0.02052624f, 
    -0.03173533f, -0.03847116f, 0.01163432f, 0.01414782f, 0.02906104f, 0.02139745f, 0.02319867f, -0.04079013f, 
    0.03608736f, 0.03761029f, -0.03916480f, 0.03411979f, -0.03736992f, 0.03309395f, -0.05125288f, -0.00193440f, 
    -0.03368811f, -0.02609691f, -0.00675129f, 0.02636052f, -0.03655934f, -0.01411614f, 0.02432192f, -0.01618792f, 
    -0.02469053f, -0.00481443f, 0.02052938f, -0.02351105f, -0.04308052f, -0.03169729f, 0.03183315f, -0.04559982f, 
    0.02911422f, -0.01049733f, -0.02240028f, 0.04732528f, -0.01822104f, -0.04966540f, -0.05296499f, -0.01948832f, 
    -0.03573520f, -0.01464909f, 0.02655319f, -0.02760461f, -0.03168875f, -0.04969503f, 0.03186264f, -0.01153521f, 
    -0.03977516f, 0.01144435f, -0.00501960f, -0.01756335f, 0.01479802f, -0.04021106f, -0.01559810f, -0.03324068f, 
    -0.04877431f, -0.04409702f, -0.00912117f, 0.01678017f, 0.03875775f, -0.04331312f, -0.04805937f, 0.01006957f, 
    0.02725859f, -0.02575631f, -0.02715850f, -0.02100035f, -0.00903208f, 0.01357175f, -0.03304179f, -0.03667319f, 
    -0.05813224f, 0.01578039f, -0.00358372f, -0.03487196f, 0.00726570f, -0.02680716f, 0.03049986f, 0.03030158f, 
    -0.02275263f, -0.01352945f, -0.00968631f, 0.04108695f, 0.02281497f, -0.02720298f, 0.01770254f, -0.02264832f, 
    -0.05196870f, 0.02553300f, -0.00623994f, 0.01459663f, -0.02759069f, -0.01596475f, 0.04053154f, 0.01085383f, 
    -0.00747030f, -0.04424505f, -0.01045376f, -0.02567786f, 0.04491534f, 0.02408435f, -0.05196083f, 0.03505951f, 
    -0.05493922f, -0.01665100f, -0.04627764f, -0.02410124f, -0.01972527f, 0.00407517f, -0.04885079f, -0.02824669f, 
    0.00576439f, -0.03236310f, -0.04894464f, -0.00302642f, 0.02671417f, -0.01908883f, -0.00629878f, 0.04525764f, 
    -0.04284612f, 0.02197922f, -0.03107409f, 0.03526285f, -0.01135574f, -0.02125203f, 0.00108132f, -0.00020670f, 
    -0.00483699f, 0.02149896f, -0.02859935f, -0.00705985f, 0.01118984f, 0.00952176f, -0.05674475f, 0.00562077f, 
    0.01996340f, -0.01373222f, 0.02187954f, 0.00877211f, 0.00895503f, 0.03080559f, -0.05701961f, -0.05476426f, 
    -0.00859665f, 0.01187596f, -0.03650837f, 0.02330225f, 0.04221547f, -0.04783779f, 0.04494550f, 0.04430396f, 
    0.00116971f, 0.00940152f, -0.00690326f, -0.02798252f, -0.00349541f, 0.02032260f, 0.03289344f, -0.02558220f, 
    0.01870215f, -0.00025003f, 0.00622419f, -0.05003436f, -0.02274589f, -0.03432139f, 0.04029373f, 0.00191844f, 
    0.01798509f, 0.01640702f, 0.00448015f, 0.03091357f, 0.01028168f, 0.03393516f, -0.03785357f, 0.04185416f, 
    0.04055479f, 0.01973359f, 0.00915145f, -0.02462564f, 0.03308235f, -0.04623206f, 0.03852829f, -0.04943895f, 
    -0.02202977f, -0.00441017f, 0.03610998f, -0.02643202f, 0.03154223f, 0.00637700f, 0.01803097f, -0.03062788f, 
    0.00117022f, -0.04486924f, -0.00060867f, -0.04566612f, 0.00855616f, -0.05784604f, -0.00214575f, 0.02357421f, 
    -0.05300065f, -0.04578083f, -0.03829596f, 0.03846767f, 0.03327420f, -0.05416377f, -0.02733688f, -0.04742477f, 
    -0.01594348f, 0.03962136f, 0.02648569f, 0.03401949f, -0.05326592f, 0.04395943f, -0.00358403f, -0.04201232f, 
    0.01220988f, -0.04086303f, 0.00236200f, -0.03108554f, 0.01773766f, -0.04938066f, 0.02839534f, 0.00050682f, 
    -0.00148211f, 0.00925330f, 0.01812292f, 0.04007033f, -0.03425065f, 0.01354385f, -0.02546239f, -0.02959602f, 
    0.02242014f, 0.03429900f, -0.01140845f, -0.01088354f, 0.04209618f, 0.04232209f, 0.02667874f, 0.01996790f, 
    0.00843003f, 0.01374855f, 0.04285056f, -0.02465992f, -0.04436770f, -0.01466857f, 0.03790643f, -0.04126878f, 
    -0.00374881f, -0.03634463f, -0.01704099f, -0.02082696f, 0.04318530f, -0.05073770f, 0.03581225f, 0.01874115f, 
    0.34149238f, -0.53656447f, 0.06805106f, -0.06191720f, 0.11309604f, -0.03151648f, -0.06307091f, 0.00048222f, 
    0.14437541f, -0.02333620f, 0.04330656f, 0.05125942f, -0.04875026f, 0.19147712f, 0.09947333f, -0.10020757f, 
    -0.04785787f, 0.08567726f, -0.09148654f, 0.01211332f, -0.02204514f, -0.08326909f, 0.00900964f, 0.01220376f, 
    -0.19493516f, -0.20614460f, -0.00939426f, 0.08608115f, -0.05449427f, -0.07359249f, -0.04716937f, -0.05603791f, 
    -0.21466412f, -0.09444835f, -0.03800917f, -0.01468458f, -0.27299958f, -0.05511758f, -0.11836419f, 0.04687872f, 
    -0.13369752f, -0.00762315f, -0.00614051f, 0.08393129f, 0.01663258f, -0.15074013f, -0.13137674f, -0.21244819f, 
    0.59082168f, 0.25924647f, 0.03154381f, -0.03305127f, 0.01069686f, -0.06473245f, 0.02835011f, 0.06419289f, 
    0.14810595f, 0.08363441f, -0.05743748f, 0.03227684f, 0.10060074f, -0.13667127f, -0.17238456f, 0.15754920f, 
    0.11960664f, -0.09030387f, 0.07158952f, 0.02672395f, 0.21345414f, -0.11498041f, -0.20248803f, 0.04905663f, 
    0.32599512f, -0.22186044f, -0.07638026f, 0.23748578f, 0.17757362f, 0.03163628f, 0.05914688f, -0.24228235f, 
    0.02391837f, 0.04906521f, 0.11905910f, 0.09562098f, 0.01418298f, 0.01705034f, -0.00777754f, -0.16191959f, 
    0.17018379f, -0.00932765f, 0.02690453f, 0.01938482f, 0.13053900f, 0.11372871f, 0.00514187f, 0.17745247f, 
    0.04516777f, -0.20279150f, 0.07292469f, 0.15030769f, 0.00584425f, -0.01843950f, 0.02143320f, -0.02583525f, 
    0.03396003f, 0.00324237f, -0.09009041f, -0.01973259f, 0.15565467f, -0.08529507f, -0.12082069f, -0.19078858f, 
    0.15824997f, -0.03284890f, 0.03399937f, -0.10103960f, 0.04503867f, -0.05288761f, 0.08207522f, -0.03879016f, 
    -0.26377743f, 0.13050227f, -0.05265198f, 0.17204218f, -0.14335036f, 0.12780285f, -0.02664031f, -0.06837606f, 
    0.04488392f, 0.01958771f, -0.02918964f, 0.01138459f, 0.30722770f, 0.07106956f, -0.13613372f, -0.20599817f, 
    0.07206054f, -0.04036268f, 0.00447085f, -0.02292772f, -0.08019923f, -0.04240633f, -0.13906920f, -0.05136071f, 
    -0.10855489f, -0.12737261f, 0.21545236f, -0.01129745f, 0.08922321f, 0.03584823f, 0.07345223f, 0.07250460f, 
    -0.28103280f, -0.04483861f, -0.07330521f, -0.07403383f, 0.52959937f, -0.06869216f, -0.18772121f, -0.25628409f, 
    0.03589484f, -0.14492907f, -0.02727614f, -0.06995866f, -0.03711674f, 0.01596407f, 0.08249432f, -0.01585238f, 
    0.11773452f, 0.13890645f, -0.04118619f, -0.08046238f, -0.00258655f, 0.04134088f, 0.08866405f, 0.04678063f, 
    -0.00478467f, -0.14051859f, 0.06200011f, 0.12655787f, 0.41829276f, 0.06768630f, -0.21839957f, 0.09409252f, 
    0.11772171f, 0.06605511f, -0.00528636f, 0.00862165f, 0.08155467f, -0.00064161f, -0.02754255f, -0.03609076f, 
    -0.24328507f, -0.12916501f, 0.11141792f, 0.28208113f, 0.10414333f, -0.06566464f, -0.06497955f, -0.00111941f, 
    0.06147429f, -0.01975102f, 0.03133245f, 0.03061679f, -0.14208293f, 0.19210671f, -0.23396590f, 0.08277176f, 
    0.19690663f, -0.02723431f, 0.03191352f, -0.14291656f, 0.05573150f, 0.04425953f, -0.03743071f, 0.08857094f, 
    0.09172326f, 0.15346867f, 0.03139110f, -0.08140265f, 0.19170906f, 0.00337712f, -0.03021814f, -0.01715016f, 
    -0.01354822f, 0.02083086f, 0.15254061f, 0.13464613f, 0.08782333f, -0.00243027f, 0.09593900f, -0.36924040f, 
    -0.12019823f, 0.02337066f, -0.01038890f, 0.14363755f, 0.04482668f, 0.05067975f, 0.05153096f, 0.04412561f, 
    -0.08720291f, 0.26293060f, -0.17232823f, 0.30470085f, 0.25575048f, 0.08658121f, 0.01058078f, -0.06005745f, 
    0.10515793f, 0.11193341f, 0.12683892f, 0.09640231f, 0.12451644f, 0.01153436f, -0.13753033f, -0.12293252f, 
    -0.02702665f, -0.00763849f, -0.03240459f, -0.00977050f, 0.01585061f, 0.04042150f, 0.10360795f, -0.00631725f, 
    -0.16917461f, -0.19946511f, -0.11727352f, -0.09452069f, 0.00237698f, -0.00023919f, -0.17384139f, 0.20391367f, 
    -0.14447621f, 0.04889563f, 0.21380648f, -0.17517132f, -0.12930273f, 0.31112605f, -0.21569008f, 0.05082273f, 
    0.01940745f, -0.27140206f, -0.02069582f, 0.01029297f, -0.03618453f, 0.08181363f, 0.01347260f, 0.20303677f, 
    -0.05689422f, 0.17006841f, 0.01477799f, -0.01328590f, -0.14593203f, -0.11248183f, -0.11613502f, -0.05438191f, 
    0.09485406f, -0.00869921f, 0.08407938f, -0.12673980f, -0.12751682f, -0.18069683f, 0.01599735f, 0.02251584f, 
    0.11661100f, -0.01740905f, 0.17178385f, 0.33491948f, 0.11409490f, 0.09563953f, 0.11669419f, 0.09732038f, 
    -0.01502253f, -0.10541911f, 0.12726666f, -0.14288677f, -0.12506366f, -0.18009730f, -0.11055034f, 0.12899944f, 
    0.00976811f, -0.06430592f, 0.09924256f, 0.07319383f, 0.11876607f, -0.34239972f, -0.12176555f, 0.12050211f, 
    0.05765897f, -0.00150807f, 0.00500607f, -0.00792995f, -0.08403660f, 0.04187721f, -0.08289181f, 0.11313122f, 
    0.05186085f, 0.16471221f, -0.14706333f, -0.27122468f, 0.17239879f, 0.06650174f, -0.03925605f, 0.14384809f, 
    -0.04254625f, 0.12891600f, -0.03228077f, -0.18927120f, 0.46327841f, 0.09682173f, -0.27229452f, 0.20683214f, 
    -0.02381231f, -0.01453139f, 0.11395831f, 0.00620958f, -0.00083972f, -0.07288994f, 0.06954537f, 0.05646706f, 
    0.32076162f, 0.14443310f, -0.05812061f, -0.15105410f, 0.12470965f, -0.03403559f, -0.07402216f, -0.04140928f, 
    -0.04462517f, -0.04713197f, 0.01476971f, -0.17369379f, 0.18643637f, 0.26140630f, 0.23160486f, 0.04636972f, 
    0.10883349f, 0.03147184f, 0.10649845f, 0.22164704f, -0.04875302f, -0.09271590f, -0.02202395f, 0.00697737f, 
    -0.08159382f, -0.04107454f, 0.20432763f, 0.17883985f, -0.11340800f, 0.11241084f, -0.02079883f, 0.26748723f, 
    -0.08120015f, 0.15953144f, -0.02740012f, -0.01411756f, -0.13159172f, 0.11360467f, -0.03667521f, 0.05886011f, 
    0.14363337f, 0.05485221f, 0.06160924f, -0.01579266f, -0.07578414f, 0.01738229f, -0.05102519f, 0.15915814f, 
    0.11085110f, 0.27538499f, 0.05727526f, -0.02282204f, -0.05349290f, 0.13923077f, -0.09771080f, -0.07891998f, 
    -0.20232815f, 0.11030152f, 0.08866980f, 0.01098883f, 0.12042468f, 0.02410888f, 0.14321703f, -0.08150970f, 
    0.08854615f, -0.07650091f, -0.01842798f, 0.05276592f, -0.02618452f, 0.04731518f, -0.00572439f, -0.02961197f, 
    -0.30155486f, -0.24530061f, 0.08052190f, 0.17590484f, 0.05820221f, -0.00283036f, 0.00253887f, -0.03230373f, 
    -0.01656925f, 0.05011984f, -0.06110136f, 0.05032296f, -0.50286984f, -0.07762627f, 0.10631403f, -0.17168264f, 
    0.04540126f, -0.06882925f, 0.05103417f, -0.05378261f, -0.05722007f, -0.12252980f, -0.09737933f, -0.01168297f, 
    0.66991591f, -0.25566044f, 0.03273197f, 0.16527800f, -0.00310038f, 0.07313340f, 0.04042587f, -0.07100607f, 
    -0.00690185f, 0.26147670f, 0.13111602f, 0.03668379f, 0.18889031f, -0.17527631f, 0.05004992f, -0.21242124f, 
    -0.05464823f, 0.04792196f, 0.00732408f, -0.01614585f, 0.10643686f, 0.02522749f, -0.02931990f, 0.10229164f, 
    0.53328300f, -0.00077114f, 0.02682892f, 0.07250306f, -0.07889339f, 0.05385966f, -0.08143691f, 0.06312922f, 
    -0.06772479f, 0.11164769f, 0.18294366f, 0.01589682f, 0.25674066f, 0.16282414f, -0.04537057f, 0.11822535f, 
    0.19092597f, -0.01290858f, -0.24816884f, -0.01189227f, 0.04182162f, 0.14462528f, -0.11056460f, 0.06024248f, 
    0.24609841f, 0.11778284f, 0.10946551f, 0.05841371f, 0.07406979f, -0.06197146f, -0.08607776f, -0.04343133f, 
    -0.01463754f, 0.13559939f, 0.00099751f, 0.07798099f, -0.27314410f, -0.04358740f, -0.18749762f, -0.11111675f, 
    0.04989188f, 0.10331047f, 0.04743200f, -0.04227573f, 0.01539511f, -0.12730381f, 0.11289211f, 0.18630810f, 
    -0.08954456f, 0.02018872f, -0.00082163f, -0.06956968f, 0.00743073f, 0.02052281f, 0.20892975f, -0.04392194f, 
    -0.01876508f, -0.02506436f, 0.11277174f, 0.00806743f, -0.26956442f, -0.19911405f, -0.14619491f, -0.02489686f, 
    0.09748792f, 0.13021430f, 0.00590985f, 0.00391791f, -0.07491407f, 0.14396003f, 0.07282431f, -0.05734582f, 
    0.17391759f, 0.02142983f, 0.09000704f, -0.04843669f, -0.10818686f, -0.04522734f, 0.12054234f, -0.04201869f, 
    -0.14476644f, -0.04941203f, -0.02073973f, 0.12359030f, -0.36546689f, -0.11530121f, -0.00527991f, -0.14584641f, 
    0.12811348f, 0.01880087f, 0.00285934f, -0.04289524f, -0.06642966f, 0.06432817f, -0.00280292f, -0.02158204f, 
    0.17283808f, -0.09285967f, -0.04881458f, -0.02781310f, -0.09230208f, -0.02085975f, 0.20695075f, -0.05694696f, 
    -0.00645702f, 0.00297665f, -0.01030879f, 0.04218310f, -0.25412259f, -0.01257283f, -0.08326207f, -0.07238265f, 
    0.02438933f, -0.14427191f, -0.04596310f, -0.01389841f, -0.02758168f, -0.05829903f, 0.01349184f, -0.12283975f, 
    -0.28600359f, 0.02052267f, -0.23798171f, -0.06803596f, -0.13168383f, 0.09629764f, 0.06159174f, -0.09872691f, 
    0.03055779f, -0.08532614f, 0.11399600f, 0.10624644f, -0.07699167f, 0.12278781f, -0.01519875f, 0.02216277f, 
    0.09782781f, 0.03544771f, -0.03951939f, -0.12706731f, -0.02496340f, 0.00433477f, 0.12043151f, 0.02853866f, 
    -0.36433512f, 0.23577712f, -0.27527130f, -0.11931062f, 0.05697765f, -0.03123907f, -0.05138325f, -0.00595401f, 
    0.04376088f, 0.03393129f, 0.09433824f, 0.01581525f, -0.14294812f, -0.01563827f, -0.12848452f, 0.05096819f, 
    0.10608161f, -0.09675314f, -0.07238750f, 0.12981984f, -0.12739511f, -0.12343755f, -0.04271464f, -0.03612493f, 
    -0.20228577f, -0.03423511f, 0.00184205f, -0.06630147f, 0.20286387f, -0.05291937f, 0.04320895f, 0.08533424f, 
    -0.10846122f, 0.06692591f, -0.00105444f, 0.02066041f, 0.16247548f, 0.20964453f, 0.18255495f, 0.21180318f, 
    -0.11083917f, 0.15732421f, -0.03808715f, 0.00198517f, -0.08157274f, -0.03850568f, 0.17902604f, 0.00800952f, 
    0.40882197f, -0.05134017f, 0.23725063f, -0.00866238f, -0.06053777f, -0.02426256f, -0.10846304f, -0.03358088f, 
    -0.21198902f, 0.05331784f, -0.02766489f, 0.09448458f, 0.19562806f, -0.33492216f, 0.06089952f, -0.19990753f, 
    0.08453628f, 0.04485616f, 0.14888370f, 0.04955043f, 0.06785057f, -0.03467675f, 0.04412429f, 0.01972651f, 
    0.23369262f, 0.18655482f, 0.14943141f, 0.03978671f, -0.09923428f, -0.03639073f, -0.00823601f, 0.01976335f, 
    0.09195399f, 0.14275564f, 0.00113262f, 0.17873891f, -0.02411347f, 0.33324608f, 0.07062904f, 0.23739073f, 
    0.08570764f, -0.07077345f, 0.02824553f, -0.04274555f, -0.12892017f, 0.04870619f, 0.10219473f, 0.03856831f, 
    0.15420716f, -0.09770979f, 0.05577395f, 0.12608014f, 0.03599609f, 0.15323871f, -0.16990381f, 0.05002819f, 
    -0.00361663f, -0.00561787f, -0.01376043f, 0.05304961f, 0.33866644f, -0.04777719f, 0.08638797f, -0.04047824f, 
    -0.11799611f, 0.11126430f, -0.02356048f, 0.08345447f, -0.00204089f, 0.06566483f, -0.01004082f, -0.01177679f, 
    -0.17784268f, -0.20884602f, -0.11519182f, -0.23298678f, 0.00683092f, 0.06296228f, -0.03709957f, 0.00809124f, 
    -0.08654409f, 0.05773446f, -0.02413891f, -0.06872018f, 0.01492854f, -0.14155215f, -0.07602017f, 0.06280922f, 
    -0.02664409f, 0.05414170f, -0.09102483f, 0.11414755f, -0.04220742f, -0.00147520f, -0.07421767f, -0.05269846f, 
    -0.01379948f, -0.04438660f, 0.00251420f, -0.03775718f, 0.00905645f, 0.02629947f, -0.05431094f, 0.00590780f, 
    0.03600968f, 0.01094324f, 0.00491548f, 0.03369562f, -0.01695586f, -0.01406385f, -0.03454628f, -0.02729244f, 
    -0.05402429f, -0.02821182f, 0.00690212f, -0.00731319f, 0.03533099f, -0.05159357f, -0.01826589f, 0.01861398f, 
    0.00253984f, 0.02981723f, 0.03788251f, -0.02244907f, -0.04494958f, -0.02994564f, 0.01574796f, 0.01955222f, 
    -0.01352957f, 0.02610736f, -0.05028768f, 0.03677119f, -0.04027568f, -0.01970883f, -0.04181938f, -0.02903260f, 
    0.03340486f, 0.01320021f, 0.00214569f, 0.04454329f, -0.05458812f, -0.04062087f, -0.01403375f, -0.04780879f, 
    0.01069205f, -0.03110909f, 0.01039306f, 0.03402395f, -0.04355304f, -0.02572643f, 0.01409442f, -0.03919460f, 
    0.02971936f, 0.04311109f, 0.03514647f, -0.01861999f, 0.02051020f, -0.01185661f, -0.04375302f, -0.04372270f, 
    -0.03273454f, -0.05259842f, -0.01947045f, 0.03442516f, 0.01386258f, -0.03769992f, -0.05514192f, 0.03049334f, 
    0.03737492f, -0.02780055f, -0.01806034f, -0.01889331f, -0.01335488f, 0.00711397f, -0.02134588f, -0.03091716f, 
    0.00341198f, 0.02671702f, -0.00056417f, -0.03027683f, -0.02109987f, 0.02926207f, -0.04331142f, -0.02371144f, 
    0.00209537f, -0.02741374f, 0.02434249f, 0.01040051f, 0.04150289f, -0.04003480f, 0.03087788f, -0.04437216f, 
    -0.05082354f, -0.00169749f, -0.02503392f, -0.04978022f, -0.00036647f, 0.01143992f, 0.00484784f, -0.04926106f, 
    0.01055378f, -0.01022855f, 0.01587206f, 0.04235568f, -0.04353282f, -0.03911551f, -0.04715997f, 0.00845417f, 
    -0.04561180f, 0.00110345f, 0.01892579f, -0.00730244f, -0.01350722f, 0.02797377f, -0.04521654f, 0.03491250f, 
    -0.05684747f, 0.00987825f, -0.05524223f, -0.00162401f, -0.02692472f, 0.00200317f, 0.01038528f, -0.04618990f, 
    0.04211183f, -0.00577759f, 0.04327767f, -0.04772136f, 0.03133048f, -0.01109224f, -0.04148389f, 0.04990049f, 
    -0.00577099f, 0.04409724f, 0.00220782f, 0.00192194f, -0.01458424f, 0.03685208f, 0.03641102f, -0.05281978f, 
    0.03676803f, -0.02172037f, -0.00258101f, -0.01980235f, -0.00446600f, -0.02916653f, 0.02638858f, -0.01630966f, 
    -0.00122013f, -0.01362406f, 0.02718022f, -0.05290563f, -0.02588322f, -0.01747226f, 0.04353523f, 0.00561732f, 
    0.02514431f, 0.00111869f, -0.00997226f, 0.04495135f, -0.04109346f, -0.05790712f, -0.04381755f, 0.03531820f, 
    -0.03913638f, 0.00581380f, -0.01103846f, -0.03496889f, -0.01767537f, 0.01089686f, 0.02857026f, -0.03329567f, 
    0.03753536f, -0.03194024f, -0.02067504f, 0.02140254f, 0.02498995f, -0.04258291f, 0.01428511f, 0.03709368f, 
    -0.02913953f, 0.04051990f, 0.03773513f, 0.01980584f, -0.02522171f, 0.02438859f, -0.03134542f, 0.04764141f, 
    0.03767937f, -0.01606136f, -0.01413522f, -0.01286673f, -0.05095817f, 0.04042720f, -0.00545077f, -0.04408042f, 
    0.01096740f, -0.02484743f, 0.00639053f, -0.00911326f, 0.04204048f, -0.03685335f, 0.00987272f, -0.03046910f, 
    -0.01082237f, -0.02782462f, 0.01226050f, 0.02200198f, 0.03342748f, 0.00257014f, -0.04544868f, -0.03574869f, 
    -0.02294779f, -0.04192562f, 0.02140067f, -0.02119597f, -0.00255744f, -0.03487949f, -0.03169079f, 0.00166394f, 
    -0.03500105f, -0.03545731f, 0.01614872f, -0.03463334f, -0.02148273f, -0.04504351f, -0.04530593f, -0.00786638f, 
    0.01033352f, -0.01183731f, -0.00749303f, 0.01313044f, -0.04841255f, -0.05756799f, 0.01418919f, -0.01128548f, 
    0.02806667f, 0.03513235f, 0.03956333f, -0.03678383f, -0.02956071f, -0.03112460f, 0.02382573f, -0.00489538f, 
    -0.00281452f, -0.02321904f, 0.01421887f, -0.03237703f, -0.02090135f, -0.00959329f, -0.00868188f, -0.05368341f, 
    -0.02196327f, -0.00886643f, 0.01951627f, -0.05104125f, -0.02121270f, -0.02591497f, -0.05594612f, -0.01332405f, 
    0.01083533f, -0.04164270f, -0.01579854f, 0.00927237f, 0.04201120f, 0.02929192f, -0.03631353f, -0.04380279f, 
    -0.01699690f, -0.04524637f, -0.04012542f, -0.02971795f, -0.02396232f, -0.05905217f, 0.01860080f, -0.01264537f, 
    0.01853246f, 0.01434305f, -0.01514694f, -0.02799605f, -0.03313065f, 0.00999645f, 0.00328026f, -0.00470721f, 
    0.00971761f, -0.00000580f, -0.01242572f, 0.01124192f, -0.01172840f, 0.02813724f, -0.02345803f, -0.00703855f, 
    -0.03222455f, 0.02657567f, -0.03884248f, 0.00165243f, -0.03216680f, -0.04744980f, 0.01070068f, 0.01021579f, 
    0.01510674f, 0.01602293f, 0.01071591f, 0.03017900f, -0.01175494f, 0.01665309f, -0.04710082f, 0.01594674f, 
    -0.03482707f, 0.01542378f, 0.01508499f, 0.04144252f, 0.00833350f, 0.02388832f, 0.03916070f, -0.00492447f, 
    0.02389748f, 0.00228309f, -0.02499231f, 0.02812911f, -0.04266812f, 0.04068323f, -0.02818678f, -0.04672704f, 
    -0.00490160f, -0.05240619f, 0.02625139f, 0.02184651f, 0.05011868f, -0.05439828f, -0.03796505f, 0.01836756f, 
    -0.03270485f, -0.01328835f, 0.01074243f, -0.02959042f, -0.00547667f, -0.00115312f, -0.00228374f, 0.03757664f, 
    -0.04278858f, -0.02649043f, -0.01273717f, -0.00994814f, -0.00537021f, 0.02675962f, 0.01764320f, 0.02909411f, 
    0.02991489f, 0.01587253f, -0.02482246f, 0.02994710f, -0.00060131f, -0.01375611f, -0.00779306f, -0.04335985f, 
    0.02544308f, 0.01721675f, -0.03576637f, -0.03975414f, 0.01057850f, 0.00343737f, 0.03599437f, 0.03243008f, 
    -0.00861756f, -0.02821493f, -0.01437017f, -0.02116211f, -0.03352151f, -0.04199751f, 0.03575363f, 0.01874525f, 
    0.02215359f, 0.01149145f, -0.00098736f, -0.04359908f, -0.03219152f, -0.00383067f, 0.01726729f, -0.01140713f, 
    -0.26474187f, 0.01593655f, 0.10400587f, 0.14306538f, 0.23644891f, -0.03920611f, 0.15155195f, -0.13979705f, 
    0.07607182f, -0.00061258f, 0.05910688f, -0.03080475f, 0.35631230f, 0.02679232f, 0.26327336f, -0.10560045f, 
    0.01695469f, 0.17811923f, 0.11252200f, 0.01645030f, -0.03533267f, 0.01545134f, -0.11143389f, 0.03369056f, 
    -0.07952809f, 0.00027540f, 0.13003767f, 0.27395990f, 0.03313265f, -0.02517296f, -0.05491814f, -0.09661948f, 
    -0.05480272f, -0.05025608f, 0.01064196f, 0.15651682f, 0.10204234f, 0.26426551f, 0.16599444f, -0.17134817f, 
    0.00892631f, 0.03592894f, -0.06346634f, 0.05938342f, -0.03268014f, 0.10119344f, -0.04446026f, -0.21051048f, 
    -0.18846002f, -0.15142375f, 0.30328333f, -0.03261650f, 0.15098451f, 0.10389183f, 0.05944524f, 0.00878435f, 
    0.12359183f, 0.13710983f, -0.10104893f, 0.06916484f, -0.33027673f, 0.00963156f, -0.00274953f, -0.14601430f, 
    0.12198963f, 0.04455442f, 0.06195731f, -0.01344857f, 0.05946720f, 0.01944733f, 0.03450874f, -0.05577146f, 
    0.10785418f, 0.10647587f, 0.16564636f, -0.30649757f, 0.01937346f, -0.08004166f, 0.07928421f, 0.09353225f, 
    -0.11751325f, 0.00456888f, 0.11235239f, 0.14374872f, 0.14427640f, 0.06104109f, 0.07630908f, -0.43844268f, 
    0.18795262f, -0.13573508f, -0.04171751f, 0.06640901f, 0.12730816f, 0.13956478f, 0.11083892f, 0.10027131f, 
    -0.08612180f, -0.15785711f, 0.30689418f, 0.12101704f, -0.01669354f, -0.07745555f, 0.10921220f, 0.08524728f, 
    -0.05397271f, 0.09648564f, 0.05996472f, 0.14509426f, 0.37350827f, -0.00533360f, -0.03276328f, -0.08200117f, 
    0.11492008f, -0.07302418f, 0.09034412f, -0.20108548f, -0.05249695f, 0.01979945f, 0.12743311f, 0.03543738f, 
    0.42021331f, -0.22512826f, 0.21360761f, -0.23080261f, -0.03865372f, 0.08268145f, 0.04422696f, 0.08317821f, 
    0.03589821f, 0.11806474f, -0.01318188f, -0.02934764f, -0.14855994f, -0.03386878f, -0.02552862f, -0.46586186f, 
    0.17632428f, -0.05607554f, -0.00613418f, 0.00237323f, 0.12822630f, -0.02660951f, -0.05658328f, 0.00146248f, 
    -0.34562615f, 0.30306515f, 0.09692251f, -0.27161005f, 0.04229705f, 0.02178210f, 0.04425347f, 0.00301597f, 
    -0.01043362f, -0.22755924f, -0.05368954f, 0.01399786f, -0.07481267f, 0.08427383f, -0.01084021f, -0.25724074f, 
    0.12909171f, 0.03565152f, 0.01460810f, 0.04705499f, 0.04822412f, -0.01623832f, 0.19308297f, 0.05788320f, 
    -0.14618459f, 0.19438255f, 0.05642959f, 0.11889801f, -0.07950671f, 0.18158996f, 0.23648334f, 0.01135323f, 
    0.03693981f, 0.02670432f, -0.02422245f, -0.09883115f, -0.33254528f, 0.02823168f, -0.06395285f, -0.11356897f, 
    0.14820912f, 0.15595500f, -0.12226190f, -0.02819798f, -0.05723589f, 0.13476165f, 0.11319581f, 0.02203008f, 
    0.11230656f, -0.03448110f, 0.00274321f, 0.01069973f, 0.16597240f, -0.05742351f, -0.01508278f, 0.25138935f, 
    0.17697404f, 0.05533597f, 0.01071504f, 0.05597317f, -0.23454526f, 0.23172681f, -0.00013702f, -0.22942679f, 
    0.22905497f, -0.02973305f, 0.02671419f, 0.03246051f, -0.10238732f, 0.08800337f, 0.04039935f, -0.00965010f, 
    -0.17975812f, 0.20633762f, -0.08385477f, -0.32810453f, 0.13573012f, -0.02019778f, -0.01628449f, -0.01889132f, 
    -0.10718385f, 0.09738698f, -0.00284223f, 0.25198567f, -0.02172913f, 0.14750585f, 0.07584915f, -0.32630858f, 
    0.03298767f, 0.05321544f, 0.04305618f, -0.02308364f, 0.07581983f, 0.17256002f, -0.00955763f, 0.17016234f, 
    -0.34732461f, 0.07889305f, -0.07343973f, -0.04470566f, 0.07697425f, 0.02892405f, 0.12188096f, -0.06322632f, 
    0.08243566f, 0.10638557f, 0.12782481f, 0.26631862f, 0.15071349f, 0.09326724f, 0.32537672f, -0.21561451f, 
    -0.09083187f, -0.07703909f, -0.06692806f, 0.07987133f, 0.15830931f, 0.14273623f, -0.01132524f, -0.01370542f, 
    0.11214213f, -0.34114718f, -0.08942802f, 0.52054608f, 0.00009770f, -0.15908612f, 0.07540327f, 0.00165965f, 
    -0.16356933f, -0.08304443f, -0.06427141f, 0.10024826f, -0.21338136f, 0.22220521f, -0.44979212f, 0.53599179f, 
    -0.06499118f, -0.00892169f, -0.01500862f, 0.02127461f, 0.08501292f, 0.10269780f, -0.05838346f, 0.06272534f, 
    0.12340799f, 0.11504959f, 0.11625692f, 0.07468528f, 0.04052904f, 0.15781796f, -0.04099407f, 0.02027894f, 
    0.06380092f, 0.04881183f, 0.10992987f, 0.00215402f, -0.08532960f, -0.08521017f, -0.07038734f, 0.01805669f, 
    -0.06044617f, 0.09517688f, -0.07008043f, 0.22769225f, -0.01629159f, -0.01428921f, 0.19933736f, 0.14053079f, 
    0.05175655f, 0.29403445f, -0.02982547f, 0.43948218f, -0.01686231f, 0.04702789f, -0.01378763f, -0.08376418f, 
    -0.00686252f, 0.01471011f, -0.00199306f, 0.07716645f, 0.01311823f, -0.11423583f, 0.15728837f, 0.08727534f, 
    0.00748530f, 0.04962044f, -0.03551914f, -0.02049121f, -0.05143496f, -0.00014540f, 0.06682886f, 0.02272758f, 
    -0.14470805f, 0.07514320f, -0.22697566f, 0.21076120f, -0.03852412f, 0.02128819f, 0.00010850f, -0.15606159f, 
    0.09188969f, 0.02475375f, 0.03097077f, -0.02913781f, -0.01063863f, -0.33986121f, 0.01332402f, 0.10106453f, 
    0.03677120f, 0.01129054f, 0.09377954f, -0.06315890f, -0.08046149f, 0.05380410f, -0.08894821f, -0.00757005f, 
    -0.35021585f, 0.17973232f, -0.08592613f, -0.07640711f, 0.05872315f, 0.04476177f, -0.10142931f, -0.09105754f, 
    0.04498621f, -0.05795824f, 0.05603081f, -0.10734074f, -0.31473452f, 0.19830902f, 0.12470723f, 0.54232621f, 
    0.08629195f, 0.14674102f, 0.11843948f, -0.01136191f, 0.12155716f, -0.07764411f, 0.07227665f, -0.13997832f, 
    0.04406741f, 0.03547919f, -0.05121466f, 0.01735074f, -0.03140135f, -0.05582333f, -0.01502557f, 0.04725427f, 
    -0.02556412f, -0.05432233f, 0.03935376f, -0.04089631f, -0.01685321f, 0.03002476f, 0.03734460f, 0.03206933f, 
    -0.01190456f, -0.05325344f, -0.03838214f, -0.02016846f, -0.02812483f, -0.05937852f, 0.00913000f, 0.02548474f, 
    -0.05356729f, -0.02789931f, 0.01990692f, -0.05360109f, 0.03504805f, 0.00286813f, 0.00486510f, -0.02896027f, 
    0.00940391f, -0.01013527f, 0.02026800f, 0.03404626f, -0.03741128f, 0.02168072f, -0.01737393f, -0.03052235f, 
    -0.01164671f, 0.02285497f, -0.03126777f, -0.04353331f, -0.01825039f, -0.06070202f, -0.03632041f, -0.05205940f, 
    0.04049275f, 0.03495338f, -0.01948932f, -0.00554258f, -0.00752073f, -0.04289643f, -0.00221729f, -0.00553177f, 
    -0.03603132f, -0.01309401f, 0.01884027f, -0.05438085f, 0.03878111f, -0.05339471f, 0.03226593f, 0.02457340f, 
    -0.00813474f, -0.02918347f, -0.04839856f, 0.00155595f, 0.02002160f, -0.03259487f, -0.00519167f, -0.05427079f, 
    0.03849319f, 0.01775299f, 0.01466703f, 0.02468648f, -0.04971483f, 0.02854015f, 0.01483412f, 0.02160819f, 
    -0.02262786f, 0.03167326f, -0.05288935f, -0.00641689f, 0.00061545f, -0.01573624f, -0.01022527f, 0.00468979f, 
    0.01153780f, -0.02444468f, 0.01146030f, 0.03240392f, -0.03730081f, 0.03232942f, 0.01228113f, 0.01048955f, 
    -0.00698871f, -0.00157850f, -0.01908738f, -0.02678299f, -0.03293142f, -0.01837737f, 0.02848626f, -0.03326692f, 
    -0.00161725f, -0.03433425f, -0.04512797f, -0.02560086f, -0.01054055f, 0.00163639f, -0.02645897f, -0.06136830f, 
    -0.04181578f, -0.03743100f, -0.05240994f, 0.00785907f, -0.02415101f, -0.00597851f, -0.01097939f, -0.04580369f, 
    -0.01604853f, 0.02718419f, -0.00660338f, 0.02406096f, 0.02482911f, 0.03794780f, 0.04045149f, -0.01612771f, 
    -0.00830869f, -0.02436752f, 0.02884863f, 0.03848968f, -0.04695021f, -0.03567734f, -0.00574174f, 0.03042298f, 
    -0.02374318f, 0.01912389f, -0.05085241f, -0.05975836f, -0.02406896f, 0.01827901f, 0.01546009f, 0.00842013f, 
    -0.01150256f, -0.04676146f, 0.01170781f, 0.01589720f, -0.02963290f, -0.03498213f, 0.01536451f, -0.01113043f, 
    0.01819064f, 0.02206980f, -0.02474338f, -0.03483108f, 0.03780334f, 0.04422807f, -0.00285222f, -0.03984896f, 
    0.00864752f, 0.03160109f, -0.02687388f, -0.05627093f, 0.01782079f, 0.00859040f, 0.01776224f, 0.03162241f, 
    -0.05326075f, 0.02851650f, -0.03147537f, -0.04822252f, -0.03794324f, 0.04092576f, -0.01239790f, -0.05669956f, 
    -0.03683900f, -0.01672602f, 0.03938095f, 0.00147349f, -0.05503798f, 0.03102615f, -0.01573385f, 0.02182342f, 
    -0.01308999f, 0.02645360f, -0.01619786f, 0.02052659f, 0.00731022f, -0.05506869f, -0.05853859f, -0.04878114f, 
    0.04012559f, -0.01102928f, 0.00229670f, 0.04016897f, 0.00901871f, -0.05085517f, 0.02705964f, -0.05750187f, 
    -0.05546442f, -0.02544982f, -0.04278660f, 0.02285459f, -0.03400585f, -0.02510297f, -0.04335377f, 0.03009187f, 
    -0.01521999f, 0.00400285f, -0.04099014f, -0.04944935f, -0.01764759f, -0.05305940f, 0.02050185f, 0.01053901f, 
    -0.01082155f, -0.00405453f, 0.02033062f, -0.03078416f, 0.03325138f, -0.01389788f, 0.03301160f, -0.00330829f, 
    -0.01981347f, -0.05484080f, -0.02732011f, -0.02008119f, -0.01640098f, -0.04841857f, -0.04191712f, -0.02793799f, 
    -0.00158159f, 0.01474729f, -0.01748119f, -0.05824201f, 0.03838732f, -0.04376522f, -0.03325976f, -0.03414871f, 
    -0.05426414f, 0.03117981f, 0.01601906f, -0.04587756f, 0.02592136f, -0.05579809f, -0.00342779f, 0.01979655f, 
    -0.02429334f, 0.00087566f, 0.02236074f, -0.00841074f, -0.05040941f, -0.00563598f, 0.02204218f, 0.02609648f, 
    -0.04669964f, 0.01628124f, -0.01537524f, 0.01683129f, -0.03057320f, -0.00014893f, 0.03449712f, -0.01722293f, 
    -0.00603278f, 0.00393269f, 0.00773440f, -0.04198162f, -0.03461237f, -0.05017804f, -0.04651243f, -0.01880024f, 
    -0.04925633f, 0.00168057f, -0.05856661f, -0.01278963f, -0.02823172f, -0.01300973f, -0.01881781f, -0.01533511f, 
    -0.00801763f, -0.05376918f, -0.04985180f, -0.04460904f, 0.02623710f, 0.04276294f, -0.03851189f, 0.01131780f, 
    0.02818306f, 0.03951151f, 0.02653567f, -0.04989673f, -0.04491735f, 0.01580501f, 0.00837557f, -0.05137293f, 
    -0.00190788f, -0.02050244f, -0.04714042f, -0.01813717f, 0.01579668f, -0.03088979f, -0.01917454f, 0.03817925f, 
    -0.00471763f, -0.03384674f, -0.04837039f, 0.03835358f, 0.03487537f, -0.01295219f, -0.04436354f, 0.03090031f, 
    -0.01997326f, 0.00490796f, 0.01845746f, -0.03249279f, 0.01539466f, 0.00135319f, -0.00134296f, -0.00914357f, 
    -0.00884922f, -0.02683032f, -0.02014053f, 0.03606174f, -0.03189506f, -0.05148634f, 0.02000768f, -0.04634033f, 
    -0.05983308f, 0.03017589f, 0.01893590f, -0.04733221f, -0.01785132f, -0.01969739f, -0.04006068f, -0.00273594f, 
    -0.03912865f, -0.02735353f, -0.04766700f, 0.03825283f, -0.00445312f, 0.02385649f, 0.03928105f, -0.00641079f, 
    0.03525288f, -0.00175677f, 0.03189756f, 0.00507058f, 0.00869052f, -0.00162979f, 0.02355695f, -0.00611969f, 
    0.00050453f, 0.01500854f, -0.01217154f, -0.05329509f, -0.00780598f, -0.04282606f, 0.02889993f, 0.01109161f, 
    0.00549898f, -0.03633643f, -0.03767836f, -0.01878133f, 0.04193085f, -0.01433784f, 0.01636611f, -0.01639545f, 
    0.00029951f, 0.02708968f, -0.05306341f, -0.04240382f, -0.01543827f, -0.00893292f, 0.01580286f, 0.02773516f, 
    0.03650662f, -0.03508692f, -0.04521801f, 0.01732780f, -0.01800103f, -0.05668505f, -0.04809637f, -0.00740068f, 
    -0.27025688f, 0.04386764f, 0.10089237f, 0.07424705f, -0.07893791f, 0.07585886f, 0.00498933f, -0.02054825f, 
    0.02691163f, 0.02380174f, 0.06923074f, 0.08008821f, 0.08650037f, -0.16573793f, 0.00332462f, -0.04843558f, 
    -0.02306417f, -0.15470187f, -0.06474598f, 0.01033304f, 0.01732513f, -0.01020842f, 0.03995486f, 0.01064944f, 
    -0.28628314f, -0.05762542f, -0.05575275f, 0.08106659f, 0.28147116f, 0.06864771f, 0.00956427f, 0.12595385f, 
    0.18468583f, 0.13542451f, -0.09328645f, -0.13880357f, -0.01769033f, 0.12433206f, 0.23769230f, 0.11047801f, 
    0.00018267f, 0.02653957f, -0.13030843f, -0.05236429f, 0.07711136f, 0.04738351f, 0.13358535f, 0.21938750f, 
    0.03864285f, 0.12462118f, 0.22842914f, -0.04040587f, -0.12538280f, -0.05444214f, -0.01859741f, -0.05989709f, 
    0.13469058f, -0.11331227f, -0.02154017f, -0.03510466f, 0.53090632f, 0.31155917f, 0.16865674f, -0.00855500f, 
    -0.02293537f, -0.08345453f, 0.04722663f, 0.08397681f, -0.03082564f, 0.13468677f, -0.06838372f, 0.03427901f, 
    -0.52053082f, 0.18128936f, -0.14633563f, -0.07731733f, 0.07713203f, 0.09559914f, -0.03653182f, 0.16126184f, 
    -0.06182493f, -0.02110214f, 0.02468554f, 0.08704550f, 0.00332126f, 0.11092311f, 0.01585117f, 0.17094263f, 
    0.01171915f, 0.04684143f, 0.13109268f, -0.01531228f, -0.08478703f, 0.06067747f, 0.02190984f, 0.05078524f, 
    -0.80976462f, 0.08365370f, -0.35974154f, -0.01083545f, 0.15914091f, 0.15190223f, -0.00368518f, 0.02836147f, 
    0.08376756f, -0.03253324f, 0.02612731f, 0.16566184f, -0.30534858f, -0.09702304f, 0.00955261f, 0.16594568f, 
    -0.13142264f, 0.08064085f, -0.05260412f, 0.09215896f, -0.11643944f, -0.11525051f, -0.10626886f, 0.00945735f, 
    -0.28802207f, 0.12748790f, -0.11437359f, -0.08488303f, 0.06105977f, -0.03719746f, -0.11437876f, 0.07258956f, 
    -0.08337895f, -0.10235158f, -0.03262482f, 0.01557128f, 0.22344369f, 0.05819010f, 0.19645607f, 0.09634498f, 
    -0.05998107f, -0.09445318f, -0.08601590f, 0.01754600f, 0.15442798f, 0.10021347f, 0.03237957f, -0.14174008f, 
    0.24090378f, 0.26753461f, -0.16653460f, 0.05016921f, -0.02285944f, 0.07778923f, 0.00126428f, -0.00299268f, 
    0.04071618f, 0.06735568f, 0.09380146f, 0.05629650f, -0.20127138f, 0.33203697f, 0.22319604f, -0.02884896f, 
    0.03185002f, 0.11923734f, -0.14041325f, 0.01833048f, -0.01330695f, -0.00460100f, 0.03242414f, 0.03048616f, 
    -0.11306072f, -0.26463002f, 0.07510651f, 0.25413701f, 0.00127945f, -0.03003592f, -0.00685612f, 0.01924493f, 
    0.03312928f, 0.00614953f, 0.04940938f, -0.08108684f, 0.18738164f, 0.03954799f, 0.31056181f, 0.14516392f, 
    -0.13270545f, -0.10464469f, -0.01554804f, -0.00802413f, 0.09581666f, -0.09573874f, -0.09599842f, 0.05693743f, 
    0.22368857f, 0.00085352f, -0.16183183f, -0.25953251f, -0.05866568f, 0.12805013f, -0.10221915f, 0.03701920f, 
    -0.02662808f, -0.02281956f, 0.03249945f, -0.04540546f, 0.05259724f, 0.05769788f, 0.07780673f, 0.09434286f, 
    -0.16030410f, 0.05283565f, 0.05054888f, 0.03881831f, 0.05484653f, 0.13874930f, -0.10445347f, 0.00644712f, 
    0.30263403f, -0.14486843f, 0.15167806f, 0.18931760f, 0.00290353f, -0.04492118f, 0.12421860f, 0.06164820f, 
    0.00690887f, 0.00184048f, 0.07445420f, 0.05107400f, 0.12242210f, 0.04314378f, 0.19870782f, 0.01807260f, 
    0.04454859f, -0.07936291f, -0.03874335f, -0.08570806f, 0.09532138f, -0.09789613f, -0.05260558f, 0.17196317f, 
    0.16426055f, -0.03457031f, 0.18682463f, -0.03467109f, -0.06449528f, -0.04672220f, -0.02863121f, 0.10124824f, 
    -0.03135702f, -0.08594418f, -0.07206655f, 0.01276194f, -0.10509287f, 0.09204707f, 0.13159430f, -0.15085496f, 
    0.05572392f, 0.13004255f, -0.07855389f, 0.05910968f, 0.04745146f, 0.00164619f, -0.05887192f, 0.19145480f, 
    0.21765818f, -0.06913932f, 0.08338211f, -0.10283262f, -0.02481446f, 0.02133299f, 0.09038258f, -0.00499551f, 
    0.05993365f, -0.00788771f, -0.01100654f, 0.03579802f, 0.13406345f, -0.37077683f, 0.00667466f, -0.12532614f, 
    0.11224967f, -0.03821798f, 0.08002079f, -0.01330688f, 0.00976194f, -0.08593889f, 0.07130852f, -0.08382550f, 
    -0.28894606f, -0.18535590f, -0.02804280f, -0.03507451f, 0.10090266f, 0.15325285f, 0.06666935f, 0.00431169f, 
    -0.09693826f, -0.16250968f, 0.08986916f, -0.13413993f, -0.17887923f, 0.12916450f, 0.04176930f, 0.12250508f, 
    0.04797199f, 0.10432521f, -0.03449639f, -0.05541569f, -0.00241687f, 0.22024368f, -0.03198975f, 0.09193569f, 
    0.01155357f, -0.25237074f, -0.33951285f, -0.03652875f, 0.11205668f, 0.08121195f, 0.01753056f, -0.08164173f, 
    -0.02552548f, -0.24096273f, -0.11598914f, 0.05836723f, -0.36632097f, -0.20278193f, -0.08382548f, -0.08849567f, 
    0.05811755f, 0.18255126f, 0.17256078f, 0.10815386f, 0.00896988f, 0.03362655f, -0.07130121f, 0.05748069f, 
    -0.02469717f, 0.03552776f, 0.30640039f, 0.35376534f, -0.14314818f, -0.09895911f, 0.12271570f, -0.04388367f, 
    0.00853547f, -0.12754633f, 0.12344930f, 0.15745823f, -0.47499675f, 0.18558182f, -0.09969699f, -0.15235756f, 
    0.06494058f, -0.01305706f, 0.10256676f, 0.09970035f, 0.11595143f, 0.00680673f, 0.05854948f, -0.03268431f, 
    0.15893190f, 0.15558034f, 0.40801853f, 0.08480968f, -0.02427086f, -0.15885793f, 0.02062593f, -0.05264207f, 
    0.05754652f, -0.06021043f, 0.13822366f, 0.09125897f, -0.00275070f, -0.31536931f, -0.03849083f, -0.14470544f, 
    0.03247593f, 0.00068310f, -0.05878300f, -0.09763234f, 0.01819467f, 0.09026179f, 0.04853744f, 0.04279485f, 
    0.06368529f, -0.12007020f, -0.05503404f, -0.05490242f, 0.14605144f, -0.05155380f, 0.03684907f, 0.00271049f, 
    0.08214369f, 0.05908396f, 0.08026090f, -0.22156574f, 0.47257295f, 0.11261511f, -0.05948890f, -0.12338813f, 
    -0.13825397f, 0.07402243f, 0.09232337f, 0.09218868f, 0.11111886f, -0.03892105f, -0.06365436f, -0.06005448f, 
    0.09677424f, -0.10761461f, 0.08114483f, 0.06552260f, 0.03027600f, 0.08629792f, 0.00268036f, 0.00784577f, 
    0.00584698f, -0.04446178f, 0.02223545f, 0.04077659f, -0.16237691f, -0.11237369f, 0.10886380f, 0.28419983f, 
    0.13401718f, 0.10217205f, -0.07025322f, 0.00890976f, -0.01541866f, 0.07278619f, -0.04241382f, 0.12709787f, 
    0.26091468f, -0.10769581f, -0.14140901f, -0.04826517f, -0.06537987f, 0.15837412f, 0.01230716f, -0.00879239f, 
    -0.05862014f, -0.00859468f, 0.18290350f, -0.03159403f, 0.10230535f, -0.02820120f, 0.07925965f, 0.11376366f, 
    0.20526877f, 0.17608818f, 0.13606553f, -0.06806229f, 0.05846193f, -0.06653205f, 0.19302200f, 0.03795946f, 
    -0.37856105f, 0.26504305f, -0.03395730f, -0.20266302f, 0.00535242f, -0.01862247f, -0.14577480f, 0.09548829f, 
    0.03093690f, -0.04220174f, -0.07289190f, -0.09038328f, -0.39066377f, 0.08002405f, 0.01006317f, -0.17073353f, 
    -0.23041381f, -0.07608158f, -0.04494981f, 0.15306807f, -0.02305441f, 0.15308936f, 0.03709733f, 0.07954784f, 
    -0.21798441f, 0.00164500f, -0.12152712f, 0.18225300f, 0.13575368f, -0.02262055f, -0.00614545f, 0.04005779f, 
    0.02506677f, -0.05078639f, -0.08992966f, -0.14674632f, 0.01667984f, -0.03378283f, -0.06330829f, 0.11981211f, 
    -0.14692515f, -0.12405859f, 0.10180073f, 0.09888077f, 0.04080006f, -0.06248074f, -0.06892289f, 0.09368536f, 
    -0.04997754f, 0.10289982f, -0.09647105f, -0.23682617f, -0.00588862f, 0.12685679f, -0.05949105f, -0.07641397f, 
    -0.05705485f, -0.00311548f, 0.00518090f, -0.03893272f, 0.07774395f, -0.08933815f, -0.19110611f, 0.22775008f, 
    -0.14618294f, -0.00309902f, 0.00428860f, -0.03641980f, -0.07807359f, 0.08452555f, -0.14897911f, -0.01347888f, 
    0.22010942f, 0.14478797f, 0.05379435f, -0.41026515f, 0.10960487f, 0.01624416f, 0.01649683f, -0.11619277f, 
    0.04358502f, -0.04042045f, -0.02475315f, 0.03364512f, 0.20086357f, -0.00738886f, -0.00319388f, 0.23193854f, 
    0.00134287f, 0.07776263f, -0.02090415f, 0.09722590f, 0.09000541f, -0.03295961f, -0.10974503f, -0.02339338f, 
    0.20801966f, -0.01146347f, -0.04412385f, 0.24077982f, -0.11615737f, 0.05408899f, -0.06401496f, 0.15696272f, 
    0.03674065f, 0.09782893f, -0.00012187f, -0.00821104f, 0.19806561f, -0.00072176f, -0.24578333f, 0.35910138f, 
    -0.01768426f, 0.04811502f, 0.16306946f, -0.02088135f, -0.05680689f, -0.06781824f, -0.14106554f, 0.05806927f, 
    -0.04284950f, 0.30811569f, 0.05323187f, 0.01167242f, -0.09613086f, -0.00316940f, -0.07396203f, 0.00618467f, 
    -0.11439449f, -0.06855772f, -0.05358962f, -0.02882788f, -0.10868070f, 0.08118796f, 0.24214706f, -0.29857078f, 
    0.25503322f, 0.13613480f, 0.11445976f, -0.11334909f, -0.00689347f, -0.08760808f, -0.00839512f, 0.00174953f, 
    0.04864885f, 0.02726743f, -0.18190277f, -0.13771306f, 0.19929524f, 0.06742148f, 0.07751651f, 0.05989757f, 
    0.13997392f, 0.07449709f, 0.01823849f, -0.04225229f, 0.10602701f, -0.10047967f, -0.15774812f, 0.24235463f, 
    0.16924553f, 0.10420647f, 0.05953791f, -0.05776699f, -0.02784425f, -0.06251175f, 0.08484551f, 0.02819489f, 
    0.32233837f, -0.07774059f, -0.01272735f, -0.07713779f, 0.11438526f, -0.01635716f, 0.04875600f, -0.09645245f, 
    0.03371843f, 0.13450015f, 0.04753656f, 0.03050936f, 0.07578304f, 0.08078991f, 0.01820118f, 0.26840490f, 
    0.08206232f, 0.16226935f, -0.04384863f, -0.01728296f, -0.04960806f, 0.01944874f, 0.13136768f, 0.03500326f, 
    0.00709283f, 0.08310154f, -0.06215240f, 0.10728756f, -0.06579008f, 0.00330456f, 0.02705367f, 0.13157135f, 
    -0.02095482f, -0.02479058f, 0.05755252f, -0.01727045f, -0.07680309f, 0.22125915f, -0.11271763f, 0.22885709f, 
    0.02755889f, -0.12880026f, -0.12877852f, 0.09315999f, -0.00647607f, 0.15066132f, 0.01125548f, 0.00299877f, 
    0.11089512f, -0.06301106f, -0.13085769f, 0.37927449f, 0.13843861f, -0.03090743f, 0.03499847f, 0.02335209f, 
    -0.05574439f, 0.16500297f, 0.02468809f, 0.03516826f, -0.21359102f, 0.45084733f, -0.02428663f, 0.01130174f, 
    0.04025590f, -0.07007211f, -0.04196715f, -0.03583190f, -0.10219982f, -0.07346138f, -0.03568818f, -0.04099357f, 
    0.07601300f, -0.18817680f, -0.10098835f, 0.45394239f, 0.00878019f, 0.06125790f, -0.25344843f, 0.01219668f, 
    -0.00216453f, -0.10421377f, 0.06747941f, -0.00071093f, -0.50029129f, 0.06060799f, 0.00719265f, -0.08107988f, 
    -0.03781595f, -0.01873509f, 0.06153394f, 0.10705727f, 0.05691740f, -0.18034883f, 0.05459802f, -0.01774117f, 
    0.21337730f, 0.11752287f, -0.06911424f, 0.10084387f, -0.05552423f, -0.07728612f, 0.09625532f, -0.10474784f, 
    0.06609488f, 0.03541748f, -0.04231621f, -0.01580395f, 0.28288695f, -0.11537141f, 0.10028757f, 0.07946333f, 
    0.00533536f, -0.01214551f, 0.01716598f, -0.10563599f, -0.10297379f, -0.00633217f, 0.06322426f, -0.10549290f, 
    0.17140232f, 0.03126897f, -0.11487137f, 0.40980923f, -0.08686216f, 0.00501635f, 0.10879494f, -0.06589513f, 
    -0.11195458f, -0.02571062f, 0.01827129f, 0.13458809f, 0.35844108f, -0.00145259f, 0.06762148f, -0.06288904f, 
    -0.23776509f, -0.10376629f, -0.01311608f, -0.08993385f, -0.01787570f, 0.04099463f, -0.14186449f, 0.02311161f, 
    0.02766841f, -0.02901267f, 0.02573743f, -0.00436623f, 0.04277337f, 0.01628970f, 0.02947018f, 0.02090191f, 
    0.02316290f, -0.02502012f, 0.00867359f, -0.00325747f, -0.00036576f, -0.00959210f, -0.01690316f, -0.01854304f, 
    0.04843963f, -0.04909078f, -0.03657480f, -0.02857579f, -0.04646226f, 0.02518264f, 0.01672604f, 0.02504138f, 
    0.01544865f, -0.03215415f, -0.03234424f, 0.00133742f, -0.04102119f, -0.00861315f, -0.03090258f, 0.00249841f, 
    -0.02089944f, 0.05386635f, -0.05517093f, 0.01721942f, 0.00123466f, -0.01167435f, -0.04723895f, 0.02273933f, 
    0.01415885f, -0.03803902f, 0.02851856f, 0.00377385f, -0.03318654f, 0.03605682f, -0.03717639f, -0.03837182f, 
    -0.01630526f, 0.03692067f, -0.01993486f, 0.03329519f, -0.03342243f, 0.02254413f, 0.00098622f, 0.03742635f, 
    0.03387448f, -0.05738483f, -0.02139957f, -0.03361392f, -0.02955331f, 0.05645286f, -0.04885749f, -0.04934512f, 
    -0.01559822f, -0.02607050f, -0.03707724f, -0.04422235f, 0.00081883f, 0.02546100f, -0.00016992f, 0.04495989f, 
    0.04212305f, -0.02507975f, 0.00173679f, -0.01002559f, -0.01150406f, 0.00855151f, -0.01282651f, 0.00091340f, 
    -0.02868593f, 0.02336712f, -0.03837027f, -0.04891014f, -0.02064858f, -0.04215895f, -0.05499952f, -0.00538169f, 
    0.00978284f, 0.02477011f, 0.01869703f, 0.02159146f, -0.02147265f, 0.03872550f, 0.03346212f, 0.03724531f, 
    -0.01154050f, 0.04793585f, 0.00830737f, 0.00089262f, -0.03380394f, -0.04602600f, -0.02937305f, -0.02763350f, 
    -0.01196426f, -0.04357805f, -0.01282404f, -0.05524816f, 0.03479610f, -0.00038565f, -0.04143674f, -0.04178989f, 
    0.03700877f, 0.01151907f, -0.02271333f, -0.03806501f, -0.03484667f, 0.00923339f, -0.05138050f, -0.02761837f, 
    -0.05665764f, 0.00494607f, 0.02175955f, -0.02182954f, -0.03696109f, -0.01498325f, -0.00553146f, 0.03662146f, 
    0.02687953f, 0.02433369f, -0.00411175f, -0.05136046f, 0.01344274f, -0.02369835f, 0.02367549f, -0.03400950f, 
    0.01960030f, -0.03438324f, -0.02202071f, -0.01218233f, -0.01398666f, -0.05386456f, -0.00677912f, -0.04862694f, 
    -0.03968903f, -0.04632862f, -0.04600152f, 0.04209726f, -0.02532402f, -0.01606505f, -0.03550684f, 0.01004596f, 
    -0.02634745f, 0.02555924f, -0.02555008f, 0.01742210f, 0.00266172f, 0.01851850f, -0.01307259f, 0.04367524f, 
    -0.03771406f, -0.02522438f, -0.00172653f, 0.01877115f, 0.00891016f, -0.00973460f, -0.02939365f, -0.05160097f, 
    0.00595697f, -0.05676553f, -0.03609164f, 0.01549995f, 0.01530312f, -0.05047148f, 0.00926812f, 0.05099862f, 
    -0.00050029f, 0.01676171f, 0.00539705f, -0.01805283f, 0.01193725f, -0.05208716f, -0.00435985f, 0.00453464f, 
    -0.01256530f, -0.05464629f, 0.00180722f, 0.03361632f, 0.01738724f, -0.00725610f, 0.03398176f, -0.05333051f, 
    -0.01306481f, 0.03564605f, -0.01118266f, -0.00992920f, -0.01163487f, -0.05690948f, -0.03732249f, 0.02071204f, 
    -0.04545858f, 0.03119785f, -0.02418618f, 0.03690033f, 0.03218538f, -0.02139183f, -0.04039782f, 0.04237828f, 
    0.02692478f, -0.03156922f, 0.01681142f, -0.05249848f, -0.03415705f, -0.03632840f, 0.00295187f, -0.04004886f, 
    0.00385820f, 0.00979614f, 0.01957298f, -0.00282883f, -0.04730555f, -0.00259355f, -0.02303740f, 0.01470977f, 
    -0.01805548f, -0.04469823f, -0.01156300f, -0.01026777f, 0.02190307f, -0.04463755f, 0.00365605f, 0.02575383f, 
    -0.00788963f, -0.01469965f, 0.00297546f, 0.02610431f, 0.01638309f, 0.01602396f, -0.02670030f, -0.04463978f, 
    -0.01031915f, 0.00490846f, -0.00589257f, 0.01917073f, 0.03995462f, -0.03280552f, -0.01389319f, -0.04313751f, 
    -0.02238305f, 0.01437981f, 0.00664913f, -0.00691200f, -0.00220733f, 0.03753605f, -0.02542830f, 0.05528262f, 
    0.04741751f, -0.04418344f, -0.04738580f, -0.02281288f, 0.04249924f, 0.01080316f, 0.02046599f, -0.03424785f, 
    0.00737047f, 0.03418488f, 0.02829968f, 0.04062092f, -0.02581452f, -0.01496263f, -0.05394295f, 0.03491116f, 
    0.01361816f, -0.01190957f, -0.00838403f, 0.02393971f, 0.03827190f, 0.01356167f, -0.04900537f, 0.01654124f, 
    -0.05550322f, 0.00438421f, -0.03756932f, -0.01447264f, 0.03907743f, 0.01116406f, 0.01953673f, -0.00423237f, 
    0.00075797f, -0.02315103f, -0.00653058f, -0.01041972f, -0.01070066f, -0.00943730f, -0.02213887f, 0.04246910f, 
    -0.02735177f, 0.04046328f, 0.01404413f, -0.00008639f, -0.01259327f, 0.00394352f, -0.03443968f, 0.00657958f, 
    0.03770527f, -0.05388086f, -0.04457753f, 0.02055090f, -0.04386035f, -0.03684649f, -0.03309327f, 0.05379253f, 
    0.03616211f, -0.00264341f, 0.01486108f, -0.05708208f, -0.00895132f, 0.00715485f, -0.00286342f, 0.03297556f, 
    -0.00523563f, 0.02660590f, 0.02469337f, 0.02503125f, -0.03867495f, -0.00924232f, -0.01677012f, 0.01866634f, 
    0.02795571f, -0.05698874f, -0.01938904f, 0.04272322f, -0.01504340f, 0.02144046f, 0.03481003f, -0.04901622f, 
    -0.04797233f, 0.04054109f, 0.00562673f, 0.02221801f, 0.03202795f, 0.02764108f, -0.01672382f, 0.00428365f, 
    -0.03604883f, -0.02794710f, 0.03879737f, 0.03260626f, 0.03410845f, 0.01927816f, 0.00957421f, -0.01900842f, 
    0.02158659f, 0.03578114f, 0.02209293f, -0.01653176f, -0.02153089f, -0.00126524f, -0.01681672f, -0.04008380f, 
    0.00460549f, -0.03766071f, -0.03448013f, -0.03367338f, -0.02084197f, 0.00853132f, 0.00938658f, -0.03421631f, 
    -0.03687717f, -0.01294100f, -0.01570614f, -0.01092193f, -0.00440473f, 0.03539483f, 0.03614745f, 0.02365451f, 
    -0.04390370f, 0.03221511f, 0.01765281f, 0.03948595f, -0.04219512f, -0.04539600f, 0.00561275f, -0.03002332f, 
    -0.30381885f, 0.03258174f, 0.18794769f, -0.02256137f, 0.01995381f, 0.00234696f, 0.01576163f, -0.02327797f, 
    0.02448430f, -0.06625409f, 0.17085254f, -0.22194740f, 0.12058695f, 0.30381349f, 0.01362243f, -0.02246204f, 
    0.09281314f, -0.18845519f, -0.06485936f, -0.01845418f, 0.14412425f, -0.00700981f, 0.23018825f, 0.15409973f, 
    0.11827695f, -0.02546902f, -0.12420216f, 0.16100544f, 0.26172471f, 0.25934964f, -0.09290069f, 0.01872496f, 
    0.25649175f, -0.18662037f, 0.09958632f, -0.17545523f, 0.06332107f, -0.05498813f, -0.30673489f, -0.20584880f, 
    -0.05529244f, -0.10213529f, 0.05070880f, 0.09912551f, -0.02997648f, 0.16269200f, 0.43257362f, 0.35986376f, 
    0.25020289f, 0.24228945f, -0.01647633f, 0.12350588f, 0.04455470f, 0.06698068f, 0.03019346f, -0.01782214f, 
    -0.13668692f, -0.19178559f, 0.14019553f, 0.02576328f, 0.07824723f, -0.01653958f, -0.02559838f, 0.20286272f, 
    0.13383542f, -0.03327294f, -0.06112264f, -0.10033561f, -0.13174783f, 0.13414189f, -0.01465158f, 0.06021732f, 
    0.01748018f, 0.25235128f, -0.10692573f, 0.12318005f, 0.07407108f, -0.06461102f, -0.06070085f, 0.26557288f, 
    0.04935989f, 0.13340262f, -0.12967603f, -0.11583754f, -0.20266955f, 0.01661518f, 0.02444868f, 0.13397588f, 
    -0.13246153f, 0.02789699f, -0.19181365f, 0.05034854f, -0.13188566f, -0.04507169f, -0.19829880f, -0.14002989f, 
    -0.04672760f, 0.32064852f, -0.34855002f, 0.11363692f, 0.08155558f, 0.03206227f, 0.03052411f, -0.12072451f, 
    0.15230918f, -0.09461907f, -0.13887471f, -0.11895103f, -0.02268268f, -0.09764790f, -0.00130531f, 0.28503668f, 
    -0.01381719f, -0.03405288f, 0.23058826f, 0.18118529f, -0.00911421f, 0.13699745f, -0.08374552f, 0.13648322f, 
    -0.14663222f, 0.15777411f, -0.16684748f, 0.30511194f, 0.06948942f, -0.05794857f, -0.15562192f, -0.00391257f, 
    -0.00089185f, -0.12439410f, 0.25976944f, -0.01150233f, 0.14478125f, 0.10987893f, 0.01471179f, -0.00600628f, 
    0.08170749f, 0.16184431f, -0.02805424f, 0.16985995f, -0.02544228f, 0.09352531f, -0.04026408f, 0.31756064f, 
    -0.22885694f, -0.03073730f, -0.00667578f, -0.08981203f, 0.03939762f, -0.06652093f, -0.14600703f, 0.09636124f, 
    0.04591789f, 0.25758591f, 0.18523020f, 0.11582496f, -0.18875726f, 0.15887082f, 0.13298480f, 0.09869646f, 
    0.08341135f, 0.09012688f, 0.15526237f, -0.18703587f, 0.15308236f, -0.01923301f, 0.01863936f, -0.01524760f, 
    0.06707605f, 0.07941598f, -0.06599274f, 0.10460240f, 0.06200942f, -0.10570092f, -0.09578552f, -0.14152522f, 
    -0.07284565f, -0.01090916f, -0.17241868f, -0.18590774f, 0.09753785f, -0.14076884f, 0.09621342f, 0.00848246f, 
    0.06308021f, -0.02265215f, 0.05773327f, 0.16271770f, 0.03092505f, -0.02569473f, 0.09493960f, 0.16765012f, 
    0.02074417f, 0.03280861f, 0.03501954f, -0.24292505f, -0.09216157f, 0.01739618f, 0.09271368f, -0.12324197f, 
    -0.12910171f, 0.08795855f, 0.07539627f, -0.05798781f, -0.28637680f, 0.08067006f, -0.15210772f, -0.13681948f, 
    0.16856788f, -0.12735085f, -0.18282413f, -0.04896688f, 0.18192557f, -0.05118962f, 0.20669033f, 0.05973343f, 
    0.35861450f, 0.08435895f, 0.00711818f, -0.05998174f, 0.02905114f, 0.07250443f, -0.03656956f, 0.09448483f, 
    0.19656557f, -0.04400558f, -0.03094245f, -0.19039880f, 0.00982537f, -0.04515744f, -0.10278405f, -0.19570193f, 
    0.18157719f, -0.16396897f, -0.08170896f, 0.09854466f, -0.17727186f, -0.16632989f, 0.17757794f, 0.06023448f, 
    0.06847743f, 0.10819113f, -0.00580081f, 0.13682225f, 0.07007319f, -0.03654828f, -0.18987586f, -0.27770701f, 
    0.12222002f, -0.08496729f, -0.16972657f, -0.13761558f, -0.11907678f, -0.02063176f, 0.00499260f, 0.03599162f, 
    0.04704667f, -0.01672447f, -0.20614080f, -0.09788185f, -0.12504886f, -0.23336358f, 0.31093568f, -0.07788596f, 
    0.16430643f, -0.38444170f, -0.07568353f, -0.03189999f, 0.04853684f, 0.11784519f, -0.07177513f, 0.06368097f, 
    0.22770615f, 0.02987264f, 0.06247636f, -0.01282596f, -0.04453009f, -0.03680293f, 0.18590491f, -0.20151755f, 
    0.09356198f, 0.12730736f, -0.05779220f, -0.02260487f, 0.21166316f, -0.08233367f, 0.13610777f, -0.04735614f, 
    0.04297585f, 0.02853823f, 0.01080665f, 0.03360944f, 0.17931688f, 0.23247072f, -0.18153693f, 0.12345425f, 
    -0.01161137f, -0.02465697f, -0.14284158f, -0.15553491f, 0.41562867f, 0.14804599f, 0.05274180f, -0.04521322f, 
    0.03652527f, -0.02777258f, -0.11481645f, -0.33352932f, -0.04680960f, 0.08387419f, -0.27646104f, -0.31809804f, 
    0.13678876f, -0.05876049f, 0.30721596f, 0.05974502f, 0.21231860f, 0.27563971f, -0.11104877f, 0.06643702f, 
    0.13886902f, -0.06551418f, 0.07966080f, 0.05194354f, -0.66445237f, -0.29343355f, -0.09269886f, 0.00779168f, 
    0.01547267f, -0.15327813f, 0.18349172f, 0.01668924f, 0.04983069f, 0.04783092f, 0.00439875f, -0.08065676f, 
    -0.04943800f, 0.11945106f, 0.05853514f, -0.06062170f, -0.02093305f, -0.08631817f, 0.02641257f, -0.07203828f, 
    -0.04668182f, 0.03362102f, 0.13230693f, 0.14788795f, 0.27805164f, 0.11718281f, -0.05713442f, -0.10624748f, 
    -0.03782812f, 0.05262592f, -0.04617066f, 0.06496526f, 0.04525764f, -0.14854191f, 0.28666633f, -0.09976982f, 
    -0.14817250f, 0.04148201f, 0.20416339f, 0.07224462f, -0.06081869f, 0.14550726f, 0.12550642f, -0.01408589f, 
    -0.10299477f, 0.10851818f, 0.01495882f, 0.30815551f, 0.61054528f, 0.30670848f, -0.05995898f, -0.24523652f, 
    -0.04024949f, 0.03278491f, 0.07192779f, -0.14198899f, 0.00991731f, 0.10494515f, -0.07915729f, 0.18987456f, 
    -0.24821991f, -0.15860674f, 0.15660556f, -0.28492805f, -0.18210940f, 0.02652745f, 0.09795236f, -0.04016697f, 
    -0.09482475f, 0.08126963f, -0.02886614f, 0.11221684f, -0.07740574f, -0.10219065f, -0.02562582f, -0.00582482f, 
    -0.09881856f, -0.03282335f, -0.03145733f, -0.19180048f, -0.10032038f, 0.04192996f, -0.09872787f, -0.00077516f, 
    -0.38763809f, 0.20043281f, 0.38550007f, 0.12962182f, 0.18282731f, -0.11112138f, 0.00071835f, 0.06458262f, 
    -0.09471048f, 0.15898767f, -0.02603464f, 0.06136376f, -0.15147017f, -0.04257479f, 0.00157344f, 0.15684192f, 
    -0.05172892f, 0.10059082f, -0.08408874f, 0.02020357f, 0.18329389f, -0.16165461f, -0.20073777f, 0.01007147f, 
    -0.06903234f, 0.04577171f, 0.22372912f, -0.22741291f, -0.12892628f, -0.05357340f, 0.11339682f, 0.09315824f, 
    0.07221010f, -0.03602927f, -0.09646948f, -0.09530332f, 0.28561568f, 0.15694405f, -0.20949833f, -0.00869930f, 
    0.00767150f, -0.07142810f, 0.17777351f, 0.17146593f, 0.07812636f, 0.01669982f, -0.15943164f, 0.04142741f, 
    -0.12597002f, 0.03547570f, -0.20708925f, 0.06508231f, -0.06868535f, 0.21530819f, -0.04373305f, -0.12199814f, 
    0.02345807f, -0.01628692f, -0.00389584f, 0.08188313f, 0.02041683f, 0.26021191f, -0.09995543f, 0.17305070f, 
    0.03361393f, 0.10404147f, 0.27385640f, -0.05564608f, 0.00380377f, 0.07329323f, -0.11488241f, 0.11239947f, 
    -0.13299195f, 0.15121363f, 0.10796747f, 0.19070262f, 0.04008619f, 0.08093398f, -0.18830134f, 0.13464439f, 
    0.06721186f, 0.04948912f, 0.10271992f, 0.17995475f, -0.25469208f, -0.00053312f, 0.16110902f, -0.23576204f, 
    -0.00373496f, 0.12105906f, -0.05188526f, 0.01064507f, 0.02132938f, -0.19668616f, 0.05671068f, -0.01781821f, 
    -0.22741523f, 0.15988953f, -0.20025115f, 0.09049432f, -0.00235220f, 0.08982466f, -0.01129387f, -0.03131148f, 
    -0.07371072f, -0.09006052f, -0.09631350f, -0.06531802f, 0.05321452f, 0.11005061f, 0.19101200f, 0.12915418f, 
    -0.24508269f, -0.09329607f, 0.06811489f, -0.04224903f, -0.00164478f, 0.07289891f, 0.00009584f, -0.16949110f, 
    0.12345836f, 0.23938911f, -0.27152872f, 0.15770605f, 0.15384746f, 0.14057679f, -0.03600570f, 0.05771493f, 
    -0.21917324f, 0.05612649f, -0.06008760f, -0.00485980f, -0.17627122f, 0.34521565f, 0.06931928f, -0.29612896f, 
    -0.03019878f, 0.01945630f, -0.12596166f, 0.11347635f, -0.11878324f, 0.04463136f, -0.00726647f, 0.01471014f, 
    0.16039041f, -0.13100107f, 0.33901924f, 0.06292441f, -0.02775049f, -0.01338179f, 0.13719702f, 0.11264654f, 
    0.00027123f, 0.00156073f, 0.05489894f, 0.13887690f, 0.04940275f, 0.06285296f, 0.10245565f, 0.01894765f, 
    -0.14242963f, 0.05428647f, -0.02260356f, -0.06003126f, 0.05864254f, -0.09074362f, -0.15299176f, -0.04808110f, 
    0.03991966f, -0.12240420f, -0.17557077f, 0.12451635f, 0.08093765f, 0.17947777f, -0.09397001f, -0.15236375f, 
    -0.06782020f, -0.05200852f, 0.00594922f, -0.11906337f, 0.16396530f, -0.08496150f, -0.08427628f, 0.21529561f, 
    -0.08609324f, 0.08661467f, 0.07410159f, 0.07883275f, -0.04102219f, 0.10268573f, -0.07219568f, -0.06092001f, 
    0.23434624f, 0.05212090f, 0.13615555f, 0.24777922f, 0.00917605f, 0.03036343f, 0.09611052f, -0.05303807f, 
    -0.07555523f, 0.05009832f, 0.11258342f, 0.11798816f, 0.00613587f, -0.15752403f, 0.12348931f, -0.13310552f, 
    -0.19208802f, -0.05800372f, -0.02528956f, 0.00048139f, 0.10293525f, 0.05517072f, -0.07986456f, -0.03738989f, 
    0.38932773f, -0.02728215f, 0.10993241f, 0.01373317f, -0.08915348f, 0.03838703f, 0.04772994f, 0.34401938f, 
    -0.12021343f, 0.05707644f, 0.02105165f, -0.17928419f, -0.19211687f, -0.03475774f, -0.13208099f, -0.05334380f, 
    0.01019049f, 0.10585480f, 0.09042085f, 0.07775444f, -0.02075503f, 0.11884671f, -0.13608472f, 0.01597941f, 
    0.35747805f, 0.02428918f, 0.11306268f, -0.29241323f, 0.01738638f, -0.00187260f, -0.04204622f, -0.03161329f, 
    -0.03538335f, 0.04250671f, 0.07822126f, -0.10999373f, 0.29322338f, -0.24076745f, -0.06092861f, 0.04819604f, 
    0.04508261f, 0.00789880f, 0.06676879f, 0.00641917f, -0.23602098f, 0.01584308f, 0.05845275f, 0.01915610f, 
    0.07874827f, -0.03919223f, 0.13698874f, 0.02008698f, -0.11264497f, -0.00707558f, 0.10104890f, 0.00214970f, 
    -0.02156195f, -0.03149824f, 0.00708357f, -0.03896378f, -0.11953398f, 0.00052722f, 0.09726577f, 0.15848221f, 
    0.02459554f, 0.07836403f, 0.11521694f, 0.09123883f, 0.09528107f, 0.04455609f, 0.10059239f, 0.18459567f, 
    0.10691334f, -0.02548483f, -0.19579320f, 0.01394991f, 0.06239121f, -0.09831159f, -0.00069132f, 0.12427192f, 
    0.00809353f, -0.01740025f, 0.11260714f, 0.02443101f, 0.36783031f, -0.09898578f, 0.02866956f, 0.07866019f, 
    0.08141254f, 0.07845949f, 0.00451967f, 0.02893367f, 0.04119943f, -0.02320764f, -0.05778140f, 0.07108597f, 
    -0.11878422f, 0.03095812f, 0.23984259f, -0.08198059f, 0.03745461f, 0.19508684f, 0.13942398f, 0.07402822f, 
    -0.09871253f, 0.02744198f, 0.00270155f, 0.00803803f, 0.25793180f, 0.03695923f, 0.11015252f, 0.12967247f, 
    -0.00047258f, -0.04148142f, 0.00420836f, -0.06070552f, 0.14391245f, 0.05334540f, -0.00304150f, -0.03265786f, 
    0.18892518f, 0.11232076f, 0.12678401f, -0.21075466f, 0.05504119f, -0.10245916f, 0.14505404f, 0.03780678f, 
    -0.04219704f, -0.00325013f, -0.03925980f, -0.16392824f, 0.01496560f, -0.26885810f, 0.19110456f, -0.26234147f, 
    -0.13485980f, -0.09925712f, -0.02507859f, 0.00048597f, -0.04316893f, -0.04865146f, 0.08470851f, 0.02792568f, 
    0.25737295f, 0.25011081f, -0.09603002f, 0.09047982f, 0.18895565f, -0.01458943f, -0.08679429f, -0.06844221f, 
    -0.04485321f, -0.00415092f, 0.21622445f, 0.06892584f, 0.58038181f, -0.17709230f, 0.05608056f, -0.24175072f, 
    0.01395214f, 0.03726908f, 0.02539334f, 0.05759342f, 0.02450960f, 0.06629311f, -0.05734788f, -0.06369431f, 
    -0.10043523f, -0.08835299f, 0.00616390f, 0.04074568f, -0.10843430f, 0.06428457f, -0.02601989f, -0.08212800f, 
    0.05710651f, 0.01268729f, -0.05197141f, 0.14796619f, -0.22560841f, 0.01492304f, 0.05736425f, -0.08198438f, 
    0.02013927f, 0.06182712f, 0.07511608f, -0.04553916f, 0.02954419f, 0.14273095f, 0.02829001f, -0.07561377f, 
    0.28273210f, -0.01858099f, 0.02499674f, -0.05467243f, 0.17662573f, 0.07406580f, -0.10720596f, 0.01958124f, 
    0.12747402f, 0.04537410f, 0.01930658f, 0.00653684f, 0.17237723f, 0.03968921f, 0.04151132f, 0.01581360f, 
    0.04625295f, 0.09664119f, 0.04518594f, 0.11886627f, 0.03994101f, 0.08219815f, 0.11605304f, -0.03583238f, 
    -0.25051546f, 0.10474250f, 0.08589409f, -0.24578853f, 0.06130701f, -0.11770773f, 0.04427904f, 0.08438563f, 
    -0.08641544f, -0.11689942f, 0.01581325f, 0.08241220f, 0.17179736f, -0.05825019f, 0.23745599f, -0.09563184f, 
    0.16215371f, -0.08253965f, -0.00866747f, 0.07509843f, 0.06959456f, 0.00967559f, 0.13683079f, 0.06520183f, 
    -0.59543020f, -0.23067185f, 0.15807611f, -0.05498664f, 0.07365065f, 0.00472755f, 0.07721553f, -0.07383011f, 
    -0.03375426f, -0.00271671f, -0.01430569f, 0.03201078f, 0.25776556f, 0.04823152f, -0.09940418f, 0.10514188f, 
    -0.02293083f, -0.07723007f, 0.08081006f, -0.02232635f, -0.07483514f, 0.02660975f, 0.05983412f, 0.05213663f, 
    0.03307723f, -0.17674807f, 0.21504278f, -0.16028248f, 0.04410530f, -0.04375036f, -0.01029616f, 0.04216901f, 
    0.01723612f, 0.05137691f, 0.04435888f, 0.03378863f, 0.10190070f, -0.12598862f, 0.00992082f, -0.16270976f, 
    0.11736891f, 0.08098945f, -0.04193284f, 0.03887039f, 0.04165509f, -0.05695980f, -0.04243742f, -0.18568054f, 
    -0.05588919f, 0.34547013f, 0.19438727f, -0.22905746f, -0.06979342f, 0.09039659f, 0.12253065f, -0.02105596f, 
    -0.00211647f, -0.15260889f, 0.01033601f, -0.08470651f, 0.28911889f, 0.08809488f, -0.06715473f, 0.01514101f, 
    0.00117120f, 0.14875084f, 0.09818348f, 0.12732153f, 0.01678692f, -0.03095064f, 0.07127823f, 0.07913228f, 
    -0.25410849f, 0.30446371f, -0.00792156f, 0.09261932f, -0.05917599f, 0.11642618f, -0.09772149f, 0.02011293f, 
    0.14706536f, 0.05688230f, 0.11777781f, 0.00245567f, 0.07536617f, -0.02269115f, 0.02440096f, -0.03190792f, 
    -0.00839862f, 0.06777788f, 0.00445255f, 0.06004035f, -0.01733973f, 0.08480865f, -0.03224524f, 0.01888953f, 
    0.12702048f, -0.04638415f, 0.08928180f, -0.08610272f, 0.09934065f, -0.01890759f, -0.04728172f, 0.24509585f, 
    0.13429274f, 0.01007076f, -0.03209993f, -0.02894942f, -0.13662764f, 0.29576766f, 0.05932593f, -0.10155289f, 
    0.04916963f, -0.00198951f, 0.07767662f, 0.06331956f, -0.02823652f, 0.00790113f, 0.02501382f, 0.01937819f, 
    0.00037366f, 0.03132959f, -0.00199652f, -0.10348848f, 0.05244429f, 0.04843470f, 0.06549099f, 0.04682465f, 
    -0.15114562f, -0.02659623f, 0.01406218f, -0.02422566f, -0.00553912f, -0.02675282f, 0.01739294f, -0.15374966f, 
    0.03605695f, 0.00881441f, 0.00282599f, 0.00307719f, 0.04660228f, 0.06161910f, -0.07642885f, 0.17113888f, 
    -0.31323764f, 0.15423295f, 0.01483205f, 0.12367354f, -0.00751812f, 0.07297715f, 0.04399161f, 0.03167924f, 
    -0.05927018f, -0.00473659f, 0.03565904f, 0.13440137f, 0.04914337f, -0.07051407f, 0.22281587f, -0.23629476f, 
    -0.08296090f, -0.08661167f, 0.07420920f, 0.06031001f, 0.21417880f, 0.16634357f, -0.06338632f, 0.10715062f, 
    -0.05149682f, -0.17973508f, 0.07083350f, 0.41079405f, -0.01408285f, -0.21740423f, 0.02540878f, -0.00018086f, 
    -0.06330281f, -0.01988650f, -0.10929441f, 0.14368784f, -0.00041253f, 0.17078429f, -0.30251831f, 0.06680043f, 
    -0.05613914f, -0.06839915f, -0.02187539f, 0.00857929f, 0.16626517f, 0.07098507f, -0.06981753f, 0.00188629f, 
    -0.30994907f, 0.08530796f, -0.11689635f, -0.06144228f, 0.04370623f, 0.11174639f, -0.08480855f, -0.02137231f, 
    0.05228884f, 0.03088107f, 0.10758223f, 0.09548361f, -0.44381088f, 0.02710098f, 0.03126871f, 0.09555834f, 
    0.03940223f, -0.04857194f, -0.06279130f, 0.01198038f, 0.06933119f, -0.01166344f, 0.15817523f, -0.00276169f, 
    -0.03485119f, 0.00798930f, -0.06801851f, 0.10550836f, -0.04631989f, 0.01257585f, 0.01995415f, -0.12192711f, 
    -0.10822414f, -0.04087493f, -0.06379860f, 0.07594822f, -0.19517858f, -0.06873300f, 0.19927815f, 0.04581716f, 
    -0.00603541f, 0.10000216f, -0.09579986f, -0.07400174f, 0.07320467f, -0.03796855f, 0.05332362f, -0.02879203f, 
    0.08796681f, 0.06842498f, -0.26240203f, 0.15903492f, -0.17355190f, -0.01969340f, -0.06465409f, -0.06514999f, 
    0.15488088f, -0.00834422f, 0.07308426f, -0.05196549f, -0.57464278f, 0.00242047f, 0.03605831f, -0.00621056f, 
    0.08414478f, -0.04654841f, 0.07787820f, -0.06062134f, 0.04374010f, 0.05731703f, 0.01482863f, 0.15429339f, 
    -0.03072102f, 0.16002131f, -0.13638844f, 0.01266597f, -0.01580129f, 0.09461001f, -0.08170600f, 0.06866413f, 
    0.02696940f, -0.09820857f, 0.06088555f, -0.09103363f, -0.07582697f, 0.24304235f, -0.04890136f, 0.36265889f, 
    0.07543740f, 0.10142561f, 0.00389232f, -0.10384198f, 0.17235677f, 0.08936617f, 0.02817676f, 0.04218353f, 
    -0.09800881f, -0.01265973f, 0.09690492f, -0.12545826f, -0.02447525f, -0.05821891f, -0.03352085f, -0.04323451f, 
    0.00359121f, 0.06881526f, 0.03103645f, -0.10658454f, 0.50030756f, -0.33354950f, 0.09886862f, -0.41795561f, 
    0.09618533f, 0.03035601f, 0.12548459f, -0.04748975f, -0.18161663f, 0.03934753f, -0.07037202f, 0.17310032f, 
    -0.27081698f, 0.35677159f, 0.39612055f, 0.28210038f, 0.21538979f, -0.00931746f, 0.07462890f, 0.17633168f, 
    -0.04119031f, -0.00519179f, -0.00490523f, 0.05461835f, -0.26824060f, 0.00879708f, 0.24062714f, 0.18208985f, 
    -0.03162965f, -0.06850209f, -0.03865718f, -0.06655160f, 0.15595829f, 0.07311402f, -0.14936647f, -0.09760348f, 
    -0.29408416f, -0.49129990f, 0.01338370f, -0.12748045f, -0.06780406f, 0.04355795f, -0.02354868f, -0.04525429f, 
    0.11056721f, -0.14150634f, 0.01092260f, 0.01123913f, -0.08411223f, -0.12805985f, -0.11169385f, 0.25285223f, 
    0.01403600f, 0.06701305f, 0.09127156f, -0.02376821f, -0.03574007f, -0.00858759f, 0.09866934f, -0.05094583f, 
    0.15355030f, 0.12126070f, -0.10967053f, -0.02232087f, -0.10040884f, 0.13995264f, -0.01709843f, 0.15107535f, 
    -0.01243757f, 0.14442602f, -0.02215152f, 0.12040027f, 0.08614766f, -0.05517159f, 0.18427767f, -0.23022382f, 
    -0.08225863f, -0.14970158f, 0.01135047f, -0.15343045f, -0.09495353f, 0.06822687f, 0.02327835f, 0.01545012f, 
    -0.27764535f, -0.11844451f, 0.30657187f, 0.17072187f, 0.14663666f, 0.05451572f, 0.01001590f, 0.09208884f, 
    -0.04619790f, 0.09588689f, -0.05325741f, -0.05332655f, 0.26451498f, 0.15022697f, -0.11360227f, 0.01214228f, 
    0.06299273f, 0.03429225f, 0.07756261f, -0.09010571f, -0.05786029f, -0.19340748f, -0.11828069f, 0.10916889f, 
    0.05651172f, -0.04214280f, 0.07904069f, -0.22184572f, 0.05929425f, 0.07351281f, -0.02294448f, -0.03920671f, 
    -0.07875151f, 0.09818127f, 0.04617262f, 0.13135287f, -0.29832134f, -0.18852766f, -0.12367430f, 0.24366258f, 
    -0.11060227f, -0.07891616f, -0.12434872f, -0.02610117f, -0.04322357f, 0.01872906f, -0.10153630f, -0.10707755f, 
    0.04959841f, 0.41347489f, -0.15096207f, -0.05155090f, -0.06591699f, 0.04568014f, 0.08970266f, 0.04560919f, 
    -0.07502838f, -0.20164475f, 0.12357067f, 0.05851667f, -0.19986473f, 0.23194222f, -0.08431543f, -0.10253034f, 
    -0.04531157f, -0.04570088f, -0.12784812f, 0.03710100f, -0.03338264f, -0.21425283f, 0.04441905f, 0.14073090f, 
    0.16910163f, 0.10288218f, 0.12710476f, 0.09295987f, -0.05178169f, 0.20173728f, 0.03608217f, 0.08202033f, 
    0.00443568f, 0.10744179f, 0.02758021f, 0.07365209f, -0.27740866f, -0.41427553f, -0.02663893f, 0.03944093f, 
    -0.07744509f, 0.15359093f, -0.01990819f, -0.11377156f, -0.04808881f, -0.07950073f, -0.16480900f, 0.08888455f, 
    0.41042343f, -0.02966518f, -0.16441371f, 0.06780699f, 0.06875262f, -0.01750858f, -0.00764192f, 0.06049671f, 
    -0.00262112f, 0.13034637f, -0.05496281f, 0.00836837f, -0.33534452f, 0.15095145f, -0.03185840f, -0.00868263f, 
    -0.04915314f, -0.09219427f, 0.07711529f, -0.07202399f, 0.01931627f, 0.00892306f, 0.04189207f, -0.01734111f, 
    0.07038193f, 0.03613493f, -0.15086633f, -0.04411910f, 0.13110200f, 0.14757265f, -0.06408790f, -0.16378471f, 
    0.01588300f, -0.00371137f, -0.05832012f, 0.10531364f, -0.14925419f, -0.03223806f, 0.22057042f, 0.05415514f, 
    -0.04141393f, 0.00987346f, -0.09238228f, -0.13730252f, 0.07796551f, 0.01928720f, 0.04710509f, -0.06308268f, 
    0.09564319f, 0.10596070f, -0.13527501f, 0.00662932f, -0.20950492f, -0.03211629f, -0.29611650f, -0.00815772f, 
    -0.09769646f, 0.04629864f, -0.05294415f, 0.02463010f, -0.40735111f, -0.04859764f, 0.04130844f, 0.08581030f, 
    0.16257404f, 0.07552778f, -0.07902116f, 0.14576681f, -0.01245693f, 0.15151824f, 0.07612820f, -0.07597528f, 
    0.10152568f, -0.07279360f, 0.10162941f, 0.03875900f, 0.08397637f, -0.05944196f, 0.00421288f, 0.04679166f, 
    0.08925759f, 0.05527457f, 0.02804979f, 0.08341647f, 0.19225021f, 0.15762208f, -0.17873938f, 0.39538452f, 
    -0.16895600f, 0.19649872f, -0.02723565f, 0.06801234f, -0.08406895f, 0.10280883f, -0.03756108f, -0.00811953f, 
    0.45700097f, -0.07663392f, 0.23464876f, 0.14595014f, 0.05693962f, 0.07781782f, 0.10756536f, 0.05120197f, 
    -0.11405671f, 0.04080830f, -0.06663761f, 0.01751796f, -0.06333684f, -0.08992831f, 0.13793297f, 0.04163840f, 
    0.08315741f, 0.06283922f, 0.07434616f, -0.01113290f, 0.12090546f, -0.00674889f, 0.11664832f, -0.01734849f, 
    0.20717834f, 0.02468475f, 0.05775611f, 0.33921051f, 0.05688078f, 0.12002791f, -0.07500181f, 0.10333110f, 
    0.08373829f, 0.02591523f, 0.12902944f, 0.06703529f, -0.48384899f, 0.12091202f, 0.18085885f, 0.16663463f, 
    0.19950573f, -0.06389607f, 0.13521139f, 0.04045330f, 0.11007595f, -0.12061209f, 0.00629502f, -0.01756947f, 
    0.30804318f, -0.08820961f, 0.05579852f, 0.09199186f, -0.23110393f, 0.20257214f, 0.04760842f, 0.03082727f, 
    0.13443932f, 0.02018064f, -0.11398068f, -0.05644084f, -0.03485113f, -0.16240641f, 0.15355504f, 0.03213306f, 
    -0.10577007f, -0.01767910f, 0.06945243f, -0.06417911f, 0.00881405f, 0.14007685f, -0.03565958f, -0.11849137f, 
    0.12714455f, -0.05308821f, -0.17973267f, 0.09100445f, -0.07410097f, 0.11900216f, -0.09391136f, -0.01211314f, 
    -0.20821367f, -0.08603223f, -0.07898938f, -0.08223622f, 0.12288231f, -0.05623813f, -0.01263267f, 0.02190226f, 
    -0.09816550f, 0.05359041f, -0.06228993f, -0.07977376f, 0.10657125f, 0.05967213f, -0.01441653f, 0.13854547f, 
    0.03036194f, 0.03939842f, -0.04599158f, 0.02874724f, -0.01222586f, -0.00287113f, 0.00909456f, -0.02757141f, 
    -0.00752037f, -0.04092938f, -0.02154937f, 0.04360275f, 0.01875663f, -0.01665421f, 0.00396216f, -0.03775842f, 
    0.04445694f, -0.04627190f, 0.00770768f, 0.04784043f, 0.01407114f, -0.01901119f, -0.02437264f, -0.01393859f, 
    0.03032135f, 0.01524379f, -0.02019951f, -0.02517186f, 0.00434305f, 0.00064908f, 0.02378341f, 0.00739179f, 
    -0.00727780f, 0.02011754f, 0.00373677f, -0.04825715f, -0.04489007f, -0.03363167f, -0.01382361f, 0.02472679f, 
    -0.01003760f, -0.04231005f, 0.02864181f, -0.00057275f, -0.00425840f, 0.01593483f, 0.03113118f, 0.04923254f, 
    0.03111781f, 0.01911286f, 0.04823665f, -0.04609226f, 0.00471149f, -0.00424278f, 0.04680899f, -0.03911265f, 
    -0.04408171f, 0.01994580f, -0.01199608f, -0.03474811f, 0.04612694f, -0.00277957f, 0.01757995f, 0.04188360f, 
    0.00866869f, 0.01018762f, -0.04768232f, -0.03426644f, -0.03833885f, -0.00622521f, -0.02653621f, -0.03931685f, 
    0.03927097f, -0.00612309f, 0.00558971f, 0.03260794f, -0.02329751f, 0.02818510f, -0.01547773f, 0.03841170f, 
    0.03717902f, 0.00936411f, -0.02014173f, -0.01036485f, -0.03493931f, -0.03263086f, -0.01782256f, -0.01606481f, 
    -0.01076994f, -0.00735103f, -0.01675390f, -0.00112857f, 0.03494972f, -0.02687501f, -0.03625504f, -0.01027679f, 
    0.02421570f, -0.04154749f, 0.02056850f, -0.02804921f, 0.01958930f, 0.03035093f, -0.01880383f, -0.01933878f, 
    -0.02398380f, -0.00959636f, 0.01926333f, 0.03836608f, 0.01157299f, 0.02317352f, 0.01808366f, 0.03441004f, 
    -0.01929115f, 0.02425825f, -0.04493247f, -0.03645645f, 0.00526507f, -0.05099399f, 0.03933749f, -0.03740503f, 
    -0.03305598f, -0.02857377f, 0.01324145f, -0.02945715f, -0.02522405f, 0.04531363f, 0.01026684f, -0.03981116f, 
    -0.03325423f, -0.00148269f, -0.02952492f, 0.00616580f, 0.02740593f, -0.04249812f, 0.03917723f, -0.02516386f, 
    -0.03714541f, 0.01204291f, -0.02850178f, -0.03868334f, 0.04175945f, -0.03218205f, -0.01877913f, -0.02745258f, 
    0.00306814f, 0.03019568f, 0.01778523f, -0.05096449f, -0.01698988f, 0.03209547f, 0.02870952f, -0.03163408f, 
    -0.00736252f, -0.02076024f, -0.02707957f, 0.02755111f, 0.02933113f, -0.05048443f, 0.04787859f, -0.04660472f, 
    0.01802520f, 0.00204779f, -0.00546856f, 0.03211727f, 0.04846965f, 0.02671390f, -0.04275911f, -0.02390328f, 
    0.00957629f, -0.03022745f, 0.00783978f, -0.00774623f, 0.00599177f, 0.01127262f, 0.02819020f, -0.03022661f, 
    -0.03114148f, 0.03628791f, 0.04320147f, -0.02940341f, 0.01944022f, -0.00540833f, 0.00175070f, -0.02315647f, 
    -0.01965278f, -0.03573551f, 0.00538525f, 0.03714903f, -0.05042768f, -0.00144537f, -0.00593559f, -0.03207022f, 
    0.00836456f, -0.01922007f, -0.03097543f, 0.00143137f, 0.01556420f, -0.04384438f, -0.01120528f, 0.02269978f, 
    0.00951129f, -0.01106810f, -0.04850630f, -0.03500480f, 0.02493299f, -0.02579197f, -0.01481040f, -0.02039015f, 
    -0.03524996f, 0.01663045f, 0.00651927f, -0.03467833f, -0.01407106f, 0.02269617f, 0.03848108f, -0.01676296f, 
    0.00936508f, -0.04250019f, 0.00733477f, -0.01450843f, 0.03526813f, -0.01519563f, -0.02320226f, 0.03572423f, 
    -0.00339626f, 0.00697853f, -0.01768121f, -0.00737904f, 0.03666212f, 0.01422487f, 0.00384877f, 0.02899609f, 
    0.04387404f, -0.01205131f, 0.01596416f, 0.01706862f, -0.04246487f, -0.00300175f, -0.04839079f, -0.00475711f, 
    0.04371359f, 0.01686180f, -0.02209966f, 0.03394221f, 0.01822428f, 0.02115706f, -0.01029412f, 0.00376578f, 
    -0.00500339f, -0.03958796f, -0.01702831f, 0.01462664f, -0.04161990f, -0.03771421f, -0.03405295f, -0.04535254f, 
    -0.04368423f, 0.03961869f, 0.02980685f, -0.01672485f, 0.04044171f, -0.00781243f, -0.00097316f, -0.00554100f, 
    0.01274287f, -0.03286594f, -0.02749089f, -0.00839958f, 0.00928777f, -0.02973719f, 0.02144314f, -0.03366500f, 
    -0.00362986f, -0.00486468f, 0.04777705f, -0.04184620f, -0.00881926f, 0.01008716f, -0.03219777f, 0.00241058f, 
    0.03820614f, -0.04410633f, -0.02465513f, -0.03861907f, -0.03087865f, -0.00478867f, 0.03083379f, -0.01310561f, 
    0.00028616f, 0.03535305f, -0.04286676f, -0.01428804f, -0.00603635f, -0.02374107f, -0.00963371f, 0.02736021f, 
    -0.03913992f, -0.03883757f, 0.02766523f, -0.02002769f, 0.03926540f, -0.04805188f, 0.00339899f, -0.03573915f, 
    -0.03536822f, 0.03647847f, -0.02197790f, 0.00625299f, -0.00751869f, 0.02009215f, -0.01380102f, -0.01143633f, 
    -0.02878283f, 0.00157206f, -0.01420246f, 0.04320874f, -0.04388501f, -0.02946102f, -0.02897637f, 0.00296219f, 
    0.03920374f, 0.02622052f, 0.01003039f, -0.00975428f, -0.03872541f, -0.00296572f, 0.01563612f, -0.01629559f, 
    -0.01114277f, 0.00917482f, 0.02448043f, 0.03376186f, 0.00807970f, -0.01548716f, -0.01803745f, 0.01401554f, 
    -0.01605848f, -0.02056511f, -0.04178382f, -0.04451512f, -0.02564858f, -0.04246851f, 0.00945674f, 0.00896531f, 
    0.04727479f, -0.01387734f, -0.02276643f, 0.02313530f, 0.01313826f, -0.04772841f, -0.03865706f, -0.00295043f, 
    -0.02314297f, -0.01683123f, 0.01390075f, -0.00147642f, -0.00412551f, -0.01707206f, -0.03018199f, -0.02885118f, 
    0.02973519f, 0.03533407f, 0.00885826f, -0.04265867f, -0.00769286f, 0.03051049f, -0.02739633f, 0.00457577f, 
    0.03024333f, -0.02833206f, 0.02374410f, -0.00157649f, -0.01037423f, -0.01231846f, -0.00652285f, 0.04197681f, 
    -0.04120674f, -0.04067658f, -0.02836402f, -0.03871089f, 0.00772488f, 0.03735166f, -0.02821459f, 0.04543710f, 
    0.08855223f, 0.04437430f, 0.30483916f, 0.14184763f, 0.11152573f, 0.05065050f, 0.02075604f, -0.02347969f, 
    0.09665987f, -0.11308835f, -0.11534903f, 0.02337747f, -0.13486911f, 0.41703039f, 0.08332001f, 0.40731853f, 
    -0.01013459f, 0.14892916f, 0.04589024f, 0.07775985f, -0.00241664f, 0.02796656f, 0.10086013f, -0.06815795f, 
    0.05847701f, -0.19570051f, -0.20867412f, -0.06919275f, -0.12401925f, 0.10689665f, 0.00141554f, -0.16065021f, 
    -0.01531186f, 0.03671044f, 0.01108737f, 0.09120265f, 0.33523342f, 0.28118005f, -0.09280552f, -0.02240195f, 
    0.08692666f, -0.02880459f, 0.05282064f, 0.07360211f, -0.09375993f, -0.08657293f, -0.11178830f, -0.13839881f, 
    0.14079945f, 0.27772617f, 0.22616568f, 0.15165941f, 0.11639692f, 0.05142547f, 0.02641770f, -0.00212733f, 
    -0.08875439f, 0.07795765f, -0.06061362f, 0.03346361f, -0.24630092f, 0.03437914f, -0.11323670f, -0.42228678f, 
    -0.13893759f, -0.00074740f, -0.06627053f, 0.03614303f, 0.06521320f, -0.12012526f, -0.11512823f, 0.01868789f, 
    0.32657954f, -0.04736502f, 0.01382808f, 0.12721455f, 0.21901122f, 0.03443255f, 0.06949580f, -0.13424480f, 
    -0.02346243f, -0.00062385f, 0.20887385f, -0.03723722f, 0.04564982f, 0.16300909f, -0.09467787f, -0.10753145f, 
    0.00958676f, 0.01510443f, -0.01437748f, 0.04770014f, 0.18048979f, 0.07793874f, -0.09128773f, 0.19184995f, 
    0.42538196f, 0.17047668f, -0.08170073f, -0.22002457f, 0.04232351f, -0.03203327f, 0.02280052f, 0.07476103f, 
    0.04664194f, 0.03344473f, 0.12650298f, -0.00631902f, -0.09030835f, 0.04693975f, 0.14789413f, 0.03533902f, 
    0.13671625f, -0.11522786f, -0.00264020f, -0.05794552f, 0.04121644f, 0.16694339f, 0.17229611f, -0.02775653f, 
    -0.01095290f, 0.02714332f, 0.01221248f, 0.15032946f, 0.06000768f, 0.04872464f, 0.11204839f, 0.04467740f, 
    0.13165891f, 0.08141559f, 0.04169101f, -0.05777174f, 0.00407711f, 0.18366671f, 0.00617702f, -0.39601392f, 
    0.10008159f, 0.01213182f, -0.01325743f, -0.00790614f, -0.05301776f, -0.00479531f, 0.01459620f, 0.15958577f, 
    -0.46541309f, 0.02606658f, 0.06105839f, 0.06008853f, 0.22123970f, -0.07918579f, -0.03719878f, 0.04668137f, 
    0.09924044f, -0.00358611f, -0.13285260f, 0.14473929f, 0.10715450f, -0.04449757f, -0.08223738f, -0.14183754f, 
    0.20866250f, -0.02273471f, -0.00179464f, -0.01103387f, 0.04827560f, 0.09397091f, 0.08093202f, 0.01327318f, 
    -0.26423126f, -0.11705854f, -0.13581419f, -0.11176054f, 0.14374505f, 0.03029633f, 0.09476824f, 0.07934046f, 
    -0.09284594f, -0.08752255f, 0.01122825f, 0.09910302f, 0.13045198f, 0.20900702f, 0.07350633f, -0.24106124f, 
    -0.06847664f, 0.09441753f, -0.07647960f, 0.01261593f, -0.02468282f, -0.00626420f, 0.11729653f, 0.02319874f, 
    -0.25349048f, 0.01485552f, 0.04018863f, 0.18609951f, -0.02488839f, -0.03197388f, 0.11534932f, 0.10164516f, 
    0.03642032f, -0.06590670f, -0.01956666f, 0.06116369f, -0.24776773f, 0.06877273f, -0.01960213f, -0.08881504f, 
    0.15178269f, -0.11933021f, -0.00128947f, 0.06141422f, -0.04315910f, 0.12182462f, -0.02910926f, 0.12634340f, 
    -0.26400033f, 0.16328019f, -0.00546990f, -0.22306074f, 0.04092871f, -0.04632401f, -0.08237778f, 0.02706211f, 
    -0.07198517f, 0.08701720f, 0.14846824f, 0.06073863f, 0.29573822f, 0.16316107f, 0.02087434f, -0.24928476f, 
    0.00363700f, -0.03178724f, 0.10906868f, 0.02175719f, -0.00746463f, 0.16702507f, 0.02352514f, 0.00668193f, 
    -0.48563567f, 0.15044795f, -0.06654866f, -0.12279382f, 0.09006020f, -0.02307795f, 0.08538337f, 0.01047779f, 
    0.20702966f, 0.06903365f, 0.23254338f, 0.07085416f, 0.39261839f, 0.25574103f, 0.07446577f, -0.05133377f, 
    -0.16807865f, -0.14413017f, 0.11843300f, 0.03636743f, 0.06723134f, 0.09564743f, 0.04572991f, 0.05823025f, 
    0.03042494f, -0.20682096f, 0.11936493f, 0.02178569f, 0.00608196f, 0.01652499f, -0.05175193f, 0.06158880f, 
    -0.10064026f, 0.09020972f, 0.04915619f, 0.00270226f, -0.11716083f, 0.15041518f, -0.07565968f, 0.13219988f, 
    0.03483041f, 0.01126939f, 0.04295874f, -0.01045839f, 0.07054515f, 0.02784167f, 0.03384335f, 0.01278835f, 
    -0.21044819f, 0.00808750f, -0.29365104f, -0.11959120f, -0.01858455f, -0.00084128f, 0.04677601f, -0.05295808f, 
    0.17168982f, 0.14292580f, 0.14890940f, 0.08149586f, 0.10988595f, -0.10846957f, -0.08590829f, -0.19254778f, 
    -0.01924445f, 0.04436982f, -0.04457694f, 0.14220949f, 0.09178128f, -0.11869794f, 0.06456622f, 0.04220541f, 
    0.02831487f, -0.00796994f, -0.06997838f, -0.12592489f, 0.01193090f, -0.04788763f, 0.03920233f, 0.06179882f, 
    0.02307476f, 0.06411522f, -0.08673675f, 0.06631359f, 0.49905464f, -0.20426577f, -0.06348748f, 0.07171682f, 
    -0.12622535f, 0.08276667f, -0.01413025f, 0.01531398f, 0.04602748f, 0.15174226f, -0.00671367f, 0.06587402f, 
    -0.14616187f, 0.14349371f, 0.18246111f, -0.13928026f, 0.18598828f, -0.00275899f, -0.11483871f, -0.00414097f, 
    -0.00230823f, -0.15210268f, -0.11963063f, 0.02130193f, 0.08021738f, -0.08081536f, -0.30341727f, 0.06339163f, 
    0.14441183f, -0.00642723f, 0.13766418f, 0.12153698f, -0.05041228f, 0.13130881f, -0.09442630f, 0.02146906f, 
    -0.01482420f, 0.01424659f, 0.03166565f, -0.23938283f, 0.15615799f, -0.11417770f, -0.03071917f, 0.00187265f, 
    -0.04364953f, -0.11524396f, -0.12547500f, -0.08600279f, -0.23663341f, 0.06574646f, 0.19290975f, 0.20177579f, 
    0.19137228f, 0.07158510f, 0.22232185f, 0.14599179f, 0.03902425f, -0.12092027f, 0.01683526f, -0.10133717f, 
    -0.01468469f, 0.00732465f, -0.00757426f, -0.03994790f, 0.04467966f, 0.01840537f, 0.01190752f, -0.03301809f, 
    0.03093775f, -0.01967629f, 0.01675123f, -0.04977005f, 0.00964085f, 0.01861630f, 0.04665859f, 0.03415261f, 
    -0.05386521f, -0.04416613f, -0.02692063f, 0.00063728f, 0.03551112f, 0.02602474f, 0.02593326f, -0.01252369f, 
    -0.03337397f, 0.02436093f, -0.02364137f, 0.04264042f, 0.04235145f, -0.03523497f, 0.01622559f, -0.03626915f, 
    0.01269399f, -0.03956354f, 0.03515771f, 0.00941002f, -0.00604875f, -0.02029252f, 0.01525804f, -0.00780134f, 
    -0.00697695f, -0.02186588f, 0.05609923f, -0.00292314f, 0.03344800f, -0.04680634f, 0.01540896f, 0.01823464f, 
    -0.04357751f, -0.02689452f, 0.03631231f, 0.00803811f, 0.01471936f, 0.03298496f, 0.04839510f, -0.05676671f, 
    0.00113346f, -0.02232026f, 0.00466068f, -0.00665214f, 0.02395097f, -0.00690024f, -0.00941732f, 0.02414905f, 
    -0.01030778f, 0.01536273f, 0.04039985f, 0.03030821f, -0.01976082f, -0.02311228f, -0.01609825f, 0.04495220f, 
    0.01017630f, -0.01518446f, 0.00727558f, 0.04093651f, 0.01917263f, 0.04273586f, 0.02370499f, -0.01563864f, 
    0.03816082f, -0.00376988f, -0.05741543f, -0.00659596f, 0.02545985f, 0.00124841f, -0.05080219f, -0.02149453f, 
    0.02533135f, 0.01987202f, 0.00091916f, -0.04028297f, 0.02294731f, 0.03678718f, -0.03661931f, 0.03785655f, 
    -0.01379954f, 0.04090879f, -0.02303688f, 0.05246648f, -0.03874527f, 0.02422834f, 0.03392817f, -0.00577679f, 
    -0.02387866f, -0.03720514f, -0.00474752f, 0.01331045f, 0.03032945f, 0.01762958f, -0.04854543f, -0.02577174f, 
    -0.01328711f, 0.00690529f, -0.03239494f, -0.03222789f, -0.00670848f, 0.03532855f, 0.04365577f, -0.00934700f, 
    0.02247808f, -0.02453757f, 0.00743039f, -0.01608182f, 0.00431528f, 0.00880032f, 0.03244153f, 0.04601296f, 
    0.01232585f, 0.01225688f, -0.01613162f, -0.02740726f, -0.05123066f, 0.00238406f, 0.01597083f, -0.05377916f, 
    0.03705894f, -0.01106859f, -0.04462859f, 0.02454176f, 0.04583884f, -0.03200385f, -0.05904920f, -0.03562845f, 
    -0.04715519f, -0.01257840f, 0.01534364f, -0.02500874f, 0.03487652f, 0.03565655f, 0.00755505f, 0.01448786f, 
    -0.04475231f, 0.03084436f, 0.01596008f, 0.02899022f, -0.05143562f, 0.02447761f, 0.02920792f, -0.02500135f, 
    -0.00375577f, 0.02688709f, 0.01893670f, -0.02503705f, 0.00867473f, 0.00617557f, -0.01856632f, 0.00994464f, 
    0.03908524f, -0.03244870f, -0.03918089f, 0.04101669f, -0.05045965f, -0.02747633f, 0.00728179f, -0.03129253f, 
    0.01160816f, 0.04010900f, 0.04025984f, -0.00008200f, 0.02074171f, -0.02413270f, -0.04252263f, 0.00346601f, 
    0.01538238f, 0.02611448f, -0.01524650f, -0.04769864f, -0.02227556f, -0.03185936f, 0.01837951f, -0.01512481f, 
    -0.01607796f, -0.01784540f, -0.05445831f, 0.03608635f, -0.01538261f, -0.01857409f, -0.00420064f, -0.04571921f, 
    -0.03344803f, -0.01576309f, 0.03013067f, -0.05515663f, -0.03814489f, -0.03772998f, -0.03707037f, -0.02278107f, 
    -0.00437231f, 0.00779066f, 0.02716951f, 0.00381490f, -0.03745805f, -0.04460592f, -0.01794067f, -0.05098158f, 
    0.01638557f, 0.04560794f, -0.00629875f, 0.02873749f, -0.01753566f, -0.01587147f, 0.00201219f, -0.03393206f, 
    -0.04448670f, 0.02118799f, -0.00801063f, 0.00997969f, -0.02543975f, -0.03707117f, 0.04138870f, 0.01846912f, 
    -0.01854532f, -0.02060428f, -0.01872596f, 0.04667481f, -0.04169928f, -0.05622974f, -0.05545588f, -0.01177574f, 
    -0.03022509f, -0.04327437f, 0.02500976f, -0.02103798f, -0.05025309f, 0.02272028f, -0.03740066f, 0.03452352f, 
    -0.03385677f, -0.01097291f, -0.02019563f, 0.02210753f, -0.04431669f, 0.05128975f, 0.03339064f, 0.03050375f, 
    0.01086035f, -0.03679625f, 0.01003914f, -0.01535331f, -0.04738833f, -0.03193634f, 0.02052559f, 0.00492824f, 
    -0.00864846f, -0.04495313f, 0.01544874f, 0.03407471f, 0.01814510f, -0.03432958f, -0.04256850f, -0.03854454f, 
    0.02561782f, -0.00330496f, 0.01219410f, -0.04628560f, -0.01697567f, -0.00634979f, -0.03907366f, 0.02376018f, 
    0.02560269f, 0.01069221f, 0.00165013f, -0.03843245f, 0.00330343f, 0.01322975f, 0.00195093f, -0.02640301f, 
    -0.01340138f, 0.04217551f, 0.04760730f, 0.00877481f, -0.00198964f, 0.03042672f, 0.01492749f, 0.00763506f, 
    0.04090223f, -0.01685046f, -0.04278857f, 0.02977238f, 0.01230082f, -0.04445671f, -0.02481230f, -0.03839952f, 
    -0.01643471f, -0.02609090f, -0.02434989f, -0.04195949f, -0.00743984f, -0.04830810f, 0.01522560f, 0.02630026f, 
    -0.01591126f, 0.00862248f, -0.04999807f, -0.04540379f, -0.01877071f, -0.01200697f, -0.04036364f, 0.00306564f, 
    -0.00284365f, -0.03321826f, -0.04044198f, 0.02748176f, -0.05056673f, 0.04275748f, -0.05078616f, 0.00013965f, 
    0.05482966f, 0.03733674f, -0.01764120f, 0.01760345f, 0.04321560f, 0.04100227f, -0.01814786f, 0.03381550f, 
    -0.04369774f, -0.01406735f, 0.01229292f, -0.01647178f, -0.00336035f, -0.02150204f, 0.01244310f, 0.01194773f, 
    -0.03625005f, -0.01971163f, -0.03783249f, 0.04440614f, -0.03735983f, -0.01171763f, -0.03301063f, -0.00356885f, 
    -0.03103319f, 0.01347526f, -0.05503647f, -0.01589008f, -0.00337420f, -0.02805946f, -0.00112535f, 0.02096600f, 
    0.02091400f, 0.01433501f, -0.04825844f, 0.02553874f, -0.00958404f, 0.03995075f, -0.00796708f, -0.04201402f, 
    -0.01250788f, 0.01470241f, -0.05409003f, -0.03247117f, -0.03638048f, -0.01614821f, -0.03063605f, 0.04283423f, 
    -0.05398105f, -0.02239097f, 0.02854752f, -0.01336539f, 0.03638788f, 0.02781928f, -0.02773718f, -0.00610551f, 
    -0.19164009f, -0.18042129f, 0.10286262f, -0.44092911f, 0.04907627f, 0.05849887f, 0.15345724f, -0.06647084f, 
    0.00415773f, 0.02869117f, -0.04569659f, -0.11919414f, -0.03979949f, 0.25324872f, 0.07272291f, 0.18659461f, 
    0.01890825f, 0.10486785f, 0.11261292f, 0.00204757f, -0.10927247f, 0.11340243f, 0.07407050f, 0.22330707f, 
    -0.13240001f, -0.02625688f, 0.06896363f, -0.01261410f, -0.09581728f, -0.14386286f, -0.00224171f, 0.13502674f, 
    -0.00983287f, -0.03053820f, 0.14256828f, 0.04553727f, 0.13256940f, 0.14860964f, 0.15190570f, 0.39085609f, 
    -0.15312037f, -0.05430734f, -0.01221044f, 0.12238599f, 0.14319877f, -0.00923832f, 0.04673035f, 0.05872736f, 
    -0.49812552f, -0.20598604f, 0.10617212f, 0.04446603f, 0.06567772f, 0.11070124f, -0.00432211f, -0.00665037f, 
    0.04525740f, -0.07254751f, 0.09106053f, 0.01324959f, -0.50248551f, -0.31790671f, -0.29684108f, -0.03476303f, 
    0.09468213f, -0.03114907f, -0.08631326f, 0.05364525f, 0.01236203f, 0.00188042f, 0.16170512f, 0.07447639f, 
    -0.03555549f, 0.18194957f, -0.12094712f, 0.17198588f, 0.22529179f, 0.11500809f, -0.02582634f, 0.05555418f, 
    0.00806006f, 0.01011576f, 0.01877464f, 0.04879842f, -0.38434702f, 0.24588798f, -0.16686055f, 0.08527367f, 
    0.03752441f, 0.09778739f, 0.04374207f, 0.07897502f, -0.03156549f, 0.04527977f, -0.21903412f, 0.06324851f, 
    0.19068991f, 0.13155952f, -0.05358154f, -0.01174441f, -0.00723064f, -0.20092613f, -0.03039536f, 0.14676541f, 
    0.01889056f, 0.00170343f, 0.03375675f, -0.10974471f, -0.11412229f, 0.02993981f, 0.18356059f, -0.22206813f, 
    0.01346341f, 0.15513775f, -0.00552944f, 0.02544201f, 0.21812601f, -0.05149801f, 0.01471865f, 0.01940567f, 
    -0.09429569f, 0.20682307f, -0.07759141f, 0.07236741f, -0.04985875f, 0.13637477f, -0.02090971f, 0.11827253f, 
    0.01593228f, 0.06403748f, 0.07254656f, 0.07223247f, -0.33161807f, 0.06756411f, 0.00053883f, 0.33445111f, 
    0.08975932f, -0.05224470f, 0.04825287f, 0.00208896f, 0.09812728f, 0.07147618f, -0.04932564f, 0.13196735f, 
    0.04859602f, -0.07727911f, -0.17671439f, 0.29467177f, 0.27921709f, -0.06307016f, 0.08309527f, 0.14809313f, 
    0.11990900f, 0.08645882f, 0.06361747f, 0.21661852f, -0.35116976f, 0.19513936f, -0.02489492f, -0.19558793f, 
    0.22589292f, -0.05773681f, -0.04001702f, 0.05199953f, 0.06279987f, 0.05032080f, -0.04401166f, 0.03528676f, 
    -0.05231463f, -0.22268796f, 0.05663425f, -0.02786294f, -0.04865081f, -0.03261838f, 0.08577102f, -0.02305891f, 
    -0.02165563f, 0.01114491f, 0.03917835f, 0.08134840f, 0.06686100f, -0.25898325f, -0.07557933f, 0.07204907f, 
    -0.00373252f, 0.10094417f, -0.00222349f, -0.06784968f, 0.21869633f, 0.08322825f, -0.08712152f, 0.05857363f, 
    -0.08836243f, -0.06973302f, -0.16937974f, 0.36301988f, 0.08130895f, -0.00769646f, 0.12864640f, 0.01986012f, 
    0.04450045f, 0.10656294f, 0.04193300f, 0.08002881f, -0.33637443f, -0.28685248f, -0.10915319f, 0.27284169f, 
    0.04523125f, -0.06987131f, -0.01616491f, 0.02250000f, 0.03277597f, 0.05899810f, 0.19207296f, 0.13500006f, 
    -0.18371010f, -0.18395661f, -0.10447855f, 0.10932320f, 0.22598669f, 0.02867528f, -0.04570654f, -0.06434626f, 
    0.18228404f, 0.04092452f, 0.03943282f, 0.00346069f, 0.07026926f, -0.02764921f, 0.21952969f, 0.18827227f, 
    0.03691669f, 0.00683996f, 0.02979928f, 0.10635971f, 0.07340385f, 0.05827310f, 0.09054548f, -0.18228516f, 
    0.22116503f, -0.37435815f, -0.30110282f, -0.15474623f, -0.01674322f, 0.04546760f, -0.00097657f, 0.06309941f, 
    0.22344753f, 0.04622799f, -0.01231090f, -0.16659454f, -0.29471684f, 0.41729212f, -0.09677448f, 0.32124877f, 
    0.02954507f, 0.06467143f, -0.02135520f, 0.15583906f, -0.07258727f, 0.11609066f, 0.06995263f, -0.08983995f, 
    0.34562349f, 0.18338911f, -0.01661457f, -0.16522130f, -0.20112981f, 0.15482044f, -0.05077840f, 0.06050846f, 
    -0.08359062f, 0.16444427f, 0.02296663f, -0.02478150f, -0.22391725f, -0.04038463f, -0.01915916f, 0.34894353f, 
    0.04467742f, 0.07277577f, 0.12803739f, 0.06955782f, -0.05911807f, 0.03525660f, 0.05681915f, 0.03146534f, 
    0.02817452f, -0.15554233f, -0.00247611f, -0.08310930f, -0.09123325f, -0.05246589f, 0.16090640f, 0.07165977f, 
    -0.07737809f, 0.11067952f, -0.00686491f, 0.03112324f, 0.13311930f, 0.10731130f, -0.09021617f, 0.13904744f, 
    -0.00253601f, -0.08294741f, 0.04896633f, 0.14974003f, -0.01584311f, -0.08760741f, -0.00674603f, 0.00070806f, 
    -0.01001983f, -0.22249164f, -0.13626468f, -0.14159994f, -0.09320589f, -0.04935152f, -0.00497670f, 0.16424473f, 
    0.10383163f, 0.06371013f, 0.06157866f, 0.04570530f, 0.20193754f, -0.15627603f, -0.19259977f, 0.10923678f, 
    -0.12912410f, -0.03245760f, 0.04865908f, -0.05630145f, 0.05633412f, -0.08417598f, -0.03253989f, 0.03788283f, 
    -0.01943249f, 0.03773442f, 0.49205136f, -0.28284815f, 0.06092998f, 0.28667077f, 0.10571456f, 0.05046579f, 
    0.12864079f, -0.02462355f, -0.05833007f, 0.13354547f, 0.36857715f, 0.18112515f, -0.18447807f, 0.18422203f, 
    -0.08657388f, -0.12863564f, -0.05493972f, 0.06758735f, -0.04945585f, 0.18615769f, 0.08847009f, -0.10780477f, 
    -0.04407014f, -0.17903887f, -0.14074349f, -0.14507352f, 0.11851024f, 0.06995022f, 0.09409438f, 0.04308553f, 
    0.13461843f, 0.07641367f, -0.11568283f, -0.00394399f, 0.01216619f, -0.25253972f, 0.21292643f, -0.17600961f, 
    -0.08022830f, 0.11526806f, 0.10596126f, -0.07228609f, 0.01926008f, -0.01912995f, -0.01097524f, 0.17025048f, 
    0.01166233f, -0.04871235f, 0.02414630f, -0.01305739f, -0.01437684f, -0.04701941f, -0.05055445f, -0.03238720f, 
    0.01521091f, -0.00987129f, 0.01651071f, -0.04237780f, -0.00962245f, -0.01221372f, 0.00751394f, -0.04133993f, 
    -0.00078788f, 0.01344570f, -0.01067984f, 0.02540722f, -0.02114414f, 0.03416283f, -0.00145900f, 0.03702377f, 
    -0.02097785f, -0.05085823f, 0.02640631f, -0.04154740f, -0.04294930f, 0.03108803f, 0.03357011f, -0.00705347f, 
    0.04458918f, -0.01641966f, 0.02711269f, -0.00204119f, 0.03198085f, 0.03502727f, 0.01609336f, -0.02513552f, 
    -0.03312613f, -0.03793969f, 0.02455966f, -0.00388319f, 0.00464540f, 0.00625587f, -0.00961849f, -0.03015885f, 
    -0.00733190f, -0.03933178f, -0.02688051f, 0.01583232f, 0.02479318f, -0.03568048f, 0.00290129f, 0.00522888f, 
    -0.04024535f, -0.05030618f, 0.02273815f, -0.00109468f, -0.03470145f, -0.03705632f, 0.03111007f, -0.02537274f, 
    -0.04769445f, -0.04624010f, 0.01010371f, 0.04303662f, 0.00149696f, 0.00725677f, -0.03793940f, -0.05103618f, 
    0.00869402f, -0.01806929f, 0.02272746f, 0.00784796f, -0.04918316f, 0.04408533f, 0.01489991f, 0.01767987f, 
    -0.00564664f, -0.04140607f, -0.04062319f, 0.02197136f, -0.00587501f, -0.03009388f, -0.02782886f, 0.03696783f, 
    0.00706641f, -0.02824811f, -0.02108629f, -0.04384559f, 0.03515457f, -0.00494719f, -0.01122183f, 0.01513849f, 
    0.00318874f, 0.02715265f, 0.04059113f, 0.01621673f, 0.02928121f, -0.03599624f, -0.01822276f, -0.03723717f, 
    -0.00611446f, 0.03562021f, 0.03093407f, 0.00114938f, -0.04432178f, 0.00977619f, -0.03824575f, -0.02311237f, 
    0.01329119f, -0.01662844f, -0.04955361f, -0.02017014f, -0.02486009f, 0.01987090f, -0.04685099f, 0.04054977f, 
    0.01002079f, -0.02502544f, -0.02541271f, 0.02672208f, -0.01966664f, -0.01277601f, 0.00832860f, -0.05696549f, 
    -0.02296339f, -0.02954672f, -0.04553663f, -0.01957674f, -0.04160607f, -0.04853097f, -0.00087745f, 0.01162499f, 
    -0.00728155f, 0.01711463f, 0.00545224f, -0.04711773f, -0.02891095f, -0.04379725f, -0.01944567f, -0.00961778f, 
    0.03311826f, -0.01332068f, -0.00450309f, 0.02511287f, -0.05389453f, -0.02540483f, -0.02211864f, -0.04205374f, 
    0.01000325f, -0.00738693f, 0.01320534f, -0.00428624f, -0.03236662f, -0.04184554f, 0.01658190f, 0.00742437f, 
    0.00878410f, 0.03618765f, 0.00160027f, 0.00824475f, -0.02631010f, 0.01951118f, -0.03410705f, -0.03968640f, 
    -0.03352012f, 0.03961580f, -0.03338968f, 0.00665384f, 0.02541185f, -0.04073426f, -0.02982678f, -0.01129889f, 
    -0.01561397f, 0.01187349f, -0.00804038f, -0.01782622f, 0.00111787f, 0.02091421f, -0.02157592f, -0.00652338f, 
    0.00948768f, -0.03258118f, -0.00170179f, -0.00185677f, -0.01455712f, -0.02422553f, 0.00915327f, -0.01840719f, 
    -0.05277853f, -0.03216046f, -0.04599800f, -0.03755936f, 0.04284310f, -0.02141569f, -0.05569822f, -0.02447125f, 
    -0.05059874f, -0.00917719f, -0.00561457f, 0.01983569f, -0.03069732f, -0.05429643f, 0.03894679f, -0.01428217f, 
    -0.03907794f, -0.02703022f, 0.03697480f, 0.01024068f, -0.03775092f, -0.03380943f, -0.02393076f, -0.02467848f, 
    -0.05442103f, -0.04647255f, -0.03803075f, 0.02874732f, 0.04050188f, 0.03210769f, -0.02980359f, 0.04064487f, 
    0.02673126f, -0.04343381f, -0.02098467f, -0.01540774f, -0.02483747f, -0.00932066f, 0.03812283f, 0.02591031f, 
    -0.04846503f, -0.03105085f, 0.03879062f, -0.05325445f, 0.00971933f, 0.01893294f, 0.01404515f, 0.02717101f, 
    -0.03416261f, -0.04296536f, 0.04125665f, -0.00893944f, 0.02616114f, -0.04829895f, 0.00858184f, -0.00696103f, 
    0.01536013f, 0.01027556f, 0.03749450f, 0.00118115f, 0.01484896f, -0.04982689f, -0.01672763f, -0.01650984f, 
    0.03400492f, 0.02907607f, -0.05393132f, 0.01427057f, 0.04997125f, 0.00276455f, -0.05485995f, -0.01389905f, 
    -0.02160810f, -0.03666041f, 0.04324810f, -0.02749335f, -0.05646679f, -0.02527427f, -0.02792234f, -0.03624168f, 
    -0.00140976f, -0.00664377f, -0.04282346f, 0.03806035f, -0.02998826f, -0.00003074f, 0.00375976f, -0.00945332f, 
    0.00300865f, -0.01118305f, -0.00847216f, -0.00977830f, -0.04938198f, 0.00761179f, -0.03021214f, -0.02928855f, 
    -0.00205375f, -0.02064284f, 0.00379470f, -0.03149916f, -0.04775760f, -0.00808688f, 0.01199600f, -0.01932501f, 
    -0.00812876f, -0.01699715f, 0.00205424f, -0.03053896f, 0.02793281f, -0.02971502f, -0.05307174f, -0.01932400f, 
    -0.04283528f, -0.00768742f, -0.03695075f, -0.01933390f, 0.01092115f, 0.02405636f, -0.04111005f, 0.02629453f, 
    -0.04403918f, -0.00495041f, 0.02067390f, -0.04451539f, -0.04912238f, 0.00432673f, -0.00356698f, 0.03027007f, 
    0.00881710f, -0.01849278f, 0.02439381f, -0.01407261f, 0.01299363f, -0.00083148f, -0.01455394f, -0.00787231f, 
    0.02760994f, 0.01217117f, 0.00516257f, -0.01333682f, 0.02116607f, -0.01697239f, -0.01779657f, 0.04440138f, 
    -0.02299414f, -0.03638407f, 0.00792756f, -0.00600403f, -0.02125378f, -0.01823123f, -0.01854680f, -0.03730454f, 
    -0.01775432f, 0.02634401f, 0.01180246f, 0.00178500f, 0.01392531f, -0.00842469f, -0.03278781f, -0.00121175f, 
    -0.03853806f, -0.00471627f, -0.02577756f, -0.01472160f, 0.00865829f, 0.02146647f, -0.05575524f, 0.03306745f, 
    -0.00829344f, -0.03884255f, 0.02775972f, 0.02946764f, -0.00813492f, -0.03151556f, -0.04005764f, -0.00488293f, 
    -0.02426315f, -0.00726411f, -0.04051865f, 0.00015798f, -0.03358479f, 0.00865904f, 0.03937392f, 0.04052215f, 
    0.00283816f, -0.05146410f, -0.03367924f, 0.00125465f, -0.05214885f, -0.03491597f, 0.00461696f, -0.03825011f, 
    -0.05655278f, 0.03520058f, 0.00768346f, -0.01316114f, 0.00487128f, -0.03006065f, 0.02008906f, 0.04202003f, 
    -0.05415616f, 0.04096191f, 0.02650111f, -0.01703993f, -0.05356910f, 0.04327600f, -0.00146979f, -0.00307258f, 
    -0.04600282f, 0.00512146f, -0.03013571f, 0.03002848f, -0.05506132f, 0.03211838f, 0.01241869f, 0.01458443f, 
    0.00698064f, 0.04381979f, -0.03710067f, -0.05014688f, -0.00095183f, 0.03492496f, -0.04129492f, -0.02469780f, 
    -0.04346543f, -0.03520992f, -0.00371359f, 0.00070429f, -0.00328718f, -0.04232313f, 0.02890461f, -0.03115812f, 
    0.04418199f, 0.03310747f, -0.05303031f, 0.02960796f, 0.04037777f, 0.00815323f, 0.00227548f, -0.01648612f, 
    -0.03226453f, -0.03151774f, -0.02306980f, -0.03309325f, 0.03616419f, -0.01573857f, 0.04371615f, 0.01158506f, 
    0.02725914f, -0.01288301f, -0.05310449f, 0.01769223f, -0.04431388f, -0.03974994f, 0.04324106f, -0.05071110f, 
    0.00122709f, -0.05153332f, 0.01864085f, -0.00153600f, 0.03412322f, -0.04539546f, -0.02122304f, 0.00503669f, 
    -0.01353215f, -0.05203956f, -0.03647027f, 0.03528070f, -0.00514395f, -0.00138981f, 0.04119414f, -0.01801554f, 
    -0.00036704f, -0.03802647f, -0.02023884f, 0.01782458f, 0.02786562f, -0.03336360f, -0.02470000f, -0.05671048f, 
    0.01905524f, 0.02981492f, 0.01547814f, -0.02208696f, -0.03149217f, 0.01570462f, -0.05125284f, -0.04685759f, 
    -0.03106591f, 0.01498733f, 0.03041531f, 0.01198878f, -0.04020264f, -0.03427900f, 0.03477878f, 0.02369886f, 
    0.03050724f, -0.02205266f, -0.03591306f, -0.00426929f, -0.05133497f, -0.02342899f, 0.01916826f, 0.04479398f, 
    0.03926463f, 0.03491866f, -0.00613643f, 0.03455789f, 0.03681697f, -0.05685447f, -0.04480289f, -0.00568378f, 
    0.03153777f, 0.04403671f, 0.00492389f, -0.00250516f, -0.02081707f, -0.03577271f, 0.04097410f, 0.00849688f, 
    0.01765038f, 0.02942310f, -0.03354973f, 0.03791689f, -0.02876228f, 0.00438521f, -0.00707572f, -0.02202956f, 
    -0.01030223f, -0.03932158f, 0.03310205f, -0.03045885f, -0.00600122f, -0.00187502f, -0.03911974f, -0.04880176f, 
    -0.04349663f, 0.00156778f, -0.05386380f, -0.03773923f, -0.02309125f, 0.00910978f, 0.01737981f, -0.01830843f, 
    0.01172373f, -0.03233078f, -0.03917269f, -0.00585252f, 0.02979035f, -0.05563901f, -0.01679206f, -0.00049212f, 
    0.03603356f, 0.02141119f, -0.05594593f, -0.05619852f, -0.01528543f, -0.02924223f, -0.03355745f, 0.01385165f, 
    0.00790054f, 0.02183026f, 0.01374314f, -0.02464813f, -0.03642420f, -0.01376515f, -0.02936600f, 0.02738072f, 
    0.03562987f, 0.00330101f, 0.00695715f, -0.05194914f, 0.00496747f, 0.00462598f, -0.02733969f, -0.04174773f, 
    -0.04299167f, -0.02467468f, 0.03146030f, -0.03539594f, -0.04171920f, 0.04086469f, 0.01880046f, 0.02996437f, 
    0.02449168f, 0.00959034f, 0.00979032f, 0.02847422f, -0.02188244f, -0.04366753f, -0.05454989f, 0.02931463f, 
    -0.00387458f, -0.02134066f, 0.00884817f, 0.00422654f, -0.05313024f, -0.04589695f, 0.03164679f, -0.02368946f, 
    -0.03067655f, -0.02242771f, -0.02720964f, 0.01183268f, 0.03687733f, -0.04854432f, -0.00822120f, 0.03971076f, 
    0.01864602f, -0.03378787f, 0.03558112f, -0.05070549f, -0.01077897f, -0.01027735f, 0.01761449f, -0.04869633f, 
    0.04272857f, -0.00699011f, -0.00854222f, -0.03789262f, -0.02778397f, 0.00598995f, 0.02325647f, 0.00523272f, 
    0.03855694f, 0.04437706f, 0.02457666f, -0.04339379f, -0.05114128f, 0.03384344f, -0.02114396f, -0.02102980f, 
    -0.04753667f, -0.03236163f, -0.02891124f, 0.02980849f, 0.02220593f, -0.01726363f, -0.00232373f, 0.00013189f, 
    0.03505912f, 0.03496354f, 0.01692311f, -0.05038709f, -0.02665253f, -0.04660076f, 0.01170325f, -0.00095374f, 
    0.03549747f, 0.00627909f, -0.01436246f, -0.05613799f, -0.05294118f, -0.00763341f, -0.05157240f, 0.01194671f, 
    0.04252236f, -0.02097318f, 0.01418130f, 0.04203669f, -0.05220024f, -0.00494002f, -0.04966146f, 0.01047789f, 
    0.02908075f, 0.01649561f, -0.04102900f, 0.01041260f, -0.04719805f, 0.03548968f, -0.03754700f, -0.03750717f, 
    0.02906017f, -0.01518270f, 0.02865655f, 0.04414535f, -0.02006166f, -0.05339165f, 0.00527377f, -0.02299657f, 
    -0.05605540f, -0.01426241f, 0.00720243f, -0.05402681f, 0.03368055f, -0.03483897f, -0.01083251f, -0.04175306f, 
    0.01389639f, 0.01076764f, -0.02368485f, 0.02707696f, -0.01478659f, -0.02317934f, -0.05562973f, 0.01034106f, 
    -0.03450925f, -0.02445244f, 0.00572112f, 0.04064994f, -0.01898879f, -0.04568702f, 0.00331218f, 0.04130411f, 
    0.01378255f, 0.03553567f, -0.04521599f, 0.02375105f, -0.04724095f, 0.02671786f, -0.04441743f, -0.00576702f, 
    -0.01852144f, -0.02634186f, 0.02287025f, 0.03542417f, -0.04945483f, -0.03730857f, -0.04762983f, 0.01782487f, 
    0.00360852f, 0.03117761f, 0.01445453f, 0.00528600f, -0.02715744f, -0.05119180f, 0.02892041f, -0.02938632f, 
    -0.04071378f, 0.01000463f, 0.00094731f, 0.00744249f, 0.03844696f, 0.04626037f, 0.00641700f, -0.03880126f, 
    -0.04821026f, -0.02826666f, 0.04247136f, -0.00074985f, 0.02324904f, -0.04559834f, 0.01494564f, -0.00505912f, 
    0.03434575f, 0.02818810f, -0.05536937f, -0.02069802f, -0.03239099f, -0.01572007f, -0.03621139f, -0.02637593f, 
    -0.04968994f, -0.00548318f, 0.03016269f, 0.02455662f, -0.03052788f, 0.03309598f, 0.01070708f, -0.04924453f, 
    -0.03765439f, 0.04131319f, -0.01454945f, -0.03867475f, 0.00257556f, 0.01268108f, -0.01147863f, -0.02237727f, 
    -0.03928464f, -0.01838131f, 0.03813301f, 0.02732904f, -0.01271550f, 0.01546587f, -0.00706531f, -0.01848503f, 
    -0.04940693f, 0.40100056f, 0.24363451f, -0.00718617f, 0.04397150f, -0.01074725f, 0.08671691f, 0.07778955f, 
    -0.02548466f, 0.00552539f, 0.00600432f, -0.02462798f, 0.22112624f, -0.03722757f, -0.02073173f, 0.11240759f, 
    0.04093855f, -0.06124810f, 0.12155409f, 0.14457448f, 0.02673033f, 0.07854089f, -0.04749565f, 0.01370147f, 
    -0.24275224f, -0.18160006f, 0.03233583f, -0.19146933f, 0.33297348f, 0.08082901f, -0.15262403f, 0.05485702f, 
    0.06278497f, 0.00264492f, -0.18477689f, 0.14684381f, 0.00075259f, 0.10106739f, -0.10702500f, -0.27765867f, 
    -0.01063707f, -0.08620108f, -0.00424299f, 0.06587109f, -0.05758398f, 0.02349996f, -0.07602827f, -0.05552682f, 
    -0.00380839f, 0.16385441f, 0.09562627f, 0.22275341f, 0.06288494f, 0.15369689f, 0.07817168f, 0.08697871f, 
    -0.09382883f, 0.05615753f, 0.00977589f, -0.03618422f, 0.27884287f, 0.33230495f, 0.16322482f, 0.18857850f, 
    0.07999334f, 0.11733480f, 0.12758116f, 0.02035360f, -0.13934894f, -0.00802735f, -0.05917202f, 0.05807282f, 
    0.58569330f, 0.18764710f, -0.08663619f, -0.04898140f, 0.05343129f, -0.02937581f, 0.03562752f, 0.10016157f, 
    0.06166829f, 0.03398130f, 0.05172453f, -0.07929312f, 0.25130078f, 0.08556421f, -0.03406363f, 0.35031366f, 
    -0.17031458f, 0.03715844f, 0.04646438f, -0.02561161f, -0.06598093f, -0.05562795f, 0.02375652f, 0.10119125f, 
    0.03109891f, -0.25142270f, -0.03517858f, -0.16289793f, 0.10878260f, 0.03395706f, 0.06593379f, 0.02881893f, 
    -0.08844618f, -0.00354693f, -0.02546393f, 0.20906882f, -0.27261367f, -0.07859369f, 0.04320851f, -0.24144311f, 
    -0.05193465f, -0.16338070f, 0.09206057f, -0.00684102f, -0.23204976f, -0.01881236f, -0.00114168f, 0.05948669f, 
    0.36407584f, -0.27664480f, -0.06909648f, 0.12843007f, 0.06017553f, -0.11454757f, 0.02666588f, -0.02668754f, 
    0.02840074f, -0.00173115f, -0.02737771f, 0.08198853f, 0.07071604f, 0.26509008f, 0.16484915f, 0.16414645f, 
    0.00358391f, -0.04900616f, 0.06440038f, -0.13968153f, 0.14690849f, -0.05478774f, 0.09516114f, 0.13216425f, 
    -0.20950569f, 0.30638319f, -0.03570881f, -0.00054653f, 0.11324686f, 0.00792561f, -0.00041923f, -0.04426058f, 
    0.08748741f, 0.00367436f, -0.02701448f, -0.01169439f, -0.02230215f, 0.33617955f, 0.09902994f, -0.05344945f, 
    0.05273581f, -0.00093541f, 0.10124110f, 0.03574645f, 0.05238011f, 0.00221173f, 0.04575832f, 0.01056295f, 
    -0.32931322f, -0.03771158f, -0.09686957f, -0.07003882f, 0.07860040f, 0.08424409f, 0.05567915f, 0.14161147f, 
    -0.08703955f, 0.01639032f, -0.03938061f, -0.12643386f, -0.10442621f, 0.08157865f, 0.39298698f, 0.03335391f, 
    -0.06426682f, 0.02180851f, 0.02850955f, -0.01330414f, -0.04306479f, 0.02021657f, 0.03992868f, 0.05048447f, 
    -0.03239604f, 0.06344014f, -0.07783754f, 0.10801726f, -0.03524663f, 0.02447628f, 0.13940199f, -0.07523926f, 
    -0.13081174f, 0.07242657f, -0.06631301f, -0.03420888f, 0.25007224f, 0.35908604f, 0.12222189f, -0.07963376f, 
    0.00718897f, -0.09746590f, 0.00437040f, 0.08860391f, 0.05521462f, 0.04818055f, 0.11859553f, -0.06158879f, 
    0.05130092f, 0.41181377f, 0.12073538f, 0.18897647f, -0.00389119f, -0.02951932f, 0.04799866f, -0.16902243f, 
    0.10151446f, -0.00074843f, 0.01513788f, -0.06807758f, -0.19425081f, -0.00534340f, -0.00846021f, -0.12649907f, 
    -0.06694331f, 0.07338469f, -0.10966535f, -0.12199083f, 0.02170942f, 0.06573280f, 0.05714943f, 0.05128833f, 
    0.06018796f, 0.37195128f, 0.12871274f, -0.11580946f, 0.03864884f, -0.08185478f, -0.04069679f, -0.09966201f, 
    0.08143935f, 0.10140933f, 0.06803301f, 0.02756556f, 0.25098768f, 0.08483711f, -0.01289614f, 0.12300600f, 
    -0.14108551f, -0.06578998f, 0.00887709f, -0.02151561f, 0.04067558f, -0.03547189f, 0.08917054f, -0.03767670f, 
    0.30593237f, -0.37163877f, -0.07430458f, 0.07674046f, 0.07950296f, -0.02896346f, 0.02191403f, 0.13026878f, 
    -0.00310775f, -0.09809019f, 0.09023975f, 0.07723863f, -0.36914167f, -0.06572589f, 0.08938971f, -0.16853106f, 
    -0.17789462f, 0.27831149f, -0.02360869f, 0.09143618f, 0.08461732f, -0.13082416f, 0.03225337f, 0.05006528f, 
    -0.23611771f, -0.29355529f, -0.26798368f, -0.06578019f, 0.12376953f, -0.08524279f, -0.03060701f, 0.19922905f, 
    0.01822801f, 0.02687773f, -0.02562726f, 0.03479256f, 0.36313158f, 0.03383429f, 0.04475229f, 0.07097303f, 
    0.05590732f, 0.14581887f, -0.05771096f, -0.10627338f, -0.00716799f, -0.14758253f, 0.17769167f, -0.05158917f, 
    -0.43928203f, -0.05322637f, 0.11135598f, 0.05125143f, 0.11535973f, 0.12538442f, -0.12841307f, 0.19155216f, 
    -0.09197301f, -0.08212333f, -0.01248242f, 0.16657348f, -0.48664084f, -0.25978225f, -0.01524749f, -0.22867370f, 
    0.05223062f, -0.02180189f, 0.03980597f, 0.00979491f, 0.00942361f, 0.00005585f, 0.02334546f, 0.01986331f, 
    -0.37139568f, -0.11908017f, -0.06916647f, -0.33870634f, -0.03715200f, -0.00442182f, 0.07540942f, -0.10025491f, 
    -0.05897138f, -0.11460362f, -0.02718036f, -0.04440877f, -0.02239919f, -0.35593385f, -0.07387250f, -0.10485352f, 
    -0.07311299f, 0.09040884f, 0.01897960f, 0.06905717f, 0.04761577f, 0.03259358f, -0.08350220f, -0.01402975f, 
    -0.17533761f, 0.13535470f, 0.04149645f, -0.00599293f, -0.00476423f, 0.10800407f, 0.03945987f, -0.12792061f, 
    -0.10349685f, -0.05771585f, -0.08235039f, -0.15662701f, 0.31329784f, 0.36231193f, 0.06325148f, 0.27636918f, 
    -0.10666618f, 0.03190751f, 0.16865180f, 0.03328197f, 0.04583243f, -0.04179250f, 0.02937533f, -0.06803767f, 
    -0.10604940f, 0.05197712f, -0.25071982f, 0.03312057f, -0.08248165f, -0.06073206f, 0.03778012f, 0.07454005f, 
    0.06199146f, -0.02346457f, -0.08875241f, 0.07904263f, -0.51493132f, 0.01301688f, -0.10835979f, 0.13645405f, 
    0.02035439f, -0.02396881f, -0.09628757f, -0.00892274f, 0.00933766f, -0.01137433f, 0.02452666f, 0.00634086f, 
    0.30220792f, 0.11320708f, -0.00354214f, -0.12965654f, -0.09205999f, -0.12303259f, 0.07540306f, 0.03474246f, 
    -0.07205946f, -0.02840509f, 0.01337047f, -0.09051847f, 0.16895439f, -0.04711256f, -0.17124741f, -0.17877783f, 
    -0.09146436f, 0.02397228f, 0.01504975f, -0.00001104f, 0.02642602f, -0.12386392f, 0.07629999f, -0.07867429f, 
    -0.01510972f, 0.23891529f, -0.06843247f, 0.12548636f, 0.07144862f, -0.06931459f, 0.12534435f, 0.00541028f, 
    -0.07758220f, 0.04874440f, -0.04498689f, 0.07991914f, 0.01645269f, 0.01811899f, 0.04867072f, 0.08711252f, 
    0.06118809f, -0.10398841f, -0.08186630f, -0.05020459f, -0.04308246f, 0.02718739f, -0.05874195f, 0.00330962f, 
    0.22319707f, -0.25261375f, 0.17194021f, 0.18102454f, -0.04035420f, -0.00197515f, 0.15292029f, -0.02651334f, 
    0.19692209f, 0.10980389f, -0.01412011f, -0.01232791f, 0.11030200f, -0.07111469f, -0.12938154f, 0.12905043f, 
    0.01752463f, 0.14400828f, -0.01781913f, -0.11384003f, 0.01850360f, -0.09939305f, 0.04229734f, -0.18269351f, 
    0.69429833f, 0.12996660f, 0.18002962f, 0.10641120f, -0.23365074f, 0.11997657f, 0.04860444f, 0.04823789f, 
    0.06412275f, 0.00896978f, 0.01458728f, 0.10097425f, -0.06946543f, -0.08872433f, 0.07211631f, -0.19356616f, 
    0.09941559f, 0.11417027f, -0.09089465f, 0.05753248f, 0.06243939f, 0.11365813f, 0.05967280f, -0.05162942f, 
    0.34689176f, -0.16020253f, 0.08266083f, 0.25090623f, -0.12588528f, -0.02048630f, 0.05936384f, 0.01900462f, 
    0.10614821f, -0.08867716f, 0.01568441f, -0.04157809f, 0.13195987f, 0.15163431f, 0.14768790f, 0.00064123f, 
    0.09313426f, 0.04095987f, 0.10571089f, -0.01895694f, 0.03853186f, -0.04456104f, 0.08874797f, 0.26976302f, 
    0.06299012f, -0.46309555f, 0.09921782f, 0.20376185f, -0.03984977f, 0.02436237f, -0.03226675f, 0.12040921f, 
    -0.04691371f, 0.22843523f, -0.00196256f, -0.14564385f, 0.01235591f, -0.17873409f, 0.04054616f, 0.02502086f, 
    -0.02039661f, -0.07184369f, 0.15626219f, -0.06734532f, 0.08362690f, 0.02545112f, 0.01411484f, -0.03538274f, 
    0.12981071f, 0.04017166f, 0.00574078f, -0.16892341f, 0.11602984f, -0.08877616f, 0.01659229f, -0.04052204f, 
    0.01330625f, -0.01078300f, -0.05380061f, -0.03649351f, -0.10857823f, 0.31989771f, 0.09765341f, 0.00360805f, 
    0.24844627f, 0.01572326f, 0.03125568f, 0.16010256f, -0.01239479f, 0.03375171f, 0.13712367f, 0.02130556f, 
    -0.24869378f, -0.02142530f, 0.12146107f, 0.10484225f, 0.01427972f, 0.05281163f, 0.10716351f, -0.18830010f, 
    0.00350982f, 0.01751436f, 0.12254366f, 0.04055193f, 0.58151305f, 0.00969585f, -0.06466548f, 0.24757762f, 
    -0.00354080f, 0.10615698f, -0.06753448f, 0.13063879f, 0.06859800f, -0.06682642f, -0.00296378f, -0.08502562f, 
    0.06298877f, 0.08254103f, 0.14837456f, 0.06054335f, -0.04069119f, -0.08199517f, 0.04137618f, 0.06829571f, 
    0.04550683f, -0.01821432f, -0.06014925f, -0.00547609f, -0.13640346f, 0.04703951f, -0.16530630f, -0.04744762f, 
    -0.07378204f, 0.06571923f, -0.03770402f, 0.09201609f, 0.01302581f, -0.01380942f, -0.08980198f, -0.03505828f, 
    0.19915788f, 0.00975727f, 0.08739197f, 0.11142802f, 0.17918067f, -0.00801010f, 0.08853405f, 0.02617625f, 
    -0.02852073f, 0.02631404f, 0.07144777f, 0.01355306f, 0.22027566f, -0.22308291f, -0.15464480f, -0.01605679f, 
    0.07751300f, -0.03127120f, -0.01200953f, -0.20296831f, -0.11083055f, -0.13874479f, -0.07827829f, -0.02976125f, 
    -0.03054574f, 0.27495340f, -0.13393500f, -0.11464792f, 0.12199029f, 0.12001269f, -0.00854704f, -0.06998845f, 
    0.06253383f, -0.02866302f, 0.07520956f, -0.02021827f, -0.11761942f, -0.14762911f, 0.33141097f, -0.40186089f, 
    0.12138206f, 0.05413464f, 0.03556208f, -0.06410108f, 0.08224000f, 0.00156031f, -0.07633825f, 0.03326753f, 
    0.06609404f, 0.18334395f, 0.13193101f, -0.04975279f, 0.01334980f, -0.10940793f, -0.00043367f, -0.09855587f, 
    0.08619380f, -0.12563814f, -0.09760287f, -0.05869039f, 0.35131729f, -0.03512274f, 0.02970024f, 0.02160330f, 
    -0.01252380f, 0.09768835f, 0.03376104f, 0.10059688f, 0.02760751f, 0.04612802f, -0.04456301f, 0.01913318f, 
    -0.21908279f, 0.29521951f, 0.22948632f, -0.06223521f, 0.06092660f, 0.03192498f, 0.13996476f, 0.00004571f, 
    -0.03082581f, 0.05752113f, -0.00469703f, -0.11836524f, 0.61638898f, 0.19246148f, -0.02110392f, -0.07679261f, 
    0.04472489f, -0.00733960f, -0.10075476f, 0.05237281f, -0.07864206f, 0.11585045f, -0.00716509f, -0.04289186f, 
    -0.28138876f, -0.00406007f, -0.15664585f, -0.21491709f, 0.22514881f, -0.04153404f, -0.03493365f, 0.02474548f, 
    -0.12000315f, 0.17315479f, 0.14195828f, -0.09148660f, 0.37480357f, 0.07557441f, 0.12529275f, 0.03968146f, 
    0.03391034f, 0.10701428f, -0.04089378f, 0.13901840f, -0.06827043f, -0.10252656f, 0.02075619f, 0.07178470f, 
    -0.08378828f, 0.08960059f, 0.08018983f, -0.05689796f, 0.13070792f, -0.01611673f, 0.02725664f, -0.01656654f, 
    0.09188970f, 0.11886635f, 0.11397374f, 0.08636927f, -0.03140196f, 0.15536672f, -0.06902087f, -0.08384529f, 
    0.10079727f, -0.04162022f, 0.06378391f, 0.20420207f, -0.01898852f, 0.05300117f, 0.06235283f, -0.06882898f, 
    -0.00470844f, 0.03082054f, 0.03625802f, -0.04506169f, 0.00855899f, -0.00146556f, 0.03927992f, -0.01334051f, 
    -0.02578752f, 0.03130333f, 0.02155822f, -0.01726071f, -0.01033594f, 0.01030877f, -0.03433334f, -0.05637150f, 
    -0.02346674f, 0.03397778f, -0.04426691f, -0.00168768f, 0.00513316f, -0.04203018f, -0.03381507f, -0.00100470f, 
    0.03837698f, 0.00505935f, -0.02407853f, -0.00216242f, -0.01490039f, 0.02929789f, -0.03527708f, 0.00694983f, 
    0.03119173f, -0.02487081f, -0.00141497f, 0.05147587f, -0.02863376f, -0.03286231f, -0.02134185f, -0.04050443f, 
    -0.04631415f, 0.03626471f, -0.04999657f, -0.00996940f, -0.01030813f, -0.01092916f, 0.03301490f, -0.04547146f, 
    -0.01632464f, 0.04299370f, -0.02007642f, 0.01667653f, -0.03028070f, 0.02701057f, -0.05389444f, -0.00199822f, 
    -0.01805588f, 0.02564459f, -0.03588600f, 0.02500868f, -0.01750900f, 0.00957148f, 0.01575496f, 0.00577654f, 
    -0.00529911f, -0.05749555f, -0.01641321f, 0.01519366f, 0.02895001f, 0.01834345f, -0.00422349f, -0.03644957f, 
    -0.03570681f, -0.02844735f, -0.00034181f, 0.02939226f, -0.03049572f, 0.00457480f, -0.01584448f, -0.05759416f, 
    -0.00654916f, 0.01181449f, -0.00791663f, -0.03332814f, -0.04300915f, -0.00045493f, 0.03253311f, -0.02647821f, 
    -0.03876098f, 0.02398296f, 0.01513807f, 0.01520120f, -0.03561267f, 0.01957173f, -0.02105271f, -0.02267292f, 
    0.04053069f, -0.05494038f, -0.03344515f, -0.02136380f, 0.01036225f, 0.00328116f, 0.03258953f, -0.01089827f, 
    -0.01780615f, 0.00160421f, -0.03974435f, -0.04994709f, -0.04084164f, 0.00391330f, 0.02363527f, 0.03283279f, 
    -0.03325198f, 0.01849709f, -0.02357573f, 0.01050176f, 0.03504202f, 0.03775932f, 0.00727556f, -0.03584038f, 
    -0.00878851f, 0.00439753f, -0.02434432f, -0.00441858f, 0.00266256f, 0.03692551f, -0.04781374f, -0.05868797f, 
    -0.03860157f, -0.03230674f, 0.04230117f, 0.00519363f, -0.01393430f, -0.01769053f, 0.01192169f, -0.01729809f, 
    0.03940068f, -0.04113068f, 0.01490219f, -0.01271414f, 0.01380317f, -0.00444908f, -0.00607143f, 0.00944234f, 
    0.01183982f, 0.01962219f, 0.00786866f, -0.00262566f, -0.05586531f, 0.04195780f, -0.02657556f, -0.03358877f, 
    -0.02717601f, 0.00808946f, 0.03321878f, 0.01045107f, -0.04374820f, 0.01787704f, -0.03402417f, 0.01003381f, 
    -0.03258472f, -0.03420446f, 0.02546158f, -0.00238954f, -0.00278856f, -0.00998213f, 0.01751143f, -0.03027689f, 
    -0.02273331f, 0.00660748f, 0.05100868f, -0.05292418f, -0.02836892f, -0.00488600f, 0.01330370f, 0.00408423f, 
    0.01152308f, 0.01169935f, 0.01100461f, 0.01639513f, -0.04762492f, -0.03139501f, -0.00203209f, -0.04408080f, 
    0.04624681f, -0.04870627f, 0.01921112f, 0.04465742f, -0.02209205f, -0.02213839f, -0.05752358f, -0.04848998f, 
    0.01016345f, -0.01948006f, -0.01224626f, 0.04000141f, -0.03130144f, -0.02727327f, 0.02689859f, 0.00492050f, 
    0.03035327f, 0.02331946f, 0.00796750f, -0.05235987f, 0.02895707f, -0.02690428f, -0.05877143f, -0.04261739f, 
    0.03688404f, 0.02628750f, -0.00936089f, 0.04929145f, 0.00432860f, 0.02238150f, 0.03454886f, 0.03051064f, 
    -0.04207293f, 0.02292070f, 0.03860397f, 0.02309874f, 0.00155193f, 0.01407539f, 0.02807589f, -0.02044491f, 
    0.00045179f, 0.02135160f, -0.05000421f, -0.05650046f, -0.02289691f, -0.05849802f, 0.02588881f, -0.00017715f, 
    -0.00210619f, -0.00448805f, -0.01971522f, -0.01512903f, -0.04987902f, -0.03223689f, -0.03855133f, 0.01071168f, 
    -0.02846413f, -0.03690001f, 0.01563246f, -0.02440176f, 0.01839814f, 0.01054344f, -0.05268470f, -0.04612354f, 
    -0.05086892f, -0.00384647f, 0.04141352f, -0.00727944f, 0.04779787f, -0.04031716f, -0.01450585f, 0.00143604f, 
    -0.03498592f, 0.00940076f, -0.00188926f, 0.04361097f, -0.03604915f, 0.02032877f, 0.00362474f, 0.00716052f, 
    0.04108352f, -0.03869572f, -0.01603493f, -0.00587612f, 0.01496351f, 0.02487491f, -0.03285612f, -0.04409786f, 
    0.03466217f, -0.00525402f, -0.01669152f, 0.02240045f, -0.02298218f, -0.05711017f, 0.03031954f, -0.01148942f, 
    0.03912053f, -0.02599085f, 0.02874932f, -0.03099099f, -0.03763366f, -0.05800994f, 0.01067818f, 0.01161544f, 
    0.00377993f, -0.04696660f, 0.01801183f, -0.03553386f, 0.01221341f, -0.00362534f, -0.05540896f, -0.05117432f, 
    0.01094656f, -0.01146873f, -0.04488153f, 0.04274239f, -0.01568157f, -0.04378698f, -0.02276762f, -0.03278970f, 
    0.04176518f, 0.00865723f, -0.05139614f, -0.01077769f, 0.00128584f, -0.00627204f, 0.03776393f, -0.01050225f, 
    0.03857690f, -0.04524544f, -0.03334531f, -0.05257022f, -0.00106790f, 0.00049668f, 0.02306194f, -0.01971804f, 
    -0.01128896f, -0.01234261f, 0.02972507f, -0.00182405f, -0.01714358f, -0.03003149f, -0.01619191f, 0.04019770f, 
    -0.03274853f, -0.05062323f, -0.04901065f, -0.00425200f, -0.01927771f, 0.02400017f, 0.02845113f, 0.04012120f, 
    -0.05535823f, -0.02791865f, -0.03932725f, 0.01797061f, -0.03421418f, -0.03697315f, -0.04626991f, -0.01543699f, 
    -0.00207685f, 0.00946672f, -0.04982544f, -0.00873600f, -0.02742120f, 0.00510362f, -0.00015732f, -0.04691909f, 
    -0.01157242f, -0.03615650f, 0.03362371f, 0.05324678f, 0.03858133f, -0.01208141f, 0.01805028f, 0.01032402f, 
    -0.05463549f, -0.00622776f, 0.01632694f, 0.02089924f, 0.02187544f, 0.03501879f, 0.04156350f, -0.01123130f, 
    -0.04330893f, -0.04603009f, -0.00646599f, 0.00215386f, 0.00686891f, -0.05802994f, -0.02815488f, 0.02300551f, 
    0.00197318f, 0.01682927f, -0.05107780f, 0.03657658f, -0.03467182f, 0.02834283f, -0.05761981f, 0.03675859f, 
    0.55742800f, -0.01485293f, -0.15134287f, 0.18807489f, 0.10795486f, 0.19130108f, -0.02804962f, 0.16749182f, 
    0.09250442f, 0.06160493f, -0.06145068f, 0.10106460f, -0.45551383f, -0.10619561f, -0.13407376f, 0.08780611f, 
    0.11823905f, -0.06349017f, 0.06672650f, 0.06795681f, 0.08976068f, 0.08035547f, -0.06718940f, -0.06623717f, 
    0.21688320f, -0.09529904f, -0.14243053f, -0.21563272f, 0.03075982f, 0.03039584f, 0.02726065f, 0.03754289f, 
    0.02280422f, 0.15456475f, -0.01257913f, -0.09121055f, 0.00331024f, -0.03886976f, 0.03920606f, 0.05188654f, 
    0.15306120f, 0.15642360f, -0.02705956f, -0.06138467f, -0.08859652f, -0.00886017f, -0.03357813f, 0.06950630f, 
    0.08640408f, 0.04598387f, -0.10046687f, 0.12111343f, -0.11764104f, 0.04959876f, -0.03307905f, 0.09170173f, 
    0.14324221f, -0.03427359f, 0.01368441f, 0.01478657f, 0.34608227f, 0.10583322f, 0.36030897f, 0.06264712f, 
    0.00249774f, 0.02793917f, -0.03499404f, 0.02696978f, 0.01288090f, -0.03226969f, 0.01627637f, 0.16647066f, 
    0.01687612f, -0.18221694f, 0.04376145f, 0.00301272f, 0.02914365f, -0.01960150f, 0.06321570f, -0.09605671f, 
    0.13410832f, -0.00830923f, 0.05873158f, 0.00034118f, -0.04517446f, -0.08254094f, 0.03200205f, 0.25854236f, 
    -0.02799218f, 0.07371796f, 0.02777121f, 0.14682953f, -0.08712466f, 0.06569289f, 0.19123712f, -0.00296561f, 
    -0.04768074f, -0.43332899f, -0.29307666f, -0.22815049f, -0.06112176f, 0.02359753f, -0.00589639f, -0.07190046f, 
    -0.00898430f, -0.04004645f, 0.09653623f, 0.13978079f, -0.23023614f, 0.03663285f, -0.05081860f, -0.05074129f, 
    -0.01239347f, 0.01785582f, -0.14699119f, 0.11536039f, -0.01898745f, 0.05122064f, 0.00737097f, 0.00739361f, 
    -0.02669371f, 0.02898649f, 0.05596793f, -0.04605003f, -0.03958109f, 0.02186619f, 0.01290000f, 0.05288578f, 
    0.04175854f, -0.08864626f, 0.03678283f, 0.07287458f, 0.21979894f, 0.07839721f, 0.14617652f, 0.52890551f, 
    -0.01865216f, 0.04567914f, -0.00565769f, 0.03313480f, 0.01304879f, -0.05662034f, 0.10820772f, -0.10072989f, 
    0.55294061f, -0.32390556f, 0.01685995f, -0.00602565f, -0.14400484f, -0.02152396f, -0.12335435f, 0.05746837f, 
    0.14539719f, 0.03707884f, 0.10050087f, -0.08298858f, 0.21565905f, -0.11762793f, 0.23139846f, 0.28276047f, 
    0.09537372f, 0.02468640f, 0.01663564f, 0.03257278f, 0.01866834f, 0.05294355f, -0.06108132f, -0.02276883f, 
    0.10940797f, -0.17375757f, -0.03543802f, 0.04095566f, 0.01416291f, -0.00043625f, -0.03710856f, 0.10606196f, 
    0.10297944f, 0.03471842f, 0.17293723f, 0.08115147f, 0.22004908f, 0.18119936f, 0.20084693f, 0.22690237f, 
    0.04478496f, -0.13867310f, 0.07286879f, 0.06530554f, -0.00756916f, 0.08113896f, -0.14301397f, 0.00804933f, 
    -0.08263732f, 0.09044822f, 0.00215427f, -0.03043543f, -0.08129319f, -0.00623920f, 0.02504407f, -0.07307574f, 
    0.00574326f, -0.02499613f, 0.04922622f, 0.05567988f, 0.56454027f, -0.11344273f, 0.17225197f, 0.00238915f, 
    -0.17848408f, 0.19973123f, -0.07479475f, 0.02427848f, 0.06547032f, 0.01099385f, -0.01893650f, 0.07955854f, 
    -0.11503489f, -0.06829903f, 0.14325778f, 0.26324037f, -0.18260852f, -0.10374818f, 0.07982901f, 0.07650814f, 
    0.12740622f, -0.07312479f, 0.06443308f, -0.01839224f, 0.20515487f, 0.15532675f, 0.12083355f, 0.27946371f, 
    0.05258722f, 0.14560860f, 0.06055547f, 0.04457460f, 0.01487756f, -0.05673632f, -0.05215852f, 0.10925057f, 
    0.22433797f, -0.18375222f, 0.14549518f, 0.01655643f, -0.03566501f, -0.04322112f, 0.05184637f, 0.03069690f, 
    -0.08876102f, 0.02221375f, 0.05778957f, 0.15538538f, 0.35567638f, 0.16325076f, -0.08420337f, 0.11141988f, 
    0.19880462f, 0.04806761f, 0.15300480f, 0.01152769f, -0.00018419f, -0.07291457f, -0.05229958f, 0.05576288f, 
    -0.31373808f, 0.46858644f, -0.05017266f, -0.19883396f, -0.03228590f, 0.08972419f, 0.13762082f, -0.02518375f, 
    0.22057331f, 0.03664441f, 0.04135230f, 0.12687588f, -0.00991878f, -0.06873959f, 0.33973444f, -0.43479055f, 
    -0.02487947f, -0.00872454f, 0.13387628f, 0.00330971f, 0.01302736f, 0.09806833f, 0.10002788f, 0.04281495f, 
    -0.09569255f, -0.20559610f, -0.12555704f, -0.03088308f, 0.06282786f, -0.12535693f, 0.03872909f, 0.04193087f, 
    0.02038481f, 0.00609427f, 0.08175478f, 0.08528820f, -0.01721848f, 0.03063068f, -0.01525138f, 0.11814930f, 
    0.08654591f, 0.03665790f, 0.03569388f, -0.08525284f, -0.02220235f, 0.06222122f, 0.08627345f, 0.08918680f, 
    -0.34704044f, -0.30512699f, -0.05474740f, -0.28202519f, -0.10317764f, -0.11330375f, 0.03201017f, -0.01722143f, 
    -0.04135649f, 0.05164281f, -0.06204989f, 0.08459619f, -0.07639616f, 0.28956074f, -0.04642210f, -0.12168983f, 
    0.04344067f, 0.11889248f, 0.05337546f, 0.10818380f, -0.06548029f, 0.10125116f, -0.00089020f, 0.00971901f, 
    0.10307741f, -0.16936772f, -0.00264988f, -0.09475507f, 0.18326125f, 0.02370402f, 0.13094333f, 0.12283126f, 
    -0.04294286f, 0.06601566f, 0.09719069f, 0.08896966f, -0.20185921f, 0.14733078f, -0.01196457f, -0.07916658f, 
    0.09368312f, 0.15468484f, -0.02145329f, 0.19450875f, 0.08922704f, -0.08376820f, 0.01573946f, 0.12836857f, 
    0.26177716f, -0.04126877f, 0.04664296f, 0.29994947f, -0.11922944f, -0.02063504f, 0.00065888f, -0.08058163f, 
    0.10353111f, -0.03453681f, 0.07419065f, -0.07092077f, 0.14606778f, -0.12155119f, -0.14640220f, -0.02122715f, 
    0.09509788f, -0.10171025f, -0.02629910f, 0.12128475f, -0.05063055f, 0.01834088f, 0.01088515f, 0.02315015f, 
    -0.02564557f, -0.04954096f, 0.02270315f, 0.01784623f, 0.03066105f, 0.01139318f, -0.00145612f, 0.02105652f, 
    0.03228614f, 0.00087812f, -0.03874053f, -0.01860791f, 0.02502790f, -0.01869005f, 0.04267894f, -0.02954844f, 
    -0.04158702f, -0.03805158f, -0.03820376f, 0.03230479f, -0.04119782f, 0.00743224f, 0.02366537f, -0.04753371f, 
    0.01942696f, -0.02608024f, -0.03032655f, -0.01453262f, -0.01329429f, -0.00678163f, 0.02232786f, -0.05509907f, 
    0.01356951f, -0.00825059f, 0.04599751f, -0.00622222f, -0.05284175f, -0.02110367f, -0.00709050f, -0.01825629f, 
    -0.03705084f, -0.01948900f, -0.01821765f, 0.00533494f, -0.01253693f, 0.04237482f, -0.03559301f, 0.00205967f, 
    -0.02759146f, -0.00556843f, -0.00747676f, -0.02916957f, 0.04245560f, -0.05649969f, -0.02621908f, -0.00349202f, 
    -0.03041769f, -0.02776742f, -0.00371783f, -0.01286605f, 0.00171718f, -0.03675921f, 0.03431764f, 0.01687674f, 
    0.01802293f, 0.01198110f, -0.00645604f, -0.04266130f, -0.02515635f, -0.02865010f, 0.02238900f, -0.03601485f, 
    -0.03006420f, 0.00473390f, 0.01394523f, -0.03901280f, -0.04610097f, 0.01412002f, 0.00272274f, 0.03234102f, 
    0.03061116f, 0.01350383f, -0.02558981f, 0.03863753f, -0.03915239f, 0.02904154f, 0.03904546f, -0.03609028f, 
    -0.02831709f, 0.01199836f, -0.01143617f, -0.00491019f, 0.04057799f, -0.00447622f, -0.01362992f, -0.05716522f, 
    0.04334839f, -0.01989295f, -0.04904624f, -0.00867408f, 0.00317353f, -0.02377342f, -0.01614173f, -0.00793712f, 
    0.04563541f, -0.03963928f, -0.02879952f, -0.02704797f, 0.04237647f, -0.01773237f, 0.02991377f, -0.02400628f, 
    -0.01816179f, 0.02983112f, 0.00916984f, 0.03033954f, -0.05063510f, -0.00215542f, -0.01391226f, -0.02135918f, 
    -0.01049444f, -0.03660893f, -0.01201875f, -0.05297841f, -0.01527508f, -0.01279155f, 0.04109494f, -0.00153662f, 
    0.00199450f, 0.01633942f, 0.03634526f, 0.04040188f, 0.01610432f, -0.04863232f, -0.02800636f, 0.03888528f, 
    0.01303509f, -0.03571880f, -0.05371113f, 0.01842847f, -0.01064377f, 0.03702895f, -0.03586074f, 0.01455727f, 
    -0.02119797f, 0.00850673f, -0.00742813f, 0.03389278f, -0.01096641f, -0.05357707f, 0.03532145f, -0.02123543f, 
    -0.03647564f, -0.02781350f, 0.02169572f, 0.00331602f, 0.01648555f, -0.00053242f, 0.01966127f, -0.04948205f, 
    -0.01064510f, -0.00046153f, 0.01719058f, -0.01813798f, 0.02020534f, -0.03029688f, 0.03308445f, 0.03010812f, 
    0.00766602f, 0.03840876f, -0.01365229f, -0.00315427f, -0.01122608f, 0.00716088f, 0.02143581f, -0.04585404f, 
    0.02269800f, -0.01017128f, 0.00833978f, 0.01185820f, 0.04443680f, -0.00188807f, -0.03647435f, 0.00268460f, 
    0.03875436f, 0.00044948f, -0.01349318f, 0.02874775f, 0.02585972f, -0.00847762f, -0.01528207f, -0.02845664f, 
    -0.00766105f, -0.04008556f, -0.02518990f, 0.03605180f, 0.01067158f, 0.01969146f, -0.02966147f, -0.00639936f, 
    -0.04038944f, -0.01118923f, 0.01656758f, 0.03106319f, -0.03386406f, 0.01347199f, -0.05560685f, -0.01080237f, 
    -0.00847095f, -0.02367476f, 0.04302594f, -0.04787139f, -0.02436967f, -0.03769028f, -0.02598147f, -0.05172383f, 
    -0.04047106f, -0.04697527f, -0.00230626f, 0.01421254f, -0.04185198f, -0.04902816f, 0.02491162f, -0.05046259f, 
    -0.03860689f, -0.02269790f, 0.03069344f, -0.04056292f, 0.01079262f, -0.04188895f, 0.02591626f, -0.03633867f, 
    0.04855043f, 0.01915484f, -0.00619121f, 0.03382744f, 0.02640861f, 0.00834099f, -0.01955016f, -0.02235003f, 
    -0.00477956f, -0.04971672f, -0.04087332f, 0.02433262f, -0.04396785f, -0.03286833f, 0.01983787f, -0.00247426f, 
    0.00928621f, -0.03609621f, -0.03326064f, -0.00956015f, -0.03409369f, 0.02939616f, -0.05160056f, 0.03114093f, 
    -0.01959336f, -0.00805519f, 0.00094928f, 0.01511926f, -0.04058168f, -0.04630373f, 0.03098358f, 0.02272161f, 
    -0.04641450f, 0.03039241f, -0.00712971f, 0.01078521f, -0.03743604f, -0.03345287f, 0.01854566f, 0.01648723f, 
    0.03534300f, 0.01472720f, -0.04285061f, -0.03077310f, 0.01128348f, 0.04186009f, -0.00416927f, -0.03220902f, 
    0.01547463f, 0.01231747f, -0.04103933f, -0.02811958f, 0.00687679f, -0.02239927f, 0.04092723f, 0.00802399f, 
    0.01730480f, -0.05408566f, -0.04772949f, 0.00959095f, -0.05710382f, -0.05348352f, -0.03925041f, 0.01088122f, 
    0.01599550f, 0.00123333f, -0.04803503f, -0.01673006f, -0.04285988f, -0.05178989f, 0.01913631f, -0.03870079f, 
    -0.03123127f, 0.04199797f, 0.02542834f, 0.01996990f, 0.01132019f, -0.02165506f, -0.05578583f, 0.04105033f, 
    0.02717560f, -0.01161991f, -0.03502464f, 0.03353862f, 0.03244499f, -0.02381657f, -0.02598383f, 0.03162767f, 
    0.01693517f, 0.00995845f, 0.01578435f, -0.00924726f, -0.03350172f, -0.00117279f, 0.01495524f, 0.00716154f, 
    0.01987061f, 0.01428080f, 0.03033786f, 0.02081997f, 0.04461506f, -0.01940185f, -0.01593329f, -0.00047031f, 
    -0.05161414f, -0.04710387f, -0.04353476f, -0.04556765f, 0.00476647f, 0.00359498f, -0.05727457f, -0.02563588f, 
    -0.05230433f, 0.00256716f, -0.04148942f, -0.02841994f, -0.04721814f, -0.03030883f, -0.04581978f, 0.01971906f, 
    0.04318167f, -0.05375957f, -0.03382305f, 0.04281105f, -0.03277297f, 0.01126554f, 0.04145703f, -0.01234863f, 
    -0.04199428f, 0.02256473f, 0.00267777f, 0.02394351f, -0.00181339f, -0.02917032f, -0.00094370f, 0.03747904f, 
    0.05558307f, 0.03563782f, -0.02935553f, -0.02285435f, 0.02184828f, 0.03416655f, 0.02457638f, 0.03765547f, 
    -0.02292761f, -0.00607102f, 0.00895934f, 0.01408804f, -0.03291085f, 0.03610590f, -0.01122156f, -0.05094218f, 
    -0.03778669f, 0.01846846f, 0.00115015f, 0.01902335f, 0.02902515f, 0.00424324f, -0.00253487f, -0.02935370f, 
    0.00250570f, 0.00206124f, -0.03533170f, -0.05253137f, -0.02722069f, -0.04834346f, -0.04259849f, -0.05527591f, 
    -0.02875251f, -0.04737690f, 0.03089355f, 0.00760565f, 0.04119632f, -0.00249057f, 0.01373016f, 0.04130071f, 
    -0.02722612f, -0.04316267f, 0.01490805f, -0.01119947f, 0.01650819f, -0.03301229f, 0.03645467f, 0.00262736f, 
    0.01393864f, -0.00422187f, -0.02460493f, -0.05295885f, 0.01113569f, 0.03553868f, 0.02755612f, 0.03860058f, 
    0.01377454f, 0.02367813f, 0.02713555f, -0.05268470f, -0.00314273f, -0.03452151f, 0.02192068f, 0.00657123f, 
    0.01959057f, -0.05813095f, -0.01929425f, -0.05017206f, -0.04453976f, -0.02963745f, 0.03642971f, -0.01540552f, 
    -0.00862528f, -0.05639515f, 0.04187159f, 0.02013625f, 0.02935356f, -0.00100434f, -0.01971915f, -0.01111472f, 
    0.02975447f, 0.03018467f, 0.00559030f, -0.00651189f, 0.01226479f, 0.01141285f, -0.01708875f, -0.01890662f, 
    0.04043877f, -0.01114408f, -0.03984591f, 0.02097522f, -0.04007930f, 0.01730803f, -0.01027586f, -0.05524790f, 
    -0.04142996f, -0.02496180f, -0.02662669f, -0.03437928f, -0.05449003f, -0.04392287f, 0.04545321f, 0.02282987f, 
    -0.01293924f, -0.05458751f, -0.00287238f, -0.03107190f, 0.00203894f, -0.01746154f, 0.04878665f, -0.00075631f, 
    0.03125038f, 0.01050046f, 0.04083057f, -0.00702568f, 0.00896802f, -0.02106817f, -0.02425798f, 0.01719931f, 
    0.02410842f, -0.02097495f, -0.01097664f, -0.05758515f, -0.02571684f, -0.00263561f, -0.02538678f, 0.00351680f, 
    -0.03426835f, 0.04958211f, 0.02472352f, 0.00551838f, 0.00287305f, -0.03338755f, -0.01453245f, 0.01208268f, 
    -0.01265117f, -0.00110688f, -0.02979808f, 0.01291200f, 0.02484586f, 0.03207752f, -0.02447383f, -0.04845234f, 
    0.02771345f, -0.03754753f, 0.01113137f, 0.03935718f, 0.00216024f, -0.01403916f, -0.03289969f, -0.01061163f, 
    -0.06076728f, 0.00300781f, -0.00316541f, -0.05414506f, -0.05607520f, 0.02763664f, 0.03208044f, -0.03250364f, 
    -0.05774665f, -0.02978887f, 0.02711649f, -0.01186016f, -0.00483819f, 0.02458758f, 0.01822252f, -0.03384506f, 
    -0.04859635f, 0.03858653f, 0.02063979f, 0.03113368f, -0.04852761f, -0.03067219f, 0.03889859f, -0.01862790f, 
    -0.00937194f, 0.03597075f, -0.01118666f, 0.02893088f, 0.02353155f, 0.01070647f, -0.01461437f, -0.05306962f, 
    0.03168315f, 0.04066198f, -0.01998949f, -0.01295935f, -0.00394167f, -0.02529172f, 0.03350127f, -0.00088203f, 
    0.00279880f, -0.04391962f, -0.03025905f, -0.00004758f, -0.01426741f, -0.04037464f, -0.03798696f, 0.00474966f, 
    0.01220658f, 0.01029042f, -0.02653792f, 0.01879476f, -0.02671606f, -0.05680951f, -0.05053243f, -0.04378139f, 
    -0.03048217f, -0.01638126f, -0.04423241f, -0.01989717f, 0.03344319f, -0.00406023f, -0.05638196f, -0.05552157f, 
    0.02779934f, 0.01877554f, 0.00619180f, -0.01267471f, -0.03987170f, -0.00951140f, -0.03725570f, -0.00325032f, 
    -0.02188575f, 0.01684494f, -0.01369432f, -0.00264506f, 0.04932111f, -0.00124599f, 0.02624491f, -0.04327694f, 
    -0.02416382f, 0.01426838f, 0.01000937f, 0.01169613f, -0.02812474f, -0.02292302f, 0.01911832f, -0.00132250f, 
    -0.00539559f, -0.03417224f, 0.02317166f, 0.00166444f, 0.04179412f, -0.04808986f, 0.00311437f, -0.02531796f, 
    -0.05268621f, -0.05824516f, -0.01821559f, -0.02572036f, -0.00885724f, 0.03772264f, -0.00017101f, -0.04693091f, 
    -0.04624540f, 0.05065478f, -0.01732890f, 0.01146526f, -0.03968543f, 0.01842532f, 0.01331254f, -0.02187926f, 
    -0.02420669f, 0.04354541f, -0.00591003f, 0.02228606f, -0.03568161f, -0.01710952f, 0.02451201f, 0.02942493f, 
    -0.04939488f, 0.03342538f, -0.04353356f, 0.01960199f, 0.00871778f, 0.01779095f, -0.04719647f, 0.01883059f, 
    0.02194025f, -0.01128735f, 0.00929889f, -0.01953468f, -0.05356110f, 0.02055892f, -0.00609302f, -0.00487460f, 
    0.03820539f, 0.02004676f, 0.02645160f, -0.04987381f, -0.00522577f, -0.02251667f, -0.03539249f, -0.04627120f, 
    -0.03178038f, -0.03835486f, -0.03871689f, 0.02272714f, 0.02626839f, -0.03052396f, 0.00116181f, 0.04150087f, 
    0.00618439f, -0.00396849f, 0.00917015f, -0.02476810f, -0.02679233f, 0.03939592f, -0.05160984f, 0.01957161f, 
    0.04048835f, 0.03664513f, 0.01301582f, -0.05686519f, 0.03104779f, -0.03848466f, -0.02737930f, -0.05600268f, 
    -0.00509534f, -0.01138554f, 0.00943364f, -0.01726206f, 0.03861981f, -0.02861929f, 0.02424874f, 0.02653757f, 
    -0.00239931f, 0.04128321f, 0.00348468f, -0.03356673f, -0.04736945f, 0.01649485f, -0.04290721f, 0.00452363f, 
    -0.03963032f, 0.01311135f, -0.05227025f, 0.03959348f, -0.05581012f, 0.03084603f, -0.01804090f, -0.03935454f, 
    -0.03877101f, 0.04172180f, -0.00395026f, -0.03061982f, -0.00882486f, -0.05153213f, -0.03461877f, -0.02122373f, 
    0.02304935f, 0.02196415f, -0.01023352f, 0.00903751f, -0.00848269f, 0.02415540f, -0.02095885f, -0.02754848f, 
    0.02234690f, -0.00313833f, 0.01308215f, -0.04218628f, 0.03536404f, 0.01151996f, -0.00285832f, 0.00627586f, 
    -0.03421511f, 0.01363022f, 0.02762742f, 0.03687791f, 0.03071436f, 0.01580351f, -0.01308832f, -0.03367585f, 
    -0.04727709f, 0.02258438f, -0.02913558f, 0.03312491f, -0.02883662f, 0.03680092f, -0.02055698f, 0.01864492f, 
    -0.01890761f, -0.05466579f, -0.05252689f, -0.02417356f, -0.03639405f, -0.02029393f, -0.01557786f, -0.05197293f, 
    -0.01302777f, 0.02396932f, -0.00581397f, -0.03257756f, -0.00997785f, 0.03388305f, 0.01712205f, -0.04186940f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00148933f, 0.03663082f, 0.03939081f, -0.03567912f, -0.05038052f, 0.02399576f, 0.09236727f, 0.02611921f, 
    0.01338464f, 0.07870283f, -0.02862730f, 0.05910943f, 0.03954669f, 0.01709459f, 0.04140614f, -0.05674121f, 
    0.09897353f, -0.10285472f, 0.00920368f, 0.01234055f, 0.02452966f, 0.05475771f, -0.05306110f, 0.12888694f, 
    -0.05490298f, -0.03057760f, 0.00074742f, -0.05005470f, -0.01940032f, 0.06323592f, 0.02235774f, -0.04966621f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05115345f, -0.02998535f, 0.16550486f, 0.52769554f, -0.06633481f, 0.04945680f, -0.14605385f, -0.15299302f, 
    -0.20737143f, -0.53584379f, 0.16807717f, -0.57485431f, 0.02893225f, 0.23032109f, -0.55392891f, 0.03361554f, 
    -0.12792377f, 0.45609117f, -0.21000990f, -0.50964719f, 0.06120209f, 0.19295479f, 0.09149098f, 0.09380683f, 
    0.00563540f, -0.03224564f, -0.14144154f, 0.22157182f, -0.16807148f, -0.03562514f, -0.14600033f, 0.02167897f, 
    -0.12933263f, 0.14681973f, -0.19266692f, -0.84814763f, 0.02923249f, -0.06237761f, 0.32631192f, -0.01584357f, 
    0.23635454f, 0.28042659f, 0.05139719f, -0.70215440f, -0.12215205f, 0.28801927f, 0.03774256f, -0.11661185f, 
    0.34671527f, 0.20637067f, -0.50450259f, -0.04939712f, -0.17250383f, -0.31443566f, 0.06156687f, -0.07340154f, 
    0.09188219f, 0.07207059f, 0.11207217f, 0.15612327f, -0.13248207f, 0.27280515f, 0.01603463f, 0.17299888f, 
    0.09046423f, -0.03194718f, -0.64321285f, 0.25847471f, 0.16927749f, -0.07380923f, 0.17589518f, 0.11490399f, 
    -0.03204485f, -0.30901998f, 0.03685877f, 0.21499364f, -0.14950380f, -0.60058981f, 0.38543510f, 0.09580581f, 
    -0.25277376f, 0.11161982f, -0.50866544f, -0.53006750f, -0.08594836f, 0.13670908f, 0.10316029f, 0.13408709f, 
    -0.09430006f, -0.03317218f, 0.19182631f, 0.42415246f, 0.08031321f, -0.02480831f, -0.01724537f, 0.07032045f, 
    -0.05534261f, 0.01619377f, 0.29209191f, 0.08718819f, 0.17038612f, 0.01340960f, -0.01257044f, -0.16807352f, 
    -0.34944177f, 0.23941913f, -0.11504458f, -0.15070869f, 0.09785847f, -0.63466650f, 0.37126133f, -0.06805474f, 
    -0.81214339f, -0.22561637f, -0.11252851f, 0.20268607f, -0.00087295f, -0.07159021f, 0.01563532f, 0.19812103f, 
    -0.06243052f, 0.00619315f, -0.38819337f, -0.21298386f, -0.14693201f, 0.29103169f, 0.06616627f, 0.01977384f, 
    -0.12697969f, 0.00086568f, -0.05788247f, 0.15816091f, -0.10716975f, 0.16676436f, 0.18931383f, 0.11727776f, 
    -0.27431560f, -0.46284890f, -0.01637013f, 0.22071883f, 0.06658477f, 0.48074779f, 0.20907946f, -0.11314259f, 
    -0.29180351f, 0.35597688f, 0.26521197f, 0.28563175f, -0.09245493f, -0.33264947f, 0.16908981f, 0.09370545f, 
    -0.16067517f, 0.03278137f, -0.18572420f, -0.45853099f, -0.00030624f, -0.10691532f, -0.11442519f, 0.12913713f, 
    0.10301884f, 0.06206283f, 0.22501843f, -0.35379091f, 0.04775108f, 0.08938295f, -0.25311306f, 0.01095866f, 
    -0.63391960f, -0.48169810f, -0.01377720f, -0.11180139f, 0.16619503f, 0.27634296f, 0.46191528f, -0.11950423f, 
    0.58400744f, -0.35541353f, 0.14739177f, -0.35158655f, 0.02587591f, -0.01141947f, 0.15175697f, -0.15195765f, 
    0.07823541f, 0.06111730f, 0.12015070f, -0.25910732f, -0.02055345f, 0.04731960f, -0.15860566f, 0.00474139f, 
    0.08500616f, 0.11374642f, 0.07641826f, -0.43619141f, -0.18304013f, -0.05757334f, -0.38487911f, 0.09072918f, 
    -0.02203085f, 0.15651229f, -0.14246611f, 0.35405543f, -0.13396116f, 0.02295722f, -0.59824044f, 0.08110999f, 
    -0.51291656f, -0.28197828f, 0.27975011f, -0.61506391f, 0.11968306f, 0.38402805f, 0.14493051f, -0.44234389f, 
    0.04086927f, -0.04576944f, 0.24275601f, 0.11950437f, 0.07518362f, 0.22191583f, 0.12330850f, 0.02385739f, 
    0.12197082f, -0.06065608f, 0.16269371f, 0.27712965f, -0.11128872f, 0.09973097f, -0.24389201f, 0.10587432f, 
    -0.40479541f, 0.37529689f, -0.10396091f, 0.41617355f, 0.00009850f, -0.12562644f, 0.04701494f, -0.03922262f, 
    0.01808569f, -0.09371991f, -0.00365089f, 0.28981540f, -0.11571659f, -0.40756664f, 0.13262455f, -0.47363156f, 
    -0.15570273f, -0.07889844f, -0.09701424f, 0.15918671f, -0.13317367f, -0.68097192f, 0.13550130f, -0.03873973f, 
    0.01395805f, 0.13428159f, -0.31008157f, 0.14276221f, -0.16955829f, 0.02870527f, 0.52668834f, -0.09750191f, 
    0.17672348f, -0.42591652f, 0.04294254f, 0.09279206f, 0.00558042f, -0.59242290f, -0.09004956f, -0.18336296f, 
    0.17383365f, -0.60502928f, 0.38979617f, 0.08020599f, 0.09096666f, -0.48300463f, -0.16965465f, -0.16314872f, 
    -0.13628215f, 0.14549795f, 0.17248879f, 0.23258907f, 0.00185391f, -0.03655511f, 0.00804197f, 0.06326942f, 
    -0.07209483f, 0.00388467f, -0.35216075f, 0.03043019f, -0.17601626f, 0.12298094f, -0.65063637f, -0.10359268f, 
    0.40321639f, 0.09587025f, -0.10531311f, 0.28897631f, -0.01631876f, -0.12673384f, 0.05825896f, 0.02992642f, 
    0.17608528f, 0.11910959f, 0.07581544f, 0.16474588f, -0.15241581f, 0.37536526f, -0.17013927f, 0.12766412f, 
    0.14952058f, 0.14165898f, 0.34137237f, -0.41396400f, -0.11987128f, -0.40023622f, -0.01191758f, -0.09660611f, 
    -0.15460351f, -0.15905510f, -0.06554239f, -0.43548119f, -0.00593348f, -0.07281411f, 0.08361313f, 0.09779178f, 
    -0.13836843f, 0.36823735f, 0.12996745f, 0.23532918f, -0.01616065f, -0.39209151f, -0.49728277f, 0.04418700f, 
    0.37900102f, -0.32268569f, -0.55255538f, -0.18473196f, -0.14909998f, 0.40775514f, 0.14920014f, 0.43073925f, 
    -0.01878762f, -0.16488495f, -0.52622736f, 0.15919220f, 0.16830166f, -0.32004327f, 0.12254891f, -0.14797340f, 
    0.03089482f, 0.09275560f, 0.19635436f, 0.14331396f, 0.17018314f, 0.03609597f, 0.21767701f, -0.09834513f, 
    0.69581360f, -0.44561854f, 0.01504037f, 0.10472574f, -0.15137334f, -0.16635403f, 0.41773742f, -0.13338953f, 
    -0.16321902f, -0.21894403f, 0.22719283f, -0.37171564f, -0.05519570f, 0.21092264f, -0.14742236f, -0.16657601f, 
    0.14350554f, 0.09496778f, -0.83326340f, -0.19407953f, -0.12924136f, -0.13986368f, 0.01032520f, -0.04630101f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.11295196f, -0.11000466f, -0.07823298f, 0.15929310f, 0.06887983f, 0.16330993f, -0.00598221f, -0.24260546f, 
    -0.00452536f, -0.04485165f, 0.21029332f, -0.03615986f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
