#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.71497202f, 0.09488456f, 0.61486161f, -0.07955674f, 0.83074683f, -1.08117104f, 0.25064096f, 0.16297784f, 
    -0.60805357f, -0.63146442f, 0.08790091f, -0.28791407f, 0.47543526f, 0.04133715f, 0.15335260f, 0.28990728f, 
    0.23620293f, -0.12907334f, -0.08827583f, 0.27508146f, 0.33865824f, 0.22150196f, -0.31411719f, -0.13685916f, 
    0.31829187f, 0.55435622f, 0.90634829f, 0.91862351f, 0.35055572f, 0.60391408f, -0.92378372f, -0.76246363f, 
    0.23533605f, -0.58452284f, 0.40321404f, 0.61475241f, 0.33240831f, -0.07911463f, 0.58945072f, -0.28130427f, 
    0.30209067f, 0.27855608f, -0.07200964f, 0.04679926f, 0.07031914f, 0.36433583f, 0.25135055f, -0.20221974f, 
    0.25144628f, 0.05387631f, -0.67255557f, -0.76372635f, 0.73042315f, 0.66824198f, -0.71826398f, -0.22423697f, 
    -0.38870412f, 0.49688491f, -0.15210022f, 0.02321377f, 0.06006998f, -0.24380530f, 0.19144653f, 0.28183854f, 
    0.29688317f, -0.42720941f, -0.13352561f, -0.07378649f, -0.40224698f, -0.41721967f, -0.52722043f, -0.45408446f, 
    -0.03168219f, -0.45855510f, -0.24143530f, 1.04397392f, 0.53636003f, 0.50331819f, 1.20337999f, 0.81007349f, 
    0.85524404f, 0.65385127f, -0.50456637f, -0.06136744f, -0.08727845f, -0.29481333f, 0.04437358f, -0.30326679f, 
    0.16560133f, -0.46469301f, -0.21673736f, 0.08473305f, 0.11761915f, -0.09580072f, -0.19621760f, 0.12462987f, 
    0.31717280f, -0.20160446f, -0.20043838f, 0.30099773f, 0.31923440f, 0.11285266f, -0.24592362f, 0.91951656f, 
    -0.29045063f, -0.33806980f, 0.33342350f, 0.29767588f, -0.15008333f, -0.65699875f, -0.71362722f, -0.60005975f, 
    -0.79450029f, -0.12093292f, 0.14199825f, -0.08986551f, 0.02133641f, -0.10246238f, -0.01343027f, 0.04926674f, 
    0.32905275f, -0.16734670f, 0.48819914f, -0.09674300f, -0.32831565f, 0.04903569f, 1.10632789f, -0.48781475f, 
    -1.13003218f, -0.66299760f, 0.37337416f, -0.75670874f, -0.35681221f, -0.05859561f, -0.34299323f, 0.28651613f, 
    -0.13815200f, -0.19305581f, 0.23750675f, -0.11554381f, -0.02989724f, 0.30290017f, 0.01189727f, -0.06940264f, 
    -0.24745998f, -0.24425128f, -0.11798534f, 0.39444646f, -0.07596432f, 0.24455880f, -0.37195235f, -1.45902789f, 
    -0.90354508f, 0.12105451f, -0.27210316f, -0.70766497f, 0.86658442f, 0.69480610f, -0.67379183f, 0.46527755f, 
    0.58333564f, 0.10532997f, -0.04686878f, 0.01067289f, -0.24564099f, -0.20630434f, 0.13428520f, 0.00585164f, 
    -0.20630318f, -0.20372875f, 0.05585003f, 0.02558092f, 0.32762122f, 0.01791628f, 0.18393703f, -0.13333476f, 
    -0.66786772f, 0.06508069f, 1.06885517f, -0.01709099f, -0.90737867f, 0.35226837f, -0.33571577f, -0.84246135f, 
    0.04239053f, 0.63020480f, 0.43155289f, -0.27669147f, 0.14305960f, 0.18747714f, -0.13962764f, 0.08782292f, 
    -0.21540324f, 0.08571339f, 0.15276422f, -0.36035070f, -0.15753751f, 0.38021564f, 0.22725840f, -0.10361277f, 
    -0.20756452f, -0.02473183f, 0.31823254f, 0.47016412f, 0.23693004f, 0.75147820f, 0.93757653f, 0.94617885f, 
    0.18345927f, 0.14195697f, 0.18678802f, 0.20150135f, -0.01303197f, -0.37326416f, -0.22957906f, -0.30569923f, 
    -0.27649733f, -0.23439276f, 0.13423754f, 0.42013308f, -0.02031460f, 0.50746739f, 0.10355734f, 0.27151734f, 
    0.09263808f, -0.87804365f, -0.91056770f, -0.24075817f, -0.00201212f, 0.11782487f, 0.00433323f, 0.56974930f, 
    -0.34721014f, 0.38453490f, -0.45468929f, -0.19877371f, -0.19306338f, -0.20278712f, 0.56139493f, 0.33157337f, 
    -0.32657394f, -0.20347266f, -0.67935592f, -0.51327735f, -0.40932235f, 0.08078293f, 0.35030219f, -0.14314087f, 
    0.33425924f, -0.11220724f, 0.89580274f, 0.35496837f, 0.98545843f, 0.70763415f, 0.08782238f, 0.79901206f, 
    -0.37761718f, 0.21039233f, -0.16210382f, -0.49112344f, 0.11768360f, 0.16138603f, -0.27866015f, 0.21377113f, 
    0.11084384f, 0.61370134f, 0.09599477f, -0.28315037f, 0.08236951f, 0.18905981f, -0.11888687f, -0.17501117f, 
    0.30230519f, -0.31396779f, 0.40554297f, -0.70861757f, -0.38088244f, -0.58624709f, -0.12351099f, -0.71743524f, 
    0.80453718f, 0.67579460f, -0.69542038f, 0.63004905f, 0.61213928f, 0.39493668f, -0.09397606f, 0.25840613f, 
    -0.18801995f, -0.28742468f, 0.14008968f, 0.01800245f, 0.11091410f, -0.00664544f, 0.03758623f, -0.05340279f, 
    -0.35400474f, 0.02035287f, 0.33083835f, -0.16263203f, 0.50507081f, -0.99969000f, -0.80585164f, 0.27743176f, 
    1.17257571f, -0.18893144f, 0.39113629f, 0.66038853f, 0.25102273f, -0.15922935f, 0.01598075f, 0.01173500f, 
    -0.61300838f, 0.02980036f, -0.05555749f, 0.11309764f, -0.09550589f, 0.00497558f, -0.09045710f, -0.12977821f, 
    0.04571097f, 0.02334199f, 0.06686186f, 0.04236258f, -0.10409943f, 1.11612427f, 0.30803096f, 0.01232837f, 
    0.83849370f, 0.21457060f, -0.11872352f, 0.14550349f, -0.51126891f, 0.83618963f, 0.46727791f, 0.02347640f, 
    0.34191686f, -0.41933990f, 0.56122661f, -0.43522066f, -0.13306478f, -0.34008548f, -0.39402011f, -0.02060557f, 
    -0.50271231f, 0.27925318f, 0.44705829f, 0.03722534f, -0.07425299f, 0.11463395f, 1.32874787f, 1.11997020f, 
    -0.35635406f, -0.05775730f, 0.26672119f, -0.57670087f, 0.72097242f, -0.24875116f, 0.23581678f, -0.36108083f, 
    0.04288078f, 0.05370079f, 0.03293691f, -0.04046795f, -0.31221771f, -0.03051936f, -0.04349433f, 0.13803802f, 
    -0.02038159f, -0.19544746f, -0.41749045f, -0.01693263f, -0.01138782f, 0.22750972f, -0.31830281f, -0.05191942f, 
    -0.10303273f, -0.17572072f, -0.09105401f, -0.40570888f, -0.63470083f, -0.55083793f, -0.02886319f, -0.66821289f, 
    -0.63606489f, 0.04147026f, 0.26621047f, 0.68973190f, 0.15419935f, 0.48169711f, 0.19173424f, 0.00458822f, 
    -0.24937020f, 0.09540260f, -0.20137756f, 0.39609662f, 0.19149430f, 0.36296552f, 0.47235230f, 0.21077089f, 
    -0.49562246f, -0.65030491f, -0.84649456f, -0.63030773f, 0.18855557f, -0.74304110f, 0.29393527f, 0.43937182f, 
    0.52059770f, -0.17063393f, -0.50103760f, -0.40202686f, 0.02317086f, 0.05784083f, -0.14129025f, 0.41362664f, 
    0.24440446f, -0.08195311f, 0.11290704f, 0.17303032f, 0.59328210f, -0.06862256f, 0.44289365f, 0.29960856f, 
    0.14916202f, 0.72611374f, -1.16460776f, 0.11149500f, 0.66609091f, -0.29269144f, 0.61026484f, 0.85153949f, 
    0.19407104f, 0.70908290f, -0.36336818f, -0.52489477f, 0.32728815f, -0.01837699f, 0.21996018f, 0.23641951f, 
    -0.53641987f, -0.43987104f, -0.18910047f, 0.10450155f, 0.07988831f, -0.05645216f, 0.27539334f, 0.17646006f, 
    -0.01036784f, -0.24352652f, -1.19092941f, 0.49407652f, 0.17198877f, -0.27074111f, 0.68450433f, -0.62550926f, 
    0.45353952f, -0.25403866f, -0.52837127f, -0.50436348f, 0.01525060f, 0.68983650f, 0.75379288f, 0.15872738f, 
    -0.18666196f, -0.04881555f, -0.04192564f, 0.26840571f, 0.21659425f, 0.27325502f, -0.20068593f, -0.32537651f, 
    -0.30087575f, -0.09590634f, -0.09105471f, -0.52932805f, -0.26719388f, -0.25903642f, -0.72470790f, -0.63879138f, 
    -0.32003227f, -0.79304522f, -0.44676855f, -0.15357213f, -0.32801864f, 0.35875425f, 0.06032461f, 0.21158989f, 
    0.45280266f, 0.41966599f, -0.39103395f, 0.02427937f, 0.03774628f, 0.33458051f, 0.37000513f, 0.06723753f, 
    0.38988438f, -0.36655647f, 0.33053628f, -0.13925509f, 1.26430666f, -0.47718632f, -0.45402843f, -1.03131139f, 
    -0.30296037f, 0.75223005f, -0.14182098f, -0.09626658f, 0.47473416f, 0.05952024f, 0.10555241f, 0.28626060f, 
    -0.49531537f, 0.14863899f, 0.18942967f, 0.09125948f, -0.12905946f, 0.07425691f, -0.02158620f, 0.29252750f, 
    0.10243513f, 0.05831762f, -0.07377490f, -0.10380023f, 0.21975265f, 0.59936309f, 0.58571225f, 0.22704642f, 
    0.55965751f, -0.82447982f, -0.52471608f, -0.72348052f, -0.17824952f, -0.44995791f, -0.24616522f, 0.02251924f, 
    0.55036825f, 0.25610289f, 0.10359906f, -0.31906840f, -0.03520821f, -0.19054961f, 0.14063209f, 0.15477704f, 
    0.20600331f, 0.27052334f, 0.15647601f, -0.18954633f, 0.12215178f, 0.06234586f, -0.80520087f, -1.10475075f, 
    -0.44412684f, 0.25901893f, 0.28251034f, 0.65429342f, 1.04905128f, 0.25133777f, -0.02025081f, 0.46076387f, 
    -0.39224565f, -0.40460604f, 0.19044144f, -0.24605109f, 0.03555905f, -0.13559994f, 0.25575769f, 0.32188874f, 
    0.23742069f, -0.32334459f, 0.02103055f, -0.47367713f, -0.56991911f, 0.14975812f, 0.22558801f, -0.69827533f, 
    0.96656746f, 0.28962320f, -0.07869274f, 0.56134927f, 0.75426137f, -0.67822164f, -1.05358934f, -0.43452361f, 
    -0.76336747f, 0.00925508f, -0.02116785f, 0.24157844f, 0.40965849f, -0.27691704f, -0.23255709f, -0.25829300f, 
    -0.07542464f, -0.35217604f, 0.05377066f, -0.28974909f, 0.09760807f, 0.04605717f, -0.10807463f, -0.14781730f, 
    -0.78692377f, -1.09543633f, 0.68175912f, 0.43442726f, -0.34614071f, 0.71146524f, 0.41389012f, 0.43920875f, 
    -0.66635638f, -0.74961704f, 0.02619309f, -0.36282590f, 0.18193382f, 0.29967496f, 0.02112691f, -0.11427660f, 
    0.37421691f, -0.00281287f, -0.12415057f, 0.17803493f, -0.01664149f, 0.32686684f, 0.05049528f, -0.08749607f, 
    -0.16485585f, 0.05060656f, 0.60974830f, 1.03706157f, 0.50477403f, 0.03388961f, -0.24006981f, 0.25209090f, 
    -0.29675665f, 0.13323538f, 0.14558066f, 0.50493520f, 0.35510075f, -0.66894823f, -0.64789915f, 0.06093910f, 
    0.40395051f, -0.48706052f, -0.32445341f, -0.36822620f, 0.28334394f, -0.23957141f, -0.14041343f, 0.37510380f, 
    -0.11451109f, -0.17218538f, 1.02000451f, 0.09176289f, 0.16231307f, 0.10716905f, 0.69006544f, -0.12637229f, 
    -0.86710840f, 0.04220200f, -0.09666779f, 0.08973337f, 0.00584182f, -0.04531970f, 0.35261354f, 0.03239296f, 
    -0.16636959f, 0.33441612f, 0.26375678f, 0.51640290f, 0.59472048f, 0.21331485f, -0.40738380f, 0.34575236f, 
    0.37884718f, -0.50611597f, -0.25907290f, 0.72518772f, 0.10041603f, 1.13225520f, -0.74728107f, -0.00315584f, 
    -1.06937027f, 0.09276895f, -0.45885056f, -0.31819418f, -0.41843620f, 0.04951534f, 0.17018758f, -0.29296613f, 
    -0.11937311f, 0.45924860f, -0.39063653f, -0.21920931f, -0.02722373f, -0.01638085f, 0.26872587f, -0.08243053f, 
    0.27841532f, -0.02364831f, -0.15855390f, 0.07264903f, -0.54286397f, 0.18105111f, -0.23062652f, -0.71078801f, 
    -0.77953523f, 0.98079395f, 0.89613801f, 0.42026880f, 0.34218985f, -0.09961339f, -0.24805778f, -0.37879255f, 
    -0.87025607f, -0.45114076f, 0.31103042f, 0.10774413f, 0.35455176f, -0.17818865f, 0.01417342f, 0.09565881f, 
    -0.09741715f, -0.24900815f, 0.20471635f, -0.19112852f, -0.15961654f, -0.65112901f, -0.96366304f, -0.76310915f, 
    -0.76693922f, -0.24896736f, 0.28046018f, -0.64903152f, -0.48287353f, -0.17353751f, -0.20239364f, -0.34529775f, 
    0.16608237f, 0.24156177f, -0.25631839f, -0.22930914f, 0.42611992f, 0.13036659f, 0.14851427f, 0.01053418f, 
    -0.14747995f, -0.09475239f, 0.14240597f, -0.08748866f, -0.16314037f, 0.00509794f, 0.89973253f, -0.21090397f, 
    0.01360967f, 1.46110499f, 0.60109162f, -0.31023550f, -0.38073698f, 0.43097657f, 0.10840606f, 0.44706288f, 
    -0.04130411f, -0.13334918f, 0.23254079f, -0.26163259f, 0.18277435f, 0.13419071f, -0.00271841f, 0.13167869f, 
    -0.18083864f, 0.13928847f, 0.32065615f, 0.27615160f, -0.21363246f, 0.40406108f, 0.20887554f, 0.54511535f, 
    0.33428189f, -0.61324322f, 0.64320582f, 1.13219893f, 0.44003889f, -0.39065498f, -0.76355767f, -0.20871502f, 
    0.09995001f, -0.19246778f, 0.52099991f, -0.07874745f, -0.23914954f, 0.24957265f, -0.10200130f, -0.40721124f, 
    0.06196377f, 0.17959794f, 0.49094480f, 0.13078111f, -0.17264847f, -0.08037268f, -0.23083633f, -0.15908393f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02659509f, 0.02013373f, 0.24486923f, 0.21832207f, 0.14319064f, 0.17153753f, 0.14128317f, 0.19304135f, 
    -0.07989620f, -0.13661237f, 0.17208771f, 0.06442843f, 0.13797756f, 0.22985782f, 0.11552291f, 0.20080556f, 
    0.17632890f, -0.04304881f, 0.19442295f, 0.25688186f, 0.36612159f, -0.00040121f, 0.11634457f, -0.01909991f, 
    0.08288202f, 0.03018341f, 0.12059014f, 0.18176091f, -0.02642704f, 0.38062021f, 0.08054139f, 0.19100368f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.09331353f, 0.10036988f, -0.07971521f, 0.11823399f, -0.03934081f, 0.02313011f, -0.01039178f, -0.04443678f, 
    -0.05147504f, -0.20696153f, 0.00316434f, 0.06821270f, 0.01893275f, 0.07446121f, -0.04623441f, -0.12691163f, 
    -0.09697619f, -0.03444443f, 0.01290062f, -0.01121993f, -0.02351203f, 0.00073551f, 0.14555144f, -0.08785915f, 
    -0.23511787f, -0.00562282f, -0.29596108f, 0.45519137f, 0.04646503f, -0.01549593f, 0.13028508f, -0.00301617f, 
    -0.03785913f, 0.04521512f, -0.01024940f, 0.00523530f, 0.08814609f, -0.00822856f, 0.05889487f, 0.35093337f, 
    -0.26740944f, -0.19504173f, 0.08244920f, 0.00128378f, -0.14426319f, 0.10884218f, -0.15549475f, -0.07442892f, 
    0.04260343f, 0.13711631f, -0.19988596f, 0.26285461f, -0.24787264f, 0.16004047f, -0.12179555f, -0.18434063f, 
    0.09232789f, -0.12986869f, 0.07060808f, -0.17224681f, -0.25486735f, 0.18308899f, 0.14407396f, -0.29708344f, 
    -0.07733510f, -0.03390212f, 0.11095212f, -0.08002013f, -0.09375017f, -0.06672260f, -0.01462334f, 0.01643444f, 
    -0.68775523f, 0.22190706f, -0.08023624f, -0.02455634f, 0.01098176f, 0.06789131f, -0.14037608f, 0.09195407f, 
    -0.03262448f, 0.08959431f, -0.08285610f, 0.03102221f, 0.17338662f, -0.18412529f, -0.18486580f, 0.35774681f, 
    0.00456864f, -0.00243500f, -0.07566691f, -0.07126331f, -0.00537632f, 0.07913062f, 0.03046761f, -0.00668848f, 
    -0.30619040f, 0.21307600f, 0.07948028f, 0.10383550f, 0.00568022f, 0.12071105f, 0.06514636f, -0.14327976f, 
    -0.06984097f, 0.08673100f, -0.10572819f, 0.03713535f, -0.24692439f, 0.03428449f, 0.01499700f, -0.14809951f, 
    0.22836874f, -0.03308662f, 0.02216839f, 0.00714405f, 0.12589984f, -0.11413728f, -0.04868035f, -0.01430510f, 
    0.04126759f, -0.16872311f, -0.21667059f, 0.09884623f, -0.17275216f, -0.03245598f, 0.02595099f, 0.21521021f, 
    0.05866689f, -0.03925121f, -0.07138546f, -0.21379262f, 0.60046685f, 0.16898811f, -0.20994411f, -0.37855321f, 
    -0.07267907f, 0.02225397f, 0.04504869f, 0.05880551f, -0.01057801f, -0.07891906f, 0.04374405f, -0.07093709f, 
    -0.18579067f, 0.35420915f, 0.01043789f, -0.00088199f, -0.09651856f, 0.10010847f, -0.00660416f, -0.07534682f, 
    -0.09800205f, -0.05270982f, 0.06575205f, -0.15369837f, 0.19167124f, -0.08839172f, -0.14128120f, 0.34430024f, 
    0.03840224f, -0.11890744f, -0.11444348f, 0.04731464f, -0.05204548f, 0.05141717f, 0.11853839f, -0.09470859f, 
    0.01990561f, 0.24499716f, 0.12692496f, -0.29612729f, -0.26204273f, -0.06045147f, -0.05559841f, 0.16657120f, 
    -0.00519458f, 0.00525377f, 0.06020734f, -0.26290166f, -0.34206709f, -0.02685102f, 0.06740734f, 0.13041741f, 
    0.09062079f, 0.09313390f, 0.12711297f, -0.08358343f, -0.03477729f, 0.13278618f, 0.04343082f, 0.04883399f, 
    -0.36367676f, 0.29904184f, -0.27540717f, -0.23105790f, -0.02756801f, 0.11751521f, 0.03560099f, 0.13113181f, 
    0.06478836f, 0.13893762f, 0.02737334f, 0.08960043f, 0.00753323f, 0.03533803f, -0.33304745f, 0.14249778f, 
    -0.04613290f, -0.03868787f, -0.00503114f, 0.05146056f, 0.06622548f, 0.01110050f, 0.23218103f, -0.04763864f, 
    -0.63600415f, -0.39530298f, 0.11419582f, -0.03259882f, 0.06957003f, 0.05741926f, 0.05314519f, 0.00761559f, 
    0.15839919f, -0.07056730f, -0.11293079f, -0.04523744f, -0.55604142f, -0.28641900f, 0.07133937f, 0.04573850f, 
    -0.11190271f, 0.09996200f, 0.20391288f, -0.12361539f, 0.10957529f, -0.03251447f, 0.04411507f, 0.11126634f, 
    0.16001230f, -0.34883261f, 0.15902834f, -0.45965415f, -0.14481406f, 0.03810322f, -0.01705737f, 0.03240904f, 
    -0.04446199f, -0.09828274f, 0.04895967f, 0.01926143f, 0.10886038f, 0.06839739f, 0.15226120f, 0.11265454f, 
    0.00929792f, 0.05489387f, -0.16587214f, 0.00083320f, 0.07428233f, -0.05616443f, -0.14161476f, 0.02737850f, 
    0.09085271f, 0.04191336f, 0.06522828f, 0.07541250f, 0.19260107f, -0.00144339f, -0.01823718f, 0.10042020f, 
    0.05143921f, -0.08299582f, -0.18017769f, 0.12369828f, -0.30417895f, 0.21970536f, 0.13980147f, -0.18557911f, 
    -0.05374841f, -0.17574896f, 0.03007047f, -0.19297917f, 0.05550299f, -0.05663978f, -0.02119288f, 0.01587096f, 
    -0.36795914f, 0.16698091f, 0.21651542f, 0.10955020f, 0.10416359f, 0.11909597f, -0.09731673f, -0.00021619f, 
    -0.12981088f, -0.02447939f, 0.10288110f, -0.06048167f, -0.08718210f, -0.00866478f, 0.08857803f, 0.24526991f, 
    -0.11826576f, 0.01254456f, 0.02863564f, -0.06077333f, 0.15042609f, 0.04464876f, 0.14683929f, -0.16815461f, 
    0.27295679f, -0.24568781f, 0.07630932f, -0.13804692f, -0.18501016f, 0.17053713f, -0.18581478f, 0.03716568f, 
    0.02664391f, -0.07908637f, -0.08005275f, -0.07961316f, 0.22597116f, 0.27674982f, -0.08021161f, -0.17618962f, 
    -0.05393836f, 0.09835561f, -0.09960039f, 0.06321454f, -0.09209234f, -0.22007023f, -0.03508101f, 0.02869972f, 
    0.30822623f, 0.25824827f, 0.22654262f, -0.27586657f, -0.06465324f, 0.24096419f, -0.00337379f, 0.08542395f, 
    -0.02031099f, -0.05003900f, -0.02942597f, 0.08013186f, -0.14195642f, -0.53627425f, 0.13281453f, -0.23951301f, 
    -0.06390948f, -0.10936042f, 0.03657519f, -0.04996520f, -0.11105619f, -0.06387176f, -0.03654417f, -0.10779285f, 
    0.23964955f, -0.10765114f, -0.13962632f, 0.55559862f, 0.07579134f, 0.09910519f, -0.04524344f, -0.05471759f, 
    -0.21888490f, -0.06092377f, 0.02426928f, 0.06208006f, 0.27388749f, -0.26970163f, 0.36466441f, -0.03340843f, 
    -0.23839425f, 0.01181168f, 0.12633760f, -0.04308481f, 0.02713409f, -0.05714518f, 0.01766607f, -0.01159461f, 
    -0.17940967f, 0.08767048f, -0.11461550f, -0.14470500f, 0.10615891f, 0.04751511f, -0.12150712f, -0.17926717f, 
    -0.09819401f, 0.16678452f, -0.07267660f, -0.00904562f, 0.01696249f, 0.05954638f, 0.27967763f, 0.12388430f, 
    0.02928498f, 0.04673024f, -0.04725523f, 0.01512704f, 0.07976509f, 0.08048913f, -0.01425811f, 0.01842957f, 
    -0.44082835f, 0.33341193f, -0.07613809f, 0.02606997f, -0.14421532f, 0.06855799f, -0.16010299f, -0.15428582f, 
    -0.05996070f, -0.24509822f, -0.04299856f, 0.03409570f, 0.46847039f, -0.03584279f, 0.21392405f, 0.12481432f, 
    -0.13588160f, 0.14943148f, -0.09389514f, 0.04845203f, -0.04530161f, -0.17850401f, 0.17699917f, -0.15059601f, 
    0.08447590f, -0.09674771f, -0.02218798f, 0.10417293f, -0.07901775f, 0.01611897f, -0.09021059f, 0.13844649f, 
    0.05227372f, 0.16503589f, -0.11989872f, 0.10990036f, -0.26169363f, -0.21265967f, -0.11165949f, -0.51986814f, 
    -0.07686470f, -0.02946021f, 0.08330657f, -0.02317970f, -0.02251498f, 0.08679666f, 0.11536586f, -0.02285577f, 
    0.47336721f, -0.19490843f, -0.30521289f, 0.26231825f, -0.13418327f, 0.01140750f, 0.00203860f, 0.04535250f, 
    0.07617115f, -0.20428279f, -0.05269367f, 0.03566176f, -0.37471312f, -0.15442950f, -0.14486377f, 0.12348326f, 
    -0.02087114f, -0.02644850f, 0.02204347f, -0.11037634f, 0.00885351f, -0.04837777f, 0.03099035f, 0.03628809f, 
    0.02397476f, 0.21993381f, 0.09328843f, 0.14807899f, -0.00996346f, 0.05633221f, -0.11121021f, 0.01833003f, 
    0.01654514f, 0.06697587f, -0.04858535f, 0.16081634f, 0.14522165f, -0.00355815f, -0.19747099f, 0.06196468f, 
    -0.06760810f, 0.09697942f, -0.07694530f, -0.05000137f, -0.04931057f, -0.04635103f, -0.31385970f, -0.12098518f, 
    0.07777044f, 0.16842711f, 0.18211655f, 0.11409663f, -0.13428780f, 0.11954990f, -0.03954981f, -0.04026624f, 
    -0.03214190f, 0.03195400f, -0.01821580f, 0.16250668f, -0.27677348f, -0.23389128f, 0.06886061f, 0.04040310f, 
    0.08201628f, -0.15756157f, 0.08411154f, -0.06897933f, -0.03777249f, -0.00863834f, 0.07839242f, 0.22023402f, 
    0.23562430f, -0.51363760f, 0.11974873f, -0.03511158f, -0.04249298f, 0.11560177f, -0.11862676f, 0.09474561f, 
    0.04025278f, 0.13721904f, 0.02142641f, -0.04940170f, 0.35727316f, 0.01152403f, 0.11378428f, 0.25604773f, 
    -0.09864683f, -0.02829211f, 0.05056421f, 0.02736289f, 0.01762559f, -0.10018186f, -0.28888980f, -0.05260165f, 
    0.47607255f, 0.03238910f, -0.02162229f, -0.02436357f, -0.10956571f, 0.02034049f, 0.01240552f, 0.04411300f, 
    -0.00582115f, -0.11060773f, -0.06362849f, 0.31303304f, -0.16972254f, -0.12646683f, -0.08815416f, -0.06316328f, 
    0.01635185f, -0.01113139f, -0.06462765f, 0.02385579f, 0.00698977f, -0.03347886f, -0.12547877f, 0.00719793f, 
    0.13109270f, 0.00937761f, 0.11730979f, -0.29392907f, 0.05323076f, -0.05296407f, -0.10972184f, 0.07041066f, 
    0.10495225f, -0.01804012f, -0.08631229f, 0.14446299f, 0.55606854f, -0.46372807f, 0.01669378f, 0.02774677f, 
    -0.05918802f, 0.03040685f, 0.05036229f, -0.06204424f, -0.07424707f, 0.02894508f, -0.13050009f, 0.06569460f, 
    -0.14518891f, 0.11921688f, -0.06056122f, -0.29106867f, -0.09526049f, 0.07391363f, -0.06944707f, -0.22898443f, 
    -0.04614701f, -0.08526426f, 0.18182698f, -0.02864217f, -0.09136008f, 0.00418404f, 0.07754054f, 0.01869620f, 
    -0.04366079f, 0.02151700f, -0.12295365f, 0.00189961f, 0.06832427f, 0.15859319f, 0.03849456f, 0.02723223f, 
    0.23529784f, -0.43872648f, 0.10653457f, -0.35475060f, 0.14648229f, 0.15676688f, -0.04374715f, 0.06437159f, 
    -0.16854690f, 0.08272430f, 0.02997710f, 0.02725987f, -0.07182854f, -0.19618186f, -0.23569714f, 0.03884089f, 
    -0.10435198f, 0.05331569f, -0.07421084f, 0.08881114f, -0.05508380f, 0.04750690f, 0.03608004f, 0.06814452f, 
    0.26664922f, 0.12800434f, -0.22373071f, -0.00209912f, 0.03446671f, 0.09315955f, -0.23336945f, -0.03521251f, 
    -0.00291263f, 0.05516683f, 0.13141787f, -0.10105850f, 0.10729472f, -0.28568849f, -0.05367611f, -0.34429744f, 
    0.03477729f, 0.06255752f, 0.10383993f, -0.18500198f, -0.06874879f, 0.07588505f, -0.02938353f, 0.03107579f, 
    -0.49632570f, 0.16234164f, -0.14973395f, 0.31404865f, -0.11677091f, -0.03946105f, 0.00296887f, -0.05015628f, 
    0.01446856f, 0.03768519f, -0.07903749f, -0.02673309f, -0.09098948f, 0.11364101f, 0.10144363f, 0.13005818f, 
    -0.12709440f, -0.06468812f, 0.10329333f, -0.03251718f, -0.17793243f, -0.21094711f, 0.00388324f, 0.02126930f, 
    0.09083248f, -0.14473994f, 0.17214814f, 0.08328326f, 0.18853337f, -0.24010076f, 0.21942416f, -0.03420082f, 
    -0.01721823f, 0.01207368f, 0.13947657f, 0.12526116f, -0.11648645f, 0.07546355f, -0.14757264f, 0.08242688f, 
    0.15976450f, -0.09557401f, -0.04307485f, 0.05408988f, 0.10339753f, 0.01636632f, -0.06182493f, 0.02176656f, 
    -0.40172455f, -0.14015137f, -0.16886207f, -0.16725585f, -0.01129414f, -0.11030177f, 0.02586669f, -0.17171192f, 
    0.20687971f, 0.08216799f, -0.21827115f, -0.02999732f, -0.00649868f, 0.20509350f, 0.13201548f, -0.03779583f, 
    0.04971762f, 0.02859415f, 0.13886297f, -0.10863373f, 0.12973419f, 0.03670426f, 0.06602038f, 0.03455776f, 
    0.11391225f, 0.05625737f, 0.02040300f, 0.38204810f, -0.23210172f, 0.04586397f, -0.06540531f, 0.06785018f, 
    0.14982325f, -0.02323781f, -0.03080243f, 0.14542629f, -0.03927216f, -0.29670286f, -0.10916917f, 0.04383560f, 
    0.05018296f, -0.14470580f, -0.10655425f, -0.00877286f, -0.10007732f, 0.04570720f, -0.04437915f, -0.05894442f, 
    0.34278283f, -0.05667345f, -0.31813526f, 0.20610940f, 0.14518589f, -0.01241744f, 0.00557197f, -0.07664371f, 
    0.11806256f, -0.08587662f, 0.03650996f, 0.00118527f, 0.02781308f, 0.32827088f, -0.05195783f, 0.23266897f, 
    -0.01504020f, 0.06664889f, 0.02676824f, -0.08712387f, -0.12749681f, 0.01455689f, -0.08103302f, -0.02192155f, 
    0.20507629f, -0.10978332f, -0.25887343f, 0.01433884f, -0.12780654f, 0.15122271f, -0.12264342f, 0.11694901f, 
    0.12779555f, 0.17025922f, -0.05336736f, -0.03207458f, 0.11224861f, -0.23785852f, 0.10310387f, -0.04104581f, 
    0.12454053f, 0.10645028f, 0.09865650f, -0.01945191f, -0.01138949f, 0.07041230f, -0.01645513f, 0.07132446f, 
    -0.17869151f, -0.11025994f, -0.47404432f, -0.30712730f, 0.05901872f, -0.04740221f, -0.07011481f, -0.00627670f, 
    0.02686511f, -0.03328661f, 0.12394518f, 0.02801852f, -0.37184370f, -0.11070457f, -0.03573424f, -0.29392263f, 
    0.09367373f, 0.04458005f, 0.07810967f, -0.15360306f, -0.09542466f, 0.02264424f, -0.00119577f, -0.14809693f, 
    0.70486295f, -0.07573755f, 0.23300177f, 0.30203566f, -0.27898556f, 0.02232134f, -0.08499010f, -0.01281251f, 
    -0.03235568f, 0.02859761f, 0.05325826f, 0.02207802f, 0.41470668f, -0.01696136f, -0.26861548f, -0.08521312f, 
    -0.08844779f, 0.11102551f, -0.15688077f, 0.00732241f, -0.05014348f, -0.07301084f, -0.02005361f, -0.06621325f, 
    0.10426512f, -0.00257264f, 0.13613436f, 0.11390208f, -0.02281978f, -0.17013766f, -0.01606103f, -0.01003367f, 
    -0.07536648f, -0.03677163f, 0.08761582f, -0.01198553f, 0.44482413f, -0.07969310f, 0.10168445f, -0.11171400f, 
    -0.17085639f, -0.08979541f, -0.00951113f, -0.13132808f, 0.12071304f, -0.06115726f, 0.03483117f, 0.00216066f, 
    -0.11691870f, -0.00532066f, -0.14337015f, -0.03717364f, 0.11236487f, -0.02987304f, -0.01790040f, -0.00489147f, 
    0.03545644f, 0.01867368f, -0.12906660f, -0.06336854f, 0.47079423f, -0.01488067f, 0.37252113f, 0.04706755f, 
    -0.00815829f, -0.14338839f, -0.05117987f, 0.12828644f, -0.00730947f, 0.19221842f, 0.04739991f, -0.23393661f, 
    0.25190288f, -0.21018752f, 0.04780073f, -0.03234387f, -0.01537217f, -0.00771380f, -0.03779008f, -0.03316660f, 
    0.11177852f, 0.01310791f, 0.00639457f, 0.01114888f, 0.16985115f, -0.08757766f, -0.02943853f, -0.13050885f, 
    0.05860158f, 0.03692326f, 0.07659627f, 0.03115196f, -0.08912691f, 0.14062645f, 0.02118640f, -0.11936145f, 
    0.20055744f, 0.06150933f, -0.17070517f, -0.27101326f, 0.15682840f, 0.00918496f, 0.10789990f, -0.01221223f, 
    -0.15168123f, 0.02905108f, 0.11315410f, -0.11366222f, 0.11568934f, 0.03878951f, -0.29350069f, -0.39730275f, 
    0.00065518f, 0.04572695f, -0.06255337f, 0.03307645f, 0.07464789f, -0.05904294f, -0.04263567f, -0.18840352f, 
    0.14972372f, 0.05510606f, -0.16195774f, 0.24946982f, -0.13379525f, -0.06192293f, -0.23847051f, 0.02192007f, 
    -0.03674274f, 0.01747168f, -0.03539580f, 0.11403630f, -0.10513489f, 0.09893315f, 0.04912556f, -0.06280027f, 
    -0.11139829f, -0.02963789f, -0.05285529f, 0.01372432f, -0.05865844f, -0.06256509f, -0.00560750f, -0.04026984f, 
    0.33171043f, 0.06204975f, -0.13475566f, -0.01150006f, 0.05693235f, -0.11663662f, -0.02368336f, -0.05256696f, 
    -0.16308682f, -0.04559118f, -0.09347332f, -0.03129703f, -0.43314427f, -0.02446032f, -0.11803511f, -0.25565001f, 
    -0.03189659f, -0.05206605f, -0.07214729f, 0.03838092f, -0.08289770f, -0.13844740f, -0.15305652f, 0.01958941f, 
    -0.28586772f, -0.03565157f, 0.06636239f, 0.01015595f, 0.07081550f, -0.02138054f, 0.11132508f, -0.05054532f, 
    0.04723054f, -0.12437139f, -0.00531507f, -0.04198803f, -0.73183119f, 0.11170006f, 0.00046338f, -0.24987411f, 
    -0.02304485f, 0.01773759f, 0.03096055f, -0.09395437f, 0.02246244f, 0.09480689f, -0.14250280f, -0.11294019f, 
    0.25615904f, -0.23696740f, 0.32584450f, 0.28088513f, -0.07340007f, -0.18655449f, 0.13327947f, 0.09384840f, 
    0.00056151f, 0.05955824f, -0.05909787f, 0.11175455f, 0.16161014f, 0.01360046f, -0.07776624f, -0.09457661f, 
    0.10391875f, 0.04906017f, 0.06655213f, -0.07286590f, -0.06675477f, 0.10565218f, -0.07662093f, 0.04343143f, 
    0.09756253f, -0.20247786f, 0.12250193f, -0.19838297f, -0.15441933f, 0.12819792f, -0.09801140f, -0.02282253f, 
    0.16849321f, -0.11972632f, -0.19976082f, -0.10599224f, 0.21257699f, 0.01017026f, -0.15208335f, -0.00212086f, 
    -0.08046985f, 0.09854209f, -0.00541493f, 0.03503408f, -0.09648775f, -0.18917997f, 0.09995189f, -0.18827610f, 
    -0.56809402f, 0.19416590f, 0.09353570f, -0.07779159f, 0.10279867f, 0.10969169f, -0.01947503f, 0.03252161f, 
    -0.08358362f, -0.00555737f, -0.02289414f, -0.10262168f, -0.16935261f, 0.15574625f, -0.37041542f, -0.26749265f, 
    0.08408581f, 0.02249899f, 0.03164186f, -0.02391613f, 0.06609296f, -0.11309175f, -0.06430963f, -0.01429298f, 
    0.35021204f, 0.08142955f, 0.08420630f, 0.19295296f, 0.00323217f, -0.12876324f, -0.02894745f, 0.23156816f, 
    -0.10408840f, -0.09089272f, 0.22537456f, -0.01800030f, -0.48556018f, -0.24112602f, -0.00920972f, -0.16763318f, 
    -0.02469046f, -0.28950685f, -0.19518909f, -0.05254837f, 0.02391665f, 0.08020453f, -0.11083411f, 0.01830326f, 
    0.05346673f, 0.12287825f, -0.11649852f, 0.04089695f, 0.15071762f, -0.13724178f, -0.03364136f, 0.08427812f, 
    0.00374590f, -0.04392990f, 0.04307142f, -0.09339536f, 0.01440354f, -0.19925196f, 0.18724054f, -0.15777060f, 
    0.14088951f, 0.05464840f, 0.09911237f, -0.17161615f, 0.02429860f, 0.06004701f, 0.06246005f, -0.10847565f, 
    -0.52381706f, 0.15101005f, 0.28349945f, 0.17223595f, 0.02614155f, 0.01322889f, 0.01201343f, -0.01488803f, 
    0.00787676f, 0.03625539f, -0.08268598f, -0.05359952f, -0.53869683f, -0.50539666f, -0.07444393f, 0.31280547f, 
    -0.00668165f, 0.08432095f, 0.08471336f, -0.04242940f, -0.05633244f, -0.05705855f, 0.00103023f, -0.13649133f, 
    0.29793102f, -0.03826722f, 0.08199339f, -0.16433541f, -0.09677736f, 0.13866238f, 0.04455304f, 0.18843846f, 
    -0.09847789f, 0.08397651f, 0.12430322f, 0.16573085f, -0.37068588f, -0.76083386f, -0.30975053f, 0.22044742f, 
    -0.17940895f, -0.01937557f, -0.07090901f, 0.01691819f, 0.02814415f, -0.07800472f, 0.04295835f, 0.02789298f, 
    -0.09490920f, -0.20016629f, 0.10195699f, 0.01256856f, -0.20838372f, 0.05969643f, 0.11488028f, 0.01899324f, 
    -0.02818831f, -0.11378980f, 0.25127736f, 0.01627789f, 0.25925201f, 0.05326312f, 0.07858928f, -0.03600342f, 
    -0.08866396f, -0.03209685f, -0.02180118f, 0.14889230f, 0.10787244f, 0.08289471f, -0.09368455f, -0.03141421f, 
    0.15851086f, -0.01831535f, 0.08085518f, -0.06193218f, -0.08818322f, -0.03677558f, 0.00496602f, -0.02174212f, 
    -0.08596084f, 0.07343306f, -0.12208684f, -0.00379109f, -0.40356249f, 0.03441552f, 0.20047654f, -0.08608259f, 
    0.09278452f, -0.00636094f, 0.05337133f, 0.12062522f, -0.03085904f, -0.07082713f, -0.07102766f, -0.17927018f, 
    -0.45167005f, -0.17825152f, 0.15172000f, -0.27346665f, -0.11154824f, -0.17277546f, -0.10471673f, 0.06390441f, 
    0.07938363f, -0.02147571f, 0.17567845f, -0.08313089f, 0.11718392f, 0.28733516f, -0.00043111f, 0.24126324f, 
    -0.05764294f, -0.07346331f, -0.02802832f, -0.05739521f, -0.00036397f, -0.02054230f, 0.10691999f, 0.09029626f, 
    -0.15358894f, -0.61160725f, -0.20051867f, 0.22482686f, -0.12674785f, -0.12883049f, 0.04961002f, 0.06272944f, 
    0.06681728f, -0.09379406f, -0.01557455f, -0.07932559f, 0.13385221f, 0.09972368f, -0.20283163f, -0.28539568f, 
    0.01773245f, -0.13889793f, 0.01089494f, 0.03598569f, -0.03074669f, -0.08722896f, 0.03476123f, 0.04537016f, 
    -0.09138467f, 0.16958615f, 0.10577891f, 0.23692282f, -0.06635355f, 0.13078693f, 0.12583034f, -0.20762855f, 
    -0.10968158f, 0.06905308f, 0.03247364f, -0.02804694f, 0.00785901f, -0.31169641f, -0.29008040f, -0.12037113f, 
    0.03160719f, -0.03717951f, 0.02251468f, -0.19090222f, 0.13653889f, 0.05780194f, 0.21082671f, 0.10529324f, 
    -0.14375155f, -0.31323013f, -0.04831173f, -0.22126001f, -0.15804714f, -0.00937620f, -0.01001021f, 0.08788236f, 
    -0.17951784f, 0.08608025f, 0.12620333f, 0.04333216f, 0.18371847f, -0.05191105f, 0.17112954f, 0.02250496f, 
    -0.01434868f, -0.01496612f, -0.05983801f, -0.06818048f, 0.16218114f, 0.16022268f, 0.10705063f, -0.06183288f, 
    0.04324798f, 0.03125222f, -0.01908336f, 0.09933531f, -0.10666045f, -0.17710587f, 0.06098919f, 0.04003374f, 
    -0.21190012f, -0.04856807f, -0.07445893f, -0.04376363f, 0.04159901f, -0.05541352f, -0.11459391f, -0.06507418f, 
    -0.00747671f, 0.07836709f, -0.07821208f, 0.00324347f, 0.07221236f, -0.00760066f, 0.05966188f, -0.01213343f, 
    -0.17650342f, 0.32541415f, 0.29049531f, 0.04520825f, 0.08302165f, 0.14116584f, 0.06688440f, 0.10456812f, 
    0.05639745f, 0.12223838f, -0.32165688f, 0.10108200f, 0.05352879f, 0.16217498f, 0.00585919f, 0.02740932f, 
    0.01368818f, 0.08368154f, -0.06477095f, 0.08565978f, -0.04853052f, -0.05123117f, 0.02670232f, 0.10617571f, 
    -0.02813926f, -0.13384691f, 0.02913655f, 0.05447815f, -0.05083648f, -0.00881290f, 0.04495699f, -0.03178737f, 
    0.00206988f, 0.18218909f, -0.08405767f, -0.00007902f, 0.25650710f, -0.39405420f, 0.00671856f, 0.20219579f, 
    0.04455788f, 0.13832875f, -0.05778925f, 0.17461310f, 0.08319755f, 0.15453114f, -0.17248286f, 0.08547761f, 
    -0.09666285f, -0.10201278f, -0.03210845f, -0.13323003f, -0.12505919f, -0.22461741f, 0.16305719f, 0.03414599f, 
    -0.06118841f, -0.05135649f, -0.08056834f, -0.07104336f, 0.85444486f, 0.04883168f, 0.01592758f, 0.22901191f, 
    0.10446607f, 0.00128478f, -0.09326378f, 0.17314965f, 0.06983642f, 0.12002306f, 0.04751424f, -0.08573110f, 
    0.26664335f, -0.17875046f, -0.03442119f, -0.01577453f, -0.01964653f, 0.01216247f, -0.07855073f, 0.04558750f, 
    -0.04659008f, -0.06647148f, -0.10109058f, 0.10583375f, -0.57185489f, 0.10778890f, -0.14801742f, 0.07279702f, 
    -0.02296733f, 0.02381930f, -0.02934987f, 0.06836967f, -0.06690755f, 0.10141313f, 0.09204833f, -0.13896938f, 
    0.14417613f, -0.09867891f, -0.01315423f, 0.02175961f, -0.01490091f, 0.21900699f, 0.09235684f, -0.13319916f, 
    0.12485462f, -0.06313429f, -0.12319782f, 0.02198070f, -0.21907242f, 0.36412546f, -0.09187875f, 0.13047826f, 
    0.15432940f, 0.07163617f, 0.02407743f, 0.01248333f, 0.04568636f, -0.00503029f, 0.06592610f, -0.17805842f, 
    -0.33009177f, -0.10553541f, -0.00166806f, -0.20402299f, -0.13144286f, -0.04938079f, 0.01648944f, 0.06362952f, 
    -0.05312036f, -0.12853664f, 0.09361868f, 0.00876243f, 0.09466895f, -0.00705333f, -0.12171076f, 0.01424641f, 
    -0.15420347f, -0.16492894f, -0.01192100f, 0.07997495f, -0.09208241f, -0.04555199f, 0.02570169f, 0.01570812f, 
    0.17651901f, -0.06652801f, -0.19504586f, 0.10248557f, -0.19018368f, -0.05049556f, 0.09909429f, -0.22333936f, 
    -0.05984075f, -0.07572687f, -0.01827223f, -0.16196384f, 0.23111530f, -0.11434070f, 0.01606480f, 0.22413266f, 
    0.01137692f, 0.13612475f, -0.13025506f, -0.08761995f, -0.02839432f, -0.01078238f, -0.00892787f, -0.14620923f, 
    -0.32407427f, 0.18497732f, 0.07912920f, 0.10246365f, -0.07860509f, -0.16407079f, -0.00061367f, -0.00189733f, 
    -0.00562129f, -0.13384587f, 0.02568101f, -0.00885869f, -0.46930638f, -0.43726352f, -0.09701259f, 0.29170209f, 
    -0.23934394f, -0.19953120f, 0.00429983f, -0.16872492f, 0.06303221f, 0.12156572f, -0.06778792f, -0.22813991f, 
    0.02378040f, -0.23413149f, 0.06017341f, -0.14556924f, 0.02112241f, 0.01665585f, -0.03879603f, -0.02587107f, 
    0.02389418f, 0.11152995f, -0.12629098f, 0.13764839f, 0.10882680f, 0.21727128f, -0.11175888f, -0.02544436f, 
    0.03524468f, 0.04488660f, 0.02001466f, 0.12753342f, -0.00802305f, 0.09144126f, -0.01109371f, 0.17014562f, 
    0.37100965f, 0.03022077f, 0.17802872f, -0.10216821f, 0.22103685f, 0.06001190f, 0.05770510f, -0.11771592f, 
    -0.07901306f, -0.06649311f, 0.13683504f, 0.14531539f, 0.30455154f, -0.06331103f, -0.09961487f, 0.11959191f, 
    -0.10176118f, 0.07594393f, 0.15473804f, 0.09790515f, 0.09690206f, 0.01091406f, 0.04142641f, -0.02708888f, 
    -0.70074201f, 0.07399871f, -0.17257726f, 0.04244537f, 0.15363392f, 0.08512408f, 0.08248281f, 0.10276669f, 
    -0.14772750f, 0.05452829f, 0.01153916f, 0.00026421f, -0.45724738f, -0.11181912f, 0.17198680f, -0.01479198f, 
    -0.01546924f, -0.05868510f, -0.04339401f, 0.00074853f, -0.00854015f, -0.01253125f, -0.16471785f, -0.06657117f, 
    -0.24745181f, 0.12921534f, -0.11834661f, 0.09983126f, -0.06193001f, 0.02649800f, 0.12310202f, 0.11159817f, 
    -0.07449085f, 0.03284355f, 0.18600830f, -0.26295838f, -0.14908430f, 0.00549962f, -0.26183504f, -0.21031250f, 
    0.02536604f, -0.00524222f, 0.06956197f, 0.15581274f, -0.01605423f, -0.10703967f, 0.04147838f, 0.08260841f, 
    -0.03799380f, 0.16185325f, 0.17245141f, -0.16649631f, -0.06482277f, 0.00697590f, -0.04460109f, 0.06434976f, 
    0.09867385f, -0.15187265f, 0.10644971f, -0.19069715f, -0.32059637f, 0.11096477f, 0.11573432f, 0.32806566f, 
    0.12832186f, 0.04160523f, -0.07185803f, 0.02981945f, -0.12116684f, 0.00638131f, 0.02132884f, -0.11086534f, 
    -0.00684446f, -0.16475804f, -0.39465779f, -0.02767803f, 0.04479702f, -0.09158659f, 0.08102214f, -0.09440938f, 
    0.03586337f, -0.03862474f, 0.14828338f, 0.04039460f, 0.00166216f, 0.07137797f, 0.06165835f, 0.17785421f, 
    -0.00410609f, 0.07232872f, -0.00734551f, -0.02302009f, 0.04064513f, -0.05209289f, 0.00155845f, 0.03220323f, 
    0.20787200f, -0.10861280f, 0.23718010f, -0.03673681f, -0.08725964f, -0.03616558f, -0.01250593f, 0.07300384f, 
    0.12663652f, 0.04252175f, -0.07281809f, -0.09003991f, 0.10645294f, -0.23315282f, 0.16466996f, 0.15285958f, 
    -0.07706026f, -0.12965722f, -0.15488575f, 0.02167883f, 0.02387295f, -0.06590034f, -0.04854896f, -0.11021709f, 
    0.09854100f, -0.06901490f, -0.12988888f, 0.28339440f, 0.11718019f, -0.21054858f, -0.04414879f, 0.06171776f, 
    0.00236410f, -0.11082813f, 0.09505546f, 0.00176398f, -0.56309217f, 0.47003418f, -0.03923053f, 0.06673176f, 
    -0.04026572f, 0.14604878f, 0.00856336f, 0.11849274f, -0.09240291f, 0.05414618f, 0.01938594f, -0.00323951f, 
    -0.28780666f, 0.32753360f, 0.20619842f, 0.08649960f, 0.01462625f, -0.10297991f, 0.18988352f, 0.06433941f, 
    0.00711795f, 0.10337663f, -0.22506192f, -0.06399852f, 0.32331204f, 0.08944814f, 0.13924779f, 0.00871530f, 
    0.09172738f, 0.07212853f, 0.10554762f, 0.19898579f, 0.05873004f, -0.17961513f, -0.06265844f, 0.06334549f, 
    -0.19821411f, 0.07206599f, 0.08821754f, 0.02615863f, -0.01671625f, 0.10637181f, 0.12222072f, -0.21999031f, 
    -0.08158879f, -0.09715818f, 0.01117148f, -0.03522898f, -0.33822963f, -0.33592346f, 0.07901451f, 0.09538892f, 
    -0.15174791f, 0.13819386f, -0.06184388f, -0.16204406f, 0.09493061f, -0.04845045f, 0.07457932f, -0.11334713f, 
    -0.79381734f, 0.07232424f, -0.16568586f, 0.07937866f, 0.00256387f, -0.15382093f, 0.01121892f, 0.01597088f, 
    0.00757487f, 0.12289088f, -0.06177977f, 0.23929736f, -0.28537279f, 0.44038814f, 0.16472241f, -0.19260344f, 
    0.01304727f, 0.13787061f, -0.05191252f, 0.16452843f, -0.01574219f, -0.04039576f, 0.20879804f, -0.00528250f, 
    -0.22526927f, 0.09617078f, -0.24431734f, -0.67744422f, -0.05201228f, 0.03884380f, -0.09599968f, 0.06176821f, 
    -0.01328141f, -0.02176085f, 0.00460893f, 0.15684462f, -0.27027828f, 0.08014606f, 0.12662187f, -0.21242113f, 
    -0.13023359f, 0.10112142f, -0.07090416f, 0.02978409f, -0.10443356f, 0.04264635f, 0.06310878f, -0.03233823f, 
    -0.00498738f, -0.16889869f, -0.16635445f, 0.24139021f, -0.09846561f, 0.03233627f, -0.15534461f, 0.06165402f, 
    0.18935283f, -0.08946213f, -0.04743480f, -0.09807643f, -0.20587267f, -0.35264358f, 0.21800193f, -0.03562293f, 
    -0.21569251f, -0.02134327f, 0.00908728f, -0.20637964f, 0.04665456f, 0.02809178f, 0.04909161f, -0.07679217f, 
    -0.04360004f, -0.04002545f, 0.17566811f, 0.22358115f, 0.11723060f, -0.06518660f, 0.17647736f, -0.07358499f, 
    0.08476929f, -0.00074040f, 0.03758018f, 0.26419854f, 0.04657097f, -0.13507281f, 0.10982156f, 0.26120433f, 
    0.07685547f, 0.02483761f, -0.03237440f, 0.27992237f, -0.04086394f, -0.04560396f, 0.06705254f, 0.10276943f, 
    0.29272270f, 0.01579544f, 0.04986587f, 0.15667598f, -0.12440108f, -0.09234774f, -0.00661561f, 0.01441825f, 
    0.07425050f, 0.02936294f, -0.11858492f, -0.29970378f, -0.02456954f, -0.05390256f, -0.06184449f, 0.11859185f, 
    -0.05024028f, 0.05930394f, 0.00193353f, 0.12453848f, 0.01355048f, -0.36113435f, 0.01389128f, 0.09196655f, 
    -0.02344372f, -0.15168509f, -0.02012676f, -0.02212882f, 0.09857906f, -0.02183581f, 0.10108584f, 0.07607007f, 
    -0.04931052f, 0.20740193f, 0.02308284f, 0.04695417f, 0.20136338f, 0.04442956f, 0.12714489f, 0.07597321f, 
    -0.34763706f, 0.01178122f, 0.01397997f, -0.01218974f, -0.06482486f, 0.03005704f, 0.08192603f, 0.32728994f, 
    0.06225832f, -0.25371459f, 0.01289749f, 0.02328545f, 0.11122999f, -0.02269678f, -0.00469833f, -0.06427050f, 
    -0.09175999f, -0.12646748f, 0.11372978f, -0.13024338f, -0.01766382f, -0.17323281f, 0.15159220f, 0.01429484f, 
    -0.03833124f, 0.00089762f, 0.03528138f, -0.00616494f, 0.07515893f, 0.03601307f, -0.07182772f, 0.07684935f, 
    -0.10558495f, 0.15543018f, -0.05857906f, -0.05754154f, -0.12605202f, -0.11927006f, -0.00607773f, 0.17682192f, 
    0.02693735f, 0.08589371f, -0.20145713f, -0.28368723f, -0.18647549f, 0.04598525f, 0.15936944f, 0.21305645f, 
    0.10015787f, -0.07149398f, -0.01708889f, 0.10060342f, 0.01151840f, -0.12828545f, -0.08671023f, -0.02167068f, 
    -0.84710366f, -0.04921772f, -0.22571521f, -0.16272642f, 0.20817919f, -0.03000952f, -0.10307904f, 0.01998438f, 
    0.17433767f, -0.08134390f, -0.07137130f, 0.02035976f, 0.03342850f, 0.08150335f, 0.19625756f, -0.34155306f, 
    0.12242074f, -0.06699883f, 0.07640798f, -0.04363402f, 0.02381288f, -0.17320310f, -0.07665482f, 0.13976446f, 
    0.03283625f, 0.15378189f, 0.08857565f, -0.19849084f, 0.10741328f, -0.03274429f, 0.17199489f, 0.09716494f, 
    0.10266878f, -0.02332981f, 0.08984578f, 0.10353717f, -0.62212950f, 0.01061160f, -0.14816424f, -0.08488163f, 
    0.00602093f, 0.03438250f, 0.23303153f, 0.21527573f, -0.05711619f, 0.21324193f, -0.13816048f, -0.12487711f, 
    -0.01595639f, 0.04290287f, -0.04142577f, 0.35280219f, -0.06708005f, 0.04887400f, 0.17114230f, -0.13973828f, 
    -0.06574881f, 0.03708856f, -0.09463719f, 0.26384383f, -0.36402538f, 0.02897224f, -0.21787807f, -0.07781170f, 
    0.03238569f, 0.13362619f, 0.01747707f, -0.24263935f, 0.04130623f, -0.15584832f, 0.08111793f, -0.17289899f, 
    -0.40724161f, 0.39286199f, -0.01440028f, -0.53149438f, 0.01529610f, -0.06560546f, -0.01798422f, -0.14151859f, 
    0.01765988f, -0.07444440f, -0.24537757f, -0.00321668f, -0.13623579f, -0.11463480f, -0.00691923f, -0.12591064f, 
    0.11474293f, -0.04434277f, 0.00521362f, 0.00107027f, -0.03560146f, -0.10665116f, -0.03114035f, -0.08034594f, 
    -0.04302831f, -0.16055706f, 0.06911933f, 0.32341310f, 0.03411879f, -0.12850507f, 0.11020662f, -0.15473497f, 
    -0.05870210f, -0.04962669f, 0.04878490f, 0.01300119f, -0.16763625f, 0.16083519f, 0.16365424f, 0.27651453f, 
    -0.06539495f, -0.01545238f, -0.01307950f, 0.19329987f, 0.04187707f, 0.00285500f, 0.03665275f, 0.15726842f, 
    0.00376131f, -0.18910170f, -0.23383002f, -0.04923579f, 0.14767665f, 0.20318484f, 0.05446389f, -0.07336465f, 
    0.11650186f, 0.02239324f, -0.02019820f, -0.18092723f, -0.20154385f, 0.28439185f, 0.09367942f, 0.04512534f, 
    -0.00610611f, -0.01257227f, -0.20915471f, -0.01872327f, -0.03107419f, 0.01062694f, -0.02140666f, -0.29270712f, 
    0.03894973f, -0.20970947f, -0.18791181f, 0.08699025f, 0.17008264f, -0.07470264f, -0.01473164f, -0.02206383f, 
    0.08107013f, 0.18253262f, 0.18972759f, 0.30765456f, -0.02679058f, -0.31212506f, -0.09269607f, 0.13056065f, 
    0.10440658f, -0.22118565f, 0.01816667f, 0.05224600f, 0.01301647f, 0.28669035f, 0.09928905f, 0.17187575f, 
    -0.07917132f, -0.09906130f, -0.26691085f, 0.07249652f, -0.21438336f, -0.13312578f, -0.02275930f, 0.02955889f, 
    0.21864988f, 0.04639312f, 0.04281021f, 0.03643941f, 0.18085775f, 0.29995862f, 0.09238554f, 0.05174257f, 
    -0.06952950f, -0.01412062f, 0.17085664f, 0.06908786f, -0.26493424f, -0.12160029f, 0.13851272f, 0.05236157f, 
    -0.12949230f, 0.44664821f, -0.07278937f, -0.24214654f, 0.00398310f, 0.21719466f, -0.19059159f, -0.20158887f, 
    0.05781262f, -0.23559722f, 0.00869075f, -0.24942166f, -0.09635711f, -0.39719531f, 0.22540942f, 0.33487049f, 
    -0.27870056f, -0.00512802f, 0.17374000f, -0.03712531f, -0.17233148f, -0.04007357f, -0.09237695f, 0.07403771f, 
    -0.53781599f, -0.11809804f, 0.09070433f, 0.04968658f, 0.16906522f, 0.00323945f, 0.11744462f, -0.04253565f, 
    0.00863483f, -0.04150719f, 0.11264189f, -0.01787269f, 0.11085054f, -0.03295221f, -0.08214972f, 0.24176864f, 
    0.09041960f, -0.01641803f, -0.07604536f, -0.03460078f, 0.16680489f, 0.10315067f, -0.32440045f, 0.20311604f, 
    0.06152292f, -0.04622103f, 0.06773893f, -0.05342897f, -0.05581473f, -0.29040229f, 0.02591012f, -0.02070599f, 
    0.10300394f, -0.06857884f, 0.15293373f, 0.27301991f, 0.03881179f, 0.12559791f, 0.18142618f, 0.16174528f, 
    -0.11926376f, -0.05740495f, 0.10795353f, 0.12420874f, -0.14775641f, 0.01527503f, 0.04740610f, -0.11231751f, 
    0.10299908f, 0.23431706f, -0.07550552f, -0.02740405f, 0.09127482f, -0.05986909f, 0.02769634f, -0.27538270f, 
    0.06792768f, 0.09335670f, -0.02414575f, -0.14938547f, -0.20854160f, -0.02153624f, -0.26691833f, 0.09170237f, 
    0.08721691f, 0.17813052f, -0.06016345f, 0.01415986f, 0.00883847f, 0.15155251f, 0.15788791f, 0.03198562f, 
    -0.02362606f, -0.08069693f, 0.06560706f, -0.54834694f, 0.02577545f, 0.05635563f, -0.19679371f, 0.03213298f, 
    0.00025921f, 0.10035929f, 0.09931092f, 0.03503167f, -0.03371803f, -0.08196885f, 0.15972041f, -0.40942109f, 
    0.05396969f, 0.05735111f, 0.00526570f, -0.00397017f, -0.07637772f, 0.06088548f, 0.08496034f, 0.09914454f, 
    0.38303068f, 0.09795048f, 0.04218965f, -0.05679513f, -0.08086077f, 0.25156519f, 0.10376817f, -0.06281204f, 
    -0.00453906f, -0.10968464f, -0.03091008f, -0.20519720f, 0.07514285f, 0.47206381f, 0.19927159f, -0.28360406f, 
    0.13131902f, 0.12678103f, 0.04485042f, -0.04038747f, -0.01812319f, -0.03171486f, -0.06729494f, -0.11145536f, 
    0.05252858f, -0.21892408f, 0.08550787f, -0.26453114f, 0.02527788f, -0.11238262f, 0.10823417f, 0.12004937f, 
    0.16832864f, 0.02082195f, -0.02766771f, 0.09876323f, -0.10959120f, 0.10861533f, 0.06305267f, -0.34223124f, 
    -0.18437634f, -0.09726906f, 0.06193643f, 0.14418715f, 0.01349379f, -0.06313895f, 0.05314261f, -0.02537776f, 
    -0.08616141f, 0.00053778f, 0.22984549f, -0.03537893f, 0.25125301f, -0.02157201f, -0.00007434f, -0.00708599f, 
    -0.12209117f, -0.01388031f, -0.09374771f, 0.07417478f, 0.19547746f, -0.18550162f, -0.21900710f, 0.43336356f, 
    -0.07315991f, 0.03891608f, -0.13176814f, -0.07254541f, -0.03931788f, 0.12716162f, -0.09286673f, -0.01277619f, 
    0.17702150f, -0.12611561f, -0.04269075f, -0.37844375f, 0.04868008f, 0.10626531f, 0.17250244f, -0.12973158f, 
    0.02216290f, -0.05486615f, 0.11789276f, -0.00566561f, 0.35601044f, 0.08330645f, -0.08806508f, -0.05067572f, 
    -0.14233498f, 0.06201329f, 0.09167443f, 0.11478510f, 0.08690514f, 0.12461136f, 0.14225909f, -0.20916806f, 
    0.33291307f, -0.61484224f, -0.09617584f, 0.30454051f, -0.01566903f, -0.04133409f, 0.00032645f, 0.01590274f, 
    0.01703954f, -0.01482559f, -0.04601607f, -0.05243275f, 0.48298618f, -0.00670670f, -0.03094884f, -0.03161727f, 
    0.08752646f, -0.03500582f, -0.02255351f, -0.31101796f, -0.17060953f, -0.03262548f, 0.26460737f, 0.02181206f, 
    -0.08809781f, 0.25562578f, 0.09937724f, -0.12034120f, -0.20179355f, 0.02935804f, -0.08138089f, 0.05461082f, 
    -0.00295772f, -0.04801532f, 0.02801834f, -0.09567504f, 0.05430405f, -0.16326238f, -0.02742464f, -0.06436121f, 
    -0.00609928f, 0.07446357f, 0.03422270f, -0.11692316f, -0.02065656f, 0.18618691f, -0.07428605f, 0.10056544f, 
    0.24960805f, -0.26784182f, 0.21281904f, 0.07801525f, -0.02937677f, -0.07341418f, 0.06206563f, 0.15897568f, 
    0.04224283f, -0.08489967f, 0.08665533f, 0.08297410f, -0.28590178f, 0.28444457f, 0.11646499f, -0.01925337f, 
    -0.04352655f, 0.01968433f, -0.04980147f, 0.08956122f, -0.06928927f, 0.16424944f, 0.12340688f, 0.09345470f, 
    -0.40781265f, 0.34112442f, -0.14564312f, 0.16709934f, 0.24410778f, 0.06212331f, -0.01812906f, 0.21923530f, 
    0.14421733f, 0.09616248f, 0.02381578f, 0.09966013f, -0.28623858f, -0.29796395f, -0.26398277f, -0.09166519f, 
    0.08016516f, -0.12522702f, -0.04709224f, -0.08263790f, -0.07989725f, -0.08481704f, 0.19386087f, -0.15094888f, 
    -0.43875545f, -0.18897226f, -0.00732404f, -0.32742408f, -0.03839549f, 0.01005909f, 0.12174483f, -0.25174847f, 
    -0.05136652f, 0.02610525f, 0.16210341f, -0.15182763f, 0.09827963f, -0.42511305f, 0.27264971f, -0.18987565f, 
    -0.02821841f, -0.08012220f, 0.07105751f, -0.16857119f, 0.07342710f, -0.17448430f, 0.02846447f, 0.00549705f, 
    0.12620896f, -0.12262074f, 0.07765115f, 0.18601067f, -0.10080113f, 0.14099865f, -0.00621772f, -0.08715704f, 
    0.10665086f, -0.19285125f, -0.16855288f, 0.02569862f, -0.22615083f, 0.02562890f, -0.05079778f, 0.06171088f, 
    -0.03093825f, 0.03986408f, -0.02112472f, 0.10763526f, -0.08485146f, -0.05394667f, -0.11374112f, -0.13897884f, 
    -0.18788595f, 0.11774970f, -0.39609706f, 0.26148963f, 0.14309612f, -0.06637782f, 0.13582882f, -0.04996494f, 
    -0.01101629f, -0.10475960f, -0.03905725f, -0.09857246f, -0.16512388f, -0.07696836f, 0.02635769f, -0.03155974f, 
    0.12933637f, -0.03012363f, -0.02166876f, -0.00881024f, -0.05309657f, -0.12190951f, -0.07137035f, 0.06511600f, 
    0.02725825f, -0.97050691f, -0.19285813f, -0.34934768f, -0.05557972f, 0.17066541f, 0.03238597f, 0.04609188f, 
    0.00689118f, 0.14226566f, 0.02647972f, 0.29677418f, 0.23302236f, -0.06636714f, -0.04658349f, -0.07646669f, 
    -0.03220765f, -0.06079220f, -0.06944618f, 0.15526111f, 0.15995440f, 0.04148410f, -0.05982627f, 0.12799615f, 
    0.13149074f, -0.47730666f, -0.04201379f, -0.05286123f, -0.02858494f, 0.06203244f, -0.01155740f, 0.06506093f, 
    -0.02721061f, -0.03568141f, 0.04335095f, -0.12362770f, 0.18456699f, 0.11627933f, 0.07674047f, -0.11847506f, 
    0.02224419f, -0.08114547f, 0.07560886f, -0.04962558f, 0.00627132f, 0.09583776f, 0.17298765f, -0.00863960f, 
    0.08674127f, 0.22341608f, 0.02658045f, -0.18920597f, -0.04777983f, 0.27763918f, -0.01469128f, 0.15039328f, 
    -0.22414847f, 0.05308073f, -0.06866515f, -0.09054966f, 0.05628104f, 0.02966882f, 0.00082706f, 0.05831162f, 
    0.08249605f, -0.01363189f, -0.07862569f, 0.12655884f, -0.01476885f, 0.02696946f, 0.03932397f, 0.09823097f, 
    0.23527969f, -0.28826439f, -0.21492998f, 0.21271366f, -0.05602252f, -0.00417655f, -0.17093258f, 0.12647334f, 
    -0.13602795f, -0.02535410f, 0.07159729f, 0.06587520f, 0.01274920f, 0.01511817f, -0.28737184f, -0.28754246f, 
    -0.13984860f, -0.08694541f, -0.15136871f, -0.32278955f, -0.20031056f, 0.06484631f, -0.05236890f, 0.06113950f, 
    0.08414115f, 0.07496799f, 0.25981778f, -0.42373258f, -0.06142549f, 0.04648321f, 0.15446515f, -0.05411518f, 
    -0.18194410f, -0.03077747f, -0.08085972f, -0.04061772f, 0.01261153f, 0.19634978f, 0.00283483f, -0.23276649f, 
    -0.21881819f, 0.05852505f, 0.05696700f, 0.09950785f, 0.15819542f, -0.27636883f, -0.14599140f, 0.08061063f, 
    0.28717282f, -0.48862165f, 0.14123937f, 0.18808986f, -0.02013374f, -0.02798878f, 0.01219037f, -0.02856089f, 
    -0.00646130f, 0.14243783f, -0.07936853f, -0.08932601f, -0.27662370f, -0.14163603f, -0.31985962f, -0.18401021f, 
    0.07596949f, -0.04330155f, -0.02144232f, 0.01431544f, -0.14741476f, -0.00479829f, 0.00012543f, -0.11215927f, 
    0.25358212f, -0.07999262f, 0.02106823f, 0.06515382f, 0.05058266f, 0.03370584f, 0.06925872f, -0.03742348f, 
    -0.09235795f, 0.12300985f, -0.09651376f, -0.05526759f, -0.42737558f, 0.29723462f, -0.17103823f, -0.12067597f, 
    -0.08777387f, -0.02576438f, 0.01569179f, -0.16725744f, 0.00323971f, -0.01788187f, -0.19239777f, -0.04259808f, 
    0.26978901f, -0.05336367f, 0.10080792f, 0.01744364f, -0.13084596f, -0.05408848f, 0.00185826f, -0.14736883f, 
    0.06216381f, 0.00864888f, 0.01209292f, -0.11119721f, -0.13613328f, 0.24823110f, 0.00133732f, 0.27555123f, 
    0.14352630f, -0.04337394f, -0.12561248f, 0.00665166f, 0.05210174f, 0.01268658f, -0.05810365f, -0.04892219f, 
    0.26654565f, -0.00441173f, 0.27512795f, 0.02945249f, -0.00904043f, 0.02139043f, 0.01619279f, 0.05933719f, 
    -0.04053681f, 0.16655055f, -0.07951903f, 0.00809737f, 0.30730191f, -0.06337678f, 0.03089993f, -0.13856529f, 
    -0.13080963f, -0.07565161f, -0.03092029f, -0.04330710f, -0.03373630f, -0.03290308f, -0.11132997f, -0.06941092f, 
    0.02394947f, -0.06568237f, 0.02689330f, -0.14947502f, 0.00403975f, -0.00192732f, 0.05735838f, -0.09754106f, 
    -0.01207439f, -0.01201444f, 0.14964993f, 0.08609520f, -0.10150074f, 0.02748783f, 0.24015068f, -0.01404747f, 
    0.17280720f, 0.05033721f, -0.05169542f, -0.02507030f, -0.06125212f, -0.04589543f, 0.09809472f, 0.05171999f, 
    -0.14611681f, 0.11353791f, -0.12047686f, -0.02030784f, -0.10364953f, -0.12692292f, 0.00721889f, -0.06555285f, 
    -0.08153600f, 0.03375871f, 0.04056625f, -0.20177388f, -0.20342152f, 0.28331882f, 0.10544545f, 0.20510335f, 
    0.01434556f, 0.04002034f, -0.00360797f, 0.04174354f, 0.06703070f, 0.07971271f, 0.04883197f, -0.11173592f, 
    0.15806411f, -0.26248065f, 0.10578725f, 0.13487676f, -0.04780912f, 0.04917332f, -0.04528768f, -0.08812560f, 
    0.00714311f, 0.05651602f, -0.04979163f, -0.07348169f, -0.30762002f, 0.13136469f, -0.15027508f, -0.09904109f, 
    -0.05601856f, 0.01879724f, -0.08190203f, -0.11227518f, -0.24916652f, -0.08125173f, 0.07496540f, -0.05826657f, 
    -0.25519758f, 0.04228003f, 0.03917716f, 0.03430455f, 0.01039053f, -0.02190220f, -0.06778407f, 0.00271129f, 
    0.12300169f, 0.13517448f, 0.00985685f, -0.03198587f, 0.23207757f, 0.05451242f, 0.06919019f, 0.07300690f, 
    -0.10898273f, -0.14290145f, -0.02648980f, -0.04609874f, -0.00749553f, -0.13622715f, 0.08655817f, -0.00787205f, 
    0.06925531f, 0.06537066f, 0.22531232f, 0.16404504f, 0.18653432f, 0.11914694f, -0.03575245f, 0.01433206f, 
    -0.11120337f, 0.09540944f, 0.07535678f, -0.08393632f, 0.09295567f, 0.18578877f, -0.07913983f, -0.01754610f, 
    -0.20848727f, -0.02700114f, -0.10372519f, 0.02044166f, 0.07102979f, -0.08861797f, -0.12853031f, -0.00575464f, 
    0.08776405f, -0.37851837f, 0.16879724f, 0.12173852f, 0.17801273f, -0.07149323f, -0.04561761f, 0.06556521f, 
    0.02533632f, -0.00233853f, -0.09155788f, -0.03365178f, 0.09093289f, 0.15711127f, 0.12002375f, 0.18467836f, 
    -0.01150993f, -0.12305882f, 0.04343789f, -0.04826220f, -0.05370551f, -0.12476070f, -0.12735815f, -0.17228661f, 
    -0.01367742f, 0.18396746f, -0.40321755f, 0.17826393f, -0.13003471f, 0.02458375f, -0.14900778f, 0.03690900f, 
    0.00991981f, -0.05956899f, -0.00411532f, -0.10965856f, -0.06794383f, 0.10649031f, -0.09331702f, 0.16759320f, 
    -0.17865127f, -0.05519118f, -0.08384932f, -0.01778959f, -0.18933944f, -0.07904992f, 0.02601662f, -0.06333843f, 
    -0.15909736f, 0.05906677f, 0.16706035f, -0.05362950f, 0.01191943f, 0.10443727f, 0.07008431f, 0.06775586f, 
    -0.17935933f, 0.15109396f, 0.11236157f, -0.06831414f, -0.31784704f, 0.26219660f, 0.12702285f, 0.27774221f, 
    0.00648820f, -0.15331438f, 0.04717092f, 0.03952254f, -0.14691031f, 0.14268900f, 0.04411222f, -0.14739805f, 
    0.16215646f, 0.00261136f, 0.09472460f, 0.07290098f, -0.01283504f, -0.02616075f, -0.09366643f, -0.00060345f, 
    -0.07361311f, -0.08102747f, -0.00626561f, -0.06704776f, -0.25214195f, -0.33740306f, -0.20699507f, -0.25380522f, 
    0.01493385f, 0.03615988f, -0.00997891f, -0.05735403f, -0.15615627f, -0.09238516f, 0.03954691f, 0.11042815f, 
    -0.10293534f, -0.03093433f, -0.23628891f, -0.06424613f, -0.02365945f, -0.05070571f, -0.08141278f, -0.05366175f, 
    -0.19347718f, 0.05919388f, 0.00198426f, -0.03940419f, 0.18255971f, -0.52515459f, -0.01066238f, 0.16308010f, 
    -0.04744458f, -0.00897906f, -0.10875025f, 0.04118253f, -0.18687636f, -0.13363165f, -0.02583614f, -0.04706395f, 
    0.12212609f, 0.23432755f, 0.14834239f, 0.13632573f, 0.07760139f, 0.03708711f, -0.05860259f, 0.01095323f, 
    -0.03620527f, -0.08563418f, 0.11782648f, -0.02552142f, 0.09869858f, 0.21570291f, 0.12670802f, 0.21788906f, 
    0.13526735f, 0.01143275f, -0.00330996f, -0.00993716f, 0.00014271f, -0.07549860f, -0.16279002f, -0.07158910f, 
    0.00498276f, 0.24939525f, -0.23364572f, -0.32654548f, 0.01194608f, 0.04687698f, 0.01016633f, -0.14083461f, 
    -0.06310794f, -0.01732911f, 0.10268465f, -0.05740957f, -0.47477251f, 0.33381930f, -0.08995441f, 0.05362260f, 
    -0.05216578f, -0.06920744f, -0.07968791f, -0.06445476f, -0.01986290f, -0.09439166f, -0.12796699f, -0.07479236f, 
    0.00522413f, -0.21902175f, 0.14413127f, -0.04152197f, -0.08438839f, -0.06903365f, -0.13574149f, -0.01314481f, 
    0.09718180f, 0.15887804f, -0.05779304f, -0.01090266f, 0.15556848f, -0.16923094f, -0.13933453f, 0.09640869f, 
    0.19249089f, -0.00269742f, -0.07391100f, 0.03132056f, 0.14697705f, -0.02175732f, 0.14056432f, 0.06401145f, 
    -0.02364225f, -0.37887320f, 0.19812566f, -0.18796742f, 0.07136345f, -0.18369061f, 0.03849487f, -0.02130395f, 
    -0.09441188f, 0.01718547f, -0.00811120f, -0.15778847f, 0.20675007f, -0.01149804f, 0.09493895f, 0.29796672f, 
    0.08086802f, 0.08202793f, -0.06862378f, -0.00989095f, 0.12002911f, -0.09211806f, 0.03398609f, 0.01462405f, 
    -0.06268784f, -0.12451280f, -0.08272531f, -0.00744733f, 0.02694728f, -0.26957276f, 0.02493813f, -0.01043741f, 
    -0.09076835f, 0.10881781f, -0.19472511f, -0.06259239f, 0.02089809f, 0.53666991f, -0.29249164f, -0.16421570f, 
    0.09607749f, -0.20552593f, -0.15692660f, -0.06601866f, -0.03308566f, -0.15024227f, 0.08463356f, 0.12511112f, 
    -0.13511893f, -0.16106685f, 0.33162698f, -0.11643348f, -0.05156921f, -0.07888740f, 0.02623295f, -0.05661355f, 
    0.00550893f, -0.07569417f, -0.08993851f, 0.11537406f, 0.07813224f, -0.13165334f, -0.19815227f, -0.24714731f, 
    0.04728185f, -0.08025691f, 0.11661921f, -0.08790178f, -0.17646372f, 0.09062272f, 0.06196075f, 0.16234341f, 
    0.22567306f, 0.08971148f, -0.00404398f, 0.19689326f, -0.07357968f, -0.11594396f, 0.02432365f, -0.01101703f, 
    0.04082431f, -0.03335947f, 0.01200998f, -0.00323444f, -0.25876927f, -0.17919968f, 0.15910856f, -0.12602462f, 
    0.13290156f, -0.00091167f, -0.12028344f, -0.19143511f, 0.00040059f, 0.07413749f, -0.07753641f, -0.03362917f, 
    -0.04535413f, 0.13272747f, 0.09694604f, 0.22035587f, 0.17365505f, 0.08846808f, -0.09284052f, -0.17894553f, 
    -0.00673011f, -0.01337097f, -0.04626545f, 0.17819954f, -0.04802943f, 0.03594599f, 0.19100524f, 0.10351504f, 
    -0.16357380f, 0.07818884f, -0.05435725f, 0.02562114f, -0.04781558f, -0.12909052f, -0.00960325f, 0.09346806f, 
    -0.35487130f, 0.17139740f, 0.07403307f, 0.03756503f, -0.12898493f, -0.10856311f, -0.06078010f, 0.09706847f, 
    -0.03687464f, -0.03103743f, -0.19157253f, 0.12920932f, 0.15093648f, -0.06173288f, 0.12085890f, 0.10139690f, 
    0.11394326f, -0.11437135f, -0.09250031f, 0.04777244f, 0.00253955f, -0.15906879f, 0.03987356f, -0.20641665f, 
    0.11477587f, -0.13041657f, -0.38632235f, 0.10205897f, 0.10254993f, 0.08458611f, -0.16711593f, -0.16267952f, 
    -0.03160770f, -0.07500390f, 0.01339824f, 0.07675384f, 0.02333360f, 0.17006116f, -0.15753244f, -0.25484997f, 
    -0.06538851f, 0.01425326f, 0.09982488f, 0.10504020f, 0.27499026f, 0.07330618f, 0.09704448f, 0.17974904f, 
    -0.37618935f, -0.13371000f, 0.14078727f, -0.24035279f, -0.04631538f, 0.08883669f, 0.02245955f, -0.00953608f, 
    0.01457807f, -0.05961164f, -0.06863805f, -0.06475205f, 0.27228913f, 0.12410861f, 0.14528050f, 0.06060016f, 
    0.02352802f, 0.00264297f, -0.05151359f, 0.05188194f, -0.07585607f, 0.03953522f, 0.12692846f, -0.27925056f, 
    -0.06369667f, -0.11730163f, -0.08789825f, 0.00527574f, -0.02238452f, 0.00243093f, -0.23592570f, -0.10936866f, 
    0.02153796f, 0.09447903f, 0.11271272f, 0.03603655f, -0.07119993f, 0.04264341f, -0.02034375f, -0.26366675f, 
    -0.00310394f, -0.30043167f, -0.06536276f, 0.00071825f, -0.04417969f, 0.19187734f, 0.08367134f, 0.06639054f, 
    0.11300396f, 0.38101918f, 0.05308939f, -0.05711171f, -0.12379245f, 0.11532140f, -0.06953902f, -0.11360955f, 
    0.05545675f, 0.02863453f, -0.07933915f, 0.00138513f, 0.12281609f, -0.32541177f, -0.14791277f, -0.11769124f, 
    0.07537039f, -0.10046339f, 0.09529755f, 0.02363440f, 0.12158112f, 0.07443170f, 0.06195758f, 0.07160473f, 
    -0.04108866f, -0.10120232f, 0.22057146f, 0.09040955f, -0.04685165f, -0.11231094f, -0.05168618f, -0.09432405f, 
    0.02896020f, -0.17079757f, -0.04717462f, -0.19572522f, -0.14983264f, -0.29737157f, -0.15633295f, -0.03781415f, 
    0.08942330f, 0.02280853f, -0.20306505f, 0.09585906f, 0.17952304f, 0.09309688f, -0.01559547f, -0.08152793f, 
    -0.03917161f, 0.00440941f, -0.04004040f, -0.23602599f, -0.10319187f, -0.28971031f, 0.10575920f, 0.06926380f, 
    -0.01424409f, 0.02734600f, -0.01880320f, 0.14842001f, 0.13675724f, -0.22123544f, -0.03244854f, 0.27732721f, 
    0.21143460f, 0.02137882f, -0.06429873f, 0.00991094f, 0.03349334f, 0.12334415f, -0.39181110f, 0.21207765f, 
    -0.19700144f, 0.11609604f, -0.02980795f, -0.10040987f, -0.04406850f, -0.04311811f, -0.02035430f, -0.02771359f, 
    0.21205735f, 0.10328931f, 0.10371234f, 0.09855490f, 0.06899484f, -0.46547297f, -0.22265998f, -0.33037892f, 
    0.03780415f, 0.21621534f, -0.04819921f, -0.13258766f, 0.08121487f, 0.15474491f, -0.00664819f, -0.02860481f, 
    0.23154403f, 0.17398296f, -0.04540486f, 0.00354369f, -0.06447455f, -0.10711707f, 0.01929762f, -0.07780865f, 
    -0.05527472f, -0.01772422f, -0.11291432f, -0.00878418f, -0.39691761f, 0.01322389f, 0.16106559f, -0.28386024f, 
    -0.01801385f, -0.04159501f, -0.16481709f, -0.03717956f, 0.16020128f, -0.04658667f, -0.07767990f, -0.08567926f, 
    0.05531117f, -0.31233355f, 0.16101150f, 0.02405329f, 0.14510839f, -0.07912882f, 0.08934282f, 0.09089707f, 
    0.13196689f, 0.01209509f, -0.06109918f, -0.05210719f, -0.10156479f, -0.09238307f, -0.20272541f, 0.20403887f, 
    -0.01476905f, -0.01816709f, -0.06334335f, -0.11997141f, 0.05105667f, 0.08587614f, -0.06829429f, -0.19784456f, 
    0.29474938f, -0.22532323f, -0.34561187f, -0.33466917f, -0.04870273f, -0.07131301f, 0.10453045f, 0.01503942f, 
    0.09195381f, -0.01310844f, 0.00295002f, 0.03310354f, 0.12028971f, -0.21047929f, 0.33207268f, -0.44177172f, 
    0.04537272f, -0.02943129f, 0.06515842f, -0.04066330f, -0.00136021f, -0.11491980f, -0.02905015f, -0.16038781f, 
    0.19789636f, 0.23675451f, -0.16527963f, -0.11370210f, 0.02254989f, -0.06150566f, -0.06767128f, 0.08223321f, 
    0.14781660f, 0.04714185f, -0.00452078f, 0.03842122f, -0.65415251f, 0.49290851f, -0.22337635f, -0.22178864f, 
    0.21738490f, -0.07333391f, -0.04798683f, -0.12804127f, -0.00100310f, -0.00478031f, -0.10903756f, -0.18502109f, 
    -0.18491639f, 0.10062111f, -0.15878433f, 0.11151443f, -0.09596885f, 0.08035149f, 0.08478309f, -0.04519180f, 
    -0.05166774f, -0.06201853f, 0.14334188f, 0.00393112f, -0.10485581f, -0.21104355f, 0.40345788f, -0.16401958f, 
    0.04759083f, 0.04072762f, -0.13973612f, 0.15715386f, -0.05655672f, -0.07802260f, -0.05559013f, -0.05119347f, 
    -0.02329097f, -0.33189726f, -0.02531545f, 0.15289590f, -0.06576294f, 0.04860441f, -0.08961388f, -0.03456566f, 
    -0.12878823f, 0.22803172f, 0.07657346f, -0.18466897f, -0.37604561f, 0.13277903f, 0.09055866f, -0.06527103f, 
    0.02039973f, 0.11451454f, -0.09597099f, 0.02042552f, 0.09871329f, -0.05634714f, 0.17462650f, 0.05120213f, 
    0.12751439f, 0.01786634f, -0.08659813f, -0.05016600f, 0.06987505f, 0.18399872f, -0.14663106f, -0.03727293f, 
    -0.20675807f, -0.00149354f, -0.09898847f, 0.05760219f, -0.24039491f, -0.47816202f, 0.08427311f, 0.33259860f, 
    0.00579175f, 0.01985605f, -0.22561063f, 0.04311063f, 0.13750267f, -0.00396100f, 0.13302767f, 0.18972112f, 
    0.22676434f, 0.10981245f, -0.01561028f, -0.31682476f, 0.22382519f, -0.04726873f, 0.03553330f, 0.16944626f, 
    -0.09487162f, 0.09075399f, 0.08521424f, 0.01147118f, -0.67603868f, -0.20590334f, -0.02083138f, -0.06693789f, 
    0.03868137f, 0.03087211f, -0.01273492f, 0.16600074f, 0.12452685f, 0.20068128f, 0.01822462f, 0.00540689f, 
    -0.14635548f, 0.33343229f, -0.34876108f, 0.24570483f, 0.06539943f, 0.11167739f, -0.04782317f, 0.09028555f, 
    -0.11417480f, -0.10945516f, 0.09109636f, 0.04940193f, -0.36919799f, 0.31613660f, 0.10375185f, -0.34945926f, 
    -0.06910048f, 0.15580590f, 0.00550301f, -0.13971052f, 0.11771210f, 0.07573052f, -0.02833483f, 0.08229036f, 
    -0.18926848f, 0.05983409f, 0.16386409f, -0.13086830f, 0.00598202f, -0.00658979f, -0.10240077f, -0.04911709f, 
    -0.06243965f, -0.02158724f, -0.05455083f, -0.00818469f, -0.09026251f, -0.09394100f, -0.06181777f, 0.04165037f, 
    -0.05467631f, 0.09907220f, -0.00642022f, -0.13035451f, -0.03024119f, -0.07208278f, -0.19241209f, 0.00700692f, 
    0.08388374f, -0.22285520f, -0.22556879f, 0.23975942f, -0.02540096f, 0.06232635f, -0.12662303f, 0.04729341f, 
    -0.22463340f, -0.06078731f, -0.11710922f, 0.13363932f, -0.04577285f, 0.09140439f, -0.06705619f, 0.08890305f, 
    0.19858108f, -0.17665549f, 0.09445994f, -0.11397300f, 0.05778112f, -0.03042525f, 0.07348169f, 0.18390688f, 
    0.52434480f, -0.38786027f, -0.22249791f, 0.01039454f, -0.04190969f, -0.00979190f, 0.00573879f, 0.06253558f, 
    -0.01765203f, -0.08820459f, -0.02395399f, -0.18721572f, -0.14150999f, -0.09909011f, 0.02498414f, -0.12242851f, 
    0.14371958f, -0.02741636f, -0.11967711f, -0.18648985f, -0.01422481f, -0.31875405f, -0.06927805f, -0.07593329f, 
    0.31709245f, 0.42726913f, 0.14914699f, 0.25503194f, 0.02555392f, -0.02806226f, 0.01910729f, 0.37150937f, 
    0.04813647f, 0.11428999f, -0.03487756f, 0.00509637f, 0.01292454f, 0.24394521f, 0.09118540f, -0.24536501f, 
    0.08018509f, -0.15320495f, 0.10253303f, -0.07619338f, -0.03815008f, 0.01543824f, -0.05502927f, -0.23608790f, 
    0.21566787f, -0.21411465f, 0.15375152f, -0.07040330f, 0.25006035f, -0.08781143f, 0.23819827f, 0.02788039f, 
    -0.12574849f, 0.06392162f, -0.00281239f, 0.09330859f, -0.28571445f, 0.05811359f, -0.28646946f, -0.26565862f, 
    0.02573432f, -0.06309829f, -0.09181320f, 0.01375942f, 0.03261582f, -0.09696805f, -0.00656825f, -0.02686369f, 
    0.70327991f, 0.32217798f, -0.23168373f, 0.22109313f, 0.19988893f, -0.05504786f, -0.04137537f, 0.13994768f, 
    -0.07503539f, 0.01702382f, -0.03582235f, 0.10746296f, 0.02711970f, 0.00562413f, 0.27116638f, -0.13858907f, 
    0.06161843f, 0.02614299f, -0.05361960f, 0.01098463f, 0.11189914f, 0.03919953f, -0.08284479f, -0.12839700f, 
    -0.09829971f, 0.17043191f, 0.04274726f, -0.03620632f, -0.01586338f, 0.06793524f, 0.07253323f, -0.14918654f, 
    -0.12535316f, 0.06862496f, -0.22760317f, -0.11113487f, 0.20118695f, -0.22851092f, 0.00671303f, -0.11560056f, 
    0.05534503f, -0.02219104f, -0.03689134f, -0.15636706f, -0.11574163f, 0.09268308f, 0.10960402f, 0.15238523f, 
    -0.26732928f, 0.03545709f, -0.11171407f, 0.14779879f, 0.27895573f, 0.06249689f, -0.03863121f, 0.06432230f, 
    -0.02319120f, -0.17220339f, 0.19793496f, 0.01527316f, -0.24648662f, -0.17126285f, 0.00686110f, 0.18775032f, 
    0.06984176f, 0.14562663f, 0.11791211f, 0.07572570f, 0.06587976f, -0.04837690f, -0.05679018f, 0.00065962f, 
    -0.47090468f, 0.09669092f, -0.11318689f, -0.26390103f, 0.08096665f, -0.02896184f, -0.07019281f, -0.10115802f, 
    -0.12501228f, -0.11323620f, 0.04227044f, -0.00410726f, -0.55459380f, 0.41545218f, -0.15090445f, -0.10387411f, 
    0.06401191f, 0.08783420f, 0.14710917f, 0.00810258f, -0.03795077f, 0.24872015f, 0.16585995f, -0.03607814f, 
    -0.10414662f, 0.28667837f, -0.15696478f, -0.23425773f, 0.10668493f, 0.15646504f, 0.02268449f, 0.20755197f, 
    0.03958930f, 0.04807558f, 0.11836214f, 0.12546027f, -0.27167019f, 0.19854152f, -0.11689912f, -0.15559921f, 
    0.10281415f, 0.01003877f, -0.04053124f, -0.02645266f, 0.07551944f, 0.02740191f, 0.14937426f, 0.17301910f, 
    -0.03933335f, 0.16124462f, 0.04429548f, 0.30385664f, 0.01769115f, -0.01031203f, -0.08758103f, -0.21569756f, 
    -0.08255865f, -0.17564878f, -0.19387709f, -0.19401561f, -0.62036872f, -0.31442940f, -0.29971203f, -0.40322664f, 
    0.02433689f, -0.07616621f, -0.06603158f, -0.07198436f, 0.03230958f, -0.07956208f, 0.12745017f, -0.02613066f, 
    -0.29496145f, 0.02390815f, 0.10801002f, 0.00584114f, 0.05485563f, -0.12905654f, -0.04444717f, 0.12808339f, 
    0.11139445f, 0.06962692f, -0.00720633f, 0.04068852f, -0.25868559f, 0.09532019f, 0.07171481f, 0.08872344f, 
    0.13643557f, 0.00965561f, 0.03641120f, -0.03194631f, -0.05673067f, 0.05329905f, -0.01812756f, -0.03540385f, 
    0.26207167f, 0.08611540f, -0.04934216f, -0.10796066f, -0.00376452f, 0.03701218f, 0.03607244f, -0.02585428f, 
    0.03341340f, 0.01614703f, 0.02429583f, 0.02205946f, 0.18104282f, 0.10394943f, 0.14412382f, 0.20855816f, 
    0.06251838f, 0.08233391f, 0.09049860f, -0.06081552f, -0.00518537f, 0.03605212f, -0.06579155f, 0.07287420f, 
    0.16823517f, -0.08411308f, -0.19647491f, -0.27016276f, 0.00947763f, -0.05524157f, -0.01847074f, -0.04487050f, 
    0.01589254f, 0.02768261f, -0.07388033f, 0.13292272f, 0.33869904f, -0.16516252f, -0.08044856f, 0.05687754f, 
    -0.16583499f, -0.06604092f, -0.10160994f, -0.04058689f, 0.09114718f, -0.16309541f, -0.20184992f, -0.19761392f, 
    -0.78206646f, -0.43529263f, -0.06347091f, -0.16852318f, 0.10670543f, -0.09312019f, -0.05017872f, -0.06516723f, 
    0.02841579f, 0.08908057f, 0.00724093f, 0.12951627f, 0.24093905f, 0.24914320f, -0.09908908f, 0.15899584f, 
    -0.06715833f, -0.16139977f, 0.02991601f, -0.07888606f, 0.01866057f, -0.09375838f, 0.07689799f, 0.10045613f, 
    0.15211420f, -0.16613033f, -0.10611660f, 0.05281789f, -0.00274270f, -0.25220269f, -0.03837826f, 0.19855350f, 
    -0.03235679f, 0.02909103f, -0.04386579f, 0.01910123f, -0.44091156f, -0.55043834f, 0.02824667f, 0.11471107f, 
    0.10674489f, 0.05068715f, 0.08581495f, 0.11354421f, 0.07404099f, 0.02111224f, -0.16045760f, 0.09761875f, 
    -0.86138922f, -0.56363767f, 0.21673976f, 0.24148703f, -0.04965314f, -0.00871720f, 0.11978566f, -0.07719933f, 
    0.04826380f, -0.17857552f, 0.07828372f, -0.04296428f, 0.12577923f, 0.10793892f, -0.02990398f, -0.09602120f, 
    0.12327003f, 0.20763935f, 0.13855980f, -0.03365125f, -0.05221330f, 0.11271239f, 0.07267188f, 0.12500384f, 
    0.19314247f, -0.24025552f, 0.07037892f, -0.13019328f, -0.12944923f, 0.05960587f, -0.03347767f, -0.01710484f, 
    0.12528817f, 0.16101408f, 0.08052325f, 0.02087968f, -0.08399920f, -0.20732158f, -0.04382598f, -0.11247380f, 
    -0.01540368f, 0.00405640f, 0.12687825f, 0.02308402f, 0.00459359f, 0.07552180f, -0.02393851f, 0.04994424f, 
    0.22437567f, 0.09829691f, -0.23057047f, -0.18216200f, -0.13819113f, -0.05894279f, 0.05240914f, -0.08662838f, 
    0.04927328f, 0.08011162f, 0.15706235f, -0.00734885f, 0.44862187f, 0.11144941f, -0.07297745f, -0.12450226f, 
    0.00455929f, 0.17457336f, 0.03780983f, -0.01955290f, 0.04164855f, 0.21081096f, 0.03092572f, 0.02248945f, 
    -0.33792144f, -0.22449422f, 0.08156333f, -0.00915308f, 0.10721173f, 0.15824276f, 0.03817405f, 0.05435973f, 
    0.21891323f, 0.01068436f, 0.05133903f, 0.11304064f, -0.12518416f, 0.04572175f, 0.12042221f, 0.03384186f, 
    0.07250050f, -0.02596910f, 0.01765478f, -0.03679474f, -0.03803923f, 0.08860992f, 0.06083559f, 0.06994513f, 
    0.29644844f, 0.13837700f, -0.19893904f, 0.20094684f, -0.17009428f, -0.05962297f, -0.10746793f, 0.07676724f, 
    -0.05507989f, 0.05971255f, 0.03870148f, -0.22462097f, -0.14951950f, -0.02586163f, -0.18041107f, -0.11668807f, 
    0.20848352f, -0.04859465f, -0.10353347f, -0.02697018f, 0.05313284f, -0.08496414f, -0.05240509f, -0.17571972f, 
    0.17386471f, 0.02837514f, -0.12169787f, 0.17425612f, 0.01868250f, -0.10296510f, 0.09970741f, -0.10514150f, 
    -0.00338745f, 0.04515126f, 0.14150357f, -0.08705661f, -0.40269235f, 0.13679686f, -0.10242128f, -0.24166894f, 
    0.02824689f, -0.23756203f, -0.04691552f, -0.03846211f, 0.00730248f, -0.06498035f, -0.10096906f, 0.20710850f, 
    -0.47264603f, -0.20437521f, -0.01019968f, -0.05440650f, 0.05098087f, -0.20631325f, 0.08757287f, -0.05407676f, 
    0.06756119f, 0.27747148f, 0.22662790f, -0.03374444f, -0.50011861f, 0.08470719f, 0.24241723f, -0.13662887f, 
    0.09879561f, -0.04849882f, 0.10754784f, 0.08205856f, -0.11660735f, 0.15202010f, -0.12083427f, 0.17734139f, 
    0.17430252f, -0.23786044f, -0.01710373f, -0.11141863f, -0.24086550f, 0.04135465f, 0.05118495f, -0.09483165f, 
    -0.02731075f, 0.09078685f, -0.29096869f, -0.21844327f, 0.28632709f, 0.21711212f, -0.05417254f, -0.21729645f, 
    -0.03397352f, 0.01149580f, 0.14266083f, -0.12470611f, -0.15381797f, -0.04577837f, 0.05675851f, -0.09632162f, 
    -0.36138934f, -0.30193114f, -0.17713816f, -0.12007823f, 0.07069282f, -0.00647669f, 0.03101694f, 0.14282955f, 
    0.00564769f, 0.15578556f, 0.08459834f, 0.28259978f, 0.39293572f, -0.17563231f, -0.04959872f, 0.05451895f, 
    0.03283512f, 0.02926047f, 0.14363116f, 0.10197942f, 0.02216168f, 0.13283382f, 0.03187222f, 0.05687724f, 
    -0.48476034f, -0.00492884f, 0.06337071f, -0.02471563f, -0.15921615f, -0.04949084f, 0.00893711f, 0.06399043f, 
    -0.07646122f, -0.13554087f, -0.01476343f, 0.09769589f, 0.43295187f, -0.12963365f, -0.37315175f, -0.28312385f, 
    0.01460144f, 0.04946493f, -0.12174301f, 0.23338681f, 0.04830811f, 0.08199899f, -0.01364346f, -0.09112833f, 
    -0.17328469f, 0.17812248f, 0.03567383f, -0.13700077f, -0.05486790f, -0.12512438f, 0.01402853f, -0.03922526f, 
    0.14126320f, 0.07344703f, 0.18747306f, 0.02103945f, 0.31239480f, -0.38825759f, -0.07318551f, -0.40583739f, 
    0.05806653f, 0.02098492f, 0.07146768f, -0.05627787f, 0.07814725f, -0.00712601f, -0.07855678f, 0.03486992f, 
    -0.04421327f, -0.11320254f, 0.13974617f, -0.18157397f, 0.13241662f, 0.02679290f, 0.08230353f, -0.03339683f, 
    -0.09119081f, -0.17742848f, -0.02279291f, 0.05540136f, 0.36404935f, -0.26732978f, -0.17353103f, 0.10895004f, 
    0.14081819f, 0.13002403f, -0.06892572f, -0.16871846f, 0.16113041f, 0.16746302f, 0.05002377f, 0.12831204f, 
    -0.29405272f, 0.31100357f, -0.07197967f, 0.02851350f, 0.12323408f, -0.07178126f, 0.04750778f, -0.19188035f, 
    0.03530454f, -0.00589735f, 0.05676422f, -0.29774410f, 0.08465019f, 0.21163855f, -0.14617945f, 0.00379630f, 
    0.24164280f, -0.00093741f, -0.08252145f, -0.17062102f, -0.05730628f, 0.11016767f, 0.05969146f, -0.01909423f, 
    -0.66558111f, -0.31450945f, -0.14513665f, -0.24176694f, -0.06973468f, 0.07816660f, 0.07131594f, 0.01188557f, 
    0.10779548f, -0.09225525f, -0.10233947f, -0.14300326f, -0.05880642f, -0.02398910f, 0.16695867f, -0.19906111f, 
    -0.05888690f, -0.19106947f, 0.02635127f, -0.00182572f, -0.09408236f, 0.01169340f, 0.18466076f, 0.08811831f, 
    0.32966614f, -0.50498635f, -0.06747185f, -0.23170739f, 0.10146020f, -0.17821394f, 0.01819596f, 0.06663491f, 
    -0.11702880f, 0.03874728f, 0.09875773f, 0.07675342f, 0.25216383f, -0.32874724f, -0.10025790f, 0.01933640f, 
    -0.12305898f, 0.04437310f, 0.06705938f, 0.10184788f, -0.01065115f, -0.14679384f, -0.25125274f, -0.04737040f, 
    -0.17541556f, -0.00105390f, 0.08771166f, -0.04439806f, 0.06202945f, -0.00684795f, 0.07738732f, -0.00992993f, 
    0.04211133f, 0.06446495f, 0.06996346f, -0.00246674f, 0.38497502f, 0.03389106f, -0.08539089f, -0.49047074f, 
    0.01047793f, 0.05776843f, -0.00312965f, 0.09204352f, 0.05071260f, -0.00711167f, -0.02379697f, -0.03290405f, 
    0.19311389f, 0.19531357f, -0.12638547f, 0.11046923f, 0.01894816f, 0.10790021f, 0.06381451f, -0.11572791f, 
    0.07213891f, 0.05514105f, -0.05248631f, 0.04326202f, -0.16399206f, 0.12963068f, -0.04331700f, 0.06901997f, 
    0.08270632f, -0.05499455f, 0.13441445f, 0.08825248f, -0.04623668f, -0.10345016f, -0.16609661f, -0.12784992f, 
    0.02465351f, 0.34617233f, 0.15191020f, -0.01798975f, -0.13396885f, -0.24684942f, -0.00046024f, -0.12604858f, 
    0.04967265f, -0.06858181f, 0.14039694f, -0.04317377f, -0.56085974f, -0.53282279f, 0.07364187f, -0.04380666f, 
    0.26145089f, 0.05829923f, -0.01667224f, 0.06813607f, 0.07456926f, -0.08693120f, -0.05548713f, 0.17689294f, 
    -0.27607384f, 0.21381943f, 0.05660721f, 0.17411453f, -0.07482358f, 0.01733904f, 0.09074286f, 0.14437735f, 
    -0.12368784f, -0.09619757f, 0.02946359f, 0.01096545f, 0.06314757f, -0.06362338f, -0.17025293f, 0.11717176f, 
    -0.11825100f, 0.06089969f, -0.21661788f, 0.02394565f, 0.01477589f, -0.17140371f, -0.12061497f, -0.20804717f, 
    0.04029613f, -0.18972364f, -0.04083471f, 0.09299506f, 0.10576844f, -0.09788608f, -0.06829455f, -0.12511092f, 
    -0.09443862f, -0.01398976f, -0.04484970f, -0.04476428f, 0.49492016f, 0.19177124f, -0.08493061f, -0.04209121f, 
    0.16664901f, -0.00760447f, 0.00583133f, -0.02729416f, 0.18759497f, 0.02576178f, 0.05945190f, -0.10900533f, 
    0.10921765f, -0.04424496f, 0.18878159f, 0.10131466f, -0.06606784f, -0.05090340f, 0.14816967f, -0.02146485f, 
    -0.06219038f, -0.06734347f, -0.01270619f, -0.02093593f, -0.02969752f, -0.32212961f, -0.00888499f, 0.41801044f, 
    -0.01122884f, -0.08089280f, 0.16556583f, -0.08255094f, 0.13336216f, -0.08577115f, 0.14074628f, 0.18471380f, 
    -0.16009893f, -0.17197616f, 0.21624804f, 0.06028297f, -0.17165808f, 0.03196349f, 0.03882778f, -0.20249355f, 
    0.03746421f, 0.10786697f, 0.06709677f, -0.01440210f, 0.56846857f, -0.10093757f, -0.14399955f, -0.18629254f, 
    -0.00593985f, 0.15262358f, -0.03326786f, 0.17006318f, 0.00623231f, -0.02682743f, 0.13954782f, 0.08610979f, 
    -0.02472350f, 0.28290054f, -0.18327522f, 0.18660186f, 0.09327081f, -0.17146987f, -0.17233226f, 0.00854180f, 
    -0.07065671f, -0.07353973f, -0.01794305f, -0.21547854f, 0.43267316f, 0.16588286f, -0.20227650f, 0.16890433f, 
    -0.23242192f, -0.06143505f, 0.05100390f, 0.05406167f, 0.26994255f, -0.01333011f, -0.00013658f, 0.02640659f, 
    -0.16384272f, -0.34371749f, 0.06487738f, -0.12103485f, -0.04006068f, 0.11012565f, -0.04611558f, 0.14185965f, 
    -0.20105541f, 0.11477035f, 0.12611356f, -0.22868080f, 0.22323865f, -0.04512508f, -0.30688938f, -0.09150928f, 
    -0.20556431f, -0.02669166f, -0.04932135f, -0.07115208f, 0.04231630f, -0.14503911f, -0.06989913f, -0.12087850f, 
    -0.47971982f, 0.01914162f, -0.00886131f, -0.10736216f, 0.14104241f, 0.02006787f, 0.08687174f, 0.00597381f, 
    0.04461402f, 0.01067573f, -0.09564505f, 0.05440954f, 0.09189341f, 0.10598911f, -0.06775731f, 0.38032207f, 
    0.18733349f, -0.03057910f, -0.05401674f, 0.01804026f, 0.23221658f, -0.04213897f, 0.03395187f, 0.04060005f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08992802f, 0.01028666f, -0.11444040f, 0.04100770f, -0.02695965f, 0.05415087f, -0.01987008f, -0.09415653f, 
    -0.00115493f, 0.04229597f, 0.14033231f, 0.03330460f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
