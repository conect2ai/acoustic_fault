#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.63361335f, 0.69038963f, 0.29601052f, -1.15249395f, -0.04795016f, -0.57082373f, -0.17921959f, 0.23107664f, 
    0.29035947f, -1.12387764f, -0.52223796f, -0.46509510f, -0.15895937f, -0.34314078f, -0.29459110f, 0.29004657f, 
    -0.62925851f, 0.10467706f, 0.54367775f, 0.33077189f, 0.42677054f, -0.23002090f, 0.36942890f, 0.07219706f, 
    0.29421315f, 0.20373367f, -0.45936528f, -1.26076996f, 0.97757775f, -0.31607202f, 0.03136112f, -0.47479090f, 
    0.83606255f, -0.12132984f, -0.13087103f, 0.07838617f, 0.59157324f, 0.64690018f, 0.68983036f, 0.07793304f, 
    0.23094553f, -0.94978881f, 0.09353826f, -0.06317152f, -0.18454742f, -0.37283736f, -0.60358131f, -0.85914153f, 
    0.16478834f, 0.40568677f, 0.48624340f, -0.41201571f, -0.23512682f, -0.65546799f, 0.33639821f, 0.45376506f, 
    0.06396519f, 0.32692084f, -0.58584213f, 0.94126695f, -0.55762494f, -0.46034914f, -0.28705963f, -0.10582229f, 
    1.18962705f, -0.58945990f, -0.22214966f, -0.08055436f, 0.24570644f, -0.26299456f, 0.22124903f, 0.54875916f, 
    -0.33565769f, 0.20599112f, 0.64666760f, -0.53382415f, 0.18091087f, 0.26649389f, 0.74908453f, -0.53705078f, 
    0.35454309f, 0.69831169f, -0.86793578f, -0.14940487f, -0.23880653f, -0.08616835f, -0.75717151f, -0.25816616f, 
    -0.60059071f, 0.20758684f, -0.32851860f, 0.26100799f, 0.23253080f, -0.53720951f, 0.05382843f, -0.78337336f, 
    0.59328198f, 0.46225333f, 0.38747045f, 0.41122201f, -0.52514821f, -0.04473004f, -0.10125501f, -0.41907746f, 
    -0.57255363f, 0.11836433f, 0.46506378f, 0.73446381f, -0.15479524f, 0.45486295f, -0.02381439f, 0.82656485f, 
    0.96529347f, -0.08001618f, 0.27247807f, -0.48575896f, 0.03886579f, 0.21879077f, -0.18495713f, -0.62062508f, 
    -0.93942285f, -0.56806529f, -0.62599850f, 0.57720572f, -0.71458381f, -0.18199684f, -0.47250035f, -0.41364488f, 
    -0.40263078f, 0.64748341f, 0.59498578f, 0.41273218f, 0.02270262f, 0.69369811f, -0.42599586f, -0.43734571f, 
    -0.09358872f, -0.09410886f, -0.22391729f, -0.96867818f, -0.78071392f, -0.28556094f, -0.09540007f, 0.03407250f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.09853970f, 0.73526865f, 0.39443770f, -0.23060398f, 0.25772536f, 0.13468796f, -0.20206849f, 0.51726615f, 
    -0.06062718f, 0.61139339f, -0.03324188f, 0.01658043f, 0.16013226f, -0.03596595f, 0.21989429f, -0.79503769f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.26162368f, -0.00384402f, 0.12089591f, 0.02006244f, -0.05922914f, -0.17245847f, -0.17636386f, 0.06979126f, 
    -0.08191330f, -0.13740127f, 0.05286109f, 0.14506705f, 0.07081212f, 0.23485228f, 0.11350817f, -0.15655170f, 
    -0.13709472f, 0.23072946f, 0.01999484f, -0.04789181f, 0.14186358f, -0.17153682f, 0.12740055f, 0.01505492f, 
    0.02031353f, 0.26851901f, -0.09905636f, 0.12116939f, 0.00264776f, 0.17164643f, -0.12771316f, 0.07255219f, 
    0.11740398f, -0.05794485f, 0.21211846f, 0.12131696f, -0.26267776f, 0.12284031f, 0.21428595f, 0.04764728f, 
    0.16357507f, -0.02571210f, -0.02845991f, 0.09670240f, -0.22905239f, 0.05645731f, -0.24797662f, -0.04817164f, 
    -0.16273092f, 0.05098044f, 0.16117221f, -0.19884102f, -0.02953294f, 0.13991113f, -0.25826052f, -0.13883474f, 
    0.17275842f, -0.05392737f, -0.20105007f, -0.26032612f, -0.04487540f, 0.04067375f, -0.15499479f, 0.47569215f, 
    0.34656039f, 0.12140184f, -0.03150173f, -0.01353411f, 0.26623398f, 0.10533070f, 0.24027120f, 0.08918934f, 
    -0.06409300f, -0.11203551f, 0.17668116f, 0.16071476f, 0.22719063f, -0.18073899f, -0.04550432f, 0.07128598f, 
    -0.26512125f, 0.18029939f, 0.14054054f, 0.36328131f, 0.07158772f, 0.07954910f, -0.06465311f, 0.12028171f, 
    0.23011883f, -0.00478618f, -0.31402037f, -0.21742333f, -0.26962134f, -0.08958005f, -0.29520845f, -0.51033664f, 
    -0.02937875f, 0.14764653f, 0.24745047f, 0.20127727f, -0.27522886f, -0.09004615f, -0.15274948f, -0.21204194f, 
    -0.11279137f, 0.13321109f, -0.15702938f, 0.24402921f, -0.21774502f, -0.12778290f, -0.20798844f, 0.23822474f, 
    -0.15679485f, 0.12539642f, -0.16085553f, 0.09855515f, -0.04511137f, -0.03450509f, -0.09459833f, -0.09311811f, 
    0.11224322f, -0.02078968f, -0.06712655f, 0.04049217f, 0.04511593f, 0.12256131f, 0.10071208f, -0.10406075f, 
    0.15312232f, -0.13914688f, 0.13640481f, -0.04594518f, 0.01856430f, 0.02213208f, 0.10292044f, -0.21748362f, 
    -0.45156842f, -0.24546972f, 0.05271703f, 0.10687936f, -0.21160612f, -0.04434051f, -0.17854850f, -0.01041747f, 
    -0.13645846f, -0.94923908f, -0.29563987f, 0.08234026f, -0.20730874f, -0.10800476f, -0.02882615f, 0.10283665f, 
    0.03801291f, 0.35375831f, 0.32207951f, 0.29705003f, 0.01908929f, 0.03271351f, 0.13415718f, 0.07404278f, 
    -0.01155608f, 0.02239144f, 0.03435747f, -0.26369399f, -0.05451082f, 0.12811299f, 0.01645286f, 0.01059138f, 
    0.03912077f, 0.10146576f, -0.01400225f, -0.67383170f, 0.28006810f, 0.37271136f, -0.32074189f, -0.13565414f, 
    0.06595741f, 0.10834966f, 0.06941386f, -0.02773693f, 0.13951248f, -0.40415239f, -0.12564714f, -0.02726843f, 
    0.11289564f, -0.02834483f, 0.17208208f, 0.08514792f, -0.03971156f, 0.02697501f, -0.11527340f, -0.06908616f, 
    0.04523144f, 0.05573957f, 0.16913217f, 0.06736181f, -0.08471939f, -0.17051281f, -0.20407504f, -0.12355136f, 
    -0.26675376f, 0.01444170f, -0.11056479f, -0.21029462f, 0.11430332f, 0.00112793f, -0.03838198f, 0.08319882f, 
    -0.05165238f, -0.75625896f, -0.14680292f, 0.29665947f, 0.24913599f, 0.07950900f, 0.08367494f, 0.16214207f, 
    0.13647771f, -0.14116602f, 0.10102157f, 0.20527488f, -0.12321929f, 0.00414716f, -0.31563574f, 0.00104743f, 
    -0.09083936f, 0.50543934f, 0.29240990f, 0.19562332f, 0.12686862f, 0.04748068f, 0.05760660f, -0.04035061f, 
    -0.07007568f, -0.01930496f, -0.03664782f, 0.18573156f, 0.38700888f, 0.02106046f, -0.20387119f, 0.10247406f, 
    0.08026047f, 0.11065166f, 0.02831071f, 0.25594351f, 0.40907714f, 0.18288226f, -0.04972523f, 0.04954631f, 
    -0.13019511f, 0.11624630f, -0.13940388f, 0.10120113f, 0.02950595f, -0.09663884f, -0.29243121f, -0.11349175f, 
    -0.26180643f, -0.05000468f, 0.04477889f, -0.07489709f, 0.02218507f, -0.07148638f, 0.47681558f, 0.16484199f, 
    -0.09697890f, 0.07455373f, -0.02607469f, -0.05754580f, -0.12610205f, -0.01993174f, -0.06799791f, -0.11113531f, 
    -0.15519628f, -0.08549567f, 0.23948251f, -0.14070110f, 0.13390398f, 0.07820342f, 0.25057402f, 0.09823859f, 
    0.28670886f, 0.24875322f, 0.01579739f, 0.11541137f, -0.24716181f, 0.11567103f, 0.00647665f, 0.08890343f, 
    -0.02489199f, -0.19071722f, -0.07342607f, 0.18814145f, -0.00964452f, -0.05277546f, 0.13999300f, 0.04791979f, 
    0.09096094f, -0.29536867f, 0.18750902f, 0.11604961f, 0.05613827f, -0.19540159f, -0.05145558f, 0.12883528f, 
    -0.02563688f, 0.01155872f, -0.33228388f, -0.17311697f, -0.04922543f, -0.03604237f, 0.06808778f, 0.23947221f, 
    -0.01455713f, 0.17752634f, -0.03517114f, 0.18910822f, 0.05360999f, 0.49043968f, -0.08375439f, -0.28185573f, 
    -0.14749497f, -0.08321185f, -0.12554343f, -0.20453733f, -0.04497395f, -0.24466297f, -0.09912634f, 0.34307793f, 
    0.02259937f, 0.18972838f, 0.03854196f, 0.09515430f, -0.14145085f, -0.04306477f, -0.01299205f, 0.03785485f, 
    -0.19869795f, -0.37975195f, 0.13981034f, -0.32868773f, -0.23273037f, -0.27559641f, 0.06789420f, -0.18919547f, 
    -0.14535120f, -0.17764854f, 0.15384027f, 0.07985455f, -0.23819755f, -0.42460448f, -0.22091965f, 0.09703746f, 
    0.03234437f, 0.32632783f, -0.05892045f, 0.17491406f, -0.08131704f, 0.18007088f, 0.00342739f, 0.08058224f, 
    0.10119532f, -0.20322391f, -0.07838983f, 0.06884828f, 0.14795937f, 0.17421626f, 0.10922095f, -0.12324957f, 
    0.32767308f, 0.28648174f, 0.15694369f, -0.15313296f, 0.07981046f, 0.09887565f, 0.04069179f, -0.11815196f, 
    -0.07373394f, 0.06901979f, -0.14916645f, 0.15548582f, 0.02163250f, 0.01522433f, 0.09156739f, 0.05538680f, 
    0.38370022f, 0.39226034f, 0.26139295f, -0.03396104f, -0.00427931f, -0.02397189f, -0.05905154f, 0.38845974f, 
    0.11738458f, -0.02128042f, 0.22586243f, 0.11720056f, -0.08604956f, -0.10863144f, -0.00388540f, 0.05272920f, 
    0.07949067f, 0.05600149f, -0.01635352f, 0.12460354f, -0.07931609f, -0.14415681f, 0.42071432f, -0.38759214f, 
    0.10388722f, -0.06925239f, 0.16322780f, 0.30295119f, 0.18323693f, -0.34355792f, -0.04126041f, 0.20702413f, 
    -0.16751191f, 0.29955813f, 0.08895821f, 0.06328998f, -0.07852861f, 0.08624180f, -0.07174321f, -0.28129110f, 
    -0.35162139f, -0.29338187f, 0.25927138f, 0.02586551f, 0.10577211f, 0.12994263f, 0.03418521f, -0.15460525f, 
    0.39747471f, 0.33196089f, 0.15933566f, 0.16413887f, -0.26967409f, -0.03780393f, -0.23688127f, 0.02453848f, 
    0.05397665f, 0.20967034f, 0.05178098f, 0.15826632f, 0.01105378f, 0.09907360f, 0.01899466f, 0.01379190f, 
    0.07941790f, 0.17404301f, 0.25729996f, 0.42227179f, 0.14125633f, -0.11925954f, 0.00704154f, 0.24766397f, 
    0.12977871f, 0.13162586f, 0.05099951f, 0.29684705f, -0.56772864f, -0.33896536f, 0.28228340f, -0.04529287f, 
    -0.10026635f, 0.20282313f, -0.15386473f, -0.08559147f, 0.37497920f, 0.37341762f, 0.35322464f, -0.17230099f, 
    0.01479995f, 0.07956535f, 0.03990220f, -0.01525615f, 0.02212524f, -0.21615209f, -0.10490000f, -0.11638711f, 
    -0.00667033f, 0.15830652f, 0.11083498f, -0.23353185f, 0.09484114f, 0.50589895f, -0.01980854f, -0.18487047f, 
    0.05430081f, -0.18325616f, -0.19692217f, -0.07682210f, 0.02948290f, 0.13880399f, -0.08592207f, 0.16459073f, 
    -0.00946777f, 0.03451924f, 0.06706769f, 0.06221877f, 0.03733260f, 0.18534422f, 0.12424335f, 0.06445672f, 
    -0.16622542f, -0.19245701f, -0.02978906f, 0.03859993f, 0.04015603f, -0.18626201f, 0.04106731f, 0.17452940f, 
    -0.05934072f, 0.01845583f, 0.18844479f, 0.12363912f, 0.12202482f, 0.02010119f, -0.06183207f, -0.06784979f, 
    0.16754074f, -0.12479492f, -0.31105897f, -0.29928896f, -0.15927823f, 0.04842225f, -0.26918134f, -0.27611226f, 
    -0.02571774f, -0.10238492f, -0.33629370f, -0.03394694f, -0.14295469f, 0.25902444f, -0.01745504f, 0.01903187f, 
    -0.16315639f, 0.07351289f, 0.00592056f, -0.27710715f, -0.49550197f, -0.10662194f, -0.03598342f, 0.06026533f, 
    0.25178814f, 0.13772696f, -0.04532274f, 0.10619472f, -0.09742677f, 0.13577279f, -0.13816984f, 0.09850365f, 
    0.04578719f, -0.04313932f, -0.19781876f, -0.02593516f, 0.17985088f, 0.08269313f, -0.19355361f, -0.44709486f, 
    -0.01832949f, -0.13358840f, 0.04704055f, 0.09879579f, 0.05444402f, -0.08052880f, 0.17338489f, 0.13572736f, 
    -0.14492607f, 0.36724299f, 0.13875151f, -0.04709356f, 0.02714834f, 0.13771486f, -0.21931623f, -0.09118603f, 
    0.08713643f, -0.68934900f, -0.00529121f, -0.07217742f, -0.00063154f, -0.08448219f, -0.05643645f, 0.04023959f, 
    0.02152199f, 0.07198196f, 0.02381620f, 0.33667767f, 0.03761484f, 0.12591939f, 0.00997831f, -0.03368968f, 
    -0.02558382f, 0.10737491f, 0.29484805f, 0.15366033f, 0.12824245f, -0.02233418f, 0.09090518f, 0.00390967f, 
    0.12472448f, 0.02528175f, 0.38081905f, -0.30874741f, -0.26063147f, -1.09176874f, -0.08638609f, -0.19371635f, 
    -0.00522687f, 0.04238566f, 0.00678875f, -0.02223293f, 0.02103768f, -0.08803733f, 0.21149471f, 0.01574325f, 
    0.11135975f, -0.15883435f, -0.09615546f, 0.12144368f, 0.16436835f, -0.03160869f, 0.11772312f, 0.07549240f, 
    0.12940995f, -0.02034060f, -0.11366908f, 0.04701376f, 0.09154150f, 0.02995565f, -0.22149052f, 0.05965615f, 
    0.10483605f, -0.15096371f, 0.02784611f, -0.06648134f, 0.02572152f, -0.10006192f, 0.06224591f, 0.58120590f, 
    -0.15416935f, -0.05866699f, 0.22158000f, 0.00584573f, 0.25246537f, 0.12242529f, 0.12561962f, 0.09912964f, 
    0.30043611f, -0.15015416f, -0.39585975f, 0.05913820f, -0.19698583f, -0.12336950f, -0.08346813f, 0.04814055f, 
    0.06756859f, -0.01607331f, 0.24393176f, -0.10296214f, 0.12902327f, -0.02112443f, 0.10368182f, 0.22227010f, 
    0.08510516f, 0.21430534f, -0.04630795f, -0.69881195f, -0.01226427f, -0.00407525f, -0.02506340f, -0.11856981f, 
    0.06480060f, 0.01914886f, 0.05790685f, -0.42082477f, -0.20118240f, -0.35736129f, 0.23388588f, -0.09256051f, 
    -0.04278822f, 0.10333734f, -0.04170642f, 0.12793067f, 0.04540260f, -0.13037474f, -0.02502727f, 0.01317404f, 
    0.07716106f, -0.24815014f, 0.03402066f, -0.05626497f, 0.11896073f, -0.64164054f, -0.63778722f, -0.14081508f, 
    -0.06624213f, 0.03174232f, 0.01463222f, -0.00374568f, -0.08806477f, -0.02140937f, -0.48266253f, -0.16766620f, 
    0.44154468f, -0.11652821f, 0.05145531f, 0.04279697f, 0.06261206f, -0.05990909f, 0.04852032f, -0.14590923f, 
    0.04601466f, 0.31645223f, -0.20709826f, -0.03560812f, -0.46624875f, 0.01496991f, -0.05713319f, 0.05690591f, 
    -0.05091082f, 0.05221020f, 0.06608335f, -0.04773172f, 0.01994772f, 0.01434879f, -0.05070093f, 0.05452343f, 
    0.01484618f, 0.01262346f, -0.00829971f, -0.08793911f, 0.02065027f, 0.00866261f, 0.02612670f, -0.04213559f, 
    -0.07184490f, 0.02996377f, 0.01623256f, 0.03210741f, 0.01719464f, 0.05396130f, -0.09066668f, -0.06692591f, 
    -0.06361488f, -0.06929173f, 0.04145779f, 0.04160250f, -0.06735163f, -0.07651343f, 0.02226546f, 0.00730329f, 
    -0.02373419f, 0.02210475f, 0.05344013f, -0.07893464f, 0.03633916f, 0.00003465f, 0.02721143f, 0.03905825f, 
    -0.07633797f, 0.05570998f, 0.00459850f, -0.02125656f, 0.05303335f, -0.05570599f, 0.05990078f, 0.01663519f, 
    -0.08337294f, 0.04960280f, 0.00711350f, -0.01764606f, -0.07122400f, 0.01097536f, 0.06742540f, 0.01950267f, 
    0.00689164f, -0.08743933f, -0.01353166f, 0.01532714f, 0.01161324f, -0.09614386f, 0.02805942f, 0.05350821f, 
    0.01312567f, -0.08650862f, -0.06493531f, 0.03910680f, -0.05677156f, -0.08618086f, -0.09641507f, 0.05348969f, 
    0.00750500f, -0.06942294f, -0.05724584f, -0.07885713f, -0.07545146f, -0.00586244f, 0.01595797f, -0.05227078f, 
    -0.07749539f, -0.06844763f, -0.08863856f, 0.07225443f, -0.00150151f, 0.04305460f, -0.01587472f, -0.07743839f, 
    -0.07433521f, 0.00095095f, -0.08355396f, -0.00824479f, 0.01879049f, 0.05760645f, -0.08913493f, -0.08661599f, 
    0.04819718f, -0.05748169f, -0.05334073f, -0.06713966f, -0.00842795f, 0.05635922f, -0.02299198f, 0.03300595f, 
    -0.08227721f, -0.05216120f, 0.01825960f, -0.07752412f, -0.08188979f, 0.02116555f, -0.09630776f, -0.03510416f, 
    0.02374364f, 0.03816592f, -0.03555228f, -0.01636917f, 0.03372733f, 0.06064729f, 0.00467880f, -0.04077050f, 
    0.06227545f, 0.03150607f, -0.05210837f, -0.03279014f, -0.08438411f, -0.06858052f, 0.05302946f, 0.00890940f, 
    0.03285845f, -0.08221523f, -0.07246336f, -0.08497927f, -0.07313861f, -0.07823966f, -0.07755961f, 0.05667924f, 
    -0.04908289f, -0.02976190f, -0.03501867f, -0.02639232f, -0.03200398f, -0.00305938f, -0.08799871f, -0.04262604f, 
    0.07573502f, -0.30024928f, -0.24923865f, 0.09884144f, 0.02925166f, 0.01173901f, 0.03589052f, -0.08106273f, 
    -0.15705302f, 0.13809134f, -0.54899466f, -0.11453050f, 0.15918343f, 0.12661944f, -0.17105806f, -0.02111028f, 
    0.03358245f, 0.08560070f, 0.01425631f, -0.19237769f, 0.03827231f, 0.09819397f, 0.03107642f, 0.03366102f, 
    -0.02732224f, 0.00574072f, 0.09737807f, 0.28964174f, -0.13087654f, -0.00340180f, -0.10872199f, 0.13304870f, 
    0.14077324f, -0.00886410f, 0.18130295f, -0.20553085f, 0.22877765f, -0.27112421f, 0.01758780f, 0.07240595f, 
    0.13682112f, -0.10026817f, 0.05158810f, 0.03913960f, 0.11464009f, 0.39283231f, -0.37605140f, -0.36974123f, 
    -0.04116913f, 0.00181411f, 0.06239108f, -0.09585634f, 0.09961749f, 0.11600891f, -0.02764777f, 0.11293148f, 
    -0.09269655f, -0.00854821f, -0.12613882f, -0.06546455f, 0.07824302f, 0.23051728f, 0.41561645f, 0.05592193f, 
    0.18096612f, -0.54937243f, 0.14225535f, 0.00250303f, 0.34936062f, 0.14431843f, 0.16134202f, 0.10765203f, 
    -0.03243770f, 0.03448994f, 0.19821437f, -0.09195855f, 0.10399952f, -0.16954945f, -0.05731458f, -0.01637682f, 
    -0.08433505f, -0.65497482f, -0.90005392f, 0.03162794f, -0.03205710f, 0.25853330f, 0.10934804f, 0.11633893f, 
    0.13969749f, 0.00881396f, 0.07913760f, -0.24242651f, 0.03781781f, -0.18536586f, 0.37589201f, 0.01753360f, 
    -0.03244885f, -0.09816813f, -0.14118533f, -0.15937972f, -0.00196787f, 0.50665677f, -0.06453440f, 0.14642234f, 
    0.08578745f, 0.22517741f, 0.04202851f, -0.28918764f, 0.07863428f, 0.06299336f, 0.19682291f, -0.22054164f, 
    0.06398256f, -0.12530416f, 0.19991331f, 0.03313375f, 0.04741773f, -0.09359203f, -0.20698224f, -0.05128264f, 
    -0.05556363f, -0.11069316f, -0.23745047f, 0.09691806f, -0.06546041f, 0.25969994f, 0.17614381f, 0.28420535f, 
    0.11537696f, -0.12689467f, -0.13044864f, -0.09275484f, 0.10580651f, -0.02770095f, -0.01522284f, 0.24519701f, 
    0.28374541f, 0.85175198f, -0.16474071f, -0.06419141f, -0.13727908f, -0.02041281f, -0.32547718f, 0.33253253f, 
    -0.40324903f, 0.16876206f, 0.21265668f, -0.01856234f, -0.02892754f, -0.03987480f, -0.19214176f, -0.02570827f, 
    -0.05932998f, -0.07653446f, -0.16345175f, 0.28302488f, 0.07565683f, -0.07099383f, -0.19830495f, 0.04749700f, 
    0.15886030f, 0.12510468f, -0.10488160f, 0.40486184f, -0.04382879f, -0.15695111f, -0.07917398f, 0.13532676f, 
    0.14703362f, 0.13204861f, 0.16416779f, -0.58988291f, 0.16061538f, -0.14163184f, -0.07866904f, 0.11177619f, 
    0.11189049f, -0.09885860f, 0.07803734f, -0.33980146f, -0.42341948f, 0.30710065f, 0.07151531f, -0.19359697f, 
    0.05039874f, 0.04127559f, 0.16154191f, 0.11191720f, 0.04074572f, -0.21210834f, 0.30294627f, 0.01343304f, 
    0.19274510f, -0.28251448f, -0.00835702f, 0.17622755f, -0.12669235f, -0.00229804f, -0.81788081f, 0.10690617f, 
    0.01204362f, -0.02394362f, -0.04953501f, -0.03703753f, -0.01204537f, -0.06753238f, 0.12640406f, -0.28189191f, 
    -0.18530563f, -0.19083704f, 0.17197467f, 0.08619327f, 0.08115144f, 0.08210056f, -0.11779528f, -0.11586522f, 
    -0.30220842f, 0.14336275f, 0.17075019f, 0.19614507f, -0.07321446f, -0.19664377f, -0.13642816f, -0.02260576f, 
    0.25245708f, 0.39950761f, 0.42585808f, 0.05695022f, 0.09709975f, -0.06184354f, 0.11534056f, -0.06010602f, 
    0.05341960f, -0.07918549f, 0.01185781f, -0.18141139f, 0.01648337f, 0.10831292f, 0.05172117f, -0.09462868f, 
    0.15021504f, -0.06309740f, -0.06670543f, 0.10429285f, -0.11433496f, 0.21455561f, -0.12421282f, -0.03942556f, 
    0.18079844f, 0.06689495f, -0.02432561f, 0.09366313f, -0.08509831f, 0.11818829f, 0.03926176f, 0.01905425f, 
    0.09595087f, -0.07148420f, 0.04009794f, 0.01547793f, 0.14893177f, -0.07826717f, -0.26108378f, 0.52937204f, 
    -0.10039103f, 0.08694030f, -0.12331344f, -0.04660044f, -0.01368721f, 0.21818809f, 0.08751679f, 0.52276373f, 
    0.39491433f, -0.18328670f, -0.19861586f, -0.22303917f, 0.03059391f, 0.04452840f, 0.09178418f, 0.02353576f, 
    0.09887010f, 0.40262547f, -0.08495401f, -0.09712616f, -0.34378523f, 0.16863564f, 0.01843090f, -0.03007626f, 
    0.06128541f, -0.11424357f, 0.23220134f, 0.04321909f, -0.02617753f, 0.14803830f, 0.13599280f, -0.37903577f, 
    0.14107649f, -0.16994430f, 0.13163333f, -0.21718854f, -0.02213089f, -0.06484325f, 0.04617897f, 0.00893869f, 
    0.07786917f, -0.23968859f, 0.23884475f, -0.01883890f, 0.17691122f, -0.07229831f, -0.00491178f, 0.03372971f, 
    -0.04571855f, 0.24193855f, 0.13189375f, -0.53442436f, 0.35202804f, 0.24959774f, 0.06292255f, 0.20174883f, 
    -0.10755634f, 0.21041743f, -0.00339890f, -0.01894278f, 0.09406063f, 0.06711825f, 0.20962590f, 0.00758543f, 
    0.10155141f, 0.03523102f, -0.05182297f, 0.08674039f, 0.00802225f, -0.41941911f, 0.18610029f, -0.25058183f, 
    -0.03717266f, -0.14930375f, -0.11489081f, 0.02851834f, -0.22902222f, -0.05512922f, 0.05468665f, 0.05609425f, 
    0.13152280f, 0.07561284f, -0.09107914f, 0.03079933f, -0.08275114f, -0.14524233f, 0.01178525f, 0.10654698f, 
    0.10176575f, 0.28528416f, 0.17864273f, 0.19913448f, 0.13087571f, 0.34099928f, -0.28835723f, -0.04204867f, 
    -0.12652273f, 0.11601132f, 0.27948552f, 0.18405463f, -0.13228539f, -0.06299175f, -0.11483768f, 0.09139896f, 
    0.11103162f, 0.31119400f, -0.01248008f, 0.00184404f, 0.01188670f, 0.03924629f, 0.05568917f, -0.09915937f, 
    -0.02630187f, -0.03754364f, 0.00666943f, 0.06945781f, 0.20191672f, 0.16638067f, -0.00141037f, 0.14383389f, 
    0.12864929f, 0.01026929f, 0.10356315f, -0.11361831f, -0.17277178f, -0.58267361f, 0.02933568f, 0.00813679f, 
    0.17992820f, -0.00846931f, 0.10097817f, 0.34721279f, 0.21292305f, 0.19638394f, 0.24000445f, -0.18136296f, 
    0.15387774f, -0.02239960f, -0.09571003f, -0.06033961f, -0.16668656f, -0.03053766f, -0.09996819f, -0.41132286f, 
    -0.03388308f, 0.04602814f, -0.19273721f, -0.00243827f, 0.22257881f, -0.19888933f, -0.06693053f, 0.05766501f, 
    -0.03651424f, -0.15308562f, -0.08566778f, -0.16667183f, -0.02428387f, -0.06498618f, 0.03612862f, 0.46962053f, 
    -0.05209409f, 0.10816403f, -0.03077209f, 0.07756875f, 0.01840576f, 0.07374489f, 0.09661179f, -0.02207926f, 
    -0.21346103f, 0.19049616f, 0.11930447f, -0.00101254f, 0.11743599f, -0.00294002f, -0.08429223f, 0.03141387f, 
    0.12291639f, 0.47605246f, -0.01815354f, -0.60687435f, 0.03685156f, -0.00510014f, 0.04592329f, 0.07838836f, 
    0.00121107f, 0.01018652f, -0.14629306f, 0.14975065f, 0.16082111f, 0.00645151f, 0.03761039f, -0.21499641f, 
    0.07949988f, -0.02900033f, 0.03753884f, 0.69967461f, 0.15872104f, -0.35238838f, -0.07434103f, 0.10175245f, 
    -0.08526384f, 0.08252765f, 0.15312774f, -0.18834911f, -0.14226829f, 0.02561189f, 0.17642149f, -0.03426528f, 
    -0.02428772f, -0.06253770f, 0.12066797f, -0.12032515f, 0.02780942f, -0.07838809f, -0.23999356f, 0.05040915f, 
    0.05501546f, -0.00766453f, -0.05471661f, 0.08150750f, 0.04735810f, 0.03536640f, -0.20301500f, -0.09760731f, 
    0.30494708f, -0.12516794f, 0.11395104f, 0.10079419f, -0.06784251f, -0.24754079f, 0.06038880f, -0.24036521f, 
    -0.03491582f, 0.05378021f, -0.25326005f, 0.23844329f, 0.04871531f, -0.17270580f, -0.28748444f, 0.11226527f, 
    0.08733433f, 0.38338801f, 0.17275549f, 0.19137380f, -0.07710075f, -0.25607318f, 0.25687590f, 0.01196235f, 
    -0.09622284f, -0.04222586f, 0.09087085f, -0.31113717f, -0.09459228f, -0.00742712f, -0.00754600f, -0.03015228f, 
    0.01387374f, 0.01012015f, 0.08182921f, -0.02507449f, -0.05232079f, 0.17281261f, 0.02918718f, 0.14138177f, 
    0.09756289f, -0.03945562f, 0.09955125f, 0.19638659f, -0.06182282f, 0.10604774f, -0.09800492f, 0.02654634f, 
    -0.02602579f, 0.14471467f, 0.02761997f, 0.08738500f, 0.13576448f, 0.24749391f, 0.41585746f, -0.30937529f, 
    -0.05471688f, -0.46258992f, 0.04465851f, 0.02885878f, -0.08836008f, 0.40934503f, 0.12428620f, -0.15445088f, 
    -0.16792041f, -0.08499423f, -0.04318962f, -0.04663009f, 0.08094403f, -0.12913141f, 0.24498871f, -0.14036253f, 
    0.11063079f, -0.26951107f, -0.03779361f, -0.11674470f, 0.02059705f, 0.03891464f, -0.06782545f, 0.70322943f, 
    0.31763083f, -0.12844247f, -0.10323264f, -0.23792440f, -0.26770973f, -0.03072282f, -0.09871744f, 0.16485670f, 
    -0.02952095f, 0.15002060f, -0.25487521f, 0.04193481f, -0.07477886f, 0.15420769f, 0.06887919f, 0.04051343f, 
    -0.00610657f, 0.02179433f, -0.09957968f, 0.14355640f, -0.12335633f, -0.09059497f, 0.08428338f, 0.11079147f, 
    -0.02910328f, 0.11843856f, 0.15938255f, -0.17054662f, -0.26313728f, 0.10969310f, -0.05231395f, -0.04584924f, 
    0.19804242f, 0.02368713f, 0.03451405f, 0.30214077f, 0.00634677f, -0.32329756f, -0.28916046f, -0.02039294f, 
    0.38420621f, 0.18314715f, 0.00953594f, 0.30325171f, 0.35610321f, -0.05951665f, -0.33887732f, 0.11398147f, 
    0.12599643f, 0.04289464f, 0.05469209f, 0.01585279f, -0.00838361f, -0.16572744f, -0.10820191f, -0.04538373f, 
    -0.20793636f, 0.25154793f, 0.15389174f, 0.10550713f, 0.14481841f, 0.13093527f, -0.05645514f, 0.02734277f, 
    -0.59425187f, 0.01561620f, 0.09610067f, -0.00365327f, 0.09667242f, 0.18826759f, 0.07866284f, -0.25871763f, 
    0.05487442f, -0.21444468f, -0.07214436f, 0.09730551f, -0.12995203f, 0.04381632f, -0.06208584f, -0.23920844f, 
    0.27339631f, -0.06674450f, -0.01798703f, 0.25826189f, 0.14866726f, 0.11471206f, -0.10047535f, 0.20653507f, 
    -0.27725953f, -0.07880200f, 0.33693081f, 0.14054000f, 0.18033335f, 0.07434314f, -0.06523066f, -0.04834773f, 
    -0.11728942f, -0.03308226f, 0.03539207f, -0.07355734f, -0.00168905f, 0.08812223f, -0.06363094f, -0.10905020f, 
    -0.14213073f, -0.52703846f, -0.37233049f, 0.06437002f, 0.14585640f, 0.19195715f, 0.14282537f, 0.08070755f, 
    -0.23266202f, -0.36070436f, -0.08487701f, -0.22865123f, -0.00989812f, -0.10069352f, -0.25463971f, 0.22466433f, 
    0.16220671f, 0.13952734f, -0.03207343f, -0.04764424f, 0.14349717f, 0.12003901f, 0.04569848f, 0.14716558f, 
    0.11693601f, -0.12256867f, 0.11789297f, 0.05536035f, 0.00189690f, -0.01666280f, 0.27733609f, -0.19439925f, 
    0.30304489f, 0.05355602f, 0.20541926f, 0.05702541f, 0.20706955f, -0.15957777f, 0.10189275f, 0.22739494f, 
    0.04027120f, 0.57679468f, 0.25678745f, 0.10535443f, 0.16624543f, -0.16293293f, -0.07418688f, -0.04601577f, 
    -0.59939182f, -0.49229699f, 0.27992141f, -0.17069283f, -0.35306752f, -0.22606476f, -0.01874092f, 0.10441185f, 
    0.10049680f, 0.33691496f, 0.18026242f, 0.13174666f, 0.12216768f, 0.35482603f, 0.12752359f, 0.01272787f, 
    0.07219829f, -0.15830000f, -0.16640632f, -0.22021057f, 0.13063499f, 0.08173580f, -0.08597413f, -0.04477772f, 
    0.00113222f, -0.01749216f, 0.20859130f, 0.83893740f, 0.18615445f, -0.66401404f, 0.12484517f, 0.20286196f, 
    -0.12846240f, -0.00957605f, -0.04606317f, -0.14908870f, -0.82966572f, -0.35519952f, 0.13791680f, -0.19550100f, 
    -0.04055113f, 0.05534977f, 0.03784018f, 0.14752130f, 0.11181079f, 0.60580003f, 0.51533365f, 0.25503016f, 
    0.08099167f, 0.03404410f, 0.01127498f, 0.03776659f, 0.03993863f, -0.13407265f, 0.12667036f, 0.20544390f, 
    -0.09249153f, 0.02702570f, 0.12683535f, 0.16370764f, 0.05888867f, 0.12629034f, -0.05702383f, -0.27958927f, 
    0.11627956f, 0.02023465f, 0.02507247f, -0.11086076f, -0.03987601f, 0.25687611f, 0.08346370f, -0.10752630f, 
    -0.19321932f, -0.14812072f, -0.50810027f, 0.07795316f, 0.16028920f, -0.22384700f, 0.12261193f, 0.13988160f, 
    0.36013117f, -0.20284627f, 0.26932317f, -0.00852377f, 0.00190472f, 0.06402103f, 0.03028961f, 0.01910523f, 
    0.07141672f, -0.09766550f, 0.23611504f, 0.00434418f, -0.08723324f, -0.05546289f, -0.26515609f, 0.15800135f, 
    -0.18196373f, -0.16651736f, 0.21076469f, 0.17658930f, 0.04230511f, 0.01062732f, -0.01402684f, -0.00836581f, 
    -0.02213444f, 0.04296885f, 0.05177012f, 0.22740132f, -0.16121855f, -0.43405902f, -0.05264620f, 0.05760785f, 
    0.05845100f, -0.07315415f, 0.08471619f, -0.07542685f, -0.07387048f, -0.07885415f, 0.06962106f, -0.09827705f, 
    -0.13677286f, -0.02221828f, 0.14513814f, -0.07785774f, -0.14759746f, 0.05493631f, -0.51578319f, -0.12753785f, 
    -0.01560507f, 0.08075493f, 0.15728132f, 0.14291768f, 0.11935280f, -0.05868580f, 0.19900501f, 0.08406927f, 
    0.05694747f, 0.16376407f, -0.23011492f, -0.27751768f, 0.05546510f, 0.07446820f, -0.02350145f, -0.02208099f, 
    -0.12329818f, -0.84303266f, -0.22535992f, -0.05622995f, 0.15233143f, -0.24222803f, -0.05617966f, -0.26382318f, 
    -0.07547949f, -0.12111232f, 0.42915490f, 0.26341882f, 0.15226708f, 0.07751470f, 0.14863993f, 0.03279515f, 
    0.06831712f, 0.04560967f, -0.11792496f, -0.03499451f, -0.13551587f, 0.13607976f, 0.17195261f, 0.03477445f, 
    0.19137819f, 0.24165967f, -0.02388727f, -0.71149892f, -0.53920072f, -0.48638135f, -0.16775994f, -0.02586306f, 
    -0.16897859f, 0.09060331f, -0.00206540f, -0.10199228f, 0.02776177f, -0.13865210f, 0.26188195f, 0.11274061f, 
    0.12239270f, -0.05218168f, 0.07042520f, -0.01685641f, 0.17980506f, -0.05310160f, 0.02628829f, 0.63795733f, 
    -0.11792523f, 0.04516561f, 0.11982697f, 0.18231721f, 0.04067708f, 0.00559698f, -0.33410436f, -0.52744669f, 
    0.09351175f, -0.33067802f, 0.07399961f, -0.06811998f, -0.10046128f, -0.12678190f, 0.08222189f, 0.31149042f, 
    -0.28099886f, -0.18974067f, -0.10065067f, 0.32422447f, 0.14795791f, 0.04486922f, 0.06559362f, 0.10314263f, 
    0.00431004f, -0.43743676f, -0.29034394f, -0.12174456f, 0.06111188f, -0.04542534f, 0.10201715f, 0.01943882f, 
    0.06354248f, 0.14780362f, -0.11583941f, -0.38117498f, 0.27243745f, 0.16285004f, -0.05343679f, 0.08221751f, 
    0.05656765f, -0.06542323f, -0.20740756f, -0.26289397f, -0.01365224f, 0.07964081f, -0.07792463f, -0.16313851f, 
    -0.18832226f, 0.02330316f, -0.08547387f, -0.05166449f, -0.00060652f, -0.11964201f, -0.03195886f, 0.08289285f, 
    -0.20758979f, -0.00227022f, 0.13886710f, 0.03809562f, -0.28120786f, 0.12692869f, 0.21543416f, -0.29323447f, 
    -0.17468086f, -0.09419883f, 0.09403934f, 0.02749175f, -0.06248866f, -0.32919466f, -0.10506251f, -0.34279028f, 
    -0.15710738f, 0.03540434f, -0.08937331f, 0.17172529f, 0.02778847f, -0.05332643f, 0.18287440f, 0.28057131f, 
    0.54670084f, -0.07501262f, -0.17610763f, 0.01140918f, 0.12732136f, 0.16636825f, 0.15167592f, 0.06588443f, 
    0.14724836f, -0.16037923f, -0.67289996f, -0.48915601f, -0.40009162f, 0.18017495f, 0.08142549f, 0.12256578f, 
    -0.58469528f, -0.01696352f, 0.01352921f, 0.11644739f, 0.01328162f, -0.21755157f, 0.17101800f, -0.07128043f, 
    0.23773375f, 0.10220485f, 0.27458334f, -0.27764794f, -0.11629595f, 0.12299708f, 0.00158377f, -0.06230929f, 
    0.06493517f, 0.00380750f, 0.03211975f, 0.00285317f, 0.07558782f, 0.12992467f, -0.01657866f, 0.01667046f, 
    -0.02294119f, -0.06708116f, 0.05600818f, -0.04830230f, 0.42390603f, -0.03077681f, -0.01448758f, 0.23888566f, 
    0.26101986f, -0.11600960f, 0.07061119f, -0.06737754f, -0.27183965f, 0.13563752f, -0.13891654f, 0.08210494f, 
    0.11727279f, -0.16606474f, -0.15398741f, 0.07711317f, 0.04170491f, -0.07608760f, 0.10245591f, -0.13822691f, 
    0.24762285f, -0.09037593f, -0.02311741f, -0.04049098f, 0.11325656f, -0.10183343f, 0.25030193f, 0.13753738f, 
    0.20507249f, 0.20971616f, -0.01499442f, -0.11911608f, -0.08898538f, -0.11455292f, -0.08299144f, -0.02227890f, 
    0.01735840f, -0.42111385f, 0.01184514f, 0.22448833f, 0.26590914f, 0.03295464f, 0.29043642f, -0.13514590f, 
    -0.20925882f, 0.24512337f, 0.29715726f, -0.09497157f, -0.36347732f, -0.11152667f, 0.14640585f, -0.05963803f, 
    -0.05571828f, 0.09785541f, -0.10214692f, 0.23208541f, -0.01425134f, 0.04311015f, -0.01078702f, 0.07567764f, 
    -0.20153034f, -0.13961130f, -0.43764624f, 0.15309840f, 0.03137406f, 0.05010830f, 0.09044102f, -0.06887197f, 
    0.20089670f, -0.05453334f, 0.20955661f, 0.06471764f, -0.31250870f, 0.25837845f, -0.23653379f, -0.09667905f, 
    0.00751945f, 0.03937702f, -0.30385768f, 0.15932463f, 0.25149503f, 0.04902314f, -0.20217851f, -0.24878018f, 
    -0.17055781f, -0.06867038f, 0.15669867f, 0.19789566f, 0.00814259f, -0.28756303f, -0.36279675f, -0.16610359f, 
    -0.07542255f, 0.06818341f, -0.24715471f, 0.06326743f, -0.02039368f, -0.12529896f, 0.16651694f, 0.27667171f, 
    0.20067458f, -0.02509545f, 0.05941057f, 0.01062806f, 0.02772204f, 0.03040995f, -0.03058264f, -0.26487827f, 
    -0.12706904f, 0.18989262f, -0.09517127f, -0.19723246f, -0.20909035f, 0.10827035f, -0.04673544f, 0.02753669f, 
    -0.04100108f, 0.00141414f, -0.08233056f, 0.02362959f, 0.00298307f, -0.02022606f, -0.02031214f, 0.03374201f, 
    0.05056744f, -0.02566541f, 0.02373231f, 0.03611067f, -0.07296471f, -0.07833911f, 0.07413814f, 0.03013545f, 
    -0.05984480f, 0.07282282f, 0.01824453f, 0.01613125f, -0.00316270f, 0.01250832f, -0.05689263f, -0.03263894f, 
    -0.08038208f, -0.04090753f, -0.07010932f, 0.06580742f, 0.05979443f, -0.08363167f, -0.07778350f, 0.00384232f, 
    -0.06564608f, -0.03116980f, 0.02887569f, 0.04589197f, 0.03295286f, 0.04006121f, -0.05372255f, -0.07095651f, 
    0.03863835f, -0.03155439f, -0.05548219f, -0.00195468f, -0.00097393f, 0.03217943f, -0.07984351f, 0.02081601f, 
    0.01336695f, -0.03794427f, 0.04313360f, 0.02110226f, -0.07741033f, 0.01246562f, -0.06856554f, -0.02823433f, 
    0.02311557f, 0.00129155f, 0.04528322f, 0.00721539f, -0.09363759f, 0.05776687f, 0.01429274f, 0.02714412f, 
    -0.04517245f, 0.06782177f, -0.02117907f, -0.06380110f, -0.01268346f, -0.09063361f, 0.04814671f, 0.02118555f, 
    0.03938349f, 0.00709922f, 0.00445953f, -0.03769910f, -0.04276280f, -0.00872580f, -0.02450586f, 0.01632339f, 
    -0.02954232f, -0.07029995f, -0.06978115f, -0.02504261f, -0.00740534f, -0.05739850f, -0.03370510f, -0.01215454f, 
    0.06746315f, 0.02459107f, -0.03220312f, -0.04478962f, -0.04434909f, -0.04767438f, 0.05123137f, 0.01678373f, 
    0.01070890f, 0.02922250f, -0.08789546f, -0.06726966f, 0.05111961f, -0.01573317f, -0.09107945f, 0.00310842f, 
    -0.06441643f, 0.00965088f, -0.01441024f, -0.02207606f, 0.06807449f, -0.04624525f, -0.01819790f, -0.01765195f, 
    0.04907423f, -0.02298733f, -0.02247923f, -0.06315611f, -0.02339456f, -0.05776359f, 0.04323423f, -0.03169288f, 
    -0.04841988f, -0.05760493f, -0.03888066f, -0.07537725f, 0.00369953f, -0.07202606f, -0.05458851f, 0.05416305f, 
    0.03159150f, 0.07192588f, -0.02352093f, -0.02122540f, -0.06748103f, 0.06514957f, -0.02518190f, -0.01741328f, 
    0.06003666f, 0.04098720f, -0.02065649f, 0.03966832f, 0.02751669f, 0.04213782f, -0.08193950f, -0.08938208f, 
    -0.00300053f, 0.03941952f, 0.02932450f, -0.01386265f, -0.07230280f, -0.07758461f, -0.03212442f, -0.08359995f, 
    0.06898692f, 0.02898282f, -0.01814883f, -0.01454585f, -0.08912575f, -0.05274313f, -0.03252901f, 0.02678217f, 
    0.06553746f, -0.01999197f, -0.07881766f, 0.00492810f, 0.02138391f, -0.04763331f, 0.07344958f, -0.03273271f, 
    0.05801094f, 0.00333919f, -0.04752578f, 0.02827874f, -0.04080210f, -0.04075753f, 0.00536726f, 0.00508641f, 
    -0.06743830f, -0.04382420f, -0.07054135f, -0.08348648f, 0.04406649f, -0.00091345f, -0.01998172f, -0.07995246f, 
    0.03566771f, -0.06408225f, 0.00876949f, 0.05945175f, 0.00149113f, 0.03554054f, -0.04328410f, 0.02004456f, 
    0.04436556f, 0.03564231f, -0.09278087f, -0.08162980f, -0.05181585f, -0.02981772f, -0.07461766f, 0.05160939f, 
    0.02866956f, 0.01409814f, 0.01079363f, -0.07364681f, -0.01425787f, -0.06887294f, -0.00098148f, -0.08012938f, 
    -0.08295240f, -0.04302953f, -0.05831647f, -0.01316449f, -0.04450620f, -0.04178065f, -0.05880455f, 0.04761897f, 
    0.02515858f, 0.03708062f, 0.01440904f, -0.07773864f, -0.01860512f, -0.01991503f, -0.09130584f, 0.03966144f, 
    0.05999190f, 0.02993489f, -0.05033716f, -0.09697852f, 0.05919970f, -0.08158042f, 0.04404133f, -0.05730749f, 
    -0.02933406f, -0.02139023f, -0.07654019f, -0.06310530f, -0.00371310f, -0.04014099f, -0.05907912f, -0.03951994f, 
    0.02580394f, 0.02906345f, 0.01957939f, -0.02868994f, 0.00099238f, 0.01098790f, 0.06154062f, -0.02865173f, 
    0.02665407f, 0.04610017f, 0.01815703f, -0.05902365f, -0.03919598f, -0.05841288f, -0.01204194f, 0.03995273f, 
    0.05288533f, 0.06238394f, 0.03485620f, -0.06685270f, 0.02165948f, 0.04504120f, -0.03105920f, -0.05013432f, 
    -0.01257419f, 0.01208801f, 0.06764632f, -0.08123573f, -0.04711464f, -0.07078290f, -0.09465947f, -0.03474512f, 
    -0.07520178f, -0.07574032f, -0.00234241f, -0.03789686f, 0.03526167f, -0.03608499f, -0.04998938f, -0.00692099f, 
    0.00984222f, 0.01335895f, -0.03515176f, 0.03741866f, 0.05901556f, -0.01573910f, -0.07727645f, 0.03605826f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.19804792f, 0.07590559f, 0.08716422f, 0.24618150f, 0.51383841f, -0.04419027f, 0.07428406f, -0.06446114f, 
    0.22948191f, -0.16328688f, -0.17521271f, 0.04818970f, 0.39049989f, 0.00442889f, 0.06279183f, -0.07707355f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.63935858f, 0.30650300f, -0.24190345f, 0.28289801f, -0.37417191f, -0.20425552f, 0.32873327f, -0.19859475f, 
    0.14347392f, 0.29007822f, 0.03732249f, 0.40867120f, 0.21631150f, -0.09815275f, -0.02282113f, -0.12486974f, 
    -0.04993834f, 0.37416467f, -0.12819795f, 0.10835347f, -0.60801905f, -0.13320315f, 0.12445962f, -0.48078367f, 
    0.11221526f, 0.41703278f, -0.10926027f, 0.12992148f, -0.38011721f, -0.71823233f, -0.12299183f, -0.01718652f, 
    -0.15502116f, 0.08519397f, -0.07942809f, 0.18262143f, -0.23174810f, -0.03476866f, 0.29780185f, 0.43949744f, 
    -0.18060508f, -0.23548193f, 0.38554022f, -0.35188958f, -0.08164077f, 0.41567689f, -0.24469548f, 0.13668165f, 
    0.10607693f, -0.14580700f, 0.08535890f, 0.18665376f, 0.32139429f, -0.17018960f, 0.12261846f, -0.26413333f, 
    0.23253359f, -0.13937868f, 0.09526835f, -0.04840225f, 0.62663388f, -0.46093148f, 0.00699676f, 0.21911505f, 
    0.00993256f, 0.03980202f, -0.17486085f, 0.17478749f, 0.07447237f, 0.16470760f, 0.22311224f, 0.13983101f, 
    0.38344839f, 0.16764584f, -0.15512720f, -0.40569007f, -0.61152625f, -0.11129757f, -0.24692909f, -0.17731482f, 
    0.51816010f, -0.17367287f, 0.38442391f, 0.25486547f, 0.14704527f, 0.24106953f, 0.19841312f, 0.42389330f, 
    -0.14642833f, -0.31560192f, 0.04215240f, -0.22690898f, -0.04827527f, 0.02861057f, -0.16018791f, 0.03924869f, 
    0.03972622f, 0.01814012f, -0.12915091f, 0.20659854f, -0.11992309f, -0.04564735f, 0.24834926f, 0.47330737f, 
    0.05877775f, -0.34273365f, 0.24504383f, -0.41577813f, 0.02072311f, 0.07951340f, -0.16970883f, -0.04793017f, 
    0.36006561f, 0.04041289f, -0.01107078f, -0.24788629f, 0.03785549f, 0.01999544f, -0.04351218f, 0.28314254f, 
    0.31948176f, 0.15608747f, -0.53929198f, 0.11749719f, 0.22255394f, 0.08029489f, 0.06353216f, -0.07699957f, 
    -0.24971679f, 0.15942946f, -0.01046744f, 0.05727606f, -0.42325038f, 0.15818217f, -0.08258332f, 0.06296436f, 
    -0.08353294f, -1.02145004f, 0.17493193f, 0.61198324f, 0.60454130f, -0.55129701f, -0.06178433f, 0.10238294f, 
    0.04504451f, 0.13989039f, -0.44679770f, 0.18356185f, -0.22107151f, 0.06125843f, 0.11859579f, 0.39959565f, 
    -0.15441537f, 0.10831309f, 0.30719617f, 0.32690883f, -0.31000200f, 0.41322428f, 0.12669031f, 0.17439458f, 
    -0.00110155f, 0.42105034f, 0.52627397f, 0.40991437f, 0.03508353f, -0.00145200f, -0.38663417f, -0.04412815f, 
    0.31889603f, -0.47692609f, -0.01653278f, -0.28374910f, -0.29023510f, -0.46739250f, -0.13155204f, -0.13164541f, 
    0.43188533f, 0.43015113f, 0.28898230f, -0.11334031f, -0.18101679f, 0.23432781f, -0.28589851f, 0.39989331f, 
    0.17502551f, -0.24125251f, -0.13994554f, -0.38336074f, -0.17064488f, 0.21196085f, 0.03688266f, -0.22523572f, 
    -0.09079713f, 0.59785181f, 0.18492360f, -0.26279044f, -0.12299158f, -0.02809773f, -0.32721278f, 0.14685191f, 
    -0.22990115f, -0.58866882f, 0.04104614f, 0.10730695f, 0.64519286f, -0.41784728f, 0.16532990f, -0.15939112f, 
    -0.40167108f, 0.42801997f, 0.05382989f, -0.32293555f, -0.04577864f, 0.17350560f, 0.00109492f, 0.16681749f, 
    0.33214211f, 0.32563666f, 0.11620443f, -0.21304278f, 0.68787915f, -0.13534667f, 0.17255598f, -0.09569173f, 
    -0.29110184f, 0.49644810f, 0.25064984f, 0.07251111f, 0.21515419f, -0.18860079f, -0.26268908f, -0.20764220f, 
    0.23193455f, -0.00742872f, -0.01916675f, 0.42679700f, -0.14880562f, -0.37169778f, -0.01266397f, 0.12400158f, 
    -0.14163128f, -0.06056030f, 0.11656942f, 0.60089445f, 0.23051655f, 0.19520780f, 0.31660315f, 0.12494165f, 
    -0.02877875f, 0.12577817f, -0.34064209f, -0.51115870f, -0.58851063f, -0.15209207f, -0.17820856f, 0.01888657f, 
    -0.00864027f, 0.16859360f, 0.09362006f, 0.00848100f, -0.12095479f, -0.19271728f, 0.12356263f, 0.08001252f, 
    0.09509140f, 0.56101447f, -0.33464524f, 0.18145123f, 0.30187735f, -0.40802425f, 0.09333652f, -0.14111072f, 
    0.52344811f, 0.13626635f, 0.58659434f, 0.18198371f, 0.41108295f, -0.24512340f, -0.73204905f, 0.18680073f, 
    -0.09795129f, -0.18290463f, -0.10791572f, -0.22850047f, 0.42180660f, -0.07056156f, -0.19431223f, 0.07755210f, 
    0.27127126f, -0.34804705f, -0.58026302f, 0.33780864f, 0.66410750f, 0.04787936f, 0.15553895f, -0.03189766f, 
    -0.15792088f, -0.24002540f, 0.14770842f, -0.01639229f, -0.08864758f, 0.28246951f, -0.09553515f, 0.07104903f, 
    0.26042035f, 0.20011249f, -0.09689510f, 0.37032738f, -0.50821555f, 0.06920806f, 0.32845977f, 0.07464608f, 
    -0.67483276f, 0.36299697f, 0.31114119f, 0.17835699f, -0.33729210f, -0.09947635f, 0.03070018f, -0.08129508f, 
    0.17227341f, 0.47351632f, -0.09723627f, 0.13027853f, 0.00972633f, -0.08533511f, 0.08626962f, -0.01533980f, 
    -0.46751195f, 0.60732198f, -0.37722087f, -0.38542089f, 0.42437121f, -0.10150174f, 0.14315966f, -0.12640828f, 
    0.28018063f, 0.03868706f, -0.20848975f, 0.48697388f, 0.42412549f, -0.10727098f, 0.38337478f, -0.24390374f, 
    0.17169338f, -0.45109522f, -0.22235678f, -0.60182786f, -0.42531732f, 0.30345526f, 0.20927185f, -0.05493146f, 
    0.11550526f, 0.47716716f, 0.15141883f, -0.18445404f, 0.51149762f, -0.11469427f, -0.37258989f, -0.19382772f, 
    0.33309132f, -0.60851997f, -0.42301166f, 0.11776135f, 0.56376964f, 0.05305152f, 0.10333243f, 0.12120701f, 
    -0.02909775f, -0.18977015f, 0.16755606f, -0.12069272f, 0.00517185f, 0.22163980f, -0.02330544f, 0.36761096f, 
    0.15006487f, -0.38921651f, 0.02919446f, 0.25453123f, -0.05886744f, 0.05863810f, -0.13164279f, -0.23389085f, 
    0.22385649f, 0.12368302f, 0.43803668f, 0.23288020f, 0.24354635f, 0.00575060f, -0.34764567f, -0.62014216f, 
    0.00598737f, -0.25087515f, -0.08405261f, 0.40155271f, -0.31188339f, -0.25325471f, -0.05485769f, -0.21927808f, 
    0.33808437f, 0.70768553f, 0.30353636f, -0.05870344f, -0.28439760f, -0.04474691f, -0.29407397f, 0.36775416f, 
    -0.04627227f, 0.31249306f, -0.18280067f, 0.26356214f, -0.28905869f, 0.01333383f, -0.20166072f, -0.09168294f, 
    -0.23297438f, 0.11438530f, 0.17708293f, -0.06999283f, -0.28843763f, 0.01465766f, 0.02829886f, -0.25246325f, 
    -0.19215849f, -0.02159598f, -0.24991287f, -0.24502522f, -0.08180668f, -0.15888460f, -0.02124509f, -0.02255718f, 
    -0.00984608f, 0.00969022f, -0.34587982f, 0.02933607f, 0.25718567f, 0.03042288f, 0.34904364f, -0.30390123f, 
    0.26472041f, 0.01947768f, -0.00514426f, -0.00328444f, -0.09072539f, 0.24843995f, 0.01803064f, 0.16546957f, 
    -0.37343365f, -0.01289321f, -0.24011058f, 0.35709772f, -0.04669753f, 0.05641276f, 0.37183797f, -0.27054274f, 
    0.26632339f, -0.06351717f, 0.06651918f, -0.13877618f, 0.24501055f, 0.02340611f, -0.16495284f, -0.15055829f, 
    0.22929479f, 0.26794475f, 0.12671047f, 0.24137621f, -0.37008125f, -0.17491715f, 0.10888740f, -0.27706644f, 
    0.01818453f, -0.48887345f, 0.39575100f, -0.47151196f, 0.16043012f, -0.09604739f, 0.23903233f, -0.22919942f, 
    -0.09151566f, 0.43248793f, -0.19642542f, -0.01239304f, 0.21420796f, 0.24726367f, 0.05798261f, -0.31817123f, 
    0.12114428f, 0.18374264f, 0.12922178f, -0.06676743f, -0.13943079f, 0.28016508f, 0.16784585f, 0.22403304f, 
    -0.07920639f, 0.23990034f, 0.33006129f, 0.32685807f, -0.07065616f, 0.16486542f, 0.11592481f, -0.38505819f, 
    0.01445952f, 0.28716516f, -0.13605969f, 0.47085387f, -0.23242967f, -0.43154436f, -0.13918784f, 0.06789845f, 
    0.37534896f, -0.17767535f, 0.29458457f, -0.12117878f, 0.10851604f, -0.06714308f, -0.18732709f, -0.33163473f, 
    0.33477435f, -0.20299011f, -0.17854173f, 0.36093292f, 0.79302824f, -0.22111745f, -0.11944407f, -0.15500417f, 
    0.25000480f, 0.20024431f, 0.04341655f, 0.19453521f, 0.33661002f, -0.08369035f, 0.20685813f, -0.04193862f, 
    -0.43006819f, 0.10184921f, 0.13332823f, 0.40550855f, -0.97597218f, 0.01540063f, -0.19381589f, -0.01945882f, 
    0.19670619f, -0.35326177f, 0.16946514f, 0.39238361f, 0.41424099f, -0.13591899f, 0.33537191f, -0.07670092f, 
    -0.19342902f, -0.05362545f, 0.45231870f, -0.19756995f, -0.01833547f, 0.08676881f, -0.02929647f, 0.00729708f, 
    0.24403501f, 0.30364564f, -0.00438447f, -0.13797408f, 0.71395230f, 0.25248441f, -0.14876506f, 0.18869796f, 
    -0.02838412f, -0.35413235f, -0.39003187f, 0.55299431f, -0.33261153f, 0.28678685f, -0.22947918f, 0.05499127f, 
    -0.38685971f, 0.38977924f, 0.09945700f, 0.06703787f, -0.74412000f, -0.09326022f, 0.14957468f, 0.36788985f, 
    -0.13016646f, -0.17639311f, 0.34165028f, 0.32720533f, 0.39114782f, -0.64177078f, 0.14765345f, 0.15129648f, 
    0.20415609f, -0.60459095f, 0.00980590f, 0.27546579f, 0.25156635f, 0.19228894f, 0.03656264f, 0.19199011f, 
    -0.21110867f, 0.08730000f, 0.21696125f, 0.31660950f, 0.02765488f, 0.01321621f, -0.14087477f, -0.03092834f, 
    -0.16477048f, -0.28904188f, 0.20097682f, 0.19507645f, -0.31033260f, 0.02985874f, 0.14727378f, -0.32037440f, 
    0.25384352f, 0.21971232f, 0.20996833f, -0.04135944f, 0.90303254f, -0.08825991f, 0.16778803f, -0.04216034f, 
    -0.13946776f, -0.21702474f, 0.19046879f, 0.11692651f, -0.29726687f, -0.05894903f, 0.17174196f, -0.31247544f, 
    0.25589508f, 0.19908200f, 0.16184880f, 0.03925070f, 0.54468876f, -0.12143264f, 0.07159270f, -0.24435206f, 
    0.05715698f, 0.16623069f, 0.34004277f, 0.24842158f, -0.00415089f, -0.00876663f, -0.31877372f, -0.19532433f, 
    0.30215853f, 0.00238503f, -0.36506683f, 0.22908564f, -0.23711278f, -0.09512379f, 0.01861425f, -0.23374687f, 
    0.42778984f, -0.14050953f, -0.03187306f, 0.10177378f, -0.36634448f, 0.05442958f, -0.07483789f, 0.10810342f, 
    0.25583881f, -0.09896550f, 0.18507642f, -0.22874932f, -0.77534735f, 0.08069728f, 0.06407038f, -0.10667190f, 
    0.03245753f, -0.11388642f, 0.13161020f, 0.45909315f, 0.37832364f, -0.04047788f, 0.14768787f, -0.37583032f, 
    -0.60019112f, 0.43554085f, -0.04335406f, 0.31993693f, 0.10992145f, -0.43445045f, -0.21443355f, 0.06966817f, 
    0.45815513f, -0.29010183f, 0.02408420f, 0.08293680f, 0.30354151f, 0.11019770f, 0.20507635f, 0.65482146f, 
    -0.29669392f, 0.12383810f, -0.12368992f, 0.14739382f, -0.62751895f, 0.22015543f, 0.07404426f, -0.14624549f, 
    0.15684505f, 0.14774938f, -0.41777015f, -0.03870042f, -0.18233310f, -0.18178505f, 0.33584040f, -0.22785603f, 
    -0.12919584f, -0.05738301f, 0.21013951f, 0.45623788f, 1.06876075f, 0.14117169f, -0.19498795f, -0.00067072f, 
    0.10846993f, -0.25802788f, -0.44267851f, 0.59755439f, 0.28719926f, -0.04737440f, -0.16608959f, 0.65924591f, 
    -0.33471939f, -0.63543534f, 0.29271477f, -0.23278499f, 0.52257502f, -0.60451090f, -0.07122795f, 0.20154725f, 
    -0.57924050f, 0.13503052f, 0.34576565f, -0.38745394f, 0.25013080f, -0.15300405f, -0.10099545f, -0.10269684f, 
    0.17014563f, 0.08297440f, -0.19198686f, -0.06910866f, 0.23285846f, 0.36779517f, 0.20472482f, 0.19336569f, 
    -0.11648420f, -0.24684171f, -0.03168521f, -0.27251032f, -0.09822813f, -0.00083461f, -0.11511227f, 0.07265739f, 
    -0.14359197f, 0.05634878f, 0.19308363f, 0.04134078f, -0.19211125f, 0.02731246f, -0.03959099f, -0.12390222f, 
    -0.16634806f, -0.20339061f, 0.22808556f, -0.16618103f, 0.18197115f, -0.11382111f, -0.29604810f, -0.28919998f, 
    0.07393485f, 0.47436699f, 0.34330291f, 0.57228082f, -0.23926666f, -0.03467675f, -0.18889630f, 0.15022072f, 
    0.16264206f, 0.10645013f, 0.08322701f, 0.05377774f, 0.48013970f, 0.21412794f, 0.14724676f, 0.14331363f, 
    -0.17411339f, -0.24463993f, 0.10308502f, -0.34041953f, 0.31778583f, 0.26345012f, 0.08941742f, 0.23903373f, 
    0.19377117f, 0.01672749f, 0.19776827f, -0.29751885f, 0.40962991f, -0.08837119f, -0.25278845f, 0.35332388f, 
    0.21322078f, 0.31232843f, -0.17875096f, 0.34901312f, -0.24185459f, -0.00060876f, -0.11893162f, -0.14206322f, 
    -0.02986354f, -0.11033154f, 0.03275341f, -0.05884200f, -0.20196554f, 0.20604178f, 0.03780806f, -0.15561718f, 
    -0.12017828f, 0.03728130f, -0.12068745f, 0.15630412f, 0.03102225f, -0.09566933f, 0.23122406f, 0.04611850f, 
    -0.60408920f, 0.61082727f, -0.33243474f, -0.11648188f, 0.08642117f, 0.06996308f, 0.40182844f, -0.10836320f, 
    -0.12674001f, 0.31195843f, 0.15058713f, 0.30766481f, -0.57128412f, 0.12848553f, 0.05300602f, 0.14662130f, 
    0.00047177f, -0.23933768f, -0.16203031f, -0.21142404f, -0.25238883f, 0.06068228f, -0.18038067f, -0.14974554f, 
    0.11236028f, 0.02162728f, 0.09350533f, -0.06165349f, 0.16595595f, 0.02494112f, 0.01582869f, -0.11630574f, 
    -0.38957223f, -0.04455908f, -0.62570423f, 0.52670783f, 0.09424023f, 0.06625722f, -0.09531437f, 0.03676464f, 
    -0.08873960f, -0.41232625f, 0.47635597f, 0.35608995f, 0.52027673f, -0.39343274f, 0.02381378f, 0.15584068f, 
    0.38564703f, -0.08339886f, 0.22829944f, -0.04406991f, 0.40536997f, -0.03840287f, 0.25503889f, -0.17697492f, 
    -0.18626383f, -0.03568299f, 0.11114487f, -0.21542954f, 0.68121022f, -0.16334233f, 0.18537761f, 0.20968154f, 
    0.11878823f, 0.27980471f, -0.23168099f, 0.30144477f, -0.29195940f, 0.07000220f, -0.13978952f, -0.26234636f, 
    -0.39394808f, 0.51873928f, 0.32290867f, 0.21731044f, -0.16615275f, -0.39033410f, -0.05394113f, 0.08191648f, 
    0.17701261f, -0.13594720f, -0.34164366f, 0.08424943f, -0.32267794f, -0.07457826f, 0.25265306f, 0.55403322f, 
    -0.14707150f, -0.40652803f, 0.35287452f, -0.03644535f, 0.59910977f, 0.13786127f, 0.08753821f, 0.08418533f, 
    0.48030752f, -0.12955272f, -0.19414303f, 0.38456365f, 0.51859397f, 0.07133584f, 0.44596219f, -0.08913504f, 
    -0.18361518f, -0.27256516f, -0.24079874f, -0.41575778f, -0.40229657f, 0.17013644f, -0.11271728f, 0.17442816f, 
    0.34146827f, 0.28116459f, 0.18938561f, -0.32978332f, -0.30904958f, 0.05969675f, -0.39672875f, 0.30014229f, 
    0.10882796f, 0.46497923f, 0.30782282f, 0.06133869f, 0.57435375f, -0.71788502f, -0.00935228f, -0.24604368f, 
    -0.16622031f, -0.20749021f, -0.23318851f, -0.24577236f, -0.12310153f, -0.22990951f, -0.23055029f, -0.22874731f, 
    -0.24261299f, -0.16159338f, -0.07367584f, -0.10086289f, -0.21678361f, 0.00060257f, 0.12968656f, -0.11280426f, 
    0.44315377f, 0.05849486f, 0.05810310f, 0.49388492f, 0.17040502f, -0.12825996f, -0.56560034f, -0.07417989f, 
    -0.41989350f, -0.71034932f, 0.31061807f, -0.31832159f, 0.61689097f, 0.08573999f, -0.02315628f, 0.17284723f, 
    0.10343137f, -0.10902973f, -0.16581495f, -0.15864806f, 0.06185608f, 0.01989860f, 0.07825706f, -0.27252254f, 
    -0.01928210f, -0.20928824f, 0.05513524f, 0.07083402f, 0.13051203f, -0.21563046f, 0.08505902f, 0.01021338f, 
    0.51756042f, -0.41413692f, 0.25914714f, 0.10236168f, 0.29274839f, -0.07582898f, -0.10253052f, 0.53267419f, 
    -0.27770764f, -0.09112617f, 0.03892174f, 0.27908221f, -0.44523466f, -0.06292079f, -0.11412910f, -0.06780529f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.09788397f, -0.55087626f, -0.07647992f, -0.03006557f, 0.41616195f, 0.28787249f, 0.00023561f, 0.11212142f, 
    0.23688862f, -0.07660394f, 0.18666770f, 0.00586197f, 0.07796317f, 0.04176029f, 0.57872242f, 0.28123617f, 
    -0.24293275f, 0.22745182f, 0.31903467f, -0.07414982f, -0.20955814f, -0.04718493f, 0.59681374f, 0.13834928f, 
    -0.18292072f, 0.12962675f, 0.18161370f, 0.29296717f, 0.21230011f, -0.09254465f, -0.09906481f, -0.08540899f, 
    0.56156874f, 0.21911111f, 0.15989846f, 0.47134990f, 0.10254406f, 0.24041440f, -0.04781420f, 0.26877320f, 
    0.07317585f, -0.12166537f, 0.28989688f, 0.04025048f, 0.34339270f, 0.58332568f, -0.37878212f, -0.01784551f, 
    0.04497173f, -0.00018877f, 0.39860207f, -0.14440542f, 0.07610823f, 0.06832832f, 0.30830044f, -0.12620153f, 
    -0.29909155f, -0.12545210f, 0.11171616f, 0.38509321f, 0.04710448f, 0.14554352f, -0.23312379f, -0.06861019f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.31650954f, 0.90350384f, -0.28744620f, -0.02318451f, -0.10362509f, -0.51740289f, -0.37271157f, 0.04594812f, 
    -0.10971038f, 0.15634085f, -0.27437150f, 0.00735012f, 0.02222759f, 0.21478251f, -0.01209553f, -0.82899886f, 
    0.13770625f, -0.25284293f, -0.32201862f, 0.20131889f, 0.80119026f, -0.41972160f, -0.16259348f, -0.29966548f, 
    -0.17010571f, 0.15128124f, 0.06583804f, 0.00574192f, -0.22040345f, -0.36675569f, 0.18149830f, 0.14180765f, 
    -0.35271287f, -0.04361172f, -0.30536914f, -0.08555518f, 0.12083745f, -0.42068353f, 0.15880138f, 0.05526676f, 
    0.00132794f, 0.11910359f, 0.02293736f, -0.27657974f, 0.06900674f, -1.23167491f, 0.05144406f, -0.08168082f, 
    0.14485095f, -0.23436512f, -0.04315496f, 0.05159205f, 0.27574721f, -0.07904944f, -0.07431496f, -0.01168108f, 
    0.26516926f, -0.44832462f, -0.29687691f, 0.00613456f, 0.07934314f, -0.48577583f, 0.11496405f, -0.80938762f, 
    0.17149758f, -0.82860160f, -0.44453186f, 0.16306366f, 0.20917706f, -0.15922588f, -0.13850626f, 0.14848788f, 
    0.41350359f, -0.18042219f, 0.25005761f, -0.10115191f, 0.04563241f, 0.15796998f, 0.32926860f, 0.33361471f, 
    -0.02165674f, -0.00758167f, 0.28787968f, -0.64593655f, -1.17053485f, 0.20620586f, 0.45220417f, 0.05079921f, 
    0.16357675f, 0.00594735f, -0.09077343f, 0.13928208f, 0.15845516f, -0.35041261f, 0.03571104f, 0.16194338f, 
    0.37406603f, -0.31002665f, -0.25241420f, 0.23747750f, 0.17833102f, -0.24184309f, -0.02476418f, 0.01232902f, 
    0.21420310f, -0.19256054f, -0.31009236f, -0.28506294f, 0.13380790f, -0.40456140f, -0.27297258f, -0.02606907f, 
    0.00995764f, -0.22430481f, 0.09919409f, -0.08521843f, -0.06252822f, 0.09143353f, 0.00339748f, -0.14951323f, 
    -0.45770133f, -0.32957914f, 0.40208533f, 0.07362771f, -0.04794772f, -0.49976608f, 0.00488953f, -0.34577483f, 
    -0.44876650f, -0.13970260f, -0.11202449f, 0.10136501f, 0.08985426f, -0.12026844f, -0.02558227f, -0.11889392f, 
    -0.12608927f, -0.08583304f, -0.62465781f, -0.16218252f, 0.18504275f, 0.14556435f, -0.03590005f, -0.91383505f, 
    -0.20886606f, 0.16939037f, 0.30560207f, -0.94717419f, -0.26935589f, -0.91622961f, 0.17324427f, -0.03679003f, 
    -0.48450640f, -0.48597926f, 0.04759385f, -0.06628755f, -0.32079566f, -0.30915210f, 0.06226585f, -0.46652284f, 
    -0.04289117f, -0.23601656f, 0.16559054f, 0.23720063f, -0.31465936f, 0.27776268f, -0.00964371f, 0.02499983f, 
    -0.29502475f, 0.14928012f, 0.27149314f, 0.02073584f, 0.24872510f, 0.56798333f, 0.20490278f, -0.02345309f, 
    0.23744391f, 0.14716765f, 0.13116176f, -0.06136020f, 0.10922019f, -0.12592325f, 0.38343996f, 0.04712548f, 
    -0.96143007f, 0.12769820f, -0.96946818f, 0.18114938f, 0.04401223f, 0.33242702f, 0.05898846f, 0.09218525f, 
    0.09660248f, -0.15002139f, -0.06080860f, -0.29829627f, -1.09097767f, -0.16974221f, -0.27055728f, -0.41743022f, 
    0.15413414f, 0.29466254f, -0.46974835f, -0.44511023f, -0.21519260f, -0.35161963f, -0.01700755f, -0.76785493f, 
    0.01620490f, -0.27682495f, -0.09321881f, 0.37901661f, -0.64959830f, -0.90530080f, -0.87943029f, 0.04101030f, 
    0.02984158f, -0.01163980f, 0.05216304f, -0.42242825f, -1.49135816f, -0.68082708f, -0.34823960f, 0.10880801f, 
    -0.09778631f, 0.27624989f, 0.11901879f, -0.07876069f, 0.15346713f, 0.76600349f, 0.11847634f, 0.16784514f, 
    -0.02360443f, -0.27925879f, 0.27865076f, 0.24405918f, 0.10546122f, 0.06996561f, 0.57299775f, -0.05174912f, 
    0.59404409f, -0.46973899f, -0.00437572f, -0.08584873f, 0.01211916f, -0.09243842f, 0.29023921f, -0.41511711f, 
    0.10281594f, 0.01478706f, -0.81958586f, -0.06846569f, 0.11290249f, -0.31416562f, 0.06294631f, 0.37526149f, 
    0.16316983f, -0.55376840f, 0.31055266f, -0.27570495f, -0.10702252f, -0.12466583f, 0.29140595f, 0.04902207f, 
    0.13611358f, 0.29117060f, 0.06874036f, 0.15115909f, 0.13579643f, 0.05563501f, 0.05643909f, 0.07520640f, 
    -0.13175140f, -0.17881103f, -1.75099313f, 0.10315187f, 0.03934942f, 0.00728511f, -0.19017991f, 0.03824709f, 
    -0.35963422f, 0.00900648f, -0.06257619f, 0.03182200f, 0.23443474f, 0.21350802f, 0.07035613f, -0.17972907f, 
    -0.67462373f, 0.00806950f, -0.25142980f, -0.12860379f, 0.22987169f, -0.45660594f, 0.08252547f, 0.09121319f, 
    -0.17605089f, -0.08123682f, -0.67483699f, -0.02355535f, 0.04761401f, 0.09443794f, -0.12013083f, -0.11066756f, 
    -0.25774345f, -0.01755999f, -0.19610228f, 0.11321144f, 0.20565021f, 0.00053218f, 0.17218287f, -0.38961157f, 
    -0.22161099f, 0.45991945f, -0.26308161f, 0.02841822f, 0.08369111f, -0.16744065f, -0.07973392f, -0.24683000f, 
    -0.20143415f, -0.09160784f, 0.01981249f, -0.06001067f, 0.30786952f, -0.05396502f, -0.03814675f, -0.25143498f, 
    0.12372192f, -0.04730920f, 0.42292121f, 0.20308608f, 0.27641097f, 0.03397879f, 0.17296493f, 0.04455765f, 
    -0.16043676f, 0.26198134f, -0.57909924f, -0.14157155f, -0.00240775f, -0.09311743f, 0.33320764f, -0.00426333f, 
    0.34330556f, 0.09566014f, 0.05451293f, 0.04739798f, 0.34876511f, 0.51092094f, 0.17541578f, 0.03350849f, 
    0.01710101f, -0.03531051f, 0.07977732f, 0.12230144f, 0.03029460f, -0.34327644f, -0.12087994f, -0.10534609f, 
    0.11057458f, 0.14163662f, -0.06089932f, -0.29812410f, -0.18923000f, -0.42666194f, -0.24544971f, 0.04073000f, 
    -0.03294890f, 0.02923931f, -0.12449471f, -0.00664319f, -0.23726666f, 0.05374804f, -0.29969907f, -0.13557763f, 
    -0.36864814f, -0.49596921f, -0.65410393f, 0.03527210f, -0.07109074f, 0.22513689f, 0.10597966f, -0.18168950f, 
    -0.38293254f, -0.08380091f, 0.12246734f, 0.13895285f, -0.34959251f, 0.21639869f, 0.20221579f, -0.05226150f, 
    -0.88436747f, -0.04738557f, -1.00917161f, -0.12291920f, -1.03121388f, -0.26079530f, -0.90242434f, -0.73169553f, 
    -0.43064725f, -0.00780066f, 0.25804293f, -0.07189462f, -0.04613949f, 0.16785163f, 0.16099478f, 0.00595350f, 
    -0.01146512f, -0.98008722f, 0.02190720f, 0.16882017f, -0.13379151f, 0.32337844f, -0.09000545f, -0.45009744f, 
    0.22083074f, -0.26928052f, 0.27422851f, -0.12184878f, -1.62296414f, 0.20448813f, 0.21981271f, 0.12910092f, 
    -0.29752359f, 0.06310733f, 0.20492049f, 0.00816001f, 0.35547301f, 0.25608590f, 0.11646329f, -0.05879490f, 
    0.34754404f, 0.18779208f, -0.31215304f, 0.09026270f, -0.33368939f, -0.08053724f, 0.14504516f, 0.28367463f, 
    -1.19214976f, 0.47890049f, 0.15008712f, -1.19296443f, 0.05586335f, 0.47442317f, 0.02793835f, -0.09344045f, 
    -0.05852310f, 0.01445892f, 0.15215148f, -0.01069265f, -0.04690909f, 0.09900013f, 0.03584073f, -0.04806823f, 
    -0.35755861f, 0.01321430f, -0.77524781f, -0.02254396f, -0.47546601f, -0.10539930f, -0.04793220f, 0.08021241f, 
    -0.10282701f, -0.97299743f, 0.07711629f, 0.42663446f, -0.19372866f, 0.25129634f, -0.78862321f, -0.11244322f, 
    -0.27716830f, -0.19945490f, -0.03738314f, 0.16719903f, -0.12002043f, -0.23316739f, 0.04515750f, -0.00842723f, 
    -0.26246905f, 0.53280163f, 0.16262370f, 0.15124740f, -0.27084792f, -0.22610743f, -0.26073498f, -0.08727989f, 
    -0.12706372f, -0.18651268f, 0.38176307f, 0.12023825f, 0.43529662f, -0.55173391f, 0.30782330f, 0.04812386f, 
    -0.07067765f, 0.18242209f, -0.05737766f, -0.04631473f, 0.38210160f, 0.08610470f, -0.21373248f, 0.20539065f, 
    0.05877369f, -0.27283072f, 0.21231359f, -0.84573412f, -0.00249335f, -0.93416995f, -0.01945157f, -0.10003739f, 
    -0.88731253f, -0.78737569f, -0.41277033f, 0.15412986f, -0.28595048f, 0.18725108f, -0.10302009f, 0.12841201f, 
    -1.47998405f, -0.52953839f, 0.34931883f, 0.07852333f, -0.39455861f, -0.19633096f, 0.13287099f, 0.01776496f, 
    0.14702450f, 0.24197903f, -0.44307360f, -0.18506247f, 0.97083175f, 0.01804455f, -0.03736927f, -0.07051984f, 
    0.43588868f, -0.05518436f, 0.01510052f, -0.19710408f, -0.07853745f, -0.25645322f, -0.05447059f, 0.32260218f, 
    0.20366225f, 0.49391839f, 0.16605493f, 0.15294501f, -0.70150226f, 0.09237042f, -0.09454320f, -0.00624658f, 
    0.21983986f, -0.16310446f, 0.68612611f, 0.08453906f, -1.26839697f, -0.18929514f, -0.46295685f, 0.01336065f, 
    0.20325652f, -0.04727668f, 0.07266270f, -0.04998960f, -0.32854909f, 0.12368444f, -1.18914020f, 0.25931680f, 
    -0.25920039f, -0.73899293f, -0.10850355f, 0.07794593f, -0.00813161f, -0.43531829f, 0.05764554f, 0.28905520f, 
    0.18798374f, -1.43777156f, 0.03029327f, 0.22311366f, 0.04646559f, 0.07968729f, 0.06712104f, -0.14237213f, 
    0.30890006f, -0.28708795f, -0.07612037f, -0.03011978f, 0.21242742f, 0.21043558f, -0.38231471f, 0.07154584f, 
    0.12131763f, -0.04470295f, -0.15532769f, 0.10357942f, 0.11769316f, -0.11690847f, -0.27367350f, -0.16761526f, 
    -0.35260385f, -0.39306656f, -0.07795789f, -0.03864079f, 0.15385729f, 0.38736543f, -0.43270653f, -0.17550844f, 
    0.18222806f, -0.55406451f, 0.13954414f, -1.01274872f, 0.41153091f, 0.04219726f, 0.43068859f, 0.41361535f, 
    -0.37280113f, -0.49667886f, 0.14072499f, -0.23508756f, 0.34522170f, 0.27904359f, 0.13117312f, -0.09977571f, 
    -0.85579211f, -0.05554444f, -0.44894317f, -0.08705057f, -0.77224690f, 0.01019250f, 0.07982937f, 0.16626668f, 
    0.01404672f, 0.26937705f, -0.15310639f, 0.47736529f, 0.09650140f, 0.18979821f, -0.03614603f, -0.41606516f, 
    -0.73860127f, -0.49509013f, 0.04730166f, -0.32631174f, -0.40455657f, 0.20562679f, 0.07414009f, 0.38477910f, 
    -0.33619648f, 0.17358543f, -0.14605445f, 0.41260284f, 0.00202988f, 0.17224954f, -0.14922385f, -0.72886360f, 
    0.06049861f, 0.28997272f, -0.25235522f, 0.03992790f, -0.01711211f, -0.01141076f, 0.15315223f, 0.15943828f, 
    -0.52171803f, 0.36096159f, 0.10445167f, -0.83638394f, -0.67570698f, -0.30997407f, -0.76604342f, -0.41131940f, 
    0.13920005f, -0.46872923f, -0.29723138f, 0.17915507f, 0.00547432f, -0.06070361f, -0.36194441f, -0.40576449f, 
    0.08092222f, 0.20709373f, -1.18247139f, 0.26430318f, -0.27879974f, -0.26767418f, 0.06154267f, 0.09107486f, 
    -0.28722906f, 0.06368853f, 0.24229258f, 0.04608431f, -0.77246404f, -0.04680590f, -0.82682949f, -0.06285544f, 
    -1.08056533f, 0.21889128f, -0.31212774f, 0.17859107f, 0.10164347f, -0.31375077f, -0.06495519f, 0.36221671f, 
    -0.65518552f, -0.38852412f, 0.06253814f, 0.05814055f, 0.27461642f, 0.23182924f, 0.15948620f, -0.23264706f, 
    0.22732112f, 0.01211638f, 0.25806084f, 0.22377644f, -0.42577207f, -0.68257707f, -0.24980968f, 0.13299975f, 
    -0.28428152f, 0.02859202f, 0.25086996f, -0.13175586f, -0.73483348f, 0.33127692f, -0.57521731f, -0.00063931f, 
    0.01914213f, -0.15601258f, 0.09254283f, -0.08103818f, -0.58627725f, 0.37252453f, -0.32841134f, -0.15417975f, 
    -0.19352010f, 0.23290180f, 0.06542336f, 0.12912831f, -0.11395689f, 0.14927323f, -0.28672054f, -0.15644798f, 
    0.06813528f, 0.43051279f, -0.15128709f, 0.21023284f, -0.89596593f, 0.44086289f, 0.21070985f, -0.10458060f, 
    -0.43560255f, -0.04642447f, -0.02120797f, 0.06471667f, -0.73061830f, 0.01562305f, 0.07305276f, -0.15850435f, 
    -0.31494114f, -0.09176078f, 0.27362314f, -0.41375089f, 0.01396728f, 0.49541143f, -0.10803115f, 0.32785180f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.41533905f, 0.25081584f, -0.05811541f, 0.11598635f, -0.06814463f, 0.08097643f, -0.21806864f, -0.17575115f, 
    -0.08812924f, 0.04413899f, 0.08784884f, 0.10219914f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
