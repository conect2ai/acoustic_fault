#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.12376033f, 0.27805230f, 0.23576474f, -0.21666349f, -0.72292554f, -0.89018542f, 0.40986064f, 0.37169173f, 
    0.11252408f, -0.37931582f, 0.33748502f, 0.53338379f, 0.00475128f, 0.23488127f, 0.44290531f, 0.09706020f, 
    -0.07567912f, 0.10009252f, 0.39948666f, -0.81795365f, 0.86350292f, -0.38168430f, -0.42066985f, 0.06662887f, 
    0.26758328f, 0.12106813f, 0.42952272f, 0.74260569f, 0.69623297f, -0.89086616f, -0.19314398f, 0.11552261f, 
    -0.18188995f, -0.56017822f, 0.63286710f, -0.33037242f, 0.76311290f, -0.20109183f, -0.54354930f, 0.06416669f, 
    0.21308142f, -0.12619436f, 0.30580398f, -0.28207695f, 0.06557573f, -0.40828317f, -0.76321000f, -0.59967154f, 
    0.36096376f, 0.15836105f, 0.32959285f, -0.24190934f, -0.34572476f, -0.49542773f, 0.00328190f, -0.23877783f, 
    -0.53622776f, -0.43119892f, -0.47571638f, 0.01269202f, 0.05882496f, -0.40919527f, 0.09984655f, 0.60384792f, 
    -0.66659957f, -0.26735333f, 0.38017243f, 0.19879813f, -0.18988909f, -0.30281687f, -0.51043016f, -0.21271053f, 
    -0.13457158f, 0.33587804f, 0.67787004f, 0.03089957f, 0.53898931f, -0.44873685f, -0.36873966f, 0.12524328f, 
    -0.55562395f, -0.10494915f, 0.61198288f, -0.70961112f, -0.55781835f, 0.05628304f, 0.22895545f, 0.50251019f, 
    -0.20021735f, -0.30481869f, 0.05516330f, -0.21229808f, -0.22712803f, -0.07315624f, 0.56361598f, 0.60689741f, 
    -0.11356334f, -0.07116180f, 0.27862364f, 1.16869402f, -0.96901035f, -0.18678740f, -0.06454018f, -0.25639021f, 
    0.19895586f, -0.00383985f, 0.04681420f, -0.31432015f, -0.02134879f, 0.10910669f, 0.15804458f, 0.57729733f, 
    0.51686835f, -0.97500187f, -0.31508920f, -0.32650819f, 0.54770869f, 0.09305996f, 0.03758040f, 0.23592512f, 
    0.42715102f, -0.23187394f, 0.60332429f, 0.54654497f, -0.69663155f, -0.54908550f, -0.67325777f, -0.08770913f, 
    0.66308898f, 0.77129978f, -0.16856965f, -0.72173905f, 0.32401454f, -0.39942795f, -0.46808106f, 0.64540291f, 
    0.36669075f, 0.36558545f, 0.29161543f, -0.05786191f, -0.15939412f, 0.38040465f, 0.34047881f, -0.14136806f, 
    -0.70857775f, -0.33848247f, 0.29004398f, 0.16462599f, 0.55105031f, 0.35779187f, -0.06037494f, -0.80613565f, 
    -0.12484454f, -0.57038420f, 0.12715741f, 0.67577714f, -0.54754144f, 0.12982160f, 0.65085053f, -0.41636360f, 
    0.31306505f, -0.32555521f, 0.55815834f, 0.40445882f, 0.50160027f, 0.11235019f, -0.02495327f, 0.15410936f, 
    0.24095999f, -0.05134219f, 0.50813115f, -0.80613506f, -0.63930959f, -0.50889492f, 0.09294613f, 0.29992849f, 
    0.44645965f, 0.14045699f, 0.47385290f, -0.20175102f, -0.62046039f, -0.21804795f, -0.27997389f, 0.24742559f, 
    -0.46311855f, -0.30452555f, -0.07118201f, -0.08482572f, 0.33416492f, -0.18816836f, -0.30721140f, -0.74017078f, 
    0.47684357f, 0.98003668f, -0.24314539f, -0.23012786f, -0.29974502f, -0.30324566f, 0.06222632f, 0.05874003f, 
    -0.58724767f, 0.12504584f, 0.50235391f, 0.01919109f, 0.05816060f, 0.52070785f, -0.20899637f, 0.34706473f, 
    -0.28050867f, 0.05752941f, -1.02190781f, -0.49663052f, -0.26415297f, -0.46804589f, 0.61748153f, -0.24328646f, 
    -0.62510765f, 0.05046378f, 0.54172158f, 0.46686542f, -0.11971300f, 0.04441758f, 0.32034251f, 0.12020922f, 
    -0.44889385f, 0.32462674f, -0.39700636f, -0.46829993f, 0.52776748f, 0.56142604f, 0.55593652f, 0.21990983f, 
    0.45849994f, -0.40638292f, -0.84945124f, 0.04253971f, 0.73851007f, -0.30239198f, -0.32668445f, -0.53290671f, 
    -0.05357656f, 0.53353763f, -0.32910424f, -0.63494796f, -0.00965709f, -0.23462375f, -0.45932800f, -0.54426652f, 
    -0.50026864f, -0.26225916f, -0.30166957f, -0.42939270f, -0.35009104f, -0.12905341f, -0.02417732f, -0.65129685f, 
    0.07560121f, 0.02550486f, 0.29753152f, 0.78752381f, -0.18250459f, 0.66958004f, 0.02426115f, 0.15193179f, 
    -0.26561245f, 0.07522476f, -0.58975166f, -0.03747166f, -0.08470810f, 0.83834708f, -0.65055811f, -0.47015744f, 
    -0.01283294f, -0.33081788f, 0.00943431f, -0.76154900f, 0.62951487f, 0.58967847f, 0.03463336f, -0.95760709f, 
    0.26882112f, 0.56800932f, -0.92526329f, -0.48211777f, 0.69637990f, -0.18991575f, -0.04250111f, 0.43293333f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.05665727f, 0.22404514f, 0.15751666f, -0.17899320f, 0.56275040f, 0.27832982f, 0.06292950f, 0.00892597f, 
    -0.12429810f, 0.13206942f, 0.25968164f, -0.12407092f, -0.13933903f, -0.11983673f, -0.03727088f, -0.24677001f, 
    -0.06797639f, 0.09265410f, 0.26473698f, -0.10833514f, -0.46417123f, -0.28628758f, 0.35696387f, 0.18796691f, 
    0.09357989f, 0.32052955f, 0.08990129f, -0.19286984f, 0.26170298f, -0.10245141f, -0.09663628f, -0.09529465f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.54106879f, -0.88260835f, 0.16839212f, 0.02540343f, 0.15844062f, 0.06346604f, -0.05261268f, -0.25829941f, 
    0.00737870f, 0.15190418f, 0.11534780f, -0.02421792f, -0.15511759f, -0.03884786f, -0.09250416f, 0.10701744f, 
    0.07610571f, 0.10822644f, -0.22157781f, -0.01540514f, -0.18010445f, 0.06245060f, 0.06311496f, 0.22635178f, 
    -0.09018378f, 0.07805351f, -0.09591196f, 0.10065620f, 0.14649993f, -0.03153626f, 0.07745829f, -0.05208183f, 
    0.08722580f, 0.16798609f, 0.02600763f, -0.10885357f, 0.23217696f, 0.05498572f, -0.02534292f, 0.10480527f, 
    -0.13793860f, -0.00595680f, 0.08950311f, 0.02068356f, -0.01393155f, 0.14671156f, -0.27612150f, -0.15526521f, 
    -0.10381767f, -0.10796624f, -0.08999562f, 0.14891180f, 0.18771227f, 0.02536461f, -0.62000382f, -0.12253877f, 
    -0.34283224f, 0.03614976f, 0.02953231f, -0.14081714f, -0.05139257f, 0.15986942f, -0.07313936f, -0.16337813f, 
    -0.11797006f, 0.06103544f, -0.02148475f, -0.02978333f, 0.15088932f, 0.00101424f, 0.03250065f, 0.08344604f, 
    0.08805027f, 0.10866319f, 0.02732937f, -0.04619162f, 0.00900550f, -0.07618249f, -0.09667075f, -0.07127736f, 
    -0.05416662f, 0.08515245f, 0.07270164f, -0.16805649f, 0.12746280f, 0.06895845f, 0.12279686f, 0.04204952f, 
    0.17876279f, -0.03981582f, 0.02347550f, 0.06879697f, -0.18756035f, -0.07763916f, -0.02161434f, -0.09220650f, 
    0.05531264f, -0.10584816f, -0.02396634f, -0.05824197f, 0.14351343f, -0.27308190f, 0.06436419f, 0.13827416f, 
    0.22463500f, 0.10996289f, 0.18810008f, 0.15415516f, 0.10957857f, 0.10567126f, -0.03651728f, 0.11140151f, 
    0.09886567f, -0.06728847f, -0.03548785f, 0.27108726f, 0.15979967f, 0.08657110f, -0.02856358f, 0.16633463f, 
    -0.12337385f, -0.05215197f, -0.29683357f, 0.00971321f, -0.01035267f, 0.14360885f, 0.08300141f, -0.09342851f, 
    -0.05606435f, -0.03118733f, -0.10880496f, -0.04101293f, 0.08248477f, 0.07335379f, -0.13584949f, 0.00655665f, 
    -0.11059971f, 0.17948022f, 0.03727501f, 0.01988360f, -0.04718445f, -0.10593273f, 0.00360519f, 0.14619519f, 
    0.10867577f, -0.02257635f, 0.08019053f, -0.05361490f, 0.05175095f, -0.23086567f, 0.02724663f, 0.14518066f, 
    0.02796072f, 0.07797831f, 0.09081433f, -0.04083103f, -0.09030016f, 0.01241952f, 0.02272011f, -0.08452787f, 
    0.11950740f, -0.07333607f, -0.04437806f, -0.06787793f, 0.14190111f, -0.02948575f, -0.06544976f, -0.04653491f, 
    -0.03524206f, 0.07773653f, 0.10978793f, 0.51567566f, 0.29501486f, 0.33391479f, -0.23255226f, 0.17186715f, 
    -0.25312951f, 0.12737873f, 0.00890543f, 0.02084528f, 0.48821858f, -0.42078894f, 0.69857943f, -0.07473812f, 
    0.02891316f, -0.14683841f, 0.08064511f, -0.11420653f, -0.05420950f, -0.36940390f, -0.46038592f, 0.21029125f, 
    -0.15479694f, 0.00809013f, 0.14535135f, 0.03250262f, 0.18048942f, 0.07803005f, -0.00573149f, 0.07136314f, 
    0.12239456f, 0.05151508f, -0.01161741f, 0.04594497f, 0.17278343f, -0.05701649f, 0.05600131f, -0.62435716f, 
    -0.74197477f, -0.37055457f, 0.00454638f, -0.06655224f, -0.06894831f, 0.05277383f, -0.01831547f, 0.00527252f, 
    0.17326558f, 0.08734234f, 0.17395045f, -0.11665075f, 0.05850555f, -0.14235774f, 0.00783947f, 0.03896496f, 
    0.07154794f, 0.03217690f, 0.03496571f, -0.01980197f, -0.23513593f, -0.02861681f, -0.14150675f, 0.21842445f, 
    -0.03636518f, 0.02297151f, -0.46522814f, -0.34746867f, 0.14645101f, 0.17727531f, -0.05897619f, 0.04079896f, 
    0.06267418f, -0.02408324f, -0.04163955f, -0.37121823f, -0.31713715f, -0.46350178f, 0.04686669f, -0.09395678f, 
    -0.20857935f, -0.00129790f, 0.00380077f, 0.17402665f, 0.05650439f, 0.20477346f, 0.24779783f, 0.04733239f, 
    -0.01830996f, 0.06264163f, -0.05372899f, 0.04461554f, -0.05763963f, -0.12720434f, -0.23753773f, 0.27265343f, 
    0.04989121f, 0.15183772f, 0.03525979f, -0.06210496f, -0.11612219f, -0.08007027f, 0.20798855f, -0.17190641f, 
    -0.00325975f, -0.01301214f, 0.07633020f, 0.01732820f, 0.09146456f, -0.06370316f, -0.01128888f, 0.08865562f, 
    -0.55094755f, -0.40710878f, 0.00561682f, 0.13299714f, -0.25522900f, -0.09965150f, 0.08821468f, -0.09981402f, 
    0.04759504f, 0.02212085f, 0.04666434f, -0.06336838f, 0.01265647f, -0.02844914f, 0.04157500f, -0.06405540f, 
    0.01279407f, -0.02791464f, 0.02972232f, 0.03168514f, -0.00100204f, 0.01759900f, -0.02262634f, -0.02618807f, 
    0.05721981f, 0.01082424f, -0.00740408f, 0.02955260f, 0.02079858f, -0.05780555f, 0.05204571f, 0.04805034f, 
    0.02456569f, 0.03187518f, -0.02987563f, -0.00252990f, -0.05621236f, -0.04531585f, -0.02543181f, 0.01023121f, 
    -0.00776519f, -0.06287977f, -0.06176109f, 0.04300676f, 0.02761024f, -0.01185212f, -0.02753344f, -0.03265452f, 
    -0.01191353f, 0.01098271f, 0.04009924f, 0.01778869f, 0.02206674f, -0.01961109f, -0.05002026f, -0.04286262f, 
    -0.01721860f, -0.05862888f, -0.03028995f, 0.02062002f, -0.04882926f, 0.00312473f, 0.04171166f, 0.05747731f, 
    -0.02234667f, 0.02663023f, -0.01530391f, -0.03089090f, -0.03971035f, 0.00441276f, -0.04976918f, -0.03146923f, 
    -0.00977574f, -0.03838401f, 0.01734226f, -0.01582804f, 0.03793349f, -0.05145437f, -0.00717178f, -0.03016520f, 
    -0.04193451f, -0.00703089f, 0.02007543f, -0.03731988f, 0.00173032f, -0.00297402f, -0.06164401f, -0.05530161f, 
    -0.03056530f, -0.00608570f, -0.03774021f, -0.02094160f, 0.01739387f, -0.01472131f, 0.04706228f, 0.00861939f, 
    0.04691091f, 0.00098996f, -0.05540798f, -0.01461335f, 0.02472962f, -0.02813251f, -0.00907409f, 0.02630786f, 
    -0.04203206f, -0.01565020f, -0.04701235f, 0.04898727f, -0.03853000f, -0.00221240f, -0.01090364f, 0.03068290f, 
    -0.03014726f, -0.06065330f, -0.04920492f, -0.05369078f, -0.04869068f, 0.02833383f, -0.05705076f, -0.01989679f, 
    -0.01403326f, -0.04063544f, -0.05662873f, 0.03923584f, -0.05501029f, 0.01778255f, 0.01639008f, -0.03095529f, 
    -0.03536252f, 0.03841984f, 0.00681584f, -0.04531437f, 0.04221953f, 0.02741293f, 0.03275831f, -0.01056030f, 
    -0.01897165f, -0.01587086f, -0.03334191f, -0.03152550f, -0.03775129f, 0.01009972f, -0.03717543f, 0.02460149f, 
    -0.03989343f, 0.01435254f, -0.04551265f, -0.04486388f, 0.03242075f, 0.01685782f, -0.02791882f, 0.04945001f, 
    0.04788442f, -0.03260762f, -0.02481269f, 0.04121781f, 0.01914212f, -0.00847823f, 0.04976261f, -0.05622004f, 
    0.03701653f, 0.04760531f, -0.04972968f, 0.02503666f, 0.00835259f, -0.05674741f, 0.02195019f, -0.02600185f, 
    -0.02399145f, -0.00218620f, -0.00232867f, -0.01436127f, 0.03572109f, -0.01024414f, 0.03070124f, -0.02825133f, 
    -0.02375044f, -0.00265231f, 0.03483109f, -0.01792929f, -0.03090358f, 0.02363604f, -0.06231935f, -0.04204246f, 
    -0.05939400f, -0.06186954f, -0.04616012f, -0.01208800f, 0.03371714f, 0.04370562f, 0.04003991f, -0.03838282f, 
    -0.02380649f, 0.06331432f, -0.01725792f, -0.01971818f, 0.00340483f, -0.00378658f, -0.05293963f, 0.03314053f, 
    -0.01527756f, 0.00316080f, -0.00598786f, 0.01682534f, 0.02952041f, 0.00746386f, 0.04219881f, -0.00763061f, 
    0.01200757f, -0.06224601f, -0.06222759f, -0.00831031f, 0.02255018f, 0.04196997f, -0.01873982f, -0.05546896f, 
    0.00581975f, 0.00796102f, -0.03165733f, 0.04582329f, 0.03285676f, 0.02104785f, -0.03179284f, -0.05879657f, 
    -0.04262266f, -0.00267061f, -0.00356039f, 0.02406839f, -0.05938140f, -0.04425249f, 0.04190071f, -0.01028867f, 
    0.04273568f, -0.02366831f, -0.02372716f, -0.02520783f, -0.05627628f, 0.02879041f, -0.05879753f, -0.05966381f, 
    0.04064056f, -0.00777166f, 0.05817413f, 0.00742809f, -0.05499003f, -0.02896156f, -0.04501234f, 0.01576042f, 
    -0.06195919f, -0.05048379f, 0.03065275f, -0.02038357f, -0.03419694f, 0.01479331f, 0.03800185f, 0.00229517f, 
    0.01560966f, -0.05351815f, 0.01310499f, 0.00729796f, -0.03955230f, -0.00191285f, 0.02043341f, -0.01573412f, 
    -0.04608442f, 0.00775906f, -0.05472543f, -0.01039567f, 0.02576116f, 0.03102384f, -0.03307752f, 0.04644364f, 
    -0.02829401f, -0.00162787f, -0.01668037f, 0.04060744f, -0.03238741f, -0.05347892f, 0.03078661f, 0.03768989f, 
    0.03173941f, -0.00009907f, -0.03361106f, 0.02140084f, -0.05509467f, -0.03578144f, 0.01962787f, 0.05984734f, 
    -0.04057379f, -0.01015832f, -0.03359341f, 0.02264056f, -0.06395404f, 0.02651657f, 0.01505158f, -0.02950702f, 
    -0.04461414f, -0.24860409f, 0.01959133f, 0.06526972f, -0.00465062f, 0.03392159f, -0.08575782f, 0.06930154f, 
    -0.01772508f, 0.17342085f, 0.07918920f, -0.11596136f, -0.10400695f, -0.00490135f, -0.04667266f, 0.19513717f, 
    0.03029901f, 0.02830160f, 0.28997955f, -0.27882886f, -0.42959473f, 0.07598074f, 0.07746751f, 0.07937396f, 
    -0.00597199f, 0.08693995f, -0.09509633f, 0.33548194f, -0.28677741f, 0.40522277f, -0.30259320f, -0.30074489f, 
    -0.01282449f, -0.03987681f, -0.03314088f, 0.13532919f, -0.24022460f, 0.08420228f, 0.08570029f, -0.03731842f, 
    -0.01959532f, -0.01277857f, 0.06521010f, 0.03064799f, 0.00662979f, 0.07251037f, 0.12259572f, 0.05963694f, 
    0.13124135f, 0.19403142f, 0.37198123f, -0.02184962f, 0.07347631f, 0.04669173f, 0.02674781f, -0.05375659f, 
    0.15266465f, 0.06739772f, 0.09795089f, -0.07895084f, -0.09256078f, 0.02743852f, -0.10408506f, 0.05012638f, 
    0.22340308f, -0.02695930f, -0.12631075f, 0.06594860f, 0.06931096f, 0.04325995f, 0.15013374f, -0.13137276f, 
    -0.07205503f, 0.10083020f, -0.19735092f, -0.22159563f, -0.17238003f, 0.00239620f, 0.14407144f, -0.04976316f, 
    0.16276501f, 0.24948981f, -0.18698052f, 0.07123794f, 0.06087350f, 0.12844431f, -0.10467660f, -0.09663918f, 
    -0.03604034f, 0.14325581f, 0.06207847f, 0.11620601f, 0.28820044f, 0.06379688f, 0.04242959f, -0.03090926f, 
    -0.04496506f, -0.04948680f, 0.13390058f, -0.06059396f, 0.09291440f, 0.19557799f, -0.07067095f, -0.08221108f, 
    -0.14149308f, 0.01449217f, 0.13429840f, 0.00259793f, -0.13957421f, -0.00735632f, 0.15624519f, -0.17509079f, 
    -0.34950817f, -0.00847835f, 0.05788035f, 0.00288376f, 0.16177703f, -0.00858664f, -0.05817848f, -0.17936000f, 
    -0.27398118f, 0.07886757f, -0.06533735f, 0.15224640f, 0.11062263f, -0.04347081f, -0.03717113f, 0.33931363f, 
    0.27504963f, -0.06598836f, 0.01725032f, 0.11771921f, 0.09689729f, 0.15033865f, 0.09138947f, 0.00977534f, 
    0.10793906f, -0.06358530f, -0.19613259f, -0.25623316f, 0.03538214f, -0.07110733f, -0.06361580f, 0.08199792f, 
    0.33267367f, -0.00280219f, -0.24221796f, -0.10716318f, 0.16879021f, -0.03158278f, -0.00557411f, -0.18305747f, 
    0.06211464f, 0.41881242f, 0.07849974f, -0.22174245f, -0.08891860f, -0.12059213f, 0.01697198f, 0.10104511f, 
    -0.10718103f, 0.07624917f, 0.14236522f, 0.13811196f, -0.04268559f, -0.17198201f, -0.11084759f, 0.00809676f, 
    -0.01118614f, 0.07538877f, -0.00316762f, -0.14208543f, -0.30701259f, 0.34942204f, 0.14103293f, 0.06837160f, 
    -0.03160081f, -0.07774723f, -0.09442618f, -0.02840041f, -0.01343802f, -0.05722083f, 0.00373867f, 0.07907304f, 
    -0.02271364f, -0.17771241f, -0.24755834f, 0.07428730f, 0.02129898f, 0.22837454f, -0.01940113f, -0.12173831f, 
    -0.08408432f, 0.15976632f, -0.00716270f, -0.00494045f, -0.10904323f, 0.10514860f, 0.05981098f, -0.10606454f, 
    0.09523701f, 0.06080135f, 0.04731615f, 0.01543000f, 0.03282395f, -0.08275410f, 0.09398328f, 0.14335701f, 
    -0.04448662f, 0.17074779f, -0.03084392f, 0.03626361f, 0.05711326f, 0.03620365f, -0.03800095f, 0.11593865f, 
    0.15833855f, 0.06874291f, -0.36092192f, -0.00046464f, 0.06980994f, 0.14605153f, 0.15101573f, 0.09178416f, 
    0.02987716f, -0.01166938f, 0.03048884f, 0.04252584f, 0.07568194f, 0.05567709f, 0.07021853f, 0.02661182f, 
    -0.06918328f, 0.14012975f, 0.40706131f, 0.13125326f, -0.13327721f, 0.01139333f, -0.06648639f, 0.10894183f, 
    0.06323539f, 0.06870461f, -0.05316985f, 0.13833927f, -0.00489233f, 0.05520182f, -0.01158845f, 0.09858695f, 
    -0.10182155f, -0.02116523f, 0.10924023f, -0.07883134f, 0.17910066f, -0.07256764f, -0.09110762f, 0.02262813f, 
    0.06650984f, -0.00942253f, 0.08041336f, -0.13306521f, 0.01009481f, -0.01217238f, -0.25664139f, 0.04031040f, 
    0.08974623f, 0.08482037f, -0.03921240f, -0.00810037f, 0.22355016f, -0.00179720f, 0.08376935f, -0.14625809f, 
    -0.14339745f, 0.04757626f, 0.19120157f, 0.02326182f, 0.02629185f, -0.06036317f, -0.10705382f, 0.74809384f, 
    0.12745917f, -0.13412048f, 0.02310460f, -0.07540593f, -0.07228977f, -0.25472137f, -0.00083473f, 0.08041264f, 
    0.09448444f, 0.17097837f, -0.09746629f, -0.07396270f, 0.17368856f, -0.16907892f, 0.03597121f, -0.13413040f, 
    0.15599617f, -0.05006230f, 0.15785556f, -0.11906523f, 0.12251227f, -0.14172441f, -0.00902760f, -0.18099526f, 
    0.00805318f, -0.08963583f, -0.12628977f, 0.33600172f, 0.27614966f, -0.02576102f, 0.01022360f, 0.21519309f, 
    0.01391591f, 0.03330418f, 0.04041792f, 0.25725764f, 0.33438185f, 0.16507515f, -0.00325655f, 0.30283073f, 
    -0.14645272f, 0.09589338f, 0.16557308f, -0.17317264f, 0.15502772f, 0.06687447f, 0.28268671f, -0.00652959f, 
    0.12473208f, 0.05524692f, -0.06765518f, 0.07990012f, 0.01355280f, 0.05672078f, -0.24767599f, -0.06049335f, 
    0.08298123f, -0.02810319f, -0.05499273f, 0.03351578f, -0.14585896f, -0.00419919f, 0.10290027f, -0.15007755f, 
    -0.03171132f, 0.07730129f, -0.03631250f, -0.09922177f, 0.00738729f, 0.05194386f, 0.10123626f, 0.11173712f, 
    -0.13349797f, 0.09493698f, 0.03952665f, 0.01432804f, 0.12445422f, -0.05463353f, -0.09396574f, -0.02754902f, 
    -0.07042910f, 0.08236557f, -0.07358966f, -0.11562230f, -0.04795387f, -0.16477245f, -0.02205863f, 0.05808360f, 
    -0.18907501f, 0.25286371f, 0.29454872f, -0.02015513f, 0.07841145f, 0.08850006f, 0.17745760f, 0.01765472f, 
    0.23706083f, -0.17048739f, -0.00637175f, -0.21353549f, -0.13623059f, 0.00405383f, 0.04333805f, 0.05533721f, 
    -0.11023255f, 0.02623011f, -0.05876471f, 0.20366170f, -0.08603349f, 0.68528968f, 0.14743139f, 0.20383590f, 
    -0.00356099f, -0.08650026f, -0.11689878f, 0.03611631f, 0.11674416f, 0.31622615f, -0.16270383f, 0.00655447f, 
    0.08069060f, 0.12900344f, -0.01537090f, -0.07846905f, -0.22349343f, -0.00615308f, -0.04861028f, 0.06976554f, 
    -0.09960922f, -0.13307740f, 0.01191750f, -0.20988679f, -0.15873997f, -0.13623431f, -0.25058952f, 0.15862215f, 
    -0.25219411f, 0.06293239f, -0.21136153f, 0.01658666f, -0.07349891f, 0.08033615f, -0.00300717f, 0.03567240f, 
    0.07375804f, -0.04104747f, -0.01186557f, 0.14371414f, -0.18073452f, -0.02389051f, -0.09924030f, -0.00467626f, 
    -0.03035718f, 0.17903721f, -0.04866848f, 0.14367343f, -0.12571786f, 0.00590707f, -0.15775540f, 0.05658223f, 
    -0.10873081f, -0.06397688f, 0.15585943f, -0.07336318f, -0.04875638f, 0.08326485f, 0.15128824f, 0.07158047f, 
    -0.04919761f, -0.18410268f, 0.15264107f, 0.07518037f, 0.01203370f, -0.04939561f, -0.05203451f, -0.06096485f, 
    -0.07822622f, -0.01067925f, 0.07189668f, -0.22983973f, -0.42322510f, -0.17403728f, 0.22421639f, 0.08658692f, 
    -0.03101851f, -0.05212124f, -0.11193617f, 0.09491350f, -0.38566497f, -0.00995658f, 0.01982872f, 0.13459481f, 
    0.13077511f, 0.03323536f, 0.02404247f, -0.18098007f, 0.09144100f, 0.05866333f, 0.02597489f, -0.06624614f, 
    -0.03885037f, 0.01922820f, 0.12457719f, -0.00441387f, 0.08134060f, -0.03972526f, -0.10231603f, -0.01961809f, 
    -0.02527481f, -0.07614442f, 0.08170040f, 0.04164685f, -0.09054454f, 0.05102723f, -0.08938175f, 0.05790231f, 
    -0.24588753f, 0.01550758f, -0.03847563f, 0.11962643f, 0.02779824f, 0.10394468f, 0.00145725f, 0.05132483f, 
    -0.08891757f, 0.19797251f, -0.13046798f, 0.00409119f, -0.02400040f, -0.10265782f, -0.23672406f, 0.08049456f, 
    -0.02802007f, -0.11045509f, -0.02281564f, -0.14760779f, -0.03032254f, 0.09043834f, -0.08419728f, 0.05776707f, 
    -0.16126062f, 0.02559184f, -0.26033357f, 0.27203152f, 0.03460407f, -0.03519827f, 0.16107704f, 0.06315813f, 
    -0.08392262f, -0.08425382f, 0.14866298f, -0.05446224f, -0.11716837f, 0.05354752f, 0.07486121f, -0.05839201f, 
    0.05842496f, -0.02302044f, -0.06994317f, 0.16195741f, -0.04381536f, 0.02313637f, 0.16055390f, -0.06263179f, 
    0.23136714f, -0.01244055f, -0.01151210f, 0.05584443f, -0.00856973f, 0.37962273f, 0.18675825f, 0.30154142f, 
    -0.16861875f, 0.08133420f, -0.06948540f, -0.03872037f, -0.19448459f, 0.06728171f, -0.10710554f, -0.15761572f, 
    0.01324388f, -0.02220696f, 0.01906663f, 0.14244132f, -0.04283790f, -0.06784835f, 0.05751893f, -0.11168297f, 
    0.21606851f, 0.33235431f, 0.07059231f, 0.02549264f, 0.04089229f, 0.05543453f, 0.09341224f, -0.12687154f, 
    0.04165357f, 0.07135810f, -0.11837336f, -0.05974622f, -0.05002192f, 0.17445749f, 0.13418712f, 0.16619155f, 
    0.14065322f, 0.11522160f, 0.04909776f, 0.10533652f, -0.06546629f, -0.07670253f, 0.02522670f, -0.09399437f, 
    -0.07433771f, -0.01391604f, 0.04451466f, 0.20625922f, -0.14312483f, 0.07551563f, 0.18511483f, 0.02288562f, 
    -0.03189055f, 0.18405071f, 0.08059402f, 0.13441733f, -0.24157843f, 0.11025483f, 0.02809819f, 0.11327294f, 
    0.00409651f, 0.07779549f, -0.10986524f, -0.08248037f, 0.07852514f, 0.14587440f, 0.21425000f, 0.07112335f, 
    0.09027885f, 0.16121426f, 0.05315882f, 0.09190527f, 0.05663721f, -0.11009527f, 0.01242989f, 0.00973218f, 
    -0.14946239f, -0.01758430f, -0.14281598f, -0.11266685f, -0.21525085f, 0.14178069f, -0.16657405f, 0.02021514f, 
    -0.01440032f, -0.15322593f, -0.00573180f, 0.00102831f, -0.02667557f, 0.10427418f, -0.11431661f, -0.09391612f, 
    -0.09239625f, -0.10878294f, -0.16843592f, 0.12622496f, 0.02394013f, -0.24290380f, -0.09906545f, -0.22334667f, 
    -0.07093999f, -0.11950517f, 0.03208157f, 0.07904381f, -0.07214619f, -0.13993339f, -0.07501822f, -0.19427162f, 
    -0.40312007f, -0.08833187f, 0.07029985f, -0.02948865f, 0.12824492f, -0.15421924f, 0.11146411f, -0.08204800f, 
    0.27288315f, 0.04817726f, 0.26349103f, 0.01362503f, 0.01192179f, -0.04402631f, -0.00990589f, 0.09987041f, 
    0.04468166f, 0.00238370f, 0.03954701f, -0.10635380f, -0.00781910f, -0.25246382f, 0.08290418f, 0.05763378f, 
    0.09791777f, -0.24338125f, 0.05783186f, -0.06604040f, -0.11210887f, 0.10418726f, 0.18544513f, -0.01086793f, 
    0.06715833f, 0.06353489f, 0.39259416f, -0.02736356f, 0.07545619f, -0.09783200f, 0.02485120f, -0.11468800f, 
    -0.27978089f, 0.09357250f, 0.17983943f, 0.00304546f, -0.10892105f, -0.41554087f, -0.29481536f, 0.07787266f, 
    0.19440906f, 0.01468506f, 0.13714275f, 0.23195547f, -0.04199613f, -0.00400869f, -0.32935157f, -0.05814897f, 
    -0.04130720f, 0.01689152f, -0.03116210f, -0.09171128f, -0.01271535f, 0.18594493f, -0.05313089f, 0.14292663f, 
    -0.04650354f, -0.03881846f, -0.09308749f, 0.08924662f, -0.04174351f, 0.05053849f, 0.13865416f, -0.16770826f, 
    -0.18536891f, -0.00552043f, -0.08193907f, 0.06647858f, 0.11889149f, -0.15402912f, 0.01972676f, 0.00369431f, 
    -0.05647819f, 0.11991622f, -0.00635662f, -0.01830823f, 0.07586689f, 0.04207296f, 0.09881703f, -0.03086825f, 
    0.05774487f, 0.05676730f, 0.08852449f, -0.00758894f, -0.18262048f, 0.01352890f, -0.17289545f, -0.20215735f, 
    -0.19734314f, -0.05310299f, -0.05367619f, -0.03451485f, -0.32934251f, -0.03593162f, -0.02049436f, -0.15227176f, 
    -0.03573442f, 0.01701647f, 0.05477542f, 0.09066366f, -0.22351781f, -0.10757330f, 0.02461346f, 0.13495396f, 
    -0.08930431f, -0.07539767f, -0.09461959f, -0.17260709f, -0.20729309f, -0.01008989f, 0.16630846f, -0.01590802f, 
    -0.03839917f, 0.05600981f, 0.05029453f, 0.00505312f, 0.02826584f, 0.00698349f, 0.11266463f, 0.21900703f, 
    -0.11932942f, -0.15352811f, 0.07640959f, 0.12011414f, -0.01131981f, -0.05042297f, 0.19482656f, -0.05786259f, 
    0.03827919f, 0.13488072f, 0.05109666f, 0.00448103f, -0.00975983f, 0.10597157f, -0.14127102f, 0.04839836f, 
    -0.04631406f, 0.24161561f, -0.02572595f, -0.02686992f, 0.00058714f, 0.14594854f, 0.10553673f, -0.08120945f, 
    -0.03119420f, 0.01486434f, -0.13084783f, -0.10061987f, 0.04071951f, 0.18435191f, 0.01047335f, 0.15417659f, 
    0.13024873f, -0.16266514f, 0.04534705f, -0.24512564f, -0.11956432f, 0.10212515f, -0.04220327f, 0.09292551f, 
    -0.00496344f, -0.10501318f, 0.00444185f, -0.13852996f, 0.02011885f, 0.10064159f, -0.04016442f, 0.06036346f, 
    -0.05903826f, 0.02198729f, 0.06768379f, 0.09648792f, 0.08996803f, 0.02399477f, -0.16199479f, -0.14750063f, 
    0.08869215f, 0.08159125f, -0.12498143f, 0.28874254f, 0.13979891f, 0.03612308f, 0.10745077f, 0.05939055f, 
    0.04872865f, -0.06926163f, -0.05356269f, -0.00402998f, -0.06977120f, 0.04640414f, -0.01410916f, -0.18628868f, 
    -0.08683156f, 0.45338807f, 0.26758707f, 0.07631616f, 0.18927327f, 0.09274819f, -0.01435572f, 0.15114218f, 
    -0.02437786f, -0.10086826f, -0.10459028f, -0.05284419f, -0.15066990f, -0.23634672f, -0.06950237f, -0.13228227f, 
    -0.15689766f, -0.11784452f, 0.23805371f, 0.02241731f, 0.05922056f, -0.04767622f, -0.01303532f, 0.01674438f, 
    0.04174976f, -0.12469256f, -0.09319016f, 0.15288895f, 0.08342644f, 0.04499825f, 0.25975254f, 0.18903130f, 
    0.01214890f, -0.07291863f, -0.17923410f, 0.02281953f, -0.21434763f, 0.68151265f, 0.18207978f, -0.02707227f, 
    -0.05253746f, 0.03491627f, 0.14161003f, 0.07575433f, 0.17112871f, -0.02341378f, 0.07431102f, 0.19438583f, 
    0.33555824f, 0.07720729f, 0.19949012f, 0.02722593f, -0.06708096f, 0.03628500f, 0.12479646f, -0.14482702f, 
    0.00782338f, 0.10154090f, 0.00213176f, -0.04576173f, 0.02344475f, 0.19461785f, -0.13163660f, 0.13174018f, 
    -0.04363769f, -0.09712244f, -0.05332536f, -0.05433575f, 0.03286175f, 0.12061204f, -0.01149562f, 0.29138464f, 
    -0.25863770f, -0.09720266f, -0.10178339f, 0.08054966f, 0.02812316f, -0.08567284f, 0.06205602f, 0.25014082f, 
    -0.09543730f, 0.13569975f, -0.05093680f, -0.00745988f, 0.13103600f, -0.14877690f, 0.19360866f, 0.08136054f, 
    0.10068241f, -0.22076981f, 0.10285037f, 0.21598956f, 0.00893597f, -0.16480461f, 0.20114763f, -0.22489560f, 
    0.24357435f, -0.00198511f, 0.01589944f, 0.03820163f, 0.07172094f, -0.07724170f, -0.20341924f, -0.09687871f, 
    0.04994555f, -0.01007501f, -0.18774699f, -0.00908035f, -0.34005708f, 0.39928642f, -0.12421582f, 0.04660583f, 
    0.30053952f, -0.21331030f, -0.18775097f, 0.13312425f, 0.11716234f, 0.05616282f, 0.23982199f, -0.02520873f, 
    -0.15825872f, -0.00527085f, 0.08686766f, 0.00307138f, 0.09580919f, 0.09339287f, 0.06344792f, 0.30489448f, 
    -0.12606829f, -0.04021348f, -0.16336977f, -0.14520817f, 0.03303443f, -0.10713552f, -0.09213449f, 0.01952754f, 
    0.12475428f, -0.01466747f, 0.23276058f, -0.30195907f, -0.00445413f, 0.13451350f, 0.18142503f, 0.26229194f, 
    0.01735627f, -0.02464888f, 0.03342024f, -0.07236902f, -0.11627369f, -0.05653270f, 0.05929681f, -0.02252013f, 
    -0.11388209f, 0.07410011f, 0.26922774f, -0.03295162f, 0.15681115f, -0.16815254f, -0.01009912f, 0.19154675f, 
    0.18983555f, -0.36319095f, 0.29757884f, 0.04467805f, 0.00278267f, -0.03646831f, 0.11661343f, 0.13204998f, 
    0.08257739f, 0.12892605f, 0.14488043f, 0.24924406f, -0.09206934f, 0.12500402f, -0.07200967f, -0.05577960f, 
    0.13445958f, -0.01702938f, 0.02119006f, -0.07665163f, 0.16193144f, -0.42028540f, -0.04447782f, -0.16407809f, 
    -0.20680782f, -0.11439636f, -0.01942743f, 0.13953838f, -0.11606120f, 0.00167113f, 0.10948003f, -0.29177335f, 
    0.03856051f, -0.12832801f, 0.07121197f, 0.12800159f, -0.16495039f, 0.15052076f, -0.12000430f, -0.21586470f, 
    -0.17968209f, 0.05086796f, -0.16135213f, -0.11582991f, 0.07294545f, 0.04490062f, 0.07954103f, -0.16003089f, 
    0.03342031f, 0.06818195f, 0.02579035f, 0.12367850f, -0.01219223f, 0.05595645f, -0.03432781f, -0.20786694f, 
    -0.17642498f, 0.29523563f, -0.08694313f, -0.00635217f, -0.05727537f, -0.01645692f, 0.05249593f, 0.06049087f, 
    -0.04890334f, 0.13064080f, 0.24992043f, -0.01668036f, 0.15384099f, -0.18430197f, -0.20347388f, 0.06397657f, 
    -0.09317645f, 0.16134733f, -0.16965264f, 0.02790142f, -0.04611536f, -0.06627201f, -0.03055994f, -0.05050997f, 
    -0.01187191f, -0.08043505f, -0.75186896f, -0.09687501f, -0.13216452f, -0.03692090f, 0.14201333f, -0.12528260f, 
    -0.05051637f, -0.26713282f, 0.02596023f, -0.03965480f, -0.18003568f, -0.03343458f, -0.05401786f, -0.08529759f, 
    -0.15234758f, 0.10749049f, 0.08833782f, 0.06542283f, -0.09922106f, -0.04782001f, 0.02288462f, 0.14540906f, 
    -0.06371251f, 0.09774937f, -0.02420937f, 0.14057568f, 0.01865385f, 0.41007486f, 0.37570634f, -0.10795830f, 
    -0.09058935f, -0.12209538f, 0.20765501f, 0.12864168f, -0.11535092f, -0.15578210f, -0.13606307f, -0.08265824f, 
    0.22317836f, -0.04702722f, -0.00543711f, -0.06852815f, -0.06110995f, -0.06904979f, -0.04359876f, -1.13660371f, 
    0.41574800f, -0.45660549f, 0.01939029f, -0.12566160f, 0.15017059f, 0.04222695f, 0.09230042f, -0.00879864f, 
    -0.04027412f, -0.10301965f, 0.27889246f, -0.03249846f, -0.14176282f, -0.20339990f, -0.14842623f, 0.01148878f, 
    0.22783604f, -0.14854813f, -0.23065804f, -0.16566750f, 0.00041988f, -0.19860382f, 0.08938635f, -0.10825417f, 
    0.00790570f, 0.00757963f, -0.10412075f, 0.02560152f, -0.29745099f, -0.25414711f, 0.16223876f, 0.07483560f, 
    0.01436703f, 0.11228595f, -0.09835659f, 0.03833537f, -0.46404964f, -0.87835014f, 0.03410441f, 0.02978484f, 
    0.07687987f, 0.07510395f, 0.03594458f, -0.20340115f, 0.22764765f, 0.17563008f, -0.40868255f, -0.09634423f, 
    -0.02533507f, 0.01851346f, -0.01287577f, 0.06752266f, 0.04892361f, 0.21064869f, 0.04117306f, 0.10818329f, 
    0.03617120f, 0.05937489f, 0.15331969f, 0.10945458f, -0.05629090f, 0.07576711f, -0.01806657f, 0.28331470f, 
    0.11469738f, 0.02020565f, 0.03683674f, 0.12284886f, 0.14356492f, 0.06999248f, -0.01696592f, 0.42886776f, 
    -0.14772902f, 0.23185150f, 0.07880931f, 0.03772039f, 0.07826404f, 0.13732953f, 0.05129624f, 0.03109921f, 
    0.11352649f, -0.46648866f, -0.41802406f, 0.11273991f, 0.11623075f, -0.08487985f, 0.01596279f, -0.01244044f, 
    0.05475299f, -0.32078481f, 0.00987839f, -0.12378427f, 0.01026172f, -0.09069660f, 0.08376250f, -0.04943852f, 
    0.02746639f, -0.06138261f, 0.00164635f, -0.34701198f, -0.16555569f, -0.03270340f, -0.03998513f, 0.05591261f, 
    0.15446252f, 0.09128276f, 0.05539575f, 0.60010624f, 0.04359462f, -0.18531093f, -0.31940669f, -0.02742820f, 
    -0.10707314f, 0.12938917f, 0.05076279f, -0.02731187f, -0.43035141f, -0.22610463f, 0.23673847f, 0.10848876f, 
    0.18927893f, -0.11263794f, -0.03514779f, 0.11403472f, 0.02487213f, -0.22128354f, -0.06309862f, -0.08817855f, 
    0.05725622f, 0.04251266f, -0.04664066f, 0.00468550f, -0.06056426f, 0.00748668f, -0.02730911f, -0.06843852f, 
    -0.31989983f, -0.02344613f, 0.05924233f, 0.07305875f, 0.16323499f, 0.04002017f, 0.09535298f, 0.03634455f, 
    0.07119665f, -0.03503441f, 0.23420888f, -0.02956787f, -0.04983300f, 0.03925019f, 0.01804698f, 0.14997153f, 
    0.10584644f, -0.20325524f, 0.15953238f, -0.00747037f, -0.09587947f, 0.09599459f, 0.11623549f, 0.07675125f, 
    0.05625533f, -0.26901612f, -0.51699984f, -0.07979093f, 0.18700223f, -0.03047410f, -0.21493036f, 0.12389523f, 
    0.13105135f, -0.01496942f, 0.07235362f, -0.24606664f, -0.37168133f, 0.04129861f, -0.02996574f, 0.04537456f, 
    0.11393119f, 0.01885652f, 0.10014082f, 0.06893691f, -0.25480750f, -0.14246643f, -0.03265621f, 0.20003581f, 
    0.22953230f, 0.08426712f, 0.01095848f, 0.18342307f, 0.12575047f, 0.18789046f, 0.18195860f, -0.09151607f, 
    0.19593669f, -0.16235210f, 0.08665576f, 0.03672275f, 0.07520313f, 0.26217142f, -0.20340006f, 0.16526365f, 
    -0.02473510f, 0.07271670f, 0.31446394f, 0.10761373f, 0.02940994f, -0.04011071f, -0.05278732f, -0.20669985f, 
    -0.55366671f, 0.04341340f, 0.08801017f, -0.01436887f, -0.01619856f, 0.17344488f, -0.09243335f, 0.08256294f, 
    0.15568122f, -0.03272007f, -0.04582225f, 0.10811114f, -0.22600794f, 0.04460998f, -0.14630969f, -0.12085859f, 
    -0.43206850f, -0.03602269f, -0.13434216f, -0.14701530f, -0.15235260f, 0.04689707f, -0.11388253f, 0.08628676f, 
    -0.02356114f, 0.34174359f, -0.33162284f, -0.33994791f, -0.09491536f, -0.04148639f, 0.06362885f, 0.02992942f, 
    0.10474410f, 0.10323004f, -0.03300193f, -0.04621306f, 0.00990359f, -0.01417573f, 0.00702522f, -0.07859709f, 
    0.03114353f, 0.04995937f, -0.06825653f, 0.09262552f, 0.17916293f, 0.25480896f, 0.06782059f, -0.05713835f, 
    0.00911322f, 0.04718456f, -0.02628228f, -0.10285282f, 0.05738410f, -0.05684768f, 0.02599956f, 0.05988741f, 
    0.05211063f, -0.04230361f, 0.02473580f, 0.04274235f, -0.01506443f, 0.10059628f, 0.05969696f, -0.33197150f, 
    -0.27073261f, -0.02982323f, -0.34421545f, 0.07629805f, -0.10273775f, 0.07369781f, 0.00446020f, 0.11833483f, 
    0.19969307f, -0.02320220f, 0.01707704f, -0.04799050f, 0.04701949f, 0.00634978f, 0.00500873f, -0.19758974f, 
    -0.13913485f, -0.02379698f, 0.10015856f, 0.07898835f, -0.05432027f, 0.16112317f, 0.21352172f, 0.03058126f, 
    0.14869912f, -0.07925969f, -0.13670401f, -0.03217550f, -0.05077249f, -0.23137160f, -0.05537853f, -0.20218636f, 
    -0.24774453f, 0.01625487f, -0.01306073f, 0.05646240f, 0.08387420f, 0.11687510f, 0.13492104f, 0.05707598f, 
    0.12929250f, -0.06747151f, 0.20417552f, 0.03377681f, 0.02459217f, -0.03012129f, 0.00256278f, -0.14010760f, 
    -0.13605009f, -0.11600097f, -0.25140315f, -0.12047748f, -0.19678101f, -0.29009029f, 0.06199179f, 0.01358181f, 
    0.16539370f, 0.05396966f, -0.01274748f, 0.22351243f, 0.09583870f, -0.00972997f, -0.04916564f, 0.09264555f, 
    0.03934936f, 0.04569130f, 0.20383194f, 0.16683836f, 0.07756317f, 0.13273539f, 0.11242303f, 0.29403579f, 
    -0.01426020f, 0.03050208f, 0.03368651f, 0.10757447f, 0.08227812f, 0.14650910f, -0.13323048f, 0.03144180f, 
    -0.07811837f, -0.04340514f, 0.06922016f, 0.00189146f, -0.04309006f, 0.15152565f, -0.02008265f, -0.30674231f, 
    -0.01692819f, -0.00697092f, -0.02307103f, 0.04354122f, -0.13079910f, 0.03425096f, 0.13007972f, 0.25861686f, 
    0.01178846f, 0.16677441f, -0.06213852f, 0.06952577f, -0.04582741f, -0.02348401f, 0.07636036f, 0.07501357f, 
    0.13859048f, 0.11508636f, 0.02775857f, -0.06597951f, -0.01383780f, 0.07290184f, 0.09946654f, 0.07141837f, 
    -0.00567222f, 0.09095366f, 0.02231778f, 0.14967370f, 0.26227123f, -0.03583210f, 0.04938458f, 0.02609277f, 
    -0.00672270f, 0.16204341f, 0.02651188f, -0.61038196f, 0.12704633f, 0.04117955f, 0.00620339f, -0.12862103f, 
    0.05830563f, -0.00890334f, 0.10686015f, 0.26024857f, -0.18562707f, 0.01575476f, -0.09489907f, 0.00494018f, 
    -0.01388939f, -0.16750485f, -0.05563926f, 0.09789708f, 0.02737772f, 0.16063552f, 0.04849716f, -0.01387715f, 
    -0.04190927f, -0.04575251f, -0.00834845f, 0.07077555f, 0.02731379f, 0.18143967f, -0.22692634f, -0.02279070f, 
    0.01551912f, 0.08420788f, 0.07634068f, -0.06252338f, 0.06974655f, 0.05293079f, 0.09126903f, 0.00277697f, 
    -0.13583709f, -0.09797195f, 0.01235266f, 0.01398094f, 0.02907201f, 0.01474993f, -0.07024787f, -0.26907253f, 
    0.09629130f, 0.16495065f, 0.20570326f, -0.13944286f, -0.14995357f, -0.11578589f, 0.01748443f, 0.06793539f, 
    0.21328337f, 0.07977409f, -0.08142901f, -0.13270870f, 0.02279790f, -0.01507622f, 0.17425732f, 0.09129584f, 
    0.11028411f, -0.14851528f, 0.05487575f, -0.09193407f, -0.02218525f, -0.02611017f, 0.07817006f, 0.10714140f, 
    -0.03710429f, -0.05232533f, -0.14972758f, -0.22593601f, 0.27802068f, 0.61887640f, -0.09751975f, 0.08409669f, 
    -0.20081693f, -0.12285335f, -0.05252603f, -0.03144658f, -0.02297890f, -0.30822563f, -0.45536166f, 0.08944568f, 
    -0.18336806f, -0.15827657f, -0.04975772f, -0.04508006f, -0.12169377f, -0.18647207f, -0.18341492f, 0.00217296f, 
    -0.02535070f, -0.16679072f, -0.32373750f, 0.06119050f, 0.10509419f, 0.29811093f, 0.08791429f, 0.12595032f, 
    0.18063064f, 0.08170342f, 0.03811197f, 0.20721968f, 0.10433568f, 0.08446775f, 0.03997443f, -0.29224983f, 
    -0.26250333f, 0.07757989f, 0.08534390f, 0.10300004f, 0.00049911f, -0.03729559f, -0.01452807f, 0.09196093f, 
    -0.13378131f, 0.05142680f, 0.22242340f, -0.02078113f, 0.04365713f, 0.01456192f, 0.16320114f, 0.03539716f, 
    0.02367609f, 0.04510385f, 0.12060854f, 0.19575056f, 0.06713094f, 0.03772790f, 0.15069596f, 0.00089669f, 
    0.01928240f, 0.10759041f, -0.17810367f, -0.48420590f, -0.18232648f, 0.11327824f, 0.04251099f, -0.25853753f, 
    -0.06841592f, 0.08351109f, 0.05861410f, -0.21512881f, -0.18418856f, -0.02572330f, -0.03946293f, 0.00393372f, 
    0.02457979f, -0.04317947f, 0.06024637f, 0.03476340f, -0.05482935f, 0.22996587f, 0.24519409f, 0.02208065f, 
    0.03827964f, -0.24434461f, -0.08902459f, -0.05261678f, -0.11305064f, 0.16609994f, -0.09447917f, -0.12886514f, 
    -0.02874426f, -0.13924100f, -0.04911776f, -0.16128816f, -0.12450155f, -0.19263493f, -0.33635104f, 0.03873841f, 
    0.12581591f, 0.11299627f, 0.07350814f, -0.21423140f, 0.02729123f, -0.07312634f, -0.10464420f, -0.42274618f, 
    -0.50013304f, -0.33493343f, -0.08439200f, 0.04550025f, -0.04044956f, -0.10556149f, 0.03229122f, -0.06332212f, 
    -0.07286460f, 0.21316235f, 0.03491296f, 0.03883442f, -0.07995295f, 0.02632044f, -0.10208333f, 0.21658935f, 
    0.01691941f, -0.15100385f, -0.25646225f, -0.06807339f, -0.03222702f, -0.18503734f, -0.20028612f, -0.09094002f, 
    -0.02336797f, -0.00105506f, 0.01408576f, -0.26602700f, -0.18357620f, -0.00706238f, -0.04097594f, 0.07297023f, 
    -0.03480081f, 0.10779142f, 0.13371815f, 0.52877229f, -0.06278815f, -0.29679847f, -0.08246239f, 0.09590201f, 
    0.25797394f, 0.08195569f, -0.13344496f, 0.16203615f, 0.08970098f, 0.12280607f, 0.24608341f, 0.00621872f, 
    -0.05104181f, 0.03442980f, 0.16556755f, 0.06151861f, 0.03009217f, -0.26547560f, 0.01712633f, -0.07624568f, 
    -0.02251658f, -0.09375068f, -0.00205419f, 0.03825932f, -0.01423004f, 0.05594701f, 0.00035990f, -0.13208471f, 
    0.14161325f, 0.10242655f, 0.06162903f, 0.19158018f, 0.11138641f, -0.00372903f, -0.07897395f, 0.06530368f, 
    0.17851138f, 0.00991966f, -0.06930328f, 0.09606393f, 0.01269499f, 0.12662120f, -0.06785972f, -0.04607444f, 
    -0.10998316f, -0.02725668f, 0.00078936f, 0.07743853f, 0.06864147f, 0.00054864f, 0.00822240f, -0.37250477f, 
    -0.32024869f, 0.13218066f, 0.01776079f, 0.11764807f, 0.12386016f, -0.03980993f, 0.35362619f, 0.16886267f, 
    0.00165537f, 0.07925244f, -0.03475283f, -0.15479304f, -0.14719389f, -0.16141649f, 0.01915220f, -0.06621552f, 
    0.02447844f, 0.12089677f, 0.11423906f, 0.18848802f, -0.02134473f, -0.04520187f, 0.12072695f, -0.02994312f, 
    -0.07237179f, 0.05341538f, -0.19032577f, -0.19611692f, -0.23820797f, -0.10754184f, 0.01434315f, -0.26974517f, 
    0.05892015f, -0.04646937f, 0.23793593f, -0.06251552f, -0.14805108f, -0.15128678f, -0.07350951f, -0.06816735f, 
    -0.08485966f, 0.28792575f, -0.12817869f, -0.06217502f, -0.26450482f, -0.17773978f, -0.39975676f, -0.21659029f, 
    0.30582702f, -0.13494484f, -0.00793797f, 0.07963517f, 0.19682258f, -0.12402466f, -0.11411928f, -0.24727763f, 
    -0.11182461f, -0.16658626f, 0.00207215f, -0.16403814f, -0.09463810f, 0.13213255f, 0.15195172f, -0.02230111f, 
    -0.25760528f, 0.06064644f, -0.20164657f, 0.04136455f, -0.07540205f, -0.10987388f, -0.08530058f, -0.08690815f, 
    0.07683143f, 0.10041390f, -0.10813647f, -0.04865450f, -0.05174216f, 0.12052033f, -0.03802782f, -0.08177143f, 
    -0.12354672f, -0.20865387f, -0.23831855f, -0.21527748f, -0.04372076f, -0.09853826f, -0.08177426f, 0.01498555f, 
    0.09253667f, 0.02498393f, 0.09507804f, -0.20255949f, -0.10252646f, -0.00002998f, -0.00675440f, -0.12981348f, 
    -0.03499746f, 0.19644369f, 0.10992426f, -0.05570162f, -0.28695175f, -0.16181724f, 0.09896287f, 0.07571848f, 
    -0.03611696f, -0.04122878f, 0.11370564f, -0.07370759f, 0.19688267f, -0.40199599f, 0.25689632f, -0.01987062f, 
    -0.09077089f, -0.07869868f, 0.03044564f, 0.00097846f, -0.02264985f, -0.13129264f, -0.04634448f, 0.05762885f, 
    0.04082438f, 0.06009169f, 0.06605935f, 0.03421551f, 0.05720467f, 0.18924819f, 0.04141418f, 0.16631772f, 
    0.03599743f, 0.25205112f, 0.11377385f, 0.18750384f, 0.09897278f, 0.12217952f, 0.15647301f, -0.13681495f, 
    0.04876566f, -0.12220198f, -0.02781573f, -0.02841002f, -0.21748614f, -0.02742812f, 0.05758383f, 0.03669077f, 
    -0.03901492f, -0.16478506f, -0.05085138f, -0.15168788f, 0.09184804f, 0.12158596f, 0.01969684f, 0.00097025f, 
    0.09188854f, -0.04166730f, -0.00498102f, -0.08223354f, 0.30445960f, -0.00310411f, 0.14286105f, 0.02835688f, 
    0.06054331f, -0.02122692f, -0.20914508f, -0.25413781f, -0.04849647f, 0.21828972f, 0.09647869f, 0.09116121f, 
    0.10551555f, 0.21202108f, 0.10245943f, -0.11507250f, 0.16017728f, 0.12246850f, 0.32661408f, 0.08225867f, 
    0.21639742f, 0.10689147f, 0.00113727f, 0.06464703f, 0.05058308f, -0.29891261f, -0.04539528f, -0.10984963f, 
    -0.14449410f, -0.00445561f, -0.04386707f, 0.13942134f, -0.04830007f, 0.22576228f, 0.00590939f, -0.10757119f, 
    0.16554545f, 0.03084702f, 0.01506472f, 0.13758868f, 0.02638265f, 0.00733780f, 0.01134686f, 0.03842788f, 
    -0.24895851f, -0.06242437f, 0.19055066f, -0.00989306f, -0.01754560f, 0.12796906f, 0.09498189f, -0.02000709f, 
    -0.09505263f, 0.08452652f, 0.07635320f, 0.05260695f, 0.04101005f, -0.18085508f, 0.19040382f, 0.16545962f, 
    0.15276769f, -0.16785856f, -0.01423673f, -0.18088065f, 0.02803187f, 0.03077929f, -0.00090754f, -0.05129633f, 
    -0.02252880f, 0.05684305f, -0.27791053f, 0.01655360f, -0.01857810f, -0.08369610f, 0.10365911f, 0.12300063f, 
    0.07086219f, 0.22369975f, 0.16380119f, -0.11433158f, 0.18092248f, -0.03861446f, -0.00224052f, 0.06349288f, 
    -0.08670691f, -0.06400926f, 0.09213172f, -0.03019621f, -0.09182966f, -0.01058026f, 0.30338186f, 0.05929849f, 
    0.06121761f, 0.06541188f, -0.01171090f, -0.12042753f, -0.00153060f, -0.03854442f, -0.00289526f, 0.12287549f, 
    0.06655055f, -0.01022197f, -0.08147518f, -0.04035350f, -0.13008739f, -0.24322428f, -0.12255560f, 0.04391756f, 
    0.16280843f, -0.08228089f, -0.06907503f, -0.00819098f, -0.07154606f, 0.06065973f, 0.02014657f, 0.01943000f, 
    -0.09965803f, 0.03001036f, -0.04671068f, 0.04210639f, -0.10465790f, -0.04353625f, -0.10554789f, -0.10795205f, 
    -0.29629371f, 0.31932440f, 0.03942193f, -0.02211463f, -0.09806661f, -0.06170509f, 0.02083214f, 0.00297794f, 
    -0.13964237f, 0.12420682f, 0.09655507f, 0.15753543f, -0.04694169f, 0.05969042f, 0.05517562f, -0.07797428f, 
    -0.07837373f, 0.11668000f, -0.08852994f, 0.03697830f, -0.25785974f, 0.01972141f, -0.06393097f, 0.06849070f, 
    -0.00627788f, -0.13581713f, 0.14740418f, 0.30136541f, -0.18660937f, -0.03804271f, 0.06376532f, -0.04786526f, 
    0.28038090f, -0.13293035f, 0.14808363f, -0.21056063f, -0.01201484f, 0.18752097f, -0.23618580f, -0.08003891f, 
    -0.03665314f, -0.03657264f, -0.11737583f, 0.00749537f, 0.12759912f, -0.29825333f, 0.07048279f, 0.20856839f, 
    0.09429208f, 0.04070267f, -0.07530607f, -0.01795084f, 0.05899951f, -0.09923695f, -0.29077524f, -0.26932773f, 
    0.04452951f, -0.10168634f, 0.12431428f, -0.11340230f, -0.18752876f, 0.01370951f, -0.13253814f, -0.01169455f, 
    -0.00692142f, 0.04307455f, -0.04394521f, 0.05308021f, -0.03793083f, 0.18707184f, -0.02815842f, 0.01237903f, 
    -0.23352726f, -0.11345623f, -0.20540977f, 0.02991459f, 0.23558143f, -0.03161364f, -0.20239110f, -0.05122865f, 
    -0.23054110f, -0.14178258f, 0.09976650f, -0.14932457f, 0.09305555f, -0.05499282f, -0.07220964f, -0.04110105f, 
    0.14645112f, -0.00531870f, -0.06921652f, 0.00902557f, -0.09448269f, -0.03938783f, 0.15245339f, -0.05077261f, 
    0.00421847f, -0.06599619f, 0.05727220f, 0.12147344f, 0.20985645f, -0.01365641f, -0.20360093f, -0.22011966f, 
    0.09310851f, 0.07301633f, 0.06286717f, -0.14373377f, -0.03050432f, 0.12790564f, 0.39589590f, -0.31550002f, 
    0.10648082f, 0.10595267f, -0.04621829f, 0.05394697f, -0.03984365f, -0.07190613f, 0.28854138f, 0.17188670f, 
    0.00882368f, 0.14612186f, -0.10103428f, -0.03016984f, -0.20351602f, -0.13069716f, -0.07865451f, 0.15624344f, 
    -0.07004799f, 0.04662568f, 0.02976417f, 0.07123049f, -0.04000367f, -0.13192932f, 0.04308182f, 0.18889029f, 
    0.20017083f, 0.25004035f, -0.06298753f, 0.10864249f, -0.11686797f, -0.10809502f, 0.13114744f, -0.01240634f, 
    -0.06217110f, -0.11947042f, 0.05509165f, 0.02481131f, 0.17124397f, -0.14909872f, -0.14423913f, 0.06883351f, 
    -0.07467718f, -0.05266528f, 0.05445908f, -0.11634482f, -0.00770861f, 0.00732288f, -0.00428237f, -0.00270820f, 
    -0.09430670f, -0.01927046f, 0.07269969f, 0.09493146f, 0.16793862f, -0.00130256f, 0.15822394f, -0.22193630f, 
    -0.09690032f, 0.05321412f, -0.04537410f, -0.03039511f, -0.10434889f, 0.18788531f, -0.06021856f, -0.07909171f, 
    0.08185589f, 0.03723766f, -0.13592127f, -0.01368427f, 0.05497339f, 0.08608525f, -0.12773441f, -0.08006705f, 
    0.19325680f, 0.00464097f, 0.12579384f, 0.12379823f, 0.15547460f, -0.05765691f, 0.18121678f, 0.12174150f, 
    -0.00412193f, 0.23395212f, 0.09249166f, 0.06401270f, 0.22494280f, 0.19280192f, -0.03749868f, 0.04932782f, 
    0.19208272f, -0.05732698f, -0.01110009f, -0.08007168f, 0.11929523f, 0.12255650f, 0.12807928f, -0.13070610f, 
    0.03554377f, -0.04735377f, 0.16172716f, 0.11575609f, 0.10841046f, -0.03081768f, -0.01138346f, 0.02148603f, 
    0.03171029f, 0.00016251f, -0.05594859f, -0.04840082f, -0.00410261f, 0.01397379f, 0.03099498f, 0.00258597f, 
    -0.02157800f, 0.04614579f, 0.00198030f, -0.05862237f, 0.00494241f, -0.02749891f, 0.00766442f, -0.04798466f, 
    -0.02463770f, -0.00488545f, 0.00598360f, 0.03418318f, 0.03843792f, 0.03040012f, 0.02629763f, 0.02473983f, 
    0.01106283f, -0.01526787f, 0.02512739f, -0.01054694f, 0.00065547f, -0.01004570f, 0.01515874f, -0.06387951f, 
    -0.00162578f, 0.01803662f, 0.02398729f, 0.01761455f, -0.02594109f, 0.00659660f, -0.06335539f, -0.03937683f, 
    0.03287012f, 0.01168118f, 0.01010008f, 0.02487507f, -0.03555918f, 0.01540093f, 0.01234246f, -0.01721240f, 
    -0.02852005f, -0.01307037f, -0.05095872f, -0.01303007f, 0.02672613f, 0.04083997f, -0.05169906f, 0.00395658f, 
    -0.05144018f, -0.05618918f, -0.04921276f, -0.05602026f, -0.04485394f, 0.01430204f, -0.01410213f, 0.01703926f, 
    -0.03234863f, -0.05767005f, -0.00686628f, -0.02672192f, 0.02162165f, -0.05328161f, -0.06349730f, 0.00880290f, 
    -0.00504214f, -0.02047479f, -0.05140696f, -0.02092230f, 0.03310414f, -0.03856634f, 0.04607281f, -0.02322747f, 
    -0.01515252f, -0.02473220f, 0.02720189f, 0.02613039f, -0.06128330f, -0.03888226f, -0.02340354f, 0.03431447f, 
    -0.02223235f, -0.02795353f, 0.02933905f, -0.05531644f, 0.03239536f, -0.06326137f, -0.02096388f, -0.01527346f, 
    -0.04633232f, -0.01195948f, -0.05375654f, 0.00764169f, -0.00524252f, -0.03588152f, 0.01026831f, -0.03140416f, 
    -0.00484429f, 0.04524908f, -0.04178705f, -0.01892498f, -0.04423219f, 0.03091584f, 0.02668478f, 0.04223279f, 
    0.04359175f, -0.01090609f, 0.01666154f, 0.01876344f, -0.01647815f, -0.00102363f, 0.04085162f, 0.01469594f, 
    0.02683561f, -0.04436204f, -0.00087887f, -0.05302097f, -0.00440925f, -0.05018446f, 0.00971796f, -0.03766040f, 
    -0.05028816f, -0.02198446f, -0.00836009f, 0.04670757f, 0.03579987f, 0.03547555f, -0.00565493f, -0.04047562f, 
    0.02908380f, 0.01308303f, -0.05094628f, 0.04341859f, -0.06111772f, 0.04748634f, -0.03621488f, -0.01094765f, 
    0.02114788f, 0.01822320f, 0.02391668f, -0.00187440f, 0.02197727f, -0.01659697f, 0.01320171f, -0.03938675f, 
    -0.01798440f, 0.01724782f, -0.05795084f, -0.05679206f, -0.04312200f, 0.00072483f, 0.02419479f, 0.02972871f, 
    -0.04225553f, -0.04549516f, -0.05021993f, -0.00632859f, -0.04284434f, -0.05512075f, -0.03598238f, -0.05027221f, 
    0.01352780f, 0.00234360f, 0.01297595f, -0.02984298f, -0.00539041f, -0.02680698f, -0.04719679f, -0.02372208f, 
    -0.05448560f, 0.05610863f, 0.05214745f, 0.00265221f, -0.01717358f, 0.02410316f, 0.03559063f, 0.04781491f, 
    0.04823218f, -0.05993784f, -0.02466987f, -0.06161045f, -0.01584753f, -0.03741072f, -0.01099816f, 0.00250801f, 
    -0.03807484f, 0.05267711f, -0.06206375f, -0.03399444f, -0.02728225f, -0.03156115f, -0.04681233f, 0.04035247f, 
    0.03790366f, -0.01765218f, -0.00711441f, -0.04877361f, -0.01080389f, -0.00571618f, -0.05324562f, -0.00343671f, 
    0.05361900f, -0.04670266f, 0.00940704f, 0.04855592f, -0.00442071f, -0.00325671f, 0.02069076f, 0.04837756f, 
    0.02530668f, 0.02266594f, -0.05698485f, 0.05246138f, -0.05630573f, -0.05259206f, -0.03574358f, -0.04087897f, 
    -0.04935795f, 0.00047076f, 0.04669491f, 0.01709029f, -0.04553438f, 0.01681442f, 0.00008017f, -0.04301184f, 
    0.02795256f, 0.04171116f, -0.06315681f, 0.01012744f, 0.01117890f, -0.00353375f, -0.00337369f, -0.03347001f, 
    -0.04916274f, -0.03318486f, 0.04770979f, -0.01290699f, -0.01901773f, 0.04387322f, -0.01788886f, 0.00461615f, 
    0.00783379f, -0.03946420f, -0.00577334f, -0.05970229f, -0.02496112f, 0.01656999f, -0.04738679f, 0.01538434f, 
    0.00187778f, -0.04037660f, -0.04269793f, -0.00614316f, 0.04049667f, -0.01637205f, -0.01020470f, 0.01079565f, 
    -0.02128952f, -0.02355277f, 0.02964452f, -0.02759511f, -0.00079113f, 0.01835557f, 0.03878263f, -0.02249638f, 
    0.03605072f, 0.00586648f, 0.02167063f, -0.03160019f, -0.00354701f, 0.03762510f, -0.02021940f, 0.04672090f, 
    0.05850844f, -0.00244816f, -0.03876274f, -0.03254662f, 0.00750674f, -0.01229182f, -0.05843242f, 0.01771730f, 
    -0.00633952f, -0.05401571f, 0.00491224f, -0.02055262f, -0.04737902f, -0.05455402f, -0.04770653f, -0.06527936f, 
    -0.01387345f, -0.07422006f, -0.01099929f, -0.03551488f, -0.01374231f, -0.01788598f, -0.04758710f, 0.04320060f, 
    -0.01664343f, -0.06910315f, 0.01865423f, -0.06061454f, -0.00227192f, -0.03181751f, 0.00212624f, -0.03281492f, 
    -0.01043095f, -0.02795476f, -0.03727354f, -0.02977154f, 0.00535842f, 0.03034752f, 0.02447551f, 0.03536493f, 
    0.00283772f, -0.02675386f, 0.02788309f, -0.02467053f, -0.03667039f, -0.03569278f, 0.01723379f, -0.05587014f, 
    0.05294087f, -0.00777080f, 0.04855735f, -0.03467501f, 0.00835154f, -0.00155141f, 0.02240265f, -0.05780977f, 
    -0.04599856f, -0.03209548f, 0.03289249f, 0.01425937f, -0.03032677f, 0.04992196f, 0.00863845f, -0.03587782f, 
    0.02319232f, -0.00361409f, 0.03060499f, -0.02022190f, 0.02375983f, -0.05646893f, -0.04062997f, -0.03123652f, 
    -0.05934248f, -0.06420152f, -0.04065804f, 0.04058792f, 0.00069423f, 0.00514698f, 0.00039561f, -0.03456193f, 
    0.02650230f, -0.03612747f, 0.04485205f, -0.01871414f, -0.03443290f, 0.01283274f, 0.02663842f, -0.06060080f, 
    -0.06987975f, -0.00437155f, -0.04886695f, -0.00982089f, -0.00486268f, -0.06005247f, -0.05700414f, 0.04003960f, 
    -0.01785565f, -0.01522260f, 0.01054917f, 0.04551859f, -0.03899723f, -0.00127621f, 0.02354634f, -0.06026446f, 
    0.00172706f, 0.01190905f, -0.00557231f, -0.06901094f, -0.00892648f, -0.01025835f, 0.05929862f, -0.06056015f, 
    0.05818931f, 0.00729373f, -0.03261763f, 0.00749682f, 0.00093245f, -0.04818280f, -0.01623942f, -0.05269254f, 
    -0.03245813f, 0.02309818f, -0.00863648f, 0.03484992f, 0.03890528f, -0.04919080f, -0.05107259f, 0.05160502f, 
    0.01151026f, 0.02416787f, 0.02693538f, -0.04243070f, 0.00797754f, 0.04903800f, -0.01072784f, -0.02062235f, 
    -0.05637514f, 0.02018451f, 0.04256783f, 0.05479262f, 0.04284067f, -0.03145723f, -0.03049501f, 0.00858895f, 
    0.01928495f, -0.01176196f, -0.01797127f, 0.04835940f, -0.00280942f, -0.01884020f, 0.01849342f, -0.00755556f, 
    0.03619971f, -0.04305362f, 0.03243809f, 0.02205855f, -0.06170379f, 0.00669687f, -0.00961113f, 0.00338031f, 
    0.00234399f, -0.01969206f, 0.00397312f, -0.00730720f, -0.01554793f, 0.02663420f, -0.03497594f, -0.05370813f, 
    0.04385693f, 0.03555131f, -0.02060064f, 0.00657988f, -0.07121745f, -0.04408885f, -0.02179395f, -0.05031335f, 
    -0.02216903f, -0.02989435f, -0.04037151f, -0.05749342f, -0.05106198f, -0.01977717f, -0.00833545f, 0.01966915f, 
    0.04387240f, -0.01589284f, -0.00319346f, 0.00590883f, 0.01171627f, -0.04102952f, 0.01266492f, -0.03855895f, 
    0.00430224f, -0.04295363f, 0.02623042f, 0.03194666f, -0.03459899f, -0.04365075f, 0.00447927f, 0.05417478f, 
    0.01147671f, 0.02205366f, 0.04657326f, -0.00328286f, -0.03020533f, 0.00605587f, -0.03821032f, -0.03225197f, 
    -0.04951580f, -0.04667943f, 0.05114793f, 0.03505291f, -0.04402401f, -0.01693970f, -0.01022653f, -0.01635317f, 
    -0.05181495f, 0.00055201f, -0.02876238f, 0.04297878f, 0.04445370f, -0.04186186f, -0.05514939f, -0.05133560f, 
    -0.05956236f, -0.00365223f, -0.04015997f, -0.00909470f, -0.06340205f, -0.00243177f, 0.03107927f, -0.02153202f, 
    -0.00136581f, -0.03170602f, -0.05307255f, -0.01740184f, -0.03492796f, 0.02831573f, -0.00886028f, 0.00775097f, 
    -0.04147056f, -0.05216775f, 0.04684878f, -0.03917735f, 0.02930846f, 0.04551905f, 0.04306922f, -0.01575706f, 
    -0.07353555f, -0.05219340f, 0.00056345f, 0.03037984f, -0.06138622f, 0.05805802f, 0.00213716f, -0.05626241f, 
    -0.05510818f, -0.04027372f, -0.01766102f, -0.01098259f, 0.01747974f, 0.01108691f, 0.00548141f, 0.04225975f, 
    0.01591127f, -0.04108286f, -0.01237993f, 0.00951547f, 0.01868013f, -0.05655285f, -0.00371276f, -0.04968521f, 
    0.02262511f, 0.00967859f, 0.05521461f, 0.04601558f, -0.04349787f, 0.01106552f, 0.02597923f, -0.02290341f, 
    0.01970492f, 0.03918776f, -0.05185705f, -0.02293684f, -0.00844400f, 0.04579576f, 0.04585048f, 0.02955421f, 
    0.00293863f, 0.00429526f, 0.02953455f, -0.01718506f, 0.02496195f, 0.01129543f, -0.03223505f, 0.02533171f, 
    -0.11151315f, -0.38580048f, 0.07128367f, -0.19397034f, -0.09551241f, -0.02351677f, -0.07124633f, 0.21397008f, 
    0.23778902f, -0.18675666f, -0.11141907f, -0.12256266f, 0.04115811f, -0.03985060f, -0.03721471f, 0.01647112f, 
    -0.01775961f, 0.08472338f, 0.09113432f, 0.10061164f, -0.05274756f, 0.11181010f, 0.26015803f, 0.03603885f, 
    -0.05906814f, 0.18878743f, 0.35155267f, -0.39026776f, -0.12713426f, -0.22145079f, -0.19268300f, -0.07775819f, 
    -0.04735225f, -0.12015836f, 0.10630015f, 0.10620271f, -0.00883434f, 0.06789463f, 0.19150054f, -0.01022785f, 
    0.07387996f, 0.22116606f, 0.07718602f, 0.14164406f, -0.03953573f, 0.11464878f, 0.10310372f, 0.13448542f, 
    0.03977891f, 0.06480045f, -0.06557728f, 0.04910713f, -0.13675925f, -0.31113595f, 0.06625474f, -0.07656378f, 
    -0.16436173f, -0.09398723f, -0.04769088f, -0.06018069f, -0.00689407f, -0.05833262f, -0.00695604f, 0.07496379f, 
    -0.12963295f, 0.15423580f, -0.08304249f, 0.03619042f, -0.17860073f, -0.03579912f, -0.21039848f, -0.13397378f, 
    -0.18143369f, -0.05939987f, -0.19394135f, -0.08420513f, -0.09600112f, -0.06136922f, -0.12845260f, 0.12894353f, 
    0.07080649f, 0.06620596f, 0.09630370f, 0.40169549f, -0.02135923f, 0.09365749f, -0.01933630f, 0.15043969f, 
    0.01959133f, 0.06051168f, -0.04107374f, 0.05448668f, 0.11129621f, 0.05451020f, 0.00762002f, 0.07788449f, 
    -0.04970903f, 0.09054270f, 0.10455407f, 0.25842226f, -0.15061747f, -0.07229922f, -0.16432656f, -0.05256770f, 
    -0.00308353f, 0.14754331f, -0.07992172f, -0.12245028f, -0.12364440f, 0.08188026f, -0.08433344f, 0.06904917f, 
    0.06676482f, 0.10700841f, 0.16280329f, 0.19738404f, 0.17757982f, -0.33838060f, -0.09017455f, 0.18629618f, 
    -0.00198869f, -0.01915528f, -0.17555724f, 0.06302384f, -0.06387607f, 0.07116937f, 0.06353100f, 0.06926693f, 
    -0.06472974f, -0.15043688f, 0.12085444f, -0.01028977f, -0.10521404f, 0.01666539f, -0.17841490f, -0.32402599f, 
    -0.15649806f, 0.02843445f, 0.00534584f, 0.03651924f, 0.02434769f, 0.10921622f, 0.02100139f, 0.07717052f, 
    0.00860510f, -0.16343337f, 0.08465562f, 0.01126703f, 0.15912385f, 0.03413728f, 0.02482141f, -0.09329189f, 
    -0.11376864f, 0.05304113f, 0.25952229f, 0.01013272f, 0.08114466f, -0.05020920f, 0.21253827f, 0.07902274f, 
    0.02012901f, 0.01636487f, -0.32300785f, -0.10868758f, 0.00662235f, -0.08317627f, 0.04262883f, 0.05646366f, 
    0.00059573f, -0.01883388f, 0.15280107f, -0.17887180f, 0.15985133f, -0.15183368f, -0.05538946f, 0.05878328f, 
    0.05601675f, 0.04118046f, -0.02318950f, -0.11217039f, -0.10325687f, 0.00511902f, 0.01047560f, -0.07041907f, 
    0.13646823f, -0.01235397f, -0.12982416f, 0.00410401f, -0.05140435f, 0.16194242f, 0.25391534f, 0.19860023f, 
    0.12769480f, 0.15093750f, -0.15069330f, -0.08575752f, -0.30417415f, -0.29027697f, -0.12457196f, -0.05903265f, 
    -0.07416855f, 0.09279736f, -0.00163986f, 0.10627263f, 0.05403042f, -0.06560897f, 0.01905300f, 0.18246536f, 
    -0.07686373f, -0.38250905f, -0.01823129f, 0.06594852f, 0.00183190f, 0.00463811f, 0.05409714f, 0.00529413f, 
    0.14020744f, 0.03115749f, 0.16619821f, -0.04767172f, 0.17129780f, 0.01781587f, -0.12117565f, 0.16546005f, 
    -0.03296915f, -0.14704557f, -0.11304202f, 0.08535621f, 0.01672731f, -0.01161075f, 0.11703645f, 0.10768054f, 
    -0.05794213f, -0.08534924f, 0.23352322f, 0.11910743f, -0.08906773f, -0.00273940f, 0.20865412f, 0.20452803f, 
    -0.07741614f, 0.10585494f, 0.01951243f, 0.18502386f, -0.16862500f, -0.24897684f, -0.00402663f, -0.02125864f, 
    0.00054213f, -0.00392989f, -0.04460218f, -0.12109356f, 0.20465377f, 0.01501772f, -0.11760797f, -0.13121106f, 
    0.12436870f, 0.12937818f, 0.07976061f, -0.05972458f, 0.05662869f, -0.07362013f, -0.15099768f, -0.10881097f, 
    -0.15981162f, 0.00381364f, 0.16976748f, 0.04610169f, 0.13078092f, 0.29420981f, 0.05899734f, -0.08383191f, 
    -0.23771948f, -0.28183740f, -0.01733881f, 0.15829268f, -0.03156144f, -0.01786449f, 0.08544280f, 0.00831120f, 
    0.20403761f, -0.11548050f, 0.01188011f, 0.13380396f, 0.13371791f, -0.00418104f, 0.04142277f, -0.04510654f, 
    0.03278023f, 0.27298740f, 0.32629910f, -0.00908775f, -0.16836964f, 0.01535745f, -0.10095228f, -0.08564827f, 
    -0.24776939f, 0.20645815f, 0.02606962f, 0.06553067f, 0.02395351f, -0.08305009f, -0.17095113f, 0.09400707f, 
    0.17455016f, 0.06695821f, -0.16891535f, -0.48133245f, 0.06508215f, 0.11133693f, -0.00913265f, -0.27311423f, 
    -0.01643841f, 0.17872362f, -0.01694885f, 0.15779673f, 0.14450090f, -0.05155307f, -0.19667336f, 0.19890256f, 
    0.06758408f, 0.24736650f, 0.03715462f, -0.04034910f, 0.01355296f, 0.21444377f, -0.22601488f, -0.05810467f, 
    0.25073093f, -0.06565638f, 0.12372269f, 0.18727461f, 0.10634594f, -0.01321454f, -0.00737511f, -0.13031614f, 
    0.03967037f, 0.02053333f, 0.10604712f, -0.03231818f, 0.06826542f, 0.08045728f, 0.07613298f, -0.18529348f, 
    0.17583156f, 0.00942891f, -0.00897060f, -0.03218711f, -0.11136439f, 0.06876966f, -0.21489885f, -0.01150727f, 
    0.17354338f, -0.01430223f, -0.09802022f, 0.25085717f, 0.01025478f, 0.30518794f, 0.08016283f, 0.05379720f, 
    0.13606639f, -0.01830403f, -0.07310236f, -0.11949056f, -0.13587491f, -0.11953825f, -0.07770754f, -0.09888372f, 
    0.12890418f, 0.12107293f, 0.05543787f, -0.05126562f, 0.13255517f, -0.05959894f, -0.01711943f, -0.05751359f, 
    -0.00238050f, -0.02715372f, 0.15470226f, -0.13674319f, 0.05679847f, -0.19727597f, 0.16554402f, -0.20088974f, 
    -0.01014168f, 0.08784807f, 0.00724465f, -0.08406352f, -0.20994961f, -0.02486746f, -0.11426698f, 0.37575558f, 
    -0.19922012f, 0.33958077f, 0.17362039f, 0.00124001f, 0.21414649f, 0.10283659f, -0.10008929f, -0.26776868f, 
    -0.05752041f, 0.08753186f, 0.23087403f, -0.03297824f, -0.10747761f, -0.04731876f, 0.25518420f, -0.17498308f, 
    0.11756864f, 0.16784620f, -0.19332303f, -0.06278072f, 0.02890269f, 0.19098496f, -0.02763203f, 0.27634797f, 
    0.07912031f, 0.08279479f, -0.06952552f, 0.06674054f, 0.12885292f, -0.08391852f, 0.09592845f, 0.06015220f, 
    0.26519442f, -0.01086843f, -0.01682707f, -0.22099884f, 0.08988227f, -0.22705984f, -0.05954173f, -0.00179649f, 
    0.09614709f, 0.08498153f, -0.04867729f, -0.07376125f, -0.10067067f, 0.11905577f, -0.01553656f, -0.01485462f, 
    -0.01894578f, 0.20541166f, -0.07142892f, 0.01247334f, 0.04681899f, 0.04874104f, -0.00162789f, -0.10740013f, 
    -0.03839613f, -0.08713327f, 0.05243647f, 0.03673479f, 0.00253583f, -0.08519444f, -0.14189875f, -0.21017185f, 
    -0.06999052f, 0.11979339f, -0.07574329f, -0.05963881f, 0.11363588f, 0.10457432f, 0.00894420f, 0.00934201f, 
    -0.12242860f, -0.01550788f, -0.02968146f, 0.05745414f, 0.06000456f, -0.18071704f, 0.01747010f, 0.04164871f, 
    -0.22786309f, 0.03054671f, -0.29820338f, -0.15338898f, -0.03654718f, -0.19050594f, 0.23735276f, -0.23346698f, 
    -0.30599096f, 0.12960479f, -0.12708704f, 0.01735603f, 0.07208931f, 0.03109943f, 0.04361397f, 0.12226331f, 
    -0.24625459f, -0.32603747f, 0.11024198f, -0.09412631f, 0.09301385f, 0.18454391f, 0.19986328f, -0.21679002f, 
    -0.05177239f, 0.39827693f, 0.02057401f, -0.04614748f, 0.01445379f, 0.07009351f, -0.09135097f, 0.07693797f, 
    0.20021775f, 0.25791994f, -0.20606646f, 0.16090257f, -0.18983558f, 0.10706978f, 0.06043683f, -0.06035602f, 
    0.03518806f, 0.00685375f, 0.14053956f, -0.12824623f, -0.28254461f, 0.02738863f, -0.11758764f, 0.04852505f, 
    0.05821807f, 0.16702913f, 0.21619147f, 0.27207443f, 0.24784927f, -0.11745093f, 0.09094539f, 0.06271787f, 
    -0.05698596f, 0.12002918f, 0.09264004f, -0.12611766f, 0.07303177f, 0.17495109f, -0.04274773f, -0.10037643f, 
    0.05417982f, -0.01301590f, -0.08878259f, 0.02638403f, 0.03964659f, -0.33877596f, 0.24798116f, 0.02074799f, 
    0.15447988f, -0.00853998f, -0.05892186f, 0.07961163f, 0.09782076f, -0.23213746f, 0.44352415f, -0.37309009f, 
    -0.09147234f, -0.11055854f, -0.21449812f, -0.05783729f, 0.14091115f, -0.32051238f, -0.01679045f, -0.40964496f, 
    -0.16138628f, 0.08826551f, 0.09170837f, 0.07907858f, -0.10405323f, -0.08788622f, -0.15614313f, 0.27537319f, 
    0.04663705f, 0.20820184f, -0.03592211f, 0.03882111f, -0.18767346f, -0.06041643f, 0.04732038f, -0.09924756f, 
    0.37193421f, -0.28408289f, -0.21215457f, -0.01512953f, 0.18134946f, -0.08828128f, 0.07446806f, 0.02864709f, 
    0.03020441f, -0.07217433f, 0.12950115f, 0.06358226f, -0.11693646f, 0.04117363f, -0.01215709f, 0.03340904f, 
    -0.01959885f, 0.09583691f, 0.33503333f, -0.06170059f, -0.33348912f, 0.08064418f, 0.11549622f, 0.17034224f, 
    0.02804415f, 0.06574751f, -0.11380853f, 0.23005824f, -0.31245875f, -0.38010937f, -0.06896335f, -0.08051274f, 
    0.15132508f, -0.21245585f, -0.01771337f, -0.08221414f, 0.44619745f, 0.24510927f, -0.13300920f, 0.13933168f, 
    0.06423056f, 0.15680768f, 0.20217690f, 0.09023229f, 0.15030746f, 0.16068076f, 0.03613782f, 0.26749247f, 
    -0.09485501f, -0.01731978f, 0.04655214f, 0.11761606f, 0.10705081f, 0.16056222f, -0.06427912f, 0.20239112f, 
    0.02282707f, -0.07249832f, -0.06642667f, -0.03161930f, 0.05133000f, 0.04006445f, 0.08546825f, 0.08091488f, 
    -0.20155054f, -0.12406516f, 0.01536161f, -0.04895259f, 0.01504548f, 0.21280521f, -0.05464975f, 0.03335705f, 
    -0.10347726f, -0.11139900f, 0.04105853f, -0.02432903f, -0.03551706f, -0.06179960f, -0.23863108f, -0.09186733f, 
    0.07800011f, -0.21707726f, 0.07169060f, -0.19139627f, -0.04588472f, 0.00433903f, 0.05325308f, 0.16793682f, 
    0.01182225f, 0.16730352f, 0.11749129f, 0.08795079f, 0.11142226f, -0.07748117f, 0.04758869f, 0.00153651f, 
    0.05674607f, 0.02513430f, -0.01729468f, 0.07414164f, -0.21402270f, -0.66489357f, -0.09155751f, -0.14455867f, 
    0.04798570f, 0.05604063f, -0.00570886f, 0.18077716f, -0.51689410f, -0.28593925f, 0.03987784f, 0.05513735f, 
    0.08418048f, 0.04579622f, -0.09653305f, 0.05961963f, 0.07680950f, -0.01438740f, 0.08486914f, 0.03066751f, 
    -0.14799921f, 0.03581946f, -0.18892288f, -0.10219528f, -0.07049473f, 0.16094369f, -0.40167940f, -0.30005258f, 
    -0.09986193f, -0.02887173f, -0.00291408f, -0.00719723f, 0.00476287f, 0.10992122f, 0.10843004f, 0.15746681f, 
    -0.28333563f, -0.13925993f, 0.01520550f, -0.02799293f, -0.09908990f, 0.08606755f, 0.07466289f, -0.05902717f, 
    -0.03035861f, 0.08959465f, 0.11063037f, -0.03333048f, -0.09520804f, -0.07432863f, 0.14035526f, -0.02443120f, 
    0.16165233f, -0.06601422f, -0.06967566f, -0.11553745f, -0.11843968f, -0.06341244f, -0.00465300f, 0.18262975f, 
    0.06523824f, -0.02617799f, 0.14748488f, -0.21809632f, -0.06844930f, 0.10240729f, 0.05156810f, 0.07984723f, 
    -0.03328699f, 0.03256552f, -0.01870855f, -0.07640595f, -0.04704354f, 0.57810873f, 0.08405183f, -0.00288800f, 
    -0.03030149f, -0.05753170f, 0.02685320f, -0.01048920f, -0.19708221f, 0.16456372f, 0.46210760f, -0.15315495f, 
    -0.24533772f, -0.21270707f, -0.00670585f, 0.05113070f, -0.01762912f, -0.16710921f, -0.26042423f, 0.00359909f, 
    -0.01220086f, -0.00436469f, -0.00806446f, -0.01882748f, -0.07505365f, -0.00287642f, 0.03553921f, 0.07944203f, 
    0.12931585f, 0.22206785f, -0.03099971f, -0.01314694f, -0.03338225f, 0.11973467f, 0.07569332f, -0.06943403f, 
    -0.14754334f, -0.65811521f, -0.13644992f, 0.00656417f, 0.03102168f, 0.12725845f, 0.01050391f, -0.00470771f, 
    -0.14646554f, 0.07045398f, 0.01807291f, -0.08810088f, -0.01673481f, -0.10100410f, 0.09423023f, -0.06218622f, 
    0.15665117f, 0.12338697f, 0.15348740f, 0.09976403f, 0.09023475f, -0.16704845f, -0.07223132f, 0.02278523f, 
    0.00554029f, 0.11212882f, -0.42919737f, -0.28403136f, -0.40693450f, -0.01114624f, 0.01615898f, -0.11583377f, 
    0.07343453f, 0.13442528f, -0.01207459f, -0.03750083f, 0.19679631f, -0.00259889f, -0.04657165f, -0.01822919f, 
    -0.05404520f, -0.11440424f, 0.04380079f, 0.22175963f, -0.28263509f, 0.18471903f, 0.40032887f, 0.07844444f, 
    0.03768257f, -0.02122476f, -0.04027263f, 0.05854589f, -0.04168888f, 0.39524823f, -0.35296941f, -0.48782942f, 
    0.01427962f, 0.17123969f, -0.02637739f, 0.00863138f, 0.02947703f, -0.21258833f, -0.47059819f, 0.04069299f, 
    0.32423317f, -0.16037679f, 0.03758055f, -0.20337029f, -0.11967983f, 0.07306717f, -0.02572212f, -0.54991424f, 
    -0.54286849f, -0.51311302f, -0.15609486f, -0.01175023f, -0.01188390f, -0.01049581f, -0.01907945f, 0.06286692f, 
    -0.64272159f, 0.09488326f, -0.05311359f, 0.07890079f, -0.05929969f, -0.23453070f, 0.17520364f, 0.02221360f, 
    0.07879245f, 0.17771272f, 0.04800905f, -0.21859363f, 0.05370860f, -0.14950666f, -0.01000529f, 0.10600810f, 
    -0.06602570f, 0.12501837f, 0.30014300f, -0.11884100f, -0.08978336f, 0.03695019f, 0.06378965f, 0.11509884f, 
    0.06893598f, 0.09246878f, 0.04987784f, 0.25709936f, 0.14650325f, 0.06742164f, -0.23562571f, -0.02163865f, 
    -0.06786958f, -0.17171355f, 0.13399521f, 0.17475159f, -0.06212620f, 0.38223130f, 0.09869790f, 0.17873622f, 
    -0.07090864f, -0.05830642f, 0.10105155f, 0.18564591f, 0.14466909f, -0.01562493f, -0.13933136f, 0.02207277f, 
    0.04800533f, 0.07763606f, 0.15041882f, 0.05702522f, 0.03025348f, 0.05786236f, -0.51069129f, -0.49621677f, 
    -0.03168494f, -0.08866639f, 0.11926477f, 0.02370240f, 0.05762496f, 0.03071855f, -0.01883357f, -0.47629714f, 
    0.20942898f, 0.09229064f, 0.01054658f, 0.11808508f, -0.01453320f, 0.06612957f, 0.02518917f, -0.00734941f, 
    -0.14979006f, 0.06278680f, 0.06688349f, 0.04489666f, -0.10820051f, -0.20400429f, -0.09443107f, -0.04046165f, 
    0.10714250f, 0.23992369f, 0.08176285f, 0.09153151f, 0.05010995f, 0.13630947f, 0.14816514f, 0.09807631f, 
    0.12226691f, -0.01653322f, -0.10020823f, 0.04900174f, 0.01146167f, 0.18592244f, 0.12803023f, 0.17181939f, 
    0.04413229f, -0.14319819f, 0.03096937f, -0.15666062f, 0.35604593f, -0.68368709f, -0.08447197f, 0.32444775f, 
    0.03631078f, 0.05091097f, 0.10485192f, 0.15790768f, 0.15660095f, 0.13099718f, 0.12725344f, -0.23530501f, 
    0.04225850f, -0.36185262f, 0.07614531f, -0.09578481f, 0.04693104f, -0.08386941f, 0.14644891f, -0.02657548f, 
    -0.06063911f, -0.08895004f, -0.09378478f, -0.02665478f, 0.21439099f, 0.26966342f, -0.02564774f, 0.05240225f, 
    -0.11470453f, -0.04524665f, -0.03744815f, -0.05210399f, 0.20636141f, 0.23774104f, 0.17532764f, 0.12654030f, 
    0.07395129f, -0.22306083f, -0.23008387f, -0.36653987f, -0.12752032f, -0.23595011f, -0.03298362f, -0.02523953f, 
    0.05989099f, 0.10170028f, -0.18475343f, 0.10076976f, -0.01632130f, 0.03565050f, -0.12823732f, -0.03122832f, 
    0.12376472f, 0.22402546f, 0.02284565f, -0.01491114f, -0.05307482f, 0.04485446f, 0.14557502f, 0.05079491f, 
    0.05556269f, 0.20399839f, 0.25310251f, 0.03720628f, 0.07260524f, -0.15362440f, -0.23795930f, -0.11504910f, 
    -0.10666517f, -0.02536162f, -0.03613131f, -0.16562600f, 0.14955430f, 0.25435930f, -0.03706463f, 0.13870388f, 
    -0.03888733f, -0.00860757f, -0.00476630f, 0.01862360f, -0.37156188f, 0.13935351f, -0.36368206f, -0.28703901f, 
    -0.31025079f, -0.30726796f, -0.03375327f, -0.07779814f, 0.02853706f, -0.38457888f, -0.03018209f, 0.39016867f, 
    -0.08711977f, 0.13384576f, 0.01327428f, -0.09533593f, -0.09234547f, 0.22757304f, -0.17543089f, 0.04823694f, 
    0.28690830f, 0.04516762f, 0.10148811f, -0.10981721f, -0.01870192f, -0.02147222f, 0.05459204f, -0.15908626f, 
    -0.44984886f, -0.05144319f, -0.17036693f, 0.02593346f, -0.04188546f, 0.02954687f, -0.01034867f, 0.04666026f, 
    0.14079459f, -0.03300053f, -0.29872844f, 0.13516226f, -0.01524995f, 0.07273360f, 0.11031371f, 0.22500987f, 
    -0.02857293f, -0.30694729f, 0.02529283f, 0.06217776f, -0.05516633f, 0.16635588f, 0.00264499f, 0.00844094f, 
    0.03047051f, 0.11313863f, -0.35962814f, 0.11266310f, 0.29204664f, 0.04845383f, -0.07720813f, -0.18361107f, 
    0.19915976f, 0.02761145f, 0.04805972f, -0.29378200f, -0.32115787f, -0.37364182f, -0.42703122f, -0.11739614f, 
    -0.16253720f, 0.00174038f, -0.12434526f, 0.00218577f, -0.16704324f, -0.10216743f, 0.35704571f, 0.00200361f, 
    0.26559296f, -0.12432195f, 0.02650166f, 0.13126454f, -0.01676832f, 0.16857089f, 0.00609889f, 0.05276076f, 
    -0.07777166f, -0.20950823f, -0.09196631f, -0.01945087f, 0.14312308f, -0.07565505f, -0.69380224f, -0.48057309f, 
    -0.07181320f, -0.04921249f, 0.10897572f, -0.02204777f, -0.09670559f, 0.02365921f, 0.00305910f, -0.29919186f, 
    -0.23074432f, -0.31925681f, -0.07065593f, 0.06013990f, 0.01356859f, -0.03933143f, 0.05100446f, 0.10398202f, 
    -0.04893448f, 0.04114271f, -0.02679433f, -0.03775844f, -0.05751563f, 0.04122406f, 0.02398854f, 0.01411202f, 
    0.01062955f, -0.00430251f, -0.04011029f, 0.00270661f, 0.00141950f, 0.01025861f, 0.04832792f, 0.00701455f, 
    -0.04286766f, -0.03402555f, -0.03521116f, -0.01322498f, 0.05556925f, 0.03537548f, -0.04899754f, -0.01725519f, 
    -0.04705326f, -0.01938941f, 0.04606396f, -0.04506335f, -0.04345981f, 0.05208006f, -0.04722656f, -0.01299115f, 
    -0.03343471f, 0.02271872f, 0.00387105f, -0.01433396f, -0.01275458f, 0.04145686f, 0.04877526f, -0.04376012f, 
    -0.02178704f, 0.04739903f, -0.04373400f, -0.03138122f, 0.01062553f, -0.00412552f, -0.02128582f, -0.04851940f, 
    0.00131067f, 0.01817790f, -0.05221032f, 0.01400757f, -0.03543029f, -0.05631899f, 0.03570045f, 0.05619410f, 
    -0.03756243f, -0.01213165f, 0.00860758f, -0.01043571f, -0.00855026f, -0.00363005f, 0.02333970f, -0.01739248f, 
    -0.04780496f, -0.02005981f, -0.00350868f, 0.04200477f, -0.03813469f, 0.01326798f, 0.02698306f, -0.02385013f, 
    -0.02527506f, -0.00296158f, -0.04967246f, 0.05680113f, -0.03896751f, -0.04166798f, 0.04492804f, -0.02005763f, 
    -0.05810569f, 0.00597569f, -0.02679681f, -0.04910908f, 0.01065944f, -0.03131264f, -0.02824102f, 0.05290791f, 
    -0.04529485f, 0.02323982f, -0.03137427f, 0.05344751f, -0.03765678f, 0.03130009f, -0.03018087f, -0.00938692f, 
    -0.03704537f, -0.05584684f, 0.03731185f, -0.05592637f, 0.05743022f, 0.01463343f, 0.01307398f, 0.04536242f, 
    0.05651830f, 0.03112576f, 0.02501994f, -0.05506171f, -0.03579764f, -0.02288168f, -0.05725715f, 0.01568675f, 
    0.01513046f, 0.00827130f, -0.05019108f, -0.05664651f, 0.00471401f, -0.02720923f, -0.02557515f, -0.03512665f, 
    -0.02906204f, -0.02544211f, -0.04413652f, 0.05735102f, 0.04334245f, -0.02094827f, -0.04999928f, 0.03889709f, 
    0.05028403f, -0.03086092f, -0.00100529f, -0.05339804f, -0.04432411f, -0.03008257f, -0.02298499f, 0.00324265f, 
    0.04021597f, 0.03315792f, 0.05264423f, 0.04759390f, -0.03031389f, 0.01818478f, 0.03509696f, -0.05620549f, 
    0.00848568f, 0.01831752f, 0.04857764f, -0.02911888f, 0.02577204f, -0.04493112f, -0.00342848f, -0.00382206f, 
    -0.01250888f, 0.01931355f, -0.00268445f, 0.05567481f, 0.02739578f, -0.04663114f, -0.05385746f, -0.02795639f, 
    -0.04806626f, 0.00801419f, -0.01695551f, 0.00146487f, -0.01985875f, -0.03055799f, -0.03424252f, -0.00609648f, 
    -0.04732981f, -0.02559461f, -0.05435128f, -0.01077276f, -0.04973197f, -0.04544671f, -0.02401862f, 0.02092579f, 
    0.00974958f, 0.04340184f, -0.04873669f, -0.00567039f, -0.04891424f, -0.04336653f, 0.05203342f, 0.04743148f, 
    -0.02938351f, 0.00915616f, -0.01290456f, -0.02869142f, 0.02324602f, 0.01569109f, 0.00586146f, 0.00744202f, 
    0.05025644f, -0.03246355f, 0.01914016f, -0.00066245f, 0.03548986f, 0.02139706f, -0.00519564f, -0.02689786f, 
    -0.02721820f, 0.05851453f, -0.01256067f, 0.02838909f, -0.02517274f, -0.04962532f, 0.03266587f, -0.01768450f, 
    -0.03661156f, -0.02085699f, 0.03730895f, -0.01927504f, 0.03466921f, -0.05502214f, -0.05375983f, -0.01411263f, 
    0.01751516f, -0.05839251f, 0.02405355f, 0.01029651f, -0.04671720f, 0.04576905f, 0.00019557f, 0.04797759f, 
    -0.04047848f, 0.03174981f, 0.03900501f, -0.03797069f, 0.02637334f, -0.02287841f, 0.01407304f, -0.04417159f, 
    0.05232773f, -0.05043489f, -0.01241745f, 0.00765387f, 0.05072984f, -0.03230622f, 0.05087182f, -0.00514759f, 
    -0.00499778f, -0.02450859f, 0.01880968f, -0.01670329f, -0.00115158f, 0.04252575f, -0.04005339f, 0.05015701f, 
    0.01285605f, 0.05626139f, -0.05125705f, 0.03378131f, -0.04350185f, -0.04952655f, -0.02441681f, 0.03361389f, 
    -0.03279240f, 0.00995775f, -0.03600587f, -0.00893885f, 0.01282924f, 0.01593252f, -0.03475751f, -0.02939238f, 
    0.00098295f, 0.04661085f, -0.02882940f, -0.03599254f, -0.01642965f, 0.01909585f, -0.03375638f, 0.00291655f, 
    0.02133348f, -0.00875580f, 0.05105149f, -0.02462769f, -0.04592274f, -0.04898518f, -0.00565061f, -0.05475666f, 
    0.00937002f, -0.02157400f, 0.00442768f, 0.01231820f, -0.01344257f, 0.03259634f, -0.05351494f, 0.00300702f, 
    0.10503772f, -0.30398950f, -0.06734648f, -0.05094600f, 0.14378317f, -0.20236272f, 0.28502622f, 0.03092296f, 
    -0.04194473f, -0.17792395f, 0.10570310f, -0.04283028f, 0.10112417f, 0.04321991f, 0.06516170f, 0.06055244f, 
    0.20429538f, 0.09212770f, 0.33577663f, -0.23872346f, -0.08487014f, 0.02886358f, -0.13252084f, -0.00690500f, 
    0.15109856f, 0.05012787f, 0.24798578f, -0.08112077f, -0.29863051f, -0.26133752f, -0.00527973f, -0.00726961f, 
    0.06142295f, -0.05163089f, -0.02850924f, -0.10497712f, 0.12450510f, 0.18433179f, -0.01342511f, -0.01393161f, 
    0.13002221f, 0.06708230f, 0.21036214f, 0.16786630f, -0.03149301f, 0.18762831f, 0.04507432f, 0.34770221f, 
    -0.10084272f, 0.08070414f, -0.06506124f, -0.04201858f, -0.03553879f, 0.14279091f, -0.06788303f, 0.01568670f, 
    0.02985457f, 0.01684810f, -0.05975768f, -0.02862396f, 0.11688263f, 0.05369754f, -0.10595205f, 0.01811374f, 
    -0.12140328f, 0.02656608f, -0.11052196f, 0.08887225f, 0.00775630f, 0.04961282f, 0.17684811f, -0.05742792f, 
    -0.26289785f, -0.23434278f, -0.11964051f, -0.02933780f, -0.19299546f, -0.06329282f, -0.11052707f, 0.04567537f, 
    0.04398977f, 0.05113852f, 0.12187342f, -0.14236507f, 0.20899469f, -0.05109191f, 0.03089241f, 0.07789227f, 
    0.18965796f, -0.02054309f, 0.14315243f, 0.06646756f, 0.11697447f, 0.04127339f, -0.02743392f, 0.12683442f, 
    -0.03910289f, 0.07585105f, 0.33380312f, -0.35288358f, -0.29047903f, 0.02279987f, 0.00330181f, 0.01874897f, 
    -0.09546329f, 0.05652377f, 0.02029181f, -0.19674748f, -0.30163917f, -0.18043464f, 0.03958681f, 0.05165217f, 
    -0.25043577f, -0.05556833f, 0.22401135f, -0.02039015f, -0.28935531f, 0.03210172f, -0.08925314f, -0.17113562f, 
    -0.30578899f, 0.14108868f, -0.02935853f, 0.08428693f, -0.25326383f, 0.18755564f, -0.47287765f, 0.11047279f, 
    -0.00468822f, -0.05302459f, 0.12908691f, -0.13681975f, 0.18164700f, -0.02469954f, 0.01246991f, -0.04502790f, 
    -0.08585896f, -0.11691973f, -0.18272905f, -0.02898997f, -0.08324105f, 0.04089406f, 0.12604681f, 0.09107902f, 
    0.04625191f, 0.00951413f, -0.01683433f, -0.05780283f, 0.00410511f, -0.16331586f, 0.08765245f, -0.00355104f, 
    0.10802656f, 0.09388246f, -0.04953947f, -0.12308171f, 0.05677604f, -0.10225166f, 0.07695485f, -0.12421522f, 
    0.10940278f, 0.14297843f, -0.04954882f, -0.04958082f, -0.06758915f, 0.06766145f, 0.00438310f, 0.16392101f, 
    0.04242921f, 0.02727834f, -0.04911581f, -0.09009845f, -0.06759543f, 0.24302618f, 0.08375387f, -0.26402658f, 
    -0.12243523f, -0.19227660f, -0.05935929f, 0.07811094f, -0.23068382f, -0.41931254f, -0.15559651f, -0.19960240f, 
    -0.06169009f, -0.36719730f, 0.10551766f, -0.13822347f, 0.02796241f, -0.04718277f, -0.25852728f, -0.10062869f, 
    -0.21961057f, -0.12118815f, 0.01571158f, -0.00153312f, 0.03697535f, 0.11212172f, -0.00348758f, 0.17714806f, 
    0.12840021f, -0.00576990f, 0.02487316f, 0.03483288f, 0.03975664f, 0.04407087f, 0.25138298f, -0.11797291f, 
    -0.23223047f, -0.12410165f, 0.26628762f, -0.00639478f, 0.08748798f, -0.02796591f, 0.01989849f, 0.07294448f, 
    -0.23095237f, 0.00081165f, 0.07379874f, 0.06554037f, 0.16936326f, -0.11992561f, 0.21965575f, 0.06814779f, 
    0.03610417f, -0.02129996f, 0.10747313f, 0.12351197f, 0.03622520f, 0.02549909f, 0.04467578f, -0.00517682f, 
    -0.07348385f, 0.25496998f, -0.02417556f, -0.33597755f, -0.13872613f, 0.12352675f, 0.07839159f, -0.00215629f, 
    0.07131585f, 0.01967599f, 0.15376672f, -0.18232931f, -0.00262145f, 0.14362001f, -0.04570765f, -0.03617861f, 
    0.04898526f, -0.02199831f, -0.06284734f, 0.06334022f, -0.14227021f, 0.01813170f, 0.01587802f, -0.00397124f, 
    0.02268350f, 0.07520829f, -0.00609397f, 0.02703051f, 0.16916625f, 0.11846151f, -0.14408651f, -0.23814327f, 
    0.15341787f, -0.03714206f, -0.18652581f, 0.14994381f, -0.01483881f, 0.04600783f, -0.24156937f, -0.10713661f, 
    0.01125545f, -0.08313315f, 0.00044592f, -0.18869115f, 0.00879529f, -0.04689816f, 0.11949366f, -0.22401074f, 
    -0.31437111f, -0.13249479f, 0.10748406f, -0.02843026f, 0.03301598f, -0.03439738f, -0.06422918f, 0.06499159f, 
    -0.46218938f, -0.31864455f, -0.15130687f, -0.11980304f, -0.18344983f, -0.04175698f, -0.13884349f, -0.17066631f, 
    0.19138031f, 0.05475971f, 0.01672197f, -0.11291202f, -0.16054748f, -0.10628975f, -0.03504997f, -0.00911633f, 
    0.02117318f, 0.08277230f, -0.43115702f, -0.29308081f, -0.41261578f, 0.09477752f, 0.25903916f, 0.08633171f, 
    -0.13402641f, 0.04213148f, -0.03628176f, -0.60176730f, 0.08760139f, -0.34701127f, -0.07727435f, 0.14572349f, 
    -0.16454153f, 0.00327088f, -0.07401144f, -0.01137577f, 0.26677793f, 0.20509297f, 0.07087895f, 0.09217913f, 
    0.05385264f, 0.13986437f, -0.03674342f, 0.19498551f, 0.09371784f, 0.23194522f, 0.26216286f, 0.25928739f, 
    0.04306897f, 0.14222282f, -0.04956253f, 0.21734908f, 0.13127913f, -0.05408233f, 0.11668015f, 0.25294271f, 
    0.12541661f, -0.06838237f, -0.05192965f, -0.14759970f, 0.09908329f, 0.18019082f, -0.17591029f, 0.17628025f, 
    0.16988482f, 0.09513247f, 0.09956347f, 0.08121938f, -0.05213377f, 0.02974060f, 0.00771552f, -0.11947544f, 
    -0.23061916f, -0.18022653f, 0.06771217f, -0.19566695f, -0.05456449f, 0.00790133f, 0.18009041f, -0.08260962f, 
    -0.05411776f, -0.28014061f, 0.17894058f, 0.00039463f, 0.21509023f, 0.08141138f, -0.02555949f, 0.08440065f, 
    -0.02952647f, -0.02963182f, 0.09270974f, 0.02960023f, 0.17864241f, 0.06338071f, 0.00627332f, -0.07435576f, 
    0.06393167f, 0.11989623f, -0.06184486f, 0.55215371f, 0.12266976f, -0.14342146f, 0.02168847f, -0.13495657f, 
    -0.00800877f, -0.17611347f, 0.11073214f, 0.00361703f, -0.20791501f, 0.27608535f, -0.00416910f, -0.12046840f, 
    0.13520432f, 0.00124043f, 0.09746034f, 0.02478249f, -0.09542500f, -0.13270430f, -0.15758689f, 0.23035400f, 
    -0.15019330f, 0.06903972f, -0.21999860f, 0.10544074f, -0.04296232f, 0.13298115f, 0.25211984f, -0.11353988f, 
    -0.05060217f, -0.21627140f, -0.17377487f, -0.02937942f, 0.08473682f, 0.10692434f, 0.01923685f, -0.78765035f, 
    0.13957895f, 0.01471746f, -0.15589285f, -0.01296779f, 0.05477300f, 0.07531539f, 0.00254192f, -0.06868075f, 
    -0.02805201f, -0.11755025f, 0.36059785f, -0.02929199f, -0.21430716f, 0.10020735f, -0.03705408f, 0.08568314f, 
    -0.00982163f, -0.27781385f, -0.03894485f, 0.14670171f, 0.13425966f, 0.09967369f, -0.11835722f, 0.20944732f, 
    0.05807807f, 0.17127992f, -0.22050099f, 0.16049974f, 0.04650385f, -0.03889321f, -0.04482507f, -0.00302816f, 
    0.11063034f, 0.14361693f, 0.11846392f, 0.26921025f, 0.07950468f, 0.28207251f, -0.10594881f, 0.01991302f, 
    0.10774694f, 0.11320814f, 0.09354793f, 0.07910205f, 0.20576285f, 0.25308284f, 0.39136988f, -0.25722227f, 
    -0.09762460f, -0.19583932f, -0.04413318f, -0.02502813f, 0.04750108f, -0.01221591f, 0.20857054f, 0.32609344f, 
    0.09082215f, 0.08537891f, -0.07609915f, 0.29018375f, -0.00306552f, -0.01704109f, -0.03289696f, 0.08849603f, 
    -0.07602707f, 0.04703217f, -0.03929051f, 0.06989532f, 0.09114565f, -0.08438301f, 0.03952039f, -0.28225788f, 
    -0.01837544f, -0.03173907f, -0.04047650f, -0.07770452f, -0.06596938f, -0.10038363f, 0.06196642f, 0.00759914f, 
    0.10370743f, 0.01894179f, 0.05748946f, -0.20805983f, -0.19352394f, -0.01586081f, 0.02153331f, -0.03008657f, 
    0.08620650f, 0.34684643f, 0.23707932f, -0.08746387f, -0.09756814f, -0.14678924f, -0.00744298f, 0.03915507f, 
    -0.19986066f, 0.02561840f, 0.04742765f, 0.07018071f, 0.08232597f, -0.05163770f, 0.03757600f, 0.12069819f, 
    -0.05367669f, -0.05423440f, 0.25056246f, 0.10680743f, 0.11900447f, 0.05475293f, -0.06145212f, -0.14705838f, 
    -0.07176353f, 0.10883432f, 0.00214960f, -0.09018055f, -0.22918114f, -0.16056912f, 0.02155156f, 0.03310311f, 
    0.06344790f, -0.06200322f, -0.00395971f, -0.09392904f, -0.03675972f, -0.46308458f, -0.06438186f, -0.07994855f, 
    -0.03588077f, -0.24155803f, -0.12336941f, -0.06772753f, 0.02941800f, -0.18566990f, -0.00364113f, -0.17998107f, 
    -0.09902722f, 0.06094668f, -0.06865112f, -0.01164833f, -0.04425801f, -0.09962530f, 0.14197977f, -0.41796368f, 
    -0.04831853f, -0.04259374f, -0.09485900f, 0.02511061f, -0.08678797f, 0.03407253f, 0.25562122f, -0.12860389f, 
    -0.24822716f, 0.08833100f, -0.42109585f, -0.15435109f, 0.05555149f, -0.09250762f, -0.00393893f, 0.04357053f, 
    0.22948146f, -0.07612225f, -0.02907068f, 0.22766089f, -0.06057765f, -0.11189692f, 0.01686607f, -0.00968059f, 
    0.06750914f, -0.05233464f, -0.28292477f, 0.20266929f, 0.08571904f, -0.04994200f, 0.03998498f, -0.01668794f, 
    -0.01019955f, 0.05189852f, 0.13706273f, -0.23077653f, -0.39689246f, -0.21447067f, -0.04693815f, 0.33746356f, 
    -0.01592883f, -0.06406914f, 0.06442585f, 0.12751485f, 0.03510588f, -0.05375149f, -0.01651045f, 0.14126866f, 
    0.11738043f, 0.05648706f, 0.05087914f, 0.00701786f, 0.19716343f, 0.04968604f, -0.24024102f, -0.25835872f, 
    0.04408827f, 0.04797015f, -0.11148874f, -0.01572059f, -0.06060044f, 0.01464382f, 0.00657341f, 0.14661905f, 
    0.00755541f, 0.02841348f, -0.02542429f, 0.06823745f, 0.13090789f, -0.08958495f, -0.00650679f, 0.18327264f, 
    -0.15251017f, -0.05216881f, 0.04612019f, -0.06868648f, -0.11846761f, 0.13306925f, -0.01202228f, -0.06712450f, 
    -0.47515446f, 0.02456687f, 0.49447900f, -0.21177652f, -0.01051443f, 0.00561015f, -0.00790029f, -0.04892952f, 
    -0.00163429f, 0.18413691f, -0.02940054f, 0.10559869f, -0.09167201f, 0.03982173f, -0.15633163f, 0.02598063f, 
    0.28025305f, 0.10946737f, -0.25347263f, -0.26786795f, -0.25129464f, -0.02314379f, -0.02145242f, -0.06922045f, 
    0.06542362f, 0.18785596f, 0.08922755f, -0.08218778f, -0.09734499f, -0.32695451f, -0.04851624f, -0.02903634f, 
    0.31549925f, 0.04029049f, -0.12865049f, -0.18121774f, -0.44993472f, 0.31560022f, -0.04177857f, -0.09487559f, 
    -0.15098299f, -0.30546698f, 0.24482858f, 0.22305642f, 0.01077393f, 0.02319785f, 0.19288652f, 0.03334961f, 
    -0.06690993f, -0.10243012f, -0.38947794f, 0.06630011f, 0.16029902f, 0.06553669f, -0.09118351f, -0.01077341f, 
    -0.11562087f, 0.02920540f, 0.14296786f, 0.01751287f, 0.09943356f, 0.02076868f, 0.20823160f, -0.18117344f, 
    -0.08247072f, 0.03502139f, 0.16763119f, 0.11953684f, -0.08023871f, -0.02664047f, 0.16749170f, 0.01603049f, 
    0.06192514f, 0.07209480f, 0.12669064f, -0.05535938f, -0.00914064f, -0.09757400f, 0.18816246f, -0.16320413f, 
    0.09364675f, -0.53657573f, -0.04238666f, 0.26287517f, -0.18809180f, -0.03631335f, 0.03175990f, -0.02339626f, 
    -0.04757082f, 0.07629728f, -0.40700668f, -0.23691794f, 0.10293828f, -0.06474505f, 0.03926168f, 0.02344019f, 
    -0.06210693f, -0.00929518f, 0.07371233f, -0.11930192f, -0.22818184f, -0.21599518f, 0.12203988f, 0.10454843f, 
    -0.09892134f, -0.05839450f, -0.02359507f, 0.16988885f, -0.01154650f, 0.36643955f, -0.11191478f, -0.17555667f, 
    -0.27275315f, 0.12068392f, -0.04025413f, -0.00241579f, 0.13906510f, -0.02857990f, -0.35536915f, -0.59232569f, 
    -0.04773031f, -0.13171330f, -0.17099521f, 0.11518854f, 0.15446925f, -0.16731565f, -0.20097332f, -0.11782825f, 
    -0.09943748f, 0.15151417f, 0.16991480f, -0.03743623f, 0.01526228f, 0.16400251f, 0.05073104f, -0.13608047f, 
    0.26757413f, 0.26009858f, -0.05344524f, 0.08572296f, 0.05944464f, 0.00623186f, -0.07818791f, 0.07406361f, 
    -0.02415252f, 0.10123800f, 0.25449634f, 0.03567381f, 0.05854135f, 0.02445659f, 0.07650479f, -0.02355845f, 
    0.12825717f, -0.24885748f, -0.13949171f, -0.08196095f, 0.14762001f, -0.03820062f, -0.08643528f, 0.09210905f, 
    0.17896798f, -0.07174252f, -0.29501691f, 0.11467989f, -0.01950259f, 0.02901233f, 0.03186196f, 0.06490772f, 
    -0.10740317f, 0.04469854f, -0.05338761f, 0.00022931f, 0.24638911f, 0.11773700f, -0.10652117f, -0.08471020f, 
    -0.03467602f, 0.08351570f, -0.14933617f, 0.07839740f, -0.05706173f, 0.13184088f, 0.44635293f, -0.01712118f, 
    -0.01664615f, -0.07022873f, -0.01247718f, 0.09412494f, 0.06504113f, -0.42470604f, -0.16178825f, 0.06685682f, 
    -0.27164537f, 0.06639007f, -0.01561406f, 0.10520079f, -0.05632582f, 0.15344737f, 0.00800158f, 0.25109351f, 
    0.18624480f, -0.09650557f, -0.05903951f, -0.01310591f, -0.05967919f, -0.10323974f, -0.01726873f, -0.47535291f, 
    0.07919401f, 0.22639583f, 0.01362194f, -0.13284507f, -0.23205461f, -0.05875647f, 0.04334632f, -0.17524643f, 
    0.02905426f, 0.02920196f, 0.01776272f, -0.04016879f, -0.03356589f, -0.05694113f, -0.03086836f, 0.02246505f, 
    0.00865848f, -0.07331774f, -0.06340412f, -0.00957700f, -0.01763138f, -0.05522044f, 0.01175294f, -0.05120900f, 
    0.02499142f, 0.03521865f, -0.06110411f, 0.01016303f, 0.00597703f, -0.03805177f, 0.01992101f, 0.01388698f, 
    0.02505293f, -0.02396674f, -0.03015551f, 0.03562516f, 0.04191884f, 0.02534260f, -0.03881947f, 0.03393297f, 
    0.03242189f, 0.01365801f, -0.03415594f, -0.06116128f, 0.03144559f, 0.02639174f, 0.00598479f, -0.05073336f, 
    -0.00527522f, -0.05497551f, 0.04498528f, 0.01695430f, -0.01197248f, 0.01701189f, 0.04841212f, -0.01885011f, 
    0.04823492f, -0.02024870f, 0.02296027f, 0.00429494f, -0.02998581f, -0.03461761f, -0.05341238f, -0.05587481f, 
    -0.02624652f, 0.02068567f, -0.02262282f, -0.06491949f, -0.01279207f, -0.03717383f, -0.02622749f, -0.02963523f, 
    0.01496251f, -0.06091077f, 0.04736815f, 0.04119699f, -0.01824909f, 0.03034456f, 0.00888634f, -0.03177696f, 
    -0.04083179f, -0.05064504f, -0.01186935f, 0.04431750f, -0.02318737f, -0.04640104f, -0.00732004f, 0.02550170f, 
    0.03349584f, -0.05043631f, -0.05272424f, -0.04544649f, -0.06175058f, -0.00915430f, -0.06186337f, -0.02204847f, 
    0.03977007f, -0.05732077f, 0.00855370f, -0.05001026f, -0.01471613f, -0.00132945f, -0.00686631f, 0.02027902f, 
    0.01979152f, -0.04722986f, -0.00035923f, 0.02694918f, 0.02093479f, 0.02486700f, 0.03265711f, 0.01146069f, 
    0.03795358f, -0.01480711f, 0.03299525f, 0.02326499f, -0.02336112f, 0.03473094f, -0.01450831f, 0.02198859f, 
    0.03960685f, 0.03810959f, -0.00071524f, -0.01748873f, 0.02855141f, -0.02304834f, 0.00302798f, 0.04397219f, 
    -0.01389662f, -0.03352777f, -0.00078882f, 0.01216801f, -0.03233483f, -0.05097348f, 0.02250822f, 0.01450574f, 
    -0.07109258f, -0.01534459f, -0.04185179f, -0.03388909f, 0.03990728f, -0.01020842f, 0.00788281f, -0.05584708f, 
    -0.04233254f, 0.00273489f, -0.04065261f, -0.00494994f, -0.04033289f, 0.02080023f, -0.00564484f, 0.00373592f, 
    -0.06852022f, 0.00254512f, 0.03699387f, 0.00604347f, -0.06473902f, -0.04856315f, 0.03899498f, 0.00921705f, 
    -0.03435503f, -0.03722942f, 0.00908088f, 0.00734088f, 0.04046239f, -0.03799118f, -0.02836416f, 0.01427400f, 
    0.03914241f, -0.03667976f, 0.04318247f, -0.01011159f, -0.03899243f, -0.06650008f, -0.03679848f, -0.06060995f, 
    0.00353137f, 0.00132581f, 0.02118800f, -0.03619148f, 0.02266949f, -0.05339416f, 0.00225423f, -0.06266171f, 
    -0.05566991f, 0.03626658f, -0.03661654f, -0.03143752f, 0.01616620f, -0.01082936f, 0.05661007f, -0.06421291f, 
    -0.02025649f, 0.03250555f, 0.00407091f, 0.00066897f, 0.03136604f, 0.01341706f, -0.03954424f, -0.03753287f, 
    -0.02883084f, -0.03210677f, -0.01858750f, -0.01276349f, -0.01307381f, -0.03326258f, -0.05353078f, -0.04527654f, 
    -0.03446476f, -0.01965470f, 0.00897700f, 0.01014506f, -0.05632599f, 0.00223464f, 0.05374180f, -0.01490355f, 
    0.03221834f, 0.00833704f, -0.07143340f, -0.03935277f, 0.01115533f, 0.05051779f, 0.00368316f, 0.04152246f, 
    -0.03224387f, -0.04461509f, 0.01821095f, 0.00109680f, 0.02931147f, 0.01150322f, 0.03763630f, 0.00545182f, 
    -0.00359422f, 0.03788405f, -0.05761245f, -0.00805241f, -0.06207432f, 0.00970635f, 0.00544945f, -0.02100811f, 
    -0.06493500f, -0.00743634f, -0.06983242f, -0.03553067f, 0.01211408f, 0.01022618f, -0.04794981f, -0.01103922f, 
    -0.02485602f, 0.00616444f, -0.01288928f, 0.02670906f, -0.01253594f, 0.01457377f, -0.02996228f, -0.05678704f, 
    -0.05655358f, 0.03104013f, 0.03401371f, -0.05763257f, 0.02658249f, -0.01465519f, -0.03690679f, 0.01088380f, 
    -0.07655980f, -0.04472565f, 0.04847111f, 0.00033743f, -0.01594424f, -0.01576983f, 0.03323588f, -0.02567770f, 
    0.03278178f, -0.02621249f, -0.05316386f, 0.01636580f, 0.02863297f, -0.02200668f, 0.01715850f, 0.05632122f, 
    0.02238243f, 0.02048048f, -0.04093949f, 0.00089694f, 0.05050582f, 0.04474578f, -0.02268822f, -0.01902001f, 
    -0.00387041f, 0.04986201f, 0.03278207f, -0.01882136f, 0.00680939f, -0.03066695f, -0.02835624f, 0.00194157f, 
    0.14938435f, 0.08484448f, -0.20269783f, -0.14554112f, 0.04271245f, -0.16375777f, 0.08037800f, 0.11787611f, 
    0.14483255f, 0.02048347f, 0.06837808f, 0.18327928f, -0.12294828f, -0.05307081f, -0.12788570f, -0.00234329f, 
    0.10018329f, -0.08790738f, -0.31099626f, 0.18340281f, 0.44229245f, -0.07374084f, 0.04035735f, -0.01037413f, 
    0.13229565f, 0.07957798f, -0.03651926f, -0.41423279f, -0.17150238f, 0.24681605f, 0.06262854f, -0.16908926f, 
    0.21241747f, 0.22522068f, 0.09424376f, -0.15873823f, -0.08012579f, -0.11796629f, -0.59218371f, -0.10301065f, 
    -0.02109457f, -0.07773643f, 0.02881178f, 0.02901546f, -0.03075648f, 0.29406652f, -0.05059900f, -0.12340743f, 
    0.01416825f, 0.02121615f, 0.03103075f, -0.09396816f, 0.07594946f, -0.04994462f, 0.26695186f, 0.11783905f, 
    -0.05939101f, -0.06408954f, 0.05497089f, 0.01896599f, -0.08702471f, -0.03074138f, -0.09332144f, 0.18672948f, 
    -0.08793173f, -0.04416187f, -0.05896568f, -0.06344639f, 0.12919468f, 0.06040895f, -0.08854334f, -0.10026464f, 
    -0.07501106f, -0.07467836f, 0.19269782f, 0.03354333f, -0.07680713f, -0.16223055f, -0.07227589f, 0.00729469f, 
    0.04939549f, 0.00022811f, -0.02561318f, -0.06601870f, 0.01373741f, 0.13438872f, 0.00406179f, -0.07822320f, 
    0.03892245f, 0.01429413f, 0.05657437f, -0.18597676f, -0.24429384f, -0.12145142f, 0.06438614f, -0.35650012f, 
    0.04882034f, 0.05801437f, -0.03987993f, 0.13945143f, 0.05028092f, -0.03129134f, -0.10336258f, 0.04698502f, 
    -0.04190496f, 0.08769926f, 0.06069095f, -0.19850770f, 0.01878266f, -0.13693246f, -0.29044127f, 0.22941966f, 
    -0.26472044f, 0.02522628f, 0.21572855f, -0.03763773f, 0.03979624f, -0.07464222f, 0.00085905f, 0.08822625f, 
    -0.16025095f, -0.15208770f, 0.07956802f, 0.14164113f, -0.08316566f, -0.05419050f, 0.25831690f, 0.41542047f, 
    -0.50562108f, -0.01340941f, 0.04095909f, 0.00131355f, -0.14546883f, 0.09788199f, -0.12976575f, -0.06492639f, 
    0.02477097f, 0.12061220f, -0.03507167f, -0.01440691f, -0.17219684f, -0.15653914f, 0.12297241f, 0.07381827f, 
    0.51003683f, 0.03031526f, 0.17683977f, -0.15762019f, -0.03469505f, 0.06933112f, -0.06595325f, 0.09248803f, 
    -0.04883819f, -0.49039298f, -0.31962097f, 0.43051720f, -0.01367801f, 0.11008087f, -0.11944358f, -0.10800554f, 
    0.05053848f, -0.00355129f, -0.15516916f, 0.09635780f, 0.15007165f, -0.01036812f, -0.07913288f, -0.24863940f, 
    -0.05041407f, 0.06991626f, -0.12815632f, 0.36624521f, 0.00260828f, -0.10890669f, 0.08418336f, 0.10140616f, 
    0.03156788f, -0.17479207f, 0.05632079f, 0.08755281f, 0.49517423f, 0.37503827f, -0.04598364f, -0.09429926f, 
    0.10695651f, 0.17147078f, 0.16099988f, -0.05150422f, -0.02025681f, 0.44247869f, -0.04768297f, -0.18524669f, 
    0.03376474f, 0.03290669f, 0.13460739f, -0.00745536f, 0.11280397f, -0.02441596f, -0.08930330f, -0.23813745f, 
    -0.35816956f, 0.01137637f, -0.18891740f, -0.02520327f, -0.06145174f, -0.10403549f, -0.08265806f, -0.05112411f, 
    0.12686186f, 0.02051448f, -0.24807081f, 0.01466015f, -0.02620772f, -0.00020278f, -0.06470294f, -0.05548273f, 
    0.06857780f, 0.16224895f, 0.11421573f, -0.02315661f, -0.10188312f, 0.09512800f, -0.13768746f, -0.03742613f, 
    -0.04477067f, 0.03888237f, -0.10501993f, -0.20482825f, -0.01560678f, -0.19554088f, -0.26026949f, 0.08280011f, 
    -0.03288152f, -0.06392717f, 0.19988273f, 0.32429087f, -0.00174403f, -0.22204362f, 0.03109125f, 0.02917155f, 
    0.12503378f, -0.00923227f, -0.03345603f, 0.17063864f, 0.15695898f, -0.03887501f, -0.06057939f, 0.02096325f, 
    -0.03770824f, 0.11757076f, -0.19493330f, -0.06076344f, 0.05365225f, 0.11678692f, 0.06478351f, -0.06840404f, 
    0.08508401f, -0.07680001f, -0.03920317f, 0.02383044f, 0.04076392f, -0.08265909f, -0.13325392f, 0.06071612f, 
    0.04849270f, -0.06874365f, -0.16761300f, 0.12351047f, 0.36817294f, 0.07438597f, 0.26593208f, 0.30088818f, 
    0.02475810f, 0.09522633f, -0.01218360f, 0.02831798f, 0.07067049f, -0.01569591f, 0.00530561f, 0.11144815f, 
    0.21295296f, 0.53155416f, -0.27353445f, 0.07563885f, -0.25735685f, 0.12608007f, 0.00181382f, -0.02732415f, 
    -0.16209392f, -0.24802902f, 0.01017706f, -0.00602185f, -0.08547710f, -0.14358887f, -0.03812581f, 0.04711121f, 
    -0.30885452f, -0.03763481f, -0.05215525f, -0.16663237f, 0.07081582f, 0.03602280f, 0.07363199f, 0.06584045f, 
    -0.04209800f, -0.10803942f, -0.03335662f, -0.20175657f, 0.06768762f, 0.07120295f, 0.02249292f, -0.13174012f, 
    0.12762585f, 0.04633983f, -0.22451653f, -0.42479500f, -0.20821646f, 0.52676183f, 0.09386525f, -0.15432097f, 
    0.21441759f, 0.07415891f, 0.25970000f, 0.07408902f, -0.09108734f, 0.00400296f, 0.16573742f, -0.06515241f, 
    0.19037725f, 0.02883587f, 0.05520688f, 0.06873003f, 0.06620128f, 0.03483414f, 0.01472431f, 0.01900214f, 
    0.10646700f, 0.09396964f, 0.19063716f, -0.05724025f, 0.22766340f, 0.17050974f, 0.01287038f, -0.23371968f, 
    -0.07029582f, -0.00698639f, -0.17700127f, -0.00699050f, 0.00498165f, -0.04777521f, 0.08171210f, -0.06225305f, 
    -0.23149554f, 0.03716053f, -0.02719087f, 0.06303551f, 0.00764663f, -0.08314268f, 0.27579114f, 0.22774392f, 
    -0.10383102f, -0.03864278f, -0.10318008f, -0.04551645f, 0.13673241f, -0.08122919f, 0.05564138f, -0.15342782f, 
    0.07816727f, 0.05204300f, -0.00833265f, 0.12517810f, 0.08766779f, 0.20785783f, -0.01073732f, 0.00505171f, 
    0.19269346f, 0.01196425f, 0.00109835f, 0.01345766f, 0.04383158f, -0.05504814f, -0.09159383f, 0.06306359f, 
    -0.04750217f, -0.16060500f, 0.17481737f, -0.21576786f, -0.30159932f, 0.18908015f, -0.05704386f, -0.03994692f, 
    0.26353461f, -0.13086481f, 0.19274764f, 0.03777638f, -0.20380856f, 0.07508470f, -0.03627019f, -0.09085205f, 
    -0.12670277f, -0.33491868f, 0.10382709f, -0.03289592f, -0.14372109f, -0.12231247f, -0.04834967f, 0.23603104f, 
    -0.19447421f, -0.01321206f, -0.07881339f, -0.02232683f, 0.18622370f, 0.12033495f, -0.10984714f, 0.05489822f, 
    0.04129335f, -0.13680492f, 0.17989665f, -0.16772300f, 0.01995115f, 0.07076707f, 0.08025255f, 0.19511226f, 
    0.01351497f, -0.09462392f, -0.25619939f, -0.19839481f, -0.13990915f, -0.21152811f, 0.05831391f, -0.19845518f, 
    0.11770124f, -0.09668954f, -0.07064162f, -0.03570302f, 0.06621321f, -0.15456420f, -0.00465153f, 0.03439566f, 
    0.23432000f, 0.06758514f, 0.30595231f, -0.28389904f, 0.00418371f, 0.07722715f, -0.00616864f, -0.08401479f, 
    0.01145060f, 0.09231519f, 0.09892711f, 0.05418285f, -0.16529827f, 0.04378665f, -0.00723056f, -0.12946697f, 
    0.01213363f, 0.03057363f, -0.20376951f, 0.09949785f, -0.05572239f, -0.04237091f, -0.06018458f, -0.16583872f, 
    0.12048537f, -0.02216595f, -0.16923331f, -0.05165032f, 0.05793864f, -0.43497133f, -0.17868830f, 0.11928368f, 
    -0.10427085f, -0.08945819f, -0.02324747f, 0.03166540f, 0.01495271f, -0.03903027f, -0.50326842f, 0.08863975f, 
    0.20602438f, 0.08332860f, -0.04406856f, -0.15814994f, 0.21338455f, 0.22579379f, -0.03339042f, -0.14653835f, 
    0.19210216f, -0.00967039f, 0.01167739f, 0.08335514f, -0.03388819f, 0.11848440f, 0.12873566f, -0.22171956f, 
    -0.05062202f, 0.23360641f, -0.09724213f, -0.11552705f, 0.08009563f, 0.02813052f, 0.18847272f, 0.05245248f, 
    0.13685542f, 0.06565236f, -0.00166962f, -0.12935682f, 0.16964047f, -0.11315020f, -0.00084453f, 0.04998741f, 
    0.05570741f, -0.11570445f, -0.23240256f, 0.00638774f, -0.04484450f, -0.00052734f, 0.11495791f, -0.00873267f, 
    0.00044596f, 0.12300884f, 0.10107604f, 0.02769963f, -0.09450152f, -0.05324090f, 0.13499206f, -0.19081831f, 
    0.11445198f, -0.12411556f, 0.02183948f, 0.14693555f, -0.14369923f, 0.03522274f, -0.04818576f, -0.12098967f, 
    -0.10249452f, 0.09232064f, 0.14546205f, 0.05843110f, 0.02679805f, 0.03740136f, 0.16421434f, 0.12760746f, 
    0.07611753f, -0.14901450f, 0.08966532f, -0.01681269f, -0.02630421f, -0.00890181f, 0.08007038f, 0.01627723f, 
    0.02788114f, -0.07715116f, -0.15247944f, 0.14750762f, -0.10477380f, 0.03350914f, 0.00857486f, 0.04633448f, 
    0.15232655f, 0.00777783f, 0.04874812f, -0.07268923f, 0.15577683f, -0.01315136f, -0.18101265f, 0.15287323f, 
    0.13191892f, -0.39696833f, -0.05112408f, -0.07984428f, 0.09966978f, 0.04953100f, 0.03046423f, 0.06502434f, 
    -0.23655683f, -0.19980282f, 0.31173548f, -0.01912363f, -0.05624311f, -0.16564772f, -0.06849718f, -0.00421256f, 
    0.25155386f, 0.36704138f, 0.28766257f, 0.03122687f, -0.12046091f, 0.02595981f, 0.01432033f, -0.00658047f, 
    -0.05773801f, -0.08024918f, 0.24312568f, -0.06975204f, -0.25367579f, 0.11646535f, 0.17743011f, -0.02604356f, 
    0.09401789f, 0.08661210f, 0.15767364f, -0.26634520f, -0.00242466f, 0.12562881f, -0.04423892f, -0.17221870f, 
    0.08067986f, 0.00840411f, 0.01188768f, 0.13203204f, 0.07139427f, 0.23261309f, 0.29640788f, 0.13674912f, 
    0.32494754f, 0.22482087f, 0.13857266f, 0.05100624f, 0.13369681f, -0.05784664f, -0.37034723f, -0.49136648f, 
    -0.00906319f, -0.01262724f, 0.01581582f, 0.06784755f, -0.10535741f, -0.08719936f, -0.14806114f, -0.24713787f, 
    -0.56782037f, -0.06733842f, 0.05498439f, 0.00775002f, 0.11427554f, 0.00110083f, -0.04320710f, -0.02946913f, 
    -0.41077432f, -0.10757995f, -0.04549866f, 0.08514076f, 0.03546788f, -0.04626398f, -0.08993210f, -0.03676193f, 
    -0.00733142f, 0.13704905f, -0.03075547f, -0.07015403f, -0.09953880f, -0.27818444f, 0.00415018f, -0.07735336f, 
    0.01979942f, -0.29295307f, 0.08061764f, -0.13671809f, 0.00933010f, -0.05099354f, 0.07126097f, 0.17006129f, 
    0.10423999f, 0.21402484f, -0.00646346f, -0.03265961f, -0.07032506f, 0.04140225f, 0.00777964f, 0.01125251f, 
    -0.08666345f, -0.12715289f, -0.17773324f, 0.45353004f, -0.37201783f, -0.28032330f, 0.02867455f, 0.21986987f, 
    0.30534369f, -0.15312037f, -0.20612153f, -0.03181597f, -0.06239041f, 0.16003002f, 0.20799725f, -0.03072695f, 
    0.10310712f, -0.18635160f, 0.24861126f, -0.00845883f, -0.13912074f, -0.10696327f, -0.00058567f, 0.26813611f, 
    0.04014990f, -0.08787534f, -0.05663897f, -0.09487614f, -0.02129016f, 0.08532471f, 0.04675236f, -0.00546689f, 
    0.08216078f, -0.17216656f, 0.04125362f, 0.06399316f, 0.14701545f, 0.19013064f, 0.08989625f, 0.06126817f, 
    0.15442757f, 0.18421695f, -0.16824421f, -0.13028710f, -0.17040864f, 0.11297051f, -0.03784715f, 0.07747273f, 
    -0.08146652f, -0.12014052f, -0.24350588f, -0.02514574f, 0.08408928f, -0.03560737f, -0.05854527f, 0.03184106f, 
    0.09897991f, 0.15151167f, 0.15454903f, 0.05193853f, 0.01464495f, 0.03426467f, -0.18749760f, 0.17631544f, 
    0.02386565f, 0.16480023f, 0.23266025f, 0.35843202f, 0.08807068f, 0.04471706f, -0.07117168f, -0.09035604f, 
    0.10206027f, 0.00344445f, 0.05214968f, -0.05769349f, -0.52186871f, -0.75290310f, -0.19300388f, -0.17799249f, 
    -0.24095401f, -0.09770510f, -0.19331184f, -0.09703065f, 0.08884338f, 0.29353374f, 0.11027676f, -0.22400162f, 
    -0.06924005f, -0.28055263f, -0.10451333f, -0.02884279f, -0.18004347f, -0.20211706f, -0.20814516f, -0.30503261f, 
    -0.14214504f, 0.14011052f, 0.08523958f, -0.11582769f, -0.07585725f, -0.25241509f, 0.01915521f, -0.07191736f, 
    -0.02078944f, 0.03574166f, 0.12883496f, -0.00824734f, 0.00712118f, -0.01231211f, 0.10812339f, 0.18646124f, 
    -0.07288706f, -0.10284261f, 0.11733061f, -0.00235060f, -0.02829929f, -0.03524167f, 0.02449515f, -0.04630150f, 
    0.32286361f, -0.04267497f, 0.05915437f, 0.01780556f, 0.13476165f, 0.11562555f, -0.00189874f, 0.07829020f, 
    0.01486311f, 0.01625230f, -0.06104650f, 0.07268388f, -0.12202530f, -0.01788408f, 0.03133047f, -0.04147478f, 
    -0.09316712f, -0.07204533f, 0.00516314f, -0.05133874f, 0.15531237f, 0.14618908f, -0.02454784f, -0.02533076f, 
    0.03270696f, 0.02825670f, 0.00161316f, -0.05939586f, -0.02737558f, -0.04943486f, -0.14642631f, -0.07673646f, 
    -0.03232422f, 0.10296245f, 0.02086515f, -0.14725634f, -0.14091130f, -0.41276944f, -0.32715276f, 0.01486274f, 
    0.17999159f, 0.03548472f, 0.10808528f, 0.04521459f, 0.16130435f, 0.22778741f, 0.15790015f, 0.16017762f, 
    0.05637335f, 0.05350887f, 0.01115325f, 0.00622386f, 0.16041076f, -0.00129058f, 0.07047481f, -0.24969894f, 
    -0.27940890f, -0.00197196f, 0.13321126f, 0.03324779f, -0.15978469f, -0.14702886f, 0.03962292f, 0.24241593f, 
    0.10805903f, -0.48706210f, 0.27190900f, -0.04624829f, 0.00416979f, 0.15279613f, 0.05964204f, 0.14053066f, 
    -0.22624037f, -0.22817856f, -0.29211974f, 0.12595065f, -0.12702225f, -0.01690388f, 0.03518333f, 0.13541459f, 
    -0.03801279f, 0.02754824f, -0.04965888f, 0.12244423f, -0.00106757f, -0.06733561f, 0.01722149f, -0.03578942f, 
    0.06918989f, 0.04450304f, -0.12360411f, 0.07220419f, 0.27941701f, 0.03418957f, -0.05546709f, -0.07525735f, 
    -0.03033725f, 0.21754108f, 0.12745805f, 0.07909495f, -0.14255111f, 0.06201854f, -0.00959217f, 0.15581165f, 
    0.04258100f, -0.17359239f, -0.06580549f, -0.01784566f, 0.03270211f, 0.07520317f, 0.15553807f, 0.07524304f, 
    -0.04361034f, -0.10505737f, 0.12107715f, 0.05110465f, 0.23381747f, -0.04230344f, 0.13670862f, 0.19098294f, 
    0.04259321f, 0.03114204f, -0.20657906f, -0.08847506f, -0.20716533f, -0.15468433f, 0.19731301f, 0.04668024f, 
    -0.12136990f, -0.00209238f, 0.05883330f, 0.01538917f, 0.00424385f, 0.08294623f, 0.08399975f, -0.07440672f, 
    -0.03387737f, -0.04918601f, 0.02676596f, -0.09165959f, -0.15578918f, 0.09747265f, -0.40207964f, -0.20448926f, 
    0.01705908f, -0.04214875f, 0.08648161f, 0.03266831f, -0.02994378f, 0.18886329f, 0.05027137f, -0.15945780f, 
    -0.33639443f, 0.16153108f, 0.19542754f, 0.17269924f, 0.06040484f, -0.10714573f, 0.05197284f, -0.07475913f, 
    0.12870087f, 0.17894937f, 0.11572688f, -0.01809474f, 0.23506331f, 0.03176500f, 0.15076479f, 0.11283732f, 
    -0.06986487f, 0.09705959f, 0.02662545f, 0.04792086f, -0.12944257f, 0.17216045f, 0.12724458f, -0.10188891f, 
    -0.34939739f, 0.01418525f, -0.13942400f, -0.00543660f, -0.02408031f, -0.07423116f, -0.18287084f, 0.16632038f, 
    -0.08644300f, -0.10480548f, -0.08234025f, 0.07506526f, 0.25050882f, -0.01159596f, -0.14159414f, -0.08666029f, 
    0.23015016f, -0.06836770f, 0.27618787f, -0.25042564f, -0.17537627f, -0.14270775f, 0.14826250f, 0.12754913f, 
    -0.04767377f, 0.21102710f, -0.08767723f, 0.34199709f, -0.09206631f, -0.04639164f, -0.08862891f, -0.14489497f, 
    -0.02112440f, 0.08128235f, -0.00441642f, -0.06186419f, 0.06159991f, 0.01676078f, -0.07426071f, -0.04104939f, 
    0.03334602f, -0.09812324f, 0.03169802f, 0.19280630f, -0.01034931f, -0.10588860f, -0.14196230f, 0.04425100f, 
    -0.36509007f, 0.01028755f, -0.07462412f, 0.25776136f, 0.04493160f, 0.02958564f, 0.23715369f, -0.00571780f, 
    0.09261858f, -0.11574902f, -0.02533027f, 0.02273894f, 0.10115947f, 0.01530935f, -0.03092470f, 0.00292537f, 
    0.00935667f, 0.01423541f, -0.10622121f, 0.02338638f, 0.22817463f, 0.23599181f, 0.17560084f, -0.03563855f, 
    -0.09623296f, -0.07373006f, 0.02094552f, 0.02231593f, -0.22007543f, -0.17975421f, -0.01659721f, 0.01494463f, 
    -0.09822083f, 0.01963317f, 0.03860990f, 0.13277911f, 0.29006508f, 0.09300291f, 0.01045095f, -0.04535456f, 
    0.11002154f, -0.01119064f, -0.17006122f, -0.12026511f, -0.26762089f, -0.27200398f, 0.18177234f, 0.06719574f, 
    0.13570610f, 0.07047155f, 0.03244565f, 0.03154132f, -0.03921497f, 0.11196251f, 0.14430536f, -0.11400506f, 
    -0.21531257f, -0.06219098f, 0.09475181f, 0.05311609f, 0.12392180f, -0.00392022f, 0.01349651f, -0.14455861f, 
    0.09450101f, 0.08577131f, 0.07655099f, 0.17578886f, -0.14151189f, 0.17748338f, -0.22728412f, 0.05743873f, 
    0.06786937f, 0.03842807f, 0.03866001f, 0.12081980f, 0.08639254f, 0.07382027f, 0.03448015f, -0.00953599f, 
    0.10607289f, -0.00703794f, -0.03021768f, 0.12861879f, -0.04834125f, 0.06992722f, 0.03804474f, 0.10010693f, 
    -0.04927100f, -0.06145014f, -0.27807280f, -0.03157697f, -0.06732962f, -0.09871966f, 0.04585099f, -0.02785042f, 
    0.08377902f, 0.02657877f, -0.15740588f, -0.18132916f, 0.01704992f, -0.06718586f, 0.02109969f, 0.00019278f, 
    -0.00600762f, -0.12680477f, 0.15956743f, 0.07144285f, -0.04680046f, -0.35815114f, -0.18003289f, 0.07969499f, 
    -0.00857799f, 0.19468659f, -0.22469938f, 0.15240782f, 0.11431424f, -0.01468628f, -0.14344770f, -0.32935628f, 
    -0.22727090f, -0.13608402f, -0.10115987f, -0.06003884f, -0.02404232f, 0.03888506f, -0.09492943f, 0.13745958f, 
    -0.07634974f, 0.13208190f, 0.09137637f, 0.02347278f, -0.14837569f, 0.10214013f, 0.10346650f, -0.05426980f, 
    0.13084947f, -0.16518375f, 0.04333446f, 0.04615665f, 0.07462180f, -0.01569184f, 0.18468468f, 0.12320105f, 
    0.12781292f, -0.10372847f, 0.08334117f, -0.06101754f, -0.05776201f, -0.00740257f, 0.08265048f, 0.13696326f, 
    0.09293793f, 0.08144639f, -0.14516890f, -0.01001096f, -0.15745082f, -0.08416782f, 0.15782060f, -0.07113142f, 
    0.15366106f, -0.12334983f, -0.05629621f, -0.36728564f, -0.43046650f, -0.09064708f, -0.13296796f, -0.21310236f, 
    -0.07601885f, 0.02787839f, 0.02618053f, -0.11948792f, -0.17615081f, -0.12808807f, -0.05128653f, -0.04410328f, 
    -0.03876714f, 0.09773146f, 0.09790993f, 0.16609593f, 0.10661420f, -0.21188593f, -0.04208941f, 0.09664062f, 
    -0.02927743f, -0.02257554f, -0.06640153f, 0.07520444f, -0.03984367f, 0.00495486f, 0.05193349f, 0.19370838f, 
    0.10298572f, 0.00591085f, 0.07903825f, 0.17892733f, 0.08557232f, -0.07024919f, -0.05049387f, -0.15440542f, 
    -0.04390192f, -0.22844520f, 0.02993518f, 0.00363082f, 0.00845313f, 0.16406588f, 0.00057665f, 0.15713866f, 
    -0.52700645f, 0.02938956f, -0.03665411f, -0.07537896f, 0.00582589f, -0.14420743f, 0.04281548f, 0.01838035f, 
    -0.15597810f, 0.07636875f, -0.00603145f, 0.02278072f, 0.15744872f, 0.10451525f, 0.09470946f, 0.11719297f, 
    0.02839228f, 0.08124433f, -0.06625804f, 0.10885002f, -0.00367809f, -0.10523638f, -0.00337811f, 0.09295087f, 
    -0.01372693f, 0.03133217f, 0.18225858f, -0.23714833f, -0.51989198f, -0.59057277f, -0.02657251f, -0.11885276f, 
    0.18042061f, 0.04371226f, -0.25585917f, -0.06342806f, -0.25269195f, -0.00548063f, -0.15018734f, -0.30402744f, 
    -0.14045796f, -0.11823656f, 0.12886862f, -0.11299180f, 0.17933084f, -0.25788003f, 0.04016652f, 0.05933939f, 
    -0.07615700f, -0.13481306f, -0.00984609f, 0.01983431f, -0.18662429f, 0.21806817f, -0.69506568f, -0.65713644f, 
    -0.14226420f, -0.07409674f, 0.00535673f, -0.24719577f, -0.03057190f, -0.09985155f, 0.06325550f, -0.13127239f, 
    -0.08255528f, -0.06559999f, -0.03332877f, 0.02583213f, 0.00225603f, 0.25484651f, 0.07377951f, -0.06095106f, 
    -0.32011569f, -0.04784722f, -0.07029928f, -0.21096191f, 0.01041624f, 0.02465954f, 0.07952838f, -0.01687822f, 
    0.02535257f, -0.30549574f, 0.04386507f, -0.34051833f, -0.08549028f, 0.00108427f, -0.08372688f, -0.02079129f, 
    0.21519531f, 0.17725195f, -0.15310927f, -0.07425693f, -0.04836816f, 0.15668140f, 0.13157210f, 0.01301929f, 
    0.08244877f, -0.09168243f, 0.02759357f, 0.35532346f, 0.26621944f, 0.02015502f, -0.22447732f, -0.17781760f, 
    0.04636944f, 0.05747035f, -0.05536085f, 0.01100352f, 0.20405956f, 0.19630666f, 0.21697097f, -0.20744777f, 
    -0.01590567f, -0.00032574f, -0.08421684f, 0.01684454f, 0.03512966f, -0.20691235f, 0.10429367f, 0.08059919f, 
    -0.16146773f, -0.23369700f, -0.05065362f, 0.01971078f, 0.00342455f, 0.11363675f, 0.02252341f, 0.10620134f, 
    -0.04020047f, -0.11119650f, -0.04515754f, 0.10820907f, -0.05995882f, 0.15528052f, 0.08833825f, 0.02896256f, 
    0.34974653f, 0.31798112f, -0.00710813f, 0.00627405f, -0.03032789f, -0.05299920f, 0.06288910f, -0.11954146f, 
    -0.32686555f, -0.11847358f, 0.00046413f, -0.13104676f, 0.14822799f, 0.00256039f, -0.00134580f, 0.11349974f, 
    0.00667042f, 0.12444340f, 0.08230735f, 0.06272738f, -0.05028380f, -0.04526822f, 0.05816628f, 0.01705569f, 
    0.05569722f, -0.01219227f, -0.05556627f, 0.10995640f, 0.30156711f, -0.12489935f, 0.14140584f, -0.03501260f, 
    -0.05695557f, 0.05469347f, -0.00608568f, 0.04249171f, 0.15711737f, 0.14524479f, 0.01321172f, 0.07298877f, 
    0.03230917f, 0.06390384f, -0.05331646f, 0.10275739f, 0.14489707f, 0.24155936f, 0.13806443f, -0.07113744f, 
    -0.11361356f, 0.08014075f, 0.28032285f, 0.26746175f, -0.00390462f, -0.31520250f, 0.25549132f, -0.15222688f, 
    -0.00733288f, 0.12459784f, 0.06994464f, 0.13492376f, -0.09866269f, -0.01742322f, 0.28001368f, 0.18474357f, 
    0.28884798f, 0.01939233f, -0.07555441f, -0.10928529f, 0.08925661f, 0.14331037f, 0.07434996f, -0.45773101f, 
    0.20206599f, 0.11265395f, 0.10913394f, -0.20297201f, -0.26468194f, -0.20386226f, 0.03045191f, 0.09864385f, 
    -0.03899831f, 0.04647763f, -0.02653692f, -0.06116948f, -0.01362338f, 0.03177406f, 0.04557357f, 0.00672909f, 
    -0.00082304f, 0.01508992f, 0.01128461f, -0.02890702f, -0.06140310f, -0.04667082f, -0.04305005f, 0.05423084f, 
    0.00901928f, 0.03431312f, 0.01432873f, -0.00998867f, -0.05155534f, -0.00884886f, -0.06530728f, -0.03913406f, 
    -0.04105131f, -0.04149845f, 0.02686659f, -0.03600106f, 0.01909998f, 0.02710387f, 0.00556314f, 0.02092834f, 
    0.01447410f, 0.04982952f, -0.05294195f, -0.04281364f, -0.03174553f, -0.02516129f, -0.03367931f, -0.04274738f, 
    -0.04522697f, -0.04756648f, -0.02975140f, 0.00380213f, -0.00507998f, -0.05864068f, -0.00767176f, -0.04135074f, 
    -0.03639594f, -0.06719517f, -0.02311590f, -0.02597326f, -0.06354425f, 0.00688373f, 0.03965469f, 0.01693591f, 
    0.00011313f, -0.02015200f, -0.03381100f, -0.00922207f, 0.03612715f, -0.05695857f, -0.02339547f, -0.04261857f, 
    0.03617699f, 0.04801279f, 0.02295636f, -0.00065706f, 0.04319277f, -0.01181560f, 0.00994126f, 0.00692024f, 
    -0.04346512f, -0.03128134f, 0.02237614f, 0.03032231f, -0.06486438f, -0.04053089f, -0.01413515f, 0.04403960f, 
    -0.01616360f, 0.02175520f, 0.03838525f, 0.00615139f, 0.02181495f, -0.01008228f, -0.00117823f, -0.02740832f, 
    0.04117034f, 0.01887191f, -0.05077656f, -0.05966771f, 0.03632154f, 0.02857751f, 0.00709293f, -0.03333608f, 
    -0.02933082f, 0.01155288f, 0.04638761f, -0.00017727f, -0.05390069f, -0.05438493f, 0.03894582f, 0.01027569f, 
    -0.06837156f, -0.01198509f, 0.01626408f, 0.00384349f, -0.04163995f, -0.00218334f, 0.03304928f, -0.04759283f, 
    -0.04729799f, 0.02171810f, 0.03868623f, 0.01751956f, -0.01096765f, -0.01507526f, 0.04747462f, -0.02058956f, 
    0.02108926f, 0.01628783f, 0.03106313f, -0.02505891f, -0.01702578f, -0.05308978f, -0.01282577f, 0.03556613f, 
    -0.02079957f, 0.01749949f, -0.06210702f, 0.04779613f, -0.01398533f, 0.03331662f, -0.02010478f, -0.02972489f, 
    -0.01021691f, 0.00773526f, -0.05225374f, -0.02651733f, -0.00119696f, 0.04904226f, 0.05096880f, 0.00945350f, 
    -0.01784565f, -0.00417247f, 0.04090082f, -0.06542286f, -0.04469522f, 0.04415144f, 0.01029930f, -0.02458364f, 
    0.01595642f, 0.01601842f, -0.03113931f, 0.01035923f, 0.02793698f, 0.03301381f, -0.04070564f, -0.03305580f, 
    -0.05429752f, -0.02706077f, -0.02613214f, 0.02698588f, -0.06127880f, -0.05741610f, -0.03998442f, 0.03522025f, 
    -0.00407501f, -0.03293211f, -0.01759493f, -0.03986347f, 0.04040810f, -0.00212792f, -0.06649898f, 0.02167324f, 
    -0.04863128f, 0.00110423f, -0.02159513f, -0.01732985f, -0.04342614f, -0.04314688f, -0.03735863f, 0.01021043f, 
    0.00404757f, -0.04279999f, 0.01550607f, 0.01988785f, -0.03465308f, -0.01630047f, -0.02044286f, 0.02084718f, 
    -0.01167597f, -0.01031682f, -0.02148265f, 0.00685910f, 0.02326110f, -0.02014490f, -0.02146475f, 0.03694123f, 
    -0.06003188f, -0.01970861f, 0.01820637f, -0.06352182f, 0.04369942f, -0.00699941f, 0.02441945f, -0.02989728f, 
    0.03154498f, -0.04577092f, -0.02694615f, -0.04621898f, 0.04575691f, -0.04928290f, 0.02541820f, -0.02728643f, 
    0.02675536f, 0.01983413f, 0.00438565f, -0.00004433f, 0.04661115f, -0.05509242f, 0.03020523f, -0.02643652f, 
    -0.00684233f, 0.00731690f, 0.03563588f, -0.01774504f, 0.03469691f, 0.03269066f, 0.03096707f, -0.00261980f, 
    0.04454285f, 0.04590037f, -0.04668241f, 0.00614160f, 0.04682865f, -0.04954061f, 0.03404588f, 0.01070195f, 
    -0.05737931f, 0.00232031f, -0.03717829f, -0.06527425f, -0.04384392f, -0.06000572f, 0.04468692f, -0.06167963f, 
    -0.03368478f, -0.02588449f, 0.03432512f, -0.05619749f, -0.00608746f, 0.04664613f, 0.03501540f, -0.03253237f, 
    -0.02103456f, 0.03923186f, -0.04534147f, 0.02554447f, 0.01309484f, -0.05261766f, 0.04626404f, 0.04411155f, 
    0.04112511f, -0.04141240f, 0.02351741f, -0.06305677f, -0.02977864f, -0.00472665f, -0.06553508f, -0.02093944f, 
    0.02563326f, -0.05479272f, 0.02056815f, 0.00794329f, -0.05356076f, -0.02660774f, -0.01536008f, -0.01807077f, 
    -0.05332612f, 0.03490220f, -0.04270202f, -0.05981892f, 0.01042082f, 0.01748552f, 0.03873787f, 0.02611170f, 
    -0.09751553f, 0.11924720f, -0.27163303f, 0.10157945f, -0.00269705f, -0.08661310f, 0.31337541f, 0.24243039f, 
    0.08759791f, -0.07256689f, -0.21481916f, 0.06165553f, 0.02376452f, -0.03837921f, 0.08647321f, -0.13724843f, 
    -0.04391393f, -0.14342467f, 0.01613409f, 0.11427321f, 0.05659325f, 0.05975237f, 0.01461316f, 0.16343185f, 
    0.29928753f, 0.00801761f, 0.18792218f, 0.23015115f, -0.30176634f, 0.06548694f, -0.01941546f, 0.17086001f, 
    0.05653904f, -0.18203215f, 0.00824229f, -0.04941288f, 0.08230496f, 0.02076002f, 0.04699229f, 0.09177468f, 
    -0.11039406f, 0.16704069f, 0.01477946f, 0.12055507f, -0.18910870f, -0.11853200f, 0.01982372f, 0.02861264f, 
    0.03318550f, -0.11812581f, -0.05633349f, -0.07568275f, -0.23210154f, -0.14029934f, -0.05492851f, 0.04579158f, 
    0.07949780f, -0.06083514f, -0.02812047f, 0.01310231f, -0.01312943f, 0.03428984f, 0.10372052f, 0.07841304f, 
    -0.00153745f, -0.03872249f, 0.00769858f, -0.07151178f, 0.08902403f, -0.03812994f, -0.25770378f, -0.12640052f, 
    -0.18406956f, -0.39672998f, -0.07725257f, 0.00838519f, 0.08138210f, -0.09704110f, -0.05290280f, 0.09754965f, 
    -0.28784171f, 0.16471706f, 0.09838523f, 0.03148977f, 0.09372862f, -0.05988276f, 0.06801001f, -0.19721158f, 
    0.20664908f, 0.01911768f, -0.07356049f, -0.12063668f, 0.00565517f, 0.07817915f, 0.20448166f, 0.08270165f, 
    0.15731943f, 0.06528954f, 0.00801990f, 0.10326234f, -0.19484235f, 0.07992601f, 0.24784967f, -0.05713017f, 
    -0.00686269f, -0.15434387f, 0.02816223f, 0.14194889f, -0.17954151f, -0.25531155f, 0.09317014f, 0.02152381f, 
    -0.13447593f, 0.06649861f, -0.12193023f, 0.07760786f, 0.03866716f, -0.04388400f, -0.26257080f, -0.03101417f, 
    -0.11261514f, -0.05410612f, 0.19170620f, -0.25976443f, -0.24991260f, -0.18216726f, -0.06490453f, -0.15395197f, 
    0.18698423f, 0.23297246f, 0.01086509f, -0.00144964f, -0.28750685f, -0.01959954f, -0.06317689f, -0.07991897f, 
    -0.00329297f, -0.03184114f, -0.04943030f, 0.06341548f, -0.08846952f, -0.07569214f, -0.07143853f, -0.06342753f, 
    -0.16103271f, -0.17330207f, 0.19449170f, 0.26263791f, -0.04902807f, -0.01794025f, -0.12315919f, -0.31949818f, 
    -0.17428064f, -0.01148618f, -0.25779149f, 0.19056207f, -0.06778721f, 0.17455073f, -0.00439753f, 0.03965775f, 
    -0.20939846f, -0.04060988f, -0.08116712f, 0.02944899f, -0.06275027f, -0.08442885f, -0.12787679f, -0.01018627f, 
    -0.04777028f, -0.02135477f, 0.03482036f, -0.07788635f, 0.13794176f, 0.02006872f, 0.05880216f, 0.09229012f, 
    -0.12242726f, 0.01240683f, -0.07664419f, 0.00249734f, -0.45717362f, -0.00461253f, -0.02407580f, 0.00630487f, 
    0.00214208f, 0.08030482f, 0.01488952f, 0.01124812f, -0.07006794f, -0.10517567f, 0.17571303f, 0.03267758f, 
    0.09494846f, -0.07513037f, 0.07574418f, -0.09327495f, -0.23749201f, -0.21808006f, 0.10538554f, 0.08669791f, 
    0.04323729f, 0.15831226f, 0.07032390f, 0.04996810f, 0.01547863f, 0.07517133f, -0.04977376f, 0.25005242f, 
    -0.13329038f, -0.17039214f, -0.01710499f, 0.21838395f, 0.14609505f, -0.03065126f, 0.03884052f, -0.02391021f, 
    -0.02612684f, -0.09987261f, 0.10247607f, 0.08839727f, 0.08006300f, -0.02561728f, -0.31512630f, -0.15624124f, 
    0.06529006f, -0.04329333f, 0.04190192f, -0.04136996f, 0.13788263f, 0.12234129f, 0.10025172f, 0.09690899f, 
    0.03775805f, 0.01217296f, -0.12211089f, -0.30606893f, 0.16052781f, -0.01081039f, 0.09349851f, 0.07308725f, 
    0.10063011f, -0.02849454f, 0.03222477f, -0.17754003f, -0.06242028f, -0.09852596f, -0.04745140f, 0.05594384f, 
    -0.03106193f, -0.05423653f, 0.09486454f, 0.00556874f, 0.14014147f, 0.01228708f, -0.05965023f, -0.12171689f, 
    0.01130200f, -0.14065000f, 0.05473251f, 0.14046352f, 0.17367978f, 0.06085099f, -0.03412327f, -0.22315599f, 
    0.04378739f, -0.25062102f, 0.01319435f, 0.25620332f, 0.02484159f, 0.08733780f, -0.14569439f, -0.08446628f, 
    -0.09690138f, -0.16472329f, -0.11148164f, -0.06710222f, 0.05601513f, 0.15060428f, 0.21640381f, -0.09676446f, 
    -0.17906813f, 0.50177598f, 0.06843123f, 0.22852997f, 0.32904515f, 0.15458807f, -0.15751770f, 0.37483758f, 
    -0.00031916f, 0.02587881f, 0.01510134f, 0.01858718f, 0.02309520f, -0.05015609f, -0.04608918f, -0.02606230f, 
    -0.04991283f, -0.01020293f, 0.04468910f, -0.01756260f, -0.04513957f, -0.05354432f, -0.06522683f, 0.05153525f, 
    -0.01764101f, -0.00500290f, -0.02076457f, -0.04867918f, 0.04007160f, 0.01322489f, 0.00123583f, -0.00362507f, 
    -0.03535815f, -0.05155197f, 0.00153802f, 0.01784619f, 0.00881225f, -0.01005847f, -0.04837597f, -0.05193074f, 
    -0.03025323f, -0.05355801f, -0.02031751f, 0.01007207f, -0.03452031f, -0.04371942f, -0.02212461f, -0.03647834f, 
    -0.03045242f, -0.02543445f, -0.00840320f, -0.01244698f, -0.03467432f, 0.01253350f, -0.05591580f, 0.05204013f, 
    -0.05887160f, -0.01060284f, 0.02731627f, -0.03316453f, 0.04393876f, -0.01370558f, 0.04608432f, 0.03122602f, 
    -0.03565067f, -0.05317043f, 0.01304755f, -0.03526541f, 0.01324624f, 0.03909302f, -0.01531162f, 0.04205873f, 
    -0.06559183f, 0.04071102f, -0.02377764f, -0.02481178f, 0.00114616f, 0.04171003f, -0.04650177f, 0.00239987f, 
    -0.06234320f, -0.00142004f, 0.04180373f, -0.05809055f, -0.01997085f, -0.02400597f, -0.00280551f, 0.04471868f, 
    -0.06521370f, -0.02427011f, 0.03617999f, 0.01589143f, -0.04711812f, -0.04002912f, -0.04766537f, 0.04773681f, 
    0.04676630f, -0.02512268f, 0.04797621f, -0.05732115f, -0.03238945f, -0.04277357f, -0.03993064f, 0.01507289f, 
    0.02793094f, -0.03137675f, -0.00065274f, -0.03401943f, -0.04168578f, 0.03008945f, -0.05728408f, -0.00721295f, 
    0.03382067f, -0.02144083f, -0.02756075f, 0.01426545f, 0.02178492f, -0.03613687f, 0.01755721f, -0.01462283f, 
    0.04492486f, -0.01925584f, 0.01947217f, -0.02680450f, -0.06586145f, -0.03155182f, -0.05046132f, 0.04235803f, 
    -0.05196809f, 0.04947729f, -0.01709207f, -0.05304939f, -0.04385607f, -0.02621429f, -0.01878608f, -0.04052265f, 
    0.04366920f, -0.03284457f, 0.03560617f, -0.02703676f, 0.04524365f, 0.00478262f, -0.01034495f, -0.03587734f, 
    -0.02236239f, 0.02203683f, 0.00578139f, -0.00378664f, 0.04816170f, 0.03454663f, -0.02889973f, -0.02146025f, 
    0.01040275f, -0.04229306f, -0.03947545f, 0.03990659f, 0.00790154f, -0.00577078f, -0.05708602f, 0.02789910f, 
    0.01431590f, -0.00339238f, -0.04017229f, -0.02613533f, -0.02095785f, 0.04176600f, -0.00416629f, -0.05268157f, 
    0.02081443f, -0.00211555f, 0.01990089f, 0.00323078f, 0.05168338f, -0.04629654f, -0.03376150f, -0.02768410f, 
    -0.01097049f, 0.03840524f, 0.03484304f, 0.01056875f, -0.01216221f, 0.01637902f, -0.01565114f, -0.04695429f, 
    0.02369082f, 0.04084453f, 0.01820139f, -0.02027191f, 0.00270817f, -0.02647416f, 0.04053160f, -0.02215730f, 
    -0.05773897f, 0.04117673f, 0.03110338f, -0.01308633f, 0.01592674f, -0.04583735f, -0.01836367f, 0.05441796f, 
    -0.03863015f, -0.05279697f, 0.01107871f, -0.05521430f, -0.03898713f, -0.05048561f, -0.02025754f, 0.02644398f, 
    -0.03093927f, 0.02940914f, -0.00991926f, 0.02185535f, 0.00525351f, 0.03721387f, -0.02991232f, -0.03087813f, 
    -0.05311787f, 0.02536448f, -0.06291974f, -0.04120925f, 0.02713697f, 0.02327753f, 0.03957324f, 0.01687507f, 
    0.01647980f, 0.03721955f, -0.04279582f, -0.04822734f, 0.01775254f, -0.00152271f, 0.00762440f, -0.03371628f, 
    0.03586651f, -0.00531430f, -0.00897866f, -0.03933117f, 0.04348493f, 0.05821954f, -0.04008845f, 0.03052117f, 
    -0.05524414f, -0.05472058f, -0.01303201f, -0.01003837f, -0.02272796f, -0.03191272f, 0.02888251f, 0.01528992f, 
    0.04739625f, -0.04169715f, -0.03707595f, -0.01486596f, 0.02736717f, -0.03236987f, 0.01409562f, 0.04684589f, 
    0.00754569f, -0.03009513f, -0.03385594f, -0.05227758f, 0.02045001f, 0.01840444f, -0.05972501f, 0.04622826f, 
    -0.01828192f, -0.02729795f, -0.01465486f, 0.01503380f, -0.02847649f, 0.01290952f, -0.00145325f, -0.03120503f, 
    0.01396770f, -0.02449061f, -0.02264355f, -0.02831684f, 0.00377558f, -0.00562765f, 0.00965469f, -0.05078762f, 
    0.00719144f, -0.00415760f, -0.03888260f, -0.02427680f, -0.04099343f, -0.04271181f, -0.02281220f, 0.03168319f, 
    0.01768204f, 0.00270614f, 0.04469877f, 0.00704359f, 0.01563564f, -0.03156062f, -0.00125868f, 0.04826380f, 
    -0.05145155f, 0.04291220f, 0.03113770f, -0.02039205f, 0.02905364f, -0.02655219f, 0.00893367f, 0.04187352f, 
    -0.03264831f, 0.02420224f, 0.00564127f, 0.01346135f, 0.01782496f, 0.05030385f, -0.05556586f, 0.04774253f, 
    0.04858012f, -0.01377401f, -0.00723948f, 0.02207832f, -0.05853551f, 0.01021725f, -0.00822873f, -0.00620884f, 
    0.03995137f, -0.03876832f, 0.03518267f, -0.00189269f, 0.02956070f, -0.02303275f, 0.05084731f, -0.06334388f, 
    -0.03908289f, -0.03520624f, 0.00543703f, 0.03156040f, 0.01485265f, -0.00500454f, 0.02551953f, 0.01369651f, 
    0.03893021f, -0.05571177f, 0.01176677f, -0.02924517f, -0.05000656f, -0.05223207f, 0.04125637f, 0.00987441f, 
    -0.05819767f, -0.02722034f, -0.06128062f, 0.04699684f, 0.04674139f, 0.04621018f, -0.05817470f, -0.05718856f, 
    0.04592172f, -0.00784629f, 0.01177674f, 0.02937269f, -0.03764453f, -0.01722856f, -0.06701446f, -0.03394325f, 
    0.04288679f, 0.04408261f, -0.05892755f, 0.00891174f, -0.01642315f, -0.04895018f, -0.00929276f, 0.02501070f, 
    -0.03337709f, -0.00583668f, -0.00642264f, -0.04392768f, -0.02959727f, -0.04548297f, -0.00735009f, -0.04595610f, 
    -0.02586698f, -0.04994779f, -0.02008453f, -0.00310789f, -0.01109888f, 0.04334959f, -0.05655091f, 0.00651976f, 
    0.01183487f, 0.01751258f, -0.05701566f, -0.05492011f, 0.04136663f, 0.04910805f, 0.04552500f, 0.04358349f, 
    -0.00800785f, -0.04489421f, -0.00829906f, -0.00591188f, -0.06507659f, 0.01370148f, 0.03283697f, 0.05154784f, 
    -0.01863661f, -0.01271644f, 0.03023316f, -0.05487009f, 0.01569663f, -0.03403839f, -0.04312598f, 0.03110484f, 
    -0.00633183f, 0.00354061f, 0.00318231f, -0.01134602f, -0.01784861f, -0.05050997f, -0.04455516f, -0.03817010f, 
    0.01537646f, -0.02039452f, 0.03889730f, -0.00535773f, -0.03149195f, 0.02899754f, -0.03204735f, -0.00819819f, 
    -0.02669035f, 0.03651435f, -0.01919705f, -0.00919594f, -0.02090870f, -0.03240589f, 0.04769730f, -0.01071792f, 
    -0.06209706f, -0.05564482f, -0.00451408f, -0.04544049f, 0.02141079f, -0.05537718f, -0.01775093f, 0.00619806f, 
    0.02730884f, 0.01413054f, -0.06307997f, -0.01440769f, 0.00095536f, -0.01573768f, -0.02293828f, -0.04298406f, 
    -0.05831061f, 0.04255239f, 0.02410884f, 0.03999069f, 0.02337797f, -0.04850757f, -0.03334515f, 0.01383312f, 
    0.01929472f, 0.04060125f, 0.01055501f, -0.06114144f, -0.02223381f, 0.01262823f, -0.02416530f, 0.00532702f, 
    0.04388238f, -0.02995506f, -0.01055988f, -0.01734321f, -0.04785065f, -0.02373725f, 0.01067459f, -0.03922103f, 
    -0.02202188f, 0.01555669f, -0.03193336f, -0.06322916f, -0.02372835f, -0.05501616f, 0.03222330f, -0.05364751f, 
    -0.01838582f, 0.04482862f, -0.05129337f, 0.04292552f, -0.02159911f, 0.03280104f, -0.01888376f, -0.01854396f, 
    -0.04884938f, -0.02149053f, 0.03577365f, -0.00745993f, -0.02841148f, 0.04424777f, -0.03112898f, -0.04674465f, 
    -0.05971797f, -0.00187656f, 0.03579069f, -0.03959038f, -0.03787401f, -0.03831786f, 0.04246833f, 0.02339318f, 
    -0.02480029f, 0.01844558f, -0.05494049f, -0.05142838f, -0.04463032f, 0.01848237f, 0.01859150f, -0.01440834f, 
    0.00920755f, -0.01055678f, -0.02393919f, -0.02665116f, -0.03033656f, -0.00375833f, 0.01295248f, -0.05720256f, 
    -0.00573613f, -0.03030789f, -0.02148570f, -0.06835986f, 0.00480913f, 0.00641437f, -0.02650366f, -0.05206967f, 
    0.04614209f, 0.01535112f, -0.03293183f, -0.03217334f, -0.05579806f, -0.06319002f, -0.04946038f, 0.05002498f, 
    -0.04136005f, 0.04375555f, -0.03977111f, 0.02259665f, -0.04566354f, -0.04938421f, -0.04950255f, 0.04972041f, 
    0.04447635f, -0.03856543f, -0.04954799f, -0.05846201f, 0.03748595f, -0.05018992f, -0.03401036f, -0.04484343f, 
    0.00106323f, 0.04508391f, -0.02417243f, -0.01314756f, -0.06408259f, 0.00731859f, -0.00020058f, -0.01016311f, 
    -0.04273411f, 0.02143575f, -0.02105483f, 0.00512800f, -0.02749790f, -0.02707891f, -0.00785028f, -0.02910377f, 
    0.01607737f, -0.02302619f, -0.00693275f, -0.04426309f, 0.02471137f, -0.03969550f, -0.05046127f, -0.00728550f, 
    0.03562948f, 0.00399118f, -0.00649359f, 0.03071027f, 0.00569828f, -0.00422587f, 0.04501385f, 0.02271724f, 
    0.33007979f, -0.11376437f, 0.02926370f, -0.01213547f, 0.05312366f, -0.03507159f, -0.04870967f, -0.08812825f, 
    -0.05360248f, -0.04683835f, -0.12058885f, -0.25061816f, -0.11323240f, -0.04227804f, 0.20932238f, 0.06204765f, 
    0.14484474f, 0.06370281f, -0.04061515f, 0.01742311f, -0.24573261f, -0.00199825f, -0.01650424f, -0.17555533f, 
    -0.05500672f, -0.06705455f, -0.03520831f, -0.25444746f, 0.19303389f, -0.34496412f, 0.16640046f, 0.01722712f, 
    -0.17054488f, -0.10877008f, 0.11647978f, -0.27930689f, -0.17753971f, 0.04995707f, -0.03563853f, 0.10859501f, 
    0.02027434f, 0.00524402f, -0.12114611f, 0.09844226f, 0.13155097f, -0.02430032f, -0.10294907f, 0.18590631f, 
    0.07041585f, 0.06273668f, 0.00200633f, -0.05357683f, 0.06641291f, 0.05091542f, 0.01554781f, 0.07348190f, 
    0.22071224f, -0.00399092f, 0.04082691f, 0.07229232f, 0.07584721f, 0.04497753f, 0.02711333f, 0.14128213f, 
    0.16537815f, 0.13704187f, -0.01753122f, 0.16999701f, -0.04334954f, 0.07652862f, -0.11682541f, 0.06452374f, 
    -0.12758338f, 0.00889628f, 0.11803772f, -0.00197746f, -0.08170519f, 0.03111362f, 0.06966294f, -0.11012842f, 
    -0.11270156f, 0.04077277f, 0.21268852f, -0.27987286f, -0.09402344f, 0.11540593f, 0.34150252f, 0.04571602f, 
    0.22628213f, -0.07038248f, -0.05813437f, -0.07747912f, -0.18161957f, -0.07973214f, 0.05447486f, 0.23754267f, 
    -0.06146475f, 0.15376109f, -0.07149089f, -0.32747564f, 0.06217720f, -0.05203304f, 0.06995603f, 0.14346094f, 
    0.11547909f, 0.06671863f, -0.15713501f, 0.01860095f, 0.11099724f, -0.18159360f, -0.01955421f, -0.12572256f, 
    0.12965479f, -0.21347409f, -0.01516741f, 0.02768498f, 0.05149889f, 0.03921445f, -0.06859031f, -0.11000199f, 
    0.07972980f, -0.05556860f, 0.10654370f, -0.12256209f, 0.17252511f, 0.14263743f, 0.12299125f, -0.05752097f, 
    0.09022712f, 0.09368828f, 0.01563425f, -0.09875125f, 0.17229617f, -0.01652539f, 0.07408659f, 0.01991561f, 
    -0.13214006f, -0.02006426f, -0.00379119f, 0.02852763f, -0.18375528f, 0.07692968f, -0.09990892f, -0.08926120f, 
    0.07470837f, -0.17606537f, -0.18852150f, -0.10764315f, 0.06635131f, -0.04054125f, -0.04744323f, 0.06441072f, 
    0.10197770f, -0.01372582f, -0.15143055f, -0.25959304f, -0.01275273f, -0.07172465f, 0.02486167f, 0.05502200f, 
    -0.00064579f, 0.17977075f, -0.04839551f, -0.08815162f, -0.20114952f, 0.07822528f, -0.03810057f, 0.08670001f, 
    -0.08965774f, 0.03393612f, -0.07441341f, -0.04923502f, 0.05665794f, 0.23462914f, 0.20238531f, 0.03982825f, 
    0.13875109f, 0.01224017f, 0.09313525f, 0.20501825f, 0.09369539f, 0.06027867f, 0.31345764f, 0.02292743f, 
    0.03912967f, -0.05900278f, -0.00016022f, -0.07246591f, 0.09367618f, -0.03955759f, -0.04950120f, 0.08264973f, 
    0.00507931f, 0.07970710f, -0.19112515f, -0.18941368f, -0.02075964f, 0.16124913f, -0.15987661f, -0.03801042f, 
    -0.10571346f, -0.05104559f, 0.01165297f, 0.16125771f, -0.05894549f, 0.01147364f, 0.05849787f, -0.04996884f, 
    0.23178835f, 0.33873272f, 0.08210931f, 0.18122955f, 0.05783112f, -0.06002662f, -0.12666619f, -0.16022997f, 
    0.05812314f, -0.21690615f, -0.06909397f, -0.08829129f, 0.10477667f, -0.06081728f, 0.02258947f, -0.09482629f, 
    0.20519845f, -0.14510278f, -0.09784981f, -0.23884606f, 0.08993376f, -0.00531134f, 0.05511209f, -0.16039070f, 
    -0.02353133f, -0.00562101f, 0.11139473f, 0.13686526f, 0.36150354f, -0.11674073f, 0.07343064f, -0.04214353f, 
    -0.01683106f, 0.01682247f, 0.08060525f, 0.15173824f, 0.09348003f, 0.34180820f, -0.00504001f, 0.02786966f, 
    0.05791928f, 0.03340395f, -0.03915429f, 0.06454557f, 0.06540678f, 0.16099401f, 0.31172961f, -0.10240500f, 
    0.00896017f, 0.01323567f, 0.19806056f, 0.02649274f, 0.02990879f, -0.07719909f, -0.11973605f, 0.29113162f, 
    0.00649181f, 0.12921655f, -0.03136066f, -0.18094678f, -0.05114619f, -0.27314055f, 0.33220032f, 0.15966693f, 
    0.34537584f, 0.00528014f, -0.01243100f, -0.02548830f, 0.00586082f, 0.03046730f, 0.03513363f, -0.06993103f, 
    0.11647903f, -0.16710211f, 0.04072512f, 0.00130216f, -0.03105974f, 0.12454264f, -0.10719738f, -0.08020974f, 
    0.42127579f, 0.60136598f, 0.46016246f, -0.02677790f, 0.07638744f, 0.17010075f, 0.13672103f, 0.05048805f, 
    0.06027293f, 0.04592381f, 0.08689590f, 0.05167134f, -0.05786495f, -0.04379967f, 0.02645030f, -0.06847723f, 
    0.05136106f, -0.00313227f, 0.19793740f, -0.01245180f, 0.17360149f, 0.03978920f, -0.06901946f, 0.06576088f, 
    0.22802135f, 0.13337214f, -0.05504794f, -0.08331817f, 0.25718591f, -0.08651662f, 0.16128768f, 0.02510507f, 
    0.15095513f, -0.28741494f, -0.22114253f, -0.06842622f, -0.07978021f, 0.02890704f, -0.07043777f, 0.08950644f, 
    0.01499533f, 0.05832969f, 0.07291777f, 0.09697731f, 0.00640969f, 0.16777064f, 0.15770929f, 0.17235902f, 
    -0.06565975f, -0.19958009f, -0.02679765f, -0.05380255f, -0.15317479f, -0.13206817f, 0.06417380f, -0.28904465f, 
    0.05645606f, 0.08947608f, -0.25235671f, 0.01301754f, -0.05974654f, 0.05701523f, -0.02552283f, 0.13806143f, 
    -0.03918879f, -0.13577937f, 0.12298157f, -0.16060118f, 0.03262169f, 0.06930025f, -0.08047976f, -0.37315652f, 
    0.04049386f, 0.03561440f, 0.05171648f, 0.12345193f, 0.03505553f, -0.14694287f, -0.08521351f, 0.06888336f, 
    -0.25060147f, -0.29000941f, -0.23118483f, -0.15854439f, 0.19882064f, 0.12481060f, -0.08664735f, -0.22185510f, 
    -0.02910447f, -0.19991501f, 0.18954466f, 0.04830432f, 0.22247171f, -0.19593097f, -0.28221649f, -0.20834613f, 
    -0.07685302f, 0.01763047f, -0.07023498f, -0.37364784f, -0.42959198f, -0.56158131f, 0.13448635f, -0.13239956f, 
    -0.13036178f, 0.10435768f, 0.06845926f, -0.23153213f, 0.14858106f, -0.08812140f, 0.03253543f, 0.06207550f, 
    0.23047519f, -0.14342852f, -0.14719434f, -0.27033004f, -0.18504062f, 0.09773903f, -0.06308570f, 0.12797037f, 
    -0.00808891f, 0.06247336f, -0.05886996f, -0.06273829f, 0.03701245f, -0.15474132f, -0.12057829f, -0.20992920f, 
    0.20174542f, 0.04113672f, -0.12949361f, -0.17030476f, 0.06385195f, -0.19833745f, -0.12707114f, 0.02293325f, 
    0.04728970f, 0.03831248f, -0.07967675f, 0.08962055f, -0.04218837f, 0.13322504f, 0.16444314f, -0.15040287f, 
    0.08208296f, 0.14693040f, 0.37797466f, -0.13601674f, 0.02658689f, -0.13586940f, -0.07956697f, -0.03626421f, 
    -0.13665396f, -0.12859309f, 0.22319572f, 0.12364943f, 0.16287409f, 0.01096190f, -0.11795221f, -0.01686052f, 
    0.01558143f, -0.22039534f, 0.05455386f, 0.01917785f, -0.09444380f, 0.16280892f, 0.10182336f, 0.04563612f, 
    0.13712576f, -0.02124083f, 0.06046237f, 0.24904124f, 0.04255462f, -0.00031039f, 0.05165983f, -0.08584640f, 
    -0.16285458f, 0.08473329f, 0.09743334f, -0.03036960f, 0.03575139f, -0.52030194f, -0.07586034f, -0.05340210f, 
    -0.09794934f, -0.13590732f, -0.06442706f, -0.01000146f, 0.07117331f, 0.46892875f, 0.21812207f, 0.06932301f, 
    -0.08713081f, -0.15038472f, -0.24511433f, -0.06907357f, -0.13840124f, -0.20236073f, 0.23544973f, 0.11639418f, 
    -0.02374992f, -0.18129051f, -0.24285987f, -0.18437581f, 0.01277401f, 0.19699903f, -0.05268839f, -0.17533000f, 
    0.12949519f, 0.07399051f, 0.00876509f, 0.00484958f, -0.00974717f, -0.01353256f, 0.07655683f, -0.13322002f, 
    0.09919836f, 0.10824728f, 0.07752834f, -0.07772225f, -0.17266151f, -0.17640854f, -0.05244410f, -0.02767086f, 
    -0.23467332f, 0.25671393f, 0.13631997f, 0.13105671f, -0.29897705f, -0.37529007f, -0.33603859f, -0.05529673f, 
    0.05804022f, 0.07025573f, 0.18872780f, 0.43299928f, -0.36309761f, -0.09331867f, 0.05598644f, 0.01916053f, 
    0.04487544f, 0.08340143f, -0.17659479f, -0.31283110f, -0.29891679f, -0.03568117f, -0.09344913f, -0.10831478f, 
    0.00587738f, 0.17379531f, -0.07409430f, 0.03227155f, 0.07975632f, -0.01923322f, -0.11832296f, 0.03525089f, 
    0.01282366f, 0.01334982f, 0.04478232f, 0.15787652f, -0.17274541f, 0.13300171f, 0.19307964f, 0.07272222f, 
    0.13651147f, 0.11859829f, 0.09142144f, 0.13463284f, 0.03458725f, 0.09040886f, 0.43986413f, 0.04543210f, 
    0.24871387f, 0.20237996f, -0.05654685f, -0.13308527f, 0.04477614f, 0.02177612f, 0.08304507f, -0.26061004f, 
    0.04457910f, -0.12033814f, 0.12758830f, -0.06121950f, 0.01150511f, 0.11717922f, -0.02567252f, -0.15738569f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.06120861f, -0.02541570f, 0.09695177f, 0.04092458f, 0.22681192f, 0.08418587f, 0.04919041f, 0.09973393f, 
    0.23805629f, -0.07494237f, -0.00631851f, -0.04961622f, 0.07222568f, 0.07172272f, 0.20231596f, 0.21486551f, 
    -0.03143743f, 0.27593502f, 0.15463223f, 0.17458543f, -0.05228763f, -0.22940800f, 0.04687608f, 0.21214552f, 
    0.07301533f, 0.09909629f, -0.06078606f, 0.00962600f, -0.02622116f, -0.06564452f, 0.00697450f, -0.01648162f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.18502960f, -0.14421974f, 0.14826083f, 0.28595418f, -0.06582213f, 0.12752920f, -0.24666843f, 0.16984248f, 
    -0.03347353f, -0.23528950f, 0.04043071f, -0.02984066f, -0.22688319f, 0.08283307f, 0.22690193f, 0.45691285f, 
    -0.17391324f, -0.05266441f, -0.33581111f, 0.33882490f, 0.02787355f, 0.22209358f, -0.14764909f, 0.23065256f, 
    -0.28247356f, -0.56228989f, -0.16600649f, -0.30164450f, 0.14987332f, 0.16937138f, 0.11198504f, -0.10853336f, 
    -0.07612434f, -0.15776695f, -0.16093405f, -0.08062828f, -0.12170219f, -0.12945189f, 0.03192407f, -0.12325045f, 
    0.10164987f, -0.04556901f, -0.00142971f, -0.14055185f, -0.15799794f, -0.16244830f, -0.18236618f, -0.16937786f, 
    0.03904857f, -0.02516377f, 0.14340523f, 0.00149006f, 0.16592890f, 0.05447843f, 0.12003499f, 0.05899424f, 
    -0.03779753f, -0.12089597f, -0.18135238f, -0.06912246f, -0.02480005f, 0.01461690f, -0.05980673f, 0.00927653f, 
    0.00282039f, 0.06522294f, -0.15292510f, 0.16744931f, -0.07822638f, 0.35602939f, -0.03916783f, 0.02418402f, 
    0.02844151f, 0.34540972f, 0.04527596f, -0.16697358f, 0.27631605f, -0.22693813f, -0.10906472f, -0.00577881f, 
    0.12316360f, -0.07027592f, 0.08305978f, -0.14233345f, -0.00172185f, -0.16466884f, 0.15420239f, -0.09726302f, 
    0.04817291f, 0.57250541f, 0.02443029f, -0.19136089f, -0.01366464f, -0.05993646f, 0.01596715f, -0.06307068f, 
    -0.58928341f, 0.09747899f, 0.06484398f, -0.01057344f, 0.28879377f, -0.07000539f, 0.33880472f, 0.11313016f, 
    0.25622022f, -0.26521587f, 0.09170850f, 0.16886090f, -0.04337487f, 0.32466629f, -0.08704241f, -0.34220082f, 
    0.11755211f, 0.26250535f, 0.34045532f, 0.66582149f, -0.15431011f, 0.01788060f, -0.18910235f, -0.15909475f, 
    -0.01429605f, 0.12106201f, -0.14433694f, -0.12183750f, -0.02193632f, -0.08403978f, 0.35172561f, 0.28667042f, 
    0.30229574f, 0.07714079f, 0.20835887f, 0.11007900f, -0.38676387f, -0.47396538f, -0.01957628f, -0.21035036f, 
    -0.07533557f, -0.41931295f, 0.06257950f, 0.09073399f, -0.12706454f, 0.44959238f, -0.39837128f, 0.23161037f, 
    0.12366068f, -0.11020172f, 0.15598629f, -0.02552523f, -0.00413009f, 0.14853856f, 0.29368019f, -0.05289396f, 
    -0.13016267f, -0.13125995f, -0.15523870f, -0.47098932f, 0.01933476f, 0.02312444f, 0.27679086f, -0.07100912f, 
    -0.27515045f, 0.08715610f, 0.06399184f, -0.15281019f, -0.11683927f, -0.27804008f, 0.05954079f, -0.14910702f, 
    0.13865878f, -0.08802126f, -0.11448272f, 0.02204532f, 0.18629993f, 0.36141533f, -0.42319718f, 0.26026055f, 
    0.08510945f, 0.06107190f, 0.29843247f, 0.58503985f, 0.05585902f, 0.46369287f, -0.12840696f, 0.15039204f, 
    0.40201780f, 0.01379076f, 0.03324521f, -0.03622255f, 0.05101302f, 0.01227526f, 0.14491461f, 0.06028337f, 
    -0.09553943f, 0.12460102f, -0.19006616f, 0.03558680f, -0.18102399f, -0.03653377f, 0.17245921f, -0.11763104f, 
    0.12212450f, -0.10140070f, 0.02270655f, -0.00486962f, -0.02047421f, -0.17212713f, 0.26263085f, -0.01337336f, 
    -0.08961417f, 0.23942272f, 0.05186990f, 0.25119808f, -0.00755472f, 0.13770293f, 0.01836415f, -0.21141642f, 
    -0.31906405f, 0.40451634f, -0.10080156f, -0.04642200f, 0.04538008f, 0.17140280f, -0.00305853f, -0.33280709f, 
    -0.13553192f, -0.09359695f, 0.29667816f, 0.28897771f, 0.12731224f, 0.36176527f, -0.06304162f, 0.24644133f, 
    -0.21004929f, -0.09525154f, 0.13422295f, -0.06205940f, -0.26261309f, 0.31031623f, -0.19396895f, -0.06891215f, 
    -0.09502021f, 0.36280680f, 0.08914295f, -0.36187872f, -0.10573564f, -0.20094042f, 0.56251121f, -0.34130895f, 
    -0.14566192f, -0.31149027f, -0.10992429f, -0.20337437f, 0.03888983f, -0.13903053f, -0.16006009f, -0.49937847f, 
    -0.08771106f, 0.03089471f, 0.29526940f, 0.22374333f, -0.01803063f, -0.19503394f, -0.22977498f, -0.04404613f, 
    0.06006178f, 0.24384910f, -0.00260086f, -0.15603556f, 0.08404173f, -0.21722405f, -0.05776810f, -0.18029085f, 
    -0.16601439f, 0.24898575f, -0.39996251f, 0.05104364f, -0.04131174f, 0.56169420f, 0.50120336f, 0.20921597f, 
    -0.10104024f, 0.13058375f, 0.17561728f, 0.05929033f, -0.01736211f, 0.10552253f, -0.15610768f, 0.05743228f, 
    -0.00496989f, -0.17835602f, 0.41768834f, -0.07475013f, -0.23030187f, 0.11666340f, -0.23492940f, 0.25183046f, 
    -0.13291882f, 0.05097837f, -0.01131960f, -0.06608526f, 0.01758409f, 0.21420227f, 0.07186742f, 0.20447719f, 
    0.06374083f, 0.01837608f, 0.02981273f, -0.12911560f, -0.15130275f, -0.07096774f, 0.45359188f, -0.30349979f, 
    0.12019412f, -0.41107887f, -0.09806332f, -0.30555335f, -0.04571255f, -0.13190213f, -0.04187974f, -0.78597164f, 
    0.11203217f, -0.14001405f, -0.17125039f, 0.23667434f, -0.07274371f, -0.15619627f, 0.06189379f, -0.01540834f, 
    0.22675867f, 0.33597678f, 0.05829193f, -0.01398261f, -0.14727648f, 0.26311788f, 0.13984923f, 0.21917613f, 
    0.07082219f, -0.25584248f, 0.32761481f, -0.06774980f, -0.07790188f, -0.47406483f, -0.07047259f, 0.14705746f, 
    -0.19916527f, 0.34236452f, 0.15576902f, -0.02835107f, -0.08454851f, 0.12368805f, 0.19370300f, -0.12701404f, 
    -0.34840530f, -0.16113023f, 0.15729648f, 0.05213592f, 0.32163370f, 0.15069599f, 0.51540649f, -0.29034263f, 
    0.15824905f, -0.04969004f, -0.16116670f, 0.14677595f, 0.13852811f, -0.10922953f, -0.03339838f, -0.15275195f, 
    -0.15916367f, -0.02052432f, -0.05957552f, -0.04309440f, -0.04615029f, 0.36449525f, 0.18116845f, 0.43491369f, 
    -0.17859398f, -0.05729590f, -0.16431437f, 0.11402275f, -0.10021367f, 0.09357462f, 0.04636928f, -0.10475595f, 
    0.10349302f, -0.02272876f, 0.20517850f, 0.20230153f, -0.06603410f, 0.08733409f, -0.13620602f, 0.19102997f, 
    -0.07434522f, 0.12380601f, -0.01989133f, -0.09132496f, -0.22886604f, 0.14033793f, -0.19324316f, 0.48457661f, 
    0.01363448f, 0.20412433f, -0.37738547f, -0.67713255f, 0.08457654f, 0.03205674f, 0.48317218f, 0.38682491f, 
    0.00486640f, -0.11965863f, 0.02158866f, 0.01801861f, -0.16697665f, -0.07756433f, -0.30726153f, -0.17303258f, 
    -0.00554002f, 0.09276007f, 0.35171443f, 0.01733981f, -0.21062316f, 0.10712926f, -0.01594824f, 0.37261006f, 
    -0.23925486f, -0.11928481f, 0.02032066f, 0.06171187f, -0.04912917f, 0.05732516f, 0.26173353f, -0.49828514f, 
    -0.12160204f, 0.14107952f, -0.12437479f, -0.21095143f, -0.08912777f, 0.03405908f, 0.25175607f, -0.21273772f, 
    -0.00406079f, 0.23644747f, -0.10100988f, -0.05312918f, 0.09099580f, -0.04279410f, -0.13891546f, 0.02353535f, 
    -0.18648551f, 0.13379189f, -0.10725214f, 0.32793656f, -0.03636024f, 0.18212961f, 0.19890167f, -0.08899810f, 
    0.02335621f, -0.10720927f, 0.09735814f, -0.07939638f, -0.38668457f, 0.13884421f, 0.06188747f, -0.48677522f, 
    -0.05539236f, 0.22408488f, -0.19952518f, 0.29866681f, -0.06562508f, -0.27318683f, 0.21584813f, 0.13201109f, 
    -0.05198471f, 0.49787936f, 0.06429376f, -0.15629679f, 0.04773496f, 0.16059172f, 0.35266015f, 0.23304650f, 
    -0.12722880f, -0.14601564f, 0.39871374f, 0.03358508f, 0.05447742f, -0.22916929f, -0.38719827f, 0.20893313f, 
    0.37809938f, 0.08412485f, 0.04348331f, 0.00928636f, 0.24821812f, -0.07386283f, 0.23763509f, -0.16698919f, 
    -0.15445128f, 0.34453702f, -0.14142460f, -0.25385168f, -0.09970056f, -0.13438272f, 0.07218574f, -0.24235873f, 
    -0.01457279f, -0.21370511f, 0.05326517f, -0.05952604f, -0.01137488f, 0.14624168f, 0.08253296f, 0.02796908f, 
    0.02613055f, -0.13083817f, -0.18811163f, -0.08657405f, 0.01167551f, -0.06436484f, -0.04222374f, 0.05629583f, 
    -0.18144064f, -0.20240276f, -0.01343262f, 0.08699415f, -0.09005784f, -0.11891917f, 0.05978983f, -0.12375481f, 
    -0.02994732f, -0.10360853f, -0.10725412f, -0.06180760f, -0.00147044f, 0.01902799f, 0.01126078f, -0.18104447f, 
    -0.04926774f, -0.03942256f, 0.13709904f, 0.07671934f, 0.05949584f, 0.07686203f, 0.07683229f, -0.13473858f, 
    -0.36455342f, 0.06612972f, 0.36702079f, -0.19842547f, 0.31889254f, -0.02878396f, -0.04005056f, 0.18704872f, 
    0.29974958f, -0.11378475f, -0.14321736f, -0.10967174f, -0.05573248f, 0.26074043f, -0.04949539f, 0.24562861f, 
    -0.09974273f, 0.39215991f, -0.17780909f, 0.08143956f, -0.04974144f, -0.25776637f, 0.35326186f, -0.01358827f, 
    0.05288907f, -0.30685857f, 0.03044208f, 0.11227161f, -0.09678856f, -0.12558244f, -0.14544733f, -0.30946913f, 
    -0.04908969f, -0.02930012f, 0.15676625f, 0.21391362f, -0.24279854f, -0.17270596f, -0.24202394f, 0.08316688f, 
    0.14203610f, 0.26548576f, 0.15051174f, 0.06202106f, 0.14076060f, 0.01138332f, -0.65201479f, 0.08386448f, 
    -0.01133386f, -0.37111783f, -0.15308662f, 0.40439910f, -0.02981612f, 0.39351907f, 0.37518498f, -0.29801294f, 
    0.02507318f, 0.36961406f, 0.08500717f, -0.46289206f, 0.06679349f, 0.16610336f, 0.34800968f, 0.36225319f, 
    -0.39927411f, -0.10843710f, 0.15423417f, -0.27733263f, -0.03626746f, 0.03454420f, -0.08987273f, 0.27564639f, 
    0.34233233f, -0.14769001f, 0.11794397f, 0.08349843f, -0.38410717f, 0.33688623f, -0.53773654f, -0.13868295f, 
    -0.06665214f, 0.10839136f, -0.26137292f, 0.31722757f, 0.01702558f, 0.12502740f, 0.45638141f, -0.15444849f, 
    -0.07753592f, 0.37663665f, -0.07462525f, -0.30428356f, -0.16388986f, 0.01771318f, 0.36828926f, 0.28402501f, 
    0.05574954f, -0.14302024f, -0.17898348f, 0.08522753f, 0.24394995f, -0.21029630f, 0.41556752f, -0.03793191f, 
    0.42255378f, 0.02963351f, 0.09080715f, -0.06340473f, -0.19692813f, 0.22393797f, 0.38183913f, 0.01946021f, 
    -0.07140464f, 0.05618542f, 0.29181308f, 0.03384972f, 0.04830628f, -0.11678274f, -0.40307319f, 0.23253343f, 
    -0.05639820f, -0.05534087f, 0.15495220f, 0.22715841f, -0.00679589f, 0.16270439f, -0.06163711f, -0.20732899f, 
    0.15631458f, 0.05441365f, 0.16746953f, -0.18132785f, 0.05960892f, 0.20092727f, 0.21534306f, 0.14282897f, 
    -0.26011765f, 0.15119007f, 0.13058266f, 0.14902708f, 0.23078547f, -0.16482191f, 0.01041811f, 0.37279007f, 
    -0.12560010f, -0.04901534f, 0.08986270f, -0.18606889f, 0.14939485f, 0.37336019f, 0.00169873f, -0.28202614f, 
    0.00404191f, 0.04671064f, -0.10188648f, -0.00848521f, 0.15083995f, -0.08312646f, -0.20085944f, -0.13211517f, 
    0.17129321f, -0.03274113f, -0.03342925f, 0.17218077f, -0.14374956f, 0.05999057f, -0.23073304f, 0.30084622f, 
    -0.00068589f, -0.24437079f, 0.09471373f, -0.18048841f, -0.19397698f, 0.33282968f, 0.42500451f, 0.18809117f, 
    -0.04169248f, 0.23779663f, 0.56081378f, -0.32976386f, 0.03783008f, -0.16714711f, -0.05142277f, -0.31385732f, 
    0.03990940f, 0.03085775f, -0.14483826f, -0.03453592f, 0.02427163f, 0.11613081f, -0.16964480f, -0.02675778f, 
    -0.01692296f, 0.10249701f, -0.16485268f, 0.18607424f, 0.15103903f, 0.02282041f, 0.16887441f, -0.33418933f, 
    0.10436868f, -0.03545864f, -0.04835933f, 0.07317963f, 0.25377622f, -0.11270339f, 0.11709228f, 0.00538874f, 
    -0.03800556f, -0.16624755f, -0.02444830f, 0.52129674f, 0.09036382f, 0.52227283f, -0.18581942f, -0.09292658f, 
    0.29114321f, 0.02370143f, 0.05891934f, 0.24296279f, 0.12673421f, -0.13410489f, 0.13412525f, -0.14239262f, 
    0.08140829f, 0.05756509f, 0.02123340f, -0.05336745f, 0.10395542f, 0.26270035f, 0.33860832f, 0.14859582f, 
    -0.28507721f, -0.05561285f, 0.12900199f, -0.15579219f, 0.21157484f, -0.09690206f, 0.17606889f, -0.28103450f, 
    0.06856352f, 0.06585117f, 0.23797144f, -0.14072515f, 0.00055098f, 0.20700696f, 0.14530708f, 0.19430789f, 
    -0.09382802f, -0.06295992f, -0.03510895f, -0.19843270f, -0.06594791f, 0.15774488f, -0.14901046f, -0.06589299f, 
    0.01582121f, 0.09969535f, 0.20004223f, -0.02557242f, -0.07762240f, 0.32399392f, -0.09356999f, -0.10887443f, 
    0.02712616f, 0.12298214f, -0.14437170f, 0.07986414f, -0.26030082f, 0.08419614f, -0.49830458f, 0.32816336f, 
    -0.15272659f, -0.10130791f, -0.22247601f, -0.24674170f, 0.09138073f, 0.08042333f, 0.11979273f, -0.13037014f, 
    0.05359384f, -0.38006830f, 0.05817116f, 0.01882108f, 0.13751206f, -0.03333215f, -0.07408330f, -0.03050366f, 
    0.01669487f, -0.05404442f, 0.28263441f, -0.16264853f, -0.06990732f, -0.06124309f, -0.24785809f, 0.29742762f, 
    -0.02006712f, 0.25571138f, -0.01763042f, -0.06545512f, 0.34006485f, -0.28518993f, -0.24273546f, -0.19408154f, 
    -0.10152823f, 0.19375715f, 0.31098408f, -0.25115588f, -0.06525198f, -0.28338078f, 0.23532391f, -0.06996270f, 
    0.17240508f, 0.06465226f, 0.04471143f, -0.12233966f, -0.12350266f, 0.12352759f, 0.01836702f, -0.00147017f, 
    0.24087137f, 0.13095605f, 0.25458828f, 0.00318992f, -0.20972569f, -0.20856372f, -0.24824086f, 0.25711599f, 
    -0.18337701f, -0.52768028f, -0.04217445f, -0.01548096f, 0.13252828f, 0.27081585f, 0.34314576f, 0.29659110f, 
    0.12824699f, -0.02003095f, 0.24693781f, -0.00047324f, -0.15927345f, 0.42491624f, 0.11473577f, -0.17018919f, 
    -0.31213221f, -0.29505864f, 0.14707702f, -0.41651976f, -0.11712551f, -0.10282167f, 0.19485724f, -0.44797722f, 
    0.14871374f, -0.15395850f, -0.02096158f, 0.23816371f, 0.00737215f, -0.20520493f, 0.03937554f, 0.11103877f, 
    0.13762689f, -0.08442838f, 0.13002415f, 0.16185762f, -0.47125909f, 0.27640191f, 0.43992171f, -0.05548345f, 
    -0.12085149f, 0.12260941f, 0.19189776f, 0.36503616f, 0.10184573f, -0.34745392f, -0.34003797f, 0.01165115f, 
    -0.18090944f, 0.14598185f, -0.01968411f, 0.09816171f, 0.01866371f, -0.04877899f, 0.24415609f, 0.22996910f, 
    -0.05768221f, -0.04839961f, 0.02400344f, 0.05884037f, 0.11409166f, 0.34500751f, 0.02374852f, -0.05594519f, 
    0.27616674f, -0.12231857f, 0.00055548f, 0.07967170f, 0.36712107f, -0.09534512f, -0.35536298f, 0.35741842f, 
    0.13367327f, -0.04647999f, 0.08007486f, 0.33932948f, 0.07374670f, -0.12814629f, 0.05083453f, 0.05673591f, 
    0.00105877f, -0.45208687f, -0.05157029f, 0.08011979f, 0.08448539f, -0.16858226f, 0.01666099f, -0.15966055f, 
    0.03663151f, -0.12085214f, 0.12216976f, -0.27235579f, -0.02528712f, -0.11831225f, 0.04216917f, 0.11246921f, 
    0.00451088f, -0.02879590f, 0.01443806f, 0.05386627f, -0.16489661f, 0.18932229f, 0.00127741f, 0.45081472f, 
    -0.03515456f, 0.22847471f, -0.11903251f, -0.23030441f, 0.02673898f, -0.32712829f, 0.20173655f, 0.01141754f, 
    0.13518500f, 0.02065758f, 0.01350433f, 0.12864543f, -0.09121343f, -0.12853524f, -0.17010923f, -0.07803194f, 
    -0.06002915f, 0.18611747f, 0.10889061f, -0.12072131f, 0.16778541f, 0.04113948f, -0.22076476f, -0.26536170f, 
    0.12710631f, 0.50309753f, 0.14570345f, -0.09877817f, 0.30012441f, 0.05553890f, -0.56068319f, 0.41062769f, 
    -0.04662678f, -0.20501618f, 0.18820737f, -0.40821207f, 0.12035111f, -0.45573533f, 0.35269257f, 0.30435562f, 
    0.04573713f, 0.08607869f, 0.08314756f, 0.06385156f, -0.08142442f, -0.02516212f, 0.15962024f, -0.72926193f, 
    -0.23767681f, 0.13959306f, -0.03043174f, 0.20528586f, 0.30844536f, 0.50544101f, 0.29694584f, -0.12918334f, 
    -0.08877505f, 0.14120793f, 0.04254315f, -0.05266509f, 0.08342310f, -0.20875612f, -0.33773813f, 0.06889490f, 
    0.11912815f, -0.18464595f, -0.32074404f, 0.05232504f, -0.05521241f, 0.25204480f, 0.03473096f, 0.41406280f, 
    0.14761324f, 0.41630417f, 0.08480807f, 0.16143553f, 0.17426781f, 0.05833593f, 0.11561380f, -0.47275615f, 
    -0.04920850f, -0.10021592f, 0.19665185f, -0.40113214f, 0.08027282f, -0.58633274f, 0.27826139f, -0.09912281f, 
    0.07538436f, -0.11525140f, -0.08513073f, -0.06917850f, 0.32115451f, 0.26675403f, 0.04829025f, 0.22576229f, 
    -0.15624517f, 0.02039066f, 0.55501240f, 0.21211261f, -0.01086225f, -0.02970524f, -0.27192450f, 0.13828418f, 
    0.26021293f, -0.44253990f, 0.16956453f, 0.37146044f, -0.13580303f, 0.14452709f, -0.11918039f, -0.55616242f, 
    -0.12416013f, 0.08641218f, -0.14337724f, 0.05663193f, -0.05296644f, 0.09339224f, 0.06653939f, 0.04800727f, 
    0.14332500f, -0.18965030f, -0.09298456f, -0.02623481f, -0.10734457f, -0.06583174f, 0.00786388f, 0.15684462f, 
    0.04888339f, -0.31442091f, 0.06820460f, -0.02559832f, 0.06907459f, -0.12531701f, -0.11097145f, 0.20783928f, 
    -0.24645095f, -0.11300330f, 0.14043730f, -0.24416548f, -0.07784446f, -0.03864238f, -0.19860329f, 0.07885076f, 
    -0.10768387f, -0.05414285f, -0.16536054f, 0.24844517f, -0.02029343f, -0.14261468f, 0.21368611f, -0.01691315f, 
    0.31482765f, 0.17021023f, 0.12951948f, 0.08898821f, 0.21629943f, 0.22706009f, -0.07565480f, -0.39891967f, 
    0.00915809f, 0.15553388f, 0.67446357f, 0.05072091f, 0.01182755f, -0.65475190f, -0.05866905f, -0.19752230f, 
    0.14388593f, 0.27555731f, 0.13992086f, 0.08857378f, 0.02065743f, -0.17159297f, 0.19545667f, -0.07210141f, 
    -0.19446161f, -0.09434441f, 0.04622094f, 0.11543425f, -0.11860412f, -0.19569747f, 0.08753809f, -0.15310743f, 
    -0.16422199f, -0.07305501f, 0.09519807f, -0.06404296f, -0.14725612f, 0.03780030f, 0.14395097f, 0.07594035f, 
    0.15522492f, 0.11251772f, -0.17343029f, 0.19295792f, -0.08322066f, 0.08126249f, 0.03103516f, 0.03593623f, 
    -0.07336821f, -0.18505101f, 0.12230863f, 0.14293684f, -0.05374275f, 0.09835359f, -0.12212377f, -0.07504226f, 
    -0.08310840f, 0.11390516f, 0.26576579f, -0.25270209f, 0.16864131f, -0.42032725f, -0.28790027f, 0.02973962f, 
    -0.06748577f, -0.13458182f, -0.01041712f, -0.07402143f, 0.14407027f, 0.11543974f, 0.01345737f, 0.42296740f, 
    -0.06136942f, 0.03021313f, -0.05994129f, -0.11797512f, 0.09578598f, 0.04477574f, -0.03348615f, 0.07760096f, 
    0.03620899f, 0.06941139f, 0.07978820f, 0.06026013f, 0.15615712f, -0.00826670f, -0.17971916f, 0.18638444f, 
    -0.49250415f, -0.05135107f, 0.13979903f, 0.00126017f, -0.55433196f, 0.45518902f, 0.18250240f, 0.07645046f, 
    0.04418276f, -0.08910510f, -0.09591856f, 0.09022889f, -0.05127813f, 0.16628399f, -0.45076361f, -0.43227699f, 
    -0.01540343f, -0.48909301f, -0.10727909f, 0.09659057f, -0.07564753f, 0.54715627f, 0.15358710f, -0.14056362f, 
    -0.13780025f, 0.16267730f, -0.16077356f, -0.33596221f, 0.12319933f, 0.12569107f, 0.29425555f, 0.14441474f, 
    0.04175256f, 0.17002451f, -0.01578604f, -0.01881552f, 0.04779710f, -0.22585253f, -0.28576243f, 0.17238761f, 
    0.25619704f, 0.19571067f, -0.00061480f, -0.04329102f, -0.36371073f, -0.08347063f, 0.03619003f, -0.11588034f, 
    0.05196474f, 0.20493601f, -0.23050590f, -0.04847720f, -0.10748513f, -0.06032735f, 0.34090239f, -0.16565856f, 
    0.07963929f, 0.39969873f, 0.14749977f, 0.17967224f, -0.13316499f, -0.12778261f, 0.21596114f, -0.06070794f, 
    -0.41199994f, 0.13673000f, 0.30185026f, -0.09378153f, 0.06973904f, -0.34885550f, -0.02300033f, -0.17290339f, 
    0.06636848f, 0.00400728f, -0.04103951f, -0.08470511f, -0.09357916f, 0.43809766f, -0.46006173f, 0.39477053f, 
    -0.14342971f, 0.32382166f, -0.44964600f, 0.02945215f, -0.15185246f, -0.14967684f, 0.39977753f, 0.04213338f, 
    -0.17257169f, 0.03472174f, -0.12471481f, 0.29214481f, -0.03897199f, -0.16077037f, -0.05302252f, 0.19938926f, 
    -0.16257232f, -0.17191668f, 0.07300687f, -0.13969789f, -0.03835363f, 0.04183441f, 0.32114792f, -0.07499024f, 
    0.11208963f, 0.24128735f, 0.09772037f, 0.16777591f, 0.19349968f, -0.24391302f, 0.11805809f, -0.23440541f, 
    -0.04617371f, -0.14168932f, 0.38940665f, -0.36980048f, -0.01424927f, -0.21699019f, -0.06447231f, -0.18376231f, 
    0.01494954f, -0.12467888f, -0.12867624f, -0.02686223f, -0.00596276f, -0.07594272f, -0.17841414f, -0.06325715f, 
    0.31374291f, 0.07395585f, -0.28889295f, 0.21756636f, -0.07979862f, 0.17335872f, 0.07333156f, 0.03324286f, 
    -0.30956125f, 0.03115174f, -0.02273182f, -0.11133668f, -0.03881822f, 0.05285157f, 0.39451832f, 0.36126015f, 
    -0.16442274f, -0.13821733f, 0.33721000f, -0.00348529f, -0.01029799f, 0.18597563f, 0.00705182f, 0.20461458f, 
    -0.16034667f, 0.41109377f, -0.09090231f, 0.15806480f, -0.09335985f, -0.03884852f, 0.08748990f, -0.22751378f, 
    -0.25054812f, -0.14174083f, 0.28048024f, 0.01885999f, 0.21326968f, 0.31659389f, 0.13950136f, 0.08138400f, 
    0.12924251f, -0.01495691f, -0.06763922f, 0.00080429f, 0.03166930f, -0.46993867f, 0.30316597f, 0.03489715f, 
    -0.15093495f, 0.10488436f, -0.11054373f, -0.21939629f, 0.05401639f, -0.24531309f, 0.24993239f, 0.30821133f, 
    -0.14621733f, -0.00457270f, -0.15788931f, 0.09346905f, 0.02892024f, -0.02028284f, 0.03554058f, -0.24274892f, 
    -0.15183191f, 0.16852376f, 0.14559278f, 0.11593001f, 0.27675787f, -0.47984490f, -0.33467969f, -0.11532917f, 
    0.35018578f, -0.07610077f, 0.09686632f, 0.10260157f, 0.51114213f, -0.13880862f, 0.33871573f, 0.55445266f, 
    0.14280505f, 0.27789405f, -0.04057564f, 0.14255561f, 0.02213131f, 0.20433129f, -0.00589187f, -0.11640049f, 
    0.24368662f, -0.35194331f, 0.06398389f, 0.21655346f, -0.15749511f, 0.16959566f, -0.00277355f, -0.39250851f, 
    -0.21339028f, 0.11890082f, -0.06296913f, 0.30176374f, 0.11159775f, 0.16461986f, -0.31026754f, -0.06726300f, 
    0.28579918f, 0.31246313f, -0.11878651f, 0.16102244f, -0.06477511f, 0.07953511f, -0.43189207f, -0.15168473f, 
    -0.17186877f, 0.10907153f, -0.05530738f, 0.39403895f, 0.01419176f, -0.18502660f, 0.09922601f, 0.19804370f, 
    0.24229728f, 0.43064800f, -0.14482756f, 0.01415248f, -0.11416509f, -0.16438118f, 0.11564846f, -0.03514345f, 
    0.09712424f, -0.14502874f, -0.16458896f, 0.04973953f, 0.26052794f, -0.24390382f, 0.06061089f, -0.31211165f, 
    0.20268968f, 0.15113051f, 0.07514301f, 0.08205768f, 0.41497755f, 0.13089046f, -0.29809985f, 0.14613506f, 
    0.13093637f, -0.22545250f, 0.10193385f, 0.56907111f, 0.00840278f, 0.34721479f, -0.37434199f, 0.12574722f, 
    0.29108852f, 0.12601830f, -0.09812927f, 0.19310169f, -0.03262279f, 0.08927552f, 0.21650217f, 0.05274772f, 
    0.11801286f, -0.10966092f, 0.11944818f, -0.15310767f, -0.12373812f, 0.05196170f, -0.02878240f, -0.18304592f, 
    -0.11156878f, 0.03890756f, -0.04685235f, -0.07044502f, -0.13214670f, -0.13534987f, -0.03090628f, -0.16453272f, 
    0.08633512f, -0.01122776f, -0.04774573f, -0.12377051f, -0.08507164f, -0.14580196f, -0.00132935f, -0.05472050f, 
    -0.04983398f, -0.11204314f, -0.16986217f, -0.19081999f, 0.03464717f, 0.14719039f, 0.09461251f, -0.05372271f, 
    -0.14261635f, 0.03907249f, -0.27254611f, 0.40992534f, -0.06399842f, 0.30347466f, -0.03777685f, 0.05602289f, 
    -0.08581695f, 0.12478010f, 0.00543352f, 0.16791806f, -0.16293311f, 0.38273531f, -0.09942510f, -0.18002433f, 
    -0.15998863f, 0.03479718f, 0.01874080f, 0.47487682f, -0.06681844f, 0.15636529f, 0.23730356f, -0.21219121f, 
    0.17573014f, 0.42801276f, 0.14825378f, -0.23568501f, -0.12713946f, 0.01359646f, 0.20400922f, 0.14892305f, 
    -0.17047356f, -0.06556075f, 0.09220541f, 0.02401258f, 0.26344585f, -0.06265200f, 0.22122200f, -0.38404348f, 
    0.39961153f, 0.21095072f, -0.14504537f, -0.08682730f, 0.15522026f, 0.18331073f, -0.08485265f, 0.19029416f, 
    0.01595446f, -0.15150353f, 0.11213768f, -0.00054608f, 0.15385880f, -0.44640815f, -0.32893983f, 0.25125051f, 
    0.04638745f, -0.01434801f, 0.09477203f, -0.06572484f, -0.13678563f, -0.04913839f, 0.04858541f, 0.10595884f, 
    -0.18650769f, 0.16492020f, -0.16720892f, -0.06147544f, 0.11706250f, -0.17637505f, -0.16965255f, -0.01662700f, 
    -0.13839266f, -0.05220640f, 0.17600282f, -0.16527517f, -0.10021845f, -0.03227194f, -0.14066145f, 0.05431318f, 
    -0.05753532f, 0.15351366f, -0.04093908f, -0.04785398f, 0.13543272f, -0.10127613f, 0.14113070f, -0.10889985f, 
    0.10600622f, -0.02083436f, -0.09616686f, -0.00893498f, -0.11121710f, 0.03731273f, 0.00138746f, -0.05366679f, 
    0.06996479f, 0.02572762f, 0.01131838f, -0.03777334f, 0.00282147f, 0.31619596f, 0.20387383f, 0.03476688f, 
    -0.26486927f, -0.06922698f, -0.15365483f, -0.03041370f, 0.06506322f, 0.08856131f, -0.05046732f, 0.41894776f, 
    0.12760377f, -0.05864307f, -0.30875745f, 0.08949868f, 0.06682859f, 0.15212683f, 0.00585500f, 0.28886276f, 
    0.04799464f, -0.19369999f, -0.17365384f, -0.14876050f, 0.16461730f, 0.03736394f, -0.14031239f, 0.09107616f, 
    -0.17038697f, -0.17068112f, 0.02543450f, -0.16327390f, 0.20427503f, 0.20840999f, 0.16505632f, -0.05836413f, 
    0.35485137f, -0.09772827f, -0.04514286f, -0.06260041f, 0.24064898f, 0.15906729f, -0.42604253f, 0.23599273f, 
    -0.04676741f, -0.12078314f, -0.05092204f, 0.45844439f, -0.10740916f, -0.45507404f, -0.27241528f, 0.12407614f, 
    0.07382955f, -0.22372778f, -0.17147365f, 0.16860025f, -0.12378261f, 0.15127724f, 0.12930444f, 0.09992104f, 
    0.01171936f, 0.05051167f, 0.31330335f, 0.00605227f, -0.13096796f, -0.05654895f, 0.36353388f, 0.33400443f, 
    -0.14582372f, -0.45385405f, -0.16535564f, 0.17334683f, -0.24404712f, 0.37699476f, 0.43320510f, -0.06942616f, 
    0.10657633f, 0.20307717f, 0.41028252f, -0.15571244f, 0.09802773f, 0.10602042f, -0.15095435f, -0.30463895f, 
    -0.25349137f, 0.08914802f, 0.07321746f, -0.40046266f, 0.07340124f, -0.11766552f, 0.33621868f, -0.00268512f, 
    -0.43848774f, 0.11638641f, 0.30921957f, -0.12037186f, -0.18882996f, 0.35689783f, 0.29271430f, 0.38018084f, 
    -0.06566171f, -0.23827472f, 0.16025463f, 0.13556267f, -0.37070966f, 0.09281689f, 0.19172789f, -0.04801615f, 
    0.04656118f, 0.30275646f, -0.05542941f, -0.06355079f, 0.13457322f, 0.05150611f, -0.00378734f, -0.30435431f, 
    -0.00498601f, 0.19056632f, -0.10678881f, -0.27200735f, 0.10383996f, -0.03552649f, 0.20938548f, 0.13282342f, 
    -0.02028659f, 0.06177981f, 0.08931939f, 0.25052094f, 0.00638505f, 0.05836538f, -0.28873846f, -0.15038237f, 
    -0.09341071f, 0.16557805f, 0.07531376f, 0.03207674f, 0.37567475f, 0.08421510f, -0.17955512f, 0.01097745f, 
    0.11310360f, 0.36148509f, 0.45968145f, -0.37094209f, 0.09387522f, -0.04891481f, 0.21458548f, 0.11102392f, 
    -0.08649876f, -0.22617118f, -0.08742575f, -0.18081474f, 0.16916643f, 0.05092099f, -0.01419422f, 0.05519026f, 
    -0.14330406f, -0.02658674f, 0.11525547f, -0.14041191f, 0.14982744f, 0.31343806f, 0.25752234f, 0.37128398f, 
    0.27417102f, -0.31961840f, 0.05690007f, 0.09819054f, 0.17801297f, -0.13361953f, 0.37387824f, -0.19124207f, 
    0.02328360f, 0.04674407f, 0.04171278f, 0.02338987f, -0.03074036f, -0.13576590f, 0.00769375f, -0.04854093f, 
    0.23521441f, -0.20039497f, 0.12377798f, -0.04041311f, 0.09940966f, -0.12062007f, 0.00802068f, -0.11774942f, 
    -0.14235716f, -0.06148828f, -0.07897558f, 0.17119735f, 0.13822974f, 0.49560171f, -0.06002680f, 0.18632591f, 
    -0.19092111f, -0.12055430f, 0.11441068f, 0.16758582f, -0.28521103f, -0.02284955f, 0.66794717f, 0.02782392f, 
    -0.02898026f, 0.25411382f, -0.54774493f, -0.13585150f, 0.08093487f, 0.17501803f, 0.29563978f, 0.12721522f, 
    -0.22780684f, -0.13373016f, 0.09343053f, -0.28200087f, 0.08280217f, 0.11289227f, 0.09230900f, -0.18214801f, 
    -0.54948503f, -0.14008982f, 0.23760313f, 0.11068317f, -0.19001234f, 0.07453242f, -0.14005052f, 0.46828943f, 
    0.26909652f, 0.12016567f, 0.02211293f, -0.05808175f, -0.33879465f, 0.07168889f, -0.06513680f, 0.32248488f, 
    0.09352375f, 0.48983535f, -0.12792130f, 0.00048468f, 0.03728098f, -0.40824926f, 0.39303556f, -0.40213069f, 
    -0.14388560f, 0.13810207f, -0.11514979f, -0.08096118f, 0.10764112f, -0.04744668f, 0.12230560f, 0.00645140f, 
    0.08927314f, 0.05336996f, 0.12080644f, -0.23733701f, -0.04712866f, 0.06003179f, 0.01842248f, -0.01096953f, 
    0.06001854f, -0.09909225f, -0.08365456f, 0.06596108f, -0.13726422f, 0.14637023f, -0.25441366f, 0.24905743f, 
    0.00733418f, 0.08689857f, -0.08118864f, -0.28609765f, 0.04342803f, -0.02048873f, 0.22112797f, 0.21227773f, 
    -0.15066040f, 0.18618417f, 0.00202581f, 0.21731192f, 0.04386507f, 0.00269516f, -0.18371555f, -0.26670653f, 
    0.17639111f, -0.03059656f, 0.25961015f, -0.03890318f, -0.02172170f, -0.25510940f, -0.30475488f, -0.22846416f, 
    -0.05561870f, 0.25288761f, -0.03328484f, 0.01823336f, 0.09843639f, 0.08418208f, -0.18662523f, 0.15203354f, 
    0.00698076f, -0.13629144f, 0.20167397f, -0.46183816f, -0.15754071f, -0.28059682f, 0.33731037f, 0.27702269f, 
    -0.09795768f, 0.17819290f, -0.15541242f, -0.33438396f, -0.00715382f, -0.00600549f, 0.29581767f, 0.07972402f, 
    0.14759576f, -0.07212032f, -0.02970229f, -0.32998317f, 0.16295967f, 0.06256270f, 0.49561846f, -0.18771471f, 
    -0.01635418f, 0.08672444f, 0.13639323f, -0.00227767f, -0.00188734f, 0.07101940f, 0.24491054f, -0.25868773f, 
    0.01227752f, -0.14229161f, 0.47018710f, -0.27471343f, 0.06720584f, 0.02286682f, -0.08148535f, 0.21782689f, 
    -0.10846291f, -0.06583850f, 0.05130685f, -0.23871885f, 0.16574545f, -0.08989270f, 0.22503763f, 0.18516098f, 
    0.00491003f, 0.08013115f, -0.10029110f, 0.13368197f, 0.16714105f, -0.09352404f, 0.01475587f, -0.02006014f, 
    0.44514060f, 0.13905764f, 0.04748331f, 0.12734985f, 0.03411933f, 0.10988074f, 0.12079642f, 0.61013156f, 
    -0.02364853f, 0.06830626f, 0.10440423f, 0.06928880f, -0.08720224f, -0.32155207f, -0.20084038f, 0.19419529f, 
    0.13826537f, -0.18308295f, 0.08384563f, 0.41689798f, 0.13420798f, 0.11412052f, -0.08255866f, -0.28399238f, 
    -0.18168251f, -0.15083845f, -0.12897864f, -0.26917624f, 0.12714897f, -0.10390231f, 0.68610090f, -0.04717043f, 
    -0.05244277f, 0.08171885f, 0.10033914f, -0.10716712f, 0.09348564f, -0.34785417f, 0.21896467f, -0.56255263f, 
    0.10147888f, -0.02889892f, 0.42285529f, 0.25366855f, -0.10589124f, 0.21815781f, -0.47260052f, -0.45433915f, 
    0.00561659f, 0.48018220f, 0.12367881f, 0.08975513f, 0.01477529f, -0.05175651f, 0.22201376f, 0.07308626f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.08545845f, 0.06165031f, 0.03507072f, 0.45217356f, 0.01165946f, 0.10303190f, -0.14738947f, 0.20830482f, 
    -0.08207230f, 0.24108492f, 0.13004513f, -0.04000596f, 0.16562781f, 0.19775930f, 0.08168715f, 0.25338274f, 
    -0.21791109f, 0.25100663f, 0.13902719f, 0.11313452f, 0.29050958f, -0.06477744f, 0.16130188f, 0.05946622f, 
    0.19311324f, -0.06552652f, 0.13709518f, 0.05899702f, -0.09346461f, -0.03030132f, 0.15567626f, 0.18037462f, 
    -0.13415767f, 0.27491948f, 0.16626512f, 0.01320779f, -0.07290497f, -0.21029234f, -0.19085313f, -0.14398155f, 
    0.01035013f, 0.16505297f, 0.11760667f, 0.24415649f, 0.16401044f, 0.09173205f, -0.01690585f, -0.08047626f, 
    -0.05623139f, 0.21082439f, -0.14388868f, -0.07834191f, -0.02315180f, 0.21585914f, 0.26058418f, 0.16464280f, 
    0.51396036f, 0.26106769f, 0.39062965f, -0.06716058f, -0.08330452f, 0.09070240f, 0.00815411f, -0.08772830f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.20346859f, -0.05174114f, -0.01924194f, 0.01947500f, 0.05729945f, 0.16353138f, 0.06953475f, 0.11539882f, 
    0.14162502f, -0.10582392f, -0.38185507f, 0.05504714f, -0.59736580f, 0.04606171f, -0.13511562f, -0.50858831f, 
    0.00378031f, -0.62831074f, 0.21596324f, 0.00526889f, -0.12541156f, 0.28329673f, 0.15711631f, 0.18464485f, 
    0.14495172f, -0.45946947f, -0.19570735f, 0.27926600f, -0.03760154f, -0.36905155f, -0.08493878f, -0.61433363f, 
    0.18987636f, 0.07044229f, -0.13661189f, -0.13049041f, -0.10172127f, -0.02483584f, 0.35392964f, -0.08884593f, 
    -0.44073939f, -0.07501207f, 0.24727650f, -0.43876040f, -0.28411961f, -0.18620558f, 0.16319546f, -0.05127010f, 
    0.19481365f, -0.32866082f, 0.02791819f, 0.07987460f, -0.26907501f, 0.12650043f, 0.06701362f, -0.25860840f, 
    -0.00274762f, -0.17175464f, -0.73916978f, -0.08933031f, -0.28344041f, 0.16392110f, -0.32270089f, 0.25630018f, 
    0.34881797f, 0.02350634f, -0.03194716f, 0.07762892f, -0.30998194f, -0.03639673f, -0.10514408f, -0.30703998f, 
    -0.31427115f, -0.17492744f, 0.12406007f, 0.37847999f, -0.06238639f, -0.24206291f, -0.18610367f, -0.08812196f, 
    0.03199027f, -0.08761772f, -0.53733534f, -0.63267767f, 0.26154503f, 0.03535575f, -0.14945453f, 0.08373037f, 
    0.19721016f, -0.27268130f, -0.05076846f, -0.27775097f, -0.02996791f, 0.18688717f, -0.18256965f, 0.09669430f, 
    0.23773862f, 0.41792342f, 0.27907753f, 0.24204054f, -0.08753439f, -0.25971329f, -0.67402816f, -0.24905880f, 
    -0.64811409f, 0.53751910f, 0.07528973f, 0.18175796f, -0.00828919f, -0.10934356f, 0.08117708f, 0.10727493f, 
    -0.22468048f, 0.21521698f, -0.06339026f, 0.06722243f, 0.14218427f, -0.02497516f, -0.25628018f, -0.02371734f, 
    0.14718808f, 0.25611186f, -0.66121733f, -0.05508384f, -0.12385246f, 0.25516027f, 0.12619680f, 0.28598404f, 
    -0.34470081f, -0.05618341f, -0.21046185f, 0.07019005f, 0.37543848f, 0.11661249f, -0.57489431f, 0.10842194f, 
    -0.49059686f, 0.23515864f, 0.11201318f, -0.78215265f, -0.09727658f, 0.04438683f, -0.69988185f, 0.06357982f, 
    -0.06385124f, 0.04584959f, -0.20237951f, -0.28733465f, 0.00135629f, 0.04714298f, 0.25039294f, -0.30841675f, 
    -0.05102091f, -0.20774397f, 0.16381484f, 0.36240309f, 0.08372498f, -0.07340155f, 0.24675077f, 0.16151868f, 
    -0.74755096f, 0.54684359f, 0.06131089f, 0.20429404f, -0.12020814f, 0.12781817f, -0.84118038f, 0.00209069f, 
    -0.01882656f, -0.04395752f, -0.05076866f, -0.24280845f, 0.01462871f, -0.26579940f, -0.08814217f, 0.01816790f, 
    -0.07979707f, -0.12473896f, 0.09459442f, -0.14727658f, -0.06657197f, 0.31696439f, 0.01525734f, 0.10845641f, 
    0.21295053f, -0.65887320f, 0.27091184f, -0.04385541f, 0.06045645f, 0.07604117f, 0.04261572f, -0.43917659f, 
    -0.52895039f, 0.10731506f, -0.34309247f, 0.13492282f, 0.35273081f, 0.03739733f, -0.38782856f, 0.04856170f, 
    0.15810715f, 0.40622196f, -0.32408747f, -0.02315820f, -0.37849727f, 0.18181427f, -0.02737524f, 0.29922730f, 
    0.02913536f, 0.03384767f, 0.32287484f, 0.26242667f, -0.51543909f, -0.09117472f, -0.53631514f, -0.13955927f, 
    0.01615783f, -0.36954379f, 0.20227107f, 0.25845897f, -0.16483161f, -0.07241856f, -0.40304038f, -0.05882092f, 
    -0.32057545f, -0.00792508f, -0.13480401f, -0.01261956f, 0.14391519f, 0.21442614f, 0.05650100f, -0.07551235f, 
    0.37479123f, -0.16479596f, -0.70770109f, -0.05374851f, -0.13414121f, -0.03149224f, -0.03694353f, -0.03639407f, 
    -0.12464291f, 0.01475490f, -0.06511699f, 0.07316748f, 0.05130942f, 0.15738073f, 0.18661281f, 0.04549281f, 
    0.07106558f, -0.76216722f, 0.05521142f, -0.30731782f, 0.27508974f, 0.12975696f, -0.47873116f, 0.00996424f, 
    -0.20935583f, -0.03576497f, 0.34355223f, 0.05029983f, -0.01104570f, -0.10630726f, 0.17912781f, -0.82608604f, 
    -0.26057565f, -0.54536259f, 0.34180194f, -0.16615431f, -0.07179622f, -0.00219045f, 0.37532899f, -0.17831297f, 
    -0.00093532f, -0.46310303f, 0.16545330f, 0.17554878f, -0.07080929f, -0.28994912f, -0.17898104f, -0.11459906f, 
    0.00519654f, -0.24624145f, -0.08055143f, -0.28926805f, 0.25545946f, -0.38083431f, -0.12721361f, 0.04364572f, 
    0.03237152f, -0.41255736f, -0.25735298f, 0.16396105f, -0.07501519f, 0.05997430f, 0.08603463f, 0.20143373f, 
    -0.26931515f, -0.08296364f, 0.16101718f, -0.05544445f, -0.79524213f, 0.07953723f, -0.02923948f, 0.00513742f, 
    0.10137885f, 0.06608747f, 0.08399525f, 0.08923050f, 0.01269083f, 0.13669470f, 0.16300909f, -0.25754526f, 
    -0.06693376f, -0.40600076f, 0.25478390f, -0.18361367f, 0.17713803f, 0.09245036f, -0.14764908f, 0.20496234f, 
    0.22410154f, -0.07045548f, -0.42310956f, 0.24112034f, -0.18255161f, 0.14547540f, 0.08111505f, -0.22079940f, 
    -0.16535085f, -0.52413338f, -0.04952456f, -0.02460550f, -0.26373342f, -0.21964139f, 0.21789248f, -0.07614662f, 
    -0.11939482f, 0.12578283f, -0.06824158f, 0.14628591f, 0.11133268f, -0.24815431f, -0.12126864f, 0.15310006f, 
    -0.32242313f, 0.23170726f, -0.22646372f, -0.43557867f, 0.23228222f, 0.17831062f, -0.02375573f, -0.30644214f, 
    -0.01800269f, 0.22589900f, 0.08478698f, 0.06215814f, -0.02190679f, -0.03254386f, -0.28524128f, 0.00776110f, 
    0.35284773f, -0.23262599f, -0.28509870f, -0.19730885f, 0.02766461f, 0.14881116f, 0.17623380f, -0.00807078f, 
    0.18123747f, 0.10108301f, -0.06900999f, 0.09677320f, 0.30442765f, -0.06080263f, -0.03973081f, -0.25298750f, 
    0.05468578f, -0.19302070f, 0.06237413f, -0.35116029f, -0.46449840f, -0.17949302f, 0.12232401f, 0.09754246f, 
    0.32644984f, 0.06916408f, -0.16647111f, -1.00536287f, -0.16864263f, -0.74311203f, 0.17750739f, 0.10838491f, 
    -0.20682849f, 0.39089182f, -0.07672289f, -0.69474345f, 0.16124105f, 0.12405977f, -0.62624627f, 0.16659032f, 
    -0.06921066f, 0.17143774f, -0.22666678f, -1.13876331f, -0.09149455f, 0.20469196f, 0.15441969f, -0.03288202f, 
    -0.01012594f, -0.17993438f, 0.00609034f, 0.58341986f, 0.04430738f, 0.08124363f, 0.06684764f, -0.31767756f, 
    -0.28236067f, -0.09979342f, 0.16573584f, -0.77768046f, -0.11843539f, 0.11489131f, -0.43069673f, -0.02641802f, 
    -0.41628101f, -0.17200360f, 0.24265666f, 0.17721701f, 0.30444774f, -0.49523041f, -0.27581862f, 0.02971367f, 
    -0.29267290f, -0.43083858f, 0.01826026f, 0.04538235f, -0.26345450f, 0.27315399f, 0.15226428f, -0.10741989f, 
    0.07288255f, 0.35368839f, 0.23087141f, -0.14758103f, -0.12455242f, -0.43048236f, 0.11517653f, -0.37337339f, 
    0.10033083f, -0.03063809f, -0.07199302f, -0.61140960f, 0.73597127f, 0.00257500f, -0.14402190f, 0.08926145f, 
    0.01520477f, 0.04369432f, 0.27731368f, -0.05145221f, 0.25288081f, -0.31381959f, 0.01807860f, -0.42451134f, 
    0.01725550f, -0.09684985f, -0.00924946f, -0.18803340f, -0.03158586f, -0.21714607f, -0.10931626f, -0.28916603f, 
    -0.05847756f, 0.04691248f, -0.17087264f, 0.42219692f, 0.02785521f, -0.00411113f, -0.01888148f, 0.12243786f, 
    -0.12849794f, -0.15897769f, -0.17677929f, -0.23556957f, -0.07061707f, -0.02187831f, -0.48755440f, -0.35012081f, 
    0.34724808f, -0.14142196f, 0.16209544f, -0.25853449f, -0.24923858f, 0.10474205f, 0.05024193f, 0.05730467f, 
    0.10049390f, 0.23318326f, -0.11180102f, 0.07213128f, 0.06247079f, 0.22443086f, -0.52087593f, 0.24254438f, 
    -0.91371405f, -0.20973785f, -0.38633263f, 0.08975488f, 0.25230813f, 0.09313913f, 0.01984847f, -0.16962130f, 
    -0.25535291f, 0.10335064f, -0.34563276f, -0.34344074f, -0.21923560f, -0.02838929f, -0.21072139f, -0.32401478f, 
    0.35787642f, -0.26837519f, -0.12495297f, 0.31166807f, 0.19572969f, -0.14994343f, -0.52599621f, 0.15300949f, 
    -0.02130864f, 0.24741620f, -0.22471198f, -0.02853532f, 0.20979285f, -0.04227032f, -0.26138338f, -0.05034492f, 
    -0.24980892f, -0.17681849f, -0.03338733f, -0.57389939f, -0.09601584f, -0.07570552f, 0.19745049f, 0.25925976f, 
    0.15425472f, 0.19446529f, 0.01479110f, -0.34648085f, -0.15559128f, 0.32371047f, -0.53287321f, 0.36123621f, 
    0.59271407f, -0.10200360f, -0.25582299f, 0.21580458f, 0.33774823f, -0.01714477f, 0.03951102f, -0.12695929f, 
    -0.56637752f, 0.07425303f, -0.11500259f, -0.09180012f, -0.02417900f, -0.82563692f, -0.58554620f, -0.07122718f, 
    -0.11198958f, -0.18281090f, -0.09049408f, 0.11634744f, 0.05367168f, -0.19273840f, 0.22718042f, -0.69884706f, 
    -0.01092229f, -0.11179920f, -0.13577943f, 0.22868638f, -0.39993778f, -0.41577598f, -0.02804372f, 0.17439511f, 
    0.14374965f, -0.18282597f, -0.01592575f, 0.12600741f, 0.00988385f, 0.29838338f, 0.46077633f, 0.20511095f, 
    0.02719284f, 0.09633711f, -0.72804999f, -0.18683054f, 0.08137307f, -0.29217440f, 0.24755690f, -0.23777571f, 
    0.06996816f, -0.15906215f, -0.01315438f, -0.09479987f, 0.20813610f, -0.36731273f, -0.07032007f, -0.62697327f, 
    -0.28454179f, -0.54291332f, -0.23340735f, 0.09257821f, -0.00163374f, -0.33068150f, -0.72182459f, 0.13402739f, 
    0.01158324f, 0.00858689f, -0.04055729f, 0.05573538f, -0.19758384f, -0.07644801f, -0.49571958f, -0.02564091f, 
    0.20849270f, -0.27582979f, -0.10498602f, -0.21062264f, -0.45545480f, 0.31234714f, 0.32869676f, 0.16433540f, 
    0.13593535f, 0.30030695f, 0.19358046f, -0.16543235f, -0.11325587f, -0.05449321f, -0.11399779f, -0.11295725f, 
    -0.38687542f, -0.06697094f, 0.55667901f, -0.16419315f, -0.41469383f, 0.00572505f, -0.20262222f, -0.13440721f, 
    0.09738179f, 0.23136851f, 0.15542655f, -0.23131630f, -0.24177232f, -0.21113095f, -0.09621612f, 0.23330493f, 
    -0.01092855f, -0.13437438f, 0.29471728f, -0.51976210f, -0.29979241f, -0.04946847f, -0.05979762f, 0.18979141f, 
    -0.54195672f, -0.28581247f, 0.28109711f, -0.41173634f, -0.20957559f, 0.23452522f, -0.25544253f, 0.22718433f, 
    0.12244634f, -0.31637400f, -0.11251009f, 0.31969926f, -0.06715559f, -0.21163481f, -0.48464999f, 0.09488723f, 
    -0.66693014f, -0.24534565f, 0.02857879f, -0.03205700f, 0.29001623f, 0.32622701f, 0.21177341f, -0.06425684f, 
    0.30944309f, -0.06719327f, -0.00011392f, -0.50943637f, 0.04312692f, -0.65682095f, -0.65614450f, 0.25104889f, 
    -0.09322082f, -0.47730795f, -0.04512038f, -0.14948417f, 0.04484008f, -0.47176358f, 0.04812506f, -0.31823292f, 
    -0.23087107f, -0.03116651f, 0.39881104f, -0.28708583f, -0.54484838f, -0.32812393f, -0.27403384f, 0.47944486f, 
    0.09451286f, 0.23219411f, -0.39321634f, 0.06806184f, 0.18136618f, 0.13794370f, -0.05791248f, -0.07210340f, 
    -0.11848710f, 0.26960197f, -0.10729709f, 0.13848573f, -0.42268801f, 0.33642679f, -0.10028750f, -0.30903834f, 
    0.09867586f, 0.28586799f, 0.09690691f, -0.51669961f, -0.74112195f, 0.25977454f, 0.11840669f, 0.26000196f, 
    0.42520410f, -0.65377152f, -0.08239213f, -0.30713862f, 0.13627656f, -0.27503297f, -0.52239883f, -0.02320789f, 
    0.19586885f, -0.12293609f, -0.12652905f, 0.18676069f, -0.28798476f, 0.09818157f, -0.33152431f, -0.03760229f, 
    0.07107320f, -0.25912398f, -0.08981004f, 0.12287544f, 0.01943045f, -0.23936851f, 0.12677269f, -0.05832075f, 
    0.17652400f, 0.19589180f, 0.24235958f, 0.05757635f, -0.26940039f, -0.38130906f, -0.09237602f, -0.28921402f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.26092967f, 0.21128170f, 0.16161063f, -0.08752013f, 0.03973395f, 0.03830631f, 0.01992878f, -0.20906380f, 
    -0.04941035f, 0.15880503f, -0.05715374f, -0.02876166f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
