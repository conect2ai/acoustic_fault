#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.31969407f, 0.64779896f, -0.18936788f, -0.56441194f, 0.69438708f, -0.53624785f, 0.12066849f, -0.23255438f, 
    -0.33446956f, -0.08705153f, 0.04618783f, 0.09808863f, 0.12618643f, 0.04283299f, -0.24413338f, -0.16346291f, 
    -0.29385430f, 0.30036759f, 0.24392270f, 0.06001088f, 0.13503055f, -0.05362073f, -0.01316728f, -0.06400266f, 
    -0.05037288f, -0.13550392f, -0.08281734f, -0.14832520f, 0.34030673f, 0.19621165f, -0.12786865f, 0.20142759f, 
    0.05067554f, -0.22941655f, -0.21046942f, -0.13078240f, 0.07030109f, -0.07939908f, -0.07111306f, 0.25548014f, 
    0.08143564f, -0.40064749f, 0.27093792f, -0.10084455f, -0.03473119f, 0.12001640f, -0.03978638f, -0.01353149f, 
    0.20068237f, -0.08029299f, -0.65271646f, -0.61415005f, -0.64475125f, -0.28904521f, -0.00524546f, 0.33887488f, 
    -0.07347153f, 0.40963233f, 0.21035065f, 0.63795549f, 0.34182897f, 0.05180225f, 0.08323904f, -0.05924833f, 
    0.06578890f, 0.12596954f, 0.22530328f, -0.00198889f, -0.10524199f, -0.00615350f, -0.03119011f, 0.08052360f, 
    0.02423530f, -0.13279380f, -0.12393942f, -0.65136093f, -0.14610617f, -0.08319892f, -0.57155758f, -0.57604450f, 
    0.72834307f, -0.09051152f, -0.41681913f, -0.03074732f, 0.22068542f, -0.08849560f, -0.01906247f, 0.02131270f, 
    -0.06396422f, -0.27302378f, -0.06412710f, -0.05791623f, -0.13128391f, -0.06445416f, -0.11402610f, 0.08065534f, 
    0.15275285f, 0.15868250f, -0.11361416f, 0.09816331f, 0.60052431f, -0.63102937f, -0.77989984f, -0.06421468f, 
    0.00385770f, 0.44073555f, 0.20221010f, 0.41540736f, 0.45188937f, -0.67636144f, 0.07539781f, -0.06002344f, 
    -0.21521404f, -0.12942016f, -0.20743512f, 0.00803918f, 0.02036700f, 0.30555874f, 0.15892613f, 0.15236278f, 
    0.10605785f, -0.24438867f, -0.11178761f, 0.04124566f, 0.04959840f, 0.80690402f, 0.77472728f, 0.13772677f, 
    -0.59416878f, -0.67862964f, -0.21654567f, -0.20366418f, 0.10782594f, -0.11217137f, 0.04567030f, 0.00380758f, 
    -0.05589347f, 0.13729438f, 0.18849117f, -0.23120023f, 0.29136196f, 0.10746715f, -0.12633851f, -0.05345569f, 
    -0.37246898f, -0.06155910f, -0.02186497f, -0.12929074f, 0.08539069f, -0.00548781f, 0.15784942f, -0.10884254f, 
    0.19419809f, 0.29098269f, -0.50026220f, -0.52825642f, -0.29059958f, -0.40990070f, -0.25808674f, -0.57087708f, 
    0.34817597f, -0.43758622f, -0.24652423f, 0.38932410f, 0.43412524f, -0.01067635f, 0.10541134f, -0.27895987f, 
    -0.06571702f, -0.23881045f, -0.05614910f, -0.16213077f, 0.11877373f, -0.05198342f, -0.04432506f, -0.28295538f, 
    0.18178877f, 0.22833337f, -0.18448150f, 0.01043491f, 0.03649085f, -0.02325880f, -0.12867828f, 0.36758915f, 
    -0.07554546f, -0.07426786f, -0.03955628f, -0.18656005f, 0.57493031f, -0.12941588f, -0.15991969f, 0.07674000f, 
    -0.26779869f, -0.11372020f, 0.01513822f, 0.19676298f, 0.06222370f, 0.04210347f, 0.09134845f, -0.16225502f, 
    -0.71959543f, 0.67336285f, -0.17574757f, -0.89148402f, -0.14492816f, -0.04040322f, 0.14789166f, 0.14550671f, 
    0.30831066f, 0.12324224f, 0.16788799f, 0.34242257f, -0.23799065f, -0.07844874f, -0.19654973f, -0.30762199f, 
    -0.30333745f, -0.13085251f, 0.40199777f, -0.32362568f, 0.18291785f, -0.07250357f, 0.02841038f, 0.11543413f, 
    0.22976695f, -0.62992716f, -0.09776305f, -0.47649032f, -0.28719795f, -0.03272526f, 0.11868768f, 0.40548044f, 
    0.25022408f, -0.34968704f, 0.02333971f, 0.01110348f, -0.12510447f, -0.21667415f, -0.32912710f, -0.06184564f, 
    0.08667473f, -0.29527998f, -0.14796372f, -0.22038074f, -0.45917153f, -0.16606210f, 0.15445448f, 0.19317900f, 
    -0.29688767f, 0.00303266f, 0.10863294f, -0.19717273f, -0.03889301f, 0.17558207f, 0.26102522f, 0.04493083f, 
    -0.03320438f, -0.23443039f, 0.11500274f, 0.30363151f, 0.14742056f, -0.06989927f, -0.36874643f, 0.26032895f, 
    0.24306814f, 0.12639926f, -0.19145761f, -0.15459375f, 0.03133369f, -0.09985095f, -0.41998896f, 0.20511891f, 
    0.02419228f, 0.10810342f, 0.11821965f, 0.08572191f, -0.53177249f, -0.80123043f, -0.53176093f, 0.30806941f, 
    -0.19848356f, 0.17597385f, 0.29877698f, -0.18411848f, 0.23898336f, 0.12622812f, 0.41243854f, 0.16485946f, 
    -0.11444426f, -0.06892113f, 0.13193183f, -0.19443183f, -0.22306214f, 0.18292055f, -0.15889877f, 0.15867044f, 
    -0.23585629f, -0.07468513f, 0.06129156f, 0.31884986f, 0.11585041f, -0.09074074f, 0.12557137f, -0.11215509f, 
    -0.21880129f, 0.09335049f, -0.03543713f, -0.39701456f, -0.24059354f, 0.31991339f, 0.17477666f, 0.22679448f, 
    -0.10308599f, -0.12909716f, 0.16017814f, -0.11868727f, 0.23702282f, 0.22224228f, 0.09435792f, 0.20298769f, 
    0.15612806f, -0.04195675f, 0.26506105f, -0.28899160f, -0.07458803f, -0.13834511f, -0.13519271f, -0.41298401f, 
    -0.59029096f, -0.07275329f, 0.19642527f, 0.21055111f, -0.17862058f, -0.10438552f, -0.10278904f, -0.13137551f, 
    0.33042100f, -0.27840552f, -0.04303445f, 0.40861991f, 0.03566398f, 0.03231731f, 0.05283021f, -0.17020276f, 
    -0.31677526f, 0.01885386f, -0.35481149f, 0.04097825f, 0.08671366f, -0.25288460f, -0.15288305f, 0.17004421f, 
    0.25587603f, -0.19706371f, 0.03314980f, 0.13924019f, 0.45394722f, -0.08638679f, -0.12571448f, -0.31385702f, 
    -0.10703817f, -0.15181462f, -0.19259277f, 0.21480477f, -0.20440167f, 0.25882071f, -0.11811720f, -0.27696997f, 
    0.22203979f, -0.26766255f, -0.01586088f, 0.00216989f, 0.16712812f, 0.25737831f, 0.17610343f, 0.30681530f, 
    -0.51560825f, -0.34946901f, 0.43460852f, 0.18989234f, -0.27858177f, 0.38843882f, -0.59261674f, -0.52552879f, 
    -0.52492136f, 0.20629080f, -0.07432292f, 0.28150502f, 0.08269080f, 0.02366360f, -0.16459149f, 0.19602221f, 
    -0.22521684f, -0.01964517f, 0.15382385f, -0.28618962f, -0.12397394f, 0.09229547f, -0.11107575f, 0.10697374f, 
    0.18424654f, -0.37102476f, -0.64557165f, -0.31294039f, -0.52388370f, 0.57167321f, 0.06093189f, 0.28217107f, 
    0.18057829f, 0.00917597f, 0.07885159f, 0.19854417f, 0.29457253f, 0.07668476f, 0.07445841f, 0.09341101f, 
    -0.22936891f, 0.00740864f, -0.12946054f, -0.32453588f, -0.02000539f, 0.03234684f, 0.10265569f, 0.24685179f, 
    -0.16674154f, -0.23761237f, -0.06477834f, -0.21401852f, 0.15449312f, 0.13413958f, -0.06404284f, 0.40075260f, 
    0.18954423f, 0.22788359f, 0.22029391f, 0.01461015f, 0.06933720f, 0.03746422f, 0.36384532f, -0.34690866f, 
    -0.29675448f, 0.14936824f, -0.07912491f, -0.05344024f, -0.01486468f, 0.23415144f, -0.13479814f, 0.10247073f, 
    0.14706811f, 0.02583171f, 0.35766447f, 0.12639274f, 0.28874502f, 0.25640479f, 0.01916448f, 0.06109031f, 
    -0.02220568f, 0.32487005f, -0.37233111f, -0.13517465f, -0.10115673f, -0.04572300f, 0.16555919f, -0.03999714f, 
    0.18095763f, -0.15001351f, 0.13416120f, 0.00067058f, 0.07415687f, -0.18808192f, 0.01987432f, -0.15977617f, 
    0.06753378f, -0.09181453f, 0.04797729f, -0.42800009f, -0.04432655f, 0.31264138f, 0.01846637f, -0.04010916f, 
    -0.48115474f, -0.24991913f, 0.21753901f, -0.23232503f, -0.45171192f, 0.30064940f, 0.14231698f, -0.28708267f, 
    0.18934935f, -0.12839326f, -0.01085812f, 0.27483556f, 0.02342964f, -0.24311256f, -0.42681175f, -0.28179085f, 
    0.01482196f, 0.27109563f, -0.18940015f, 0.40446347f, 0.51188493f, -0.69538075f, -0.17548224f, 0.08788797f, 
    0.42328337f, -0.19721819f, -0.07394049f, 0.16688389f, 0.18902893f, -0.09274329f, -0.22802721f, -0.32312974f, 
    0.21833010f, -0.36553049f, 0.44960240f, 0.10808355f, 0.01263130f, 0.02488635f, 0.14789696f, -0.32705638f, 
    -0.20010050f, -0.17178123f, -0.27477315f, -0.47057873f, -0.22025183f, -0.14554219f, -0.41933534f, -0.45856640f, 
    -0.08563630f, -0.54322743f, 0.46717992f, 0.00108577f, 0.13060412f, 0.23284423f, 0.27268109f, 0.26335645f, 
    -0.01505709f, -0.01512064f, -0.19606154f, 0.11611568f, -0.30268738f, -0.20233388f, -0.04458244f, -0.22676092f, 
    -0.14436908f, 0.16967708f, -0.03147460f, -0.02947458f, 0.14859036f, 0.43929181f, -0.34509438f, -0.26821327f, 
    -0.37083128f, -0.20006239f, 0.04840683f, -0.33830586f, -0.41768888f, -0.31746840f, -0.22074699f, 0.21398270f, 
    0.47322789f, 0.16095361f, -0.08619505f, -0.39166829f, -0.23804864f, -0.00914630f, 0.23787157f, 0.13757528f, 
    -0.11389254f, -0.06112216f, 0.21970148f, -0.04143148f, 0.12003502f, 0.35529888f, -0.12679756f, -0.61843497f, 
    0.37684855f, 0.15928507f, -0.45055270f, -0.08165319f, -0.12622046f, -0.22417460f, 0.38763592f, 0.82762700f, 
    -0.15441145f, -0.20861557f, -0.22952844f, 0.02823126f, 0.32038805f, -0.32214779f, -0.02920230f, 0.00991555f, 
    -0.18611573f, -0.16558546f, 0.46235052f, -0.19474253f, 0.28908780f, 0.08332822f, -0.01289528f, 0.00539853f, 
    0.18904829f, 0.01355465f, -0.05096314f, 0.05304785f, -0.08017623f, 0.28348878f, -0.19697621f, 0.10843008f, 
    0.13489649f, -0.18335481f, -0.00475008f, 0.08952384f, -0.12833355f, 0.13351311f, 0.14136669f, 0.13711192f, 
    -0.31763509f, 0.12925611f, 0.04949725f, -0.30581537f, 0.03114801f, 0.05069457f, -0.01413505f, 0.01679699f, 
    0.19386530f, -0.34977734f, 0.22039883f, -0.46714580f, -0.14357078f, 0.12481029f, 0.06340043f, 0.04268087f, 
    0.08357935f, 0.19711560f, -0.16920592f, 0.14593302f, 0.22765768f, 0.06337768f, 0.24609630f, -0.45038301f, 
    0.04710195f, -0.19799405f, -0.06815799f, 0.08490475f, 0.17896281f, -0.19768250f, 0.16003014f, 0.23684819f, 
    -0.23500244f, -0.18420793f, 0.37220213f, 0.72430295f, 0.53603512f, -0.43646389f, -0.35504115f, -0.26818037f, 
    -0.24822642f, -0.23846053f, -0.32786992f, -0.46262413f, 0.13503908f, 0.21872266f, -0.25022140f, 0.08052041f, 
    0.13490921f, 0.08519614f, -0.18295383f, 0.02291174f, -0.15128280f, 0.12984331f, -0.05530258f, 0.01741956f, 
    -0.08109093f, -0.30394870f, -0.32188502f, 0.00609934f, -0.50015396f, -0.76930648f, -0.60196257f, -0.51881409f, 
    0.35027808f, 0.14687063f, 0.13371953f, 0.11013861f, -0.30482081f, 0.33371320f, -0.05692766f, 0.26741919f, 
    -0.35018948f, 0.18152112f, -0.27756763f, -0.09205790f, -0.02099204f, 0.05835294f, 0.08158489f, -0.27482682f, 
    -0.23042068f, 0.14562471f, 0.07647955f, -0.39013734f, -0.41528004f, 0.97600484f, 0.61592734f, -0.71501631f, 
    0.01048192f, -0.35831460f, -0.13316798f, 0.01983171f, 0.34983453f, 0.13046432f, -0.37970313f, -0.36294410f, 
    -0.35033974f, -0.01371235f, 0.32604393f, 0.33240452f, 0.36273864f, -0.04533448f, -0.17315722f, 0.13023478f, 
    -0.23988566f, -0.06823508f, -0.20617560f, -0.05809336f, -0.18125607f, 0.31351221f, -0.43186238f, -0.52770334f, 
    -0.12386942f, -0.19263339f, 0.00428265f, 0.29974943f, 0.41939282f, 0.52128857f, -0.40679401f, -0.34246355f, 
    -0.06287766f, -0.14166234f, -0.19992159f, -0.31777263f, -0.25963703f, -0.08657995f, 0.18989462f, 0.22969383f, 
    0.11482377f, 0.19680627f, 0.12601078f, -0.26372877f, -0.10906386f, 0.38225845f, 0.18339096f, -0.05061916f, 
    0.02451752f, 0.17422770f, -0.54258126f, -0.17711598f, -0.38360962f, -0.04938405f, 0.37638968f, -0.03974963f, 
    -0.02796486f, -0.22357860f, -0.15097465f, 0.46140841f, -0.24583417f, 0.00188634f, 0.02556946f, 0.06443901f, 
    -0.16928466f, -0.13964087f, -0.10857582f, -0.28926969f, 0.02102339f, 0.02476067f, -0.24054933f, 0.65549123f, 
    0.14581043f, -0.31589469f, 0.12538907f, -0.84016949f, -0.26840296f, -0.07309635f, -0.13705432f, 0.17196232f, 
    -0.11808413f, 0.33587143f, -0.08701993f, 0.04332144f, -0.19336657f, -0.22604817f, -0.28862134f, -0.17237008f, 
    -0.00372004f, 0.04134230f, -0.16097653f, -0.26829052f, 0.06007984f, -0.12362962f, -0.12091491f, -0.40376580f, 
    -0.28838345f, 0.10634399f, 0.48045093f, -0.05355784f, -0.10025463f, -0.76299345f, -0.36725751f, 0.25134367f, 
    0.49439165f, 0.24982689f, -0.19624741f, 0.15957153f, 0.33526152f, -0.10343946f, -0.24723715f, 0.32271478f, 
    -0.25901386f, -0.11931147f, -0.27352074f, -0.08541238f, -0.10000239f, 0.17567092f, 0.07854787f, -0.03626239f, 
    0.02967823f, -0.21789202f, -0.18516840f, -0.33642760f, 0.03163730f, -0.43949959f, 0.20551170f, 0.18455352f, 
    -0.32964134f, -0.38220146f, 0.12022977f, -0.28419429f, -0.47007760f, -0.08680903f, -0.23844892f, -0.02436185f, 
    0.07397269f, -0.19063570f, -0.02011975f, 0.03366458f, -0.14741495f, -0.11043973f, -0.29348248f, -0.29133484f, 
    -0.10649617f, -0.26963261f, 0.09635931f, -0.20699015f, 0.05786014f, -0.10926486f, 0.05541466f, 0.15429044f, 
    0.13314396f, -0.01723940f, 0.22365227f, 0.22710930f, -0.15113401f, 0.13310850f, 0.04793074f, 0.08165885f, 
    0.07341741f, -0.07736176f, 0.10986021f, 0.08540276f, 0.13209799f, 0.11088400f, -0.22061542f, 0.20170331f, 
    0.27348095f, -0.09558082f, -0.29007116f, 0.80011290f, -0.53757876f, -0.54732603f, -0.16554070f, -0.18868281f, 
    -0.05096514f, -0.00174554f, 0.35944957f, 0.15914993f, -0.14094903f, -0.37766847f, 0.51498085f, -0.26977107f, 
    -0.23902580f, 0.27409470f, -0.20232436f, 0.15882328f, 0.17301419f, -0.26185071f, -0.21524811f, 0.10856639f, 
    0.03392947f, -0.13508719f, -0.04201718f, 0.04908567f, -0.16853547f, 0.18214402f, -0.15085816f, 0.18335460f, 
    -0.19820474f, 0.11887278f, -0.29523242f, 0.13797638f, 0.25090000f, 0.05571780f, 0.03679651f, 0.13505428f, 
    0.05431902f, -0.24876027f, 0.04696142f, 0.09262489f, 0.08303609f, 0.13789949f, -0.13302800f, -0.30507919f, 
    -0.09832115f, -0.05337520f, -0.25394180f, 0.28083506f, -0.28799728f, 0.30343860f, 0.15716501f, 0.05832880f, 
    0.07554851f, 0.14334603f, -0.23054150f, -0.28421634f, 0.26833624f, 0.20025033f, -0.12137160f, 0.20624733f, 
    -0.30192974f, -0.13913798f, 0.22333102f, 0.18697922f, 0.17339389f, 0.18389556f, -0.29619303f, -0.09829052f, 
    -0.16526631f, 0.15715063f, 0.10423507f, -0.00093767f, 0.13778879f, -0.10837875f, 0.60613924f, 0.22334823f, 
    0.06974571f, -0.27437302f, -0.44214839f, 0.34940508f, -0.42330158f, -0.18952848f, 0.47449383f, -0.16660540f, 
    0.28547990f, -0.31128019f, -0.08680698f, 0.14619082f, -0.22717100f, 0.21047425f, 0.03480304f, 0.28397056f, 
    -0.26217225f, 0.00774918f, -0.15390652f, 0.03052092f, -0.23164734f, 0.06195340f, 0.32018861f, -0.71983957f, 
    -0.29794881f, -0.03093344f, -0.35652342f, -0.29038474f, 0.37834650f, -0.00064558f, -0.27703899f, -0.24414042f, 
    0.01021690f, -0.09506123f, -0.16815323f, -0.15059364f, -0.30881533f, -0.00400216f, 0.26548338f, 0.30451450f, 
    0.15511627f, 0.11879086f, 0.16801184f, 0.17375414f, 0.09456466f, 0.02845038f, -0.24333918f, -0.35161704f, 
    0.10676720f, -0.24948800f, -0.53169686f, -0.55358595f, -0.33503896f, 0.35643062f, 0.36434069f, 0.15350676f, 
    0.45015097f, -0.06340367f, -0.11764976f, -0.04147260f, -0.05634073f, -0.05761787f, -0.02770532f, 0.22695446f, 
    0.33359417f, -0.06584013f, -0.18143311f, -0.04784519f, 0.03584274f, -0.06807914f, -0.21931095f, -0.15729907f, 
    0.07336903f, 0.14498432f, -0.33483496f, -0.42929879f, -0.35032648f, -0.26894885f, -0.20021924f, -0.21233384f, 
    0.19454809f, 0.33433855f, -0.10871346f, -0.07387179f, 0.04021853f, -0.06920776f, 0.15323123f, -0.09193867f, 
    0.10946040f, 0.17845121f, -0.01463384f, -0.10098477f, 0.12169397f, -0.11068186f, -0.17084782f, -0.17801300f, 
    -0.18253139f, -0.30921832f, -0.30135989f, -0.16031103f, 0.38368380f, 0.65952593f, 0.51135367f, -0.00631751f, 
    -0.36800754f, -0.47573769f, -0.22084779f, 0.08101092f, -0.30732292f, -0.19838142f, -0.24637493f, -0.03603084f, 
    0.18737379f, 0.14520119f, -0.07253613f, 0.12698741f, 0.04198433f, 0.14663070f, -0.08847337f, 0.04768939f, 
    -0.30968070f, 0.13467896f, 0.03893176f, -0.55226427f, 0.32755342f, 0.44185731f, 0.05987627f, -0.33250549f, 
    -0.57518923f, -0.17796172f, 0.25770995f, 0.07605158f, -0.12780757f, 0.15703738f, 0.42699385f, 0.21138231f, 
    -0.19360253f, -0.10015310f, 0.21255822f, -0.12545550f, -0.15303794f, -0.36785743f, -0.46501464f, 0.09675024f, 
    0.10741236f, 0.09562198f, 0.26966935f, 0.24362914f, -0.63131142f, 0.16881332f, 0.19698925f, -0.39419639f, 
    -0.37055281f, 0.52373791f, -0.36594537f, -0.67215800f, -0.33211598f, -0.34966502f, -0.19245295f, -0.07908215f, 
    -0.04723924f, -0.35437825f, -0.27423406f, -0.15397073f, -0.06632123f, -0.06066462f, -0.19642276f, -0.30345249f, 
    0.08159018f, -0.04980934f, -0.15189236f, -0.15513106f, -0.05417536f, -0.93238634f, -0.13264792f, -0.43579614f, 
    0.51068246f, 0.50454515f, -0.25069448f, -0.02360930f, 0.50973165f, 0.42284560f, 0.11682261f, 0.16245599f, 
    0.03086262f, 0.28583419f, -0.16224355f, 0.03053161f, -0.06820408f, -0.05770700f, 0.00732834f, -0.34795901f, 
    -0.02933427f, -0.03364753f, -0.03612204f, 0.12617585f, 0.11379994f, 0.21206298f, 0.38333079f, 0.08881125f, 
    -0.14437118f, -0.21829921f, 0.17836237f, 0.23281237f, 0.03479082f, 0.04385596f, -0.31525090f, 0.03322961f, 
    0.33285651f, -0.28105077f, 0.48815328f, -0.54472321f, -0.18196872f, 0.30395675f, 0.02336830f, -0.08804253f, 
    0.13828467f, -0.34914124f, 0.13936161f, -0.13846116f, -0.07038744f, 0.31025344f, -0.02705464f, 0.24751414f, 
    -0.51474214f, -0.13742463f, 0.20650558f, -0.00177782f, -0.27629066f, -0.03564803f, -0.37548184f, -0.12544723f, 
    -0.32978454f, 0.39917660f, -0.52615583f, 0.27346987f, 0.16982484f, 0.16456853f, -0.39550689f, 0.04226137f, 
    0.05084021f, -0.19960019f, -0.07589259f, 0.15972330f, 0.04180078f, -0.02322764f, 0.02951182f, 0.24899590f, 
    -0.55097526f, 0.05573354f, 0.57286882f, -0.12936038f, 0.22896914f, -0.41992158f, -0.34673908f, -0.40458351f, 
    -0.07390090f, 0.07564170f, 0.36756086f, -0.13643016f, 0.21214366f, 0.19303469f, -0.02669421f, -0.05178795f, 
    -0.06009088f, 0.04678001f, -0.13280071f, -0.09073797f, 0.01001008f, -0.31774801f, -0.22069529f, -0.03841887f, 
    -0.22084671f, -0.35264769f, -0.02512443f, 0.01596020f, 0.39142203f, 0.21983133f, -0.58949775f, -0.42716807f, 
    0.11332339f, -0.03777682f, 0.65519309f, -0.26318714f, -0.00586787f, 0.11695603f, 0.23166922f, -0.18540391f, 
    -0.06556704f, 0.18000695f, 0.02768010f, -0.00691179f, -0.32044125f, -0.07547993f, 0.08981338f, 0.20165740f, 
    -0.32440326f, 0.15807155f, 0.27969781f, 0.18912444f, 0.34341460f, 0.22781524f, -0.16180094f, 0.09950878f, 
    -0.17258346f, -0.07565072f, 0.42621917f, -0.25765908f, -0.30076727f, -0.16127387f, -0.17605101f, 0.10227167f, 
    -0.09776657f, 0.22227660f, 0.01027848f, -0.22466552f, 0.08958204f, 0.27665743f, 0.09998896f, -0.11631763f, 
    -0.19610217f, -0.32871404f, -0.27328417f, 0.48589471f, 0.46511391f, 0.37130216f, 0.10378740f, -0.17496784f, 
    -0.24977642f, -0.33268344f, 0.05141740f, 0.00228716f, -0.27856910f, -0.19365972f, 0.07891377f, 0.12388086f, 
    -0.06847864f, -0.08350430f, -0.10721616f, 0.30929571f, 0.01699409f, -0.27312964f, 0.10725033f, 0.10695974f, 
    -0.32307473f, -0.25214422f, 0.10012722f, 0.19306739f, 0.37524423f, 0.22520268f, 0.36612159f, -0.05806486f, 
    -0.12371916f, 0.13985266f, -0.14724918f, -0.22715588f, -0.23554812f, 0.51381910f, 0.23750386f, 0.07351106f, 
    0.04888137f, -0.29472253f, -0.24528076f, -0.13402800f, -0.24913764f, -0.04170160f, 0.01551268f, -0.01745756f, 
    -0.05238552f, -0.19846682f, -0.05339784f, -0.01302025f, 0.17086653f, -0.18352571f, -0.40999582f, 0.29016045f, 
    0.22500323f, -0.02304520f, 0.38341185f, -0.06576002f, 0.07104447f, 0.08169210f, -0.10092489f, -0.11151945f, 
    0.16279528f, -0.27726990f, 0.10193013f, -0.12279870f, -0.08835791f, -0.04391884f, -0.19046909f, -0.17338239f, 
    0.23557837f, -0.17376551f, -0.15459445f, 0.15015869f, 0.25627935f, 0.12977637f, -0.13668540f, -0.36836010f, 
    -0.15463167f, -0.15688832f, -0.12813807f, 0.05936623f, -0.36009848f, -0.41066611f, -0.28198284f, -0.34993553f, 
    -0.24238868f, 0.02302303f, -0.01795514f, -0.16637693f, -0.37793100f, 0.08621708f, -0.31423822f, -0.11726595f, 
    -0.14114143f, -0.09484164f, -0.29342157f, -0.03700838f, 0.15434971f, 0.16334675f, 0.14264238f, -0.06678905f, 
    0.15811825f, 0.20383358f, -0.22263131f, -0.21595736f, -0.34781671f, -0.08818220f, 0.59031230f, -0.36374158f, 
    -0.29412413f, -0.41389704f, -0.02819027f, -0.01890598f, -0.01673222f, 0.13558310f, 0.02330840f, -0.32836753f, 
    -0.03057628f, -0.03389005f, 0.40498203f, -0.27524275f, 0.08556464f, -0.39615345f, -0.02217236f, -0.44781095f, 
    0.44005197f, -0.45691779f, -0.12354966f, 0.19129463f, 0.36878312f, 0.11528322f, -0.34150043f, 0.11165825f, 
    -0.33734325f, 0.09286340f, -0.06634856f, 0.25781429f, -0.03492851f, -0.54020643f, 0.27995652f, -0.16173023f, 
    0.23210582f, -0.27234623f, 0.09346980f, 0.06738218f, -0.21111205f, 0.13211390f, -0.10397735f, 0.01146260f, 
    0.05306976f, -0.33613420f, -0.26237869f, -0.27616516f, 0.14628337f, 0.14867590f, -0.17739518f, -0.02653510f, 
    0.20556496f, -0.06032163f, -0.36037195f, -0.13088076f, 0.34570262f, -0.03998573f, -0.00652621f, 0.09323993f, 
    0.19461486f, -0.22004746f, -0.04868252f, -0.05836970f, 0.08364744f, 0.16332425f, 0.13622901f, 0.12105941f, 
    0.06795300f, -0.14767498f, 0.22605933f, 0.06172080f, 0.11601692f, 0.33168909f, -0.33528805f, 0.28961530f, 
    -0.06166052f, -0.13502344f, 0.16173467f, -0.09034534f, -0.10050722f, 0.06132080f, -0.04268536f, -0.13883772f, 
    -0.18367864f, -0.00646916f, -0.00739586f, -0.00700507f, 0.13893357f, -0.00081222f, -0.24776295f, -0.24392661f, 
    0.03897257f, -0.30004531f, -0.51486659f, -0.41502041f, -0.37043571f, -0.20973334f, -0.11503638f, 0.18491693f, 
    -0.10768085f, -0.40289420f, -0.52426612f, -0.48272225f, -0.30811477f, 0.44479164f, 0.51767284f, 0.37474790f, 
    0.10594092f, -0.03626575f, -0.35409626f, 0.10295220f, -0.20128748f, -0.33601424f, -0.22240444f, 0.31853732f, 
    0.08354908f, -0.13862160f, -0.00016966f, -0.04370186f, -0.04516547f, -0.28801045f, 0.15242454f, 0.25848544f, 
    0.32357603f, 0.45682287f, 0.42662445f, -0.14362752f, -0.18019892f, -0.06863049f, -0.26098749f, 0.20433228f, 
    0.03574111f, -0.11450321f, -0.28060004f, -0.07609810f, 0.00094267f, -0.01120205f, 0.07673036f, 0.06718756f, 
    0.02991504f, -0.24557664f, -0.07068509f, -0.24551766f, -0.03354862f, -0.49574894f, 0.53219324f, 0.20981225f, 
    -0.37387881f, -0.01948685f, -0.17843522f, 0.27921176f, 0.03236431f, -0.16400521f, -0.13200234f, 0.35174739f, 
    0.09819502f, -0.21181396f, -0.20752005f, 0.22254759f, -0.24466850f, 0.06957756f, -0.04241411f, -0.24601164f, 
    -0.41681221f, 0.04028613f, -0.04241203f, -0.27830857f, -0.24068207f, -0.34838533f, 0.05145327f, -0.66101217f, 
    0.36859894f, 0.42917827f, 0.53128767f, -0.45205343f, -0.33067232f, 0.29008055f, -0.11824936f, -0.12320717f, 
    0.07982294f, -0.35441807f, 0.26889646f, -0.19847013f, 0.25535983f, -0.30025747f, -0.18232763f, 0.42062035f, 
    -0.14724222f, -0.26934579f, 0.05247845f, -0.07899072f, -0.19471388f, 0.39547524f, 0.18034546f, -0.50448269f, 
    -0.32191294f, -0.14541890f, 0.20662522f, -0.02280672f, -0.19899297f, -0.14059459f, 0.02935249f, 0.29710758f, 
    0.40622228f, -0.00725746f, -0.19980572f, 0.34331203f, -0.04562355f, 0.24949101f, -0.19515280f, 0.12124860f, 
    -0.36204427f, 0.00829642f, -0.21129470f, 0.36778376f, -0.19288144f, 0.20280507f, 0.00393156f, 0.26402083f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.04935763f, 0.02543690f, 0.11259553f, 0.10932104f, 0.26734561f, 0.06936633f, -0.17959872f, 0.11768053f, 
    0.11346216f, -0.21788868f, 0.24949616f, 0.26400185f, -0.03414918f, -0.22073776f, 0.15700363f, -0.07499056f, 
    0.22627564f, 0.10530791f, -0.26099446f, 0.12812503f, -0.06892150f, 0.15223292f, 0.08446523f, 0.18873087f, 
    -0.05372918f, 0.03626300f, -0.05530582f, -0.14802943f, 0.21899097f, 0.12992145f, 0.17858472f, 0.09081599f, 
    0.17675695f, -0.30111575f, -0.20799665f, 0.01310390f, -0.01894556f, -0.17895019f, 0.17355545f, -0.11974934f, 
    0.11509406f, -0.20809674f, -0.06836155f, 0.09857993f, -0.01250111f, -0.03819074f, 0.06317052f, -0.02091093f, 
    -0.03680221f, 0.20526527f, -0.05368013f, 0.15841104f, 0.31832746f, 0.28714022f, -0.16690120f, 0.22514270f, 
    0.00998077f, 0.00752984f, -0.08567842f, -0.05350280f, -0.03221618f, -0.12178627f, 0.19597258f, -0.01894109f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.02399565f, -0.02811597f, -0.02294537f, 0.02158769f, -0.00233151f, -0.02355979f, -0.00117967f, -0.00809097f, 
    0.02863004f, 0.01270785f, 0.01550486f, -0.01417259f, 0.01045681f, -0.00819154f, -0.03274117f, 0.02121970f, 
    -0.00488335f, -0.01010006f, -0.03477719f, 0.00441970f, 0.02036124f, -0.00853570f, -0.03331253f, -0.00183881f, 
    0.02407856f, -0.02503109f, -0.02863331f, -0.02040055f, 0.01235810f, -0.02482131f, -0.02675043f, -0.01952860f, 
    0.00083202f, -0.01448628f, -0.02780497f, 0.02099769f, 0.00894381f, -0.03858199f, -0.00318184f, -0.02683645f, 
    -0.00310507f, -0.03795951f, -0.00378355f, -0.00999904f, 0.00595457f, -0.01506328f, 0.02941245f, -0.04181023f, 
    -0.03861279f, 0.00562285f, -0.02604205f, 0.00746054f, 0.03483437f, -0.02377835f, 0.00792734f, -0.00275815f, 
    0.00762972f, -0.03976544f, -0.01851306f, -0.02644063f, -0.01737776f, 0.01783229f, 0.00357613f, 0.00767770f, 
    0.02077109f, -0.00442019f, 0.01152492f, -0.00101175f, -0.03723793f, 0.01303919f, 0.02495109f, 0.00293915f, 
    -0.00892367f, -0.00862215f, -0.00288015f, 0.01724673f, 0.01112434f, -0.03017142f, 0.02228126f, -0.02595194f, 
    -0.03323270f, 0.00657113f, -0.03508115f, 0.01891304f, -0.01711256f, -0.02680812f, 0.02440248f, 0.02433870f, 
    -0.03478491f, -0.00463730f, 0.00905853f, 0.02503048f, 0.02659182f, -0.04201561f, 0.02290835f, 0.00264758f, 
    0.01272654f, -0.03842607f, 0.01870758f, 0.01185241f, 0.00779051f, 0.02937886f, -0.04078764f, -0.00524558f, 
    0.01626941f, 0.01659411f, -0.00294940f, -0.02862152f, -0.01730407f, -0.01572681f, 0.02441601f, -0.03833511f, 
    0.02857412f, -0.00903162f, 0.02113554f, 0.00744073f, 0.00828670f, 0.00208438f, -0.01483279f, -0.00318014f, 
    -0.02030086f, -0.02046591f, -0.01210571f, -0.02346556f, -0.01570185f, 0.02164494f, -0.01801399f, 0.01859180f, 
    -0.02309811f, 0.01099692f, -0.02042609f, -0.03157211f, -0.01275946f, -0.00680008f, -0.02907666f, -0.04033649f, 
    -0.00757587f, 0.00882964f, 0.02466096f, 0.00441937f, -0.00439716f, 0.00974342f, 0.02709633f, 0.01637362f, 
    -0.03170134f, 0.02327876f, 0.00548001f, -0.03536700f, 0.01812356f, -0.00951367f, 0.01278918f, -0.00402692f, 
    0.00562419f, -0.03217475f, -0.00993740f, -0.01760919f, -0.04100273f, 0.02971914f, -0.01221112f, -0.00557575f, 
    -0.02860834f, -0.00637095f, 0.02637762f, -0.00406457f, -0.03875257f, 0.00895686f, -0.01634740f, -0.03425673f, 
    0.01183416f, -0.03149658f, 0.02057069f, -0.04397631f, 0.01335792f, 0.01222190f, -0.00553099f, -0.04054606f, 
    -0.00910962f, -0.00049182f, -0.04209488f, -0.00767149f, -0.00609804f, -0.01737338f, 0.02015931f, -0.00878942f, 
    0.00598681f, 0.01073689f, -0.04289843f, -0.03397818f, -0.03326602f, -0.01124152f, -0.02859218f, 0.00874553f, 
    0.01781530f, -0.01054363f, -0.02115481f, 0.00256358f, -0.01177587f, 0.03039080f, -0.03460090f, 0.01746168f, 
    -0.01587487f, 0.00466781f, 0.01461171f, -0.04444798f, -0.02088078f, -0.00004904f, 0.01317064f, -0.00987155f, 
    -0.01769160f, -0.00383903f, -0.00388770f, -0.02329548f, 0.00983075f, -0.02890071f, 0.00585390f, -0.01631671f, 
    -0.01994351f, 0.02462552f, -0.01124433f, 0.00773797f, 0.02810821f, -0.02154479f, -0.03582443f, -0.00414462f, 
    -0.03925941f, 0.02215616f, 0.02412030f, -0.03390029f, 0.00476491f, 0.01670531f, -0.00381518f, 0.01769176f, 
    -0.01834349f, -0.03534226f, -0.03087943f, -0.00140413f, -0.03993826f, 0.00640226f, 0.01092384f, -0.01353686f, 
    -0.02150222f, 0.00640653f, -0.03493354f, 0.00469729f, 0.02343642f, -0.03844903f, -0.03120895f, -0.01653242f, 
    -0.00493994f, 0.01293916f, 0.02033241f, -0.02259117f, 0.01536506f, -0.00226629f, -0.03419675f, -0.04401728f, 
    -0.04432420f, -0.00675512f, 0.00043458f, -0.02445388f, 0.01365967f, -0.02954742f, 0.01426545f, -0.03537164f, 
    -0.00552257f, 0.00827750f, 0.00949610f, -0.02396948f, 0.01662763f, -0.01457693f, -0.01564747f, -0.01646346f, 
    0.01148624f, 0.02337975f, -0.03603494f, 0.00801954f, 0.00890485f, 0.02455822f, 0.03167206f, -0.01494871f, 
    0.02123147f, -0.01950030f, 0.01595046f, -0.02671991f, -0.01798926f, 0.02121977f, -0.03164521f, -0.02156390f, 
    0.01683919f, 0.02133131f, -0.03232661f, 0.01232493f, -0.00398184f, 0.02819431f, -0.01116214f, 0.01666441f, 
    -0.00013044f, -0.03636314f, 0.00498137f, 0.00464014f, -0.02554974f, -0.00450209f, 0.00338291f, 0.01212526f, 
    -0.02476747f, -0.01974428f, -0.01903283f, -0.00549291f, -0.01529620f, 0.01228199f, -0.01986722f, -0.01171931f, 
    -0.00620266f, -0.00428325f, 0.01354319f, -0.03370570f, 0.02721745f, -0.01699373f, 0.02592641f, 0.01318610f, 
    -0.02191877f, 0.01681685f, -0.01688261f, -0.00155593f, 0.00314188f, 0.01117602f, -0.00230217f, 0.01051142f, 
    -0.02845020f, 0.00208966f, 0.02235760f, -0.03386436f, 0.02003222f, -0.01500465f, 0.01647229f, -0.00805343f, 
    -0.02100779f, -0.03413375f, 0.01853920f, 0.02729937f, -0.01063583f, -0.01183811f, 0.02610089f, 0.02750235f, 
    0.00786106f, -0.03578791f, -0.01265576f, 0.00909414f, 0.02451611f, -0.00435274f, -0.00415677f, -0.01960334f, 
    0.00581198f, 0.02411575f, -0.00611513f, -0.03063593f, -0.00011513f, 0.01735410f, 0.01832811f, -0.00595242f, 
    0.00529055f, -0.03927185f, -0.02140919f, -0.02393998f, -0.02242376f, 0.02864293f, -0.03934401f, -0.02931176f, 
    -0.03170759f, -0.02910568f, 0.01437845f, -0.00182476f, -0.00836070f, -0.03011839f, -0.01029973f, 0.01200758f, 
    0.02286522f, 0.03303498f, 0.00141098f, 0.02025010f, 0.01860627f, -0.01467484f, 0.01386143f, 0.00492928f, 
    -0.01219495f, -0.00520348f, -0.02463282f, -0.01456066f, -0.04231204f, 0.01086051f, -0.04224578f, 0.00948933f, 
    0.01909170f, -0.00373838f, -0.00158250f, 0.02535863f, -0.04241327f, 0.02943472f, 0.01851134f, 0.02456226f, 
    -0.01974777f, 0.00180166f, -0.00578669f, 0.02483066f, -0.02882041f, 0.02763014f, 0.02531866f, 0.01303747f, 
    0.02351640f, -0.03645665f, -0.01004158f, 0.01816264f, 0.00461924f, 0.01793433f, -0.01571659f, 0.01543697f, 
    0.01854672f, 0.00992003f, -0.02040803f, -0.00725909f, -0.02038946f, -0.03272760f, 0.00726863f, 0.00346087f, 
    0.02378161f, 0.01105936f, 0.01801843f, -0.00866641f, -0.02766344f, 0.02432776f, 0.01239284f, -0.01662474f, 
    0.01435650f, -0.02314525f, 0.00082870f, 0.01262905f, 0.02374750f, 0.01183852f, 0.02597169f, -0.01208466f, 
    -0.04125456f, -0.01602646f, 0.01005414f, 0.00094794f, -0.01640322f, -0.00076165f, -0.00355661f, 0.02661858f, 
    -0.02616428f, 0.02697296f, -0.01961765f, 0.01279062f, -0.00937734f, -0.02815819f, 0.02323322f, 0.01055016f, 
    -0.04025959f, -0.00780606f, -0.03491972f, 0.02185482f, 0.01015920f, -0.02048707f, -0.01531475f, -0.03526026f, 
    0.00870134f, -0.01349117f, -0.01560764f, 0.00065344f, 0.01697937f, 0.00214610f, -0.01420633f, 0.00454523f, 
    -0.03103413f, -0.00235731f, 0.03132369f, 0.00526796f, 0.00818943f, -0.00619150f, -0.02242709f, -0.02772330f, 
    -0.03078914f, 0.01759480f, -0.02487623f, 0.02281795f, 0.01557464f, 0.00753525f, -0.00832434f, -0.01234721f, 
    -0.02398234f, 0.00715248f, 0.01848368f, -0.03962253f, -0.03152159f, 0.01977468f, 0.02565250f, 0.02589359f, 
    0.00215519f, 0.01541831f, -0.04386372f, 0.00978579f, -0.00632024f, -0.03430254f, -0.04109748f, -0.03727208f, 
    0.02275941f, 0.02174854f, 0.01851453f, 0.01511395f, 0.01351170f, 0.00304067f, 0.00712984f, 0.02970356f, 
    -0.00156868f, -0.01749823f, -0.03071159f, -0.02505810f, -0.02429670f, -0.01199767f, -0.03177439f, -0.03930870f, 
    0.01053401f, -0.03596713f, -0.00388216f, -0.00015077f, -0.02900765f, -0.00259668f, -0.03752564f, -0.02065563f, 
    -0.04109573f, -0.03502639f, -0.01118745f, -0.00715861f, -0.03435169f, 0.02241399f, -0.03826405f, -0.02386598f, 
    0.00797404f, -0.03661551f, 0.02883225f, -0.03276939f, -0.03209981f, -0.04210100f, -0.01347840f, -0.01407013f, 
    -0.02795109f, 0.01029051f, -0.00587094f, -0.03489417f, -0.02972659f, -0.00554234f, -0.00138236f, 0.00542003f, 
    0.02111038f, -0.04336952f, 0.02304165f, 0.01379191f, -0.01820784f, 0.00621764f, 0.02132148f, -0.01917554f, 
    0.01776647f, -0.02301632f, 0.00906325f, -0.04045450f, -0.01513656f, -0.02166632f, -0.03765928f, -0.03423328f, 
    0.01158861f, -0.03599235f, 0.01186982f, -0.01329975f, 0.00710692f, 0.02699406f, 0.00121863f, -0.00169687f, 
    0.01409212f, -0.04269467f, -0.02021211f, 0.00165360f, 0.00195588f, -0.02406038f, -0.01740851f, 0.01846294f, 
    -0.02857938f, 0.01263731f, 0.02608656f, 0.03293499f, 0.01032211f, 0.01015800f, 0.02237465f, 0.01826923f, 
    -0.00688737f, 0.01167646f, 0.02467390f, 0.01845842f, -0.01215294f, -0.01516847f, 0.02243770f, -0.00312801f, 
    -0.03619634f, -0.00578632f, -0.01123539f, -0.02877118f, -0.01543485f, -0.03179551f, -0.00045215f, -0.02815734f, 
    -0.01607641f, 0.01443858f, 0.01570516f, 0.01950440f, 0.01348497f, 0.01435669f, 0.00381363f, -0.01005145f, 
    0.00896918f, -0.03436961f, -0.01097464f, -0.01896205f, 0.01953542f, -0.01965603f, -0.00836925f, -0.04039462f, 
    -0.00169712f, -0.00399166f, -0.02406115f, 0.02309196f, -0.03100793f, 0.02535589f, -0.02776061f, 0.00653572f, 
    -0.00545302f, -0.03397843f, -0.00927115f, -0.00705756f, -0.02692482f, -0.03213548f, -0.03980279f, -0.01186472f, 
    -0.03041983f, -0.01116950f, -0.03142678f, 0.00338479f, 0.01466241f, 0.01057763f, -0.01393149f, -0.04240592f, 
    -0.02635979f, -0.03662600f, -0.02853747f, -0.02235941f, -0.01964209f, -0.02923769f, 0.00865289f, -0.03106343f, 
    -0.03294877f, 0.02118796f, 0.03142644f, 0.01937542f, 0.00104658f, -0.03403758f, -0.02649401f, 0.01336733f, 
    -0.01427684f, 0.02216104f, 0.02303098f, 0.00932888f, -0.03296154f, -0.03062762f, -0.02268071f, 0.01222509f, 
    -0.01386552f, 0.00185006f, -0.00258619f, -0.03845940f, 0.00553236f, 0.00758552f, -0.03779002f, 0.00611915f, 
    -0.02473410f, 0.01217629f, 0.01115889f, -0.00522304f, -0.02723179f, -0.01911495f, -0.04397020f, -0.01869815f, 
    -0.02882006f, -0.00453970f, -0.01983754f, -0.04240424f, -0.03844060f, -0.03248006f, -0.01620434f, 0.01308046f, 
    0.01590849f, 0.00596984f, 0.01265639f, 0.02536625f, 0.02553046f, -0.01641928f, 0.02008620f, 0.01520196f, 
    -0.00571691f, 0.00678288f, -0.03473701f, -0.00761632f, 0.02039036f, -0.03528738f, 0.01287318f, 0.02364252f, 
    -0.00554371f, -0.01297930f, -0.02660320f, 0.01830810f, 0.00020982f, 0.02757784f, -0.01893206f, 0.00143558f, 
    -0.00519457f, 0.00922589f, 0.01948777f, -0.00662221f, -0.03384537f, 0.01296607f, -0.01754034f, 0.02295760f, 
    -0.02681756f, -0.00872817f, -0.02599669f, 0.00080067f, -0.02136357f, -0.02648171f, -0.01834284f, -0.01788412f, 
    0.02559964f, -0.03921266f, -0.00643875f, -0.00659261f, -0.02902288f, -0.02331640f, -0.02740339f, -0.03850321f, 
    0.00997704f, -0.03494046f, 0.01623059f, -0.02502989f, -0.03582484f, -0.01618285f, 0.02512102f, -0.03442544f, 
    0.01462013f, -0.00525728f, -0.00193639f, -0.00503063f, -0.01844029f, 0.02758489f, 0.02290845f, -0.03178218f, 
    -0.03115214f, -0.00383145f, -0.01036264f, -0.01650880f, -0.00393592f, 0.01306013f, -0.01716029f, 0.01031020f, 
    0.00548821f, 0.24925463f, -0.17639853f, -0.18603691f, 0.00174966f, -0.07762185f, 0.07431278f, 0.07682286f, 
    0.11167852f, -0.05068729f, -0.04593699f, -0.15272999f, 0.02611331f, -0.08194512f, 0.07714334f, -0.09402105f, 
    0.04638190f, -0.09374726f, 0.06606427f, 0.18227226f, -0.07828549f, -0.06594673f, -0.06230643f, -0.06193101f, 
    0.54231322f, 0.11573804f, 0.13141567f, 0.21079972f, -0.00677970f, -0.07725251f, -0.06199384f, -0.19530213f, 
    0.14044276f, 0.04185311f, 0.11727186f, 0.14573948f, 0.19338720f, 0.27757281f, 0.14946844f, 0.02410130f, 
    -0.12441282f, 0.14251709f, -0.04863886f, 0.19332287f, 0.04917418f, -0.05059606f, -0.06547510f, -0.01972639f, 
    0.21183619f, -0.19138181f, 0.13139182f, 0.09784183f, -0.03911176f, -0.04694822f, 0.05374753f, 0.09120438f, 
    0.11404830f, -0.05495808f, 0.05952606f, 0.07926788f, -0.25132483f, 0.10328722f, 0.17735744f, -0.02174401f, 
    -0.04872860f, -0.00149735f, -0.12282880f, -0.16287859f, 0.05681692f, 0.04476741f, 0.01454383f, 0.20011923f, 
    0.17526585f, 0.21679427f, 0.17771938f, -0.08372819f, -0.01586623f, -0.05451314f, -0.01507500f, 0.24220572f, 
    0.02999247f, 0.15100297f, -0.01247200f, -0.02870795f, -0.05895241f, -0.03804691f, -0.24943769f, 0.10692813f, 
    -0.07343141f, -0.08747678f, -0.03234937f, -0.03845502f, 0.05530133f, -0.21334541f, 0.03475065f, 0.02834625f, 
    0.12571384f, 0.11064513f, 0.06476998f, -0.13789766f, 0.15667035f, -0.13160646f, 0.06371203f, -0.15550084f, 
    -0.10381033f, -0.06002908f, -0.05369841f, 0.00260518f, 0.16250639f, 0.16653553f, 0.15127835f, 0.14958717f, 
    0.19904730f, 0.16142388f, -0.06215987f, -0.13683495f, 0.13968311f, 0.06609736f, -0.15449569f, 0.08062303f, 
    -0.00172808f, -0.13541956f, 0.03279978f, 0.02670447f, -0.02180913f, -0.05251723f, -0.02636823f, -0.07840172f, 
    -0.02711561f, -0.05607946f, -0.05681081f, -0.04757825f, 0.15497519f, 0.01970317f, 0.17205121f, 0.03357280f, 
    -0.00207352f, -0.03163808f, 0.01890506f, -0.09093018f, 0.01116577f, 0.01001920f, 0.05761009f, 0.01055032f, 
    0.09888300f, 0.10079816f, 0.06995581f, -0.14442073f, 0.02969498f, 0.08355952f, -0.06701574f, -0.11020370f, 
    0.03127324f, -0.02356321f, -0.04461432f, -0.04755966f, 0.23867291f, -0.16224903f, 0.04102659f, 0.15543132f, 
    0.01175679f, 0.14340383f, -0.17602195f, -0.07206781f, 0.08801716f, 0.01085457f, -0.02681419f, 0.02234538f, 
    -0.09810746f, -0.13614485f, 0.01638833f, -0.00404267f, 0.13443361f, 0.03885621f, 0.04157070f, 0.04418695f, 
    -0.12720671f, -0.13171487f, 0.01834757f, -0.16941960f, 0.21752442f, 0.02297254f, 0.23052242f, -0.22478004f, 
    -0.06679384f, -0.05503561f, 0.20497021f, 0.00444907f, 0.00266147f, 0.03410769f, 0.06122554f, 0.04069991f, 
    0.39213639f, 0.03440254f, 0.15906543f, 0.06722330f, -0.05348180f, -0.09162713f, -0.06770217f, -0.07611057f, 
    -0.06082677f, -0.01434414f, 0.06789154f, 0.08260240f, 0.20462351f, -0.05521925f, -0.08021503f, 0.14687279f, 
    -0.04366961f, -0.05741197f, -0.00200249f, -0.02956139f, 0.04547118f, 0.00352313f, -0.10629412f, 0.02370032f, 
    0.02244669f, -0.15064560f, -0.07743214f, -0.08326603f, 0.04855021f, 0.00775110f, 0.01500150f, -0.11147939f, 
    0.05948335f, -0.01844123f, 0.05467471f, -0.04071528f, -0.07742804f, 0.12307912f, 0.03804519f, 0.12231965f, 
    0.02423112f, -0.00785794f, 0.02063482f, 0.17688145f, -0.12257022f, -0.01687607f, -0.16487725f, -0.12616543f, 
    0.07941990f, -0.16743858f, 0.08160482f, -0.01950192f, 0.04635908f, 0.03385402f, 0.01751634f, -0.26384240f, 
    0.13450851f, -0.04943746f, -0.14601618f, 0.26009616f, 0.40750465f, 0.16311522f, 0.15206839f, -0.16227108f, 
    0.00285274f, 0.06019546f, 0.06347079f, -0.00303864f, -0.12152091f, -0.04846793f, -0.01966592f, -0.05200877f, 
    0.17798306f, 0.17383796f, 0.26073730f, 0.07464597f, 0.06443270f, -0.11307146f, -0.05651251f, -0.01420137f, 
    0.06380022f, -0.02458518f, -0.04976166f, 0.05233520f, -0.43492544f, 0.05874452f, -0.06555115f, -0.04384564f, 
    0.13743357f, -0.11230235f, -0.01944870f, 0.05031743f, 0.02871136f, -0.10014263f, 0.06194797f, 0.01548593f, 
    0.07272043f, -0.02234522f, -0.08452513f, 0.01652350f, -0.03173715f, -0.02956385f, 0.07714497f, 0.00177320f, 
    -0.02418922f, -0.01220952f, 0.03520081f, 0.01976006f, -0.00093212f, 0.00425281f, -0.06593148f, 0.05783924f, 
    0.05378519f, -0.17537625f, -0.04826969f, 0.08617898f, 0.07079425f, -0.07371787f, 0.12462703f, 0.11045009f, 
    0.11157181f, 0.39830711f, -0.22334753f, 0.01348476f, 0.02435667f, -0.01134094f, 0.02329198f, 0.04276583f, 
    0.10354195f, 0.09877179f, 0.02025558f, 0.00829501f, 0.32563213f, -0.10682760f, 0.22619438f, -0.04332849f, 
    0.09407128f, -0.02222368f, 0.11317947f, 0.01288891f, 0.04402016f, -0.03222925f, 0.06887449f, 0.04799129f, 
    -0.25177628f, 0.17014912f, -0.23373993f, 0.02953158f, 0.19800206f, -0.06582276f, -0.07966305f, -0.15593493f, 
    0.16517586f, 0.11960515f, 0.02227480f, 0.06669591f, 0.08259160f, 0.08937346f, 0.05968449f, -0.13307205f, 
    0.05284364f, 0.02047408f, -0.01441348f, 0.11851610f, -0.03722519f, -0.09603295f, -0.11827994f, -0.20042297f, 
    -0.03385995f, -0.06096245f, 0.02618242f, -0.06473354f, -0.02378854f, -0.04050502f, 0.08048388f, -0.11968490f, 
    0.08050314f, 0.02331152f, 0.06724747f, 0.13190877f, -0.07661866f, 0.07348068f, 0.18471254f, -0.26031950f, 
    -0.00287243f, -0.05943950f, -0.06600504f, 0.06539446f, 0.10667196f, -0.05030847f, 0.07598808f, 0.11582828f, 
    -0.39900070f, 0.02615679f, -0.09695041f, 0.00891886f, -0.01259424f, 0.13431348f, -0.13438690f, -0.10939385f, 
    0.19303951f, -0.04260989f, 0.03217716f, 0.04914774f, 0.18920659f, 0.04533497f, 0.00616873f, -0.01702219f, 
    0.11722066f, 0.08921739f, -0.04391294f, 0.08299444f, 0.08709235f, 0.07330617f, 0.02578614f, 0.14026760f, 
    0.06692816f, -0.00654884f, 0.04698320f, -0.00302400f, 0.04155993f, -0.05061996f, 0.02670639f, 0.03146505f, 
    0.09592427f, -0.00064429f, 0.06786954f, 0.04806288f, 0.22391203f, 0.03529618f, 0.20438583f, -0.14999700f, 
    -0.12255809f, 0.05816301f, 0.03484966f, -0.09726199f, 0.01313918f, 0.01135563f, -0.16115738f, -0.05672756f, 
    -0.01626336f, 0.02408176f, 0.05587674f, -0.02486558f, -0.05645368f, -0.05334291f, -0.02167519f, -0.17913949f, 
    0.04032845f, 0.04936264f, 0.10579424f, 0.01736275f, -0.12507023f, -0.13382414f, -0.10701148f, 0.14793536f, 
    -0.01962220f, 0.02646816f, 0.09577405f, 0.07614893f, 0.05233051f, 0.04999212f, 0.00029072f, -0.01170226f, 
    -0.09232998f, -0.18976635f, 0.06429125f, -0.28055584f, -0.04708030f, -0.00478517f, 0.10406545f, -0.07485480f, 
    -0.05640617f, -0.03594771f, -0.06596162f, -0.15944265f, 0.05780343f, 0.07721373f, 0.12170980f, 0.10003798f, 
    -0.07467751f, 0.06687047f, -0.09066534f, 0.16143996f, 0.13274086f, 0.00239928f, -0.07335689f, 0.03594128f, 
    0.11190184f, 0.10769846f, 0.07417840f, 0.03229862f, -0.07846776f, 0.00660635f, -0.08485742f, -0.05175847f, 
    0.08002599f, 0.07358002f, 0.05245668f, 0.01570410f, -0.02602101f, 0.05559307f, 0.08751044f, 0.03772575f, 
    -0.02387295f, 0.04666738f, 0.09199985f, -0.08145590f, 0.13992111f, 0.18920968f, 0.11185092f, 0.16018683f, 
    0.01759458f, -0.23183028f, -0.07345261f, -0.09818650f, 0.05238524f, -0.06878597f, 0.00291121f, 0.14848846f, 
    0.02974141f, -0.00031069f, 0.01005910f, -0.08233990f, -0.25396246f, 0.26362026f, -0.00366636f, 0.18149129f, 
    -0.05422442f, 0.18208060f, 0.01169763f, 0.06433690f, -0.03573537f, -0.02384368f, 0.01594904f, -0.05569552f, 
    0.12306406f, 0.21985845f, -0.03540780f, 0.05401741f, -0.02028963f, 0.04630065f, -0.01958453f, 0.18518665f, 
    0.11104089f, 0.06748304f, -0.06113209f, -0.01594542f, 0.07607806f, 0.20939910f, 0.01438730f, 0.29988584f, 
    0.03099731f, -0.07213688f, 0.01094138f, -0.10094213f, 0.03637933f, 0.22127442f, -0.01065164f, 0.15527050f, 
    0.00752788f, -0.13100359f, -0.05064458f, -0.06273460f, -0.08636597f, -0.05194635f, 0.17740619f, -0.07055420f, 
    -0.09830541f, -0.08582929f, -0.00866122f, 0.00651502f, -0.04872229f, 0.05171064f, 0.15102105f, -0.07209241f, 
    -0.02988718f, -0.10044571f, 0.12097947f, 0.07381678f, 0.00848897f, -0.00561290f, -0.03689644f, -0.14523962f, 
    -0.03536302f, 0.20112287f, -0.15770735f, 0.12752409f, 0.09203572f, 0.10425603f, -0.12980226f, -0.00348833f, 
    0.04875469f, 0.05767344f, 0.07298741f, 0.15422955f, -0.22868435f, -0.02231120f, 0.00298089f, 0.06821548f, 
    0.09854289f, 0.11006589f, 0.05268836f, -0.09071010f, 0.06112359f, -0.08619617f, 0.07888211f, 0.01703653f, 
    -0.04772173f, -0.02691620f, -0.09603553f, -0.08826326f, 0.05754760f, -0.10015097f, 0.00544579f, 0.07611612f, 
    0.07777002f, 0.10096886f, 0.06858395f, 0.11266965f, -0.04010646f, 0.10457662f, -0.23756507f, 0.05232236f, 
    0.03977954f, 0.02206967f, -0.04932948f, -0.06683511f, 0.04972667f, 0.01515048f, -0.09606608f, -0.08403927f, 
    -0.09212142f, -0.29309079f, 0.07298408f, -0.08219803f, 0.00950242f, 0.08678582f, -0.04993166f, -0.05999933f, 
    -0.01980825f, 0.00061939f, -0.03825175f, -0.04610823f, 0.03085331f, -0.08088271f, -0.17453414f, -0.06626613f, 
    0.01725956f, 0.05738524f, 0.05946091f, -0.06797399f, -0.10368989f, 0.01246556f, -0.02174879f, -0.02404358f, 
    0.06970007f, 0.23381574f, 0.20945473f, 0.19758447f, 0.02077848f, 0.12391731f, 0.11123005f, 0.10464782f, 
    -0.02746914f, 0.02729498f, -0.03749479f, -0.12853950f, -0.16680217f, 0.12782538f, -0.06613757f, -0.04166152f, 
    0.13945211f, -0.01712706f, -0.10941629f, 0.08995009f, -0.12055423f, 0.09507810f, 0.08306596f, 0.11417218f, 
    0.15974203f, -0.42224374f, -0.24108468f, -0.17493965f, 0.06387396f, 0.09624573f, 0.05292032f, -0.16597703f, 
    0.05129934f, -0.02940741f, -0.16949290f, -0.14776389f, 0.08403613f, 0.06419171f, 0.07056394f, 0.04145274f, 
    -0.02725526f, -0.00100084f, -0.02238943f, 0.16340429f, -0.00703932f, -0.02153453f, -0.04127308f, -0.04440122f, 
    0.14948532f, -0.04889854f, 0.05120910f, -0.05590159f, 0.00261079f, -0.01363610f, 0.02848430f, -0.03029923f, 
    -0.11877151f, 0.05432359f, 0.24040876f, 0.16678841f, 0.15779902f, 0.19622016f, 0.04649422f, 0.20023268f, 
    0.07490487f, -0.04402447f, 0.08243331f, 0.23476049f, 0.16610132f, 0.04461600f, 0.06150731f, 0.05527082f, 
    0.08859445f, -0.04308492f, 0.22909571f, 0.06901386f, -0.00117924f, 0.00049978f, -0.17109302f, -0.07877468f, 
    0.03919797f, 0.22786058f, 0.14624467f, 0.04607896f, -0.04619205f, -0.04086097f, -0.06428456f, 0.09365222f, 
    0.04457543f, 0.00251701f, -0.12870252f, -0.06982543f, -0.01750243f, 0.11625411f, 0.04737547f, 0.14236698f, 
    -0.30121869f, -0.10368921f, -0.06276619f, -0.04655030f, -0.09513310f, -0.08524387f, 0.10157980f, -0.07391355f, 
    -0.08256987f, -0.05600258f, -0.13776790f, -0.15590413f, 0.14004867f, 0.10475562f, 0.03456714f, 0.10816580f, 
    0.02676524f, 0.07140162f, 0.09887596f, 0.08106479f, -0.02643690f, -0.06830402f, 0.00691197f, -0.07216640f, 
    -0.31224495f, -0.25040525f, -0.30774629f, -0.28881136f, 0.15806688f, 0.16078290f, 0.11591454f, 0.07859123f, 
    0.07899321f, -0.04140833f, -0.04163650f, -0.12072281f, -0.18395466f, -0.21934713f, 0.09633710f, -0.14087465f, 
    0.07925361f, 0.07752857f, 0.08080047f, 0.12642328f, 0.13847958f, 0.07073758f, -0.07650064f, 0.06211662f, 
    -0.28621545f, 0.16328053f, 0.38614434f, 0.20972471f, -0.10252869f, -0.12298284f, -0.01113648f, 0.24451005f, 
    -0.03489152f, 0.00091180f, -0.05283479f, 0.09711663f, -0.09658480f, 0.04903338f, 0.17348425f, 0.17742056f, 
    0.10196335f, -0.05522192f, 0.18293384f, 0.08331542f, 0.05157366f, -0.05382360f, -0.06633588f, -0.00814114f, 
    -0.37420332f, 0.50885886f, 0.14243731f, 0.04766101f, -0.01263518f, 0.01803958f, -0.04448684f, 0.03894461f, 
    0.03772363f, 0.08096277f, 0.00830715f, 0.01523405f, 0.19705361f, 0.11045492f, -0.41924945f, 0.00329749f, 
    0.04688615f, -0.14661428f, -0.17239040f, -0.10319456f, -0.02172652f, 0.12772787f, -0.14862750f, -0.01895217f, 
    -0.17751259f, 0.03638833f, -0.26779315f, -0.00945015f, 0.11742415f, 0.00515172f, -0.16369162f, -0.07968736f, 
    -0.05519730f, 0.02706853f, -0.19351725f, -0.00020831f, 0.00788422f, 0.26530412f, -0.13576961f, 0.03416093f, 
    -0.04417007f, -0.06092843f, -0.00820057f, -0.01737775f, 0.06894472f, 0.28178018f, 0.07251950f, 0.06739567f, 
    0.06060084f, 0.30331552f, 0.40889210f, 0.01834139f, -0.06802263f, 0.06651761f, 0.10787848f, 0.08364199f, 
    -0.02591340f, 0.05720628f, -0.01057965f, -0.09546074f, -0.01779311f, 0.06701072f, 0.28725073f, -0.08213263f, 
    -0.05870229f, -0.06746395f, 0.03220094f, 0.23709773f, 0.04613581f, -0.02646799f, -0.08369400f, 0.06657699f, 
    -0.02377990f, 0.10840753f, 0.10626378f, -0.06494910f, -0.02650144f, 0.00121942f, 0.03966251f, 0.05758620f, 
    0.06344890f, 0.15433952f, -0.11925099f, 0.05744375f, 0.21237595f, 0.22924146f, 0.41756967f, -0.02280495f, 
    0.01078097f, 0.12303753f, -0.11079504f, 0.22207727f, 0.08689801f, -0.03174062f, -0.05367852f, -0.04930473f, 
    -0.00194957f, -0.07931561f, 0.08557377f, 0.07705017f, 0.09726454f, -0.02713620f, 0.04558272f, 0.28497019f, 
    -0.00086517f, 0.09641894f, 0.13269585f, 0.02708447f, -0.02584771f, 0.18684363f, 0.30520833f, -0.09937824f, 
    0.00669280f, -0.18938988f, 0.04715814f, 0.10563737f, 0.01471179f, 0.10952032f, -0.00410856f, 0.05394573f, 
    -0.04221455f, 0.08523253f, 0.13471524f, -0.11349603f, 0.09320229f, -0.07359535f, -0.02644028f, 0.01810845f, 
    0.15743598f, 0.15103348f, -0.03866889f, 0.06831028f, -0.06662042f, 0.14002545f, 0.03607947f, 0.02206166f, 
    0.07475875f, 0.18835004f, -0.25476968f, -0.02258941f, 0.08169588f, -0.02412373f, 0.07084222f, -0.01423336f, 
    0.29013351f, 0.46652421f, 0.11006583f, 0.11144842f, -0.07447934f, -0.07789004f, 0.01250283f, -0.00065171f, 
    0.10334277f, 0.00909975f, -0.00918988f, 0.04473051f, -0.02493805f, 0.10638858f, 0.13133934f, -0.04356759f, 
    -0.09711241f, -0.05498433f, -0.05178861f, 0.03258539f, 0.08910014f, 0.09599280f, 0.09319177f, 0.02153472f, 
    -0.37603793f, -0.31490520f, -0.12413018f, -0.07596255f, 0.01714133f, -0.13552244f, -0.05392317f, 0.00172219f, 
    -0.13291575f, -0.07083592f, -0.03454476f, -0.03630951f, 0.13194659f, 0.11699556f, 0.01053265f, -0.00434803f, 
    0.07384333f, 0.03092584f, 0.20420510f, 0.08493241f, 0.11079715f, 0.02778605f, 0.12485250f, 0.13561167f, 
    -0.19158591f, 0.00866344f, -0.01078938f, -0.16963246f, 0.03777074f, 0.03802881f, -0.02019393f, 0.19339716f, 
    0.05037875f, -0.13499992f, -0.05846297f, 0.13357626f, 0.06807505f, 0.21243656f, 0.21978199f, 0.14872645f, 
    -0.11618181f, 0.03170683f, -0.05279908f, 0.01732532f, -0.04586439f, 0.00074455f, 0.02161718f, 0.01092182f, 
    -0.17229594f, 0.03374483f, 0.18351758f, 0.14414443f, 0.07924281f, 0.05763633f, 0.06413297f, 0.10794434f, 
    0.00759189f, -0.04532526f, 0.02070568f, 0.08665626f, -0.17727175f, 0.56633854f, -0.14280689f, 0.22720502f, 
    -0.08009144f, 0.00010616f, 0.08421367f, 0.06821760f, 0.01808285f, 0.09557391f, -0.10480467f, -0.01896990f, 
    -0.23843250f, -0.12109455f, -0.14914167f, -0.03679909f, -0.04528599f, -0.08056176f, 0.05468522f, -0.04500768f, 
    0.06011591f, -0.01469562f, 0.05977979f, 0.05649201f, -0.09536091f, 0.07703252f, 0.06406596f, -0.03383521f, 
    -0.00471749f, -0.20022707f, 0.06179887f, 0.03401085f, 0.03742580f, -0.01594893f, 0.07469170f, 0.04565758f, 
    0.05289432f, -0.04668659f, -0.16683239f, 0.11712630f, 0.15263993f, -0.03956259f, 0.01879271f, -0.24784705f, 
    -0.00727285f, 0.01879310f, -0.04782819f, -0.07562090f, -0.10302930f, 0.40765193f, 0.28650784f, 0.14208655f, 
    -0.06613851f, -0.01321984f, -0.19058971f, 0.00107429f, -0.14409810f, -0.03281268f, -0.05311979f, -0.00309652f, 
    0.09771010f, -0.01984687f, -0.36842173f, 0.09611613f, -0.02284041f, -0.15838088f, -0.02368883f, 0.01815079f, 
    0.00742986f, 0.05411851f, -0.01117703f, -0.04614471f, -0.31552878f, 0.35313806f, 0.21880342f, 0.10212757f, 
    -0.04506361f, 0.09250545f, 0.02755184f, -0.07733715f, 0.06846186f, 0.05973480f, 0.05253869f, -0.01513382f, 
    0.02092032f, 0.38606426f, -0.16630299f, -0.00607970f, 0.04142124f, 0.11328015f, 0.10931210f, -0.04706066f, 
    -0.01108180f, 0.01309347f, 0.00200770f, -0.08106022f, 0.20709021f, 0.34139472f, -0.04284150f, 0.12058999f, 
    0.09458366f, 0.24297310f, 0.14062804f, -0.05760321f, 0.16624804f, -0.03069072f, -0.04478248f, -0.07439406f, 
    -0.01917790f, -0.06739385f, -0.18701909f, 0.19515407f, -0.05513184f, -0.05149947f, -0.01699162f, 0.00620565f, 
    0.01571207f, -0.05369315f, -0.02108040f, 0.02584638f, -0.15627442f, -0.08298139f, 0.23275302f, -0.08727653f, 
    0.04928543f, -0.05528845f, 0.02396504f, -0.03189303f, 0.14555283f, -0.03595541f, -0.09586626f, -0.04251339f, 
    -0.14367573f, -0.13567530f, -0.07825045f, -0.07474480f, -0.04376935f, -0.08575464f, 0.11886168f, 0.03104776f, 
    -0.02351263f, 0.07817814f, 0.10556728f, 0.09458620f, -0.13066481f, 0.17366752f, 0.31090346f, -0.05661654f, 
    0.00331922f, 0.05257019f, -0.10386931f, 0.00231384f, 0.05390931f, 0.03377280f, 0.17341551f, 0.03462692f, 
    -0.00272349f, 0.02090274f, -0.32291555f, 0.00843425f, -0.11448183f, 0.05790047f, 0.03395670f, 0.04220298f, 
    0.11299682f, -0.07871100f, 0.09144833f, 0.06020727f, -0.42904302f, -0.33145419f, -0.33744758f, -0.25065300f, 
    0.01467824f, -0.06392316f, -0.04234300f, -0.05405127f, -0.04330016f, 0.03337650f, -0.06687596f, -0.02798452f, 
    -0.04135831f, 0.52453715f, -0.39593530f, 0.00004066f, 0.12947594f, 0.06481219f, 0.04758463f, 0.01372688f, 
    0.16059880f, 0.00827694f, -0.00625539f, 0.23088364f, -0.30210590f, -0.25955188f, 0.04830163f, 0.14015225f, 
    0.07879841f, -0.06269640f, 0.08480989f, 0.13797382f, -0.06545915f, -0.02303032f, 0.00268499f, 0.06087104f, 
    0.08971322f, 0.34918556f, 0.13742141f, -0.00235820f, 0.05732263f, -0.10417940f, -0.03557210f, 0.21256953f, 
    0.06271481f, 0.06395697f, 0.00289504f, 0.11957097f, -0.12833852f, 0.20472774f, 0.01899846f, 0.09897438f, 
    0.06686466f, 0.04127451f, -0.03946972f, 0.11197209f, -0.11158152f, -0.01531847f, -0.13931441f, -0.07695158f, 
    -0.45209500f, -0.37256271f, -0.01460871f, 0.18533479f, -0.09669758f, 0.10175084f, -0.09542326f, -0.05030829f, 
    0.00806154f, -0.10780547f, -0.14270145f, -0.03022371f, 0.13202409f, 0.02844195f, 0.04283601f, -0.13430978f, 
    -0.00831892f, 0.12638807f, 0.14624371f, -0.01407976f, 0.03295789f, -0.19553864f, -0.06551919f, 0.07416894f, 
    0.02807036f, -0.08265356f, 0.10561053f, -0.00587172f, 0.13871107f, -0.12131246f, 0.03263400f, -0.02927048f, 
    0.10167340f, -0.04653680f, -0.04924826f, -0.04756241f, -0.12767985f, 0.16667083f, 0.16702926f, 0.18033288f, 
    -0.22669406f, -0.09847082f, -0.08452262f, 0.14342149f, -0.02359339f, -0.05823362f, -0.00917786f, 0.06328444f, 
    0.09036602f, -0.20431153f, -0.00156850f, 0.06060448f, -0.06194229f, 0.03866138f, -0.16874421f, 0.08138284f, 
    0.13124715f, -0.07864375f, 0.02577772f, 0.27908862f, 0.06365455f, 0.12223712f, 0.02437811f, 0.17175978f, 
    0.03071430f, 0.14887571f, -0.07535813f, 0.07173245f, 0.03081948f, 0.01869881f, -0.03295599f, 0.01790638f, 
    -0.12087739f, -0.00772025f, 0.00084878f, 0.13695440f, 0.08414965f, 0.02524187f, -0.02900879f, -0.04534151f, 
    0.04595892f, 0.05815034f, -0.06710871f, 0.01422160f, -0.28550297f, -0.14963804f, -0.00254054f, 0.30350929f, 
    -0.20723742f, -0.02433086f, 0.02408241f, 0.24053098f, 0.07340641f, 0.16318569f, -0.02075966f, 0.03931894f, 
    0.00484497f, -0.07730827f, -0.32416227f, -0.20168974f, -0.11303411f, -0.07772627f, -0.16924110f, -0.12516028f, 
    -0.07655610f, 0.05312101f, -0.11891784f, -0.13390960f, -0.39802521f, -0.20007399f, -0.30066255f, 0.01133414f, 
    -0.06565403f, -0.00743968f, -0.10696441f, -0.00559544f, -0.13843870f, -0.10442811f, 0.11533723f, -0.19025704f, 
    -0.15489964f, -0.04209061f, -0.29863375f, 0.03386399f, 0.03012395f, -0.05958404f, -0.04194956f, 0.04724902f, 
    0.05871791f, -0.00501465f, -0.06921590f, 0.11230939f, -0.03236835f, 0.03429141f, -0.00743278f, 0.17819741f, 
    0.01723561f, -0.04850093f, -0.01651621f, -0.03677982f, 0.11997718f, 0.01272114f, 0.14314225f, 0.03375069f, 
    -0.08496199f, -0.02269209f, 0.03180511f, 0.04607354f, 0.04739638f, 0.05150109f, 0.01023475f, -0.00456010f, 
    0.09032274f, 0.03081269f, 0.10570706f, 0.06937237f, -0.01585529f, -0.04090301f, 0.03433440f, 0.24634278f, 
    0.00539996f, 0.11666548f, 0.07634090f, -0.04199456f, -0.01231809f, -0.01020491f, -0.00941696f, -0.03845002f, 
    -0.08880614f, -0.26916939f, 0.06611555f, 0.10656680f, -0.07950903f, -0.06095761f, -0.00450919f, -0.05764815f, 
    0.01055926f, -0.09059039f, 0.06346574f, 0.18452521f, -0.15311612f, 0.00913406f, 0.13032988f, 0.12321076f, 
    -0.08495799f, 0.07155332f, 0.14634226f, 0.13855247f, 0.04159187f, 0.07434008f, 0.01313768f, 0.09101719f, 
    0.03816628f, -0.22885107f, -0.20015185f, -0.18499602f, 0.03059380f, -0.01071528f, -0.03253399f, -0.06711042f, 
    0.07138322f, -0.09468437f, 0.00186640f, -0.12327418f, 0.26001036f, 0.02003960f, 0.19028294f, -0.08138097f, 
    0.06234846f, -0.09044167f, -0.04843382f, 0.00096494f, -0.02182723f, -0.00676429f, 0.06324490f, 0.09817494f, 
    -0.07983171f, -0.34901053f, 0.05544641f, -0.17459120f, -0.00038337f, -0.09421457f, -0.11157311f, -0.04205892f, 
    0.06451138f, -0.03971796f, -0.05140539f, -0.06098403f, 0.10448702f, 0.03097987f, 0.02784653f, 0.01372791f, 
    0.05252257f, -0.11130122f, 0.06964845f, 0.03523666f, 0.04806156f, -0.04522558f, 0.05984168f, -0.01894410f, 
    -0.23794849f, -0.24587612f, 0.16569112f, 0.27961689f, -0.01834113f, 0.07499515f, 0.08451897f, 0.15763333f, 
    0.01502743f, -0.00983776f, 0.01999255f, 0.12298110f, -0.02439656f, -0.01943374f, 0.04171494f, 0.11577328f, 
    -0.15391603f, 0.06525760f, -0.02243779f, 0.20220786f, -0.01566306f, 0.08659372f, 0.02498187f, -0.00941947f, 
    -0.11413751f, 0.23716219f, -0.46760502f, 0.08315200f, 0.05936015f, -0.10998027f, -0.03155636f, -0.00253321f, 
    0.21760009f, -0.03241662f, -0.06305227f, 0.09720723f, 0.04670041f, -0.04710269f, -0.13133839f, -0.06902482f, 
    0.08578055f, -0.12238238f, 0.15927510f, 0.11099713f, 0.00857797f, 0.00032564f, -0.09586565f, -0.03818407f, 
    -0.11149104f, -0.11687920f, -0.18342008f, -0.05380242f, 0.17013870f, 0.14255126f, 0.12201788f, 0.00278869f, 
    -0.00716786f, 0.00870621f, 0.05445677f, -0.01663550f, 0.07605392f, 0.19328749f, 0.11623206f, -0.02307877f, 
    0.04499443f, 0.14071451f, 0.00628249f, 0.05404940f, 0.00496566f, -0.02031024f, -0.00992275f, 0.01007625f, 
    0.14544521f, -0.06648158f, -0.12047956f, -0.03093526f, -0.00755970f, 0.05961318f, 0.06628323f, 0.03314144f, 
    0.01285803f, 0.05042068f, -0.02099312f, 0.08450557f, -0.02963596f, -0.30772293f, -0.14953633f, 0.17058632f, 
    -0.07006104f, 0.07532398f, -0.10568143f, -0.07207313f, 0.07393981f, -0.01048085f, 0.04793251f, 0.06794984f, 
    0.23939370f, 0.18545930f, 0.37071782f, -0.01583880f, -0.01920848f, 0.02331138f, -0.05612776f, 0.10348836f, 
    -0.03141340f, -0.00145712f, -0.02963583f, -0.04793095f, -0.13891499f, -0.41156387f, 0.08594277f, 0.01428962f, 
    0.05579482f, -0.03832869f, -0.09826220f, 0.01771438f, 0.03019598f, -0.01998546f, -0.04064560f, 0.06814511f, 
    -0.15874156f, 0.15686917f, -0.08457183f, 0.20112045f, 0.13654868f, 0.13251232f, -0.03266185f, 0.07394242f, 
    0.05301363f, -0.05968423f, -0.00348364f, 0.00012444f, 0.05367511f, 0.27013642f, -0.02687327f, -0.01673739f, 
    0.15514366f, 0.16317616f, 0.04343316f, -0.00570002f, 0.08454920f, -0.00358916f, 0.00392386f, -0.01608136f, 
    -0.23493282f, -0.30206296f, 0.05645824f, -0.15949793f, 0.01779492f, -0.03974215f, -0.01170001f, 0.00085139f, 
    0.13320979f, -0.03289139f, 0.02745414f, 0.07281522f, 0.05483721f, 0.20090148f, -0.07350329f, 0.16087344f, 
    0.14219931f, 0.02461974f, 0.07953950f, 0.03365852f, -0.06217483f, -0.04888913f, -0.01104723f, 0.09024606f, 
    0.11026747f, -0.03111604f, 0.00895696f, -0.02300064f, 0.06802451f, 0.12676707f, -0.05079364f, 0.04546659f, 
    0.10008584f, -0.00544678f, -0.00823633f, -0.05217996f, 0.24059360f, 0.04673567f, -0.11820899f, 0.33073789f, 
    0.07120745f, 0.09391031f, -0.03823847f, 0.01209585f, -0.01347366f, -0.19148423f, 0.09676542f, 0.05391448f, 
    -0.12770946f, -0.08818112f, -0.36220512f, 0.04262261f, 0.15742110f, -0.06479779f, -0.04478612f, 0.06232981f, 
    -0.05241563f, -0.02762762f, 0.07189041f, -0.05779503f, 0.32508439f, 0.12123461f, 0.22006080f, -0.03764842f, 
    0.08982547f, -0.07831876f, 0.19557311f, -0.01215084f, -0.00413723f, -0.04030524f, -0.05113526f, 0.11184201f, 
    -0.02374416f, -0.14314049f, -0.11117519f, 0.06206447f, 0.09433162f, 0.02008396f, -0.04810113f, -0.03007682f, 
    0.07363204f, -0.03553443f, 0.00487294f, -0.03918230f, -0.05299717f, -0.26896125f, -0.23365004f, -0.01674215f, 
    -0.08041189f, -0.02896954f, -0.04431354f, -0.03696050f, -0.03704930f, 0.03986142f, -0.09125116f, -0.03816412f, 
    -0.25948152f, -0.22132063f, -0.38694820f, -0.04379909f, 0.12411865f, 0.04981322f, -0.05726697f, -0.02472085f, 
    -0.05159432f, -0.05747459f, -0.04893837f, 0.03536033f, 0.12926652f, 0.06166442f, 0.31901735f, 0.09645150f, 
    -0.03150488f, -0.01927945f, 0.00694518f, 0.02466711f, -0.03808997f, 0.00005824f, -0.09546323f, -0.08760353f, 
    -0.08794035f, -0.36485764f, -0.02716844f, -0.09519965f, -0.05265138f, 0.04492878f, -0.00677293f, -0.12629639f, 
    -0.03302109f, 0.03744576f, -0.02850485f, 0.13870551f, -0.01444630f, -0.01621462f, 0.04609394f, 0.05136302f, 
    0.11441715f, 0.06387785f, 0.03573972f, 0.01950607f, 0.05878848f, 0.01520377f, -0.04940093f, 0.01762947f, 
    0.26757416f, 0.25266778f, 0.20269573f, -0.00615885f, 0.10622234f, 0.21707515f, 0.01202350f, 0.07594801f, 
    -0.03505382f, 0.04812922f, 0.01432790f, -0.05211703f, -0.10044309f, -0.13327122f, 0.23439030f, 0.05112681f, 
    -0.07142307f, 0.14293121f, -0.11912963f, 0.13189796f, 0.05938216f, -0.03297187f, -0.05386829f, 0.18678662f, 
    -0.12577182f, -0.30757535f, -0.15461101f, -0.16586705f, 0.02276668f, -0.07498224f, 0.00097016f, 0.08287173f, 
    -0.06190205f, 0.03589145f, 0.05374417f, 0.09124375f, -0.11907769f, -0.20406248f, -0.18951322f, 0.09738327f, 
    0.05025774f, -0.03443694f, -0.00076428f, 0.09626467f, -0.05383058f, 0.04627161f, 0.09815931f, -0.08843403f, 
    0.04488522f, 0.21573335f, -0.04493443f, 0.17490830f, -0.03328558f, 0.07518770f, -0.15692680f, -0.06897052f, 
    -0.02384454f, 0.02036563f, 0.02899696f, -0.06224833f, 0.21691529f, 0.03850329f, -0.01306366f, 0.06761454f, 
    0.26220319f, 0.17030038f, 0.09469759f, 0.11310039f, -0.09028573f, -0.04205932f, -0.04081471f, 0.05007887f, 
    -0.47100738f, 0.06101421f, 0.05918340f, 0.03185495f, 0.00212068f, 0.07105692f, -0.10279363f, -0.01962035f, 
    0.23944853f, 0.04903293f, 0.01296709f, 0.01949064f, 0.17636582f, 0.01668985f, 0.09693862f, -0.01885078f, 
    0.07021456f, 0.00186793f, -0.03215656f, 0.06210506f, 0.01078219f, -0.02558566f, -0.00163464f, 0.02392448f, 
    0.11585172f, -0.12604629f, 0.14886004f, -0.02770244f, -0.04776432f, 0.01984968f, -0.07447163f, -0.03665483f, 
    0.03070981f, 0.01530453f, -0.04664611f, 0.02355666f, 0.12974223f, 0.04291201f, 0.10063510f, 0.05150149f, 
    -0.01753679f, 0.01199936f, -0.03736623f, 0.02492286f, -0.04996672f, -0.00846225f, 0.01660050f, 0.02085834f, 
    -0.33626452f, -0.25525364f, 0.00574531f, -0.03808874f, -0.07617510f, -0.05655162f, -0.07613855f, 0.02269262f, 
    0.03481908f, 0.05814685f, -0.00120284f, -0.02528386f, 0.17508595f, 0.28896227f, 0.08019458f, 0.07556544f, 
    0.09272216f, 0.04528459f, 0.08920205f, 0.01224917f, -0.12858842f, -0.03004192f, 0.00371844f, 0.04403370f, 
    -0.01878056f, -0.21895257f, -0.15606189f, -0.01386546f, -0.01121104f, 0.07077006f, -0.01989829f, 0.03893904f, 
    0.07172184f, -0.01114217f, 0.02427066f, 0.01794769f, 0.27023682f, 0.03511789f, 0.07180856f, 0.13180807f, 
    0.07372324f, -0.07437823f, 0.17566514f, -0.08796347f, 0.06873155f, -0.04834470f, 0.02776817f, -0.06133981f, 
    -0.06413808f, -0.24973932f, -0.03763549f, -0.13549325f, -0.03540597f, -0.04119023f, -0.02079920f, 0.02276601f, 
    0.07482406f, 0.05730468f, 0.09662604f, -0.01173476f, -0.07750653f, -0.36385143f, -0.07520138f, -0.11646754f, 
    0.00635163f, 0.03422405f, 0.02993921f, -0.03286012f, 0.08820393f, 0.02610811f, 0.10891065f, -0.03516022f, 
    0.14120400f, -0.36675882f, 0.10096688f, -0.29078034f, -0.09016397f, 0.01578241f, -0.05267184f, 0.00750239f, 
    0.06155280f, -0.12145622f, 0.07641282f, 0.04609168f, 0.11958715f, 0.30486557f, 0.19886179f, 0.16019237f, 
    0.06863194f, 0.16833231f, 0.04256797f, -0.02847448f, 0.02044020f, 0.02749145f, 0.08616505f, 0.00160069f, 
    0.02349552f, -0.13204522f, -0.08842946f, -0.01468815f, 0.10098296f, 0.11241408f, 0.04909391f, 0.08346552f, 
    -0.02189886f, 0.00769040f, 0.08316907f, 0.01583930f, 0.19631803f, -0.00316637f, 0.13798279f, 0.12570025f, 
    0.13233049f, 0.19554558f, 0.09375957f, 0.02108562f, -0.00818751f, 0.01022413f, 0.14015192f, 0.08556436f, 
    0.10492443f, -0.08082429f, 0.04546249f, -0.19623663f, 0.11270261f, -0.14328817f, -0.00451521f, 0.15011030f, 
    -0.02938932f, -0.03380827f, -0.06253665f, 0.03142694f, -0.04211760f, 0.06217121f, 0.12619595f, 0.15693590f, 
    0.03208819f, 0.01606800f, -0.01085984f, 0.14365333f, 0.05585786f, 0.08343861f, -0.08449437f, -0.09522978f, 
    0.07115382f, 0.35461822f, 0.09730431f, 0.01379264f, 0.05308083f, 0.06408525f, -0.04367312f, 0.06204604f, 
    -0.06295835f, -0.01796456f, 0.08770627f, 0.02903327f, -0.10547097f, -0.30065984f, -0.15008236f, 0.00906088f, 
    0.00192405f, -0.10302401f, 0.03929858f, 0.05291843f, -0.05226795f, 0.15298527f, 0.14173581f, -0.01728916f, 
    -0.29578659f, 0.04542964f, -0.21326368f, -0.16775170f, -0.02753006f, -0.10473683f, 0.03704369f, -0.02060232f, 
    0.09539150f, -0.03333260f, -0.16601290f, -0.11885393f, 0.27653641f, 0.07636520f, 0.23931323f, -0.00378331f, 
    0.05518712f, 0.06015080f, 0.16840050f, -0.03679496f, -0.09041229f, -0.11124673f, -0.09589139f, -0.03629805f, 
    0.06721603f, 0.20210075f, 0.16827451f, 0.00798013f, 0.11499788f, 0.10722107f, -0.16829239f, 0.09898692f, 
    0.03596416f, -0.12126898f, 0.08383552f, -0.03878377f, -0.00523025f, -0.11374633f, 0.26333141f, -0.06836592f, 
    -0.01224983f, 0.03791595f, 0.02361890f, 0.20741509f, 0.05242765f, 0.03883877f, -0.02648493f, 0.01388622f, 
    -0.11233367f, -0.19744533f, -0.01867494f, -0.06870461f, -0.02054288f, 0.00202732f, -0.02976164f, -0.03645496f, 
    -0.05203428f, -0.11176040f, -0.03741496f, 0.00208524f, 0.01255107f, -0.27859375f, -0.38437203f, -0.19532152f, 
    -0.03094779f, -0.07960651f, 0.06337171f, -0.03551198f, -0.00495348f, -0.06699350f, -0.12399504f, -0.01984752f, 
    -0.23390797f, -0.42249247f, -0.38764682f, -0.17693619f, 0.01225347f, 0.03329752f, -0.07514734f, 0.00673287f, 
    -0.02654062f, -0.04640895f, -0.04487438f, 0.04242251f, 0.06789622f, -0.31677401f, -0.01734813f, -0.16660380f, 
    -0.03836539f, 0.02941939f, 0.05933804f, -0.09378769f, -0.04709316f, 0.03898105f, -0.04430899f, 0.08818734f, 
    0.25447574f, 0.31201899f, 0.19712655f, 0.03497177f, 0.16662252f, 0.12973487f, 0.10906864f, 0.01040520f, 
    -0.05943803f, -0.05918887f, -0.07287723f, 0.04741847f, 0.05773258f, 0.21934582f, 0.03162070f, 0.14790381f, 
    -0.01074915f, 0.01165047f, 0.00258086f, -0.10173115f, 0.00714106f, 0.04194914f, 0.01287703f, 0.00009229f, 
    -0.11068551f, -0.37318286f, -0.06019598f, -0.31142622f, 0.23259673f, -0.06318793f, -0.00278285f, -0.06022162f, 
    0.06012149f, -0.08689246f, -0.06038452f, 0.02996972f, 0.26656905f, 0.09568994f, 0.10324505f, 0.06175338f, 
    0.10806304f, 0.02805213f, 0.21504170f, -0.11230073f, 0.00706552f, -0.00854754f, 0.02706071f, -0.00722776f, 
    -0.12172975f, -0.20238657f, -0.15278548f, -0.10010128f, -0.00597449f, -0.00939149f, 0.02211956f, -0.07757118f, 
    -0.26475766f, -0.12258016f, 0.07358350f, 0.06373335f, 0.34147862f, 0.38899642f, 0.11252443f, 0.02598432f, 
    0.09764312f, 0.00271389f, 0.03259409f, 0.06317981f, 0.12980284f, -0.10097886f, -0.03632491f, -0.08826752f, 
    -0.11643267f, -0.09025234f, -0.16762269f, -0.16181311f, 0.04527676f, -0.04682544f, 0.05786982f, -0.00210464f, 
    -0.07570042f, 0.11402716f, 0.07365252f, 0.00361077f, -0.08930898f, 0.13886656f, -0.07728488f, 0.16132045f, 
    0.04679301f, 0.05308501f, -0.12096645f, -0.03654586f, 0.16671105f, 0.01742771f, 0.18908936f, 0.07138343f, 
    -0.04626404f, -0.39658442f, 0.01360398f, -0.27456829f, 0.02315985f, -0.03196794f, 0.01618881f, 0.11314039f, 
    -0.03022017f, -0.01019662f, -0.13711911f, 0.01002202f, -0.01143058f, -0.11131225f, 0.05102659f, -0.02473374f, 
    0.08054120f, -0.00387182f, -0.03568207f, 0.03503453f, 0.07009017f, 0.02007788f, -0.17798696f, -0.09302160f, 
    0.00529557f, -0.01269238f, -0.00865636f, 0.01294130f, 0.02399143f, -0.01791522f, 0.00241289f, 0.01836651f, 
    -0.02346732f, -0.03422331f, -0.01591715f, -0.03418506f, -0.01480843f, 0.02925851f, 0.03047419f, -0.03583571f, 
    -0.01999826f, -0.04066869f, -0.01869724f, -0.00111530f, -0.00050134f, 0.00574529f, -0.02672000f, -0.01456105f, 
    -0.03099336f, 0.01331801f, -0.00558183f, 0.02354295f, 0.01734283f, -0.03048484f, -0.03188779f, 0.02004118f, 
    -0.01845520f, 0.00947866f, -0.03790860f, -0.01009935f, -0.02015595f, -0.01232493f, -0.01627855f, -0.01635438f, 
    0.02071510f, -0.04174814f, -0.03214189f, 0.01690648f, -0.00915718f, -0.01759255f, 0.00032252f, -0.01150666f, 
    -0.00317722f, -0.02733053f, 0.02160372f, -0.03716181f, -0.01734210f, 0.00875928f, 0.03445275f, -0.01175436f, 
    0.00728030f, 0.02809743f, -0.00602606f, -0.03084242f, -0.02144079f, -0.02347047f, 0.02285253f, -0.00968919f, 
    0.00456993f, -0.02665061f, -0.02108676f, 0.01939518f, 0.02174716f, 0.02045709f, -0.01639977f, -0.01393571f, 
    0.01633413f, 0.02916356f, -0.00836313f, -0.01415477f, -0.01254451f, -0.00060004f, 0.00350633f, 0.01210168f, 
    -0.02268101f, 0.01174381f, 0.00423995f, -0.02952328f, -0.03107795f, -0.01574968f, -0.00082420f, -0.04190351f, 
    0.00667407f, -0.01183735f, -0.03621198f, -0.01966903f, -0.00143559f, 0.00112331f, -0.02433353f, -0.04056660f, 
    -0.02909672f, -0.02445534f, -0.04111164f, 0.01991971f, 0.02301906f, 0.00063783f, -0.03545221f, -0.00671626f, 
    -0.00628992f, 0.00301799f, 0.01330081f, -0.01661546f, 0.00878079f, -0.02991603f, -0.02176990f, -0.02231152f, 
    0.02177317f, -0.01404100f, 0.02305098f, 0.01066182f, -0.01619790f, 0.01373398f, 0.01745224f, 0.03357346f, 
    -0.01409244f, -0.02808869f, 0.01689271f, -0.02231546f, 0.01084943f, 0.02614793f, -0.00401239f, 0.00694702f, 
    -0.01973364f, -0.02459214f, -0.00172811f, 0.01273682f, -0.01779770f, 0.03083804f, -0.03089282f, 0.00546780f, 
    0.00131785f, 0.00461961f, 0.02996071f, 0.00498664f, 0.03999548f, 0.03181979f, 0.01811722f, -0.02449102f, 
    -0.00294091f, -0.02625316f, -0.00789347f, 0.02816201f, -0.02502351f, -0.01331593f, 0.00381106f, 0.01610713f, 
    -0.03736867f, -0.00404916f, 0.00889242f, 0.01000821f, -0.01863787f, 0.02278982f, -0.02248976f, 0.01694161f, 
    0.00278766f, -0.02337586f, 0.01412205f, -0.02602790f, -0.03177648f, -0.00904011f, -0.02369648f, 0.00458719f, 
    -0.02566298f, -0.00032933f, -0.03267985f, -0.03936956f, -0.01241440f, -0.03606376f, 0.00722478f, -0.03471679f, 
    0.00016740f, 0.00641851f, -0.01783536f, 0.00164948f, 0.02196547f, 0.00025822f, -0.03225646f, -0.03435244f, 
    0.04119192f, 0.03538293f, 0.01625810f, -0.01701210f, -0.02368958f, -0.01170452f, 0.02106788f, 0.01152670f, 
    0.02409746f, -0.00215065f, 0.00419707f, 0.01714087f, -0.01668756f, -0.01495696f, -0.00393279f, -0.01116732f, 
    -0.01202300f, -0.03299660f, -0.01297538f, 0.01479693f, -0.03343710f, 0.00253746f, 0.00185471f, 0.00744829f, 
    0.02153436f, -0.01125379f, 0.02569767f, 0.00705273f, 0.01788408f, 0.00655449f, 0.02057735f, 0.00015173f, 
    0.02268678f, -0.01376816f, 0.00818432f, 0.01147300f, -0.00639566f, -0.02772236f, -0.01356796f, 0.00589352f, 
    0.01716246f, 0.01972771f, -0.04051873f, -0.01416686f, 0.01918782f, -0.01724352f, 0.00575854f, -0.02854647f, 
    0.02633975f, -0.03385078f, 0.00981453f, -0.02306094f, 0.03309537f, 0.02127407f, -0.00561959f, 0.03150101f, 
    0.00114396f, -0.01396009f, -0.01266185f, -0.02449240f, 0.02840187f, 0.02837297f, 0.02992931f, 0.01507660f, 
    -0.01829902f, -0.02827315f, -0.02617344f, -0.04525895f, 0.00037177f, -0.02666067f, -0.00355573f, 0.02243006f, 
    0.01040214f, -0.02086351f, 0.02073368f, -0.03951737f, 0.02169138f, -0.00139802f, 0.02073773f, -0.01353469f, 
    0.02632216f, 0.02934266f, 0.01753322f, 0.01515738f, 0.01536851f, -0.02750163f, -0.01604926f, -0.00440553f, 
    0.01286811f, -0.03154703f, -0.00421543f, 0.01277406f, 0.01676884f, -0.01161519f, -0.02015708f, 0.02450728f, 
    -0.00986593f, -0.00364852f, -0.00967515f, 0.01937161f, -0.01246992f, -0.00760258f, 0.01468986f, -0.01916028f, 
    -0.00214697f, 0.01720600f, -0.02940749f, -0.03189941f, -0.01361767f, -0.01549256f, 0.02911582f, -0.00167954f, 
    -0.00373113f, -0.02129147f, -0.00057058f, 0.02734930f, -0.00342319f, -0.02149330f, -0.03142221f, 0.01879661f, 
    -0.00125667f, 0.01878653f, 0.00414787f, -0.00981709f, 0.02121954f, -0.03342368f, -0.02039497f, -0.04528567f, 
    0.02128506f, -0.01330829f, -0.03632101f, 0.01726553f, -0.02868440f, -0.01899130f, 0.03112281f, 0.03180630f, 
    -0.02744683f, -0.00230695f, -0.02398845f, 0.02656297f, 0.01379798f, -0.02099063f, 0.02156215f, -0.01033591f, 
    0.01417305f, 0.00462660f, -0.02557028f, -0.03787069f, -0.01737421f, -0.02612168f, 0.00481482f, 0.00321472f, 
    -0.02388571f, -0.00903797f, 0.01946525f, -0.00662577f, 0.02333689f, 0.01171917f, 0.00616967f, 0.01343646f, 
    -0.00684862f, 0.03280719f, 0.01116111f, -0.00531315f, 0.01912916f, 0.00990373f, -0.02059129f, 0.03730299f, 
    0.02231691f, -0.01660499f, 0.01309942f, -0.00526280f, 0.01299836f, -0.02647409f, 0.02654506f, 0.02098280f, 
    0.02884489f, 0.02900625f, -0.00229174f, -0.02757730f, -0.00515993f, 0.00233946f, -0.03306641f, 0.04020322f, 
    -0.03557385f, 0.03503679f, -0.03583635f, 0.00076139f, 0.02163883f, 0.03157198f, -0.03607281f, 0.03381412f, 
    0.00728170f, -0.03366618f, -0.02415595f, 0.02574495f, -0.01605381f, -0.01510697f, -0.02224423f, -0.01829485f, 
    -0.04755697f, -0.00046013f, -0.03226655f, -0.00980689f, -0.02071973f, -0.03229372f, -0.01595816f, 0.00830602f, 
    0.00734334f, -0.00471825f, 0.01097278f, -0.03386306f, -0.00176927f, 0.03121200f, 0.00871188f, -0.02468665f, 
    0.02301216f, -0.02782071f, -0.02016932f, 0.01817155f, 0.01032246f, -0.02799633f, 0.03145406f, -0.00899659f, 
    0.02565129f, 0.00224581f, -0.00142840f, 0.02782070f, -0.00773547f, 0.00341846f, -0.01635597f, -0.03537741f, 
    0.01211960f, -0.02372933f, -0.02048774f, 0.02631795f, 0.03002889f, -0.00721243f, -0.01315420f, -0.01461836f, 
    0.01108747f, -0.03083483f, 0.01316831f, 0.00161057f, -0.00371599f, -0.02642108f, 0.03010700f, 0.02854957f, 
    -0.02945626f, -0.01919154f, -0.03067800f, -0.03324782f, -0.00646136f, 0.00863670f, -0.03865167f, -0.00534878f, 
    -0.03006689f, -0.01436039f, -0.02780397f, -0.04339780f, -0.04552070f, -0.00193090f, -0.01186953f, -0.03031355f, 
    0.00326095f, 0.00655143f, -0.00336837f, -0.03053467f, 0.00136363f, 0.03201985f, 0.01580969f, 0.00256626f, 
    0.00856636f, 0.00125612f, 0.00212309f, 0.00585879f, -0.02429335f, -0.02732608f, -0.00249493f, 0.03584840f, 
    0.01835521f, -0.00969521f, -0.03347801f, -0.02827569f, -0.03851051f, -0.02910285f, -0.02092947f, -0.02051145f, 
    -0.02589326f, -0.04659620f, -0.02138203f, 0.03062418f, -0.02379437f, 0.01780349f, -0.03108105f, 0.02858755f, 
    -0.01479211f, 0.00513728f, -0.04208755f, -0.03224752f, 0.01782671f, -0.02946724f, -0.01999964f, 0.02997332f, 
    -0.02081380f, -0.02067648f, 0.00611063f, -0.00768106f, -0.01734580f, -0.02472585f, -0.03309936f, -0.02228887f, 
    -0.01318789f, -0.01528250f, 0.04674996f, -0.01659293f, -0.00635534f, -0.03083481f, -0.03933991f, -0.02126585f, 
    0.01946599f, -0.00638515f, -0.02141754f, -0.00413702f, 0.01585132f, -0.01690701f, 0.00563756f, -0.03516209f, 
    -0.03010123f, 0.02839943f, 0.02018226f, -0.00660950f, 0.02679474f, -0.00763246f, 0.02702842f, -0.03305009f, 
    -0.00284743f, 0.00813012f, 0.00396903f, -0.00439990f, 0.02324041f, 0.01162962f, 0.00481871f, 0.03263834f, 
    -0.00144141f, -0.00277453f, 0.01945425f, 0.00476592f, 0.00171936f, 0.03498190f, 0.00514284f, 0.00968208f, 
    -0.01906982f, -0.03832534f, -0.02996927f, -0.02627232f, -0.00050508f, -0.01238377f, -0.03688231f, 0.02154319f, 
    -0.01783462f, 0.00239198f, 0.02289293f, -0.00461962f, -0.01022439f, -0.03200213f, 0.00322659f, 0.00553560f, 
    -0.02258784f, -0.01482357f, 0.01236806f, -0.01943477f, 0.02010836f, -0.03724043f, -0.01324140f, -0.02578996f, 
    0.00027998f, -0.00156364f, -0.00546889f, 0.01345569f, 0.01002202f, 0.00206339f, 0.02030499f, 0.02690383f, 
    -0.02210576f, 0.00980290f, -0.04617415f, -0.01761288f, -0.02426338f, 0.02960361f, -0.02458499f, 0.02310761f, 
    -0.01477074f, 0.01377611f, 0.01796217f, 0.02430521f, 0.02085186f, -0.00706599f, 0.00801099f, 0.02114942f, 
    -0.00646715f, -0.02054024f, 0.01655082f, -0.03666896f, -0.02757948f, -0.01105830f, -0.03042642f, -0.00643954f, 
    -0.04032989f, -0.03928852f, 0.00068557f, -0.00084186f, -0.02061389f, 0.02481980f, 0.01896429f, 0.00696212f, 
    -0.03661119f, 0.01328374f, -0.03624893f, -0.00797701f, 0.00570212f, 0.01221701f, 0.00671245f, -0.02767634f, 
    0.01622870f, -0.02631476f, -0.00218348f, -0.04411355f, -0.00837705f, 0.00461757f, -0.02843074f, -0.02406300f, 
    -0.01931901f, -0.01735048f, -0.02299411f, -0.00648485f, -0.02215295f, -0.04416233f, 0.00524071f, -0.00242783f, 
    -0.03130264f, -0.01047373f, 0.01158461f, -0.02384478f, 0.02730258f, -0.01112408f, -0.02483254f, -0.00810646f, 
    0.00668388f, 0.01372494f, -0.01684751f, 0.03219035f, -0.01816475f, 0.00866924f, 0.00582674f, 0.02514715f, 
    -0.01259287f, 0.01674452f, -0.00791182f, -0.02993720f, -0.04157158f, -0.01925132f, -0.03409281f, 0.01417163f, 
    -0.02330574f, -0.01829009f, -0.02693600f, -0.00724847f, -0.03514854f, 0.02198025f, 0.01683327f, 0.00165074f, 
    -0.00065206f, 0.01434100f, 0.02224175f, -0.00078402f, 0.01753004f, 0.01801152f, 0.02187625f, -0.01536481f, 
    -0.02040748f, 0.00409338f, 0.01271150f, 0.01947454f, 0.03381931f, 0.00130583f, 0.02093819f, -0.02887153f, 
    0.01461439f, -0.01708207f, -0.03076038f, 0.01561931f, 0.01005187f, -0.00790482f, 0.02145976f, -0.00498572f, 
    -0.01494280f, -0.02885064f, 0.01788018f, -0.02694039f, -0.01235142f, -0.02077397f, 0.01665985f, 0.02450208f, 
    -0.01998051f, -0.01738257f, 0.00853906f, -0.03134733f, -0.01058612f, -0.01727358f, -0.00405022f, -0.01108413f, 
    -0.02799340f, 0.02322299f, 0.00195441f, 0.02890206f, 0.02390728f, 0.01836362f, -0.03106400f, 0.00890933f, 
    -0.02927475f, 0.00183895f, -0.01334136f, 0.00602558f, 0.01781269f, 0.00338391f, 0.00376568f, -0.01939724f, 
    0.00424504f, -0.03005520f, 0.03124527f, -0.01700822f, -0.02285314f, 0.01453928f, -0.00234764f, -0.00223018f, 
    0.02966157f, 0.00354455f, -0.03855827f, -0.03853471f, 0.02785590f, -0.02862009f, -0.01104199f, 0.01171257f, 
    0.01796271f, -0.02776301f, -0.03222359f, -0.01580492f, 0.02450418f, -0.01078184f, 0.01784970f, -0.00846639f, 
    -0.00429098f, 0.00530795f, 0.01020861f, -0.00450718f, 0.01051302f, -0.01219299f, 0.00229042f, -0.03067449f, 
    0.02836360f, -0.01470643f, -0.02246446f, -0.00349905f, -0.04071776f, -0.01678300f, 0.00117684f, -0.02587650f, 
    -0.03486688f, 0.00123962f, 0.03020435f, -0.00781753f, -0.03768533f, 0.02585550f, -0.01623272f, -0.02974034f, 
    0.00715129f, -0.03394940f, -0.00996681f, -0.03561202f, 0.00158094f, 0.01946457f, -0.03471406f, 0.02639563f, 
    -0.09375247f, 0.03454676f, -0.12631291f, -0.03334884f, -0.13030580f, -0.02325089f, 0.11081769f, 0.11285376f, 
    -0.05606445f, -0.05434965f, 0.05625516f, -0.02641831f, 0.02184990f, 0.03958848f, 0.05470856f, -0.13471286f, 
    -0.13263585f, 0.02455441f, -0.11597580f, 0.02622879f, 0.01292061f, 0.01243069f, 0.11651948f, 0.02701693f, 
    -0.05986553f, -0.16921440f, -0.21268041f, -0.04793541f, 0.08959254f, -0.04536762f, -0.10202048f, -0.08933049f, 
    -0.08932431f, 0.06343735f, -0.05410789f, 0.00679797f, 0.25889766f, 0.08632039f, -0.04009838f, -0.03740397f, 
    -0.03959658f, 0.10004874f, 0.01018088f, 0.22280811f, -0.08297177f, 0.00770323f, -0.02109024f, 0.05894671f, 
    0.48332056f, 0.04971946f, -0.23069040f, 0.04397275f, 0.11839777f, -0.03419477f, 0.06716053f, 0.02802432f, 
    0.10846300f, -0.07741987f, 0.01086539f, 0.12137531f, -0.38302892f, -0.22071090f, 0.19881955f, 0.08015491f, 
    -0.05580904f, -0.05591115f, 0.04570863f, -0.01221691f, -0.06073818f, -0.08384290f, -0.04583876f, 0.08802889f, 
    0.09237770f, -0.06788468f, 0.03064635f, -0.36875787f, 0.11274580f, 0.01059739f, 0.01964044f, 0.19230619f, 
    -0.06272661f, 0.07589905f, 0.01649727f, 0.02980377f, -0.01314907f, -0.01944200f, -0.12921920f, -0.00488434f, 
    -0.13827172f, -0.06797790f, 0.01951806f, 0.05920371f, -0.01730249f, -0.07616782f, 0.11885049f, -0.00554572f, 
    0.17551747f, -0.00768221f, 0.16633761f, 0.00901866f, -0.03211995f, 0.12016689f, -0.00798898f, -0.02271143f, 
    0.08317742f, 0.00789411f, 0.17770316f, 0.07156483f, 0.25767347f, 0.08906861f, -0.03420753f, 0.04597269f, 
    0.08063134f, 0.00826269f, 0.00443288f, 0.05000708f, 0.00533062f, 0.13675885f, -0.14508969f, 0.09387974f, 
    -0.06744702f, 0.23841369f, -0.03888088f, 0.00076121f, -0.07209606f, 0.00763593f, -0.00590215f, -0.10497700f, 
    0.04369498f, 0.08017960f, 0.08750039f, 0.16954289f, 0.14800726f, 0.05965114f, -0.23944774f, -0.01515724f, 
    0.01732174f, 0.04707521f, -0.00694442f, -0.04008505f, 0.05633345f, -0.07004818f, 0.05315111f, 0.08393709f, 
    -0.04964476f, 0.02042442f, 0.02913689f, -0.13096659f, 0.06873211f, 0.01921305f, 0.01110029f, 0.09332974f, 
    -0.09270986f, -0.09569187f, 0.05686839f, 0.01110245f, 0.15899402f, -0.01112112f, 0.06645427f, -0.02376465f, 
    0.02405290f, 0.11388049f, -0.03553216f, 0.08108602f, 0.02992044f, 0.01678213f, 0.02614030f, -0.07068134f, 
    -0.11311530f, -0.20681770f, 0.12879074f, -0.01834243f, -0.12573543f, -0.08573505f, 0.04067731f, 0.02407428f, 
    -0.00891755f, -0.02740094f, 0.05033848f, 0.09026056f, 0.13104090f, 0.02339899f, -0.13380975f, -0.00894597f, 
    0.08988819f, 0.06515314f, 0.13218148f, 0.02394298f, 0.00943755f, 0.05764645f, 0.07056969f, 0.03449646f, 
    -0.02884125f, -0.19722070f, -0.05866009f, 0.03110975f, 0.03154216f, 0.02650560f, -0.00904702f, -0.03241264f, 
    -0.10096232f, 0.08970343f, 0.06283037f, -0.09237923f, -0.10560083f, -0.09805259f, -0.00485517f, -0.01400026f, 
    -0.05733358f, -0.03142655f, -0.03562795f, -0.05724354f, 0.05891309f, 0.03146372f, 0.06753549f, -0.04718146f, 
    -0.21089700f, -0.21073321f, 0.00647520f, -0.01318619f, -0.15537730f, -0.03981424f, -0.09650472f, -0.15245917f, 
    -0.06342144f, -0.16077965f, -0.03508110f, -0.11347103f, 0.06752864f, 0.13408203f, 0.01534604f, -0.14055786f, 
    0.05796295f, 0.04175619f, 0.04698022f, 0.10816177f, 0.02019374f, 0.15780571f, -0.06694943f, 0.21605906f, 
    -0.15312654f, 0.02669773f, -0.01845371f, 0.07436144f, -0.04354405f, 0.02327251f, -0.05378640f, -0.07727612f, 
    0.04477790f, 0.05000551f, -0.13535739f, -0.15652923f, 0.02019512f, 0.14057170f, 0.00450874f, -0.02474285f, 
    0.04628263f, 0.06331163f, -0.03729556f, 0.03966677f, 0.06772703f, 0.09752606f, 0.08792237f, 0.06780507f, 
    0.13393386f, 0.04056770f, 0.00179781f, -0.05714463f, 0.12675570f, 0.05846224f, -0.01482316f, 0.06081632f, 
    -0.08079138f, -0.10373491f, 0.01373973f, 0.12740551f, 0.01706422f, 0.15475471f, 0.06226318f, -0.11721472f, 
    -0.03606660f, 0.08328628f, -0.00516450f, 0.05756574f, 0.01436820f, -0.00617108f, 0.02007898f, 0.04373810f, 
    -0.10284682f, -0.02238592f, -0.10173234f, -0.02941997f, -0.12332568f, 0.01333737f, -0.08768982f, -0.12534007f, 
    -0.09073425f, 0.07873329f, 0.09593387f, 0.12624760f, -0.12119041f, -0.01103873f, -0.12096031f, -0.03458776f, 
    -0.07298408f, -0.04635530f, 0.06140656f, 0.07857912f, -0.17784260f, 0.11534163f, -0.08285695f, 0.03131110f, 
    -0.01083719f, -0.18636404f, 0.06331054f, -0.08074207f, -0.04931463f, 0.01543113f, 0.03442590f, 0.14307927f, 
    -0.09762014f, -0.03900546f, -0.05061348f, -0.00205396f, 0.19610868f, -0.16079722f, -0.23812400f, 0.04654982f, 
    0.16971166f, 0.00997942f, 0.04792262f, 0.11607374f, 0.03000680f, 0.08758937f, -0.02731489f, -0.02274067f, 
    -0.29555336f, 0.01826612f, 0.20834547f, -0.03895630f, 0.07020535f, -0.09254420f, -0.09985790f, 0.07246617f, 
    0.00687947f, 0.10825544f, -0.03706516f, 0.01362212f, 0.30284148f, 0.23397845f, -0.12966453f, 0.08074715f, 
    0.00655114f, 0.00915197f, 0.05904257f, 0.02674041f, 0.02830117f, 0.02312963f, 0.07480101f, -0.03297077f, 
    -0.04349481f, 0.08663279f, -0.04260521f, -0.16439438f, -0.00077490f, 0.03782217f, -0.01863311f, 0.01675462f, 
    0.04504414f, -0.07156867f, -0.11595457f, -0.10193490f, -0.05441879f, -0.04673869f, -0.01517863f, -0.09852301f, 
    -0.06333533f, -0.10017793f, -0.15244295f, 0.15387642f, -0.10656250f, -0.08451725f, -0.01937259f, 0.04720474f, 
    -0.08930615f, 0.29963794f, 0.29115826f, -0.18600568f, 0.02583391f, -0.01706736f, 0.01383668f, 0.11468619f, 
    0.06346388f, -0.05569081f, -0.05234294f, 0.19861349f, 0.30106711f, 0.16438603f, -0.04615351f, -0.00771298f, 
    0.15297160f, 0.00002509f, -0.15003845f, -0.07733853f, 0.01740474f, -0.09460219f, -0.05372908f, -0.01852570f, 
    -0.12100790f, -0.03766119f, -0.09502428f, -0.12664846f, -0.09539748f, -0.11709824f, -0.02717927f, -0.10219239f, 
    -0.04274610f, 0.18799753f, -0.02227458f, -0.03658186f, 0.16269615f, 0.17507242f, 0.01714370f, 0.01534227f, 
    -0.06430689f, 0.17051992f, 0.07309821f, 0.13377558f, 0.02398814f, 0.17916895f, -0.07176151f, 0.05757508f, 
    -0.22383094f, -0.04042508f, 0.06486773f, 0.04774646f, -0.00218039f, -0.07483707f, 0.01801332f, -0.02421566f, 
    -0.10646836f, -0.06620323f, -0.09530270f, 0.01252093f, -0.23799571f, -0.04749430f, -0.06618879f, -0.01301912f, 
    -0.15871383f, -0.02532437f, -0.00182330f, -0.07948481f, -0.11566319f, -0.02585832f, -0.00636152f, 0.08771462f, 
    -0.05931951f, -0.11121234f, -0.18437153f, -0.07753478f, -0.08492722f, 0.07949078f, 0.06167376f, -0.17829072f, 
    -0.10487541f, 0.02722761f, 0.10699664f, 0.17557001f, 0.35991710f, 0.14089949f, -0.07470586f, -0.05931026f, 
    0.03299490f, 0.01805710f, -0.03043782f, 0.08568414f, -0.07604646f, -0.01976790f, -0.06112691f, 0.00334294f, 
    0.19309780f, -0.12086158f, -0.17766298f, 0.03972487f, 0.05477874f, 0.03825335f, 0.03491274f, -0.08965390f, 
    -0.05182698f, 0.04911093f, -0.01096508f, -0.07007032f, 0.13412039f, -0.06282713f, -0.09925337f, 0.02625026f, 
    0.05087854f, 0.05673910f, -0.03445593f, 0.05079981f, 0.04287351f, 0.00433875f, 0.01259856f, -0.02934726f, 
    -0.10195588f, 0.20428628f, -0.06664861f, -0.12836862f, -0.02344119f, -0.10216975f, 0.02202011f, -0.00491434f, 
    0.02609274f, -0.03493644f, -0.01745372f, -0.09876210f, 0.04723791f, 0.03088412f, 0.17109224f, -0.13122253f, 
    0.02786800f, 0.12735599f, -0.04134917f, 0.11690073f, 0.01146988f, 0.05491808f, 0.06456448f, 0.27709612f, 
    0.17216866f, 0.21224526f, -0.20871009f, 0.01143081f, -0.07830778f, 0.07680125f, 0.00158204f, 0.12011709f, 
    -0.02835117f, -0.03319862f, 0.06436451f, 0.10948732f, -0.10138256f, -0.00378778f, 0.04293475f, -0.11472573f, 
    -0.07084576f, -0.04433040f, 0.00015454f, -0.13423234f, 0.02473957f, -0.00398813f, 0.06482849f, 0.19350004f, 
    -0.26643270f, -0.06456999f, -0.10497351f, 0.38563213f, -0.09249580f, -0.04872613f, 0.10963997f, -0.08983645f, 
    -0.08075398f, -0.08722857f, 0.24685001f, 0.21413478f, 0.07988939f, 0.17180720f, -0.16616249f, -0.19109669f, 
    -0.06216365f, 0.09037445f, 0.12330853f, 0.03449464f, 0.05778382f, 0.02316334f, 0.10484578f, 0.06576915f, 
    0.08592870f, 0.17031217f, 0.05786091f, -0.17058530f, -0.02972235f, 0.05931119f, -0.01849883f, 0.12575842f, 
    0.01131733f, -0.00607947f, 0.06149174f, -0.19103740f, -0.13109195f, 0.37388444f, 0.09227186f, -0.13145667f, 
    0.22522184f, 0.13060585f, 0.00579048f, -0.01892344f, 0.09464247f, 0.04939627f, -0.03896093f, 0.05247217f, 
    -0.23383218f, -0.06851386f, 0.07967175f, 0.00977175f, -0.05903141f, -0.05428579f, -0.13219558f, 0.00155005f, 
    -0.08976567f, 0.03119010f, -0.06118761f, -0.12105585f, -0.23047103f, -0.06787186f, 0.09578517f, 0.10511329f, 
    -0.01934386f, -0.04703382f, -0.04573222f, -0.11123345f, -0.01709553f, -0.04581416f, 0.05785597f, 0.00673845f, 
    -0.15567219f, -0.02512560f, 0.01325592f, 0.24226664f, -0.10230849f, -0.06071907f, -0.03573964f, -0.03722283f, 
    0.01403160f, -0.15370236f, -0.02238421f, 0.00196093f, 0.02908748f, 0.01345494f, 0.02212645f, -0.21229807f, 
    -0.04926343f, -0.10527115f, 0.00252812f, 0.02303322f, 0.03995410f, 0.03352224f, 0.09213618f, 0.14942710f, 
    0.18134965f, 0.05290106f, -0.24139972f, 0.00239411f, 0.01379570f, 0.08968739f, 0.12994105f, 0.00879265f, 
    -0.00547736f, 0.02329029f, -0.02416850f, 0.13042210f, 0.08775833f, -0.14692146f, 0.14422111f, -0.05089189f, 
    0.01860009f, 0.00892385f, -0.04054119f, -0.02100881f, -0.00392125f, 0.05173104f, 0.07312998f, -0.06504191f, 
    -0.22307882f, -0.01624938f, -0.15988691f, 0.14051950f, -0.03618338f, 0.04163209f, -0.06791724f, -0.04013649f, 
    -0.01885231f, -0.00072819f, -0.00959480f, -0.07989316f, 0.10017093f, 0.14850095f, -0.18769589f, -0.09522991f, 
    -0.05653353f, 0.06597237f, 0.02075193f, 0.01512997f, -0.07157461f, 0.05607673f, 0.07411911f, 0.01167975f, 
    -0.14592098f, -0.06089994f, -0.04465305f, 0.02225292f, -0.04952080f, 0.05622490f, -0.04951710f, -0.02190860f, 
    -0.18951842f, -0.03695783f, -0.00725231f, -0.25664964f, 0.09676782f, 0.11235347f, -0.22510536f, -0.05649257f, 
    -0.08365895f, 0.12610328f, 0.12554432f, 0.23418601f, 0.02479679f, -0.10997210f, -0.01295737f, 0.07551831f, 
    0.15019247f, -0.02402784f, 0.01882309f, 0.03105055f, -0.12329658f, -0.08848677f, -0.03384287f, -0.11842024f, 
    -0.02337405f, 0.01085920f, -0.00575519f, -0.00433383f, -0.06843470f, -0.22592056f, 0.15931469f, -0.03441549f, 
    -0.07624322f, 0.06841699f, -0.01411744f, 0.07691220f, -0.22685550f, 0.02275313f, -0.23275882f, -0.07231530f, 
    -0.20442022f, 0.24936658f, 0.12374227f, -0.13347973f, -0.09344617f, 0.07019492f, -0.03067525f, -0.10117970f, 
    0.06016454f, 0.03486200f, 0.04944889f, 0.01032226f, -0.19531739f, 0.14194933f, 0.15405147f, -0.16927879f, 
    -0.01021527f, 0.01387216f, 0.03571646f, -0.11408719f, 0.05352646f, -0.02224034f, 0.05315232f, -0.00362179f, 
    0.14177804f, 0.13845134f, 0.23405996f, 0.01684518f, 0.08915383f, 0.17613381f, -0.05959649f, 0.02201298f, 
    0.02298956f, -0.23240793f, -0.23667480f, -0.18958125f, -0.06080113f, 0.04065287f, -0.19534817f, 0.03486099f, 
    0.29506844f, -0.05824739f, 0.06971148f, -0.01669606f, -0.12266269f, -0.11046611f, -0.18479536f, -0.09178979f, 
    0.24139351f, 0.17968556f, 0.28706512f, 0.09083281f, -0.05392695f, -0.01661312f, 0.12020351f, 0.04959960f, 
    0.08656324f, 0.03246165f, 0.05271636f, 0.09204515f, -0.06556237f, -0.01376952f, 0.06640205f, 0.01875928f, 
    0.00459016f, 0.07489713f, 0.00448410f, 0.01099366f, 0.04574403f, -0.04860992f, -0.03866063f, 0.04234195f, 
    -0.24617487f, -0.04780658f, 0.21687128f, -0.00148838f, -0.09164242f, 0.05138271f, 0.10639494f, 0.13162148f, 
    -0.07675353f, -0.03484319f, 0.14187361f, 0.07556248f, -0.02282229f, 0.22319950f, 0.19154301f, -0.01983384f, 
    -0.01676462f, 0.05329994f, -0.06375695f, -0.10225181f, -0.04699567f, 0.11452307f, 0.23970528f, 0.11256550f, 
    0.00634317f, 0.08282238f, 0.06942619f, 0.37320629f, -0.02770264f, 0.10211397f, 0.05046234f, 0.13710532f, 
    0.05745411f, -0.06345103f, -0.02847221f, 0.03722397f, -0.07425623f, -0.08269840f, -0.00856085f, -0.03363834f, 
    0.03870598f, -0.10383989f, -0.03692306f, -0.08726012f, 0.00875728f, -0.05399524f, -0.06193101f, -0.06267665f, 
    0.21514755f, 0.05953138f, -0.10636286f, 0.04220562f, 0.13584903f, -0.20342462f, -0.04509092f, -0.07240110f, 
    -0.11848199f, 0.08554863f, -0.06012718f, 0.08192300f, 0.01476918f, 0.03252389f, 0.05257684f, 0.09993538f, 
    0.05368337f, 0.03807703f, 0.03784639f, -0.05957908f, -0.01616403f, -0.01090559f, 0.17597142f, 0.08772565f, 
    0.05253184f, -0.16463789f, 0.04590693f, 0.02179974f, 0.00983937f, -0.14936028f, -0.11322555f, 0.01875988f, 
    -0.08988409f, -0.03785661f, 0.01553999f, -0.23051845f, -0.07491412f, 0.08578374f, 0.19963433f, 0.11224135f, 
    -0.01592647f, -0.05526936f, 0.00637320f, -0.06408200f, -0.06673029f, 0.10470711f, -0.00596857f, -0.12727012f, 
    -0.00484039f, 0.05704692f, -0.06133400f, 0.04524525f, 0.03491141f, 0.05774634f, 0.04195710f, -0.21009319f, 
    0.01883452f, -0.01174526f, -0.14383684f, -0.10237619f, 0.04079445f, -0.06652313f, -0.08048102f, 0.17483680f, 
    -0.03357680f, -0.03745270f, 0.07539386f, 0.01931118f, 0.11459540f, -0.02997178f, -0.08864487f, 0.19608790f, 
    -0.01552773f, 0.13635336f, -0.13109507f, 0.07244676f, 0.20110805f, 0.03602600f, -0.11784537f, -0.11357564f, 
    -0.23272000f, -0.11731716f, -0.07207255f, -0.19458087f, 0.01755514f, -0.08179529f, 0.08107073f, 0.05893417f, 
    -0.08711571f, -0.00885431f, 0.00175405f, 0.15649647f, 0.06788050f, 0.06077775f, -0.03283204f, -0.05908426f, 
    0.09889228f, 0.09704511f, 0.17472714f, 0.03879099f, -0.13909435f, -0.06990231f, -0.00700996f, -0.03325571f, 
    0.08297671f, -0.08445698f, 0.02770552f, 0.05956941f, 0.14972329f, -0.02410521f, -0.18535607f, 0.01714033f, 
    0.05634785f, 0.05305586f, -0.00745064f, 0.05517843f, -0.07439411f, 0.08741456f, -0.10274822f, 0.02184802f, 
    0.27435458f, 0.08457153f, -0.20511597f, -0.17667152f, 0.15188941f, -0.01818935f, 0.10583327f, 0.17422833f, 
    -0.07577631f, 0.16158800f, 0.09761781f, -0.01927053f, -0.00535199f, 0.00060315f, 0.05652755f, 0.26126334f, 
    0.03764818f, 0.13372698f, -0.04169525f, 0.01111904f, -0.15906464f, -0.11519649f, 0.02321672f, -0.21461932f, 
    -0.05858115f, 0.00191676f, 0.02229427f, -0.08100808f, 0.01312828f, -0.00747349f, 0.05899498f, 0.04947463f, 
    0.16283502f, 0.30213583f, 0.08158829f, 0.31739980f, 0.15588608f, -0.03820329f, 0.10050576f, 0.01884254f, 
    0.00860336f, -0.06422006f, 0.04314192f, -0.05360510f, -0.12005726f, -0.11041619f, -0.07187053f, -0.11032327f, 
    0.02807245f, 0.06359632f, 0.07602911f, 0.01011617f, -0.04899862f, -0.13409986f, 0.01677511f, -0.07231106f, 
    -0.04217228f, 0.14589910f, -0.10377553f, -0.09032798f, 0.17746972f, -0.24964854f, 0.02713777f, 0.06158698f, 
    0.14079951f, 0.03959486f, -0.06466459f, 0.05452258f, -0.01965012f, 0.04412036f, 0.11268684f, -0.03815800f, 
    0.07719009f, -0.09896322f, -0.10306442f, 0.00829633f, 0.00915449f, -0.05343108f, -0.00157116f, 0.10012911f, 
    -0.05709302f, -0.09335215f, -0.06203658f, -0.18882458f, 0.20454319f, 0.00041138f, -0.07969261f, 0.05329514f, 
    -0.00968578f, -0.05288912f, -0.13287851f, -0.00775307f, 0.25234202f, 0.01893093f, 0.18477547f, -0.02572784f, 
    -0.02536896f, 0.39321271f, 0.06634112f, 0.19600838f, 0.06289626f, 0.09723543f, 0.07825555f, -0.01019379f, 
    0.11666837f, -0.01174712f, -0.05743864f, 0.16152656f, -0.09567965f, -0.01147774f, 0.24923247f, 0.02641722f, 
    -0.09705228f, -0.07067443f, 0.12003116f, -0.04262968f, 0.09156408f, -0.02152146f, 0.11875647f, -0.02578266f, 
    0.39638323f, -0.05482765f, -0.04375212f, -0.00755996f, -0.04288960f, 0.04853358f, 0.02122034f, -0.08907754f, 
    0.04912615f, 0.06121946f, 0.12575841f, 0.12314533f, -0.12521113f, -0.13653176f, 0.13343924f, -0.07778028f, 
    0.03967862f, 0.06622931f, -0.00007763f, 0.00116511f, -0.13685578f, -0.06704901f, 0.00736303f, 0.00811743f, 
    -0.05863345f, -0.17123361f, 0.09714487f, 0.15502451f, -0.03761646f, -0.03609671f, 0.10351346f, 0.00511721f, 
    0.05922046f, 0.10090192f, 0.21451089f, 0.26938927f, -0.10443623f, 0.03754189f, 0.04359089f, 0.07785680f, 
    -0.04641849f, 0.08849549f, 0.14208031f, 0.10716303f, 0.11137681f, 0.24154839f, 0.15737534f, 0.20764776f, 
    0.00687587f, -0.10914841f, -0.05772180f, 0.12613502f, -0.02668684f, 0.15974583f, -0.13091899f, -0.12028658f, 
    0.03361202f, 0.05781556f, 0.07988137f, -0.10674987f, -0.18114489f, -0.04594176f, 0.00088457f, 0.09071234f, 
    -0.03654124f, 0.06108746f, 0.14090142f, 0.26158455f, 0.08581050f, 0.16232236f, 0.12850685f, 0.23443732f, 
    0.07095776f, -0.07633681f, -0.09667704f, 0.01661582f, 0.09185176f, 0.10419696f, 0.09057715f, 0.09395576f, 
    0.05389123f, -0.09791641f, -0.00983541f, -0.01812856f, -0.21262760f, -0.11048727f, 0.14271043f, 0.01779296f, 
    -0.06606753f, -0.03662052f, 0.05610654f, -0.03347614f, -0.09424885f, -0.15119851f, -0.00230541f, -0.09617381f, 
    0.11506452f, -0.00201402f, -0.08469220f, -0.05803820f, -0.15781659f, -0.07262552f, -0.11446418f, -0.07360420f, 
    0.11113559f, 0.12726004f, 0.13343410f, 0.06125527f, 0.18229114f, -0.07739788f, 0.02311421f, 0.10134649f, 
    0.00340424f, -0.02081513f, 0.00385752f, 0.10321973f, -0.06229979f, -0.07899908f, -0.02285472f, -0.23807429f, 
    0.03347847f, -0.09562943f, 0.24972641f, 0.03477424f, -0.12071823f, -0.01729200f, -0.03889379f, 0.11612353f, 
    -0.13517255f, -0.03493486f, 0.00151086f, -0.33671793f, -0.06614463f, -0.07332203f, 0.09125555f, 0.09623025f, 
    -0.09156583f, 0.00066709f, 0.12335464f, 0.06585737f, 0.07169031f, -0.02257770f, -0.02472800f, 0.19148983f, 
    -0.06989045f, 0.13414778f, 0.18248616f, -0.02263704f, -0.09046618f, 0.01908032f, 0.01475907f, 0.06209745f, 
    0.05803637f, -0.02486135f, 0.11369494f, 0.23606130f, -0.03590783f, -0.09387116f, 0.11693473f, -0.11029238f, 
    -0.00176192f, 0.01667894f, 0.12439675f, 0.09544842f, 0.09485384f, 0.10106018f, 0.13370322f, 0.23641653f, 
    0.14492384f, 0.03425685f, 0.10912520f, 0.08820415f, 0.09915435f, -0.04070676f, 0.05028065f, 0.06678086f, 
    -0.12825657f, 0.02171757f, -0.03649810f, -0.06367006f, 0.02924258f, 0.15380812f, -0.06190770f, 0.23783065f, 
    -0.05041556f, -0.03466176f, 0.07280617f, -0.11145248f, -0.12350380f, 0.01412669f, -0.15634854f, -0.21651128f, 
    -0.04893158f, -0.15513366f, 0.09450437f, 0.12811899f, 0.10684221f, 0.03084285f, 0.15590425f, 0.07060145f, 
    0.04275354f, 0.14702238f, -0.01405917f, 0.02434132f, -0.11033189f, 0.12786162f, -0.04619518f, 0.16896200f, 
    0.13770711f, -0.04685428f, -0.00703516f, 0.09582412f, -0.04435184f, 0.16571064f, -0.05667431f, -0.21482126f, 
    0.02977218f, 0.09144527f, 0.13379201f, -0.30658132f, 0.05021865f, 0.03371561f, -0.04008125f, -0.04847072f, 
    -0.11751002f, 0.14074652f, -0.02365075f, -0.21082088f, -0.10142428f, -0.07736421f, 0.09777919f, 0.14009950f, 
    0.01923385f, 0.00472610f, 0.03627228f, 0.05464434f, -0.00161969f, -0.02059403f, -0.17537844f, -0.23427075f, 
    -0.08169173f, -0.02535177f, -0.05696977f, 0.13864520f, 0.05052865f, 0.05474706f, 0.04323649f, -0.13792250f, 
    0.08596326f, 0.10363917f, 0.03351166f, 0.33149949f, 0.12396708f, -0.17969033f, 0.01577917f, 0.14723389f, 
    0.00241345f, 0.09306275f, -0.05969562f, -0.05045927f, 0.07930113f, -0.16077240f, 0.09113637f, -0.09700906f, 
    0.09275229f, -0.09018908f, 0.01264683f, 0.02497852f, 0.05316862f, -0.03190053f, 0.14757992f, 0.22699547f, 
    0.19306523f, 0.09020451f, 0.06879155f, 0.22320454f, 0.18911855f, 0.08513674f, 0.03793621f, 0.00239495f, 
    0.02142323f, 0.03108034f, -0.08278929f, 0.04844265f, -0.16131976f, -0.03144972f, -0.09305905f, -0.12503637f, 
    0.02435852f, -0.04399537f, 0.18189961f, -0.15530929f, -0.02758024f, -0.03556160f, -0.10939655f, -0.17766176f, 
    -0.20421304f, 0.06078437f, -0.09748688f, 0.07580961f, -0.11032121f, 0.05043916f, -0.04721726f, 0.05322874f, 
    0.16388865f, 0.00848394f, -0.02038353f, -0.02857666f, -0.14346388f, 0.03655837f, -0.08261552f, -0.10040469f, 
    -0.14553492f, -0.01578275f, 0.11640031f, 0.05051117f, 0.07796376f, 0.01422529f, -0.08013764f, 0.06557456f, 
    -0.05004935f, -0.05774812f, -0.06512927f, -0.17089280f, -0.06251119f, 0.14137515f, -0.02108268f, -0.02359397f, 
    0.10375319f, 0.08399690f, 0.12565255f, 0.16995041f, 0.03718846f, 0.04303833f, -0.02735903f, 0.22983107f, 
    0.12736998f, 0.04211471f, 0.07491047f, -0.10621507f, -0.06300076f, -0.06989157f, 0.00058954f, -0.07791445f, 
    -0.07119770f, -0.12028813f, -0.15239866f, -0.09187830f, -0.00922931f, -0.07463465f, 0.09649694f, -0.05630264f, 
    0.11656056f, -0.09870432f, -0.01745145f, 0.16370040f, 0.01346107f, -0.14871684f, -0.20414896f, -0.17211094f, 
    0.00474867f, -0.07672449f, -0.08409163f, -0.02042592f, -0.01406289f, -0.09732213f, 0.12905663f, 0.10040676f, 
    0.25020123f, 0.19232948f, 0.16217248f, 0.40435717f, 0.05717664f, 0.10434394f, 0.08683667f, 0.08689788f, 
    0.08214609f, -0.20320576f, -0.07786537f, 0.08589931f, 0.06870677f, -0.04350640f, 0.00872930f, -0.02101595f, 
    -0.21694107f, 0.08945587f, -0.03445197f, -0.03766914f, 0.01791352f, 0.05531081f, 0.03072991f, 0.12538733f, 
    -0.00425283f, 0.28180173f, 0.10948487f, 0.18108539f, 0.17791542f, 0.23164359f, -0.10482207f, 0.15213262f, 
    0.03177867f, -0.12498660f, -0.15321548f, -0.20859145f, 0.22483325f, 0.25511533f, 0.26743481f, 0.33827996f, 
    0.10021252f, 0.02699418f, -0.05052082f, 0.10334888f, 0.09400616f, -0.22765018f, -0.00242074f, -0.11929011f, 
    -0.23759952f, 0.02135167f, -0.14281011f, -0.17698747f, 0.13427961f, -0.06895081f, -0.01275964f, 0.14894968f, 
    0.08957535f, -0.04606360f, 0.01658804f, 0.08393293f, 0.06764128f, -0.00566351f, -0.20185234f, -0.09507824f, 
    0.15573835f, 0.11752398f, -0.15660071f, 0.06113536f, -0.10569170f, 0.03901687f, 0.10882403f, 0.03753390f, 
    -0.00790740f, -0.00748548f, 0.09634071f, 0.01599653f, -0.04560753f, 0.03472106f, 0.10469830f, 0.04914112f, 
    -0.21907179f, 0.07118838f, -0.06368975f, 0.05121703f, 0.02271487f, 0.09645300f, 0.14198172f, 0.04674996f, 
    -0.10327805f, -0.01615652f, -0.16858476f, 0.03513305f, -0.00401959f, 0.00486874f, 0.08946309f, 0.14419620f, 
    -0.12346086f, -0.04412900f, -0.18351968f, -0.24925765f, 0.22786912f, 0.28440955f, 0.06371823f, 0.08714835f, 
    0.00726299f, 0.03517503f, 0.02227458f, 0.22338672f, -0.02003737f, -0.06891471f, -0.05802699f, -0.08377097f, 
    0.32277662f, 0.04429060f, -0.24399710f, 0.23810001f, -0.03459796f, -0.00784693f, -0.12310849f, 0.02940124f, 
    0.04843552f, -0.08607972f, -0.07023010f, 0.06227682f, 0.03059725f, -0.49386853f, 0.07246754f, 0.01061453f, 
    0.08649249f, -0.01319695f, -0.12972158f, -0.01768745f, -0.04694991f, -0.06673992f, -0.17983072f, -0.03576165f, 
    -0.04108639f, 0.20194045f, 0.14084698f, -0.15818794f, -0.01870024f, -0.12894230f, -0.13139725f, 0.09126914f, 
    -0.09316098f, 0.10994699f, -0.09331208f, 0.07876204f, 0.00312199f, 0.05380685f, -0.04636607f, 0.08244732f, 
    0.01191875f, 0.01632080f, -0.00345207f, 0.01322450f, 0.09852447f, 0.02839751f, 0.01747648f, 0.08472423f, 
    0.03440291f, 0.00126066f, 0.13178736f, -0.25234699f, -0.16151467f, 0.05122063f, -0.06383961f, 0.10578691f, 
    0.04833106f, 0.06639504f, -0.08388427f, -0.24225983f, 0.17271644f, 0.10562069f, 0.09532271f, 0.10812108f, 
    0.00802144f, -0.10112381f, 0.07425322f, 0.00880230f, 0.04470135f, 0.03405447f, -0.13522026f, 0.07288240f, 
    -0.15093072f, 0.12752679f, 0.03028916f, 0.05305438f, -0.09956919f, 0.08166772f, 0.09470520f, 0.05742700f, 
    0.09206023f, 0.12544678f, -0.01567258f, 0.03040558f, 0.13097274f, 0.05342846f, -0.12511742f, 0.00226948f, 
    -0.06222797f, 0.21402048f, 0.00785980f, 0.03017147f, 0.06745559f, -0.11367572f, -0.07751767f, -0.06590807f, 
    -0.03022647f, 0.13074271f, 0.06950039f, -0.02961971f, -0.03121998f, -0.16350630f, -0.02978769f, -0.04334224f, 
    -0.16573408f, -0.04434944f, 0.07953269f, 0.06586730f, 0.15803063f, 0.10761013f, 0.26638362f, 0.05790863f, 
    0.00695969f, 0.14449421f, -0.16789052f, -0.02215837f, 0.15214376f, -0.06639568f, -0.12269533f, -0.22056703f, 
    0.19513188f, -0.05043829f, 0.18628381f, 0.02184457f, -0.08124966f, -0.07222710f, 0.07212988f, -0.02321587f, 
    0.01000877f, 0.05845273f, 0.02772550f, 0.15526141f, 0.05920530f, 0.20060956f, 0.20324713f, -0.07166991f, 
    -0.08466533f, 0.08047968f, 0.16149023f, -0.09007371f, -0.10741778f, 0.03820688f, 0.07135703f, 0.08030235f, 
    0.20896024f, -0.16141658f, -0.16317765f, -0.02103596f, 0.03246713f, 0.11277611f, 0.05666682f, 0.11089604f, 
    -0.09995177f, 0.09318689f, -0.12665057f, -0.16695820f, -0.00215663f, 0.03849398f, -0.03420182f, -0.06275244f, 
    -0.04390497f, -0.00239939f, 0.02879902f, 0.08088025f, 0.04797581f, -0.04619274f, -0.07502911f, -0.16040315f, 
    0.02621365f, -0.03849217f, 0.07411706f, 0.00576517f, -0.05275377f, -0.00984036f, -0.05670632f, -0.00687631f, 
    0.06615166f, 0.10949751f, 0.10679694f, 0.06812558f, -0.05756033f, 0.14073358f, 0.18317492f, -0.08474899f, 
    -0.05589134f, -0.05014830f, 0.11258300f, 0.01724686f, -0.01152234f, -0.00291385f, -0.12732328f, 0.07542156f, 
    -0.07795773f, -0.09614538f, -0.00059084f, -0.03436174f, -0.01115846f, 0.04641028f, -0.00713375f, -0.00764703f, 
    -0.01774579f, -0.24576606f, -0.21836419f, 0.14490026f, 0.06009098f, 0.17876343f, -0.11751342f, -0.09845690f, 
    -0.10673866f, 0.09216619f, 0.02629831f, 0.02608122f, 0.08559380f, 0.15475035f, 0.03045023f, -0.12511833f, 
    0.03441861f, 0.10442896f, 0.03627522f, 0.18095784f, 0.00861604f, 0.00478072f, -0.03639899f, 0.08594415f, 
    -0.02065384f, -0.03939036f, 0.03870572f, 0.09500231f, -0.29061875f, 0.33264947f, 0.12662525f, -0.10268646f, 
    0.01296968f, -0.08150186f, 0.04093347f, 0.00921847f, -0.03747441f, 0.10153714f, -0.13894217f, -0.03053855f, 
    0.06561903f, -0.01731485f, -0.04008433f, 0.04199935f, -0.03988755f, 0.00604344f, 0.07110365f, -0.01848932f, 
    0.02619313f, 0.05763710f, 0.09829856f, -0.01870153f, 0.04963884f, 0.00086831f, -0.05248873f, 0.04756363f, 
    -0.03797608f, -0.02137560f, 0.13457815f, 0.06176574f, -0.16386968f, -0.01147066f, -0.05303921f, -0.08788874f, 
    0.10025493f, -0.09229974f, -0.11661299f, -0.16189903f, -0.04758912f, -0.31917253f, 0.05523370f, -0.01600236f, 
    -0.12282593f, 0.00383945f, -0.03148288f, -0.10382023f, 0.23739047f, 0.14898962f, -0.02167047f, 0.11823717f, 
    0.10470741f, 0.12630440f, 0.09113581f, 0.00708899f, 0.03021112f, 0.02760499f, -0.23098454f, -0.13989201f, 
    -0.35690948f, 0.05588238f, 0.08100059f, 0.04452038f, 0.12998728f, -0.04772088f, -0.03771056f, 0.03313698f, 
    -0.11296284f, 0.12243253f, -0.29950330f, -0.21712559f, 0.11792519f, 0.35919705f, 0.01671867f, 0.01500100f, 
    -0.09038340f, 0.10132772f, -0.15048257f, -0.04365866f, 0.00460416f, 0.00286518f, -0.02900887f, -0.12496630f, 
    -0.07202366f, 0.08961386f, -0.02901878f, -0.17107520f, 0.05098361f, 0.01496444f, -0.09780322f, -0.00966218f, 
    -0.02865740f, -0.11497168f, -0.15675159f, 0.02217716f, 0.07371815f, -0.03111877f, 0.05235882f, -0.06692198f, 
    0.03599669f, -0.10611209f, -0.10823338f, -0.08491240f, -0.02724676f, -0.15993069f, -0.03967224f, -0.01640452f, 
    -0.35822996f, -0.00434028f, 0.18203945f, -0.11351778f, -0.05830150f, -0.04392112f, -0.00035536f, 0.11659040f, 
    0.07211514f, 0.05575262f, 0.03143198f, 0.04784960f, 0.27127013f, 0.14428785f, 0.07536057f, 0.04260710f, 
    0.04303078f, -0.09786754f, -0.02411674f, -0.11147130f, -0.08413821f, -0.20369051f, -0.11414131f, -0.00461098f, 
    0.01573602f, 0.03361750f, 0.00266319f, 0.01891327f, -0.05347181f, -0.00794824f, 0.04507313f, 0.03813778f, 
    -0.14815649f, -0.00184727f, -0.00985629f, -0.12948003f, 0.32501015f, 0.26061556f, 0.16778392f, 0.06082135f, 
    -0.11569184f, 0.21179698f, -0.04745058f, 0.01886641f, -0.09874431f, 0.03039388f, -0.05771079f, -0.08747463f, 
    -0.10232550f, -0.06087150f, 0.02520841f, -0.00484633f, -0.00807596f, 0.00722057f, 0.06052634f, 0.06882878f, 
    -0.17431352f, -0.03124233f, -0.04071858f, 0.01271297f, 0.01949674f, -0.00598854f, 0.03947990f, 0.04840761f, 
    -0.00344310f, 0.04077474f, -0.02933574f, 0.07355029f, 0.03742716f, 0.09507843f, 0.07750277f, 0.11309990f, 
    0.15265489f, 0.06937522f, -0.07524676f, 0.02738331f, 0.04798153f, 0.02704784f, -0.06377327f, -0.02079861f, 
    0.01352159f, 0.02189873f, 0.02074501f, 0.14883859f, 0.10763482f, 0.13427635f, -0.03752356f, -0.03608218f, 
    0.04314141f, -0.10210714f, -0.11373798f, 0.02747451f, -0.09732666f, -0.02567200f, -0.07068027f, -0.01848846f, 
    0.03862072f, -0.01725988f, -0.13829987f, -0.00506680f, -0.02239900f, 0.03628064f, -0.02263042f, -0.04694078f, 
    -0.09191027f, -0.05195455f, -0.12363170f, -0.22483942f, 0.06092476f, 0.05947451f, -0.01637119f, 0.02135993f, 
    0.02879479f, 0.02805436f, -0.11835150f, -0.11618443f, -0.08159849f, -0.09463029f, -0.17774500f, -0.14704092f, 
    -0.22942637f, 0.07811374f, -0.20439123f, -0.01715041f, -0.08030638f, -0.14663170f, -0.07056548f, 0.05974250f, 
    0.11396088f, 0.10644522f, 0.03809926f, 0.02720439f, -0.21777497f, -0.05223070f, 0.15116367f, -0.12705116f, 
    -0.03428801f, 0.25975865f, -0.05110185f, 0.12299115f, 0.01202069f, -0.07234189f, 0.07180642f, 0.09476773f, 
    0.16587387f, 0.20761558f, -0.10260896f, 0.10371706f, -0.08104941f, -0.04278905f, -0.06104287f, 0.02626501f, 
    0.00139440f, -0.11834132f, -0.02312501f, -0.05064421f, -0.10918181f, 0.03573157f, -0.00475873f, -0.16778494f, 
    -0.09649788f, -0.00441467f, 0.09360863f, 0.05284128f, -0.06594745f, -0.03932726f, 0.05346034f, 0.05242495f, 
    0.19339141f, -0.05508259f, 0.09953594f, 0.17973928f, -0.09652269f, 0.03675207f, -0.01165819f, 0.12928127f, 
    0.00522558f, -0.19609788f, 0.17868441f, 0.33567128f, -0.11360013f, 0.17723282f, 0.21715362f, 0.03713598f, 
    -0.13952287f, 0.00799309f, 0.06204028f, 0.04176333f, -0.00367248f, -0.01163106f, 0.06125031f, 0.09140130f, 
    -0.06072138f, 0.03022415f, -0.06087992f, -0.02681927f, -0.13122934f, 0.06728876f, 0.09580092f, 0.10041104f, 
    -0.01037137f, -0.01187740f, -0.04657013f, -0.10055926f, -0.47363716f, 0.15778226f, 0.03684118f, -0.02772504f, 
    0.02975485f, 0.06756558f, 0.13817722f, 0.10223269f, 0.05339614f, 0.15200032f, 0.03408951f, -0.00393107f, 
    0.02151153f, -0.01077676f, -0.02929558f, -0.01878058f, 0.03950305f, -0.00145625f, -0.14141190f, 0.01963904f, 
    0.06338606f, 0.20859702f, -0.05392228f, -0.11152550f, 0.05786892f, -0.00779259f, -0.02890964f, -0.04817051f, 
    0.00035605f, 0.01910881f, -0.09012099f, -0.02081563f, 0.03339767f, 0.03566571f, 0.17045256f, 0.04495096f, 
    0.05077240f, 0.04229642f, -0.22787695f, -0.06185204f, -0.03647916f, 0.03458687f, 0.02414843f, 0.07381832f, 
    0.07724133f, -0.03984153f, 0.14070180f, 0.05851493f, 0.15696797f, -0.02631797f, 0.10776733f, -0.08981398f, 
    -0.04726262f, 0.02426545f, 0.10059369f, 0.00971939f, 0.09897749f, 0.07393209f, 0.12467416f, 0.04745103f, 
    0.18654032f, 0.15561467f, 0.01765757f, 0.17397822f, 0.05579899f, 0.12582222f, 0.11330394f, 0.09964400f, 
    0.01165346f, 0.04847201f, -0.05141402f, -0.01700269f, 0.05055563f, -0.06739672f, 0.03470801f, -0.10124295f, 
    -0.05976293f, -0.09287450f, -0.20649463f, -0.16776837f, -0.08332032f, -0.03751092f, -0.10737851f, -0.00242938f, 
    0.01588555f, 0.04776346f, -0.01982722f, -0.02404756f, -0.03363627f, 0.02986557f, 0.01635811f, -0.01494492f, 
    -0.00337372f, 0.12929730f, 0.11958623f, 0.07418026f, -0.04780073f, 0.06067767f, 0.16523798f, 0.08199102f, 
    -0.20218796f, 0.18390705f, -0.04711624f, 0.07510344f, -0.01085322f, 0.02723240f, 0.07144053f, 0.08800329f, 
    0.04248961f, -0.01870686f, -0.06179211f, -0.05845340f, 0.00182884f, 0.03169129f, -0.05065275f, 0.02575784f, 
    -0.23395175f, -0.02260368f, 0.04452504f, -0.14614786f, 0.03147713f, 0.12853885f, 0.07713229f, 0.22003996f, 
    -0.14760412f, 0.06038677f, 0.08807123f, 0.09579165f, -0.03797456f, -0.05086390f, -0.02009560f, -0.00871359f, 
    0.07687326f, -0.16719769f, -0.02534423f, -0.05962479f, -0.00327112f, 0.03349246f, -0.02265126f, -0.02974046f, 
    0.07966723f, 0.00663816f, -0.02456508f, -0.14863475f, -0.13663019f, -0.29572076f, 0.03394379f, -0.19784229f, 
    -0.05574514f, -0.04902589f, -0.02979499f, 0.10471019f, -0.15879335f, -0.13865642f, 0.00790252f, -0.09028773f, 
    -0.62991381f, 0.05166334f, 0.38505256f, -0.12327513f, -0.16202055f, 0.00788625f, 0.02953492f, 0.09306893f, 
    0.06029454f, -0.00703018f, 0.12321669f, 0.06124570f, -0.26515296f, 0.19363523f, 0.08529282f, -0.07295209f, 
    -0.07418709f, -0.03448446f, 0.18015641f, 0.16582777f, 0.06131582f, 0.03563813f, 0.14890836f, -0.03297814f, 
    -0.00895036f, -0.04436593f, 0.00131452f, 0.00523042f, 0.00649107f, -0.01214990f, 0.02167387f, -0.01694218f, 
    0.01625949f, 0.01668637f, 0.02163306f, 0.01047834f, 0.02375149f, 0.01344221f, -0.03000931f, 0.02008444f, 
    0.02483995f, -0.03487480f, 0.01291648f, -0.00397275f, -0.01163512f, -0.00462429f, -0.03257766f, -0.00894181f, 
    0.01161797f, -0.02011964f, -0.00979799f, -0.01906702f, -0.03426753f, -0.01631239f, -0.00642863f, -0.03146963f, 
    0.00133390f, 0.00433564f, 0.01721863f, -0.01797010f, -0.01706946f, -0.00408527f, -0.03278892f, -0.03309036f, 
    -0.02024725f, 0.01984334f, 0.01064303f, -0.00499531f, 0.01472335f, -0.00948197f, -0.02860438f, -0.00810744f, 
    -0.01373516f, -0.00601743f, 0.01111618f, 0.01898638f, 0.01319601f, -0.03189841f, 0.00563266f, -0.01997044f, 
    -0.00905832f, -0.02976875f, -0.00313233f, -0.04020732f, -0.04086520f, 0.01183649f, 0.02200265f, -0.00982723f, 
    -0.00623581f, -0.00095057f, -0.00654768f, -0.02445088f, 0.02411317f, -0.01300778f, -0.00343078f, 0.01530218f, 
    -0.02446314f, 0.00793557f, 0.00758964f, 0.01030181f, -0.03024123f, -0.01522223f, 0.01119270f, -0.03491624f, 
    -0.00581138f, 0.00132654f, -0.01998221f, -0.02297271f, 0.02664627f, 0.02258352f, 0.02591649f, -0.01697137f, 
    -0.01536251f, -0.04135819f, 0.01961291f, -0.02993029f, -0.02883993f, 0.02012196f, -0.02236633f, -0.00130091f, 
    -0.01273936f, -0.02012870f, -0.00727155f, -0.03674918f, -0.01967819f, 0.01880977f, -0.01396834f, -0.02005073f, 
    0.02954710f, -0.01261435f, -0.01352186f, 0.00844654f, 0.00899074f, -0.01307013f, -0.03006928f, 0.03653345f, 
    -0.02055529f, -0.01483199f, -0.03347827f, -0.02806555f, 0.00503794f, -0.02856181f, 0.01108138f, -0.03214083f, 
    -0.04173411f, -0.04080592f, 0.01565156f, -0.01814322f, 0.02344475f, -0.01002239f, 0.02372035f, -0.03582853f, 
    0.01867687f, -0.03264667f, -0.03370257f, 0.02649192f, -0.02786631f, -0.00782368f, 0.03405131f, 0.02031334f, 
    0.00263848f, -0.02399458f, 0.02920694f, 0.00686151f, -0.02173904f, 0.00522315f, -0.00456908f, -0.00419108f, 
    -0.02819935f, 0.00030947f, 0.01984464f, -0.02430325f, 0.00829452f, -0.00998191f, -0.00696799f, 0.00533217f, 
    -0.03558577f, -0.01914516f, -0.00342739f, -0.04467165f, -0.01640083f, 0.00616697f, -0.00587392f, 0.00848458f, 
    -0.00061186f, -0.01470566f, 0.01304322f, 0.02858246f, 0.01763799f, -0.01937888f, 0.01051764f, -0.01080708f, 
    -0.02584412f, -0.00054798f, 0.02052324f, -0.00531475f, -0.00797329f, -0.02757206f, -0.03980394f, 0.01747805f, 
    0.02339930f, 0.01585026f, 0.01129791f, -0.02889353f, -0.00062774f, 0.03493433f, 0.01353522f, -0.01516943f, 
    0.00087028f, -0.00200353f, -0.02232884f, 0.02663917f, 0.00581562f, 0.00592573f, -0.00291816f, 0.01044253f, 
    -0.03095174f, 0.03222296f, 0.03450621f, 0.01980965f, -0.00676598f, 0.02024454f, 0.02726153f, 0.01409024f, 
    0.01554696f, 0.02371023f, -0.00803481f, 0.02809528f, 0.02635937f, -0.02216533f, -0.01892919f, -0.00722230f, 
    -0.03484457f, -0.02705813f, -0.00260462f, 0.01276482f, 0.02697815f, -0.01853869f, -0.00727147f, -0.01896311f, 
    0.01803046f, -0.03573864f, -0.03850821f, -0.04172831f, 0.01470280f, -0.01240471f, 0.00881912f, -0.00383516f, 
    -0.00272628f, -0.02440782f, -0.00406639f, -0.00882489f, 0.01996149f, 0.02195557f, 0.01093660f, -0.02583294f, 
    -0.02774963f, -0.00943677f, -0.03486939f, -0.03445569f, -0.00587598f, 0.02999472f, 0.01489939f, -0.00354048f, 
    -0.04092733f, 0.00923566f, -0.03970343f, 0.00883133f, -0.03904780f, 0.00591770f, 0.00370631f, -0.00152346f, 
    -0.01571757f, 0.02018806f, 0.03574055f, -0.02600005f, -0.01751442f, -0.04220577f, -0.03505715f, 0.00248433f, 
    -0.01746380f, -0.03532394f, -0.01414051f, -0.00734744f, 0.00617322f, -0.02354414f, -0.01236396f, -0.00545270f, 
    0.00020579f, -0.03606757f, 0.00245396f, -0.01888923f, -0.01544174f, -0.00743525f, 0.01046528f, 0.01112196f, 
    -0.02917826f, -0.01650560f, 0.00871937f, 0.00010069f, -0.00200138f, 0.02548594f, -0.02183566f, 0.01358920f, 
    -0.03883966f, 0.02721137f, -0.04053131f, 0.00322933f, -0.03652136f, -0.03860943f, -0.02109403f, -0.03326689f, 
    -0.02473159f, 0.00768318f, -0.02270640f, 0.01060812f, -0.00840552f, 0.00878526f, 0.02219629f, -0.01211819f, 
    -0.00027909f, -0.03341067f, 0.02260536f, -0.02980528f, -0.00427161f, -0.03908232f, -0.02370933f, -0.00348639f, 
    0.01417352f, -0.03794538f, -0.00182180f, 0.00457153f, 0.00354696f, -0.02160333f, 0.00449126f, -0.01499867f, 
    -0.02829190f, -0.01983964f, -0.01860189f, -0.02723701f, 0.02393271f, 0.00795683f, -0.01338489f, 0.03116892f, 
    -0.03866202f, 0.00685630f, -0.02272810f, -0.01657020f, -0.00805836f, -0.02823195f, -0.00114948f, 0.03219441f, 
    -0.01084586f, 0.01868503f, 0.01271377f, 0.01216324f, 0.02094544f, 0.02488320f, -0.00144418f, 0.00181978f, 
    0.02837959f, 0.02182763f, 0.02372623f, -0.00715750f, -0.03519547f, 0.01158262f, 0.02865067f, -0.04288010f, 
    -0.03658115f, 0.00373870f, 0.00411963f, 0.01276125f, -0.00971619f, -0.00143680f, -0.00273066f, 0.00461246f, 
    0.02043674f, -0.01703553f, 0.00711696f, -0.03711702f, -0.02403569f, -0.02623780f, 0.01103727f, -0.00854860f, 
    0.01737947f, -0.03075141f, 0.02029352f, -0.02175486f, 0.00332667f, -0.01823283f, -0.02227287f, -0.02216215f, 
    -0.02995115f, -0.00652132f, -0.00300285f, 0.04183304f, 0.01957462f, -0.00534669f, -0.02169992f, -0.02010810f, 
    0.00461473f, -0.01488046f, 0.03743465f, -0.00683629f, 0.02509360f, -0.02953925f, 0.02541670f, -0.01379744f, 
    0.02242601f, 0.01296230f, -0.00365788f, -0.04378984f, 0.00056023f, 0.02599130f, -0.01600509f, 0.02700922f, 
    0.00788998f, 0.00531389f, -0.03354235f, -0.03380247f, 0.01696436f, -0.01858804f, 0.00259802f, 0.03127263f, 
    -0.00520823f, -0.03349306f, 0.03081976f, 0.01800908f, -0.02324131f, -0.03296769f, -0.01567959f, 0.00122147f, 
    -0.01503076f, -0.03934289f, 0.01529531f, -0.01173129f, 0.00952748f, -0.02846910f, 0.02325703f, -0.03766914f, 
    0.03340495f, 0.03066796f, 0.03068989f, 0.00137059f, -0.00458319f, 0.00839364f, 0.02095359f, 0.03420487f, 
    -0.02322849f, -0.00769889f, -0.00310991f, -0.00934068f, 0.00425835f, -0.00939905f, -0.02874809f, -0.03881169f, 
    -0.03353884f, -0.00743023f, -0.02828941f, -0.01815525f, -0.02684067f, 0.00490389f, 0.02647599f, 0.02023292f, 
    -0.00348781f, 0.01663242f, 0.03450074f, 0.03439226f, 0.00607129f, 0.01913252f, 0.00146155f, 0.00796200f, 
    -0.01553920f, -0.03946372f, -0.01436539f, 0.02877155f, 0.01627978f, -0.00094102f, -0.04109984f, -0.03362252f, 
    -0.00130728f, -0.02321143f, -0.00907466f, -0.00772471f, -0.01746952f, 0.02240445f, -0.01599416f, 0.02834135f, 
    -0.01626796f, -0.00425893f, -0.01566950f, 0.00596036f, -0.02072444f, 0.01412305f, 0.00230502f, -0.00573465f, 
    0.01901088f, -0.03218829f, 0.00838219f, 0.02401334f, 0.02017577f, 0.01426103f, -0.02319130f, 0.01044288f, 
    0.02719793f, -0.02012122f, -0.01610007f, 0.00712569f, 0.01708627f, 0.00863186f, -0.00880191f, -0.01631558f, 
    0.02783367f, 0.02784753f, -0.00284834f, 0.00390287f, 0.01327478f, -0.01839142f, -0.04195189f, 0.02782129f, 
    0.02002490f, -0.03081023f, -0.01511900f, 0.02768271f, -0.03818732f, -0.02844925f, -0.00339627f, 0.01401209f, 
    -0.00363872f, 0.02423342f, -0.01893006f, 0.01889967f, -0.03730414f, 0.00857191f, -0.02359399f, -0.03199403f, 
    -0.04195600f, 0.01906676f, -0.02966620f, -0.02486316f, -0.04235880f, -0.01777057f, 0.00995976f, -0.00113371f, 
    0.01738041f, 0.00280169f, -0.03963457f, -0.00408415f, -0.02341108f, -0.01243786f, -0.03133456f, -0.04153765f, 
    -0.01605687f, 0.02968809f, -0.03294156f, -0.01018445f, -0.01881035f, -0.03127576f, -0.01555359f, -0.01605313f, 
    -0.02509969f, 0.01974127f, -0.03357238f, 0.03035212f, 0.01026220f, -0.01503477f, 0.01270118f, 0.01818284f, 
    -0.02194263f, 0.02705615f, -0.03690805f, -0.01977939f, -0.00301131f, -0.02371064f, -0.02047355f, -0.02080841f, 
    0.01471661f, 0.01715347f, 0.01786591f, -0.02670502f, -0.03860941f, -0.01177941f, -0.00125815f, 0.01400885f, 
    -0.02269375f, -0.03042215f, 0.01875484f, -0.01186563f, -0.00832102f, -0.02372858f, 0.01448774f, 0.01919194f, 
    -0.02240412f, 0.02908804f, -0.04352348f, 0.00260260f, -0.02670172f, -0.01617952f, -0.01071810f, 0.01276274f, 
    -0.01946150f, -0.01555930f, -0.02585150f, 0.02264557f, -0.00550713f, -0.00784645f, -0.01905473f, 0.02691833f, 
    -0.02634580f, -0.01879957f, 0.03381835f, 0.03296535f, -0.03806172f, -0.01615938f, 0.01736134f, 0.02286049f, 
    0.02762345f, -0.00884429f, 0.02261577f, 0.01642180f, -0.02185307f, -0.02873390f, 0.01055167f, 0.01958621f, 
    -0.01444912f, -0.01501134f, -0.03201620f, -0.02286080f, -0.01840331f, -0.01828729f, -0.02239701f, -0.02555368f, 
    0.02581436f, 0.01872828f, 0.03756335f, 0.03503412f, -0.03968658f, 0.00563289f, 0.01508423f, 0.01471412f, 
    -0.03584186f, -0.00189029f, 0.02793355f, -0.02571803f, -0.02685511f, 0.01904463f, 0.00496039f, -0.03726799f, 
    0.01062236f, -0.01028446f, -0.03610684f, 0.00638207f, 0.01257501f, 0.00207075f, 0.01306596f, -0.02041640f, 
    -0.02185926f, -0.01337130f, -0.04376532f, 0.03017998f, 0.02213587f, -0.00732533f, 0.00188758f, -0.01248292f, 
    0.02565321f, 0.01160612f, -0.01834518f, -0.01920889f, -0.03262986f, -0.02484812f, -0.03711854f, 0.02512887f, 
    -0.04265174f, -0.03264043f, 0.02234111f, 0.01680308f, 0.01739751f, 0.02995870f, 0.02131576f, -0.02860489f, 
    -0.00921788f, -0.02488951f, -0.02281278f, 0.01351958f, 0.00775286f, -0.01392184f, 0.01834283f, 0.02454228f, 
    -0.02703996f, 0.02578472f, 0.02376111f, 0.01641023f, -0.02231582f, 0.00876177f, 0.01613522f, -0.00081947f, 
    -0.00348063f, -0.04322584f, -0.03062300f, -0.02480704f, -0.00773085f, 0.00143227f, -0.02386119f, -0.03453909f, 
    -0.03207685f, -0.03186355f, -0.00211119f, -0.01432910f, -0.03791957f, 0.01936682f, -0.02927300f, 0.01872391f, 
    0.03288935f, -0.02352712f, 0.01444180f, -0.00819223f, -0.01910070f, -0.00690013f, -0.04382945f, 0.00479415f, 
    -0.00938195f, 0.02862520f, 0.01620177f, 0.00676010f, -0.04183746f, -0.02010842f, -0.01210054f, 0.01832978f, 
    0.04176600f, -0.04102004f, 0.03431767f, 0.04066548f, 0.00888957f, 0.02837182f, -0.02789818f, 0.02209820f, 
    -0.01044525f, 0.02848040f, 0.00396828f, 0.01905817f, 0.02514467f, -0.03771691f, 0.00272220f, -0.00921281f, 
    0.01814361f, -0.01890243f, 0.00672040f, -0.03121163f, -0.01297166f, -0.01785290f, -0.01215017f, 0.02659937f, 
    -0.00614516f, -0.03534775f, -0.00468748f, 0.03366837f, 0.00725557f, -0.01719332f, -0.00413454f, 0.03731693f, 
    0.00570068f, -0.03606280f, -0.01253252f, 0.00691423f, -0.00816144f, 0.02727878f, 0.03821950f, 0.01211606f, 
    0.01339400f, -0.01477704f, 0.01785255f, 0.00801504f, -0.02998186f, -0.02188480f, 0.02813484f, 0.02095167f, 
    0.02092613f, -0.00429605f, 0.00790949f, -0.01235164f, -0.02156647f, -0.02431505f, 0.02025278f, 0.03099615f, 
    -0.02930715f, -0.01934800f, 0.00388896f, 0.02006650f, -0.01973074f, -0.02036431f, -0.02856881f, 0.00150746f, 
    0.00803270f, 0.01241876f, 0.02419568f, -0.00317829f, 0.00067936f, -0.01717520f, -0.00004213f, 0.01917257f, 
    0.01914576f, -0.00861202f, -0.01222583f, -0.00746394f, -0.02592897f, 0.00079235f, 0.03116693f, -0.02889054f, 
    0.00607164f, -0.03615426f, 0.02107494f, 0.00105871f, -0.00565960f, -0.01623914f, -0.02604609f, 0.00367261f, 
    -0.00677727f, -0.01980627f, -0.02572918f, -0.02106206f, -0.02153233f, -0.03907888f, 0.00519528f, -0.01917159f, 
    -0.02934167f, 0.00009148f, -0.01275972f, 0.02081632f, -0.01374735f, -0.00609681f, -0.03568586f, -0.04478965f, 
    -0.04272547f, -0.02699428f, -0.00663605f, -0.04226260f, -0.01402730f, -0.00397341f, -0.02172160f, -0.02109729f, 
    0.01341486f, -0.01052971f, -0.03469759f, 0.03450742f, 0.01603876f, -0.03582848f, -0.03370072f, 0.01988750f, 
    -0.03304901f, 0.00996318f, -0.01592764f, 0.02606203f, -0.02539744f, -0.03971552f, 0.01297343f, -0.00023658f, 
    0.00683659f, 0.00761008f, 0.02662808f, 0.02280903f, 0.02154745f, -0.03412296f, 0.02231580f, 0.01221286f, 
    0.01785004f, -0.01098451f, -0.02685721f, -0.00343633f, -0.01946179f, -0.01292823f, -0.00660976f, 0.03047423f, 
    0.04187005f, -0.02672087f, -0.00254438f, -0.00708981f, 0.00479792f, -0.03106756f, 0.00737525f, 0.01822312f, 
    -0.00110349f, 0.00023090f, -0.01824882f, -0.01722319f, 0.00423358f, 0.00166491f, 0.00658377f, 0.03025270f, 
    0.02339150f, 0.01714892f, 0.01014737f, -0.00998725f, 0.01394388f, 0.03109500f, -0.02698397f, 0.00392642f, 
    -0.01542573f, 0.02585116f, 0.02271116f, -0.01929417f, -0.01258773f, -0.03459491f, -0.00411016f, -0.00621190f, 
    0.01238845f, 0.00735582f, -0.03259194f, 0.03288810f, 0.02467079f, -0.00065424f, -0.00979238f, -0.02862588f, 
    -0.00200571f, -0.02548505f, 0.00805936f, 0.02586231f, -0.00744965f, -0.03508125f, -0.00720200f, -0.00240235f, 
    0.00445562f, -0.03651129f, 0.00894751f, 0.02016301f, 0.00960270f, -0.03056258f, -0.03059345f, 0.00800016f, 
    0.01895143f, -0.00504859f, 0.00568957f, -0.03163708f, -0.04181583f, -0.02045507f, -0.02569721f, 0.00148219f, 
    0.03145298f, -0.03332566f, -0.00576274f, 0.01072742f, 0.02608141f, -0.03337837f, -0.03905096f, -0.04021032f, 
    0.00446912f, 0.02772161f, -0.02327211f, 0.01130694f, -0.03765028f, 0.02796396f, 0.01958548f, 0.02486873f, 
    0.01792265f, 0.03595624f, -0.00224942f, 0.00822177f, 0.00049000f, 0.00215539f, -0.00629059f, 0.00619682f, 
    -0.03727584f, -0.00306880f, -0.02360089f, -0.01279248f, 0.03110325f, -0.01055220f, -0.02313292f, 0.03187019f, 
    -0.00893087f, 0.02463917f, 0.02909882f, 0.02069458f, -0.00099907f, -0.01402583f, 0.01785733f, -0.00534273f, 
    0.03673585f, -0.02210164f, 0.01987562f, -0.03120851f, -0.00301235f, -0.04220786f, -0.02122131f, 0.02344726f, 
    0.01020116f, 0.01162827f, -0.02672864f, 0.00956989f, -0.02533656f, -0.00793659f, -0.02038078f, 0.02390838f, 
    0.01707292f, -0.03879448f, -0.00109102f, -0.00184381f, 0.00289303f, -0.01416925f, 0.02732662f, -0.00806153f, 
    0.01593126f, 0.03459034f, 0.02894640f, -0.03757816f, 0.02849321f, -0.02482004f, -0.00666066f, -0.02015452f, 
    0.00082767f, 0.01840404f, 0.02137714f, -0.01858289f, 0.01530793f, -0.02840681f, 0.00332846f, 0.00543666f, 
    -0.04251252f, -0.03468181f, -0.00325744f, 0.00385170f, -0.01297341f, 0.02365700f, -0.00426915f, -0.00433030f, 
    -0.04376714f, 0.01829850f, 0.00542502f, -0.01605479f, -0.02393541f, 0.03392564f, 0.01378532f, -0.01068004f, 
    -0.02639476f, -0.01620458f, 0.02467693f, -0.02285112f, 0.03875384f, -0.02027961f, -0.02393031f, 0.03687745f, 
    0.01076365f, 0.02645057f, -0.00801250f, -0.02571140f, -0.00912209f, 0.00281043f, -0.00365682f, 0.01063737f, 
    0.03209068f, 0.01223753f, -0.01375125f, -0.03031470f, -0.00377363f, -0.00819463f, 0.00978704f, 0.00535884f, 
    0.00758431f, -0.00700526f, -0.00806616f, 0.00351483f, 0.00262388f, -0.02104340f, -0.00355540f, 0.00358534f, 
    0.01565989f, 0.00657880f, -0.02054245f, 0.00667025f, -0.02249270f, 0.01146572f, -0.00817186f, -0.02997753f, 
    -0.02351017f, -0.00539891f, -0.00166817f, -0.02071088f, 0.00928399f, 0.02454374f, -0.00414758f, 0.01143634f, 
    -0.00350942f, 0.00002634f, -0.03753703f, -0.01008642f, -0.00973750f, -0.03803873f, -0.01071770f, -0.02389278f, 
    0.00224502f, -0.01686698f, -0.00626226f, 0.01077008f, -0.03492644f, -0.02272687f, 0.00561254f, -0.01406629f, 
    -0.03383258f, 0.02246447f, -0.02445221f, -0.03557920f, -0.00958722f, -0.03863959f, 0.01842003f, -0.01114736f, 
    0.01677790f, -0.00738482f, -0.01530901f, -0.02453620f, 0.01225280f, -0.00412818f, 0.01188401f, -0.02895781f, 
    -0.01199881f, -0.03448328f, 0.01412733f, 0.02964493f, 0.00176370f, 0.00976000f, -0.01631744f, 0.01684043f, 
    -0.02739415f, -0.03492356f, -0.00106723f, -0.01509289f, 0.01891631f, 0.00133718f, 0.00092347f, -0.03611460f, 
    0.02250849f, -0.02348375f, 0.01342455f, -0.02556454f, 0.03007522f, 0.01971046f, 0.02066140f, 0.00231177f, 
    0.02478096f, 0.00539070f, -0.01339074f, -0.02233833f, -0.03563603f, -0.01670064f, 0.00254000f, -0.04302171f, 
    0.00721225f, 0.00541229f, 0.00029474f, -0.03312488f, 0.02987367f, 0.00938434f, -0.02500746f, 0.01668406f, 
    -0.02977366f, -0.02796837f, -0.03138813f, 0.01467384f, -0.02638549f, -0.02997798f, -0.01885740f, 0.00325783f, 
    -0.00251697f, -0.02906701f, -0.01550585f, 0.01476762f, 0.01940060f, -0.01826439f, -0.01165406f, -0.02797657f, 
    0.02977147f, 0.00513089f, -0.00719587f, 0.02347405f, -0.00972335f, 0.01088038f, -0.03380337f, 0.02813958f, 
    -0.00474307f, 0.01533559f, -0.02272230f, -0.03461506f, -0.01011944f, -0.01619291f, 0.03054331f, -0.01118391f, 
    0.00218930f, 0.02158736f, -0.03822521f, -0.00918995f, -0.02995777f, 0.00898741f, 0.02353491f, -0.01239373f, 
    0.01402187f, -0.02782798f, 0.02515003f, -0.03295021f, -0.00545191f, -0.03697006f, -0.02901857f, -0.03592663f, 
    0.02626716f, -0.01595601f, -0.01485838f, -0.01467516f, -0.02109367f, 0.02782517f, -0.03394136f, -0.03152115f, 
    -0.03416850f, -0.02303257f, 0.02823019f, 0.00270931f, 0.01494626f, -0.02542098f, 0.02106529f, -0.00919566f, 
    -0.02623528f, -0.00299046f, -0.00611729f, 0.02785378f, -0.00919871f, 0.03290964f, 0.01685292f, -0.03215099f, 
    0.02247567f, 0.01092756f, -0.01032886f, -0.03736036f, -0.01414219f, 0.01529191f, 0.02232020f, -0.00057583f, 
    -0.03267694f, -0.01150036f, 0.02966531f, 0.00322686f, 0.00830657f, -0.01544224f, 0.03123066f, -0.01466084f, 
    0.02850540f, 0.01704692f, 0.00394753f, -0.03329499f, 0.00701787f, 0.03067953f, 0.00545975f, -0.02594705f, 
    0.00970421f, 0.02757022f, 0.00983295f, 0.02973281f, -0.03680101f, -0.01242487f, 0.02188487f, -0.03451563f, 
    0.02399297f, -0.00238791f, -0.00475645f, 0.03077514f, 0.00315204f, 0.01585784f, -0.01721307f, -0.02835364f, 
    -0.02550262f, -0.03471531f, 0.01336120f, -0.03654452f, -0.01326559f, -0.01929899f, 0.01660228f, 0.02053541f, 
    -0.01265184f, -0.03896451f, 0.02555472f, -0.01706726f, -0.00575343f, 0.03295127f, -0.02084303f, 0.02678966f, 
    0.02740072f, -0.03062059f, -0.00310668f, 0.01846757f, -0.01878648f, -0.01515542f, 0.00142817f, -0.03429394f, 
    0.03916717f, -0.00702304f, 0.02907787f, -0.02259053f, 0.02696077f, -0.01485356f, 0.01414553f, -0.01314704f, 
    -0.00667537f, -0.03481010f, 0.00975146f, -0.00828640f, -0.03196571f, -0.00039337f, 0.01782096f, 0.03035643f, 
    -0.00214176f, 0.00709822f, -0.03334963f, 0.03062788f, 0.01590719f, 0.02400635f, -0.01338289f, 0.02730609f, 
    -0.03881731f, -0.01896427f, -0.03611341f, 0.02613495f, 0.01502544f, -0.00084242f, -0.02215287f, 0.03579570f, 
    0.01341161f, -0.01728882f, -0.02965092f, 0.01687767f, -0.01721621f, -0.00875723f, 0.01828515f, 0.00579996f, 
    -0.00848025f, 0.01241396f, -0.00411640f, 0.01695186f, -0.03472282f, -0.03013421f, -0.00286963f, 0.01890029f, 
    -0.00178216f, 0.02240444f, -0.02338602f, -0.02091546f, -0.00894037f, 0.02911314f, -0.02960498f, -0.03175148f, 
    0.00871557f, -0.03422598f, -0.02127661f, 0.01511836f, -0.00548735f, -0.02947081f, 0.02421542f, -0.02160418f, 
    0.03293807f, -0.02436853f, -0.03760530f, -0.03479413f, 0.02703577f, -0.02045395f, -0.02717116f, -0.01900465f, 
    -0.02327567f, 0.02063230f, 0.01869276f, 0.02675795f, -0.02222189f, 0.00612898f, -0.01957744f, 0.03512922f, 
    0.00287055f, -0.01667508f, 0.01179037f, 0.01056858f, 0.02003707f, 0.01637858f, 0.00601806f, 0.00475405f, 
    0.00956835f, 0.00326473f, -0.03450959f, -0.00306535f, 0.02018440f, 0.00039317f, -0.00114725f, -0.01358352f, 
    -0.03973602f, 0.02337866f, 0.02809199f, 0.01412806f, -0.02629196f, 0.00898428f, -0.02906272f, 0.00770139f, 
    -0.01618608f, -0.03216952f, -0.03511003f, 0.03353218f, 0.00190647f, -0.02394199f, 0.00461601f, 0.00267365f, 
    0.01874475f, 0.00212845f, 0.01694089f, -0.01848351f, 0.00727035f, -0.03555068f, -0.00522743f, 0.00842688f, 
    -0.02864989f, 0.02863514f, 0.02712297f, -0.01788031f, 0.02995813f, -0.02195873f, -0.03151634f, 0.01124491f, 
    -0.03771107f, 0.02061281f, -0.01639001f, 0.00459107f, -0.01243476f, 0.01703532f, 0.02953880f, 0.00875020f, 
    0.00894100f, 0.01369501f, 0.00188637f, -0.00455109f, -0.02836305f, -0.02344473f, -0.03838009f, -0.01689082f, 
    -0.03402718f, 0.02883051f, 0.02730596f, -0.00162687f, 0.03094555f, -0.00974589f, 0.00422312f, -0.03484760f, 
    0.02143151f, -0.03555082f, -0.03755705f, -0.02200422f, -0.03512921f, -0.02718112f, 0.01687808f, 0.01678400f, 
    -0.02665529f, 0.00644012f, -0.01723125f, 0.00093692f, -0.01751600f, -0.02816635f, 0.03029376f, -0.02237475f, 
    0.00307385f, 0.03211991f, -0.03294989f, -0.03875414f, -0.03993165f, 0.02381603f, 0.02143727f, -0.01359789f, 
    -0.00373827f, -0.01650369f, -0.03571614f, -0.03779792f, -0.01367944f, 0.02257196f, -0.03050343f, 0.00265507f, 
    0.01640669f, 0.01090620f, -0.00267776f, -0.02073526f, -0.00761953f, -0.00224754f, -0.03029797f, -0.03039998f, 
    -0.03120098f, -0.02781035f, -0.02768925f, 0.00888113f, -0.00936723f, -0.01146726f, -0.00044093f, 0.01508299f, 
    -0.03309528f, 0.02248088f, 0.01933527f, 0.00266065f, -0.01228775f, -0.02531666f, -0.00822333f, -0.03036041f, 
    -0.02593585f, -0.01222359f, -0.00059775f, -0.00556676f, 0.00405228f, 0.00929305f, 0.00246601f, -0.01721451f, 
    -0.02050676f, 0.00790017f, 0.03801908f, 0.02379276f, -0.02105809f, 0.03067679f, 0.02581022f, -0.01622946f, 
    -0.00521423f, -0.03549317f, 0.00753509f, -0.03175601f, 0.00668735f, -0.03394164f, -0.01312413f, 0.01043184f, 
    0.03120467f, 0.00858200f, 0.01156972f, -0.03689199f, -0.01403694f, -0.02315210f, -0.02343069f, 0.01900302f, 
    -0.01852495f, -0.02798292f, -0.01216047f, 0.02405829f, -0.01295887f, -0.02050172f, -0.00040864f, -0.00365246f, 
    -0.02874693f, -0.02541528f, -0.00378306f, -0.04113530f, 0.01840002f, 0.00808462f, -0.03782158f, 0.02228330f, 
    -0.02144895f, 0.03862170f, -0.02922359f, 0.02384788f, 0.01949503f, 0.00699686f, -0.02427677f, 0.02029742f, 
    -0.00219540f, 0.01971154f, -0.00402195f, 0.01502906f, 0.03433741f, 0.00299156f, 0.02444616f, 0.00936955f, 
    -0.00277673f, -0.09843156f, 0.10918754f, -0.13453493f, 0.12246433f, -0.11580466f, 0.01668470f, 0.08862185f, 
    0.09939210f, 0.01481338f, -0.02191244f, 0.07769219f, 0.05688469f, -0.02396323f, 0.00762161f, -0.06631984f, 
    0.06480893f, 0.14758924f, 0.19199009f, -0.00584723f, 0.04999768f, 0.05010002f, -0.02813373f, 0.02594232f, 
    0.22391026f, -0.09759668f, -0.01942161f, -0.10108907f, -0.07657703f, -0.07400411f, -0.02656714f, -0.04421328f, 
    0.01385279f, -0.10908528f, 0.12216357f, -0.00726021f, -0.21302402f, -0.09445654f, 0.23078291f, 0.10984464f, 
    0.04491300f, -0.04574598f, 0.12233803f, 0.03844904f, 0.01078286f, 0.02441108f, 0.01965468f, -0.00370620f, 
    -0.21591730f, 0.00455196f, 0.41344166f, -0.05138416f, 0.00199233f, 0.01882834f, 0.25600857f, 0.04511947f, 
    -0.02615759f, -0.05904667f, 0.01138594f, 0.03706634f, 0.24088158f, 0.43569779f, -0.13393895f, -0.20844214f, 
    -0.02907123f, 0.00706571f, 0.12153814f, 0.03434093f, 0.21171249f, 0.01755245f, 0.13231082f, -0.06632189f, 
    -0.18666205f, -0.00242271f, -0.00685704f, 0.52254838f, 0.04225156f, 0.02690473f, 0.26134735f, -0.09828952f, 
    -0.00230297f, -0.08035146f, 0.03291043f, -0.01000969f, 0.11947943f, 0.04532209f, 0.00202909f, -0.04756556f, 
    0.03784055f, 0.00966260f, -0.04527413f, -0.07940155f, 0.02805113f, 0.07940894f, 0.20588663f, 0.04937972f, 
    -0.06305397f, -0.06319062f, -0.19666879f, 0.22437781f, 0.13465472f, -0.13161173f, 0.22756343f, 0.19753994f, 
    0.01741585f, 0.11367460f, -0.04555278f, 0.33766726f, -0.29407173f, 0.01020484f, 0.08340924f, -0.02829660f, 
    -0.11835665f, -0.10000387f, -0.03058366f, -0.00253158f, 0.04196465f, -0.03047369f, 0.09364820f, -0.15375556f, 
    0.15791453f, -0.10459269f, -0.06819628f, -0.12110052f, 0.07209520f, 0.01593966f, -0.00713394f, 0.01575648f, 
    0.13133207f, 0.00656777f, 0.01050107f, 0.08103117f, -0.06277709f, -0.31861979f, 0.13256316f, 0.08608885f, 
    -0.07996787f, -0.08212472f, 0.18082094f, 0.23121330f, 0.02874573f, 0.14785001f, 0.03778704f, 0.04200726f, 
    -0.06421725f, -0.07379821f, -0.00138216f, -0.03574107f, -0.03255983f, 0.10092972f, 0.14487444f, 0.03433400f, 
    0.06991394f, 0.01214148f, 0.02029609f, -0.02605768f, -0.25047353f, 0.01551662f, 0.05923028f, -0.04155890f, 
    0.05396920f, -0.13637333f, 0.19506821f, 0.14893797f, 0.09439571f, 0.03164735f, 0.03705360f, -0.03177196f, 
    0.05696532f, 0.22059149f, -0.02149209f, 0.05681287f, 0.06342822f, 0.09624568f, 0.01505039f, -0.03833635f, 
    0.08675319f, 0.05774355f, -0.05512350f, -0.04535479f, -0.29862612f, -0.07890669f, 0.20911826f, 0.10391609f, 
    0.14224643f, 0.03123291f, 0.07849935f, -0.05551867f, 0.02032827f, -0.06686074f, 0.00328980f, -0.00442905f, 
    -0.08069073f, 0.13892470f, 0.10661039f, -0.12315530f, -0.00346268f, 0.03155880f, 0.03659140f, 0.08869039f, 
    0.13488999f, -0.06059373f, 0.20194837f, 0.12950282f, 0.14015460f, 0.08793864f, -0.08476262f, -0.07139247f, 
    0.02880694f, 0.03038776f, -0.04673126f, -0.03585722f, -0.07347819f, -0.01501486f, 0.07819352f, 0.23426472f, 
    0.08984856f, 0.11222357f, 0.01815544f, -0.08270442f, -0.09258190f, -0.05326270f, -0.00050346f, -0.03482803f, 
    0.05570297f, 0.00583476f, -0.02102023f, 0.03183636f, -0.16135973f, -0.03977081f, -0.11468302f, 0.28068739f, 
    0.07476638f, 0.05727755f, 0.14749496f, -0.07891179f, -0.03704002f, 0.00836096f, 0.07833156f, -0.05804626f, 
    0.22482547f, -0.09681906f, -0.17074895f, -0.00619925f, -0.02310111f, -0.13703108f, -0.05110939f, -0.05713281f, 
    0.02821588f, -0.06767387f, 0.13410838f, -0.15818922f, 0.17416950f, -0.20977575f, -0.02088359f, 0.01885104f, 
    -0.02796138f, 0.00144108f, 0.02820622f, 0.28136271f, -0.04173499f, -0.01827590f, 0.07709868f, 0.15216072f, 
    -0.17137438f, -0.14498082f, 0.04719865f, 0.33967260f, -0.11654942f, -0.00616151f, 0.19807117f, 0.09496393f, 
    0.02347964f, -0.00663497f, -0.03293189f, -0.04294922f, 0.32641798f, -0.11406692f, -0.19185665f, 0.35811526f, 
    0.08500472f, 0.15495236f, 0.08582418f, -0.10107603f, -0.00471119f, 0.00515819f, 0.02051813f, 0.13072531f, 
    0.06685398f, 0.02095362f, 0.03554764f, -0.11047531f, 0.00140274f, 0.02061341f, 0.03719933f, -0.06146212f, 
    0.13174094f, -0.04494242f, -0.01194433f, 0.08799087f, 0.05972679f, -0.00668806f, 0.04999655f, -0.06495630f, 
    0.01849991f, 0.01044492f, -0.00161352f, -0.10776853f, 0.14624359f, -0.07700552f, 0.02582016f, 0.13625313f, 
    -0.16273001f, 0.09574801f, -0.03233519f, -0.05044271f, 0.04581895f, -0.00886422f, 0.13468222f, 0.23702624f, 
    -0.00188891f, -0.05446148f, -0.03498587f, 0.06708234f, -0.31596583f, 0.09280575f, 0.31062484f, -0.13610782f, 
    -0.22604313f, -0.03851881f, 0.18005966f, 0.12279548f, 0.04657847f, -0.01873400f, 0.11558443f, -0.06146198f, 
    0.46047878f, -0.06601514f, -0.02656967f, -0.00218793f, -0.11633746f, 0.11883953f, 0.05022718f, -0.03787732f, 
    -0.13792278f, -0.00581896f, 0.02802576f, 0.08298710f, -0.15479881f, -0.14084186f, 0.12075949f, 0.07298956f, 
    -0.03862612f, 0.06777430f, 0.23164056f, 0.02446051f, -0.02124343f, 0.00622612f, -0.11396446f, 0.10479111f, 
    0.11188085f, -0.09802003f, 0.07894600f, 0.12564501f, -0.03687304f, -0.02283858f, 0.03934320f, 0.01080043f, 
    0.12430081f, 0.06197736f, 0.06663515f, 0.01991957f, 0.08239568f, 0.04018842f, 0.00744490f, 0.15077505f, 
    -0.10840937f, 0.06067278f, -0.02971307f, -0.02502035f, 0.16188005f, -0.02070883f, 0.05588975f, -0.17861778f, 
    0.46118361f, -0.17234722f, -0.29342407f, 0.25992230f, 0.03783973f, 0.11979838f, 0.00152868f, -0.06766527f, 
    -0.08695865f, 0.15026832f, 0.08267251f, -0.11785914f, -0.23436898f, -0.18395190f, 0.25331435f, -0.00930147f, 
    -0.16806951f, -0.07948588f, 0.10305432f, 0.23699705f, -0.03849584f, 0.04400330f, 0.02084833f, -0.08562653f, 
    0.02416827f, 0.00752435f, 0.00071014f, -0.09093224f, -0.04243385f, 0.02940046f, -0.04817591f, -0.02730300f, 
    0.15621804f, -0.01753036f, 0.08311864f, 0.00231355f, -0.04786292f, -0.12759885f, 0.04234063f, 0.08669043f, 
    0.01953177f, 0.03979633f, 0.06612904f, 0.10375853f, 0.13865069f, -0.10658136f, 0.12640557f, 0.05602641f, 
    0.09439160f, 0.06460498f, -0.01364306f, -0.07165082f, 0.00108422f, 0.01213900f, -0.06963292f, -0.03113173f, 
    0.10888259f, 0.03146074f, 0.10204413f, -0.01279668f, 0.04529164f, 0.04802728f, 0.03970604f, -0.04303294f, 
    0.05735365f, 0.04481986f, -0.00016277f, -0.04320515f, 0.02924755f, 0.00777224f, 0.09987380f, -0.04562869f, 
    -0.01827016f, 0.10861985f, 0.29283753f, 0.02037747f, 0.22936748f, 0.08012120f, 0.15852258f, -0.00893945f, 
    0.13353109f, 0.00590519f, 0.08467590f, 0.13638940f, -0.24561822f, -0.02988235f, 0.29998457f, 0.10880771f, 
    -0.00296726f, -0.08802538f, 0.04698413f, 0.00105425f, 0.04490286f, -0.04878584f, -0.05876946f, -0.15730187f, 
    -0.15085469f, 0.02336461f, 0.08511662f, -0.08921554f, -0.01209294f, -0.04661915f, 0.04543468f, 0.15637611f, 
    0.04798144f, -0.09801514f, 0.01211395f, 0.07162262f, -0.20648678f, -0.10685822f, -0.08171625f, -0.05344797f, 
    0.00308720f, 0.06728162f, 0.23027478f, 0.08968763f, 0.06556921f, -0.05651104f, 0.01159170f, 0.02534756f, 
    0.19065130f, -0.40591106f, -0.08117589f, -0.19400524f, 0.15767664f, -0.06834081f, -0.12517726f, -0.13576999f, 
    0.01558559f, 0.04527262f, 0.02143347f, -0.03668624f, 0.00754634f, 0.08935172f, -0.20796679f, 0.42211211f, 
    0.05212506f, -0.11918323f, 0.11158101f, 0.09279814f, -0.02036909f, 0.07044253f, 0.31005627f, 0.13329059f, 
    -0.21871909f, -0.18294783f, 0.48673910f, 0.11288298f, 0.05554260f, -0.01269107f, 0.05285333f, 0.06011583f, 
    -0.05257450f, -0.01871359f, 0.01392133f, -0.01381112f, 0.51008260f, -0.02849402f, -0.24869350f, -0.04855226f, 
    0.06202353f, -0.00747254f, -0.04114122f, -0.05480878f, 0.05990949f, 0.06858353f, -0.03500867f, 0.12064736f, 
    0.05425914f, 0.15142372f, 0.09176619f, -0.17219506f, 0.10655239f, 0.02109046f, 0.03697147f, 0.01312703f, 
    0.13296731f, 0.18150055f, -0.05902343f, -0.05356539f, -0.11286315f, -0.11143419f, 0.24730626f, 0.32250047f, 
    0.08536956f, -0.01929302f, 0.07273524f, 0.13369527f, 0.00146696f, -0.00610834f, 0.01473109f, 0.05456088f, 
    -0.04594129f, -0.34108138f, -0.12980101f, 0.10495349f, 0.11863250f, -0.11304683f, 0.05371633f, -0.01690576f, 
    -0.04386214f, -0.02606362f, -0.07004065f, 0.23472621f, 0.37527770f, -0.41794637f, -0.21546051f, 0.15724029f, 
    -0.03688470f, 0.17151889f, -0.06335643f, -0.01354977f, 0.02153416f, 0.12953824f, 0.03700581f, -0.02170429f, 
    0.27685526f, 0.12807204f, -0.05928798f, 0.04497652f, 0.00431393f, -0.03101987f, -0.01020310f, -0.07065319f, 
    -0.00296928f, 0.10459092f, 0.19322057f, 0.10708168f, 0.26566780f, 0.16712382f, -0.13873570f, -0.13788792f, 
    -0.03378130f, -0.01704312f, -0.03204869f, -0.00411577f, 0.04852179f, 0.00125779f, 0.01854087f, -0.01046859f, 
    0.09641288f, 0.20656866f, 0.25083116f, -0.21330288f, 0.04249161f, -0.03987110f, -0.08072802f, -0.03836729f, 
    0.07804057f, 0.10037837f, 0.01742318f, -0.07494979f, 0.03431903f, 0.08976224f, -0.13110143f, 0.05157498f, 
    0.13524640f, 0.09095486f, -0.08130236f, -0.03045316f, 0.06840952f, 0.09664317f, -0.13996588f, 0.02901288f, 
    -0.17369141f, -0.02262960f, 0.37707791f, 0.18001081f, -0.08970219f, -0.02436263f, 0.03113004f, 0.01298589f, 
    -0.02518598f, -0.02677896f, -0.04132751f, -0.06635444f, 0.01483443f, 0.16212851f, -0.19759931f, 0.12881887f, 
    -0.15155859f, 0.02000839f, 0.13307707f, 0.16531426f, 0.06749158f, 0.14704448f, -0.02085545f, 0.04681293f, 
    0.18094730f, -0.14001878f, 0.04667297f, -0.25966537f, 0.10343663f, -0.08116728f, -0.05712593f, 0.03820254f, 
    0.09370961f, -0.01842891f, -0.03628131f, 0.02155142f, -0.00724378f, -0.17724556f, 0.01197492f, 0.07193360f, 
    0.10526047f, -0.04452698f, 0.11279266f, 0.12526247f, 0.10168095f, 0.06793248f, 0.01679106f, 0.04562105f, 
    0.13380995f, 0.18339866f, 0.07227266f, -0.03870994f, -0.01513410f, -0.13986486f, -0.00109468f, -0.03346975f, 
    0.12045012f, -0.01736890f, -0.05787550f, 0.01461603f, -0.21986684f, -0.28008550f, 0.30274352f, 0.22644907f, 
    0.07116950f, -0.09232586f, 0.00745735f, 0.04824577f, -0.18975177f, 0.00056387f, 0.15594098f, 0.10656541f, 
    -0.02969747f, 0.17795804f, 0.02997592f, -0.04163061f, 0.04128982f, -0.03849832f, -0.06224525f, 0.01200774f, 
    0.03129929f, 0.01048752f, -0.05319674f, -0.05019611f, 0.05370730f, 0.17728613f, 0.01048368f, 0.02149865f, 
    0.07497399f, 0.02256972f, 0.00998845f, -0.04511897f, 0.14118063f, -0.11111499f, 0.08223362f, -0.07012524f, 
    0.61989290f, -0.26395547f, -0.41062719f, 0.08399421f, 0.10175524f, -0.04483360f, -0.03678275f, -0.06227909f, 
    0.06088442f, 0.03638850f, -0.02145199f, -0.09714429f, 0.57364178f, -0.36428788f, -0.18183084f, 0.12353224f, 
    0.04491413f, -0.01562389f, -0.11084143f, 0.07436387f, 0.03885840f, 0.19016814f, 0.14474481f, 0.08200349f, 
    -0.12139506f, -0.18084618f, 0.05500807f, -0.21932769f, -0.06785628f, -0.09928785f, 0.06184540f, 0.08206544f, 
    -0.03039827f, 0.04061563f, -0.00099694f, 0.04522220f, -0.00313314f, -0.05330349f, 0.05518744f, -0.10432277f, 
    -0.15209293f, 0.07769518f, 0.00278846f, -0.06404788f, 0.07246090f, 0.12821043f, -0.00719262f, 0.14953651f, 
    -0.17516232f, -0.08184990f, 0.00762311f, 0.07474706f, -0.02567359f, 0.03941090f, 0.03137391f, 0.01079846f, 
    0.05962118f, 0.02312602f, -0.04472548f, -0.00709841f, -0.09480441f, -0.07779666f, 0.17314795f, 0.23287359f, 
    0.08960583f, 0.06276141f, 0.10083998f, 0.02824767f, 0.01629430f, 0.10982069f, -0.00996879f, 0.07566189f, 
    -0.00460641f, 0.22517860f, 0.18154407f, -0.07130083f, 0.01080176f, -0.24097174f, 0.14467485f, -0.07519367f, 
    0.11688495f, 0.10869116f, 0.03857087f, -0.13027599f, -0.15122750f, 0.14600262f, -0.06760283f, -0.01934320f, 
    0.01675227f, -0.04096712f, 0.02951743f, 0.04739694f, -0.04675337f, -0.11934623f, -0.02142945f, -0.07417772f, 
    -0.35897061f, -0.18581846f, -0.13421309f, -0.21039163f, 0.06367636f, -0.10208248f, 0.02383267f, -0.22051804f, 
    0.05062648f, -0.07718867f, 0.05319752f, 0.07770015f, -0.02637330f, -0.14884244f, -0.06980461f, -0.11123681f, 
    0.08394940f, 0.00082325f, 0.02148402f, 0.03062679f, -0.11055280f, 0.04075341f, 0.16839698f, 0.16184770f, 
    -0.01534746f, 0.08867630f, 0.07208582f, 0.23870584f, -0.02171377f, 0.12385176f, 0.05722479f, 0.00865588f, 
    0.07340878f, -0.02162892f, 0.02381266f, 0.03837268f, -0.24266276f, 0.04917198f, 0.23825069f, -0.04817349f, 
    -0.04432674f, 0.02574061f, 0.15921421f, 0.25851852f, 0.09249099f, 0.07842328f, 0.01007019f, -0.16340655f, 
    0.09029330f, 0.08219533f, -0.05456644f, -0.09641748f, 0.05011409f, 0.03097698f, 0.03566806f, 0.04559985f, 
    0.07307434f, 0.10093141f, 0.10993794f, 0.19512443f, 0.20975116f, -0.16673853f, 0.04306283f, -0.02860814f, 
    -0.05927656f, -0.01753710f, 0.02988019f, 0.10841578f, 0.17091182f, 0.06649902f, -0.05798130f, -0.02071350f, 
    -0.07569437f, -0.09760545f, 0.02134165f, -0.01753568f, -0.04774531f, 0.09143186f, 0.09980250f, 0.24464944f, 
    0.05679559f, 0.04254865f, 0.11084255f, 0.05227375f, -0.21765026f, 0.10324113f, 0.25232559f, -0.19980565f, 
    0.01161610f, 0.05808127f, 0.13396905f, 0.07073756f, -0.06770782f, 0.06396345f, -0.00221450f, 0.01085704f, 
    -0.21549655f, 0.00062705f, 0.07647131f, -0.07197183f, 0.01070816f, 0.00257933f, 0.00032237f, -0.01265728f, 
    0.03555752f, 0.05731984f, 0.12926696f, 0.05365765f, -0.06422550f, 0.08505563f, -0.32686433f, 0.07414636f, 
    0.07125174f, 0.06836423f, -0.07039709f, -0.24421035f, 0.18871239f, 0.05617897f, 0.03923161f, -0.05445447f, 
    -0.34125578f, 0.25146151f, 0.12081750f, 0.01081850f, 0.04388107f, 0.06029906f, 0.05205144f, -0.01805499f, 
    0.07810336f, 0.00043603f, -0.12164431f, 0.02444448f, -0.13437144f, -0.06002996f, 0.07278859f, -0.03313977f, 
    0.02544999f, -0.00008894f, 0.05770824f, 0.00593323f, 0.18042891f, 0.13114801f, 0.18462656f, 0.10446552f, 
    -0.14065385f, 0.01507827f, -0.03732083f, 0.01342890f, -0.05809613f, -0.01126190f, 0.04781406f, 0.06456269f, 
    -0.09975784f, -0.10111573f, -0.06150961f, 0.03504922f, 0.06566114f, 0.08117107f, -0.23212676f, -0.09801950f, 
    0.10005834f, -0.05462837f, 0.06108044f, 0.11360483f, 0.17317912f, 0.11612034f, 0.11640272f, 0.16967483f, 
    0.04304777f, -0.04323791f, -0.12152849f, 0.06287233f, -0.02760428f, -0.00068238f, -0.01476252f, 0.03929608f, 
    0.01947478f, -0.09813912f, 0.18966617f, -0.32406673f, -0.26163182f, -0.02802892f, 0.04862352f, 0.17601448f, 
    0.00929806f, 0.09439628f, 0.04825917f, 0.04531397f, 0.14615072f, 0.05671111f, 0.01523456f, 0.12122516f, 
    -0.13752972f, -0.16627602f, -0.22592615f, 0.11234889f, 0.03334614f, 0.08920647f, 0.08240002f, 0.14216289f, 
    -0.03187331f, -0.04814065f, 0.01423282f, -0.00304558f, 0.15754524f, 0.26629919f, -0.09342753f, 0.20364654f, 
    0.03576100f, 0.14631321f, -0.04654862f, -0.04761558f, -0.05014140f, 0.05452783f, -0.09520857f, 0.04570803f, 
    -0.21723473f, -0.04860372f, -0.04497079f, -0.09228531f, -0.01381050f, 0.05069437f, 0.02053757f, 0.03679249f, 
    0.04641927f, 0.09253266f, 0.10821127f, 0.17594853f, -0.03643670f, -0.04399208f, -0.04236108f, 0.01900535f, 
    -0.03370344f, -0.00548923f, 0.03940428f, 0.01051737f, 0.03370136f, 0.02767129f, -0.06373912f, -0.05841500f, 
    -0.15202980f, -0.23863922f, 0.25680819f, -0.16413108f, 0.15331407f, -0.02945843f, -0.11431127f, 0.13343996f, 
    -0.12307239f, -0.17111158f, -0.12577561f, -0.02841682f, -0.08783959f, 0.16848850f, 0.03639078f, -0.00359822f, 
    -0.06969661f, 0.03440542f, 0.07778984f, 0.08451690f, 0.01535924f, 0.00704827f, -0.02823807f, -0.15923719f, 
    -0.02078167f, -0.18571389f, -0.01912232f, -0.01440000f, 0.05843273f, 0.06563192f, -0.06130436f, 0.02891008f, 
    -0.16903061f, -0.07607360f, 0.11740789f, -0.00343988f, -0.01147548f, 0.11530726f, 0.09442647f, 0.20400491f, 
    -0.06012754f, -0.11820222f, 0.08474872f, 0.06216616f, 0.07426082f, 0.05945979f, 0.03818823f, 0.09594866f, 
    0.01838604f, 0.16303833f, 0.02671209f, 0.05689435f, 0.02989516f, 0.06525928f, 0.08707825f, 0.07883088f, 
    0.08638069f, 0.00557090f, 0.04669828f, -0.10891028f, 0.02296079f, 0.17675275f, -0.13056131f, 0.06587726f, 
    0.08441057f, 0.13648325f, 0.01697784f, 0.00882958f, 0.03542287f, -0.04768921f, -0.03541551f, -0.07069120f, 
    0.36865783f, 0.15165934f, -0.34070528f, 0.26965287f, 0.10434569f, 0.05994894f, 0.01594323f, -0.01515244f, 
    -0.04257022f, 0.11226248f, 0.13909571f, 0.09303400f, 0.00523785f, -0.04218877f, 0.27566800f, -0.03747079f, 
    0.11155384f, 0.01615100f, 0.04726879f, -0.06628393f, 0.08801091f, -0.02046976f, -0.02458095f, -0.22981055f, 
    -0.11312740f, -0.00895503f, 0.01085689f, -0.02261977f, -0.02446022f, -0.00497480f, 0.02266698f, -0.03974978f, 
    0.10308152f, 0.20771977f, 0.14735252f, 0.14301178f, 0.03652348f, 0.15940467f, -0.04434868f, 0.09220875f, 
    0.02372846f, 0.28875375f, -0.02297011f, -0.00113023f, 0.17397943f, -0.00038490f, -0.19009253f, 0.22116309f, 
    0.04882997f, -0.08328413f, -0.09355900f, 0.02794943f, 0.06390726f, -0.00921927f, -0.01919077f, -0.00288967f, 
    -0.03785125f, -0.13339569f, -0.07213307f, -0.03271777f, -0.20052464f, -0.00899915f, -0.05483339f, -0.05516798f, 
    0.06986936f, 0.01590848f, 0.08030701f, -0.03674448f, -0.02780692f, 0.05147279f, 0.06908181f, 0.06906225f, 
    -0.29299569f, 0.32612199f, 0.07079176f, 0.00714447f, 0.15497768f, -0.06865828f, 0.00653144f, 0.17228864f, 
    -0.04624892f, 0.04941836f, 0.04763646f, 0.07315121f, -0.04792634f, -0.01883486f, -0.01758214f, -0.08705084f, 
    0.03455407f, 0.02641103f, 0.04345410f, 0.08590513f, -0.01653463f, 0.01604165f, -0.02170555f, -0.09132843f, 
    0.02200978f, 0.06752405f, 0.05559644f, 0.12367215f, 0.01036836f, 0.02381065f, 0.11453000f, -0.07440503f, 
    0.13565563f, 0.02362029f, -0.08755280f, 0.07360480f, -0.01455273f, -0.00882057f, -0.07608914f, 0.04987766f, 
    0.04544683f, 0.07235758f, 0.05487677f, 0.07249525f, 0.11407488f, -0.00906348f, 0.00272628f, -0.11547502f, 
    -0.17911850f, -0.04091255f, 0.00271517f, -0.09135821f, 0.19724734f, 0.09120630f, 0.03469563f, -0.04120066f, 
    -0.00156576f, -0.07399546f, -0.00313155f, -0.10173041f, 0.15141140f, -0.10757785f, -0.28185964f, 0.03226089f, 
    0.07441673f, -0.03188391f, -0.04145762f, 0.04494156f, 0.07943018f, 0.15043275f, 0.00464801f, 0.21566817f, 
    0.01206073f, 0.04726999f, 0.08837713f, -0.07807630f, -0.08167677f, 0.01296392f, -0.02081543f, -0.01280011f, 
    0.01928883f, 0.03128802f, 0.04235870f, 0.01674050f, 0.05190213f, -0.14828342f, -0.12957086f, 0.04478746f, 
    -0.00335141f, 0.04809278f, -0.00563924f, 0.00210788f, 0.18628348f, 0.08680113f, 0.04972928f, 0.15082532f, 
    -0.20509568f, -0.05925420f, -0.17272566f, -0.00146458f, 0.10776202f, -0.12194242f, 0.02881265f, -0.00387924f, 
    0.07156423f, -0.00401297f, 0.13253859f, 0.01914291f, 0.08058283f, 0.00931036f, -0.09345272f, -0.15805529f, 
    -0.01108812f, 0.02172771f, -0.08125242f, -0.09381716f, 0.05258380f, 0.08221339f, 0.01304998f, 0.04446342f, 
    0.23523663f, -0.06019886f, 0.05661346f, -0.08272452f, 0.03791962f, -0.14311175f, 0.08347934f, 0.07292764f, 
    -0.07417218f, -0.03250260f, -0.10203722f, -0.20325720f, 0.27863091f, -0.03118796f, -0.05786534f, 0.05659796f, 
    0.06215453f, 0.07942406f, -0.05100754f, 0.07210885f, 0.02854498f, 0.29513118f, -0.01030911f, 0.09408706f, 
    -0.17977670f, 0.00012006f, -0.08330764f, -0.07180520f, -0.06749427f, 0.03433641f, -0.00648201f, -0.11644392f, 
    -0.29171136f, -0.13243991f, -0.10862488f, -0.09801347f, -0.27455291f, 0.06524852f, 0.09039763f, -0.06890634f, 
    0.06966766f, 0.02302554f, 0.08437874f, 0.06230690f, -0.00922863f, -0.09695032f, -0.00604005f, -0.00833828f, 
    -0.13303718f, 0.07243145f, 0.12094326f, 0.00507377f, -0.01264652f, -0.03782278f, -0.03328615f, 0.06695903f, 
    -0.01454340f, -0.05230455f, 0.04827154f, -0.07290137f, 0.03800450f, 0.04837725f, -0.07231890f, -0.04832687f, 
    -0.00231427f, -0.12255572f, -0.06564770f, 0.08136097f, 0.21382855f, 0.04131665f, 0.06130678f, 0.10511865f, 
    -0.01753091f, -0.09152149f, 0.00705578f, -0.06853319f, 0.01512533f, -0.08598071f, 0.07850678f, -0.04332190f, 
    0.08006591f, 0.08649022f, 0.05199436f, 0.08135848f, 0.19301720f, -0.01722236f, -0.03563635f, 0.17104168f, 
    0.05216791f, 0.19466868f, 0.01097720f, 0.11970752f, 0.13095643f, -0.03110290f, -0.01589103f, -0.16433792f, 
    0.01152483f, 0.05008445f, -0.16326615f, 0.08004225f, -0.00192105f, 0.00458938f, 0.03455028f, -0.11238151f, 
    0.04339107f, -0.03930829f, -0.03998273f, 0.04670851f, 0.04750520f, -0.14576420f, -0.03345542f, 0.08277343f, 
    -0.06321371f, 0.03666477f, 0.16024017f, -0.08238520f, 0.00373648f, 0.07319280f, -0.03632738f, -0.01625013f, 
    -0.20199685f, 0.01397789f, -0.10987393f, 0.01077707f, -0.02888777f, -0.01190780f, -0.05638015f, -0.04108705f, 
    0.03624016f, -0.02861484f, -0.04572653f, -0.32098931f, -0.10973345f, -0.31944868f, -0.07949499f, -0.18814214f, 
    -0.17609110f, 0.03207275f, 0.07536083f, -0.04877540f, -0.04847274f, 0.06288600f, -0.05539302f, 0.01463772f, 
    -0.01689209f, -0.10559355f, -0.27051261f, 0.02593138f, -0.07754208f, -0.06834319f, 0.02416289f, 0.02757887f, 
    -0.20249450f, -0.22655998f, -0.16991042f, -0.17154007f, -0.04950849f, -0.00441249f, 0.14071377f, -0.10928787f, 
    -0.00041766f, 0.00119152f, -0.01321934f, 0.06006737f, -0.14518477f, 0.14739378f, -0.09683856f, -0.11129224f, 
    0.24443093f, 0.03455588f, -0.35469854f, 0.03728775f, 0.13793026f, 0.03355931f, 0.03173573f, -0.02355328f, 
    0.05071380f, 0.10494176f, 0.01566662f, 0.05220390f, 0.01665457f, -0.14883311f, -0.13351160f, 0.11381961f, 
    0.06224866f, 0.04349997f, -0.04342023f, 0.01186852f, 0.11567267f, 0.02634104f, 0.01492000f, 0.10896680f, 
    -0.47165015f, -0.23627175f, -0.45492342f, -0.21959676f, 0.25792509f, -0.02570519f, 0.15691684f, -0.05428374f, 
    -0.02449723f, 0.11073743f, -0.08392557f, 0.11941054f, -0.09156740f, -0.16048481f, 0.10197890f, -0.00950461f, 
    -0.03316018f, 0.06192563f, 0.10247860f, -0.01176240f, -0.04834469f, 0.02921837f, -0.10180924f, -0.00537551f, 
    -0.10418630f, 0.09947515f, 0.20036231f, -0.02267808f, -0.08985019f, 0.06179481f, -0.05587283f, 0.13770014f, 
    -0.02234787f, -0.02622826f, 0.04228134f, -0.00883223f, -0.29320791f, -0.15918240f, 0.03167072f, -0.24466620f, 
    0.15099069f, -0.05040529f, 0.04661910f, -0.03614600f, -0.00407278f, 0.02892785f, -0.00627686f, -0.02422225f, 
    -0.27368960f, 0.02665305f, -0.09045770f, -0.18661420f, 0.07599556f, -0.03884977f, 0.16745870f, -0.04928219f, 
    0.02822428f, 0.08095299f, 0.06167377f, -0.05026992f, 0.43201208f, 0.13239819f, -0.40602213f, 0.10820884f, 
    0.01891689f, -0.09886017f, -0.03447663f, 0.06003597f, 0.06295005f, 0.08392003f, -0.01811126f, -0.03333410f, 
    -0.08896783f, -0.08940940f, -0.16517450f, -0.15702912f, 0.14556648f, 0.09382400f, -0.05927897f, -0.31972611f, 
    -0.04194777f, -0.06997945f, -0.02891212f, -0.02730287f, 0.04498604f, 0.16352034f, 0.05718921f, -0.01348470f, 
    0.02968623f, 0.03275456f, -0.12133764f, -0.03824120f, 0.03639753f, 0.16388236f, 0.14219189f, 0.05702391f, 
    -0.36394587f, 0.02595347f, 0.10797920f, 0.19477278f, -0.03042497f, 0.10347119f, 0.06425944f, 0.05564675f, 
    0.17306122f, 0.02465112f, 0.07530244f, -0.04320780f, -0.23820321f, 0.04954081f, -0.00128124f, -0.32639772f, 
    -0.10968594f, 0.00561477f, 0.09569670f, 0.19881104f, 0.08529290f, 0.10718173f, 0.06629215f, -0.07234854f, 
    0.00888593f, 0.03163945f, 0.16852944f, -0.09767511f, 0.02285371f, -0.04493257f, 0.03575880f, 0.15640749f, 
    0.12791452f, -0.00037105f, 0.06693244f, 0.07333273f, 0.04598891f, 0.06756946f, 0.17936836f, -0.15123299f, 
    0.09486823f, 0.02213249f, 0.13049351f, 0.17687231f, 0.10999400f, -0.00928510f, -0.04999657f, 0.11055885f, 
    0.06186405f, -0.31021547f, -0.05816090f, -0.01851783f, 0.03798515f, 0.09581852f, -0.00295252f, 0.23725443f, 
    -0.02293295f, 0.04253608f, 0.05727054f, -0.00836947f, -0.19459525f, 0.14082915f, -0.04654969f, -0.31095266f, 
    0.16749960f, 0.03216540f, 0.05422137f, 0.00443613f, -0.02817784f, 0.00456560f, 0.07082572f, 0.09790762f, 
    -0.10190222f, 0.12719731f, 0.04325742f, -0.07390343f, 0.05404155f, -0.10511577f, -0.04194262f, 0.00417086f, 
    0.11325353f, 0.12353689f, 0.07494412f, 0.05712740f, -0.07373598f, -0.07785029f, -0.13335583f, -0.16429728f, 
    0.17376512f, 0.03466228f, -0.02613622f, -0.17348145f, 0.11124821f, -0.03005805f, -0.04293449f, 0.03214912f, 
    0.02998486f, 0.22634727f, -0.04429510f, -0.06769507f, 0.03547816f, 0.01615350f, 0.03750871f, -0.00032729f, 
    0.19680500f, 0.04423833f, 0.05058550f, -0.01224689f, 0.00514078f, 0.03579663f, 0.14900906f, 0.07700973f, 
    -0.07252657f, -0.14279547f, -0.07158174f, -0.03127369f, 0.07627863f, 0.03796469f, 0.11028964f, 0.06209882f, 
    -0.17544839f, 0.00233160f, -0.03913597f, 0.07976795f, -0.06878737f, -0.09324893f, -0.05961385f, 0.03754782f, 
    -0.19581187f, -0.17281079f, -0.19133647f, 0.01816766f, -0.09081068f, -0.04664271f, -0.10764209f, -0.24579379f, 
    0.02268800f, 0.04027301f, 0.06629578f, -0.00232740f, 0.06890103f, -0.02338934f, 0.10676655f, 0.03345295f, 
    0.03551036f, -0.16496828f, -0.07105386f, -0.02677197f, 0.00258594f, -0.06886778f, 0.04910735f, 0.10510811f, 
    0.05276246f, -0.10838640f, 0.19286458f, -0.04740316f, -0.13983095f, -0.14832743f, 0.08733783f, 0.03422894f, 
    -0.09103165f, 0.00251019f, -0.03120594f, 0.08925334f, 0.16220386f, 0.04353089f, 0.08930178f, 0.11311764f, 
    -0.09222285f, -0.05890794f, 0.02475712f, -0.00069614f, 0.02895256f, 0.20772286f, 0.10500477f, 0.10514358f, 
    -0.06978819f, -0.14270853f, 0.01365017f, -0.07593656f, -0.29333332f, 0.43004397f, -0.06777681f, 0.10380889f, 
    -0.01796710f, 0.13634679f, 0.03301543f, -0.05715610f, -0.02955353f, 0.03040353f, -0.03513804f, 0.12740253f, 
    -0.14425020f, -0.02502849f, 0.09021962f, -0.13774122f, -0.06419621f, -0.16350606f, -0.00896017f, -0.05575294f, 
    0.05922813f, -0.06063605f, -0.06505670f, 0.10427915f, -0.03318869f, 0.02360436f, 0.14532506f, -0.00744777f, 
    -0.02069476f, -0.05937009f, 0.00086175f, 0.02645813f, 0.01163230f, 0.00281116f, -0.01849138f, -0.00453081f, 
    -0.06900819f, -0.25425348f, -0.20770402f, -0.00812274f, -0.00321425f, 0.10968830f, -0.06065560f, -0.06405666f, 
    0.04978000f, 0.05592613f, 0.08676980f, -0.02698782f, -0.13077134f, 0.35138789f, -0.03562725f, -0.19110888f, 
    -0.04174603f, 0.24822558f, -0.18306038f, 0.06114276f, -0.02924017f, -0.06912471f, 0.10130881f, 0.01116544f, 
    -0.29592249f, 0.10609154f, 0.09998807f, 0.18989030f, -0.06549912f, 0.08624554f, -0.09624466f, 0.14124613f, 
    0.04083965f, 0.03127568f, 0.18898842f, 0.00354344f, -0.26544362f, -0.07756197f, 0.00537580f, 0.05604700f, 
    -0.05902015f, -0.00628450f, 0.20326185f, -0.08052482f, 0.00307704f, 0.07386962f, 0.02504835f, 0.20735267f, 
    0.17296250f, 0.15492654f, -0.01502908f, -0.02069859f, 0.04707607f, 0.13551635f, 0.00243576f, 0.05811933f, 
    0.10778598f, 0.10901766f, 0.05503324f, -0.06057197f, 0.27427018f, 0.13938151f, -0.14025460f, 0.02113880f, 
    0.14768381f, 0.11688209f, 0.08473057f, -0.04737331f, 0.14847028f, 0.10471988f, 0.00029900f, -0.05595324f, 
    0.08374584f, 0.02549938f, -0.37396750f, 0.23150922f, 0.07529497f, -0.13508940f, 0.05211176f, 0.06115843f, 
    -0.02992765f, 0.04706884f, -0.01191129f, 0.00773068f, -0.08213639f, -0.03590134f, 0.09171065f, -0.22270502f, 
    0.00623922f, -0.04842820f, 0.09824736f, 0.02686978f, 0.01613370f, -0.10761006f, -0.02865289f, -0.01375478f, 
    -0.06773829f, -0.09946682f, 0.03093478f, -0.07788590f, -0.15297090f, -0.04555273f, -0.09967027f, -0.03188521f, 
    -0.10941556f, 0.00618477f, 0.04493007f, 0.02877323f, -0.14775115f, 0.06116582f, -0.23470502f, -0.11480005f, 
    0.12798102f, -0.02702654f, 0.00377908f, -0.03322759f, 0.24316101f, -0.06825732f, 0.15523751f, 0.13258930f, 
    0.16261202f, 0.08578369f, -0.08023418f, -0.03650080f, -0.04512957f, -0.00911910f, 0.01855044f, 0.07859474f, 
    0.14804521f, -0.01724578f, 0.10530052f, -0.00566059f, -0.17706715f, 0.01050274f, -0.07702897f, -0.25641733f, 
    0.08397728f, -0.12382983f, -0.08788400f, -0.08931038f, -0.11252188f, -0.05489472f, -0.03273015f, -0.04999511f, 
    0.03499534f, 0.40078118f, -0.22558987f, -0.24400078f, 0.24640387f, 0.06367207f, -0.00725232f, 0.10694063f, 
    0.19656785f, 0.03326111f, 0.11273865f, 0.16815931f, -0.24612440f, -0.02147487f, -0.06597965f, -0.12962639f, 
    0.10630546f, 0.09244073f, 0.01212882f, 0.07209329f, -0.13544007f, -0.06780201f, 0.03812553f, -0.02635134f, 
    -0.09811972f, 0.04259697f, -0.07028497f, -0.03761367f, 0.05015214f, -0.06291636f, 0.03877757f, 0.17132509f, 
    0.14419492f, 0.09853021f, 0.08701969f, 0.10530961f, -0.09049128f, 0.07594548f, -0.02474741f, -0.05446240f, 
    -0.02297399f, 0.11545143f, 0.11468798f, 0.10775837f, -0.02599618f, -0.09744854f, -0.03940961f, -0.12085056f, 
    -0.09379392f, -0.38170338f, 0.00439615f, 0.13729672f, 0.01045572f, 0.02257244f, 0.03039010f, 0.02472759f, 
    0.02511574f, -0.13020220f, -0.03831393f, 0.00379151f, -0.03871660f, -0.12252883f, -0.15172341f, -0.05082759f, 
    -0.00445268f, 0.03618017f, 0.09788118f, 0.11123779f, 0.00291852f, -0.06810290f, -0.06572624f, -0.01223755f, 
    -0.11898125f, 0.07347511f, 0.10194650f, -0.18329650f, 0.04451790f, 0.07278217f, 0.03192914f, 0.00846124f, 
    0.03888693f, -0.02140127f, 0.10137884f, -0.00421205f, 0.18401973f, 0.03207893f, 0.06575141f, 0.00258267f, 
    -0.23342213f, -0.03829165f, -0.03860874f, 0.07916106f, 0.01279796f, -0.05000774f, 0.09694149f, -0.07608244f, 
    0.02980976f, 0.03238240f, -0.22992595f, -0.12630194f, 0.13341017f, -0.10511438f, -0.08403416f, 0.11868573f, 
    0.13808678f, 0.04345821f, -0.17759416f, -0.00370607f, 0.14676784f, -0.16243334f, -0.00577089f, -0.17202571f, 
    0.14640887f, 0.10709828f, -0.05998753f, -0.14542547f, -0.04881608f, -0.04005317f, -0.10242522f, 0.11508848f, 
    -0.03803446f, -0.14414005f, 0.09321912f, -0.02387099f, 0.03089136f, 0.11643744f, 0.05397350f, 0.16366035f, 
    0.07470232f, 0.05998928f, -0.01595506f, -0.10552021f, 0.22953957f, -0.24227151f, -0.07195389f, 0.06032190f, 
    -0.05692431f, -0.01840458f, 0.08125311f, 0.30421722f, -0.00646305f, 0.16462106f, -0.15131113f, 0.08229634f, 
    -0.10889568f, 0.06323642f, -0.09579585f, 0.08248654f, -0.08505640f, 0.07971599f, 0.00121271f, -0.16680595f, 
    -0.09400633f, -0.09132443f, 0.04902461f, -0.06056246f, -0.05820157f, -0.03169233f, -0.19997448f, 0.02474855f, 
    -0.02176425f, -0.00287997f, 0.11123452f, 0.02222145f, -0.03312062f, -0.06433935f, 0.03347150f, 0.01316981f, 
    0.09831112f, 0.01159189f, -0.18539330f, 0.12803310f, 0.03615282f, -0.06518199f, -0.05568424f, 0.06225261f, 
    0.06856903f, 0.07492504f, -0.03848070f, 0.02725299f, 0.18445382f, -0.01219513f, 0.06087064f, 0.04861585f, 
    -0.12478786f, -0.03223744f, -0.02059266f, -0.03787931f, 0.26306307f, 0.04420064f, 0.17879111f, 0.01621275f, 
    0.04675353f, -0.00477396f, 0.02586761f, -0.33892488f, 0.10071925f, -0.04089473f, 0.05351589f, -0.03085970f, 
    0.07626560f, -0.00184685f, 0.07814573f, 0.07229207f, -0.06522211f, 0.12774348f, -0.13723223f, 0.17869079f, 
    -0.01057106f, 0.13767564f, 0.13410176f, -0.00717788f, 0.07410548f, -0.00977550f, 0.10862496f, -0.00802269f, 
    0.07451393f, -0.15399800f, 0.13142441f, 0.04360880f, 0.09535462f, -0.14106481f, 0.01244325f, -0.03203716f, 
    -0.01848664f, -0.12308613f, 0.11216669f, 0.15285291f, -0.06074882f, 0.03932773f, -0.03382729f, 0.08518980f, 
    -0.00277000f, 0.03590178f, 0.23477881f, -0.22384433f, -0.09404032f, -0.04529637f, -0.00563122f, 0.06377959f, 
    0.06120345f, -0.03446522f, 0.01058257f, -0.08659771f, -0.07907000f, -0.03966375f, 0.01430936f, -0.03880532f, 
    0.06214740f, -0.00377130f, 0.01797537f, -0.09925520f, -0.01400116f, -0.11100487f, 0.07759225f, -0.20878714f, 
    0.04855453f, 0.11857123f, 0.01262519f, -0.17968616f, -0.09776142f, -0.00117777f, 0.06990362f, 0.02661511f, 
    0.08143348f, -0.06620051f, 0.09463923f, 0.09468445f, -0.11046793f, -0.16962233f, 0.00339249f, -0.01416385f, 
    0.14941064f, 0.00305934f, 0.04119791f, -0.07472520f, -0.08440439f, 0.06054457f, 0.15310173f, -0.05526888f, 
    -0.02327632f, 0.05279428f, 0.07458894f, 0.08189362f, 0.18086469f, 0.06152744f, 0.16351719f, -0.06696785f, 
    0.19627467f, -0.24438377f, 0.00480062f, 0.16980104f, 0.09679898f, 0.10860144f, 0.04210881f, 0.13976887f, 
    -0.00652242f, 0.00547856f, -0.01141005f, 0.07038978f, 0.19360833f, -0.15504317f, -0.01289567f, 0.03767623f, 
    -0.09632324f, 0.08200301f, -0.04041110f, 0.12211332f, -0.09018592f, 0.03758559f, -0.01594522f, -0.01699096f, 
    -0.00034247f, -0.03463381f, 0.02906677f, -0.02853378f, 0.00426002f, 0.00912733f, 0.03389507f, -0.00221387f, 
    0.01995861f, -0.00291066f, -0.02298791f, -0.03551405f, 0.02188633f, 0.02418089f, 0.00658042f, -0.00781877f, 
    -0.03725693f, -0.00780917f, 0.01703875f, -0.00623631f, 0.02743656f, -0.01247335f, 0.01390021f, 0.01506941f, 
    -0.01695401f, -0.02707916f, -0.02765491f, 0.02153743f, -0.03281612f, -0.03516234f, -0.03289875f, -0.00990889f, 
    0.02813809f, -0.00251635f, -0.02747028f, -0.03450284f, -0.01440717f, -0.01090430f, 0.02247363f, -0.03277149f, 
    0.00297271f, -0.03134651f, -0.00441667f, 0.01668191f, 0.01905402f, -0.01702718f, -0.01159426f, 0.01347368f, 
    0.01539849f, -0.03477018f, -0.00692150f, 0.01097154f, -0.00184439f, -0.01244870f, -0.03669242f, -0.02584942f, 
    -0.00543281f, 0.02321589f, -0.03594251f, -0.04110026f, -0.00756445f, -0.03618535f, 0.01002498f, -0.01907056f, 
    0.00957608f, -0.02025930f, 0.01382948f, 0.02723164f, 0.02061103f, -0.01865211f, 0.02461144f, 0.01185592f, 
    -0.02905643f, -0.02614883f, -0.02104462f, -0.02518834f, -0.01768682f, -0.01329215f, 0.02119398f, -0.02253261f, 
    -0.03112170f, -0.02663343f, 0.01552254f, 0.02173818f, 0.02578659f, -0.00971515f, 0.02506966f, -0.03082690f, 
    0.01400732f, -0.00747197f, -0.02058707f, -0.02612624f, -0.03675200f, -0.01233394f, -0.03120480f, -0.03701582f, 
    -0.03823325f, 0.01683301f, -0.00361540f, -0.03753908f, 0.00341942f, 0.00181694f, 0.02067602f, -0.01230691f, 
    0.02165406f, -0.01808925f, 0.00938426f, -0.01205726f, -0.03274769f, 0.00410913f, 0.01719706f, 0.02533836f, 
    -0.02284649f, 0.00000208f, 0.00740612f, -0.04106436f, 0.02936673f, -0.01115016f, 0.00969764f, -0.00261129f, 
    -0.02031993f, -0.00944222f, -0.03707533f, -0.02110036f, 0.01237099f, -0.00366525f, -0.03256916f, -0.02751971f, 
    0.00680660f, -0.00846045f, -0.01014865f, 0.01487729f, -0.00953205f, -0.01736649f, 0.02359077f, 0.00141692f, 
    -0.00483602f, 0.02653427f, -0.01048706f, 0.01984407f, -0.00661020f, 0.00943494f, 0.00018357f, 0.01303236f, 
    0.02699646f, 0.02934722f, 0.02660342f, -0.00626585f, 0.02996072f, 0.01500905f, -0.02067012f, -0.00722461f, 
    0.00435362f, -0.03402024f, -0.02960906f, -0.02203039f, -0.01172610f, 0.00960313f, 0.00922909f, -0.02911267f, 
    -0.01006470f, -0.01973819f, 0.01979386f, 0.00101751f, 0.01177561f, -0.01596337f, -0.01022890f, 0.00209081f, 
    -0.02681644f, -0.02564967f, 0.02390450f, 0.01353003f, -0.00329026f, -0.01311012f, -0.00131876f, -0.01747934f, 
    0.00399675f, 0.02423952f, -0.03377653f, -0.01082859f, 0.00766002f, 0.00064948f, 0.02767007f, 0.02339724f, 
    -0.03722959f, -0.01695440f, -0.02168186f, -0.03425276f, 0.01767698f, -0.00853177f, 0.02582823f, -0.02210940f, 
    -0.00246203f, -0.02665976f, -0.03514100f, -0.02162323f, 0.02056797f, -0.01482951f, 0.01600551f, -0.01362736f, 
    -0.03731085f, 0.01642917f, 0.01277292f, -0.01240023f, -0.03283194f, 0.01940143f, -0.02830051f, 0.01162635f, 
    0.00368696f, -0.02250997f, 0.01589732f, -0.01193529f, -0.01828014f, -0.00178980f, -0.03847590f, 0.02440749f, 
    -0.03343011f, -0.02973692f, 0.02097564f, 0.00592596f, -0.02385127f, -0.00749807f, 0.01975784f, -0.02505142f, 
    -0.00039245f, 0.02459556f, 0.02559558f, 0.01844164f, -0.02827252f, 0.02804594f, 0.02242851f, 0.00275507f, 
    -0.01328631f, -0.03227216f, -0.01700081f, -0.03624284f, 0.01866530f, -0.03018608f, -0.02094655f, -0.00853769f, 
    -0.01597250f, -0.02733241f, 0.02842929f, 0.02955366f, -0.00518888f, 0.01672384f, -0.03958697f, 0.02933782f, 
    -0.00698227f, -0.00706005f, 0.02571903f, -0.04036649f, -0.04153549f, -0.01776110f, 0.00192538f, -0.00901966f, 
    0.00789883f, -0.01230539f, 0.00572415f, -0.01895763f, 0.00115398f, -0.01315524f, -0.03382408f, 0.00104566f, 
    -0.02611196f, -0.03381014f, -0.03010772f, 0.02115428f, -0.00777418f, 0.01854863f, -0.00419840f, -0.00989673f, 
    0.01039251f, -0.00807506f, -0.02848099f, -0.01055093f, -0.00958947f, -0.01575257f, 0.00194969f, -0.01653948f, 
    -0.00186537f, -0.01542343f, 0.01413832f, -0.01640888f, -0.02509945f, -0.01335313f, -0.02167503f, -0.02159194f, 
    0.00995139f, -0.01354383f, 0.00542150f, -0.02963124f, -0.02551460f, 0.00671828f, 0.00230534f, -0.03578650f, 
    -0.00509741f, 0.02701551f, -0.02561523f, 0.03198184f, 0.00838174f, -0.02349855f, -0.00978063f, 0.02999303f, 
    -0.04176244f, -0.01482163f, 0.01381899f, -0.00151075f, 0.02773646f, 0.01302273f, -0.01356862f, 0.00113571f, 
    0.00520596f, 0.00742037f, -0.00518544f, 0.00073309f, -0.02433805f, -0.01474044f, -0.02554492f, 0.00113261f, 
    -0.00667887f, 0.01072151f, -0.00573601f, 0.00603015f, 0.02818950f, -0.03031124f, 0.02724517f, 0.02759892f, 
    0.01016822f, 0.01190136f, -0.04108758f, 0.02005919f, 0.02682714f, 0.00812018f, -0.04188781f, -0.01452232f, 
    -0.03344098f, 0.01486239f, 0.02162245f, -0.01229843f, 0.01078699f, 0.02382429f, -0.03551203f, -0.00609381f, 
    -0.00879562f, -0.02426205f, -0.03671290f, -0.00268532f, -0.02927575f, -0.01859877f, 0.01212642f, -0.00720580f, 
    -0.02295896f, 0.02038792f, 0.01661500f, -0.00818945f, -0.03432074f, 0.00097232f, -0.00131617f, 0.01524144f, 
    0.01341287f, -0.03885635f, -0.02828119f, -0.03251610f, -0.02658116f, 0.01377688f, -0.02616557f, -0.00851952f, 
    -0.01676337f, -0.03507060f, -0.02842084f, 0.01570312f, 0.01186117f, -0.00009297f, 0.00512066f, -0.03234032f, 
    -0.02983203f, -0.03107726f, 0.01825067f, 0.02860591f, 0.00533227f, -0.00219856f, -0.02282242f, 0.01711737f, 
    -0.03668928f, -0.01302637f, -0.00072697f, 0.01898476f, -0.02030526f, -0.03255446f, -0.01244436f, -0.03443151f, 
    0.01773164f, -0.00450430f, -0.00134969f, -0.03202217f, -0.02358541f, -0.02070820f, -0.00916082f, -0.03073781f, 
    -0.00384032f, 0.00918675f, 0.00869648f, -0.01758481f, -0.00691327f, 0.02962908f, -0.00041501f, 0.02245881f, 
    -0.00856138f, 0.01405080f, -0.01725527f, -0.01432490f, 0.02985100f, 0.00524376f, -0.03216296f, -0.03063721f, 
    0.01738570f, 0.00650676f, -0.02769762f, -0.01711362f, 0.02245091f, -0.03548304f, -0.01596442f, 0.02368428f, 
    0.00568710f, -0.00636358f, -0.03140669f, -0.00957948f, -0.04185821f, 0.02964778f, -0.03896765f, 0.01843045f, 
    0.00812684f, -0.01644988f, -0.03809793f, -0.01966821f, 0.00079157f, -0.03469032f, 0.00636650f, -0.00090421f, 
    -0.02652197f, -0.04018990f, -0.04009572f, 0.02877051f, 0.01065392f, -0.01450133f, -0.00790738f, -0.02642891f, 
    0.02449430f, -0.01851944f, -0.00845016f, 0.00950976f, -0.00798405f, 0.02174443f, 0.02361202f, -0.04189641f, 
    -0.03453087f, 0.00583802f, -0.01124720f, -0.01186103f, 0.02317495f, -0.02921564f, 0.01746058f, 0.01302676f, 
    0.00966760f, -0.03813927f, -0.02085479f, -0.00922833f, -0.04053834f, -0.02448001f, -0.01133277f, -0.00827858f, 
    -0.01885059f, -0.00738976f, 0.02171111f, 0.00589685f, -0.01403615f, 0.00109200f, -0.01869123f, 0.01656964f, 
    -0.03412658f, -0.01047881f, -0.01380860f, 0.02536268f, -0.01047572f, -0.04068196f, 0.01568557f, -0.00996335f, 
    -0.00566361f, -0.00493697f, 0.02172607f, -0.03781559f, 0.01176688f, -0.01283608f, 0.00253436f, -0.03272194f, 
    0.02675523f, -0.00829674f, -0.01158914f, 0.02874241f, -0.02861851f, 0.01941866f, -0.01155731f, -0.00131744f, 
    0.02813455f, -0.04191408f, -0.01784203f, 0.02035939f, 0.01395665f, -0.03053303f, -0.02166958f, 0.01160612f, 
    0.00735997f, 0.02140982f, 0.02431080f, -0.00827304f, 0.01244709f, 0.00029190f, -0.03685465f, -0.03972213f, 
    -0.01878820f, -0.03641200f, 0.01748419f, 0.02592455f, -0.02177333f, 0.00519780f, -0.00109210f, -0.00418031f, 
    -0.03296733f, 0.02476275f, 0.01952202f, 0.01831746f, -0.04191804f, 0.02206141f, 0.02408732f, 0.01168220f, 
    0.00092881f, -0.02597461f, -0.01547773f, -0.00164350f, 0.01705131f, 0.00806431f, 0.00652259f, -0.01127546f, 
    -0.02993778f, -0.00058152f, -0.01405918f, -0.00899817f, -0.03652726f, -0.03082614f, 0.00445448f, 0.00975645f, 
    -0.02656989f, -0.02086698f, -0.00366302f, -0.02413923f, -0.03026676f, -0.01352469f, -0.00896664f, -0.01450402f, 
    -0.01108457f, 0.02331828f, -0.01723082f, 0.01829763f, -0.03094194f, -0.02835092f, 0.00315185f, 0.02902447f, 
    -0.00210381f, 0.01849356f, -0.02082855f, -0.02588471f, 0.01295462f, -0.01288279f, -0.04157244f, -0.00718285f, 
    -0.04024173f, -0.03064765f, -0.02633585f, -0.02016990f, 0.01787750f, -0.02144920f, -0.00837466f, 0.00948546f, 
    -0.00217660f, -0.01680184f, -0.01542457f, -0.01921943f, -0.03396555f, 0.01619798f, 0.02134983f, 0.00485421f, 
    -0.02149214f, 0.02585755f, 0.00259488f, -0.03061164f, -0.00662221f, -0.01034052f, -0.01031888f, -0.00109023f, 
    -0.02537721f, -0.01132027f, 0.01679929f, -0.04161060f, -0.01319730f, 0.00294450f, -0.03099612f, 0.00803396f, 
    -0.03496915f, -0.02948219f, -0.01716969f, -0.00541233f, -0.00107730f, -0.01816691f, -0.02222858f, -0.03608643f, 
    0.01245886f, 0.01458147f, 0.00092845f, 0.02577490f, -0.00150127f, -0.00813580f, 0.00741649f, 0.02253374f, 
    -0.00281643f, -0.02327186f, -0.02203193f, -0.02257739f, 0.00579255f, 0.00477384f, 0.00862827f, 0.00890744f, 
    -0.03957438f, -0.02561269f, -0.03619847f, 0.01790595f, 0.00414588f, 0.01100328f, -0.01988254f, -0.00437752f, 
    -0.02388328f, -0.01909055f, -0.04172937f, -0.04039003f, -0.02882473f, -0.03630206f, 0.02638624f, -0.02983112f, 
    0.01122085f, -0.01596541f, -0.02044844f, -0.01241861f, 0.02710913f, 0.01179974f, -0.00643969f, -0.01661777f, 
    -0.02832577f, 0.02850982f, -0.01517563f, -0.02858149f, 0.02920246f, -0.00978140f, -0.03733300f, 0.01280962f, 
    -0.02215078f, -0.00493097f, -0.00958651f, -0.00738733f, 0.00030857f, -0.02720820f, 0.00642432f, -0.02737047f, 
    0.02820382f, 0.00367388f, 0.01412948f, 0.01015475f, -0.03435648f, 0.00676526f, -0.02305419f, -0.01082322f, 
    -0.00635885f, 0.00913482f, 0.02252382f, 0.01938339f, -0.03241511f, 0.01573054f, -0.04009553f, 0.02599871f, 
    -0.02150077f, -0.00215792f, -0.03155290f, 0.02643034f, 0.02586764f, 0.02952190f, -0.00705591f, -0.04029411f, 
    -0.04027851f, -0.04020311f, 0.01923247f, 0.01351348f, 0.02689951f, -0.03662996f, 0.02472036f, 0.01597130f, 
    0.02992974f, 0.01563654f, 0.00255979f, -0.02329270f, -0.01081242f, 0.00873353f, -0.01344498f, 0.01040154f, 
    0.01573298f, -0.01930958f, 0.00791577f, 0.02172463f, 0.01081230f, -0.00067670f, -0.00897804f, -0.01351624f, 
    -0.02799473f, -0.00034102f, 0.02434359f, -0.01564822f, 0.00142345f, -0.01285940f, -0.01297866f, 0.02225027f, 
    -0.03493372f, 0.02089948f, -0.02398216f, 0.01293686f, 0.00058563f, 0.01436090f, 0.01857301f, -0.00182626f, 
    -0.02430086f, -0.00468326f, -0.01841063f, -0.01134175f, -0.00636761f, -0.04077366f, 0.00415564f, -0.02628861f, 
    -0.03505183f, 0.02639652f, 0.02577959f, -0.02591649f, -0.01288007f, -0.00640806f, -0.02878378f, 0.01697913f, 
    0.02595918f, -0.03811776f, -0.01642090f, -0.02682416f, 0.00108355f, 0.01966915f, 0.01557863f, -0.00770492f, 
    -0.03064444f, -0.02994391f, -0.01708503f, 0.01187357f, -0.03661040f, -0.01698400f, -0.04068709f, -0.04013058f, 
    0.07132702f, 0.08801150f, -0.18765433f, 0.12123239f, 0.12653041f, -0.13339762f, -0.01420340f, -0.13000058f, 
    -0.05948842f, -0.11491779f, 0.04573558f, 0.03793463f, -0.04578751f, -0.11141116f, 0.03340697f, 0.05701301f, 
    -0.08934689f, 0.06171675f, 0.04796040f, -0.02328966f, -0.08740263f, 0.01848922f, 0.03943101f, -0.04638038f, 
    0.11248784f, -0.14648862f, -0.10523016f, -0.08641092f, -0.03504088f, -0.01257845f, -0.10899420f, -0.05922535f, 
    -0.22384115f, -0.02379282f, 0.16407688f, -0.10016403f, 0.04975015f, 0.09433395f, 0.02316410f, -0.15328196f, 
    0.07131984f, 0.05099515f, -0.01117753f, 0.25133416f, -0.13249299f, 0.00777519f, -0.06089449f, -0.07805763f, 
    0.50720102f, -0.01673925f, -0.23432215f, 0.15063493f, 0.17278795f, 0.02667941f, 0.05794833f, -0.09310964f, 
    0.01407428f, -0.04495115f, 0.07660844f, -0.04801230f, 0.27309066f, -0.13493302f, 0.09055129f, -0.04842065f, 
    0.05047390f, 0.05610591f, 0.17667617f, 0.06722507f, 0.20521787f, 0.06024260f, 0.02774016f, 0.04899935f, 
    0.05446022f, -0.09669204f, -0.01816031f, -0.22803417f, 0.00260188f, -0.06074561f, 0.07892752f, -0.01646670f, 
    -0.24524941f, 0.04941781f, 0.14504339f, -0.00158119f, 0.02832164f, 0.09481384f, 0.07335532f, 0.07416189f, 
    -0.10815614f, -0.00749586f, -0.07110041f, 0.02837578f, 0.14275733f, -0.13528356f, 0.22274114f, 0.03242832f, 
    -0.23403306f, -0.23289096f, 0.03147577f, -0.02729226f, -0.01171497f, -0.00044615f, 0.10030077f, -0.02973920f, 
    -0.02779859f, 0.22254471f, 0.00403576f, -0.04396933f, -0.01497332f, -0.04278538f, -0.11001790f, 0.06593283f, 
    0.09099529f, 0.02419612f, 0.12101592f, 0.14465351f, 0.11128089f, 0.09186434f, -0.08088339f, 0.03137884f, 
    0.08876088f, 0.06180772f, 0.14793311f, 0.08116894f, -0.01221242f, 0.05297307f, 0.08729330f, 0.01988365f, 
    -0.00801677f, 0.09129844f, 0.14400744f, -0.05063432f, -0.08355941f, -0.15441446f, -0.19768888f, -0.11203440f, 
    0.00486214f, 0.02309255f, 0.20665152f, -0.00794643f, 0.12827417f, -0.01490379f, -0.06751733f, 0.01799073f, 
    -0.02241869f, -0.01683053f, 0.08293356f, -0.05740151f, 0.15903179f, 0.16063918f, 0.03365968f, -0.08740645f, 
    -0.13511753f, -0.12583104f, -0.11297328f, -0.04783845f, 0.05983576f, -0.12863259f, 0.09675018f, -0.04891146f, 
    0.05334001f, 0.22219352f, -0.07667720f, 0.03422252f, 0.01311443f, 0.02609502f, -0.02976924f, -0.14247194f, 
    0.11576515f, -0.13732789f, 0.15737067f, 0.14475226f, -0.13648048f, -0.11928292f, 0.09519923f, -0.05685513f, 
    -0.06083966f, -0.05515072f, 0.00935821f, 0.00526549f, -0.16393149f, -0.08194467f, -0.03216734f, -0.06927805f, 
    0.05650612f, -0.02532495f, 0.25078833f, -0.04344366f, 0.03817799f, 0.01258731f, 0.01376869f, 0.12996277f, 
    0.45059237f, -0.11616090f, -0.25895703f, -0.25487351f, -0.04450244f, 0.01140930f, 0.01229179f, -0.04156702f, 
    0.00939930f, 0.19696304f, 0.13061541f, 0.00618456f, 0.05532889f, 0.09328382f, 0.11131559f, 0.07624216f, 
    -0.07898117f, 0.00136968f, -0.00523856f, 0.00060984f, 0.00723757f, 0.00811417f, 0.03033139f, -0.02897215f, 
    0.11587062f, 0.09423165f, 0.08668696f, 0.09996083f, -0.04390373f, -0.03484523f, -0.02041839f, -0.07539834f, 
    0.04076374f, 0.00199383f, -0.03374269f, 0.03408488f, -0.27760479f, -0.03135384f, -0.08455512f, -0.17620115f, 
    -0.02986604f, -0.03774873f, 0.05160845f, 0.00658860f, -0.15936758f, 0.08204459f, -0.16667545f, 0.04353942f, 
    0.05601832f, 0.00938303f, -0.10017522f, 0.01045610f, 0.02496312f, -0.03335768f, 0.03461875f, -0.10675564f, 
    -0.05408382f, -0.18923944f, -0.18155600f, -0.16581161f, 0.06605414f, 0.00201434f, -0.05854563f, -0.16265874f, 
    -0.08604284f, -0.02683164f, -0.03381575f, 0.11480301f, 0.09078780f, 0.16771437f, 0.10611085f, -0.10073541f, 
    -0.03581172f, -0.13457459f, 0.10323446f, 0.08827496f, 0.05758563f, 0.05294679f, 0.04501954f, 0.07691348f, 
    -0.18068266f, -0.09627821f, -0.11763502f, 0.00756691f, -0.28961623f, 0.23463586f, 0.04186582f, -0.03658163f, 
    -0.12347440f, 0.14080094f, -0.13897021f, 0.01388728f, -0.10990811f, 0.04113645f, 0.07473149f, -0.07572899f, 
    0.12403657f, 0.01099084f, 0.06856277f, 0.03671877f, -0.02780860f, -0.02813167f, 0.03039534f, -0.04828995f, 
    0.01156526f, 0.02447712f, -0.02844894f, -0.03303683f, -0.03269977f, 0.08740525f, 0.02553749f, 0.02702001f, 
    -0.03662921f, 0.07274207f, 0.04678724f, -0.02086638f, -0.08582970f, 0.09325764f, -0.06908864f, 0.05703306f, 
    0.11891638f, -0.20390871f, -0.06430716f, -0.08456194f, -0.02374310f, 0.03140285f, 0.14698622f, 0.30188522f, 
    -0.10129695f, -0.13017720f, 0.11288500f, 0.01085878f, -0.00919067f, -0.02580717f, -0.06431457f, -0.17216448f, 
    0.02469652f, 0.10716310f, 0.02913890f, 0.10164248f, 0.19668144f, 0.02688093f, -0.09410384f, 0.02363812f, 
    -0.14802477f, 0.13197213f, 0.21453498f, 0.04263677f, -0.02260379f, -0.04785052f, 0.08578889f, 0.04565696f, 
    0.20373906f, 0.18554993f, 0.09337053f, -0.03045112f, 0.14627488f, 0.15181653f, -0.16942091f, -0.01231999f, 
    0.02630566f, -0.11610001f, 0.06686115f, -0.03309312f, -0.08232812f, 0.05004977f, -0.09343148f, -0.04228684f, 
    0.09287374f, -0.03847249f, -0.00033863f, -0.07273461f, -0.02562053f, 0.07584804f, -0.04906301f, 0.11161881f, 
    0.10305744f, -0.01007940f, -0.09716453f, -0.09190015f, 0.17266475f, -0.11112174f, 0.14246221f, -0.08865796f, 
    -0.01338950f, -0.05716921f, -0.03812175f, 0.18243052f, -0.03455639f, -0.07374330f, 0.01991640f, 0.02464708f, 
    -0.11538805f, 0.18044214f, 0.13036042f, 0.02400316f, 0.04479752f, 0.20388363f, -0.06676491f, 0.15274841f, 
    -0.01763709f, 0.00576995f, 0.02638688f, 0.05803282f, 0.19431365f, 0.02290072f, -0.01608179f, 0.01472391f, 
    0.09677590f, 0.03962855f, -0.08138482f, 0.04286526f, -0.03743107f, -0.05972242f, -0.06553257f, 0.04395352f, 
    0.06181467f, 0.06958051f, 0.07223862f, 0.01242121f, 0.00476550f, -0.00009531f, -0.05561734f, -0.01187119f, 
    -0.05919673f, -0.05599089f, 0.01368323f, -0.10858125f, 0.34654367f, 0.19456911f, -0.16370010f, -0.10278960f, 
    0.02747873f, 0.08858362f, 0.12406470f, 0.17036645f, 0.08491455f, 0.07615670f, -0.14679776f, -0.00455686f, 
    -0.04845714f, -0.04163112f, 0.19978830f, -0.07224494f, -0.01474858f, 0.02963565f, 0.05914923f, 0.03895422f, 
    -0.00711478f, 0.08724197f, 0.01424012f, -0.06532052f, 0.09544239f, 0.03966871f, 0.11179788f, -0.01346753f, 
    0.00917470f, -0.03321863f, 0.02490697f, -0.05488290f, -0.08809533f, -0.01643341f, -0.02515100f, 0.01890846f, 
    0.28854176f, -0.00904541f, 0.02423580f, -0.07876542f, 0.06332783f, 0.04671276f, 0.07424623f, -0.02444309f, 
    0.12418082f, 0.17180757f, 0.03231118f, -0.05342855f, 0.10636856f, 0.21125647f, 0.08429916f, -0.11650253f, 
    0.11281610f, 0.01566552f, -0.17608021f, -0.01855292f, -0.13736369f, -0.12755804f, -0.06644149f, -0.06806215f, 
    0.23222902f, -0.17633660f, -0.22851703f, -0.08944958f, 0.04731899f, 0.02708210f, 0.02261929f, -0.11377946f, 
    -0.04616898f, 0.00144707f, -0.02585880f, -0.17572148f, 0.00856429f, -0.05476481f, -0.06807896f, 0.00798711f, 
    -0.07489062f, 0.05102997f, 0.02672972f, -0.07243164f, 0.07040399f, -0.14204639f, -0.07596182f, -0.12337609f, 
    0.00498856f, 0.01858041f, -0.08683697f, -0.03851778f, -0.01647160f, -0.03774426f, -0.06615020f, 0.05800947f, 
    -0.02595227f, 0.07504399f, 0.01064053f, -0.00053041f, -0.37895718f, -0.06968870f, -0.04043135f, -0.22273411f, 
    -0.04678122f, 0.09939444f, 0.16851912f, 0.23126946f, -0.11738028f, 0.05963593f, 0.02286328f, 0.11174520f, 
    -0.02498745f, 0.02197488f, -0.02292430f, 0.09830405f, -0.00307189f, 0.03166910f, -0.03294279f, 0.13088165f, 
    -0.01758266f, -0.06484895f, 0.00420278f, 0.15353039f, -0.01041737f, 0.04571147f, 0.08535384f, 0.07075314f, 
    -0.09846063f, 0.01029857f, 0.00425128f, -0.02572705f, -0.00252722f, 0.15003565f, 0.05428228f, 0.13840404f, 
    0.20543626f, 0.07514384f, -0.02062145f, 0.22144312f, -0.03046481f, -0.19012146f, 0.10978848f, 0.02820081f, 
    0.00445861f, -0.04252427f, -0.02055786f, 0.08653118f, -0.18229172f, 0.07151403f, -0.04700645f, -0.20988673f, 
    0.01798577f, -0.13510697f, 0.13977851f, 0.00715232f, -0.03320960f, -0.09018657f, 0.04525853f, -0.03229420f, 
    -0.17556965f, -0.09335008f, -0.07856026f, -0.05560499f, -0.07520817f, 0.08543191f, 0.00827314f, 0.16892824f, 
    -0.00947523f, -0.01303100f, 0.07140023f, -0.07985789f, -0.21576005f, 0.06331757f, 0.00967676f, -0.07901531f, 
    0.21085538f, 0.27829117f, -0.04350911f, 0.10048985f, -0.05312421f, 0.09360509f, -0.01961395f, 0.02810521f, 
    0.09616058f, 0.23488165f, 0.09598605f, 0.07379188f, -0.01682037f, -0.04110686f, -0.07370239f, 0.09138495f, 
    0.25697210f, 0.04885988f, 0.24301338f, 0.05848485f, 0.25663847f, 0.12069205f, 0.12686835f, -0.02499091f, 
    0.03725403f, -0.03408203f, 0.06496090f, -0.20995997f, 0.02907926f, 0.00174474f, -0.03857500f, 0.09615688f, 
    0.38365805f, 0.22160323f, 0.17392115f, 0.18377563f, 0.01179002f, -0.01846975f, 0.01170699f, -0.00385956f, 
    0.06708691f, -0.00138658f, 0.07032604f, 0.03424304f, 0.12942949f, 0.08744013f, 0.07902519f, 0.02785945f, 
    -0.09536964f, 0.08007462f, 0.00136677f, 0.01178440f, 0.11655027f, 0.06266113f, 0.17935576f, 0.08824967f, 
    0.11668268f, 0.04107567f, 0.04766351f, 0.08715998f, -0.04576271f, 0.06748769f, 0.07833233f, 0.01365175f, 
    -0.05976910f, 0.00331551f, -0.10935186f, 0.02790234f, -0.02352366f, 0.03513851f, -0.01837687f, -0.03265636f, 
    0.16422749f, -0.06706444f, 0.01609553f, -0.03369702f, -0.13799293f, 0.06742217f, 0.16706109f, 0.03383508f, 
    0.07835787f, 0.07826727f, -0.03904028f, 0.00615484f, 0.11402909f, 0.02080864f, -0.07410198f, 0.16728579f, 
    -0.01688497f, 0.00687191f, -0.06355514f, 0.05882531f, -0.11861582f, 0.07434454f, -0.06912464f, 0.12637316f, 
    0.01845743f, 0.12351825f, -0.05159382f, -0.03849880f, -0.17217657f, -0.08122111f, 0.00513981f, 0.02084575f, 
    0.01261389f, 0.08347850f, 0.11371382f, 0.01349030f, -0.10947125f, 0.07057826f, -0.08293805f, -0.00045844f, 
    -0.12238812f, -0.00320362f, 0.08306190f, -0.11821511f, -0.33357409f, -0.07331114f, -0.00177682f, 0.20243058f, 
    0.03303339f, 0.11198342f, 0.01728004f, 0.19459474f, 0.02015241f, 0.00231287f, -0.01027283f, 0.11543960f, 
    0.09554598f, 0.14205720f, 0.20437934f, 0.13591686f, -0.05285743f, -0.01934323f, -0.03976887f, 0.01286231f, 
    0.23274121f, 0.15803732f, 0.20900232f, 0.11528537f, -0.16713461f, -0.36557132f, 0.19451620f, -0.13290472f, 
    -0.11702660f, -0.04063966f, -0.09879608f, 0.10455465f, -0.03357014f, -0.31758407f, -0.09548486f, -0.22209585f, 
    -0.13281418f, 0.13877346f, 0.06251159f, -0.08487682f, 0.02018137f, 0.04670810f, -0.02204859f, -0.01965139f, 
    -0.01929882f, 0.05591865f, -0.05978072f, 0.13641790f, -0.18792495f, 0.07561801f, 0.16111828f, -0.02593023f, 
    -0.11072715f, 0.07071103f, 0.00983624f, 0.06547779f, -0.15003151f, -0.04210089f, 0.02831404f, -0.04940308f, 
    0.20196114f, -0.17369564f, 0.24903782f, 0.00536544f, 0.02048488f, 0.03922274f, 0.04013046f, 0.19364516f, 
    -0.21845256f, 0.04451622f, -0.08900101f, 0.07540151f, 0.07826396f, 0.05481032f, -0.07842628f, 0.02605754f, 
    -0.09513458f, 0.06299615f, 0.05166142f, -0.00093950f, 0.03235754f, 0.04288691f, 0.06062047f, 0.03446027f, 
    -0.62428695f, -0.04967381f, -0.15945545f, -0.15340690f, -0.07819960f, 0.01074071f, -0.02776994f, 0.15236592f, 
    -0.10252072f, -0.08836246f, 0.01800337f, -0.09177051f, -0.05124461f, -0.00724482f, 0.04817025f, 0.07334886f, 
    0.09375257f, 0.04837907f, 0.11397437f, -0.07343876f, -0.10367339f, 0.01656263f, -0.03395775f, -0.07873072f, 
    0.17042184f, 0.23734336f, -0.04122351f, -0.02078232f, 0.09881868f, 0.17647313f, 0.01475057f, -0.06058833f, 
    -0.05378469f, -0.02280999f, 0.04950832f, 0.04080214f, 0.30457681f, -0.22399002f, 0.09931460f, -0.21662118f, 
    0.04613863f, 0.03584410f, 0.04801662f, 0.18373092f, 0.06705419f, -0.11817554f, -0.01933342f, -0.03337863f, 
    -0.10502397f, 0.00032964f, 0.07119697f, -0.16160500f, -0.04685447f, -0.07994060f, 0.06366529f, -0.17272457f, 
    -0.01839706f, -0.05003967f, 0.07424412f, 0.06644852f, 0.04155668f, -0.11819996f, 0.08487229f, -0.00178539f, 
    0.06844626f, -0.04520828f, 0.09023943f, -0.02689015f, 0.04055122f, 0.17909896f, 0.16384347f, 0.11568272f, 
    -0.23473018f, -0.11436812f, 0.09076987f, 0.02469921f, -0.02771638f, 0.20752443f, 0.01485880f, 0.07576981f, 
    0.10163087f, 0.03258831f, 0.18110539f, -0.00448042f, -0.21572666f, -0.02231751f, -0.06070740f, -0.04962136f, 
    -0.06549043f, -0.01337616f, 0.04492095f, 0.14487623f, 0.06806764f, 0.02598054f, -0.01070379f, -0.10153079f, 
    0.05432097f, 0.15617789f, -0.07038266f, 0.06085337f, 0.01263335f, 0.10667336f, -0.03548030f, 0.03138926f, 
    0.12633716f, 0.08723520f, 0.14025958f, 0.23376852f, 0.00470589f, -0.01006181f, 0.01202987f, 0.02897450f, 
    0.08532547f, 0.09975363f, 0.05003329f, 0.22795548f, 0.07644589f, -0.10322998f, -0.01393854f, 0.04929625f, 
    -0.06608099f, -0.03767877f, -0.03016822f, -0.02526934f, 0.00311045f, 0.03801068f, 0.15606700f, 0.22936952f, 
    -0.07647028f, -0.08104493f, -0.00536493f, -0.07149234f, -0.13664311f, 0.21981782f, 0.23933412f, -0.03175491f, 
    -0.00729804f, -0.03492352f, 0.04496844f, 0.13970754f, -0.04526970f, -0.00783483f, 0.07005379f, -0.05360587f, 
    0.11218830f, -0.06382505f, 0.05795871f, -0.09103896f, -0.15867439f, -0.05655918f, 0.01142550f, -0.09407279f, 
    0.09073885f, 0.09947242f, 0.06625900f, 0.20065266f, -0.18216069f, 0.02811678f, -0.13373524f, 0.12088875f, 
    0.03512225f, 0.11454149f, 0.02925325f, -0.10447434f, 0.02072536f, -0.07811162f, -0.02213001f, 0.04483467f, 
    -0.24529544f, 0.01061124f, 0.04234593f, -0.04862389f, -0.00122124f, 0.07607850f, 0.04859716f, 0.10692298f, 
    -0.02935925f, 0.06862291f, -0.03324693f, -0.10879159f, -0.26639053f, -0.08048867f, 0.06240744f, -0.02949248f, 
    -0.00756689f, -0.03622195f, -0.03227879f, -0.03737726f, 0.13824131f, 0.10775515f, 0.24687938f, 0.05676650f, 
    -0.08877825f, 0.02588172f, 0.04966602f, 0.02656654f, -0.05248944f, -0.07700557f, -0.04329667f, -0.02619467f, 
    -0.12182087f, -0.02535371f, -0.14252947f, -0.07547390f, 0.08963028f, 0.08301642f, 0.01249407f, -0.12602305f, 
    0.03834167f, 0.03107963f, 0.10993810f, -0.02767907f, 0.14958255f, 0.07740869f, 0.06751201f, 0.24499775f, 
    -0.12396805f, 0.06047920f, -0.08010074f, 0.08732121f, -0.03829221f, -0.05982897f, -0.11858577f, 0.06159272f, 
    -0.05784843f, -0.01600720f, 0.20665248f, -0.27989164f, -0.39947778f, -0.02981882f, -0.06053988f, 0.15143563f, 
    0.01123671f, 0.04398879f, 0.01763155f, 0.02012650f, 0.17361559f, 0.06754895f, -0.01415051f, 0.01858001f, 
    -0.01857564f, -0.03273283f, -0.00462518f, 0.17086811f, -0.06744280f, 0.12529230f, 0.13538510f, 0.11699095f, 
    -0.09002373f, -0.16689746f, -0.01021578f, -0.11282324f, 0.18317176f, 0.04721360f, 0.02694284f, 0.13761568f, 
    0.04733290f, -0.00429396f, 0.05610118f, -0.12239611f, 0.00864465f, 0.06904726f, -0.01162961f, 0.11871666f, 
    -0.11365807f, -0.01000925f, -0.01712411f, -0.07234384f, -0.07514181f, 0.02403946f, -0.07358359f, -0.04823131f, 
    0.11216331f, 0.13391609f, 0.08724660f, 0.06101922f, -0.15168333f, -0.06770464f, 0.01320654f, -0.08412494f, 
    -0.04807535f, 0.11384118f, 0.00434084f, -0.02280695f, -0.04122419f, 0.14615986f, 0.00157646f, 0.05290968f, 
    -0.03129316f, -0.38215694f, 0.26706913f, -0.23912178f, 0.06538938f, 0.00928442f, -0.05294433f, 0.01624359f, 
    -0.14924322f, -0.02575241f, -0.04375051f, 0.02366756f, -0.07397415f, 0.11765942f, -0.12899268f, 0.04251108f, 
    -0.06750662f, 0.04277275f, -0.03789641f, 0.00619521f, -0.06870088f, 0.09743996f, -0.05735850f, -0.06272685f, 
    0.05387022f, -0.19827680f, 0.31207079f, -0.09079859f, 0.05118755f, -0.16156396f, 0.05152303f, 0.21295182f, 
    0.00726176f, 0.12465286f, -0.01314308f, -0.04054800f, 0.16927692f, 0.09944892f, -0.00345553f, 0.14597696f, 
    0.03311297f, 0.06398057f, 0.00394851f, -0.13500059f, -0.05218367f, 0.01155357f, 0.12007676f, 0.09382609f, 
    0.13029377f, 0.06372081f, 0.14829901f, 0.12856485f, 0.19656584f, 0.05054038f, 0.02326852f, 0.13941436f, 
    0.10350478f, 0.05511755f, 0.00187167f, -0.10793317f, 0.18988578f, -0.03471644f, -0.05351665f, 0.15907596f, 
    0.06423053f, 0.06138299f, 0.07872559f, 0.00956989f, -0.02119720f, -0.02930633f, -0.05882267f, -0.09436801f, 
    0.35266477f, 0.12163670f, 0.21051779f, 0.16982904f, 0.17914538f, -0.05843531f, 0.15514866f, 0.10580623f, 
    -0.05904273f, 0.02469355f, 0.04219427f, 0.14390935f, 0.01040871f, 0.02392447f, 0.08061582f, -0.00808462f, 
    0.06613623f, 0.02518648f, 0.02113191f, -0.08733022f, 0.01317922f, -0.01058040f, -0.01997450f, -0.16434962f, 
    -0.13622859f, -0.05079050f, -0.09507047f, -0.07899952f, -0.05873539f, -0.03869622f, -0.03915425f, -0.07057579f, 
    0.05878471f, 0.21700473f, 0.05468864f, 0.02667174f, 0.07973580f, 0.17782345f, -0.10363850f, 0.21293090f, 
    0.11564085f, 0.13739486f, -0.01941068f, 0.16711451f, 0.02007254f, 0.04432592f, 0.08005612f, 0.13734953f, 
    -0.09328192f, -0.03247276f, -0.01984965f, -0.00714348f, 0.00544359f, -0.03696621f, 0.00370715f, 0.01878861f, 
    -0.05315424f, 0.01142929f, -0.04738452f, 0.03891237f, 0.02990464f, 0.01192696f, -0.01626630f, -0.10560594f, 
    -0.04085527f, 0.04669304f, -0.07144655f, -0.06404995f, -0.03887004f, -0.07244477f, 0.05047835f, 0.05720068f, 
    0.18966922f, 0.10836502f, 0.04463997f, 0.20330788f, 0.19511388f, 0.00435337f, -0.05112519f, 0.02304970f, 
    0.11709994f, 0.11607245f, 0.09730756f, 0.19893984f, 0.08637255f, 0.13916130f, 0.03787470f, -0.08316770f, 
    0.04783605f, -0.03345525f, 0.03180991f, -0.12458353f, -0.14943893f, -0.00060022f, -0.05125950f, -0.16206235f, 
    0.05547895f, -0.02850025f, -0.08539823f, -0.12251272f, 0.09893078f, 0.02664423f, 0.03587858f, -0.07688372f, 
    0.00111976f, -0.07409833f, -0.06266382f, -0.02962103f, 0.06780764f, 0.00262582f, -0.06399210f, -0.01795407f, 
    0.09539369f, -0.02899430f, -0.11768504f, 0.03335445f, -0.01560262f, -0.11060128f, -0.06657478f, -0.16118966f, 
    -0.15132242f, 0.21527149f, 0.02861600f, 0.07293129f, -0.11568011f, -0.06794403f, 0.02211449f, 0.03421688f, 
    -0.04800245f, -0.07623170f, -0.03927672f, -0.07997855f, 0.11011562f, -0.18874069f, -0.02772495f, -0.21647249f, 
    0.06629276f, -0.02998180f, -0.00804961f, 0.11787660f, 0.01402146f, 0.03434065f, 0.09903958f, 0.07884222f, 
    -0.02675158f, 0.09793848f, 0.01400390f, -0.01894858f, 0.03158023f, 0.02251096f, 0.02870024f, -0.10895385f, 
    0.03920646f, -0.03891492f, 0.05275426f, 0.05168163f, -0.23270512f, -0.27254507f, -0.02947250f, -0.05758325f, 
    -0.12136458f, -0.02966283f, -0.10307492f, -0.03388161f, 0.13354337f, -0.01281009f, 0.16515745f, 0.10768832f, 
    0.01792382f, 0.02398711f, 0.11589573f, 0.14354280f, -0.03303740f, 0.01603460f, -0.07767902f, 0.06295409f, 
    0.05289191f, 0.09566879f, 0.19253683f, 0.09784708f, 0.10088158f, 0.13969065f, -0.05314213f, -0.01862658f, 
    -0.02327523f, 0.05569356f, -0.01723365f, -0.04315128f, -0.00324264f, -0.07419716f, 0.04393940f, 0.13113943f, 
    0.04474575f, -0.11350823f, 0.12554963f, -0.16268106f, 0.01574567f, -0.07483636f, 0.14055641f, 0.11643164f, 
    -0.00042374f, -0.09873636f, -0.03458367f, -0.16317844f, 0.03792582f, 0.06844107f, 0.07628968f, 0.07331618f, 
    0.12857865f, -0.05383344f, 0.07538485f, 0.25878301f, 0.05871430f, 0.16803934f, -0.00455321f, 0.08346707f, 
    -0.05661567f, -0.07915369f, 0.07405888f, -0.08033208f, -0.09900924f, -0.05642355f, -0.06792002f, -0.03322601f, 
    -0.07838566f, -0.02025147f, -0.04919636f, -0.20929556f, 0.10960685f, -0.08467162f, 0.26683307f, 0.02766572f, 
    -0.00729195f, -0.05153108f, -0.00163897f, -0.00452680f, -0.03653047f, -0.02141803f, -0.02571980f, -0.00105121f, 
    0.23701775f, 0.22402723f, 0.05026051f, 0.13381292f, -0.03102825f, -0.04253062f, -0.02563294f, 0.07770348f, 
    0.05355996f, -0.01133432f, 0.04485226f, 0.02715076f, -0.00187250f, -0.01412279f, 0.06986280f, 0.12971319f, 
    -0.07080597f, -0.06326293f, -0.10459756f, -0.00890931f, 0.18403138f, -0.02128362f, 0.04509503f, 0.21655755f, 
    0.07214142f, 0.00011977f, -0.07536262f, -0.03082796f, -0.03837903f, -0.03242206f, 0.06343225f, -0.08177503f, 
    0.11979464f, 0.06956737f, 0.01546085f, 0.12613854f, 0.33008346f, -0.06849298f, 0.20174718f, -0.03329130f, 
    -0.00752269f, 0.06683222f, 0.09670709f, 0.06454281f, 0.10630905f, 0.14430746f, 0.08383694f, -0.10765620f, 
    -0.02306033f, 0.30979735f, -0.00747719f, 0.21298672f, -0.11388167f, 0.08219112f, -0.05225413f, 0.13029039f, 
    -0.01948683f, -0.04306962f, -0.00132908f, 0.11502890f, -0.01100279f, 0.04969148f, 0.05354966f, 0.11500784f, 
    0.05177588f, 0.02302368f, 0.11136123f, -0.05201861f, 0.00296685f, -0.00299478f, 0.02642987f, -0.01614654f, 
    -0.17587541f, -0.12317528f, -0.15209462f, -0.09258156f, -0.06169460f, -0.01588661f, -0.05937090f, -0.07270221f, 
    -0.05912642f, -0.12528405f, -0.10458837f, -0.30532092f, -0.21293071f, -0.16430834f, -0.10442946f, -0.07209942f, 
    -0.12693565f, 0.12979133f, -0.01678450f, -0.06060864f, -0.10213488f, -0.02529484f, -0.01854284f, -0.07900354f, 
    -0.05501461f, -0.08473228f, -0.31986454f, -0.08834973f, -0.14450097f, -0.06756604f, 0.00592100f, -0.05505233f, 
    0.01959230f, -0.08738604f, -0.03051719f, 0.03675844f, -0.11726233f, 0.04637433f, 0.04973551f, -0.13584796f, 
    -0.04162716f, 0.04032931f, -0.02007943f, 0.08960886f, -0.10347194f, -0.08463251f, -0.14298382f, -0.14124478f, 
    0.22294439f, 0.21126677f, -0.01286173f, 0.02656687f, 0.03435316f, 0.06493135f, -0.12859520f, 0.03409556f, 
    0.05243476f, -0.03807104f, 0.10341391f, 0.10895190f, -0.27661008f, -0.11801571f, 0.01175368f, -0.07390483f, 
    0.03225563f, -0.01338512f, 0.03511609f, -0.00667327f, 0.00824734f, 0.02863668f, -0.01027548f, 0.00737868f, 
    0.37436765f, -0.22279240f, 0.37227380f, 0.18037942f, -0.10923494f, 0.10769433f, -0.00925598f, 0.17597169f, 
    -0.09790356f, -0.09908527f, -0.04152359f, -0.10053568f, -0.12767914f, 0.04969805f, -0.08973370f, 0.11335386f, 
    0.00650327f, 0.02487192f, -0.06305756f, -0.01347156f, 0.04394522f, 0.05698199f, 0.10137831f, 0.07051965f, 
    -0.35911083f, 0.06064726f, -0.06982560f, -0.04378300f, -0.06667015f, -0.07268015f, -0.02680293f, 0.06890391f, 
    -0.07094847f, 0.02963944f, -0.00204596f, 0.00232308f, 0.13579488f, 0.08124045f, 0.05446361f, 0.34487432f, 
    0.09687011f, -0.05925024f, 0.04538992f, -0.05754448f, -0.08352376f, 0.07763213f, 0.00868608f, 0.00302642f, 
    0.15839627f, 0.47696161f, 0.08265675f, 0.21772519f, 0.14004683f, 0.18610841f, -0.10499352f, -0.08385903f, 
    0.03054745f, -0.01036381f, -0.01295282f, -0.01031104f, 0.02704098f, -0.16848756f, 0.34009591f, -0.28021896f, 
    0.07133618f, -0.01074625f, -0.09172364f, -0.16261277f, 0.03140029f, 0.04663791f, 0.07315865f, 0.01768580f, 
    -0.20504360f, -0.10298632f, 0.02260748f, -0.02873634f, -0.03923779f, -0.11707290f, 0.04822250f, -0.02049477f, 
    -0.04510792f, 0.06178990f, 0.09309969f, 0.06476685f, 0.02015738f, -0.09761788f, -0.03176416f, -0.00281327f, 
    -0.02116585f, -0.00378973f, 0.05162120f, 0.02983926f, -0.03800544f, -0.08736706f, 0.10205752f, 0.12312458f, 
    0.32695311f, 0.02171248f, 0.05204452f, 0.06407589f, -0.00747486f, 0.01831685f, -0.02705844f, 0.10057574f, 
    -0.07666449f, 0.10538577f, 0.07027601f, -0.04043019f, -0.01121946f, -0.16787006f, 0.17280199f, 0.13721712f, 
    0.02738256f, 0.00239458f, 0.02939948f, 0.10380664f, 0.04337377f, 0.05929173f, 0.04814249f, -0.01273562f, 
    0.03578231f, 0.19604199f, -0.27227759f, 0.12856413f, -0.01598927f, 0.00552332f, -0.04241270f, 0.11157439f, 
    -0.13105905f, 0.05868398f, 0.10606064f, 0.15093933f, 0.03022449f, 0.09319535f, -0.04535513f, 0.22318473f, 
    -0.08405353f, 0.13393594f, -0.03951123f, 0.06084515f, 0.14913656f, 0.01950017f, -0.02508483f, -0.13355517f, 
    -0.13511290f, 0.02915117f, -0.04825088f, 0.09043557f, 0.13624935f, 0.05103534f, 0.16185305f, -0.02267131f, 
    -0.04467051f, -0.08148295f, -0.04820148f, -0.02045699f, 0.03113093f, -0.01318269f, 0.31115410f, 0.14487928f, 
    -0.06972330f, -0.01652895f, 0.01931380f, 0.05006812f, 0.10880109f, 0.06848354f, 0.02461379f, 0.03715985f, 
    0.16477649f, -0.06557466f, 0.08386857f, 0.02898834f, -0.02302881f, 0.01362896f, -0.03326124f, -0.09007602f, 
    -0.05305612f, -0.03173885f, -0.04534458f, 0.03527668f, -0.29619682f, 0.01014394f, -0.23318246f, 0.39119381f, 
    -0.05286198f, 0.10942328f, -0.06092423f, 0.01538445f, -0.03492313f, -0.00894849f, 0.04741136f, -0.00042476f, 
    -0.09274830f, 0.19453910f, 0.15293524f, 0.16695236f, -0.12567940f, 0.06057427f, 0.03661666f, 0.08085379f, 
    0.03819781f, 0.09114677f, -0.00436208f, -0.00800338f, -0.19074589f, -0.01859367f, 0.09330339f, -0.14898486f, 
    0.00526579f, -0.00123526f, 0.06593639f, 0.06799946f, 0.05277138f, 0.11819502f, 0.13347302f, 0.10626061f, 
    0.01753902f, 0.02543812f, 0.03514306f, -0.07643748f, -0.01519689f, -0.05487002f, -0.05338768f, 0.00134855f, 
    0.05074985f, 0.14706917f, -0.00463735f, 0.01132447f, 0.12246515f, 0.01098975f, 0.00539509f, -0.11854385f, 
    -0.09030557f, -0.01200198f, 0.07981521f, -0.02501228f, -0.01898178f, 0.06744761f, 0.00254309f, 0.16197820f, 
    -0.10464064f, 0.35211104f, -0.10438532f, 0.05133112f, -0.08624290f, 0.09212460f, -0.10967337f, 0.03854042f, 
    0.03215814f, 0.11353896f, 0.07459472f, -0.05159312f, -0.14945640f, 0.23012473f, -0.00099652f, 0.20990610f, 
    0.03332846f, 0.00632938f, 0.07013321f, -0.00017792f, 0.02544076f, 0.05443956f, 0.01821297f, -0.01376502f, 
    -0.12939262f, -0.12207839f, -0.09361593f, 0.17100541f, -0.11137401f, -0.15062936f, -0.01744322f, -0.03920196f, 
    -0.04614246f, -0.02819023f, -0.06625608f, -0.03709428f, 0.39284268f, -0.06812152f, 0.01006295f, 0.10691692f, 
    -0.01598483f, 0.01919802f, -0.06658787f, -0.00643631f, -0.06199551f, 0.07962304f, -0.00149177f, -0.08182702f, 
    0.01574091f, 0.00628587f, -0.12453939f, 0.03598074f, 0.03799113f, 0.09479070f, 0.01496545f, 0.01256541f, 
    0.06011143f, 0.13473837f, 0.06707242f, -0.01423160f, -0.11608414f, -0.02885697f, -0.01621173f, -0.00867299f, 
    -0.04983152f, 0.02130037f, -0.05242636f, -0.05494095f, -0.01017331f, 0.09275964f, 0.00071555f, 0.02436214f, 
    0.13506952f, -0.24200596f, 0.34163091f, -0.16847937f, 0.21110596f, -0.06710517f, -0.12566392f, -0.00186720f, 
    0.05894933f, -0.03501744f, 0.01035514f, 0.05123302f, -0.22202264f, 0.17121346f, 0.18374947f, 0.37841630f, 
    -0.08508681f, -0.11792548f, 0.07408667f, -0.26613989f, 0.04654103f, 0.23718810f, -0.06355233f, -0.00011444f, 
    0.62724376f, -0.30494681f, 0.16274808f, -0.17414768f, 0.00144270f, -0.15366565f, 0.08297254f, 0.03264796f, 
    -0.03693696f, 0.11541723f, -0.05720834f, -0.07478030f, 0.12406954f, 0.33107927f, 0.08050063f, 0.16674060f, 
    -0.00750051f, 0.18117891f, -0.04468355f, -0.03720030f, -0.03440413f, -0.03638656f, -0.03066785f, -0.06326229f, 
    -0.10069396f, 0.11387017f, 0.09812593f, 0.07306702f, 0.07780185f, 0.00186947f, 0.03342243f, 0.07096982f, 
    0.09218892f, 0.04492863f, 0.05845152f, -0.00319019f, -0.10365734f, 0.05095680f, 0.00542555f, 0.10112165f, 
    0.04043158f, 0.07042104f, 0.03280962f, -0.10845523f, 0.07753284f, 0.00270333f, 0.02777428f, 0.06716697f, 
    0.27420041f, 0.08741347f, 0.11304507f, -0.07198839f, -0.00866815f, 0.10904103f, -0.00415765f, 0.11817863f, 
    -0.12345251f, -0.05764561f, 0.07357811f, 0.08492441f, -0.04849641f, -0.07669968f, 0.09520120f, 0.24509686f, 
    0.04938697f, 0.10960507f, 0.06373584f, -0.11567449f, 0.09121369f, 0.15315503f, 0.07405189f, -0.02870729f, 
    -0.05865309f, 0.02819159f, -0.10357704f, -0.00553745f, 0.00415895f, 0.01746058f, 0.02220742f, -0.01215020f, 
    0.11364333f, 0.09400681f, -0.03427843f, 0.07261568f, 0.10373641f, 0.22986101f, 0.08581167f, 0.23829138f, 
    -0.04929828f, 0.22190800f, 0.04072677f, 0.02679880f, -0.08361982f, 0.08793457f, -0.09834433f, 0.08732159f, 
    -0.11937211f, 0.01879379f, -0.04638454f, -0.06242864f, 0.08040051f, 0.02198010f, -0.06485530f, -0.05341544f, 
    -0.14324391f, 0.06398793f, -0.05734507f, 0.05697989f, 0.17447723f, -0.01465957f, -0.11047226f, 0.04168284f, 
    -0.04128966f, 0.11311708f, -0.05337731f, 0.03185898f, -0.03816900f, -0.02385036f, 0.09652184f, 0.01675760f, 
    0.14797594f, 0.03549461f, 0.11515323f, 0.22262707f, 0.16181445f, -0.11844449f, -0.08482134f, -0.05307652f, 
    0.09191942f, 0.11728440f, -0.05277451f, -0.05275025f, 0.09417598f, -0.09635451f, 0.16802411f, 0.13749987f, 
    0.00739254f, -0.15862538f, -0.00020679f, -0.19640611f, -0.10054720f, -0.02383118f, -0.13777821f, -0.10907381f, 
    0.18925075f, 0.13371947f, 0.12357297f, 0.03418772f, 0.07378989f, 0.10632087f, 0.00046631f, -0.14707372f, 
    0.01396434f, -0.06096496f, -0.05074187f, 0.08399168f, 0.00881541f, 0.01529490f, 0.01947342f, 0.08229146f, 
    0.09016073f, 0.02799598f, -0.11056245f, -0.09786537f, 0.13739219f, 0.02576254f, -0.03662417f, 0.08347291f, 
    -0.22901747f, 0.38154885f, -0.11928793f, 0.18002544f, -0.15621556f, -0.08631205f, -0.05619269f, 0.03138028f, 
    -0.02175011f, 0.07840919f, -0.07628269f, -0.06262758f, 0.27544972f, -0.04910759f, 0.06256577f, -0.21254714f, 
    0.00054216f, -0.02890882f, -0.02222550f, -0.03429558f, -0.01637955f, 0.08108710f, 0.05639675f, 0.02503910f, 
    0.03931462f, -0.23483333f, -0.04507226f, 0.11739174f, 0.12968644f, 0.01508644f, -0.03648011f, -0.13167772f, 
    0.07798755f, 0.07838198f, -0.00219597f, 0.09208713f, -0.27425542f, -0.08569905f, -0.11726556f, -0.12179531f, 
    -0.03467843f, -0.03896934f, 0.00361352f, 0.06825861f, 0.18885605f, 0.11568666f, 0.01101676f, 0.16161074f, 
    0.09589724f, -0.10535003f, 0.16576001f, 0.08546885f, -0.02288572f, 0.12009830f, -0.04958040f, -0.04644157f, 
    -0.09314831f, 0.15077837f, 0.21014462f, 0.07943392f, -0.19087562f, 0.12883075f, -0.06418908f, 0.15861705f, 
    -0.10128750f, 0.02306320f, 0.04088296f, 0.07125502f, 0.03147338f, 0.02112624f, 0.09808834f, -0.01376355f, 
    0.06591249f, -0.04675141f, -0.06097169f, -0.13246670f, 0.07895667f, 0.00792753f, 0.00682849f, -0.11222550f, 
    0.04032900f, 0.07811501f, 0.04715852f, 0.07352401f, -0.25268990f, 0.08147874f, -0.11430694f, 0.03710713f, 
    -0.04624178f, 0.00817642f, 0.07923736f, 0.04854536f, 0.01991801f, 0.05637587f, 0.05133982f, 0.07028589f, 
    0.09967773f, 0.05918089f, 0.17806992f, -0.09164026f, -0.11223297f, -0.07245263f, -0.10851256f, 0.04006870f, 
    0.11150124f, 0.06157484f, 0.01076486f, 0.01486983f, 0.07555027f, -0.04232386f, 0.35625687f, -0.09513970f, 
    -0.03554465f, -0.03817727f, -0.11162677f, -0.13014455f, 0.00881973f, 0.04445543f, 0.01731973f, 0.04196446f, 
    0.05508592f, 0.11737922f, 0.23420316f, -0.03527010f, 0.00534527f, -0.01851108f, -0.01952066f, -0.02573946f, 
    -0.02823851f, -0.06727043f, 0.00601610f, -0.01918889f, -0.14806765f, 0.15729496f, 0.02777308f, 0.05295766f, 
    0.12343722f, -0.05214402f, -0.03002521f, 0.01678996f, -0.03593286f, 0.01966833f, -0.03754927f, 0.17426273f, 
    -0.19951411f, -0.14667852f, -0.17703593f, 0.23958682f, -0.07559122f, 0.06461307f, -0.00187088f, -0.01513263f, 
    0.05817267f, 0.06748335f, -0.02337030f, -0.00805106f, 0.22783002f, -0.14394437f, 0.24678440f, 0.00114786f, 
    -0.05428996f, 0.05946735f, 0.03144822f, 0.01753736f, 0.04046284f, 0.09375185f, -0.01316626f, -0.07020625f, 
    -0.11028040f, 0.26959714f, -0.14865997f, 0.24940804f, -0.19176587f, 0.00066716f, -0.03405131f, 0.06903072f, 
    -0.04395021f, 0.01681199f, -0.13641402f, 0.05695553f, -0.13890275f, -0.11593223f, 0.10186581f, 0.00994568f, 
    -0.12103409f, 0.01633231f, -0.17330174f, 0.09161954f, 0.05057769f, 0.03327145f, 0.07166426f, -0.03203874f, 
    -0.15389690f, 0.05485415f, -0.07826098f, 0.03098394f, -0.04048774f, 0.00475328f, -0.09907057f, -0.07581287f, 
    0.09320915f, 0.08146489f, -0.05546830f, -0.07952087f, -0.17587699f, -0.22004277f, -0.17022316f, 0.11134124f, 
    0.06474826f, 0.05831599f, 0.03873469f, 0.00896126f, -0.02187345f, 0.04471972f, -0.03945803f, 0.04478012f, 
    -0.03855341f, 0.01201738f, -0.18213722f, -0.21744263f, 0.04339618f, 0.01842029f, -0.00422266f, 0.01695924f, 
    -0.04535882f, -0.05196764f, -0.03822407f, 0.08980013f, 0.27875289f, -0.04495831f, 0.02910517f, -0.13345239f, 
    0.08457004f, -0.05669321f, -0.05613651f, -0.00955332f, -0.15749313f, -0.07051916f, -0.14802875f, -0.00569645f, 
    -0.19188902f, 0.45155209f, -0.12123907f, 0.03358738f, -0.09756501f, -0.09061547f, -0.07573158f, -0.02848207f, 
    -0.03279955f, 0.02247632f, 0.07317131f, 0.13353021f, -0.38151485f, 0.00162537f, -0.02919591f, 0.01026697f, 
    -0.04303392f, -0.01237607f, 0.16620144f, 0.01153449f, -0.01469293f, 0.07971586f, 0.02219633f, 0.10883558f, 
    -0.03224870f, 0.10213885f, 0.01303281f, 0.00246029f, 0.11142123f, 0.00418836f, -0.01625598f, 0.04725275f, 
    -0.06245812f, 0.01634722f, -0.07442438f, 0.02874722f, 0.21018806f, 0.06984282f, -0.03131864f, -0.03586159f, 
    0.02993960f, 0.09599057f, 0.18874091f, -0.06069985f, -0.05287922f, -0.02704211f, -0.07161532f, -0.04799660f, 
    -0.20705698f, -0.28490034f, -0.25015670f, -0.20471321f, 0.08227321f, 0.01958530f, -0.03033097f, 0.02571964f, 
    0.05980376f, -0.05731627f, 0.06373344f, -0.08387016f, -0.17384782f, -0.14529349f, -0.03848014f, -0.19653931f, 
    0.04364615f, 0.06886557f, 0.12706146f, -0.00190223f, 0.02733904f, 0.05274126f, 0.04633793f, -0.04630890f, 
    0.14795670f, -0.20995460f, -0.17779027f, -0.22987010f, -0.01520050f, 0.01578031f, 0.13519424f, -0.00019476f, 
    -0.10277460f, -0.07803915f, 0.04382726f, 0.04436022f, 0.09734046f, 0.05856111f, -0.10817497f, 0.22895129f, 
    0.00070952f, 0.12064604f, 0.03443306f, 0.14863300f, 0.06301931f, -0.14724472f, 0.00585292f, -0.11323831f, 
    0.15105318f, 0.03545404f, 0.08947158f, 0.11531927f, 0.06792732f, 0.03789049f, 0.06532974f, -0.01827933f, 
    0.01746995f, 0.01923611f, -0.00005269f, -0.05429330f, 0.08445982f, 0.01819375f, 0.20576613f, -0.04795596f, 
    0.07149848f, -0.04942483f, -0.02646543f, -0.03912658f, -0.06113076f, 0.15820391f, 0.03523926f, 0.09315234f, 
    -0.54368293f, -0.19197001f, -0.18903661f, 0.09235996f, 0.05353567f, 0.15810825f, 0.12537928f, -0.03498550f, 
    0.19711380f, -0.03810140f, 0.15149942f, 0.07715031f, -0.24973033f, 0.15393452f, -0.29503548f, -0.17779411f, 
    -0.01064267f, 0.07814030f, 0.06073097f, -0.03949613f, 0.17812979f, 0.09596391f, -0.03574453f, -0.02454610f, 
    0.05277225f, -0.02911215f, 0.18894897f, -0.08356401f, 0.02730418f, 0.00886742f, -0.01095759f, -0.05746964f, 
    0.14286557f, 0.02840514f, 0.07206965f, 0.16817775f, -0.01025695f, -0.19721109f, -0.06643265f, -0.02748959f, 
    0.16501412f, 0.03730043f, 0.17286699f, 0.02627273f, 0.04807124f, 0.04288964f, 0.04750349f, 0.14752555f, 
    -0.06636440f, -0.09346350f, -0.01700509f, -0.00361761f, -0.05721099f, 0.11172029f, 0.07786159f, 0.28727636f, 
    -0.05475007f, -0.05477478f, -0.04744100f, -0.12586483f, -0.12266906f, 0.17597185f, -0.24287061f, -0.08410408f, 
    0.09888154f, -0.05860659f, 0.12509927f, 0.01402584f, -0.00639331f, -0.01690322f, 0.09842031f, 0.02017602f, 
    -0.02976071f, 0.21765523f, -0.07003245f, 0.04729959f, -0.00092594f, -0.02452238f, -0.11084542f, -0.07961702f, 
    -0.00447795f, 0.05244420f, 0.02378855f, 0.02061719f, 0.11725675f, 0.10382664f, 0.06086953f, -0.17681567f, 
    0.08096652f, -0.00023460f, 0.04887505f, 0.03057600f, 0.08299446f, -0.02673880f, -0.08511645f, -0.02139439f, 
    -0.18786308f, -0.40068254f, -0.12552062f, -0.07558165f, 0.11131286f, 0.03390267f, -0.01401996f, -0.01048305f, 
    0.17124599f, -0.03429500f, 0.03296880f, -0.14606814f, -0.01854652f, -0.04148646f, -0.05444805f, 0.09302296f, 
    0.03328130f, 0.00147414f, -0.04879709f, -0.12559530f, 0.06323887f, 0.06724079f, 0.19214903f, 0.14138389f, 
    -0.00426282f, 0.10568436f, 0.10178830f, 0.09209260f, 0.01647432f, 0.02606157f, -0.06423248f, -0.04653630f, 
    -0.04600607f, -0.05717529f, -0.03480155f, -0.05747373f, 0.06723769f, 0.03909873f, 0.07236207f, 0.12679802f, 
    0.18688841f, 0.01073218f, 0.00813985f, 0.01501661f, 0.05528630f, -0.00187711f, 0.17177184f, 0.09781969f, 
    0.20597875f, -0.29322979f, 0.06529970f, 0.00832296f, -0.04084148f, -0.03978827f, 0.02204705f, -0.02888536f, 
    -0.13615650f, -0.00432051f, 0.03314859f, -0.26851633f, -0.28050596f, -0.37724757f, -0.19897874f, -0.00672945f, 
    0.00740445f, 0.07282458f, 0.00282830f, -0.00579650f, 0.21753299f, -0.00006342f, 0.03803258f, 0.00963286f, 
    0.10401240f, 0.12425147f, -0.02129846f, -0.04315134f, 0.13127258f, 0.21524768f, 0.16619343f, 0.15517832f, 
    -0.09419630f, -0.04673237f, 0.13060670f, -0.08745500f, -0.00052273f, -0.21057251f, 0.15156315f, 0.03544211f, 
    0.06798862f, 0.17694847f, 0.03367799f, -0.08123044f, 0.05713158f, 0.08676378f, 0.03462937f, 0.16388690f, 
    -0.05035978f, 0.03202765f, 0.09492505f, -0.02211220f, -0.00262509f, 0.01014415f, -0.04314742f, 0.00340547f, 
    0.04234132f, -0.00620329f, -0.02741769f, 0.09581208f, 0.04619522f, -0.09711476f, -0.07035018f, -0.07554965f, 
    0.05752853f, 0.08760006f, -0.00171156f, -0.07595524f, 0.05891323f, 0.13053498f, 0.08601761f, 0.00394505f, 
    -0.21901220f, 0.11094276f, 0.05550203f, 0.19959079f, -0.06379366f, 0.03701609f, -0.08923225f, 0.11028636f, 
    -0.11041141f, 0.05709152f, 0.02788313f, 0.04998305f, 0.08910167f, -0.09958170f, -0.24449243f, -0.18167259f, 
    0.08856410f, 0.22184002f, -0.00597185f, 0.15117237f, 0.05024359f, -0.08085922f, 0.06934882f, -0.09046786f, 
    -0.34354731f, 0.03308596f, 0.27300194f, 0.06510747f, 0.01322154f, 0.00642126f, 0.01335698f, 0.18862936f, 
    -0.04527261f, -0.04610642f, 0.00998617f, 0.09226749f, 0.13419659f, -0.43152821f, -0.03594783f, -0.04448596f, 
    0.05402982f, -0.04475494f, 0.12150847f, -0.04508530f, -0.06014928f, -0.00437474f, 0.11411039f, 0.15579048f, 
    0.23614886f, -0.15453805f, 0.14148548f, 0.05742110f, 0.08116368f, 0.11875097f, 0.06167314f, 0.04404384f, 
    0.12134271f, 0.01104122f, 0.03760869f, -0.11051024f, 0.19206661f, -0.08187841f, -0.08710319f, 0.10267487f, 
    0.07161973f, 0.05719015f, -0.04414691f, 0.13694611f, -0.11147451f, -0.09124555f, -0.01887691f, -0.19471951f, 
    0.18952958f, -0.01959339f, 0.22274622f, 0.23344226f, 0.15732479f, -0.11057309f, 0.01004330f, -0.05326150f, 
    0.02987074f, 0.15227780f, 0.10540670f, 0.14761189f, -0.00610679f, 0.09905956f, -0.00184030f, -0.15469745f, 
    0.00552631f, -0.11411154f, -0.03583039f, 0.05905303f, -0.01900452f, -0.04391481f, 0.08233266f, -0.07985350f, 
    -0.01437914f, -0.07975537f, -0.02341791f, -0.06643132f, -0.05414970f, 0.00073703f, -0.06273666f, -0.09443164f, 
    0.11190636f, 0.15582068f, 0.09088469f, 0.07261977f, -0.07036793f, -0.28446323f, -0.09283891f, 0.12229514f, 
    0.15174465f, -0.05015982f, 0.05822916f, 0.22424018f, 0.28635657f, -0.08022781f, 0.14831142f, 0.21530095f, 
    0.03764763f, -0.03278679f, -0.01153862f, -0.02034349f, 0.03162018f, -0.03029121f, -0.01599571f, 0.01498196f, 
    0.16935822f, -0.06251659f, 0.02187544f, -0.00456926f, -0.01064438f, 0.14129385f, 0.18337287f, -0.05708085f, 
    0.11421797f, -0.02724274f, -0.09591000f, -0.10923011f, -0.00078773f, -0.05492344f, 0.06256602f, -0.00276635f, 
    0.00288460f, -0.02298329f, 0.09610396f, 0.07620132f, 0.19911155f, 0.03930637f, -0.10018100f, 0.11951458f, 
    -0.06929292f, -0.10825784f, 0.14209285f, 0.10488886f, -0.02031916f, 0.19160894f, -0.04149570f, -0.13773526f, 
    0.02916623f, 0.03135907f, 0.08731317f, 0.05820676f, -0.07493148f, 0.01044549f, 0.04397078f, -0.07684877f, 
    -0.20966150f, -0.30602837f, -0.14903922f, -0.11640908f, 0.14866120f, 0.05373925f, -0.06868052f, 0.09616380f, 
    0.00927644f, -0.12552981f, 0.02645280f, 0.01503840f, 0.15155141f, -0.06621822f, 0.01114984f, -0.11644047f, 
    0.06660865f, -0.03468348f, 0.02432415f, 0.14547648f, -0.04934845f, -0.15097739f, 0.04697164f, -0.05386299f, 
    0.33100137f, 0.09128256f, 0.38082531f, -0.12219854f, 0.07312275f, -0.08703286f, 0.06894737f, -0.01496307f, 
    -0.02423901f, -0.01969783f, -0.00818818f, -0.01067649f, -0.03231450f, -0.06220129f, -0.01441488f, 0.12509382f, 
    0.21309388f, -0.02212950f, -0.09713410f, -0.09082089f, -0.01544119f, 0.01476884f, 0.03879210f, 0.06868053f, 
    -0.06483665f, 0.19142362f, 0.13744654f, -0.08665550f, -0.03182895f, 0.02803136f, 0.07671161f, 0.03004959f, 
    0.03502847f, -0.03179618f, 0.24531108f, 0.03672397f, 0.31438562f, -0.14108658f, 0.02857557f, 0.00922542f, 
    -0.01890164f, -0.05332220f, -0.03377065f, -0.09199128f, 0.06792153f, -0.07894733f, 0.17965925f, -0.01473311f, 
    -0.06691704f, 0.26165751f, 0.03995003f, -0.01865321f, 0.12664659f, 0.04505448f, -0.09832025f, -0.09516661f, 
    0.11334614f, -0.03625872f, 0.00013543f, -0.05514801f, 0.27172875f, -0.03438443f, 0.02328393f, -0.03292817f, 
    0.12389281f, 0.09684183f, 0.02207154f, -0.00895535f, -0.01293638f, 0.00188061f, 0.00963790f, 0.07316505f, 
    0.08654199f, 0.06535874f, 0.21109517f, -0.02003206f, 0.03344933f, -0.09514389f, 0.10090818f, 0.12807907f, 
    0.03456612f, -0.07185715f, -0.04734910f, -0.17321028f, 0.45680606f, -0.07735394f, 0.21806902f, -0.05052362f, 
    0.12148378f, -0.02013862f, -0.00732966f, 0.14812160f, -0.02356751f, 0.11069642f, 0.08559442f, 0.08916762f, 
    0.03242654f, -0.09980806f, 0.10348894f, 0.07910153f, -0.05256310f, 0.03591267f, 0.15820299f, -0.05675169f, 
    0.04323035f, -0.02363947f, 0.11405019f, -0.00389300f, 0.20809729f, 0.10148895f, 0.07347470f, 0.31293139f, 
    0.05222725f, -0.06949122f, -0.03724295f, 0.04092291f, -0.03427069f, -0.08876275f, -0.01160932f, -0.00896038f, 
    0.28533164f, 0.26014945f, -0.06105896f, 0.22268584f, 0.00762420f, -0.07334930f, -0.03402233f, -0.00828555f, 
    0.03360419f, -0.01688354f, 0.01812096f, 0.13969193f, 0.11928575f, -0.05104193f, 0.11133508f, 0.10473553f, 
    -0.08199687f, -0.01885202f, -0.02692938f, -0.05556810f, 0.21029863f, -0.09576125f, 0.04552376f, 0.09614662f, 
    0.15006725f, 0.05174010f, 0.08366210f, -0.26221105f, 0.04609558f, 0.03204688f, 0.03598804f, -0.06626774f, 
    0.07323218f, 0.03398492f, 0.10844028f, 0.17802414f, 0.16302796f, 0.09553778f, 0.03949086f, 0.09314970f, 
    0.03795984f, 0.02396921f, 0.05805513f, 0.16625352f, 0.14804269f, 0.08444321f, 0.10250518f, -0.10007507f, 
    0.09408285f, 0.12150680f, 0.19214016f, 0.01438405f, 0.10683418f, 0.01350364f, -0.08072135f, -0.04018497f, 
    0.03153255f, -0.06846112f, 0.05846793f, 0.05335160f, 0.20230567f, 0.06156080f, -0.14505273f, -0.00720554f, 
    0.18086235f, 0.04013295f, 0.27981469f, -0.10337567f, -0.03392363f, -0.01861029f, -0.09432811f, -0.04402250f, 
    0.03446887f, -0.01545602f, 0.00648533f, -0.01060525f, -0.00301636f, -0.00867831f, 0.02545384f, -0.01491494f, 
    -0.02769380f, -0.19913174f, -0.14132640f, -0.21548733f, 0.12437910f, 0.09054475f, 0.03163768f, -0.16243981f, 
    -0.17127968f, 0.02389451f, 0.02649119f, 0.03282214f, -0.01053909f, -0.05952847f, 0.08924799f, -0.06311199f, 
    0.13057508f, 0.03142226f, -0.09291684f, 0.02867877f, -0.13223423f, -0.00829207f, 0.00290650f, -0.06851333f, 
    0.20846966f, -0.08662169f, 0.02854466f, -0.00703025f, -0.29972422f, 0.23205154f, -0.03417487f, 0.16270083f, 
    -0.01895048f, 0.10428455f, 0.06752358f, 0.03440943f, 0.14152226f, -0.02177217f, -0.13195363f, -0.10834540f, 
    0.77652144f, -0.30647603f, 0.23800361f, 0.09619341f, 0.17865428f, -0.04816948f, -0.09627708f, -0.07840735f, 
    0.03582723f, -0.05052321f, 0.01288074f, -0.10540665f, 0.18189886f, -0.24543461f, 0.00648267f, -0.10983033f, 
    0.10836368f, -0.01019392f, -0.13019709f, -0.11397538f, 0.12527888f, 0.00424275f, -0.01944047f, -0.02310986f, 
    -0.00666472f, -0.03780401f, -0.03491191f, 0.00504527f, 0.03002524f, 0.00870142f, -0.03449143f, 0.01626861f, 
    -0.01228671f, -0.02683503f, 0.02794118f, -0.00236696f, -0.02029866f, 0.00049723f, 0.02227593f, -0.01761207f, 
    -0.00105996f, -0.02936364f, 0.01251454f, -0.00617718f, 0.01820551f, 0.00428921f, -0.01458666f, -0.00108192f, 
    -0.01573467f, 0.02938097f, -0.03400140f, -0.01595484f, -0.03959307f, 0.01696803f, 0.02709084f, -0.01073610f, 
    -0.02659440f, 0.02646514f, 0.02066075f, 0.01270337f, 0.01085633f, -0.02011812f, 0.01087992f, -0.01250011f, 
    -0.01736842f, 0.00567121f, 0.02828178f, -0.04135943f, 0.00108669f, -0.00281664f, -0.03305251f, 0.02639989f, 
    0.02114007f, -0.04063707f, 0.00297661f, -0.03915600f, -0.02309770f, 0.01500189f, -0.00635506f, 0.02101879f, 
    0.01069020f, 0.02654144f, 0.02059707f, -0.03527349f, -0.00964940f, -0.03421807f, -0.02978034f, 0.02860529f, 
    0.02761172f, -0.00063603f, 0.01539982f, -0.00851284f, -0.01038862f, 0.00370861f, -0.01825453f, -0.01847147f, 
    0.01117964f, 0.00832430f, -0.00003033f, -0.00876759f, -0.00261624f, -0.04202440f, 0.00107053f, -0.01290535f, 
    -0.03716696f, 0.01659841f, -0.01230210f, -0.03525253f, 0.02885235f, 0.01446954f, -0.02138310f, -0.02941022f, 
    -0.00642726f, -0.02516540f, -0.01721068f, -0.01897787f, 0.02528482f, -0.00750370f, -0.01425592f, -0.02777692f, 
    -0.01215480f, 0.02583390f, -0.02709191f, 0.02190675f, -0.00475104f, 0.02097766f, -0.03037192f, -0.01886750f, 
    -0.01911105f, -0.01230280f, 0.02822201f, 0.01559118f, 0.00813204f, 0.02762891f, -0.01546404f, -0.01669394f, 
    0.02449241f, -0.01474560f, 0.00511513f, -0.02532070f, -0.04024787f, -0.02861618f, 0.01135063f, -0.02937557f, 
    -0.02867309f, 0.02048113f, -0.03213186f, -0.03503748f, -0.00867183f, -0.01217415f, 0.02068365f, -0.01762094f, 
    -0.02022044f, -0.02117176f, 0.01314379f, -0.02310801f, 0.00861169f, -0.01193433f, 0.01384071f, -0.02060252f, 
    -0.03789311f, 0.02740473f, -0.00060468f, -0.02998946f, -0.03660790f, 0.01235546f, 0.00031905f, -0.01509077f, 
    -0.00583232f, -0.01631931f, 0.00048000f, 0.00638240f, -0.01839937f, -0.03231072f, 0.01338337f, -0.00877458f, 
    -0.03603851f, -0.00916819f, -0.00251878f, -0.02552541f, 0.00801414f, 0.00704547f, 0.00221824f, -0.01542906f, 
    0.01352809f, -0.03775860f, -0.02801239f, -0.01681671f, 0.01987888f, 0.00389568f, -0.02488404f, -0.02533378f, 
    -0.01057699f, 0.01358466f, 0.02704461f, -0.00097605f, 0.00978555f, -0.00360585f, 0.02252560f, -0.03997835f, 
    -0.00608626f, 0.00500187f, -0.04023475f, 0.00448729f, -0.01359188f, 0.00405855f, 0.02481316f, -0.02917692f, 
    0.03262782f, 0.00826791f, 0.00104018f, -0.01990967f, 0.01787691f, 0.00793702f, -0.00794935f, -0.02845374f, 
    0.00887024f, -0.02694452f, 0.00022094f, -0.01290112f, 0.00318803f, -0.03930925f, 0.00961725f, -0.02670077f, 
    0.02771168f, -0.02802509f, -0.00689058f, 0.02294428f, -0.01804498f, 0.00059724f, 0.02714585f, -0.03889829f, 
    -0.01237958f, -0.01865363f, 0.00033295f, -0.03733494f, 0.01225077f, 0.03089407f, 0.02538860f, 0.03241696f, 
    -0.03607487f, 0.02342630f, 0.00825724f, -0.00814595f, 0.01980451f, 0.00064698f, -0.02686259f, 0.02156709f, 
    0.02351454f, -0.03419365f, 0.02296114f, 0.02948262f, 0.01630311f, -0.02894123f, -0.02297455f, 0.00611682f, 
    -0.00088123f, -0.02162392f, -0.02405445f, -0.02707064f, -0.01861780f, 0.01266852f, 0.02098274f, -0.02613856f, 
    0.02793827f, -0.01989154f, -0.00604950f, 0.02660538f, -0.04191075f, -0.01816636f, -0.03305412f, -0.00400239f, 
    0.00550829f, 0.00472272f, -0.03034385f, -0.01079596f, -0.01893556f, -0.02173540f, -0.01004637f, -0.02057340f, 
    -0.02162845f, -0.00651124f, 0.02713122f, 0.00231803f, 0.02202505f, -0.00113444f, 0.00766511f, 0.00815378f, 
    0.02869479f, -0.02852946f, -0.04038255f, -0.01381736f, -0.00569635f, 0.01306385f, 0.01630883f, 0.00250373f, 
    -0.01429950f, 0.00657004f, 0.00086904f, 0.02197714f, -0.02778926f, -0.03128368f, 0.00431304f, -0.04121273f, 
    0.01230650f, -0.03099631f, -0.01088976f, -0.01071512f, 0.02701290f, -0.00587600f, -0.02342477f, -0.01839730f, 
    -0.03720471f, 0.01435780f, -0.00204430f, -0.01058120f, -0.03240443f, -0.01966374f, 0.00185073f, -0.01925186f, 
    0.03553342f, 0.00749096f, -0.02528461f, -0.00930122f, -0.02542544f, -0.03450169f, 0.01492350f, -0.03708430f, 
    0.02529526f, -0.01814010f, -0.02732100f, -0.00952473f, -0.03584445f, 0.03305347f, 0.02326099f, -0.01734094f, 
    0.00386265f, -0.02042786f, -0.03479377f, 0.02802576f, 0.00381409f, -0.03516765f, -0.01076302f, -0.00390510f, 
    0.02060546f, -0.01475426f, 0.01780128f, -0.01041650f, 0.00132842f, -0.02546117f, -0.03839101f, 0.01929452f, 
    0.00399731f, -0.03440164f, 0.02609664f, 0.02728739f, -0.03067785f, -0.01589518f, 0.01997980f, 0.00825939f, 
    -0.00727979f, -0.02805007f, -0.03408141f, 0.01498522f, -0.03754295f, 0.00197107f, -0.01405230f, -0.00410995f, 
    -0.00267539f, -0.00519800f, 0.00084976f, 0.00980530f, -0.02685943f, -0.01978111f, -0.01201363f, -0.03077042f, 
    0.00185733f, -0.02657841f, -0.04068235f, -0.00270392f, 0.01628302f, -0.03574988f, 0.01229306f, 0.00749766f, 
    0.01887788f, 0.02692027f, 0.01882925f, -0.00559651f, -0.00989269f, -0.00450722f, 0.02228845f, -0.03551166f, 
    -0.00257418f, 0.02692624f, 0.02216604f, -0.02055864f, 0.02887772f, -0.02508974f, -0.00099945f, -0.04080630f, 
    -0.02693591f, 0.02813910f, -0.00372221f, 0.01083509f, 0.01270857f, -0.02374103f, -0.02603905f, 0.02701400f, 
    -0.01485303f, -0.03820582f, 0.02453133f, 0.01225469f, 0.02259472f, 0.00954306f, -0.03325274f, 0.00309335f, 
    -0.02298427f, 0.00518524f, 0.00678541f, -0.01881035f, 0.00801730f, -0.01776011f, -0.01433530f, -0.01192826f, 
    -0.03814800f, -0.02063502f, 0.00672149f, -0.04042428f, -0.03474218f, -0.04086719f, 0.00723984f, -0.01372261f, 
    0.02022477f, 0.00657360f, 0.01752380f, -0.01440956f, -0.00685408f, 0.02383203f, -0.01423911f, 0.01070331f, 
    -0.01568827f, -0.01467861f, -0.00509108f, -0.00164733f, 0.00341550f, -0.03185229f, -0.02526841f, -0.01999270f, 
    -0.00290342f, -0.03172239f, 0.00141381f, -0.00083279f, -0.02968523f, -0.00492877f, 0.00584746f, 0.01011642f, 
    0.02028533f, -0.00975833f, 0.01110897f, -0.01972329f, 0.00626691f, -0.00995729f, -0.01381886f, -0.00585934f, 
    0.00258398f, -0.00835743f, 0.01665373f, 0.01019213f, 0.01799391f, 0.01393836f, -0.01618949f, -0.03787225f, 
    0.00395443f, 0.00930006f, -0.03417071f, -0.02178868f, -0.01356634f, -0.00481706f, 0.00281067f, 0.00704878f, 
    -0.03756665f, 0.01668042f, -0.00669613f, 0.00004477f, -0.00942000f, 0.01343501f, 0.02769866f, 0.00401702f, 
    0.01941094f, 0.01441438f, -0.00394166f, 0.02028279f, 0.00891173f, -0.04190389f, -0.03864857f, -0.02437714f, 
    -0.03375216f, 0.00816108f, -0.03958134f, -0.02415817f, -0.02485583f, -0.03415004f, 0.01609689f, 0.01614349f, 
    -0.04156199f, -0.02158541f, -0.02009191f, -0.03461522f, -0.00424130f, -0.01156664f, -0.02035929f, -0.02988380f, 
    -0.00459730f, -0.01018329f, 0.00370616f, 0.01670845f, 0.00929124f, 0.00632359f, 0.01210525f, 0.01444301f, 
    0.01642694f, -0.01260930f, -0.02696047f, -0.00702013f, -0.03717721f, 0.01012296f, 0.01331786f, 0.02744487f, 
    0.00341982f, -0.00366077f, -0.02607034f, -0.00542535f, -0.03777041f, 0.00344363f, -0.03825414f, -0.00804779f, 
    -0.03127581f, 0.00439052f, 0.00070820f, -0.01019555f, -0.03224474f, -0.03977042f, -0.00237087f, -0.02565335f, 
    -0.01276851f, 0.00013037f, 0.01176986f, -0.03236669f, -0.03407690f, 0.01051368f, -0.03590521f, -0.03873430f, 
    0.02671950f, -0.01892891f, 0.00280217f, 0.02963437f, -0.02501348f, 0.01284988f, -0.02672351f, 0.01590083f, 
    -0.00706494f, -0.02707303f, 0.00619465f, -0.01263962f, 0.02184586f, -0.02208918f, -0.03659131f, 0.01902505f, 
    -0.00096993f, 0.01010797f, 0.00175340f, 0.01457874f, -0.00062552f, 0.01349362f, 0.01344451f, 0.01298906f, 
    0.01961592f, -0.02873693f, -0.01468844f, -0.02159795f, 0.01784126f, 0.01043110f, -0.02068859f, 0.03600230f, 
    -0.03844012f, -0.02357727f, -0.04090241f, 0.00118745f, 0.00774068f, -0.03287338f, 0.01174342f, 0.01217437f, 
    -0.01721180f, 0.01917873f, -0.03674409f, 0.01803843f, -0.00709844f, -0.00535067f, 0.02063883f, -0.02104387f, 
    0.01944625f, -0.00145982f, 0.00188941f, -0.02347795f, -0.00935175f, -0.00556165f, -0.02436363f, 0.01161675f, 
    -0.00829749f, -0.02716378f, 0.02894969f, -0.01634857f, -0.00548272f, -0.01406638f, 0.01037584f, 0.02794807f, 
    -0.02057786f, 0.02516910f, 0.03562514f, 0.00770492f, -0.01863012f, 0.03562652f, -0.03275233f, -0.03787899f, 
    -0.03684438f, -0.03507017f, -0.01683185f, 0.00194613f, -0.02571500f, -0.03074301f, -0.03191450f, -0.01351597f, 
    -0.03281756f, -0.00626774f, -0.03758483f, 0.02682706f, 0.01950915f, 0.01481453f, -0.01703070f, -0.03782592f, 
    0.01556224f, -0.03469099f, -0.03505462f, -0.00303824f, -0.02133149f, -0.00540806f, -0.04007004f, -0.01904977f, 
    -0.02182341f, -0.02274102f, 0.00593165f, -0.01876256f, 0.02807693f, 0.02013765f, -0.02949195f, -0.00211257f, 
    -0.00842220f, -0.00197250f, -0.01736449f, -0.02899400f, -0.02983423f, -0.00451767f, 0.00424857f, -0.03676941f, 
    0.01663992f, -0.02722918f, -0.00286469f, -0.03395051f, -0.03442784f, -0.03129385f, -0.01502491f, -0.00020345f, 
    0.00402580f, -0.02176372f, -0.00171877f, -0.03481799f, -0.01087371f, -0.00702823f, -0.00238851f, -0.02983667f, 
    0.02790374f, 0.02744840f, -0.01924757f, -0.04201566f, 0.02130292f, -0.02985430f, 0.00067064f, 0.01862976f, 
    -0.02757004f, 0.00988408f, -0.03827016f, 0.00371191f, -0.02083642f, -0.03343502f, -0.01589466f, 0.01751565f, 
    0.01118763f, 0.01305429f, 0.01780632f, 0.01787233f, 0.02663449f, -0.01384059f, -0.00245723f, -0.01068628f, 
    -0.00953196f, -0.01736115f, 0.00310276f, 0.01590642f, 0.02504644f, -0.01283657f, -0.01672535f, 0.01958775f, 
    0.00192642f, 0.01324102f, 0.01528086f, 0.01789278f, -0.02727964f, -0.03228943f, -0.01645220f, 0.01878793f, 
    0.01799303f, -0.03402217f, -0.03557612f, -0.00637753f, 0.01669424f, -0.00228732f, 0.01762075f, 0.01411400f, 
    -0.03977074f, -0.01708360f, -0.01042828f, -0.03000560f, 0.02566785f, 0.00341944f, 0.02352984f, -0.00181524f, 
    -0.01911154f, 0.02364617f, 0.01530961f, 0.02508106f, 0.01550447f, -0.02244832f, -0.00222813f, 0.01183512f, 
    0.00669595f, -0.04140364f, 0.02329265f, -0.00414187f, -0.01389048f, 0.02758124f, -0.00784841f, 0.01880063f, 
    -0.00340523f, 0.02598787f, -0.03745207f, -0.02877446f, 0.01489809f, 0.02673427f, 0.02365267f, -0.00739479f, 
    -0.02862232f, 0.01517568f, 0.02331633f, 0.00774295f, -0.00512193f, -0.03711981f, -0.02577930f, -0.03686162f, 
    -0.01516742f, 0.02527794f, -0.02340914f, 0.00728736f, -0.00842733f, 0.00512597f, -0.00647677f, -0.02124131f, 
    -0.03973551f, -0.01202294f, -0.03315295f, 0.02232311f, 0.02999038f, 0.01589178f, 0.02601589f, 0.02717904f, 
    -0.02066936f, -0.01071753f, -0.01085445f, 0.00080169f, -0.00578726f, -0.02661140f, -0.03192971f, -0.00763866f, 
    -0.01839960f, -0.01079321f, 0.01807473f, -0.02745091f, -0.01963146f, 0.02247881f, -0.01196908f, 0.00124272f, 
    -0.00904500f, 0.01723715f, -0.04001873f, -0.01362498f, 0.00492879f, -0.03147315f, -0.01948605f, -0.04369875f, 
    0.02556317f, 0.02593480f, 0.01244416f, 0.02055464f, -0.00327438f, 0.02467319f, 0.01737879f, -0.00167690f, 
    -0.00585547f, 0.02690948f, -0.00102470f, 0.00717700f, 0.01891296f, 0.01932642f, 0.00630014f, -0.02823809f, 
    0.00781497f, 0.02085855f, -0.01183775f, -0.03408345f, 0.02127535f, -0.01401388f, 0.01170200f, 0.00074610f, 
    0.01204981f, -0.01175404f, -0.02690264f, 0.00989865f, 0.02467488f, -0.00609066f, -0.00139694f, -0.00039849f, 
    0.00811211f, -0.04144963f, -0.03630474f, -0.02877400f, 0.00927516f, -0.01096425f, -0.02529634f, -0.00989990f, 
    -0.02985942f, 0.00311923f, -0.01585203f, 0.01681414f, 0.01197570f, 0.00362301f, 0.00382017f, 0.01746628f, 
    0.00704587f, -0.02671990f, -0.01834113f, -0.01442460f, -0.01066552f, 0.00880529f, -0.02675991f, -0.01475751f, 
    0.01177037f, 0.02179513f, 0.02463465f, -0.01670023f, 0.01496871f, 0.02838925f, -0.03868199f, -0.01748404f, 
    0.02604867f, -0.01561803f, -0.01147824f, -0.01414055f, -0.00477812f, 0.01744485f, -0.02132016f, -0.03446975f, 
    -0.01570733f, -0.01222620f, 0.01493156f, -0.01405305f, -0.02841992f, 0.00861778f, 0.00908223f, 0.00017687f, 
    -0.01240595f, -0.01609796f, 0.00718991f, 0.00429725f, -0.04309453f, -0.03359830f, -0.04420657f, 0.00480883f, 
    0.01028285f, -0.02526661f, -0.02343178f, -0.03471074f, 0.02670896f, -0.01734236f, -0.00006738f, -0.01371851f, 
    -0.04145833f, 0.00521323f, -0.00920279f, -0.02068019f, 0.01422152f, 0.00194064f, 0.00695604f, -0.00139753f, 
    0.02291984f, -0.02141363f, -0.01697377f, -0.02150042f, -0.04036819f, 0.02831216f, 0.02009115f, -0.02412485f, 
    -0.01105275f, -0.00304972f, -0.03770506f, -0.03717869f, -0.03222431f, -0.00458896f, -0.03633532f, 0.01988122f, 
    -0.01067120f, 0.02163853f, -0.00117232f, 0.01216409f, -0.04296905f, -0.01843709f, -0.02993015f, -0.04139172f, 
    -0.01373358f, 0.01958841f, -0.00051577f, -0.03470824f, -0.00630301f, -0.03008092f, -0.00159020f, -0.03149023f, 
    0.01093626f, -0.01903760f, -0.03152612f, 0.00111544f, -0.00440406f, 0.00565354f, -0.02630988f, -0.03623543f, 
    0.02492648f, -0.01651793f, -0.00438461f, 0.01122821f, -0.00163719f, -0.00827293f, 0.02509734f, -0.02333384f, 
    -0.03750085f, -0.02114323f, 0.01920042f, -0.02414103f, -0.03795136f, 0.02299268f, -0.02972191f, -0.03461569f, 
    0.00417090f, -0.01289432f, 0.00684737f, 0.00700545f, 0.01258966f, -0.01419988f, 0.02084797f, -0.03307093f, 
    0.00408942f, -0.01016192f, 0.00771317f, -0.03842629f, 0.01276521f, -0.01610550f, 0.01141151f, 0.03010773f, 
    -0.01334536f, 0.00415092f, 0.00132629f, -0.03003517f, 0.02569102f, 0.00391200f, -0.03734116f, 0.00662689f, 
    0.00625604f, 0.00331382f, 0.00715402f, 0.00244853f, 0.00455567f, 0.01755209f, -0.03504837f, -0.02353185f, 
    -0.04311582f, -0.01230379f, 0.00809098f, 0.00552958f, -0.04009171f, 0.01377768f, -0.02926483f, -0.01449951f, 
    -0.00053299f, -0.00803168f, 0.01384412f, -0.01789518f, -0.02202885f, 0.01964109f, -0.02024865f, 0.01616899f, 
    -0.02222414f, 0.01524199f, 0.00978950f, -0.02147815f, 0.00171659f, -0.02832947f, -0.01778590f, -0.01822652f, 
    0.00156528f, -0.00410256f, 0.02810510f, 0.00741995f, -0.03134448f, -0.02996656f, -0.00831578f, -0.03467782f, 
    -0.00342336f, 0.00333465f, -0.01749262f, -0.02588974f, -0.03847812f, 0.00536410f, 0.01493124f, -0.01572717f, 
    0.03155962f, 0.00874317f, 0.02831850f, 0.02730706f, 0.02135687f, -0.00401044f, -0.02639000f, -0.03013101f, 
    -0.00564489f, -0.02131312f, -0.03905208f, -0.03984838f, 0.01876175f, -0.00542763f, -0.00577273f, -0.02680536f, 
    -0.01894162f, 0.00513689f, -0.01406393f, 0.00877952f, -0.01079718f, -0.02356604f, -0.00843979f, 0.02048991f, 
    -0.03765399f, 0.00336091f, -0.03983895f, -0.02760695f, 0.01442261f, -0.02741145f, -0.03183402f, -0.00499513f, 
    0.01941393f, -0.01356021f, -0.03456866f, 0.01649902f, -0.02303525f, -0.01711945f, -0.00321567f, -0.04229287f, 
    0.00974785f, -0.02906808f, -0.01231046f, 0.00372529f, -0.02396500f, -0.00901300f, -0.00340941f, -0.03758899f, 
    0.00282337f, 0.01147149f, 0.01168284f, 0.02263170f, -0.00632828f, -0.03312580f, 0.01184991f, 0.02506397f, 
    0.03401347f, 0.02145840f, 0.02322407f, 0.02107383f, 0.00490519f, -0.00336161f, -0.00953346f, -0.00632217f, 
    -0.02121559f, 0.01522087f, 0.01100601f, 0.00905494f, 0.01801999f, -0.01433543f, -0.01266554f, -0.02726331f, 
    -0.02256594f, 0.01261215f, -0.00470411f, 0.01491845f, 0.02512877f, -0.03311724f, -0.00678050f, 0.00256734f, 
    0.03478776f, -0.01129563f, -0.00915283f, 0.02094032f, -0.01187638f, -0.04048774f, -0.00854126f, -0.03804481f, 
    -0.02937017f, 0.01374129f, -0.03187035f, -0.03069812f, 0.01904423f, -0.00259268f, 0.00744752f, 0.00246873f, 
    0.02108041f, -0.00221928f, -0.02063840f, -0.02759665f, 0.01491320f, -0.01254679f, 0.01674888f, 0.00856654f, 
    0.01726469f, 0.02574912f, 0.01255897f, -0.02372726f, -0.00626235f, 0.00400212f, -0.03517737f, -0.02886940f, 
    -0.02498781f, -0.00274678f, 0.00945004f, 0.02633472f, 0.00181843f, -0.03122676f, 0.02702689f, -0.01320585f, 
    -0.02906183f, -0.00750080f, 0.01892827f, 0.01404023f, 0.02014996f, -0.02306197f, -0.00907774f, 0.01316104f, 
    0.01794568f, 0.02022500f, 0.02134694f, 0.01573015f, -0.03576884f, -0.00085403f, 0.02330029f, -0.02642003f, 
    -0.01687296f, -0.02569665f, -0.03342304f, -0.03421335f, -0.03019905f, -0.03718570f, 0.00994085f, 0.01728354f, 
    -0.01245027f, -0.02256805f, -0.00684429f, -0.04310146f, -0.00112783f, 0.00968771f, 0.01212093f, -0.01747318f, 
    -0.04256004f, -0.02937092f, -0.01257111f, -0.01148405f, -0.02636226f, 0.02161642f, -0.03251824f, 0.03006792f, 
    0.01947524f, -0.01561836f, -0.01055476f, -0.02905853f, -0.01632416f, -0.01482703f, 0.02437458f, -0.03860552f, 
    0.00098095f, 0.03801361f, -0.00559284f, -0.02491203f, -0.02972358f, 0.01057960f, 0.01456501f, -0.00300116f, 
    0.01584596f, -0.03980084f, 0.00124208f, -0.03494107f, 0.00330012f, 0.01467036f, -0.03498544f, 0.01297184f, 
    -0.04144933f, -0.03890057f, -0.02222818f, -0.04366949f, 0.01710327f, -0.00962681f, -0.01784641f, -0.01976526f, 
    -0.00882428f, 0.00424766f, 0.00113261f, 0.02276428f, 0.00922534f, -0.02196561f, 0.01763161f, -0.01928052f, 
    0.01737570f, -0.01637770f, 0.00469218f, 0.02530166f, 0.02251307f, -0.01650139f, 0.00889208f, 0.02515461f, 
    -0.01916570f, -0.04290298f, -0.03384712f, 0.02769640f, 0.00274783f, 0.02340885f, 0.00912895f, -0.04416019f, 
    -0.02868673f, 0.02876821f, 0.01359725f, 0.00446736f, -0.01699448f, 0.02756242f, -0.00193252f, -0.00236555f, 
    -0.00786805f, -0.02075644f, 0.00585837f, 0.00267888f, 0.02538667f, 0.00685008f, -0.01110256f, 0.01024718f, 
    -0.04407867f, -0.03335632f, 0.02402690f, -0.03832865f, -0.02050921f, -0.00229898f, -0.00527626f, -0.01985892f, 
    -0.03418649f, 0.01974445f, 0.01489619f, -0.03490520f, -0.03803949f, -0.00515374f, -0.02995756f, -0.03255766f, 
    -0.01642648f, -0.03829883f, -0.00916223f, 0.03482941f, 0.00715008f, -0.03710184f, -0.01489008f, 0.00149064f, 
    -0.02441567f, 0.00810248f, 0.00965915f, -0.00683356f, -0.02633916f, 0.02355466f, -0.03109492f, 0.00877068f, 
    -0.01333283f, 0.02312584f, -0.00843388f, 0.00658058f, 0.02346029f, 0.02997042f, -0.00253355f, 0.01249829f, 
    0.02694904f, -0.00486669f, 0.00549435f, 0.01235525f, 0.01867157f, -0.01302863f, 0.01282355f, -0.00393264f, 
    -0.03677752f, -0.03026447f, -0.01607780f, -0.00790755f, -0.00542292f, -0.02667886f, -0.01933440f, 0.00012588f, 
    -0.03445651f, -0.00812554f, -0.01435910f, -0.00660645f, -0.01663299f, -0.01696491f, 0.02140037f, 0.02452235f, 
    -0.03594768f, 0.01404500f, -0.00684396f, -0.01780287f, 0.02074697f, 0.03060840f, 0.02325118f, -0.01698076f, 
    -0.01781237f, -0.00191092f, -0.02110264f, 0.02277471f, -0.02087644f, -0.00112756f, -0.01470131f, 0.00218259f, 
    -0.02584471f, 0.00962606f, -0.00171370f, 0.02927843f, -0.02897124f, -0.03014753f, 0.00094239f, -0.03458424f, 
    -0.03394841f, -0.03274439f, 0.01448439f, 0.01728337f, -0.04159822f, -0.00909576f, 0.02387114f, 0.00507929f, 
    -0.03193312f, -0.03027754f, 0.02461233f, -0.03766060f, -0.00785558f, -0.02738133f, -0.02836639f, 0.01063518f, 
    -0.00539137f, -0.02612458f, -0.02477600f, -0.02566359f, 0.02803050f, -0.03961351f, -0.01127418f, -0.02850191f, 
    -0.01187954f, 0.01510570f, -0.01221460f, 0.02472891f, 0.01457679f, -0.03979142f, -0.01577407f, -0.01979895f, 
    0.00093540f, 0.01962770f, 0.00527105f, 0.02251507f, -0.04278386f, 0.01734184f, -0.02758792f, -0.02027338f, 
    -0.00553519f, 0.00581131f, -0.02900811f, -0.00209448f, 0.00267925f, -0.02161888f, -0.04028297f, 0.01862385f, 
    0.00070418f, -0.00198776f, -0.01481235f, 0.02661327f, 0.00736919f, -0.01615635f, 0.00490814f, -0.01120903f, 
    -0.03772510f, -0.00052280f, 0.03566274f, -0.03009990f, -0.04324115f, -0.03884650f, -0.00357777f, 0.00217024f, 
    -0.00474261f, 0.03135043f, 0.02000045f, 0.01318577f, -0.01048543f, -0.00261966f, -0.00232391f, 0.02007257f, 
    -0.03669675f, -0.03526884f, -0.02366562f, 0.01063479f, -0.03299667f, -0.02129631f, -0.01456833f, -0.02114238f, 
    -0.02258984f, 0.01741559f, -0.03214249f, 0.02567014f, 0.02775325f, -0.03400256f, -0.01650873f, 0.01714185f, 
    -0.02564528f, 0.00258213f, -0.00892748f, 0.00493454f, -0.03289822f, 0.01837888f, 0.02652724f, 0.01563324f, 
    -0.01329811f, -0.00763725f, -0.02021943f, 0.02439355f, -0.02351682f, -0.03785233f, 0.03128946f, 0.02069771f, 
    -0.01075890f, -0.03040308f, 0.01021618f, -0.00124962f, -0.02607996f, 0.00061887f, 0.01439892f, -0.03954834f, 
    -0.01728697f, -0.00995541f, 0.01434824f, 0.00679171f, -0.02692919f, -0.00882419f, -0.02635718f, 0.00148630f, 
    -0.01534138f, 0.00814374f, 0.03585275f, -0.01786228f, 0.01065923f, -0.00200592f, -0.03182635f, -0.02691961f, 
    -0.00983719f, -0.00491946f, 0.02647447f, 0.02368025f, 0.00892796f, 0.00496956f, 0.02227402f, -0.01534414f, 
    0.01548725f, 0.02972288f, -0.02577944f, -0.00754327f, -0.01980036f, 0.01250023f, -0.00423250f, -0.01730653f, 
    -0.04380436f, -0.01113216f, -0.02610514f, -0.00866790f, -0.02008550f, 0.01267094f, 0.01406348f, -0.02688374f, 
    -0.03567127f, -0.01462242f, -0.01786114f, 0.01939496f, -0.02106561f, 0.02641978f, 0.00282859f, 0.00282471f, 
    -0.00191129f, -0.00170679f, 0.03277085f, -0.03450030f, 0.03332174f, -0.02419904f, -0.00300145f, 0.00637240f, 
    -0.02969352f, -0.03211936f, -0.02818545f, 0.00364120f, 0.00049354f, 0.01454155f, -0.00116325f, 0.02565071f, 
    -0.01754206f, -0.01296910f, 0.01755606f, -0.01967023f, -0.03453445f, -0.01195194f, 0.02381814f, 0.02635495f, 
    0.00354144f, 0.02001631f, 0.00963779f, 0.02583868f, -0.00249317f, -0.00825367f, 0.01725542f, -0.00986629f, 
    -0.02961129f, -0.02734139f, 0.02020079f, -0.00105541f, 0.02086838f, -0.00823509f, -0.03735273f, 0.01327243f, 
    -0.02875474f, 0.18573985f, -0.11250505f, -0.28299126f, -0.00552508f, -0.05538721f, 0.13107273f, 0.13474381f, 
    0.04532186f, -0.00968216f, 0.02557136f, -0.10062517f, 0.11880464f, -0.05037964f, 0.09722673f, -0.21902022f, 
    0.00563274f, 0.03189662f, 0.06712586f, 0.27088425f, 0.00086150f, -0.01792320f, 0.01528755f, -0.02914858f, 
    0.19888294f, -0.20585935f, -0.09645078f, 0.03889767f, 0.03831270f, -0.11430068f, -0.16973451f, -0.23149016f, 
    0.03065872f, 0.03127986f, 0.08053853f, 0.09489860f, 0.16246441f, 0.24623713f, 0.03928247f, -0.05804086f, 
    -0.03979162f, 0.16374619f, 0.04435567f, 0.35604599f, 0.01107322f, -0.06625675f, -0.01502059f, -0.02933998f, 
    0.40979975f, 0.00346631f, -0.11216435f, -0.07107294f, 0.08278410f, -0.07400993f, 0.11974198f, 0.07815570f, 
    0.10688461f, 0.01560795f, 0.06872886f, 0.09016748f, -0.25081369f, -0.03156744f, 0.20831759f, 0.11054882f, 
    -0.11262628f, -0.05959994f, 0.04873276f, -0.07446013f, 0.09035838f, -0.09364677f, -0.12986632f, 0.14748403f, 
    0.16202717f, 0.06025028f, 0.11359472f, -0.19689606f, 0.06045853f, -0.02177042f, -0.00321459f, 0.13930047f, 
    -0.11579768f, 0.06073759f, 0.04279143f, -0.08806100f, 0.04708243f, 0.02845428f, -0.16805051f, 0.17245854f, 
    -0.14924943f, -0.07499284f, 0.03839093f, -0.01009400f, 0.11912280f, -0.08775956f, 0.13191724f, 0.04117745f, 
    -0.05505458f, 0.10580911f, 0.12180922f, -0.14899614f, 0.03464639f, 0.15841471f, 0.05058996f, -0.10966927f, 
    0.02553657f, -0.02753826f, 0.05492070f, 0.08564727f, 0.13469051f, 0.20353469f, 0.05098309f, 0.09827136f, 
    0.17171456f, 0.15986221f, 0.04627422f, -0.03804296f, 0.03407265f, 0.05324274f, -0.18201156f, 0.05333960f, 
    -0.05803643f, 0.07479846f, 0.13053098f, 0.10974327f, -0.03787776f, 0.02250601f, -0.00733961f, -0.21254894f, 
    0.06377936f, 0.08456904f, 0.04160449f, 0.10915565f, 0.20455028f, 0.06069095f, -0.00559820f, -0.11137118f, 
    0.08003456f, 0.04380564f, 0.09986185f, -0.09225337f, -0.01467400f, -0.01222375f, 0.03611303f, 0.09430360f, 
    -0.05703194f, 0.02039990f, 0.11951849f, -0.28022203f, 0.07723349f, 0.01759905f, -0.08385351f, 0.07943810f, 
    0.04903514f, 0.03863397f, 0.09714817f, -0.02436436f, 0.15613425f, 0.02890561f, 0.15243219f, -0.07230019f, 
    0.04445757f, 0.01971376f, -0.11444132f, -0.04784818f, 0.01862147f, 0.04547424f, -0.01484701f, -0.08778685f, 
    -0.02087996f, -0.16592355f, 0.03761029f, 0.01708087f, -0.05000831f, -0.06111800f, 0.07233355f, 0.07449729f, 
    0.00597217f, -0.08331204f, 0.07071640f, -0.03349544f, 0.18989989f, 0.06626450f, 0.10645550f, -0.26345921f, 
    0.00348502f, 0.09284435f, 0.21412176f, 0.05191725f, -0.01163917f, 0.03969367f, 0.06945537f, -0.01996523f, 
    0.24577560f, -0.20937288f, 0.02700347f, -0.06252182f, 0.04077303f, -0.06041819f, -0.04559171f, -0.17159407f, 
    -0.02748123f, 0.12952946f, 0.08396051f, -0.00854132f, 0.07621486f, -0.04469527f, -0.03803425f, 0.14055505f, 
    -0.04931138f, -0.05674976f, -0.01493348f, -0.07436669f, 0.04899283f, -0.02053296f, 0.08525039f, 0.04430389f, 
    -0.13238540f, -0.13798712f, 0.01290776f, 0.01641017f, -0.13276264f, -0.07564013f, -0.08389165f, -0.21874477f, 
    0.06636382f, -0.07324083f, 0.08109778f, -0.08255496f, -0.05122238f, 0.11988811f, 0.07346874f, 0.06277386f, 
    0.16101268f, 0.05408808f, 0.12258783f, 0.19475560f, -0.03201506f, 0.11739620f, -0.10059555f, 0.05605098f, 
    -0.08116209f, -0.14175963f, 0.08448950f, 0.13731232f, 0.01406088f, 0.02665592f, -0.13772598f, -0.17573242f, 
    0.06891671f, 0.02930371f, -0.14229029f, -0.01824302f, 0.15903880f, 0.01346256f, 0.02069810f, -0.19185318f, 
    -0.01525232f, 0.15475729f, -0.02502418f, -0.00954801f, 0.05616117f, 0.06888064f, 0.02816303f, 0.02539312f, 
    0.08321229f, 0.16237172f, 0.15388191f, -0.09908238f, 0.19983263f, 0.01440837f, 0.04609867f, 0.13609125f, 
    0.01081649f, -0.01971662f, 0.03672092f, 0.15680586f, -0.38240203f, 0.15441434f, -0.13360992f, 0.08414033f, 
    0.00050315f, 0.07905707f, 0.06037320f, -0.02395250f, 0.14198042f, -0.02190374f, -0.01423924f, 0.04698458f, 
    0.01454563f, -0.00291870f, -0.06237101f, -0.02219300f, -0.10589552f, 0.00014543f, -0.05302849f, -0.09903078f, 
    0.05749088f, 0.12806812f, 0.09647464f, 0.15838531f, -0.08591366f, -0.02129270f, -0.21716255f, 0.02341883f, 
    0.00008677f, -0.08726081f, 0.08855285f, 0.02920125f, 0.01396906f, 0.06396306f, 0.07707431f, 0.13064387f, 
    -0.03207695f, 0.16006638f, -0.05931487f, -0.12274645f, -0.08110112f, -0.05538872f, 0.03118622f, 0.11596745f, 
    -0.07923096f, 0.00895528f, -0.09927650f, -0.08679291f, 0.24998409f, -0.20686020f, -0.06182393f, -0.15104336f, 
    0.07777835f, -0.03161889f, 0.13028868f, 0.05989197f, -0.02131268f, 0.04573111f, -0.01219266f, -0.03275024f, 
    -0.38379061f, 0.17892015f, 0.01452912f, 0.06613450f, 0.18232158f, -0.11204822f, -0.04317164f, -0.06270821f, 
    0.14804749f, 0.07151485f, -0.07616264f, 0.04322955f, 0.16236562f, 0.15809783f, -0.03424099f, -0.05813795f, 
    0.05502538f, -0.03870255f, 0.10121819f, 0.09564329f, -0.00776799f, 0.02638386f, 0.06801715f, -0.09893782f, 
    0.01867795f, 0.11998466f, -0.02136398f, -0.08869227f, -0.05683639f, 0.03727661f, 0.01802766f, -0.06807242f, 
    0.02228370f, -0.10606629f, -0.01109473f, -0.04599752f, -0.00550759f, 0.09011999f, 0.13909027f, -0.16795537f, 
    -0.07823502f, -0.03282724f, -0.14967331f, 0.14758402f, -0.06949265f, -0.10235652f, 0.08604806f, 0.04050679f, 
    -0.29860464f, 0.11740644f, 0.22443442f, 0.20725949f, 0.00654928f, 0.01431951f, -0.04759572f, -0.09733232f, 
    0.14959450f, -0.06356380f, -0.00342281f, 0.17981233f, 0.26307812f, 0.23641814f, 0.06618493f, -0.02902264f, 
    0.16200686f, 0.00030292f, -0.17513697f, 0.00209290f, 0.01742807f, -0.03079797f, -0.07365422f, 0.02031344f, 
    -0.03203339f, -0.11995490f, -0.05466492f, -0.03013107f, -0.00001082f, -0.09092481f, -0.04247772f, -0.14022730f, 
    0.09432383f, 0.19694008f, 0.16608600f, 0.06417193f, 0.17860761f, 0.10744026f, 0.18482757f, 0.01335020f, 
    -0.02249614f, 0.11005673f, -0.03255264f, -0.00944080f, 0.05804069f, 0.14522064f, -0.14948140f, -0.02002700f, 
    -0.20318560f, -0.06689524f, 0.04727386f, 0.02537530f, -0.03080949f, -0.08864401f, -0.04349775f, -0.14546669f, 
    0.06947086f, -0.09452986f, 0.00027732f, 0.02961107f, -0.21779303f, -0.06136605f, -0.08101879f, 0.13473244f, 
    -0.12510678f, -0.02644402f, 0.06062232f, -0.07281148f, -0.00290121f, 0.03682812f, 0.00225040f, 0.13926660f, 
    -0.06027082f, -0.01217405f, -0.08027033f, -0.20272294f, -0.04079975f, 0.17516157f, 0.08194683f, -0.12201079f, 
    -0.04926964f, 0.05924076f, 0.09533001f, 0.21117511f, 0.16453031f, 0.22597770f, 0.03292812f, -0.09108944f, 
    -0.00988118f, -0.02652322f, -0.05077833f, 0.19737114f, 0.06751170f, -0.00017419f, -0.00091569f, 0.06747930f, 
    0.18405651f, -0.00749228f, -0.10874617f, 0.03439464f, 0.01453552f, -0.01853623f, -0.07928871f, -0.14581187f, 
    0.05200822f, 0.03802954f, -0.02564416f, -0.07579107f, 0.08963728f, -0.01112878f, -0.08392089f, 0.08623271f, 
    0.06087324f, -0.04531221f, -0.05631222f, -0.07350196f, 0.01671794f, 0.08585129f, 0.01898766f, 0.01383726f, 
    -0.10312126f, 0.00321605f, 0.04842954f, -0.14744093f, -0.03770721f, -0.14640120f, -0.06701281f, -0.01058932f, 
    -0.06019194f, -0.04596203f, -0.07909296f, -0.11314091f, -0.20755450f, 0.14001879f, 0.08285051f, 0.07453477f, 
    0.11760472f, 0.25666016f, -0.00327172f, 0.09748562f, 0.01343926f, -0.08018553f, -0.03018922f, 0.22565404f, 
    0.14423437f, 0.35959011f, -0.09084176f, -0.00182898f, -0.04011245f, 0.11648723f, -0.03695319f, 0.23367284f, 
    -0.01188898f, 0.00880503f, 0.01704564f, 0.00887206f, 0.03342432f, 0.05690321f, 0.02841059f, 0.25100183f, 
    -0.04797209f, -0.07846546f, -0.05752587f, -0.21198764f, -0.02374717f, 0.02821287f, 0.08531421f, 0.20330018f, 
    -0.02277647f, -0.09243415f, -0.08172449f, 0.21339294f, -0.08527722f, -0.05511658f, 0.22107109f, -0.08030573f, 
    0.00027219f, -0.08085496f, 0.17867187f, 0.23747145f, 0.04772270f, 0.20557474f, -0.04827509f, -0.18072905f, 
    -0.02142107f, 0.08393676f, 0.19162662f, 0.07180168f, 0.00663083f, 0.01317644f, 0.08528219f, -0.04307648f, 
    0.04019329f, 0.21965306f, 0.03029415f, -0.03767006f, 0.05482856f, 0.04840460f, -0.00396578f, 0.14892292f, 
    -0.11391920f, -0.01831332f, 0.04402751f, -0.10685357f, -0.24647078f, 0.11439277f, 0.15912189f, 0.14233576f, 
    0.17816466f, 0.16751365f, 0.03390962f, -0.00904267f, 0.01964225f, 0.01433365f, 0.07776583f, 0.02053618f, 
    -0.17293842f, -0.03894113f, -0.15886828f, -0.02206150f, -0.01268481f, -0.15546471f, -0.04543364f, -0.02382861f, 
    -0.03688140f, 0.00544164f, -0.08679115f, -0.16794260f, -0.13973522f, 0.09236494f, -0.08716591f, 0.15664859f, 
    -0.00408264f, -0.04721961f, -0.09709442f, -0.06506206f, -0.02585176f, -0.04252829f, -0.07390422f, -0.06983254f, 
    -0.08131424f, 0.00009435f, 0.05883852f, 0.16349030f, -0.07042564f, 0.00015893f, -0.04895414f, -0.03625441f, 
    0.11320502f, -0.09963963f, -0.05606040f, -0.00506267f, 0.10816788f, -0.00514052f, -0.05064833f, -0.05097366f, 
    -0.08296005f, -0.02897089f, 0.03217163f, -0.01556698f, 0.07270585f, 0.03916733f, 0.08236536f, 0.10455550f, 
    0.15445618f, 0.17234957f, -0.03269926f, -0.03479587f, -0.04042443f, 0.19946863f, 0.17198536f, 0.05072099f, 
    -0.03901635f, -0.00509621f, -0.03066249f, 0.01974243f, 0.01414684f, 0.07503279f, -0.02321597f, -0.00744873f, 
    0.10235918f, -0.10577416f, -0.03403763f, 0.08503531f, -0.02904107f, 0.15534817f, 0.04832330f, 0.04802946f, 
    -0.01214343f, -0.20029931f, -0.12032296f, 0.06761150f, 0.02338113f, 0.07375000f, -0.12194704f, -0.01822244f, 
    0.01339660f, -0.00152241f, -0.05320983f, -0.12698372f, 0.08228253f, 0.20813324f, -0.12953076f, 0.05603532f, 
    0.05231998f, 0.03080956f, 0.17680849f, 0.19598043f, -0.11404532f, 0.04835591f, -0.07407917f, 0.04093046f, 
    0.02008289f, -0.04643181f, -0.00598405f, -0.02524908f, -0.12678377f, 0.00081107f, -0.03558293f, -0.05391388f, 
    -0.26078585f, -0.08729761f, 0.02719535f, -0.17630425f, 0.19767784f, 0.17708394f, -0.04309012f, -0.00967456f, 
    0.06522962f, 0.05620036f, 0.10647801f, 0.30657578f, 0.08558898f, -0.04793477f, -0.03503986f, 0.00311375f, 
    0.11366395f, -0.03688487f, 0.08657467f, 0.02151090f, -0.13070449f, -0.05312642f, -0.09098595f, -0.10170339f, 
    0.16317309f, 0.03928876f, 0.03131510f, -0.11236680f, -0.14919382f, -0.11234608f, 0.08434281f, 0.02251229f, 
    -0.10891576f, 0.06139120f, -0.08059980f, 0.05428193f, -0.03625884f, 0.02654856f, -0.21154171f, -0.01375388f, 
    -0.15825316f, -0.01524464f, 0.19271640f, 0.04044550f, -0.13004789f, 0.05719912f, 0.02360596f, -0.12236220f, 
    -0.03851480f, 0.00644719f, -0.01915831f, -0.13002966f, -0.07588232f, 0.03389358f, 0.14250277f, -0.08751683f, 
    0.03439131f, 0.11542102f, -0.03483172f, -0.01490595f, 0.01895973f, -0.08398071f, 0.11866096f, -0.04879409f, 
    0.01051642f, -0.02154635f, -0.01807247f, -0.03165923f, -0.04085562f, -0.00105238f, -0.02431124f, -0.04556728f, 
    -0.02793997f, 0.02309816f, -0.01646709f, -0.00795584f, 0.02836306f, 0.02340767f, 0.02555436f, 0.02237692f, 
    -0.03565586f, 0.00255849f, -0.02297770f, 0.01266684f, -0.01508891f, -0.03479771f, 0.00773429f, -0.00887125f, 
    -0.01935739f, 0.01054283f, -0.00142673f, -0.01206091f, 0.01779599f, -0.00136499f, 0.02035569f, -0.01819054f, 
    -0.00692565f, -0.03293938f, 0.00456365f, -0.01384977f, 0.01425845f, -0.01747328f, -0.02441908f, -0.02085608f, 
    0.01219273f, -0.02256409f, 0.01111461f, 0.00786900f, 0.02783433f, -0.00634164f, -0.00770309f, 0.00053112f, 
    0.03101503f, 0.00320278f, 0.02116637f, 0.00278814f, -0.02979952f, -0.01097714f, -0.01063785f, 0.01868864f, 
    -0.00235261f, -0.00304362f, -0.00143521f, -0.03707011f, 0.00046381f, 0.01814315f, -0.02510779f, 0.00127035f, 
    0.00986210f, 0.02097557f, 0.01605665f, 0.03162935f, 0.00846821f, -0.03984835f, -0.01599468f, -0.02132488f, 
    0.00034884f, 0.00084956f, -0.01396790f, -0.01740288f, 0.00731850f, -0.02927660f, -0.01535353f, -0.01860410f, 
    -0.01337498f, 0.03129429f, 0.00244819f, -0.00414115f, 0.00243839f, -0.02467968f, -0.03719947f, 0.00520330f, 
    0.01018320f, -0.02799472f, -0.03455921f, -0.02799635f, -0.02158036f, -0.00018264f, -0.02365511f, -0.01472393f, 
    -0.01362033f, 0.00997475f, 0.01141457f, 0.02819305f, 0.02432122f, 0.01815696f, 0.02120963f, 0.03189811f, 
    0.01856445f, 0.00836155f, -0.00979596f, -0.02674128f, -0.01644883f, 0.01856409f, -0.00407449f, -0.02998448f, 
    0.00206438f, -0.02523080f, -0.01246930f, -0.01113308f, 0.02950224f, 0.02297789f, -0.02009250f, -0.01520911f, 
    -0.02283750f, 0.02244142f, 0.00119487f, 0.01068858f, 0.01874513f, 0.02677063f, -0.00081265f, -0.03109528f, 
    -0.03749347f, 0.01432212f, 0.00216158f, -0.03683795f, -0.02612988f, -0.00385825f, -0.03321740f, -0.02321006f, 
    0.01397260f, -0.01576626f, -0.01643171f, -0.01938955f, 0.00225538f, 0.00725180f, -0.01928280f, -0.01508169f, 
    -0.00312081f, -0.00595672f, 0.00519674f, -0.00090780f, -0.03557470f, -0.00518985f, -0.00417030f, -0.00156238f, 
    -0.02768244f, -0.02945602f, -0.00809630f, 0.02970189f, -0.03138095f, -0.00534545f, -0.01484793f, 0.02426354f, 
    0.00807550f, 0.02026855f, 0.02015607f, -0.01420750f, -0.00730777f, -0.02624949f, -0.01922666f, -0.04069974f, 
    -0.00047834f, 0.00287975f, -0.04276811f, 0.02278727f, -0.00059536f, 0.03392342f, -0.01028307f, 0.00889783f, 
    -0.03058095f, 0.00763332f, -0.01209150f, 0.00393739f, 0.02472586f, -0.02460553f, 0.00527698f, 0.02372638f, 
    -0.03040214f, 0.03023499f, -0.00706640f, 0.02515612f, -0.03092940f, 0.01071017f, -0.00438289f, -0.01395608f, 
    -0.01906805f, 0.01725808f, -0.03425474f, -0.00947466f, -0.01875219f, -0.01566668f, 0.00338679f, -0.04096981f, 
    0.02008785f, 0.02464496f, 0.00319139f, 0.00835749f, 0.01598532f, 0.01148620f, 0.01271035f, 0.00213944f, 
    0.00878939f, -0.03719244f, -0.00545499f, 0.01392540f, 0.02552809f, -0.03515625f, -0.00823170f, 0.01238785f, 
    -0.03117817f, -0.02411443f, -0.00109856f, 0.01772411f, 0.02390256f, 0.02574826f, 0.00998906f, 0.01644576f, 
    0.00549521f, -0.04727555f, -0.03716970f, 0.01637436f, -0.00224509f, -0.02522514f, 0.01904419f, -0.03323659f, 
    -0.02924347f, 0.03394780f, -0.01274855f, 0.02189049f, 0.02308365f, -0.00567356f, -0.02523224f, 0.01472939f, 
    0.02681766f, -0.01562969f, -0.01870892f, -0.01261759f, 0.00479578f, 0.00198506f, 0.03174496f, -0.02918109f, 
    0.02516107f, -0.03772192f, 0.00844069f, -0.00287054f, -0.00380555f, 0.01049151f, 0.02751340f, 0.02931128f, 
    0.00318387f, -0.03810132f, -0.01393576f, 0.01163601f, -0.00557771f, -0.00842720f, 0.01036841f, -0.00848343f, 
    0.01343012f, 0.02311053f, -0.00742521f, -0.01574346f, 0.00929625f, 0.01813066f, 0.00395925f, 0.03226040f, 
    -0.02186342f, 0.01194835f, 0.03025661f, 0.03336916f, -0.03409122f, -0.03512584f, -0.03555012f, 0.03331180f, 
    0.02934018f, -0.03209288f, 0.03254248f, -0.01598958f, 0.02110986f, -0.02481013f, 0.02584504f, 0.02930168f, 
    -0.03222274f, 0.02539990f, -0.01326353f, -0.01673101f, -0.04078520f, -0.01788492f, 0.00233181f, 0.02259569f, 
    0.02144505f, -0.01759488f, -0.02413417f, -0.02342435f, -0.01199617f, 0.01940610f, -0.02668597f, -0.02540645f, 
    -0.02092323f, -0.00405037f, -0.00883761f, 0.02748949f, -0.00381267f, -0.03533119f, -0.03044934f, 0.02373918f, 
    0.01464151f, 0.00867385f, -0.01228853f, -0.00299425f, -0.01279959f, 0.03040515f, 0.00246747f, 0.01109276f, 
    -0.01682095f, 0.02185199f, -0.00368272f, -0.03306255f, 0.00902081f, -0.01867569f, -0.01508922f, -0.03238278f, 
    0.02625715f, 0.03059506f, 0.00838180f, -0.03447285f, 0.00295983f, 0.02267286f, -0.01659166f, -0.02623356f, 
    0.00203585f, 0.01385447f, -0.01712841f, 0.01523329f, -0.03082403f, -0.02484334f, -0.00519168f, -0.00706774f, 
    0.03122589f, 0.01743359f, -0.01973375f, -0.00033322f, 0.02979912f, 0.02664428f, 0.02140051f, -0.01400846f, 
    -0.03442419f, 0.02348421f, -0.01977720f, -0.02746559f, 0.01668577f, 0.01355912f, 0.00233484f, 0.00644817f, 
    -0.01896231f, -0.01728524f, -0.02286023f, -0.02385573f, 0.00937846f, 0.03688945f, 0.00069909f, 0.01809352f, 
    -0.03670732f, -0.01026239f, -0.01569522f, -0.03887852f, -0.03105016f, -0.02759297f, -0.00426849f, -0.02412852f, 
    -0.02842402f, 0.02945251f, -0.01745538f, -0.00570618f, 0.02529072f, -0.02760377f, -0.00511375f, -0.02645632f, 
    0.01881541f, -0.04065352f, -0.01201363f, -0.01870693f, -0.01413017f, 0.02156459f, -0.00013015f, -0.02323155f, 
    -0.01972776f, 0.02068635f, -0.03739511f, -0.02006301f, 0.03494832f, 0.01190863f, -0.01112219f, -0.03490212f, 
    -0.01977165f, 0.03282616f, 0.02426181f, 0.02290289f, 0.01304404f, -0.00200983f, 0.01323344f, 0.00818622f, 
    -0.03415101f, -0.02968957f, -0.01611025f, 0.02430058f, -0.02363311f, -0.00300044f, -0.00515439f, -0.00305009f, 
    -0.03803379f, -0.00048486f, -0.04199023f, -0.02510691f, 0.01800643f, 0.02424544f, -0.00445283f, -0.00403847f, 
    0.02216778f, -0.00282357f, 0.03843777f, -0.03368277f, 0.00673385f, -0.00592571f, 0.00038572f, 0.01482623f, 
    0.00772790f, 0.00178297f, -0.03574191f, -0.00823179f, 0.01500587f, -0.03438921f, -0.00521414f, 0.01085954f, 
    -0.03808346f, 0.00911168f, 0.00949797f, -0.02132839f, -0.03795871f, -0.02203764f, 0.01406464f, -0.02648149f, 
    0.01380827f, -0.04100523f, -0.01951766f, 0.00927384f, 0.02667430f, -0.01197702f, -0.03834194f, -0.00465497f, 
    -0.02205290f, -0.03532682f, 0.02064550f, 0.01642616f, -0.01922816f, -0.03558291f, -0.03591026f, 0.01097080f, 
    -0.00192692f, 0.01618826f, 0.01003407f, -0.01568127f, 0.02722159f, -0.02659444f, 0.03396628f, -0.00330896f, 
    0.03328850f, 0.03051322f, -0.04063248f, 0.01101071f, -0.00732000f, 0.02915650f, -0.00445855f, 0.01002109f, 
    0.01771836f, -0.00110809f, 0.02381108f, 0.03135198f, 0.02643591f, 0.03624666f, 0.02251388f, 0.00621004f, 
    0.01222728f, -0.00071111f, -0.02872035f, -0.00855319f, -0.01984883f, -0.00040639f, 0.02683205f, 0.01260868f, 
    0.00605654f, -0.01020005f, 0.01413076f, -0.02576287f, -0.00718152f, 0.00128616f, 0.01532646f, 0.00111620f, 
    0.02309528f, -0.02339068f, -0.01806943f, -0.00795968f, -0.01694626f, -0.03120386f, 0.03306995f, 0.00985317f, 
    0.03025855f, -0.02602917f, -0.02366634f, -0.02296983f, 0.03706199f, -0.03766891f, -0.03402091f, 0.01526219f, 
    0.02839859f, 0.00610013f, 0.02355888f, -0.00589924f, -0.02591546f, -0.03248613f, -0.01092109f, 0.01053187f, 
    0.01348533f, -0.02022483f, -0.01713576f, -0.01747817f, 0.00582135f, -0.01918644f, -0.02795726f, -0.02135321f, 
    0.02895456f, -0.02765496f, -0.00476039f, -0.02185288f, -0.02554574f, 0.00708272f, -0.01013318f, -0.00486487f, 
    -0.02139535f, -0.01278789f, -0.04017857f, -0.02690978f, -0.03959879f, 0.00315041f, -0.01006950f, -0.00703734f, 
    -0.02270749f, -0.03669970f, -0.00707235f, -0.01623804f, -0.02705292f, -0.02406540f, -0.02865219f, -0.00130950f, 
    0.00230519f, 0.03115676f, -0.00141045f, -0.03344600f, 0.02540338f, -0.01977003f, -0.03283551f, 0.00143811f, 
    -0.03858664f, -0.02058283f, -0.00626399f, -0.00333511f, 0.01851488f, 0.02166978f, -0.01537513f, 0.02776079f, 
    -0.00310448f, -0.00224156f, 0.02223972f, 0.02293414f, 0.01230449f, -0.01558504f, -0.01857591f, -0.00214403f, 
    -0.03782510f, 0.03041471f, -0.02917045f, -0.03212290f, -0.02885733f, 0.02937306f, -0.01763704f, 0.02318978f, 
    -0.03106103f, -0.00255038f, -0.02396278f, -0.03107220f, -0.02665911f, -0.00941532f, -0.03502142f, 0.03301268f, 
    0.00042706f, -0.02627902f, 0.02496924f, -0.00801507f, -0.02204190f, 0.02919467f, -0.02507555f, -0.00028753f, 
    0.03428518f, -0.02048902f, -0.02725716f, 0.02056109f, -0.04421525f, 0.01201393f, 0.01893564f, 0.00894797f, 
    -0.03586875f, 0.01819116f, -0.03018998f, -0.01331272f, 0.00082866f, -0.00832002f, -0.03907956f, -0.01488526f, 
    0.01439356f, 0.02060085f, 0.01698516f, 0.00655877f, 0.01280095f, 0.03231958f, -0.03774077f, -0.00757284f, 
    -0.01430397f, -0.02957296f, 0.00578022f, -0.00142100f, -0.03860584f, -0.03815403f, -0.00702375f, -0.01153788f, 
    0.00630872f, 0.00620317f, 0.00315806f, -0.03426664f, -0.03181371f, -0.01547881f, 0.02107073f, -0.01056140f, 
    -0.02182378f, 0.03025167f, -0.04049951f, -0.01181120f, 0.00862489f, -0.03327144f, -0.01102705f, 0.00803878f, 
    -0.01557279f, 0.01588170f, -0.03046610f, -0.01899839f, -0.02408340f, 0.02833860f, -0.02834646f, -0.01516736f, 
    0.02333440f, 0.02632542f, -0.02859995f, 0.03112778f, 0.01417388f, -0.00432512f, -0.00456842f, -0.01964729f, 
    -0.02423491f, 0.01232168f, 0.02221340f, 0.02082175f, -0.01889514f, -0.02046057f, -0.03917724f, -0.03462576f, 
    0.02097059f, 0.02561249f, 0.02468722f, -0.03278630f, 0.00705878f, 0.02609432f, -0.03594285f, 0.00466188f, 
    0.00711828f, -0.02828422f, -0.00639825f, 0.01285801f, -0.01505726f, -0.03325169f, -0.03317728f, -0.00559448f, 
    -0.03145948f, 0.00305442f, 0.02636351f, 0.00909667f, 0.02979809f, 0.00433925f, -0.01843683f, -0.02827597f, 
    -0.02426511f, -0.02201749f, 0.00876452f, -0.03959404f, -0.00042702f, -0.03186169f, -0.00247558f, 0.00591277f, 
    0.00132782f, -0.00950175f, -0.00173096f, -0.01872647f, -0.01141910f, 0.02061365f, -0.01083318f, -0.01628218f, 
    -0.04036180f, 0.02508815f, -0.00501470f, 0.02775756f, 0.02967611f, 0.03606967f, -0.01107729f, 0.00445343f, 
    -0.00886997f, 0.00350714f, -0.00639367f, 0.03281462f, -0.02855671f, 0.01068168f, -0.01055645f, 0.02426605f, 
    -0.00115746f, 0.02548462f, 0.01141944f, -0.01302437f, 0.02967965f, -0.03070821f, -0.02686989f, 0.00605521f, 
    0.01455297f, -0.01263964f, -0.00689430f, -0.02095315f, -0.02706942f, -0.02027197f, 0.02916354f, -0.03268879f, 
    0.01011181f, -0.02232503f, 0.02185979f, -0.02114791f, -0.01242885f, 0.01041376f, 0.00956897f, 0.00147066f, 
    0.01068191f, -0.01580820f, -0.01564666f, -0.00015668f, -0.01871824f, -0.03146047f, 0.03204527f, 0.01297330f, 
    -0.02652698f, 0.01324962f, -0.01811883f, -0.02649119f, 0.03847491f, -0.00876370f, 0.02932861f, 0.02033710f, 
    -0.02669603f, -0.00820180f, -0.00926195f, -0.01896152f, -0.03605847f, -0.00475592f, -0.03125582f, 0.02413019f, 
    0.03922205f, -0.01121363f, -0.00517088f, 0.02242529f, -0.00564611f, 0.01826910f, -0.02770511f, -0.03453275f, 
    0.00628841f, -0.01458550f, -0.02893719f, -0.01179985f, -0.01425532f, -0.03645084f, -0.03895537f, 0.02623893f, 
    0.03671905f, -0.00661204f, -0.01983401f, 0.03285293f, -0.02331045f, 0.02480487f, 0.00019978f, -0.04096584f, 
    -0.02370657f, -0.02985708f, 0.01576178f, -0.01213026f, 0.02119706f, -0.01096358f, -0.03205414f, 0.02172381f, 
    0.00593729f, -0.01440188f, -0.02768837f, 0.00416057f, -0.02504176f, 0.02237334f, -0.03675933f, 0.01558432f, 
    0.02448023f, 0.02123847f, -0.01376500f, -0.00239248f, -0.00962815f, -0.03953909f, -0.01449842f, 0.02007080f, 
    -0.04181420f, -0.00230828f, 0.00231503f, -0.00689233f, -0.03431486f, 0.03294736f, 0.03857252f, 0.03906098f, 
    -0.02244413f, 0.01103001f, -0.02370084f, 0.01815227f, -0.01319053f, -0.02537937f, -0.03071715f, -0.01164064f, 
    0.01837083f, 0.01464726f, 0.02042642f, 0.01725118f, 0.02401713f, -0.00382095f, -0.03096294f, 0.02461066f, 
    -0.03143206f, -0.03157990f, -0.01975799f, 0.02573979f, -0.00961953f, -0.03661910f, 0.01456986f, -0.04134905f, 
    0.01673602f, -0.01552749f, 0.02183471f, -0.03502075f, -0.01866862f, 0.01875031f, 0.02256309f, -0.00295909f, 
    0.00477234f, -0.03048230f, -0.02614523f, -0.00470934f, 0.00489142f, 0.01218807f, 0.00628964f, -0.00591029f, 
    -0.01103805f, -0.00911968f, 0.02934071f, 0.01103959f, 0.01467487f, -0.00846938f, -0.02148424f, -0.01165348f, 
    0.02755232f, -0.01935821f, -0.00341861f, -0.00367702f, 0.01928904f, 0.01223995f, -0.02848198f, -0.02785070f, 
    0.01067814f, 0.01495126f, -0.02056616f, -0.01054246f, 0.01577528f, -0.01052479f, 0.00647496f, 0.02833407f, 
    -0.01278857f, -0.03168150f, -0.01699576f, -0.00261426f, -0.01969709f, 0.00365790f, -0.00970288f, -0.00648172f, 
    -0.01764808f, -0.01911820f, -0.03403526f, -0.00194516f, 0.01995618f, -0.00823476f, -0.01031231f, -0.00784928f, 
    0.00362366f, 0.02204013f, -0.02509871f, -0.01932363f, -0.02452656f, -0.03989256f, -0.01682606f, -0.03385076f, 
    0.02583544f, -0.02080738f, -0.02422429f, -0.01450459f, -0.04074638f, -0.01484856f, -0.03190774f, 0.00088892f, 
    -0.02103412f, 0.02701929f, 0.01318175f, -0.04025943f, -0.00439188f, 0.02531585f, 0.01395942f, -0.00166240f, 
    -0.02295416f, 0.00451658f, -0.02476662f, -0.04158925f, -0.03096958f, 0.01645166f, -0.01206486f, -0.03045151f, 
    -0.02543495f, 0.04116632f, 0.02267708f, 0.00509437f, 0.02821111f, 0.02932689f, 0.02954773f, -0.04177669f, 
    -0.00369102f, -0.00181278f, 0.02426681f, 0.00582807f, -0.00162679f, 0.02938609f, -0.01129418f, -0.03573693f, 
    0.02098822f, -0.03788097f, 0.01701530f, -0.02893241f, 0.01560342f, 0.01207534f, -0.00073263f, -0.03527739f, 
    0.00499054f, 0.00896347f, 0.00335529f, -0.00398173f, -0.00091143f, 0.01716586f, -0.03947284f, -0.02097836f, 
    0.01669926f, 0.01976411f, -0.00024369f, -0.01503881f, 0.02797857f, 0.00493201f, -0.00042137f, -0.02141439f, 
    -0.02963840f, -0.02397059f, 0.03793059f, -0.02793185f, 0.00097763f, -0.00496826f, -0.00983256f, 0.02156219f, 
    0.01966304f, -0.02068924f, -0.03862517f, 0.00005000f, -0.02111647f, 0.00611025f, 0.02383038f, 0.02221098f, 
    -0.02321498f, 0.01727507f, -0.03961669f, 0.01638165f, -0.01792740f, -0.01412213f, 0.02934824f, -0.04094068f, 
    0.02273586f, -0.02290399f, 0.00924976f, -0.01350772f, -0.00293637f, -0.00106079f, -0.02448870f, 0.00461069f, 
    0.02016604f, -0.03995250f, 0.01858822f, -0.02091913f, 0.00987768f, -0.00854736f, 0.00838744f, 0.01465632f, 
    -0.02992691f, 0.00370367f, -0.03617694f, -0.00597070f, 0.00612050f, -0.02726400f, 0.03433196f, 0.01194562f, 
    -0.01753291f, 0.00589162f, -0.03549126f, -0.02320812f, -0.02451044f, -0.04020770f, 0.01370948f, -0.03195893f, 
    -0.01577538f, 0.00850378f, 0.00823646f, 0.01193954f, 0.01121255f, -0.02090537f, 0.00256046f, 0.00158465f, 
    0.02281423f, 0.00664432f, -0.03399996f, 0.00148607f, -0.02371196f, 0.02283721f, -0.00624627f, 0.02530775f, 
    -0.01738117f, -0.01379416f, -0.00248806f, -0.00653413f, -0.03412736f, -0.02242884f, -0.00678568f, 0.02321829f, 
    0.01371008f, -0.00232393f, 0.02591962f, 0.02380793f, 0.01430582f, 0.03835637f, -0.01369872f, -0.03844819f, 
    -0.02253156f, 0.00414280f, -0.02849233f, -0.02415919f, -0.02316149f, 0.00102679f, -0.00728523f, -0.03113329f, 
    -0.03614867f, 0.01171318f, -0.01776333f, -0.00106314f, -0.04168138f, 0.00526704f, -0.01630140f, -0.00891941f, 
    0.02364587f, 0.00810060f, 0.01672981f, -0.02056394f, -0.01862232f, 0.01440987f, -0.03144465f, -0.01640103f, 
    -0.03022084f, -0.01377655f, -0.03397735f, -0.03926704f, 0.01663722f, 0.01649524f, -0.02322886f, -0.02652490f, 
    0.01769678f, -0.03993886f, 0.00295146f, -0.01133382f, -0.03905021f, 0.02138227f, -0.01681363f, 0.00652872f, 
    0.02444655f, -0.03843822f, 0.02416924f, 0.02088098f, 0.02806520f, 0.00758383f, 0.00430360f, -0.02178015f, 
    0.00518152f, -0.04026676f, -0.01483653f, -0.00864835f, 0.02524473f, 0.00439421f, 0.02170539f, -0.01074677f, 
    -0.00605001f, 0.01893527f, 0.02635997f, -0.00833174f, 0.02901473f, -0.01657506f, 0.00112527f, -0.02344025f, 
    -0.00617992f, -0.00685429f, -0.01653565f, 0.02768759f, -0.02016956f, -0.02961240f, -0.02828600f, 0.00221847f, 
    -0.01825299f, -0.02389168f, 0.02563887f, -0.02164752f, 0.01525345f, 0.02121316f, -0.00319540f, -0.00463472f, 
    0.01706259f, -0.03861601f, -0.00730470f, -0.02636505f, -0.00906940f, -0.02445615f, -0.02359611f, 0.01799481f, 
    0.00102891f, -0.02036209f, 0.01824119f, -0.01823939f, 0.00583322f, -0.00007128f, -0.03647035f, -0.04153286f, 
    0.00408651f, -0.04184082f, 0.02450539f, -0.03666589f, 0.01017522f, 0.01678531f, 0.01944521f, 0.00917471f, 
    -0.01702400f, 0.03320107f, 0.00090882f, -0.02850179f, -0.02299268f, 0.02180723f, -0.01862896f, -0.02049891f, 
    -0.02547693f, -0.00047760f, 0.02427244f, -0.04196905f, -0.02704358f, -0.01041457f, -0.02297081f, -0.03948351f, 
    0.01937628f, 0.02723509f, 0.01650675f, 0.02511254f, 0.00454511f, -0.00843994f, -0.01739503f, -0.03831587f, 
    0.02016594f, -0.00484634f, -0.00504126f, -0.00349995f, -0.01980504f, 0.01133443f, -0.02570364f, -0.00226947f, 
    -0.02679384f, -0.03484775f, 0.00564413f, 0.02641253f, 0.02959635f, 0.00110904f, 0.02695340f, 0.01625058f, 
    -0.01768018f, -0.03107588f, 0.02532878f, -0.01064870f, -0.02010093f, -0.03759340f, 0.00399359f, 0.02392783f, 
    -0.03807795f, 0.02347928f, 0.01458687f, -0.00392061f, -0.00656033f, -0.01883056f, -0.03422197f, 0.00647329f, 
    -0.00527487f, 0.02352019f, 0.00505037f, -0.04200218f, -0.01857017f, 0.01343905f, -0.01110577f, -0.00459033f, 
    -0.00530194f, -0.00986143f, -0.00299027f, -0.04034138f, 0.02901712f, 0.00310577f, -0.02359978f, -0.01051840f, 
    -0.00612512f, 0.03443924f, -0.01166809f, 0.01547498f, -0.00169846f, -0.03309526f, 0.02688073f, 0.00523109f, 
    -0.03058604f, -0.00617196f, 0.01879917f, -0.01407209f, -0.00720282f, -0.03435696f, -0.02251058f, -0.00596474f, 
    -0.04012598f, -0.02708790f, 0.01093126f, -0.00133885f, -0.04190313f, -0.02522101f, 0.01018589f, -0.02092280f, 
    -0.01495805f, -0.02641385f, -0.00403231f, 0.00255399f, -0.03035242f, 0.01844851f, 0.02266496f, 0.00376250f, 
    -0.02766147f, 0.01426313f, -0.03265268f, 0.00077206f, -0.02406087f, -0.03431538f, -0.02324421f, -0.01383207f, 
    0.02303351f, -0.03259518f, 0.01675918f, 0.02869337f, -0.02250092f, 0.02615475f, 0.00410931f, 0.01746419f, 
    0.00185381f, -0.01808919f, -0.02622440f, -0.01303669f, -0.02498552f, 0.01058745f, -0.03241237f, 0.01443307f, 
    -0.01357582f, -0.02751729f, 0.00403673f, 0.02645572f, 0.00092545f, 0.01462041f, 0.00282871f, -0.00137860f, 
    0.01484527f, -0.00863465f, -0.00672704f, -0.03657320f, 0.02056029f, 0.02762305f, 0.01481015f, 0.01167447f, 
    -0.02099941f, 0.01354254f, -0.02107868f, 0.01472045f, -0.02318029f, -0.04172189f, 0.01979968f, -0.00586650f, 
    0.00916199f, 0.01546427f, -0.03007283f, -0.01167969f, -0.02648121f, 0.02575263f, -0.03444102f, 0.00886338f, 
    0.02974884f, -0.01511556f, -0.02776859f, -0.03965545f, -0.00919729f, 0.01147909f, 0.01118291f, -0.03332701f, 
    0.01647497f, -0.03575436f, 0.02986321f, 0.00009171f, 0.02952148f, 0.00298549f, 0.01537330f, -0.03612656f, 
    -0.03077986f, -0.03396384f, -0.02772222f, -0.02224382f, -0.02129491f, -0.03135512f, 0.00490713f, -0.04089777f, 
    0.00667450f, 0.00976243f, 0.01443690f, -0.00096721f, 0.01537282f, -0.02747024f, 0.02610096f, 0.02199504f, 
    0.02065260f, -0.01903573f, -0.00168598f, -0.02540453f, 0.02398529f, -0.01216677f, 0.00816009f, -0.01500885f, 
    -0.00429737f, 0.01990748f, -0.01891265f, -0.02310851f, 0.01526922f, -0.02260064f, -0.01480947f, -0.02719753f, 
    -0.00495231f, -0.00272172f, 0.00501130f, -0.02638068f, -0.01233448f, -0.01367652f, 0.01043454f, -0.02035670f, 
    0.00726852f, -0.00557258f, -0.03840716f, -0.03568719f, -0.01185469f, 0.00553826f, -0.00925552f, -0.02035483f, 
    -0.01987766f, -0.01120300f, -0.02055215f, -0.03422001f, -0.02399354f, -0.03843486f, -0.00303249f, -0.02070174f, 
    -0.02886268f, 0.01180820f, -0.02960211f, -0.03752725f, 0.02385415f, -0.02181865f, -0.03029037f, -0.03175078f, 
    0.01121680f, 0.00389483f, -0.00046399f, 0.00705421f, -0.03927092f, -0.02579045f, -0.01345169f, -0.01532109f, 
    -0.00166511f, -0.02766197f, -0.02783807f, -0.02267934f, 0.00715620f, -0.00648063f, 0.02847819f, -0.04043480f, 
    -0.00275442f, -0.02676982f, -0.03664172f, -0.00929326f, -0.00403289f, 0.00069796f, 0.01222226f, 0.00787900f, 
    -0.00739606f, -0.01347829f, 0.02363972f, 0.00032463f, 0.02045576f, -0.00310096f, -0.00435919f, 0.00643648f, 
    -0.00390306f, 0.01347716f, 0.02891782f, 0.00967670f, -0.03800205f, 0.01092357f, -0.02961392f, 0.00731323f, 
    -0.01508742f, 0.01494963f, 0.01069464f, -0.01218790f, -0.00602920f, -0.00888847f, -0.01970886f, 0.02563595f, 
    -0.03671761f, 0.02281833f, -0.00576559f, 0.00239346f, -0.03024220f, 0.01463747f, -0.01000253f, -0.01109587f, 
    -0.00660893f, 0.00515404f, -0.02616163f, 0.00575791f, 0.00378368f, -0.00568807f, 0.00574459f, 0.00533234f, 
    0.02424359f, -0.03418969f, -0.03638037f, -0.00900555f, -0.02693596f, -0.03088978f, -0.02019318f, 0.02500010f, 
    0.02225900f, 0.01763062f, 0.02139724f, 0.01129702f, -0.01530615f, -0.03789586f, -0.02703616f, -0.00230011f, 
    0.00390884f, -0.00658581f, -0.01158286f, -0.01096189f, 0.02370480f, 0.02279165f, -0.00363369f, 0.00429997f, 
    -0.00376373f, -0.01857579f, -0.03649108f, -0.01164923f, -0.00006461f, -0.01377310f, -0.03007664f, 0.00114368f, 
    -0.03677536f, 0.00177806f, -0.00111741f, 0.02210461f, -0.00880173f, -0.02844194f, -0.01635796f, -0.04181257f, 
    -0.00078719f, 0.03750435f, -0.02146061f, -0.03308890f, -0.02248570f, -0.00730985f, -0.01075287f, -0.00499990f, 
    0.01485011f, 0.00742504f, -0.04810365f, 0.01966839f, -0.00126398f, -0.03045045f, 0.01698990f, -0.03156948f, 
    0.02752864f, -0.01261451f, 0.02569209f, 0.00045711f, 0.00090702f, -0.04988950f, 0.00825882f, -0.04355523f, 
    -0.01837104f, -0.03142126f, -0.01281646f, -0.04673900f, 0.00141459f, -0.00274492f, -0.03190806f, -0.00834560f, 
    -0.02661236f, 0.01515176f, 0.01239647f, 0.02433677f, 0.01904192f, 0.00427388f, -0.02667064f, -0.02204786f, 
    -0.01375845f, -0.00884389f, -0.03934409f, -0.00976521f, -0.04162050f, -0.04148235f, -0.00276937f, 0.02665803f, 
    -0.00642271f, -0.03522338f, -0.04183213f, 0.00258599f, 0.02068185f, -0.00241698f, 0.02960608f, 0.01339897f, 
    -0.04033491f, 0.03869509f, -0.02592214f, 0.02337822f, -0.01818718f, -0.00031610f, -0.02329256f, 0.00256451f, 
    0.00190518f, -0.01038431f, -0.01661478f, 0.00729114f, 0.00202137f, 0.01534325f, -0.04500338f, -0.02153489f, 
    -0.02727490f, -0.00867467f, -0.02302632f, 0.03055146f, 0.01223824f, -0.03076497f, -0.03289076f, -0.01691278f, 
    0.01140271f, -0.05590603f, -0.01189372f, -0.03148263f, -0.03347276f, 0.00262727f, 0.01578986f, 0.02480633f, 
    -0.02557357f, 0.02535200f, 0.03271892f, 0.02763513f, 0.01608608f, -0.00940699f, -0.00633479f, -0.01624103f, 
    -0.03193677f, -0.03761038f, -0.02513211f, -0.01081425f, -0.02211096f, -0.02815071f, 0.01353791f, -0.02120305f, 
    0.03973249f, -0.00192967f, 0.00231977f, 0.00203958f, -0.04337394f, -0.02623065f, -0.00595618f, 0.00197872f, 
    0.03292810f, 0.01017739f, -0.02643515f, -0.03900931f, -0.00071549f, -0.00467763f, 0.01442176f, -0.04631468f, 
    -0.00976470f, -0.01914889f, -0.00398482f, 0.02261300f, -0.02601601f, 0.00954464f, 0.00505406f, -0.02339425f, 
    -0.04788991f, 0.01609967f, -0.03483411f, 0.02693877f, 0.02396283f, 0.00941796f, -0.01359915f, -0.01022505f, 
    -0.01631822f, -0.02970170f, 0.00066112f, -0.01507350f, 0.01542895f, -0.02825436f, -0.00087040f, -0.01093242f, 
    -0.00122847f, -0.03042331f, -0.02095759f, 0.02956626f, 0.01164867f, -0.01107456f, 0.00991520f, -0.01597607f, 
    0.00131140f, -0.00368535f, -0.02523547f, 0.01425784f, -0.01885236f, -0.01296786f, -0.03204861f, -0.03947220f, 
    -0.02441878f, 0.02307603f, 0.02775683f, 0.02484747f, 0.00472829f, -0.03842686f, -0.00475037f, 0.01133300f, 
    0.02298982f, 0.01161266f, 0.03671901f, -0.00645165f, -0.02679455f, -0.00115267f, -0.02452725f, 0.00677523f, 
    0.02439795f, -0.03876266f, -0.02497034f, -0.01353917f, 0.00050960f, 0.01688986f, -0.01351430f, -0.03456139f, 
    0.03082744f, 0.00610123f, -0.00956322f, -0.02642503f, -0.01418190f, 0.00457056f, -0.01222477f, -0.01725655f, 
    -0.02907194f, -0.01482848f, -0.00238141f, -0.00315535f, -0.03634069f, 0.00709398f, 0.00129425f, -0.01394155f, 
    -0.02393878f, -0.00356667f, -0.04113489f, -0.01972818f, 0.03066340f, -0.02763945f, -0.01587286f, 0.00057557f, 
    -0.03762886f, -0.02443107f, -0.00756328f, -0.01266444f, 0.02008560f, 0.01627130f, 0.02660073f, -0.01702858f, 
    -0.00512459f, -0.04279855f, 0.02219644f, 0.00731924f, -0.01533442f, -0.01737332f, 0.01572513f, -0.02192919f, 
    -0.02007130f, -0.03711190f, -0.00494102f, -0.01654501f, -0.02516258f, -0.03577977f, -0.01975867f, 0.00896591f, 
    -0.00865938f, 0.01153159f, -0.00502286f, 0.00024640f, 0.02259640f, -0.00108043f, 0.01065742f, -0.03699581f, 
    -0.02189501f, -0.02802972f, -0.02254103f, -0.03068516f, 0.02197393f, 0.02344996f, -0.01619742f, 0.01980160f, 
    0.00074118f, 0.01144651f, -0.02676740f, 0.01036323f, -0.02661555f, -0.00247493f, 0.01646697f, -0.03237453f, 
    0.00802022f, -0.03676750f, 0.01131250f, -0.01553540f, -0.01231409f, -0.02295420f, 0.02127079f, 0.03032186f, 
    0.00918748f, 0.01832542f, -0.03661831f, 0.02881414f, -0.00982774f, 0.00944009f, -0.01307891f, 0.00915379f, 
    -0.01227945f, -0.00593052f, 0.02731940f, 0.01493042f, -0.02785932f, 0.00698505f, -0.00340742f, -0.03571809f, 
    0.01065143f, 0.00232101f, 0.01758244f, -0.01767857f, -0.00896872f, 0.02630046f, -0.03840740f, 0.00420007f, 
    -0.03980122f, -0.02087218f, 0.00612048f, 0.02776450f, 0.02339605f, -0.00920657f, -0.02655390f, 0.00346789f, 
    0.00415185f, 0.01027254f, 0.00381158f, 0.00805697f, -0.04408888f, 0.00349246f, -0.01349538f, 0.01801787f, 
    -0.03803118f, -0.02864487f, -0.00076618f, 0.02334721f, -0.02902006f, -0.02805893f, 0.00029052f, -0.02658944f, 
    0.03202926f, 0.01696864f, -0.02716657f, -0.04118744f, 0.00266013f, -0.00946132f, -0.04187106f, -0.03597660f, 
    0.01825674f, -0.02784250f, 0.02117246f, 0.03271627f, -0.01871286f, 0.02713238f, 0.02618575f, -0.00533082f, 
    0.00824703f, -0.03846255f, -0.03842315f, -0.03402600f, -0.03046638f, -0.02295482f, 0.00561415f, -0.00012207f, 
    0.00982494f, 0.04303977f, -0.01076755f, -0.00838926f, -0.00568757f, 0.01731662f, 0.01823705f, -0.01140696f, 
    -0.01214547f, -0.03333040f, -0.03651579f, 0.00509012f, 0.01065182f, -0.01446243f, 0.01425862f, 0.02871033f, 
    0.02407706f, 0.00699785f, -0.01872786f, -0.03540669f, -0.02516399f, 0.00407170f, -0.03272291f, 0.01676778f, 
    -0.03959688f, -0.00514216f, -0.01523391f, 0.01193108f, -0.00262349f, 0.02819380f, 0.01931869f, 0.00858892f, 
    -0.02774194f, -0.02736597f, -0.00431732f, 0.02594098f, 0.01101836f, 0.00253836f, 0.01894814f, -0.00643838f, 
    -0.00555916f, 0.00418776f, 0.02232122f, -0.00106463f, -0.04255656f, 0.02042553f, -0.01138623f, -0.01170798f, 
    -0.02177056f, -0.02168514f, 0.00117125f, 0.00426701f, -0.00382882f, -0.01387321f, 0.01220798f, -0.03735255f, 
    -0.01090579f, -0.00304387f, -0.00276378f, -0.02425116f, -0.00794701f, -0.01040529f, -0.01030348f, 0.02992548f, 
    0.00098225f, 0.00685374f, -0.01671312f, -0.00671192f, -0.03171904f, -0.02685736f, -0.04362911f, 0.01325431f, 
    -0.00732385f, -0.01886131f, 0.02931047f, 0.01904131f, 0.01343465f, -0.02278873f, 0.01404379f, 0.01554365f, 
    -0.00723118f, -0.03704420f, 0.02332681f, -0.02604270f, 0.00176077f, 0.01825366f, -0.03463896f, -0.04152689f, 
    -0.03012342f, -0.02628271f, -0.03639953f, -0.02428626f, 0.00413795f, -0.02973687f, -0.03144956f, -0.00616930f, 
    -0.02722349f, -0.02938411f, 0.00784253f, 0.01478318f, -0.00654229f, 0.03350275f, 0.03181124f, 0.00605064f, 
    -0.00074834f, -0.02275500f, 0.00617856f, 0.02230408f, -0.00575240f, -0.02264919f, 0.00308236f, -0.03545269f, 
    0.01923256f, -0.02202103f, 0.00424417f, -0.04971075f, -0.02235076f, -0.01215380f, -0.03809519f, 0.00930651f, 
    -0.00892681f, -0.02306638f, -0.01598737f, 0.01431721f, 0.01696046f, -0.01084814f, -0.01282887f, 0.00128691f, 
    0.02314342f, -0.02691616f, -0.04868396f, -0.02435468f, -0.02019935f, -0.02438535f, 0.02306017f, 0.00013796f, 
    0.02507112f, 0.02276375f, 0.02166233f, 0.00659639f, 0.02555130f, 0.00607760f, -0.02824772f, 0.02932379f, 
    0.01043731f, -0.03193605f, -0.02404254f, -0.04091235f, 0.03034978f, -0.02471768f, -0.02361814f, -0.00585205f, 
    -0.00211675f, -0.01885650f, -0.00934059f, -0.02231286f, 0.00188801f, -0.01378125f, -0.01662914f, 0.01017386f, 
    -0.01086160f, -0.04634879f, 0.01381977f, -0.05312885f, -0.03960805f, 0.02281955f, -0.02093918f, 0.01676526f, 
    0.02499719f, -0.01775858f, -0.01470496f, 0.01321945f, -0.04670804f, -0.02872921f, -0.04909622f, -0.00756993f, 
    -0.03913864f, 0.00063800f, 0.01580127f, 0.02583904f, 0.01241758f, 0.00829404f, -0.04157135f, -0.00682859f, 
    -0.03986064f, -0.03445078f, -0.01797901f, 0.02336993f, -0.01295924f, -0.00215221f, -0.00369024f, -0.05230900f, 
    -0.02020810f, -0.01731119f, -0.01845230f, 0.02341939f, 0.00384834f, 0.02627398f, -0.01887742f, 0.02228527f, 
    -0.02009962f, -0.04198071f, -0.01293228f, -0.03631566f, 0.02128459f, 0.02233325f, -0.01226549f, -0.01340249f, 
    -0.02638092f, 0.03015012f, -0.01425908f, 0.01300099f, 0.00584657f, -0.04116188f, -0.02241338f, 0.01025254f, 
    -0.00325879f, -0.02743334f, -0.02080229f, 0.02449617f, 0.00093979f, -0.03245757f, 0.00833793f, 0.00893205f, 
    0.00293120f, 0.02988749f, -0.04541047f, -0.02101144f, -0.00156593f, 0.00233233f, -0.00882811f, -0.00608760f, 
    0.01937528f, -0.00466093f, -0.00191929f, 0.01993130f, 0.02012886f, 0.00212365f, -0.03568986f, -0.00140107f, 
    -0.04102112f, -0.01483497f, -0.03867873f, -0.03752299f, -0.03062942f, -0.02085697f, 0.03059419f, 0.02228860f, 
    -0.02487256f, 0.01071052f, 0.00608088f, 0.01077883f, -0.01112943f, -0.00477004f, 0.03072090f, 0.03874056f, 
    -0.05043109f, -0.00010760f, -0.01377491f, 0.00728097f, -0.02136845f, -0.00765085f, 0.02432751f, -0.03187133f, 
    -0.02743972f, 0.00880612f, 0.02154026f, -0.01232801f, -0.00865288f, -0.00985801f, -0.03289733f, -0.02088602f, 
    -0.02193750f, 0.01293160f, 0.01755613f, -0.02324963f, 0.03003893f, 0.02430647f, -0.03255921f, -0.00917615f, 
    -0.04308196f, 0.03167998f, -0.00273770f, -0.04162889f, -0.02352157f, 0.00665789f, -0.03141199f, 0.01862371f, 
    -0.03574554f, 0.00707437f, 0.01177013f, -0.00717170f, -0.03557267f, -0.03169150f, -0.03444102f, -0.01564270f, 
    -0.02441714f, -0.00750684f, -0.00819683f, 0.00054234f, 0.02208211f, -0.01849336f, 0.02438060f, 0.01470874f, 
    0.03566781f, -0.02628638f, 0.01245164f, 0.03338769f, -0.02311016f, -0.02160478f, -0.00013613f, -0.02206674f, 
    0.01074273f, -0.03614157f, 0.02297323f, 0.00330187f, -0.00854651f, 0.02789139f, 0.01951764f, -0.01453882f, 
    0.01403873f, -0.02117673f, 0.01002932f, -0.03600638f, -0.03867619f, 0.01801118f, 0.01819251f, 0.00644956f, 
    0.02127719f, 0.03328688f, -0.01661808f, -0.00865434f, 0.00289801f, 0.00160250f, 0.00488453f, 0.02877809f, 
    -0.01907687f, -0.01811205f, 0.01529284f, -0.02871152f, 0.02130035f, -0.00916781f, 0.00346746f, 0.01924478f, 
    0.02239374f, -0.00180787f, -0.02846332f, -0.01415958f, 0.01013524f, 0.00936733f, -0.00047086f, 0.00220679f, 
    -0.02924372f, 0.03173811f, -0.03213475f, 0.00007157f, 0.02910076f, 0.00231303f, 0.00331309f, -0.00782004f, 
    -0.01921476f, 0.00514625f, -0.03289756f, -0.00660331f, -0.00954503f, -0.02987865f, -0.03200021f, -0.01985252f, 
    -0.00540837f, -0.02812227f, -0.02566420f, -0.03555853f, 0.02892402f, 0.01815415f, -0.00921332f, -0.02895932f, 
    0.02119432f, 0.02528999f, 0.03967597f, -0.03521230f, -0.04199105f, -0.05140485f, 0.00104284f, -0.03842118f, 
    -0.01376623f, 0.00174490f, 0.03052949f, -0.00952302f, 0.00940688f, 0.00212017f, -0.01000131f, -0.03619067f, 
    0.00990916f, -0.04441818f, -0.01910699f, -0.04311995f, -0.02566124f, -0.00781019f, -0.00788195f, -0.02860896f, 
    0.00669958f, 0.01827022f, 0.00505932f, -0.02622087f, -0.03871171f, -0.03433055f, 0.01930249f, -0.01462717f, 
    -0.02819225f, 0.02041215f, -0.00099096f, 0.00435911f, 0.01554442f, -0.00248707f, 0.01736232f, -0.02764646f, 
    -0.02084170f, -0.01164392f, 0.01512340f, -0.02325634f, -0.02867004f, 0.03323371f, -0.02515966f, 0.01926280f, 
    0.00585223f, 0.02968326f, -0.02907521f, -0.02210491f, 0.00456116f, -0.02271096f, 0.00394255f, -0.02520637f, 
    -0.02174779f, -0.03354889f, -0.02398279f, -0.01770361f, -0.01290348f, 0.00684220f, -0.03798272f, 0.00563764f, 
    -0.03295427f, 0.01907184f, -0.01505957f, -0.02011421f, -0.03549317f, -0.01197724f, -0.03448225f, 0.01374143f, 
    -0.02612761f, 0.00221009f, -0.01362283f, 0.01909445f, -0.02653790f, -0.00509719f, 0.01339089f, 0.01446871f, 
    0.00866351f, -0.04056839f, -0.03865988f, 0.01466459f, 0.02116461f, 0.02040300f, -0.03681672f, -0.02433931f, 
    0.00050848f, -0.00056095f, 0.00777133f, -0.02736613f, 0.02272152f, 0.02402237f, -0.03614998f, -0.01177880f, 
    -0.03894466f, -0.02723792f, -0.01541987f, -0.01647005f, -0.02783273f, 0.00920831f, 0.01354188f, 0.00184243f, 
    -0.01685818f, -0.03383452f, -0.02678547f, -0.02113850f, -0.01101969f, 0.03662369f, -0.01686575f, -0.02361648f, 
    0.00908613f, 0.01473548f, -0.01418532f, 0.00766575f, -0.02200437f, 0.00988465f, -0.04044404f, -0.02328498f, 
    0.01182813f, -0.01788229f, -0.01396449f, -0.02568418f, 0.01242783f, -0.01393625f, -0.00203501f, 0.00468397f, 
    -0.02525728f, -0.02100357f, 0.00622114f, -0.01184035f, -0.02302691f, 0.01522419f, 0.01741481f, -0.00636805f, 
    0.01981235f, -0.01466460f, 0.00243551f, 0.02073758f, -0.02566211f, -0.02902434f, 0.00840916f, 0.00693101f, 
    0.01040508f, -0.01319266f, 0.02250056f, 0.01680298f, 0.00223176f, 0.00220350f, 0.01569177f, -0.02870307f, 
    0.00742773f, 0.02470505f, -0.00906744f, 0.00647541f, -0.00133506f, 0.00226249f, 0.00440756f, -0.03038636f, 
    -0.02897810f, 0.00700611f, -0.02982046f, -0.03195829f, -0.03258993f, -0.03918291f, 0.00762150f, -0.02523979f, 
    -0.03420662f, -0.04133616f, 0.01247845f, 0.01343361f, 0.00685295f, 0.01257812f, -0.00647948f, -0.03051827f, 
    0.01616157f, -0.00409228f, -0.03986354f, -0.01785583f, 0.00605945f, 0.01850126f, 0.02841024f, -0.02498945f, 
    -0.01677305f, -0.03104231f, -0.00747875f, 0.02420659f, -0.03686501f, 0.02465986f, -0.00615564f, -0.03556343f, 
    0.02683720f, 0.02564316f, -0.02303516f, -0.03726279f, 0.01017192f, -0.01800447f, 0.02043895f, 0.01621756f, 
    -0.02252791f, 0.00648007f, 0.02692434f, -0.01383848f, -0.03936577f, 0.00705836f, 0.00313456f, -0.01544080f, 
    0.01863649f, 0.02300293f, 0.01707110f, -0.04037294f, 0.02373862f, -0.02246555f, -0.01770049f, 0.00120560f, 
    0.02685330f, 0.01814904f, -0.01702634f, 0.01000909f, -0.00305029f, -0.03487679f, 0.00329414f, 0.00138206f, 
    0.02902580f, 0.01538849f, -0.01170437f, -0.01882213f, 0.00960506f, -0.02715779f, -0.00058820f, -0.02921639f, 
    0.01858702f, 0.02937038f, 0.02431789f, 0.00006308f, 0.00865208f, 0.00688739f, -0.00731102f, -0.03875010f, 
    0.01409669f, 0.01993728f, -0.03007458f, 0.00200962f, -0.01661117f, -0.02638751f, 0.01388155f, -0.02887146f, 
    -0.01718969f, -0.03211107f, -0.03730504f, -0.02530242f, -0.00933280f, -0.01181187f, 0.00669978f, 0.00784239f, 
    -0.02438262f, -0.00617524f, 0.02035716f, -0.03728435f, -0.00462528f, -0.03702326f, 0.02061225f, 0.00388959f, 
    -0.03036422f, -0.00359959f, 0.00113034f, 0.00891111f, 0.01978999f, -0.00529653f, -0.00202856f, -0.04202374f, 
    0.02054206f, -0.03238842f, -0.02985307f, 0.02383162f, 0.01678263f, -0.01136558f, 0.01885727f, -0.03219989f, 
    -0.03809432f, -0.00634133f, -0.02060488f, -0.00045012f, -0.00901593f, 0.02721226f, 0.02937500f, -0.02549564f, 
    -0.03791431f, -0.00020535f, 0.00069461f, 0.02534840f, -0.03457722f, 0.02019077f, -0.01332137f, -0.01795229f, 
    0.01175885f, -0.01035345f, -0.04144168f, 0.01004712f, -0.03193487f, -0.01325034f, -0.01060725f, 0.01497893f, 
    -0.00085676f, -0.03621420f, -0.01489471f, -0.03669470f, -0.02969895f, 0.02344420f, 0.00748479f, 0.01373961f, 
    -0.03291976f, -0.02383707f, 0.00554879f, 0.00252073f, -0.00474357f, -0.00935929f, 0.01740792f, 0.01610749f, 
    -0.01364965f, 0.02849014f, 0.00380872f, 0.01099438f, -0.02660188f, -0.01990631f, 0.00438016f, 0.01501488f, 
    -0.01894599f, -0.03007036f, -0.03006098f, 0.00594761f, 0.02520445f, -0.00950993f, -0.01543319f, -0.01946249f, 
    -0.04173062f, -0.03239651f, -0.00458908f, -0.02194092f, -0.03907360f, -0.03634223f, -0.01594815f, 0.00666396f, 
    0.00863989f, -0.02800295f, -0.02491249f, -0.03935352f, 0.00748814f, -0.03883724f, -0.02245060f, -0.00593214f, 
    0.00056567f, -0.04088715f, -0.03490940f, 0.02638976f, 0.00855973f, -0.02180977f, 0.02923165f, -0.03346398f, 
    -0.01052394f, -0.00184541f, -0.04108781f, 0.00835837f, -0.01044559f, 0.01019938f, -0.03108768f, 0.00247739f, 
    -0.02342962f, 0.00302607f, -0.01634935f, 0.00760233f, -0.02901353f, -0.00641688f, 0.02039808f, 0.00347179f, 
    -0.02084079f, 0.00462002f, 0.00785648f, 0.00033993f, 0.03878232f, 0.00871038f, -0.01370070f, -0.03788406f, 
    -0.02199205f, 0.01548605f, -0.02959625f, -0.01429668f, 0.02328179f, 0.01948158f, -0.04084355f, -0.01720196f, 
    -0.02994043f, -0.01657081f, -0.03278897f, 0.02537084f, 0.00884884f, 0.02919129f, 0.02003367f, 0.00263375f, 
    0.02592796f, 0.02685568f, 0.02940529f, -0.01573338f, -0.00630340f, -0.03620035f, -0.03046442f, -0.00393386f, 
    -0.04122503f, -0.02950987f, -0.03938077f, 0.01027814f, -0.03127389f, -0.01807803f, 0.01089395f, -0.00498596f, 
    -0.02029226f, -0.03398624f, -0.00354531f, 0.02747748f, 0.02075558f, -0.01361921f, -0.03936191f, -0.03321805f, 
    -0.03832927f, 0.00746070f, -0.01720865f, 0.00129866f, 0.02180262f, 0.02790477f, 0.01933325f, 0.02039547f, 
    0.01747048f, -0.00602276f, 0.01729990f, -0.03148443f, 0.02768375f, 0.00224979f, 0.00597326f, -0.02562637f, 
    0.03137604f, -0.00402609f, 0.01814755f, 0.01557505f, 0.02759144f, -0.00297523f, -0.01963818f, 0.01174410f, 
    0.02905136f, -0.02841430f, -0.01140826f, 0.02865598f, -0.03370436f, -0.03333410f, 0.01235438f, -0.01568761f, 
    0.01085011f, -0.00312214f, 0.01124809f, -0.00986457f, -0.00958108f, -0.00630874f, 0.01684421f, 0.02356834f, 
    0.03244768f, -0.02688678f, 0.01833125f, -0.03279985f, 0.00154972f, -0.03692413f, -0.03580465f, -0.00680648f, 
    -0.03564585f, -0.00575216f, -0.01980186f, -0.03387839f, -0.04118481f, -0.03932710f, 0.00163506f, 0.01874610f, 
    0.01096502f, 0.00082137f, -0.02570894f, 0.00089383f, 0.00345110f, 0.02349263f, 0.02936301f, -0.03252706f, 
    -0.02279433f, 0.00806865f, 0.00020640f, 0.02580201f, 0.00213945f, 0.01887489f, -0.04180896f, 0.02351487f, 
    -0.01454004f, 0.00461720f, -0.00266554f, 0.02571539f, -0.04140244f, 0.00412098f, 0.00673872f, -0.01718015f, 
    -0.02336799f, 0.01522939f, 0.00451932f, 0.01081903f, 0.01654263f, -0.02125035f, 0.02937906f, -0.03972256f, 
    -0.03242015f, 0.02253300f, 0.02187549f, -0.01816247f, -0.00069620f, -0.00739725f, 0.00166182f, 0.01682752f, 
    -0.04201459f, 0.01208381f, -0.03406828f, -0.01312578f, 0.02230816f, 0.01696803f, 0.02611657f, 0.00488877f, 
    -0.04027245f, 0.00598858f, -0.02997376f, -0.01323551f, 0.00172434f, -0.03847399f, -0.00284072f, -0.00792663f, 
    0.02879381f, 0.01335023f, 0.02246851f, -0.00914895f, 0.00272556f, 0.02220976f, 0.02084954f, -0.03931027f, 
    -0.01257829f, 0.00176308f, 0.01287012f, 0.01379062f, 0.01728828f, -0.02447295f, -0.01375442f, -0.03352184f, 
    -0.02217304f, 0.00060175f, 0.00690965f, 0.00002746f, -0.00274435f, 0.01404228f, 0.00059327f, -0.03814128f, 
    -0.01937513f, 0.01279482f, -0.00088554f, -0.00986010f, -0.00371483f, 0.02866570f, -0.00636768f, -0.01626037f, 
    -0.02244924f, 0.02956241f, -0.02571788f, -0.00792944f, 0.00585098f, -0.02341443f, -0.01466917f, 0.01634804f, 
    -0.01863255f, -0.00763380f, -0.01069864f, -0.01892086f, -0.03744764f, -0.00121838f, -0.02931894f, -0.02151034f, 
    -0.00399756f, -0.02458645f, -0.01152833f, -0.01443198f, 0.02910129f, -0.02653050f, 0.02258555f, 0.01932133f, 
    -0.02090207f, 0.02841640f, -0.03417816f, 0.02651142f, 0.02456711f, 0.02617534f, -0.04176285f, -0.04029492f, 
    -0.00267758f, -0.03518033f, 0.00681370f, -0.00604666f, -0.01581159f, -0.00032240f, -0.00039424f, -0.04084769f, 
    -0.01339417f, -0.01686072f, 0.01395653f, -0.01627680f, 0.02388692f, -0.03552052f, -0.00964100f, -0.01470575f, 
    0.02026557f, 0.02362810f, -0.04152428f, -0.01568310f, 0.00568778f, -0.03805812f, -0.04040112f, -0.02469567f, 
    -0.00512057f, -0.01343276f, 0.00071977f, -0.03086125f, -0.01792969f, -0.00442035f, -0.04107961f, -0.01003617f, 
    -0.02062772f, -0.03544771f, -0.02680254f, 0.00417933f, -0.02728990f, -0.00345855f, -0.03037718f, 0.00603402f, 
    0.01809645f, 0.02612662f, -0.02888335f, -0.00872130f, -0.02410023f, 0.00130833f, 0.02451203f, -0.00098177f, 
    -0.01714223f, -0.00364878f, 0.02116673f, -0.00601986f, 0.01768618f, -0.04142214f, -0.00161014f, 0.02238915f, 
    -0.00381733f, -0.02468369f, -0.00668373f, 0.00482624f, -0.03304590f, 0.00951629f, -0.01405417f, 0.00027011f, 
    0.02390901f, 0.02391480f, -0.00035420f, -0.02400704f, -0.00929191f, -0.02207542f, -0.02913286f, -0.02512334f, 
    -0.01565219f, 0.00466544f, -0.00504335f, -0.01648921f, -0.03316209f, 0.00813910f, 0.01450298f, -0.00741577f, 
    0.00418587f, -0.02078515f, -0.01211222f, 0.00223454f, 0.02004373f, -0.00615145f, -0.03230392f, -0.02835176f, 
    0.00188158f, 0.01055276f, 0.02391229f, -0.02631037f, 0.03941099f, 0.01735285f, -0.01414434f, -0.03276365f, 
    0.02694219f, 0.00343521f, -0.04123899f, 0.02373286f, 0.02685973f, 0.00932926f, -0.01965634f, -0.01798712f, 
    -0.01164880f, -0.00312241f, -0.03624828f, -0.02838629f, -0.03518188f, 0.01936847f, -0.01897879f, 0.01600691f, 
    0.00484306f, 0.00944382f, 0.02267417f, -0.02172992f, -0.02847273f, -0.00571241f, 0.02384390f, -0.00555311f, 
    -0.00310443f, -0.00531031f, 0.02641900f, 0.02834025f, -0.03061286f, -0.02364299f, -0.03634113f, -0.03246263f, 
    -0.02239709f, 0.00318025f, 0.00939088f, -0.03168402f, 0.01971884f, -0.00672161f, -0.03038386f, -0.04145687f, 
    -0.01113703f, -0.03782648f, 0.02853196f, 0.00381952f, 0.01672733f, -0.01940119f, 0.00657166f, -0.02833252f, 
    -0.01393793f, -0.01629592f, 0.00805031f, -0.00821315f, -0.04199045f, 0.02552672f, -0.01566698f, 0.01976332f, 
    0.01914224f, -0.03679945f, 0.01859547f, -0.02004195f, 0.00595568f, -0.02329694f, 0.01550778f, 0.02410266f, 
    0.00363477f, 0.01358605f, -0.00843618f, 0.00653789f, -0.03588327f, 0.02450079f, -0.03868232f, -0.02292892f, 
    0.00474336f, 0.01831154f, -0.02882096f, -0.01250508f, -0.00683455f, -0.04004178f, 0.01013589f, -0.02292080f, 
    0.01064920f, 0.01600768f, -0.00461031f, -0.03761651f, -0.02079710f, -0.01277339f, -0.03567941f, -0.02584643f, 
    -0.02429977f, -0.02861644f, -0.03001125f, -0.03728358f, -0.02249595f, 0.02218355f, 0.02277430f, 0.02719428f, 
    -0.03615729f, 0.02176245f, -0.03440592f, -0.01384163f, -0.04163514f, -0.03082067f, 0.02375052f, 0.01101716f, 
    0.00757747f, 0.00159340f, 0.00946017f, 0.02119080f, -0.03813814f, 0.00078667f, -0.02652780f, -0.01891010f, 
    0.01088073f, 0.02908504f, -0.01891272f, -0.01406080f, 0.01648599f, 0.03006634f, 0.02091788f, -0.01762297f, 
    -0.03343317f, 0.02846911f, -0.02781577f, -0.00570112f, 0.00236789f, 0.02346651f, -0.02620901f, -0.01006489f, 
    0.02281923f, 0.01029764f, 0.00606534f, 0.00431833f, -0.01039097f, -0.02371246f, -0.02114126f, 0.03000908f, 
    0.08589163f, -0.11767107f, 0.06130729f, 0.00455127f, 0.04009764f, 0.22836336f, 0.06710114f, 0.05782119f, 
    -0.04883171f, 0.03157221f, -0.08923924f, -0.06974100f, -0.13109060f, -0.13683873f, -0.00677237f, 0.06179221f, 
    0.26908597f, 0.05806716f, 0.01305087f, 0.10440511f, 0.04635954f, -0.11270600f, -0.01456825f, 0.03234892f, 
    -0.12963404f, 0.39157432f, 0.30252308f, 0.19252318f, -0.02866627f, -0.00137899f, -0.05466223f, -0.05920288f, 
    0.11964193f, 0.13056274f, 0.11503291f, 0.23000929f, -0.03967999f, -0.01358729f, -0.09156858f, 0.03625723f, 
    0.00082425f, -0.08561870f, -0.04844332f, -0.20173620f, 0.01662064f, -0.05255263f, -0.02871146f, 0.05155405f, 
    -0.35803252f, 0.07391465f, 0.32959491f, 0.17192134f, 0.13629889f, 0.14731511f, -0.16470036f, 0.20277038f, 
    0.01930475f, 0.20458724f, 0.13353536f, 0.01170900f, 0.26019713f, 0.12908682f, 0.06428830f, -0.25061944f, 
    -0.03220182f, -0.11651932f, 0.07516829f, -0.07381571f, -0.04742108f, 0.34568867f, 0.09077375f, 0.13647576f, 
    0.12194572f, -0.01949937f, -0.22153836f, 0.00051612f, -0.05632118f, -0.01535174f, -0.00218008f, -0.00726741f, 
    0.08431476f, -0.03572133f, -0.07696981f, 0.01473968f, -0.07286841f, 0.03313258f, -0.07554322f, 0.13279362f, 
    0.02487050f, 0.02796220f, 0.04824445f, -0.03398441f, 0.14351283f, 0.00464760f, -0.03050155f, -0.01534221f, 
    0.03298249f, 0.14262697f, 0.31430176f, -0.10648852f, 0.13586578f, -0.10151513f, -0.12097944f, 0.02143193f, 
    -0.02459238f, -0.03334961f, 0.05293344f, -0.00824974f, -0.15658371f, -0.14885312f, 0.21283530f, 0.13191818f, 
    -0.11994036f, 0.01992329f, -0.11218562f, 0.00826427f, -0.15389889f, -0.13159299f, 0.18453026f, 0.13185516f, 
    0.09977339f, -0.00125203f, -0.01708091f, 0.24367203f, 0.03592394f, -0.07431969f, -0.03888345f, 0.06093220f, 
    -0.07208958f, -0.03292548f, -0.03556510f, -0.12934229f, -0.10328008f, 0.32832581f, 0.45355657f, 0.06822845f, 
    0.03109912f, 0.07454210f, -0.23435774f, 0.13149591f, -0.00524525f, 0.06362506f, 0.15182945f, -0.07346758f, 
    0.18679044f, 0.00217791f, -0.08192040f, 0.04132105f, 0.02986722f, 0.02404103f, -0.00406706f, -0.15601839f, 
    0.05974773f, 0.08053114f, -0.08287304f, -0.06785978f, -0.04582353f, 0.00178410f, 0.08301985f, -0.05915513f, 
    -0.11877353f, -0.16618639f, -0.06221282f, 0.06203127f, -0.17712994f, 0.03231698f, 0.06439143f, 0.17556040f, 
    -0.00656569f, -0.11811462f, 0.04091753f, -0.02295519f, 0.09147962f, 0.10278770f, 0.00541505f, 0.00791143f, 
    -0.01705706f, -0.01889000f, -0.03503821f, -0.08826160f, 0.01102921f, -0.06881673f, 0.00255158f, 0.15565893f, 
    -0.10003973f, 0.00320619f, -0.12649752f, 0.12154686f, -0.00456258f, -0.02416296f, -0.03816827f, -0.07273719f, 
    0.19328782f, 0.42414117f, 0.34479079f, 0.13533510f, -0.05010062f, -0.14610155f, -0.08955088f, 0.07171317f, 
    0.00626994f, 0.07391927f, 0.11655921f, 0.20366620f, -0.04570230f, -0.00230167f, 0.15394428f, 0.09298109f, 
    0.09158015f, 0.02363504f, -0.01087505f, 0.03465361f, 0.10861272f, -0.02335325f, -0.02765839f, 0.04454737f, 
    0.01834999f, -0.07367599f, -0.04842410f, -0.08695654f, 0.13194224f, 0.06656695f, 0.02691106f, 0.05998830f, 
    -0.01627161f, -0.01885631f, 0.00909014f, 0.00966585f, 0.03547014f, -0.06205778f, 0.04459726f, -0.09353540f, 
    -0.03523394f, -0.03333292f, -0.06653790f, 0.05326907f, 0.00854206f, -0.08373380f, 0.05239492f, -0.06892824f, 
    -0.15210664f, 0.18930665f, 0.11785148f, -0.05097373f, 0.02720091f, 0.02999256f, 0.01309740f, 0.08991155f, 
    0.15442127f, 0.04724078f, 0.15425310f, 0.41492632f, 0.04500490f, 0.25334352f, 0.30889291f, 0.15702611f, 
    0.05610714f, -0.11224245f, -0.01536864f, -0.12476714f, -0.12209968f, -0.12109746f, 0.10627890f, 0.05339037f, 
    -0.11576594f, 0.04171269f, 0.17348136f, 0.03079679f, -0.03543326f, -0.16727464f, -0.14686507f, -0.13526802f, 
    0.07209126f, 0.03807499f, -0.06352206f, -0.04822646f, -0.12867439f, 0.08683854f, 0.01326255f, -0.03238616f, 
    0.21721336f, -0.25225225f, 0.08747993f, 0.10749672f, 0.18989268f, -0.01630703f, 0.05163549f, 0.02705517f, 
    -0.01259920f, 0.00747977f, -0.07315532f, 0.05157765f, 0.06733987f, 0.02776749f, -0.02848895f, -0.01798775f, 
    0.04611338f, 0.05101470f, -0.04316950f, -0.07951608f, -0.16612695f, -0.02120508f, 0.24613182f, -0.02473153f, 
    0.02328412f, -0.05393972f, -0.11173534f, 0.02230650f, 0.13355900f, 0.07383116f, 0.12017679f, 0.08376039f, 
    0.25183526f, -0.01010993f, -0.05975300f, -0.14123583f, -0.01155076f, 0.20426303f, 0.10688569f, -0.20674618f, 
    0.19249919f, 0.06370979f, 0.00419881f, 0.12181962f, -0.12243104f, 0.11472974f, 0.25683078f, 0.09523991f, 
    -0.13150299f, -0.14699423f, -0.18919091f, -0.11381860f, -0.14579731f, 0.08359685f, 0.11384370f, 0.13896087f, 
    0.27189654f, 0.08793450f, -0.29860997f, -0.05588100f, -0.03932136f, -0.04224827f, 0.22262590f, 0.06970644f, 
    0.16945453f, 0.01108040f, 0.18831544f, 0.16422632f, -0.20786636f, 0.08068603f, 0.24153493f, -0.07147056f, 
    0.13754572f, -0.02929213f, -0.16036317f, 0.11298078f, 0.02032026f, 0.04407201f, 0.05566010f, 0.03811635f, 
    -0.01315064f, 0.14156301f, -0.15424281f, 0.16018716f, -0.08096731f, -0.09334368f, 0.13033152f, 0.00664821f, 
    0.03573805f, 0.12576833f, 0.07447736f, 0.27174923f, 0.11371846f, 0.12267730f, 0.03851192f, -0.04437664f, 
    0.01057398f, 0.01156221f, 0.26164916f, -0.01115517f, 0.11693064f, 0.27900672f, 0.04677485f, 0.17366545f, 
    -0.03409870f, 0.15786825f, -0.15614438f, -0.07074766f, 0.01642632f, -0.04307865f, 0.16070724f, 0.00687604f, 
    0.02073463f, -0.07771388f, 0.03074448f, -0.04312634f, -0.12838328f, -0.14821669f, -0.08343181f, 0.00440444f, 
    -0.14374867f, 0.15477432f, 0.14661339f, 0.08108415f, 0.01306369f, 0.10823470f, 0.06445713f, 0.22697592f, 
    -0.01998040f, -0.00853098f, -0.04150203f, -0.00044428f, 0.09440615f, 0.01570532f, 0.02317997f, 0.01406047f, 
    -0.01856420f, -0.09659441f, -0.06096835f, 0.12341219f, -0.10452411f, 0.05887306f, 0.07183202f, -0.11817111f, 
    0.05348316f, -0.20186140f, -0.02912989f, -0.10263363f, -0.09149319f, -0.03903152f, 0.06350814f, -0.13188228f, 
    -0.01459136f, 0.14582008f, -0.09776186f, 0.07144694f, -0.06593058f, 0.02692885f, 0.00067127f, -0.02715947f, 
    0.12836418f, 0.25536096f, 0.15228803f, 0.14671232f, 0.14002404f, -0.03222312f, -0.14641826f, -0.05877252f, 
    -0.00341447f, -0.02443725f, 0.00317334f, 0.03512392f, 0.00423678f, 0.01577305f, -0.06900485f, -0.05303875f, 
    0.19672304f, 0.00354457f, -0.20753877f, 0.08501682f, -0.01494055f, -0.04450260f, 0.21175225f, 0.12232907f, 
    0.08507355f, 0.00978657f, -0.09113048f, -0.12507871f, -0.14464130f, -0.17239581f, -0.02371408f, 0.15447393f, 
    -0.10657445f, 0.01062208f, 0.02927117f, -0.07264299f, 0.08457529f, 0.02905624f, 0.02955572f, 0.07459815f, 
    0.00210899f, 0.36570257f, 0.25855279f, 0.01651269f, -0.00578500f, -0.11022488f, -0.04048010f, 0.12454978f, 
    0.08318957f, 0.19142535f, 0.16868582f, 0.11070511f, -0.05192041f, 0.18185012f, 0.12173923f, -0.07544493f, 
    -0.07930306f, -0.20177869f, -0.03761312f, 0.04506104f, -0.00201588f, 0.16260375f, 0.07253943f, 0.06906162f, 
    -0.07095266f, -0.08036512f, -0.15955935f, 0.33287388f, -0.07923666f, 0.20787600f, 0.13536263f, 0.13234276f, 
    -0.02308562f, -0.07840401f, -0.03012851f, 0.04327464f, -0.02067219f, 0.14629470f, 0.02382057f, -0.18800573f, 
    -0.07537846f, 0.02841625f, 0.07185762f, -0.10454372f, 0.06415094f, -0.02596146f, -0.12265898f, -0.23693715f, 
    -0.00463288f, -0.22390527f, -0.08135259f, 0.05068537f, 0.08780926f, 0.03884759f, 0.09180839f, -0.11138500f, 
    0.02723392f, 0.03238913f, -0.07983375f, 0.04144888f, -0.50216204f, 0.10136711f, 0.21397798f, 0.29058501f, 
    0.00079955f, 0.03618252f, -0.10566343f, 0.00933874f, 0.02917946f, 0.04401646f, -0.02048251f, -0.00787676f, 
    0.22219498f, -0.13941239f, 0.16804804f, -0.15577622f, 0.02877347f, 0.10168116f, -0.00911422f, 0.07481899f, 
    -0.02732458f, 0.19950059f, -0.01897841f, -0.11882010f, -0.00148323f, -0.00184929f, -0.09449602f, 0.08254701f, 
    0.01856139f, -0.13010223f, -0.10238411f, 0.05239340f, -0.01529195f, 0.00084847f, -0.05653431f, -0.09362149f, 
    -0.07935435f, 0.03879608f, -0.09329739f, 0.13479897f, -0.01099481f, 0.00861820f, -0.01818068f, -0.14777327f, 
    0.01698162f, 0.09015569f, 0.09726568f, 0.14756007f, -0.27358115f, 0.12206984f, -0.15514326f, 0.11749106f, 
    -0.04355077f, -0.14474374f, 0.16927633f, -0.00166797f, 0.02102695f, -0.09860694f, -0.08087067f, -0.02023042f, 
    0.00541823f, -0.01754211f, -0.02171629f, -0.09352504f, 0.05516319f, 0.06220028f, 0.06935714f, 0.02386469f, 
    0.02206101f, -0.13559769f, -0.06002140f, 0.16878508f, 0.00337178f, -0.00309860f, -0.10610389f, -0.04926579f, 
    0.00006780f, 0.13814726f, 0.10274471f, 0.07465196f, -0.01998180f, 0.00073466f, -0.06736625f, -0.00195146f, 
    0.05393783f, -0.18974110f, 0.06561159f, 0.04665982f, -0.00791663f, 0.05385776f, 0.05949455f, -0.04430598f, 
    -0.07714113f, 0.05564470f, -0.05745797f, -0.00137286f, -0.07949153f, -0.02110252f, -0.01655651f, 0.27073669f, 
    0.05793878f, 0.04738493f, 0.04185453f, 0.04189137f, -0.09431477f, -0.01959505f, -0.02410531f, -0.01116708f, 
    -0.14761879f, -0.13493319f, -0.05484535f, 0.03932548f, -0.00445050f, -0.11801370f, -0.16710863f, 0.00997698f, 
    -0.09983662f, -0.08746365f, -0.06390662f, -0.03823854f, -0.14411974f, -0.09458379f, 0.07548086f, -0.14529584f, 
    0.02288079f, 0.11775081f, 0.12881900f, 0.09175253f, -0.00134174f, 0.02785949f, 0.04291552f, 0.27401495f, 
    0.08777159f, -0.09351380f, 0.07178832f, 0.16909778f, 0.01716598f, 0.07182505f, 0.13276467f, 0.04830608f, 
    -0.05296932f, -0.05820960f, -0.02257839f, -0.07693274f, -0.22232017f, -0.01794478f, 0.25018314f, -0.01022904f, 
    -0.05769662f, -0.08660062f, -0.22720341f, 0.10683250f, 0.02160865f, -0.05215370f, -0.01672827f, -0.02200241f, 
    0.03279837f, -0.19949369f, -0.00455128f, 0.04199562f, 0.03518087f, -0.00315339f, 0.07293402f, -0.01508264f, 
    0.16833395f, 0.14848205f, 0.13462763f, 0.38786948f, -0.11832425f, -0.02764056f, 0.09581306f, 0.10647080f, 
    0.05174188f, -0.10133887f, -0.21300553f, -0.13251700f, 0.06818561f, 0.09230234f, -0.06017860f, -0.07900225f, 
    -0.16699791f, -0.18155688f, 0.20249669f, 0.08283582f, 0.06320544f, 0.03128128f, -0.03512700f, 0.07440409f, 
    -0.02051836f, -0.00035888f, 0.09623808f, 0.23107825f, 0.16845421f, 0.13146758f, -0.03798178f, -0.04505298f, 
    -0.03626846f, -0.06611300f, 0.01509853f, -0.15271251f, 0.10327127f, 0.08550654f, 0.24637638f, 0.19553375f, 
    -0.27451727f, 0.06695152f, -0.00641548f, 0.15557928f, 0.03152371f, 0.04276743f, 0.02100387f, 0.02045240f, 
    -0.05523425f, -0.09367420f, -0.04802317f, 0.02198952f, -0.28556401f, 0.12141607f, -0.00209639f, 0.05962302f, 
    0.03087148f, -0.02557268f, 0.05627760f, -0.00739511f, -0.07733633f, -0.05733399f, -0.07260700f, 0.01226466f, 
    -0.08717678f, -0.20080319f, 0.57498050f, 0.17161861f, -0.00538936f, 0.01034803f, -0.03921018f, -0.00932607f, 
    -0.01767104f, 0.01878378f, 0.03490853f, 0.05568435f, 0.05933003f, 0.27779675f, -0.14033976f, -0.10065334f, 
    0.04804609f, -0.11298834f, 0.03916483f, -0.05449361f, -0.02961890f, -0.06516214f, -0.02266433f, 0.00036017f, 
    0.06941788f, -0.10864456f, -0.07668955f, -0.01526660f, 0.11178371f, 0.10333046f, 0.12204705f, 0.08581970f, 
    0.00536699f, 0.10912795f, -0.08987822f, 0.11655969f, 0.15541542f, -0.11599417f, 0.06083088f, 0.22467425f, 
    0.02467187f, 0.04480591f, -0.01387528f, -0.01146907f, 0.02806087f, -0.00118388f, -0.02916879f, 0.04448916f, 
    -0.04500633f, 0.16676277f, 0.04358624f, -0.08490369f, 0.09088168f, -0.01155488f, 0.07526587f, 0.03939100f, 
    -0.08937535f, -0.06538586f, 0.06041298f, 0.05567493f, -0.47141773f, 0.04030796f, 0.14549883f, 0.18263739f, 
    -0.03681963f, 0.09298467f, -0.21052513f, -0.07967662f, 0.03567547f, -0.04452968f, 0.08347111f, 0.00794232f, 
    -0.09559515f, -0.11637756f, 0.04774619f, 0.14650263f, 0.05096022f, 0.14111595f, 0.09067295f, 0.15079291f, 
    0.02954125f, -0.03569498f, -0.00091347f, 0.00395903f, 0.17743452f, -0.18595076f, -0.03641468f, -0.18693390f, 
    0.00222725f, -0.02902836f, 0.05744205f, 0.11181980f, -0.11963759f, 0.05810002f, -0.16234291f, 0.00757681f, 
    0.59263527f, 0.19561598f, -0.20746551f, 0.29932612f, -0.04859863f, 0.01871104f, -0.03210189f, -0.07413740f, 
    0.04019572f, -0.00425139f, 0.06605663f, 0.03115057f, 0.23711689f, 0.01083437f, 0.07009558f, -0.00176534f, 
    -0.00393990f, -0.05258964f, 0.00820206f, -0.05942715f, 0.03722139f, 0.05818796f, 0.01171886f, -0.02017873f, 
    0.00131340f, -0.05810570f, -0.01674008f, -0.15148455f, -0.05209101f, -0.08009437f, 0.00919622f, -0.01435177f, 
    -0.05320381f, -0.05686365f, 0.04713541f, 0.10386074f, 0.04615238f, -0.00195356f, -0.20560905f, 0.19384173f, 
    -0.02044289f, 0.03447822f, 0.11699134f, -0.03400831f, -0.03067023f, 0.07598928f, 0.04733640f, 0.02840751f, 
    -0.18299894f, -0.11963111f, -0.06588741f, 0.08014975f, 0.00806100f, 0.01408229f, 0.06405061f, 0.05346089f, 
    -0.01282818f, -0.05180453f, -0.01805476f, 0.06964386f, 0.01148281f, -0.05487033f, -0.00780590f, 0.12886155f, 
    0.00823389f, -0.05828340f, 0.06334868f, 0.01186041f, 0.04668774f, -0.04366683f, -0.10154658f, 0.09478500f, 
    -0.00463960f, 0.26396966f, -0.20843190f, -0.07647757f, -0.07767550f, 0.04507640f, -0.16647188f, 0.03550299f, 
    -0.14337488f, -0.08210709f, 0.08125801f, 0.09125570f, -0.04972314f, -0.13251394f, -0.20414840f, 0.24813463f, 
    0.04955870f, 0.03442330f, -0.04228016f, 0.01678031f, -0.03669287f, 0.05829620f, -0.05756828f, -0.05974050f, 
    -0.36197212f, -0.05194913f, 0.09382559f, 0.26714602f, -0.04487925f, 0.01190258f, 0.12879328f, 0.01033370f, 
    0.09099614f, -0.04715632f, -0.02936208f, 0.05288745f, -0.04804172f, 0.00396840f, -0.11716678f, -0.16651262f, 
    0.03109624f, -0.01242546f, 0.09854012f, -0.01561918f, -0.09464012f, 0.10332865f, 0.00733927f, -0.03271582f, 
    -0.23352164f, 0.03182945f, -0.17202485f, -0.01959329f, -0.05463379f, -0.06409051f, -0.07634570f, 0.09485991f, 
    -0.15022086f, 0.06000866f, -0.00900614f, -0.08002812f, 0.23632851f, 0.02944611f, -0.00826979f, 0.14911246f, 
    0.01445483f, 0.12552950f, 0.04427766f, -0.01520309f, 0.06029084f, 0.01567667f, 0.11775261f, 0.03973817f, 
    -0.14169273f, 0.17049856f, -0.14535831f, 0.08048353f, 0.00036274f, 0.05311152f, 0.01410401f, -0.02064575f, 
    0.11801101f, 0.35726762f, 0.14241190f, -0.11731503f, -0.04606694f, -0.05156473f, -0.00664367f, 0.19826052f, 
    0.05808857f, 0.04626410f, 0.06176469f, -0.05722016f, 0.00139930f, 0.06386310f, 0.00633582f, 0.03350297f, 
    0.13012511f, -0.02684072f, -0.24876301f, -0.07181013f, 0.00861967f, -0.02031548f, 0.11147600f, 0.05816074f, 
    -0.03066171f, 0.03409310f, 0.03149188f, -0.00059140f, 0.64023054f, -0.18216920f, -0.01480723f, 0.16057791f, 
    -0.07280379f, 0.16567503f, -0.05901695f, 0.13889833f, -0.03261419f, 0.08918066f, -0.02557824f, -0.01243033f, 
    -0.23756492f, -0.02238357f, -0.05453085f, -0.06220399f, 0.00938507f, -0.07278259f, -0.09208235f, 0.12662214f, 
    -0.09287131f, -0.09229469f, 0.01281679f, -0.06513269f, 0.19584972f, -0.08748268f, -0.27151164f, 0.00592233f, 
    -0.03959050f, -0.00699467f, -0.09036856f, 0.05075836f, -0.01101327f, 0.04931429f, -0.00495567f, -0.05789953f, 
    -0.26950556f, 0.00634420f, 0.25255346f, 0.15367113f, 0.13044252f, 0.11930285f, -0.19034664f, 0.03605246f, 
    0.08006590f, -0.00516860f, -0.04735984f, 0.07337231f, -0.20259166f, -0.11027741f, -0.06884397f, 0.26276615f, 
    0.04586099f, -0.15849622f, 0.18246131f, -0.09007531f, 0.01174266f, 0.08152948f, -0.01075317f, -0.04032429f, 
    0.52052510f, -0.16769756f, 0.29576224f, 0.00786024f, -0.07556044f, 0.14692654f, -0.08177397f, -0.00145847f, 
    0.00616858f, 0.02259494f, 0.08197238f, 0.01706533f, 0.09761632f, 0.07556215f, 0.01925199f, 0.16275813f, 
    0.08467245f, 0.14293261f, 0.04842574f, -0.00520360f, 0.01685338f, -0.03973014f, 0.13056438f, -0.00008984f, 
    -0.12782709f, -0.06147066f, 0.08287800f, 0.03456671f, -0.04069559f, -0.00845174f, -0.02419765f, 0.03464355f, 
    0.04528792f, 0.04635729f, 0.12843359f, 0.00543543f, -0.35734448f, 0.01926202f, -0.07455836f, 0.13043553f, 
    -0.07510439f, 0.00334171f, -0.07703040f, -0.10658105f, 0.00198638f, 0.01885612f, 0.02899963f, 0.01740219f, 
    0.42291579f, -0.00540889f, 0.07853562f, 0.03381149f, -0.12473062f, 0.00473487f, -0.08684202f, -0.00031699f, 
    0.01381159f, -0.01557607f, -0.06338078f, 0.08678665f, -0.11685548f, -0.01166157f, -0.00181556f, 0.12339437f, 
    0.03540258f, -0.05691969f, -0.02657194f, -0.08796448f, 0.03773280f, -0.00188480f, 0.01678706f, -0.07487249f, 
    -0.13250004f, -0.01173970f, -0.06662522f, -0.04007517f, -0.02821562f, -0.02509486f, 0.03517577f, 0.00627978f, 
    -0.03165073f, -0.00683710f, -0.12704657f, -0.02856995f, -0.21217461f, 0.01271834f, 0.03654889f, 0.18639237f, 
    -0.10084064f, 0.13779140f, 0.05531421f, -0.04057152f, -0.06954588f, 0.05845065f, -0.01427898f, 0.00352661f, 
    -0.03307075f, -0.15683241f, -0.06442900f, -0.05799636f, 0.05574124f, -0.03054342f, 0.01366212f, 0.01180039f, 
    -0.04887103f, -0.02931882f, -0.04392859f, 0.03097847f, -0.19086923f, -0.11052378f, 0.01767581f, 0.11362573f, 
    -0.18210530f, -0.11567412f, 0.00045744f, 0.01749855f, -0.08402222f, -0.21002831f, -0.08037207f, -0.01780083f, 
    -0.48897076f, 0.07943001f, 0.23139036f, 0.03093462f, -0.03263037f, 0.04212510f, -0.13374534f, -0.01625398f, 
    -0.12597047f, -0.00247437f, 0.03698424f, -0.02242661f, 0.18966188f, -0.05347907f, 0.06889846f, 0.13263969f, 
    0.02040591f, 0.00961590f, 0.13238434f, 0.03969167f, -0.06610841f, 0.02574957f, -0.05206859f, 0.08510804f, 
    0.00293957f, -0.00824358f, 0.03315178f, 0.23160310f, 0.00456177f, 0.08687207f, 0.06831235f, -0.04541105f, 
    -0.02102601f, 0.01453277f, -0.08406390f, 0.23687489f, 0.02859198f, -0.13131683f, -0.04855922f, 0.12781137f, 
    0.06494355f, 0.07402817f, 0.03776327f, -0.01930412f, 0.02407681f, -0.01108107f, -0.03734146f, 0.07068243f, 
    0.02100117f, 0.42111686f, 0.33299541f, -0.00637152f, -0.07618066f, -0.11678420f, -0.04082004f, -0.06635761f, 
    -0.08583568f, 0.09882620f, -0.03386516f, 0.07326296f, 0.50606859f, -0.02808657f, -0.02072328f, 0.19676831f, 
    0.07586308f, -0.06879935f, -0.02448616f, 0.00031901f, 0.03332006f, 0.08203091f, -0.15060593f, 0.05375617f, 
    0.09125751f, -0.02745265f, 0.02988034f, -0.00428454f, -0.00809883f, -0.03622497f, -0.04031907f, -0.00950180f, 
    -0.04640027f, 0.04989667f, -0.12623130f, -0.05254847f, 0.29077914f, -0.06461672f, -0.28244531f, -0.30960894f, 
    0.01446859f, 0.06615925f, 0.02520634f, 0.04924192f, -0.02094920f, 0.14721753f, -0.14653587f, -0.10223015f, 
    -0.28271532f, 0.08716902f, -0.12049819f, -0.08813750f, 0.09560665f, 0.05287708f, -0.00647969f, -0.18617193f, 
    -0.05214317f, 0.10386975f, 0.12242392f, -0.05386079f, 0.03735715f, -0.00325756f, -0.09838000f, 0.07943952f, 
    0.03438895f, 0.19246218f, 0.06105368f, -0.00637044f, -0.05699730f, 0.12613228f, 0.02030789f, -0.03574990f, 
    0.27700675f, 0.02759832f, 0.07858519f, -0.12048812f, 0.02960133f, 0.07478646f, -0.07807327f, -0.13669249f, 
    0.11270744f, 0.02671963f, -0.05080289f, 0.04000525f, 0.48300886f, -0.03162917f, 0.11170567f, -0.07025574f, 
    -0.10025526f, 0.03714544f, -0.05068466f, 0.09395210f, -0.01503294f, -0.13193358f, 0.14033321f, 0.00679051f, 
    -0.09424277f, -0.01838996f, 0.21080026f, 0.05015687f, -0.08703683f, -0.00574762f, 0.03318977f, 0.07256246f, 
    0.16230817f, 0.03346541f, 0.03956620f, -0.04760361f, -0.33990997f, -0.08427628f, 0.39071891f, 0.04572506f, 
    -0.09090482f, -0.10379628f, -0.17298330f, 0.05808645f, -0.05617256f, -0.01834862f, -0.09238055f, -0.02630934f, 
    -0.17731774f, 0.10109796f, 0.19243918f, -0.09549398f, -0.01392291f, -0.11987763f, -0.17559597f, -0.02498472f, 
    -0.05048643f, -0.04732949f, 0.03450292f, -0.00838043f, -0.17490515f, 0.12557274f, 0.00121945f, -0.22430405f, 
    -0.01339495f, -0.12728684f, -0.03537867f, 0.08640598f, -0.18669920f, 0.09152202f, -0.08856506f, -0.00451350f, 
    -0.11351352f, -0.03761236f, -0.10675147f, 0.03029589f, 0.02315586f, -0.02226425f, 0.00055552f, 0.00683057f, 
    0.00408216f, -0.07074276f, -0.04416580f, -0.00655520f, 0.14114562f, 0.03011487f, 0.00742617f, 0.17382514f, 
    -0.02809563f, 0.04628503f, 0.02266795f, 0.00860178f, 0.10475704f, 0.01269490f, -0.05370969f, -0.14113450f, 
    -0.24945579f, 0.19142464f, -0.06894043f, 0.07261802f, -0.15564574f, -0.15004764f, -0.07927743f, -0.09367597f, 
    -0.02623795f, 0.05088062f, -0.00997734f, 0.09264197f, 0.18786833f, -0.00181289f, -0.16703911f, -0.09264201f, 
    0.10131452f, -0.02716464f, 0.10001597f, 0.08090004f, 0.11482763f, 0.02970676f, -0.06404457f, -0.02490961f, 
    -0.30631551f, 0.05732672f, -0.09905026f, 0.07594867f, 0.04393573f, -0.01055103f, 0.05700826f, 0.01589165f, 
    0.16624181f, 0.08201551f, -0.03482169f, -0.05406148f, 0.19568591f, 0.00686241f, -0.18590136f, -0.11549726f, 
    0.12120348f, 0.03706226f, 0.15413189f, 0.07855865f, 0.02592591f, 0.00907899f, -0.04320369f, -0.04134028f, 
    -0.01990641f, 0.22185919f, -0.24397534f, -0.23799437f, 0.07946796f, -0.02713772f, 0.20566134f, 0.01454197f, 
    -0.13886702f, 0.06680885f, -0.00255530f, 0.09786333f, 0.28322127f, 0.09193187f, -0.04868597f, 0.15582399f, 
    0.07219402f, -0.01507660f, -0.14241482f, -0.10781702f, -0.06923348f, 0.27832720f, -0.12135033f, 0.15251574f, 
    0.28778791f, 0.43624845f, -0.11228650f, 0.05235077f, -0.03976194f, -0.17467567f, -0.01479200f, -0.01339896f, 
    -0.01508610f, 0.06575695f, 0.10413392f, 0.01436662f, 0.29608107f, -0.05590266f, 0.01531467f, 0.04092826f, 
    -0.01132309f, 0.11065339f, -0.04408530f, -0.06447849f, 0.12920329f, 0.15408079f, -0.07146422f, 0.09160882f, 
    -0.16989897f, 0.28455758f, -0.22505400f, 0.11419030f, 0.08929448f, 0.21170923f, 0.05575821f, 0.05723635f, 
    0.26328498f, -0.06351735f, -0.09884687f, -0.08845613f, -0.04944103f, 0.05993627f, -0.07287358f, -0.19226773f, 
    0.18464893f, 0.01955331f, 0.18642136f, 0.06599537f, -0.04732890f, -0.06891858f, -0.17544101f, -0.10682086f, 
    -0.06903836f, -0.20391735f, -0.05220608f, -0.09600224f, 0.09188044f, 0.03904384f, 0.12782709f, 0.10602843f, 
    0.06974371f, -0.01415003f, 0.03936124f, -0.04030887f, 0.01375117f, -0.03216178f, -0.06113595f, -0.00382903f, 
    0.01491650f, 0.03021333f, 0.02169583f, 0.00213710f, 0.06002199f, -0.07101426f, 0.04441470f, 0.03215067f, 
    -0.13955304f, 0.04229381f, -0.05148159f, -0.01976726f, -0.16265585f, -0.02287767f, -0.13213782f, 0.20524330f, 
    -0.06054461f, -0.01508661f, -0.02239713f, 0.00750886f, -0.03772542f, -0.01557693f, -0.28197134f, 0.46662873f, 
    -0.02401146f, 0.03219198f, -0.02861271f, -0.17930834f, -0.09702577f, 0.02066840f, -0.02125224f, -0.00906182f, 
    0.23830798f, 0.30194622f, 0.15348375f, 0.28811756f, 0.05354876f, 0.06066688f, -0.07386119f, 0.24032474f, 
    -0.02125264f, -0.01607739f, -0.20807573f, 0.01848849f, -0.13246946f, 0.13302462f, 0.09565056f, -0.06624343f, 
    -0.02099106f, 0.03747663f, -0.12232561f, -0.05582636f, -0.10441948f, 0.19613583f, -0.13784303f, 0.00035436f, 
    -0.02413894f, 0.10168590f, -0.04659634f, -0.09202828f, -0.04483213f, 0.19155617f, 0.10197280f, 0.09817417f, 
    0.01662004f, 0.13433193f, -0.02820431f, -0.03120217f, 0.20400476f, 0.15195100f, -0.12747088f, -0.05132498f, 
    0.12960161f, 0.13141958f, 0.14282967f, -0.02897827f, 0.08850645f, -0.05181830f, 0.04353582f, 0.11950726f, 
    -0.14269969f, -0.09371103f, 0.21143112f, -0.17040952f, -0.07915889f, -0.08197878f, -0.08336622f, -0.13579080f, 
    -0.00965953f, -0.00536700f, -0.21682632f, 0.01040996f, 0.10327132f, 0.08481903f, 0.05425210f, -0.00398350f, 
    0.08908442f, 0.14234230f, -0.07884924f, 0.00105183f, -0.00741660f, 0.01935709f, -0.00855190f, -0.00334173f, 
    0.00258882f, 0.12689225f, -0.00539893f, 0.05662384f, -0.01192105f, -0.11382737f, -0.02215286f, 0.12867516f, 
    0.05275185f, 0.13883796f, 0.05946291f, -0.10612153f, 0.10827203f, 0.19300650f, -0.17106073f, 0.21729544f, 
    0.06538150f, -0.10343501f, 0.06542252f, 0.03374720f, 0.03191043f, -0.03722458f, 0.08769158f, 0.02201267f, 
    -0.12062358f, 0.17552462f, -0.21299084f, -0.00848021f, 0.18048292f, 0.01548873f, -0.06748858f, -0.00671683f, 
    -0.00942551f, -0.03603023f, -0.07360095f, -0.09652643f, 0.33807933f, 0.23708539f, 0.38288391f, -0.03723179f, 
    0.05073642f, 0.05893597f, -0.13586354f, 0.22305457f, -0.00348247f, 0.08692101f, 0.04786235f, -0.07344403f, 
    0.07608537f, -0.15752739f, -0.16758171f, 0.04836256f, 0.04390620f, -0.00175906f, 0.01041437f, -0.06894245f, 
    0.06959195f, -0.10793702f, -0.07490700f, -0.12821306f, 0.12071731f, 0.06819775f, -0.25698268f, -0.03431385f, 
    -0.06122981f, 0.05971502f, -0.05045609f, 0.07091253f, -0.10071018f, 0.02853604f, -0.05483153f, -0.06472939f, 
    -0.12979935f, -0.15577838f, 0.00132404f, 0.05615303f, 0.18151911f, 0.09059133f, -0.01790702f, 0.09883817f, 
    -0.04274111f, 0.00947918f, 0.04656322f, -0.07288411f, 0.23507780f, 0.06352444f, 0.33487496f, 0.29451475f, 
    0.07311571f, 0.09244934f, 0.10772823f, 0.01394594f, 0.01792216f, -0.06614286f, 0.04551229f, -0.11345003f, 
    -0.08216863f, -0.19925343f, 0.17896862f, -0.30311167f, -0.04882743f, 0.01771448f, -0.00235829f, 0.14406405f, 
    -0.03621003f, -0.04036929f, -0.17301244f, 0.15462661f, 0.09276414f, -0.03768941f, -0.10858959f, 0.01507119f, 
    0.02805861f, 0.14513800f, -0.02231409f, -0.06921102f, 0.00694254f, -0.02500558f, 0.00393250f, 0.00148659f, 
    0.11975104f, 0.18664718f, 0.17389555f, 0.02710274f, 0.05552204f, 0.10120790f, 0.02540508f, 0.06178720f, 
    -0.00450489f, 0.05863553f, 0.18488830f, 0.05982600f, -0.01653560f, -0.01076084f, 0.03685476f, -0.10635018f, 
    -0.02053159f, 0.08470316f, -0.01000369f, 0.12066624f, 0.07265784f, 0.02807840f, -0.03767952f, 0.17597759f, 
    -0.04704345f, -0.00836714f, -0.07712565f, 0.00922263f, -0.04445778f, -0.01908703f, -0.01609951f, 0.07489853f, 
    -0.07943797f, -0.03897196f, -0.01815967f, 0.08345721f, 0.05670500f, 0.00371093f, -0.22284263f, -0.15245992f, 
    0.04976226f, -0.11121867f, 0.06992375f, 0.07482061f, 0.08092767f, -0.07375478f, 0.10720049f, -0.08319285f, 
    0.00746892f, 0.51883715f, -0.05096317f, 0.47076234f, 0.06158122f, -0.01968084f, 0.17449738f, -0.18949379f, 
    -0.02802650f, 0.08524257f, 0.00073361f, -0.15866379f, 0.17563610f, -0.02683817f, -0.06743004f, 0.03145120f, 
    0.19610588f, 0.10208073f, 0.05857926f, 0.09136191f, -0.01877359f, 0.02546568f, -0.01356432f, -0.05033986f, 
    -0.24832386f, 0.18565355f, -0.32961637f, 0.07433697f, -0.04361289f, -0.06965164f, 0.07777814f, -0.08483694f, 
    0.13238595f, -0.05399145f, -0.05898484f, 0.08820771f, -0.08515364f, -0.09454553f, 0.08433395f, -0.07684406f, 
    0.01204871f, 0.04394628f, -0.03016028f, 0.07647830f, -0.02239393f, 0.02273096f, 0.12072811f, 0.08912289f, 
    0.14483626f, 0.02656948f, -0.02894974f, 0.04320669f, -0.08549965f, 0.10758017f, 0.07406846f, -0.01874936f, 
    -0.11360148f, -0.07374996f, -0.05321295f, 0.01946926f, 0.08836013f, 0.06541368f, 0.04778085f, 0.14938174f, 
    0.01904840f, 0.15042166f, 0.03391168f, 0.06802603f, 0.02256382f, -0.09443135f, -0.08420045f, -0.16967858f, 
    -0.46474954f, -0.27039921f, 0.21090396f, -0.00691116f, -0.09701474f, -0.09482601f, -0.08865218f, -0.07560760f, 
    0.03499587f, -0.09445742f, -0.02774327f, -0.02412740f, -0.06503818f, 0.16087931f, 0.04201039f, -0.07909852f, 
    0.04847102f, -0.00008973f, 0.00750554f, 0.08527760f, 0.03592081f, -0.01430105f, 0.00505920f, 0.08475579f, 
    0.08876210f, -0.09987547f, -0.05490001f, -0.01957537f, 0.07248500f, -0.07271720f, 0.12768109f, 0.04450879f, 
    -0.03983016f, 0.02337680f, 0.03042516f, 0.02922080f, -0.11716516f, -0.22095710f, 0.29551783f, 0.01439099f, 
    0.05802523f, -0.08969504f, -0.05631957f, 0.13637461f, 0.08885375f, -0.12068888f, 0.15891480f, -0.06838099f, 
    0.10967051f, -0.11536018f, -0.22395284f, -0.01907034f, -0.09130809f, 0.06239453f, 0.03296348f, -0.01108805f, 
    0.10610771f, -0.18351325f, 0.05919277f, -0.00367394f, -0.19595893f, -0.23781320f, 0.03629378f, 0.02748739f, 
    0.11295395f, 0.02200782f, -0.04531923f, 0.04182841f, -0.04191890f, 0.08873306f, -0.04887589f, 0.02814009f, 
    -0.01169843f, -0.06424070f, -0.34155735f, 0.21734047f, -0.01544196f, 0.04400992f, -0.09504995f, 0.07165436f, 
    -0.07019471f, -0.22165458f, 0.07997304f, 0.04872584f, -0.03123025f, 0.10385459f, 0.05375193f, 0.15728608f, 
    0.01426064f, -0.02914648f, 0.20357023f, 0.12163058f, -0.01175882f, -0.01493506f, 0.08964590f, 0.14717630f, 
    -0.11953104f, -0.09837811f, -0.08994409f, -0.09915797f, 0.09583153f, -0.00258230f, -0.01702127f, 0.21425694f, 
    0.04470757f, -0.05556609f, 0.07274571f, -0.00961385f, 0.14636762f, 0.09482183f, 0.04260702f, -0.03558370f, 
    0.08795967f, 0.02569922f, -0.05450634f, 0.15967087f, -0.02995167f, 0.02009884f, 0.02572765f, 0.01685386f, 
    0.12760344f, -0.11798310f, 0.40563169f, 0.09102864f, 0.03511750f, 0.14968920f, -0.00679289f, -0.07587974f, 
    0.01101661f, 0.01105814f, -0.08222180f, -0.00951460f, 0.03424450f, 0.06244708f, 0.29844812f, 0.18974485f, 
    -0.00774274f, 0.09567363f, 0.11553776f, -0.05965332f, -0.05451070f, -0.14794222f, -0.17637691f, 0.02742819f, 
    0.02156897f, 0.14989546f, 0.07889223f, 0.10168721f, -0.07035169f, -0.07036728f, 0.07702784f, -0.01425262f, 
    0.01133368f, -0.02699062f, 0.00370224f, -0.06489227f, 0.19516550f, 0.12229981f, 0.21599236f, -0.02510508f, 
    -0.08739299f, -0.05384895f, 0.00151691f, 0.05313634f, -0.11227729f, -0.08483868f, 0.04915830f, -0.15917942f, 
    -0.17609309f, 0.07248003f, 0.09490582f, 0.03385141f, -0.07069472f, 0.13553379f, -0.24788135f, -0.13561389f, 
    0.09837736f, -0.14723918f, 0.00783869f, -0.00450336f, 0.31068847f, 0.13197738f, 0.24667515f, 0.34824663f, 
    -0.01881370f, 0.15164843f, -0.01559100f, 0.15000457f, -0.05781494f, -0.01821028f, -0.05838243f, -0.11245864f, 
    0.02988779f, 0.27360177f, 0.28995210f, 0.29785308f, -0.07460511f, 0.07267874f, -0.00173238f, -0.02228876f, 
    0.10119148f, 0.05204434f, -0.03010024f, 0.13839735f, -0.11395248f, -0.06073391f, 0.32947168f, 0.03157919f, 
    -0.15550376f, -0.03637996f, -0.09337945f, 0.06338155f, -0.02439989f, 0.01264679f, 0.02437443f, -0.04533966f, 
    0.09407998f, -0.07053569f, -0.18209073f, -0.02246011f, -0.02189258f, 0.04382776f, 0.03805565f, 0.07620728f, 
    0.00427144f, -0.02603053f, -0.12192538f, -0.05521745f, -0.06671713f, -0.22974625f, -0.26256165f, 0.17955546f, 
    0.05106347f, 0.01836772f, -0.07939555f, 0.09171166f, -0.08170784f, -0.10658596f, 0.02108376f, -0.22231860f, 
    -0.21501119f, -0.16990858f, -0.32409617f, 0.14234334f, -0.04962696f, -0.04202746f, -0.02903607f, -0.09252959f, 
    -0.03809565f, 0.03116160f, -0.09144809f, 0.14015344f, -0.02482775f, -0.13881813f, 0.06230242f, 0.02228601f, 
    -0.06020050f, -0.00652066f, 0.00683193f, -0.03595302f, -0.04170240f, -0.03866148f, 0.09634596f, -0.08480990f, 
    0.16222474f, 0.21700703f, 0.21029820f, 0.07224300f, 0.13146368f, 0.14611611f, 0.02585031f, 0.04472146f, 
    0.00708667f, -0.05120117f, 0.02196587f, 0.08603729f, -0.11362309f, 0.10561197f, 0.04000390f, 0.16156863f, 
    0.04450167f, -0.07580467f, 0.04030483f, 0.00469741f, 0.07001235f, -0.04895705f, -0.10012027f, -0.03051259f, 
    -0.10106835f, -0.19017909f, 0.41164041f, -0.13473733f, 0.12211751f, 0.03550066f, -0.01351304f, -0.04238388f, 
    0.00407303f, -0.12908903f, 0.12704051f, -0.03762206f, 0.17644154f, 0.05959992f, 0.16600674f, -0.01332871f, 
    0.05564818f, 0.03624494f, 0.10280311f, 0.09407736f, 0.08004002f, -0.01560204f, -0.04448976f, -0.02974105f, 
    0.15977211f, -0.20783205f, -0.15503959f, -0.07127322f, 0.03641508f, 0.04230580f, 0.09629922f, 0.04919853f, 
    -0.03793757f, -0.12155005f, -0.05567291f, -0.02608720f, 0.53176337f, 0.37658453f, 0.22361584f, 0.04780493f, 
    0.02798286f, 0.06545910f, 0.02088506f, -0.02485749f, 0.10750445f, -0.02293228f, 0.12362649f, 0.01601431f, 
    -0.06386137f, -0.16010734f, 0.08013464f, -0.07570294f, 0.05396720f, -0.01651884f, 0.09522077f, 0.01618897f, 
    0.12460615f, 0.00863610f, -0.03255567f, -0.07440814f, 0.05345974f, 0.26258722f, -0.15220040f, 0.38478550f, 
    0.02733210f, -0.03140942f, 0.02311516f, -0.13345169f, 0.18677717f, -0.06247739f, 0.01607161f, 0.02636805f, 
    -0.08099334f, -0.42913830f, 0.52676320f, -0.00227584f, 0.13011888f, 0.03002039f, 0.08858838f, 0.09034795f, 
    -0.10300454f, -0.14450148f, -0.12192613f, -0.03711429f, 0.08569083f, 0.05292656f, 0.10646139f, -0.00570422f, 
    -0.00454659f, 0.04103204f, -0.13740739f, 0.06591436f, 0.09742659f, 0.07888531f, -0.15073736f, -0.02528116f, 
    -0.04353471f, -0.04234470f, -0.02230020f, 0.01771190f, 0.01639467f, 0.00132737f, 0.01429712f, -0.03800647f, 
    0.02140924f, 0.02160146f, 0.02038915f, -0.03145186f, -0.00909272f, -0.00459874f, 0.00444044f, -0.02362200f, 
    -0.03011154f, 0.02075861f, -0.03478710f, -0.01738041f, -0.01139892f, -0.00693807f, 0.01055185f, -0.00042874f, 
    0.00349682f, 0.00259695f, -0.03468041f, 0.01074283f, -0.03315514f, -0.01699477f, -0.00778482f, -0.00133054f, 
    0.02366704f, 0.01878395f, -0.02574263f, -0.02386389f, -0.03211339f, -0.00190360f, 0.02885534f, -0.00367658f, 
    -0.02766663f, -0.02133697f, -0.01512089f, 0.01096122f, -0.01344339f, -0.02181741f, 0.01847879f, -0.02422458f, 
    -0.02469723f, 0.02681568f, 0.00894576f, 0.01162429f, 0.02259717f, -0.00307680f, 0.00941643f, 0.02811839f, 
    -0.02871511f, -0.01902901f, 0.02440727f, -0.03711601f, 0.00986876f, -0.00454165f, -0.00439190f, 0.02335582f, 
    -0.01950151f, -0.03059652f, -0.01660407f, 0.00682195f, -0.01938787f, -0.00635313f, -0.02408434f, 0.00782906f, 
    -0.03803435f, 0.02209014f, -0.03231991f, 0.01864733f, -0.00008631f, -0.00169832f, 0.00328747f, -0.01271592f, 
    -0.02845330f, -0.03311069f, -0.02277582f, 0.02527416f, 0.01916819f, -0.03131926f, -0.03151597f, 0.02009171f, 
    -0.01042270f, -0.00087026f, -0.01692107f, 0.01668981f, -0.00953115f, 0.01246642f, 0.00296390f, 0.01792460f, 
    -0.01016639f, 0.00942905f, -0.03465316f, 0.02663525f, 0.03257636f, 0.01510760f, -0.03268193f, -0.00487206f, 
    -0.01273783f, 0.00051582f, 0.00534174f, -0.00594304f, -0.03438001f, -0.02187933f, -0.01359129f, 0.01748190f, 
    -0.03892699f, 0.00218640f, 0.00197804f, 0.01870110f, -0.02306672f, 0.02667236f, -0.00460311f, 0.00774452f, 
    -0.01749878f, 0.02087544f, -0.03775455f, 0.01263617f, 0.00746895f, -0.01915749f, -0.04139641f, 0.00876959f, 
    -0.01958777f, 0.03200114f, 0.03234914f, -0.03237141f, 0.01846370f, 0.00811365f, -0.01857003f, -0.01474759f, 
    -0.00073640f, -0.03352540f, -0.01818904f, 0.02830405f, 0.02472341f, -0.01701871f, 0.02307615f, -0.03653285f, 
    -0.00146640f, -0.01649968f, -0.00770739f, -0.03251865f, -0.00758920f, -0.03684165f, -0.02256613f, -0.02508325f, 
    -0.02126367f, 0.01525756f, -0.03109127f, -0.03703612f, 0.01130826f, -0.02831289f, -0.02407455f, 0.02776910f, 
    -0.00405003f, 0.00752687f, -0.03306507f, 0.03389627f, -0.00394704f, 0.01861296f, 0.01592943f, -0.01988939f, 
    0.02383599f, 0.00753620f, -0.03546958f, 0.01773453f, 0.02794069f, -0.01909812f, 0.00243212f, -0.00349443f, 
    0.01886072f, -0.00781765f, -0.03521715f, -0.02118720f, 0.02330479f, -0.00955302f, -0.01823137f, -0.04149878f, 
    -0.01058627f, -0.00216266f, -0.01536368f, -0.01751231f, 0.02657511f, -0.00184325f, 0.02516508f, 0.01187886f, 
    -0.01580966f, -0.03743244f, -0.00106863f, 0.01619135f, -0.01009490f, -0.00135872f, -0.02792471f, 0.00900103f, 
    0.01743181f, 0.00019352f, 0.02355078f, -0.01797623f, -0.03043766f, -0.01306459f, 0.00925265f, -0.02942272f, 
    0.01540474f, -0.03139995f, -0.01635567f, -0.01759766f, -0.01009797f, 0.01489616f, 0.01527108f, 0.02273938f, 
    0.00327322f, 0.00907745f, 0.01024140f, 0.00131826f, 0.01400786f, -0.03030021f, -0.02085246f, 0.00262472f, 
    0.01671445f, -0.03231373f, -0.00449102f, -0.02278628f, -0.03372568f, -0.00951073f, 0.02569498f, 0.00905098f, 
    -0.01761543f, -0.02671709f, 0.00975728f, -0.03724172f, -0.01188517f, -0.01819226f, 0.01606760f, 0.01482715f, 
    0.00202881f, 0.00371955f, -0.03422115f, -0.01535197f, -0.00052350f, 0.02993857f, 0.02702753f, 0.01385264f, 
    -0.02416003f, -0.01065202f, -0.03258577f, -0.01127679f, -0.03490248f, -0.03051939f, -0.02807392f, -0.00039485f, 
    0.00899341f, -0.01397690f, -0.02418659f, -0.00847577f, -0.01743552f, 0.00699600f, 0.00292994f, -0.03199662f, 
    0.01432900f, -0.01432816f, -0.01125813f, 0.01202412f, -0.00603071f, -0.02236150f, 0.02598698f, -0.02232542f, 
    0.03425262f, 0.03132645f, 0.00599270f, -0.03229731f, -0.00339795f, 0.03003918f, 0.01597075f, 0.01319524f, 
    -0.00572940f, 0.00054162f, -0.00003514f, -0.00445633f, 0.02395221f, -0.01756858f, 0.02043169f, 0.03258497f, 
    -0.01609446f, -0.00000514f, 0.01502720f, 0.00181853f, 0.02934153f, -0.00466441f, -0.02096481f, 0.00725120f, 
    0.01280887f, -0.03604127f, 0.02456753f, -0.03772492f, -0.01903178f, 0.01741011f, -0.01005575f, -0.01204665f, 
    0.00959376f, -0.00956855f, 0.00296305f, -0.03238103f, -0.03932736f, -0.02661398f, 0.00600096f, 0.00750474f, 
    0.03020400f, -0.00545649f, -0.00897426f, -0.00099740f, -0.01480084f, -0.03584981f, -0.01039427f, -0.01537391f, 
    -0.03076985f, 0.01589397f, 0.01757782f, 0.02942439f, -0.00204233f, 0.00345393f, 0.01571995f, -0.02766444f, 
    0.01038022f, -0.00785119f, 0.01330733f, 0.01138378f, -0.00367990f, -0.00722591f, 0.00399160f, -0.01617202f, 
    0.03006938f, -0.02522782f, 0.01204871f, 0.01467772f, -0.02808805f, -0.02329258f, -0.03477440f, -0.02993096f, 
    0.00767459f, -0.00020722f, -0.02919562f, -0.03385051f, -0.01931771f, -0.03654822f, -0.03915635f, -0.00619126f, 
    -0.02936395f, 0.02071317f, 0.00063785f, 0.01179523f, -0.02325606f, -0.02624606f, -0.00742721f, 0.01063483f, 
    -0.01205668f, -0.02504019f, -0.03420659f, 0.01079533f, 0.02394945f, -0.03502030f, 0.03197284f, -0.00970808f, 
    0.02359338f, -0.02081713f, 0.02796514f, 0.03909877f, -0.02876093f, -0.03428542f, 0.01774255f, 0.02268221f, 
    0.00196561f, 0.00232431f, 0.00149512f, -0.00696187f, -0.00128782f, -0.01129377f, -0.00750322f, 0.03107096f, 
    -0.02406460f, 0.00611745f, -0.03582868f, -0.02651553f, -0.01229656f, -0.00878521f, 0.00500696f, -0.03288132f, 
    0.01516773f, 0.02870127f, 0.00779410f, 0.00301142f, -0.00361683f, 0.02000957f, -0.00526300f, -0.01903059f, 
    0.01092888f, 0.00482186f, -0.00909483f, -0.01441580f, -0.01882084f, -0.00678887f, -0.01177317f, 0.01755321f, 
    -0.03118956f, 0.02039530f, -0.02370318f, 0.02594876f, -0.00609267f, -0.00131428f, 0.01416736f, -0.03512743f, 
    0.00591599f, 0.02904846f, 0.00931458f, -0.00553206f, -0.03881188f, -0.00620840f, -0.01025855f, 0.01341863f, 
    0.00109468f, -0.00943000f, -0.00028946f, -0.02075565f, 0.03204384f, -0.03521598f, 0.02608562f, 0.01334154f, 
    0.02271083f, -0.00033750f, -0.02063837f, -0.02824917f, 0.02751153f, 0.03215024f, -0.00664678f, -0.02617101f, 
    -0.00181681f, -0.01296171f, 0.03487678f, 0.03428821f, 0.00608098f, -0.03216792f, -0.01329048f, -0.01838445f, 
    -0.00856930f, -0.00312198f, -0.04195007f, -0.02775703f, -0.01446936f, 0.01653724f, -0.03791818f, 0.01081642f, 
    -0.00520602f, -0.02021035f, -0.01678825f, 0.03790597f, -0.03305118f, -0.02665594f, 0.00426878f, -0.01422720f, 
    0.01379906f, -0.02321399f, -0.00048898f, -0.01898090f, 0.01308827f, 0.02288897f, 0.02710442f, 0.03536514f, 
    0.02385767f, -0.02761451f, -0.00423918f, -0.00932759f, 0.00998597f, 0.00026434f, -0.00117248f, 0.03728139f, 
    0.01068059f, -0.02610953f, -0.01428344f, 0.02401885f, 0.00143663f, 0.03442705f, 0.00180895f, -0.00697304f, 
    0.00883388f, 0.01701517f, 0.02521366f, -0.01333361f, -0.00005728f, -0.00395263f, 0.02258613f, 0.02338628f, 
    -0.00030253f, 0.02697593f, -0.00061498f, 0.00077181f, 0.00471367f, -0.02503303f, -0.01855651f, -0.03213661f, 
    -0.03332919f, -0.01369478f, 0.02093011f, -0.03536082f, 0.00751758f, 0.01824944f, 0.01925551f, -0.03361091f, 
    -0.02719449f, -0.01618621f, 0.02536896f, -0.00560766f, 0.02339052f, 0.02893293f, 0.00711385f, -0.01179729f, 
    -0.03391987f, 0.00528218f, -0.02618798f, 0.02161498f, -0.00182909f, -0.00108963f, 0.01135616f, 0.01558821f, 
    0.01148679f, 0.02870950f, 0.03219581f, 0.03427049f, 0.02168026f, 0.01140951f, -0.02043904f, -0.01597918f, 
    -0.02204595f, -0.00167717f, 0.03260979f, -0.01797077f, -0.03296546f, 0.00492530f, -0.03164391f, 0.02935295f, 
    0.00492148f, 0.01404490f, 0.02213988f, -0.00951619f, -0.01728901f, 0.02952706f, -0.00385369f, -0.03943971f, 
    0.02318712f, 0.02345821f, -0.00172139f, 0.00744620f, 0.01294786f, -0.00136880f, -0.01082892f, 0.00165181f, 
    -0.01325637f, 0.00758778f, -0.01004890f, 0.02182240f, 0.00184898f, -0.00318732f, 0.01655056f, -0.00427287f, 
    -0.02354212f, -0.02773938f, 0.01557280f, -0.02551443f, -0.02341674f, -0.03032081f, 0.00013760f, -0.03255818f, 
    0.00418910f, -0.03836615f, -0.02062921f, 0.02697977f, -0.01671464f, -0.01342650f, -0.01412392f, -0.00613221f, 
    -0.00631180f, -0.00827302f, 0.02513649f, -0.03465714f, 0.00555856f, -0.00590789f, 0.01245694f, -0.01266799f, 
    -0.03239556f, 0.00448696f, 0.01378973f, 0.01934846f, 0.01343726f, 0.02668636f, 0.01699826f, 0.00405071f, 
    -0.00469932f, -0.01158433f, -0.00493768f, 0.02361047f, 0.02279995f, -0.00318342f, -0.02410243f, -0.02299400f, 
    0.00808341f, -0.01681991f, 0.01092241f, -0.01998981f, -0.02031545f, 0.00402500f, 0.00432947f, 0.01800399f, 
    -0.01208882f, 0.02791896f, 0.00154508f, 0.01416080f, -0.03442283f, -0.02457889f, 0.00167372f, 0.01775815f, 
    0.00415940f, 0.02801250f, 0.00871765f, 0.02005575f, -0.03243802f, -0.00976104f, 0.02189169f, -0.02143539f, 
    0.02548259f, -0.02711270f, 0.00301316f, 0.00029109f, -0.02630435f, 0.02850617f, -0.02179382f, -0.03613928f, 
    0.01667252f, 0.02534967f, -0.00639749f, 0.00971035f, -0.00590769f, 0.00733999f, 0.01734017f, -0.01557579f, 
    -0.00854771f, 0.02305585f, -0.02764155f, 0.00187157f, 0.03248444f, -0.00649654f, -0.03445076f, -0.00926824f, 
    0.01414232f, -0.00883904f, 0.01694922f, 0.02655131f, -0.03652844f, 0.02842551f, 0.02053835f, 0.00825291f, 
    0.01589416f, 0.02937807f, 0.02667382f, 0.00163261f, 0.01612615f, -0.02258841f, 0.01849142f, -0.03507916f, 
    -0.03242547f, 0.03178915f, -0.02244155f, -0.04331218f, 0.00351737f, 0.03392468f, -0.00930175f, -0.02803847f, 
    0.01093383f, 0.03028609f, -0.03355127f, 0.02031010f, -0.02908461f, -0.00754305f, 0.02691448f, 0.02041334f, 
    0.00642074f, 0.02389043f, 0.01756794f, 0.02142848f, -0.02255441f, 0.00941124f, -0.01918669f, -0.01567391f, 
    -0.02686971f, 0.01384134f, 0.01298560f, -0.00066340f, 0.00286721f, 0.01029420f, 0.02856651f, 0.02180180f, 
    0.00780102f, -0.01507611f, -0.00786545f, -0.02338082f, 0.00308675f, 0.02123146f, 0.03371346f, -0.00811629f, 
    -0.01456091f, -0.01636116f, -0.02416573f, 0.03660490f, -0.01556949f, -0.03607178f, 0.02918885f, -0.00634775f, 
    -0.03564761f, -0.00069361f, 0.03220120f, 0.01124660f, 0.01923239f, -0.03264610f, 0.00922227f, -0.02498346f, 
    -0.00898774f, 0.01062771f, -0.00493648f, 0.03126187f, 0.03106558f, -0.00303513f, 0.01693061f, -0.01641191f, 
    0.01413624f, 0.01880948f, 0.02051063f, -0.00617743f, 0.00382572f, 0.02109221f, 0.03396644f, 0.00210405f, 
    0.02715612f, -0.01987590f, 0.02779253f, -0.02605274f, 0.00957232f, 0.03682939f, -0.02843387f, 0.00193124f, 
    0.02126159f, -0.02237591f, 0.02362108f, 0.02471979f, -0.02996890f, -0.02365593f, -0.03373003f, -0.04177162f, 
    0.02280292f, 0.02269424f, -0.02809883f, -0.02743729f, 0.01290375f, -0.00125733f, 0.00686901f, -0.00335404f, 
    0.00079512f, -0.03910393f, 0.02673572f, -0.04139604f, 0.00517367f, 0.00365605f, 0.01561265f, -0.01743496f, 
    0.00853788f, 0.00157212f, -0.02175245f, 0.02463341f, -0.00410650f, -0.03197841f, -0.02054970f, 0.03010091f, 
    0.01597635f, 0.02767598f, 0.01632287f, 0.02146028f, -0.00312998f, -0.01725224f, -0.02602432f, 0.02935537f, 
    0.02843560f, 0.01353593f, 0.01888295f, -0.01516241f, -0.03798901f, -0.02225874f, 0.00241432f, 0.02150612f, 
    -0.03206081f, -0.03829794f, -0.03735210f, -0.02039006f, -0.04337084f, 0.01003177f, -0.03368204f, 0.02638456f, 
    -0.01943032f, 0.01760120f, -0.01621563f, 0.01274368f, -0.01158438f, 0.02658745f, -0.01683553f, 0.00202584f, 
    -0.03975021f, -0.04250068f, 0.02204168f, 0.01141996f, -0.01224599f, -0.00010481f, 0.01792968f, -0.02142776f, 
    0.01532868f, -0.01585434f, -0.03886088f, 0.01237100f, 0.00409263f, 0.02058891f, 0.01073245f, -0.01669452f, 
    0.00033184f, 0.02184847f, -0.00351981f, -0.03685282f, -0.01401017f, -0.01742898f, -0.01592219f, -0.02143720f, 
    -0.03682432f, -0.00509506f, -0.02744475f, -0.03449064f, 0.01971198f, 0.01904638f, -0.00094237f, 0.01425237f, 
    0.00726778f, -0.00112035f, -0.00914044f, 0.01686928f, 0.00290969f, 0.02788180f, -0.00182709f, -0.02984989f, 
    0.00917313f, -0.02435737f, 0.02862959f, -0.02762809f, 0.01258762f, -0.00321482f, -0.00278796f, 0.02565094f, 
    0.02141405f, 0.00355055f, 0.02887099f, -0.01452764f, -0.03953904f, 0.02406440f, -0.01157639f, -0.01623097f, 
    0.00753581f, -0.01941563f, 0.01539415f, 0.01229319f, -0.00315924f, -0.01452635f, -0.01807998f, -0.02088684f, 
    -0.00704902f, 0.00452689f, -0.02055078f, -0.00837786f, -0.03972322f, -0.03075300f, 0.02469689f, -0.01415532f, 
    -0.03491807f, -0.01455251f, 0.00033223f, 0.02928695f, -0.03406951f, -0.03604255f, -0.00110288f, 0.00064276f, 
    0.02784416f, -0.02069626f, 0.01237840f, -0.03357861f, 0.03023365f, -0.02803173f, 0.00480740f, -0.01219385f, 
    -0.03668676f, 0.02852565f, -0.02516152f, -0.02929195f, -0.04128902f, 0.00981459f, -0.02289441f, -0.02765552f, 
    -0.02051292f, 0.01719540f, -0.01258792f, -0.02704452f, 0.00647794f, 0.03378779f, 0.02651766f, 0.00619603f, 
    -0.00286615f, -0.02450067f, -0.03564540f, -0.00399621f, -0.02753255f, -0.02992289f, 0.01918786f, -0.04352208f, 
    0.02266449f, 0.02040681f, -0.01698389f, -0.01389459f, -0.01161518f, 0.03064899f, -0.01838147f, -0.03295339f, 
    0.01458762f, -0.00353284f, -0.01985728f, 0.01109198f, 0.00237701f, 0.00570473f, -0.03172965f, -0.01769142f, 
    -0.03901872f, -0.00633069f, 0.02925539f, 0.00541857f, -0.00585361f, 0.00084839f, -0.02439157f, -0.02652756f, 
    -0.01267673f, -0.03822797f, -0.00845309f, -0.03235102f, 0.00909334f, -0.00239252f, -0.02004411f, 0.00056329f, 
    -0.03524187f, -0.00587666f, -0.00231364f, -0.02853983f, -0.00973179f, -0.03261462f, 0.02307769f, -0.00902139f, 
    0.01252418f, -0.01253746f, -0.01829823f, -0.00900648f, -0.03264833f, 0.00865942f, 0.01952781f, -0.03481159f, 
    -0.00515463f, -0.02008583f, 0.01740974f, 0.02077271f, 0.00772595f, 0.02103133f, 0.02406875f, 0.00843713f, 
    -0.02194946f, 0.00955581f, -0.04069746f, -0.01339451f, -0.00931089f, 0.04474740f, 0.01794947f, -0.02098626f, 
    0.01314275f, -0.02736782f, 0.01425828f, -0.02458366f, -0.04075308f, -0.01337742f, 0.00898702f, -0.03109841f, 
    -0.03917452f, 0.01267420f, -0.01019584f, -0.02331214f, -0.02952338f, -0.00413419f, 0.02584036f, -0.01318788f, 
    -0.01952358f, -0.00721802f, -0.00289868f, -0.00997476f, -0.03373528f, -0.01358430f, -0.03886105f, -0.00239827f, 
    -0.02385842f, 0.02926070f, 0.02634659f, -0.04091641f, -0.00410771f, -0.03338674f, 0.01216202f, 0.01077701f, 
    -0.00043234f, -0.03017329f, 0.01379315f, 0.01344848f, 0.01174663f, -0.00490715f, -0.01441995f, -0.01910813f, 
    -0.00245982f, -0.00082375f, -0.04329880f, -0.02944315f, 0.00162513f, -0.03166034f, 0.00915737f, 0.02203817f, 
    -0.03256444f, -0.02329656f, -0.03537590f, 0.00408053f, 0.02081238f, -0.01896905f, 0.00492786f, 0.00551327f, 
    0.00386722f, -0.02761356f, -0.01881625f, 0.00599144f, 0.01420420f, 0.03320850f, -0.03068748f, 0.00627857f, 
    -0.02390591f, -0.03248918f, 0.02254314f, -0.02865206f, 0.00763446f, -0.01678413f, -0.01048500f, -0.02074966f, 
    0.02856834f, -0.00326241f, -0.02666941f, 0.01001826f, -0.00116297f, -0.02743425f, -0.01119393f, -0.02725027f, 
    0.00126686f, 0.03721629f, 0.00870106f, 0.02406246f, -0.00920798f, 0.00937775f, 0.00234964f, -0.02651474f, 
    -0.02828544f, -0.00130577f, -0.00240157f, -0.00113187f, -0.02196983f, 0.01560803f, -0.01546627f, 0.00359701f, 
    -0.01125059f, 0.02359527f, -0.03078201f, 0.01761229f, 0.01255295f, -0.03529413f, 0.01130268f, -0.02110527f, 
    0.01111147f, 0.00199377f, -0.02786950f, 0.02734488f, 0.00812057f, -0.03557176f, -0.00161637f, -0.02084030f, 
    -0.03872282f, -0.01147400f, -0.02606995f, -0.01144869f, 0.00607836f, -0.02689499f, 0.00622145f, 0.02678503f, 
    0.02535426f, -0.03763047f, -0.02796376f, -0.02788603f, -0.00122621f, 0.01685887f, -0.01567021f, -0.00335450f, 
    0.02510879f, 0.01420975f, -0.04153286f, 0.01221007f, -0.00670709f, 0.00945209f, -0.02160342f, -0.03878757f, 
    -0.03400751f, 0.00595901f, 0.00265495f, -0.02454272f, -0.00532381f, -0.01517869f, -0.00556417f, -0.01378498f, 
    0.01358735f, 0.02454223f, -0.01389639f, -0.01343850f, -0.01248188f, 0.00994831f, 0.02468254f, 0.00109031f, 
    0.00154308f, -0.03466200f, -0.03702337f, 0.00843393f, 0.02702884f, 0.01509104f, 0.02253751f, -0.01875179f, 
    -0.00653578f, -0.02885634f, -0.02850556f, 0.01966602f, 0.01111486f, -0.03710136f, -0.01687072f, -0.02080001f, 
    0.02755908f, 0.01965192f, 0.01398543f, 0.02477762f, -0.03663472f, 0.02313364f, -0.00564278f, 0.02494154f, 
    -0.03039107f, 0.02787625f, 0.01901916f, -0.02754088f, -0.00911978f, 0.02126619f, -0.01679971f, -0.01792145f, 
    -0.00882186f, 0.01940870f, -0.03510033f, -0.03864221f, -0.00945619f, -0.01193367f, -0.02421152f, -0.02654004f, 
    0.01083655f, -0.01842607f, 0.01629530f, 0.00588026f, 0.02268191f, 0.02085223f, 0.01888407f, -0.04354808f, 
    0.02885417f, 0.00203922f, -0.03675817f, 0.02766930f, -0.00385525f, -0.00090944f, -0.02137703f, 0.00479644f, 
    0.01366883f, -0.03466774f, -0.00170758f, -0.02247347f, -0.03150303f, 0.01273576f, -0.00129602f, -0.01719226f, 
    -0.02117360f, -0.03036712f, 0.02383458f, -0.02478442f, -0.03564626f, -0.00643296f, -0.00746222f, -0.03505988f, 
    0.01769394f, -0.02809861f, -0.00386919f, -0.00598236f, 0.00532352f, 0.03047619f, -0.00516586f, 0.01978816f, 
    -0.02968615f, 0.01880485f, -0.03938114f, -0.03427351f, 0.00851332f, -0.03478378f, -0.03188577f, 0.02328553f, 
    -0.01537634f, 0.02568476f, -0.02624232f, 0.01795034f, 0.00360850f, -0.02381348f, 0.02620846f, 0.01002196f, 
    -0.01255048f, -0.00472416f, -0.02454143f, -0.00448904f, -0.00529909f, -0.03489821f, -0.01594312f, -0.00475494f, 
    0.01645394f, -0.03398757f, -0.00218015f, 0.00920203f, 0.01422603f, -0.00972498f, -0.01022224f, 0.00590233f, 
    -0.00487545f, -0.02203563f, 0.00163767f, -0.02715137f, -0.01681123f, -0.03053920f, 0.02754604f, -0.00208982f, 
    0.01162658f, 0.03059732f, 0.02638013f, -0.03250436f, -0.00919556f, -0.01473959f, -0.03218876f, 0.00099292f, 
    0.01731167f, -0.01214493f, 0.01133685f, -0.03030153f, -0.01644304f, 0.01358959f, -0.00856055f, -0.01787769f, 
    0.01691501f, -0.01266339f, -0.00352696f, -0.03827688f, -0.01354304f, 0.01026511f, 0.01997237f, -0.03779261f, 
    -0.01487528f, 0.01688687f, -0.01990153f, -0.03669072f, -0.01454770f, 0.02476656f, -0.02454225f, 0.02880624f, 
    -0.03640433f, 0.00668723f, 0.01636589f, -0.01473179f, -0.02886084f, -0.02738737f, -0.03489963f, 0.02575699f, 
    0.01140688f, -0.02392001f, 0.02167706f, 0.02339970f, 0.02356228f, 0.01106306f, -0.03505268f, 0.01920114f, 
    -0.01562606f, 0.02314518f, -0.01891284f, -0.00986651f, 0.01280625f, 0.01209117f, 0.01459805f, -0.03016575f, 
    -0.02753499f, 0.01097895f, -0.01050981f, -0.03137794f, 0.02628064f, 0.01356368f, 0.03097231f, -0.03808876f, 
    0.01645511f, -0.03480445f, -0.01357630f, 0.00808276f, -0.03769485f, 0.00876751f, 0.01998116f, 0.01129930f, 
    -0.01579032f, -0.00456409f, 0.00673220f, -0.00374642f, -0.02324973f, -0.03585584f, -0.00827728f, -0.01703142f, 
    0.01571306f, 0.02214652f, 0.00738291f, -0.03820887f, 0.02748588f, 0.01672721f, 0.02940693f, -0.00583985f, 
    0.02361042f, 0.02102130f, -0.02701916f, 0.00785231f, -0.01707053f, 0.00505424f, 0.01929446f, 0.00165813f, 
    -0.02744667f, -0.00689764f, -0.01575976f, 0.01437681f, 0.01887000f, 0.01191873f, -0.01434959f, -0.02671884f, 
    -0.01973442f, -0.00509554f, 0.01188933f, 0.02808589f, -0.01871596f, 0.02236016f, 0.03001725f, -0.03621082f, 
    -0.03951803f, -0.03463802f, -0.03040765f, -0.01738374f, -0.00814714f, 0.00244399f, 0.00404679f, 0.03119484f, 
    -0.01134326f, 0.00003628f, -0.03733139f, 0.01826473f, 0.01238507f, -0.01465776f, -0.01745757f, -0.00941106f, 
    0.02396111f, -0.03848937f, -0.03087644f, -0.01883092f, 0.01486068f, -0.02523506f, -0.01468579f, -0.00412684f, 
    0.00804953f, -0.00079696f, 0.02943885f, -0.00410697f, -0.03168893f, 0.00324293f, 0.02074201f, -0.04130565f, 
    0.01191590f, -0.02226339f, 0.01842296f, -0.00485465f, 0.03237172f, -0.01555338f, 0.01911559f, 0.02703223f, 
    -0.01267661f, 0.00388861f, -0.00482991f, -0.00397714f, 0.02094965f, 0.02405204f, -0.01735390f, 0.00496168f, 
    -0.02166599f, 0.01408521f, -0.01355880f, -0.00734460f, 0.00883441f, -0.03137956f, -0.00906353f, 0.01985429f, 
    -0.01635337f, 0.02972941f, 0.02252505f, -0.03451435f, 0.00680155f, 0.01348385f, -0.03695521f, -0.03766640f, 
    -0.01240773f, -0.00445424f, 0.02416051f, 0.01315699f, 0.03704277f, -0.02464252f, 0.03140513f, -0.02044701f, 
    0.01277309f, -0.02509739f, -0.03280777f, -0.00627740f, -0.03431712f, -0.02041078f, 0.02330280f, 0.01946417f, 
    -0.03446937f, -0.02195677f, 0.00067578f, -0.01025742f, 0.02916606f, -0.00128298f, 0.02427958f, 0.01232954f, 
    0.00669361f, -0.02013444f, -0.02051173f, -0.01350239f, 0.02214679f, 0.01677004f, -0.01324787f, -0.00411530f, 
    -0.00322078f, 0.02121838f, -0.00065841f, -0.02760435f, 0.02656571f, 0.02320897f, -0.00410665f, -0.01744844f, 
    0.00792155f, 0.01297102f, 0.03001733f, -0.02503844f, 0.02895461f, -0.03400565f, -0.03931886f, -0.00673636f, 
    -0.00909218f, -0.02101620f, -0.00446941f, 0.00148169f, 0.01142685f, 0.02020806f, -0.03049970f, 0.01171646f, 
    0.01382220f, -0.02903159f, -0.01624249f, -0.00529616f, -0.00348642f, -0.03706580f, -0.01331564f, -0.01105054f, 
    0.02314286f, -0.03596478f, 0.01937620f, -0.00259955f, 0.00400973f, -0.03509218f, 0.00642811f, 0.02006426f, 
    0.02320515f, 0.01257213f, -0.04263233f, 0.02766694f, -0.00338791f, 0.01928505f, -0.01206511f, -0.03567684f, 
    -0.00238117f, -0.01722822f, -0.02549068f, 0.00399314f, 0.00271061f, -0.02181067f, 0.02355701f, 0.01553195f, 
    -0.02026144f, 0.03344861f, 0.01313796f, -0.02307500f, -0.00437914f, -0.01124062f, -0.01499853f, -0.01943255f, 
    0.30581042f, -0.11651503f, 0.46312761f, 0.29614189f, -0.08736942f, 0.14046247f, -0.03078075f, 0.12039419f, 
    -0.10493986f, -0.06305765f, -0.00436618f, -0.07699563f, -0.02044791f, 0.21002905f, -0.13852069f, 0.09083330f, 
    -0.02526820f, 0.09958386f, -0.07874691f, -0.08093055f, 0.02618996f, 0.02314418f, 0.10340741f, -0.00258884f, 
    -0.18976910f, -0.04878858f, -0.31010112f, -0.17298189f, 0.01751845f, 0.04754004f, 0.03658373f, 0.03337529f, 
    -0.03840844f, 0.02310487f, 0.03773206f, -0.03959589f, 0.24490546f, 0.02730676f, 0.02108393f, 0.23984750f, 
    -0.01355929f, -0.07325577f, -0.04054491f, -0.00773551f, -0.08842789f, 0.07375415f, -0.02962662f, 0.01143413f, 
    0.20128646f, 0.31490996f, 0.02152031f, 0.17894864f, 0.05104997f, 0.09797212f, -0.13818772f, -0.00863920f, 
    -0.04734015f, -0.04505029f, -0.05811904f, -0.00058588f, -0.05932903f, -0.24305564f, 0.38672408f, -0.09315266f, 
    -0.01507494f, 0.03216695f, 0.02768792f, -0.04773363f, -0.02312496f, -0.02585536f, 0.04937442f, 0.01973124f, 
    -0.15936215f, -0.06468894f, 0.08000422f, 0.17336805f, -0.03576464f, -0.04406233f, 0.12687464f, 0.05835059f, 
    -0.04845453f, -0.02412254f, 0.12295654f, 0.07087368f, 0.05294757f, -0.07682652f, 0.00216370f, -0.17835689f, 
    -0.03527337f, -0.01562958f, 0.05586569f, 0.00038647f, -0.01522520f, -0.07876815f, 0.05852459f, 0.11232814f, 
    0.43393219f, -0.11011337f, -0.08013293f, -0.02675240f, -0.01066396f, 0.07704255f, 0.03560161f, 0.09189896f, 
    -0.01291962f, 0.06820124f, 0.05114678f, -0.02503265f, 0.13721336f, -0.21575862f, -0.02093705f, 0.27469549f, 
    0.03839409f, -0.04210964f, 0.03283227f, 0.01526691f, 0.06339656f, 0.03200974f, 0.06862626f, 0.00696390f, 
    -0.03865901f, 0.13013200f, -0.33049557f, -0.00129579f, -0.03181103f, 0.04281231f, -0.03496223f, 0.02081341f, 
    -0.07236368f, 0.04084760f, 0.09138770f, 0.09739777f, -0.10760276f, 0.00915782f, -0.17092596f, 0.22652106f, 
    0.01530377f, 0.05753120f, 0.00104372f, 0.02659349f, 0.05951434f, 0.00811656f, -0.00088825f, -0.12151709f, 
    -0.16398108f, 0.07113445f, -0.03955147f, 0.05234643f, 0.13013986f, 0.03604458f, 0.13859542f, -0.04068740f, 
    -0.06019285f, -0.11006675f, -0.08284029f, -0.07046442f, 0.09708281f, 0.00596230f, 0.15987432f, 0.23505658f, 
    -0.03175891f, -0.00571729f, 0.02810592f, 0.12397197f, 0.10491839f, 0.06731172f, 0.06906119f, 0.06657794f, 
    0.16237263f, -0.06666461f, 0.03001634f, -0.02376665f, -0.09893399f, 0.03692048f, -0.01180120f, -0.10724092f, 
    -0.11674535f, -0.03600418f, -0.01452282f, 0.01855846f, -0.25727826f, 0.04944702f, -0.08728332f, 0.36236086f, 
    -0.08991570f, 0.07272875f, 0.02232395f, 0.09305055f, -0.01843872f, -0.04517957f, 0.05178010f, 0.01555445f, 
    -0.12288872f, -0.02096677f, -0.03493458f, 0.12727933f, -0.05294170f, 0.03855571f, 0.01509668f, 0.09774029f, 
    -0.04298250f, 0.04763262f, -0.03296188f, 0.03847427f, -0.18897361f, -0.02077695f, -0.08822370f, -0.21548310f, 
    0.03029316f, 0.07613761f, 0.07019914f, 0.00014928f, 0.03124442f, 0.08813874f, 0.06899151f, 0.05172083f, 
    0.14250541f, 0.06746619f, -0.01152418f, -0.11962537f, -0.05937360f, -0.02945725f, 0.01320393f, -0.01869208f, 
    0.02304739f, 0.13619113f, -0.03478969f, -0.05733440f, 0.12514998f, 0.00505465f, 0.10531209f, 0.02117074f, 
    -0.10871923f, -0.01050669f, 0.09394859f, -0.04059036f, -0.04949781f, 0.08187432f, -0.05955623f, 0.04933996f, 
    -0.04813252f, 0.34492207f, -0.08610721f, 0.03338259f, -0.06279806f, 0.01804697f, -0.14706951f, 0.05350183f, 
    -0.02714352f, 0.14736995f, 0.03749597f, -0.08782157f, -0.10145553f, 0.10540156f, -0.14968784f, 0.10749500f, 
    0.06311516f, -0.02582116f, 0.10199338f, -0.02827405f, 0.03384415f, 0.02774046f, 0.01588253f, -0.02979961f, 
    -0.03659709f, -0.12082815f, -0.12141056f, 0.12759106f, -0.08443119f, -0.06065996f, -0.00429431f, -0.00757660f, 
    -0.03295023f, -0.02395461f, -0.05459175f, -0.02099171f, 0.55289268f, -0.20670839f, 0.13261802f, 0.00725853f, 
    0.02000346f, 0.05736195f, -0.05736963f, -0.00447904f, -0.01966169f, 0.03585561f, -0.02560551f, -0.07837467f, 
    0.03437579f, -0.00622077f, -0.11602307f, 0.02464357f, -0.02708147f, 0.09071229f, -0.05710811f, -0.01488002f, 
    0.03832719f, 0.07455774f, 0.08139765f, -0.06466344f, -0.02399347f, -0.05077789f, -0.06974730f, -0.05419296f, 
    -0.09523523f, 0.11386175f, -0.05700639f, -0.02631989f, -0.03333635f, 0.10349236f, -0.05235839f, -0.01882989f, 
    0.00971193f, -0.22142774f, 0.30529085f, -0.04269859f, 0.10320062f, -0.07393325f, 0.05274471f, 0.11521797f, 
    -0.02256668f, -0.08254353f, -0.03670045f, 0.09262753f, -0.10676586f, 0.00035562f, 0.00594386f, 0.36867431f, 
    -0.01793354f, -0.13162157f, 0.11199472f, -0.02866855f, 0.14760788f, 0.19981329f, -0.05257164f, 0.02449331f, 
    0.54816109f, -0.22384924f, 0.27231735f, -0.22826783f, -0.07319174f, -0.08792613f, 0.13180512f, -0.03269523f, 
    0.00510295f, 0.09274702f, -0.05995092f, -0.02343926f, 0.25288597f, 0.23821005f, -0.02952262f, 0.12335369f, 
    -0.00135089f, 0.07784422f, -0.11130159f, -0.01681516f, -0.03478108f, -0.04515898f, 0.00308860f, -0.09413347f, 
    -0.03292629f, -0.04944308f, 0.12091587f, 0.12731571f, 0.03501374f, 0.04128537f, -0.02524686f, 0.12279976f, 
    0.05277124f, 0.00731898f, -0.02775627f, 0.01901836f, -0.13172634f, -0.10514592f, 0.04349315f, 0.18680462f, 
    -0.01512450f, 0.04410979f, 0.02708134f, 0.01862085f, 0.04383931f, 0.03921192f, 0.01675063f, 0.08368290f, 
    0.26573062f, 0.01755782f, 0.29138425f, -0.17726746f, -0.05879889f, 0.07885140f, 0.05014767f, 0.09373688f, 
    -0.10961200f, -0.05096554f, 0.00610156f, 0.06550726f, -0.03159340f, -0.05070696f, -0.05846722f, 0.27755934f, 
    0.08575282f, 0.08740863f, 0.01957080f, -0.09490626f, 0.12151120f, 0.10802158f, 0.05782920f, -0.02972483f, 
    -0.09818193f, 0.01083830f, -0.10204452f, -0.08196587f, -0.03550905f, 0.02785393f, -0.04236925f, -0.02242487f, 
    0.16674875f, 0.12537917f, -0.03699367f, 0.04288157f, 0.08896198f, 0.17303753f, 0.05036988f, 0.27318567f, 
    -0.04221615f, 0.15985635f, 0.03695754f, 0.13823895f, -0.17617831f, 0.10488413f, -0.03886949f, 0.03179086f, 
    -0.13426571f, -0.02239454f, 0.03780086f, -0.05418495f, -0.00581546f, -0.01719798f, -0.05154451f, -0.06005659f, 
    -0.16434503f, 0.08447123f, -0.05498264f, 0.05172812f, 0.15911379f, 0.00461189f, -0.01297926f, 0.06361751f, 
    -0.12564978f, 0.10675827f, 0.01341509f, 0.01585458f, -0.07930420f, 0.00177589f, 0.02368582f, -0.06659430f, 
    0.15246446f, -0.18043347f, 0.24141172f, 0.27004182f, -0.04545981f, -0.09715154f, 0.00764224f, -0.04788866f, 
    -0.00924901f, 0.10385493f, 0.02453716f, -0.06783048f, 0.21901646f, -0.04261034f, 0.06349289f, 0.15645424f, 
    0.00609366f, -0.18243846f, -0.04607045f, -0.12545779f, -0.09339037f, -0.04390690f, -0.06693610f, -0.10699169f, 
    0.14018705f, 0.02254576f, -0.03538079f, -0.03901431f, -0.00340018f, 0.07658914f, 0.09373526f, -0.15242335f, 
    -0.01207346f, -0.05599988f, -0.05726350f, 0.01149745f, 0.04891734f, -0.04436450f, -0.05420177f, 0.06452220f, 
    0.03654320f, -0.03157929f, -0.10899077f, -0.05784761f, 0.15471169f, 0.05404291f, 0.04349165f, 0.09678844f, 
    -0.07768696f, 0.34393975f, -0.15298679f, 0.02954952f, -0.06361777f, -0.03600581f, -0.00902143f, -0.07704338f, 
    -0.01354800f, 0.02310864f, -0.07206656f, -0.10779066f, 0.23737955f, -0.08675373f, 0.17787169f, -0.04724735f, 
    0.03317285f, -0.10982624f, -0.02522424f, 0.08659061f, -0.08042789f, 0.11982998f, 0.13876744f, -0.01339299f, 
    0.07802878f, -0.21454990f, -0.04850164f, 0.17852192f, 0.04342626f, -0.01831813f, 0.01258451f, -0.05728968f, 
    -0.01720240f, 0.06737583f, 0.06065716f, 0.12153220f, -0.17224316f, -0.16811565f, -0.12307079f, -0.32927158f, 
    -0.03300733f, 0.01057389f, -0.00032540f, 0.00405227f, 0.19174649f, 0.10372943f, 0.01984390f, 0.08094662f, 
    -0.01118016f, -0.02955928f, 0.26233748f, 0.13896282f, -0.04025517f, 0.06555682f, -0.00710639f, -0.04095544f, 
    -0.18502201f, 0.18462047f, 0.24086219f, 0.02070086f, -0.19612873f, 0.15351129f, 0.01425994f, 0.22497730f, 
    -0.05791965f, -0.01923938f, 0.05828704f, 0.11556478f, 0.04424654f, -0.01570974f, 0.04294214f, -0.04239152f, 
    0.04488033f, -0.07818264f, -0.02321393f, -0.07002307f, 0.03491349f, 0.03598757f, 0.01674934f, -0.09015881f, 
    0.06140812f, -0.04298097f, 0.01625295f, 0.08850687f, -0.13588534f, 0.21543148f, -0.06685255f, -0.08999611f, 
    0.02898361f, 0.09230029f, 0.00745513f, -0.10913768f, 0.01441470f, 0.01556970f, 0.02307743f, -0.09092899f, 
    0.18356805f, 0.03297514f, 0.19615932f, -0.02987278f, -0.13040334f, -0.01325397f, -0.04140534f, 0.01245069f, 
    0.10071445f, -0.01587602f, 0.01067466f, 0.00183468f, 0.12449435f, -0.07081079f, 0.33425912f, -0.09976220f, 
    -0.10408329f, -0.05356133f, -0.00359353f, -0.04407908f, 0.03874982f, 0.06509043f, -0.05899741f, 0.04332331f, 
    0.07767632f, 0.17761903f, 0.22046642f, -0.02593409f, -0.09789802f, -0.04925779f, 0.01028800f, -0.06872610f, 
    -0.07130963f, -0.03298792f, -0.00774318f, -0.06647248f, -0.16522229f, 0.10935727f, 0.04187087f, -0.09891382f, 
    0.04790408f, -0.00208244f, -0.05131783f, 0.04684155f, -0.06537993f, 0.06441508f, -0.03056854f, 0.06201817f, 
    -0.11498742f, -0.11707777f, -0.13263711f, 0.26779440f, -0.13828503f, -0.01595703f, -0.05036627f, 0.00891463f, 
    -0.02363636f, 0.01569219f, -0.03568515f, 0.00101172f, 0.27084836f, -0.15330492f, 0.28527087f, -0.04944336f, 
    -0.00840636f, 0.01393385f, 0.03357736f, -0.02112255f, 0.04652963f, 0.07433194f, 0.03219416f, -0.04529051f, 
    -0.08239020f, 0.37056077f, -0.07433047f, 0.06812244f, -0.17303555f, 0.00263707f, -0.09794248f, 0.14207634f, 
    -0.09389853f, 0.06108022f, -0.06367838f, -0.08523375f, -0.05413872f, 0.00292774f, 0.09987859f, -0.02074407f, 
    -0.04607004f, 0.03340326f, -0.21431859f, 0.06560825f, 0.05120589f, 0.01230814f, 0.06437048f, -0.06233610f, 
    -0.11970222f, 0.12654571f, 0.03535177f, 0.02931534f, -0.12697513f, -0.00186409f, -0.07050005f, 0.00006622f, 
    0.01090200f, 0.04635185f, -0.10609580f, -0.05718309f, -0.20320378f, -0.11178739f, -0.08545183f, 0.19720966f, 
    0.04630487f, 0.04020028f, 0.03302222f, 0.09755147f, 0.03682268f, 0.04347907f, -0.01342289f, 0.01947802f, 
    -0.06459547f, 0.17261685f, -0.24253051f, -0.13450713f, -0.02179418f, 0.00621330f, 0.00640503f, -0.00281670f, 
    -0.12442687f, 0.00056273f, -0.01968890f, 0.07843061f, 0.27295813f, -0.05109404f, 0.00235506f, -0.00492285f, 
    -0.04983039f, -0.07305082f, -0.02758584f, -0.00589395f, -0.10986411f, -0.15316616f, -0.15661249f, -0.00199582f, 
    -0.04620549f, 0.49208590f, -0.05768073f, -0.22733162f, -0.02998207f, -0.07710745f, -0.08448391f, -0.07775035f, 
    0.05706717f, 0.02713286f, 0.04407006f, 0.05979670f, -0.32149476f, 0.06025640f, 0.02151272f, -0.12928513f, 
    0.01456899f, 0.00686802f, 0.18791305f, -0.07523566f, 0.09880620f, 0.06679858f, 0.04124079f, 0.03730461f, 
    -0.00035685f, 0.01045182f, 0.00618645f, -0.00793659f, 0.00298932f, 0.01708213f, -0.03591820f, -0.02774722f, 
    0.01884982f, 0.00469395f, -0.01365212f, -0.02285795f, -0.03213832f, -0.00719000f, -0.00320535f, 0.01854665f, 
    -0.00590026f, 0.02719992f, 0.01287514f, -0.01179619f, -0.00267977f, -0.02412896f, -0.01518174f, -0.03217147f, 
    0.00381031f, -0.03061420f, 0.01279265f, -0.04179551f, 0.00177337f, -0.03565407f, -0.00930069f, -0.02138899f, 
    -0.00455572f, 0.00013705f, -0.00533018f, -0.00035292f, -0.00223067f, 0.01795879f, 0.02376502f, -0.02418578f, 
    -0.00862714f, 0.00133104f, 0.02265349f, 0.00275956f, 0.00125635f, -0.00411337f, -0.00694167f, 0.01691421f, 
    0.01317063f, 0.00266393f, -0.03876425f, 0.02209269f, -0.00081337f, -0.03621063f, -0.01280072f, 0.00716458f, 
    0.01136924f, -0.00884323f, -0.03560917f, 0.02022167f, 0.00528023f, 0.03686177f, 0.00200511f, 0.01270936f, 
    -0.00942786f, -0.02888370f, -0.02285900f, -0.00077258f, -0.03835638f, 0.01211160f, -0.01267592f, -0.01261420f, 
    -0.02749367f, -0.01208978f, -0.03521615f, -0.03669651f, 0.02446998f, -0.00730627f, 0.02215048f, 0.03150834f, 
    -0.03661629f, -0.01468023f, 0.02764254f, -0.03635599f, -0.01835379f, 0.02638931f, 0.02002487f, -0.00458566f, 
    0.00636242f, -0.00739550f, -0.02418022f, -0.01884228f, 0.02941161f, 0.02482792f, -0.00171920f, -0.03724220f, 
    -0.00068355f, 0.00321184f, 0.01580912f, 0.01008217f, 0.01810182f, -0.01452735f, -0.00211159f, -0.00668702f, 
    -0.01519714f, -0.01545490f, 0.01612859f, -0.02227952f, -0.02411281f, -0.01681168f, 0.00953811f, -0.03840112f, 
    -0.00469390f, 0.02072232f, -0.00665701f, -0.01327803f, 0.01018142f, -0.00026691f, 0.02080524f, -0.03914727f, 
    0.00035613f, -0.02794439f, -0.00448999f, -0.01114142f, -0.03325274f, -0.00438790f, -0.02046943f, 0.01786449f, 
    0.01054485f, -0.02160567f, -0.01028398f, -0.03769077f, -0.01552713f, -0.01009061f, 0.00419390f, 0.02797754f, 
    -0.03176466f, -0.01521457f, 0.02233390f, 0.02769107f, -0.00283301f, 0.01346115f, -0.02166156f, -0.02086035f, 
    -0.00868775f, 0.00200301f, -0.00624030f, -0.01786386f, -0.02208778f, 0.00627221f, -0.00027956f, 0.00740374f, 
    0.01051538f, 0.00492928f, -0.03465597f, -0.03995104f, 0.00606842f, -0.03187700f, 0.01206241f, 0.00562039f, 
    -0.02441192f, -0.02330278f, 0.03132645f, 0.02430444f, 0.03954758f, 0.01549752f, -0.02641895f, -0.01154508f, 
    0.01512026f, -0.03891616f, -0.01811329f, -0.02033735f, -0.03466151f, -0.01493785f, -0.02785142f, 0.01328987f, 
    -0.02935352f, -0.01560398f, 0.02179613f, 0.00050649f, -0.02944547f, -0.02081246f, -0.02221096f, 0.03029322f, 
    0.02393997f, -0.01382351f, -0.03802086f, -0.01351770f, -0.00310125f, 0.01611504f, -0.00834914f, 0.02743024f, 
    0.02698314f, 0.00234245f, 0.02343609f, 0.00328987f, 0.00425964f, -0.00755142f, 0.02482299f, 0.02682407f, 
    0.00132620f, 0.01736875f, 0.01014173f, 0.01909134f, -0.01635388f, -0.00907228f, -0.01833057f, -0.02091223f, 
    -0.01803141f, 0.02011674f, -0.02855267f, -0.00434375f, -0.02198302f, 0.01619040f, 0.02060398f, -0.01997523f, 
    0.03182823f, 0.00362955f, -0.01892760f, -0.00728775f, 0.03102847f, -0.01604199f, -0.01101115f, -0.02144916f, 
    -0.02608286f, -0.03325790f, -0.00780425f, -0.01890177f, -0.02924083f, -0.02830525f, -0.02319128f, 0.01433467f, 
    -0.00032893f, 0.00412641f, 0.02647699f, -0.01282616f, 0.01836582f, 0.00706557f, -0.01100242f, 0.01548889f, 
    0.04003566f, -0.00474727f, -0.01461957f, 0.00417435f, 0.02677708f, -0.01842235f, 0.04177150f, -0.01321911f, 
    -0.03496092f, -0.02106306f, -0.01262856f, -0.01355579f, -0.00191687f, 0.01769665f, -0.02117346f, 0.00442889f, 
    -0.01285063f, 0.01568283f, 0.00924796f, 0.00986061f, 0.02834643f, -0.00816991f, -0.01956486f, -0.00790967f, 
    0.02120407f, -0.00862626f, 0.01092601f, -0.02375183f, 0.00461837f, -0.04001015f, 0.02917241f, -0.00602407f, 
    -0.03057034f, 0.02311621f, -0.01773683f, 0.02929469f, 0.02457816f, 0.01333994f, 0.02710863f, -0.03845373f, 
    0.04074028f, 0.02959090f, -0.03035238f, -0.00183321f, -0.02325714f, 0.02254392f, 0.01761332f, -0.00116836f, 
    0.00501911f, 0.00245562f, 0.03170009f, 0.01590988f, 0.01727407f, 0.01815733f, -0.02142194f, 0.02723336f, 
    0.01702136f, 0.00473385f, -0.02466608f, -0.00143282f, -0.02412489f, -0.02746152f, -0.02801222f, 0.01818152f, 
    -0.01412788f, -0.04193677f, -0.02672142f, -0.01243961f, 0.00485313f, -0.03446395f, 0.00740177f, 0.00914998f, 
    0.01112175f, -0.01122357f, -0.03211922f, 0.01714293f, -0.03802758f, -0.01284646f, -0.00785634f, -0.03913555f, 
    -0.01158629f, 0.00598196f, -0.02238914f, 0.02773451f, -0.01141952f, -0.00376696f, -0.00423284f, -0.02290751f, 
    0.02349617f, 0.00377910f, 0.00665004f, 0.01399615f, -0.02551646f, -0.02806170f, -0.00655959f, 0.01570763f, 
    -0.03080542f, 0.00132003f, -0.00610431f, 0.01202482f, -0.00410895f, -0.01607258f, -0.00596988f, -0.01019108f, 
    -0.00685134f, -0.01668396f, -0.03272022f, -0.02169272f, -0.01633491f, 0.00973740f, -0.01347601f, -0.01209641f, 
    -0.00578000f, -0.02226578f, -0.02273171f, -0.04073589f, -0.02397248f, -0.01798981f, -0.03148775f, -0.03460229f, 
    -0.00845362f, 0.02139819f, 0.01443121f, -0.02703188f, 0.02395792f, -0.02846800f, -0.02082366f, 0.02951966f, 
    -0.02959181f, 0.01813151f, -0.02133884f, -0.02591397f, 0.02119024f, -0.00953897f, 0.02467257f, -0.02598748f, 
    0.01383233f, -0.01918737f, 0.02479332f, -0.00557149f, -0.03457301f, -0.01107064f, -0.00949734f, -0.00097979f, 
    -0.04331465f, 0.02056244f, -0.02566287f, -0.03466056f, -0.02700027f, -0.02248091f, -0.02632227f, 0.02524893f, 
    0.01451784f, 0.01997132f, 0.01305765f, -0.00827306f, -0.00555183f, -0.01513893f, -0.02518548f, -0.01197646f, 
    0.02462547f, -0.00463709f, -0.00342786f, -0.00963273f, -0.00271783f, -0.01151855f, 0.02824871f, 0.01875911f, 
    -0.01045309f, 0.02036120f, 0.01521853f, -0.03217237f, -0.02083020f, 0.01115899f, -0.03687593f, 0.00225406f, 
    0.00346465f, 0.00931086f, -0.00888433f, 0.01310869f, -0.02900068f, 0.01042549f, -0.02634880f, 0.00087389f, 
    0.03435298f, 0.00791149f, 0.00213201f, 0.01956408f, 0.02400474f, -0.02332460f, -0.03546675f, 0.00009064f, 
    0.02941193f, 0.01415565f, 0.00501007f, -0.02353700f, -0.01023106f, -0.02151274f, 0.00118860f, 0.02654039f, 
    -0.02161546f, -0.02715697f, 0.00483828f, -0.01935515f, 0.01115610f, 0.03334020f, 0.03303003f, 0.01699400f, 
    0.02575478f, -0.03930430f, 0.01600320f, -0.00031959f, -0.03808909f, -0.02274992f, 0.01115817f, -0.00156035f, 
    0.01959205f, -0.00261655f, 0.00091759f, -0.00573519f, 0.01998107f, -0.01695835f, 0.00633972f, -0.02665705f, 
    -0.01270402f, 0.02340719f, -0.04001430f, -0.02012338f, 0.02977885f, 0.01791629f, -0.02552920f, 0.00131931f, 
    0.00155853f, 0.02613660f, -0.00625928f, -0.02079377f, 0.03279364f, 0.02748159f, 0.00721475f, 0.01516922f, 
    0.03138040f, 0.00285305f, -0.00726734f, -0.02946324f, 0.02897312f, -0.03497640f, -0.01458594f, -0.02446308f, 
    0.00219305f, -0.01775329f, -0.02554924f, -0.00407980f, 0.01602758f, 0.00411454f, 0.02540244f, -0.02609775f, 
    0.00793900f, 0.02153696f, 0.03090059f, 0.02164255f, 0.00104808f, 0.01299026f, 0.02593906f, -0.02248764f, 
    -0.02054623f, -0.00293495f, 0.00429787f, -0.03207516f, 0.03046859f, -0.04083722f, -0.03984531f, 0.02216682f, 
    -0.01881173f, 0.03315300f, 0.01007754f, -0.01579842f, -0.02431937f, -0.02121025f, 0.00018587f, -0.01724297f, 
    -0.01787624f, -0.03250357f, -0.03985435f, 0.02762699f, 0.00326735f, 0.00945189f, -0.03555264f, -0.02857991f, 
    -0.03288242f, -0.03021573f, 0.00848182f, -0.00416931f, 0.01992867f, -0.03080103f, -0.03636878f, 0.01259044f, 
    0.01997813f, 0.00100228f, -0.02243677f, -0.03635545f, 0.01305196f, 0.01483271f, 0.03325664f, 0.01828304f, 
    -0.03568532f, -0.03238191f, -0.03277933f, -0.03150088f, -0.02937412f, -0.02036679f, 0.02225839f, -0.03793319f, 
    -0.04226680f, -0.01842572f, 0.02383661f, 0.00072620f, -0.00903868f, -0.02282387f, -0.03327643f, -0.01248117f, 
    -0.00860528f, -0.01957124f, -0.00562329f, 0.01445325f, 0.01325177f, 0.02474993f, -0.00529000f, 0.02782537f, 
    0.02811783f, 0.02292155f, -0.01578609f, 0.00355963f, -0.02702824f, -0.01315635f, -0.02078165f, 0.01512999f, 
    -0.01769522f, -0.00731032f, 0.02616975f, 0.01627358f, 0.00255971f, -0.03756263f, -0.00129773f, -0.03665251f, 
    0.01873406f, 0.00674474f, 0.00704775f, 0.00126074f, -0.03666854f, -0.02550146f, 0.01463849f, -0.02418365f, 
    -0.00190147f, -0.02441160f, -0.00958382f, -0.00231791f, -0.04013448f, -0.02717269f, 0.01014315f, 0.01476981f, 
    -0.03518349f, -0.00172246f, 0.01450935f, -0.00607726f, 0.02408210f, -0.02141624f, 0.00699044f, -0.02785930f, 
    -0.03590038f, -0.03948769f, 0.03025348f, -0.00555468f, -0.00585099f, 0.02976121f, -0.01417019f, 0.02531303f, 
    -0.02742267f, 0.02275740f, -0.02068046f, -0.00567729f, 0.00186555f, 0.03129642f, 0.01093370f, -0.01538366f, 
    0.01226289f, 0.02780730f, -0.01990321f, -0.01737375f, 0.01963111f, -0.01140625f, 0.03710368f, 0.00227030f, 
    -0.03173326f, -0.02156406f, 0.01656119f, -0.03374536f, 0.02450012f, 0.02970300f, 0.02195175f, 0.01940286f, 
    -0.03321578f, -0.03353703f, 0.02721550f, 0.00273740f, 0.00099988f, -0.01630255f, -0.03952103f, -0.00332027f, 
    0.01849556f, -0.03190028f, -0.02749821f, -0.02113303f, -0.02503395f, -0.01699552f, -0.03554564f, 0.00748532f, 
    -0.02631920f, -0.02419590f, 0.03469396f, -0.03654413f, 0.01566462f, -0.03847810f, 0.00386380f, 0.00598035f, 
    0.02303243f, 0.03100241f, -0.00421531f, -0.02800606f, -0.01641497f, 0.00816367f, -0.03241716f, 0.02636270f, 
    0.01983032f, -0.00162035f, 0.00047683f, 0.01395803f, -0.01774701f, -0.01857462f, -0.03420172f, -0.01730531f, 
    0.00599047f, 0.02005664f, -0.02305277f, -0.00055157f, 0.02506638f, 0.01462767f, 0.00497329f, 0.02176034f, 
    -0.03143620f, -0.01231567f, -0.03816012f, -0.00852840f, 0.03034606f, -0.03515194f, 0.02405980f, -0.01582736f, 
    0.02068003f, 0.00209181f, -0.00860775f, -0.03459047f, -0.02303562f, -0.00618977f, -0.02044560f, 0.01306200f, 
    0.00479353f, 0.02424747f, -0.03975130f, -0.00598674f, 0.02065217f, -0.01407856f, 0.00118113f, 0.02646929f, 
    -0.00789968f, 0.00314621f, -0.02355003f, -0.01727751f, -0.01334764f, -0.02849903f, 0.02391727f, 0.01890595f, 
    0.01390787f, -0.00239990f, 0.01958667f, 0.00598494f, -0.03757603f, 0.01244731f, -0.02527114f, -0.02017828f, 
    -0.01416208f, -0.02597671f, 0.01981401f, 0.02391594f, -0.03281509f, -0.00966644f, -0.01074360f, -0.02280978f, 
    0.00371444f, 0.03091500f, -0.03581661f, -0.00043524f, 0.00251072f, -0.02017463f, -0.02823585f, -0.00508972f, 
    -0.00059225f, 0.02861097f, 0.02829230f, 0.00793272f, 0.01554148f, 0.01739027f, -0.01050526f, 0.02806134f, 
    -0.03397172f, -0.03731884f, -0.02591685f, -0.03671835f, -0.01086012f, -0.02907079f, 0.00691606f, 0.01245666f, 
    -0.02539920f, -0.02171527f, -0.00573470f, -0.02792332f, 0.02639965f, 0.02024366f, -0.01199108f, -0.02055491f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02497826f, -0.03805001f, 0.15102266f, -0.03931456f, -0.04027660f, 0.04493592f, 0.02558119f, -0.03558540f, 
    -0.03282587f, -0.00306955f, 0.16185795f, 0.07596797f, 0.10116971f, -0.03667673f, 0.09318364f, 0.13210936f, 
    0.11036685f, 0.11359428f, 0.00466717f, 0.02603402f, 0.09405116f, 0.00992657f, -0.03387451f, 0.02318021f, 
    -0.01824724f, 0.09065072f, -0.04566140f, -0.08699844f, -0.02024689f, -0.01314769f, -0.01333125f, 0.00798193f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.06746928f, -0.24435024f, 0.37788552f, -0.16256103f, 0.16313384f, -0.00142848f, -0.06252943f, -0.09502225f, 
    0.10083722f, 0.02141331f, -0.01058376f, 0.32424548f, 0.34353924f, -0.16521698f, -0.15974379f, 0.08563759f, 
    -0.14051926f, 0.07616556f, -0.02275102f, 0.08416085f, 0.01785774f, 0.04274093f, -0.02417931f, 0.11539639f, 
    0.16433002f, 0.25033107f, 0.17948323f, -0.11138608f, 0.15107489f, 0.04345790f, -0.34831506f, 0.08227250f, 
    0.16839819f, -0.13320753f, -0.07244462f, -0.11566775f, -0.02383451f, -0.13188991f, 0.06378902f, -0.16904502f, 
    -0.03414250f, -0.03421406f, -0.08441299f, 0.06809684f, -0.01871616f, 0.08774125f, -0.00113048f, -0.08119975f, 
    -0.17474744f, -0.14005856f, 0.16253653f, 0.06733960f, -0.17716651f, -0.02393413f, -0.16165087f, 0.07038951f, 
    -0.08849856f, -0.05162562f, 0.13949873f, -0.12738985f, 0.13923997f, 0.02635092f, 0.14137834f, 0.14533453f, 
    -0.05562362f, 0.19368836f, 0.04265990f, 0.02971833f, 0.12221766f, 0.10533368f, 0.22519094f, -0.09231736f, 
    0.09782734f, 0.11281542f, 0.24187385f, 0.06811994f, 0.01359786f, 0.02837517f, -0.11925191f, -0.05741226f, 
    -0.40506062f, 0.19677287f, 0.06204947f, 0.09879229f, 0.13852108f, -0.06686179f, 0.07836447f, -0.14578202f, 
    -0.06398945f, 0.07113925f, -0.12999783f, 0.26662958f, 0.15072310f, -0.00368571f, -0.45588708f, 0.14700760f, 
    -0.02504900f, -0.31226623f, -0.17382903f, -0.07322009f, -0.16268063f, -0.21044637f, 0.05127868f, 0.00267160f, 
    -0.10152104f, -0.07342127f, 0.21397601f, -0.16436784f, 0.26260412f, -0.06613161f, 0.33310083f, 0.01026076f, 
    -0.13052481f, 0.32960793f, 0.09946028f, -0.15602495f, -0.33455524f, 0.14234313f, -0.00988416f, 0.15515053f, 
    0.16636840f, 0.11708426f, -0.27322289f, -0.16800427f, -0.08095947f, -0.04390532f, 0.19948861f, 0.00317880f, 
    -0.00838141f, -0.25178993f, -0.09094208f, -0.34025633f, 0.13859522f, -0.26189938f, -0.02268135f, 0.08568893f, 
    0.11077482f, 0.06308593f, -0.10392331f, 0.28997341f, -0.11239891f, -0.00798036f, -0.08766488f, -0.06182110f, 
    -0.24582256f, -0.16010767f, -0.05218612f, 0.10018333f, -0.08662316f, 0.11757653f, 0.13029782f, -0.10792602f, 
    0.09067945f, 0.20265207f, -0.15038049f, -0.21551566f, 0.11233189f, -0.06039095f, 0.16052504f, -0.04911193f, 
    -0.17103291f, 0.36652842f, 0.26889068f, -0.01227969f, -0.13382483f, 0.29600528f, -0.06565148f, 0.17271951f, 
    -0.11234897f, 0.02476004f, -0.17905532f, -0.02839401f, -0.29036972f, 0.03247050f, 0.08648335f, -0.08709587f, 
    0.18402250f, -0.26595190f, -0.14012016f, 0.09793409f, 0.30660853f, 0.14850952f, 0.09411179f, -0.10103224f, 
    -0.14487661f, 0.04769547f, 0.34667420f, 0.08920234f, -0.11331929f, 0.00483091f, 0.34974521f, -0.15871967f, 
    -0.01621109f, -0.04235882f, 0.03528588f, 0.28486958f, -0.00524666f, 0.24637020f, -0.12834410f, -0.12462274f, 
    0.02464219f, -0.07137538f, -0.17203920f, 0.01543366f, 0.28342909f, -0.01346804f, -0.01759157f, 0.26306418f, 
    -0.27138126f, 0.47840890f, -0.00042162f, -0.15307431f, 0.12676033f, 0.09697940f, -0.10849307f, 0.15667713f, 
    0.05376541f, -0.12019135f, -0.17508723f, 0.25401497f, -0.13847315f, 0.01460153f, -0.33939752f, 0.10937800f, 
    -0.04224666f, -0.07712667f, 0.01580677f, 0.10004792f, 0.10728042f, -0.24847735f, 0.25178111f, -0.25392088f, 
    0.10163727f, 0.15890294f, 0.04847550f, -0.30081308f, -0.07404279f, 0.06100807f, -0.28640968f, -0.00610449f, 
    0.11767207f, 0.21041280f, -0.14860991f, -0.15370607f, 0.05435938f, -0.04099650f, -0.07257161f, 0.12333601f, 
    -0.17001338f, -0.08534353f, 0.53259498f, 0.40460381f, 0.17996205f, 0.00288841f, 0.08848185f, 0.10105227f, 
    -0.07565784f, -0.00233850f, 0.35034007f, -0.23138064f, 0.08290231f, -0.08294998f, -0.22271168f, -0.10011344f, 
    -0.10763051f, -0.05040774f, -0.03707904f, 0.00312833f, 0.11389791f, 0.01860358f, 0.10615425f, 0.37541291f, 
    0.24715532f, 0.16314618f, 0.07334976f, -0.06090654f, 0.08158516f, -0.11788099f, 0.04025220f, 0.03159570f, 
    0.07481159f, 0.30224165f, -0.59788251f, 0.19576919f, -0.08505446f, 0.02800277f, 0.05678402f, -0.09136388f, 
    -0.10196877f, -0.17212293f, 0.35139719f, -0.04738632f, 0.09183652f, 0.22878514f, -0.47749558f, 0.20745364f, 
    -0.16030109f, 0.02692796f, 0.12438440f, 0.34446844f, 0.29653355f, 0.12244705f, 0.20014718f, 0.38902563f, 
    0.32371864f, 0.04264467f, 0.13088684f, -0.16290644f, 0.01493380f, 0.01537192f, 0.07533722f, 0.08073354f, 
    0.12323034f, -0.14188027f, -0.16552915f, -0.25304309f, 0.08567151f, 0.07904668f, 0.16544156f, 0.07776337f, 
    0.11205960f, -0.37754378f, 0.15196863f, -0.18716881f, 0.01204896f, -0.09065678f, 0.21461812f, -0.06169795f, 
    -0.17496608f, 0.11547440f, 0.29921573f, 0.11421400f, -0.13810413f, -0.05907236f, -0.16335779f, 0.28168833f, 
    0.27174804f, -0.04647546f, 0.16193230f, 0.03910105f, -0.22774801f, -0.04259838f, -0.14266771f, 0.11816118f, 
    0.06336288f, 0.09845666f, 0.36298046f, 0.24350800f, 0.12898596f, -0.14309217f, 0.40006495f, 0.00661144f, 
    0.05596978f, 0.30688339f, 0.04157329f, 0.02928171f, -0.10817827f, -0.43111774f, 0.48578951f, -0.30521473f, 
    -0.03940797f, -0.01904279f, 0.27910227f, 0.05689467f, -0.05962697f, 0.02588584f, -0.16504584f, -0.16603453f, 
    0.17596018f, -0.06649263f, 0.04736749f, 0.15548033f, -0.29626516f, -0.15359259f, 0.04609393f, -0.01152541f, 
    -0.02993145f, 0.27498227f, 0.25122753f, -0.14901727f, 0.06995396f, 0.11563413f, -0.09875619f, 0.02498216f, 
    -0.04969380f, 0.01604436f, -0.03501656f, -0.02423284f, 0.10960854f, -0.08257927f, -0.16625181f, -0.14950776f, 
    0.09452886f, 0.08045460f, -0.07846525f, -0.15263744f, 0.11965434f, -0.09519226f, -0.18177564f, -0.20374960f, 
    -0.03014037f, -0.03501748f, -0.12971595f, -0.14114067f, 0.09501398f, 0.16361617f, 0.11966611f, 0.07413667f, 
    0.17061789f, -0.11649809f, -0.16954568f, -0.05913548f, 0.12748384f, 0.04500160f, -0.00015879f, -0.04856781f, 
    -0.00349471f, 0.36475620f, -0.20166154f, 0.33232206f, -0.14972427f, 0.04025848f, 0.01519664f, 0.09702467f, 
    -0.11923021f, -0.11974367f, -0.06113751f, -0.06893224f, -0.14562850f, 0.02993048f, 0.30316254f, 0.09913751f, 
    0.08341768f, -0.06184828f, -0.02572901f, -0.09168478f, 0.27578148f, -0.14154428f, -0.02653860f, 0.12894306f, 
    -0.04405690f, 0.03839255f, -0.18061291f, -0.04970980f, 0.10620339f, 0.07018048f, -0.11006124f, 0.17575036f, 
    0.00088962f, 0.06540256f, 0.02876251f, 0.32623887f, 0.13244253f, -0.18556856f, -0.20512497f, 0.06258054f, 
    -0.11610782f, -0.01583084f, 0.24996649f, 0.29266128f, 0.12133448f, -0.11082423f, 0.07710915f, 0.11373951f, 
    -0.24037787f, 0.40538406f, 0.03312502f, 0.15534098f, 0.25582537f, 0.02373250f, 0.09870882f, 0.05355976f, 
    0.06000296f, -0.26203507f, -0.03175254f, 0.11927680f, -0.03453738f, 0.03308661f, -0.32198989f, -0.12559693f, 
    0.14523670f, -0.21901511f, -0.21514779f, 0.15891242f, -0.11256003f, -0.08392611f, 0.27442670f, 0.04333130f, 
    -0.05311951f, -0.05758569f, -0.02584607f, -0.04497857f, 0.05840465f, 0.17493083f, -0.01125856f, 0.34240553f, 
    0.16001858f, 0.02503414f, -0.01459805f, 0.05232607f, -0.32012317f, 0.08024111f, -0.02952318f, 0.02567925f, 
    -0.10338443f, 0.27760869f, -0.24113132f, -0.39468673f, 0.00327100f, -0.13988873f, 0.17069323f, 0.10974814f, 
    -0.07815596f, -0.19259375f, -0.06635050f, 0.06374022f, 0.03767768f, -0.07887071f, -0.09779025f, -0.06029239f, 
    -0.06785727f, -0.11600956f, -0.08612221f, -0.06611491f, -0.02864719f, -0.00618119f, 0.15211622f, -0.01838865f, 
    0.00266371f, -0.06766614f, -0.11534061f, 0.05647763f, -0.20049220f, 0.07914921f, 0.13003695f, -0.04456062f, 
    -0.10204534f, -0.03390172f, -0.04121051f, -0.01463770f, -0.09192820f, 0.08540162f, 0.05016324f, 0.10345393f, 
    0.05035878f, -0.08603206f, -0.13915084f, 0.14531593f, 0.16273052f, -0.05499835f, -0.12184479f, -0.20387690f, 
    0.09294061f, 0.04288467f, 0.05706747f, -0.13770691f, 0.10164402f, -0.13105373f, -0.15467072f, -0.15578625f, 
    -0.03318238f, -0.16229740f, 0.13777012f, 0.00455970f, 0.07524356f, 0.16700310f, 0.02046130f, 0.12891400f, 
    0.16848317f, -0.13520545f, -0.06925434f, -0.00096528f, -0.04628006f, 0.04621935f, 0.01170806f, -0.06399666f, 
    -0.09407532f, 0.30287328f, 0.26763999f, -0.19502836f, 0.16865763f, -0.16411519f, 0.37013099f, -0.04533239f, 
    -0.02844989f, 0.00294589f, 0.32200325f, -0.07229429f, 0.11783987f, 0.08272436f, 0.18778948f, -0.04200169f, 
    -0.07674802f, -0.20485796f, 0.15974444f, -0.10620555f, 0.13550948f, 0.12747876f, 0.14591305f, 0.04742751f, 
    -0.02308156f, 0.27725378f, -0.30409026f, -0.23624410f, 0.09077817f, -0.06662775f, -0.16668108f, 0.13117875f, 
    0.08083165f, 0.17258562f, 0.09297221f, -0.08631858f, 0.07136507f, 0.22560024f, 0.22047399f, 0.09321465f, 
    -0.11026704f, -0.03751442f, -0.28293791f, 0.07009704f, 0.03362697f, 0.15121466f, -0.06587884f, -0.13753726f, 
    0.01213329f, -0.21329230f, -0.16777135f, 0.12867969f, 0.39984199f, -0.15519300f, 0.06139734f, 0.00200742f, 
    0.01520986f, 0.19854003f, 0.28623682f, -0.08936678f, -0.14165334f, 0.00564036f, -0.02660706f, 0.18160675f, 
    0.12944311f, -0.31989256f, -0.05965238f, -0.21022207f, 0.11827509f, -0.02951260f, -0.14701706f, -0.25605375f, 
    -0.09122969f, -0.09801055f, 0.01958448f, -0.15459780f, 0.03415910f, 0.16369253f, 0.16683023f, 0.23837668f, 
    0.33020377f, 0.18439399f, -0.01371568f, 0.05405402f, 0.15961166f, 0.16029866f, 0.00020061f, -0.05681389f, 
    -0.13961986f, 0.05507302f, -0.39092347f, -0.37210688f, 0.15345185f, 0.13207994f, 0.02762799f, 0.04459162f, 
    0.13859364f, -0.11298939f, -0.10966457f, 0.02504341f, 0.10187469f, -0.10537144f, -0.12004889f, -0.02600318f, 
    -0.09407315f, 0.00958896f, -0.29485369f, 0.06556947f, 0.02889082f, 0.04231784f, 0.07682596f, -0.23140521f, 
    0.09839652f, -0.06736688f, 0.00639429f, -0.14526607f, -0.18047416f, -0.06204625f, 0.10187947f, 0.07846405f, 
    0.08031992f, -0.02309719f, 0.14166515f, -0.08923193f, 0.01503401f, -0.12797384f, -0.00076895f, -0.16408077f, 
    -0.10759290f, 0.24430978f, 0.24583074f, 0.25376222f, 0.07393385f, -0.04870979f, 0.12368335f, -0.30934009f, 
    -0.01428646f, -0.08446511f, -0.03157642f, -0.12912147f, 0.42838356f, 0.15492316f, 0.16873109f, -0.35087520f, 
    0.01816686f, -0.15492880f, 0.01892495f, -0.01751863f, -0.06358086f, -0.16512716f, -0.16004692f, -0.10035276f, 
    -0.17064618f, 0.20922408f, -0.07073222f, 0.27620718f, 0.11351150f, -0.04053146f, -0.23162346f, -0.12676676f, 
    0.07589272f, 0.03944140f, 0.16150503f, 0.15981659f, 0.12820962f, 0.15855712f, 0.05207365f, -0.09146138f, 
    0.10505094f, -0.10654149f, -0.15482382f, -0.27095181f, -0.06458124f, -0.02833392f, 0.10028025f, -0.01873733f, 
    0.02240846f, -0.03291274f, -0.08362240f, 0.06082565f, -0.02447070f, 0.15595764f, -0.05540561f, 0.18323244f, 
    0.06246237f, 0.02126775f, 0.22488761f, 0.15809101f, 0.13810951f, 0.02917961f, 0.03701356f, 0.10031235f, 
    0.03842601f, -0.07566442f, -0.16771461f, 0.13443030f, 0.12055475f, -0.13179883f, -0.01520327f, -0.15200804f, 
    0.01668579f, 0.17501463f, 0.23481379f, -0.11109119f, 0.18303004f, 0.15452996f, 0.20084172f, 0.29785874f, 
    0.00900969f, 0.22155853f, 0.03316731f, 0.05711709f, 0.16020036f, -0.05453663f, 0.02196083f, -0.14282940f, 
    -0.02180254f, -0.19015656f, 0.02428512f, -0.02081633f, 0.14815904f, -0.01912755f, 0.26343122f, -0.00585288f, 
    0.14134245f, 0.25497004f, 0.23587428f, 0.57597589f, -0.03509538f, 0.16234374f, 0.00460688f, -0.01523458f, 
    -0.13434714f, 0.09100261f, -0.06249148f, -0.31135583f, -0.22742434f, -0.11958332f, 0.13256459f, 0.08370839f, 
    0.11456370f, -0.07428382f, -0.15117687f, 0.10028332f, 0.34894630f, -0.16858025f, 0.13101839f, -0.02926688f, 
    -0.06554658f, -0.06549641f, -0.34539473f, 0.44479683f, -0.16466437f, 0.06240811f, 0.11897779f, -0.05435115f, 
    0.01851061f, 0.02575462f, -0.30716124f, 0.20056230f, -0.06243794f, 0.28732610f, -0.06126089f, -0.16638997f, 
    -0.13386749f, -0.00796179f, 0.08067254f, 0.01568367f, -0.20359901f, -0.07126229f, 0.12215457f, -0.04403796f, 
    0.06670870f, 0.23607376f, 0.13675298f, -0.05843759f, 0.06376279f, -0.05607724f, 0.16932644f, -0.14939350f, 
    -0.11380292f, -0.10059535f, 0.23722951f, -0.17405263f, -0.06832843f, -0.14819537f, 0.35598478f, -0.06197504f, 
    0.03676156f, 0.12416355f, 0.00016334f, 0.17248516f, 0.00589991f, -0.22588736f, 0.15167272f, 0.17941733f, 
    0.07035136f, -0.16458000f, -0.03243417f, -0.30618393f, -0.12015070f, 0.01828486f, -0.10137563f, -0.30688936f, 
    -0.17919187f, 0.09723052f, -0.08486415f, 0.13888566f, 0.05385906f, -0.17286736f, 0.00358543f, -0.17327280f, 
    -0.15963249f, 0.20474815f, -0.11559501f, 0.33571404f, -0.04908182f, -0.09025497f, -0.12346794f, 0.16852383f, 
    0.06162180f, -0.20509806f, -0.03468946f, -0.22748737f, 0.14227651f, 0.15391803f, -0.08283408f, -0.28545806f, 
    0.04066503f, 0.15681107f, 0.02155413f, 0.31270427f, -0.05739939f, 0.10949852f, -0.11305071f, 0.33940378f, 
    0.39693978f, 0.17046696f, -0.14458202f, 0.11776473f, 0.09191377f, -0.16659044f, 0.08647450f, -0.15112586f, 
    0.06013615f, 0.11275113f, 0.42578655f, -0.27345717f, 0.09077369f, 0.05404115f, 0.27617803f, -0.01874081f, 
    0.00294433f, 0.15331313f, -0.06608605f, 0.09100009f, -0.01586041f, 0.11465158f, 0.10595224f, 0.22624418f, 
    -0.01790244f, -0.15435243f, -0.10223323f, -0.08561390f, -0.36224434f, 0.02015423f, -0.11922910f, -0.05032623f, 
    0.15965950f, 0.00533931f, -0.15473852f, 0.06632052f, -0.01079469f, -0.13146485f, 0.12194092f, -0.16665047f, 
    0.13458611f, 0.18115607f, -0.04485081f, 0.20505247f, 0.16123286f, -0.06326728f, 0.27152395f, -0.06908694f, 
    0.14154425f, 0.26471850f, -0.22800735f, -0.05005926f, 0.04314012f, -0.15635945f, 0.00630889f, 0.05365579f, 
    0.09164501f, -0.09435215f, -0.08930622f, -0.05162490f, -0.22283734f, 0.01422631f, -0.24894275f, -0.23555239f, 
    -0.26990187f, -0.18799038f, 0.04766598f, 0.05076537f, 0.03502696f, -0.06534380f, -0.09884904f, 0.11831880f, 
    -0.13130070f, 0.09486604f, 0.01444137f, 0.03065333f, -0.13921909f, -0.16614734f, -0.18734623f, 0.07145979f, 
    0.03009270f, 0.09906545f, -0.11777952f, -0.11756346f, -0.03902575f, 0.01914770f, 0.18935402f, -0.38384283f, 
    -0.03467966f, 0.12633309f, 0.11595052f, -0.20481372f, -0.01388997f, 0.13675766f, 0.24776848f, -0.16107705f, 
    -0.11548533f, 0.14776865f, 0.12808295f, 0.13891412f, 0.14258029f, -0.00728802f, -0.06597101f, 0.05017580f, 
    0.04446574f, 0.19809614f, -0.53637820f, -0.02236880f, -0.03229377f, -0.06918782f, -0.16759090f, -0.03064966f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.02021100f, 0.04711895f, -0.11274648f, 0.16662686f, -0.09084096f, -0.01263747f, 0.07922467f, -0.16424961f, 
    0.10322870f, 0.24225315f, 0.15648650f, -0.01929282f, 0.10683827f, -0.05673187f, 0.16138659f, 0.02412776f, 
    -0.01513090f, -0.13196041f, 0.31156355f, -0.12984471f, 0.27171376f, -0.09139594f, 0.03349520f, -0.00207912f, 
    0.17895621f, 0.07352844f, 0.07414939f, -0.10470646f, 0.20009643f, 0.04811151f, -0.15643649f, 0.10420600f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.17881598f, -0.07151652f, -0.02031093f, 0.00718484f, 0.25092852f, 0.20011060f, 0.37862173f, 0.08068462f, 
    -0.24536937f, -0.26146710f, -0.41852486f, -0.49125066f, -0.04216960f, 0.22185563f, -0.13042840f, 0.12571351f, 
    0.00794582f, -0.03076792f, -0.26947880f, 0.29480106f, -0.53902143f, 0.08094142f, 0.02921951f, 0.16091052f, 
    -0.17180224f, 0.13126448f, 0.04886088f, 0.12572591f, -0.31182879f, 0.16117842f, -0.02679536f, -0.02245511f, 
    -0.30348518f, 0.01535420f, -0.26081127f, 0.21221600f, 0.03993803f, 0.24023707f, -0.03734315f, -0.37127802f, 
    0.10108022f, 0.24310559f, -0.31054989f, -0.27985436f, -0.06737618f, 0.36141264f, 0.08999929f, -0.14487442f, 
    0.13212670f, -0.12745167f, 0.09298726f, 0.04318619f, 0.50208694f, 0.10127691f, -0.21595986f, -0.11357978f, 
    0.06150295f, 0.19989036f, 0.08746785f, -0.47954568f, -0.11852978f, 0.08453733f, 0.06197327f, 0.28539380f, 
    0.21723811f, -0.12920424f, -0.24608861f, -0.53049523f, 0.04532772f, 0.04934004f, -0.44145602f, 0.12397946f, 
    -0.07035038f, 0.04843625f, 0.02237030f, 0.23878165f, -0.04495778f, -0.21636400f, -0.07119843f, -0.04190709f, 
    -0.13820641f, 0.09933709f, 0.26161382f, 0.43094185f, -0.43068922f, 0.01335598f, -0.06823608f, -0.06294353f, 
    -0.16244000f, -0.23392652f, -0.52518094f, -0.16115208f, 0.27369449f, -0.07124376f, 0.15142813f, -0.59842134f, 
    -0.55429590f, -0.03398079f, -0.32804886f, -0.29520082f, -0.40485427f, 0.19239894f, -0.34997454f, 0.25706309f, 
    -0.48947227f, -0.23466355f, 0.28697446f, 0.08326394f, 0.12843452f, -0.05330266f, -0.21850570f, -0.45995569f, 
    -0.09174871f, -0.08767855f, -0.16245438f, 0.11175508f, -0.65812093f, -0.01041687f, -0.05971847f, 0.18546303f, 
    -0.00094706f, 0.05946837f, 0.36980835f, -0.14873281f, 0.21887657f, 0.06365502f, -0.06580880f, -0.19308664f, 
    -0.19839253f, -0.16397731f, -0.03859273f, 0.17396818f, -0.27261531f, 0.09167069f, -0.15910250f, 0.22713810f, 
    -0.05281666f, -0.13960755f, 0.06510174f, 0.16183248f, 0.06892683f, -0.05716987f, 0.01343464f, 0.05817900f, 
    -0.11410017f, 0.10634510f, 0.05936422f, -0.11796427f, 0.05954796f, 0.14004254f, 0.22573204f, -0.03773585f, 
    -0.22819757f, 0.12327377f, -0.25561470f, 0.35567436f, -0.44450402f, 0.19109556f, -0.26045185f, -0.48111212f, 
    0.12729999f, 0.11146168f, 0.17490047f, -0.17609803f, 0.03077782f, -0.12470426f, 0.47304305f, 0.11518635f, 
    0.13746783f, 0.11648571f, 0.00248070f, -0.33542106f, -0.12138674f, -0.11642225f, 0.31414020f, -0.20021786f, 
    0.02823773f, 0.15625753f, -0.13122280f, -0.12473983f, -0.45134297f, -0.01231102f, -0.03223437f, 0.02211071f, 
    0.05087148f, 0.13671155f, -0.22437103f, 0.14048964f, -0.17844093f, -0.07908072f, 0.03526500f, -0.19467859f, 
    0.28638417f, 0.10384735f, -0.33683449f, 0.17534609f, -0.12562802f, -0.53808212f, -0.38480669f, -0.42504251f, 
    0.23897156f, 0.11132956f, 0.13084316f, 0.18388227f, -0.18185540f, -0.25398001f, -0.43135890f, 0.33486697f, 
    -0.29239267f, -0.05383277f, 0.21158172f, -0.22531782f, -0.00347735f, -0.00612720f, 0.25470534f, -0.03826746f, 
    -0.07640968f, -0.49389663f, -0.52007931f, -0.39840946f, -0.15206574f, -0.23193672f, -0.07745676f, -0.06998061f, 
    -0.23289460f, -0.04203304f, 0.11399854f, 0.19438677f, -0.07639402f, -0.37667587f, -0.13143064f, 0.34388605f, 
    -0.50713539f, -0.11267733f, 0.02241524f, 0.09659424f, 0.19562799f, -0.02897399f, 0.25496796f, -0.44643027f, 
    -0.06481077f, -0.07653769f, 0.21065140f, -0.45095825f, -0.56656891f, 0.06359507f, -0.09022771f, -0.26670095f, 
    0.30882916f, -0.20726913f, 0.02743291f, 0.06031303f, -0.24693729f, -0.23384871f, -0.07934780f, 0.00035763f, 
    0.20363513f, 0.11950383f, -0.11086223f, -0.13984229f, -0.32717001f, -0.15738292f, 0.26791605f, -0.12584899f, 
    -0.20386796f, 0.22120340f, 0.16991441f, -0.20289543f, 0.05889465f, -0.40070015f, 0.21277022f, -0.12816043f, 
    -0.08546230f, -0.12585756f, -0.45020619f, -0.35196242f, -0.09906868f, -0.07254971f, -0.52802014f, -0.29901546f, 
    -0.02880624f, -0.61252439f, 0.28056064f, -0.40669581f, 0.34039333f, -0.33613178f, -0.29549387f, -0.37047157f, 
    0.09867574f, 0.03000145f, 0.29190415f, -0.20092371f, -0.05305445f, -0.07184111f, -0.15188524f, -0.25531197f, 
    0.18521617f, -0.47616822f, -0.21423523f, 0.25274879f, -0.02272965f, 0.08171886f, -0.06347606f, -0.15697567f, 
    -0.21263914f, -0.02511102f, 0.31374562f, 0.11323445f, -0.23878062f, -0.06173623f, 0.13023889f, -0.12534852f, 
    -0.19144832f, -0.04189337f, -0.26548713f, 0.01936519f, -0.27730903f, -0.08878236f, -0.25163427f, 0.35005251f, 
    -0.02874791f, 0.00505820f, -0.78634036f, -0.21383561f, -0.71805120f, 0.20603456f, -0.28249314f, -0.06379373f, 
    0.43151978f, 0.25402328f, 0.26014954f, -0.52617502f, -0.10736237f, -0.39580455f, -0.30996406f, -0.41800079f, 
    -0.38947710f, 0.00631155f, 0.04172061f, 0.13113381f, 0.10051039f, -0.23776911f, -0.33572131f, 0.06632905f, 
    -0.11434140f, -0.00313481f, -0.34009036f, -0.18960975f, 0.07658298f, 0.16141097f, -0.55051243f, -0.31944001f, 
    -0.28083113f, -0.17361851f, -0.32116768f, 0.12191425f, -0.27219376f, -0.16672818f, -0.40271688f, 0.16730115f, 
    0.13865693f, -0.30702066f, 0.24199939f, 0.15170205f, -0.15484369f, 0.04662852f, -0.34514150f, 0.47367322f, 
    -0.10424268f, -0.11014175f, -0.03656629f, -0.12847467f, 0.08456009f, 0.01517203f, -0.57128716f, -0.16041376f, 
    0.13795148f, -0.05765150f, -0.03587335f, -0.17806754f, 0.22866271f, 0.19106919f, -0.73935932f, -0.05722921f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.38105506f, -0.12918822f, 0.10096296f, -0.13974959f, -0.10694915f, 0.07958673f, -0.01584655f, 0.14379545f, 
    0.13148554f, 0.13141748f, 0.08941837f, -0.11456878f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
