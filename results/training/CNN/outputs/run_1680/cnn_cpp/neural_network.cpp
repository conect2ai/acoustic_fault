#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.40051070f, -0.58547741f, -0.67277569f, -0.69710064f, -0.62058592f, 0.32359359f, -0.23660231f, -0.18032913f, 
    0.06960626f, -0.37504995f, 0.48359045f, -0.13017532f, 0.28095111f, 0.36288583f, 0.29923844f, -0.38159850f, 
    -0.07854122f, -0.16271339f, -0.00664398f, -0.22275646f, -0.41169271f, -0.23772207f, 0.14158480f, -0.23568593f, 
    -0.43221042f, -0.54119760f, -0.52390659f, 0.05453749f, 0.87488621f, 0.36593613f, 0.70165884f, -0.73483014f, 
    -0.53140044f, 0.17788136f, 0.12694724f, -0.30452591f, -0.16469719f, -0.35291243f, 0.08945258f, -0.04711287f, 
    -0.35869864f, 0.18593965f, 0.36571449f, 0.05080876f, 0.16193959f, 0.14953950f, 0.21729299f, -0.03207249f, 
    -0.14531890f, 0.00517189f, 1.08133650f, 0.77564591f, 0.22073297f, -0.14962886f, -0.61468917f, -0.75811529f, 
    -0.61591256f, -0.39735559f, -0.97858894f, -1.19553697f, 0.08197061f, 0.01729011f, -0.31320199f, 0.02249937f, 
    -0.09162751f, -0.16790293f, -0.09406167f, 0.37641370f, 0.13283378f, 0.09941511f, -0.20628187f, 0.27046576f, 
    -0.04560687f, -0.32485190f, -0.32751077f, -0.23615935f, -0.48124874f, -0.48381010f, -0.11953430f, 0.22533250f, 
    0.15115766f, -0.16374408f, 0.57272828f, -0.32037604f, 0.23815636f, -0.21374246f, -0.67015404f, 0.11234920f, 
    -0.54438710f, 0.16908590f, 0.40614176f, 0.27815819f, -0.17446324f, 0.09727701f, 0.06963032f, -0.16637203f, 
    -0.48122829f, -0.18526605f, -0.36275989f, -0.38668147f, -0.34717622f, -0.17634739f, -0.09901163f, -0.62044394f, 
    -0.31021875f, -0.01523474f, -0.06553534f, -0.36743990f, -0.62892210f, -0.54060316f, -0.02563678f, 0.10006522f, 
    -0.09306138f, 0.35723069f, -0.05872481f, 0.33347854f, -0.60526264f, -0.31423008f, 0.31219846f, -0.39790842f, 
    0.29202449f, 0.34383902f, 0.34653175f, 0.29583853f, 0.34007090f, 0.17292742f, 0.21115595f, 0.38129473f, 
    -0.28597504f, 0.24257040f, -0.52830458f, 0.13205095f, -0.07474697f, -0.25213042f, 0.00991207f, -0.05971357f, 
    -0.28348947f, 0.53119773f, -0.16550508f, -0.03831797f, 0.11927002f, 0.05816443f, -0.31504557f, -0.21803153f, 
    -0.43500158f, 0.07018312f, 0.37390617f, 0.31726187f, 0.11944322f, 0.19196211f, 0.53927785f, 0.28456354f, 
    0.05118124f, 0.03671373f, 0.17748030f, 0.26465425f, 0.38233116f, -0.11858529f, -0.18455313f, 0.02730422f, 
    0.12262212f, -0.38746369f, -0.05819759f, -0.08271328f, -0.00440160f, -0.05228091f, -0.00797992f, -0.14737742f, 
    -0.09168137f, -0.07732575f, -0.29355222f, -0.06160770f, -0.44021183f, -0.53187829f, -0.51315492f, 0.43171501f, 
    0.38077208f, 0.36714265f, -0.38464001f, -0.74938899f, -0.11760811f, -0.00118843f, 0.15065973f, 0.29437128f, 
    -0.05484916f, 0.12775435f, 0.18052542f, -0.11227454f, 0.08629707f, 0.11640870f, 0.19149257f, -0.17376912f, 
    0.12879680f, -0.04666623f, 0.05418037f, -0.05492514f, -0.10519509f, -0.12079455f, -0.14068447f, 0.72113252f, 
    0.67210674f, -1.16125929f, -0.30044252f, 0.22272176f, 0.61114192f, 0.14100201f, 0.49200323f, -0.43931484f, 
    -0.43994892f, -0.08227467f, -0.19531973f, -0.25744262f, 0.42248973f, -0.35698542f, 0.49109498f, -0.08634672f, 
    -0.21568590f, 0.00229461f, 0.09335703f, -0.11668738f, -0.24038565f, -0.06151794f, -0.14752506f, 0.27837792f, 
    0.14922942f, -0.38720652f, -0.14705616f, -0.09522501f, 0.44863006f, 0.46087343f, 0.27047640f, 0.14458857f, 
    0.00586899f, 0.32579231f, -0.07681940f, 0.07513242f, -0.08680381f, 0.24164662f, -0.03216365f, -0.22635031f, 
    -0.43143845f, 0.05308104f, -0.23301408f, -0.33680344f, -0.03634494f, 0.17991374f, -0.11206841f, -0.04041087f, 
    0.44533262f, 0.40321073f, -1.27471375f, -0.86143732f, -0.46445143f, -0.32144600f, -0.34279546f, 0.36194256f, 
    0.37333024f, 0.61973470f, 0.68548763f, 0.73153859f, 0.17838602f, 0.26200348f, 0.15661080f, -0.11147445f, 
    0.16027991f, -0.25388572f, 0.01571023f, 0.09822423f, -0.29791254f, -0.31709242f, 0.02479155f, 0.30198646f, 
    0.39295134f, 0.05323635f, -0.00778711f, -0.84718585f, 0.86309385f, -0.01709688f, -1.12891328f, -0.89222568f, 
    0.04499272f, 0.41254586f, 0.12501563f, 0.65237755f, 0.42719537f, -0.48689088f, 0.33820871f, -0.15840292f, 
    -0.22280076f, -0.22115554f, 0.19276512f, -0.04151777f, -0.22359063f, -0.02284883f, 0.22684346f, -0.19972539f, 
    0.19757542f, 0.11877387f, -0.04838527f, 0.06529054f, -0.53237087f, 0.07307947f, -0.27906349f, 0.16878898f, 
    -0.25619230f, -1.05413842f, -0.39202067f, -0.32383567f, -0.18270420f, -0.02384344f, 0.02326327f, -0.40715840f, 
    0.18528400f, -0.40125483f, -0.06799617f, 0.17542829f, 0.23554635f, 0.18860273f, 0.08958846f, 0.11073390f, 
    -0.01397880f, 0.08896876f, -0.16338663f, 0.37845963f, 0.48915580f, 0.29664344f, -0.61601192f, -0.84239280f, 
    -0.51438540f, 0.14216812f, -0.53682262f, 0.03466558f, -0.76219451f, -0.40788999f, -0.36672828f, 0.39909264f, 
    0.48040247f, 0.46676654f, -0.56835181f, -0.36228427f, -0.29407126f, -0.34146163f, -0.50224537f, -0.27893510f, 
    -0.11317048f, 0.17577070f, -0.25192994f, -0.19772591f, 0.16525480f, 0.03890121f, 0.21176299f, -0.79879689f, 
    0.28281564f, -0.20227782f, 0.59974521f, -0.25161082f, -0.08870932f, -0.17448550f, -0.12876363f, 0.12147456f, 
    -0.14794014f, 0.19740647f, -0.06483743f, -0.22121839f, 0.09389356f, 0.11883301f, -0.09658713f, 0.01134182f, 
    0.04628544f, -0.08591437f, -0.18898053f, -0.10735443f, -0.04590914f, -0.08049185f, 0.48101223f, -0.17093645f, 
    0.31182081f, -0.04918731f, -0.04792893f, 0.03985467f, 0.26576710f, -0.17654060f, -0.13641037f, 0.43401659f, 
    -0.14385951f, 0.15473041f, -0.12531662f, -0.49176618f, -0.14255479f, 0.52824628f, -0.15359674f, 0.14603744f, 
    -0.21203734f, 0.19891369f, 0.29394838f, 0.15602346f, 0.06957272f, -0.11701561f, -0.05036102f, -0.28461611f, 
    0.48962200f, 0.18766639f, 0.46829975f, 0.48279157f, 0.33764243f, 0.14548926f, -0.09332834f, 0.03345376f, 
    0.18768382f, 0.17983580f, 0.13317111f, 0.27185977f, -0.01672546f, -0.06340279f, 0.02570049f, -0.00374635f, 
    0.05712976f, -0.01421922f, 0.08730918f, -0.25691304f, 0.01831714f, -0.06905329f, 0.06381460f, 0.16583757f, 
    -0.04978731f, 0.21358508f, -0.45778075f, -0.96797991f, -0.46987972f, -0.25719950f, 0.01717643f, 0.25141203f, 
    0.75483388f, -0.27935085f, -0.14635737f, 0.21862116f, 0.52084351f, 0.36866745f, -0.44910282f, -0.28155309f, 
    0.30264536f, 0.25790429f, 0.07950953f, 0.10606086f, 0.11623747f, -0.17443690f, -0.21683712f, 0.02632740f, 
    -0.26444954f, -0.00913308f, -0.09888121f, -0.11952891f, 0.10918752f, 0.12026687f, -0.52156514f, 0.22819430f, 
    -0.47045156f, -0.67756742f, -0.83150250f, -0.69380087f, -0.01741467f, -0.02035400f, -0.15805225f, -0.55640829f, 
    -0.06167201f, 0.03583117f, 0.10553615f, 0.07373542f, -0.23064171f, -0.35385281f, -0.58730352f, -0.47960985f, 
    -0.22259866f, -0.08711211f, -0.09878979f, 0.38446775f, 0.22104304f, 0.00326848f, 0.09238191f, -0.26157427f, 
    0.15418534f, -0.03358380f, 0.07658581f, 0.49586987f, 0.28001443f, 0.51182097f, -0.69333440f, -0.50598514f, 
    0.54713637f, -0.08576449f, -0.30208027f, 0.17815942f, 0.16094333f, -0.39194915f, -0.43737683f, -0.00309043f, 
    0.29581720f, -0.20722267f, -0.03837675f, 0.06452023f, 0.16832025f, 0.42139724f, 0.25766385f, 0.42615795f, 
    0.24950239f, -0.09509420f, -0.31566966f, -0.28416696f, 0.11804137f, 0.23593104f, 0.09339313f, 0.11417593f, 
    0.10667513f, 0.17584082f, -0.26750281f, 0.05283511f, -0.03643966f, -0.17026970f, -0.06710748f, -0.21669032f, 
    -0.06116084f, -0.06153249f, -0.22128990f, -0.37610218f, -0.44023204f, 1.19917214f, -0.17862180f, -0.64192080f, 
    0.04846645f, -0.20990784f, 0.88163507f, 0.51293570f, 0.21601236f, -0.49401113f, -0.28656426f, 0.15308577f, 
    0.69732922f, -0.33636352f, -0.35072935f, -0.34622490f, -0.21537295f, -0.14720218f, 0.32110032f, -0.25123388f, 
    -0.11579063f, 0.01549064f, -0.16180456f, -0.00877054f, 0.07975272f, -0.26319641f, 0.87989551f, -0.01711076f, 
    -0.63065881f, -0.67817336f, -0.82177633f, -0.43408355f, -0.50824511f, 0.02934332f, 0.12403058f, -0.22179689f, 
    0.56821632f, 0.56568450f, 0.65499288f, -0.24915689f, -0.00255628f, 0.23661461f, 0.04868209f, 0.05365323f, 
    -0.10082989f, -0.22847256f, 0.01483908f, 0.11067582f, 0.06380453f, 0.19752079f, -0.05343846f, -0.96806568f, 
    -0.97833300f, -0.23547417f, 0.89977759f, 0.68955541f, 0.34117430f, 0.17049453f, -0.89460999f, -0.68195707f, 
    -0.18433450f, -0.07015713f, -0.28699762f, -0.40950841f, 0.15289475f, -0.36791372f, -0.09401978f, -0.12506963f, 
    -0.19239420f, 0.08225873f, 0.17610796f, 0.07150999f, -0.15825115f, 0.01667505f, 0.08878619f, -0.29233775f, 
    0.42244110f, -0.96416920f, -0.09879006f, -0.30011627f, -0.04594192f, 0.49061111f, 0.65270478f, 0.23342136f, 
    0.01276721f, 0.11891658f, -0.13836727f, -0.39855212f, -0.12446637f, 0.34195763f, 0.04236944f, 0.19814497f, 
    -0.20857430f, -0.37583286f, -0.22376169f, -0.06619393f, -0.35767791f, 0.22135752f, 0.15977080f, -0.11739311f, 
    -0.33915132f, -1.12429619f, -0.62990648f, 0.05469756f, -0.50856775f, -0.38864312f, 0.44186324f, -0.02226405f, 
    -0.54363966f, -0.14689440f, 0.42918566f, -0.28875878f, -0.40046561f, -0.21868522f, 0.10692523f, -0.31112853f, 
    -0.03253577f, -0.08937071f, -0.56492656f, -0.13983087f, -0.33273062f, -0.22916710f, -0.01201634f, 0.29585421f, 
    -0.17830460f, -0.07677780f, -1.00729704f, -0.41572717f, -0.44343072f, -0.81534189f, -0.33210424f, 0.30332404f, 
    0.23026711f, 0.08640282f, -0.02761979f, 0.17404073f, -0.28559378f, 0.15865166f, -0.53241920f, -0.49604863f, 
    -0.35074344f, 0.05668233f, -0.05549688f, -0.01270513f, 0.14180259f, 0.10942955f, 0.05819737f, -0.00343200f, 
    -0.38260135f, -0.03452681f, -0.10634835f, -0.47514415f, -0.33214644f, -0.45660499f, -0.39455494f, -0.14119960f, 
    0.01044837f, -0.52009702f, -0.74706829f, -0.95904458f, -0.16054791f, -0.03069935f, 0.01067224f, -0.03630242f, 
    0.52201933f, 0.34109843f, 0.45468533f, 0.04688301f, -0.16509278f, -0.27446571f, -0.64050949f, -0.34590307f, 
    0.33058608f, 0.10576541f, 0.13417707f, 0.04800189f, -0.96102655f, 0.99667257f, -0.39689997f, -0.24915093f, 
    -0.52175927f, -0.64044136f, -0.06584780f, 0.61540467f, 0.40626088f, -0.13077953f, -0.08734601f, -0.36103490f, 
    0.23053758f, -0.34827349f, -0.10068471f, 0.39759320f, -0.25779945f, -0.11686239f, 0.25078675f, -0.52148080f, 
    -0.25195366f, -0.01584147f, -0.12784784f, 0.01833025f, -0.41038051f, -0.88355213f, -0.73593038f, -0.70669955f, 
    0.05717543f, 0.16769931f, -0.31134674f, 0.04858466f, 0.07969218f, -0.32178319f, 0.64187413f, -0.42888439f, 
    -0.27560261f, -0.21502456f, -0.12607890f, 0.26640287f, -0.25370723f, 0.33290100f, -0.17186658f, -0.17818484f, 
    -0.43363541f, 0.45525187f, 0.03039522f, 0.17047368f, -0.08227512f, 0.05225415f, 0.39195323f, -1.36333513f, 
    -0.43396160f, 0.91231257f, 0.42707607f, -0.35415938f, 0.01628549f, -0.12043871f, 0.08424787f, 0.00934828f, 
    -0.05282133f, -0.20612885f, -0.35736266f, -0.22286050f, 0.34784546f, 0.22203170f, 0.08404573f, 0.14343722f, 
    0.60985684f, 0.10327086f, -0.28667343f, -0.19022296f, -0.30650395f, -0.48620704f, -0.56926250f, 0.26609305f, 
    0.33958763f, 0.47849923f, 0.18416288f, 0.11379407f, -0.09324315f, -0.11810835f, 0.16906153f, 0.20613596f, 
    0.11911339f, 0.18844002f, -0.10947323f, -0.09182452f, 0.23290169f, -0.18583548f, 0.23425405f, -0.13257745f, 
    0.04776057f, -0.24939099f, 0.04473465f, -0.00807845f, -0.29051098f, -0.17858371f, 0.01668928f, 0.26875144f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.16559117f, 0.32731953f, -0.09267689f, 0.06070267f, -0.10526727f, 0.15740936f, -0.02309798f, 0.04702775f, 
    0.39241081f, 0.29271176f, 0.36280844f, 0.32007727f, 0.22420183f, 0.28739244f, 0.29103076f, 0.32712752f, 
    -0.15043877f, 0.10631370f, 0.03864287f, 0.40516293f, 0.17291799f, 0.33170041f, 0.50847751f, 0.36984879f, 
    -0.00819595f, -0.02533202f, -0.24269724f, -0.04654539f, 0.31588086f, -0.11211158f, 0.06571350f, -0.12684543f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04460721f, -0.04222847f, 0.01451639f, -0.01550807f, 0.02224618f, -0.05259601f, 0.01758447f, -0.04879274f, 
    -0.00471565f, -0.01652500f, -0.02665128f, 0.01561629f, -0.04117101f, -0.02838004f, -0.01910341f, -0.04877875f, 
    0.01620646f, -0.00813141f, -0.00800678f, 0.01044127f, 0.00915847f, -0.02763150f, -0.02422839f, -0.01789406f, 
    -0.01369051f, -0.03312995f, -0.02292145f, 0.02707687f, 0.00293942f, -0.00111808f, -0.04903020f, 0.04181936f, 
    0.01568543f, 0.02703855f, -0.02523093f, 0.02612535f, 0.00198242f, 0.00880893f, 0.03127703f, 0.01548300f, 
    -0.04483911f, 0.00988670f, -0.01746251f, 0.03806799f, 0.02960533f, -0.01746452f, 0.00833762f, -0.01214632f, 
    -0.05067564f, -0.01117198f, -0.00916277f, 0.03384905f, 0.00678098f, -0.04076681f, -0.04490063f, 0.03656152f, 
    -0.04876355f, 0.02160804f, 0.01958829f, 0.02468801f, 0.00823862f, -0.04543457f, -0.03424107f, -0.05681073f, 
    -0.05200014f, -0.05775756f, 0.03716897f, 0.01815708f, -0.04839028f, 0.00189508f, -0.04195966f, 0.02773074f, 
    -0.01750170f, 0.02354540f, -0.01946347f, -0.05529352f, 0.00477459f, -0.05377675f, 0.03025991f, -0.04275514f, 
    0.02736057f, 0.01894061f, 0.00042095f, 0.00841281f, 0.00382597f, 0.00103382f, 0.00500468f, -0.00792074f, 
    -0.02732359f, -0.05387777f, -0.04968704f, -0.01847271f, -0.02821575f, -0.00119584f, -0.00483757f, -0.00916084f, 
    -0.01616240f, 0.00986203f, -0.05303509f, 0.02843311f, 0.01257004f, -0.04943328f, -0.04807779f, -0.00673286f, 
    -0.04599536f, 0.01740980f, -0.05422560f, -0.05635541f, 0.03715011f, 0.03787100f, -0.05412619f, -0.01216266f, 
    -0.03961812f, -0.02400371f, 0.02730175f, -0.01137018f, 0.03405369f, -0.00017096f, 0.00244888f, -0.01072977f, 
    -0.00502652f, -0.05765082f, 0.00782398f, 0.03619681f, -0.00411051f, 0.00653236f, 0.02313745f, 0.02213458f, 
    -0.02458038f, 0.01503234f, 0.03233910f, -0.03672792f, -0.03626722f, -0.00491530f, -0.02344380f, 0.00318923f, 
    -0.01653178f, 0.03380264f, 0.03368739f, -0.00761282f, 0.03265795f, -0.02293899f, -0.00696213f, -0.02435377f, 
    -0.02652743f, 0.00210859f, -0.02346512f, 0.01405661f, -0.04741906f, -0.04600749f, -0.05529600f, 0.00394105f, 
    0.04319066f, -0.01695888f, -0.02816711f, -0.04527699f, 0.03474194f, -0.05194482f, -0.00299273f, -0.01858935f, 
    -0.01995952f, 0.03470306f, -0.02649355f, 0.00393237f, -0.00289783f, -0.05597841f, -0.00824289f, -0.04240125f, 
    -0.04387830f, -0.05322019f, -0.00066248f, -0.04149727f, -0.04885979f, 0.02991918f, -0.00329446f, -0.00685682f, 
    -0.02471552f, 0.01718457f, 0.02930456f, 0.02052554f, -0.04180783f, -0.00153767f, -0.01897832f, -0.02842567f, 
    -0.01705647f, -0.04507593f, -0.00814166f, -0.02863632f, 0.02012073f, -0.01860751f, 0.02329219f, 0.02877984f, 
    0.02847681f, -0.00807395f, -0.00645077f, -0.02971010f, 0.00591536f, 0.00328678f, 0.01359908f, 0.02364229f, 
    0.02045101f, -0.00029869f, -0.04747028f, -0.01511034f, -0.01855065f, -0.01544880f, -0.04620136f, -0.02948031f, 
    -0.04679438f, -0.00891379f, 0.03890204f, 0.02158288f, 0.00056948f, 0.01209136f, 0.02510124f, 0.00347699f, 
    -0.01449273f, -0.03651841f, -0.02311365f, 0.02005057f, -0.05376142f, -0.02438828f, -0.02968751f, 0.01976310f, 
    0.01441279f, 0.02542746f, -0.04875201f, 0.00442335f, -0.03758562f, 0.01828039f, -0.00883817f, 0.02635529f, 
    -0.00009579f, -0.02985143f, -0.04309902f, -0.00232748f, -0.00340344f, 0.03269435f, -0.00042519f, 0.02706200f, 
    0.03242939f, -0.02961849f, -0.00658154f, -0.03044768f, 0.00473369f, 0.02353202f, -0.02085487f, -0.02579218f, 
    0.02583265f, -0.04199060f, 0.03954158f, 0.00573672f, -0.01169185f, -0.03698382f, -0.03917642f, 0.00639955f, 
    0.01632953f, 0.02243821f, -0.05565116f, 0.01750470f, -0.04256319f, -0.05847241f, 0.02155956f, 0.04068463f, 
    0.02889291f, 0.03555143f, -0.00054813f, 0.00094276f, -0.06236690f, 0.02136704f, -0.02942590f, -0.01384674f, 
    -0.00951954f, -0.01113465f, 0.00507083f, -0.04641622f, -0.04498540f, -0.03276828f, 0.01316797f, -0.01233681f, 
    0.01078619f, -0.01553463f, -0.02092845f, 0.01073547f, 0.00359569f, 0.00245221f, -0.00479718f, 0.03552276f, 
    -0.00801835f, 0.01751151f, -0.00828211f, 0.00510868f, 0.02035860f, -0.01301982f, -0.02882459f, -0.03601161f, 
    -0.01510245f, 0.01490077f, 0.02542575f, 0.00463463f, -0.03199319f, -0.04901237f, 0.01107203f, -0.02652476f, 
    -0.05545807f, -0.04224978f, 0.01179973f, 0.03914423f, 0.02668408f, -0.05882966f, -0.02244691f, -0.02976903f, 
    0.01575224f, -0.02243403f, 0.00163381f, 0.02787706f, 0.03102468f, -0.00984951f, 0.03622390f, 0.01433069f, 
    0.01568465f, -0.02477505f, -0.04928480f, 0.04427684f, -0.04012737f, -0.03959261f, 0.02321868f, 0.00406412f, 
    0.02281852f, 0.02513497f, -0.04007643f, 0.03680587f, -0.05797154f, 0.00582987f, -0.02761230f, -0.01175981f, 
    -0.02473552f, -0.02453764f, 0.00047964f, 0.00540651f, 0.01447437f, 0.01851767f, -0.04892563f, 0.03919884f, 
    0.03481852f, -0.05923803f, 0.01995922f, -0.00355242f, 0.01103710f, -0.00507109f, 0.01774284f, 0.03022268f, 
    -0.06090028f, 0.01766131f, 0.01482239f, -0.05568920f, -0.01584979f, 0.00314769f, 0.03813339f, 0.02528540f, 
    0.03748119f, -0.04924141f, 0.03686187f, -0.05905199f, 0.01843037f, -0.04253807f, -0.05327052f, -0.00854559f, 
    -0.04719599f, -0.01786789f, -0.00402106f, 0.02645264f, 0.03514799f, 0.01846834f, 0.02759040f, -0.01332581f, 
    0.03242015f, 0.01947351f, -0.01903781f, -0.01886068f, -0.01254595f, 0.00766993f, -0.04829421f, 0.00573728f, 
    -0.02575692f, -0.00208268f, 0.00484267f, -0.02774980f, -0.02176646f, -0.03815808f, 0.04331737f, 0.02229498f, 
    -0.04839646f, 0.01442301f, 0.02000429f, -0.02764460f, -0.02667695f, 0.02264934f, 0.04348487f, -0.05365517f, 
    0.02086424f, -0.03028840f, 0.03246415f, 0.04601935f, -0.05389451f, 0.00423369f, -0.01126860f, -0.04710009f, 
    0.03394931f, 0.03571413f, 0.04560060f, 0.03443313f, 0.03570802f, -0.00090047f, 0.01376125f, -0.01479320f, 
    -0.00803107f, 0.00573416f, -0.02738525f, 0.00862632f, -0.01094015f, -0.01380558f, -0.03606727f, 0.03010245f, 
    0.02346185f, -0.02523341f, 0.02520409f, 0.00586273f, 0.03548988f, 0.03207393f, -0.02274561f, 0.01787009f, 
    0.00753816f, -0.02625559f, 0.01450988f, -0.01957620f, -0.04873464f, -0.01368630f, -0.02966375f, 0.03058983f, 
    -0.03027298f, -0.01832630f, 0.04219174f, 0.01166059f, 0.02881625f, -0.01536514f, -0.02191490f, -0.01994125f, 
    -0.01851438f, -0.01674070f, -0.00881822f, 0.02021976f, 0.03394005f, 0.02047862f, 0.00348637f, -0.01691674f, 
    -0.03747228f, -0.00569213f, -0.00655168f, -0.02080441f, 0.02256870f, -0.02457741f, 0.03138812f, -0.05071111f, 
    -0.03310969f, -0.04019335f, -0.05755807f, -0.02404621f, -0.01254637f, -0.04582615f, 0.02566861f, -0.04071859f, 
    -0.02638233f, -0.03382967f, 0.00211655f, 0.02757500f, -0.02968897f, 0.02170253f, -0.01365251f, 0.03915400f, 
    -0.05158125f, 0.02472766f, 0.03233937f, -0.04303315f, -0.01831985f, 0.00254980f, 0.02750907f, 0.02972989f, 
    0.03547337f, 0.00534049f, 0.02158658f, 0.03486535f, -0.04697844f, 0.03828371f, -0.01662484f, -0.03304693f, 
    -0.00095580f, -0.01775596f, -0.00192002f, 0.03503018f, -0.03559522f, 0.02989228f, 0.03826045f, -0.00139924f, 
    -0.03936152f, 0.00896031f, -0.03506195f, -0.02407872f, 0.01994466f, 0.01472421f, 0.03662875f, -0.00286089f, 
    -0.00299216f, -0.02090775f, 0.03565122f, 0.04135969f, 0.03259203f, -0.03606397f, -0.01868588f, 0.02723930f, 
    0.02616989f, 0.02529177f, 0.00348994f, 0.02650478f, 0.01452809f, 0.03135673f, -0.04077978f, -0.04275671f, 
    -0.02213058f, -0.00857798f, 0.03904203f, -0.04456707f, -0.01618802f, 0.01710469f, 0.02430502f, -0.01666055f, 
    -0.01454941f, 0.02552728f, 0.04008703f, -0.04550328f, 0.03823166f, -0.00765387f, -0.01470446f, -0.03355671f, 
    -0.03214580f, 0.03662969f, -0.00052817f, -0.02403694f, 0.00849307f, -0.00913734f, -0.04598145f, 0.03861560f, 
    0.03159507f, -0.00478416f, -0.01114777f, 0.01025453f, -0.03821200f, -0.01395205f, 0.04615387f, -0.03100659f, 
    -0.02994633f, 0.02756696f, -0.04685867f, -0.02127660f, 0.02020771f, 0.01191501f, 0.01855382f, 0.03806542f, 
    -0.01996723f, -0.01755098f, -0.00650585f, -0.02491131f, -0.04631538f, -0.02115615f, 0.04188628f, -0.04487566f, 
    0.03227327f, -0.02530094f, 0.04331799f, -0.02381805f, 0.04332174f, -0.02365558f, -0.03311550f, -0.03984960f, 
    -0.04971799f, 0.04031799f, 0.00557433f, 0.02076220f, -0.02564394f, -0.03918381f, 0.00177263f, -0.00010681f, 
    0.03864695f, 0.03680902f, -0.01125571f, -0.04272417f, -0.01504026f, 0.01381475f, 0.03004980f, 0.03002432f, 
    -0.00336966f, -0.02709212f, -0.03209205f, -0.04137975f, 0.04343469f, -0.03667513f, 0.02280942f, 0.02768071f, 
    -0.02294181f, -0.02765950f, -0.01169720f, -0.00299033f, 0.03101760f, -0.03964438f, -0.00851897f, -0.01496830f, 
    -0.03644816f, 0.02513886f, -0.00506455f, -0.01592814f, -0.05598424f, -0.05465440f, -0.00354320f, -0.02812297f, 
    0.02926088f, -0.00170102f, -0.02618941f, 0.00038022f, -0.02643336f, 0.03080613f, -0.05244305f, 0.03656845f, 
    -0.01841927f, -0.04209404f, 0.03383439f, -0.03361496f, 0.04429321f, 0.02541265f, -0.03353731f, -0.04344996f, 
    0.01042890f, -0.02698763f, -0.01168329f, -0.03976416f, 0.00221084f, -0.03097133f, -0.02132173f, -0.03964446f, 
    0.03842399f, -0.03750472f, -0.02542147f, -0.03003374f, -0.01188570f, -0.01194615f, 0.03334685f, -0.01537588f, 
    -0.00962060f, -0.01301643f, -0.05466136f, 0.02561830f, 0.02784285f, 0.00829044f, -0.02678315f, -0.03944006f, 
    -0.00342090f, -0.05089134f, -0.02708648f, -0.02416042f, -0.01699960f, 0.01780020f, -0.03105028f, -0.04230421f, 
    -0.03255239f, -0.00713058f, -0.00736774f, -0.05531651f, -0.01403911f, -0.01315909f, 0.02857223f, -0.05233202f, 
    -0.02882663f, 0.01512398f, -0.02396204f, -0.01878252f, -0.04737750f, 0.00963349f, -0.03991349f, -0.00438944f, 
    0.00766871f, 0.03431556f, -0.01830708f, 0.03815315f, 0.02718467f, 0.01779177f, -0.01166881f, -0.03840561f, 
    0.00587214f, -0.03727284f, 0.03391458f, 0.01689790f, -0.00595058f, -0.03440084f, -0.01924416f, 0.01873540f, 
    -0.02015270f, -0.05131911f, -0.00844114f, -0.03061372f, -0.04298400f, 0.03811605f, -0.02144658f, -0.04275392f, 
    -0.05008925f, -0.02834159f, 0.04470868f, -0.02435746f, -0.03756329f, -0.00573260f, -0.01656732f, 0.02951191f, 
    0.00090120f, -0.03605115f, 0.01068421f, -0.04668268f, -0.03603639f, -0.03116622f, 0.04504848f, 0.01016589f, 
    -0.03024110f, 0.03146613f, 0.02799397f, -0.04021939f, -0.00435978f, 0.00572645f, 0.02014717f, 0.00543221f, 
    0.04184216f, -0.02835320f, -0.02514157f, -0.04678179f, 0.00271211f, 0.03024481f, 0.03282142f, -0.01027594f, 
    -0.04200793f, -0.01353012f, -0.01096741f, 0.02845314f, 0.00199421f, -0.05233397f, 0.00283981f, 0.01258777f, 
    0.04016914f, -0.01194984f, -0.01997908f, -0.00856950f, -0.03558413f, 0.00307792f, -0.03570274f, -0.00232652f, 
    -0.02012176f, 0.03718907f, -0.02817036f, -0.03299294f, 0.01240742f, 0.02896792f, -0.00221604f, 0.02629831f, 
    -0.30315375f, -0.23014741f, 0.09409785f, 0.36097431f, -0.03845265f, 0.01002073f, 0.10379649f, 0.03853464f, 
    -0.03059479f, 0.06902093f, -0.08707847f, -0.08263069f, -0.45305896f, 0.56641883f, -0.54692078f, 0.34226426f, 
    0.20478006f, 0.10486282f, 0.11706772f, 0.00612536f, -0.11407421f, -0.05804332f, 0.02861614f, 0.03352221f, 
    -0.04657724f, -0.37442899f, 0.41202289f, -0.04283996f, -0.04683543f, -0.07313849f, -0.22344846f, -0.23394632f, 
    -0.05526881f, -0.11700419f, 0.00586274f, 0.06634637f, -0.00923491f, -0.01083212f, -0.13130628f, 0.07357772f, 
    0.20062071f, 0.00762819f, 0.00997855f, -0.09407188f, 0.09406450f, 0.17178038f, -0.04267512f, -0.02737970f, 
    0.04176889f, -0.32294112f, 0.21362910f, 0.35671902f, -0.21862979f, -0.05450350f, 0.05215236f, 0.10856529f, 
    -0.03565851f, -0.13902724f, 0.07145500f, -0.09547685f, 0.41947687f, 0.14281370f, 0.26026657f, -0.13523364f, 
    -0.11564438f, -0.15378837f, -0.03189975f, -0.02147548f, -0.14174376f, 0.02571110f, 0.07366097f, 0.01275825f, 
    -0.04255169f, 0.29932413f, -0.00946413f, -0.12359548f, -0.13540779f, -0.01972561f, -0.18473743f, -0.04408762f, 
    0.05225359f, 0.03010659f, 0.16667913f, -0.02625751f, 0.25054944f, 0.00578975f, 0.25963375f, -0.02027142f, 
    0.11674600f, 0.10202593f, -0.10037757f, -0.02990601f, -0.00130095f, 0.00906165f, 0.03187500f, -0.16791752f, 
    -0.23639911f, 0.64768869f, -0.35312685f, 0.57171595f, 0.00463819f, 0.15474845f, 0.08250558f, 0.23005100f, 
    0.00182838f, 0.00748626f, 0.31265670f, -0.05530339f, -0.07787779f, 0.09087701f, -0.21054004f, -0.19966823f, 
    0.13837104f, -0.11760283f, 0.11769599f, 0.03731864f, 0.09209432f, 0.02100235f, 0.02874428f, 0.02378294f, 
    -0.13145207f, 0.15820588f, -0.17566705f, -0.15493271f, 0.02522138f, 0.08276065f, 0.27043942f, 0.21355753f, 
    -0.00496698f, 0.15255134f, 0.06299928f, -0.02213879f, 0.77663291f, 0.16262746f, 0.33141834f, 0.30746627f, 
    0.06415328f, 0.18942852f, -0.16476388f, -0.00055521f, -0.04751840f, 0.06841622f, 0.01290386f, 0.09400553f, 
    -0.05621253f, -0.11973639f, -0.03513307f, 0.05426466f, -0.14263031f, 0.02538489f, -0.09015272f, -0.10288959f, 
    -0.10218781f, 0.00317370f, -0.15722165f, -0.16411692f, -0.18484132f, -0.35239491f, -0.22497955f, 0.42293987f, 
    0.02301009f, 0.06716880f, -0.00111664f, 0.06917291f, 0.01535416f, 0.15166488f, 0.04609767f, 0.05504568f, 
    0.03516815f, 0.48252109f, -0.20676330f, 0.37490830f, -0.29582670f, -0.00107870f, 0.01910884f, -0.01522281f, 
    0.00850002f, 0.23592506f, 0.01391564f, 0.01194212f, 0.17047471f, 0.08403976f, 0.00133159f, -0.06332511f, 
    0.08001672f, 0.24647096f, 0.06476401f, 0.11292242f, -0.00538485f, -0.08213697f, -0.05594854f, 0.03433947f, 
    0.26271108f, 0.38713238f, 0.03995284f, 0.03007576f, -0.23044206f, -0.17201981f, 0.00566832f, -0.11838237f, 
    -0.05074967f, 0.10526504f, -0.13820124f, -0.03783226f, -0.13651502f, -0.11479487f, -0.20039001f, 0.25288868f, 
    -0.16186191f, 0.15292324f, 0.24084423f, -0.16567253f, 0.11714343f, -0.01929051f, -0.13472642f, -0.11087683f, 
    -0.30444387f, -0.21172875f, 0.07154100f, 0.09186216f, -0.01860218f, -0.06613103f, -0.11806003f, -0.10621109f, 
    0.06705645f, -0.02007463f, -0.00687842f, 0.09929555f, -0.22783294f, 0.24823329f, 0.24703364f, 0.11449708f, 
    -0.00236893f, -0.05083597f, 0.00663403f, 0.08726329f, 0.05429327f, 0.08762705f, 0.05826087f, 0.23462607f, 
    -0.01439999f, 0.30052415f, -0.02764099f, -0.19818288f, -0.15425825f, -0.11071221f, -0.07941328f, 0.00492941f, 
    -0.01887448f, 0.13898857f, 0.09943344f, 0.22892593f, 0.02848053f, 0.22656994f, 0.10542215f, 0.36481774f, 
    -0.11440828f, -0.04328874f, 0.04038594f, 0.03255052f, -0.05656794f, 0.16703010f, -0.07408828f, 0.20302799f, 
    -0.28908625f, -0.36650780f, -0.07104470f, 0.31603846f, 0.00014817f, 0.09692784f, 0.08089813f, -0.03043032f, 
    0.03726223f, -0.04831217f, -0.03841094f, 0.08370920f, -0.11513040f, 0.06512629f, -0.32047963f, 0.16514076f, 
    0.04405357f, 0.02418105f, 0.09726477f, -0.05938150f, -0.03314224f, 0.12973365f, 0.11565076f, 0.11566003f, 
    -0.31424093f, 0.13280039f, 0.41888514f, -0.06123872f, -0.08219096f, 0.18234761f, -0.03272722f, 0.17870061f, 
    -0.08378869f, -0.12578815f, -0.07777564f, 0.00057842f, 0.25681564f, -0.04816023f, 0.12379025f, 0.28612521f, 
    0.06525060f, -0.05159546f, 0.02349096f, 0.00412944f, -0.00483671f, 0.08546467f, 0.07065488f, -0.01970723f, 
    0.17669605f, -0.11901677f, 0.04092583f, 0.30756474f, -0.02731017f, 0.01787927f, -0.07395459f, -0.03915992f, 
    -0.15257227f, -0.00380029f, -0.02602680f, -0.06542120f, -0.22695524f, -0.23372914f, 0.03332309f, 0.45995536f, 
    0.05527386f, -0.05234126f, -0.01556848f, 0.06318017f, -0.01948322f, 0.09101320f, -0.06161058f, -0.04679459f, 
    0.38388836f, -0.20301820f, 0.22341686f, -0.01777812f, 0.06170699f, 0.19344230f, 0.12241846f, 0.00162153f, 
    0.09072796f, 0.16881397f, -0.01445645f, 0.04841696f, -0.19831747f, -0.03234621f, 0.06672590f, 0.05998320f, 
    -0.08902150f, 0.13604622f, 0.20476361f, 0.08229481f, -0.09537613f, 0.19715394f, -0.04988853f, 0.01412847f, 
    -0.26203975f, 0.46107420f, -0.49395275f, 0.11883218f, -0.00679760f, 0.14338452f, 0.01836113f, 0.04164879f, 
    0.00278643f, -0.03640230f, 0.05240781f, 0.02926100f, 0.23711282f, 0.19936240f, 0.17826502f, -0.15985771f, 
    -0.16677219f, -0.11985748f, -0.11486644f, -0.02804235f, 0.12807395f, 0.07820117f, -0.02008284f, -0.08265220f, 
    -0.10667907f, 0.03896855f, 0.18900932f, 0.30053511f, -0.01468321f, -0.01190209f, 0.09292194f, 0.07479160f, 
    -0.08227523f, 0.21532618f, 0.09552159f, 0.14680257f, -0.19688158f, 0.04201603f, -0.41559029f, 0.33262515f, 
    0.17437765f, 0.06046898f, 0.17850679f, -0.13398683f, -0.15227588f, -0.07342669f, -0.02506670f, 0.04414061f, 
    0.05576050f, -0.24593155f, 0.04269936f, 0.10219613f, 0.06558443f, 0.10432977f, -0.03409314f, -0.17736728f, 
    -0.00427373f, 0.02605881f, -0.08108195f, 0.01651171f, -0.06887215f, 0.00910990f, 0.06229969f, 0.17759775f, 
    0.01856164f, 0.05041579f, -0.08682092f, -0.12546192f, 0.16233636f, 0.17077368f, -0.01381922f, 0.03000520f, 
    0.14715268f, -0.06219999f, 0.25869337f, 0.20788512f, -0.26782778f, -0.13059391f, -0.03463867f, 0.22642638f, 
    0.04987227f, -0.03050428f, 0.15853709f, 0.00581520f, -0.08624915f, -0.18727371f, 0.08960797f, -0.14096166f, 
    0.01917604f, 0.09533308f, 0.10965729f, 0.01471871f, 0.02234057f, 0.06837519f, 0.01820856f, -0.01028775f, 
    0.05151226f, 0.04628385f, 0.12313019f, 0.02951265f, 0.00228602f, 0.00559836f, -0.08127441f, -0.03543029f, 
    -0.23492843f, 0.01666665f, 0.17792085f, 0.14522652f, -0.06051667f, 0.02911188f, -0.09018383f, -0.12649657f, 
    0.05939511f, -0.08628076f, -0.16049737f, 0.03178454f, 0.19731830f, 0.01449772f, 0.19256134f, -0.12785411f, 
    0.00554007f, 0.17405686f, -0.13954675f, 0.18920852f, 0.08815958f, 0.05914994f, -0.02537572f, 0.14440444f, 
    -0.06876287f, -0.07435947f, 0.17277992f, 0.10760114f, -0.20528534f, -0.18242152f, -0.08496810f, 0.22100496f, 
    0.03778167f, -0.10860132f, 0.00882552f, 0.00008614f, -0.07303408f, -0.02323733f, 0.00716283f, -0.02778815f, 
    0.00341259f, 0.52642798f, 0.19535355f, 0.21689510f, 0.14248371f, -0.12561962f, 0.00712057f, 0.06017443f, 
    0.00437660f, 0.09538244f, 0.01995318f, 0.19473387f, 0.47152543f, 0.41856894f, 0.23721920f, 0.10085154f, 
    -0.00173151f, -0.09009492f, -0.06540816f, 0.11056464f, -0.14136024f, 0.04850263f, 0.09618720f, -0.02832031f, 
    -0.08473174f, -0.18190481f, -0.13546939f, 0.16431728f, -0.22475885f, 0.09724363f, 0.13737340f, -0.05922130f, 
    0.05523792f, 0.05521788f, -0.05183184f, -0.06882776f, -0.06185373f, -0.27786243f, -0.04911316f, 0.19020300f, 
    -0.09219246f, 0.03210044f, -0.09224779f, 0.09925411f, 0.04825792f, 0.06678018f, 0.14273579f, 0.13993752f, 
    -0.14049618f, 0.13281845f, -0.09280951f, 0.21867375f, -0.13127695f, -0.01567782f, 0.18363033f, 0.14153147f, 
    0.02753556f, 0.14186904f, -0.00865968f, 0.00127260f, -0.02004807f, -0.16347687f, -0.17996509f, -0.07900947f, 
    -0.00877943f, 0.29648435f, -0.01896366f, -0.14021619f, 0.04410359f, -0.11413690f, 0.09223852f, 0.13020667f, 
    -0.19437090f, -0.20017539f, -0.22000556f, -0.03653601f, -0.09169069f, -0.09342675f, -0.03331897f, -0.07483582f, 
    -0.01214481f, 0.08882240f, -0.09327777f, -0.05036622f, -0.06514993f, -0.26002380f, 0.23500440f, -0.07556932f, 
    0.04164486f, 0.10074734f, -0.00106627f, -0.09315104f, 0.20959792f, 0.02754270f, -0.08437084f, -0.14083910f, 
    -0.14568618f, -0.23999609f, -0.15662915f, 0.05911225f, 0.10234800f, 0.13991116f, 0.10728423f, 0.02500092f, 
    0.20172942f, 0.21898578f, 0.07049388f, -0.02638029f, -0.18938033f, 0.29597864f, -0.24387242f, -0.03165721f, 
    -0.04887612f, -0.13546115f, -0.01283827f, -0.03206936f, -0.13869002f, -0.00470795f, -0.01514642f, 0.03562554f, 
    -0.08113652f, 0.06054079f, -0.17977695f, 0.09933169f, -0.04463263f, -0.03455639f, 0.01463591f, -0.07032591f, 
    -0.12201007f, 0.09899615f, -0.10000847f, 0.01170350f, 0.11367888f, -0.25218216f, 0.32376343f, 0.01158758f, 
    -0.09832804f, 0.03939468f, -0.05387041f, -0.17175327f, -0.08243975f, 0.01125390f, -0.16320145f, 0.24247177f, 
    -0.06617519f, 0.01976803f, 0.32405224f, 0.02282668f, -0.00580823f, 0.08168457f, 0.09902929f, 0.09891157f, 
    -0.00711308f, 0.03959688f, -0.04564176f, 0.04135689f, -0.35662237f, -0.10510727f, -0.20610560f, 0.10599954f, 
    0.08659034f, 0.12208370f, -0.10528382f, -0.16066763f, -0.07008391f, 0.06827585f, 0.08893505f, 0.19974472f, 
    -0.15250313f, 0.19454867f, 0.55840313f, -0.12152512f, -0.09464730f, 0.04867111f, -0.07589384f, 0.06390162f, 
    -0.19266318f, -0.17313299f, -0.00732217f, -0.01822237f, -0.06242438f, 0.05868728f, -0.18189396f, 0.26752317f, 
    -0.03752556f, 0.00455278f, 0.13743339f, 0.03623423f, -0.04861702f, 0.04769932f, 0.17192151f, -0.13826725f, 
    -0.03591570f, -0.37433586f, 0.10029674f, 0.13043045f, -0.07111755f, -0.06275634f, -0.22265616f, -0.17735308f, 
    -0.04140894f, 0.04833806f, 0.05357954f, -0.05049427f, -0.08646711f, -0.12426659f, -0.10219038f, 0.39423448f, 
    -0.04039533f, 0.00410298f, -0.00200083f, 0.14562725f, 0.02093459f, 0.11384846f, 0.02879540f, 0.06264240f, 
    0.07731400f, -0.13956994f, 0.02587535f, 0.07757683f, 0.04342774f, 0.09503098f, 0.06653681f, 0.05373719f, 
    0.10884568f, 0.17392807f, 0.00867502f, 0.01090867f, -0.27513936f, -0.01842142f, 0.01418359f, 0.17760772f, 
    -0.13074492f, 0.04019058f, 0.08495682f, 0.05232325f, -0.07445624f, 0.03134545f, 0.03927757f, 0.12021008f, 
    -0.22442020f, 0.26843810f, -0.15964867f, 0.23115622f, -0.14179006f, 0.20704561f, -0.06667566f, 0.03282312f, 
    0.18716778f, 0.00333405f, -0.01591428f, -0.06367782f, -0.22970821f, -0.10612727f, -0.17229778f, -0.01514948f, 
    0.00338700f, 0.00063423f, -0.05241213f, -0.01750387f, 0.10854781f, -0.03779295f, -0.08622944f, -0.11296809f, 
    -0.02201085f, -0.01407489f, -0.03795866f, 0.02861733f, -0.01581764f, 0.01314512f, -0.02701405f, -0.05587052f, 
    -0.03546114f, -0.00780732f, -0.01005505f, 0.00796287f, 0.03983578f, 0.00794481f, -0.01715701f, 0.02495831f, 
    -0.02670170f, -0.04772193f, -0.02944356f, 0.03743356f, 0.01695632f, 0.01567142f, 0.02308159f, -0.02011831f, 
    0.01841123f, -0.05525308f, -0.05289269f, -0.04488122f, -0.04485466f, 0.03616260f, 0.03492608f, -0.00256382f, 
    -0.05394226f, -0.03328681f, 0.02056394f, -0.01957992f, -0.00464893f, -0.02787603f, 0.02856010f, -0.04995302f, 
    -0.01993095f, 0.00997971f, -0.00693046f, 0.01811802f, -0.00508831f, -0.04009118f, 0.01933865f, -0.01412187f, 
    0.03352496f, -0.00906193f, 0.01622037f, -0.05934585f, 0.03990129f, -0.03960743f, -0.01621399f, 0.02274911f, 
    -0.02621251f, 0.02811903f, -0.00233255f, -0.02298942f, -0.03565024f, 0.01673906f, 0.02858925f, -0.00982721f, 
    0.00704546f, 0.03981942f, 0.03298828f, 0.02312626f, -0.02161877f, 0.04365307f, 0.02741375f, 0.03685113f, 
    0.01914974f, -0.01342973f, -0.04497236f, -0.00421024f, 0.01833939f, -0.04959520f, -0.01732142f, -0.03569404f, 
    -0.02664280f, 0.02810013f, -0.04613595f, 0.01834440f, -0.03186207f, 0.04520003f, 0.04655405f, -0.00865163f, 
    -0.03805570f, -0.01450276f, 0.02639126f, -0.03093676f, 0.02082037f, -0.05448791f, 0.04644731f, -0.03681517f, 
    0.03837169f, -0.01660752f, -0.04216288f, -0.03370062f, -0.05557387f, -0.05763677f, 0.01605828f, -0.04683864f, 
    -0.05215482f, 0.04075474f, -0.00174087f, -0.00357574f, -0.05022660f, -0.03589020f, -0.03328184f, -0.03595671f, 
    0.02507949f, -0.02358387f, -0.05486109f, -0.05430210f, 0.01397836f, -0.06018237f, -0.00396073f, -0.02216397f, 
    -0.05012151f, -0.01435001f, -0.01645588f, -0.00752693f, 0.01313838f, -0.00767441f, -0.04891318f, -0.02157374f, 
    0.03502381f, -0.05327531f, -0.02006764f, -0.03445448f, 0.01102788f, 0.02536076f, -0.00687764f, 0.01114181f, 
    -0.02158725f, -0.02314906f, 0.01611831f, -0.03372232f, -0.03185879f, 0.03817474f, -0.03491943f, 0.03840026f, 
    -0.03030268f, -0.04849245f, 0.02053582f, -0.04529826f, -0.04668910f, 0.00028365f, 0.03946072f, -0.01205395f, 
    -0.05316336f, -0.05017152f, -0.02270856f, 0.01933794f, -0.03633773f, -0.02707934f, 0.00390618f, -0.03978641f, 
    0.02350452f, -0.01138189f, -0.01421617f, 0.03368409f, 0.03863461f, 0.00679566f, 0.01137675f, -0.01581613f, 
    -0.03293343f, -0.05251585f, 0.02806559f, -0.00931365f, -0.02768490f, 0.02259705f, 0.01084356f, 0.00585189f, 
    -0.01573941f, -0.01117611f, 0.01210761f, 0.00375757f, 0.01296275f, -0.00027476f, 0.00398987f, -0.01839139f, 
    0.02990500f, 0.04114654f, -0.04699829f, 0.01164662f, 0.04407872f, -0.05017820f, -0.01664808f, -0.02381571f, 
    0.04310647f, 0.00371270f, -0.02265457f, -0.04055795f, 0.01971761f, -0.03837691f, 0.00262696f, 0.04132044f, 
    0.02451996f, -0.05825092f, 0.04238078f, -0.02736105f, 0.01631383f, -0.02747682f, 0.03450753f, 0.03244178f, 
    0.03017214f, -0.00294241f, -0.01090225f, 0.03342516f, 0.00208370f, -0.01424976f, 0.03509817f, 0.00165850f, 
    0.01354714f, -0.00976986f, -0.01538338f, -0.02298665f, 0.00738722f, 0.03897186f, 0.02894410f, -0.01956150f, 
    -0.01873082f, -0.00732905f, -0.04794348f, 0.00462497f, 0.01706358f, -0.04332656f, 0.03083840f, -0.04212105f, 
    -0.04209887f, -0.00318295f, -0.00100642f, -0.03498552f, 0.03933220f, -0.05355770f, -0.00190426f, 0.03928649f, 
    0.02243854f, -0.04657243f, 0.02777759f, -0.03144809f, 0.00789903f, 0.01387863f, 0.00585185f, -0.04040864f, 
    -0.01618724f, 0.01699836f, 0.00085066f, -0.03331679f, -0.04417404f, -0.02525208f, -0.01528352f, 0.01348136f, 
    0.01756935f, -0.03383868f, 0.03077863f, 0.00476995f, -0.01510408f, 0.00855447f, 0.03536265f, -0.02805705f, 
    -0.00859740f, 0.00100070f, -0.02363321f, 0.01883485f, -0.00503294f, -0.05495957f, -0.05439229f, 0.01420621f, 
    -0.00092258f, -0.00621509f, -0.04519695f, -0.00394256f, 0.04117772f, 0.02504463f, -0.05202013f, 0.00298491f, 
    -0.02445814f, -0.02587515f, -0.01243770f, 0.01418753f, 0.01189999f, -0.03990462f, -0.00846739f, -0.03317403f, 
    -0.03337152f, 0.01636783f, -0.00589917f, -0.00016137f, -0.04417741f, -0.00910634f, -0.04241054f, 0.03867476f, 
    0.00100500f, 0.01048761f, 0.03123296f, -0.04642035f, -0.02728530f, 0.03615658f, -0.05886178f, -0.00752089f, 
    0.03934238f, -0.00246238f, -0.04850414f, -0.03970969f, 0.01873216f, -0.01490029f, -0.04199513f, 0.02056534f, 
    0.00143961f, -0.02244513f, 0.03515217f, 0.03955444f, 0.03999408f, -0.03111257f, -0.01408657f, 0.03973695f, 
    -0.02118460f, -0.01790562f, 0.00174816f, -0.00104389f, 0.02945866f, 0.02276728f, -0.00528105f, 0.00554330f, 
    -0.05388552f, 0.03994555f, -0.04732821f, -0.01510566f, 0.02969877f, -0.04179228f, 0.01918818f, -0.05908684f, 
    0.04099519f, -0.00818032f, -0.01733649f, -0.01425979f, -0.02745720f, 0.00493996f, 0.01325383f, 0.00654128f, 
    -0.03839272f, -0.05244202f, 0.00245394f, -0.04839651f, -0.00397977f, -0.04086368f, -0.00131536f, -0.00627686f, 
    0.02659872f, 0.03125995f, 0.01233338f, -0.03683582f, 0.03181862f, -0.05677745f, -0.00104714f, -0.01549131f, 
    -0.04901055f, -0.00564531f, 0.01962830f, -0.03702723f, -0.05269883f, 0.03334709f, -0.04577043f, -0.02468119f, 
    -0.04583947f, 0.00874461f, 0.00896450f, -0.00709035f, -0.04129358f, 0.04540878f, -0.04494426f, 0.00926608f, 
    -0.00970264f, 0.03387547f, 0.03184121f, -0.04113813f, -0.01010461f, 0.02377182f, 0.00772134f, -0.02543548f, 
    -0.04869391f, 0.12606655f, 0.01761612f, 0.06857934f, -0.07428959f, -0.03919689f, -0.03083557f, 0.10323320f, 
    0.16312283f, 0.11505125f, -0.26417732f, -0.28994215f, -0.29804721f, -0.17109689f, -0.06562799f, 0.05851188f, 
    -0.04124934f, 0.18222636f, -0.02127941f, 0.05617881f, 0.03744835f, 0.05379133f, -0.00382170f, -0.04116902f, 
    0.28459698f, 0.16673075f, -0.35151455f, -0.18483357f, 0.08576731f, -0.13499548f, 0.14279301f, 0.01563432f, 
    -0.09093801f, -0.00846595f, -0.02092375f, -0.06534214f, -0.31504899f, -0.08934510f, -0.02858915f, -0.00143838f, 
    -0.03631742f, 0.02399630f, -0.10777112f, -0.07260302f, -0.08796261f, -0.19155750f, -0.20125599f, 0.02652115f, 
    0.25180736f, 0.03975418f, 0.07275523f, -0.01538211f, -0.01406395f, -0.10471410f, 0.16638735f, 0.37116522f, 
    0.01404265f, -0.01625221f, 0.07637604f, 0.07130516f, 0.05537316f, -0.10444062f, 0.20279303f, 0.16118696f, 
    -0.04955730f, 0.08768578f, 0.11816673f, 0.06820277f, -0.07478032f, -0.01255945f, 0.01788992f, 0.02052354f, 
    0.14065576f, 0.06356583f, -0.14699706f, 0.08267961f, -0.05078600f, -0.01238162f, -0.03943796f, 0.05926203f, 
    -0.23613875f, -0.11537345f, -0.07877039f, 0.04765287f, 0.13243365f, -0.01873089f, 0.04618924f, -0.09715212f, 
    -0.01104005f, 0.03461177f, 0.03098149f, -0.04845824f, 0.11363702f, 0.07804191f, -0.05896645f, -0.07206022f, 
    0.21175241f, -0.10089941f, 0.20443559f, -0.03416065f, -0.08667430f, -0.00320202f, 0.09718061f, 0.17549902f, 
    -0.00623006f, 0.08569869f, 0.30877602f, 0.04445530f, -0.02470405f, 0.20162486f, 0.08507700f, 0.25241691f, 
    -0.10218387f, 0.09094542f, 0.03710284f, 0.04741369f, 0.16023470f, 0.04661269f, 0.10421117f, 0.04293846f, 
    -0.06823885f, 0.13696261f, -0.21260758f, -0.36082667f, -0.18168533f, -0.03479513f, -0.02791649f, 0.01806369f, 
    -0.07778937f, -0.01821345f, -0.00483082f, -0.28571638f, -0.13851163f, 0.08030742f, 0.13214090f, -0.37974125f, 
    -0.03327790f, -0.25181636f, 0.21251650f, -0.08033281f, 0.07585894f, -0.10846334f, -0.19914420f, -0.11125231f, 
    -0.34295815f, -0.03046195f, -0.06039032f, 0.04561326f, 0.02591514f, 0.24130443f, 0.08670716f, -0.04387604f, 
    0.00695499f, 0.02445288f, -0.04567540f, 0.05256255f, 0.13573705f, -0.03363219f, 0.17810698f, 0.26870561f, 
    -0.06341932f, 0.07893806f, -0.08204799f, 0.03314302f, 0.06658053f, -0.24700788f, -0.05997262f, 0.11615857f, 
    -0.07291960f, -0.03490119f, -0.03547056f, 0.03860020f, -0.14685535f, 0.19094075f, 0.09364780f, 0.02767511f, 
    0.01844336f, 0.10613842f, 0.00822771f, 0.16550024f, -0.00030064f, 0.08931443f, -0.00561193f, 0.09167999f, 
    0.07534284f, -0.03085010f, 0.02192852f, 0.00020777f, -0.16994832f, 0.10152078f, -0.05252198f, -0.08945704f, 
    0.07381342f, -0.01864276f, 0.09923378f, 0.09438239f, -0.06625972f, 0.01607945f, 0.00291067f, -0.07931913f, 
    -0.00348809f, 0.05791572f, 0.07984879f, 0.02625652f, 0.05965235f, -0.22128196f, -0.00805732f, -0.09305664f, 
    -0.05578844f, -0.01242319f, 0.06289513f, -0.15194856f, -0.05331177f, -0.08979826f, -0.15133037f, -0.13931258f, 
    0.14366561f, 0.17459796f, 0.00202787f, -0.09147716f, 0.13120370f, -0.01577199f, -0.02753015f, 0.04277248f, 
    -0.02241408f, -0.02854407f, 0.08383375f, -0.03057789f, 0.24393484f, 0.10139976f, 0.01246875f, -0.11842538f, 
    -0.02023255f, 0.01844739f, 0.05595978f, 0.01058579f, 0.12722182f, -0.00449111f, -0.01118962f, -0.00559707f, 
    -0.11744598f, -0.04925107f, -0.10760197f, 0.11956378f, 0.02894507f, -0.01235959f, 0.01669668f, -0.04344909f, 
    0.04892041f, 0.21370573f, 0.08391248f, 0.01704164f, 0.65988964f, -0.13891518f, -0.15457851f, -0.12010518f, 
    -0.00163859f, -0.10591995f, 0.02557578f, 0.09715401f, 0.05064771f, -0.10829046f, -0.14299256f, -0.08404034f, 
    0.09793377f, -0.22342771f, 0.06243988f, -0.20946443f, 0.00081194f, 0.22698177f, -0.07394698f, -0.07652817f, 
    0.08228771f, 0.07302959f, -0.02982759f, 0.12994058f, -0.00836108f, -0.20611554f, 0.29699621f, -0.17106289f, 
    0.07005315f, -0.00321167f, 0.03826641f, 0.05180835f, 0.04994322f, 0.03847590f, -0.04113422f, -0.09879480f, 
    0.27052131f, 0.04441538f, 0.08554886f, -0.19298834f, -0.01596718f, -0.08061142f, -0.01800116f, 0.15554750f, 
    -0.01583586f, 0.05983938f, -0.11942593f, 0.05909123f, 0.17791091f, 0.27635130f, 0.09895726f, 0.04459293f, 
    0.03874356f, -0.08447915f, 0.19277042f, 0.20631075f, -0.07725954f, 0.00342709f, -0.06630490f, 0.01121935f, 
    0.00335953f, 0.00323874f, 0.25078306f, 0.03898251f, -0.09680848f, 0.01312119f, -0.15351851f, 0.00466881f, 
    -0.06935339f, -0.05207720f, -0.22497995f, -0.16168812f, 0.05582937f, 0.23784690f, 0.18189055f, 0.19577701f, 
    0.13948755f, -0.00259348f, 0.11203324f, 0.11498407f, -0.00002449f, -0.01047316f, 0.00831435f, 0.04005772f, 
    -0.26093552f, -0.05842656f, 0.13274156f, -0.01977221f, -0.04493158f, -0.03335342f, 0.07657363f, -0.04147515f, 
    0.08800484f, 0.06087143f, -0.15450561f, -0.10590348f, -0.23341818f, 0.10565042f, 0.29340702f, 0.06271224f, 
    -0.09421174f, 0.05705816f, 0.11998376f, 0.13290159f, -0.14269622f, -0.03488884f, 0.01206220f, -0.22032540f, 
    -0.20520589f, 0.06082071f, -0.02987482f, -0.13011293f, 0.09625320f, 0.07449403f, 0.01098122f, 0.04805664f, 
    -0.20805687f, -0.19311534f, -0.11478312f, 0.01492704f, 0.03179238f, -0.02646632f, 0.02428946f, 0.08911058f, 
    -0.00490644f, 0.02722889f, -0.04742699f, -0.03837931f, 0.07226537f, -0.03679407f, 0.00856305f, 0.10744272f, 
    -0.02976047f, 0.26949251f, 0.19436134f, 0.00544400f, -0.05780532f, -0.03438513f, 0.09522089f, 0.09626763f, 
    0.23275758f, -0.08564253f, 0.03367619f, -0.02027538f, 0.25937432f, -0.41146305f, 0.49107996f, -0.17080030f, 
    -0.01599650f, -0.00902730f, -0.05226338f, 0.08659919f, 0.03271636f, 0.10018431f, -0.08084711f, -0.05272293f, 
    -0.01838802f, 0.58560902f, -0.01270603f, 0.13979551f, 0.20692907f, 0.07020675f, 0.06592056f, 0.04407303f, 
    0.04992389f, -0.02694713f, 0.03044580f, -0.23135614f, -0.08460336f, -0.12103521f, 0.13569041f, -0.01858149f, 
    -0.20857026f, -0.00962545f, 0.08319110f, 0.02612846f, -0.08636922f, -0.10394409f, 0.06996917f, 0.17584573f, 
    -0.12826726f, 0.21912596f, -0.03806189f, -0.20829538f, 0.17744756f, 0.05648528f, 0.00984205f, -0.00208879f, 
    0.07372504f, 0.12422748f, -0.20874058f, 0.11086300f, -0.22975232f, -0.15247466f, -0.27313870f, 0.22950147f, 
    0.14731629f, 0.05653674f, -0.12726353f, -0.02185634f, 0.10225446f, -0.21197595f, -0.12758480f, -0.10124256f, 
    0.06892972f, -0.12646475f, -0.03946953f, -0.09150223f, 0.06660257f, -0.01676380f, 0.15618007f, 0.04040581f, 
    0.36620241f, 0.07907903f, -0.06949027f, 0.04849290f, -0.53981972f, 0.03054904f, -0.29188848f, 0.06235840f, 
    -0.05632836f, -0.14408679f, -0.02500411f, 0.14768293f, 0.04016441f, 0.02931126f, -0.05939654f, 0.20658113f, 
    0.39464346f, -0.73559886f, 0.51946837f, -0.63074589f, -0.07206679f, 0.06536792f, 0.03656235f, 0.05332363f, 
    0.03720567f, 0.00904940f, -0.18995401f, 0.10085574f, 0.31318960f, -0.10029937f, 0.02572111f, 0.04524659f, 
    -0.21664831f, -0.04656132f, -0.08378816f, -0.05239046f, -0.14690688f, -0.05652786f, -0.00407956f, -0.00771995f, 
    0.15071139f, -0.09067754f, 0.24813275f, 0.29783744f, -0.12300425f, -0.08145928f, 0.04921248f, 0.01305564f, 
    0.24529441f, -0.20579083f, 0.10391484f, -0.07035762f, -0.24454592f, 0.20113072f, -0.24802321f, 0.17743509f, 
    0.07492734f, -0.07726650f, 0.18216340f, -0.02894230f, 0.10458495f, -0.03005277f, -0.09721837f, 0.03952487f, 
    -0.13406774f, 0.02043040f, 0.25709155f, 0.22284141f, 0.16417556f, 0.07230947f, 0.07433812f, 0.21747637f, 
    0.05952457f, -0.01537861f, 0.06637091f, 0.12579031f, 0.06745809f, 0.01796114f, 0.29628143f, -0.19764847f, 
    0.00887378f, 0.01277160f, -0.01390026f, 0.08691546f, 0.10094972f, -0.02731810f, 0.03741807f, 0.06653643f, 
    0.23085557f, -0.45996162f, 0.38464609f, -0.20396733f, 0.12552683f, 0.13390037f, -0.11152371f, 0.32825279f, 
    -0.03505069f, 0.00717611f, -0.07554772f, 0.05888620f, -0.12178453f, 0.00496883f, -0.00300649f, -0.10677002f, 
    0.08997015f, -0.25321430f, -0.02979581f, -0.01684995f, -0.02131104f, 0.14877963f, 0.11280429f, 0.20273149f, 
    -0.35151616f, -0.20370097f, 0.12353098f, -0.21041979f, 0.11151333f, -0.00224608f, -0.02402206f, 0.17914413f, 
    0.11890482f, -0.13033231f, 0.00694500f, 0.02426583f, 0.02267680f, 0.04607100f, 0.22037862f, -0.22040810f, 
    0.14137974f, -0.03744084f, 0.01778804f, 0.10779813f, -0.13104576f, -0.16890469f, 0.09630954f, 0.08600857f, 
    0.06397032f, 0.20106035f, 0.20959061f, -0.09008085f, 0.06006984f, 0.03363678f, 0.08153798f, 0.01620117f, 
    -0.01394939f, -0.05238696f, 0.05507625f, -0.07365073f, 0.28931668f, -0.08046898f, -0.01106463f, -0.20019607f, 
    0.12036026f, -0.03086655f, -0.15877199f, -0.02628523f, 0.00380549f, -0.02085082f, 0.01641297f, 0.03195847f, 
    -0.03813600f, -0.22580017f, 0.06474138f, -0.01670504f, 0.07719500f, -0.05644104f, -0.05360502f, -0.14021859f, 
    0.23462716f, 0.01973305f, 0.13447680f, -0.01777033f, -0.15749264f, 0.04246458f, 0.13074781f, -0.40711102f, 
    0.12480658f, 0.07005532f, 0.06595422f, -0.01528700f, 0.14874943f, -0.15836945f, 0.10473248f, -0.21443705f, 
    -0.02744206f, 0.38249132f, 0.16714156f, 0.01600712f, 0.19344623f, 0.12130507f, 0.07242884f, -0.01377507f, 
    0.07637206f, -0.01958459f, 0.00740672f, -0.14194958f, -0.18827769f, -0.16182713f, 0.43467364f, 0.01874968f, 
    -0.16589111f, 0.01273278f, 0.00245489f, 0.16324914f, -0.02809745f, 0.12494435f, -0.05001180f, -0.08004413f, 
    0.10494127f, -0.08696873f, 0.14168318f, 0.02655059f, 0.03745573f, -0.09487901f, 0.11741069f, -0.12870976f, 
    0.20688848f, 0.11465460f, 0.03484214f, -0.08037962f, -0.39242911f, -0.10240215f, 0.04873233f, -0.02392835f, 
    -0.08092507f, -0.04132921f, 0.00912840f, 0.10528523f, 0.17316253f, 0.06172135f, -0.00540243f, 0.12361886f, 
    -0.42020106f, -0.00653416f, 0.11322099f, 0.00540165f, -0.17213523f, -0.26360354f, -0.15076473f, -0.00442751f, 
    0.07478209f, 0.00344323f, -0.03576452f, 0.08301990f, -0.13704556f, 0.11241601f, 0.25262851f, -0.07749951f, 
    0.11849102f, 0.04391152f, 0.03629441f, 0.04915300f, 0.22733614f, -0.22705603f, -0.07267708f, 0.05324023f, 
    0.03445642f, 0.20023058f, -0.20464945f, 0.20195504f, 0.07230486f, 0.03323982f, 0.12542360f, 0.06593182f, 
    0.06546909f, -0.14168216f, 0.16424721f, -0.07576247f, -0.11971133f, -0.26451758f, 0.01073394f, 0.11057267f, 
    -0.09636702f, -0.04150737f, -0.19768436f, 0.09425056f, 0.11325372f, -0.15848790f, 0.11844777f, 0.08401230f, 
    0.20013779f, -0.32559723f, 0.32129472f, -0.13591574f, -0.00677241f, -0.05514167f, 0.06842552f, 0.03846220f, 
    -0.05757125f, 0.02569067f, 0.02389054f, 0.03328839f, -0.35536715f, -0.23311573f, -0.03251575f, 0.00416831f, 
    0.01353894f, -0.11429399f, 0.00664238f, 0.04908001f, 0.00393689f, -0.02693157f, -0.00806867f, 0.01946146f, 
    0.37092173f, -0.06514183f, -0.28113657f, -0.07997961f, 0.12299366f, 0.02043858f, 0.04835950f, 0.01431887f, 
    -0.27209195f, -0.05473190f, -0.10355778f, -0.23688208f, 0.06954514f, 0.26778173f, 0.14874266f, 0.05531049f, 
    0.11384907f, -0.13019045f, 0.20723441f, -0.05557586f, 0.10944980f, -0.01859778f, -0.03876386f, -0.11443734f, 
    0.33586752f, 0.10055906f, -0.01698950f, 0.01538673f, -0.16325617f, -0.07014734f, -0.26018301f, 0.29719973f, 
    -0.21187715f, 0.07430628f, -0.04424947f, -0.22214921f, 0.01161649f, 0.15571143f, 0.22001408f, -0.16278698f, 
    0.02244865f, 0.01063158f, -0.13757323f, 0.00469851f, 0.01682208f, -0.03985753f, -0.16966036f, -0.18594702f, 
    0.14678171f, 0.15514642f, 0.08913113f, -0.23440219f, 0.00928348f, 0.28959268f, 0.07646549f, 0.19901480f, 
    -0.02060300f, 0.01908323f, 0.00592955f, 0.06937756f, -0.07289965f, 0.06082881f, 0.14539874f, 0.02788533f, 
    0.24025829f, 0.11647727f, -0.08064879f, -0.13441975f, -0.02171249f, 0.11192726f, 0.23821157f, 0.18096043f, 
    -0.19668452f, 0.02259966f, 0.01387220f, 0.05012017f, -0.01394920f, 0.00629163f, -0.13320529f, -0.12555759f, 
    -0.20822072f, -0.17137532f, -0.30126125f, -0.48808897f, -0.25750521f, -0.05486492f, -0.01176904f, -0.03964218f, 
    0.10007641f, 0.09767680f, 0.04620388f, 0.02366291f, 0.13997234f, 0.13141747f, 0.00749110f, 0.17870289f, 
    0.20459984f, 0.09331542f, -0.05961295f, -0.04013762f, -0.07781008f, 0.04651042f, -0.03872805f, -0.08624224f, 
    0.06467351f, 0.01558305f, -0.12660865f, 0.12514547f, -0.10515608f, 0.02637867f, 0.09170479f, 0.25028622f, 
    -0.12796119f, 0.00657103f, -0.01712804f, -0.20351347f, 0.21327379f, -0.13843445f, 0.11605927f, 0.18994936f, 
    -0.28893387f, -0.38307765f, -0.26873374f, -0.10162141f, 0.13037615f, 0.11263024f, -0.05555915f, -0.13834344f, 
    -0.03603912f, 0.05355323f, 0.11838742f, -0.12016932f, -0.40407911f, -0.23368596f, -0.08169643f, -0.30340514f, 
    0.10703209f, 0.20949668f, 0.04422881f, 0.12120406f, -0.01150992f, 0.15477800f, -0.00027922f, 0.20136860f, 
    0.37977177f, 0.17112683f, 0.24942335f, 0.07142694f, 0.18173854f, -0.00756948f, -0.04329360f, 0.13883783f, 
    -0.14690813f, -0.10142221f, 0.04590738f, 0.06066360f, 0.15841037f, 0.04273050f, -0.11176556f, -0.05431505f, 
    0.07797707f, 0.26373237f, 0.25287449f, 0.10850588f, 0.03197969f, -0.03485873f, 0.10760743f, 0.11346868f, 
    0.06187938f, 0.16878705f, 0.04038107f, -0.00871061f, 0.26406169f, 0.25700271f, -0.05344017f, -0.15296127f, 
    0.03699402f, 0.03506027f, -0.07225619f, 0.08320534f, -0.16613255f, 0.09718151f, 0.09299036f, -0.06159832f, 
    -0.06055199f, -0.15705612f, 0.21137218f, 0.25938395f, 0.16083361f, 0.29244757f, -0.10264499f, -0.02283860f, 
    0.10172570f, 0.19174165f, 0.13959929f, 0.23378143f, -0.00329719f, -0.00878286f, -0.09559728f, -0.01044423f, 
    -0.02651647f, -0.05793153f, 0.01461141f, 0.00913513f, 0.11459312f, -0.20637423f, -0.21395099f, -0.06236328f, 
    0.30867645f, 0.05192605f, -0.17898574f, 0.11747506f, -0.05003567f, 0.04748221f, 0.21348435f, 0.06113405f, 
    0.24763498f, 0.27283090f, 0.13083935f, -0.01800411f, -0.02482160f, -0.01458701f, 0.05026377f, -0.01343184f, 
    0.03817586f, 0.08534956f, 0.08005152f, 0.00649436f, 0.12881342f, -0.04586687f, 0.15542892f, 0.34579295f, 
    -0.05804449f, 0.01633256f, -0.10923789f, -0.13630949f, -0.14193331f, 0.05426644f, 0.08688724f, 0.16206135f, 
    -0.01591438f, 0.19363745f, 0.25608692f, 0.07890823f, 0.06202807f, 0.01330021f, -0.09895251f, -0.08729386f, 
    -0.15498637f, -0.09067537f, 0.01091580f, -0.14010888f, 0.16684891f, 0.19280782f, -0.30527183f, 0.26580971f, 
    -0.11888237f, 0.09406830f, -0.01204280f, 0.15791497f, 0.09120606f, -0.08477508f, 0.03534105f, -0.00751549f, 
    0.02995131f, -0.19645433f, 0.26252806f, 0.08170539f, 0.19327566f, 0.27869886f, 0.03392489f, 0.20277579f, 
    -0.16458857f, -0.03010131f, 0.05764404f, -0.12131763f, 0.02249586f, 0.47549486f, 0.01232587f, -0.07486017f, 
    -0.01332165f, 0.04660532f, 0.25429785f, 0.07131755f, 0.08606916f, -0.16394000f, 0.00111141f, 0.20079544f, 
    0.25218132f, 0.09248685f, -0.26834181f, 0.22608303f, 0.01873261f, -0.03597431f, -0.08553396f, -0.19459093f, 
    -0.17307538f, 0.09875683f, -0.29770494f, -0.17196131f, 0.05836438f, 0.18751393f, -0.07574486f, -0.19544016f, 
    0.15987362f, 0.21652739f, 0.31789574f, 0.00622421f, 0.00216886f, 0.02820847f, -0.13136035f, 0.05681596f, 
    0.29083583f, 0.39097884f, -0.07285649f, -0.32455942f, 0.18184590f, 0.15980296f, 0.13487676f, 0.04393535f, 
    -0.01452371f, -0.05680104f, 0.17182110f, 0.09451050f, 0.12746307f, 0.30312341f, 0.09370539f, -0.26611534f, 
    0.10150494f, -0.01690937f, 0.10778409f, 0.01940427f, -0.04122993f, -0.07513604f, -0.03851765f, 0.06615462f, 
    0.04602243f, -0.12283999f, 0.30784369f, -0.10143500f, 0.24247552f, 0.03562926f, 0.00855402f, 0.08373947f, 
    -0.01789196f, 0.02757768f, -0.10263266f, 0.03218275f, 0.08982455f, 0.37097457f, 0.05664146f, -0.08774462f, 
    0.03550194f, 0.00605197f, -0.10670806f, 0.15038362f, -0.06900001f, -0.08118578f, 0.05195754f, -0.00453382f, 
    0.02223548f, -0.02610076f, 0.06106966f, -0.13498572f, 0.10538666f, -0.20475964f, 0.11243541f, 0.17537744f, 
    -0.22479190f, 0.05442820f, -0.16054887f, -0.27281517f, 0.10690522f, 0.00640509f, 0.27615798f, 0.18034637f, 
    0.03351897f, -0.05193229f, -0.13441467f, -0.12665361f, -0.08659077f, -0.08699688f, 0.07504949f, -0.01830108f, 
    0.00329316f, 0.24404189f, -0.16421852f, -0.90369624f, 0.09075246f, 0.11481619f, 0.00711194f, 0.17935206f, 
    0.06993534f, 0.11950061f, 0.05641301f, -0.14308660f, -0.08114275f, -0.00357279f, 0.00469714f, -0.17270090f, 
    0.02989106f, 0.31252164f, -0.08438715f, 0.05642385f, -0.04827580f, 0.07034925f, 0.01764214f, 0.09688369f, 
    0.54942793f, -0.09973513f, -0.41450506f, 0.35485864f, -0.14956598f, 0.03610996f, 0.44247454f, 0.10902184f, 
    -0.15229571f, -0.13143377f, -0.02445993f, -0.08599724f, -0.05909629f, 0.16285439f, -0.10772331f, -0.00494289f, 
    -0.03877527f, 0.02653957f, -0.09905788f, 0.14794745f, -0.03686689f, 0.00822808f, -0.14189816f, -0.10384551f, 
    0.07435251f, -0.16945887f, -0.23164518f, 0.00787603f, -0.07794928f, 0.15623197f, 0.01469478f, 0.06323260f, 
    -0.09809550f, -0.04706723f, -0.07589655f, -0.13723272f, 0.07681502f, -0.03837001f, 0.01535669f, 0.08207368f, 
    -0.00013097f, 0.03025404f, 0.02805596f, -0.05070439f, -0.09429538f, -0.07939954f, -0.11700284f, 0.00291857f, 
    0.09506068f, -0.06256789f, 0.00378909f, 0.12309304f, -0.09612259f, 0.01401140f, 0.03888942f, 0.03180482f, 
    0.05533440f, 0.06232733f, 0.04108349f, -0.02882994f, 0.03535418f, 0.05055133f, -0.10880287f, -0.04447448f, 
    -0.06327216f, 0.00578131f, 0.01409004f, 0.03512394f, 0.13224067f, -0.01995216f, -0.09951253f, -0.16355090f, 
    0.25602973f, 0.12830240f, 0.12437204f, 0.01098595f, 0.20405252f, -0.02148390f, -0.05377476f, -0.07302609f, 
    0.10111047f, 0.09034755f, 0.03415082f, 0.08087223f, 0.03375417f, 0.18424138f, 0.29863650f, 0.33335519f, 
    -0.06656069f, 0.01978692f, -0.05613689f, -0.10613882f, 0.00857530f, -0.01139166f, -0.02688089f, 0.14734113f, 
    -0.03431058f, 0.20154828f, 0.33378363f, -0.04637576f, 0.00528325f, 0.00044318f, -0.02825741f, -0.01531751f, 
    0.04875725f, 0.11117526f, -0.07845490f, 0.10541096f, -0.39343584f, 0.08351894f, -0.19767903f, -0.32132095f, 
    0.02243006f, -0.09927619f, 0.04882367f, 0.00595038f, 0.00299624f, 0.07091353f, -0.07811622f, 0.05068544f, 
    -0.48990557f, -0.26235589f, -0.51105165f, -0.42076164f, 0.10468517f, 0.23957995f, 0.07630194f, -0.34940502f, 
    -0.15990913f, -0.08958526f, -0.03255612f, -0.09551561f, -0.16943689f, 0.30148196f, 0.08197289f, -0.12351529f, 
    0.05268538f, 0.11493702f, 0.22770561f, 0.12441781f, 0.10592099f, 0.03538840f, -0.02619143f, 0.06897411f, 
    -0.14870879f, -0.00601968f, 0.13154487f, 0.06935066f, 0.10647450f, 0.06991980f, -0.08917143f, -0.05811861f, 
    0.02024465f, -0.01553868f, 0.00353000f, 0.14263447f, 0.02656422f, 0.06610556f, -0.03005874f, 0.12405936f, 
    0.15097117f, 0.10921746f, -0.07685608f, 0.16974346f, -0.05765730f, -0.00035998f, 0.08003890f, -0.06858926f, 
    0.04154601f, -0.08026355f, 0.10286512f, 0.17595142f, -0.03780634f, -0.03081097f, -0.02127307f, -0.09820358f, 
    -0.01617025f, -0.06066821f, 0.03983428f, 0.03195420f, 0.05398286f, -0.15940528f, -0.01022867f, -0.06271988f, 
    0.21650240f, -0.11374548f, -0.04909248f, 0.09260064f, 0.12051020f, 0.07994620f, -0.07181151f, -0.01184601f, 
    0.09031811f, -0.34037784f, -0.10495252f, 0.09999117f, 0.22139592f, 0.10674011f, 0.04087388f, 0.20302977f, 
    -0.00401337f, -0.01323824f, 0.05536732f, 0.11422725f, 0.42507944f, 0.40107116f, -0.07545599f, 0.14538591f, 
    -0.02870142f, 0.02442112f, 0.04060865f, 0.04448759f, 0.13923535f, 0.19227128f, 0.04889521f, -0.00094835f, 
    -0.08663747f, -0.00266183f, -0.02528379f, 0.21518213f, 0.01044918f, 0.06681834f, 0.02931075f, -0.00508087f, 
    0.07351209f, 0.13750795f, 0.12886445f, 0.15126392f, 0.54096448f, -0.12618794f, 0.30594632f, -0.15143266f, 
    -0.01479203f, -0.01978312f, -0.09127365f, -0.09221093f, 0.11781582f, 0.03268181f, -0.04495304f, 0.14863773f, 
    0.21153565f, 0.27990630f, -0.04611922f, -0.35044193f, 0.21971844f, 0.10125344f, 0.02056470f, 0.08416014f, 
    0.19941092f, 0.11239583f, -0.03687128f, -0.09871478f, -0.08360495f, 0.14390732f, -0.23485951f, -0.42966512f, 
    0.13061212f, 0.03647363f, -0.17151263f, -0.01526792f, -0.15623276f, 0.03097004f, -0.08227509f, -0.07891881f, 
    0.52202553f, 0.20945114f, 0.16128023f, -0.03278998f, -0.06756751f, 0.04897412f, -0.07070091f, 0.12299558f, 
    -0.03222424f, 0.21667074f, 0.04800953f, -0.08675361f, -0.56627327f, -0.26253211f, -0.74930215f, -0.43757382f, 
    0.03392169f, 0.15533723f, 0.15056328f, 0.15766141f, -0.06007366f, -0.00090505f, 0.01754643f, 0.01788390f, 
    -0.08519741f, -0.49406818f, -0.29736105f, -0.29854542f, -0.00546477f, -0.19892594f, -0.05058302f, -0.11256970f, 
    -0.08753455f, -0.00983829f, -0.06096258f, 0.05107108f, 0.01375780f, -0.00673503f, -0.69693142f, -0.44979244f, 
    0.17123471f, 0.13339493f, 0.04685134f, 0.24509385f, -0.11072830f, -0.08301429f, -0.05912238f, -0.03763331f, 
    -0.51314425f, -0.28877476f, -0.27197146f, -0.13908538f, 0.00831179f, 0.12243024f, 0.17288561f, -0.13426979f, 
    0.27777353f, 0.00956980f, -0.14381568f, -0.10761948f, -0.48542067f, 0.05247230f, -0.54080057f, -0.38101369f, 
    0.24076028f, 0.04525575f, -0.04221708f, 0.07479610f, -0.32371730f, -0.15982874f, -0.08695123f, -0.00993271f, 
    -0.10884764f, -0.02038770f, 0.08958542f, -0.19020888f, -0.03602592f, 0.25575823f, -0.12438790f, -0.02960039f, 
    0.06788146f, -0.01667756f, -0.11636993f, -0.04710679f, 0.00820205f, 0.07329210f, 0.03035301f, 0.15577933f, 
    -0.07901142f, -0.00863579f, 0.03811899f, -0.10042258f, 0.11428590f, -0.01488121f, -0.04459698f, 0.00523207f, 
    0.20438614f, -0.08568224f, 0.34395921f, 0.02850181f, -0.08330221f, -0.08945131f, -0.08840710f, 0.07472105f, 
    -0.14452243f, 0.13912161f, 0.10457191f, -0.05490104f, 0.03697505f, -0.06100238f, 0.03047852f, -0.17441618f, 
    0.25052565f, -0.00055267f, 0.13161159f, 0.01004210f, -0.06267627f, -0.03115762f, 0.00408979f, 0.09940454f, 
    -0.13770713f, 0.31581774f, -0.10629371f, -0.09031283f, -0.13070253f, -0.15804611f, -0.28784123f, -0.17803739f, 
    -0.12180188f, -0.04777504f, 0.00265384f, 0.01284650f, 0.09969130f, -0.30858037f, -0.04657197f, 0.08032849f, 
    0.17716786f, 0.09993590f, -0.05989503f, -0.17481053f, 0.43690997f, 0.06362757f, 0.05558992f, -0.01590451f, 
    -0.08119678f, -0.21742979f, -0.02806206f, 0.20344469f, -0.18215619f, -0.01511750f, 0.02979339f, 0.21129343f, 
    -0.07528367f, -0.08373241f, 0.00101489f, -0.04258537f, -0.06015331f, -0.14008933f, 0.02845241f, -0.04230507f, 
    0.19448115f, -0.08795391f, 0.06049244f, 0.01410178f, -0.01785069f, 0.04299868f, -0.03353048f, 0.02878334f, 
    -0.07478935f, -0.00182402f, 0.03802284f, -0.00806792f, -0.09959449f, 0.01219251f, -0.07496434f, -0.07633995f, 
    -0.17164060f, 0.14487880f, 0.16228065f, 0.30853567f, -0.06154174f, 0.11948972f, 0.10578346f, -0.14617167f, 
    0.07193322f, 0.05825387f, 0.01607428f, 0.08928856f, 0.22071828f, 0.20233928f, -0.01282994f, -0.03780141f, 
    0.66954434f, -0.53246415f, 0.22373877f, -0.19320939f, -0.03560789f, 0.17291181f, 0.12611461f, -0.10726770f, 
    -0.08747528f, 0.05836851f, 0.05645192f, -0.07411233f, -0.01398385f, -0.03899218f, -0.04883346f, 0.02811158f, 
    0.04748781f, 0.00414896f, 0.11888988f, 0.01751365f, -0.00847752f, 0.10733475f, -0.01371629f, -0.06217226f, 
    0.20699205f, 0.20835438f, -0.16136983f, 0.10235249f, -0.08949954f, 0.05515801f, 0.16761349f, 0.04477209f, 
    0.03444618f, 0.01033191f, -0.03645866f, 0.08416696f, -0.40368429f, 0.43795416f, -0.01098123f, -0.16006954f, 
    -0.10570278f, -0.01545290f, -0.07235364f, 0.01159566f, -0.10444897f, 0.02923003f, -0.03590290f, -0.02256321f, 
    -0.10859916f, 0.12253982f, -0.01267353f, -0.10801199f, -0.12884261f, -0.24414146f, -0.12179037f, 0.03399435f, 
    0.05389518f, 0.00163713f, -0.04460331f, -0.02872767f, 0.22202590f, -0.20052476f, -0.06553544f, -0.03063613f, 
    -0.12758802f, -0.11524227f, 0.10764872f, 0.17625286f, 0.12515910f, 0.05438964f, 0.07738157f, 0.12053826f, 
    0.33090386f, -0.00017562f, -0.11238437f, -0.04733491f, -0.13890044f, 0.22058488f, -0.06403360f, -0.03897417f, 
    0.21926516f, 0.22167452f, 0.01652323f, -0.08945431f, -0.01200275f, 0.07077496f, 0.05486041f, -0.03305246f, 
    0.15402450f, 0.19637245f, -0.05630146f, 0.13914186f, -0.16429976f, 0.09437370f, -0.12747806f, 0.17320357f, 
    0.09829263f, 0.12092324f, 0.11088293f, 0.07096538f, 0.02871543f, 0.03397988f, 0.11692601f, 0.01739084f, 
    0.04402073f, 0.00829513f, 0.03898227f, 0.12794293f, 0.07279081f, -0.21135589f, 0.14437972f, 0.05865070f, 
    -0.21772426f, 0.08924902f, -0.03911052f, -0.05192439f, 0.16474999f, 0.00255060f, 0.11390155f, -0.09069048f, 
    0.02276865f, 0.01994149f, 0.01093435f, -0.29065847f, 0.17229879f, -0.02065032f, 0.00939514f, 0.13897626f, 
    0.09701245f, 0.20586687f, -0.03017069f, -0.10158156f, -0.11720463f, 0.21209046f, 0.08922911f, -0.00904762f, 
    -0.07302145f, 0.01446202f, -0.01292484f, 0.04019936f, 0.06430030f, 0.11501929f, -0.12279443f, -0.03367414f, 
    -0.01163312f, 0.10394071f, 0.06833313f, 0.04478587f, 0.00585173f, 0.03790183f, -0.06538980f, -0.05737344f, 
    -0.06738533f, 0.00531205f, 0.14124703f, 0.18416665f, 0.49053949f, -0.29065058f, 0.33174092f, -0.17204045f, 
    -0.13432109f, -0.07133262f, -0.07734429f, 0.14267154f, -0.14965895f, 0.06639641f, -0.26784155f, 0.13166533f, 
    -0.10829505f, -0.12314107f, 0.45099768f, -0.05838580f, 0.13710622f, 0.11212618f, -0.01741873f, 0.01243170f, 
    0.00626527f, 0.06058734f, 0.01762956f, 0.11233110f, 0.35521314f, -0.31289104f, 0.18501584f, -0.14134017f, 
    -0.02681421f, -0.13236929f, 0.11393759f, -0.05463490f, 0.05384380f, -0.06283199f, 0.13259009f, -0.07009110f, 
    0.21596800f, 0.00533748f, 0.47600639f, 0.20132199f, -0.10258710f, -0.05863845f, -0.07669073f, -0.10162857f, 
    -0.00941601f, -0.23198919f, 0.05932288f, 0.11820878f, 0.11173174f, 0.04157623f, 0.05483678f, 0.21318813f, 
    0.04702330f, -0.00605543f, 0.09108728f, 0.03317546f, 0.08511369f, -0.10349177f, 0.08315887f, -0.21774608f, 
    0.11442835f, 0.19524215f, 0.03618376f, 0.03448313f, -0.19156294f, 0.01045668f, -0.14045908f, 0.05859461f, 
    0.09946351f, -0.08247644f, -0.27295831f, 0.06755962f, -0.02045440f, -0.15011713f, 0.20284653f, 0.12642619f, 
    -0.08871890f, 0.06423377f, -0.02248118f, 0.11029394f, -0.10469410f, 0.01894409f, -0.01068676f, -0.06747952f, 
    -0.40204510f, 0.14325970f, -0.04816936f, -0.12024140f, 0.20111121f, 0.09405669f, -0.06384590f, -0.02036473f, 
    0.08892189f, 0.06060166f, -0.08954067f, 0.02520850f, 0.06496048f, -0.02184980f, 0.12252665f, 0.12736085f, 
    0.04611182f, 0.17927966f, 0.09940096f, -0.03596277f, -0.00204442f, -0.09873993f, -0.11180371f, -0.24248436f, 
    0.07549843f, -0.18601196f, -0.01660426f, -0.02284522f, 0.16691600f, 0.15352775f, 0.05641784f, -0.25224110f, 
    0.21250910f, -0.19319545f, -0.01316231f, 0.16004044f, -0.02127489f, 0.07400922f, 0.09467562f, -0.01407936f, 
    0.02387342f, 0.04944669f, 0.00356173f, 0.03092136f, 0.05906170f, -0.08258980f, -0.01987025f, 0.13686600f, 
    -0.01706330f, -0.01855416f, 0.01994209f, -0.01444084f, 0.01348093f, 0.03045435f, 0.04610040f, -0.01333231f, 
    -0.00286025f, -0.03296106f, -0.03812598f, -0.03930200f, 0.03033592f, 0.03894784f, 0.03278835f, 0.01899846f, 
    -0.02460735f, -0.03426729f, 0.00084906f, -0.01944376f, -0.04101268f, -0.04215312f, 0.00307032f, -0.03048832f, 
    -0.02096530f, -0.05046184f, -0.05632931f, 0.02908293f, 0.00297366f, 0.04661305f, -0.03363441f, 0.01053344f, 
    -0.04139064f, -0.02144522f, -0.04755921f, -0.01868695f, 0.03693954f, -0.02632708f, 0.00237004f, -0.01654721f, 
    0.03291830f, -0.05070000f, -0.01420430f, 0.00846629f, -0.04513675f, -0.03334466f, 0.01251595f, 0.01153453f, 
    0.03474271f, -0.05131153f, -0.02288862f, 0.04429391f, -0.03843031f, 0.02878982f, 0.01721898f, -0.02510060f, 
    -0.05675469f, -0.05743162f, -0.05330477f, -0.05656150f, -0.03497123f, 0.04171738f, -0.04832271f, -0.02933678f, 
    0.03693089f, 0.03173599f, 0.04451272f, -0.00396205f, 0.01758498f, 0.02579220f, -0.03476037f, -0.03963552f, 
    -0.00953123f, -0.02261608f, -0.03351210f, 0.02578093f, 0.01945300f, -0.04938839f, -0.00995069f, 0.03591723f, 
    -0.00621734f, -0.01585423f, 0.01434843f, -0.01393187f, -0.03065751f, 0.01537859f, -0.00303265f, -0.05599879f, 
    -0.05283335f, -0.01459422f, -0.01192542f, 0.03306049f, -0.03229718f, 0.01446342f, 0.03829154f, -0.04544447f, 
    0.01608728f, -0.04531702f, -0.04663081f, 0.01881369f, 0.03658698f, 0.01094164f, 0.00603936f, -0.02921872f, 
    -0.05659171f, -0.03845278f, -0.02274328f, -0.01188129f, 0.02253931f, 0.02071816f, 0.00524529f, -0.01279252f, 
    0.02647528f, -0.01387860f, 0.02885703f, -0.01425377f, -0.03075527f, -0.02397930f, 0.00230344f, -0.03932188f, 
    -0.01834801f, -0.05591100f, -0.03705184f, -0.03905396f, 0.02460506f, 0.01321649f, 0.00466998f, -0.00715031f, 
    -0.00948148f, 0.01780620f, 0.01978941f, -0.01710093f, -0.00251462f, 0.01844165f, 0.01875132f, 0.02028655f, 
    -0.03953820f, -0.00615155f, -0.05187768f, -0.02703728f, 0.00418582f, 0.02533446f, -0.04024908f, -0.03402036f, 
    -0.00284835f, -0.05240348f, -0.00365608f, 0.00457783f, -0.04403337f, 0.03174249f, -0.02325023f, -0.03953859f, 
    -0.01226114f, -0.03712989f, 0.03025383f, -0.04478670f, -0.02507589f, 0.01291637f, 0.01668159f, -0.01468097f, 
    -0.00010619f, -0.03267921f, -0.00376924f, 0.00575094f, -0.01660937f, -0.02586160f, -0.00460589f, -0.02991349f, 
    0.00165766f, -0.01802637f, 0.00382560f, 0.02943120f, 0.03795548f, -0.03016106f, 0.02641173f, -0.04096324f, 
    0.01158472f, -0.03040334f, 0.02684402f, -0.01277708f, 0.01227307f, -0.03007115f, -0.04416756f, 0.03422832f, 
    0.02240837f, -0.04916599f, 0.01678647f, 0.03019629f, -0.02234606f, 0.04359668f, -0.03484542f, -0.02532509f, 
    0.03616524f, -0.04042091f, -0.05898927f, -0.02563023f, -0.02441608f, 0.01995856f, -0.03860973f, -0.01623129f, 
    -0.03984291f, -0.00312348f, 0.02187463f, 0.02087757f, -0.04342873f, -0.02674637f, -0.05789885f, -0.00355171f, 
    0.00179182f, -0.03137327f, -0.01076667f, 0.02181507f, 0.03037593f, -0.01317658f, -0.01506243f, 0.03425071f, 
    0.02083721f, -0.02190365f, -0.03666297f, -0.02775872f, 0.03230539f, 0.02540705f, 0.00458144f, -0.03591821f, 
    0.02749013f, -0.02043381f, -0.01254707f, -0.01586671f, 0.01457290f, 0.02012895f, -0.00873905f, -0.00115889f, 
    -0.01102897f, 0.03752351f, -0.01803761f, 0.00285374f, -0.01612453f, 0.02906661f, -0.02924873f, 0.03128171f, 
    -0.01153153f, -0.00860320f, -0.01279096f, 0.03123001f, -0.03779775f, 0.00688498f, -0.01392798f, 0.01557083f, 
    0.01334599f, -0.00531100f, 0.01163697f, 0.01974868f, 0.00624887f, 0.03390450f, -0.04853454f, 0.01358716f, 
    0.00673141f, -0.02342824f, -0.02098530f, -0.04858024f, 0.01516880f, 0.04623854f, -0.03704437f, 0.01687123f, 
    0.00767777f, -0.04058027f, -0.04398092f, -0.05365129f, -0.05493342f, -0.01197772f, 0.03437628f, 0.00588312f, 
    -0.05760711f, -0.04975233f, 0.02981313f, 0.00778682f, -0.03047975f, -0.02591514f, 0.02706316f, 0.04229824f, 
    0.02447418f, 0.01595677f, 0.02528562f, -0.03554088f, 0.03151663f, -0.04936614f, -0.05707496f, -0.03654181f, 
    0.04199651f, 0.03211819f, 0.01390323f, -0.00806145f, 0.01116897f, 0.01772862f, -0.00112578f, 0.00402568f, 
    0.04353815f, -0.05716200f, -0.00046937f, 0.04385193f, -0.01602720f, 0.01195066f, -0.01985336f, 0.03750404f, 
    0.03565573f, -0.01371265f, -0.00879939f, -0.03246977f, 0.00106780f, -0.02767980f, 0.03313887f, 0.04743081f, 
    0.04400200f, 0.01154088f, -0.02774717f, 0.01377326f, 0.00893687f, -0.02976486f, -0.00662181f, -0.00907558f, 
    0.02300619f, 0.01581923f, -0.00279549f, 0.01435267f, -0.01300088f, -0.00132597f, 0.04228849f, 0.03219698f, 
    0.01813545f, -0.00578961f, -0.04785104f, -0.01419799f, -0.04965719f, -0.01096673f, 0.01856116f, -0.00645413f, 
    -0.02889938f, -0.02208398f, -0.01266103f, 0.03402351f, 0.02206448f, -0.00566968f, -0.02421523f, 0.03195234f, 
    -0.01358661f, -0.01142117f, -0.04325713f, -0.02176984f, -0.01002440f, 0.01085247f, 0.00608382f, 0.04073334f, 
    0.00515200f, -0.01071298f, 0.00149720f, -0.02889831f, -0.00412426f, 0.02498089f, -0.01795826f, -0.03888837f, 
    0.01516532f, -0.02883484f, -0.01070438f, 0.01976789f, -0.02152659f, -0.05212695f, 0.01267962f, -0.03630118f, 
    0.02791381f, -0.02403932f, -0.02248229f, -0.00307683f, 0.02565527f, -0.04968127f, -0.03482833f, 0.00765183f, 
    0.01183157f, 0.01615511f, 0.01199804f, -0.00492487f, -0.05348292f, 0.01810295f, -0.05376482f, 0.00831469f, 
    0.02407829f, -0.01714606f, -0.03884098f, 0.00701271f, 0.03396200f, 0.03385567f, 0.04246958f, 0.01097245f, 
    -0.04934667f, -0.00419797f, 0.00707833f, -0.04558672f, 0.02817221f, 0.04271815f, -0.03000306f, -0.03722619f, 
    0.02417977f, 0.01452803f, -0.03362468f, 0.00846026f, -0.00305230f, 0.00602206f, -0.00908558f, 0.00330328f, 
    -0.04329190f, -0.04301282f, -0.01630512f, -0.01027526f, -0.01128230f, 0.01454588f, -0.04957737f, 0.00972405f, 
    -0.01889494f, -0.02361301f, -0.03053813f, -0.01078498f, -0.03806474f, 0.02364657f, 0.03100534f, -0.05401982f, 
    0.00067894f, 0.01028835f, -0.05163743f, 0.01916380f, -0.00034753f, 0.03347539f, -0.04623672f, -0.03841335f, 
    -0.01251577f, 0.03991229f, -0.00712376f, 0.00957366f, 0.04405633f, 0.02695443f, 0.04145314f, 0.02670602f, 
    -0.02857927f, -0.04863853f, -0.05161606f, -0.02537317f, -0.02031353f, -0.02633775f, -0.01484901f, 0.01685082f, 
    0.03412538f, 0.03493953f, -0.05127914f, -0.02341283f, -0.00203541f, 0.02263976f, 0.00720416f, 0.03514514f, 
    0.00690090f, -0.05067946f, 0.04427066f, 0.01704532f, -0.04906569f, -0.00543478f, -0.05100840f, 0.01447915f, 
    -0.02392806f, 0.03148384f, -0.01698352f, 0.03304154f, 0.03262139f, -0.04150451f, -0.00140252f, 0.04664973f, 
    -0.01952422f, -0.03103621f, -0.02475357f, -0.03815334f, 0.03323318f, -0.04821077f, -0.04637837f, 0.00256832f, 
    0.03534913f, -0.01244264f, -0.03671559f, 0.00674562f, -0.05044527f, -0.03791084f, 0.01029799f, 0.02150871f, 
    -0.01939623f, -0.02828068f, 0.01568917f, -0.02940131f, -0.01277982f, -0.02364074f, -0.01601650f, -0.02905792f, 
    -0.00905037f, 0.04036967f, -0.00732011f, -0.05580442f, -0.02358631f, -0.05027527f, -0.03962807f, -0.02131889f, 
    -0.04755086f, -0.01636065f, -0.01700274f, -0.04189440f, 0.00357336f, 0.02199285f, 0.04481621f, -0.00883043f, 
    -0.00774802f, 0.00363887f, -0.00138339f, -0.04881159f, -0.01758466f, -0.02347755f, -0.03906899f, 0.01673030f, 
    0.00548659f, 0.00850192f, 0.01000681f, 0.02662914f, -0.03666743f, -0.01940144f, -0.04091688f, 0.01083720f, 
    -0.00357892f, 0.00059583f, -0.00239179f, 0.02419960f, 0.02649815f, -0.04534917f, 0.04249020f, 0.01023990f, 
    -0.02091812f, 0.02315652f, -0.04259982f, 0.00433864f, 0.02744418f, -0.05473031f, -0.04977020f, -0.01500791f, 
    -0.02857765f, -0.00209116f, -0.03308180f, 0.01378571f, -0.04601752f, -0.05615201f, -0.00934553f, -0.01354271f, 
    -0.05387680f, -0.03947813f, 0.00453222f, -0.00611332f, 0.04098140f, 0.03202214f, 0.03082040f, 0.03735212f, 
    -0.02630978f, -0.04725073f, 0.03892602f, -0.03810873f, -0.00015985f, -0.02156714f, -0.05433924f, -0.00180611f, 
    0.02441763f, -0.01591763f, 0.00965461f, 0.01541006f, 0.02300287f, 0.03871670f, -0.03033471f, -0.03136257f, 
    0.03184155f, -0.01239434f, -0.03704894f, 0.02270495f, -0.03087872f, -0.00775830f, 0.00237677f, -0.00491205f, 
    -0.01463230f, -0.04883367f, 0.03797115f, -0.01152862f, -0.00742412f, 0.04368703f, -0.04867094f, -0.02058429f, 
    -0.04151695f, 0.00985377f, -0.04065813f, -0.02921019f, 0.02101944f, -0.04307494f, 0.02765240f, -0.01822112f, 
    -0.04124743f, -0.04974047f, 0.01025337f, -0.02183294f, 0.01876679f, -0.04205650f, -0.04455516f, 0.00975950f, 
    -0.05618204f, -0.01745761f, -0.02168304f, 0.01148221f, -0.00807355f, 0.01300325f, 0.02569583f, 0.03912672f, 
    -0.04118454f, -0.04436811f, -0.01846313f, -0.03854552f, -0.03646137f, -0.00433074f, -0.01243462f, -0.04631796f, 
    -0.04518032f, -0.03377178f, -0.01044846f, 0.02255203f, -0.03388046f, -0.02203957f, -0.05245527f, 0.00275311f, 
    -0.04736284f, 0.02940866f, 0.01536338f, -0.03435187f, -0.00480546f, -0.03851059f, -0.05308777f, 0.04491176f, 
    0.02670026f, 0.03667093f, 0.04286984f, 0.01359475f, -0.00256192f, 0.00350255f, -0.02136552f, -0.00501001f, 
    -0.01083647f, 0.04119958f, 0.02123219f, -0.05388792f, -0.04483924f, -0.02796781f, 0.01797344f, 0.03706582f, 
    -0.03061141f, -0.03644088f, -0.00718358f, -0.04122103f, 0.02862708f, -0.03007580f, -0.01163666f, 0.00112703f, 
    -0.01244462f, 0.04293140f, -0.03889385f, -0.03758977f, -0.02256575f, -0.02820029f, -0.03645574f, 0.00630073f, 
    0.00735400f, 0.00438136f, -0.04225722f, 0.00697531f, -0.04635097f, -0.01564112f, 0.00868865f, -0.03382899f, 
    0.01948159f, -0.00529932f, -0.00174857f, -0.05424423f, 0.00488110f, -0.00697679f, 0.03588912f, 0.02470797f, 
    -0.01667420f, 0.00322996f, -0.03660765f, -0.01380039f, -0.03508103f, 0.00693656f, -0.02031120f, 0.04264462f, 
    -0.03563748f, 0.02976931f, 0.03577670f, -0.05551418f, -0.00850030f, 0.02579999f, 0.04299428f, -0.05387106f, 
    -0.01976373f, -0.02301796f, -0.05142980f, 0.04506388f, 0.01036815f, -0.03647275f, -0.01440146f, -0.00096495f, 
    -0.02287477f, -0.01580207f, 0.02956046f, -0.04718029f, 0.04554030f, -0.03319357f, 0.03631534f, 0.01178396f, 
    -0.04529864f, 0.03476455f, -0.05233929f, 0.00116112f, 0.00138133f, -0.05116222f, -0.05374521f, 0.03282643f, 
    0.00801036f, 0.03674595f, -0.02027532f, -0.03928575f, -0.01808172f, 0.03787779f, 0.00987481f, -0.01196449f, 
    -0.02723709f, 0.03549670f, -0.00289381f, 0.00345581f, 0.02964552f, -0.03740225f, -0.03327902f, 0.04156751f, 
    0.04244314f, 0.00470682f, -0.04961327f, -0.03002624f, -0.00171264f, -0.02983560f, 0.00505435f, 0.03370147f, 
    -0.00444695f, 0.04323788f, -0.01456822f, 0.01639973f, 0.02168413f, -0.02237267f, -0.03164024f, 0.01427461f, 
    -0.02714892f, -0.01666685f, -0.00909375f, 0.04970861f, -0.02842338f, 0.01200589f, 0.03976431f, -0.04662780f, 
    -0.05691909f, 0.20255148f, 0.08231396f, 0.08519948f, -0.10318021f, -0.14996330f, -0.02744172f, -0.03579514f, 
    0.22860573f, 0.13282923f, 0.08116968f, -0.01973938f, 0.07528502f, -0.64929390f, 0.08646743f, 0.06229897f, 
    0.05575611f, 0.03803426f, 0.10565446f, -0.01562962f, 0.02741929f, -0.09740294f, -0.00693891f, 0.03414401f, 
    0.28806585f, 0.29897749f, -0.31383377f, 0.22557110f, -0.00113495f, -0.04383546f, 0.25807208f, 0.01329197f, 
    0.02978512f, 0.01879958f, 0.03735049f, -0.04155254f, -0.13501213f, 0.09538886f, 0.03378692f, -0.11333362f, 
    -0.21048251f, -0.10853926f, -0.19143158f, 0.05670156f, -0.12275431f, -0.11109096f, -0.20024352f, -0.01521004f, 
    0.07155509f, 0.30870104f, 0.21116567f, -0.02780057f, 0.05082978f, -0.05520373f, 0.01886626f, 0.09714065f, 
    0.07608853f, 0.06281354f, -0.01471359f, 0.05890002f, -0.02901811f, 0.11305253f, -0.00093823f, 0.17701373f, 
    -0.12407231f, 0.21897499f, 0.00328196f, -0.00174903f, 0.02660538f, -0.03538859f, 0.02162377f, -0.05617610f, 
    0.38155255f, 0.07710152f, 0.10142395f, 0.04245992f, 0.08000458f, -0.06793527f, 0.07818490f, -0.01483808f, 
    0.17106761f, -0.16298686f, -0.06989802f, -0.11049493f, 0.20470183f, -0.03892508f, -0.13895130f, 0.00506141f, 
    0.04542613f, -0.02935848f, -0.05099534f, -0.05279379f, 0.10811497f, -0.00471335f, 0.04848346f, -0.06542932f, 
    -0.00402511f, -0.15478396f, 0.31759459f, -0.31366771f, 0.00073441f, 0.01769644f, 0.04866686f, 0.19362022f, 
    0.13365421f, 0.01729233f, 0.03473344f, 0.14926092f, 0.32386115f, 0.06409736f, 0.32354760f, 0.39820805f, 
    0.02655079f, -0.01913209f, -0.09256855f, -0.03733836f, -0.01210536f, -0.11906916f, -0.14574219f, -0.18110754f, 
    0.53858536f, 0.13079287f, 0.10119644f, -0.21231687f, -0.05640685f, -0.19720654f, -0.16081442f, -0.04970411f, 
    0.07204931f, -0.01069837f, 0.23164822f, 0.08702058f, -0.17721474f, 0.05018993f, 0.03634924f, -0.32603770f, 
    0.11139862f, -0.16185592f, 0.23734862f, 0.16988148f, 0.03570738f, -0.01871378f, 0.17461428f, -0.06888241f, 
    -0.23881975f, -0.26112080f, -0.08691706f, 0.40214196f, 0.05177986f, 0.05697586f, 0.03239797f, -0.11956302f, 
    -0.03463711f, -0.04870990f, -0.08521057f, -0.01805397f, -0.05732248f, 0.02852748f, 0.43747383f, 0.25140196f, 
    0.00657096f, 0.04665613f, -0.18344048f, -0.04343768f, 0.07167524f, -0.19423699f, 0.18185209f, 0.16682716f, 
    -0.35769808f, -0.28582305f, 0.16655914f, -0.15503412f, 0.10093278f, -0.10322969f, -0.02832334f, 0.10254914f, 
    0.02924882f, -0.12030520f, -0.03792189f, 0.11316662f, 0.08890072f, 0.02765533f, -0.05497997f, 0.04821264f, 
    0.14381696f, 0.02210833f, 0.00519431f, -0.15860613f, 0.06516711f, -0.06234796f, 0.20558266f, -0.09712138f, 
    0.09308468f, -0.03340330f, 0.04674774f, 0.06680152f, 0.00794570f, -0.01119558f, -0.02098230f, -0.03265730f, 
    0.13232161f, 0.00517972f, -0.04249310f, 0.00052812f, -0.01137670f, -0.03375091f, 0.09744068f, -0.15604818f, 
    -0.10564092f, -0.11340746f, -0.22494297f, 0.04340637f, 0.03922587f, -0.02946461f, -0.02207569f, -0.08026695f, 
    0.18409924f, 0.01304290f, 0.15750270f, 0.11467344f, 0.10471684f, 0.10537931f, 0.02813168f, 0.08292587f, 
    0.09351749f, 0.02212049f, 0.11246596f, -0.02462110f, 0.37680069f, 0.10074703f, -0.03576744f, -0.12440491f, 
    -0.02928208f, 0.02486850f, 0.02378184f, 0.01910789f, 0.03293567f, -0.15160066f, -0.00429901f, -0.23755363f, 
    0.10123565f, -0.13373716f, -0.02599470f, 0.20810664f, -0.03603664f, 0.01338783f, 0.05377284f, -0.08044714f, 
    0.18245998f, 0.21248375f, 0.16341349f, 0.20068684f, 0.31547993f, 0.01793998f, 0.13203175f, -0.03680024f, 
    0.13163747f, 0.11235636f, 0.03044502f, 0.02670480f, -0.00056869f, -0.23123901f, 0.08481356f, -0.19131054f, 
    0.01834913f, 0.08395865f, 0.08390999f, -0.13403337f, -0.01408228f, -0.00718437f, 0.10544327f, 0.03460602f, 
    0.09266489f, 0.10435320f, 0.05815500f, 0.03118313f, -0.31112847f, -0.27479050f, 0.30142528f, 0.09001666f, 
    -0.07364271f, 0.09888131f, -0.18161857f, 0.09835646f, -0.09347880f, 0.01411551f, -0.08493898f, -0.08864526f, 
    0.19439226f, -0.00075587f, -0.16648695f, -0.13571276f, 0.03572939f, -0.12685850f, -0.05092534f, 0.04950194f, 
    -0.14459279f, 0.09212284f, 0.07609752f, -0.07861077f, -0.18878734f, 0.12449875f, -0.11560863f, -0.06336120f, 
    -0.01806537f, 0.05372272f, -0.01661834f, 0.01358206f, 0.08961779f, 0.10161015f, 0.01468267f, -0.05101008f, 
    -0.20494998f, -0.33337811f, 0.10709449f, -0.02495053f, 0.02292390f, -0.16537537f, -0.23447426f, -0.14334710f, 
    -0.05295708f, -0.08764337f, -0.00031258f, 0.04850027f, 0.04957399f, 0.32034174f, 0.26581052f, 0.32022765f, 
    0.10122729f, 0.06163834f, 0.05651046f, 0.21691023f, -0.01748389f, 0.09491847f, 0.07780699f, -0.00582743f, 
    -0.22729526f, -0.12546909f, -0.12754522f, 0.10783466f, -0.04827285f, -0.06004864f, -0.01167049f, -0.04929745f, 
    0.09599460f, 0.04201025f, -0.04125911f, -0.12434018f, -0.07530323f, 0.02406220f, 0.07652590f, 0.04140545f, 
    0.03364233f, -0.08950911f, -0.04078478f, 0.15414131f, 0.01229089f, 0.06599703f, 0.04526750f, 0.05038022f, 
    -0.00439640f, -0.09846633f, 0.03581120f, -0.09532756f, -0.19776700f, 0.00817537f, -0.09742394f, 0.11873798f, 
    0.03428057f, -0.07755598f, 0.02721597f, -0.08918725f, 0.13689655f, 0.04837650f, -0.05794467f, 0.06207742f, 
    -0.00225927f, 0.02567446f, -0.06655478f, -0.06269334f, 0.18598935f, -0.01875093f, 0.04319116f, 0.05205867f, 
    -0.22820385f, 0.01332153f, 0.13297744f, -0.24503149f, -0.10975445f, -0.10350069f, -0.09861796f, -0.10729266f, 
    0.03163086f, 0.13988122f, 0.10530140f, 0.11680576f, -0.29268339f, -0.30404338f, -0.17743360f, 0.26001903f, 
    -0.01146915f, 0.23441820f, 0.03570381f, 0.18326825f, 0.02212253f, -0.16499892f, 0.21496943f, 0.06109160f, 
    0.34687001f, -0.45957929f, -0.13565533f, -0.17089950f, -0.09450428f, -0.03474012f, 0.28752589f, -0.24217387f, 
    0.02180636f, 0.01446800f, -0.01685094f, 0.06355267f, 0.01305717f, 0.12107207f, 0.09695779f, 0.08999727f, 
    0.09299288f, 0.02221719f, 0.03556107f, 0.25033140f, 0.12766953f, 0.22213045f, 0.15077929f, 0.06857353f, 
    -0.29740560f, -0.17747721f, 0.02259237f, -0.31082883f, -0.22578324f, -0.30212510f, 0.02432959f, -0.26286751f, 
    -0.04914597f, -0.17659491f, -0.19851847f, -0.09897558f, 0.13113807f, -0.09519996f, -0.19014969f, -0.19232614f, 
    -0.12182471f, -0.09082037f, 0.01599015f, 0.00654371f, -0.03667640f, -0.07594147f, -0.14220534f, -0.13451245f, 
    0.26037103f, 0.05986250f, 0.08859463f, -0.03070484f, 0.01004926f, -0.07282422f, 0.03003945f, -0.03565846f, 
    0.06100262f, -0.01105027f, 0.38767341f, 0.37720969f, 0.26470008f, 0.07668050f, -0.09858584f, -0.08779254f, 
    -0.08757816f, -0.21620372f, 0.15067053f, -0.10021976f, 0.07276245f, 0.01469055f, -0.04352681f, -0.10245857f, 
    -0.01359729f, -0.08818137f, 0.24519961f, 0.21609770f, 0.10948862f, -0.00014655f, 0.14766820f, 0.32503545f, 
    -0.05468757f, 0.00972722f, 0.08560785f, 0.08021910f, 0.00443554f, -0.02219445f, 0.20127107f, 0.03395689f, 
    0.08119604f, -0.05548088f, -0.05218664f, -0.00574400f, -0.02643002f, 0.12568040f, -0.10028514f, -0.12109818f, 
    -0.21147293f, 0.29203820f, 0.29444396f, 0.18413521f, -0.10006435f, -0.21436688f, -0.23762798f, -0.02801770f, 
    -0.11350942f, 0.04348980f, 0.12326473f, 0.00216280f, -0.35967317f, 0.16694437f, 0.12380289f, -0.33313888f, 
    -0.09146488f, -0.07697921f, 0.21852006f, -0.10824788f, 0.19100231f, 0.02983091f, 0.18992515f, -0.04197177f, 
    -0.26972249f, -0.09590333f, -0.30825174f, -0.07507998f, 0.00636484f, -0.10610380f, 0.01716329f, -0.18682753f, 
    -0.01849229f, -0.02721244f, -0.01628764f, -0.05998913f, -0.49796158f, -0.09390997f, 0.29333207f, -0.04045274f, 
    -0.04504850f, -0.03167606f, 0.01617345f, 0.05085868f, 0.00388282f, 0.11661904f, -0.10440513f, -0.05991555f, 
    -0.22085007f, -0.19854319f, 0.22346680f, 0.06492168f, 0.04091873f, 0.07503009f, 0.21037588f, 0.36034715f, 
    -0.01317842f, -0.05813589f, -0.02386982f, -0.05584756f, 0.11702230f, 0.04928396f, -0.05689240f, 0.13351007f, 
    0.11855480f, 0.18625815f, 0.18341222f, -0.13261274f, 0.19586369f, -0.11683019f, 0.15412904f, 0.06657394f, 
    0.17775969f, -0.04156731f, -0.11104179f, -0.08087379f, -0.15496001f, 0.05547931f, 0.01321121f, -0.02353939f, 
    0.05462000f, -0.00720685f, -0.08374503f, -0.18959194f, -0.16986276f, 0.11312220f, 0.27123180f, -0.23586370f, 
    -0.10498830f, -0.00790125f, 0.19417243f, 0.18728265f, 0.19585146f, 0.21640208f, -0.10113209f, -0.00476203f, 
    -0.29540035f, -0.47905758f, 0.14051773f, 0.10623506f, 0.21268480f, 0.25214618f, 0.08310483f, 0.17787908f, 
    0.11168499f, 0.02831182f, 0.00777311f, -0.07448489f, 0.32251403f, 0.16177067f, 0.09329126f, 0.18579343f, 
    -0.12616326f, -0.06673116f, -0.05024337f, -0.06622208f, 0.20123035f, 0.08623291f, 0.16986766f, -0.05620763f, 
    0.13805643f, -0.08102534f, -0.13860096f, 0.03171846f, -0.03936090f, 0.08727088f, 0.06458395f, 0.04573233f, 
    0.04386690f, -0.07245237f, -0.04136018f, -0.13241902f, 0.54028976f, -0.06920258f, 0.34573016f, -0.04840893f, 
    -0.02932784f, -0.00278818f, -0.08433365f, 0.09042612f, 0.01181871f, 0.28824303f, 0.17943099f, 0.32395509f, 
    0.15804228f, 0.30454084f, 0.09316592f, -0.21893926f, 0.17951983f, -0.04225004f, 0.23170668f, 0.10288712f, 
    0.11993271f, 0.00220572f, -0.21775253f, -0.03719759f, -0.22622849f, -0.42796606f, -0.07155219f, 0.27615985f, 
    0.18033387f, 0.14760180f, -0.06701218f, 0.26195958f, 0.08938000f, 0.02623465f, 0.27357155f, -0.07400180f, 
    0.10617398f, 0.15043199f, 0.03776832f, 0.05552307f, -0.10421664f, 0.02308977f, -0.09663089f, -0.03696840f, 
    -0.03424843f, -0.00660964f, 0.39032039f, 0.17047997f, -0.12468081f, -0.15052637f, -0.15399638f, -0.14343730f, 
    -0.03232080f, 0.12040471f, -0.08488025f, 0.02413879f, 0.02544693f, 0.02983299f, 0.12201820f, -0.11510988f, 
    -0.41399324f, -0.20377050f, 0.14430176f, -0.14546937f, 0.02941490f, -0.02399084f, 0.22737813f, 0.12407488f, 
    0.02895419f, 0.10768718f, 0.02811378f, 0.06492797f, -0.43666381f, -0.38749170f, -0.08992957f, -0.07625845f, 
    -0.12415373f, -0.17298825f, -0.17945699f, -0.15143657f, -0.14649923f, 0.01372363f, 0.04015383f, -0.18802157f, 
    -0.47403064f, 0.06172086f, 0.18397218f, -0.09726388f, -0.03217857f, -0.02578732f, 0.14458017f, 0.08949628f, 
    0.09315620f, 0.22199103f, 0.00480102f, 0.05605138f, -0.22761585f, -0.29449758f, -0.11029879f, 0.03069109f, 
    0.10893395f, -0.13938126f, 0.01300611f, 0.02126536f, -0.04363411f, -0.06376924f, 0.06090946f, -0.06271803f, 
    -0.13675399f, -0.09302673f, -0.01330958f, 0.02234020f, 0.07670041f, 0.23983389f, 0.15687996f, 0.06983826f, 
    0.27238885f, 0.11917205f, 0.37085938f, -0.07348797f, 0.21280111f, 0.05536649f, -0.09626880f, -0.05179504f, 
    -0.06689381f, -0.01803159f, 0.00558966f, -0.08340726f, 0.09493845f, 0.04785414f, -0.02809875f, -0.07979968f, 
    0.20719437f, 0.14335725f, 0.11321623f, 0.14707054f, 0.22134157f, 0.12371768f, -0.03217285f, -0.14529620f, 
    0.24007621f, -0.00452566f, 0.01186079f, 0.18983077f, -0.08467428f, -0.01054337f, 0.20224972f, -0.05114545f, 
    -0.25255108f, -0.08775510f, 0.15388799f, 0.14859487f, 0.11774728f, 0.01087792f, -0.10145351f, -0.08168288f, 
    0.13638155f, 0.26743659f, -0.04540277f, -0.10735842f, -0.00121960f, -0.03164706f, 0.03374573f, 0.33873603f, 
    -0.02649586f, 0.02882604f, 0.09666152f, 0.00311501f, 0.01834323f, 0.10658034f, 0.08609291f, -0.01528699f, 
    0.02500302f, 0.04587956f, -0.05012881f, -0.13539912f, 0.03846449f, 0.03149942f, -0.00111236f, 0.36071023f, 
    0.58646542f, 0.50062674f, 0.43128130f, 0.42207721f, 0.07272576f, 0.03258377f, 0.08578950f, 0.30150104f, 
    -0.04368406f, -0.04638253f, 0.00069643f, -0.10781451f, -0.11533932f, -0.07892407f, 0.05329417f, -0.01200190f, 
    0.00417088f, -0.08375444f, 0.04888807f, 0.15469851f, -0.00587415f, -0.12036590f, -0.01162824f, -0.08756133f, 
    -0.21684271f, -0.32133460f, -0.31586203f, -0.03444905f, 0.00275124f, -0.01954743f, -0.14870085f, 0.01392912f, 
    -0.18669806f, 0.19808032f, -0.02578981f, 0.30303350f, -0.01532967f, -0.17066380f, 0.06207778f, 0.02139060f, 
    0.01724272f, 0.14863010f, -0.05678856f, 0.03983384f, 0.10411440f, 0.09555576f, 0.02893262f, -0.09860549f, 
    -0.11841003f, -0.06840090f, -0.08431095f, -0.28623903f, -0.12354873f, -0.02392273f, -0.04778355f, -0.26740903f, 
    -0.11664780f, -0.13506581f, -0.06734125f, -0.16859309f, -0.21576597f, -0.15181814f, -0.09883121f, -0.09884033f, 
    0.07530529f, 0.09589145f, 0.08629632f, 0.09766929f, -0.09229948f, -0.06490082f, -0.02946990f, -0.08690141f, 
    0.12995747f, 0.22714707f, 0.08518349f, 0.05542983f, 0.10084821f, 0.00035706f, 0.12222145f, -0.00974173f, 
    -0.01962573f, 0.10800878f, -0.01836246f, 0.01024583f, 0.30610806f, 0.11661661f, 0.24590646f, -0.13325131f, 
    -0.03777658f, -0.17578559f, -0.00536570f, -0.10341299f, -0.18216015f, -0.10945311f, -0.01639399f, 0.07241799f, 
    0.23700543f, 0.43312031f, 0.32490245f, 0.11780117f, 0.00612755f, 0.07434300f, 0.09256237f, -0.04973514f, 
    0.09644268f, 0.05176549f, 0.00263285f, -0.13205954f, 0.32873005f, 0.42175019f, 0.20154843f, 0.19610776f, 
    0.12886839f, 0.07933347f, -0.02560573f, 0.17494763f, -0.06416510f, -0.11998226f, -0.01740896f, -0.05785537f, 
    -0.25269127f, 0.20797785f, -0.16233082f, -0.16930287f, -0.16717941f, -0.00502339f, -0.02812361f, -0.16393040f, 
    -0.08993665f, -0.01749598f, -0.14577810f, -0.13417806f, -0.21126913f, -0.20989442f, -0.14079532f, 0.03578915f, 
    0.01045893f, -0.07181856f, -0.10051228f, -0.06123812f, -0.10588939f, 0.08019178f, -0.14386323f, -0.01689941f, 
    -0.43738866f, -0.39242801f, -0.13802810f, 0.03580455f, 0.06747697f, 0.03967827f, 0.08832125f, -0.01035067f, 
    0.06085216f, 0.11485396f, 0.12429820f, 0.20552425f, 0.34597927f, 0.12027416f, 0.00025359f, 0.20467702f, 
    0.18068658f, 0.09866090f, -0.10336895f, -0.10561098f, 0.03895019f, -0.06230626f, 0.12501624f, 0.13383171f, 
    0.31738734f, 0.51703209f, 0.11090351f, 0.07318412f, 0.07795849f, 0.16463512f, 0.09939238f, 0.32601979f, 
    -0.04315631f, -0.00588018f, 0.03989459f, -0.10161105f, -0.22329770f, -0.40773609f, -0.21126848f, -0.28392532f, 
    0.03154272f, 0.00993393f, -0.00840598f, 0.07522123f, 0.11388537f, -0.00851760f, -0.13639335f, -0.03160803f, 
    -0.43293029f, -0.24886672f, -0.07201548f, -0.04030851f, 0.05003928f, -0.11866970f, -0.06699517f, -0.00507374f, 
    0.07643171f, -0.01435941f, 0.09637941f, 0.16457082f, 0.27206478f, -0.09518017f, -0.28069201f, -0.24213433f, 
    -0.02465489f, -0.03096454f, -0.03321970f, -0.01225528f, -0.21363068f, -0.21596868f, -0.21469752f, -0.11583225f, 
    0.33721682f, 0.12758094f, 0.13055541f, -0.03606383f, 0.02035217f, 0.04367443f, -0.08158928f, -0.20858635f, 
    0.07465213f, 0.05551358f, 0.08503766f, -0.00543457f, 0.20371257f, 0.14126754f, 0.45805860f, -0.04275392f, 
    0.09011502f, 0.18647011f, 0.17362303f, -0.01514520f, 0.02366364f, -0.08958200f, -0.22353044f, -0.17593683f, 
    0.00528401f, 0.11715563f, -0.08661916f, 0.17402476f, 0.03976810f, -0.12674665f, -0.04289653f, 0.07994343f, 
    0.08146538f, -0.05480665f, 0.10199431f, 0.21060443f, 0.28728658f, 0.41498166f, 0.29992121f, 0.24164544f, 
    0.09813441f, 0.05459657f, 0.07167072f, 0.05603083f, -0.09158795f, -0.10218515f, 0.00873498f, 0.11889707f, 
    0.18109466f, 0.37349144f, 0.29674125f, 0.09204722f, 0.03736185f, 0.17068666f, 0.10908687f, 0.14453031f, 
    0.05223066f, 0.06625375f, -0.06023149f, 0.01668398f, 0.50364751f, 0.52097851f, 0.28098658f, 0.35044241f, 
    0.03507790f, 0.09217457f, 0.13765296f, 0.19654962f, 0.03944146f, -0.03000591f, -0.03490987f, -0.11498159f, 
    0.12378157f, 0.27122915f, 0.25972480f, 0.03764300f, 0.00961701f, -0.20640962f, -0.02248077f, -0.19579205f, 
    0.02386508f, 0.02557797f, 0.06895286f, 0.31116572f, 0.33015987f, 0.34498522f, 0.40020663f, 0.17652099f, 
    0.06544363f, 0.18426935f, 0.06230578f, -0.21316120f, -0.05174757f, -0.04791110f, -0.07257434f, -0.25420821f, 
    0.03650615f, 0.17251892f, 0.15533850f, 0.15213300f, -0.01370538f, -0.04763970f, -0.04567738f, -0.15650018f, 
    -0.01149152f, -0.05574786f, -0.01880581f, 0.18515319f, -0.40220603f, -0.43738776f, -0.13143773f, -0.01147877f, 
    0.08003208f, 0.08679370f, -0.03262855f, 0.08698758f, 0.17628369f, 0.04232647f, 0.00702645f, 0.24351072f, 
    0.03689280f, 0.00617900f, 0.03443227f, -0.02784639f, -0.01909814f, -0.02457855f, -0.02198432f, -0.01477005f, 
    0.01641531f, -0.03586083f, -0.05120005f, -0.00439750f, 0.04200955f, -0.01676201f, -0.04218847f, 0.01898748f, 
    -0.03299180f, 0.01383388f, -0.01884547f, -0.04833571f, -0.02593081f, 0.03972590f, 0.03357169f, 0.02492155f, 
    0.01770421f, 0.01847314f, 0.00998210f, 0.02490633f, -0.00451102f, 0.01070017f, 0.02717025f, -0.03644723f, 
    0.04733334f, -0.04279738f, 0.01046665f, -0.04966726f, -0.03130871f, -0.05449228f, -0.02003174f, 0.00771372f, 
    -0.01415554f, -0.02368966f, -0.02229955f, 0.02267594f, 0.00662230f, -0.00793370f, -0.01996026f, 0.03765641f, 
    0.01255476f, -0.04882130f, 0.00604800f, -0.03550667f, -0.04801072f, -0.01119420f, 0.03871559f, -0.04699679f, 
    0.01744649f, -0.02914467f, 0.00186406f, -0.00263329f, 0.01729712f, -0.04881822f, 0.04188032f, -0.02075806f, 
    -0.01050458f, 0.04182468f, 0.02439766f, -0.03602010f, 0.00226980f, -0.04382706f, 0.02531754f, 0.04134441f, 
    0.02822104f, -0.01234361f, -0.04678632f, 0.04162420f, -0.03112576f, -0.00443634f, -0.05776387f, 0.03058470f, 
    0.01553481f, -0.02978711f, 0.02875625f, 0.03713913f, -0.04074177f, -0.05851494f, -0.05649408f, -0.04301191f, 
    0.00661389f, -0.03627057f, -0.03030325f, -0.02881845f, -0.02806034f, 0.03980732f, 0.01764823f, -0.03648913f, 
    -0.01762986f, 0.04075471f, 0.00296705f, -0.05521931f, -0.03672185f, -0.02019180f, 0.00354042f, -0.02336379f, 
    -0.04275465f, -0.04729174f, -0.00919022f, 0.00912878f, -0.02978306f, -0.00394515f, -0.00754264f, 0.04179814f, 
    -0.00359018f, -0.05191743f, 0.04332542f, -0.02505062f, -0.03075526f, -0.04293133f, 0.01563243f, 0.01395809f, 
    -0.00946578f, -0.03422494f, 0.02857544f, 0.04328289f, -0.04240882f, -0.05351904f, -0.02572752f, -0.02525308f, 
    -0.00705371f, -0.02054914f, -0.01764214f, 0.04122438f, -0.00990931f, -0.04364393f, 0.04431850f, -0.04574499f, 
    0.04133284f, 0.03083936f, 0.00328756f, 0.00468281f, 0.01232290f, -0.01599732f, 0.03145868f, 0.00533870f, 
    -0.05263092f, -0.03689398f, 0.02109614f, -0.02792650f, -0.03366668f, 0.00006184f, 0.03936575f, -0.05592962f, 
    0.02709428f, -0.02973415f, 0.05044385f, 0.01281781f, -0.03398871f, -0.00967725f, 0.00074639f, -0.00795999f, 
    0.03737980f, -0.04744987f, -0.02712021f, 0.04136655f, 0.03431730f, -0.00389585f, 0.03769266f, -0.01173467f, 
    -0.02277777f, -0.05639308f, -0.02795033f, 0.00635206f, -0.00750554f, 0.00587777f, -0.00286938f, 0.04424914f, 
    0.01668806f, -0.00826330f, -0.00435184f, -0.01871864f, 0.00512235f, -0.04431695f, 0.00647659f, 0.03710416f, 
    -0.04599161f, 0.03342449f, 0.03667721f, -0.05490471f, -0.01071164f, 0.02705914f, 0.00683327f, -0.04016350f, 
    -0.02393354f, -0.03282331f, 0.03788618f, 0.03459089f, -0.02365523f, 0.00036740f, 0.00425035f, -0.05274736f, 
    -0.04880539f, -0.00206618f, 0.02918130f, -0.02423713f, -0.02518007f, 0.00122671f, -0.02413459f, 0.02204252f, 
    -0.05566042f, -0.04244820f, 0.01289552f, -0.02205160f, -0.00497284f, -0.03037151f, -0.00547758f, -0.04110854f, 
    -0.02702782f, 0.03780210f, -0.02926672f, 0.00603585f, -0.00528107f, -0.04681794f, -0.00681115f, -0.02774371f, 
    -0.00966736f, -0.05437923f, -0.03405144f, 0.03816824f, -0.01065723f, 0.00647860f, 0.02228105f, 0.04281978f, 
    0.03955102f, -0.03128296f, -0.04178863f, 0.02437349f, -0.00481131f, 0.02351945f, -0.04629657f, 0.02193398f, 
    0.03460798f, -0.02851479f, 0.01538687f, 0.04062415f, 0.04133495f, -0.04138932f, -0.01099688f, 0.01846925f, 
    -0.05005991f, -0.01862207f, 0.03521903f, -0.03902870f, 0.03411589f, -0.00675971f, 0.00241885f, -0.00158362f, 
    0.01480226f, 0.04395878f, -0.03274594f, 0.01939596f, 0.04358064f, -0.03760269f, -0.04590325f, 0.01193319f, 
    -0.02448288f, -0.01313836f, 0.04224411f, -0.00930710f, -0.01624309f, -0.04503942f, -0.05219509f, 0.02754886f, 
    -0.05377383f, -0.04497418f, 0.02228423f, -0.02118789f, 0.02900494f, 0.04206550f, -0.02066028f, -0.00393249f, 
    -0.01508453f, -0.04029125f, 0.02642509f, -0.02667586f, -0.00016897f, -0.03451293f, 0.03265965f, 0.00367365f, 
    0.03517850f, -0.04310772f, -0.02556079f, -0.00747567f, -0.04628935f, 0.04272569f, 0.04095279f, -0.04304143f, 
    -0.04189259f, 0.02257294f, 0.02584243f, 0.02091493f, 0.01138445f, -0.05268253f, -0.01207584f, -0.04154448f, 
    -0.04560178f, 0.00993730f, 0.04213754f, -0.03625582f, 0.03628652f, 0.01016511f, -0.03915977f, -0.03540559f, 
    -0.01913724f, -0.02735276f, -0.01696217f, -0.03560283f, 0.02132277f, 0.00829486f, -0.00091672f, -0.04614048f, 
    -0.01590231f, -0.02965134f, -0.03711259f, -0.02764430f, -0.05417736f, 0.03256333f, 0.02611991f, -0.00692416f, 
    -0.05119333f, -0.02208607f, -0.02427717f, 0.00786585f, -0.02837176f, 0.01513196f, -0.00476171f, -0.04599090f, 
    -0.01984999f, 0.04139819f, 0.01377175f, 0.00941408f, -0.04871468f, 0.04252033f, 0.03426647f, 0.04768686f, 
    0.02252509f, -0.01100529f, 0.03573170f, -0.03609187f, -0.02092167f, -0.01728171f, 0.03703984f, 0.00995681f, 
    0.01638138f, 0.03600566f, 0.04438202f, -0.04804229f, 0.00268874f, -0.01008074f, -0.01907173f, 0.00232199f, 
    -0.04956330f, 0.00261416f, -0.03979916f, 0.03191501f, -0.04455324f, -0.00383329f, -0.01347574f, -0.01059623f, 
    0.03580287f, 0.04355288f, -0.02187396f, -0.05120251f, -0.01069554f, -0.00557882f, 0.00740527f, -0.05360049f, 
    -0.01715637f, 0.03532188f, 0.00131384f, 0.03364833f, -0.00057227f, -0.05296649f, 0.03018857f, 0.03269477f, 
    -0.02660919f, 0.02036000f, 0.00957685f, 0.01632558f, -0.01252794f, -0.05043303f, -0.00063786f, -0.03789474f, 
    -0.02015980f, 0.04681447f, -0.00218911f, -0.03811948f, 0.02207231f, 0.00172654f, -0.00174500f, 0.03085036f, 
    0.03272403f, -0.04695075f, -0.03087862f, -0.02628215f, -0.04464914f, 0.01929582f, 0.00949758f, 0.04294150f, 
    0.04544047f, 0.02092360f, 0.00475267f, -0.02205213f, 0.00888650f, 0.01568064f, -0.02008830f, -0.01048383f, 
    0.04233849f, 0.01034494f, -0.03991023f, 0.01305581f, -0.01550233f, -0.00293842f, -0.05625504f, -0.03205533f, 
    -0.05086290f, -0.03785123f, -0.02022938f, -0.01884950f, 0.03823735f, 0.00180960f, -0.04173203f, -0.01370037f, 
    -0.00829441f, 0.00062681f, -0.05439597f, -0.01059143f, -0.04880060f, 0.04051136f, -0.04598372f, -0.01333379f, 
    0.03807513f, 0.02258447f, -0.03978547f, 0.01030805f, 0.00209446f, 0.03065482f, 0.03584759f, -0.01905942f, 
    0.00401913f, 0.02644562f, -0.00496163f, -0.04469265f, 0.03239900f, -0.03300463f, -0.04039459f, -0.00668965f, 
    -0.04954076f, 0.01172072f, -0.02780874f, 0.04470316f, -0.05627692f, 0.02718064f, 0.01796059f, 0.02987350f, 
    -0.00331182f, -0.04863184f, 0.01236050f, 0.00823486f, 0.04311369f, 0.02468090f, -0.05401959f, -0.02089486f, 
    0.00545514f, -0.05193977f, -0.05116369f, -0.01123050f, -0.00749410f, 0.00785086f, -0.04282849f, 0.03888683f, 
    0.01023931f, 0.02616298f, -0.05633671f, 0.02003639f, -0.00505075f, -0.03228381f, -0.01803943f, -0.00092203f, 
    0.01238567f, -0.00040718f, -0.03268551f, 0.02725992f, -0.00186963f, -0.03930875f, -0.03213759f, -0.03672317f, 
    -0.03572586f, -0.04096253f, -0.03516154f, 0.01667685f, -0.02345008f, 0.02635293f, 0.03049194f, -0.03359246f, 
    -0.05184518f, -0.04300994f, 0.01759066f, -0.04599423f, -0.03621341f, -0.02127249f, -0.03129494f, 0.00362590f, 
    -0.02207916f, -0.00359420f, -0.01142294f, 0.02825645f, -0.02837430f, -0.00501680f, 0.02201828f, -0.03594640f, 
    -0.03742572f, 0.00284084f, -0.03051518f, -0.02841340f, 0.04284769f, -0.04833987f, -0.04772649f, 0.00141006f, 
    -0.05127519f, -0.04638616f, -0.05130446f, 0.03721885f, -0.01276698f, -0.03374366f, -0.00706956f, 0.01104915f, 
    0.00136912f, -0.02061973f, -0.03666309f, 0.02902801f, 0.04136559f, 0.00491697f, -0.04866074f, 0.04217715f, 
    -0.03840650f, -0.01469069f, 0.01409634f, 0.01810120f, 0.01096510f, 0.01124356f, -0.02619589f, -0.05466663f, 
    0.02756743f, 0.02206679f, -0.02008373f, -0.04039869f, 0.02454021f, -0.03959757f, 0.03187572f, -0.01803635f, 
    0.00369133f, -0.01148750f, 0.03403299f, -0.00093065f, 0.04030650f, -0.04706938f, 0.02205386f, -0.00113426f, 
    -0.00093686f, -0.03890097f, -0.03645425f, -0.01494446f, -0.05123142f, -0.04685167f, 0.03072710f, -0.03097564f, 
    0.02102924f, -0.02207733f, -0.02131750f, -0.05475972f, 0.02557690f, 0.01769564f, -0.02534318f, 0.00052584f, 
    0.00124215f, 0.04125743f, 0.01745857f, 0.01593539f, 0.00485300f, -0.03590760f, 0.01946357f, -0.05203185f, 
    0.00195522f, -0.04035658f, 0.02389090f, -0.00324984f, -0.00703437f, 0.00403260f, -0.01270838f, 0.03900864f, 
    0.04899945f, 0.02987036f, -0.01176459f, -0.02218404f, 0.01125503f, 0.00730658f, 0.01476842f, 0.00659685f, 
    0.02369332f, 0.01829743f, 0.04468735f, -0.00347714f, 0.03189849f, 0.01525570f, -0.04863738f, 0.00710541f, 
    0.00584641f, 0.02671617f, 0.03199499f, -0.02836294f, 0.02032423f, 0.02006072f, -0.03118015f, -0.04740877f, 
    -0.04201930f, 0.03491826f, -0.00649165f, 0.00248803f, 0.01230666f, -0.02422126f, 0.03123482f, 0.01247570f, 
    -0.01337189f, 0.01185819f, 0.02952709f, 0.01225750f, 0.02247892f, 0.00887602f, -0.01865263f, 0.01183065f, 
    -0.03180229f, 0.01618017f, -0.04418808f, -0.05365787f, -0.05022959f, 0.02638810f, -0.02755930f, -0.04459538f, 
    0.01500066f, 0.03604074f, -0.02487854f, 0.02043138f, 0.00298544f, -0.03261063f, -0.00522405f, 0.01203029f, 
    -0.01209820f, 0.01601423f, -0.05466340f, 0.01885594f, 0.01005521f, -0.05198057f, 0.02495693f, -0.03462933f, 
    -0.04787852f, -0.01600094f, 0.03788557f, -0.00452343f, 0.00133551f, 0.01169218f, 0.01708900f, 0.02229794f, 
    0.01500405f, -0.04777839f, 0.03094269f, -0.04497893f, -0.00297457f, 0.02735658f, -0.00166953f, -0.00132257f, 
    0.02024732f, 0.00257958f, -0.01681940f, 0.03847450f, 0.04243801f, -0.03137822f, -0.02368972f, -0.04369379f, 
    0.01023200f, -0.04152717f, -0.05337694f, 0.00280293f, -0.00876104f, -0.01438049f, -0.03000618f, -0.04588050f, 
    -0.04554117f, -0.02496072f, 0.04610092f, -0.03086115f, -0.00820081f, -0.03860544f, -0.04775462f, -0.05031802f, 
    0.02701516f, -0.04202020f, 0.04070565f, 0.02312986f, -0.02192204f, 0.00859080f, 0.04353154f, 0.00806260f, 
    0.03262837f, -0.03679628f, 0.01120201f, -0.01786160f, 0.04200457f, -0.02921648f, -0.03722132f, -0.01158787f, 
    0.00592903f, -0.01739371f, -0.00512750f, 0.03452055f, -0.01347677f, -0.05052887f, -0.01401859f, 0.03276274f, 
    0.00824440f, -0.02917531f, -0.01860318f, 0.02048792f, -0.03308532f, -0.00301570f, -0.03303966f, -0.00322795f, 
    -0.03733065f, -0.01471351f, 0.00168383f, 0.04325815f, -0.02485036f, -0.00129641f, -0.02871815f, 0.00602170f, 
    -0.00924536f, 0.03153409f, -0.01400827f, 0.03303742f, 0.02615187f, -0.01740562f, 0.02328621f, -0.01432534f, 
    -0.01274556f, -0.04750548f, 0.02124698f, -0.02276252f, 0.03871836f, -0.03502592f, -0.05109069f, -0.04653946f, 
    -0.01082322f, -0.05308053f, -0.02001373f, -0.04881684f, -0.03484516f, 0.01130752f, -0.04503773f, 0.01619348f, 
    -0.27064121f, -0.04982641f, 0.05198856f, -0.18219313f, -0.02424743f, 0.27847800f, 0.15632907f, 0.04945407f, 
    -0.01281018f, -0.20277420f, -0.01042051f, 0.11332621f, -0.11478328f, 0.21431233f, 0.09931788f, -0.06473535f, 
    0.24339487f, 0.12562083f, -0.13331406f, 0.14892934f, 0.11401296f, 0.08827846f, -0.00866095f, 0.05032560f, 
    -0.09321775f, -0.10859608f, 0.41176054f, 0.02457285f, 0.02806918f, 0.12088346f, -0.04213442f, -0.01473495f, 
    -0.01207955f, -0.12287185f, 0.04811584f, 0.09556495f, 0.00025731f, -0.02982241f, -0.22561842f, 0.08379330f, 
    0.02308307f, 0.05964310f, 0.34625825f, 0.08155819f, -0.04102151f, 0.07964778f, 0.20673656f, 0.02854840f, 
    -0.29157263f, -0.19189027f, -0.08359245f, 0.14981753f, 0.24382672f, -0.04068665f, -0.05124956f, -0.33792642f, 
    -0.03070001f, -0.03688898f, -0.01309696f, -0.03340685f, 0.08553834f, 0.03526529f, -0.22926266f, -0.06154928f, 
    0.02829230f, -0.06670175f, -0.14476953f, 0.09644619f, -0.03142400f, 0.07190915f, 0.02479779f, -0.11338878f, 
    0.01547785f, 0.17976800f, 0.05597037f, -0.00853244f, 0.00018853f, -0.01317727f, -0.10631155f, -0.00858784f, 
    0.10565894f, -0.01472384f, 0.21589278f, -0.17407644f, 0.12350435f, -0.10479087f, 0.03745944f, -0.00951197f, 
    0.01737835f, -0.00553174f, 0.16898178f, -0.03702124f, -0.22311303f, 0.05497488f, -0.20063163f, 0.29975009f, 
    -0.10378237f, 0.09633898f, -0.12789766f, 0.17694010f, 0.15874742f, -0.11276589f, 0.02502028f, 0.09398100f, 
    0.34911054f, 0.15273182f, -0.02805297f, -0.10013980f, -0.09102508f, 0.01422826f, -0.03942924f, -0.27120873f, 
    0.11625660f, -0.12334937f, 0.07605655f, 0.03398012f, 0.03444601f, 0.11223991f, 0.02541977f, 0.06592846f, 
    -0.33267280f, -0.06695437f, -0.00290690f, 0.16618717f, -0.00718638f, 0.15007487f, 0.10085029f, 0.08623434f, 
    -0.09597882f, 0.08102103f, 0.08879370f, 0.02212964f, 0.20961936f, -0.17782138f, -0.34667283f, 0.68506694f, 
    0.34766644f, 0.39016628f, -0.12303666f, 0.17630666f, 0.21576293f, 0.13863002f, -0.01302817f, 0.19371504f, 
    0.15353805f, 0.10947632f, 0.09179051f, -0.16159762f, 0.06147267f, -0.04336110f, -0.08433398f, 0.07694726f, 
    -0.00599425f, -0.00237763f, -0.03634670f, -0.04696484f, -0.15603089f, 0.04073501f, -0.09178562f, 0.04739393f, 
    0.02736294f, 0.09923491f, 0.09719017f, -0.05217750f, -0.10223533f, 0.13085479f, -0.21054229f, -0.03980471f, 
    0.30600271f, 0.08894894f, 0.03305710f, -0.15638404f, -0.01843462f, -0.01894731f, -0.13841966f, -0.07349818f, 
    0.14067359f, 0.03043566f, -0.00954016f, 0.12942712f, 0.07160290f, 0.03349730f, 0.10157581f, 0.07808153f, 
    0.01915922f, 0.02657575f, -0.00668496f, 0.18981527f, 0.28313759f, -0.04485118f, 0.21889250f, -0.05136942f, 
    0.15226926f, 0.28376150f, 0.13553867f, -0.03344412f, -0.09044265f, -0.10375659f, -0.11345117f, 0.01773243f, 
    -0.08711438f, -0.09633090f, -0.09061238f, 0.02097066f, -0.11129786f, 0.25644666f, -0.22442611f, 0.08862249f, 
    -0.00398886f, 0.00713627f, 0.37259686f, -0.04957845f, 0.02432277f, 0.08001331f, -0.01743368f, 0.10199783f, 
    -0.23885712f, -0.03973469f, 0.17196156f, 0.12131947f, -0.04163315f, -0.14612077f, 0.01623019f, -0.17593302f, 
    -0.13903531f, -0.16256277f, -0.00794866f, 0.11359783f, -0.04510721f, 0.07924672f, 0.19727184f, 0.17104758f, 
    0.07356655f, -0.01805026f, -0.13906109f, 0.01989858f, 0.00682971f, 0.00684934f, 0.25613353f, 0.24279755f, 
    0.31661195f, 0.14219329f, 0.17485176f, -0.06332241f, -0.00396759f, -0.03109146f, -0.08994678f, 0.07013623f, 
    -0.00097372f, -0.07459103f, -0.00943958f, -0.03317441f, -0.39454409f, 0.53329879f, -0.07068522f, -0.02319572f, 
    0.03922937f, -0.21057901f, 0.06068649f, -0.10415680f, 0.12974216f, 0.11064089f, 0.13250661f, 0.01855054f, 
    -0.00884301f, 0.03180986f, -0.45631281f, 0.10009702f, 0.00010674f, -0.02024757f, 0.05499879f, 0.01588270f, 
    0.14995985f, 0.10417351f, -0.05166212f, 0.01293732f, 0.11583033f, 0.15660331f, 0.01137536f, 0.04216810f, 
    0.01875935f, -0.17309681f, 0.21390453f, 0.13188902f, 0.02731045f, 0.20078513f, 0.08993725f, 0.07926181f, 
    -0.05964997f, -0.06068332f, -0.13664651f, 0.02632962f, 0.06357922f, 0.11405118f, 0.00661615f, -0.01188511f, 
    0.14696102f, 0.03429791f, 0.22513896f, 0.01510733f, -0.08094355f, -0.35463667f, 0.27459401f, 0.03048408f, 
    0.00098409f, 0.00328713f, -0.09015330f, -0.06167032f, -0.00960381f, 0.01122512f, 0.06122649f, 0.11003119f, 
    -0.09559466f, 0.20468482f, -0.19643098f, 0.12875007f, 0.06476852f, -0.04939152f, 0.14992356f, 0.00895343f, 
    0.05451549f, 0.00738202f, 0.05523896f, 0.16832514f, -0.08084474f, -0.20418856f, 0.08664145f, -0.07357657f, 
    0.15346837f, -0.02737410f, -0.07479557f, -0.20490371f, -0.03238474f, -0.03089195f, -0.02826336f, 0.05352819f, 
    0.27069774f, -0.00626740f, -0.11652075f, 0.00184079f, -0.04453148f, 0.13346964f, -0.07830088f, 0.09845737f, 
    0.00196992f, -0.00974195f, 0.17799622f, -0.07064677f, -0.03556215f, -0.16326879f, -0.28818926f, -0.31477830f, 
    0.07243072f, -0.07599181f, 0.06606172f, 0.05490003f, 0.03000985f, 0.12137201f, 0.03367870f, 0.27354825f, 
    -0.01384075f, 0.02163900f, -0.22066008f, 0.10378906f, 0.19668941f, -0.11536070f, 0.18671948f, 0.03067783f, 
    -0.00469910f, 0.17306842f, 0.21425995f, 0.05061556f, 0.25283459f, 0.15732417f, 0.13178368f, -0.07490422f, 
    -0.04833542f, -0.10523500f, -0.01475707f, -0.02433396f, -0.18375997f, -0.11271840f, 0.02561962f, -0.02285020f, 
    -0.00905800f, 0.01402312f, -0.08263022f, -0.01011548f, -0.04712490f, -0.07885240f, 0.00735082f, -0.05506671f, 
    -0.02094000f, -0.04862351f, -0.03788834f, -0.06578547f, -0.06276280f, -0.03745255f, -0.01949385f, 0.02197147f, 
    0.02105645f, 0.00161965f, -0.02351581f, -0.08867360f, -0.03364595f, -0.05347881f, -0.03181470f, -0.02187236f, 
    -0.02472786f, 0.03814787f, -0.03176416f, 0.01645453f, 0.00811615f, -0.04870439f, 0.03285903f, -0.05283625f, 
    0.01624710f, -0.03311347f, 0.01991335f, -0.03618059f, 0.00880931f, -0.03735928f, -0.02276090f, 0.00376927f, 
    -0.04021529f, -0.05442785f, -0.02251694f, 0.00812272f, -0.01521661f, -0.02875031f, -0.05361471f, -0.05784700f, 
    0.03328704f, 0.01019133f, -0.03529470f, -0.04042267f, -0.01475260f, 0.00403885f, -0.00620345f, -0.02546007f, 
    -0.04067539f, -0.05470296f, 0.00620765f, -0.00500142f, -0.08661305f, -0.03600857f, 0.00753552f, -0.02403463f, 
    -0.02811346f, -0.05985531f, -0.00533432f, -0.03403501f, 0.00628198f, -0.02845745f, -0.07790548f, -0.04083198f, 
    -0.07130259f, 0.00847297f, 0.01130394f, 0.00503672f, 0.00996000f, 0.00841449f, -0.07125832f, 0.01141633f, 
    0.00858592f, -0.04142052f, 0.03890486f, -0.05932276f, -0.06686914f, 0.02555873f, 0.01548383f, -0.05044634f, 
    -0.02350025f, -0.06770959f, -0.03899528f, -0.06055413f, 0.00503752f, -0.00913121f, -0.01161378f, 0.01211889f, 
    -0.01849434f, -0.03512582f, -0.05280790f, -0.02074674f, -0.06881537f, 0.00637710f, -0.07071413f, -0.01729183f, 
    -0.04370607f, -0.01737183f, 0.00182821f, -0.08712877f, 0.00183081f, -0.00244719f, -0.05697321f, -0.03583558f, 
    0.00100377f, -0.05377143f, -0.08433869f, -0.03972714f, -0.06623822f, -0.00166621f, -0.05164304f, -0.01177427f, 
    -0.06126516f, -0.00614505f, -0.02136817f, -0.05122437f, -0.02701430f, -0.01606926f, -0.03834292f, -0.07112104f, 
    0.03707980f, -0.00170416f, -0.02223571f, -0.03545724f, -0.06223937f, -0.08029119f, -0.05005993f, -0.00889457f, 
    -0.00756616f, -0.03423446f, -0.05721529f, -0.03342858f, -0.01071311f, -0.07902128f, -0.04427309f, -0.06003456f, 
    -0.01141738f, -0.02220553f, -0.04988259f, -0.05491091f, -0.00493201f, -0.02782193f, -0.03143614f, 0.00073212f, 
    -0.06694281f, -0.06011641f, -0.02189081f, -0.05644855f, -0.06324483f, -0.04817512f, 0.01686409f, -0.00987053f, 
    -0.04415083f, -0.02721890f, -0.01087409f, -0.02422511f, 0.01423475f, -0.06709287f, -0.03168611f, -0.04766904f, 
    -0.06486759f, -0.07683940f, 0.01000684f, -0.05388121f, -0.05463828f, -0.01431651f, -0.07406458f, 0.01752398f, 
    -0.03460582f, -0.06937814f, 0.01030065f, -0.06349096f, -0.05532631f, 0.01298160f, -0.06206279f, 0.00704596f, 
    -0.00554756f, 0.02461769f, 0.01164412f, 0.03745229f, -0.06975274f, -0.06555222f, -0.07366904f, 0.01744086f, 
    -0.08940399f, 0.00536334f, -0.03314076f, -0.07221702f, -0.03401000f, 0.01551371f, -0.04438761f, -0.05058026f, 
    -0.03763050f, -0.05712670f, -0.04441442f, -0.08848519f, -0.05023437f, -0.00299984f, -0.00157738f, -0.03451510f, 
    0.00848133f, -0.07215337f, -0.00601265f, -0.03636551f, -0.07560868f, -0.07302220f, -0.03806960f, -0.01476054f, 
    0.01909280f, -0.00758108f, -0.02905498f, 0.03067828f, -0.00908695f, 0.00513737f, -0.01220465f, -0.01384543f, 
    -0.06175248f, -0.03095808f, 0.01485613f, -0.01486641f, -0.02530936f, -0.03221969f, -0.00170977f, -0.02073172f, 
    -0.06160647f, -0.06617771f, 0.01219924f, -0.04639579f, -0.00807489f, -0.07794924f, 0.02790349f, 0.03712126f, 
    -0.03019411f, 0.02530174f, -0.05250880f, -0.03993596f, 0.00458364f, -0.03414501f, -0.02564637f, -0.04634880f, 
    -0.07581459f, -0.01209029f, -0.05020833f, -0.01850591f, 0.02215903f, 0.01126848f, -0.05766681f, -0.02763328f, 
    -0.08346937f, -0.01394293f, -0.06927851f, 0.01512629f, 0.01126209f, -0.03703474f, -0.07565045f, -0.00841752f, 
    -0.03636785f, -0.00521883f, 0.00682442f, -0.03794309f, -0.02687558f, 0.01201607f, -0.02662902f, -0.00149704f, 
    -0.08172946f, 0.00902875f, -0.03800147f, -0.00112379f, 0.00048675f, -0.01296987f, -0.05891329f, -0.04461089f, 
    -0.08630139f, -0.04594163f, -0.03097384f, -0.01683753f, -0.05129716f, 0.00626061f, -0.04686730f, 0.01070016f, 
    -0.01875661f, -0.02791437f, -0.05602092f, -0.05136538f, -0.03295197f, -0.05618470f, -0.07106588f, -0.01213532f, 
    -0.02065187f, 0.02158235f, -0.05773759f, 0.00080588f, 0.01496990f, 0.01826527f, 0.00400078f, 0.00025482f, 
    -0.07908731f, -0.05235765f, -0.07960738f, -0.06754090f, -0.01779012f, -0.02315059f, -0.02878909f, -0.02357516f, 
    0.01611023f, 0.02049697f, 0.00530036f, -0.02593117f, 0.03770956f, 0.03161856f, -0.02696971f, 0.02827120f, 
    -0.06418851f, -0.05540434f, -0.01333499f, -0.02814083f, 0.04511751f, -0.04296383f, -0.05688467f, 0.02366986f, 
    -0.05900415f, -0.02568312f, 0.03548422f, 0.02095084f, -0.06958563f, 0.00284180f, 0.01606021f, 0.00313914f, 
    0.02051110f, 0.01612090f, 0.01023584f, -0.07273078f, -0.04868563f, -0.05784157f, 0.01101654f, -0.08314490f, 
    0.00112149f, -0.03205498f, -0.05719271f, 0.04262339f, -0.04120909f, 0.03494218f, 0.01341244f, 0.02596894f, 
    -0.03502024f, 0.01961893f, 0.03742225f, 0.00641173f, -0.07357194f, 0.01616407f, -0.03863128f, -0.07819944f, 
    -0.01172676f, -0.05929182f, -0.04609656f, -0.03124940f, -0.04627912f, -0.01911943f, -0.04716717f, -0.06450394f, 
    -0.01717930f, -0.06642667f, 0.01081554f, -0.02170955f, -0.06227841f, -0.04948325f, -0.05706831f, -0.05822380f, 
    -0.06271454f, -0.06413948f, 0.00691118f, -0.00626402f, -0.08421955f, 0.00277460f, -0.01763779f, -0.05925811f, 
    -0.16256537f, 0.01592710f, -0.10024847f, -0.28811693f, -0.01904098f, 0.04895278f, 0.07906327f, 0.06109061f, 
    -0.28731227f, -0.43723914f, -0.28133419f, -0.25947011f, 0.03893193f, 0.02271970f, 0.08112255f, 0.14701453f, 
    0.37827799f, -0.06152472f, 0.17615584f, 0.02148002f, 0.15639241f, 0.06649908f, 0.05225516f, 0.08514844f, 
    0.19254027f, -0.03326158f, -0.11408515f, -0.06778208f, -0.06653212f, 0.20944601f, -0.06503817f, -0.00789890f, 
    -0.11522125f, -0.03695226f, -0.11945710f, -0.07573231f, -0.04807829f, 0.06751274f, 0.07323049f, 0.05887377f, 
    -0.00062744f, -0.08182904f, -0.03462793f, 0.11519875f, 0.03179379f, -0.14307348f, -0.07391842f, -0.37362820f, 
    -0.27395824f, 0.03453811f, 0.14402764f, -0.26552269f, 0.09893864f, 0.03432056f, -0.06018597f, 0.02855841f, 
    -0.00745016f, 0.09597310f, 0.06836890f, 0.03945869f, -0.08456491f, 0.01264842f, -0.16473401f, -0.05472290f, 
    0.12464795f, -0.04637464f, -0.14563169f, -0.12448441f, -0.01429956f, 0.19056161f, 0.05492030f, 0.14241762f, 
    -0.16918908f, -0.05714864f, -0.03019466f, -0.09430568f, -0.05267878f, 0.00971403f, -0.08279642f, -0.05014642f, 
    -0.10809595f, -0.23916204f, -0.18099821f, -0.56263429f, -0.12525901f, -0.05354504f, -0.02494616f, 0.01549086f, 
    0.03536935f, -0.00810038f, 0.07677433f, 0.09332445f, 0.16324559f, 0.03734094f, 0.10373822f, 0.17380376f, 
    0.34484595f, -0.12026782f, 0.05534045f, 0.00185248f, 0.06235606f, 0.17431590f, -0.04115286f, -0.04123117f, 
    0.16906211f, 0.09074621f, 0.08772783f, 0.20142254f, -0.02289988f, -0.07479905f, 0.19544546f, 0.35627672f, 
    -0.24696925f, -0.14969714f, -0.01994831f, -0.05147491f, 0.16098039f, 0.00323116f, 0.23454596f, 0.34465396f, 
    -0.53462791f, -0.15450476f, -0.15890731f, 0.05913399f, -0.08561315f, 0.06805380f, 0.00761100f, 0.05310910f, 
    0.25895911f, 0.11802875f, 0.14198640f, -0.06717888f, -0.56875229f, 0.20132080f, -0.16252810f, 0.24333428f, 
    0.10032320f, 0.14451797f, 0.06308251f, 0.07167877f, 0.01952039f, 0.22009300f, -0.02466444f, 0.10889685f, 
    0.06077649f, 0.00722428f, 0.10875526f, 0.15542711f, 0.27611405f, 0.11389094f, 0.08861363f, 0.13626347f, 
    -0.05989376f, -0.02264317f, 0.07971860f, 0.03923972f, 0.04478888f, -0.07102309f, 0.08787994f, -0.00627184f, 
    0.00266293f, 0.23093751f, -0.02425085f, 0.05678296f, 0.01445477f, -0.11674148f, 0.00840612f, 0.14169084f, 
    0.36371690f, -0.15063456f, 0.17486086f, 0.01448750f, 0.33748055f, 0.21047348f, -0.00589433f, 0.05832948f, 
    0.15478867f, -0.00351220f, 0.07854851f, 0.29027694f, -0.07409223f, 0.05339915f, 0.03720751f, -0.03514277f, 
    0.06892995f, -0.03123013f, 0.21474969f, 0.14610666f, 0.25184831f, 0.17731863f, 0.13113618f, -0.10048633f, 
    0.03156401f, 0.11724268f, -0.00581673f, -0.02192019f, -0.01091739f, -0.02909729f, -0.09085657f, -0.03163461f, 
    0.02497558f, -0.06351984f, -0.00949715f, 0.02689805f, -0.05376188f, -0.09879452f, -0.19968277f, -0.15131529f, 
    0.06725256f, 0.08944532f, 0.00260925f, 0.14488237f, -0.03772446f, -0.11589479f, -0.03503033f, -0.04133298f, 
    -0.04891504f, -0.03560238f, 0.21113165f, -0.00118300f, -0.01118181f, -0.03208005f, -0.02607542f, -0.12073810f, 
    0.10086496f, -0.06055309f, 0.15487538f, 0.02226471f, 0.12323026f, 0.28128994f, -0.08882476f, 0.08256273f, 
    -0.05526313f, -0.03573879f, -0.01026312f, -0.05796275f, 0.03622949f, 0.11981516f, 0.31530890f, 0.29530421f, 
    0.00489294f, -0.02506033f, -0.00354836f, -0.10032690f, 0.00220568f, 0.00800027f, -0.05989688f, -0.04502787f, 
    -0.19761690f, 0.00471576f, -0.11641964f, -0.40928295f, -0.00482586f, 0.14761798f, -0.10004850f, -0.20100786f, 
    -0.12078202f, 0.06568502f, -0.04827238f, -0.01290342f, 0.03497536f, -0.00997102f, 0.21891469f, 0.04034374f, 
    0.02108455f, 0.16122833f, -0.00802134f, 0.02580919f, 0.05791423f, 0.15808927f, 0.02048491f, 0.24225251f, 
    -0.09299236f, -0.18557347f, -0.08362464f, -0.02923473f, -0.12499406f, 0.27556786f, 0.21051003f, 0.16918689f, 
    0.03419649f, -0.07300962f, 0.16269954f, 0.15906185f, 0.10410752f, 0.01279885f, 0.12308104f, 0.12159261f, 
    0.21384181f, 0.11752816f, 0.00786479f, -0.24510570f, -0.11472110f, -0.04645838f, -0.09236398f, -0.13913539f, 
    -0.08455914f, 0.21055990f, 0.01346136f, -0.15596174f, -0.30105400f, -0.10748997f, 0.11499812f, -0.14541766f, 
    0.02998373f, -0.03577705f, 0.23276682f, 0.05003435f, 0.11937242f, 0.12057874f, -0.00309451f, -0.10283536f, 
    -0.11098988f, 0.19451387f, -0.02343805f, -0.05250200f, 0.02329798f, -0.08388711f, 0.05564011f, -0.17400499f, 
    0.01512644f, -0.09698807f, 0.08152783f, 0.02829089f, -0.30343387f, -0.01645084f, 0.20103057f, -0.13137066f, 
    0.08105000f, -0.08998954f, 0.06366703f, 0.02036634f, 0.09812323f, -0.04732347f, -0.04750575f, 0.15964104f, 
    -0.02534321f, 0.11666730f, -0.04601040f, 0.03494311f, 0.19999315f, 0.15029459f, 0.05146597f, 0.31370094f, 
    0.03292460f, 0.11081767f, -0.05747104f, -0.29046232f, -0.22014740f, -0.04391657f, -0.05042305f, -0.01419572f, 
    0.04640363f, 0.03294359f, -0.07103674f, 0.29349819f, 0.02303831f, 0.02277912f, 0.04606781f, 0.16851272f, 
    -0.04318753f, -0.05827035f, 0.04420032f, -0.14611775f, 0.08229923f, -0.06354983f, 0.07588872f, 0.04342617f, 
    -0.08726547f, -0.15114582f, 0.05847441f, -0.65197802f, 0.02536929f, -0.01861572f, 0.05214041f, 0.04516263f, 
    -0.06462407f, -0.08525375f, -0.05181690f, -0.09931255f, -0.13166624f, -0.07568461f, 0.06128026f, 0.05748766f, 
    -0.06680302f, -0.12179349f, -0.11362456f, -0.20023634f, 0.12434774f, 0.19636329f, 0.19546339f, 0.07333298f, 
    -0.12200719f, 0.01310880f, 0.16122016f, -0.15184273f, 0.13168800f, 0.28597099f, -0.16359067f, -0.57995582f, 
    -0.11766277f, 0.10802275f, -0.12204347f, 0.20332436f, 0.00850433f, 0.16499533f, -0.04412156f, -0.05536540f, 
    -0.34560883f, -0.23491427f, -0.14844978f, -0.19328010f, -0.11651576f, 0.02434606f, -0.05505183f, 0.02236783f, 
    -0.02084498f, -0.04892079f, -0.01606161f, 0.19593236f, 0.06645529f, 0.00123338f, -0.17537153f, 0.28052089f, 
    0.16591866f, -0.04355828f, -0.06662686f, 0.01457315f, 0.11090808f, -0.00458252f, -0.08217025f, -0.05897859f, 
    -0.07944920f, -0.07419866f, -0.03065690f, 0.15007167f, -0.01354021f, 0.31487036f, 0.05150935f, 0.05754517f, 
    -0.03441296f, 0.01634255f, 0.17679688f, -0.02886511f, -0.02605048f, 0.01108968f, -0.01898573f, 0.25916201f, 
    0.10319771f, -0.18878755f, -0.00411876f, -0.14926694f, 0.02466383f, 0.09337441f, 0.01050691f, 0.30966675f, 
    0.08678263f, 0.12878665f, 0.16900668f, 0.00483079f, -0.08140321f, -0.06540632f, -0.05643330f, -0.03616221f, 
    0.01560210f, -0.04607351f, -0.02541994f, -0.14919411f, -0.29369408f, 0.12102287f, -0.23998596f, -0.32681340f, 
    -0.22280760f, -0.02601611f, -0.08087727f, -0.18805613f, 0.14722034f, 0.11744549f, 0.05494147f, 0.22431962f, 
    0.12441888f, 0.21095856f, -0.03272190f, 0.22849935f, -0.10516614f, -0.07731307f, 0.05721361f, -0.26272219f, 
    0.18467897f, -0.00727103f, 0.03292471f, -0.14857101f, 0.16487935f, 0.11955374f, -0.12528792f, -0.11818269f, 
    0.03532637f, 0.00985815f, 0.04589585f, -0.07929102f, 0.06902951f, 0.00231985f, -0.04298124f, 0.11925461f, 
    0.42721590f, -0.16130011f, 0.01767598f, -0.14626487f, -0.05431801f, 0.10773439f, 0.05876916f, -0.02460623f, 
    -0.04952295f, 0.10993771f, 0.16162281f, 0.18683819f, 0.29099768f, 0.23914650f, -0.08927149f, 0.23124859f, 
    -0.17944042f, 0.25354630f, 0.09769966f, -0.02505290f, -0.06181683f, 0.10439558f, -0.18065868f, 0.17261964f, 
    -0.05740693f, 0.00230278f, -0.08893164f, -0.15727708f, 0.22068439f, 0.11726567f, -0.00254519f, -0.07848547f, 
    0.00900374f, 0.00632273f, 0.04742935f, 0.04130068f, -0.00508510f, 0.05664776f, -0.09342420f, -0.06604394f, 
    0.21045414f, 0.05062929f, 0.25887525f, 0.16998141f, 0.02743837f, -0.11570916f, -0.04138076f, 0.13094549f, 
    0.07994796f, 0.10222051f, -0.08721425f, -0.08638938f, 0.07774873f, -0.15981568f, -0.14069317f, -0.01044650f, 
    0.09627807f, -0.06103668f, 0.03863823f, 0.19142573f, 0.04627723f, -0.15682298f, -0.01095251f, -0.11522692f, 
    -0.00216832f, 0.05259700f, 0.01977782f, 0.08787884f, 0.05761081f, 0.08592596f, 0.00472789f, -0.06960414f, 
    -0.27974683f, -0.06143152f, 0.23398478f, -0.17551847f, -0.22790940f, -0.19182165f, -0.18833242f, -0.32203019f, 
    0.06557553f, -0.06880873f, 0.06605926f, 0.09798297f, 0.05742007f, 0.01304619f, -0.27718496f, 0.06734954f, 
    0.18146898f, -0.03063514f, 0.19998156f, -0.04772130f, 0.06607751f, -0.02092722f, 0.00513013f, 0.14215627f, 
    -0.11004826f, 0.06576939f, 0.12494919f, -0.16798989f, 0.08424695f, 0.07951430f, -0.05007147f, 0.14013617f, 
    -0.01796057f, -0.09864220f, 0.10397387f, 0.09614481f, -0.04666684f, 0.08694004f, 0.11777090f, -0.06037005f, 
    -0.14571656f, 0.14277118f, -0.01540565f, -0.08125760f, 0.16357701f, -0.06420249f, 0.05587725f, 0.01848985f, 
    -0.15037425f, 0.07342461f, 0.08466975f, -0.05224147f, -0.11323938f, -0.15552825f, -0.11357918f, -0.00155537f, 
    -0.03832041f, -0.09068902f, -0.02838488f, -0.15623929f, 0.51572382f, 0.19410765f, 0.42052865f, -0.11975576f, 
    -0.00589043f, -0.04720382f, -0.05158965f, 0.05355255f, 0.25541604f, 0.08930568f, -0.06934768f, 0.02405028f, 
    -0.37567827f, 0.04011101f, -0.40533322f, -0.13927266f, 0.13127330f, 0.11344198f, 0.00709148f, -0.02060340f, 
    -0.01730668f, -0.06436765f, 0.12010547f, 0.29591459f, 0.25172588f, 0.28348181f, -0.08206435f, -0.23271248f, 
    0.06328932f, -0.06993701f, 0.14975747f, 0.20996375f, 0.05326636f, -0.11143932f, -0.03114638f, -0.09567402f, 
    0.51873565f, -0.04985717f, 0.21283470f, 0.19778574f, -0.10572924f, -0.14428753f, -0.07704092f, -0.20482482f, 
    -0.01116580f, 0.18018806f, 0.00064208f, -0.12584354f, 0.29299793f, 0.03825987f, 0.36320597f, 0.07374112f, 
    0.13595404f, 0.19046971f, 0.01978195f, 0.30451447f, -0.11091857f, 0.06520896f, -0.01490460f, -0.05821290f, 
    0.24580584f, 0.34761897f, -0.14914717f, 0.05802588f, 0.06688601f, 0.00875845f, -0.01778956f, 0.22309537f, 
    0.02079201f, -0.05852601f, -0.05871826f, -0.06440939f, 0.05085512f, -0.30002236f, 0.08684681f, -0.08802878f, 
    0.08947768f, -0.01021453f, 0.01012726f, 0.13224161f, -0.06720745f, 0.05462074f, 0.06914845f, 0.05014062f, 
    -0.11074939f, 0.24154058f, 0.02871407f, 0.30799627f, 0.00563062f, -0.00305667f, 0.20166966f, -0.19272961f, 
    -0.11013448f, -0.07529013f, -0.16896521f, -0.09825173f, 0.32973942f, 0.06232894f, 0.16064507f, 0.01992082f, 
    0.13979262f, 0.06011739f, -0.06373706f, 0.13049483f, 0.00033704f, 0.11564657f, -0.10689365f, -0.06066558f, 
    0.04626025f, 0.06038862f, -0.02479699f, -0.15929960f, 0.10906563f, -0.07152268f, -0.00638355f, -0.10539607f, 
    -0.10718922f, -0.15812489f, -0.01366184f, -0.03821670f, -0.20824006f, 0.14228955f, -0.06172231f, -0.00560903f, 
    -0.19269259f, -0.14615549f, -0.19957876f, -0.22785096f, 0.05667895f, -0.01503159f, 0.00880967f, 0.22422868f, 
    0.04325717f, -0.04867144f, 0.04101912f, 0.03415891f, 0.02380972f, 0.03098816f, 0.01822706f, 0.03275611f, 
    0.04278536f, -0.02664482f, -0.01848870f, -0.04755158f, 0.02864658f, -0.04616208f, -0.04061963f, -0.03640476f, 
    -0.02527180f, -0.00293540f, -0.02929784f, 0.00074113f, -0.04545968f, -0.05036545f, -0.01868054f, 0.01896792f, 
    -0.04824071f, -0.02974729f, -0.02031229f, 0.03830563f, -0.03123836f, -0.01425930f, 0.03680191f, 0.04421959f, 
    -0.03439363f, 0.04691800f, 0.02481882f, -0.02588800f, 0.02303947f, 0.01426200f, -0.03277411f, -0.02028621f, 
    0.00289561f, 0.01646743f, 0.02599055f, -0.05826082f, 0.01044002f, -0.03441313f, 0.03593432f, 0.02359728f, 
    -0.03881402f, -0.02613404f, -0.01771131f, -0.02903256f, -0.06160476f, 0.03381384f, -0.00201935f, -0.04353409f, 
    0.03582162f, -0.00282141f, -0.03992982f, -0.03928714f, -0.01420993f, -0.06224450f, 0.00561359f, -0.00572409f, 
    -0.02032209f, 0.03370947f, -0.01094234f, 0.01632520f, -0.01697249f, -0.04094015f, -0.02647325f, -0.01751805f, 
    -0.00099973f, -0.03848721f, -0.04539996f, -0.02053360f, 0.04760488f, -0.00673592f, -0.00139388f, -0.00521432f, 
    -0.01772990f, -0.02561221f, -0.03050204f, -0.00724176f, -0.00345302f, 0.02285300f, 0.03557107f, 0.01850281f, 
    0.03193009f, -0.04100439f, -0.03439592f, -0.02114007f, -0.03984785f, 0.02284031f, -0.03970768f, 0.03918931f, 
    -0.02683635f, -0.01506555f, 0.01154568f, 0.03481716f, -0.00958841f, -0.03605502f, -0.00351260f, -0.00794565f, 
    0.00467376f, 0.02165628f, -0.04410810f, -0.03483110f, 0.00560229f, 0.02279929f, -0.00885561f, 0.03665894f, 
    -0.02383550f, 0.02142005f, 0.01951890f, 0.04051507f, -0.04333192f, 0.03715223f, -0.00416315f, 0.02548485f, 
    0.00983320f, 0.03962570f, 0.04824118f, 0.04148997f, -0.00182446f, -0.04328432f, -0.06102439f, -0.04668112f, 
    -0.00434043f, -0.00881382f, -0.03315938f, 0.04528561f, 0.02906088f, -0.05579531f, 0.00435298f, 0.02921302f, 
    0.00846785f, -0.03475248f, 0.02978050f, -0.00491540f, 0.02475335f, -0.01752279f, -0.01446596f, 0.03931262f, 
    0.00120892f, -0.04975703f, -0.00666755f, 0.01215779f, -0.05275149f, 0.01211008f, 0.01506421f, 0.01237159f, 
    0.00828687f, 0.04700455f, -0.02220092f, -0.04081983f, 0.01420882f, -0.03281531f, 0.04349944f, -0.03126526f, 
    -0.00757470f, 0.04039551f, 0.01184733f, -0.05025636f, 0.03694277f, 0.00896213f, 0.03947532f, 0.00160086f, 
    -0.03240224f, 0.00178311f, -0.04318517f, 0.05296534f, 0.01455178f, 0.04226167f, -0.00755282f, -0.03004467f, 
    0.01698619f, -0.05211929f, 0.00542963f, -0.00269967f, -0.03315391f, 0.04160230f, -0.00652982f, -0.01767576f, 
    0.02772667f, 0.02814304f, -0.00024364f, 0.01372410f, -0.00802936f, -0.04934691f, -0.03705891f, -0.02503049f, 
    0.01432726f, -0.02873504f, -0.01799149f, -0.06153116f, 0.01132807f, 0.01711289f, -0.05458810f, -0.01966180f, 
    -0.06151535f, 0.02429174f, 0.01900898f, -0.05301938f, 0.02064679f, 0.01850718f, -0.01594759f, -0.04156867f, 
    -0.00149521f, -0.04610145f, 0.03314531f, -0.00523985f, -0.04347481f, -0.01123041f, -0.04967487f, 0.02642986f, 
    -0.03456729f, 0.01575585f, -0.04666541f, 0.00698935f, 0.00747246f, 0.03852937f, 0.04618057f, -0.01663562f, 
    0.04581244f, -0.03744781f, 0.01226329f, -0.05046593f, -0.00906592f, -0.01072600f, -0.05734130f, -0.03350121f, 
    -0.04773673f, -0.02781771f, -0.01230868f, -0.04613213f, 0.02646996f, 0.03638027f, 0.03064433f, 0.00341331f, 
    -0.00713773f, 0.01224806f, -0.01232399f, -0.02522732f, -0.00046859f, -0.03765755f, -0.00552473f, -0.04964674f, 
    -0.05800515f, -0.04018640f, -0.01199958f, -0.03755247f, -0.02196415f, -0.03951183f, 0.03845036f, -0.00732201f, 
    0.04762139f, 0.03364621f, -0.02295754f, -0.01873031f, 0.03897439f, -0.01712844f, 0.02346509f, -0.01200691f, 
    -0.02966994f, 0.00728070f, 0.01406885f, 0.01050758f, -0.02809979f, -0.06076944f, 0.02835508f, 0.01107709f, 
    0.03929596f, -0.04994499f, 0.02978637f, 0.02997346f, -0.05016503f, -0.01685175f, 0.02414419f, -0.04924280f, 
    0.04149003f, 0.00021726f, -0.05217161f, 0.03606046f, -0.04740896f, -0.00291856f, -0.02595928f, -0.04460479f, 
    -0.01187628f, -0.04429196f, -0.02109777f, -0.02342693f, -0.03671582f, -0.04231727f, -0.04320079f, 0.03703232f, 
    -0.04303409f, 0.00733114f, -0.00347521f, -0.03110623f, -0.02955163f, 0.02868076f, 0.03098229f, 0.01746761f, 
    -0.04085254f, -0.03162953f, 0.00007605f, 0.03248236f, 0.01958137f, -0.02381539f, 0.01761651f, 0.01146876f, 
    0.04952109f, 0.04101865f, 0.03873063f, -0.02614851f, -0.04750941f, -0.02558201f, -0.03801736f, -0.00724882f, 
    -0.00619023f, -0.05243188f, 0.01935552f, 0.03114093f, -0.02509484f, 0.01904868f, 0.00356750f, 0.01248692f, 
    0.02806464f, 0.01941751f, -0.01414012f, 0.01658343f, -0.05344913f, 0.02263856f, 0.02583740f, 0.03017545f, 
    0.03272139f, 0.01982343f, -0.01268166f, -0.05168092f, -0.00676509f, -0.01389638f, 0.05095232f, 0.03741274f, 
    -0.05075103f, -0.05748205f, 0.02298984f, 0.01421509f, 0.01514666f, -0.01357291f, 0.03903431f, 0.00908536f, 
    0.00101357f, -0.02106879f, -0.00702420f, 0.02608254f, -0.02384862f, 0.03443901f, -0.00563383f, 0.04359028f, 
    -0.05699505f, 0.02172480f, -0.04341852f, -0.04750584f, 0.00724784f, 0.03711640f, -0.00166409f, -0.00399049f, 
    -0.04528396f, -0.02848964f, -0.01971672f, -0.03684922f, -0.05378966f, -0.04091966f, 0.01815616f, -0.05586220f, 
    -0.03514715f, -0.02463760f, -0.04692183f, 0.02487576f, -0.04691854f, -0.05563027f, 0.03242118f, -0.03301120f, 
    -0.05218754f, -0.05199707f, -0.16011992f, 0.12699895f, -0.08332784f, -0.26228672f, -0.05528413f, 0.08900132f, 
    -0.13618185f, -0.19592454f, -0.32268175f, -0.19470546f, 0.19603990f, 0.06910645f, -0.04100021f, 0.23703028f, 
    0.24088928f, -0.05909369f, 0.10842954f, 0.04764292f, -0.06746151f, 0.04257734f, 0.10720161f, -0.04624994f, 
    -0.10450333f, 0.02058036f, 0.32840049f, 0.25587115f, 0.09450687f, -0.00596780f, -0.14502227f, 0.20070249f, 
    -0.00035939f, -0.05054902f, -0.08730228f, -0.20541885f, 0.14429484f, 0.01570918f, 0.15521377f, -0.14186466f, 
    -0.04027830f, -0.02899314f, 0.09331854f, 0.10025839f, -0.08527797f, -0.17602690f, 0.06547330f, -0.09017362f, 
    -0.19165659f, -0.05223025f, -0.00271764f, -0.43117073f, -0.05675349f, 0.04289430f, 0.03685262f, 0.03165326f, 
    0.07873023f, 0.11904111f, -0.06835394f, 0.08400114f, 0.02722976f, 0.08098956f, 0.08371852f, -0.05529663f, 
    0.08518837f, 0.13892411f, -0.11367770f, 0.03012511f, 0.02458943f, 0.11238107f, 0.15082154f, 0.10517611f, 
    -0.02098386f, 0.04473766f, 0.03239801f, -0.07235919f, -0.10397639f, -0.09115528f, -0.02578388f, -0.09147996f, 
    0.16041586f, -0.07131378f, -0.12104756f, -0.26496020f, -0.12587488f, 0.07538321f, -0.00339154f, 0.04436814f, 
    0.01616476f, 0.01627424f, 0.04574893f, 0.15083912f, -0.00588898f, 0.01331860f, 0.11220463f, 0.14178446f, 
    -0.04087715f, 0.19260573f, 0.00346067f, -0.04576677f, 0.13479717f, 0.24017377f, 0.00355525f, 0.20587453f, 
    0.00034882f, 0.13684422f, -0.05747407f, 0.14871843f, 0.12654215f, 0.01768211f, -0.02624408f, -0.09941067f, 
    -0.02498767f, -0.00767175f, 0.00321804f, -0.07756853f, 0.08616085f, -0.01655822f, 0.02693314f, 0.09019866f, 
    0.08615844f, -0.23330113f, -0.01723351f, 0.07119919f, -0.02639068f, -0.04679238f, 0.01419556f, 0.03781996f, 
    0.13426879f, 0.05766803f, 0.10931280f, -0.16496111f, 0.16614543f, -0.07500714f, 0.08062712f, 0.25831887f, 
    0.03555278f, 0.18089008f, 0.26288188f, 0.08508187f, 0.12151085f, 0.06955376f, -0.02272411f, 0.04874803f, 
    0.15126643f, -0.14079517f, 0.13964534f, 0.26504746f, 0.16396822f, 0.08823361f, 0.03710045f, 0.28243664f, 
    -0.02564034f, -0.00664672f, -0.01348458f, 0.03267753f, -0.20835909f, -0.29052043f, 0.09843628f, 0.07226663f, 
    0.04295614f, 0.15972997f, 0.01125174f, 0.15962851f, -0.05228433f, -0.05371051f, 0.04339292f, -0.07921707f, 
    0.17548221f, 0.04905460f, 0.07268008f, 0.17703097f, 0.16780104f, 0.22707720f, 0.19739994f, 0.31899613f, 
    0.01649768f, 0.08108801f, -0.04792893f, 0.01874711f, -0.01295890f, 0.10247252f, 0.06757974f, -0.17156005f, 
    -0.01873177f, -0.09729224f, 0.11140837f, -0.01780251f, 0.14894009f, 0.21477397f, 0.09287170f, 0.19059514f, 
    0.05702115f, 0.14431046f, 0.02946078f, -0.08364537f, -0.04715573f, -0.07548983f, 0.03956576f, 0.10793182f, 
    -0.04687249f, -0.04721663f, 0.00192573f, -0.06594644f, -0.17826648f, -0.01238873f, 0.07436807f, 0.00759704f, 
    -0.02389407f, -0.02300633f, 0.03068815f, 0.26794535f, -0.04936105f, -0.10047109f, 0.07342436f, -0.10179852f, 
    -0.03234185f, 0.04287969f, 0.17276475f, 0.07265359f, -0.05484019f, -0.13463074f, 0.03328229f, -0.09055597f, 
    0.08460525f, -0.12773570f, -0.05508688f, -0.09016446f, -0.00718731f, 0.02563730f, 0.20242304f, 0.08609581f, 
    -0.02282072f, -0.01078400f, -0.05697424f, -0.06512925f, -0.14013682f, 0.00566949f, 0.08197769f, 0.21063285f, 
    0.19997388f, 0.08414707f, 0.02393498f, -0.19553542f, -0.11554892f, -0.03324011f, -0.05958884f, -0.03133697f, 
    -0.11112862f, -0.07909700f, -0.17641440f, -0.25481424f, -0.63074547f, 0.38740271f, 0.13447885f, 0.40537348f, 
    -0.00034641f, -0.06845129f, -0.00704953f, 0.00177439f, 0.02483749f, -0.16235289f, 0.24355625f, -0.03173860f, 
    -0.28743356f, -0.16710894f, 0.13438194f, 0.55041915f, 0.02293410f, 0.03724246f, 0.11604297f, 0.16810451f, 
    -0.23367527f, -0.16819850f, -0.02003762f, -0.07409167f, -0.15943444f, 0.08460233f, -0.09414737f, 0.28950775f, 
    -0.00999781f, 0.10330256f, 0.04621605f, 0.04215876f, -0.07310075f, 0.02609785f, 0.01920477f, 0.15995315f, 
    -0.20562936f, -0.08853273f, -0.04174987f, -0.08761733f, -0.06181903f, -0.07334470f, 0.01182883f, -0.18481460f, 
    0.08319014f, 0.09341577f, -0.21602277f, -0.06226804f, -0.20730285f, -0.11768156f, -0.14907105f, -0.17372690f, 
    0.03013058f, -0.08219747f, 0.02600757f, 0.02807799f, -0.03447564f, 0.07361230f, -0.17252813f, 0.07969858f, 
    -0.06185777f, -0.06376976f, 0.01789347f, -0.14783069f, 0.04395441f, -0.07724249f, 0.10183068f, 0.11344082f, 
    -0.09200895f, -0.04741817f, 0.09963318f, 0.03744028f, -0.29771599f, 0.06401996f, -0.00862101f, -0.16251761f, 
    0.02602272f, -0.10513213f, -0.05134460f, -0.01727039f, 0.10113440f, -0.09491375f, -0.12926254f, 0.03483914f, 
    0.57513964f, -0.07806265f, 0.12114479f, 0.06367171f, 0.19032377f, 0.11949153f, 0.18759733f, 0.26887664f, 
    -0.16855206f, 0.01945730f, 0.10582864f, 0.05159328f, -0.14758857f, -0.06893129f, -0.13779074f, 0.05727461f, 
    -0.11295003f, 0.02586701f, -0.18204965f, 0.14746499f, -0.02362152f, 0.04513205f, 0.10394332f, 0.13619561f, 
    0.09987399f, -0.05865956f, -0.16015279f, -0.17350122f, 0.04578420f, 0.08334658f, 0.07855332f, 0.10105561f, 
    -0.12663676f, 0.16428186f, -0.01903272f, -0.24420634f, 0.13543510f, 0.07068135f, 0.10018253f, -0.13943198f, 
    -0.07686201f, -0.08539504f, 0.01322277f, -0.03009116f, -0.07490421f, -0.06119776f, 0.07445937f, -0.10267941f, 
    0.26522717f, -0.03378917f, 0.13687256f, 0.11865687f, -0.01757528f, -0.00864537f, -0.06495572f, 0.00061457f, 
    0.30100024f, 0.06263808f, 0.18638435f, 0.32224876f, 0.22420126f, -0.08410977f, 0.37877226f, 0.19573136f, 
    -0.04212805f, 0.03355225f, 0.10242849f, -0.05312712f, -0.02687462f, -0.03991564f, -0.07272114f, -0.11180769f, 
    -0.02555273f, 0.08610158f, 0.26495084f, 0.34698734f, 0.23271927f, 0.10158642f, 0.32417744f, 0.16834350f, 
    0.03394056f, 0.05814571f, -0.06888969f, -0.07725418f, 0.04767399f, -0.04470629f, 0.01383898f, -0.17945714f, 
    0.09801302f, 0.13584395f, 0.28054038f, 0.16647027f, -0.01565651f, 0.18164138f, 0.35114315f, 0.40959948f, 
    -0.00180513f, 0.00306312f, -0.27710721f, -0.05684363f, 0.10159408f, -0.00174052f, 0.00697446f, -0.09751386f, 
    -0.17403242f, -0.28622755f, -0.22994159f, -0.23486194f, -0.21179013f, -0.00958576f, -0.02573731f, -0.07783932f, 
    0.27838731f, 0.10414869f, -0.15169978f, -0.01293367f, -0.42369688f, -0.52895719f, -0.46419325f, -0.60807782f, 
    -0.03639758f, -0.19747096f, -0.07882266f, -0.02187456f, -0.15610667f, -0.14960666f, 0.07767734f, -0.04573485f, 
    0.34501943f, 0.38716832f, 0.27305242f, 0.53761846f, 0.15602580f, -0.00948941f, -0.04641705f, 0.14341137f, 
    -0.03955377f, -0.08359643f, -0.02473699f, 0.00864539f, -0.05823152f, -0.11247056f, -0.04327179f, -0.32217446f, 
    -0.12074094f, -0.01473309f, -0.00670023f, -0.15644807f, 0.17096992f, -0.27270505f, 0.05497427f, -0.09856430f, 
    -0.12059581f, -0.08375040f, -0.27523416f, -0.23435180f, 0.17494710f, 0.03504303f, 0.18126148f, -0.13674906f, 
    0.33467489f, 0.03317044f, -0.28896984f, -0.04774423f, -0.44044012f, -0.06832057f, -0.11032850f, -0.27492541f, 
    0.26291355f, 0.21142761f, 0.28783998f, 0.29622740f, 0.04739736f, -0.12323464f, -0.13332021f, -0.06320109f, 
    0.02265675f, -0.06006271f, -0.21991989f, -0.00346978f, 0.11186061f, -0.08041571f, 0.04111158f, 0.00798755f, 
    0.00501710f, 0.03682790f, -0.20360103f, 0.13467313f, 0.08155343f, 0.01655481f, 0.04349210f, 0.20080088f, 
    0.11706262f, -0.01664160f, -0.02984557f, -0.07040150f, -0.11833502f, -0.21341440f, 0.11128174f, 0.06114267f, 
    -0.03176919f, -0.12106427f, -0.09338024f, -0.18112972f, 0.05682828f, 0.27974084f, -0.03502825f, -0.15695556f, 
    -0.04996127f, -0.05798243f, 0.14429532f, 0.00887732f, -0.02172419f, 0.12170724f, 0.10304873f, -0.17673934f, 
    -0.21259286f, -0.08188155f, 0.08263910f, 0.07635642f, 0.14510734f, -0.20724180f, -0.03277801f, -0.13333671f, 
    -0.09568153f, -0.22243485f, -0.12493688f, -0.55902380f, 0.16876930f, -0.04793209f, -0.08765453f, -0.08269074f, 
    -0.17706946f, 0.08256571f, 0.01362748f, -0.02273293f, 0.02352318f, -0.36473885f, 0.00543677f, 0.09959866f, 
    0.13254482f, -0.10340467f, -0.14209375f, 0.10141915f, 0.10550609f, 0.14454819f, 0.14976729f, 0.06565338f, 
    -0.12834796f, -0.05483921f, -0.00657233f, -0.02838640f, -0.18390077f, 0.34079608f, 0.22570039f, 0.03227627f, 
    -0.06076631f, 0.10616391f, 0.10494086f, 0.21746279f, -0.12656401f, 0.09608582f, -0.09397495f, -0.06176287f, 
    0.10532431f, -0.04964166f, -0.18052574f, 0.23212393f, -0.03103504f, 0.09557812f, 0.19691898f, 0.13490249f, 
    -0.01019244f, 0.24542467f, -0.09746438f, 0.06784021f, 0.20215292f, -0.11620387f, 0.13843760f, -0.02027680f, 
    -0.05745202f, -0.18850680f, -0.09654751f, -0.16766740f, -0.01274392f, 0.12493133f, 0.05702047f, 0.05313824f, 
    0.09216297f, -0.36956546f, -0.07803306f, 0.05239613f, 0.01516487f, -0.00042159f, -0.01682358f, -0.07651173f, 
    0.24571387f, -0.05808127f, 0.11679148f, 0.39501894f, -0.52350873f, -0.05463193f, 0.07155612f, 0.18544339f, 
    0.03890686f, 0.08457484f, 0.09948329f, -0.15422902f, -0.04490445f, 0.22853097f, 0.26340559f, 0.13635936f, 
    0.23754080f, 0.33377546f, 0.03944373f, -0.14393802f, -0.04424192f, -0.09331438f, 0.09758358f, -0.00774779f, 
    -0.00268263f, 0.25338453f, -0.19683987f, -0.38189837f, 0.16979069f, -0.04201772f, -0.09574547f, 0.21486013f, 
    0.11511318f, 0.18524344f, -0.14220499f, -0.06724240f, -0.01442446f, 0.11824954f, 0.09646498f, 0.10605374f, 
    -0.25283977f, 0.01178567f, -0.10103901f, 0.11522140f, 0.03585666f, 0.06466706f, 0.14288613f, -0.00246636f, 
    0.18337016f, 0.05903229f, 0.21302757f, 0.26738119f, -0.00793703f, -0.07993002f, -0.19455504f, 0.02156622f, 
    -0.02073404f, 0.00384231f, -0.03905362f, -0.02563729f, 0.05520763f, -0.03029451f, 0.07963038f, 0.34396467f, 
    -0.03751856f, -0.11048348f, -0.02083337f, 0.10138654f, 0.11861812f, 0.17304505f, 0.20603792f, 0.11082347f, 
    0.03031670f, 0.15001701f, 0.18082350f, 0.23487234f, 0.29037535f, 0.07590345f, -0.25878307f, -0.07954883f, 
    -0.12631162f, 0.17636313f, 0.01671535f, 0.00548793f, -0.07106930f, -0.14706871f, -0.15821952f, -0.06744961f, 
    0.25590840f, 0.15503179f, 0.01358729f, 0.05803430f, -0.01234807f, -0.04756919f, -0.01715938f, 0.24671060f, 
    0.10399896f, 0.08117592f, 0.35396484f, 0.33339000f, 0.22398539f, 0.04577135f, -0.17121890f, 0.04210672f, 
    0.17833030f, -0.00477782f, 0.09143417f, -0.11872302f, -0.00243319f, -0.14317763f, -0.07709011f, 0.17425686f, 
    -0.02261241f, -0.22131111f, 0.02005713f, 0.17979088f, 0.08585464f, 0.05050845f, 0.24329866f, 0.14865758f, 
    0.49819386f, 0.31166646f, 0.16250943f, 0.50613070f, 0.06873441f, -0.16497211f, -0.14950168f, 0.02676415f, 
    -0.01083312f, 0.07364728f, 0.24561580f, 0.01455230f, -0.12322670f, 0.15649401f, 0.14840627f, -0.10996337f, 
    -0.32176307f, -0.01410448f, 0.19541597f, 0.17662546f, -0.16099909f, -0.21182632f, -0.02924507f, 0.07155361f, 
    0.15674588f, 0.02273007f, 0.11977265f, 0.11482763f, -0.21876396f, 0.01516900f, 0.04406350f, 0.42169291f, 
    -0.14381516f, 0.10888503f, 0.01482207f, 0.03652454f, -0.09465168f, 0.10237493f, -0.02202832f, -0.14619188f, 
    -0.15867849f, -0.20096190f, 0.30070001f, 0.26310369f, 0.03540477f, 0.06305028f, -0.00314240f, 0.05168234f, 
    0.03944766f, 0.04724204f, -0.10758684f, -0.11636283f, -0.15735802f, 0.04185447f, 0.13359165f, -0.13493784f, 
    0.00579342f, 0.04822845f, 0.09699993f, 0.01521482f, -0.08258967f, 0.21343833f, 0.08479305f, 0.35246807f, 
    -0.13626067f, 0.01702305f, -0.01089579f, -0.18725376f, 0.01005702f, 0.00961938f, 0.00680022f, -0.08632743f, 
    0.17862296f, -0.10529120f, 0.00257310f, -0.01404934f, 0.05267742f, -0.17004116f, -0.08816760f, -0.01568792f, 
    0.01263939f, 0.13241999f, 0.05981794f, 0.00986248f, 0.11446327f, -0.24535276f, -0.03248576f, -0.12829612f, 
    0.28270838f, -0.07597411f, -0.10389955f, -0.09095333f, 0.04923831f, -0.05097647f, 0.10819986f, 0.07746816f, 
    0.18446688f, 0.09922677f, 0.09356423f, 0.13072729f, -0.08703746f, 0.06560064f, -0.17635021f, 0.07187443f, 
    -0.07114350f, 0.04486317f, 0.00362814f, 0.09867325f, 0.16057496f, 0.07087412f, 0.11081986f, -0.03862561f, 
    -0.27586347f, 0.46647134f, -0.02128876f, -0.06778242f, 0.07034667f, -0.10960291f, -0.03882231f, 0.04026949f, 
    -0.10161211f, -0.02380907f, -0.12271405f, -0.13986945f, 0.15509322f, 0.06198819f, 0.06814651f, 0.23419955f, 
    0.05014785f, -0.02954220f, -0.18388508f, 0.05352482f, -0.23501314f, -0.10058761f, -0.02560815f, -0.05645351f, 
    0.11308827f, 0.30749151f, 0.46753481f, 0.26467493f, 0.02031196f, -0.22563578f, -0.02490089f, -0.03741398f, 
    -0.09077004f, -0.10894459f, -0.04269993f, 0.02015007f, 0.69518435f, 0.24160613f, 0.05830432f, 0.16067228f, 
    0.08870852f, -0.11433386f, 0.01584523f, 0.11054661f, 0.06988632f, -0.00480916f, -0.16161975f, 0.22890510f, 
    -0.10394768f, -0.20087662f, -0.01102168f, 0.22550890f, -0.03056133f, 0.18788630f, 0.18383230f, -0.06013241f, 
    -0.01838641f, -0.01726113f, 0.02800891f, -0.00757810f, -0.18767187f, 0.04008965f, 0.18198709f, -0.02431114f, 
    0.04149717f, 0.13040018f, -0.07514077f, 0.13982819f, 0.01796096f, 0.03190530f, 0.05109605f, -0.08127231f, 
    -0.56195706f, -0.02160117f, 0.20142111f, 0.25830331f, 0.10032456f, 0.17383815f, 0.00413392f, 0.12584718f, 
    -0.11523368f, -0.08401552f, -0.07169374f, -0.11516037f, 0.08725572f, -0.06059240f, -0.23128003f, 0.08266200f, 
    -0.13003860f, -0.00622383f, 0.01707560f, -0.06707727f, 0.21166831f, 0.08555406f, 0.09890943f, 0.25636849f, 
    -0.19589253f, -0.30442086f, -0.25544748f, 0.06310137f, -0.05181983f, 0.07915059f, 0.08313420f, 0.10363898f, 
    0.09408247f, 0.05248973f, 0.06875554f, 0.02459841f, -0.16335838f, 0.16296086f, 0.36902323f, -0.06513840f, 
    0.04631371f, 0.04310803f, -0.07965106f, 0.06478118f, -0.14485030f, 0.00033193f, -0.00273519f, 0.10778193f, 
    -0.18123688f, -0.22855142f, 0.09827979f, 0.18619913f, -0.02320565f, 0.22156607f, 0.02855720f, 0.00437094f, 
    0.08265426f, 0.12472604f, -0.11406440f, -0.04486765f, 0.35237804f, -0.11882185f, -0.14136505f, -0.01943961f, 
    -0.02702604f, -0.08888534f, 0.03103688f, -0.07258028f, -0.06205269f, 0.03345505f, 0.16531828f, -0.01556177f, 
    0.01350532f, -0.22818741f, -0.13107978f, 0.11442596f, -0.03632634f, 0.06347611f, -0.00714105f, -0.01831875f, 
    0.24917454f, -0.01359350f, 0.11534052f, 0.11361572f, -0.37733525f, 0.00783700f, 0.01680858f, -0.18801527f, 
    0.03134493f, 0.16818649f, -0.04619897f, -0.09353793f, 0.05537126f, 0.09508675f, 0.10991885f, 0.01902355f, 
    -0.31072614f, 0.34359649f, 0.13997795f, 0.09538088f, 0.04170118f, 0.05613571f, 0.18077710f, 0.06613723f, 
    -0.09176467f, 0.06153622f, 0.03428018f, -0.11329109f, -0.56718355f, 0.13088699f, -0.11820724f, 0.43018836f, 
    0.12181439f, 0.18029527f, -0.16207623f, 0.09061052f, -0.01884458f, 0.13044892f, 0.03335069f, 0.11664896f, 
    -0.18764389f, 0.21881053f, 0.21757919f, -0.18424796f, 0.16902427f, -0.03803293f, -0.02327738f, 0.05789563f, 
    0.00973851f, 0.11267895f, 0.10468046f, -0.13553575f, -0.39374220f, -0.05886990f, 0.03040170f, 0.16577490f, 
    0.00251156f, 0.05706971f, -0.05546016f, -0.07474088f, 0.10400365f, -0.05394057f, 0.06150192f, 0.15401064f, 
    -0.37421960f, -0.17630771f, 0.14772190f, 0.04097740f, -0.02312233f, -0.09285960f, -0.07079796f, 0.04345359f, 
    -0.02658846f, -0.04782434f, 0.05958179f, 0.14334826f, -0.18890812f, -0.09237843f, -0.09291121f, 0.19211751f, 
    0.07438637f, 0.16740531f, 0.00921701f, 0.12894800f, 0.03680823f, -0.15017819f, -0.11831594f, 0.04132470f, 
    0.33677393f, 0.11689033f, -0.02104306f, 0.14824945f, 0.00623563f, -0.10452968f, 0.17409195f, 0.00030128f, 
    0.07488017f, -0.05089226f, 0.27741009f, 0.09112557f, -0.21632199f, -0.09797196f, 0.08345269f, 0.31343704f, 
    -0.12565929f, -0.07655245f, -0.19230610f, 0.02922718f, -0.04099204f, -0.09953850f, 0.12796761f, 0.05170484f, 
    -0.34695697f, 0.04665512f, 0.08449699f, 0.17566809f, -0.08085628f, 0.03017726f, -0.11784785f, 0.25851297f, 
    0.14441127f, 0.34071058f, 0.05352056f, 0.16214514f, -0.25455967f, -0.26136616f, -0.20871198f, 0.00899484f, 
    -0.17041856f, -0.00267981f, 0.03996167f, 0.00611179f, 0.18689255f, 0.24661531f, 0.11564474f, -0.06975888f, 
    0.23785819f, -0.28830877f, -0.08020838f, 0.25238764f, 0.21627581f, 0.03242388f, 0.02819371f, 0.16010003f, 
    0.10024244f, -0.00744986f, -0.05702948f, 0.07474191f, 0.66665250f, -0.25765967f, 0.33215934f, -0.46528804f, 
    -0.02397887f, 0.02447997f, -0.05152359f, -0.08238414f, -0.11916050f, -0.08266072f, -0.02460000f, -0.01395905f, 
    -0.01074291f, 0.62294191f, 0.08949769f, 0.71971041f, 0.04039577f, 0.00341264f, 0.04136080f, 0.21969840f, 
    -0.01892087f, -0.04192811f, 0.00632807f, -0.02454763f, 0.19681984f, -0.10349588f, -0.17439173f, -0.24553241f, 
    0.00737355f, 0.04660638f, 0.00068264f, 0.09676205f, -0.06920657f, 0.13638611f, 0.03773262f, 0.00747073f, 
    0.18541695f, 0.26150760f, 0.04743102f, 0.46324095f, -0.05813626f, 0.20324931f, -0.03536488f, 0.13933915f, 
    -0.03958586f, 0.00958071f, 0.00291713f, 0.08904535f, -0.21235962f, 0.12084713f, 0.04199575f, 0.15346941f, 
    0.11387833f, 0.17271063f, -0.11914951f, -0.05152208f, -0.01176728f, -0.04604803f, 0.06651798f, -0.14440045f, 
    -0.08774307f, 0.04902479f, 0.02261563f, 0.11954898f, -0.10173908f, -0.05945043f, -0.03135999f, -0.07282913f, 
    0.04425566f, 0.06233368f, 0.07711539f, 0.03450946f, -0.16062397f, 0.01791014f, -0.09645815f, -0.04908887f, 
    -0.06367133f, 0.02722028f, -0.00831626f, 0.12766960f, 0.15170369f, 0.09853736f, 0.17097881f, -0.05287138f, 
    0.05654174f, -0.16681784f, 0.08007891f, -0.49873072f, 0.20413260f, -0.04231426f, -0.01755543f, -0.24931322f, 
    0.02950860f, 0.00510106f, -0.11064293f, 0.09442245f, 0.17154811f, 0.13763264f, -0.04442663f, -0.18495326f, 
    0.07814547f, -0.02262721f, -0.07911939f, -0.20765786f, -0.04455547f, 0.06128864f, 0.11167867f, -0.05658313f, 
    0.80855697f, -0.38819295f, -0.32542640f, -0.24717961f, 0.23760760f, 0.04854127f, 0.01424728f, -0.14124426f, 
    0.27260384f, 0.00685967f, -0.02954636f, 0.08847247f, 0.14904319f, -0.33114159f, -0.10737082f, -0.12671746f, 
    0.03920917f, 0.21199948f, 0.09587786f, -0.00045955f, -0.13552044f, -0.08626916f, 0.06592766f, 0.05722615f, 
    0.24297220f, 0.12464365f, 0.21219233f, 0.36327907f, -0.00442902f, -0.16680738f, -0.09685789f, 0.07313791f, 
    -0.03146375f, -0.00573055f, -0.08100253f, 0.03284136f, 0.06250281f, 0.00617216f, 0.17321603f, 0.22308467f, 
    -0.01320842f, -0.14246325f, 0.11654294f, -0.02545811f, 0.08606312f, 0.18612169f, 0.15009893f, -0.01311436f, 
    -0.04795700f, 0.09553067f, 0.19097078f, -0.16272995f, 0.18416861f, -0.08714907f, -0.13773791f, -0.25159323f, 
    -0.01473005f, -0.03817068f, -0.09109264f, -0.22868893f, 0.01762437f, -0.09382670f, 0.14511023f, -0.25713480f, 
    -0.14122058f, 0.11036067f, -0.17062975f, -0.06585620f, -0.08463527f, -0.19240883f, 0.01888431f, 0.08674911f, 
    -0.04797196f, -0.07209868f, 0.09398461f, -0.18814519f, 0.09697565f, 0.03786813f, 0.07410908f, 0.00279817f, 
    0.03554313f, 0.04180610f, -0.07958721f, 0.07178627f, -0.16957448f, -0.25531018f, -0.12812352f, 0.16617635f, 
    0.14316449f, 0.05250968f, -0.00351845f, 0.17018135f, -0.10616892f, -0.05842145f, -0.00436031f, -0.12562694f, 
    0.25120997f, 0.01313271f, 0.13716041f, 0.26180238f, 0.08570010f, 0.07576518f, 0.22359638f, 0.23531212f, 
    -0.03409107f, 0.06451611f, 0.01719598f, 0.03596338f, 0.00443382f, -0.20526832f, 0.20550084f, -0.11084240f, 
    -0.07647827f, 0.01397204f, -0.04695177f, -0.17623766f, -0.09499310f, 0.12111031f, -0.10015248f, 0.05591511f, 
    0.01508501f, -0.08426394f, 0.04730133f, -0.06360550f, -0.05682398f, -0.05031465f, -0.09582634f, -0.16397177f, 
    0.13601795f, 0.05105411f, 0.01578496f, 0.12713109f, -0.25414962f, 0.14723155f, 0.17040528f, 0.35772312f, 
    0.08195617f, 0.02910150f, 0.10226176f, 0.08992253f, 0.02332036f, -0.11053722f, 0.16053616f, -0.05463701f, 
    -0.23710793f, -0.31115097f, 0.37217528f, 0.48810512f, 0.24501345f, 0.06725339f, 0.06046741f, 0.04388053f, 
    -0.21347187f, -0.05235875f, -0.00390105f, -0.15007965f, 0.20907943f, -0.13772298f, -0.06729631f, -0.19523796f, 
    0.09182736f, -0.03015882f, -0.23241241f, -0.13500930f, -0.03516665f, 0.07703125f, -0.01472676f, 0.03152916f, 
    0.03812291f, -0.08244022f, -0.24478705f, 0.17575318f, -0.05071031f, 0.00189099f, 0.05764576f, -0.11953945f, 
    0.00408773f, 0.09386875f, -0.08101428f, 0.07421768f, 0.12782495f, -0.09534422f, -0.38178548f, -0.02723076f, 
    0.14538012f, 0.11758566f, -0.07287087f, 0.04281180f, 0.05987782f, 0.00506822f, 0.04741414f, 0.28069252f, 
    0.24854000f, -0.47841936f, -0.39401531f, -0.15494142f, 0.17531307f, -0.04629557f, 0.03711164f, 0.15447032f, 
    0.10083578f, 0.06410085f, 0.12119706f, 0.08131777f, 0.44165221f, 0.35803404f, 0.15695466f, 0.25798663f, 
    -0.08190736f, 0.13569805f, 0.12775564f, 0.30338401f, -0.04428947f, -0.04210923f, 0.00472618f, 0.00457697f, 
    0.30216587f, -0.26727760f, -0.21749075f, 0.03465989f, 0.06488581f, 0.04586152f, -0.01272852f, 0.04010772f, 
    0.12189157f, -0.01486287f, 0.08901045f, 0.14447400f, 0.46280310f, 0.11720229f, -0.24973926f, -0.10143209f, 
    0.18593538f, -0.04496874f, -0.12685049f, -0.03744791f, -0.01891648f, 0.08034846f, 0.02494667f, 0.15404463f, 
    0.29093680f, -0.13462725f, -0.08374052f, -0.01767039f, 0.09713628f, 0.04929837f, 0.12250295f, 0.03005582f, 
    -0.00838891f, 0.07314916f, -0.12465733f, 0.16378684f, -0.02545127f, -0.00605931f, 0.01425570f, -0.04683143f, 
    -0.04723999f, -0.01592353f, 0.03534620f, -0.04081871f, 0.04462891f, 0.06038141f, 0.03290823f, -0.12068404f, 
    -0.01168061f, 0.02834684f, -0.04802703f, -0.01484215f, 0.01650755f, -0.00568653f, 0.03065774f, -0.04167568f, 
    -0.05269254f, -0.04641069f, -0.01335699f, -0.00739046f, -0.02440906f, 0.03777377f, 0.02358152f, -0.01154717f, 
    0.02704782f, -0.05983127f, -0.05143677f, 0.01188743f, 0.02988173f, -0.03588600f, -0.00007659f, -0.00404290f, 
    0.03731777f, 0.03080678f, -0.03390509f, 0.00973239f, -0.03251277f, 0.03867926f, 0.02073576f, 0.00634066f, 
    0.01977916f, -0.02284812f, 0.03718767f, 0.02482447f, 0.02363204f, 0.03798734f, 0.02701924f, -0.00509056f, 
    0.03146687f, 0.00560527f, -0.02863411f, -0.03995584f, 0.00134942f, 0.00354152f, 0.01737900f, -0.00021588f, 
    0.03153179f, -0.00134866f, -0.04452226f, 0.00135367f, -0.01404739f, -0.04136385f, -0.00743942f, 0.02434517f, 
    -0.02140174f, -0.00269266f, -0.01508466f, -0.05742639f, 0.04084564f, 0.03776183f, 0.03463599f, 0.01941779f, 
    -0.00358809f, 0.02992888f, -0.00583085f, -0.00834798f, 0.00114133f, -0.01609857f, -0.03381421f, 0.03953792f, 
    0.01333204f, 0.00292427f, 0.00007691f, -0.04758902f, -0.03301419f, 0.00300868f, 0.03123353f, -0.05168746f, 
    -0.00313317f, -0.03125457f, 0.02426521f, 0.03140773f, 0.03662337f, -0.04803788f, -0.02530074f, -0.01452686f, 
    -0.02102177f, 0.04091651f, 0.03900916f, -0.02768590f, -0.00992623f, -0.02952695f, -0.03347157f, 0.01347393f, 
    -0.01433698f, 0.01345574f, -0.00377155f, -0.02473960f, 0.00644614f, -0.01164313f, -0.05944955f, -0.00489734f, 
    -0.05001064f, 0.00846048f, -0.04880114f, -0.02287158f, -0.01288980f, -0.02913067f, -0.00280579f, 0.02914355f, 
    -0.02020732f, -0.06009163f, 0.03272364f, -0.02041931f, 0.00978772f, 0.00726761f, -0.05018347f, -0.01186486f, 
    -0.03567147f, -0.00734684f, 0.01166042f, 0.00120027f, -0.06275525f, -0.00662149f, 0.00797391f, 0.02385482f, 
    0.03903550f, 0.00138123f, -0.06184947f, 0.01616736f, 0.03418874f, 0.03089833f, -0.01312915f, -0.03382153f, 
    0.01744013f, -0.02751871f, 0.01375225f, -0.01459346f, 0.01423735f, -0.01300894f, -0.02021282f, 0.03609305f, 
    -0.02074857f, -0.00620772f, 0.01659523f, 0.03617091f, -0.01756077f, 0.00865494f, -0.00987772f, -0.05914179f, 
    0.01503312f, 0.00073230f, -0.01350246f, -0.01792146f, 0.01850026f, 0.01884333f, -0.03318763f, 0.01106373f, 
    0.02969131f, -0.06031238f, 0.00520290f, -0.01958847f, -0.02689627f, -0.03860969f, -0.04244154f, -0.05422773f, 
    -0.02602341f, 0.00658646f, -0.05336862f, -0.01676290f, 0.03133405f, -0.04673857f, 0.00164871f, 0.03761046f, 
    -0.02356323f, -0.03149302f, -0.00292148f, -0.01395341f, -0.01697406f, -0.05596944f, -0.03593478f, -0.03192858f, 
    0.02197491f, -0.05882127f, -0.02482587f, -0.06018759f, 0.02322108f, -0.03503752f, -0.00819666f, -0.02989225f, 
    0.03364938f, 0.00619314f, 0.03940482f, -0.02137091f, 0.03927192f, -0.04391405f, 0.00955177f, -0.04097019f, 
    0.02216583f, -0.02379214f, -0.01078677f, 0.02938000f, 0.00786724f, -0.04154168f, -0.04947174f, -0.02806347f, 
    -0.00622803f, 0.01205353f, 0.02511100f, 0.02245465f, -0.05216948f, -0.05176142f, -0.05586708f, -0.04952437f, 
    -0.02780336f, 0.02241521f, -0.05577678f, -0.00680333f, 0.02727693f, 0.01058570f, -0.00596036f, -0.05767714f, 
    -0.02530228f, 0.00301569f, -0.05431810f, -0.03397104f, 0.00335366f, -0.03366706f, -0.04187940f, 0.02137455f, 
    -0.01670343f, -0.03310466f, -0.05075398f, -0.03860950f, -0.00334764f, 0.00996830f, 0.02986427f, -0.02383321f, 
    0.02525687f, -0.04118513f, -0.00260813f, 0.00545572f, -0.02397627f, 0.02420167f, -0.04097744f, -0.04383940f, 
    -0.05489396f, 0.03237005f, -0.01615957f, 0.02453092f, -0.05814475f, -0.03454401f, 0.03826223f, -0.00053042f, 
    -0.02784283f, -0.05463536f, 0.02936461f, -0.04982419f, 0.02004842f, 0.03786332f, 0.00647354f, -0.03462503f, 
    -0.02999805f, 0.01223313f, -0.00078235f, -0.00071901f, -0.05497710f, -0.01942253f, -0.02072547f, 0.02603772f, 
    -0.04197093f, 0.00512462f, -0.01790841f, 0.01562655f, 0.00373515f, 0.01749962f, 0.01329104f, 0.00924875f, 
    0.02778322f, -0.03121894f, -0.06170417f, -0.05424389f, 0.03402702f, -0.00724733f, -0.01309735f, -0.01031124f, 
    -0.05255092f, -0.05689702f, -0.03746393f, 0.01141999f, 0.00793624f, 0.02056562f, 0.02672629f, 0.02609853f, 
    -0.05558707f, -0.02390955f, 0.03159551f, -0.01792494f, -0.05064964f, -0.03406489f, 0.03843005f, -0.06293839f, 
    -0.04285682f, -0.02590329f, -0.05894412f, -0.03390779f, -0.03056232f, 0.00535000f, 0.01374307f, 0.00834597f, 
    0.01684895f, -0.04829856f, -0.02943323f, 0.03761533f, 0.01909767f, -0.03793876f, 0.00234875f, -0.02045690f, 
    0.02614697f, -0.01490419f, -0.06110826f, 0.02069047f, 0.02631683f, 0.02134739f, 0.03399169f, 0.00424676f, 
    0.03598186f, -0.00899593f, -0.02155546f, -0.03834266f, 0.02812524f, -0.04669977f, -0.05634847f, 0.00277523f, 
    0.03545325f, 0.03831309f, -0.03048841f, -0.04366393f, 0.02497674f, 0.01604343f, -0.05116027f, -0.00322812f, 
    0.00010918f, 0.03561509f, -0.04481912f, 0.00583513f, -0.02527832f, 0.02681075f, -0.02509573f, -0.03844102f, 
    -0.03129265f, -0.02329316f, -0.02140122f, -0.05473094f, 0.03276976f, -0.05872516f, -0.00442110f, 0.02387403f, 
    0.02166501f, -0.04911827f, 0.01764233f, 0.03577820f, -0.01315340f, -0.04564162f, 0.02871410f, -0.02346678f, 
    -0.04914023f, -0.05130549f, -0.04963105f, -0.04230082f, -0.05429412f, -0.03545580f, -0.04137636f, -0.04989936f, 
    0.00793177f, -0.04677310f, 0.04101865f, -0.04655904f, -0.04627489f, 0.01027382f, -0.02691441f, -0.02502984f, 
    0.03973516f, 0.02340402f, -0.03487173f, -0.01259150f, -0.02179470f, 0.00783936f, -0.03547205f, 0.03191826f, 
    0.01570250f, -0.01310202f, -0.02059931f, -0.05151856f, -0.04824580f, -0.02619273f, -0.02888336f, -0.00617317f, 
    -0.02216650f, -0.00940392f, 0.02074348f, 0.00378045f, 0.00868550f, -0.01794756f, -0.04301639f, -0.03893359f, 
    -0.00961430f, 0.01886281f, 0.00906172f, 0.01812734f, -0.02376484f, -0.01474266f, -0.01048319f, 0.01079116f, 
    -0.02090277f, -0.03451761f, -0.03249092f, -0.00960122f, 0.00905499f, 0.00945884f, -0.01341566f, -0.02246235f, 
    0.02866076f, 0.00683405f, -0.04219027f, -0.00166543f, 0.00441426f, -0.02217123f, 0.01769500f, -0.04697040f, 
    -0.00032709f, -0.02531580f, 0.03707433f, 0.01620276f, 0.02906036f, 0.00009868f, -0.04716540f, 0.03791127f, 
    -0.00452385f, 0.02087479f, -0.00459727f, 0.00206085f, 0.04022800f, -0.03030901f, 0.01751355f, 0.00528950f, 
    -0.05066410f, 0.03647137f, -0.02248949f, 0.02961143f, -0.00085740f, 0.02232271f, -0.00374195f, -0.00189304f, 
    -0.05106342f, 0.03747174f, -0.01428868f, -0.01059866f, -0.01429322f, 0.03926556f, -0.01915088f, -0.04841235f, 
    0.00237107f, -0.01185247f, -0.01514481f, 0.03861957f, -0.03116515f, -0.01991011f, -0.00114532f, 0.03205831f, 
    0.01527549f, 0.02488509f, -0.01130149f, 0.04084495f, -0.00205492f, -0.01770534f, 0.02190846f, -0.02119191f, 
    -0.05776723f, 0.00719882f, -0.01672405f, -0.03685112f, 0.02371274f, -0.04112545f, -0.01685045f, -0.03196923f, 
    -0.00595091f, 0.00420923f, -0.04709145f, -0.04366037f, -0.00558110f, 0.00234408f, -0.03569219f, 0.01642129f, 
    -0.03767074f, -0.00543762f, -0.02582560f, 0.03346989f, -0.01557729f, -0.02078168f, -0.00166803f, 0.01497732f, 
    -0.03290522f, -0.02205020f, -0.01100634f, 0.00807012f, -0.00004420f, -0.04893957f, 0.01291548f, -0.02060518f, 
    -0.06210809f, 0.03824415f, -0.01576942f, -0.02404811f, -0.03293464f, -0.03622099f, -0.05086496f, 0.01717516f, 
    -0.00307462f, -0.01467099f, 0.01211404f, -0.04156619f, -0.04273019f, 0.02888180f, 0.03418850f, -0.02569820f, 
    -0.04653154f, -0.01889085f, 0.00624381f, -0.05462522f, 0.04131340f, 0.00268952f, 0.02261110f, -0.05250529f, 
    -0.02541340f, -0.06250979f, 0.01755251f, -0.00072943f, 0.00362772f, -0.03234844f, -0.01552874f, -0.04754269f, 
    0.02939477f, 0.01857834f, -0.04105296f, 0.03959895f, -0.02691036f, -0.05508248f, -0.04666509f, -0.02624843f, 
    -0.04384737f, -0.01008430f, -0.03966620f, -0.01377847f, 0.01437951f, -0.01284962f, 0.02441203f, -0.05126837f, 
    -0.05203829f, -0.05780850f, -0.00170213f, -0.02345314f, -0.04575355f, 0.01073432f, -0.01907843f, 0.03168099f, 
    -0.00622143f, -0.00407792f, -0.05378357f, -0.02114170f, -0.03303366f, -0.04618426f, 0.03480297f, -0.04240901f, 
    -0.01412840f, 0.01891156f, -0.05897257f, 0.01473744f, 0.04187768f, -0.01006369f, -0.03447301f, -0.04592108f, 
    -0.04492059f, 0.01283482f, -0.04952118f, 0.02327668f, -0.04859417f, 0.03336698f, -0.00873649f, -0.01811269f, 
    0.02806118f, -0.01594637f, -0.01689447f, -0.01276781f, 0.01213357f, -0.04829394f, -0.04772298f, 0.01024228f, 
    -0.03882235f, 0.02057118f, 0.00459590f, -0.02109709f, 0.00306363f, 0.02927051f, -0.04463163f, -0.03973469f, 
    0.02093455f, -0.05992441f, 0.02848563f, -0.01332412f, -0.03034572f, -0.05949748f, 0.03829272f, -0.05444302f, 
    -0.01925017f, -0.04937704f, 0.00749637f, -0.02636510f, -0.04065329f, -0.03076290f, -0.05312733f, -0.04526559f, 
    -0.01366308f, -0.01383321f, -0.03443018f, -0.05888221f, -0.02546719f, -0.03200097f, -0.02126607f, -0.00568290f, 
    -0.03894157f, -0.04513352f, -0.00388923f, 0.00773957f, 0.02906759f, 0.01894078f, 0.03085384f, -0.01092552f, 
    -0.01654033f, -0.03924898f, -0.04923383f, -0.03026021f, 0.00162531f, -0.03231079f, 0.02390811f, -0.03051208f, 
    -0.02277731f, 0.00302240f, -0.01895279f, -0.01284274f, -0.00208589f, 0.03489693f, -0.03968137f, -0.00071243f, 
    0.03488476f, -0.01222280f, 0.01018529f, 0.01825674f, 0.01044178f, -0.03906657f, -0.02520741f, -0.03170379f, 
    -0.03238451f, 0.03951425f, -0.05352617f, -0.04639177f, 0.00759940f, 0.02049314f, -0.03408862f, 0.00992792f, 
    0.02100924f, 0.01357228f, 0.01645087f, -0.06264917f, 0.01671650f, -0.04828228f, -0.02029312f, -0.02692019f, 
    -0.06087449f, 0.03188036f, -0.03195881f, -0.04133925f, -0.00913779f, 0.01548488f, -0.01830111f, 0.02592963f, 
    -0.00866148f, 0.03167022f, 0.03808245f, -0.04308264f, -0.04660518f, 0.03094114f, 0.04208627f, -0.04628642f, 
    0.03566650f, -0.04774391f, 0.03267940f, 0.03043906f, 0.04225592f, -0.01437607f, 0.02429100f, 0.02760616f, 
    0.02369582f, 0.01389283f, -0.01496437f, 0.04199770f, 0.03787615f, 0.00707285f, -0.00894935f, -0.02213819f, 
    0.04556506f, -0.02492090f, 0.03934217f, -0.00654298f, 0.01074881f, 0.03641749f, -0.03323523f, 0.01486615f, 
    0.02062275f, 0.02319264f, -0.02051340f, -0.02632015f, -0.00613576f, -0.02852986f, -0.00767547f, -0.04357161f, 
    0.02052782f, -0.03372359f, -0.00327495f, 0.00996746f, -0.00439020f, -0.03720046f, 0.01002137f, -0.01530570f, 
    0.01476176f, -0.05823388f, -0.04953295f, 0.00972966f, -0.02417841f, -0.03973956f, -0.01700534f, -0.01948762f, 
    0.01377902f, -0.04934095f, 0.03729880f, -0.05164948f, -0.03869522f, -0.04710494f, -0.03518532f, 0.02604479f, 
    -0.00818054f, -0.02144946f, -0.00010464f, 0.00385631f, 0.00670804f, -0.03767313f, -0.01549598f, -0.04568236f, 
    -0.04063744f, -0.03715162f, -0.05395677f, 0.02919063f, 0.03904117f, -0.05346008f, 0.00758346f, 0.00978914f, 
    -0.00203979f, 0.23207937f, -0.15445146f, -0.03821509f, 0.13426419f, 0.11942559f, 0.07338735f, 0.15975028f, 
    -0.15161966f, -0.09950084f, -0.20472020f, -0.10231559f, 0.02690362f, 0.19718149f, -0.23551217f, 0.36784157f, 
    0.17274190f, 0.05111345f, 0.04503043f, -0.16199480f, -0.02287440f, 0.19268823f, 0.02169997f, 0.02911371f, 
    -0.15460931f, -0.49857724f, -0.15768246f, -0.22593224f, 0.29555517f, 0.17253910f, 0.12156197f, -0.05212210f, 
    0.04199903f, 0.00222735f, -0.05388205f, 0.05127366f, 0.13130657f, 0.06775721f, 0.21093079f, 0.19276534f, 
    -0.03822829f, 0.13556612f, 0.14048705f, 0.20526083f, -0.04525074f, -0.15712456f, 0.16107489f, -0.28317133f, 
    0.06746925f, -0.10799169f, -0.14252268f, -0.32920605f, 0.18037753f, 0.01327806f, -0.02802871f, -0.01520518f, 
    -0.03347259f, 0.11499898f, -0.01147156f, 0.08406483f, -0.28247496f, -0.20818251f, 0.01663883f, -0.00325947f, 
    0.03979122f, -0.00198754f, 0.05702985f, -0.15094957f, -0.13031051f, 0.22267914f, 0.00416861f, 0.24288300f, 
    -0.13836171f, -0.07523542f, -0.07121536f, -0.12278625f, -0.04540869f, -0.03793979f, -0.02932522f, -0.04998575f, 
    -0.00269426f, -0.08386353f, -0.16700830f, -0.06117873f, -0.13124211f, -0.11599365f, -0.13955113f, -0.00746125f, 
    -0.08795774f, -0.05111483f, 0.01669469f, -0.07759481f, -0.11976328f, -0.11001171f, 0.05276198f, 0.17286092f, 
    0.05179147f, 0.22264719f, -0.06645354f, 0.18348312f, 0.06513791f, 0.18966465f, -0.22680396f, 0.22375578f, 
    0.14415152f, 0.15848358f, 0.11272626f, 0.31213742f, 0.04653197f, 0.10145687f, 0.11284853f, 0.01599535f, 
    -0.14668900f, -0.06261592f, -0.02516771f, -0.07465561f, 0.12652266f, -0.04330046f, 0.11632606f, 0.26417753f, 
    -0.37472185f, 0.11010873f, 0.28811067f, 0.04792180f, -0.19452628f, 0.03375045f, 0.04547358f, 0.09693551f, 
    0.02500077f, 0.08763196f, 0.07492197f, 0.02480517f, 0.15529315f, -0.11449031f, 0.26280415f, 0.38674960f, 
    -0.05425260f, 0.06117600f, 0.20211239f, 0.22428830f, 0.09201102f, 0.08990218f, 0.15528360f, -0.08817142f, 
    0.07322709f, -0.07681374f, 0.08767230f, -0.07599439f, 0.15005001f, 0.30857232f, 0.24209745f, 0.12076176f, 
    -0.04884956f, 0.02470081f, 0.06296840f, 0.08847103f, 0.14961772f, 0.00232439f, -0.31424657f, -0.08132006f, 
    0.05564634f, 0.13879269f, -0.15787029f, -0.07194324f, 0.05760367f, -0.08002826f, 0.10026755f, 0.09841850f, 
    0.40119967f, -0.08684529f, -0.04045623f, 0.19784234f, 0.07807153f, 0.06190548f, 0.42464912f, 0.41038918f, 
    0.00531680f, 0.03208620f, 0.17076626f, 0.22233504f, -0.09363103f, 0.16539629f, -0.09846206f, -0.00531098f, 
    -0.08472414f, -0.00020160f, 0.08061840f, -0.09511442f, 0.00124485f, 0.14779989f, 0.03328201f, -0.09734887f, 
    -0.27734166f, -0.05085663f, -0.19376864f, -0.14828557f, -0.02877197f, -0.07801162f, -0.19553041f, -0.08255633f, 
    -0.13469619f, -0.03025652f, 0.01253911f, -0.10538276f, -0.03356649f, -0.04182941f, -0.13119134f, -0.05931936f, 
    0.05391587f, 0.13912629f, 0.01694034f, 0.20582266f, -0.03529665f, -0.05169721f, -0.11755139f, -0.09925548f, 
    0.05101133f, 0.15130366f, -0.28164095f, -0.09962001f, 0.17815085f, -0.11644870f, -0.12522987f, -0.16771385f, 
    0.00746846f, -0.09541383f, 0.23893695f, 0.17200445f, -0.14663135f, 0.39539176f, -0.10629841f, -0.10113101f, 
    0.07057841f, -0.05513531f, -0.03484407f, 0.00157306f, -0.11582424f, 0.09020378f, 0.17420457f, 0.26505280f, 
    -0.10831068f, 0.00905528f, -0.29005617f, 0.00971566f, -0.06488345f, -0.01542182f, 0.03996698f, -0.05266305f, 
    -0.14352459f, 0.13228391f, -0.01361613f, -0.02343667f, -0.43443340f, -0.21085142f, -0.08646175f, 0.20083797f, 
    0.04242882f, -0.03345388f, -0.08607432f, -0.07776686f, 0.09322526f, 0.01013816f, 0.07475525f, 0.07543083f, 
    0.37195137f, 0.02303867f, -0.44673058f, 0.08808430f, 0.00982979f, 0.11032407f, -0.07706208f, 0.19578631f, 
    -0.04306572f, -0.21131606f, -0.05941046f, 0.12751445f, 0.28787479f, 0.08643275f, -0.05988404f, 0.02045916f, 
    0.19385459f, 0.04965932f, 0.04303360f, -0.11250736f, -0.13354893f, 0.04255781f, -0.02542147f, 0.05298764f, 
    0.14540280f, 0.14876863f, 0.23022892f, -0.33499566f, -0.12220292f, -0.04903502f, -0.00293260f, 0.12324798f, 
    0.12620495f, 0.15849666f, -0.21823710f, -0.02783109f, -0.07451002f, -0.07752313f, -0.17534174f, -0.35517916f, 
    0.02805221f, -0.09625521f, 0.17180106f, 0.10068222f, -0.06419377f, 0.11733677f, -0.11740509f, -0.02740699f, 
    -0.00289369f, 0.05426950f, 0.13127457f, 0.05486551f, 0.02377818f, 0.12080388f, 0.06985348f, -0.10197665f, 
    -0.10963986f, -0.05671626f, -0.05368341f, -0.14162683f, -0.08527741f, 0.06196559f, -0.41231862f, -0.37553909f, 
    0.12712729f, -0.11932997f, -0.02934835f, -0.26760542f, -0.01190000f, -0.05626270f, 0.02283736f, 0.13485819f, 
    0.19378017f, -0.04920617f, 0.12356646f, 0.09101434f, -0.01476996f, 0.21524237f, 0.29311982f, 0.42081848f, 
    0.01998611f, 0.05505559f, -0.02099185f, -0.10950232f, -0.22797835f, 0.00600578f, -0.12124728f, -0.14802963f, 
    -0.15325142f, 0.16575529f, 0.10204984f, 0.19215831f, -0.04098121f, 0.00078982f, -0.10893265f, 0.19555335f, 
    -0.04270621f, -0.02970904f, -0.11486395f, -0.10074267f, 0.08552439f, 0.22329585f, 0.03309596f, 0.01135107f, 
    -0.05123797f, 0.11211852f, -0.00500885f, -0.23325300f, -0.14402780f, -0.01357340f, -0.22373205f, -0.18710357f, 
    -0.07494041f, -0.10492964f, -0.07884755f, -0.11869678f, -0.18029916f, -0.09015381f, -0.08836173f, 0.03273886f, 
    0.04980944f, 0.03564421f, -0.04439922f, -0.03311975f, 0.02432235f, -0.01976241f, 0.04861657f, 0.02668823f, 
    -0.03819020f, 0.01938086f, -0.00389162f, -0.02853387f, 0.04288015f, -0.05652592f, 0.03374762f, -0.01414896f, 
    -0.02096272f, -0.04565270f, -0.00655548f, -0.00577702f, 0.01415462f, 0.01236363f, -0.00451660f, 0.00333568f, 
    -0.03482357f, 0.01458281f, -0.02483004f, 0.00810182f, -0.03115179f, -0.02866683f, 0.05231896f, 0.01431397f, 
    -0.02237942f, 0.03528039f, -0.03358132f, 0.04583339f, -0.04082539f, -0.00133832f, 0.00216084f, -0.04604841f, 
    0.01189053f, 0.02199594f, -0.01580142f, 0.01554834f, -0.05899921f, 0.00521065f, 0.02517705f, 0.01869449f, 
    -0.02374106f, -0.00530129f, 0.01128143f, -0.05568408f, 0.00820016f, -0.04277321f, -0.00609350f, -0.03594539f, 
    0.03952154f, 0.03444459f, -0.00291626f, -0.00287662f, -0.00582239f, 0.01508819f, 0.02513572f, 0.01506277f, 
    -0.00522063f, 0.00013105f, 0.01020210f, -0.05853204f, -0.01787628f, -0.04075221f, -0.02705583f, -0.01652043f, 
    -0.02130539f, -0.00712832f, -0.01509733f, -0.05285262f, 0.04098236f, 0.00427674f, -0.03131566f, -0.01083248f, 
    -0.01070323f, -0.04806698f, -0.02538887f, 0.04622304f, 0.03081776f, 0.00139013f, -0.05331479f, 0.03211575f, 
    -0.03192319f, -0.02312001f, -0.02320444f, -0.02152029f, 0.03541571f, -0.04076259f, 0.01579359f, 0.03717283f, 
    -0.04651890f, 0.01573679f, 0.01903371f, 0.00170761f, 0.02396547f, -0.04434379f, -0.01615693f, 0.01234160f, 
    0.01657088f, 0.02601091f, 0.03158084f, 0.02562129f, -0.00028391f, 0.02824395f, -0.02882290f, 0.00873845f, 
    0.03532558f, 0.04105046f, 0.04352053f, -0.00198398f, 0.01549988f, 0.03385403f, -0.01153343f, -0.00401366f, 
    -0.03301852f, -0.00944401f, -0.03358563f, -0.05663941f, -0.01193701f, -0.05620433f, -0.02511537f, 0.00682634f, 
    -0.03360863f, -0.01756130f, 0.01642088f, -0.02480593f, 0.01861301f, 0.03142871f, -0.03665024f, 0.02160294f, 
    -0.04734675f, 0.01736073f, -0.04504430f, -0.03007306f, 0.02768095f, -0.02456767f, -0.01690814f, 0.03622716f, 
    -0.03775434f, 0.03741823f, -0.03499846f, -0.04911290f, 0.03083845f, 0.01459063f, 0.05051488f, -0.01325388f, 
    0.03659062f, -0.04491462f, 0.01696878f, 0.03886515f, -0.00588122f, 0.02393601f, 0.03972843f, 0.01546466f, 
    0.05490347f, 0.00058953f, 0.02845414f, -0.03610095f, 0.00702085f, -0.03917931f, -0.00799281f, -0.00098978f, 
    -0.00120452f, 0.00572710f, -0.05310971f, 0.01109174f, 0.03138045f, -0.00262353f, -0.04987529f, 0.02564351f, 
    -0.01721973f, -0.02982612f, 0.00597276f, 0.03521105f, 0.00471799f, -0.01365698f, -0.02628615f, -0.01503027f, 
    -0.05567311f, -0.03067172f, -0.05108723f, 0.00796947f, 0.00885374f, -0.05252152f, -0.03184964f, 0.02913923f, 
    -0.02695340f, 0.03119357f, -0.00603217f, -0.00873536f, 0.03220426f, 0.03496879f, 0.04009216f, -0.05484895f, 
    -0.03937140f, 0.03659786f, 0.04099760f, -0.04892045f, -0.00063563f, 0.03647539f, -0.02207122f, 0.01786448f, 
    0.01059000f, 0.03762138f, -0.05201118f, -0.00838710f, 0.04339461f, 0.04311208f, -0.01552682f, 0.02013423f, 
    -0.01533795f, -0.02498942f, -0.00921378f, 0.04997414f, 0.03323255f, -0.00773255f, 0.00639167f, -0.02761896f, 
    -0.04357609f, 0.00476025f, 0.02298548f, -0.04912739f, -0.05482310f, -0.05336384f, 0.02270531f, 0.00055563f, 
    0.04052417f, -0.05622651f, 0.01726547f, -0.02177666f, -0.04624775f, 0.01521919f, -0.00085359f, 0.04301392f, 
    0.02120656f, 0.00878704f, 0.01564928f, 0.01426688f, -0.03371818f, -0.05723967f, -0.00655511f, 0.03681117f, 
    -0.00907119f, 0.01168716f, 0.02243391f, -0.04069850f, 0.02587829f, -0.01078114f, -0.03771348f, 0.01361728f, 
    0.03904824f, -0.03365118f, 0.04054442f, 0.00560364f, -0.05024309f, -0.03786826f, 0.03620271f, 0.03788295f, 
    0.03394159f, -0.04731211f, 0.00052665f, -0.04747401f, -0.04495427f, -0.03570006f, -0.01244024f, -0.02776629f, 
    0.00098005f, -0.02650085f, -0.01577668f, -0.03857217f, -0.00256586f, -0.04723767f, -0.04267886f, -0.02763703f, 
    -0.04369115f, -0.00596460f, -0.02862888f, 0.00696228f, -0.03419540f, -0.04618491f, 0.02740631f, 0.04056196f, 
    0.04710475f, -0.01635940f, 0.00508857f, -0.03969587f, -0.01783345f, 0.00849142f, 0.01689303f, -0.01173562f, 
    -0.00868709f, -0.00644391f, -0.01361395f, -0.00860050f, -0.03327081f, 0.02189204f, -0.04011126f, -0.00295269f, 
    0.02811357f, -0.02707679f, -0.00960403f, 0.02812686f, -0.02398971f, 0.01484798f, -0.03326199f, -0.02325313f, 
    -0.00689646f, -0.02065529f, 0.05539945f, -0.03538958f, -0.01975179f, -0.00325937f, -0.02440955f, -0.02507322f, 
    -0.02797150f, 0.01285760f, 0.00428132f, 0.03104090f, -0.02985871f, 0.01004449f, -0.03228233f, 0.01525973f, 
    -0.02661660f, 0.03953284f, 0.02122876f, -0.00965659f, 0.02190928f, 0.02320240f, -0.04347596f, 0.02261273f, 
    0.02947327f, 0.01033365f, 0.03560686f, 0.01509371f, 0.00591157f, -0.03371773f, 0.04415881f, -0.05133799f, 
    0.01196632f, 0.05343761f, -0.01203528f, -0.02925209f, 0.01386763f, -0.01393487f, -0.01869419f, 0.01083243f, 
    -0.02894494f, 0.00088113f, -0.04051565f, 0.01432495f, -0.00594313f, 0.03797010f, 0.01858432f, -0.03633340f, 
    -0.01160229f, -0.03727137f, -0.02933500f, -0.02548760f, -0.05191588f, -0.03152732f, -0.00890847f, 0.02807344f, 
    0.03966976f, 0.03630520f, -0.02186236f, -0.04500408f, -0.01788379f, 0.01090198f, -0.02318616f, 0.01371226f, 
    0.02836815f, 0.00937541f, -0.03729597f, -0.04416939f, -0.01328338f, 0.02503642f, 0.01934701f, -0.00527552f, 
    0.27296528f, -0.02891203f, 0.06905176f, -0.09683948f, -0.12636648f, -0.21216458f, 0.01194163f, 0.07181914f, 
    -0.06744580f, 0.11578367f, -0.07095783f, -0.04335213f, -0.11511187f, -0.14957404f, -0.03410916f, 0.13521217f, 
    0.16906345f, 0.15922172f, 0.14608040f, 0.05816479f, 0.11198099f, -0.17904082f, -0.04920113f, -0.07864007f, 
    0.49880362f, 0.22117752f, -0.31686780f, -0.40131503f, -0.26720801f, -0.30182776f, -0.13382354f, 0.10063050f, 
    -0.14837399f, 0.06592616f, 0.00724655f, -0.05425297f, -0.04590760f, -0.00546555f, 0.08546165f, 0.01930264f, 
    0.11424509f, 0.02023163f, -0.25812969f, 0.09915231f, 0.13885522f, 0.14447190f, 0.02468575f, 0.09223265f, 
    0.15655205f, 0.07639192f, 0.16949713f, -0.03962554f, -0.15418544f, -0.01759688f, 0.13450080f, 0.14576398f, 
    -0.06247279f, -0.13371728f, -0.22546548f, -0.01201757f, 0.17345287f, 0.03806268f, 0.16464020f, -0.13970235f, 
    -0.06637927f, -0.04214450f, -0.02823560f, -0.08682813f, -0.10845143f, -0.06841718f, -0.06304355f, -0.15980677f, 
    0.13801011f, 0.05328520f, 0.02347571f, 0.14320606f, 0.02443983f, 0.01810729f, -0.07187854f, -0.01665856f, 
    0.07790603f, -0.02723426f, 0.11580370f, 0.18768813f, 0.03007212f, -0.03319087f, 0.16264416f, -0.11076643f, 
    -0.07350232f, 0.10318512f, 0.09776345f, -0.01685685f, 0.02124254f, 0.05483384f, -0.06538722f, 0.00590428f, 
    0.33321998f, -0.30655798f, 0.16105691f, -0.03326449f, -0.04173128f, 0.04722918f, 0.20524248f, 0.11321440f, 
    -0.06878845f, 0.04794575f, 0.06889193f, 0.00865386f, -0.02913136f, -0.02711008f, 0.05523081f, 0.22688107f, 
    0.04764184f, 0.01121366f, 0.01704441f, -0.03862720f, 0.07127519f, -0.07842467f, -0.18099082f, -0.04083053f, 
    -0.30651075f, 0.00072011f, -0.17219616f, -0.14569663f, -0.11422208f, -0.04644329f, -0.09534083f, -0.09790482f, 
    -0.20109440f, -0.11190104f, 0.01191586f, -0.13475092f, -0.86155683f, -0.08035405f, 0.04237482f, -0.87261617f, 
    0.08743316f, 0.01341138f, 0.17661728f, 0.22032660f, 0.10144885f, -0.06037396f, 0.00471298f, -0.00159722f, 
    0.05435611f, 0.18278089f, 0.05830995f, 0.01018702f, 0.06815292f, -0.12235609f, -0.15824972f, 0.04649130f, 
    -0.05406990f, -0.08682910f, 0.00020429f, -0.05814882f, -0.08037685f, -0.03140394f, 0.17094423f, -0.01699597f, 
    -0.07418617f, -0.04400507f, -0.03355505f, 0.08914253f, 0.09936351f, -0.01205115f, -0.00344490f, 0.04877041f, 
    -0.05271716f, 0.06621888f, 0.01572135f, -0.14102809f, -0.06235749f, 0.24888352f, -0.04229189f, -0.15197416f, 
    -0.06004703f, 0.04540177f, -0.06025145f, -0.20401312f, -0.08933759f, 0.17846945f, 0.08337124f, 0.19370206f, 
    0.03939592f, -0.04139626f, 0.04044337f, 0.04097614f, 0.02434547f, 0.06693558f, -0.06105686f, -0.02841450f, 
    0.23440354f, 0.08443766f, 0.01751545f, 0.17754792f, -0.06761858f, -0.02569700f, 0.05133673f, -0.03179630f, 
    0.03113488f, 0.00212345f, 0.03847709f, -0.05588451f, 0.06192717f, -0.13814101f, 0.14381753f, -0.14757052f, 
    0.00165348f, -0.02460548f, -0.08169210f, -0.05956685f, 0.12429056f, 0.17452773f, 0.12828732f, -0.02861491f, 
    0.17538416f, 0.16518587f, 0.01569354f, -0.17224306f, -0.00041443f, -0.03458715f, -0.07034974f, -0.03113918f, 
    0.13144858f, 0.09097414f, 0.06735948f, 0.06770417f, 0.29315919f, -0.07900838f, 0.21578647f, 0.31628081f, 
    -0.12355630f, -0.07723194f, -0.03468116f, 0.00137325f, 0.09240899f, 0.09686380f, 0.11582834f, -0.11496142f, 
    0.06176410f, 0.06578740f, 0.13014621f, 0.09920630f, 0.05817419f, 0.00155315f, -0.03912883f, -0.02422759f, 
    0.01885337f, 0.07720668f, 0.30841833f, 0.19173701f, 0.78926098f, 0.01005775f, -0.12102180f, 0.04960387f, 
    -0.14584522f, 0.00658987f, -0.03365929f, 0.28382128f, -0.12369370f, 0.04261132f, -0.06822997f, 0.22260697f, 
    0.02437552f, -0.26081243f, 0.51258183f, -0.17665663f, 0.24556763f, 0.13191879f, 0.02726475f, 0.10064748f, 
    0.05437879f, 0.13227405f, 0.01565513f, -0.05551331f, 0.00276003f, -0.17854360f, 0.19959463f, -0.06109838f, 
    0.06320308f, -0.09255939f, 0.04533429f, 0.06546707f, 0.18766937f, -0.08666581f, 0.06243113f, -0.06267747f, 
    0.24525765f, -0.05923796f, -0.15332368f, 0.24006514f, 0.01630308f, -0.10308593f, -0.04313550f, -0.06559907f, 
    -0.16280371f, -0.10583720f, 0.04906093f, 0.07088073f, 0.06017055f, 0.26021633f, -0.13670827f, -0.09505525f, 
    0.03624822f, -0.08994065f, 0.08931658f, -0.01871521f, 0.18517901f, -0.02109534f, 0.10194467f, 0.03890037f, 
    0.06182363f, 0.25821513f, 0.17127183f, -0.35795340f, -0.04746525f, 0.02305158f, 0.00007031f, 0.11052632f, 
    0.14422041f, 0.07496712f, 0.04880964f, 0.08400672f, -0.01341804f, 0.22212139f, 0.15404978f, 0.06284203f, 
    -0.07658959f, -0.01379097f, -0.02694170f, -0.11147931f, 0.04274889f, -0.00810538f, 0.03226563f, -0.06512948f, 
    -0.55513167f, -0.08784328f, 0.23911938f, -0.26239005f, 0.19115189f, -0.13473478f, -0.11793808f, -0.02832964f, 
    0.18793009f, 0.18011217f, -0.07306419f, 0.06308262f, 0.09371497f, 0.27112338f, 0.27934924f, -0.04093086f, 
    0.13548043f, -0.03937851f, 0.00063818f, -0.09542290f, 0.06913334f, -0.07029861f, 0.05750887f, -0.19098553f, 
    -0.09065458f, -0.18538201f, 0.11678957f, 0.05995236f, 0.13417695f, -0.04019453f, 0.06385606f, 0.23878074f, 
    -0.04479075f, 0.08056787f, 0.01394631f, 0.13762343f, 0.21059158f, 0.01990603f, 0.11819521f, 0.11991886f, 
    -0.09471190f, -0.00259957f, 0.01837135f, -0.03278708f, 0.06504777f, 0.02663140f, 0.04824709f, 0.08660139f, 
    -0.03294256f, -0.02529901f, -0.05500214f, -0.00265104f, 0.01441563f, 0.03595168f, -0.01820232f, 0.00912626f, 
    -0.02330993f, -0.03802915f, 0.03638653f, -0.04600902f, -0.00160874f, -0.05801387f, -0.01343727f, 0.03878313f, 
    -0.05314315f, -0.02046041f, 0.03059292f, -0.03133456f, -0.01091110f, 0.01274457f, -0.01909520f, 0.00843056f, 
    0.03698241f, 0.00757213f, 0.00237002f, -0.00112464f, 0.01582595f, -0.02188802f, 0.01743060f, -0.01938205f, 
    -0.00726341f, -0.01540714f, -0.02368080f, 0.02548669f, -0.00167934f, -0.05213622f, 0.00454267f, 0.01034699f, 
    0.01080768f, -0.01942879f, -0.01700589f, -0.04235469f, -0.05914650f, -0.00790739f, 0.00955596f, -0.01895550f, 
    -0.01018358f, 0.02783406f, -0.01807415f, -0.00034361f, -0.03370528f, -0.04387915f, 0.01539032f, 0.03937395f, 
    -0.04780025f, -0.05622365f, -0.04543930f, 0.02715541f, 0.02273759f, -0.01608485f, -0.02218260f, 0.03293095f, 
    -0.04136816f, -0.04144148f, -0.02231390f, 0.02808605f, -0.04047630f, -0.03435289f, 0.01526003f, -0.02127563f, 
    -0.05237653f, -0.01099551f, 0.02385863f, -0.02691094f, -0.02191060f, -0.01787839f, -0.00402106f, -0.01277224f, 
    0.04587293f, 0.04154135f, -0.03230241f, -0.01514926f, -0.00971146f, -0.04548573f, -0.05514649f, -0.00306344f, 
    -0.04768944f, -0.00536208f, 0.02469531f, 0.02790887f, -0.00606109f, 0.02714558f, 0.01213229f, -0.05992185f, 
    -0.04711216f, -0.04227632f, -0.01105003f, -0.03148210f, 0.00647630f, -0.00103030f, -0.05218937f, -0.04726147f, 
    -0.01113843f, -0.02170921f, -0.00844550f, -0.01683777f, -0.04404886f, 0.03940091f, -0.04949169f, 0.03319046f, 
    0.00231999f, -0.01225315f, -0.01762373f, 0.00043938f, -0.03418428f, -0.00926509f, 0.01078976f, -0.02855858f, 
    -0.00566445f, 0.01267537f, 0.03044757f, 0.02642293f, -0.01954572f, 0.00894156f, 0.00994047f, 0.00681776f, 
    0.00808828f, -0.01690790f, -0.01416345f, -0.02981753f, -0.03187485f, -0.04166128f, 0.00808081f, 0.00126504f, 
    0.01884170f, 0.00261600f, -0.02432484f, 0.00735860f, -0.06115067f, 0.02132039f, 0.02510689f, 0.01140277f, 
    -0.01924611f, 0.00813715f, -0.04547516f, 0.02222638f, -0.03597908f, -0.04809370f, -0.01211400f, 0.00458132f, 
    0.00262298f, -0.04928388f, 0.00068030f, -0.02831482f, 0.01425750f, -0.05432432f, -0.02720032f, -0.04187471f, 
    0.05429221f, -0.00427098f, -0.00983892f, 0.03541793f, -0.06045311f, 0.02300167f, 0.02562287f, -0.01980977f, 
    0.02414633f, -0.00331118f, -0.04011969f, -0.02226606f, 0.01595335f, -0.02212722f, 0.04017216f, -0.00172688f, 
    -0.01617272f, -0.01221517f, -0.03955024f, -0.04151791f, -0.05503187f, -0.02784824f, 0.02276535f, -0.05259316f, 
    0.02183784f, 0.00226045f, -0.04179980f, 0.02611479f, -0.03909436f, -0.05873667f, -0.02030502f, 0.03879787f, 
    0.00328144f, 0.00327595f, 0.01706926f, -0.01177909f, -0.00832616f, 0.01699711f, 0.02650635f, 0.00962718f, 
    -0.00965829f, -0.00062685f, 0.01649898f, -0.03359238f, -0.04661544f, -0.03519829f, -0.04361174f, 0.01114445f, 
    -0.01697113f, 0.00246144f, -0.04882531f, -0.02655846f, -0.00715705f, 0.02600949f, 0.02810056f, 0.00069478f, 
    -0.01729916f, -0.02285286f, -0.00122582f, -0.01825226f, -0.04624499f, -0.04516990f, 0.00652103f, -0.02607036f, 
    0.00844979f, -0.02698108f, -0.05257893f, -0.03220193f, -0.01229470f, 0.02227413f, 0.03489081f, 0.00329416f, 
    -0.03089398f, 0.01806725f, 0.00405257f, -0.00997892f, -0.02256951f, 0.00139611f, 0.02893143f, 0.00767010f, 
    0.00517999f, -0.04911505f, 0.01009484f, -0.03803734f, 0.01970925f, -0.01102807f, 0.01316371f, 0.03274052f, 
    -0.03964312f, 0.00523707f, 0.03441448f, -0.01183355f, -0.03923153f, -0.05318064f, -0.00772025f, -0.02537458f, 
    0.01536303f, 0.00913015f, 0.00969682f, 0.04415370f, 0.03906181f, -0.03720668f, -0.02362119f, 0.00567125f, 
    -0.04702614f, -0.00675698f, 0.03976507f, -0.00763614f, -0.01334850f, 0.02557291f, -0.03291043f, 0.03621699f, 
    -0.01083117f, 0.02005087f, -0.00926296f, 0.03481060f, 0.00542433f, 0.02123353f, 0.03603629f, -0.05784173f, 
    0.04148038f, -0.00199368f, -0.01886401f, 0.00741713f, -0.02623209f, 0.03936011f, -0.01502892f, -0.03437090f, 
    -0.01420070f, -0.04691579f, -0.05828783f, 0.01065775f, -0.01448189f, 0.00099691f, -0.02716315f, -0.01837903f, 
    0.02916089f, 0.02428238f, 0.02205888f, -0.03710370f, -0.02747059f, -0.03856991f, -0.04373784f, 0.01091404f, 
    -0.04989551f, 0.02158278f, 0.00271770f, -0.02248868f, -0.05890336f, -0.03376856f, -0.05201561f, -0.01892477f, 
    -0.00146200f, 0.02258310f, 0.01804505f, 0.04227014f, -0.03629823f, 0.02740511f, 0.03920421f, -0.03510173f, 
    0.01285095f, 0.03145168f, -0.03399593f, 0.03275558f, -0.00835488f, 0.01403803f, -0.01083268f, 0.03528318f, 
    -0.05499496f, 0.02579433f, 0.01772174f, -0.02462329f, -0.02917219f, 0.00608632f, 0.00648373f, 0.02144601f, 
    0.02214440f, 0.03549732f, 0.00932180f, -0.04681446f, -0.02914161f, -0.02151069f, 0.00154372f, -0.05342546f, 
    0.03721474f, -0.04226231f, 0.02655648f, -0.02224399f, -0.03466864f, -0.00535219f, -0.00681587f, -0.03176228f, 
    0.02404520f, 0.03308121f, -0.03908387f, 0.01517420f, 0.03154244f, -0.04644017f, -0.03725025f, 0.02748124f, 
    -0.04484646f, -0.02168859f, -0.03890574f, 0.01158737f, 0.04082921f, 0.02316048f, -0.00389298f, -0.00373324f, 
    -0.03839219f, -0.04687839f, 0.02617020f, -0.00485155f, 0.05136343f, -0.02561751f, -0.05262817f, -0.03241891f, 
    0.00122024f, 0.02400909f, 0.03308585f, -0.02279151f, 0.03413435f, 0.00078476f, 0.02569473f, 0.00767783f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01499318f, -0.02749822f, 0.06440811f, 0.06025036f, -0.02242214f, 0.10983004f, 0.09654083f, 0.15534562f, 
    0.17437136f, 0.13276114f, -0.00332516f, -0.02838698f, 0.04173096f, 0.23031837f, -0.12869634f, 0.00954155f, 
    0.00407147f, 0.01452077f, -0.00587503f, 0.22974531f, 0.00860390f, -0.02980836f, 0.08242852f, -0.10134408f, 
    0.10043672f, -0.15367216f, 0.03728316f, -0.04249521f, 0.16666365f, 0.02222537f, 0.18797177f, 0.01477598f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.09453209f, 0.09762965f, -0.55351591f, -0.36309618f, 0.05685418f, 0.01231915f, -0.43099269f, 0.15014517f, 
    -0.11110195f, 0.03629908f, 0.13747680f, -0.11591001f, -0.41722077f, -0.31838176f, 0.37730646f, -0.12011367f, 
    -0.03617229f, -0.00421234f, -0.02759733f, -0.51688987f, 0.25737256f, 0.00713387f, -0.50206280f, 0.22333826f, 
    -0.54059869f, 0.05782502f, -0.12758628f, -0.09078345f, 0.23749760f, 0.15556358f, 0.13728794f, 0.13358004f, 
    -0.02560666f, -0.11922383f, 0.27902359f, 0.08930048f, 0.03865097f, 0.32170230f, -0.34286898f, 0.13314512f, 
    0.42538431f, 0.16683757f, -0.06782511f, 0.10387422f, -0.00569692f, 0.12959976f, 0.23149954f, -0.16636552f, 
    -0.12255743f, 0.04218291f, -0.08441812f, 0.08467841f, 0.30094898f, 0.13714881f, -0.42997292f, -0.76692069f, 
    -0.58120453f, -0.12414104f, -0.17183281f, 0.06121539f, -0.25403249f, -0.12392963f, 0.42711365f, -0.04326075f, 
    0.09853866f, -0.05744393f, 0.28639522f, 0.05422057f, 0.16784336f, -0.27492917f, 0.24754186f, -0.47543561f, 
    -0.82643342f, 0.20469995f, 0.06006068f, 0.08066554f, -0.39545000f, -0.02106979f, 0.04161588f, -0.06939598f, 
    -0.10815758f, 0.20695712f, 0.08437856f, -0.10408370f, 0.40619531f, 0.00972209f, 0.10056221f, 0.03664718f, 
    0.36418048f, -0.68744522f, -0.01799526f, -0.18112077f, -0.02673498f, -0.11771943f, -0.44669405f, -0.09671560f, 
    0.03521904f, 0.07856494f, 0.45604131f, 0.12723538f, 0.08597085f, -0.43427697f, -0.41255972f, -0.04503880f, 
    -0.10917023f, -0.63194847f, 0.05049600f, 0.17040296f, -0.17757812f, -0.51488179f, 0.11539683f, -0.06496220f, 
    0.07194231f, 0.04663104f, 0.15532200f, -0.41334689f, 0.20236464f, 0.10181841f, -0.11557218f, 0.11788951f, 
    0.24423668f, 0.29426888f, 0.08246764f, 0.03880455f, -0.32354814f, -0.08100564f, -0.81510365f, -0.11676069f, 
    -0.14538413f, -0.13963746f, -0.26981679f, 0.11049989f, 0.03849220f, 0.17102021f, 0.38883185f, -0.24103589f, 
    -0.27366754f, 0.09794682f, -0.02753138f, 0.01267556f, 0.30339140f, -0.51063603f, 0.17363904f, -0.14072989f, 
    0.12466177f, -0.09211229f, -0.11947097f, -0.42362997f, -0.38271046f, -0.04546089f, -0.19895172f, 0.12587984f, 
    0.08348844f, 0.23335896f, -0.15409707f, 0.07553356f, -0.21269558f, -0.01249683f, -0.16882543f, 0.01913819f, 
    0.07989210f, 0.15324862f, -0.65622091f, -0.23183833f, 0.05999866f, 0.04936869f, 0.44872302f, 0.33362859f, 
    0.02183676f, -0.42151365f, -0.07470560f, -0.13827434f, 0.19523463f, -0.31956181f, 0.09739681f, -0.03870157f, 
    -0.01439240f, 0.22154079f, -0.04355114f, 0.33356789f, 0.07484295f, -0.08017253f, 0.05955966f, -0.42552534f, 
    -0.08688650f, -0.01723300f, 0.02250134f, 0.15298240f, 0.11572771f, -0.13728900f, 0.08602782f, -0.14706743f, 
    0.01993829f, 0.14199553f, 0.12341835f, 0.14238819f, 0.10346689f, -0.30443785f, -0.26479638f, -0.85157096f, 
    -0.00330792f, -0.25153333f, 0.05440334f, 0.12392299f, 0.03535085f, 0.48440436f, -0.56850356f, 0.06062685f, 
    -0.15566030f, 0.28937674f, 0.01695764f, 0.09252979f, -0.26973751f, 0.01375221f, -0.14520909f, 0.26827502f, 
    0.09689221f, -0.60856342f, 0.14378296f, -0.00496093f, 0.44308177f, -0.07090908f, -0.34562728f, 0.10957801f, 
    0.14129364f, 0.08950067f, -0.17942032f, -0.66698283f, 0.07450555f, 0.06631191f, 0.34237352f, -0.28730306f, 
    -0.23429836f, 0.03029718f, 0.13751516f, 0.03274649f, 0.37229672f, 0.11423866f, -0.57205141f, 0.00194304f, 
    0.16845429f, -0.01759550f, -0.13501310f, -0.31226462f, 0.45447567f, -0.06052009f, 0.28278282f, 0.05939551f, 
    -0.50696087f, 0.55693215f, -0.05930600f, 0.11833283f, -0.63708776f, 0.15135875f, -0.06389642f, -0.10482486f, 
    0.17512204f, -0.13032508f, 0.27963775f, 0.19581673f, 0.16615258f, -0.45843512f, 0.01574429f, 0.22759464f, 
    -0.13930941f, 0.27556938f, -0.09720971f, -0.01018197f, -0.44168949f, -0.21898067f, -0.70907849f, 0.16101202f, 
    -0.04058907f, 0.13466337f, -0.02333252f, 0.36012894f, 0.24042244f, -0.11799014f, 0.30343431f, -0.49334645f, 
    -0.87748265f, 0.15381312f, 0.15968126f, -0.14542460f, 0.41054028f, -0.16797712f, -0.39122427f, -0.08025247f, 
    -0.10461637f, 0.13994786f, -0.85377407f, 0.20546430f, 0.03203230f, -0.41918990f, 0.23931484f, -0.18847889f, 
    0.13368255f, 0.44256827f, 0.08337549f, -0.10189415f, 0.19972758f, 0.31261554f, -0.04134777f, -0.03729562f, 
    0.13058601f, -0.37381476f, -0.14153865f, -0.10361353f, -0.11697385f, -0.02260429f, -0.20694377f, 0.32959998f, 
    0.24911273f, -0.05309945f, -0.04918721f, -0.02787925f, -0.50677878f, -0.05737691f, 0.25853953f, -0.01952795f, 
    0.09469337f, 0.14704946f, 0.47387210f, 0.44651946f, 0.08827344f, 0.24565104f, -0.50134337f, 0.09579670f, 
    -0.36232981f, -0.64409488f, 0.02042788f, 0.12016929f, 0.18676178f, -0.06266310f, -0.09500757f, 0.02094933f, 
    -0.03604414f, -0.57581264f, 0.05142204f, -0.02293004f, -0.02711480f, 0.14311290f, 0.39453962f, -0.60384625f, 
    0.16791055f, -0.02550363f, 0.12768345f, -0.08281039f, 0.46232218f, 0.06508547f, -0.32314929f, -0.11780187f, 
    0.08014055f, 0.00382548f, 0.44316003f, -0.03781556f, -0.00998474f, -0.40883875f, -0.49312717f, 0.28647965f, 
    -0.53002661f, -0.09021105f, 0.06297646f, -0.10995550f, -0.22732069f, 0.22712246f, -0.13994768f, -0.03712657f, 
    0.11277777f, 0.13120382f, -0.18158619f, -0.02261374f, -0.66821504f, -0.04832910f, 0.34970516f, 0.04976696f, 
    -0.01977719f, -0.07261750f, 0.10051282f, -0.19205181f, -0.29847848f, -0.03046496f, 0.47126827f, -0.05794799f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.16236655f, -0.08581801f, 0.40740895f, -0.29727504f, -0.05196475f, 0.16874661f, 0.06877352f, -0.26687369f, 
    0.10777506f, 0.09030860f, -0.02295741f, -0.17163476f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
