#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.56830186f, 0.89034396f, -0.57185429f, -1.09600461f, -0.29968977f, -0.24855964f, 0.56058788f, 0.27470535f, 
    -0.06056326f, 0.35693505f, -0.41748065f, -0.18388441f, -0.37998256f, -0.56614959f, -0.04750711f, 0.19407240f, 
    0.23196872f, -0.52034134f, -0.20569129f, -0.76207691f, -0.40112990f, -0.48654920f, -1.07424712f, -0.76203060f, 
    -0.91927803f, -0.20054585f, -0.37059680f, 0.25954849f, 0.81514251f, -0.12659998f, 0.53220034f, 0.03454193f, 
    0.16356488f, -0.19534104f, 0.02726914f, -0.52466381f, 0.07929146f, 0.15517806f, -0.20962153f, 0.25020385f, 
    -0.16423009f, -0.31555673f, 0.11664318f, -0.17628194f, -0.05287572f, -0.45535380f, 0.35160252f, 0.55269355f, 
    0.23036245f, 0.37360817f, 1.40635884f, -0.99352127f, -1.61940753f, -1.16973329f, -1.28962386f, 1.00709200f, 
    0.36979976f, 0.71936858f, -0.02733389f, -0.38608205f, -0.45212251f, 0.31762168f, 0.20423225f, -0.18713695f, 
    0.00248798f, -0.13448425f, -0.17078596f, 0.47622764f, -0.43876323f, 0.00072397f, 0.13255729f, -0.34336537f, 
    -0.30174989f, 0.30397639f, -0.24554706f, -1.69836509f, -0.71816212f, -0.21082701f, -0.40365949f, 0.14589782f, 
    -0.03533427f, -0.09541738f, 1.47388387f, -0.62781864f, -0.79306734f, -0.73253608f, -0.19602259f, -0.33619529f, 
    0.38017133f, 0.01466441f, 0.68064284f, -0.12196682f, 0.14556311f, 0.42064556f, 0.45030805f, 0.26751426f, 
    0.05210835f, -0.02657523f, 0.10063174f, -0.33198231f, -1.53310919f, -0.23916163f, 0.21114369f, -1.03736246f, 
    -0.81194943f, -0.40098050f, -1.08460855f, -1.69235086f, -1.18399167f, -0.64755058f, -0.28679892f, -0.29790547f, 
    -0.46623147f, -1.15877831f, -0.54318547f, -0.08078158f, -0.40123409f, -0.33704486f, -0.36037853f, -0.33252800f, 
    0.01791075f, -0.07586191f, 0.00988473f, 0.06030819f, 0.09871092f, -1.08767962f, -1.43766916f, -1.34029591f, 
    0.00200784f, 0.97680676f, -0.09789979f, 0.22226986f, 0.51879221f, 0.50223297f, 0.33895537f, 0.61159158f, 
    0.30566984f, 0.05736038f, -0.06676047f, 0.09738068f, 0.35893017f, 0.18247364f, -0.19969088f, 0.04806780f, 
    -0.20668490f, -0.16914092f, -0.21052073f, -0.03478732f, -0.20825812f, -0.19781226f, 0.60918528f, -0.14296874f, 
    0.54899269f, 0.44596547f, 0.60928518f, -0.28336647f, -0.61541748f, -0.58628404f, -0.49174714f, -0.06947906f, 
    -0.38633528f, 0.06317338f, 0.19925034f, 0.00137366f, 0.15875207f, -0.07929394f, -0.59495080f, 0.14315693f, 
    0.45986104f, 0.19804522f, -0.32716221f, 0.28419855f, -0.00113553f, 0.22584128f, 0.22118388f, 0.50731552f, 
    0.72528774f, 0.55483222f, -0.64098358f, -0.47402859f, -0.26336831f, 0.28567055f, -0.04485006f, -0.03600800f, 
    0.20483874f, 0.39653185f, 0.71758193f, -0.25998327f, 0.37209973f, -0.75555879f, -0.32588866f, 0.09675103f, 
    -0.01127037f, 0.38463658f, -0.10704766f, -0.02567319f, 0.42442045f, 0.12855287f, -0.06268213f, 0.06740099f, 
    -0.31643379f, -1.43582022f, -0.62116265f, -0.28824663f, 0.22890966f, 1.07519507f, 0.35216430f, -0.80573398f, 
    -0.53335172f, 0.94809765f, -0.02675892f, -0.42406943f, -0.33542785f, 0.25574094f, 0.02561271f, -0.01306161f, 
    -0.44038144f, -0.15298915f, 0.11396795f, -1.15297055f, 0.32999805f, -0.25732955f, 0.17481412f, -0.07520066f, 
    0.20636277f, 1.28702402f, 0.94877821f, 0.21299088f, -0.49778530f, -1.12753797f, -0.92966288f, -0.88110590f, 
    -0.57124150f, -0.99798167f, -1.65891445f, 0.00575194f, 0.59041905f, -0.55692375f, -0.21038976f, 0.42014286f, 
    0.05566804f, 0.33207166f, 0.07828959f, -0.12273252f, 0.14547744f, -0.11365495f, -0.09902031f, 0.04263287f, 
    0.00689702f, -0.26259375f, 0.68185771f, -0.06719401f, -0.88382357f, -0.86763674f, -0.38701564f, 0.54903769f, 
    -0.23329237f, -0.17597033f, -0.14310738f, -0.26037601f, 0.36353362f, -0.67067593f, -0.16421503f, -0.29386467f, 
    0.37234077f, -0.36157277f, 0.17699613f, -0.07417606f, -0.23457979f, -0.33780453f, 0.05598841f, 0.36709344f, 
    0.66363972f, 0.21753366f, 0.61093110f, -0.13975443f, 1.24955428f, 0.93241256f, -0.74795538f, -0.07964453f, 
    -1.09030640f, -0.34782010f, 0.23079742f, 0.12084837f, -0.03412051f, -0.55991113f, 0.09583233f, -0.21910463f, 
    0.47357720f, -0.40720651f, 0.18172139f, 0.07482544f, -0.00767224f, 0.30197194f, -0.08075000f, -0.21160769f, 
    0.27743787f, 0.11563406f, -0.30828571f, 0.12383170f, 0.45680490f, 0.20841403f, -0.22145690f, -0.01581953f, 
    0.06079900f, 0.46165496f, 0.46710473f, 0.14148432f, 0.20603360f, 0.10345187f, 0.09082866f, 0.13408960f, 
    -0.14868896f, 0.02481145f, 0.32836816f, 0.34561428f, 0.09745124f, -0.77218890f, -0.44461381f, -0.17144333f, 
    -0.20055030f, 0.07274280f, -0.30514139f, 0.19032283f, 0.06049860f, 0.78655291f, 0.80767584f, 0.42967483f, 
    0.04071480f, 0.55426002f, -0.15000688f, 0.24678135f, -0.12455741f, -0.44827500f, -0.25599012f, -0.03380083f, 
    0.56075549f, 0.02709267f, -0.30470288f, -0.39310905f, -0.24819700f, -0.08392019f, 0.04985390f, -0.13038942f, 
    0.13240784f, -0.03061870f, 0.20855199f, -0.12624969f, -0.27178195f, -0.42779770f, 0.24423675f, -1.16249001f, 
    -0.58062035f, 0.05483054f, 0.21037552f, -0.38836020f, 0.91738981f, 0.56897599f, 0.44575810f, -0.52947217f, 
    -0.13895553f, 0.25790155f, 0.26568827f, 0.03026257f, -0.31797764f, -0.52625960f, -0.37894753f, 0.46225896f, 
    -0.02922894f, 0.64587075f, 0.03803043f, 0.01053198f, -0.37108916f, -0.16315177f, 0.32004669f, 0.87572962f, 
    0.28110206f, 0.36044386f, 0.10856469f, 0.13714910f, -0.27308908f, 0.17033677f, 0.23936659f, -0.21010274f, 
    -0.17697762f, 0.05783516f, 0.04598694f, -0.36900035f, -0.09820929f, -0.24217629f, -0.41072422f, -0.23286013f, 
    0.23114602f, -0.19147187f, -0.10069711f, 0.65855980f, -0.58926529f, -0.55304778f, 0.44970271f, -0.21283872f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12913592f, 0.32358387f, 0.49680325f, 0.28407553f, -0.08275001f, 0.10498647f, 0.54153055f, 0.45592895f, 
    0.81422168f, 0.30827576f, 0.08766554f, 0.55219805f, 1.00668681f, 0.07600231f, 0.52905726f, 0.51034808f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.12854706f, 0.06953373f, -0.07053946f, 0.01728337f, 0.00716969f, 0.11178349f, -0.11747438f, -0.13684882f, 
    -0.00841794f, 0.02175761f, 0.10108931f, 0.05199704f, -0.15396078f, -0.01787343f, 0.07499560f, -0.04824587f, 
    0.04559595f, 0.00305128f, 0.03852490f, 0.03429901f, -0.09647989f, -0.05730675f, 0.03613354f, -0.01900924f, 
    0.24713321f, -0.23556229f, -0.57705957f, 0.02580238f, 0.12139596f, 0.16559258f, -0.13810885f, -0.09917436f, 
    0.00042505f, -0.09251154f, -0.02095535f, 0.09990375f, 0.53933680f, -0.01372643f, 0.09070217f, -0.26919317f, 
    0.15695412f, 0.51782203f, 0.21879554f, -0.09108655f, -0.02111656f, 0.08261744f, 0.03763261f, 0.13126090f, 
    0.48813868f, 0.65750301f, -0.30397442f, -0.32920647f, 0.06990870f, 0.27651170f, 0.11188840f, 0.20408617f, 
    -0.06543051f, -0.17070132f, -0.07825861f, -0.12051339f, 0.40930879f, 0.30104449f, 0.03745407f, -0.03959888f, 
    0.17711139f, 0.20566438f, 0.18219632f, -0.01946006f, -0.12785690f, 0.06226796f, -0.00126325f, 0.12501967f, 
    -0.25586227f, 0.41018841f, -0.08119231f, -0.23700863f, 0.00347080f, -0.10333293f, -0.11289228f, -0.10567927f, 
    -0.09109897f, 0.05152871f, -0.05870581f, -0.08224077f, -0.16530815f, -0.22274584f, -0.06439744f, 0.30776590f, 
    -0.17293493f, -0.00333605f, 0.08642290f, 0.00660757f, -0.27551985f, -0.14844492f, -0.06812476f, -0.24440880f, 
    0.37240097f, 0.05596188f, -0.28421804f, -0.11638582f, -0.04279774f, 0.00137015f, 0.06297756f, -0.64533383f, 
    -0.02451320f, -0.07335370f, -0.10501505f, -0.10814720f, 0.34148625f, -0.18325602f, -0.06405429f, -0.12551650f, 
    -0.00366104f, 0.05138956f, -0.07029171f, 0.08601334f, 0.02819958f, 0.15470460f, -0.02807703f, -0.01124796f, 
    0.31622753f, -0.00432933f, -0.31230083f, -0.05171395f, -0.06923507f, 0.22570124f, -0.40733552f, -0.27815691f, 
    -0.08896263f, -0.03828298f, 0.03127315f, 0.06264421f, -0.27732581f, 0.24865882f, 0.06018622f, -0.03951099f, 
    -0.04865748f, 0.00784859f, -0.33222142f, -0.16515434f, -0.02894692f, -0.02685983f, -0.09953652f, -0.10290796f, 
    -0.92545921f, -0.84887075f, -0.37095729f, 0.19923964f, -0.07117567f, -0.00474905f, 0.00120403f, 0.00913668f, 
    -0.25125083f, 0.03592072f, -0.41547313f, -0.41574407f, -0.43922848f, -0.24548118f, -0.72558159f, 0.55941027f, 
    0.16230428f, 0.10770550f, 0.10077132f, -0.02488427f, -0.01469800f, 0.03456986f, 0.21197958f, 0.03701765f, 
    0.38056767f, 0.06441715f, -0.35821763f, -0.13072777f, -0.04745331f, -0.27105254f, -0.00559028f, -0.26532158f, 
    -0.04297970f, -0.24728528f, -0.17516331f, -0.39110678f, -0.71926868f, -0.83894175f, -0.70200682f, 0.39562774f, 
    0.03444842f, 0.12428630f, -0.03293944f, 0.01800756f, -0.02453176f, -0.02150281f, 0.02333377f, 0.11098532f, 
    -0.12061779f, -0.19988716f, 0.26729161f, -0.05434152f, 0.09199491f, -0.00588560f, -0.19958256f, -0.04223564f, 
    -0.39025557f, -0.12095013f, -0.60178149f, -0.25897098f, 0.03285865f, -0.00924747f, 0.07098889f, 0.25673646f, 
    -0.11879602f, 0.11233591f, 0.00283310f, 0.07435483f, -0.11798569f, 0.05260006f, 0.05326163f, -0.00050542f, 
    0.98100978f, -0.11724330f, 0.11152017f, -0.30543095f, -0.09713084f, 0.15749639f, 0.18055633f, -0.13118532f, 
    0.06557807f, -0.07599361f, -0.04644480f, -0.13158716f, -0.38232854f, -0.04210398f, 0.42786387f, 0.29264206f, 
    -0.05824235f, -0.01735060f, -0.24031770f, -0.17404999f, -0.01269554f, 0.00298136f, -0.03137219f, -0.14789058f, 
    0.12656553f, 0.24074534f, 0.03182988f, 0.34275603f, -0.03931886f, 0.25265226f, -0.25041714f, 0.18282436f, 
    0.03020381f, 0.04738845f, 0.00811806f, 0.09781947f, -0.32902423f, -0.24685982f, -0.25915152f, 0.01074435f, 
    0.00854563f, 0.13638557f, 0.10164908f, -0.10008795f, -0.03178346f, 0.02188264f, 0.00465313f, 0.05952166f, 
    0.29698020f, 0.03209912f, -0.13906974f, 0.06982977f, -0.20422320f, 0.02865755f, -0.14406615f, -0.26753742f, 
    -0.03710299f, 0.04314116f, 0.05888874f, -0.02261003f, 0.19748142f, -0.16557159f, 0.19303140f, -0.05359151f, 
    0.22419819f, -0.17544021f, -0.07375735f, 0.17661592f, 0.14707814f, -0.04573576f, 0.00787415f, 0.10823831f, 
    0.31599882f, -0.41602483f, -0.23491850f, -0.26184586f, 0.12068636f, -0.02345670f, -0.05991074f, 0.11269902f, 
    0.08487426f, -0.15055004f, -0.03406077f, -0.15750274f, 0.21366924f, -0.41935343f, -0.42130321f, -0.70559394f, 
    -0.28347668f, -0.28371751f, -0.17646839f, -0.01643266f, -0.13330391f, 0.02317408f, -0.09423617f, 0.11147698f, 
    0.27436739f, 0.27113479f, 0.17814623f, -0.18964592f, -0.06662457f, -0.08539991f, 0.22619618f, 0.20230103f, 
    -0.20966011f, 0.14903061f, 0.02147751f, -0.19337167f, 0.20468423f, -0.44172999f, 0.04397588f, -0.24046500f, 
    -0.10205805f, -0.14214830f, -0.10157567f, 0.02257695f, -0.08093949f, 0.06956295f, -0.02313790f, 0.05609911f, 
    0.35834876f, 0.03489591f, 0.22211976f, 0.29886761f, 0.02799894f, -0.05773206f, 0.06506006f, 0.05253347f, 
    -0.16305730f, -0.04743225f, -0.01398545f, -0.14896685f, 0.19844814f, 0.16797815f, 0.18305501f, 0.12164031f, 
    0.01284519f, -0.13016954f, -0.14251362f, 0.05165414f, -0.14195208f, -0.01548417f, -0.02164415f, 0.00541549f, 
    0.24471334f, -0.08234402f, -0.31616688f, 0.10993781f, 0.04315464f, -0.03137541f, 0.20867890f, -0.47308272f, 
    0.04131770f, 0.10877623f, 0.15929534f, -0.02827353f, 0.57203072f, 0.48174959f, 0.59134477f, 0.38963920f, 
    -0.00776105f, -0.07632149f, 0.04822212f, 0.00499189f, 0.09287449f, -0.18194342f, 0.11931223f, 0.03778435f, 
    0.22872636f, -0.19559485f, 0.34404129f, 0.15609011f, -0.02239128f, -0.16115120f, 0.15387866f, -0.12880287f, 
    0.13019352f, 0.25917587f, 0.01361765f, 0.27999735f, -0.06401256f, 0.11425488f, -0.29859883f, -0.08619851f, 
    -0.02630610f, -0.04160944f, 0.13683000f, 0.07872889f, -0.05531118f, -0.10683202f, 0.07645820f, -0.20307188f, 
    -0.28690532f, 0.76780361f, 0.82622194f, -0.04707069f, -0.08574139f, -0.11417216f, 0.23113303f, -0.13792747f, 
    0.07599893f, 0.11008004f, -0.03697929f, -0.06198436f, -0.16689026f, -0.13579144f, 0.22382843f, 0.26968151f, 
    0.05280304f, -0.16626363f, 0.22925375f, 0.12703805f, -0.02388427f, 0.05423542f, 0.03142027f, 0.00388595f, 
    -0.82991606f, -0.28795740f, -0.09260304f, -0.28042477f, -0.14225978f, 0.02514010f, 0.00016862f, 0.06887691f, 
    -0.10987279f, -0.00184219f, -0.10574991f, -0.09837084f, 0.17192626f, 0.03733648f, 0.22762300f, 0.23118094f, 
    0.04425548f, 0.01958355f, 0.12623154f, 0.06737416f, 0.00821000f, -0.09843604f, -0.11883411f, 0.28429237f, 
    -0.39268821f, 0.20829967f, 0.05018944f, -0.16213576f, -0.15054299f, 0.18534383f, 0.02150176f, 0.09820392f, 
    -0.01869385f, -0.02846763f, 0.03918980f, -0.20229259f, 0.00216842f, -0.20782931f, -0.15423268f, -0.24120589f, 
    0.05895262f, -0.23721941f, -0.22297980f, 0.22539423f, 0.05818926f, -0.16924466f, 0.09991774f, 0.06608218f, 
    -0.26706865f, -0.13723935f, 1.09469211f, 0.50364137f, 0.20100322f, 0.08933596f, -0.04933354f, 0.10064846f, 
    -0.07563294f, -0.34362882f, 0.12098224f, -0.21965332f, -1.24163556f, -0.34669125f, 0.14625260f, -0.38577098f, 
    -0.01271290f, -0.12421591f, -0.34425080f, -0.58899814f, 0.11205520f, -0.01461816f, -0.14516614f, 0.10003480f, 
    -0.40247470f, -0.10361307f, 0.14182150f, -0.20106351f, -0.10738808f, 0.11710049f, -0.05402911f, -0.20227462f, 
    -0.08570171f, -0.03889706f, -0.20513472f, 0.02656866f, 0.16903713f, -0.47792917f, 0.23509006f, -0.17188211f, 
    -0.20133530f, 0.07608679f, -0.12403076f, 0.17426243f, 0.00795981f, -0.14576083f, 0.03058509f, 0.04987870f, 
    0.15503031f, -0.32504797f, 0.11352462f, 0.00757468f, -0.02702570f, 0.05177206f, 0.02790192f, 0.03889040f, 
    0.06374939f, 0.01301598f, -0.24550606f, 0.45138866f, -0.12885964f, -0.23911987f, 0.23701541f, -0.85316426f, 
    -0.03415870f, -0.18969388f, -0.07714513f, 0.06404623f, 0.09586447f, -0.09631314f, -0.05366241f, 0.02099243f, 
    -0.12889461f, 0.17610498f, 0.10304026f, 0.09930725f, -0.08094575f, 0.06954642f, -0.01170592f, 0.11441936f, 
    0.23582853f, 0.10215988f, 0.15459545f, -0.49992114f, -0.25674346f, 0.07920089f, 0.17388073f, -0.14036067f, 
    -0.03006355f, -0.04280194f, 0.12767169f, 0.15098868f, 0.01851674f, 0.03574127f, -0.02391175f, 0.03357781f, 
    0.52547175f, -0.24838109f, -0.19344944f, 0.09607330f, 0.09516655f, -0.01928072f, 0.05777088f, -0.11667126f, 
    -0.29382730f, 0.12796906f, -0.06977480f, 0.12808354f, 0.16731966f, 0.63407123f, 0.05774986f, -0.40188256f, 
    0.23142868f, -0.19703437f, -0.13982095f, 0.38229004f, -0.54426146f, -0.09575360f, -0.24518326f, -0.06887889f, 
    -0.27577078f, -0.08353512f, 0.08071247f, 0.56463563f, 0.18498074f, 0.16541828f, 0.12255815f, -0.13053779f, 
    -0.00824461f, 0.05774240f, 0.33277553f, 0.20795225f, 0.42074284f, 0.41323805f, -0.40911135f, -0.06643263f, 
    -0.00058234f, -0.04916156f, -0.16765510f, -0.12454872f, -0.01961614f, -0.14858668f, 0.03244393f, 0.08482408f, 
    0.11667693f, -0.53714395f, 0.03750425f, 0.27613890f, -0.01313826f, 0.06003441f, 0.08848698f, 0.01647137f, 
    -0.15772755f, 0.05411180f, -0.17011832f, 0.10251840f, -0.04134789f, 0.42786673f, -0.52383047f, -0.09443399f, 
    0.27896503f, -0.05747939f, 0.24791001f, -0.22331542f, -0.20516282f, 0.15567036f, -0.17419532f, 0.09031620f, 
    -0.50574708f, -0.11383391f, 0.06155261f, 0.32445881f, -0.08472152f, -0.08835143f, -0.17731084f, -0.28214166f, 
    0.02056187f, 0.02576816f, 0.06661189f, -0.15504344f, -0.14042449f, 0.12899391f, -0.64173424f, 0.22084290f, 
    -0.06740689f, 0.12652390f, -0.57714027f, -0.15263633f, -0.22964105f, 0.20270348f, -0.11536691f, -0.20041658f, 
    -0.15118830f, 0.19929801f, -0.19534734f, 0.14131843f, 0.24032909f, 0.10183849f, -0.05242040f, -0.25039631f, 
    -0.18006854f, -0.10191989f, 0.03423816f, 0.02604175f, -0.13643339f, -0.63879853f, 0.43272382f, 0.30101800f, 
    0.00568134f, 0.11276269f, 0.18290682f, 0.17038992f, 0.13689041f, -0.17638120f, -0.16124752f, 0.04943050f, 
    -0.05300685f, 0.07095736f, -0.02947481f, 0.49623331f, 0.03526879f, -0.10068338f, -0.13457875f, -0.48905441f, 
    0.33180019f, 0.24209686f, 0.15131286f, 0.14371628f, 0.65651250f, -0.08282541f, 0.59040588f, -0.57933313f, 
    -0.42893821f, -0.08142770f, -0.36681893f, 0.08226752f, 0.11364263f, -0.20125939f, 0.29883227f, -0.17949739f, 
    -0.35082939f, 0.30270010f, -0.66851902f, -0.03942580f, 0.09194054f, -0.05107766f, 0.17889576f, 0.11377083f, 
    -0.19401245f, 0.01834026f, -0.07161330f, -0.15294504f, -0.53840661f, 0.08395866f, 0.42211530f, -0.02847752f, 
    -0.37899306f, -0.31563076f, -0.08831023f, 0.13958991f, 0.31083104f, 0.07663229f, -0.13986367f, 0.18178155f, 
    0.16959186f, 0.51193285f, -0.32925865f, -0.14939554f, 0.28656134f, -0.00311492f, -0.17685749f, 0.02038728f, 
    -0.13786621f, 0.08408915f, 0.02473529f, -0.17465384f, -0.56518316f, 0.26157400f, 0.10399394f, -0.10896561f, 
    -0.29100481f, -0.29433206f, 0.15220866f, -0.17565124f, 0.04977364f, 0.18204656f, -0.10523274f, -0.08652241f, 
    -0.02519479f, 0.00471742f, -0.20281029f, -0.02840547f, -0.00301309f, -0.18047284f, 0.17100157f, -0.09582265f, 
    0.19732928f, -0.05418479f, 0.13968971f, 0.26698351f, 0.07049152f, -0.21556824f, -0.00577073f, 0.13394707f, 
    0.05430924f, 0.11551318f, 0.03492124f, 0.06475834f, -0.13732186f, -0.08893955f, -0.01389907f, -0.16857608f, 
    -0.21791422f, 0.12543733f, 0.33673531f, 0.15697043f, -0.14085725f, -0.31188095f, -0.10334586f, -0.34810504f, 
    -0.11662482f, 0.00694630f, 0.06368475f, 0.17669018f, -0.30929533f, -0.17095770f, 0.18151359f, -0.03468323f, 
    -0.40190765f, -0.22035547f, -0.16672762f, -0.10048804f, 0.01348835f, 0.10271418f, -0.05082308f, 0.16197956f, 
    -0.02175460f, 0.05507639f, 0.12359657f, 0.23802009f, 0.04616781f, -0.14151198f, -0.01154183f, -0.14290985f, 
    -0.00524400f, -0.14130083f, 0.08293749f, 0.09001278f, 0.22300522f, -0.29266906f, 0.08181909f, 0.17304672f, 
    -0.20247088f, 0.09874074f, -0.18499851f, 0.15648036f, 0.01354099f, -0.15048856f, -0.06227644f, 0.02396684f, 
    -0.07221805f, -0.06051663f, 0.32595918f, 0.17977230f, -0.08232620f, 0.21558341f, 0.43252009f, 0.36051339f, 
    -0.01454997f, -0.02858729f, 0.00476209f, -0.02844231f, 0.03262398f, 0.03169543f, -0.13722901f, 0.02813137f, 
    0.30046833f, 0.34687912f, 0.19330068f, -0.25144443f, 0.09064003f, -0.12105801f, -0.16691826f, -0.15199372f, 
    0.16185467f, 0.02537397f, -0.38806820f, 0.11247990f, -0.24185576f, -0.14715932f, -0.16602692f, -0.03043799f, 
    -0.00255177f, 0.00721377f, -0.11685943f, -0.03707926f, 0.26715019f, 1.12008631f, -0.01980719f, 0.32178143f, 
    0.27574605f, 0.34452838f, 0.13171875f, 0.02628836f, 0.05763144f, -0.06171506f, 0.10294347f, -0.24844801f, 
    0.01181628f, -0.03275924f, -0.08087359f, -0.10244200f, 0.12791340f, -0.11079416f, -0.09481188f, 0.18180321f, 
    0.02645261f, 0.02922291f, 0.11557782f, 0.03495301f, 0.09505541f, -0.09199800f, -0.49649537f, 0.40862638f, 
    0.11268450f, -0.12674370f, 0.01847052f, -0.24104233f, 0.13126591f, -0.16073194f, -0.07601047f, -0.23375265f, 
    -0.14720809f, -0.36516139f, -0.02573403f, -0.15082097f, 0.03016325f, 0.05363949f, -0.03250785f, 0.03297575f, 
    0.04796138f, -0.28695235f, 0.01430016f, -0.11735521f, 0.19593708f, -0.14048865f, -0.28962693f, 0.20199983f, 
    0.11200419f, 0.06431753f, 0.27282089f, -0.10088725f, 0.15438332f, 0.07811777f, 0.13212025f, -0.03421339f, 
    -0.32136124f, -0.63094151f, 0.27947524f, -0.05637900f, -0.28593180f, 0.03558630f, -0.15076171f, 0.19615039f, 
    0.13947752f, -0.18411972f, -0.31858468f, -0.25141546f, -0.29091635f, -1.13282895f, -0.66123444f, -0.04646582f, 
    0.14955275f, 0.00311733f, -0.09611024f, 0.03950199f, 0.11779349f, 0.05804474f, 0.01173109f, -0.00541410f, 
    -0.34077144f, 0.39520678f, -0.24236149f, -0.14483757f, -0.15712760f, 0.08900053f, 0.09649736f, 0.04994603f, 
    0.15444298f, -0.52443975f, -0.14199528f, -0.53394127f, 0.13485156f, -0.22701374f, 0.00584868f, -0.01679333f, 
    -0.00680722f, -0.20193596f, -0.17893934f, -0.10713726f, 0.20769507f, -0.00647478f, -0.24002922f, 0.20371559f, 
    -0.16484635f, 0.04719951f, -0.36870030f, -0.45273530f, 0.21191442f, 0.00131460f, -0.24925749f, 0.04686761f, 
    0.09053084f, -0.16913781f, -0.04841082f, -0.08509357f, -0.32485336f, 0.35294014f, -0.42308494f, -0.02707981f, 
    0.32070798f, -0.02843738f, 0.22953366f, 0.09257159f, 0.05975989f, -0.00669095f, 0.07423810f, -0.00763888f, 
    -0.10334597f, 0.33222020f, 0.42817211f, -0.16279058f, 0.22000699f, -0.04187834f, 0.11943033f, 0.17112727f, 
    0.09829385f, 0.01269051f, 0.06401751f, 0.02975435f, -0.24226755f, -0.14340556f, 0.04174738f, -0.22328904f, 
    0.12410917f, -0.13871647f, -0.06274832f, 0.11616234f, 0.03215766f, -0.21490946f, 0.08575211f, -0.13810632f, 
    -0.14543450f, -0.18244696f, 0.04099711f, -0.10778652f, 0.23285748f, -0.15200464f, 0.11074656f, -0.05333382f, 
    0.13586336f, 0.03168454f, -0.15871042f, 0.10758330f, -0.15205193f, 0.10525678f, -0.34163070f, 0.11535283f, 
    0.07210656f, -0.20113251f, -0.20824642f, -0.17958781f, -0.03653833f, 0.16586064f, 0.00780707f, 0.10347017f, 
    -0.46189320f, 0.00911613f, 0.40174189f, -0.56583774f, -0.03187498f, 0.00394599f, 0.10080663f, 0.21419361f, 
    0.10364295f, -0.03783032f, -0.10159231f, 0.19534373f, 0.15255331f, 0.24585031f, -0.18941812f, -0.04112671f, 
    -0.10020259f, -0.05455691f, -0.03623779f, 0.11544158f, -0.15942967f, 0.00933162f, 0.12095512f, -0.14645638f, 
    0.06457251f, -0.09630720f, -0.14032607f, -0.23188722f, 0.01366279f, 0.11028392f, 0.08970889f, -0.12080101f, 
    0.19079894f, 0.04355109f, -0.05767734f, 0.09410835f, -0.57308441f, 0.30995983f, -0.03006089f, 0.46309617f, 
    0.21819289f, -0.03787923f, 0.09795202f, 0.08534665f, 0.01079155f, 0.23432927f, 0.05690594f, 0.09971783f, 
    0.02804970f, -0.04927512f, -0.24121554f, 0.04032626f, 0.03305100f, -0.11344966f, 0.00015704f, -0.05290887f, 
    0.39750603f, 0.26343408f, -0.16841252f, 0.35850412f, -0.10618576f, -0.35674676f, -0.34274909f, 0.36909616f, 
    0.01590271f, -0.06347733f, -0.07113477f, 0.07050961f, 0.04807290f, -0.20454390f, 0.21247643f, -0.14842318f, 
    0.22948559f, -0.27527592f, -0.23573139f, 0.01512013f, -0.11839361f, 0.14865911f, -0.09827140f, 0.05511579f, 
    -0.07057004f, 0.09796252f, 0.16141716f, 0.49540034f, 0.06117226f, -0.34561598f, -0.47638974f, 0.04477105f, 
    0.09877090f, 0.12241163f, -0.00910461f, 0.12732457f, -0.09805963f, -0.07945377f, -0.06959918f, -0.03738424f, 
    0.00148167f, 0.04399069f, -0.10344426f, 0.07733429f, -0.16236736f, 0.06313856f, 0.19508825f, 0.28881764f, 
    0.03153105f, 0.24434707f, 0.34722963f, 0.28085747f, -0.24541202f, -0.18244042f, -0.06593500f, 0.08093416f, 
    -0.00722036f, -0.04438739f, -0.07118761f, 0.13721013f, -0.06624624f, -0.00118966f, 0.03992877f, 0.09866137f, 
    -0.47822341f, 1.07629204f, -0.01003527f, 0.24330373f, -0.00437217f, -0.19770029f, 0.01570329f, 0.14730820f, 
    0.10268442f, 0.15343894f, -0.04200020f, 0.07238070f, -0.97835732f, -1.24084949f, -0.14117499f, -0.22771622f, 
    0.02882680f, -0.02800446f, -0.01343226f, -0.33452457f, -0.06550626f, -0.03466144f, 0.00128059f, -0.05109987f, 
    -1.35591197f, -1.58732891f, -0.71819174f, -0.33659756f, -0.18814704f, -0.21143542f, -0.16064206f, -0.53310376f, 
    -0.02600983f, 0.03500513f, 0.11307884f, -0.16624631f, -0.51739585f, 0.47247291f, 0.26254976f, -0.04284921f, 
    -0.19183967f, 0.08236057f, -0.03070646f, 0.16012743f, -0.05626211f, -0.01398148f, 0.09379636f, -0.14577539f, 
    -0.11795354f, -0.57178599f, -0.25082424f, 0.53805476f, 0.12541784f, 0.25341561f, 0.16106650f, 0.03366848f, 
    0.00194210f, -0.20346530f, -0.10415087f, 0.14194389f, 0.46065822f, -0.16688333f, 0.06292295f, 0.06484350f, 
    0.02081624f, 0.11869963f, 0.10346824f, -0.16282773f, 0.04782682f, -0.09185666f, -0.20420967f, -0.25396091f, 
    -0.63266820f, 0.18569660f, 0.12090670f, -0.11239378f, -0.01830146f, -0.01115597f, 0.19922695f, 0.29615393f, 
    0.07777839f, 0.31820625f, 0.26370761f, 0.13118330f, 0.28993800f, -1.14043188f, -0.10644572f, -0.58330518f, 
    -0.00906100f, -0.06998973f, 0.21143928f, -0.60312843f, 0.16289409f, -0.05862755f, 0.06072649f, 0.12758055f, 
    -0.22936651f, 0.04256842f, 0.25369743f, -0.12863734f, 0.03865027f, -0.35853869f, 0.04099305f, 0.28383955f, 
    0.12194162f, -0.13537729f, 0.13940874f, -0.29016051f, 0.35842523f, -0.15256445f, -0.66909796f, -0.46969575f, 
    -0.25451496f, 0.26294297f, 0.24507672f, 0.08960401f, -0.09251230f, -0.11247790f, -0.10336417f, -0.03345830f, 
    0.22567022f, 0.35456666f, 0.05910989f, -0.14907742f, 0.08927149f, 0.05570828f, 0.02632489f, 0.13016272f, 
    0.01816694f, 0.09309392f, 0.51053059f, 0.02681699f, -0.13060132f, -0.39457059f, -0.17643294f, -0.04761578f, 
    0.01525645f, 0.13227001f, -0.12155818f, -0.06855650f, -0.05873106f, -0.06958051f, -0.09174830f, -0.17749383f, 
    -1.06162608f, 0.48509115f, 0.61772472f, 0.13504745f, -0.09683267f, 0.20789365f, 0.00205895f, -0.09573270f, 
    0.04005592f, 0.04971016f, -0.50744182f, 0.13418666f, 0.05877129f, 0.06281447f, -0.11618613f, -0.38313657f, 
    0.18818226f, -0.00543408f, 0.02536835f, -0.15744741f, -0.06026954f, 0.12791696f, -0.10610420f, 0.01467185f, 
    0.05744586f, -0.27174404f, -0.21749809f, 0.24593768f, -0.01324970f, -0.21938220f, -0.05879545f, -0.04786694f, 
    0.29119036f, 0.05051292f, -0.01306350f, -0.13435453f, 0.29165304f, 0.16086169f, 0.02143149f, -0.22540416f, 
    -0.04463938f, 0.01593864f, 0.06763548f, -0.07332034f, -0.06714107f, 0.02826333f, 0.02897383f, -0.18781461f, 
    -1.06312859f, -0.44844934f, -1.06459725f, -0.35962838f, -0.11982674f, -0.12531373f, 0.35217538f, 0.02106932f, 
    -0.12093654f, -0.06508385f, -0.01799318f, 0.03204150f, 0.66184974f, 0.10398934f, -1.10012960f, -0.23753974f, 
    0.40893909f, -0.19862492f, -0.15952525f, 0.12131004f, 0.10605133f, 0.02411001f, -0.01154366f, 0.00926175f, 
    -0.81355429f, -0.67196834f, 0.58510423f, 0.95323068f, -0.06846858f, -0.01694642f, -0.15434618f, 0.15724199f, 
    -0.00715777f, -0.02762821f, -0.16433023f, -0.04426049f, 0.69790393f, -0.15332195f, -0.22062020f, -0.20032939f, 
    0.05612648f, -0.05724121f, 0.03640950f, -0.13450517f, 0.13449639f, 0.13224955f, 0.13687256f, -0.07575626f, 
    -0.16465430f, -0.04926349f, 0.09675963f, -0.24613619f, 0.03952171f, -0.25494355f, -0.02894801f, -0.03610952f, 
    0.09480511f, 0.06383515f, 0.03034117f, -0.05381627f, -0.10855184f, -0.01136078f, 0.14246151f, -0.00617925f, 
    -0.06142851f, 0.11042420f, 0.05487335f, 0.01293123f, 0.02752198f, 0.04454602f, 0.04736605f, -0.06074994f, 
    0.78402519f, -1.20211291f, 0.39065745f, -0.47966012f, -0.04372481f, -0.01792879f, 0.03869472f, 0.00481236f, 
    0.08923724f, 0.28889096f, 0.04157856f, -0.06690262f, -1.55982065f, 1.23813212f, -0.60494089f, 0.20686124f, 
    0.05002888f, -0.15279585f, -0.00861957f, -0.03752683f, 0.04209220f, -0.03719809f, 0.13143282f, -0.06649511f, 
    -0.39597198f, 0.03057529f, 0.19791047f, -0.09448349f, -0.02513036f, 0.05089030f, 0.28547519f, -0.02208089f, 
    0.00771231f, 0.12413904f, 0.01626119f, -0.01786614f, -0.77407092f, 0.27501661f, -0.51296741f, 0.12736925f, 
    -0.04738289f, 0.36758751f, -0.01407079f, -0.30192637f, -0.02118017f, 0.05147538f, 0.00242736f, 0.02763853f, 
    0.01727841f, 0.01519728f, 0.09096397f, -0.04480572f, -0.06436745f, 0.06221002f, 0.03725612f, -0.10073771f, 
    0.04223094f, -0.35124835f, -0.46207997f, -0.72433758f, 0.02731809f, 0.34824699f, 0.08480333f, -0.03764419f, 
    -0.03707571f, -0.22474088f, -0.06958773f, 0.14943516f, 0.17077452f, 0.02821920f, 0.09828683f, -0.03088620f, 
    0.40055713f, 0.31973782f, 0.03844616f, -0.15993512f, 0.09357155f, -0.21342306f, 0.06657422f, 0.04022231f, 
    -0.37761009f, -0.10319982f, 0.05754589f, 0.00128199f, 0.08881145f, 0.28969431f, -0.06332870f, -0.32406095f, 
    -0.00171489f, -0.08682423f, -0.08358265f, -0.15045898f, 0.09175626f, 0.13885523f, 0.09448529f, -0.09163458f, 
    0.00425959f, -0.05463514f, 0.19733377f, 0.02538300f, 0.12784275f, 0.10129951f, -0.10641647f, 0.11474077f, 
    -0.21596894f, 0.01887647f, -0.16484745f, -0.68767118f, -0.08101252f, 0.01493649f, -0.04815530f, 0.03896438f, 
    -0.00681680f, -0.03367092f, -0.13185728f, -0.12211944f, 0.24377334f, 0.38534045f, 0.13278548f, 0.39084810f, 
    -0.46698341f, -1.32131970f, -0.20590270f, 0.65412915f, 0.16434789f, 0.30414653f, 0.08629315f, -0.13486266f, 
    0.07013388f, 0.05725211f, 0.13712093f, 0.16064842f, 0.79880750f, -0.62329179f, -0.69998860f, 0.34414935f, 
    -0.06020176f, 0.20110232f, 0.03932282f, 0.34011990f, -0.01202358f, -0.09687920f, -0.04565942f, -0.17067289f, 
    -0.36857754f, -0.56586301f, -0.84137404f, -0.39658958f, -0.09156179f, -0.10235777f, 0.06078943f, -0.36313909f, 
    0.11810840f, 0.05287757f, 0.00824626f, 0.01536489f, -0.17724732f, -0.50824779f, -0.44433096f, -0.44125214f, 
    -0.10571774f, -0.00473145f, 0.02725616f, 0.08323967f, 0.02370691f, -0.20349440f, -0.18306099f, -0.24035507f, 
    0.35884771f, 0.09401018f, 0.10329680f, -0.11947818f, -0.05661716f, -0.09304864f, -0.21997607f, -0.25517416f, 
    0.08614815f, 0.18163943f, 0.09339144f, 0.04505317f, -0.29011548f, 0.27860487f, -0.02204843f, 0.04583322f, 
    -0.06266348f, 0.04367550f, -0.01395375f, 0.21728279f, -0.04337816f, 0.04530443f, 0.06362031f, 0.15316498f, 
    0.30401695f, -0.75895488f, 0.09462075f, 0.08232287f, 0.10157455f, 0.24463925f, 0.12961747f, 0.12203605f, 
    0.09287485f, -0.19585082f, 0.09289406f, -0.11453062f, -0.83989322f, -0.10176405f, 0.25459811f, 0.24201632f, 
    0.22764051f, 0.21012962f, -0.32916692f, -0.09096786f, 0.00774264f, 0.10461944f, 0.00556892f, -0.03836907f, 
    -0.77184975f, -0.62452453f, -0.21167503f, 0.34406692f, 0.45185354f, 0.25084999f, 0.05018383f, 0.15817097f, 
    -0.17718215f, -0.07261297f, 0.01055242f, 0.18900667f, -0.12502626f, 0.32447547f, 0.34008262f, 0.20877868f, 
    0.12641925f, -0.13428399f, -0.28021255f, 0.26652753f, 0.06690627f, 0.04782872f, 0.24114753f, 0.18620810f, 
    -0.77191395f, 0.08365429f, 0.22474417f, -0.43792388f, -0.02329686f, 0.10904977f, -0.00512993f, 0.05891635f, 
    0.09792051f, 0.17674419f, 0.09024274f, 0.12571923f, -0.66872865f, 0.10597229f, 0.01945967f, -0.29341567f, 
    -0.25615638f, -0.07630493f, -0.07798833f, -0.19594006f, -0.25164247f, -0.04598625f, -0.28260627f, 0.07596533f, 
    0.12826687f, -0.36835471f, -0.12054388f, -0.08785382f, -0.36809474f, 0.14521289f, 0.35075620f, 0.05206434f, 
    0.32169122f, -0.02339100f, 0.19445670f, -0.05718241f, -0.21014252f, 0.13067041f, 0.24028738f, -0.02564004f, 
    -0.19972911f, -0.10338696f, -0.08586127f, -0.21524629f, -0.14732467f, -0.06743857f, 0.00656616f, -0.05224829f, 
    0.00185156f, 0.17705996f, 0.22588833f, -0.08584762f, 0.08822019f, -0.02490981f, -0.06528625f, -0.11937030f, 
    0.04276284f, 0.11640261f, 0.19639072f, 0.26248774f, -0.05267745f, -0.22807080f, 0.38081366f, -0.04443873f, 
    0.04356477f, 0.12758401f, -0.29151171f, -0.12367045f, -0.06380896f, -0.20409834f, -0.02240432f, -0.10391498f, 
    0.17521618f, -0.03518207f, 0.41270992f, -1.33332026f, -0.06125689f, -0.27020821f, -0.15115719f, -0.01041961f, 
    -0.25077736f, -0.00956501f, 0.04676030f, 0.03460688f, -0.74747247f, 0.30428383f, -0.54601139f, 0.11258287f, 
    -0.20055883f, -0.05406987f, -0.23261283f, 0.10924605f, 0.05654069f, -0.12095551f, 0.08699984f, -0.01390895f, 
    -0.52025288f, -0.05660515f, 0.10236235f, 0.04161362f, -0.30993372f, -0.09322054f, -0.12981918f, 0.21460199f, 
    0.18417336f, 0.11335125f, 0.13662213f, 0.05013076f, 0.18686292f, -0.09226953f, 0.93251902f, 0.76908761f, 
    0.11576186f, -0.34750289f, -0.27239037f, -0.32147792f, 0.01444850f, 0.13572596f, 0.08842646f, 0.02203763f, 
    0.37637883f, -0.51715869f, -0.04301613f, -0.17664829f, 0.32807654f, 0.28394347f, 0.07065371f, 0.07288462f, 
    -0.12304008f, -0.14942043f, -0.03293817f, -0.00382818f, -0.32333076f, 0.22701582f, -0.34065658f, -0.22989456f, 
    -0.08053312f, 0.10958882f, 0.33842009f, 0.09555474f, 0.27867356f, -0.07590228f, -0.23375738f, -0.11446039f, 
    0.34017742f, -0.49248457f, 0.15995671f, 0.32906121f, -0.20246178f, -0.07181096f, -0.54494333f, -0.32849553f, 
    -0.04278835f, 0.04190609f, -0.18899302f, 0.01312217f, 0.20461842f, 0.35507187f, -0.66564441f, -0.27123326f, 
    0.06655405f, 0.06049079f, 0.16755895f, 0.16323495f, 0.04751938f, -0.02116684f, 0.03249114f, 0.08662439f, 
    0.42432237f, -0.38524947f, 0.13114983f, -0.74144304f, 0.08903900f, -0.10141397f, 0.11520696f, 0.07431696f, 
    -0.16264609f, -0.04306200f, -0.06369797f, -0.16912641f, -0.74707037f, 0.61318046f, -0.87476945f, 0.15632410f, 
    0.20325458f, -0.29433849f, 0.16409311f, -0.21742597f, -0.09126641f, -0.13325916f, -0.11131077f, 0.08974159f, 
    -0.02015794f, 0.25566399f, -0.00974646f, 0.09816600f, -0.09141445f, -0.01897970f, -0.01066897f, -0.26778203f, 
    0.05122001f, -0.00749881f, 0.33697432f, -0.01148164f, 0.09081144f, -0.42018971f, -0.01598268f, -0.31643647f, 
    0.18275452f, 0.19044007f, 0.13978824f, 0.13449714f, 0.14044727f, 0.06676664f, 0.00809285f, 0.08351100f, 
    -0.51692587f, -0.36803883f, 0.48696604f, -0.29028496f, 0.49109349f, -0.44388959f, -0.08527045f, 0.25372928f, 
    0.01844742f, -0.15305620f, -0.30033255f, 0.27523589f, -0.17157766f, -0.23885117f, -0.00273568f, 0.09102233f, 
    -0.02103528f, 0.15735769f, 0.01490205f, -0.05560996f, 0.15355755f, 0.06369095f, 0.06716205f, 0.02521727f, 
    0.38614020f, 0.29911831f, 0.36850783f, -0.27371365f, -0.08052971f, -0.08561357f, -0.11595127f, 0.07876093f, 
    -0.17035717f, -0.23760654f, -0.38209659f, -0.46981803f, -0.07493099f, -0.14194280f, 0.20314792f, 0.23149434f, 
    -0.25093684f, 0.16909669f, -0.06383059f, -0.14673193f, 0.28325897f, 0.31991923f, 0.15441994f, 0.50666904f, 
    -0.03116022f, 0.14271499f, -0.16685493f, 0.43728822f, 0.08155265f, 0.00770988f, -0.49168241f, 0.26299986f, 
    -0.02013920f, 0.11477186f, -0.22780301f, -0.42358324f, 0.13112910f, -0.08841927f, 0.57649791f, 0.26782829f, 
    -0.15611953f, 0.06676542f, -0.26637864f, 0.57882708f, -0.43402433f, 0.13919795f, -0.12753567f, 0.04581941f, 
    -0.09533689f, -1.15295112f, -0.31248838f, -0.00966828f, -0.12693298f, -0.00950840f, 0.05118988f, 0.18466008f, 
    0.05447010f, 0.12029732f, -0.01788953f, 0.05315730f, -0.78233230f, 0.27540919f, -0.29601380f, -0.02449495f, 
    -0.10787922f, 0.16382487f, -0.42264351f, -0.07670864f, -0.09148467f, -0.10480145f, -0.37049624f, -0.25220335f, 
    -0.65983224f, -0.47630823f, -0.57183236f, 0.09146834f, -0.15797584f, -0.19438674f, 0.03865326f, 0.06084238f, 
    0.14605330f, 0.01596479f, 0.14767161f, -0.07161710f, 0.26090831f, -0.13489307f, 0.56024098f, -0.58379072f, 
    -0.34093878f, -0.19919206f, 0.23192123f, -0.21085893f, -0.07169729f, 0.16352557f, 0.37376493f, 0.22332828f, 
    -0.20850380f, 0.54065907f, -0.48925811f, 0.28241366f, 0.12544695f, -0.11355358f, 0.05702941f, 0.04710119f, 
    0.13213502f, 0.18327217f, -0.27503189f, 0.00600979f, -0.07100269f, -0.36004972f, 0.36143914f, -0.19296217f, 
    0.03659054f, -0.16467449f, -0.14300564f, 0.18530728f, -0.07437911f, -0.01261591f, -0.02127762f, -0.00839127f, 
    0.12357961f, 0.45876858f, -0.51257831f, 0.60463667f, 0.00097695f, -0.16198578f, 0.09839236f, 0.14251505f, 
    0.03489416f, 0.18130215f, 0.02090773f, 0.30224800f, 0.37497851f, 0.11464945f, 0.08640584f, 0.13216276f, 
    -0.16259137f, 0.12739910f, 0.50592035f, 0.18619037f, -0.03121798f, 0.25271311f, -0.07702331f, 0.04891970f, 
    0.11764903f, 0.09917642f, 0.11332092f, -0.41162476f, -0.04717342f, -0.01939894f, 0.12167984f, -0.08460830f, 
    -0.14275391f, 0.00765096f, 0.05303945f, 0.05504608f, -0.09615853f, -0.44482550f, 0.07846861f, 0.00250394f, 
    -0.35665816f, -0.46905002f, 0.04627166f, 0.02961808f, -0.36840346f, -0.12899920f, 0.01414176f, -0.17244537f, 
    -0.69162393f, 0.58833802f, 0.52710634f, 0.36873963f, -0.12264872f, -0.07665288f, -0.00157005f, 0.06406095f, 
    -0.04901844f, -0.11870884f, 0.20663081f, 0.08505749f, -0.31819922f, -0.13407901f, 0.23141356f, -0.23553474f, 
    -0.09149474f, -0.03039569f, -0.35428435f, -0.10716997f, 0.26751778f, -0.18217912f, -0.04258080f, -0.18651293f, 
    -0.24834563f, 0.33940467f, -0.19132364f, -0.19686502f, 0.06996886f, 0.06945980f, -0.13154393f, 0.17061649f, 
    -0.00103867f, 0.12447583f, 0.45247540f, 0.07201579f, -0.30551791f, 0.22403632f, -0.44264737f, -0.11035520f, 
    0.14365764f, -0.01297914f, 0.16381295f, -0.10849708f, 0.06778156f, -0.18168372f, -0.12449193f, -0.43758228f, 
    -1.14299667f, -0.03657330f, 0.09874043f, -0.30971628f, -0.50716871f, -0.11196525f, 0.15931065f, 0.20899662f, 
    -0.16776882f, 0.06764572f, -0.09528477f, -0.05948610f, 0.03140204f, -0.09822377f, 1.06411815f, -0.42753765f, 
    0.01727447f, 0.05897991f, 0.29433167f, -0.30198541f, 0.07813415f, -0.12434645f, -0.17859234f, 0.05370732f, 
    -0.19621494f, -0.58824253f, -0.23188661f, -0.08548044f, -0.25129011f, -0.32130629f, 0.16874160f, -0.38256562f, 
    0.11568514f, 0.13945878f, -0.00765794f, -0.02757400f, -0.53650659f, 0.08907951f, -0.34206316f, 0.07953025f, 
    -0.01893210f, -0.06505239f, -0.10966419f, -0.00712223f, 0.29528064f, 0.18946879f, 0.11313226f, -0.11221911f, 
    0.70644629f, 0.44867679f, 0.04272378f, -0.02439767f, -0.19927242f, -0.04234608f, 0.04666112f, 0.14146028f, 
    -0.20756115f, 0.01080158f, -0.04679559f, -0.04236599f, 0.13242768f, 0.03476525f, 0.66017210f, 0.10438849f, 
    -0.08674154f, 0.25066572f, 0.06614414f, -0.11022418f, -0.65137017f, -0.21631800f, 0.18222155f, -0.02183698f, 
    -0.96367526f, 0.99666822f, -0.66233265f, 0.57596421f, 0.16635896f, -0.23254964f, 0.08257496f, -0.00668868f, 
    -0.23952135f, 0.02958952f, 0.16785859f, 0.14838649f, 0.04238193f, -0.26286006f, 0.43290550f, -0.10719672f, 
    -0.25457430f, -0.15463142f, -0.24866737f, -0.19008334f, 0.04403319f, 0.09050763f, -0.06582360f, 0.18603851f, 
    -0.44038945f, -0.15545233f, 0.36131227f, -0.31497273f, -0.18009336f, 0.46148473f, -0.15068562f, -0.16628541f, 
    -0.14648639f, -0.11336420f, -0.14654376f, -0.28737536f, 0.62821048f, -0.43458882f, 0.93883657f, -0.32685336f, 
    0.18617922f, -0.05623959f, -0.05400737f, -0.01395861f, -0.20935710f, -0.18167080f, -0.11017089f, 0.04370295f, 
    -0.23231773f, 0.03466269f, -0.25024509f, 0.02015935f, -0.01343635f, 0.07741380f, -0.05727668f, 0.08456743f, 
    -0.25953883f, -0.13814893f, 0.10920183f, 0.12916315f, 0.50582844f, 0.60122353f, 0.07156461f, -0.12424880f, 
    -0.25927389f, 0.35943285f, -0.14260456f, 0.08261079f, -0.07864179f, 0.06132112f, -0.03183205f, -0.06928303f, 
    -0.29495764f, 0.15600777f, -0.28657699f, 0.40162942f, 0.19335243f, 0.27441463f, -0.12066093f, 0.17661896f, 
    -0.06126290f, 0.19009097f, 0.11789266f, -0.10793709f, 0.24299964f, 0.00025058f, 0.05380433f, -0.14562513f, 
    -0.07698920f, 0.01009089f, 0.11386248f, 0.12695904f, -0.08753965f, 0.05460609f, -0.09856100f, 0.01674508f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.34676224f, 0.13531347f, 0.13768719f, -0.15433687f, -0.19163899f, 0.16260006f, 0.21162143f, -0.15339810f, 
    0.14130399f, 0.03288528f, 0.12657873f, -0.03005455f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
