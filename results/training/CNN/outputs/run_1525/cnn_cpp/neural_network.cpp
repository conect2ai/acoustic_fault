#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.68570739f, 0.86913741f, -0.75551534f, 0.37075430f, -0.42095223f, -0.30015150f, 0.43457916f, -0.12967783f, 
    -0.16880892f, -0.52430367f, -0.62385345f, -0.70134884f, 0.40083158f, 0.63036382f, 0.48509172f, -0.01482545f, 
    0.41599998f, 0.05073910f, 1.03136528f, -0.60609883f, -0.38501579f, 0.52082145f, -0.24319595f, 0.54903543f, 
    0.01375913f, -0.02243607f, -0.39538690f, 0.43265158f, 0.09578949f, 0.07283895f, 0.24412841f, -0.10943119f, 
    0.28427637f, 0.86420405f, -0.96448147f, 0.13343176f, 0.70595545f, 0.58550072f, 0.58914459f, 0.45942599f, 
    0.34410399f, 0.29417264f, -0.02467963f, 0.00270125f, 0.10970625f, 0.57841218f, 0.41382939f, 0.70083827f, 
    -0.59108829f, -0.29856825f, -0.71715605f, 0.43105409f, 0.19200905f, 0.35092747f, -0.26899680f, -0.28213409f, 
    -0.33414927f, -0.10239410f, -0.26587138f, -0.77153867f, 0.10653023f, 0.12652130f, 0.92678154f, -0.21174277f, 
    0.52750891f, -0.51110131f, 0.28800753f, 0.52211726f, -0.06950440f, 0.42967451f, 0.41018498f, 0.52098042f, 
    -0.66902411f, -0.00577368f, 0.40079692f, 0.32354066f, 0.54376543f, 0.48929238f, 0.08894087f, -0.54842687f, 
    -0.23144738f, 0.38860777f, -0.13882674f, -0.34459198f, 0.61530274f, 0.03321321f, 0.89702898f, -0.33769518f, 
    -0.22688121f, 0.34053749f, -0.48326936f, -0.01562557f, 0.93825579f, 0.47410324f, -0.33032694f, -0.21677294f, 
    -0.58331621f, -0.23838359f, -0.19065857f, 0.05290857f, 0.78282458f, -0.26283607f, 0.09083244f, -0.54935962f, 
    0.03954094f, -0.34617153f, -0.03100197f, 0.55282050f, -0.37749380f, -0.67898095f, -0.54403114f, 0.22228789f, 
    -0.02949002f, 0.26319787f, -0.07521795f, -0.19839156f, -0.51706076f, 0.03546191f, -0.25991189f, -0.40202311f, 
    -0.56020558f, -0.83132952f, -0.44520319f, -0.41523805f, -0.34209806f, -0.34704080f, 0.59779537f, 0.24152078f, 
    -0.89496285f, -0.41671583f, -0.17361830f, -0.34005284f, 0.30738151f, 0.26726672f, 0.20124252f, -0.58649212f, 
    -0.36483786f, -0.58583379f, 0.55546790f, 0.68927640f, -0.68191797f, -0.24725167f, -0.30581966f, -0.30182961f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.38047773f, 0.04785912f, 0.42605650f, 0.21918461f, 0.08985003f, 0.23827145f, 0.16811040f, 0.34831727f, 
    0.37913954f, 0.33719903f, 0.04131240f, 0.17450090f, 0.26961222f, 0.01821943f, 0.45812771f, -0.08767852f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.33404836f, 0.37573043f, 0.25716925f, 0.17789771f, -0.02168791f, 0.10339910f, -0.06875872f, 0.03046604f, 
    0.12144142f, -0.16501032f, -0.09714552f, 0.21832637f, 0.20645133f, -0.17273107f, 0.10417625f, 0.14510012f, 
    -0.08099193f, 0.01245662f, 0.30339864f, 0.15484604f, -0.39361110f, 0.36674073f, -0.00312554f, -0.03329930f, 
    0.00983445f, -0.10755952f, 0.14494710f, 0.15203135f, 0.09881487f, -0.26421854f, 0.03458526f, 0.12571481f, 
    -0.01558658f, 0.00715712f, -0.11361580f, -0.00159637f, -0.10748638f, -0.28223398f, -0.01414683f, -0.00639851f, 
    0.06373681f, -0.10215470f, 0.22168285f, -0.14600900f, 0.01455457f, 0.24463677f, 0.04372307f, -0.09062399f, 
    0.02206220f, -0.04709700f, 0.10576169f, 0.00607706f, 0.08816861f, 0.16682422f, 0.06282295f, 0.10234386f, 
    0.20742130f, -0.07399528f, 0.02889512f, -0.16215383f, 0.05831002f, 0.04652227f, -0.03795591f, -0.23371439f, 
    0.08696324f, 0.07929546f, -0.01353764f, -0.03412126f, 0.14018285f, -0.09430178f, 0.22140318f, -0.00830299f, 
    -0.20917265f, 0.05653578f, -0.14186634f, 0.15938169f, 0.16189989f, -0.26249379f, -0.03531753f, 0.13238272f, 
    -0.04441393f, 0.05761404f, -0.10008429f, -0.09014291f, -0.05425336f, 0.12820835f, -0.01859748f, 0.21750744f, 
    -0.09932250f, 0.12229849f, -0.53729481f, -0.32352406f, -0.00390751f, -0.02369070f, -0.13060102f, -0.20405614f, 
    -0.07506631f, -0.19749193f, -0.07203585f, 0.46903890f, -0.09414588f, -0.43191114f, 0.02060602f, 0.24438187f, 
    0.04618229f, 0.07168977f, -0.23381136f, 0.01225355f, -0.17095484f, 0.05513144f, -0.10037937f, 0.09845432f, 
    0.00771624f, -0.00366492f, -0.04277939f, -0.20056151f, -0.22820808f, 0.31236133f, 0.22986268f, 0.34002933f, 
    0.11621323f, -0.00953849f, 0.24795713f, 0.10381943f, 0.04862057f, -0.29154581f, -0.10916937f, 0.18443909f, 
    0.21585339f, -0.02407167f, 0.04002671f, 0.17090753f, 0.03499281f, 0.09580400f, -0.03269701f, -0.42048052f, 
    0.12212529f, 0.10926700f, -0.17644899f, 0.14427777f, 0.17471220f, 0.08043381f, -0.16905048f, 0.13747014f, 
    -0.46489206f, -0.01640256f, 0.18158942f, 0.09524687f, -0.21806557f, 0.08212356f, 0.21615815f, 0.13939434f, 
    -0.15262035f, -0.04903318f, -0.09668915f, -0.29720476f, -0.01221784f, -0.13319242f, 0.01673837f, -0.29851142f, 
    0.07894483f, 0.07177424f, 0.45032355f, -0.15342645f, 0.10924190f, 0.02516591f, 0.08084423f, 0.16713448f, 
    0.06815849f, 0.00711147f, 0.10849618f, 0.05729139f, 0.06124954f, 0.40570036f, -0.00435309f, 0.14319009f, 
    -0.04427752f, -0.15840545f, -0.11883737f, 0.11705706f, 0.34687692f, 0.01902252f, 0.16150686f, -0.04003530f, 
    0.02981677f, -0.08350477f, 0.08309915f, 0.01722784f, -0.04769729f, 0.26376712f, -0.13820300f, -0.16826543f, 
    0.19225161f, -0.03113094f, -0.12370429f, 0.02504111f, 0.05461715f, 0.20836890f, -0.02905245f, 0.20991285f, 
    0.19286293f, -0.05734861f, -0.08578568f, -0.19597827f, 0.06332041f, -0.01435447f, -0.17499901f, -0.02968026f, 
    -0.06050281f, -0.00736808f, 0.01534265f, 0.00852191f, 0.18204618f, 0.08223946f, 0.01163858f, -0.14891203f, 
    -0.29556498f, 0.09052469f, 0.00503331f, -0.02270076f, 0.08964691f, -0.12110493f, -0.00967368f, -0.41820988f, 
    0.01926485f, 0.09448457f, 0.15628622f, -0.21328965f, -0.00385578f, -0.16279747f, 0.08996845f, 0.10473394f, 
    -0.25066152f, -0.04441505f, -0.37620720f, -0.11756688f, 0.55664039f, 0.10450841f, 0.07080881f, 0.04783124f, 
    0.14014050f, -0.00060762f, -0.00902745f, 0.56884700f, 0.22826935f, -0.12266006f, 0.07601832f, -0.30998939f, 
    0.07007746f, 0.10181525f, 0.36676645f, -0.23580661f, -0.17042468f, 0.06061856f, -0.03328182f, 0.16670015f, 
    0.09966531f, 0.10299866f, -0.29992220f, -0.04951399f, 0.31843281f, -0.19230847f, -0.13932483f, -0.11728127f, 
    0.00503355f, 0.02051537f, 0.17734420f, 0.09946419f, 0.06548557f, 0.14786561f, 0.06041365f, 0.02075954f, 
    -0.10868973f, 0.20015182f, -0.10103148f, 0.25497818f, 0.03325420f, -0.02232573f, -0.11360803f, -0.41164303f, 
    -0.31007427f, 0.25287193f, -0.10792521f, 0.27450690f, -0.07043853f, -0.10532729f, -0.03353086f, -0.02325480f, 
    -0.20746002f, -0.28647071f, 0.03223496f, -0.09745809f, -0.05180305f, -0.23478423f, 0.11469273f, -0.02735985f, 
    -0.02734317f, -0.89240485f, 0.15871882f, 0.45230451f, -0.06540082f, 0.12487434f, -0.20105664f, 0.05379156f, 
    0.04968534f, -0.05418872f, 0.01507777f, 0.37409765f, 0.15006724f, 0.09782241f, -0.00597272f, 0.07099932f, 
    0.04721022f, -0.08887821f, 0.19243900f, 0.07840783f, 0.06452809f, 0.19687693f, 0.03619922f, -0.01997531f, 
    -0.09312043f, 0.16882867f, 0.05266139f, 0.13873713f, 0.35669068f, 0.10982895f, 0.07576907f, -0.03582555f, 
    0.17178968f, 0.09959215f, -0.25308099f, -0.13687320f, 0.03005416f, 0.53080022f, -0.30518994f, -0.42022055f, 
    0.15378554f, 0.16502750f, 0.02611310f, -0.09562269f, -0.02714026f, -0.12300932f, -0.64779490f, 0.06630217f, 
    -0.03287493f, 0.14042580f, -0.06983386f, -0.19016504f, -0.05843208f, -0.08923721f, -0.14640674f, 0.19034377f, 
    -0.10569399f, 0.00021142f, 0.09283190f, 0.03819060f, 0.20054825f, 0.15422438f, -0.08590826f, 0.02955955f, 
    0.08594969f, 0.23431234f, 0.04715905f, 0.07869940f, -0.26753518f, -0.07250961f, -0.13345030f, -0.04408377f, 
    0.22643939f, -0.23931026f, 0.11187297f, 0.10918678f, -0.00424597f, 0.03731305f, -0.04895847f, 0.04755910f, 
    0.08531836f, 0.01623284f, 0.15138367f, -0.00891692f, -0.08430368f, -0.26330930f, -0.08006784f, -0.15366286f, 
    0.18410799f, 0.19102022f, 0.11165853f, 0.10070681f, -0.00156796f, 0.19263466f, 0.05060383f, -0.17925750f, 
    0.04641195f, 0.03153111f, -0.16137606f, -0.18844643f, 0.06788217f, -0.08066148f, 0.02830113f, -0.02467602f, 
    0.09815482f, 0.07022195f, 0.12989645f, 0.14784066f, 0.28415784f, -0.11892877f, 0.00450757f, -0.34625337f, 
    -0.10767617f, -0.03640831f, -0.20593582f, 0.05077249f, -0.03499253f, -0.04635074f, 0.44479027f, 0.28617638f, 
    -0.46387497f, -0.02538164f, 0.03611839f, -0.00707115f, 0.02438327f, -0.02576994f, -0.08716543f, -0.20535545f, 
    -0.36928236f, -0.00654932f, -0.03601874f, 0.03325059f, -0.03916746f, -0.19120717f, 0.18166642f, 0.10329339f, 
    0.21475296f, 0.21311820f, -0.03771710f, 0.16285375f, 0.08899882f, 0.18688226f, 0.14384842f, 0.01695397f, 
    -0.00978266f, 0.16567655f, -0.21067509f, 0.31860670f, -0.02391486f, 0.09182303f, -0.06999151f, 0.07138652f, 
    -0.00632557f, 0.06020972f, 0.02974111f, -0.14994004f, -0.03599605f, 0.11030865f, 0.08180669f, 0.04349411f, 
    0.00050052f, 0.01898062f, -0.10824050f, 0.06372804f, -0.17571330f, 0.38524738f, -0.14594027f, -0.03372568f, 
    0.18752456f, 0.03038312f, -0.26428199f, 0.02664305f, -0.12039148f, -0.05834062f, 0.12047876f, 0.04326447f, 
    -0.10500169f, -0.30808747f, 0.05889464f, 0.08220118f, 0.05320131f, -0.51851767f, -0.29094860f, -0.07864786f, 
    0.08356320f, 0.15703040f, 0.14180563f, -0.05909565f, -0.11004329f, 0.03484155f, 0.17176530f, 0.24579160f, 
    0.38089535f, -0.00625786f, -0.02121864f, -0.25034925f, 0.19398424f, 0.00045254f, 0.15408303f, -0.28845105f, 
    -0.10190703f, 0.11877442f, -0.05736304f, -0.03645670f, 0.28166404f, -0.01570940f, 0.04192037f, 0.08210544f, 
    -0.32728013f, -0.45659846f, -0.06662785f, -0.06684829f, -0.07858904f, -0.12880951f, 0.09895792f, -0.09280959f, 
    0.12841801f, -0.41309580f, -0.33255821f, 0.04283364f, -0.22988118f, -0.31750387f, -0.07088862f, 0.02679655f, 
    0.17702296f, 0.01336920f, -0.35820359f, -0.84314239f, 0.00711143f, -0.08347640f, 0.10657035f, 0.07993398f, 
    0.19919172f, 0.05335064f, -0.08323989f, 0.13241594f, -0.33919790f, 0.02226418f, -0.06017500f, 0.07789344f, 
    0.05201827f, -0.12998620f, 0.12799801f, -0.01376866f, -0.31483239f, -0.06049606f, -0.20566267f, 0.02815935f, 
    0.15536129f, -0.04901785f, 0.23581666f, -0.01722669f, -0.07296844f, 0.04014730f, 0.38920027f, 0.14380629f, 
    -0.04625655f, 0.17305088f, -0.18226536f, -0.03933669f, 0.00859094f, -0.10601884f, -0.09152724f, 0.06189664f, 
    -0.05909712f, -0.04299499f, 0.05121806f, 0.09340468f, -0.00352032f, 0.05156778f, 0.01763778f, -0.01730181f, 
    0.06301097f, 0.25531110f, 0.09922776f, -0.01678739f, -0.15363610f, 0.23639081f, 0.19744806f, -0.01015939f, 
    -0.67345035f, 0.04190876f, 0.05369838f, 0.20849545f, 0.02286708f, 0.04810279f, 0.13537595f, 0.06189055f, 
    0.05840617f, -0.15523630f, -0.65107012f, -0.63041794f, -0.03144806f, 0.18165389f, 0.22922373f, 0.07434911f, 
    0.03707901f, 0.07502562f, 0.41026971f, 0.20094307f, -0.17800598f, 0.07704311f, 0.17858195f, -0.19222738f, 
    0.09604293f, 0.27646130f, 0.04961588f, 0.08774270f, 0.50995642f, -0.16602618f, 0.06154125f, 0.04689748f, 
    -0.26573679f, 0.09981344f, 0.01816059f, 0.19880112f, 0.02394502f, 0.08800787f, 0.11064371f, -0.21080872f, 
    -0.10680510f, 0.00664884f, -0.02115547f, -0.06171869f, -0.09587041f, -0.12865649f, -0.23974895f, 0.03779575f, 
    -0.02222783f, -0.04568053f, -0.04308168f, -0.01245579f, 0.02730173f, 0.20316483f, -0.29839373f, 0.30197537f, 
    -0.17842062f, 0.21183623f, -0.02698734f, -0.06036361f, 0.06862352f, 0.07698226f, 0.07673318f, 0.08151633f, 
    -0.07706557f, -0.11480711f, -0.28841552f, 0.14996308f, -0.02068360f, 0.09783746f, 0.08745278f, 0.05226951f, 
    0.23237795f, 0.29995593f, -0.13877822f, -0.04301237f, -0.00120317f, -0.19720022f, 0.04442188f, -0.04875275f, 
    0.12550440f, 0.09337636f, -0.14757875f, 0.29431027f, -0.06594612f, -0.05314754f, -0.24733160f, 0.09386562f, 
    -0.10355144f, 0.08534764f, -0.07554919f, -0.17347795f, -0.25484434f, 0.20257173f, 0.06331129f, 0.18053100f, 
    -0.06287394f, -0.05475099f, 0.07993748f, -0.02477777f, 0.09870408f, 0.01676661f, -0.12916245f, 0.19757845f, 
    0.09298250f, -0.02526993f, 0.03619439f, 0.10913186f, -0.14206961f, -0.78357667f, -0.75705707f, -0.17223513f, 
    -0.17963414f, 0.33389705f, 0.14837687f, -0.00398249f, -0.14094926f, -0.60207391f, -0.37851405f, 0.08228105f, 
    -0.10942552f, -0.08894025f, -0.04969116f, 0.23018919f, -0.15415512f, 0.19701318f, -0.15678346f, -0.02673583f, 
    -0.07950386f, 0.13879782f, 0.18888509f, 0.15592255f, 0.07512986f, 0.07163873f, -0.08603480f, -0.09866248f, 
    -0.36980677f, -0.45654294f, -0.21784671f, -0.05511983f, -0.00888146f, 0.08530066f, 0.00764952f, -0.12417391f, 
    0.02035162f, -0.15609816f, 0.06487732f, 0.02221798f, 0.15115592f, 0.26966122f, 0.10965604f, 0.00461027f, 
    0.03244675f, 0.08239117f, 0.50885510f, -0.16574141f, -0.17139433f, -0.06051922f, -0.08780673f, 0.07520488f, 
    0.02209840f, 0.04497842f, 0.67968017f, 0.09133382f, -0.07191749f, -0.02299820f, 0.01434288f, 0.05272550f, 
    -0.00088962f, -0.00625728f, 0.02884947f, 0.07077491f, -0.14906980f, 0.02922087f, -0.26570946f, 0.19186534f, 
    -0.20034955f, 0.06313467f, 0.05821634f, -0.00872611f, -0.11810201f, 0.10265350f, 0.17299934f, -0.04391104f, 
    -0.40115204f, -0.04251638f, -0.09676757f, -0.14701858f, -0.05560540f, -0.49867821f, -0.08242510f, -0.18148430f, 
    -0.03471457f, -0.30288845f, -0.05634987f, 0.04104182f, 0.06334700f, 0.19882341f, -0.43160227f, -0.19085802f, 
    0.21462788f, -0.06451920f, -0.06055573f, 0.11078846f, 0.06584274f, 0.11461885f, 0.13628134f, -0.08372418f, 
    -0.13215205f, -0.09464689f, 0.03799521f, 0.10345684f, 0.03866562f, 0.04488090f, 0.14699058f, 0.17980365f, 
    -0.00579838f, 0.02663868f, -0.00438876f, 0.09743904f, 0.00167514f, -0.02896460f, -0.03039618f, -0.26617187f, 
    -0.13455047f, -0.05214629f, 0.12491392f, 0.02437346f, 0.09753756f, 0.09236056f, 0.06831926f, -0.00349525f, 
    0.02180636f, -0.02900863f, 0.20189029f, -0.40236917f, 0.20433332f, 0.08461458f, 0.04407606f, -0.06647819f, 
    0.12878920f, -0.02645740f, -0.16415766f, 0.05209634f, 0.02310382f, 0.05019448f, 0.07454098f, -0.04845158f, 
    -0.07777732f, -0.06650129f, -0.03266758f, 0.16691470f, -0.28039038f, 0.26330259f, -0.10759304f, 0.00223394f, 
    -0.01295886f, -0.07258236f, -0.09644630f, -0.12870070f, -0.13475917f, -0.24000841f, 0.02464143f, -0.14667998f, 
    -0.06610036f, 0.14539984f, 0.03833415f, 0.19080654f, 0.16740808f, -0.04294148f, 0.09807932f, -0.46992317f, 
    -0.06880824f, 0.08077202f, 0.19534205f, 0.00491584f, -0.04167409f, 0.14456201f, 0.07599059f, -0.42182866f, 
    0.45862201f, 0.34596571f, -0.09548175f, -0.04220597f, -0.09707817f, -0.14836673f, -0.06390090f, -0.10507939f, 
    0.01904493f, 0.15089417f, 0.48380303f, 0.12555416f, 0.11015128f, 0.11067741f, -0.17553526f, 0.10335090f, 
    0.08874027f, -0.11848775f, 0.31474984f, 0.15178783f, -0.12498855f, 0.00302525f, 0.07701236f, 0.03023403f, 
    -0.31092638f, -0.12889345f, 0.11617314f, 0.02679298f, 0.46595517f, 0.00503179f, -0.02881825f, 0.31350055f, 
    -0.06156317f, 0.19071496f, 0.01529819f, 0.03246403f, -0.19873741f, 0.03852873f, 0.01877840f, 0.12362258f, 
    0.29171383f, -0.01468131f, 0.04264372f, -0.06132283f, -0.16584145f, -0.34985828f, -0.19289100f, -0.17143077f, 
    -0.09440355f, -0.31845221f, 0.08646385f, 0.14414681f, -0.22401927f, -0.36468077f, -0.20013343f, -0.14071567f, 
    -0.03866026f, 0.10642441f, -0.15252730f, -0.02370593f, 0.23722886f, 0.18281031f, -0.17178267f, -0.12223285f, 
    -0.12754527f, -0.05986591f, -0.11664590f, -0.05901998f, 0.27750450f, 0.07721008f, 0.09339696f, -0.08007891f, 
    0.16843286f, -0.02551465f, -0.01491478f, 0.11610147f, -0.11687779f, -0.06434253f, 0.19617273f, -0.00605061f, 
    -0.03152722f, -0.09438039f, -0.29281336f, 0.15516369f, 0.19160809f, 0.20667180f, 0.05331235f, -0.02141378f, 
    -0.16342886f, 0.08119536f, -0.06779551f, -0.00592977f, 0.09377334f, -0.01038983f, 0.06389435f, -0.02927022f, 
    -0.20210147f, 0.10826336f, -0.20611793f, 0.26567683f, 0.17908765f, -0.04747058f, 0.17177804f, -0.10084623f, 
    0.03420820f, -0.24479224f, -0.00113761f, 0.00356784f, 0.01731718f, 0.03963856f, 0.10347772f, 0.27617794f, 
    0.03467225f, -0.14354411f, -0.04872519f, -0.02122618f, -0.05839136f, 0.01700686f, 0.22768266f, 0.05448229f, 
    0.15307510f, 0.10359828f, -0.25337052f, 0.12889762f, -0.13918318f, -0.03449783f, -0.13268706f, 0.13914900f, 
    0.21449181f, 0.08062626f, -0.04017629f, 0.02633669f, 0.12305444f, -0.01013012f, -0.08142925f, 0.12183267f, 
    0.28095126f, -0.03557563f, -0.03023125f, -0.03479918f, 0.12204479f, 0.37541690f, 0.08759657f, -0.43695349f, 
    0.17093566f, 0.05391749f, 0.14221184f, -0.04939320f, 0.15704010f, 0.00210106f, 0.18767910f, -0.08817383f, 
    0.00796388f, 0.00091095f, -0.06287988f, 0.02119696f, -0.01839343f, -0.08335432f, 0.04728138f, -0.07724745f, 
    -0.07272329f, -0.09275682f, 0.05601065f, 0.00884849f, -0.05558003f, 0.05395249f, -0.07954565f, 0.06958865f, 
    -0.06581895f, -0.06807961f, -0.05432109f, -0.05514297f, -0.03698320f, -0.04693018f, 0.06247324f, -0.05845583f, 
    -0.09211905f, -0.08797374f, -0.01795452f, -0.07755926f, 0.06877731f, 0.03412878f, -0.07912284f, 0.03670893f, 
    -0.04594378f, 0.06110088f, 0.01869630f, 0.04165693f, 0.02266935f, -0.06686562f, -0.03540348f, 0.08257265f, 
    0.00038833f, -0.00828473f, -0.05739719f, -0.06783901f, -0.03661089f, 0.03826700f, -0.07714522f, -0.00695145f, 
    -0.00333647f, -0.02395863f, -0.00987735f, 0.00491398f, 0.03169674f, 0.04278466f, 0.01128001f, 0.04200586f, 
    0.03260366f, -0.01217331f, -0.04322685f, 0.07233035f, -0.04540810f, 0.03745649f, 0.06426922f, -0.03578141f, 
    0.07174995f, 0.02808304f, -0.03387042f, -0.05521253f, 0.08303073f, -0.04425436f, -0.05662505f, -0.04362705f, 
    0.01480429f, -0.07470110f, -0.08005457f, 0.01595413f, -0.07338063f, -0.06800999f, -0.04412998f, -0.08709628f, 
    0.01318840f, -0.05466392f, -0.00998320f, -0.02845531f, -0.06108286f, -0.04385721f, -0.07112068f, -0.07077333f, 
    -0.03955826f, -0.03116626f, -0.03392572f, -0.01398352f, -0.01041982f, -0.08910451f, -0.07145466f, 0.06929898f, 
    0.01084534f, -0.08563865f, -0.03805076f, -0.06440940f, 0.05840933f, -0.03971822f, 0.06644046f, -0.07344564f, 
    -0.01593900f, 0.04342332f, -0.01365010f, 0.01288575f, -0.06145721f, 0.06148436f, 0.03927283f, -0.01238325f, 
    -0.09040439f, 0.01627514f, 0.06538478f, -0.05454373f, -0.07933606f, 0.01663417f, -0.04742725f, -0.02619256f, 
    -0.05732030f, -0.00768201f, -0.00464243f, 0.02179418f, 0.04489744f, -0.07298481f, 0.01832642f, -0.06766863f, 
    0.02202999f, 0.02213189f, 0.00914353f, -0.04982123f, 0.06745623f, -0.05139555f, -0.09134715f, -0.06211383f, 
    0.06925560f, 0.05592309f, -0.01366118f, 0.00124315f, 0.00433409f, 0.03872551f, -0.08943106f, -0.00592637f, 
    0.23563834f, 0.27232525f, -0.03906397f, 0.14007783f, -0.13756980f, -0.08007627f, -0.10925341f, 0.13622378f, 
    -0.02377111f, -0.18810400f, 0.05746434f, -0.22807689f, 0.11005697f, 0.02808508f, 0.05252483f, -0.15926240f, 
    0.05244711f, 0.06084977f, 0.03924216f, 0.01638187f, 0.04339619f, 0.13633886f, -0.00115727f, -0.03691094f, 
    0.08041991f, -0.11404242f, -0.19437149f, 0.02931448f, 0.23616064f, 0.16980204f, 0.16205259f, -0.12991019f, 
    0.21919370f, -0.15958653f, 0.23310751f, -0.07794131f, -0.47995540f, -0.12188181f, -0.07934622f, 0.03091688f, 
    0.07845584f, 0.26595020f, -0.25610980f, -0.17244385f, -0.06589931f, -0.13098054f, 0.06144192f, 0.02779429f, 
    -0.04554028f, 0.06553884f, 0.09429250f, 0.23215383f, 0.06184202f, 0.22681727f, 0.05777666f, -0.07816691f, 
    -0.15746428f, -0.09033052f, 0.13205227f, 0.05715874f, 0.25965860f, 0.15018170f, 0.18993415f, -0.10420046f, 
    0.21106374f, 0.16132070f, -0.02563322f, -0.21710747f, 0.04376354f, -0.09538183f, 0.30848294f, 0.11254248f, 
    -0.09167178f, -0.18020988f, 0.13644926f, 0.23568480f, 0.04727159f, -0.01345014f, -0.04710553f, -0.09302343f, 
    -0.12026595f, 0.01847280f, -0.10707689f, 0.07610024f, 0.12257488f, 0.20722841f, 0.00322985f, 0.10038417f, 
    -0.02445231f, -0.14566401f, 0.03360849f, -0.00985813f, -0.01637449f, 0.14730494f, 0.03555653f, 0.07929282f, 
    0.07536381f, -0.20453934f, -0.05805047f, -0.09678136f, -0.08971429f, 0.03906899f, 0.14429621f, -0.06337010f, 
    0.27791968f, 0.06910571f, 0.02237361f, 0.03970230f, -0.08998955f, 0.31323811f, -0.13217071f, -0.10915318f, 
    -0.08806490f, -0.01013137f, -0.11669938f, -0.22251804f, -0.17602986f, 0.33586499f, -0.04531375f, -0.26267630f, 
    0.09349779f, 0.14136405f, 0.04665520f, -0.20211908f, -0.01940222f, 0.01911392f, 0.02631110f, -0.03576208f, 
    -0.04871083f, -0.06389906f, -0.07803641f, 0.20968527f, 0.22591920f, 0.15747538f, 0.24850224f, 0.32979146f, 
    0.24580123f, -0.19101442f, 0.18382709f, -0.03727016f, 0.05072001f, -0.17141718f, -0.21028852f, -0.32127979f, 
    0.21661760f, 0.08147755f, 0.02982627f, 0.25259194f, 0.15380149f, 0.07653933f, 0.17950088f, 0.03905541f, 
    0.15088674f, -0.19808231f, -0.14699389f, 0.42099723f, 0.00151127f, 0.05531844f, 0.18907370f, -0.14814968f, 
    0.06206970f, 0.12151825f, -0.37275782f, 0.09946495f, 0.13126224f, -0.06816565f, 0.06631019f, 0.11596692f, 
    0.26009122f, 0.14138792f, 0.23993200f, -0.07759112f, -0.02728736f, 0.00759373f, -0.01281415f, -0.04321679f, 
    0.07910038f, 0.19998109f, 0.03806363f, 0.33925301f, 0.10909245f, 0.32486385f, -0.04731628f, -0.04064598f, 
    -0.12405709f, 0.03062170f, -0.10476806f, 0.08727926f, 0.10262355f, 0.05602710f, 0.09202497f, -0.07414845f, 
    -0.09647371f, 0.09099454f, -0.07058273f, -0.13365526f, -0.23827434f, -0.07026760f, 0.30971014f, 0.18614499f, 
    0.35791138f, 0.05494375f, 0.11085717f, 0.15407372f, -0.05387902f, 0.08598179f, -0.38984817f, 0.03675741f, 
    0.02047142f, -0.01335528f, -0.08960053f, 0.16009119f, 0.12486072f, -0.03355516f, 0.07780695f, -0.05737255f, 
    0.19793886f, -0.17205139f, -0.23489420f, -0.01041388f, -0.10484405f, -0.02144729f, 0.20407490f, -0.06865850f, 
    0.20398597f, 0.02834543f, -0.09707861f, -0.36475635f, 0.12134561f, 0.05005540f, 0.05072312f, 0.27534816f, 
    0.24867946f, -0.14955778f, 0.26314074f, 0.22379541f, 0.15093610f, 0.14752008f, -0.13292620f, 0.14088477f, 
    -0.02384364f, 0.32224974f, -0.00401979f, 0.04495091f, 0.36057025f, -0.07316705f, 0.12388355f, -0.06655753f, 
    -0.01591511f, -0.02263056f, 0.06627359f, -0.12149040f, -0.11875324f, 0.22805732f, 0.17155379f, -0.17638981f, 
    0.09841222f, -0.03063632f, 0.19444773f, 0.07935940f, 0.18590768f, 0.22007549f, 0.21755928f, 0.51771164f, 
    0.08636168f, 0.01521907f, -0.14028823f, 0.05763937f, 0.07750238f, 0.06644507f, 0.12572241f, 0.33479616f, 
    0.15911137f, 0.09149853f, 0.08619702f, -0.03791121f, 0.19945088f, -0.06081895f, -0.07397154f, -0.24606654f, 
    -0.22053969f, 0.05618699f, 0.04897801f, 0.11414202f, -0.16543482f, 0.11133887f, 0.11329298f, 0.01825840f, 
    0.08235788f, -0.02411786f, -0.07456785f, 0.10251403f, 0.14637586f, 0.09325615f, -0.07916127f, -0.05282921f, 
    0.06926280f, 0.22147974f, -0.33177820f, 0.02698886f, 0.05892801f, 0.02703866f, 0.19898699f, -0.02834731f, 
    -0.20229498f, 0.07605715f, -0.26315176f, 0.10238398f, -0.07805363f, 0.05294028f, 0.11705269f, 0.23561302f, 
    -0.04957256f, 0.09851304f, -0.01924871f, 0.04487482f, -0.13208331f, -0.20079085f, 0.09781231f, 0.21348032f, 
    -0.04399037f, 0.00133892f, 0.11224165f, -0.23923884f, 0.10399473f, 0.25560892f, -0.13532963f, -0.09686778f, 
    -0.17938873f, 0.09163215f, 0.02529567f, -0.01118217f, 0.03403245f, 0.12157218f, 0.21660326f, -0.17901674f, 
    0.01537971f, 0.05893306f, -0.11506022f, 0.03194525f, -0.01853576f, -0.14094472f, -0.00447687f, -0.10010588f, 
    -0.29066005f, 0.33937755f, 0.10054772f, 0.16525958f, -0.02717611f, 0.01426883f, -0.18685390f, -0.24599615f, 
    -0.00142361f, -0.04494661f, 0.20557059f, 0.08198112f, 0.05481937f, -0.25735050f, -0.20997211f, -0.41550577f, 
    0.16782801f, 0.12721999f, -0.24134843f, 0.02435865f, 0.18229668f, 0.09982173f, 0.05781954f, -0.12845710f, 
    -0.00272609f, -0.09483423f, 0.05388379f, 0.01323133f, 0.11208890f, 0.22448111f, -0.03901638f, -0.03219684f, 
    0.06769118f, -0.11142606f, 0.31769606f, 0.10021526f, -0.25733584f, 0.14097607f, 0.02349373f, -0.06025086f, 
    -0.01374185f, 0.09526607f, -0.12164891f, -0.08967661f, -0.06866754f, 0.15431009f, 0.18764919f, 0.23371100f, 
    -0.04670659f, 0.12406836f, 0.10859860f, -0.19301972f, -0.00963709f, -0.24170502f, -0.19146134f, -0.12176548f, 
    -0.02291550f, 0.19623536f, 0.03631726f, 0.15795913f, 0.29096699f, 0.36194849f, -0.06719549f, 0.16835171f, 
    0.32842037f, 0.00901998f, 0.01409380f, -0.01234145f, 0.01076218f, 0.05397603f, -0.06296423f, 0.00311868f, 
    0.06146249f, 0.11598131f, 0.10247102f, -0.07165354f, -0.02169885f, -0.11682457f, -0.16655076f, -0.09189507f, 
    -0.37279201f, -0.25847834f, 0.06494672f, -0.15083294f, 0.11971658f, -0.02126377f, 0.07023165f, 0.20280384f, 
    0.11566643f, -0.37495711f, 0.20284851f, -0.15162310f, 0.36378816f, -0.08557846f, -0.02208779f, 0.00644364f, 
    0.03349899f, 0.49474251f, -0.11148404f, -0.29114315f, 0.08544095f, -0.32871395f, -0.04176818f, 0.13893759f, 
    0.08286477f, -0.09004290f, 0.03787615f, -0.01358224f, 0.29605502f, 0.00506425f, -0.08551235f, 0.04326235f, 
    0.15551978f, -0.13886678f, 0.01335271f, -0.02427827f, 0.07723334f, 0.44627643f, 0.07323597f, -0.07916510f, 
    -0.43591449f, -0.04710221f, -0.12786452f, -0.00201516f, 0.09049249f, -0.10917608f, 0.09948888f, 0.08306531f, 
    -0.02445267f, 0.06764973f, 0.09152061f, -0.02466657f, 0.11572841f, -0.06198046f, 0.01459280f, 0.23340796f, 
    -0.09452521f, 0.27164122f, -0.01027143f, -0.00144645f, -0.00966015f, 0.10812386f, 0.05153628f, 0.22283344f, 
    0.16710804f, -0.00927039f, -0.01542237f, 0.01787717f, -0.00026741f, -0.15449440f, 0.19303940f, 0.26678059f, 
    0.27251604f, 0.03052657f, -0.11950564f, 0.15750143f, -0.00995531f, 0.11478016f, 0.02243130f, -0.19071056f, 
    -0.13031368f, 0.18305686f, 0.11469217f, -0.18940440f, -0.13117798f, -0.19267692f, -0.05570729f, -0.03581766f, 
    -0.06259133f, 0.09751936f, 0.18727392f, 0.20338526f, -0.04446869f, -0.25738293f, -0.17561923f, -0.16084327f, 
    -0.09023985f, -0.03229467f, -0.05818852f, -0.12190890f, -0.05350133f, 0.06593151f, 0.16051778f, -0.11966595f, 
    -0.01195136f, 0.03746628f, 0.02363560f, -0.32720742f, 0.23250784f, 0.10242536f, 0.05739277f, 0.11636774f, 
    -0.07302494f, -0.13020934f, 0.05238874f, -0.02139167f, 0.24813619f, -0.17579752f, -0.20054710f, 0.05434186f, 
    -0.01483593f, -0.13483581f, 0.12472077f, 0.02480460f, -0.00420767f, 0.13491081f, -0.01717179f, 0.32207647f, 
    -0.02629327f, -0.07218786f, -0.09568778f, 0.03525344f, -0.02585687f, 0.00581367f, -0.29368562f, -0.11748647f, 
    0.14192607f, -0.09104411f, -0.17474161f, 0.16471940f, -0.20556149f, 0.01593078f, 0.02461997f, 0.37087014f, 
    0.31397402f, 0.07317784f, 0.00384756f, -0.03592538f, -0.07562492f, -0.01833677f, 0.00430170f, 0.00844375f, 
    0.01999045f, -0.00850380f, -0.06504140f, -0.06673302f, -0.03092233f, -0.00619845f, -0.00385271f, -0.09445038f, 
    0.01309229f, 0.02443716f, 0.03804403f, 0.03509292f, -0.03315531f, -0.04744191f, 0.05653927f, -0.04776831f, 
    -0.06161605f, -0.08618137f, 0.02356344f, -0.02097945f, 0.02331975f, -0.11046878f, -0.03855072f, -0.00517393f, 
    -0.06596562f, -0.05749090f, -0.02504909f, -0.08892545f, -0.08013153f, -0.07934146f, -0.00976389f, 0.01246693f, 
    -0.04491640f, 0.02025083f, 0.03192957f, -0.06309799f, 0.01845950f, 0.02195640f, 0.01632880f, 0.07740328f, 
    0.05010433f, -0.00982585f, 0.07878791f, -0.02960530f, -0.06009911f, -0.06584002f, -0.08091716f, 0.00240463f, 
    -0.02437278f, -0.04428501f, -0.00137716f, -0.07209054f, -0.07310534f, -0.08607452f, -0.06056484f, -0.03981992f, 
    -0.02226211f, 0.08155590f, -0.01491977f, -0.09480222f, -0.06987570f, -0.10251339f, 0.03749863f, -0.08725341f, 
    0.00677219f, 0.05934190f, -0.02517829f, -0.08918269f, 0.06087211f, 0.00991204f, 0.01645941f, -0.02308530f, 
    -0.04021797f, -0.06862747f, -0.07459600f, -0.10705236f, -0.03682869f, -0.00682821f, -0.01871299f, -0.08984350f, 
    -0.05543828f, 0.01404690f, 0.00394609f, -0.09029870f, -0.03912344f, -0.06901319f, -0.07682911f, -0.08524390f, 
    -0.04998701f, -0.05094663f, 0.05139541f, 0.07364791f, -0.08535486f, 0.02457346f, 0.01453406f, -0.06314651f, 
    -0.08625579f, -0.05328793f, 0.02298856f, 0.00699627f, -0.09822137f, 0.00168169f, -0.03172397f, -0.05690328f, 
    -0.07604752f, 0.06104796f, 0.02643411f, -0.09230371f, -0.00059084f, -0.08795647f, -0.13336580f, -0.02750567f, 
    -0.07527763f, -0.03827389f, -0.05669337f, -0.09072977f, 0.03156816f, 0.05380026f, -0.02331981f, -0.12174116f, 
    -0.01038715f, -0.01725955f, -0.04599928f, -0.00573817f, -0.08914105f, -0.03173736f, 0.05622298f, -0.06658716f, 
    -0.07186844f, 0.00454574f, -0.01054144f, -0.06027899f, -0.03711374f, -0.06981931f, -0.09781048f, -0.12977369f, 
    -0.13924532f, -0.03859595f, 0.00252200f, 0.07616483f, -0.04336748f, 0.00982353f, -0.12387334f, -0.06126853f, 
    -0.07425860f, -0.07016082f, -0.07660054f, 0.06185900f, -0.05195777f, 0.04737469f, -0.07647125f, 0.04792529f, 
    0.06480968f, 0.06089567f, -0.03403613f, 0.05252216f, 0.05120816f, 0.02018697f, -0.05224779f, -0.07218710f, 
    0.00947655f, -0.00304548f, -0.05112489f, 0.06671931f, 0.00610801f, -0.06587797f, -0.04427779f, 0.01532703f, 
    0.00017782f, 0.00940478f, -0.00961079f, -0.08671296f, 0.01868965f, -0.02221662f, 0.05812764f, -0.00187305f, 
    -0.06361616f, 0.06570170f, -0.03807106f, -0.07726262f, -0.03297541f, 0.06851552f, -0.04013917f, -0.04448448f, 
    -0.05890761f, -0.05874661f, -0.04914514f, -0.07178248f, 0.06452659f, 0.04800009f, 0.04612403f, 0.00554432f, 
    -0.07825281f, -0.05591286f, -0.01732312f, 0.06865203f, -0.06803332f, -0.00273688f, 0.05106414f, 0.03613755f, 
    -0.04864223f, -0.07848135f, 0.03455607f, 0.03592174f, -0.08454496f, -0.02170504f, 0.04775713f, 0.02487934f, 
    0.05685932f, 0.00189933f, -0.05156774f, 0.03646607f, -0.04217960f, 0.02727508f, -0.00877941f, -0.04153294f, 
    -0.08247918f, -0.05227583f, -0.04716126f, 0.04427849f, 0.02652798f, -0.08844507f, -0.07296460f, 0.04677378f, 
    0.00613389f, 0.05800552f, -0.00731870f, 0.02054475f, 0.05855820f, -0.05790096f, -0.03116439f, 0.00978787f, 
    -0.04053041f, -0.01870244f, -0.02372333f, -0.00600935f, 0.04090219f, -0.08636732f, 0.05490519f, 0.01728359f, 
    -0.00968444f, 0.00526496f, -0.00812271f, 0.01153276f, 0.03970463f, -0.02683109f, 0.05809176f, -0.02344269f, 
    -0.07197943f, -0.07743771f, 0.05747678f, -0.02616687f, 0.02404316f, -0.08511348f, -0.02895519f, 0.05243152f, 
    -0.07663958f, 0.01566992f, 0.05858329f, 0.00595593f, -0.05331400f, -0.06556506f, -0.04157728f, -0.09561084f, 
    -0.05749600f, -0.07308138f, 0.05079947f, 0.03063426f, -0.08398610f, -0.02006048f, 0.04882152f, 0.05356604f, 
    -0.04557914f, 0.06682327f, -0.06774160f, -0.09167074f, -0.03982875f, 0.02025743f, -0.07410065f, -0.01613396f, 
    -0.05995145f, -0.00969648f, 0.06582302f, 0.06036869f, 0.03057079f, -0.00476926f, -0.00173856f, 0.01698944f, 
    -0.10031440f, 0.11076381f, 0.00252540f, -0.20476885f, -0.16410935f, 0.13653216f, 0.07252082f, 0.14489001f, 
    -0.10215941f, 0.14911047f, -0.25878549f, -0.35154670f, -0.01551479f, 0.06138743f, 0.32796967f, -0.09942716f, 
    -0.00862822f, 0.00051636f, 0.57263476f, -0.40467992f, -0.21069118f, 0.01677075f, 0.06450007f, -0.11358594f, 
    0.15180865f, 0.07633544f, -0.22475986f, -0.45701581f, 0.01771124f, 0.03202123f, -0.16612236f, -0.10657208f, 
    0.08617178f, -0.09963697f, 0.05145252f, 0.06879108f, 0.14263156f, -0.20485494f, -0.44181386f, 0.22306170f, 
    0.12651220f, -0.04345263f, -0.01373448f, -0.06414504f, 0.03625758f, -0.26692197f, -0.33437827f, 0.20743833f, 
    -0.26391581f, 0.00179127f, -0.11400750f, -0.05949974f, 0.07542802f, 0.11984120f, 0.18341513f, 0.43303248f, 
    0.22805987f, -0.06112434f, -0.14560750f, -0.11317668f, -0.02971409f, -0.04838898f, 0.14382453f, 0.03707634f, 
    -0.52935594f, -0.48513192f, 0.20118044f, -0.22789049f, 0.03588462f, 0.05202694f, 0.28640908f, 0.06923123f, 
    -0.05418944f, -0.30005738f, 0.34659293f, -0.14735083f, -0.12450549f, -0.14877905f, 0.00529722f, 0.08285568f, 
    0.12616338f, 0.64812142f, -0.14140175f, -0.13686080f, -0.10328405f, 0.09356137f, -0.01842481f, 0.06162012f, 
    -0.09279437f, -0.04111378f, -0.27155733f, 0.08334693f, -0.49674788f, 0.06221093f, -0.00076665f, -0.03548725f, 
    0.25373104f, -0.05026095f, -0.11760990f, -0.50434655f, -0.17595197f, -0.30666447f, 0.13142361f, 0.19122115f, 
    -0.14164981f, -0.07314843f, -0.02891495f, -0.08030783f, 0.41770470f, -0.11439101f, 0.13327573f, 0.05031159f, 
    0.02719122f, 0.07288377f, 0.22971137f, -0.03167586f, -0.00813158f, -0.01017479f, 0.22083801f, 0.22571771f, 
    -0.07966389f, 0.13826445f, -0.08896176f, 0.08371874f, -0.15190893f, 0.06555131f, 0.13495770f, 0.24368927f, 
    -0.38758031f, 0.09521104f, -0.08300152f, 0.01221868f, 0.06018120f, 0.20966119f, -0.05940506f, 0.39299777f, 
    0.04641500f, 0.07164276f, 0.10899951f, -0.08527116f, 0.08167078f, 0.04928024f, 0.06221116f, 0.02338870f, 
    -0.20332222f, -0.27347109f, -0.18155721f, 0.11010919f, -0.17036894f, 0.07864814f, 0.13973938f, 0.29560554f, 
    -0.14176911f, -0.28295892f, -0.32597160f, -0.39417395f, -0.02534903f, -0.09645091f, -0.16270871f, -0.00669369f, 
    -0.24644600f, -0.10161392f, -0.03492837f, 0.07762685f, 0.13664779f, -0.04044364f, -0.09997521f, -0.01404907f, 
    -0.20769577f, 0.11633141f, 0.02353577f, -0.19282164f, 0.17563692f, 0.29656494f, -0.04987497f, 0.11465617f, 
    -0.09811702f, -0.10025495f, -0.03587727f, 0.15397407f, 0.43946013f, 0.24940385f, 0.10391276f, -0.18761687f, 
    0.04646912f, -0.15871492f, -0.04267824f, 0.01465327f, 0.05826684f, 0.64188260f, 0.15066020f, 0.24073440f, 
    0.04416793f, 0.02363350f, 0.06666992f, 0.08848000f, 0.07015774f, 0.32833266f, 0.07316257f, -0.15568820f, 
    -0.00126578f, -0.06807398f, 0.06152609f, -0.00087418f, 0.11881443f, 0.04424409f, 0.26610795f, -0.25719342f, 
    0.10766394f, -0.02709498f, 0.11326794f, -0.07459257f, 0.11346911f, 0.11124284f, 0.03875214f, -0.03974058f, 
    -0.06492700f, -0.30781054f, -0.11244323f, 0.11806551f, 0.06038054f, -0.19484136f, 0.00255319f, 0.11467697f, 
    -0.05384512f, -0.34532589f, 0.02579049f, 0.09635381f, -0.11154435f, 0.09150165f, -0.07056966f, -0.05158102f, 
    -0.06083255f, 0.03797182f, -0.15946448f, 0.02556341f, 0.13223326f, 0.11582279f, -0.02738414f, -0.03418482f, 
    -0.07084176f, 0.00059611f, -0.04292521f, 0.14090765f, -0.25999475f, 0.25855052f, -0.01540284f, 0.10880549f, 
    0.01349435f, 0.20483246f, 0.08226416f, -0.11594529f, 0.02860993f, 0.18153815f, -0.06557452f, 0.02564094f, 
    0.06009395f, -0.00476355f, -0.03237968f, -0.14190492f, -0.16515990f, 0.23923521f, -0.04424201f, -0.36043838f, 
    -0.05603850f, -0.35345781f, -0.09503937f, 0.06700715f, 0.13959451f, -0.01057012f, -0.09356903f, -0.30599025f, 
    -0.16514629f, 0.07651171f, 0.06093455f, 0.30662721f, 0.03964930f, 0.26627821f, 0.04584761f, -0.11505599f, 
    -0.01135167f, -0.13186182f, -0.19596876f, 0.12343438f, -0.09343244f, 0.00023947f, -0.16132486f, -0.11996902f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.20691095f, 0.18980114f, 0.18079549f, 0.07189240f, 0.29220003f, 0.25429031f, 0.27047244f, 0.06581672f, 
    0.00671574f, 0.11968835f, 0.16677377f, -0.22648187f, -0.07203444f, -0.06700610f, -0.11140297f, 0.24798934f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.27290606f, -0.19398706f, 0.48846740f, 0.17650145f, -0.52633274f, 0.43864286f, 0.34647444f, 0.07941854f, 
    -0.32565445f, 0.10805885f, 0.13755253f, -0.53275895f, 0.20986345f, -0.18436295f, -0.44149908f, -0.49159330f, 
    0.36333448f, 0.24709703f, -0.48240846f, -0.14148034f, -0.05253351f, -0.39226478f, 0.02145172f, 0.21157879f, 
    0.05562824f, 0.08835351f, -0.11652543f, 0.22494538f, 0.08365426f, 0.23653875f, 0.76172262f, -0.04626622f, 
    -0.29697591f, 0.25318184f, 0.04432148f, -0.43722159f, -0.08960389f, 0.19938533f, 0.28220466f, 0.20877206f, 
    -0.29098514f, 0.28025374f, 0.49380857f, -0.61179924f, 0.16093704f, 0.02820709f, -0.29910785f, 0.02845130f, 
    0.05222258f, 0.21780623f, -0.17245473f, 0.21227770f, -0.70423609f, -0.65468299f, -0.12126771f, 0.08416982f, 
    -0.10797341f, 0.36307946f, 0.34390733f, 0.07540679f, -0.17217557f, -0.01491392f, -0.02395352f, -0.26097286f, 
    -0.02811477f, 0.34444124f, -0.15772216f, -0.53115880f, -0.70824409f, -0.55854774f, 0.25565633f, 0.23824987f, 
    -0.05763787f, 0.36392537f, 0.10531139f, -0.18598528f, -0.02511933f, 0.01023746f, -0.43848732f, 0.05106346f, 
    0.03005357f, -0.18969531f, -0.82318699f, 0.34264022f, 0.03401949f, 0.01588488f, 0.12659024f, -0.15381359f, 
    0.42392242f, -0.09416560f, -0.34279367f, 0.18484625f, 0.12542243f, 0.11577000f, 0.67362827f, -0.44578087f, 
    0.30956960f, 0.09654275f, 0.13718569f, 0.59330660f, 0.23238376f, 0.29070485f, -0.29387292f, -0.12307665f, 
    -0.51703882f, 0.24282657f, 0.21657988f, -0.45855951f, -0.14920698f, 0.03708720f, 0.03356376f, -0.44675326f, 
    0.04688102f, -0.76839477f, -0.38136184f, 0.35191128f, -0.50153285f, 0.00899141f, -0.31992665f, -0.18043773f, 
    -0.36394426f, 0.20819364f, 0.22962499f, 0.45886561f, -0.12098202f, -0.05494536f, 0.31599259f, -0.99095279f, 
    -0.12128790f, 0.52448773f, -0.21433328f, 0.17980193f, 0.11427491f, -0.50502855f, 0.20342520f, 0.04503539f, 
    -0.40040892f, 0.06909930f, 0.15261477f, 0.16873097f, 0.18075901f, 0.14748330f, 0.16242750f, 0.02867035f, 
    0.12122417f, 0.31441551f, -0.23247404f, 0.46788138f, 0.35535869f, -0.40936202f, -0.11354113f, 0.22904487f, 
    -0.33007714f, -0.00231562f, 0.13306271f, 0.13158447f, -0.14443080f, 0.15580720f, 0.44740918f, 0.00708469f, 
    -0.01214607f, 0.03479357f, 0.06845117f, -0.10956786f, 0.03520786f, -0.19637983f, 0.04080420f, -0.20217821f, 
    -0.29487389f, -0.28681552f, -0.21493416f, 0.31081635f, -0.15487006f, 0.20129147f, 0.04208789f, 0.14590029f, 
    0.08175093f, 0.30649593f, 0.08765229f, 0.60949427f, 0.33615896f, -0.32062325f, 0.27489829f, -0.10868433f, 
    -0.25922924f, -0.13294734f, -0.08333529f, 0.21518151f, 0.03615971f, -0.23882718f, -0.29908723f, -0.35852131f, 
    0.36420617f, 0.06763575f, -0.47209981f, 0.52478439f, -0.37220556f, 0.28835317f, -0.11717643f, 0.15627122f, 
    0.08168345f, 0.07074735f, 0.20521541f, 0.19017306f, 0.18561079f, -0.07684762f, 0.39058897f, -0.06020105f, 
    -0.11009078f, 0.20287850f, -0.09245246f, -0.09931441f, -0.17087291f, 0.19960590f, -0.23621617f, 0.03317013f, 
    -0.17522049f, -0.01940644f, -0.02440311f, -0.21153247f, -0.00794876f, -0.05508679f, -0.05440988f, 0.01572174f, 
    0.14440383f, 0.15413193f, 0.41570422f, -0.06825321f, -0.07433617f, 0.37605262f, 0.23853350f, -0.16589692f, 
    0.08624191f, 0.16846567f, -0.17668687f, -0.67729068f, -0.16898084f, -0.08226079f, -0.29847074f, 0.16637178f, 
    -0.02401424f, 0.32895908f, -0.23593508f, -0.36424547f, 0.53084320f, 0.03023437f, -0.00317500f, -0.20076549f, 
    -0.12350252f, 0.07645552f, -0.13244338f, 0.47589573f, -0.11739928f, -0.04205510f, -0.16081075f, -0.14443932f, 
    0.17451967f, 0.24444048f, 0.51877207f, 0.21155821f, -0.20445190f, -0.44792098f, 0.31923425f, -0.21626043f, 
    -0.41386300f, 0.24330899f, 0.17358030f, -0.51345187f, 0.16294138f, 0.14499114f, -0.54682887f, 0.00620442f, 
    -0.33273208f, 0.01759408f, -0.24779652f, -0.25188005f, 0.27769235f, -0.74192965f, 0.04354989f, -0.09146936f, 
    0.05656197f, 0.25403765f, 0.14483036f, -0.14980271f, 0.23240213f, -0.18456167f, 0.44492844f, 0.55889702f, 
    0.00388686f, -0.15951659f, -0.03889930f, -0.22340032f, 0.05581197f, 0.02776715f, -0.23672172f, -0.16448310f, 
    -0.22386894f, 0.14026439f, -0.04297503f, -0.23285529f, 0.03217962f, -0.22011217f, 0.15143795f, -0.08317907f, 
    0.27286521f, -0.24695581f, -0.50591236f, 0.25533587f, -0.13594115f, -0.18892640f, -0.09118943f, -0.06959537f, 
    -0.08571994f, 0.51410985f, -0.25690785f, 0.24649012f, -0.01886159f, 0.03765497f, 0.01984292f, -0.19803880f, 
    0.30992645f, 0.12059852f, -0.50125933f, 0.42257002f, -0.08627904f, 0.50040388f, 0.08491527f, 0.07404523f, 
    0.50151110f, -0.03905772f, -0.24098486f, -0.72253203f, -0.15534450f, 0.08987258f, 0.30023792f, 0.04724368f, 
    0.22924817f, 0.38771287f, 0.03028556f, 0.32601437f, -0.21599729f, 0.15505096f, 0.18819910f, -0.04314065f, 
    0.03523824f, -0.19636591f, -0.41628194f, -0.10201636f, -0.06141187f, -0.19361801f, -0.09601384f, 0.51692867f, 
    0.43164852f, 0.26122335f, -0.20414472f, -0.03789549f, 0.16859157f, -0.23685497f, 0.28651628f, 0.01355085f, 
    -0.30324563f, 0.26577067f, -0.43355441f, -0.40995532f, 0.14643461f, -0.07643346f, -0.19200803f, 0.35878912f, 
    0.36298871f, -0.21593529f, -0.11144856f, 0.22395691f, 0.15792304f, 0.46043041f, 0.19556938f, 0.11364750f, 
    0.26035839f, -0.12719855f, -0.08112966f, 0.29994386f, -0.03402203f, 0.19987215f, -0.68981713f, 0.08253526f, 
    0.12951392f, 0.08295124f, -0.36076349f, -0.28527474f, -0.53156900f, 0.30445695f, -0.00013770f, -0.14732705f, 
    -0.08580431f, 0.32524168f, 0.40698528f, -0.71725535f, -0.12446252f, 0.23434307f, 0.13442622f, -0.61333567f, 
    0.36947277f, -0.24907309f, 0.06264928f, -0.07731897f, 0.28517231f, -0.32206553f, 0.13592975f, 0.10389870f, 
    -0.08749013f, 0.08913089f, 0.56216133f, 0.03327801f, -0.01620722f, -0.18784486f, 0.09471858f, -0.45709470f, 
    0.36515006f, -0.05359853f, -0.47090253f, 0.13817567f, -0.01824072f, 0.08169369f, 0.33919525f, -0.06459495f, 
    0.47648078f, -0.16541940f, -0.03339851f, -0.41536537f, -0.05422795f, 0.23129119f, -0.40891635f, 0.37317801f, 
    0.16063648f, 0.21955995f, 0.09975129f, -0.14782305f, -0.11713146f, -0.08184136f, -0.27168307f, -0.06616929f, 
    0.08446072f, -0.12892576f, 0.22322655f, 0.35607970f, 0.12306179f, 0.05020578f, 0.76395774f, 0.42023304f, 
    -0.23610032f, 0.05493840f, 0.50589210f, -0.10917372f, 0.53761148f, -0.37131020f, -0.02943227f, -0.24646029f, 
    0.20324194f, 0.09945466f, 0.01889464f, -0.03200542f, -0.10582541f, 0.09461820f, -0.01333146f, -0.40328720f, 
    0.08761850f, -0.15624903f, 0.09121627f, 0.11023159f, 0.19347525f, 0.18817258f, -0.05997803f, 0.19948110f, 
    -0.12393492f, -0.17219102f, -0.13686004f, -0.12886353f, 0.19005764f, 0.01592070f, 0.11440875f, 0.00916275f, 
    0.10524721f, -0.38819849f, -0.60122883f, 0.27681050f, -0.01652839f, -0.39949003f, 0.38157585f, 0.04747791f, 
    -0.15811235f, 0.02021187f, 0.10943802f, 0.63382995f, 0.06799906f, -0.13788030f, -0.65176302f, 0.24370578f, 
    0.25428301f, -0.23518442f, -0.25891960f, 0.30544946f, 0.19982487f, -0.07148225f, 0.21447630f, 0.10837612f, 
    0.14974578f, 0.03676916f, -0.18610787f, -0.03440254f, 0.11984303f, 0.06707720f, 0.65088463f, 0.21105960f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.12783878f, -0.29909518f, 0.34757414f, 0.04616231f, -0.12138934f, 0.05705206f, 0.11334944f, -0.22812673f, 
    -0.29631802f, 0.12173466f, 0.16968410f, -0.01686438f, 0.11834918f, -0.09033909f, 0.23525786f, -0.35844478f, 
    0.43252838f, 0.15061505f, -0.13687570f, 0.26521805f, 0.22406103f, 0.24000694f, 0.21428335f, 0.14378288f, 
    0.40683535f, 0.19816184f, -0.04104270f, -0.29696533f, 0.16495325f, -0.24240638f, 0.15866394f, 0.15670496f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.45709822f, 0.52763379f, 0.03092544f, 0.31940228f, 0.37046340f, 0.28633323f, 0.41621387f, 0.60621423f, 
    0.10743055f, 0.40612370f, 0.52255398f, -0.72842604f, 0.44573757f, 0.14486185f, -0.39274716f, -0.13620022f, 
    -0.08057894f, 0.44651121f, -0.05982134f, 0.41694325f, 0.09447224f, -0.50795096f, -0.21321362f, -0.43197039f, 
    0.38412154f, 0.31757104f, -0.35073000f, 0.49311191f, -0.32879063f, -0.03860093f, -0.32938790f, 0.21923493f, 
    0.65609348f, -0.27565527f, 0.36017641f, 0.42382205f, 0.16519094f, -0.19018899f, 0.76280707f, 0.57589447f, 
    -0.60159117f, -0.10104086f, 0.09179122f, -0.33991101f, -0.10330049f, 0.09170695f, 0.22786725f, -0.57841575f, 
    0.27868655f, -0.23427099f, -0.12201803f, 0.20345640f, 0.20707171f, -0.22675586f, 0.10249066f, -0.41714594f, 
    0.86999452f, 0.16320892f, -0.16742224f, -0.67742914f, 0.20579050f, 0.15903053f, -0.45494545f, -0.11802498f, 
    -0.08514709f, 0.06496964f, 0.14961523f, 0.50219727f, 0.42956248f, -0.44854581f, 0.00932610f, -0.78058439f, 
    0.09300281f, -0.06501675f, 0.57297748f, 0.09586849f, -0.28533372f, 0.02276872f, 0.19810852f, 0.07758459f, 
    0.18627718f, 0.16052501f, 0.15133280f, -0.00036560f, -0.44817111f, 0.38070887f, 0.23366523f, -0.09449229f, 
    0.07344542f, -0.15851538f, -0.21939670f, 0.06461985f, 0.35504892f, -0.06361158f, -0.75975275f, 0.10659911f, 
    -0.20620672f, 0.37612832f, -0.13890480f, -0.01126997f, -0.23819941f, 0.12965813f, 0.36635494f, -0.13071974f, 
    0.76436651f, 0.57317007f, 0.23505762f, 0.48796567f, -0.06710732f, 0.08151293f, 0.16917458f, 0.37205726f, 
    0.08189976f, -0.20688188f, -0.13598500f, 0.09487066f, 0.10430553f, 0.31314382f, 0.31863689f, -0.29212147f, 
    -0.40866825f, -0.03746866f, 0.08856468f, 0.04342016f, 0.06323861f, -0.09307948f, -0.27130499f, -0.05792082f, 
    -0.08588244f, 0.00892049f, -0.10656968f, -0.04588293f, -0.11143380f, -0.14936261f, -0.04810692f, -0.14292850f, 
    -0.00951969f, -0.05752571f, -0.07644989f, 0.00199199f, -0.10560190f, -0.08334078f, -0.00673245f, -0.06117994f, 
    0.04640035f, -0.14117090f, -0.08786113f, -0.06281145f, -0.15255697f, 0.00961734f, -0.02024941f, -0.00264467f, 
    0.04256973f, -0.02019597f, -0.03362905f, -0.16960593f, -0.03617194f, -0.15155122f, -0.13860703f, 0.13696292f, 
    0.29406413f, 0.03437179f, -0.06704200f, -0.13650163f, 0.32135969f, 0.28043395f, -0.56076175f, 0.08497222f, 
    -0.22749975f, -0.18732162f, 0.06781037f, -0.14330173f, 0.09073693f, 0.08585405f, 0.28551167f, -0.33568677f, 
    0.17590675f, -0.36805180f, 0.07923097f, 0.27195349f, 0.01457505f, 0.44612244f, 0.19598392f, 0.44243839f, 
    -0.13556236f, -0.31128302f, 0.42536229f, -0.55485624f, -0.33733186f, 0.14194083f, 0.57740116f, 0.14700392f, 
    0.92255926f, -0.02793565f, 0.43150070f, 0.45072904f, 0.45258084f, -0.21009819f, 0.14523236f, 0.16478810f, 
    0.09039434f, -0.08438645f, 0.08169823f, 0.30825880f, -0.07283408f, 0.05864894f, 0.10985615f, -0.16745469f, 
    0.45591342f, -0.31651059f, 0.07973655f, 0.03163798f, -0.33702829f, -0.12637967f, 0.22530152f, -0.40474790f, 
    0.43241036f, 0.15085177f, -0.33066657f, -0.26536879f, 0.03619971f, 0.00315377f, 0.16275997f, -0.03111495f, 
    0.08832696f, 0.25024119f, 0.20092535f, 0.25815794f, 0.39883003f, 0.05190817f, -0.00994560f, -0.21400625f, 
    -0.32083413f, -0.26724401f, 0.00211064f, -0.76481837f, 0.07261846f, 0.13718207f, 0.07044044f, -0.59962356f, 
    -0.09109759f, -0.04547248f, 0.00461356f, 0.30080926f, 0.17547150f, -0.19261074f, 0.19658521f, -0.36503366f, 
    0.73556709f, 0.06501971f, -0.20642920f, 0.15660663f, -0.76095486f, -0.11744840f, -0.07786700f, -0.03752077f, 
    -0.07730269f, -0.03522532f, -0.18379045f, -0.04585746f, 0.08530113f, 0.14372167f, -0.14681371f, -0.18296754f, 
    0.00391914f, -0.12114881f, 0.12975764f, -0.08079709f, 0.03458522f, -0.00011618f, -0.16235226f, 0.08916654f, 
    -0.06122072f, -0.18262072f, -0.10785791f, -0.07565989f, 0.09474088f, -0.07840071f, 0.04619917f, 0.05643235f, 
    0.10575018f, -0.09463802f, -0.01815638f, -0.07703252f, -0.10201550f, 0.05128814f, 0.03493323f, -0.10807827f, 
    -0.01063966f, 0.06158732f, 0.24079418f, -0.37413010f, 0.07392356f, -0.84951836f, 0.14131360f, 0.05538620f, 
    0.70178115f, 0.64846039f, -0.41972935f, 0.27532399f, -0.42370811f, -0.05148118f, 0.08639672f, 0.16008399f, 
    0.59305137f, 0.66746068f, 0.07565734f, -0.48925859f, -0.43007341f, 0.23070762f, 0.30133343f, -0.13397963f, 
    -0.20662177f, 0.12431606f, -0.18089211f, -0.22608425f, 0.18888791f, 0.15158561f, 0.38744277f, -0.19792821f, 
    0.54516995f, -0.10718777f, -0.13330849f, -0.05927242f, -0.07340311f, -0.04434143f, 0.29015487f, -0.13572019f, 
    0.24513087f, -0.01175543f, -0.07874699f, 0.55822361f, 0.05549745f, -0.13993594f, -0.05825087f, -0.12965441f, 
    0.39210400f, -0.82817602f, -0.07655964f, -0.07956421f, 0.16066799f, 0.22530785f, 0.22113630f, 0.34296629f, 
    -0.13348664f, 0.14150369f, -0.03971717f, -0.50459629f, -0.22129062f, -0.15313056f, 0.54076511f, -0.15561967f, 
    0.01535151f, 0.17581293f, -0.03150146f, -0.08115993f, -0.10048705f, 0.01564223f, 0.27606863f, 0.25735793f, 
    0.04029916f, 0.13954589f, 0.23698324f, -0.17037636f, 0.41084161f, 0.08740093f, 0.04630752f, -0.13124456f, 
    0.13261439f, -0.21021584f, -0.01148281f, 0.08122758f, 0.47442833f, 0.42087892f, 0.24086958f, 0.04475018f, 
    -0.03818026f, -0.00426161f, 0.43600270f, 0.16151787f, -0.39858058f, -0.17667748f, 0.21774757f, 0.35461548f, 
    -0.28036872f, 0.39277351f, -0.38398066f, 0.45591637f, -0.12131184f, 0.13565931f, 0.20400909f, 0.50438935f, 
    0.61473316f, 0.60113227f, 0.27786773f, 0.33678690f, 0.45509320f, -0.07740661f, -0.01052117f, 0.27460897f, 
    -0.12809497f, 0.20368895f, 0.18448758f, 0.53740531f, -0.10384437f, 0.12118498f, -0.01049659f, 0.07728749f, 
    0.05469046f, 0.27354592f, -0.20835711f, 0.06944881f, -0.06712047f, 0.15102725f, 0.22150633f, 0.15445201f, 
    0.04559716f, 0.15309565f, -0.08927208f, -0.47335073f, -0.31774959f, -0.49159291f, -0.37269869f, -0.38742802f, 
    -0.18459664f, 0.14010604f, -0.12890187f, -0.13159913f, -0.08231805f, 0.13532196f, 0.15498668f, -0.20589295f, 
    0.04162137f, 0.25684923f, -0.13752484f, -0.73593611f, -0.05024182f, -0.21316510f, -0.01675015f, 0.08104569f, 
    0.09194779f, 0.66390729f, 0.22676535f, 0.18966328f, 0.38788003f, 0.05653405f, 0.48255417f, 0.43305793f, 
    0.13010572f, -0.38835800f, 0.52240342f, -0.12384349f, 0.53381240f, -0.26494649f, -0.33135664f, 0.07330253f, 
    0.08923072f, -0.22904320f, 0.08043059f, -0.30863851f, -0.23548456f, -0.02656242f, 0.32566467f, -0.47143868f, 
    0.47086570f, 0.29403466f, -0.03390920f, -0.77455461f, 0.26056644f, 0.26951599f, 0.01576787f, -0.02283962f, 
    0.40709788f, 0.11535179f, 0.35743028f, -0.00750364f, -0.17004795f, -0.13440013f, -0.13675351f, -0.10385724f, 
    -0.12943891f, -0.05806382f, -0.08249211f, 0.01830119f, -0.15376702f, -0.12966819f, 0.00652476f, -0.09878677f, 
    -0.12293572f, -0.05011631f, -0.14778124f, -0.16424546f, 0.01221135f, -0.05740422f, -0.01737820f, -0.18833213f, 
    -0.04718731f, -0.10584113f, -0.15585609f, -0.14704134f, -0.13638696f, -0.05460826f, 0.01970074f, -0.03803241f, 
    -0.04633749f, 0.06633402f, -0.12494305f, -0.19662313f, 0.14571540f, 0.11356331f, -0.03155050f, -0.15188587f, 
    0.52254999f, -0.05840741f, -0.27334920f, -0.19534206f, -0.79645908f, -0.15525602f, 0.43697986f, -0.23715474f, 
    -0.18542448f, 0.07591982f, 0.18145047f, 0.57224828f, 0.20999844f, -0.09137437f, 0.25597620f, -0.16147444f, 
    0.20938025f, -0.59720665f, 0.13990571f, -0.09896217f, 0.33660930f, 0.34639946f, 0.17493661f, 0.19425355f, 
    -0.09160645f, 0.23979987f, 0.18138447f, -0.19787833f, -0.01671361f, -0.05688103f, 0.03033560f, -0.05962420f, 
    -0.58165401f, 0.44107124f, 0.03684618f, -0.19968654f, 0.08038831f, 0.29865211f, -0.33330211f, -0.09603912f, 
    0.57213622f, 0.22874561f, 0.57520312f, 0.19927163f, 0.09568447f, 0.10011970f, 0.08499821f, 0.03427938f, 
    -0.08703543f, 0.25890127f, 0.14203680f, 0.07557485f, 0.34362665f, 0.35338295f, 0.31230250f, -0.06862509f, 
    -0.31107888f, -0.03721824f, 0.48450789f, -0.34033412f, -0.25617406f, 0.08889043f, -0.00701961f, 0.24646536f, 
    0.35804862f, 0.28103951f, 0.36139247f, 0.31282040f, 0.82792580f, -0.18325186f, -0.16702063f, 1.17437351f, 
    -0.04987526f, 0.10103332f, -0.46245828f, -0.09401339f, -0.14749993f, 0.20675603f, -0.03333838f, 0.01925305f, 
    0.02773463f, 0.33675340f, -0.13036871f, -0.07211385f, -0.19138475f, -0.20941518f, 0.12668854f, 0.16136965f, 
    0.14166884f, 0.21411410f, 0.09813646f, 0.17139806f, 0.05609211f, -0.12646925f, 0.69190431f, -0.14775887f, 
    -0.24885759f, -0.02648439f, -0.03846567f, -0.37823659f, -0.73525012f, 0.40384993f, 0.20856535f, -0.63066041f, 
    -0.26557636f, 0.33610857f, 0.35406855f, 0.16292386f, 0.22419906f, 0.11987209f, 0.03198428f, 0.15122047f, 
    -0.01397651f, -0.15505165f, -0.15653975f, 0.13400179f, 0.57591891f, 0.13726853f, -0.00522077f, 0.28188401f, 
    0.01715097f, 0.19180283f, 0.17496251f, 0.21532761f, 0.14562385f, -0.07816490f, -0.33128628f, 0.24925268f, 
    -0.03323786f, 0.35617232f, 0.31278834f, -0.26376563f, 0.14979328f, 0.08014487f, -0.43971118f, -0.33251548f, 
    0.13022205f, -0.09097674f, 0.54680353f, -0.30334294f, 0.04155875f, 0.15553853f, 0.14614342f, -0.26261604f, 
    0.01734363f, -0.01348770f, -0.07343837f, -0.12216461f, -0.14785494f, 0.27928683f, 0.13076824f, -0.25659764f, 
    -0.16472147f, 0.12468785f, 0.20050311f, 0.30718255f, 0.01216447f, 0.12483250f, -0.27258360f, 0.16889544f, 
    0.40921918f, -0.48028922f, 0.39134848f, 0.41007540f, 0.07520659f, -0.59977919f, 0.36929813f, -0.47071221f, 
    -0.05316037f, -0.01588394f, 0.02085809f, 0.37673202f, -0.33168519f, -0.09927721f, 0.00423909f, 0.13833082f, 
    0.30117664f, 0.06556413f, -0.16735594f, 0.00816943f, -0.32172194f, -0.34339020f, -0.04641572f, 0.18848275f, 
    0.49686307f, 0.31139189f, 0.03296865f, -0.32971695f, 0.50402987f, 0.06765907f, 0.06803754f, -0.34779739f, 
    -0.07527641f, 0.15197079f, -0.02086178f, -0.25974327f, 0.01736663f, 0.22667718f, -0.01433884f, -1.17914474f, 
    -0.06692925f, 0.00427517f, 0.43098435f, -0.05861494f, -0.02588051f, 0.10280792f, 0.07335548f, -0.38365760f, 
    0.08120637f, 0.22015715f, 0.02077504f, -0.34327406f, 0.53446507f, 0.56454498f, 0.26464272f, -0.03103017f, 
    0.02863442f, -0.11628414f, 0.43530026f, 0.03493563f, -0.15204518f, 0.06268468f, -0.40534455f, 0.08752801f, 
    -0.48775601f, 0.38467020f, 0.01716966f, 0.16936393f, 0.00896045f, 0.38947141f, 0.25379109f, -0.22246267f, 
    0.06920480f, 0.08480217f, 0.33396190f, -0.06887721f, 0.04672300f, 0.11001384f, 0.04462590f, 0.22700444f, 
    0.12459596f, 0.21317869f, -0.13562755f, 0.22796890f, 0.36411962f, -0.03089292f, 0.30783519f, -0.29884037f, 
    0.22842199f, -0.16447680f, 0.14316364f, 0.05666474f, -0.41101766f, 0.07133145f, -0.62341237f, 0.12169247f, 
    0.20345354f, -0.13523242f, 0.16758905f, -0.35329923f, -0.41075492f, 0.03648479f, 0.46460453f, -0.46163747f, 
    -0.30451837f, -0.08718732f, 0.43455207f, -0.31031585f, 0.09573054f, 0.06590763f, 0.31447968f, 0.03130010f, 
    -0.05853712f, -0.14732867f, -0.15822360f, 0.06651199f, 0.13480128f, 0.24773200f, 0.21514969f, 0.27349067f, 
    0.30891451f, -0.15320621f, 0.06496079f, 0.41170678f, 0.07600303f, -0.02875492f, -0.54600209f, -0.07411297f, 
    0.07943347f, 0.12617277f, -0.08646929f, -0.13509263f, -0.07862755f, -0.06555862f, -0.15568739f, -0.13618477f, 
    0.14377463f, -0.04239245f, 0.17436039f, -0.19786891f, -0.11676217f, -0.17155457f, 0.09446232f, 0.00046189f, 
    -0.06324557f, -0.00612221f, -0.13181654f, -0.09937456f, -0.15374584f, -0.06395730f, -0.15989813f, -0.03865619f, 
    0.13495943f, -0.06813931f, -0.07900727f, -0.14165029f, -0.03371731f, 0.10252450f, -0.13832210f, -0.10577738f, 
    0.00601037f, -0.19147630f, -0.19602737f, -0.10037236f, 0.04935707f, -0.12932986f, -0.05655245f, -0.05033715f, 
    0.13022034f, -0.08645488f, 0.17234105f, 0.10820570f, 0.00234147f, 0.11760557f, -0.12305748f, -0.06428135f, 
    -0.12188652f, -0.02457585f, -0.11089436f, 0.13670325f, -0.11729109f, -0.12306305f, -0.17033739f, 0.04369781f, 
    -0.12647989f, 0.08439589f, -0.16268113f, -0.13094561f, -0.07253696f, 0.05592467f, -0.04467591f, -0.03164568f, 
    0.07796521f, -0.16569000f, 0.69391704f, 0.28047782f, 0.82375681f, -0.24220130f, -0.21654356f, -0.21800478f, 
    -0.40998337f, -0.40640438f, -0.28901285f, -0.48272356f, 0.01086012f, -0.02883662f, 0.38307679f, -0.22645912f, 
    0.22085114f, -0.02469335f, -0.02048569f, 0.21345536f, -0.06951452f, 0.19334973f, 0.04994802f, 0.19785206f, 
    0.41347864f, 0.16775398f, 0.52895170f, 0.18854846f, -0.14530483f, 0.13669893f, 0.25788176f, -0.18400280f, 
    -0.44114938f, 0.31605804f, -0.12806137f, 0.16934581f, 0.16141306f, 0.03426900f, -0.03965098f, -0.03511946f, 
    0.07507281f, 0.05267868f, -0.01324091f, -0.09042469f, 0.17608547f, -0.02952074f, -0.00612789f, 0.12858723f, 
    0.02686085f, -0.05488293f, -0.12647128f, 0.28413975f, 0.12930718f, -0.38775709f, 0.02160064f, 0.19039485f, 
    -0.00370341f, 0.32920861f, 0.31021559f, -0.07637656f, -0.15673889f, 0.11309149f, 0.58522105f, 0.21418868f, 
    -0.31781039f, 0.00750387f, -0.01974765f, -0.33180651f, -0.15157095f, 0.22891775f, -0.49473649f, -0.65571660f, 
    0.43555030f, 0.00150431f, 0.05317343f, 0.27206966f, 0.08498492f, 0.09262617f, 0.07227843f, -0.09863558f, 
    0.27073243f, 0.15989622f, 0.11551137f, 0.14223115f, 0.26354474f, 0.28247333f, 0.20836106f, 0.21111733f, 
    -0.53649223f, -0.13479465f, 0.24646990f, -0.07173989f, -0.36976787f, -0.03605422f, 0.75672626f, 0.25503448f, 
    0.06204128f, -0.20091699f, 0.39896142f, -0.25803792f, 0.15525328f, 0.42091450f, -0.22608247f, -0.43167555f, 
    -0.12358079f, -0.12510902f, 0.26714382f, -0.61017156f, -0.02254619f, 0.12374520f, 0.39549419f, -0.26335397f, 
    0.19829160f, 0.10705438f, -0.01745662f, 0.07535099f, 0.45669147f, 0.28840443f, 0.36045027f, 0.21736889f, 
    0.13733411f, -0.21198125f, 0.14745428f, -0.21346192f, -0.30905908f, -0.07518683f, -0.16546722f, 0.10855488f, 
    -0.27485585f, 0.14375883f, -0.04092895f, -0.34313178f, -0.07233993f, 0.53015387f, -0.10529565f, 0.13358787f, 
    -0.71316183f, -0.40700364f, 0.05240149f, -0.39844435f, 0.34849527f, 0.15365224f, -0.04868568f, 0.02407448f, 
    -0.12262700f, -0.31200594f, -0.01947792f, 0.15873650f, 0.56683230f, -0.02820221f, 0.15625602f, 0.47797662f, 
    -0.03997548f, 0.20776106f, 0.58014125f, -0.20412916f, -0.20332985f, -0.03149623f, 0.23498602f, 0.23836133f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.01734111f, 0.02627906f, 0.49406350f, -0.13497061f, -0.04004682f, 0.12688465f, 0.08396352f, 0.06130958f, 
    -0.15112601f, 0.24133827f, 0.22377621f, -0.18493752f, 0.08312096f, 0.28469911f, 0.08618084f, 0.01448174f, 
    0.19761476f, -0.33320796f, -0.38051486f, 0.34015709f, -0.17701487f, 0.61922622f, 0.33470130f, 0.03582000f, 
    -0.11927040f, -0.13408870f, -0.13535197f, 0.39176700f, 0.32728598f, 0.21106641f, 0.46540517f, 0.02881635f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.49196070f, -0.10085430f, -0.26839593f, -0.00588533f, -0.04778511f, -0.54466498f, -0.43197164f, 0.03931755f, 
    0.03864943f, -0.72780228f, -0.74912018f, 0.01809891f, 0.19657068f, 0.12715016f, 0.08224566f, -0.05037610f, 
    -0.49423504f, 0.08997115f, -0.00805659f, 0.21067466f, -0.34924018f, 0.07619440f, -0.26944950f, 0.26399496f, 
    0.08382687f, -0.11226645f, -0.04448454f, -1.05722344f, 0.02113604f, -0.29663333f, -0.51620746f, 0.11411998f, 
    -0.08329973f, -0.40791401f, 0.13695633f, 0.19761404f, -0.07283744f, -0.04964788f, -0.64823335f, 0.10494082f, 
    -0.06280153f, 0.13719997f, -0.20352624f, -0.00832183f, 0.03737521f, -0.28356618f, -0.23607063f, -0.13430917f, 
    -0.00481738f, 0.26365182f, -0.79437447f, 0.37454447f, -0.01051070f, 0.05962352f, 0.34307608f, 0.29969102f, 
    0.15628365f, 0.05020018f, -0.20084894f, -0.26614586f, 0.01313641f, 0.21518224f, 0.21541427f, 0.12754083f, 
    -0.51906884f, 0.53581065f, -0.08198529f, -0.60035175f, 0.08097079f, 0.13866599f, 0.10426595f, 0.44089112f, 
    -0.04659319f, -0.70019037f, 0.13860272f, -0.02784246f, -0.33391672f, -0.04266468f, -0.09601954f, 0.01808303f, 
    0.15610670f, -1.07828128f, -0.13957363f, 0.13694675f, -0.19296348f, 0.14046276f, 0.06793872f, -0.08514256f, 
    0.46959129f, 0.03995744f, -0.09256353f, 0.35333228f, -0.24461444f, -0.35672694f, 0.26766726f, -0.50799894f, 
    0.20542675f, 0.08508993f, -1.08767307f, -0.35041612f, 0.10353095f, -0.04096631f, 0.19523117f, 0.23625140f, 
    -0.08492503f, -0.48092338f, -0.23639792f, -0.06022322f, 0.14727935f, 0.14020364f, -0.39728749f, 0.12900619f, 
    -0.68278289f, -0.15972012f, 0.36005560f, -0.17530301f, -0.43977025f, 0.00079255f, -0.55133861f, 0.07874688f, 
    -0.56357044f, -0.10698599f, -0.12415478f, 0.32216790f, 0.19917628f, -0.17609993f, -0.02709750f, 0.00111397f, 
    0.11727869f, 0.06579193f, 0.13649748f, 0.33977214f, -0.00573711f, -0.11773862f, 0.19542821f, -0.09321855f, 
    -0.08700363f, -0.40238222f, 0.32850200f, 0.14648357f, 0.34716910f, 0.14003205f, -0.61417609f, 0.04387792f, 
    0.46551123f, -0.23641536f, 0.03781231f, 0.06001636f, 0.47107551f, -0.95413631f, -0.70519555f, -0.05641675f, 
    -0.03015969f, 0.08149227f, 0.03967396f, -0.38754052f, -0.00355640f, -0.12588657f, -0.28692821f, -0.17415465f, 
    -0.11228400f, -0.08671086f, -0.24031715f, 0.32817012f, -0.09779192f, 0.07131460f, -0.34045532f, -0.12451173f, 
    0.05687639f, 0.13840051f, 0.07205076f, 0.13230120f, -0.06734747f, -0.48744866f, -0.25292599f, 0.09561893f, 
    0.19407114f, 0.15081277f, 0.05036733f, 0.16471528f, -0.12554666f, -0.58356494f, 0.00729530f, 0.28900167f, 
    0.28056037f, 0.09415257f, 0.08454812f, 0.10792694f, -0.07804704f, -0.08246566f, 0.06768890f, 0.18995534f, 
    -0.77293158f, 0.47400782f, 0.23331362f, -0.11066024f, -0.00928276f, -0.02836675f, 0.40841919f, -0.96496046f, 
    0.10174348f, 0.27941057f, 0.10668392f, -1.06180191f, -0.74771065f, 0.07550166f, 0.29414645f, -0.08220656f, 
    0.02941689f, -0.34196326f, 0.11210152f, -0.29859254f, -0.09488863f, 0.40734518f, -0.31289884f, -0.69197619f, 
    0.13216153f, -0.00511995f, 0.10111459f, 0.05685078f, -0.80248958f, -0.35599968f, -0.03681421f, -0.99257463f, 
    -0.09194607f, -0.48025414f, -0.00907635f, 0.19319853f, -0.11994447f, 0.08483706f, 0.02964877f, -0.46461561f, 
    0.03494272f, 0.43090582f, 0.61717016f, -0.45807457f, 0.13024405f, 0.31736338f, -0.76901174f, -0.04912592f, 
    0.23119605f, 0.01952307f, 0.10793626f, 0.05465573f, -0.27577147f, 0.09757464f, -0.26540709f, -0.35568190f, 
    -0.50695753f, -0.15444744f, 0.03008354f, -0.97112226f, 0.17106079f, 0.28854033f, -0.93503988f, -0.49308556f, 
    -0.98068047f, -0.29901341f, -0.44564548f, -0.36053264f, -0.05755118f, 0.08931204f, -0.39572501f, -0.91030675f, 
    -0.13635918f, 0.19335173f, -0.06721372f, 0.20260188f, -0.43175539f, 0.48065886f, 0.54844546f, 0.12939638f, 
    0.05171096f, 0.05030411f, 0.04102321f, 0.10206150f, 0.29396632f, -0.28363627f, 0.24214152f, -0.27558109f, 
    -0.12187358f, 0.12972884f, 0.13028029f, 0.28671706f, -0.01960632f, 0.32957739f, 0.13583545f, 0.41799420f, 
    0.14618827f, 0.21463907f, 0.37873694f, -0.10704039f, -0.11943171f, -0.25817534f, 0.24609153f, -0.10564272f, 
    -0.27338344f, -0.07491316f, -0.14604139f, -0.37004057f, -0.00740185f, -0.00853916f, -0.04100640f, -0.01832779f, 
    0.07183816f, -0.45919991f, 0.19319871f, -0.03817959f, -0.21898890f, 0.33753979f, 0.17717226f, 0.18837088f, 
    -0.51762658f, -0.01862738f, 0.08003122f, 0.21223809f, 0.03719839f, -0.51150340f, -0.11554664f, -0.79354638f, 
    -0.86513448f, -1.06010401f, 0.02966885f, -0.02613523f, -0.11799592f, 0.52230513f, -0.22499830f, -0.83358437f, 
    0.13952048f, -0.51089895f, 0.46266827f, 0.05980384f, 0.10737451f, -0.37122104f, -0.68524611f, -0.04807816f, 
    0.20376089f, 0.11376964f, -0.05283118f, 0.05046473f, -0.47861537f, -0.02977615f, -0.20766626f, -0.22438785f, 
    -0.64564282f, 0.12692389f, -0.01734273f, 0.12337061f, 0.13532774f, 0.41459396f, 0.15717989f, 0.40551382f, 
    -0.64499837f, -0.57867986f, 0.10660078f, -0.09758879f, 0.09681059f, 0.39110434f, 0.17139417f, 0.22244303f, 
    -0.03082064f, 0.29215708f, -0.10327873f, -0.06383697f, -0.30674183f, -0.38933724f, 0.49756768f, -0.02073554f, 
    -0.45798793f, 0.42044395f, 0.09764356f, -0.82289785f, 0.36519593f, -0.26633343f, 0.34972107f, 0.06184313f, 
    -0.49451315f, 0.12252198f, -0.00483743f, 0.18581423f, -0.34961399f, 0.26404253f, 0.23124836f, -0.89910316f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.09038243f, 0.42605355f, 0.05601289f, 0.17185548f, -0.03152102f, -0.27685174f, -0.14943916f, -0.19956405f, 
    0.03956245f, 0.19497675f, 0.32026520f, -0.52028269f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
