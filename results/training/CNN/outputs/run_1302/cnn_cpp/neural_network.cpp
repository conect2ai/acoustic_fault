#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.80979967f, -1.00683093f, -0.47467637f, 0.96642143f, 0.60858196f, 0.28119206f, -0.15360452f, -0.49348694f, 
    0.26716128f, 0.31878585f, -1.24713326f, 0.36191937f, -1.11739898f, -0.74052203f, 0.05660631f, -0.46733668f, 
    -0.63737971f, 0.41672811f, -0.12607576f, -0.84064037f, -0.18559518f, -0.36925673f, -0.99251956f, -0.52544850f, 
    0.59857875f, 0.93228358f, 0.63389736f, 1.42924690f, -1.38358128f, 0.18049642f, -0.57082111f, 0.66442138f, 
    -0.43140426f, -0.29294169f, 0.00433310f, -0.39884678f, -0.71082246f, -0.73971826f, -0.23030195f, 0.32476684f, 
    -0.15671659f, -0.29022986f, -0.59184122f, -0.65364605f, -0.81439829f, 0.64369518f, -0.32523555f, 0.44311216f, 
    0.27175951f, 0.27442360f, 0.30697522f, 0.03472467f, -0.09050697f, 0.68657935f, 0.21438253f, -0.69294959f, 
    0.46748647f, 0.90413767f, 0.52035993f, -0.64906776f, -0.29362866f, 0.01590855f, -0.31578302f, -0.12702480f, 
    -0.93579561f, -0.99412835f, 0.53746176f, -0.41911003f, 0.05108317f, 0.01839676f, -0.68474311f, -0.65607154f, 
    0.32628110f, 1.31412721f, 0.13504334f, -1.07119262f, -0.46643746f, 0.05418334f, -0.16027737f, 0.39904538f, 
    0.25005382f, 1.02392352f, -0.95825648f, -0.83498585f, 0.36961302f, -0.45942378f, 0.52724242f, -0.55052912f, 
    0.30000001f, 0.17833957f, -0.72669405f, -0.26780307f, 0.77199018f, 0.17733146f, 0.38497469f, 0.58622342f, 
    -0.34498787f, -0.58621269f, 0.66693389f, -0.22530533f, -0.82734406f, -0.96648222f, 0.17359690f, 0.44129625f, 
    0.83875555f, 0.55644524f, -0.18556632f, 0.26113588f, -0.67405629f, -0.61153990f, -0.40408620f, -0.54175204f, 
    -0.66641665f, -1.01020396f, 0.02672301f, 0.34519249f, -0.42070761f, -0.76486832f, 0.93860471f, -0.13604958f, 
    -0.90549237f, -0.23623301f, 1.16840339f, -0.46405345f, 0.19198477f, 0.13402052f, 0.34731027f, -0.42431530f, 
    0.32623935f, -0.09422347f, -0.03730072f, 0.15109293f, 0.77134556f, -0.52393854f, -0.17899093f, -0.50607413f, 
    -0.68770087f, -1.07333601f, 0.61612105f, 0.17820647f, -0.09856199f, -0.20980801f, 0.29564524f, 0.28462279f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05738958f, 0.49314499f, 0.59799916f, 0.11445996f, 0.25213361f, -0.06093490f, 0.31913263f, -0.03478096f, 
    0.29705137f, 0.51757532f, -0.03404141f, -0.08451004f, -0.22489940f, 0.37911591f, 0.24314450f, 0.35762015f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.42808500f, -0.09665036f, -0.19007736f, 0.13540992f, -0.25435778f, -0.17285512f, -0.06116933f, 0.08182588f, 
    0.00632086f, 0.08314937f, -0.02804372f, -0.04727410f, -0.07520335f, -0.05125115f, 0.03421742f, -0.00660781f, 
    0.06716367f, 0.09111229f, -0.09425148f, -0.03762370f, 0.55172908f, 0.24432334f, 0.56632620f, -0.02539430f, 
    -0.09464259f, -0.00059519f, 0.09534276f, 0.06547941f, 0.15786888f, 0.08297887f, 0.00805610f, 0.00456731f, 
    0.04217643f, 0.18414696f, 0.03316706f, -0.05158953f, 0.06601425f, -0.06639221f, 0.09975855f, -0.00659846f, 
    0.55028731f, 0.20663223f, 0.29663807f, -0.19181959f, -0.04449037f, 0.07275604f, -0.06488137f, 0.07378688f, 
    0.05866140f, 0.23337352f, 0.12015370f, 0.02432215f, -0.01106643f, -0.05404565f, -0.00783835f, 0.00671179f, 
    0.01168758f, -0.02953943f, 0.13317439f, 0.10791359f, 0.16295528f, 0.15825221f, -0.16193205f, -0.11830577f, 
    0.07476562f, 0.10820546f, -0.10171935f, -0.32718882f, 0.41537148f, -0.07220791f, -0.04100622f, 0.06384754f, 
    0.03228946f, -0.10781184f, 0.07352344f, -0.11485010f, 0.12858789f, -0.15006529f, 0.10095423f, 0.06377155f, 
    -0.11702644f, 0.15060931f, 0.12446731f, 0.03041986f, -0.32052937f, -0.06586131f, 0.08960590f, 0.08271087f, 
    -0.09742320f, 0.04975893f, -0.00096256f, 0.02982537f, 0.06826449f, 0.10062946f, 0.01769783f, 0.03576408f, 
    0.08859168f, 0.04975314f, -0.08302400f, 0.16014555f, -0.12858292f, -0.23376718f, 0.07944823f, 0.05888926f, 
    -0.04533202f, 0.04251514f, 0.04221741f, -0.00585211f, 0.03947975f, 0.00541208f, 0.14273059f, 0.13278139f, 
    0.22779030f, 0.22353411f, 0.31030309f, 0.02601119f, 0.00829894f, -0.05548701f, 0.07060064f, 0.07523058f, 
    -0.21020477f, -0.05693375f, -0.17157792f, -0.12761441f, -0.25042149f, -0.00945743f, -0.01036697f, 0.06714591f, 
    -0.02287053f, -0.00765272f, -0.06838457f, 0.05538636f, 0.10597955f, 0.06491287f, 0.07901753f, -0.19202162f, 
    -0.00576743f, 0.05607784f, 0.06139988f, -0.02233204f, 0.07118548f, 0.07450773f, 0.09264707f, 0.21462314f, 
    -0.24560155f, -0.07555330f, 0.17959574f, -0.11362582f, -0.14450075f, 0.10493691f, -0.10920261f, -0.04043848f, 
    -0.07042111f, 0.26750341f, 0.08693680f, 0.00364029f, 0.03232647f, 0.02311993f, 0.21987444f, 0.10088846f, 
    -0.04196367f, 0.00676979f, 0.31547543f, 0.27200550f, 0.04880488f, 0.00590690f, -0.03738962f, -0.11318670f, 
    -0.09152452f, -0.00163761f, -0.11349694f, 0.00173432f, -0.04825516f, 0.04572076f, 0.04963140f, 0.07690907f, 
    0.11849567f, 0.08301521f, -0.16461967f, -0.10042336f, -0.12729447f, -0.35210389f, 0.17832869f, 0.38090974f, 
    -0.31559020f, 0.19775611f, -0.09913614f, -0.21562485f, 0.07054020f, -0.02708599f, -0.08601952f, -0.03454388f, 
    -0.00558458f, -0.06576687f, 0.04719404f, 0.04949892f, 0.05126847f, -0.07835072f, 0.09398877f, -0.11837537f, 
    -0.06553841f, -0.26221618f, 0.21654713f, -0.15042447f, 0.12106011f, 0.02561987f, -0.07818557f, 0.14292637f, 
    0.04032901f, 0.01313652f, 0.12387987f, 0.08490877f, -0.06567736f, -0.03225223f, 0.10813650f, -0.06476583f, 
    -0.10096011f, 0.04502023f, 0.02414281f, -0.01760661f, 0.00037753f, -0.34150729f, 0.19279255f, 0.16336390f, 
    -0.02735976f, 0.05957495f, 0.09253791f, -0.05855860f, 0.20131738f, -0.03147358f, 0.16535734f, -0.03870679f, 
    -0.08982074f, 0.01834756f, -0.09731109f, -0.09152248f, 0.00228606f, 0.14261141f, -0.00498014f, -0.05351574f, 
    0.30076021f, 0.28507632f, 0.42760849f, -0.11773628f, -0.06741586f, 0.11936722f, 0.02512858f, 0.19999659f, 
    -0.17067212f, 0.12361404f, -0.00272297f, -0.03802456f, 0.07791273f, 0.08493229f, -0.03668988f, -0.02744742f, 
    0.07378349f, -0.09612831f, 0.02609778f, 0.06193306f, 0.03456331f, -0.24056846f, 0.26405945f, 0.10056902f, 
    0.03620116f, 0.32899851f, -0.22576684f, -0.24557734f, 0.21901362f, -0.20843467f, -0.05432684f, -0.12315773f, 
    -0.07280950f, -0.06277738f, 0.03395456f, 0.11734936f, -0.04216499f, 0.04104699f, -0.23490952f, 0.08549479f, 
    -0.11008980f, -0.25019732f, -0.16186675f, 0.17852171f, -0.02027048f, -0.04949090f, -0.10432566f, 0.13634326f, 
    0.06743838f, -0.03746496f, -0.04622930f, 0.15969241f, 0.00937144f, 0.10709352f, 0.10950284f, 0.25743282f, 
    -0.00492391f, 0.14378144f, -0.14733967f, 0.05040251f, 0.02834241f, -0.00157091f, -0.09802936f, 0.31902078f, 
    -0.01395253f, 0.02100381f, 0.00278292f, -0.20751981f, -0.09790035f, 0.11196039f, -0.00697625f, -0.15088880f, 
    0.06173948f, -0.08986162f, 0.05073523f, 0.02272873f, 0.05768783f, 0.08412155f, 0.05383924f, -0.05175018f, 
    -0.02677537f, 0.01394077f, -0.02154419f, 0.03410269f, -0.00444186f, 0.01545631f, -0.02723789f, 0.03920229f, 
    0.02239738f, 0.01364663f, -0.01535519f, 0.02470611f, -0.05285860f, 0.03480169f, 0.02494887f, -0.03312674f, 
    0.00292556f, -0.05526082f, -0.01983149f, -0.04705857f, 0.02887607f, 0.04118676f, 0.01871755f, -0.04044052f, 
    -0.05717316f, 0.03925380f, -0.04227736f, -0.02013054f, -0.03823438f, -0.01787714f, 0.02943162f, 0.01506500f, 
    -0.03097434f, 0.03704929f, -0.01129941f, -0.06193120f, -0.02238235f, 0.04260478f, -0.05690522f, -0.01960578f, 
    0.01778378f, 0.01724225f, -0.01797092f, -0.01767272f, -0.00183596f, 0.02916805f, -0.05058539f, 0.01114578f, 
    -0.02086394f, 0.03679794f, -0.05301315f, 0.02487644f, -0.03499028f, -0.03191317f, 0.00866171f, -0.00855885f, 
    0.00900466f, -0.04280847f, -0.04965051f, -0.02259360f, 0.03587669f, -0.02516321f, 0.01481417f, 0.01671652f, 
    -0.00036313f, -0.02674599f, 0.01047132f, -0.01527327f, -0.04435846f, -0.05754510f, 0.03236622f, -0.00681149f, 
    0.01493995f, -0.05942004f, 0.05035368f, -0.03516874f, 0.01913605f, -0.05450669f, 0.02848234f, -0.02756425f, 
    -0.04394650f, 0.01271820f, 0.04886676f, -0.00690489f, -0.03200860f, -0.04001283f, -0.02980015f, -0.04271222f, 
    -0.05130221f, -0.01443002f, -0.03237786f, -0.04700608f, 0.04469080f, 0.03404929f, -0.02779382f, -0.01431811f, 
    -0.00950418f, -0.04598220f, -0.05259075f, -0.04133516f, -0.05976794f, -0.05520052f, -0.01899165f, 0.02061622f, 
    -0.00217147f, 0.01711347f, -0.02521691f, -0.04813601f, 0.00730158f, -0.01540626f, -0.00281326f, -0.00653893f, 
    0.02500931f, -0.00583900f, 0.04965481f, 0.03929752f, -0.02978998f, -0.05324692f, -0.04843814f, 0.01107495f, 
    -0.02632592f, 0.00303738f, 0.02029005f, -0.04444342f, -0.02205749f, -0.03014258f, -0.01662096f, -0.02270007f, 
    -0.00477735f, 0.04506540f, -0.03178200f, -0.01381955f, -0.05484678f, 0.00836904f, -0.04833946f, 0.02741481f, 
    0.01720189f, -0.03000128f, -0.01605660f, -0.02638272f, -0.01083342f, -0.05968569f, -0.00218083f, -0.01500462f, 
    -0.06304812f, -0.01958765f, -0.01903099f, -0.04959080f, 0.04795754f, -0.03525583f, 0.00471257f, 0.00778035f, 
    -0.00203622f, -0.02921466f, -0.01119763f, 0.02903610f, -0.04872021f, -0.05608102f, 0.03622511f, 0.00709555f, 
    0.00150085f, 0.01204746f, -0.03443873f, 0.03407395f, -0.02330106f, 0.00817633f, 0.03673371f, -0.01178888f, 
    0.04464976f, -0.04647149f, 0.03200232f, -0.04141389f, -0.02546780f, -0.04285596f, 0.04064325f, 0.01116275f, 
    -0.04909602f, 0.04791465f, 0.03900553f, -0.06038481f, -0.05268216f, -0.04924112f, -0.00625483f, -0.00887061f, 
    -0.03990793f, -0.01552733f, -0.00322519f, -0.03633435f, 0.02256607f, -0.05233550f, -0.01638291f, 0.04689603f, 
    0.04732572f, -0.05266777f, -0.00450935f, 0.02263755f, -0.02371870f, 0.03079204f, 0.03120149f, 0.04227767f, 
    -0.00468196f, -0.04320218f, -0.03995893f, -0.00260777f, -0.04163687f, 0.00777120f, 0.04216623f, -0.03180345f, 
    -0.01994028f, -0.00537494f, -0.04417091f, -0.03262075f, -0.04043183f, -0.04416000f, 0.02696775f, -0.02570889f, 
    0.04559560f, 0.01194373f, -0.06011149f, 0.03021302f, -0.00108795f, 0.05929803f, -0.04184072f, 0.02037800f, 
    0.00746986f, -0.01920406f, 0.03406686f, -0.00198572f, -0.05482043f, -0.00105697f, -0.05543372f, -0.00307847f, 
    -0.04073310f, 0.00040196f, 0.02442104f, -0.05625691f, -0.03712559f, -0.03797520f, -0.04713987f, 0.04304997f, 
    0.01276692f, 0.01559074f, 0.00760409f, 0.01342151f, -0.02795135f, -0.02155846f, -0.04018293f, -0.01460920f, 
    -0.05008863f, -0.02211811f, -0.05290253f, -0.00988826f, -0.01258004f, 0.00527426f, -0.03211806f, -0.05021448f, 
    -0.06154807f, -0.03902168f, -0.05827616f, -0.05539982f, -0.03672581f, -0.00272241f, -0.01082268f, -0.04130933f, 
    -0.01216983f, 0.04524287f, 0.02208161f, -0.05852664f, 0.00393900f, 0.04062888f, -0.05332861f, -0.01355240f, 
    -0.05012981f, -0.03449826f, 0.00686144f, -0.02909084f, -0.01543380f, -0.03255305f, 0.01981284f, -0.03239295f, 
    0.00385490f, 0.03410306f, -0.03688947f, -0.01115155f, -0.00497524f, -0.02465434f, 0.04256631f, 0.01099975f, 
    0.00844273f, -0.04442802f, 0.01627094f, 0.04665664f, 0.00012989f, -0.00261353f, -0.00240387f, 0.02326084f, 
    -0.01356387f, -0.03258220f, 0.01317808f, 0.01424409f, 0.00220033f, 0.00120784f, 0.04766457f, -0.01129030f, 
    -0.00773086f, 0.04794974f, 0.01119064f, 0.04693442f, 0.04353521f, -0.02636231f, 0.04690524f, -0.03524986f, 
    -0.02790490f, 0.00708164f, -0.05056467f, -0.01136767f, -0.02150703f, 0.02968921f, -0.00353375f, 0.03118126f, 
    -0.05594441f, 0.04090795f, -0.05383841f, 0.02425006f, 0.03557494f, 0.02848528f, 0.04739578f, -0.05969884f, 
    0.00135344f, 0.02962870f, 0.00918571f, -0.01717678f, -0.02476817f, -0.00684437f, 0.02928743f, -0.05129351f, 
    -0.04604807f, -0.04268727f, -0.05549976f, 0.03893371f, -0.01788759f, 0.01199661f, -0.02504567f, -0.04880537f, 
    0.04266888f, -0.04520518f, 0.02764379f, -0.00225845f, 0.04975049f, 0.02555128f, 0.01644693f, 0.03431834f, 
    0.04319725f, -0.05508047f, -0.04162086f, -0.04339088f, -0.01465799f, 0.04348518f, -0.02141494f, -0.02252847f, 
    0.03328568f, 0.01687957f, -0.05934004f, -0.05167785f, -0.02422374f, -0.02199866f, 0.01862984f, 0.00506694f, 
    -0.05439799f, -0.00139348f, -0.00187109f, -0.03374421f, -0.04816871f, 0.00786971f, -0.02989770f, 0.02909196f, 
    0.02417083f, -0.02584419f, 0.04558279f, -0.01652524f, -0.04726645f, -0.00863449f, 0.04231877f, 0.01171788f, 
    -0.01888317f, -0.05859245f, -0.01612745f, -0.01269373f, 0.01186254f, -0.03078645f, 0.04581367f, -0.03974316f, 
    -0.03877577f, -0.01477572f, 0.01566507f, -0.02128384f, 0.03537943f, -0.00349186f, -0.03484703f, -0.03525796f, 
    0.00106111f, 0.00250455f, 0.04140963f, 0.04021086f, 0.03713511f, 0.04031982f, -0.03054442f, -0.04507921f, 
    -0.04563434f, -0.00565225f, 0.00379031f, -0.01783246f, 0.00271990f, 0.05085529f, 0.02134392f, 0.02666020f, 
    0.02190985f, 0.00947790f, 0.00404591f, -0.02631094f, -0.01956635f, -0.03492669f, 0.03962844f, 0.05035238f, 
    -0.04406539f, 0.02480862f, 0.03811833f, -0.00124156f, 0.01900563f, -0.02247306f, 0.01566258f, -0.02325915f, 
    0.01409559f, -0.02974013f, -0.04800249f, -0.02489861f, -0.01568021f, -0.02366490f, 0.03468547f, -0.03097812f, 
    0.00632392f, -0.01866448f, -0.03602338f, -0.01107171f, 0.01344452f, -0.02949967f, -0.05728265f, 0.00522687f, 
    0.02975610f, 0.00356529f, -0.04484940f, -0.05233349f, 0.03719457f, 0.00731616f, -0.04752780f, 0.01846081f, 
    -0.04097551f, -0.02213383f, -0.01985845f, -0.00830704f, -0.01000257f, 0.04420676f, -0.02251364f, 0.01413441f, 
    -0.02808663f, -0.04204208f, -0.00857660f, -0.04897594f, -0.02644812f, -0.01609043f, 0.05184395f, -0.04694578f, 
    0.04969616f, -0.03891182f, 0.04722589f, -0.00273824f, 0.01930474f, 0.00725648f, -0.00382272f, -0.05787473f, 
    0.01818245f, 0.03572901f, -0.04891197f, 0.00862036f, 0.03705129f, -0.02935769f, -0.03035443f, -0.00743695f, 
    -0.00086006f, -0.01733888f, 0.05035486f, -0.04947571f, 0.01250845f, 0.01811531f, 0.00741454f, -0.04283622f, 
    0.00474116f, -0.05217249f, -0.04001409f, 0.03159057f, 0.00943687f, -0.02748203f, -0.04990545f, -0.04312552f, 
    -0.00825761f, 0.00637330f, 0.04456887f, 0.02477580f, -0.01690396f, 0.01908815f, 0.00075049f, 0.03377188f, 
    -0.01601042f, 0.02932045f, -0.03690182f, -0.01963980f, -0.05015405f, 0.03352961f, -0.04057789f, 0.02636658f, 
    0.01590655f, -0.02420098f, -0.02951456f, -0.05696581f, -0.01043679f, 0.04295747f, -0.04543107f, -0.03837173f, 
    0.02265560f, 0.00426464f, -0.00587828f, 0.00428064f, -0.03514450f, 0.02021930f, -0.03086872f, 0.00821792f, 
    0.02014490f, 0.03863159f, -0.03220234f, -0.04141203f, 0.03988308f, 0.03455294f, -0.04879694f, 0.04515577f, 
    -0.02948102f, 0.01731217f, -0.03302228f, -0.00061015f, -0.00894736f, -0.04941723f, 0.04725260f, 0.02034650f, 
    -0.02357327f, 0.04573501f, 0.00929245f, -0.04232300f, 0.04894198f, -0.02484789f, 0.02468186f, -0.02009571f, 
    0.04975924f, 0.03998284f, 0.00092681f, -0.02538163f, 0.01055136f, 0.04672286f, 0.03841735f, 0.04559589f, 
    0.03306277f, -0.05277835f, 0.02912906f, 0.01796878f, 0.01052940f, -0.02160592f, -0.03517605f, -0.01251460f, 
    0.00246853f, 0.03056088f, -0.03490853f, 0.01234818f, -0.05641111f, -0.01303330f, 0.00891190f, -0.04234136f, 
    -0.02052792f, 0.04689752f, -0.01321132f, 0.00221725f, -0.05493392f, -0.04267497f, -0.03206163f, -0.03422142f, 
    0.00378554f, -0.01660049f, -0.03670870f, 0.02159927f, -0.00227575f, 0.01632015f, -0.02122567f, -0.00363860f, 
    0.01604304f, -0.05084375f, 0.04482556f, 0.00303132f, 0.02386450f, 0.01493393f, 0.03650427f, -0.04143967f, 
    -0.02221396f, 0.04820404f, -0.00803038f, -0.03930806f, -0.00053993f, 0.04648148f, 0.01006287f, -0.04626611f, 
    0.04370512f, 0.04758336f, 0.04965705f, 0.02930729f, -0.05794337f, -0.02349415f, -0.00523235f, -0.04887050f, 
    0.05095578f, -0.03510487f, 0.02587275f, -0.03873639f, 0.02817807f, -0.01648849f, -0.02842410f, -0.00277595f, 
    -0.03113582f, -0.02107093f, 0.02225453f, -0.03737769f, -0.03179790f, 0.02105236f, 0.03989849f, 0.03371177f, 
    -0.05891601f, 0.23128067f, -0.27827942f, -0.15873949f, 0.22472648f, 0.13681987f, 0.06054543f, 0.09540841f, 
    0.16978571f, 0.10682659f, -0.14917921f, 0.09168337f, -0.01196385f, 0.25305709f, 0.05743070f, -0.09102118f, 
    -0.10459182f, -0.02118634f, 0.04514566f, 0.04177241f, 0.17991665f, -0.20873715f, -0.17689770f, 0.19015762f, 
    0.25812620f, 0.10473770f, -0.06295896f, -0.02538965f, 0.22970951f, -0.20437221f, 0.01436313f, 0.01721215f, 
    -0.10304504f, 0.05834004f, 0.04896004f, 0.04959054f, 0.06834458f, 0.07992850f, 0.24546306f, 0.07990036f, 
    -0.07848659f, -0.37487715f, -0.10856517f, 0.11569051f, 0.06070812f, 0.21198829f, -0.08493631f, -0.07382512f, 
    -0.08900974f, 0.01656509f, -0.03571307f, 0.00225421f, -0.11908831f, -0.16344510f, -0.00373173f, -0.00454494f, 
    0.04155977f, 0.13428900f, 0.07976197f, -0.07020950f, -0.53127885f, -0.04665726f, -0.17463869f, 0.57388264f, 
    0.24360381f, 0.19603662f, 0.06921423f, 0.33659360f, 0.25917882f, -0.08212107f, 0.10903487f, 0.08006309f, 
    0.11442930f, 0.08760469f, 0.05533641f, 0.13463186f, 0.16013134f, 0.17612697f, -0.02590751f, 0.03675382f, 
    0.00650417f, -0.04549306f, -0.44030714f, -0.05513067f, 0.26005587f, 0.04431668f, -0.05287217f, 0.07211421f, 
    0.09610850f, 0.14300075f, 0.02321929f, 0.01233916f, 0.06297473f, 0.24680477f, 0.14190909f, 0.18421412f, 
    0.13955916f, 0.25647572f, 0.01000983f, -0.00034287f, -0.26453686f, -0.05159822f, 0.01763948f, -0.19512022f, 
    -0.24619351f, -0.01898076f, -0.08035447f, -0.10500532f, 0.02045619f, -0.00399657f, 0.03501588f, 0.06939667f, 
    0.02232676f, 0.14358763f, 0.14760251f, 0.09195969f, -0.01397299f, 0.06014826f, 0.07566310f, -0.02032311f, 
    -0.68812525f, 0.50663018f, 0.00947614f, 0.19828236f, -0.24960874f, 0.00580202f, 0.01297903f, -0.02380740f, 
    -0.13551016f, -0.04446855f, -0.00118387f, -0.16046879f, 0.08567734f, 0.05778447f, 0.08551301f, -0.06301163f, 
    -0.13826782f, 0.08750125f, 0.05270418f, 0.09362356f, -0.18465731f, -0.17272955f, -0.35363516f, -0.07935472f, 
    0.40627411f, 0.04684944f, 0.00537208f, 0.03605133f, 0.08483528f, 0.03539528f, 0.00786532f, -0.08123218f, 
    0.05704699f, 0.17324969f, 0.00511135f, 0.13278715f, 0.12970166f, 0.30254111f, 0.11428910f, 0.02483058f, 
    0.04921734f, 0.02820904f, 0.21371286f, -0.02861554f, 0.01157159f, -0.20393634f, 0.03276904f, 0.35199580f, 
    0.12795834f, -0.21710584f, 0.02577873f, -0.00434682f, -0.01902374f, -0.08173415f, -0.01337363f, -0.02030928f, 
    0.07100704f, 0.24436074f, -0.01716330f, 0.08394318f, -0.58229578f, 0.02966370f, 0.20663361f, 0.00447269f, 
    0.47795856f, 0.18842959f, 0.01552511f, -0.01067560f, 0.17722358f, 0.01732997f, 0.02942186f, 0.07405436f, 
    -0.01251138f, -0.08982393f, 0.14275828f, 0.08308925f, -0.08173582f, 0.08011531f, 0.02999001f, 0.01021628f, 
    -0.05325718f, 0.28674752f, -0.19556479f, -0.22651067f, -0.40927139f, -0.02510902f, 0.03677643f, -0.01003141f, 
    -0.06918353f, 0.02744403f, 0.12672284f, 0.15615281f, 0.12847583f, 0.25097260f, 0.19738720f, -0.01947934f, 
    0.10934491f, -0.09075117f, 0.05357274f, -0.00714043f, -0.33030766f, 0.15697140f, 0.19554622f, -0.02872745f, 
    0.26367083f, -0.02280970f, 0.04852976f, -0.03221456f, 0.12888655f, 0.20885381f, -0.00302197f, 0.11010846f, 
    0.11522233f, 0.01002309f, 0.01985511f, -0.08237402f, -0.02760125f, 0.06614638f, 0.14577949f, -0.04649348f, 
    -0.12339678f, -0.37527779f, -0.31237999f, -0.05944717f, 0.15304881f, 0.05665846f, -0.00081216f, -0.03246116f, 
    -0.04457587f, -0.08634895f, -0.02466625f, -0.05987463f, -0.05265215f, -0.04182433f, -0.07314542f, -0.05138143f, 
    -0.00020762f, 0.13165849f, 0.10573727f, 0.00134280f, 1.23170495f, 0.43409708f, -0.04135355f, -0.18521355f, 
    0.25977162f, 0.05449740f, 0.13454974f, 0.22471499f, 0.34698671f, 0.00656830f, 0.06447875f, 0.05543483f, 
    0.03745008f, -0.03673268f, 0.05843469f, 0.22120279f, 0.11744393f, -0.07017709f, 0.05263864f, -0.12037737f, 
    0.07390410f, -0.06557501f, 0.13890229f, 0.19139674f, -0.20343709f, 0.04537189f, 0.06077983f, 0.02578964f, 
    0.02671736f, 0.09781982f, 0.08041517f, 0.00098307f, 0.13150904f, -0.04526265f, 0.03206192f, -0.04768925f, 
    0.25544098f, 0.08548386f, 0.12146712f, 0.08778589f, -0.11464960f, 0.05131086f, -0.07127789f, 0.00048414f, 
    0.40151396f, 0.14732628f, 0.00164731f, -0.02690720f, 0.04785902f, 0.20707080f, -0.05268894f, 0.01107093f, 
    -0.05599864f, 0.00278446f, -0.05046460f, -0.05809399f, -0.05107949f, 0.02688941f, -0.01241759f, 0.03517845f, 
    -0.03810420f, 0.04588533f, -0.00321991f, 0.03188372f, 0.03454877f, -0.05731390f, 0.00179761f, 0.02931498f, 
    0.00246763f, 0.02531547f, -0.04882125f, -0.05636085f, -0.04319737f, -0.02416622f, -0.05867240f, 0.03880076f, 
    -0.01497888f, -0.02176635f, -0.00595588f, 0.00970405f, 0.00614364f, 0.02291405f, -0.02819305f, 0.03617310f, 
    -0.05494440f, -0.04267462f, -0.00726155f, 0.03494569f, -0.00773356f, -0.01656241f, -0.00074207f, 0.00375586f, 
    -0.02024904f, -0.04136419f, -0.05909006f, -0.02022812f, -0.00081603f, -0.04892449f, 0.01314023f, 0.04408660f, 
    0.00723503f, -0.04601811f, -0.02185317f, 0.04034629f, -0.00098339f, -0.00950332f, 0.02944044f, 0.01446146f, 
    0.02376003f, -0.06118116f, -0.01418930f, 0.03991379f, 0.03727027f, -0.03039710f, 0.01961257f, 0.03757859f, 
    0.04220925f, -0.03401319f, -0.01857435f, -0.03317203f, -0.06362327f, -0.02888903f, -0.05446409f, -0.04668465f, 
    -0.04186055f, -0.02754052f, 0.01806065f, -0.02047173f, -0.02636950f, 0.02026524f, -0.03103409f, -0.00607666f, 
    0.02593608f, -0.04704410f, -0.00725481f, 0.04407926f, 0.01082750f, 0.02764736f, -0.02213681f, -0.03553294f, 
    -0.02767463f, -0.03524917f, -0.06011703f, -0.03797929f, 0.01433134f, -0.02908810f, -0.04396147f, 0.04026413f, 
    -0.00215560f, -0.04976256f, -0.06204056f, -0.05385168f, -0.00701327f, -0.04777217f, 0.00938244f, 0.02631094f, 
    -0.03744091f, -0.01607259f, -0.04567250f, -0.04977746f, 0.01292376f, 0.02918610f, 0.00106158f, -0.02444384f, 
    0.04229443f, 0.03262069f, 0.01570138f, -0.00454592f, -0.02279369f, 0.01536758f, 0.02534829f, 0.03889449f, 
    -0.01284607f, 0.00961315f, -0.03082785f, -0.02845555f, 0.04004576f, -0.06092492f, 0.01482698f, 0.00771867f, 
    0.02165508f, 0.02786791f, 0.04577113f, 0.03543480f, -0.05974480f, -0.03479837f, 0.04039393f, -0.04839113f, 
    -0.02261475f, -0.06315199f, -0.02145324f, -0.00234792f, 0.00375609f, -0.00773588f, 0.01564375f, -0.02539524f, 
    0.03748724f, -0.02604574f, -0.00826008f, -0.05121823f, -0.04103934f, -0.02589465f, 0.00075468f, 0.01933737f, 
    0.01905308f, 0.03163407f, 0.02028395f, 0.02940266f, -0.05945211f, 0.01654244f, -0.00540362f, -0.00359488f, 
    0.02583717f, -0.05485763f, -0.00746595f, -0.02112376f, -0.01223082f, 0.04658095f, -0.03322667f, -0.00486456f, 
    -0.04035898f, -0.01005741f, -0.06202956f, -0.02125764f, -0.00941459f, 0.02148457f, 0.04471483f, -0.04738076f, 
    0.02777227f, -0.03923344f, -0.04837813f, -0.00859723f, -0.05777043f, -0.03052690f, 0.00429559f, -0.03293916f, 
    -0.00311612f, -0.00718383f, 0.00764877f, -0.02983044f, 0.00149935f, 0.04201364f, 0.02271045f, -0.03309578f, 
    0.02946366f, 0.03045769f, 0.01301572f, -0.05165402f, 0.00970151f, 0.02663623f, -0.03074720f, 0.03796664f, 
    -0.00025293f, -0.01316677f, -0.01666250f, -0.05687409f, -0.00574378f, -0.00916063f, 0.00876415f, 0.01439079f, 
    0.02174444f, 0.02044042f, -0.00831649f, 0.03997070f, -0.02866540f, 0.04591971f, -0.05071973f, 0.02414293f, 
    0.04156828f, -0.06147523f, 0.01778309f, 0.02191066f, -0.04559535f, -0.05132731f, -0.04723554f, -0.00990149f, 
    0.00405028f, 0.02415127f, 0.01585644f, -0.01545761f, 0.03132447f, -0.04689927f, -0.03050783f, -0.03128855f, 
    0.02189361f, -0.05984068f, 0.04495463f, 0.01304273f, -0.04758207f, 0.03892713f, -0.02454688f, 0.02560401f, 
    -0.05494566f, 0.02404530f, 0.00823310f, -0.03840454f, -0.04539132f, 0.02525196f, -0.03645557f, -0.00900127f, 
    0.04353337f, -0.04181009f, -0.01073836f, 0.01235771f, -0.05727844f, -0.00902469f, -0.00061430f, -0.03654171f, 
    0.02436815f, -0.04834038f, -0.02132549f, -0.05477133f, 0.02155133f, 0.02363127f, 0.04648861f, 0.00492258f, 
    -0.00301514f, -0.05058515f, 0.03231088f, -0.04808474f, -0.00298278f, -0.01962002f, 0.00542338f, 0.02551746f, 
    -0.03436270f, -0.01907570f, 0.02574328f, -0.03625922f, -0.03074723f, -0.04634462f, 0.03541983f, -0.02467476f, 
    -0.00409197f, -0.02983562f, -0.02746994f, 0.00583571f, 0.00147114f, 0.01086271f, -0.06117528f, -0.00042930f, 
    -0.06008730f, 0.03918579f, -0.00039879f, 0.04743315f, -0.03810322f, -0.04387347f, -0.01305280f, -0.03009230f, 
    -0.00351236f, 0.02894484f, -0.01669788f, 0.03409426f, -0.02222921f, -0.03760128f, 0.02433426f, -0.01885627f, 
    -0.01863987f, -0.04066864f, -0.01143911f, -0.00618965f, -0.02131745f, 0.01952776f, -0.03285348f, -0.06030814f, 
    -0.00587834f, -0.04274093f, 0.03219800f, -0.01483710f, -0.02704139f, 0.00213316f, -0.05728283f, -0.01991709f, 
    -0.05177869f, -0.06222006f, 0.03855370f, 0.00118068f, 0.03337464f, -0.00292590f, 0.00031703f, 0.02700808f, 
    -0.13087738f, -0.05620075f, 0.55709273f, 0.09861200f, 0.37739882f, 0.01340376f, 0.03943951f, 0.18247524f, 
    0.10544496f, 0.06432116f, 0.17041472f, 0.03705726f, -0.03714054f, -0.14737201f, 0.04117521f, -0.04057164f, 
    -0.05912577f, -0.02515395f, 0.01362708f, -0.07693852f, -0.06690621f, 0.01569587f, -0.43676463f, 0.34795395f, 
    0.10045337f, -0.14170101f, 0.18106717f, -0.09096806f, -0.04994195f, 0.03049276f, 0.02956352f, 0.04781405f, 
    0.00015825f, 0.02860112f, 0.13093945f, -0.01437021f, 0.02916599f, 0.10778774f, -0.27732533f, 0.06637091f, 
    -0.17426631f, -0.21931189f, -0.42205897f, 0.05372180f, 0.06791250f, 0.10511316f, 0.11084666f, 0.05300439f, 
    0.13983235f, 0.16219169f, -0.08441845f, -0.00319303f, 0.04394870f, 0.04120924f, 0.06218543f, 0.03303690f, 
    0.08906757f, 0.06735816f, 0.09038852f, 0.12721263f, -0.10159934f, 0.33051658f, -0.16084684f, 0.41825095f, 
    -0.12803394f, -0.18576847f, 0.24439059f, -0.11597472f, -0.07414787f, 0.24541593f, 0.07046112f, 0.03153307f, 
    0.06471150f, 0.14094351f, 0.08609993f, -0.05113733f, 0.16661282f, -0.03451631f, -0.06809853f, -0.22056024f, 
    -0.19391641f, -0.06689712f, -0.09857292f, 0.15466495f, 0.31528965f, -0.02110976f, -0.03509760f, 0.03551123f, 
    0.07665338f, 0.12453966f, 0.06656372f, 0.01031618f, -0.00504068f, 0.03278166f, 0.14339502f, -0.03118641f, 
    -0.01603716f, -0.02892674f, -0.07543597f, -0.09536704f, -0.21472642f, -0.13914935f, -0.17281228f, -0.01949254f, 
    -0.19690998f, -0.10507372f, -0.12314755f, -0.15076427f, -0.17984690f, 0.07832413f, 0.01363370f, 0.02885385f, 
    -0.05888158f, 0.07611815f, 0.13029520f, 0.11471412f, -0.02806223f, 0.01742403f, -0.02011289f, -0.05851315f, 
    0.18403587f, 0.22276440f, 0.19018942f, 0.00639235f, -0.19820091f, 0.07389300f, -0.08147600f, -0.11637883f, 
    0.05917428f, -0.00286225f, 0.04607496f, 0.01686677f, 0.14013955f, 0.02493087f, -0.14174280f, 0.06089547f, 
    -0.03126475f, 0.01858276f, -0.09141514f, -0.16795813f, -0.23674685f, 0.04916618f, -0.11925719f, 0.09030961f, 
    0.47377664f, 0.09256353f, -0.11328287f, 0.08273435f, -0.02966039f, -0.16756141f, 0.02649604f, -0.03189382f, 
    -0.03208173f, 0.04293665f, 0.09131794f, -0.00834798f, -0.01034993f, -0.00815951f, -0.04830837f, 0.02950659f, 
    -0.21583867f, -0.26517594f, 0.23490794f, -0.30429089f, 0.07000209f, -0.07090054f, -0.02800887f, -0.01357466f, 
    -0.17084557f, -0.18730012f, -0.11427120f, -0.18378475f, -0.01701582f, -0.04965977f, 0.06777249f, 0.01176011f, 
    0.03000229f, 0.09578361f, 0.15074828f, -0.00817297f, 0.30299255f, 0.18089412f, -0.22033714f, 0.12045217f, 
    0.28020748f, 0.11599727f, 0.17640382f, 0.11375990f, -0.02876777f, 0.16150555f, 0.18155248f, 0.08095521f, 
    0.00585961f, 0.12847964f, 0.09162148f, -0.00660286f, 0.10115578f, -0.08922919f, 0.07700754f, 0.04103164f, 
    0.11159723f, -0.07180079f, -0.12765521f, -0.33065543f, -0.32939488f, -0.18039311f, -0.08573134f, -0.12749170f, 
    -0.12945940f, -0.10305071f, -0.00800783f, -0.09181096f, 0.04622353f, 0.16588770f, -0.03727726f, 0.16506669f, 
    0.02993541f, -0.06929421f, -0.16934615f, -0.18894827f, -0.30065688f, -0.03057358f, 0.06771699f, -0.17223635f, 
    0.34766918f, -0.22064251f, 0.04749671f, -0.01909714f, -0.06084869f, 0.08392010f, 0.34985334f, -0.06378717f, 
    0.00256047f, -0.12140227f, 0.00813605f, 0.04684727f, 0.01974806f, -0.06050534f, 0.00947296f, -0.08722935f, 
    -0.21835612f, -0.26141062f, -0.33082300f, 0.21949135f, 0.19354530f, -0.25456962f, -0.16214757f, -0.23647852f, 
    0.07569695f, -0.35110709f, -0.13201009f, -0.04957532f, 0.01343520f, 0.02598718f, 0.14851223f, 0.02629799f, 
    0.10579024f, 0.11269048f, -0.07838586f, 0.05887517f, 0.86651284f, 0.21003644f, -0.17068975f, -0.21507037f, 
    0.12692495f, -0.07622238f, 0.15111062f, 0.19274884f, 0.17091708f, -0.00658319f, 0.06306941f, 0.00811059f, 
    -0.02660758f, -0.09079252f, 0.12756632f, 0.04113954f, 0.03777681f, 0.00803600f, 0.14088899f, -0.11559700f, 
    0.08666275f, 0.22597300f, -0.09142631f, -0.15503469f, 0.07119904f, 0.12275883f, -0.07690112f, -0.05314072f, 
    0.16656971f, -0.00427384f, 0.03874922f, 0.08144363f, -0.00335681f, 0.16747332f, -0.03677028f, -0.13750550f, 
    0.14569822f, 0.25474980f, 0.04263436f, 0.09136761f, 0.08159420f, -0.10560862f, 0.17684096f, 0.17359158f, 
    0.29384241f, 0.01145192f, 0.09217414f, 0.12255814f, 0.09533627f, 0.02705766f, 0.14883912f, 0.07026830f, 
    0.03213191f, 0.05943650f, 0.02499192f, 0.04232347f, 0.04632631f, 0.03864980f, 0.03068500f, -0.05594337f, 
    -0.08975282f, -0.34347194f, -0.75865489f, -0.55240035f, -0.04478704f, 0.13659935f, -0.10120412f, -0.21111859f, 
    -0.14526142f, -0.09242357f, -0.07545255f, 0.05740401f, -0.09203822f, 0.06253813f, -0.08797625f, -0.01719010f, 
    -0.02397387f, -0.04618223f, 0.08261540f, 0.00137891f, -0.76544869f, -0.25841537f, -0.41729715f, -0.23212151f, 
    -0.08642922f, -0.06768845f, 0.26429808f, -0.07444588f, 0.02896310f, 0.06938531f, -0.18257271f, 0.07546076f, 
    0.02709273f, 0.09983901f, 0.12367696f, -0.07684982f, 0.10207940f, 0.01986562f, 0.09505383f, 0.18407001f, 
    -0.62700337f, 0.04697277f, 0.08780811f, -0.25502539f, 0.08553477f, 0.28793934f, 0.36468372f, 0.07350626f, 
    0.10709945f, 0.21825169f, 0.05108358f, 0.00210830f, -0.01488585f, 0.00941077f, -0.05758703f, -0.11062721f, 
    0.01733577f, 0.01186944f, -0.08601057f, -0.01606642f, 0.03061064f, 0.57966310f, 0.23376691f, -0.08180569f, 
    0.17892098f, 0.02388124f, 0.23982176f, 0.25447696f, 0.23984997f, -0.03009146f, -0.01290647f, -0.07467587f, 
    0.12775488f, 0.09824261f, -0.19847450f, 0.09211221f, -0.06758254f, 0.24203233f, 0.08074118f, 0.00374234f, 
    -0.20217969f, -0.37454560f, -0.91050279f, -0.54388261f, 0.00167485f, 0.09979290f, 0.15027712f, -0.14742340f, 
    0.08082979f, 0.13589890f, -0.10831469f, -0.00167423f, -0.02360428f, 0.14529051f, -0.02001554f, -0.00146137f, 
    0.04942471f, -0.14300679f, 0.28130412f, 0.12058911f, 0.25323355f, 0.05575312f, 0.05963152f, 0.21343169f, 
    0.05980277f, -0.02267903f, -0.09237163f, -0.07613422f, -0.03514477f, 0.11215103f, 0.15968306f, 0.00347242f, 
    0.06689066f, 0.02342492f, 0.09551207f, -0.10385986f, -0.17962928f, -0.10343227f, -0.15347126f, -0.12161165f, 
    0.50317562f, -0.00895272f, 0.22135288f, 0.16449840f, 0.12826310f, 0.00251100f, 0.12572034f, -0.03022844f, 
    -0.00630115f, -0.04294547f, 0.09985533f, 0.30748698f, 0.16359085f, 0.19617137f, -0.20299459f, 0.14180449f, 
    0.14676508f, -0.01234358f, 0.02172302f, 0.09531158f, -0.40795547f, -0.39748877f, -0.99201334f, -0.26064077f, 
    0.20987315f, 0.00403547f, 0.07622193f, -0.29234859f, 0.06898689f, 0.11058477f, -0.08925899f, -0.02181607f, 
    -0.03152943f, 0.05474995f, -0.03499534f, -0.18385692f, 0.14706264f, -0.14113075f, 0.00396070f, 0.12109002f, 
    0.17842554f, 0.11010046f, 0.09674164f, 0.05336832f, 0.14273767f, -0.10196977f, 0.10543195f, 0.18444766f, 
    -0.01879241f, 0.02225602f, 0.01465071f, -0.07202667f, -0.06147999f, 0.05027399f, 0.03733898f, 0.03715102f, 
    -0.06607480f, 0.00401915f, -0.00794844f, -0.01015346f, 0.45591897f, -0.05168771f, -0.33565986f, -0.24029368f, 
    -0.11647552f, 0.10752621f, 0.09399147f, 0.12909093f, -0.04645704f, 0.06682982f, 0.14354791f, 0.18350336f, 
    -0.08405694f, 0.21298073f, -0.06879462f, -0.03638866f, 0.04321959f, 0.13443172f, 0.01718808f, 0.17210473f, 
    0.11079127f, 0.08666843f, 0.29889885f, 0.14214729f, -0.04683708f, -0.08823528f, 0.00663999f, -0.01719725f, 
    -0.02011715f, -0.03980561f, -0.01790342f, -0.02603986f, -0.16392013f, 0.01585047f, 0.08368628f, -0.02690912f, 
    -0.03657793f, -0.16254555f, -0.01636631f, -0.00279479f, 0.20222884f, -0.32334512f, -0.34829345f, -0.19499248f, 
    -0.03625683f, 0.02974400f, -0.10595883f, -0.04690178f, -0.23062173f, -0.08521135f, -0.01880277f, 0.07266715f, 
    0.17129157f, -0.09924700f, -0.15708162f, -0.13363819f, -0.03684560f, -0.05821276f, -0.05028371f, 0.02912345f, 
    -0.51062018f, -0.07923742f, -0.71343815f, -0.48442689f, -0.27024090f, 0.06400970f, 0.33434907f, -0.24647407f, 
    -0.08132805f, 0.05944668f, -0.09893501f, -0.06128190f, -0.08405701f, 0.03978870f, 0.02588422f, -0.17283653f, 
    -0.03288103f, 0.24208122f, 0.18702142f, 0.09706364f, -0.18791221f, -0.00883596f, 0.20038231f, 0.07945518f, 
    -0.13098864f, -0.09044009f, 0.16209732f, 0.27003944f, -0.04297938f, 0.18741921f, 0.06640374f, 0.02734337f, 
    -0.02823673f, 0.11169869f, 0.05301298f, -0.01247775f, 0.10294239f, 0.15248471f, 0.25807407f, 0.21508804f, 
    0.29258731f, 0.22064526f, 0.20371793f, 0.05400330f, 0.13488919f, 0.19212613f, 0.07547279f, 0.19038528f, 
    -0.00736827f, -0.02448143f, 0.05539857f, 0.13380580f, -0.03621181f, 0.07257355f, 0.05470373f, 0.02731868f, 
    0.10466909f, 0.03058571f, -0.01200129f, -0.05913788f, -0.18940912f, -0.21143985f, -0.49994293f, -0.38768262f, 
    -0.10027052f, 0.08883031f, 0.08831035f, 0.19088896f, -0.11645691f, -0.14093256f, -0.10473360f, 0.14303035f, 
    -0.03002457f, 0.10289647f, 0.00701549f, -0.03354891f, -0.04077483f, 0.04036398f, 0.01300497f, -0.01770741f, 
    -0.18751162f, 0.04921450f, -0.22203875f, -0.16032189f, -0.26753733f, -0.08134311f, -0.09747712f, -0.11298987f, 
    -0.04479400f, 0.03344532f, 0.03016171f, -0.06039933f, -0.10356326f, 0.10397434f, -0.11683238f, 0.03887226f, 
    -0.06442042f, 0.07769602f, -0.00454528f, 0.01390219f, 0.33276495f, -0.04803940f, 0.14248581f, -0.01035695f, 
    -0.16392215f, 0.36035299f, -0.05901024f, 0.12004586f, -0.08154280f, 0.13282686f, 0.09059634f, 0.04531765f, 
    0.09229513f, 0.08554531f, 0.13112807f, 0.20424743f, 0.04381266f, -0.01373229f, 0.07315299f, 0.08288934f, 
    0.01711091f, -0.07221361f, 0.00446412f, -0.15845315f, -0.37027445f, -0.16153036f, 0.03190996f, -0.08003947f, 
    -0.04144735f, -0.11149779f, -0.04095623f, -0.13561502f, -0.01805750f, -0.04221476f, 0.02158757f, -0.07177653f, 
    0.18171565f, 0.08227194f, 0.17598936f, 0.11842744f, 0.75598973f, -0.28345048f, 0.27910942f, 0.05453476f, 
    -0.09579910f, 0.33750734f, 0.16849211f, -0.22160995f, 0.10569704f, 0.28768826f, 0.09494999f, 0.02247917f, 
    0.07397175f, -0.06075480f, 0.16809486f, -0.12444418f, -0.18885329f, -0.00624689f, -0.06257121f, 0.02108764f, 
    0.17969699f, 0.18508987f, 0.05363867f, -0.09118351f, -0.17405617f, 0.18814401f, -0.00575371f, 0.04192742f, 
    0.09340167f, 0.17883959f, 0.03781215f, 0.01818176f, 0.02561638f, 0.10934689f, 0.04929598f, 0.04923200f, 
    -0.12921993f, -0.09206259f, 0.01915281f, -0.08084153f, 0.12848701f, -0.01267040f, 0.17090662f, 0.05825765f, 
    -0.12432281f, -0.15937833f, -0.13837954f, -0.08779174f, -0.09233037f, -0.13021208f, 0.13525793f, 0.17905243f, 
    0.23227338f, 0.16150859f, 0.09645151f, 0.00396588f, 0.02840311f, 0.01334963f, 0.08714658f, 0.16277547f, 
    0.43715569f, -0.26762396f, 0.09969617f, 0.08856246f, 0.27892190f, -0.29996106f, -0.00361989f, -0.11429144f, 
    -0.09928651f, -0.23749776f, 0.27727911f, 0.08931321f, 0.07265126f, 0.15538979f, 0.18947063f, 0.21540539f, 
    0.01823172f, 0.03235180f, 0.06846894f, -0.07089525f, 0.13493699f, 0.10631105f, -0.13828807f, 0.00530089f, 
    -0.28733510f, 0.09553437f, 0.01562718f, 0.12747453f, 0.09353583f, 0.07590392f, -0.00225457f, -0.03472500f, 
    0.02169162f, 0.05455392f, 0.11084575f, 0.06118247f, -0.00479153f, 0.03508949f, 0.03981446f, 0.09389731f, 
    0.22053565f, 0.12149879f, -0.19660212f, 0.09971771f, -0.22659276f, 0.17084534f, 0.11688298f, 0.23542254f, 
    0.18069378f, -0.05558757f, -0.19987291f, 0.04800161f, -0.04819406f, 0.05989106f, -0.06344295f, 0.21333753f, 
    0.23766315f, 0.06882408f, 0.07658254f, -0.05070325f, 0.13647629f, 0.07487770f, -0.12833442f, 0.04885643f, 
    -0.27041614f, 0.11125006f, 0.10059036f, 0.10444614f, 0.28206012f, 0.20731175f, 0.03324613f, 0.04843486f, 
    -0.02464352f, 0.02626914f, -0.06025793f, 0.12992325f, 0.00374618f, -0.03347853f, 0.02902042f, 0.09267031f, 
    -0.26540738f, -0.14891109f, 0.36261791f, 0.17939308f, 0.20174560f, -0.12633887f, -0.14956771f, -0.02059574f, 
    -0.08925468f, -0.19053066f, 0.23843127f, 0.20554851f, 0.04081279f, 0.20255794f, 0.13119315f, 0.08273641f, 
    0.00647089f, 0.08226747f, -0.02490991f, 0.06670352f, -0.32515165f, -0.27599180f, -0.37962538f, -0.12599467f, 
    -0.33167583f, -0.08976635f, 0.01978816f, -0.09981423f, 0.05064143f, -0.03092506f, 0.00826053f, 0.09365281f, 
    0.08555590f, -0.09420031f, -0.15192232f, -0.05325839f, -0.07236776f, -0.03665795f, -0.06291066f, -0.00472538f, 
    -0.04461072f, 0.17205147f, 0.10112488f, -0.09887858f, -0.19698328f, 0.01118655f, -0.15776551f, 0.05994491f, 
    -0.18642746f, -0.23724036f, 0.01767221f, -0.03965454f, 0.02173584f, -0.03687803f, 0.04964088f, -0.08888122f, 
    0.01316211f, 0.17100564f, 0.10096636f, 0.07641362f, -0.49476644f, -0.03403266f, 0.16193976f, 0.19384216f, 
    0.13717642f, 0.32908148f, 0.29649508f, 0.06981768f, 0.02725687f, 0.34600773f, -0.08644474f, 0.15604927f, 
    0.02944831f, 0.16430439f, -0.14105725f, 0.20628673f, 0.32047075f, 0.02590007f, 0.32981634f, 0.06482743f, 
    0.31777391f, 0.29387170f, -0.06836361f, 0.25187865f, 0.38381362f, 0.06954545f, 0.07782727f, 0.04485948f, 
    -0.03295781f, 0.07364171f, 0.05585522f, -0.03269316f, 0.08172740f, 0.12417538f, 0.28501964f, 0.15048431f, 
    -0.15568273f, 0.07779255f, 0.03990880f, 0.04467206f, -0.27089158f, 0.15096389f, -0.17317778f, -0.19901814f, 
    -0.30420285f, 0.05758228f, 0.05374303f, 0.10251981f, -0.01015023f, 0.23670651f, -0.09768196f, -0.00155512f, 
    -0.16875988f, -0.02399084f, -0.19941150f, -0.07065970f, -0.01109795f, -0.02089996f, 0.01208492f, 0.10353954f, 
    -0.05633518f, -0.05771322f, 0.01960514f, 0.01330687f, -0.00771170f, -0.05659167f, 0.04612511f, -0.00616189f, 
    0.03990327f, 0.02694179f, 0.02106700f, -0.03572577f, 0.02774836f, 0.03144292f, -0.04480509f, -0.00863677f, 
    -0.05145654f, -0.00769518f, -0.06054898f, 0.02434324f, 0.01690405f, 0.00106873f, 0.04066465f, 0.02135532f, 
    -0.01606238f, 0.00074236f, -0.02597309f, 0.01187622f, -0.02519681f, 0.00065382f, -0.06455924f, 0.00660771f, 
    -0.04317750f, -0.06736016f, 0.00689817f, 0.01933904f, -0.05483915f, -0.04632169f, -0.05626490f, -0.02874256f, 
    0.03065348f, -0.01293593f, -0.06433274f, 0.00057429f, -0.03048624f, 0.03736812f, 0.00771706f, 0.02459040f, 
    0.01287256f, 0.02342506f, 0.00293012f, -0.01624616f, 0.00669607f, 0.01082737f, 0.01740617f, 0.03670094f, 
    -0.05481587f, -0.03817998f, -0.03512174f, -0.02395595f, 0.03183321f, 0.00015771f, -0.01139052f, 0.05772714f, 
    0.00001047f, -0.00258766f, 0.01607735f, 0.02434420f, -0.03524784f, 0.00712307f, 0.04638248f, 0.01145608f, 
    -0.03462669f, 0.03358719f, -0.05552925f, -0.02692547f, -0.02216126f, -0.01572726f, -0.05209106f, -0.02870152f, 
    -0.03853276f, -0.03682587f, 0.00410202f, -0.01864366f, -0.03085796f, 0.04484752f, -0.06164115f, -0.02419139f, 
    -0.00972662f, 0.00379746f, -0.05700846f, 0.01933329f, 0.03005487f, -0.02922570f, -0.05511655f, 0.02526988f, 
    0.00744919f, 0.00683976f, -0.01633432f, -0.02444465f, 0.02180249f, -0.04718523f, 0.02368833f, -0.03136234f, 
    0.00631397f, 0.01968893f, 0.03124548f, 0.02528673f, 0.03771150f, 0.04121491f, 0.01031200f, -0.00863790f, 
    0.03203418f, 0.03752754f, -0.05666626f, -0.03135305f, 0.05345052f, 0.04156621f, -0.05196975f, 0.02188472f, 
    -0.01345565f, 0.05031702f, 0.02920241f, -0.00603035f, 0.02319858f, 0.04336915f, 0.03781742f, -0.02061249f, 
    -0.03558559f, -0.06286994f, 0.01702079f, 0.02282077f, 0.01124213f, -0.04913643f, 0.00529799f, -0.03834893f, 
    0.04008897f, -0.05177422f, -0.06368124f, -0.00913334f, -0.03228909f, -0.03117905f, 0.00469600f, -0.00894674f, 
    0.03990791f, 0.04781789f, -0.01174385f, -0.02592993f, -0.05071844f, -0.05347310f, -0.02852245f, -0.02362613f, 
    0.03694000f, -0.01338030f, -0.03380315f, 0.02532310f, 0.00368118f, -0.04611582f, 0.01908018f, 0.00433207f, 
    0.00808724f, -0.03637623f, -0.01489456f, -0.05428093f, -0.02073869f, 0.01148692f, -0.02258130f, 0.01618926f, 
    0.02922614f, -0.06576063f, -0.05902786f, -0.00067808f, -0.02585451f, -0.02234682f, -0.02126094f, 0.01289639f, 
    0.01179105f, -0.02643203f, 0.03103170f, -0.05007655f, -0.04188340f, -0.06675555f, 0.03326590f, -0.01768154f, 
    -0.04228678f, -0.02620950f, 0.04118733f, 0.03057352f, 0.01668842f, -0.01797953f, -0.06359154f, -0.06553888f, 
    0.02168291f, -0.06448925f, -0.02731018f, 0.04358002f, -0.03138601f, -0.04709447f, 0.02038640f, -0.00230226f, 
    -0.04099545f, 0.01621398f, 0.03893616f, -0.02795947f, 0.02990546f, -0.03987999f, 0.01860782f, -0.02647896f, 
    0.00258521f, 0.03084672f, 0.00539700f, -0.05894048f, -0.04197744f, 0.04256853f, -0.06141568f, 0.01899350f, 
    0.04070252f, 0.01160005f, 0.03910446f, -0.01034498f, -0.05394104f, 0.03352537f, 0.03468718f, -0.01236698f, 
    0.00427288f, -0.05918614f, -0.03145207f, 0.01300905f, 0.03337094f, -0.01195731f, -0.05319697f, 0.00010708f, 
    -0.01387799f, 0.00356282f, -0.05927767f, 0.04642838f, -0.04290293f, 0.02108561f, -0.02358894f, -0.00056203f, 
    -0.05789373f, -0.04995934f, -0.06261969f, 0.04467598f, -0.00059782f, -0.03907306f, 0.00060314f, -0.01991580f, 
    0.02984124f, -0.05718952f, 0.03232659f, -0.03997282f, 0.01412152f, -0.01936682f, -0.01503589f, 0.00353305f, 
    -0.01026967f, -0.00636746f, 0.03104993f, -0.00851473f, 0.03062881f, -0.06422568f, -0.04810743f, -0.04478648f, 
    -0.06338497f, 0.02079774f, -0.06508684f, -0.02309483f, 0.04321392f, 0.01485322f, 0.03175583f, -0.02233212f, 
    -0.02864296f, 0.03206939f, 0.02225018f, 0.01471909f, -0.03251636f, -0.02865317f, -0.04296741f, -0.04362306f, 
    -0.05924266f, -0.03553548f, -0.01086375f, 0.00802151f, -0.01626120f, -0.06367582f, -0.02985656f, -0.06471268f, 
    0.00810148f, -0.03399752f, 0.04344240f, -0.03372537f, 0.04357427f, -0.03400348f, 0.01577513f, -0.02622969f, 
    0.00580063f, -0.00154575f, 0.02036070f, 0.02415888f, -0.04127686f, 0.03236607f, 0.04151581f, -0.02697388f, 
    -0.02304261f, -0.02858716f, 0.01877566f, -0.04815987f, 0.00068568f, -0.00942840f, 0.02184954f, 0.00287489f, 
    -0.02379130f, -0.02582279f, 0.02723983f, 0.01643485f, -0.01285000f, -0.01602959f, -0.01160755f, 0.01036475f, 
    -0.57216746f, 0.20243064f, 0.54391122f, 0.09367637f, 0.12583153f, 0.20605533f, -0.07319143f, 0.12703249f, 
    0.03415426f, -0.00044914f, -0.10704020f, -0.01029882f, 0.06393392f, -0.08412155f, 0.07241884f, 0.00330683f, 
    -0.02789146f, -0.11049008f, -0.19036970f, 0.01366097f, -0.10945196f, -0.02738211f, -0.29337317f, 0.17583120f, 
    -0.11764154f, -0.13358796f, -0.05079430f, -0.07433043f, -0.04241743f, 0.08932644f, -0.03644902f, 0.03939097f, 
    -0.01777639f, 0.01948641f, 0.04521343f, 0.02089206f, 0.00468666f, 0.10212961f, -0.16740736f, 0.09306080f, 
    -0.31249762f, -0.34556699f, -0.41359544f, 0.20488580f, 0.06890932f, 0.02478835f, -0.10916885f, 0.05896826f, 
    -0.03379377f, -0.07213155f, -0.02143652f, 0.06555017f, -0.07340506f, -0.02856524f, -0.09228385f, -0.00095216f, 
    -0.09480693f, 0.10778312f, -0.22670987f, -0.13119379f, -0.45286265f, 0.40922764f, -0.71437174f, 0.52086061f, 
    -0.50819206f, -0.18285671f, 0.12082821f, -0.19436505f, -0.06445955f, -0.16058978f, -0.02130564f, -0.05585320f, 
    0.09274898f, 0.00469248f, -0.12744750f, 0.18865232f, -0.05166018f, 0.16586067f, 0.29953387f, 0.02171882f, 
    -0.14641987f, 0.00851649f, 0.16651398f, 0.25266939f, 0.03525721f, 0.09937379f, 0.09825316f, 0.06070406f, 
    0.04978565f, 0.02985993f, -0.00357356f, 0.05275651f, 0.11416485f, 0.06343102f, 0.03664738f, 0.02771586f, 
    0.13039951f, 0.14474770f, 0.03477141f, 0.12944326f, 0.06485678f, 0.03120932f, -0.01981556f, -0.04622849f, 
    0.06749707f, 0.02567791f, 0.00004739f, 0.03352815f, -0.12244058f, -0.00728606f, -0.08898528f, 0.03829522f, 
    0.18298873f, -0.14008994f, 0.13050783f, 0.08313841f, -0.05045354f, -0.01629138f, -0.16392006f, -0.21833368f, 
    -0.36274943f, 0.61782253f, -0.22693187f, 0.01559855f, -0.04999123f, 0.05999129f, 0.08309453f, 0.08514003f, 
    -0.00828073f, -0.04145316f, 0.05447731f, 0.00074820f, -0.07396077f, -0.11711304f, 0.06000679f, 0.22504023f, 
    0.02112884f, 0.14445214f, 0.33831513f, -0.22407393f, -0.21606784f, 0.20602544f, 0.41563487f, -0.00179138f, 
    0.05496722f, 0.06576758f, -0.05508554f, -0.03497018f, -0.03564498f, -0.03943099f, -0.00043055f, 0.07315329f, 
    0.15292808f, 0.05395477f, 0.05679546f, 0.01257478f, 0.07732814f, 0.03245994f, 0.12240797f, -0.02064897f, 
    0.43303096f, -0.08509175f, 0.59745651f, 0.01010962f, 0.29617646f, 0.11074443f, 0.16175348f, -0.26234862f, 
    0.00152872f, 0.08639370f, -0.08786534f, -0.02990194f, -0.01303268f, 0.11163535f, 0.02692684f, -0.07369988f, 
    -0.07533309f, -0.10499937f, -0.02800195f, 0.13362078f, 0.32154962f, 0.41416854f, 0.12428196f, 0.11178337f, 
    0.10774419f, 0.03353144f, 0.10268840f, 0.08305156f, 0.06678022f, 0.06880365f, 0.08484184f, 0.08121831f, 
    0.05339405f, -0.00142121f, -0.03195895f, 0.05359122f, 0.02226335f, 0.22494060f, -0.04029267f, -0.00522298f, 
    0.01513966f, -0.17790532f, -0.14479508f, -0.09090962f, 0.23640236f, 0.12140631f, 0.05714739f, 0.01539336f, 
    -0.05286454f, -0.04305360f, 0.00345804f, -0.01775652f, 0.22155447f, 0.01877436f, 0.17020735f, 0.10996086f, 
    0.13444397f, -0.08027217f, -0.20469528f, -0.08782281f, -0.54671669f, 0.24011475f, 0.19100671f, -0.04310333f, 
    0.13034676f, -0.12787512f, -0.12183110f, 0.05129641f, 0.07361035f, -0.02541048f, 0.01925566f, -0.02539831f, 
    0.15686113f, -0.05381124f, 0.04969408f, -0.07591207f, -0.11785011f, -0.05907435f, -0.03690590f, -0.02981912f, 
    -0.25589553f, -0.29370964f, -0.25591177f, 0.13129440f, -0.03161428f, -0.11937451f, -0.22130193f, -0.13578734f, 
    0.03696676f, -0.24813622f, -0.07269831f, -0.03809302f, -0.08149184f, -0.00778627f, -0.06533504f, -0.03994041f, 
    0.03238143f, 0.10619043f, -0.17134087f, 0.03257789f, 0.47524649f, -0.08663864f, -0.09039793f, -0.08556666f, 
    0.29554805f, 0.05285979f, 0.15946838f, -0.10683819f, 0.02876360f, 0.09620982f, 0.00549730f, 0.16460691f, 
    -0.05590014f, 0.01234108f, 0.10896502f, 0.06705091f, 0.12363110f, -0.04062571f, 0.07045238f, 0.18318275f, 
    0.07108145f, 0.29406279f, -0.07961172f, 0.13450514f, -0.02735257f, 0.12743728f, 0.04737405f, -0.01061491f, 
    -0.05316868f, -0.00683474f, 0.08919983f, 0.09263445f, 0.20932010f, 0.07820059f, -0.07319483f, 0.01826488f, 
    0.21472532f, 0.13074325f, 0.04702190f, -0.21910715f, -0.26355302f, 0.14110000f, 0.44534594f, 0.22095263f, 
    0.06565565f, 0.11460390f, -0.10563599f, 0.07738146f, 0.03440578f, -0.00191786f, 0.04549108f, 0.03487268f, 
    -0.11508515f, 0.08703458f, 0.05158430f, 0.00170763f, -0.05573024f, 0.08494941f, -0.07511732f, 0.01362984f, 
    -0.01924032f, 0.56414735f, -0.02168417f, 0.00370780f, -0.28091732f, 0.31845611f, -0.07828577f, -0.41810977f, 
    0.07819760f, -0.00970866f, -0.15248334f, 0.05522449f, 0.08098391f, 0.08952551f, 0.09948950f, 0.04774630f, 
    -0.13590080f, -0.11462942f, 0.07034116f, 0.08685935f, -0.14742720f, -0.16196440f, -0.20798190f, 0.37876648f, 
    -0.06347585f, 0.19601685f, -0.17102413f, -0.01956667f, 0.24430874f, 0.19941030f, 0.04767847f, 0.09385928f, 
    -0.01173628f, -0.04160494f, 0.03974203f, 0.11435801f, -0.05598074f, -0.06687798f, 0.10326596f, 0.11329786f, 
    -0.50866354f, -0.33274475f, 0.02717775f, 0.10409533f, -0.08450381f, 0.08031494f, -0.02239595f, 0.16490699f, 
    0.01533738f, -0.03005104f, 0.02184134f, -0.10541527f, -0.03218631f, -0.08919028f, -0.09001078f, 0.08942062f, 
    0.13631067f, 0.12813844f, 0.08721213f, 0.18843974f, -0.30810454f, 0.18257712f, 0.25157443f, 0.24014415f, 
    -0.00072721f, 0.08910019f, -0.17730652f, -0.01655313f, 0.18190630f, 0.03575490f, -0.06220845f, -0.05917690f, 
    0.27233398f, -0.13699633f, 0.02241191f, -0.02090166f, -0.09031969f, 0.11336549f, 0.04275253f, -0.04753585f, 
    -0.00779226f, 0.13602249f, -0.11567798f, 0.16566002f, -0.11003163f, 0.08972897f, 0.00558462f, -0.09892665f, 
    0.14785877f, 0.10714427f, -0.00044980f, 0.01833159f, 0.00462178f, 0.07697304f, 0.01273517f, -0.12298293f, 
    -0.08954445f, -0.00793558f, 0.01430620f, -0.03659588f, -0.08099736f, -0.03922006f, 0.01782733f, -0.19080175f, 
    -0.03648922f, -0.16546723f, -0.16220327f, -0.07827060f, 0.06732985f, -0.15356039f, -0.01107297f, -0.02036738f, 
    0.17615725f, -0.06728114f, -0.07794908f, 0.06785813f, 0.16729669f, 0.08520649f, 0.12505470f, 0.04490993f, 
    -0.31137472f, 0.30996573f, 0.09337161f, 0.08906814f, 0.14533907f, -0.10321219f, 0.15578035f, -0.04344051f, 
    -0.04927184f, -0.12267326f, 0.05514643f, -0.03000681f, -0.05568601f, -0.06763190f, 0.05519059f, 0.03021210f, 
    0.22175129f, -0.03207689f, 0.20391561f, -0.06707242f, -0.08460677f, 0.08962897f, -0.08126129f, 0.07009709f, 
    -0.14486863f, 0.05222467f, -0.10183746f, -0.06295616f, 0.23258148f, 0.18044540f, 0.02167162f, 0.00690974f, 
    0.03218776f, -0.11641268f, -0.04771082f, -0.01089989f, -0.00450880f, 0.00424885f, 0.07357360f, -0.13048674f, 
    -0.15967466f, 0.03891117f, -0.22172683f, -0.14223439f, -0.12474138f, 0.04613956f, -0.00082618f, 0.45147783f, 
    0.05296721f, -0.05423357f, -0.02932091f, 0.02819476f, -0.09149040f, 0.03825082f, -0.09145024f, 0.17819551f, 
    0.16351515f, 0.15203826f, 0.01885359f, 0.01361198f, -0.23584524f, 0.41112599f, 0.28829208f, -0.18631408f, 
    0.02746344f, 0.01382158f, -0.06103643f, 0.02877595f, 0.29859549f, 0.14593875f, 0.11045204f, 0.25783360f, 
    0.04116492f, -0.04319220f, -0.12370623f, 0.10582184f, -0.03810131f, 0.19808094f, 0.10512900f, 0.03954987f, 
    -0.06239541f, 0.20432086f, 0.08549743f, 0.26524621f, -0.14472009f, 0.04452133f, -0.03174912f, -0.07894024f, 
    -0.10240181f, -0.16918157f, -0.07827637f, 0.04845019f, 0.07727014f, -0.09406045f, 0.07453419f, 0.12576769f, 
    0.06973743f, 0.04557948f, -0.04901020f, 0.12798475f, -0.15367991f, 0.32027325f, 0.10196739f, 0.18819512f, 
    -0.40010262f, 0.14511648f, -0.22728227f, -0.24144419f, -0.07513311f, -0.04575823f, -0.09657478f, 0.13715477f, 
    0.22476660f, 0.17857541f, 0.08829560f, -0.01947644f, -0.05616758f, 0.00421739f, -0.00443527f, 0.10522386f, 
    -0.43834844f, -0.30492893f, -0.09865087f, -0.02051763f, -0.09307029f, 0.04051350f, -0.24553072f, -0.00012785f, 
    0.22868328f, -0.15620214f, -0.01926272f, -0.05168392f, 0.04724600f, -0.13405356f, -0.09747494f, -0.08409620f, 
    -0.01249504f, 0.05067502f, 0.11734758f, -0.11126284f, -0.19841965f, 0.36688304f, -0.25106344f, 0.20184888f, 
    -0.02277915f, 0.16320397f, 0.08145738f, 0.30900544f, -0.19803511f, 0.17689453f, -0.05438926f, 0.17951326f, 
    -0.01156755f, 0.03149680f, 0.06013935f, 0.27942184f, 0.02673144f, 0.15784739f, 0.19963065f, 0.14772210f, 
    0.09132682f, 0.05414211f, -0.08937705f, 0.22008638f, 0.01434197f, -0.05791140f, 0.16014208f, 0.02917646f, 
    -0.10111394f, 0.01144231f, 0.12071023f, 0.04614516f, 0.04828093f, 0.07388186f, -0.03270528f, 0.05696807f, 
    0.12672582f, 0.12291665f, 0.09184204f, -0.11115418f, -0.30773306f, 0.31738704f, -0.00192861f, -0.13295050f, 
    -0.23408507f, 0.15701899f, -0.02433542f, -0.15205468f, 0.26636073f, 0.11018699f, -0.05736334f, 0.26423401f, 
    -0.05991370f, 0.00109344f, -0.14908354f, 0.04865278f, -0.04861737f, 0.06868609f, 0.01203124f, 0.16599774f, 
    -0.06452753f, -0.16406170f, 0.39412338f, 0.05531619f, -0.26794928f, -0.21526785f, -0.17254816f, 0.00810881f, 
    0.00677192f, 0.08887662f, 0.01631161f, -0.04208166f, 0.12170845f, 0.03158903f, -0.04594015f, 0.09956356f, 
    -0.01399495f, -0.07721297f, 0.00384847f, 0.05574064f, -0.23859337f, -0.11941250f, 0.12238900f, -0.10838031f, 
    -0.01422678f, 0.02913914f, 0.12475860f, 0.13438024f, 0.02749616f, 0.08689475f, 0.07633917f, -0.11411778f, 
    -0.03472719f, 0.09953100f, 0.03569987f, 0.01478391f, 0.13065736f, 0.08918896f, 0.03475152f, 0.10791705f, 
    -0.30977190f, 0.19002239f, 0.39825958f, 0.03589337f, 0.00079479f, 0.06554855f, -0.02862284f, -0.05940531f, 
    -0.11137871f, -0.10086201f, 0.05248547f, -0.00847345f, 0.02781658f, 0.04129549f, 0.05278053f, -0.03405800f, 
    -0.12744689f, -0.05569631f, -0.00527332f, -0.23420320f, 0.30279815f, -0.18946126f, -0.01474041f, -0.44057491f, 
    0.01509730f, 0.00085740f, 0.15875818f, 0.05731556f, 0.14021266f, -0.27435011f, 0.00120542f, -0.06164523f, 
    0.00491333f, 0.11226895f, 0.03250661f, 0.18234226f, -0.08790829f, 0.08933654f, 0.13781705f, 0.15750881f, 
    -0.10275364f, -0.15585606f, 0.30820426f, 0.06305515f, -0.18311629f, -0.04421936f, 0.02968691f, -0.00163642f, 
    -0.11763638f, -0.05889847f, 0.00287202f, -0.06660132f, 0.01379855f, -0.07339800f, -0.07838733f, 0.01490936f, 
    0.13092954f, -0.00712069f, 0.26479995f, 0.24579062f, 0.23879243f, 0.14337942f, -0.03051277f, -0.04189181f, 
    0.10682531f, -0.00422616f, -0.02008453f, 0.06441455f, -0.04290962f, 0.01732172f, 0.07600515f, 0.05656278f, 
    -0.00693172f, 0.00188475f, -0.04765263f, -0.00992862f, -0.11134574f, -0.07851885f, -0.12695286f, -0.05816121f, 
    0.63193840f, -0.59274465f, 0.08892732f, -0.05385443f, 0.02729664f, 0.06623881f, 0.25668618f, -0.03198834f, 
    0.08342063f, 0.03011356f, 0.28497297f, 0.25003245f, -0.07891030f, 0.06900590f, -0.03450416f, 0.22348893f, 
    0.08759046f, 0.14090709f, 0.01687282f, 0.00231758f, -0.22744150f, -0.02979027f, 0.19886021f, 0.09811638f, 
    -0.42112845f, -0.11339761f, 0.03497070f, -0.12217417f, -0.06568345f, -0.03170894f, -0.03349517f, -0.02751716f, 
    0.05229460f, -0.11646202f, -0.12188464f, -0.03499651f, 0.06788743f, -0.02499877f, 0.09116719f, 0.10579896f, 
    0.49878356f, -0.01026944f, -0.34465969f, -0.10767759f, 0.25816283f, 0.15568784f, 0.01365534f, -0.03026099f, 
    0.03391153f, 0.14891164f, 0.07036224f, -0.04356970f, -0.00496219f, -0.04396415f, -0.09694097f, -0.04195630f, 
    -0.00776800f, -0.07174497f, -0.08917582f, 0.09700368f, 0.17702998f, 0.32806519f, 0.25497523f, -0.02614458f, 
    -0.32518518f, -0.08057550f, -0.00064222f, -0.05060064f, 0.01391451f, -0.01815468f, 0.05511393f, -0.05493701f, 
    0.10243891f, 0.09097114f, 0.13942333f, 0.07490733f, -0.05541761f, 0.18932416f, -0.05245200f, 0.08196271f, 
    0.07609710f, -0.02822597f, -0.08310013f, 0.09766848f, 0.31855735f, 0.04067556f, -0.02791980f, 0.00399650f, 
    -0.04199436f, 0.07381015f, -0.00739429f, -0.02554611f, -0.10782100f, 0.06593240f, -0.03926898f, -0.07476603f, 
    -0.01672734f, -0.01418430f, -0.07777566f, 0.04343928f, -0.14683905f, 0.17086260f, 0.15843947f, 0.10526827f, 
    -0.15151557f, -0.07731631f, -0.02736242f, -0.05911680f, 0.11651853f, 0.12525934f, -0.02280623f, -0.09044044f, 
    0.04187768f, -0.05131454f, -0.04290139f, 0.05122317f, -0.01154183f, -0.11132143f, -0.01885421f, 0.06987938f, 
    -0.02711968f, 0.10548268f, 0.32010451f, 0.27272892f, -0.17278558f, -0.20914781f, 0.09399400f, -0.15145436f, 
    -0.10224345f, 0.21481571f, 0.01728329f, 0.00045699f, 0.07741930f, -0.00080476f, -0.02742035f, -0.01496340f, 
    -0.06522136f, -0.05273783f, 0.13621600f, -0.13354267f, -0.60477370f, -0.29309618f, -0.12206849f, -0.13017252f, 
    0.26700786f, 0.20676683f, -0.12805416f, -0.08773822f, -0.04204305f, 0.22642191f, 0.12525901f, 0.03199920f, 
    0.12096971f, -0.02174582f, -0.12417424f, -0.19822109f, 0.01613065f, -0.10621952f, 0.02505741f, 0.20906828f, 
    0.19981889f, 0.10933068f, 0.07910964f, 0.00816127f, 0.02329268f, 0.04787868f, -0.02268550f, 0.18810917f, 
    -0.09453297f, 0.15193404f, -0.01523329f, -0.01624492f, 0.14886908f, -0.02686209f, -0.09843478f, 0.18889073f, 
    0.06501939f, -0.19722733f, 0.01327491f, 0.04644322f, -0.01858285f, 0.15669826f, 0.57916242f, 0.03214156f, 
    -0.32776773f, -0.10808442f, -0.05412381f, -0.08852215f, 0.13372488f, 0.06962853f, -0.01373131f, -0.05939338f, 
    0.01832887f, 0.08289459f, 0.00752603f, 0.07676046f, -0.04491654f, 0.03368421f, 0.00205999f, 0.08294247f, 
    0.33550045f, -0.19349234f, -0.03817693f, -0.09505782f, 0.03911919f, 0.18373986f, 0.02426339f, 0.02728117f, 
    0.25242424f, -0.12014210f, 0.16732110f, -0.12711214f, -0.00869016f, -0.13538323f, 0.00648254f, 0.03259387f, 
    0.02494986f, -0.11165044f, -0.09554750f, -0.11001178f, -0.01795716f, 0.09693605f, -0.39573926f, 0.10027432f, 
    0.09522808f, 0.02819103f, -0.16614492f, -0.01163575f, -0.24628246f, 0.03710226f, -0.05460569f, 0.08879925f, 
    0.03197104f, -0.04977674f, 0.03422358f, 0.11760272f, 0.02162426f, 0.14304474f, -0.24893138f, -0.19492069f, 
    -0.17287827f, -0.60930192f, -0.49792120f, 0.25503770f, 0.05619646f, 0.08491226f, 0.03470277f, 0.03428050f, 
    0.15865403f, 0.01870232f, -0.03802247f, 0.02885750f, 0.04576838f, -0.01906099f, 0.02363855f, 0.05726423f, 
    -0.09494868f, 0.11359178f, -0.04903094f, -0.00555244f, 0.13811570f, -0.03059934f, -0.11694031f, 0.32546398f, 
    0.13472882f, -0.09884899f, -0.02749446f, 0.08504418f, -0.29190588f, 0.15239598f, -0.05587634f, 0.05326312f, 
    0.00253390f, 0.02991724f, -0.11192419f, 0.11601042f, -0.03606783f, 0.00756174f, -0.00843227f, -0.10700815f, 
    0.17328833f, -0.02278917f, 0.01777346f, -0.01689743f, 0.23842040f, 0.07401774f, 0.02888461f, 0.07357624f, 
    0.33595690f, 0.13962257f, 0.05644074f, -0.06907465f, -0.07074284f, 0.09617516f, 0.16705294f, 0.00661060f, 
    0.00911229f, 0.04784785f, 0.03710726f, -0.04988242f, 0.00343982f, 0.09141047f, -0.00402798f, -0.11427988f, 
    -0.23363081f, -0.09892930f, -0.05545016f, 0.07528378f, -0.22297886f, -0.11477794f, 0.11587697f, 0.02506866f, 
    0.01840264f, -0.00367226f, 0.11404479f, 0.00711098f, 0.12307366f, 0.11428393f, -0.11314231f, -0.08770826f, 
    -0.16132635f, 0.32810241f, -0.00807141f, 0.25084779f, 0.08043021f, -0.00337222f, 0.01562487f, 0.05319942f, 
    0.06464463f, -0.08291904f, -0.05418626f, -0.12439246f, 0.13741867f, 0.05878162f, -0.01929920f, 0.06618459f, 
    -0.01893122f, -0.04284276f, -0.04388139f, -0.18914324f, 0.18420090f, 0.01586206f, 0.17049155f, -0.18905827f, 
    0.15923229f, 0.13210565f, -0.15738346f, 0.19974039f, 0.23826721f, -0.09531868f, 0.08317194f, 0.01559254f, 
    -0.02015275f, 0.01225233f, 0.05645251f, 0.08080037f, 0.05318213f, 0.12097964f, -0.12812147f, -0.02411387f, 
    -0.06783006f, 0.18294953f, 0.45175382f, 0.04584074f, -0.26989475f, 0.07054044f, -0.07246402f, -0.39496386f, 
    -0.02143468f, -0.13314888f, 0.06681029f, 0.03051602f, 0.03450645f, 0.21415016f, 0.02251558f, -0.03954337f, 
    0.06340373f, -0.11645549f, 0.16267142f, 0.14091240f, 0.37070662f, -0.26804784f, -0.15615687f, -0.01912210f, 
    0.24769136f, -0.06626131f, 0.07428221f, 0.24128257f, 0.00430635f, 0.24270330f, 0.00160328f, 0.03653267f, 
    -0.05889006f, -0.03271767f, 0.00757330f, -0.03535977f, 0.04006592f, 0.08627453f, -0.10215852f, -0.03201247f, 
    0.11700130f, 0.26796341f, -0.32441998f, -0.13142434f, -0.22115105f, -0.01078654f, 0.19159465f, 0.00733222f, 
    -0.02481686f, -0.10341257f, 0.13010007f, 0.00425269f, 0.26690581f, 0.05827311f, -0.01147912f, 0.17100474f, 
    0.06013706f, -0.05746206f, -0.13189894f, -0.11965293f, 0.19191538f, -0.38368097f, -0.36478055f, -0.22453114f, 
    -0.08057073f, -0.05704833f, -0.09967631f, 0.23472363f, 0.01540477f, 0.05651044f, 0.14931124f, 0.01731895f, 
    0.06319045f, -0.01663795f, 0.03668581f, 0.10165142f, -0.06144817f, -0.05744360f, 0.02162648f, -0.08380974f, 
    0.09635467f, -0.10356747f, -0.44564301f, 0.07365724f, 0.15591335f, -0.10028360f, -0.01045738f, -0.17520094f, 
    0.40991932f, 0.01931752f, -0.05258133f, -0.08904098f, -0.07945080f, -0.08982296f, -0.04249909f, 0.00003735f, 
    0.06922451f, 0.12002257f, -0.03808240f, 0.00695468f, 0.63005942f, 0.16565335f, -0.01923474f, -0.02479272f, 
    -0.02397325f, 0.07793214f, 0.10598796f, 0.09494387f, -0.08719338f, -0.08633485f, 0.16388269f, 0.15284577f, 
    0.00625053f, 0.05149468f, 0.16382672f, -0.02483781f, -0.00276075f, 0.12308577f, 0.03610837f, 0.08492208f, 
    -0.09745128f, 0.28519651f, 0.11798716f, -0.21301745f, -0.07107279f, -0.10446495f, 0.09121826f, -0.08871291f, 
    0.05503229f, -0.22863831f, 0.16001363f, 0.09163120f, 0.09862099f, 0.02382793f, -0.02689080f, -0.09393363f, 
    0.11792444f, 0.24299261f, 0.14262804f, -0.05167229f, 0.31522596f, -0.38424847f, -0.11047660f, -0.07098406f, 
    0.16110666f, -0.04510608f, 0.00761479f, 0.08705942f, 0.13253367f, -0.12991634f, 0.01627635f, -0.20358372f, 
    0.00534184f, -0.01775897f, -0.02611374f, -0.02499384f, 0.04145066f, -0.05821549f, -0.01311140f, -0.02568912f, 
    0.13266435f, 0.19626524f, 0.31494635f, 0.20879228f, -0.10331143f, 0.21168622f, 0.05512906f, 0.12309905f, 
    0.13566351f, -0.03067203f, 0.08149079f, 0.01975554f, 0.07240909f, -0.00307671f, 0.14621805f, 0.08245569f, 
    0.15702356f, -0.01536105f, 0.02019625f, -0.01341020f, -0.17633200f, 0.27140722f, -0.06119055f, -0.27557224f, 
    0.05296414f, -0.00555715f, -0.24852207f, 0.05906664f, -0.22098327f, 0.03393523f, -0.05326365f, -0.03005387f, 
    -0.19973373f, -0.12904881f, -0.08297519f, 0.02395239f, 0.02362102f, 0.04430173f, -0.12935410f, -0.24962676f, 
    0.03780523f, 0.27622810f, -0.02069641f, 0.22427042f, 0.15049854f, -0.08876011f, -0.02701565f, 0.08027016f, 
    0.08561795f, 0.00572083f, 0.07369186f, 0.11270828f, 0.03299929f, 0.05632917f, -0.04979574f, 0.01167009f, 
    -0.37084797f, -0.03244131f, 0.02537122f, -0.14730796f, -0.05190358f, -0.10173539f, -0.28509113f, -0.23388679f, 
    -0.04573760f, -0.14117442f, -0.14069977f, -0.13488564f, -0.19441298f, 0.16007306f, -0.15878314f, -0.13555424f, 
    0.03340274f, 0.07484317f, -0.14291553f, 0.00064173f, 0.04453273f, 0.12886800f, 0.17193009f, 0.21838318f, 
    0.29297027f, 0.17239572f, 0.33725512f, 0.07665321f, 0.00765460f, 0.00436981f, 0.02841421f, 0.16075173f, 
    0.07920916f, 0.09111462f, -0.03274987f, -0.09942354f, 0.03007302f, 0.10366248f, 0.17799470f, 0.05103538f, 
    0.07900346f, 0.11486614f, 0.11965172f, 0.24436535f, -0.19234715f, -0.19512801f, -0.35125759f, -0.59575570f, 
    -0.08982263f, -0.09439219f, 0.24748395f, 0.25747100f, -0.47740412f, -0.35465038f, -0.01330615f, -0.04572826f, 
    0.00271410f, -0.20563905f, -0.28683493f, -0.18572882f, 0.18805444f, 0.06685727f, -0.52975869f, -0.42780474f, 
    -0.04721470f, -0.11696427f, -0.27977401f, -0.05201383f, 0.34208694f, -0.02223478f, -0.01788916f, 0.17265739f, 
    0.04152280f, 0.02450780f, -0.04976875f, -0.07367551f, 0.13656162f, 0.14366360f, -0.01434347f, 0.09176653f, 
    0.08235256f, -0.07461027f, 0.03745207f, -0.03187000f, 0.32872519f, 0.21953395f, 0.50216413f, -0.04225206f, 
    -0.09063864f, 0.05298709f, -0.07187673f, 0.16942322f, 0.08883366f, 0.04261370f, -0.00777392f, 0.06476484f, 
    0.09153084f, 0.01132373f, 0.24008709f, 0.11028789f, -0.03414994f, 0.18418103f, 0.00438912f, 0.11340851f, 
    0.13121554f, 0.04501246f, 0.36808366f, -0.15182734f, -0.31770444f, 0.24814871f, 0.05140508f, -0.40415341f, 
    0.17910920f, -0.16588686f, 0.04614279f, -0.00480503f, 0.03619309f, 0.13072371f, -0.01844081f, -0.09450587f, 
    0.21477540f, -0.46679243f, 0.09646229f, -0.05467322f, 0.40210131f, 0.20232530f, -0.06171216f, 0.08866480f, 
    -0.05923054f, -0.07165213f, 0.09469629f, -0.00222234f, -0.14045182f, 0.14892262f, -0.04190674f, -0.04439729f, 
    -0.04406738f, 0.02965553f, 0.08727126f, -0.05175028f, 0.03670844f, 0.06034604f, -0.03839751f, -0.05384409f, 
    -0.70642674f, -0.07628143f, -0.42151764f, 0.18878542f, 0.55726492f, 0.13002281f, 0.33409935f, 0.04223394f, 
    0.14246613f, -0.39773616f, 0.14211456f, 0.00637513f, 0.10468376f, -0.16090705f, -0.19130999f, 0.13904290f, 
    0.18048166f, -0.02150571f, -0.03967672f, -0.25104669f, 0.12288444f, 0.12296089f, -0.16437843f, 0.23266938f, 
    -0.46791247f, 0.20738515f, 0.04588105f, 0.23135202f, -0.17698437f, -0.19144855f, -0.05115793f, 0.09398462f, 
    0.08098070f, -0.01382593f, 0.15021574f, 0.06149263f, -0.03335587f, -0.07074265f, -0.02627498f, -0.06323985f, 
    0.24232660f, 0.24796204f, -0.05781161f, 0.14518492f, 0.14449209f, 0.00255037f, -0.00600882f, 0.03143370f, 
    0.14288895f, 0.32357490f, 0.05733186f, -0.03464394f, -0.03202135f, -0.11469920f, -0.08354980f, 0.10667437f, 
    -0.09715801f, 0.13444442f, -0.04726276f, 0.18945412f, -0.47632101f, -0.07456414f, 0.09510204f, -0.13327254f, 
    -0.11061049f, 0.12353915f, -0.09928807f, -0.10706030f, -0.12179473f, -0.30233952f, 0.10118514f, 0.14394581f, 
    0.02737555f, 0.13930944f, 0.06460211f, -0.05467686f, 0.03046079f, -0.05143387f, -0.07070498f, -0.08455575f, 
    -0.51675820f, -0.09858706f, -0.29921156f, -0.25048238f, 0.04310143f, -0.31067154f, 0.10222632f, -0.17786801f, 
    0.07879243f, -0.12357825f, -0.03632884f, 0.07771305f, 0.08543471f, -0.02028441f, -0.05142331f, -0.02767748f, 
    -0.04752134f, -0.13774414f, -0.03535456f, -0.25563431f, 0.21479104f, 0.13517183f, 0.22795400f, 0.16552573f, 
    -0.07058517f, 0.08469659f, 0.02073301f, 0.03849555f, 0.01506419f, -0.04402509f, 0.08038777f, -0.06529786f, 
    0.03810276f, 0.08917267f, 0.21574515f, 0.04664758f, -0.02995493f, 0.00496265f, 0.12718886f, -0.04108674f, 
    0.00501095f, -0.05907682f, -0.01248704f, -0.02002804f, 0.02577461f, 0.00135946f, -0.00643249f, -0.06153434f, 
    -0.05385717f, -0.05533942f, -0.04847281f, 0.01291431f, 0.03226692f, -0.05089369f, -0.05950148f, -0.05640912f, 
    -0.00501811f, -0.01009051f, 0.00721798f, -0.06442080f, 0.03944869f, 0.00824873f, 0.04313162f, -0.00848708f, 
    -0.04190598f, -0.01830893f, 0.03938282f, -0.01564584f, -0.03114836f, -0.00863543f, -0.03564680f, -0.05462148f, 
    -0.02776920f, -0.04992805f, -0.05685159f, -0.01009734f, -0.04717740f, 0.02504118f, 0.02835181f, -0.03851189f, 
    0.03356548f, -0.00781395f, 0.04259870f, -0.03843542f, 0.03076497f, -0.04517935f, 0.02125961f, 0.04295362f, 
    0.00142732f, 0.02558819f, -0.04429011f, -0.03141967f, -0.06365417f, 0.03352435f, -0.00383809f, -0.06161565f, 
    0.04150508f, -0.02333473f, -0.02538584f, -0.04879826f, 0.00827075f, -0.05525464f, 0.04113088f, -0.01838684f, 
    0.01257905f, -0.02836192f, 0.00013365f, 0.00263536f, 0.02157214f, 0.01868671f, 0.03111540f, 0.00355196f, 
    0.01322910f, 0.03430835f, 0.02783819f, -0.03211123f, 0.03416249f, -0.04560693f, -0.01585125f, 0.00781830f, 
    0.02319809f, -0.03951437f, -0.04004404f, -0.02909382f, -0.01375570f, -0.06311657f, -0.05369771f, -0.00276233f, 
    -0.02166536f, -0.01913538f, -0.05141414f, -0.03118591f, -0.01035150f, 0.01787230f, 0.03236360f, 0.00964930f, 
    0.02364069f, -0.01307835f, 0.01801864f, -0.04775446f, 0.02581432f, -0.03477854f, 0.00610771f, -0.03297289f, 
    -0.01360386f, -0.02256607f, -0.03982370f, -0.05329851f, 0.00076606f, 0.00012458f, 0.02497581f, 0.01652851f, 
    -0.02246980f, -0.00314770f, -0.00714222f, -0.03757802f, 0.03733934f, 0.02997396f, 0.00261160f, 0.03525018f, 
    -0.05962545f, 0.00845026f, 0.01735475f, -0.00337865f, -0.01092223f, 0.03828860f, -0.02260077f, -0.03713665f, 
    0.00006072f, 0.00002993f, -0.00877025f, -0.06293289f, 0.00648498f, -0.04305177f, -0.05290258f, 0.03417483f, 
    -0.04410526f, 0.00467341f, 0.03423437f, 0.03853071f, -0.00606741f, 0.01878793f, -0.04017140f, 0.02573841f, 
    0.02579036f, 0.02244679f, 0.03191533f, -0.04761999f, -0.02508133f, -0.01770101f, -0.03298743f, 0.02794487f, 
    0.02354567f, -0.05385120f, -0.00404923f, -0.01143000f, 0.02627032f, 0.01733211f, 0.00588921f, 0.02250005f, 
    0.00991140f, -0.02704781f, 0.02108802f, -0.04755892f, 0.00206477f, -0.03546055f, -0.01035703f, -0.04089039f, 
    -0.05920601f, -0.05061143f, -0.04839534f, -0.02002052f, -0.05048760f, 0.02190287f, 0.00656500f, 0.03965818f, 
    -0.01448407f, -0.03612816f, 0.04163517f, -0.02328989f, 0.01961694f, -0.00341784f, -0.01659371f, -0.04519214f, 
    0.00469963f, 0.02274359f, 0.02253850f, 0.03008975f, -0.00244113f, 0.03811521f, 0.02604621f, -0.04511353f, 
    -0.00534951f, -0.04960530f, 0.02194268f, -0.06404760f, 0.00457047f, -0.03794071f, -0.06026514f, 0.04508704f, 
    0.00762317f, -0.05398900f, -0.01085746f, -0.03688276f, 0.00856528f, -0.02872294f, 0.00010836f, 0.00843000f, 
    0.00808419f, 0.03551657f, -0.00628502f, 0.02590197f, 0.03160533f, -0.01698504f, 0.03585063f, 0.02153861f, 
    -0.01547318f, -0.00544498f, 0.04059285f, -0.00449029f, 0.03850403f, 0.04273311f, 0.04067061f, -0.05813251f, 
    -0.03820658f, -0.00203471f, 0.03240244f, -0.02445710f, -0.05651826f, 0.02384488f, -0.04736489f, -0.04039666f, 
    -0.02609053f, -0.03035357f, -0.02637104f, 0.03732438f, 0.04039872f, -0.05661265f, -0.05080954f, 0.00380847f, 
    -0.02507579f, 0.00801427f, -0.00126332f, -0.06310758f, 0.01339843f, 0.03882806f, 0.00100215f, -0.04070707f, 
    -0.01330148f, -0.03686981f, -0.03051791f, -0.01494506f, 0.04448189f, 0.03488198f, -0.00232066f, 0.01573790f, 
    -0.00187762f, -0.02064354f, 0.00639435f, -0.01612461f, -0.05035734f, -0.04833121f, -0.05091692f, 0.04279004f, 
    -0.02666211f, -0.03073922f, -0.04451124f, -0.03479884f, -0.01239952f, -0.02341072f, 0.01045982f, -0.05994348f, 
    -0.00083186f, -0.00953529f, 0.00201666f, 0.01049257f, -0.02363326f, 0.04244730f, -0.05671728f, -0.02361414f, 
    -0.01768388f, -0.02802202f, 0.03815785f, 0.02302440f, 0.00537658f, -0.03322315f, 0.02116200f, -0.04624726f, 
    0.03415586f, -0.01097314f, 0.02275633f, -0.02827555f, -0.04990533f, -0.03239768f, -0.00663239f, -0.03092930f, 
    0.00416856f, 0.02909701f, -0.01770291f, -0.04774230f, -0.00586301f, -0.01722058f, 0.00779838f, 0.03732765f, 
    0.02986805f, 0.04172829f, 0.04223176f, 0.02931569f, 0.00720147f, -0.00681840f, -0.05873903f, -0.02932207f, 
    0.01469948f, 0.02584044f, -0.06197281f, 0.02866317f, -0.03714740f, -0.01191416f, 0.00525024f, 0.00808866f, 
    -0.03873878f, -0.03988859f, 0.02904459f, -0.03751823f, 0.04375091f, 0.01225208f, 0.00379062f, -0.03142048f, 
    -0.03668800f, 0.03702010f, 0.03865889f, 0.03552439f, 0.01172826f, -0.04479199f, -0.03258548f, -0.00484733f, 
    0.02168932f, 0.04178476f, -0.00299176f, -0.01251827f, -0.01412692f, 0.01854034f, 0.03687326f, -0.02887711f, 
    -0.05240075f, -0.06040674f, -0.03437746f, 0.05017031f, -0.06008983f, 0.00735290f, -0.02193153f, -0.01761688f, 
    0.03757394f, 0.03558227f, -0.03124184f, -0.04223317f, -0.02714181f, 0.01049769f, -0.01153410f, 0.03380689f, 
    -0.01569488f, 0.01769543f, 0.00224683f, -0.02366965f, 0.03825284f, 0.00127208f, 0.00013976f, 0.00239986f, 
    -0.04281282f, 0.00991632f, -0.00034750f, 0.03742716f, -0.02306630f, 0.03741189f, -0.05555222f, 0.02883579f, 
    0.04513845f, 0.03643790f, -0.04595829f, -0.05610691f, -0.01763315f, -0.03549145f, -0.06053040f, -0.02301084f, 
    0.01267871f, -0.00023086f, -0.05900286f, -0.06078777f, -0.03326768f, 0.04326405f, -0.02739388f, 0.00915713f, 
    -0.03363546f, 0.00936541f, -0.03620020f, 0.00238695f, -0.04226377f, -0.01650221f, -0.04846879f, 0.00967016f, 
    -0.06038176f, -0.05499965f, -0.02872884f, -0.01048400f, -0.06033346f, -0.04172862f, -0.03653216f, -0.05984139f, 
    -0.01435069f, 0.00852438f, 0.03591298f, -0.04940255f, 0.04449344f, -0.02044835f, 0.02357470f, 0.04304923f, 
    0.01894971f, 0.04736880f, 0.04084367f, 0.02993474f, -0.00423615f, 0.03173862f, -0.02700232f, 0.00731527f, 
    0.04195921f, 0.00825409f, 0.03488962f, -0.00536800f, -0.04597415f, 0.05405514f, 0.00720505f, -0.01560331f, 
    0.04246767f, 0.02389311f, -0.00948423f, 0.00761354f, -0.03435521f, 0.04693203f, -0.04046929f, 0.00209938f, 
    -0.03945386f, -0.01330268f, 0.04260483f, 0.00200409f, 0.03203231f, 0.03333206f, -0.00509124f, 0.04686494f, 
    -0.05962563f, 0.01162304f, -0.05087675f, -0.02793204f, -0.04455838f, -0.05564688f, 0.01913696f, 0.03479470f, 
    0.02019140f, 0.01115697f, -0.02347702f, -0.04799015f, 0.01288256f, 0.01801995f, -0.03515504f, 0.03475727f, 
    0.03063181f, -0.03261390f, 0.04660459f, 0.04845959f, -0.01714651f, -0.04027925f, 0.01372106f, 0.03845023f, 
    0.01553711f, 0.04315124f, -0.01026536f, 0.04984419f, -0.00555784f, -0.03768608f, 0.04126187f, 0.00500076f, 
    -0.04114890f, 0.04282358f, -0.02136737f, -0.04443253f, -0.05590095f, -0.03232126f, -0.03193495f, 0.02022967f, 
    0.02235175f, 0.00981403f, 0.05030152f, -0.03597119f, -0.04892928f, -0.00706430f, -0.06025250f, 0.03403641f, 
    -0.04594693f, 0.02786310f, 0.00450243f, -0.03615453f, 0.03510886f, -0.02097069f, -0.00213965f, -0.04993356f, 
    0.00866969f, -0.03404819f, -0.05229783f, -0.01233615f, 0.00288648f, 0.04178918f, 0.00043276f, 0.03132166f, 
    -0.03911965f, -0.00124010f, -0.00415333f, -0.02238386f, 0.00657572f, -0.01906452f, -0.03105081f, 0.02654793f, 
    0.04340334f, -0.03875812f, -0.01075519f, -0.05843651f, -0.03855294f, -0.02817520f, 0.04022614f, 0.00016998f, 
    0.04192073f, -0.01125563f, 0.03134188f, -0.01180258f, -0.03269427f, 0.04896914f, 0.01484770f, -0.02577942f, 
    -0.00474335f, -0.05914288f, 0.02780329f, 0.01505993f, -0.02129861f, -0.03295321f, -0.01356400f, -0.03404818f, 
    -0.01522121f, -0.02827301f, 0.05380867f, 0.02108995f, -0.05545187f, 0.00189674f, -0.01318529f, 0.00622251f, 
    -0.00055183f, -0.03522665f, 0.04510844f, -0.03418874f, -0.02275544f, -0.05216879f, -0.05368244f, -0.02577823f, 
    -0.05377424f, 0.03544693f, 0.00153814f, 0.02959635f, 0.05372646f, -0.02235265f, 0.00010601f, 0.04613729f, 
    -0.02088741f, -0.00839221f, -0.02833484f, 0.00456932f, 0.03666848f, 0.02021043f, 0.01533194f, 0.01382479f, 
    0.02058863f, 0.03146486f, -0.00291056f, 0.00545874f, 0.02527505f, 0.02606369f, 0.04034099f, -0.04808117f, 
    -0.01486148f, 0.01154592f, 0.02523888f, -0.00388382f, -0.05429877f, 0.01421052f, -0.05699947f, 0.01245628f, 
    -0.00563849f, 0.04782907f, -0.04447380f, -0.00436969f, -0.02260732f, -0.05078414f, -0.04552778f, -0.01340238f, 
    -0.03251203f, -0.05705040f, -0.00672443f, -0.05113031f, 0.04276057f, -0.05776449f, -0.03326539f, 0.00922442f, 
    -0.00456707f, -0.00940583f, 0.02519328f, 0.04398522f, -0.02087961f, -0.02385197f, -0.01749831f, -0.01484356f, 
    -0.04800447f, 0.00963648f, 0.03344921f, -0.01040588f, 0.02662317f, -0.05253097f, 0.02987159f, -0.00269048f, 
    0.02554689f, -0.00326384f, -0.05665646f, 0.00698031f, -0.02368619f, -0.05993946f, -0.04501946f, 0.04497419f, 
    -0.00048024f, -0.03875159f, -0.02531648f, -0.05305219f, -0.05446661f, -0.00793234f, -0.03821437f, -0.05859387f, 
    -0.36940575f, -0.05718331f, -0.36006707f, -0.43843970f, -0.12422498f, -0.08217227f, -0.06497711f, -0.00323497f, 
    -0.07559582f, 0.29124770f, 0.00740632f, 0.16743091f, -0.08872976f, 0.28887701f, 0.00385207f, -0.01068813f, 
    -0.01685509f, -0.03146993f, 0.04639631f, 0.05789759f, 0.40214962f, -0.20457001f, 0.38644698f, 0.17308538f, 
    0.07952505f, 0.21799251f, 0.15538724f, 0.01085057f, 0.13685696f, 0.01777667f, 0.13029754f, 0.02933296f, 
    -0.09633792f, 0.10146504f, 0.06758688f, 0.01052457f, -0.01778269f, 0.02658982f, 0.19272520f, 0.27830067f, 
    0.25254345f, -0.09243762f, 0.27549133f, -0.03759241f, -0.18813565f, -0.04545877f, -0.09627843f, -0.07922882f, 
    -0.16922390f, -0.06430921f, 0.02517687f, 0.02748638f, 0.01551373f, -0.04396967f, 0.04846248f, 0.01982780f, 
    0.04411391f, -0.04848522f, 0.07029557f, -0.07612561f, 0.35071775f, -0.14663106f, 0.15020421f, -0.03705494f, 
    0.29782191f, 0.00953459f, 0.29635763f, 0.19454980f, 0.08584459f, -0.14133757f, 0.20065483f, -0.04734325f, 
    0.10191098f, 0.01444859f, 0.14253822f, -0.09356666f, -0.18367706f, 0.16169317f, -0.03140567f, -0.05170676f, 
    -0.17741776f, -0.11701181f, 0.02735001f, -0.06840137f, 0.05621481f, -0.03205486f, -0.07760884f, -0.00520049f, 
    -0.07752977f, -0.04043793f, 0.00394007f, -0.00688049f, -0.02626012f, 0.04219315f, -0.00667274f, 0.02311734f, 
    -0.02595996f, 0.05413008f, -0.11833404f, -0.11058942f, 0.15664721f, 0.08280043f, -0.09370013f, -0.05474304f, 
    0.03039072f, 0.06886097f, 0.05120493f, -0.03602475f, 0.02392556f, 0.05658220f, -0.06223712f, 0.01934420f, 
    -0.14535375f, -0.03111235f, 0.04540089f, 0.10728909f, -0.06459154f, -0.06996511f, -0.04811317f, 0.07973514f, 
    -0.07409734f, 0.09544720f, 0.01883574f, -0.02167488f, -0.13276105f, 0.08498096f, 0.11702078f, 0.02203638f, 
    -0.04874115f, 0.04212748f, 0.20303020f, -0.10200767f, -0.11273377f, 0.05750942f, -0.02565020f, -0.08343179f, 
    -0.12690113f, -0.00420354f, 0.07731884f, 0.02496699f, -0.26732481f, -0.04918626f, -0.14114025f, -0.00761305f, 
    -0.01718332f, -0.12354675f, 0.09920122f, 0.07623324f, 0.09401912f, 0.00411493f, 0.05536335f, -0.04389889f, 
    -0.08917821f, 0.15434684f, 0.05353903f, -0.07503245f, -0.03860247f, 0.18518659f, 0.28181663f, -0.04055612f, 
    0.44892827f, 0.14620383f, -0.41751039f, 0.27286780f, 0.23473935f, 0.12296034f, 0.08714207f, 0.15477082f, 
    0.11307010f, 0.04992639f, -0.00167030f, 0.06884769f, -0.02347635f, -0.16955723f, -0.02790235f, -0.02093153f, 
    -0.00054448f, 0.27416211f, -0.08266696f, 0.07117858f, -0.44919610f, -0.16393839f, 0.19788769f, -0.15836522f, 
    -0.05350684f, 0.05913813f, -0.05688243f, -0.11143640f, 0.14340718f, -0.01253675f, 0.04528446f, -0.01847068f, 
    -0.05037587f, 0.00715497f, -0.02186851f, 0.01102268f, -0.03294836f, 0.18617877f, 0.06649789f, 0.05389846f, 
    0.11866560f, 0.11653382f, -0.10769795f, -0.12771182f, -0.14351940f, 0.05933889f, 0.00810387f, -0.13653204f, 
    -0.00228722f, 0.11906018f, -0.00186378f, -0.04396603f, -0.16235226f, 0.17573939f, 0.16360889f, -0.13609564f, 
    -0.07193017f, -0.05558684f, 0.05130441f, 0.16630934f, -0.37001082f, -0.02111058f, -0.34022173f, -0.34879550f, 
    -0.02302668f, -0.05981113f, 0.05921755f, -0.06590772f, 0.07111418f, 0.24119475f, -0.02908201f, -0.00384792f, 
    -0.07852455f, 0.07036906f, -0.01183692f, 0.06704012f, -0.01694493f, 0.03104858f, -0.00280879f, -0.00670545f, 
    -0.12279227f, -0.08699325f, 0.42034432f, 0.01052149f, 0.01925565f, 0.06700777f, 0.04525286f, 0.19822888f, 
    -0.35248727f, -0.18256740f, 0.05222069f, -0.03220674f, -0.04584033f, -0.05406094f, 0.01717162f, 0.01366247f, 
    -0.03490515f, -0.05991507f, 0.11010429f, -0.01021831f, 0.46568817f, 0.03249009f, -0.25231254f, 0.23191856f, 
    0.09996419f, 0.09927156f, 0.15188225f, -0.32477468f, 0.26684412f, 0.19440953f, -0.07691194f, 0.09743062f, 
    0.11996812f, -0.07208160f, 0.06234248f, 0.14866279f, 0.06309512f, -0.01669513f, -0.00604532f, 0.08790883f, 
    0.35519734f, 0.09481197f, 0.21742889f, 0.10936181f, -0.10842540f, 0.10912650f, -0.05542070f, -0.01520723f, 
    -0.06143987f, 0.12966576f, -0.02251672f, -0.11083119f, 0.17653875f, -0.04160376f, -0.02750611f, 0.02642312f, 
    -0.09241788f, 0.00910137f, 0.00651071f, 0.15145223f, -0.27671263f, 0.12384307f, -0.00484113f, -0.30168438f, 
    -0.06616218f, -0.12066867f, 0.00890744f, -0.11908484f, 0.04427150f, 0.29259753f, 0.08185470f, 0.16428140f, 
    -0.11651953f, -0.03335172f, -0.07309603f, -0.04522744f, -0.04939339f, 0.08844434f, -0.09675544f, 0.07544400f, 
    -0.04470290f, -0.04065038f, -0.00331144f, -0.01058939f, -0.04315970f, -0.00806439f, -0.04351398f, -0.05787167f, 
    -0.01651866f, -0.04120503f, 0.04326896f, -0.02827607f, 0.00859486f, 0.02038492f, -0.04695287f, -0.00486548f, 
    -0.03042831f, -0.06138609f, 0.02585584f, -0.01822964f, -0.01962014f, -0.04903266f, 0.03360147f, 0.00332353f, 
    -0.03268665f, 0.04329080f, -0.03325653f, 0.02101560f, -0.02071072f, -0.01877214f, -0.02894951f, -0.02503524f, 
    0.04804062f, 0.01192303f, -0.03225192f, -0.01380641f, -0.01082890f, 0.01044349f, 0.01248977f, -0.01065143f, 
    -0.04569959f, 0.02821086f, 0.02999230f, -0.03241438f, 0.00507765f, -0.03592448f, -0.05545659f, 0.00994799f, 
    0.03104962f, 0.01214049f, -0.02419884f, -0.00124034f, 0.00798650f, 0.03412424f, -0.03394183f, -0.00618494f, 
    0.00173586f, -0.01425700f, -0.03262211f, -0.05154401f, -0.05971741f, -0.02367550f, -0.01776602f, 0.02909904f, 
    0.01278380f, -0.01315463f, -0.05851553f, -0.01013698f, 0.01035746f, -0.02788377f, -0.00754283f, -0.04943168f, 
    -0.05148420f, -0.04088899f, -0.02062760f, 0.03734260f, -0.01343945f, 0.01565177f, 0.04808431f, 0.04205129f, 
    -0.03788961f, -0.04697480f, 0.00152836f, -0.06203600f, -0.04423745f, 0.01853786f, 0.00656779f, 0.00446418f, 
    0.03953028f, -0.01145044f, -0.00033356f, 0.02075029f, -0.00776547f, 0.04525439f, 0.00492268f, -0.03394922f, 
    0.03298008f, -0.00512607f, 0.01308908f, -0.04041447f, 0.00692705f, -0.03549830f, -0.01160597f, -0.04360835f, 
    -0.00776752f, -0.05424896f, 0.02009363f, 0.01005520f, -0.02383958f, -0.02376929f, -0.00710059f, -0.04952127f, 
    0.03031857f, -0.05739081f, -0.00791453f, -0.03142573f, 0.03530860f, 0.04275646f, -0.05770719f, 0.04593576f, 
    -0.06221770f, 0.02379408f, 0.02855725f, -0.00551084f, -0.05756079f, 0.04552158f, -0.03428212f, 0.04119869f, 
    -0.05201726f, -0.01510773f, 0.02500679f, -0.00990903f, -0.02195542f, -0.02766028f, -0.00952762f, 0.00227417f, 
    -0.01121446f, -0.02046589f, 0.02281249f, -0.04810875f, 0.01717770f, 0.04575588f, 0.02949065f, -0.04845151f, 
    -0.02499592f, 0.03722272f, 0.01444612f, 0.02344084f, -0.03756259f, 0.04254176f, -0.03835664f, -0.05213127f, 
    -0.01475562f, 0.03158844f, -0.06068291f, -0.00899510f, 0.01116092f, -0.02400904f, 0.01768289f, -0.02153899f, 
    -0.04140192f, 0.03281638f, -0.00179792f, -0.01535163f, 0.03312762f, 0.02073491f, -0.04819288f, -0.05761731f, 
    -0.04039560f, 0.01548647f, 0.00541959f, -0.02892549f, 0.00517806f, 0.02490577f, -0.01896154f, 0.03039825f, 
    0.00290354f, -0.01239463f, -0.04419644f, -0.01384016f, -0.06269533f, -0.00856557f, -0.01530745f, -0.04161924f, 
    -0.05500836f, -0.04581680f, -0.01168824f, 0.00034011f, -0.02112693f, -0.01937460f, 0.01012370f, -0.05927318f, 
    -0.00163148f, 0.03081516f, 0.04533868f, -0.05257041f, -0.03032355f, -0.00116646f, -0.05204414f, -0.00661888f, 
    0.02776814f, 0.00007022f, 0.01828047f, 0.02796700f, -0.00263002f, -0.00990647f, 0.01438275f, 0.00822550f, 
    0.00029293f, -0.02945182f, 0.03413096f, 0.04302969f, -0.00724114f, 0.00575048f, -0.06144228f, -0.06449020f, 
    -0.04412179f, -0.00705004f, -0.00929736f, -0.06304128f, 0.01281885f, 0.03989202f, 0.02049672f, 0.04038700f, 
    -0.03272264f, 0.01578000f, 0.00737152f, -0.04335424f, 0.04535400f, 0.00428119f, 0.02595544f, 0.00049010f, 
    -0.02019520f, 0.01592756f, 0.00989068f, -0.00172292f, -0.05659876f, -0.01651721f, 0.03718470f, 0.00916655f, 
    -0.03151752f, -0.02459241f, -0.02878502f, -0.04154697f, 0.03668232f, 0.02599218f, 0.01663556f, -0.05303427f, 
    0.03741375f, -0.00497052f, 0.04364241f, -0.00635759f, 0.02337966f, 0.01209979f, -0.04345816f, 0.02363111f, 
    0.03471836f, -0.06135954f, 0.02911181f, -0.05950476f, 0.03557121f, 0.04643982f, -0.03495347f, 0.04380640f, 
    -0.05504168f, -0.02475114f, -0.02762626f, -0.05364700f, -0.05484017f, 0.02258351f, 0.04222532f, 0.04480898f, 
    -0.03249066f, -0.04629201f, -0.02449273f, 0.00430201f, -0.01343735f, 0.01574718f, -0.03394477f, -0.03055964f, 
    0.04250636f, -0.02776907f, -0.04095130f, 0.03564438f, 0.02851807f, -0.02721940f, -0.00043323f, -0.03032027f, 
    0.04655756f, 0.00150548f, -0.04693166f, 0.01169623f, 0.04150956f, -0.03283070f, 0.00854108f, -0.02416839f, 
    0.03190467f, 0.03607663f, -0.04804367f, -0.04244388f, -0.01125620f, 0.04549026f, 0.03717804f, 0.04646708f, 
    0.00076116f, -0.02246653f, 0.04460258f, 0.02268771f, -0.00527569f, 0.01070678f, 0.02512069f, -0.05403175f, 
    -0.01367214f, 0.01362215f, -0.02830941f, 0.01945271f, -0.00511839f, 0.01476242f, 0.02608523f, 0.02281843f, 
    -0.19235404f, 0.20255351f, 0.09112797f, 0.03097103f, -0.19569518f, 0.11036669f, -0.02950311f, -0.12332238f, 
    -0.10583629f, -0.00343168f, 0.01585546f, -0.10839137f, 0.01714095f, -0.14285424f, 0.00358448f, -0.00091608f, 
    -0.09074824f, -0.04376196f, -0.09483719f, -0.00933495f, 0.24782918f, 0.15632638f, 0.06208692f, -0.00544657f, 
    -0.25767174f, 0.10948605f, -0.19386488f, 0.00514227f, -0.21395379f, 0.15377098f, 0.05763298f, 0.08820274f, 
    0.06393692f, -0.05760218f, 0.00691908f, 0.03885721f, 0.01457128f, -0.10215377f, -0.22183476f, -0.07233731f, 
    0.03108668f, -0.14012583f, -0.46259159f, -0.11174574f, -0.24110746f, -0.00292586f, 0.00868218f, -0.01896529f, 
    0.10015590f, -0.11533415f, 0.03050874f, -0.07108881f, 0.00330171f, 0.03091187f, -0.05793807f, -0.05040038f, 
    0.16266647f, 0.08237056f, 0.03722565f, 0.27774075f, 0.36235023f, 0.11322062f, -0.02066099f, 0.42593628f, 
    -0.39852726f, -0.01086277f, -0.16865447f, -0.31527427f, -0.00282211f, 0.37590927f, -0.08188897f, 0.01026332f, 
    0.10749511f, -0.13998613f, -0.01152189f, -0.03656043f, -0.24288987f, -0.06262398f, 0.13018470f, -0.03866989f, 
    0.25674093f, 0.26179624f, 0.22650617f, 0.03449852f, -0.06936029f, 0.20047095f, 0.06402289f, 0.09068134f, 
    0.07763261f, 0.08173823f, 0.06330331f, -0.04894518f, 0.03174901f, -0.02647620f, 0.07666337f, 0.00747153f, 
    -0.29724687f, -0.04804713f, -0.11292564f, -0.18923636f, 0.04898986f, -0.11089648f, -0.02007103f, 0.11634825f, 
    -0.06907211f, -0.22153726f, -0.08975700f, -0.06478118f, -0.22523592f, -0.21767224f, -0.03459904f, 0.05532911f, 
    0.34511772f, -0.00067133f, 0.03642027f, -0.08426775f, 0.02720595f, -0.05323582f, 0.09647782f, 0.03201725f, 
    0.27107924f, 0.46526009f, -0.07526932f, 0.06277782f, 0.27912894f, -0.16988118f, -0.10328031f, -0.04091527f, 
    -0.03591285f, -0.13829769f, 0.03240023f, 0.07784439f, -0.01574662f, 0.08820669f, 0.09774901f, 0.04480597f, 
    -0.04704481f, -0.03042600f, 0.10906096f, -0.09232105f, 0.32792658f, 0.24360006f, 0.19679818f, -0.15851837f, 
    -0.14689261f, 0.09730061f, -0.09446998f, 0.11665460f, -0.02865423f, 0.07583839f, 0.04302898f, 0.04192114f, 
    0.01814734f, -0.06309018f, 0.00315997f, -0.03583824f, -0.11198429f, 0.09320950f, -0.06735528f, -0.07093252f, 
    -0.08402091f, 0.00462322f, 0.43790048f, 0.03835653f, -0.21767212f, -0.04838335f, -0.03034727f, -0.32105780f, 
    -0.01765863f, -0.03477461f, -0.18524595f, 0.03264917f, 0.00718945f, 0.22328763f, -0.04283512f, 0.10371724f, 
    0.12046149f, 0.04424604f, 0.12128576f, 0.14319573f, 0.44034398f, 0.12534979f, -0.24118282f, 0.16083509f, 
    -0.07044604f, 0.06405796f, 0.10932150f, 0.16136216f, 0.17148219f, 0.23543340f, 0.10827032f, 0.18754078f, 
    0.04946491f, -0.00456568f, -0.07174153f, 0.10044748f, 0.10823278f, -0.01752369f, 0.07434483f, 0.14107327f, 
    -0.04660489f, -0.38105842f, 0.29104838f, 0.05826010f, 0.38304895f, 0.02172388f, -0.10975219f, -0.16372024f, 
    -0.08549740f, -0.18323769f, -0.03531646f, 0.04424607f, 0.15773475f, -0.08001918f, 0.11174855f, 0.10628209f, 
    -0.05186693f, -0.01204388f, -0.06249883f, 0.05042467f, -0.22684309f, -0.36738074f, -0.38962463f, -0.15144363f, 
    -0.31599715f, 0.03880484f, -0.06191450f, -0.08973944f, -0.11283008f, -0.04360555f, -0.02188089f, -0.00125755f, 
    0.15122133f, -0.01714825f, -0.00718554f, -0.03954102f, -0.00202113f, -0.02713547f, -0.02767208f, -0.04521704f, 
    0.13220629f, 0.15042976f, -0.09981920f, -0.26408854f, -0.29406673f, 0.13351345f, -0.10844103f, 0.12514114f, 
    0.02999057f, -0.35011572f, 0.01915573f, -0.11902434f, -0.11189631f, 0.05356282f, 0.02398062f, -0.00129645f, 
    0.01271798f, 0.09049797f, -0.12478895f, 0.05704540f, -0.24036270f, 0.02677739f, 0.21277183f, 0.34029585f, 
    0.06762831f, 0.21176124f, 0.18904167f, -0.06336889f, 0.07301860f, 0.21715364f, 0.08814269f, 0.16369399f, 
    -0.04053458f, 0.10604723f, 0.11288126f, 0.12313370f, 0.14512998f, 0.07452662f, 0.25817347f, 0.26784062f, 
    -0.06433359f, 0.19328986f, -0.13014664f, 0.07680666f, 0.36792961f, -0.02910662f, 0.12957883f, -0.05852684f, 
    -0.05578871f, -0.00275728f, -0.07491717f, 0.05309534f, 0.23365337f, 0.28435972f, 0.13133623f, 0.08324751f, 
    -0.12000394f, 0.20677821f, 0.01458027f, -0.15245505f, -0.10380216f, 0.10742945f, -0.14535785f, -0.04663922f, 
    -0.16489340f, 0.10317943f, 0.04947650f, 0.12366023f, -0.04743199f, 0.11133919f, -0.07672790f, 0.00209711f, 
    -0.03002748f, -0.06891549f, -0.12818097f, 0.06395525f, -0.00742883f, -0.02931665f, -0.02498676f, 0.07415078f, 
    0.74852169f, -0.38358781f, -0.44548738f, -0.10678432f, -0.36113840f, 0.02510514f, -0.05484338f, -0.12476748f, 
    0.17490265f, -0.15519240f, 0.03468449f, -0.04379098f, -0.10562367f, -0.11118378f, -0.04174232f, 0.04580832f, 
    0.00510297f, -0.04447387f, 0.02062184f, 0.00990948f, -0.00008433f, 0.25661591f, 0.50945646f, 0.08834846f, 
    0.19448097f, 0.15904593f, -0.00988409f, 0.01017624f, -0.04442673f, 0.06180299f, -0.00401466f, 0.04027428f, 
    0.12018007f, -0.03117703f, -0.03563178f, 0.09681447f, 0.06164491f, -0.02012709f, -0.13907307f, -0.19727829f, 
    0.07590167f, -0.15338212f, 0.03425834f, 0.00593672f, 0.07037320f, 0.26189297f, 0.17594354f, 0.16546096f, 
    0.24586859f, 0.21149197f, -0.02733140f, 0.13956906f, 0.03926794f, -0.02657785f, 0.04299838f, -0.07723548f, 
    0.02213138f, -0.07860779f, -0.01239437f, 0.17122091f, 0.77136397f, -0.19149616f, 0.44052634f, -0.20346601f, 
    0.69143635f, 0.04290006f, 0.01827254f, 0.12245401f, -0.05321144f, 0.03852051f, -0.12830572f, 0.05806248f, 
    -0.05496581f, 0.03763141f, -0.05488395f, -0.08292011f, -0.11777356f, -0.00120531f, 0.02275147f, -0.03324767f, 
    0.21960270f, 0.07897142f, 0.13574350f, -0.14438893f, -0.00771681f, 0.17048898f, 0.10889002f, -0.03013885f, 
    0.22844258f, 0.06183973f, 0.04140586f, 0.03963386f, -0.07721585f, 0.08563528f, 0.09898878f, 0.03067742f, 
    0.01908356f, -0.03251862f, 0.02379249f, -0.01709740f, 0.13875501f, 0.06757020f, 0.03699292f, 0.06639592f, 
    -0.01326074f, -0.07168459f, 0.06015655f, -0.01782744f, -0.05532385f, -0.03205698f, 0.17214814f, -0.03542288f, 
    -0.04523464f, 0.03407416f, 0.04955482f, -0.03879432f, -0.01930184f, 0.05906824f, 0.01135560f, -0.04579257f, 
    0.25955608f, 0.00358332f, 0.06985826f, 0.15100956f, 0.15728430f, 0.01510068f, -0.10906727f, 0.10158090f, 
    0.03156652f, -0.02754624f, 0.07538700f, 0.02488351f, 0.05224562f, 0.18949834f, 0.07492287f, -0.11197411f, 
    -0.03554858f, -0.14774399f, -0.07120036f, -0.01693639f, 0.32643935f, 0.17921996f, 0.06951179f, -0.01244379f, 
    -0.07389051f, 0.01839874f, 0.00070475f, 0.18341067f, 0.18664730f, 0.04300668f, -0.00123966f, -0.02828211f, 
    -0.06928010f, 0.06560704f, 0.12021994f, 0.12624525f, -0.09651145f, -0.05533599f, -0.13180780f, 0.04127890f, 
    -0.03501178f, 0.24903858f, 0.06544083f, 0.29781696f, -0.25424394f, 0.09715186f, -0.00093687f, -0.23663177f, 
    0.01242672f, 0.07808255f, 0.04420791f, 0.04921734f, 0.11491711f, 0.18169951f, 0.01407782f, 0.00469126f, 
    0.10047548f, 0.05240273f, 0.03782497f, 0.00291348f, 0.34125805f, -0.65388089f, -0.18642184f, -0.08743181f, 
    -0.08756613f, -0.05756311f, 0.03223059f, 0.18958068f, -0.04433870f, 0.12441900f, -0.01522364f, -0.07503241f, 
    -0.02961979f, -0.01385616f, -0.09421854f, -0.01022848f, 0.13543805f, -0.05282134f, -0.09305487f, 0.04508165f, 
    0.15391426f, 0.09010372f, -0.08037712f, 0.03115588f, -0.08946562f, 0.03978256f, 0.03209706f, 0.02968020f, 
    -0.01070403f, -0.07353647f, 0.10239422f, 0.01496392f, 0.23528959f, -0.12122654f, -0.12293007f, -0.02187673f, 
    -0.03010902f, 0.07286690f, -0.02470664f, -0.00896678f, 0.56391996f, -0.54006487f, -0.48713258f, -0.23398025f, 
    -0.33153257f, -0.05414137f, -0.07660048f, 0.21361850f, 0.02509504f, 0.21977058f, 0.12662177f, 0.06471843f, 
    -0.09335136f, 0.03000847f, -0.07503487f, -0.05068187f, -0.02891038f, 0.08943406f, -0.06309184f, 0.06273036f, 
    0.44098556f, 0.55305034f, 0.33533388f, 0.13948064f, 0.16126311f, -0.10884780f, 0.21646376f, -0.05240652f, 
    0.29880115f, 0.23031372f, -0.02615122f, -0.00139089f, -0.03247699f, 0.02090702f, -0.00691565f, 0.04284171f, 
    0.04812535f, -0.02969398f, 0.09990592f, 0.08722880f, 0.02686229f, -0.18272893f, 0.48112223f, 0.21318290f, 
    -0.31956351f, 0.02777107f, 0.18264331f, -0.05865550f, -0.05301880f, -0.04721522f, 0.04780344f, 0.10064026f, 
    0.04810641f, 0.17413044f, 0.06878813f, -0.04842974f, -0.08614624f, 0.18911789f, -0.03829529f, 0.07494862f, 
    0.11821873f, 0.13883966f, 0.29122892f, -0.05825092f, -0.03041043f, -0.10159717f, 0.00236287f, -0.07840779f, 
    0.00256084f, -0.19971150f, -0.01758392f, 0.05203109f, 0.00620017f, 0.05822182f, 0.02565890f, 0.16612540f, 
    -0.21330491f, 0.08608361f, 0.20970824f, -0.05013268f, 0.54098916f, -0.34592652f, -0.43387294f, -0.17179577f, 
    -0.26958430f, -0.15581581f, 0.08252841f, 0.03679264f, 0.04066402f, -0.06479685f, -0.02098956f, -0.10874513f, 
    -0.05403908f, -0.16788927f, -0.10866463f, -0.00453138f, 0.05908927f, -0.06428263f, 0.04774967f, 0.03149002f, 
    -0.19233613f, 0.13487110f, 0.43569008f, 0.28354663f, -0.03399481f, -0.26051858f, -0.20273580f, -0.17219870f, 
    -0.10650628f, -0.01346495f, 0.16816787f, 0.02989850f, -0.01798490f, 0.04000366f, -0.08080686f, 0.01384563f, 
    -0.06349939f, -0.00271490f, 0.00523112f, -0.03566152f, 0.04836734f, -0.06907449f, -0.14453264f, 0.19340596f, 
    -0.11743446f, 0.10095566f, 0.03960874f, 0.10089042f, 0.01718258f, 0.19091831f, 0.08739572f, -0.00604832f, 
    0.03459386f, 0.15777695f, 0.08159557f, -0.01798768f, 0.19002929f, 0.13649650f, -0.06890797f, 0.20318201f, 
    -0.05724415f, 0.17538433f, 0.25649494f, -0.04441296f, -0.18771312f, -0.06602985f, 0.01982680f, 0.05095243f, 
    0.05371292f, 0.15900019f, -0.15148121f, 0.02921337f, 0.05577421f, -0.08929960f, 0.01800774f, 0.04639241f, 
    0.10261884f, 0.03298699f, 0.25236723f, 0.03618760f, 0.63912666f, -0.38715866f, 0.15219463f, -0.53690004f, 
    -0.01826752f, 0.17244644f, 0.11740547f, -0.26685783f, -0.00988617f, 0.02343668f, 0.16198337f, -0.16625598f, 
    0.18488446f, -0.00508145f, 0.22156079f, -0.14737350f, 0.07660177f, -0.09665718f, -0.16349237f, -0.10597064f, 
    -0.18498336f, 0.03324419f, 0.10739214f, 0.25255185f, 0.00772975f, -0.07091569f, -0.11463360f, -0.01122953f, 
    0.01182647f, -0.08334285f, 0.07092042f, -0.01970641f, 0.01447981f, -0.14000413f, -0.08621310f, -0.11292695f, 
    0.08214364f, -0.08113605f, 0.01969588f, 0.07179142f, 0.04119058f, 0.04801472f, -0.08416233f, 0.03994275f, 
    0.07537916f, -0.02213711f, -0.00543371f, -0.07171911f, -0.09941249f, 0.03269443f, 0.16655430f, 0.29099432f, 
    0.13950677f, 0.28174797f, 0.18597881f, 0.01912000f, -0.04258527f, 0.01426934f, 0.05306512f, 0.24675959f, 
    0.50814980f, -0.61925799f, 0.34300211f, -0.23093799f, 0.21506260f, -0.06752673f, 0.11002903f, -0.29761636f, 
    -0.05566564f, -0.04762101f, 0.23539485f, 0.13935745f, 0.13238466f, 0.06987652f, -0.05795440f, 0.13921998f, 
    0.17609471f, 0.04225583f, -0.03162944f, 0.11292530f, -0.25428462f, 0.00196927f, -0.05892901f, 0.25949061f, 
    -0.19907746f, -0.16724221f, -0.03327690f, -0.11107743f, 0.06245661f, -0.03431308f, 0.00527925f, -0.06382552f, 
    -0.10037550f, -0.04159981f, -0.04595665f, -0.06697313f, 0.04500807f, -0.03320323f, -0.05359869f, 0.05127367f, 
    -0.18748783f, 0.13480982f, -0.60978723f, -0.08787455f, 0.18350816f, 0.15299775f, 0.06336302f, 0.45867303f, 
    -0.01652664f, 0.04662394f, 0.08664334f, -0.16727804f, 0.00107776f, -0.08870399f, -0.06197572f, 0.18535829f, 
    0.09299247f, -0.15471791f, 0.08920238f, -0.08389864f, 0.28442562f, 0.22533977f, 0.07188051f, -0.07484549f, 
    -0.31635675f, 0.11176030f, -0.03591073f, -0.07142152f, 0.01264846f, 0.05994117f, 0.23805985f, 0.05929146f, 
    0.02702858f, 0.14816764f, 0.10631515f, 0.06858445f, 0.03028732f, 0.09788273f, 0.04461158f, 0.06381495f, 
    -0.04551103f, 0.29215828f, 0.11063720f, 0.34690112f, 0.02274902f, -0.19556624f, -0.18186383f, -0.19870973f, 
    -0.04400831f, -0.03861469f, 0.04206218f, 0.10996996f, -0.04079219f, 0.13511300f, 0.03798194f, 0.03265486f, 
    -0.00725990f, -0.03858527f, -0.04566081f, 0.11078539f, -0.05871754f, 0.19090362f, 0.31302679f, 0.00419401f, 
    -0.12526418f, -0.07950550f, -0.17142269f, -0.29010826f, -0.04451852f, -0.04456386f, 0.08547805f, -0.06651122f, 
    0.03273953f, -0.06754080f, 0.09103110f, 0.01504339f, -0.03869064f, -0.03520031f, 0.00305330f, -0.02810842f, 
    -0.42461464f, -0.20450005f, 0.28080612f, 0.27521670f, -0.16331393f, -0.25094631f, -0.22069027f, -0.04478639f, 
    -0.14374559f, -0.15871435f, 0.02564756f, -0.06090168f, 0.06177633f, 0.02997310f, 0.01909816f, -0.03359330f, 
    0.07548363f, 0.13733454f, -0.01665755f, -0.01836327f, -0.66309512f, 0.20752296f, -0.64215696f, 0.25741249f, 
    -0.10896466f, 0.18055479f, -0.03158283f, 0.12767048f, -0.03998180f, 0.12824850f, 0.12889653f, -0.08282242f, 
    0.09804086f, 0.03942132f, -0.11973426f, 0.17449434f, 0.10647961f, -0.04494110f, 0.35479879f, 0.08546466f, 
    0.41165873f, -0.01660199f, -0.21295670f, -0.22854342f, 0.33975062f, 0.16889137f, 0.07352343f, -0.02177730f, 
    0.06745350f, 0.10927737f, 0.08060643f, 0.04586194f, 0.02752047f, -0.06784984f, 0.00887201f, 0.18280086f, 
    0.20638065f, -0.04209821f, -0.07252343f, 0.18369801f, -0.02886357f, 0.15069441f, 0.45489579f, 0.04384192f, 
    -0.15784833f, -0.03741203f, -0.06757411f, -0.08077649f, 0.08966708f, 0.11648043f, 0.18703468f, 0.12360130f, 
    0.05101214f, 0.09289939f, -0.02529168f, -0.00139268f, -0.03052043f, 0.02746456f, -0.03267027f, -0.04790282f, 
    0.34595990f, -0.01553580f, 0.11375474f, -0.03258772f, 0.00567813f, 0.01637237f, 0.07052687f, 0.17572892f, 
    -0.08179761f, -0.01063490f, 0.28482264f, 0.13712947f, -0.14041528f, 0.01052522f, -0.03129938f, 0.01142551f, 
    -0.03827662f, 0.03846622f, 0.00047295f, -0.05096465f, 0.14307381f, 0.35423484f, 0.47095534f, -0.10805219f, 
    0.12698093f, 0.07416750f, 0.14204648f, 0.03809947f, -0.11254555f, 0.02218382f, -0.01039501f, -0.06309669f, 
    0.06503686f, 0.03591359f, -0.01349504f, 0.05315402f, -0.00197632f, -0.13876294f, -0.22099975f, -0.10918022f, 
    0.28664815f, 0.39887375f, 0.28520343f, 0.02604300f, 0.13519976f, -0.00127005f, 0.07421336f, 0.00235957f, 
    0.00242090f, 0.05742567f, -0.02943125f, -0.06645816f, 0.05067677f, 0.13398995f, -0.00611180f, -0.00283293f, 
    0.05391789f, -0.07517365f, 0.06974824f, 0.06134836f, 0.59057587f, 0.01564544f, 0.16114320f, -0.31871623f, 
    0.20459723f, -0.08013106f, 0.14607890f, -0.03867993f, -0.01574905f, 0.04155773f, -0.08787803f, -0.04499018f, 
    -0.20634353f, 0.13820791f, -0.01596793f, -0.24246393f, -0.24894542f, -0.09346864f, -0.16618389f, -0.08969075f, 
    0.26815385f, 0.25838217f, 0.36045557f, -0.04904345f, 0.04780210f, 0.12989400f, 0.07490760f, 0.08625744f, 
    0.10457348f, 0.01337712f, -0.03222004f, -0.07069609f, -0.10474365f, 0.01085917f, -0.00620024f, 0.01754506f, 
    -0.10058866f, -0.23409747f, -0.11107731f, -0.16380438f, -0.05256274f, -0.22672014f, -0.20067999f, -0.10061073f, 
    -0.07929117f, -0.03549020f, 0.07144124f, -0.11517173f, -0.04663647f, -0.05844128f, -0.01758797f, 0.06609180f, 
    0.02459491f, 0.04475984f, -0.05641341f, -0.04395414f, -0.04549107f, -0.05652098f, -0.09434031f, -0.01307880f, 
    0.54534036f, -0.67149472f, 0.02185273f, -0.21871017f, -0.02770740f, -0.00012650f, -0.14454210f, -0.07799879f, 
    0.03683426f, -0.06044858f, -0.10406398f, 0.19686180f, -0.03279613f, 0.07975188f, -0.07460844f, 0.00703013f, 
    -0.01905301f, -0.19427466f, -0.03303447f, -0.00289212f, 0.26998162f, 0.39458165f, 0.15741426f, 0.10126631f, 
    0.05675447f, 0.03366054f, 0.13465138f, 0.14932962f, 0.08554828f, -0.13065803f, 0.02046965f, -0.05586135f, 
    -0.22853369f, 0.10922676f, 0.16635728f, -0.00081151f, -0.05565894f, -0.21192186f, -0.12107380f, -0.24250297f, 
    -0.05259689f, -0.16602299f, -0.29324511f, -0.00249983f, -0.30699345f, 0.14239849f, -0.03428893f, -0.02777480f, 
    -0.04630315f, 0.11489142f, -0.04707269f, -0.00214501f, 0.08364550f, -0.05340743f, 0.04609399f, -0.00199994f, 
    0.07789151f, 0.06099166f, 0.05469666f, 0.03888369f, 0.35846975f, 0.03027029f, -0.10274094f, 0.21875754f, 
    -0.06835545f, -0.07217620f, 0.22442003f, -0.00527264f, -0.04194136f, -0.05098882f, 0.00119750f, -0.13068809f, 
    -0.06592219f, 0.06402808f, -0.05363234f, -0.01899725f, 0.12484562f, -0.16809335f, -0.01564001f, 0.00401913f, 
    -0.23755358f, -0.46559101f, 0.00969008f, -0.15076981f, -0.05922886f, -0.04257528f, -0.04736956f, 0.02283478f, 
    -0.07496765f, 0.04854212f, 0.13101989f, 0.06277467f, 0.00197635f, 0.02193107f, -0.16041587f, -0.05406393f, 
    -0.16528898f, 0.09704771f, -0.03372201f, 0.11830163f, 0.12440430f, -0.11633296f, -0.45952559f, 0.01893068f, 
    -0.12448230f, -0.10079892f, 0.07588114f, 0.06807450f, -0.06201655f, 0.17876381f, 0.21580566f, 0.15466079f, 
    -0.01914817f, 0.09005036f, 0.03536714f, 0.01024406f, -0.03256023f, 0.02375108f, -0.02148298f, -0.01998948f, 
    0.36985824f, 0.52792430f, 0.41329798f, 0.14955601f, 0.21435797f, -0.06661978f, 0.20255718f, -0.05649119f, 
    -0.12535316f, 0.02725841f, 0.03406999f, -0.06398067f, -0.08759025f, 0.01427064f, 0.15062535f, 0.01228722f, 
    0.05473194f, -0.15049037f, -0.03045173f, -0.00512461f, -0.39910963f, -0.12597926f, 0.33017710f, 0.06668217f, 
    -0.00567038f, 0.16821745f, -0.02155819f, -0.23614725f, 0.10846325f, 0.08015392f, 0.17543718f, 0.05109234f, 
    0.10284778f, -0.03241584f, -0.09523038f, -0.05436003f, -0.08014421f, -0.03346145f, -0.18963888f, 0.09966052f, 
    -0.28904080f, -0.11010840f, -0.04329053f, -0.15705331f, -0.02223905f, -0.15288487f, -0.10277797f, -0.08988458f, 
    -0.00360812f, -0.04519333f, -0.23844571f, -0.13492535f, -0.10645778f, -0.07656885f, 0.03749052f, 0.00101452f, 
    -0.30488065f, -0.12869895f, 0.12689868f, -0.06020338f, 0.24433599f, 0.18564194f, 0.11957924f, 0.08191750f, 
    -0.03302493f, -0.11174303f, 0.21795012f, 0.05743129f, -0.05134973f, 0.03570926f, 0.07417867f, -0.02056920f, 
    0.02084991f, -0.08062478f, -0.01812537f, 0.03430589f, -0.00749140f, -0.06823237f, -0.07322107f, -0.01572080f, 
    0.20505328f, 0.02363021f, -0.20089607f, 0.36040840f, 0.02303882f, -0.20453066f, 0.00495664f, -0.06174485f, 
    0.10182194f, 0.08740387f, 0.00352583f, -0.02627747f, 0.11295556f, 0.19920111f, 0.18008821f, -0.21880449f, 
    0.01145783f, 0.16315438f, -0.09424320f, -0.04738075f, 0.32273144f, -0.14771940f, 0.15487404f, 0.11811887f, 
    0.21522275f, 0.18339796f, 0.11951394f, 0.14440002f, 0.32055843f, 0.02994444f, 0.00381571f, -0.10504459f, 
    -0.14577554f, -0.18089908f, 0.08373802f, -0.05430038f, 0.19317667f, 0.16459687f, 0.28541026f, 0.41155556f, 
    0.51485443f, 0.16747336f, 0.61981440f, 0.07258367f, -0.05885723f, 0.14256240f, -0.03139096f, 0.15262419f, 
    0.06642456f, 0.31600559f, 0.09749113f, 0.17742373f, -0.19773723f, -0.29243153f, -0.03240208f, -0.22785519f, 
    -0.33549404f, -0.27376950f, -0.21301046f, -0.34614047f, -0.24226767f, -0.43853146f, 0.20213462f, -0.51602083f, 
    0.43685052f, 0.29334968f, -0.14659728f, 0.44663009f, 0.14116172f, -0.16927077f, 0.13180724f, -0.05858504f, 
    -0.06282652f, 0.01390511f, -0.01864357f, 0.35905215f, 0.35611936f, 0.17742425f, 0.12832640f, 0.09090391f, 
    -0.05029308f, -0.10845609f, 0.05151101f, 0.09715495f, -0.00361123f, 0.05639692f, 0.06228200f, 0.02753909f, 
    0.03848704f, 0.07881996f, 0.04219988f, -0.05764261f, 0.10388999f, 0.18473341f, 0.15398999f, 0.07189743f, 
    0.38053995f, 0.22667603f, 0.21986146f, 0.42884204f, -0.26215801f, 0.16845733f, -0.20794767f, -0.20828362f, 
    -0.02923576f, 0.27821368f, 0.15056925f, 0.03519634f, -0.18458207f, -0.12562732f, 0.30635104f, 0.19887798f, 
    -0.10301246f, 0.18436800f, 0.29571885f, -0.12647204f, -0.22839867f, -0.16628972f, -0.54600924f, -0.26785260f, 
    -0.31082064f, -0.06771781f, 0.07845047f, -0.21609668f, -0.01735282f, -0.14219035f, 0.05751754f, -0.11498867f, 
    -0.13951810f, -0.02461518f, 0.05573345f, 0.08999229f, -0.06673207f, -0.03118124f, 0.00978950f, -0.01428610f, 
    0.09132373f, 0.16069408f, 0.03483624f, 0.22682239f, -0.03199595f, -0.37019032f, 0.12178919f, 0.13722812f, 
    -0.05608868f, -0.07441426f, 0.21708474f, -0.12899305f, 0.16657421f, 0.19597173f, -0.04306719f, -0.17905167f, 
    0.08717605f, 0.25435925f, 0.01235619f, 0.00892414f, 0.21140261f, 0.06188925f, 0.34777057f, 0.31111670f, 
    -0.24967116f, 0.41537085f, -0.63009220f, 0.32764325f, 0.28950882f, 0.11936409f, 0.15878877f, 0.29236659f, 
    -0.14827432f, 0.04064684f, 0.16144951f, -0.03672929f, -0.04331766f, -0.35877338f, -0.04772420f, 0.20464335f, 
    -0.05318015f, 0.00717284f, -0.19534303f, -0.23916720f, -0.43494904f, -0.21254183f, 0.54514927f, -0.13854037f, 
    -0.00065712f, 0.01354987f, -0.12133592f, 0.04794728f, 0.01999674f, -0.10893827f, 0.09876019f, 0.02520757f, 
    -0.00107657f, -0.09427601f, 0.24347284f, -0.03727574f, -0.32396105f, 0.08025587f, -0.18984915f, -0.20167966f, 
    0.15027061f, 0.62455684f, -0.30793446f, 0.12360943f, -0.20922390f, 0.02300593f, 0.02914343f, -0.33348480f, 
    -0.01756779f, 0.05139164f, 0.12906651f, 0.04748889f, 0.00799155f, 0.03392763f, 0.25138810f, -0.23860575f, 
    -0.07775950f, -0.16584109f, -0.12935530f, 0.11573883f, 0.56854981f, 0.18401489f, 0.62941766f, 0.00269540f, 
    0.14882286f, 0.05663760f, -0.14960232f, -0.12500486f, 0.19681726f, -0.20253640f, -0.08713035f, 0.16011623f, 
    0.18855992f, -0.05483296f, 0.04428460f, -0.23121123f, -0.10911335f, -0.08051014f, -0.08408216f, -0.12864615f, 
    0.06124701f, -0.18868358f, 0.31210873f, 0.09001108f, 0.03204148f, 0.19121809f, 0.16178216f, 0.19209337f, 
    0.10803635f, 0.56250125f, 0.00867975f, -0.00054467f, -0.09760874f, -0.04725485f, -0.16022167f, 0.06789838f, 
    0.03565349f, 0.00662317f, 0.17821044f, 0.14041619f, 0.26709154f, 0.34286007f, -0.49167153f, 0.13285704f, 
    0.01143516f, 0.16857721f, -0.12711245f, 0.08619294f, -0.20243300f, -0.08942489f, 0.00162535f, -0.12597351f, 
    -0.08043180f, -0.18777548f, 0.03246379f, -0.04278634f, -0.02279773f, -0.02532781f, -0.05524195f, 0.05632363f, 
    0.20582081f, -0.48134595f, 0.24481407f, -0.13552196f, -0.34868366f, 0.13812841f, 0.04422676f, 0.09383825f, 
    -0.05088869f, -0.17819351f, 0.26177078f, 0.09785132f, 0.05706709f, -0.13987845f, -0.16103712f, 0.15467127f, 
    0.46788648f, -0.28358841f, -0.07370410f, 0.10048003f, 0.23738053f, -0.07823563f, 0.24022037f, 0.17207097f, 
    0.14421746f, 0.01486543f, 0.02759657f, -0.15216437f, 0.06077562f, -0.01413535f, 0.19423647f, -0.07121681f, 
    0.07754257f, 0.10179105f, 0.14684139f, -0.10336710f, -0.12261149f, 0.17522208f, -0.13813645f, -0.08232374f, 
    0.44324407f, -0.25427094f, 0.51544613f, 0.44732291f, -0.03324215f, -0.15778323f, -0.07861549f, -0.09462329f, 
    0.09650595f, -0.08987469f, 0.12224377f, -0.17607148f, 0.14576490f, -0.07437738f, 0.02047974f, 0.08211037f, 
    0.01226205f, 0.01306012f, -0.03363211f, -0.05123141f, -0.42057252f, 0.03142679f, -0.24429174f, -0.14774285f, 
    0.02154939f, -0.03919503f, -0.06424823f, 0.11180411f, -0.07769100f, -0.08131512f, 0.01066028f, -0.06142275f, 
    0.06325728f, -0.07830501f, 0.00025669f, 0.10968975f, 0.08384087f, 0.09838773f, 0.16857484f, -0.14431678f, 
    -0.38357636f, -0.00750806f, -0.05126463f, 0.22435254f, 0.10716186f, -0.07017978f, -0.03517396f, -0.06842423f, 
    -0.04648284f, -0.06679802f, 0.02123918f, 0.00187609f, 0.10553508f, 0.09718852f, 0.10169422f, 0.02769831f, 
    -0.10657831f, -0.06584433f, -0.05852283f, -0.30118483f, -0.07882416f, -0.21805981f, -0.06085820f, -0.19653957f, 
    0.01856017f, 0.13709413f, 0.01265309f, -0.00469383f, 0.16348857f, 0.04259878f, -0.02607020f, -0.05645140f, 
    -0.09184033f, 0.00745855f, -0.04003502f, 0.13079570f, 0.06586973f, -0.04934277f, 0.01440632f, 0.14613728f, 
    0.06364498f, -0.11711251f, 0.06292818f, 0.14332861f, -0.03114882f, 0.04095253f, 0.06257093f, 0.09753347f, 
    0.06843050f, -0.02527207f, 0.01872383f, 0.00067472f, 0.04943288f, -0.03210471f, 0.01544246f, -0.01319471f, 
    0.14532353f, 0.03254828f, 0.28134483f, 0.21022139f, 0.06328630f, 0.14589214f, 0.13307482f, -0.09051649f, 
    0.01194731f, -0.02951472f, 0.02870035f, 0.10584665f, 0.05627630f, 0.00353586f, 0.03825799f, 0.04473687f, 
    0.04758947f, 0.07513484f, -0.06339798f, -0.01877289f, -0.01381135f, -0.00475322f, -0.09241626f, -0.01017969f, 
    0.17456783f, -0.60936141f, 0.18880969f, 0.29886445f, 0.23723896f, 0.07584386f, 0.06419352f, -0.04968662f, 
    0.05869658f, -0.02984465f, -0.10257155f, 0.03266077f, 0.12895790f, 0.04923037f, -0.02293797f, 0.34062496f, 
    0.30534202f, 0.22076701f, -0.19971479f, -0.00939287f, 0.04451393f, -0.14226598f, 0.10159530f, 0.19581848f, 
    -0.30216420f, 0.06520263f, -0.16684960f, 0.06695074f, -0.03254733f, 0.02460359f, 0.03322018f, 0.04257541f, 
    -0.01394469f, -0.16775496f, -0.19806476f, 0.13065836f, 0.06509066f, -0.14853856f, -0.09959149f, 0.00940945f, 
    0.16739656f, 0.03798030f, -0.06913208f, -0.32547027f, -0.07450934f, 0.04341149f, 0.08339207f, -0.11084814f, 
    0.01064518f, -0.06189652f, 0.14073336f, 0.00429776f, 0.08843391f, 0.11392014f, 0.03946959f, -0.02467212f, 
    0.10006680f, -0.16730900f, 0.15219350f, 0.01022879f, 0.29645360f, 0.17763403f, 0.06286471f, 0.13265803f, 
    -0.15004829f, -0.13776773f, -0.03725064f, -0.00953309f, 0.03417275f, 0.07094189f, -0.00003426f, -0.09268194f, 
    0.08289918f, 0.10955076f, 0.07823040f, -0.03551316f, 0.06302714f, 0.02088145f, -0.10254522f, -0.06277171f, 
    0.03092046f, 0.16341211f, -0.07687958f, 0.13186400f, 0.13608660f, -0.03405666f, 0.09809906f, 0.18578164f, 
    0.01489691f, -0.00370106f, 0.00422274f, 0.05740657f, 0.09986086f, 0.01049627f, -0.03977071f, 0.07951352f, 
    0.02196389f, 0.01008560f, -0.06772914f, -0.07182300f, 0.22244117f, 0.13851798f, 0.59222305f, 0.33884043f, 
    -0.13989185f, -0.18857594f, -0.15194628f, 0.04723668f, -0.07442588f, -0.02444167f, 0.15430644f, -0.00837991f, 
    0.09067140f, 0.03236467f, 0.06153684f, -0.01932320f, 0.00429138f, -0.06099763f, -0.00243777f, 0.03776549f, 
    -0.08612381f, -0.03188494f, -0.18830043f, 0.21010004f, -0.18995503f, -0.24313505f, -0.16441001f, -0.25850299f, 
    0.02698200f, 0.27173775f, -0.05710088f, 0.03670709f, 0.02024876f, -0.07596351f, -0.06046061f, -0.04852698f, 
    -0.00338514f, 0.00992231f, 0.00933028f, -0.11980962f, -0.39884913f, -0.23743699f, 0.14553751f, -0.36942124f, 
    0.28093350f, 0.10324647f, 0.03610629f, 0.19293480f, -0.05934513f, -0.00460773f, 0.07857876f, 0.05357536f, 
    0.07686459f, 0.03429317f, 0.06460454f, -0.21596448f, 0.13071384f, 0.05262134f, 0.03355559f, 0.02518787f, 
    -0.04653329f, 0.16602547f, 0.11215346f, 0.09595306f, 0.11389364f, -0.09781616f, 0.11893952f, 0.08009966f, 
    0.08453149f, 0.12867042f, 0.08764027f, 0.02926600f, -0.07198723f, 0.02834914f, 0.01715128f, 0.07114158f, 
    0.12706834f, -0.00499463f, -0.04484589f, 0.01335474f, 0.26935759f, -0.09877646f, 0.27985191f, 0.27456862f, 
    -0.14665660f, -0.12261782f, -0.12941690f, -0.08329386f, 0.17929111f, -0.13185446f, -0.00130403f, -0.06004430f, 
    0.14672068f, 0.09112094f, 0.07439169f, -0.00887369f, -0.03162294f, -0.09925976f, 0.10784294f, -0.07052132f, 
    0.02063508f, 0.32563996f, 0.18615168f, 0.10755850f, 0.14573948f, 0.00342415f, -0.00453972f, -0.09986094f, 
    -0.12303895f, 0.01018749f, 0.01194203f, 0.13116044f, 0.01984590f, 0.02317461f, 0.17349073f, -0.00228474f, 
    0.08383380f, 0.10235141f, 0.13353617f, 0.00488556f, -0.10963482f, 0.17481048f, 0.24935248f, -0.01168837f, 
    -0.13955650f, -0.03319174f, 0.28446442f, 0.19388966f, 0.11804315f, 0.30171064f, 0.00283307f, 0.09622859f, 
    0.02522407f, -0.05463285f, -0.00839917f, -0.01835648f, -0.01624906f, -0.13883518f, 0.09116282f, 0.18373753f, 
    0.33699095f, 0.47839981f, 0.45600784f, -0.23452452f, -0.12380867f, 0.16504329f, 0.15759003f, 0.14178695f, 
    0.15748122f, 0.08525961f, 0.13608991f, 0.07927605f, 0.08405179f, 0.00083688f, 0.01016574f, -0.01105137f, 
    -0.22561084f, -0.33721107f, -0.23024599f, -0.05579077f, -0.18542783f, 0.44939736f, 0.17683068f, -0.25104344f, 
    -0.13213387f, 0.14167482f, -0.18000032f, 0.07188088f, -0.05719158f, 0.16946918f, 0.09091494f, -0.07224327f, 
    -0.00860694f, -0.07361789f, -0.00908237f, 0.14592648f, 0.20928910f, 0.01602794f, 0.25429639f, 0.21747300f, 
    -0.10363735f, 0.16604733f, 0.34458184f, 0.13944052f, 0.00428431f, 0.04009145f, 0.13593817f, 0.00319159f, 
    -0.03900442f, 0.09133045f, -0.05545740f, 0.01789887f, -0.08625657f, 0.03412440f, 0.07077533f, 0.05589124f, 
    0.16431499f, 0.15353099f, 0.05925746f, 0.23957978f, 0.08128127f, -0.30127689f, -0.31484449f, -0.18965961f, 
    0.40467748f, -0.06166151f, -0.37938678f, -0.29883271f, -0.18826538f, -0.25831282f, 0.11640775f, 0.01349214f, 
    0.15953383f, 0.10957070f, 0.11129922f, -0.06603772f, -0.12891456f, -0.15274644f, -0.08820726f, -0.23890716f, 
    0.20628750f, 0.12762247f, 0.00305958f, -0.31430089f, -0.13069902f, -0.01208625f, -0.26386967f, -0.23944099f, 
    -0.11750011f, -0.12983103f, -0.00553922f, 0.12658022f, 0.03173422f, -0.19483522f, -0.02831032f, -0.07377045f, 
    0.18039928f, 0.02776155f, 0.26735497f, 0.40618309f, -0.02151076f, 0.11733116f, 0.22888802f, 0.02196549f, 
    0.18947075f, -0.04103779f, 0.24976552f, -0.10342870f, -0.01841977f, 0.11388492f, -0.03302285f, -0.03517543f, 
    -0.07633685f, 0.05906158f, 0.08926517f, 0.15408452f, 0.20227571f, 0.11683290f, 0.23953629f, 0.16148357f, 
    -0.62400031f, -0.23584962f, -0.52260989f, 0.03210254f, 0.24191143f, -0.00709639f, -0.05303349f, 0.06312390f, 
    -0.31142405f, 0.08657330f, 0.12253721f, 0.00504275f, -0.18030950f, -0.30191565f, -0.16896102f, 0.01746967f, 
    -0.10635481f, 0.07050966f, -0.17922305f, -0.08505461f, -0.12704964f, 0.37720120f, 0.44381300f, -0.07831684f, 
    0.16319925f, 0.03257732f, -0.01053293f, 0.09944306f, -0.13410616f, -0.12788002f, 0.07849279f, 0.17690939f, 
    0.10876229f, -0.02758641f, -0.00272894f, 0.08352261f, -0.07413001f, -0.02735972f, -0.08235224f, -0.01092550f, 
    0.18675517f, 0.05034568f, 0.21471909f, 0.06393910f, 0.05989314f, -0.12237737f, -0.39452478f, -0.29295006f, 
    -0.24913721f, -0.16553220f, -0.11348802f, 0.13917680f, -0.00227881f, -0.22144894f, 0.10703661f, -0.19816783f, 
    0.13214308f, 0.13452563f, -0.06937844f, 0.27967322f, 0.45135605f, 0.54689330f, 0.53354794f, 0.13296756f, 
    0.31691486f, 0.06802603f, -0.18076150f, -0.16053186f, -0.15538758f, -0.08083832f, -0.07333532f, -0.08429516f, 
    0.03422927f, 0.11194309f, 0.22095181f, -0.03360767f, 0.00399192f, 0.04643084f, 0.02954870f, -0.10139779f, 
    0.02176432f, 0.15064113f, 0.49507427f, -0.11326059f, -0.03734789f, 0.41187572f, 0.26770085f, 0.36797827f, 
    0.18199109f, 0.17840883f, 0.09040878f, -0.02100513f, 0.10383712f, 0.05165989f, 0.01907506f, 0.09718722f, 
    0.02686250f, -0.04597445f, -0.06008748f, 0.19060764f, -0.59263879f, 0.16506584f, -0.14641686f, 0.22040106f, 
    -0.09388400f, -0.04043559f, -0.02763043f, 0.07473440f, -0.28083652f, -0.00463362f, -0.00417068f, -0.09023045f, 
    -0.05760467f, -0.04409762f, 0.03326055f, -0.09230459f, -0.12730573f, 0.09101798f, -0.12341835f, 0.06615356f, 
    -0.24122785f, -0.37824383f, -0.16610807f, -0.14264266f, 0.03949376f, 0.13924424f, 0.08671647f, -0.06644518f, 
    -0.16294686f, -0.10220352f, 0.08284329f, 0.11240478f, -0.03832560f, 0.03617398f, 0.06984814f, 0.14471017f, 
    0.09842175f, -0.02967319f, -0.14480446f, -0.21058172f, 0.06331073f, 0.22680596f, 0.32238960f, -0.04415004f, 
    0.10245906f, 0.09449814f, 0.00561308f, 0.03659884f, -0.00786365f, -0.01091617f, -0.03146199f, 0.15080476f, 
    0.16041961f, 0.13615587f, 0.07152255f, 0.12716280f, -0.07725043f, 0.03265024f, 0.01399206f, 0.01515092f, 
    0.46904960f, -0.12914193f, 0.51972717f, 0.02611825f, 0.06117829f, -0.00544884f, -0.00295718f, 0.04798207f, 
    0.06430319f, -0.05501934f, 0.04791769f, 0.06642162f, 0.04149120f, -0.26097223f, -0.19443555f, 0.10148314f, 
    -0.00415276f, -0.02721806f, 0.05999721f, -0.00271198f, -0.71193033f, 0.11442174f, -0.12356913f, 0.14728074f, 
    0.13421495f, -0.18075722f, 0.16764933f, -0.08102477f, 0.01147204f, 0.08699605f, 0.00593974f, -0.02948627f, 
    0.06066657f, 0.04284321f, -0.02289708f, 0.11018923f, 0.02433640f, -0.11687580f, 0.05133482f, -0.06317942f, 
    -0.66924125f, -0.02236401f, -0.15380237f, 0.05140216f, 0.07823003f, 0.10206703f, 0.25614053f, 0.13890167f, 
    0.04189489f, 0.03068900f, 0.03394806f, -0.03875892f, 0.06870704f, 0.09118079f, 0.07946661f, -0.05328703f, 
    0.08457115f, -0.04476980f, 0.09812779f, 0.24695924f, -0.39410084f, 0.52480763f, 0.41728982f, 0.06440128f, 
    -0.04036146f, 0.12163924f, -0.01611446f, 0.09756834f, 0.04641469f, 0.12260205f, -0.03515833f, 0.01476540f, 
    -0.11139754f, 0.14790480f, 0.00309778f, -0.01600605f, -0.00416116f, -0.12194718f, -0.01525009f, -0.13280316f, 
    -0.05169489f, 0.02840924f, -0.07679784f, 0.11545391f, 0.14594027f, -0.03303224f, 0.00868142f, -0.01836162f, 
    0.10539287f, -0.01482920f, 0.05553523f, 0.00466926f, -0.05882955f, -0.20514558f, -0.07000146f, -0.08680093f, 
    -0.16100210f, -0.20163105f, 0.06501110f, -0.13523079f, 0.05289013f, 0.00416380f, -0.07298919f, 0.05600352f, 
    -0.04666198f, -0.02731255f, -0.02011769f, -0.04799781f, 0.09250252f, 0.04384043f, -0.15095027f, -0.15374428f, 
    0.04335248f, -0.04790773f, -0.06179181f, -0.13913018f, 0.03653109f, 0.02194102f, 0.25785044f, 0.01711064f, 
    0.50414145f, -0.16741486f, 0.42133942f, 0.17863828f, 0.09921257f, 0.07366282f, 0.01167435f, 0.03782856f, 
    0.11602695f, -0.11137748f, 0.03007175f, 0.15529126f, 0.04481078f, -0.07445502f, 0.02270475f, -0.00212353f, 
    -0.01166705f, -0.11371047f, -0.19278497f, -0.00047441f, -0.15722477f, 0.16162165f, -0.11083047f, 0.24391991f, 
    0.15498193f, 0.08485464f, -0.10541105f, 0.02619659f, 0.05583463f, 0.00858219f, 0.00022294f, 0.07145996f, 
    -0.08665437f, -0.26627505f, -0.14148812f, 0.01200563f, -0.09276003f, -0.17641012f, -0.06912145f, -0.01543235f, 
    -0.34641463f, -0.30311447f, -0.04449559f, -0.27382594f, -0.08314380f, -0.04667973f, -0.10572757f, 0.11096106f, 
    -0.03917499f, 0.01250373f, 0.01779643f, -0.08207218f, 0.22103974f, 0.05293820f, 0.03499982f, -0.11381690f, 
    -0.07291681f, 0.06110023f, 0.06112895f, -0.03630124f, 0.30610153f, 0.41688913f, -0.26555866f, 0.02402965f, 
    0.15535475f, -0.12674727f, 0.07020311f, 0.32306179f, 0.11757004f, 0.15297429f, 0.07030108f, -0.01823447f, 
    -0.04034861f, 0.00237746f, 0.03099503f, -0.05561407f, 0.06096925f, -0.09224118f, 0.07021981f, 0.03763292f, 
    0.21236239f, -0.03261851f, 0.22524227f, 0.03683533f, -0.04167107f, -0.10557340f, -0.03441840f, 0.02854560f, 
    -0.04673553f, 0.05308886f, -0.21421500f, -0.06664479f, -0.16797529f, 0.02013848f, -0.24600422f, -0.04017739f, 
    -0.07518320f, 0.06766594f, 0.05123721f, -0.10456664f, 0.06705559f, 0.05340675f, 0.02173481f, 0.15513909f, 
    0.03393640f, -0.06773081f, -0.02651896f, 0.15404527f, -0.12685193f, -0.01285670f, 0.07521079f, -0.10417593f, 
    -0.00725406f, -0.01599072f, -0.00714561f, 0.02312165f, -0.02424938f, 0.01301571f, -0.01626042f, -0.01975962f, 
    -0.28655705f, 0.09349725f, -0.14238591f, 0.14992034f, 0.06690164f, -0.16883819f, 0.07049965f, -0.29427412f, 
    0.34549931f, 0.01667430f, -0.08124050f, 0.05316263f, 0.00468444f, -0.08599779f, 0.02295001f, -0.01617912f, 
    -0.03867083f, -0.02747245f, 0.12701669f, 0.02124177f, -0.24490738f, -0.08467466f, 0.12618631f, 0.03679150f, 
    0.02822672f, -0.26818693f, 0.13973197f, 0.46889326f, -0.02972500f, 0.05696135f, -0.01681177f, 0.06685256f, 
    -0.06366206f, 0.06213951f, -0.10815235f, -0.17699873f, 0.01943576f, 0.10347065f, 0.24120326f, -0.11175112f, 
    0.12567288f, 0.09520342f, 0.04058613f, 0.17785950f, 0.20098361f, -0.00618788f, 0.00568637f, 0.04542883f, 
    0.05306995f, 0.10836886f, -0.01121310f, 0.12759393f, -0.18502586f, 0.24286892f, 0.09322370f, 0.00247425f, 
    -0.15460429f, -0.01744697f, 0.21477184f, -0.01085550f, 0.27901754f, 0.00563204f, 0.06701662f, -0.00671160f, 
    -0.12641849f, -0.09872624f, 0.09368361f, 0.35264170f, 0.17481677f, -0.16100314f, -0.05145148f, 0.09178726f, 
    0.05850340f, -0.04109627f, -0.06058031f, 0.05442335f, 0.02620106f, -0.13466203f, 0.16213645f, 0.01641209f, 
    -0.04904938f, 0.05193226f, 0.18396738f, -0.05681867f, -0.05728128f, 0.17838335f, 0.04240666f, -0.03689370f, 
    0.03107981f, 0.09260737f, -0.06479947f, 0.04198676f, 0.04930383f, -0.04026419f, -0.02505066f, 0.01963511f, 
    0.11115595f, -0.08878528f, -0.10531872f, -0.08592847f, -0.40492329f, 0.16699959f, 0.09034355f, -0.17812589f, 
    0.26826391f, -0.18264894f, -0.08927619f, -0.10631137f, 0.14256050f, -0.12588075f, -0.12493760f, 0.00787750f, 
    -0.06261899f, 0.07705735f, 0.05084850f, 0.13303317f, -0.02569873f, -0.06420390f, 0.10754114f, -0.22556081f, 
    -0.25939390f, 0.07965497f, -0.03094561f, 0.12805803f, 0.36226204f, 0.07491249f, -0.00995628f, 0.12692809f, 
    0.04747412f, 0.07052120f, 0.05933540f, 0.08881429f, -0.02115115f, 0.04364345f, 0.04541219f, 0.01778895f, 
    -0.13275194f, -0.09234709f, -0.09941899f, -0.08860267f, -0.65695637f, 0.47278756f, -0.48683318f, 0.28839391f, 
    0.22533685f, 0.00823462f, 0.22451875f, 0.04380639f, 0.35648221f, -0.19258898f, -0.15821183f, -0.04122180f, 
    -0.06035200f, 0.05419689f, -0.07099260f, -0.00006318f, 0.04097855f, 0.18466535f, 0.00684280f, 0.13041894f, 
    -0.08812184f, -0.07479540f, -0.30988351f, 0.05621335f, 0.05382642f, 0.04016933f, 0.07520661f, 0.08287241f, 
    -0.04554329f, 0.03453166f, -0.06720892f, 0.01666562f, 0.05876774f, 0.07422053f, 0.10540839f, 0.03369267f, 
    0.07407270f, 0.00197184f, 0.17484367f, 0.14746970f, 0.02004899f, -0.01576252f, 0.13711374f, -0.00722031f, 
    -0.07741047f, -0.05530787f, 0.08650294f, 0.01869393f, 0.12078740f, -0.01014874f, -0.09687299f, 0.03539501f, 
    0.12615055f, -0.05935820f, 0.03453926f, -0.03611508f, 0.03302077f, -0.13181567f, -0.08299109f, -0.22260635f, 
    -0.23283206f, 0.11722161f, 0.04171587f, 0.46291932f, -0.09610151f, 0.19022852f, -0.02765134f, 0.16781402f, 
    -0.09282946f, 0.01115538f, -0.13074513f, -0.10384710f, -0.00107386f, 0.09091212f, 0.07040789f, -0.00279042f, 
    0.10340232f, 0.03003795f, -0.04887914f, -0.06712650f, -0.04102989f, 0.15527318f, -0.14856976f, 0.19241597f, 
    0.11546513f, 0.11459971f, -0.03306586f, -0.02992114f, -0.15124403f, 0.06830753f, -0.07115795f, 0.04851086f, 
    0.04298124f, 0.03622565f, 0.11383472f, 0.10133225f, 0.00697340f, -0.06663712f, 0.11223225f, 0.09609995f, 
    0.39538863f, -0.13068368f, 0.48457307f, -0.14285205f, 0.06872757f, 0.10640822f, 0.19009317f, -0.06036202f, 
    -0.02855307f, -0.03416384f, -0.18498279f, 0.09830622f, 0.08461625f, -0.02762193f, 0.10931227f, -0.08321194f, 
    0.10729419f, 0.05276577f, 0.04705868f, 0.16729978f, 0.06378470f, 0.09466418f, -0.01520280f, 0.25849816f, 
    -0.00311338f, -0.00207950f, 0.04091129f, -0.07518847f, 0.07751668f, 0.08866606f, -0.08444826f, -0.24697533f, 
    -0.13643415f, 0.05945622f, 0.02975480f, -0.12269554f, 0.12823626f, 0.02296098f, -0.05323288f, -0.02101292f, 
    -0.04313484f, -0.33677205f, 0.12781049f, -0.18781729f, 0.01717746f, 0.07544921f, 0.07351163f, 0.11781285f, 
    0.02689530f, 0.10636094f, -0.04300493f, 0.00016390f, -0.04006864f, 0.07340803f, 0.08021102f, 0.06873021f, 
    -0.00827281f, -0.13460127f, 0.01823619f, -0.32390293f, -0.20308098f, -0.09543811f, 0.02696765f, 0.26016310f, 
    -0.16586813f, -0.13385032f, -0.02444739f, -0.13333485f, -0.04249923f, 0.03350863f, 0.04954764f, -0.02410856f, 
    -0.08305374f, 0.01413477f, -0.11604788f, -0.00365812f, -0.00578801f, 0.05622412f, -0.07905082f, -0.04064667f, 
    0.08339022f, 0.24461022f, -0.15497619f, 0.26192355f, 0.39122522f, -0.16434832f, 0.01910463f, -0.27488625f, 
    -0.08709653f, 0.16383091f, -0.03587656f, 0.11141882f, -0.01961201f, -0.03848600f, -0.01022885f, 0.09865987f, 
    -0.05422963f, -0.11713411f, 0.01284718f, 0.06348848f, 0.31201881f, -0.50299042f, 0.51407248f, -0.46145004f, 
    0.30044031f, -0.00015576f, 0.18150572f, 0.05911124f, 0.31092680f, -0.14765994f, -0.01149806f, 0.11462228f, 
    -0.05310244f, -0.00223362f, 0.26467514f, 0.07853768f, 0.13094492f, 0.00951974f, -0.02688519f, -0.07995825f, 
    -0.17942001f, 0.03762195f, 0.24103259f, 0.26946697f, -0.12370174f, -0.18417050f, -0.11467932f, 0.03026250f, 
    0.03682419f, -0.00782564f, -0.14741932f, 0.00559019f, -0.01972415f, -0.01249424f, -0.01464140f, -0.07563394f, 
    -0.08854440f, 0.05684273f, -0.01536077f, 0.06425555f, 0.01141966f, 0.12716524f, -0.01848715f, 0.28112593f, 
    0.12548260f, -0.03979660f, 0.01182730f, 0.01298304f, -0.01194483f, -0.11289482f, -0.06097569f, -0.04447603f, 
    -0.02177108f, -0.03871031f, -0.03655940f, 0.04291816f, 0.03264415f, -0.09555015f, 0.05483120f, -0.08573315f, 
    0.02296284f, 0.01072140f, -0.00969022f, -0.01288529f, -0.01531527f, -0.00738426f, 0.03966843f, 0.01691918f, 
    0.03836163f, -0.00772362f, -0.00524588f, -0.01581789f, 0.03829893f, -0.02583127f, 0.03978953f, 0.03294010f, 
    -0.00038021f, 0.02071208f, -0.00410693f, 0.02481912f, 0.04127364f, -0.05403199f, -0.00272425f, 0.02397367f, 
    -0.02286176f, -0.04166830f, -0.03615560f, 0.03371766f, 0.00098220f, 0.00028505f, 0.04172304f, 0.02865602f, 
    -0.03954702f, -0.02895596f, 0.02586707f, -0.02771210f, 0.02220759f, 0.00215769f, -0.05349406f, -0.00881096f, 
    -0.02852444f, -0.04967663f, 0.03926981f, -0.02787529f, -0.05787677f, -0.04611868f, 0.02494639f, 0.02282824f, 
    -0.00269357f, -0.04963197f, 0.03095385f, -0.02311143f, 0.04708384f, -0.02379653f, -0.05455489f, -0.05914070f, 
    -0.03548181f, -0.03381661f, -0.04787799f, 0.03387984f, 0.02665690f, 0.00458868f, -0.04159304f, -0.01371011f, 
    -0.06293719f, -0.05860143f, -0.04341243f, -0.01473611f, -0.03829123f, -0.03847180f, -0.00126063f, -0.01545863f, 
    0.03371993f, 0.02684169f, -0.02957916f, -0.00191938f, -0.02977432f, 0.00723555f, 0.03287981f, -0.03931691f, 
    0.01291909f, -0.02712497f, 0.02132428f, -0.01013867f, -0.02701991f, 0.01642244f, -0.02633336f, -0.04672386f, 
    -0.04849770f, -0.00179496f, 0.01012868f, -0.01796003f, 0.01303202f, 0.00179146f, 0.00055768f, -0.02300921f, 
    -0.01018643f, -0.03195326f, 0.04484829f, -0.00513426f, -0.00009345f, -0.02848292f, -0.01260059f, -0.05536334f, 
    0.01556023f, 0.02435575f, -0.06059089f, 0.01952207f, -0.01782337f, 0.01473837f, 0.01967352f, 0.01575206f, 
    -0.01586394f, 0.01507325f, 0.01810971f, -0.06476486f, 0.02576284f, 0.03113256f, 0.04323534f, -0.02730468f, 
    -0.01152025f, 0.02265286f, -0.03693828f, -0.00618669f, 0.01034667f, 0.01022023f, 0.00361534f, -0.03294536f, 
    -0.00868601f, -0.04397767f, 0.01332519f, 0.03817891f, 0.01344414f, -0.03805513f, 0.02548544f, -0.01093284f, 
    -0.03456351f, -0.03273962f, -0.03207288f, 0.01417038f, -0.05929303f, 0.00501308f, 0.02169823f, -0.05332209f, 
    0.02863227f, -0.01303471f, -0.01135915f, 0.03831730f, 0.01943603f, -0.05987317f, -0.04660350f, 0.01667548f, 
    -0.05424731f, 0.03888478f, 0.02961966f, 0.04606053f, -0.03828367f, 0.04511191f, 0.00958541f, -0.04016849f, 
    -0.00447993f, -0.04609676f, 0.04478060f, -0.01910748f, -0.00913125f, 0.02480846f, 0.01265476f, 0.01108971f, 
    0.01414379f, 0.01604947f, -0.01918836f, 0.00782662f, 0.03030506f, 0.00325093f, -0.03003861f, -0.01701840f, 
    0.00802726f, 0.00687388f, -0.00462745f, 0.02986529f, -0.01886656f, 0.01667165f, -0.00187556f, -0.02761129f, 
    0.04534281f, -0.00427241f, -0.04959877f, 0.00666684f, 0.03760827f, -0.06042758f, -0.01634529f, 0.03350869f, 
    -0.04369491f, -0.05632357f, -0.05716916f, 0.02919829f, 0.00293264f, 0.01176544f, 0.00083490f, -0.05550499f, 
    -0.00907809f, -0.01025687f, -0.00612688f, -0.06057125f, 0.03968074f, 0.03684917f, -0.04980730f, -0.05241831f, 
    -0.02319403f, 0.02626439f, -0.02966940f, -0.01316093f, 0.04475975f, 0.03991669f, 0.02676728f, -0.01592784f, 
    0.03867017f, -0.00608533f, -0.03788357f, -0.02826497f, -0.00153870f, -0.01561977f, -0.03264441f, -0.04729112f, 
    0.03434711f, -0.02976835f, -0.00579208f, -0.02697924f, -0.05166224f, 0.01277508f, -0.01015411f, 0.03644500f, 
    -0.01285115f, 0.00496794f, -0.00699972f, -0.01952630f, 0.00367963f, -0.03672724f, 0.01818636f, -0.05802094f, 
    -0.04509878f, -0.02943770f, 0.01005318f, 0.03809549f, -0.05214343f, 0.03649853f, -0.05022551f, 0.00196575f, 
    -0.04776574f, -0.02206688f, -0.04090239f, 0.01502562f, 0.03228205f, -0.02233110f, -0.03513994f, 0.00905277f, 
    0.01519380f, 0.04565689f, -0.02185220f, -0.05941016f, -0.02286188f, -0.04201556f, 0.03899078f, -0.00453112f, 
    -0.04457535f, -0.02697506f, -0.05703014f, 0.03027897f, 0.01389630f, -0.03905700f, -0.01563147f, 0.01496994f, 
    0.03889635f, 0.01816515f, 0.02473661f, -0.04980044f, 0.02844999f, -0.04310720f, -0.02617921f, -0.00526558f, 
    0.01512265f, 0.00362783f, 0.00728945f, -0.01335684f, -0.01973530f, -0.05228208f, 0.04812904f, -0.05875660f, 
    0.02951340f, -0.04629330f, 0.01705625f, 0.02083191f, -0.00481378f, -0.02390862f, 0.02545159f, -0.01777685f, 
    -0.03568824f, -0.05034909f, -0.03644602f, 0.01075517f, -0.05038514f, 0.00051551f, -0.00802142f, -0.00446905f, 
    0.04315279f, -0.04705552f, 0.04434881f, -0.03271501f, 0.02141690f, 0.02904975f, 0.01105534f, -0.00039034f, 
    -0.05091212f, 0.03313138f, -0.05802176f, -0.05514869f, 0.04123176f, 0.00224457f, -0.00044194f, -0.00695262f, 
    -0.03304785f, 0.53527188f, 0.12657470f, 0.13438858f, 0.03520292f, 0.24647695f, 0.09924741f, 0.02750281f, 
    -0.07087818f, -0.07973743f, -0.16483587f, -0.06400986f, -0.03048060f, -0.02034859f, -0.11022237f, 0.02423145f, 
    -0.06470813f, -0.10944062f, -0.00121261f, 0.03629548f, -0.27784473f, 0.30732918f, 0.33092725f, 0.36992142f, 
    0.13412954f, -0.12259004f, 0.08987252f, -0.08204059f, 0.23584779f, 0.27552879f, 0.05168293f, -0.01605958f, 
    -0.01511628f, 0.00220241f, -0.06420643f, 0.16007015f, -0.01844230f, -0.09808415f, -0.29047626f, -0.01298564f, 
    -0.02622658f, 0.32307008f, 0.17324664f, 0.09059404f, 0.20921765f, 0.27729329f, 0.11488724f, 0.30587193f, 
    0.28800026f, 0.27722692f, -0.03852053f, -0.19916813f, 0.01116809f, 0.00455469f, 0.00917512f, 0.09668160f, 
    0.00499764f, -0.08631555f, -0.02642063f, 0.18523812f, -0.08269392f, 0.89306837f, -0.04127148f, 0.12184688f, 
    0.12303971f, -0.09273687f, -0.03092689f, -0.07203504f, 0.06106910f, -0.28854355f, -0.17513596f, 0.05456463f, 
    -0.02576035f, 0.02785644f, -0.00260370f, -0.27594015f, -0.05685087f, 0.06543487f, 0.16212307f, -0.25734991f, 
    -0.20809695f, 0.26008749f, 0.24815610f, 0.16783069f, 0.14259246f, 0.07914707f, -0.15014286f, 0.04274714f, 
    -0.01463419f, -0.03573743f, 0.03120306f, 0.01676929f, -0.02512722f, -0.26315206f, -0.08312422f, -0.00183014f, 
    -0.01164041f, -0.05032274f, 0.00266346f, -0.09760682f, -0.17418189f, -0.33128783f, -0.25005457f, -0.15779424f, 
    -0.02012856f, 0.03371653f, -0.03789739f, -0.05212130f, -0.06522899f, 0.00881044f, 0.09398299f, 0.16606465f, 
    0.15347759f, 0.07793397f, 0.04761999f, 0.05646234f, 0.14371152f, 0.09189445f, 0.10768482f, 0.03573776f, 
    0.05601246f, 0.04685452f, -0.09086431f, -0.19505695f, -0.17559651f, 0.04939948f, -0.01749906f, 0.02708952f, 
    -0.06284168f, 0.01496045f, -0.05056661f, 0.08169972f, -0.14116150f, -0.01820939f, 0.21945040f, -0.15791081f, 
    -0.09749508f, -0.19862843f, 0.08108604f, -0.09855539f, -0.02649105f, 0.57040501f, 0.09717034f, 0.24571034f, 
    0.38956082f, -0.03444278f, -0.04324090f, -0.03980010f, -0.10301626f, 0.05133387f, 0.01456016f, -0.03445656f, 
    -0.06399153f, -0.08987602f, 0.10864251f, 0.12992425f, -0.09218509f, 0.13640979f, -0.02236203f, 0.05858119f, 
    -0.23725165f, -0.31991613f, -0.08781280f, -0.04232325f, -0.05227199f, -0.06356411f, -0.11353873f, -0.21747389f, 
    -0.04438048f, 0.11637540f, 0.02049963f, 0.08480596f, 0.11508385f, 0.01898923f, 0.06329293f, -0.02722142f, 
    0.10051854f, 0.14365670f, 0.06279483f, 0.01186867f, 0.32931587f, 0.34298524f, 0.18062182f, 0.15080488f, 
    0.18852323f, 0.04403573f, 0.09491575f, 0.00901215f, -0.07439613f, -0.07312264f, -0.05150213f, -0.18203716f, 
    -0.03365858f, -0.08207939f, -0.16262265f, -0.00864018f, 0.02512885f, 0.07350025f, 0.02975657f, 0.09885460f, 
    -0.22275111f, -0.49555218f, 0.04168793f, -0.16467547f, -0.13317497f, 0.07835919f, -0.10846543f, -0.07822579f, 
    -0.01528415f, 0.05712891f, -0.10492917f, -0.00555844f, 0.04326977f, -0.09591648f, 0.01737559f, 0.07557291f, 
    -0.05480127f, 0.01023700f, 0.04091013f, -0.03474396f, -0.11773290f, -0.00636034f, -0.08318739f, 0.24059458f, 
    -0.09308641f, 0.11549009f, 0.07575776f, -0.13721386f, -0.17936480f, 0.04695652f, 0.01732557f, -0.00245263f, 
    -0.06964654f, 0.03461655f, -0.06601558f, -0.07970401f, 0.01795407f, 0.11762816f, -0.06645904f, 0.12420533f, 
    -0.07780003f, 0.24144560f, 0.35654363f, 0.38761654f, 0.41445068f, 0.02404326f, -0.04400851f, 0.07627640f, 
    0.17073426f, 0.12467202f, 0.02727549f, 0.04210403f, 0.13089177f, -0.01542807f, 0.05948164f, 0.02894032f, 
    0.06026568f, -0.04893580f, -0.23588485f, 0.05195899f, -0.13333841f, -0.13515021f, 0.17468989f, 0.38733941f, 
    -0.17155877f, 0.06644558f, 0.06483122f, -0.09637855f, -0.06321377f, -0.06722750f, -0.05957437f, 0.06287903f, 
    -0.01052426f, -0.01396261f, 0.00812615f, -0.01151969f, -0.23106651f, 0.07659978f, 0.13823836f, -0.02193417f, 
    -0.21747392f, -0.14542066f, -0.04417868f, -0.03176618f, -0.25066441f, -0.06837517f, -0.08793555f, -0.08370452f, 
    -0.03649962f, -0.09823670f, -0.15685363f, -0.02188304f, 0.02413883f, 0.03766625f, 0.05094650f, 0.09682035f, 
    -0.05896141f, 0.06829610f, 0.16540039f, -0.02111339f, 0.03372533f, 0.38167921f, 0.23250285f, 0.09377697f, 
    0.18380459f, 0.06968596f, 0.17583232f, 0.17023441f, 0.01891798f, -0.09658351f, -0.05707081f, -0.00018256f, 
    -0.04361469f, -0.12636256f, -0.11736739f, 0.01961847f, 0.00968295f, -0.12020015f, -0.03654030f, 0.07861757f, 
    -0.24775004f, -0.32174170f, 0.27772883f, 0.20696057f, -0.11874110f, -0.21294203f, -0.19322738f, 0.07328492f, 
    -0.03583490f, 0.14053369f, 0.02912376f, 0.04794827f, 0.02253424f, -0.15337601f, -0.00207514f, 0.00096958f, 
    -0.15793994f, 0.02719198f, -0.10266335f, -0.09828857f, 0.36459970f, -0.09924486f, 0.28746229f, 0.40549758f, 
    -0.12347102f, -0.04226515f, 0.11646799f, -0.12343507f, 0.14231062f, 0.12102348f, 0.05083339f, 0.02276519f, 
    0.10288157f, 0.14748162f, 0.07632859f, 0.02059247f, 0.11096071f, 0.02510292f, -0.12129344f, 0.13773093f, 
    0.04750335f, -0.31764317f, -0.11856306f, 0.12653589f, -0.09646823f, 0.12686430f, 0.01286707f, 0.01993556f, 
    0.01165400f, 0.13989228f, -0.04698914f, 0.06967153f, 0.00219658f, -0.03822439f, -0.08960516f, -0.06748722f, 
    0.19883944f, -0.07782302f, -0.09708898f, 0.01465228f, 0.33368164f, 0.30474004f, 0.05286979f, 0.25843939f, 
    -0.12173627f, 0.16416475f, 0.31400430f, -0.34036288f, 0.33865309f, -0.00215166f, -0.03673297f, -0.00309630f, 
    0.01742597f, 0.01563330f, 0.12807472f, 0.06599239f, -0.14575346f, -0.16323423f, 0.18770961f, -0.07494183f, 
    -0.27765581f, -0.06148371f, 0.31428567f, 0.26701012f, -0.11243288f, 0.02152080f, 0.05084464f, 0.00676170f, 
    -0.16937152f, -0.05308341f, -0.01451135f, -0.00742001f, 0.03937232f, 0.00537653f, -0.00367686f, 0.05039762f, 
    0.09666715f, -0.11059645f, -0.15846838f, -0.00753678f, -0.09835707f, -0.12465287f, -0.02133877f, 0.02997718f, 
    -0.19938156f, -0.20162639f, -0.11781460f, -0.04804602f, -0.03321278f, 0.01473824f, -0.06074861f, 0.00404167f, 
    0.18487501f, 0.11282188f, 0.24800509f, -0.03914152f, -0.09051742f, -0.00868009f, 0.25989267f, 0.08216311f, 
    -0.18415487f, 0.02043455f, -0.14937966f, -0.03438633f, -0.06168192f, 0.11874398f, -0.04185971f, 0.02548044f, 
    -0.05129001f, -0.10337855f, 0.07290640f, 0.16131416f, -0.11044990f, -0.05960862f, 0.08804451f, 0.11309969f, 
    -0.08354771f, -0.03392064f, 0.35077223f, -0.08084596f, -0.38013032f, 0.12365393f, 0.16404872f, 0.22167562f, 
    -0.18468966f, -0.03210111f, -0.04429600f, 0.01607732f, -0.08245539f, -0.07901913f, -0.12769809f, -0.00619671f, 
    -0.11653762f, -0.00680216f, -0.09032175f, -0.00954266f, 0.09380517f, -0.24435557f, 0.06613849f, -0.01646284f, 
    0.14261323f, -0.07583938f, 0.29292515f, 0.23656569f, 0.12469019f, 0.05479787f, 0.24713929f, -0.13879238f, 
    -0.15878877f, -0.03329691f, -0.21451157f, 0.08320310f, 0.03587087f, 0.01440796f, 0.06218134f, 0.00404707f, 
    -0.00801929f, 0.22349681f, -0.08348819f, 0.14983968f, 0.07179496f, -0.11304247f, 0.23492242f, 0.34016025f, 
    -0.25673246f, 0.07053766f, -0.00665678f, -0.00106199f, 0.14440015f, 0.10678857f, 0.15928875f, 0.06523389f, 
    0.04272386f, -0.05932586f, 0.07660865f, 0.01929949f, 0.05902598f, -0.07421307f, 0.06567784f, -0.00736037f, 
    0.13717587f, -0.46220410f, -0.07166380f, -0.20631522f, 0.01757292f, -0.19287449f, -0.15257926f, -0.02875725f, 
    -0.22869179f, -0.10155714f, -0.04933516f, 0.00709373f, -0.04021033f, 0.05159865f, 0.11405405f, 0.00328520f, 
    -0.07684720f, 0.19408131f, -0.11671919f, 0.07649679f, -0.27987438f, -0.59936118f, 0.19210540f, -0.22594900f, 
    -0.07516607f, -0.40552565f, -0.11874500f, -0.05725982f, 0.19767277f, 0.12952338f, 0.07512131f, -0.09898216f, 
    0.05682035f, -0.03726392f, -0.06017742f, -0.10557061f, 0.02195649f, 0.07791657f, -0.02086308f, -0.07061116f, 
    -0.19149446f, -0.13183805f, 0.29545873f, 0.20955549f, -0.14062896f, -0.19922799f, -0.14411323f, -0.05986821f, 
    -0.23303124f, -0.24790834f, -0.08668169f, -0.07755300f, -0.04780795f, 0.04024323f, 0.09746036f, -0.03023238f, 
    0.07267165f, -0.23744428f, -0.18002038f, 0.05286402f, 0.46264082f, -0.22456504f, 0.13609442f, 0.11048459f, 
    0.12194226f, 0.22230792f, 0.35593164f, -0.18434437f, 0.28151864f, 0.17824970f, -0.16319667f, 0.03598561f, 
    0.11411592f, -0.02186716f, 0.06632172f, 0.04310977f, 0.11361986f, 0.17025477f, 0.07780243f, 0.12116399f, 
    0.24326701f, 0.08000732f, -0.03713740f, 0.25838965f, -0.01313631f, -0.01164453f, -0.13033815f, 0.06531692f, 
    0.04471576f, -0.04114332f, -0.00170888f, -0.01680244f, 0.06590819f, 0.12320357f, 0.11732918f, 0.20540173f, 
    0.02271092f, 0.19064628f, 0.09755871f, 0.10413386f, -0.12232983f, -0.06949361f, 0.23686987f, 0.23953806f, 
    -0.11947913f, -0.01969662f, -0.13446102f, 0.04807226f, 0.09532186f, 0.13337882f, 0.09032501f, -0.09190167f, 
    0.04859608f, -0.10304723f, -0.11381749f, 0.05501010f, 0.04012283f, -0.00770279f, -0.04498389f, -0.00103747f, 
    -0.16523513f, 0.27663282f, 0.35972211f, -0.03069235f, 0.46034417f, 0.15257005f, 0.03258023f, 0.23039137f, 
    0.03901207f, 0.16853157f, -0.15356384f, 0.16474102f, -0.00647227f, 0.03135028f, 0.00666253f, -0.16796935f, 
    0.05036492f, 0.03916672f, -0.02930596f, -0.04295123f, -0.05436037f, 0.12834549f, -0.20294207f, -0.36349803f, 
    -0.01083905f, -0.13980284f, 0.06256837f, 0.06532040f, -0.12419738f, -0.09605125f, -0.17492762f, -0.10859681f, 
    -0.12562123f, -0.03061456f, -0.10961591f, 0.01608612f, -0.12835893f, 0.11747102f, 0.13308246f, 0.00244385f, 
    -0.15696897f, 0.07012679f, -0.43577620f, -0.23662424f, -0.04500265f, 0.09058081f, 0.03299419f, -0.09924201f, 
    -0.04902430f, -0.12149712f, 0.18668643f, 0.00011452f, -0.05191666f, -0.06107296f, -0.05414963f, -0.03972841f, 
    -0.34705994f, 0.00861875f, 0.05596798f, 0.10984171f, -0.48464242f, 0.31564525f, -0.44871441f, 0.57770890f, 
    -0.50771332f, -0.20257273f, -0.05069812f, 0.04539065f, -0.18300247f, 0.08565443f, 0.05194231f, 0.02743568f, 
    -0.10684503f, 0.03083079f, -0.09490537f, 0.16607046f, 0.22539163f, 0.20008512f, 0.11983800f, 0.24993885f, 
    0.17848612f, 0.05323623f, -0.00546468f, -0.08848587f, 0.14062490f, 0.01205311f, -0.01375618f, 0.08110602f, 
    -0.05663799f, 0.04057678f, 0.00681182f, -0.04148351f, -0.06467200f, -0.01258508f, -0.00088763f, 0.18456838f, 
    0.11110262f, 0.22325435f, 0.00097080f, 0.03595717f, -0.03916071f, -0.16667408f, -0.09058589f, -0.15772104f, 
    0.17885780f, 0.00841257f, -0.29792204f, 0.04453575f, 0.00910670f, 0.07259626f, -0.06383683f, -0.09746423f, 
    -0.03735037f, -0.16369486f, -0.14249860f, -0.02348341f, -0.11984172f, -0.27483714f, -0.33062467f, -0.59239870f, 
    -0.09576187f, 0.59561574f, -0.15266919f, 0.24127714f, -0.16056095f, 0.09691572f, -0.22512794f, 0.22099717f, 
    -0.04034113f, 0.18461911f, -0.16704319f, 0.02261417f, 0.06473509f, 0.01916733f, 0.16786872f, -0.04313358f, 
    0.02794131f, 0.13914759f, 0.05848540f, 0.06331947f, 0.13511206f, 0.03404051f, 0.04241120f, -0.18777792f, 
    0.25993377f, 0.13502574f, 0.05363884f, -0.00242680f, -0.10177752f, 0.00324494f, -0.03452117f, -0.00753255f, 
    0.06005104f, 0.01860815f, 0.07273183f, 0.19833814f, 0.10271267f, 0.28898868f, 0.02707436f, 0.13116315f, 
    0.16806132f, -0.55402493f, 0.66246146f, -0.32240438f, 0.36506960f, -0.10125519f, 0.01226736f, -0.04113527f, 
    0.13318686f, -0.09451896f, -0.01724703f, 0.02753770f, 0.00341483f, 0.09207680f, 0.07710277f, -0.10273997f, 
    -0.13292961f, -0.05709575f, -0.04539036f, -0.03097926f, 0.09188540f, 0.53275532f, -0.11818164f, 0.04917254f, 
    0.38135421f, 0.05509703f, 0.13204359f, 0.05724460f, -0.01355939f, 0.07378194f, 0.05560928f, 0.08126320f, 
    0.09991241f, 0.01330931f, 0.03760128f, 0.09513266f, 0.06176963f, 0.03379709f, 0.08655669f, 0.02530268f, 
    0.19109119f, -0.07334042f, 0.22991221f, -0.38189918f, 0.22566204f, 0.01903038f, 0.06360760f, 0.06134277f, 
    0.12929070f, 0.26547396f, 0.02375450f, 0.07153159f, 0.13944155f, 0.02808152f, -0.01498477f, -0.11634982f, 
    0.02467440f, -0.13889436f, 0.15601151f, -0.09935840f, -0.35908610f, 0.52931768f, 0.04801911f, 0.08370746f, 
    0.54508680f, -0.13174056f, -0.03590985f, 0.04362644f, -0.01579813f, 0.20861067f, 0.00283936f, -0.03127296f, 
    0.02132360f, -0.05149444f, 0.04086541f, -0.04804053f, -0.03218608f, -0.09143643f, 0.05811957f, -0.26399043f, 
    0.28374508f, 0.06069209f, -0.43820164f, -0.28679436f, 0.11218640f, 0.21101069f, 0.19755360f, 0.10053880f, 
    -0.09997904f, -0.07441834f, -0.10206368f, -0.16900346f, -0.13508081f, -0.12323815f, -0.09257830f, 0.05287584f, 
    -0.19801663f, -0.01199861f, 0.04161304f, 0.05168005f, 0.40704709f, 0.09675252f, 0.23841089f, -0.28165990f, 
    0.25260374f, -0.18546802f, 0.10929713f, 0.15626767f, 0.28270888f, 0.06764209f, 0.10107800f, -0.02327474f, 
    0.03396865f, 0.17933701f, 0.12524140f, 0.02664294f, 0.14611737f, -0.13387206f, -0.03471506f, -0.07056238f, 
    -0.31460699f, 0.19695514f, -0.13761434f, 0.02674307f, -0.01555171f, 0.06389470f, -0.01900353f, -0.10574876f, 
    0.02628182f, 0.27955014f, 0.09820519f, 0.09910990f, 0.22669064f, 0.05274631f, 0.23528790f, -0.14388761f, 
    0.02361288f, -0.00309828f, 0.05992625f, -0.00592605f, -0.01652672f, 0.18073495f, 0.09576034f, 0.04826052f, 
    0.28980684f, 0.05959001f, -0.01389416f, 0.22390936f, -0.13647112f, -0.03698217f, -0.07184089f, 0.01340170f, 
    0.01216835f, 0.05692955f, 0.09580605f, 0.07185496f, 0.02143272f, 0.04681668f, 0.01786676f, -0.04009529f, 
    -0.00510796f, -0.17949080f, -0.42178878f, -0.12701847f, 0.30316830f, 0.14786489f, 0.22563945f, 0.19789626f, 
    -0.01244190f, 0.03260844f, 0.18419923f, 0.06269811f, -0.16371849f, 0.16923708f, 0.06071055f, -0.08318708f, 
    -0.01373712f, 0.13614291f, 0.09170936f, -0.03131872f, 0.54139727f, 0.05149734f, 0.16001834f, -0.03087055f, 
    -0.04595836f, 0.15735824f, 0.08404391f, 0.09148233f, -0.13493714f, 0.02177043f, -0.00604721f, -0.00552817f, 
    -0.01208019f, -0.02032385f, -0.14740124f, -0.10626753f, -0.03482043f, 0.01629448f, -0.07803031f, 0.10037576f, 
    0.62387323f, 0.11305723f, -0.08091515f, -0.11356787f, -0.06536668f, -0.05467971f, 0.07377636f, -0.07457319f, 
    0.05300792f, -0.05716244f, 0.11108085f, 0.09432060f, -0.05174835f, -0.05756707f, 0.00478182f, -0.05889742f, 
    0.07145643f, 0.02302381f, 0.01715597f, 0.00975975f, 0.39441356f, -0.38708657f, 0.18937892f, 0.07459754f, 
    -0.17999040f, -0.09101874f, -0.11505232f, 0.18935402f, -0.34445196f, 0.25283822f, 0.09394076f, -0.02826499f, 
    -0.02262544f, -0.07943486f, -0.03329951f, -0.00980082f, -0.00547914f, 0.10594514f, 0.04748174f, -0.00079024f, 
    0.20211689f, 0.04641605f, 0.18586379f, -0.25806218f, 0.03989764f, 0.00089040f, -0.05728522f, 0.00254793f, 
    0.04259603f, 0.03009140f, 0.06584169f, -0.02598926f, -0.06537271f, 0.05279545f, 0.06743914f, 0.09021854f, 
    -0.13946262f, 0.08636485f, -0.20476663f, -0.13973211f, -0.05330815f, -0.09716629f, -0.09006251f, 0.12651849f, 
    0.08757978f, -0.04656423f, 0.04164582f, -0.01178128f, -0.04966632f, 0.03038062f, -0.08036387f, -0.08697376f, 
    -0.10665844f, 0.03504298f, 0.06077486f, 0.02784973f, -0.05358498f, -0.02209481f, -0.02229198f, 0.09970564f, 
    0.07574777f, 0.26194102f, -0.20337193f, -0.24027747f, 0.00935247f, -0.08320873f, -0.12098058f, -0.00244230f, 
    -0.02575575f, 0.07952788f, 0.08498303f, -0.10147499f, 0.04638325f, 0.04793599f, 0.07338799f, -0.08018710f, 
    -0.14296183f, -0.04786776f, 0.17774257f, 0.05078528f, 0.25926867f, -0.08594280f, 0.00447201f, -0.39590672f, 
    0.04033447f, 0.09162572f, 0.13754426f, 0.15753633f, 0.06724253f, -0.04026719f, 0.02334229f, 0.02057983f, 
    -0.02238907f, 0.14980468f, 0.10024679f, -0.21838234f, -0.01019587f, -0.01578800f, -0.03581391f, -0.07932470f, 
    -0.08096061f, 0.06954396f, -0.11846939f, 0.19886217f, -0.07558157f, -0.07099114f, -0.06709624f, -0.09766245f, 
    0.01505256f, 0.06494516f, 0.03725864f, 0.13824396f, -0.09750461f, 0.07242057f, 0.03423150f, 0.06680949f, 
    -0.09252637f, 0.12764259f, -0.03088481f, 0.07442471f, -0.04466859f, -0.26183081f, -0.07967535f, -0.07721478f, 
    0.20649979f, 0.10458931f, 0.09497054f, 0.15773085f, -0.05856622f, 0.00773439f, 0.03917719f, 0.04882656f, 
    0.03966254f, -0.03700234f, -0.04186429f, 0.06718088f, -0.01716349f, -0.06464279f, 0.06612534f, 0.03623101f, 
    -0.04683870f, 0.01092608f, -0.09762025f, 0.00127751f, -0.03620186f, 0.00199728f, -0.02780526f, -0.00244841f, 
    0.06694593f, -0.01510227f, 0.09777006f, 0.05032340f, 0.06021740f, 0.04585405f, 0.02250755f, -0.07999893f, 
    0.07329659f, 0.02591383f, 0.00221610f, 0.16540858f, 0.16182360f, -0.03474924f, -0.37620828f, -0.19890426f, 
    0.33755371f, 0.15166201f, 0.15161414f, 0.18336047f, 0.09811361f, 0.02227518f, -0.00720272f, 0.12318049f, 
    0.06632034f, 0.01446296f, 0.07142884f, 0.07158688f, 0.08383315f, 0.03847587f, 0.10295771f, -0.04958022f, 
    0.41011858f, 0.06481829f, 0.02892121f, -0.37129092f, -0.16148515f, 0.29191464f, 0.22676407f, 0.30130637f, 
    -0.02045805f, -0.24232259f, 0.08124954f, -0.07078697f, -0.20226565f, 0.00524114f, -0.00745941f, 0.00450676f, 
    0.05912165f, 0.04882505f, -0.02986629f, 0.10725322f, 0.24345610f, 0.29975188f, -0.08626714f, 0.27872768f, 
    -0.27173543f, -0.00707316f, 0.08898821f, -0.16364790f, 0.02511160f, 0.10885039f, -0.08234870f, 0.08485406f, 
    -0.02167265f, -0.04714235f, -0.02952645f, 0.02572369f, -0.00100283f, -0.03494691f, -0.14725526f, -0.04287509f, 
    -0.05591245f, -0.03211129f, 0.03669283f, -0.19854628f, 0.12788731f, 0.08769250f, 0.01925476f, -0.13607799f, 
    0.05384944f, 0.00137740f, 0.01464418f, -0.00071986f, 0.08799350f, 0.02406111f, 0.03885969f, -0.17079398f, 
    -0.09391670f, 0.06557684f, 0.06715125f, 0.02049063f, 0.01132146f, -0.19397192f, -0.33210725f, -0.21820039f, 
    0.23407155f, 0.11573984f, 0.17965406f, 0.12368090f, -0.19562081f, 0.15336533f, 0.11241332f, -0.04706809f, 
    -0.13732256f, 0.03874192f, -0.04792757f, -0.02124411f, -0.00675924f, 0.00653313f, -0.05544977f, -0.03518323f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02071606f, 0.02955657f, -0.02641340f, 0.00373226f, 0.03126462f, 0.06599813f, 0.17595747f, 0.19196273f, 
    -0.02111331f, 0.17931034f, 0.16674772f, 0.15881512f, 0.07366056f, -0.02924045f, -0.03459632f, -0.03872909f, 
    -0.01883833f, -0.03040574f, 0.14149213f, 0.00410123f, 0.23175956f, -0.05232356f, 0.02622453f, 0.07826367f, 
    -0.00971065f, 0.02842272f, 0.05106579f, -0.05514404f, 0.04535966f, 0.15637790f, 0.02289765f, -0.06958563f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.15145625f, 0.11031553f, 0.14601536f, -0.41566652f, -0.13026650f, -0.58235139f, -0.45378461f, 0.10477191f, 
    0.05713049f, -0.74881518f, -0.47117811f, -0.12344421f, -0.18728785f, 0.32648596f, 0.01073135f, 0.04747463f, 
    -0.57573551f, 0.01861365f, 0.15673710f, 0.16656072f, -0.37036392f, 0.23777702f, -0.03844193f, 0.03965631f, 
    0.24630809f, -0.04662238f, -0.12528077f, -0.02390501f, 0.02486442f, -0.58585328f, 0.31264034f, 0.28180701f, 
    -0.06115763f, 0.05274158f, -0.06363792f, -0.56246442f, -0.14551012f, 0.15473507f, 0.65456110f, 0.19644330f, 
    -0.02948904f, 0.10093600f, -0.03824218f, 0.16568671f, 0.20564826f, 0.42815378f, -0.15404686f, -0.14699033f, 
    -0.22574292f, -0.01950732f, 0.32022646f, 0.19035840f, 0.11262278f, 0.30050710f, -0.80905604f, 0.13026674f, 
    -0.13362224f, 0.23269191f, 0.05980935f, -0.05611679f, 0.16090545f, -0.00360654f, -0.19905388f, -0.08260652f, 
    0.09194529f, 0.11823167f, -0.04385348f, -0.14404206f, 0.01875069f, 0.44054383f, -0.99892628f, -0.24783665f, 
    0.09295714f, 0.40110663f, -0.04527568f, 0.05616753f, 0.13336769f, -0.16377957f, 0.00612651f, 0.16019236f, 
    -0.49994004f, 0.12161547f, 0.21271561f, -0.42569405f, 0.14963156f, -0.76933587f, -0.00194968f, 0.22005272f, 
    0.20511036f, 0.10146579f, -0.46630308f, 0.06725448f, -0.26909557f, 0.51374501f, 0.30206281f, 0.04635657f, 
    0.00764610f, -0.09294237f, -0.07249721f, 0.39140078f, 0.05077583f, 0.32768667f, -0.24067363f, -0.66544867f, 
    -0.03810961f, 0.30782795f, 0.19542141f, -0.71935987f, 0.28914189f, 0.14028443f, -0.13200535f, 0.13271077f, 
    -0.23077381f, -0.13914587f, -0.14994320f, -0.13027291f, -0.52182811f, -0.17815989f, -0.02929935f, -0.58579355f, 
    0.14629731f, -0.13046198f, 0.22982918f, -0.10503275f, 0.26620567f, -0.32574883f, 0.35550895f, 0.00708277f, 
    0.21233234f, -0.17306845f, -0.13697651f, -0.08697961f, 0.01109559f, 0.04921748f, -0.19327417f, -0.47248578f, 
    -0.12728256f, -0.27981067f, -0.56176621f, 0.28143191f, -0.23615982f, -0.09440387f, -0.09666305f, -0.10789654f, 
    0.24486540f, 0.07093301f, -0.80447459f, 0.06997060f, 0.08267657f, 0.16510113f, 0.30799031f, 0.04144166f, 
    0.12530431f, -0.11742268f, 0.19372685f, 0.14368746f, 0.16944693f, 0.17980850f, -0.16689062f, -0.13264348f, 
    0.15760525f, -0.16087466f, -0.06717522f, -0.19597422f, -0.16471229f, -0.22074667f, -0.19939572f, 0.35514149f, 
    0.02805908f, -0.18498553f, 0.10272191f, 0.03581964f, -0.34538910f, -0.32749665f, -0.16536126f, 0.12575600f, 
    0.47921252f, -0.00021162f, 0.24781996f, 0.08868738f, 0.18914987f, 0.15663297f, -0.15823385f, -0.50664562f, 
    0.13071725f, -0.21697453f, -0.46997106f, -0.10596602f, 0.17969419f, 0.29400599f, -0.37036598f, 0.17088804f, 
    -0.55027092f, -0.13494016f, -0.16393791f, 0.28274360f, -0.08472916f, 0.22002235f, -0.14936507f, 0.11487229f, 
    -0.14235187f, 0.09611515f, 0.15257952f, 0.32562223f, -0.37339783f, -0.74778366f, 0.02986324f, 0.02925092f, 
    0.25663221f, 0.17548515f, -0.50334835f, -0.86688793f, 0.31781811f, -0.40735415f, -0.04860789f, 0.17696781f, 
    -0.17736235f, -0.00893145f, -0.10437292f, -0.11890629f, -0.44687989f, -0.38332978f, 0.52566606f, -0.11643919f, 
    -0.48650545f, 0.08578170f, 0.12667288f, 0.21932057f, -0.18170893f, -0.07669098f, 0.09043183f, -0.05251079f, 
    0.01915696f, -0.53392214f, 0.17052726f, 0.00596885f, 0.44114077f, -0.35103884f, 0.11568756f, -0.00246124f, 
    0.11879861f, -0.06046599f, -0.38529712f, 0.40880334f, -0.20590410f, -0.08423958f, 0.33219403f, 0.22403242f, 
    -0.20081621f, 0.15721779f, -0.48059034f, 0.03711802f, -0.61928260f, -0.39076921f, -0.75460285f, 0.03307539f, 
    0.06162738f, -0.15294109f, 0.12807591f, 0.30783543f, -0.04324676f, 0.55614114f, -0.17731056f, 0.28302860f, 
    0.07635916f, -0.22695585f, -0.26801345f, -0.47365314f, 0.47078067f, -0.84882563f, -0.13575515f, -0.05583565f, 
    0.09488751f, 0.11690480f, 0.28949687f, 0.25829339f, 0.06874564f, -0.15153718f, -0.33114547f, -0.06474300f, 
    -0.91891378f, -0.27820060f, -0.39586201f, -0.11888698f, -0.47936645f, 0.22934344f, 0.03584024f, 0.25135449f, 
    0.03472230f, -0.06020144f, -0.05624461f, -0.13534757f, -0.00312091f, -0.50865549f, -0.19616699f, 0.19116624f, 
    -0.15773082f, -0.21597458f, 0.31694797f, 0.24612197f, -0.21780957f, 0.26016596f, -0.00882385f, -0.14990826f, 
    -0.29131597f, 0.00351397f, -0.24306262f, -0.16626561f, 0.53444004f, -0.45963684f, 0.40197960f, 0.41041484f, 
    0.07601725f, -0.27823636f, -0.39118785f, 0.03122614f, -0.15625952f, -0.35695055f, -0.59023821f, -0.48863491f, 
    0.14408983f, 0.05820555f, 0.06177340f, 0.13201903f, 0.16196711f, 0.25858730f, -0.37177387f, 0.14444038f, 
    0.05447918f, -0.30172548f, 0.28644660f, -0.41810668f, -0.38915905f, -0.92878634f, -0.06037139f, 0.01761764f, 
    -0.17418523f, 0.14581899f, 0.00961736f, -0.00138252f, -0.03321385f, 0.01991484f, -0.50586516f, -0.06887191f, 
    -0.04947417f, 0.53224260f, 0.58351153f, 0.07224393f, 0.29170936f, 0.27338165f, -0.07962699f, -0.69183218f, 
    0.18952519f, 0.07878082f, -0.12851144f, 0.27279219f, -0.15328011f, -0.52521676f, -0.30649075f, 0.16379009f, 
    0.06455907f, 0.46326834f, 0.02390009f, 0.19495600f, 0.12797125f, 0.36891446f, -0.03771786f, -0.14130034f, 
    0.13793856f, 0.08458398f, 0.12913188f, -0.02466166f, -0.55161905f, -0.57967180f, -0.17409471f, 0.29788071f, 
    -0.74032092f, -0.60876119f, 0.71495467f, -0.05467397f, -0.33881539f, 0.40316775f, 0.07127278f, -0.32766145f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.15476929f, 0.07713813f, 0.06176321f, -0.05678406f, 0.03473889f, -0.14997473f, -0.23185155f, -0.05580365f, 
    0.11404802f, 0.05396624f, -0.05813048f, -0.08761464f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
