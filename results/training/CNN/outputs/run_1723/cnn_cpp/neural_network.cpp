#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.28883737f, -0.50343978f, -0.11890905f, 0.50189120f, 0.35063851f, 0.63094896f, -0.18979871f, -0.35893056f, 
    -0.57889271f, -0.24346401f, -0.02614917f, 0.00918878f, -0.18816178f, -0.22679313f, -0.49278083f, -0.32944131f, 
    0.28684250f, 0.10894577f, 0.07361909f, 0.20092779f, 0.11696996f, 0.00402571f, -0.32310003f, -0.28252342f, 
    -0.08683653f, -0.17281812f, 0.05547186f, 0.31023720f, 0.02839925f, -0.08851667f, -0.09423893f, 0.07060957f, 
    -0.38628098f, 0.14073901f, 0.31061313f, -0.21832271f, 0.54224056f, 0.19933850f, -0.46404609f, -0.04180731f, 
    -0.28495571f, -0.03886420f, -0.22371718f, 0.04217175f, 0.24514554f, 0.05847862f, 0.21689196f, 0.09680707f, 
    -0.28255701f, 0.25235644f, -0.04771923f, 0.14378411f, -0.18372878f, -0.19180441f, -0.38327965f, -0.45748562f, 
    -0.39239177f, -0.33667693f, -0.21674787f, -0.12772022f, 0.48432520f, 0.20265684f, 0.28550696f, -0.02219890f, 
    -0.21424642f, 0.04792347f, -0.38531968f, -0.03993029f, -0.47466758f, -0.35482010f, -0.11901194f, 0.17754379f, 
    -0.06551451f, 0.06492152f, 0.06885321f, 0.68201244f, 0.63461059f, -0.41234702f, -0.15577094f, 0.14510244f, 
    -0.24386325f, -0.52703208f, 0.08528302f, 0.12879066f, 0.20547105f, -0.01993624f, 0.01328365f, 0.02101426f, 
    -0.30995879f, 0.17740601f, -0.07528768f, 0.12396289f, -0.13495041f, 0.19305755f, -0.16532426f, 0.21912540f, 
    0.08319830f, 0.19951542f, 0.04450576f, -0.24508171f, -0.19468494f, 0.29744878f, 0.10831192f, -0.18126588f, 
    -0.16182047f, 0.20214774f, 0.18160163f, -0.13176487f, -0.40830967f, -0.05171013f, 0.15736760f, -0.07008759f, 
    0.31761980f, -0.03575691f, -0.03051952f, -0.06571605f, -0.22577932f, 0.17379606f, 0.20241320f, 0.06690806f, 
    0.11960356f, 0.26291990f, 0.03818619f, -0.04242125f, -0.08437694f, -0.38544002f, -0.31716257f, -0.46508607f, 
    0.26636225f, 0.41388160f, -0.29218170f, -0.47463337f, -0.10484064f, -0.19966085f, -0.65651107f, 0.51908338f, 
    0.46609095f, 0.00331782f, -0.10453293f, 0.27155620f, -0.45902175f, 0.23892172f, 0.10731903f, -0.24611990f, 
    -0.03846019f, -0.32168245f, 0.07217716f, 0.20917523f, -0.27531046f, -0.01320299f, -0.05487328f, -0.48952317f, 
    -0.58805734f, -0.24427268f, -0.17561741f, 0.24914108f, -0.11820029f, -0.00710342f, -0.13519704f, -0.06050876f, 
    -0.41678801f, -0.38575530f, -0.40442157f, 0.48416498f, 0.50154006f, 0.10835484f, -0.19087391f, -0.14532781f, 
    -0.14854352f, -0.58876735f, 0.13414726f, -0.21862271f, 0.08268712f, 0.25898397f, -0.28772035f, 0.45711836f, 
    -0.33130854f, -0.19906773f, -0.58956170f, -0.12841828f, 0.31798318f, -0.35455999f, 0.02508634f, 0.10496048f, 
    -0.23920646f, -0.05725875f, -0.23341578f, -0.13138337f, 0.01926240f, 0.02527735f, -0.25539193f, -0.18974301f, 
    0.01475287f, 0.14921734f, -0.01981625f, -0.26592267f, 0.25196463f, -0.02846515f, -0.12901801f, 0.26920959f, 
    -0.42451552f, -0.54529417f, -0.64490116f, -0.01666796f, 0.03740142f, 0.38058934f, -0.15709309f, 0.20907268f, 
    0.33861172f, 0.47592893f, 0.35737795f, 0.13162808f, -0.24947058f, -0.04542710f, 0.26168194f, -0.05849674f, 
    0.04750867f, 0.11301615f, -0.04207921f, -0.25543755f, 0.09292309f, -0.19195402f, -0.06147034f, -0.18967780f, 
    0.29908806f, 0.39386839f, -0.27351111f, -0.51660925f, -0.48905307f, -0.59907728f, 0.47800136f, 0.08992693f, 
    0.35783589f, -0.07077397f, 0.26681289f, 0.07216941f, -0.07997773f, -0.02906801f, 0.23555993f, -0.10042323f, 
    0.13309009f, 0.11853858f, 0.21858494f, -0.13758434f, 0.13329281f, -0.18240522f, -0.13250500f, 0.04863592f, 
    -0.02354731f, 0.15681925f, -0.53657937f, -0.24302539f, -0.22727217f, 0.07465942f, -0.36775258f, -0.06948338f, 
    0.65842736f, -0.32890987f, -0.10291164f, -0.04870563f, -0.28526267f, -0.32867354f, -0.13152528f, -0.03324471f, 
    0.03858462f, -0.07377698f, -0.04655933f, 0.19846959f, 0.25545245f, 0.08690263f, -0.07791370f, -0.09428506f, 
    0.09318124f, -0.05001632f, -0.05251534f, -0.43704781f, 0.11604568f, -0.24050008f, -0.47220647f, -0.00623840f, 
    0.29462633f, 0.14587225f, 0.25699884f, -0.09988826f, 0.47491705f, 0.06191711f, 0.41365734f, -0.38368666f, 
    -0.13094518f, 0.04468594f, -0.56082326f, 0.09862599f, 0.08959089f, 0.09568342f, -0.18697825f, 0.09319277f, 
    0.29371127f, -0.01580727f, 0.10725062f, 0.18535249f, 0.19826138f, -0.10041607f, -0.29920268f, -0.02873772f, 
    -0.26230735f, 0.25842777f, 0.23832645f, -0.12816320f, -0.04000867f, -0.34463000f, 0.45899191f, 0.14750718f, 
    0.08316772f, -0.02133323f, -0.12436049f, -0.35424849f, -0.07170140f, 0.04905403f, -0.24143913f, 0.01752717f, 
    -0.30390713f, 0.17755188f, 0.40512142f, 0.45480195f, -0.10834455f, -0.20683032f, -0.42868865f, 0.36024967f, 
    -0.72663647f, -0.61518037f, 0.55157560f, 0.25001925f, -0.25006473f, -0.11384968f, 0.48290876f, -0.30895448f, 
    -0.44107667f, -0.04833346f, 0.01290479f, 0.02279436f, 0.02723313f, 0.19043823f, -0.14374423f, -0.09762280f, 
    0.15527488f, -0.07528940f, 0.04026254f, -0.02450050f, -0.37897983f, -0.28446290f, 0.34111044f, 0.20839745f, 
    0.19053793f, 0.36426395f, -0.50213057f, -0.20374519f, -0.04332700f, 0.22114180f, -0.00106916f, 0.31696394f, 
    0.17154911f, -0.11637555f, 0.06929158f, -0.15567307f, 0.06631998f, 0.12297998f, -0.12113006f, -0.09015725f, 
    -0.05576732f, -0.06039122f, -0.01158119f, -0.06893864f, -0.11995327f, 0.15042931f, 0.21324435f, 0.18959917f, 
    0.05954496f, 0.20075391f, -0.11599568f, -0.05961517f, 0.33079618f, -0.00260516f, 0.32843012f, 0.05609694f, 
    0.27648136f, -0.05182986f, 0.10321300f, -0.19069624f, -0.18202472f, 0.25272992f, -0.15969944f, -0.02005179f, 
    -0.28168190f, -0.20823149f, -0.12754691f, 0.40449515f, 0.36888787f, -0.23891120f, -0.05587147f, 0.27744880f, 
    -0.24214283f, 0.34196821f, 0.16566156f, 0.11511197f, 0.32224256f, -0.06020363f, 0.17614536f, -0.01695168f, 
    0.17583926f, 0.34696636f, 0.22411232f, -0.24810155f, 0.09780554f, -0.13774003f, -0.36270699f, -0.13596928f, 
    0.09210260f, -0.05245130f, -0.15290618f, 0.16406289f, -0.25963905f, -0.26448974f, -0.20817581f, 0.12092815f, 
    -0.44344789f, 0.61353666f, 0.37772614f, 0.01471352f, 0.12169681f, 0.24970165f, 0.08588456f, 0.25971198f, 
    0.11137211f, -0.14748047f, -0.26321924f, -0.28126806f, 0.05661233f, 0.22413042f, -0.19090477f, -0.12274856f, 
    -0.20816602f, 0.13967206f, -0.05056931f, 0.20985010f, -0.23836449f, -0.07105767f, -0.02718213f, -0.28674030f, 
    0.06903346f, -0.25511965f, -0.86065733f, 0.30959994f, -0.26488194f, -0.76049519f, -0.51112062f, 0.14447424f, 
    0.11356041f, 0.09440895f, -0.10409931f, 0.07621375f, -0.05670569f, -0.05740322f, 0.06153497f, -0.09330894f, 
    0.05376865f, 0.08021101f, 0.09542539f, -0.07346527f, 0.02110380f, 0.02617169f, -0.07548260f, 0.11418806f, 
    -0.27294469f, -0.20846446f, -0.35324901f, -0.28422239f, 0.12063914f, -0.06308410f, -0.35480639f, -0.25095391f, 
    -0.45321861f, -0.29933977f, -0.39148352f, -0.33671817f, -0.35843924f, 0.15129595f, -0.00012340f, 0.13366416f, 
    -0.21969417f, 0.01230597f, 0.17350242f, 0.01729329f, -0.00784882f, -0.04455458f, -0.03845416f, 0.04138144f, 
    0.22906323f, 0.18358567f, 0.17028564f, 0.33447754f, -0.05063050f, -0.34068504f, -0.54886848f, -0.14946277f, 
    0.31705782f, 0.24545561f, 0.10634905f, -0.32194731f, -0.36012241f, 0.15655398f, 0.18728808f, -0.03002018f, 
    -0.14548488f, -0.17973778f, 0.03583740f, 0.17022905f, 0.31487608f, 0.22349681f, -0.19354346f, 0.32176486f, 
    -0.35720834f, 0.14631352f, -0.19202705f, -0.20224753f, -0.49603096f, -0.50268853f, -0.29516342f, -0.18564926f, 
    0.28826517f, -0.11262251f, 0.50724864f, -0.36640751f, -0.45838931f, 0.33066863f, -0.21949248f, 0.09055446f, 
    -0.29983133f, -0.18050596f, -0.34245360f, -0.33979106f, 0.14186630f, 0.23494224f, 0.01344839f, -0.14249979f, 
    0.16423418f, 0.00762700f, 0.12035252f, -0.00426930f, -0.08290354f, 0.19298896f, -0.85457689f, -0.27296910f, 
    0.31720254f, -0.54168737f, -0.49235648f, 0.16331138f, 0.25684962f, -0.40915352f, -0.02821803f, 0.20706306f, 
    0.24502447f, -0.02764670f, -0.26660100f, -0.26958290f, -0.12007990f, -0.23673551f, 0.02796821f, -0.23746355f, 
    -0.02520703f, -0.12731934f, -0.05017109f, -0.06839062f, 0.05366987f, 0.12697800f, 0.06618115f, -1.03417611f, 
    -0.49558234f, 0.17931896f, 0.74309975f, 0.58038449f, 0.49908668f, 0.22812925f, -0.12837875f, 0.02036948f, 
    0.34840009f, -0.13038871f, -0.19584505f, -0.14254670f, 0.46693906f, -0.35239688f, -0.14948213f, 0.20240378f, 
    -0.13906208f, -0.29158363f, 0.16024053f, -0.24497256f, 0.07062409f, 0.21298109f, 0.09401480f, -0.17682499f, 
    -0.16099131f, 0.18507758f, -0.19242792f, -0.24371195f, 0.02629294f, -0.17045368f, -0.40255269f, -0.29311618f, 
    -0.38495934f, -0.24395749f, 0.26702213f, 0.04281592f, 0.33053476f, 0.37692308f, 0.37608376f, 0.11164784f, 
    -0.06148566f, -0.28133404f, -0.26153690f, 0.14400266f, 0.31639698f, 0.33169723f, 0.08277684f, 0.00733600f, 
    0.12431289f, 0.07917669f, -0.09754509f, 0.19814333f, 0.25439388f, -0.15883331f, -0.54223502f, 0.44318625f, 
    0.06616669f, 0.03475198f, 0.03367362f, -0.14192648f, -0.04125015f, -0.02115215f, 0.36744741f, -0.03566770f, 
    0.15397209f, -0.08965935f, -0.04358068f, 0.12238022f, -0.34122604f, -0.06419212f, 0.08205373f, -0.04009885f, 
    -0.07959100f, 0.24228175f, -0.39154702f, 0.10453550f, 0.20079309f, 0.10981172f, -0.08073901f, 0.13372672f, 
    0.53363872f, 0.11847065f, -0.10621691f, 0.48049736f, 0.08038229f, 0.21358334f, -0.11544731f, -0.09739440f, 
    -0.20333102f, -0.16329445f, -0.11709134f, 0.01196317f, -0.14427941f, 0.10692325f, -0.00950891f, -0.07835625f, 
    0.18359989f, 0.15963839f, -0.20382112f, 0.58397692f, -0.70196962f, -0.49231875f, 0.37285236f, 0.47424248f, 
    0.43825141f, 0.93630207f, 0.40089107f, -0.78297228f, -0.67252862f, -0.38702744f, -0.23501898f, -0.08066981f, 
    -0.24064805f, 0.11224969f, 0.09835702f, -0.15509313f, 0.06430525f, 0.09781676f, 0.20837632f, 0.05100170f, 
    -0.11239609f, -0.07757751f, -0.11537371f, 0.04109992f, 0.02154019f, 0.18869390f, 0.21975608f, -0.27456397f, 
    0.33039635f, 0.05727117f, -0.31317517f, -0.24066584f, -0.20972201f, -0.32348874f, -0.10541248f, 0.24075140f, 
    0.26506057f, -0.25293821f, -0.03405650f, 0.01540948f, -0.30893597f, -0.25978866f, 0.15561344f, 0.38829336f, 
    -0.41748300f, 0.38469061f, 0.03796837f, -0.05528493f, -0.36398941f, 0.32306209f, 0.38379800f, 0.05368685f, 
    -0.37332556f, 0.21725056f, 0.09946773f, -0.20776805f, 0.22292145f, -0.35030690f, -0.27108541f, -0.16754206f, 
    -0.01151078f, -0.10888600f, 0.08182348f, -0.31089216f, -0.31454328f, -0.05257249f, -0.25151730f, 0.29741317f, 
    -0.05073104f, 0.16346055f, 0.19871990f, -0.07937847f, 0.12758417f, 0.23395839f, 0.21856923f, 0.70973927f, 
    -0.10884503f, -0.31561297f, -0.10695750f, 0.02188233f, 0.10501914f, -0.17078550f, 0.18834981f, -0.05859943f, 
    0.00266075f, -0.13640852f, -0.26179984f, -0.00273925f, 0.02059698f, 0.48627725f, -0.13207215f, 0.01112009f, 
    -0.39630759f, 0.16399546f, -0.19205800f, 0.07610378f, -0.25133049f, -0.12440663f, -0.06932451f, 0.81834906f, 
    -0.67668450f, -0.66676992f, -0.40549454f, -0.75956768f, 0.04474264f, -0.01464030f, 0.25377229f, 0.32548660f, 
    0.29162052f, -0.07446557f, 0.25631061f, -0.07482137f, -0.05498716f, 0.02195491f, 0.03711710f, -0.02187274f, 
    0.05391135f, 0.03142663f, -0.24486783f, 0.06299175f, -0.18687728f, -0.13782848f, -0.10649148f, -0.06408786f, 
    -0.21772048f, 0.27788252f, 0.38871473f, 0.41335863f, 0.13883954f, -0.15961982f, -0.25630811f, 0.16040131f, 
    0.07082620f, -0.18079057f, -0.25054255f, -0.40809563f, -0.08520839f, 0.37892264f, 0.18353076f, 0.06988023f, 
    0.20331688f, -0.01691592f, -0.14555193f, -0.05737476f, -0.11717844f, -0.05848832f, -0.21713395f, -0.15500145f, 
    -0.00076121f, -0.15233503f, 0.47329858f, 0.36540753f, 0.15684792f, 0.22999440f, -0.65395975f, -0.74689293f, 
    -0.23768154f, 0.50443619f, 0.07764008f, -0.19785057f, -0.31312174f, -0.24541691f, 0.23177117f, -0.07704331f, 
    0.25593570f, 0.29483354f, -0.14973755f, 0.00660058f, 0.06459869f, -0.20150317f, -0.05307688f, -0.17741139f, 
    -0.07782587f, 0.14395458f, 0.50442672f, -0.47643858f, -0.05660383f, 0.35829082f, 0.21319032f, 0.14508924f, 
    -0.33788082f, 0.15173928f, -0.29694280f, -0.11830140f, -0.16171354f, -0.13774523f, 0.39006272f, -0.31623140f, 
    0.17865250f, -0.12110204f, -0.10255452f, 0.29363438f, -0.08108849f, 0.06701604f, 0.14717685f, -0.16975111f, 
    -0.14465652f, 0.20228469f, 0.15571968f, -0.58531755f, -0.31179971f, -0.30296543f, -0.62665772f, -0.54420263f, 
    0.44607449f, 0.36308777f, 0.04341534f, -0.22574589f, -0.00411567f, -0.01890292f, -0.00544464f, -0.11799758f, 
    -0.14589842f, 0.10190107f, -0.12184908f, -0.01071839f, -0.39969888f, -0.41722003f, -0.18394862f, 0.00302707f, 
    -0.00037200f, -0.20475681f, 0.25432804f, -0.08042812f, -0.79801387f, -0.01879271f, 0.42345163f, 0.11809548f, 
    0.47010154f, -0.64662355f, -0.28893146f, 0.09205644f, 0.27333650f, 0.26588961f, -0.12797211f, -0.22217448f, 
    -0.14220175f, 0.36071485f, 0.21720251f, -0.08928000f, -0.28335166f, 0.32248148f, -0.03151406f, -0.33033893f, 
    -0.13119538f, 0.32709500f, 0.21138369f, 0.24456999f, 0.13345134f, -0.13982524f, -0.19651726f, -0.29769304f, 
    -0.28085643f, -0.27361092f, 0.05214158f, -0.41101152f, -0.42551467f, -0.50426388f, -0.49604079f, 0.11253822f, 
    0.13735440f, 0.15175676f, 0.34964591f, -0.02353392f, -0.11031850f, -0.26190901f, -0.21318753f, 0.04475878f, 
    -0.30316436f, -0.22733900f, -0.27542949f, 0.05174950f, -0.10445718f, -0.14900784f, 0.81912583f, -0.29126203f, 
    0.01183897f, 0.15904683f, -0.28766719f, 0.20343842f, 0.47712970f, -0.25682130f, -0.17202117f, -0.07883566f, 
    0.16791977f, 0.01831482f, 0.06628088f, -0.42978859f, -0.12078810f, 0.31143659f, -0.20715143f, 0.15387964f, 
    -0.08101787f, -0.14252056f, 0.08706360f, -0.09026025f, -0.16180634f, -0.19226898f, -0.31025380f, -0.95338476f, 
    -0.33550248f, -0.42432046f, -0.42328119f, -0.01391578f, -0.16289791f, 0.07885082f, 0.51322740f, 0.42099521f, 
    0.66406143f, 0.33349267f, 0.17642505f, 0.08071613f, -0.04305760f, -0.00399153f, -0.17484154f, 0.03817882f, 
    0.06885456f, -0.05462869f, -0.13793142f, 0.10451687f, 0.03520220f, 0.21538429f, 0.03811917f, -0.28865010f, 
    -0.36957234f, -0.13482460f, 0.61120164f, -0.39479223f, -0.66049957f, 0.13403721f, -0.18985534f, -0.15895362f, 
    0.30419439f, 0.07990748f, -0.09039655f, -0.09994301f, 0.11376284f, 0.44179732f, 0.04812771f, 0.09770639f, 
    0.33375043f, -0.15385896f, -0.27159116f, -0.41907114f, 0.11928962f, -0.14643621f, 0.12478065f, -0.20828934f, 
    -0.27884653f, -0.40585521f, -1.02263069f, 0.51537150f, 0.15180863f, 0.43869033f, -0.62970376f, -0.72021699f, 
    0.18085796f, 0.24600613f, -0.12735310f, 0.10625271f, -0.08001033f, -0.24561046f, 0.31417593f, 0.11398901f, 
    -0.38540530f, 0.13798094f, -0.00705026f, 0.04260582f, 0.13250929f, -0.35799628f, -0.23568586f, -0.43095103f, 
    0.12143109f, 0.29100055f, 0.48237252f, -0.73353922f, -0.58126634f, -0.00831911f, -0.59405947f, 0.48800623f, 
    0.22696179f, 0.55311286f, -0.09522953f, 0.04402679f, -0.35280010f, 0.42467213f, -0.09366763f, 0.09450597f, 
    0.00841201f, -0.04408922f, 0.04772030f, 0.19772536f, 0.04437001f, 0.24272053f, 0.10485791f, -0.12098296f, 
    -0.18333726f, 0.00790974f, 0.04428465f, 0.09666062f, -0.13082868f, -0.07252784f, -0.09849825f, -0.27516717f, 
    -0.56468797f, -0.46960267f, -0.46168962f, -0.35608864f, 0.12597089f, 0.34174681f, 0.35365003f, 0.38437673f, 
    -0.08145874f, -0.01437670f, -0.05533961f, 0.20994046f, -0.23393153f, -0.43447843f, -0.43303072f, 0.09171515f, 
    -0.24854450f, 0.13242824f, -0.17238000f, -0.16572262f, 0.53043371f, 0.84417635f, -0.43940833f, -0.14984564f, 
    -0.08729467f, 0.13726264f, -0.34658125f, -0.08923882f, -0.31223589f, -0.51914084f, -0.13773373f, 0.27556869f, 
    0.11413711f, 0.18595608f, 0.01673774f, -0.07779174f, -0.07935847f, 0.00814318f, -0.08988500f, 0.20198086f, 
    0.05891729f, 0.04344543f, 0.08334081f, -0.05764262f, -0.02076044f, 0.16932303f, 0.17845872f, -0.55597550f, 
    -0.09345677f, -0.16766800f, 0.30028394f, 0.25922868f, 0.25830576f, -0.53503412f, -0.22804433f, -0.19726735f, 
    0.32620344f, 0.08585110f, -0.31437212f, -0.06145979f, -0.14590143f, 0.34270987f, 0.49253583f, -0.40621552f, 
    0.01467839f, -0.35733485f, -0.38460031f, -0.05503941f, 0.15368922f, 0.27817655f, 0.48937455f, 0.47316158f, 
    -0.08959667f, 0.44057953f, -0.39402524f, -0.25635812f, -0.10581158f, 0.02857061f, 0.01657995f, -0.02584040f, 
    0.00312034f, -0.11394376f, 0.30523741f, -0.27686426f, -0.30457863f, 0.13984810f, 0.29091439f, -0.00586096f, 
    -0.27151713f, 0.10217301f, -0.12269440f, -0.06125232f, 0.15931565f, 0.06761391f, -0.08696319f, 0.18042988f, 
    0.41477546f, 0.24104062f, -0.09122443f, 0.07831047f, -0.49372688f, -0.35674855f, 0.32880950f, 0.21230993f, 
    -0.15474971f, 0.21236266f, 0.11162609f, -0.06319550f, -0.22253838f, 0.04187229f, 0.11835732f, -0.23570506f, 
    -0.36363161f, 0.08104365f, -0.05085367f, -0.36009139f, 0.23715116f, -0.11152361f, -0.15358658f, -0.05818728f, 
    -0.13876620f, -0.31947589f, -0.39881212f, 0.05751261f, -0.30227968f, -0.26810202f, 0.17356475f, -0.40395403f, 
    -0.28246734f, -0.22424361f, -0.31644779f, -0.06588607f, -0.07085982f, -0.26978976f, -0.31246006f, -0.17904221f, 
    0.05124690f, -0.20278507f, -0.23979482f, 0.06679401f, -0.07266115f, 0.02210036f, 0.12812147f, 0.05259704f, 
    -0.12307074f, 0.67766082f, -0.09738688f, -0.31425890f, -0.25190434f, -0.71646947f, 0.57256103f, -0.18103465f, 
    -0.04589965f, 0.27755839f, -0.07382506f, 0.29036534f, -0.08160809f, 0.03462746f, 0.30376056f, -0.27023566f, 
    -0.07929365f, -0.14825407f, -0.05245271f, -0.21518600f, 0.12231964f, 0.23140684f, -0.01518108f, -0.17709537f, 
    -0.11367473f, 0.30105305f, -0.16766290f, -0.26804140f, -0.27469543f, -0.13903296f, -0.16580966f, -0.38218132f, 
    -0.27102089f, -0.45562431f, -0.34329519f, 0.00862358f, -0.03728157f, 0.36821458f, -0.20338480f, -0.32422340f, 
    -0.21824166f, 0.11156287f, -0.13137968f, -0.09496071f, 0.04618143f, 0.10031894f, 0.02736350f, 0.16373289f, 
    -0.16893467f, -0.28474617f, -0.30610505f, -0.68295681f, -0.53721714f, -0.13877279f, 0.00560195f, -0.40083566f, 
    0.42688483f, 0.02228034f, 0.09786717f, 0.39048892f, 0.16137628f, 0.03933311f, -0.24224791f, 0.02357547f, 
    0.40599340f, -0.01743179f, -0.17597139f, -0.13099016f, -0.08851562f, -0.14507221f, -0.38921371f, -0.12298579f, 
    0.22156093f, 0.33457682f, 0.00628726f, -0.16500232f, 0.00830534f, -0.28700837f, -0.07539968f, 0.38509208f, 
    0.00009932f, 0.26827434f, 0.12148134f, 0.13139559f, 0.02394395f, 0.06575470f, 0.18040466f, 0.05246751f, 
    -0.08695091f, -0.36969861f, -0.11900171f, -0.22706196f, 0.44426274f, 0.05560402f, 0.16361003f, 0.00516980f, 
    -0.19814295f, -0.12154789f, -0.28470537f, -0.33515778f, 0.10585280f, -0.57900566f, 0.10159744f, -0.08094411f, 
    -0.59231079f, -0.21782075f, -0.02749791f, 0.06697889f, -0.04884545f, -0.13747652f, 0.45377037f, 0.09026579f, 
    -0.36360767f, -0.32712269f, -0.22840001f, -0.38859397f, 0.08459835f, 0.40987253f, 0.10017386f, -0.17025238f, 
    -0.34796342f, -0.18169697f, -0.32042244f, -0.17568439f, -0.16983742f, -0.10834317f, -0.55494010f, 0.29997817f, 
    -0.27628073f, -0.68316400f, -0.29689783f, 0.15185264f, 0.41953075f, 0.35651508f, 0.03810015f, 0.26969060f, 
    -0.23960611f, -0.34566554f, -0.17639700f, -0.66258776f, -0.02503660f, 0.40604347f, -0.27285963f, 0.01546615f, 
    0.43052113f, 0.21685323f, -0.23693153f, 0.11581053f, -0.10247866f, -0.02150866f, 0.32700619f, 0.51423717f, 
    0.16971219f, -0.55683285f, -0.15451197f, -0.15150198f, 0.16269802f, -0.09201916f, 0.12724651f, -0.08835255f, 
    -0.01042806f, 0.06319112f, -0.16439921f, 0.37367442f, -0.04348821f, 0.13441414f, -0.23432282f, -0.15084097f, 
    -0.17749326f, 0.09208185f, -0.17978323f, 0.01368445f, 0.17548637f, 0.16483358f, -0.01187487f, 0.40521070f, 
    0.36298895f, -0.60515863f, -0.21659923f, 0.28186351f, 0.41911960f, 0.15722936f, 0.13432060f, -0.03193479f, 
    0.34482720f, -0.08824861f, -0.08633400f, 0.14278828f, -0.20175022f, -0.12090540f, 0.38542750f, -0.18298125f, 
    -0.17309543f, -0.17293459f, 0.27605829f, -0.08735236f, 0.18603787f, -0.06022102f, -0.24767631f, -0.15826535f, 
    0.33752882f, -0.29962623f, -0.49116087f, -0.32500407f, 0.44929785f, 0.47786248f, -0.44918165f, -0.24933849f, 
    0.19595219f, 0.48276198f, -0.15469904f, -0.29381308f, 0.14487472f, -0.28924766f, 0.43402240f, -0.45516893f, 
    -0.02691113f, -0.13683544f, -0.07997306f, 0.07598866f, -0.09475747f, 0.19000109f, -0.17853554f, 0.26965171f, 
    -0.53803217f, 0.15825342f, -0.18324076f, -0.36410481f, -0.27753478f, -0.15649323f, 0.13889492f, -0.06693893f, 
    0.32218221f, 0.26056084f, 0.23715155f, 0.23322867f, 0.14487427f, 0.06114828f, 0.03182128f, 0.23606652f, 
    0.13779204f, 0.17392156f, -0.34466624f, -0.08687953f, -0.21719189f, -0.23106404f, -0.19728282f, 0.13981152f, 
    0.02953517f, 0.20760940f, 0.03977785f, 0.23118401f, 0.14476958f, -0.17979112f, 0.16899897f, 0.34269923f, 
    -0.40415061f, -0.22015861f, 0.03738177f, -0.08786723f, 0.02394572f, -0.03953370f, 0.14350533f, 0.00684829f, 
    0.07411312f, -0.06302796f, 0.21069907f, -0.27152672f, -0.10235409f, 0.01160231f, -0.39850780f, -0.20721604f, 
    0.39481458f, 0.13863528f, 0.29023537f, 0.26133087f, 0.34491229f, -0.78549683f, -0.26300046f, -0.24700892f, 
    -0.47246996f, -0.04323914f, 0.26014042f, 0.21713053f, 0.19248185f, -0.16312994f, -0.01987347f, 0.11301879f, 
    -0.09929303f, -0.41530907f, -0.00453956f, 0.05612196f, 0.09066961f, -0.25397822f, -0.28820515f, -0.05905966f, 
    -0.34840700f, 0.09198189f, 0.00812717f, 0.02848415f, -0.33439690f, -0.43230814f, 0.29235214f, 0.55381185f, 
    -0.24973761f, 0.46599966f, 0.00054474f, -0.24014297f, 0.01820172f, -0.05956627f, -0.07220539f, 0.28278056f, 
    -0.21746004f, 0.12836643f, -0.27793941f, -0.01020182f, 0.06050322f, 0.00691266f, -0.24479178f, -0.00808121f, 
    0.09911654f, 0.07315583f, -0.09678131f, 0.10498337f, 0.14969510f, 0.25375605f, -0.75804985f, 0.44755492f, 
    0.62224782f, -0.30161449f, -0.34482425f, 0.16231960f, 0.42178047f, 0.04309607f, -0.13911484f, -0.23799880f, 
    -0.34615216f, 0.14999439f, 0.38758263f, -0.39063448f, 0.13586396f, 0.32819700f, -0.17890997f, -0.43236461f, 
    -0.05913079f, 0.06730238f, -0.22040033f, 0.23168279f, 0.47170287f, -0.23272915f, -0.01629373f, 0.19361572f, 
    -0.23697925f, -0.40956253f, -0.09177187f, 0.07177490f, -0.02601049f, 0.09972086f, -0.30108035f, -0.35144621f, 
    -0.57591498f, 0.14502119f, -0.16970487f, 0.04452363f, 0.11815819f, -0.20063001f, 0.18928513f, -0.03790520f, 
    -0.05681748f, -0.16374145f, -0.03813757f, -0.11545049f, 0.27110994f, 0.24664485f, 0.05765403f, 0.36809933f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03448750f, 0.02218513f, 0.02313449f, 0.17463945f, 0.12978964f, -0.05639812f, -0.27401853f, 0.29170054f, 
    0.24930482f, 0.11677781f, -0.13837968f, 0.14833796f, 0.13712642f, 0.01758616f, 0.06420186f, -0.08084082f, 
    -0.07592447f, -0.20907584f, -0.02068596f, 0.00796240f, 0.04129890f, 0.15268889f, 0.07372015f, 0.32860559f, 
    -0.12062935f, 0.08739608f, 0.17082471f, 0.10137866f, 0.08315974f, -0.04052280f, 0.24663281f, 0.16438532f, 
    0.14303035f, 0.17874087f, 0.09023450f, -0.08529033f, 0.20704655f, -0.20650351f, 0.17528805f, 0.14531258f, 
    -0.00115772f, 0.18408391f, 0.20619522f, 0.00099207f, 0.22203837f, 0.35112026f, -0.01893084f, 0.18646653f, 
    -0.17242815f, 0.25010985f, -0.14645256f, -0.14779216f, 0.17973098f, 0.10396562f, -0.07377661f, 0.01032021f, 
    0.13701129f, 0.12632310f, -0.22738017f, 0.00428481f, 0.11126784f, 0.13889806f, 0.22971509f, -0.03999003f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.08541162f, 0.13802856f, 0.15600254f, 0.19872908f, 0.04456223f, 0.08195350f, 0.04073648f, -0.02420829f, 
    -0.06258523f, 0.07698971f, -0.03432323f, 0.06196222f, 0.06784607f, -0.10008550f, -0.09409266f, -0.07443446f, 
    0.04146651f, 0.00425396f, 0.04846031f, 0.04751474f, -0.04277639f, -0.13146299f, 0.01597644f, 0.01670746f, 
    0.02274488f, -0.02642150f, -0.02952099f, 0.05613206f, 0.05486473f, -0.01643693f, 0.09707564f, -0.01914260f, 
    -0.02567453f, 0.07761039f, 0.06432636f, -0.11665256f, 0.09316028f, 0.04677346f, 0.09551626f, 0.04050380f, 
    0.02207483f, 0.06671345f, -0.14043343f, 0.00447987f, 0.04322321f, 0.00484028f, 0.02110797f, -0.05018018f, 
    -0.08959811f, -0.00594126f, 0.06504989f, -0.00130249f, -0.02034198f, -0.00075724f, 0.00000462f, -0.01708815f, 
    0.04358648f, 0.01069626f, 0.04585213f, -0.06076759f, -0.03224323f, -0.16010197f, -0.03856712f, 0.04180954f, 
    0.13161613f, 0.19043811f, -0.15822592f, -0.05223581f, 0.12911974f, -0.05964696f, -0.05914474f, -0.10385307f, 
    -0.11942479f, -0.04451376f, -0.27817056f, 0.07689224f, -0.04351622f, 0.01832309f, 0.02995402f, -0.03439483f, 
    -0.04128812f, -0.10904330f, -0.04190053f, 0.18377942f, -0.08523478f, -0.11628307f, 0.18879412f, 0.10205667f, 
    0.07126661f, 0.07243366f, -0.03868727f, -0.01564300f, -0.01028132f, -0.04295650f, 0.10046012f, 0.07883621f, 
    0.02191921f, -0.06613776f, 0.02578544f, 0.05971265f, 0.14617230f, -0.02759367f, 0.05147708f, 0.08412616f, 
    -0.03932568f, 0.03584079f, -0.00774499f, 0.03597880f, -0.32970053f, 0.19495140f, 0.09985891f, 0.20994189f, 
    0.00363189f, 0.08433633f, -0.02127726f, 0.07203875f, -0.07161310f, -0.01476828f, -0.12002589f, -0.04133160f, 
    -0.02534471f, 0.01160072f, -0.13001080f, 0.06392179f, 0.02186456f, -0.02986765f, 0.04899297f, -0.07445419f, 
    -0.18968862f, -0.00752431f, 0.01210011f, 0.02974435f, 0.02720498f, -0.07121760f, -0.15557465f, 0.14103448f, 
    -0.00532572f, -0.02717182f, 0.05849884f, -0.10419449f, 0.02984039f, 0.02400616f, 0.08505239f, 0.13610190f, 
    -0.09848303f, 0.05322364f, 0.02326573f, 0.17359579f, -0.01891656f, -0.02457737f, 0.02313374f, -0.11928142f, 
    0.03032747f, -0.00741439f, 0.06741320f, -0.07212187f, -0.01296727f, -0.08805472f, 0.03377939f, 0.10828052f, 
    -0.00599274f, 0.04127549f, 0.18375081f, 0.02714922f, 0.07394181f, 0.06295815f, -0.03147465f, 0.22657637f, 
    -0.04788215f, 0.04952442f, 0.03380930f, -0.00542092f, 0.01915092f, -0.03731452f, 0.09640031f, 0.04957622f, 
    -0.02032801f, 0.06395125f, -0.01746139f, -0.03475950f, -0.09210379f, 0.05789747f, -0.00794692f, -0.06872101f, 
    0.05856152f, -0.03509927f, 0.06211266f, -0.03550444f, -0.03616843f, -0.08927438f, -0.11606713f, -0.00225915f, 
    -0.12991799f, -0.08637106f, -0.14670028f, -0.23225513f, -0.06881349f, 0.01909105f, 0.07342328f, 0.07571971f, 
    0.24408789f, 0.09705748f, 0.09774268f, 0.02829554f, -0.14332378f, 0.10672014f, 0.15359104f, -0.07523446f, 
    -0.05218466f, 0.04274935f, 0.05002693f, 0.18262510f, 0.03426952f, 0.08602397f, -0.04955288f, 0.01156021f, 
    0.21519561f, -0.03475743f, -0.02982335f, 0.04125331f, 0.02990855f, -0.11329794f, 0.13516137f, 0.09627623f, 
    0.03760239f, -0.02765566f, -0.04966326f, 0.08212338f, 0.00753307f, -0.12933330f, -0.05591159f, 0.03924015f, 
    0.09927890f, -0.02930878f, 0.00328022f, -0.07234854f, -0.01291526f, -0.08640635f, -0.07154781f, -0.14629328f, 
    -0.09026941f, 0.06406029f, -0.07158748f, 0.06868920f, 0.04608038f, 0.06068859f, 0.08377327f, 0.08797186f, 
    -0.02399852f, 0.13939814f, 0.11964721f, 0.03987477f, -0.03729879f, -0.12133856f, 0.16549088f, 0.14353955f, 
    -0.03034805f, 0.00798529f, -0.06341510f, -0.08522853f, -0.05378249f, -0.02786514f, 0.00201013f, 0.05678300f, 
    -0.10138629f, -0.10101136f, 0.06690823f, 0.19145139f, 0.05101363f, -0.03676568f, -0.02414220f, -0.08800382f, 
    0.05577097f, 0.12955005f, 0.06601687f, 0.06435733f, -0.17949422f, 0.41827792f, -0.32410991f, -0.35238245f, 
    0.17719156f, 0.15468651f, -0.03967904f, 0.09025449f, -0.06776264f, 0.04389744f, 0.11497442f, 0.14521341f, 
    0.02505379f, -0.01057599f, 0.08332951f, -0.01615498f, 0.05621322f, 0.06306361f, -0.13244113f, 0.04504779f, 
    0.05442514f, -0.03481111f, -0.10489830f, -0.09208459f, 0.00842120f, 0.11668941f, -0.09356414f, -0.08346058f, 
    0.03537713f, -0.07249153f, 0.14256459f, 0.12947194f, -0.01229780f, 0.07019473f, 0.05322410f, 0.00446784f, 
    -0.17255762f, 0.12231752f, -0.03309713f, 0.00815454f, 0.12230900f, 0.04921116f, 0.07174345f, 0.05955189f, 
    0.02676846f, 0.06585737f, -0.04212543f, 0.00226762f, -0.38501695f, 0.65420538f, -0.46608549f, 0.07725347f, 
    0.15808713f, -0.00789637f, -0.06448109f, 0.05380260f, -0.16087119f, -0.07836284f, -0.07259556f, -0.00457183f, 
    -0.12500729f, 0.00256649f, 0.23336272f, -0.02042185f, 0.13527410f, 0.23138176f, -0.02809435f, -0.00709302f, 
    0.11108275f, -0.07456680f, 0.13242084f, 0.13591842f, -0.00728212f, 0.08630945f, 0.34705216f, -0.18350975f, 
    0.06634463f, 0.01987535f, -0.15735851f, -0.07309568f, 0.01997421f, -0.09441347f, -0.03676533f, -0.00229103f, 
    0.21085089f, -0.20688494f, 0.06933652f, 0.02974510f, -0.09531069f, 0.04071387f, 0.00667104f, 0.02980713f, 
    0.03524953f, 0.00710494f, 0.22710682f, -0.05448449f, -0.36663017f, 0.09395504f, -0.13539690f, 0.29780969f, 
    -0.03865084f, 0.04349757f, 0.05056340f, 0.10274080f, -0.08536062f, 0.10078683f, 0.01270347f, 0.00416205f, 
    0.12968934f, 0.16713542f, 0.06608243f, 0.04839178f, -0.10600750f, -0.00087958f, 0.02542914f, -0.05570274f, 
    0.00175139f, 0.08367516f, 0.25417584f, -0.01262056f, 0.33799627f, -0.04150604f, 0.13091879f, 0.06150207f, 
    -0.20499988f, 0.11592487f, 0.03301701f, -0.02331680f, -0.03231048f, 0.00789526f, 0.04288733f, -0.11585134f, 
    -0.14127284f, 0.19078536f, -0.00143078f, 0.15352394f, 0.01334139f, 0.01952891f, 0.01750799f, 0.04493256f, 
    -0.10229129f, -0.04608417f, -0.03161629f, -0.07533708f, -0.18363482f, -0.04813069f, -0.01006546f, 0.14321443f, 
    -0.00641127f, -0.13199387f, 0.13359034f, 0.04373111f, 0.07337771f, 0.08240076f, -0.11507004f, 0.03399697f, 
    0.54006654f, 0.10813130f, -0.10376530f, 0.06934662f, -0.01392453f, 0.00682921f, -0.07110855f, -0.14051478f, 
    -0.03781989f, -0.09478035f, 0.08669455f, -0.02554279f, -0.19209841f, -0.03003333f, 0.01397436f, 0.10665367f, 
    0.07975345f, 0.09023633f, 0.01447941f, -0.06313860f, 0.07342644f, -0.09924428f, -0.05091092f, -0.00219883f, 
    -0.47660345f, 0.22313778f, -0.07279469f, 0.08587485f, 0.05922274f, 0.09607968f, 0.10724699f, -0.03464279f, 
    0.21959347f, 0.21233064f, 0.07861429f, -0.12194868f, 0.39822090f, 0.09889446f, 0.04594291f, 0.14547004f, 
    0.08946206f, 0.01724677f, 0.08424179f, 0.02883528f, -0.00462926f, 0.09244911f, -0.05437728f, -0.01729024f, 
    0.13300778f, -0.00330419f, 0.13398881f, 0.21433856f, -0.06012611f, -0.02492304f, -0.00571382f, -0.18480572f, 
    0.14348498f, 0.10252926f, -0.10492126f, 0.18808523f, 0.06484567f, -0.14736232f, 0.00035816f, 0.16552292f, 
    0.08589102f, 0.04447490f, -0.08085065f, 0.13197501f, 0.01320919f, 0.06640681f, 0.03830813f, 0.04689096f, 
    -0.39711398f, 0.22425988f, 0.13421491f, 0.13158612f, 0.06951210f, 0.01169981f, 0.06567545f, 0.06411076f, 
    -0.11961029f, -0.03039190f, -0.04865321f, -0.07150954f, 0.06226693f, -0.12933372f, -0.07162418f, 0.09744949f, 
    0.05470355f, -0.02630223f, 0.08581483f, -0.12326034f, 0.07058563f, 0.14922263f, -0.04791616f, -0.05134749f, 
    -0.00521344f, -0.14039089f, 0.45097283f, 0.01840743f, 0.16237608f, 0.05336663f, -0.13770457f, 0.01331359f, 
    0.08976337f, -0.07367103f, 0.00566564f, 0.00008099f, -0.32995141f, 0.16316833f, 0.09671136f, 0.05896804f, 
    -0.01654692f, -0.10203711f, -0.03018252f, -0.06241256f, -0.12785862f, 0.03823586f, 0.01455096f, 0.00080438f, 
    -0.07129159f, 0.04080784f, 0.14789385f, 0.00046906f, 0.02517730f, -0.11772192f, 0.04607633f, 0.09323189f, 
    0.09055863f, 0.03281808f, -0.09261203f, -0.08117951f, 0.11307699f, 0.07872698f, 0.00003439f, -0.05628250f, 
    -0.00987259f, 0.07384458f, -0.08594436f, -0.04509429f, -0.02158597f, 0.04096400f, 0.05849522f, 0.12730233f, 
    -0.08802172f, -0.08514372f, -0.08001020f, 0.15397561f, -0.00957576f, 0.02843620f, -0.04797640f, -0.12079820f, 
    -0.04616309f, -0.03758189f, -0.07065849f, -0.09866623f, -0.29354051f, 0.01316052f, 0.26191777f, 0.31651407f, 
    0.04709383f, 0.04675126f, -0.12265152f, 0.04066330f, 0.03494598f, 0.10058299f, -0.00038481f, 0.10569087f, 
    -0.03195850f, -0.12024520f, -0.00725459f, 0.04315586f, -0.00499983f, 0.06942315f, 0.14574529f, 0.04447953f, 
    0.00337664f, -0.03339249f, -0.04203006f, -0.03693911f, 0.00906955f, -0.15692075f, 0.10049098f, 0.06044548f, 
    0.04653112f, -0.03611290f, -0.00835637f, 0.05136445f, 0.04342598f, 0.11499463f, -0.00126132f, 0.11581162f, 
    -0.03164016f, 0.05684108f, -0.11960556f, -0.19686250f, -0.00169773f, 0.02869851f, 0.17801443f, 0.15451860f, 
    -0.05467602f, 0.12929709f, 0.02225837f, 0.10074564f, 0.05455110f, -0.08109026f, -0.07639132f, 0.00178674f, 
    -0.00497598f, -0.06187434f, 0.12667853f, 0.04543654f, -0.13209432f, 0.06336039f, 0.13931303f, 0.12354097f, 
    0.31411999f, -0.17256181f, -0.04710011f, 0.11195953f, 0.20637579f, -0.13697031f, -0.07248161f, 0.07634617f, 
    -0.05408713f, -0.07264090f, 0.25381446f, 0.13981174f, -0.14433081f, 0.01710029f, 0.12335844f, 0.06060513f, 
    -0.04805072f, -0.01296608f, -0.19738905f, -0.00844229f, 0.00508208f, 0.01888139f, 0.07121787f, -0.07194038f, 
    -0.18301977f, 0.14088157f, -0.05141585f, -0.12934828f, 0.07739208f, 0.01583165f, 0.06165832f, 0.07799941f, 
    0.06099189f, -0.03507299f, 0.15388557f, -0.03268056f, 0.21918881f, 0.12788230f, -0.04078029f, -0.02821850f, 
    0.10518870f, 0.06669173f, -0.08870953f, 0.05872910f, 0.06138793f, 0.12189378f, 0.23583128f, 0.01326103f, 
    0.07139896f, 0.13094471f, -0.07514150f, -0.05732309f, -0.01398916f, 0.05578469f, 0.11562713f, 0.15759508f, 
    -0.00806869f, 0.03952776f, -0.08112688f, -0.11626261f, 0.17410532f, -0.04436930f, -0.10875010f, 0.05111681f, 
    0.06094491f, 0.01673571f, -0.02670957f, 0.12770391f, 0.01216012f, -0.01630121f, 0.05647480f, -0.08251260f, 
    -0.24274884f, 0.06595797f, -0.03726193f, 0.06116847f, 0.02168291f, 0.03764536f, 0.08290343f, 0.00000056f, 
    0.04232829f, 0.12852556f, -0.04571388f, 0.07552877f, 0.21850970f, 0.09597375f, 0.01879754f, -0.10858911f, 
    0.05186864f, 0.08549496f, -0.13138376f, 0.00181570f, 0.03453686f, -0.09772207f, 0.00166984f, -0.04801876f, 
    0.07363476f, 0.04088467f, 0.02663730f, -0.04106318f, 0.10195060f, 0.01142271f, -0.12490092f, -0.11746874f, 
    0.05955892f, -0.07735422f, 0.00451007f, 0.06134322f, -0.11714807f, -0.05619712f, -0.12879537f, 0.07441799f, 
    -0.01912972f, 0.08122133f, -0.14109437f, -0.03639890f, 0.01670318f, -0.04316625f, 0.00616263f, -0.11619640f, 
    -0.21457191f, -0.04464917f, 0.21023834f, 0.11800770f, 0.10386112f, 0.00742823f, 0.13906895f, 0.00465023f, 
    -0.05075303f, 0.12234981f, 0.04694117f, 0.03836957f, -0.21522099f, -0.12848231f, -0.01240850f, 0.30533418f, 
    0.01317005f, 0.07340135f, 0.14331880f, 0.05178716f, -0.01292827f, -0.05011428f, 0.16622961f, 0.17407708f, 
    -0.01307429f, -0.10418466f, 0.00314519f, -0.06001504f, 0.06044735f, -0.06616797f, 0.14054243f, -0.05423172f, 
    0.03411996f, 0.02343865f, 0.02785640f, -0.04743575f, 0.61735249f, 0.14185303f, 0.05255974f, 0.01197110f, 
    0.02665922f, 0.13328324f, -0.07624178f, 0.15046310f, -0.01406741f, -0.01649148f, 0.07441614f, -0.07916118f, 
    -0.03484023f, -0.02350021f, 0.01135729f, -0.02411535f, 0.07505016f, -0.00419540f, 0.15354934f, 0.03795511f, 
    0.02002148f, 0.09100229f, -0.10346895f, -0.01541623f, -0.26026490f, -0.07444486f, 0.05175284f, -0.03521301f, 
    0.07041762f, 0.11889315f, -0.08814333f, -0.14378913f, 0.06204790f, -0.11066557f, -0.00537855f, -0.04947445f, 
    -0.16137688f, 0.03600666f, -0.27908587f, -0.17610824f, -0.04221125f, -0.07615732f, -0.10181323f, 0.01542698f, 
    0.04197639f, 0.00050439f, -0.09702937f, 0.18670642f, 0.02503713f, -0.02910388f, 0.16491511f, -0.02666015f, 
    0.12139663f, 0.06525193f, 0.14676878f, 0.06330644f, 0.04594529f, 0.04420331f, 0.15329593f, 0.16777349f, 
    -0.21234438f, 0.05212878f, 0.22776417f, 0.09798151f, -0.06405304f, -0.11339357f, -0.00491605f, 0.10908664f, 
    0.11050181f, 0.02580055f, 0.08103453f, 0.08971604f, -0.11927924f, 0.19666512f, -0.02344601f, -0.08752529f, 
    -0.05823141f, -0.05118952f, -0.13088909f, 0.21338813f, 0.02313106f, -0.02361420f, -0.05562071f, -0.03757036f, 
    -0.24736670f, -0.02757809f, -0.17254725f, 0.05636987f, -0.02264268f, -0.00646044f, 0.08193752f, 0.02752323f, 
    -0.07385592f, 0.06371030f, 0.01889662f, -0.00338771f, -0.20759876f, -0.00487622f, 0.14531796f, 0.12758712f, 
    -0.16031893f, -0.06870794f, -0.04443865f, 0.02490943f, 0.08807104f, 0.05009696f, 0.16852151f, 0.11304364f, 
    -0.06028533f, 0.00707732f, -0.00226257f, 0.00120254f, 0.01895703f, 0.05674065f, -0.02740548f, -0.07027005f, 
    0.12806664f, 0.07769060f, 0.05608415f, -0.04539694f, -0.08775323f, 0.08189261f, -0.14158197f, -0.04133741f, 
    0.05253782f, -0.06965662f, 0.20533022f, 0.17329720f, 0.07282102f, 0.02188960f, 0.03919216f, 0.10106017f, 
    0.19869812f, 0.15380347f, 0.05916662f, 0.01507469f, -0.06844317f, -0.12618400f, 0.08902942f, 0.01841660f, 
    0.02109475f, 0.01792377f, -0.07407870f, 0.02654546f, -0.05197469f, 0.15833588f, 0.05710210f, 0.03242336f, 
    -0.15144725f, -0.13661385f, -0.09437308f, -0.05732405f, 0.06912876f, -0.15946017f, 0.04851129f, 0.14103448f, 
    0.02765556f, -0.17415905f, -0.04668695f, 0.03643400f, -0.00147424f, -0.03978690f, -0.06683968f, 0.01791756f, 
    0.06682463f, -0.02608062f, 0.14180498f, 0.10381665f, 0.02421270f, 0.04317272f, 0.25182354f, -0.05654244f, 
    -0.06868422f, 0.06089326f, -0.02976290f, 0.10679672f, -0.02381827f, -0.08968543f, -0.05730282f, -0.10091052f, 
    -0.07981274f, 0.11820430f, -0.00460733f, -0.20899084f, -0.06169678f, -0.16099392f, 0.17319804f, 0.19547984f, 
    0.16791956f, -0.09335047f, 0.03836053f, -0.06991991f, -0.19467938f, -0.11819798f, -0.05307296f, -0.11908703f, 
    0.10018392f, 0.00926119f, 0.14849800f, -0.00274792f, 0.00622863f, -0.08542308f, 0.01056650f, -0.07284456f, 
    -0.11745379f, 0.02579421f, 0.12065752f, -0.11299010f, 0.02901632f, -0.01923159f, 0.06396887f, 0.16569287f, 
    -0.00881882f, 0.07457070f, 0.25231692f, 0.00894448f, -0.22939715f, -0.18067428f, 0.17292309f, 0.23550883f, 
    0.04587334f, 0.10820822f, 0.01935217f, -0.04919758f, 0.02345719f, -0.05333859f, 0.14638048f, 0.06779822f, 
    -0.33873019f, -0.10156390f, -0.01989529f, 0.07460845f, -0.03795908f, -0.09026083f, 0.17076434f, -0.10307570f, 
    0.07493179f, 0.05952409f, 0.02000618f, -0.06774594f, -0.29601821f, -0.09649516f, -0.01347821f, 0.31579891f, 
    -0.04028695f, -0.05724152f, -0.10959261f, 0.00955452f, 0.10442343f, 0.00545017f, 0.10174579f, 0.18935791f, 
    -0.09753951f, -0.14665714f, -0.03791432f, -0.14267787f, -0.04260749f, -0.03460516f, -0.10617694f, -0.04528054f, 
    -0.09272843f, -0.07151051f, -0.17635642f, -0.09714428f, 0.09419923f, 0.03885303f, 0.02003580f, -0.06568675f, 
    0.00506619f, -0.08551686f, 0.05034175f, 0.03175111f, 0.11838012f, 0.16366196f, 0.00941583f, 0.12735927f, 
    -0.13993108f, -0.02042794f, 0.09700020f, 0.16351865f, -0.04045287f, -0.10536433f, -0.04165091f, -0.07787016f, 
    0.15289383f, 0.12083969f, 0.10942274f, 0.09401823f, -0.55525607f, 0.14341924f, -0.00298346f, -0.08158785f, 
    -0.08032528f, 0.03188524f, -0.13615774f, 0.02035868f, -0.07287847f, 0.01904978f, -0.15189601f, 0.05426340f, 
    0.00455923f, -0.12542383f, 0.19900560f, -0.01730448f, 0.21139449f, 0.24752104f, 0.10051873f, -0.07808565f, 
    0.13029607f, -0.02294262f, 0.05942769f, 0.09897009f, 0.04736171f, 0.07699613f, 0.27732024f, -0.15213358f, 
    0.01935596f, 0.03323493f, -0.18430856f, -0.11287976f, -0.02582702f, -0.03084601f, -0.05147806f, 0.01684013f, 
    0.38936052f, 0.05963651f, -0.06465448f, 0.17771560f, 0.01870251f, 0.01858142f, 0.06251245f, 0.02304222f, 
    0.12639520f, 0.15396439f, 0.12065355f, 0.09941725f, 0.04218500f, 0.27824083f, -0.07009752f, -0.00398056f, 
    -0.02981002f, -0.05841828f, -0.05430158f, 0.26813552f, 0.05216867f, 0.02780151f, 0.08436369f, -0.07605986f, 
    0.09097187f, 0.03606408f, 0.04161872f, 0.14548466f, -0.04625150f, 0.02187294f, 0.05286531f, -0.01480256f, 
    -0.01432445f, 0.04767437f, 0.21067291f, -0.01966026f, 0.12621376f, -0.11439083f, 0.01493424f, 0.16197601f, 
    -0.04105862f, 0.21067306f, 0.13723284f, 0.05116821f, -0.03373670f, 0.01157993f, 0.03127972f, -0.00242744f, 
    -0.06419025f, -0.04990341f, 0.12524541f, 0.07284043f, 0.05829200f, 0.07563962f, -0.01215025f, 0.22972478f, 
    -0.07303318f, -0.03896113f, 0.02851296f, 0.10223202f, -0.29710650f, 0.03717840f, -0.04953550f, -0.17443010f, 
    -0.07975375f, -0.16101438f, 0.05323647f, -0.08318921f, 0.12216596f, -0.00681002f, -0.01895095f, -0.10820518f, 
    -0.01488096f, -0.12321240f, -0.10313691f, 0.22305489f, 0.12234742f, 0.04341153f, 0.05522755f, 0.08899330f, 
    0.00132199f, -0.00687712f, -0.02675974f, 0.00839645f, -0.19818468f, -0.01925977f, -0.00753196f, -0.14299804f, 
    0.04351198f, -0.05350124f, -0.12889756f, -0.23467323f, 0.00013023f, -0.14403395f, -0.03070003f, 0.07602835f, 
    0.03003823f, 0.08244853f, 0.11911480f, 0.02399597f, 0.02911355f, 0.10283353f, 0.00249304f, 0.06013649f, 
    0.22332798f, 0.11626779f, -0.01001557f, 0.01781882f, -0.32730651f, 0.09941353f, 0.09121367f, 0.05764073f, 
    -0.20929499f, 0.00445527f, -0.04315973f, 0.06947477f, 0.08110636f, 0.05221336f, 0.06334229f, -0.05316672f, 
    0.03357624f, 0.08894765f, -0.10987955f, 0.01994030f, 0.04725182f, -0.04933099f, 0.04337013f, -0.09116225f, 
    0.06633782f, 0.05340652f, -0.01431304f, 0.06544890f, 0.13431677f, -0.25305447f, 0.08197800f, 0.20002167f, 
    0.18371978f, 0.05616634f, 0.06755064f, 0.05006476f, 0.07382277f, 0.11949129f, 0.07075592f, 0.04491027f, 
    -0.29781535f, 0.21092619f, 0.01740643f, 0.02866537f, 0.00336487f, 0.07755370f, -0.01484131f, 0.18791401f, 
    -0.08549189f, -0.01418542f, 0.03232632f, 0.02395970f, 0.01199269f, -0.09611618f, -0.02851959f, -0.15819818f, 
    0.10482016f, -0.01957457f, -0.02570693f, -0.17393233f, -0.01396005f, 0.12694700f, -0.03878977f, -0.01394224f, 
    0.20399520f, -0.02975635f, 0.13053103f, -0.06252279f, 0.10867567f, 0.11911708f, 0.01127192f, -0.05080885f, 
    0.05191002f, -0.03703285f, 0.01098840f, 0.00001345f, -0.17220911f, 0.24395646f, 0.17421426f, -0.05912200f, 
    0.06753614f, 0.09713002f, -0.00642972f, 0.06557697f, -0.06454229f, 0.11971982f, 0.10988381f, 0.22524834f, 
    0.34057978f, -0.08263008f, 0.16686775f, 0.05926501f, -0.00500972f, -0.08790074f, 0.09754570f, 0.05390475f, 
    0.03187430f, -0.01748005f, -0.01440244f, -0.06123634f, 0.31032127f, 0.17024443f, -0.12550858f, 0.13548477f, 
    0.00238277f, 0.03254106f, 0.01441163f, 0.05891012f, 0.00371342f, 0.03700895f, 0.03677920f, 0.10771716f, 
    -0.16940634f, -0.04946310f, -0.05151930f, 0.02801894f, -0.04199429f, -0.00398218f, -0.00725849f, -0.07203053f, 
    0.02027849f, 0.06164619f, 0.09341235f, -0.05367368f, 0.06229721f, 0.30281416f, 0.11129844f, 0.14854029f, 
    0.04158058f, -0.00040155f, 0.04557097f, 0.02809170f, 0.18734266f, 0.03535654f, 0.02271423f, 0.11339866f, 
    -0.10973898f, -0.08020344f, 0.08902117f, -0.00336675f, -0.01885184f, 0.09607042f, 0.04197523f, 0.00852747f, 
    0.02175935f, 0.03600945f, -0.04137741f, -0.02507882f, -0.38491729f, -0.11004679f, -0.15876040f, -0.03060815f, 
    -0.03852004f, -0.12310411f, -0.08118472f, -0.05862650f, 0.04286472f, 0.10895408f, 0.06704053f, 0.04295285f, 
    0.02576586f, -0.02255731f, -0.16015197f, -0.03297780f, -0.02034239f, -0.06665707f, 0.00466287f, 0.11163257f, 
    0.03725642f, 0.08196384f, 0.16929942f, 0.13540885f, -0.12924753f, 0.05216823f, 0.01454979f, -0.03916185f, 
    -0.01555386f, -0.00119025f, 0.17526345f, 0.06575128f, -0.00770884f, 0.05758209f, 0.13953818f, 0.07076347f, 
    -0.06102923f, -0.10352603f, 0.01184212f, 0.04173699f, 0.08039798f, -0.16019996f, 0.04661603f, 0.07415809f, 
    -0.03320751f, 0.03878384f, 0.12223715f, 0.17760853f, 0.20365763f, 0.03332857f, 0.19878012f, -0.18592411f, 
    -0.07969805f, -0.07245870f, 0.00848228f, 0.07855991f, 0.05062817f, 0.01202433f, -0.09534112f, 0.03745335f, 
    -0.15508379f, 0.03985181f, 0.24120966f, 0.18779777f, -0.04116795f, 0.09023968f, -0.02198443f, 0.08368462f, 
    0.16857825f, -0.04893297f, 0.14905418f, 0.12249452f, 0.02935136f, 0.13652188f, 0.25622559f, 0.18542315f, 
    0.14061116f, 0.10211911f, 0.00749709f, 0.11575964f, 0.19014123f, 0.16208996f, 0.19606845f, 0.20141356f, 
    -0.00166635f, 0.15473934f, 0.08990886f, -0.08977845f, -0.15472850f, -0.07833309f, -0.06686778f, -0.00458315f, 
    0.07244594f, 0.04567187f, -0.01996085f, -0.08594321f, 0.17815708f, -0.13368292f, -0.11043929f, -0.07414148f, 
    0.06452508f, 0.06802596f, 0.02779292f, 0.12843902f, -0.01978459f, -0.10380077f, -0.08934852f, -0.04783997f, 
    0.07496756f, 0.11083622f, 0.10355261f, -0.05286086f, 0.03667723f, 0.12530096f, 0.00438157f, 0.10052983f, 
    0.10708135f, 0.07669610f, 0.12237784f, -0.06563828f, 0.06082312f, -0.01861500f, -0.02563910f, -0.00323629f, 
    0.05365429f, 0.09642548f, -0.00117681f, 0.03816064f, -0.09350675f, -0.09483504f, -0.02112429f, 0.05724340f, 
    -0.21347444f, 0.02397285f, -0.00945726f, -0.01255791f, 0.19318326f, 0.04166869f, 0.12076890f, -0.01490256f, 
    0.29960713f, -0.02330115f, -0.03847153f, 0.18316773f, -0.19543454f, -0.09787188f, -0.01805070f, -0.08224905f, 
    0.01194202f, 0.14754103f, -0.08582545f, -0.05228498f, 0.01398154f, 0.01329225f, -0.08619221f, -0.00298959f, 
    0.27222031f, 0.20784645f, -0.11817855f, -0.17084055f, 0.03026373f, -0.01845543f, 0.18233785f, 0.12983549f, 
    0.02077217f, 0.01834997f, 0.02138445f, -0.00923799f, -0.04018462f, 0.16233699f, 0.08903897f, 0.25796118f, 
    0.05763143f, 0.10952187f, -0.10089353f, -0.00931043f, 0.11312096f, 0.03002192f, 0.01416676f, 0.07408535f, 
    0.07458802f, 0.06847581f, -0.11397853f, -0.12214213f, 0.02952043f, 0.02397041f, 0.03048798f, 0.11022343f, 
    -0.05240867f, -0.01946194f, -0.01370964f, 0.04368080f, 0.25706649f, -0.09521075f, 0.11934754f, 0.18606251f, 
    -0.01833035f, -0.00094757f, 0.10961601f, 0.09484859f, 0.02017702f, -0.05598038f, -0.04769433f, 0.07439844f, 
    -0.03818956f, -0.02123943f, -0.08493662f, -0.00126957f, 0.05188395f, 0.01789469f, -0.00160088f, 0.05091590f, 
    -0.04328732f, -0.00824994f, -0.05806096f, 0.04927764f, 0.19862199f, 0.12510684f, -0.00779821f, -0.19814767f, 
    -0.01144642f, 0.14687182f, 0.07977685f, -0.07376659f, 0.08961444f, 0.02803380f, -0.03865268f, 0.03836843f, 
    0.23477063f, -0.02551302f, 0.26591277f, -0.16919866f, 0.17402653f, -0.01997218f, -0.08541562f, -0.03604796f, 
    -0.06445046f, -0.05427736f, 0.09130770f, -0.13340710f, 0.23059532f, 0.05941053f, -0.00914956f, -0.14041138f, 
    0.07505659f, -0.01219668f, 0.07094613f, -0.01927117f, 0.03736540f, 0.02524547f, 0.11086580f, 0.03847768f, 
    -0.07721977f, -0.01205705f, -0.05548776f, -0.17267188f, -0.03711978f, 0.02576089f, 0.15082529f, -0.02675769f, 
    0.14182355f, 0.02258860f, 0.00483211f, -0.04839429f, 0.11464874f, -0.36418313f, -0.35284957f, -0.19545858f, 
    0.01636802f, 0.10305308f, 0.05520853f, 0.07236274f, 0.03793781f, -0.09303816f, -0.01378630f, -0.10252681f, 
    0.26731405f, 0.14828320f, -0.02204886f, -0.18669359f, 0.06624751f, 0.10635009f, 0.02372667f, 0.02674582f, 
    0.01160459f, -0.07027545f, -0.06112545f, 0.10167400f, -0.31857258f, -0.21827120f, -0.09610451f, 0.01056709f, 
    -0.05053872f, 0.14600416f, -0.00902794f, 0.10074507f, 0.09583770f, 0.03325583f, -0.00852709f, -0.05742334f, 
    0.06492178f, -0.07666298f, -0.05660813f, -0.09254881f, 0.06957915f, 0.00890824f, 0.03020173f, 0.09234636f, 
    -0.00026086f, 0.01231033f, 0.01455672f, -0.03737756f, 0.20058560f, -0.02517388f, -0.03931031f, -0.08759946f, 
    0.04215164f, 0.09560180f, -0.01013666f, 0.09106842f, 0.06593861f, -0.03966542f, 0.08097027f, -0.02074025f, 
    0.26607037f, 0.16888319f, 0.03943145f, 0.16532163f, 0.00302505f, 0.03554427f, 0.10118876f, 0.00881405f, 
    -0.00686878f, 0.01787850f, 0.01954804f, 0.04919800f, 0.06688161f, 0.03705400f, -0.11721947f, 0.16510622f, 
    -0.03311593f, -0.02387600f, -0.07939485f, 0.01300981f, 0.00108329f, 0.04815909f, 0.03352651f, 0.09461452f, 
    0.01463998f, -0.10430425f, 0.08975461f, 0.16552049f, -0.05508905f, -0.02303053f, 0.01329211f, 0.13106485f, 
    -0.16118826f, -0.00724677f, 0.11412738f, 0.05948361f, 0.05923110f, 0.10189972f, 0.09814756f, 0.24933837f, 
    -0.03104690f, -0.05852633f, -0.00957290f, -0.04359806f, -0.02959114f, -0.02421515f, 0.03551268f, 0.10173596f, 
    -0.16759664f, 0.14061292f, 0.00203184f, -0.05528459f, 0.10666138f, 0.26378927f, -0.09014449f, -0.00038736f, 
    -0.00297892f, 0.00281961f, -0.00702724f, -0.06900287f, 0.11412808f, 0.17576550f, -0.07785355f, -0.14487176f, 
    0.02561618f, -0.01557182f, -0.10360343f, -0.01255227f, -0.08846652f, -0.00554457f, -0.00555373f, -0.04373211f, 
    0.14616403f, 0.00423701f, -0.14449081f, -0.00951985f, 0.08838776f, 0.10543214f, 0.14741543f, -0.00964256f, 
    -0.00962819f, -0.06662811f, -0.00841774f, -0.10729526f, 0.21912101f, 0.17031568f, 0.08668588f, -0.18422157f, 
    0.06739410f, -0.06426095f, 0.10743891f, 0.08676028f, -0.05772617f, -0.01124012f, 0.03747118f, 0.06218214f, 
    0.05624215f, 0.11020695f, -0.00531485f, -0.21870014f, 0.06659581f, 0.14494240f, 0.01441236f, 0.14712341f, 
    0.06947258f, -0.03011644f, -0.01820017f, -0.02381191f, 0.26883534f, -0.37823057f, 0.20440833f, 0.09416188f, 
    -0.09530530f, -0.12656806f, 0.08675805f, 0.06450226f, 0.23343875f, -0.00147668f, 0.07938240f, -0.02145276f, 
    0.14634481f, 0.08983137f, -0.09312993f, -0.14836073f, 0.10077568f, -0.05152512f, 0.09259433f, 0.01883269f, 
    -0.11747384f, 0.07108639f, 0.00102589f, -0.04475199f, 0.10830053f, -0.03153348f, 0.04770738f, 0.16867325f, 
    0.00926750f, 0.02021527f, 0.11989699f, -0.02678881f, 0.06977674f, -0.01848781f, 0.03231746f, 0.13934375f, 
    0.15195364f, -0.06568099f, -0.05435814f, 0.26595172f, -0.15921555f, -0.05938851f, 0.09516025f, 0.06827760f, 
    0.25654653f, 0.11100397f, 0.11619042f, 0.07610188f, 0.59021521f, -0.39129010f, -0.18324983f, 0.09545237f, 
    -0.10976367f, -0.21868910f, 0.21105257f, -0.02019223f, 0.07158221f, 0.23384176f, 0.11345416f, 0.00214658f, 
    0.04538845f, 0.17880633f, -0.08755353f, 0.06080599f, -0.01403118f, -0.03155941f, 0.03994055f, 0.07746907f, 
    -0.08956917f, 0.05074787f, -0.01545492f, -0.07840206f, -0.08815680f, 0.13162367f, -0.21221341f, 0.03471653f, 
    -0.10273272f, -0.09316821f, -0.05537988f, -0.06332505f, -0.06856883f, -0.11032142f, 0.02792429f, 0.05288140f, 
    -0.31334031f, -0.20249091f, 0.00042983f, 0.17878883f, -0.04718753f, -0.05333861f, -0.06634024f, 0.06909542f, 
    0.10141218f, 0.11902712f, -0.11539883f, 0.00373367f, 0.37765250f, -0.23743364f, -0.14536364f, -0.12113407f, 
    0.05739639f, 0.00988896f, 0.18338458f, -0.03293356f, 0.11929007f, 0.06927931f, 0.04413609f, 0.06382713f, 
    -0.17846863f, -0.13706332f, 0.27131179f, -0.05195390f, 0.02282400f, -0.02459026f, 0.07807588f, 0.04918363f, 
    0.04247934f, 0.01777268f, 0.03798045f, 0.00673847f, -0.07043855f, 0.18286951f, 0.34562862f, -0.16686049f, 
    0.13975836f, -0.09911986f, -0.01391620f, 0.05165064f, -0.04411528f, -0.10463630f, -0.01112330f, 0.04092633f, 
    0.12291840f, -0.02765393f, -0.12613000f, -0.03897504f, 0.04635549f, 0.07791726f, -0.01655439f, -0.18944792f, 
    -0.02889526f, 0.10321213f, -0.13083285f, 0.04632897f, -0.01624041f, 0.03278844f, -0.19347000f, -0.16217923f, 
    0.03458559f, 0.11129651f, 0.03156526f, -0.04283914f, 0.06634399f, -0.13642672f, 0.12648779f, -0.02989645f, 
    -0.16873421f, 0.03359627f, 0.32924116f, -0.20632742f, 0.08522906f, 0.04886426f, -0.00430764f, 0.04882322f, 
    0.01093540f, 0.01587649f, 0.08457233f, -0.05662590f, 0.19506754f, 0.02813748f, -0.10328193f, -0.06252962f, 
    0.04826764f, 0.09578167f, -0.05229643f, -0.00211155f, -0.03360556f, -0.02595460f, 0.04937172f, 0.01733541f, 
    0.10846475f, -0.23915225f, -0.15399089f, 0.11925527f, -0.05147886f, -0.05981482f, 0.04570473f, -0.05060539f, 
    0.02526407f, 0.12077885f, -0.04253011f, 0.03697915f, -0.26629150f, -0.17118083f, -0.06291864f, -0.05633622f, 
    -0.07306787f, 0.21288455f, -0.01501763f, 0.03800477f, -0.03083147f, 0.05366411f, 0.07389623f, -0.06628436f, 
    -0.00933898f, -0.13077909f, 0.06019251f, -0.10573204f, 0.12159473f, 0.13118248f, -0.07414642f, 0.18624392f, 
    0.06423219f, -0.02239425f, 0.13098338f, -0.11122530f, 0.37944782f, 0.10402869f, 0.08267144f, -0.19740359f, 
    0.17824106f, 0.02857735f, 0.06061908f, -0.01603493f, 0.10024498f, -0.06467725f, 0.00747823f, 0.04216460f, 
    0.32703280f, -0.15599863f, -0.39909920f, -0.18340103f, 0.05679049f, 0.01953067f, 0.27823707f, 0.03064759f, 
    0.09807903f, -0.03040596f, -0.08111746f, 0.04597644f, 0.18168563f, 0.15661584f, -0.00151245f, -0.19414140f, 
    -0.03207972f, 0.07325582f, -0.00467413f, 0.17084470f, 0.02645968f, -0.05012623f, 0.04890399f, 0.04069177f, 
    0.09928164f, 0.03061605f, -0.15668252f, -0.05030346f, -0.05021372f, -0.11995977f, 0.07896867f, 0.05809378f, 
    -0.08293216f, 0.06482043f, -0.04776915f, 0.06246732f, 0.04767300f, -0.08487663f, -0.28232181f, 0.02164756f, 
    0.05697257f, 0.08759166f, 0.04710684f, 0.07324784f, 0.17878026f, 0.02039044f, -0.04761124f, 0.22074626f, 
    0.22946543f, 0.16463509f, 0.07864001f, 0.07699928f, 0.07707773f, -0.14807364f, -0.01408186f, -0.04831120f, 
    -0.02810668f, 0.05896407f, -0.11510100f, 0.17229277f, 0.08837623f, 0.02773160f, 0.08521474f, 0.17982650f, 
    0.10604913f, -0.01771314f, -0.06120753f, 0.10492559f, -0.06889909f, -0.01018646f, -0.00959477f, -0.01584854f, 
    0.34530663f, 0.13363868f, -0.02035429f, -0.12176763f, 0.06172664f, -0.01290142f, 0.05927139f, -0.01042975f, 
    -0.00623726f, -0.01773424f, -0.01942896f, 0.10983598f, 0.13651103f, -0.17080911f, -0.15743466f, -0.18118964f, 
    -0.03732024f, 0.02016741f, 0.12541062f, 0.01847822f, 0.10741790f, -0.00407285f, 0.09615006f, -0.06760304f, 
    0.24139507f, 0.25279519f, -0.06527460f, -0.09589745f, 0.06943853f, 0.04451577f, 0.01659858f, -0.05511250f, 
    -0.14491428f, -0.08483303f, -0.00934669f, 0.02113362f, -0.03551221f, -0.14511579f, -0.01595661f, -0.12940507f, 
    0.04785201f, 0.09076785f, -0.10913033f, -0.06113611f, 0.00755423f, 0.07718612f, 0.05610234f, -0.03178032f, 
    -0.08603637f, -0.11695006f, -0.18610004f, 0.08068334f, -0.01036159f, -0.03162696f, 0.09576643f, -0.06800377f, 
    0.06976245f, 0.01352570f, 0.01428279f, 0.10385473f, -0.02597800f, 0.13037331f, 0.03176087f, 0.03075073f, 
    0.02820204f, 0.12040973f, 0.07439676f, 0.12643829f, -0.03282293f, 0.03943083f, 0.06697641f, -0.05868390f, 
    -0.01844255f, 0.31882659f, -0.10987452f, 0.03165419f, -0.03998334f, 0.05855707f, 0.05010799f, -0.03912505f, 
    0.03479965f, -0.03701732f, -0.00532411f, 0.08540191f, 0.01753590f, -0.02149963f, -0.28648981f, -0.09902495f, 
    0.11312225f, 0.00733242f, 0.07788458f, 0.01498467f, -0.10664349f, -0.01024528f, -0.12342049f, -0.03506916f, 
    0.12543228f, -0.15363957f, -0.04231717f, 0.15306585f, -0.06197407f, 0.01989815f, 0.08244935f, -0.09995050f, 
    -0.02085249f, 0.19065642f, 0.17328689f, 0.03636193f, 0.39316213f, -0.10839998f, 0.10475391f, -0.11018503f, 
    0.20212439f, 0.07579847f, 0.09449729f, -0.03850715f, -0.02906407f, -0.08280452f, -0.02209531f, -0.02856910f, 
    0.12548520f, -0.05134450f, 0.00519717f, 0.05737506f, -0.04263673f, 0.05061447f, -0.04476081f, 0.01916246f, 
    0.06008683f, 0.04054186f, -0.04356258f, 0.05867385f, -0.05701102f, 0.14827847f, 0.00654241f, 0.07831372f, 
    0.11106628f, -0.00393063f, -0.10523776f, -0.11609247f, -0.05048325f, 0.07137842f, -0.11661083f, 0.06699155f, 
    0.30815545f, -0.09013541f, -0.13330299f, -0.04094972f, 0.03359811f, 0.05391606f, 0.08885501f, 0.02203475f, 
    0.07146630f, 0.06100621f, 0.09387532f, 0.04101086f, -0.13037594f, 0.11796010f, 0.11711082f, 0.01579591f, 
    0.13883930f, -0.03524831f, -0.00849416f, -0.01487102f, 0.01977655f, 0.01951613f, -0.03408409f, -0.04065322f, 
    -0.29133427f, 0.10754180f, -0.12029389f, 0.06815083f, 0.06049257f, -0.00108674f, 0.11827646f, 0.14299035f, 
    0.11442915f, 0.13581771f, 0.01276158f, 0.09139153f, 0.16532949f, 0.11459057f, -0.06623730f, -0.19480424f, 
    0.03123672f, 0.02577455f, 0.18570520f, -0.06131413f, -0.07125586f, -0.03381289f, -0.08309779f, -0.00102267f, 
    -0.01062302f, -0.04199516f, 0.02624523f, -0.03684946f, -0.03101908f, -0.03184050f, -0.01608937f, 0.01641450f, 
    0.01005709f, -0.01150060f, -0.03203146f, 0.02106375f, -0.00011420f, 0.02570726f, 0.02410024f, -0.03196757f, 
    0.02018247f, 0.00394484f, 0.02717868f, -0.03754842f, -0.00941071f, -0.01804250f, 0.01228979f, -0.01174248f, 
    0.00150243f, -0.00208123f, -0.02664248f, -0.04105091f, 0.00319127f, 0.02456609f, 0.02311878f, 0.02372070f, 
    -0.03320437f, -0.00995223f, 0.01385536f, -0.03813228f, -0.02348499f, -0.02335741f, -0.02267268f, 0.04114820f, 
    -0.00801142f, 0.01857691f, -0.01475191f, 0.03039769f, 0.01291496f, -0.00377861f, -0.01024850f, -0.01827955f, 
    0.01276646f, 0.01214195f, 0.00773292f, 0.02000805f, 0.02095870f, 0.02112561f, -0.03520837f, -0.04198344f, 
    0.02911539f, 0.01273310f, -0.03851320f, -0.02337461f, 0.00646822f, -0.03424650f, -0.00510893f, -0.03565139f, 
    -0.02128755f, 0.01694397f, -0.01861299f, -0.02219426f, 0.01043124f, -0.01217548f, -0.02184052f, 0.00097898f, 
    -0.01138629f, -0.03351631f, 0.02596105f, 0.00564116f, 0.01858466f, 0.01426663f, 0.01723053f, 0.01539230f, 
    -0.02256677f, 0.01638526f, -0.04275754f, -0.00119275f, 0.02686230f, -0.02550284f, -0.04053810f, 0.01336357f, 
    0.01867686f, 0.02699820f, -0.03748201f, -0.02036233f, -0.03751814f, 0.01746795f, 0.00267357f, -0.01151102f, 
    -0.03726100f, -0.01420128f, -0.01575582f, -0.02995957f, -0.02563435f, 0.01192882f, -0.02112534f, 0.00475641f, 
    -0.03796255f, -0.00653476f, 0.00474835f, -0.01050359f, -0.03060233f, 0.03349886f, 0.01487320f, -0.01875723f, 
    0.01312310f, 0.01127746f, -0.03340561f, 0.02810553f, 0.02613620f, 0.01354313f, 0.00582490f, -0.00068068f, 
    0.02848447f, -0.03912042f, -0.01685703f, -0.03268100f, -0.00024823f, -0.00758268f, 0.01281081f, -0.00436408f, 
    -0.01094431f, 0.02316033f, 0.00031426f, -0.02837807f, 0.00754336f, -0.02876090f, -0.03566775f, -0.00915135f, 
    0.00754837f, -0.01955659f, 0.02301938f, -0.02397254f, -0.00777641f, 0.02762543f, -0.01248226f, -0.02769404f, 
    -0.02148333f, 0.01796189f, -0.01416203f, -0.04038208f, 0.00625834f, -0.01693344f, -0.02278853f, 0.02637673f, 
    -0.01854912f, -0.04211047f, -0.01197573f, 0.02988047f, -0.00585519f, -0.03194113f, -0.03121635f, 0.02883127f, 
    0.02147643f, 0.01046430f, 0.02501767f, 0.02729569f, 0.02464989f, 0.02246154f, -0.00625616f, -0.01039824f, 
    -0.00907168f, 0.01535451f, 0.01007489f, -0.00209826f, -0.02178679f, -0.02802866f, 0.00852612f, 0.00300557f, 
    -0.03050950f, -0.01415052f, 0.01147532f, -0.03927656f, -0.00805764f, -0.01091225f, 0.02865631f, 0.02995525f, 
    -0.00337337f, 0.03404804f, 0.01152154f, -0.01291151f, -0.02175687f, -0.02750096f, -0.01926748f, -0.03358519f, 
    0.00200864f, -0.01848387f, 0.00805970f, -0.03083585f, -0.02420241f, 0.01284961f, -0.01319362f, -0.03650822f, 
    -0.02552548f, 0.00184256f, -0.04129177f, 0.02339822f, 0.00124259f, -0.02270567f, -0.03081036f, -0.03264765f, 
    0.02236137f, 0.02938230f, -0.01526089f, -0.03400188f, -0.00630806f, -0.02121633f, -0.02975360f, 0.00038296f, 
    -0.02090205f, 0.00145250f, 0.02810620f, -0.00601706f, 0.01700703f, -0.02726130f, -0.04151224f, 0.01306236f, 
    0.01222753f, -0.03155120f, -0.00426118f, -0.01311590f, 0.02230594f, -0.01124771f, 0.02592543f, -0.04014973f, 
    0.01381129f, -0.02018279f, 0.01154398f, -0.03525972f, -0.00862466f, -0.00050306f, -0.03050864f, -0.03370449f, 
    0.02026355f, 0.01278490f, -0.00826350f, -0.02866827f, -0.02792306f, -0.00883615f, 0.00728149f, 0.00889963f, 
    -0.01147881f, 0.01289126f, -0.04022282f, 0.00164980f, -0.00182819f, -0.01969023f, 0.02298507f, 0.00891162f, 
    -0.03370500f, -0.02556961f, -0.02053331f, -0.01765463f, 0.01346408f, -0.03454063f, 0.00803869f, -0.03367250f, 
    0.01276288f, 0.02606209f, 0.00386016f, -0.03507382f, -0.03601237f, -0.01135581f, 0.02750215f, 0.02258367f, 
    0.02496528f, -0.02883558f, 0.02490117f, -0.00863022f, -0.03039351f, -0.02328891f, -0.03443283f, 0.01176073f, 
    -0.02612832f, 0.01098279f, -0.00842841f, 0.01005967f, -0.00481734f, 0.02404035f, 0.02464287f, -0.03498316f, 
    -0.00566692f, 0.01623218f, 0.01404034f, 0.02644849f, 0.02330218f, -0.03833601f, 0.01732432f, -0.03078692f, 
    0.00936879f, -0.01141299f, -0.03794646f, 0.01084869f, 0.01085854f, -0.01821276f, -0.01589234f, 0.00071442f, 
    -0.01202608f, -0.02600952f, -0.02064676f, -0.01921719f, -0.03939422f, 0.02904922f, 0.02229084f, 0.00311225f, 
    -0.03347378f, 0.01439071f, -0.00875219f, -0.04169304f, 0.03371849f, 0.01539338f, -0.00648737f, -0.02270012f, 
    0.01839246f, -0.00458345f, -0.00509508f, -0.04107743f, 0.01637540f, -0.02137474f, 0.03637280f, -0.01303568f, 
    -0.01270617f, -0.02080961f, 0.00508136f, 0.00129978f, -0.03176116f, 0.01331079f, 0.02771518f, 0.00781070f, 
    -0.02074867f, -0.03704192f, -0.03435938f, -0.00529476f, 0.00421174f, -0.01922459f, -0.00413134f, 0.01823118f, 
    -0.01157149f, -0.01215839f, -0.01535493f, 0.00734728f, -0.01541227f, 0.01516210f, 0.02376210f, 0.02289647f, 
    0.00099629f, -0.00418569f, 0.01520775f, -0.02951881f, 0.02938765f, -0.01055783f, -0.02251655f, -0.01026776f, 
    0.01705433f, -0.00116347f, 0.02390158f, 0.02627742f, -0.02478953f, 0.01423328f, -0.01940458f, 0.03415598f, 
    -0.01691886f, 0.00408738f, 0.02838034f, -0.00446712f, -0.01381677f, -0.02972576f, -0.02980618f, 0.01112040f, 
    -0.02577560f, -0.01550406f, -0.00337642f, -0.02164139f, -0.02139415f, -0.01808740f, -0.02787169f, 0.01940904f, 
    -0.02405142f, -0.01660521f, -0.02097816f, -0.00818808f, -0.03189001f, 0.03629563f, 0.02091161f, 0.01052082f, 
    0.02554093f, -0.01862084f, -0.02365220f, -0.00945688f, 0.00768166f, 0.00107451f, 0.00958562f, -0.02551169f, 
    -0.03418289f, -0.03434169f, -0.03650278f, 0.02279888f, 0.02113760f, 0.00484062f, 0.00809843f, -0.02993013f, 
    -0.03723494f, -0.02713338f, 0.00969671f, -0.01936164f, -0.02180687f, 0.00490153f, -0.01343074f, 0.02488958f, 
    0.01429942f, 0.02209251f, 0.00494867f, -0.02684395f, -0.00384091f, 0.01175783f, -0.01767308f, -0.03454109f, 
    -0.01003017f, 0.01435834f, -0.01110943f, 0.03447613f, -0.02738336f, -0.02256507f, -0.00764980f, 0.00964592f, 
    -0.04194885f, -0.01031837f, -0.02793850f, -0.02419820f, 0.01665735f, -0.01881517f, -0.02088007f, 0.00096821f, 
    -0.02463090f, 0.03030211f, -0.02831428f, 0.01665700f, 0.02150982f, -0.01332540f, -0.03541569f, -0.01866312f, 
    0.00421352f, 0.02327585f, 0.00300999f, 0.02153047f, 0.00311707f, 0.01713069f, 0.02097169f, -0.02734986f, 
    -0.00708437f, -0.01780262f, 0.01484069f, 0.00179413f, 0.01609181f, -0.00447302f, -0.02606172f, -0.00274024f, 
    -0.02645318f, 0.00377448f, -0.01502257f, 0.02932793f, 0.00926299f, 0.03113850f, -0.03552848f, 0.00587416f, 
    0.00500819f, 0.00387090f, 0.01943093f, -0.00910260f, -0.04144760f, 0.01139038f, -0.00861514f, 0.00881137f, 
    -0.01593347f, -0.03224378f, 0.02408750f, -0.02014858f, -0.03633706f, 0.01962079f, -0.02776442f, 0.00924638f, 
    -0.02815925f, 0.00279702f, -0.02203622f, -0.03082141f, -0.00579292f, -0.00491462f, 0.00957143f, 0.02391234f, 
    -0.00038440f, -0.02478120f, 0.02557394f, -0.01199486f, 0.01383285f, -0.03890602f, 0.01050353f, 0.01595301f, 
    0.00308066f, 0.02714952f, 0.04190591f, 0.03379893f, -0.03742042f, -0.02619842f, -0.04013239f, -0.01903226f, 
    -0.02793934f, -0.00628402f, 0.00797274f, 0.00727208f, 0.00474513f, -0.03078045f, -0.00174404f, 0.02475009f, 
    0.01800283f, -0.02427502f, -0.02601948f, -0.03231685f, -0.02342074f, -0.00743316f, -0.00707059f, 0.02148448f, 
    -0.00152910f, -0.03569045f, 0.00827409f, 0.02108397f, -0.01752787f, -0.01574765f, 0.00218617f, -0.00308865f, 
    -0.03356866f, -0.02710915f, -0.01549518f, -0.03137326f, -0.02810150f, 0.01802561f, 0.00801910f, -0.02354460f, 
    -0.02619075f, 0.01439056f, -0.01674248f, 0.00388510f, 0.01899239f, -0.02714453f, -0.00404978f, -0.00645477f, 
    0.02579053f, 0.00109342f, 0.02854378f, -0.01806587f, 0.01555923f, -0.00081175f, 0.01084870f, -0.00539720f, 
    0.01917730f, 0.01226033f, -0.01794203f, -0.01693881f, 0.02583148f, -0.02984449f, 0.02982645f, -0.01226814f, 
    -0.03620683f, 0.00915724f, -0.01811699f, -0.01469172f, 0.02742034f, 0.01674321f, 0.01532758f, -0.01397741f, 
    0.00949784f, -0.02732004f, -0.01328950f, 0.02386767f, -0.03771556f, -0.00129774f, -0.03307578f, -0.00153355f, 
    0.02433600f, -0.01041049f, 0.00886964f, 0.00896070f, 0.02539334f, -0.00185636f, -0.01238778f, -0.00724367f, 
    -0.00273532f, -0.02656891f, 0.00838905f, -0.01665469f, -0.03040664f, 0.00002552f, -0.02949982f, -0.03364737f, 
    0.00373870f, -0.02944560f, 0.00940427f, 0.01608104f, -0.00181388f, -0.04429843f, 0.00968780f, -0.03832430f, 
    -0.01985024f, -0.01289289f, 0.01960654f, -0.02737417f, 0.02477898f, -0.00018801f, -0.02503014f, -0.03146359f, 
    -0.03872150f, -0.02594292f, -0.01053328f, -0.01274593f, -0.03892274f, 0.01095169f, -0.03337105f, 0.02171442f, 
    -0.02706723f, -0.01528430f, 0.00035292f, -0.03340518f, 0.03271441f, 0.01054897f, 0.00482147f, -0.02293548f, 
    -0.01814842f, -0.01506318f, 0.01162960f, -0.02553985f, -0.03419865f, -0.03010370f, -0.03755308f, -0.00750507f, 
    0.00621367f, 0.01095270f, 0.02684157f, -0.04055131f, -0.04365608f, 0.01036057f, -0.00663527f, 0.02718737f, 
    -0.01239767f, 0.01792248f, 0.01077806f, -0.02046788f, -0.03448926f, -0.03336626f, -0.00530691f, 0.00430421f, 
    0.00503348f, -0.00629981f, 0.01316045f, 0.00783448f, -0.03599381f, 0.01537909f, -0.02654285f, 0.00214762f, 
    0.02663472f, -0.01471158f, -0.01600684f, 0.02977921f, 0.03031172f, -0.03911297f, -0.03227656f, -0.02720701f, 
    -0.04068296f, -0.01155828f, 0.00281445f, 0.00669430f, 0.02878330f, -0.00454496f, 0.02811749f, 0.02597888f, 
    -0.03959207f, -0.02063491f, -0.00478396f, 0.02469579f, -0.03153588f, 0.00754626f, -0.00200469f, 0.01521036f, 
    0.00010376f, -0.02654497f, -0.01456109f, -0.03023664f, -0.00593693f, -0.01440143f, -0.01855394f, -0.00081734f, 
    0.01439346f, 0.03960618f, -0.02277051f, 0.02825544f, -0.01788160f, -0.00908984f, 0.03277441f, -0.03194900f, 
    -0.04078336f, 0.03096944f, 0.02774594f, 0.00647561f, -0.01354437f, 0.00132494f, 0.00055065f, -0.00471561f, 
    -0.00667232f, -0.01625002f, -0.02056272f, -0.01692194f, 0.01819552f, 0.00149751f, -0.00057037f, -0.03417023f, 
    0.00413103f, -0.00668169f, 0.00315583f, -0.04086888f, -0.01059788f, -0.01432969f, -0.01160104f, -0.00367882f, 
    -0.01050570f, -0.03059713f, -0.02926100f, 0.01059177f, -0.00963847f, 0.00497343f, -0.02441408f, -0.01867691f, 
    0.02878757f, 0.00469058f, -0.01022924f, -0.02092730f, 0.00044651f, -0.01232672f, 0.01397253f, -0.00286378f, 
    -0.00215778f, -0.02001094f, 0.00005713f, -0.02984823f, 0.00697449f, -0.03299582f, 0.00814203f, 0.01489017f, 
    -0.02875572f, 0.02165245f, -0.00443900f, -0.00361008f, -0.01686453f, 0.02152701f, -0.02171105f, 0.00909797f, 
    -0.02846598f, -0.00031056f, -0.02729103f, -0.00685774f, -0.00970703f, 0.01641327f, -0.01481240f, -0.01855471f, 
    -0.15234393f, 0.19803104f, 0.10027788f, -0.05691806f, -0.03007593f, -0.17058745f, 0.09623518f, 0.04295379f, 
    -0.08471772f, 0.02042400f, 0.01620748f, 0.05458065f, -0.01602721f, -0.14811905f, 0.02226755f, 0.30292013f, 
    0.02418024f, -0.02110860f, 0.04760785f, 0.11820704f, -0.00962654f, 0.08037691f, 0.10050711f, 0.08806321f, 
    -0.10933058f, -0.14769617f, -0.06856983f, 0.01896753f, 0.02762852f, -0.05537641f, 0.14181806f, 0.07660583f, 
    -0.00015987f, 0.00783200f, 0.08373211f, 0.02188529f, 0.22864076f, 0.00066601f, 0.28062057f, 0.13802339f, 
    0.09948160f, 0.14250578f, -0.16537128f, 0.07454785f, 0.03456622f, 0.12419379f, 0.11927974f, -0.07872736f, 
    -0.04851681f, 0.01722883f, -0.02958659f, -0.04585864f, 0.06782201f, 0.06787600f, 0.12074396f, 0.12295377f, 
    0.01709395f, 0.13044272f, 0.11197380f, 0.09961373f, -0.09466285f, 0.08408870f, 0.02811361f, -0.05376258f, 
    -0.11002481f, 0.21486619f, 0.21150200f, -0.16247533f, -0.01666337f, 0.02885895f, 0.00687870f, 0.00391089f, 
    -0.22509862f, -0.07794951f, -0.02176795f, -0.10225290f, 0.03294990f, -0.08776111f, 0.09557787f, 0.15591142f, 
    0.16069321f, -0.00145363f, -0.04437317f, 0.06618053f, 0.06565416f, 0.04257203f, 0.11351620f, 0.03930371f, 
    0.13795023f, 0.08117242f, 0.14251713f, 0.06233837f, 0.12858893f, 0.04789571f, 0.04006679f, 0.13194734f, 
    -0.17671256f, -0.26356843f, -0.07814465f, -0.10948924f, 0.04589262f, 0.01202886f, 0.07525407f, 0.05730946f, 
    0.16740021f, -0.06136483f, 0.03589164f, 0.04310871f, -0.15024622f, -0.10759655f, -0.07048145f, -0.14519711f, 
    0.07666397f, 0.18410254f, 0.04308873f, 0.04583086f, 0.05598747f, 0.00734266f, -0.07193355f, -0.00597977f, 
    -0.12322821f, 0.00225213f, -0.17605682f, -0.07497489f, -0.05875855f, 0.03337141f, 0.04736519f, 0.14597186f, 
    0.00771334f, 0.03559144f, -0.02747325f, -0.03071579f, -0.12815450f, -0.10247753f, -0.02758395f, 0.09546880f, 
    -0.09831929f, 0.09336367f, 0.07834693f, 0.11116868f, 0.19764718f, 0.04876309f, 0.21824136f, 0.14143181f, 
    -0.16508313f, -0.06688245f, 0.03071532f, 0.07723760f, -0.05658693f, 0.12281860f, 0.09083942f, 0.09658749f, 
    0.21731442f, 0.00290537f, 0.10339667f, 0.02213946f, 0.03620107f, -0.03720274f, -0.00308970f, 0.10033214f, 
    -0.06295690f, 0.09126116f, 0.07085776f, 0.09430358f, -0.01536798f, -0.07076847f, -0.10434521f, -0.16219440f, 
    0.09365392f, 0.12693898f, 0.03902083f, 0.09374466f, 0.09086996f, -0.08520447f, 0.02652685f, -0.08051452f, 
    0.10313659f, 0.05522320f, 0.10563171f, 0.08734348f, -0.18099816f, 0.07657367f, 0.11769519f, 0.06532183f, 
    -0.01464926f, -0.05316684f, -0.03515195f, -0.07709492f, 0.02537153f, -0.07278002f, 0.12481261f, 0.25219601f, 
    0.11924627f, 0.02362486f, -0.00591876f, -0.00182463f, 0.02076142f, 0.00679056f, -0.10566115f, 0.00975797f, 
    -0.14377519f, -0.17328121f, -0.01191940f, -0.19367562f, 0.09305017f, 0.17370942f, 0.18613882f, 0.14598359f, 
    -0.05208098f, 0.05075235f, -0.05351993f, -0.00550381f, -0.01490202f, -0.08504701f, -0.00245686f, -0.05511409f, 
    -0.16682526f, 0.00970688f, -0.08777940f, -0.06828742f, -0.01462690f, -0.01181148f, 0.09069071f, 0.10529724f, 
    -0.00717828f, -0.08054765f, -0.08644662f, -0.19064413f, -0.20666386f, -0.16662332f, -0.04533472f, -0.03781331f, 
    0.12625322f, 0.09936630f, 0.11051234f, 0.01549403f, -0.00868861f, 0.03974773f, 0.02294331f, 0.09293374f, 
    -0.16041026f, 0.04290271f, 0.08012944f, -0.11261572f, -0.11504911f, -0.06196301f, 0.06401682f, 0.08533682f, 
    0.00171560f, -0.11146355f, 0.08376582f, -0.18996108f, -0.17218094f, -0.02601695f, 0.12520581f, 0.13039432f, 
    0.12513192f, 0.01410469f, 0.12605187f, 0.06900340f, 0.00484318f, 0.00120599f, 0.11826172f, 0.12233158f, 
    -0.27900997f, -0.13171189f, -0.04683289f, 0.09731607f, -0.02868791f, 0.02298041f, 0.08613937f, 0.13583595f, 
    0.10206100f, 0.06238340f, 0.07553371f, 0.04663906f, -0.12741789f, 0.05456509f, -0.21921563f, 0.00876878f, 
    0.01037660f, -0.08939815f, -0.06237611f, 0.03076892f, 0.12627199f, -0.02341674f, 0.10229848f, 0.11394425f, 
    -0.18520805f, -0.17775065f, 0.00669972f, -0.08086541f, 0.06516092f, -0.02033934f, -0.03721365f, 0.01088610f, 
    -0.15480468f, 0.13657267f, -0.00653905f, 0.07843402f, 0.14954990f, 0.11289594f, -0.03726926f, 0.01134505f, 
    0.01447839f, -0.06453864f, 0.06064554f, 0.00851262f, 0.12155079f, 0.10395976f, 0.07976058f, 0.12884447f, 
    -0.08337594f, 0.05939684f, -0.02389771f, 0.15048921f, 0.01470642f, 0.01446295f, -0.03737913f, -0.00873634f, 
    0.24110188f, 0.09882199f, 0.16190271f, 0.14717723f, -0.01573635f, 0.33717701f, -0.19486046f, 0.11024559f, 
    -0.17913315f, -0.11105778f, 0.04207680f, -0.11709287f, -0.06126740f, 0.04091900f, -0.15069760f, 0.11363292f, 
    -0.04805486f, 0.11879077f, 0.22665341f, 0.00476704f, 0.07600265f, 0.15477087f, 0.00823739f, -0.02795857f, 
    -0.02953882f, -0.04849932f, -0.05886115f, -0.00064755f, -0.02409843f, 0.03427320f, 0.22431704f, -0.06292155f, 
    0.04868265f, -0.04285906f, -0.07673632f, -0.10946158f, 0.05728409f, -0.01491500f, 0.02859955f, 0.08054158f, 
    0.16890691f, 0.00790286f, 0.12773579f, 0.15290259f, 0.01011954f, 0.03938167f, 0.05190476f, -0.06344024f, 
    0.07932438f, -0.06801685f, -0.04448057f, 0.01495358f, 0.00812546f, -0.19415878f, -0.25192705f, -0.02551859f, 
    0.03113784f, 0.02447808f, 0.05611263f, 0.05394892f, 0.04184581f, -0.07866958f, 0.05419011f, -0.06942333f, 
    0.24954483f, -0.05132663f, 0.11378249f, 0.15060702f, -0.02246847f, 0.03513693f, 0.00739877f, -0.06126144f, 
    -0.04059770f, -0.04332811f, 0.09496918f, -0.12063171f, 0.10580780f, -0.14111404f, 0.35363212f, 0.14974217f, 
    0.16245358f, 0.05607250f, -0.01897959f, -0.07340572f, 0.00503790f, 0.07608004f, 0.02436273f, -0.03999287f, 
    0.09356963f, 0.00409641f, -0.01448369f, 0.10853482f, 0.02177633f, 0.00077366f, -0.08365411f, -0.02462127f, 
    -0.00847754f, 0.08025756f, -0.01045878f, 0.06711710f, -0.33669797f, -0.07816632f, -0.04015594f, -0.13011214f, 
    0.00684793f, 0.11482529f, 0.12458208f, 0.12609522f, 0.18183802f, -0.01382097f, -0.00972329f, 0.01763118f, 
    0.19935714f, -0.16932425f, 0.02310186f, 0.07846197f, 0.02849531f, -0.07692870f, -0.09177033f, 0.10028639f, 
    0.01050755f, 0.20359604f, 0.06743939f, 0.03895484f, -0.20980339f, -0.01872474f, 0.02166328f, -0.07904256f, 
    0.00674319f, 0.02953972f, -0.05309305f, -0.11095104f, -0.02805181f, -0.10639437f, -0.03573173f, 0.05788129f, 
    -0.00351303f, 0.22946560f, 0.07931445f, 0.20875219f, 0.05022337f, 0.02699082f, -0.01862461f, -0.08838976f, 
    0.11315407f, 0.04902194f, -0.01586502f, -0.22376099f, -0.02525653f, -0.36930898f, -0.25960988f, -0.02619689f, 
    -0.03691902f, 0.04737792f, 0.06110261f, 0.04750726f, 0.04095370f, 0.03748295f, 0.13249059f, -0.12736665f, 
    -0.14309630f, -0.17710881f, -0.04009546f, 0.00816464f, 0.10546018f, 0.03228955f, -0.03764470f, 0.11077580f, 
    0.04843541f, 0.02534036f, -0.07703018f, -0.09539351f, 0.35054862f, -0.17958985f, 0.01572609f, 0.28302410f, 
    0.07278322f, -0.07306348f, 0.08739584f, 0.12339600f, 0.12427267f, 0.01049323f, 0.03981578f, 0.09629162f, 
    -0.12795700f, 0.00761007f, -0.22095786f, -0.06538036f, -0.01248950f, 0.19402508f, 0.13959379f, 0.14986750f, 
    0.07835581f, 0.00693945f, 0.00007570f, -0.04526171f, -0.05090712f, -0.13793884f, 0.00251254f, -0.12760788f, 
    -0.00238787f, -0.04837174f, 0.10509850f, 0.02416925f, -0.03210282f, -0.04302882f, 0.06970123f, -0.04900061f, 
    0.06734750f, 0.02802845f, 0.17213854f, 0.00805487f, 0.06216598f, 0.03987244f, -0.05515466f, -0.03030294f, 
    0.00766914f, -0.01814432f, 0.01517497f, 0.14668049f, -0.19267344f, 0.28860071f, 0.00657850f, -0.03296677f, 
    -0.00222136f, 0.08142301f, 0.05895951f, -0.03859011f, 0.07731785f, -0.08115526f, -0.02307940f, 0.27570948f, 
    0.18359058f, 0.15831098f, 0.18219726f, 0.06924707f, 0.06818191f, 0.01391895f, 0.02604576f, -0.09035784f, 
    0.04108908f, 0.04020770f, 0.01917577f, 0.00413555f, 0.19600119f, 0.26023790f, -0.00792325f, 0.17363706f, 
    0.06431517f, -0.01086486f, -0.07727221f, -0.01936075f, -0.07666557f, 0.03601059f, 0.02253317f, 0.04364607f, 
    -0.14652617f, 0.04272620f, 0.04192893f, 0.00938037f, -0.06417273f, 0.03602290f, 0.11083820f, 0.02771082f, 
    0.08433610f, 0.12066031f, 0.08753594f, 0.10240149f, -0.09382056f, 0.09356969f, 0.14725971f, 0.05273927f, 
    0.11658238f, 0.21022415f, 0.05397969f, -0.07829754f, 0.19077434f, 0.07538433f, -0.00765913f, 0.15860373f, 
    -0.13347079f, -0.05716203f, 0.06994718f, 0.00317351f, -0.10684099f, 0.03424372f, 0.05271876f, 0.03474457f, 
    -0.06574807f, -0.03738193f, 0.00244959f, 0.09545118f, -0.25708085f, -0.32385224f, -0.22041616f, -0.10771839f, 
    0.04853198f, 0.05447545f, -0.01011877f, 0.01398156f, 0.04302824f, 0.12626810f, -0.01426099f, -0.04468235f, 
    0.01583122f, 0.02265545f, -0.10155099f, -0.07059796f, 0.05535482f, -0.10243107f, 0.04161995f, -0.01905601f, 
    -0.08115905f, -0.06135620f, 0.09311243f, 0.05322834f, -0.16016524f, 0.00186283f, 0.00599246f, -0.00472604f, 
    -0.06639604f, -0.02735001f, -0.00013456f, 0.02552765f, -0.14593537f, -0.09795060f, 0.02737577f, -0.07293405f, 
    0.07603548f, 0.00745664f, -0.07559785f, 0.07500272f, -0.02770901f, -0.11257909f, 0.06422643f, -0.01093752f, 
    -0.04357752f, -0.01463969f, -0.05373005f, 0.12798433f, -0.02949164f, -0.09270932f, 0.12494063f, -0.00887233f, 
    -0.07598801f, 0.11695473f, 0.02336265f, 0.00193167f, 0.09502870f, 0.08346868f, 0.05219590f, 0.14983492f, 
    0.08457065f, -0.03747411f, 0.03611128f, -0.05580818f, 0.01379826f, 0.04943069f, -0.00866657f, -0.05610058f, 
    0.10422830f, 0.03995700f, 0.08366970f, 0.04559965f, 0.20938531f, 0.02586041f, -0.04566893f, 0.13475950f, 
    0.06811411f, -0.01882004f, 0.24155441f, 0.06091907f, 0.12199213f, 0.09915423f, 0.15147249f, 0.07471757f, 
    -0.02327294f, -0.13484205f, -0.21549755f, -0.12216217f, -0.02376029f, -0.01488200f, -0.04810389f, -0.02188406f, 
    0.26739821f, 0.10376193f, 0.02412392f, -0.00366467f, 0.06478206f, 0.01300416f, 0.02356393f, -0.03150896f, 
    0.01998491f, 0.06834400f, -0.10391770f, -0.04285726f, 0.08943687f, 0.12093137f, 0.01307717f, 0.08049435f, 
    0.03623548f, -0.02905654f, 0.01137673f, -0.05188762f, 0.00298518f, 0.17105262f, 0.05679084f, 0.07079221f, 
    0.07409393f, -0.12606539f, 0.00756288f, -0.12456144f, 0.12691575f, 0.07081988f, -0.02832189f, -0.09237266f, 
    0.24147497f, -0.13631408f, -0.08630424f, -0.03559238f, 0.08855737f, 0.02405378f, 0.09529109f, 0.07384511f, 
    -0.25791159f, 0.07121845f, 0.01950016f, 0.12909125f, 0.15254229f, 0.01377612f, 0.05952026f, 0.04609886f, 
    0.10219333f, 0.11895981f, 0.04474117f, 0.11126823f, -0.18988881f, -0.00066393f, 0.03635239f, -0.02322038f, 
    0.08696868f, 0.21635632f, 0.13620134f, -0.03226891f, 0.04796867f, 0.11563165f, -0.01194049f, 0.07709958f, 
    -0.16175556f, -0.05144725f, 0.13792437f, -0.07158662f, 0.07427427f, -0.04421030f, 0.02563660f, -0.05694355f, 
    -0.01247195f, -0.00049976f, -0.01735834f, -0.03844912f, -0.13073294f, -0.26717988f, 0.05534086f, 0.26822001f, 
    0.06353620f, 0.00128641f, 0.06461789f, 0.09173785f, 0.04060163f, -0.06439481f, 0.17130736f, 0.32248577f, 
    -0.05882256f, -0.01314993f, 0.06209491f, 0.01602385f, 0.03754791f, -0.10093396f, 0.06027942f, 0.09095909f, 
    0.09559897f, 0.04466416f, -0.11870740f, 0.00767057f, 0.15855746f, 0.02768954f, -0.19063276f, -0.16147982f, 
    0.17698033f, 0.03935476f, 0.04071662f, 0.06110980f, 0.05928940f, 0.01219115f, 0.16891107f, -0.10792821f, 
    -0.00552977f, -0.04027797f, 0.02744508f, -0.04550630f, 0.15996411f, 0.08414167f, 0.11574870f, 0.15507159f, 
    0.11652916f, 0.13772419f, 0.06634790f, 0.09232512f, -0.15113975f, 0.09109738f, 0.18914768f, 0.08486956f, 
    -0.04413354f, -0.03113717f, 0.08617252f, -0.01708496f, -0.08794585f, -0.04379721f, -0.03826593f, 0.05489440f, 
    -0.04029692f, 0.12758639f, 0.00007440f, -0.00054363f, 0.14850873f, 0.03699950f, -0.04011049f, 0.22001630f, 
    0.08522545f, 0.00961907f, -0.12664983f, -0.08410519f, 0.18879041f, 0.09151734f, 0.03163164f, 0.00048272f, 
    0.10732182f, -0.01007949f, 0.22055714f, 0.14252026f, 0.04645602f, 0.12746951f, 0.02929580f, 0.14274329f, 
    0.03504547f, -0.09954474f, 0.15411983f, 0.11451687f, -0.03178712f, -0.01695981f, 0.00017570f, 0.11985044f, 
    0.12294416f, -0.08016627f, 0.00796864f, -0.07567066f, 0.10208619f, -0.08725352f, 0.04748243f, -0.14699934f, 
    0.03346391f, 0.04768502f, 0.11698560f, 0.11197706f, 0.14109905f, 0.10163663f, -0.08670442f, 0.06023972f, 
    -0.22442713f, 0.03728035f, 0.03019840f, 0.04217589f, 0.06431650f, 0.03734785f, -0.02849690f, 0.19820984f, 
    0.01798322f, -0.03780637f, 0.00193078f, -0.03123841f, -0.03857927f, -0.03963758f, 0.30481759f, 0.08636457f, 
    -0.10423580f, -0.01882679f, 0.03722759f, 0.00013504f, 0.22974797f, 0.12053232f, 0.29076749f, 0.15586783f, 
    0.12513593f, 0.03226986f, 0.17934309f, -0.15950404f, -0.04156494f, 0.00306475f, -0.12678185f, -0.00335823f, 
    0.15886606f, 0.01592050f, 0.12206849f, 0.08715624f, -0.02207589f, -0.00383017f, -0.07137927f, -0.04698882f, 
    0.05900887f, -0.02813979f, 0.00880282f, 0.16691799f, -0.19360511f, -0.15565386f, -0.13292900f, -0.13634171f, 
    -0.19737554f, -0.03218505f, -0.06906322f, -0.01017688f, -0.01605393f, -0.02544771f, -0.02683363f, -0.06809835f, 
    0.18331748f, 0.11094263f, 0.11095252f, 0.15302844f, -0.20596142f, -0.09087424f, 0.14143203f, -0.12087115f, 
    -0.08901031f, -0.14681582f, -0.12302767f, -0.11527639f, 0.14909761f, 0.10786699f, 0.38255501f, 0.26432073f, 
    -0.09184338f, -0.17150050f, -0.17127840f, -0.05734089f, 0.00710742f, -0.02141773f, -0.20176028f, -0.12382314f, 
    -0.04328400f, -0.14242938f, -0.07908115f, -0.10989453f, -0.44701207f, -0.23286274f, -0.11948529f, -0.20165959f, 
    0.06678282f, 0.00619071f, -0.00089284f, -0.04739164f, -0.07588374f, -0.07456917f, -0.06692247f, -0.04033502f, 
    -0.09534679f, 0.10316266f, -0.00615119f, -0.10308672f, 0.04102970f, -0.00088040f, 0.10122512f, 0.21081281f, 
    -0.04392044f, -0.11595165f, -0.15693466f, -0.20364983f, -0.13390113f, -0.07612326f, 0.08138324f, 0.07416792f, 
    -0.03299133f, -0.01517618f, 0.05543415f, 0.10980330f, -0.00418176f, -0.00783208f, 0.02039730f, 0.09481789f, 
    -0.12722881f, -0.05369461f, 0.23488714f, -0.22413056f, 0.02464591f, -0.03973823f, 0.05547991f, 0.14709353f, 
    0.00954282f, -0.24466327f, -0.01784870f, -0.17306338f, -0.10664397f, 0.07197826f, -0.07933259f, 0.13167308f, 
    0.05945262f, 0.11291616f, 0.06913314f, 0.15782064f, -0.02813701f, -0.09117487f, 0.03465881f, 0.06880035f, 
    -0.20625880f, -0.06764524f, 0.04459512f, 0.02153437f, 0.01369597f, 0.03505638f, 0.11576223f, 0.19473153f, 
    0.06719789f, -0.02433042f, 0.05747067f, -0.05965208f, -0.13707854f, -0.11070430f, 0.10589209f, 0.13215527f, 
    -0.16916697f, -0.07368811f, -0.11041957f, 0.00663151f, 0.18975914f, 0.01976272f, 0.07273633f, 0.20558985f, 
    -0.07608508f, -0.03453835f, 0.10384386f, -0.00943246f, -0.00609689f, -0.03486076f, 0.05296561f, -0.14829008f, 
    -0.19717985f, -0.03135537f, -0.03036317f, 0.00829338f, -0.03455191f, 0.03868372f, -0.00160779f, -0.09001117f, 
    0.08553334f, 0.05437205f, -0.07498197f, 0.11017373f, 0.20720470f, 0.14564516f, 0.11948394f, 0.17176254f, 
    -0.12545829f, -0.06818748f, 0.07828441f, 0.03558517f, -0.07957772f, -0.01100210f, -0.18744774f, -0.12678470f, 
    0.24071109f, 0.09811772f, 0.21198820f, 0.11613593f, -0.52005082f, -0.14572023f, 0.38232362f, -0.36193681f, 
    -0.13181034f, -0.05862672f, -0.14109839f, -0.07052375f, 0.05666860f, -0.12927067f, -0.00858203f, 0.16841787f, 
    0.05085548f, -0.26919410f, -0.09044965f, 0.17909642f, 0.12508298f, 0.17281188f, 0.16166985f, 0.02224816f, 
    0.05320216f, -0.15966776f, -0.11508960f, -0.01565105f, -0.30692530f, -0.14525557f, 0.00790866f, -0.00968488f, 
    -0.06894733f, -0.15191028f, -0.09379577f, -0.11003920f, 0.05168376f, 0.06701834f, 0.09441312f, 0.06481721f, 
    0.02798158f, 0.12552197f, -0.20877086f, -0.06490064f, 0.06549002f, -0.07504868f, 0.07144058f, -0.06693824f, 
    -0.00660350f, 0.09104896f, 0.00363650f, 0.10404300f, 0.32766482f, -0.00462563f, 0.11931083f, -0.08617049f, 
    -0.00336616f, -0.07127495f, -0.02311458f, 0.08476002f, 0.12161686f, -0.07820264f, -0.11110912f, -0.17697632f, 
    -0.29491740f, -0.21442915f, -0.24738115f, 0.00804265f, 0.01507617f, 0.09147508f, -0.00261570f, -0.12161058f, 
    -0.13535163f, -0.13627155f, -0.08362507f, -0.12367728f, -0.20116676f, -0.04822550f, -0.38119191f, 0.16874832f, 
    0.13937490f, 0.05444274f, 0.15679489f, 0.01518437f, 0.03193636f, 0.04859208f, -0.00391148f, -0.03517903f, 
    -0.10019955f, -0.33093849f, 0.11180543f, -0.01758176f, 0.05384125f, -0.00529776f, -0.02586900f, -0.05099276f, 
    0.00011031f, -0.01029961f, 0.10008976f, 0.22763215f, -0.00686367f, 0.15081689f, 0.04857164f, -0.10479368f, 
    0.03420963f, 0.07561792f, -0.02622758f, 0.25228673f, 0.09051040f, 0.05098271f, 0.13872047f, -0.03090998f, 
    0.05844199f, -0.09217857f, -0.20310222f, 0.14934506f, 0.02989031f, -0.06859087f, -0.00213717f, 0.14572577f, 
    0.15312274f, 0.19404916f, -0.01479991f, 0.18153863f, -0.08062802f, 0.07999798f, 0.10685091f, -0.07618503f, 
    0.03648222f, 0.05797100f, 0.03740160f, -0.08258968f, 0.01312947f, -0.02574048f, -0.07601418f, 0.01850832f, 
    0.18567705f, -0.03525169f, 0.08132137f, -0.15005204f, -0.05523542f, -0.04476060f, -0.22606152f, -0.08206004f, 
    0.03958302f, -0.01880063f, -0.17174557f, 0.06069143f, -0.20292181f, -0.12291475f, 0.07427182f, 0.15507375f, 
    -0.12111045f, -0.05572423f, -0.07317501f, 0.05835246f, 0.16471560f, -0.01646523f, 0.01849087f, -0.03070223f, 
    0.07674146f, 0.25202933f, -0.19750036f, -0.08664216f, 0.05050571f, -0.01370919f, -0.00353744f, 0.22695245f, 
    -0.20193310f, -0.09497384f, -0.04978218f, -0.19169830f, 0.06657308f, 0.00600427f, -0.04337122f, 0.19851892f, 
    0.05152509f, -0.06634815f, 0.12320074f, 0.06513370f, 0.17843147f, -0.00416396f, 0.07672171f, -0.07189739f, 
    -0.11980560f, 0.02647569f, -0.05845294f, -0.04352042f, 0.08001202f, 0.17290686f, 0.04372366f, 0.18277957f, 
    -0.00683536f, 0.04075985f, 0.06884695f, -0.06054784f, 0.01762437f, -0.03422362f, 0.07593964f, 0.03990166f, 
    0.00417117f, 0.02833890f, -0.05417125f, 0.04837502f, -0.00685784f, -0.01204492f, -0.05564834f, -0.08310202f, 
    -0.05083384f, 0.01863616f, -0.08051721f, 0.04987080f, 0.16341674f, 0.08586127f, 0.03590569f, -0.14514898f, 
    0.06394587f, -0.07914873f, 0.03632420f, 0.12513332f, 0.13033301f, 0.08239671f, 0.14941649f, 0.04499235f, 
    0.08671480f, 0.19177520f, 0.06799597f, 0.19975770f, 0.24165490f, -0.00307150f, 0.10183404f, 0.35315403f, 
    -0.01546663f, -0.07778068f, -0.27484161f, 0.17235088f, 0.01649406f, 0.14463098f, 0.03044406f, -0.08838131f, 
    0.12933429f, -0.00044616f, 0.09440552f, -0.06521821f, -0.13730496f, 0.00016241f, -0.35943839f, 0.04382624f, 
    0.02695975f, -0.06762102f, 0.21732831f, -0.03643327f, 0.05509318f, 0.00185601f, 0.03382756f, -0.04490347f, 
    -0.09537062f, -0.01714691f, 0.09239103f, 0.05420780f, -0.05121325f, 0.05271478f, 0.01237556f, 0.08497049f, 
    0.19195062f, 0.08025785f, 0.17035420f, 0.15413658f, 0.28348899f, 0.38388872f, 0.04282534f, -0.11781526f, 
    0.03053553f, -0.01248085f, 0.17966120f, -0.05342214f, 0.15753123f, 0.08861745f, -0.02380857f, 0.04272846f, 
    -0.05479559f, -0.03948037f, 0.19324924f, 0.12593877f, -0.10193127f, 0.08012882f, -0.02425974f, 0.01294405f, 
    -0.05889735f, 0.03725932f, 0.11236601f, -0.03523330f, -0.20373905f, 0.18354626f, -0.19109339f, -0.10555696f, 
    -0.11471574f, -0.04899151f, -0.01278692f, 0.07508570f, 0.00674785f, 0.07713453f, 0.00867292f, -0.08932000f, 
    -0.03409791f, -0.20722882f, -0.03949437f, -0.11139315f, 0.01027597f, -0.02930281f, -0.14584254f, -0.07531557f, 
    -0.06193206f, -0.10684613f, 0.09432069f, -0.11486316f, 0.00304825f, -0.00322662f, 0.12617874f, 0.02356990f, 
    -0.02260144f, -0.09151490f, 0.08444061f, 0.07266781f, -0.00305338f, -0.06350318f, -0.11387876f, -0.16322757f, 
    -0.09358621f, 0.01015947f, 0.05410171f, 0.06621084f, -0.10949043f, 0.00313441f, 0.10049894f, -0.07492325f, 
    -0.08762091f, -0.01583490f, -0.12148856f, 0.06019115f, 0.22574356f, -0.04730009f, 0.04083146f, -0.19407310f, 
    -0.01157735f, -0.19252525f, 0.07068555f, -0.09421308f, 0.16515738f, 0.19101012f, 0.10049731f, 0.28315011f, 
    -0.03716516f, -0.15005305f, 0.37733445f, -0.11231306f, -0.00206260f, 0.05054734f, -0.04422394f, -0.00244061f, 
    0.08671583f, -0.03235833f, 0.14329259f, 0.11357116f, -0.14308409f, 0.32723173f, -0.01531745f, 0.36741486f, 
    -0.00391183f, -0.01189800f, 0.08969714f, 0.09338156f, 0.20265107f, 0.23613866f, -0.06376628f, 0.16582061f, 
    -0.08762494f, 0.04280367f, 0.02811114f, -0.09556305f, -0.02847629f, -0.06861596f, -0.08454309f, -0.03009579f, 
    0.15898670f, 0.08456197f, 0.16409522f, 0.01486920f, -0.09047836f, -0.19808687f, -0.09701935f, -0.13447647f, 
    0.10423125f, -0.13160214f, 0.01853025f, -0.04414098f, 0.12538059f, 0.10415669f, 0.10162584f, 0.02440256f, 
    0.08959157f, 0.14593729f, 0.12918259f, 0.06970386f, 0.08846894f, 0.13662168f, -0.09063318f, 0.19517542f, 
    0.10452710f, -0.13509950f, 0.04438621f, -0.22845024f, -0.01577983f, -0.09755103f, -0.15867840f, 0.06043316f, 
    0.11325883f, -0.01343267f, 0.09643464f, -0.00498397f, 0.17550626f, 0.09902167f, 0.12822051f, 0.11981424f, 
    0.04428787f, 0.15899263f, 0.07914148f, 0.23892137f, 0.16359282f, 0.03600407f, 0.04275056f, 0.25374302f, 
    0.19734469f, 0.03458172f, -0.11361340f, 0.12961289f, -0.03692995f, 0.00691733f, 0.12458177f, -0.05691655f, 
    -0.00352886f, 0.05653102f, 0.04432150f, -0.01117817f, 0.01231406f, 0.05189160f, 0.01012629f, 0.14012830f, 
    -0.09070900f, -0.29947361f, 0.16023487f, 0.17595699f, 0.12141386f, 0.14910311f, -0.15041059f, -0.04710690f, 
    0.05247125f, -0.02782352f, -0.04069369f, 0.01928879f, 0.10727750f, 0.01046122f, 0.15690532f, -0.16082165f, 
    0.04954666f, 0.00508894f, 0.14981543f, -0.02767354f, -0.01654105f, -0.00984791f, -0.09789307f, -0.02462518f, 
    -0.00347412f, 0.05026824f, 0.23513351f, 0.19927487f, 0.09628044f, 0.04507471f, -0.02962229f, 0.06947088f, 
    0.13906191f, 0.04851357f, 0.05759518f, 0.07594403f, -0.16454394f, 0.03984665f, -0.31434023f, -0.19189890f, 
    -0.02210987f, -0.00846153f, 0.06661779f, -0.03965168f, 0.03087784f, 0.00006228f, 0.06221424f, -0.03891360f, 
    0.04747196f, -0.01001904f, 0.00484126f, -0.00645609f, 0.08175665f, 0.06869008f, 0.02327355f, 0.03651081f, 
    0.04003475f, -0.01203998f, 0.03766806f, -0.00659234f, -0.07541384f, -0.06312948f, 0.22592589f, 0.32814595f, 
    0.08966549f, -0.12093507f, -0.02158218f, 0.17375825f, -0.02368235f, 0.07516988f, 0.06239755f, 0.03446620f, 
    -0.09034112f, 0.19006014f, -0.03735707f, 0.29199672f, -0.01992918f, 0.16883625f, 0.11428827f, 0.12178490f, 
    0.00636337f, 0.00229645f, -0.09947884f, -0.00630472f, -0.12910493f, 0.09119480f, 0.04754303f, 0.15696347f, 
    -0.03534168f, 0.02469316f, 0.06061133f, 0.10964911f, -0.06533527f, 0.08690754f, -0.06780914f, -0.07515816f, 
    0.27317441f, 0.15860264f, 0.02356750f, 0.19582252f, 0.00728653f, 0.02672075f, -0.15937376f, 0.04064048f, 
    -0.08882685f, 0.04704451f, 0.04106704f, -0.03215721f, 0.06001304f, 0.14838457f, 0.14226538f, 0.09007316f, 
    -0.04669912f, -0.08055705f, 0.23743221f, 0.04251076f, -0.05310056f, 0.05027975f, 0.01899577f, 0.03276394f, 
    -0.13261406f, -0.05134288f, 0.24473482f, 0.22090675f, -0.00005907f, -0.03898714f, 0.00840085f, -0.02250968f, 
    0.04570816f, -0.03185828f, -0.03564636f, -0.08092204f, 0.38873672f, 0.28018403f, 0.15259752f, -0.05457792f, 
    0.11189309f, -0.08046822f, 0.02591359f, -0.07211336f, -0.06208964f, 0.05411361f, 0.09956279f, 0.02382480f, 
    0.20612910f, 0.16836829f, 0.15902051f, 0.10475273f, -0.00339252f, -0.03893128f, 0.02491570f, 0.13937531f, 
    -0.02204905f, 0.04568990f, 0.01981691f, 0.04870722f, -0.14275278f, 0.13647518f, 0.06176765f, 0.06659483f, 
    0.05674705f, 0.01020616f, 0.00692944f, -0.01254055f, -0.00421157f, -0.01347482f, 0.02761523f, 0.08812211f, 
    -0.10055512f, -0.23891644f, -0.08951981f, -0.20825987f, -0.13785349f, 0.05307432f, -0.06119864f, -0.04573606f, 
    0.01235729f, 0.07133425f, 0.05866416f, -0.03658548f, 0.17276147f, -0.05343007f, 0.08129498f, -0.16460966f, 
    -0.03498890f, -0.03033114f, 0.05500881f, -0.07803424f, 0.01293870f, 0.08417418f, 0.13263544f, -0.01644147f, 
    -0.08597592f, 0.09452448f, -0.01330001f, -0.17022860f, -0.07216144f, -0.07443176f, -0.06364661f, -0.11411797f, 
    0.24393193f, 0.20656767f, -0.02115128f, 0.04147233f, -0.05674471f, -0.22473118f, -0.17641035f, -0.23372740f, 
    0.00294568f, -0.06876672f, -0.02209022f, -0.00556050f, 0.05038052f, 0.11473488f, -0.00313814f, 0.00965873f, 
    0.19450356f, -0.04616261f, 0.12569423f, 0.10129184f, 0.01485655f, -0.03878219f, 0.07022081f, 0.00161812f, 
    0.13029297f, 0.05966004f, 0.07731691f, 0.09976500f, 0.03255095f, 0.01206325f, 0.20339431f, 0.28172168f, 
    -0.05479401f, -0.00273458f, 0.03364657f, 0.09996346f, 0.04933448f, 0.02642634f, -0.00144818f, 0.01755267f, 
    -0.05156944f, -0.03192381f, 0.12635764f, 0.08457028f, 0.00080821f, 0.06351826f, -0.09973769f, 0.11794776f, 
    0.00791143f, 0.05293823f, 0.00976577f, 0.15081260f, -0.02805866f, -0.06082170f, -0.03332318f, 0.15866838f, 
    -0.05849386f, 0.05064461f, -0.02483067f, 0.08453631f, -0.00737600f, -0.03456795f, -0.06946362f, -0.06399170f, 
    0.09400564f, 0.03112933f, 0.01002505f, 0.16441733f, 0.06719279f, -0.06938811f, -0.01516794f, -0.12029134f, 
    -0.03978008f, 0.05656632f, 0.08368253f, -0.00018642f, -0.00743497f, 0.23621505f, 0.24388254f, -0.06164598f, 
    0.03066972f, 0.10289812f, -0.01927538f, -0.09741291f, -0.11507402f, 0.12771052f, 0.03576066f, 0.00786264f, 
    0.00735735f, 0.08203591f, 0.08365839f, 0.03987289f, 0.01644734f, 0.13268243f, 0.06620770f, 0.02392474f, 
    0.12552844f, -0.06649955f, 0.09208086f, 0.01733343f, -0.12428261f, -0.01254822f, -0.01050306f, -0.12324268f, 
    -0.00247467f, 0.03877397f, -0.07661214f, -0.02027065f, -0.08264956f, 0.05158335f, 0.03972147f, -0.06309310f, 
    0.04556059f, 0.11719056f, 0.14736359f, -0.21322444f, 0.11453528f, -0.05594361f, -0.05327037f, -0.09080645f, 
    -0.08689717f, 0.04339469f, 0.01410301f, 0.03009710f, -0.35012954f, 0.08064032f, 0.45974129f, -0.02713623f, 
    0.16294754f, 0.12412565f, -0.17968391f, 0.01868343f, 0.08885712f, -0.12010130f, 0.06311126f, 0.05403418f, 
    0.09625344f, -0.12518854f, 0.01949404f, 0.10485002f, 0.05260405f, 0.00682727f, 0.17213526f, 0.06008830f, 
    0.03547741f, -0.12770243f, -0.03618717f, 0.00687952f, 0.06104125f, -0.05668445f, 0.04602822f, 0.02935868f, 
    0.04377279f, -0.04072481f, 0.01518402f, 0.09288153f, -0.00841408f, 0.01456618f, -0.05455288f, -0.13009581f, 
    0.14934640f, 0.26469103f, -0.06207408f, -0.14565924f, -0.00740370f, -0.06775590f, 0.01689427f, 0.00916469f, 
    0.01840442f, 0.09257918f, 0.17948468f, 0.03759796f, -0.10891394f, 0.19249204f, 0.18855995f, 0.03196568f, 
    -0.08074204f, -0.02842773f, -0.05513115f, 0.08216793f, 0.04816885f, 0.00894038f, -0.11385690f, 0.03205428f, 
    0.02904163f, 0.01576160f, -0.23418976f, -0.10420843f, -0.06322736f, 0.00441374f, 0.02012790f, -0.05240781f, 
    -0.00123122f, -0.01982129f, -0.10861669f, 0.09794705f, 0.10320041f, -0.02730823f, -0.45942062f, 0.10795458f, 
    -0.10765466f, 0.12679295f, 0.05720541f, 0.05352011f, -0.04765962f, 0.04519531f, 0.01356682f, -0.08387895f, 
    -0.00608862f, -0.07775093f, 0.21089248f, -0.07845356f, 0.02323622f, -0.09142113f, 0.04813161f, 0.15801176f, 
    -0.02546541f, -0.05665934f, 0.07117610f, -0.00257462f, 0.25168189f, 0.13699816f, 0.17745003f, 0.15953128f, 
    0.01866952f, -0.12195079f, -0.02704894f, 0.09362010f, -0.01619113f, 0.20887545f, 0.07244334f, 0.04869607f, 
    -0.09316982f, 0.05460195f, -0.25126123f, 0.01631962f, -0.04160725f, 0.09981495f, 0.07742330f, -0.01486641f, 
    -0.00511577f, -0.05841090f, -0.00148957f, 0.03262054f, 0.00245167f, 0.04928893f, 0.21184775f, 0.23472553f, 
    0.08477912f, 0.04593182f, 0.13735341f, 0.15131229f, 0.12317222f, 0.14376645f, 0.02672364f, 0.02908735f, 
    0.20980150f, 0.10294981f, 0.20488754f, -0.12582277f, -0.02904164f, -0.01654290f, 0.01637562f, 0.09405804f, 
    -0.03263255f, -0.00750155f, 0.02479670f, 0.17738402f, 0.39073688f, 0.25865963f, 0.21198198f, 0.02624038f, 
    0.02361578f, -0.24326047f, -0.10191619f, 0.02804019f, 0.03234570f, 0.01019498f, -0.05341388f, 0.08096439f, 
    0.08109296f, 0.26028043f, 0.02936410f, 0.07275871f, -0.06385022f, -0.05090532f, 0.06955458f, -0.05259185f, 
    0.00911982f, 0.06433960f, 0.07005091f, 0.10740100f, -0.42666095f, 0.11719723f, 0.01441016f, 0.10133815f, 
    -0.16460270f, 0.06113054f, 0.09815757f, 0.03533660f, -0.10557783f, 0.09405267f, -0.00390666f, -0.06143575f, 
    -0.05377441f, 0.09209999f, 0.32576326f, 0.11565317f, 0.01448034f, 0.00830094f, -0.07606281f, 0.04006028f, 
    -0.00707941f, -0.02883537f, 0.01015429f, -0.01388861f, -0.06998456f, 0.08603088f, 0.12369000f, 0.37122434f, 
    0.15558694f, 0.10416454f, 0.04134962f, 0.01057634f, 0.08008637f, 0.10760756f, 0.06786218f, 0.11381216f, 
    -0.04028412f, 0.16576502f, 0.01434761f, 0.09291087f, 0.09086028f, 0.15682504f, 0.15926732f, 0.11156158f, 
    0.08751388f, -0.03408039f, 0.06124939f, -0.09315150f, 0.21815708f, 0.07136855f, 0.30725595f, 0.09534533f, 
    0.07202817f, -0.02679637f, 0.03079590f, 0.12168816f, -0.00628969f, 0.16747166f, 0.09873649f, -0.16994151f, 
    -0.09944260f, -0.18634692f, -0.14514156f, -0.02320674f, -0.13269773f, 0.10864463f, -0.00205112f, -0.01339998f, 
    -0.00116824f, -0.01880773f, 0.07484156f, -0.15312505f, -0.10544627f, -0.09894155f, -0.12771156f, -0.20354798f, 
    -0.17656299f, -0.01021542f, 0.16405521f, -0.03653830f, 0.11337177f, -0.00002835f, 0.03836279f, -0.05681127f, 
    -0.21676961f, -0.14853512f, 0.08012684f, 0.18337055f, 0.04548324f, 0.07024785f, -0.01032883f, 0.07877421f, 
    -0.01995360f, -0.02197784f, 0.08854856f, 0.02193738f, 0.20076148f, 0.15987203f, 0.14513083f, 0.14648043f, 
    -0.11976283f, -0.12285058f, 0.02532481f, 0.07751312f, 0.02650569f, 0.09044659f, -0.01420639f, -0.01521508f, 
    -0.14229411f, -0.06748484f, 0.11029817f, 0.17937933f, -0.02884471f, -0.05579928f, 0.00685345f, -0.01735424f, 
    0.12456703f, 0.04151728f, 0.01946964f, 0.03090539f, 0.24451070f, 0.30911797f, 0.08193034f, 0.14728197f, 
    -0.07670482f, -0.14404336f, 0.10403769f, 0.10297463f, -0.00090078f, 0.04109949f, 0.04726855f, 0.04964578f, 
    0.01633137f, -0.01935319f, 0.18857101f, -0.07172755f, -0.06531913f, 0.09111411f, -0.04269446f, -0.03377985f, 
    0.02265835f, 0.10623004f, 0.02130742f, -0.11007378f, 0.16476551f, -0.08512918f, 0.05809076f, 0.07974568f, 
    0.05836637f, -0.05107159f, 0.03040445f, -0.03505896f, 0.16177094f, 0.03359393f, 0.00972153f, 0.10797964f, 
    -0.02452714f, -0.14961867f, 0.18891817f, 0.08145640f, 0.01459195f, 0.12629154f, 0.06517234f, 0.07790230f, 
    -0.00898232f, -0.00863853f, -0.07563528f, -0.07769882f, 0.18155441f, 0.09661491f, 0.16071223f, 0.06553969f, 
    -0.07930592f, -0.07713010f, 0.07657123f, 0.07156381f, 0.07715266f, 0.02115543f, 0.14119904f, 0.01641443f, 
    -0.06789092f, 0.13473287f, 0.04213137f, -0.16162898f, 0.05343784f, 0.01163686f, -0.08360561f, 0.03378019f, 
    0.01615700f, -0.11545111f, -0.12496664f, -0.01456251f, -0.40001044f, 0.10772817f, 0.00937760f, 0.09999550f, 
    -0.23540927f, 0.00271098f, -0.06276442f, 0.06332645f, 0.00823347f, 0.13570972f, -0.07767396f, 0.12966385f, 
    0.01743011f, 0.12815368f, -0.00149918f, -0.05616892f, -0.04282953f, -0.05997981f, 0.01300773f, -0.05517801f, 
    -0.03631119f, 0.02524455f, 0.13649127f, 0.02585579f, -0.07025649f, -0.11323596f, 0.06860707f, -0.11293912f, 
    -0.00204220f, -0.03459262f, 0.09705519f, 0.03417941f, -0.07001194f, -0.08114694f, 0.03155123f, -0.08236255f, 
    -0.15173806f, 0.16860844f, 0.12760215f, 0.14756851f, 0.10126158f, -0.04938050f, -0.00850040f, 0.09012977f, 
    -0.01690111f, 0.10508672f, 0.07184632f, 0.05816805f, -0.08552238f, -0.19447313f, -0.09821139f, 0.11698315f, 
    -0.09553687f, 0.08888952f, 0.08962389f, 0.06420408f, -0.00703838f, -0.03741867f, 0.01921985f, -0.11534487f, 
    0.45620391f, 0.01091241f, 0.30130231f, 0.02407455f, -0.03422107f, 0.08878565f, 0.00143877f, 0.09775170f, 
    0.04838920f, -0.00609170f, 0.05076695f, -0.01523353f, -0.02320384f, -0.06144737f, 0.23913686f, 0.29179442f, 
    -0.04732566f, -0.09907548f, -0.02501114f, 0.17176192f, 0.01852990f, 0.00370224f, 0.01324956f, -0.03349331f, 
    0.00005129f, -0.23383084f, -0.44576973f, -0.09654456f, -0.01108354f, 0.15320286f, -0.07515103f, 0.13997439f, 
    0.05504481f, 0.01451274f, -0.15101211f, -0.14315444f, -0.08746633f, 0.12930126f, -0.09546621f, 0.09087040f, 
    -0.02734907f, 0.17898858f, -0.15475477f, 0.03251801f, 0.05784141f, -0.04087979f, -0.05600864f, 0.10815968f, 
    -0.26101854f, -0.13947152f, -0.01287754f, -0.17006801f, -0.02862226f, -0.04347147f, -0.07326037f, 0.04022347f, 
    0.09079961f, 0.02915739f, 0.01087915f, -0.12937592f, 0.15520906f, 0.13207021f, 0.14422260f, 0.07630228f, 
    0.02361852f, 0.07996871f, 0.03131832f, 0.00092782f, -0.07191086f, 0.01121451f, -0.05836361f, 0.06728588f, 
    0.03190277f, 0.04071321f, 0.01213518f, 0.02523697f, 0.10520542f, -0.01481500f, -0.05881664f, -0.02673816f, 
    -0.10371724f, -0.03833905f, -0.06753823f, -0.03387074f, -0.31072366f, -0.16657299f, -0.18254577f, -0.02441650f, 
    -0.09294938f, -0.14232101f, -0.07914796f, -0.09638768f, 0.18981637f, 0.10525824f, -0.14931343f, -0.09200728f, 
    -0.05412497f, -0.00296849f, -0.28724959f, 0.02953558f, 0.05340925f, -0.09469676f, -0.09519005f, -0.10620760f, 
    0.06095351f, -0.07316569f, 0.00319044f, -0.06596374f, 0.02609977f, -0.14710450f, -0.40784863f, 0.12427520f, 
    -0.03382962f, -0.03650263f, -0.05868649f, 0.09114578f, 0.08573312f, 0.04855917f, 0.03975115f, -0.14889555f, 
    -0.04367540f, 0.10868356f, 0.09937329f, 0.00323792f, -0.06597468f, -0.01088216f, -0.04689449f, 0.01475167f, 
    -0.15566699f, -0.05765956f, 0.12145786f, 0.02573142f, 0.04416461f, -0.04118578f, 0.00161532f, 0.03876276f, 
    0.04930360f, -0.09063515f, -0.08829434f, 0.01876702f, -0.13490447f, -0.21622139f, 0.04759694f, -0.08885082f, 
    -0.14217083f, -0.05096932f, -0.21050653f, -0.07208956f, -0.05466890f, -0.10224815f, -0.13873877f, -0.15616748f, 
    -0.08936410f, -0.02355589f, -0.00602597f, 0.02376610f, -0.07449749f, 0.16920862f, 0.09258963f, 0.03722679f, 
    0.00267483f, -0.02402227f, -0.04444735f, -0.05478602f, -0.23609276f, 0.02106899f, -0.04451450f, 0.00210183f, 
    0.12849481f, -0.34849143f, -0.29335198f, -0.07542069f, -0.04513586f, -0.11332650f, -0.06283084f, 0.16719045f, 
    0.12065618f, 0.31042132f, -0.01555531f, -0.07571299f, -0.09071062f, -0.11856594f, -0.19254106f, -0.06298476f, 
    0.04099802f, -0.10061398f, -0.26547113f, -0.04754071f, -0.11561477f, -0.12083059f, 0.07920063f, -0.06376965f, 
    0.11478936f, 0.12262405f, 0.08648304f, 0.10515598f, -0.02395351f, -0.00672134f, 0.05536873f, 0.00157084f, 
    0.02597446f, 0.04350011f, 0.00976820f, 0.04567378f, 0.07109165f, 0.09926894f, 0.03851171f, 0.10389373f, 
    0.02093915f, 0.04177177f, 0.01942474f, 0.02758297f, 0.02049982f, -0.10360002f, -0.03512441f, 0.02530413f, 
    0.02730117f, -0.03052216f, 0.04494784f, 0.09175561f, 0.01837470f, 0.03726696f, 0.05646237f, 0.09297303f, 
    0.12057445f, 0.04204737f, 0.19796497f, 0.17249367f, 0.08634985f, 0.04054848f, 0.06340002f, 0.06798320f, 
    -0.03766238f, -0.01574938f, 0.01892762f, 0.03481382f, 0.02615648f, 0.07041164f, 0.06831088f, 0.10663173f, 
    -0.08198383f, -0.04310974f, 0.14151025f, -0.03462332f, 0.03652099f, -0.05015659f, -0.19871178f, -0.12675305f, 
    0.07441704f, -0.03018103f, 0.02766382f, -0.08764493f, -0.02968013f, -0.15756547f, -0.06423051f, -0.26355159f, 
    -0.02817146f, -0.05829692f, -0.06863312f, -0.01911771f, -0.07192773f, -0.08232760f, -0.06313723f, -0.06423579f, 
    -0.04024056f, -0.04910513f, -0.12305009f, -0.05334658f, 0.01571958f, -0.13146476f, -0.14420860f, -0.12643605f, 
    0.18468621f, -0.13285421f, -0.12478942f, -0.14710325f, -0.24486731f, -0.00546951f, -0.28031421f, -0.13133849f, 
    0.13009191f, 0.02592701f, 0.02081446f, -0.02690161f, -0.08511229f, -0.11939164f, -0.07591196f, -0.06447320f, 
    -0.10277098f, -0.18397669f, -0.10245926f, -0.03128674f, 0.07622806f, -0.05536241f, 0.12985805f, 0.08715668f, 
    -0.07608330f, -0.01875374f, -0.05798088f, -0.07071520f, 0.02788455f, 0.05845793f, 0.26555020f, 0.20459847f, 
    -0.02441151f, 0.15432766f, 0.04447277f, 0.04606878f, -0.10732514f, 0.02040503f, -0.04484681f, 0.05434310f, 
    -0.02487228f, -0.10235474f, -0.16306740f, -0.06682435f, 0.06942628f, 0.04494283f, 0.05799119f, 0.09935133f, 
    0.03963659f, -0.14858676f, -0.01238413f, -0.04670717f, 0.02838570f, -0.03277889f, 0.14160185f, 0.04197022f, 
    -0.07004122f, 0.01405682f, 0.01249559f, 0.03975252f, 0.02548314f, 0.07610285f, 0.06946167f, 0.04946540f, 
    0.13570565f, 0.10615779f, 0.10136196f, 0.06641256f, 0.00636229f, 0.03911351f, 0.02220989f, 0.00851570f, 
    0.00755972f, 0.02704875f, -0.00694876f, -0.03479188f, 0.44881061f, 0.10734436f, -0.06905814f, 0.12806013f, 
    -0.04413018f, -0.00116105f, -0.07367557f, 0.05724540f, 0.24515070f, 0.09356314f, 0.00133602f, -0.09391065f, 
    0.13459662f, 0.20260584f, 0.00641927f, -0.13135779f, -0.03353723f, -0.02871826f, -0.14111654f, -0.06519012f, 
    -0.09377497f, -0.04310542f, 0.06713181f, -0.04817132f, 0.34769064f, 0.12783040f, 0.01444050f, 0.00677503f, 
    0.00029548f, 0.00241176f, -0.01258727f, -0.03332140f, -0.08898835f, -0.02731346f, 0.00366547f, -0.02527313f, 
    0.18068507f, 0.00518543f, -0.08114344f, -0.06480943f, -0.01535260f, -0.03608556f, 0.04033349f, 0.11811933f, 
    0.19428889f, 0.17504059f, 0.01638728f, 0.05617273f, 0.24419825f, -0.11217280f, 0.01467162f, -0.18232943f, 
    0.08124187f, 0.03233313f, -0.10179080f, -0.27685973f, 0.17132348f, -0.06792035f, 0.03532843f, -0.05854756f, 
    0.05320704f, 0.23956922f, 0.14512999f, 0.09072940f, -0.03578404f, -0.09126512f, 0.06909557f, 0.02826703f, 
    0.15548933f, 0.15859422f, 0.09945709f, 0.09416816f, 0.05378091f, 0.24126981f, 0.12935521f, -0.05662908f, 
    0.03277835f, -0.10653999f, 0.03203834f, 0.10597474f, -0.03118913f, 0.02735099f, 0.03284539f, 0.04905573f, 
    0.15935148f, 0.18742406f, 0.03694396f, 0.11579503f, -0.08553749f, -0.17796205f, -0.05917276f, 0.01525772f, 
    0.02706963f, 0.01128662f, -0.04850541f, 0.03002821f, -0.04928064f, -0.29986423f, -0.06141466f, -0.00998449f, 
    0.03271887f, -0.13446805f, 0.03428348f, 0.00175111f, 0.05588764f, -0.14069714f, -0.10520495f, -0.07159383f, 
    -0.22290097f, 0.05350089f, 0.07674888f, -0.06279875f, 0.03696720f, 0.14422435f, 0.05376789f, 0.12122135f, 
    -0.05318470f, -0.05903584f, 0.01469977f, 0.00442244f, 0.10978155f, -0.22734949f, -0.08004559f, 0.07151105f, 
    -0.03061436f, -0.03764519f, 0.00330101f, 0.01680124f, 0.23630829f, -0.08318102f, -0.05651761f, -0.14766914f, 
    0.18889943f, -0.06980068f, -0.01031035f, -0.10463286f, -0.08819951f, 0.02837790f, 0.05728701f, 0.02529451f, 
    0.06986319f, 0.05275730f, 0.04588026f, 0.01169803f, -0.29747796f, -0.03527253f, 0.01488175f, 0.05927823f, 
    -0.06933594f, 0.04528197f, -0.07031159f, 0.00544142f, -0.19537130f, -0.01581410f, 0.12040093f, 0.00983138f, 
    -0.30128932f, 0.08189938f, -0.04918019f, -0.25806627f, 0.09025911f, 0.04595912f, -0.07367145f, -0.16325375f, 
    -0.04703962f, -0.11544666f, 0.09799411f, -0.16080271f, -0.35005179f, 0.06716704f, -0.12003960f, -0.20526588f, 
    0.04483725f, -0.05179639f, 0.01197586f, -0.16025133f, 0.14479037f, 0.08058050f, 0.07382173f, -0.02577768f, 
    0.15321711f, -0.06185604f, -0.07706175f, 0.01072511f, 0.11038766f, -0.03434346f, -0.02066090f, -0.15313473f, 
    -0.15510666f, -0.13952415f, -0.13837603f, 0.03821152f, -0.17104830f, -0.08122437f, 0.02820051f, -0.14164990f, 
    -0.02971900f, -0.10813496f, 0.00068979f, -0.00746132f, 0.15699382f, -0.00100598f, -0.08498555f, -0.03741787f, 
    0.09909791f, 0.08163336f, 0.01334065f, 0.05797223f, 0.13011572f, 0.05074351f, 0.02230484f, -0.12063047f, 
    -0.06795877f, -0.03400114f, -0.03601994f, 0.02848144f, 0.10998228f, -0.24725701f, -0.11689408f, 0.01260952f, 
    0.15550981f, -0.11531547f, -0.12176008f, 0.07943217f, 0.16538183f, 0.20463324f, -0.09241375f, 0.07594038f, 
    0.17911081f, 0.03595465f, 0.13490741f, 0.05733623f, -0.03322337f, -0.09880875f, -0.00533746f, 0.00037107f, 
    -0.05880366f, -0.01315516f, -0.06418404f, 0.07341222f, 0.05504017f, 0.08415437f, 0.21517760f, 0.13391934f, 
    0.05750774f, 0.08279356f, 0.01021595f, 0.06160560f, -0.04078839f, 0.02541822f, 0.07251239f, 0.10902259f, 
    -0.06582983f, -0.16042522f, -0.39937225f, -0.19266620f, 0.14341992f, 0.15822276f, 0.03163695f, -0.06612823f, 
    0.00977858f, 0.00206102f, -0.06458998f, -0.06577920f, 0.41609150f, 0.13147600f, -0.25878301f, -0.08478270f, 
    -0.05073318f, -0.00813075f, -0.09222850f, 0.03029923f, 0.26924840f, 0.08822177f, 0.07993970f, -0.18861359f, 
    0.02839819f, -0.10922929f, -0.21132793f, -0.11401919f, 0.07540663f, -0.14779134f, -0.13000718f, -0.08449215f, 
    0.03107077f, 0.00202119f, -0.07759405f, -0.06558035f, -0.24811442f, -0.06978285f, -0.18667276f, 0.08625281f, 
    -0.06821828f, 0.02132255f, -0.05539396f, -0.05992061f, -0.05140685f, -0.23863995f, -0.05247958f, -0.23627724f, 
    0.01292504f, -0.01946477f, 0.01357438f, 0.04468931f, -0.05755157f, 0.04400971f, 0.04642268f, 0.10998992f, 
    0.17613240f, -0.14736201f, -0.18703625f, 0.05960238f, 0.05206116f, -0.13839601f, 0.03151562f, -0.05880398f, 
    0.12767117f, 0.09401737f, -0.13259196f, -0.18490517f, 0.12455755f, 0.20632835f, 0.06253744f, 0.11244178f, 
    -0.03865698f, 0.05748823f, -0.12941934f, -0.34559253f, 0.01573830f, -0.17284967f, -0.07153747f, -0.13747044f, 
    -0.12819241f, -0.09329717f, -0.05926670f, 0.04856587f, 0.23512389f, -0.00226336f, 0.08996979f, -0.01875449f, 
    -0.12147596f, 0.06446603f, 0.07599934f, -0.02143507f, -0.05503615f, 0.01732177f, -0.08421713f, -0.17525293f, 
    0.22560918f, 0.19464701f, 0.06978872f, 0.15614145f, 0.00741937f, 0.01344125f, 0.02794349f, 0.07131615f, 
    0.12074672f, 0.03460129f, 0.05211717f, 0.14324465f, -0.40637645f, 0.05643930f, 0.06139609f, -0.10913611f, 
    0.04793025f, 0.11703531f, 0.03488711f, -0.06398582f, 0.10078251f, 0.08344793f, 0.09855027f, 0.01743740f, 
    0.03849231f, 0.01157650f, 0.12330403f, 0.01788019f, -0.07663542f, 0.00569142f, 0.02917233f, 0.00398840f, 
    -0.06525017f, -0.12884666f, -0.04221641f, -0.03810911f, 0.03313176f, 0.00225442f, 0.03376486f, 0.00591278f, 
    0.05780918f, 0.03590791f, -0.07495941f, -0.04914509f, -0.10337317f, -0.00336164f, 0.00068457f, 0.00313453f, 
    0.05206252f, -0.18091868f, 0.16199182f, -0.06397374f, 0.10633566f, 0.01957590f, -0.04820248f, -0.02200677f, 
    0.18401521f, -0.03886083f, -0.03156752f, -0.07596119f, 0.00121571f, 0.03394109f, 0.03006049f, 0.03533701f, 
    0.02645467f, -0.02604322f, 0.00096566f, -0.02494108f, -0.04316530f, -0.05306417f, -0.02248093f, 0.02071680f, 
    -0.00875613f, -0.21529539f, 0.06451134f, 0.05240041f, -0.04166679f, 0.02133557f, -0.06011839f, 0.12388098f, 
    0.18304853f, 0.01276047f, -0.16405357f, 0.17210318f, 0.15635984f, -0.18358539f, -0.20917286f, -0.01531772f, 
    0.01498349f, -0.02121042f, -0.01568525f, -0.02025965f, -0.03115371f, -0.10230160f, -0.05510743f, -0.05845262f, 
    -0.00145219f, -0.03408557f, 0.00113386f, -0.03868257f, -0.03312625f, 0.02262008f, -0.00771599f, -0.03149321f, 
    -0.04071011f, -0.02660287f, -0.00912934f, -0.00438623f, -0.03927001f, 0.00782669f, -0.03046962f, -0.01738479f, 
    -0.03875233f, -0.03299431f, -0.00294974f, -0.01420427f, 0.01994282f, -0.00821911f, 0.01559822f, 0.02400619f, 
    -0.00068158f, 0.02645845f, -0.02737273f, 0.01459171f, -0.03900821f, -0.00010478f, 0.02462709f, -0.02667572f, 
    -0.04207548f, -0.02411349f, -0.04016097f, -0.01991136f, -0.01256976f, 0.02575364f, -0.00050927f, -0.02786060f, 
    -0.03637235f, 0.00301050f, -0.00956794f, -0.04084240f, 0.02715043f, 0.01001354f, -0.02539730f, 0.00090884f, 
    -0.04171548f, 0.01692201f, -0.00018151f, -0.00893004f, -0.01080898f, 0.00194744f, -0.00082111f, -0.01421306f, 
    0.00620414f, 0.01998411f, -0.02698707f, 0.01226439f, 0.00237243f, -0.04401524f, 0.00501147f, 0.03165150f, 
    -0.01164418f, 0.01920229f, -0.02120922f, -0.01088369f, 0.00483088f, -0.01037311f, -0.00501011f, 0.00987031f, 
    -0.03347263f, -0.01124007f, -0.00071991f, -0.02969984f, -0.01171519f, -0.04183828f, 0.02090499f, -0.00033179f, 
    -0.02289930f, -0.02810703f, -0.02946454f, -0.04336549f, 0.00244523f, 0.01521664f, 0.00824091f, -0.03115080f, 
    0.00609286f, 0.00704052f, 0.01500157f, -0.01502048f, -0.03439241f, 0.01834242f, -0.04215393f, -0.03294630f, 
    -0.01727246f, -0.02900783f, -0.02040150f, -0.03719639f, 0.01287201f, 0.01921121f, -0.02549385f, -0.02938395f, 
    -0.02041480f, -0.00205538f, -0.01524003f, 0.00648507f, -0.03743813f, -0.04092908f, 0.02418976f, 0.01244174f, 
    -0.01423782f, -0.03925708f, -0.04225691f, 0.00007604f, 0.00287515f, 0.00518383f, 0.01278810f, 0.00798444f, 
    -0.00365613f, 0.00663896f, -0.00564748f, 0.01490301f, 0.00814332f, -0.03540345f, 0.01295159f, 0.02143572f, 
    -0.01897068f, -0.03104482f, -0.01616979f, 0.00045893f, 0.02829633f, 0.01802698f, -0.03127922f, -0.03008397f, 
    -0.00454887f, -0.04382891f, 0.01547520f, -0.03208028f, 0.01316917f, -0.01295796f, 0.01625220f, -0.01755161f, 
    -0.02918856f, -0.03915598f, -0.03820829f, -0.03655924f, -0.02356186f, -0.02378192f, -0.00882096f, -0.04081685f, 
    -0.00687849f, 0.01216871f, 0.02223077f, -0.02864826f, -0.03396375f, -0.01428884f, -0.02503376f, -0.00047103f, 
    -0.04366558f, -0.01319691f, 0.01664738f, 0.01532483f, -0.00969277f, -0.00310685f, -0.00687391f, 0.00474521f, 
    0.00875755f, -0.03457923f, 0.01261008f, -0.02050673f, 0.02702426f, -0.00945258f, 0.01187083f, -0.04033481f, 
    -0.00773434f, -0.03827417f, 0.01384381f, -0.03849679f, -0.00466938f, -0.00283793f, 0.00098289f, -0.02275562f, 
    0.01786007f, -0.00852212f, -0.03426973f, -0.00274600f, -0.01201947f, 0.02036253f, -0.01248353f, -0.02696925f, 
    0.01083380f, 0.01604371f, -0.00083362f, 0.02046251f, 0.02219749f, -0.03571223f, -0.03619646f, -0.02460191f, 
    -0.02861472f, -0.03328037f, -0.03011633f, -0.01281347f, -0.01725051f, -0.02446545f, 0.00734536f, 0.01280676f, 
    -0.02107630f, -0.02603866f, 0.01908308f, -0.02615723f, -0.00987362f, 0.02238470f, 0.00936878f, -0.01573955f, 
    -0.00267579f, -0.01050274f, 0.01916259f, -0.00338308f, -0.03313975f, -0.01899161f, 0.01189464f, 0.01389541f, 
    -0.02659666f, 0.01430279f, 0.00206876f, -0.03917464f, -0.01128387f, -0.02212724f, -0.02032631f, 0.00662882f, 
    -0.01195777f, -0.03556658f, -0.02712091f, -0.03541806f, -0.04075361f, 0.02592474f, -0.03137155f, -0.03183543f, 
    -0.00246573f, -0.01965438f, -0.01849564f, -0.04329624f, 0.02774409f, 0.02332506f, 0.00976762f, -0.00297295f, 
    -0.00846510f, -0.01894682f, 0.00947707f, -0.03788313f, 0.01773098f, 0.02587471f, -0.03509213f, 0.02707236f, 
    -0.00926989f, 0.01766900f, -0.03543713f, -0.03688726f, 0.02428390f, -0.00331875f, 0.02013764f, -0.01806043f, 
    0.01053749f, 0.01303697f, -0.02147354f, -0.01954532f, -0.00207584f, 0.01146293f, -0.02811815f, 0.00699060f, 
    -0.04076041f, 0.00795195f, -0.00081012f, 0.00313364f, 0.01101116f, 0.01644730f, 0.01157454f, -0.03697866f, 
    -0.02561621f, 0.02150551f, 0.00560516f, -0.01849320f, -0.00720215f, 0.00265345f, -0.03974307f, 0.01922630f, 
    0.03289699f, 0.01324720f, 0.01152606f, 0.00733015f, 0.01074420f, 0.00186598f, 0.01697404f, -0.00327405f, 
    -0.00771285f, 0.02241327f, -0.01356633f, -0.04123051f, 0.02398725f, 0.00343249f, -0.02809723f, -0.00660911f, 
    -0.03583091f, 0.00411419f, -0.04116983f, 0.00385949f, -0.04110787f, 0.00173371f, 0.01934990f, 0.00741960f, 
    0.00945979f, 0.00541031f, -0.00812368f, -0.02579943f, 0.02868175f, 0.00893576f, 0.00330462f, -0.02695549f, 
    -0.02923306f, -0.01692094f, -0.01490542f, -0.02774370f, 0.00027665f, 0.01986572f, -0.01856439f, -0.02889225f, 
    -0.01823293f, -0.01540303f, 0.01065450f, 0.02622464f, -0.04017641f, -0.02460441f, 0.00524010f, 0.01622573f, 
    -0.03560249f, 0.01206234f, -0.00643171f, -0.03045135f, -0.01457144f, 0.01288074f, -0.01010238f, -0.01578002f, 
    0.00849761f, -0.02338278f, -0.03730416f, 0.02466571f, -0.00118454f, -0.00138678f, 0.00853278f, 0.01137188f, 
    -0.00348205f, 0.00304489f, 0.00055546f, 0.02973051f, 0.00374985f, 0.01106494f, -0.03416011f, 0.02747162f, 
    -0.03220448f, 0.01270614f, -0.00237864f, -0.02113295f, 0.01718512f, -0.01840288f, 0.00663753f, 0.00806683f, 
    -0.02412651f, 0.00574331f, -0.01466779f, 0.00333969f, -0.01826305f, -0.02428903f, 0.01698327f, -0.00741267f, 
    0.00345630f, -0.01823381f, 0.01979240f, -0.01253226f, -0.01581946f, -0.03918798f, -0.02895916f, -0.01496203f, 
    0.00726046f, -0.03386823f, 0.00977661f, 0.00679050f, -0.00665770f, -0.03120754f, -0.02755301f, 0.00571030f, 
    0.02402133f, -0.01729908f, -0.03500502f, -0.01637031f, -0.00092999f, -0.04266868f, -0.03038519f, -0.01891044f, 
    -0.00339732f, -0.01741019f, 0.00887329f, -0.02548609f, -0.02305518f, 0.01774916f, -0.04045722f, 0.01071456f, 
    -0.00601075f, 0.01340114f, -0.00549758f, -0.02940959f, -0.04192815f, 0.01596200f, -0.03059829f, 0.00719186f, 
    0.01099765f, -0.04243282f, 0.02322095f, 0.02283779f, 0.01409669f, 0.03157991f, 0.01100678f, -0.00463209f, 
    -0.00038461f, -0.03288031f, -0.00469480f, 0.01785959f, -0.02138170f, 0.02215436f, -0.00300717f, -0.02278679f, 
    0.01621956f, -0.01259353f, -0.02007475f, 0.01995280f, 0.00634860f, 0.01489409f, -0.00069608f, 0.01922914f, 
    0.00187055f, -0.03231211f, 0.00623896f, 0.02712003f, -0.00445057f, -0.01800033f, -0.03292967f, -0.02030979f, 
    -0.03013100f, -0.02414519f, -0.02319150f, 0.01595210f, 0.01529448f, -0.03464679f, -0.01025907f, -0.02851382f, 
    -0.02199744f, 0.00815350f, -0.04275091f, -0.00958925f, 0.01644348f, -0.02987654f, 0.00526146f, 0.02390032f, 
    0.02254288f, -0.02418698f, 0.01678987f, 0.00871076f, -0.01499497f, 0.01581032f, 0.00247403f, 0.01297165f, 
    0.01335728f, 0.01231610f, -0.00222152f, -0.00130438f, -0.02652423f, 0.02163433f, 0.01517427f, 0.02214259f, 
    -0.01461379f, 0.01898724f, 0.01240090f, -0.01658457f, 0.01803945f, -0.03224890f, -0.00926357f, -0.01770440f, 
    -0.01343032f, -0.02653808f, 0.00111217f, -0.00548097f, 0.02560056f, -0.02153398f, 0.01707747f, 0.02451151f, 
    -0.01046802f, -0.03944212f, 0.00720396f, 0.00764332f, 0.01050255f, -0.00710419f, -0.04137634f, 0.02069683f, 
    -0.00891069f, -0.01897229f, -0.00852652f, -0.02562347f, -0.03255457f, 0.00076083f, 0.01416313f, -0.02175861f, 
    0.01294938f, -0.04346525f, -0.03524545f, 0.01964438f, -0.02822241f, -0.03897144f, -0.00549826f, 0.02417480f, 
    -0.01946535f, -0.02786724f, 0.01217937f, 0.02260141f, 0.00708392f, -0.00985275f, -0.04145164f, -0.01029045f, 
    -0.03407218f, -0.04255484f, 0.01564218f, -0.01059876f, -0.01273259f, -0.04213570f, -0.04454510f, 0.02444788f, 
    -0.02863619f, 0.01719921f, 0.01999884f, -0.04334496f, -0.01601274f, -0.02641549f, -0.00117822f, -0.01759927f, 
    -0.00399006f, 0.00133024f, -0.03142114f, -0.03979799f, 0.01344947f, 0.01374982f, -0.04237767f, -0.00220426f, 
    -0.02802316f, 0.02798186f, -0.00264927f, -0.03821658f, 0.01010949f, 0.02483561f, -0.02839235f, 0.02100860f, 
    -0.00620068f, 0.01142565f, -0.00809938f, 0.02506033f, 0.00907815f, -0.02850932f, 0.02234321f, -0.03792337f, 
    0.02580884f, 0.00670525f, -0.00815862f, 0.00838309f, 0.02133109f, -0.02006816f, -0.04423591f, -0.01100639f, 
    -0.02977730f, 0.02622444f, 0.02189924f, 0.01406325f, -0.02242107f, -0.03515140f, 0.01989167f, -0.00344531f, 
    -0.00022334f, -0.02466268f, -0.02192458f, -0.04284261f, 0.00151324f, -0.04202126f, -0.01597429f, 0.01877728f, 
    -0.00910373f, -0.01939613f, -0.01815630f, -0.02477012f, -0.03792198f, 0.00966155f, 0.01376764f, -0.01511071f, 
    -0.02329105f, -0.02468123f, -0.00422313f, -0.00484224f, 0.01766201f, 0.01550304f, -0.00178376f, -0.00666215f, 
    -0.01722522f, -0.02886996f, -0.02022069f, -0.02809736f, 0.02741824f, 0.02862567f, 0.01682862f, -0.03125005f, 
    -0.02179006f, -0.02415873f, -0.01260038f, -0.02763642f, 0.01578860f, -0.03232972f, -0.02678376f, -0.03890526f, 
    -0.00795711f, 0.01464356f, -0.03263459f, -0.04008247f, -0.03827348f, -0.03746107f, -0.03660266f, 0.00983314f, 
    -0.00738058f, -0.01506470f, -0.00525869f, -0.01622776f, -0.02270837f, 0.00561332f, -0.02615789f, 0.00454769f, 
    0.00295718f, 0.00503837f, -0.04407210f, -0.02249794f, -0.02105724f, -0.01309451f, -0.02862393f, -0.00826559f, 
    -0.00430911f, -0.03389905f, -0.04197361f, -0.01460194f, 0.02555958f, -0.03391183f, -0.00482358f, -0.03212667f, 
    0.00415221f, 0.01844378f, -0.02847470f, -0.01068394f, -0.01795788f, 0.02159694f, 0.02045782f, 0.01235281f, 
    -0.03077994f, -0.01879590f, -0.00087079f, -0.00126313f, -0.01145910f, 0.01947192f, 0.01157973f, -0.01531966f, 
    -0.02536212f, 0.02736462f, -0.01493181f, -0.03359378f, -0.02983821f, -0.00237040f, 0.00784911f, -0.02420537f, 
    -0.03645363f, -0.00601316f, -0.00341469f, -0.01887264f, -0.04255427f, -0.02748374f, 0.02227189f, -0.02985027f, 
    0.01777335f, -0.01222364f, -0.01919365f, -0.03428960f, -0.00777244f, -0.00450899f, -0.02389689f, 0.00301236f, 
    0.02978899f, 0.02839357f, -0.01076051f, 0.00245156f, 0.02213356f, 0.00567268f, 0.02355900f, -0.02410333f, 
    0.01434035f, 0.00556609f, -0.02107055f, -0.01408412f, 0.02187454f, -0.02394801f, -0.00792949f, -0.02645169f, 
    -0.02450104f, -0.03301287f, 0.02469422f, -0.02516815f, -0.01478084f, -0.02801883f, 0.02178422f, -0.01475974f, 
    -0.02274005f, -0.00911395f, 0.00573275f, 0.00511172f, 0.02160226f, -0.02262296f, -0.01529753f, 0.00079093f, 
    -0.01507451f, 0.00092897f, 0.01435027f, -0.00883752f, -0.01800626f, -0.01445358f, -0.01953636f, -0.01161049f, 
    -0.01020299f, 0.02263112f, 0.02775287f, -0.02630148f, 0.02351855f, -0.03099931f, -0.02500139f, 0.02083373f, 
    0.00398710f, -0.01443637f, -0.03038228f, 0.01394673f, 0.00678226f, -0.01026297f, -0.03159264f, 0.02533462f, 
    0.00327929f, 0.02276391f, 0.00033050f, -0.02406619f, -0.03047191f, -0.00257604f, 0.01126527f, 0.02351981f, 
    -0.00485655f, -0.02876993f, 0.01639924f, -0.00279667f, 0.00130412f, 0.00582068f, 0.01480637f, 0.01359700f, 
    0.03039016f, -0.03009705f, -0.03816086f, -0.02319478f, -0.01586311f, -0.04064654f, 0.01322322f, -0.03880664f, 
    -0.01677041f, 0.00165256f, -0.02553964f, -0.01927714f, 0.01602016f, -0.03270459f, 0.02650960f, -0.02663267f, 
    -0.01805843f, 0.00928035f, -0.02122729f, 0.02415916f, -0.02389551f, 0.00582380f, -0.02685129f, -0.00204033f, 
    -0.03324088f, 0.03063604f, -0.03731951f, 0.01379705f, 0.00226954f, 0.00749450f, 0.00819590f, 0.00369039f, 
    -0.01264118f, -0.01284454f, -0.02462535f, 0.01768820f, 0.01847203f, -0.00985863f, -0.02811794f, -0.01423553f, 
    -0.00000687f, -0.02238201f, -0.04087439f, -0.03458130f, -0.03537981f, -0.01803846f, -0.01119012f, 0.01333686f, 
    0.02104079f, 0.02754381f, 0.03316481f, 0.00158632f, -0.03395607f, 0.01574487f, -0.03622056f, 0.02898689f, 
    -0.04296582f, 0.01934628f, -0.01417188f, 0.00878379f, -0.02187491f, 0.03016483f, 0.01794265f, 0.03123339f, 
    -0.00717837f, -0.00549608f, -0.01191138f, -0.04173256f, -0.03366459f, 0.00646760f, -0.02301296f, -0.02418968f, 
    -0.04274800f, -0.01659300f, -0.02937899f, 0.01653556f, 0.02187470f, 0.03035674f, -0.00690243f, 0.00257733f, 
    -0.00615460f, 0.00085659f, -0.02416283f, 0.00095560f, 0.02713107f, -0.00010571f, 0.02515954f, 0.00332124f, 
    0.01094531f, -0.04155720f, -0.04239411f, -0.02217296f, -0.01431419f, 0.00181243f, 0.00959850f, -0.03671472f, 
    0.02081818f, 0.00625811f, -0.00899327f, 0.01002514f, -0.03064689f, -0.03040529f, -0.02198454f, 0.00837168f, 
    -0.00098192f, 0.00116170f, 0.01453878f, 0.02556287f, 0.02027079f, -0.00394090f, -0.03005937f, 0.03183809f, 
    -0.03518283f, -0.00613726f, 0.02193999f, -0.01223734f, -0.03105100f, 0.02332544f, -0.02044671f, -0.01457750f, 
    -0.02867938f, -0.00493245f, 0.01263473f, -0.01744154f, -0.00120202f, -0.00233258f, 0.02239486f, 0.00778503f, 
    0.00057659f, 0.00471547f, 0.01981307f, 0.01720300f, 0.02557868f, -0.00792962f, 0.01515703f, 0.02815979f, 
    0.02518300f, -0.02268579f, 0.00776899f, -0.00817558f, 0.00047789f, -0.03420507f, -0.03965482f, 0.01950009f, 
    0.02544031f, -0.01816798f, -0.03292148f, -0.02139810f, -0.00971064f, -0.02505458f, -0.02844121f, 0.01117211f, 
    -0.03821129f, -0.02642007f, -0.01367235f, -0.03939069f, -0.02068736f, 0.02683412f, -0.03565796f, -0.04208744f, 
    -0.02662774f, -0.00769590f, -0.03043722f, 0.01511263f, -0.02368714f, -0.02727272f, -0.00550812f, 0.00081079f, 
    -0.00720712f, -0.03887984f, 0.00574902f, -0.03358929f, -0.01382595f, -0.01397232f, 0.02803067f, 0.02905751f, 
    0.01870598f, -0.00380331f, -0.01926808f, -0.00697668f, -0.04231462f, 0.01987353f, -0.01136656f, -0.01406065f, 
    0.00476743f, 0.01847357f, 0.00335605f, -0.01068630f, 0.02654769f, 0.02142164f, 0.01130882f, -0.02416114f, 
    -0.03934994f, -0.03093205f, -0.02916122f, 0.01811627f, 0.01900602f, 0.03063844f, 0.01560287f, -0.01450949f, 
    -0.03372440f, 0.01509175f, -0.03796559f, 0.02687231f, 0.00256366f, 0.02708599f, 0.02535212f, -0.02137583f, 
    0.02693379f, -0.03276718f, -0.00676256f, 0.00459729f, 0.02221437f, 0.00349423f, 0.01720440f, 0.01957447f, 
    -0.01452991f, -0.02786265f, -0.00181614f, 0.01282204f, 0.00130596f, -0.01947843f, 0.01644874f, 0.02404413f, 
    0.02966607f, -0.01665694f, 0.00900635f, -0.03290796f, 0.02743492f, 0.02855367f, 0.01271695f, 0.00141193f, 
    0.00292374f, -0.02414629f, 0.00850379f, 0.02362056f, -0.01713907f, -0.02513981f, 0.00475684f, 0.02514227f, 
    -0.02721284f, 0.00948553f, -0.00016043f, -0.01212713f, -0.03691762f, 0.01706845f, -0.04245380f, 0.01962025f, 
    -0.01886052f, 0.00883794f, 0.01468777f, -0.03613429f, -0.00110967f, 0.00269969f, 0.02363212f, -0.01005805f, 
    0.02842835f, 0.00498817f, 0.00043330f, 0.02240098f, 0.00613871f, -0.03548590f, 0.00000102f, -0.00367662f, 
    0.02846230f, -0.00957898f, 0.02062469f, 0.00265220f, 0.00991301f, -0.02664643f, -0.01215440f, -0.00036686f, 
    0.01849258f, 0.01919064f, 0.02612929f, -0.01902130f, -0.00616510f, -0.00025082f, 0.00041368f, -0.02724459f, 
    0.00982583f, 0.00228408f, -0.02060925f, 0.01952638f, -0.03403887f, 0.00707877f, 0.01366746f, 0.01172517f, 
    0.00610581f, 0.00173798f, -0.01166006f, -0.01469532f, -0.01984639f, -0.00016649f, 0.00455763f, -0.03064361f, 
    0.00636804f, -0.02970749f, -0.02388158f, -0.03886498f, -0.01164199f, 0.00556693f, 0.01398038f, -0.03017178f, 
    0.00821573f, -0.01108719f, -0.01636931f, 0.01280994f, -0.00253561f, -0.00669395f, -0.02613183f, 0.02299944f, 
    0.02402738f, 0.01499934f, -0.00949704f, -0.01289002f, 0.00964882f, -0.02305607f, 0.03630908f, -0.02759134f, 
    0.02779868f, 0.01587070f, -0.04148531f, 0.00848130f, 0.02725849f, -0.02333768f, 0.01592498f, 0.01323292f, 
    -0.03328627f, -0.03980681f, 0.01942877f, 0.01090825f, -0.03215842f, -0.01374510f, -0.03173114f, -0.00482278f, 
    -0.03430396f, -0.03160766f, 0.02033336f, 0.01359974f, 0.01747780f, -0.00970414f, -0.03596994f, -0.03879830f, 
    0.00864133f, 0.00510453f, -0.02142125f, -0.01784862f, 0.01804734f, 0.00125067f, -0.01947497f, -0.03227650f, 
    -0.02046897f, -0.00766695f, 0.01468186f, 0.02376730f, -0.03318694f, -0.03169134f, -0.00208838f, -0.01317825f, 
    0.02986015f, 0.00009158f, -0.00858235f, -0.01328037f, -0.00769106f, 0.02123311f, -0.02797835f, 0.00637100f, 
    -0.00615973f, -0.02035091f, -0.03654482f, 0.02372951f, -0.03169388f, -0.01804014f, -0.02359803f, -0.03515157f, 
    -0.00023170f, -0.02845012f, -0.02170869f, -0.03031048f, -0.03605787f, -0.02006316f, -0.02216001f, -0.00758833f, 
    0.02489122f, -0.00827558f, -0.02368484f, -0.04030634f, -0.03364642f, -0.02866167f, -0.01386783f, 0.01608137f, 
    -0.02448039f, -0.00602441f, 0.01136188f, 0.00929753f, 0.00000807f, -0.03613972f, -0.01949403f, 0.00940152f, 
    -0.03823618f, -0.02485502f, -0.00744926f, 0.01950010f, 0.02002571f, -0.01351286f, 0.01214355f, 0.02175088f, 
    -0.03170192f, -0.00031503f, -0.01161884f, -0.01887536f, 0.02619513f, -0.03146797f, -0.01372140f, 0.01494768f, 
    -0.02241389f, 0.01058604f, -0.02558672f, 0.02153810f, -0.02810131f, -0.04207185f, -0.01395177f, 0.02286222f, 
    0.02439897f, 0.01281899f, -0.03587589f, -0.03901016f, 0.00784411f, 0.02160739f, 0.02528474f, 0.00951260f, 
    0.00623423f, -0.01734444f, 0.01846787f, 0.03141110f, -0.03999700f, -0.02270707f, 0.02433498f, 0.02706731f, 
    0.01478134f, 0.02123873f, 0.02000937f, 0.00961946f, 0.01228927f, 0.00636376f, -0.00333798f, -0.00054406f, 
    0.02219223f, 0.02354716f, -0.01386082f, -0.00518917f, 0.01441074f, -0.02087070f, -0.00477873f, -0.00263025f, 
    0.02442718f, -0.03189031f, 0.01249075f, 0.00431848f, 0.01519221f, -0.04231047f, -0.01952466f, -0.01665213f, 
    -0.03767139f, 0.03398578f, -0.02502637f, -0.01441293f, -0.02580991f, -0.00636531f, -0.02616674f, -0.03324953f, 
    -0.01002363f, 0.01514587f, 0.01363429f, -0.02388814f, 0.00454104f, 0.02775882f, -0.03937805f, -0.04117415f, 
    -0.00697807f, -0.01189802f, 0.02346196f, -0.01041336f, -0.00192693f, -0.02720273f, -0.00836975f, 0.01894898f, 
    0.01276576f, -0.02590490f, -0.01617655f, -0.03952688f, -0.01320087f, 0.00707810f, -0.01243539f, -0.02836582f, 
    -0.00217978f, 0.01374684f, -0.02367653f, -0.03661860f, 0.00514600f, -0.03153938f, 0.01825410f, 0.00679305f, 
    -0.00092451f, 0.01885941f, -0.01941594f, -0.02418954f, -0.01819879f, 0.00535337f, 0.00744144f, -0.02737588f, 
    -0.02308039f, -0.04252387f, 0.01629943f, 0.01542167f, -0.03269181f, -0.03763052f, -0.01186149f, 0.02727970f, 
    0.01237588f, -0.00110680f, -0.02904400f, -0.01908703f, -0.00623900f, -0.00742461f, -0.01442583f, -0.03885838f, 
    0.02995598f, -0.01559529f, -0.00712429f, -0.00017200f, 0.01642211f, -0.00341118f, -0.03915734f, 0.01785783f, 
    0.02553410f, -0.00367156f, -0.01654702f, 0.00635896f, -0.01668082f, -0.01363668f, -0.00447634f, -0.01353045f, 
    0.01945650f, -0.03529943f, -0.01525040f, -0.02733324f, -0.00963512f, -0.02675423f, -0.04418452f, -0.03762176f, 
    -0.01987824f, 0.01398993f, -0.01038331f, 0.01850638f, 0.00786453f, -0.03095300f, 0.00668349f, -0.03335112f, 
    0.00860611f, 0.01753906f, -0.01243207f, -0.00181576f, -0.04174362f, -0.01135731f, -0.00897591f, 0.00446805f, 
    -0.02089049f, -0.01590671f, 0.00232233f, 0.02078122f, 0.03072732f, 0.00310135f, -0.01159502f, 0.00684833f, 
    0.00083225f, 0.03768983f, 0.03139257f, -0.02740160f, -0.03137038f, 0.01996989f, 0.01872349f, -0.01496848f, 
    0.01397528f, -0.02762114f, -0.03895498f, -0.02320541f, 0.02379315f, -0.02256827f, -0.02275997f, 0.02040149f, 
    -0.02940957f, 0.01739040f, 0.00729534f, -0.01518105f, -0.02750528f, 0.01534350f, -0.01379676f, -0.00713797f, 
    -0.00844751f, 0.03424865f, -0.03817327f, -0.03464773f, 0.00154755f, 0.01945867f, -0.03822729f, 0.02516068f, 
    0.01650332f, -0.01703584f, -0.00860014f, -0.01872907f, 0.01439887f, -0.00777016f, -0.00741549f, -0.00124478f, 
    0.00677258f, -0.04102355f, 0.00615982f, 0.01595895f, -0.02957996f, -0.01857726f, -0.03996198f, -0.03810627f, 
    -0.02552352f, -0.01014870f, -0.00311624f, -0.00764229f, -0.00466044f, -0.02479107f, -0.02281170f, -0.02627030f, 
    -0.00086486f, -0.03808725f, -0.04208478f, -0.03795313f, 0.02245308f, 0.02874775f, -0.02004768f, 0.02847178f, 
    0.02765579f, 0.03210583f, 0.01823191f, -0.02042586f, 0.01414637f, -0.00470487f, 0.03158588f, -0.02926342f, 
    -0.00386023f, 0.00052668f, -0.03345928f, -0.04150925f, 0.02633474f, -0.01586055f, 0.00042646f, -0.00255416f, 
    0.00965203f, -0.03327336f, 0.01331684f, -0.00295412f, 0.02048650f, -0.02466791f, -0.02587587f, -0.04039420f, 
    -0.02342900f, -0.00373798f, 0.02713630f, -0.02243304f, 0.00589604f, -0.00977885f, -0.01164431f, 0.00969775f, 
    -0.00485725f, -0.04181404f, 0.01273459f, 0.02087404f, -0.00292646f, -0.01151079f, -0.01877059f, -0.00888010f, 
    0.02296884f, -0.01408614f, -0.02924553f, 0.02110969f, -0.00770538f, 0.01188498f, 0.00957564f, -0.03265294f, 
    0.00540971f, 0.02319689f, 0.02112236f, -0.01629468f, 0.00876186f, 0.01767884f, -0.04034665f, -0.03384926f, 
    -0.00471670f, -0.00512592f, -0.01055838f, 0.01116688f, -0.00361657f, 0.00790946f, 0.00137648f, -0.01778268f, 
    -0.03722610f, -0.01015338f, 0.00946667f, -0.00802003f, -0.02227377f, -0.01125630f, 0.03290226f, 0.03211811f, 
    -0.02066521f, -0.01287144f, -0.00241400f, -0.00135569f, 0.02519307f, -0.03626331f, -0.00649849f, -0.00206909f, 
    0.03570190f, -0.00281103f, -0.03306171f, -0.04055978f, -0.04397871f, 0.03179824f, 0.00905327f, -0.01341819f, 
    -0.00542323f, 0.01351057f, -0.01803255f, -0.04328094f, -0.03662218f, -0.03294904f, -0.01673099f, 0.01626786f, 
    0.01650103f, 0.01108400f, 0.01932721f, 0.01978258f, 0.00050378f, 0.02707088f, 0.00589028f, -0.03229630f, 
    -0.02771934f, -0.02939592f, 0.00081766f, -0.03593927f, 0.02267198f, -0.01213552f, 0.01753358f, -0.02678683f, 
    -0.02317577f, 0.02938219f, -0.01800837f, 0.02732444f, 0.01623600f, -0.02376398f, 0.01226871f, -0.01508451f, 
    -0.00589252f, 0.00223911f, -0.03420007f, 0.00548907f, -0.02175710f, -0.03916847f, 0.01615640f, 0.02634281f, 
    -0.01209957f, -0.02213359f, 0.00543052f, -0.03797792f, -0.00161182f, -0.02898139f, -0.00362117f, -0.03256123f, 
    -0.01401734f, -0.00886489f, 0.02720289f, -0.03829498f, 0.01691383f, -0.01435578f, 0.02219017f, -0.00143239f, 
    0.01541960f, -0.02511525f, 0.01608052f, -0.01893435f, -0.02477510f, -0.03892309f, -0.00964318f, 0.01139786f, 
    0.01744365f, 0.00913676f, -0.00814306f, 0.00661531f, 0.01958768f, -0.01764836f, 0.00165037f, -0.01382250f, 
    0.02389055f, 0.02160525f, 0.02076242f, 0.02956259f, 0.00233531f, -0.00247357f, 0.00144808f, -0.00246575f, 
    -0.04413029f, -0.00722355f, 0.00502342f, 0.01917099f, -0.01546056f, -0.01697953f, 0.00659950f, 0.01156678f, 
    -0.04880747f, -0.04097786f, 0.02385890f, -0.01512749f, 0.01535899f, -0.03290477f, -0.02078961f, 0.02083732f, 
    -0.04199893f, -0.01381256f, 0.00885284f, 0.02344670f, -0.00641825f, -0.00052935f, 0.00718285f, -0.02974469f, 
    -0.00136800f, -0.02008800f, -0.01993440f, -0.01550720f, 0.02096052f, -0.00454466f, 0.01683138f, -0.03860550f, 
    -0.00369819f, 0.02404592f, 0.02959279f, -0.01218245f, -0.02215948f, 0.01709446f, -0.01908524f, 0.02825394f, 
    0.01604392f, 0.02619760f, -0.00095491f, 0.02402051f, -0.00930836f, 0.02421985f, 0.00268921f, 0.01162642f, 
    -0.00845047f, -0.03104218f, -0.02471728f, 0.02169413f, -0.01378161f, -0.02530686f, 0.01112837f, -0.01088830f, 
    -0.01368598f, 0.00379281f, 0.00658615f, 0.02324129f, -0.00805391f, -0.03450700f, -0.02344431f, 0.02438294f, 
    -0.03294422f, -0.03396681f, -0.00687604f, -0.02914469f, -0.04137162f, 0.02689811f, -0.02842286f, 0.02878841f, 
    -0.00711677f, -0.04480326f, 0.01465038f, -0.02730800f, -0.01500372f, -0.00892315f, -0.00965332f, 0.00462366f, 
    0.02456458f, -0.02169407f, 0.01615755f, 0.02972871f, -0.03711735f, 0.00117215f, 0.01517741f, 0.02492146f, 
    0.00582629f, -0.01418316f, -0.02395829f, -0.03213320f, -0.00140311f, 0.00527584f, -0.02568967f, 0.00895593f, 
    -0.02881753f, -0.00211529f, -0.01754252f, 0.00566680f, -0.04394462f, 0.02807541f, -0.03101318f, -0.01829417f, 
    -0.01054252f, -0.01961138f, -0.04050788f, -0.02053116f, 0.00823773f, -0.03527777f, 0.02078547f, -0.03085959f, 
    -0.01849538f, -0.01571231f, 0.03040828f, 0.01678277f, 0.03094270f, 0.02100242f, -0.02092204f, -0.00230248f, 
    0.03095799f, -0.00859052f, 0.00334834f, 0.00564379f, -0.03370513f, -0.02767617f, -0.03499880f, -0.02769854f, 
    -0.00150508f, -0.04038038f, -0.01007853f, 0.01395103f, 0.00297350f, -0.01900177f, -0.03807654f, -0.04011364f, 
    -0.00442961f, -0.04026795f, -0.03304831f, 0.00779671f, -0.01944430f, -0.02247246f, 0.02360733f, -0.03231812f, 
    0.00017891f, -0.00197898f, -0.01399109f, 0.00691700f, -0.02351406f, 0.00874804f, -0.02876993f, -0.03817016f, 
    -0.02333147f, 0.00960277f, -0.00903463f, -0.00944174f, -0.04303886f, 0.00204542f, 0.00154946f, 0.00015785f, 
    -0.01812848f, -0.02480749f, -0.02538570f, 0.01890392f, -0.02113381f, -0.04149932f, -0.00479634f, -0.03642898f, 
    0.01934328f, 0.00728906f, -0.01770699f, -0.00502764f, -0.03441571f, -0.02739975f, 0.02372735f, 0.00628784f, 
    -0.01441431f, 0.03036380f, 0.03266137f, 0.02343977f, -0.01691240f, 0.02288000f, -0.01751105f, 0.01195872f, 
    0.00035499f, -0.03902458f, -0.00615537f, 0.00141596f, -0.01219929f, -0.02796094f, 0.02357519f, 0.01430399f, 
    -0.01923291f, -0.00350836f, -0.00351525f, -0.00012289f, -0.01702493f, -0.02644170f, 0.00952364f, -0.02460592f, 
    -0.02991413f, -0.01787869f, 0.02984609f, -0.01409201f, 0.02804897f, 0.01933574f, -0.00662835f, -0.04370649f, 
    0.00478837f, -0.00832717f, -0.01793176f, -0.04296876f, 0.01632353f, -0.02865183f, -0.01670787f, -0.00079065f, 
    0.01709825f, 0.02626924f, 0.01936181f, -0.02972751f, -0.04021950f, 0.01995281f, -0.02737170f, -0.01543419f, 
    -0.02545492f, 0.01674966f, 0.01852307f, 0.03198377f, -0.01161794f, -0.00968910f, -0.01945230f, -0.02164854f, 
    -0.03330971f, -0.00972794f, -0.03979465f, -0.00262196f, -0.00685013f, -0.04051071f, -0.03392075f, -0.02156758f, 
    -0.00752625f, -0.00916930f, -0.00662030f, -0.03611446f, 0.00315911f, 0.00781520f, 0.01712035f, -0.02969152f, 
    -0.01747279f, 0.00577954f, -0.02896889f, -0.00599376f, 0.02441079f, -0.03683733f, -0.03708035f, 0.01484370f, 
    -0.00713193f, 0.02758722f, -0.03368422f, -0.04022508f, 0.01124401f, -0.04092352f, -0.00224124f, -0.03884688f, 
    0.01173693f, 0.01946032f, -0.00145497f, 0.00646347f, -0.02933488f, 0.01075630f, -0.04242161f, 0.01723995f, 
    -0.03407085f, -0.01585883f, 0.02719557f, 0.01595339f, -0.02916974f, -0.03698962f, 0.01369341f, 0.00815512f, 
    -0.02233947f, -0.01848490f, -0.01101381f, -0.03712483f, -0.00447099f, -0.03694967f, -0.03441737f, 0.04147338f, 
    0.01009133f, -0.00423540f, -0.03926228f, -0.01172282f, -0.02315209f, 0.02173047f, 0.01476359f, -0.02048815f, 
    0.02087144f, 0.02227121f, 0.00379749f, -0.02662959f, -0.03847724f, 0.01079680f, -0.03418314f, 0.01877431f, 
    -0.00855436f, -0.00013251f, -0.02350378f, -0.02291314f, -0.00744834f, -0.02598358f, 0.00601605f, -0.01223597f, 
    -0.00145985f, -0.02003309f, -0.00746756f, -0.03608689f, -0.01807690f, 0.02829541f, 0.01154239f, -0.03271254f, 
    -0.00945564f, -0.01056659f, 0.02268784f, 0.00160286f, -0.03654663f, -0.01449496f, 0.00179944f, -0.01321750f, 
    0.00636084f, -0.01492970f, -0.03941425f, -0.02179901f, -0.01502011f, -0.01782351f, -0.02919974f, 0.01845030f, 
    -0.02243496f, -0.00516996f, -0.01976249f, 0.01027624f, -0.04075167f, 0.00337627f, 0.01254966f, -0.00050270f, 
    0.01806141f, 0.01372807f, -0.01313228f, -0.03485370f, 0.00643941f, -0.01487817f, 0.00301609f, 0.00991041f, 
    -0.00209023f, -0.00044809f, -0.00019962f, 0.02007858f, -0.02498773f, -0.02714487f, 0.00979735f, -0.01997582f, 
    0.02053252f, -0.01996778f, -0.01256437f, 0.02141977f, -0.00054464f, -0.02674063f, -0.01765882f, -0.03614759f, 
    -0.04535382f, -0.03842737f, -0.01842686f, -0.02041545f, 0.00529141f, -0.03384306f, -0.00705195f, 0.00572814f, 
    -0.01755029f, -0.04262492f, -0.00033041f, -0.03113452f, 0.02626381f, -0.00389803f, 0.00147559f, 0.00809531f, 
    -0.01275146f, -0.01453434f, 0.03249456f, -0.00263472f, 0.02735748f, 0.00449586f, -0.03007062f, -0.03787503f, 
    -0.03673847f, -0.03622896f, -0.03682618f, 0.02292887f, -0.00101189f, -0.00372846f, -0.03893647f, -0.02553887f, 
    -0.01011997f, -0.02020997f, 0.00298968f, -0.02089947f, -0.00443672f, -0.00881182f, -0.01421341f, 0.02446029f, 
    0.02321648f, 0.00430657f, -0.03611673f, 0.01241795f, 0.01471782f, -0.01574281f, 0.00789103f, -0.00161314f, 
    0.01844537f, -0.00965358f, -0.02757278f, 0.03228757f, 0.02076167f, -0.03981457f, 0.00434539f, 0.02202391f, 
    0.00820830f, -0.02251498f, 0.00379240f, -0.01180139f, 0.00708185f, -0.02870249f, -0.03383086f, 0.00059493f, 
    -0.02465660f, -0.01330958f, 0.01453334f, -0.01949283f, -0.03200283f, -0.00586987f, 0.01937530f, -0.02777093f, 
    -0.04126609f, -0.02657257f, -0.03663236f, -0.02293131f, 0.01143173f, 0.00588915f, -0.00763875f, -0.00918758f, 
    -0.00177370f, -0.02688878f, 0.00408343f, 0.01110194f, -0.01579118f, -0.03521571f, 0.03238476f, -0.02169505f, 
    -0.01291050f, 0.02183344f, 0.01966222f, -0.03616541f, -0.00027788f, -0.00497703f, -0.03138459f, 0.00099529f, 
    0.00888766f, 0.02371256f, -0.00946852f, -0.03344437f, 0.00897252f, -0.01753508f, 0.01371527f, 0.00809359f, 
    -0.02597612f, -0.02362238f, 0.00468115f, -0.03916765f, -0.03799821f, -0.02038607f, -0.01909065f, 0.01525264f, 
    0.01662675f, -0.00201567f, -0.00300105f, 0.01931361f, -0.03046359f, -0.03527283f, -0.00301406f, -0.03808611f, 
    0.00197362f, -0.04207183f, -0.02153699f, 0.02146330f, 0.02524495f, -0.00306890f, -0.03745027f, 0.01741573f, 
    -0.03010713f, 0.03155727f, 0.02700673f, 0.01093848f, -0.04045030f, 0.01820928f, -0.01913656f, -0.02521249f, 
    0.01878688f, 0.00087666f, -0.03518816f, -0.00682984f, -0.03450208f, -0.02962595f, -0.01236941f, 0.02184395f, 
    -0.00339382f, 0.00333237f, -0.02491288f, 0.01334982f, -0.02912458f, 0.00289193f, -0.00969121f, 0.00363620f, 
    -0.02437151f, -0.04009804f, 0.01377538f, 0.00621917f, -0.01013934f, 0.01713476f, -0.01672465f, -0.03187827f, 
    -0.03017917f, -0.02673370f, 0.01922726f, 0.01651584f, 0.02084252f, 0.01767587f, -0.02691444f, -0.03503700f, 
    0.03257419f, 0.03050018f, 0.00508433f, 0.00241980f, -0.03728755f, -0.02298711f, -0.00174450f, 0.02798914f, 
    -0.03874837f, -0.01765282f, -0.02786435f, 0.01928332f, -0.02025759f, 0.02428550f, 0.01706225f, -0.00668061f, 
    -0.01024223f, -0.00643266f, -0.02651164f, 0.02019678f, -0.02225581f, 0.01187721f, 0.00897339f, -0.00576566f, 
    0.01128595f, 0.01911483f, 0.02770410f, -0.02401966f, 0.03334764f, -0.04247427f, -0.03976897f, 0.00930297f, 
    0.00819282f, -0.00415935f, 0.00014724f, -0.02222898f, 0.00021173f, -0.01993527f, -0.01095608f, 0.01598932f, 
    0.02812978f, 0.02080882f, -0.00098260f, -0.00635245f, 0.01968428f, 0.01466271f, 0.00864154f, -0.03345114f, 
    0.02201129f, -0.01536742f, 0.00485271f, -0.02183425f, 0.00218954f, -0.02753883f, 0.03178888f, 0.02017098f, 
    0.02704636f, 0.02505657f, -0.01507815f, 0.01082724f, -0.00062291f, -0.04025842f, -0.03460877f, -0.00643632f, 
    0.01223644f, 0.01963182f, -0.00282064f, -0.00633283f, -0.02145458f, 0.02965257f, -0.01709398f, 0.00313021f, 
    -0.03798185f, 0.03269281f, 0.02055622f, -0.03568709f, 0.02132308f, 0.02580490f, 0.02436874f, 0.02504046f, 
    -0.02232118f, -0.01159251f, -0.00674302f, -0.04003007f, 0.01410845f, -0.03582805f, -0.02004872f, -0.01248415f, 
    0.00478461f, -0.03803663f, -0.00998874f, -0.01996772f, 0.01959329f, 0.00359064f, -0.03884808f, -0.00867827f, 
    -0.01123198f, 0.02798563f, -0.03137638f, -0.01584073f, -0.01075757f, -0.04200295f, 0.00424479f, -0.03019182f, 
    0.02419738f, -0.01997035f, 0.01432293f, -0.00980745f, -0.04076964f, -0.00867613f, -0.01539266f, -0.00543010f, 
    -0.00883438f, -0.02724326f, 0.00043745f, 0.02462227f, 0.01265790f, 0.01923032f, -0.03712495f, 0.02526345f, 
    -0.04025441f, -0.01107171f, -0.02979777f, -0.02127341f, -0.00539996f, 0.02143891f, -0.03552494f, 0.02655619f, 
    0.01845550f, 0.00297466f, 0.02544720f, -0.00586023f, -0.01333477f, -0.04034864f, 0.01408722f, -0.04444510f, 
    0.00992811f, -0.02480337f, -0.01932942f, 0.00938600f, -0.04102082f, -0.03459519f, -0.03549678f, -0.01896153f, 
    -0.00897358f, -0.01661774f, -0.03196643f, 0.02900375f, -0.03938834f, -0.01921251f, -0.02359028f, 0.02785051f, 
    -0.02681052f, -0.03375494f, 0.02114402f, -0.02133900f, -0.04118614f, 0.01218084f, 0.01723008f, 0.00486627f, 
    -0.01029923f, -0.01042912f, 0.01102236f, 0.01764986f, -0.01982250f, 0.00188581f, -0.04725193f, -0.00068488f, 
    0.00452824f, -0.02962316f, -0.04141632f, -0.02877183f, -0.01523273f, -0.01142627f, 0.00496808f, -0.02346503f, 
    -0.00832054f, 0.01837776f, -0.01457758f, -0.00621390f, 0.00095722f, 0.00147591f, 0.02899836f, 0.03129453f, 
    -0.03868239f, -0.03688196f, 0.01079017f, -0.02003191f, -0.01612447f, 0.02337343f, 0.01301199f, -0.03768982f, 
    0.14554711f, 0.27975646f, -0.23194514f, -0.09926361f, 0.04064908f, -0.00862681f, 0.12356454f, 0.09329200f, 
    -0.02618753f, -0.00662279f, 0.03426262f, 0.00167135f, 0.04962751f, 0.02871576f, 0.12300021f, 0.09928501f, 
    -0.04490985f, 0.04107825f, -0.01907909f, 0.10436611f, 0.04700721f, 0.04564328f, 0.01986200f, 0.08621442f, 
    0.03192621f, -0.04828562f, -0.16652635f, -0.06663083f, 0.13737166f, 0.11447780f, 0.00972446f, 0.05490950f, 
    -0.10763317f, -0.03341420f, 0.01341053f, 0.16169663f, -0.19264585f, -0.01702289f, 0.15185419f, 0.22059864f, 
    -0.15640590f, -0.04637157f, 0.02739441f, 0.15343925f, 0.01067821f, 0.01749446f, -0.06313235f, 0.12652998f, 
    -0.06495981f, -0.15022370f, -0.04178936f, -0.00180493f, 0.06286091f, 0.01623624f, 0.04105901f, 0.08020563f, 
    0.00046868f, 0.02428748f, 0.07093731f, 0.10322128f, 0.03857762f, 0.24704403f, -0.17353927f, -0.03476097f, 
    -0.02406735f, 0.21168742f, 0.17538638f, 0.00357481f, -0.03961824f, 0.13213208f, -0.08573283f, 0.07897199f, 
    0.13573857f, 0.02424463f, 0.27349517f, -0.09216356f, 0.11242173f, -0.03427112f, 0.05116302f, -0.03509271f, 
    -0.01387874f, -0.08030338f, -0.04921453f, -0.12779160f, 0.21851276f, 0.08186044f, -0.05619806f, 0.05339757f, 
    0.13756059f, 0.18162097f, 0.01362304f, 0.12086588f, 0.07345581f, 0.07000832f, 0.01629683f, -0.01883052f, 
    -0.27456087f, 0.03189112f, -0.14312032f, -0.08369644f, 0.07165242f, 0.03879220f, 0.03834901f, -0.00871845f, 
    0.12808530f, -0.02752101f, 0.07096671f, 0.07343750f, 0.03030696f, -0.22091241f, -0.18166366f, -0.05433302f, 
    0.00280884f, 0.06424239f, -0.05256961f, -0.11554066f, 0.12762474f, 0.05602966f, 0.07085865f, 0.04019270f, 
    0.27511382f, 0.17196828f, 0.20042211f, -0.14886044f, 0.11690675f, 0.21209833f, 0.00090788f, 0.10396993f, 
    0.01040977f, -0.07924458f, -0.03530392f, -0.02443556f, -0.18364862f, -0.18077667f, -0.04265086f, 0.02521937f, 
    -0.12237089f, 0.14095566f, -0.02270512f, 0.06326106f, 0.15897685f, 0.07898358f, 0.08452152f, 0.06338135f, 
    0.01414505f, -0.00711151f, -0.10690660f, 0.03950163f, 0.06380400f, 0.02471516f, 0.13814282f, 0.11290234f, 
    0.03312640f, 0.02334164f, 0.00488387f, 0.08806183f, 0.42844492f, 0.02787817f, 0.17428535f, 0.14823553f, 
    0.09315694f, -0.06683104f, 0.00294205f, 0.07131907f, -0.02258041f, 0.03773252f, -0.00317199f, -0.17124671f, 
    -0.10125103f, 0.08150787f, 0.02198636f, 0.01375689f, -0.05269387f, -0.05796779f, -0.00750869f, -0.05253257f, 
    0.01281735f, -0.03648312f, 0.07705846f, 0.04075548f, -0.15655665f, -0.11238147f, -0.12525372f, 0.04807676f, 
    -0.04401806f, -0.12540908f, -0.10932393f, -0.12857822f, 0.05214952f, 0.11313237f, 0.12281205f, 0.14763920f, 
    -0.03408226f, -0.02885931f, -0.00465209f, -0.09148531f, -0.09281049f, -0.03037060f, -0.03665262f, -0.02652583f, 
    -0.17363492f, -0.16732225f, 0.01265572f, -0.12802599f, -0.09814341f, 0.07049061f, -0.01189504f, 0.02824247f, 
    -0.18020496f, -0.04690528f, -0.10984055f, -0.12530136f, -0.12010063f, -0.21799822f, -0.14436471f, -0.14397390f, 
    0.11047457f, 0.08354603f, 0.00017897f, 0.03031832f, 0.08966969f, 0.10030977f, -0.05632240f, 0.09468950f, 
    -0.11534127f, 0.03006467f, -0.05744663f, -0.16094624f, 0.09296638f, 0.02043455f, -0.01004642f, -0.07676090f, 
    0.07676620f, 0.11044262f, -0.04557893f, 0.05693385f, -0.03423962f, -0.02797543f, -0.02836903f, 0.05024590f, 
    0.06976119f, 0.04800007f, -0.16136292f, 0.05319020f, 0.13493061f, 0.10079380f, 0.14623626f, -0.02466425f, 
    0.01674539f, -0.03274843f, -0.09379052f, -0.10329378f, 0.14346983f, 0.22033972f, -0.10996135f, -0.08341707f, 
    0.19382998f, 0.13604720f, 0.13875556f, 0.12012392f, -0.05451137f, 0.02827121f, -0.03147031f, 0.15393427f, 
    0.28205246f, 0.02592432f, 0.07348394f, -0.12526901f, 0.14831066f, 0.20228170f, 0.06267238f, 0.21225925f, 
    0.04315981f, -0.07295575f, -0.00855532f, -0.01720636f, -0.05059233f, 0.11414997f, 0.00284466f, -0.10134202f, 
    -0.01913066f, -0.06028539f, -0.00684632f, -0.04184868f, 0.14155656f, -0.07770811f, 0.03317943f, 0.14960867f, 
    -0.06703272f, -0.08023389f, -0.13267018f, -0.13408840f, 0.02043005f, 0.01567496f, 0.09406620f, 0.06157031f, 
    -0.10627612f, 0.07423851f, 0.05777154f, 0.01086415f, -0.07122000f, 0.01917575f, 0.03504584f, 0.07373321f, 
    -0.04852534f, 0.03465828f, 0.06491983f, 0.00523499f, 0.05346693f, -0.03714430f, 0.06828371f, 0.08487144f, 
    0.03551276f, -0.01598640f, 0.08918908f, -0.01838878f, -0.13106842f, -0.06893342f, -0.08881107f, -0.05743494f, 
    0.18638960f, 0.00609276f, 0.08233698f, 0.09742525f, 0.59913272f, 0.02663134f, -0.23386987f, 0.07300572f, 
    -0.16428067f, -0.13293825f, -0.06613067f, -0.06965766f, -0.00926153f, 0.10845082f, 0.09350731f, 0.05949256f, 
    0.02673175f, 0.05693159f, -0.01170666f, 0.09435964f, 0.00790310f, 0.00000734f, 0.16873761f, 0.18046406f, 
    -0.08663623f, 0.02420186f, -0.13387746f, -0.09087949f, -0.10885867f, -0.14857888f, 0.01576869f, 0.11397117f, 
    -0.15472591f, -0.03786528f, 0.00868502f, -0.01706051f, -0.00959806f, -0.03793188f, 0.03302561f, 0.05469136f, 
    -0.19484740f, -0.06057670f, 0.14338858f, 0.10066579f, -0.12965459f, -0.15301028f, -0.01159043f, 0.00581890f, 
    0.03544871f, 0.08758569f, -0.17290094f, 0.02215694f, 0.19160147f, -0.07560770f, -0.20330368f, 0.00755813f, 
    0.02972619f, -0.01826551f, -0.00505980f, -0.04818348f, 0.10360581f, 0.02879053f, 0.09005667f, 0.09248427f, 
    -0.11342730f, 0.13452396f, 0.22460973f, -0.08089121f, -0.05366601f, -0.04722938f, 0.06649113f, -0.01226256f, 
    -0.06240728f, -0.15450773f, -0.18131837f, -0.12838821f, 0.01281393f, 0.18215446f, 0.32188553f, -0.12256109f, 
    0.13643977f, -0.02245964f, 0.05255184f, 0.06835638f, -0.04873814f, -0.08056545f, -0.07195585f, 0.00315034f, 
    -0.16929698f, 0.10457762f, -0.16071728f, 0.11585627f, -0.05514298f, 0.21557002f, -0.09900339f, -0.02644557f, 
    0.06544819f, 0.06694107f, 0.11813938f, 0.00458852f, 0.10062727f, -0.00377170f, 0.02080197f, -0.05712253f, 
    0.05702545f, 0.11819911f, 0.00096845f, 0.13649519f, 0.03784500f, -0.03911262f, 0.08163440f, -0.09050539f, 
    0.09259916f, 0.10142305f, 0.03546462f, -0.22910839f, 0.06464048f, 0.11393350f, 0.03720670f, 0.07767218f, 
    0.02517383f, 0.12939548f, -0.00754308f, 0.12243827f, 0.09320372f, -0.08573750f, -0.15748692f, -0.04852694f, 
    0.11568534f, 0.10059542f, -0.00209268f, -0.07482715f, -0.08354186f, -0.05740697f, 0.03555104f, -0.09777381f, 
    -0.05347863f, 0.01855785f, -0.03016018f, 0.21538547f, -0.10786505f, -0.07831841f, -0.12377835f, 0.02222022f, 
    -0.03956511f, 0.02748647f, -0.00987239f, -0.03451031f, -0.21924052f, -0.12048762f, -0.05612068f, -0.05522587f, 
    -0.07720339f, 0.08809400f, 0.05979654f, -0.06176178f, 0.01808490f, -0.02971829f, 0.09119940f, 0.06342734f, 
    0.18734869f, -0.03262692f, 0.11909716f, -0.05580490f, 0.09039820f, -0.01518926f, 0.05025696f, 0.31466523f, 
    -0.01923379f, 0.01240762f, -0.01754821f, -0.09139273f, 0.27683839f, 0.23068503f, 0.03918143f, -0.20890826f, 
    0.20943108f, 0.17417996f, 0.09797259f, 0.10831699f, 0.06264051f, -0.02823736f, 0.07388759f, 0.05707716f, 
    0.10754705f, -0.10455561f, -0.21780403f, -0.06633247f, 0.09623638f, 0.03081923f, 0.10723916f, 0.05239159f, 
    0.12812223f, 0.13421462f, 0.08079287f, -0.05410964f, 0.08264946f, 0.01526743f, -0.04894388f, -0.17293179f, 
    0.05589704f, 0.11231819f, 0.03711605f, 0.17924328f, 0.01369152f, -0.03530385f, 0.00285876f, 0.04046402f, 
    -0.13428259f, -0.28181526f, 0.00407004f, -0.01685095f, 0.00918883f, 0.03379906f, 0.02862509f, 0.05237462f, 
    0.01577923f, 0.02120425f, -0.00560522f, 0.09337360f, 0.17610334f, -0.18205176f, 0.02279920f, 0.27838698f, 
    0.05475226f, 0.13324653f, 0.05253733f, 0.00912524f, 0.26988250f, -0.04164784f, 0.12660944f, 0.33293316f, 
    -0.16665763f, -0.04144640f, 0.12395301f, 0.02703095f, -0.06586939f, -0.06892224f, -0.04137419f, -0.08831542f, 
    0.02181124f, 0.01400895f, -0.06691200f, 0.11068241f, -0.00947902f, -0.02317554f, 0.20934294f, 0.04677162f, 
    0.04687956f, -0.08857232f, -0.00132098f, 0.03721225f, -0.12867260f, -0.09762997f, -0.12152894f, 0.00831449f, 
    0.24311472f, 0.10331731f, -0.04962319f, -0.01376389f, 0.12115576f, 0.14775579f, 0.12910406f, -0.07153594f, 
    -0.05556020f, -0.00768047f, -0.10858180f, 0.03950686f, -0.04974938f, -0.05108529f, -0.13648917f, 0.13292894f, 
    0.02197724f, 0.10914126f, 0.03150427f, -0.01782175f, 0.04998577f, 0.07737634f, 0.10650622f, 0.01136857f, 
    0.19972296f, 0.13664234f, -0.09045198f, -0.02873884f, 0.08784299f, 0.03662211f, -0.02025226f, 0.01323574f, 
    -0.11557557f, -0.07840525f, -0.11475507f, -0.00190779f, -0.08765120f, -0.00159239f, 0.04181392f, -0.03780383f, 
    -0.00494976f, 0.10398662f, 0.01827725f, -0.03909020f, -0.05490673f, 0.02270444f, 0.00085374f, -0.06991813f, 
    -0.14789516f, -0.05820993f, -0.22015473f, -0.06439661f, -0.01442615f, -0.00860361f, -0.03556225f, -0.12983684f, 
    0.02346722f, -0.00785246f, 0.09074488f, 0.05644230f, 0.15896879f, 0.13546483f, 0.01421297f, 0.01066311f, 
    0.09642028f, 0.15696768f, -0.03241966f, 0.11095463f, -0.00404833f, -0.08381890f, -0.03852936f, -0.07054117f, 
    0.20179594f, 0.22344632f, 0.05435288f, 0.13262883f, 0.01525447f, 0.16056627f, 0.03669833f, -0.10407493f, 
    0.03419999f, 0.04144127f, -0.08181351f, 0.05326094f, -0.13251215f, -0.08302108f, -0.22174272f, 0.06338194f, 
    -0.05428004f, 0.13823897f, 0.01179961f, -0.05177866f, 0.02916317f, 0.07949957f, 0.03244389f, 0.12785150f, 
    0.10640555f, 0.33786884f, -0.08631825f, 0.07024320f, -0.14733319f, -0.01004911f, -0.11443683f, -0.08511917f, 
    0.02660856f, 0.12103674f, 0.16051827f, 0.06526269f, 0.33977437f, 0.32996017f, -0.15394865f, -0.06273361f, 
    0.12280822f, 0.09419575f, 0.20753142f, 0.02990626f, 0.05525424f, -0.05438004f, 0.10193067f, -0.04971352f, 
    -0.00753891f, -0.03521160f, -0.10754935f, -0.10905753f, -0.14936571f, -0.01136971f, -0.04614982f, -0.07872604f, 
    0.02671918f, -0.01859690f, -0.00186359f, 0.13552350f, -0.04202197f, -0.00992951f, -0.09455375f, -0.03977544f, 
    -0.02853816f, 0.04707737f, -0.02273280f, -0.14057553f, -0.02075162f, 0.12240513f, 0.01917209f, 0.11882693f, 
    0.23981838f, -0.01557491f, -0.05181014f, 0.04337179f, 0.07981765f, 0.13782613f, 0.00981051f, 0.01695752f, 
    0.07360344f, -0.03766958f, -0.05261855f, 0.03772596f, -0.08748107f, -0.07390162f, 0.03522480f, -0.14764963f, 
    0.08880188f, -0.01041505f, 0.06206857f, -0.03685777f, 0.09808769f, 0.07092516f, 0.01609713f, 0.12156955f, 
    0.23579201f, -0.02177309f, 0.14968991f, 0.10182178f, 0.07133424f, 0.01890313f, 0.14526618f, 0.25753719f, 
    -0.00018902f, 0.25375319f, 0.00713115f, 0.04481237f, 0.07144815f, 0.08286755f, -0.14402141f, -0.03041889f, 
    0.05017754f, 0.12663534f, 0.15076619f, -0.00628486f, -0.04537361f, 0.02790877f, -0.04419733f, 0.06659500f, 
    -0.02393336f, 0.05611003f, -0.20107913f, 0.04613850f, -0.00515579f, 0.11441428f, -0.06555471f, -0.07767639f, 
    -0.06644173f, -0.04765292f, -0.07066891f, 0.01296747f, 0.36764213f, 0.06289981f, 0.13672918f, -0.21070774f, 
    -0.00838566f, -0.02181211f, -0.02440769f, 0.09288520f, -0.09283588f, 0.14836322f, -0.07080023f, -0.09775825f, 
    -0.06259435f, -0.24082904f, -0.09228642f, 0.08938020f, 0.15041053f, 0.12511957f, -0.07633515f, 0.11204193f, 
    -0.02221829f, -0.04259037f, 0.10384369f, 0.09117259f, -0.45061231f, -0.02601307f, 0.15415533f, 0.12764983f, 
    -0.00911201f, -0.06928551f, -0.05257013f, 0.02942174f, -0.00602427f, -0.01125657f, 0.05339471f, 0.13402213f, 
    0.04801470f, -0.03089885f, 0.03307690f, -0.02670383f, -0.02555237f, 0.04431316f, -0.09307346f, 0.07463111f, 
    -0.26552424f, -0.03302711f, 0.20446503f, 0.02893838f, -0.21993975f, -0.13312207f, -0.23769368f, 0.12643258f, 
    -0.05288875f, 0.08288554f, -0.00803920f, 0.15004480f, -0.10434206f, 0.08482999f, -0.02008793f, 0.09674665f, 
    -0.17475076f, 0.03235259f, 0.10819215f, 0.16890019f, -0.01388183f, 0.18602735f, 0.13718262f, -0.00366680f, 
    0.06507778f, -0.01371834f, 0.06695537f, -0.16631806f, -0.15694433f, 0.11606339f, -0.01752200f, 0.22987682f, 
    0.06923702f, 0.08493102f, 0.02968003f, 0.00747533f, 0.04824540f, 0.06768718f, -0.06983009f, -0.15807284f, 
    0.03452619f, 0.08124127f, -0.21038336f, -0.11830758f, 0.01071830f, 0.06577641f, -0.03117225f, 0.01010861f, 
    -0.07638282f, 0.06892475f, 0.04893517f, 0.01483250f, -0.05262566f, 0.02835305f, 0.04614285f, 0.17865659f, 
    -0.03105162f, 0.10269674f, 0.18349908f, -0.11352354f, 0.00860047f, 0.07376844f, -0.03235095f, -0.03359957f, 
    0.05035938f, -0.01674761f, 0.24967682f, -0.10907911f, 0.04943634f, 0.10739471f, -0.03255529f, 0.00098759f, 
    -0.04224104f, -0.10108890f, -0.05576440f, -0.21115899f, 0.17377204f, 0.03034345f, -0.01653050f, 0.05386287f, 
    0.15472937f, -0.00545659f, 0.13224536f, -0.01992597f, -0.09668763f, -0.03865638f, -0.02129999f, 0.11618669f, 
    -0.19230644f, -0.04839529f, 0.00968025f, 0.10222865f, -0.06520479f, -0.08045788f, 0.14169788f, 0.24500896f, 
    -0.02752817f, 0.06392670f, -0.08290291f, 0.18629821f, 0.30179223f, -0.05458198f, 0.34396163f, 0.37823582f, 
    0.07363383f, 0.01827514f, 0.00513488f, -0.03976014f, -0.11912195f, 0.02390279f, 0.03397853f, -0.08522072f, 
    -0.02417177f, 0.15156285f, 0.15239482f, 0.05443810f, -0.02560902f, 0.07719076f, -0.00978102f, -0.08075008f, 
    -0.01184142f, -0.00765716f, 0.13275225f, 0.02382400f, 0.02567915f, 0.00475619f, 0.11863400f, 0.02320807f, 
    0.05214760f, 0.03863246f, 0.04561452f, -0.01917610f, -0.02583591f, 0.04259767f, -0.03403222f, 0.11321547f, 
    0.06522029f, 0.15134485f, 0.05343673f, -0.24861568f, -0.08464465f, -0.04125348f, -0.04362473f, -0.03086798f, 
    0.14533153f, 0.01438038f, 0.00706765f, -0.25735158f, 0.02042970f, 0.18652388f, 0.05492693f, 0.09052968f, 
    -0.10182744f, -0.13080305f, -0.05094545f, -0.03674852f, 0.05039580f, -0.00467465f, -0.02317987f, 0.05720513f, 
    0.36951563f, -0.17394231f, 0.00943110f, 0.19949414f, 0.13452458f, 0.09560447f, 0.01964248f, -0.10244888f, 
    -0.24850693f, 0.09951650f, -0.07554325f, 0.00111434f, 0.01584859f, -0.23360972f, -0.09780591f, 0.04515639f, 
    -0.08252189f, 0.05118258f, -0.05548425f, -0.02450069f, -0.08426245f, 0.04334519f, -0.08911069f, -0.03986968f, 
    -0.07794034f, -0.03834533f, -0.14065577f, 0.11995019f, 0.09006998f, 0.10324538f, 0.00199076f, -0.05967820f, 
    0.04491174f, -0.05955708f, -0.21801879f, -0.02839382f, -0.03761573f, 0.06614590f, -0.22642854f, -0.10217874f, 
    0.14362817f, -0.00681301f, 0.07688250f, 0.11478309f, -0.09878441f, 0.06063700f, -0.21963939f, -0.02544259f, 
    0.28200904f, -0.16599634f, 0.03462403f, 0.13241374f, 0.15950802f, 0.11845311f, -0.11984171f, 0.10746136f, 
    -0.10064083f, -0.02842733f, 0.08222619f, 0.05149378f, 0.20169900f, 0.62098342f, -0.06945706f, -0.54926604f, 
    0.03191274f, 0.12265366f, 0.06592214f, 0.01301099f, -0.12861575f, 0.10372912f, -0.04847094f, 0.06276920f, 
    -0.14825201f, -0.15183353f, -0.02928552f, 0.09279433f, 0.07796148f, 0.04403660f, 0.04046210f, -0.00582181f, 
    -0.12444358f, 0.02274485f, 0.09547848f, 0.06215324f, 0.02261394f, 0.18061599f, -0.01898611f, 0.02744490f, 
    -0.16201149f, 0.04958070f, 0.08400863f, -0.03315220f, -0.10215701f, -0.12738255f, 0.15287948f, -0.03760742f, 
    0.20823334f, 0.18031617f, 0.09159749f, -0.11813332f, 0.02050704f, 0.08328810f, -0.03403535f, -0.03784877f, 
    -0.03629488f, -0.05157342f, -0.03762177f, -0.00734689f, 0.52198523f, 0.49655464f, -0.10590183f, 0.40100268f, 
    0.03135826f, -0.08702148f, 0.10076611f, -0.16495444f, 0.16075820f, -0.04431720f, 0.15749370f, -0.05892172f, 
    0.02221484f, 0.01650564f, 0.09419608f, 0.05787280f, -0.01220856f, -0.15862478f, -0.01372744f, 0.17458469f, 
    -0.08617774f, 0.01736257f, 0.02214704f, -0.10753988f, 0.14472924f, 0.06098785f, 0.15820400f, 0.03750436f, 
    -0.03588743f, -0.09045247f, 0.01741461f, -0.00221531f, -0.04584583f, -0.02060965f, 0.08448356f, -0.08141417f, 
    0.13675816f, 0.00524012f, 0.33323896f, -0.01927624f, -0.08094252f, -0.08055846f, -0.04615807f, -0.01829680f, 
    -0.02264450f, 0.04911074f, -0.02780463f, -0.04566176f, -0.15988746f, 0.12467335f, -0.12835859f, 0.17786875f, 
    -0.09481246f, 0.12596518f, 0.06498738f, -0.22180602f, 0.08469556f, 0.07306984f, 0.04318593f, 0.04727519f, 
    0.02335097f, 0.33602104f, 0.02643623f, -0.09760544f, -0.10694581f, -0.05128831f, -0.00579953f, -0.03222073f, 
    0.09818395f, 0.02185244f, -0.12296883f, -0.06567265f, 0.14317085f, 0.08750314f, 0.08483385f, -0.20422097f, 
    -0.11726713f, 0.03828660f, -0.13835537f, -0.02765805f, -0.07067720f, 0.02527737f, 0.02889741f, -0.03322377f, 
    -0.04407666f, 0.30741322f, -0.10872281f, 0.31034672f, -0.07485905f, -0.02711827f, -0.08345411f, -0.08233970f, 
    0.07475592f, 0.03394200f, 0.05268880f, 0.01540802f, 0.13723309f, -0.09586329f, 0.28156403f, 0.29300055f, 
    0.01131588f, 0.07559640f, 0.13307574f, 0.17376627f, -0.04710664f, 0.14935592f, 0.05285152f, 0.12197123f, 
    0.34352612f, 0.15769683f, -0.16765310f, -0.27372685f, -0.16704477f, 0.07740115f, -0.03693738f, 0.13000877f, 
    -0.08100997f, 0.00560599f, 0.08429691f, 0.05005663f, -0.12066996f, -0.29700264f, -0.01166813f, 0.19621854f, 
    0.10414996f, 0.10905800f, 0.11946839f, 0.10312232f, -0.00607607f, 0.02807114f, 0.00036943f, -0.09642087f, 
    -0.07574025f, 0.28706238f, 0.11254601f, 0.10933906f, 0.01515171f, -0.03540276f, -0.02458167f, -0.00088117f, 
    -0.01456955f, -0.00999025f, 0.05547482f, -0.01507913f, 0.51796252f, 0.02388307f, -0.11096999f, -0.09790635f, 
    0.02230148f, -0.01554264f, 0.06261306f, -0.00570605f, -0.12350295f, -0.01783379f, 0.02002966f, 0.02233934f, 
    0.11455999f, -0.03753825f, 0.14970860f, 0.12311342f, -0.03118218f, 0.06525749f, -0.05959102f, 0.14770092f, 
    -0.01357562f, 0.10247350f, -0.01223686f, 0.05222293f, -0.31278840f, 0.27916846f, -0.32966131f, -0.14183606f, 
    -0.12067008f, 0.08926032f, -0.04925207f, 0.04335425f, -0.01983958f, -0.00814965f, 0.05323971f, -0.07611448f, 
    0.08380557f, 0.01972230f, 0.10672826f, 0.11736827f, -0.00499985f, 0.01573044f, 0.10727806f, -0.07653470f, 
    -0.00047905f, -0.00581273f, -0.02983919f, -0.07787599f, -0.15776737f, -0.25277233f, -0.15651426f, 0.15665877f, 
    0.05031573f, 0.12158591f, 0.05224787f, 0.11167704f, 0.06687891f, 0.01171037f, -0.05256533f, 0.07355430f, 
    -0.32299989f, -0.06956920f, 0.33722067f, 0.10089400f, 0.11077271f, -0.07935430f, -0.02175045f, 0.05757757f, 
    -0.01618046f, -0.04431254f, -0.01399349f, 0.07157125f, 0.00453992f, -0.15262078f, 0.23192638f, 0.25269654f, 
    -0.00487127f, 0.01203974f, 0.09415036f, -0.02505584f, 0.08227555f, 0.06891275f, -0.04272427f, 0.07289894f, 
    -0.32146916f, 0.14382727f, 0.15197708f, -0.04201255f, -0.13833603f, -0.01367208f, 0.02456654f, -0.06663150f, 
    -0.04748814f, 0.03018568f, 0.00365196f, 0.07850654f, 0.04470815f, 0.03418671f, 0.26076826f, -0.14998293f, 
    -0.02948230f, -0.00314005f, -0.02903151f, -0.03940910f, -0.09336085f, 0.00515140f, 0.05962764f, -0.04254662f, 
    -0.09967840f, -0.13816805f, -0.07699998f, 0.05016426f, -0.04599898f, 0.09242965f, 0.10620701f, -0.06099602f, 
    -0.09952191f, 0.01617600f, -0.23295243f, 0.01232923f, -0.09101303f, 0.12442400f, 0.06836464f, 0.17922243f, 
    0.10236163f, -0.05106102f, -0.03208614f, 0.01545462f, -0.02777323f, 0.13981056f, -0.01587487f, -0.00363824f, 
    -0.03803815f, -0.15567690f, -0.26036534f, 0.06895483f, 0.01077006f, -0.07231817f, -0.06792975f, -0.09797656f, 
    -0.03057123f, -0.05868189f, -0.11074915f, -0.00564207f, 0.04328318f, 0.00571910f, 0.19514088f, -0.01420024f, 
    -0.07684275f, -0.00123802f, -0.01520851f, 0.09112024f, -0.13282429f, 0.04946620f, -0.00747042f, 0.01499562f, 
    -0.06467736f, 0.24882813f, 0.14862214f, -0.10032874f, -0.04873530f, 0.05222576f, -0.01128523f, -0.05218366f, 
    -0.05317573f, -0.06380153f, -0.12374542f, -0.07902098f, 0.27095085f, -0.10031631f, -0.03100636f, 0.07871655f, 
    0.11510897f, 0.08229425f, -0.03368450f, -0.02051798f, 0.02996926f, -0.02770981f, -0.09491530f, -0.10272048f, 
    0.25184098f, -0.12131462f, 0.09461758f, 0.28321168f, -0.02869803f, 0.16063720f, -0.00318106f, -0.10269593f, 
    -0.05274038f, -0.11236451f, -0.13830699f, -0.18996590f, -0.18828575f, 0.10769162f, 0.02087576f, 0.21160646f, 
    0.01301750f, 0.15186010f, 0.08429994f, -0.02893130f, 0.04376708f, 0.00549469f, 0.11787640f, -0.04466754f, 
    0.29611883f, 0.43701181f, -0.22593926f, -0.09967259f, -0.00537181f, -0.01358119f, -0.01696221f, -0.04353836f, 
    0.06532959f, 0.09259468f, 0.02907557f, -0.07141437f, 0.05563613f, 0.30859131f, -0.45141211f, -0.16521068f, 
    -0.15675080f, 0.02637602f, 0.12869567f, 0.00826760f, -0.06045543f, 0.04660666f, 0.03203320f, -0.08319052f, 
    0.07742269f, 0.01861493f, -0.16137780f, -0.13078035f, -0.05824383f, 0.07669015f, 0.07592562f, -0.03501351f, 
    -0.02136723f, -0.06036884f, 0.04792763f, 0.07016248f, 0.02235190f, 0.07708793f, -0.04275102f, 0.01096385f, 
    -0.03988272f, -0.11761395f, -0.00680235f, -0.07764161f, -0.03366615f, 0.00735553f, 0.08586652f, 0.02709353f, 
    -0.25855514f, 0.12818684f, -0.05521863f, 0.13119045f, -0.02237979f, 0.08819526f, -0.00534501f, -0.08090118f, 
    -0.01480039f, 0.08264716f, -0.05625191f, 0.04277482f, 0.16571639f, 0.01725908f, -0.06619798f, -0.04981326f, 
    -0.05859461f, -0.07694433f, -0.03260507f, -0.02061987f, -0.03169082f, 0.09675181f, 0.10360307f, 0.00939867f, 
    0.53858465f, -0.15982144f, 0.32699931f, 0.07687391f, -0.08840401f, 0.07155402f, 0.01767963f, 0.07470457f, 
    -0.20225888f, 0.24129848f, 0.06584337f, -0.01548407f, -0.14905404f, -0.13319366f, -0.06193222f, 0.23862743f, 
    -0.00503169f, -0.02309603f, -0.00338110f, -0.04768545f, -0.06804322f, -0.02494229f, -0.04608545f, -0.05076652f, 
    -0.03379468f, -0.03839961f, -0.01686964f, 0.01255489f, -0.00618217f, 0.02596579f, 0.02294284f, 0.01322481f, 
    -0.01610501f, -0.00373631f, -0.01399000f, -0.01293935f, 0.01505977f, -0.03455141f, 0.01322048f, 0.01889717f, 
    0.02868141f, 0.02404961f, -0.03337430f, 0.02545257f, -0.02137610f, -0.01767194f, -0.00673405f, -0.00984171f, 
    -0.02936963f, 0.02966939f, 0.00892196f, 0.03159006f, -0.02103498f, 0.00552275f, 0.02503423f, 0.01330743f, 
    -0.04087588f, -0.01220330f, -0.00362151f, -0.01582874f, -0.03934468f, -0.03350956f, 0.00616761f, 0.02416286f, 
    -0.02016894f, 0.01008230f, 0.00411980f, -0.00229119f, -0.02070999f, 0.01628954f, -0.02532509f, -0.02139279f, 
    -0.02057052f, -0.01017815f, 0.01158024f, -0.02446182f, 0.00128852f, 0.00830427f, -0.02627313f, 0.02582686f, 
    -0.01826263f, 0.01859555f, -0.02259063f, -0.03473339f, -0.02490892f, -0.02190203f, 0.01149630f, -0.01926926f, 
    -0.04412734f, -0.00958093f, 0.02316138f, -0.01442944f, -0.02387760f, -0.02574520f, -0.02067494f, -0.03987095f, 
    -0.02861284f, 0.01916483f, -0.02171659f, -0.02123307f, -0.03179752f, -0.00741929f, 0.00342039f, -0.03014084f, 
    0.01144124f, 0.00121876f, -0.04269480f, -0.02278420f, 0.01561803f, 0.01670765f, -0.00055602f, -0.01933234f, 
    0.01765687f, 0.00335535f, -0.02660240f, 0.02274195f, 0.02715171f, -0.03397785f, 0.00284575f, 0.01538880f, 
    0.01016613f, -0.02776162f, -0.01663593f, 0.03148304f, -0.02709482f, -0.00050450f, 0.01069963f, 0.02364214f, 
    0.00358099f, -0.01126148f, -0.03486773f, -0.01308600f, -0.00906799f, -0.03933348f, -0.01045565f, 0.02970209f, 
    -0.03527628f, -0.02058591f, -0.01491191f, -0.01420924f, -0.01000179f, -0.02743534f, 0.00797969f, 0.01579475f, 
    0.03081350f, -0.03978765f, -0.03642716f, 0.00184596f, -0.03150561f, -0.01551634f, 0.01564874f, 0.02700929f, 
    0.02176441f, 0.00338552f, -0.02702466f, 0.02399841f, -0.00859625f, -0.02686068f, 0.00617596f, 0.02994266f, 
    0.03304940f, 0.02452254f, -0.00688298f, 0.01740274f, 0.01580022f, -0.03636753f, -0.01618261f, -0.02116402f, 
    -0.00710523f, -0.01593597f, 0.02225984f, -0.02387056f, -0.02388841f, -0.00717486f, 0.02734406f, -0.01512953f, 
    -0.03917608f, 0.01145900f, 0.01493003f, -0.03128943f, 0.00656496f, 0.01721041f, 0.01186072f, -0.03038961f, 
    -0.00349010f, -0.00452065f, -0.00390723f, -0.02520367f, -0.02105937f, 0.01638664f, 0.01046563f, -0.03273110f, 
    -0.04205987f, -0.02069282f, -0.02938782f, 0.01356659f, -0.02499629f, 0.01204900f, -0.03146970f, -0.03801570f, 
    0.02837775f, -0.00969176f, -0.02189177f, -0.00281914f, -0.03856971f, -0.03676320f, -0.04170618f, 0.02788496f, 
    0.01171771f, -0.03807466f, -0.03958636f, 0.01360360f, 0.00428089f, -0.01181106f, 0.00634806f, -0.02691251f, 
    -0.01419106f, -0.01788337f, -0.00872623f, -0.01179682f, -0.01987554f, 0.00074080f, -0.00170826f, 0.01946277f, 
    -0.01311968f, -0.01645955f, -0.01859742f, -0.02158063f, -0.04449659f, 0.00792551f, -0.04251198f, 0.00170455f, 
    -0.03429107f, -0.00990464f, -0.01552142f, -0.03190114f, -0.01410660f, -0.04058598f, -0.04051924f, 0.00198751f, 
    0.00959680f, -0.03398834f, 0.02788197f, 0.00444572f, -0.02361440f, -0.02524295f, 0.01005125f, -0.04315480f, 
    0.02560952f, -0.00805635f, 0.00983141f, 0.01445535f, 0.02898867f, -0.02270998f, -0.02629650f, -0.00561273f, 
    -0.01107255f, -0.01394449f, 0.01437060f, -0.03042975f, -0.01322150f, 0.00368968f, 0.02311653f, -0.00785303f, 
    0.02023365f, 0.02126822f, 0.00142019f, 0.01489046f, -0.03290885f, -0.00568831f, 0.01634420f, -0.01380547f, 
    -0.03518950f, 0.01500505f, 0.01137346f, -0.03048876f, -0.03969304f, -0.02277433f, 0.01255352f, 0.00084100f, 
    -0.02413856f, 0.01521521f, -0.01459968f, -0.00960126f, -0.04266954f, -0.02118832f, -0.00716990f, -0.00159688f, 
    0.02957402f, 0.01874454f, -0.02247809f, -0.00385700f, 0.00631211f, 0.00702109f, -0.01446200f, -0.01493668f, 
    -0.03884979f, -0.01965105f, -0.00186961f, 0.01212628f, -0.03162263f, 0.02059801f, -0.00626901f, -0.02689726f, 
    -0.00399633f, 0.00657156f, 0.02284375f, -0.00746194f, -0.02572164f, 0.00047088f, 0.00482582f, -0.02299388f, 
    -0.03489570f, -0.04128227f, 0.00159266f, -0.01084745f, -0.01305372f, 0.00381787f, -0.01717665f, -0.01052385f, 
    -0.01631525f, 0.02514797f, 0.02716308f, 0.02716470f, -0.00299416f, -0.03122710f, 0.01189656f, -0.02710330f, 
    0.01495814f, -0.01552253f, 0.02638650f, -0.00902420f, -0.00272806f, -0.02825234f, -0.00400497f, 0.02263012f, 
    -0.03794701f, -0.02691333f, -0.02742085f, -0.03469352f, -0.00842428f, 0.01451593f, -0.00899141f, 0.02404145f, 
    -0.02763482f, -0.00196806f, 0.02507710f, 0.03009801f, -0.01270225f, 0.00923249f, 0.02136928f, -0.02199115f, 
    0.02054096f, -0.02517965f, -0.00534904f, 0.03508678f, -0.02028619f, -0.00685123f, -0.00719301f, 0.01048929f, 
    -0.00482084f, 0.00968589f, 0.02527095f, -0.01513120f, 0.02862210f, 0.00303025f, -0.00918019f, 0.00316410f, 
    0.02205655f, -0.02938616f, 0.02668871f, -0.03770919f, -0.01775429f, 0.00132233f, 0.01772453f, 0.00774873f, 
    0.03455926f, -0.03601932f, 0.02661747f, 0.00913396f, -0.03751395f, -0.00588707f, 0.00716721f, -0.03998228f, 
    0.02426219f, -0.01941555f, -0.03196260f, -0.00146166f, -0.00447755f, 0.00487732f, -0.01971043f, -0.00435769f, 
    -0.02456116f, 0.02324452f, -0.01691127f, -0.02538020f, 0.01533758f, 0.02619341f, -0.01388873f, 0.03124354f, 
    0.02185412f, -0.00412957f, -0.02487681f, 0.02578008f, -0.01523075f, 0.01509995f, 0.01794545f, 0.02429698f, 
    -0.01911952f, 0.00829170f, 0.01376048f, -0.03120146f, 0.02111324f, -0.02491722f, -0.03799932f, -0.02157400f, 
    -0.00458328f, 0.00907873f, -0.03395292f, -0.01771996f, 0.01435230f, 0.01943970f, 0.00541762f, -0.02177902f, 
    0.02516567f, -0.01604448f, -0.02068560f, -0.02061452f, 0.01106029f, -0.02485467f, 0.02669302f, -0.02331445f, 
    0.02152776f, 0.01308837f, 0.00787371f, -0.01097309f, 0.01919533f, -0.01322304f, -0.01587176f, 0.02168921f, 
    -0.00788993f, 0.00699294f, -0.03941404f, -0.03544260f, 0.01319480f, -0.01514750f, -0.02524336f, 0.01326131f, 
    0.01192935f, 0.02647360f, 0.01635257f, 0.02648006f, -0.00721182f, -0.02513726f, 0.03316107f, -0.00361889f, 
    -0.01695257f, 0.00000049f, -0.01926855f, 0.01914144f, -0.01675391f, -0.01618162f, -0.00033751f, -0.00386207f, 
    -0.00161565f, 0.00205048f, -0.02055333f, -0.01017976f, 0.00164136f, -0.01674553f, 0.01804681f, -0.00585004f, 
    0.01635909f, 0.00311639f, -0.01345733f, 0.01954337f, -0.01842481f, 0.02829707f, -0.03264255f, -0.03507688f, 
    0.02289844f, 0.01142369f, 0.00701775f, 0.00446653f, -0.03659098f, 0.01584705f, 0.00905872f, -0.02846711f, 
    -0.03384055f, -0.02577966f, -0.03929046f, 0.02175695f, -0.01404832f, -0.01101771f, -0.00568001f, -0.03645610f, 
    -0.01229136f, -0.03176343f, 0.02351359f, -0.02403132f, 0.01595690f, 0.02212243f, -0.00852035f, -0.04387604f, 
    0.02350544f, 0.03075731f, 0.00282416f, -0.03428387f, 0.02355121f, -0.02567020f, 0.01304055f, -0.04159735f, 
    -0.00069145f, -0.00573144f, -0.00679433f, -0.00422295f, 0.02280420f, 0.02053105f, 0.01826879f, 0.00481887f, 
    0.00406365f, 0.00565919f, 0.00828344f, -0.03489808f, 0.00097163f, 0.02646307f, 0.01504513f, -0.01707336f, 
    -0.03754885f, -0.01152723f, -0.02798188f, -0.02199861f, 0.00750630f, -0.00494403f, -0.02261384f, -0.03241730f, 
    -0.02455837f, -0.02819445f, -0.01631997f, 0.01329693f, 0.00892025f, -0.01781941f, -0.01594634f, 0.00069942f, 
    0.00282016f, -0.02008353f, 0.00865473f, -0.01016392f, -0.03350560f, 0.00494398f, -0.01021063f, 0.02574723f, 
    0.02078183f, 0.01736741f, -0.04212603f, -0.02628743f, 0.01902821f, 0.00820223f, 0.00861440f, 0.02783705f, 
    -0.02827807f, -0.02948598f, 0.01083153f, 0.03076950f, 0.00791822f, -0.00535068f, 0.01966652f, 0.01937140f, 
    0.02702126f, -0.03401870f, 0.01374427f, -0.01376940f, -0.00761962f, -0.00899949f, 0.00306734f, -0.01817874f, 
    -0.03397201f, 0.01627679f, -0.01754133f, -0.00572734f, 0.03108358f, 0.00959582f, -0.00914060f, -0.02551818f, 
    -0.02171072f, -0.02464251f, -0.01401723f, 0.01877504f, 0.01009410f, -0.04382994f, 0.00033184f, 0.00124468f, 
    -0.04265373f, -0.01744824f, 0.02847899f, -0.01351187f, -0.01572222f, -0.03153436f, -0.00668790f, -0.00074096f, 
    -0.00343370f, 0.01507161f, -0.04038681f, -0.03165064f, -0.00983383f, -0.00225610f, 0.00069019f, -0.01158065f, 
    0.00529695f, 0.02756514f, 0.01069190f, 0.00273619f, -0.04000168f, 0.02791009f, 0.02475858f, -0.02352459f, 
    -0.00539094f, -0.02847256f, -0.03555994f, -0.03343747f, -0.01963059f, 0.01418938f, -0.01652678f, -0.02162904f, 
    0.00266726f, 0.01352291f, 0.01149150f, 0.01678965f, -0.00615229f, 0.03560831f, 0.02994321f, -0.03237126f, 
    -0.00143905f, 0.02250848f, 0.00501860f, 0.00862980f, -0.00981098f, 0.02997810f, -0.00010282f, -0.00817579f, 
    0.02567225f, -0.01605078f, -0.02326742f, 0.01138432f, -0.00029982f, -0.03693198f, 0.03761662f, -0.01799832f, 
    -0.01876861f, -0.02190375f, 0.00799557f, -0.03353189f, 0.01918391f, 0.00689723f, -0.03424031f, 0.00227112f, 
    0.00417370f, 0.02163810f, 0.03023798f, -0.00116676f, 0.02639882f, -0.01492184f, -0.04120277f, 0.03265047f, 
    -0.02822322f, 0.02630245f, 0.02117517f, 0.00384712f, -0.01090895f, 0.02479187f, -0.04056360f, -0.00843138f, 
    0.01818872f, 0.01867506f, -0.01537528f, 0.02930784f, -0.02853046f, 0.01955795f, 0.02926717f, 0.01537746f, 
    0.00079367f, 0.00230214f, -0.00300501f, -0.00858486f, 0.01068140f, -0.01140338f, -0.02087233f, 0.00103678f, 
    0.03154132f, -0.03854884f, 0.02654371f, -0.00728894f, -0.03863956f, 0.00838785f, 0.01169602f, 0.01784147f, 
    0.02338589f, -0.00849913f, 0.00152897f, 0.00048028f, 0.01247282f, -0.02487849f, 0.00726425f, 0.02253222f, 
    -0.04212913f, -0.03795448f, -0.04036427f, -0.00701695f, -0.03627246f, -0.02936978f, -0.02637908f, -0.01120968f, 
    -0.02735109f, -0.02417011f, 0.02322450f, -0.02888632f, -0.01596772f, -0.00864750f, -0.04443615f, -0.02172419f, 
    0.02892333f, 0.01848238f, 0.01601784f, -0.01450041f, 0.00733762f, -0.03084429f, -0.03636587f, -0.00099112f, 
    -0.02766752f, 0.01451830f, 0.03064859f, 0.01567980f, 0.00726542f, 0.01503927f, -0.00597400f, -0.01112074f, 
    -0.01355913f, -0.02903829f, 0.00508754f, -0.01786332f, 0.01294517f, -0.04409573f, -0.00547003f, 0.01781901f, 
    -0.03593804f, 0.00503849f, 0.01675220f, 0.01070280f, -0.03945141f, 0.02236543f, -0.03401351f, -0.00585877f, 
    -0.03310215f, -0.02683659f, 0.01423786f, -0.04325348f, -0.02327440f, -0.04217149f, -0.04331509f, -0.01713199f, 
    0.01409512f, -0.01239753f, 0.03818718f, 0.02030862f, -0.02301855f, -0.03555251f, -0.01187480f, -0.01845273f, 
    0.01109449f, 0.00603139f, -0.00796207f, -0.00504590f, -0.02315107f, -0.02691320f, -0.03982115f, 0.00302804f, 
    0.00551267f, -0.01604930f, 0.02235917f, -0.03384794f, 0.00035949f, 0.02091235f, 0.00683827f, 0.00113729f, 
    -0.01327936f, 0.02753134f, -0.01175967f, -0.02506324f, -0.00607691f, 0.00697787f, 0.01882689f, -0.03832487f, 
    0.06380824f, 0.26155066f, 0.16967197f, 0.19881210f, -0.08003049f, 0.00625439f, 0.01214374f, 0.24177769f, 
    0.08790696f, 0.09697261f, 0.03151225f, 0.07198609f, -0.23492277f, -0.04284643f, -0.13911362f, -0.24792917f, 
    0.07603669f, 0.03014490f, -0.14484955f, 0.07253844f, 0.07235483f, -0.22136647f, 0.02871353f, -0.05333384f, 
    0.17458630f, 0.28475815f, 0.05408253f, 0.11791878f, 0.03813296f, 0.11701813f, 0.09640978f, -0.19369929f, 
    0.01212006f, 0.03600213f, 0.03715900f, 0.02506699f, -0.18305375f, 0.07984903f, 0.08811940f, -0.01577617f, 
    -0.05694814f, 0.12968801f, -0.04295490f, -0.17504682f, 0.01931245f, 0.06445829f, -0.17140663f, 0.01675005f, 
    -0.15356210f, 0.10456418f, -0.24142961f, -0.13133593f, 0.02114023f, -0.02364156f, 0.01114147f, 0.00471332f, 
    0.29567298f, -0.03096746f, -0.15945019f, -0.18396461f, 0.48984578f, -0.01686148f, 0.02897717f, -0.04858419f, 
    0.22192517f, -0.05470379f, 0.00218246f, 0.02595849f, 0.18732364f, 0.07308280f, 0.06132274f, -0.01425555f, 
    0.11892556f, -0.09436713f, -0.24311237f, 0.00431873f, 0.02279497f, -0.00818011f, 0.05970095f, -0.00136955f, 
    0.01011784f, -0.05163810f, -0.01177962f, 0.20452484f, -0.06016325f, -0.08442845f, 0.11644759f, 0.01390569f, 
    -0.02646913f, -0.03623380f, -0.17963946f, -0.02311327f, 0.00412880f, -0.10747559f, 0.08237244f, 0.02141168f, 
    0.14547911f, -0.20015469f, 0.13731730f, -0.01250840f, 0.06342394f, 0.04291578f, -0.03527923f, 0.00108156f, 
    -0.03343225f, 0.00092362f, 0.00764134f, 0.12629750f, -0.34992579f, 0.04370718f, -0.00320462f, -0.01877767f, 
    0.02225746f, 0.06092788f, -0.15263747f, 0.01575053f, -0.13963556f, -0.10198888f, -0.03427119f, -0.04693510f, 
    0.03005065f, 0.14455159f, -0.09824357f, 0.16860689f, -0.00613139f, -0.06777051f, 0.07225077f, -0.10220612f, 
    -0.19467409f, 0.05638439f, -0.02498360f, 0.01192584f, 0.08621235f, -0.05812416f, -0.16428132f, -0.05533748f, 
    -0.04738697f, 0.06911017f, -0.16701289f, -0.12225649f, 0.08702154f, 0.01663296f, 0.04222499f, -0.09154195f, 
    0.13320920f, -0.01332331f, -0.11873652f, 0.05469119f, 0.16713731f, 0.08172896f, 0.03352286f, -0.15706088f, 
    -0.02753089f, -0.07102420f, 0.00754775f, -0.12868327f, -0.10149568f, 0.00946308f, 0.00103821f, -0.07678663f, 
    -0.08310096f, 0.01435223f, 0.07033632f, -0.06117739f, 0.16447820f, 0.11978693f, -0.02827378f, 0.24094629f, 
    -0.11745013f, -0.16113873f, -0.10609887f, 0.06025908f, 0.17887878f, -0.06211739f, -0.08543274f, 0.01234976f, 
    -0.03317425f, 0.00097100f, 0.00055022f, 0.00514685f, 0.03802885f, -0.02252620f, -0.21173778f, 0.06892029f, 
    0.07698204f, 0.07307493f, -0.13635068f, 0.02716463f, -0.06634496f, -0.05151267f, -0.05448499f, -0.06514143f, 
    -0.17988557f, -0.19115201f, -0.09658619f, 0.15134297f, 0.00066918f, 0.09187181f, 0.06464403f, 0.07011861f, 
    0.20652814f, 0.16756259f, 0.06951988f, 0.22405401f, 0.04172540f, 0.01963066f, -0.03459638f, 0.05203551f, 
    0.08764549f, -0.03174018f, -0.05090160f, 0.03001861f, 0.13828127f, 0.18636687f, 0.06241371f, 0.04774657f, 
    0.13126096f, 0.05077726f, 0.02304909f, 0.17463851f, 0.03055296f, -0.04853614f, 0.05058565f, 0.16121015f, 
    0.15092240f, -0.05203303f, 0.07252916f, 0.16801171f, 0.16352025f, 0.17775749f, 0.00192873f, 0.14410271f, 
    0.25289902f, 0.13706081f, 0.06726176f, 0.07203025f, -0.00602513f, -0.04833294f, -0.05064276f, -0.07521507f, 
    0.11016279f, -0.00411014f, -0.00268297f, 0.00442732f, 0.13355795f, -0.01587431f, 0.12648429f, 0.09291863f, 
    -0.04565299f, 0.13320760f, 0.11934660f, 0.25690502f, 0.08413352f, -0.01098160f, 0.16365924f, 0.07597671f, 
    -0.06028886f, 0.10236964f, -0.08153600f, -0.14161862f, -0.02590893f, -0.04984837f, -0.00885806f, 0.06645814f, 
    0.02468355f, 0.16473304f, 0.05390076f, 0.12823451f, -0.00542738f, 0.01484502f, 0.02670148f, -0.02395701f, 
    0.01167834f, 0.02906286f, -0.02858615f, 0.11388571f, -0.17324226f, 0.01717526f, 0.12189747f, 0.09756269f, 
    0.07111975f, -0.08711916f, -0.02250421f, -0.04364094f, 0.02771215f, 0.09994843f, 0.06177468f, -0.01267482f, 
    0.21307088f, 0.13879500f, -0.04518165f, -0.10859619f, 0.10096850f, 0.12405528f, -0.01506200f, 0.16801368f, 
    0.18786620f, -0.05447885f, -0.27893254f, -0.29334170f, -0.03159068f, -0.20974250f, -0.09217056f, 0.19867200f, 
    0.09704468f, -0.04550912f, -0.17322478f, 0.10136093f, -0.07146230f, 0.09961803f, -0.04978328f, -0.11201363f, 
    -0.00348293f, -0.06352367f, -0.15034232f, 0.04665810f, 0.05837173f, -0.06902644f, 0.04379825f, 0.03111437f, 
    0.02378329f, 0.09651064f, 0.05834857f, 0.04219057f, -0.10680696f, 0.44274208f, -0.33364314f, -0.17768164f, 
    -0.00718650f, -0.05468532f, 0.09480882f, 0.02021642f, -0.11623552f, 0.09676935f, -0.20906235f, -0.10081506f, 
    -0.17214976f, 0.19204395f, 0.19847222f, -0.06399117f, 0.07756097f, 0.08346428f, -0.07874309f, 0.02119767f, 
    0.05984654f, -0.05033251f, 0.03982727f, -0.03073556f, -0.04447111f, 0.12347410f, 0.07175393f, 0.12747997f, 
    0.03798195f, 0.08696333f, -0.10332134f, -0.00020667f, -0.10527301f, -0.22372402f, -0.26659510f, -0.19358082f, 
    -0.23718803f, -0.11743889f, -0.18933906f, 0.00698742f, -0.03764652f, 0.06925430f, -0.04839421f, -0.01783491f, 
    0.09446587f, 0.01109373f, 0.04158936f, 0.09447063f, -0.38949022f, -0.04856483f, 0.10357156f, 0.09812947f, 
    0.02579230f, -0.02209141f, -0.00277228f, 0.06497984f, -0.01502056f, 0.15638840f, 0.06522792f, 0.07161950f, 
    0.02871325f, -0.05020321f, 0.16966449f, 0.18144342f, 0.02141138f, -0.10117816f, -0.13375019f, 0.00908128f, 
    -0.00136482f, 0.10926480f, 0.22613677f, 0.11704481f, 0.14205503f, -0.03652001f, 0.43686616f, 0.18878932f, 
    0.00668799f, 0.03641619f, -0.06228724f, 0.01181946f, 0.05937175f, -0.04108498f, -0.03869452f, -0.13521606f, 
    -0.14637576f, 0.07804758f, -0.05687079f, -0.15215383f, 0.12734306f, 0.01170304f, 0.06051228f, 0.03468744f, 
    -0.18931639f, -0.04902677f, -0.18816099f, -0.29806274f, 0.06168252f, -0.03426740f, -0.19135624f, 0.16688348f, 
    0.11208323f, -0.03045206f, 0.01031565f, -0.07576868f, 0.05522997f, -0.03526460f, -0.11765130f, 0.12579632f, 
    0.03351349f, -0.08206826f, 0.32260486f, 0.16032524f, 0.05666363f, 0.03188071f, -0.05680127f, -0.21888383f, 
    -0.07044492f, -0.24815123f, -0.24535017f, -0.30258855f, 0.15869865f, 0.20739587f, -0.05283475f, -0.01157304f, 
    0.06835575f, -0.00351879f, 0.08437697f, 0.03404066f, 0.10888083f, 0.02950766f, 0.10256057f, 0.02856485f, 
    -0.39312169f, -0.06102277f, -0.16592957f, -0.05801874f, -0.01809169f, 0.01027657f, 0.12614875f, -0.02340313f, 
    0.20502003f, 0.13937747f, 0.03014250f, -0.08153866f, 0.19652723f, 0.06518710f, 0.06536008f, 0.12566036f, 
    0.11578781f, -0.12625886f, 0.06291156f, -0.03423883f, 0.01435591f, 0.01936559f, 0.08266844f, 0.06530850f, 
    0.08751439f, -0.08753905f, -0.00100407f, 0.27621120f, -0.05941679f, 0.05545794f, -0.02475490f, -0.14195311f, 
    0.20126049f, -0.02297222f, -0.14943314f, 0.22052099f, 0.25299960f, -0.13692501f, 0.24474497f, 0.05230400f, 
    0.18395698f, 0.12639184f, -0.13141252f, 0.09124289f, -0.03643376f, 0.01008915f, -0.06401460f, 0.04144947f, 
    -0.20338906f, -0.00633453f, 0.06564239f, -0.14856699f, 0.09002738f, -0.02519384f, -0.05343782f, 0.11018787f, 
    -0.07342914f, 0.05267125f, -0.09819345f, -0.13720867f, 0.27906683f, 0.19079041f, 0.10762694f, 0.16346681f, 
    0.07884642f, 0.01847968f, 0.08297073f, -0.14750242f, -0.02532494f, 0.05224748f, 0.05972353f, 0.16134709f, 
    -0.04555395f, 0.03960036f, -0.01262666f, -0.08846840f, -0.00372553f, 0.04698388f, -0.04816194f, -0.07721268f, 
    0.06633229f, 0.02273540f, -0.00967220f, -0.31509879f, -0.10055449f, 0.09601235f, -0.24237254f, -0.08661851f, 
    0.02743422f, -0.04332162f, -0.10369060f, -0.19666402f, -0.19744632f, -0.04970217f, 0.12032145f, -0.15645546f, 
    -0.09850759f, -0.06648175f, 0.01302746f, 0.20488331f, 0.21285641f, 0.02190908f, -0.19656684f, 0.09522291f, 
    0.01781171f, -0.10289306f, -0.07361522f, -0.06680295f, -0.34399188f, -0.09310084f, 0.02188555f, 0.26018271f, 
    0.05356549f, 0.13921030f, -0.28161889f, -0.13833776f, 0.06944511f, -0.04931616f, -0.02378719f, 0.13831958f, 
    0.07729173f, 0.11902289f, 0.02106684f, 0.10224465f, 0.14318275f, -0.03969162f, 0.01616742f, 0.07944509f, 
    0.00618137f, 0.00968292f, 0.06846928f, 0.02179841f, -0.39079008f, -0.13120243f, 0.01023526f, 0.11729185f, 
    -0.17153278f, 0.15865903f, -0.11871585f, -0.00111250f, -0.00939409f, 0.00917191f, 0.08584359f, -0.02955610f, 
    0.09480178f, 0.05616682f, 0.17580532f, 0.00980621f, 0.18407141f, 0.11641961f, 0.12884319f, 0.19097370f, 
    0.13279043f, 0.01076906f, 0.00191373f, 0.10417356f, 0.27428192f, -0.12495936f, 0.08091192f, 0.23911059f, 
    0.13228071f, 0.01912117f, -0.01795580f, -0.05020548f, 0.15901791f, 0.03011832f, 0.08835573f, 0.11186782f, 
    0.05413644f, -0.12403850f, -0.20293267f, -0.01223607f, 0.10637988f, -0.09346438f, 0.07965136f, 0.15023980f, 
    0.05621685f, 0.18579544f, 0.07742914f, 0.02940301f, 0.01812538f, 0.11446681f, -0.01943514f, -0.02062928f, 
    -0.00161895f, 0.05448309f, 0.03644843f, 0.03298881f, -0.02192343f, -0.01991093f, 0.15953694f, 0.17714697f, 
    0.14163272f, -0.01670416f, -0.04925096f, -0.07431240f, 0.10665490f, -0.11122548f, -0.08860304f, 0.11797146f, 
    0.05656614f, 0.00033592f, 0.10689916f, 0.08950495f, -0.18462834f, -0.04689198f, -0.21636222f, 0.03491888f, 
    -0.04949012f, 0.05036336f, -0.16582373f, -0.16949354f, -0.01455056f, -0.14654446f, -0.07802673f, -0.26547858f, 
    -0.14952265f, -0.04152323f, 0.07719295f, -0.04409538f, 0.03491746f, -0.03035125f, -0.01777620f, 0.06000885f, 
    0.05037927f, 0.03614828f, -0.06675864f, 0.00549005f, 0.32025000f, -0.25723362f, 0.17001753f, -0.01380326f, 
    0.06627071f, -0.03789574f, -0.20377845f, -0.00598966f, 0.01159179f, -0.05923198f, 0.13651223f, -0.03524737f, 
    0.22483252f, -0.20464970f, -0.04175373f, 0.21020445f, 0.01505302f, -0.07310463f, 0.03809725f, -0.04950392f, 
    0.11258761f, 0.07090122f, -0.05883684f, -0.11907378f, 0.01205103f, 0.12520842f, 0.21509965f, 0.14001411f, 
    0.15399383f, 0.17517337f, -0.05133522f, 0.03892108f, -0.21928631f, -0.27427608f, -0.22569312f, -0.20347039f, 
    0.08636652f, -0.09286148f, 0.00380763f, 0.06454811f, 0.06338146f, -0.08136395f, 0.12138446f, -0.00370635f, 
    -0.00588424f, 0.06561368f, 0.00281747f, 0.13271089f, -0.15702885f, 0.12277050f, 0.24538074f, 0.03168195f, 
    0.10585340f, 0.15571062f, -0.15140142f, -0.02317414f, -0.05327413f, -0.24345320f, -0.25626916f, -0.28427705f, 
    0.00022118f, 0.10136180f, -0.33707896f, -0.07443100f, 0.12255102f, 0.00468347f, -0.11247395f, -0.02242510f, 
    0.02215086f, -0.16848972f, -0.07341393f, 0.05962995f, 0.08026856f, 0.13657190f, -0.13790649f, 0.06623197f, 
    0.14608084f, 0.13121824f, -0.10296819f, 0.10860907f, 0.01477308f, -0.11678757f, 0.03258217f, -0.00853686f, 
    -0.03048927f, -0.00524807f, -0.02858264f, -0.02237504f, -0.01683293f, -0.02446693f, 0.00468806f, -0.01399677f, 
    0.01964683f, -0.03491823f, -0.00944010f, 0.01883036f, 0.02082126f, 0.01320383f, 0.03612942f, -0.01261412f, 
    -0.02498633f, 0.00503433f, -0.00746323f, 0.01512386f, -0.03809298f, 0.00632760f, 0.02822964f, 0.01908816f, 
    0.02782449f, -0.04014071f, -0.01591354f, 0.01344497f, -0.01254819f, 0.01913976f, 0.01099046f, 0.02026173f, 
    -0.02277823f, -0.02833302f, -0.03725218f, -0.02254019f, -0.00479206f, -0.01421692f, -0.01742416f, 0.03946518f, 
    -0.00064306f, -0.02315163f, 0.01317507f, -0.00110610f, -0.02675983f, -0.03190275f, -0.00323043f, -0.00623881f, 
    0.02156057f, -0.02545932f, 0.04206582f, -0.02193725f, 0.02009266f, 0.01256623f, -0.00883757f, -0.03390681f, 
    0.00711811f, -0.02230084f, -0.04100841f, -0.03553223f, -0.00806499f, 0.01432246f, 0.02495774f, -0.02053478f, 
    -0.01284776f, -0.03553503f, -0.00940346f, -0.03325591f, 0.01195558f, 0.02026375f, 0.00835113f, -0.00661957f, 
    -0.01371505f, -0.02344029f, 0.00352639f, 0.00862892f, 0.02441694f, 0.02063910f, -0.01886271f, 0.02474881f, 
    -0.01397035f, 0.02813040f, 0.00143551f, 0.02038337f, 0.01453186f, -0.03663637f, 0.00827541f, 0.00126522f, 
    -0.01492283f, 0.00292039f, -0.02105408f, -0.00502395f, 0.00304446f, 0.01950266f, -0.01790647f, 0.02539416f, 
    -0.00525248f, -0.01306510f, 0.01818820f, 0.01087429f, -0.02351785f, -0.04157347f, 0.02812759f, 0.01305035f, 
    0.02252175f, 0.02126321f, 0.02975389f, -0.01488731f, 0.02593138f, -0.00565698f, -0.01728419f, 0.00202220f, 
    0.00220449f, -0.02676490f, 0.01530564f, -0.02352153f, -0.03226114f, 0.01626697f, 0.01514617f, -0.04068459f, 
    -0.00446213f, -0.02878758f, 0.01029276f, -0.02462757f, 0.00657409f, 0.01433509f, -0.03721991f, -0.02165389f, 
    -0.02585425f, 0.01292387f, -0.01136022f, -0.01390268f, 0.01360261f, 0.02879004f, -0.02157946f, -0.02043569f, 
    0.00899418f, 0.00408461f, -0.03597159f, 0.00453975f, 0.02314699f, 0.02542741f, 0.00015925f, -0.00510100f, 
    0.02203997f, 0.02789358f, 0.00093593f, 0.00831144f, -0.00879388f, -0.01672140f, 0.01038834f, 0.02348815f, 
    -0.03232093f, -0.01593169f, 0.00640449f, 0.02717346f, -0.01322396f, 0.01932438f, -0.03125479f, 0.02687597f, 
    -0.03906876f, 0.01444205f, -0.01379289f, -0.01034760f, -0.00820882f, 0.01122854f, -0.03778411f, -0.01290669f, 
    -0.02269807f, -0.01652327f, 0.01695664f, 0.02916791f, 0.03796105f, -0.02258424f, 0.00131017f, -0.03682516f, 
    0.00786500f, -0.01576062f, -0.00099157f, -0.03957697f, 0.03153807f, 0.02199498f, -0.02197392f, 0.00106931f, 
    0.01054402f, 0.02443829f, 0.01033287f, -0.01915298f, 0.01335402f, 0.00068754f, -0.01644587f, 0.01460261f, 
    -0.01946012f, 0.00023346f, -0.03154854f, -0.01010331f, -0.01734617f, 0.00620345f, -0.00911492f, -0.00020319f, 
    0.02779987f, -0.02790320f, 0.02764824f, -0.04106358f, 0.01532358f, 0.02319258f, 0.03198750f, -0.02847620f, 
    0.02875083f, 0.01386834f, 0.01646124f, 0.02156171f, -0.02928295f, -0.02414422f, 0.01290757f, -0.03962764f, 
    0.02340913f, -0.02815286f, -0.02368166f, 0.01912080f, -0.02235004f, 0.01355584f, -0.01116410f, 0.00285690f, 
    -0.02857323f, -0.04201913f, 0.00487762f, 0.02967574f, -0.01745535f, -0.01720796f, -0.02297749f, -0.02032435f, 
    -0.03233424f, 0.02057072f, -0.00416522f, 0.02484268f, -0.00916476f, 0.01980238f, -0.01524738f, 0.00911437f, 
    0.00395993f, -0.03179098f, 0.03159961f, -0.04273121f, 0.01747155f, 0.02458425f, -0.03422949f, -0.01518096f, 
    -0.02184620f, 0.01942999f, 0.02128302f, 0.00211168f, -0.03445303f, -0.01229480f, -0.00055726f, -0.01401796f, 
    -0.01345431f, -0.00981923f, -0.00707845f, 0.02226188f, -0.00936541f, -0.02662511f, 0.01543371f, 0.01687609f, 
    -0.00290445f, 0.01177111f, -0.01057857f, -0.03282221f, -0.02148775f, -0.03013234f, -0.01343449f, 0.01916286f, 
    -0.03929037f, 0.00276822f, 0.00653428f, -0.00532173f, -0.00434529f, 0.03747126f, -0.03824404f, -0.02333440f, 
    0.00179834f, -0.03899748f, 0.00056633f, -0.02722819f, 0.00690017f, -0.01981225f, -0.01276676f, 0.01928413f, 
    0.01955179f, -0.01045715f, 0.01907024f, 0.01844457f, -0.02553889f, -0.03981683f, -0.00143818f, 0.01306881f, 
    -0.02230569f, 0.02884888f, 0.01804945f, -0.01365567f, 0.03355914f, -0.00304583f, -0.02890773f, -0.04076461f, 
    -0.03834366f, -0.02322543f, -0.02644000f, -0.02201389f, 0.00157179f, -0.01962516f, -0.03315131f, 0.02311057f, 
    -0.02916634f, -0.03860029f, 0.01014509f, -0.00902949f, 0.01522112f, -0.02563669f, -0.00486978f, -0.01264792f, 
    -0.03293322f, -0.00896213f, 0.01428720f, 0.01827164f, -0.01188908f, 0.02197218f, -0.00173535f, 0.03549258f, 
    0.00719314f, 0.01561132f, 0.01013135f, 0.01505924f, -0.02416009f, 0.02088506f, -0.00001762f, 0.00017789f, 
    -0.03317321f, 0.01892724f, 0.03525405f, -0.00768902f, -0.01306008f, 0.01168796f, -0.02033685f, -0.03810300f, 
    0.02597318f, 0.00243923f, 0.01504460f, -0.01991772f, 0.01081932f, 0.02731347f, -0.02527165f, -0.01996549f, 
    -0.00912663f, -0.00658330f, 0.02661524f, 0.02324506f, -0.02568737f, 0.02889977f, 0.01669292f, 0.03369182f, 
    -0.00172648f, -0.00617326f, -0.00132761f, -0.00098323f, 0.03270737f, 0.01007034f, 0.04042010f, 0.03014622f, 
    -0.03268960f, -0.01108557f, 0.01225661f, 0.00865473f, -0.00524850f, -0.00055731f, -0.01785338f, 0.01264258f, 
    -0.00034335f, 0.01384288f, -0.03780762f, -0.00133446f, 0.01900481f, 0.02330811f, -0.01906852f, 0.01558784f, 
    0.00113884f, 0.01081047f, -0.03476449f, -0.01948453f, -0.02752632f, -0.02659385f, -0.00874977f, 0.03311994f, 
    0.02669693f, -0.01373946f, 0.01734556f, -0.01645785f, -0.01547115f, -0.01088724f, 0.02247440f, 0.01605507f, 
    -0.02201277f, -0.01610451f, 0.02186060f, 0.02310205f, -0.02054514f, 0.01665845f, 0.02705017f, 0.00410712f, 
    0.01558261f, -0.00762200f, 0.01965008f, 0.00156388f, -0.00682547f, 0.01617546f, -0.03291646f, 0.02333400f, 
    -0.01499095f, -0.01065677f, 0.00949300f, 0.02508722f, 0.00359301f, -0.02863055f, -0.00132505f, 0.00624306f, 
    0.02513256f, -0.03369639f, -0.02155883f, 0.00394556f, -0.02715793f, -0.01229963f, 0.02882131f, 0.02014264f, 
    0.02805330f, 0.01985379f, -0.01499492f, -0.01560738f, 0.01939076f, -0.01709297f, 0.02142714f, -0.01287178f, 
    0.00881302f, -0.02481625f, 0.01186970f, -0.02810461f, -0.03848167f, 0.01015888f, 0.00072821f, -0.01327999f, 
    -0.03557098f, -0.00685179f, 0.03840004f, 0.03272207f, 0.03030602f, 0.01993643f, 0.02880148f, -0.01434902f, 
    -0.00897501f, 0.00508689f, 0.00823101f, 0.00776362f, 0.00759057f, 0.03766863f, -0.00662531f, 0.00245150f, 
    -0.02509057f, 0.02429635f, -0.03602643f, 0.02528896f, 0.01757207f, -0.00244355f, -0.02739172f, -0.00223316f, 
    -0.02691142f, -0.03450417f, 0.00345944f, -0.00505044f, -0.03464272f, -0.01771906f, -0.02537736f, -0.03968498f, 
    -0.00617422f, -0.01218748f, 0.00620843f, 0.01054288f, 0.01070871f, 0.01308202f, -0.01296370f, -0.01323321f, 
    0.00492858f, -0.03597462f, 0.02285784f, -0.00830114f, 0.01803731f, 0.02596281f, -0.04239406f, -0.03542253f, 
    0.01346668f, -0.03951877f, -0.02970945f, 0.00852347f, -0.00017590f, -0.01614933f, 0.02971708f, -0.01407766f, 
    -0.01788854f, -0.00087005f, 0.00034682f, 0.00171178f, 0.02974783f, 0.01791619f, -0.02892605f, 0.01153715f, 
    -0.03089100f, -0.03761789f, -0.03494157f, -0.03791472f, -0.00271376f, -0.02278852f, -0.01859637f, -0.04170220f, 
    -0.00277675f, -0.02858643f, 0.04019268f, -0.03146857f, 0.00526157f, 0.02809954f, -0.02545998f, -0.02740640f, 
    -0.01521304f, -0.03404824f, 0.02037518f, 0.02084322f, 0.00135426f, -0.04055485f, -0.01033899f, 0.02300946f, 
    -0.00938497f, -0.00004549f, 0.02286191f, -0.00367577f, -0.04107019f, -0.00674631f, 0.01065627f, 0.00291424f, 
    -0.00422250f, -0.00738789f, 0.02387784f, -0.03960655f, -0.04167194f, 0.01656538f, -0.03460327f, 0.02014601f, 
    0.01321614f, 0.00223240f, 0.03748353f, 0.02291815f, -0.01694278f, -0.00225527f, -0.03921129f, 0.03000391f, 
    0.01054859f, 0.02633228f, -0.02609858f, -0.03075242f, 0.02128320f, -0.01483777f, -0.01822251f, 0.03133964f, 
    -0.03577341f, -0.03414872f, 0.03812766f, 0.02223052f, -0.02491691f, -0.03409649f, -0.00921243f, 0.00196109f, 
    -0.02842097f, -0.03315715f, -0.03086633f, -0.03793941f, -0.01353874f, 0.00474250f, -0.02765370f, 0.02746655f, 
    0.01743105f, 0.01824151f, 0.01185813f, 0.01505544f, 0.02145360f, 0.02071883f, -0.00939329f, 0.01662287f, 
    -0.02309902f, -0.01065775f, -0.00774791f, -0.00335272f, 0.01202949f, 0.00817862f, 0.01706469f, -0.02184593f, 
    0.00698556f, -0.02170363f, 0.00811955f, -0.00464523f, 0.02789216f, -0.02046707f, 0.02889913f, -0.01243477f, 
    -0.02589075f, 0.00704154f, 0.00379173f, 0.00294775f, -0.02945512f, -0.02635630f, -0.01739167f, -0.02245083f, 
    -0.01781747f, 0.01584843f, -0.02951070f, -0.03056826f, -0.00819013f, -0.00426259f, 0.02323785f, -0.02638288f, 
    0.02789464f, -0.02093701f, -0.02284754f, -0.02679228f, 0.00477333f, 0.01215056f, -0.03274160f, 0.00747835f, 
    0.01290731f, -0.01709872f, -0.01687064f, 0.00149134f, 0.01349413f, 0.01883482f, 0.01835918f, -0.03082443f, 
    -0.01219375f, -0.00327265f, -0.00594604f, 0.00607036f, 0.00313929f, -0.00190070f, -0.04203929f, 0.02944101f, 
    0.00821516f, -0.00407187f, 0.00004492f, 0.00056494f, -0.03047444f, -0.02707600f, -0.03817806f, 0.00930151f, 
    -0.01368018f, -0.01896044f, 0.00865250f, -0.03347481f, -0.02048933f, -0.00724194f, -0.02114188f, -0.00424648f, 
    0.03369531f, 0.00182730f, 0.01946636f, -0.02168174f, 0.01609952f, -0.03019728f, 0.01362533f, -0.00809169f, 
    -0.02473028f, -0.01056378f, 0.01733812f, 0.00590676f, -0.02962108f, 0.01539901f, -0.00784719f, -0.01117889f, 
    0.02356742f, 0.00839431f, -0.02525038f, 0.00750882f, -0.03365415f, 0.00768173f, -0.03664553f, -0.00095479f, 
    0.00300012f, -0.00249416f, -0.00635160f, -0.03164637f, 0.00331442f, -0.01387128f, 0.02001004f, -0.04065910f, 
    0.01761377f, -0.04130510f, 0.00406677f, -0.02834508f, 0.02909824f, -0.00036887f, 0.02839477f, -0.00442294f, 
    -0.02735138f, -0.03206633f, -0.03928950f, 0.00734355f, -0.01035017f, -0.02184677f, -0.01066380f, 0.03884710f, 
    -0.02839104f, 0.02223719f, -0.04033043f, 0.02839926f, -0.01605248f, -0.00201280f, -0.00343090f, -0.03903010f, 
    0.00942337f, 0.02276583f, 0.00632898f, -0.00886727f, -0.01549183f, -0.04051286f, -0.01318044f, -0.02893616f, 
    -0.00961963f, -0.02483379f, 0.01787461f, -0.00100037f, 0.02291098f, -0.00190366f, -0.01640883f, 0.01696889f, 
    -0.03346510f, -0.02457841f, 0.02095598f, -0.03486690f, -0.02318541f, -0.00237292f, -0.01049191f, 0.01097556f, 
    0.02165466f, 0.01752208f, -0.03071411f, 0.00179191f, -0.01814322f, -0.00017371f, 0.01757865f, 0.00441183f, 
    -0.01978458f, -0.01014282f, -0.02869815f, -0.02094181f, -0.02301224f, -0.01553644f, -0.02963811f, 0.00122887f, 
    0.00673840f, -0.00613597f, -0.02953370f, -0.00572313f, -0.01169747f, 0.02018669f, 0.03419007f, 0.01935503f, 
    -0.06559958f, -0.14346515f, -0.01535819f, -0.19039026f, 0.05544182f, -0.01929838f, -0.02846924f, 0.03772574f, 
    0.05684072f, 0.02016076f, 0.00311906f, 0.04732422f, 0.19057834f, -0.25848573f, -0.14646828f, -0.04328793f, 
    0.17357351f, 0.11249969f, -0.22677583f, 0.17713663f, 0.12139226f, -0.05886493f, 0.03633589f, 0.10846531f, 
    -0.07102225f, -0.10203645f, -0.28966478f, -0.25134712f, 0.00564369f, -0.02958924f, -0.01213790f, -0.04330422f, 
    0.10126572f, 0.04463101f, 0.02052199f, -0.02363036f, -0.09158857f, -0.19578728f, 0.01266306f, 0.06811912f, 
    -0.01009059f, -0.07676503f, -0.00623132f, -0.14455827f, 0.16532148f, -0.00055812f, 0.01894232f, 0.04975697f, 
    0.09533889f, -0.15063721f, 0.08221750f, -0.21020110f, 0.05871043f, -0.08712226f, -0.00550555f, 0.08549359f, 
    -0.14595723f, 0.01668809f, 0.01445373f, -0.13221955f, -0.46973136f, -0.29984251f, -0.29905391f, -0.26565748f, 
    -0.02078901f, -0.07297550f, -0.08254155f, -0.01309566f, 0.04521991f, -0.13804175f, -0.03713167f, 0.02274308f, 
    -0.23649995f, -0.28228250f, 0.19041757f, -0.00384754f, 0.00169192f, 0.11126544f, -0.04295890f, -0.10452291f, 
    0.05944182f, -0.10363001f, 0.11418255f, 0.00223609f, -0.25987875f, 0.19656129f, 0.14911349f, -0.26157677f, 
    -0.08291773f, 0.03444647f, 0.12497353f, 0.00927313f, 0.01803271f, -0.00360804f, 0.11278271f, 0.02260713f, 
    0.02811547f, 0.15576415f, 0.35990098f, 0.02323606f, -0.03951872f, -0.02932079f, 0.09835201f, 0.08377867f, 
    0.06701699f, 0.10374423f, 0.04196328f, 0.07776683f, 0.16995779f, 0.41881791f, 0.17084225f, 0.01081553f, 
    -0.15635501f, 0.10808373f, 0.14904201f, 0.09602029f, 0.02237392f, 0.01332708f, -0.03496841f, 0.04146457f, 
    -0.17671596f, -0.30523697f, 0.08261554f, -0.29666001f, -0.02231303f, -0.08682900f, -0.02746778f, -0.01906054f, 
    -0.00910922f, -0.11383088f, 0.03684178f, -0.07692707f, 0.12016243f, -0.20008492f, 0.14645813f, 0.10642675f, 
    0.10741515f, -0.02898229f, -0.02060715f, 0.01205056f, 0.04314281f, 0.00233651f, -0.09989884f, 0.06895415f, 
    -0.12931587f, 0.05182990f, 0.08508547f, -0.36036009f, -0.02503772f, -0.03289004f, -0.07311149f, -0.04205336f, 
    0.08515522f, -0.06845727f, -0.03854707f, -0.02670250f, 0.09924507f, -0.23654865f, 0.32284129f, 0.18041685f, 
    -0.02047291f, 0.14560685f, -0.08498256f, 0.02098203f, 0.06847145f, 0.00379958f, 0.10873469f, 0.15374556f, 
    -0.07702579f, 0.05349550f, -0.11801737f, -0.03327180f, -0.13221194f, -0.10321871f, -0.13714267f, -0.04634686f, 
    0.02091228f, -0.01814754f, -0.04164600f, 0.09578728f, 0.09855596f, -0.07556946f, -0.06518819f, -0.06836860f, 
    -0.00999618f, -0.06446033f, -0.14601552f, 0.04462392f, 0.01865070f, -0.07063986f, -0.00874986f, 0.09296396f, 
    0.07889618f, 0.01231560f, -0.01459605f, -0.11541722f, -0.09095509f, -0.14741282f, 0.05489235f, 0.01486535f, 
    0.14191666f, 0.07782422f, 0.17095056f, 0.10260223f, -0.15416944f, 0.04999909f, -0.06583166f, -0.09542191f, 
    -0.06099457f, -0.29914987f, -0.07612056f, -0.24108027f, -0.04312843f, -0.05590992f, 0.02389218f, 0.02083300f, 
    0.06230895f, 0.18571602f, 0.00804853f, 0.28473026f, -0.11172279f, 0.07999946f, 0.03507006f, 0.06252642f, 
    0.03691074f, 0.07814532f, 0.01546808f, 0.18143299f, -0.40781224f, -0.22708592f, -0.30150342f, -0.31680748f, 
    -0.09688432f, 0.02589604f, -0.02390354f, -0.04719135f, 0.01672134f, -0.00870940f, -0.04881005f, -0.01925598f, 
    -0.04675177f, -0.23973359f, 0.13722001f, 0.03960060f, 0.05270627f, 0.01757863f, 0.03974082f, 0.07347804f, 
    0.12977917f, -0.05612588f, -0.02670467f, 0.10884956f, -0.23838581f, -0.08990771f, -0.15647396f, -0.07850891f, 
    -0.06416238f, -0.12630923f, -0.09476589f, 0.03080144f, 0.04315624f, 0.02348669f, -0.09574349f, 0.05206351f, 
    0.08448499f, 0.04859369f, 0.23022261f, 0.14772414f, -0.05252462f, 0.06714422f, -0.05075868f, 0.10912018f, 
    -0.01034830f, 0.01299493f, 0.02619223f, -0.06126579f, 0.26010188f, 0.01136083f, 0.14895406f, -0.01575758f, 
    -0.02117359f, -0.09977344f, -0.21451870f, 0.19119813f, 0.07142618f, 0.03192997f, 0.04766824f, 0.03392985f, 
    -0.20411456f, -0.27601108f, -0.17053980f, -0.10329831f, 0.02910042f, -0.13177124f, -0.00987585f, -0.11314791f, 
    -0.08072142f, -0.10926668f, -0.07354573f, -0.03601522f, -0.00577427f, 0.09783319f, -0.19299036f, 0.05996809f, 
    -0.04856290f, -0.01144718f, -0.11174110f, -0.07511731f, -0.03291065f, -0.09352045f, 0.08863358f, -0.01777601f, 
    0.18296306f, -0.09753095f, 0.00647422f, -0.07992333f, 0.00252496f, 0.03772238f, -0.00552055f, 0.00272248f, 
    0.06379397f, 0.07906111f, 0.10535298f, 0.05612322f, 0.22144453f, -0.07996117f, -0.00964606f, 0.05904577f, 
    0.02865838f, -0.20976330f, 0.04938488f, -0.01014854f, 0.04133803f, 0.02852250f, 0.07438991f, -0.11442836f, 
    -0.16138411f, -0.11933047f, -0.26004437f, -0.04651496f, 0.12018560f, 0.03871883f, 0.04355891f, 0.11237618f, 
    0.20734957f, -0.06242691f, 0.10931865f, -0.01512898f, -0.17772488f, 0.01583992f, -0.04591212f, -0.21454452f, 
    0.05685113f, -0.04674907f, 0.03444925f, -0.09066602f, -0.08226322f, -0.08746085f, -0.05838815f, -0.07992364f, 
    0.08487222f, 0.12751208f, 0.12400975f, -0.03410071f, 0.10076988f, 0.01205328f, 0.04032444f, -0.07066047f, 
    0.04835334f, 0.11648479f, 0.06183892f, 0.07143380f, 0.09084780f, 0.53810966f, 0.14240295f, 0.23261736f, 
    -0.07726060f, 0.12198584f, 0.14599840f, -0.16575740f, 0.00982798f, 0.09910567f, 0.12663235f, 0.13971174f, 
    -0.13692178f, 0.06885255f, -0.15843967f, 0.18043488f, -0.04859734f, -0.12805024f, -0.05891863f, -0.10169520f, 
    -0.02642153f, 0.09460246f, 0.11573607f, 0.03109332f, -0.36822757f, -0.10495660f, -0.14596789f, 0.04852500f, 
    0.02873683f, 0.04428791f, 0.05195670f, 0.03065672f, 0.05421942f, 0.01850059f, 0.01125041f, 0.06574716f, 
    -0.06859846f, 0.14287384f, -0.07805167f, 0.15781333f, -0.01242563f, -0.01693372f, 0.06247146f, -0.14279780f, 
    -0.06490479f, 0.00812353f, -0.01168144f, 0.04604859f, -0.00757764f, 0.16994634f, 0.37721768f, 0.20323069f, 
    -0.17821831f, 0.01407920f, 0.02680959f, 0.02661611f, 0.00812711f, -0.02604837f, -0.00058654f, 0.07192842f, 
    0.05081357f, -0.00877510f, -0.18953229f, 0.20454948f, -0.08270799f, 0.00840454f, -0.13828243f, 0.12567361f, 
    -0.03668203f, -0.20967555f, 0.08312825f, 0.08794509f, -0.35125801f, -0.40954745f, -0.01220523f, -0.18026029f, 
    -0.03326440f, 0.06856844f, 0.03887500f, -0.13820729f, 0.02427958f, 0.06510320f, 0.08850388f, 0.00248346f, 
    0.05757723f, 0.13368201f, 0.05450378f, -0.09136172f, -0.00843309f, 0.02112774f, -0.00003386f, -0.14263053f, 
    0.16700186f, 0.12432037f, 0.12358827f, 0.13375366f, 0.20899257f, 0.36204997f, 0.13615246f, 0.26859912f, 
    -0.09506697f, -0.07868989f, 0.04814568f, 0.01755547f, 0.01488291f, 0.06880845f, -0.01463671f, -0.02715923f, 
    0.30467382f, 0.11906564f, -0.02821098f, 0.13732524f, -0.09097426f, 0.09196605f, -0.00543076f, -0.07076984f, 
    0.00245032f, -0.00106412f, 0.00763286f, 0.17431715f, -0.23188120f, 0.08657564f, -0.57439744f, -0.05737263f, 
    -0.08154869f, -0.01665918f, -0.06342752f, 0.09810031f, 0.04947291f, 0.00663571f, 0.15470845f, 0.01650951f, 
    0.09002969f, 0.31418431f, 0.32529142f, -0.04785200f, -0.01137178f, -0.03715244f, 0.15369517f, -0.07361999f, 
    0.01071119f, -0.06939038f, -0.02461072f, 0.10038722f, -0.07132754f, -0.39080605f, -0.27261436f, -0.16625939f, 
    -0.08588749f, 0.05203214f, -0.11255716f, -0.13305759f, 0.16209100f, 0.13334522f, -0.05547961f, -0.00325347f, 
    -0.35064501f, -0.03492806f, 0.09890908f, -0.27426681f, 0.15548877f, -0.03457368f, -0.03988478f, -0.14377895f, 
    0.04866776f, -0.11174680f, -0.06735074f, 0.08568844f, 0.05821776f, 0.06127302f, 0.16610970f, -0.17930357f, 
    -0.10533801f, 0.05744555f, -0.00761042f, -0.06023734f, 0.06066946f, 0.07407812f, -0.04923673f, 0.17221065f, 
    -0.31370530f, 0.07512520f, -0.15564708f, -0.04860982f, -0.15113363f, 0.01203782f, 0.02059538f, -0.14879034f, 
    0.04149031f, -0.02999501f, -0.07177293f, -0.03064767f, -0.06807414f, -0.09535468f, -0.12369944f, 0.05834234f, 
    0.01715775f, -0.04601647f, 0.02152124f, -0.12293109f, 0.11211904f, -0.08326795f, 0.01064007f, -0.00306591f, 
    -0.03069134f, -0.23322299f, -0.06800482f, -0.12085782f, -0.16197920f, -0.03767385f, 0.02514675f, 0.02572648f, 
    -0.01921050f, -0.01601756f, 0.00465356f, 0.01660659f, 0.00756366f, 0.49337855f, -0.00509267f, -0.32375652f, 
    0.07502326f, -0.12356910f, 0.05373019f, -0.02756139f, 0.05827389f, 0.03986143f, 0.03288702f, 0.14502810f, 
    -0.23069584f, -0.38080454f, -0.24624176f, -0.14567031f, 0.01276047f, 0.08922102f, 0.03298165f, 0.02972367f, 
    -0.00647612f, -0.05834272f, -0.00144967f, 0.03677496f, -0.15950459f, 0.19735883f, 0.39387926f, -0.08306924f, 
    -0.08275931f, 0.00947515f, 0.01494714f, 0.09878748f, 0.05689355f, -0.05650510f, 0.09596745f, 0.05977304f, 
    0.16770896f, 0.11552107f, 0.05910035f, -0.00261139f, -0.09100378f, -0.05597591f, -0.11809126f, 0.03963519f, 
    0.14690904f, 0.03526239f, -0.01450234f, 0.18770412f, 0.01665531f, 0.01145264f, 0.01588884f, 0.17453541f, 
    0.07446880f, -0.04362958f, 0.15580274f, 0.10162781f, 0.06694797f, 0.23867585f, -0.07875700f, 0.16402283f, 
    -0.09463168f, 0.00388277f, 0.17812802f, 0.13892134f, 0.01381517f, -0.05084018f, 0.06314925f, 0.19262578f, 
    0.01155809f, -0.11270364f, 0.06080540f, -0.08619293f, -0.05815489f, 0.17972304f, -0.04190528f, -0.22002354f, 
    0.07374264f, -0.10675804f, -0.08958949f, -0.19395448f, -0.04961079f, -0.00630643f, -0.10568448f, -0.00379651f, 
    0.17871042f, 0.01969968f, 0.10802309f, 0.06550392f, -0.05015343f, -0.06496749f, 0.05432806f, 0.11983986f, 
    -0.05557019f, 0.08664073f, 0.13669397f, 0.00246307f, 0.04156474f, 0.22790350f, -0.10536103f, 0.01607076f, 
    0.01562569f, 0.02860828f, 0.02961279f, 0.09934085f, -0.08027721f, 0.18570219f, 0.11096799f, 0.01035208f, 
    0.04328072f, 0.17555360f, 0.08201981f, -0.17362484f, -0.05285634f, -0.07032535f, 0.03405091f, 0.12597561f, 
    -0.06526621f, 0.06426639f, 0.08059732f, -0.02573635f, -0.16078503f, -0.21659653f, -0.04481801f, 0.07547210f, 
    0.01115495f, -0.25871733f, -0.04231206f, -0.04207342f, -0.01112915f, -0.13325253f, -0.16721338f, -0.10093462f, 
    -0.08257949f, 0.23134886f, 0.08712868f, 0.06449246f, -0.11729130f, 0.11472558f, 0.09748749f, -0.05587184f, 
    0.12819579f, 0.08494321f, -0.00877094f, 0.11019018f, -0.01577321f, 0.05305622f, -0.08099908f, 0.08791050f, 
    -0.00811331f, -0.01595042f, -0.08586671f, 0.05622161f, -0.03056357f, -0.10221402f, 0.04926021f, -0.11809933f, 
    0.13292252f, 0.17258975f, -0.17716902f, 0.18472330f, 0.08137796f, -0.00786190f, -0.02375094f, -0.06142763f, 
    0.11819703f, 0.12059248f, 0.07118935f, 0.10061472f, -0.26945385f, -0.25043085f, -0.02793483f, -0.31659892f, 
    -0.08076520f, -0.09079824f, 0.02391584f, -0.01542154f, 0.08861332f, -0.01658414f, 0.00572686f, -0.01854099f, 
    -0.02399450f, -0.02754246f, 0.02655486f, 0.01549930f, -0.00851330f, -0.01446152f, -0.01335333f, 0.00883639f, 
    -0.03095703f, -0.00971035f, -0.02035211f, 0.01536972f, 0.01937208f, -0.03738614f, -0.00251725f, -0.00333087f, 
    0.00360448f, -0.00396302f, 0.02767394f, 0.00142336f, -0.01933817f, -0.02491143f, 0.01084801f, 0.01631411f, 
    0.00395731f, -0.03051901f, -0.02994320f, -0.03694763f, 0.00651717f, 0.00432318f, 0.03355761f, 0.00043742f, 
    0.00526816f, -0.01782317f, -0.02354704f, -0.02147268f, -0.03255443f, 0.02731641f, 0.00596117f, -0.00358773f, 
    0.02588794f, -0.02249743f, -0.00367657f, -0.00889942f, 0.01001655f, -0.02713294f, -0.00555868f, -0.01900929f, 
    -0.03594357f, -0.04351567f, -0.03389278f, 0.00025984f, 0.01840586f, 0.01724774f, -0.01843686f, -0.01027109f, 
    0.01104849f, 0.02186820f, -0.02095422f, 0.00888415f, -0.03391143f, -0.01839933f, 0.02535087f, -0.01301479f, 
    0.02190148f, 0.00463241f, -0.00093415f, 0.02757744f, 0.02022686f, -0.02689669f, -0.02628150f, 0.01362149f, 
    -0.00369279f, -0.02767442f, -0.01933035f, 0.02749107f, 0.03171756f, 0.01884009f, -0.02280426f, -0.01978957f, 
    -0.00678951f, -0.02534617f, -0.01882900f, 0.03114828f, 0.00480707f, 0.02484607f, 0.03174250f, -0.01441915f, 
    0.00906190f, 0.00292295f, -0.03638839f, 0.01392272f, 0.01015339f, 0.00450770f, -0.01260542f, 0.01417465f, 
    -0.00352436f, -0.02719881f, -0.02495728f, 0.00390668f, 0.00947659f, -0.04034607f, 0.02314894f, -0.03580285f, 
    0.01378154f, -0.01662236f, -0.02459381f, 0.01483358f, 0.01890860f, -0.03607056f, 0.02178508f, -0.00299116f, 
    -0.03735893f, -0.01382293f, -0.02003692f, -0.04005190f, 0.02198295f, 0.00947373f, -0.03974079f, 0.01478532f, 
    0.03454570f, -0.01941810f, -0.00667369f, 0.01244736f, -0.03047114f, -0.01292185f, 0.00758330f, -0.03002545f, 
    -0.03927385f, -0.03072643f, -0.00331117f, 0.02791251f, -0.01852415f, -0.00831425f, -0.03486735f, 0.01653755f, 
    -0.00294802f, 0.02698632f, 0.02841476f, 0.02691189f, -0.01677770f, -0.02498149f, 0.01418606f, 0.00679362f, 
    -0.02364708f, -0.01784498f, 0.03672163f, 0.01462425f, -0.03354753f, -0.00997271f, -0.01093658f, 0.03030977f, 
    -0.01109188f, -0.03372171f, 0.02175909f, 0.00127360f, 0.02198458f, -0.02000198f, 0.02732379f, 0.02359419f, 
    -0.01912562f, 0.01855040f, -0.01005886f, -0.04056997f, 0.02891120f, 0.01054850f, -0.01762357f, -0.03068283f, 
    -0.00319983f, 0.01061492f, 0.01052387f, 0.02126438f, 0.00368315f, 0.01210388f, -0.00105853f, 0.02732796f, 
    -0.00453577f, 0.02460246f, 0.01663053f, -0.00938712f, -0.01260307f, 0.02085267f, 0.02047024f, -0.01242895f, 
    -0.02015332f, -0.02933789f, 0.00834075f, -0.00164467f, -0.01142171f, 0.02111586f, -0.00745518f, -0.01260740f, 
    -0.02617264f, -0.03919818f, -0.01560861f, -0.00742607f, -0.00852399f, 0.01840712f, -0.02058492f, -0.02548234f, 
    0.00653482f, 0.01751327f, 0.02299276f, -0.01214681f, -0.03825530f, -0.01024935f, -0.00480415f, -0.00908197f, 
    -0.02182927f, 0.02292378f, -0.00404100f, -0.02670786f, 0.01370830f, 0.01419726f, -0.00747870f, -0.01749026f, 
    0.00040627f, 0.01020830f, -0.01685887f, -0.01865860f, -0.01978404f, 0.00638397f, -0.02834808f, -0.02165704f, 
    0.00208275f, -0.03644439f, -0.02763490f, -0.03262794f, 0.00273025f, -0.00111370f, 0.02582747f, -0.00826040f, 
    0.00733145f, 0.01006617f, 0.00934748f, -0.02193491f, -0.04092894f, -0.01890290f, -0.00441995f, -0.04390093f, 
    0.00965687f, -0.00475454f, -0.00915364f, -0.01017120f, 0.01470207f, -0.03788140f, 0.02829797f, 0.02692408f, 
    -0.01060587f, 0.00737600f, 0.00555717f, -0.03011511f, -0.01738240f, 0.02212406f, 0.00075233f, -0.02591768f, 
    0.00373727f, -0.01643304f, -0.03647977f, -0.01578436f, 0.01380293f, 0.00754842f, -0.02687758f, 0.01836010f, 
    -0.01754418f, -0.01213620f, 0.00407104f, -0.01956869f, -0.01471293f, -0.02579297f, 0.00901556f, -0.02871685f, 
    0.03365026f, -0.02149505f, 0.01078165f, 0.02271701f, -0.04017651f, 0.00864556f, -0.00831732f, 0.02202958f, 
    -0.00883296f, 0.00594523f, -0.00742059f, -0.03190712f, -0.04295761f, -0.00166292f, -0.02123026f, -0.02498918f, 
    0.01887645f, -0.03735192f, -0.01815377f, -0.03233448f, -0.02095997f, 0.01425212f, 0.02494661f, -0.00678578f, 
    -0.02513383f, 0.02253382f, -0.00675468f, 0.00105691f, -0.01137205f, -0.04077423f, -0.02099969f, -0.00036199f, 
    0.01300231f, 0.00171399f, 0.02258781f, -0.03559815f, 0.02486804f, -0.02159182f, -0.03905286f, 0.01324311f, 
    -0.00805849f, 0.00754400f, 0.02377763f, -0.03664984f, 0.00613307f, -0.02542019f, -0.01398489f, 0.01746548f, 
    0.00236509f, 0.00165340f, -0.01269866f, -0.02844838f, 0.02227973f, -0.02569325f, -0.01358934f, 0.00504244f, 
    -0.02012652f, -0.02813873f, -0.00545082f, 0.00706499f, 0.01102444f, -0.00275262f, 0.01476039f, -0.03738524f, 
    -0.03324568f, 0.00274831f, -0.00649710f, -0.01336087f, 0.00309343f, 0.00741896f, -0.02561452f, -0.00315057f, 
    -0.04392027f, -0.01637932f, -0.03184082f, 0.02552272f, -0.02633882f, -0.00984329f, -0.00337088f, -0.00609683f, 
    -0.01883462f, 0.00874526f, -0.01722394f, 0.01914027f, 0.02188733f, 0.01834689f, 0.00530333f, 0.01863088f, 
    -0.01176857f, 0.01953326f, -0.02220669f, -0.03191924f, 0.01692776f, -0.01792572f, -0.01166346f, -0.00785726f, 
    0.00215195f, -0.01684532f, -0.03754028f, -0.00921687f, -0.04408861f, 0.00151817f, -0.01973641f, 0.00842285f, 
    -0.01424561f, -0.02184259f, -0.01535197f, -0.00344432f, -0.00748123f, -0.02265511f, 0.01423821f, 0.02388063f, 
    0.00626542f, 0.01396315f, -0.03751988f, 0.00743491f, -0.02376786f, -0.03621930f, -0.01300510f, -0.02935804f, 
    0.02276043f, -0.02823206f, 0.00138480f, -0.03590779f, 0.02291333f, -0.00506361f, 0.00013145f, -0.02466890f, 
    0.02296966f, 0.01712943f, -0.02628442f, 0.03441302f, -0.02204476f, -0.02676796f, 0.02335074f, -0.00564166f, 
    -0.00909773f, -0.01213396f, -0.00627368f, -0.02963476f, -0.00564621f, -0.01427809f, -0.00766194f, -0.03479345f, 
    0.00357978f, -0.00222764f, -0.03408937f, -0.04278684f, 0.01893545f, 0.01115271f, -0.01072793f, 0.02893173f, 
    -0.01295732f, 0.02330472f, -0.00945420f, -0.00223837f, 0.03137942f, -0.00317208f, -0.02580370f, 0.01892879f, 
    -0.04032356f, -0.02047808f, -0.03000957f, -0.04376467f, 0.01640104f, -0.01465379f, -0.02925936f, -0.01561275f, 
    -0.03059743f, 0.00219351f, -0.02208183f, -0.02045008f, -0.03335139f, 0.01262174f, -0.02954024f, -0.01404458f, 
    -0.03998570f, 0.02020909f, 0.01652789f, 0.01845371f, -0.02846125f, 0.00726097f, 0.00441807f, 0.02437800f, 
    -0.03236320f, -0.02378625f, -0.00764667f, -0.04448267f, -0.01659222f, -0.00076405f, -0.02103612f, -0.01824608f, 
    -0.01900787f, -0.00702089f, 0.00342211f, 0.00529958f, 0.02948326f, -0.03473300f, -0.01684930f, -0.01662250f, 
    0.01097534f, -0.01709723f, -0.01377748f, -0.01673581f, -0.00026071f, 0.01094348f, 0.00810589f, -0.03718353f, 
    0.00021004f, 0.00531196f, -0.04389607f, -0.00247853f, -0.04044239f, -0.01005760f, -0.01920819f, -0.03013063f, 
    -0.03473425f, 0.02491160f, 0.02484062f, 0.02564896f, 0.01566320f, 0.01729256f, -0.04325597f, -0.01171056f, 
    0.01394172f, 0.01819071f, -0.02086548f, -0.00406945f, 0.02720693f, -0.00542263f, 0.01207351f, 0.01094247f, 
    -0.02823938f, 0.02297023f, -0.01374891f, 0.00380608f, 0.01166693f, 0.01459125f, -0.00314753f, -0.03251102f, 
    0.01120997f, 0.01978721f, -0.00379275f, -0.03363344f, 0.03036373f, 0.02512419f, -0.00371229f, -0.01450148f, 
    -0.03979073f, -0.01730818f, -0.02250193f, -0.00291014f, 0.01448229f, -0.02053507f, 0.00042737f, -0.01843645f, 
    -0.00319252f, -0.03767439f, 0.02162226f, 0.02097597f, 0.00259625f, 0.01970709f, -0.01250895f, 0.01506689f, 
    -0.04139315f, 0.02529510f, 0.00252979f, -0.02866181f, 0.00701312f, 0.01944792f, -0.02192909f, -0.01945125f, 
    -0.01534160f, -0.02620533f, -0.00797516f, -0.03481425f, -0.00018053f, 0.01316252f, -0.02252218f, -0.00451523f, 
    0.00199497f, -0.03761971f, -0.04047148f, -0.00333212f, -0.03195493f, 0.00898994f, -0.04365442f, -0.00185434f, 
    -0.01230307f, -0.01536368f, 0.01867471f, -0.00982292f, 0.00321116f, -0.01772880f, -0.01901551f, 0.02416728f, 
    0.01326822f, -0.01629376f, 0.00436424f, 0.02075505f, -0.00847917f, -0.00302956f, -0.03056714f, -0.01825653f, 
    0.03864234f, 0.03537020f, 0.03141611f, 0.01390372f, -0.02485385f, 0.00317890f, -0.01040492f, 0.00365147f, 
    0.00165569f, -0.02839401f, -0.02129597f, 0.01784529f, 0.03330096f, 0.00029006f, 0.00489522f, 0.00944470f, 
    -0.03899484f, -0.01650339f, -0.00587366f, -0.03462499f, -0.02226323f, -0.03529912f, 0.01426356f, 0.01822390f, 
    0.01995936f, -0.03181756f, 0.02701998f, -0.00258035f, -0.03031553f, -0.02971520f, 0.00982850f, -0.01003229f, 
    -0.03633754f, 0.00367126f, 0.02302902f, -0.02488250f, -0.00673720f, -0.02030543f, 0.00119238f, 0.03636770f, 
    0.01976105f, -0.01907809f, -0.00266532f, -0.00638794f, -0.02546112f, -0.02094370f, -0.03631955f, -0.02879709f, 
    0.00560566f, -0.00006691f, -0.00425575f, -0.02494615f, -0.00911042f, 0.01355430f, -0.00899422f, 0.00825052f, 
    0.01098100f, -0.00343906f, -0.02354871f, -0.01474631f, 0.02152096f, 0.03167145f, -0.01261270f, 0.00875098f, 
    -0.04233245f, 0.02394424f, -0.00395146f, -0.01591661f, -0.00565339f, -0.00875515f, -0.04432831f, -0.03865018f, 
    -0.01525323f, -0.00192243f, 0.00713533f, -0.00878060f, 0.00116025f, -0.02711449f, -0.02391502f, -0.00037868f, 
    0.02016934f, 0.01252403f, -0.02456155f, 0.01985762f, -0.03825751f, -0.02488019f, 0.02651923f, 0.00171411f, 
    -0.01375987f, -0.03326168f, 0.00044412f, -0.03768332f, 0.02325532f, 0.02438918f, -0.02616270f, 0.01176771f, 
    0.02274393f, 0.00540656f, -0.00333913f, 0.01732559f, 0.00252722f, 0.02275472f, -0.01621227f, 0.01824614f, 
    0.01013129f, 0.01473309f, -0.00416415f, -0.03084973f, 0.00893146f, 0.01254065f, -0.01209852f, -0.02943665f, 
    0.00924998f, -0.00916678f, -0.03314357f, 0.01282118f, -0.03126435f, -0.02774832f, 0.03014627f, -0.04319383f, 
    0.02606996f, 0.00993665f, 0.00632019f, -0.03324251f, -0.01620366f, -0.01777575f, -0.03089496f, -0.02928763f, 
    0.02628658f, 0.02513201f, 0.00499461f, -0.01580329f, -0.03517950f, -0.03417051f, -0.00611711f, -0.03575428f, 
    0.01315475f, -0.03360162f, 0.00612690f, 0.02518647f, -0.04440515f, -0.02686320f, -0.02122923f, -0.03367992f, 
    0.00441117f, 0.01659936f, -0.00769742f, -0.03838877f, 0.00812826f, -0.01092319f, -0.03967984f, 0.01652270f, 
    -0.00762404f, -0.00404545f, -0.04295941f, -0.03211530f, 0.01269211f, -0.04109068f, -0.03955898f, 0.01053382f, 
    0.00347407f, -0.00388924f, -0.00450447f, 0.01069155f, -0.00839993f, -0.01191899f, 0.00960271f, 0.01577725f, 
    -0.02306819f, 0.00037662f, -0.00050954f, 0.00762524f, -0.03768815f, -0.01646063f, -0.03558763f, -0.02936934f, 
    0.01230255f, -0.00968131f, -0.03745174f, 0.02028581f, 0.02958477f, -0.02895885f, -0.01907414f, 0.00494664f, 
    0.01713991f, -0.00073091f, 0.02147593f, -0.02466890f, -0.00735880f, -0.04303101f, -0.00722721f, 0.00281577f, 
    0.11493001f, 0.05686852f, 0.15051810f, -0.05787409f, -0.06098355f, 0.02263740f, -0.02302780f, 0.19193278f, 
    -0.00293985f, -0.09537484f, -0.05823856f, 0.01211038f, -0.07697566f, -0.05671968f, -0.20132674f, -0.02745334f, 
    0.10306625f, -0.08632156f, -0.14208955f, 0.06662230f, -0.00858510f, -0.11375369f, -0.08000452f, 0.13028964f, 
    0.13431025f, 0.30312687f, 0.11321863f, 0.09440669f, -0.02422272f, 0.11348844f, 0.04372126f, 0.00106752f, 
    -0.00792292f, -0.13164741f, -0.03725226f, -0.03224385f, -0.27211335f, -0.17104080f, 0.07039469f, -0.13022862f, 
    -0.00839385f, 0.09768306f, -0.12993093f, -0.17976366f, 0.10614549f, 0.01018857f, 0.00735937f, 0.08078696f, 
    -0.05551381f, 0.00760072f, -0.15852159f, -0.07026155f, 0.05519771f, -0.02100740f, -0.00792541f, 0.07794899f, 
    0.20014542f, 0.08391435f, -0.06032497f, -0.01262840f, 0.39303693f, 0.03037806f, 0.05891921f, 0.02393010f, 
    0.00210758f, -0.05812343f, 0.15309598f, 0.14660119f, 0.05796488f, -0.03112261f, 0.10467068f, -0.05552711f, 
    0.12885684f, -0.01480627f, 0.37522939f, 0.27263483f, 0.11026737f, 0.04882336f, 0.08573379f, 0.00624931f, 
    0.06161395f, -0.05782396f, -0.01675956f, -0.14081234f, -0.02385729f, 0.19341883f, 0.12226956f, -0.01734998f, 
    -0.05591219f, 0.01042638f, 0.10137150f, 0.05198334f, -0.01087783f, -0.07205573f, 0.01191461f, -0.11109147f, 
    0.19946547f, 0.01400965f, 0.13879436f, 0.08070810f, 0.02461581f, -0.00356029f, 0.04468167f, -0.01330480f, 
    -0.07677466f, -0.00603766f, 0.01847026f, 0.01745240f, 0.11461020f, 0.04046932f, 0.05396806f, -0.01616312f, 
    0.06771464f, 0.10148314f, -0.00099011f, -0.09869379f, -0.00954688f, -0.10422835f, 0.02239727f, 0.16488953f, 
    -0.07104269f, 0.09996113f, 0.22679096f, 0.30473760f, 0.00511728f, 0.05524927f, 0.02193877f, 0.09732312f, 
    -0.05638972f, 0.03082019f, 0.01276962f, -0.06214780f, 0.13330299f, -0.05400162f, -0.00343903f, -0.15913491f, 
    0.01764881f, -0.03649490f, -0.09214295f, 0.04147322f, 0.10039868f, -0.04429366f, 0.02574306f, -0.05409398f, 
    0.16638188f, 0.09232706f, 0.10996770f, -0.08443023f, 0.08499458f, 0.12619478f, 0.01962103f, 0.05905464f, 
    -0.03710620f, -0.13947666f, 0.07415255f, -0.13901991f, -0.07188003f, 0.04546908f, 0.22467837f, 0.00141219f, 
    -0.09392728f, 0.05402159f, -0.15727328f, 0.01681245f, -0.04923446f, -0.02201691f, 0.01918792f, 0.06090597f, 
    -0.36732161f, -0.32717386f, -0.18665108f, -0.00253909f, 0.11065738f, 0.04391449f, -0.16274966f, -0.01353257f, 
    0.08957689f, 0.06223234f, 0.02258061f, 0.15892284f, -0.01246526f, -0.22842295f, -0.22218981f, -0.04749493f, 
    0.08942805f, 0.05252348f, -0.07053073f, -0.01150628f, 0.03474158f, 0.09434606f, -0.05494036f, -0.05114881f, 
    -0.24962242f, -0.20865148f, -0.21037102f, -0.01545193f, 0.08285159f, 0.06243938f, 0.02569919f, 0.08479347f, 
    -0.02600866f, 0.00764303f, -0.05292306f, 0.14115232f, -0.27626562f, -0.25747132f, -0.31290311f, -0.20480593f, 
    0.06627586f, -0.02383342f, -0.00624702f, -0.13724042f, 0.05768670f, 0.02074923f, 0.04988838f, 0.00728324f, 
    0.00037219f, 0.13040124f, 0.10302258f, 0.24188484f, 0.02730644f, 0.00824734f, -0.01524637f, 0.04590298f, 
    0.02200490f, -0.17302287f, 0.02174593f, 0.07344900f, 0.16996083f, 0.49802563f, 0.26521289f, 0.28286341f, 
    0.07096072f, 0.10388603f, 0.07521018f, 0.11564783f, 0.05319191f, -0.00123973f, 0.02333889f, -0.02095697f, 
    0.18436456f, -0.07438065f, 0.15468705f, -0.05279011f, 0.06339109f, 0.07123252f, 0.01914370f, 0.07143436f, 
    -0.04021203f, -0.01809892f, -0.11251085f, 0.20184331f, 0.06313340f, 0.18038729f, 0.16018124f, 0.04538896f, 
    -0.05363593f, 0.08471785f, 0.06697780f, 0.01113152f, 0.08157292f, 0.02046245f, 0.01481669f, -0.06675848f, 
    0.07310049f, 0.36763537f, 0.15036939f, -0.02986247f, 0.05272242f, 0.05813367f, -0.03815548f, 0.12783191f, 
    -0.02605847f, -0.04210047f, -0.07075177f, -0.05737115f, -0.06731395f, -0.21259558f, 0.21045622f, 0.12854402f, 
    0.01275758f, -0.03189663f, -0.04689929f, 0.09770231f, 0.00066926f, 0.07012276f, 0.00763744f, -0.00893027f, 
    0.27840194f, 0.13853119f, 0.07870842f, 0.03916944f, 0.04267146f, 0.01330829f, 0.08506908f, 0.14931537f, 
    0.31190330f, -0.01056666f, -0.00574918f, 0.01838096f, -0.22618702f, -0.26352498f, -0.20924482f, 0.12663661f, 
    0.04816436f, 0.06811443f, -0.10235411f, 0.06028219f, 0.06221177f, 0.00286749f, 0.02254307f, 0.12090018f, 
    -0.05144223f, -0.19911253f, -0.21848261f, -0.08201930f, 0.08550193f, -0.04090736f, -0.04812041f, 0.09952661f, 
    -0.12203044f, -0.03638360f, -0.00493464f, 0.01352761f, 0.08533141f, -0.06581583f, -0.10271714f, -0.34961450f, 
    -0.07925692f, -0.10489884f, 0.10370466f, 0.09958100f, -0.09635324f, 0.05811813f, -0.04764698f, -0.06351445f, 
    0.13609198f, 0.06957809f, -0.16469236f, 0.01717244f, 0.15033095f, -0.00471289f, -0.06440894f, 0.10025783f, 
    -0.01918854f, -0.09123283f, -0.05285116f, -0.05748081f, -0.04177426f, -0.02424075f, -0.30828935f, 0.05032598f, 
    -0.02140366f, -0.10309333f, 0.02524748f, 0.11635220f, -0.02698011f, -0.00738262f, -0.10370249f, -0.07665810f, 
    -0.25931194f, -0.05646177f, -0.20871125f, -0.14940995f, 0.09076055f, 0.05165854f, -0.03071468f, -0.07170745f, 
    0.24909490f, -0.02319469f, -0.05909461f, 0.12576912f, 0.10216869f, 0.00516261f, 0.29223627f, -0.03344965f, 
    0.04093768f, -0.06072982f, -0.00593852f, -0.10501391f, -0.07772998f, -0.05503195f, 0.00540090f, 0.05738122f, 
    -0.27236828f, -0.22907628f, -0.23216781f, 0.00582376f, 0.01692655f, -0.03656793f, -0.09960118f, -0.03867688f, 
    -0.03854902f, 0.02940977f, 0.01070566f, 0.01194791f, -0.12037598f, -0.06268214f, 0.11187239f, 0.17633410f, 
    0.00064762f, -0.13253956f, -0.11447161f, 0.00163380f, 0.06125178f, -0.00937725f, 0.00261670f, -0.05680396f, 
    0.07241826f, -0.19045538f, -0.05929794f, -0.27693000f, -0.10732960f, 0.01859919f, 0.12702081f, -0.01470139f, 
    -0.00877153f, -0.00381078f, -0.03776670f, -0.01715918f, 0.21349260f, 0.21256123f, 0.10878593f, 0.13231292f, 
    0.09727859f, 0.05914328f, -0.04370957f, 0.05227507f, 0.01198358f, 0.03333981f, -0.08033516f, 0.03579715f, 
    -0.16097069f, -0.16456743f, 0.25750864f, 0.18547885f, -0.02831724f, -0.01224353f, -0.00860766f, 0.04668225f, 
    0.02418997f, 0.01022396f, -0.02498862f, -0.03936148f, 0.20577866f, 0.26503819f, 0.14498617f, 0.02662782f, 
    0.08782472f, 0.06016901f, 0.08966810f, 0.12015367f, 0.00351916f, -0.03728559f, -0.03342884f, -0.01761879f, 
    -0.01516094f, -0.10650574f, -0.09367351f, -0.22534241f, -0.05497726f, -0.04105651f, -0.04708083f, -0.05441737f, 
    0.12777241f, 0.00581918f, -0.03031343f, 0.14378184f, 0.09608193f, 0.09165439f, 0.16479872f, 0.15047418f, 
    0.03903561f, -0.18181857f, 0.05855982f, 0.06472801f, -0.08269235f, -0.04535146f, 0.07768334f, 0.03621013f, 
    -0.01805222f, 0.02138284f, 0.01510155f, 0.25745574f, -0.10813583f, 0.04861451f, -0.06809055f, -0.00632364f, 
    0.09718499f, 0.01835570f, 0.02186681f, 0.04794483f, 0.12185431f, -0.00800395f, 0.01559193f, 0.12737675f, 
    -0.03288110f, 0.10195109f, 0.04770934f, 0.03722619f, -0.08102980f, 0.01365175f, -0.02152705f, -0.01267853f, 
    0.13980225f, -0.06575283f, 0.06396674f, -0.03232636f, 0.09534178f, 0.05307668f, -0.02394322f, -0.02783047f, 
    0.00385463f, 0.01452915f, 0.02131951f, 0.04231949f, 0.16713713f, 0.28347129f, 0.29125497f, 0.18054745f, 
    0.03125792f, 0.00424152f, 0.03052947f, 0.06926373f, -0.03250311f, -0.05525673f, 0.00685546f, 0.08048752f, 
    0.03274953f, 0.04554565f, -0.19768210f, -0.06075531f, 0.01433767f, 0.08703452f, 0.02486475f, -0.03565005f, 
    0.04923764f, -0.01021977f, 0.05411417f, -0.08123433f, 0.25497609f, 0.09061163f, -0.11680146f, -0.06875455f, 
    0.15473057f, 0.09055066f, 0.07711231f, -0.00060781f, -0.05918053f, 0.06116129f, 0.07669980f, -0.02463980f, 
    -0.13498808f, -0.13393462f, -0.22057010f, 0.02471963f, 0.10486414f, 0.07662864f, -0.18004620f, -0.07106393f, 
    0.11915709f, -0.08168109f, 0.04742504f, 0.01363953f, -0.36172971f, -0.27043870f, -0.16841386f, 0.11618643f, 
    0.03200598f, 0.03055374f, -0.12095785f, -0.01002883f, 0.11842106f, 0.03428438f, -0.07525112f, 0.03094086f, 
    0.01548625f, 0.22553402f, 0.33526760f, 0.14158612f, 0.12043286f, 0.04496201f, 0.13501401f, 0.16261366f, 
    0.01037720f, -0.00984246f, -0.01891290f, 0.01179357f, -0.02740924f, 0.02294116f, -0.01087633f, -0.14335729f, 
    -0.10850767f, 0.01775920f, 0.07092115f, 0.02968422f, 0.03002391f, -0.12594944f, 0.10151350f, 0.00372272f, 
    0.01966449f, 0.09387229f, 0.28114626f, 0.11383652f, 0.11433002f, 0.10245447f, 0.00173633f, 0.14725003f, 
    0.02010465f, -0.01691659f, -0.01635576f, -0.00661215f, 0.28128624f, 0.20533198f, 0.18821920f, 0.22283801f, 
    -0.02738582f, 0.02551776f, 0.04373462f, -0.00022455f, 0.02782060f, -0.06120630f, 0.09113480f, -0.06029828f, 
    -0.03468038f, -0.12978229f, -0.08778220f, -0.09743172f, 0.08638043f, -0.02146070f, -0.01785707f, 0.00265659f, 
    -0.08588089f, -0.01638769f, 0.05792505f, 0.00263467f, 0.06202972f, 0.14509220f, 0.14258629f, 0.06806543f, 
    0.07122035f, 0.06548212f, -0.00319098f, 0.02728365f, 0.05214915f, -0.08710471f, 0.01910066f, 0.13252427f, 
    -0.02677204f, 0.24552262f, 0.09780934f, -0.06275582f, 0.01580642f, 0.03744987f, 0.03060094f, 0.08245160f, 
    0.03275740f, -0.03584462f, -0.00230756f, 0.06961200f, -0.09812263f, 0.02127696f, -0.09363307f, -0.03881108f, 
    -0.03233409f, 0.09429977f, 0.03997602f, 0.02040785f, -0.03151521f, -0.08362158f, 0.05152233f, 0.02036864f, 
    -0.04335253f, -0.28137484f, -0.00669062f, -0.05383970f, 0.02726253f, -0.05708056f, 0.01001392f, 0.00906395f, 
    -0.10436760f, 0.02213537f, -0.15813562f, 0.07869789f, 0.01264287f, -0.27851200f, -0.00780441f, 0.17615211f, 
    -0.07185949f, -0.14358461f, 0.01108440f, -0.04507729f, 0.01711087f, 0.06663554f, -0.04553465f, 0.03691512f, 
    -0.01127472f, -0.15997988f, 0.08246063f, 0.22285263f, -0.02554680f, -0.06925783f, 0.02538646f, -0.03126701f, 
    -0.03583385f, 0.02360802f, -0.00231109f, 0.00935684f, -0.12342636f, -0.06652176f, 0.17095731f, 0.00833946f, 
    0.04285166f, -0.03285635f, -0.00733027f, 0.02460910f, -0.02626287f, -0.12293374f, -0.06774633f, 0.03249390f, 
    0.32363769f, 0.00913930f, 0.15318450f, 0.13458292f, 0.05209918f, -0.07470793f, 0.04430264f, 0.00107901f, 
    -0.09161989f, 0.03874882f, -0.06707054f, 0.04553391f, -0.21579917f, -0.02211805f, 0.01961450f, 0.09448908f, 
    0.09783532f, -0.05268586f, -0.01711160f, 0.04632992f, 0.00125192f, 0.02677660f, -0.10923706f, -0.04003237f, 
    -0.09309319f, 0.30752128f, -0.23300019f, 0.09597982f, -0.09679019f, -0.00726287f, -0.05222413f, 0.13031177f, 
    -0.02536130f, -0.02077789f, -0.00915209f, 0.05668755f, 0.20297076f, 0.37029314f, 0.27158248f, -0.00829843f, 
    0.05181893f, 0.03919280f, 0.19680528f, 0.13271672f, 0.09333996f, 0.02487368f, -0.06019574f, -0.03602859f, 
    -0.14163768f, 0.21729228f, -0.04017330f, 0.09016636f, -0.11429647f, 0.06548788f, 0.00206724f, -0.03242410f, 
    0.01550712f, 0.00331420f, 0.03435441f, 0.06802756f, 0.16461173f, 0.05154244f, -0.10181826f, -0.01402758f, 
    -0.03467773f, -0.05651252f, 0.04139910f, -0.04034246f, -0.06245224f, 0.00721313f, -0.22735091f, -0.07045502f, 
    -0.06739435f, -0.11888944f, 0.00808983f, 0.06099030f, -0.04436846f, -0.05586978f, 0.04269079f, 0.15252192f, 
    0.02686508f, 0.14874099f, 0.14231265f, 0.05446111f, 0.01329369f, -0.10148131f, 0.27262029f, 0.12181147f, 
    0.09314559f, 0.07293990f, -0.17966864f, 0.10390490f, -0.05376422f, 0.06764903f, 0.02870978f, -0.00736215f, 
    -0.05950417f, -0.02776969f, 0.01361937f, -0.03125037f, 0.09300020f, 0.19393510f, 0.06308055f, 0.01825302f, 
    -0.15897723f, -0.01663096f, -0.03019053f, -0.04236577f, -0.03914394f, -0.04806291f, 0.00411942f, 0.11334579f, 
    -0.09518100f, 0.11901027f, -0.03192412f, 0.04514177f, 0.00087654f, -0.02739251f, -0.06759930f, 0.05947710f, 
    -0.14782323f, -0.16130450f, 0.15804504f, 0.11935107f, -0.17114916f, -0.07573365f, 0.15517505f, -0.03460569f, 
    0.07782920f, 0.04931657f, 0.07315692f, 0.10467491f, 0.03208092f, -0.10005651f, 0.16021401f, 0.15325990f, 
    0.02845325f, 0.04359207f, 0.04176022f, 0.00378808f, 0.00690717f, 0.02644730f, 0.11380145f, 0.02201812f, 
    -0.05102725f, -0.02274558f, -0.24490441f, 0.07769357f, 0.04528963f, -0.05981198f, 0.00889549f, 0.00109396f, 
    -0.05609491f, 0.03391212f, 0.08595378f, 0.07563087f, -0.08852417f, -0.10713494f, 0.03035820f, -0.04213493f, 
    -0.02232375f, 0.09717363f, 0.07883427f, -0.01293844f, -0.01397546f, 0.05287012f, 0.04065508f, -0.02425558f, 
    0.10674965f, 0.01202482f, -0.03241387f, 0.12977979f, -0.03442778f, 0.10951214f, -0.01259835f, 0.06890013f, 
    0.01517226f, -0.02038068f, 0.00312013f, -0.02307897f, -0.05604696f, 0.02473307f, -0.25703096f, 0.11254065f, 
    0.02832869f, 0.00392073f, 0.05009528f, 0.04438195f, -0.02827877f, -0.03289124f, 0.01816763f, 0.09966782f, 
    -0.09107965f, 0.01587363f, 0.03067177f, 0.19627510f, -0.07188118f, 0.00565594f, 0.17184959f, 0.08831936f, 
    -0.00456833f, 0.16109750f, 0.05537317f, 0.04296901f, 0.07576746f, 0.20299546f, 0.13796796f, 0.16361938f, 
    -0.03529736f, 0.07652694f, 0.01718888f, -0.08001244f, 0.09143628f, 0.02078768f, 0.10220806f, -0.01959181f, 
    -0.07372241f, -0.01998401f, -0.00153639f, -0.06332762f, 0.03844019f, -0.01580385f, 0.05758154f, -0.08032742f, 
    0.01200225f, 0.01634899f, 0.06638416f, -0.03426133f, -0.30326325f, 0.03775628f, -0.05213780f, -0.06321090f, 
    0.00942846f, -0.03671755f, -0.03327066f, -0.05113864f, -0.05329510f, 0.01482582f, -0.14681867f, 0.12076359f, 
    -0.05249599f, -0.12468475f, -0.08040649f, -0.14006853f, -0.02962416f, -0.04870326f, -0.02109987f, -0.10716812f, 
    0.04754347f, 0.14034729f, 0.19554852f, -0.06853609f, -0.00420259f, -0.04066543f, 0.11539876f, -0.08062252f, 
    -0.05689520f, 0.07034408f, -0.06005028f, 0.06075653f, -0.09206051f, 0.00321847f, -0.10625499f, 0.01465913f, 
    0.09555542f, -0.03611655f, 0.03149967f, 0.12142138f, -0.01433172f, -0.08037194f, -0.04077102f, -0.12837982f, 
    -0.03582450f, 0.14866406f, 0.02651999f, 0.02043685f, 0.05795291f, -0.00987626f, 0.08811159f, 0.02594985f, 
    -0.06731226f, -0.03443670f, -0.07420602f, -0.02239072f, -0.01479580f, 0.02561795f, -0.06907894f, -0.08050753f, 
    -0.12285164f, 0.09532175f, -0.09439746f, 0.12205384f, -0.09476142f, 0.02733133f, -0.02215621f, 0.01867461f, 
    0.15542811f, 0.15255713f, -0.02742635f, -0.08163358f, -0.01832403f, 0.05429649f, 0.26986769f, 0.12739035f, 
    0.03850423f, -0.10561142f, 0.10870825f, 0.02126914f, 0.07736734f, -0.02938946f, -0.03093649f, -0.02058227f, 
    -0.01459676f, -0.04010602f, 0.01399603f, 0.18155690f, -0.00172315f, -0.01937392f, -0.08234370f, -0.09418815f, 
    0.04458616f, 0.01069296f, 0.02294698f, 0.19406329f, -0.38515425f, 0.30860963f, -0.41337553f, -0.16622576f, 
    0.09836581f, 0.04928365f, -0.06483481f, -0.04239307f, -0.04631195f, -0.09359293f, 0.14286363f, 0.13117084f, 
    -0.05290584f, -0.04593453f, 0.01734470f, -0.01886396f, 0.05074551f, 0.04791275f, 0.03174099f, 0.11738221f, 
    -0.07029971f, 0.00650869f, -0.02374386f, -0.01238148f, 0.00728590f, 0.04192324f, -0.18368764f, -0.04340920f, 
    0.01248437f, -0.00883029f, 0.09666617f, 0.06019161f, 0.09342790f, -0.10440797f, 0.12739383f, 0.03568554f, 
    -0.22777843f, 0.00086684f, -0.29764220f, -0.14150447f, 0.02754637f, -0.01596760f, -0.04572595f, -0.04599174f, 
    0.02308817f, 0.08524645f, -0.00384576f, 0.13801733f, -0.09904617f, 0.38760376f, -0.21900055f, 0.22221249f, 
    0.02682524f, 0.06468260f, -0.01793503f, -0.00830555f, -0.00253136f, -0.09432197f, 0.03058828f, -0.03571743f, 
    0.20105778f, 0.04550156f, 0.25690854f, -0.01436117f, -0.02321598f, -0.01405594f, -0.05974375f, -0.04319863f, 
    -0.07297994f, 0.00802350f, 0.03501585f, 0.08929199f, 0.10526077f, -0.07221845f, 0.28019756f, -0.08515605f, 
    -0.02484807f, 0.02951889f, -0.10393203f, -0.05229069f, -0.00439638f, -0.08220545f, 0.03609051f, -0.01443100f, 
    0.05786433f, -0.18258947f, 0.24063274f, -0.00630927f, -0.05352782f, 0.00398099f, -0.06696407f, -0.04380794f, 
    0.00468333f, 0.09192307f, 0.11679520f, -0.01513783f, 0.00709011f, -0.09577882f, -0.06339779f, 0.16202518f, 
    -0.01025541f, -0.01770933f, 0.05780236f, -0.09353700f, -0.00327900f, 0.03293743f, 0.16462003f, 0.10074441f, 
    0.13684008f, 0.13425238f, 0.09460096f, -0.13416484f, -0.00404219f, -0.00488845f, 0.10394683f, 0.00244926f, 
    0.06479965f, -0.04667274f, 0.10203451f, -0.02619507f, 0.37733266f, -0.25904754f, 0.24239571f, -0.01822943f, 
    0.05575808f, -0.07969598f, 0.02891427f, -0.02748415f, -0.01627797f, -0.10094960f, -0.05546943f, -0.01209283f, 
    0.11107578f, 0.17635527f, -0.10819450f, -0.01631858f, -0.03094392f, 0.01516980f, 0.00579840f, -0.06024766f, 
    -0.02182543f, 0.04006848f, -0.10074384f, -0.08539174f, -0.17067097f, -0.07687750f, 0.08919619f, 0.08743986f, 
    -0.05997349f, -0.00861151f, 0.17538378f, 0.01093094f, -0.07801631f, 0.09688729f, 0.06035187f, 0.08499001f, 
    0.37223595f, 0.00544672f, -0.22744109f, -0.13911754f, 0.10498870f, -0.06193198f, -0.12605973f, -0.00690083f, 
    0.03947394f, 0.05917225f, 0.17099410f, 0.00844973f, -0.18930228f, -0.15863270f, 0.10094748f, 0.07441025f, 
    -0.13201183f, -0.00110174f, 0.05689032f, 0.07459410f, -0.04856489f, -0.04009071f, 0.01689926f, 0.07599996f, 
    -0.27379206f, 0.19236951f, -0.01238125f, 0.22263947f, 0.01897015f, 0.12690499f, 0.08626940f, 0.04277714f, 
    -0.04906734f, 0.13580266f, 0.11616112f, -0.16428098f, 0.18409193f, -0.13582921f, -0.21126309f, 0.04436345f, 
    0.05888419f, 0.02038172f, 0.06686766f, -0.06599736f, -0.03796876f, 0.10268264f, 0.00233193f, 0.10997217f, 
    -0.19191779f, -0.14285208f, 0.25515589f, 0.12409186f, -0.02817584f, -0.03012265f, 0.15271010f, 0.05363030f, 
    0.00745047f, 0.13959526f, -0.00352103f, 0.06430972f, 0.09539670f, -0.12640269f, -0.03901734f, 0.14579831f, 
    0.01905349f, -0.03837879f, -0.07965691f, -0.00268383f, 0.14221822f, -0.04029846f, 0.06984260f, 0.13975613f, 
    -0.04641917f, 0.09892169f, -0.15856677f, -0.02151815f, -0.01569301f, 0.01406385f, 0.13257472f, 0.09553498f, 
    0.01502863f, -0.07157988f, -0.01481738f, -0.00927097f, -0.07356506f, -0.12915447f, -0.10959029f, -0.00819656f, 
    -0.05220640f, -0.01256675f, 0.12205046f, 0.12876604f, 0.08011389f, 0.03416745f, 0.10997800f, 0.03876068f, 
    0.05578712f, -0.13999791f, 0.27906919f, -0.07527509f, 0.05003244f, 0.01824751f, -0.10912990f, 0.12475526f, 
    -0.04702535f, 0.01606981f, -0.07313971f, 0.12757988f, -0.16655403f, 0.08023334f, 0.11620909f, 0.21993080f, 
    0.02623793f, 0.03993360f, -0.01119871f, 0.07829171f, 0.02519839f, -0.00152648f, -0.06574278f, 0.02602907f, 
    -0.03104876f, 0.03118711f, 0.18099718f, -0.12810434f, -0.00254445f, -0.09510861f, 0.08011226f, -0.02565623f, 
    -0.00658329f, 0.09327611f, -0.08416913f, -0.04905560f, 0.24307667f, 0.08277071f, 0.14214063f, -0.10561997f, 
    0.03767631f, 0.03034161f, -0.12084656f, -0.08935490f, -0.03074757f, 0.01486584f, 0.04135854f, 0.07170153f, 
    -0.15123564f, -0.04959050f, -0.02665963f, 0.11773320f, -0.17517389f, -0.08499850f, -0.11424319f, -0.08683086f, 
    0.05476949f, 0.06884558f, -0.05762648f, -0.05130371f, -0.17703909f, -0.30972353f, 0.36800948f, 0.13623230f, 
    0.08205523f, 0.07338006f, 0.00507525f, 0.05834317f, -0.03492262f, 0.09573272f, 0.08056923f, 0.02603025f, 
    -0.03203653f, -0.05192981f, -0.07274655f, 0.11472633f, -0.25465408f, -0.11612783f, -0.05054503f, -0.11753868f, 
    0.06538942f, 0.08955641f, -0.02011007f, -0.00678036f, -0.06203984f, -0.28185204f, 0.05621487f, 0.15894651f, 
    -0.03403636f, -0.00364265f, 0.03980486f, 0.04746981f, -0.14037269f, 0.03246075f, 0.12623484f, 0.12466502f, 
    -0.12746803f, 0.03819044f, -0.14914098f, -0.08629725f, 0.01471240f, 0.01026492f, 0.07575549f, -0.07533837f, 
    0.03982290f, 0.05788001f, 0.02388378f, 0.04360770f, 0.08686855f, -0.02966032f, -0.00540774f, -0.02123918f, 
    0.01211371f, -0.00378350f, -0.14642744f, -0.14324328f, 0.06930080f, 0.13406222f, 0.03620791f, -0.09626552f, 
    0.27469495f, -0.00145537f, -0.02101549f, 0.17354660f, 0.03221931f, 0.00980097f, -0.08057936f, -0.02908746f, 
    -0.07605591f, -0.00891369f, 0.03017400f, -0.02767867f, -0.15997644f, -0.01929026f, 0.14433886f, -0.00505819f, 
    -0.06635354f, 0.08911753f, -0.07656029f, 0.19664334f, 0.01699064f, 0.07347219f, 0.12130686f, -0.09987291f, 
    -0.09816641f, 0.10308954f, -0.29958287f, 0.00162212f, -0.01728572f, -0.04237538f, -0.10415560f, -0.05491013f, 
    0.04150559f, 0.00239383f, 0.12548968f, 0.03285247f, 0.14509110f, -0.31018460f, -0.20065856f, 0.09819813f, 
    0.23632340f, -0.08282294f, -0.01147939f, -0.05256193f, 0.10848264f, 0.00506945f, 0.28988820f, -0.01221243f, 
    -0.14147997f, -0.13486390f, -0.29872426f, -0.11134355f, -0.06759721f, -0.00448479f, 0.00967416f, 0.01736598f, 
    0.12524314f, 0.06498518f, 0.09324414f, 0.03884269f, 0.22255017f, 0.01605486f, -0.13093668f, -0.02669461f, 
    0.00737483f, -0.01151153f, -0.11418185f, 0.05488857f, 0.00819816f, 0.07529153f, 0.07267237f, -0.04417040f, 
    -0.18863370f, -0.02193980f, 0.00984659f, 0.06974833f, -0.00995943f, 0.03803989f, -0.01820974f, -0.04538179f, 
    0.03780551f, 0.08012299f, -0.06179358f, 0.09831660f, 0.15226938f, 0.00548040f, -0.02745013f, -0.19720985f, 
    0.12580034f, -0.10806392f, -0.11864164f, -0.03169283f, -0.03451199f, 0.00619252f, 0.01909881f, -0.05343170f, 
    -0.04496028f, 0.03613703f, 0.12018713f, 0.02773959f, -0.08934762f, 0.08678892f, -0.13296168f, -0.03936113f, 
    -0.12287489f, 0.01687044f, 0.02351057f, -0.01888407f, -0.14750089f, 0.01561462f, 0.17280218f, 0.14403595f, 
    -0.09756714f, 0.06154777f, -0.04611523f, 0.00558889f, -0.01311756f, -0.03072495f, 0.02068992f, -0.12817656f, 
    0.02077005f, -0.26050806f, 0.13365753f, 0.03234330f, 0.01336859f, 0.11821767f, -0.01782715f, 0.02577148f, 
    0.13437998f, 0.13010277f, 0.00881048f, 0.06949855f, -0.03360553f, 0.01685398f, 0.00824093f, -0.19284897f, 
    0.17408566f, 0.21501406f, 0.08126156f, -0.23906282f, 0.10429382f, -0.10222567f, -0.14401080f, -0.06768589f, 
    0.03482786f, 0.16958587f, 0.13139422f, 0.00865078f, -0.10074525f, -0.07052340f, -0.03957851f, 0.13355458f, 
    0.13014820f, 0.16610111f, 0.05269649f, 0.08728618f, 0.08774067f, -0.08393098f, -0.25375742f, -0.19499341f, 
    0.07906322f, 0.07911380f, 0.08834993f, -0.07448912f, -0.10150401f, -0.04301354f, 0.06609497f, -0.01380491f, 
    -0.01786767f, 0.05845608f, 0.01290753f, -0.05880084f, 0.04070201f, 0.05768378f, 0.02526603f, 0.03220791f, 
    -0.02537249f, -0.15864906f, -0.18260181f, -0.13009167f, 0.10110061f, -0.23211016f, 0.09916478f, -0.04451533f, 
    0.20337518f, -0.10087207f, -0.10481162f, 0.19797990f, 0.00387129f, -0.12960358f, 0.00926534f, -0.09598894f, 
    0.08314571f, -0.05432271f, -0.19171518f, 0.05645092f, -0.01154436f, 0.13875452f, 0.06348886f, 0.07209958f, 
    0.04304202f, -0.02585497f, 0.12938426f, 0.12615246f, -0.06266975f, -0.17238201f, 0.03851774f, -0.08777375f, 
    -0.08534783f, -0.08614940f, 0.08308698f, -0.00032326f, 0.00417061f, -0.00314288f, -0.05727502f, -0.00926334f, 
    0.34356764f, 0.21266946f, 0.32024157f, 0.10775717f, -0.04176245f, -0.09957652f, -0.02744278f, -0.14443822f, 
    -0.01015277f, 0.07833124f, 0.06365217f, -0.02990812f, 0.15017723f, 0.08720704f, 0.15177578f, -0.12147694f, 
    -0.01681528f, -0.11817824f, 0.14717396f, 0.14808100f, -0.07703207f, 0.03996166f, 0.01587922f, -0.14355130f, 
    -0.07193731f, -0.27382532f, -0.21742991f, 0.04075367f, 0.00927730f, -0.08048682f, -0.03267353f, 0.00082049f, 
    0.08161579f, -0.08305503f, 0.02011446f, 0.12316497f, 0.19616342f, 0.11297159f, -0.00118001f, -0.00018025f, 
    0.17831892f, -0.13298339f, 0.03582848f, -0.12666155f, -0.10734669f, -0.06384116f, -0.12961526f, -0.20799367f, 
    0.14259273f, 0.07421646f, 0.15266018f, -0.00303431f, -0.05517922f, -0.08849443f, -0.10630792f, 0.12127433f, 
    -0.07436524f, 0.04834887f, 0.01224895f, -0.10109109f, -0.23207118f, -0.05681318f, -0.25504437f, -0.25194961f, 
    -0.07334080f, 0.27246219f, -0.03998192f, -0.00266379f, 0.16576529f, -0.02385461f, 0.14912216f, 0.30564004f, 
    0.05492591f, -0.08772944f, -0.11868778f, -0.06713743f, -0.07142056f, 0.13689910f, 0.13333049f, 0.01546333f, 
    -0.05059538f, 0.07922024f, 0.03974137f, -0.03540400f, 0.11042686f, 0.08448184f, 0.01641973f, -0.01851043f, 
    -0.07741616f, 0.10824164f, 0.10570709f, -0.09716281f, -0.03574154f, 0.02628922f, -0.09654899f, -0.16150099f, 
    0.03016386f, -0.03502756f, 0.06361773f, 0.10871756f, -0.04399065f, -0.01689106f, -0.05869650f, -0.12704574f, 
    0.15615013f, 0.36636204f, 0.15387085f, 0.32412139f, 0.06322963f, -0.18270715f, 0.01981718f, -0.03163730f, 
    0.07185790f, -0.01045610f, 0.19368206f, 0.07326088f, 0.00194290f, 0.27482286f, 0.10388249f, 0.34610894f, 
    -0.09379676f, -0.10338990f, -0.02287754f, -0.07578327f, -0.02850433f, 0.06085375f, 0.01479413f, -0.08969326f, 
    0.22400144f, 0.09606849f, 0.12441903f, 0.24630782f, -0.03302323f, 0.09348385f, -0.06103812f, -0.02348500f, 
    -0.05087369f, -0.08225357f, 0.05794277f, 0.08792613f, -0.13932435f, -0.05193964f, -0.03333717f, -0.12430031f, 
    0.03771677f, -0.07332706f, 0.06554029f, -0.05184621f, -0.02961914f, 0.11433860f, 0.01435617f, 0.10698932f, 
    0.16225721f, 0.13272017f, 0.16307040f, 0.13418643f, 0.00390395f, -0.09830432f, -0.04829600f, -0.03137149f, 
    -0.09439908f, -0.05823000f, -0.03681810f, -0.00136800f, 0.07279695f, -0.09408697f, 0.09987250f, -0.17239834f, 
    -0.16512336f, 0.00164757f, -0.03618523f, 0.02023066f, -0.05703864f, -0.04805046f, -0.04867753f, -0.07020403f, 
    0.01078768f, -0.01228886f, 0.04298359f, 0.01911871f, 0.16067338f, 0.03713232f, 0.06397951f, 0.13655570f, 
    -0.03090672f, 0.14189261f, -0.12676777f, -0.07609718f, 0.03131267f, 0.07542164f, 0.15322505f, -0.11823106f, 
    0.17182297f, 0.30273685f, 0.06323244f, -0.05605344f, -0.01059051f, -0.00453784f, 0.09587782f, -0.00046768f, 
    0.03016310f, -0.22514766f, 0.02765724f, -0.26859382f, -0.04972099f, 0.11763906f, -0.07231231f, -0.12263383f, 
    0.09683479f, 0.01794205f, 0.10142116f, -0.09343758f, 0.01085751f, 0.00785098f, -0.08882815f, -0.15605809f, 
    0.04077537f, -0.01432264f, -0.01158212f, 0.03708773f, -0.06226369f, 0.04653708f, -0.01245172f, -0.11318401f, 
    0.00712423f, 0.04370869f, 0.00769384f, 0.09984659f, -0.23548126f, -0.15444489f, 0.30835652f, 0.03753833f, 
    0.15874523f, 0.03613554f, -0.07673971f, -0.00712268f, 0.04095788f, 0.01643562f, 0.10221400f, -0.02263519f, 
    0.19143197f, 0.02623827f, -0.10479675f, 0.01135967f, 0.08280277f, 0.06124088f, 0.06023402f, 0.02953994f, 
    0.00882131f, -0.07687259f, 0.13815217f, 0.15351173f, 0.01398627f, -0.04024130f, -0.02375375f, -0.00181956f, 
    0.16990921f, -0.06366728f, 0.08026101f, -0.03798547f, -0.17882489f, -0.10558934f, -0.26821041f, -0.22703589f, 
    0.01128115f, 0.02817353f, -0.05297451f, -0.02647348f, -0.10925145f, 0.01450142f, 0.07632045f, 0.01112998f, 
    0.04994377f, 0.12030157f, 0.22689876f, 0.07659934f, 0.01903917f, 0.04220952f, 0.40293035f, 0.04653994f, 
    -0.00666713f, -0.09692944f, 0.05384215f, -0.07664219f, -0.04971900f, 0.16008887f, 0.06520541f, 0.12061222f, 
    0.06609914f, 0.04037561f, -0.04051204f, 0.01476554f, 0.06746938f, 0.09858365f, 0.02816663f, -0.02116701f, 
    -0.00655631f, 0.07225993f, 0.21084490f, 0.13929254f, 0.03022246f, 0.10883538f, -0.40548089f, 0.02634943f, 
    0.09266140f, 0.02896450f, 0.07375568f, -0.02295061f, -0.06086399f, -0.07012537f, 0.09593741f, -0.11881599f, 
    0.19878535f, -0.11047974f, 0.09436746f, -0.18489251f, 0.16129981f, -0.17715700f, 0.11310101f, -0.06796989f, 
    -0.11101972f, -0.20019458f, -0.29474074f, -0.16028719f, -0.06847534f, -0.00520433f, -0.11781093f, -0.00669738f, 
    0.03056182f, -0.05461726f, -0.03494400f, 0.02184536f, -0.01087251f, 0.08114970f, 0.07993944f, 0.15970093f, 
    -0.19037071f, 0.10055652f, 0.00732450f, 0.01729365f, 0.04123938f, -0.01215592f, 0.06055265f, -0.16876572f, 
    -0.08944825f, -0.15979816f, 0.01063511f, -0.23583780f, 0.04384510f, -0.00906037f, -0.01135525f, 0.09268480f, 
    -0.09726720f, -0.02722815f, 0.06452345f, 0.26515752f, 0.16352096f, 0.19287109f, 0.04932776f, 0.09468883f, 
    0.04751810f, -0.12721971f, 0.05696535f, 0.00409475f, -0.05629367f, -0.06701557f, 0.17262886f, 0.07271672f, 
    0.09330216f, 0.14216584f, 0.08873861f, 0.26760411f, 0.26319665f, 0.24582894f, 0.32120124f, 0.16591924f, 
    0.12723054f, -0.15564089f, -0.13455211f, -0.08818842f, 0.03316832f, 0.06379475f, -0.00414534f, 0.04002444f, 
    -0.08455609f, 0.13191602f, -0.08482314f, -0.07274152f, -0.11058310f, 0.01758721f, -0.09280656f, -0.16685458f, 
    0.11678309f, 0.12171543f, 0.13306218f, 0.19713698f, -0.30566746f, -0.05442541f, -0.01608684f, -0.03771738f, 
    0.06380537f, -0.05254589f, 0.11388799f, 0.00410317f, 0.08758948f, 0.04289852f, 0.09234277f, -0.07474163f, 
    0.01557492f, 0.08583225f, 0.14324367f, -0.07358466f, -0.01324817f, -0.09341487f, 0.09468812f, -0.10264087f, 
    -0.01044003f, -0.10856716f, -0.13593693f, 0.03142414f, 0.00942794f, 0.16113614f, 0.03231875f, 0.12747066f, 
    -0.05547382f, -0.08478849f, 0.03506088f, 0.03456337f, 0.05148192f, 0.08510808f, 0.14265257f, 0.09588694f, 
    0.18638001f, 0.27755252f, -0.04422336f, 0.07053985f, 0.03584260f, 0.03317566f, 0.07740159f, 0.14056388f, 
    -0.05527971f, -0.09246504f, -0.12661757f, -0.15440911f, 0.00301019f, 0.07083476f, 0.04113991f, -0.01734564f, 
    0.06328162f, -0.01470090f, -0.08082079f, 0.22777183f, -0.06948680f, 0.19741610f, -0.13295533f, -0.17569244f, 
    0.00540721f, 0.00088672f, -0.06446047f, 0.04923786f, 0.04219894f, 0.11863925f, 0.07276324f, 0.11374027f, 
    -0.19241442f, 0.05596858f, -0.03782807f, -0.07262375f, -0.01874384f, -0.00057831f, -0.22724263f, -0.01137674f, 
    -0.04514631f, 0.13963027f, 0.04941742f, -0.01447929f, 0.08970820f, 0.04398439f, 0.09472920f, -0.08416029f, 
    -0.08896762f, -0.10171357f, -0.11757529f, -0.05055389f, 0.01071747f, -0.08694712f, -0.06004751f, 0.12782452f, 
    -0.00830683f, 0.03250565f, 0.12216305f, -0.00088208f, 0.14000049f, -0.06241991f, 0.17575803f, -0.17325927f, 
    -0.18911669f, -0.27386594f, 0.06052580f, 0.03740191f, 0.00455567f, 0.10833195f, -0.02449911f, -0.01844264f, 
    -0.03918680f, -0.02205953f, -0.09336087f, -0.01865179f, 0.01989369f, 0.02399928f, 0.07546066f, -0.03885420f, 
    0.10540881f, 0.09768495f, 0.08179063f, -0.00404888f, 0.23057148f, 0.09617092f, 0.01715360f, 0.10135049f, 
    -0.17252144f, -0.11060739f, -0.08475147f, -0.02058629f, 0.13722220f, -0.07687221f, 0.04798793f, 0.11003341f, 
    0.09471355f, 0.00973088f, 0.26253945f, 0.00421564f, -0.07365272f, 0.08002551f, -0.04239175f, 0.02564934f, 
    0.19004790f, 0.17118143f, 0.09921248f, 0.07867044f, 0.01854806f, -0.06358593f, 0.04683540f, 0.04948850f, 
    0.05530756f, -0.02881561f, 0.01119490f, -0.02410841f, 0.12310577f, 0.24442230f, 0.18009849f, 0.19690199f, 
    -0.08871836f, -0.16277653f, -0.05962025f, -0.11335209f, 0.02706562f, -0.01068762f, 0.01722210f, 0.02793072f, 
    -0.08215787f, -0.02525693f, 0.11354784f, -0.01266269f, 0.18953101f, 0.13940960f, 0.08431981f, -0.09260941f, 
    0.01012288f, -0.27207902f, 0.03315736f, 0.10892759f, -0.18624471f, -0.06355987f, -0.12940530f, -0.18965918f, 
    0.00118503f, -0.16746297f, 0.13273714f, -0.07575177f, 0.13206948f, -0.14681694f, 0.01969337f, -0.11721882f, 
    0.02721658f, -0.08184163f, -0.02490085f, -0.04664147f, -0.07261968f, -0.08599868f, 0.18258709f, 0.03923962f, 
    0.12041413f, -0.11623437f, -0.18716274f, -0.02772698f, 0.02909908f, 0.10764333f, 0.09863246f, 0.13649829f, 
    0.06005896f, 0.16573678f, 0.14434429f, 0.20039091f, 0.04743879f, -0.16628884f, -0.02618940f, -0.15677729f, 
    -0.04547679f, 0.10046670f, 0.07230841f, -0.14135389f, 0.00169540f, -0.03046701f, 0.03549390f, 0.00008501f, 
    0.09851242f, -0.01313415f, 0.00163092f, -0.02829546f, -0.17819533f, -0.22088876f, -0.14328396f, -0.38193068f, 
    -0.21594307f, -0.04303192f, 0.00997828f, 0.09191224f, 0.08512539f, -0.02518522f, 0.02787995f, 0.06840731f, 
    -0.00527673f, 0.13077845f, 0.10771441f, 0.18043922f, -0.20502545f, -0.07086574f, -0.05548551f, 0.10007206f, 
    -0.04833183f, 0.09293421f, 0.02049423f, -0.10039537f, -0.19902384f, -0.18760970f, -0.04310812f, -0.48872614f, 
    -0.23489842f, 0.23263808f, -0.00333233f, 0.11176085f, -0.04744028f, 0.06403415f, -0.16410868f, -0.02309488f, 
    0.06481433f, -0.08185345f, 0.05877542f, 0.09292307f, -0.03249406f, -0.09785427f, 0.05018017f, -0.00919515f, 
    0.00976249f, -0.02597102f, -0.04622420f, 0.17131086f, -0.05604755f, -0.02792428f, 0.04770710f, -0.20030417f, 
    -0.01686664f, 0.01639852f, 0.07605028f, -0.33609745f, 0.02558834f, 0.07620937f, -0.00721267f, 0.25376254f, 
    0.03199176f, -0.10780305f, 0.02777995f, -0.03175239f, 0.02307673f, 0.17297590f, 0.14306375f, -0.21283874f, 
    0.05049242f, 0.03591769f, -0.10715914f, -0.01948796f, 0.19595264f, -0.00403641f, 0.06703357f, 0.12899224f, 
    -0.13769522f, 0.05086880f, 0.19478995f, 0.40000623f, -0.02946060f, 0.07348005f, -0.00264116f, 0.08332107f, 
    0.04348179f, -0.01038206f, 0.05776437f, 0.00485684f, -0.31029361f, 0.03477101f, -0.13235599f, -0.15018404f, 
    0.06813890f, -0.09014127f, 0.18498167f, -0.25476846f, 0.09950221f, -0.03284252f, -0.00685658f, 0.00283702f, 
    0.02259518f, 0.11875661f, -0.07684258f, -0.16106983f, -0.03816058f, 0.04513330f, -0.05435405f, 0.07032946f, 
    0.07994401f, -0.06295121f, 0.09180152f, -0.03623441f, 0.48096144f, -0.27339414f, 0.07186227f, 0.07767993f, 
    0.25494233f, -0.12966657f, 0.27564058f, 0.25422925f, 0.04427416f, 0.01266733f, 0.00172325f, -0.08075457f, 
    0.19997016f, 0.11420209f, -0.29345500f, 0.12017612f, 0.23574594f, 0.16238244f, 0.14000328f, 0.07057983f, 
    0.03148463f, -0.04553211f, -0.07567571f, 0.11382734f, -0.14620847f, -0.19272760f, -0.21128169f, -0.19852166f, 
    -0.10492606f, -0.06546871f, 0.03634821f, 0.08573217f, -0.12787119f, -0.00871998f, -0.05587646f, 0.07345881f, 
    0.49033460f, -0.42913884f, 0.09618533f, -0.13074258f, -0.05624226f, 0.07426990f, -0.18487349f, -0.06958341f, 
    0.11665019f, -0.00117579f, 0.07727879f, 0.00850314f, -0.34629464f, -0.27399585f, 0.05901874f, -0.22852015f, 
    -0.10633562f, -0.09136413f, 0.05009061f, 0.01376231f, 0.00112283f, -0.04389365f, 0.04183640f, 0.04435218f, 
    -0.13092686f, -0.18112446f, -0.13433574f, -0.17648071f, 0.00836138f, -0.13492355f, -0.07459216f, 0.17622022f, 
    0.01275819f, -0.15681040f, -0.02502172f, 0.15120353f, 0.32728103f, -0.11025662f, 0.14870028f, -0.18245983f, 
    0.06032348f, 0.07864624f, -0.02723252f, -0.06349487f, 0.14211230f, -0.02908517f, 0.05473579f, -0.00178365f, 
    0.06357741f, -0.01626959f, 0.13569303f, 0.05412278f, 0.12942311f, -0.05007402f, 0.00352370f, 0.14263181f, 
    0.07715690f, 0.02964076f, 0.04829444f, -0.00135893f, -0.13164385f, -0.33698109f, -0.15014249f, -0.12846144f, 
    -0.09555249f, 0.18540919f, -0.06359093f, 0.00716363f, 0.09640193f, 0.02471292f, -0.01774364f, 0.06801729f, 
    -0.01628133f, 0.03393983f, 0.02897988f, 0.05161805f, -0.06495206f, 0.04613494f, -0.23938985f, -0.08436073f, 
    -0.00477595f, -0.01384846f, 0.00979091f, 0.07707935f, 0.24047114f, 0.03225219f, 0.12377342f, -0.01767825f, 
    0.03129603f, 0.05717490f, -0.06370872f, -0.24938284f, 0.13274363f, 0.13258801f, 0.06066841f, 0.00056589f, 
    0.22483909f, 0.14400096f, 0.10309444f, 0.00134679f, -0.04750061f, 0.01612136f, -0.01113976f, -0.07283743f, 
    0.04001241f, 0.03208995f, -0.08301193f, 0.07083039f, 0.09561937f, 0.09857620f, 0.03724538f, 0.12216811f, 
    0.14188461f, -0.23335233f, 0.08306347f, -0.11328470f, 0.14595735f, 0.07051715f, 0.14221571f, 0.06279781f, 
    -0.13612051f, -0.30072632f, -0.20218115f, -0.00295010f, -0.01994111f, -0.00502542f, -0.02556658f, -0.01861478f, 
    0.09671346f, -0.04155948f, -0.04319082f, 0.05740210f, -0.11968363f, -0.19318572f, -0.22305743f, 0.34130511f, 
    0.02348242f, 0.15472333f, 0.11774953f, 0.14105257f, -0.04060484f, 0.02348556f, 0.07369095f, 0.05825617f, 
    0.05730792f, -0.19885482f, 0.17608491f, -0.11554037f, 0.00543114f, 0.06314754f, 0.00150555f, 0.06029698f, 
    0.07430819f, -0.04469402f, -0.08925288f, 0.05778354f, -0.02072761f, -0.08034304f, -0.09382650f, -0.33444420f, 
    -0.07103173f, 0.03115866f, -0.03506542f, 0.17608604f, -0.00142316f, -0.12910731f, -0.02379434f, -0.04358989f, 
    -0.05512327f, -0.31453899f, -0.19787833f, 0.03624325f, -0.05352844f, 0.24097098f, -0.09786723f, 0.29384232f, 
    0.15958159f, -0.06639610f, 0.01574762f, 0.02495972f, 0.36352924f, 0.13637626f, 0.09292425f, -0.14497790f, 
    -0.21944025f, 0.10213040f, -0.13305841f, -0.01189699f, 0.09189895f, 0.03347654f, 0.10512955f, -0.07868080f, 
    -0.11186824f, 0.14119844f, -0.04929673f, 0.00775921f, 0.04745165f, 0.07792513f, 0.13407783f, 0.01229357f, 
    0.09018153f, -0.01907816f, 0.01971382f, -0.08524458f, 0.00482593f, 0.13005015f, -0.00930311f, -0.02284813f, 
    -0.11264304f, -0.01872101f, -0.07141488f, -0.15073402f, -0.08051740f, 0.02525210f, -0.14397073f, -0.09395526f, 
    0.21382660f, 0.15070127f, 0.04449732f, -0.00322136f, -0.00533481f, 0.16267042f, -0.08862667f, -0.14371701f, 
    0.04183061f, 0.03191682f, -0.02523050f, 0.03073565f, 0.20464946f, 0.19386309f, 0.10585165f, -0.04584750f, 
    0.04023424f, -0.13659455f, 0.14172299f, 0.07358471f, 0.03270151f, 0.12991388f, 0.03094978f, 0.02044865f, 
    -0.21853203f, 0.18197501f, -0.00587223f, 0.08144402f, 0.06876807f, -0.00012235f, 0.06464981f, 0.18365267f, 
    0.02977023f, -0.03105521f, -0.00146936f, -0.12286122f, 0.00809385f, 0.17817540f, -0.07840739f, 0.16281892f, 
    0.00265826f, -0.25562504f, 0.20515832f, -0.09159667f, 0.04028180f, 0.10318915f, 0.00109981f, -0.09368699f, 
    -0.15455821f, 0.07246605f, -0.02235781f, -0.02626958f, -0.03115888f, 0.05087582f, 0.15790348f, 0.02716796f, 
    0.04661143f, -0.01899428f, -0.00126139f, -0.00907404f, -0.10786987f, -0.51131362f, 0.22062790f, -0.27974531f, 
    -0.18302281f, -0.17844421f, 0.05967746f, -0.17902504f, 0.04005257f, -0.00462494f, -0.00311348f, 0.00529009f, 
    0.10528589f, 0.08031272f, 0.03231901f, 0.07832399f, -0.08070664f, -0.09110260f, 0.07092464f, -0.09717218f, 
    0.01994567f, 0.09573957f, 0.00978113f, -0.03428526f, -0.23184094f, 0.22102216f, 0.05383240f, 0.11819068f, 
    0.10813755f, 0.02136992f, 0.00541114f, 0.03657942f, 0.01652057f, 0.06337519f, -0.02392818f, -0.11675772f, 
    0.19133927f, -0.00434111f, 0.13080077f, -0.18186507f, 0.07172350f, -0.20806164f, 0.08783258f, -0.12446513f, 
    -0.11208147f, -0.07246875f, -0.04454365f, -0.17992678f, 0.07367565f, -0.40372297f, -0.40357766f, -0.05087765f, 
    0.06156655f, 0.12105187f, -0.02612355f, 0.20771711f, 0.15149364f, 0.07762035f, -0.05387732f, 0.09926385f, 
    0.20495403f, 0.06160237f, 0.16444959f, 0.09877732f, -0.00574648f, 0.02103285f, -0.08686574f, -0.04006625f, 
    0.00968902f, -0.02660632f, -0.09761723f, -0.05130202f, 0.03290438f, 0.11491065f, 0.09646927f, -0.04808135f, 
    -0.02837265f, 0.10644917f, 0.19661540f, 0.31529957f, 0.02197326f, 0.08531405f, 0.07969984f, -0.09426767f, 
    -0.02643975f, 0.15997528f, 0.08749356f, -0.03016360f, -0.04203717f, -0.06165121f, 0.07805401f, 0.01360860f, 
    0.00374265f, -0.05454492f, -0.02667881f, 0.03816954f, 0.51933450f, -0.26891634f, -0.05799182f, -0.16549987f, 
    0.17799501f, -0.19152506f, -0.10732182f, -0.12652677f, 0.16940898f, -0.05958953f, 0.05993573f, 0.06697596f, 
    -0.05374035f, 0.23693208f, -0.19684097f, 0.08856387f, -0.10324588f, 0.08551896f, -0.07595135f, 0.05821347f, 
    0.11309869f, -0.01799507f, 0.01151306f, -0.03113097f, -0.12565531f, 0.07910683f, -0.05522257f, 0.14488301f, 
    -0.01580082f, -0.00729791f, 0.03683808f, 0.02328423f, -0.07656509f, -0.03529131f, -0.03272099f, -0.07131942f, 
    -0.00295463f, -0.43446803f, -0.06850298f, -0.28982347f, 0.03713172f, -0.10678966f, -0.00712787f, 0.00912370f, 
    -0.05790234f, -0.05467440f, -0.07019950f, 0.01895069f, -0.19825797f, 0.08282752f, 0.31297830f, 0.47004190f, 
    0.00018194f, 0.02239415f, 0.04379708f, 0.14672658f, 0.06197409f, -0.02357531f, 0.03854787f, -0.02631146f, 
    -0.42507762f, 0.32110840f, -0.09699507f, -0.06498559f, -0.00092636f, 0.01837043f, 0.14470808f, 0.09592339f, 
    0.00241577f, -0.09791727f, -0.01919511f, -0.12446924f, 0.11164053f, 0.06454317f, -0.01947047f, -0.02709896f, 
    -0.08665988f, -0.01978117f, 0.08558390f, 0.11043114f, 0.08756876f, -0.01145248f, 0.00195876f, 0.02599055f, 
    -0.07369335f, 0.24032448f, -0.11835047f, 0.11575843f, 0.06626494f, 0.06267650f, -0.16680606f, 0.05786602f, 
    0.06912937f, -0.14853990f, 0.14487138f, -0.04706100f, -0.17212363f, 0.07490297f, -0.01951252f, 0.14662957f, 
    0.06340346f, -0.06792530f, 0.05025347f, -0.08975081f, 0.08831010f, -0.06786288f, 0.01202818f, -0.00174198f, 
    -0.15366185f, -0.11987676f, 0.14151579f, -0.14063199f, 0.11975364f, -0.07969296f, 0.08513915f, 0.11999501f, 
    0.05219322f, -0.05998327f, 0.07193227f, 0.06840873f, -0.08468631f, -0.00925494f, 0.02626185f, -0.21121410f, 
    -0.23855297f, -0.00807457f, -0.06838288f, 0.06924300f, 0.05416954f, 0.10865094f, 0.03606400f, 0.03727835f, 
    -0.03932299f, -0.11789221f, 0.03688385f, -0.01484095f, 0.09969014f, -0.02261225f, 0.10587621f, 0.14043526f, 
    0.00483148f, -0.05541908f, 0.02338090f, 0.06326070f, 0.57990342f, -0.13044876f, -0.28312272f, -0.15504135f, 
    0.01549793f, 0.07427000f, -0.05779940f, 0.08561254f, 0.22312233f, -0.07913045f, 0.04177700f, 0.05499383f, 
    0.13690813f, 0.06081788f, 0.20045748f, -0.10372867f, -0.16419411f, 0.15455069f, -0.10877613f, 0.04213491f, 
    0.03142576f, -0.00092854f, -0.02077723f, -0.10522319f, -0.01443066f, -0.24868745f, 0.00110883f, 0.23060219f, 
    -0.09979706f, 0.01428893f, -0.01715113f, 0.03525375f, 0.13137153f, -0.06822231f, -0.02789133f, 0.03356815f, 
    -0.33504707f, -0.31281963f, -0.22040923f, -0.09178139f, -0.01832415f, 0.03852554f, 0.08772478f, 0.05107535f, 
    -0.04373232f, -0.02986937f, 0.02433149f, 0.21966869f, -0.10663482f, 0.17865066f, -0.00502802f, -0.09200282f, 
    0.01835268f, -0.02489656f, 0.08458142f, -0.21922524f, 0.00108900f, 0.08076118f, 0.02103260f, 0.06101078f, 
    0.26027191f, -0.10394322f, 0.20638116f, -0.36684382f, 0.06306893f, -0.12562208f, 0.02597762f, -0.20955126f, 
    -0.12788510f, 0.16936390f, -0.04366335f, -0.04739982f, 0.04254245f, 0.13847646f, -0.20047402f, 0.08273905f, 
    0.00473119f, -0.08095754f, -0.07552822f, -0.06548260f, -0.07406271f, 0.08379547f, -0.07914286f, 0.02261447f, 
    0.21294697f, -0.07753368f, 0.02199453f, -0.08830208f, 0.06288673f, -0.07467425f, 0.01580920f, -0.42513934f, 
    0.09894890f, 0.02170290f, 0.04958583f, 0.07371524f, -0.20149352f, 0.01830040f, 0.27516949f, 0.10625271f, 
    0.07109712f, -0.04582681f, 0.02564244f, -0.23311925f, 0.03932265f, 0.01313152f, -0.06055133f, -0.06622332f, 
    -0.20500332f, -0.15292998f, 0.06036215f, 0.01149587f, -0.04621600f, -0.14114973f, 0.06785271f, 0.06853738f, 
    0.00591482f, -0.02462915f, -0.04939936f, -0.08700532f, -0.12835619f, 0.12388703f, -0.00082329f, 0.03785679f, 
    -0.08878119f, 0.01192137f, -0.03080133f, -0.13590777f, -0.04935808f, -0.00674929f, -0.08028088f, -0.00229256f, 
    0.18482889f, 0.35022730f, -0.04703655f, 0.34432900f, -0.08683891f, 0.13364051f, 0.00531977f, 0.07026548f, 
    0.09786055f, -0.00389921f, 0.04906713f, -0.02941874f, -0.12531599f, -0.01248841f, 0.03176330f, -0.13113101f, 
    0.08705445f, -0.02913511f, 0.23800461f, 0.27005580f, 0.05125256f, 0.05724240f, 0.01386624f, 0.04107810f, 
    -0.01710536f, -0.01863769f, 0.00265900f, 0.02429699f, 0.02350264f, -0.02529102f, -0.02691114f, -0.04249897f, 
    0.00451157f, -0.00430573f, 0.02174536f, -0.04107448f, 0.02475461f, -0.00229142f, -0.00720762f, -0.02196621f, 
    0.01430125f, 0.01821763f, -0.02017390f, -0.03502328f, -0.01039667f, -0.01802458f, -0.02744791f, 0.02263801f, 
    0.02813831f, -0.03977813f, 0.02897749f, 0.01154928f, 0.01926235f, 0.02574453f, -0.03794522f, -0.03517339f, 
    -0.04059197f, -0.02417699f, -0.02005886f, -0.00534804f, 0.02628467f, -0.03053778f, 0.01719753f, 0.01598370f, 
    0.01085474f, -0.00870425f, -0.02112843f, 0.02092140f, -0.02131598f, 0.00303940f, -0.01146228f, 0.02664800f, 
    -0.00416430f, 0.02852222f, -0.02079394f, 0.01303473f, -0.03582680f, 0.03200408f, -0.02247746f, -0.01370406f, 
    -0.03267730f, 0.00164278f, 0.01171696f, 0.01091981f, 0.00099918f, 0.02381490f, -0.00852503f, -0.04438208f, 
    -0.01176096f, 0.01144116f, 0.01319345f, -0.00312407f, 0.00040678f, 0.00967104f, -0.02930346f, -0.00213600f, 
    0.02745063f, -0.01579077f, -0.00602316f, 0.00674466f, -0.01767502f, -0.02376222f, -0.04583183f, 0.02701438f, 
    0.02103614f, -0.02372336f, -0.00967894f, 0.02088116f, 0.02840739f, 0.02513052f, 0.01105488f, -0.02934729f, 
    0.02964793f, -0.04099992f, -0.02760350f, -0.01582955f, -0.00284969f, -0.01326971f, 0.00512515f, 0.01024740f, 
    0.02782398f, -0.00644222f, -0.00353932f, 0.00464956f, -0.01996514f, -0.02697958f, -0.03707684f, 0.02805943f, 
    -0.01130653f, -0.04452528f, -0.04279655f, -0.00758332f, 0.00711589f, -0.03246089f, -0.00106225f, -0.01224358f, 
    0.02893943f, 0.00094360f, -0.00794749f, -0.01151147f, -0.02111991f, -0.01576860f, -0.02674516f, -0.01659416f, 
    0.02414730f, -0.01637962f, 0.02224481f, -0.01746978f, 0.02530818f, 0.02890965f, 0.01717612f, -0.02466751f, 
    -0.00990308f, 0.02672314f, -0.00115891f, 0.00228612f, -0.02917322f, -0.00962524f, -0.03337293f, 0.02536100f, 
    0.01140814f, 0.00635902f, 0.01652783f, 0.00683145f, -0.03012240f, 0.00416008f, -0.00736492f, 0.01418986f, 
    0.02072575f, -0.02062066f, -0.01417957f, 0.00280470f, -0.01708166f, -0.02911956f, -0.02277488f, 0.01931112f, 
    -0.01274942f, 0.01573453f, -0.01328034f, 0.01969191f, -0.00056217f, -0.00196882f, -0.04060245f, -0.03875654f, 
    -0.03044266f, -0.01813910f, -0.04514118f, -0.00686927f, -0.01210629f, -0.00042644f, -0.01188660f, -0.02534667f, 
    -0.03711072f, -0.03977383f, 0.01653130f, -0.00285970f, -0.02638166f, 0.01899225f, -0.04128301f, -0.01464463f, 
    0.02393225f, -0.00872258f, 0.01713865f, 0.03253407f, 0.03238962f, 0.00170587f, -0.02797197f, 0.02446749f, 
    -0.03769711f, -0.03568129f, -0.03717704f, -0.03768859f, 0.00160801f, 0.02797588f, -0.03976442f, -0.04192115f, 
    -0.01501205f, -0.01263826f, 0.02155242f, -0.02081171f, 0.02334895f, 0.00995358f, -0.02809411f, 0.02663213f, 
    -0.00634231f, 0.00970445f, -0.02851411f, 0.01024979f, 0.02045867f, 0.01757037f, -0.03009599f, 0.02421511f, 
    -0.01007267f, -0.02311568f, -0.03110768f, -0.02282293f, -0.01495723f, -0.01076406f, -0.04018057f, 0.01761200f, 
    0.00353179f, 0.00398750f, 0.00090982f, -0.01397104f, 0.00294876f, 0.02053763f, -0.01164246f, -0.01024967f, 
    -0.00179763f, -0.03317955f, 0.01366926f, -0.03351526f, 0.02511619f, -0.00446969f, 0.00923908f, 0.02554449f, 
    -0.00127842f, -0.00897119f, -0.04071867f, -0.01893884f, 0.00726990f, 0.02815296f, 0.00673749f, 0.02441474f, 
    -0.02621326f, 0.01269899f, -0.02072324f, -0.00042291f, 0.02036193f, 0.01409243f, 0.00407322f, 0.01283449f, 
    0.02084370f, 0.02344286f, -0.02895439f, -0.00842024f, -0.00581548f, 0.00054168f, 0.00849597f, -0.00960870f, 
    0.02216624f, -0.04181411f, -0.03453806f, -0.02401112f, -0.02823834f, 0.02097895f, -0.01852217f, -0.01634562f, 
    -0.03546789f, -0.01980055f, -0.01844264f, -0.02889042f, -0.00730606f, -0.02379182f, -0.03491374f, -0.04022775f, 
    -0.01133873f, -0.01083326f, 0.01196172f, 0.02450806f, 0.00523698f, 0.01233163f, 0.02634573f, 0.01240420f, 
    0.00940735f, -0.00789693f, -0.00678260f, 0.02020047f, -0.00937015f, -0.02765975f, 0.01674488f, 0.02407972f, 
    -0.00181502f, 0.00283556f, -0.00221784f, -0.01713484f, 0.01782928f, 0.01339350f, 0.02828476f, -0.02794205f, 
    -0.03007438f, -0.02979386f, -0.02968560f, -0.00927466f, -0.02754383f, 0.02980307f, -0.01744689f, -0.01495503f, 
    0.00472787f, 0.02536860f, 0.01137574f, 0.00037970f, -0.02779286f, -0.01024002f, -0.03177214f, -0.01219571f, 
    0.02567239f, -0.02407562f, 0.02140327f, -0.02809388f, 0.01413160f, -0.00474647f, -0.03773032f, 0.02938461f, 
    -0.03690938f, -0.02323387f, 0.01266480f, -0.02009013f, -0.00190588f, -0.00491474f, -0.02042032f, 0.03365205f, 
    0.02559258f, -0.00552897f, 0.00412409f, 0.00235084f, 0.01145382f, 0.01756595f, -0.00839208f, 0.01570737f, 
    0.02144161f, 0.00520952f, 0.02368603f, -0.00567911f, -0.00865021f, -0.02958830f, 0.01510012f, -0.00144562f, 
    0.02167371f, -0.01809586f, -0.00120177f, 0.00550119f, -0.02301054f, -0.01433120f, 0.01053174f, -0.03875306f, 
    -0.00819427f, -0.02435048f, -0.01897307f, 0.02244850f, 0.00417381f, -0.02173539f, -0.04106565f, 0.01278271f, 
    0.00683569f, -0.03502514f, -0.00379364f, -0.01619489f, 0.00017641f, -0.03806441f, 0.00427177f, 0.02680163f, 
    0.00526673f, -0.01531057f, -0.01213958f, -0.01913848f, -0.03297929f, 0.02366068f, -0.02310870f, 0.01604672f, 
    -0.02467706f, 0.00969640f, -0.02704173f, -0.02534295f, 0.01302003f, -0.02159570f, -0.02306508f, -0.00873664f, 
    -0.02659281f, -0.00488539f, 0.02914721f, -0.00954195f, 0.02224960f, 0.00690386f, 0.01625670f, 0.01372114f, 
    -0.03586513f, -0.00265075f, -0.02281775f, -0.01169053f, -0.02913670f, -0.00635087f, 0.00918582f, 0.01463269f, 
    -0.00818996f, 0.00100143f, 0.00667487f, 0.01498084f, -0.01566837f, -0.00275736f, 0.02259451f, 0.01959634f, 
    -0.03045820f, -0.00604702f, 0.01710301f, 0.02084273f, -0.00496283f, 0.01495410f, -0.01990465f, 0.02832654f, 
    -0.02585297f, -0.00807619f, -0.02385774f, 0.01921113f, -0.01374353f, -0.00369173f, -0.03028826f, -0.03663241f, 
    -0.03657233f, -0.00300212f, -0.01680521f, -0.02317283f, -0.02541778f, 0.01609878f, 0.02044054f, -0.03491669f, 
    0.01438178f, -0.03154450f, -0.00672757f, 0.02064903f, -0.03721241f, 0.02161835f, -0.02374928f, 0.01312268f, 
    0.02180165f, 0.00615421f, 0.02129919f, -0.02428163f, -0.01979609f, -0.04021489f, -0.01260297f, 0.02386921f, 
    -0.04077015f, 0.00112423f, -0.00936095f, -0.00378605f, 0.02336345f, 0.02824984f, 0.00790242f, -0.03195275f, 
    -0.00218711f, 0.02160798f, -0.03134789f, 0.00561974f, 0.00945518f, 0.02140678f, -0.00826178f, 0.01554869f, 
    -0.02760830f, 0.00304204f, 0.01470993f, 0.01198042f, 0.01336586f, -0.04047102f, -0.00185451f, -0.01134181f, 
    -0.02650482f, -0.03196090f, -0.02012957f, -0.01928515f, 0.00912845f, 0.02024753f, 0.02134387f, 0.02001083f, 
    -0.01615117f, -0.04238931f, -0.03082744f, 0.01620347f, -0.00911291f, -0.03776722f, -0.00160498f, 0.01295121f, 
    -0.03739385f, -0.04488132f, -0.02551234f, -0.02860049f, 0.01114664f, -0.00381650f, -0.02144617f, 0.02265734f, 
    0.02203801f, -0.02925691f, -0.04092486f, -0.01536137f, -0.00329858f, -0.02910329f, -0.01663556f, -0.01462966f, 
    0.02768161f, -0.03920327f, 0.01828294f, 0.02578692f, -0.02877450f, -0.04191504f, 0.00773937f, 0.00563299f, 
    0.02513995f, 0.01436736f, -0.02065925f, 0.02925882f, 0.00691539f, -0.00920147f, -0.03237130f, 0.00320280f, 
    -0.00146883f, -0.00547942f, 0.00019834f, 0.02184241f, -0.03031040f, 0.01479622f, 0.01360589f, 0.02266665f, 
    -0.02105040f, 0.00107496f, 0.02940075f, 0.01529187f, 0.02488595f, 0.00486712f, -0.01519845f, -0.01320745f, 
    -0.02834604f, -0.02933756f, 0.02054421f, -0.00687049f, -0.03400065f, -0.01285159f, -0.04421454f, -0.01750165f, 
    -0.00615812f, -0.02465390f, -0.00296632f, -0.01492503f, -0.01220702f, 0.01462914f, -0.03673718f, 0.01427139f, 
    0.01150115f, 0.02584084f, -0.02075131f, -0.02488537f, 0.01477842f, 0.00397019f, -0.00661163f, -0.02307745f, 
    0.01944785f, -0.02013848f, 0.01328350f, -0.02229271f, 0.00501346f, -0.01124056f, 0.02532914f, -0.03749107f, 
    -0.02280121f, 0.01456568f, -0.01178449f, -0.01496572f, 0.02023244f, -0.03130566f, 0.02728250f, -0.03850571f, 
    -0.01663205f, 0.02240776f, 0.01883462f, 0.01694023f, -0.03073434f, -0.00556391f, -0.01615662f, -0.02907398f, 
    -0.01461744f, 0.02647215f, -0.02047214f, -0.01205834f, -0.02179564f, 0.00342398f, -0.00747746f, -0.01144775f, 
    -0.00313287f, -0.03010951f, -0.00208121f, -0.02367851f, 0.02223151f, -0.03946134f, 0.00751054f, -0.03492193f, 
    0.00815948f, -0.00691257f, 0.03504162f, -0.03077580f, -0.02179208f, 0.03014161f, 0.01231839f, 0.01781873f, 
    -0.00836503f, -0.00814990f, -0.04121577f, -0.03055279f, 0.02050375f, -0.00033944f, 0.00251657f, 0.00365224f, 
    -0.00260526f, -0.01373867f, -0.01066686f, -0.02363456f, -0.00376945f, -0.03604537f, 0.01438369f, -0.02589844f, 
    -0.03292894f, 0.00864956f, 0.01141498f, 0.01126597f, -0.00223639f, 0.00020010f, 0.00378074f, -0.04253622f, 
    0.00439369f, -0.00673589f, 0.00303105f, -0.04371956f, -0.00514242f, -0.02966287f, 0.00841624f, -0.01768862f, 
    0.00490601f, 0.00753787f, -0.02453720f, -0.03765647f, -0.02881834f, -0.01584867f, 0.01769689f, -0.04541601f, 
    0.00640628f, -0.04028153f, -0.00142633f, -0.02528711f, 0.01418664f, 0.01387100f, 0.02387422f, -0.00214937f, 
    0.01169772f, -0.01896576f, 0.00578766f, -0.00191609f, -0.01677891f, 0.02384631f, -0.01600125f, -0.00860710f, 
    0.01426167f, 0.01062145f, -0.02552278f, -0.00129539f, 0.02013658f, 0.02459101f, 0.00215941f, 0.01909683f, 
    -0.01725370f, -0.03916178f, 0.02319738f, 0.00077625f, -0.03379015f, -0.01581258f, 0.00772940f, -0.03626267f, 
    -0.02607522f, -0.03741866f, -0.02638498f, -0.00793662f, 0.02338171f, -0.02261260f, 0.00807867f, -0.00761408f, 
    -0.00412813f, -0.03271738f, -0.02671553f, -0.04365774f, 0.01324433f, 0.02108681f, -0.00202047f, -0.03350901f, 
    -0.02082259f, -0.01853264f, -0.01075468f, 0.02998815f, 0.01730474f, -0.00997218f, -0.03396502f, 0.00293751f, 
    0.01870363f, -0.00706421f, 0.01447589f, -0.02302402f, 0.01688796f, -0.01911055f, 0.01672474f, 0.00565167f, 
    0.03143550f, 0.00041718f, 0.02169511f, -0.01986407f, 0.00135184f, -0.00604327f, -0.02289499f, 0.02723701f, 
    -0.04108126f, -0.02095187f, 0.00605917f, -0.01190651f, -0.03559458f, -0.02083513f, -0.02421977f, -0.00559577f, 
    0.00915637f, -0.02338643f, -0.03576556f, -0.01041248f, -0.01443421f, -0.02228407f, 0.00198324f, 0.02081898f, 
    0.02370272f, 0.02103406f, -0.01257909f, 0.00042430f, -0.01216778f, 0.02378231f, 0.00005879f, -0.01564581f, 
    -0.00349303f, 0.01333726f, -0.00372945f, -0.00298831f, -0.02325600f, 0.01630880f, -0.03585999f, 0.00726696f, 
    0.01795484f, 0.00948705f, 0.00040141f, -0.03198304f, 0.02067033f, -0.03243262f, -0.04114050f, -0.00148672f, 
    0.03478956f, 0.02674279f, -0.03475611f, -0.01681849f, -0.00408158f, -0.03096909f, -0.01279022f, -0.02762768f, 
    -0.07405843f, -0.21844633f, 0.17617002f, 0.17539455f, -0.05039385f, 0.07248139f, -0.16511871f, -0.11409158f, 
    0.09256601f, -0.01353910f, 0.10311395f, -0.01771166f, 0.01735162f, 0.08987763f, -0.32711822f, 0.04266229f, 
    0.00226891f, 0.15436094f, -0.13977863f, -0.00866604f, -0.09286275f, 0.01820748f, 0.03506859f, 0.13555758f, 
    -0.16040872f, -0.13639374f, 0.04015362f, -0.29437321f, 0.14435503f, 0.08735850f, -0.02570324f, 0.08238632f, 
    0.03412013f, 0.03152624f, -0.00047395f, -0.08850262f, 0.19823143f, 0.21263704f, -0.03716633f, -0.03981626f, 
    -0.03791558f, -0.22816348f, 0.06602176f, -0.01699088f, 0.01343781f, -0.02603280f, 0.01285840f, -0.00872518f, 
    0.05733927f, -0.04829384f, -0.00977811f, 0.04789509f, 0.13524453f, -0.01699980f, -0.13385044f, -0.13261792f, 
    -0.10121876f, -0.01472042f, -0.03215767f, 0.01975876f, -0.06558619f, -0.07764288f, 0.00015192f, -0.17199957f, 
    -0.06836573f, 0.04997741f, -0.22345860f, 0.15582098f, 0.07309727f, -0.11517302f, -0.06418448f, 0.02917792f, 
    -0.07128339f, -0.10816893f, -0.26675391f, 0.13165581f, 0.05149306f, 0.18002351f, -0.03371655f, 0.06021883f, 
    -0.12851450f, 0.04385102f, 0.15267210f, -0.21926428f, -0.00417045f, 0.07496450f, -0.16321465f, -0.04359744f, 
    -0.08940729f, -0.10220828f, 0.01883300f, -0.04038363f, -0.02703043f, -0.04990906f, 0.08483134f, -0.07000386f, 
    -0.32722116f, 0.19448322f, -0.07832366f, -0.08545171f, -0.03162068f, 0.06824889f, 0.01220751f, 0.10010280f, 
    0.06082399f, 0.05108007f, 0.05351282f, -0.16669159f, 0.20333980f, 0.03714039f, -0.02220722f, 0.15607750f, 
    0.15233560f, 0.00020826f, -0.13187072f, 0.04877337f, -0.06072313f, -0.13665456f, 0.09276839f, -0.07559944f, 
    0.01798217f, -0.03269720f, -0.11361311f, -0.08134540f, 0.02237543f, -0.01952932f, -0.05914907f, -0.25732061f, 
    -0.10075861f, -0.01681250f, 0.00919703f, -0.06166110f, -0.04235250f, 0.11856753f, 0.09983187f, 0.00439719f, 
    0.02856416f, -0.11640535f, 0.01535506f, 0.00714441f, -0.10123246f, 0.05642354f, -0.08639214f, -0.04477501f, 
    -0.00953510f, -0.14430943f, -0.02030723f, -0.14296882f, 0.19444539f, 0.09074688f, 0.13884890f, -0.00795729f, 
    -0.05602560f, 0.27310103f, -0.06241102f, -0.01724817f, -0.04355770f, -0.24141474f, -0.02660402f, -0.11016029f, 
    0.10658412f, -0.07271890f, 0.08141122f, 0.03390098f, -0.18571925f, -0.06611485f, 0.22108592f, 0.06684609f, 
    0.16667321f, 0.08871176f, 0.05628303f, 0.04039354f, -0.00931490f, -0.01601383f, 0.02166644f, 0.04968061f, 
    0.12787594f, 0.08982243f, -0.00932455f, 0.07664646f, 0.14943582f, 0.14789905f, -0.00421848f, 0.08421402f, 
    -0.01623303f, 0.01675325f, 0.01157127f, 0.05431376f, 0.13244542f, 0.02981675f, 0.02308153f, 0.05177291f, 
    0.00213187f, -0.06274831f, 0.02933968f, -0.03060376f, 0.01946353f, -0.02466379f, 0.06381789f, 0.10986029f, 
    -0.00636498f, -0.10170516f, 0.07376987f, 0.14853735f, 0.05589774f, -0.05009951f, 0.00245601f, -0.00415988f, 
    -0.01135205f, -0.01867913f, 0.01746366f, -0.09830187f, 0.06949248f, 0.11976372f, 0.03237933f, 0.08097427f, 
    -0.19699112f, -0.22122987f, 0.00223091f, -0.10784194f, 0.08260564f, 0.13705367f, 0.15290725f, -0.13117753f, 
    -0.17900167f, -0.07535850f, -0.03050257f, 0.04321994f, 0.08602063f, 0.06487021f, 0.04696575f, 0.03346219f, 
    0.09970172f, -0.09515557f, -0.01127531f, -0.05024247f, -0.04492139f, -0.03657134f, -0.05217415f, -0.02281963f, 
    0.02179120f, -0.05257828f, -0.12335517f, 0.12645888f, 0.13804378f, 0.09014515f, -0.04305698f, -0.06423156f, 
    0.11440310f, -0.24769489f, -0.14428110f, 0.17479734f, -0.02697943f, 0.11707193f, -0.19633766f, -0.08098917f, 
    0.16622077f, 0.00938644f, -0.03410693f, -0.02983912f, 0.02868170f, 0.02821652f, -0.05190627f, -0.06264377f, 
    -0.04641676f, -0.10123713f, -0.06746046f, -0.02632974f, 0.19099210f, -0.09578811f, 0.21226801f, 0.01768248f, 
    -0.01047892f, -0.03802069f, -0.14497827f, -0.07106858f, 0.20683834f, 0.00883555f, 0.35036564f, -0.03379656f, 
    -0.08893335f, 0.14095624f, -0.02607241f, 0.05359194f, -0.02414628f, 0.16632861f, -0.11575684f, 0.13967450f, 
    0.02441638f, -0.03183275f, -0.00820209f, 0.04578219f, 0.23533429f, 0.01351713f, 0.07009028f, 0.15766875f, 
    -0.05451422f, -0.10777929f, 0.00292363f, -0.00823998f, 0.04089916f, 0.01277259f, 0.07248756f, -0.03391581f, 
    -0.07239276f, 0.00867717f, -0.00622406f, -0.03351332f, 0.08489259f, -0.04205099f, -0.00183636f, -0.02754824f, 
    0.22404231f, -0.02136212f, -0.02657746f, -0.09601998f, -0.02011670f, -0.07987040f, 0.09706247f, 0.05801115f, 
    0.07972648f, 0.05174030f, -0.01890437f, 0.00142388f, 0.36446792f, -0.08743654f, 0.06348116f, 0.03272421f, 
    0.00791413f, 0.00452245f, -0.04070865f, 0.04024349f, 0.05717281f, 0.15689307f, 0.01951411f, -0.08312543f, 
    0.10129327f, 0.14956652f, -0.02631076f, -0.01186283f, 0.01094730f, 0.03004808f, -0.08361307f, -0.16201000f, 
    -0.12121619f, 0.03729773f, 0.12809084f, -0.07237080f, 0.41783997f, 0.38682583f, 0.05014703f, 0.06357425f, 
    -0.06346837f, -0.10223699f, -0.06989353f, -0.01345470f, -0.01278240f, 0.04276713f, 0.02677101f, 0.02977281f, 
    0.05971439f, 0.05634198f, -0.09070957f, 0.01124729f, 0.01611812f, -0.03550141f, 0.01316111f, 0.14470169f, 
    0.08937199f, 0.09170945f, 0.11708759f, -0.22086664f, 0.28288281f, 0.17784891f, -0.07749724f, -0.09855723f, 
    0.06598835f, 0.10690304f, -0.05467060f, 0.01334401f, 0.16753362f, 0.04087849f, -0.05377328f, -0.17281529f, 
    -0.17033091f, 0.16411969f, -0.00378617f, 0.03115439f, -0.07141965f, -0.08096877f, 0.00606273f, 0.06163839f, 
    0.10373030f, 0.04477798f, 0.02087978f, 0.09070351f, -0.14764275f, 0.17232591f, -0.22801366f, -0.10509772f, 
    -0.44836417f, -0.18342103f, -0.05748309f, 0.09625710f, 0.01956176f, -0.06380379f, -0.05117318f, 0.06780254f, 
    0.14371493f, 0.19377501f, 0.11217780f, 0.19363983f, -0.09604739f, -0.00172825f, -0.00708179f, 0.11305923f, 
    0.03134673f, -0.04647920f, -0.03519227f, 0.10340575f, 0.04484904f, 0.03671831f, -0.08414590f, -0.09913497f, 
    -0.04382368f, -0.09609639f, 0.16685037f, 0.06013999f, 0.01769050f, 0.01898832f, 0.12117155f, 0.09956708f, 
    -0.12529083f, 0.05784106f, 0.10505155f, -0.10446198f, 0.00341992f, 0.03757265f, 0.06117764f, 0.07024122f, 
    0.03961878f, -0.17537564f, -0.02060016f, -0.00442271f, -0.12731661f, -0.16170545f, 0.00457091f, -0.03241558f, 
    -0.04586956f, 0.05487473f, 0.09811869f, 0.22096127f, 0.20371413f, -0.13645545f, 0.01918230f, 0.06681214f, 
    0.31688738f, -0.25703293f, -0.10091472f, -0.19254960f, 0.01089492f, 0.01646331f, 0.07622034f, 0.05570905f, 
    0.09228306f, 0.02722738f, 0.05437119f, 0.04596100f, -0.34925443f, 0.08941699f, -0.03627250f, -0.15403201f, 
    -0.06516184f, 0.07850009f, -0.00494441f, 0.23282100f, 0.01733310f, 0.08310381f, -0.01814166f, -0.09982051f, 
    -0.35115364f, -0.05227675f, -0.27967325f, -0.36617613f, 0.00757809f, 0.07263270f, -0.06935621f, 0.02600438f, 
    0.03075322f, -0.03827083f, 0.09962214f, -0.28155321f, -0.27673262f, 0.12344564f, -0.26411200f, -0.41466603f, 
    -0.35673007f, 0.04808019f, -0.20101286f, -0.19348615f, 0.09579460f, -0.07809652f, -0.13481301f, -0.05706275f, 
    0.13953267f, 0.01861169f, 0.06376426f, 0.08828348f, 0.18821840f, -0.04566430f, -0.04797168f, -0.07472480f, 
    -0.21144672f, -0.14607425f, 0.00143427f, -0.03503191f, -0.23978594f, -0.04905593f, -0.15685937f, -0.05453619f, 
    -0.02787494f, -0.05247614f, -0.03414461f, 0.07888447f, 0.19262125f, 0.10507376f, -0.05939484f, 0.01342860f, 
    0.10704753f, 0.07861011f, 0.05618434f, 0.02544382f, 0.13612187f, 0.05435527f, 0.24194269f, -0.17330773f, 
    -0.08559675f, -0.03390303f, 0.03370786f, -0.04144836f, 0.18662089f, -0.35608372f, -0.02566334f, -0.11183033f, 
    0.13892892f, 0.12500370f, 0.11495680f, -0.00604271f, -0.01581536f, 0.27175412f, -0.08462150f, -0.03184714f, 
    0.12548813f, 0.04299088f, 0.00011304f, -0.06094080f, -0.15341696f, -0.11829801f, 0.02583038f, -0.01934683f, 
    0.02063285f, 0.07461007f, -0.06832375f, 0.05378939f, 0.02604087f, 0.01017540f, 0.16196960f, -0.05704258f, 
    0.04129004f, -0.02875324f, 0.05456368f, 0.01013723f, 0.02968051f, 0.09603783f, 0.08286408f, -0.02409072f, 
    -0.11133493f, -0.15010053f, -0.09733960f, -0.16326140f, 0.11110576f, 0.15952580f, 0.09947587f, -0.09258961f, 
    -0.06644280f, -0.02051265f, -0.14607604f, 0.00363102f, 0.38253194f, 0.25828922f, -0.26145691f, -0.10443127f, 
    0.04791020f, -0.19509226f, -0.11992086f, 0.08135241f, 0.30966258f, -0.03591669f, 0.10518900f, -0.16553694f, 
    -0.00000496f, -0.08229995f, -0.12214503f, 0.09903955f, 0.10545886f, 0.04300849f, -0.29760879f, -0.21887346f, 
    -0.04002137f, -0.04107844f, -0.16780908f, 0.03751237f, -0.26289758f, 0.01654317f, -0.22228678f, -0.54609406f, 
    -0.09534825f, 0.04157464f, 0.05402761f, 0.10613603f, 0.14629468f, 0.10899891f, 0.03452898f, -0.12201379f, 
    0.03569874f, -0.03833902f, 0.09394016f, 0.05520071f, -0.01269588f, 0.11073421f, -0.00979597f, 0.02974567f, 
    0.18948421f, -0.12475117f, -0.08064546f, 0.17685583f, -0.02430363f, -0.30011758f, -0.00742255f, 0.08822097f, 
    0.10872415f, 0.16169144f, 0.10854644f, 0.05821224f, 0.05803040f, 0.21631369f, 0.06392699f, 0.06585924f, 
    0.08243877f, 0.04097947f, -0.05661244f, 0.17935637f, 0.05664929f, -0.07358950f, 0.00527123f, -0.01223979f, 
    -0.03598687f, 0.01676499f, 0.02635079f, -0.13641295f, 0.19442649f, 0.18919875f, 0.11766006f, 0.12180860f, 
    0.09622478f, -0.16015610f, 0.02338897f, 0.05649752f, 0.07682069f, 0.08166568f, 0.04436686f, -0.14539754f, 
    0.04095406f, 0.12555282f, -0.05386930f, 0.15543723f, -0.01848491f, -0.01028383f, -0.01015654f, 0.07070016f, 
    0.19486713f, 0.19738059f, 0.10860717f, 0.22060198f, -0.20276566f, 0.11851975f, 0.14601915f, -0.45930755f, 
    -0.28422508f, 0.20767176f, -0.31335551f, -0.17200994f, -0.11996140f, -0.07709815f, -0.23617584f, -0.04319399f, 
    -0.15508351f, -0.09501848f, 0.04805221f, 0.00980736f, -0.04754493f, 0.00220336f, -0.00453239f, 0.09628250f, 
    0.02304562f, -0.03852615f, -0.09094729f, -0.06054796f, 0.12251657f, 0.05703530f, 0.06677833f, 0.11519547f, 
    0.09218495f, -0.11234417f, 0.07333090f, 0.00451908f, -0.06219374f, -0.02043166f, -0.04582147f, 0.03711623f, 
    0.05073331f, -0.06054493f, -0.08861945f, -0.05184616f, -0.06877486f, 0.04112603f, 0.01899029f, -0.12423352f, 
    0.07733769f, 0.11577750f, 0.06479076f, 0.05500894f, 0.07664258f, 0.04783211f, 0.05617733f, 0.20555818f, 
    -0.27043727f, 0.03054261f, -0.00633993f, 0.01506795f, -0.03966811f, -0.06442283f, 0.02622560f, 0.08052722f, 
    0.16406512f, -0.23905745f, 0.08951183f, -0.03314770f, -0.11822978f, -0.16707927f, 0.22984827f, -0.06919080f, 
    0.00239833f, 0.02885763f, -0.05637150f, 0.00362570f, 0.09788504f, 0.04544102f, -0.01725982f, 0.02991544f, 
    0.11724325f, -0.08743513f, 0.01175990f, -0.05838010f, -0.02145249f, -0.08151925f, 0.02825558f, 0.01198836f, 
    -0.21678124f, -0.26326036f, 0.06936553f, 0.01919190f, 0.17661235f, 0.09146415f, -0.04959920f, -0.10717134f, 
    0.05240537f, 0.11519869f, 0.05940994f, 0.07572746f, -0.06709874f, -0.16066031f, -0.06052563f, -0.00374315f, 
    0.17973384f, 0.11518604f, -0.20041572f, 0.02036444f, 0.20562091f, -0.07610114f, 0.05601437f, 0.12642045f, 
    0.05183334f, 0.28458926f, -0.19231372f, -0.46882668f, 0.05199980f, -0.05845781f, 0.00756067f, 0.07119120f, 
    0.12702663f, 0.10185533f, -0.18902034f, 0.01199354f, 0.19518603f, 0.08932966f, -0.18738817f, -0.01679665f, 
    0.00219923f, -0.04957229f, 0.19947805f, -0.10630284f, 0.02278315f, -0.12821031f, -0.04184680f, 0.01581011f, 
    0.03120368f, -0.01827240f, -0.04063074f, 0.02687536f, 0.05590352f, -0.07232548f, -0.05746522f, -0.04231833f, 
    0.09907968f, 0.05563515f, -0.08419801f, 0.02479240f, -0.13371168f, -0.31827852f, -0.04404360f, -0.31802967f, 
    0.14221321f, -0.11471627f, -0.06945199f, 0.07619775f, -0.23275770f, -0.02843529f, -0.03073566f, -0.04720729f, 
    0.01440598f, -0.28769594f, 0.03924726f, 0.02575640f, -0.06497854f, 0.04097030f, -0.04693251f, -0.04569204f, 
    -0.11954988f, -0.00842912f, 0.08423902f, -0.03395028f, -0.01404036f, -0.04729294f, 0.06365282f, -0.23579648f, 
    -0.03613981f, -0.05310782f, 0.08881722f, -0.11682016f, 0.01813936f, 0.07585707f, 0.02120005f, 0.00277444f, 
    0.15284511f, 0.19655085f, 0.48195821f, 0.19804157f, -0.00525786f, -0.04406286f, -0.05451477f, 0.01433307f, 
    -0.03417256f, 0.07686269f, 0.00949945f, 0.12295681f, 0.16001673f, 0.15640219f, 0.16170892f, 0.00507448f, 
    0.01238376f, -0.18818347f, 0.00245762f, 0.10870022f, 0.07118333f, 0.02930907f, 0.15592869f, -0.00554720f, 
    -0.29949713f, -0.30309871f, 0.00403837f, -0.09321319f, -0.10076302f, -0.08671009f, -0.19557866f, -0.04314160f, 
    0.00097213f, -0.00436928f, 0.12386678f, 0.04703213f, -0.06011930f, -0.00646821f, 0.11016978f, 0.21919705f, 
    0.12096004f, -0.16335016f, -0.06006402f, 0.01710209f, -0.16468526f, -0.04940908f, -0.16552533f, 0.10127056f, 
    0.13522600f, 0.03098667f, 0.08714242f, -0.35916761f, 0.09111511f, -0.10408712f, -0.16647346f, 0.04387246f, 
    0.02825059f, 0.15267567f, 0.02592471f, 0.02213557f, -0.10514502f, -0.14535944f, 0.06158745f, -0.26062381f, 
    -0.00149960f, -0.10856974f, -0.06571295f, 0.10115333f, 0.14189947f, 0.04873648f, 0.08755561f, 0.11755068f, 
    0.12765059f, 0.10717088f, 0.04675810f, 0.03856267f, -0.05835091f, -0.01067141f, 0.03853455f, 0.04631694f, 
    -0.00934554f, -0.03594152f, -0.13904184f, -0.09754036f, 0.21054125f, -0.02629910f, -0.07841405f, 0.10407854f, 
    -0.07152168f, -0.08143363f, -0.02201733f, 0.00497963f, 0.01128302f, -0.06711151f, -0.16838236f, 0.02627391f, 
    0.04819323f, -0.00305470f, 0.06756119f, 0.22676262f, -0.02499864f, -0.04209787f, 0.01607436f, 0.06037138f, 
    0.04207480f, 0.17459510f, 0.15797783f, 0.25340781f, -0.03577662f, -0.07035063f, 0.11043973f, 0.10503937f, 
    0.06550150f, -0.04457575f, -0.00968812f, -0.04442478f, -0.05088051f, -0.08566986f, -0.07444022f, 0.03355801f, 
    -0.24808829f, 0.16109274f, -0.00376017f, -0.14650400f, -0.11434239f, -0.05019883f, -0.00957434f, 0.09197625f, 
    0.11300404f, 0.07383061f, 0.14275438f, 0.02687855f, -0.37688005f, -0.09736776f, -0.22364891f, -0.46514443f, 
    -0.18450285f, -0.10500124f, -0.05397478f, -0.09528144f, -0.03584064f, -0.09739757f, 0.01155249f, -0.00809129f, 
    0.02991939f, -0.08562323f, 0.06299220f, -0.02905652f, 0.09744611f, 0.04796260f, 0.01413727f, 0.05886669f, 
    0.15880717f, 0.04741321f, 0.07903886f, -0.00597880f, -0.30725488f, -0.23611827f, -0.20771784f, -0.11956901f, 
    -0.05487452f, -0.06248036f, -0.06651872f, -0.11778522f, 0.02504371f, 0.05646109f, -0.00235232f, 0.00917634f, 
    -0.19031955f, 0.05379917f, 0.25703770f, -0.06958535f, -0.17121911f, -0.06113645f, -0.03766811f, -0.00274298f, 
    -0.04160304f, 0.01633096f, 0.08603437f, -0.02054147f, -0.00938622f, -0.04859668f, 0.30318892f, 0.45177901f, 
    -0.06191188f, 0.05051054f, -0.05612127f, 0.02935628f, -0.06301203f, 0.01032433f, -0.05193488f, 0.01394745f, 
    0.10775020f, -0.02507498f, -0.05107056f, -0.02737246f, 0.10669223f, 0.02839584f, 0.08762676f, 0.04845225f, 
    0.05685690f, -0.17608707f, -0.01205924f, -0.05264536f, 0.03283395f, 0.00395524f, -0.01193775f, 0.05073677f, 
    -0.02136258f, 0.03631475f, -0.03500113f, 0.03793794f, 0.08761659f, -0.00681716f, 0.03906086f, -0.07049113f, 
    0.15310305f, -0.02108734f, 0.23740070f, 0.22748987f, -0.09461129f, -0.01450162f, -0.01466639f, 0.01722048f, 
    0.05568360f, -0.02232905f, 0.05627427f, 0.08843106f, -0.00387484f, -0.02891785f, 0.21531136f, 0.02702763f, 
    0.14951758f, -0.02035301f, -0.22658363f, 0.09037350f, 0.12634373f, -0.10605333f, 0.04406216f, -0.03994714f, 
    -0.03794454f, -0.34691280f, -0.29024470f, 0.04145870f, 0.11060200f, 0.12010974f, -0.00290927f, -0.00387314f, 
    0.13486101f, 0.01439818f, 0.11077255f, -0.00016957f, -0.01431928f, -0.13332817f, -0.07180823f, 0.05712303f, 
    0.07352356f, 0.04363864f, 0.01847326f, 0.00935026f, 0.01639198f, -0.05615837f, -0.01519794f, -0.01649482f, 
    0.22886899f, 0.10400588f, -0.08934028f, -0.07620998f, -0.00884108f, -0.06592380f, 0.05851189f, 0.05449622f, 
    -0.11008834f, 0.13745834f, 0.06547563f, 0.09320214f, 0.27843601f, 0.32550463f, 0.41471156f, 0.05656780f, 
    0.02249644f, -0.01654972f, -0.07359019f, 0.00884040f, 0.03070786f, 0.21429673f, -0.00300305f, 0.02901532f, 
    -0.03059031f, 0.11274146f, -0.14557399f, 0.22732885f, 0.02929404f, 0.06119271f, 0.05509669f, 0.04414266f, 
    -0.11145371f, -0.06587204f, -0.04249612f, 0.10039842f, -0.27177247f, -0.00085184f, -0.49886286f, 0.07366639f, 
    0.00886705f, 0.14627118f, 0.19960570f, 0.03932922f, -0.04661871f, -0.01355563f, 0.02664118f, 0.03620072f, 
    -0.16071457f, 0.07005455f, -0.11200722f, 0.10710850f, 0.20088503f, -0.01044102f, 0.13627256f, -0.07403367f, 
    0.03614645f, -0.04972950f, -0.05042937f, 0.10488970f, -0.14256188f, 0.22779517f, 0.27042744f, -0.03063015f, 
    -0.07989961f, -0.04066697f, 0.00419233f, -0.02260356f, -0.06160025f, -0.10800680f, 0.11503026f, -0.09256234f, 
    -0.38093403f, -0.06731669f, -0.10905703f, 0.13924463f, -0.04653963f, 0.12160041f, 0.06007725f, 0.01321037f, 
    -0.02580666f, -0.06499399f, 0.02733444f, 0.06409856f, -0.05670182f, -0.18477616f, -0.14940707f, -0.24317513f, 
    -0.09002858f, 0.04630257f, 0.08722797f, -0.00542301f, -0.17293905f, 0.01592241f, 0.03097223f, 0.02118304f, 
    0.28501427f, -0.11937456f, 0.17510024f, -0.09796529f, 0.05008367f, -0.00274656f, 0.07364316f, -0.05954855f, 
    0.09990352f, 0.07473121f, 0.07448904f, 0.19660574f, -0.23990580f, 0.38068575f, 0.38255772f, 0.27097154f, 
    -0.03770941f, -0.02194619f, -0.10359844f, -0.12678330f, -0.09202506f, -0.09485130f, -0.08458707f, 0.16710807f, 
    0.18487798f, 0.30416441f, -0.34760222f, -0.19308598f, 0.03530693f, -0.00749555f, -0.04351123f, -0.02408906f, 
    -0.02767920f, -0.02307592f, 0.06350297f, 0.00823071f, -0.35065827f, -0.05238036f, -0.25442004f, -0.10250369f, 
    0.01929050f, -0.13119738f, -0.10961865f, 0.03272542f, -0.27519992f, 0.09145870f, 0.14599280f, -0.01233902f, 
    0.04425351f, 0.07304149f, 0.18395847f, -0.02320147f, 0.05440640f, -0.17277701f, 0.02249189f, -0.10889260f, 
    0.09575140f, 0.03092285f, 0.00792837f, 0.08707087f, 0.09046506f, 0.09048644f, -0.34868938f, -0.36759388f, 
    0.02119230f, 0.15790679f, -0.01307862f, -0.02140503f, 0.04293422f, 0.03626265f, -0.07728700f, -0.01958344f, 
    -0.03781101f, 0.01033615f, -0.08972949f, -0.10030926f, 0.09592758f, 0.12324879f, 0.16034792f, -0.12185239f, 
    0.04279968f, -0.08070381f, -0.03420124f, 0.01143415f, -0.04121801f, -0.09327644f, -0.06791508f, -0.17825074f, 
    0.15476140f, -0.02130890f, -0.00938530f, 0.04472161f, 0.04250436f, 0.07773843f, 0.05609601f, -0.02264169f, 
    0.00322430f, -0.06114425f, -0.14385405f, 0.05034573f, 0.02380455f, 0.01724916f, 0.07295898f, -0.03060340f, 
    -0.04867313f, -0.03723110f, -0.09245381f, 0.04212831f, 0.04361735f, 0.01982130f, -0.04228816f, 0.03932941f, 
    0.03178877f, 0.02409804f, 0.05955176f, 0.01848402f, -0.08355530f, -0.04984277f, -0.03126371f, -0.08274867f, 
    -0.08312756f, 0.01881229f, -0.17264508f, -0.08860267f, -0.09638907f, 0.05843465f, -0.05264875f, -0.00564215f, 
    0.00044692f, 0.00238250f, 0.08204624f, -0.04581854f, 0.25016540f, 0.40070227f, 0.07056018f, -0.46634227f, 
    0.01652848f, -0.21669209f, 0.07875092f, -0.02889982f, 0.09109408f, 0.06325595f, 0.04346455f, -0.01848440f, 
    -0.20554672f, -0.08324146f, -0.02335152f, -0.21073732f, -0.01838757f, 0.04864508f, -0.10021094f, -0.12971811f, 
    0.00371109f, 0.03166274f, -0.06286864f, -0.00061698f, -0.31666112f, 0.34723035f, 0.23418768f, 0.07766115f, 
    -0.02463837f, -0.00996939f, -0.00533801f, -0.04348893f, -0.05935493f, -0.03264471f, -0.01382130f, 0.03413995f, 
    0.07446843f, -0.04132412f, 0.12649238f, 0.12731035f, -0.00854093f, 0.00241285f, -0.04414867f, 0.08403732f, 
    0.12988605f, 0.02186345f, 0.01945251f, 0.17796747f, -0.10310018f, -0.07445653f, 0.14422287f, -0.04884442f, 
    0.13865444f, 0.04927707f, 0.19084907f, 0.01247199f, 0.03883884f, 0.14157815f, 0.03107854f, 0.07891006f, 
    -0.03691482f, -0.06399513f, 0.14009358f, 0.06118771f, -0.14617756f, 0.06296051f, 0.07594891f, 0.13629477f, 
    0.02407370f, 0.02562408f, 0.12188143f, 0.01864442f, 0.17193823f, 0.12990391f, -0.01195046f, -0.05818243f, 
    0.16156374f, -0.25296432f, 0.09918533f, -0.04123889f, 0.03217566f, 0.11549930f, -0.16046427f, -0.06990756f, 
    0.11725908f, 0.08840677f, 0.32054529f, 0.19604874f, 0.07539014f, -0.07041710f, 0.04007348f, 0.07943167f, 
    0.01649157f, -0.10835783f, 0.16085050f, 0.10325406f, -0.29103962f, 0.06475284f, 0.10464624f, 0.11767074f, 
    -0.01945379f, -0.11737748f, -0.10930485f, 0.17485680f, -0.19913395f, 0.04797939f, 0.01787361f, 0.01284581f, 
    0.13678066f, 0.23015305f, 0.30960530f, 0.12911381f, -0.05929287f, -0.07294627f, -0.06632363f, -0.00775840f, 
    -0.13616745f, 0.01130287f, 0.04558630f, -0.01994317f, -0.06446927f, -0.19146618f, -0.11415032f, 0.04281221f, 
    0.16881949f, -0.02811946f, 0.14975287f, 0.02661523f, -0.01224076f, -0.02933365f, -0.05548754f, -0.07123648f, 
    -0.04060903f, 0.14059302f, 0.16402857f, -0.00760237f, 0.06263047f, 0.05926076f, -0.03368253f, -0.00079553f, 
    -0.00569645f, 0.09777910f, 0.08667356f, 0.04253509f, -0.10142742f, -0.14312194f, -0.06690909f, 0.08567458f, 
    -0.02499096f, 0.13232009f, 0.05325709f, -0.02322220f, -0.08471809f, -0.08683308f, 0.02453777f, 0.00812615f, 
    -0.12732241f, 0.03233401f, -0.01611746f, 0.06785502f, 0.06755080f, 0.11830293f, -0.13399497f, 0.10498432f, 
    0.33231360f, -0.06060720f, -0.01371180f, 0.17657267f, -0.16695438f, -0.34779358f, -0.08859189f, -0.39659202f, 
    -0.10495816f, -0.17683531f, -0.08937012f, -0.12126314f, -0.01364291f, -0.06446858f, 0.04166438f, -0.06572358f, 
    0.00762162f, -0.01501634f, -0.01888849f, 0.01623750f, -0.03385775f, 0.02752461f, -0.02351968f, 0.02359062f, 
    0.03075625f, 0.02265967f, 0.00378693f, 0.00961176f, 0.00501104f, 0.00037804f, -0.00235365f, -0.03274717f, 
    0.01605948f, 0.00031586f, -0.00482032f, 0.02134912f, 0.00480207f, -0.01676037f, -0.01676038f, -0.01611905f, 
    -0.04075976f, 0.00822905f, 0.02679268f, -0.00402815f, -0.02834931f, 0.01935530f, 0.01122368f, 0.02279460f, 
    0.00167120f, -0.03060309f, 0.01227119f, -0.03389504f, -0.03497792f, -0.03086138f, -0.02829546f, 0.01704102f, 
    0.00708253f, 0.02908095f, -0.02995116f, -0.00637944f, -0.00240762f, -0.03480114f, -0.00704765f, -0.03366344f, 
    0.01246756f, 0.03185345f, -0.01081288f, 0.02642682f, 0.02444687f, -0.01228526f, -0.00416566f, -0.03416313f, 
    0.02695727f, 0.01699870f, 0.01051327f, 0.00145510f, -0.03621368f, 0.01469303f, -0.00611814f, -0.01667845f, 
    0.00960353f, -0.03575664f, -0.00725605f, -0.01657420f, -0.02806679f, 0.01331762f, -0.00925131f, 0.00384279f, 
    0.01885158f, 0.01719555f, -0.03176674f, 0.01201096f, 0.01617303f, -0.00030126f, -0.03908278f, -0.01283711f, 
    -0.03494310f, -0.00215517f, 0.01222234f, -0.03181328f, 0.01881072f, -0.00999455f, -0.00601998f, 0.02179452f, 
    0.02938596f, -0.02529068f, 0.02936198f, -0.01148846f, -0.04054444f, -0.01733175f, -0.02998932f, 0.01429415f, 
    -0.01603172f, 0.00864530f, 0.01674169f, 0.02958223f, 0.01415221f, 0.02874861f, -0.00663792f, 0.01925259f, 
    -0.03240719f, -0.00198359f, 0.02551901f, 0.02734566f, 0.01534970f, 0.01147290f, -0.01421149f, 0.00867149f, 
    -0.02608063f, 0.02137985f, -0.01985132f, 0.00376332f, 0.00060752f, -0.00537625f, -0.03600473f, -0.03449410f, 
    -0.00224813f, -0.00867280f, 0.00002385f, -0.00251858f, -0.00902068f, -0.00906320f, -0.01514642f, -0.01047989f, 
    0.01748540f, -0.00964897f, -0.03709402f, -0.03095916f, 0.00938418f, 0.00066694f, -0.03433635f, -0.01537102f, 
    0.02953697f, 0.01043342f, -0.02702284f, 0.02172540f, -0.00434509f, -0.01971218f, -0.01355018f, -0.01463975f, 
    -0.02867986f, -0.03756781f, -0.02560234f, -0.02600262f, 0.00193204f, -0.01881077f, 0.01448459f, 0.02490337f, 
    -0.03559521f, 0.00499504f, 0.01368170f, 0.01725580f, -0.02223232f, -0.01563833f, 0.00007532f, -0.01832109f, 
    0.01758475f, -0.01489097f, 0.01079364f, 0.00280111f, 0.00536399f, 0.01729146f, 0.00177281f, 0.02484133f, 
    -0.02223936f, -0.03349282f, -0.01618441f, 0.02870153f, -0.00427579f, 0.00931583f, -0.02671635f, -0.03482779f, 
    -0.00154934f, -0.01644074f, 0.02030974f, -0.01039068f, -0.02926748f, 0.01949519f, 0.00572240f, -0.00499825f, 
    -0.02973616f, 0.00675523f, -0.01971480f, -0.02753207f, 0.01284526f, -0.02630159f, -0.00132422f, 0.01130759f, 
    -0.02944574f, -0.00317851f, 0.01358007f, -0.03802098f, 0.01081167f, -0.02928966f, 0.00985171f, -0.01479904f, 
    0.00847234f, -0.00356396f, 0.00775176f, -0.03629947f, 0.01771869f, 0.01137770f, 0.01522274f, 0.01412145f, 
    -0.00414238f, 0.03158384f, -0.01157597f, -0.01902183f, 0.00484006f, 0.01750362f, -0.01226406f, 0.02634193f, 
    -0.02978148f, -0.02948506f, -0.03276322f, -0.01449730f, -0.03514325f, -0.03943565f, -0.01087285f, 0.02970637f, 
    0.00134033f, -0.02703630f, -0.03319474f, 0.00492863f, -0.03767681f, 0.01111294f, 0.00829236f, 0.02239168f, 
    0.02794622f, 0.01510992f, -0.02738295f, -0.03095114f, 0.01451760f, -0.01611727f, 0.02748175f, -0.00557462f, 
    -0.01040372f, -0.03146966f, -0.00099395f, 0.01169146f, 0.02350968f, -0.03418206f, -0.00159961f, 0.01306356f, 
    0.00722442f, 0.00446505f, 0.02040959f, -0.03841212f, 0.00027260f, 0.01894536f, -0.00643517f, -0.00787770f, 
    0.02225957f, -0.02738182f, 0.01512977f, 0.00314298f, -0.03261696f, -0.00886771f, 0.01813335f, -0.00975460f, 
    -0.00218302f, 0.02600929f, 0.02025664f, 0.01389200f, -0.01632127f, -0.01637210f, -0.01545321f, -0.03300688f, 
    0.02038659f, -0.01396096f, -0.00625337f, -0.01580090f, -0.03626820f, -0.01160226f, 0.00678734f, -0.00858050f, 
    -0.01578283f, 0.00457192f, -0.02939455f, -0.02820310f, 0.02096695f, 0.02031423f, 0.01317874f, -0.00965956f, 
    0.00394022f, 0.02007039f, 0.00602659f, 0.01237968f, -0.01405409f, 0.02027233f, -0.01638541f, -0.01954423f, 
    0.02793623f, -0.01299116f, -0.03845141f, -0.01358591f, -0.03250834f, -0.03444809f, 0.02763797f, -0.03695779f, 
    -0.00283584f, -0.02581139f, -0.00239453f, -0.02922067f, -0.02409211f, 0.00245744f, 0.01509976f, -0.03234091f, 
    -0.02946083f, -0.01784044f, 0.01335012f, 0.00963653f, -0.03052733f, -0.01265328f, 0.02787843f, -0.03411043f, 
    0.01189196f, -0.02807464f, 0.01468506f, -0.00303542f, 0.02875835f, -0.01329133f, -0.00787057f, 0.01359912f, 
    -0.04107662f, -0.02701988f, -0.02078131f, -0.02460556f, -0.00474534f, -0.02771326f, -0.02069272f, 0.02736711f, 
    -0.01735266f, -0.02887883f, 0.00204352f, 0.00775208f, -0.00367972f, -0.00182960f, 0.02149341f, 0.01503615f, 
    -0.01780166f, 0.00703994f, 0.00107286f, 0.00146039f, 0.02236260f, 0.02347126f, -0.00636914f, 0.00766775f, 
    -0.01364484f, -0.00421274f, 0.02567007f, 0.00995551f, -0.01465583f, 0.02901266f, -0.03294799f, -0.00203827f, 
    0.02728895f, 0.02869975f, 0.00394654f, -0.01948328f, -0.00748013f, 0.00995558f, 0.00530834f, -0.00987196f, 
    0.02434264f, 0.00065162f, 0.00470871f, -0.02826324f, 0.02371990f, 0.01151306f, 0.01547844f, 0.01826488f, 
    0.00313257f, -0.01532863f, 0.02495169f, -0.03755881f, -0.03895336f, 0.01463635f, -0.01497215f, 0.01907109f, 
    -0.02267509f, -0.01355889f, -0.01541010f, -0.03495730f, 0.00791691f, -0.02798701f, 0.00717903f, -0.01049072f, 
    -0.01339273f, -0.03719060f, 0.01848471f, -0.00835811f, -0.02823215f, 0.00904721f, -0.02602895f, 0.00884992f, 
    -0.03434904f, -0.02365783f, -0.03718346f, 0.02752322f, 0.01234329f, -0.00361507f, 0.03040525f, -0.03991924f, 
    -0.03179257f, -0.01989352f, -0.03856018f, -0.03516434f, -0.03784035f, 0.01972234f, -0.03200150f, -0.03602049f, 
    0.02153512f, -0.02661385f, 0.00768538f, -0.00203347f, -0.02461372f, 0.02496068f, -0.01177637f, -0.01121037f, 
    -0.03130249f, -0.01422235f, -0.01423284f, 0.00385192f, -0.01679389f, -0.01837964f, -0.02341954f, 0.00095209f, 
    -0.01366045f, 0.00845644f, 0.03110444f, 0.00370069f, 0.02660417f, -0.02930663f, 0.02831946f, -0.00184691f, 
    -0.00595856f, -0.01474429f, -0.00133941f, 0.02121267f, 0.00709168f, -0.03366600f, 0.02437398f, 0.01959374f, 
    -0.01889408f, -0.01491485f, -0.03318731f, -0.01454312f, -0.02500723f, -0.03332370f, -0.03265231f, -0.01642827f, 
    -0.03512688f, -0.01029679f, 0.00724365f, -0.04085533f, -0.02970392f, -0.04109126f, -0.01668998f, -0.01594480f, 
    -0.01000785f, 0.01102070f, 0.01785833f, -0.02213250f, -0.00863022f, 0.00201151f, 0.00810186f, 0.01629435f, 
    0.00819270f, -0.02704136f, 0.02008424f, -0.01998032f, -0.01252535f, -0.03636277f, 0.01215998f, 0.00633002f, 
    -0.00407646f, -0.00952220f, -0.03843547f, -0.01752980f, 0.02505288f, -0.02790777f, -0.02520554f, 0.02915158f, 
    0.01592138f, -0.00803287f, -0.03898948f, -0.03855333f, 0.01743179f, -0.00532351f, -0.01833407f, -0.03471139f, 
    0.02594635f, 0.02936599f, -0.01500736f, 0.01646537f, -0.02771447f, -0.02323464f, 0.00282375f, 0.02075208f, 
    -0.03605163f, -0.02131535f, -0.00067955f, 0.01312564f, -0.02430007f, -0.03349464f, -0.01815341f, -0.03265677f, 
    0.01289250f, -0.00835195f, -0.03455304f, 0.01670427f, -0.00652494f, -0.01215628f, 0.01466148f, 0.00406331f, 
    0.01609491f, -0.03258350f, -0.00118528f, -0.02439077f, 0.02432930f, -0.00951177f, -0.03967208f, 0.01045631f, 
    0.00704334f, -0.03173242f, -0.03188327f, -0.01997536f, -0.00388938f, 0.00291134f, -0.00446561f, -0.02635185f, 
    -0.03180620f, -0.00190969f, -0.01214045f, -0.03335730f, -0.00307878f, -0.02165371f, -0.01991164f, 0.00307450f, 
    -0.00251851f, -0.02754525f, -0.03963658f, 0.01635453f, 0.01842442f, 0.01782176f, -0.02161698f, -0.02959616f, 
    0.02940533f, -0.00527693f, -0.03907621f, -0.03799997f, -0.03631516f, -0.00754473f, 0.02152044f, -0.01733988f, 
    -0.02238346f, 0.02318808f, -0.00214722f, -0.00184734f, 0.00253901f, -0.00856460f, 0.01765928f, 0.02335688f, 
    -0.01336887f, 0.01772057f, -0.01809510f, 0.00290257f, -0.00608224f, 0.03121789f, 0.00683431f, 0.01121943f, 
    -0.03316855f, 0.00508206f, -0.02730616f, -0.00263932f, -0.04077698f, 0.02075377f, 0.00859930f, -0.01062548f, 
    -0.00501306f, 0.02444549f, 0.00479447f, 0.00797244f, -0.00199832f, -0.02065629f, -0.00645552f, -0.01954402f, 
    -0.00621672f, -0.00713769f, 0.02950213f, -0.02853558f, -0.02760722f, -0.01077748f, -0.00842748f, 0.00612883f, 
    -0.02912398f, 0.01514597f, -0.02066944f, 0.01317138f, -0.03278276f, 0.01217881f, -0.03627783f, -0.02826520f, 
    -0.00689471f, -0.02533042f, -0.02090861f, 0.02245576f, 0.02155176f, -0.01843190f, 0.02482030f, 0.02216814f, 
    0.02352772f, 0.01250597f, -0.03752671f, 0.00790719f, -0.03436265f, -0.00263431f, 0.00381621f, 0.01642854f, 
    0.00787822f, -0.00778583f, 0.00822198f, 0.02591590f, -0.03936132f, -0.03717005f, -0.01221175f, -0.02256957f, 
    0.02345472f, -0.00039771f, 0.00134687f, -0.01867152f, -0.03212156f, -0.02046595f, -0.03185778f, -0.03400601f, 
    -0.01166780f, 0.00098070f, 0.00122124f, -0.02222807f, -0.00836197f, 0.01712064f, -0.01186992f, 0.02783887f, 
    0.02035138f, -0.02624715f, -0.02729405f, -0.00145359f, 0.00968721f, -0.00140467f, 0.00583979f, -0.01555985f, 
    -0.00116917f, -0.00321207f, -0.00584406f, 0.02565353f, -0.01623227f, -0.01559090f, -0.02994529f, -0.03103928f, 
    0.00531454f, -0.03832496f, 0.01996082f, 0.01148588f, 0.02375871f, -0.02383941f, -0.02652775f, 0.02207530f, 
    0.02427297f, -0.00236371f, 0.00889396f, -0.01049397f, -0.01895747f, -0.01396586f, -0.01218211f, -0.03831868f, 
    0.00500806f, 0.03121115f, 0.02176581f, -0.01513832f, 0.00386493f, 0.01413427f, 0.00087502f, -0.03235077f, 
    0.00068190f, -0.00704234f, -0.00787651f, 0.00808970f, -0.02886652f, 0.03253777f, -0.03022274f, -0.01112520f, 
    0.00097329f, 0.02975922f, -0.01464370f, 0.02582384f, -0.01646150f, -0.01834110f, -0.01254245f, -0.03459411f, 
    0.03076063f, -0.03510884f, -0.01468579f, -0.03963382f, -0.02477269f, 0.01171778f, 0.01306571f, -0.02558994f, 
    0.01536793f, -0.01160820f, -0.01457829f, 0.00069360f, 0.00613590f, -0.00166567f, -0.03183576f, 0.00062958f, 
    -0.03572841f, -0.00136268f, -0.02579980f, 0.00031878f, 0.02176771f, -0.03207368f, -0.03070265f, -0.04114106f, 
    0.00347937f, -0.03882047f, 0.00837387f, -0.02319750f, 0.03464610f, -0.03554733f, 0.00678331f, 0.01235366f, 
    -0.02477818f, -0.02972331f, -0.02022365f, 0.01207064f, -0.01865432f, -0.04001377f, -0.03843061f, -0.02850049f, 
    0.02592357f, 0.02368020f, 0.03008499f, -0.01282317f, 0.00460304f, 0.01733758f, -0.03736686f, -0.03626608f, 
    0.00343410f, -0.02290305f, 0.02729105f, 0.00326038f, 0.01600743f, -0.03402406f, -0.03797129f, -0.00855128f, 
    0.01810358f, 0.00985192f, 0.02725605f, -0.02883133f, 0.01354660f, -0.03491605f, 0.02284385f, -0.00180758f, 
    -0.05233689f, -0.09384643f, 0.24269827f, 0.11668807f, 0.04106705f, 0.06057095f, -0.07297601f, 0.10964478f, 
    -0.08229260f, -0.05958570f, 0.01627958f, -0.02841907f, -0.17702220f, 0.13605697f, 0.08602481f, 0.10281537f, 
    -0.03730911f, -0.11708230f, 0.10060326f, 0.00197404f, -0.01760492f, 0.07836133f, -0.04814821f, -0.03671902f, 
    0.00954027f, 0.15021183f, 0.17800960f, 0.22084729f, 0.06362642f, 0.13106145f, 0.04957244f, -0.15386453f, 
    -0.02887818f, -0.19361961f, 0.08977187f, -0.07621726f, 0.24632712f, 0.23638421f, -0.06204727f, -0.03105582f, 
    -0.00208178f, 0.02079731f, 0.05730974f, 0.01517448f, 0.02402121f, 0.07041988f, -0.06421690f, -0.01390758f, 
    0.05107804f, 0.09808971f, -0.06009974f, 0.01593602f, -0.09004443f, -0.01077819f, -0.02908586f, -0.02143708f, 
    0.13540642f, -0.02112839f, -0.03651928f, -0.05639008f, 0.18244688f, 0.08626299f, 0.28603086f, 0.14799392f, 
    0.19321044f, -0.11181659f, 0.11623676f, 0.06377931f, 0.04830146f, 0.16255972f, 0.07918774f, -0.10559989f, 
    -0.03310867f, 0.15741792f, -0.25740322f, 0.02805243f, 0.07563005f, -0.06745631f, 0.01474451f, 0.14231898f, 
    -0.07385759f, 0.03242739f, -0.15254757f, 0.03422362f, -0.08987046f, -0.08561153f, -0.11825980f, -0.00456932f, 
    -0.06039188f, -0.03655334f, 0.04548663f, 0.11563916f, -0.11197624f, -0.10689335f, -0.00997675f, 0.02699076f, 
    0.11240793f, -0.09492736f, -0.04791997f, -0.01400028f, -0.02839330f, 0.04850565f, -0.08248693f, -0.05508098f, 
    -0.00229037f, -0.00578764f, -0.06549681f, 0.01417392f, 0.00006020f, 0.13128623f, -0.03384520f, -0.01832277f, 
    0.03575698f, -0.06503960f, -0.10772673f, 0.00265218f, -0.07456174f, -0.07439905f, 0.01900709f, 0.07891071f, 
    -0.27117857f, 0.04223987f, -0.00166398f, 0.25145063f, -0.06675942f, -0.18425015f, 0.05946232f, -0.09658399f, 
    -0.09297712f, 0.01689230f, -0.02356420f, -0.04950156f, 0.13804765f, 0.07533002f, 0.03862279f, -0.19079229f, 
    0.04434092f, 0.01281592f, -0.05356491f, -0.04141108f, 0.12192047f, -0.03066383f, 0.07380975f, -0.02789587f, 
    0.09412646f, 0.01713449f, -0.07857314f, 0.02690934f, 0.19616233f, 0.16760401f, -0.03164145f, -0.17235348f, 
    0.05856314f, -0.15090099f, 0.09835440f, -0.03532302f, -0.29186085f, 0.10226386f, -0.14717300f, -0.25933042f, 
    -0.06893649f, -0.12642208f, 0.00521263f, 0.10166790f, -0.12391493f, 0.06167555f, -0.01942777f, -0.06113733f, 
    0.12451471f, 0.04037535f, 0.06374510f, 0.10883530f, 0.07856467f, -0.01119836f, -0.09247508f, 0.02135465f, 
    0.01946614f, 0.02494861f, -0.03999362f, 0.02776749f, 0.27344385f, 0.10346638f, 0.17698786f, 0.12373746f, 
    0.10295989f, 0.03609007f, -0.01874792f, -0.01968143f, -0.01079265f, -0.03976143f, -0.07430267f, -0.17321041f, 
    0.07868327f, 0.18007304f, 0.13539255f, 0.17167801f, 0.02585561f, -0.02126720f, 0.00564944f, 0.04673900f, 
    -0.07546862f, -0.15437247f, -0.24343675f, 0.01521403f, 0.36991957f, 0.03909276f, 0.04872333f, 0.13522911f, 
    0.03390853f, 0.04044956f, 0.00444359f, -0.00135714f, 0.17428938f, 0.11635903f, 0.11791965f, -0.09855016f, 
    -0.08448189f, -0.04372524f, -0.01546660f, -0.16849360f, -0.00635117f, -0.13501115f, 0.03658641f, 0.04325186f, 
    0.20525084f, -0.06242466f, 0.13108136f, -0.01235917f, 0.07965612f, 0.20659153f, 0.22454152f, 0.24463505f, 
    0.11811757f, 0.08674270f, 0.13270766f, 0.08783314f, 0.03866563f, -0.01066167f, 0.02911546f, -0.00998725f, 
    0.01647378f, 0.02322940f, 0.13205789f, -0.09990300f, -0.00169413f, -0.17563839f, -0.13804044f, -0.06128460f, 
    -0.26345298f, 0.12191774f, 0.01720049f, 0.27284187f, -0.10902075f, -0.11827182f, 0.16668653f, 0.07907911f, 
    -0.06284384f, 0.11779416f, -0.13638757f, -0.17092651f, -0.02433756f, -0.02813765f, -0.00531062f, -0.02708226f, 
    -0.18667844f, 0.03660991f, -0.07695594f, -0.01571018f, -0.04463938f, -0.01703686f, 0.12168601f, -0.08180943f, 
    -0.04518133f, -0.00726458f, -0.03551100f, 0.09813256f, 0.19191518f, -0.13705328f, 0.23772711f, 0.24583168f, 
    -0.00732055f, -0.00133989f, 0.06130340f, -0.02090761f, -0.04608490f, 0.00338340f, -0.16193342f, -0.13591577f, 
    0.11535657f, 0.12143705f, -0.05181773f, 0.00320403f, -0.02693661f, 0.07937840f, 0.04470143f, 0.06531778f, 
    0.24448177f, 0.00044701f, -0.10577931f, -0.06187074f, 0.15424362f, -0.00175634f, 0.16355342f, 0.06433610f, 
    0.05882696f, -0.00456662f, -0.08977209f, -0.02053104f, 0.03036434f, 0.06069146f, -0.12013708f, 0.00890150f, 
    0.13296053f, 0.09127436f, 0.07288176f, 0.00964691f, 0.10590424f, 0.01648582f, 0.01589721f, 0.03609308f, 
    -0.11696529f, -0.07673975f, -0.13305077f, -0.13628252f, -0.09185303f, 0.05209295f, 0.26367325f, -0.08063229f, 
    -0.03079321f, 0.18650344f, -0.02962769f, 0.15156260f, 0.05841001f, -0.09452982f, -0.03138817f, -0.03793668f, 
    -0.17272305f, -0.08883586f, 0.04975078f, -0.02468358f, -0.07149351f, -0.01385747f, -0.02251435f, -0.00047245f, 
    0.11421781f, -0.02487076f, -0.12073851f, -0.02746547f, 0.27277422f, 0.13320926f, -0.05828000f, 0.15441923f, 
    0.01866930f, 0.09998543f, 0.02909579f, 0.01875730f, 0.02933058f, 0.03786544f, -0.07926166f, -0.10399029f, 
    0.17231575f, 0.23856863f, -0.16084708f, 0.05258534f, 0.04759616f, 0.11670526f, 0.02402730f, 0.05427762f, 
    0.13740301f, -0.05728906f, -0.10930786f, 0.13237320f, -0.11963897f, -0.15898766f, -0.04584093f, -0.30199218f, 
    -0.03681869f, -0.11812384f, -0.12429591f, 0.14699917f, -0.01895753f, -0.17442508f, -0.03398178f, -0.13127151f, 
    0.18617000f, -0.08921964f, 0.10073424f, 0.19585216f, -0.00757284f, -0.00449536f, -0.10669361f, -0.03098763f, 
    0.06456514f, 0.10071033f, 0.08670007f, 0.06519670f, -0.04001830f, 0.07194061f, -0.09478261f, 0.23755857f, 
    -0.10045402f, -0.03642091f, -0.07548781f, 0.04321190f, 0.04616765f, 0.05356971f, 0.00586558f, 0.02885766f, 
    0.23538029f, -0.07151160f, 0.26688889f, -0.10374074f, 0.02861730f, 0.02251368f, -0.00403203f, 0.07306875f, 
    0.01779286f, -0.10467813f, 0.09416863f, -0.09594819f, 0.15457296f, -0.03298327f, -0.15910275f, -0.09335471f, 
    0.10035780f, -0.11995398f, -0.08800128f, -0.03584921f, 0.09529124f, 0.09714671f, -0.13134257f, -0.03098541f, 
    -0.14268146f, -0.09514599f, 0.18427922f, 0.24918112f, 0.00464296f, -0.05232709f, 0.13346204f, -0.04060854f, 
    -0.01777002f, -0.10204038f, -0.18900593f, -0.08484799f, 0.14004117f, 0.35017806f, 0.13026604f, 0.03111847f, 
    0.22654818f, 0.07295375f, 0.13153817f, 0.03889117f, -0.00411572f, 0.09992986f, 0.04952350f, -0.10158389f, 
    0.29323849f, -0.02185657f, 0.05882826f, -0.11220209f, 0.02223494f, -0.00198718f, 0.02432180f, 0.02284808f, 
    0.07547025f, -0.28217110f, -0.14621156f, 0.01660351f, 0.02839118f, -0.14697143f, -0.02429304f, -0.21519566f, 
    0.04808891f, -0.08092284f, -0.03604138f, 0.04804312f, 0.08690273f, -0.04507914f, 0.09919325f, 0.10500806f, 
    -0.15623967f, 0.12436449f, -0.16547771f, 0.04856500f, -0.04781419f, -0.09392080f, 0.09988349f, -0.14325711f, 
    0.01821215f, 0.01296916f, 0.08233305f, -0.03699620f, -0.13331667f, -0.12902617f, 0.25558817f, 0.20980740f, 
    -0.09128195f, 0.15054448f, 0.03699221f, -0.16522759f, -0.27679589f, 0.03155519f, -0.15930960f, -0.02715771f, 
    0.00041008f, -0.02711835f, 0.09304488f, 0.05631337f, 0.01804362f, -0.03437632f, -0.30272296f, -0.04465900f, 
    -0.04816547f, 0.05232148f, 0.00969034f, -0.01600524f, -0.00045659f, 0.23992062f, 0.38663992f, 0.24084836f, 
    0.24781094f, 0.02851361f, 0.04452831f, -0.09405676f, -0.10892051f, -0.05113641f, 0.11953980f, 0.01227750f, 
    0.21606056f, 0.15847178f, -0.21754715f, 0.15232545f, -0.14565760f, 0.12886837f, 0.06568570f, 0.02347568f, 
    0.09533002f, 0.08899811f, 0.13418651f, -0.07336437f, 0.01545232f, 0.21105315f, -0.22149095f, -0.14532799f, 
    0.00969690f, 0.06268170f, -0.00031712f, -0.07818450f, -0.12243395f, 0.01215043f, 0.21664363f, -0.11827083f, 
    0.40678427f, 0.05132603f, 0.01346663f, 0.17183401f, 0.06127297f, 0.00573810f, -0.07791512f, 0.06184145f, 
    0.14350899f, -0.03565399f, 0.04865035f, -0.09998476f, -0.01511176f, 0.06678107f, 0.10185558f, 0.10893928f, 
    -0.04017700f, -0.04812709f, 0.01989102f, -0.02081233f, 0.08816990f, 0.04096304f, -0.04315267f, 0.01189676f, 
    -0.24813919f, 0.11563682f, 0.20173003f, 0.09995713f, 0.17783721f, 0.00340880f, 0.08325294f, 0.16169479f, 
    -0.08270348f, -0.06631372f, 0.10838582f, 0.04245128f, 0.08170315f, -0.17188784f, -0.19913022f, 0.11433617f, 
    -0.09962991f, 0.11651449f, -0.03543881f, 0.12624332f, 0.08447961f, -0.05918517f, 0.05750702f, 0.12783073f, 
    -0.08088107f, 0.07162331f, 0.29741669f, 0.06783421f, 0.12933411f, 0.01367057f, 0.03058415f, 0.17771147f, 
    -0.02267965f, -0.04433464f, 0.09102933f, 0.03618369f, 0.29069057f, 0.02935199f, -0.38199878f, -0.04323259f, 
    0.06286693f, -0.13280442f, 0.05745950f, -0.01489245f, 0.06675897f, 0.04722588f, 0.01632333f, -0.15296662f, 
    0.17082587f, -0.02975556f, 0.10926972f, 0.11174018f, 0.00601451f, 0.03828949f, -0.06922877f, 0.04504961f, 
    -0.10987367f, -0.11270881f, -0.01756947f, -0.09550004f, -0.12748449f, 0.03316345f, -0.01944481f, -0.03925480f, 
    -0.09949984f, -0.10963903f, -0.00043386f, -0.05385723f, -0.04384012f, -0.30082595f, -0.03254866f, 0.08933957f, 
    -0.30654812f, -0.07833010f, -0.07961062f, -0.14693120f, 0.12638615f, -0.02896840f, 0.09567514f, 0.12513085f, 
    -0.00665452f, -0.03373940f, -0.00605673f, 0.14649865f, 0.17277530f, -0.00635239f, 0.02289022f, 0.05363572f, 
    -0.05894202f, 0.12893625f, -0.01048674f, -0.03032668f, 0.09372246f, -0.08940230f, 0.03942607f, 0.06601302f, 
    0.02255715f, 0.00809773f, 0.28093717f, 0.07815472f, 0.07382962f, 0.03857100f, -0.04110043f, 0.06900612f, 
    -0.02466801f, -0.00926683f, -0.19982357f, 0.01771020f, -0.38477960f, -0.11275569f, 0.33089104f, 0.00333413f, 
    -0.15173832f, 0.00429240f, -0.08076906f, -0.00966161f, -0.10297748f, -0.05740516f, -0.08688353f, 0.18100341f, 
    0.05657925f, -0.00294668f, 0.14453280f, 0.07557407f, 0.08912976f, -0.01769133f, 0.02394420f, -0.03749525f, 
    -0.07552397f, -0.07110105f, -0.03172648f, 0.08048028f, 0.08547973f, 0.08980073f, 0.12968796f, 0.04078159f, 
    -0.11286141f, 0.08347341f, 0.07817904f, -0.02137606f, 0.04942710f, -0.14944239f, -0.03253528f, 0.00278942f, 
    0.06009959f, -0.14226085f, 0.01556477f, -0.15175417f, -0.02845358f, -0.20563497f, -0.00442522f, 0.11186956f, 
    -0.08766357f, -0.13569506f, -0.02301918f, -0.16518641f, 0.00129871f, -0.00488218f, 0.10281695f, 0.12012182f, 
    0.04313200f, 0.10322200f, 0.05995189f, -0.01692027f, -0.02293487f, 0.00195827f, -0.15628873f, -0.00646943f, 
    -0.03156525f, 0.08155946f, -0.10830636f, -0.13280958f, 0.02397136f, 0.04602659f, 0.00672599f, -0.03680947f, 
    -0.00237410f, -0.01640956f, 0.06556029f, -0.06603194f, 0.08133513f, 0.24353194f, 0.03215624f, 0.08494478f, 
    0.10708135f, 0.06615001f, 0.03224830f, 0.10142750f, 0.00805770f, -0.04474014f, -0.03323817f, 0.00752638f, 
    0.02495146f, -0.01103162f, -0.04479398f, -0.03280577f, 0.01745442f, -0.02830149f, -0.01373813f, 0.02991811f, 
    -0.00145202f, -0.00939071f, -0.00292573f, 0.00621218f, -0.02475645f, 0.01034571f, 0.02592138f, -0.03298236f, 
    0.00485134f, -0.03111460f, -0.00898453f, 0.02456847f, -0.00546744f, -0.00871048f, -0.03317593f, -0.01139900f, 
    -0.02352115f, -0.00692136f, -0.00240314f, 0.02647825f, 0.02540174f, 0.00262191f, -0.03288021f, -0.01689272f, 
    -0.00623054f, 0.03112819f, -0.00382906f, 0.03440499f, -0.02304460f, 0.01735367f, -0.01176888f, -0.02592549f, 
    -0.00619966f, 0.00194638f, -0.02305813f, 0.01319246f, 0.00262139f, -0.02122744f, 0.02638518f, 0.01360699f, 
    -0.01433279f, 0.02555509f, -0.01203419f, -0.02153228f, -0.03070173f, -0.03966035f, -0.01423314f, 0.00314450f, 
    -0.02742354f, -0.03277471f, 0.01700396f, -0.02164334f, -0.04083857f, 0.02539285f, -0.00203541f, -0.01436570f, 
    -0.03797226f, 0.02737538f, 0.02626401f, -0.01635570f, -0.02048653f, 0.00477104f, -0.02584916f, 0.02246161f, 
    -0.02364201f, -0.00929654f, -0.01328320f, -0.00473733f, 0.03300368f, -0.01439983f, -0.01083051f, -0.02451407f, 
    -0.03098587f, -0.00213489f, 0.02551183f, -0.01648097f, 0.00060550f, -0.03992471f, -0.02262654f, 0.02276136f, 
    0.00524314f, -0.01575814f, -0.04121152f, -0.02098102f, 0.01605827f, 0.01071714f, 0.02627077f, -0.01521827f, 
    -0.00997726f, -0.03195203f, 0.00151763f, 0.02521365f, -0.00261034f, 0.02379734f, 0.01375097f, 0.02552900f, 
    -0.00203461f, -0.04541352f, -0.03351540f, -0.00408653f, -0.00466600f, -0.01655688f, -0.01690055f, -0.00003073f, 
    0.01640309f, -0.01992197f, 0.02278293f, -0.00832715f, -0.01476868f, 0.02075501f, 0.00790862f, -0.03587609f, 
    0.02405933f, 0.00278277f, 0.00537941f, -0.01819713f, 0.01068953f, 0.02402331f, -0.03181284f, -0.01153284f, 
    -0.00145596f, -0.02294682f, -0.01556725f, -0.01326951f, -0.03981559f, -0.04226235f, -0.04347882f, 0.01239794f, 
    -0.02074253f, -0.00208354f, 0.01629728f, 0.01719657f, -0.03601824f, -0.03680629f, -0.01182632f, 0.02651915f, 
    0.01166510f, 0.01394770f, -0.03029647f, -0.01089638f, -0.01423815f, 0.01689193f, 0.00664571f, 0.01013395f, 
    -0.01826013f, -0.00621664f, 0.03183881f, 0.01509558f, -0.01055353f, -0.00509027f, 0.00431798f, 0.02338368f, 
    -0.01687658f, 0.01381870f, 0.02360043f, 0.03559306f, -0.03125935f, 0.02590029f, -0.00714862f, -0.02212790f, 
    0.01552099f, -0.02749470f, -0.02332812f, 0.01034495f, -0.01390356f, -0.01389883f, 0.01890898f, -0.02291394f, 
    0.01155738f, 0.00215417f, -0.01482126f, -0.02993684f, -0.02716521f, 0.00965379f, -0.03416736f, -0.01998001f, 
    -0.00093860f, 0.01437883f, -0.01569774f, -0.03995625f, 0.00954657f, 0.01228662f, -0.02836945f, -0.02393848f, 
    -0.00813784f, -0.03886175f, -0.04144695f, -0.03756414f, -0.00597813f, 0.02324010f, 0.03130925f, 0.01216508f, 
    0.01070698f, -0.01786674f, -0.01815841f, -0.00865396f, 0.00974343f, 0.00719342f, -0.02410303f, 0.01691255f, 
    -0.03484831f, 0.02306231f, -0.03234083f, 0.02225303f, -0.02614396f, 0.02065473f, 0.03026533f, -0.04234255f, 
    -0.02168282f, -0.02205791f, -0.02502179f, 0.00667329f, -0.00764432f, -0.00487111f, 0.01152274f, 0.03294734f, 
    -0.02545494f, -0.02286042f, -0.02322261f, -0.03556341f, -0.01661318f, -0.01244332f, -0.02824990f, 0.01104143f, 
    -0.03878253f, 0.00213202f, 0.00209756f, 0.00381899f, -0.00255997f, 0.02509436f, 0.02416955f, -0.03193270f, 
    -0.01657395f, 0.02286697f, 0.02439054f, -0.00385163f, -0.02410503f, 0.00249348f, -0.02858462f, -0.00107278f, 
    0.02394174f, 0.00291463f, 0.03005039f, -0.00726603f, -0.04204728f, 0.01394218f, -0.03206506f, 0.03486087f, 
    -0.03624056f, -0.02038580f, -0.03156300f, -0.03325618f, -0.03889452f, -0.01005703f, -0.00483867f, 0.02496176f, 
    -0.00452399f, 0.00423462f, -0.02135227f, 0.00268565f, 0.01928913f, 0.02651262f, -0.02223685f, -0.02254706f, 
    -0.00178533f, -0.01157459f, -0.02754164f, -0.02271186f, 0.01565877f, 0.02299067f, 0.01405044f, 0.01411470f, 
    0.01360960f, -0.02198334f, -0.02654849f, 0.01796635f, -0.00566222f, -0.00712125f, -0.03929795f, -0.01901426f, 
    -0.04062141f, -0.03307542f, -0.01833434f, 0.02604732f, -0.03696151f, -0.01289808f, 0.01738828f, 0.02753169f, 
    -0.02080543f, -0.03352711f, -0.00213547f, -0.01341930f, 0.00503431f, 0.01373080f, -0.03491387f, -0.02653853f, 
    -0.02510869f, 0.00553537f, -0.02995573f, -0.02309263f, 0.01648774f, -0.01500428f, 0.02607294f, -0.01005343f, 
    -0.00115966f, -0.00733877f, -0.03936467f, -0.01212700f, -0.02470780f, -0.02291228f, -0.00273378f, -0.03665632f, 
    0.01718975f, -0.00999469f, 0.02604152f, -0.00558878f, 0.00716758f, -0.00051700f, -0.01440017f, 0.02672780f, 
    0.00745988f, -0.03611277f, -0.03423353f, 0.01477320f, 0.02956398f, 0.02467751f, 0.02137649f, -0.00436942f, 
    -0.00590302f, -0.04344008f, -0.03630092f, -0.03750568f, -0.04148090f, 0.02217360f, -0.00438050f, -0.01501514f, 
    -0.00144357f, 0.02224425f, 0.02691597f, -0.02471886f, 0.01416731f, 0.00149337f, -0.02776171f, -0.00222134f, 
    -0.01747634f, 0.02571110f, -0.02645637f, -0.00903732f, 0.01609400f, 0.00590378f, 0.00002826f, -0.00813643f, 
    -0.00858449f, -0.03492028f, -0.01665077f, -0.03264746f, -0.02598905f, -0.00114755f, 0.00829530f, -0.03255107f, 
    -0.03503132f, 0.03351648f, -0.03249757f, 0.02517336f, 0.01195297f, 0.04169755f, -0.02484386f, 0.01999126f, 
    -0.00927590f, -0.01369532f, -0.03493300f, -0.01949727f, -0.01421082f, -0.00104860f, -0.01448135f, -0.02374735f, 
    0.00708568f, 0.00006675f, -0.01352618f, 0.00421323f, -0.03866204f, -0.01883215f, 0.01078492f, 0.02246376f, 
    -0.00063044f, 0.00065819f, -0.04086518f, 0.00417098f, 0.01209780f, 0.03024609f, 0.02640657f, 0.00956233f, 
    -0.01857753f, -0.04037870f, 0.01860941f, -0.00641106f, -0.00586703f, -0.03808488f, -0.02056345f, 0.02363284f, 
    0.00369244f, -0.01458748f, -0.00278194f, -0.02798301f, 0.01431710f, -0.00883263f, -0.03107710f, 0.01292256f, 
    -0.02310058f, -0.01660116f, -0.01927170f, -0.00712412f, -0.01667252f, 0.00911399f, 0.03893013f, -0.00545871f, 
    -0.01584723f, 0.00382135f, 0.01009820f, 0.01091083f, -0.01099440f, -0.02142954f, -0.00677367f, -0.02799705f, 
    -0.04521790f, -0.00700535f, -0.00478165f, -0.01065782f, 0.02637268f, -0.01432759f, -0.01369897f, -0.00932781f, 
    0.01860809f, -0.02503302f, -0.00915934f, 0.02128569f, 0.03479937f, -0.03413128f, 0.01492379f, -0.01754533f, 
    0.02461145f, 0.00138930f, -0.02131588f, -0.02401944f, -0.02011217f, 0.01629523f, -0.02120054f, 0.02307663f, 
    -0.04167084f, -0.02233598f, 0.01352087f, -0.01163720f, 0.02016043f, 0.02722480f, -0.02504962f, -0.00050838f, 
    -0.00626190f, -0.00518746f, -0.03955706f, -0.01807590f, -0.01996740f, -0.02274595f, -0.03663446f, 0.01817789f, 
    0.00815043f, 0.00352168f, -0.00769563f, 0.02936099f, 0.00441191f, -0.04442162f, 0.03230948f, -0.03805844f, 
    -0.01818545f, 0.00357446f, 0.02515577f, 0.01156294f, 0.00306540f, 0.02617146f, -0.02329708f, -0.01784884f, 
    -0.02771063f, 0.02099610f, -0.03633221f, 0.01374337f, -0.03053124f, -0.00802707f, 0.02345017f, 0.01445482f, 
    -0.01494315f, 0.00111492f, -0.02511006f, -0.03738824f, -0.02902806f, -0.01753480f, -0.00140588f, -0.00801896f, 
    0.02358086f, 0.00038440f, -0.00880760f, 0.00268467f, 0.01068087f, -0.01741222f, -0.01273660f, -0.02436212f, 
    0.01053826f, -0.01334753f, -0.02523363f, -0.02145422f, 0.03240302f, -0.03187031f, -0.00938127f, 0.00884393f, 
    -0.01569222f, 0.00895204f, 0.00295883f, 0.00755076f, -0.00551617f, -0.02206179f, 0.01018731f, -0.03515329f, 
    -0.00987682f, -0.03365086f, -0.03961816f, -0.03880512f, 0.01411800f, 0.01129348f, -0.01394395f, -0.00909795f, 
    0.00330142f, 0.01204933f, -0.02431713f, -0.02734521f, -0.00099850f, 0.02308827f, -0.01902616f, 0.02197702f, 
    0.02619203f, 0.02247831f, 0.02595296f, 0.01912849f, -0.00702136f, 0.02529047f, -0.03416762f, 0.02303927f, 
    -0.04479003f, -0.01580312f, -0.01454187f, -0.04329929f, -0.00362078f, -0.01864532f, -0.01876051f, 0.02380845f, 
    -0.03476155f, -0.02343770f, 0.02920901f, -0.03916984f, -0.01445506f, -0.00454530f, -0.00662266f, -0.00698604f, 
    0.00175433f, 0.02128919f, 0.03020946f, -0.03716383f, -0.01241336f, 0.02837326f, -0.02387472f, 0.01476440f, 
    0.01189095f, -0.01330931f, 0.02876388f, 0.02420478f, 0.02364099f, -0.00336485f, -0.01658393f, -0.00281911f, 
    0.01528092f, -0.00926114f, 0.02408927f, 0.00222861f, -0.02016693f, -0.00183001f, 0.00220000f, 0.01831315f, 
    -0.00925240f, -0.00237289f, -0.01221361f, -0.03045337f, 0.02238142f, 0.03147351f, 0.00140115f, 0.02391290f, 
    0.00944810f, 0.01210575f, -0.03054705f, -0.00498156f, 0.01467666f, 0.01893097f, 0.00896015f, -0.02886502f, 
    0.02265173f, -0.03517710f, -0.00230542f, -0.02119886f, -0.03434458f, -0.02623313f, 0.02037870f, -0.02244311f, 
    0.00547918f, 0.03039328f, -0.00495327f, -0.00257548f, 0.02797220f, -0.00032410f, 0.01128466f, -0.04111945f, 
    0.00303788f, -0.00190491f, 0.01146287f, -0.00980587f, 0.02456347f, 0.00240250f, 0.02930713f, 0.02204001f, 
    0.02270787f, -0.03426704f, -0.04522128f, -0.00219121f, -0.04042850f, -0.01356492f, 0.00911089f, -0.01074445f, 
    -0.02868369f, 0.02327237f, -0.02374545f, -0.02275405f, 0.00102113f, -0.02240608f, -0.02618129f, 0.01405041f, 
    -0.02741041f, 0.00752074f, -0.01602171f, 0.02040042f, -0.03119056f, 0.00486190f, 0.01196410f, -0.00309220f, 
    -0.02215433f, 0.02915803f, -0.00158072f, -0.02945054f, -0.01385097f, -0.00752804f, -0.02031665f, 0.01925683f, 
    -0.01319770f, -0.03038791f, 0.02019170f, 0.02727744f, -0.01632609f, 0.01350509f, -0.00308147f, 0.01899431f, 
    -0.01854506f, 0.01861740f, -0.03257324f, 0.02269620f, -0.04144445f, -0.02993913f, 0.01067384f, 0.02901290f, 
    -0.02656516f, -0.01818914f, 0.02245210f, -0.02611613f, 0.01088644f, 0.02005262f, -0.02695914f, 0.00206207f, 
    -0.04151951f, 0.01163683f, 0.01246799f, 0.00147600f, 0.01991304f, -0.00145232f, -0.01881899f, -0.00525887f, 
    -0.02715302f, 0.02760240f, -0.01614830f, -0.02705958f, 0.01202969f, 0.02173559f, -0.01910417f, -0.02114107f, 
    0.00406732f, -0.00657491f, -0.00031289f, 0.00859500f, -0.04213270f, -0.01084645f, -0.03873832f, 0.00123071f, 
    0.01172993f, -0.02096055f, 0.02241866f, -0.02688451f, -0.00996005f, -0.01397452f, 0.02519778f, 0.00005430f, 
    -0.01040608f, 0.02366832f, -0.01032978f, 0.02521625f, -0.00100397f, -0.00526148f, 0.00638736f, 0.00822258f, 
    0.03623054f, 0.02410776f, -0.01224750f, -0.04138131f, -0.00097834f, 0.00976082f, -0.02561481f, -0.00053453f, 
    0.02836420f, -0.00106529f, 0.02144367f, -0.01899526f, 0.01019255f, -0.03518552f, 0.00908161f, 0.02168687f, 
    0.02789286f, -0.03540381f, -0.01531499f, 0.02458943f, -0.01885261f, 0.00106364f, -0.03060039f, 0.02877220f, 
    0.01635341f, -0.00290955f, -0.01946721f, -0.00501381f, 0.02593456f, -0.03168281f, 0.02954915f, -0.02014345f, 
    -0.01829856f, 0.00284848f, -0.02227630f, 0.02727939f, 0.02197814f, -0.00216455f, 0.00597910f, -0.03794598f, 
    0.08731030f, -0.11203516f, -0.08456866f, 0.04328012f, -0.01268353f, 0.11502706f, -0.09000836f, 0.12094361f, 
    0.13855085f, 0.02566356f, -0.08821473f, -0.10438801f, -0.01478491f, 0.07000207f, -0.04769260f, -0.22008039f, 
    0.02342565f, 0.15552182f, -0.08991993f, 0.14728624f, 0.10541559f, -0.07514587f, -0.04500449f, -0.01554425f, 
    -0.00975038f, 0.02246893f, 0.06232126f, 0.05386230f, 0.01626416f, 0.10877538f, -0.01521333f, 0.01491456f, 
    0.02876643f, -0.04226927f, -0.11746421f, 0.10859901f, -0.32084763f, -0.05500574f, -0.00379479f, 0.05390386f, 
    -0.02817826f, -0.01276983f, 0.05646025f, -0.02660026f, -0.02920970f, 0.05872550f, -0.00114613f, 0.13614076f, 
    0.00657912f, -0.04132481f, 0.05447792f, 0.04684688f, 0.07383238f, 0.05880341f, 0.01402564f, 0.04196633f, 
    0.03679656f, 0.00585737f, 0.03722988f, -0.01033156f, 0.10978542f, 0.25023353f, 0.00834546f, 0.23397864f, 
    -0.05677607f, -0.14009717f, 0.03780832f, 0.20335981f, -0.06194932f, 0.12976249f, -0.06661303f, -0.00713301f, 
    0.11339611f, 0.15855525f, 0.31044269f, 0.28948653f, 0.06084969f, -0.00266279f, 0.04328971f, 0.01052428f, 
    -0.07151530f, -0.03898529f, -0.05576662f, -0.14250056f, 0.04934618f, 0.24017425f, -0.00966487f, 0.13884339f, 
    0.05089346f, 0.07502511f, -0.04443475f, 0.12155146f, 0.00780772f, 0.01097955f, -0.05426912f, -0.11776640f, 
    -0.09819184f, 0.21050669f, 0.09097484f, 0.19604197f, 0.04166385f, 0.08324581f, -0.04103851f, 0.08956827f, 
    0.00632005f, 0.03682780f, 0.06299834f, 0.11160477f, 0.12353578f, 0.07879301f, 0.12382439f, 0.08757800f, 
    0.07838285f, 0.04521571f, 0.05844320f, -0.04489895f, 0.07053063f, 0.05921136f, 0.14053959f, 0.00634628f, 
    -0.02767139f, 0.02821386f, 0.41417980f, 0.24731122f, 0.06449592f, 0.08449985f, 0.04780539f, 0.08444061f, 
    0.03654310f, 0.01710145f, -0.07982987f, 0.00021403f, -0.01712404f, 0.13852669f, 0.07019060f, 0.00223002f, 
    0.09196174f, 0.07057633f, -0.06581567f, 0.01075539f, 0.01905673f, 0.01912483f, -0.07794406f, 0.05368379f, 
    0.22422647f, 0.07454770f, 0.03724355f, 0.02021817f, 0.04771292f, 0.01661156f, -0.00728907f, -0.04394672f, 
    -0.07384499f, -0.00158480f, -0.20066328f, 0.03552090f, 0.13436219f, 0.23297109f, 0.21191823f, 0.17122938f, 
    0.07110396f, -0.14844894f, -0.04122489f, 0.02894967f, 0.05893046f, 0.08087810f, 0.06469294f, -0.00694649f, 
    -0.23283614f, -0.16532941f, -0.00950012f, -0.07527950f, -0.02328377f, 0.03970664f, -0.00239016f, 0.03699184f, 
    0.05577350f, 0.02635329f, 0.07640260f, 0.12089088f, -0.14018108f, -0.21209398f, -0.24082391f, -0.01150643f, 
    -0.04951603f, 0.01272884f, -0.05298944f, 0.04842520f, 0.00871902f, 0.11816450f, 0.12261658f, 0.01115495f, 
    -0.17529045f, -0.13415718f, -0.13251495f, -0.00838656f, 0.01013020f, 0.02261787f, 0.00458717f, -0.04636390f, 
    0.05719172f, 0.01242872f, -0.04757093f, 0.08848096f, -0.07345136f, -0.24048585f, -0.24525392f, -0.12720706f, 
    -0.07619104f, 0.00867902f, -0.02035895f, -0.01298675f, -0.04798043f, 0.02242826f, 0.04823649f, 0.04116840f, 
    0.12247440f, 0.06223959f, 0.11469670f, 0.14433946f, 0.15160994f, 0.02905999f, -0.10172118f, 0.05679993f, 
    0.00283965f, 0.13423622f, 0.02820508f, 0.10962489f, 0.18234548f, 0.24996310f, 0.17684153f, 0.12904158f, 
    -0.00154161f, 0.13035314f, 0.03230378f, 0.16239432f, -0.02217726f, -0.03173443f, -0.07041721f, 0.03030678f, 
    0.09197500f, -0.00251991f, -0.09391835f, 0.10539354f, 0.05302656f, 0.03542784f, -0.06782188f, 0.04775376f, 
    0.09844689f, 0.06672151f, 0.02106218f, 0.12068978f, 0.12740739f, 0.21020858f, -0.12648112f, 0.15980408f, 
    0.14914666f, 0.15599708f, 0.10159634f, 0.12762639f, 0.02147806f, 0.05193307f, -0.11368229f, -0.04627800f, 
    0.37216106f, 0.23380806f, 0.09358562f, 0.03474396f, 0.12678544f, 0.01682371f, 0.09521862f, 0.09088156f, 
    -0.02962123f, -0.04447524f, -0.10156862f, 0.04272364f, -0.27314335f, -0.20772836f, 0.19593041f, 0.35043710f, 
    0.01545170f, -0.03246278f, 0.06511512f, -0.01147799f, 0.04007168f, -0.01043900f, -0.04755814f, 0.06043849f, 
    -0.05051176f, 0.04967537f, -0.00315718f, 0.08988819f, 0.03319851f, 0.06980500f, 0.11397286f, 0.02501028f, 
    -0.01382476f, -0.04464667f, -0.03213291f, -0.04068807f, -0.13692173f, -0.19738901f, -0.00834278f, 0.00879829f, 
    0.00726759f, 0.08229266f, -0.08534715f, 0.08191260f, 0.01964233f, 0.06508315f, 0.06302091f, 0.00139456f, 
    -0.06478976f, -0.18987931f, -0.02340236f, -0.05985989f, -0.02370149f, -0.03119273f, 0.01726503f, 0.00560940f, 
    -0.09229424f, -0.01704996f, 0.00336254f, 0.01887722f, 0.26023385f, -0.35926545f, 0.25282890f, -0.30381137f, 
    0.00198469f, 0.00520519f, -0.09802165f, 0.07015200f, 0.15231898f, 0.03256630f, -0.02886837f, -0.06881282f, 
    0.18105046f, 0.11494981f, -0.13216014f, 0.13360499f, -0.03816484f, -0.07147692f, 0.11943396f, 0.17660819f, 
    -0.06123050f, -0.00088985f, -0.03528934f, -0.07937457f, 0.10538308f, -0.18100616f, -0.05914962f, 0.08163071f, 
    -0.07251538f, 0.04719564f, -0.00673764f, 0.08806507f, 0.00707253f, -0.05365989f, 0.03031444f, -0.06076878f, 
    -0.09706689f, -0.02918079f, -0.06996551f, -0.17209624f, -0.03589168f, -0.05347634f, -0.03305887f, -0.05387392f, 
    -0.05410108f, 0.06666748f, -0.06015612f, 0.20848219f, 0.02192120f, 0.37642112f, 0.19593690f, -0.04228787f, 
    0.05601919f, 0.07890254f, -0.06629485f, -0.01644900f, 0.09830862f, 0.13856624f, 0.00949815f, 0.04290372f, 
    -0.16920668f, -0.01702532f, -0.10522281f, -0.10201541f, 0.04073484f, -0.05771909f, -0.06584584f, 0.02570793f, 
    0.01421443f, 0.01194126f, -0.19124791f, 0.07453374f, -0.03061181f, 0.07210563f, -0.09575906f, -0.02160558f, 
    0.10539893f, 0.00827282f, 0.06455991f, 0.11127913f, 0.01218298f, 0.01203403f, -0.00725097f, -0.01933001f, 
    -0.03158763f, -0.08736151f, -0.05506498f, 0.02189770f, -0.02245999f, 0.03998427f, 0.02439977f, 0.08582834f, 
    0.07162584f, -0.01186451f, 0.06802852f, -0.00382742f, 0.38825732f, 0.08828166f, 0.31887311f, 0.17035775f, 
    0.07955428f, 0.08841573f, -0.08574186f, -0.01947297f, -0.11035955f, -0.03880611f, 0.00146851f, -0.07195213f, 
    -0.31008443f, 0.10798732f, -0.04995007f, 0.05016362f, 0.13772267f, 0.17986512f, 0.13105038f, -0.06347001f, 
    0.08744851f, -0.06579233f, -0.05144719f, 0.01764848f, 0.10858196f, -0.13710749f, -0.01223646f, 0.08163551f, 
    -0.04178279f, -0.06807251f, 0.13544442f, 0.09458349f, 0.03242477f, 0.01232087f, 0.05023263f, -0.10061195f, 
    0.04299399f, -0.22015773f, -0.06199786f, -0.16188255f, -0.06370106f, 0.04587896f, -0.13057828f, 0.07409456f, 
    -0.11862274f, -0.07082043f, 0.11867724f, 0.28847668f, -0.26791376f, 0.33741987f, 0.16177119f, 0.16960694f, 
    -0.00951059f, -0.01235994f, 0.06193574f, 0.09223519f, 0.05936516f, -0.05313850f, 0.01061113f, 0.15002021f, 
    0.04324490f, 0.16835822f, -0.01534473f, 0.08410675f, 0.02309275f, -0.03526722f, 0.07386571f, -0.01282550f, 
    -0.03064578f, -0.06380144f, -0.02119325f, 0.12661630f, -0.20464933f, 0.20960036f, 0.04527793f, -0.16359843f, 
    0.08823553f, 0.08897099f, 0.01141613f, 0.03961049f, 0.02688516f, 0.03964946f, -0.03391399f, -0.01628736f, 
    0.14961621f, 0.01646985f, 0.26174501f, 0.03163540f, 0.13891049f, 0.13213907f, -0.06034962f, 0.07723237f, 
    0.04057844f, 0.11972571f, 0.11783569f, 0.03129698f, -0.16358833f, -0.02468203f, 0.07577733f, 0.16132073f, 
    0.01545544f, 0.07163145f, -0.00986124f, -0.01411987f, 0.03608295f, 0.01207321f, -0.07347275f, 0.11392222f, 
    0.02597867f, 0.00014962f, -0.14680959f, -0.00946746f, -0.00530935f, 0.09593910f, 0.05098478f, 0.04762816f, 
    0.01237496f, 0.02448761f, -0.01731203f, -0.03186005f, 0.42669436f, -0.22062969f, 0.13391456f, 0.02593887f, 
    0.07594863f, 0.05335632f, 0.01293550f, 0.03432641f, 0.13985758f, 0.07815631f, 0.06667102f, -0.07731569f, 
    -0.14500763f, -0.17367870f, 0.03878276f, -0.16469119f, -0.06357493f, 0.08276449f, -0.05905069f, 0.09407534f, 
    -0.01275693f, 0.02151874f, 0.05453744f, 0.02258301f, -0.12132753f, -0.20198900f, 0.04003768f, -0.10882184f, 
    -0.10337027f, -0.02747287f, 0.02723636f, 0.00636103f, 0.08347845f, -0.04536072f, 0.01094853f, 0.12338958f, 
    0.03570521f, -0.02056768f, 0.16839333f, 0.13261986f, 0.04675340f, 0.16827442f, 0.05208167f, 0.13712229f, 
    -0.02613817f, -0.04833521f, -0.03989678f, -0.05434516f, 0.12536505f, 0.12735307f, -0.05250634f, 0.05747278f, 
    -0.01527089f, 0.06018162f, 0.00318585f, 0.01725326f, -0.02326621f, -0.06468798f, -0.02841857f, -0.15429129f, 
    -0.00133175f, -0.00332882f, 0.09606526f, 0.07354715f, 0.20969611f, -0.03086052f, -0.04221832f, 0.14758690f, 
    -0.00241315f, -0.00364936f, -0.04514817f, -0.01887303f, 0.07833706f, 0.42192167f, 0.29770121f, 0.22218977f, 
    0.02250525f, -0.03330290f, 0.16456148f, 0.04495275f, -0.02245967f, -0.16116895f, 0.02617518f, -0.07311945f, 
    -0.04582439f, -0.10914738f, -0.05904457f, 0.05668181f, -0.05809920f, 0.05861062f, -0.04700604f, -0.00126140f, 
    0.13587596f, 0.03256704f, -0.01213414f, 0.07024600f, 0.10162757f, 0.21428911f, 0.07714229f, 0.08784281f, 
    0.11741056f, -0.04440206f, -0.06082809f, -0.00743419f, 0.20877603f, 0.09276576f, -0.04122039f, 0.13635583f, 
    0.09245422f, 0.33031666f, 0.31770298f, -0.05453012f, -0.09856720f, 0.15398581f, -0.08612674f, -0.02554133f, 
    0.05360332f, 0.03672625f, -0.11758653f, -0.09577058f, -0.02951307f, -0.07345245f, -0.05533001f, 0.09129087f, 
    0.00280205f, 0.15777887f, -0.01537538f, 0.00044426f, -0.00649489f, -0.05827099f, 0.02664387f, -0.15100694f, 
    -0.12802126f, 0.06783231f, -0.10712273f, 0.09969997f, -0.02941913f, 0.01722530f, -0.06910811f, 0.14683801f, 
    0.01327003f, 0.07161495f, -0.07426114f, 0.08480955f, -0.22311831f, 0.09284742f, 0.07548061f, 0.07685097f, 
    -0.08818164f, 0.00860831f, -0.06494260f, 0.04950823f, 0.00014983f, -0.01552827f, -0.09532788f, -0.06757509f, 
    -0.15459907f, -0.07647483f, 0.08013956f, 0.04017141f, -0.01708625f, 0.05176846f, 0.02496949f, 0.02544210f, 
    -0.08695121f, 0.01728537f, 0.05943289f, 0.13043135f, -0.05121996f, -0.01809208f, -0.01662178f, 0.02061363f, 
    -0.03977045f, 0.06447905f, 0.07071970f, 0.00800140f, 0.00762830f, -0.03206193f, 0.05114025f, 0.03196634f, 
    0.15990114f, 0.21465670f, 0.21143715f, 0.06904174f, 0.03299752f, -0.01244755f, -0.06273390f, 0.02614643f, 
    -0.03279883f, 0.00486008f, 0.01977399f, 0.21149386f, -0.05765951f, -0.13716404f, -0.05158439f, 0.00379261f, 
    -0.01814464f, 0.06763959f, 0.14052258f, 0.06644318f, 0.02080530f, 0.05749347f, 0.01256248f, 0.01965880f, 
    0.44470724f, -0.14725100f, 0.16821636f, -0.09293962f, 0.06753663f, 0.02501511f, 0.08925370f, 0.09422855f, 
    -0.02662882f, 0.10332567f, -0.05778956f, -0.05895054f, 0.22896272f, 0.11201975f, 0.16739696f, 0.16345857f, 
    -0.04035412f, -0.04961710f, 0.11677876f, 0.17898050f, -0.05883698f, -0.12754050f, 0.01809246f, -0.05765288f, 
    -0.01118756f, -0.02531136f, -0.00049974f, -0.03569644f, -0.01630490f, -0.03086022f, 0.00389792f, -0.02712939f, 
    -0.04108849f, -0.00935647f, -0.03949222f, -0.03991903f, -0.01325909f, 0.00148495f, 0.00063020f, -0.01526522f, 
    0.01679522f, -0.00838928f, 0.00390845f, 0.02593708f, -0.02570041f, -0.00029863f, 0.00677815f, 0.00393284f, 
    -0.00078454f, -0.00711285f, 0.02958633f, -0.03724027f, 0.00239466f, -0.04027884f, 0.00468400f, 0.00851860f, 
    0.02317154f, -0.02976361f, 0.00486369f, 0.02126471f, -0.01781792f, 0.01867861f, -0.01283431f, -0.00763931f, 
    0.02316271f, -0.01971904f, 0.01150777f, -0.03111400f, 0.02351577f, -0.00526507f, -0.00756902f, -0.00822055f, 
    0.02197436f, -0.04163692f, -0.03974586f, -0.02673408f, 0.02052080f, -0.02865296f, -0.04113457f, -0.02274242f, 
    -0.02883919f, 0.01395641f, -0.03939927f, -0.03693673f, -0.01636496f, -0.01084203f, 0.02312687f, 0.00616357f, 
    -0.01119024f, 0.02348608f, -0.03513547f, 0.00503688f, 0.02444886f, 0.00491627f, 0.01622430f, 0.00767442f, 
    -0.00546150f, 0.02684708f, -0.01724738f, -0.01942092f, 0.00799449f, -0.00967851f, -0.00088293f, -0.01305974f, 
    0.02390655f, 0.01760095f, 0.00900773f, -0.01927002f, 0.02229037f, 0.00758490f, 0.00116635f, -0.02463466f, 
    -0.00491814f, -0.03666387f, -0.02179141f, 0.00076693f, -0.02282584f, -0.00046585f, -0.00876003f, -0.02959699f, 
    -0.03578649f, -0.03320891f, -0.01042762f, -0.03260906f, -0.03588893f, 0.02451141f, -0.00607588f, -0.02885329f, 
    -0.03502280f, 0.00555326f, -0.01739472f, -0.00969163f, 0.01680867f, 0.00282437f, 0.00739788f, -0.00112338f, 
    -0.02736493f, 0.00886758f, -0.00107493f, -0.01933935f, -0.01400280f, -0.02708410f, -0.02759248f, -0.03856698f, 
    -0.03281828f, 0.02562093f, -0.00790129f, -0.01343097f, 0.00966009f, 0.02913857f, 0.02221984f, 0.00333624f, 
    -0.01380105f, -0.01070804f, -0.01647504f, -0.03062056f, -0.00463594f, -0.00491457f, -0.04147388f, -0.00341992f, 
    -0.00150979f, -0.01498695f, 0.01217325f, -0.00072319f, 0.00815310f, 0.01486880f, -0.00875102f, 0.01875153f, 
    -0.04166776f, -0.00628329f, 0.00505962f, -0.02141801f, -0.04119085f, 0.03034276f, -0.02030613f, -0.00735783f, 
    -0.03860665f, 0.00801027f, -0.02960255f, -0.03350811f, -0.01172847f, -0.03528860f, -0.01523278f, 0.01345252f, 
    -0.00460861f, -0.04121423f, -0.01071861f, 0.02442906f, 0.03516665f, -0.00233927f, -0.03023860f, 0.00500058f, 
    0.00599517f, -0.04136612f, 0.00566113f, 0.00251512f, -0.02829684f, 0.00767006f, 0.01349466f, -0.00478556f, 
    -0.00596051f, 0.01802544f, -0.01326239f, -0.03094557f, -0.02729731f, -0.00248482f, -0.02507065f, -0.03120130f, 
    -0.03840715f, 0.02509661f, 0.01017662f, 0.01478812f, -0.02728902f, 0.01599099f, 0.02736188f, -0.02563199f, 
    -0.00968329f, -0.01118093f, 0.00488638f, -0.03874741f, 0.02285337f, -0.00733136f, -0.00696908f, 0.02866488f, 
    -0.00665792f, 0.00850424f, 0.01237366f, 0.01536113f, -0.03489744f, 0.01756047f, 0.01240664f, -0.00249845f, 
    0.00299876f, -0.02736688f, -0.01123375f, 0.01815848f, 0.02928136f, 0.01525073f, -0.02768663f, 0.01110675f, 
    0.01040023f, -0.01071218f, -0.03155524f, 0.02799976f, 0.02354652f, 0.02615739f, -0.00865405f, -0.03354524f, 
    -0.00985447f, -0.02110355f, -0.00800086f, -0.03832020f, -0.01938757f, -0.01333966f, 0.00252053f, 0.01045926f, 
    -0.00165137f, -0.01639138f, -0.01200259f, -0.03050062f, 0.01907969f, 0.02147241f, 0.00498852f, -0.02300357f, 
    -0.00561810f, -0.03573140f, 0.02796982f, -0.03879985f, -0.00593129f, 0.01753294f, -0.00583287f, 0.02439229f, 
    0.02932454f, 0.02117570f, 0.00040113f, -0.03448582f, -0.00738497f, -0.01246188f, 0.00971584f, -0.00224136f, 
    0.02345075f, -0.01285663f, -0.03331185f, -0.01441133f, 0.01451296f, -0.00699899f, 0.01560398f, 0.02958470f, 
    -0.01522840f, -0.03353579f, 0.01411092f, -0.00433024f, -0.01155910f, 0.01182833f, -0.02239236f, 0.01660157f, 
    -0.01843911f, -0.02650743f, 0.02552908f, -0.00442127f, -0.03733253f, -0.01867458f, -0.03565250f, 0.00281373f, 
    0.00382932f, -0.03056474f, 0.02030713f, 0.01559706f, -0.03569157f, 0.01849107f, 0.00748140f, 0.02998094f, 
    -0.02313305f, -0.00264101f, -0.03910060f, -0.01813744f, 0.02637880f, -0.01190940f, -0.01329769f, -0.02725535f, 
    -0.00467235f, -0.02320988f, 0.01570701f, -0.04069706f, -0.01098919f, -0.03849528f, -0.03906468f, -0.00988138f, 
    -0.02384889f, 0.01784322f, -0.03753857f, -0.03166198f, -0.01554151f, 0.02958219f, -0.03760909f, 0.02013059f, 
    -0.02289668f, 0.01640651f, 0.01354194f, -0.02650965f, 0.01495730f, -0.01434017f, -0.00993040f, 0.00885517f, 
    0.00927318f, -0.00757934f, -0.00785124f, -0.01443754f, 0.02440836f, 0.00390391f, -0.03820146f, -0.01909474f, 
    -0.01332070f, 0.02004517f, 0.01731052f, 0.02333182f, 0.02958373f, 0.01485384f, -0.01601531f, -0.02275864f, 
    -0.00119921f, -0.01850802f, 0.01782804f, 0.00356219f, -0.03044379f, 0.02665571f, 0.02919873f, -0.01865201f, 
    -0.00699296f, 0.00385538f, -0.01976114f, 0.01488924f, -0.03931229f, 0.01465886f, 0.02009068f, 0.03502945f, 
    -0.01619425f, 0.00269345f, -0.00127288f, -0.01071259f, -0.02082387f, -0.02446245f, -0.03936852f, -0.02330255f, 
    0.00311619f, -0.01032394f, -0.03733660f, -0.02306105f, -0.02323026f, -0.00186536f, 0.01668203f, -0.03748674f, 
    0.00693127f, 0.01007096f, -0.02476858f, 0.02225107f, 0.01011080f, 0.00659608f, 0.02659526f, 0.00012664f, 
    -0.04146215f, 0.00495197f, -0.00878170f, -0.04125693f, -0.01831128f, 0.00937610f, 0.02345377f, 0.00092206f, 
    0.01429497f, 0.03438093f, -0.03831573f, -0.03542794f, -0.01096904f, 0.00347010f, 0.01072832f, 0.02682815f, 
    0.01147770f, 0.00525383f, -0.00585499f, 0.03333918f, -0.03938466f, -0.03748336f, -0.00801509f, 0.03144213f, 
    -0.01410792f, 0.02972553f, -0.02807848f, 0.01455549f, 0.01978583f, 0.01323590f, 0.02063477f, 0.01141274f, 
    -0.02115654f, -0.01082029f, -0.03539245f, -0.03894615f, -0.01753956f, -0.03952118f, 0.01777873f, -0.00949449f, 
    0.01267537f, -0.01633564f, -0.01785410f, 0.02427218f, -0.00094516f, -0.03178365f, -0.02768262f, -0.02624204f, 
    0.01919228f, -0.03253011f, -0.00159310f, -0.03245207f, 0.00770173f, -0.03672810f, -0.03749038f, -0.03827979f, 
    -0.03148399f, 0.01390694f, -0.02184014f, -0.02254605f, -0.03719894f, 0.01757046f, -0.04119413f, 0.00997827f, 
    0.00845370f, -0.01071933f, 0.00962885f, 0.02343279f, -0.00030115f, -0.02728128f, -0.00278183f, -0.02086098f, 
    0.02325691f, -0.03595059f, -0.00908404f, -0.01058514f, 0.02054342f, 0.01624186f, -0.02745152f, 0.00821478f, 
    0.03039428f, 0.01332050f, 0.01087230f, -0.01143228f, -0.03008601f, -0.03923724f, -0.02101104f, 0.01310528f, 
    -0.02928215f, -0.00610524f, 0.03868943f, -0.00749579f, -0.02007492f, -0.00852620f, 0.00457919f, 0.01712072f, 
    -0.03558026f, 0.00959989f, -0.03560662f, 0.01441022f, 0.01767481f, 0.00967779f, -0.01702615f, 0.01046646f, 
    0.03154143f, -0.01000938f, -0.03400706f, 0.02671343f, 0.02883496f, -0.00801992f, 0.00451961f, -0.00026152f, 
    0.02914562f, 0.01522303f, 0.01401984f, -0.02880920f, -0.03206171f, -0.01001943f, -0.00704978f, -0.03096658f, 
    0.02531907f, -0.03789080f, -0.00236460f, 0.00432137f, 0.00651575f, 0.01198759f, -0.00480390f, 0.00780240f, 
    -0.03454835f, 0.02135734f, -0.00144210f, 0.01092166f, -0.00981737f, -0.01024719f, -0.02314847f, -0.01545293f, 
    -0.01031669f, -0.00361366f, 0.01225295f, 0.02035676f, 0.03006316f, -0.03687428f, -0.03252658f, -0.00349634f, 
    0.00112029f, -0.00220207f, 0.02018882f, -0.03162635f, -0.01535194f, 0.00973860f, 0.00716604f, 0.01032012f, 
    0.00662606f, 0.00981418f, 0.00488354f, 0.02837859f, -0.00346257f, -0.00703043f, 0.03855000f, -0.02810524f, 
    -0.01665735f, 0.00224651f, 0.02401424f, -0.02526325f, -0.02057027f, -0.01867471f, 0.00403413f, 0.00817966f, 
    0.00369649f, 0.00027920f, -0.00262127f, 0.02456421f, -0.00590665f, -0.01629701f, -0.01851289f, 0.02151217f, 
    -0.02827803f, -0.01545579f, -0.02186330f, -0.01915576f, 0.00274136f, 0.01612944f, 0.02199360f, 0.01764505f, 
    0.02036037f, -0.03534427f, 0.00327708f, 0.02649035f, -0.00836783f, 0.01533204f, 0.02116765f, -0.03675036f, 
    -0.04187822f, -0.04075281f, -0.03132313f, -0.01334732f, -0.01790866f, 0.02124550f, -0.00251925f, -0.01946171f, 
    0.00475012f, 0.02652051f, -0.02325819f, -0.03893173f, -0.03865636f, 0.01127385f, -0.00359720f, 0.00959308f, 
    -0.00200816f, -0.02304913f, -0.01112645f, -0.00318709f, 0.01856164f, 0.02530437f, -0.01778401f, -0.03911671f, 
    -0.03358581f, -0.04156101f, -0.01687209f, 0.01117975f, 0.01774298f, -0.02986301f, 0.00971445f, 0.03044045f, 
    0.01427842f, 0.00866780f, 0.01226689f, 0.00092845f, -0.01135775f, -0.02230278f, -0.02368569f, -0.00071424f, 
    -0.02265837f, 0.02296575f, 0.02810448f, 0.02537270f, 0.02364437f, -0.03806021f, -0.02322563f, -0.00728148f, 
    0.01899951f, -0.00634478f, 0.00448721f, -0.01478643f, -0.01607126f, -0.02038541f, -0.02137857f, 0.01021193f, 
    0.00178499f, 0.02511741f, -0.03253036f, 0.01845952f, 0.01812643f, 0.01034027f, -0.03201975f, -0.01951335f, 
    0.02297723f, -0.02979506f, -0.03034679f, 0.00092120f, -0.00771624f, -0.01705615f, 0.00377447f, -0.02295810f, 
    -0.02622235f, -0.01825307f, -0.01688490f, 0.01425649f, 0.02379121f, 0.00054719f, 0.03090178f, -0.01708033f, 
    0.02495392f, -0.00329698f, 0.02072598f, -0.00393914f, 0.02109307f, -0.04144748f, -0.00576183f, 0.01502540f, 
    0.02192753f, 0.02197465f, -0.00867559f, 0.02833810f, 0.02754402f, 0.02271413f, 0.02582749f, 0.00844979f, 
    0.01740579f, 0.01005075f, -0.02651503f, -0.00620925f, 0.02112672f, -0.03367718f, -0.02594454f, -0.02412114f, 
    0.02812688f, -0.03712608f, -0.01256581f, 0.00013549f, 0.00996279f, 0.02541537f, -0.03066548f, -0.03087092f, 
    -0.03930486f, 0.01394333f, -0.01085388f, 0.01026268f, -0.01821899f, -0.01863128f, 0.03533522f, 0.04102427f, 
    0.01433443f, 0.01090344f, 0.02691271f, -0.03220238f, -0.00890232f, -0.02794267f, 0.03689979f, -0.00761520f, 
    -0.03097938f, -0.00141141f, 0.02862390f, -0.01938383f, -0.01184845f, -0.02100584f, -0.03348615f, -0.00388822f, 
    0.00640877f, 0.01354257f, 0.01794174f, 0.01254918f, 0.00487839f, 0.02111158f, 0.00287521f, 0.02483999f, 
    0.02149032f, -0.00300628f, -0.02039743f, -0.03571597f, 0.00005928f, -0.01690285f, 0.02754405f, 0.01853648f, 
    -0.00759877f, -0.03273854f, -0.03447247f, -0.00599804f, -0.03710553f, 0.01512421f, -0.03676813f, 0.01288052f, 
    0.02281201f, 0.01871286f, -0.00269311f, -0.01409244f, -0.01046279f, -0.03103658f, -0.00726147f, -0.00118277f, 
    0.01685050f, 0.02533653f, 0.02596686f, 0.02884961f, 0.01706474f, 0.00102053f, -0.02255419f, -0.03664223f, 
    -0.03478380f, -0.02793982f, 0.02927520f, -0.00418074f, -0.02706636f, 0.01565261f, -0.00839541f, -0.01544965f, 
    -0.00127739f, 0.01952953f, -0.00895676f, -0.02182607f, -0.01874808f, -0.03139705f, 0.00526316f, 0.02169407f, 
    0.00409054f, -0.03474030f, -0.03567446f, -0.01431249f, -0.03689128f, 0.02837110f, -0.00122641f, -0.03870600f, 
    -0.04377151f, -0.02053063f, 0.35288808f, 0.17578927f, 0.00741425f, 0.05283850f, 0.10330595f, 0.00586226f, 
    0.04636968f, 0.17178807f, 0.08346728f, 0.11314500f, -0.07543644f, -0.15111388f, -0.06877148f, 0.02189834f, 
    0.08064535f, 0.16304301f, 0.09719355f, -0.02324165f, 0.01241077f, -0.07993419f, 0.00521331f, -0.00228497f, 
    0.04177214f, 0.09329315f, 0.10557576f, 0.00330254f, -0.05287918f, -0.12406531f, 0.05674848f, 0.00326723f, 
    0.04619760f, 0.09598591f, 0.02079685f, -0.01099223f, 0.48256400f, -0.02916632f, -0.14159550f, -0.18072149f, 
    -0.01535968f, 0.08444463f, -0.02581824f, -0.00356851f, 0.03914023f, -0.04105679f, -0.02704542f, -0.10423008f, 
    -0.05447912f, 0.09731126f, -0.02866354f, -0.04635681f, 0.04508484f, 0.04574584f, 0.10461359f, -0.00188309f, 
    0.10009059f, -0.00060656f, -0.09197533f, -0.08531817f, -0.01105366f, -0.12178754f, 0.13891971f, -0.05665322f, 
    0.11115800f, 0.06278812f, -0.21421510f, -0.04014450f, 0.13587528f, -0.24275509f, -0.01489018f, -0.07645704f, 
    -0.05138342f, -0.02770209f, -0.21632348f, -0.03674796f, -0.01260715f, 0.06395619f, -0.00244205f, 0.00396561f, 
    -0.00984615f, -0.00750798f, 0.07616688f, 0.18154204f, -0.04803076f, -0.06187604f, 0.17345385f, -0.09014287f, 
    0.00861040f, 0.02317183f, -0.01801372f, -0.09657683f, 0.02977194f, -0.09714366f, 0.09525221f, 0.14099418f, 
    0.02378753f, 0.04490850f, 0.20371965f, 0.04673819f, 0.01930930f, -0.08111997f, 0.09805179f, 0.03679562f, 
    -0.01131186f, 0.01463745f, 0.00657925f, 0.03605323f, -0.06607927f, 0.21702082f, 0.04301202f, 0.08939684f, 
    0.01531896f, 0.07784202f, 0.01858087f, 0.21476567f, -0.14829990f, -0.06697751f, -0.05322342f, -0.13221990f, 
    -0.02787292f, -0.03832892f, -0.26639584f, 0.04768699f, -0.04491174f, -0.09174852f, 0.12717563f, -0.10220077f, 
    -0.09752869f, -0.03023827f, 0.02570420f, 0.10224471f, -0.09196744f, -0.04770187f, -0.13320352f, 0.09183316f, 
    0.06784060f, -0.12822419f, 0.06340115f, -0.00786095f, 0.00418544f, 0.05785088f, -0.03374849f, -0.00295347f, 
    -0.01720097f, 0.07819282f, 0.03916255f, 0.05168156f, 0.01918358f, 0.02958298f, 0.00745767f, -0.04723759f, 
    0.02406542f, -0.04233706f, 0.05459287f, -0.06527621f, -0.30312440f, -0.02247263f, -0.21549365f, -0.13909654f, 
    0.03996120f, 0.18883346f, 0.12104179f, 0.07262656f, 0.13631505f, -0.04566629f, 0.09134622f, 0.32636178f, 
    0.16744287f, -0.02026024f, -0.10424608f, -0.06186945f, -0.02871833f, -0.05859597f, 0.23525622f, 0.05800788f, 
    -0.03179258f, 0.04741374f, -0.09338175f, -0.06337407f, -0.00294749f, 0.08383641f, -0.09641808f, -0.06549100f, 
    -0.01846628f, -0.04386624f, 0.05662819f, 0.03571040f, -0.04592699f, -0.06919953f, -0.10219028f, -0.08694237f, 
    -0.09135263f, -0.16178635f, -0.09899658f, -0.06867255f, -0.05480842f, -0.02811585f, -0.02669659f, 0.04616950f, 
    0.16550642f, 0.20374848f, 0.16179565f, 0.24113590f, -0.02364908f, -0.04430819f, 0.10725215f, -0.09369173f, 
    0.03340886f, 0.06069052f, 0.11589087f, 0.08109321f, 0.04178989f, 0.12524943f, 0.02054591f, 0.14086662f, 
    -0.06403038f, -0.00420786f, 0.03573304f, -0.01964670f, 0.01207983f, 0.00068314f, 0.16070946f, 0.00754684f, 
    0.17406720f, -0.02654281f, 0.01965820f, 0.17189620f, -0.01291691f, 0.04662413f, 0.03310464f, -0.00470861f, 
    0.10771580f, -0.05111579f, 0.08045812f, -0.01027580f, -0.10548461f, -0.10528208f, -0.08242735f, -0.20267007f, 
    -0.09206791f, 0.01437252f, 0.06115787f, -0.00019726f, -0.02280868f, 0.01582822f, 0.05835328f, 0.14279997f, 
    0.06785527f, 0.12990515f, 0.23231654f, 0.17623363f, 0.03323390f, -0.17358567f, 0.27391592f, 0.15425642f, 
    -0.02383555f, -0.03869118f, -0.15023594f, -0.13289568f, 0.09839311f, -0.07045468f, 0.11422940f, -0.05442059f, 
    -0.31529522f, 0.01283351f, 0.01893908f, 0.13542816f, -0.01919880f, -0.15558288f, -0.00266257f, -0.17552738f, 
    0.00908016f, 0.11351389f, -0.02989430f, 0.03016851f, -0.11735217f, -0.05440521f, -0.16215479f, -0.01590280f, 
    0.14760336f, 0.03902582f, -0.13256736f, 0.04272406f, -0.02831081f, 0.09535597f, 0.09459334f, 0.02502295f, 
    0.09925494f, 0.17116435f, 0.09731815f, -0.04077656f, 0.00174974f, 0.02840803f, -0.08116790f, 0.05423561f, 
    0.04197600f, -0.17132479f, -0.14386338f, -0.27861997f, 0.05721905f, 0.02161393f, -0.14973439f, -0.09125610f, 
    0.14981326f, -0.06704320f, 0.12457197f, -0.03876585f, 0.01802183f, 0.04426568f, -0.01377868f, -0.09610125f, 
    -0.13291657f, -0.04039638f, -0.17667013f, 0.02227748f, 0.07067207f, 0.02101641f, 0.10918374f, -0.03904622f, 
    -0.02277421f, 0.05895920f, 0.03102514f, 0.11306486f, -0.50530261f, 0.16005528f, -0.10636739f, 0.10238900f, 
    0.12364956f, 0.02509091f, -0.01965009f, -0.06306893f, -0.05283776f, 0.02083645f, -0.09168358f, 0.00805656f, 
    0.02481672f, 0.11065431f, 0.13775407f, -0.05297289f, 0.14101432f, 0.23273213f, -0.02877130f, -0.08840435f, 
    0.08072360f, -0.08745696f, 0.20968145f, 0.18194383f, 0.13263822f, 0.14296798f, 0.09268328f, -0.22450610f, 
    0.10246361f, 0.12635274f, -0.21357979f, -0.15676424f, -0.13055232f, -0.15850285f, -0.28376704f, -0.12664685f, 
    0.18294482f, -0.17259525f, -0.11903580f, 0.07905565f, -0.00926500f, 0.12265158f, -0.02805814f, 0.08841383f, 
    0.09314328f, 0.03972582f, 0.27533972f, -0.00479056f, -0.12969592f, 0.08082167f, 0.06776576f, 0.23422603f, 
    0.02298490f, 0.05189137f, 0.09425842f, 0.10679931f, -0.07050282f, 0.03514269f, 0.04584928f, 0.03911133f, 
    0.12000387f, -0.04235145f, -0.04601650f, 0.07851721f, -0.02982994f, 0.07711570f, 0.00874513f, -0.07301336f, 
    -0.04463337f, 0.17043893f, 0.34919435f, 0.09305518f, 0.21091947f, -0.06455948f, -0.01312048f, 0.07596274f, 
    -0.06419490f, 0.11039895f, 0.00951364f, -0.03742125f, -0.06814543f, -0.03186169f, 0.01670655f, -0.07092588f, 
    0.13971108f, 0.01797687f, 0.12723094f, -0.07465645f, 0.04905846f, -0.07899487f, 0.07986188f, 0.00426153f, 
    -0.14576137f, -0.13467760f, -0.24188130f, -0.13997909f, -0.27439266f, 0.10129000f, -0.12061362f, 0.02808291f, 
    0.04206550f, -0.15997766f, 0.12275254f, -0.05180884f, 0.03748387f, -0.02024992f, -0.10073383f, 0.07351712f, 
    -0.02777620f, -0.04759888f, 0.03516704f, 0.16935854f, 0.06688134f, -0.06694441f, 0.00932635f, -0.19348679f, 
    -0.04073592f, -0.09403379f, 0.02791610f, -0.20371138f, -0.11634930f, 0.05991875f, 0.03854434f, 0.06306808f, 
    -0.08031814f, -0.04642329f, -0.05568088f, 0.02212251f, 0.14194238f, -0.02234977f, 0.01400357f, 0.15001327f, 
    -0.17761336f, -0.00854361f, -0.09588844f, 0.02902130f, 0.05228008f, 0.03137101f, 0.24312685f, 0.04817429f, 
    0.22368228f, 0.19654576f, 0.07941778f, 0.08969031f, 0.04708576f, 0.14901629f, 0.16223904f, 0.13734257f, 
    0.12441435f, -0.01192992f, 0.00832466f, 0.05215134f, 0.00086712f, 0.16998400f, -0.01646070f, -0.08347623f, 
    -0.01705612f, -0.05470763f, 0.06720007f, 0.09487534f, 0.01496694f, 0.05202289f, -0.10070381f, -0.23934808f, 
    0.15336470f, 0.09481048f, 0.06128116f, 0.15827250f, 0.07855622f, -0.24931683f, 0.08066813f, 0.08011514f, 
    0.06660397f, 0.02888161f, -0.03336724f, 0.04606088f, 0.09892740f, 0.07635960f, 0.03174485f, 0.04683508f, 
    -0.29691893f, 0.19840352f, 0.02516439f, 0.05687300f, 0.07749461f, 0.05689686f, 0.08865467f, 0.05459262f, 
    -0.07287463f, -0.18191589f, -0.10878314f, -0.01291765f, 0.13750690f, 0.02328311f, -0.03508134f, 0.06703082f, 
    -0.02603438f, -0.16380304f, -0.02900985f, -0.07767407f, 0.03210244f, 0.07127933f, 0.00994434f, 0.02032376f, 
    0.34737137f, 0.07665734f, 0.24354702f, -0.04267532f, 0.05147715f, 0.07135008f, 0.00887324f, 0.02694206f, 
    0.04426539f, -0.05168419f, -0.02150219f, -0.12712923f, -0.20748743f, 0.26911077f, -0.02820324f, -0.07831494f, 
    -0.01924687f, -0.06701382f, -0.02627409f, 0.02575975f, -0.15206829f, 0.06356696f, -0.09769182f, -0.08578627f, 
    0.20177944f, -0.04450170f, -0.02192413f, -0.10333866f, 0.07309549f, -0.13499415f, 0.12965293f, 0.14722550f, 
    -0.00495277f, 0.01934933f, -0.16512541f, -0.08799940f, 0.19805391f, 0.05805398f, -0.16765568f, -0.08859682f, 
    -0.03536836f, 0.16605115f, -0.10972167f, 0.03330243f, 0.06898137f, 0.09371503f, 0.12185381f, -0.00833140f, 
    -0.08316951f, 0.02531347f, -0.08631095f, 0.07260460f, 0.05055384f, -0.09013695f, -0.07406296f, -0.01625516f, 
    -0.05888393f, 0.01768412f, 0.04120081f, -0.00004848f, -0.00224171f, -0.00690985f, 0.20006347f, 0.14559753f, 
    -0.02787047f, -0.05945038f, -0.00953977f, 0.05421847f, 0.05382505f, 0.04314762f, 0.02571950f, 0.08284371f, 
    0.03477012f, 0.02763454f, 0.02031523f, 0.03336624f, 0.02645156f, 0.12356004f, 0.14380425f, -0.02370804f, 
    0.09280194f, -0.03047984f, 0.05169578f, 0.01265521f, -0.03818093f, -0.21903165f, 0.05223184f, 0.04901186f, 
    -0.00851861f, -0.02434791f, -0.02211667f, 0.02585076f, 0.12824014f, 0.06981629f, 0.03417861f, 0.13655323f, 
    -0.09087250f, 0.00110330f, -0.02216654f, -0.08962344f, 0.03008511f, -0.05039794f, 0.12357123f, 0.11334839f, 
    0.04047136f, 0.19575438f, 0.06267729f, 0.18037036f, -0.04353189f, -0.06730942f, -0.03050712f, -0.03666419f, 
    0.00261765f, -0.08603191f, 0.16669112f, 0.06868128f, -0.09045534f, 0.21234746f, 0.24614261f, 0.21010236f, 
    0.11991061f, -0.07887271f, -0.08910865f, 0.02284723f, 0.16003524f, -0.23068810f, -0.05743749f, 0.11163969f, 
    -0.06070681f, 0.01168305f, 0.25627530f, 0.11658868f, 0.11515878f, 0.04592645f, 0.10030492f, -0.07476673f, 
    -0.00845691f, -0.16708039f, -0.15743831f, 0.10815933f, -0.00524907f, -0.04780801f, 0.01317605f, -0.21380000f, 
    -0.18124972f, -0.13467164f, -0.06717171f, 0.04187789f, 0.09340532f, 0.02895263f, 0.02290625f, -0.00913165f, 
    0.13389798f, -0.03399545f, 0.08785000f, 0.00820057f, 0.08872208f, -0.17909855f, 0.35254601f, -0.00917451f, 
    0.15435523f, -0.00440698f, -0.21719973f, -0.04609264f, 0.11059254f, 0.10262665f, 0.21569665f, 0.07418401f, 
    -0.07502379f, 0.10671211f, -0.00753541f, 0.09342310f, 0.01273399f, 0.00032648f, 0.05194395f, 0.10536280f, 
    0.05421652f, 0.14096038f, -0.00756473f, -0.13647996f, 0.15159881f, -0.06450600f, -0.00112036f, -0.01591701f, 
    0.11834375f, 0.04397396f, -0.06248607f, 0.12845530f, -0.12425674f, -0.26850867f, -0.11760803f, -0.27042460f, 
    -0.13863993f, 0.01882281f, -0.04770184f, 0.06924476f, -0.01463714f, 0.00843492f, 0.12036080f, 0.06298192f, 
    0.00556609f, 0.09988770f, 0.10874242f, 0.09949668f, 0.01378863f, 0.06895214f, -0.02087826f, 0.01650788f, 
    0.09408829f, 0.13856466f, -0.12187396f, 0.06010428f, -0.08981811f, -0.20582689f, -0.11634836f, -0.21854891f, 
    -0.30425313f, 0.15491679f, -0.12388925f, -0.00183302f, 0.14698052f, 0.02775040f, -0.06449796f, -0.19897509f, 
    0.09261740f, -0.11643067f, 0.06280205f, 0.06025106f, -0.08684890f, 0.02490157f, 0.06375886f, 0.03295572f, 
    0.05436923f, 0.01870763f, -0.11475252f, 0.01388300f, -0.02544971f, -0.06723578f, -0.03314488f, -0.18056163f, 
    -0.02979501f, -0.01330065f, 0.01982123f, -0.00638694f, -0.03360825f, 0.00632167f, -0.00148984f, -0.00231649f, 
    0.00628852f, 0.00570952f, 0.02523129f, -0.02127584f, -0.02765986f, -0.03463910f, -0.02991962f, -0.03029894f, 
    0.00476676f, 0.00100299f, 0.01813298f, -0.00496312f, 0.02504471f, -0.02749699f, -0.02532868f, -0.02596667f, 
    0.00394848f, 0.01297033f, 0.00740774f, -0.02658045f, 0.01013588f, 0.00371526f, -0.03801560f, -0.03864802f, 
    0.01812090f, -0.03182424f, -0.02463989f, -0.02755952f, -0.00648605f, 0.02538639f, 0.01612597f, 0.02025975f, 
    -0.00569329f, 0.00458438f, 0.01911958f, -0.00120004f, 0.03997933f, 0.03027412f, 0.03227430f, 0.01968852f, 
    0.01667401f, -0.02873603f, -0.01549275f, -0.04197625f, -0.00833646f, 0.02925355f, 0.02479577f, 0.00543396f, 
    -0.00756863f, -0.01281391f, -0.01061773f, -0.00078674f, -0.03253752f, 0.02571224f, -0.00823070f, -0.02763059f, 
    0.00558175f, -0.03221900f, 0.01784738f, -0.01600195f, -0.01259464f, -0.01851430f, -0.02058594f, 0.00917725f, 
    0.00984188f, -0.00545087f, -0.00909513f, 0.01589362f, -0.00092319f, -0.00246437f, -0.00468277f, -0.00105115f, 
    -0.00398171f, -0.03989382f, -0.00280415f, -0.02372084f, 0.00820041f, -0.00756138f, 0.01113681f, 0.00271972f, 
    -0.04292727f, 0.00090234f, -0.01701337f, 0.00227478f, -0.03244041f, -0.00868688f, 0.01367903f, 0.02011520f, 
    -0.01698185f, 0.00549406f, -0.02159907f, -0.00730648f, -0.00767015f, -0.03474699f, 0.00798812f, -0.02841841f, 
    -0.02821209f, -0.00145356f, 0.01822213f, 0.00946812f, -0.03095923f, -0.03974125f, -0.01200838f, 0.02331248f, 
    0.02905931f, -0.00574730f, 0.02490817f, -0.00074128f, -0.02272434f, -0.01858732f, 0.00895057f, 0.04042257f, 
    0.02994581f, -0.03449557f, 0.00569235f, -0.00492750f, -0.02717350f, 0.01942906f, 0.02553349f, 0.01538121f, 
    0.01995820f, -0.02016378f, 0.00708535f, -0.02452961f, -0.00420706f, -0.02687546f, 0.01101095f, 0.00808574f, 
    0.00320772f, 0.01877894f, 0.02290081f, -0.01309280f, 0.02758180f, -0.00597618f, 0.02253513f, 0.00602025f, 
    -0.02396935f, 0.00133433f, -0.01111952f, 0.01469628f, 0.00905997f, 0.00190523f, 0.03238633f, 0.03178566f, 
    0.02324624f, 0.01233301f, -0.04142911f, -0.02194198f, -0.00087880f, -0.00886996f, -0.02818336f, -0.03584156f, 
    0.00590471f, -0.01293226f, 0.02692950f, 0.00340025f, -0.04379031f, -0.02682335f, -0.04032873f, -0.00982242f, 
    0.00417248f, -0.03590522f, -0.01762982f, -0.03891908f, -0.00758997f, -0.00740616f, 0.02122276f, -0.00193833f, 
    -0.00031634f, -0.00456678f, 0.01322002f, 0.01384947f, 0.02105974f, -0.03099080f, 0.00656572f, 0.01947828f, 
    0.01542418f, -0.00581813f, 0.00148127f, 0.00324612f, -0.01338150f, 0.00422770f, 0.03283951f, -0.00096747f, 
    -0.03965179f, 0.02267282f, -0.03038197f, -0.01528129f, -0.01696019f, 0.00473734f, 0.02342002f, 0.03157905f, 
    0.00407289f, 0.01892729f, -0.03934192f, 0.00096798f, 0.00738114f, -0.00395958f, -0.02593270f, 0.02881447f, 
    -0.00864368f, 0.02900920f, -0.03431643f, -0.00439386f, -0.00145647f, -0.03747431f, -0.02811450f, -0.00833785f, 
    0.02701916f, -0.02979917f, -0.02877595f, -0.00682436f, -0.02974967f, -0.00128348f, -0.03865992f, -0.00981376f, 
    -0.03669355f, 0.00763589f, -0.01343174f, -0.00339521f, -0.03053465f, 0.01018194f, -0.02400255f, -0.02742668f, 
    -0.00881066f, 0.00257621f, -0.02480284f, 0.00377923f, 0.01928382f, -0.01300614f, -0.02118319f, -0.00427531f, 
    0.02816864f, 0.00376297f, -0.01798744f, 0.02067238f, -0.02985285f, -0.04101989f, -0.03192708f, -0.04021798f, 
    -0.03754851f, -0.04105797f, -0.04001707f, 0.01399137f, 0.02568622f, 0.03155235f, -0.00908892f, 0.01913275f, 
    -0.00237846f, 0.02684077f, -0.03035864f, -0.00970529f, -0.02313079f, -0.02925351f, -0.02500223f, -0.01700086f, 
    0.02037084f, -0.02275749f, -0.03797262f, -0.03303420f, 0.01564101f, 0.00590203f, 0.00148226f, 0.01154376f, 
    -0.00278195f, 0.01845230f, -0.02720280f, -0.04356345f, -0.02089710f, -0.01439955f, 0.01243730f, -0.03560404f, 
    0.02941463f, 0.00178437f, -0.04275777f, -0.02278411f, 0.00674215f, 0.01841592f, 0.03005382f, -0.03785669f, 
    0.02782205f, -0.01581036f, -0.03643705f, 0.00418550f, 0.02629309f, -0.00836127f, 0.02089728f, 0.00381741f, 
    -0.01848165f, -0.00550975f, 0.00660758f, 0.01075200f, -0.00662006f, -0.01977563f, -0.01388565f, 0.03030579f, 
    0.03167352f, -0.00639380f, 0.03702539f, 0.03948015f, -0.03116279f, -0.01774614f, 0.00936016f, -0.00258541f, 
    0.02318184f, 0.00038145f, 0.01130237f, 0.01074996f, -0.02926229f, -0.02553133f, -0.03822199f, 0.00731988f, 
    -0.01601617f, 0.01163145f, -0.01458054f, -0.00256338f, 0.02207041f, -0.01139706f, 0.00912436f, -0.00639235f, 
    0.01341737f, -0.00328388f, -0.01746085f, 0.00880539f, 0.00459516f, -0.04206003f, -0.01967275f, 0.01064112f, 
    -0.00996945f, -0.01128224f, 0.02267637f, 0.00386642f, 0.01477974f, -0.03019112f, 0.02369544f, 0.02281335f, 
    -0.01267059f, 0.02879585f, 0.02814176f, -0.02353556f, 0.00733272f, -0.03481692f, -0.01606138f, 0.02050698f, 
    0.01592035f, -0.01843428f, -0.01295449f, 0.01879723f, 0.01553807f, 0.00387600f, 0.00058956f, -0.01640901f, 
    -0.01609281f, 0.02969196f, -0.01083877f, -0.02053627f, 0.01221729f, -0.01058207f, 0.02705819f, -0.03886939f, 
    0.03817629f, -0.03168131f, 0.00464643f, 0.02461172f, -0.02035377f, 0.02405186f, 0.01324801f, -0.04003745f, 
    -0.00140945f, 0.00322794f, -0.03043387f, 0.03504451f, 0.01725228f, 0.03177940f, -0.02147492f, -0.02829952f, 
    0.01478356f, -0.03468632f, 0.01862514f, -0.02265198f, 0.02660205f, -0.00588391f, -0.01394514f, -0.01465012f, 
    -0.02006024f, 0.01939669f, -0.02869157f, -0.00151635f, 0.02131975f, -0.01034090f, -0.00981884f, -0.02480494f, 
    0.02704921f, -0.00213915f, 0.00833861f, -0.03073362f, -0.03751278f, 0.00026798f, -0.00329932f, 0.02818109f, 
    -0.00323755f, -0.04188519f, -0.00107839f, -0.00682826f, -0.01359542f, -0.02950927f, 0.04192735f, 0.02147724f, 
    -0.01630937f, 0.02968930f, -0.00861456f, -0.01633499f, 0.03503116f, -0.02209668f, -0.01233540f, 0.00232977f, 
    -0.00806529f, -0.02038257f, -0.03835469f, -0.01177447f, -0.02108630f, -0.00674487f, -0.01224378f, 0.03010393f, 
    -0.01626928f, 0.02098981f, 0.00536313f, -0.00151338f, -0.01089762f, -0.02083345f, 0.03217221f, 0.02037438f, 
    -0.02647330f, -0.00700154f, 0.01697824f, -0.03009227f, -0.02896991f, -0.00078503f, 0.00489483f, -0.00663618f, 
    -0.02989651f, -0.02631363f, -0.01452903f, -0.02352259f, -0.02334614f, -0.03143372f, -0.02160031f, -0.02267675f, 
    0.01464322f, 0.02307524f, -0.00156363f, -0.00938986f, -0.03459832f, -0.03592710f, 0.02405637f, 0.01230449f, 
    0.01057566f, -0.03266325f, -0.04442091f, 0.00991384f, -0.03411166f, -0.03029239f, 0.00431722f, 0.01213582f, 
    0.03652710f, -0.02162165f, 0.01742168f, 0.02687779f, -0.00149716f, 0.02648119f, -0.02864740f, -0.01384361f, 
    -0.01033269f, 0.03120430f, -0.04289554f, 0.03543967f, -0.02663275f, -0.01817848f, 0.00891002f, 0.00016763f, 
    0.02745182f, 0.00290387f, -0.02723934f, -0.01163164f, 0.00871242f, 0.00553863f, 0.01651167f, -0.01963634f, 
    -0.00415592f, 0.00245803f, 0.00968387f, 0.02746941f, -0.04331424f, -0.01793434f, -0.01590546f, -0.02340685f, 
    -0.00212478f, -0.01139628f, -0.03081217f, 0.02001124f, 0.02047477f, 0.01090612f, -0.02150799f, 0.02762594f, 
    0.01998128f, -0.02256836f, 0.00495922f, 0.01617832f, 0.00103735f, 0.02386312f, -0.03614034f, 0.00059439f, 
    0.00119548f, 0.00212905f, -0.02062467f, 0.01948167f, -0.01389288f, 0.01222982f, -0.02842147f, 0.01430110f, 
    0.01549010f, -0.02922574f, 0.00670528f, 0.00539142f, -0.03172608f, 0.02277019f, -0.01443752f, -0.00985812f, 
    0.03436052f, 0.01903484f, 0.02410081f, 0.02853015f, 0.01378586f, -0.01985766f, -0.03880760f, 0.02695430f, 
    -0.01257750f, 0.00014774f, -0.02902779f, 0.01268118f, 0.02021633f, 0.02397241f, 0.00461842f, -0.03174641f, 
    -0.00334119f, 0.00407493f, 0.01152588f, -0.03843338f, 0.00951568f, 0.00582148f, -0.00159184f, 0.00854881f, 
    -0.01888384f, 0.02043215f, 0.03402791f, -0.01782767f, -0.00472826f, 0.01634357f, -0.02825368f, -0.01476386f, 
    -0.02252857f, -0.04449264f, -0.01895370f, 0.02142695f, 0.03118759f, 0.01235471f, -0.01769664f, -0.00379153f, 
    -0.03458234f, 0.03924831f, -0.04300600f, -0.01005024f, 0.00045516f, -0.01229083f, 0.00658862f, 0.03037163f, 
    0.01686885f, 0.01658992f, 0.02571768f, -0.03483031f, 0.03622020f, -0.02937542f, -0.00456472f, 0.00430415f, 
    -0.01533512f, -0.01177356f, 0.03193612f, 0.00913674f, -0.01107705f, 0.00604081f, -0.00284457f, -0.00928965f, 
    -0.00355370f, -0.01813454f, -0.02289311f, -0.02263493f, 0.01518043f, -0.01437834f, 0.02046714f, -0.03236939f, 
    -0.02247379f, -0.02337829f, 0.02457915f, -0.03637533f, -0.01460528f, 0.01460750f, -0.03754922f, 0.02483036f, 
    0.02606825f, 0.01060905f, -0.00321512f, 0.02172880f, -0.02547804f, 0.03715242f, -0.03959904f, 0.00434667f, 
    -0.02334430f, -0.00133569f, -0.00160139f, -0.03382302f, -0.00024307f, 0.01504364f, 0.00484118f, -0.01005334f, 
    -0.01106210f, -0.02022016f, 0.00067917f, -0.00847587f, 0.02600441f, -0.03003261f, -0.04132353f, -0.01893788f, 
    -0.03735397f, -0.00731132f, 0.00758951f, 0.02548603f, -0.02512887f, -0.04013021f, -0.00927529f, -0.03588514f, 
    -0.03940229f, 0.02249847f, -0.01857530f, 0.00197148f, 0.00081880f, 0.01302278f, 0.02209724f, 0.03103736f, 
    -0.03545508f, -0.02898064f, 0.02220501f, -0.00994653f, -0.01849414f, -0.01573472f, 0.02058248f, -0.03736256f, 
    -0.03575620f, -0.02016053f, -0.00072175f, -0.01749155f, -0.02589335f, -0.01848845f, 0.02823741f, -0.01997422f, 
    0.02503884f, -0.00594323f, 0.01192699f, 0.00579691f, -0.00690623f, 0.03015277f, -0.01397941f, 0.01557288f, 
    -0.01600777f, -0.03595886f, 0.00267047f, -0.03303759f, -0.02965759f, -0.01421017f, -0.01409256f, 0.02077622f, 
    0.01400499f, -0.04115980f, 0.01144061f, 0.00657005f, -0.02000952f, -0.02596587f, -0.00430823f, 0.02633161f, 
    -0.02508845f, -0.01526458f, 0.03373361f, 0.03354952f, 0.02823319f, -0.02785944f, -0.02112657f, 0.00594683f, 
    0.02098954f, 0.02010204f, -0.00504962f, 0.02665607f, -0.03822556f, 0.00573022f, -0.01611606f, 0.00954228f, 
    -0.02824069f, 0.01643333f, 0.01425560f, 0.01992702f, 0.01914923f, -0.00342949f, -0.03363702f, -0.01923762f, 
    0.01628114f, -0.00683966f, 0.00702357f, 0.02913615f, 0.00683934f, 0.01325417f, -0.01458746f, 0.01575324f, 
    0.00049003f, -0.03774275f, -0.03439632f, -0.02074192f, 0.01143033f, -0.03926615f, -0.04291472f, -0.03184318f, 
    0.00286742f, 0.00662146f, -0.02299407f, -0.02053507f, -0.02696736f, -0.01430895f, -0.00396617f, -0.02707822f, 
    -0.01800468f, -0.04339785f, -0.01472813f, -0.01400945f, -0.03522162f, -0.02896905f, -0.00428194f, 0.00243922f, 
    -0.00704211f, 0.02600832f, 0.00321025f, 0.03620004f, -0.02425203f, 0.02365940f, 0.03202600f, -0.04253668f, 
    -0.01457343f, -0.00106019f, 0.03216294f, -0.01890105f, -0.02021029f, -0.02986946f, 0.01684433f, 0.00306862f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03873018f, 0.18586946f, 0.06154869f, -0.02842677f, 0.06742369f, 0.20859273f, 0.02980972f, 0.23145561f, 
    0.02172243f, -0.02696879f, 0.02085778f, 0.07305986f, 0.02118441f, -0.01832774f, -0.03439547f, 0.00524358f, 
    0.10550673f, -0.01952128f, 0.06232487f, 0.00287854f, -0.00754860f, -0.04106962f, -0.00177102f, 0.09516031f, 
    0.09965889f, 0.02121205f, -0.00476423f, 0.02660177f, 0.11100000f, 0.00194587f, -0.01060420f, 0.00849014f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.32638943f, 0.31417388f, -0.20202179f, -0.04929774f, 0.06851468f, -0.03422403f, 0.00210990f, 0.06197814f, 
    -0.02437334f, -0.09598367f, 0.03120169f, 0.16734000f, -0.14114378f, 0.01160766f, -0.15281315f, 0.15868412f, 
    0.22893427f, -0.00223961f, -0.24827673f, 0.23635052f, -0.01435908f, -0.38095722f, -0.17803366f, -0.06969801f, 
    0.36184949f, -0.04098549f, -0.19289403f, 0.06003264f, 0.03414601f, -0.01220812f, 0.15031509f, -0.00537552f, 
    0.43850467f, 0.13260512f, -0.31275499f, 0.03346459f, 0.11695628f, 0.05710516f, 0.23068488f, -0.32367265f, 
    0.01397035f, -0.06438281f, -0.16976772f, -0.16404660f, 0.46544790f, 0.08156812f, -0.07472254f, -0.02951670f, 
    0.29294416f, 0.15693763f, 0.08915392f, 0.32952410f, 0.19354917f, 0.07340824f, -0.05084142f, -0.07589335f, 
    -0.18293083f, -0.14693025f, -0.28538328f, -0.05217407f, -0.17967857f, -0.01210363f, 0.24679893f, -0.12981802f, 
    -0.26342881f, 0.23316030f, -0.12946653f, -0.12932880f, -0.03342307f, 0.11890932f, 0.09290469f, 0.09204558f, 
    -0.14940046f, 0.06740434f, -0.05864881f, -0.03380271f, -0.23136638f, -0.00926803f, -0.15598324f, -0.10277962f, 
    -0.04759160f, 0.01336917f, -0.02420737f, -0.14852361f, 0.34666765f, 0.22202694f, -0.15436281f, 0.12360884f, 
    0.28121507f, -0.01564114f, 0.07824501f, 0.03631522f, 0.24560925f, 0.04116150f, -0.03184606f, -0.09187701f, 
    -0.12775950f, 0.30949485f, 0.20190395f, -0.16404574f, 0.29548749f, 0.36840236f, -0.14053528f, -0.00054093f, 
    -0.13374579f, -0.05124569f, -0.17884558f, 0.28976715f, -0.37783122f, -0.15414813f, -0.23899388f, 0.09466191f, 
    -0.37492004f, 0.15731391f, 0.06788159f, 0.15662587f, -0.22441371f, -0.25389552f, -0.05189636f, -0.19231819f, 
    -0.06435978f, 0.11797839f, -0.12276558f, -0.06334399f, -0.05110680f, 0.11341544f, -0.07489113f, -0.14928465f, 
    0.24839504f, -0.13858086f, 0.26116878f, -0.07315207f, -0.00002130f, -0.14396496f, 0.05097270f, -0.02377069f, 
    0.04076501f, 0.02634719f, -0.13029957f, 0.23953758f, 0.05811145f, -0.04003619f, 0.22387840f, 0.11487287f, 
    -0.41702053f, 0.12877923f, 0.21805018f, 0.39638111f, -0.07990786f, -0.17486936f, 0.12186354f, 0.21255057f, 
    -0.21363156f, 0.11773524f, -0.04582173f, 0.05522471f, 0.22529079f, -0.12750596f, 0.06353949f, 0.12018979f, 
    0.21746333f, 0.35732681f, 0.14751565f, 0.03372850f, 0.05232007f, -0.20301463f, -0.03055424f, 0.10474467f, 
    0.14115356f, 0.05165153f, -0.08471377f, -0.05757227f, -0.07866236f, 0.09355724f, -0.12295249f, -0.03924462f, 
    -0.16403520f, -0.09957353f, -0.39741886f, 0.08801447f, 0.07442521f, -0.49202779f, -0.07927112f, 0.02214756f, 
    -0.11038431f, -0.05554681f, 0.02773205f, -0.05550165f, 0.00951545f, -0.04448367f, 0.33618867f, 0.06153716f, 
    -0.16979150f, 0.16626132f, -0.02657844f, -0.03001351f, -0.04459419f, -0.28133303f, -0.01304672f, -0.10487510f, 
    0.08580168f, -0.14966010f, -0.01489602f, -0.19363436f, -0.09212025f, -0.12571774f, -0.15959118f, 0.03866019f, 
    0.00226864f, -0.09212104f, -0.22224945f, -0.12733440f, -0.28003860f, -0.08040787f, 0.15459904f, -0.16165400f, 
    0.08094448f, 0.05567991f, -0.07618507f, 0.00198021f, 0.06329027f, -0.10219462f, 0.02367300f, -0.02411946f, 
    -0.20205133f, 0.14304946f, 0.30578825f, -0.13631839f, -0.14595099f, -0.12898530f, -0.01633496f, 0.17805731f, 
    -0.12608334f, -0.03256583f, 0.01702363f, 0.17729060f, -0.06519000f, 0.16283262f, 0.36661637f, 0.04923932f, 
    0.45071065f, -0.02946209f, 0.37174383f, -0.21949536f, 0.26181048f, -0.42416477f, -0.00784436f, 0.07915337f, 
    0.21029845f, -0.03305038f, 0.01831238f, -0.03817634f, 0.33807904f, -0.14589067f, 0.19272056f, -0.04678521f, 
    0.51640666f, 0.22630395f, 0.00058326f, -0.13745488f, 0.03567784f, 0.20212846f, -0.02238657f, -0.16165200f, 
    -0.01645033f, -0.09445594f, -0.12826794f, -0.13808058f, -0.47685966f, 0.01829207f, 0.38112658f, -0.12031756f, 
    0.21005192f, -0.03433380f, -0.03560216f, 0.03635510f, 0.31615824f, 0.23558274f, 0.08155376f, -0.38494211f, 
    -0.19356982f, -0.02089923f, -0.12085773f, -0.11576734f, -0.01198219f, 0.08974763f, 0.41692132f, 0.03994383f, 
    0.00684412f, -0.21622780f, 0.15306385f, -0.10317650f, 0.17056388f, -0.05149473f, -0.11235408f, -0.14840797f, 
    0.11326809f, 0.14920908f, -0.13310701f, -0.14798759f, 0.04193573f, 0.11522332f, 0.16837189f, -0.11997239f, 
    -0.01894053f, 0.06065967f, -0.24992400f, -0.11954514f, -0.06531164f, 0.06482001f, -0.05966119f, -0.04270691f, 
    -0.04941374f, 0.09760556f, 0.30089137f, 0.11412383f, 0.17585275f, -0.16804019f, -0.15507808f, -0.12492360f, 
    -0.30183244f, 0.12505591f, 0.31024271f, -0.13096838f, 0.30539420f, 0.31281027f, 0.01519534f, -0.09509966f, 
    0.05235203f, 0.14611307f, 0.02738755f, 0.26269671f, 0.11270082f, -0.13326742f, -0.36263373f, -0.12816846f, 
    0.18803592f, -0.08474233f, -0.09205845f, -0.10469688f, -0.33190382f, -0.10810630f, -0.16768114f, -0.06258750f, 
    0.06375501f, 0.05876926f, -0.25954956f, -0.11600436f, 0.21096756f, 0.05053911f, -0.36016241f, -0.01617103f, 
    0.24038257f, -0.15100588f, 0.24067371f, -0.06019137f, -0.24438408f, -0.02848919f, -0.00174398f, -0.11657383f, 
    0.16157490f, 0.08630245f, 0.00719423f, 0.12046100f, 0.08695372f, 0.07976711f, 0.13450296f, -0.13771068f, 
    0.27982301f, -0.06050225f, -0.06142535f, -0.23265849f, 0.28053275f, 0.24875411f, -0.13674477f, 0.10533709f, 
    0.17495298f, -0.01870242f, -0.38843229f, -0.13754167f, -0.09793425f, -0.15453835f, 0.22378334f, -0.02414053f, 
    0.15498865f, -0.03643511f, -0.06936294f, 0.02257369f, -0.22360899f, -0.03319490f, 0.04410337f, 0.05699935f, 
    -0.00154623f, -0.14787647f, -0.09520545f, -0.05349859f, -0.05795814f, -0.13801792f, -0.12001928f, -0.01290469f, 
    -0.17342952f, 0.01738560f, 0.08583002f, -0.07354728f, -0.00666492f, -0.22506317f, 0.09487039f, 0.03927648f, 
    -0.13283287f, -0.02816120f, 0.07183693f, -0.10992961f, -0.14705692f, -0.06498320f, 0.22411114f, 0.11159215f, 
    0.06925603f, 0.24351755f, -0.00898384f, -0.10681453f, 0.15229535f, -0.04119268f, 0.12995787f, -0.06896750f, 
    -0.09243116f, 0.04112075f, -0.13398691f, -0.17843586f, -0.47346750f, -0.02202984f, 0.27055338f, -0.14640781f, 
    -0.47260815f, -0.02175184f, 0.24555914f, 0.00438136f, 0.30864662f, -0.18470372f, 0.09497838f, -0.12577081f, 
    -0.00781505f, -0.05364556f, 0.27035764f, -0.06338073f, -0.08763210f, 0.14482017f, 0.36914515f, 0.02648535f, 
    -0.08554430f, 0.01861568f, 0.25573686f, 0.15119363f, -0.15982910f, -0.14878923f, 0.02065826f, 0.30715758f, 
    0.13453689f, 0.13673702f, 0.07111356f, 0.06058392f, 0.00342385f, 0.10068519f, -0.27323279f, 0.05324602f, 
    0.02282028f, 0.06337073f, -0.10044859f, -0.17378877f, 0.06262504f, 0.22213860f, 0.13934770f, 0.08083441f, 
    0.02791420f, -0.02860483f, 0.13247803f, -0.16076626f, -0.07366213f, 0.06417416f, -0.05638221f, 0.18043166f, 
    -0.40513915f, -0.14810456f, 0.01290558f, -0.08612648f, 0.09096558f, -0.00784359f, -0.01669056f, -0.28253758f, 
    -0.16951820f, -0.02319774f, 0.05984263f, -0.12631190f, 0.11499216f, 0.10689141f, 0.08958656f, -0.15379888f, 
    -0.13911888f, -0.08556421f, -0.25882259f, -0.23368359f, 0.08562760f, -0.18557222f, -0.05604157f, -0.08190344f, 
    0.11095037f, 0.11054762f, 0.23615864f, -0.14825030f, -0.11599814f, 0.02517186f, 0.02378883f, -0.13190518f, 
    0.22039363f, -0.19586545f, -0.23266309f, -0.01888090f, -0.15899205f, -0.01110433f, 0.11689486f, 0.01590102f, 
    -0.02003960f, -0.03220863f, -0.04755014f, -0.17956440f, -0.30102119f, -0.04384724f, -0.13480203f, -0.01346244f, 
    -0.04343452f, -0.04103641f, 0.15790309f, 0.14635980f, -0.05195447f, 0.07623339f, 0.07991295f, 0.16478123f, 
    0.00132975f, 0.01041820f, -0.14252701f, -0.12547778f, -0.05775898f, -0.03335700f, -0.09167256f, -0.04840827f, 
    0.03390538f, 0.11140806f, 0.22661951f, 0.06658905f, 0.20526354f, -0.06087810f, 0.00140071f, 0.11717539f, 
    -0.15258823f, 0.04413747f, 0.16118744f, 0.03521861f, -0.10711292f, -0.09750096f, -0.03038490f, -0.16072020f, 
    -0.30478740f, 0.14865980f, -0.14265646f, 0.03135490f, 0.37034434f, 0.37123936f, 0.03004358f, -0.12436995f, 
    -0.11167683f, -0.02562967f, -0.00878110f, 0.00744383f, -0.23990971f, 0.11888000f, 0.25461352f, 0.16178469f, 
    0.20654331f, 0.23810573f, 0.02847665f, -0.02874725f, 0.04912749f, -0.17187449f, -0.06465858f, 0.06821793f, 
    -0.05422661f, 0.05927502f, -0.05831728f, 0.02622955f, 0.23280406f, -0.05325979f, -0.36287403f, 0.10750284f, 
    0.14691067f, -0.11938225f, -0.53918087f, 0.15881999f, -0.12376133f, 0.12325834f, -0.10629886f, 0.13393538f, 
    0.09306082f, 0.01022687f, -0.04949388f, -0.04806888f, -0.11371741f, 0.13969035f, 0.20200859f, -0.05334063f, 
    -0.04043796f, 0.05342386f, 0.06746720f, -0.16034611f, 0.18407606f, -0.01194932f, -0.02224826f, 0.07846282f, 
    -0.07822897f, -0.01307716f, 0.13066684f, 0.05463633f, 0.07679447f, 0.03336728f, -0.32726672f, 0.09007377f, 
    0.06889872f, -0.13110842f, -0.48022348f, -0.18290532f, 0.25909540f, 0.34163389f, 0.17479458f, 0.07079396f, 
    0.01581876f, -0.10010508f, 0.17206781f, 0.01740918f, -0.21601349f, -0.14835009f, 0.22577955f, 0.10728022f, 
    0.32496300f, 0.18111686f, 0.16872402f, 0.00931504f, 0.28866148f, -0.08380371f, -0.11270311f, -0.22204304f, 
    -0.13602024f, -0.13377485f, 0.15800671f, 0.29944870f, 0.30281693f, -0.07757979f, 0.21881382f, 0.08012863f, 
    -0.01094425f, 0.15401679f, -0.15465903f, 0.29570502f, -0.27177569f, 0.08072806f, -0.00418241f, -0.27565759f, 
    -0.23205283f, -0.01473090f, -0.11865209f, 0.08320618f, -0.06491024f, 0.07589333f, -0.02351776f, 0.09836821f, 
    -0.22309221f, 0.00108253f, -0.12421884f, 0.14029209f, 0.03150778f, -0.20981857f, -0.12433155f, -0.05092015f, 
    -0.03605007f, -0.13446562f, 0.12153940f, -0.07853112f, -0.17563538f, 0.05969136f, -0.02793864f, 0.01900887f, 
    0.02964589f, -0.15127933f, 0.02580747f, 0.00691930f, 0.09133425f, 0.00242124f, 0.13749403f, -0.00248779f, 
    -0.06496728f, 0.01229917f, -0.18473242f, 0.04537793f, 0.11645411f, -0.17892158f, -0.21937884f, -0.13291383f, 
    0.22457203f, 0.05415349f, -0.00695925f, 0.02067240f, -0.14159007f, -0.18155260f, -0.21728034f, 0.16460378f, 
    -0.00458102f, 0.04947193f, -0.02068539f, -0.21444079f, -0.03310814f, 0.18130398f, -0.12955914f, 0.12577091f, 
    -0.19274500f, 0.12057487f, -0.01863909f, -0.08582770f, -0.06347197f, 0.21096143f, -0.00016777f, 0.03439144f, 
    0.05354493f, -0.09639884f, 0.09175729f, -0.08825815f, -0.06254438f, 0.10750493f, 0.18028031f, 0.02056166f, 
    -0.32916290f, -0.32138711f, 0.38383016f, 0.09644012f, -0.24562272f, -0.04467725f, 0.17433326f, -0.06280237f, 
    0.02671236f, -0.10438598f, -0.15659612f, 0.11072064f, -0.20086111f, -0.04094743f, 0.00587152f, 0.12022930f, 
    -0.12550044f, -0.01705544f, 0.20865694f, 0.10937459f, 0.34141752f, 0.28598884f, -0.15245634f, -0.12798101f, 
    0.13942139f, 0.14283390f, -0.11058959f, 0.16170907f, 0.03605055f, -0.17037679f, 0.04017865f, 0.10333475f, 
    -0.22230881f, -0.10754115f, 0.06083247f, 0.16774885f, 0.12587075f, -0.35089952f, -0.02306932f, 0.20305496f, 
    -0.09033809f, 0.08576106f, 0.04138792f, -0.07526486f, 0.11224713f, 0.00061965f, 0.17854494f, 0.14757435f, 
    -0.02508582f, 0.14751650f, -0.11823903f, 0.09406981f, -0.07630013f, -0.29059225f, 0.07615684f, 0.19036593f, 
    -0.06953255f, -0.13176091f, 0.10359824f, -0.03129432f, -0.30003631f, 0.00652172f, -0.21266814f, -0.14712891f, 
    0.18740372f, 0.19963302f, -0.16131462f, 0.03261550f, -0.04136315f, 0.16798998f, 0.17202522f, 0.12418198f, 
    -0.04648281f, -0.06135034f, 0.09491075f, -0.05105988f, 0.50614935f, -0.12651163f, -0.27084759f, 0.16283447f, 
    0.38143337f, 0.03027650f, -0.23811401f, 0.13172892f, 0.28977966f, -0.21629584f, 0.15783149f, 0.01678589f, 
    0.01690336f, 0.06518526f, -0.35588643f, -0.00219033f, 0.08202726f, 0.01577468f, 0.17546032f, -0.00848149f, 
    0.25818482f, 0.08380706f, 0.04579091f, -0.04176499f, -0.16074257f, 0.01270355f, 0.12638429f, -0.05201311f, 
    0.00185109f, 0.12928651f, 0.03324461f, 0.19960989f, 0.19065490f, -0.10292307f, 0.11111028f, 0.01744521f, 
    -0.12736674f, 0.03474249f, -0.25088152f, -0.25818199f, -0.19657639f, 0.02364509f, -0.13258098f, -0.33957753f, 
    -0.16668473f, 0.07144207f, 0.13921791f, 0.13256520f, -0.06168163f, -0.01879678f, -0.22104247f, -0.00380276f, 
    0.12536861f, 0.19685878f, -0.19939004f, 0.08944888f, -0.05800837f, -0.26259932f, -0.16218355f, 0.25745153f, 
    -0.02267581f, -0.10850108f, -0.07220796f, -0.07403974f, -0.00057857f, 0.10078783f, 0.09885170f, -0.16849029f, 
    -0.05190264f, -0.01527620f, -0.00422212f, -0.00394089f, 0.13265517f, 0.41116700f, 0.12862629f, 0.05764005f, 
    0.07472925f, 0.15496251f, 0.13608032f, -0.11332548f, 0.04189741f, 0.01919242f, -0.14851321f, -0.05845993f, 
    -0.12955357f, -0.17602475f, -0.23366629f, 0.11539383f, -0.06914108f, 0.16846226f, 0.34026775f, -0.08877557f, 
    -0.14617410f, -0.07561187f, -0.07796008f, 0.05785049f, 0.29853648f, 0.04507137f, -0.06014197f, 0.14847095f, 
    -0.54222852f, -0.10575173f, -0.01121379f, 0.26482287f, 0.10177894f, 0.11170467f, 0.05645600f, -0.01073266f, 
    -0.33627561f, -0.02309291f, -0.01421525f, 0.08967553f, 0.14492275f, -0.01959367f, -0.17388728f, -0.14379852f, 
    0.40360436f, -0.08898362f, -0.42693928f, -0.16492346f, -0.11761345f, -0.23389825f, 0.25411737f, -0.17003006f, 
    0.13929379f, -0.02753331f, 0.05823087f, -0.04705270f, 0.28192601f, -0.14683793f, 0.15790476f, 0.07829846f, 
    -0.08056270f, -0.08831718f, -0.12257642f, 0.04972346f, 0.19341014f, 0.16904745f, -0.11387414f, -0.06721851f, 
    -0.15570228f, 0.07489754f, 0.15204415f, -0.12998845f, 0.11449181f, -0.01823526f, 0.16195931f, 0.13860792f, 
    -0.02292113f, -0.01921958f, -0.20100081f, -0.10216840f, -0.17403315f, 0.14535928f, 0.27789527f, 0.08480103f, 
    -0.03150904f, 0.11624003f, -0.12218885f, 0.21126658f, 0.15295571f, -0.00006790f, 0.13814296f, 0.09809671f, 
    0.31020492f, -0.14389348f, 0.25783235f, -0.35058692f, -0.12763156f, 0.44149753f, -0.11584700f, -0.18573964f, 
    -0.11979583f, -0.16667764f, 0.17043205f, 0.11058737f, 0.25336319f, 0.15927067f, -0.24566457f, -0.05806978f, 
    -0.05168229f, 0.33681214f, -0.04541278f, -0.01805527f, -0.13842973f, 0.35902047f, 0.30152836f, -0.20577505f, 
    -0.12178395f, -0.12117755f, 0.03489314f, -0.08036856f, -0.42272881f, 0.15318170f, -0.13191444f, -0.11030308f, 
    -0.08037209f, -0.07285504f, -0.08361907f, -0.22975022f, 0.05962819f, -0.10704827f, 0.08995859f, -0.00026849f, 
    0.16179898f, -0.11440302f, 0.05549664f, -0.03478844f, 0.02091215f, 0.02826096f, 0.13519071f, 0.10080343f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.13587256f, 0.16494972f, -0.00098100f, 0.28043538f, -0.05162130f, 0.05039337f, -0.12083776f, 0.05216290f, 
    0.11987835f, 0.20170102f, 0.17774275f, -0.08386458f, 0.08685110f, -0.15963013f, 0.17949204f, 0.07377633f, 
    -0.14547177f, -0.06667349f, 0.30236629f, 0.08408079f, 0.21450768f, 0.11156286f, 0.11484022f, -0.15363079f, 
    0.07340936f, -0.06632957f, -0.08886899f, 0.05097983f, -0.01877772f, -0.05907779f, 0.01003081f, 0.03045513f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.30372873f, -0.65520370f, 0.03223148f, -0.35124290f, 0.19355561f, -0.05907262f, -0.21972702f, 0.18407893f, 
    -0.18917763f, 0.10340930f, -0.14158957f, 0.38198304f, -0.08091275f, -0.12662259f, -0.15528791f, -0.16790108f, 
    0.13912557f, -0.33409679f, -0.33623672f, -0.23005997f, -0.03008412f, -0.42487472f, -0.01064343f, 0.35715693f, 
    -0.17194474f, -0.41309798f, -0.01058940f, 0.15962504f, -0.22840092f, -0.08052828f, 0.07992695f, -0.35890785f, 
    -0.23251417f, -0.12448205f, -0.01754460f, 0.08599760f, 0.06932911f, 0.15342700f, -0.14542376f, 0.11127777f, 
    -0.62427860f, -0.07108275f, 0.22842689f, -0.37920061f, -0.01742184f, -0.36155412f, 0.12646975f, -0.23825830f, 
    0.01440671f, 0.16760561f, 0.30061340f, 0.08614935f, -0.12983358f, 0.02740805f, 0.10377651f, 0.24759071f, 
    -0.05457805f, 0.01983531f, -0.45603299f, 0.13890974f, 0.20318770f, -0.31770009f, 0.06520839f, -0.26895785f, 
    0.27589294f, 0.19307789f, -0.04020655f, -0.09380869f, -0.13883932f, -0.37423950f, -0.10369683f, 0.21336623f, 
    0.13058156f, 0.14431521f, -0.04569765f, -0.08246373f, -0.11879513f, -0.25883275f, 0.03676973f, -0.25514260f, 
    -0.35478121f, -0.69906563f, -0.14070277f, -0.40193763f, -0.02235820f, 0.01462984f, 0.14309481f, -0.72026652f, 
    -0.44574633f, 0.16821478f, -0.27108315f, -0.04004832f, -0.71377140f, 0.15367548f, 0.17692780f, -0.19948906f, 
    -0.08461998f, 0.25737482f, -0.57403904f, -0.25327498f, 0.20148201f, -0.27256235f, -0.09184901f, -0.02470053f, 
    0.04903911f, 0.01350999f, -0.35079274f, 0.00897100f, 0.01660176f, -0.18703762f, -0.16314851f, -0.43941906f, 
    -0.21704391f, -0.09915250f, -0.09852253f, -0.27167711f, 0.16611893f, 0.01180418f, -0.65234214f, -0.18094070f, 
    -0.43848288f, -0.09870538f, -0.08974262f, -0.32714719f, 0.15939286f, 0.25537807f, 0.06882059f, -0.74213803f, 
    -0.51370400f, -0.02627840f, 0.07072335f, -0.29615751f, 0.10030437f, -0.05413020f, -0.03155774f, 0.03451530f, 
    0.04179817f, -0.07413316f, -0.47986943f, -0.08625355f, -0.05305635f, 0.32488385f, 0.15234491f, 0.09904785f, 
    0.15728629f, -0.27970263f, 0.02247984f, -0.01802233f, -0.31403771f, -0.00131700f, -0.04644642f, -0.08690216f, 
    0.23388262f, -0.34952632f, -0.37340793f, -0.24624141f, 0.08923054f, 0.16576920f, 0.06971686f, 0.19321057f, 
    -0.06524955f, -0.24899913f, -0.17659912f, 0.34153232f, 0.01943136f, -0.23878904f, -0.14226624f, 0.06322823f, 
    0.12593625f, -0.08062762f, 0.01654773f, -0.48009664f, -0.10297763f, 0.15210956f, -0.27365783f, -0.02987742f, 
    -0.07918480f, 0.08939672f, -0.18928201f, -0.09008122f, 0.07937521f, -0.25990552f, -0.04712628f, -0.23122160f, 
    -0.00368600f, -0.52203572f, 0.19832894f, 0.03631998f, -0.23878334f, -0.29869103f, 0.18200380f, 0.15973985f, 
    0.29173669f, 0.18387057f, 0.01154390f, -0.12467515f, -0.60888833f, 0.29334152f, 0.03194920f, -0.05260148f, 
    0.05287587f, 0.16519023f, -0.08260894f, 0.18402320f, -0.04681443f, -0.09844363f, -0.10972629f, 0.18225299f, 
    -0.03463132f, -0.27970007f, 0.20184405f, -0.02429136f, -0.33102781f, 0.06351802f, -0.19902986f, -0.82019526f, 
    -0.49307245f, 0.24278454f, -0.12181722f, -0.23599035f, -0.38632420f, -0.20145008f, -0.42556497f, 0.26317221f, 
    -0.28226095f, 0.14903238f, -0.25398970f, -0.30329913f, -0.36666325f, -0.22239277f, -0.28524244f, -0.54852533f, 
    0.22095354f, 0.11014447f, -0.21601735f, 0.08456445f, 0.03973094f, -0.10132429f, 0.06712290f, 0.02501594f, 
    -0.13461231f, 0.13369016f, 0.14649908f, 0.12830411f, 0.08446107f, -0.10437565f, -0.10640357f, 0.12733504f, 
    -0.02777842f, -0.04471608f, -0.06028382f, -0.07469922f, 0.18821853f, 0.17921118f, 0.09595823f, -0.11801001f, 
    0.11804333f, 0.12668626f, -0.35129628f, 0.18693079f, 0.09836534f, -0.15195298f, -0.05969404f, -0.58327532f, 
    -0.04079404f, -0.03998268f, 0.34328699f, 0.11941078f, -0.19633824f, -0.64797664f, -0.16731855f, -0.24811326f, 
    0.11121626f, -0.07890617f, 0.17206730f, -0.10235877f, 0.35522014f, 0.10172228f, -0.38009650f, -0.56656575f, 
    -0.38996875f, 0.08026056f, -0.08322049f, -0.24602361f, -0.14445481f, -0.34570900f, -0.36401379f, -0.52962166f, 
    0.04155917f, 0.04685200f, 0.34460899f, -0.06462154f, -0.25608751f, -0.48516566f, 0.07418039f, 0.00454937f, 
    0.25304526f, -0.19319303f, -0.31676099f, 0.00736659f, -0.14788748f, 0.10926576f, 0.00841350f, -0.28821445f, 
    -0.12611121f, -0.04437195f, -0.22221468f, -0.10885613f, -0.68086457f, -0.25246832f, -0.49221143f, 0.11702996f, 
    -0.58911127f, 0.03944312f, -0.37526110f, 0.13577643f, -0.21720955f, -0.02467481f, -0.06533612f, 0.14592697f, 
    0.00632532f, 0.01623212f, -0.02183739f, 0.03359867f, -0.15157346f, -0.11288408f, -0.56694925f, -0.24523367f, 
    -0.34516457f, -0.28801504f, 0.13008121f, -0.39005795f, -0.07296091f, -0.54769832f, -0.37011516f, -0.37528551f, 
    -0.07163315f, -0.43416208f, -0.23507044f, -0.19391419f, -0.11976542f, -0.06513422f, -0.13025449f, -0.72125053f, 
    -0.36115152f, 0.24988337f, 0.55883789f, -0.25430405f, 0.31134906f, 0.22924887f, 0.29929867f, 0.27932686f, 
    0.21542662f, 0.04203768f, -0.15201256f, 0.11103555f, 0.10125499f, 0.42024323f, -0.23118889f, -0.16065693f, 
    0.07134593f, -0.50317174f, -0.28473318f, -0.59030527f, -0.16065943f, 0.14417009f, -0.27084830f, -0.13368748f, 
    0.04328485f, 0.00131925f, 0.12393966f, -0.25155362f, 0.17255856f, 0.08759796f, -0.06630308f, -0.06122281f, 
    -0.39343259f, 0.09149698f, -0.19312711f, -0.02186808f, -0.27382407f, 0.00969957f, -0.46764356f, -0.13516720f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.27178675f, 0.31968653f, 0.25108668f, -0.07299093f, -0.00023763f, 0.04326197f, -0.04015819f, -0.09462741f, 
    -0.04516168f, 0.06651096f, -0.12687746f, -0.21124792f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
