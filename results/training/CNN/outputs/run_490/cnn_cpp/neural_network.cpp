#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.11419463f, 0.87260944f, -0.91746002f, -0.35294774f, -0.87272644f, 0.88720363f, 0.49355122f, 0.52045780f, 
    1.14928889f, 0.09199664f, -0.03310910f, -0.19853248f, -0.50460285f, -0.14045343f, 0.31545466f, 0.26900214f, 
    -0.22897123f, -0.29569432f, 0.15423021f, 0.26993346f, -0.17849940f, 0.06057337f, -0.13171232f, -0.31406143f, 
    -0.10248847f, -0.62139601f, 0.02982080f, -0.97915274f, -0.77392286f, -0.49820960f, 1.02619898f, -0.59442925f, 
    -0.22388081f, 0.18651266f, 0.35283238f, -0.35684788f, -0.55164862f, 0.01956983f, -0.36993450f, -0.36550409f, 
    0.32924789f, 0.37060329f, 0.34090909f, 0.12514080f, -0.03417785f, 0.05354932f, -0.23333205f, -0.01867601f, 
    0.10030632f, 0.21385361f, 0.28269258f, 1.04341972f, 1.14716029f, -0.95579469f, 0.97712761f, 0.51658708f, 
    -0.22005674f, 0.43303999f, 0.07546793f, 0.28396672f, 0.03890704f, 0.40592283f, 0.02876222f, 0.35620910f, 
    -0.48369232f, -0.17664158f, 0.16829310f, -0.23902041f, -0.03200506f, -0.31156701f, 0.09121531f, 0.11510427f, 
    0.11652253f, 0.00715765f, 0.35261658f, -0.29168624f, 1.09040248f, 0.67356390f, 0.00951373f, 0.06694902f, 
    0.77130556f, -0.30194983f, -0.75430709f, 0.33613291f, -0.55627215f, 0.42911330f, 0.28075713f, 0.16199452f, 
    0.28922769f, -0.28419253f, 0.23944715f, 0.14688639f, 0.18392552f, 0.34392938f, 0.28651485f, -0.06923214f, 
    -0.59319359f, -0.03533681f, -0.11399441f, 0.03067834f, 0.05088563f, 1.27588367f, -0.76355070f, 0.98900622f, 
    0.62169749f, 0.02013704f, 0.69322449f, 0.02074824f, 0.32029587f, 0.49261650f, -0.04839630f, -0.44712153f, 
    0.20577787f, -0.52310622f, 0.17462443f, -0.00300840f, -0.03859084f, -0.13526258f, -0.23318493f, -0.38180777f, 
    0.08994356f, -0.07693765f, -0.20008731f, 0.15390275f, 0.14629707f, 0.91483843f, 1.20197177f, 1.07505500f, 
    0.73322088f, 0.19684201f, -0.23292361f, 0.33869472f, -0.74584174f, -0.12142520f, 0.12451381f, 0.25790402f, 
    -0.11569975f, -0.20139220f, 0.17337181f, -0.31577262f, -0.33452061f, -0.26044619f, 0.47775644f, -0.41528592f, 
    -0.45198312f, -0.17657559f, 0.00241083f, -0.01852605f, -0.03457240f, 0.00543895f, 0.95930117f, 0.57650846f, 
    -0.12498207f, -0.87089527f, -0.07730482f, 0.33079273f, 0.52369469f, 0.46264651f, -0.37912753f, 0.24231015f, 
    -0.05022161f, 0.66084021f, 0.11957360f, 0.25673610f, 0.45003968f, 0.05197567f, -0.09877311f, 0.11470059f, 
    0.39894697f, 0.07933047f, 0.58045077f, 0.27077010f, -0.06497744f, 0.13808939f, -0.11670998f, 0.17338982f, 
    -0.78142560f, -0.85820395f, -0.52629077f, -0.57592970f, -0.37714219f, 0.89499372f, 0.39808816f, 0.07792308f, 
    0.20163378f, 0.14722271f, -0.03413795f, -0.32677266f, 0.22153765f, -0.01132730f, -0.24189340f, 0.16945077f, 
    0.06228351f, -0.01349830f, 0.05734133f, -0.04462776f, -0.06396382f, 0.44752297f, -0.18782981f, 0.21749383f, 
    0.54228342f, 0.50543982f, 0.52048230f, 0.06925183f, 0.43753383f, -0.84212554f, -0.73939693f, -0.30466649f, 
    -0.35084084f, -0.93161732f, -0.17458156f, 0.13332599f, 0.32699427f, 0.04838888f, 0.49426281f, -0.08255767f, 
    -0.02808007f, -0.08066849f, -0.46731430f, 0.59748650f, -0.37316635f, 0.33204132f, -0.16030093f, 0.03555015f, 
    0.07664499f, 0.70932245f, -1.99736464f, 0.70807791f, 0.27537879f, 0.45110351f, 0.40294218f, 0.59366387f, 
    0.64176118f, 0.09491967f, -0.10776106f, 0.11391636f, 0.41262019f, -0.03754911f, 0.41481316f, -0.02183713f, 
    -0.16416477f, -0.19690457f, 0.08352566f, 0.18008055f, 0.22093527f, -0.02421840f, 0.12603067f, 0.18103300f, 
    0.00950336f, 0.25083950f, 0.20254505f, -0.30124351f, 0.01804605f, 1.18550897f, 0.91821033f, 0.53063303f, 
    0.87057805f, 0.79104984f, 0.40278211f, 0.39533040f, -0.01189959f, -0.53971952f, -0.02144569f, -0.13805710f, 
    0.12074164f, -0.14646511f, -0.04941862f, 0.13799345f, -0.26262328f, 0.00954983f, 0.50038505f, 0.34561914f, 
    -0.21492478f, 0.26955992f, -0.13143203f, -0.47594956f, -1.02840555f, 0.33309186f, -0.24946281f, -0.75238019f, 
    -0.36686498f, -0.54996610f, -0.59307218f, -0.96780503f, 0.00329565f, -0.52231282f, 0.06234805f, -0.42259836f, 
    -0.36742434f, -0.41980362f, -0.27881941f, -0.21210988f, 0.33778581f, 0.29217184f, -0.32575193f, 0.08712553f, 
    0.18574372f, -0.04037089f, 0.10676692f, -0.04030716f, 0.64304304f, -0.32506317f, -1.21420860f, -0.97761095f, 
    0.73530537f, 0.74003595f, -0.30369264f, 0.03701362f, 0.76906574f, 0.33624059f, -0.68214959f, 0.06620530f, 
    0.11284166f, -0.15868178f, -0.43983471f, -0.33912963f, 0.10900069f, 0.16859142f, 0.13469900f, 0.12469944f, 
    -0.00378431f, -0.23262051f, -0.36804277f, 0.22149180f, 0.00204420f, -0.42149127f, 0.35161477f, 0.87803191f, 
    1.08320057f, 0.43632767f, -0.83390981f, -0.60188466f, -0.66967696f, -0.66696811f, 0.13309163f, 0.24807836f, 
    0.23165163f, 0.01855377f, 0.06681560f, 0.37710997f, 0.24673542f, -0.25830075f, 0.42214158f, 0.30934387f, 
    0.35647079f, 0.23375025f, 0.32939422f, 0.09103343f, 0.23057409f, 0.13429789f, -0.92218733f, 0.17831925f, 
    0.82185352f, 0.54471129f, 0.85769397f, -0.36757338f, 1.23443675f, 0.08415271f, -0.66849613f, 0.54661059f, 
    -0.24845520f, -0.05548306f, 0.61209244f, 0.06442245f, 0.27367151f, -0.03622981f, -0.03500034f, 0.24077846f, 
    0.11735269f, -0.09155246f, 0.08922505f, -0.54018271f, -0.29729772f, -0.07611938f, -0.49725640f, 1.24193621f, 
    0.80240971f, 0.57214618f, 1.24858928f, 1.10660493f, 0.53064680f, -0.10231198f, -0.05114862f, -0.50776422f, 
    -0.05305856f, -0.17759095f, 0.07848519f, -0.29694676f, 0.07302307f, -0.08058780f, -0.00588644f, 0.07646990f, 
    0.32644731f, 0.03160293f, 0.25800040f, 0.20953976f, 0.14497219f, 0.27083665f, -0.00568512f, 0.40347880f, 
    -0.04541747f, -0.97239345f, -0.81264192f, -0.43668729f, -0.33312526f, 0.15708287f, 1.09798121f, 0.20775345f, 
    0.27982560f, 0.59314090f, -0.25769460f, -0.17235728f, -0.29528135f, -0.36357674f, -0.23061176f, -0.18450397f, 
    0.22460666f, 0.05022550f, 0.29717931f, -0.22238430f, -0.00520036f, -0.03427564f, -0.34374812f, -0.00519773f, 
    0.40720230f, 0.23759198f, 0.02159382f, 0.59204227f, 1.11993682f, -1.23080015f, -0.55628645f, 0.17663234f, 
    -0.35801303f, 0.02651981f, -0.59059805f, 0.05316148f, 0.01104835f, 0.06368813f, -0.24969301f, -0.13944837f, 
    -0.64265996f, -0.25724494f, -0.16102917f, 0.32670686f, -0.09247792f, 0.00023906f, -0.30276167f, 0.02647455f, 
    -0.33888996f, -0.32120842f, -0.83354348f, 0.58351994f, 0.63427353f, -0.99683517f, 1.22531092f, 0.36778706f, 
    -0.48219749f, -0.63834345f, -0.78958726f, -0.71205217f, 0.43867934f, -0.00436180f, 0.34394225f, 0.35378781f, 
    -0.23106667f, -0.10045736f, -0.02525874f, 0.05157090f, -0.17385609f, 0.13275164f, -0.12676868f, -0.15348305f, 
    -0.00052356f, 0.15687715f, 0.21730627f, 0.19815481f, -0.84807289f, -0.68553102f, -0.79936904f, -0.13622922f, 
    0.17125608f, -0.87441623f, -0.63942903f, -0.20985231f, -0.52760750f, -0.44228837f, 0.33892804f, 0.50332218f, 
    0.26978683f, 0.17106444f, 0.46760088f, 0.37311465f, 0.41853893f, 0.33511537f, -0.16214228f, 0.07812212f, 
    0.19764629f, 0.14658067f, -0.32657799f, 0.09178241f, 0.57931113f, 0.25264671f, 0.16070931f, 0.71576917f, 
    -0.00343024f, -0.95830303f, -0.87395513f, 0.64659399f, 0.83315808f, -0.30409116f, -0.58577192f, 0.27323818f, 
    -0.26621369f, -0.33624083f, -0.07629415f, 0.12126414f, -0.06547149f, -0.21057622f, 0.33936128f, 0.00777169f, 
    0.18093181f, -0.17431779f, 0.08148135f, -0.12851986f, -0.28045788f, 0.51294219f, 0.63927269f, 0.44306391f, 
    -0.03888981f, -0.12009678f, 0.59953105f, 0.07743222f, -0.32558358f, -0.21014068f, -0.06534501f, 0.35509166f, 
    0.44737616f, -0.27179986f, -0.48818684f, -0.19382872f, -0.64975893f, -0.20788312f, -0.35636735f, -0.20261298f, 
    -0.96579647f, 0.11182195f, 0.19718519f, -0.18022875f, 0.01712942f, -0.14060773f, -0.39359343f, 0.25268877f, 
    0.07534699f, -0.75688815f, -0.52286971f, -0.10650846f, -0.40239367f, -0.40454897f, 0.40761569f, -0.50809795f, 
    -0.62401605f, 0.34092486f, -0.02814659f, 0.58177894f, -0.39846903f, -0.24271630f, 0.37367433f, -0.18388733f, 
    -0.20746008f, -0.58502632f, -0.06775417f, -0.23669858f, 0.23128757f, 0.24080892f, 0.66766697f, -0.60923129f, 
    -0.92377263f, -1.09116673f, 0.55656528f, 0.18477559f, 0.44286951f, 0.75819117f, -0.06915997f, 0.48651910f, 
    -0.00580589f, 0.32158983f, -0.01025559f, -0.53497487f, 0.21240808f, -0.16529061f, 0.24730740f, -0.39530852f, 
    -0.70169991f, -0.55276680f, -0.37074104f, -0.02075619f, 0.06671152f, 0.20134658f, 0.18573782f, -0.25924292f, 
    0.36742458f, -0.82745832f, 0.82606560f, 0.73167735f, 0.34189010f, 0.35691291f, -1.06919980f, 0.45587555f, 
    0.19869862f, -0.03246506f, 0.41870934f, -0.64541376f, -0.70135766f, -0.21794844f, -0.03145637f, 0.55876005f, 
    0.49710914f, 0.02000853f, 0.06271047f, 0.19641638f, 0.14089468f, -0.25027731f, 0.18541674f, -0.03111199f, 
    -0.34581432f, 1.03759050f, 0.99934942f, -0.20960756f, -0.67900527f, -1.16257870f, 0.40195960f, -0.48539943f, 
    -0.22362186f, -0.67792153f, 0.18597719f, 0.40929407f, 0.24076502f, 0.06627891f, 0.29358894f, -0.49662054f, 
    0.00135084f, -0.22650795f, -0.10304406f, 0.12264010f, 0.01050308f, -0.04348879f, 0.26751432f, 0.05054843f, 
    -0.33624148f, 0.08712076f, -0.78294975f, -0.64756477f, -1.22045839f, -0.58091426f, 0.63997495f, -0.42651290f, 
    0.67429864f, 0.50602710f, -0.00148441f, 0.31454015f, 0.32202253f, -0.18042326f, 0.49196056f, -0.31524786f, 
    0.22542644f, -0.34231678f, 0.10888892f, -0.11844867f, -0.09888066f, -0.09639566f, -0.11170878f, -0.12832974f, 
    -0.17431401f, -0.25223005f, -0.21635167f, -0.67035818f, -1.15050352f, -0.61835748f, -0.43098801f, -0.34962282f, 
    -1.01062608f, 0.11365476f, 0.88271570f, -0.49509683f, 0.12288464f, 0.11763143f, 0.13113475f, 0.41254872f, 
    -0.07193104f, 0.35468063f, -0.07516003f, 0.08086153f, 0.23069261f, -0.23997538f, -0.03719116f, 0.38948175f, 
    -0.30356431f, 0.13942549f, 0.23744087f, 0.02183243f, -1.18930709f, 1.16541100f, 0.14884086f, -0.96810877f, 
    -0.18787383f, -0.08244702f, 0.13048162f, 0.19884621f, 0.04722198f, 0.80076802f, 0.09420069f, 0.21085951f, 
    -0.06448085f, 0.09904096f, -0.14845486f, -0.25719455f, 0.38833579f, 0.33102217f, -0.02105081f, 0.24631707f, 
    0.25000507f, 0.23240404f, -0.02712514f, -0.31079414f, -0.08455225f, 0.72187382f, 0.31297553f, -0.73184156f, 
    -0.70806092f, -0.14082040f, -0.21131170f, -0.74984908f, -0.25890788f, -0.28149277f, -0.42381644f, -0.45586893f, 
    0.29113072f, 0.39810178f, -0.01286398f, 0.40088615f, -0.00296485f, -0.32203004f, -0.03396627f, 0.04691251f, 
    0.48614034f, 0.54077005f, 0.45487380f, -0.23837741f, -0.12320649f, 0.13493407f, -0.02154836f, 0.78554547f, 
    0.43684083f, -0.42595929f, -0.77129197f, -1.18419242f, -0.14711782f, -0.30634791f, 0.46694812f, -0.17716600f, 
    0.45618448f, -0.12863863f, -0.53732008f, -0.25398901f, 0.08171179f, -0.38121769f, 0.03764344f, 0.07588342f, 
    -0.21952944f, 0.09674730f, 0.20684977f, -0.31741834f, -0.28869680f, -0.25087079f, 0.14818530f, 0.32542267f, 
    0.31579846f, -0.73801202f, 0.15818487f, 1.29454517f, 0.74650598f, 0.03586873f, -0.99953723f, 0.12393656f, 
    0.31170645f, -0.14925592f, -0.31210592f, -0.34093389f, 0.47222117f, 0.30635694f, 0.04144058f, 0.05200597f, 
    0.05047571f, 0.16489443f, -0.08110082f, 0.36243027f, 0.29220015f, 0.18511678f, -0.30699706f, -0.37246785f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.40931761f, 0.02315001f, 0.15262797f, -0.01423691f, 0.00324656f, 0.25865293f, 0.40222275f, 0.29440990f, 
    0.33717182f, 0.25958216f, 0.22575919f, 0.13483123f, 0.03115052f, 0.37044451f, 0.08945316f, 0.22187878f, 
    0.22810540f, 0.02153317f, 0.11971429f, 0.40025038f, 0.06548723f, 0.22368881f, 0.28193256f, 0.27083027f, 
    0.19579612f, 0.25883198f, 0.15959696f, 0.27767169f, 0.18366057f, 0.36967477f, 0.20529573f, 0.10403011f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16604386f, -0.08202294f, -0.02812583f, -0.36108005f, -0.07908386f, -0.08052304f, -0.01334998f, -0.00955227f, 
    -0.05946014f, -0.01772921f, 0.01179153f, 0.02821636f, 0.56458032f, -0.32058167f, -0.03008219f, -0.15430367f, 
    0.07958638f, -0.14829922f, 0.07224169f, 0.07699104f, 0.06549083f, 0.15229112f, -0.03936415f, 0.09041980f, 
    -0.20702443f, 0.06349036f, 0.17318797f, -0.45528385f, -0.09368595f, -0.05262137f, -0.04787618f, -0.05864854f, 
    0.16085656f, -0.01166476f, 0.09788045f, 0.03589391f, -0.20010205f, 0.15221037f, 0.01461187f, -0.02130087f, 
    -0.30557373f, -0.15060011f, 0.00503492f, 0.02081230f, 0.19915353f, 0.08137967f, -0.03901466f, -0.05547519f, 
    0.39922649f, 0.15267566f, 0.21909913f, 0.17585033f, -0.25889069f, -0.07324298f, 0.22992414f, -0.08991446f, 
    -0.02049837f, 0.13267982f, 0.05880655f, 0.01304957f, 0.17948148f, 0.13107057f, -0.13983743f, -0.02653330f, 
    -0.35268319f, -0.05176613f, -0.00383788f, 0.09303580f, -0.02630411f, 0.10260512f, -0.10533375f, -0.09818375f, 
    -0.10994298f, -0.07170829f, -0.00087170f, -0.41105384f, 0.03804914f, 0.00631940f, -0.08609351f, -0.12843136f, 
    0.00145733f, -0.01499875f, 0.03513105f, 0.00944727f, -0.24829291f, 0.15388420f, 0.12395701f, -0.44070157f, 
    -0.12423804f, 0.06807931f, 0.08983068f, -0.02406596f, -0.09266362f, -0.03557554f, -0.08144527f, -0.02969194f, 
    0.24006203f, 0.17482875f, 0.03332239f, -0.10028236f, 0.02690806f, -0.18521386f, 0.03763622f, 0.26889652f, 
    -0.08633590f, -0.18923144f, -0.22369045f, -0.17881772f, 0.06191998f, 0.04905592f, -0.14423026f, 0.04865398f, 
    -0.09837331f, 0.00705571f, -0.02525668f, -0.10562410f, 0.08898482f, 0.08720023f, -0.11551507f, 0.01329543f, 
    -0.39106074f, 0.27480969f, 0.03931455f, 0.37437931f, -0.06325323f, 0.10006075f, -0.04181988f, -0.04421248f, 
    -0.06870664f, -0.13667874f, -0.04037831f, -0.04427301f, -0.51596904f, -0.29485175f, 0.21663283f, 0.18672927f, 
    -0.17504685f, 0.06759909f, -0.10690317f, -0.01094612f, -0.09877026f, 0.26019546f, -0.15593927f, 0.04762692f, 
    0.31236187f, 0.12056395f, 0.05150946f, -0.22007723f, 0.21159756f, 0.13652091f, 0.18968642f, 0.01545057f, 
    -0.05916951f, 0.03465138f, -0.06264067f, 0.22628212f, 0.04324674f, 0.11541922f, -0.22442150f, 0.18569069f, 
    -0.03068354f, -0.03274284f, -0.00525255f, 0.02382448f, 0.08243354f, -0.07076513f, -0.08989365f, 0.02821696f, 
    -0.32946655f, -0.12269538f, 0.03819411f, 0.19321698f, -0.11326738f, -0.10405990f, -0.02249488f, -0.01467537f, 
    0.18051812f, -0.03595859f, 0.06378514f, 0.02816474f, 0.35327893f, -0.02872398f, 0.12063956f, 0.23577984f, 
    -0.33652309f, -0.07638103f, -0.01962798f, 0.06136591f, -0.07138067f, 0.01500400f, -0.05203261f, 0.01224346f, 
    0.09820242f, 0.11621419f, -0.02000235f, -0.34947118f, 0.10781174f, -0.03391230f, 0.03476756f, -0.03193133f, 
    -0.04425890f, 0.01817234f, 0.04552415f, 0.05701594f, 0.08906372f, 0.26193342f, -0.29844430f, 0.42920226f, 
    0.05444645f, 0.06365141f, 0.05623294f, -0.07734766f, -0.02345367f, 0.08162719f, -0.03378115f, -0.08263657f, 
    -0.67258400f, -0.15092014f, 0.35515988f, -0.24730970f, -0.03814581f, 0.00399064f, -0.09202799f, -0.11973027f, 
    0.13301510f, -0.06679176f, 0.04660175f, 0.03118738f, -0.06046351f, -0.24614403f, 0.35273564f, -0.06939749f, 
    -0.04381433f, 0.00394732f, 0.08336136f, -0.14159939f, -0.08450718f, -0.03883881f, -0.09482933f, 0.02856727f, 
    0.26438317f, -0.10525756f, -0.07649595f, 0.28347614f, -0.02218382f, -0.17194231f, -0.10843228f, -0.05756966f, 
    0.09050511f, -0.13547197f, 0.24778697f, -0.04256794f, -0.10891134f, -0.06518459f, -0.07238130f, -0.07512712f, 
    -0.23598436f, 0.06184991f, 0.09368640f, -0.13062733f, -0.21911934f, 0.11482666f, 0.00377809f, -0.08219954f, 
    -0.34206820f, 0.02783081f, 0.13298073f, -0.01155711f, 0.08351168f, 0.11121971f, 0.04620820f, -0.09879183f, 
    0.04661482f, 0.10494630f, -0.13000026f, -0.11341451f, 0.04600410f, 0.20288846f, 0.04199285f, 0.02091339f, 
    0.11301229f, 0.17717853f, -0.12560394f, 0.03238520f, -0.02061941f, -0.01124658f, 0.10740424f, -0.10235564f, 
    0.11912408f, -0.16682968f, -0.04754051f, 0.34252983f, -0.11354893f, 0.04993058f, 0.16554077f, -0.06585237f, 
    0.00349119f, -0.10261293f, 0.04264875f, -0.02746641f, -0.33218130f, 0.03208763f, 0.08133608f, -0.40732968f, 
    -0.05207159f, 0.14635761f, -0.03803087f, 0.01583644f, -0.19481076f, -0.07385269f, -0.12177639f, 0.08943772f, 
    -0.28284165f, 0.37424943f, -0.01484395f, -0.19182885f, 0.02781991f, 0.01225669f, 0.05312605f, -0.01025779f, 
    -0.12273515f, 0.17462528f, -0.16859967f, 0.20205611f, -0.73178303f, 0.01970115f, -0.45014051f, 0.08768252f, 
    0.06778324f, 0.03307809f, -0.14310163f, 0.08690058f, 0.07842028f, 0.02070857f, -0.07886706f, 0.09409577f, 
    0.16728996f, 0.04303617f, -0.00692048f, -0.27356163f, 0.20016092f, -0.05383438f, 0.19108589f, -0.08233470f, 
    0.04572897f, -0.10703476f, -0.02264760f, -0.16461937f, -0.00976337f, -0.07227483f, 0.08471216f, -0.41495347f, 
    0.08072873f, 0.11788248f, 0.12539417f, 0.01482566f, -0.05966377f, -0.20089675f, -0.10100742f, 0.10850883f, 
    -0.21166897f, 0.06235671f, -0.03451961f, 0.01079881f, -0.17175728f, -0.12786601f, -0.08361797f, -0.19241890f, 
    -0.09772358f, -0.01782113f, -0.01773573f, -0.05254718f, 0.07548147f, -0.06917399f, 0.35917577f, 0.12985601f, 
    -0.02024464f, 0.25172976f, 0.02885552f, -0.15465844f, 0.04095739f, 0.10208388f, 0.03365999f, 0.00778847f, 
    0.25263304f, -0.44214153f, 0.22564894f, 0.01989608f, 0.01823901f, -0.28072143f, -0.09536798f, 0.03539349f, 
    0.00288299f, 0.11824551f, -0.14147562f, 0.00884051f, -0.44579181f, 0.02487610f, 0.23743175f, -0.41010451f, 
    0.13150302f, 0.08395336f, 0.17487614f, 0.04120962f, 0.35046688f, -0.01539875f, 0.02247935f, -0.01507670f, 
    0.16289417f, 0.18656203f, 0.02774978f, 0.04578358f, -0.21142113f, 0.05051670f, 0.12095688f, 0.05588987f, 
    -0.10253081f, -0.18536012f, -0.15234986f, -0.09136268f, -0.17003900f, -0.15771839f, 0.18518727f, 0.09438214f, 
    -0.05035373f, 0.11894172f, -0.01486520f, -0.12128920f, 0.07355172f, 0.04570647f, 0.00355666f, 0.04970461f, 
    0.22995158f, -0.04521419f, -0.12941380f, 0.08992580f, 0.03916319f, 0.15709443f, -0.10953627f, 0.02876526f, 
    0.00685155f, 0.04111604f, 0.13323481f, 0.03114528f, 0.27331313f, 0.17357954f, 0.10115318f, 0.10740034f, 
    -0.26504061f, -0.12808007f, 0.07030924f, 0.02693765f, -0.00224321f, -0.18185794f, 0.12918349f, -0.03684885f, 
    0.30844715f, 0.19734702f, 0.23205620f, -0.22021464f, 0.05820912f, -0.10163974f, -0.06701089f, -0.05722529f, 
    -0.03031267f, 0.02483783f, -0.07733005f, -0.00791871f, 0.22187740f, -0.22911356f, -0.29404986f, -0.01695122f, 
    0.03347893f, 0.02922283f, -0.00353609f, -0.00578919f, 0.05333097f, -0.03121172f, 0.06573178f, 0.00689096f, 
    -0.04540053f, -0.10746369f, -0.07337989f, -0.00642535f, 0.01722845f, 0.02117368f, -0.04602690f, -0.08035268f, 
    0.08300274f, 0.12029044f, -0.01604203f, 0.13561092f, 0.23713475f, -0.22262235f, -0.00302372f, 0.07847078f, 
    -0.08463550f, 0.01443117f, 0.01144411f, 0.11631416f, -0.01347236f, -0.12301164f, 0.21426348f, 0.05298836f, 
    0.30890781f, 0.03542521f, 0.08049300f, 0.19182341f, 0.00819289f, 0.11204744f, -0.08689520f, 0.04551340f, 
    0.16176967f, 0.30518210f, 0.06256548f, 0.21579437f, -0.01386828f, -0.02186549f, -0.10840831f, 0.20148616f, 
    0.05150907f, -0.06504571f, 0.10718016f, 0.03987043f, 0.03742933f, -0.08374150f, 0.04895161f, -0.16140883f, 
    0.03000293f, -0.48749137f, 0.21471417f, -0.30818573f, 0.07528785f, -0.00358284f, -0.22989158f, 0.05771375f, 
    0.04415305f, -0.16752405f, -0.00560023f, -0.07147205f, -0.09260203f, -0.15641372f, 0.01393549f, 0.03687933f, 
    0.01192401f, -0.02037786f, -0.06001927f, 0.01918731f, -0.08727429f, 0.10826010f, 0.05762491f, 0.10835806f, 
    0.12616324f, 0.13995056f, -0.04405757f, -0.02930824f, -0.12576185f, 0.01983847f, -0.05545377f, 0.04612722f, 
    -0.15112816f, 0.09509458f, 0.15371904f, -0.11588112f, 0.21960498f, -0.02981957f, 0.19196075f, 0.39522535f, 
    -0.17377689f, 0.04992252f, 0.05639017f, 0.07510315f, -0.05251854f, 0.04458115f, 0.04058046f, -0.01080025f, 
    0.18215103f, -0.39984041f, -0.07978627f, -0.14742339f, 0.17865577f, -0.09788240f, 0.00191251f, 0.00005427f, 
    0.19321775f, -0.01593697f, -0.01041440f, -0.00043132f, -0.34524617f, -0.39196584f, -0.70240468f, -0.01950963f, 
    -0.11022381f, -0.12531427f, -0.05280514f, 0.03536993f, 0.05170329f, -0.18536644f, 0.00741888f, 0.03269955f, 
    0.21439013f, -0.02558820f, -0.12223586f, -0.29873607f, -0.03201174f, 0.06237507f, 0.10602932f, -0.04512243f, 
    -0.11674150f, 0.14885142f, -0.11191841f, -0.06837157f, 0.14082806f, 0.06578112f, 0.18111600f, -0.18450293f, 
    0.00334075f, 0.03184346f, 0.14712895f, 0.05021247f, 0.05581039f, 0.17191198f, 0.19738658f, 0.08295310f, 
    -0.02042345f, -0.15621315f, -0.03166003f, 0.21690741f, -0.16464706f, -0.16363247f, -0.08263003f, -0.04126552f, 
    -0.12424371f, -0.17295618f, -0.46816698f, 0.15496358f, -0.03744112f, 0.07451217f, 0.12189398f, 0.03808755f, 
    -0.13542177f, 0.20082304f, 0.01458871f, 0.01302468f, -0.01671930f, -0.17677127f, -0.23214178f, -0.10159414f, 
    -0.33740675f, -0.05450602f, -0.16453448f, -0.14095625f, 0.08825339f, -0.16738804f, 0.13655718f, 0.27103934f, 
    -0.02862421f, -0.26274365f, 0.07016649f, -0.22362828f, 0.20197862f, -0.07840214f, -0.18546432f, 0.05505228f, 
    0.03747966f, 0.02516940f, -0.03902310f, -0.06884488f, 0.01592029f, 0.11131885f, -0.44240999f, 0.08447736f, 
    -0.15994425f, 0.20826863f, 0.14351666f, 0.09591188f, -0.09894173f, 0.06854101f, 0.03778515f, 0.01733029f, 
    0.08750233f, 0.10174394f, -0.20705828f, -0.03890306f, 0.20574409f, -0.07518709f, -0.00904523f, -0.23412816f, 
    0.03766323f, -0.08295131f, 0.01626248f, -0.08629772f, -0.05900546f, 0.08335043f, 0.04738137f, 0.01881268f, 
    0.52851415f, 0.01223170f, -0.00976968f, -0.12017474f, 0.18229543f, 0.01507866f, 0.00520927f, 0.15303016f, 
    -0.05481707f, -0.10743278f, -0.01043578f, -0.17807700f, 0.19669887f, -0.17439084f, 0.04893282f, 0.11856098f, 
    -0.00609667f, 0.02941325f, -0.15957451f, 0.09536727f, 0.09520728f, -0.09366940f, 0.06519578f, 0.08875255f, 
    -0.55739641f, -0.01646442f, -0.13068289f, -0.31712341f, -0.12631102f, -0.00180580f, 0.02732853f, 0.05669523f, 
    0.17265017f, 0.18498728f, 0.03369177f, -0.09412505f, 0.04525129f, -0.46576953f, -0.02103573f, -0.20164393f, 
    -0.09525838f, 0.01873408f, -0.02951454f, -0.01696537f, -0.12024664f, 0.11781259f, -0.02617446f, 0.02499477f, 
    -0.37967855f, 0.02191573f, -0.60982156f, -0.38211110f, 0.08644993f, 0.06995435f, 0.05354759f, 0.16939382f, 
    0.10437295f, -0.06292164f, 0.00976183f, 0.09564124f, 0.06407072f, -0.26412484f, -0.27206978f, -0.24991560f, 
    -0.27301410f, -0.21864046f, -0.08585094f, -0.02411943f, -0.09297652f, 0.10902748f, -0.08035184f, -0.11559140f, 
    0.23316136f, 0.03315725f, -0.12245688f, 0.18956679f, -0.01256765f, -0.18668842f, 0.15026024f, 0.22300287f, 
    -0.07672569f, -0.10264295f, 0.21750136f, -0.02718179f, -0.19210342f, 0.08276568f, 0.01179301f, 0.35798243f, 
    0.15496385f, 0.06017772f, -0.09791850f, -0.10492107f, -0.02901397f, 0.14063688f, -0.08740649f, 0.09875609f, 
    0.15718371f, -0.01073133f, -0.10667730f, 0.14506665f, 0.12922575f, -0.02399527f, 0.04962020f, -0.02595079f, 
    -0.16123199f, 0.12862329f, -0.11124989f, 0.14077894f, 0.28428572f, 0.12261640f, -0.01937157f, 0.17373796f, 
    0.11159388f, 0.21144906f, 0.16474117f, -0.08133440f, -0.23500291f, -0.08393432f, 0.00625075f, -0.11571807f, 
    0.22539006f, -0.32387966f, -0.06334741f, -0.31272370f, 0.17459658f, -0.06895491f, -0.00375031f, -0.18574370f, 
    -0.00647333f, 0.09712424f, -0.00462314f, -0.01514659f, -0.04443258f, 0.03895837f, -0.12752810f, -0.08031191f, 
    0.27943361f, 0.09346423f, 0.07438046f, -0.01772656f, 0.08148818f, 0.10928538f, -0.14029650f, 0.03421646f, 
    -0.18073411f, 0.07295000f, 0.00951472f, -0.22434038f, -0.03498567f, -0.15037616f, 0.01065451f, -0.05479149f, 
    -0.19139069f, -0.14745739f, -0.00716160f, 0.01449321f, 0.27368602f, 0.03829079f, 0.19098654f, 0.32541737f, 
    -0.17179319f, -0.24214946f, -0.00713728f, 0.04491945f, -0.05434748f, -0.05975292f, -0.02561222f, 0.10190004f, 
    -0.19202095f, 0.03306144f, -0.47229007f, -0.10325527f, 0.12040795f, 0.11892299f, 0.03289021f, -0.16237313f, 
    0.02812763f, 0.03882427f, -0.15647908f, -0.10161383f, -0.01843307f, 0.04245448f, 0.02113460f, -0.14489490f, 
    -0.00687488f, 0.01494995f, -0.04726554f, 0.06287975f, -0.01888235f, -0.03165905f, -0.01915050f, -0.09727310f, 
    -0.10175335f, -0.08002172f, 0.09410144f, -0.03591606f, 0.08642518f, 0.02894698f, -0.02314013f, -0.03830511f, 
    0.13442604f, 0.01333703f, 0.07678887f, -0.02788276f, -0.27423686f, -0.41914853f, -0.13836861f, -0.35731637f, 
    -0.11122730f, 0.00763770f, -0.00237343f, -0.09305444f, 0.03848484f, 0.21587873f, -0.01117007f, 0.05859325f, 
    -0.33102164f, 0.10764229f, 0.02540811f, 0.16840889f, -0.12157068f, 0.08352274f, 0.16651122f, 0.02400866f, 
    0.01217393f, -0.03357409f, -0.08070181f, 0.13035397f, 0.22674623f, 0.13087730f, -0.15122946f, 0.06330629f, 
    0.06806957f, 0.03418787f, -0.00992273f, -0.14577158f, -0.17108564f, -0.07551210f, -0.01499883f, -0.12163244f, 
    0.30272704f, -0.14886457f, -0.10079819f, 0.01419538f, 0.04250216f, 0.04062579f, 0.08526903f, -0.07087006f, 
    0.00783357f, 0.00744659f, 0.08235949f, 0.02523953f, -0.11213236f, -0.09078782f, -0.00018112f, -0.03695847f, 
    0.22796290f, -0.06652252f, -0.00587610f, -0.07041052f, -0.02129383f, 0.05328840f, -0.03115931f, 0.02486266f, 
    0.29911280f, -0.01185210f, 0.29053205f, 0.27152833f, -0.15440384f, -0.20622234f, -0.03983879f, 0.09767517f, 
    -0.01019320f, 0.02119200f, -0.05542370f, 0.03589477f, -0.38809392f, -0.00179677f, -0.27994859f, -0.32415393f, 
    -0.15566222f, 0.01124941f, 0.00103808f, 0.00536594f, 0.11025497f, 0.20926185f, -0.05085978f, 0.03307791f, 
    0.19802101f, 0.14707331f, -0.27025005f, 0.11091108f, 0.11199434f, -0.08260665f, 0.05833043f, -0.18481889f, 
    -0.12030564f, 0.07718978f, -0.02781021f, -0.05865183f, -0.67463267f, -0.31766784f, -0.19962385f, -0.12699996f, 
    -0.04376577f, -0.11105005f, -0.14375789f, -0.17177014f, -0.03866243f, 0.00023584f, -0.18290509f, -0.08380228f, 
    -0.05253262f, 0.21823637f, -0.05726670f, 0.05319995f, -0.00127550f, 0.02968020f, 0.05142303f, 0.13576441f, 
    0.10563886f, -0.05883218f, 0.16870795f, -0.14677909f, 0.03357339f, -0.02941225f, -0.10056956f, -0.15921621f, 
    -0.08914649f, -0.04922558f, -0.03174018f, -0.07719810f, 0.01293700f, 0.23410368f, 0.11822338f, 0.06783592f, 
    -0.31284222f, 0.05338842f, -0.26299357f, -0.11870743f, 0.02638089f, 0.01022260f, -0.15348148f, -0.16194695f, 
    -0.02224152f, 0.01100941f, -0.05216685f, -0.06461211f, 0.29105866f, -0.26225734f, 0.17086373f, 0.03947657f, 
    -0.06651123f, 0.02658838f, -0.21883537f, 0.00343847f, 0.14643149f, 0.15353486f, 0.10263059f, -0.07383381f, 
    -0.40448594f, 0.06659367f, -0.24426667f, 0.06932369f, -0.18797500f, -0.02121251f, -0.17620727f, -0.12123858f, 
    -0.07885653f, -0.23350672f, -0.03266567f, -0.15265493f, -0.38911372f, 0.03269239f, 0.06767242f, -0.45237610f, 
    0.02160217f, -0.01509656f, 0.17320023f, 0.00092525f, -0.08954709f, 0.07461578f, -0.07082672f, -0.02932562f, 
    0.32389966f, 0.06858481f, 0.12575065f, 0.20727296f, -0.14144111f, 0.04957672f, -0.04313609f, 0.07606423f, 
    0.08417321f, 0.06194810f, -0.00349453f, 0.06522696f, 0.92510629f, 0.08021383f, -0.10900438f, 0.20673454f, 
    -0.23291685f, -0.15920009f, -0.08532126f, -0.03893687f, -0.00648139f, -0.04063883f, 0.02145845f, 0.00092862f, 
    0.51672113f, 0.07436323f, -0.06019933f, 0.04760278f, -0.02855258f, -0.14291321f, 0.18695869f, -0.10402501f, 
    -0.15075906f, -0.09164377f, -0.11949131f, -0.06889084f, -0.62805003f, -0.04263015f, -0.01243378f, -0.33134148f, 
    0.04042090f, -0.04996206f, -0.00107674f, -0.05316512f, 0.09094772f, 0.01015147f, -0.08740737f, 0.02382173f, 
    -0.24747078f, -0.21066609f, 0.10878932f, -0.03160390f, -0.00878844f, 0.12155005f, 0.09155889f, 0.06327567f, 
    -0.02048429f, -0.02474483f, -0.03056336f, 0.04809234f, 0.13820179f, -0.44448656f, 0.14587574f, -0.18595938f, 
    0.00489822f, 0.18343176f, -0.03944433f, -0.17589575f, 0.01340893f, -0.13774128f, 0.01488127f, -0.03924928f, 
    -0.17988306f, -0.16503577f, 0.08577777f, -0.23069902f, -0.09116530f, 0.15927471f, -0.05553041f, 0.04642682f, 
    -0.03660124f, 0.00140967f, 0.08509641f, -0.02958958f, 0.02946801f, 0.16310169f, -0.01111058f, -0.14134933f, 
    -0.18981670f, -0.18498588f, 0.05864804f, 0.07136963f, -0.08278210f, -0.04010652f, -0.20848449f, -0.02820174f, 
    -0.14828244f, -0.70213223f, -0.18424122f, -0.27762523f, -0.06263754f, 0.00179181f, 0.08913772f, -0.06280170f, 
    -0.02957641f, 0.12925151f, -0.19621284f, -0.03663399f, 0.64803880f, 0.02959503f, -0.28787318f, 0.19784166f, 
    0.17449710f, -0.02931317f, 0.06246694f, 0.21333101f, -0.03969109f, 0.07956002f, -0.04348517f, -0.07501409f, 
    -0.20468499f, 0.00921349f, -0.43772835f, -0.11870331f, -0.11889034f, -0.11414599f, 0.09459079f, 0.03050227f, 
    -0.00335482f, 0.00792793f, -0.06832758f, 0.02303707f, -0.17111008f, -0.43438417f, -0.31026769f, 0.25301275f, 
    -0.12513188f, 0.09967662f, -0.05368022f, -0.06511663f, 0.09553986f, 0.03316654f, 0.10310771f, -0.00215774f, 
    -0.20573731f, -0.35851598f, -0.04363903f, -0.06418307f, -0.18943638f, 0.01451249f, -0.07678384f, 0.12093842f, 
    -0.10996757f, -0.10068209f, 0.05291592f, 0.11736130f, 0.06170168f, -0.16923766f, -0.11221116f, -0.03626699f, 
    -0.15706225f, -0.09526535f, 0.00835421f, 0.04351986f, -0.05714512f, 0.06442878f, -0.15530789f, 0.07363315f, 
    0.05381393f, -0.04426110f, 0.06693600f, 0.05220614f, 0.08767112f, 0.08055817f, 0.00498610f, -0.02824174f, 
    0.04987463f, -0.00505642f, 0.08226795f, -0.16237317f, 0.13438034f, -0.02436331f, -0.04183919f, 0.04227624f, 
    -0.10744088f, 0.09113695f, -0.07677405f, 0.02853659f, -0.02302389f, -0.05334026f, -0.00568852f, 0.05249966f, 
    -0.58624649f, -0.06432772f, -0.15436277f, -0.16057192f, -0.16865340f, -0.01489902f, 0.09396337f, -0.11249974f, 
    -0.06662895f, 0.05704059f, -0.03372798f, -0.16816500f, 0.09913150f, 0.28380489f, 0.19322504f, 0.01994212f, 
    -0.07597015f, -0.01434477f, -0.06177849f, 0.08982869f, 0.06504662f, 0.09366670f, -0.10700066f, 0.13410559f, 
    -0.16072944f, 0.17473701f, 0.08384783f, -0.01946752f, -0.21388143f, -0.11740596f, 0.11668352f, -0.10270936f, 
    -0.05882043f, 0.14189664f, 0.06393251f, 0.05112002f, -0.50149089f, -0.09636199f, 0.14380644f, 0.29629710f, 
    0.18020523f, 0.09342437f, -0.05652498f, -0.13191848f, -0.15662093f, -0.12217850f, -0.18998456f, -0.12900490f, 
    -0.80221128f, -0.02279802f, 0.39589384f, 0.13876261f, 0.07420705f, 0.06684352f, 0.03206590f, 0.01707234f, 
    0.02337061f, 0.14474972f, -0.14412959f, 0.11672730f, -0.66859305f, -0.67272103f, -0.24655400f, 0.30643925f, 
    -0.14712074f, 0.03168607f, -0.07119105f, -0.06703446f, -0.00829198f, -0.37907538f, -0.09353706f, 0.08662501f, 
    -0.01822742f, -0.07822035f, -0.13278106f, -0.05063685f, -0.10798095f, 0.00292158f, 0.02263625f, -0.12187754f, 
    -0.17183451f, -0.03143033f, -0.00101189f, 0.09343415f, -0.11260734f, 0.23736197f, -0.03717756f, 0.12374967f, 
    0.03225295f, 0.14291286f, -0.06524005f, 0.12589645f, -0.08646609f, 0.05630704f, 0.00011841f, 0.03780596f, 
    0.41518116f, 0.06004485f, 0.34243315f, 0.10416386f, 0.18531367f, 0.02705253f, 0.03766024f, 0.13769980f, 
    0.07610112f, -0.07731850f, -0.23707503f, -0.23849458f, 0.12149603f, -0.07376329f, 0.08168669f, 0.09214332f, 
    -0.07039891f, 0.08873755f, -0.05705754f, -0.06478579f, 0.08415779f, -0.01460090f, -0.19721761f, -0.01029955f, 
    0.16158035f, 0.00983911f, 0.25866759f, 0.02799552f, -0.00282572f, -0.00254783f, -0.00231188f, -0.03185615f, 
    -0.07967049f, 0.07152476f, -0.04162521f, 0.12800221f, 0.05012984f, -0.12365048f, 0.02982912f, 0.14945553f, 
    -0.01142498f, -0.01074586f, -0.03987114f, -0.02621094f, 0.01124645f, 0.17875732f, -0.05622523f, 0.03358165f, 
    0.19630004f, 0.09339979f, 0.11646405f, 0.11732689f, -0.07540452f, -0.13192454f, -0.10697702f, 0.00148313f, 
    -0.05964005f, 0.06481061f, -0.04982855f, 0.08433244f, 0.26530161f, 0.13416298f, -0.10399107f, -0.02362685f, 
    -0.01915775f, -0.16076691f, 0.10771834f, -0.04691582f, -0.04550968f, 0.07632806f, 0.11544128f, -0.11519200f, 
    0.18508182f, -0.38838875f, 0.08291069f, 0.30819210f, -0.00210572f, 0.23643444f, 0.08273459f, -0.04339196f, 
    -0.11456986f, 0.18979545f, 0.08886386f, -0.15213677f, 0.17905761f, -0.20211965f, -0.16704385f, 0.25260165f, 
    -0.22562459f, 0.02670856f, -0.02160500f, 0.17332381f, -0.06748769f, 0.09015697f, -0.13686927f, 0.13508157f, 
    -0.04982101f, 0.06763762f, -0.13883717f, 0.08246490f, -0.19957061f, -0.06971545f, 0.04603138f, 0.09642585f, 
    -0.14045122f, 0.09068567f, -0.01681708f, 0.02914828f, 0.36806628f, -0.26563656f, -0.01328084f, -0.18219650f, 
    -0.11057050f, -0.20073301f, -0.03713019f, -0.04069163f, -0.11490622f, -0.04478641f, -0.06276364f, 0.04664325f, 
    -0.14144525f, 0.27322134f, 0.18566820f, -0.12872195f, -0.05535017f, 0.05795432f, -0.14904423f, 0.00205327f, 
    0.14384253f, -0.07782719f, -0.16891250f, 0.18778348f, 0.25532299f, 0.01505697f, 0.09989902f, 0.09681668f, 
    -0.05426063f, 0.06671638f, 0.07202034f, 0.11489853f, 0.13618983f, 0.07487763f, -0.06515050f, -0.00103266f, 
    -0.20209573f, 0.28901428f, -0.02303767f, 0.07897267f, 0.07076600f, 0.05768799f, 0.06671920f, 0.22560029f, 
    0.04532755f, -0.07763844f, 0.10580708f, -0.11094801f, 0.63666356f, -0.02736247f, 0.05831852f, 0.01701023f, 
    -0.07569157f, 0.16456960f, -0.24785270f, -0.16532886f, -0.08084735f, -0.10243267f, 0.07660309f, -0.10790238f, 
    -0.10307999f, 0.08289973f, 0.03265760f, 0.19147649f, -0.07108982f, 0.11239292f, 0.02854603f, -0.09424584f, 
    0.08972162f, -0.13567258f, 0.06409170f, 0.04180080f, -0.04152894f, -0.20143862f, 0.06914786f, 0.33297798f, 
    0.05989112f, -0.17641574f, 0.04793111f, -0.01826498f, -0.33039540f, 0.02059614f, 0.03958685f, 0.01654142f, 
    0.47619760f, -0.02989892f, -0.36940971f, -0.06024375f, -0.06263684f, -0.08105457f, -0.05697766f, 0.03329046f, 
    -0.07189820f, 0.04964239f, -0.05123329f, -0.07085199f, -0.23539616f, 0.25997537f, -0.16937312f, -0.43428910f, 
    -0.09490446f, 0.13906230f, 0.09529521f, 0.16843860f, -0.13347419f, -0.05575020f, -0.06325553f, -0.08886651f, 
    0.06320443f, -0.19095846f, 0.10873539f, -0.04254472f, -0.10046209f, 0.18286249f, 0.09695522f, 0.08294239f, 
    -0.06145003f, -0.00262059f, -0.06497734f, -0.01628663f, -0.24782674f, 0.10121144f, 0.26349908f, 0.00111384f, 
    -0.19181770f, 0.11970790f, 0.00766848f, 0.05871741f, 0.11894103f, -0.02754024f, -0.09915864f, 0.05579525f, 
    -0.09571218f, -0.35244042f, -0.00339157f, -0.10491791f, 0.03224826f, -0.08795622f, -0.10115857f, -0.44769162f, 
    0.14581968f, -0.08094356f, 0.01293679f, -0.01514311f, -0.56841797f, 0.06080411f, 0.18449892f, 0.11881597f, 
    0.12213181f, 0.10918198f, 0.04210139f, -0.00836544f, 0.03323766f, -0.04389444f, 0.00263586f, 0.12721239f, 
    -0.25064847f, -0.23138542f, 0.13297762f, 0.24395855f, -0.09756861f, 0.01604914f, 0.00547228f, -0.25052249f, 
    0.04950522f, 0.05004676f, 0.05794261f, -0.00721634f, -0.72064549f, 0.33595422f, -0.16566308f, -0.28828496f, 
    0.06095945f, -0.00897034f, -0.01326958f, -0.03588255f, 0.05653923f, -0.09382805f, -0.04231587f, -0.11429543f, 
    0.15770686f, 0.01588387f, -0.16112709f, 0.11664124f, -0.17594810f, 0.03489813f, 0.16075590f, 0.00105815f, 
    -0.13432391f, -0.04597982f, 0.11825810f, -0.02293627f, 0.19269049f, -0.19210802f, 0.12445157f, 0.01315643f, 
    0.12559092f, 0.11541635f, -0.07923014f, 0.12689625f, 0.15219787f, -0.09162495f, 0.11322948f, 0.18658330f, 
    -0.23398910f, -0.27574587f, -0.33579147f, 0.24405883f, 0.00051442f, -0.14791955f, 0.12970467f, 0.01306856f, 
    -0.19171287f, -0.13292590f, -0.00741953f, -0.09827346f, -0.55313933f, -0.17285633f, 0.22557817f, 0.22438166f, 
    -0.07007723f, 0.03092954f, -0.11472291f, -0.04063363f, 0.18909995f, -0.13785878f, -0.19923879f, -0.05947772f, 
    -0.76761556f, 0.23694408f, -0.08978462f, -0.04104671f, -0.12353811f, -0.05952619f, 0.18385877f, 0.12219529f, 
    -0.02516326f, 0.11647180f, -0.10332506f, 0.15369588f, 0.25976855f, 0.16955055f, 0.03742347f, 0.01685024f, 
    -0.03204929f, -0.01086038f, 0.01153200f, -0.00734858f, 0.06775224f, 0.02467956f, 0.05352639f, -0.09442822f, 
    -0.83089542f, 0.11969002f, 0.19072381f, 0.18260512f, 0.00815266f, -0.16831057f, 0.00103274f, 0.03371385f, 
    -0.17043601f, 0.03737820f, 0.16881113f, 0.07077989f, -0.13724408f, -0.17258555f, 0.05856956f, -0.36406934f, 
    0.06253791f, 0.15091413f, 0.01428911f, -0.08812599f, -0.02011960f, -0.06871244f, -0.00098235f, -0.06000398f, 
    -0.24328081f, 0.43406960f, -0.05392497f, -0.10790749f, -0.05206569f, -0.04085083f, -0.16461405f, 0.06476893f, 
    -0.05623708f, -0.00747842f, 0.01168066f, -0.12529068f, 0.00778776f, 0.08162899f, 0.08316264f, 0.20340447f, 
    -0.06803933f, 0.13680790f, 0.09770271f, 0.22635576f, 0.12226077f, -0.09725148f, -0.02252672f, 0.00780392f, 
    0.06845862f, -0.21724506f, 0.05196854f, 0.10119420f, -0.05913353f, 0.19341052f, 0.04277032f, -0.07319088f, 
    0.07671212f, 0.12755357f, 0.00094180f, -0.00652448f, -0.20467310f, -0.01561605f, 0.15237407f, 0.00472192f, 
    0.03650039f, -0.15532845f, 0.12089267f, -0.02066571f, 0.05911140f, -0.00103422f, -0.09853350f, 0.11811756f, 
    0.51499861f, -0.06300350f, 0.04141994f, -0.14957771f, -0.03406741f, 0.01152122f, -0.04647589f, 0.14781412f, 
    0.08947226f, 0.05499625f, -0.01945049f, 0.08733165f, -0.36532250f, 0.13864395f, -0.14627117f, -0.07308085f, 
    -0.00933992f, 0.06963764f, 0.01383329f, 0.16266330f, -0.01076624f, -0.08539972f, 0.19704285f, 0.14938539f, 
    0.03184789f, 0.00204307f, -0.04013006f, -0.19623254f, 0.25817007f, 0.08746099f, -0.02568148f, 0.08419091f, 
    0.17119379f, 0.00285561f, 0.00997974f, -0.05851343f, -0.26033983f, -0.22343257f, 0.01639773f, -0.01623962f, 
    -0.05530136f, 0.06388844f, -0.00028173f, 0.07555098f, -0.02015887f, -0.06655768f, -0.01224005f, -0.15666911f, 
    -0.14384031f, 0.06732181f, -0.08071976f, 0.02406734f, 0.06123546f, 0.02672789f, 0.08641062f, -0.04351770f, 
    0.11532405f, -0.11935466f, 0.08011367f, 0.05511760f, -0.16431591f, 0.03342295f, 0.06374444f, -0.05068569f, 
    0.12299497f, 0.02006174f, 0.03142933f, 0.12359192f, -0.03162226f, -0.03733007f, -0.08407619f, 0.04733312f, 
    0.32834736f, 0.07441092f, 0.16974850f, 0.05547326f, -0.23247589f, 0.22335394f, 0.06986282f, 0.08308057f, 
    0.09469332f, 0.05953451f, 0.05857054f, 0.08924019f, 0.07640214f, -0.06650981f, 0.01842853f, 0.14543959f, 
    -0.07669313f, -0.03539402f, -0.00393044f, -0.05957927f, -0.04334245f, -0.02001897f, 0.07648081f, -0.15104266f, 
    -0.06878424f, -0.20103984f, 0.03803056f, -0.03253527f, 0.00320039f, -0.03081274f, 0.10474485f, -0.12066708f, 
    0.04774826f, 0.14933133f, -0.02240664f, 0.01004487f, 0.09171073f, -0.09015784f, -0.11902399f, 0.06677689f, 
    0.01063516f, 0.14369027f, 0.02107334f, -0.09530748f, -0.04045125f, -0.13540046f, -0.11036690f, 0.09900325f, 
    0.57780337f, 0.26556551f, -0.20675309f, -0.14572260f, 0.03542593f, -0.02945451f, -0.09795000f, -0.27613527f, 
    -0.13967013f, 0.13341555f, -0.17452519f, 0.03644915f, 0.03002608f, -0.12527443f, 0.05262317f, -0.10240348f, 
    0.16455232f, 0.21456391f, -0.08514274f, -0.02648973f, 0.12384400f, -0.11177684f, -0.00042389f, -0.15292117f, 
    -0.16495940f, 0.01433774f, 0.30480313f, 0.19728601f, 0.02668324f, -0.07909170f, 0.00669794f, 0.09831326f, 
    0.02642310f, -0.11363931f, -0.14722487f, 0.07603739f, -0.17396332f, -0.18365647f, 0.09232637f, -0.03361921f, 
    -0.01500425f, 0.00374217f, -0.02017438f, -0.07798218f, -0.05099739f, -0.01582079f, 0.04230977f, 0.23812088f, 
    -0.26939237f, 0.16023508f, 0.37525171f, -0.09004166f, -0.20484595f, 0.09596276f, -0.09778274f, -0.09619216f, 
    0.15148957f, -0.20852649f, -0.05886139f, -0.05593976f, -0.09270097f, -0.08076662f, -0.00008935f, 0.29852998f, 
    0.05707180f, 0.01559616f, -0.05722846f, -0.14385074f, -0.04362020f, -0.07378446f, 0.00855594f, -0.01246704f, 
    0.03465006f, 0.05590250f, 0.17717031f, 0.10059755f, -0.11587932f, 0.09913249f, 0.10163758f, 0.22688004f, 
    0.05491547f, 0.13971169f, 0.11042210f, 0.11428937f, -0.35182837f, -0.27632251f, -0.32914904f, 0.01058910f, 
    0.20873356f, 0.05072948f, -0.12887999f, 0.02103088f, 0.10464084f, 0.06109269f, -0.09941790f, 0.03797022f, 
    0.17320272f, -0.00795764f, 0.15263893f, 0.16824161f, -0.16646115f, -0.00349449f, 0.15882929f, -0.02326293f, 
    -0.41549805f, -0.06175827f, 0.17839858f, 0.21099459f, -0.81908172f, 0.36990467f, 0.18060645f, -0.02091627f, 
    -0.02878049f, -0.02251682f, 0.00486025f, -0.04753828f, 0.03310138f, 0.03659274f, 0.00246686f, 0.09634595f, 
    -0.06147898f, 0.29185691f, 0.09688041f, -0.38964152f, 0.04622313f, -0.03081758f, -0.08518998f, 0.13569993f, 
    0.14506879f, 0.00253038f, -0.06919166f, -0.12847742f, 0.12406282f, 0.28115585f, -0.24638958f, 0.04450894f, 
    0.10983725f, -0.07125878f, 0.13339822f, 0.13105215f, -0.00537005f, -0.25275990f, 0.12940449f, -0.30444375f, 
    0.30147585f, -0.02491685f, -0.05986282f, -0.24363747f, 0.10753777f, 0.18503730f, -0.12225997f, -0.08630009f, 
    0.09050334f, -0.05631538f, 0.04750647f, -0.16148242f, 0.29744878f, -0.02550677f, -0.11412158f, -0.06976614f, 
    -0.19519019f, -0.01425458f, 0.09056824f, 0.02929914f, -0.05682368f, 0.14927091f, 0.07949236f, 0.22638334f, 
    0.00686624f, 0.03122157f, 0.12672330f, -0.35211074f, 0.15983945f, 0.02364394f, 0.04424941f, -0.07764655f, 
    0.01648982f, -0.27861416f, 0.01386843f, -0.20748627f, 0.05698331f, 0.07073316f, 0.16219281f, -0.14722094f, 
    -0.11692993f, 0.08722933f, 0.13396670f, 0.01978896f, 0.04225344f, 0.04538666f, 0.00742033f, 0.29315019f, 
    -0.00765176f, -0.03622811f, -0.38209736f, -0.07849491f, 0.06317765f, 0.26284879f, -0.17645925f, -0.03866592f, 
    0.03815864f, -0.05998847f, -0.10107254f, -0.06242840f, 0.01655808f, 0.11353170f, 0.17651534f, 0.16435198f, 
    0.06762192f, -0.16886973f, 0.09486574f, 0.28377146f, -0.27302766f, -0.02222398f, -0.03852137f, -0.20936896f, 
    -0.27533376f, -0.16134122f, 0.15112422f, 0.29333618f, -0.21873692f, 0.05754329f, 0.19107375f, 0.06828017f, 
    -0.17054100f, -0.06145988f, 0.16813049f, 0.20167701f, -0.17145354f, -0.22128248f, -0.17802162f, 0.01765618f, 
    0.14120215f, -0.11637490f, -0.02594605f, 0.16269608f, 0.05021157f, 0.08092448f, 0.35231230f, 0.13814719f, 
    0.10438907f, 0.03266850f, 0.04435322f, -0.17635238f, 0.02042862f, -0.12807928f, -0.15854667f, 0.02070385f, 
    -0.05492490f, 0.06361882f, -0.06184491f, -0.09909288f, -0.02621128f, -0.22093649f, 0.15366162f, 0.18610142f, 
    0.14070085f, -0.16852629f, -0.17784904f, 0.12874658f, 0.11102246f, -0.17855524f, -0.15152685f, -0.20057140f, 
    -0.11411675f, -0.06132873f, -0.01659950f, 0.24610776f, 0.03671376f, -0.01890854f, 0.01212748f, -0.14775333f, 
    -0.05870378f, -0.21047606f, 0.03807184f, 0.08197334f, -0.51065892f, -0.06844340f, -0.12592405f, -0.34168363f, 
    0.11957099f, -0.02202358f, 0.35191566f, -0.16609308f, -0.05660512f, -0.01968822f, -0.24672920f, -0.08079851f, 
    -0.24270506f, -0.00740691f, -0.20212676f, 0.02075851f, 0.12973808f, -0.07892197f, -0.03797933f, -0.02777436f, 
    0.04223228f, 0.11432765f, 0.16992714f, 0.28033012f, -0.09219161f, 0.24862137f, -0.00128663f, 0.17792211f, 
    -0.02970401f, -0.16352910f, 0.08523132f, 0.12133117f, 0.14745452f, -0.14699487f, 0.08034594f, 0.00681334f, 
    -0.59289181f, -0.19174659f, -0.32656246f, -0.15226181f, 0.02341196f, 0.09581931f, -0.12969649f, -0.21580298f, 
    -0.01701852f, -0.01595584f, -0.07664577f, 0.01675067f, -0.70213938f, -0.21952039f, -0.27476454f, -0.06756534f, 
    0.10875681f, -0.10257966f, 0.18055607f, 0.09958986f, 0.05048960f, -0.00233563f, 0.00016157f, 0.04139435f, 
    -0.13466872f, -0.13144191f, -0.08711580f, 0.04432654f, 0.09852564f, -0.11142405f, -0.19262666f, -0.12434001f, 
    -0.02917235f, 0.01940075f, 0.10378176f, -0.04581175f, -0.04036092f, 0.01522615f, 0.10090742f, 0.21982256f, 
    -0.07902171f, -0.24420784f, 0.05453251f, 0.00284278f, -0.06315131f, 0.11517042f, 0.06373667f, -0.04117042f, 
    0.00693724f, -0.03689547f, 0.07977336f, 0.20298269f, 0.03004647f, -0.04102968f, -0.10344762f, 0.15180790f, 
    -0.15915138f, -0.02326115f, 0.07592171f, -0.01033031f, -0.25415653f, 0.07500271f, -0.05519405f, -0.27510166f, 
    -0.08683521f, -0.08339664f, 0.11980660f, 0.10902341f, 0.12135953f, 0.09780851f, 0.06933147f, 0.04145718f, 
    -0.64519376f, -0.10387229f, -0.23718052f, 0.39203170f, 0.03493153f, 0.05472074f, 0.10612465f, 0.09953663f, 
    0.13286637f, -0.17699474f, 0.20808420f, 0.00379275f, -0.07972728f, 0.14025107f, -0.32339853f, 0.05902451f, 
    -0.26597553f, 0.00884135f, -0.01584921f, 0.05099517f, -0.14865781f, 0.06999496f, -0.06986340f, 0.17803450f, 
    -0.61003375f, 0.29811099f, -0.00185360f, 0.39772817f, -0.18459380f, -0.17626044f, -0.12024163f, -0.03857285f, 
    -0.04114979f, 0.27391198f, 0.06915095f, 0.08967546f, 0.25031614f, 0.02814949f, 0.08677894f, 0.20669378f, 
    -0.09131834f, -0.04700423f, 0.04207800f, -0.03953661f, 0.16654456f, -0.03187345f, -0.16080417f, -0.05523856f, 
    -0.38251618f, 0.31010127f, -0.21292087f, 0.21020921f, 0.04915031f, -0.00242116f, 0.16434516f, 0.09070250f, 
    -0.04326760f, 0.04536895f, -0.00242229f, 0.15842766f, 0.03035180f, 0.38159686f, 0.10112935f, -0.28170809f, 
    0.06930994f, -0.14909931f, -0.03099936f, 0.19448204f, -0.00539625f, 0.10596383f, 0.04255451f, 0.09697258f, 
    -0.22245160f, 0.07668034f, -0.16696538f, 0.19788609f, -0.03498806f, -0.10505236f, 0.01404434f, 0.15898372f, 
    -0.03595164f, -0.25794443f, -0.01339886f, -0.19805583f, -0.12503067f, -0.15890424f, -0.11630995f, -0.16194108f, 
    0.06839176f, -0.09041423f, 0.03542242f, -0.10563142f, 0.07959612f, -0.06305864f, 0.08465763f, 0.07699409f, 
    -0.04940121f, 0.35485566f, -0.04466479f, -0.27942953f, 0.14351147f, -0.09106956f, -0.04079888f, 0.06200777f, 
    0.08317798f, -0.07515765f, 0.08085101f, -0.02353018f, 0.72686827f, -0.35397780f, 0.08450058f, 0.31684220f, 
    0.14669754f, 0.01636478f, 0.01000174f, 0.03337755f, -0.03568215f, -0.00386974f, 0.01029263f, -0.11840766f, 
    0.12456664f, -0.45877907f, 0.21240306f, -0.11429446f, -0.10294233f, 0.01452923f, 0.10887589f, 0.02643030f, 
    -0.10523458f, -0.06961968f, 0.03023314f, 0.10027909f, -0.16911016f, -0.07566879f, -0.20006464f, -0.18732351f, 
    -0.09569348f, 0.04049959f, 0.04205777f, -0.09170453f, -0.19829100f, 0.13912635f, -0.12348251f, 0.16763273f, 
    -0.44113997f, -0.23322980f, -0.09949112f, -0.27648172f, -0.13598065f, -0.05710307f, 0.22428204f, -0.04710519f, 
    -0.01560653f, 0.12024959f, 0.07646173f, 0.06730002f, 0.09837911f, 0.25969702f, 0.10132242f, -0.42241478f, 
    0.06656389f, 0.04437598f, 0.13233159f, 0.01778783f, -0.03373760f, -0.13675727f, -0.02286021f, -0.22618738f, 
    0.31378046f, -0.24389699f, 0.13019831f, -0.04921178f, -0.07749414f, -0.15021382f, 0.15752880f, 0.05372790f, 
    0.06497359f, -0.06076839f, -0.23218770f, 0.12266885f, 0.09765754f, 0.23837063f, 0.28900990f, -0.71510887f, 
    -0.18936588f, 0.05080421f, -0.13553871f, 0.02678287f, 0.00766055f, 0.00413001f, -0.08135293f, -0.14529063f, 
    -0.05450968f, -0.25384697f, -0.16836250f, -0.20152581f, -0.10131747f, 0.06848929f, 0.05284156f, -0.11681555f, 
    -0.04487902f, 0.10246331f, 0.07648061f, 0.17778149f, 0.26067358f, -0.07713260f, 0.46646678f, -0.47851649f, 
    0.14203373f, 0.14926246f, 0.17387725f, -0.00310514f, 0.12867247f, -0.11847060f, -0.12704375f, 0.18833710f, 
    0.31185827f, -0.12771100f, 0.05227548f, -0.12810276f, -0.06413439f, -0.09072946f, -0.03991831f, 0.00417021f, 
    0.11693633f, -0.12291574f, -0.16128373f, -0.01782639f, 0.12688302f, -0.14481105f, -0.15509807f, -0.23681441f, 
    0.04415790f, -0.02422743f, -0.09002086f, -0.07673207f, -0.03924005f, -0.06516907f, -0.16447544f, -0.13666908f, 
    -0.09529693f, 0.22856805f, 0.14635371f, -0.41038066f, -0.00894856f, 0.07211216f, 0.17637743f, 0.20547043f, 
    -0.25326830f, 0.04941238f, 0.09083405f, 0.09798329f, 0.12964879f, 0.07772260f, -0.18939942f, 0.08158141f, 
    -0.06634612f, 0.06661919f, -0.01114171f, 0.13935380f, -0.08608155f, 0.15363532f, 0.18435857f, 0.13025016f, 
    0.13035440f, -0.08162684f, -0.17563450f, 0.07231602f, -0.13022535f, -0.05144884f, 0.01211915f, -0.15930077f, 
    -0.05836841f, 0.07574794f, 0.13837224f, -0.10264774f, 0.27820638f, -0.32476628f, 0.06725401f, -0.05910701f, 
    0.02453209f, -0.03340164f, -0.06809380f, -0.05638174f, 0.03923658f, -0.08775213f, 0.17285624f, 0.04329197f, 
    0.04172030f, 0.14476386f, 0.14788581f, -0.39361614f, 0.01781543f, 0.17997883f, 0.06900875f, -0.08186305f, 
    0.00463448f, -0.00025691f, -0.20177081f, -0.03899219f, 0.11257470f, 0.10702611f, -0.10827977f, 0.43097129f, 
    0.04004195f, 0.29212919f, -0.11212944f, 0.01588169f, 0.01332944f, -0.00559138f, -0.10722651f, -0.02912075f, 
    -0.54481679f, -0.14133038f, -0.00616057f, -0.03056175f, 0.02270302f, -0.00101091f, 0.01056474f, 0.08372655f, 
    0.14985399f, -0.02226108f, 0.07123760f, 0.12401912f, -0.30957380f, -0.05774532f, 0.01425751f, -0.30752927f, 
    0.01420294f, 0.00791488f, 0.05873195f, -0.14574103f, -0.01071111f, 0.00313912f, 0.01851791f, -0.15090974f, 
    -0.05077170f, 0.06055804f, -0.06861436f, 0.09566703f, -0.06285302f, -0.09528040f, 0.08000084f, -0.05874996f, 
    -0.09998992f, 0.01491143f, 0.04313955f, -0.08741143f, -0.04258535f, -0.06559862f, -0.21499519f, 0.04603939f, 
    0.06454483f, 0.08369390f, -0.01130812f, 0.09697159f, 0.15999343f, -0.33766311f, 0.17812079f, 0.04752648f, 
    -0.10377148f, -0.12488572f, -0.10175142f, 0.25591826f, 0.22092497f, -0.04765402f, 0.03442363f, -0.23241360f, 
    0.05974369f, -0.08043625f, -0.10979955f, -0.17372014f, -0.21322626f, -0.07714990f, 0.08990142f, -0.10026517f, 
    0.03582197f, 0.01951996f, -0.06902654f, 0.09896334f, -0.04898861f, -0.02654408f, -0.05145373f, -0.23101012f, 
    -0.16146114f, 0.12242898f, -0.19126803f, -0.14774050f, -0.10397553f, 0.04905062f, -0.01083464f, 0.01798894f, 
    0.05028410f, -0.01764221f, 0.04750031f, 0.01650175f, 0.18569295f, 0.29187968f, -0.09855191f, 0.45557877f, 
    0.17380649f, 0.08822962f, 0.05357151f, 0.02854163f, -0.15653041f, -0.14752343f, 0.03345516f, -0.04766600f, 
    -0.03946441f, -0.05253886f, 0.11448610f, -0.02276206f, 0.18115996f, -0.02722891f, 0.00195592f, 0.00924621f, 
    -0.05771851f, 0.00275794f, -0.00120230f, -0.05055424f, -0.46068606f, 0.12742797f, 0.01179699f, 0.04151110f, 
    0.05116600f, -0.05787123f, 0.08885448f, 0.03106478f, -0.00482423f, 0.02196379f, 0.08254639f, -0.08755074f, 
    -0.44367185f, 0.20890485f, 0.18654604f, -0.18410389f, 0.03110596f, -0.11144717f, -0.12421229f, 0.09050435f, 
    -0.03828680f, -0.18494932f, -0.03502588f, -0.06571649f, -0.23506100f, -0.27556840f, -0.15817113f, -0.15931359f, 
    0.01760723f, -0.00014274f, 0.03493545f, -0.06141969f, -0.11436648f, -0.01225651f, -0.01829551f, 0.00546348f, 
    -0.26826614f, -0.07010099f, -0.15692466f, -0.04045607f, -0.08644003f, -0.06596669f, 0.06543923f, -0.01751357f, 
    0.00137369f, -0.04377830f, -0.01717974f, -0.08448248f, 0.12189040f, 0.22782868f, 0.33030072f, 0.10188831f, 
    0.04221310f, 0.10503007f, 0.02439266f, 0.00923741f, -0.02490154f, 0.01348764f, -0.05007123f, -0.04986886f, 
    -0.08809494f, -0.25663942f, 0.04474640f, 0.10874982f, -0.01577941f, -0.07938983f, -0.11960990f, -0.02166500f, 
    -0.16336206f, -0.00616393f, 0.07682977f, -0.07906414f, 0.15698670f, -0.32127249f, -0.12982629f, -0.12311808f, 
    -0.12821504f, -0.07167146f, -0.01888769f, 0.01545815f, 0.00664159f, 0.08807460f, -0.15227896f, 0.09384675f, 
    -0.08722336f, -0.03700554f, -0.04601933f, -0.14922185f, -0.06063357f, -0.01703699f, -0.11224195f, -0.12174448f, 
    0.04470710f, -0.00555300f, -0.08017964f, -0.14410967f, 0.15566446f, -0.04897553f, 0.08070356f, 0.27575073f, 
    0.03196280f, 0.03254952f, 0.00634200f, -0.09819105f, -0.09093614f, -0.05524417f, -0.11992882f, -0.14525017f, 
    0.39515781f, 0.19391431f, -0.08410301f, 0.07336967f, 0.06239249f, 0.10946106f, 0.05827457f, -0.13469048f, 
    0.02569303f, 0.07689974f, -0.12185761f, -0.06496739f, -0.08173793f, -0.29651272f, -0.19534992f, -0.27640066f, 
    0.04775969f, -0.06622618f, -0.04348760f, -0.12083916f, -0.03043789f, 0.01571427f, -0.00121809f, -0.04967766f, 
    0.18846273f, -0.42347330f, 0.13567096f, -0.08934273f, -0.01016483f, 0.04770007f, 0.00033031f, -0.03974222f, 
    -0.05663394f, 0.03116816f, -0.08571001f, -0.12245707f, -0.42709264f, 0.17159057f, -0.09717517f, -0.19225460f, 
    0.05986328f, -0.03179075f, 0.00092802f, -0.15194751f, -0.09953007f, 0.00556760f, -0.00704766f, -0.02010246f, 
    0.11283215f, 0.22898957f, 0.19969425f, 0.06340055f, -0.03122331f, 0.06269100f, 0.03099385f, -0.02856342f, 
    -0.06383015f, 0.04097339f, -0.10068162f, -0.06176139f, 0.34509909f, -0.12519382f, -0.02146453f, 0.19205321f, 
    -0.04136480f, -0.04951005f, 0.02409517f, -0.10877617f, -0.00597958f, -0.13921557f, -0.04070723f, -0.07811402f, 
    0.00500667f, -0.11737150f, 0.14044441f, 0.42074800f, 0.03867232f, -0.15985163f, -0.05628387f, 0.02021608f, 
    -0.01600471f, -0.01558218f, -0.05635674f, -0.04970562f, 0.13622873f, 0.22974090f, 0.00071962f, 0.12217328f, 
    0.03657611f, 0.02887978f, -0.04174706f, -0.00422146f, -0.01354916f, -0.05486177f, -0.03701030f, -0.08884170f, 
    0.21003754f, 0.20118730f, -0.03876149f, -0.08421375f, -0.06111580f, 0.06072304f, -0.00149355f, -0.12635691f, 
    -0.03776188f, -0.00356363f, 0.05467380f, -0.19823885f, -0.22148421f, -0.09678891f, -0.16220427f, -0.07674011f, 
    0.04993242f, -0.01899513f, 0.01520153f, -0.02692432f, -0.05861890f, -0.04746894f, -0.03868093f, 0.04505583f, 
    0.14178881f, 0.20683698f, -0.01526544f, 0.22292101f, 0.00763908f, 0.05636587f, -0.03161357f, -0.09035075f, 
    -0.01018235f, 0.04547333f, 0.02371489f, -0.04586139f, -0.34872055f, 0.07989455f, 0.14801240f, -0.00956055f, 
    -0.06983396f, -0.00473884f, -0.16806747f, 0.10225759f, -0.09323955f, 0.08447099f, 0.14098339f, 0.01247753f, 
    0.07102355f, 0.03362897f, -0.18167454f, -0.06839182f, -0.19136676f, -0.01882323f, -0.07606929f, -0.11821435f, 
    -0.07801042f, -0.04645012f, 0.03928567f, -0.07670040f, -0.35029948f, 0.03317130f, -0.04473621f, 0.16349177f, 
    -0.11306164f, -0.17054363f, -0.08529700f, 0.06760675f, -0.00917367f, -0.03535541f, -0.05183974f, -0.01466288f, 
    -0.04426222f, -0.06456918f, 0.14642194f, 0.07415058f, 0.02595926f, 0.03720119f, 0.04309209f, -0.02158176f, 
    -0.01108299f, 0.12336829f, 0.01101839f, -0.02704152f, 0.31737256f, 0.06284418f, 0.23874687f, 0.11915426f, 
    0.07379700f, 0.10270796f, 0.04150078f, -0.12635545f, -0.04795038f, 0.06792299f, -0.05731863f, -0.05189975f, 
    0.27256379f, -0.00073677f, 0.17480175f, 0.11093210f, 0.28260419f, 0.02272390f, -0.04030752f, -0.16979767f, 
    -0.08599346f, -0.10679780f, -0.17482758f, -0.07851933f, -0.07418501f, 0.19740081f, -0.05025247f, 0.23727848f, 
    -0.08131076f, -0.04693329f, -0.10013343f, 0.02405167f, 0.00237323f, -0.05377380f, -0.00624842f, 0.02063728f, 
    0.24720189f, -0.21866702f, 0.10343877f, -0.00394167f, 0.03603069f, -0.00049900f, -0.06473827f, -0.10482135f, 
    -0.10865021f, -0.13605639f, -0.04387528f, 0.00913638f, -0.38838381f, 0.28101587f, -0.20083281f, -0.13394737f, 
    -0.08153805f, 0.00440264f, -0.07774686f, -0.02239452f, -0.08687685f, -0.03809027f, 0.13428472f, -0.08082691f, 
    0.18018337f, 0.27942529f, -0.16848823f, 0.06006454f, -0.13875924f, 0.02568109f, -0.24964680f, -0.06257024f, 
    -0.10202675f, -0.03047330f, -0.12364107f, -0.01604904f, -0.31079054f, 0.17529167f, 0.10626533f, -0.24167973f, 
    -0.04966142f, 0.02626446f, -0.21881463f, -0.08124059f, 0.11744543f, -0.16405651f, 0.10323960f, 0.02107754f, 
    0.35243744f, 0.07597172f, -0.21507882f, 0.07641634f, 0.03488705f, -0.03870542f, -0.00132520f, -0.07927565f, 
    0.03406763f, 0.03205638f, 0.09258367f, 0.07241269f, 0.17575651f, -0.14844882f, -0.31400332f, -0.06341001f, 
    0.16685912f, -0.11875795f, -0.20257224f, -0.07532880f, 0.03899822f, 0.03706044f, 0.11767855f, 0.14924321f, 
    0.29740444f, 0.15250485f, -0.21227582f, 0.17792882f, -0.02025144f, -0.12119574f, -0.12718374f, -0.15762256f, 
    0.09020080f, -0.07624245f, -0.04396180f, -0.03137663f, -0.06866851f, -0.32932684f, -0.06189179f, 0.38122791f, 
    0.22956806f, 0.11063018f, -0.07214293f, -0.04959921f, 0.05231521f, -0.06886592f, 0.29999551f, -0.15616797f, 
    0.15648763f, 0.21034279f, -0.32815462f, 0.06931292f, -0.10673812f, 0.00816295f, 0.10318675f, -0.06114697f, 
    0.07309856f, 0.15951243f, 0.00049230f, 0.15188259f, -0.09374934f, 0.18069066f, 0.07435814f, -0.09947930f, 
    0.03326011f, -0.06530800f, -0.02194998f, -0.00214045f, 0.07054779f, -0.01384529f, -0.09697459f, -0.07487544f, 
    -0.29257008f, -0.34346578f, -0.17919606f, -0.32647857f, 0.00681243f, 0.03966291f, -0.11161532f, 0.01828926f, 
    0.15962964f, 0.17764609f, -0.03712699f, -0.07957246f, -0.06686323f, 0.04754244f, 0.11052770f, 0.00339819f, 
    0.04382415f, 0.03616719f, -0.06766581f, -0.11841185f, 0.12758757f, -0.08602791f, 0.00772441f, 0.13282147f, 
    0.25565693f, 0.00879674f, 0.05536811f, 0.08117557f, -0.05721324f, -0.12611486f, -0.00101882f, 0.03974913f, 
    0.03937858f, 0.05994285f, -0.20270088f, -0.07461033f, -0.21426991f, -0.16074395f, -0.04675700f, -0.39639288f, 
    -0.03361125f, -0.07193708f, 0.08240689f, 0.00306390f, 0.04744100f, -0.19243941f, 0.03150605f, -0.14086993f, 
    -0.36748996f, 0.10083446f, 0.13037829f, 0.12351007f, -0.17774154f, 0.02709315f, -0.18453212f, -0.02154115f, 
    -0.10203060f, 0.00071514f, 0.11244323f, -0.11544600f, -0.08347819f, -0.21973135f, -0.04773165f, -0.01020861f, 
    0.06452578f, -0.13736531f, 0.08003369f, 0.04720739f, 0.12084699f, 0.08131028f, 0.02143310f, -0.00374482f, 
    0.19041215f, 0.09024919f, -0.02481931f, 0.18040651f, -0.00383559f, -0.08314325f, -0.00653219f, -0.14844334f, 
    -0.08785964f, 0.00619216f, 0.06693403f, -0.06683908f, -0.07353940f, 0.06879308f, 0.02238832f, 0.25344583f, 
    0.12312035f, 0.00578485f, -0.03252009f, -0.07012881f, 0.11111604f, 0.06305529f, 0.07025088f, 0.01068272f, 
    -0.06194300f, 0.21536373f, 0.01008879f, 0.09415787f, -0.14743359f, 0.17730574f, -0.07867764f, 0.11371963f, 
    -0.02233103f, -0.12107161f, -0.06143672f, -0.08562908f, 0.01693391f, -0.55967891f, -0.11040588f, -0.12644675f, 
    -0.06374285f, -0.20664538f, -0.04653082f, -0.07628991f, -0.13930805f, 0.19935000f, 0.02709222f, -0.02689246f, 
    -0.03637626f, -0.03164345f, -0.22346529f, -0.05401383f, 0.04032288f, -0.04239984f, -0.22305232f, -0.00033794f, 
    0.02962120f, 0.06931097f, 0.05245271f, 0.03515837f, -0.26681295f, 0.07703200f, -0.13064244f, -0.19415246f, 
    -0.04121053f, -0.00179946f, -0.05535228f, 0.03674983f, 0.08580280f, -0.03460380f, 0.12405752f, -0.06969820f, 
    -0.25960526f, -0.36593890f, -0.03188925f, -0.22426572f, 0.24397773f, -0.11963572f, -0.13005652f, 0.14954424f, 
    -0.06523301f, 0.10532846f, -0.01863449f, 0.18229525f, 0.16106750f, 0.00001495f, -0.18732645f, 0.09081367f, 
    0.08492444f, -0.08162878f, 0.01618230f, -0.02148998f, 0.17607899f, -0.03738925f, -0.26180953f, 0.01609815f, 
    0.13078301f, -0.12857907f, -0.10506037f, -0.31992573f, 0.09419873f, 0.09283537f, 0.02268721f, 0.03928548f, 
    -0.02558468f, -0.03233842f, -0.01851180f, 0.02551951f, -0.09539176f, -0.25246790f, 0.32005927f, 0.15934895f, 
    0.01131105f, -0.09325603f, -0.18691997f, -0.24512491f, -0.02404625f, -0.15344651f, -0.20711951f, -0.07117232f, 
    -0.33327425f, 0.11234275f, 0.04706144f, -0.00687635f, -0.02849717f, -0.16420163f, -0.06493611f, 0.01151111f, 
    0.02691425f, 0.19964901f, -0.15996598f, 0.11628103f, 0.24108298f, 0.27985129f, -0.31071639f, -0.07473892f, 
    -0.07795317f, 0.00248857f, -0.25456777f, -0.04151740f, -0.02800249f, 0.10765699f, 0.01864701f, 0.06062948f, 
    -0.31809714f, 0.08884212f, 0.20002899f, 0.01624703f, -0.10292093f, -0.03998921f, -0.24260674f, -0.26248837f, 
    0.05488936f, -0.01393898f, -0.03890573f, -0.12154751f, -0.07917537f, -0.09308559f, 0.21725856f, -0.13005880f, 
    0.09052055f, 0.13255842f, 0.00215720f, -0.08159308f, 0.06964939f, -0.01295018f, 0.18497442f, 0.09748770f, 
    0.19345999f, 0.19729705f, 0.09739427f, 0.08154014f, 0.02789725f, 0.02145005f, -0.31234327f, 0.05969611f, 
    -0.05260736f, -0.07680438f, 0.09570058f, 0.02088415f, -0.18079457f, 0.11466869f, -0.28557554f, -0.35496214f, 
    -0.10080457f, -0.07754822f, -0.26529095f, 0.13525788f, 0.18027231f, 0.16496600f, -0.02198483f, -0.02344593f, 
    0.06677248f, -0.10591588f, -0.17307518f, -0.42624098f, 0.15139687f, 0.09823321f, -0.24013314f, 0.07661467f, 
    0.07837468f, 0.03688627f, -0.07032952f, 0.01510572f, 0.09065221f, 0.06953986f, -0.01286623f, 0.19594233f, 
    0.11960994f, -0.08304943f, -0.07119173f, 0.16344418f, 0.16263554f, -0.08875272f, 0.04721314f, -0.03552353f, 
    -0.32560834f, 0.38165963f, 0.41094545f, -0.00714611f, 0.07995933f, 0.04833592f, 0.09207609f, 0.22972345f, 
    0.21527679f, -0.05810921f, 0.05540558f, -0.13391110f, -0.40057746f, -0.33307669f, 0.11910513f, -0.25018322f, 
    -0.02628576f, 0.03672339f, 0.04915601f, 0.17509304f, -0.11686517f, -0.06358189f, 0.18300937f, 0.11937814f, 
    0.00003266f, -0.02366318f, 0.07496216f, -0.38389859f, 0.06899829f, 0.16166393f, -0.06523718f, -0.11870954f, 
    -0.06401872f, -0.05958534f, 0.23643260f, 0.02759838f, -0.14315295f, 0.03650961f, 0.12903613f, -0.34402281f, 
    0.02644928f, -0.12417524f, -0.14037570f, 0.03742993f, -0.08378041f, -0.04722561f, 0.04294412f, -0.25376076f, 
    0.09116628f, -0.27003902f, 0.07976560f, -0.25824115f, 0.10699614f, -0.03157809f, 0.13194524f, -0.07322215f, 
    0.03134504f, 0.09297542f, 0.17150784f, 0.06105651f, -0.30538219f, -0.07018943f, 0.09175912f, -0.38105726f, 
    0.06756073f, 0.01535292f, -0.14844060f, 0.01048649f, -0.05533941f, 0.09782211f, -0.08969642f, -0.03532606f, 
    0.11786647f, 0.15856843f, 0.05571397f, 0.34177557f, 0.06637060f, 0.01739023f, 0.01297246f, 0.11274280f, 
    -0.08397940f, 0.08693691f, -0.12238804f, -0.04990634f, -0.19316235f, -0.08228835f, -0.01479889f, 0.11650565f, 
    -0.05255927f, 0.13504019f, -0.11486778f, 0.14856274f, -0.16914172f, -0.05788385f, -0.04068877f, -0.08666549f, 
    0.12661198f, -0.15287396f, -0.13731568f, -0.28930727f, -0.08875626f, 0.07011527f, 0.13030812f, 0.04751322f, 
    -0.09397396f, -0.05142234f, -0.02213495f, -0.03568099f, 0.53843862f, -0.12790985f, -0.18272790f, -0.17245409f, 
    0.00910604f, -0.03287487f, 0.16410284f, -0.00920451f, -0.09286475f, 0.00514982f, -0.05065739f, 0.17390862f, 
    -0.11363665f, 0.10712586f, -0.27036330f, -0.03996019f, 0.28151560f, -0.05493639f, -0.14979169f, -0.15799667f, 
    -0.20529117f, -0.16135727f, 0.02829652f, 0.01136449f, 0.06356987f, -0.01565037f, -0.11410528f, -0.21977702f, 
    -0.01846892f, 0.01210743f, -0.01443992f, -0.07178239f, -0.15476348f, -0.02076377f, -0.11035151f, 0.09757538f, 
    -0.21203001f, 0.50397044f, 0.14561395f, 0.10344043f, -0.03435994f, 0.02923413f, -0.18361804f, 0.10102890f, 
    0.08810595f, 0.15835217f, 0.00400150f, 0.10767418f, -0.07448521f, 0.06921829f, 0.17015025f, -0.28743789f, 
    0.03903721f, 0.05883068f, -0.05360920f, -0.00620848f, -0.10531575f, 0.01155700f, -0.02210393f, -0.09934932f, 
    0.57471895f, -0.14082396f, 0.02454363f, -0.22843195f, 0.12133582f, 0.10334291f, -0.05960116f, 0.14705890f, 
    0.08027107f, -0.06905130f, -0.00415105f, 0.07020254f, -0.52782029f, 0.27433965f, -0.48561567f, -0.26798457f, 
    0.19122900f, -0.10228179f, -0.04488004f, 0.07087436f, -0.14267847f, -0.16382803f, -0.06778704f, -0.18915872f, 
    -0.10877509f, -0.12310133f, -0.07410884f, 0.06237871f, 0.12272731f, -0.02064545f, -0.01102276f, 0.04372877f, 
    0.05473080f, 0.05852776f, -0.04455366f, -0.00106208f, -0.16881120f, 0.26471058f, -0.02475974f, 0.20915607f, 
    -0.19108546f, 0.08305527f, -0.00428521f, 0.06886376f, 0.03040476f, -0.05033414f, -0.01774981f, 0.13143314f, 
    -0.10707760f, -0.13762771f, -0.49097806f, -0.47703978f, -0.01362984f, -0.18913019f, -0.05668621f, 0.00768361f, 
    0.06319285f, -0.12808955f, 0.02242598f, 0.00042418f, -0.12119137f, 0.06829458f, -0.02770839f, 0.16805704f, 
    0.00771322f, 0.08680811f, -0.04872833f, -0.10235961f, -0.07738433f, -0.04300244f, -0.38322803f, -0.05454057f, 
    -0.06950573f, -0.25058568f, 0.11298449f, 0.18670245f, -0.05407199f, -0.07524778f, 0.01916318f, -0.10361274f, 
    0.22420257f, -0.01362723f, 0.14149761f, -0.09124138f, 0.04801749f, 0.19831416f, -0.01239299f, -0.00629012f, 
    0.16323474f, 0.14074436f, 0.01161684f, -0.07461123f, -0.03522493f, -0.02340362f, 0.29715988f, 0.16402853f, 
    -0.21463324f, 0.00947790f, 0.20894246f, -0.00676524f, 0.10144980f, -0.03214249f, -0.09918007f, -0.00286638f, 
    -0.04709482f, 0.01478034f, 0.04402296f, 0.35910314f, -0.32360640f, 0.23167676f, -0.01572571f, 0.31779838f, 
    -0.02492265f, 0.03408945f, -0.17832354f, 0.08828633f, 0.13040799f, 0.09496001f, 0.13165082f, -0.04023939f, 
    0.58204406f, 0.14637621f, 0.11582310f, -0.27230090f, -0.05957139f, -0.05476307f, 0.14336219f, -0.01530413f, 
    -0.05997061f, -0.08995172f, 0.20844521f, -0.09194570f, 0.20354873f, 0.19399405f, 0.25326905f, -0.13002485f, 
    -0.09047851f, -0.05262955f, 0.07767060f, -0.07971483f, 0.04063321f, 0.08330642f, -0.02345923f, 0.06755783f, 
    0.15381712f, -0.50836909f, -0.04703055f, 0.16375928f, -0.02953128f, -0.03471078f, -0.08504357f, 0.17672372f, 
    -0.06540323f, 0.03971612f, 0.05583890f, -0.06571544f, -0.07110369f, -0.09189432f, -0.26340851f, 0.13305029f, 
    -0.01246433f, 0.04132678f, 0.04583969f, -0.13863549f, -0.07621119f, 0.00405652f, -0.07061448f, -0.17941126f, 
    0.06220958f, -0.94741851f, 0.05252608f, -0.18219338f, -0.05549349f, -0.05990738f, -0.00403624f, -0.02554835f, 
    -0.13574152f, 0.01994513f, 0.03127007f, 0.13482332f, -0.22777142f, 0.18062101f, 0.09471063f, 0.07664172f, 
    -0.03101709f, -0.05688220f, 0.06910335f, -0.09054893f, -0.00344718f, 0.03143682f, -0.18632747f, -0.05241288f, 
    0.37336618f, -0.13150197f, 0.22254832f, 0.03740487f, -0.21579750f, -0.09420661f, 0.14603187f, 0.18706146f, 
    -0.03868089f, 0.00300438f, 0.11073059f, -0.11597388f, -0.36188251f, 0.50301898f, -0.02232587f, -0.05853079f, 
    0.09724744f, 0.11811913f, -0.10781363f, -0.07083444f, -0.18372348f, -0.15216914f, -0.04733428f, 0.09839885f, 
    -0.21686174f, -0.29956868f, -0.01220858f, -0.15175782f, 0.02302375f, 0.09388707f, 0.09455807f, -0.14653768f, 
    0.09226416f, -0.06286021f, -0.16640079f, 0.08516024f, -0.08420522f, -0.07902829f, -0.04063568f, -0.10246295f, 
    -0.04529360f, 0.02759112f, 0.05352943f, -0.31245255f, 0.00314747f, 0.02252495f, -0.06090874f, 0.05478137f, 
    -0.77420449f, 0.03068341f, -0.09073262f, -0.10517976f, 0.10229167f, 0.05232494f, -0.00484693f, 0.04084992f, 
    0.02622295f, 0.02948253f, -0.02681473f, 0.06988516f, -0.67153287f, -0.27691585f, -0.13931203f, -0.06984762f, 
    0.12504105f, 0.06238092f, -0.18706192f, 0.01759662f, 0.01868864f, 0.12703466f, 0.04871942f, 0.02178262f, 
    -0.31339809f, -0.16041245f, -0.31705791f, 0.01332591f, 0.21013489f, 0.09448823f, -0.17523775f, -0.02504558f, 
    0.02406902f, -0.08488635f, -0.02703188f, 0.16159993f, -0.83286387f, -0.25751680f, 0.01199137f, -0.35827300f, 
    0.18152501f, 0.09581266f, 0.00200768f, -0.08001116f, -0.08818943f, -0.04870940f, 0.02058882f, -0.04679016f, 
    -0.13829960f, -0.29890314f, -0.06705651f, 0.09123653f, -0.01449184f, 0.02575516f, -0.00796693f, 0.11003169f, 
    0.17629883f, 0.22210336f, 0.16909631f, -0.00473330f, 0.28948185f, -0.01081196f, 0.06303598f, -0.12489975f, 
    -0.17779317f, -0.01724817f, 0.05847178f, -0.10556185f, 0.08314364f, 0.01556082f, 0.02454334f, -0.14848523f, 
    0.00500647f, 0.09750710f, 0.15735185f, -0.05791104f, 0.27139997f, 0.07975937f, 0.02629249f, 0.08447640f, 
    0.08908907f, 0.13843063f, -0.08817821f, 0.23942851f, 0.00638845f, -0.02247904f, 0.22664401f, 0.00152059f, 
    0.09097242f, -0.05117737f, 0.04482337f, -0.00737049f, -0.05947322f, 0.18980215f, 0.08112942f, -0.02578598f, 
    0.38299358f, -0.09153916f, -0.44952205f, -0.06747636f, 0.00307743f, -0.01714520f, -0.04852064f, 0.10756516f, 
    -0.04617766f, 0.01403381f, 0.04862504f, 0.13138103f, 0.24569233f, 0.12647764f, 0.03484616f, 0.10654474f, 
    0.05834121f, 0.07994553f, 0.05615348f, 0.00089385f, -0.02614566f, 0.03943085f, -0.03219673f, -0.17313892f, 
    -0.18028925f, -0.23328666f, -0.01427342f, 0.18988353f, -0.11574071f, -0.01006306f, -0.10720917f, 0.07810583f, 
    0.04233566f, -0.14440967f, -0.10025428f, -0.15622436f, 0.28356460f, 0.39473921f, 0.02460194f, 0.06519079f, 
    0.04266658f, -0.07465396f, 0.04432420f, 0.09606110f, -0.00760370f, 0.19698910f, 0.23737101f, 0.16981576f, 
    -0.40215245f, 0.13789943f, -0.28063285f, 0.12295968f, -0.02954328f, -0.10388780f, -0.33471158f, -0.05745221f, 
    -0.05362267f, -0.09086960f, 0.12821078f, -0.12349005f, -0.63653898f, -0.43843094f, -0.18491578f, -0.47773543f, 
    0.02018534f, -0.00105793f, 0.00297955f, 0.02926238f, -0.01337212f, 0.20515181f, 0.12764335f, 0.05745330f, 
    0.25722352f, -0.06749101f, -0.03842295f, -0.05433697f, -0.15737708f, 0.03201202f, 0.05700026f, -0.05912811f, 
    0.07446596f, -0.08917912f, -0.01325409f, -0.20548891f, -0.16680560f, 0.03597294f, 0.35018066f, 0.10986614f, 
    0.11939217f, -0.16909470f, -0.00140732f, -0.09791968f, 0.12151121f, 0.07065378f, 0.00781443f, 0.06791394f, 
    0.35598788f, 0.21473612f, -0.28373137f, -0.20150219f, 0.12685072f, 0.05513701f, -0.05722935f, 0.02452117f, 
    0.13598943f, 0.07187357f, 0.11875682f, 0.12192638f, 0.07027857f, 0.17803197f, -0.02585605f, -0.18402958f, 
    0.06827475f, 0.07609051f, 0.05639013f, 0.04575397f, -0.13823503f, 0.17237778f, 0.19761312f, 0.03777642f, 
    -0.33246103f, -0.14203356f, -0.03422208f, 0.01490006f, 0.22967736f, -0.04271835f, -0.07152385f, -0.08649006f, 
    0.02224237f, -0.15346840f, -0.11793089f, 0.11924347f, -0.31106520f, -0.06481908f, -0.01253120f, -0.11535525f, 
    -0.02132801f, -0.03147354f, 0.00915837f, -0.03510598f, 0.00711570f, -0.20422532f, -0.04547165f, -0.06125883f, 
    -0.07438750f, -0.10569926f, 0.05264728f, -0.02894726f, 0.07361073f, 0.16138624f, 0.10204402f, 0.00793989f, 
    0.11184566f, -0.00940960f, 0.06585314f, -0.14335451f, 0.43391848f, -0.02235416f, -0.01065529f, 0.13555403f, 
    -0.16883941f, -0.25165129f, 0.01459433f, 0.06417585f, 0.00909899f, -0.15752254f, -0.30294204f, 0.07094539f, 
    -0.55446011f, 0.07905967f, 0.04997264f, -0.04931434f, 0.09167136f, -0.35075366f, -0.11483707f, 0.08011270f, 
    -0.08981803f, 0.04165463f, 0.02625725f, 0.16952039f, -0.58111095f, -0.17137729f, -0.06062934f, 0.02295787f, 
    0.26573133f, -0.00972306f, 0.04424843f, 0.00480065f, 0.10936362f, -0.06441724f, 0.02499395f, -0.01090229f, 
    0.33599073f, -0.02285868f, 0.07390755f, -0.03085930f, -0.12401947f, -0.14314871f, -0.07263188f, -0.04457442f, 
    -0.03296709f, -0.11976240f, -0.16683844f, -0.09212894f, 0.04402413f, 0.09252308f, -0.00415435f, -0.16382277f, 
    -0.00967075f, 0.11571992f, -0.04263943f, -0.10344304f, -0.00933854f, 0.06208377f, 0.12168859f, 0.10483548f, 
    -0.44969609f, 0.23059596f, -0.30106410f, 0.09969625f, 0.10543019f, 0.02318268f, 0.06446026f, 0.08771461f, 
    -0.03119560f, 0.19464549f, 0.16507429f, 0.02100650f, 0.12688483f, -0.24893901f, 0.17093097f, -0.04226257f, 
    0.11931396f, 0.10435484f, -0.06589227f, -0.00695896f, -0.00556928f, 0.00170767f, 0.08485328f, -0.03737349f, 
    -0.03207882f, 0.21648309f, 0.21003036f, 0.08066265f, 0.17403986f, -0.00941439f, -0.11224616f, -0.14964642f, 
    -0.21367304f, 0.08834755f, -0.19349039f, 0.00834051f, -0.28547245f, 0.00205182f, -0.14283434f, 0.11119334f, 
    0.13904911f, -0.19253358f, 0.20153806f, 0.12523121f, 0.17038800f, 0.17534225f, 0.05974042f, 0.14821805f, 
    -0.27732471f, -0.17850891f, 0.05848528f, 0.01729129f, 0.17197289f, 0.17558879f, -0.07734054f, 0.05570932f, 
    -0.04674625f, 0.08830159f, 0.02467073f, -0.04874632f, 0.32696959f, -0.13155724f, -0.24166267f, 0.07535764f, 
    -0.19490506f, -0.02292772f, 0.04683308f, -0.02881014f, -0.10369584f, -0.14299585f, -0.02064954f, -0.14501645f, 
    0.04413140f, -0.38216975f, -0.02970715f, 0.22195920f, 0.02397578f, 0.09832756f, 0.03887828f, 0.11064607f, 
    0.08789282f, 0.01791890f, 0.16176416f, -0.17806579f, 0.25447556f, -0.37720931f, -0.06393216f, 0.28850186f, 
    0.02317326f, -0.06185905f, -0.11408546f, -0.02222795f, -0.03269866f, -0.06436417f, -0.12599196f, -0.04487720f, 
    -0.20660743f, -0.30154026f, -0.29831138f, -0.04357233f, 0.13785134f, -0.08920662f, -0.01375604f, 0.13705188f, 
    -0.01857966f, 0.15556625f, -0.04021626f, -0.08185146f, 0.67508870f, 0.06924487f, -0.20726565f, -0.26678163f, 
    0.03231920f, -0.14915815f, -0.10551126f, -0.12241270f, 0.10365570f, 0.07440579f, 0.11538602f, 0.09356321f, 
    0.11468096f, 0.07508625f, -0.04453379f, 0.22783512f, 0.04483719f, 0.10161521f, 0.00892374f, 0.02047565f, 
    -0.03932459f, -0.13477586f, -0.04706068f, -0.03629855f, -0.10647273f, 0.15907629f, 0.06364547f, 0.00990089f, 
    0.10062735f, -0.13054354f, -0.03984667f, -0.09906019f, 0.03266415f, 0.09091893f, 0.07215787f, -0.14178820f, 
    0.01041122f, 0.07970524f, -0.20874976f, 0.18041295f, -0.07208078f, -0.02428011f, -0.05067644f, 0.16112180f, 
    0.13251349f, -0.08544905f, -0.04527779f, -0.08041421f, -0.54924130f, -0.12794378f, -0.04179398f, -0.04306141f, 
    0.05250313f, 0.08555078f, -0.05145243f, 0.09016003f, 0.04792529f, 0.06591895f, -0.06283880f, -0.08110161f, 
    -0.39635366f, -0.19672824f, 0.09349953f, -0.26829892f, 0.02879541f, 0.06219166f, 0.08477175f, -0.08161805f, 
    0.01365994f, -0.10588442f, -0.11288244f, -0.03617359f, -0.18305255f, -0.04040769f, -0.13039306f, -0.07611652f, 
    -0.14134717f, -0.13409165f, -0.05976805f, -0.13588120f, 0.05360959f, -0.08056148f, 0.03366323f, 0.01477086f, 
    0.15522175f, 0.07615250f, -0.23424645f, 0.16027108f, -0.05713993f, -0.19259752f, 0.08495546f, 0.03033295f, 
    0.04391245f, 0.13898283f, -0.16735068f, -0.06967328f, 0.27814502f, -0.10977485f, -0.12113022f, 0.01283377f, 
    -0.03133835f, 0.07208921f, 0.13388249f, -0.00273329f, 0.03770670f, -0.17625254f, -0.00037394f, 0.01747718f, 
    -0.33559501f, 0.14913866f, -0.28974956f, -0.11071636f, -0.00544794f, -0.05385515f, 0.02998882f, -0.03663038f, 
    -0.08730106f, 0.04451765f, -0.00074545f, 0.12436163f, 0.25714052f, -0.25544792f, -0.18849559f, -0.05726382f, 
    0.18875493f, -0.09330872f, 0.04719697f, -0.15269500f, -0.02014991f, 0.08299600f, -0.09662428f, -0.09091964f, 
    -0.09701160f, -0.13050227f, -0.12977405f, 0.07214383f, -0.03690469f, -0.07507174f, 0.11370471f, 0.02305592f, 
    0.00017166f, -0.02091070f, 0.01970900f, -0.06075875f, 0.40195701f, -0.06501041f, 0.14905332f, -0.17672017f, 
    0.15454748f, -0.07438350f, -0.14033639f, -0.06908020f, 0.09307148f, 0.11062552f, 0.18908261f, -0.01351884f, 
    -0.06566618f, -0.37174916f, 0.08746789f, 0.54432160f, -0.04633430f, 0.02407596f, 0.08111175f, 0.07632731f, 
    -0.11755535f, -0.04161312f, -0.00613413f, 0.10226020f, 0.24266624f, 0.00406764f, -0.28370053f, 0.14793161f, 
    -0.12177663f, -0.12737928f, 0.03660583f, 0.01970945f, -0.10610529f, -0.01743580f, -0.08586203f, -0.17760846f, 
    -0.31738928f, 0.40341401f, -0.24054371f, -0.47529101f, 0.14824793f, 0.27558529f, 0.06609594f, 0.12436195f, 
    0.09273633f, -0.03219724f, 0.13480219f, 0.01683109f, 0.37018168f, -0.06413095f, -0.00751031f, -0.12295796f, 
    0.01949686f, 0.03397683f, -0.08587900f, -0.25152731f, 0.03346286f, 0.09093794f, 0.05662394f, -0.07509363f, 
    -0.11139289f, 0.00879788f, -0.08107620f, 0.03626061f, -0.24842006f, 0.01799220f, 0.07968465f, -0.01216894f, 
    0.01987839f, 0.21868996f, -0.07677358f, -0.02512015f, 0.10053517f, -0.22971301f, -0.02485508f, -0.18826532f, 
    0.06387051f, -0.03501892f, 0.12888306f, 0.03859429f, -0.18029906f, -0.03428307f, 0.06188237f, -0.00018625f, 
    0.03662302f, -0.19251750f, 0.05726809f, -0.30093390f, 0.02296373f, -0.11807168f, -0.12155022f, 0.11336233f, 
    -0.15347615f, -0.17799513f, 0.03810119f, -0.06903974f, 0.58384472f, -0.39165026f, -0.16760623f, 0.13335639f, 
    0.08636400f, -0.17779009f, -0.16284654f, -0.06581890f, 0.14550684f, 0.10647725f, 0.10021366f, 0.01466746f, 
    -0.00898956f, -0.06314632f, 0.04504482f, -0.04528104f, -0.02625312f, 0.01673287f, 0.17825399f, -0.19602242f, 
    -0.01611999f, -0.00246954f, 0.17147198f, -0.09712473f, -0.47103047f, 0.43228728f, 0.06404170f, -0.05588905f, 
    -0.25255594f, 0.01051038f, 0.01161423f, -0.29623327f, 0.07502771f, -0.09559283f, -0.05798893f, -0.04039801f, 
    -0.35006168f, 0.07897506f, 0.01721638f, 0.22777992f, -0.10156775f, 0.26392099f, -0.05315120f, 0.13297166f, 
    -0.06232167f, -0.10886755f, -0.03039812f, 0.04819594f, 0.07970524f, 0.35746804f, -0.11162028f, 0.22221804f, 
    0.08655992f, 0.02094618f, -0.01607093f, -0.12449756f, -0.05771662f, -0.02782325f, -0.09069193f, 0.11963597f, 
    0.50082088f, 0.09828567f, 0.11336391f, -0.10957271f, -0.34295455f, 0.09257506f, -0.04913423f, 0.09008586f, 
    0.11443204f, -0.07263886f, 0.00949003f, 0.16537489f, 0.31619689f, -0.16257066f, 0.14939128f, 0.31943312f, 
    -0.02681507f, 0.02973831f, 0.07543749f, 0.07647582f, 0.13012794f, -0.13013443f, 0.06122443f, -0.12896077f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12760812f, 0.04123208f, -0.03690561f, -0.02125744f, 0.06154940f, 0.01991808f, 0.03733024f, -0.04788512f, 
    -0.01671124f, 0.02659471f, 0.07096735f, 0.02259393f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
