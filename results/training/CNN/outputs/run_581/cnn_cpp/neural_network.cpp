#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.10866928f, -0.07112055f, 0.82965809f, 0.41201743f, -0.09114567f, 0.16261531f, 0.26424411f, -0.73727947f, 
    -0.71180409f, 0.95260525f, 0.87960780f, 0.36464372f, 0.76255614f, -0.93712294f, 0.56372303f, -0.42492762f, 
    -0.10486601f, -0.31340158f, 1.07342947f, 1.22381580f, -0.84061688f, 0.33772302f, 0.66836202f, 0.51149148f, 
    0.51010948f, -0.42914659f, -0.19063458f, -0.77041233f, -0.55356115f, -0.50139439f, -0.88656378f, 1.13279712f, 
    -0.08896331f, -0.15159594f, 0.71037364f, -0.33679226f, 0.50862283f, 0.40190068f, -0.07103061f, -0.28121376f, 
    1.20204496f, 0.44095844f, -0.17428412f, 0.95916277f, 0.55255049f, 0.83616364f, 0.36154127f, 0.97991931f, 
    -0.85308307f, 0.21271880f, -1.01796556f, 0.28244069f, -0.77284408f, -0.10246766f, 1.35556459f, 1.00355923f, 
    0.40877262f, -0.41838032f, 0.11171329f, -0.20012751f, 0.19109382f, 0.84596926f, 0.49107707f, -0.67478335f, 
    -0.48778689f, -0.23147136f, 0.64076650f, -0.83611190f, -0.51420498f, -0.63215262f, -0.90478015f, -0.36790997f, 
    0.71263206f, -1.27194536f, -0.88229120f, 1.08602166f, -0.22308402f, 0.49437633f, 0.15329498f, -0.35544345f, 
    0.30059850f, -1.16679192f, -0.20514777f, 0.90716171f, -0.31795785f, -0.61235499f, 0.74107319f, 0.18432018f, 
    -0.26914975f, 0.75697339f, -1.18473327f, -0.81364310f, 0.39227745f, 1.26640224f, 1.28787172f, 0.46645790f, 
    0.11034532f, -0.35729516f, 0.00506864f, 0.76354927f, 0.60268402f, 1.03111625f, -1.35201430f, 0.62343675f, 
    -0.42255014f, 0.04531219f, -0.10298921f, -0.10588052f, -1.21987057f, -0.12775488f, -0.99151427f, 0.47913092f, 
    0.42405757f, 0.26826966f, 0.41952178f, -0.82959861f, -0.68425041f, -1.05104697f, 0.99356282f, 0.60268480f, 
    0.43848738f, 0.79447210f, -1.05877912f, -0.08474034f, -0.32820699f, -0.24490723f, -0.95769846f, -0.12840939f, 
    0.43245208f, -1.26823103f, -0.41624522f, -1.13521397f, 0.24937668f, 0.75268269f, 0.12288379f, -1.25816834f, 
    -1.35713792f, -1.19515848f, -0.67460495f, -0.53560531f, 0.09920080f, -0.22502877f, 0.45960259f, 0.24155040f, 
    0.24733245f, 0.46997061f, 0.08876245f, 0.54006952f, 0.72578114f, 0.76315606f, -0.98719335f, -0.78444850f, 
    -0.23075064f, 0.47103545f, 0.31534061f, 0.31789726f, -1.14315259f, -1.23256993f, -0.97495276f, -0.16170883f, 
    0.27983016f, 0.41070896f, -1.24170923f, -0.82104176f, -1.02155709f, 0.03858514f, 0.43784842f, -0.78558755f, 
    -0.38622037f, -0.31868643f, 0.23294772f, 0.92414045f, 0.50721747f, -1.47473061f, -0.46440616f, 0.17594041f, 
    -0.12567557f, 0.40401539f, 0.63432509f, -0.07041716f, -0.02240503f, -0.38897958f, -0.84837717f, -0.23908535f, 
    0.87864995f, 0.47983512f, -0.90519744f, 0.74606049f, 0.92422980f, 0.67680830f, 1.05358863f, -0.02263362f, 
    -0.76969457f, -0.99830836f, -1.08454382f, 0.48897350f, 0.14483169f, -0.35794979f, 0.13737412f, -0.31317186f, 
    0.18825428f, 0.41286322f, -0.66454315f, -0.75374037f, -0.62995070f, -0.72553790f, -0.96284771f, 1.48793733f, 
    -1.06502032f, -0.95114523f, -0.55792981f, 0.25534782f, -0.56719679f, -0.35611737f, -0.19065489f, 0.53820634f, 
    0.81395274f, 0.80207592f, 1.13765299f, 0.08614144f, 0.72032040f, -0.69702786f, -0.24331382f, 0.36829308f, 
    -0.40855622f, 0.54858643f, 0.52313358f, 0.95435864f, -0.28777939f, -0.55202699f, 1.09797227f, -0.38093939f, 
    -0.03065065f, -0.16690442f, -0.02102000f, -1.54577327f, -0.59359163f, -0.29075205f, 0.66552442f, 1.26743937f, 
    -0.36053193f, -0.24351522f, -0.11883980f, -1.14735937f, 1.16088486f, -0.96749741f, 0.74889231f, -0.27780727f, 
    -0.15149814f, 0.32191405f, 0.40556306f, -0.66580880f, -0.97467887f, 0.30349624f, -0.80295634f, 0.52334577f, 
    -0.14709334f, -0.94345725f, 0.35430238f, 0.21383424f, 0.93086714f, 1.07139003f, 0.04115853f, 0.82779944f, 
    1.20323741f, -0.74138820f, 0.41391340f, 0.50290799f, 0.78245944f, -0.23800977f, -1.42073655f, -1.07214999f, 
    0.89059210f, 0.38768750f, 0.32190290f, -0.74020869f, 0.54761595f, 0.03408402f, 0.41846052f, -0.46482161f, 
    1.17157924f, -0.32985178f, 0.75430423f, -0.58987498f, -0.85978639f, -0.43785575f, -0.33944193f, -0.28153786f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.25990641f, 0.42274129f, -0.23571099f, 0.17677270f, 0.11265011f, -0.00756507f, -0.00959699f, -0.43198398f, 
    0.03052998f, 0.10209779f, -0.16887420f, -0.05500028f, 0.28822264f, -0.18803963f, 0.21416187f, 0.07702604f, 
    0.20061208f, -0.04345676f, -0.06134409f, 0.10132145f, -0.37792417f, 0.07373250f, 0.28396320f, 0.16183998f, 
    -0.15039748f, 0.44123456f, -0.20915011f, -0.16532199f, -0.00729572f, 0.06442450f, -0.45857081f, 0.09898749f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.26493940f, 0.15713303f, 0.10858361f, 0.18636219f, 0.28368887f, 0.04793033f, -0.06055969f, 0.05493027f, 
    -0.05097166f, -0.16368744f, 0.32041389f, 0.22786276f, 0.01254464f, 0.10314218f, -0.01634835f, 0.03810309f, 
    -0.01071450f, 0.15083422f, -0.30655792f, -0.39481044f, 0.09498289f, -0.06644566f, -0.03474525f, -0.04872454f, 
    -0.04404410f, 0.00247446f, 0.04052362f, -0.03350765f, -0.06029540f, -0.08128032f, 0.07396933f, 0.15105759f, 
    0.19774780f, 0.02981224f, -0.20749931f, -0.01702604f, 0.09334950f, 0.28011295f, 0.20167056f, -0.00812795f, 
    -0.06320759f, 0.12325429f, -0.00244324f, -0.07847551f, 0.18227145f, -0.15729465f, 0.13521712f, 0.37307593f, 
    -0.03904157f, -0.06754889f, 0.01323742f, 0.01269224f, -0.21986650f, 0.08749035f, -0.13971776f, 0.26174110f, 
    0.28770033f, -0.14124270f, -0.03430412f, 0.08848795f, 0.06418991f, -0.10882477f, -0.10842002f, -0.26421073f, 
    -0.27334166f, 0.09272239f, -0.28042379f, 0.03466928f, -0.19729668f, -0.06065244f, -0.06342530f, -0.13999827f, 
    -0.26620325f, -0.42460331f, 0.20994096f, 0.00511962f, -0.07268562f, -0.14251104f, 0.06889715f, 0.01349435f, 
    -0.18384527f, 0.14085856f, -0.01049235f, -0.12412576f, -0.05686269f, -0.07366358f, -0.00076526f, -0.05887783f, 
    -0.04907154f, 0.22381160f, 0.02010252f, -0.44799998f, -0.23356977f, -0.03644583f, -0.07128637f, 0.17013355f, 
    0.17479225f, -0.01548543f, -0.08145996f, 0.09634304f, 0.40678495f, 0.30681449f, -0.18019111f, 0.10226148f, 
    -0.07259011f, -0.06035037f, -0.03241746f, -0.11191873f, 0.01759362f, -0.18479334f, -0.04053216f, 0.09049451f, 
    -0.09052683f, 0.14074273f, 0.04159717f, -0.09451958f, 0.24779217f, -0.01169652f, -0.06360912f, -0.07330024f, 
    0.03563688f, 0.20590107f, -0.05232131f, -0.09281904f, -0.13845639f, 0.13029160f, 0.29193935f, 0.08564996f, 
    -0.17571436f, -0.16920818f, 0.09670475f, 0.00291697f, -0.19120291f, 0.09590982f, -0.05491173f, -0.17759673f, 
    0.03082244f, 0.17547825f, 0.17135794f, 0.13789316f, 0.13858286f, 0.11147159f, -0.18051720f, -0.03151333f, 
    0.14518316f, 0.02754138f, 0.11199287f, 0.12942873f, -0.10114662f, -0.11206917f, 0.05932791f, -0.03622018f, 
    0.05909391f, -0.09988933f, 0.16533332f, 0.15593150f, -0.12481312f, -0.11462597f, -0.16065978f, -0.10234984f, 
    -0.00632225f, 0.11895069f, -0.32329440f, 0.00637507f, 0.11225041f, 0.13030152f, -0.12805526f, 0.02503248f, 
    -0.01199237f, -0.04713536f, -0.16557559f, 0.07228711f, -0.37819386f, 0.06099976f, -0.15819924f, 0.02982811f, 
    -0.17061129f, 0.07519083f, 0.14202344f, 0.20165220f, 0.26976040f, 0.09516636f, -0.16912304f, 0.00616389f, 
    -0.07519738f, -0.19158719f, -0.02111853f, 0.02660724f, 0.12933715f, -0.00284730f, 0.06751907f, 0.11394339f, 
    -0.12991838f, 0.05320798f, -0.04682069f, -0.11359052f, -0.03546099f, 0.06912658f, 0.00196743f, 0.02746478f, 
    -0.01169800f, 0.00374712f, 0.16493617f, -0.10108880f, 0.07372335f, -0.02554147f, 0.08540520f, -0.08468544f, 
    -0.41724607f, -0.17349119f, 0.05869918f, 0.02419478f, 0.05457247f, -0.05609041f, 0.02035600f, 0.11578941f, 
    0.15635400f, 0.23152511f, 0.28425086f, 0.13925835f, 0.15572830f, -0.05745741f, 0.03241645f, 0.02431464f, 
    -0.15002230f, -0.15615088f, 0.37138087f, 0.13949566f, -0.00898351f, 0.30531871f, -0.03205029f, 0.10685088f, 
    0.01412562f, 0.06908003f, -0.07098001f, -0.06505331f, 0.28938407f, 0.11654371f, -0.09345945f, 0.11575477f, 
    -0.03348810f, -0.05012381f, 0.19486125f, 0.14577766f, -0.01566887f, -0.37929103f, -0.00970518f, -0.02277099f, 
    -0.09963129f, -0.03311953f, -0.19345336f, 0.28003198f, 0.03165286f, 0.08056314f, -0.08758988f, 0.27562359f, 
    0.12022859f, -0.10449194f, -0.16308592f, -0.08397871f, -0.10659362f, -0.35422471f, 0.21182305f, 0.23389655f, 
    -0.04557442f, 0.01829381f, -0.05800101f, 0.03253152f, 0.04490904f, -0.10127332f, -0.16460493f, -0.06580520f, 
    -0.13195264f, -0.09028774f, -0.12772913f, -0.05833758f, 0.11964352f, 0.15051718f, -0.23110721f, 0.13552859f, 
    0.03141676f, 0.21981373f, 0.00492938f, 0.15424985f, 0.08189991f, 0.06776115f, -0.10043741f, 0.25282627f, 
    -0.02677733f, -0.05526215f, -0.06175557f, -0.00124494f, 0.01580425f, -0.01085430f, -0.05797939f, -0.02588269f, 
    -0.04310482f, 0.04187251f, 0.02589073f, -0.01329162f, 0.03635563f, -0.04862518f, -0.04060102f, -0.03405842f, 
    0.03206021f, -0.03150816f, 0.01982690f, -0.05969436f, -0.05107533f, -0.06561124f, 0.04366658f, -0.00927565f, 
    -0.00002995f, -0.05615034f, -0.04644620f, -0.05425436f, -0.04372611f, -0.02499392f, -0.01256207f, -0.04162886f, 
    0.03448285f, -0.00458155f, -0.02933599f, -0.01184104f, 0.00401976f, -0.04326978f, -0.05579090f, 0.01537276f, 
    0.04209021f, 0.04443585f, -0.04318056f, 0.03113568f, 0.03453102f, 0.04178085f, 0.04710684f, -0.02502380f, 
    0.04278056f, -0.04234151f, -0.03953736f, -0.02220615f, -0.02688585f, 0.00311167f, 0.02103079f, 0.03549886f, 
    0.00106522f, -0.00565669f, -0.05323964f, 0.01452988f, -0.05020750f, 0.00330826f, -0.03540619f, -0.05756656f, 
    0.02497386f, 0.00444913f, -0.03644259f, -0.04233205f, 0.04721781f, -0.01768215f, 0.04370152f, -0.03188770f, 
    -0.01540445f, 0.00478228f, -0.03480502f, 0.02372753f, 0.02146680f, -0.02112434f, -0.04790812f, -0.02643409f, 
    -0.01856089f, 0.02870736f, -0.03462470f, -0.03940768f, -0.03699347f, 0.00421000f, 0.01133536f, -0.04313013f, 
    0.03850679f, 0.02490839f, -0.03168398f, -0.04266809f, 0.04001988f, 0.04314896f, 0.04216059f, 0.05138991f, 
    -0.05002560f, -0.01693376f, -0.00405240f, -0.00114258f, -0.01285476f, 0.01744957f, 0.00345857f, -0.02669928f, 
    -0.04977490f, -0.00576163f, 0.00275107f, 0.03462714f, -0.04604851f, 0.04380315f, 0.04757518f, 0.03856735f, 
    0.04294560f, -0.00795674f, -0.00324867f, -0.06149228f, -0.04561126f, -0.05124134f, -0.01542699f, 0.05439075f, 
    0.00193177f, -0.04906551f, -0.02676714f, -0.06109448f, 0.02002457f, 0.05248060f, 0.05486155f, -0.02216825f, 
    0.00096798f, 0.01546959f, 0.04274742f, -0.03046802f, 0.00349972f, -0.04297877f, -0.01592829f, -0.00289483f, 
    -0.00658074f, -0.03553486f, 0.04350349f, 0.00978131f, -0.00368893f, -0.01129988f, 0.01122687f, -0.03927305f, 
    -0.02340872f, 0.01319381f, -0.02706489f, -0.04295454f, -0.00536014f, -0.02624142f, -0.02438058f, 0.00677831f, 
    0.04902001f, -0.04505907f, -0.00695381f, -0.01564767f, -0.04442709f, 0.04225312f, 0.04571975f, 0.03649684f, 
    0.01886100f, 0.04876140f, 0.04159343f, 0.03270294f, -0.02398837f, -0.00767869f, -0.04083890f, -0.04647634f, 
    0.04039538f, -0.00131910f, -0.03792381f, 0.01364894f, -0.05541834f, 0.01020773f, 0.00126244f, 0.03153662f, 
    -0.00184072f, -0.00111667f, -0.03126459f, 0.04509360f, 0.02852103f, -0.04311305f, -0.06497265f, -0.03379563f, 
    -0.04584644f, 0.00050434f, 0.01552891f, 0.01552119f, 0.02972632f, -0.00659268f, -0.01678658f, 0.03566359f, 
    -0.04978640f, -0.05312248f, 0.04102421f, -0.03636884f, -0.02484866f, 0.02673448f, -0.00207828f, -0.01804680f, 
    0.04984066f, -0.00742384f, 0.04655235f, -0.06394205f, -0.02760006f, 0.01264045f, -0.03582313f, -0.01712551f, 
    -0.03253385f, 0.03125656f, 0.02760692f, 0.01960305f, 0.02821096f, -0.02544300f, -0.03199134f, 0.00287853f, 
    -0.04399345f, 0.03834618f, 0.00931455f, -0.01124512f, 0.00995895f, 0.00313393f, 0.01013934f, -0.06426096f, 
    0.02453210f, -0.05291300f, 0.01590333f, -0.04598412f, -0.04457399f, 0.05583769f, -0.04180712f, 0.01042260f, 
    -0.05388400f, 0.02856956f, 0.02268810f, 0.00899311f, 0.04380801f, 0.01977983f, 0.02393571f, 0.00179240f, 
    -0.01239530f, 0.01185368f, 0.05183866f, -0.05433974f, -0.02278468f, 0.01086874f, 0.03204374f, 0.00425630f, 
    -0.00918334f, -0.05644206f, 0.01645905f, -0.02866802f, -0.04228135f, -0.03416640f, -0.04517751f, 0.02207680f, 
    0.02618390f, -0.03072982f, -0.02953122f, -0.04418920f, -0.03965797f, 0.02881252f, -0.06358399f, 0.01654071f, 
    0.02030711f, -0.01824940f, -0.04910523f, -0.06703393f, -0.00154515f, 0.02178117f, -0.02660890f, 0.03077098f, 
    -0.06313903f, -0.04784164f, -0.04031041f, -0.02703421f, -0.01003952f, 0.04201376f, -0.05187784f, 0.04410378f, 
    0.00816621f, -0.02667507f, 0.00837974f, -0.01772390f, -0.02103112f, -0.02926965f, -0.00360454f, -0.01441138f, 
    0.26045844f, 0.06472843f, -0.04224148f, 0.07024486f, 0.19327736f, 0.09082672f, 0.20383497f, 0.09214688f, 
    0.08843188f, 0.15623373f, 0.12518646f, 0.24335140f, 0.14111273f, 0.20549910f, 0.26456633f, 0.21936318f, 
    -0.12842242f, 0.14576748f, -0.19586203f, 0.14861058f, 0.38552025f, 0.06287333f, 0.05125462f, 0.05166752f, 
    -0.13912866f, 0.12726389f, -0.05797143f, -0.21155021f, -0.22001131f, -0.37278289f, -0.19812778f, 0.23948584f, 
    0.02360565f, -0.14821574f, 0.04508554f, -0.26211330f, 0.03065908f, 0.06185226f, 0.08526649f, 0.10415652f, 
    -0.18716787f, -0.12888159f, -0.03582914f, -0.09355830f, -0.00876734f, 0.14778839f, 0.21282141f, 0.05697268f, 
    0.10601050f, 0.06138512f, 0.21840119f, -0.11668892f, -0.15252623f, 0.04976272f, 0.50046182f, 0.21112578f, 
    0.03116588f, 0.06091154f, -0.04692945f, -0.14119421f, -0.02978177f, 0.04248789f, 0.14930736f, 0.14146298f, 
    -0.01029787f, -0.39816415f, 0.04132785f, -0.08282064f, -0.15112634f, 0.39320305f, 0.33220470f, 0.18676360f, 
    -0.36399007f, -0.11994384f, -0.44948280f, 0.09005807f, -0.02547413f, -0.08446039f, 0.19297205f, -0.11016198f, 
    -0.00579502f, -0.33993515f, -0.62868679f, -0.15658598f, -0.08435985f, -0.11305599f, 0.27199414f, 0.09189956f, 
    0.05447015f, 0.10394678f, -0.32120660f, -0.95099390f, -0.60066199f, 0.00236890f, 0.00871151f, 0.05620285f, 
    0.03918271f, -0.02899937f, -0.13519652f, -0.00270464f, 0.23718508f, 0.27244267f, 0.22001778f, -0.04444401f, 
    -0.08152203f, -0.18673232f, 0.07425725f, 0.06600615f, -0.39359808f, -0.24624039f, 0.07727309f, 0.01605353f, 
    -0.12967648f, 0.07476959f, 0.05294015f, 0.15061677f, -0.05609756f, -0.23694466f, -0.44731557f, -0.09273550f, 
    -0.20897554f, -0.09296320f, -0.12980738f, 0.02995699f, -0.11563856f, 0.29098299f, 0.01359601f, -0.29717168f, 
    -0.36154443f, -0.05363168f, 0.26062393f, 0.03343032f, -0.01587778f, 0.03299592f, 0.06478267f, -0.65571845f, 
    0.11424018f, -0.46453211f, 0.11245376f, 0.21348022f, 0.19726464f, -0.09498111f, 0.01497946f, -0.12317569f, 
    -0.23542292f, 0.06338570f, -0.21580437f, 0.18083888f, 0.06061319f, 0.10064387f, 0.04512692f, 0.14810659f, 
    0.23068519f, 0.25202933f, -0.01320231f, -0.18348588f, 0.07422081f, 0.19611552f, 0.20175071f, -0.05488789f, 
    0.03910059f, 0.09425659f, -0.50175035f, -0.17968513f, -0.25032517f, -0.19086485f, -0.05569475f, -0.12168756f, 
    -0.01052507f, 0.00594518f, -0.00137423f, 0.03458449f, -0.11400259f, 0.51885647f, 0.18628629f, -0.04389398f, 
    -0.16724628f, 0.28796887f, 0.10594068f, 0.09051964f, -0.61450219f, -0.34898421f, 0.03501529f, 0.01950669f, 
    -0.12375576f, 0.11695779f, 0.08298249f, -0.20242597f, 0.03540407f, 0.28294477f, 0.02831376f, -0.18084000f, 
    0.00794692f, -0.02470752f, -0.01691861f, 0.14597990f, -0.11083379f, 0.03620099f, 0.19675368f, -0.08612401f, 
    -0.21438256f, 0.18477742f, 0.00855320f, 0.16113287f, 0.27646479f, 0.36791340f, 0.01920772f, -0.27994937f, 
    -0.22829433f, -0.60876983f, 0.06322142f, 0.17732735f, 0.01659379f, -0.09605272f, -0.13927302f, 0.09205616f, 
    -0.07929035f, 0.12291589f, 0.15466887f, 0.22109383f, 0.02485345f, -0.10609473f, 0.02438613f, 0.03399111f, 
    -0.06464145f, 0.14429754f, 0.14765944f, 0.33730990f, 0.21836691f, 0.22056717f, 0.26019463f, 0.35529953f, 
    0.08501276f, 0.31646332f, -0.15091348f, -0.00264631f, -0.78519428f, 0.22031334f, 0.00921789f, 0.04130790f, 
    -0.14467664f, -0.13215846f, -0.03126286f, -0.57842994f, -0.26386511f, 0.18055995f, -0.23852594f, 0.05359454f, 
    -0.10561411f, 0.04274448f, -0.02477310f, -0.17294596f, -0.08151688f, -0.15801388f, 0.20304883f, -0.03593239f, 
    0.05892915f, -0.08556990f, 0.19022897f, -0.06390435f, 0.15539373f, 0.20331904f, 0.18480304f, 0.22616571f, 
    -0.15123135f, 0.05683477f, 0.06254344f, 0.22902271f, -0.03132887f, 0.04305892f, 0.02747653f, -0.37596810f, 
    -0.26496011f, -0.10841774f, -0.12109533f, -0.14675768f, 0.18575796f, -0.11822919f, 0.00360748f, -0.06376489f, 
    -0.06616517f, 0.18012768f, 0.04327400f, 0.01439451f, -0.06825396f, 0.05168341f, -0.00664076f, 0.13063516f, 
    -0.24689476f, -0.42193615f, -0.02608990f, 0.07086571f, 0.01478267f, -0.14431345f, 0.10477474f, 0.09642639f, 
    0.04929675f, 0.09301852f, -0.41720632f, -0.02058687f, -0.16247606f, -0.06611172f, -0.00779542f, 0.05833116f, 
    -0.26926851f, 0.11543112f, 0.14960849f, 0.07860757f, 0.03295840f, -0.25333279f, -0.20745797f, -0.00100244f, 
    -0.01963881f, 0.15784791f, 0.11538703f, -0.00008249f, 0.36737353f, 0.21259964f, 0.07131720f, -0.24688736f, 
    -0.18534392f, 0.03545156f, -0.23079695f, -0.29512537f, -0.15667672f, -0.44665951f, 0.08335788f, -0.00847913f, 
    -0.07600537f, -0.25850150f, 0.05768702f, -0.03274981f, 0.08743087f, -0.11421143f, -0.37708911f, 0.16399875f, 
    -0.02460077f, 0.14228813f, 0.14388575f, -0.08834083f, 0.07520100f, 0.07145209f, -0.08629851f, -0.35643429f, 
    0.08559198f, -0.18546230f, 0.15313688f, 0.03002932f, 0.11356962f, -0.24829854f, -0.06762451f, 0.24532184f, 
    0.36028883f, -0.04996022f, -0.02754427f, 0.11688704f, 0.02127773f, 0.15907782f, -0.07612343f, 0.11260107f, 
    0.46635661f, 0.15162550f, -0.19832495f, 0.04658436f, 0.33279979f, -0.05321183f, 0.11653444f, 0.01712662f, 
    0.15070732f, -0.28380254f, 0.04864344f, -0.29587793f, -0.14225559f, 0.25416937f, -0.06111875f, -0.14923343f, 
    -0.20950146f, -0.01655832f, 0.09779243f, 0.15980504f, -0.01724273f, 0.01520088f, 0.03033748f, -0.23312278f, 
    0.22186399f, 0.28445849f, 0.23143284f, -0.26238558f, -0.19959630f, -0.06340233f, -0.01388571f, 0.34901047f, 
    0.01665585f, -0.07049661f, -0.09398247f, -0.04237515f, -0.00207784f, 0.21930334f, 0.08935229f, 0.10015352f, 
    -0.00307841f, -0.10244340f, 0.17883027f, 0.09576476f, 0.10344378f, 0.51798970f, -0.17955145f, 0.24005209f, 
    0.11860767f, 0.15518437f, -0.04630367f, -0.41999167f, -0.08497143f, 0.17546943f, -0.17580956f, 0.13130823f, 
    0.11827908f, 0.07293583f, -0.02725976f, -0.14700268f, -0.06537387f, -0.06485996f, 0.09889111f, -0.28720939f, 
    0.28256178f, -0.08353493f, -0.15858133f, -0.20177925f, -0.04867160f, 0.01016080f, 0.12581432f, 0.18621232f, 
    -0.17736678f, -0.03726968f, 0.05986241f, 0.02999050f, 0.03293209f, -0.28710333f, -0.00912588f, 0.14770913f, 
    0.07639626f, 0.29726294f, -0.20095824f, -0.28044328f, -0.09118091f, 0.07207481f, -0.03833346f, -0.00566722f, 
    -0.01792177f, 0.06359175f, -0.10754766f, 0.41983408f, 0.27518684f, -0.00776690f, 0.09817596f, 0.10599679f, 
    -0.13991049f, -0.13200559f, -0.31673843f, 0.19006145f, -0.01042752f, -0.35305226f, -0.50292277f, 0.09371590f, 
    -0.21598375f, -0.17626005f, 0.01842484f, -0.14050399f, 0.20189400f, -0.02473100f, -0.20203736f, 0.01506935f, 
    -0.01663137f, 0.15354271f, 0.14867425f, 0.34395444f, -0.03278833f, 0.07861535f, -0.31812716f, -0.24875297f, 
    0.00403787f, 0.14973927f, 0.00086310f, -0.14233586f, 0.15684596f, -0.07863223f, 0.02173559f, 0.03616637f, 
    -0.14384982f, 0.00255310f, 0.07130725f, -0.10263023f, -0.06028776f, -0.15397385f, -0.10439431f, 0.13176952f, 
    0.09356415f, -0.07596968f, -0.19087149f, 0.03691236f, -0.05466740f, -0.20242320f, -0.18885970f, 0.11064523f, 
    0.03745972f, -0.39179888f, 0.05689265f, -0.07120980f, 0.07386772f, 0.02519625f, -0.12339753f, 0.01874714f, 
    0.02488764f, -0.29246199f, -0.16769353f, 0.04428350f, -0.05988448f, -0.07546887f, -0.05588306f, -0.14035462f, 
    0.03239420f, -0.12036188f, 0.42071804f, 0.09037232f, -0.27130702f, 0.28334525f, 0.18664931f, -0.07862457f, 
    -0.02858622f, 0.24742702f, 0.02319227f, 0.50594193f, 0.36778578f, 0.10185777f, 0.07454419f, 0.03175462f, 
    -0.02850973f, 0.03949153f, 0.10906766f, -0.04822919f, 0.04783817f, 0.36040652f, 0.18909757f, -0.07657722f, 
    -0.10486359f, -0.11312530f, -0.07632440f, 0.05783617f, -0.21350117f, -0.27759504f, -0.24538451f, -0.24093969f, 
    -0.03134143f, -0.02284436f, 0.17412201f, 0.06948964f, -0.06831773f, -0.04683187f, -0.26035491f, 0.03227632f, 
    0.21901682f, 0.12369116f, 0.10028461f, 0.24010058f, -0.12306313f, -0.07657873f, 0.20712428f, 0.50833976f, 
    -0.10976955f, -0.14832436f, -0.09978534f, -0.06519313f, -0.03626164f, -0.17070934f, -0.06444477f, 0.12861237f, 
    0.06600484f, -0.22570947f, 0.29020789f, -0.03050458f, -0.03426779f, 0.04170182f, -0.11701676f, 0.07364125f, 
    -0.11907647f, 0.05145023f, 0.04943639f, 0.34834948f, 0.02859100f, -0.06508838f, -0.03430150f, 0.02738908f, 
    -0.04081077f, 0.16532427f, 0.19939676f, -0.24039948f, -0.10116281f, 0.10033531f, -0.07591467f, -0.38042799f, 
    0.06893022f, -0.17023575f, 0.11181331f, 0.10171798f, 0.15130980f, -0.00112875f, 0.08110453f, -0.01922762f, 
    -0.03623826f, 0.14802364f, 0.04161938f, 0.00649593f, 0.17098691f, -0.16138670f, 0.09889513f, -0.07762394f, 
    -0.18926597f, -0.13525602f, -0.00104230f, 0.14113988f, -0.04881268f, -0.10760017f, -0.40004304f, 0.10340970f, 
    0.13850772f, -0.02002699f, 0.07957023f, -0.13373680f, -0.03328479f, 0.04197545f, -0.16646229f, -0.45280918f, 
    0.11629384f, 0.34731629f, -0.16321523f, -0.19175647f, 0.07254279f, 0.01589455f, -0.01616600f, -0.20025131f, 
    -0.00835596f, -0.10965264f, 0.29176241f, 0.16104952f, 0.05534539f, 0.09577315f, 0.15961179f, 0.06252208f, 
    0.20179911f, 0.33701488f, -0.03290079f, 0.15581426f, 0.14022548f, 0.22062920f, 0.17340155f, -0.05712059f, 
    0.09851556f, -0.28419307f, 0.48561636f, -0.06327432f, 0.02998896f, -0.00908618f, -0.12251217f, -0.09681166f, 
    -0.08330486f, 0.00754780f, -0.24709627f, 0.10020041f, -0.10987602f, -0.08241192f, 0.16862997f, 0.02182613f, 
    -0.08052248f, 0.18953457f, -0.20665380f, -0.26597026f, -0.23874661f, 0.15155523f, 0.13039593f, -0.23647693f, 
    0.25097409f, -0.08212516f, -0.16804846f, 0.07607424f, 0.42202067f, 0.32826036f, -0.09811134f, -0.10369398f, 
    0.22647619f, 0.11405069f, 0.11410789f, -0.00829152f, -0.12632954f, -0.21464869f, 0.08898653f, 0.12557986f, 
    0.04798372f, -0.22557764f, 0.00448191f, -0.13282734f, 0.09980771f, 0.01977992f, -0.30709550f, -0.14315383f, 
    -0.21032915f, 0.05846400f, 0.04722826f, -0.19698015f, 0.14061400f, 0.02276688f, 0.12229317f, 0.32290557f, 
    0.36642879f, -0.20059308f, 0.25577483f, -0.20154057f, 0.27996451f, 0.02405021f, 0.04475943f, 0.04774647f, 
    0.15842257f, -0.17141773f, 0.03349721f, -0.19623719f, -0.13625982f, -0.21451338f, 0.01557583f, 0.18639989f, 
    0.04396596f, -0.14281425f, -0.50161308f, 0.04389820f, 0.23162793f, -0.00921553f, -0.02649949f, 0.09479295f, 
    0.03091589f, -0.00336925f, -0.01369619f, 0.04944756f, 0.14755048f, 0.04330449f, 0.20592383f, -0.14803310f, 
    -0.01051294f, -0.14787497f, -0.10028142f, 0.44672507f, -0.12989798f, -0.23275518f, 0.10408063f, -0.13317461f, 
    0.09959389f, -0.07311402f, 0.14463988f, 0.04385259f, 0.10001365f, -0.25928378f, -0.07102323f, 0.02580067f, 
    -0.33902159f, -0.19686973f, -0.13366309f, -0.00035154f, 0.13846210f, -0.00466871f, -0.39662409f, -0.01486375f, 
    0.21133439f, 0.03442779f, 0.09520239f, 0.18723902f, -0.10936099f, 0.15000175f, -0.12992935f, -0.08315070f, 
    0.24176317f, -0.05873867f, 0.17163448f, 0.02563145f, -0.17498086f, 0.06766935f, 0.10009557f, 0.48383909f, 
    -0.03529405f, -0.21852587f, 0.10025810f, -0.11330207f, 0.10288338f, -0.11260480f, -0.00843674f, 0.04191286f, 
    -0.28096095f, -0.07844991f, 0.03258001f, -0.17863987f, -0.09850358f, -0.08506130f, -0.16549493f, -0.05580246f, 
    0.03794483f, -0.10636716f, 0.36747658f, 0.05374762f, 0.18510599f, 0.13782385f, -0.13175502f, 0.07567162f, 
    -0.25632739f, 0.09828890f, 0.02045710f, 0.32237533f, -0.15563427f, 0.11410486f, 0.19959846f, 0.18833603f, 
    -0.07942126f, -0.02816080f, 0.17471720f, -0.11301114f, 0.13463706f, -0.42556313f, 0.05549554f, 0.07082373f, 
    -0.20077598f, 0.02036996f, -0.03609757f, -0.06528150f, -0.03429227f, 0.15538229f, -0.07148676f, -0.03766353f, 
    0.09456379f, 0.12306568f, 0.08460670f, 0.08004532f, -0.09623150f, -0.01088971f, -0.24826626f, 0.26079732f, 
    -0.10001873f, 0.16971366f, -0.10550876f, 0.13231087f, 0.00766126f, -0.06221064f, -0.65148342f, 0.28446114f, 
    0.08139769f, -0.18733999f, 0.00481381f, -0.11900496f, -0.07479710f, 0.02023537f, -0.04386108f, -0.19892389f, 
    -0.31090528f, -0.09935044f, 0.05290617f, -0.13138357f, 0.07054697f, 0.01669279f, -0.01039141f, -0.07344380f, 
    0.00053434f, -0.03336135f, -0.48087642f, -0.09627610f, 0.01641471f, 0.22861440f, -0.00476828f, -0.18615597f, 
    -0.04531771f, 0.26012313f, -0.09773875f, -0.17192134f, 0.01260941f, 0.08389856f, 0.23424488f, -0.14286712f, 
    -0.06091123f, 0.02397776f, -0.54837370f, 0.04400948f, 0.05806215f, 0.15174128f, 0.08263064f, 0.05995706f, 
    0.15558684f, -0.10556386f, -0.00981086f, -0.03306982f, 0.24013707f, 0.14552233f, -0.08444963f, -0.18015482f, 
    0.16988525f, -0.15805435f, 0.09551945f, 0.17264585f, -0.33565450f, 0.19931930f, 0.10984577f, -0.20146647f, 
    0.17443340f, 0.15991713f, -0.01654070f, -0.24198167f, 0.08570624f, 0.29310662f, -0.01107048f, 0.01515153f, 
    -0.11133683f, -0.07871599f, 0.04805598f, 0.04482120f, 0.04413958f, 0.04936080f, -0.15000662f, 0.20505704f, 
    0.06451743f, 0.05868125f, 0.11904900f, -0.16870902f, 0.05122539f, -0.09885098f, 0.04974294f, -0.10533831f, 
    0.13575125f, 0.24897058f, 0.13678411f, 0.10713854f, 0.33473358f, -0.12519823f, 0.19849871f, 0.05320683f, 
    -0.00621602f, -0.19110554f, 0.13500281f, 0.09964921f, -0.08391714f, 0.03502373f, -0.38540527f, 0.04636203f, 
    -0.00957553f, -0.09186707f, -0.11049550f, -0.30573040f, -0.12259503f, 0.03178885f, 0.11396506f, 0.09657884f, 
    0.05332877f, -0.19739324f, -0.47494733f, -0.03987688f, 0.13957852f, 0.27283350f, 0.24456486f, 0.11037590f, 
    -0.20165609f, -0.08554252f, 0.09557549f, 0.34346765f, 0.11446671f, -0.16699210f, -0.13708098f, 0.02786945f, 
    0.17111436f, -0.04910975f, -0.02229092f, 0.18257660f, -0.23393989f, -0.07657873f, 0.25194564f, 0.09341394f, 
    0.14892343f, -0.04237543f, -0.04716724f, 0.12950963f, 0.30476025f, 0.11801957f, 0.32235339f, -0.05308860f, 
    0.04381396f, -0.23591913f, 0.25746047f, 0.05272407f, -0.05110995f, -0.31245372f, 0.23862311f, -0.15978429f, 
    0.25045875f, -0.34974957f, -0.18209302f, -0.06281887f, 0.02860765f, 0.14518735f, 0.06637424f, 0.15690582f, 
    -0.23773983f, 0.30206245f, 0.10062485f, 0.17879765f, 0.09039907f, 0.09138293f, 0.00463859f, -0.16293573f, 
    -0.14757386f, 0.02334425f, -0.00065553f, 0.02947626f, -0.02168602f, 0.14792494f, -0.21561530f, 0.00567862f, 
    0.03680818f, 0.24366388f, -0.08842908f, 0.10380982f, -0.13968179f, -0.06941273f, -0.30230862f, -0.03213159f, 
    0.07450535f, 0.08110546f, -0.45662692f, -0.03578218f, 0.36450061f, 0.20383854f, 0.03809978f, 0.20251258f, 
    -0.07621282f, 0.27307469f, 0.13242573f, 0.17497964f, 0.27384359f, -0.16099785f, -0.06675671f, 0.02812035f, 
    -0.21085733f, 0.08942523f, -0.19137968f, -0.05703522f, -0.03647574f, -0.10456237f, 0.22401638f, -0.14889817f, 
    0.12492265f, 0.24584885f, 0.10852125f, -0.30337185f, -0.11272057f, 0.05133496f, 0.10941798f, 0.00420213f, 
    0.01534655f, 0.01149030f, -0.20519167f, -0.00857644f, 0.13143456f, 0.10933571f, 0.08999737f, -0.09670902f, 
    -0.10024592f, -0.06167410f, 0.13887334f, 0.20229870f, 0.07208004f, 0.17272732f, -0.13023131f, 0.43429863f, 
    0.02301841f, 0.19401710f, -0.22202370f, -0.02826308f, 0.15359175f, 0.09468238f, 0.12456691f, -0.13608684f, 
    0.23675972f, -0.12224713f, -0.27325556f, 0.17634067f, -0.08279447f, 0.34646609f, 0.00461896f, 0.01796098f, 
    -0.43448064f, -0.02116874f, -0.11156859f, -0.43735939f, 0.04589654f, 0.03063327f, 0.19086595f, -0.08577720f, 
    -0.04555002f, 0.06340689f, 0.24595274f, -0.00815736f, 0.36995658f, -0.17645036f, 0.09039415f, 0.00328469f, 
    0.02462926f, -0.07552011f, -0.23737802f, 0.03484811f, 0.23401137f, 0.10415375f, -0.19997142f, -0.08453653f, 
    0.17742528f, -0.10833592f, -0.24646378f, 0.09257132f, -0.36891797f, 0.11808554f, 0.26563865f, -0.13789281f, 
    -0.08149899f, 0.10851032f, -0.18247244f, -0.14320892f, 0.11680772f, -0.47431901f, -0.38897166f, -0.08125699f, 
    0.04352181f, 0.10926088f, 0.08426051f, -0.08888562f, -0.02019136f, -0.16823094f, -0.04490250f, -0.00594587f, 
    -0.17931934f, -0.14026041f, 0.06077529f, 0.09669464f, 0.10846534f, 0.12918140f, -0.07844865f, -0.12344898f, 
    0.17615148f, 0.00031703f, -0.01302108f, -0.17952833f, 0.11005910f, -0.23302373f, -0.04322015f, -0.07865185f, 
    -0.02084802f, -0.02923484f, 0.01659790f, -0.04137088f, 0.04517295f, -0.05181111f, -0.06909578f, 0.01353719f, 
    0.02478960f, 0.02852411f, -0.05495881f, -0.06673553f, -0.03112091f, -0.00544360f, -0.04703460f, 0.00865696f, 
    -0.03259696f, -0.02527495f, -0.02233190f, -0.01673385f, -0.06309095f, -0.03741925f, -0.03466883f, 0.01618136f, 
    -0.02017397f, 0.03783646f, 0.03139513f, 0.02264897f, 0.01756893f, 0.04438709f, 0.04012933f, -0.06282372f, 
    0.03097360f, 0.01047499f, -0.01799850f, 0.03954111f, -0.04945055f, 0.00244308f, 0.04081306f, 0.04026456f, 
    0.02276709f, -0.02037890f, 0.03726657f, 0.04967168f, -0.03752639f, 0.02071580f, -0.04140175f, -0.02217110f, 
    -0.04716601f, -0.04624702f, -0.04859802f, 0.00952662f, -0.00894329f, -0.04382844f, -0.06282765f, -0.02515554f, 
    -0.02763556f, -0.00103251f, 0.02721016f, -0.01380863f, -0.02757734f, -0.05077710f, 0.03749026f, 0.03214421f, 
    -0.01782694f, 0.01645085f, 0.00777597f, -0.05347082f, -0.04137130f, 0.00730362f, 0.01362076f, -0.01315961f, 
    0.02283899f, 0.01711973f, 0.04147171f, 0.04555266f, 0.03253832f, 0.00394414f, 0.02892321f, 0.01349003f, 
    -0.00960163f, -0.02606367f, -0.04972667f, -0.04605962f, 0.03153792f, -0.04858945f, 0.00766533f, -0.01937160f, 
    -0.04553041f, 0.01203958f, 0.02850564f, 0.00839081f, 0.01894552f, -0.02477685f, 0.03036928f, 0.03750321f, 
    -0.02035518f, -0.03609307f, -0.02155201f, -0.05647602f, -0.03148986f, 0.03402057f, -0.04950288f, 0.01038386f, 
    -0.01378339f, -0.05149006f, -0.03985889f, -0.00825081f, -0.02900271f, -0.01704911f, 0.01125958f, -0.04639899f, 
    -0.06018290f, -0.02367356f, -0.03848520f, 0.02678525f, -0.06138221f, -0.05589145f, 0.00988051f, 0.03005452f, 
    0.02125966f, -0.05426547f, -0.02145183f, 0.03050796f, -0.06150930f, 0.02027797f, 0.03554584f, -0.03098863f, 
    0.02265933f, -0.04104953f, 0.00978119f, 0.03327245f, -0.05944288f, -0.04690296f, 0.02181011f, 0.01930597f, 
    -0.03262959f, 0.05121049f, 0.02287636f, -0.03857600f, 0.01862781f, -0.03276465f, 0.01526916f, -0.02234976f, 
    0.02699204f, -0.00278727f, 0.00945624f, 0.02951441f, 0.03705634f, -0.07189617f, 0.01151153f, 0.03778416f, 
    -0.04215163f, -0.06574501f, 0.02391537f, -0.02726489f, -0.04587264f, -0.06207705f, -0.00382399f, 0.03823689f, 
    -0.00488864f, -0.01176244f, -0.00349774f, 0.05143733f, 0.04482852f, -0.00171949f, 0.03843275f, -0.01886440f, 
    -0.03085379f, -0.04665937f, -0.01318797f, 0.03024501f, -0.01797825f, -0.01713971f, 0.02065329f, -0.03319174f, 
    0.03628016f, 0.00675693f, -0.02823413f, -0.00059711f, 0.04282691f, -0.02372042f, 0.03655874f, -0.01649629f, 
    0.02914363f, -0.03580862f, 0.00550515f, 0.02556754f, 0.03212142f, 0.01155949f, -0.02339093f, -0.01546861f, 
    0.02858466f, 0.01542856f, -0.03627466f, -0.04293387f, -0.03820433f, 0.00536447f, 0.04120299f, -0.00511436f, 
    -0.00473650f, -0.03903293f, 0.03736247f, -0.06786986f, -0.05308769f, -0.03508168f, 0.02284484f, 0.01612448f, 
    -0.02978608f, -0.05197033f, -0.05191942f, -0.05784351f, 0.04170555f, -0.00026735f, -0.06400119f, 0.01725212f, 
    0.04275896f, -0.02137140f, -0.02510200f, 0.04298516f, -0.06165546f, -0.04285137f, 0.01530392f, -0.03701585f, 
    0.03258132f, -0.01187636f, 0.03361907f, 0.02329205f, -0.04425384f, 0.00807372f, -0.02949455f, 0.00411240f, 
    -0.04210246f, 0.02158779f, 0.00407902f, 0.00474438f, 0.02240779f, 0.04487234f, -0.06825363f, -0.00640926f, 
    -0.01798173f, 0.04773939f, -0.00167154f, 0.03961509f, 0.02705886f, 0.00418521f, -0.05138713f, 0.03709705f, 
    -0.00049637f, 0.03386876f, -0.00156162f, 0.01809904f, -0.05202779f, 0.04708666f, -0.04033588f, 0.03059486f, 
    -0.01367628f, -0.04044840f, 0.01549304f, -0.05010737f, -0.02730462f, 0.02772527f, -0.02974195f, -0.04149656f, 
    -0.03906335f, -0.03330885f, 0.00029516f, -0.04212331f, -0.01747732f, -0.02335397f, 0.00703907f, -0.03214689f, 
    0.02778529f, 0.02695003f, -0.02448112f, -0.03184264f, -0.02315267f, -0.05231037f, 0.03953708f, -0.05010233f, 
    -0.04376575f, 0.00438008f, 0.02012427f, 0.03561265f, 0.03717814f, 0.01730455f, 0.04092526f, -0.04007708f, 
    -0.04576694f, 0.02914369f, 0.00292430f, -0.06309511f, 0.02803764f, 0.01130739f, -0.01584248f, -0.03016117f, 
    -0.04920935f, 0.00712538f, -0.05202119f, 0.02956274f, -0.01665997f, -0.00243186f, -0.06614625f, -0.05058701f, 
    -0.06809914f, -0.04594281f, -0.07060898f, 0.00255970f, -0.04981218f, -0.01500406f, -0.03705432f, 0.04010911f, 
    -0.04963239f, -0.04264819f, 0.02722188f, 0.03827549f, -0.06104559f, -0.05325895f, -0.04573684f, 0.00230564f, 
    -0.01577500f, -0.03056931f, -0.00630361f, 0.02226369f, 0.02672093f, -0.02237460f, -0.05772673f, 0.02299416f, 
    -0.04510934f, 0.00145930f, 0.02372083f, 0.04784232f, -0.03641626f, 0.04354414f, 0.01549993f, 0.02147881f, 
    -0.05823207f, 0.03161034f, -0.03107157f, -0.00704846f, 0.04144373f, -0.02981357f, -0.04427934f, -0.00852875f, 
    -0.01947265f, -0.03629198f, -0.05709288f, -0.02123892f, 0.01655601f, -0.02297889f, 0.01655889f, 0.01223640f, 
    -0.02628527f, -0.03494802f, 0.00871375f, -0.01723211f, 0.01483247f, 0.01180898f, -0.00000118f, -0.05395914f, 
    0.03333781f, 0.02558374f, 0.00437179f, 0.04714916f, -0.02676519f, -0.05738864f, -0.01707911f, 0.03445525f, 
    -0.03098876f, 0.03744617f, 0.02109744f, -0.06237772f, 0.00937653f, -0.05410589f, -0.03356918f, 0.00663775f, 
    0.02182899f, -0.02976575f, -0.04583578f, 0.01126604f, -0.00451276f, 0.04062834f, -0.02906029f, 0.00483911f, 
    -0.04175146f, 0.00914901f, -0.01507742f, -0.05462155f, -0.03669032f, -0.02851115f, 0.04387996f, 0.03775585f, 
    -0.00580163f, 0.03716269f, -0.05237328f, 0.01941733f, 0.04400555f, 0.03085265f, -0.05573932f, -0.05875844f, 
    0.02794564f, 0.02963252f, -0.04845396f, -0.03866937f, -0.05775036f, 0.00087819f, -0.02284074f, -0.00284532f, 
    0.01002074f, -0.03999342f, -0.00811091f, -0.07201423f, 0.00417156f, 0.03132102f, 0.00467204f, 0.02826479f, 
    -0.01944939f, -0.00884785f, -0.06960598f, -0.06279830f, 0.01645025f, 0.00840226f, 0.01409775f, -0.01183228f, 
    -0.00725245f, -0.00431059f, 0.02159052f, 0.04266009f, -0.03696617f, 0.03819028f, 0.00126285f, -0.04766224f, 
    -0.06128112f, 0.02988938f, -0.02042377f, -0.06487226f, 0.04682728f, 0.03525073f, 0.02010133f, -0.05253837f, 
    0.01149435f, 0.00651444f, -0.03953113f, -0.00634616f, -0.07058422f, -0.06213584f, -0.00776819f, 0.02178462f, 
    0.03350987f, 0.02935506f, 0.01709293f, -0.06511284f, -0.04659919f, -0.01459473f, -0.00849589f, -0.02018716f, 
    0.01578618f, 0.01141317f, -0.04535557f, -0.04477008f, -0.01083582f, -0.00405154f, -0.03143413f, -0.06175568f, 
    0.01837566f, 0.03627667f, 0.00889906f, 0.02778273f, -0.02336434f, -0.02600038f, 0.04470226f, 0.01505015f, 
    -0.00907275f, -0.05024086f, -0.00276113f, -0.02357250f, -0.01259099f, -0.02359248f, 0.01944995f, 0.02379227f, 
    0.02885484f, -0.01642910f, -0.02106033f, -0.06159182f, 0.00081676f, 0.02513167f, 0.01162203f, -0.06788365f, 
    -0.02078563f, -0.04841411f, 0.04002198f, 0.03929418f, -0.03458538f, 0.01794626f, -0.02856183f, -0.03469330f, 
    0.03690330f, 0.04222649f, 0.01986130f, 0.02115277f, -0.01094590f, -0.01635692f, -0.05439974f, -0.04071235f, 
    -0.01154966f, 0.01509281f, 0.04934123f, 0.03514870f, 0.01018284f, -0.04647805f, 0.03794939f, 0.02108162f, 
    0.02372123f, 0.03206486f, -0.06398794f, -0.01216295f, -0.03880037f, 0.02861514f, 0.00176478f, 0.02000619f, 
    0.04463089f, -0.04202496f, -0.05889111f, -0.06213034f, 0.03901817f, -0.04523427f, 0.01240228f, 0.01681550f, 
    -0.00118417f, 0.04752855f, -0.04088899f, 0.00906030f, 0.02263947f, -0.03275938f, -0.04262960f, -0.03018554f, 
    0.02630038f, 0.01023593f, 0.03222272f, -0.02944180f, 0.04659263f, -0.06354462f, -0.05034392f, 0.03146195f, 
    0.00900971f, 0.02127884f, 0.03854644f, 0.01617993f, 0.02984342f, -0.05006283f, -0.06297402f, -0.04378072f, 
    -0.01967961f, 0.03062727f, -0.04767453f, -0.00000267f, -0.01873375f, -0.01379475f, 0.00168258f, -0.00075704f, 
    -0.00536712f, -0.04000549f, -0.05204342f, 0.01507834f, -0.05123640f, -0.00493802f, -0.01351550f, -0.01068117f, 
    0.00621606f, 0.02642485f, 0.01239938f, -0.03740148f, -0.04230000f, 0.02017728f, -0.01518608f, 0.02168237f, 
    -0.06765821f, 0.25678951f, 0.10224440f, 0.03394850f, -0.05620357f, 0.01668984f, -0.03073499f, 0.06975247f, 
    -0.14651203f, -0.17040896f, 0.19081779f, -0.20003584f, -0.12869611f, -0.09940911f, 0.04143329f, 0.19626132f, 
    0.03417830f, -0.18210033f, -0.15110062f, -0.10109139f, 0.37844682f, 0.36315653f, 0.01396854f, -0.00810344f, 
    -0.01677077f, 0.00832785f, -0.49059027f, 0.16692460f, 0.22710451f, 0.15291177f, -0.04923100f, -0.13789795f, 
    0.07835474f, -0.06996883f, 0.14243598f, 0.17765535f, 0.12447186f, -0.26785764f, -0.18406703f, -0.07979383f, 
    0.05952864f, -0.12676279f, 0.01420752f, 0.19703826f, 0.09987903f, -0.19166057f, -0.02080169f, 0.11884928f, 
    0.11256211f, -0.05166928f, -0.23803961f, -0.00192294f, -0.06011728f, 0.16866224f, -0.31205443f, -0.33795798f, 
    -0.21565995f, 0.04384506f, 0.02069490f, 0.13404825f, -0.09398352f, -0.05364479f, 0.00797476f, 0.00253018f, 
    -0.05718151f, -0.01641201f, -0.03485024f, -0.10286830f, -0.13588704f, -0.26986107f, 0.10605329f, 0.08053041f, 
    -0.26137811f, 0.25015336f, 0.09388196f, 0.01932886f, 0.18201779f, 0.12669234f, -0.02542984f, 0.07291076f, 
    0.14576958f, 0.21538261f, -0.04335140f, 0.09419814f, -0.21087682f, -0.21670513f, 0.13062671f, 0.06399441f, 
    0.15989126f, -0.14846812f, -0.01097635f, -0.27808011f, 0.13490632f, 0.06262058f, -0.13826333f, 0.13419740f, 
    0.07611958f, 0.20824458f, -0.12082269f, -0.25246403f, -0.06906094f, 0.00776952f, 0.08125418f, -0.29027802f, 
    -0.01075820f, -0.02451949f, -0.11935121f, 0.00811301f, -0.14504352f, -0.15174995f, 0.01854307f, -0.13110128f, 
    0.00704476f, 0.15729631f, 0.19568898f, -0.00474824f, 0.09189892f, 0.36088899f, 0.26126722f, 0.05649927f, 
    0.27881855f, -0.15722229f, -0.01740414f, 0.11615455f, -0.03202972f, -0.05490914f, -0.13579492f, 0.19678077f, 
    0.09423948f, 0.03940923f, 0.08385999f, -0.09304824f, 0.14578056f, -0.20977210f, 0.09535088f, -0.28395763f, 
    -0.11941075f, 0.23250492f, 0.00829626f, -0.03326408f, -0.03054183f, -0.17061734f, -0.04169050f, -0.13748346f, 
    -0.10862227f, -0.02794351f, 0.12032193f, -0.00749596f, -0.06370489f, 0.13059498f, 0.26740885f, -0.03411149f, 
    -0.14754274f, 0.02472406f, 0.05661914f, -0.05574787f, 0.27176407f, -0.02962822f, -0.10341215f, 0.20368955f, 
    -0.15631950f, -0.03492083f, -0.18929528f, -0.04648543f, -0.00921161f, 0.07858536f, -0.05886045f, -0.20780970f, 
    0.15623675f, -0.17212929f, 0.14550091f, 0.34990856f, 0.10861756f, -0.30254859f, -0.15860119f, -0.24911879f, 
    0.02566934f, 0.03453252f, -0.01811996f, -0.00821703f, 0.17187381f, 0.17870107f, 0.17855005f, 0.16937420f, 
    -0.00295934f, -0.01530668f, -0.17636016f, -0.01337610f, -0.28190792f, -0.01176168f, 0.11063929f, -0.24326943f, 
    0.40197381f, -0.05434437f, -0.17621341f, -0.03133038f, -0.09554021f, 0.11452214f, 0.12213861f, 0.08719952f, 
    0.19365707f, -0.01099957f, -0.14257498f, 0.01036997f, -0.00709625f, 0.28410351f, 0.21890014f, 0.10542632f, 
    0.33920261f, 0.04150016f, -0.22189718f, 0.01823564f, -0.01679395f, 0.15696070f, -0.05573613f, 0.30897003f, 
    -0.09279601f, -0.13942711f, 0.15780665f, 0.08654048f, -0.13939710f, 0.04534784f, 0.12771167f, -0.01557137f, 
    -0.18867663f, -0.05122704f, -0.33989257f, 0.06523951f, 0.07291804f, 0.04024149f, 0.15476833f, 0.13623838f, 
    0.01201428f, -0.62934881f, 0.04747451f, -0.09928274f, 0.36973652f, 0.04174020f, 0.00112259f, 0.21851076f, 
    0.06232322f, 0.08713880f, -0.13498318f, -0.11588512f, 0.18106337f, -0.06470209f, -0.36609519f, -0.11117408f, 
    -0.00281013f, 0.05128403f, -0.29482448f, 0.06949906f, 0.03383567f, 0.08411731f, 0.01962061f, 0.03031829f, 
    0.07550140f, -0.13819879f, -0.00904634f, 0.12664495f, 0.05087253f, -0.12487154f, -0.12184539f, -0.12009943f, 
    0.05023610f, 0.12910055f, -0.13720278f, 0.07353090f, -0.04641590f, -0.16616105f, 0.11038509f, -0.27118370f, 
    0.20178363f, -0.07955208f, 0.08160013f, 0.01638980f, 0.06362741f, 0.02637532f, -0.05862597f, 0.47728941f, 
    0.01729345f, -0.32760456f, 0.10032595f, -0.05715698f, -0.08724993f, 0.01316542f, 0.22292508f, 0.26586336f, 
    -0.23028524f, -0.54085702f, -0.01087372f, 0.30581099f, 0.06223519f, 0.13882166f, -0.01998674f, -0.07844638f, 
    -0.11260884f, -0.24174984f, -0.38847828f, 0.01205814f, 0.28095978f, 0.14981703f, 0.17568843f, -0.10135841f, 
    -0.03660268f, 0.07316950f, -0.38666838f, -0.30629221f, -0.23579089f, 0.07475995f, 0.22480313f, -0.06139486f, 
    -0.01241131f, -0.00175018f, -0.30563372f, 0.10936186f, 0.12212688f, -0.06035253f, 0.07787972f, -0.13104822f, 
    -0.09338006f, -0.03839424f, 0.26024407f, 0.05793376f, -0.36271292f, -0.17439194f, 0.01231859f, 0.02048842f, 
    0.00830341f, 0.03581103f, 0.02254003f, 0.28517112f, 0.17748567f, 0.40019828f, -0.42065817f, 0.46299931f, 
    0.13550617f, -0.04571131f, 0.16468215f, -0.00623522f, -0.12687483f, -0.08790146f, -0.50854242f, -0.49883640f, 
    0.11223011f, 0.04031991f, 0.03523731f, 0.03487892f, 0.03146905f, 0.07811262f, 0.07492582f, -0.47150984f, 
    -0.37720698f, -0.03826074f, -0.19748288f, 0.00758009f, -0.08608708f, -0.20245604f, -0.29239535f, 0.04186475f, 
    0.18768822f, 0.01749754f, 0.03274017f, 0.07611366f, 0.01045848f, -0.07882448f, -0.12381879f, 0.10338189f, 
    -0.01279273f, 0.02390211f, 0.14113419f, 0.04716188f, -0.08420926f, 0.05128408f, 0.02816024f, 0.12068107f, 
    0.24148244f, 0.03333327f, 0.00554576f, -0.07384222f, -0.14036843f, -0.02401571f, 0.16855256f, 0.15101805f, 
    -0.05871589f, 0.10404483f, -0.17244689f, 0.11129623f, -0.56839204f, 0.06108014f, 0.23644976f, 0.02128736f, 
    0.15891226f, -0.00296882f, -0.05025102f, -0.26799676f, -0.03922449f, -0.09045176f, -0.06069153f, -0.47682831f, 
    0.27472180f, -0.05441132f, 0.23718554f, -0.00088275f, -0.03194503f, -0.17090462f, -0.13995010f, -0.10559639f, 
    0.23024286f, -0.04660870f, 0.03074612f, -0.00962447f, 0.18895316f, 0.10363010f, 0.35696077f, 0.39431298f, 
    0.15138464f, -0.14802052f, -0.26996604f, 0.06705413f, 0.00808098f, -0.11452970f, 0.11458392f, 0.15726313f, 
    0.07295856f, -0.04618835f, -0.12868164f, -0.15852086f, -0.18331417f, 0.00284190f, 0.06094882f, 0.18137650f, 
    -0.64686495f, -0.30823645f, 0.02748029f, 0.05923760f, 0.30045408f, 0.07468046f, -0.05125691f, 0.02007216f, 
    0.00289044f, 0.62574846f, 0.05273816f, 0.20593108f, 0.10734174f, -0.02577274f, 0.14625636f, 0.11885030f, 
    -0.06179699f, 0.03385343f, -0.02322122f, 0.00320611f, -0.02044100f, -0.53821552f, -0.17759085f, -0.14299490f, 
    0.11539897f, 0.11772668f, -0.07568049f, -0.01796841f, 0.05938476f, 0.16734341f, 0.04747698f, -0.15787002f, 
    -0.10227794f, 0.03604541f, 0.30105412f, 0.13216367f, 0.31698897f, -0.23165458f, 0.19388503f, 0.02576095f, 
    -0.36555487f, -0.15582326f, 0.19705024f, 0.09784474f, -0.03351198f, 0.67606205f, 0.00015254f, 0.26699752f, 
    -0.01782302f, 0.12978078f, 0.20491749f, 0.10677948f, -0.02129986f, -0.06718176f, -0.09140342f, -0.10154245f, 
    0.05398712f, 0.14199057f, 0.08104533f, 0.25462130f, -0.15687381f, -0.16471925f, 0.15281984f, 0.16640159f, 
    0.08734067f, 0.28038129f, 0.27044171f, 0.20680088f, -0.04700846f, 0.26936656f, 0.18075159f, -0.09512810f, 
    0.18826830f, -0.89402306f, -0.25787932f, -0.11339248f, 0.19994086f, 0.08016300f, -0.05526748f, -0.15209368f, 
    -0.01433948f, -0.62233615f, -0.63692951f, -0.08160906f, 0.10063081f, 0.06997393f, 0.00523218f, 0.04593202f, 
    0.03859108f, -0.07327895f, 0.01257712f, -0.06416976f, 0.02617878f, -0.13365966f, -0.09067806f, -0.01709071f, 
    -0.04602512f, 0.27124843f, -0.04353337f, 0.11091308f, -0.26249626f, 0.14497159f, 0.00483226f, 0.05798006f, 
    0.06741621f, -0.01440735f, 0.12480182f, -0.05563603f, 0.39831290f, 0.14810105f, 0.09952446f, -0.12414456f, 
    -0.24154742f, -0.06501920f, 0.13910274f, -0.09032569f, 0.13981429f, -0.87404948f, -0.67278451f, -0.21585411f, 
    0.25909978f, -0.07179427f, 0.21494125f, 0.16045175f, 0.09696529f, 0.28050554f, -0.10103113f, 0.26168635f, 
    -0.08994897f, -0.05091162f, -0.12043890f, -0.04083365f, -0.09368827f, -0.11237852f, -0.17361380f, 0.37117174f, 
    -0.42707589f, -0.07583264f, 0.31938514f, 0.08592691f, 0.00432250f, -0.08938723f, -0.19451426f, 0.04114649f, 
    0.23727261f, -0.05266257f, 0.17548928f, -0.01827725f, -0.02575807f, -0.02286400f, 0.04050202f, -0.06023886f, 
    -0.05483453f, 0.50138676f, 0.01106932f, 0.18065721f, 0.26095396f, 0.06322967f, 0.06893502f, -0.17532139f, 
    -0.00698342f, -0.21572709f, 0.09851179f, 0.28153205f, 0.27634096f, 0.00123116f, -0.01125221f, -0.12971854f, 
    0.00945948f, -0.14900047f, -0.07832922f, -0.14960150f, 0.21146077f, -0.07555945f, 0.06071709f, 0.17607245f, 
    0.16599089f, -0.28144574f, 0.12970629f, 0.20231801f, 0.03590592f, 0.05135944f, -0.21063018f, -0.05723866f, 
    -0.07266931f, 0.04868526f, 0.05416518f, -0.25323486f, -0.18998349f, 0.27373174f, 0.15255159f, -0.03767201f, 
    -0.06049076f, 0.17055231f, -0.05507144f, 0.28053832f, -0.07791268f, 0.14560674f, 0.09307285f, 0.31673023f, 
    -0.11381183f, 0.08413667f, 0.06968447f, -0.07930017f, -0.05155057f, -0.01753014f, -0.06183409f, 0.13454165f, 
    0.01445065f, -0.43501917f, -0.09236086f, 0.18682468f, 0.10014673f, -0.10142584f, -0.20335294f, 0.03743519f, 
    0.23596752f, -0.11139596f, 0.31846359f, 0.10832965f, -0.08212432f, -0.17034326f, -0.22104090f, 0.03502992f, 
    0.05157980f, -0.30458122f, -0.26185322f, -0.26378152f, -0.08104508f, 0.05330573f, -0.03017555f, -0.01049081f, 
    -0.10189749f, -0.11291563f, -0.52727133f, -0.03799550f, 0.04231535f, 0.16765672f, 0.05357477f, 0.07019100f, 
    -0.30671862f, -0.05488407f, -0.19422868f, 0.23458456f, 0.18991747f, -0.00558741f, -0.00471611f, 0.08544089f, 
    0.18337199f, 0.26311487f, 0.01865982f, -0.09302587f, -0.30717817f, -0.18158692f, 0.11385971f, 0.01753162f, 
    0.17544352f, 0.10584027f, -0.16954869f, 0.06007752f, -0.01479129f, -0.41545939f, -0.03798033f, -0.44208452f, 
    0.14400372f, -0.01621852f, 0.02817753f, -0.16942492f, 0.04718145f, -0.08608124f, -0.16334677f, 0.10536913f, 
    -0.27720487f, 0.12249891f, 0.24441701f, 0.09292968f, -0.17927799f, -0.04734439f, -0.18524496f, 0.15517020f, 
    0.18447660f, 0.22706583f, 0.21894518f, 0.23725355f, -0.13849591f, 0.02717267f, -0.27549541f, 0.01401514f, 
    -0.07368901f, 0.01926587f, 0.01925458f, 0.01596897f, 0.07560630f, -0.03208885f, -0.22628465f, -0.12843992f, 
    -0.25868222f, 0.20560646f, 0.31129271f, -0.22594523f, 0.01573882f, 0.24501765f, 0.13113993f, 0.10508491f, 
    0.06202882f, -0.02255527f, -0.32260141f, 0.00138722f, 0.20470463f, 0.08334818f, 0.19687593f, 0.18762520f, 
    -0.19210197f, 0.01871927f, 0.16406187f, 0.15802433f, 0.29673675f, -0.12814213f, 0.08730046f, -0.10060553f, 
    0.07302536f, -0.03348525f, 0.02031697f, 0.20426807f, 0.07345729f, -0.01345489f, 0.10325976f, 0.22314407f, 
    -0.10803158f, 0.17561953f, 0.24327314f, -0.35025984f, -0.05551693f, 0.27570242f, 0.31507608f, -0.11183224f, 
    -0.05703724f, 0.11998726f, -0.10699819f, 0.20405196f, 0.01935541f, 0.12640516f, 0.24629192f, 0.05975606f, 
    -0.33526304f, -0.17234023f, 0.03297250f, -0.10316339f, -0.09789325f, -0.09259441f, -0.00106074f, 0.44843987f, 
    -0.22244112f, -0.11075119f, 0.09517308f, -0.20724241f, -0.15378028f, -0.03176611f, -0.07582995f, -0.08491486f, 
    0.30633438f, -0.19782139f, 0.00688116f, -0.13373610f, 0.10532653f, 0.01813827f, 0.16185425f, 0.26399115f, 
    -0.07819651f, 0.14800642f, 0.09230460f, 0.11762483f, -0.07436723f, -0.21020336f, -0.16692962f, 0.16659495f, 
    -0.03777007f, -0.07259714f, 0.09350920f, -0.05948485f, 0.46048918f, 0.18583956f, -0.19016546f, 0.13680832f, 
    -0.36857969f, -0.17893592f, 0.04625716f, -0.66131926f, -0.17502624f, -0.07763264f, 0.07227901f, -0.00357544f, 
    0.10433115f, -0.00850780f, 0.15853159f, -0.19797255f, -0.25501361f, -0.01381636f, -0.04993075f, 0.22117577f, 
    0.24558155f, 0.02023351f, 0.12420321f, -0.16030800f, 0.09612595f, 0.29147851f, -0.33098489f, -0.11329074f, 
    0.10969028f, 0.08885597f, -0.02816753f, 0.08928145f, 0.03231714f, -0.10813060f, -0.22317365f, 0.10253534f, 
    -0.07009706f, 0.08676855f, 0.19532719f, -0.04902302f, -0.18386051f, 0.06616795f, -0.08018947f, -0.23702343f, 
    -0.18501985f, 0.01056637f, -0.01585074f, 0.02114050f, -0.01245229f, 0.20984980f, 0.00509397f, 0.02617988f, 
    0.15336592f, -0.00142373f, 0.07352240f, -0.36040363f, -0.11092754f, 0.04729944f, 0.24371624f, 0.13676174f, 
    0.03353024f, -0.16413090f, 0.09075686f, 0.18591730f, -0.13290119f, -0.23933135f, -0.17608941f, -0.07486131f, 
    0.15070178f, 0.03737577f, -0.12264493f, 0.35824674f, -0.13211818f, -0.14062695f, -0.21379966f, 0.09548329f, 
    -0.20837666f, 0.04463940f, 0.06821785f, -0.02102697f, -0.24706346f, -0.04190975f, -0.00015452f, 0.06381594f, 
    0.18152274f, 0.08876453f, -0.01585798f, -0.28175333f, -0.10827390f, -0.18032043f, -0.27082530f, 0.26930827f, 
    -0.05080204f, 0.05589296f, 0.17086682f, 0.11783393f, 0.02254325f, 0.02380225f, -0.09154697f, 0.06214930f, 
    -0.06646170f, -0.18298164f, 0.19260114f, 0.20769261f, -0.02721271f, 0.02704708f, 0.02666357f, 0.07080731f, 
    0.01266549f, -0.14623968f, -0.11026344f, -0.08439722f, -0.16730903f, 0.16535072f, 0.05334916f, -0.48317137f, 
    0.00045121f, -0.01679446f, 0.18534318f, 0.15487762f, 0.02371338f, -0.11349048f, 0.11261329f, -0.09896675f, 
    0.43690717f, -0.08415517f, -0.02379983f, 0.30159402f, 0.00904635f, 0.36836809f, -0.02221588f, -0.23197947f, 
    0.09386764f, 0.12586811f, -0.29811803f, -0.03647079f, 0.23295605f, -0.03267470f, -0.08671582f, 0.02119610f, 
    0.12065388f, -0.10276969f, 0.48944122f, 0.42897058f, -0.01635513f, 0.17063890f, 0.00875875f, -0.06599045f, 
    0.00218489f, -0.02743996f, -0.09344657f, 0.09668151f, -0.19614701f, 0.04040486f, -0.11813863f, -0.10675737f, 
    0.06666623f, -0.04962638f, 0.18308713f, -0.03760710f, 0.21695510f, 0.01739876f, -0.06855217f, 0.06801000f, 
    0.16030321f, -0.06658188f, 0.17236093f, 0.07934797f, 0.00095919f, -0.08460066f, 0.07362290f, 0.11751003f, 
    -0.31157878f, -0.13249284f, -0.17269142f, 0.14791615f, 0.19393276f, 0.00360036f, -0.21303974f, -0.16924024f, 
    0.05075561f, 0.12177645f, 0.06398040f, -0.02687403f, 0.07478336f, -0.23004650f, 0.19088076f, -0.49983031f, 
    0.07461690f, 0.04516950f, -0.05243568f, 0.11502040f, 0.06198466f, -0.11911602f, 0.21532884f, -0.11848570f, 
    0.35196921f, 0.23118134f, 0.01951871f, -0.14165471f, -0.21008137f, -0.13808408f, 0.18990429f, 0.22182265f, 
    0.09819366f, -0.01450330f, -0.04521459f, 0.21382304f, -0.04235721f, -0.10733659f, 0.10027691f, -0.00232920f, 
    0.02869894f, 0.16889256f, 0.09920797f, 0.03101775f, -0.02210008f, 0.07549398f, 0.10902824f, 0.03819735f, 
    -0.04225376f, 0.09980636f, -0.15280519f, -0.23360960f, 0.13016559f, 0.26962632f, -0.24094492f, -0.19798292f, 
    0.02524247f, -0.19410056f, 0.00551152f, 0.02453008f, -0.14116199f, -0.65794390f, -0.09695703f, -0.08739125f, 
    0.12370349f, 0.04703924f, -0.13523826f, 0.18548283f, -0.20385148f, 0.05469123f, -0.01884113f, 0.20811448f, 
    -0.10534269f, -0.10550280f, 0.13321531f, 0.13390589f, -0.07260432f, 0.03043232f, -0.05129567f, 0.12230248f, 
    0.22352201f, -0.07067730f, 0.11520959f, 0.06519877f, 0.14931676f, 0.11475050f, 0.06772621f, -0.88395923f, 
    -0.00510296f, -0.03387084f, -0.11269644f, -0.12247023f, 0.05304801f, -0.25779271f, -0.12895334f, -0.00351951f, 
    -0.08132587f, -0.11828741f, 0.14321798f, 0.04613690f, 0.00012138f, 0.08771983f, 0.11633967f, 0.10458256f, 
    0.09973242f, 0.22498064f, 0.08357679f, 0.27404732f, -0.17750947f, 0.08970541f, -0.08820740f, 0.00318021f, 
    0.33028856f, -0.12326682f, 0.53952307f, -0.01764423f, -0.38333037f, 0.11198921f, -0.00035332f, -0.00567503f, 
    -0.22577710f, 0.02084591f, -0.13217369f, -0.41216806f, -0.15438096f, -0.07737124f, 0.15719956f, 0.10053022f, 
    0.06702486f, -0.00732992f, -0.12637505f, 0.03841399f, -0.49750161f, -0.43859035f, -0.00891130f, 0.06402210f, 
    -0.01079781f, -0.10262515f, 0.07758341f, -0.06420964f, -0.15471908f, 0.12735257f, 0.31923708f, -0.00428204f, 
    -0.21695897f, -0.07765450f, -0.12453011f, 0.08304345f, 0.11827778f, 0.22428863f, -0.55855030f, -0.02162610f, 
    0.36652827f, 0.23270059f, 0.06369965f, 0.10257379f, 0.02161030f, 0.07746738f, -0.16148347f, -0.19163425f, 
    -0.08884694f, 0.18608895f, -0.13915004f, -0.05379279f, -0.09149391f, 0.00012874f, 0.18547259f, -0.05450475f, 
    -0.01196602f, -0.00975694f, -0.06369165f, -0.01540073f, 0.05231734f, 0.00512718f, -0.05009514f, -0.05214528f, 
    -0.05935360f, 0.00161807f, 0.01542203f, 0.03895686f, -0.01303475f, 0.02740276f, 0.01305710f, -0.02066502f, 
    -0.05272482f, 0.00077884f, -0.06487487f, 0.04009195f, 0.01456094f, -0.02549264f, -0.04407739f, -0.05803762f, 
    0.02228249f, 0.01525845f, -0.05905690f, 0.03475356f, -0.00900082f, -0.05280020f, 0.05211449f, 0.04658518f, 
    -0.05185704f, -0.04877769f, 0.02622778f, -0.05382646f, -0.01277302f, -0.05617712f, -0.02122948f, -0.00117559f, 
    0.02814417f, 0.03192329f, 0.03270157f, -0.04964945f, 0.02972267f, -0.06618730f, 0.02286932f, -0.06051601f, 
    -0.05399792f, 0.02014187f, -0.05945852f, 0.02484333f, 0.02244259f, -0.06517788f, 0.00572234f, -0.06766272f, 
    0.01798977f, -0.04336253f, -0.03668908f, -0.02552837f, -0.02343160f, 0.00682358f, 0.00585707f, -0.03036440f, 
    0.02431404f, 0.01407247f, -0.05959323f, -0.00993041f, 0.05595936f, -0.01609964f, 0.02995260f, -0.03766353f, 
    -0.04430711f, 0.02138839f, 0.00234843f, -0.04784013f, 0.02065861f, -0.06603260f, -0.00338427f, -0.04907284f, 
    -0.03198741f, -0.00262275f, -0.04236243f, -0.02617995f, -0.03577044f, -0.02605731f, -0.03670312f, -0.00581236f, 
    -0.03392068f, 0.03509007f, 0.02777225f, -0.04547723f, -0.05028536f, -0.01701171f, 0.02789500f, -0.05156947f, 
    0.05243554f, 0.01324848f, -0.00344883f, -0.05785796f, 0.00779932f, -0.04371469f, -0.02659107f, -0.03117869f, 
    -0.01588866f, 0.01579457f, -0.01831939f, 0.02775653f, -0.04747231f, -0.03015584f, -0.00591809f, 0.03255952f, 
    -0.00366943f, 0.02949917f, -0.02191552f, -0.01349122f, -0.01365670f, -0.00819375f, -0.01141239f, -0.01692139f, 
    0.01152618f, -0.05633872f, -0.03871974f, 0.04529985f, -0.02283300f, -0.04935546f, -0.04843852f, -0.03855013f, 
    0.00474942f, 0.03131150f, -0.02334613f, -0.02321022f, 0.02891899f, 0.02650012f, -0.04927905f, 0.02990871f, 
    0.00002300f, -0.03871000f, 0.02179291f, 0.01759409f, -0.04101142f, 0.01593033f, -0.01791368f, 0.02903856f, 
    0.04326863f, 0.00558821f, 0.05134260f, -0.00808555f, -0.02251408f, 0.02309476f, -0.02090020f, 0.00571745f, 
    -0.03146756f, -0.03781107f, 0.04582519f, 0.03273228f, -0.01506604f, -0.01779831f, -0.04531057f, -0.05182089f, 
    0.00529586f, 0.03272100f, 0.02926455f, -0.01201344f, -0.05358034f, 0.04392293f, -0.02574752f, 0.03788396f, 
    -0.00631427f, -0.05990599f, -0.03298358f, -0.06205621f, -0.03820677f, -0.00683486f, 0.02992836f, 0.03956787f, 
    0.00043990f, -0.02761620f, -0.00614835f, 0.02252908f, -0.00126463f, 0.03724760f, -0.04117616f, 0.02415350f, 
    -0.00451012f, 0.01223694f, -0.02816618f, -0.02361010f, -0.05851493f, 0.02032150f, -0.02648560f, 0.04304276f, 
    -0.05430593f, 0.02605453f, 0.03500167f, 0.01525640f, 0.04137792f, 0.05166139f, 0.02436692f, 0.04124342f, 
    -0.04120203f, 0.00664782f, -0.03479465f, -0.00062486f, 0.01301259f, 0.00689339f, -0.01491604f, -0.01254139f, 
    0.00400990f, 0.00521441f, 0.05390623f, -0.01286793f, 0.00907497f, 0.01920140f, 0.00732483f, -0.01717522f, 
    -0.04379233f, -0.01334621f, -0.01491894f, -0.00053859f, 0.00974030f, 0.02152226f, 0.03341557f, 0.01462855f, 
    -0.02180809f, 0.00955160f, -0.06403396f, -0.02900677f, -0.00118907f, -0.00770851f, -0.04651758f, -0.02371523f, 
    -0.07280099f, 0.03382404f, -0.06477067f, 0.04525676f, 0.04895306f, 0.00365091f, -0.04735925f, 0.00338270f, 
    0.02967746f, -0.01083605f, -0.06888490f, 0.06493941f, -0.02023454f, 0.02342654f, -0.05420415f, -0.02091968f, 
    -0.02549317f, 0.00960820f, 0.02845038f, 0.02710051f, 0.05972744f, -0.01774405f, 0.02013305f, -0.04927334f, 
    0.03219524f, 0.04498499f, -0.04745713f, -0.04662565f, -0.03233351f, 0.00183835f, 0.02060488f, -0.02174024f, 
    0.03698814f, 0.04517038f, 0.04017473f, -0.02459967f, -0.02216201f, -0.02125528f, 0.05955325f, -0.00240713f, 
    0.02579479f, -0.02677113f, -0.01546244f, 0.01217780f, 0.04713372f, -0.04622917f, -0.03009485f, 0.01143968f, 
    -0.03604109f, 0.03250425f, -0.06225199f, -0.03189904f, 0.02686039f, 0.04594732f, 0.02359387f, 0.03346942f, 
    -0.00082477f, -0.16490188f, 0.24061053f, -0.12886269f, 0.09712870f, 0.13367958f, 0.11275781f, 0.14405352f, 
    0.14004952f, 0.43461299f, -0.07047364f, 0.06855579f, 0.11183993f, 0.11953077f, 0.00780136f, -0.09145610f, 
    0.04351999f, 0.13875215f, 0.22977935f, 0.13773450f, 0.07898828f, 0.10772012f, -0.09876356f, -0.23721887f, 
    0.02002234f, 0.23871450f, -0.07522671f, -0.20792514f, 0.12534577f, -0.24178515f, -0.04246113f, -0.00018076f, 
    0.00578053f, -0.02867181f, -0.03826241f, -0.28112015f, 0.12745924f, -0.12161560f, 0.03759951f, -0.05845343f, 
    -0.02717004f, -0.34441063f, -0.11528908f, 0.05639452f, -0.08058475f, 0.30493918f, 0.21095504f, -0.06336534f, 
    -0.06110840f, 0.05108976f, -0.00600902f, 0.11082184f, -0.15764676f, 0.19844525f, 0.57032126f, 0.20255035f, 
    -0.13624501f, 0.11340476f, 0.10698765f, 0.07540934f, 0.03001582f, 0.11695734f, 0.06920638f, -0.20913818f, 
    -0.09716771f, 0.02486002f, 0.00702913f, 0.25814420f, -0.08958828f, -0.01770571f, -0.05554230f, -0.06756503f, 
    0.10508745f, -0.03635133f, -0.20374449f, 0.00498088f, 0.13318530f, -0.02635699f, 0.05002125f, -0.00452827f, 
    0.08513699f, -0.54333496f, -0.01737283f, 0.16959821f, 0.15767202f, 0.25590411f, 0.08749146f, 0.19707680f, 
    0.20431840f, 0.07583325f, -0.39240813f, -0.06085106f, 0.21191277f, -0.04560525f, 0.08650790f, -0.02443208f, 
    -0.26205242f, -0.26041093f, -0.06877444f, 0.58283561f, 0.04118364f, -0.01796025f, -0.07294261f, 0.04914143f, 
    -0.01580474f, -0.01988915f, -0.04401454f, 0.11556550f, -0.09540612f, 0.27517241f, 0.03280800f, -0.10672232f, 
    -0.04499173f, -0.18528360f, -0.21583608f, -0.03962323f, -0.07793985f, -0.12936164f, -0.05577689f, 0.24189401f, 
    -0.09371983f, -0.21577090f, 0.05303978f, -0.10869220f, -0.02153623f, 0.13342655f, 0.08998360f, -0.11051803f, 
    -0.52640486f, -0.16463079f, 0.11431572f, 0.05867696f, -0.03423591f, -0.06702906f, -0.26682007f, 0.12078238f, 
    0.35255080f, -0.61271423f, 0.00644507f, -0.06015866f, 0.16363317f, -0.14870133f, 0.12247743f, -0.15394762f, 
    0.02790406f, 0.00596448f, 0.02556046f, -0.01835448f, 0.16251956f, -0.46326122f, -0.13325278f, 0.02103368f, 
    0.02588274f, 0.54829007f, 0.26116875f, -0.28457141f, 0.06128623f, -0.00620817f, 0.26922098f, -0.04789718f, 
    -0.12971084f, 0.00990890f, 0.23142779f, 0.08229880f, -0.50387627f, -0.09063080f, -0.03661231f, 0.12942941f, 
    -0.05743346f, -0.14947587f, -0.31430081f, -0.02054881f, 0.24860692f, 0.32103714f, 0.09411564f, -0.13052170f, 
    -0.15942459f, 0.16630417f, 0.03886626f, 0.06612370f, -0.39430344f, -0.19925788f, -0.15274800f, -0.12999865f, 
    0.11094692f, -0.03311135f, -0.03491469f, 0.05993841f, 0.03693714f, 0.60822487f, 0.08518460f, -0.42479965f, 
    0.16130236f, 0.18474114f, 0.15711159f, -0.03121998f, -0.14084187f, -0.09842270f, -0.17748068f, -0.05291226f, 
    0.20145434f, 0.02880568f, 0.12748151f, 0.11200621f, 0.00855629f, -0.00498934f, -0.13588467f, -0.28139779f, 
    0.01693225f, 0.02505346f, 0.30657923f, 0.05732052f, -0.09477833f, -0.04477150f, 0.17298718f, -0.06497166f, 
    0.13542627f, 0.05778040f, -0.04445746f, -0.10732699f, 0.10522450f, 0.14997011f, 0.01679127f, 0.03203128f, 
    0.08870514f, 0.30621871f, 0.04878730f, 0.09922583f, -0.01901667f, -0.07898641f, 0.10655982f, -0.00568099f, 
    -0.03239889f, 0.07387401f, 0.03108405f, 0.18979740f, -0.20956944f, 0.06978916f, -0.13042361f, -0.07167990f, 
    -0.01971132f, 0.14971963f, -0.12589212f, -0.28189516f, -0.12501127f, 0.16760403f, -0.05529558f, -0.12470705f, 
    -0.09666076f, -0.07847729f, 0.06528357f, 0.18866038f, 0.34986892f, -0.36968663f, -0.31496769f, -0.17156065f, 
    -0.11484846f, 0.08332755f, 0.04954633f, 0.21554603f, -0.10209407f, 0.28006440f, -0.15044954f, 0.50338084f, 
    0.10536403f, 0.30852956f, 0.26475242f, 0.05355982f, 0.22268008f, 0.06365564f, -0.17613694f, -0.00255129f, 
    0.16594993f, -0.18015283f, 0.09709281f, 0.06183207f, -0.04353811f, 0.17284234f, -0.46736810f, -0.03172134f, 
    -0.16088644f, -0.23743765f, 0.21022122f, -0.05773237f, 0.23463458f, 0.05890164f, -0.12853411f, -0.00451094f, 
    -0.44176316f, -0.06214846f, -0.06040890f, 0.13196020f, 0.11218999f, 0.01058354f, -0.07635832f, -0.08935802f, 
    0.04895696f, -0.19042808f, -0.28848109f, 0.02077380f, 0.13334419f, 0.06968131f, -0.12268803f, 0.04128538f, 
    -0.16828537f, 0.03218039f, 0.25421265f, -0.73801821f, -0.47042879f, -0.21964492f, -0.14133051f, -0.10806642f, 
    -0.17716366f, 0.17902368f, 0.03622339f, 0.05450068f, -0.10689473f, -0.10054053f, 0.14341038f, 0.07339021f, 
    0.11516039f, 0.02550215f, -0.09312714f, -0.10620014f, 0.05143894f, 0.03978962f, -0.04775945f, -0.01279239f, 
    -0.06957227f, 0.11052351f, 0.11160137f, -0.03882895f, 0.14560805f, -0.45580342f, 0.19020776f, 0.02297169f, 
    0.18254237f, 0.12632376f, 0.07847541f, -0.01438132f, -0.01436651f, -0.33313364f, -0.75500786f, -0.03463415f, 
    -0.03352820f, 0.18202892f, -0.11181388f, -0.15998082f, 0.06430979f, -0.22156250f, 0.12465846f, -0.02389323f, 
    0.02017674f, -0.17185995f, -0.16337055f, -0.34533659f, 0.10776490f, -0.18526101f, 0.20359305f, -0.04029442f, 
    0.12399390f, 0.17197575f, 0.08767574f, -0.00034340f, -0.07138740f, -0.05023495f, 0.12125100f, -0.02139844f, 
    0.12164387f, -0.05598223f, 0.26210529f, -0.08931960f, 0.11515632f, 0.05905912f, 0.27449653f, -0.17071369f, 
    0.22545788f, 0.05832696f, 0.46790066f, 0.38165960f, -0.06974053f, -0.09426252f, -0.21361940f, -0.05632189f, 
    0.21853034f, 0.00700476f, -0.02767555f, -0.69811457f, 0.06884574f, -0.14493172f, 0.34948498f, 0.04488582f, 
    0.08623891f, -0.35576916f, -0.01342573f, -0.07728419f, 0.06358620f, -0.00612765f, 0.02625372f, -0.00718535f, 
    0.02563413f, -0.15164636f, -0.13982631f, 0.15242454f, -0.10154016f, 0.02186586f, 0.06855176f, -0.53593445f, 
    0.21250598f, 0.06520876f, -0.04937088f, 0.01892429f, -0.06983355f, 0.03579844f, 0.42700630f, 0.30581230f, 
    -0.20130333f, 0.08088091f, -0.00317567f, 0.17700136f, -0.21569060f, 0.09769639f, 0.18935528f, 0.19523868f, 
    0.01215893f, -0.00597336f, 0.50178033f, 0.10140976f, -0.02813969f, -0.17057309f, -0.08158416f, -0.03735324f, 
    0.35000178f, -0.13042860f, 0.07684732f, -0.17636430f, -0.05636670f, -0.15455262f, 0.08037970f, -0.05944595f, 
    -0.12265719f, 0.29358047f, 0.39601284f, 0.08126935f, 0.08469904f, -0.06238532f, 0.17601581f, -0.08055090f, 
    0.13348606f, 0.12698568f, -0.24251786f, -0.03580127f, -0.05356550f, -0.26218855f, 0.04451272f, -0.02052789f, 
    0.15992847f, 0.01593165f, -0.03576342f, -0.07833175f, -0.36834928f, 0.00795377f, 0.01143175f, 0.00685343f, 
    0.11222862f, 0.11175511f, 0.03999497f, 0.01116920f, 0.21806818f, 0.01471813f, 0.00491207f, -0.18816809f, 
    -0.07285379f, 0.19627029f, -0.13830364f, 0.09579561f, 0.04471258f, 0.11372513f, 0.39241594f, 0.25779939f, 
    0.11994586f, -0.06461564f, 0.16816352f, -0.10883588f, 0.08573371f, 0.10617222f, 0.01596037f, 0.12006366f, 
    0.10366476f, 0.12639436f, 0.09575693f, 0.21031931f, -0.19617496f, -0.04804560f, -0.04710655f, -0.13335924f, 
    -0.23654136f, 0.17761567f, 0.15936391f, 0.09823205f, 0.24120705f, 0.00653659f, -0.08609968f, -0.18900710f, 
    -0.83912641f, -0.08494399f, -0.53483486f, 0.34611106f, 0.25046390f, -0.25051251f, -0.17456268f, 0.09626858f, 
    0.08211909f, -0.58921218f, 0.03811987f, 0.00933521f, -0.09638059f, -0.02563773f, -0.00330908f, 0.04726002f, 
    0.13258977f, 0.19101690f, 0.23590897f, -0.02782288f, -0.08737525f, -0.21515937f, 0.07778297f, -0.35812214f, 
    -0.06247083f, 0.06074599f, 0.02864506f, 0.12552251f, -0.15705004f, -0.05572733f, -0.02710599f, 0.02370274f, 
    0.08568858f, 0.03841068f, 0.15458496f, 0.07197056f, 0.01929772f, 0.04211112f, -0.10964211f, -0.03447671f, 
    0.02580168f, 0.21112797f, 0.03903821f, 0.08024345f, -0.10202205f, -0.64772880f, -0.18141617f, 0.16469051f, 
    0.11943816f, -0.04046780f, -0.03845800f, 0.35052475f, -0.10836300f, 0.05541207f, 0.09636047f, 0.02655116f, 
    -0.06608770f, -0.38885623f, 0.10145269f, -0.23117252f, -0.05740748f, -0.04907857f, 0.07781642f, 0.23025806f, 
    0.19631770f, 0.11735804f, 0.12791108f, 0.33745131f, -0.09294970f, -0.04025052f, 0.06222279f, -0.07593425f, 
    -0.08345389f, 0.30456293f, 0.02524465f, 0.16616447f, -0.09929579f, -0.05513918f, 0.22405078f, -0.01273354f, 
    -0.17750940f, 0.04366118f, -0.00514469f, -0.14342853f, -0.05778446f, 0.14485888f, -0.07619311f, 0.02074760f, 
    0.07446580f, -0.09205999f, -0.03426007f, -0.28699917f, -0.41289124f, 0.07337538f, 0.21625493f, 0.03097497f, 
    -0.00874998f, -0.04195406f, -0.03039589f, -0.01408829f, 0.05177406f, 0.15758553f, -0.15030673f, 0.09473860f, 
    -0.01578533f, -0.05359708f, -0.11025327f, -0.06427351f, 0.29597086f, 0.10861777f, -0.00803138f, -0.00953088f, 
    0.05626114f, 0.07784446f, -0.13296862f, 0.02570563f, -0.03863767f, -0.31813386f, -0.23108876f, -0.39924422f, 
    0.09462876f, 0.23911276f, 0.16092862f, -0.14078452f, 0.10164228f, -0.12916370f, 0.20815659f, 0.18666190f, 
    -0.00170752f, 0.20668589f, 0.06006637f, 0.02034925f, 0.02735587f, -0.09507069f, 0.14914283f, 0.18124066f, 
    -0.25326777f, -0.05884474f, 0.10642104f, 0.24692538f, -0.23804565f, 0.06825032f, 0.07544199f, 0.17936715f, 
    0.04309306f, 0.09380066f, 0.34904462f, -0.05126828f, 0.06946652f, -0.10378879f, 0.09129916f, -0.09294103f, 
    -0.07013272f, 0.11037301f, -0.01130159f, 0.12623884f, -0.12090637f, 0.04238090f, -0.14766398f, -0.11242225f, 
    -0.00196401f, 0.07802496f, 0.51706928f, 0.13262418f, 0.32626447f, -0.15273829f, -0.23882949f, 0.17732757f, 
    -0.06047960f, 0.00841646f, 0.05767276f, -0.08725342f, 0.10104781f, -0.40797511f, 0.27579239f, 0.28376123f, 
    0.04888671f, 0.03298099f, 0.03097756f, 0.08289478f, -0.06078662f, 0.07017729f, 0.33051613f, 0.08755577f, 
    0.12351725f, 0.10254700f, -0.14672945f, 0.09291394f, 0.02524933f, 0.15342265f, -0.14851025f, -0.58809298f, 
    0.21384370f, 0.07385678f, -0.12773499f, 0.14607787f, 0.12430304f, 0.04488554f, -0.30003238f, -0.08676400f, 
    -0.46039528f, -0.36061484f, -0.29475668f, -0.10049181f, -0.00947527f, -0.24194226f, -0.19562745f, -0.08931405f, 
    0.11179477f, 0.40518174f, 0.25811934f, 0.01615016f, -0.26675171f, -0.05676929f, 0.05920404f, -0.21250547f, 
    0.23818663f, -0.00510598f, -0.10392948f, -0.14434798f, -0.00669274f, 0.09607177f, -0.13315825f, 0.28690848f, 
    0.10712660f, -0.16587864f, -0.18501210f, -0.34638873f, 0.22390708f, -0.21491025f, -0.03978132f, 0.07430478f, 
    -0.08564893f, -0.06764194f, -0.22471857f, -0.09420913f, 0.28846127f, 0.01854671f, 0.00664489f, -0.00321924f, 
    0.03576797f, 0.12552464f, 0.10955281f, 0.06147550f, 0.10280881f, -0.15853339f, 0.07595803f, -0.07447968f, 
    -0.23684020f, 0.10825855f, -0.10943746f, -0.15877673f, 0.04281131f, 0.21759310f, 0.46702608f, 0.07867896f, 
    -0.03776159f, 0.08301524f, -0.03169613f, -0.10870086f, 0.11998281f, -0.11126125f, -0.03885907f, -0.28928170f, 
    0.02316710f, -0.06425261f, -0.14230551f, 0.16998802f, -0.00806583f, -0.26937824f, -0.24987154f, -0.12985346f, 
    -0.09992207f, -0.03245133f, 0.09692914f, -0.00840868f, -0.08009827f, 0.03458047f, 0.14560881f, 0.04719629f, 
    0.19694838f, -0.10491239f, -0.04547955f, -0.06655005f, 0.09847379f, 0.03869151f, -0.00265803f, -0.08542246f, 
    0.05973279f, 0.05424014f, 0.07966790f, 0.26454902f, 0.05060187f, 0.04105595f, -0.19062398f, 0.08274445f, 
    0.31653091f, -0.45096475f, -0.12269124f, 0.03333591f, 0.17900617f, 0.14597464f, -0.14364630f, -0.02484490f, 
    0.05206062f, -0.06813406f, -0.12257361f, 0.32235715f, 0.58202308f, -0.11015257f, -0.07042150f, 0.01135068f, 
    -0.05111725f, 0.14118750f, 0.21052784f, 0.28956714f, -0.14209856f, -0.23613964f, -0.29931277f, 0.01048030f, 
    0.06540462f, -0.03549503f, 0.19636916f, 0.05064654f, -0.17209023f, -0.19133189f, -0.15574487f, 0.25530967f, 
    -0.10180838f, -0.09783327f, 0.00260681f, -0.04695645f, 0.32852590f, 0.17819361f, 0.20920351f, -0.01899048f, 
    0.10320559f, -0.05472582f, 0.04013025f, 0.22488050f, 0.18914951f, -0.16635486f, 0.08823983f, -0.36368272f, 
    0.06883409f, -0.10537472f, -0.11433305f, -0.05864470f, 0.04175397f, -0.12111427f, 0.16684313f, -0.16357942f, 
    -0.17510192f, -0.35964975f, 0.14982994f, -0.02009110f, -0.13869594f, -0.05049518f, 0.11565254f, -0.01017959f, 
    -0.14176454f, 0.04232100f, -0.00088987f, 0.09068134f, -0.08789217f, 0.13519336f, 0.03241511f, 0.12057076f, 
    0.05536208f, 0.29165474f, -0.04743070f, 0.04981507f, -0.15669242f, 0.07874352f, 0.16020547f, 0.06635505f, 
    0.00952747f, 0.07627491f, 0.29995885f, -0.32257059f, -0.24649566f, -0.38426813f, -0.04053296f, 0.08731162f, 
    -0.10014012f, 0.02923647f, -0.09257757f, -0.31726527f, 0.08646160f, -0.02750684f, 0.24082772f, 0.16035992f, 
    0.05947595f, -0.10463760f, -0.18504854f, -0.09645935f, -0.03281540f, 0.24641372f, -0.01562121f, 0.04564796f, 
    -0.09400142f, -0.08107150f, -0.05288834f, 0.13260978f, -0.08734766f, -0.03235944f, 0.00504827f, 0.19876228f, 
    -0.21488166f, 0.01101709f, -0.10153411f, 0.05693876f, -0.01133112f, 0.04298103f, -0.01888848f, 0.09727549f, 
    0.22072473f, -0.04723645f, -0.05374719f, 0.16041037f, -0.04421974f, -0.05307065f, -0.08515523f, -0.31258270f, 
    0.04214832f, -0.35516670f, 0.11362547f, -0.00723605f, 0.16097121f, 0.22563490f, -0.09799457f, -0.16873482f, 
    0.00055238f, -0.28261203f, -0.38770637f, -0.13443652f, 0.02741878f, 0.03319509f, 0.08675274f, 0.08833545f, 
    -0.16140099f, -0.28406265f, -0.08981012f, -0.19430193f, -0.00237763f, -0.11856790f, 0.03608475f, -0.33217117f, 
    0.04343703f, 0.17463669f, 0.13045859f, 0.45519450f, 0.15825844f, -0.09699136f, 0.11212367f, 0.08588346f, 
    0.04176424f, 0.02878485f, -0.15849149f, 0.03353997f, 0.09332892f, 0.04897001f, -0.08980823f, -0.18182470f, 
    -0.05157364f, -0.07437754f, 0.14233716f, 0.07977324f, 0.52973855f, 0.08618454f, -0.25422153f, 0.25262025f, 
    0.18604505f, 0.11329933f, 0.29638833f, -0.09284192f, -0.05292941f, 0.17292407f, 0.11794312f, 0.41118297f, 
    -0.05689421f, 0.37093332f, -0.00584025f, -0.15327033f, 0.02293478f, 0.04559426f, -0.06637570f, -0.46788874f, 
    -0.08234407f, -0.01197639f, 0.12200624f, 0.04677577f, -0.12805308f, 0.25250798f, 0.04721633f, -0.25812319f, 
    0.09500815f, 0.02908313f, 0.16037503f, 0.01926479f, -0.03573645f, 0.25335321f, -0.06714105f, 0.14992011f, 
    0.38969481f, 0.13065425f, 0.13428986f, 0.03704666f, -0.07743352f, -0.00299596f, 0.44292036f, 0.19485943f, 
    -0.03180626f, -0.14906278f, -0.18416052f, 0.24048311f, -0.15026659f, -0.00650162f, -0.04193748f, -0.04015855f, 
    0.05360453f, 0.14155349f, -0.02341114f, 0.10022470f, -0.29944551f, 0.16141409f, 0.00356442f, 0.08770687f, 
    0.16741310f, -0.09428781f, 0.11725827f, -0.13924305f, -0.49918711f, -0.01697542f, -0.17016096f, -0.19973318f, 
    -0.17957307f, -0.05956538f, 0.01167924f, -0.06096039f, -0.00499648f, 0.01897630f, -0.47456884f, 0.02502105f, 
    -0.08353962f, -0.01908070f, -0.25503141f, 0.08515397f, 0.14359529f, -0.10468294f, -0.14488846f, 0.25761551f, 
    -0.17393000f, 0.10238738f, 0.03265310f, -0.28074732f, 0.10196626f, 0.14732514f, -0.03219961f, 0.18339045f, 
    0.16467033f, 0.12107337f, 0.07046473f, 0.01588465f, 0.16234276f, 0.11634935f, -0.12341090f, 0.04782474f, 
    -0.59495687f, 0.06601927f, -0.13100892f, 0.05590922f, -0.01464280f, -0.07320005f, -0.13000478f, 0.07517964f, 
    0.18388297f, 0.22506721f, 0.28398484f, 0.15884727f, 0.05371200f, -0.15381439f, -0.20694096f, -0.03150117f, 
    0.07871166f, 0.28740036f, -0.12405875f, 0.00437936f, -0.04346388f, -0.05294122f, 0.11878039f, 0.08279483f, 
    0.01643656f, 0.25248063f, -0.59190339f, -0.05430933f, -0.32832029f, 0.15475592f, 0.22798163f, 0.14039037f, 
    -0.02439765f, -0.13292545f, 0.11217117f, 0.22364269f, -0.12504463f, -0.45336053f, 0.12352399f, 0.08288686f, 
    0.09757281f, 0.10174267f, -0.12763055f, 0.14823477f, -0.23920794f, -0.00077554f, -0.45594350f, 0.06123668f, 
    0.10090651f, -0.08364698f, 0.10399890f, -0.13891195f, 0.09452108f, -0.35687602f, -0.06049614f, 0.12283372f, 
    -0.07319085f, 0.06104904f, -0.12321889f, 0.06262923f, -0.14960434f, -0.11995944f, -0.94011861f, -0.24769670f, 
    -0.05223135f, 0.09380346f, -0.04592850f, -0.02708057f, -0.18240780f, 0.14791860f, 0.13443960f, 0.23711982f, 
    0.15819070f, 0.20214307f, 0.00133480f, -0.00973674f, 0.01210306f, -0.04879160f, -0.01039327f, -0.11529592f, 
    -0.20075934f, -0.01007303f, -0.03757796f, 0.07118047f, 0.03617558f, 0.01062788f, 0.06350674f, -0.04262085f, 
    0.25539252f, -0.01431440f, -0.01476791f, 0.04339204f, 0.11089978f, 0.01910018f, -0.14236467f, 0.18696697f, 
    0.10533044f, 0.13218966f, -0.17867741f, 0.10067269f, -0.19960991f, -0.06040480f, 0.04262486f, -0.30253059f, 
    0.12902939f, 0.14171363f, 0.00726059f, -0.04695993f, 0.03361857f, 0.34571010f, 0.16601606f, -0.23491105f, 
    -0.08281887f, 0.00028115f, -0.12555197f, -0.10601683f, -0.25028691f, -0.10602014f, 0.13098754f, 0.33259922f, 
    -0.02015504f, -0.04778162f, 0.20507416f, -0.06065495f, -0.13826253f, 0.05066508f, -0.11957888f, 0.12276330f, 
    -0.40297651f, 0.04692160f, -0.03782254f, -0.17495051f, 0.01060247f, -0.00557963f, -0.17349619f, -0.11953784f, 
    0.22621433f, 0.03760238f, -0.09543467f, -0.09304857f, 0.21513818f, -0.07856949f, -0.03869099f, 0.36337668f, 
    0.00386918f, -0.17586483f, 0.07256752f, 0.21817602f, 0.20842217f, -0.06881848f, 0.04615511f, -0.14248651f, 
    0.08428721f, 0.07202112f, -0.00961804f, 0.04752771f, 0.25699356f, 0.15301721f, 0.00174390f, -0.01212990f, 
    0.10614745f, -0.12042242f, -0.08593254f, -0.02692835f, 0.02433586f, -0.21402442f, 0.09513151f, -0.24300694f, 
    0.17804572f, -0.19068402f, 0.35872614f, 0.34354526f, -0.03061124f, 0.40380815f, 0.11245427f, 0.00940591f, 
    0.29689017f, 0.15998067f, 0.04301747f, -0.34597069f, -0.01119771f, 0.17533131f, -0.16087623f, -0.00753730f, 
    0.01758558f, -0.10181613f, 0.02108024f, -0.04992485f, 0.43444806f, 0.04583295f, 0.17748852f, 0.07260872f, 
    0.03086898f, -0.16685350f, 0.17857020f, 0.00917133f, 0.06953624f, -0.31994218f, 0.18265870f, 0.02625014f, 
    0.08391631f, -0.12065410f, 0.18092389f, -0.21669084f, 0.19421017f, 0.01309906f, -0.11557447f, -0.24875237f, 
    -0.00425473f, 0.08435808f, 0.03351912f, 0.02982112f, -0.02700730f, -0.10765713f, -0.30696544f, 0.24983290f, 
    0.36521074f, 0.11663371f, 0.15311454f, -0.22811823f, 0.09198056f, 0.32237381f, 0.25502643f, 0.14550003f, 
    0.10203634f, 0.04774546f, -0.16856085f, 0.10828546f, 0.13447995f, -0.04041717f, 0.08623783f, 0.20056510f, 
    0.15791216f, -0.21453206f, -0.40268809f, -0.00936758f, -0.33234236f, -0.00241176f, 0.09538747f, -0.07637620f, 
    -0.23203513f, -0.01978375f, 0.29309067f, 0.36356491f, 0.07853200f, -0.10273799f, 0.00898615f, 0.02435482f, 
    -0.13635741f, -0.02387533f, -0.33192262f, -0.24336699f, -0.19051297f, -0.13278578f, -0.06841380f, 0.00459371f, 
    -0.14076455f, -0.06837757f, 0.12924899f, -0.05485694f, -0.11577724f, 0.22691521f, -0.10406437f, -0.07220325f, 
    -0.12573691f, 0.25772977f, 0.05535244f, 0.09910773f, -0.16532233f, -0.13670865f, -0.23444119f, 0.03134674f, 
    -0.45437199f, -0.01172539f, 0.16753966f, -0.14192861f, 0.07573316f, -0.22878574f, 0.10697425f, -0.18919897f, 
    0.07879744f, 0.19646576f, 0.22127251f, 0.28516060f, -0.19854763f, -0.19152641f, -0.03328329f, 0.10566182f, 
    -0.09493849f, 0.08467090f, -0.03077109f, -0.02325812f, 0.06981640f, -0.14658548f, -0.01875961f, -0.11684381f, 
    -0.53449279f, 0.03342388f, 0.03666335f, -0.07329612f, -0.21589714f, -0.05046605f, 0.19556372f, -0.11106180f, 
    0.23941177f, 0.39011505f, -0.08984271f, -0.20080255f, -0.32720944f, -0.02295223f, 0.07010355f, 0.04851788f, 
    0.06940211f, 0.18777965f, 0.05836308f, 0.28459692f, -0.11369728f, 0.18758094f, 0.06036632f, -0.33212048f, 
    -0.06133052f, 0.29479674f, 0.12286092f, 0.27360103f, -0.01785171f, 0.02498066f, 0.16603842f, 0.18059625f, 
    -0.22339231f, 0.18157260f, 0.29321051f, -0.18318458f, -0.02855571f, -0.00587449f, 0.22201066f, 0.04984137f, 
    -0.06105724f, -0.04763982f, 0.11553583f, -0.13260026f, -0.52885598f, -0.11627547f, -0.05804526f, -0.07260250f, 
    -0.03915776f, -0.14368525f, -0.15037565f, 0.31326595f, 0.03123166f, 0.06731983f, 0.26074964f, 0.43362269f, 
    0.01317597f, 0.10407498f, -0.31960034f, -0.16210592f, 0.08015049f, 0.07688134f, -0.25299433f, -0.04057345f, 
    -0.00348063f, -0.00576081f, -0.11218349f, -0.01706170f, 0.03821142f, -0.19430068f, -0.02146218f, -0.20162715f, 
    0.21782485f, -0.10320787f, 0.01251922f, -0.17957930f, -0.33330452f, -0.23142383f, 0.12939739f, 0.11307933f, 
    -0.05863877f, 0.39211997f, 0.20175724f, -0.10249604f, 0.05075720f, -0.34221146f, -0.08926588f, -0.12439177f, 
    -0.10495603f, -0.14572306f, -0.45015183f, 0.17073253f, 0.12563008f, 0.21844213f, -0.29245031f, -0.10163821f, 
    -0.10598444f, 0.06209553f, -0.25756490f, 0.09289113f, -0.14159638f, 0.28581119f, 0.28406334f, 0.04642107f, 
    0.06083551f, 0.03865911f, -0.07997783f, -0.12760386f, -0.02212392f, -0.31076404f, 0.06611405f, 0.03724145f, 
    -0.10216600f, -0.12630427f, 0.10891899f, -0.00064280f, 0.02969318f, 0.11459564f, -0.35511050f, 0.06231552f, 
    -0.14321798f, -0.06655900f, 0.13259843f, -0.29683432f, 0.02066731f, 0.05231505f, -0.29092941f, 0.02428880f, 
    -0.06639052f, 0.02635752f, -0.03316647f, -0.00234650f, -0.01264118f, -0.04096144f, 0.16971998f, 0.32040310f, 
    0.33729231f, 0.06267095f, 0.00033435f, -0.12372687f, 0.00343561f, -0.03228522f, 0.10271729f, 0.02254575f, 
    0.26457894f, -0.15089966f, -0.15360802f, -0.14255938f, 0.27951092f, -0.07442703f, -0.03082987f, -0.05062244f, 
    -0.18955174f, 0.18335535f, -0.38913119f, -0.06306521f, 0.11143377f, -0.14957196f, -0.10692833f, 0.10335968f, 
    -0.24474984f, 0.07701453f, 0.04353520f, 0.59643829f, 0.30791116f, 0.22097531f, 0.02651321f, -0.25622758f, 
    -0.05021682f, 0.02613394f, 0.18113433f, 0.05282569f, -0.37586683f, 0.12543394f, -0.03988278f, -0.16534913f, 
    0.15060477f, -0.09724303f, -0.08105589f, 0.00337202f, -0.11406942f, 0.12133371f, 0.15285777f, 0.18960108f, 
    -0.00126172f, -0.07981983f, 0.13094760f, -0.02748989f, -0.11788808f, 0.06060079f, 0.00929389f, -0.29131597f, 
    -0.00963180f, -0.08764775f, 0.09571422f, -0.08383468f, 0.03682196f, 0.17233624f, 0.12188561f, -0.48820442f, 
    -0.02119740f, 0.16025685f, -0.15719426f, 0.05212477f, -0.23357788f, -0.15999269f, -0.23241274f, 0.18151699f, 
    0.09713134f, 0.47250238f, -0.08081998f, -0.12502609f, -0.00210164f, -0.08438117f, -0.16511300f, 0.01055138f, 
    0.05435523f, -0.06618516f, 0.14022695f, -0.14147055f, -0.03490088f, -0.15067296f, 0.15363275f, 0.10326327f, 
    -0.19971831f, -0.08928455f, -0.14391544f, -0.27828884f, -0.06069868f, -0.05618249f, 0.02411990f, -0.16634376f, 
    -0.11712871f, 0.13676928f, -0.00449782f, 0.13484570f, 0.32936719f, 0.22894911f, 0.10938171f, 0.09775179f, 
    -0.08904363f, 0.05477371f, 0.10547615f, -0.18309577f, 0.01908711f, 0.02071398f, 0.03263302f, -0.08852851f, 
    0.18710451f, 0.09198099f, -0.13435015f, 0.17848805f, 0.11108860f, -0.04622849f, 0.15451595f, -0.17417380f, 
    0.22279260f, -0.12715617f, 0.08158706f, 0.30192468f, 0.13137905f, -0.37914097f, -0.03134444f, -0.37963760f, 
    -0.03787819f, -0.11087863f, 0.04019563f, 0.04819236f, 0.11928424f, 0.07841299f, 0.22725531f, 0.25955984f, 
    -0.12952474f, -0.14633198f, -0.24182479f, 0.00016431f, -0.00124022f, 0.00429275f, -0.08908682f, 0.39772293f, 
    0.14640318f, 0.30952129f, -0.12517673f, 0.12207985f, 0.10982383f, -0.22601146f, -0.21569268f, -0.08291531f, 
    -0.16640703f, 0.03938672f, 0.17973468f, 0.26851064f, 0.19146051f, -0.01081729f, 0.20545839f, -0.29352763f, 
    0.19891939f, 0.01300991f, -0.08857917f, -0.05070132f, -0.15784055f, -0.38643679f, -0.05786824f, -0.18157192f, 
    -0.13253112f, -0.04154690f, 0.29958460f, -0.03382966f, 0.25389686f, 0.04365981f, 0.11213647f, -0.11360923f, 
    0.06266725f, 0.06984103f, 0.14834270f, -0.46899864f, 0.00992817f, -0.13952175f, 0.28535700f, -0.03590014f, 
    0.18336514f, -0.06941315f, 0.12054943f, 0.11589640f, -0.13063808f, -0.16374481f, 0.19415337f, -0.20992745f, 
    -0.07498079f, 0.05397645f, -0.03469046f, -0.14692365f, 0.15258156f, 0.07867229f, 0.06047059f, 0.15092644f, 
    0.08939917f, -0.23425992f, 0.07262785f, -0.19534867f, 0.06031987f, 0.12302519f, 0.13868420f, 0.20745939f, 
    0.25999856f, 0.01967086f, 0.04392930f, 0.06895021f, -0.16569129f, 0.26880679f, -0.05496615f, -0.29140165f, 
    0.04771972f, 0.07629002f, -0.17358276f, -0.15880060f, 0.11233910f, 0.07783405f, -0.00877778f, 0.09143625f, 
    -0.14889312f, 0.05705922f, -0.22846508f, -0.07928941f, 0.15169878f, -0.11343404f, 0.00289971f, 0.08210063f, 
    -0.05017883f, 0.07331372f, 0.15212096f, -0.17311499f, 0.07793024f, -0.03187460f, 0.07302850f, -0.00525122f, 
    -0.09762306f, -0.21318935f, 0.00036280f, 0.19321434f, -0.13268305f, -0.01002886f, 0.08132084f, -0.11073150f, 
    0.03213040f, 0.10036770f, -0.38669848f, -0.18579011f, 0.14422619f, 0.17115974f, 0.10874238f, 0.06837300f, 
    -0.00557697f, -0.34931126f, -0.07453101f, -0.07212918f, -0.01355847f, -0.30058318f, -0.03337735f, 0.36399218f, 
    0.01156115f, -0.07071605f, 0.22855835f, -0.06527551f, 0.21326388f, -0.32626969f, 0.17551099f, -0.19420086f, 
    0.07440827f, 0.03363801f, 0.09652219f, -0.00863681f, -0.00205754f, 0.22760299f, -0.18261497f, -0.20564359f, 
    0.00539083f, 0.13348709f, 0.04866640f, -0.03324480f, -0.02394417f, 0.01036316f, 0.11961108f, -0.03864126f, 
    -0.12024766f, 0.15161715f, 0.27509752f, -0.11286668f, -0.16526718f, 0.14988995f, -0.07846571f, 0.16225781f, 
    0.11238614f, 0.25275937f, -0.19111715f, -0.00393646f, 0.08224826f, -0.08869046f, 0.05394670f, 0.06282326f, 
    0.23079640f, -0.17798650f, -0.08625305f, -0.10608992f, -0.05894998f, 0.00680500f, 0.09545747f, 0.05057466f, 
    0.03418327f, -0.02950190f, 0.08419715f, 0.15400513f, -0.09931538f, -0.16046908f, -0.08052927f, 0.07779381f, 
    0.17098404f, 0.12925936f, -0.15446354f, -0.40736389f, 0.17922233f, -0.18350549f, -0.07764135f, 0.03765123f, 
    0.05336491f, -0.13172367f, 0.13168031f, 0.15388152f, -0.05654541f, 0.22332306f, 0.13275366f, -0.27691007f, 
    0.27325681f, 0.25724542f, 0.03581724f, -0.05582054f, 0.08662648f, 0.06552207f, 0.20713156f, 0.19328624f, 
    0.35846868f, -0.12415230f, -0.08573435f, -0.09137474f, 0.01397824f, 0.01027076f, -0.04304916f, 0.18650731f, 
    -0.15469064f, 0.04829863f, -0.31860515f, 0.00236347f, 0.02028740f, 0.12457636f, 0.01251312f, 0.03717073f, 
    0.17828479f, 0.20508161f, 0.24397124f, -0.06041403f, -0.12331474f, -0.07826766f, 0.04847758f, -0.01788326f, 
    0.05948157f, 0.03060659f, -0.56377232f, 0.12944941f, 0.09498144f, -0.01748818f, 0.16551566f, 0.17572987f, 
    -0.06716076f, -0.25646317f, -0.03693122f, -0.17645033f, -0.08518426f, -0.00671708f, -0.00080775f, -0.00264852f, 
    -0.11498865f, 0.33970687f, 0.14492632f, 0.15129311f, 0.37291119f, -0.12801941f, 0.13675487f, -0.05549467f, 
    -0.13094363f, 0.11895268f, -0.10575764f, -0.41784585f, 0.02063187f, -0.04775734f, -0.09004302f, -0.14550339f, 
    -0.05788944f, -0.01296502f, 0.03902636f, 0.09696007f, 0.05423684f, -0.26990449f, -0.03665952f, 0.07965478f, 
    -0.01489937f, 0.15361056f, 0.01330601f, 0.04244367f, -0.07591765f, -0.36694717f, 0.12191644f, -0.00315635f, 
    0.02327546f, -0.04845185f, -0.01322180f, -0.07330617f, 0.10511995f, 0.11262175f, -0.02753154f, 0.04566645f, 
    0.21046202f, 0.09677160f, 0.15329224f, 0.12057753f, -0.03131010f, -0.00806766f, 0.15337089f, -0.39320984f, 
    0.08790594f, 0.10978194f, -0.17494616f, -0.15259612f, -0.06717118f, 0.10413058f, 0.04858731f, -0.01348274f, 
    0.08865288f, 0.04554869f, -0.06806277f, 0.22195101f, -0.10080829f, 0.01109664f, -0.14455989f, -0.00993133f, 
    0.05903426f, 0.03178573f, 0.00590463f, -0.18132009f, 0.22480713f, 0.04670072f, -0.07664128f, 0.10027419f, 
    0.04639919f, 0.05538690f, 0.05963822f, 0.08360851f, -0.24476960f, 0.15228981f, 0.02877789f, -0.11983362f, 
    0.02305317f, 0.01507679f, 0.10384439f, 0.09239682f, 0.25929010f, 0.29617092f, -0.10833979f, -0.05701767f, 
    0.03621290f, 0.20585746f, 0.09590159f, 0.02587490f, -0.14217621f, 0.09111909f, 0.18397976f, -0.00925604f, 
    0.20768397f, 0.16467080f, 0.04681722f, 0.07795408f, 0.08261130f, 0.23397207f, 0.21733183f, 0.05628479f, 
    -0.05240256f, 0.10079165f, -0.03673780f, -0.11517458f, 0.09701318f, -0.19974104f, -0.30213693f, -0.18340671f, 
    -0.06798699f, 0.08942993f, 0.04070903f, -0.05513749f, -0.12586960f, 0.02497545f, -0.23040645f, 0.22892150f, 
    0.06426302f, -0.03989353f, 0.00544426f, -0.11882997f, -0.05570877f, -0.26609889f, 0.03400623f, 0.10805136f, 
    -0.06063620f, -0.04140431f, 0.01251403f, -0.00873725f, 0.02453756f, 0.04392573f, 0.04424121f, 0.02483130f, 
    -0.03907953f, -0.04954476f, -0.02519957f, -0.06639812f, -0.05229794f, 0.03080757f, -0.00950051f, -0.01895841f, 
    -0.02278122f, -0.06170884f, 0.02592008f, 0.03801202f, 0.00747655f, -0.05193871f, 0.00201487f, -0.02445343f, 
    0.03813286f, -0.00291972f, -0.00835325f, 0.02825572f, 0.04877430f, -0.04640648f, 0.01547337f, 0.04024658f, 
    0.00051858f, 0.02146947f, 0.00249932f, -0.05929565f, 0.04923986f, 0.01450415f, 0.02820537f, -0.00363023f, 
    0.01217571f, -0.02456308f, 0.04550478f, -0.06624306f, -0.02420037f, 0.03464448f, 0.02002252f, -0.02873358f, 
    -0.01373969f, 0.03995093f, 0.01735574f, -0.01549449f, -0.02974583f, -0.03188313f, -0.01597964f, -0.04626605f, 
    -0.06011399f, 0.02638035f, -0.05460867f, -0.02336927f, -0.06637343f, -0.03264232f, 0.00927077f, -0.05414664f, 
    -0.02300328f, 0.05162615f, 0.01209577f, -0.01396137f, -0.01254671f, 0.04758834f, -0.05023941f, 0.04788537f, 
    -0.02239466f, 0.02678745f, -0.04423438f, -0.01778797f, -0.02346798f, 0.03120929f, 0.02233559f, 0.04237819f, 
    -0.04802264f, -0.05908601f, 0.00579692f, 0.00426412f, 0.00602078f, 0.02572803f, 0.03251143f, 0.00047144f, 
    0.01185350f, -0.01049614f, 0.03475677f, -0.06086258f, -0.05511019f, 0.00778214f, -0.00689546f, 0.04067918f, 
    0.03624692f, 0.02484629f, -0.00555344f, -0.00689577f, -0.05696624f, 0.01720441f, -0.02777009f, -0.00758971f, 
    -0.04197060f, 0.03263202f, 0.02614916f, -0.05450080f, -0.04638114f, 0.01767449f, 0.04739248f, -0.05721980f, 
    0.02401151f, 0.03627303f, 0.03784801f, 0.02730006f, -0.01013417f, -0.03747124f, 0.03635258f, -0.00116317f, 
    -0.00137573f, -0.06057533f, -0.01263574f, -0.04959616f, 0.02424037f, 0.04647245f, 0.01703582f, -0.05169189f, 
    -0.00560171f, -0.05075380f, -0.05741591f, -0.02913076f, 0.03627281f, -0.00822541f, 0.02097637f, 0.02171036f, 
    0.03854089f, -0.01232012f, -0.00633438f, -0.01783421f, -0.00206570f, 0.02127093f, 0.00639130f, -0.01074734f, 
    -0.05768642f, 0.04110050f, -0.05960789f, 0.00618287f, -0.02403341f, -0.05318238f, 0.02741929f, -0.04238168f, 
    -0.05496161f, 0.01916531f, 0.02903211f, -0.06077635f, -0.05990566f, -0.01156777f, -0.05736178f, -0.04836871f, 
    -0.02098339f, -0.03985743f, -0.04645136f, 0.04890857f, -0.06456178f, -0.03296528f, -0.01733885f, 0.03751255f, 
    0.05231158f, -0.04394349f, 0.01813627f, -0.04952510f, -0.02147074f, -0.00881986f, 0.02386574f, 0.04455247f, 
    0.01374043f, 0.02882194f, -0.04138746f, -0.03953916f, -0.05157375f, 0.00396608f, 0.00245639f, 0.03902515f, 
    0.03598604f, 0.04344013f, -0.01771172f, -0.01108235f, -0.01124313f, -0.05754403f, -0.00817613f, -0.06894300f, 
    -0.05267585f, 0.03826911f, 0.03828078f, 0.00037058f, 0.00624324f, -0.01359892f, -0.06045566f, 0.01277364f, 
    -0.05459053f, -0.06405960f, -0.05809855f, 0.03308398f, 0.02005852f, 0.03081624f, -0.04063627f, -0.02898411f, 
    -0.01063988f, -0.01842003f, -0.00145455f, -0.04672187f, 0.02503574f, 0.02869324f, 0.01471036f, 0.03060861f, 
    -0.06707243f, 0.05565681f, -0.03319111f, -0.06567929f, -0.00931283f, -0.02946847f, -0.02135643f, 0.03634202f, 
    0.03523642f, -0.04863333f, -0.01197181f, 0.02123163f, -0.07103883f, 0.02611903f, 0.00733607f, -0.03776218f, 
    0.02336898f, -0.05844265f, 0.01053805f, -0.00480802f, 0.03964951f, -0.02368009f, -0.03274630f, -0.03302269f, 
    -0.01744105f, -0.03275514f, 0.01881931f, 0.01231716f, -0.01920517f, 0.02622376f, 0.03473945f, -0.00227005f, 
    -0.02962671f, -0.05430624f, -0.06791957f, -0.02427489f, -0.04885849f, -0.03171006f, 0.00786345f, 0.04264795f, 
    0.00666265f, 0.02498093f, -0.04276088f, -0.04846547f, -0.06330619f, -0.05054126f, 0.01392058f, 0.04940907f, 
    0.00421216f, -0.05281489f, 0.03450547f, 0.02824299f, 0.00357561f, 0.01580295f, -0.01912808f, -0.02114903f, 
    -0.06082213f, -0.03286099f, 0.01748395f, -0.04374411f, -0.04325638f, -0.05671783f, -0.05894081f, -0.04547820f, 
    0.04579129f, -0.06175658f, -0.06379365f, -0.03412190f, -0.03992941f, -0.04339623f, 0.00834786f, 0.00588263f, 
    0.05255489f, -0.06197360f, -0.00528058f, 0.03830155f, -0.01976500f, 0.00502866f, -0.04932459f, -0.02237990f, 
    -0.03650057f, 0.01041051f, 0.03771550f, 0.00167134f, 0.00952099f, 0.03247233f, 0.03777500f, -0.00115777f, 
    0.03490624f, 0.03730600f, -0.00416087f, -0.02320168f, 0.00236995f, -0.05035247f, -0.05997355f, 0.00109917f, 
    -0.02071973f, 0.03736175f, -0.04870964f, 0.00845976f, 0.01545209f, 0.00460888f, -0.00609601f, 0.04841212f, 
    -0.06099559f, -0.00399427f, 0.01011939f, -0.00872868f, -0.03242231f, -0.02396411f, -0.04536582f, -0.05786146f, 
    -0.00235333f, -0.06333690f, -0.06232649f, -0.04475409f, -0.04042584f, 0.00128803f, -0.01613427f, 0.04304283f, 
    0.03311960f, -0.05225420f, -0.04409664f, 0.01343876f, -0.05104926f, -0.01804200f, -0.00089683f, 0.04680212f, 
    0.02322068f, -0.03503165f, 0.03605388f, -0.02790475f, -0.04233807f, -0.04951542f, -0.04378838f, -0.03698422f, 
    -0.03415731f, -0.03468915f, -0.02033951f, -0.04056786f, 0.02372026f, -0.04735123f, 0.04503907f, 0.01745005f, 
    0.00092524f, -0.02193849f, 0.01701284f, 0.03591709f, -0.00433068f, -0.06466658f, -0.03213463f, 0.02787813f, 
    -0.06072133f, 0.04856399f, -0.01335489f, -0.02194766f, -0.02304141f, -0.04456960f, -0.02330509f, -0.02190318f, 
    -0.05117534f, -0.05302404f, -0.04717536f, -0.03050779f, 0.03829214f, -0.02019007f, -0.00694338f, -0.01452383f, 
    -0.05855934f, -0.07248182f, 0.01571133f, -0.01538452f, 0.05373928f, 0.06324796f, -0.05331542f, 0.02872209f, 
    -0.04216935f, 0.02399267f, 0.00846278f, 0.05024944f, 0.00295641f, -0.02445030f, -0.02236023f, 0.00657280f, 
    -0.06436363f, -0.05456594f, -0.01020865f, -0.06267404f, -0.03188120f, 0.05196552f, -0.05747815f, 0.05129952f, 
    0.00720312f, 0.02972698f, 0.05385854f, 0.04699880f, 0.02181128f, -0.00574370f, -0.03017591f, 0.03324581f, 
    -0.05389310f, -0.03158271f, -0.02922018f, 0.02995277f, 0.01339030f, 0.01884752f, -0.06293890f, -0.06345499f, 
    -0.05510906f, 0.03999116f, 0.02181375f, 0.03424645f, 0.05504319f, 0.04278937f, -0.02087475f, 0.03247835f, 
    -0.01080327f, -0.05376690f, -0.01384763f, -0.00879020f, -0.04023477f, 0.05135702f, 0.01157330f, 0.01924352f, 
    -0.01407534f, -0.03478675f, 0.05069830f, -0.05615005f, -0.01004413f, -0.06759802f, 0.03720505f, -0.02982114f, 
    0.03077099f, -0.05884785f, 0.00114763f, -0.04828507f, -0.07663925f, 0.05379109f, -0.04509528f, 0.04256229f, 
    -0.03317504f, 0.02152260f, -0.00540399f, 0.03737580f, -0.03071497f, 0.02388944f, 0.01276348f, -0.04461384f, 
    0.01137483f, 0.00637158f, -0.03494428f, 0.01296168f, -0.03155201f, 0.02455227f, -0.01329084f, -0.05972417f, 
    0.01021157f, 0.02869745f, -0.02001665f, 0.01799169f, 0.01105011f, -0.06162147f, 0.05198893f, -0.01154482f, 
    -0.01813706f, -0.01361606f, -0.02724859f, 0.01114213f, 0.02627809f, 0.01508857f, -0.02449712f, 0.03831415f, 
    -0.02898267f, 0.01631375f, 0.01320072f, -0.04300172f, -0.01075717f, 0.03078538f, 0.00198133f, -0.03110812f, 
    0.03006164f, -0.05056235f, -0.03031120f, 0.03328769f, 0.03863719f, -0.06530891f, 0.05018845f, -0.05229238f, 
    -0.03152029f, -0.00285019f, -0.02785940f, -0.04024243f, -0.03119247f, 0.04914708f, -0.03620342f, 0.04157697f, 
    -0.00416888f, -0.03181752f, 0.04984825f, -0.03298637f, -0.03499106f, -0.01660950f, -0.06066867f, 0.02953514f, 
    0.04061252f, 0.02161784f, -0.04959626f, -0.01456362f, 0.03881425f, 0.02388063f, 0.03164458f, -0.02233946f, 
    -0.06193540f, -0.06567980f, 0.01933726f, 0.00174907f, 0.00999457f, 0.00500752f, -0.03249398f, -0.06556249f, 
    -0.01480565f, -0.04728285f, -0.00205548f, -0.02346403f, -0.02133675f, -0.06733319f, -0.03951349f, -0.03294365f, 
    0.02824431f, -0.03493687f, -0.05178942f, 0.02684039f, -0.03826758f, -0.00961750f, 0.01591435f, -0.02809496f, 
    0.01283195f, -0.00889529f, 0.05674367f, 0.03916774f, -0.05801676f, -0.06217837f, -0.00447891f, 0.00373440f, 
    0.02549859f, -0.03624254f, 0.05044819f, -0.05059150f, -0.01769784f, 0.01899424f, -0.00686052f, -0.03657406f, 
    -0.04757149f, 0.02993678f, -0.03065963f, -0.04770251f, -0.03812582f, -0.04497593f, -0.05190366f, -0.05327376f, 
    -0.05861883f, -0.00181520f, 0.03896741f, 0.04167651f, -0.01072995f, -0.05076879f, -0.01315055f, 0.02798943f, 
    -0.04735221f, 0.04032837f, 0.03022537f, -0.01260231f, -0.04343705f, -0.04950450f, -0.04311641f, -0.05741572f, 
    0.00740143f, -0.00026444f, 0.04157545f, 0.03680620f, -0.04052033f, -0.05594659f, 0.03411641f, -0.04455442f, 
    0.01674051f, 0.04854680f, -0.03675502f, -0.01823503f, -0.00767705f, -0.00660933f, -0.00202874f, -0.06094806f, 
    0.00581817f, -0.06585872f, -0.04996116f, -0.04571518f, -0.02498495f, 0.03990458f, -0.03386257f, -0.01756343f, 
    0.04412984f, 0.00425503f, 0.03707583f, -0.01308221f, -0.02828937f, -0.00515898f, 0.02600925f, -0.01035988f, 
    -0.01507397f, -0.05700823f, 0.04635931f, -0.00522363f, -0.01499183f, 0.04460421f, -0.00656214f, -0.02825716f, 
    -0.04015845f, 0.02692117f, -0.02514524f, -0.01792081f, 0.01877166f, -0.01978303f, -0.02574665f, 0.04708851f, 
    -0.04106762f, -0.01706015f, 0.01062596f, 0.05214939f, 0.02265269f, 0.03360118f, -0.04232222f, -0.04467382f, 
    -0.05732435f, 0.02550774f, 0.03471282f, -0.03258710f, -0.03457062f, -0.04820459f, -0.01441637f, -0.04799601f, 
    0.04330672f, 0.00045750f, 0.03152851f, 0.02867842f, -0.05607307f, -0.03007701f, 0.03394892f, -0.04444629f, 
    -0.02562991f, 0.01183696f, -0.02830485f, 0.00883812f, 0.00872052f, 0.00271811f, -0.04579439f, 0.03871308f, 
    0.04106445f, -0.06019929f, 0.02858310f, 0.04501785f, -0.00806493f, -0.01717044f, -0.01504196f, -0.03054095f, 
    0.01827068f, -0.01735420f, -0.04710114f, 0.04185925f, 0.03595101f, -0.05517087f, 0.00773716f, 0.02865260f, 
    0.00263945f, 0.04646871f, 0.02037479f, 0.05032834f, 0.02794052f, -0.04498230f, -0.00442778f, 0.00944248f, 
    0.03253763f, 0.01300446f, -0.01722637f, -0.00814126f, -0.05793493f, -0.02192245f, -0.05154175f, 0.03879886f, 
    -0.03043692f, -0.05730817f, -0.04900342f, 0.03109069f, 0.03977263f, 0.00392757f, -0.05538017f, 0.00467239f, 
    -0.04314218f, -0.05426447f, -0.06632291f, 0.02761029f, 0.01022461f, 0.03879073f, -0.04056757f, -0.06016245f, 
    0.04491018f, 0.04169920f, -0.02902198f, 0.01759275f, -0.00291546f, -0.01059655f, -0.04384762f, 0.00485596f, 
    0.00276910f, -0.04444790f, -0.02074780f, 0.03131275f, -0.06368610f, -0.02060132f, -0.01485617f, -0.04163971f, 
    -0.04470042f, 0.03444168f, 0.05297129f, -0.00429145f, -0.04506474f, -0.00024727f, -0.04169130f, -0.04150983f, 
    -0.01633155f, 0.02734997f, 0.04703165f, -0.02436765f, -0.02945174f, 0.04657622f, -0.02328990f, -0.02581485f, 
    0.00471822f, -0.03878444f, -0.02293779f, -0.00322028f, -0.01775431f, -0.02977010f, 0.01334106f, 0.04465289f, 
    0.02329999f, -0.05743906f, 0.00681466f, -0.01524059f, 0.02018653f, 0.00433906f, 0.03112205f, 0.03950495f, 
    -0.00787245f, 0.01731765f, 0.01630654f, -0.06123083f, -0.01437249f, -0.06807966f, -0.04468025f, 0.04260239f, 
    0.00500329f, 0.01614079f, 0.03849767f, -0.02700605f, 0.01375449f, 0.04502658f, 0.02334388f, -0.00851024f, 
    -0.04156039f, 0.02582475f, -0.03726565f, 0.02434427f, 0.03934058f, 0.02498235f, -0.00631173f, -0.04020212f, 
    0.01807851f, -0.00253664f, 0.01792332f, 0.02610737f, -0.01169920f, 0.04883103f, 0.01681070f, 0.02762935f, 
    -0.01806911f, -0.04915166f, -0.02067554f, 0.01564673f, 0.03366085f, 0.00104302f, -0.02003690f, -0.00752248f, 
    -0.00479118f, -0.03978607f, -0.05877794f, -0.02523932f, -0.05272778f, 0.03720130f, 0.04392259f, -0.04957206f, 
    0.01704370f, -0.04401072f, -0.01116099f, -0.01829610f, -0.05263749f, -0.04310990f, -0.04607755f, 0.01215334f, 
    -0.02681151f, -0.04486911f, -0.03549884f, -0.03335511f, -0.01719507f, 0.03663012f, -0.05775814f, 0.03272757f, 
    0.00966264f, 0.03239398f, -0.02958524f, 0.00012167f, -0.06258931f, -0.02480789f, 0.03262166f, -0.02717841f, 
    0.00236076f, 0.02449285f, -0.06417321f, -0.03839696f, -0.05083547f, 0.00498882f, 0.02304681f, -0.03568312f, 
    -0.03377572f, -0.06374989f, -0.01677447f, -0.02080935f, -0.01870870f, 0.02101379f, -0.00153431f, -0.00563300f, 
    -0.01881684f, 0.02053259f, -0.02039752f, -0.01252753f, -0.03862533f, -0.05820527f, 0.04451641f, -0.01571032f, 
    0.08390550f, -0.09676981f, 0.23009825f, -0.09818161f, 0.19444871f, 0.03488075f, 0.06940451f, 0.08278804f, 
    0.01870755f, 0.10598589f, 0.05609674f, -0.24390779f, -0.11733634f, 0.10915742f, 0.29212859f, -0.06496447f, 
    -0.22607465f, -0.08177932f, 0.08922080f, 0.40618876f, -0.09236804f, -0.08685989f, -0.08268984f, 0.05972314f, 
    -0.05101172f, -0.05452706f, -0.27341497f, -0.37327066f, -0.01693599f, -0.08356820f, 0.15838374f, -0.30570915f, 
    0.09500612f, 0.05460791f, 0.00076915f, 0.20516063f, 0.07057885f, -0.51833802f, -0.03937306f, 0.09910544f, 
    -0.03355984f, -0.08599926f, -0.04234730f, -0.16474816f, 0.02225240f, -0.19667196f, 0.21103638f, -0.17733246f, 
    0.08577325f, 0.05964037f, 0.00408884f, -0.08708322f, -0.01706954f, 0.05460130f, 0.20285317f, 0.09836141f, 
    -0.02006237f, -0.12678635f, -0.15751274f, -0.02406039f, -0.22932847f, -0.23089440f, -0.14145833f, -0.19717616f, 
    -0.13812408f, -0.07338353f, -0.09053724f, -0.00109851f, -0.01514682f, -0.09656885f, -0.10412616f, -0.03334984f, 
    0.33786032f, 0.21768421f, 0.18339288f, -0.00905744f, 0.23593694f, -0.03186576f, 0.02377252f, 0.02606517f, 
    0.05132205f, 0.09737907f, 0.04094220f, 0.04642937f, 0.06695987f, 0.06578618f, 0.03149524f, -0.12315272f, 
    0.00927290f, 0.23927107f, 0.19228758f, 0.11036302f, 0.05692220f, -0.19976157f, -0.24213456f, -0.12525846f, 
    -0.00820604f, -0.00483883f, -0.02581792f, -0.33147991f, 0.38918087f, -0.40081733f, -0.02665853f, -0.03337767f, 
    -0.03841041f, -0.32169184f, 0.21132345f, -0.00121075f, -0.10017775f, -0.29861879f, 0.09337369f, 0.14787188f, 
    0.01718160f, 0.16348568f, 0.07243755f, 0.16106774f, -0.05159064f, -0.60735184f, 0.34267938f, -0.49432862f, 
    -0.24217720f, -0.12627603f, 0.12538859f, -0.08547278f, 0.00641276f, 0.03520573f, -0.36959299f, 0.27282718f, 
    -0.21455836f, 0.05195346f, -0.00727984f, 0.01267527f, 0.12804659f, -0.09333455f, -0.04963015f, -0.20687720f, 
    -0.22761914f, 0.31376159f, 0.08480249f, 0.02905363f, 0.02040908f, -0.13321967f, -0.10560668f, 0.00259953f, 
    -0.01603624f, -0.22889824f, 0.03721526f, 0.04857887f, 0.08696993f, 0.15422608f, -0.00365455f, -0.09324459f, 
    0.30441415f, 0.01925620f, 0.24820267f, -0.27706724f, 0.15289073f, -0.05783753f, -0.13334143f, 0.12218457f, 
    0.09169018f, -0.15771510f, 0.01388794f, -0.26247787f, 0.26728922f, 0.05496301f, -0.03999523f, 0.06468549f, 
    0.31550476f, -0.19112492f, 0.15125905f, 0.01367580f, 0.12893525f, 0.18752816f, 0.10361317f, -0.07148012f, 
    0.01234719f, -0.16091058f, -0.12108289f, 0.06336816f, 0.19388519f, -0.21572243f, 0.10190081f, -0.05912294f, 
    0.12775622f, -0.05225019f, 0.08150784f, -0.01124230f, -0.18497121f, 0.16246025f, 0.27260336f, -0.14562608f, 
    0.00132441f, -0.08832490f, -0.22920731f, 0.16514491f, 0.18033768f, -0.13776851f, 0.03651285f, 0.09005596f, 
    -0.07141469f, 0.09491293f, -0.07960381f, 0.19959457f, -0.11241731f, 0.05043559f, 0.03500152f, 0.06178818f, 
    -0.36207345f, 0.36091173f, 0.05842476f, -0.03855811f, 0.04450689f, 0.12905651f, -0.13300209f, -0.14188547f, 
    -0.08279458f, 0.41392216f, -0.13032362f, -0.01927328f, 0.01275157f, 0.15107325f, 0.23136289f, -0.11634590f, 
    0.07360955f, 0.05334806f, -0.03522431f, 0.22864580f, -0.03234847f, 0.01961345f, -0.04082983f, 0.16123204f, 
    0.15494019f, 0.11837132f, 0.16110542f, -0.76058215f, 0.02339151f, 0.03357998f, 0.08796100f, -0.10944501f, 
    -0.05964880f, 0.10169474f, 0.04748195f, -0.32875535f, 0.07050397f, -0.24502929f, -0.13743967f, 0.07705843f, 
    -0.04840091f, 0.05834837f, 0.10244527f, -0.00538432f, -0.21160589f, -0.19946660f, 0.07925320f, 0.13041209f, 
    -0.06202067f, 0.42204425f, 0.02908623f, -0.26640537f, -0.08890728f, 0.37413865f, -0.09317014f, -0.53631872f, 
    0.01138940f, 0.20479862f, 0.17065881f, 0.04460248f, 0.08586112f, -0.07168963f, 0.00152233f, -0.25341830f, 
    0.15236914f, -0.06286472f, 0.00825182f, -0.22973247f, 0.17006415f, -0.03362948f, 0.18548563f, -0.14665912f, 
    0.13496378f, -0.66739362f, -0.03033485f, 0.02351699f, -0.15390040f, -0.12158737f, -0.06397657f, 0.02142561f, 
    -0.01555581f, 0.02458834f, 0.03083537f, -0.03331537f, 0.01732555f, 0.03461656f, 0.00868585f, -0.03911049f, 
    -0.05207515f, -0.01680430f, 0.01354581f, 0.02823823f, -0.04601108f, 0.00829456f, -0.05730518f, -0.03269348f, 
    0.03613433f, -0.03901569f, -0.00663226f, -0.04314929f, 0.03155359f, -0.07196391f, -0.00120833f, -0.03252234f, 
    -0.00666990f, 0.04274052f, -0.03828915f, -0.01871010f, -0.03983792f, 0.01326707f, 0.00069868f, 0.03070060f, 
    0.00752893f, -0.04846144f, -0.05772324f, -0.05469368f, -0.01884622f, -0.01418826f, 0.02535787f, -0.02742487f, 
    -0.00617134f, 0.01690223f, -0.02490150f, 0.00005200f, 0.01555383f, -0.04455893f, -0.02110312f, -0.00512885f, 
    -0.00572683f, -0.02852435f, 0.04672768f, -0.05700495f, -0.06227526f, 0.02795123f, 0.03359452f, 0.01874769f, 
    -0.02032145f, -0.05786014f, 0.04233468f, 0.03600826f, -0.02969733f, -0.04332489f, 0.04587600f, -0.02634619f, 
    0.05155073f, 0.00582840f, -0.03980541f, -0.00160813f, 0.03167376f, 0.01722686f, 0.00301335f, -0.03795910f, 
    -0.02248791f, 0.00769160f, 0.04359445f, 0.03650010f, -0.06411927f, -0.00797325f, -0.00213236f, 0.02706034f, 
    0.04315092f, 0.01803000f, 0.04581728f, 0.00018124f, 0.02169402f, -0.06236418f, -0.06968755f, -0.01786709f, 
    -0.01997769f, 0.01262845f, 0.04170585f, -0.01921782f, -0.01559759f, -0.01897109f, -0.05985901f, 0.03091720f, 
    -0.02869088f, -0.00127972f, 0.03886130f, -0.01798509f, -0.04081595f, -0.03065019f, 0.01558538f, -0.03858959f, 
    0.01282209f, -0.01087904f, 0.04744668f, -0.03120320f, -0.05840678f, 0.01480781f, 0.00607814f, 0.04304678f, 
    0.02075711f, -0.00714898f, -0.01611956f, 0.01082310f, 0.01121870f, 0.02589254f, -0.05003495f, 0.05648625f, 
    -0.01135769f, 0.01089787f, -0.02608487f, 0.00555601f, -0.05335013f, 0.00006482f, -0.04682377f, -0.05709282f, 
    0.01387793f, 0.03650691f, 0.02876725f, -0.03307918f, -0.05457010f, -0.03321754f, -0.05605423f, -0.01552970f, 
    0.03068628f, 0.04582454f, -0.05471832f, 0.01883425f, -0.04977388f, 0.00662084f, -0.02278555f, -0.01833564f, 
    0.02411117f, -0.04616961f, -0.02716634f, -0.04635878f, -0.01305127f, 0.00182470f, 0.05306636f, -0.03525043f, 
    0.01694777f, 0.04402618f, 0.05510817f, -0.00931233f, 0.01514512f, -0.02823478f, 0.02751572f, -0.06232940f, 
    -0.01806035f, -0.05841182f, 0.06279074f, -0.03323090f, 0.04669525f, -0.05598827f, 0.03334571f, -0.04768419f, 
    -0.00322430f, -0.00450309f, 0.01676135f, -0.06323878f, 0.00027745f, 0.04474737f, -0.01687647f, -0.03232538f, 
    0.02399651f, -0.02738554f, -0.04730059f, 0.02952585f, 0.04813196f, -0.05543703f, 0.05124088f, -0.04192432f, 
    -0.00965097f, -0.01279404f, -0.02884580f, -0.01198507f, -0.04071493f, 0.01825712f, 0.04883616f, 0.04574175f, 
    0.03335408f, -0.01366742f, 0.03893765f, 0.04484290f, 0.00068055f, -0.02170321f, -0.04757311f, -0.06297593f, 
    0.05314085f, -0.03534579f, 0.00009170f, -0.05459319f, 0.00598982f, -0.03002881f, -0.01928332f, -0.01422292f, 
    -0.05424599f, -0.02296899f, -0.04564015f, -0.02411611f, 0.01662127f, 0.01469168f, 0.00531501f, 0.02643718f, 
    -0.04660663f, 0.00478303f, -0.02513182f, -0.01083032f, 0.04351289f, -0.00125736f, 0.00289195f, 0.01965061f, 
    -0.04369901f, -0.06441367f, -0.02898512f, 0.01439433f, -0.06106498f, -0.04580962f, -0.06036974f, -0.01825391f, 
    0.00998083f, -0.01143044f, 0.03232134f, -0.00483388f, -0.05748747f, -0.03332522f, 0.01077455f, 0.04514890f, 
    -0.01821896f, 0.05313081f, -0.00309372f, -0.01612595f, 0.00619893f, 0.03041579f, -0.00867327f, 0.06541257f, 
    -0.01251383f, -0.02646428f, 0.05171330f, 0.05594398f, 0.01925358f, 0.05514717f, -0.02554674f, -0.05291723f, 
    -0.06277072f, -0.01887340f, 0.01073410f, -0.01417727f, -0.06071418f, 0.02033909f, 0.03906144f, 0.01248993f, 
    -0.04026350f, 0.02396708f, 0.00060887f, 0.04844883f, -0.02187808f, -0.00246221f, -0.03894708f, -0.05015079f, 
    -0.06389631f, 0.04984204f, 0.01431782f, -0.01271513f, 0.02135412f, 0.01416027f, 0.00886556f, -0.05484886f, 
    0.03685882f, -0.00716505f, 0.00061417f, 0.02872224f, -0.03774133f, -0.05386644f, -0.02742018f, -0.03460957f, 
    -0.07603604f, 0.08440943f, 0.03900415f, 0.02802407f, 0.00192961f, 0.09614596f, 0.18413958f, 0.18454365f, 
    -0.12431653f, 0.03101217f, 0.22347395f, -0.06578035f, -0.01025474f, -0.18195209f, 0.05949505f, -0.19682160f, 
    0.17604136f, -0.10324778f, -0.07501283f, 0.06813385f, -0.56282216f, -0.05284714f, 0.13956454f, 0.15505005f, 
    -0.08364322f, 0.05172503f, -0.06092862f, 0.11006800f, -0.10066998f, 0.11947132f, 0.00459093f, -0.08674884f, 
    0.05313066f, -0.02886356f, -0.10091166f, -0.12452912f, 0.38857639f, 0.09611449f, -0.20558228f, -0.05385843f, 
    0.15975578f, -0.10519743f, -0.04167444f, -0.04173433f, -0.12334166f, 0.23723829f, 0.04210301f, -0.00905404f, 
    0.21904179f, 0.19234696f, -0.10906119f, 0.14267722f, 0.08470473f, -0.14022271f, 0.67662531f, 0.06460530f, 
    -0.08855394f, -0.07649641f, -0.00394027f, 0.05181393f, -0.11253256f, -0.06875109f, -0.00188170f, -0.20489533f, 
    -0.30565289f, -0.15006985f, -0.14289643f, 0.05290633f, -0.04063674f, 0.07778957f, 0.25280714f, 0.06284973f, 
    0.11109252f, -0.28703552f, 0.20363319f, -0.10047861f, -0.00090458f, 0.01347891f, -0.07747666f, -0.15363663f, 
    -0.30392444f, 0.00314970f, 0.21644466f, 0.17908449f, -0.00063718f, -0.04008166f, -0.14187725f, -0.06607491f, 
    -0.11646426f, 0.01696469f, 0.06352749f, 0.48383763f, -0.00592478f, -0.20804645f, 0.00363113f, 0.08992924f, 
    -0.19610141f, 0.07909050f, -0.07883533f, 0.47418350f, -0.38080367f, -0.03665513f, 0.00993733f, 0.02739794f, 
    0.02931076f, 0.12200894f, -0.15936106f, -0.11971593f, 0.40125474f, -0.01809954f, -0.19256611f, -0.03833199f, 
    0.08437652f, 0.15411991f, 0.07219065f, 0.11401048f, -0.03885931f, -0.21454199f, 0.08099995f, -0.13081451f, 
    -0.12222355f, -0.00864325f, 0.10373045f, 0.03279216f, 0.09108508f, 0.13313343f, -0.14810893f, -0.39525098f, 
    -0.00782650f, 0.02425542f, 0.00167014f, 0.00965483f, 0.04766525f, -0.02729467f, -0.03703398f, 0.10379702f, 
    0.21922927f, -0.23114783f, -0.06259788f, 0.00186144f, 0.07467967f, -0.00316359f, 0.11764959f, 0.04310000f, 
    0.08539241f, 0.13826886f, 0.02424526f, -0.08008713f, -0.06507031f, 0.19976237f, 0.12606744f, 0.16633914f, 
    0.08049278f, 0.12630604f, -0.13516663f, 0.01864013f, -0.04223965f, 0.01785274f, -0.02981497f, 0.06204537f, 
    0.18165839f, 0.09616020f, 0.29427353f, -0.15759429f, -0.29511955f, 0.06179119f, 0.04093021f, 0.05678431f, 
    0.06948245f, -0.20785795f, 0.08219253f, 0.29820180f, 0.12177157f, -0.24583012f, -0.03520387f, -0.24624625f, 
    0.03165897f, -0.01627689f, -0.03166791f, 0.20155679f, -0.08229080f, 0.04820800f, -0.25055000f, 0.12531358f, 
    0.14299221f, 0.09213898f, -0.17361218f, 0.02941488f, 0.01954594f, 0.16861153f, -0.09223440f, -0.01739999f, 
    -0.00764614f, 0.18441772f, 0.11989831f, 0.19370364f, -0.01366632f, -0.04738143f, -0.20407285f, 0.03731475f, 
    0.08345654f, 0.14263487f, -0.04708106f, 0.04890238f, -0.08802701f, 0.14121012f, 0.16851449f, -0.36263996f, 
    0.05192580f, -0.18007527f, 0.14688867f, 0.25198698f, 0.04689014f, 0.05804899f, -0.01679283f, -0.01098112f, 
    0.36100671f, 0.03195603f, 0.02122779f, -0.03211372f, 0.07522923f, -0.08439037f, -0.21274419f, -0.00244116f, 
    0.21651642f, 0.04334683f, -0.17924072f, 0.19969247f, -0.09992764f, -0.10191483f, -0.16571127f, -0.01482540f, 
    -0.11442831f, -0.04609746f, 0.12183222f, -0.24222422f, 0.26200885f, 0.12258832f, 0.00506908f, 0.08090290f, 
    0.12298849f, 0.12942047f, 0.12544665f, -0.35434046f, -0.21539491f, -0.51407713f, -0.27379748f, 0.13234970f, 
    -0.07157775f, 0.29624623f, -0.14335422f, -0.00742454f, 0.04415182f, -0.34623185f, -0.59376407f, 0.08886240f, 
    0.03318288f, -0.14571096f, 0.12902062f, -0.09735940f, -0.04797270f, -0.12519984f, 0.00018432f, -0.36250713f, 
    0.03295512f, 0.25856745f, -0.07968069f, -0.03505010f, -0.01378537f, 0.03043679f, -0.74675685f, 0.27971339f, 
    0.20703222f, -0.21469349f, 0.08696637f, 0.08518670f, -0.10746446f, -0.23367742f, -0.01557740f, -0.22756748f, 
    -0.26993644f, -0.12790766f, 0.19814542f, 0.02412724f, 0.00954664f, 0.11929298f, 0.02446483f, -0.01605429f, 
    0.05579823f, 0.04637142f, 0.05050762f, -0.05459033f, 0.03405650f, 0.03427613f, -0.02691728f, -0.03003757f, 
    -0.03857119f, -0.04544302f, 0.02457094f, -0.01371388f, 0.04048321f, -0.00009171f, 0.00709849f, -0.04308456f, 
    -0.03490416f, 0.00048373f, -0.00877521f, 0.03819232f, 0.04839928f, 0.00640682f, -0.00260708f, 0.04864288f, 
    -0.00235607f, 0.03827152f, 0.02080735f, 0.02513923f, 0.03278186f, 0.04222869f, -0.05066992f, 0.03113595f, 
    0.03629364f, -0.03458855f, 0.03032094f, -0.00962731f, 0.00992134f, -0.01014799f, -0.02976575f, 0.03140136f, 
    0.03132776f, 0.04585115f, 0.04249397f, -0.03276472f, 0.03264260f, 0.00046829f, -0.04296615f, -0.03798443f, 
    -0.05506147f, -0.00566701f, -0.04206469f, -0.04590559f, 0.03788792f, -0.06202210f, 0.01898356f, -0.01193443f, 
    -0.01116035f, -0.00284266f, -0.06319343f, -0.01595221f, 0.03025837f, 0.03865694f, 0.03419274f, 0.05704126f, 
    -0.01516808f, -0.03601533f, 0.04244412f, 0.06320326f, -0.01013616f, -0.01526994f, -0.04573508f, 0.01739154f, 
    -0.04793229f, -0.03027748f, -0.01244141f, -0.05151730f, 0.02986431f, 0.00867583f, 0.02277773f, -0.04418229f, 
    -0.01215072f, 0.03208676f, 0.01479630f, 0.04550119f, 0.02715603f, -0.00361033f, -0.04918871f, -0.00933458f, 
    0.04075959f, -0.05447053f, -0.00815249f, -0.01164338f, 0.00778214f, 0.00717900f, -0.06143783f, -0.04321774f, 
    -0.04237380f, 0.03180457f, -0.01625329f, -0.04898063f, 0.02100202f, -0.01588138f, 0.02216794f, 0.01947936f, 
    -0.00839144f, -0.06771406f, 0.04756831f, 0.03883145f, -0.02663484f, -0.03468896f, 0.02891735f, 0.03488938f, 
    -0.01782186f, 0.02039759f, -0.03988235f, -0.01421185f, 0.02334075f, -0.03936239f, 0.01138773f, -0.02345356f, 
    -0.05187673f, -0.00821436f, -0.00736949f, -0.04244601f, 0.00842000f, -0.03194049f, -0.03827953f, 0.04723554f, 
    0.00994843f, -0.03198372f, -0.02787551f, -0.01436865f, 0.01164694f, 0.03673652f, 0.05297640f, 0.03467111f, 
    -0.02627089f, -0.00928732f, -0.02039727f, -0.00572945f, 0.01205669f, -0.05732599f, -0.02861440f, 0.02318001f, 
    0.03719450f, -0.04869657f, -0.05471006f, -0.01943632f, -0.02992289f, 0.03954212f, 0.01883380f, 0.01932073f, 
    -0.01846494f, -0.00621274f, -0.04540213f, 0.04588181f, -0.06420850f, -0.03738955f, -0.02565968f, -0.04222660f, 
    0.01881768f, -0.03140297f, 0.04489395f, -0.03724670f, -0.02059399f, -0.03412030f, 0.03894936f, -0.05903203f, 
    -0.05881460f, -0.03277364f, 0.01025766f, -0.02067974f, 0.01175179f, 0.00958000f, -0.04397238f, 0.01271142f, 
    -0.05958443f, -0.05092834f, 0.04168351f, -0.01881684f, 0.00789526f, -0.02044846f, 0.02749343f, -0.00002422f, 
    -0.01249931f, -0.04466223f, 0.03422682f, 0.05590841f, -0.02639363f, 0.01100161f, 0.04744896f, -0.03864309f, 
    0.01057026f, 0.00747471f, 0.02417788f, -0.03000560f, -0.04857733f, 0.00215442f, 0.05220902f, -0.00627806f, 
    -0.04301625f, 0.02309418f, -0.00693533f, -0.04848918f, -0.05631885f, 0.03302353f, 0.02458814f, -0.02747613f, 
    -0.04183703f, -0.06075910f, -0.04391018f, 0.01278530f, -0.00437227f, -0.03083900f, -0.00647127f, 0.00803093f, 
    -0.05128723f, 0.04959283f, 0.03721388f, -0.04398327f, -0.03492962f, 0.01221786f, 0.04370392f, 0.00046646f, 
    0.04665353f, -0.06532688f, 0.01531448f, -0.03580776f, 0.00302380f, -0.04982189f, -0.04712421f, -0.00006103f, 
    -0.05704594f, 0.00704753f, -0.01245654f, -0.03131676f, -0.02686912f, 0.00472458f, -0.00305804f, 0.00813825f, 
    0.01805184f, 0.02592210f, -0.04475186f, 0.00437193f, -0.03237335f, 0.01048288f, 0.01104376f, -0.02071016f, 
    -0.02490736f, -0.04444433f, -0.04469336f, 0.00293231f, 0.00478198f, -0.03713429f, 0.02397016f, 0.03081837f, 
    -0.05228788f, -0.05280439f, -0.05039258f, -0.00326726f, -0.06503011f, -0.01054964f, 0.03734247f, -0.03340789f, 
    -0.01550726f, -0.03496118f, -0.03774166f, -0.02878964f, 0.03375674f, 0.01033084f, -0.06112614f, -0.03083477f, 
    -0.01670916f, 0.03239439f, 0.00121194f, 0.00715118f, 0.04424772f, 0.03099639f, -0.04629247f, -0.04408965f, 
    -0.06289717f, 0.00999716f, 0.00122857f, 0.02529329f, -0.06178156f, -0.03042666f, -0.00711702f, -0.00227714f, 
    0.03019397f, 0.04575796f, 0.02596482f, 0.03618443f, -0.03407182f, 0.00448334f, 0.03752812f, 0.02708470f, 
    -0.04239435f, -0.04017697f, -0.04335900f, -0.01066645f, -0.05907350f, -0.05727700f, 0.02078898f, 0.04150464f, 
    0.05080302f, -0.00745799f, -0.00741721f, 0.03019766f, 0.00810015f, -0.02726759f, -0.04123233f, -0.03139383f, 
    -0.05735902f, -0.02564871f, -0.02642391f, 0.03508721f, -0.02028569f, -0.01213844f, -0.01113039f, -0.00090396f, 
    -0.00684585f, -0.05469042f, -0.04592777f, -0.05966564f, -0.04180807f, -0.00187260f, -0.01187034f, 0.04118175f, 
    0.01570741f, -0.04689810f, 0.03671094f, 0.04449953f, 0.00255026f, 0.02157237f, -0.06126369f, 0.01550728f, 
    -0.06189888f, 0.04152796f, -0.05971390f, -0.01405982f, -0.01350863f, 0.03400443f, -0.01041252f, -0.02154597f, 
    0.01363066f, -0.00105756f, -0.03588175f, 0.05135161f, -0.04079321f, -0.00686332f, 0.01295700f, 0.01403700f, 
    -0.00859978f, -0.06022089f, -0.00099319f, -0.00045635f, -0.04312831f, -0.01399462f, 0.02883592f, 0.00848335f, 
    -0.02232696f, -0.04392327f, -0.01081486f, 0.03510240f, 0.00138552f, 0.04645320f, -0.02011885f, 0.01664193f, 
    -0.00280135f, 0.02932515f, -0.02453010f, -0.00018465f, 0.04397015f, 0.00125871f, -0.00966051f, -0.00827342f, 
    -0.01795893f, -0.03105495f, 0.01660519f, 0.00403111f, 0.00730718f, -0.03472675f, -0.01368952f, 0.01054922f, 
    -0.05261292f, 0.01884622f, 0.00408457f, -0.02783741f, -0.05272284f, -0.03336987f, -0.02020524f, 0.06423353f, 
    -0.02411245f, 0.00490351f, 0.02395096f, 0.01309532f, 0.02230466f, 0.02079265f, -0.02302628f, -0.05236933f, 
    0.01195477f, 0.00690974f, -0.05928287f, 0.02025920f, -0.03321917f, 0.02476266f, -0.00020458f, 0.01040081f, 
    0.00927388f, -0.01190912f, -0.06060702f, 0.00073666f, 0.02025282f, 0.03496186f, 0.02389985f, -0.00087780f, 
    -0.05213266f, -0.01543504f, -0.03959004f, 0.01835812f, 0.02249805f, 0.05148023f, 0.04118748f, 0.00971938f, 
    -0.00678563f, 0.03685555f, -0.05794910f, 0.04178101f, -0.01888531f, 0.01110888f, 0.01059259f, 0.03225439f, 
    0.04501121f, -0.00546817f, -0.00204495f, -0.01609390f, -0.03677883f, -0.01303601f, -0.02781567f, -0.02830990f, 
    -0.04605491f, 0.02259686f, -0.02101260f, -0.05840857f, -0.05670761f, -0.05905419f, -0.02659849f, 0.00455585f, 
    0.01545648f, -0.01416276f, 0.04797293f, -0.05269719f, 0.00734088f, -0.03415972f, -0.04400025f, -0.06458358f, 
    -0.02943774f, -0.05765877f, -0.03841545f, -0.06031491f, 0.03634944f, 0.00206458f, -0.02014061f, -0.04114697f, 
    -0.05754633f, 0.02895176f, 0.02610753f, -0.03560840f, 0.01440576f, -0.04938306f, 0.04271700f, 0.03026075f, 
    0.00809585f, -0.04865066f, -0.06477375f, 0.03890102f, -0.05383508f, -0.05584416f, -0.01964790f, 0.01811093f, 
    -0.03153002f, -0.06264374f, -0.06091991f, 0.01177060f, -0.06878456f, 0.02055906f, -0.03553614f, 0.02175979f, 
    0.03988918f, -0.00194507f, 0.03563814f, -0.04143706f, -0.03051213f, 0.01678863f, -0.05596440f, -0.05273385f, 
    -0.06275412f, -0.01067331f, -0.04742300f, 0.04813834f, 0.02363931f, 0.00789703f, 0.02257507f, -0.04504401f, 
    0.01517722f, -0.00067955f, 0.04805627f, -0.03563020f, -0.06728160f, 0.01911316f, 0.05010962f, 0.03485417f, 
    -0.03041499f, 0.01385224f, 0.04603727f, 0.03088882f, -0.05306420f, -0.06614174f, -0.02890291f, 0.01588362f, 
    0.04103313f, -0.03979275f, -0.00615738f, -0.02668713f, -0.00604471f, -0.01430294f, 0.02487597f, -0.01811934f, 
    -0.01988130f, 0.01383401f, 0.02300743f, -0.00880991f, -0.03805908f, -0.03541122f, 0.00643808f, -0.05959844f, 
    0.02733717f, -0.06530118f, -0.05254081f, -0.05975319f, 0.03110366f, 0.03985677f, 0.01544207f, 0.01720246f, 
    0.00683915f, 0.02124151f, -0.01693352f, -0.05227396f, -0.00258577f, -0.03181335f, -0.03234455f, -0.00818894f, 
    0.01030748f, -0.01419714f, -0.02964974f, -0.02351086f, -0.01406412f, -0.05878337f, 0.04232198f, -0.03326735f, 
    0.00959298f, 0.02371251f, -0.02770254f, -0.05121132f, -0.00603460f, -0.01793115f, -0.05936432f, -0.05179770f, 
    -0.03431812f, -0.04711183f, -0.01475159f, -0.00274736f, 0.00409943f, 0.03164467f, 0.01375283f, -0.04228045f, 
    0.21489693f, 0.26635116f, 0.09519383f, -0.16928321f, 0.01156932f, 0.30710629f, 0.30173799f, -0.00053725f, 
    0.05170905f, -0.04622107f, 0.11060096f, 0.24702407f, 0.01579168f, 0.10559803f, 0.09570760f, 0.15483001f, 
    -0.11248209f, 0.08158584f, 0.11238211f, -0.08644326f, -0.13202533f, -0.02079166f, 0.17638648f, 0.10639159f, 
    -0.01292185f, -0.03382549f, -0.07016414f, 0.23587999f, 0.22112975f, 0.01340470f, -0.06899422f, 0.08421373f, 
    -0.01834197f, -0.00701931f, 0.19712660f, 0.20828149f, -0.14774881f, 0.27213004f, 0.10654354f, -0.00159721f, 
    -0.02663856f, 0.06254242f, -0.02813311f, 0.15807530f, -0.44116351f, 0.18672198f, 0.12364347f, -0.08263053f, 
    0.15484962f, -0.18476449f, -0.00037356f, 0.00769284f, -0.04704767f, 0.17561449f, -0.17480895f, 0.17135435f, 
    -0.16717917f, 0.15441863f, -0.09046090f, -0.00423971f, -0.01859291f, 0.25108761f, -0.07015862f, -0.15138721f, 
    -0.04026638f, 0.03911648f, -0.15807161f, -0.12596488f, 0.21372980f, 0.06534106f, 0.04784778f, 0.09183898f, 
    0.38840276f, -0.11157601f, -0.05373390f, -0.10612401f, -0.03842269f, -0.20241876f, 0.10745613f, 0.15134880f, 
    -0.14464825f, 0.19617498f, 0.18872261f, -0.21468933f, 0.11630399f, -0.17509201f, 0.05584390f, -0.10900716f, 
    0.15328220f, -0.11596575f, 0.54102528f, -0.20765314f, 0.04427144f, -0.13653591f, -0.11977705f, -0.05897183f, 
    0.01517703f, 0.16218317f, -0.13379157f, 0.12694845f, 0.29595825f, -0.27308983f, -0.07759964f, -0.09663898f, 
    0.12527533f, 0.06124265f, -0.05766685f, -0.04581839f, 0.33986571f, -0.12922065f, -0.06801031f, -0.04002519f, 
    0.01175808f, 0.08089952f, -0.03218424f, 0.26659727f, 0.27035457f, 0.23524864f, 0.20076649f, -0.10613797f, 
    -0.28334534f, -0.05590392f, 0.10709126f, -0.05041639f, 0.00478632f, -0.16966338f, -0.04252227f, -0.10944477f, 
    0.12317237f, 0.17844640f, 0.02353727f, -0.25187686f, 0.11464445f, -0.11276129f, 0.04796252f, 0.20562656f, 
    -0.28203586f, -0.03474855f, -0.24370129f, 0.12473848f, 0.13388005f, 0.17588702f, -0.14291096f, 0.22253466f, 
    -0.19735251f, -0.12471882f, 0.22290638f, -0.06124214f, 0.26057971f, 0.20139380f, 0.17274982f, 0.11829471f, 
    -0.04660429f, -0.16676517f, -0.04906083f, -0.07469288f, 0.32160130f, -0.00880371f, -0.23141648f, 0.00029522f, 
    0.08816091f, -0.10381272f, 0.27088836f, -0.29336241f, 0.03488605f, -0.05027978f, -0.06353059f, -0.12276268f, 
    0.16758364f, 0.01376982f, 0.37149200f, 0.31877145f, -0.08388799f, -0.06709445f, 0.11965784f, 0.21866260f, 
    -0.00993741f, -0.11059079f, 0.08066212f, -0.03671384f, 0.16546862f, 0.08799747f, 0.12231775f, 0.06925324f, 
    -0.00607155f, -0.20523277f, -0.11901160f, -0.30466896f, -0.28966826f, -0.22475423f, 0.20552969f, -0.23376416f, 
    0.34833312f, -0.09002064f, -0.15913133f, 0.00705996f, 0.24223824f, 0.24151380f, 0.16818467f, -0.12651202f, 
    0.08423272f, -0.10956991f, 0.01390120f, 0.21471621f, 0.24078248f, 0.14783445f, -0.01287446f, 0.21502331f, 
    -0.21628545f, -0.15211266f, 0.07810850f, 0.10836907f, -0.12492837f, 0.24747366f, 0.14654262f, 0.05777082f, 
    -0.01655963f, 0.27199531f, -0.12339072f, -0.15815569f, 0.17209107f, 0.06018972f, 0.08722334f, 0.16732195f, 
    -0.16947980f, -0.08826231f, 0.13435343f, 0.01962102f, 0.00572133f, 0.24434289f, -0.09914573f, 0.21998772f, 
    -0.02049785f, -0.13958731f, 0.38349229f, -0.15346418f, -0.15612009f, -0.06390647f, -0.01254023f, -0.00526148f, 
    -0.04498820f, -0.13285969f, -0.10821564f, 0.15318474f, -0.21213725f, 0.11734620f, -0.04321261f, 0.11656246f, 
    0.07141164f, -0.31729999f, -0.00308623f, -0.03023379f, 0.53375918f, 0.09573387f, 0.04735971f, 0.07304117f, 
    -0.07336508f, -0.03097900f, -0.22726238f, -0.19350372f, -0.01732819f, 0.00890458f, 0.01136597f, -0.06223265f, 
    -0.11161420f, 0.08106507f, 0.16818219f, -0.20897266f, 0.13851428f, -0.29262903f, 0.58472008f, -0.34801516f, 
    0.09894598f, -0.03602660f, -0.11989134f, -0.18043990f, -0.11331481f, 0.00992621f, -0.33782622f, 0.16784737f, 
    -0.07413191f, -0.06476106f, -0.07123765f, 0.04595459f, 0.25535974f, 0.09742470f, 0.03881890f, -0.00187140f, 
    0.02266390f, 0.02081799f, -0.00614893f, -0.02764551f, 0.02991351f, 0.03489969f, -0.04959920f, -0.01013209f, 
    -0.04614817f, 0.04862320f, 0.00867795f, -0.03208918f, -0.00907106f, 0.01696561f, -0.04433992f, 0.00445651f, 
    -0.00824568f, 0.03440519f, -0.05594522f, -0.05322315f, 0.01348806f, -0.01281178f, -0.04728610f, -0.01163721f, 
    0.02401602f, -0.02053237f, -0.03367762f, -0.02161218f, 0.04680959f, -0.03696496f, 0.04456293f, 0.00038474f, 
    0.05022930f, 0.03863588f, -0.00602936f, -0.06259955f, -0.04773049f, 0.03895112f, 0.02204617f, -0.01784549f, 
    0.04146354f, 0.01116375f, 0.01533447f, -0.02986593f, -0.04527441f, -0.00879394f, -0.05207071f, 0.00818493f, 
    -0.06250197f, 0.04073521f, -0.00666211f, 0.03390060f, -0.03579337f, 0.00996488f, 0.03492547f, -0.01275025f, 
    -0.02281971f, -0.06445996f, 0.05298279f, 0.04492684f, -0.06489696f, -0.04977965f, 0.02943044f, -0.05583945f, 
    0.01475294f, 0.00754354f, 0.00395681f, 0.00942932f, -0.00237710f, -0.05012467f, 0.01092825f, 0.04152152f, 
    0.01633753f, 0.00307640f, 0.00163624f, -0.01395856f, 0.01171331f, -0.05370337f, 0.03034478f, -0.00668685f, 
    0.00940049f, 0.01047785f, -0.05034677f, -0.02198636f, 0.00477500f, 0.01058965f, 0.02331261f, -0.00882042f, 
    0.00100037f, 0.01595225f, -0.03074172f, -0.04033143f, -0.02988063f, -0.06411034f, 0.04700017f, 0.02033664f, 
    -0.02609617f, -0.01837322f, 0.03159701f, 0.00625580f, 0.00263433f, 0.00799566f, -0.03694541f, -0.04321826f, 
    -0.00417786f, 0.00382584f, 0.03928987f, -0.01675804f, -0.00605769f, 0.00193419f, -0.02172052f, -0.03246613f, 
    0.03478971f, -0.03132011f, 0.01590663f, -0.00994266f, 0.05098609f, 0.04804586f, 0.04388947f, -0.00605472f, 
    0.03191397f, 0.00751270f, -0.03556402f, 0.01560764f, 0.01389315f, -0.00292817f, 0.01732178f, 0.00333476f, 
    0.00533906f, -0.03540859f, -0.02504254f, 0.01580435f, 0.00951789f, -0.03241083f, 0.01211669f, -0.01242092f, 
    0.00237943f, -0.02947542f, -0.01368070f, -0.05328440f, -0.04084858f, -0.05454882f, -0.04110537f, -0.04363322f, 
    0.03346659f, -0.03533462f, 0.02319709f, -0.03836227f, -0.04138059f, 0.05371865f, 0.01891878f, -0.00223746f, 
    -0.02899971f, -0.03380954f, -0.02645963f, -0.00973203f, 0.01175553f, 0.04241997f, -0.04108503f, -0.04452761f, 
    -0.02850766f, 0.01396982f, -0.01606148f, -0.02409597f, -0.00953115f, 0.03462797f, -0.00469813f, -0.05217275f, 
    -0.01180641f, -0.05164926f, -0.04462105f, -0.05182644f, -0.05913404f, -0.01385670f, -0.02799107f, -0.00482638f, 
    -0.02499300f, -0.02327006f, -0.04445062f, 0.01994207f, -0.02151498f, -0.05884804f, 0.00689976f, 0.05123320f, 
    0.00170260f, 0.03021306f, -0.00110876f, 0.00516354f, -0.03156926f, 0.05212256f, 0.02002913f, -0.03251971f, 
    0.04629283f, -0.05876938f, -0.04487382f, -0.04385163f, 0.05200318f, 0.05287284f, 0.01908052f, -0.01472800f, 
    0.01935845f, -0.03097552f, 0.00024303f, 0.02856878f, -0.03887966f, -0.01333412f, -0.02373254f, -0.00267111f, 
    -0.03757709f, -0.04110435f, -0.04910079f, -0.03273644f, 0.04579908f, 0.02491607f, -0.04269642f, 0.02589054f, 
    -0.02163883f, 0.01687831f, -0.04670748f, -0.02227098f, -0.02916289f, -0.05881486f, 0.02683390f, -0.02977885f, 
    -0.04268526f, -0.04611855f, 0.04653495f, -0.04117092f, -0.05682676f, -0.01940462f, 0.04530825f, -0.01925690f, 
    -0.03161398f, -0.00472027f, -0.02655953f, 0.02175608f, 0.03599800f, -0.02131644f, -0.03680183f, 0.02037579f, 
    0.04030977f, 0.01310456f, -0.04587350f, 0.03611935f, 0.00674667f, 0.02905193f, -0.00799361f, 0.01922928f, 
    -0.05815290f, 0.01508299f, -0.03724011f, -0.04088937f, -0.03903668f, -0.00871688f, -0.03697845f, 0.01954049f, 
    -0.04601058f, 0.00544596f, 0.04333265f, 0.02948090f, 0.00648514f, -0.02353543f, 0.03159362f, -0.01057827f, 
    -0.03284681f, -0.03061656f, -0.02248542f, 0.04935705f, 0.04820276f, -0.04104897f, -0.01808433f, 0.03683865f, 
    0.01354132f, -0.00313981f, -0.05314444f, 0.04205533f, 0.03251677f, -0.00039918f, -0.01110830f, 0.00320803f, 
    -0.05125312f, -0.03074436f, -0.05516165f, 0.00837423f, -0.02941899f, -0.02311153f, 0.00706779f, 0.01346229f, 
    0.02487490f, 0.00200949f, 0.02858447f, 0.01552153f, 0.00478762f, -0.05705613f, 0.02487250f, 0.00376407f, 
    -0.04661380f, -0.04730552f, -0.02757138f, -0.01995691f, 0.04330226f, -0.01671110f, -0.00196326f, 0.04245324f, 
    0.00294053f, 0.03040777f, 0.03403538f, -0.05025448f, -0.05060941f, -0.02516121f, -0.01272977f, 0.03234677f, 
    -0.05851113f, 0.02544722f, -0.05336460f, 0.01792706f, 0.03763381f, 0.03993783f, -0.05782934f, -0.01396488f, 
    0.01697986f, 0.03151285f, 0.03598288f, 0.00330965f, -0.00917929f, -0.03638444f, 0.04922902f, 0.04327538f, 
    -0.00315211f, -0.04996986f, 0.02199785f, 0.03657096f, 0.02488755f, -0.03508217f, -0.05405352f, -0.03717564f, 
    -0.04040025f, 0.02782076f, -0.03925260f, -0.00796177f, -0.05725090f, -0.01603779f, 0.01343643f, 0.04613645f, 
    0.00407840f, 0.02852682f, -0.04025655f, 0.06102671f, 0.01749480f, -0.03161713f, 0.01114876f, -0.01796501f, 
    -0.03876328f, -0.02291948f, 0.03235693f, -0.04328343f, 0.01519691f, 0.02832199f, 0.00994603f, -0.02778578f, 
    -0.01613277f, 0.01785033f, -0.00824337f, -0.03367144f, 0.00364675f, -0.04728592f, -0.00547009f, -0.05689355f, 
    0.04295616f, 0.02804253f, -0.03343518f, 0.00069616f, 0.01793070f, -0.04753988f, -0.05235869f, 0.01508447f, 
    -0.04074712f, 0.00614947f, 0.02971452f, -0.00595337f, -0.01421546f, 0.00383118f, 0.03840034f, -0.00410723f, 
    -0.05540520f, -0.02161974f, 0.00212165f, -0.02513272f, 0.05300053f, 0.00486945f, 0.03536806f, -0.03556416f, 
    0.02653164f, -0.05706847f, 0.01959842f, -0.05610445f, -0.01942348f, 0.03362404f, -0.00544425f, -0.01400364f, 
    -0.06434665f, 0.00485136f, 0.02516349f, -0.03522998f, -0.06234108f, -0.04229068f, 0.01264215f, -0.06007016f, 
    0.00066043f, -0.03058977f, -0.01218833f, 0.01471186f, -0.02600216f, -0.00873235f, -0.00150001f, 0.04464778f, 
    -0.00091433f, 0.01937121f, -0.03705775f, 0.02985878f, 0.02144263f, 0.01035819f, -0.04692479f, -0.00448425f, 
    0.03271075f, 0.00801758f, -0.03046745f, -0.00957117f, 0.02749899f, -0.04982998f, -0.02877319f, 0.01232019f, 
    0.01978420f, -0.02576964f, -0.01191864f, -0.04076171f, 0.03465195f, 0.03670197f, -0.01236212f, 0.03594064f, 
    0.02054221f, 0.04500626f, -0.05413316f, -0.05561812f, -0.06359849f, 0.03417787f, 0.02056663f, 0.04455811f, 
    0.01312251f, 0.00272907f, 0.02021558f, -0.05800972f, -0.06993876f, -0.05822147f, -0.04988208f, -0.04636099f, 
    0.04056150f, -0.04212885f, -0.02100488f, -0.02260371f, -0.06543756f, 0.04408284f, -0.03894054f, -0.03102651f, 
    -0.03998889f, -0.01848098f, 0.01608769f, -0.04526143f, -0.00538574f, -0.03543517f, 0.01538828f, -0.03866742f, 
    0.04263841f, -0.01272071f, -0.05313928f, -0.03614400f, -0.04332607f, -0.04324196f, -0.03669493f, -0.04039844f, 
    0.05060121f, -0.04679690f, 0.03679418f, -0.03588233f, -0.02693288f, -0.00618244f, -0.04014090f, -0.00399218f, 
    0.00025008f, -0.00843958f, -0.04861885f, -0.06080586f, 0.03888585f, 0.03102239f, 0.03881548f, 0.02285143f, 
    -0.01630432f, -0.03635268f, 0.02143691f, -0.03687448f, -0.06675214f, -0.01184667f, -0.02264846f, 0.02737259f, 
    -0.04487509f, 0.04752837f, -0.03237352f, -0.02341698f, -0.05836576f, -0.04786906f, -0.05685359f, 0.00376575f, 
    0.01298528f, -0.02216156f, 0.03296604f, -0.02390822f, -0.06058858f, 0.04781038f, 0.01421022f, -0.01950710f, 
    0.03146011f, 0.02572632f, -0.01296357f, 0.01396750f, 0.03979754f, 0.02265266f, 0.02075830f, -0.04969218f, 
    0.02201218f, 0.03884709f, 0.00744883f, -0.00916030f, -0.01133013f, -0.07174441f, -0.02532895f, 0.00048963f, 
    -0.06505118f, 0.03636278f, -0.04614325f, -0.01739865f, -0.01849394f, 0.00148090f, -0.06535473f, 0.03838186f, 
    -0.04345622f, 0.01172391f, 0.04089092f, -0.00969277f, -0.02895325f, 0.01695549f, -0.00586029f, 0.03342491f, 
    -0.05842058f, 0.00947421f, 0.00558204f, 0.05425567f, -0.06388292f, 0.01528240f, 0.00269230f, -0.05915359f, 
    0.00170098f, -0.03563364f, -0.03784598f, 0.01843610f, -0.00593277f, -0.03059714f, -0.02805166f, -0.03005444f, 
    0.01614288f, -0.00867533f, 0.01583726f, -0.05817575f, 0.03924785f, -0.00355516f, 0.00206890f, 0.00356601f, 
    0.21242711f, 0.09372780f, 0.02330179f, 0.11539429f, -0.18982978f, -0.01394328f, 0.02433301f, 0.06029281f, 
    0.02850635f, -0.19509649f, 0.05191667f, 0.11133958f, -0.01502838f, -0.00274862f, 0.17338344f, 0.16307235f, 
    0.06915250f, -0.03783220f, 0.19923767f, 0.14341503f, 0.00810942f, 0.21500836f, -0.17216636f, -0.31985861f, 
    0.07626893f, 0.02308519f, 0.20980290f, -0.45296136f, -0.20987575f, -0.24433538f, -0.10415197f, 0.13779251f, 
    0.07464438f, 0.14173228f, 0.01508285f, -0.02136325f, 0.46807301f, 0.13591105f, -0.01214733f, 0.02630368f, 
    -0.01291173f, 0.05622439f, 0.19241814f, 0.16033868f, -0.00023596f, -0.17275636f, -0.16757728f, -0.25490159f, 
    0.28429317f, 0.15020879f, 0.06853838f, 0.17630306f, -0.09873148f, 0.18953225f, 0.12857032f, 0.25724432f, 
    0.22642168f, 0.09720897f, -0.20021966f, -0.14594933f, 0.09229980f, -0.03020690f, 0.15724874f, 0.31431603f, 
    -0.28837916f, 0.01347148f, -0.13855065f, -0.09608340f, -0.02752438f, 0.19291833f, 0.10089909f, -0.14760454f, 
    0.23710047f, 0.19908306f, -0.22100164f, -0.08603147f, 0.07671038f, 0.16164154f, -0.08587331f, -0.12844661f, 
    -0.15040126f, 0.41209930f, 0.11786551f, -0.25052068f, 0.06724714f, -0.12116223f, -0.13150033f, 0.06862479f, 
    -0.01974062f, 0.10675308f, 0.39011940f, -0.30415732f, -0.10725698f, -0.24249201f, -0.27212644f, -0.39953786f, 
    -0.02991590f, -0.00860964f, -0.06292228f, -0.13861340f, -0.16253218f, -0.09065098f, 0.28689983f, 0.13980353f, 
    -0.02404379f, 0.10174909f, -0.22817722f, 0.20754342f, -0.16950291f, 0.01069104f, -0.01695000f, -0.07561833f, 
    -0.15968497f, 0.12541069f, 0.01375208f, 0.16556554f, -0.08136691f, -0.50600559f, -0.14786522f, -0.19471084f, 
    0.02188100f, 0.12152779f, -0.01450905f, 0.05473364f, -0.04664689f, -0.07418314f, -0.21880005f, -0.47003323f, 
    -0.24976817f, 0.16376364f, 0.21223696f, -0.00640657f, 0.06007700f, -0.03498406f, 0.08697309f, -0.34810370f, 
    0.55111849f, 0.13315889f, -0.02729901f, -0.00879525f, -0.04679958f, 0.11365095f, 0.05531444f, 0.12522039f, 
    0.18558525f, -0.05015180f, -0.14720137f, -0.10328778f, -0.26021108f, -0.09593697f, 0.08055390f, 0.31758690f, 
    -0.16445614f, -0.17769596f, -0.28294265f, 0.04824035f, 0.17690811f, 0.05699552f, 0.02212729f, 0.06891531f, 
    0.02262190f, 0.12019069f, -0.15997300f, 0.05901413f, 0.34048635f, -0.17995135f, 0.05817578f, 0.16325939f, 
    0.12959576f, 0.00515608f, -0.04674640f, 0.07087553f, 0.20562950f, -0.43344334f, 0.01676562f, 0.22562571f, 
    0.01164032f, 0.18352783f, -0.19586310f, 0.15341683f, 0.02959053f, 0.08669819f, -0.25846824f, 0.26807636f, 
    -0.44666311f, 0.13274749f, -0.00693680f, 0.25141165f, 0.05307369f, -0.18634771f, -0.14149113f, -0.06543955f, 
    -0.02108990f, 0.16692494f, -0.04046584f, 0.09040406f, -0.00849332f, 0.28324252f, -0.14816715f, -0.12489785f, 
    0.24895002f, -0.00277774f, -0.02213589f, 0.05495989f, -0.03917243f, -0.11796451f, 0.06537764f, -0.09752730f, 
    0.02113869f, -0.34253120f, 0.01494259f, 0.02283774f, 0.04425263f, -0.05690961f, -0.18223646f, -0.04287250f, 
    -0.07222366f, 0.16675790f, 0.00853897f, 0.17962497f, -0.20954676f, -0.09874350f, -0.18758784f, -0.21929124f, 
    0.12249508f, -0.00001761f, -0.14627048f, 0.23398350f, 0.06732940f, 0.20267904f, 0.10346629f, 0.09453800f, 
    0.06365370f, 0.07397526f, -0.33098021f, 0.18631595f, -0.05577515f, -0.13985111f, 0.06855901f, -0.00624393f, 
    -0.07054483f, 0.11083221f, -0.17437805f, -0.66509908f, -0.43647191f, -0.76250041f, 0.10449626f, 0.20843597f, 
    0.03718054f, 0.07619032f, 0.00728736f, 0.06849498f, -0.76069760f, -0.30041283f, -0.07602283f, -0.00931328f, 
    0.23068525f, 0.13797884f, -0.14167954f, 0.18798888f, 0.23299272f, 0.20969895f, 0.30454761f, -0.00309102f, 
    0.07492128f, -0.23674946f, 0.10771541f, 0.04715720f, 0.18629198f, 0.19594839f, -0.08852598f, -0.23617381f, 
    0.44650871f, 0.02154816f, -0.05288726f, 0.00603258f, -0.21038948f, 0.14791937f, 0.01440690f, -0.66530687f, 
    -0.41809946f, -0.39138484f, 0.14704438f, -0.05995214f, 0.15296951f, -0.00298126f, -0.09639953f, -0.19801420f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.20917366f, -0.05742901f, 0.16558909f, -0.30371815f, 0.09741068f, 0.05315946f, 0.00656436f, 0.01184029f, 
    -0.16986525f, 0.23563918f, -0.00025639f, 0.09282181f, 0.01592623f, -0.03839612f, 0.21018787f, -0.04895924f, 
    0.17877907f, 0.06219654f, -0.25509128f, 0.09854987f, -0.03450045f, 0.00263029f, 0.02403771f, -0.01490952f, 
    0.01423165f, -0.04374043f, 0.03308205f, 0.03706488f, 0.14145717f, -0.02638177f, -0.03685002f, 0.13035645f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.25284940f, 0.11562172f, -0.66841722f, -0.08373448f, -0.31842217f, -0.36751837f, -0.10384174f, 0.11283326f, 
    0.31181005f, -0.18631323f, -0.48089284f, 0.35991085f, 0.14909329f, -0.01676329f, -0.01440597f, -0.31125787f, 
    0.49988878f, 0.07643119f, 0.27043685f, 0.17491619f, -0.04402074f, -0.01046662f, -0.03600303f, 0.36903790f, 
    0.06919670f, 0.65708274f, 0.06497845f, -0.14171679f, 0.15797542f, -0.17853481f, 0.14673704f, -0.43457532f, 
    0.28202492f, -0.14044017f, -0.11056136f, 0.00904429f, 0.43437847f, -0.49947134f, -0.14564252f, -0.12672342f, 
    -0.38862038f, -0.19483562f, -0.06171014f, 0.32779416f, -0.04987637f, -0.12297437f, -0.31090945f, -0.32195842f, 
    0.31711480f, 0.15908001f, 0.46139017f, -0.59877390f, -0.15237802f, 0.13556150f, -0.10083516f, -0.46329361f, 
    -0.00090012f, 0.39228618f, -0.07976229f, 0.06972161f, 0.05262757f, 0.01955153f, 0.14996654f, 0.90895528f, 
    0.16356848f, -0.13850652f, -0.51845354f, -0.89860445f, -1.09201145f, -0.02877126f, -0.01388618f, -0.14041558f, 
    -0.03902933f, -0.15894392f, 0.25712973f, -0.21208584f, -0.11387936f, 0.09081876f, 0.39692447f, 0.44859284f, 
    0.01278355f, -0.96910417f, 0.01093268f, -0.65109795f, -0.11428043f, -0.12171350f, 0.13646145f, 0.00226888f, 
    -0.00232045f, 0.52055413f, -0.10697845f, -0.06186562f, 0.42288965f, 0.03475939f, -0.03129717f, -0.21565288f, 
    0.06831820f, -0.00234120f, -0.25884917f, 0.86200953f, -0.01497659f, 0.04067847f, -0.12199326f, -0.15059774f, 
    0.42060903f, 0.53161603f, -0.56998569f, -0.54585963f, 0.14921136f, -0.09172165f, -0.00067391f, -0.40730420f, 
    -0.49688175f, -0.24347770f, -0.35733998f, 0.14892672f, 0.10490792f, -0.11198495f, 0.11896981f, 0.61966050f, 
    -0.00409873f, -0.27347526f, -0.08903915f, -0.17440228f, -0.06292754f, 0.16150324f, -0.06421407f, -0.28556302f, 
    0.34080341f, -0.14654985f, -0.29197070f, -0.40709165f, -0.07645497f, 0.28258431f, -0.12033100f, -0.07722874f, 
    -0.00527965f, -0.05615280f, 0.09231301f, -0.25038832f, 0.07573303f, -0.85604054f, -0.15394387f, 0.26052886f, 
    0.31944981f, 0.15062793f, -0.49248588f, 0.36323100f, -0.02425480f, 0.03362862f, -0.01543665f, -0.23692767f, 
    -0.09624521f, -0.69516778f, 0.17175877f, -0.08524602f, 0.33068353f, 0.05738495f, 0.08870611f, -0.07952356f, 
    0.26907384f, -0.08866024f, 0.43292892f, 0.15562190f, -0.11723858f, -0.12796445f, 0.05800158f, 0.07867120f, 
    -0.68208957f, -0.47948137f, -0.16533305f, 0.37517142f, -0.15407921f, 0.09872283f, 0.12841405f, -0.33434063f, 
    0.31156525f, 0.55083215f, -0.11185089f, 0.44066185f, 0.02326770f, 0.07822251f, 0.13438280f, -0.68001729f, 
    0.11324672f, -0.34285858f, 0.13496478f, 0.14011921f, -0.34057856f, 0.10641825f, 0.06249623f, 0.04462888f, 
    0.31620014f, -0.13107480f, 0.70983714f, -0.32653385f, 0.10980417f, -0.23780398f, 0.15390933f, -0.02939583f, 
    0.63705146f, -0.16459943f, 0.21317685f, -0.07121346f, 0.01497486f, 0.31003016f, -0.27811599f, -0.63754624f, 
    -0.08407783f, -0.43229383f, -0.45795015f, -0.16626585f, -0.06791672f, 0.14473175f, 0.00499324f, -0.28699505f, 
    -0.03022844f, -0.43447408f, 0.15945132f, -0.10075668f, 0.21142685f, -0.15005800f, 0.17406043f, -1.14693570f, 
    -0.33848521f, -0.04926259f, -0.16172314f, 0.29947758f, -0.33441243f, 0.48828807f, 0.02041813f, -0.10610753f, 
    0.14055438f, -0.06292006f, 0.07851608f, -0.46182352f, -0.02394960f, -0.45146847f, -0.44753638f, 0.15694329f, 
    -0.09409708f, 0.40483707f, 0.79775804f, -0.03066701f, -0.06911010f, -0.01098750f, 0.09639318f, -0.42097172f, 
    -0.06371722f, -0.04412530f, 0.02099218f, -0.03867436f, -0.27117458f, -0.11659489f, -0.11017585f, -0.03437228f, 
    -0.31733644f, -0.02470521f, 0.02414561f, 0.29583225f, 0.89023530f, -0.30666414f, -0.03913140f, -0.16175048f, 
    0.20680274f, -0.24661602f, 0.04856190f, 0.12051283f, -0.14378451f, 0.18269753f, -0.29045284f, 0.73248708f, 
    -0.01530823f, -0.38611493f, -0.01772361f, -0.13828267f, 0.11579417f, -0.06328132f, 0.13901183f, -0.21518455f, 
    -0.07561575f, -0.16335358f, 0.16445488f, -0.03342982f, -0.67678875f, 0.12280643f, 0.14340201f, 0.61579454f, 
    -0.25304759f, -0.12848896f, 0.25743994f, -0.23648980f, -0.30379748f, 0.13725872f, 0.02744729f, -0.17342480f, 
    0.07191086f, -0.25741264f, 0.57196945f, 0.28185138f, -0.15433088f, -0.16390443f, -0.17054032f, -0.08184334f, 
    -0.56618720f, -0.25231424f, 0.01718981f, 0.21842529f, -0.12379895f, 0.13884239f, 0.11443808f, 1.13474000f, 
    -0.04346000f, -0.65513760f, 0.11255997f, 0.06512817f, 0.13861544f, -0.14144900f, -0.13026929f, -0.11786339f, 
    -0.24277626f, 0.07610986f, -0.19128005f, -0.62082487f, 0.00204369f, -0.16370215f, -0.00470232f, -0.13568828f, 
    -0.32875204f, 0.70168096f, -0.59745497f, -0.47606620f, -0.10093186f, 0.32980394f, 0.99837852f, -0.02584758f, 
    -0.52041394f, -0.02438300f, 0.04842744f, 0.23125286f, 0.06074283f, -0.16839844f, 0.05967198f, -0.13650739f, 
    -0.06161734f, -0.35358271f, -0.12621151f, 0.12379647f, -0.20254909f, -0.13447268f, 0.10601931f, 0.11479603f, 
    -0.35116088f, -0.14064246f, -0.43972772f, -0.27476403f, 0.22833058f, 0.32885060f, -0.04560118f, -0.00449510f, 
    -0.38066831f, 0.51922309f, 0.53031230f, -0.69165528f, -0.00399783f, 0.49439567f, -0.43911621f, -0.04762996f, 
    -0.55561727f, -0.04545163f, -0.59742153f, -0.43723762f, -0.01555343f, 0.06858708f, 0.07551880f, -0.64025563f, 
    -0.08747036f, 0.28472376f, 0.08602349f, 0.09085670f, 0.13782547f, -0.16597414f, 0.11133316f, -0.20068745f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.10504165f, 0.05179064f, -0.23095804f, -0.02629284f, 0.18579963f, 0.24232033f, 0.11853052f, -0.58019328f, 
    -0.25512567f, -0.22875743f, -0.08149980f, 0.18836275f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
