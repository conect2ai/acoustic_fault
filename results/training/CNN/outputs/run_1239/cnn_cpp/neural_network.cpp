#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.13599943f, -0.67251146f, -0.69082552f, 0.61230940f, 0.64503002f, 0.43503875f, -0.06392291f, -0.24366471f, 
    -0.30360007f, 0.32343382f, 0.55947107f, -0.43439642f, 0.19103985f, 0.00625369f, -0.03991746f, -0.20679685f, 
    0.48179334f, -0.16768183f, -0.26364040f, 0.64004546f, -0.03408569f, -0.47580248f, 0.16259646f, -0.32178998f, 
    -0.36778474f, -0.46454242f, 0.65879375f, 0.45987886f, -0.35776621f, 0.34342414f, 0.31670487f, -0.26607880f, 
    0.39956087f, -0.34582695f, 0.54691684f, -0.19092384f, 0.00995872f, 0.39789584f, 0.24274595f, 0.24976748f, 
    0.30679184f, -0.26266181f, 0.13251795f, -0.45275447f, -0.36691082f, -0.25905755f, 0.11877956f, 0.56098473f, 
    -0.51430374f, -0.08514129f, 0.52373475f, 0.18024595f, -0.42555815f, -0.10941688f, 0.22824953f, 0.49913767f, 
    0.35270837f, 0.16891858f, -0.38470113f, -0.53890133f, 0.03955862f, -0.09377310f, 0.31507140f, -0.43313685f, 
    -0.00045166f, 0.28036356f, -0.47151995f, -0.28274947f, -0.48421744f, 0.42879447f, -0.27960873f, -0.28997281f, 
    0.45530295f, 0.33082330f, 0.54871213f, -0.01407902f, 0.47899562f, -0.21917301f, 0.34043822f, 0.16665743f, 
    -0.24183352f, -0.22656816f, 0.07520543f, 0.23031820f, -0.49196470f, 0.04940599f, 0.17815150f, 0.29500860f, 
    -0.44719627f, 0.47387013f, -0.09458571f, 0.33557382f, 0.28151980f, -0.47057560f, -0.09462554f, 0.45180321f, 
    -0.33036816f, -0.02541056f, 0.41595608f, 0.45974854f, -0.81607336f, 0.34837094f, -0.37843224f, 0.38425922f, 
    0.06384132f, -0.10165083f, -0.21192904f, -0.11393276f, -0.07287913f, 0.78978342f, -0.60465646f, 0.31778651f, 
    0.00715870f, 0.10829417f, 0.21157478f, 0.21385053f, 0.14054532f, -0.53988707f, -0.35796484f, -0.20939593f, 
    0.38905007f, -0.15813482f, -0.50370330f, 0.00002850f, 0.18239966f, 0.07734372f, 0.14512779f, 0.11533868f, 
    0.06629633f, 0.37708831f, 0.60388225f, -0.74721795f, -0.22976422f, 0.21771714f, 0.41291288f, -0.67895436f, 
    -0.54960644f, 0.40266499f, 0.53959787f, 0.29571745f, -0.39891165f, -0.27915856f, -0.22680521f, -0.26127768f, 
    -0.00661725f, 0.17339210f, 0.38453731f, 0.50364923f, -0.57836497f, -0.29096970f, 0.01409314f, -0.09022766f, 
    0.01675092f, -0.25758240f, -0.00950033f, 0.09721167f, 0.33714327f, 0.55318421f, 0.04516778f, 0.51524943f, 
    0.23210047f, -0.21918890f, -0.49040169f, -0.53637362f, -0.08135969f, 0.15175524f, -0.22572716f, -0.03428347f, 
    0.04112941f, -0.32241601f, -0.09480363f, 0.16607420f, -0.30396003f, 0.08281352f, 0.13041504f, -0.08664424f, 
    -0.20370717f, -0.22227396f, -0.26111382f, -0.46944037f, -0.35816485f, 0.33884302f, 0.14384335f, 0.34080985f, 
    -0.16882631f, -0.13417611f, 0.15655625f, 0.52923214f, -0.59024787f, 0.39108580f, 0.30826813f, -0.06840333f, 
    0.34412730f, -0.58206952f, 0.47554338f, -0.00971574f, -0.20804715f, 0.00747982f, 0.18414940f, 0.29025966f, 
    0.29666767f, 0.36463398f, -0.30608392f, 0.34592614f, -0.31809944f, -0.25281870f, -0.30007815f, -0.80088419f, 
    0.44187334f, -0.56285733f, -0.25341874f, 0.20051076f, -0.13702716f, -0.19863248f, 0.50654590f, -0.04170969f, 
    -0.14016339f, -0.18119803f, 0.22100703f, 0.00870464f, -0.81279844f, -0.44223088f, 0.06714910f, -0.15472420f, 
    -0.00125478f, 0.71256161f, -0.49138555f, -0.46089336f, -0.10534196f, 0.30182761f, -0.17352358f, -0.25496203f, 
    0.29137719f, -0.00239002f, 0.05938578f, -0.20174369f, -0.12513413f, -0.51933765f, -0.70767653f, -0.45416504f, 
    0.06157728f, 0.65341133f, 0.57577485f, 0.26384422f, 0.23984835f, -0.56354761f, -0.33364025f, -0.47749195f, 
    -0.18327872f, -0.35600191f, -0.13224924f, -0.35545620f, 0.66197938f, -0.19074079f, 0.34761935f, -0.45423257f, 
    0.05610852f, -0.33141899f, 0.35904434f, -0.00637395f, 0.16654442f, -0.20726758f, 0.10167243f, 0.14304836f, 
    0.02288878f, 0.04406584f, -0.28780940f, 0.25027934f, 0.39832702f, 0.25946838f, 0.20064744f, -0.00206729f, 
    -0.78738302f, -0.24323195f, 0.15658635f, 0.18723255f, 0.10821178f, 0.13927583f, 0.42767000f, -0.59627503f, 
    -0.30194792f, -0.20096001f, 0.42440760f, -0.33228216f, 0.79596877f, 0.06842839f, -0.03656344f, 0.11021185f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.17336875f, -0.13442557f, -0.22160585f, -0.18276139f, -0.11067418f, -0.02200968f, 0.01037041f, -0.41703120f, 
    -0.26234519f, 0.08594865f, 0.29915345f, -0.19816330f, 0.25711623f, -0.15346241f, -0.20082077f, 0.00600735f, 
    0.02034379f, -0.26755527f, -0.45220524f, 0.04575864f, -0.18287458f, 0.08444501f, -0.20474374f, 0.17203754f, 
    -0.04468955f, 0.04985647f, -0.22803822f, -0.38361117f, 0.26457182f, 0.17492406f, -0.01216894f, -0.13718633f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.01970633f, -0.39016575f, -0.22318131f, -0.13622467f, -0.02777670f, -0.08169711f, 0.05523157f, -0.12069974f, 
    0.16652608f, 0.25475487f, -0.09831779f, -0.41205323f, -0.04003826f, 0.16104110f, 0.03356320f, -0.08778064f, 
    0.00483109f, 0.08462743f, -0.38216010f, -0.20938352f, -0.08655703f, -0.03629948f, 0.25380340f, 0.03575754f, 
    0.13647839f, -0.10941114f, -0.04026267f, -0.19448803f, 0.08154103f, -0.14779802f, -0.06977283f, 0.04389225f, 
    -0.28753099f, 0.23770821f, 0.05258591f, 0.05019556f, 0.17356186f, 0.08494571f, 0.09053224f, 0.09963229f, 
    -0.01219915f, -0.05310030f, 0.03565265f, -0.24438725f, -0.06965967f, -0.46045384f, -0.29102847f, 0.00150282f, 
    0.04483149f, 0.02988183f, -0.03716197f, 0.14079179f, 0.11321117f, 0.13204359f, 0.15898679f, -0.44533077f, 
    -0.34961861f, 0.03648174f, 0.13192210f, 0.01279064f, 0.02902049f, -0.04191199f, -0.03142142f, 0.05000873f, 
    0.14011522f, 0.19996449f, 0.01015288f, -0.04989885f, -0.03990660f, -0.10254854f, -0.09175481f, 0.11934234f, 
    0.05175694f, -0.07133576f, 0.14347601f, 0.08082254f, 0.00650015f, -0.06502074f, 0.11384541f, -0.04334286f, 
    0.07634496f, -0.10653544f, 0.01136743f, 0.11525316f, 0.04530311f, 0.14036228f, -0.00026502f, -0.08487345f, 
    0.12261537f, -0.01735050f, -0.31035009f, -0.32063720f, -0.24514481f, 0.09581847f, 0.03548131f, 0.03307873f, 
    0.04311445f, 0.12407301f, -0.07098271f, 0.36461580f, -0.44962800f, -0.21670547f, 0.10995078f, -0.14288767f, 
    0.16663375f, 0.14648457f, 0.04393126f, 0.03241156f, 0.15510164f, 0.18860759f, -0.48026735f, -0.18410929f, 
    -0.18989792f, 0.07621582f, 0.15546814f, 0.15091418f, 0.11854579f, -0.02092422f, 0.06985120f, 0.15028496f, 
    -0.08987383f, -0.05711558f, -0.01834580f, 0.05520209f, -0.09961196f, 0.05720483f, -0.07987803f, -0.26708272f, 
    0.10752499f, -0.16375679f, -0.00481810f, -0.33201560f, 0.16067672f, -0.04187083f, 0.02385153f, -0.42103228f, 
    -0.08512152f, -0.03456071f, -0.15073438f, -0.10155098f, 0.03673101f, 0.06683996f, -0.03282956f, -0.02547457f, 
    -0.13554230f, -0.53877997f, -0.18695338f, 0.07275858f, 0.12741856f, -0.01956278f, 0.11583062f, 0.08732761f, 
    -0.02327724f, 0.17159964f, -0.02798199f, 0.04933830f, -0.01853896f, -0.33680961f, -0.08698617f, 0.25201705f, 
    -0.03461827f, -0.00189647f, 0.05087858f, 0.01956032f, 0.24394007f, -0.13166787f, -0.03660671f, 0.02420647f, 
    0.03004088f, -0.12610994f, -0.19881009f, 0.24160516f, 0.03225197f, 0.07307825f, -0.00674835f, 0.04014208f, 
    -0.06734700f, 0.19165105f, -0.04482792f, 0.09533853f, -0.03722085f, -0.17619844f, -0.22231618f, -0.06610761f, 
    -0.00137447f, -0.04440961f, 0.03347724f, 0.14411619f, 0.04348353f, 0.16915415f, 0.06177267f, -0.33638629f, 
    0.00434843f, -0.02576949f, 0.01086905f, -0.08269873f, -0.06383933f, 0.04085959f, 0.10833518f, 0.00255304f, 
    -0.14539522f, -0.00983264f, 0.00972964f, -0.02037585f, -0.17378499f, -0.13092183f, -0.11212486f, -0.05450570f, 
    0.06845850f, 0.13917115f, -0.14160147f, 0.10710089f, 0.16837385f, 0.00349974f, 0.07720371f, 0.02292398f, 
    0.17722876f, 0.14036882f, 0.15308988f, -0.03940959f, 0.03316531f, -0.10484761f, -0.00166518f, 0.02215120f, 
    0.08035504f, -0.03913647f, 0.05091324f, -0.02269934f, 0.18079825f, 0.09562834f, 0.09524643f, -0.07217514f, 
    0.13561548f, 0.01964396f, 0.21865456f, 0.24678244f, 0.24537119f, -0.12107503f, 0.11892793f, -0.07692912f, 
    -0.00428083f, -0.08749954f, -0.00180868f, 0.00308175f, 0.36314353f, 0.09457961f, -0.00163026f, 0.03272843f, 
    -0.05981047f, 0.13383406f, 0.08132321f, 0.19219466f, -0.00933178f, -0.05884666f, -0.12796062f, 0.05118808f, 
    0.07533720f, 0.08394496f, 0.03555997f, -0.07006656f, 0.06820604f, 0.08734025f, -0.02056229f, 0.07822875f, 
    -0.06012264f, 0.15543750f, -0.00981272f, 0.05228394f, 0.13979167f, 0.09682232f, -0.00455799f, 0.12780419f, 
    -0.20958231f, -0.13791470f, -0.00882917f, 0.18177088f, -0.09385411f, 0.05251678f, -0.07243705f, -0.10363625f, 
    -0.33636668f, 0.23421490f, -0.17423716f, 0.09016879f, 0.04593363f, 0.00259758f, -0.03331719f, 0.08848965f, 
    0.19842495f, -0.12873943f, -0.23944660f, -0.01334258f, -0.18710633f, 0.11263280f, -0.17793910f, -0.04814811f, 
    -0.06806695f, 0.02562659f, 0.04367391f, -0.00582645f, 0.13732399f, -0.07193610f, 0.07697341f, 0.03761770f, 
    -0.01942827f, -0.03876973f, -0.26356420f, 0.08989692f, -0.18629143f, 0.26039803f, 0.27598801f, -0.09339344f, 
    0.22454491f, -0.08511817f, 0.06044056f, 0.08401651f, 0.34282127f, 0.08334304f, 0.04479605f, -0.13469727f, 
    -0.04662463f, -0.00668081f, 0.32557306f, -0.20449755f, 0.12215391f, 0.11569439f, 0.01167010f, -0.01892489f, 
    -0.08522267f, -0.03791977f, 0.16466650f, 0.12487059f, 0.02661064f, -0.02084931f, 0.19454797f, 0.12449512f, 
    -0.07999329f, -0.00592571f, 0.11700654f, 0.03425786f, -0.01149561f, -0.14774594f, 0.06821743f, 0.10069574f, 
    0.04488290f, 0.04788988f, 0.12895654f, -0.01515368f, -0.12217520f, -0.17329389f, 0.05535338f, 0.00829313f, 
    0.04332092f, 0.09906348f, 0.11587004f, 0.17866322f, 0.00810377f, -0.07433511f, -0.12868790f, -0.08451726f, 
    0.03273363f, -0.19097209f, 0.02464240f, 0.06335998f, -0.02355058f, -0.01343128f, 0.12269422f, -0.18167242f, 
    0.15419029f, -0.07604980f, 0.21474250f, -0.04899574f, 0.06484084f, 0.17419352f, -0.00245372f, 0.08399071f, 
    -0.00687786f, -0.00655511f, -0.19859335f, 0.17437218f, -0.14885324f, 0.00835240f, 0.00194478f, 0.18719061f, 
    0.01001173f, -0.09999787f, -0.00489081f, -0.03058261f, 0.08701617f, 0.18676922f, 0.14529325f, -0.06438684f, 
    0.05495069f, 0.00824723f, 0.13415460f, 0.15571764f, 0.00060512f, 0.14136222f, -0.13279539f, 0.01455006f, 
    0.01696124f, -0.07903225f, -0.00328478f, -0.00492832f, -0.07863579f, 0.23873639f, 0.05470809f, 0.00965434f, 
    -0.11234441f, 0.02907998f, 0.09064129f, 0.00289153f, -0.12626438f, 0.15810578f, 0.21000147f, -0.04749274f, 
    0.00591578f, 0.04908396f, 0.09900815f, -0.01163488f, -0.16465922f, -0.01667837f, 0.09308910f, 0.25263092f, 
    -0.05630012f, -0.15777935f, -0.17052504f, 0.04729474f, -0.20217635f, -0.04502378f, -0.02145462f, 0.17714836f, 
    0.19250122f, 0.19496945f, 0.21269815f, 0.04760081f, 0.05178606f, -0.07001529f, -0.02436863f, -0.03963790f, 
    0.02045953f, 0.03038171f, -0.13091104f, 0.09134538f, 0.09122681f, 0.00576729f, -0.07524142f, -0.15979773f, 
    -0.15151215f, -0.06495393f, 0.45535648f, -0.02041286f, -0.21034141f, -0.05680829f, 0.09406842f, 0.03010175f, 
    0.22279200f, -0.08599242f, 0.02116507f, -0.02602142f, -0.11168514f, 0.01545385f, 0.02317467f, -0.06775013f, 
    -0.12521325f, 0.05491784f, 0.06229413f, 0.19315949f, 0.03329100f, 0.24964011f, 0.11810175f, -0.04870376f, 
    0.03224925f, -0.05475250f, 0.18251531f, -0.09589554f, -0.00447679f, -0.04386172f, 0.12612537f, 0.07418115f, 
    0.11018159f, -0.03305942f, -0.00467033f, 0.06347369f, 0.18311772f, 0.08518749f, 0.08035368f, 0.09066343f, 
    0.04986250f, 0.06295276f, -0.05042158f, -0.09295855f, 0.22820909f, 0.04204911f, 0.00493571f, 0.01738046f, 
    0.03437107f, -0.21877222f, 0.00558021f, -0.04863798f, 0.01847188f, -0.06249113f, -0.09176676f, -0.00983580f, 
    0.03067165f, 0.00782982f, 0.15522037f, 0.10294625f, 0.17250334f, -0.03690396f, -0.17024443f, -0.11067867f, 
    -0.06056891f, -0.11898615f, -0.02049036f, 0.09558012f, 0.07957879f, -0.00798951f, 0.23987858f, -0.05675191f, 
    0.09397509f, -0.01736879f, -0.24487466f, -0.13286908f, -0.07333124f, 0.13987371f, -0.00600899f, 0.08275645f, 
    -0.23269400f, -0.07380408f, -0.24397504f, -0.06797278f, -0.16597544f, 0.14393570f, 0.19559346f, -0.11456554f, 
    0.03988182f, -0.16338372f, 0.04883195f, 0.14912905f, -0.02047166f, 0.17292203f, 0.02988769f, -0.01990946f, 
    0.17516142f, 0.12652211f, -0.19065854f, -0.10426302f, -0.21506438f, 0.06934123f, -0.02283250f, -0.01948188f, 
    0.07607126f, -0.01446807f, 0.02389831f, -0.21121463f, -0.11740420f, -0.01184582f, 0.10274427f, 0.00514499f, 
    -0.21518874f, 0.11458287f, 0.02592673f, 0.08589993f, 0.01182592f, -0.01456001f, -0.13423865f, 0.27941644f, 
    0.16499548f, -0.17129561f, -0.11025090f, 0.07080808f, 0.08735390f, 0.05000497f, 0.08917223f, -0.27905864f, 
    -0.31746936f, -0.05710170f, 0.14967982f, -0.02904370f, 0.07753135f, -0.11126108f, -0.07549365f, -0.01974850f, 
    0.17432311f, 0.05279771f, -0.22170693f, -0.12376993f, 0.10401057f, -0.03526890f, 0.15766115f, 0.00466114f, 
    0.02462012f, -0.02424230f, 0.11132966f, -0.02073296f, -0.16442181f, -0.03770749f, 0.05712881f, -0.22818585f, 
    0.06331761f, -0.18451257f, -0.00212044f, 0.00342368f, 0.09763991f, -0.06366878f, 0.02324269f, 0.02878691f, 
    0.15411080f, 0.03039861f, 0.06557705f, -0.00948132f, -0.01730347f, -0.12270803f, -0.06086800f, 0.15675972f, 
    0.01908741f, 0.07664441f, 0.07049139f, 0.03474021f, -0.08364493f, 0.09364295f, -0.17548692f, -0.12959051f, 
    -0.10187319f, -0.04002414f, 0.15650900f, 0.04724539f, 0.11203282f, 0.11874271f, 0.13975930f, -0.03460282f, 
    0.11697903f, -0.17050773f, 0.11889250f, -0.04509998f, -0.05143985f, -0.03603962f, -0.03956584f, 0.03498412f, 
    0.14852977f, 0.06538294f, 0.04763771f, 0.03270410f, 0.06523730f, -0.02144317f, 0.01496522f, -0.00360857f, 
    0.06052253f, -0.04806451f, 0.19078468f, 0.02855257f, -0.10967558f, 0.01935351f, -0.04823595f, 0.10519410f, 
    0.01787494f, 0.05671590f, -0.18456942f, 0.00974314f, -0.14452949f, 0.15236560f, -0.03135062f, 0.07547056f, 
    -0.00677254f, -0.14960279f, -0.09025916f, -0.15405314f, 0.10213315f, -0.11819918f, 0.17733103f, -0.12999979f, 
    0.12621459f, -0.09824020f, 0.00518727f, -0.19582628f, 0.07178057f, -0.09804567f, 0.04687424f, -0.16411844f, 
    0.12393121f, 0.03088509f, 0.00381066f, 0.24560927f, -0.04703411f, -0.02349160f, 0.00172874f, 0.06817871f, 
    -0.08907646f, 0.03340875f, -0.07546618f, -0.14020304f, -0.15767808f, -0.21881691f, -0.10764038f, -0.08620024f, 
    0.25502443f, -0.03627753f, -0.08425637f, 0.07799425f, 0.19707814f, 0.13157196f, 0.03595466f, -0.06647623f, 
    0.14093469f, 0.06405012f, -0.11671765f, 0.16672538f, -0.06540973f, -0.22046788f, 0.03905716f, -0.24240804f, 
    0.10510073f, -0.15797926f, 0.04922049f, -0.01594222f, -0.06660288f, 0.06836795f, 0.07010738f, 0.11379538f, 
    0.24289373f, 0.06627673f, 0.16253607f, -0.02912346f, 0.13779637f, -0.00129520f, -0.05658589f, -0.00467922f, 
    0.09379062f, -0.05540979f, -0.00839199f, 0.14241971f, 0.19562282f, 0.06902535f, -0.02586470f, -0.01946174f, 
    -0.00454637f, 0.02327809f, -0.19894493f, -0.08111341f, 0.01026988f, 0.04846908f, 0.08989028f, -0.25594321f, 
    -0.01369268f, 0.14262019f, 0.07654376f, 0.05260770f, 0.02388704f, -0.08591794f, 0.15493065f, 0.15903085f, 
    0.10625061f, -0.04693086f, 0.09487240f, 0.12940049f, -0.06958297f, -0.33206195f, 0.01898349f, 0.01326602f, 
    -0.05983260f, 0.02140620f, 0.00627179f, -0.06652686f, 0.11629929f, 0.14310437f, -0.03743861f, 0.00764071f, 
    0.02389442f, -0.04608446f, -0.01984972f, 0.01269085f, 0.07023489f, 0.16844080f, 0.03542299f, -0.08880395f, 
    0.00172775f, 0.04795384f, 0.02337174f, 0.08869445f, 0.14768727f, 0.12425602f, 0.00090469f, -0.01645828f, 
    0.12414174f, 0.01153096f, 0.12747841f, 0.07130019f, -0.06936765f, -0.13357465f, -0.12667820f, 0.03044094f, 
    0.17789976f, 0.16437456f, 0.18753006f, 0.13937420f, 0.05279679f, -0.01700611f, -0.00082550f, 0.07901958f, 
    0.02006919f, -0.04839851f, 0.16463014f, 0.00249704f, 0.05608525f, -0.00066163f, -0.12475429f, -0.01227209f, 
    0.04153541f, 0.09668835f, -0.18687791f, 0.01322549f, -0.04137081f, 0.10046782f, 0.15134124f, -0.04555485f, 
    -0.14518924f, -0.26303846f, -0.28713626f, 0.17453970f, -0.05382524f, 0.15735707f, -0.00468985f, 0.05016823f, 
    -0.15203744f, -0.01283967f, 0.05112869f, 0.19525172f, -0.01791861f, -0.05117336f, 0.03203949f, 0.01895364f, 
    -0.08605537f, -0.04357343f, 0.09164904f, -0.07319624f, -0.01550319f, -0.06823823f, -0.03279533f, -0.00498666f, 
    -0.00289168f, 0.07373042f, 0.04074382f, -0.14721113f, -0.31512403f, -0.20868976f, -0.10144425f, 0.16619089f, 
    0.16645092f, -0.01407542f, -0.09733351f, -0.08361436f, 0.01264879f, -0.43300998f, -0.29462782f, -0.30483314f, 
    -0.01543263f, 0.22392502f, 0.03273061f, 0.02339832f, -0.03353459f, -0.12853418f, -0.01143831f, 0.08111214f, 
    0.31963235f, -0.21123195f, -0.19482659f, -0.06975345f, -0.15402059f, 0.05478107f, 0.01679246f, -0.03900731f, 
    0.02667100f, -0.05032964f, 0.10968537f, 0.25136143f, -0.17929772f, -0.11095284f, -0.06567387f, 0.01194084f, 
    -0.11281159f, 0.11670790f, -0.26526225f, 0.05477255f, 0.14920601f, 0.04467751f, 0.19629912f, 0.09722628f, 
    -0.22529095f, 0.06190047f, 0.31183523f, 0.07397948f, -0.04938398f, 0.36555001f, -0.16222641f, -0.18014601f, 
    -0.06874409f, -0.02304780f, 0.19098392f, -0.04659567f, 0.08437162f, 0.07867338f, 0.13197014f, 0.02192695f, 
    0.06144606f, -0.01815851f, -0.15302375f, -0.10598609f, -0.02908889f, -0.18310454f, -0.02007192f, 0.16879602f, 
    0.03122566f, -0.12186912f, 0.01946813f, -0.13842681f, -0.06131055f, 0.00781413f, -0.21242003f, -0.07543882f, 
    0.19318603f, -0.08105873f, 0.22303326f, 0.11515154f, -0.00663428f, 0.05512880f, 0.08322681f, 0.09575903f, 
    -0.04081780f, 0.13052443f, 0.02770068f, -0.01693602f, 0.00180351f, 0.09309632f, 0.06942443f, 0.07940060f, 
    0.01449657f, 0.02616416f, 0.20706798f, -0.02804810f, 0.04500669f, 0.00530603f, 0.01072258f, -0.13149288f, 
    0.04712297f, -0.07224465f, 0.25179958f, 0.05384692f, 0.03070212f, 0.06636893f, 0.05320236f, -0.16128831f, 
    0.06911776f, -0.03198336f, -0.16415067f, -0.01289983f, -0.05274956f, -0.10496631f, -0.00179881f, 0.08293529f, 
    -0.01379436f, -0.02319307f, 0.07959065f, -0.05793754f, 0.12235741f, -0.06066437f, -0.10829041f, -0.07791126f, 
    0.22554801f, -0.14929774f, 0.08341008f, 0.05390229f, 0.12845340f, 0.20280752f, 0.10151690f, -0.28631839f, 
    -0.08942091f, -0.18265812f, 0.00763053f, -0.04129211f, 0.04701985f, 0.43236631f, -0.05984271f, -0.20328905f, 
    -0.25018001f, 0.06637416f, -0.09627885f, 0.04526161f, 0.10647672f, 0.07164235f, -0.01133221f, 0.23474871f, 
    0.11756200f, -0.23476568f, 0.14631486f, -0.21941251f, -0.03006919f, -0.02236413f, 0.14450127f, 0.18898423f, 
    -0.03002303f, -0.34389323f, -0.00125699f, -0.01556524f, 0.03107766f, -0.01837214f, -0.03734224f, -0.06982159f, 
    0.01004892f, -0.09163468f, 0.13647342f, -0.08447623f, 0.18100217f, 0.02789664f, 0.08128925f, -0.08951417f, 
    -0.03296246f, 0.15314332f, 0.11621687f, 0.27947897f, -0.15869555f, 0.04338974f, -0.17532885f, -0.09005952f, 
    0.01602182f, -0.00587770f, 0.48580313f, 0.15696956f, -0.31796768f, -0.00768831f, -0.08643471f, -0.01810780f, 
    0.19526291f, 0.05520041f, -0.05695108f, -0.09079814f, -0.19681032f, -0.09890708f, 0.03792015f, -0.01497898f, 
    -0.04618896f, -0.27139285f, -0.10121747f, -0.01441277f, -0.01948365f, 0.05885260f, 0.32428062f, -0.09311260f, 
    0.12181202f, -0.04908581f, -0.11654273f, 0.05396429f, 0.07541950f, -0.11260258f, 0.04553185f, 0.06975871f, 
    0.09006260f, -0.00545722f, 0.11783025f, 0.02867870f, 0.06520374f, -0.01811725f, 0.07582942f, 0.04964942f, 
    0.03095840f, 0.04401323f, 0.15062532f, -0.06005042f, -0.06916863f, -0.10895997f, 0.01026035f, 0.36833814f, 
    -0.13824661f, -0.35932770f, -0.19013318f, 0.05403974f, -0.06011119f, 0.05557923f, -0.05147604f, -0.02287146f, 
    -0.01824818f, 0.01581617f, 0.32379043f, -0.08814677f, 0.16653180f, -0.01312277f, 0.00666029f, 0.07679456f, 
    -0.07654244f, -0.37389943f, -0.27715021f, 0.05359110f, -0.07607042f, -0.07392217f, 0.05322578f, -0.00575833f, 
    0.06380638f, -0.10794635f, -0.01518149f, -0.04306549f, 0.06881506f, -0.08027591f, 0.16514587f, 0.14337330f, 
    -0.08163147f, 0.15513378f, 0.27006423f, -0.01226858f, -0.15447088f, 0.05073192f, 0.08801137f, -0.10171639f, 
    0.06635202f, -0.17765988f, 0.04399367f, 0.04023112f, -0.04626117f, -0.05807706f, 0.09994915f, -0.04439181f, 
    0.01816632f, 0.12951599f, -0.04512936f, 0.04514288f, 0.07937775f, 0.12333871f, 0.21407443f, 0.17291647f, 
    -0.08351557f, 0.03843027f, 0.02980986f, -0.07072467f, 0.12641548f, 0.19336832f, -0.09503089f, 0.04305341f, 
    -0.33211973f, 0.07646143f, 0.03112571f, -0.03630484f, 0.03527841f, -0.05431357f, 0.05144028f, 0.45241839f, 
    0.04205303f, -0.15335900f, 0.12044803f, -0.00828141f, -0.32163331f, 0.10959905f, 0.08887000f, -0.11151020f, 
    -0.40030974f, -0.07061283f, 0.11088310f, -0.08937989f, 0.01357893f, -0.18373528f, -0.03816502f, 0.00570895f, 
    -0.10516669f, 0.15324724f, -0.03253348f, -0.04255496f, 0.10734044f, 0.05990759f, -0.04548267f, -0.01193466f, 
    -0.04636367f, 0.15185227f, 0.00133007f, -0.00572070f, -0.02449201f, -0.15131624f, -0.00437097f, 0.02681555f, 
    -0.07895094f, 0.11645122f, -0.15315446f, 0.08594836f, -0.06948512f, 0.02098010f, 0.15005985f, -0.10253832f, 
    0.25375441f, -0.06280103f, -0.21620615f, 0.07577541f, -0.09771936f, 0.13695030f, 0.08443795f, 0.00093196f, 
    -0.15892474f, -0.09057713f, -0.13920704f, 0.05882969f, 0.17529124f, 0.20219798f, 0.21683402f, -0.16568252f, 
    -0.05831458f, -0.08729637f, -0.01702987f, -0.05548650f, 0.11202536f, 0.11211795f, 0.11049073f, -0.16661350f, 
    -0.06818885f, 0.05540907f, 0.09626660f, 0.02226771f, -0.06327029f, 0.07562824f, 0.07217944f, -0.43945768f, 
    -0.34802645f, -0.30948451f, -0.09991609f, 0.05614862f, 0.00256693f, -0.00365061f, 0.02590338f, -0.09305082f, 
    0.13320413f, -0.01851572f, 0.03922266f, -0.02000605f, -0.13362156f, -0.08658628f, -0.10518590f, 0.06121856f, 
    -0.08260565f, 0.05732596f, -0.13068269f, 0.00767750f, -0.03967544f, 0.00752874f, -0.02571727f, 0.06214076f, 
    0.16435191f, 0.10079047f, 0.26991341f, 0.08257155f, 0.09186734f, 0.02289448f, 0.07584262f, 0.15154709f, 
    0.04662509f, 0.10760070f, 0.04603351f, -0.03774958f, -0.08101901f, -0.08702401f, 0.02222637f, -0.03869505f, 
    -0.10769086f, 0.03694696f, -0.10107781f, 0.04807270f, 0.15405665f, -0.06262654f, -0.05299417f, 0.10742829f, 
    0.10446110f, 0.16365346f, 0.00216657f, 0.00433771f, 0.01282538f, -0.22384071f, 0.16210590f, 0.26403525f, 
    -0.07594801f, -0.08052864f, 0.03323741f, 0.03529164f, -0.02984210f, -0.09069954f, -0.16093285f, -0.28619352f, 
    0.11362589f, -0.08729289f, 0.16344282f, -0.04470013f, 0.04190980f, 0.14523834f, 0.07634590f, 0.15977323f, 
    0.14720920f, 0.10384183f, -0.11449724f, 0.13691625f, 0.07680611f, 0.03113680f, -0.01335487f, -0.06325044f, 
    -0.12226602f, -0.24367891f, -0.03400146f, 0.10620809f, 0.14728945f, -0.03205426f, 0.05108076f, 0.17647520f, 
    0.21100836f, -0.28575364f, -0.14741717f, 0.11787602f, -0.28702015f, -0.11229978f, 0.07013235f, 0.04467417f, 
    0.01611341f, 0.06767762f, -0.18983182f, -0.07854638f, 0.29354778f, -0.10732404f, 0.00253754f, 0.12617859f, 
    -0.21556799f, -0.01517707f, -0.14727215f, 0.09824809f, 0.10572721f, -0.07740146f, 0.04265609f, 0.05078468f, 
    0.03630862f, 0.06421400f, -0.11524272f, 0.00182655f, -0.14102222f, 0.06416983f, 0.07872616f, -0.08765117f, 
    0.06931707f, 0.17113081f, -0.02510535f, 0.01671232f, 0.11803062f, 0.16765390f, 0.17802657f, 0.23408061f, 
    -0.00048440f, 0.00867337f, -0.23277387f, 0.21701258f, -0.04485299f, -0.05912367f, -0.12096011f, 0.03912768f, 
    0.12672982f, -0.02506876f, -0.04961003f, -0.12843393f, 0.12661585f, -0.27763844f, 0.01253437f, -0.06891257f, 
    0.08935345f, 0.35430679f, 0.06224791f, 0.05531344f, 0.09004571f, 0.13340257f, 0.05652186f, 0.17195897f, 
    -0.56204450f, -0.62308359f, -0.44312167f, 0.07519744f, 0.02213077f, -0.12474489f, 0.05056829f, -0.02470622f, 
    0.14286816f, 0.06919168f, 0.10665662f, -0.23867907f, 0.11727524f, 0.13341010f, -0.06430812f, -0.03834388f, 
    0.08992725f, 0.03293754f, -0.47588018f, -0.58401704f, -0.43562034f, -0.05178469f, -0.05733160f, -0.07642967f, 
    0.00741674f, 0.01151027f, 0.13053423f, -0.25810927f, -0.26357663f, -0.17346899f, -0.07071044f, 0.01631025f, 
    -0.17282951f, -0.04818607f, -0.16310740f, -0.00574613f, 0.24480969f, 0.07638037f, -0.02783140f, 0.08830233f, 
    0.04367306f, 0.14131379f, 0.00067462f, 0.10341369f, 0.07900976f, -0.18097724f, -0.05901349f, 0.21140836f, 
    0.00237104f, 0.02739093f, 0.04710819f, 0.05760211f, 0.02261377f, 0.00674560f, -0.00656656f, 0.16391088f, 
    -0.17939663f, -0.04715965f, 0.20430991f, -0.10248410f, 0.00184867f, 0.02560327f, 0.04563558f, -0.50971568f, 
    -0.02956017f, 0.08173498f, -0.17099132f, -0.05460399f, 0.12353959f, -0.06479640f, 0.00192362f, -0.09250125f, 
    -0.15837425f, -0.30755454f, -0.23175776f, -0.04617489f, 0.04643470f, 0.04400854f, 0.04882373f, 0.08487088f, 
    0.16473240f, -0.03191623f, 0.07041583f, -0.00917095f, 0.00879774f, -0.06107746f, 0.09408058f, 0.05403559f, 
    -0.07882386f, 0.03124488f, 0.12569794f, 0.00338075f, 0.05240532f, 0.07311071f, -0.11964289f, 0.04633600f, 
    0.00591042f, -0.12347397f, 0.09483141f, 0.18359391f, -0.07340565f, -0.21810894f, 0.23612073f, -0.08010717f, 
    -0.04270732f, 0.03307192f, -0.13060394f, -0.05753206f, -0.21362326f, 0.08150467f, -0.03570752f, -0.01532566f, 
    0.09812942f, 0.04755038f, 0.05319081f, -0.06099974f, -0.05395708f, 0.21406165f, 0.13779761f, 0.09315043f, 
    -0.02049675f, 0.06483909f, -0.06620654f, 0.09304702f, 0.01611830f, -0.05984865f, 0.26358879f, 0.03759105f, 
    0.14211114f, -0.10607377f, -0.15257142f, -0.03094550f, 0.03444604f, -0.02213359f, -0.01093957f, 0.39656907f, 
    0.21867789f, 0.33484069f, 0.06358568f, 0.03547427f, 0.08447145f, -0.05388828f, -0.02527597f, 0.10340209f, 
    -0.04057650f, 0.35591939f, 0.02893895f, -0.01640681f, -0.20124923f, 0.07952081f, -0.11202945f, -0.15132642f, 
    -0.02934916f, 0.22583307f, -0.05943580f, 0.13323556f, 0.10186687f, 0.00439981f, -0.07620341f, -0.08140635f, 
    -0.07919702f, 0.05109195f, 0.07464951f, -0.08878722f, 0.10329194f, -0.04206308f, -0.01149935f, -0.01011738f, 
    -0.03268617f, -0.00051734f, 0.03105456f, -0.09550730f, 0.14755572f, 0.03077696f, -0.03264517f, -0.03855905f, 
    0.01663703f, -0.06638011f, 0.08552729f, -0.05923285f, 0.01753787f, 0.03891018f, -0.27011034f, 0.03082802f, 
    -0.07206281f, -0.02120657f, 0.05416110f, -0.01250374f, -0.15836261f, -0.10475611f, 0.02998882f, -0.07787177f, 
    0.29958490f, -0.13260041f, 0.15982209f, -0.05294992f, -0.04416998f, 0.07721359f, 0.17182803f, 0.07075252f, 
    -0.11534409f, -0.08208666f, 0.10954542f, 0.11049718f, -0.08826571f, -0.03608852f, -0.14300273f, -0.07694537f, 
    0.02773495f, -0.28463581f, 0.05967024f, -0.10862573f, 0.13861781f, 0.01373272f, 0.01150199f, 0.11797614f, 
    0.06041593f, 0.20958434f, 0.21779768f, -0.14812309f, -0.03725919f, -0.07778251f, 0.04723100f, 0.02260388f, 
    -0.18555014f, 0.19340874f, 0.02257776f, -0.34228429f, -0.02946766f, 0.01862768f, 0.04863344f, -0.01733605f, 
    -0.10164217f, -0.14722693f, -0.04708011f, 0.06826668f, 0.12920581f, 0.27181956f, -0.02672663f, 0.14000458f, 
    -0.10963175f, -0.03884803f, -0.03837958f, 0.04275961f, 0.14315286f, -0.01316269f, -0.12535018f, 0.06223776f, 
    0.07527665f, 0.03480250f, 0.17568219f, 0.05188534f, -0.14272325f, 0.22382741f, -0.12866445f, 0.10950403f, 
    0.13377191f, 0.07209253f, 0.09960926f, -0.12732629f, -0.02916879f, 0.14745556f, 0.17257567f, 0.02247844f, 
    0.16150482f, 0.09650006f, -0.03912198f, 0.08494799f, -0.00792050f, -0.03105157f, -0.06266396f, 0.04105909f, 
    0.09942864f, 0.02410029f, -0.03716423f, -0.04475199f, 0.10137518f, 0.19487616f, -0.06678002f, 0.11582617f, 
    -0.08488511f, -0.21433716f, 0.29406661f, -0.01716992f, 0.16561368f, 0.01555509f, -0.17096752f, 0.05673788f, 
    0.21967256f, 0.20966554f, 0.33188263f, 0.11692160f, 0.03471510f, -0.10664124f, 0.08497413f, 0.04178837f, 
    0.03791550f, -0.21218728f, 0.20915210f, 0.18026932f, -0.07526039f, -0.01394281f, 0.01894165f, 0.02681863f, 
    0.08087109f, 0.08139800f, 0.10522017f, -0.01210443f, 0.17968778f, 0.13614711f, -0.00581183f, -0.02646337f, 
    0.03212047f, 0.05473395f, -0.15880214f, 0.37640303f, -0.06298946f, 0.26553628f, 0.10888606f, 0.13764739f, 
    0.10384565f, -0.01345369f, -0.11187359f, 0.06121105f, -0.02390528f, 0.13466063f, -0.05662049f, -0.00951055f, 
    -0.10501637f, -0.06576000f, -0.01855238f, -0.00126596f, -0.07514007f, 0.05459356f, -0.06794547f, -0.06807184f, 
    0.01480915f, -0.08851537f, 0.12761784f, 0.08399903f, -0.24889843f, -0.16621216f, -0.09640072f, -0.05251869f, 
    0.07120159f, -0.01606071f, 0.00282308f, -0.02816979f, -0.18914004f, -0.05191242f, -0.21368280f, -0.01361291f, 
    -0.44176960f, -0.13698465f, 0.24635370f, -0.06294256f, 0.18363704f, -0.01351756f, -0.00401405f, 0.04775948f, 
    -0.16658092f, 0.22173649f, -0.05106049f, -0.01606290f, -0.02622525f, -0.10249481f, -0.05797572f, -0.08975495f, 
    -0.12915662f, 0.10103012f, 0.07740572f, 0.03057817f, 0.17083262f, 0.10525271f, 0.00545796f, -0.20498729f, 
    0.07899177f, -0.03892771f, 0.22325380f, 0.29723558f, 0.14107092f, -0.10585056f, -0.06123599f, 0.13795048f, 
    0.15087953f, 0.09747081f, -0.11679754f, -0.00366721f, 0.04879481f, 0.10647798f, -0.06097259f, 0.02517936f, 
    0.12527421f, -0.08439206f, 0.00844427f, 0.05753613f, -0.04267105f, -0.07933390f, -0.07477164f, 0.13376001f, 
    -0.07672799f, 0.02000895f, -0.20937531f, -0.01151548f, -0.27073276f, 0.07290825f, 0.01732438f, 0.15015700f, 
    0.13284166f, -0.04520432f, 0.02318022f, -0.23985806f, -0.07714912f, -0.07378916f, -0.10920724f, 0.24225451f, 
    -0.01200676f, 0.01052111f, -0.11105533f, 0.02869269f, 0.00268815f, 0.08446044f, 0.03440964f, -0.24989198f, 
    -0.04247349f, -0.14413133f, 0.04484426f, 0.11610317f, 0.03154135f, 0.00723257f, -0.05178516f, -0.00805868f, 
    0.19933578f, 0.09188343f, 0.20081411f, -0.09305181f, -0.14107253f, -0.05907835f, -0.12358536f, 0.01429714f, 
    -0.14841732f, -0.06223977f, -0.07624754f, 0.10466927f, 0.07495096f, -0.06829078f, 0.06892046f, -0.02703811f, 
    0.19316193f, -0.00550172f, 0.05866072f, 0.04737433f, 0.18801503f, 0.11817618f, 0.01324926f, 0.15798874f, 
    -0.07644963f, -0.04393812f, 0.07052319f, 0.18050011f, 0.09568099f, 0.04030704f, 0.15149090f, 0.03763585f, 
    0.01364749f, -0.22107071f, -0.11830407f, -0.10490006f, -0.01344400f, 0.18042067f, 0.08654801f, 0.13013440f, 
    0.11894268f, 0.16597761f, -0.01662323f, 0.14820822f, -0.01692291f, -0.12196365f, 0.03950028f, 0.15793429f, 
    -0.08734944f, 0.01467365f, -0.07086372f, -0.04972528f, -0.12254681f, 0.10355167f, -0.10126434f, 0.10500780f, 
    0.15225817f, -0.00570165f, -0.16376525f, -0.02049891f, -0.15581934f, 0.15234216f, 0.05912051f, -0.03166232f, 
    0.00714371f, 0.01370858f, 0.11364895f, -0.05158593f, -0.03586826f, -0.09469685f, -0.17083941f, -0.09254790f, 
    -0.16788338f, 0.10386765f, -0.02419218f, -0.03156468f, 0.00383597f, -0.06274534f, -0.05355232f, 0.12317964f, 
    -0.00612239f, 0.06348071f, 0.01544740f, 0.05461180f, 0.00365489f, 0.06131783f, 0.09903102f, -0.18829551f, 
    -0.02018317f, 0.05929765f, -0.32542890f, -0.16577193f, -0.01513631f, -0.00758462f, -0.04171106f, -0.16305198f, 
    -0.12303162f, -0.15277097f, -0.17247647f, -0.00131233f, 0.00206814f, -0.15543061f, -0.01415321f, -0.03544380f, 
    0.00992681f, -0.06628905f, -0.28947377f, -0.20871550f, -0.00942610f, 0.15734811f, 0.16193008f, 0.24286163f, 
    0.08340713f, -0.09342479f, -0.30353341f, -0.03455292f, 0.02063903f, 0.11342977f, 0.01871360f, 0.09948001f, 
    0.12814075f, -0.04785208f, -0.16419584f, -0.00485615f, 0.08193698f, -0.15669967f, -0.08726299f, 0.04172967f, 
    -0.03742284f, 0.03341464f, -0.10854961f, -0.05289414f, 0.00395240f, 0.04443566f, -0.17529675f, -0.12921457f, 
    0.16871515f, 0.12624331f, -0.13719846f, -0.12207373f, -0.11827227f, 0.12898453f, -0.01290710f, 0.04435531f, 
    -0.10999098f, 0.03700243f, -0.23430760f, 0.03968558f, 0.11555203f, 0.04976324f, 0.06831407f, 0.03163214f, 
    0.14313503f, 0.17557637f, -0.11422704f, 0.10456490f, 0.01826547f, 0.07704146f, -0.07486754f, -0.11558058f, 
    -0.03263626f, 0.09027518f, 0.06656303f, -0.28289843f, -0.21090612f, 0.07061764f, -0.11085027f, 0.02101679f, 
    0.12323336f, 0.04912730f, 0.11736678f, -0.04430595f, 0.01993912f, -0.22780558f, 0.05181122f, 0.16124457f, 
    -0.06054880f, -0.09960872f, 0.01802238f, 0.03860153f, 0.10248324f, 0.14549524f, 0.08833980f, 0.03608982f, 
    -0.12406743f, -0.03130381f, -0.14364623f, 0.02944920f, 0.15866683f, 0.01278406f, 0.06156754f, 0.11271236f, 
    -0.01169964f, -0.07275935f, -0.10514920f, 0.04060790f, -0.02591173f, 0.06597680f, -0.05548221f, -0.02265248f, 
    0.04029625f, -0.03606746f, 0.01536420f, -0.18492655f, 0.12183432f, 0.04152793f, 0.06758519f, -0.03744769f, 
    0.03783252f, 0.05978156f, 0.03599870f, 0.01789569f, 0.12618211f, 0.13591683f, 0.02156042f, -0.00565544f, 
    -0.54087329f, -0.22351505f, -0.05881201f, 0.15681535f, 0.03630633f, -0.11146873f, -0.02365087f, -0.01765009f, 
    0.18486355f, 0.09417010f, 0.11759056f, 0.39792818f, -0.01315483f, -0.06650922f, -0.11723226f, 0.06879914f, 
    0.12314148f, 0.11853819f, -0.04010236f, 0.41778234f, 0.37506905f, -0.08975318f, 0.01379659f, 0.05400583f, 
    -0.05482804f, -0.04557272f, -0.16091180f, -0.06791110f, -0.12941331f, 0.46300218f, -0.18939650f, -0.00632650f, 
    0.16440757f, -0.11534782f, 0.05648905f, -0.16817546f, -0.13264804f, -0.04803113f, -0.10693195f, -0.00898947f, 
    -0.06181017f, -0.12011021f, 0.14433540f, -0.07190805f, 0.11260592f, -0.48433343f, 0.06694301f, 0.18541928f, 
    0.04921993f, -0.18100886f, -0.12874839f, -0.11589932f, -0.06690030f, 0.09627523f, -0.00847292f, 0.14779958f, 
    -0.05129098f, -0.01152210f, -0.02813037f, -0.11203386f, -0.05049459f, 0.03101701f, 0.09586260f, -0.17364399f, 
    -0.47760549f, 0.36123106f, -0.20226827f, -0.06593865f, 0.08082303f, 0.06965920f, 0.00545941f, 0.04510620f, 
    0.32210377f, 0.34246737f, -0.09337234f, 0.01889095f, -0.22355111f, 0.03672207f, 0.08916792f, 0.10327317f, 
    0.03047963f, -0.27970341f, 0.23150647f, 0.24814911f, 0.15232705f, -0.00390370f, -0.19367978f, -0.15086694f, 
    0.01763256f, 0.13040243f, -0.14922816f, 0.15461624f, -0.36768335f, -0.02797519f, -0.00919646f, -0.00571476f, 
    0.05989820f, -0.06388681f, 0.09913908f, -0.18384151f, -0.27756512f, -0.08412702f, 0.01624474f, -0.00946904f, 
    0.14958690f, -0.04469488f, -0.11984017f, 0.13689876f, -0.24684599f, -0.25820738f, -0.12885794f, 0.09431070f, 
    0.21842583f, 0.12938604f, -0.07411581f, -0.08643749f, -0.04208118f, 0.32275543f, 0.04054055f, 0.36848119f, 
    -0.01992248f, -0.08749694f, -0.20605581f, 0.07761739f, 0.12755233f, -0.06460947f, 0.23228338f, 0.24219821f, 
    -0.11524044f, -0.08160172f, -0.32570443f, -0.09168785f, 0.10543574f, -0.07431728f, 0.06626435f, -0.44930074f, 
    -0.17763190f, 0.15261212f, 0.02826789f, 0.09849988f, -0.23101582f, -0.12031151f, 0.04940310f, 0.02593114f, 
    -0.17989689f, -0.11513656f, 0.20555499f, -0.03394977f, -0.03034036f, -0.06711084f, -0.01173708f, 0.06304950f, 
    -0.02194314f, 0.01133755f, 0.05791560f, 0.18022978f, 0.15310805f, 0.09114882f, -0.01463753f, 0.10031036f, 
    -0.02447942f, 0.01751383f, -0.07994639f, -0.14849152f, -0.08631529f, 0.07986652f, 0.00097970f, 0.12460341f, 
    0.09784114f, 0.10770928f, 0.04523953f, 0.00887113f, -0.12432252f, 0.12268443f, 0.08614555f, 0.02965212f, 
    -0.04466259f, -0.01639097f, 0.01719675f, 0.06948618f, 0.07501644f, 0.11981253f, 0.13797489f, 0.03328235f, 
    0.11346783f, -0.14060844f, -0.09143756f, 0.05159046f, -0.09805270f, -0.15763605f, 0.01262451f, 0.12714593f, 
    -0.03873971f, -0.22214234f, -0.24351956f, -0.04888596f, 0.02616404f, -0.01968801f, -0.19445375f, -0.00242514f, 
    0.10760057f, -0.02258053f, -0.00075229f, -0.17205232f, 0.08028850f, 0.01845758f, 0.01446991f, 0.10656414f, 
    0.33185640f, 0.05805757f, -0.03283117f, 0.00820606f, 0.02745381f, 0.10522393f, 0.09196592f, -0.16956030f, 
    -0.18342552f, -0.12301232f, 0.12257646f, 0.00947949f, -0.11241110f, -0.02175150f, 0.02074080f, -0.01483817f, 
    0.02444861f, 0.11317355f, -0.18909216f, 0.09882699f, 0.12002886f, -0.22012320f, 0.23585723f, -0.08500604f, 
    -0.09054928f, 0.12003406f, -0.30298582f, 0.21127595f, 0.27161139f, -0.09708613f, -0.03072417f, -0.01305625f, 
    0.16629280f, -0.00191220f, -0.00178764f, 0.18971974f, 0.04486921f, 0.13279916f, 0.05488983f, 0.01774494f, 
    0.01803944f, 0.10510922f, 0.07811776f, 0.13703988f, -0.06377614f, 0.14647590f, 0.09387941f, -0.04135805f, 
    0.09959438f, 0.10294729f, -0.11483867f, -0.00006427f, -0.06242252f, -0.00428794f, -0.04260897f, -0.04772487f, 
    0.07740921f, 0.04075373f, -0.03211137f, -0.04255655f, -0.03836281f, 0.04140761f, -0.41307855f, -0.00326871f, 
    -0.16320010f, 0.14418122f, 0.02220570f, -0.04931546f, 0.02226702f, 0.01860598f, -0.04294112f, -0.26645684f, 
    0.53098786f, 0.05452516f, 0.02312251f, -0.16934212f, -0.29937252f, 0.05346992f, -0.11439593f, -0.08409487f, 
    0.02922290f, -0.03729372f, -0.01426930f, 0.01344169f, -0.00689629f, 0.03262861f, -0.03783120f, -0.02238152f, 
    -0.05715210f, 0.04390369f, -0.00441583f, 0.03648440f, -0.04157890f, -0.01123726f, -0.01658875f, 0.03477587f, 
    -0.06684707f, -0.01514831f, -0.01915773f, -0.03578049f, 0.02694635f, 0.00244053f, 0.01458766f, -0.01717984f, 
    0.02261246f, 0.00663710f, 0.05205113f, -0.00446174f, -0.01648760f, -0.04144271f, 0.01029118f, -0.01914907f, 
    -0.05655685f, -0.04239165f, 0.03494997f, -0.01893645f, -0.03986597f, 0.01868827f, -0.05843008f, -0.03093019f, 
    0.02562653f, -0.05912052f, -0.01767289f, 0.00404465f, 0.01673176f, -0.00506790f, -0.02388112f, -0.04190657f, 
    -0.06178930f, -0.01347072f, -0.04563934f, -0.06154062f, -0.03760576f, 0.01719855f, 0.03014759f, -0.04196475f, 
    -0.03489322f, -0.03625033f, 0.00711830f, 0.02799795f, -0.03456815f, 0.01955973f, -0.06315424f, 0.03172045f, 
    -0.04691017f, 0.04946775f, -0.00096217f, 0.03789094f, -0.04626492f, -0.02084911f, 0.02740392f, 0.04792156f, 
    -0.06513648f, -0.05451274f, -0.00288023f, -0.05271342f, 0.02101713f, -0.00798910f, 0.01653551f, -0.06356926f, 
    -0.03710112f, -0.02484361f, -0.04254786f, -0.03319484f, 0.04578601f, 0.04441120f, 0.03061241f, 0.04860480f, 
    0.04303584f, -0.04009582f, -0.01410199f, 0.02935530f, -0.03009477f, 0.00033947f, -0.05929418f, 0.02172058f, 
    0.00396123f, -0.00241121f, -0.03540299f, -0.05072588f, -0.04766861f, -0.01840872f, 0.02073662f, -0.00636304f, 
    -0.00569498f, 0.02804125f, -0.04812153f, -0.02613830f, -0.00172414f, 0.01281425f, 0.03664429f, 0.02053993f, 
    0.04499817f, -0.05769237f, -0.03191348f, -0.03000237f, -0.00286782f, -0.03443301f, -0.02263790f, -0.01228950f, 
    -0.05801881f, -0.04894143f, -0.03968406f, 0.05294310f, 0.01393023f, -0.05062373f, 0.02315898f, -0.00743056f, 
    -0.02839986f, 0.04907933f, 0.02947480f, -0.01296977f, 0.03783546f, -0.04147123f, -0.05305297f, 0.02696297f, 
    0.01402375f, -0.04854052f, -0.03893751f, 0.01872182f, -0.05948396f, 0.03580061f, -0.05379576f, -0.00187267f, 
    0.03810688f, 0.04840204f, -0.05471388f, -0.03506111f, 0.04900746f, -0.00340517f, -0.04885409f, 0.00017466f, 
    0.01945071f, -0.05486692f, 0.03273197f, -0.02374620f, 0.04811534f, 0.03416185f, -0.00795035f, -0.02934287f, 
    0.01829965f, 0.04473008f, 0.00376598f, 0.04379257f, -0.01420328f, -0.04361945f, -0.04492233f, 0.00774725f, 
    0.03223218f, -0.03814231f, -0.04115408f, 0.04007441f, -0.01215541f, 0.03170364f, 0.01754676f, -0.01256852f, 
    -0.00098918f, 0.03618047f, -0.05982583f, -0.02555177f, 0.02741431f, 0.03980836f, -0.04048484f, -0.06219763f, 
    0.01624717f, -0.00687850f, -0.01881376f, 0.01950632f, -0.03939482f, 0.04590741f, -0.03441500f, -0.02220746f, 
    -0.05610889f, -0.04153124f, -0.01514216f, -0.05201335f, -0.05329861f, -0.04372017f, 0.00863179f, -0.02850133f, 
    -0.01391353f, -0.01453196f, -0.05887682f, 0.00642064f, 0.00530679f, -0.02498779f, -0.04354993f, 0.03110374f, 
    -0.00984665f, 0.02248718f, 0.04952049f, 0.01117797f, -0.00476490f, 0.00637131f, -0.03123689f, 0.03639560f, 
    0.02360376f, -0.03640927f, -0.03445765f, -0.03810605f, -0.01256044f, -0.00865873f, 0.05148263f, 0.00537787f, 
    0.00203064f, 0.02284891f, -0.01491479f, -0.05012408f, -0.02637844f, -0.02745608f, -0.01714758f, -0.05094975f, 
    -0.00777413f, 0.04913968f, -0.00233494f, 0.05019696f, 0.04709328f, -0.03089720f, -0.03974903f, -0.01869125f, 
    -0.05387186f, -0.04547938f, 0.00413111f, 0.02608563f, 0.03786040f, -0.02979267f, -0.06022711f, -0.04089295f, 
    -0.00997659f, 0.00871144f, 0.02803351f, 0.01386341f, -0.03060511f, 0.02637571f, -0.05595956f, -0.01524384f, 
    0.02159433f, -0.02458441f, -0.04394390f, -0.00605562f, -0.03579976f, -0.00658041f, -0.00675783f, -0.00708906f, 
    0.02103993f, -0.03244254f, -0.06404795f, 0.00293349f, -0.05923356f, 0.01876891f, 0.04285074f, 0.02320030f, 
    0.00740868f, 0.01410708f, -0.05726339f, -0.00160772f, -0.03018437f, -0.03123860f, -0.03382539f, -0.04269359f, 
    0.00058744f, -0.01196795f, -0.03736715f, 0.02897688f, 0.03338659f, 0.02067284f, -0.00562323f, 0.00678684f, 
    -0.03277177f, 0.02185225f, 0.01342179f, -0.05036936f, -0.06023724f, 0.01563965f, 0.03053522f, -0.05532294f, 
    -0.02584001f, -0.04093064f, 0.04907702f, -0.03358763f, 0.01210162f, 0.02492508f, 0.01955109f, 0.01834597f, 
    0.01946554f, 0.04658785f, 0.03699891f, 0.00937920f, -0.00266344f, -0.02618907f, -0.00162424f, -0.05516796f, 
    0.00936560f, -0.06006987f, 0.01950907f, 0.02370175f, -0.04951639f, -0.02997006f, 0.01497855f, -0.01811978f, 
    -0.01667858f, -0.04478290f, -0.05400154f, -0.05716351f, 0.01803964f, -0.01580700f, -0.01543527f, 0.00794938f, 
    -0.06187866f, 0.00707974f, 0.00355772f, 0.00269422f, -0.03886864f, -0.00860849f, 0.03091539f, 0.03764270f, 
    0.03609528f, -0.00261222f, -0.00177327f, -0.02371357f, -0.03697650f, 0.00568402f, 0.03633293f, -0.05978590f, 
    -0.02201914f, 0.01502444f, -0.06359931f, -0.00091283f, 0.00275969f, -0.04636905f, -0.05297580f, -0.02095738f, 
    0.00023013f, 0.03460941f, -0.03426447f, -0.03433774f, 0.04467243f, 0.01880818f, -0.06495217f, -0.02306814f, 
    -0.00616573f, 0.05188404f, -0.00555070f, -0.00953229f, -0.00575017f, -0.06074376f, 0.05160303f, -0.00594729f, 
    0.01618828f, -0.02609016f, 0.01254260f, -0.06300917f, -0.02861757f, 0.00874048f, 0.03394879f, 0.02687618f, 
    -0.06477504f, -0.00726087f, 0.05194680f, 0.03228883f, 0.04479289f, 0.02119450f, -0.02029210f, -0.03374271f, 
    -0.05535319f, 0.01043931f, 0.02990795f, -0.04141715f, 0.02735461f, -0.01071280f, 0.02211348f, 0.02179681f, 
    0.03415900f, -0.03051848f, -0.00039675f, 0.02513419f, 0.02141264f, -0.06779059f, -0.06607243f, -0.01832205f, 
    -0.00156591f, 0.00254225f, 0.04183065f, -0.00924450f, -0.03541653f, 0.01258935f, 0.06273035f, 0.04681307f, 
    0.04170508f, -0.04711104f, 0.03593764f, -0.00764038f, 0.03052035f, 0.02011441f, 0.00030988f, -0.03868159f, 
    0.03818597f, -0.06021421f, 0.03599968f, -0.04612491f, -0.00014822f, 0.00281274f, -0.02157199f, 0.00110635f, 
    0.01058979f, -0.01160648f, 0.02984377f, 0.00871817f, -0.03585287f, -0.00842256f, -0.00259554f, -0.02857400f, 
    -0.02745355f, 0.02882931f, -0.01220055f, -0.02548219f, -0.03015119f, -0.05163405f, -0.04020518f, 0.02231610f, 
    -0.02464921f, -0.06353892f, 0.00007199f, -0.06243435f, -0.04374612f, -0.07468385f, 0.01124219f, 0.04085432f, 
    0.02585731f, 0.05618076f, 0.02411051f, -0.02790851f, -0.03188827f, -0.04998596f, -0.04997478f, 0.00497061f, 
    -0.00078157f, -0.03794846f, -0.05566391f, -0.02997423f, 0.01021214f, -0.02719286f, -0.06188443f, 0.00994549f, 
    -0.02171210f, -0.04063991f, -0.02966258f, 0.04650736f, 0.00004498f, 0.04067314f, -0.04502266f, -0.04103149f, 
    -0.01220424f, 0.02651103f, 0.03855000f, -0.01181309f, -0.01741510f, 0.03704254f, -0.05211671f, 0.03117298f, 
    0.01644173f, -0.01622186f, 0.00665551f, 0.06066032f, 0.00983145f, -0.06689465f, -0.02145573f, -0.06010130f, 
    0.02273444f, 0.01547933f, 0.00955653f, 0.03133832f, 0.01049851f, 0.04154170f, -0.02659139f, -0.02198300f, 
    -0.06162677f, -0.02860641f, -0.02320092f, -0.01214953f, -0.06228356f, -0.00062899f, -0.04699574f, 0.01406055f, 
    0.04035174f, 0.02714009f, -0.00528281f, -0.00264212f, 0.01517824f, -0.06761808f, 0.02794107f, 0.02449508f, 
    -0.00413223f, 0.00714779f, -0.00465919f, 0.04406518f, 0.01508282f, -0.00226585f, 0.02550177f, 0.00631300f, 
    -0.04580795f, -0.01995380f, -0.07503317f, 0.02924545f, 0.04273447f, -0.06172011f, 0.01545045f, 0.03864792f, 
    0.02915821f, -0.06652600f, 0.02366197f, -0.03134470f, 0.00839950f, -0.03968735f, 0.00648940f, 0.01814624f, 
    -0.06139689f, -0.05966352f, -0.01703568f, -0.03289013f, -0.04166523f, 0.02478461f, -0.04084930f, 0.00068271f, 
    0.04303346f, 0.01434433f, 0.03440060f, -0.06980427f, -0.00458460f, -0.03267696f, -0.03496252f, -0.00290948f, 
    -0.05376428f, 0.04425172f, 0.04021442f, 0.01943325f, -0.00736315f, -0.01052517f, -0.02117656f, 0.04919951f, 
    0.05278343f, -0.05811950f, 0.03538042f, 0.02288844f, -0.00411942f, -0.00032465f, -0.03408047f, -0.02881292f, 
    0.00264912f, 0.02324043f, -0.04307570f, 0.00877398f, -0.02653378f, 0.03325563f, 0.03001233f, 0.03847775f, 
    0.35223049f, 0.14074232f, 0.15526055f, -0.12458516f, -0.19570559f, -0.11367843f, -0.02098075f, 0.02540328f, 
    0.10295103f, -0.05367225f, -0.02410482f, -0.05327195f, -0.03757192f, 0.02582492f, 0.04705627f, 0.09349789f, 
    0.05859900f, 0.05126891f, -0.70345736f, -0.20608869f, -0.17558827f, 0.28085530f, 0.10090428f, -0.07816821f, 
    -0.01434592f, 0.01850935f, 0.01704747f, -0.05633288f, 0.06114084f, -0.02879333f, -0.07506897f, -0.06991117f, 
    0.08184034f, 0.18201151f, 0.05827362f, 0.12394407f, -0.20487921f, -0.15846302f, 0.05696460f, 0.15846451f, 
    0.10498220f, -0.10569698f, 0.13009718f, -0.07773864f, -0.02098480f, -0.30376777f, -0.16522908f, -0.37349543f, 
    0.08870661f, -0.06793179f, -0.04635593f, 0.13574594f, 0.10396254f, -0.04638609f, -0.23974596f, 0.02432338f, 
    -0.16033551f, 0.13564034f, 0.10692488f, 0.03601373f, -0.09028374f, -0.04614132f, -0.08874948f, 0.08258060f, 
    0.17857751f, 0.02592122f, 0.10852716f, -0.41199589f, 0.10230831f, 0.00041681f, 0.07667468f, -0.00056546f, 
    -0.13540646f, -0.00569960f, 0.03696235f, -0.04465791f, 0.09778214f, 0.11911245f, 0.18010509f, 0.00517887f, 
    -0.04827652f, -0.11263212f, 0.20390743f, -0.16188160f, 0.11367700f, 0.04085436f, 0.10929458f, -0.02762769f, 
    -0.01640238f, -0.12085026f, -0.27304891f, 0.04870068f, -0.24983054f, 0.23782007f, 0.00967237f, 0.13272399f, 
    -0.03505406f, 0.08425627f, -0.00299877f, -0.05120687f, -0.11673462f, 0.00028184f, -0.04973533f, -0.18822517f, 
    0.11579587f, 0.09033212f, 0.03935203f, 0.13707417f, -0.03611118f, 0.06705255f, 0.05813751f, 0.03157173f, 
    0.07482579f, 0.12700680f, 0.05276000f, -0.12893158f, 0.15905479f, 0.21938907f, -0.03526378f, -0.04151845f, 
    -0.26087359f, -0.20928881f, 0.08964097f, 0.02801036f, -0.12765716f, 0.00218945f, -0.10978273f, -0.28393313f, 
    0.05339916f, 0.00008469f, 0.16107515f, -0.15163966f, -0.01118149f, -0.08511506f, 0.11352859f, 0.26155680f, 
    0.14990842f, -0.01972142f, -0.21651962f, -0.12354182f, -0.14489156f, 0.08885168f, 0.13688146f, 0.00739048f, 
    -0.25392383f, 0.02405709f, -0.07485120f, 0.11676542f, 0.13653828f, 0.20238128f, -0.03397649f, -0.08592916f, 
    -0.01656742f, 0.10506366f, -0.06922746f, 0.03065429f, -0.11164576f, 0.13426697f, -0.09015078f, 0.16036956f, 
    -0.04784064f, 0.02828560f, 0.21411222f, 0.05787586f, -0.29016885f, -0.11892752f, -0.08350670f, 0.02723116f, 
    0.07167806f, 0.04635228f, 0.18865192f, -0.18717477f, 0.09764568f, 0.04236701f, -0.01190437f, -0.08397427f, 
    -0.05908274f, 0.08789454f, 0.05299964f, 0.09732972f, 0.04123080f, 0.01177044f, -0.05786600f, -0.04608581f, 
    0.11301097f, 0.14958394f, 0.09459267f, 0.17390844f, 0.02867669f, -0.27299190f, -0.14116153f, -0.36420527f, 
    0.01710104f, -0.05293863f, 0.27474624f, 0.11993106f, 0.04713088f, 0.10763378f, -0.20487900f, -0.27114716f, 
    -0.17652600f, 0.13598712f, -0.04527372f, 0.12478565f, 0.12407573f, -0.02161673f, 0.03737463f, 0.17489561f, 
    -0.15549961f, 0.04392743f, 0.08945614f, 0.08855454f, 0.12768693f, -0.03407894f, -0.11805098f, 0.20865384f, 
    -0.05372000f, 0.12778671f, -0.00694917f, 0.06049281f, -0.19177707f, -0.00376806f, -0.08896315f, -0.04587447f, 
    -0.01354993f, -0.09588005f, -0.22501096f, 0.24758875f, -0.09577005f, -0.00964579f, 0.11034326f, 0.02465500f, 
    0.05608832f, -0.00958220f, -0.03870835f, 0.06658468f, 0.15028489f, -0.10113356f, -0.04548384f, -0.09273557f, 
    0.00083835f, -0.17119792f, 0.02033431f, -0.15142806f, 0.14594966f, 0.10260556f, -0.07201138f, -0.04092373f, 
    -0.10625405f, -0.03767308f, 0.08393215f, 0.09783472f, -0.07017172f, 0.04284400f, 0.14273274f, 0.09377369f, 
    0.14735438f, 0.12807052f, -0.04606520f, 0.04175415f, 0.06545453f, 0.27252123f, 0.00625499f, 0.03048904f, 
    -0.01520939f, -0.04566053f, -0.08632828f, 0.04330811f, -0.21563911f, -0.07454705f, -0.10655582f, 0.10392132f, 
    0.29375395f, 0.15211023f, 0.04035611f, 0.01498284f, 0.00769584f, -0.14087416f, 0.08527395f, 0.28923425f, 
    0.12315275f, 0.16868693f, -0.21140280f, 0.02730204f, -0.13759497f, 0.08480102f, 0.06535431f, -0.04632826f, 
    0.07932849f, -0.22875792f, -0.12071403f, -0.04286769f, 0.13499944f, 0.09146915f, -0.13863076f, 0.10711907f, 
    0.23086902f, 0.08269159f, -0.02463168f, 0.03643307f, -0.13008241f, -0.02841640f, 0.19038367f, -0.00467509f, 
    0.08556584f, -0.07496904f, -0.26696983f, 0.06834335f, 0.16982071f, 0.03318531f, 0.00735153f, -0.02562818f, 
    0.00602686f, 0.07510594f, 0.03294759f, 0.03652346f, 0.07469855f, 0.03983740f, -0.13901259f, -0.04074445f, 
    0.05844653f, 0.11879021f, -0.00800112f, 0.09799930f, 0.00346954f, 0.03747900f, -0.03785910f, -0.24182265f, 
    -0.11014602f, 0.02820672f, 0.05393219f, 0.13704525f, 0.02673192f, 0.11450041f, 0.28885972f, 0.15173300f, 
    -0.06760951f, 0.15577160f, -0.03762668f, 0.02305015f, 0.02586484f, 0.05293424f, 0.20787494f, 0.11732347f, 
    -0.01000814f, 0.03556345f, -0.00328550f, -0.07686237f, 0.07753102f, 0.11127521f, -0.02020934f, -0.07464074f, 
    -0.07812599f, -0.37660655f, 0.16030368f, 0.01563511f, -0.10512415f, 0.01369618f, -0.21936581f, 0.21891201f, 
    0.08195230f, 0.05720551f, -0.04969369f, -0.05456291f, -0.05002013f, 0.07100523f, -0.10895664f, 0.01278327f, 
    0.06519105f, 0.00077093f, -0.18776377f, -0.04148158f, 0.11343659f, 0.15300387f, -0.06283653f, 0.04418095f, 
    -0.09637300f, 0.03401711f, 0.08891869f, 0.15426280f, -0.05840037f, -0.04503933f, 0.14629591f, -0.02588686f, 
    0.05718805f, 0.00383359f, -0.08252656f, 0.17699681f, -0.08452466f, 0.03797898f, -0.00704203f, 0.09233557f, 
    -0.11125775f, 0.09695806f, 0.07092793f, -0.02861775f, -0.01745121f, 0.20367542f, -0.01987701f, -0.05015377f, 
    -0.04431065f, 0.05020998f, -0.09086208f, 0.11033121f, -0.11126500f, 0.00566466f, -0.20639253f, -0.31994739f, 
    -0.09613271f, -0.06215704f, -0.21792561f, 0.00269260f, 0.00024637f, 0.11020072f, -0.06302688f, -0.04881454f, 
    0.19417784f, -0.09305225f, 0.03883414f, 0.00606342f, 0.04699264f, 0.16511184f, -0.12046641f, 0.01525384f, 
    -0.14167964f, -0.22567125f, -0.11666970f, 0.02010742f, 0.04212080f, 0.02854074f, 0.08258243f, 0.26539469f, 
    0.14549501f, 0.20458384f, 0.15466534f, -0.10303114f, -0.14557056f, 0.03136034f, 0.09333285f, 0.14501971f, 
    -0.01962830f, 0.04388042f, -0.00527816f, 0.13841660f, -0.09105192f, 0.15170698f, -0.02361917f, -0.29098642f, 
    -0.17778595f, 0.15751147f, 0.21816881f, -0.31655684f, -0.16859004f, 0.07723999f, 0.02387960f, 0.18326962f, 
    -0.06302989f, 0.02876038f, 0.07887174f, 0.02026176f, 0.02941387f, 0.05081533f, -0.08507692f, 0.05802793f, 
    0.05108562f, -0.04620580f, 0.08267110f, 0.10939515f, 0.05070228f, 0.02973313f, -0.12113041f, -0.02490356f, 
    0.24134441f, -0.12838112f, 0.05499173f, -0.04384838f, -0.02692462f, 0.16777478f, 0.06847845f, -0.04454783f, 
    0.01624280f, -0.03213164f, -0.06836689f, 0.06902165f, 0.05303182f, 0.08430045f, -0.15263848f, 0.15709519f, 
    -0.01801447f, -0.15838732f, -0.13826673f, 0.06811284f, 0.05648949f, 0.03101269f, -0.01524785f, -0.19664384f, 
    -0.03855423f, 0.03221706f, 0.05668124f, 0.17778131f, -0.00300016f, -0.08993271f, 0.06254347f, 0.02669654f, 
    0.09072176f, -0.13639918f, 0.03295216f, 0.12392155f, 0.04734273f, -0.25754669f, 0.04044561f, -0.04034276f, 
    0.02377683f, -0.32771575f, -0.05204159f, 0.16825132f, -0.00413932f, -0.01080753f, 0.20813189f, -0.10591573f, 
    0.13455941f, -0.04828471f, -0.26568532f, -0.24384481f, -0.14368786f, 0.06638816f, 0.02257306f, -0.30900016f, 
    0.12561566f, 0.04848634f, -0.03914547f, -0.17678133f, -0.25203240f, -0.04832238f, 0.16417882f, -0.18397829f, 
    0.08876449f, 0.05068759f, 0.00242672f, -0.01370592f, 0.09148710f, 0.05802754f, 0.02646538f, 0.19497125f, 
    0.05015733f, -0.07756446f, -0.04634575f, 0.06133679f, 0.01872513f, -0.16135827f, -0.05774719f, -0.11436824f, 
    0.09728129f, 0.10159914f, -0.15886992f, -0.07601071f, 0.09256716f, -0.23270237f, -0.04200700f, 0.07292963f, 
    0.15256035f, -0.02532974f, 0.01308363f, -0.03920163f, -0.19129585f, -0.03391275f, -0.21818535f, 0.22263882f, 
    -0.01823141f, 0.11477695f, -0.04952793f, -0.06245155f, 0.05557127f, -0.16334470f, 0.05710332f, 0.06255091f, 
    -0.12225839f, 0.23723350f, 0.39075762f, -0.02325294f, 0.09807760f, 0.02332175f, -0.13462466f, -0.02478183f, 
    0.13699259f, 0.08119525f, 0.07343661f, 0.11432335f, -0.15038490f, -0.09555136f, -0.18260540f, 0.12406239f, 
    -0.03727072f, 0.29679346f, 0.17460489f, 0.13353662f, -0.04992014f, -0.08109920f, -0.21246076f, -0.19425823f, 
    0.16602741f, -0.21152854f, -0.02337191f, -0.19775851f, 0.00779243f, 0.00213269f, -0.03519742f, -0.30649439f, 
    -0.11192250f, 0.12983954f, 0.03870362f, 0.27914655f, 0.05395362f, 0.00349098f, -0.11072948f, -0.08866511f, 
    -0.01788782f, -0.12465892f, 0.03875343f, 0.07217331f, -0.05622957f, 0.28181866f, -0.18135929f, -0.33248773f, 
    -0.16936944f, -0.14946468f, -0.01426256f, 0.00222561f, 0.07835778f, -0.13129833f, 0.11435568f, 0.21833268f, 
    0.06067764f, -0.01819365f, 0.00423304f, -0.13382494f, -0.06392688f, 0.02649523f, -0.03547169f, 0.02567798f, 
    -0.15730403f, 0.45752254f, -0.04120520f, 0.07089152f, 0.05866189f, -0.09896523f, -0.06586335f, 0.08401343f, 
    0.08650980f, 0.18290284f, 0.05605951f, -0.10695214f, -0.20954745f, -0.15500966f, 0.06348199f, -0.03788782f, 
    0.09408333f, 0.26300889f, -0.09639049f, -0.20681876f, -0.04040614f, -0.05660522f, 0.02644560f, 0.13112457f, 
    0.03228221f, 0.24121051f, 0.10239172f, 0.03442691f, -0.27541173f, -0.06413361f, -0.00161251f, 0.01619218f, 
    0.08363245f, 0.06953014f, -0.04201217f, 0.22898674f, 0.16030967f, -0.13059543f, -0.09922333f, 0.00980775f, 
    0.08674508f, 0.27807784f, -0.04385057f, -0.08667099f, 0.05103466f, -0.05216223f, 0.02794332f, -0.09614442f, 
    0.06336752f, -0.02748139f, 0.09905636f, 0.03967435f, 0.06377677f, -0.27474657f, -0.09318371f, 0.18969400f, 
    0.07954700f, -0.08178831f, -0.15632239f, -0.02768104f, -0.01448296f, -0.09392373f, -0.17147766f, -0.10215978f, 
    0.00616982f, -0.12662037f, -0.20452243f, -0.20228341f, 0.10073215f, 0.01043787f, -0.04006490f, -0.07034139f, 
    0.09797171f, 0.14721397f, 0.03299399f, 0.11232852f, -0.04219986f, 0.24292125f, 0.00415870f, 0.18743069f, 
    0.08016887f, -0.00685411f, 0.22777669f, -0.05780914f, -0.05881682f, -0.07841773f, -0.12010778f, -0.05703370f, 
    0.12389125f, 0.14286058f, 0.04684785f, -0.08203931f, 0.04705669f, -0.16106372f, -0.04768462f, 0.03644458f, 
    0.02980457f, 0.11935209f, -0.23778455f, -0.04852553f, 0.22898638f, -0.02493025f, -0.10271263f, -0.03132411f, 
    -0.08140644f, -0.02047082f, 0.18882674f, 0.06899680f, 0.16266584f, 0.07293469f, 0.01724934f, 0.05781419f, 
    0.06580377f, 0.26372930f, 0.25112548f, 0.22498983f, 0.13315308f, 0.15938225f, -0.51330841f, 0.07500316f, 
    0.12276586f, -0.16108420f, 0.20829599f, 0.06561009f, 0.19916855f, -0.04661967f, 0.02305390f, -0.21946661f, 
    0.07475537f, -0.09029238f, 0.00174888f, -0.04625010f, 0.00600287f, 0.02730535f, -0.08732495f, -0.01512629f, 
    -0.13611239f, -0.03383873f, -0.18431208f, -0.16118889f, -0.07656510f, 0.00760865f, 0.06462400f, 0.22205164f, 
    0.10850330f, 0.27510202f, 0.01305205f, 0.08969728f, -0.00721155f, 0.02987689f, -0.13500239f, 0.08910400f, 
    0.02287307f, -0.03882468f, 0.55764830f, 0.01864009f, 0.01032181f, -0.00211049f, 0.01739127f, -0.11708295f, 
    0.15706599f, 0.00728591f, 0.16280140f, 0.35486853f, 0.08807914f, 0.16953535f, 0.00555543f, 0.01036912f, 
    -0.03150090f, 0.17181365f, -0.04542097f, 0.05118138f, 0.22612785f, -0.11979116f, 0.08823292f, -0.03013342f, 
    0.08726984f, -0.05055964f, -0.03465960f, 0.19334541f, -0.18481041f, 0.22444952f, 0.00342944f, 0.08107294f, 
    0.12012349f, 0.06227496f, -0.03457050f, 0.16545194f, 0.22714511f, 0.02339881f, 0.07279847f, 0.13104835f, 
    0.08527067f, 0.11220894f, 0.11509857f, -0.09692838f, -0.06989636f, -0.04786338f, 0.08863828f, -0.18259068f, 
    -0.05090449f, -0.03332616f, -0.09435980f, 0.09680936f, 0.15235449f, 0.02267695f, 0.05345568f, -0.08849491f, 
    0.46246561f, 0.03460560f, 0.18429999f, -0.13588572f, 0.06651191f, -0.00481648f, -0.18325961f, -0.14107046f, 
    -0.05651511f, 0.13945916f, 0.18264817f, -0.01539273f, 0.16562037f, -0.20545208f, -0.19706215f, 0.00982831f, 
    0.03345980f, 0.05460626f, -0.13471517f, -0.09418228f, -0.06162437f, 0.11012206f, -0.13735516f, -0.28879675f, 
    -0.21141626f, -0.09280147f, -0.17194586f, -0.05265319f, 0.15509684f, 0.12081195f, 0.14521022f, 0.10129685f, 
    -0.15868238f, 0.01575327f, 0.12320228f, -0.27219227f, 0.19358991f, -0.09041476f, 0.01790051f, 0.06352070f, 
    0.11589949f, 0.01196903f, -0.06656831f, 0.10260234f, -0.13523842f, -0.21029714f, 0.01337605f, -0.06494100f, 
    0.01426129f, -0.07378815f, -0.28999308f, 0.04840551f, 0.02229669f, -0.17856000f, -0.07781611f, 0.14413057f, 
    -0.05768324f, 0.11317961f, -0.08309658f, -0.22052220f, -0.21985511f, 0.01940675f, -0.29732952f, 0.15008071f, 
    -0.00842979f, -0.00890436f, 0.07717466f, -0.11761515f, -0.09577218f, -0.02032779f, -0.21481365f, -0.21003409f, 
    0.00992762f, 0.09936455f, -0.06428325f, 0.16066557f, 0.14813218f, -0.01492952f, -0.02167648f, -0.07419612f, 
    -0.00723218f, -0.25411108f, 0.06167173f, 0.00484534f, 0.18155532f, 0.03125996f, 0.00955183f, 0.00344908f, 
    -0.06563155f, -0.21562621f, 0.08615358f, 0.06812935f, 0.11345993f, 0.16727461f, 0.09431085f, -0.12216689f, 
    0.00838709f, -0.01568780f, 0.05892580f, -0.03365111f, -0.03207143f, 0.14895926f, 0.02357556f, 0.08231574f, 
    0.07723045f, 0.09192237f, 0.07455513f, -0.10476913f, 0.13984522f, 0.03281478f, 0.08009922f, -0.05677564f, 
    -0.06326012f, -0.07709529f, 0.11701742f, 0.05658207f, 0.01789416f, -0.01845779f, -0.03758964f, 0.01722545f, 
    -0.01354846f, -0.09000932f, 0.05309708f, -0.15651129f, -0.06982846f, 0.09188229f, 0.13600527f, 0.16497351f, 
    0.10153150f, -0.07194094f, 0.11116910f, 0.05464209f, 0.02694225f, -0.06283580f, 0.16895431f, 0.10047382f, 
    0.09314562f, 0.14344974f, 0.07714463f, -0.00451128f, -0.10431898f, -0.01286594f, 0.25835261f, 0.04385397f, 
    -0.14874791f, 0.11914494f, -0.03468800f, -0.08927573f, 0.32257104f, 0.02624675f, 0.15990739f, -0.05555910f, 
    -0.01020291f, 0.10452525f, 0.12055563f, -0.16310179f, -0.03502087f, -0.13265863f, -0.21183380f, -0.27251720f, 
    -0.18982571f, -0.12300631f, 0.09196530f, 0.00931559f, 0.01957490f, 0.12154260f, 0.00320198f, 0.01668452f, 
    0.01145109f, 0.15221925f, -0.02173637f, 0.00662112f, 0.16125017f, 0.20202608f, 0.05780266f, -0.17527568f, 
    0.12157413f, 0.15311991f, -0.09239032f, 0.14042509f, -0.05968472f, 0.06382464f, -0.16268410f, -0.07452181f, 
    -0.00626187f, -0.05509879f, -0.00810378f, -0.00788278f, -0.06457004f, 0.01396020f, -0.01409680f, -0.09946750f, 
    0.01281885f, -0.09408872f, -0.06358860f, -0.28531989f, -0.10460129f, 0.11344172f, 0.07055146f, -0.00667162f, 
    -0.02005780f, 0.15671706f, -0.11830954f, 0.09188993f, 0.07162912f, 0.04066174f, -0.19942406f, -0.13955513f, 
    0.07502174f, -0.01111375f, -0.02916030f, -0.10376263f, -0.05725566f, -0.02133269f, -0.04794625f, -0.11276665f, 
    0.06096558f, -0.00413126f, -0.13137671f, -0.07358097f, -0.11257285f, 0.00077158f, -0.36074799f, 0.00260382f, 
    -0.04880076f, 0.19354191f, -0.16770326f, -0.09144825f, -0.12273486f, 0.14526097f, -0.17245393f, -0.08074343f, 
    0.07927521f, -0.01789495f, -0.03087041f, -0.00459806f, 0.15991361f, 0.03821402f, 0.10475347f, -0.02521121f, 
    -0.13677086f, 0.18885577f, -0.07723947f, -0.09041991f, 0.12762454f, 0.06133032f, -0.01967069f, 0.00053246f, 
    -0.20376009f, 0.06837484f, -0.07323627f, -0.19106910f, -0.05665553f, 0.09920772f, 0.11308917f, 0.01736716f, 
    0.18835740f, 0.14400803f, -0.02017883f, 0.10644997f, 0.12378818f, -0.15138699f, 0.22477657f, 0.13599175f, 
    0.06975897f, -0.03790264f, 0.12388258f, -0.01495112f, -0.02362025f, -0.10985159f, -0.10665934f, 0.16381684f, 
    0.05751143f, 0.10432030f, 0.08878101f, 0.05743786f, 0.06171657f, 0.09481791f, 0.07194640f, 0.14129248f, 
    0.01470708f, -0.04425510f, 0.01942911f, 0.19137408f, 0.14007233f, 0.19578986f, 0.09306056f, -0.01008014f, 
    0.20899297f, -0.08487528f, 0.09790614f, -0.11009391f, 0.08359922f, -0.05049448f, 0.03437369f, 0.01672117f, 
    0.08442227f, 0.01220562f, 0.08726085f, -0.01140232f, 0.14858732f, 0.01952896f, -0.05259657f, 0.08758013f, 
    0.03546031f, 0.03925974f, -0.01878474f, 0.01877812f, -0.06431562f, 0.01401769f, 0.03343061f, -0.00430663f, 
    -0.00347857f, -0.01754326f, -0.05939422f, -0.04602796f, 0.04438162f, 0.03651832f, 0.00327807f, 0.00765058f, 
    -0.05255264f, 0.00855448f, 0.01808901f, -0.04716696f, -0.01376663f, 0.04039219f, -0.05880434f, -0.01878897f, 
    -0.02893614f, -0.02296262f, 0.02730092f, 0.00463347f, 0.01858645f, 0.03120346f, -0.00470944f, -0.01374722f, 
    0.03834844f, -0.05246020f, -0.06812424f, 0.01360361f, 0.05186282f, 0.00440236f, 0.01297705f, -0.06087773f, 
    0.03666667f, -0.03692242f, -0.01295271f, -0.01590910f, 0.01253793f, -0.01359040f, 0.04152491f, -0.03511649f, 
    0.05001355f, -0.02631063f, 0.01822780f, -0.05240741f, 0.02184607f, 0.03154032f, 0.01536342f, 0.00438268f, 
    -0.02586088f, -0.02973531f, 0.00703699f, 0.02342265f, -0.03264037f, -0.04300024f, 0.04902432f, -0.00177599f, 
    -0.02211111f, -0.06510506f, -0.00840844f, 0.03446525f, -0.04641549f, -0.02759236f, 0.01458754f, -0.05493636f, 
    -0.05270760f, -0.04432607f, 0.01274553f, -0.02663825f, -0.05442368f, -0.03798408f, -0.06150828f, 0.00551133f, 
    0.00730768f, -0.06209579f, 0.01096878f, -0.04387189f, -0.03919070f, 0.03508930f, 0.00863692f, -0.05277935f, 
    0.01527852f, -0.06154133f, -0.01684993f, -0.01016116f, -0.04475446f, 0.00473875f, 0.03565051f, -0.01195562f, 
    0.01110980f, 0.04546985f, -0.04402754f, 0.02649727f, -0.00500427f, 0.04935626f, 0.02560228f, 0.03105588f, 
    0.03117634f, -0.01650256f, -0.01705980f, -0.03786348f, 0.02747622f, 0.04055456f, -0.02376980f, 0.03391705f, 
    0.03627971f, -0.00399830f, -0.03472950f, -0.03909748f, -0.03088115f, 0.00755058f, -0.03404260f, -0.01705187f, 
    -0.04950901f, -0.01398679f, 0.05041311f, 0.05435641f, -0.02934263f, -0.05138646f, 0.00446709f, 0.00865855f, 
    0.01954686f, 0.02787405f, -0.02890871f, 0.00193505f, 0.00887434f, 0.05001780f, -0.04028033f, -0.04448160f, 
    -0.06555167f, 0.01339590f, 0.03122312f, -0.03843537f, -0.06416345f, -0.01956433f, 0.02392617f, -0.03991860f, 
    0.01505548f, -0.02062693f, -0.04157018f, -0.03863679f, -0.04039476f, -0.00042007f, -0.03764079f, -0.01237989f, 
    0.02869914f, 0.04984507f, -0.05739482f, 0.04062054f, -0.00029810f, 0.01644692f, 0.02143354f, 0.04117439f, 
    0.05171105f, -0.00521388f, 0.03602635f, 0.01374142f, -0.03946103f, 0.04776727f, 0.03924976f, -0.00760560f, 
    -0.03699251f, 0.00267200f, -0.03687991f, 0.00128417f, 0.02551995f, -0.04138290f, 0.02090973f, 0.02958803f, 
    0.04305308f, 0.03520847f, -0.04270306f, 0.03700331f, -0.03311158f, 0.00138266f, -0.00217438f, -0.05039991f, 
    0.00495398f, -0.04172778f, 0.01348532f, -0.06295633f, 0.04023629f, -0.01668875f, 0.03941713f, -0.02113115f, 
    -0.05158559f, 0.00973006f, -0.01894437f, 0.03423387f, -0.01163531f, 0.03710038f, 0.04141747f, 0.05646486f, 
    -0.04734959f, -0.05201703f, 0.02938614f, 0.02666461f, -0.04416244f, -0.02350399f, 0.01289542f, 0.00843658f, 
    0.01218992f, -0.03630141f, -0.00798793f, -0.03795581f, 0.03088590f, 0.03417644f, 0.01858394f, -0.02010975f, 
    -0.04280267f, -0.00624376f, -0.00876587f, 0.00143355f, 0.03179974f, -0.02473082f, 0.01689134f, -0.02794194f, 
    0.04548360f, 0.01078033f, 0.03460981f, -0.06376043f, -0.06481904f, -0.04924572f, -0.04590958f, 0.03398918f, 
    -0.01548167f, 0.03820923f, -0.02870259f, -0.04896582f, 0.01285177f, -0.02236887f, 0.01238581f, -0.01803329f, 
    -0.05754258f, -0.05683640f, 0.00943903f, -0.03027272f, -0.00601368f, -0.02621110f, 0.00722857f, -0.02658053f, 
    0.03138666f, -0.02741542f, -0.01352636f, 0.03918861f, -0.01357934f, -0.01536984f, -0.05399741f, -0.04765564f, 
    -0.03077750f, 0.01523175f, 0.00585151f, 0.00379802f, -0.02482581f, 0.01339444f, -0.02699088f, -0.00881460f, 
    0.00098511f, 0.00294723f, -0.00286803f, 0.02534281f, 0.00428974f, -0.01074320f, -0.04445367f, -0.01163330f, 
    -0.02515160f, 0.00605143f, -0.00547308f, -0.05702064f, -0.05134060f, 0.04918287f, 0.04532891f, -0.05992810f, 
    -0.02234919f, -0.05078023f, -0.06709708f, 0.00590739f, 0.03075954f, -0.01873803f, -0.02793619f, 0.00301013f, 
    0.16340378f, 0.19723909f, 0.05081103f, 0.05544626f, -0.26809162f, -0.15898131f, 0.15397587f, 0.12842344f, 
    0.00704071f, 0.24051429f, -0.09060846f, -0.03230953f, 0.06824905f, -0.05642445f, 0.04336694f, 0.00889504f, 
    0.03943753f, 0.00526159f, -0.55908668f, -0.44632506f, -0.27422991f, 0.04278219f, -0.04629389f, -0.09635177f, 
    0.11068922f, -0.00608958f, 0.03153245f, 0.14904757f, 0.09314685f, -0.17503798f, -0.06135314f, 0.13103314f, 
    -0.10032634f, -0.05051332f, 0.13387035f, 0.04661515f, 0.17037567f, 0.02792035f, 0.22409579f, 0.03600421f, 
    0.07058895f, 0.01071712f, 0.00556005f, 0.02458947f, 0.16205183f, -0.04564128f, -0.21798168f, -0.06443284f, 
    -0.07361898f, 0.03638445f, 0.15123533f, 0.17679742f, 0.10156807f, 0.11624442f, 0.19028069f, -0.41347489f, 
    -0.08327024f, 0.10621039f, 0.26955974f, -0.00114414f, 0.01312457f, -0.12550695f, -0.00138463f, -0.06632251f, 
    -0.24575070f, -0.21219626f, -0.05565200f, -0.01012727f, -0.06427004f, -0.01555509f, 0.02334226f, 0.04859267f, 
    0.16327401f, -0.25302413f, 0.05169109f, 0.26497588f, 0.08246216f, -0.10772843f, 0.09258829f, -0.01022929f, 
    0.05275757f, -0.13817297f, -0.01798379f, 0.04052418f, 0.00518047f, -0.06742540f, 0.07167230f, -0.00258561f, 
    0.00894376f, 0.03000196f, -0.20522188f, -0.05783422f, -0.02045504f, 0.07283827f, 0.04075402f, 0.16809057f, 
    0.11206587f, 0.15076059f, 0.02244516f, -0.44000629f, -0.23622674f, -0.45185295f, -0.08003047f, -0.02162271f, 
    0.12117961f, 0.18417646f, -0.20144822f, -0.12463414f, 0.09321254f, 0.01675207f, 0.02391069f, -0.00826867f, 
    0.07131550f, 0.05879011f, 0.10993430f, -0.14395146f, -0.05870645f, -0.56692821f, -0.23776381f, 0.22946845f, 
    -0.07635789f, -0.12620056f, -0.18982106f, 0.13718770f, 0.14588027f, 0.06307993f, -0.11664107f, -0.36747798f, 
    0.04414812f, -0.01748607f, 0.01128819f, -0.03334872f, 0.21220492f, -0.02721551f, 0.09555829f, -0.09099018f, 
    -0.13649990f, 0.11333778f, -0.16276599f, -0.05204940f, 0.07313845f, -0.04999094f, -0.05991298f, 0.05044640f, 
    0.02381727f, -0.39374638f, -0.02916051f, 0.08530894f, 0.14522351f, 0.04328918f, 0.05014578f, -0.04709810f, 
    -0.07354294f, 0.12030575f, 0.00217461f, 0.22525750f, -0.25592101f, -0.15687187f, -0.14810196f, 0.22057052f, 
    0.12639681f, 0.04951162f, -0.15486029f, -0.12900777f, 0.57085580f, 0.24565166f, -0.00824530f, -0.04074168f, 
    -0.00191221f, 0.04548170f, 0.14667495f, -0.01184844f, -0.10998626f, -0.15823638f, -0.00132648f, 0.06870069f, 
    0.07641756f, 0.05563860f, 0.01889090f, 0.18738897f, -0.33952218f, -0.14339067f, -0.05947970f, -0.00935088f, 
    -0.10636760f, -0.05733399f, 0.02658382f, 0.06510274f, 0.18313168f, 0.14354070f, 0.10058474f, 0.22146994f, 
    -0.01610627f, 0.14887166f, -0.01766976f, 0.00699803f, 0.11291231f, 0.02440238f, 0.14276545f, 0.10867701f, 
    0.16578335f, 0.03418493f, 0.09588354f, 0.04086868f, 0.07671969f, 0.20881915f, 0.10676268f, -0.45025373f, 
    0.05616350f, -0.06817912f, 0.14049505f, 0.05282400f, -0.29690012f, 0.06803422f, -0.10536022f, 0.16814965f, 
    0.17317656f, -0.42301074f, -0.40025607f, -0.06524861f, -0.06260248f, -0.05351065f, 0.11540736f, 0.06462539f, 
    0.09415624f, 0.10462809f, 0.22171639f, -0.23266643f, -0.12319031f, -0.37713376f, 0.00047039f, 0.04538883f, 
    -0.06438502f, 0.06410418f, 0.27551156f, 0.02935174f, -0.25690955f, 0.14422591f, 0.05413287f, 0.03146364f, 
    -0.10798886f, -0.16490492f, -0.09340031f, -0.28129128f, -0.50884020f, -0.73150587f, -0.31426904f, -0.03778837f, 
    -0.05695834f, 0.05899047f, 0.11192823f, 0.02088576f, 0.26576778f, -0.14686619f, -0.31474036f, 0.21181458f, 
    0.08257770f, 0.18324526f, 0.01766599f, -0.07416836f, -0.12500623f, 0.08630212f, -0.08956895f, 0.11589930f, 
    0.14568336f, 0.09807765f, -0.06454253f, -0.12248827f, 0.00761537f, 0.06889104f, 0.24314223f, 0.26334134f, 
    -0.07312109f, -0.15208665f, -0.04887838f, 0.11827844f, 0.02805844f, -0.10244922f, -0.03930668f, -0.14390738f, 
    0.21178710f, 0.20092727f, -0.10323244f, -0.05722978f, -0.15085025f, 0.07193781f, -0.05587803f, 0.00842122f, 
    -0.29522407f, -0.01687946f, 0.31419554f, -0.03191755f, -0.00641695f, 0.10182395f, -0.05664671f, 0.05167567f, 
    0.23030990f, 0.07601181f, -0.21514162f, 0.08836906f, -0.06937608f, -0.03906301f, 0.13600516f, 0.16077752f, 
    0.11562032f, -0.11100176f, -0.01633139f, -0.13067101f, -0.11175984f, -0.15206693f, -0.22799695f, -0.12422027f, 
    0.16094558f, -0.02828532f, -0.04978802f, -0.03166198f, 0.02200790f, 0.01284559f, -0.00808387f, -0.01825877f, 
    0.08149666f, -0.04393351f, -0.11924595f, 0.05014441f, -0.06469192f, 0.00210811f, -0.08949142f, -0.01780186f, 
    0.14037897f, -0.01648366f, 0.11562756f, -0.01285838f, -0.07388541f, 0.09151701f, -0.20974492f, -0.18133883f, 
    0.00303217f, 0.13439198f, 0.01710711f, -0.05520664f, -0.06133088f, 0.07130322f, 0.09247150f, -0.12135945f, 
    0.03784645f, 0.02555113f, -0.02681638f, 0.11357158f, -0.03044267f, 0.02948702f, -0.11781573f, -0.05414900f, 
    0.07458676f, 0.09174561f, -0.11561323f, 0.04295859f, -0.09427358f, -0.05068971f, -0.01062108f, -0.01454211f, 
    0.24397135f, -0.02531199f, 0.08644406f, -0.05367586f, -0.00152531f, -0.06999693f, -0.02347834f, 0.02620568f, 
    -0.22766992f, 0.06014560f, -0.22543608f, -0.01694683f, -0.11865769f, -0.04677780f, -0.12331523f, 0.03094388f, 
    0.04704018f, 0.01598792f, 0.00757461f, -0.01742419f, -0.06587252f, -0.11849614f, 0.09147667f, 0.10612766f, 
    0.09507984f, 0.04961202f, -0.06525520f, -0.36254793f, -0.03659946f, -0.11667699f, -0.11702805f, 0.03722385f, 
    -0.12196470f, 0.19129154f, 0.15422690f, 0.05199354f, 0.11194580f, -0.12564422f, -0.00543178f, 0.07583600f, 
    0.04387062f, 0.07960036f, -0.00306698f, 0.04378398f, 0.05007619f, -0.18566459f, 0.06179249f, 0.14510310f, 
    0.13357857f, 0.10993251f, -0.16191909f, 0.12501448f, 0.07184492f, 0.07052193f, -0.12917101f, -0.08617039f, 
    0.05893907f, -0.04292812f, -0.12182425f, 0.13257350f, -0.03217067f, 0.15507197f, -0.14192800f, -0.05421107f, 
    0.18160252f, -0.18234320f, 0.01761633f, 0.16077042f, 0.02713474f, 0.00044286f, 0.15141134f, 0.19601284f, 
    -0.00523928f, 0.00066318f, 0.20787960f, -0.10775176f, -0.00627021f, 0.17007935f, 0.01813628f, 0.12266100f, 
    -0.08682322f, -0.03514964f, 0.09488709f, 0.13572475f, 0.06717955f, 0.10570041f, 0.03348977f, -0.02795743f, 
    -0.04488809f, -0.02409818f, -0.15932353f, -0.12294807f, 0.24801755f, 0.13926202f, 0.06955536f, 0.18014531f, 
    0.03748684f, 0.12332655f, 0.21145155f, -0.00570756f, 0.19926956f, 0.02992996f, 0.04193762f, 0.15174438f, 
    0.11716209f, 0.07548410f, 0.09081519f, 0.09708747f, -0.06709234f, 0.06321324f, 0.03791981f, -0.14396906f, 
    0.02928897f, -0.09488411f, 0.18436423f, -0.11824265f, 0.08096746f, 0.04569171f, 0.00285092f, 0.00505309f, 
    0.05383762f, -0.00240019f, -0.06930261f, 0.08506574f, 0.14065503f, -0.03700370f, -0.03230026f, -0.03468335f, 
    -0.20081459f, -0.00937520f, 0.08759221f, 0.04026274f, 0.06204190f, 0.02644139f, -0.08898221f, -0.06737486f, 
    0.14887540f, 0.20676598f, -0.04387752f, 0.16004983f, -0.15522890f, -0.02370765f, 0.00731119f, 0.16653855f, 
    -0.03640143f, 0.03290585f, 0.24651469f, 0.07004685f, -0.16671948f, -0.10347366f, 0.04790848f, -0.01684835f, 
    0.01033682f, -0.15322322f, 0.04491299f, 0.11985393f, -0.15496199f, 0.06099641f, 0.04088949f, -0.09420718f, 
    0.09405546f, 0.06743412f, -0.12877619f, -0.10746194f, -0.15854041f, -0.04913931f, -0.19553387f, -0.32630190f, 
    -0.05309624f, -0.28029260f, -0.06447931f, -0.05431346f, -0.06411683f, 0.22369675f, 0.04690615f, -0.02061651f, 
    -0.03478619f, -0.06664979f, 0.02608441f, -0.07617658f, 0.18073802f, -0.09114742f, -0.06444984f, 0.01866137f, 
    -0.08791650f, -0.05977871f, -0.05562023f, 0.04379310f, -0.02514881f, -0.04133173f, 0.04110101f, 0.03027427f, 
    0.05670232f, -0.00061414f, -0.21188390f, -0.02518527f, 0.10845363f, -0.02992935f, 0.13376644f, 0.10693299f, 
    0.04927554f, -0.05314529f, 0.06834037f, -0.18702468f, -0.10876402f, -0.28737929f, 0.09610743f, -0.16592842f, 
    0.03874136f, 0.20705315f, -0.19621576f, -0.07194112f, -0.10604654f, -0.11208674f, -0.05737911f, 0.13544811f, 
    -0.08286840f, 0.07441328f, -0.13517533f, -0.10295200f, -0.00203007f, 0.09008824f, 0.00808679f, -0.11354057f, 
    -0.38229093f, 0.02528012f, -0.06117876f, -0.36834624f, 0.02190316f, 0.08170156f, -0.01362059f, 0.13811636f, 
    0.04182562f, -0.03980425f, 0.14705175f, 0.00435590f, 0.01192029f, 0.02649075f, -0.11672438f, 0.08994915f, 
    0.04692537f, 0.05029060f, 0.09395542f, -0.01317490f, -0.07878404f, -0.12746663f, -0.01055117f, -0.00049995f, 
    0.14279199f, -0.02925397f, -0.13320595f, 0.00079611f, -0.03043827f, -0.08359870f, -0.13954911f, 0.00043673f, 
    0.03468815f, 0.00560908f, -0.16784176f, -0.00081688f, -0.03790843f, -0.01188750f, -0.21928544f, -0.01006114f, 
    -0.03765792f, 0.13921192f, -0.10975067f, -0.22085756f, -0.03692309f, -0.05814128f, -0.26112217f, 0.13546631f, 
    0.00600699f, 0.12234767f, 0.02661685f, -0.01493869f, 0.13316718f, 0.23250659f, -0.17840241f, -0.14713612f, 
    -0.07075676f, 0.09817843f, 0.08934986f, 0.04591877f, 0.11218724f, 0.01322596f, 0.05939473f, 0.14824913f, 
    -0.28667560f, -0.15069617f, -0.20615828f, -0.10490410f, 0.11420456f, -0.08723085f, -0.02022843f, 0.02174179f, 
    -0.07336394f, -0.04749454f, -0.09868069f, -0.08436904f, 0.09930227f, -0.02255225f, -0.02565770f, 0.17520589f, 
    -0.04406966f, 0.17497762f, 0.11678626f, -0.04080097f, -0.03617791f, 0.02349525f, -0.02171367f, 0.01177797f, 
    0.02981170f, 0.00539126f, 0.01917203f, 0.03516171f, -0.00518147f, 0.13791563f, 0.01339754f, 0.11217476f, 
    0.01939128f, 0.01070206f, 0.14681569f, -0.23174673f, -0.03643097f, 0.09138129f, 0.01087591f, 0.20531081f, 
    0.10013800f, -0.14900531f, -0.02118155f, 0.22741243f, 0.07086049f, -0.20114331f, -0.09719541f, 0.14577384f, 
    0.02451939f, -0.04160922f, 0.02300431f, -0.07037823f, 0.09099040f, -0.00708317f, 0.11225277f, -0.06045431f, 
    -0.03176225f, -0.03349560f, -0.06144177f, -0.23433688f, 0.07390103f, 0.10560919f, 0.17134999f, -0.09493617f, 
    -0.05046875f, 0.04269933f, 0.10197265f, 0.12114552f, -0.08767632f, -0.27544451f, -0.06528291f, -0.08187453f, 
    -0.04931209f, 0.00384522f, 0.03401877f, 0.01578017f, 0.07589970f, -0.02725943f, 0.06379828f, 0.07810204f, 
    -0.05611638f, -0.10159650f, 0.07153641f, -0.16074920f, 0.15379487f, 0.17056693f, 0.05712068f, -0.06513280f, 
    0.06365152f, -0.02979191f, -0.41105729f, -0.11584831f, 0.01970506f, 0.09791379f, 0.06525854f, -0.18980740f, 
    -0.06929804f, -0.15604977f, 0.02717509f, 0.00287661f, -0.07380398f, 0.14389957f, 0.01874397f, 0.08226196f, 
    -0.00454420f, -0.24559434f, -0.02120498f, -0.24646182f, 0.11805481f, -0.00836390f, -0.18914072f, 0.02069436f, 
    0.14401712f, -0.18703657f, 0.19959275f, 0.02945728f, 0.09113750f, 0.13670273f, -0.20495115f, -0.17635892f, 
    -0.04998653f, 0.07287551f, -0.01911822f, -0.10976288f, 0.12179604f, -0.03227438f, 0.02431511f, -0.07823662f, 
    -0.15301701f, -0.10335177f, -0.11794117f, 0.09692910f, -0.18529861f, 0.08909938f, -0.11137336f, 0.01837498f, 
    0.15444249f, 0.07304120f, -0.08475157f, -0.17773628f, -0.01894738f, 0.08376291f, 0.08005095f, 0.06991802f, 
    -0.13356113f, -0.05716702f, 0.03753987f, 0.02765613f, 0.12190424f, 0.08635999f, 0.05180083f, 0.08192546f, 
    0.07130139f, 0.10148716f, -0.03262557f, 0.02014013f, 0.07244597f, -0.05933778f, 0.07829387f, -0.01308366f, 
    -0.00909940f, 0.19612142f, -0.10858691f, -0.11914504f, -0.08906890f, 0.20664825f, 0.15478353f, 0.02347276f, 
    0.07025360f, 0.13085474f, 0.14311504f, -0.07259734f, -0.06560922f, -0.16142914f, 0.25333044f, 0.05482427f, 
    0.15390487f, -0.03672133f, 0.14896999f, 0.07356642f, -0.06751989f, -0.07877621f, 0.02071137f, 0.01044943f, 
    0.00081328f, 0.03702928f, 0.13434628f, 0.07523169f, 0.22036609f, 0.08981454f, 0.13255993f, 0.07918703f, 
    0.04120132f, 0.05819488f, -0.12451018f, 0.17289302f, 0.12633216f, 0.06930552f, 0.01534482f, 0.09166475f, 
    0.05549492f, 0.07967925f, -0.16646673f, 0.06861884f, 0.08403385f, 0.02438994f, 0.10405575f, -0.01036684f, 
    0.07979094f, -0.11909153f, -0.05584394f, 0.05137129f, 0.09061358f, 0.04290424f, -0.05206567f, 0.00874593f, 
    -0.25703621f, -0.20377596f, -0.11191085f, -0.21482852f, 0.03213971f, 0.05438208f, -0.01134252f, -0.24655896f, 
    -0.04614917f, 0.21779421f, 0.02064647f, -0.08174430f, -0.15468669f, 0.04479133f, -0.10874631f, -0.05112448f, 
    0.17404349f, -0.20335628f, 0.14486372f, -0.12484074f, 0.11964851f, 0.06191303f, 0.03973398f, -0.15179642f, 
    0.09922102f, 0.10791647f, 0.30883554f, 0.16735160f, 0.08589380f, -0.07120211f, -0.15438651f, -0.01735905f, 
    -0.09141620f, 0.08091111f, -0.00166541f, -0.19262157f, 0.11030998f, 0.02121873f, -0.03703151f, -0.05575671f, 
    0.01411594f, 0.09054769f, -0.14580353f, 0.07241074f, 0.10148506f, 0.23093505f, 0.05351659f, 0.28771296f, 
    -0.03155555f, 0.16911452f, 0.02921607f, -0.10475162f, 0.06452596f, -0.07959644f, 0.32511073f, 0.08555239f, 
    0.12285858f, 0.05603182f, 0.08925138f, 0.02881592f, 0.02987103f, 0.06162721f, 0.19621423f, -0.24511701f, 
    -0.11717129f, 0.17108661f, -0.16603065f, -0.01174931f, 0.04096781f, -0.02474264f, -0.01752041f, 0.01023537f, 
    0.13333693f, 0.02431451f, -0.02098452f, -0.23401172f, -0.10034655f, 0.00089130f, -0.09233966f, -0.03559557f, 
    -0.03883988f, 0.17521395f, -0.16192746f, 0.16795011f, -0.01953647f, 0.00541257f, 0.03742658f, 0.19611748f, 
    0.12240286f, 0.13728628f, 0.26890758f, -0.10477129f, 0.26410547f, 0.02814755f, 0.11635268f, -0.03111165f, 
    -0.00886065f, 0.19213668f, 0.05129708f, 0.03968117f, -0.24089041f, -0.38576651f, 0.28121719f, 0.02489934f, 
    -0.04333260f, -0.01106851f, 0.05354035f, -0.09957355f, 0.03198203f, 0.05236545f, -0.07938727f, -0.05671586f, 
    -0.02711597f, 0.04468653f, -0.01804712f, 0.08103845f, -0.00974673f, -0.15015331f, -0.06282400f, -0.35030937f, 
    -0.03235421f, -0.07639084f, -0.18933941f, -0.08135948f, -0.12662210f, -0.01140537f, 0.11150124f, 0.18935972f, 
    -0.05218210f, -0.15231536f, -0.00834873f, -0.17825162f, 0.09354246f, -0.01204817f, -0.02314273f, -0.21224269f, 
    -0.28282556f, -0.32613644f, 0.10655784f, -0.02620683f, 0.28928056f, 0.04445050f, -0.12721494f, 0.02093561f, 
    0.34773138f, 0.17485332f, -0.11527488f, 0.09256687f, 0.07643447f, 0.10682984f, 0.14294793f, -0.03582435f, 
    0.17219155f, 0.08002481f, 0.09747181f, -0.12741524f, -0.23855364f, -0.03076336f, -0.01490953f, -0.06138336f, 
    -0.07738731f, -0.04060589f, 0.01703033f, -0.22517410f, -0.13963148f, -0.09063318f, -0.11930706f, 0.08535526f, 
    0.14492224f, -0.13937956f, -0.00949018f, -0.10344008f, 0.06304171f, -0.03111841f, 0.06038215f, -0.03305577f, 
    0.22848950f, 0.03859657f, 0.02212160f, -0.02814982f, 0.04892108f, 0.16103783f, -0.05395934f, 0.19167691f, 
    -0.17933235f, -0.06715512f, 0.05163805f, 0.16236255f, -0.04344480f, 0.28890398f, -0.17503928f, 0.13150418f, 
    -0.06036653f, 0.05736522f, 0.01347765f, 0.02317100f, -0.04337282f, 0.01623054f, 0.19690181f, -0.13426894f, 
    0.05719723f, -0.04336391f, -0.06796006f, -0.02268072f, -0.23038185f, -0.04714353f, 0.06434445f, -0.42151439f, 
    -0.13906935f, -0.22791563f, 0.08534994f, 0.01969885f, -0.19130251f, -0.06782291f, 0.01283341f, -0.11422361f, 
    -0.07583819f, 0.17027943f, 0.06128044f, -0.01803152f, 0.05690915f, -0.04937572f, 0.00043397f, -0.08864353f, 
    0.09542544f, -0.30545700f, 0.07326684f, -0.37717089f, 0.15628131f, 0.29419926f, 0.04031809f, 0.12290560f, 
    -0.06697514f, 0.05266088f, -0.13399653f, -0.16912378f, -0.08723526f, -0.02052635f, 0.02900702f, -0.09438851f, 
    0.04153685f, 0.08933772f, -0.05613797f, -0.22198364f, -0.54927695f, -0.21118274f, -0.20060997f, -0.12026693f, 
    0.09896967f, -0.04950324f, -0.05982162f, 0.07733301f, 0.24509758f, 0.21115315f, 0.07052813f, 0.00119859f, 
    0.08119608f, 0.06363316f, -0.10261387f, -0.00029901f, 0.06058312f, 0.00001876f, 0.01872793f, 0.02571447f, 
    -0.00395384f, 0.13358092f, 0.06402908f, 0.01652038f, 0.16826725f, -0.04623231f, -0.16228661f, 0.02879452f, 
    -0.04210129f, 0.06628798f, 0.02888521f, 0.08413572f, 0.10273674f, 0.12237573f, 0.03854306f, -0.02794635f, 
    -0.19312643f, 0.27900970f, -0.03140553f, -0.23923226f, -0.15393089f, -0.01657789f, -0.14403749f, -0.02166186f, 
    -0.05587346f, -0.05494720f, 0.02578529f, -0.02708670f, 0.00131075f, -0.01535209f, -0.02913339f, 0.05342773f, 
    0.04220498f, 0.05173129f, -0.02052123f, -0.04992947f, 0.03208769f, -0.04332391f, 0.04940293f, 0.00414386f, 
    0.01598088f, 0.00003374f, -0.01842046f, -0.02802924f, 0.03034070f, -0.00241533f, 0.03214975f, -0.03688819f, 
    -0.04681568f, -0.05432991f, -0.04672474f, 0.01803731f, -0.04881844f, -0.03107360f, 0.02677291f, 0.04248007f, 
    -0.05157488f, 0.01480658f, -0.00403117f, -0.00284304f, -0.05840624f, -0.00740218f, -0.03486141f, -0.06110383f, 
    0.00723091f, -0.01667275f, -0.00815431f, 0.02081291f, -0.00531059f, 0.04768341f, -0.03288245f, -0.02290364f, 
    -0.02392425f, 0.01950709f, 0.03117866f, 0.04934755f, 0.03478088f, -0.03733895f, 0.03118348f, -0.06381877f, 
    0.02941123f, -0.06320985f, 0.04209569f, 0.05116357f, -0.04957237f, -0.02261605f, -0.02383178f, -0.01798332f, 
    -0.01907748f, 0.00470673f, -0.05328701f, 0.03358028f, -0.01109736f, -0.03589878f, -0.02255437f, 0.00804995f, 
    0.04489358f, -0.03921955f, 0.05016375f, 0.01100525f, -0.02807932f, -0.00450224f, 0.03928073f, -0.00281823f, 
    0.00289979f, -0.04900215f, -0.06115713f, 0.01331750f, -0.02336226f, 0.00872154f, 0.03889697f, -0.04763970f, 
    -0.06127672f, 0.01968469f, 0.02781413f, 0.00827373f, 0.02019532f, 0.00280748f, 0.02115213f, -0.04700028f, 
    -0.02496334f, 0.03158941f, -0.00217871f, -0.05723614f, -0.01593545f, 0.03759962f, 0.04868905f, -0.06427964f, 
    -0.02865201f, -0.02321470f, 0.04013485f, -0.02601659f, -0.01978784f, -0.03683136f, 0.00869205f, -0.05148768f, 
    0.01669519f, 0.02005939f, -0.05880873f, 0.03553872f, -0.01418828f, 0.05282104f, -0.02531653f, -0.02676510f, 
    0.03761286f, 0.00516862f, -0.03251395f, 0.00620505f, 0.03234895f, -0.00728367f, 0.01841245f, -0.04375451f, 
    -0.04399891f, -0.04098614f, 0.05203060f, -0.02985115f, -0.00547038f, 0.01315168f, 0.00842991f, 0.04688986f, 
    -0.02092717f, -0.00819494f, 0.00481121f, 0.00799395f, 0.01659288f, -0.03478048f, -0.03048595f, 0.01472099f, 
    0.04034073f, 0.02735096f, 0.02705653f, 0.04654223f, 0.03316400f, -0.00245739f, -0.03244755f, 0.00557655f, 
    0.01333720f, -0.05576123f, -0.05648170f, 0.01579910f, -0.02209327f, 0.04868498f, 0.04032563f, -0.03225693f, 
    -0.03490239f, 0.04081796f, -0.02971202f, -0.04595591f, -0.03599477f, 0.05529094f, 0.05851448f, 0.05007261f, 
    0.04277169f, -0.05474422f, 0.02204166f, -0.03729280f, -0.00816141f, 0.01784820f, 0.05871556f, -0.05142202f, 
    -0.03204801f, 0.01829004f, -0.03279572f, -0.00136424f, 0.00170952f, -0.02088453f, -0.04508117f, -0.05483717f, 
    0.01275790f, -0.00986758f, -0.01924568f, -0.05570688f, -0.06127574f, 0.00051945f, -0.06043443f, -0.00150742f, 
    0.02286354f, 0.00935463f, 0.05091643f, -0.01748908f, -0.00868452f, -0.00738513f, -0.01966641f, -0.00625957f, 
    0.00043917f, -0.01564483f, -0.01922925f, 0.00645193f, -0.00945053f, -0.04004188f, 0.04889301f, 0.05627925f, 
    0.00551331f, 0.00195106f, -0.04734429f, -0.04144940f, -0.04684360f, -0.04215140f, -0.05722712f, -0.03030944f, 
    -0.05745339f, -0.02525490f, -0.02603522f, -0.05752615f, 0.02698429f, -0.01370494f, 0.05601286f, -0.02955805f, 
    -0.01691562f, -0.00468825f, 0.05696961f, 0.05749666f, 0.03481168f, -0.03185511f, 0.00915423f, -0.00049133f, 
    -0.06136742f, -0.02251166f, 0.00277548f, -0.03435314f, -0.03225178f, -0.04200073f, 0.05165022f, -0.00131809f, 
    0.00035934f, 0.03580883f, -0.03612695f, -0.03680672f, -0.05170884f, 0.01029710f, -0.00092148f, 0.02014141f, 
    -0.01081300f, -0.02275039f, 0.03075869f, 0.05863572f, -0.04867421f, -0.00438023f, -0.06253181f, -0.01985241f, 
    0.02271213f, -0.03088481f, -0.02493677f, -0.02282379f, -0.02812345f, -0.04911797f, 0.00808621f, 0.04208197f, 
    -0.04907569f, -0.04338980f, -0.01078643f, -0.02523627f, -0.02005848f, 0.03741935f, -0.00609177f, -0.00855734f, 
    0.05245658f, -0.00137403f, 0.03091355f, -0.02700878f, 0.03234440f, -0.01156778f, -0.04742723f, -0.05144448f, 
    -0.04407693f, -0.03327725f, -0.05027270f, -0.04685613f, -0.05336699f, 0.03695369f, -0.03597429f, 0.03228765f, 
    0.13470198f, -0.08851758f, 0.05179542f, 0.05815962f, -0.00822506f, -0.05662880f, 0.04136462f, -0.00358555f, 
    -0.11859481f, -0.09491712f, -0.01916198f, 0.08121489f, 0.02356233f, 0.05730789f, 0.07901645f, -0.07152417f, 
    0.11027528f, -0.12916601f, -0.27938956f, -0.20490469f, 0.05678490f, 0.08871273f, -0.03043404f, 0.13664754f, 
    0.23832621f, 0.01728072f, -0.00315838f, 0.02638833f, -0.17766976f, -0.06058004f, 0.00417919f, 0.01984829f, 
    -0.04843393f, 0.04764375f, 0.10806261f, 0.06945448f, 0.18200855f, -0.18423928f, 0.36225516f, 0.09086730f, 
    -0.06628542f, -0.13790417f, 0.00622564f, -0.13380598f, -0.00847871f, -0.35401627f, -0.14048882f, 0.18099083f, 
    0.02014392f, -0.19522622f, -0.11237485f, -0.06440826f, -0.05304550f, 0.08217447f, -0.24696191f, -0.26508263f, 
    -0.02041316f, -0.18676110f, -0.16675679f, -0.04840668f, -0.00393020f, 0.09333310f, 0.01077302f, -0.02962314f, 
    0.25275552f, 0.01763851f, -0.05252216f, 0.06579238f, -0.04491113f, -0.22099070f, 0.04476603f, 0.17347118f, 
    -0.30074859f, -0.32989445f, 0.38327661f, 0.19515148f, 0.07552202f, 0.06378487f, 0.07129966f, 0.06015923f, 
    0.07956754f, -0.13451247f, 0.07542116f, 0.15800659f, -0.00634007f, 0.13810576f, -0.04722158f, -0.09312506f, 
    0.10250354f, 0.04075744f, -0.22442403f, -0.05797058f, 0.00968375f, 0.07231663f, 0.00392800f, -0.01236717f, 
    0.11539219f, 0.09493268f, 0.06346410f, 0.13957341f, -0.20979826f, 0.15444864f, 0.01169283f, -0.00050583f, 
    0.01489641f, -0.19367781f, 0.07445697f, -0.07533067f, -0.13789086f, -0.30787888f, -0.14313906f, -0.07097562f, 
    -0.16586149f, 0.18869294f, -0.05220799f, 0.13188428f, -0.03244364f, 0.43712512f, 0.40209413f, 0.25957817f, 
    0.04297076f, 0.09240530f, 0.13772473f, 0.02792762f, -0.04560609f, -0.06427801f, -0.13286564f, -0.13961129f, 
    0.03417885f, -0.00487246f, -0.00115034f, -0.12810034f, 0.13181287f, 0.09796141f, 0.03126359f, 0.30431545f, 
    0.06342894f, 0.07739269f, 0.08705886f, -0.00712867f, 0.07095894f, 0.12809663f, -0.00456973f, -0.06378365f, 
    -0.10415686f, -0.34550726f, -0.30170032f, -0.11454035f, -0.07662052f, -0.10528539f, -0.05321402f, 0.04903751f, 
    -0.08236032f, 0.21837789f, -0.30283248f, 0.17103508f, -0.07726467f, -0.08164128f, -0.11826523f, -0.16014291f, 
    -0.00611764f, 0.02715867f, 0.37383762f, 0.01976110f, 0.00721412f, -0.03316968f, 0.19913624f, 0.05302737f, 
    0.00333629f, 0.00488603f, -0.12901221f, 0.14424928f, 0.09778647f, -0.00121245f, 0.00277392f, -0.06597304f, 
    0.01599214f, 0.16463897f, -0.04293724f, -0.07511856f, 0.07918625f, -0.25140268f, 0.12177435f, -0.00590974f, 
    0.00278616f, 0.03771606f, -0.14917123f, 0.03177512f, 0.12610045f, -0.12735860f, -0.01692958f, -0.28654855f, 
    0.00833100f, -0.13733763f, -0.10646666f, -0.08761682f, 0.01946406f, -0.03712526f, 0.05691913f, -0.16747288f, 
    0.13206565f, 0.10000846f, -0.04533257f, -0.22915287f, -0.02604284f, -0.04311092f, -0.03812304f, -0.04913045f, 
    0.13543269f, 0.13502213f, -0.12601462f, -0.01277052f, 0.20482755f, 0.02312394f, 0.01814917f, 0.05976328f, 
    -0.11212274f, 0.17157236f, 0.00459260f, -0.13367832f, 0.13346606f, -0.06810947f, -0.01603374f, 0.03462792f, 
    0.17639248f, 0.23555239f, -0.07815235f, 0.04131790f, 0.10895962f, -0.01952780f, -0.00343327f, 0.06494660f, 
    -0.11488049f, -0.01209453f, -0.06136835f, 0.10539485f, 0.25614908f, -0.06820831f, -0.00794223f, -0.06869836f, 
    0.15631734f, -0.02047943f, 0.23069894f, 0.09075562f, 0.29658145f, 0.02616716f, -0.02586947f, 0.09397600f, 
    -0.02936020f, -0.02271309f, -0.04759515f, -0.01580427f, -0.17755474f, -0.04928398f, 0.07640477f, -0.03320883f, 
    -0.07015612f, 0.03771158f, -0.00068818f, 0.07576445f, 0.11923593f, 0.02626179f, 0.03064081f, 0.10320628f, 
    -0.04394797f, 0.03958697f, 0.02088323f, 0.12180778f, 0.05139561f, 0.15504794f, -0.05630135f, -0.15482764f, 
    -0.08659967f, 0.05863830f, 0.04144066f, -0.01329319f, 0.15019222f, -0.00842233f, 0.08313182f, -0.06734493f, 
    -0.04351936f, 0.15268892f, -0.04920498f, 0.12928469f, 0.18734033f, -0.06029526f, -0.00774879f, -0.16501306f, 
    -0.12663420f, 0.14137003f, -0.06422191f, 0.15175334f, 0.07984407f, -0.26266193f, 0.06154080f, 0.04227790f, 
    0.02390639f, 0.01390672f, -0.06939058f, -0.20715000f, 0.05313455f, 0.02921552f, 0.02105320f, -0.07517248f, 
    0.20892061f, -0.00969789f, 0.07206410f, -0.20717412f, 0.00388658f, 0.06882817f, 0.16983303f, 0.11372615f, 
    0.25154194f, -0.20399363f, 0.20107225f, 0.08007682f, -0.16362381f, -0.06066708f, 0.00674769f, -0.02588263f, 
    -0.15834193f, 0.05238789f, 0.06013166f, 0.03905147f, -0.12732473f, -0.12923890f, -0.03749265f, 0.11475038f, 
    -0.19827093f, -0.12002713f, -0.00481814f, -0.07922056f, -0.14414378f, -0.17251398f, -0.14141285f, -0.06696200f, 
    0.11876912f, -0.17321330f, -0.02258446f, -0.00180940f, -0.02130531f, 0.07823623f, -0.09727702f, -0.17578836f, 
    -0.10365310f, -0.05492114f, -0.03214866f, -0.02722357f, -0.15316316f, 0.04684893f, 0.11921408f, -0.27074537f, 
    0.13834824f, 0.03344633f, 0.03786878f, -0.04869898f, 0.13381985f, -0.00477443f, -0.08532043f, -0.17485842f, 
    -0.35122710f, -0.30091783f, -0.03073331f, -0.00421836f, 0.14981371f, -0.08887803f, -0.08756991f, 0.07234847f, 
    0.02074396f, 0.16590853f, 0.07402355f, 0.05064551f, 0.04389562f, 0.16326366f, -0.01691864f, -0.06169653f, 
    0.01687237f, 0.01140485f, 0.10789826f, -0.18456660f, -0.02327218f, 0.10962814f, 0.15958197f, -0.13900818f, 
    0.10420881f, -0.00131580f, 0.18273476f, 0.23753834f, 0.09842046f, 0.17383218f, 0.17415799f, 0.03190194f, 
    -0.00824372f, -0.26120871f, 0.19443385f, -0.04352693f, -0.16187909f, 0.00603266f, -0.23581247f, 0.05338859f, 
    -0.06203969f, 0.21436824f, 0.02537866f, 0.10902801f, 0.02171960f, 0.13010350f, 0.16767652f, 0.32559675f, 
    -0.10081960f, 0.11722724f, 0.04843821f, 0.10075469f, -0.15321817f, 0.00971491f, 0.07193590f, -0.10244454f, 
    -0.09477866f, -0.16676137f, 0.00989726f, 0.11048175f, 0.22223210f, 0.09756577f, 0.10481615f, 0.09157530f, 
    0.06801683f, 0.09532160f, 0.14897916f, 0.04487812f, 0.06229690f, 0.11494619f, -0.10290965f, 0.02251635f, 
    -0.26738080f, -0.18650568f, -0.19904135f, -0.02504910f, 0.07258156f, -0.14607011f, -0.16332959f, -0.03420037f, 
    0.01264301f, -0.08282163f, -0.16418253f, -0.01496930f, -0.11785541f, 0.06310024f, -0.02639039f, -0.20484805f, 
    0.05660795f, -0.14588627f, -0.05080397f, -0.00344827f, 0.02885453f, -0.01819973f, 0.09562640f, -0.08861704f, 
    0.10046845f, 0.01003998f, -0.02199887f, -0.00641118f, 0.09630930f, 0.11301984f, 0.07580813f, 0.08387626f, 
    0.02791063f, 0.04395631f, -0.14879514f, -0.16393815f, -0.04599006f, -0.07186099f, 0.41447306f, -0.00474135f, 
    0.04875651f, 0.13631390f, -0.30838865f, 0.12171612f, -0.04210315f, 0.18402120f, -0.24492875f, -0.29287320f, 
    0.02934061f, 0.04139697f, -0.22755745f, -0.17744744f, -0.08500158f, 0.08713641f, -0.04191501f, -0.21400595f, 
    -0.17984939f, 0.03020566f, -0.11870556f, -0.22120431f, 0.03015230f, -0.27132365f, -0.15894561f, 0.06736793f, 
    0.25301316f, 0.30544946f, -0.04677678f, 0.00586335f, 0.14122356f, 0.11411594f, -0.04728080f, -0.07538363f, 
    -0.28929436f, 0.10360602f, -0.02709012f, 0.00912880f, 0.19545856f, 0.13357900f, -0.14520864f, -0.02749936f, 
    -0.13340060f, 0.20794299f, -0.07953132f, 0.21908151f, 0.10901981f, 0.07615829f, 0.01537651f, 0.10781564f, 
    -0.05116489f, 0.11491264f, 0.08357094f, 0.06841989f, 0.29491556f, -0.25604966f, -0.06067908f, 0.00034111f, 
    -0.05563328f, -0.08546012f, -0.10258858f, 0.01088517f, 0.22560710f, -0.03836524f, 0.15641251f, 0.14605081f, 
    0.07275887f, 0.06446449f, -0.08706103f, -0.27125219f, 0.08435491f, 0.08309565f, 0.15547051f, 0.05406909f, 
    0.00921333f, 0.10341398f, -0.22727902f, 0.00472524f, 0.16839489f, 0.10567110f, -0.05198000f, 0.11016768f, 
    -0.12056688f, -0.02781693f, 0.01909365f, -0.19237010f, -0.03241605f, 0.00059558f, 0.02444082f, -0.14732920f, 
    0.02697303f, -0.05590997f, 0.17419654f, 0.11516964f, 0.18200716f, -0.16231140f, -0.10878795f, -0.06898414f, 
    0.13748080f, -0.08243567f, 0.09205459f, 0.05669907f, -0.03160365f, 0.02597681f, 0.24680303f, -0.05294569f, 
    0.03171501f, -0.02333462f, -0.04212693f, 0.02036711f, -0.02593724f, 0.02791222f, -0.00273334f, 0.01202350f, 
    -0.00329750f, 0.02099209f, -0.04162067f, -0.05842666f, -0.04260239f, 0.04666018f, 0.04033292f, -0.06814042f, 
    -0.04859493f, -0.01996692f, 0.02589220f, 0.01778618f, -0.01577945f, 0.02629255f, -0.03760654f, -0.02620702f, 
    0.03300375f, -0.02483300f, -0.05828232f, 0.00058956f, 0.02891152f, -0.01856676f, -0.06742009f, 0.03462710f, 
    0.02123985f, -0.04679555f, -0.05885201f, 0.02708324f, -0.06522666f, 0.02762441f, -0.03914165f, 0.00757863f, 
    -0.02401226f, -0.02033453f, 0.04087906f, -0.02683629f, 0.04121976f, -0.01076554f, 0.03524534f, -0.02105808f, 
    -0.02339871f, -0.03901609f, 0.02391712f, -0.04517083f, -0.04949001f, -0.03233770f, -0.00448238f, 0.00904542f, 
    -0.01429867f, -0.06841072f, -0.03702266f, -0.04079177f, 0.01637080f, 0.02500433f, 0.03496268f, -0.04317131f, 
    0.04043263f, -0.04600706f, 0.01749387f, -0.01277767f, 0.01577423f, 0.04724638f, 0.04114188f, -0.05323782f, 
    0.03894513f, -0.00378728f, -0.02564460f, 0.00835113f, 0.00034445f, -0.03792904f, 0.04515247f, 0.00764976f, 
    0.00706271f, 0.00366293f, -0.00562036f, 0.02627014f, -0.04836334f, -0.02841946f, -0.02883603f, 0.03098278f, 
    -0.05918677f, -0.00573871f, -0.03225755f, -0.01852498f, -0.01912805f, -0.03814537f, -0.00717097f, 0.01834297f, 
    -0.03313956f, 0.00444034f, -0.00572198f, -0.05000847f, -0.06445172f, 0.00575972f, 0.04519473f, -0.01854835f, 
    -0.06235420f, -0.04672179f, 0.03568096f, 0.03785084f, 0.04717018f, -0.02868330f, -0.00192892f, 0.00730591f, 
    -0.02074869f, -0.05601920f, 0.04305721f, 0.03096565f, -0.00963687f, -0.00363486f, -0.02020418f, 0.04085017f, 
    -0.03249458f, -0.00989229f, 0.00647612f, -0.03462999f, -0.00980313f, 0.00729770f, 0.02730713f, 0.02387618f, 
    0.00729059f, -0.01979982f, -0.04438237f, -0.04277300f, -0.06350406f, -0.00515175f, 0.01810456f, -0.01863326f, 
    0.01559599f, -0.05294435f, 0.03946427f, 0.00108955f, -0.03025794f, 0.04534786f, -0.06847472f, 0.02579354f, 
    0.01882904f, 0.00386965f, -0.01280738f, -0.00752944f, -0.02760949f, -0.05354263f, -0.02203190f, -0.00120299f, 
    -0.01585446f, -0.02474193f, 0.04600778f, -0.00490773f, -0.01829519f, -0.03592209f, -0.04460990f, 0.00017447f, 
    -0.04156971f, 0.00357224f, -0.01050213f, 0.00716435f, -0.02353419f, -0.02858694f, 0.00952472f, 0.01873824f, 
    0.04469301f, 0.00487251f, -0.04721139f, -0.05631373f, -0.00754014f, 0.04516730f, -0.02596105f, -0.04277322f, 
    -0.05739033f, -0.04721029f, 0.01856045f, -0.04233345f, 0.02553747f, -0.04512781f, 0.00277751f, -0.01885572f, 
    -0.00854224f, 0.04687397f, -0.02371370f, -0.00885418f, -0.02939180f, 0.01834424f, -0.05842086f, 0.03445560f, 
    -0.00353534f, 0.01157414f, -0.01165008f, -0.06543377f, -0.06044139f, -0.06280467f, 0.02299120f, -0.06587966f, 
    0.00896683f, 0.04131241f, -0.00097394f, 0.01534902f, 0.03377022f, 0.03238070f, -0.00851540f, -0.05768239f, 
    0.01905472f, -0.01876468f, -0.06855136f, -0.01833475f, -0.01777287f, -0.00557147f, -0.03612691f, 0.00714885f, 
    -0.00615358f, -0.00701463f, 0.04260132f, -0.01517677f, -0.04356993f, -0.01359194f, 0.00771089f, -0.02155130f, 
    -0.02189520f, 0.01924528f, 0.01285622f, -0.00571351f, 0.03938675f, -0.02945857f, 0.01298888f, -0.00497115f, 
    -0.00739417f, -0.07013329f, 0.03124760f, -0.02747460f, 0.04219940f, -0.05151726f, -0.01535198f, 0.00928361f, 
    0.01343997f, -0.04829441f, -0.03729723f, -0.02083873f, -0.02787197f, -0.06924357f, 0.04953219f, 0.01631551f, 
    0.01347022f, 0.02356765f, -0.03915982f, -0.01285723f, -0.05029884f, -0.00460981f, -0.06227909f, -0.00096929f, 
    -0.05836541f, -0.06821969f, 0.01454376f, 0.00442603f, 0.01897461f, -0.04569760f, -0.04837637f, -0.03304479f, 
    -0.05195117f, 0.01814127f, -0.05281920f, -0.01003217f, -0.05635658f, -0.00654867f, -0.03188371f, 0.02197759f, 
    0.01568278f, 0.04857411f, -0.00777397f, -0.00738367f, -0.01493752f, -0.03749099f, -0.01093117f, -0.01725594f, 
    0.02168801f, -0.04892764f, 0.01213988f, -0.00795058f, 0.03380155f, -0.06632559f, -0.05596052f, -0.00671297f, 
    -0.01556943f, -0.03534662f, -0.02196597f, 0.00699972f, -0.05189714f, -0.01388205f, -0.05801771f, -0.02724645f, 
    -0.05902172f, -0.08465292f, 0.05462558f, -0.02784809f, -0.01259684f, -0.00594618f, -0.00904310f, -0.04990490f, 
    -0.05264962f, -0.06020350f, 0.00987241f, -0.06242871f, 0.00345019f, -0.01715940f, -0.03952325f, -0.06169434f, 
    0.04987764f, 0.00087822f, 0.02050107f, -0.02867088f, -0.01484087f, 0.05365901f, -0.05356354f, -0.03658774f, 
    -0.07952176f, -0.01224616f, -0.08193590f, -0.05650785f, -0.05361289f, 0.01529684f, -0.03199821f, -0.05075322f, 
    -0.03712466f, -0.05270521f, -0.00247327f, 0.01396693f, -0.02720439f, -0.03429560f, -0.02570870f, 0.01591614f, 
    -0.05834038f, -0.09268801f, -0.00419444f, -0.00670251f, 0.00995188f, -0.07039705f, -0.04036176f, -0.02940235f, 
    -0.08223261f, -0.04465026f, 0.00875594f, -0.00646032f, 0.00307449f, -0.02543751f, -0.00483745f, -0.01393384f, 
    -0.01281452f, -0.05065768f, -0.05179780f, -0.01411895f, -0.00402517f, 0.00183038f, -0.01822542f, 0.02051923f, 
    0.04929121f, 0.05000395f, 0.02297794f, 0.00576061f, -0.03643424f, -0.04902872f, -0.05632415f, -0.06933548f, 
    -0.04485284f, -0.03074913f, -0.07403963f, -0.08328434f, 0.02403778f, -0.00345214f, 0.01064714f, -0.07681707f, 
    0.04243597f, -0.00923026f, -0.03907265f, -0.01482973f, -0.08361942f, 0.00498546f, -0.08366065f, 0.02596615f, 
    -0.07076015f, 0.01376360f, -0.05324987f, -0.02391891f, -0.07281956f, 0.00893887f, 0.02078256f, -0.00537979f, 
    -0.06944914f, -0.02447141f, -0.08390873f, 0.00567045f, 0.01178399f, -0.04180385f, 0.02156079f, -0.00545493f, 
    -0.06268961f, -0.03675305f, -0.00959231f, 0.02214572f, -0.07402537f, -0.03623429f, -0.05438631f, -0.05960296f, 
    -0.00279609f, 0.03211502f, -0.05924529f, 0.02697726f, 0.02841922f, 0.01831942f, -0.02270142f, -0.00388435f, 
    -0.05163710f, -0.07202102f, -0.06402566f, -0.08000933f, -0.03659662f, -0.03858291f, -0.04141643f, -0.04092392f, 
    -0.02088761f, -0.01371945f, -0.05136150f, -0.02097560f, -0.00698975f, -0.06153543f, 0.01573983f, -0.01125156f, 
    -0.02123745f, 0.02958278f, -0.04762991f, -0.05888785f, -0.05129176f, -0.04124523f, 0.02976671f, -0.04492042f, 
    -0.06560720f, -0.01058089f, 0.04030532f, -0.02630016f, 0.02396551f, -0.05842763f, 0.01325263f, -0.00783507f, 
    0.00804679f, -0.02180665f, -0.05104362f, 0.00659115f, -0.05519465f, -0.07317160f, 0.01137209f, -0.01454360f, 
    -0.04035431f, -0.02783193f, -0.04150609f, -0.02908977f, -0.07393623f, -0.09002844f, 0.00639887f, -0.00872757f, 
    -0.06310623f, -0.07110251f, -0.03035348f, -0.06450571f, -0.02117544f, 0.04028554f, 0.03056489f, -0.06897064f, 
    0.04031320f, -0.04907509f, -0.06956156f, -0.07146690f, -0.04146880f, 0.01839361f, -0.03213702f, -0.05470267f, 
    -0.05708502f, 0.00579772f, -0.07844032f, -0.06712474f, 0.01527631f, -0.08307135f, -0.05549410f, 0.02453023f, 
    0.03835639f, -0.02313920f, -0.06980485f, -0.07317408f, 0.02710370f, -0.01879945f, -0.06186141f, -0.07774384f, 
    -0.06035404f, -0.00236798f, 0.03905167f, 0.00233069f, -0.07951946f, -0.05470780f, -0.03412553f, -0.08875447f, 
    -0.03338005f, -0.08719437f, -0.01546560f, -0.01651528f, 0.01245398f, -0.07575807f, -0.03587947f, -0.07321730f, 
    0.00744834f, -0.04636021f, -0.02229890f, -0.06865604f, -0.02873554f, -0.07939171f, -0.04558763f, -0.02502692f, 
    0.02361305f, 0.00499702f, 0.05886787f, -0.02328247f, -0.04038722f, 0.00119258f, -0.06454105f, 0.00746582f, 
    0.03985598f, 0.06361341f, 0.00078521f, -0.06827282f, -0.04920172f, 0.01022790f, -0.01557187f, 0.02135221f, 
    0.00727461f, 0.00756640f, -0.00227780f, 0.04340952f, -0.06935957f, -0.03049931f, -0.07823776f, -0.07537230f, 
    -0.08877856f, -0.07594985f, -0.05611386f, -0.02025067f, -0.07149538f, -0.02372585f, 0.00988684f, 0.00373081f, 
    -0.00690203f, 0.00069448f, -0.01191618f, -0.05821405f, -0.01333965f, -0.05505429f, -0.02319003f, -0.05064664f, 
    -0.07873588f, 0.03768418f, -0.04014304f, -0.01659301f, -0.02193319f, 0.00564633f, 0.02089394f, -0.01803792f, 
    -0.01028111f, -0.07009346f, -0.03996296f, -0.09447070f, 0.00002485f, -0.01363532f, -0.06262853f, 0.00174428f, 
    -0.04390623f, 0.02317221f, 0.04360979f, 0.02704867f, 0.03933095f, 0.02639531f, 0.05055634f, -0.01589836f, 
    -0.03607563f, -0.01195607f, -0.00798166f, -0.03797011f, -0.00896194f, -0.03796030f, 0.01352007f, -0.04567083f, 
    -0.03502604f, 0.01569188f, -0.05704104f, -0.05341929f, 0.00158063f, 0.00387529f, 0.03244555f, -0.03698726f, 
    0.03996119f, -0.00367882f, -0.04867414f, -0.02607420f, -0.01886785f, -0.06351167f, -0.03714545f, 0.02651619f, 
    0.02195515f, 0.03659462f, -0.06067128f, -0.02589379f, -0.00484896f, -0.03538612f, 0.02021644f, -0.03934238f, 
    0.01529064f, -0.06074977f, -0.05255629f, 0.00362186f, -0.05639587f, 0.02787200f, -0.00721369f, -0.01309143f, 
    -0.01415894f, 0.01625323f, -0.05356667f, 0.02305612f, -0.04690484f, -0.00792111f, -0.02046681f, -0.00769283f, 
    -0.02305459f, -0.04041636f, -0.03458070f, -0.02471114f, -0.05073019f, -0.04892546f, -0.04106839f, -0.00924443f, 
    -0.01140380f, 0.04762979f, -0.00304926f, 0.04622609f, -0.00624454f, -0.01536545f, -0.01427023f, -0.00041712f, 
    -0.02199566f, 0.00496165f, 0.05215605f, -0.01638403f, 0.01388973f, 0.00249738f, -0.05804066f, -0.04275245f, 
    -0.01787522f, -0.01044838f, -0.03652848f, -0.06319298f, -0.01023140f, -0.03953721f, 0.01207817f, 0.03899299f, 
    0.02117933f, 0.03973947f, -0.04376036f, -0.03224576f, -0.04407495f, 0.02448950f, -0.01515688f, 0.04078515f, 
    -0.00649856f, 0.03993208f, -0.06385000f, 0.02595920f, -0.00730574f, -0.03932169f, -0.04086158f, 0.04339417f, 
    -0.03236228f, -0.01753556f, 0.01281066f, 0.02510084f, 0.04449586f, 0.00600748f, -0.00754798f, -0.00358202f, 
    -0.00396458f, -0.01303415f, -0.05436302f, 0.01870481f, -0.01791825f, 0.04962200f, 0.01978244f, -0.05440677f, 
    -0.00421874f, -0.05096156f, -0.01752699f, 0.01821769f, 0.01663599f, 0.01375023f, -0.01109964f, 0.02453046f, 
    -0.01032705f, 0.02172897f, -0.02143233f, 0.01906336f, 0.01667214f, -0.00127114f, -0.05014299f, -0.06390545f, 
    -0.00449138f, 0.01459930f, 0.02813020f, 0.03062063f, -0.05668925f, 0.02134853f, 0.00626535f, -0.02791479f, 
    0.02956009f, 0.00390948f, -0.00839312f, 0.01597400f, -0.04067474f, 0.01668040f, -0.03189729f, -0.04885258f, 
    -0.03853507f, -0.01987883f, -0.03285731f, -0.01677525f, -0.04536475f, -0.00797448f, -0.02567613f, -0.02555081f, 
    0.03814075f, -0.04681233f, 0.05061489f, -0.01417023f, 0.00373280f, -0.03872023f, -0.06386380f, -0.04360072f, 
    -0.02183276f, 0.04210819f, 0.02189811f, -0.05821976f, -0.00934250f, -0.04829422f, -0.01621681f, -0.01228933f, 
    -0.05781482f, -0.01252157f, -0.05670459f, -0.04286052f, -0.03676264f, 0.00102361f, -0.01234450f, -0.01967610f, 
    -0.02374706f, 0.01741584f, 0.03383884f, -0.02600259f, 0.01300045f, 0.05086870f, 0.03188889f, 0.03577429f, 
    0.02988138f, -0.01556771f, -0.04299778f, 0.01234662f, -0.03577204f, 0.03842641f, -0.02967465f, -0.06312030f, 
    0.00594410f, -0.05929231f, -0.02960124f, 0.01626363f, -0.05365796f, -0.05983477f, -0.00403174f, 0.05145634f, 
    0.04662639f, 0.00898058f, 0.03229025f, 0.04414936f, 0.00107577f, -0.03247438f, -0.05519737f, 0.04235090f, 
    -0.03020276f, -0.05505543f, 0.00018967f, 0.01258846f, 0.04431736f, -0.04883620f, -0.05906770f, -0.00899184f, 
    -0.03670135f, 0.01424155f, 0.01085891f, -0.01876771f, 0.04591816f, -0.01245069f, 0.00957880f, -0.05092728f, 
    -0.05163686f, -0.01767475f, -0.00899999f, 0.02903120f, -0.03773199f, 0.00673720f, -0.01976259f, 0.02054234f, 
    0.02841858f, 0.02618055f, 0.02778192f, 0.00432121f, 0.04114647f, -0.04527402f, -0.04113862f, -0.05260439f, 
    0.04520676f, 0.01998467f, 0.02261511f, -0.05733015f, 0.00008943f, -0.05755144f, -0.06263974f, 0.02212083f, 
    -0.01193093f, 0.01451789f, -0.02451862f, 0.01464223f, 0.01923586f, -0.06149244f, -0.00153942f, -0.02054241f, 
    -0.00948329f, 0.01466502f, 0.00660136f, -0.04952152f, -0.01105253f, -0.00892866f, -0.00328705f, 0.03760050f, 
    0.04374840f, -0.03873599f, -0.00403225f, -0.00912404f, -0.05276735f, -0.00482907f, 0.01651418f, -0.01592561f, 
    -0.05511602f, -0.00445126f, 0.03400586f, 0.01716680f, 0.02711105f, 0.00823033f, -0.04653442f, 0.04477743f, 
    0.03589591f, 0.02658899f, 0.04002116f, -0.06452149f, -0.02872181f, -0.02670067f, -0.02720628f, -0.05385428f, 
    -0.00755693f, 0.03227341f, 0.02604091f, -0.04967547f, -0.02321746f, -0.04980653f, -0.04022396f, -0.03447782f, 
    0.00768926f, 0.02223008f, 0.05041452f, 0.03934553f, 0.02422786f, -0.03904478f, -0.03084631f, -0.04285298f, 
    0.01671869f, -0.06913877f, -0.00132721f, -0.02139542f, 0.02615031f, 0.00012197f, 0.04086585f, 0.01043304f, 
    0.01581918f, -0.03675824f, -0.05296724f, 0.00807969f, -0.00119976f, 0.02457362f, 0.02258807f, 0.00159953f, 
    -0.04559805f, -0.02924061f, -0.02475533f, -0.01609173f, 0.04583837f, -0.01028898f, -0.03897856f, 0.01882602f, 
    0.01021082f, 0.03987068f, -0.06117706f, -0.04187798f, 0.04838594f, 0.02387974f, -0.02583649f, -0.05007764f, 
    -0.06443352f, 0.04000458f, -0.00510689f, 0.02007709f, 0.00544283f, -0.01535450f, -0.00132484f, -0.03655335f, 
    0.02396913f, 0.01632640f, 0.03900746f, 0.01946048f, 0.04303670f, -0.06527046f, -0.00890023f, 0.01177234f, 
    -0.02856889f, 0.04125166f, 0.01373143f, 0.02950075f, 0.03843280f, 0.00982327f, -0.05399022f, 0.00212058f, 
    -0.01847108f, -0.02194887f, 0.04956079f, 0.03682137f, -0.03303131f, -0.04838245f, 0.04253463f, 0.00492956f, 
    0.00768512f, -0.03343755f, 0.03495617f, -0.04778084f, 0.01850197f, -0.03219902f, -0.03035144f, 0.00844552f, 
    -0.00000623f, -0.00580603f, 0.04541966f, -0.05257983f, -0.05230186f, 0.03639225f, 0.05607948f, -0.00747328f, 
    -0.07190143f, -0.06984673f, 0.02545610f, 0.02186251f, -0.04504897f, -0.06062095f, -0.00130292f, 0.03750011f, 
    0.02601647f, -0.03762808f, -0.05347976f, 0.05339920f, -0.01877036f, -0.05029281f, 0.01092874f, 0.01505877f, 
    -0.01816447f, 0.00248291f, 0.01297188f, -0.00943657f, 0.03980526f, -0.01436098f, 0.01620198f, 0.00040373f, 
    -0.00712594f, -0.01866574f, -0.05719280f, 0.02259250f, -0.02716721f, 0.01284397f, 0.04884293f, -0.05576293f, 
    0.00486391f, -0.03671720f, 0.03129051f, -0.02227720f, -0.02052856f, 0.04709553f, -0.03615313f, -0.00604486f, 
    -0.04192787f, 0.02087492f, 0.01180659f, -0.05856215f, -0.06297085f, -0.07118128f, -0.02082920f, -0.04672886f, 
    -0.03111458f, -0.00941052f, -0.00170129f, -0.06610675f, -0.02707443f, -0.04975585f, -0.05813947f, 0.00129431f, 
    -0.00811634f, 0.01397143f, -0.03288822f, 0.03113879f, 0.03005284f, -0.05173101f, 0.05024999f, 0.05074579f, 
    0.00427907f, -0.00774731f, 0.04735184f, -0.00920374f, 0.05747768f, -0.03325148f, -0.05355876f, -0.03827509f, 
    -0.05013439f, 0.03735242f, -0.05376376f, 0.04139917f, -0.06486639f, -0.00197674f, -0.06635625f, -0.06916559f, 
    0.00368239f, -0.04521479f, 0.00730588f, 0.03862780f, -0.06078913f, -0.01354841f, 0.03032669f, 0.02595994f, 
    -0.02591618f, -0.05277658f, 0.03611918f, 0.00752233f, 0.00350112f, -0.04312744f, -0.00522711f, -0.04241857f, 
    -0.04979512f, -0.00814277f, -0.01886458f, 0.03971485f, 0.01308653f, 0.03026602f, -0.04261228f, -0.01500665f, 
    -0.00155167f, 0.01084906f, -0.04905815f, 0.04891960f, 0.02734656f, -0.05706526f, -0.04761614f, -0.05554146f, 
    0.01613089f, -0.03899315f, -0.05773688f, -0.01338770f, -0.03919859f, -0.07008860f, -0.01365618f, -0.03768940f, 
    0.03682441f, 0.02382022f, -0.03144056f, 0.00675094f, 0.04743907f, -0.04836192f, -0.05483265f, 0.03034922f, 
    -0.02492341f, 0.02933457f, 0.00887807f, -0.06117330f, 0.02584271f, -0.01965786f, 0.00241254f, -0.02668319f, 
    0.04104102f, 0.01840238f, -0.05502316f, -0.00864391f, -0.00833625f, -0.00596288f, 0.02626313f, -0.01682586f, 
    -0.05766089f, 0.03381358f, -0.00310361f, 0.03633476f, 0.02631032f, 0.03333803f, -0.06408443f, -0.00907606f, 
    -0.01830327f, -0.00376673f, 0.03828709f, 0.02503781f, -0.03077881f, -0.00283715f, 0.00797177f, 0.01148649f, 
    0.04225000f, -0.00267530f, -0.05451176f, 0.03594668f, 0.04344536f, 0.00379351f, 0.01052621f, -0.03269913f, 
    -0.03347920f, -0.01927768f, 0.00092003f, -0.04178718f, -0.05451291f, 0.05223316f, 0.02874891f, -0.06185327f, 
    0.01260342f, -0.00674409f, 0.00127073f, 0.04504045f, 0.01599147f, -0.05433751f, 0.04078516f, -0.01331448f, 
    -0.00584319f, -0.01125746f, -0.00686420f, -0.02145358f, -0.03242156f, 0.01683316f, 0.01358988f, 0.00761374f, 
    0.01541480f, -0.00232108f, 0.04536247f, 0.00312924f, 0.04318195f, 0.03157210f, 0.05283143f, -0.05522407f, 
    -0.02784972f, 0.00898235f, -0.04819949f, 0.03892272f, 0.01253281f, -0.01279731f, 0.04236004f, 0.05189062f, 
    -0.05533103f, 0.00363102f, 0.03248930f, -0.01424337f, -0.01676767f, 0.00072928f, -0.00055014f, -0.03673365f, 
    -0.05689296f, -0.05653339f, 0.02648776f, -0.03090159f, -0.00379918f, -0.03617611f, -0.02050185f, 0.04532138f, 
    -0.04787042f, -0.04680957f, -0.05442069f, -0.01894902f, 0.03913348f, 0.01027596f, 0.05017035f, -0.03411264f, 
    0.02601093f, 0.02904910f, -0.03968170f, 0.04344683f, -0.06099924f, 0.00745492f, 0.01957323f, -0.05205801f, 
    0.03322854f, -0.02237400f, 0.04354326f, 0.03165625f, -0.01919962f, -0.05354265f, 0.01716096f, 0.04172179f, 
    0.01415824f, -0.02899288f, -0.03953216f, 0.05069567f, 0.01373554f, 0.02218192f, 0.03812565f, 0.05131966f, 
    0.01237579f, -0.03251422f, -0.01510883f, 0.04259385f, -0.01070356f, -0.03809706f, 0.00047271f, 0.02504953f, 
    -0.04241982f, -0.03692267f, -0.01483307f, -0.03165490f, -0.00406120f, 0.01937684f, -0.01446617f, -0.00411579f, 
    0.01248632f, -0.04490871f, -0.05212842f, -0.03400167f, 0.04882127f, 0.02385921f, -0.00416819f, 0.04069030f, 
    0.02478737f, -0.06189107f, -0.04852935f, -0.05708780f, -0.02062646f, 0.01655553f, -0.01537551f, -0.05146184f, 
    -0.04668964f, -0.05263174f, -0.04400375f, -0.03610621f, 0.03067460f, 0.01400058f, 0.03628031f, -0.04163771f, 
    -0.03591646f, 0.03180777f, -0.01471609f, 0.04373537f, -0.05278505f, 0.05125274f, -0.02271436f, 0.00014575f, 
    -0.04049736f, -0.01914341f, -0.05205779f, 0.01462268f, -0.04368671f, 0.03272839f, -0.05945523f, 0.02049642f, 
    -0.02041184f, 0.04825512f, 0.01739145f, 0.01545313f, -0.06135163f, -0.06346572f, 0.01350493f, 0.02036283f, 
    0.04785909f, 0.04657218f, -0.06061959f, -0.01311863f, 0.00183631f, -0.04668956f, 0.01336897f, -0.01371791f, 
    0.00230096f, -0.03122484f, -0.00555154f, 0.03533664f, 0.01207731f, -0.05712869f, -0.02817665f, 0.03396398f, 
    -0.00047166f, 0.04015954f, -0.04303193f, -0.05481965f, -0.00085018f, -0.06072072f, 0.04501285f, -0.02478076f, 
    -0.04409034f, 0.00979592f, -0.05570558f, -0.05907837f, 0.01593364f, -0.01587768f, -0.00436028f, -0.00698905f, 
    0.04059877f, -0.02731325f, -0.04328934f, 0.00264430f, -0.00368312f, -0.03288624f, 0.00016273f, -0.02704553f, 
    -0.05188094f, -0.00616152f, 0.04323880f, -0.00239859f, -0.02705896f, -0.05780256f, 0.03582508f, -0.04522781f, 
    0.00222648f, -0.05142795f, 0.03671459f, 0.02761105f, -0.03172867f, -0.02971934f, -0.01004276f, 0.03592214f, 
    0.00435991f, -0.02949455f, -0.04263109f, 0.04673172f, -0.02829283f, 0.03978230f, -0.02373149f, -0.02764006f, 
    -0.01206839f, 0.00232750f, 0.01549660f, -0.06103042f, -0.06188362f, -0.01472994f, -0.04205261f, 0.02616533f, 
    -0.06088814f, -0.02954759f, 0.04736210f, -0.01543453f, -0.06047297f, -0.02579517f, -0.03247222f, -0.05910526f, 
    -0.03243982f, 0.00728416f, -0.00616308f, -0.03405782f, 0.05091879f, 0.02807638f, 0.02944280f, -0.05687350f, 
    -0.04242159f, 0.03026998f, -0.02821735f, 0.03638922f, 0.02478438f, -0.01668317f, 0.00180092f, 0.00788108f, 
    -0.00291360f, -0.00945241f, -0.06258906f, 0.02308316f, -0.00881747f, -0.03819719f, -0.02623270f, 0.04328788f, 
    -0.04413468f, -0.03737904f, 0.03168603f, -0.01522316f, -0.03887074f, 0.02867840f, -0.01802537f, -0.06162767f, 
    0.04003070f, -0.02471425f, -0.00446559f, -0.03903665f, 0.02753808f, -0.00448957f, -0.05161441f, -0.06430211f, 
    0.01597194f, -0.00724192f, 0.03287867f, -0.01647418f, -0.06472065f, 0.05159451f, 0.00494370f, -0.06124102f, 
    -0.00682592f, -0.00587684f, -0.02952033f, 0.03908842f, 0.01715159f, -0.01276090f, -0.03465314f, 0.04126122f, 
    -0.04823712f, -0.00634262f, 0.02492145f, 0.00567780f, 0.01826938f, -0.04804781f, 0.00316380f, -0.03992061f, 
    -0.04196751f, -0.00824034f, -0.05783182f, 0.01573347f, -0.02155491f, 0.01496597f, -0.04693633f, -0.00158520f, 
    0.04733347f, 0.01291903f, 0.02536270f, 0.00645593f, -0.02061747f, 0.01285638f, 0.01740607f, -0.00987181f, 
    -0.05082075f, 0.01202957f, 0.04951193f, 0.01682538f, -0.06112994f, -0.01010658f, 0.01449757f, 0.01598685f, 
    -0.02621555f, -0.01007689f, 0.00563661f, 0.04741907f, 0.02316128f, -0.03359952f, -0.02682939f, -0.02646177f, 
    0.04244386f, 0.03004732f, 0.02634908f, -0.02499446f, 0.00203495f, -0.03260126f, -0.04192570f, 0.00809332f, 
    -0.01541749f, -0.02523060f, 0.02351969f, -0.03086232f, -0.01051815f, -0.05584834f, -0.02676948f, 0.02480252f, 
    0.00357016f, 0.00362577f, 0.04592912f, 0.04536200f, 0.04650873f, 0.02975750f, -0.00694896f, -0.00405570f, 
    0.05092397f, 0.01633473f, -0.00510134f, -0.01651434f, -0.05023557f, -0.01626687f, -0.02423698f, -0.05643320f, 
    0.04903291f, 0.04027365f, -0.05250806f, -0.01956344f, -0.02020346f, -0.05839622f, -0.02043407f, -0.04292594f, 
    0.00698807f, 0.01644457f, -0.05382204f, 0.00848907f, -0.03458162f, -0.01843323f, 0.03076938f, -0.01450839f, 
    -0.05608440f, -0.01923600f, 0.01339970f, -0.03326285f, 0.02043083f, 0.00293422f, -0.03942497f, -0.05390288f, 
    -0.03304890f, -0.05920010f, 0.03192385f, 0.02536676f, -0.03840634f, 0.03840040f, -0.05954836f, -0.01215283f, 
    -0.02492399f, 0.02913652f, -0.05228169f, 0.04193114f, -0.04101584f, -0.00507548f, 0.03894872f, -0.04794713f, 
    -0.03061025f, -0.02343230f, 0.03852718f, 0.01005416f, -0.06272075f, 0.04243607f, -0.00660745f, -0.05767503f, 
    -0.04061874f, 0.03708426f, 0.03106123f, 0.00073389f, -0.00997615f, 0.01934302f, -0.00098977f, -0.05193973f, 
    0.00120768f, -0.00168588f, -0.04611335f, 0.00282914f, -0.01136269f, 0.01358464f, 0.02723522f, 0.03280777f, 
    0.04250422f, 0.04353853f, 0.04261279f, -0.03332945f, 0.03489692f, 0.05442702f, -0.04717368f, 0.00886914f, 
    -0.03324790f, -0.05976587f, 0.02534888f, -0.00333979f, 0.02757962f, 0.04057073f, 0.00001167f, -0.03838620f, 
    0.04813514f, -0.06316407f, -0.00037081f, -0.01184685f, 0.00848337f, -0.02364851f, -0.05232877f, -0.02302739f, 
    0.04084662f, 0.00370738f, 0.03984865f, -0.01129768f, 0.00502550f, -0.00338678f, 0.00889774f, 0.02024723f, 
    -0.01589599f, -0.00741766f, 0.01730998f, -0.01596767f, -0.01539532f, -0.05785886f, 0.02697715f, 0.02474838f, 
    -0.03671582f, 0.03065241f, -0.05399320f, -0.04663968f, -0.00900655f, -0.02455453f, 0.04881671f, -0.04298396f, 
    -0.00316324f, 0.03838766f, -0.04816790f, -0.04999224f, 0.01552666f, -0.01411671f, -0.02289155f, -0.03840132f, 
    -0.03423165f, -0.05749440f, -0.04439318f, -0.04454380f, -0.01594837f, -0.04778510f, 0.01216469f, 0.03992646f, 
    -0.05483189f, -0.01107723f, -0.02498718f, 0.03387788f, -0.01458158f, -0.02628572f, -0.04371124f, -0.05601310f, 
    0.03053907f, -0.05771288f, 0.03112981f, 0.03548050f, -0.00614547f, 0.01055947f, 0.03911167f, 0.05470932f, 
    -0.04767752f, -0.05066996f, -0.05875875f, -0.05256131f, -0.01487949f, 0.05174993f, -0.06181775f, -0.02061346f, 
    0.03312454f, 0.04764848f, 0.01405210f, 0.04980477f, -0.04536531f, -0.00222569f, 0.01243594f, -0.02549032f, 
    0.02319113f, -0.04839598f, -0.04784595f, -0.03793761f, -0.01246672f, 0.04448408f, -0.03471100f, 0.03792038f, 
    0.04786614f, -0.05971469f, -0.03343475f, -0.05130301f, -0.04323286f, 0.01508701f, -0.05525749f, -0.02218969f, 
    -0.03713158f, 0.00022986f, 0.04134933f, -0.06171380f, -0.04412330f, -0.04838875f, -0.05399466f, -0.03502534f, 
    0.03072797f, -0.04044956f, 0.04762889f, 0.02358579f, 0.02503392f, -0.00024466f, -0.00871983f, -0.05754546f, 
    -0.01522993f, -0.05139070f, -0.05730955f, -0.04059415f, 0.01939164f, -0.06296697f, 0.03092473f, -0.06088529f, 
    0.04895630f, -0.00880301f, -0.02279598f, -0.00290828f, -0.05582165f, -0.01004975f, 0.00007640f, -0.01808663f, 
    0.01637012f, 0.04573540f, -0.02509111f, -0.02380576f, -0.02901296f, -0.01813585f, 0.00414109f, -0.06140985f, 
    -0.01994678f, 0.05222836f, 0.03096075f, -0.02245916f, -0.00877165f, 0.05342870f, 0.00015153f, -0.01923049f, 
    0.04412615f, 0.03483977f, -0.05084359f, -0.01393383f, -0.06144701f, -0.01863426f, -0.02637220f, -0.03291869f, 
    -0.30932248f, -0.09721196f, -0.16420376f, -0.00172069f, -0.01929868f, 0.11636876f, -0.09161757f, -0.17731349f, 
    0.19451153f, -0.30694699f, 0.06327663f, 0.19043908f, 0.05587607f, -0.30420718f, -0.06581533f, 0.08090005f, 
    -0.09469449f, 0.13674898f, -0.02386336f, 0.01847326f, -0.01032929f, 0.09400411f, -0.00826146f, 0.03790958f, 
    0.04634093f, -0.01071073f, -0.05275357f, 0.05947182f, 0.08393347f, 0.09402207f, -0.20271455f, 0.10320461f, 
    0.03673102f, 0.12850818f, -0.19922693f, 0.00626415f, -0.03770153f, 0.14206602f, 0.19425356f, -0.03582705f, 
    -0.10613226f, -0.06241116f, 0.00754297f, -0.00552423f, 0.17941093f, 0.06957737f, 0.13701437f, -0.02325970f, 
    0.06307588f, -0.07921504f, 0.02112642f, -0.07656137f, 0.12865889f, 0.01608895f, 0.01377675f, 0.12952612f, 
    0.02423058f, 0.06452911f, 0.13690799f, 0.04807656f, 0.15673517f, -0.05186714f, 0.03501977f, 0.01708219f, 
    -0.07033242f, -0.12802628f, -0.13679272f, 0.11440247f, -0.05149915f, 0.08758745f, 0.03511230f, -0.12747066f, 
    0.15449212f, 0.13541020f, 0.09733973f, -0.06268915f, -0.10368597f, -0.14159949f, -0.06817256f, 0.09495527f, 
    -0.03904878f, 0.05470875f, 0.00427199f, -0.09317326f, -0.00323816f, -0.02682940f, -0.02225257f, 0.21151544f, 
    0.02472633f, 0.04247453f, 0.28166988f, 0.18436693f, -0.01659011f, 0.22886905f, 0.10114802f, 0.08884560f, 
    0.13453600f, -0.04068802f, 0.09128436f, 0.20498818f, -0.20186716f, -0.13065620f, 0.08710389f, 0.00698503f, 
    -0.06955628f, -0.07992870f, -0.01413601f, 0.11203799f, -0.12864724f, 0.11234926f, -0.09851541f, 0.06393097f, 
    -0.00673863f, 0.12479884f, 0.06140015f, -0.09181870f, -0.03607184f, -0.14049324f, -0.34500825f, -0.13432847f, 
    -0.10748904f, -0.00493341f, -0.19220318f, -0.10571393f, 0.22107199f, -0.08110690f, -0.23257084f, -0.05529281f, 
    0.24220350f, -0.01199782f, -0.18454516f, -0.34534708f, 0.01980406f, -0.15588197f, -0.02409676f, 0.21593839f, 
    -0.21297647f, -0.21162297f, 0.03789656f, -0.01881603f, 0.01976451f, -0.01163068f, 0.04375431f, 0.06554957f, 
    -0.05431442f, -0.01286698f, 0.13757305f, -0.05511424f, 0.15432653f, 0.03058490f, 0.09432648f, -0.02375031f, 
    -0.09868529f, -0.07008052f, -0.13662319f, 0.22570308f, 0.07375477f, -0.07729954f, 0.00182388f, -0.01198187f, 
    -0.00598373f, -0.04637370f, -0.04599974f, 0.03290385f, -0.25120437f, -0.14477508f, -0.20743708f, -0.01456702f, 
    0.07263155f, 0.00821036f, -0.02405679f, 0.13341436f, 0.08328985f, -0.02611350f, 0.02020621f, 0.02085098f, 
    -0.05700949f, 0.05086121f, -0.03483302f, 0.16793832f, -0.04405752f, -0.20693403f, 0.07439133f, -0.04709016f, 
    -0.09820835f, -0.13606887f, 0.02410506f, -0.02354009f, -0.05642010f, -0.08795314f, 0.27304360f, 0.02761723f, 
    -0.17067665f, 0.02583832f, 0.11101113f, 0.06756499f, -0.00106484f, -0.15237485f, 0.02514647f, 0.17516808f, 
    0.22432853f, -0.18210618f, -0.01949741f, -0.03440867f, -0.01992797f, -0.16993921f, 0.08261912f, -0.27656636f, 
    -0.33556536f, -0.02448944f, 0.00007381f, 0.08937062f, 0.15725847f, 0.10171948f, 0.04027879f, -0.08144732f, 
    -0.03730357f, -0.07238042f, -0.05535812f, 0.07188807f, -0.06696011f, -0.12465534f, -0.02586142f, 0.08869126f, 
    0.00803931f, -0.07813275f, -0.33487871f, -0.28828681f, 0.22947204f, 0.02396128f, 0.25729120f, 0.08007218f, 
    -0.07277323f, -0.11581343f, -0.06971563f, -0.15291238f, 0.03221418f, 0.07671217f, -0.07092895f, -0.03708172f, 
    -0.00569947f, -0.21100484f, 0.02947570f, -0.36351186f, -0.45081490f, 0.05447222f, -0.15925157f, -0.13125159f, 
    -0.18450527f, 0.01908332f, 0.05781154f, 0.03825663f, 0.48426867f, 0.04192884f, -0.09197222f, 0.05728276f, 
    -0.00803847f, -0.00112273f, -0.03484423f, 0.11990687f, -0.11922606f, -0.06475425f, -0.02021154f, 0.15198147f, 
    0.00609552f, 0.10766494f, 0.01766590f, 0.12334042f, -0.09995726f, -0.04578833f, -0.36432225f, 0.02499877f, 
    -0.61352432f, 0.20334221f, 0.08384743f, 0.10407271f, 0.07593422f, -0.08089882f, -0.06278552f, -0.45787182f, 
    -0.22572935f, -0.19875318f, -0.00580737f, -0.00481695f, -0.15375362f, -0.10916771f, -0.06004133f, -0.04701411f, 
    -0.09242278f, -0.76302868f, -0.52986073f, -0.12152358f, -0.00616027f, -0.21065912f, -0.05930560f, -0.06422496f, 
    -0.08850516f, -0.04216214f, 0.12192585f, -0.04174938f, -0.15723528f, 0.08733692f, -0.09841920f, -0.02937892f, 
    0.08086193f, -0.07343130f, -0.12815066f, -0.14859739f, 0.02397285f, 0.04886162f, 0.12388701f, 0.12466046f, 
    -0.01354839f, 0.00217458f, 0.02663658f, 0.00049642f, 0.08385273f, 0.09584687f, -0.09774866f, 0.02445921f, 
    -0.12754713f, 0.12208639f, -0.02179606f, 0.08929433f, -0.11109261f, 0.06513802f, 0.01307519f, 0.01027524f, 
    -0.14256960f, -0.17046976f, -0.01726457f, 0.00669815f, 0.06808340f, -0.06142595f, 0.03123885f, 0.13792324f, 
    0.02891025f, -0.00295793f, 0.03041923f, -0.07737148f, -0.02208666f, 0.14379910f, 0.00807630f, 0.07975721f, 
    0.05128594f, -0.02315855f, -0.17812662f, -0.08175359f, 0.14662145f, 0.12459949f, -0.06889910f, -0.17693476f, 
    0.14770110f, 0.42241442f, -0.18571009f, 0.08354879f, 0.10442919f, 0.02703327f, 0.03016288f, 0.17694366f, 
    -0.01911596f, 0.22379899f, 0.09006600f, -0.10112204f, -0.12851827f, -0.14830144f, 0.02831457f, 0.01275889f, 
    0.05322304f, 0.10958947f, 0.03558390f, 0.13119417f, 0.08493819f, -0.02221060f, -0.00858049f, -0.02026791f, 
    0.13758902f, 0.09301353f, 0.16936862f, -0.15363266f, 0.30960169f, 0.12727922f, 0.17077728f, -0.00980951f, 
    0.12778540f, 0.12994027f, 0.04971580f, 0.23390089f, -0.24809578f, -0.00487361f, -0.11315271f, 0.06047924f, 
    -0.13801824f, 0.16237165f, -0.06228152f, -0.15259719f, -0.04800419f, 0.09892222f, -0.11604764f, -0.05943712f, 
    0.14104474f, 0.05821015f, 0.05470368f, 0.13625012f, -0.01435285f, -0.03163650f, 0.19483864f, -0.22442979f, 
    -0.12009809f, -0.08607663f, 0.02771612f, -0.01256529f, 0.00849541f, 0.00236716f, 0.06625476f, 0.07688136f, 
    0.01059918f, -0.17837109f, -0.18860550f, -0.05194782f, 0.12777077f, 0.10816158f, -0.14331460f, -0.01942802f, 
    -0.03663200f, -0.47232100f, -0.01093496f, -0.05186565f, 0.06254948f, -0.01061119f, 0.00199862f, -0.12843636f, 
    -0.09905621f, 0.01887633f, -0.10773215f, -0.12151558f, -0.15028578f, -0.07715965f, 0.12187704f, 0.09717492f, 
    -0.03642888f, 0.14915340f, 0.03369792f, -0.11951459f, -0.22745079f, 0.14411533f, -0.07626921f, 0.23229571f, 
    -0.08107146f, 0.08603168f, 0.00542144f, -0.05670610f, -0.10379764f, -0.09840569f, -0.11309552f, 0.18923607f, 
    0.07998244f, 0.02009933f, -0.08839943f, 0.15055941f, 0.13269974f, -0.01505250f, 0.05308147f, -0.04190343f, 
    0.04867297f, 0.02421201f, -0.03789090f, 0.10566844f, 0.00694619f, 0.18794031f, -0.04108857f, 0.09402458f, 
    0.01175421f, -0.01894378f, 0.08173013f, 0.03212241f, -0.05033814f, -0.13596117f, -0.02929408f, 0.14336799f, 
    -0.06251105f, -0.12464371f, -0.03608232f, 0.08708934f, 0.06702369f, -0.01087689f, -0.01717785f, 0.03399467f, 
    0.06453507f, -0.00894359f, -0.10899757f, -0.08421157f, -0.02414456f, -0.14409378f, 0.11827438f, 0.06969040f, 
    -0.23225459f, -0.26249188f, 0.04012440f, 0.23371372f, -0.02665985f, -0.01178379f, 0.02427040f, 0.05321953f, 
    0.11037786f, 0.30425376f, 0.17302661f, -0.07212966f, 0.08976243f, -0.00742561f, 0.18234940f, -0.02159701f, 
    0.03354538f, -0.27854386f, -0.20314118f, -0.04030053f, -0.03523088f, 0.16625859f, -0.05320096f, 0.11497900f, 
    0.01287759f, 0.03238084f, 0.23345639f, -0.06655048f, -0.01257541f, -0.07538798f, -0.12298045f, -0.06846006f, 
    -0.02108718f, 0.09478752f, 0.13788275f, -0.19264005f, -0.06569120f, -0.11661519f, -0.22388987f, -0.02246295f, 
    -0.03356637f, 0.15215892f, 0.03002404f, -0.01589512f, 0.15717021f, 0.08845789f, 0.02873693f, -0.05093922f, 
    0.04973325f, -0.12242206f, -0.02922875f, 0.07088374f, 0.03369363f, 0.05768957f, -0.06070708f, 0.00499466f, 
    0.05799750f, 0.02037181f, 0.10691824f, 0.11329821f, 0.15624604f, 0.04599833f, -0.32793361f, -0.39795825f, 
    -0.13301447f, 0.22509012f, 0.15039207f, 0.11795326f, 0.01451646f, -0.02925927f, -0.05993423f, 0.03735149f, 
    -0.49233055f, -0.13232566f, -0.05167483f, -0.02777043f, -0.09104702f, 0.04870626f, -0.12695560f, -0.04753506f, 
    0.41656566f, -0.39241236f, -0.12622485f, 0.01461808f, -0.09015846f, 0.12616895f, -0.04883674f, 0.06821842f, 
    0.00644868f, -0.07178302f, 0.15969203f, -0.61385947f, 0.11157226f, 0.06135822f, -0.04563581f, 0.11904904f, 
    -0.00998370f, -0.05534774f, -0.01850257f, -0.24351272f, -0.11728350f, -0.06940117f, -0.18203990f, -0.07486492f, 
    0.22571610f, 0.12089530f, 0.05006963f, -0.02906875f, 0.19367528f, 0.06119200f, 0.07371797f, -0.11035530f, 
    0.11647405f, 0.06214401f, -0.09267354f, 0.17586680f, 0.08885975f, -0.16002454f, 0.02621624f, -0.08419564f, 
    0.02031931f, -0.08939470f, -0.00162645f, 0.02442873f, -0.05195288f, -0.38179019f, -0.13451754f, 0.07529495f, 
    0.07471641f, -0.03020041f, -0.06904090f, -0.05067187f, -0.03143317f, -0.07539181f, 0.07285463f, -0.25258312f, 
    -0.18872771f, -0.09930582f, -0.07195473f, 0.00469166f, 0.00079219f, 0.01937287f, -0.15236120f, 0.12752607f, 
    0.23808233f, 0.25886616f, -0.02116722f, 0.06442866f, -0.04101299f, 0.00170764f, -0.09006555f, 0.07915983f, 
    0.10556238f, -0.11053945f, -0.57024634f, 0.13072029f, -0.01966283f, -0.04161876f, 0.07309332f, -0.11772180f, 
    0.02516525f, -0.15748113f, -0.03225667f, 0.15759939f, 0.09939811f, -0.04012116f, -0.06240692f, 0.02991008f, 
    -0.01089015f, -0.00481635f, -0.08950119f, -0.17458844f, -0.13181742f, 0.02121462f, 0.00050909f, -0.09478176f, 
    0.04926881f, 0.16554593f, -0.06693500f, 0.10202066f, -0.26318890f, 0.08911707f, -0.08963588f, -0.11650950f, 
    0.15362175f, 0.06021036f, -0.07859907f, 0.13961701f, -0.09749219f, 0.09704800f, -0.55068594f, 0.04197105f, 
    -0.10807318f, 0.14484817f, 0.05552639f, 0.09447535f, -0.01941224f, 0.23779431f, 0.22059599f, -0.02289666f, 
    -0.05309479f, 0.08254049f, 0.17297554f, -0.12559095f, -0.04870562f, 0.11544947f, -0.07775818f, -0.07581282f, 
    0.15311711f, 0.07923187f, -0.00601951f, 0.00390631f, 0.02293190f, -0.11130520f, -0.08641753f, 0.31521225f, 
    0.04068168f, 0.00151238f, 0.04823174f, -0.03591587f, 0.05484987f, -0.10535374f, 0.03548649f, 0.01465137f, 
    -0.10845095f, -0.03441790f, -0.21700436f, -0.23709923f, 0.16035353f, -0.01195241f, 0.00109908f, -0.01239615f, 
    -0.05551907f, -0.00311936f, -0.15698560f, -0.34191984f, -0.06252903f, -0.18561262f, 0.03027311f, 0.05510440f, 
    0.03163015f, 0.02450040f, 0.40716937f, 0.04423627f, 0.17588684f, 0.04567375f, 0.06940275f, 0.15774576f, 
    -0.07267015f, 0.06473624f, -0.00066758f, 0.14574297f, -0.04212987f, 0.01229086f, 0.03087166f, 0.07338176f, 
    -0.03230612f, 0.05859100f, -0.03551836f, 0.03219710f, 0.05122029f, -0.11060394f, -0.01023289f, -0.01407060f, 
    -0.06854743f, -0.09980398f, -0.07253461f, 0.06612048f, 0.04756088f, -0.09575061f, 0.16387510f, -0.07294905f, 
    -0.12390983f, -0.05931713f, 0.00542120f, 0.07645741f, -0.02569235f, -0.16513827f, 0.04610667f, -0.11803900f, 
    -0.30771348f, -0.00204946f, -0.01754700f, -0.09085075f, 0.04993009f, 0.04838918f, -0.00317526f, -0.15355934f, 
    -0.03548649f, -0.10843740f, -0.03834524f, 0.03467702f, 0.16561012f, 0.10514887f, 0.19073811f, -0.00327813f, 
    0.11810887f, 0.24516366f, 0.04529268f, -0.07486038f, -0.00548237f, -0.04849586f, 0.08979733f, -0.10087095f, 
    0.14555456f, -0.03140000f, 0.12973808f, 0.00611587f, 0.01675420f, -0.03878078f, 0.20871879f, 0.06749226f, 
    0.03240139f, -0.12448296f, 0.19414437f, 0.17746788f, 0.10054073f, -0.12749143f, -0.00163687f, -0.20941560f, 
    0.05666961f, 0.07257661f, -0.04881388f, -0.01944816f, 0.19634031f, 0.18012731f, -0.01275708f, 0.04426626f, 
    -0.03069918f, 0.11939317f, -0.08343171f, -0.01397367f, -0.18610545f, 0.05023864f, 0.11011342f, -0.17395270f, 
    0.07193334f, -0.05345137f, -0.15950076f, 0.04956035f, -0.06405888f, 0.01371475f, -0.05396169f, 0.08218004f, 
    -0.06952512f, -0.09732858f, -0.06600959f, 0.07359968f, 0.03433624f, 0.10350228f, -0.07036739f, 0.11531241f, 
    -0.39763644f, 0.06492520f, -0.08981559f, 0.08087213f, -0.00295658f, 0.16131540f, -0.08898744f, 0.07726376f, 
    -0.14406824f, 0.16532663f, -0.09473537f, 0.21515968f, -0.03247237f, -0.06061419f, -0.07976086f, 0.03215755f, 
    -0.17181134f, -0.13626602f, 0.43731928f, -0.11015432f, -0.08883706f, -0.12844016f, 0.10976657f, -0.12625061f, 
    -0.18486738f, 0.02595047f, -0.17794754f, 0.12312759f, 0.11900659f, 0.02508491f, -0.09054515f, -0.00479564f, 
    -0.10358058f, -0.02947827f, -0.32142696f, -0.09567334f, -0.06822236f, -0.01418574f, -0.00706020f, 0.19346988f, 
    0.08223608f, 0.06024423f, 0.00817282f, -0.02605566f, -0.05233602f, -0.06126862f, 0.00068827f, -0.05579962f, 
    0.13256755f, -0.14406632f, -0.12376881f, -0.11077128f, -0.27681324f, -0.10605569f, 0.11387432f, 0.01898378f, 
    -0.04293386f, 0.13247275f, -0.09262489f, 0.07716163f, 0.08220402f, -0.19074516f, 0.03569002f, -0.17930983f, 
    -0.00946134f, 0.24992947f, -0.00473693f, 0.19759963f, -0.03028313f, 0.03597969f, -0.38544869f, -0.07611424f, 
    0.09535785f, 0.23596838f, -0.04813258f, -0.14253251f, -0.08459584f, 0.02202593f, 0.01418473f, -0.27046549f, 
    -0.35485879f, -0.16045028f, 0.04027728f, -0.05493151f, 0.07330528f, -0.09032883f, 0.14536868f, 0.11869485f, 
    -0.09996679f, 0.10293944f, 0.03965432f, -0.13686812f, 0.04012149f, -0.09864980f, -0.14194612f, 0.04635350f, 
    -0.09457780f, 0.11837795f, 0.01493861f, -0.04141953f, -0.05454998f, -0.03735223f, 0.13445681f, 0.13157636f, 
    0.19244581f, 0.23556855f, -0.00361566f, -0.00654441f, 0.07931367f, -0.01603122f, 0.10800590f, -0.06049189f, 
    0.05701753f, 0.05919433f, 0.13778888f, 0.10788583f, -0.20868492f, -0.01614192f, -0.05609681f, 0.00320667f, 
    0.06596205f, -0.00813134f, -0.03814511f, 0.00823310f, 0.06119717f, 0.05658805f, 0.08871359f, 0.11782267f, 
    -0.03512700f, 0.01968810f, -0.00850143f, 0.05466189f, -0.03954437f, -0.02715653f, -0.06999104f, 0.24872468f, 
    0.04797470f, -0.08680707f, -0.01644643f, 0.15098737f, -0.05177010f, -0.02570986f, -0.22718628f, -0.10114831f, 
    -0.21679641f, -0.17379497f, 0.00355128f, 0.01387828f, 0.09388187f, 0.04178197f, 0.05435789f, -0.07419915f, 
    -0.02084289f, 0.30510983f, -0.08170383f, 0.02140871f, -0.08743414f, -0.05672716f, 0.01390930f, -0.01735139f, 
    -0.33491084f, -0.20288134f, 0.05210857f, 0.15394749f, -0.01733503f, 0.04786682f, -0.13478157f, 0.07244460f, 
    0.01364657f, -0.14571275f, -0.11425671f, 0.06814861f, -0.06304316f, -0.01097966f, -0.00193220f, -0.01305985f, 
    0.01319304f, -0.03384082f, -0.22015134f, -0.09911147f, 0.30103466f, -0.32428131f, -0.05117474f, -0.27828103f, 
    -0.05375618f, -0.05468591f, 0.00165033f, -0.04580221f, -0.00693292f, -0.02301795f, 0.09168405f, 0.04301486f, 
    0.19516443f, 0.03931591f, 0.04756406f, 0.06953434f, 0.00476618f, -0.01745667f, 0.04361926f, 0.08682189f, 
    -0.02736709f, -0.00808821f, -0.10762785f, 0.04165531f, -0.22952403f, -0.30494463f, -0.05272332f, 0.16299187f, 
    0.03315263f, 0.09676251f, 0.03729970f, -0.15483133f, -0.05902719f, 0.05097324f, -0.32692617f, -0.11528172f, 
    0.06714953f, -0.05785980f, -0.07810466f, 0.10649981f, -0.03793133f, 0.05349710f, 0.07323893f, 0.23271464f, 
    0.14338550f, -0.03319107f, -0.09883737f, -0.07404639f, -0.03211679f, -0.06347234f, 0.04752667f, -0.00911497f, 
    -0.33374318f, -0.22954661f, -0.02832009f, 0.07085846f, 0.02435316f, 0.05553172f, 0.01435209f, 0.06387955f, 
    0.24647354f, 0.26417026f, 0.02711259f, -0.10108528f, 0.02313563f, 0.04225604f, 0.06657954f, 0.02517436f, 
    0.03267455f, -0.01545143f, -0.02815091f, 0.02660744f, -0.21282062f, 0.01949095f, 0.09656647f, -0.06360938f, 
    0.01753066f, 0.12848663f, 0.31414431f, -0.32076505f, -0.04896510f, -0.22528554f, 0.11573536f, 0.19800586f, 
    0.07232211f, -0.02617344f, 0.14636782f, 0.03470211f, 0.09102777f, 0.15144840f, 0.00125042f, 0.14540869f, 
    -0.12399822f, -0.00042808f, 0.04193742f, 0.00238332f, 0.14320688f, 0.12563483f, 0.07290788f, -0.03630393f, 
    -0.01870968f, 0.04715995f, -0.01807888f, 0.11916374f, 0.06009653f, 0.19862367f, 0.11166051f, -0.00508558f, 
    -0.12901716f, -0.21012530f, 0.02761200f, 0.06016984f, 0.01019145f, 0.07874077f, 0.17939979f, -0.14232442f, 
    -0.07111993f, 0.00073991f, 0.07305704f, -0.02883739f, 0.28985217f, 0.04047932f, -0.01283140f, 0.01496567f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.07475813f, -0.04372633f, 0.03248166f, -0.18591648f, 0.20716943f, 0.06784280f, -0.00402298f, -0.01986165f, 
    -0.01663070f, -0.04160053f, 0.02228940f, 0.08920034f, 0.28234035f, -0.05597724f, -0.02683981f, 0.02997522f, 
    0.14190833f, -0.01896651f, 0.09740692f, -0.01231309f, 0.00812246f, 0.11273315f, -0.00313894f, -0.08885462f, 
    -0.05473975f, -0.01406759f, -0.00577179f, -0.00624271f, 0.16510543f, 0.08796523f, -0.03179415f, 0.06923641f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.14535284f, -0.04894111f, -0.17723151f, -0.10057621f, -0.01820110f, 0.18428530f, 0.12326043f, -0.97684360f, 
    -0.10569443f, -0.10239813f, 0.01104989f, -0.06630906f, -0.10338365f, 0.31492531f, 0.17164388f, -0.31296468f, 
    -0.14098863f, 0.14554182f, 0.06648041f, -0.04566876f, 0.02379906f, 0.23094121f, -0.03518150f, 0.13154136f, 
    -0.08954036f, 0.16031666f, 0.11429647f, 0.03104945f, 0.39045465f, 0.27165893f, 0.12277818f, 0.33115667f, 
    0.02556308f, 0.06098280f, 0.09631283f, 0.03202388f, 0.24713142f, -0.22752042f, -0.04976228f, 0.52197814f, 
    0.14770652f, -0.04205943f, -0.20842817f, -0.19828430f, -0.08416489f, -0.03152444f, -0.17554557f, 0.16412029f, 
    0.04955276f, -0.18218905f, 0.09601206f, 0.12596948f, 0.29771116f, 0.30207777f, -0.03753311f, 0.19537194f, 
    -0.11061915f, -0.02508967f, -0.12573056f, 0.11645658f, 0.09949281f, -0.05170758f, 0.20894133f, -0.11506678f, 
    -0.06020134f, -0.09793182f, 0.13455005f, -0.16910313f, -0.04256285f, 0.00583732f, -0.15305980f, -0.00998522f, 
    0.00563788f, -0.06304576f, -0.14664185f, -0.11774737f, -0.02362087f, 0.06625791f, 0.02353950f, 0.01150715f, 
    0.05563553f, 0.13050303f, 0.07742190f, 0.15195058f, -0.05461816f, -0.03360068f, 0.04766193f, 0.00004645f, 
    -0.15366420f, 0.10610789f, 0.05512376f, -0.09396589f, -0.03805239f, -0.03946448f, 0.04916221f, -0.06580009f, 
    0.40522224f, 0.18105415f, 0.15366188f, 0.18985920f, 0.26081115f, -0.00928693f, 0.17672937f, -0.09914994f, 
    -0.03653032f, 0.13569833f, -0.35704702f, 0.03878790f, -0.12900114f, -0.10167338f, 0.14270139f, 0.34496930f, 
    -0.20541966f, -0.03372612f, 0.12105709f, -0.12726688f, 0.00094976f, 0.22544098f, 0.12832010f, -0.02934369f, 
    0.01783652f, 0.11356190f, -0.15412781f, -0.10872083f, 0.23787387f, 0.33819684f, 0.36412823f, -0.28486484f, 
    -0.01756382f, -0.17793021f, -0.03773949f, -0.09178623f, 0.07498113f, 0.02533733f, -0.02268732f, -0.35494572f, 
    0.00199433f, -0.01042111f, 0.10411288f, 0.30187613f, 0.11519001f, 0.29010251f, -0.07535956f, 0.20357782f, 
    0.12542403f, 0.20305794f, -0.30645898f, 0.01601477f, -0.27089074f, -0.46697527f, 0.12674020f, -0.09537479f, 
    0.04936426f, 0.15204819f, 0.14897907f, 0.00121868f, 0.38915843f, 0.15471421f, -0.26777038f, 0.19043782f, 
    0.09088636f, -0.06562742f, 0.27615380f, -0.26187575f, -0.04218754f, 0.06787955f, 0.13051127f, 0.01538679f, 
    0.00808515f, -0.15151368f, 0.20865387f, 0.15907387f, 0.26068905f, -0.14889102f, 0.15951784f, 0.15092742f, 
    0.28146550f, -0.05998573f, 0.07644199f, 0.04293580f, -0.17104837f, -0.10635807f, 0.13118181f, -0.01355860f, 
    0.17026152f, -0.03722580f, -0.08993286f, 0.15481262f, -0.22682948f, -0.36078608f, -0.15211803f, 0.01745969f, 
    0.02541917f, -0.24992603f, 0.21089612f, -0.18954851f, 0.20886625f, 0.08600634f, 0.21288593f, -0.14771798f, 
    -0.06352536f, -0.12214600f, 0.05524506f, -0.34390703f, 0.06333796f, -0.00985802f, 0.10385276f, -0.11835493f, 
    0.23113424f, 0.12762573f, -0.55741805f, 0.16721764f, 0.16099367f, 0.09598236f, 0.16656533f, 0.12168900f, 
    -0.01418053f, 0.01500261f, -0.02830592f, 0.00355028f, -0.59363753f, -0.27158132f, 0.16628151f, 0.07046276f, 
    0.01220842f, 0.19675778f, 0.08435598f, -0.06532227f, 0.09710027f, 0.11541625f, 0.04731159f, 0.23139085f, 
    -0.03686621f, -0.13174637f, -0.01512128f, 0.07104640f, 0.20193613f, -0.00886981f, -0.14381523f, -0.20847104f, 
    0.03910160f, 0.03944788f, 0.39423391f, 0.02132828f, -0.22697428f, -0.02594350f, 0.01991420f, -0.16681090f, 
    -0.09546616f, 0.15590370f, -0.11415489f, -0.09347777f, 0.23188654f, 0.33764625f, -0.04022538f, -0.33320525f, 
    0.54840481f, -0.24725643f, -0.07783056f, -0.28428850f, 0.31083286f, 0.00148453f, -0.09676229f, 0.23350225f, 
    -0.12750669f, -0.06073641f, -0.18795724f, 0.19926877f, -0.19972934f, -0.06837159f, -0.12997641f, -0.04190984f, 
    0.00803153f, -0.03106721f, 0.06545786f, -0.16191182f, 0.25748745f, 0.07075774f, 0.14031588f, -0.10390402f, 
    0.09456343f, -0.12863916f, -0.12459150f, 0.06972212f, -0.34411016f, 0.22826511f, 0.40178457f, 0.00251066f, 
    -0.11620421f, -0.02085280f, -0.10187078f, -0.19066754f, 0.22685248f, -0.00529064f, -0.07104733f, -0.17011468f, 
    0.15809084f, -0.10925902f, -0.04740964f, 0.01856375f, 0.05815382f, -0.16146015f, -0.12224441f, 0.07975838f, 
    0.14314893f, 0.12747601f, 0.20280732f, 0.04344200f, -0.15761799f, -0.09023415f, -0.03084136f, -0.15864295f, 
    0.04314036f, 0.04245579f, 0.11918237f, 0.00145063f, -0.07792825f, -0.15462163f, 0.06265485f, 0.07600857f, 
    -0.03845607f, 0.06647721f, -0.10765475f, 0.16834788f, -0.06842496f, 0.10783964f, -0.27450532f, -0.07809441f, 
    -0.11712363f, 0.01935137f, 0.26944253f, 0.20329684f, 0.00445723f, 0.04765330f, -0.06061416f, -0.11925033f, 
    -0.29771450f, -0.15278341f, 0.33997697f, -0.17568056f, 0.05476674f, -0.22759537f, -0.06251199f, 0.01841787f, 
    0.14785260f, -0.04184153f, 0.14416163f, 0.12931298f, -0.11251661f, 0.37202480f, 0.24704191f, -0.23445123f, 
    -0.13547567f, 0.16895418f, 0.08891181f, -0.24808992f, 0.09690844f, 0.09773367f, -0.02967376f, 0.51206803f, 
    0.16849943f, -0.11254422f, 0.19843316f, 0.24211492f, 0.13771883f, -0.27657792f, 0.01672664f, 0.04559054f, 
    0.37423864f, -0.18923637f, -0.13092259f, 0.09210416f, 0.09657695f, -0.23341818f, -0.08550692f, 0.12131689f, 
    -0.06333282f, -0.14714932f, 0.14327218f, -0.01014610f, 0.01336543f, -0.35146594f, -0.03103239f, 0.10993125f, 
    -0.16377527f, 0.00382742f, 0.07797241f, 0.10657346f, 0.01942527f, -0.10493773f, -0.10634244f, -0.03838528f, 
    0.03723360f, -0.16642343f, 0.01260094f, 0.10329574f, -0.09371960f, -0.13218233f, 0.13977765f, -0.18273744f, 
    -0.20255163f, -0.02567187f, -0.12705912f, -0.16062808f, 0.13851641f, -0.15420675f, 0.05253533f, 0.01801400f, 
    0.03014410f, -0.08827394f, -0.13411330f, -0.04069236f, -0.01654767f, -0.05986457f, -0.06797903f, -0.11513486f, 
    0.14405903f, -0.27667758f, 0.08896832f, -0.16028039f, -0.16635135f, 0.26574007f, 0.09253085f, -0.09584626f, 
    -0.10300604f, -0.12664369f, -0.15036874f, 0.02683480f, 0.17262684f, 0.15189180f, 0.14437497f, -0.00545904f, 
    -0.06915787f, -0.14100969f, -0.13154489f, -0.07103971f, 0.00938870f, 0.07092363f, 0.09306110f, -0.14588839f, 
    -0.07758159f, -0.00072200f, 0.01035336f, -0.16690525f, -0.19581416f, -0.24237218f, -0.08752737f, 0.44097897f, 
    -0.23341651f, -0.17427298f, -0.16135448f, -0.05916108f, 0.09909754f, -0.13054858f, 0.05727686f, -0.21110912f, 
    0.10370609f, -0.04286368f, -0.22014607f, -0.04011712f, 0.13142334f, -0.20555621f, -0.16830933f, 0.09549186f, 
    -0.09036808f, -0.00355230f, 0.01949699f, 0.09639106f, -0.15085463f, 0.04338278f, -0.00030662f, -0.09427021f, 
    0.04475104f, 0.06867367f, 0.00964183f, -0.05863910f, -0.08518428f, -0.13247719f, -0.07445936f, -0.06823213f, 
    -0.03844260f, 0.25820228f, 0.08405302f, -0.06022334f, 0.07478929f, 0.16437005f, -0.35350439f, -0.41310823f, 
    -0.14448957f, -0.04227573f, 0.35875919f, -0.01332124f, 0.08431264f, 0.14892024f, -0.06897048f, 0.04402801f, 
    0.00339451f, -0.08779795f, -0.38147512f, 0.11067098f, 0.03723857f, -0.07353994f, 0.10261542f, -0.00102549f, 
    0.08174442f, 0.13310596f, 0.08554876f, -0.16989142f, -0.07585191f, -0.20967814f, 0.31220427f, -0.08081196f, 
    -0.06555343f, 0.17489247f, 0.12563470f, 0.01527517f, 0.04301811f, 0.26516277f, -0.32095513f, -0.00752458f, 
    -0.05280473f, 0.03979210f, 0.18161261f, 0.19363061f, 0.06964634f, -0.35730019f, 0.01354331f, 0.03070489f, 
    -0.09240024f, -0.05982592f, 0.21273743f, -0.07148423f, 0.02856923f, -0.03627962f, 0.11591910f, 0.16166022f, 
    0.17041014f, -0.02659281f, 0.12593853f, -0.06460591f, 0.05590225f, -0.06272638f, 0.15374188f, -0.36076894f, 
    -0.25674447f, 0.07584935f, 0.09403856f, -0.17815451f, 0.31089038f, -0.31295428f, 0.10352629f, 0.60371107f, 
    -0.03478110f, -0.07278771f, 0.02147052f, 0.01753413f, 0.09637810f, -0.09850428f, 0.05844546f, 0.17917192f, 
    0.27631733f, -0.09522663f, 0.01057151f, -0.13097580f, 0.20329018f, 0.24080871f, -0.14611974f, 0.14392723f, 
    -0.10796307f, 0.10722025f, 0.12282924f, -0.10124577f, 0.10042009f, -0.38812557f, -0.23258415f, -0.05700305f, 
    -0.07428677f, -0.02956730f, 0.17482087f, -0.06067458f, -0.19281407f, 0.14859286f, 0.03765300f, -0.05489087f, 
    0.01562187f, 0.10856190f, 0.29361758f, 0.11089165f, 0.17882153f, -0.10569880f, 0.03053585f, -0.00924864f, 
    0.04423468f, -0.10615469f, 0.22253406f, 0.12448888f, -0.10173580f, 0.17376757f, -0.05876949f, 0.11992955f, 
    0.12514059f, 0.08436095f, 0.04343293f, 0.11409278f, -0.34092221f, -0.32070217f, 0.08174292f, -0.13987921f, 
    -0.22652848f, -0.16142747f, -0.23478557f, 0.10221186f, -0.13444687f, -0.18420847f, 0.06412253f, -0.03725073f, 
    0.15819478f, -0.09147459f, -0.07683471f, -0.09999987f, 0.05757271f, -0.15981211f, 0.05475356f, 0.07999155f, 
    0.03486941f, -0.11928605f, -0.12934659f, 0.00722762f, -0.01639344f, -0.05903434f, -0.03248902f, -0.10478623f, 
    0.06621889f, -0.06740326f, -0.17587022f, -0.07550503f, -0.17399895f, -0.19462027f, 0.16179590f, -0.08152205f, 
    -0.08910953f, 0.28069121f, -0.11648890f, 0.07345729f, -0.05690704f, 0.01876988f, 0.08476932f, -0.03861796f, 
    -0.09082916f, -0.12534378f, 0.25652605f, -0.28554988f, -0.19366579f, -0.18038371f, 0.00740980f, 0.01965505f, 
    -0.01091656f, -0.08352563f, -0.46701416f, 0.12316628f, 0.40409598f, 0.00353557f, 0.01704163f, 0.12746304f, 
    0.13813874f, 0.13127907f, 0.06220295f, 0.02986106f, -0.35946247f, -0.33276108f, 0.30369055f, 0.11576945f, 
    -0.07478007f, -0.14258298f, 0.08003893f, -0.20523268f, 0.10820795f, -0.17183980f, 0.08290411f, -0.00946907f, 
    0.10801808f, 0.08740579f, 0.12495197f, -0.16093849f, 0.29428414f, 0.04071402f, -0.13543491f, -0.29267511f, 
    -0.15317757f, -0.00387629f, -0.51495355f, -0.13823143f, 0.18915713f, 0.27734157f, 0.16993630f, -0.11998414f, 
    0.04274131f, 0.07236034f, -0.05496758f, -0.00410833f, -0.40035138f, -0.22238809f, -0.21763541f, 0.34471366f, 
    -0.11055171f, 0.14632815f, 0.04707963f, -0.05665772f, -0.01158214f, -0.09933426f, 0.14225814f, -0.11228179f, 
    0.00716743f, 0.03001745f, 0.00298348f, -0.08697731f, -0.01725589f, -0.17208494f, -0.03761134f, -0.04294138f, 
    -0.04505676f, -0.04918940f, -0.02683274f, 0.16273838f, -0.18811230f, -0.19770132f, -0.04259586f, -0.08279595f, 
    0.04269305f, 0.09341149f, -0.14135614f, -0.16160442f, -0.20481123f, 0.04594521f, -0.18822102f, 0.01748329f, 
    0.28844422f, -0.16855499f, 0.11623597f, -0.32694027f, 0.29070309f, -0.13061441f, 0.08719289f, 0.30652088f, 
    -0.06101265f, 0.02812057f, -0.08903866f, -0.30148676f, 0.21468666f, -0.05419810f, 0.12168641f, -0.03878792f, 
    0.12866561f, 0.03128101f, 0.18800971f, -0.16316357f, 0.07758120f, 0.35853046f, -0.17006043f, -0.06182453f, 
    -0.15858392f, -0.11726259f, 0.01911165f, -0.02329597f, -0.23333836f, -0.13020281f, -0.10804177f, -0.10902647f, 
    -0.58841187f, 0.22824410f, 0.00158498f, 0.04385237f, 0.15551239f, -0.13845053f, 0.26467234f, 0.48679242f, 
    -0.09315749f, -0.18329090f, -0.25911897f, 0.31374174f, -0.00799854f, 0.07264437f, 0.00223758f, -0.02792198f, 
    -0.05825872f, -0.13353990f, 0.04421386f, -0.02512409f, 0.11207642f, 0.14123100f, -0.15587460f, 0.16367932f, 
    -0.01123300f, -0.05750467f, 0.10986653f, 0.11261231f, 0.39701334f, -0.06872322f, -0.54648799f, 0.03029271f, 
    0.30414149f, 0.09709001f, -0.06615181f, -0.33960721f, 0.36887187f, 0.29506016f, -0.17258087f, -0.20443697f, 
    0.01693567f, -0.00566893f, 0.01011141f, 0.15428443f, 0.12734999f, -0.23261306f, 0.12335690f, 0.34017938f, 
    -0.12937744f, -0.19595248f, -0.05668782f, -0.02083809f, -0.08569805f, 0.13104458f, 0.16476810f, 0.03159669f, 
    0.17324458f, -0.17572968f, 0.16558433f, 0.05345015f, -0.19867580f, -0.23862417f, -0.07555734f, 0.09957698f, 
    -0.17238680f, -0.11138961f, 0.13695617f, -0.20569536f, -0.09931902f, -0.06678331f, -0.17946218f, -0.04255237f, 
    0.10526320f, -0.07649793f, -0.08503968f, 0.00955647f, -0.08111705f, -0.08949912f, -0.01591264f, 0.00128806f, 
    0.07032146f, -0.12456913f, 0.12973437f, -0.15900563f, 0.02038766f, -0.09167085f, 0.01829527f, -0.15103666f, 
    0.10124530f, -0.11648697f, 0.12772493f, -0.16883279f, 0.06531514f, 0.03930686f, -0.06763783f, -0.02961276f, 
    0.37719020f, 0.07209901f, 0.11739956f, 0.11634649f, -0.13239564f, 0.19114661f, -0.20368670f, -0.26594666f, 
    -0.13186857f, 0.12635924f, 0.10599782f, -0.10319693f, -0.12359141f, -0.01288520f, -0.11429759f, 0.18520382f, 
    -0.15500483f, -0.12537408f, 0.18738118f, -0.00727261f, 0.12113880f, 0.11831897f, 0.15685545f, -0.06880256f, 
    0.06751117f, -0.06243076f, -0.07500794f, -0.12631324f, 0.09195130f, -0.07894761f, 0.18584344f, -0.05132651f, 
    -0.04317756f, 0.12339721f, 0.26901698f, -0.03378025f, 0.40271568f, -0.03130020f, -0.08829803f, -0.70163482f, 
    0.16330937f, -0.13236649f, 0.21116449f, -0.15016904f, -0.00714869f, -0.07875437f, 0.08007240f, 0.10764132f, 
    0.24449204f, -0.03386378f, -0.08336904f, -0.14075281f, 0.03732660f, -0.01997380f, -0.09096555f, 0.16867247f, 
    -0.15332177f, 0.15229112f, -0.16104373f, -0.16397834f, -0.07295430f, -0.10661428f, -0.17345792f, 0.18797199f, 
    0.33905166f, -0.02955467f, 0.02486092f, -0.17817777f, -0.21994424f, -0.11229761f, 0.09294748f, 0.54102939f, 
    0.13345987f, 0.05265381f, 0.00917425f, 0.24954447f, 0.12508737f, 0.24618134f, 0.10755986f, -0.12677863f, 
    0.29290947f, 0.10064671f, 0.26717681f, -0.03686037f, -0.08537605f, -0.24285680f, -0.13993396f, -0.03540382f, 
    -0.15828624f, -0.03750020f, -0.08399521f, 0.00444410f, 0.00611282f, 0.35090980f, 0.02484920f, -0.04874346f, 
    0.17753023f, 0.00500305f, -0.15407367f, 0.32634756f, -0.28851825f, 0.08862124f, 0.00636891f, 0.10586811f, 
    0.02089662f, -0.17460221f, 0.00511195f, -0.00883693f, -0.16770707f, 0.03858827f, 0.11783409f, 0.10814041f, 
    -0.13536490f, -0.01544820f, 0.17412567f, 0.17529772f, 0.24872892f, 0.16232634f, 0.03542778f, 0.13120998f, 
    -0.02898373f, 0.07280648f, -0.01523459f, -0.00759147f, -0.11027250f, 0.16660932f, 0.29509035f, 0.06618996f, 
    -0.14650756f, 0.04027711f, 0.14724781f, -0.11937610f, -0.06439715f, -0.08341878f, 0.09935528f, -0.11465751f, 
    0.00725721f, -0.06180579f, -0.12080580f, -0.06074525f, 0.01610437f, 0.07972570f, 0.11013894f, -0.12110448f, 
    0.11619464f, -0.16773777f, -0.06541543f, 0.14362557f, -0.17882188f, -0.03248383f, 0.06813591f, 0.00364239f, 
    -0.04929732f, -0.14247547f, -0.05840011f, -0.10556525f, 0.06271425f, -0.04770373f, 0.05276437f, -0.03429858f, 
    -0.07087775f, -0.20500590f, -0.21242902f, -0.05917994f, -0.00831694f, -0.20022814f, 0.27132672f, -0.19574401f, 
    0.07080765f, -0.03898285f, 0.19590765f, -0.15242751f, 0.11017592f, 0.25749806f, 0.05614295f, -0.19293442f, 
    -0.19195154f, 0.13360150f, -0.01534064f, 0.02957598f, 0.21698369f, 0.42599738f, 0.04213345f, -0.13707733f, 
    0.09390105f, -0.11435743f, -0.17187151f, 0.03889644f, 0.25396854f, 0.17928687f, 0.23778802f, -0.00494037f, 
    0.04887664f, 0.17645654f, -0.08087876f, -0.21697280f, -0.32406276f, -0.12458257f, -0.27620202f, 0.16300271f, 
    0.01466908f, 0.05699584f, 0.46051988f, 0.00583976f, 0.28093517f, 0.10497506f, 0.09950478f, -0.07302859f, 
    0.00744319f, 0.11583070f, -0.53945500f, -0.13727711f, 0.22593683f, 0.32518324f, -0.07226744f, -0.02280096f, 
    -0.03823103f, -0.13331057f, -0.11062973f, -0.03892078f, -0.15820332f, -0.32904047f, -0.19272855f, 0.26835045f, 
    0.07606407f, -0.15680034f, -0.05907105f, -0.20893744f, 0.13808994f, -0.01487025f, 0.01196759f, -0.05622633f, 
    -0.00592825f, -0.16092286f, 0.17292196f, -0.19765157f, 0.11529092f, 0.21151054f, -0.01688951f, -0.36923999f, 
    -0.14357953f, 0.23228207f, -0.51209545f, 0.12302481f, 0.19788726f, 0.38924578f, 0.10430565f, 0.13469152f, 
    0.10298885f, -0.14626192f, -0.10045440f, -0.06479171f, -0.10585941f, -0.11887717f, 0.10357931f, 0.29211700f, 
    -0.29587325f, 0.08442636f, -0.01753837f, 0.17109510f, -0.38779789f, 0.32821682f, -0.35343561f, -0.19181727f, 
    -0.08862930f, 0.11592649f, 0.34444171f, 0.05154774f, 0.04461407f, -0.00733750f, 0.15357880f, -0.41587871f, 
    0.29723722f, 0.13318528f, 0.07358462f, 0.16121608f, -0.27202716f, 0.05281696f, 0.00143373f, -0.14202620f, 
    0.04628300f, 0.05738552f, 0.17525129f, 0.09259114f, 0.29635066f, -0.04872448f, -0.10375714f, -0.16177849f, 
    0.41579375f, 0.01099696f, -0.07100055f, 0.19796607f, -0.34948635f, 0.21178563f, -0.06697062f, -0.24322613f, 
    -0.00702914f, 0.12153299f, 0.13371217f, -0.04818956f, 0.16092746f, 0.23539101f, 0.08595087f, -0.33460781f, 
    -0.23659836f, 0.16724871f, 0.28234911f, 0.08710715f, -0.13240241f, 0.14353330f, 0.16637453f, 0.04182044f, 
    0.06162224f, -0.11309608f, 0.14888662f, 0.15779404f, 0.03507831f, 0.28467152f, 0.45276240f, -0.08001623f, 
    0.24910285f, -0.00388205f, -0.21761736f, -0.06135560f, -0.45189759f, -0.04402196f, -0.01039068f, 0.25473312f, 
    -0.00502785f, 0.01035193f, 0.22866452f, 0.14140092f, 0.13990758f, 0.00521554f, 0.05504279f, 0.03272463f, 
    -0.09571515f, 0.10110859f, 0.18532923f, -0.15325002f, 0.13745220f, 0.07502697f, 0.11878423f, -0.13151465f, 
    -0.12359984f, -0.08397264f, 0.11374693f, 0.01460243f, -0.03822380f, 0.05144952f, 0.19096565f, -0.16836020f, 
    -0.33814508f, 0.18539493f, 0.09830024f, -0.43495741f, 0.33761501f, 0.00029929f, -0.06871847f, -0.03352831f, 
    0.13413869f, -0.13030022f, -0.03022677f, 0.07649259f, 0.32001552f, -0.40140593f, -0.02165891f, -0.13825461f, 
    0.27052554f, 0.06904028f, 0.10292772f, -0.00997643f, 0.07910824f, 0.04237626f, -0.04025634f, -0.05533566f, 
    -0.13380834f, -0.16061379f, 0.00446788f, -0.05500372f, 0.36034587f, -0.16103747f, -0.18402863f, 0.07114579f, 
    0.03145209f, -0.44218570f, -0.39799556f, -0.22964722f, 0.20740345f, -0.10549846f, 0.19118948f, -0.23291764f, 
    -0.06716446f, -0.16206641f, -0.10221468f, -0.19893298f, -0.03786504f, 0.33404720f, -0.09050434f, -0.28349897f, 
    0.06084941f, 0.29958364f, -0.28376919f, 0.16722906f, 0.25038952f, 0.09048539f, -0.13763563f, -0.03502675f, 
    0.09086826f, 0.02100266f, 0.13695186f, -0.03465322f, 0.27604955f, 0.26045349f, -0.17002641f, 0.27663094f, 
    -0.25965244f, 0.07440542f, 0.13880177f, 0.03600869f, 0.04922641f, 0.29103890f, -0.06918753f, -0.44727930f, 
    -0.01918806f, -0.11280901f, 0.20599361f, 0.27042437f, 0.18636142f, 0.06288455f, 0.11827061f, -0.16840307f, 
    0.06855366f, 0.01883201f, 0.21445884f, -0.09933259f, -0.30420992f, -0.21914549f, -0.04282045f, -0.06141212f, 
    0.16160257f, 0.10991364f, -0.12768903f, 0.11760061f, -0.08022506f, -0.15282831f, -0.01286931f, 0.04622392f, 
    0.37747744f, 0.12261511f, -0.07562828f, 0.03719925f, -0.48560461f, 0.21045446f, -0.26180264f, 0.38014004f, 
    -0.07148498f, 0.10016254f, 0.23719648f, -0.00893368f, 0.03235013f, 0.11571204f, 0.16248572f, 0.15896054f, 
    -0.12308876f, -0.17029990f, 0.16047613f, 0.12603463f, 0.09660958f, 0.19218485f, 0.04114985f, 0.00232552f, 
    0.13784629f, 0.16203143f, -0.09732955f, -0.14932698f, -0.19833750f, 0.04487583f, 0.27498087f, -0.15231176f, 
    -0.13435102f, 0.08111169f, -0.03917263f, -0.09909489f, 0.03780657f, -0.16566317f, 0.15067175f, 0.13629980f, 
    -0.09121259f, -0.03367892f, -0.09177338f, -0.15079744f, -0.17780173f, -0.16847949f, -0.13249728f, -0.04803949f, 
    -0.15502074f, 0.08624370f, -0.12741737f, -0.06364916f, 0.08655556f, 0.03432731f, 0.02718267f, -0.07263301f, 
    -0.03876933f, -0.08667278f, 0.10067312f, -0.00332372f, 0.01184341f, -0.03581279f, 0.09676913f, -0.07194508f, 
    0.25381312f, 0.09167495f, -0.16597523f, -0.19005755f, -0.17326532f, 0.36234754f, -0.11797415f, -0.17645048f, 
    0.00188647f, 0.05153304f, 0.07589476f, 0.09101705f, 0.23963673f, -0.08948077f, -0.07436622f, 0.15124986f, 
    -0.04793407f, 0.03982956f, 0.24926360f, -0.06719285f, -0.10360195f, 0.12050788f, 0.07810002f, -0.13233328f, 
    -0.02346469f, 0.03003730f, -0.12267630f, 0.17357610f, -0.20788874f, -0.25719821f, 0.14469036f, -0.04299938f, 
    -0.05545330f, -0.03772210f, -0.01029167f, -0.07575845f, -0.06548562f, 0.01601610f, -0.16336504f, 0.14622457f, 
    0.08502134f, 0.12256698f, -0.16191557f, -0.03792964f, -0.06080526f, -0.01177682f, -0.16937472f, -0.00126997f, 
    0.00318150f, 0.02107861f, -0.06581664f, -0.04076399f, -0.03367072f, -0.13468817f, 0.15777460f, 0.01675295f, 
    0.08190102f, -0.14905098f, 0.14935619f, 0.07667681f, 0.09111854f, 0.00409189f, 0.06144469f, -0.13778995f, 
    -0.16956814f, 0.19386297f, -0.01841336f, -0.14573419f, -0.14646980f, 0.19175094f, -0.09564835f, -0.09801836f, 
    -0.15203097f, -0.14637643f, 0.00671108f, 0.26102048f, 0.10570683f, -0.03032998f, -0.02541085f, -0.18728098f, 
    0.02313380f, 0.15874909f, 0.29437608f, -0.09792648f, -0.14094220f, -0.14076684f, 0.12735134f, -0.12684543f, 
    -0.04122426f, -0.14784633f, -0.09721242f, -0.16311340f, 0.31524149f, 0.28087109f, 0.10066664f, -0.02665400f, 
    0.27163029f, 0.09250848f, 0.04041374f, -0.19749616f, 0.25895935f, 0.20457242f, 0.02783627f, -0.05846329f, 
    -0.01147955f, -0.16384763f, -0.13495797f, 0.06474147f, -0.01457594f, -0.12630999f, 0.02718457f, 0.11940910f, 
    0.06681965f, 0.17746130f, 0.17837976f, 0.00746204f, -0.27854460f, -0.18900570f, 0.07300331f, 0.02861717f, 
    -0.04721605f, 0.07251062f, -0.04011356f, -0.03758036f, 0.14689772f, -0.01757758f, -0.09946059f, 0.04159296f, 
    -0.11182027f, 0.08873098f, -0.18980473f, 0.11764142f, -0.05895875f, -0.19633184f, 0.10002512f, 0.66529524f, 
    -0.04629656f, 0.00365198f, 0.18556143f, -0.09273890f, 0.13414529f, -0.14425634f, -0.02263199f, -0.35676453f, 
    -0.10921728f, -0.02113272f, 0.33241659f, -0.14884382f, 0.27825534f, 0.24187672f, 0.11413908f, 0.11731889f, 
    -0.13494615f, -0.08665594f, 0.06843628f, -0.08285156f, -0.09906240f, 0.36376512f, -0.02901826f, -0.14031596f, 
    0.18830982f, -0.06993188f, -0.13015699f, 0.10712756f, -0.12250128f, 0.22655739f, -0.00834397f, 0.32115534f, 
    -0.04883575f, 0.00038556f, 0.01719144f, 0.33509690f, 0.25492766f, 0.15368299f, 0.13728476f, -0.25494078f, 
    0.19843830f, 0.09526786f, 0.19169569f, -0.00760715f, -0.29252911f, -0.18706371f, 0.04169047f, 0.11081323f, 
    -0.03930371f, -0.06664996f, 0.09537749f, -0.08559478f, 0.17150047f, 0.18132056f, -0.15708570f, -0.12406270f, 
    -0.15155573f, 0.18776532f, 0.20419325f, -0.21652392f, 0.31440207f, 0.25741163f, -0.04337161f, 0.35283181f, 
    0.00190287f, 0.07834125f, -0.07584757f, 0.22638986f, 0.25542101f, -0.12868752f, 0.15621202f, -0.11764683f, 
    -0.01924221f, 0.12946357f, 0.26139781f, 0.14103210f, -0.22762483f, 0.08618385f, -0.12766112f, 0.03392582f, 
    0.05970063f, 0.11505958f, 0.14930502f, -0.01999648f, 0.03566591f, 0.12223168f, -0.33104420f, -0.14080796f, 
    -0.04690659f, -0.05904644f, 0.10417297f, -0.29827765f, 0.34027100f, -0.08250612f, 0.22910222f, -0.33632648f, 
    -0.17873544f, 0.12468039f, -0.12970208f, 0.14372113f, 0.26655406f, 0.17012927f, 0.11017237f, -0.42987770f, 
    0.09166797f, 0.29322380f, -0.18224424f, 0.08017372f, -0.01940764f, 0.05314353f, 0.03877451f, -0.03962630f, 
    0.06191674f, 0.12798646f, -0.03675190f, -0.13414206f, 0.21365559f, 0.16962998f, -0.09933369f, 0.09716516f, 
    -0.48103765f, 0.04667579f, -0.05424765f, 0.17278460f, -0.22112088f, -0.12523401f, 0.27273998f, 0.40901446f, 
    0.04705612f, 0.04469907f, -0.01151801f, 0.08331577f, -0.08177656f, 0.04690475f, -0.15057093f, -0.22604838f, 
    -0.18713978f, 0.06123694f, -0.17784132f, -0.11684482f, 0.17327638f, 0.27505043f, 0.13905273f, -0.10606941f, 
    -0.07747529f, -0.14071208f, 0.05696399f, -0.11737505f, 0.17830853f, 0.31035057f, -0.31721216f, 0.11071035f, 
    0.25361302f, -0.25382987f, 0.15015598f, 0.02166285f, 0.25448519f, -0.13651152f, 0.26550364f, 0.14741755f, 
    -0.17299299f, -0.08129002f, 0.09876344f, -0.19547234f, 0.08073536f, 0.14684412f, -0.06885815f, -0.34109750f, 
    -0.21726742f, -0.06047024f, -0.47341248f, 0.03784755f, 0.25400159f, 0.11697979f, -0.17664139f, -0.07903887f, 
    0.07678411f, 0.04595119f, 0.14024127f, -0.14965746f, -0.27483591f, 0.11649479f, -0.13357818f, 0.30670246f, 
    -0.10342783f, 0.27508593f, 0.09397227f, 0.31378695f, -0.51666582f, 0.31906590f, -0.40983033f, 0.13251650f, 
    -0.02065662f, -0.10326365f, 0.00224338f, 0.18787690f, 0.16790192f, -0.19173284f, -0.12704740f, -0.27101290f, 
    -0.26970908f, -0.09641089f, -0.14710282f, 0.12320586f, 0.15199202f, -0.13910677f, 0.15923803f, 0.01382531f, 
    -0.04706929f, 0.06780699f, -0.04293648f, 0.09496291f, -0.26700503f, 0.26746580f, 0.15916693f, -0.23963596f, 
    0.17686856f, -0.01476791f, 0.29626885f, -0.20938119f, 0.27324858f, -0.01521549f, -0.03301918f, 0.41632703f, 
    -0.07885402f, 0.07577544f, 0.15967828f, -0.06843528f, 0.10328911f, -0.20536792f, 0.05381524f, -0.03419569f, 
    0.28146750f, 0.03447154f, -0.02791785f, -0.03811506f, -0.16557850f, -0.00301653f, 0.12681232f, -0.03868103f, 
    0.16629207f, -0.07546776f, 0.11929470f, 0.03842214f, -0.10871889f, -0.12579037f, -0.26290593f, 0.16406927f, 
    -0.21853502f, -0.27402928f, 0.19551121f, 0.02407300f, 0.17371200f, -0.04978297f, -0.09442407f, -0.11967056f, 
    0.07921037f, 0.03850423f, -0.16845994f, 0.05406221f, 0.23852563f, 0.12893988f, 0.15212922f, -0.27427989f, 
    0.02387162f, 0.18436818f, 0.14527877f, 0.16569392f, -0.11124208f, 0.17416956f, 0.01259270f, -0.03663712f, 
    -0.08161999f, 0.10167775f, -0.15238775f, 0.04516640f, 0.36265117f, 0.28620282f, -0.15169784f, 0.16942015f, 
    -0.31408232f, 0.55444336f, -0.05441245f, 0.20916542f, 0.00508735f, -0.34477517f, 0.07830453f, -0.15506630f, 
    0.13882150f, -0.10529906f, 0.13035268f, 0.07298165f, -0.47083902f, 0.11053636f, -0.10797247f, -0.11301464f, 
    -0.08274903f, -0.07073636f, 0.14776665f, 0.03163024f, -0.16551220f, -0.33325461f, -0.04812980f, -0.12412358f, 
    0.17038284f, 0.12591778f, 0.04979433f, -0.12477722f, 0.27954924f, -0.07522412f, -0.10791118f, -0.26391834f, 
    -0.20107991f, -0.04327275f, -0.09224372f, 0.13174592f, 0.19190583f, 0.08700013f, 0.12234092f, -0.48657665f, 
    -0.01833685f, 0.05071452f, -0.14693552f, -0.19502056f, -0.18104571f, 0.13244100f, 0.02047442f, 0.34915763f, 
    -0.00151659f, 0.15326954f, -0.26048237f, 0.02500421f, 0.17021689f, 0.14584513f, -0.13055456f, -0.00498317f, 
    0.07868006f, -0.03319414f, 0.13792109f, 0.14500435f, 0.32966214f, -0.13648553f, 0.06989587f, 0.16617823f, 
    -0.00203472f, 0.08560899f, -0.01020287f, 0.19691698f, -0.20404476f, 0.22442666f, -0.14487273f, -0.28773740f, 
    -0.13059679f, -0.14957424f, 0.19908151f, -0.18198262f, 0.05148996f, -0.06153555f, 0.10447423f, 0.19537364f, 
    0.09106388f, 0.01970150f, -0.04911966f, -0.01351423f, 0.06788831f, -0.18454473f, -0.03601735f, -0.20393202f, 
    0.15597907f, -0.07424154f, 0.05023921f, 0.03305573f, -0.19278203f, -0.32199338f, 0.25039524f, -0.06987306f, 
    -0.45262480f, 0.14551042f, 0.01741458f, -0.29979587f, 0.20860340f, -0.13640313f, -0.02911012f, -0.35694218f, 
    -0.01317603f, 0.16594553f, 0.05394198f, 0.10700792f, 0.19153728f, 0.20475452f, 0.14913481f, 0.04761323f, 
    0.14668623f, 0.05178682f, 0.10456563f, -0.09948840f, 0.13746524f, 0.10921562f, 0.11156996f, 0.10621337f, 
    -0.10559203f, 0.08195769f, -0.08025952f, 0.02006316f, 0.38285628f, 0.15936512f, -0.15414904f, -0.01401187f, 
    0.26965997f, 0.21834736f, 0.28784287f, -0.32508618f, 0.01178933f, 0.28362653f, -0.11090416f, -0.25429258f, 
    0.17090537f, 0.00887906f, 0.10603823f, 0.17058547f, 0.15844242f, -0.16828106f, 0.15846328f, -0.05084501f, 
    0.06858377f, -0.23436148f, -0.24051106f, 0.14368793f, -0.14513585f, -0.06518952f, 0.08812562f, 0.13583006f, 
    -0.02522126f, 0.13882834f, -0.11562789f, -0.16731107f, -0.04393955f, -0.14351527f, 0.22370495f, -0.03483598f, 
    -0.09280387f, 0.22675267f, 0.15248847f, -0.07139315f, 0.30427051f, 0.32147849f, 0.04412363f, 0.32866353f, 
    -0.14330541f, 0.04176730f, -0.13105518f, 0.31835374f, 0.20125681f, -0.21134894f, 0.01713721f, -0.34914044f, 
    0.08414509f, 0.13723488f, 0.38216683f, -0.04863502f, -0.13782723f, -0.04827911f, 0.08212691f, -0.00206750f, 
    0.00376508f, -0.07076599f, 0.15091002f, -0.13299556f, 0.22914661f, 0.36670399f, -0.13647196f, -0.37310553f, 
    -0.35268745f, -0.09436420f, -0.15162542f, -0.10999169f, 0.27157161f, 0.09779461f, 0.30022466f, -0.11655900f, 
    -0.13851492f, -0.04513208f, -0.10677493f, 0.05156654f, 0.11561748f, 0.24675746f, 0.04365206f, -0.22433855f, 
    -0.03467829f, 0.09417617f, 0.11454420f, 0.04140580f, 0.01158002f, 0.23126043f, 0.01171214f, -0.07572618f, 
    0.16806825f, 0.07672037f, -0.00341255f, -0.17451388f, 0.44322294f, 0.44660968f, -0.15285093f, -0.11902573f, 
    -0.10540383f, -0.06944341f, 0.11916924f, -0.05857947f, -0.06143754f, -0.15525489f, 0.08139459f, -0.06179198f, 
    0.06132853f, 0.10524767f, -0.03684347f, -0.07025209f, -0.10926922f, -0.10970800f, 0.03856194f, -0.01327033f, 
    -0.03751833f, -0.02291690f, -0.02685007f, 0.08807463f, -0.00940228f, -0.12175434f, -0.06139910f, 0.11572155f, 
    0.03896984f, -0.01649647f, 0.01150881f, -0.07404672f, 0.17124081f, 0.10761184f, -0.03630733f, 0.03441373f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.25223401f, 0.04242926f, -0.11015780f, 0.02182523f, -0.12164951f, 0.27884325f, 0.26361671f, 0.09692814f, 
    -0.06115186f, 0.06288648f, -0.22277561f, -0.05077905f, -0.06750677f, 0.19699475f, -0.04419350f, 0.23222396f, 
    -0.08689643f, -0.04216367f, 0.11145926f, -0.18851990f, 0.03753450f, 0.30116412f, -0.04647760f, 0.32283875f, 
    -0.11874220f, 0.34749895f, 0.00982635f, 0.15446374f, 0.25100833f, -0.26950362f, -0.16859302f, 0.05484786f, 
    0.29562220f, 0.37703013f, 0.14760281f, 0.13714951f, 0.10081070f, -0.12090609f, 0.20613453f, 0.05236079f, 
    0.01816764f, 0.04299748f, -0.01814599f, 0.06486880f, -0.09377576f, 0.23266381f, 0.24540651f, -0.07319751f, 
    -0.03100027f, 0.21910386f, 0.22850664f, 0.03538726f, 0.23953584f, 0.06269357f, 0.21157207f, 0.35280648f, 
    0.19462608f, 0.23540151f, 0.08055721f, 0.03818820f, 0.17042020f, 0.18407165f, 0.12170611f, -0.00515121f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.17515336f, 0.20012806f, 0.01523151f, -0.37470493f, -0.66341794f, -0.24548031f, 0.19237472f, -0.48932344f, 
    -0.02875080f, -0.01012472f, -0.19586521f, 0.07702605f, 0.03813652f, -0.00043037f, -0.03064229f, 0.17737462f, 
    -0.10106013f, 0.22287776f, 0.19529690f, -0.05132255f, 0.41270798f, 0.14154255f, -0.07704653f, 0.03468113f, 
    -0.36783916f, 0.03313838f, 0.06386642f, 0.16847619f, 0.00680826f, -0.48211682f, 0.05857809f, -0.07142228f, 
    0.29150134f, 0.05146523f, 0.21051620f, 0.01792700f, 0.13747506f, 0.01880771f, -0.02400386f, 0.28914538f, 
    -0.52991825f, -0.07035503f, -0.00897724f, 0.07902724f, -0.11827143f, -0.39998269f, -0.43737301f, 0.10626174f, 
    -0.58538520f, -0.43876943f, -0.00403333f, 0.01901332f, 0.08079783f, -0.21752928f, -0.40861124f, -0.18966736f, 
    -0.03165858f, 0.11327422f, 0.05264735f, 0.11961026f, -0.14452024f, -0.82751596f, -0.05790083f, 0.08512694f, 
    0.10244913f, -0.05220291f, -0.06022070f, -0.09547603f, -0.09151855f, 0.03766334f, 0.00158577f, 0.07712413f, 
    -0.10313156f, 0.08827220f, 0.10281776f, -0.07515313f, -0.06211090f, -0.11663432f, 0.02494837f, -0.08093932f, 
    -0.08203901f, -0.01696892f, -0.04240832f, -0.01916307f, -0.04019213f, 0.05436391f, 0.00583914f, -0.00460345f, 
    -0.06163703f, 0.09328182f, 0.07741174f, -0.02114879f, -0.06505950f, -0.03827384f, -0.06172949f, 0.07709512f, 
    0.08845612f, -0.08810960f, 0.07518254f, 0.01014578f, -0.07664518f, 0.04801837f, -0.04583782f, 0.11281952f, 
    0.02835956f, -0.08873323f, 0.00064513f, -0.03959370f, 0.03658421f, 0.11964425f, -0.04321383f, -0.00107728f, 
    -0.11095878f, -0.10702871f, 0.12343171f, -0.09748212f, -0.05914530f, 0.00900495f, -0.08848540f, -0.06485620f, 
    -0.08039899f, -0.06327462f, 0.00487006f, -0.06530158f, -0.01764773f, 0.07169795f, -0.09221785f, -0.12289548f, 
    -0.05264422f, 0.31381771f, 0.04929930f, 0.05582938f, -0.39953396f, -0.04490451f, 0.06956866f, 0.06235399f, 
    -0.30754304f, -0.07267002f, 0.01219145f, 0.16292864f, 0.13265023f, -0.12738740f, -0.12381643f, -0.21108887f, 
    0.18206702f, 0.38110355f, 0.05466446f, 0.11546750f, -0.16677827f, 0.00876321f, -0.09288023f, 0.08186680f, 
    0.07994734f, -0.09102613f, 0.10327842f, -0.02940074f, 0.21369807f, -0.02783795f, -0.09727584f, -0.08714169f, 
    -0.01704688f, -0.12206902f, -0.04621703f, 0.24168594f, -0.15127374f, -0.19294938f, 0.33754638f, -0.09169490f, 
    -0.08789836f, -0.25270167f, -0.11252727f, 0.01628553f, -0.09084211f, 0.05939510f, -0.13628688f, 0.18482846f, 
    -0.16574109f, 0.21248643f, 0.17763595f, 0.17269917f, 0.06013668f, -0.04262783f, 0.30799368f, 0.14405370f, 
    0.29830155f, -0.15090926f, -0.14215094f, 0.04038332f, 0.15045397f, 0.18374541f, -0.00549753f, 0.01718306f, 
    -0.05191175f, -0.15091752f, -0.07780638f, -0.43601316f, 0.20376427f, 0.28943977f, -0.00656464f, 0.10930839f, 
    -0.34971163f, -0.00688563f, -0.12504606f, 0.45389134f, 0.12431960f, -0.07766844f, 0.09413298f, 0.27830958f, 
    0.31795844f, 0.13632819f, 0.06764552f, 0.04279511f, -0.25517547f, 0.10355995f, 0.08652328f, 0.09658236f, 
    -0.02318849f, 0.29122505f, 0.01723696f, -0.04766927f, 0.02483488f, -0.06810439f, -0.43469250f, -0.09245270f, 
    -0.20538186f, 0.12731014f, -0.00546551f, 0.63652831f, -0.12634191f, 0.02454611f, 0.49835587f, -0.49696180f, 
    0.28225923f, -0.10575993f, -0.12545840f, 0.10016959f, 0.02123927f, 0.20860928f, -0.03827802f, -0.03350559f, 
    0.02225000f, 0.17814150f, 0.07687643f, -0.11591443f, -0.24937564f, 0.09993666f, 0.22478633f, 0.14836010f, 
    0.09220957f, -0.28952029f, 0.16504087f, 0.16886784f, 0.23607062f, 0.14911522f, -0.06144212f, -0.04873477f, 
    0.47480068f, 0.07659249f, -0.06700719f, 0.11000147f, -0.00640478f, -0.11517218f, 0.00806588f, 0.15959737f, 
    0.23302968f, -0.10124266f, -0.20402899f, -0.57884353f, 0.04676790f, 0.24230057f, -0.11881468f, -0.06616416f, 
    -0.07026557f, -0.28179643f, -0.16069047f, -0.00777597f, 0.07576394f, -0.05227895f, -0.01472799f, 0.03840843f, 
    0.13865824f, -0.13268003f, 0.01257703f, 0.01702781f, -0.17638181f, 0.00743896f, 0.09504899f, 0.04737845f, 
    0.18686606f, -0.05716537f, -0.07185746f, -0.20166482f, 0.18381421f, -0.06625792f, -0.33023089f, 0.47719127f, 
    -0.02508387f, -0.08381757f, 0.02729290f, 0.09914949f, -0.05662157f, -0.07356038f, -0.10119011f, -0.02175431f, 
    -0.08321176f, 0.01494625f, 0.15077890f, 0.15438679f, 0.08023199f, -0.15102768f, -0.05691923f, 0.09090922f, 
    -0.22967035f, 0.10131125f, -0.09233300f, -0.00837038f, -0.11641596f, 0.04326710f, 0.26956600f, -0.06363413f, 
    -0.12397615f, -0.06189750f, 0.07872388f, 0.04626804f, -0.00487060f, 0.10490822f, -0.08820177f, -0.13638538f, 
    0.03315072f, -0.07304905f, -0.14901504f, -0.04352431f, 0.11516309f, -0.02094046f, -0.12275228f, -0.12727050f, 
    0.02684312f, 0.02676129f, -0.04077765f, -0.11110589f, 0.03336184f, -0.16029228f, -0.00774986f, 0.03219898f, 
    -0.10270192f, -0.07122298f, -0.04917514f, -0.13512458f, 0.07307483f, 0.08567498f, -0.05874913f, 0.10148633f, 
    0.01665876f, -0.11810910f, 0.04180899f, 0.02082081f, -0.02184593f, -0.07018603f, -0.01841599f, -0.04984728f, 
    -0.09894056f, 0.01521813f, -0.08052722f, -0.09921391f, -0.06636475f, 0.09652351f, -0.09227760f, -0.03597346f, 
    -0.08667422f, -0.12829906f, 0.07655931f, -0.07218626f, 0.06532143f, -0.07825892f, 0.09737395f, 0.00212609f, 
    0.09279723f, -0.09621108f, 0.02744182f, 0.04171123f, 0.04404469f, -0.08634797f, 0.04489050f, -0.11443797f, 
    -0.21401784f, -0.11202638f, -0.02515162f, -0.15227421f, 0.13845757f, 0.44296232f, 0.05900674f, 0.00984071f, 
    0.07908946f, 0.07390676f, -0.36388084f, 0.10455265f, -0.12888856f, 0.23844282f, 0.07051283f, -0.08539214f, 
    -0.03327803f, 0.26272547f, 0.19299577f, -0.11223366f, -0.29910308f, 0.17266929f, -0.05356004f, 0.16862956f, 
    -0.05664203f, 0.52065170f, -0.02895778f, -0.21124271f, 0.01311546f, 0.08184110f, -0.19440714f, 0.13302873f, 
    0.04594146f, 0.23057522f, 0.01971828f, -0.25915256f, -0.14863932f, 0.11588334f, 0.28708991f, 0.37253159f, 
    0.03913709f, -0.07558742f, 0.13106595f, 0.27167279f, 0.10625675f, 0.02380286f, 0.16715834f, -0.08624689f, 
    0.09489691f, 0.26207933f, 0.22107646f, -0.14536436f, 0.22840571f, -0.28547445f, 0.48472339f, 0.22487791f, 
    -0.12406496f, -0.06203087f, -0.03337445f, 0.07386516f, 0.13135444f, 0.02614523f, 0.10102891f, 0.03053902f, 
    -0.16848393f, 0.17927931f, -0.14158982f, -0.04443393f, 0.13148871f, 0.06885661f, -0.09830669f, 0.08287799f, 
    -0.12691230f, -0.02966634f, -0.23163690f, 0.19378634f, 0.01882371f, -0.00757514f, -0.00715695f, -0.07032569f, 
    -0.14507009f, 0.43499753f, -0.04150590f, -0.18373694f, 0.17097218f, 0.26690897f, 0.10540524f, 0.24178734f, 
    0.36212623f, -0.18349274f, -0.11699846f, -0.24786939f, -0.14156328f, 0.08480655f, -0.01961255f, -0.04459221f, 
    0.15924135f, 0.11958904f, 0.20035008f, -0.29856777f, -0.15151659f, 0.10150073f, 0.32903862f, 0.28204677f, 
    -0.14873442f, -0.06192037f, 0.08151382f, 0.00352026f, 0.03208771f, 0.10256366f, -0.02282088f, 0.20379992f, 
    0.05385323f, -0.01165803f, 0.03475202f, 0.36950538f, 0.30554748f, -0.37358794f, 0.19815432f, -0.04526291f, 
    0.05343743f, -0.00904836f, -0.04539742f, 0.21391715f, -0.29698598f, -0.03345734f, 0.13737847f, -0.06216301f, 
    -0.38099369f, 0.09577934f, -0.06628502f, 0.04700528f, -0.18388787f, -0.11984696f, -0.03009798f, 0.00236002f, 
    0.50594950f, -0.04968579f, 0.11132794f, 0.39488277f, -0.03986332f, 0.00056857f, -0.08616866f, 0.24412802f, 
    0.15998510f, -0.25936538f, 0.10030331f, 0.13729574f, 0.37183678f, -0.13607013f, -0.07043138f, -0.03514289f, 
    -0.08273426f, 0.12664337f, -0.06506013f, 0.17188913f, -0.27311733f, -0.11399209f, 0.11233572f, 0.01600124f, 
    -0.00065798f, 0.12206522f, 0.01081100f, -0.15802175f, 0.17021382f, 0.24079442f, -0.06880467f, -0.85561842f, 
    -0.22726692f, 0.33509174f, -0.07152424f, 0.05808748f, 0.00235473f, 0.03076791f, -0.30893287f, 0.04962378f, 
    -0.24308620f, -0.10652819f, -0.26094577f, -0.10422093f, -0.13333276f, 0.61384487f, -0.35934228f, -0.44816563f, 
    0.09242375f, -0.21352164f, 0.16597937f, -0.17829412f, 0.30124629f, 0.27592096f, -0.27545866f, 0.02051389f, 
    -0.06478857f, 0.21435705f, 0.07251882f, 0.14979717f, -0.18697391f, -0.27753919f, -0.39464569f, 0.12291104f, 
    0.05310799f, 0.05944692f, 0.29733109f, -0.37608194f, -0.07563806f, -0.22242793f, 0.05442356f, -0.29918253f, 
    0.27634549f, -0.08021550f, 0.08486737f, 0.05521999f, 0.18061638f, -0.31016186f, 0.16587354f, 0.02058089f, 
    -0.04379896f, 0.02633255f, -0.05471531f, 0.36152968f, -0.00061240f, -0.09438919f, 0.31692207f, 0.07636333f, 
    -0.15588930f, -0.43885791f, -0.40461084f, 0.06850488f, 0.37697539f, 0.11454621f, -0.34141940f, -0.72736162f, 
    0.01570140f, 0.13016467f, 0.11398397f, 0.26395136f, 0.10051878f, 0.16959225f, 0.13886799f, 0.25115347f, 
    0.03743534f, 0.16878828f, -0.34502113f, -0.02736639f, -0.27702990f, 0.37384352f, -0.11957148f, 0.06446942f, 
    -0.07621385f, 0.10522427f, -0.03605595f, -0.23074079f, -0.16150334f, 0.15035754f, -0.04732366f, -0.05923246f, 
    0.28198385f, 0.02351556f, -0.04847199f, -0.22951326f, 0.01414071f, -0.08053286f, -0.04248228f, 0.09485479f, 
    -0.24902095f, 0.18852076f, -0.29789281f, 0.08766243f, -0.06216850f, -0.08710719f, -0.00962502f, -0.06050617f, 
    -0.01573025f, 0.22295144f, -0.05384704f, -0.05028591f, 0.21279514f, 0.26548788f, -0.07491960f, 0.21149103f, 
    0.31142607f, -0.09009748f, 0.06395361f, -0.27109113f, 0.11293926f, -0.01251791f, -0.33843833f, -0.11993936f, 
    0.08907425f, 0.18753877f, 0.09766246f, 0.09716486f, -0.18423279f, -0.02368474f, 0.25069392f, 0.38780373f, 
    0.00325796f, -0.32367265f, 0.03696780f, -0.00972094f, -0.05632730f, -0.05701141f, 0.04964402f, 0.15847257f, 
    -0.17598732f, 0.21986231f, 0.09302490f, 0.18451542f, 0.16106896f, -0.71749830f, 0.19174914f, 0.12711377f, 
    0.01061700f, -0.08669506f, -0.37714431f, 0.24560468f, -0.09498689f, -0.00611123f, 0.23672977f, -0.01770049f, 
    -0.16695754f, 0.04194222f, 0.02782293f, -0.11957094f, -0.04807032f, 0.27825385f, -0.01655638f, -0.00667901f, 
    -0.04169870f, 0.10215614f, -0.16618232f, 0.16438396f, -0.12337922f, 0.28230017f, -0.01999827f, -0.07568859f, 
    -0.07020839f, 0.40266848f, 0.07496590f, 0.11919170f, -0.18342431f, 0.25701132f, 0.01159164f, 0.15238571f, 
    0.24140684f, 0.12375248f, 0.06697972f, -0.04872266f, -0.36140084f, 0.13998266f, -0.26169348f, 0.01773864f, 
    0.19280778f, 0.20844331f, 0.10897578f, -0.29870117f, -0.16085397f, -0.03677396f, 0.09149776f, 0.20852835f, 
    0.00778329f, 0.03750831f, 0.09948628f, -0.02178056f, -0.07888055f, 0.10847913f, 0.09873287f, -0.02819481f, 
    0.10456676f, 0.25526288f, 0.24557480f, -0.07332987f, 0.08342198f, -0.39188313f, 0.32854253f, 0.15838087f, 
    0.13824886f, -0.20972119f, -0.21491694f, 0.06373363f, -0.06874036f, 0.08617093f, -0.03199342f, -0.01408204f, 
    0.62977284f, -0.07254935f, 0.05573450f, 0.08468401f, -0.08672179f, -0.00980676f, 0.16584419f, 0.06874682f, 
    0.18875514f, 0.06458066f, -0.13842495f, -0.57912731f, -0.06956533f, 0.12711644f, -0.03356874f, -0.08180378f, 
    -0.26457688f, -0.27739194f, -0.10219508f, 0.05160624f, -0.16892064f, 0.03470289f, -0.00873218f, 0.08815994f, 
    -0.06987421f, 0.04293025f, -0.10459301f, -0.11182339f, 0.07753772f, 0.04667571f, -0.04113957f, -0.02177664f, 
    0.28606427f, -0.05390646f, 0.19983880f, -0.06901909f, 0.11112012f, -0.11771500f, 0.13711402f, 0.57848841f, 
    0.01340375f, -0.30699837f, -0.04435121f, -0.01021955f, -0.02826285f, 0.00154947f, -0.01326992f, -0.15062980f, 
    -0.04911982f, -0.09657199f, 0.29829702f, -0.16850738f, 0.17428520f, -0.53243864f, -0.10277376f, 0.29585820f, 
    0.06088112f, -0.01042365f, -0.08781105f, 0.24186501f, -0.03175433f, -0.06452627f, 0.20260307f, -0.10048977f, 
    0.32096788f, -0.25266930f, 0.06864337f, -0.22367384f, 0.17644551f, 0.06329982f, 0.23368888f, -0.08437264f, 
    -0.27189568f, -0.02624672f, -0.05209444f, -0.02530323f, -0.10943744f, -0.06904938f, -0.10046434f, 0.32513371f, 
    0.02810119f, -0.29657680f, -0.02284194f, 0.14332232f, 0.30191210f, 0.00642307f, 0.02884657f, 0.04193152f, 
    -0.48578867f, -0.06725601f, 0.00430052f, 0.07488106f, 0.18478115f, 0.14967082f, 0.17501238f, -0.09297585f, 
    0.08567748f, 0.26189163f, 0.16827919f, 0.29417539f, 0.32385892f, 0.23334488f, 0.08297320f, -0.09617923f, 
    -0.04469447f, 0.27065691f, 0.07581625f, 0.04784146f, 0.03498396f, 0.19042349f, -0.09345586f, -0.13368979f, 
    -0.08225947f, -0.17865933f, -0.06871476f, -0.18843937f, 0.11961249f, 0.11950924f, 0.13352367f, -0.23942457f, 
    -0.02069695f, 0.01434686f, 0.23636928f, -0.04695090f, 0.10499455f, -0.13051258f, -0.02497722f, 0.08170988f, 
    -0.02769248f, 0.22536081f, 0.08467334f, 0.06236261f, -0.29889163f, 0.14822583f, 0.24453296f, 0.04702565f, 
    0.60956275f, -0.05170256f, -0.36012790f, -0.08349314f, 0.02833786f, 0.05234391f, -0.14197318f, 0.08386013f, 
    -0.03454757f, 0.32332954f, 0.15946697f, 0.11525133f, 0.12986001f, 0.31145251f, -0.05202451f, 0.38050869f, 
    0.10308667f, 0.03707724f, -0.00766090f, 0.02606288f, -0.20980757f, -0.09583795f, 0.11415626f, 0.05765241f, 
    0.24915372f, 0.03195370f, 0.09282963f, -0.39892587f, 0.02248589f, -0.00464232f, -0.23267160f, 0.15192617f, 
    -0.30065233f, 0.28984055f, -0.09282996f, 0.23317729f, 0.10977153f, -0.26420307f, -0.14250354f, 0.37047967f, 
    -0.12282579f, 0.05897803f, 0.00561181f, 0.02057898f, 0.13199791f, -0.05946415f, 0.14214911f, -0.20679587f, 
    -0.10285987f, -0.04641184f, 0.12694058f, -0.16428594f, -0.10140233f, -0.10053366f, 0.06003155f, -0.13009477f, 
    -0.21301851f, -0.19753802f, 0.03942307f, -0.01864753f, 0.13403621f, 0.41974008f, 0.10784052f, 0.14475766f, 
    0.01859076f, 0.07450353f, 0.08053674f, 0.13250798f, -0.06824202f, 0.17646359f, 0.06253646f, 0.04893773f, 
    -0.11521310f, -0.03401718f, 0.25295478f, -0.06207638f, -0.50105292f, 0.16954997f, -0.06854278f, 0.05040196f, 
    -0.13197309f, -0.00352450f, -0.03485418f, -0.01299107f, 0.01177050f, 0.31158814f, -0.10587275f, -0.07182766f, 
    -0.05684275f, 0.01133814f, 0.01022968f, 0.39277685f, 0.00580632f, -0.03813741f, -0.02632003f, -0.16657324f, 
    0.36752215f, 0.00924946f, 0.08144426f, 0.21606942f, 0.08115219f, -0.01333218f, -0.00578269f, -0.17486560f, 
    0.28903937f, 0.19637913f, 0.18345897f, -0.20030582f, -0.09765378f, -0.08517943f, 0.23008519f, 0.10009773f, 
    0.06821266f, -0.09847241f, 0.04478624f, 0.17029214f, 0.35490370f, -0.00342381f, 0.03029980f, -0.06784972f, 
    -0.34167650f, 0.20631914f, 0.07324000f, -0.04735404f, -0.12796152f, 0.19849955f, 0.21442233f, -0.00460847f, 
    0.27770317f, 0.06991075f, -0.18220961f, 0.31691694f, -0.05889086f, -0.07228648f, -0.04464564f, 0.16710646f, 
    0.23623261f, 0.26560172f, 0.17957465f, 0.03307565f, 0.03926304f, 0.17597328f, -0.07385260f, 0.31664449f, 
    -0.10630856f, 0.53739238f, 0.05270232f, 0.15124542f, 0.33171499f, -0.21738480f, 0.04093273f, 0.00932580f, 
    0.07001656f, 0.01743292f, -0.05520076f, -0.18888120f, -0.14265183f, -0.27358136f, 0.16219132f, -0.34678316f, 
    0.06569625f, -0.11454520f, 0.07931693f, 0.03615023f, -0.05393130f, -0.02471328f, 0.13121857f, -0.01492440f, 
    -0.11115243f, 0.20350707f, 0.05642368f, -0.02834441f, 0.15223625f, -0.10080560f, 0.33550599f, 0.03719045f, 
    0.09730630f, -0.02750912f, 0.11370621f, -0.03755764f, 0.36782813f, 0.02697510f, -0.10959060f, -0.01033645f, 
    0.16697325f, 0.09264223f, 0.02736054f, 0.32842144f, -0.15749060f, -0.29121539f, -0.25113636f, 0.13145290f, 
    -0.23462269f, 0.02596570f, 0.42110807f, -0.69001848f, 0.05232593f, -0.51966679f, 0.04736933f, -0.12567079f, 
    0.18028581f, -0.11781949f, 0.08768369f, -0.04928786f, 0.01369420f, -0.33081239f, -0.02438954f, 0.05628411f, 
    0.15182753f, -0.19853584f, -0.04543068f, 0.21049246f, -0.05567762f, -0.06672695f, 0.05795610f, -0.10883230f, 
    0.28345311f, -0.37505460f, -0.27294195f, 0.25480181f, 0.32636505f, -0.00355923f, -0.00071534f, 0.08774414f, 
    0.01514856f, 0.03004121f, -0.07282814f, -0.06737187f, -0.00990739f, 0.05453003f, 0.06394900f, 0.23138136f, 
    0.06252619f, 0.12551627f, -0.02286956f, -0.01089593f, -0.20484987f, 0.10307993f, -0.02464255f, 0.06381524f, 
    0.63560486f, -0.01370857f, -0.07598949f, 0.15316688f, -0.14011885f, 0.07928472f, 0.09859232f, -0.07446854f, 
    0.08332818f, 0.10442925f, 0.05884571f, -0.27052939f, -0.03012135f, -0.32098091f, -0.30862451f, 0.06631070f, 
    -0.66747892f, -0.12769762f, -0.05710486f, -0.05327788f, 0.06320538f, -0.23461081f, 0.01395257f, 0.19115962f, 
    0.08855954f, 0.24128178f, -0.00174442f, -0.06661444f, 0.26192287f, 0.16806556f, 0.06709927f, -0.01158170f, 
    0.29828063f, -0.32477677f, 0.04545295f, -0.17164153f, -0.23273151f, 0.18237613f, 0.04003258f, -0.08144577f, 
    0.29057318f, 0.28175274f, -0.00357912f, 0.45065758f, 0.10477506f, 0.13422248f, 0.24927185f, 0.13445154f, 
    -0.03030924f, 0.10602377f, 0.10099950f, -0.21508373f, -0.05508034f, 0.00420429f, -0.09814659f, 0.34284535f, 
    0.08471365f, -0.03805977f, 0.11972757f, 0.27210459f, -0.04955836f, 0.33106768f, -0.09640045f, 0.04517753f, 
    0.18052146f, -0.16901931f, -0.20841902f, 0.18261233f, -0.24687998f, 0.00201865f, 0.22810455f, -0.10170412f, 
    0.41246736f, -0.31095037f, -0.01951583f, -0.25767127f, -0.07198855f, 0.36406338f, 0.11460102f, 0.03206696f, 
    -0.51836568f, 0.17888550f, -0.27902636f, 0.36651918f, -0.03218294f, 0.00325957f, -0.01123905f, 0.31876451f, 
    0.17775901f, -0.13694641f, -0.00946815f, 0.04404246f, -0.00473010f, 0.21487349f, -0.05214353f, -0.04521628f, 
    -0.02461624f, 0.45864639f, 0.04716451f, -0.17168696f, 0.14803275f, -0.24620438f, -0.37745842f, 0.06424945f, 
    -0.20869631f, 0.12618616f, 0.04652518f, 0.33533877f, -0.14381500f, -0.24037696f, 0.39455920f, 0.06105026f, 
    0.22548963f, -0.35770693f, -0.13348718f, 0.09808832f, 0.07575247f, 0.21488656f, 0.05003204f, -0.46207997f, 
    0.10864658f, 0.23481758f, 0.21406209f, -0.31944016f, -0.00039847f, -0.27599117f, 0.15094048f, 0.02132406f, 
    -0.12528132f, -0.12182609f, -0.05323318f, 0.13116358f, 0.29625157f, 0.14402081f, 0.16096887f, -0.12423290f, 
    0.13086064f, 0.07252143f, -0.07801268f, 0.07146864f, 0.06840334f, -0.12161053f, -0.05886838f, 0.09718008f, 
    -0.31545141f, 0.03709674f, 0.17489581f, 0.17420125f, -0.07729017f, 0.08409983f, 0.08020522f, 0.16796465f, 
    0.12734677f, -0.12508036f, -0.06291960f, -0.12131140f, 0.23868418f, -0.09403373f, -0.13904335f, -0.06800293f, 
    -0.15929545f, 0.21695589f, 0.03852090f, 0.18977864f, -0.06007876f, -0.15587918f, 0.03501897f, -0.06988733f, 
    -0.13458528f, 0.20057248f, -0.07860021f, -0.11242941f, 0.06480331f, 0.13490558f, 0.07088931f, -0.20876843f, 
    -0.04776273f, 0.24972340f, 0.10146272f, 0.15897837f, -0.09449998f, 0.11670150f, 0.03764840f, -0.22518809f, 
    0.05386932f, -0.08090227f, -0.02324160f, -0.26365831f, -0.13910273f, 0.27416348f, 0.02505145f, -0.04587596f, 
    0.15042539f, -0.05167407f, 0.15133670f, 0.10233990f, 0.13417768f, -0.15454727f, -0.05873366f, 0.09150629f, 
    0.45640677f, -0.42084450f, 0.13963819f, -0.19924696f, 0.19251405f, 0.08365551f, 0.08330766f, 0.08293561f, 
    0.03784746f, 0.06602218f, 0.10351662f, -0.31234604f, -0.16936257f, 0.18981715f, 0.12060681f, -0.00404616f, 
    -0.00770563f, -0.28277186f, -0.01209461f, -0.05503765f, -0.18606916f, 0.03608405f, -0.04318459f, -0.13915642f, 
    -0.06957713f, 0.03923132f, -0.07192072f, -0.01488438f, -0.02352853f, 0.14625420f, -0.03237648f, 0.10659256f, 
    0.04847986f, -0.05838746f, -0.01799771f, 0.36777079f, 0.36017147f, -0.02806131f, -0.30193332f, 0.18836462f, 
    0.24873969f, 0.07418301f, 0.04210502f, 0.12745422f, -0.05661994f, 0.19397509f, 0.03145841f, -0.24346301f, 
    0.23706919f, -0.08875660f, 0.12465709f, -0.14107387f, -0.04823768f, 0.03128697f, 0.01335925f, 0.01444159f, 
    -0.29494798f, -0.06269132f, 0.08397725f, 0.12205041f, 0.06457691f, -0.10848046f, 0.15434140f, 0.11614160f, 
    -0.30229202f, -0.13054997f, 0.03498863f, -0.09102221f, -0.16270818f, 0.11902422f, -0.22319776f, 0.12394665f, 
    0.28531289f, -0.16781749f, 0.45885709f, 0.38082451f, -0.11938457f, 0.04272948f, 0.03578384f, -0.04358509f, 
    0.25018346f, -0.15915537f, 0.21662998f, 0.07084017f, 0.17792296f, -0.21405987f, 0.05510157f, 0.00196138f, 
    0.08958402f, 0.05166899f, -0.09281659f, 0.02307170f, -0.21126081f, 0.23532286f, 0.14048372f, 0.07036327f, 
    0.01152124f, 0.17753594f, -0.14356934f, 0.41676143f, 0.20002174f, 0.37534508f, -0.19362828f, -0.62849373f, 
    0.08400156f, 0.41244063f, -0.05938287f, 0.20436186f, -0.11027101f, 0.23574980f, -0.12085877f, 0.25769368f, 
    0.11682629f, 0.09817993f, -0.23997271f, 0.01110085f, -0.26715919f, 0.47433460f, 0.02037782f, -0.17615373f, 
    -0.19218172f, -0.45930550f, 0.11249474f, -0.08673191f, -0.00520189f, 0.10206509f, -0.18035488f, 0.11813437f, 
    -0.01486631f, -0.27542934f, -0.03405352f, -0.26629871f, -0.05397382f, 0.30653521f, 0.09822654f, 0.14657579f, 
    -0.44593590f, 0.06087755f, 0.05739971f, 0.10634510f, -0.07488728f, 0.03910926f, -0.03194964f, 0.25944400f, 
    0.16243210f, -0.10337295f, 0.19729115f, 0.03952838f, -0.11170214f, 0.00772157f, 0.01338889f, 0.18322040f, 
    -0.38895923f, 0.33130816f, -0.07768249f, 0.11754166f, 0.13923001f, 0.01137625f, -0.27651882f, -0.06121003f, 
    -0.01992252f, -0.00434736f, 0.00896382f, 0.44541177f, 0.15152560f, -0.01551439f, 0.17720774f, -0.14700146f, 
    0.11563571f, 0.10146543f, -0.12232339f, 0.17261781f, 0.01018459f, 0.01567063f, 0.03472505f, -0.18627599f, 
    0.20770106f, 0.16670927f, 0.10937972f, -0.44095582f, -0.13885309f, 0.01288188f, 0.15906726f, 0.07322896f, 
    -0.08543783f, -0.00975828f, 0.15717256f, 0.03653733f, 0.32579646f, 0.18035479f, -0.00500588f, 0.10336736f, 
    0.35288802f, -0.00635646f, 0.06213144f, 0.17036709f, 0.17380679f, -0.07141241f, -0.62157178f, 0.20730308f, 
    -0.22134361f, 0.17101897f, 0.02685857f, -0.25762239f, 0.05601204f, -0.10135188f, -0.10049888f, -0.14930464f, 
    0.28433329f, 0.00361135f, -0.16337854f, 0.03023780f, -0.00397753f, -0.24808139f, -0.11042066f, -0.07979877f, 
    -0.16696614f, -0.15829560f, -0.02058281f, -0.07067770f, 0.04759524f, 0.18751742f, -0.00429647f, 0.12990238f, 
    -0.13387075f, -0.29701048f, -0.17293516f, 0.14506508f, 0.29403007f, 0.11380035f, 0.18374471f, 0.22292279f, 
    0.04937452f, -0.07227453f, -0.01688642f, 0.01808974f, -0.03672519f, 0.14080101f, 0.17617473f, 0.11256767f, 
    0.23845203f, 0.21051428f, 0.00615554f, 0.03047176f, -0.29487795f, -0.04586063f, 0.02633628f, 0.01916951f, 
    -0.36308333f, -0.09538548f, -0.08177485f, 0.08271318f, 0.08483067f, 0.17091373f, 0.29495358f, 0.09255178f, 
    0.61528736f, -0.27077803f, -0.03788923f, -0.32599393f, -0.04986576f, 0.00526890f, 0.31497911f, -0.01821846f, 
    -0.30598995f, -0.22350405f, 0.18301216f, -0.21276161f, 0.13784888f, 0.12311694f, -0.05727420f, 0.28160232f, 
    -0.04071977f, -0.07908215f, 0.19813348f, 0.12024701f, -0.09852865f, 0.31777653f, 0.11215343f, 0.18233521f, 
    -0.27918816f, -0.02829076f, 0.01562695f, 0.01182010f, -0.00789453f, 0.02118086f, -0.32411876f, 0.06437907f, 
    0.37768766f, 0.31874809f, 0.28509870f, 0.37370846f, 0.25408795f, 0.19952948f, 0.14144920f, 0.15493241f, 
    0.02213622f, 0.02442857f, 0.11402487f, -0.05513874f, 0.05473956f, 0.07887657f, -0.07697523f, 0.15470019f, 
    -0.07517992f, 0.08276291f, 0.21659593f, 0.01996455f, 0.16168021f, -0.08758558f, 0.00931213f, 0.04492024f, 
    -0.11695434f, -0.12950125f, -0.00281957f, 0.16548680f, 0.07058929f, -0.16923077f, 0.08287779f, -0.03845731f, 
    -0.29033095f, 0.13667215f, -0.08941085f, 0.12857769f, 0.14113323f, 0.01244435f, -0.06061161f, 0.22533254f, 
    -0.27022067f, -0.01149967f, 0.12756373f, -0.12644279f, -0.05398813f, -0.22052455f, 0.10789187f, -0.01388906f, 
    0.09031439f, 0.11610392f, -0.02667453f, 0.07945450f, -0.48976606f, -0.20882736f, -0.00550672f, 0.01953793f, 
    0.18712671f, -0.26538166f, 0.00537687f, -0.04786094f, -0.19669746f, 0.43288738f, 0.03442642f, 0.08365105f, 
    0.10530721f, 0.01306736f, -0.04451447f, 0.49332473f, 0.36187994f, 0.45067495f, 0.00209421f, 0.15098722f, 
    0.03401512f, 0.20497842f, 0.07577650f, 0.15691292f, -0.03499462f, 0.03383968f, 0.14486426f, 0.39718273f, 
    0.35409364f, 0.21164513f, -0.13810974f, -0.11669320f, -0.16878280f, 0.20236561f, 0.09518638f, 0.07174502f, 
    -0.02220935f, -0.11196739f, -0.15099090f, 0.14450899f, -0.14694747f, 0.07237516f, 0.04274817f, 0.04761706f, 
    0.12529199f, 0.07107670f, 0.04204663f, -0.07160050f, -0.02926763f, -0.13941531f, -0.06173708f, 0.12735555f, 
    -0.55168301f, -0.11356644f, -0.04495243f, 0.04557391f, -0.01675665f, 0.00892808f, -0.08064143f, -0.04117901f, 
    -0.10833326f, 0.19079088f, -0.03861401f, -0.15157942f, -0.03116320f, 0.21705125f, 0.02965946f, 0.16533762f, 
    0.37981674f, -0.13947110f, -0.08960544f, -0.23658897f, -0.23160598f, -0.18275663f, -0.18672253f, -0.11404704f, 
    0.26322275f, 0.27861083f, 0.29472837f, 0.11279946f, -0.14026064f, -0.09084745f, 0.36728874f, 0.17032905f, 
    -0.21491666f, -0.03393865f, -0.08955067f, -0.11873829f, -0.10229218f, -0.05517744f, -0.07111457f, 0.27000219f, 
    -0.06310857f, 0.18753932f, 0.20727217f, 0.22896045f, 0.12960756f, -0.09827739f, -0.09988628f, 0.17592502f, 
    0.45745304f, 0.04677020f, -0.19038181f, 0.06260274f, -0.26052287f, 0.03225897f, 0.06745066f, -0.00834529f, 
    0.08865891f, 0.06055253f, 0.01541532f, -0.20401148f, -0.27994767f, -0.00358668f, 0.06262517f, 0.03950563f, 
    0.41709018f, 0.00838768f, -0.06022401f, -0.15040445f, 0.00932486f, 0.11693570f, 0.00819690f, -0.19999665f, 
    -0.29065347f, -0.09921916f, 0.06021015f, -0.05830353f, -0.29107794f, -0.00108860f, -0.00401193f, 0.12289470f, 
    0.19283156f, -0.13370152f, 0.11782653f, -0.23992230f, -0.29678798f, 0.21611401f, -0.03881506f, 0.01657616f, 
    0.17404027f, -0.05933065f, 0.12150216f, 0.02620295f, 0.21278614f, -0.04925974f, 0.07323680f, 0.45846918f, 
    0.04002275f, -0.18378927f, -0.09255434f, 0.01363247f, 0.03382888f, 0.06584191f, -0.10942397f, 0.28831634f, 
    0.20980455f, -0.03048514f, 0.23605065f, 0.16549025f, 0.21487080f, -0.31581473f, 0.08605281f, -0.00698747f, 
    -0.27340555f, -0.17342298f, -0.11659438f, -0.01982110f, -0.06238819f, 0.15493894f, 0.11766035f, -0.06621093f, 
    0.29681239f, -0.42036250f, 0.00122377f, -0.44544935f, -0.04767513f, 0.04083585f, 0.00519936f, 0.21090965f, 
    -0.36020726f, -0.12030873f, 0.20203729f, 0.02995371f, 0.02332399f, -0.18165959f, 0.06286379f, 0.04177327f, 
    -0.04258826f, -0.25420353f, 0.14629021f, 0.02138492f, -0.12410189f, 0.00341860f, -0.03478232f, -0.07075121f, 
    -0.24033661f, -0.51652896f, 0.01346265f, -0.40249404f, -0.25630215f, 0.12884124f, -0.25072506f, 0.04672031f, 
    -0.06669937f, -0.09278841f, 0.09048225f, 0.69196290f, 0.36802170f, 0.01389465f, -0.04248532f, 0.24805403f, 
    0.36929414f, -0.10112112f, 0.05346124f, 0.07508218f, -0.04259962f, 0.10757403f, 0.07064369f, 0.12299350f, 
    0.33838621f, 0.20119475f, 0.25801688f, 0.17631650f, 0.18220042f, 0.38236701f, -0.03676457f, 0.11714136f, 
    -0.40792817f, -0.32534754f, -0.09920875f, -0.08372046f, 0.01584966f, 0.23376492f, 0.19982253f, -0.10852271f, 
    0.10989381f, 0.05806131f, -0.02198158f, 0.01368617f, -0.26575619f, -0.23896554f, 0.02862959f, -0.02707728f, 
    0.54626596f, -0.07125965f, -0.22371094f, -0.27189493f, -0.02886878f, 0.04396616f, 0.19238791f, -0.28419673f, 
    -0.13775879f, 0.05916104f, -0.12972972f, 0.03932957f, -0.11441924f, 0.04792249f, -0.04982876f, 0.07800383f, 
    0.16172937f, -0.03151233f, -0.08632201f, -0.24979727f, -0.49224091f, 0.14130019f, 0.15552075f, 0.04618518f, 
    0.16077566f, 0.12650724f, 0.24221560f, -0.16499214f, 0.08572405f, 0.18003054f, -0.36051166f, 0.43946239f, 
    -0.19879173f, 0.03729178f, 0.05159151f, 0.01850809f, 0.11532488f, -0.02805952f, -0.00229339f, 0.24374476f, 
    0.07128648f, -0.04879516f, 0.18308587f, 0.20416407f, 0.27183226f, -0.25317097f, -0.06527504f, -0.06075923f, 
    -0.24036004f, 0.00266268f, -0.26192188f, -0.14203261f, -0.21712661f, -0.09547714f, 0.13998207f, 0.02988005f, 
    0.33451444f, 0.06731005f, 0.04170309f, -0.00898692f, -0.20606315f, -0.05981923f, 0.19135369f, -0.02944350f, 
    0.20213738f, 0.14627294f, -0.17656495f, -0.21994245f, -0.01261611f, 0.17709082f, 0.07438604f, -0.02988734f, 
    -0.05659601f, -0.05211446f, -0.01245666f, 0.02964235f, -0.28477645f, 0.26465458f, 0.04913732f, 0.09524354f, 
    -0.18714124f, 0.11983103f, -0.07592171f, 0.01781734f, -0.08922559f, -0.06004011f, -0.18309101f, -0.11294792f, 
    0.24840699f, -0.06630730f, 0.14004655f, -0.42249462f, 0.17661729f, -0.10380036f, 0.01890091f, 0.19275375f, 
    -0.04631836f, -0.12197108f, 0.01469634f, -0.06092150f, 0.02663167f, 0.00630817f, -0.12948826f, 0.13244087f, 
    -0.13529639f, 0.09524142f, 0.15742418f, -0.04540284f, 0.30716252f, -0.30635029f, 0.11149548f, 0.10446651f, 
    0.04018017f, -0.10837144f, -0.15025137f, 0.09972643f, -0.02665143f, -0.08304223f, 0.20737389f, -0.00817251f, 
    -0.17612109f, 0.34813845f, -0.04797183f, -0.03326874f, -0.29909956f, 0.02043999f, 0.27492660f, 0.11390743f, 
    0.61555684f, -0.21405314f, -0.04626680f, 0.10801746f, -0.08209563f, 0.35155588f, -0.14116110f, -0.08182677f, 
    0.05191743f, 0.24014840f, 0.07319301f, 0.19825423f, 0.02718708f, 0.29038066f, 0.03373215f, 0.31204674f, 
    0.08189292f, 0.31996962f, 0.03427400f, 0.07207695f, -0.10295057f, -0.08754218f, -0.02255559f, 0.06914789f, 
    0.12980245f, 0.11498849f, 0.05570341f, -0.49802318f, 0.04515459f, 0.13986459f, -0.17225012f, -0.21596423f, 
    -0.19043306f, 0.34292015f, -0.10337083f, 0.02313784f, 0.06923473f, -0.14012663f, -0.10922690f, 0.20223178f, 
    -0.14919978f, 0.12534101f, 0.13760796f, 0.21785820f, 0.32695073f, 0.20654266f, 0.06185717f, -0.09960709f, 
    0.20596422f, -0.30836564f, -0.09261227f, 0.05982788f, 0.15538774f, 0.14374822f, 0.13488078f, 0.08025853f, 
    0.15777262f, -0.13714123f, 0.07318284f, -0.23350829f, -0.31244624f, 0.14221622f, 0.16511288f, -0.03826642f, 
    -0.57082242f, -0.15336512f, -0.05731564f, -0.08021663f, 0.10170826f, 0.02536162f, -0.03579094f, 0.27433789f, 
    0.00761827f, 0.24349590f, 0.20837042f, -0.08428113f, 0.12014269f, 0.18577319f, -0.09705480f, 0.11828118f, 
    -0.11073309f, -0.02600713f, 0.10120714f, 0.02712847f, 0.09731826f, -0.15500362f, -0.24457504f, 0.00850054f, 
    0.19674943f, 0.29884106f, 0.04704829f, 0.39348245f, -0.08317330f, -0.01396967f, 0.04582501f, -0.11672910f, 
    0.08254038f, 0.05476387f, 0.03688163f, 0.10772093f, 0.09998260f, 0.04214974f, -0.19769517f, 0.16946428f, 
    -0.24968845f, -0.05441427f, 0.10734168f, 0.02056057f, 0.21771520f, 0.17009588f, 0.04553414f, -0.00643518f, 
    0.11875834f, -0.11592235f, 0.00492003f, 0.01913766f, 0.10326705f, 0.02281803f, 0.04351542f, -0.05032696f, 
    -0.53490937f, 0.06785116f, 0.04390660f, -0.03210615f, 0.16690496f, 0.16084935f, -0.17110029f, 0.09007490f, 
    -0.15285878f, 0.21276788f, 0.10460880f, 0.56876123f, 0.02687531f, -0.06709232f, 0.09517777f, -0.00828282f, 
    0.24272506f, 0.30729952f, 0.02266815f, 0.02792875f, -0.15568487f, -0.09101707f, -0.01200700f, 0.15492240f, 
    -0.04759708f, 0.23760930f, -0.01919589f, 0.10593718f, 0.18257552f, 0.13639598f, -0.02563081f, -0.03159131f, 
    -0.16826218f, 0.00135003f, 0.00192775f, -0.20008479f, 0.01007115f, 0.05965412f, 0.36799932f, -0.68379176f, 
    0.07361924f, 0.11067057f, -0.10073549f, 0.01977552f, 0.06153069f, 0.06261640f, 0.12469317f, 0.01006588f, 
    0.15337911f, 0.10254183f, 0.04885140f, -0.19809556f, -0.12386286f, -0.01282974f, 0.26718163f, 0.04285010f, 
    0.23005372f, -0.12198450f, -0.00200145f, 0.00220072f, 0.32405117f, 0.11168739f, -0.26536351f, -0.05050284f, 
    0.30207339f, -0.22695298f, -0.08648271f, -0.00279767f, -0.04464566f, 0.04333379f, -0.03225042f, 0.04252517f, 
    0.26328120f, -0.09643707f, -0.10095545f, -0.30349430f, 0.06554728f, 0.38052085f, 0.06047748f, -0.13091195f, 
    -0.11871889f, -0.30357897f, 0.14850405f, 0.04633512f, -0.27279854f, 0.01386901f, -0.02115866f, -0.09715767f, 
    -0.05335352f, 0.21974415f, -0.02305658f, 0.10689640f, -0.10447851f, -0.07246741f, 0.11745427f, -0.05162441f, 
    -0.04843564f, -0.13711180f, 0.08700320f, -0.16260654f, 0.27029043f, 0.09981503f, -0.22429448f, 0.30789572f, 
    -0.00979411f, 0.02747663f, -0.00390107f, 0.19637139f, -0.05286357f, 0.16815855f, 0.13235459f, -0.28888902f, 
    0.13995267f, 0.13692935f, 0.11321837f, 0.07957873f, 0.01767142f, -0.05413264f, -0.14418043f, 0.13334998f, 
    -0.44883254f, 0.10857815f, 0.01587297f, -0.05815531f, -0.16361026f, -0.04768250f, 0.13693097f, 0.11533634f, 
    -0.08313390f, 0.06331252f, -0.11206611f, -0.04077391f, 0.05427923f, 0.07931368f, -0.04843659f, -0.10729960f, 
    0.05781101f, -0.11606815f, 0.00418595f, 0.00827055f, -0.01395605f, 0.00459129f, -0.02630134f, -0.11584858f, 
    -0.07493789f, 0.03927819f, 0.02204040f, 0.03596823f, -0.00416048f, 0.00840186f, -0.00306548f, -0.16605677f, 
    0.04012358f, -0.07701661f, 0.06107990f, -0.02893591f, -0.00775924f, 0.01914303f, -0.12399894f, 0.07877466f, 
    -0.17689233f, 0.00056693f, -0.06626762f, 0.01169856f, -0.17464577f, 0.02527514f, -0.15165657f, -0.04911157f, 
    -0.08164841f, -0.01255023f, 0.02861145f, -0.16230315f, -0.11447720f, 0.04470821f, -0.00513366f, -0.10400911f, 
    0.00357035f, -0.06679040f, -0.11750081f, 0.03851062f, -0.05146599f, -0.03630219f, -0.02576941f, 0.02030844f, 
    0.05994921f, -0.14189872f, -0.07619845f, 0.03911354f, -0.00471313f, 0.01139861f, 0.08109633f, -0.07251056f, 
    -0.02875287f, -0.01113980f, -0.10347301f, -0.18817832f, -0.03530538f, -0.00679401f, 0.21607383f, -0.02153059f, 
    -0.27034506f, -0.06389635f, 0.10604652f, 0.12717435f, 0.12112572f, -0.00062178f, 0.00383435f, 0.30465773f, 
    0.13467038f, 0.21001169f, 0.18473333f, 0.15686868f, 0.32464620f, 0.05501852f, 0.00513003f, -0.09934433f, 
    -0.10125259f, -0.06061979f, -0.11406316f, -0.13611579f, -0.16894361f, -0.13682674f, 0.04507434f, 0.09043825f, 
    0.18740647f, 0.25645590f, 0.18551233f, 0.19042905f, -0.03789339f, 0.16788742f, 0.09640294f, -0.05122077f, 
    -0.25006399f, 0.18863524f, -0.12302016f, 0.15783642f, -0.09293424f, -0.15282987f, -0.50967097f, 0.27191871f, 
    -0.14159656f, -0.24314867f, -0.14913970f, -0.00837637f, 0.00742720f, 0.53402382f, -0.28964368f, -0.28428990f, 
    0.05486643f, -0.14774816f, 0.12568073f, 0.02894008f, 0.03824128f, -0.13128358f, -0.03708322f, -0.03575981f, 
    -0.30981985f, -0.17243327f, -0.05629034f, -0.03977976f, -0.07679176f, 0.04345933f, 0.05090205f, 0.08875234f, 
    0.70187521f, 0.06090969f, 0.21096241f, 0.12051120f, 0.02651045f, -0.11536551f, 0.01319238f, 0.17732078f, 
    0.21328233f, -0.15329176f, 0.15771049f, -0.00670240f, 0.12292372f, -0.04295370f, 0.01492083f, 0.06418689f, 
    -0.35086533f, 0.33310622f, -0.07681132f, 0.11379133f, 0.01844891f, 0.05511670f, -0.08374212f, -0.01220257f, 
    -0.10841949f, 0.01227936f, -0.08980606f, -0.02655138f, 0.31333861f, 0.10524113f, -0.12957546f, -0.31500694f, 
    0.08451506f, 0.15695447f, -0.05528261f, 0.19641128f, -0.06307851f, 0.06194421f, 0.08607475f, 0.15565531f, 
    0.07932058f, 0.17978007f, 0.03884225f, -0.40188017f, 0.09697875f, 0.52058202f, -0.00203240f, -0.18969323f, 
    -0.07642999f, -0.48239723f, 0.11397462f, -0.19579078f, 0.29613706f, 0.11461347f, -0.14992805f, -0.01095537f, 
    -0.08376297f, 0.07925515f, 0.05461518f, 0.05884441f, -0.08138967f, 0.12618382f, -0.20681569f, 0.09357023f, 
    -0.50406235f, 0.06058383f, 0.07298081f, 0.37478867f, 0.01473569f, -0.05519868f, -0.05307082f, 0.24036324f, 
    0.19525027f, 0.11639396f, -0.00789115f, -0.04318179f, -0.10553838f, -0.29762915f, 0.11844756f, 0.17127813f, 
    -0.05594883f, 0.35756129f, -0.06390209f, -0.00724719f, 0.22326998f, -0.08329481f, -0.27721468f, 0.13003848f, 
    -0.25708562f, -0.07912958f, -0.16754800f, -0.01143262f, -0.27357826f, -0.12720327f, 0.42819643f, -0.16380948f, 
    0.03236505f, -0.45700890f, -0.01648344f, 0.01378286f, -0.07243948f, 0.25782913f, 0.03646297f, -0.20464943f, 
    -0.07965359f, 0.21586967f, 0.22522214f, -0.27683127f, -0.35115179f, -0.67644858f, 0.22322732f, -0.04392099f, 
    0.37670034f, 0.08468477f, -0.19659215f, 0.19497961f, 0.30443829f, 0.23346998f, 0.15941416f, -0.01966060f, 
    -0.14976010f, 0.13672996f, 0.11984108f, 0.00428917f, 0.07379434f, 0.23598668f, -0.12075048f, 0.00305363f, 
    0.15098009f, 0.08489718f, 0.02188447f, 0.01132242f, -0.05704556f, -0.16019511f, -0.00199544f, 0.02313300f, 
    -0.16787761f, 0.18523966f, 0.20754153f, -0.04574725f, 0.16936393f, -0.15779769f, -0.05932147f, 0.06276233f, 
    0.00185466f, -0.00059311f, 0.09459060f, 0.06390667f, 0.00495076f, 0.15097564f, 0.09690282f, -0.04767306f, 
    -0.02924959f, -0.38787094f, -0.39923808f, -0.12941983f, -0.40234196f, 0.24415293f, 0.10681760f, -0.40140274f, 
    0.04880793f, 0.15171309f, 0.05942208f, 0.07560652f, -0.05183583f, -0.04329631f, 0.12457880f, 0.21871538f, 
    0.03878091f, -0.11187533f, -0.12560996f, -0.05888256f, -0.33656138f, 0.10676088f, 0.03678508f, 0.03945098f, 
    -0.21742009f, 0.08542932f, 0.12118521f, 0.10605833f, 0.22271103f, -0.41153404f, -0.13285781f, -0.06338002f, 
    0.01772911f, 0.05321718f, 0.05921927f, -0.05567487f, 0.05968172f, -0.08644672f, 0.06776719f, -0.05135744f, 
    -0.01199308f, -0.01534274f, -0.14782204f, -0.10567065f, 0.00747402f, -0.14452663f, -0.01013173f, 0.06891417f, 
    0.00126031f, -0.00436800f, -0.08439639f, 0.00364810f, 0.00783834f, 0.09346662f, -0.04259802f, -0.11309619f, 
    -0.04427280f, -0.06349817f, -0.01798925f, -0.07059778f, -0.02805785f, -0.01561331f, 0.03855093f, 0.05960231f, 
    -0.11461113f, 0.08433511f, -0.08851716f, 0.03350653f, -0.09032035f, -0.05831170f, 0.00059606f, -0.02008958f, 
    -0.05721912f, -0.03979032f, 0.02347863f, -0.11251868f, 0.06374048f, -0.02474455f, -0.15499732f, -0.07256080f, 
    0.10616212f, -0.10707320f, 0.01008073f, -0.10323085f, 0.05927707f, -0.07778613f, 0.06444133f, -0.15407287f, 
    -0.10476695f, -0.11003608f, -0.00799907f, 0.03902712f, 0.06896507f, 0.09789243f, -0.02232604f, -0.10911889f, 
    0.24372628f, -0.11259567f, 0.04849655f, -0.28952181f, -0.06313339f, 0.09917160f, 0.29861912f, -0.00625501f, 
    -0.22938037f, -0.08784090f, -0.05013590f, 0.07359640f, -0.02153057f, 0.12590477f, -0.11116164f, 0.36464974f, 
    -0.00946069f, -0.20308432f, 0.16266470f, -0.03685181f, 0.27174634f, 0.21232051f, -0.01685486f, 0.10126287f, 
    -0.58425391f, 0.04342661f, -0.11112116f, 0.28628808f, -0.09543473f, 0.08470470f, 0.16338170f, 0.08477355f, 
    0.12155451f, 0.36881056f, -0.00021903f, 0.29641122f, 0.28841719f, 0.30178615f, 0.02103155f, -0.09463958f, 
    -0.07789838f, 0.43789226f, 0.08549046f, 0.11102255f, 0.10573146f, -0.01873686f, 0.03487456f, -0.12113832f, 
    -0.00761494f, -0.06724835f, -0.01629691f, -0.14488570f, 0.05146265f, 0.14151460f, -0.06831432f, -0.15452328f, 
    -0.08683608f, -0.03551666f, 0.23613310f, -0.03590401f, 0.25479963f, -0.11059698f, -0.12525198f, -0.01919850f, 
    0.12259720f, 0.02578900f, -0.00187543f, -0.14429811f, -0.07903737f, 0.07858773f, -0.02206543f, -0.08851862f, 
    -0.06489325f, -0.08183976f, -0.11621744f, 0.05879366f, -0.01095301f, -0.11198039f, 0.07823057f, 0.01437994f, 
    -0.12932827f, 0.05640605f, -0.02799604f, -0.06423419f, -0.00818273f, -0.07205732f, -0.01094308f, -0.12452099f, 
    -0.09898917f, 0.08606817f, 0.09053242f, 0.00342826f, 0.04907724f, -0.06691962f, 0.02497079f, 0.08001642f, 
    -0.03478155f, -0.07104233f, 0.03181592f, -0.01223275f, -0.00551610f, -0.00464250f, 0.03086372f, -0.11501028f, 
    0.02744685f, -0.04925801f, 0.12242001f, -0.01537246f, 0.00817490f, 0.08583563f, 0.08187918f, 0.11292762f, 
    -0.11865472f, 0.07034943f, -0.04465228f, -0.14002806f, -0.03817867f, -0.11612122f, 0.06583761f, -0.14661773f, 
    -0.11088321f, -0.13126990f, -0.01828848f, -0.14498118f, -0.09588230f, -0.09803595f, 0.07673956f, 0.10837935f, 
    0.00774087f, -0.10726830f, 0.11942273f, 0.05852154f, -0.13183543f, 0.09630933f, 0.04839158f, 0.06400851f, 
    -0.10080865f, 0.01557776f, -0.05454163f, -0.00540115f, -0.10606962f, -0.11690676f, -0.01020747f, -0.01590797f, 
    -0.09862646f, -0.04410060f, 0.00359852f, -0.02398798f, 0.08477278f, -0.13873853f, -0.06116308f, -0.06125246f, 
    -0.06725898f, -0.01677610f, -0.10075216f, -0.01221339f, -0.06738119f, -0.05352076f, -0.05256128f, -0.03271401f, 
    0.08855236f, -0.06542123f, 0.04110941f, -0.03747481f, -0.04409060f, -0.11362576f, -0.00231960f, -0.11045001f, 
    0.04634821f, 0.02502263f, 0.00171606f, 0.03728843f, -0.11001523f, -0.07715434f, -0.07017577f, 0.02836376f, 
    0.01441351f, 0.04951525f, -0.01691663f, -0.07251230f, -0.00934948f, 0.02903287f, 0.07857776f, -0.10055291f, 
    -0.04243784f, -0.03208581f, -0.09375296f, -0.00900172f, -0.10293520f, -0.07894354f, -0.05805992f, 0.05602238f, 
    -0.15479879f, 0.16104549f, -0.08545286f, 0.05690423f, -0.11580390f, 0.20191722f, 0.36611506f, -0.05733984f, 
    0.65145659f, -0.05837204f, -0.18014124f, 0.21700464f, 0.06782397f, 0.28427556f, 0.04474820f, 0.11185430f, 
    0.04048612f, -0.26943615f, 0.06537521f, 0.00701184f, 0.00403688f, 0.07066240f, 0.07833099f, 0.26715910f, 
    -0.32809213f, 0.25097245f, -0.03514072f, 0.01826086f, -0.19191217f, 0.06149509f, -0.09110253f, -0.03374277f, 
    -0.03526481f, 0.04178031f, 0.16192406f, -0.44348386f, 0.20360871f, 0.03564674f, -0.22023898f, 0.02148744f, 
    0.03313827f, 0.21623488f, 0.03304287f, 0.22006416f, -0.10272336f, -0.00271544f, 0.09761582f, -0.14734609f, 
    -0.09276257f, -0.12813659f, -0.04285012f, -0.46619782f, 0.11079920f, -0.18477307f, 0.23006374f, -0.05168581f, 
    -0.05451282f, -0.25874063f, -0.06762220f, -0.22653121f, 0.31366262f, 0.09543192f, -0.05054962f, 0.10631852f, 
    0.71915352f, -0.54487962f, -0.01826060f, -0.05626307f, 0.22507524f, -0.13728805f, 0.12028363f, -0.13452320f, 
    -0.15720211f, -0.10884787f, 0.34474355f, -0.29215038f, -0.00376749f, 0.02524966f, -0.10116119f, 0.14606279f, 
    -0.00918964f, -0.61607200f, 0.08480669f, -0.06435406f, 0.02318623f, 0.13782147f, -0.05766629f, -0.11681683f, 
    -0.01927706f, 0.07669841f, 0.10435105f, -0.03839535f, 0.09300421f, -0.38164744f, -0.14060536f, 0.08737435f, 
    0.11226780f, 0.02693060f, 0.07634144f, 0.50932854f, 0.22882096f, -0.14155860f, 0.15428562f, 0.01783810f, 
    0.31266850f, -0.01728682f, 0.03454509f, 0.06841552f, 0.07048760f, 0.23360066f, -0.04871166f, -0.11840061f, 
    -0.07838035f, -0.09920450f, 0.09447437f, -0.02637918f, -0.07507763f, 0.24993910f, -0.34644353f, 0.18538615f, 
    -0.24434584f, 0.13653484f, 0.12543759f, 0.02343546f, 0.17284428f, 0.12798980f, 0.07780989f, 0.05742236f, 
    0.32566899f, -0.09632256f, -0.07925545f, -0.26339644f, -0.09204467f, -0.35298026f, -0.09417091f, 0.13593844f, 
    -0.09206927f, -0.14006832f, -0.04122032f, -0.41948438f, 0.05964130f, -0.09231228f, 0.07544819f, -0.17042437f, 
    -0.05420220f, -0.36854172f, 0.09557961f, 0.02338509f, -0.17698662f, 0.09121240f, -0.00323002f, 0.20557597f, 
    -0.22219703f, -0.34198132f, 0.06036973f, -0.18297035f, -0.49883214f, 0.16179632f, 0.10036396f, -0.07609151f, 
    0.02373056f, 0.01695805f, 0.03517339f, 0.46152166f, 0.42569503f, 0.17984766f, -0.00783012f, 0.43911651f, 
    -0.09179943f, -0.00257203f, -0.03914355f, 0.01960632f, 0.08667594f, 0.06937295f, -0.11031811f, 0.28252649f, 
    0.24557528f, 0.10154589f, 0.24252206f, 0.27362749f, 0.10975485f, 0.20526567f, -0.01971742f, 0.20742875f, 
    -0.16302516f, -0.29085049f, -0.19232318f, -0.04709248f, -0.00406884f, 0.09271396f, 0.11429231f, -0.01019008f, 
    0.08162569f, -0.02397209f, -0.03353992f, -0.06358226f, 0.08700703f, 0.07062175f, -0.01248649f, -0.07414513f, 
    0.06362295f, 0.01391271f, 0.02512248f, -0.05429789f, -0.11914319f, -0.05552442f, -0.05574401f, -0.08751508f, 
    0.02142753f, -0.01745615f, 0.03700438f, -0.03888062f, 0.05479165f, -0.02878398f, -0.08714151f, -0.12416170f, 
    -0.06159448f, -0.13674243f, 0.00477415f, -0.09022710f, -0.00175391f, -0.11544416f, -0.04138700f, -0.02667607f, 
    -0.13847807f, 0.04485024f, -0.10549816f, -0.07340527f, -0.00902700f, -0.01124617f, 0.11056995f, -0.07759791f, 
    -0.08143381f, 0.00861729f, -0.04363817f, 0.09473793f, -0.01590508f, -0.11113275f, -0.07786164f, -0.11165130f, 
    -0.02815905f, -0.11856358f, -0.02648784f, 0.09012726f, -0.06536540f, 0.10106480f, 0.04343052f, -0.14496997f, 
    0.08061653f, -0.03440244f, -0.11554863f, 0.11024688f, 0.04453501f, -0.00292718f, 0.01566506f, 0.07206929f, 
    0.39982688f, -0.19474709f, 0.15647124f, -0.05116824f, 0.21028800f, -0.17517056f, -0.10369840f, -0.07520806f, 
    -0.02071228f, 0.02290625f, 0.06032584f, -0.08493815f, -0.08278003f, 0.16330934f, 0.09433945f, -0.02883716f, 
    0.01915131f, -0.12115582f, -0.09475161f, 0.11240950f, 0.22659944f, 0.19984418f, 0.15775284f, -0.22056229f, 
    0.24744782f, -0.08769163f, -0.09584294f, -0.07130302f, 0.18542424f, -0.19624086f, -0.08130371f, 0.09863411f, 
    0.18523853f, 0.17020474f, 0.22137661f, 0.05293994f, -0.14416005f, -0.10665938f, 0.20263110f, 0.04433610f, 
    0.17366570f, -0.10905645f, 0.08878066f, 0.06099786f, 0.11030847f, 0.09894196f, -0.14587396f, 0.07406193f, 
    -0.02230615f, -0.00589285f, 0.06785573f, 0.23393950f, 0.22608919f, 0.12936856f, -0.07163693f, -0.01907398f, 
    -0.01298611f, 0.08576839f, 0.09943662f, 0.07909858f, 0.09339084f, -0.04910595f, 0.20164615f, 0.08642308f, 
    0.12404065f, 0.14958616f, -0.05194222f, 0.08211624f, -0.09928246f, -0.31264549f, -0.09159350f, 0.22428319f, 
    -0.05442249f, -0.07811680f, 0.31565160f, -0.28309247f, 0.05676077f, -0.25245917f, -0.04541502f, -0.35572273f, 
    0.03059545f, 0.09542179f, -0.09678955f, 0.01712857f, 0.22349167f, -0.03942880f, 0.00335465f, -0.08182333f, 
    -0.12728895f, -0.32539710f, 0.08193099f, -0.07029323f, -0.19479311f, 0.08271348f, 0.14218590f, 0.08230337f, 
    0.36321300f, 0.06080865f, 0.14184377f, 0.43419260f, 0.49508533f, 0.35349387f, -0.17376798f, 0.23186202f, 
    -0.00473782f, 0.26403522f, 0.03003007f, 0.01288255f, 0.08180565f, 0.14388940f, -0.05064338f, 0.53415185f, 
    0.24409918f, -0.01673039f, 0.09648596f, 0.21427613f, -0.02134200f, 0.66366524f, -0.18865903f, 0.23349881f, 
    -0.25309941f, -0.21353264f, -0.22971982f, 0.13613614f, -0.33098003f, 0.15238523f, 0.27869168f, 0.06648849f, 
    0.07133126f, 0.34289369f, 0.11286147f, 0.06349302f, -0.21481095f, -0.20004761f, 0.25626448f, -0.17619084f, 
    0.35202926f, 0.10504360f, -0.02503271f, -0.10174961f, 0.03665861f, -0.00562377f, -0.06914987f, 0.09043498f, 
    0.00517684f, 0.17698613f, 0.11395032f, 0.21201931f, 0.23828174f, 0.19042212f, 0.08217286f, 0.12339772f, 
    -0.68047661f, 0.09459227f, 0.02437314f, 0.08801781f, -0.33712766f, 0.08184514f, 0.19624460f, -0.06034464f, 
    0.21132746f, 0.03846293f, 0.21914642f, -0.22936077f, 0.21286924f, 0.09984007f, -0.23828277f, 0.40229011f, 
    -0.64229441f, 0.21222933f, 0.09992232f, 0.10851573f, 0.00457686f, -0.16748650f, -0.17784317f, 0.20750900f, 
    -0.26595229f, -0.34339708f, -0.03347417f, -0.12070690f, 0.08063084f, -0.06584828f, -0.13860209f, -0.09205380f, 
    0.20021027f, -0.00817655f, 0.04317346f, -0.06677271f, 0.10726111f, -0.28418803f, 0.03529930f, -0.12461843f, 
    -0.11343328f, -0.23735772f, -0.08097610f, -0.50824612f, -0.21484126f, 0.05648509f, -0.09181366f, 0.06868088f, 
    -0.38179919f, -0.08558638f, -0.04406553f, 0.25783342f, -0.11264925f, 0.08584190f, -0.00174911f, -0.09913029f, 
    -0.05783710f, 0.12111337f, -0.03761445f, 0.04690650f, -0.13965404f, 0.17212969f, 0.06361326f, 0.07288741f, 
    0.03600477f, -0.10340626f, 0.01006529f, -0.08618471f, -0.19499497f, 0.07949891f, -0.17473508f, 0.11318489f, 
    -0.10602529f, 0.29621804f, 0.00949446f, 0.54202628f, 0.05928422f, 0.09477591f, 0.17000031f, -0.01272858f, 
    -0.02576091f, -0.12244890f, 0.12527908f, 0.10626698f, -0.07540005f, 0.15097016f, -0.06781747f, 0.30651617f, 
    0.09124186f, 0.17606969f, -0.03309015f, 0.17617962f, 0.13938977f, 0.13791512f, 0.08813824f, 0.07321005f, 
    -0.03529784f, -0.23855263f, -0.23514429f, 0.13287500f, 0.06478958f, 0.09900261f, -0.07220735f, 0.03065213f, 
    -0.09921274f, -0.11690066f, 0.02011287f, 0.04176698f, -0.06858185f, 0.06006432f, -0.17669721f, 0.18209833f, 
    -0.55052149f, 0.00810957f, 0.21652706f, 0.07725900f, -0.07558212f, -0.23760259f, 0.14300162f, 0.02406257f, 
    0.31173474f, -0.20443773f, 0.04249467f, 0.02136561f, 0.08166552f, -0.21804473f, -0.06041335f, 0.06727124f, 
    -0.04392884f, 0.12126721f, 0.03009256f, -0.05849413f, -0.15688273f, 0.03072896f, -0.04186866f, 0.07877815f, 
    -0.22000831f, -0.09989624f, -0.22117414f, 0.55758435f, 0.06778939f, 0.06492625f, 0.04529920f, -0.38253349f, 
    0.15583731f, 0.21755858f, 0.06969661f, 0.13721900f, 0.06904563f, 0.21157953f, 0.15614007f, 0.04188973f, 
    0.12507443f, 0.27568662f, 0.01185388f, -0.14295636f, -0.42878073f, 0.49227992f, 0.01913642f, 0.12852719f, 
    0.16285548f, -0.15976661f, -0.02976228f, 0.11424574f, 0.06226617f, 0.29620287f, 0.05687903f, -0.02150570f, 
    0.61814249f, -0.03890442f, -0.09107871f, 0.14812121f, 0.01478282f, -0.30399024f, -0.61532402f, 0.21680020f, 
    -0.16905275f, 0.11306710f, 0.09164944f, -0.05115066f, 0.01872342f, 0.00188737f, -0.00993241f, 0.03278035f, 
    0.17933677f, -0.14280388f, -0.33177879f, 0.06754456f, -0.05434642f, -0.26413989f, 0.05742329f, -0.06954945f, 
    0.06074854f, 0.28261280f, 0.11479876f, -0.05078103f, 0.03494408f, -0.12147949f, -0.07777235f, 0.05551964f, 
    0.11437553f, -0.07684772f, -0.17642057f, -0.45576361f, -0.02026618f, -0.15649468f, 0.51540416f, 0.04630137f, 
    -0.04816620f, -0.19411449f, 0.10932973f, 0.01291312f, -0.02748485f, 0.22700089f, 0.15377879f, -0.06299485f, 
    -0.18440308f, 0.07394016f, 0.28439879f, -0.07852218f, 0.03896321f, -0.17976594f, -0.24260858f, 0.07682808f, 
    0.34484351f, 0.12282629f, -0.22343388f, 0.16472419f, 0.01715494f, 0.25831690f, 0.12960094f, -0.05836083f, 
    -0.40845150f, -0.16159856f, 0.01158448f, -0.37768698f, -0.12774800f, -0.06223524f, 0.03698404f, 0.04498470f, 
    0.05618561f, -0.09633458f, 0.04382941f, 0.19909905f, 0.11434636f, -0.20440248f, -0.01398191f, -0.04750091f, 
    0.11466003f, 0.19705297f, 0.03099822f, -0.00266876f, -0.14695698f, 0.07000746f, -0.08673722f, 0.16468103f, 
    -0.09665333f, -0.26280963f, 0.12882519f, -0.36680061f, -0.36668175f, 0.20758526f, -0.14548533f, 0.05752557f, 
    -0.11800560f, 0.12996779f, 0.15689266f, 0.22820203f, 0.15240440f, -0.03836295f, 0.32792374f, 0.03760403f, 
    -0.03123952f, 0.04637938f, 0.11975891f, 0.03215308f, -0.11662424f, 0.15747073f, 0.02902663f, 0.38178879f, 
    0.12562536f, 0.01746466f, 0.23349403f, 0.18424860f, 0.07932945f, 0.36967322f, 0.05113963f, 0.09133081f, 
    -0.25140500f, -0.65157408f, -0.18099010f, -0.06943893f, 0.17555751f, 0.24551630f, -0.01475485f, -0.05766043f, 
    0.08802343f, 0.06470200f, 0.02813795f, -0.03066580f, -0.08507905f, -0.04094930f, 0.10040611f, 0.00734679f, 
    -0.00288934f, -0.10780868f, 0.05342929f, 0.02197907f, 0.01120967f, -0.11194167f, 0.07686955f, -0.00960162f, 
    -0.11476821f, 0.03787303f, -0.13380529f, 0.06958893f, 0.03515991f, -0.01579469f, -0.07775441f, -0.01177813f, 
    -0.01451892f, -0.06780089f, -0.10155763f, 0.06945302f, 0.02685475f, -0.08247115f, -0.15115638f, 0.06824322f, 
    -0.06979322f, 0.04079771f, -0.11625447f, 0.02236332f, 0.09991020f, -0.08393721f, 0.09886532f, 0.00308387f, 
    -0.04789048f, -0.09046330f, -0.01786946f, -0.07859245f, -0.00578910f, -0.05012691f, 0.03960485f, -0.06973487f, 
    -0.14057308f, -0.12561604f, -0.00611863f, -0.09030084f, -0.06786876f, 0.10843192f, -0.04605409f, 0.03529400f, 
    -0.00776260f, 0.03438308f, -0.03293813f, -0.13064176f, -0.12117109f, -0.13384445f, -0.11257571f, 0.02567205f, 
    -0.08378083f, 0.06150158f, -0.08981176f, 0.03397680f, 0.05075989f, 0.07107666f, -0.01641000f, -0.13055967f, 
    0.06194334f, 0.12467647f, -0.14065230f, -0.13077845f, 0.07470588f, 0.08664592f, -0.12252501f, -0.12315301f, 
    0.01576445f, -0.11298637f, -0.06379905f, -0.06875797f, 0.06007643f, -0.09831954f, -0.08068484f, -0.11857530f, 
    -0.06991301f, -0.03478523f, 0.10679379f, 0.00780230f, -0.02708808f, -0.00476642f, -0.08606258f, -0.12425063f, 
    -0.11658078f, -0.14876169f, 0.10492161f, 0.08465284f, -0.09734911f, 0.08177920f, -0.11239059f, 0.06583907f, 
    0.06420697f, 0.02194202f, -0.05725946f, 0.02610845f, -0.10795936f, 0.10087260f, -0.13410152f, -0.01700792f, 
    -0.16527970f, -0.05102209f, 0.04502528f, -0.05787551f, -0.00767781f, -0.12679730f, 0.07257263f, -0.07581776f, 
    -0.02804713f, -0.16135123f, -0.08934321f, -0.10551458f, -0.03645326f, 0.04357665f, -0.04189497f, 0.10568753f, 
    0.08143064f, -0.11246799f, 0.03234604f, -0.12560606f, -0.05236194f, -0.11834531f, 0.03679477f, -0.12298390f, 
    -0.02687794f, -0.12064666f, -0.09838292f, -0.03595419f, 0.03100863f, -0.10177481f, 0.04794829f, -0.02564464f, 
    0.07122816f, -0.14276531f, -0.11715053f, -0.04243585f, 0.02418198f, -0.07511117f, 0.03118433f, -0.10276233f, 
    0.11098448f, -0.06242011f, -0.08641188f, -0.01677994f, 0.07929616f, -0.05001157f, -0.07391982f, -0.09658867f, 
    0.12279092f, 0.00647709f, 0.03999505f, 0.05635486f, 0.03529523f, -0.00547546f, -0.06815103f, 0.11574675f, 
    0.08754866f, -0.14316273f, 0.04903273f, 0.05955004f, -0.03687590f, 0.01292555f, -0.02937964f, -0.07345519f, 
    -0.12377752f, -0.12454373f, -0.10379969f, -0.05901776f, -0.10822715f, 0.04107138f, 0.03314109f, -0.06214102f, 
    -0.05699426f, -0.11943790f, -0.04473261f, -0.01400026f, -0.14850202f, 0.01845903f, 0.04893781f, -0.06227718f, 
    0.05925258f, -0.03418121f, -0.07565264f, 0.05209855f, 0.03986363f, -0.06452119f, -0.13403384f, -0.11989933f, 
    -0.08731773f, -0.05364271f, -0.05009562f, -0.07985473f, -0.03447598f, 0.02066252f, -0.02394566f, 0.03025928f, 
    -0.06078282f, 0.08332372f, 0.05441169f, -0.09414861f, -0.11279655f, 0.03305221f, 0.03604767f, -0.01189333f, 
    0.00200294f, -0.12536727f, 0.01115523f, 0.00453142f, 0.05425230f, -0.12611715f, -0.09275999f, -0.09498027f, 
    -0.16484818f, 0.09794860f, -0.10032339f, 0.01377784f, -0.11007901f, -0.05441087f, 0.04855248f, -0.05200115f, 
    -0.08655648f, -0.08677577f, 0.11217780f, 0.00733826f, 0.10444610f, 0.09903615f, 0.05301686f, -0.01019299f, 
    0.00668547f, -0.08510198f, -0.06648722f, 0.06603115f, 0.02108248f, -0.09905770f, -0.11235705f, -0.08916002f, 
    0.02931476f, -0.15783510f, -0.01614085f, -0.15785573f, -0.04137319f, -0.02227412f, -0.00511956f, 0.07789476f, 
    -0.00705452f, -0.06279213f, 0.03607295f, -0.00751997f, 0.10275217f, 0.23441614f, -0.05013698f, 0.10132990f, 
    -0.02013726f, 0.18048383f, -0.22437632f, 0.15286262f, -0.14492495f, 0.26083282f, -0.01349864f, -0.07243859f, 
    -0.07926597f, 0.09828898f, 0.17055459f, -0.09498017f, -0.39845118f, 0.31500575f, -0.03705546f, 0.09595370f, 
    0.05133605f, 0.43627411f, -0.03771603f, -0.09140790f, -0.14218640f, 0.00724220f, -0.33147401f, 0.06718861f, 
    0.03989102f, 0.28100488f, 0.24306278f, -0.13516741f, -0.13859133f, 0.08484392f, 0.34415004f, 0.25289533f, 
    -0.04978567f, -0.10125400f, 0.12460816f, 0.29720730f, 0.09128457f, 0.06749938f, 0.16686447f, -0.04984983f, 
    0.10983306f, 0.22099183f, 0.06263977f, 0.00294992f, 0.08802806f, -0.26926985f, 0.08926718f, 0.06016478f, 
    0.14327450f, 0.01000848f, -0.12700154f, 0.21669984f, 0.03430958f, 0.19755092f, 0.08324797f, -0.08279997f, 
    -0.00538420f, -0.17217888f, -0.07033363f, -0.22175734f, -0.05903170f, 0.20691600f, 0.08076885f, 0.03517490f, 
    0.12323906f, -0.06342255f, -0.17589179f, -0.02546598f, 0.03433359f, 0.23597541f, 0.03564531f, 0.16749984f, 
    0.02986690f, -0.28978994f, 0.18538794f, -0.01789770f, -0.42996204f, 0.05607526f, 0.13277969f, 0.04859347f, 
    -0.07688891f, 0.03149346f, 0.02629212f, -0.02998393f, -0.17898835f, 0.04628769f, -0.09544893f, 0.10775420f, 
    0.16781031f, 0.21215363f, 0.19143048f, 0.12287736f, 0.18820950f, 0.08963186f, -0.00469826f, -0.02602310f, 
    0.00942206f, 0.11114123f, -0.08912925f, 0.04016017f, -0.02939250f, -0.11530303f, -0.16304399f, -0.01547624f, 
    -0.01949137f, 0.14606911f, 0.23411503f, 0.06566145f, 0.09512921f, 0.03592657f, 0.03506925f, 0.18422902f, 
    -0.32765305f, -0.33415467f, -0.08943148f, -0.06817168f, 0.21577823f, -0.06569658f, 0.17010044f, -0.10630014f, 
    -0.11052135f, -0.14246418f, -0.11300965f, 0.02532700f, -0.13817891f, 0.04387423f, -0.09037012f, 0.04677894f, 
    -0.07321325f, -0.08083223f, 0.03477285f, 0.01664136f, -0.05690670f, -0.15218736f, 0.00902888f, 0.00461183f, 
    -0.03301565f, -0.04882786f, -0.08811381f, 0.09889708f, -0.10241750f, -0.08526206f, 0.05414701f, 0.01107704f, 
    -0.15380728f, 0.01545530f, -0.10510446f, -0.02517735f, -0.15251958f, 0.07557826f, -0.01268827f, -0.12449914f, 
    0.08959193f, -0.08214973f, -0.11045893f, -0.09347816f, -0.02984591f, -0.03797106f, -0.02443474f, 0.08401734f, 
    0.05209958f, -0.11704177f, -0.09352382f, -0.02294748f, 0.00308259f, -0.09028036f, -0.08585423f, -0.13250369f, 
    -0.13028957f, 0.04406316f, -0.05087655f, -0.02574736f, 0.08064731f, -0.05975190f, -0.10453692f, 0.04426292f, 
    0.04356490f, -0.13205360f, 0.06403313f, 0.02853501f, 0.02561849f, -0.11793179f, -0.09541394f, -0.11239874f, 
    -0.09343588f, 0.00686303f, -0.08804511f, -0.08720328f, -0.11355101f, -0.02090292f, -0.04827150f, 0.11965389f, 
    -0.05303116f, 0.00181760f, 0.07064045f, -0.10617707f, -0.05225891f, 0.05975277f, 0.06607217f, -0.02476818f, 
    -0.11950184f, -0.04585649f, -0.13264456f, 0.02503088f, -0.06195007f, 0.08458816f, 0.02331127f, -0.06669603f, 
    -0.11609442f, 0.09331742f, -0.05743842f, -0.07417119f, -0.08708015f, -0.02644443f, -0.08751798f, 0.12130170f, 
    -0.01452596f, 0.09280341f, -0.10428110f, -0.02999325f, -0.11330202f, -0.06600665f, 0.06968841f, 0.02356301f, 
    0.10787093f, -0.08312846f, 0.03061022f, -0.07306608f, -0.01822843f, 0.11116416f, 0.05134952f, -0.11715089f, 
    -0.09777197f, -0.11135382f, 0.08353005f, 0.09963965f, -0.10476582f, 0.03002957f, 0.09571625f, -0.01994782f, 
    0.08238588f, -0.10446647f, -0.08807027f, -0.12528056f, -0.08070909f, -0.00240713f, 0.07836893f, 0.09474014f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.05418407f, 0.01755977f, 0.12474479f, 0.22681211f, -0.15959686f, -0.02496883f, 0.32538036f, 0.13739449f, 
    -0.02948752f, -0.03816624f, 0.16323471f, 0.20780779f, 0.22048627f, 0.08104531f, 0.17562748f, 0.09930460f, 
    0.21185970f, 0.03666703f, -0.10338757f, 0.18235761f, 0.13957320f, -0.08056225f, -0.00385866f, 0.20431009f, 
    0.07500427f, 0.24691482f, 0.10737797f, 0.09028174f, -0.08200055f, -0.03706009f, 0.13146800f, 0.13095708f, 
    0.16410500f, 0.12217341f, 0.13231373f, 0.23415074f, -0.14143106f, -0.12377714f, 0.06081673f, 0.32355154f, 
    -0.30055487f, -0.12254839f, 0.18901137f, -0.09352145f, -0.14419265f, 0.14279135f, 0.08442314f, 0.09117256f, 
    -0.11208446f, 0.06526597f, 0.11429363f, -0.15679397f, 0.18465681f, 0.16597821f, 0.17379147f, -0.13529710f, 
    -0.05574885f, 0.03091016f, -0.05084450f, -0.13487619f, 0.27209631f, 0.04770207f, -0.03528336f, -0.03787917f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.09937709f, -0.07919705f, -0.04339379f, -0.60891992f, -0.07393363f, -0.10391220f, -0.60526192f, -0.40342754f, 
    0.32122684f, 0.22766824f, -0.02833529f, -0.50296646f, -0.29542491f, 0.13127913f, 0.13307983f, -0.40165961f, 
    0.01507186f, 0.04199293f, -0.10020769f, 0.01405710f, 0.09182887f, -0.16131258f, 0.19514289f, -0.27332172f, 
    0.02918223f, -0.12749508f, -0.26832995f, -0.35458195f, -0.30283949f, -0.27212125f, -0.15052079f, 0.01161172f, 
    0.18521205f, 0.00643613f, -0.06107930f, -0.07718670f, -0.07897551f, 0.22993757f, 0.19053018f, -0.34807134f, 
    -0.04625439f, -0.09865814f, 0.12348657f, -0.01339935f, 0.05594469f, 0.19689757f, -0.03017591f, -0.20873210f, 
    0.02313904f, -0.05026796f, 0.05944362f, 0.23978634f, -0.44634986f, -0.21830925f, -0.08735650f, -0.25861770f, 
    -0.05275217f, -0.14471576f, -0.02635515f, -0.01168263f, -0.57384747f, -0.07267142f, 0.07995523f, -0.08303177f, 
    0.75390291f, 0.08769593f, 0.32731882f, -0.24369965f, 0.11168299f, -0.07841327f, -0.06462464f, 0.06579105f, 
    -0.44080299f, 0.18422601f, 0.07296462f, -0.04206993f, 0.23286381f, 0.17580065f, 0.11391427f, -0.29189518f, 
    -0.06555660f, 0.10467828f, 0.04827723f, -0.22840618f, -0.03320434f, -0.14072682f, -0.58560365f, -0.13944928f, 
    0.17876716f, 0.11112198f, 0.07456160f, 0.10737546f, -0.06229703f, -0.44902658f, 0.01546247f, 0.18610600f, 
    -0.01836873f, 0.13250586f, -0.01623420f, 0.03414629f, -0.00675130f, 0.20986488f, -0.79968780f, 0.21272381f, 
    -0.21645324f, -0.01393716f, 0.09294745f, 0.06748997f, -0.12284882f, -0.02092407f, -0.00730154f, 0.02787806f, 
    -0.10578980f, -0.05000634f, 0.08036710f, 0.28901699f, -0.22487865f, 0.17657593f, 0.33076778f, -0.66678822f, 
    0.07582898f, 0.09045381f, -0.10997094f, 0.09517449f, 0.04427785f, -0.08646656f, -0.08904625f, -0.10516050f, 
    -0.24814251f, -0.01747154f, 0.25006801f, 0.14924034f, -0.04634264f, 0.06384176f, 0.16462187f, -0.09888586f, 
    -0.51663059f, -0.00587099f, 0.26677904f, 0.16100432f, 0.20239353f, -0.06974947f, -0.24489969f, 0.02321071f, 
    0.23333094f, 0.18225706f, -0.29633284f, 0.32054323f, -0.13091153f, -0.14873137f, -0.57894593f, 0.05538163f, 
    -0.37422854f, 0.16012079f, -0.70735592f, -0.01415573f, 0.07371234f, -0.25154245f, -0.55533552f, 0.19583857f, 
    0.08524703f, 0.17264090f, 0.01885322f, -0.11623540f, 0.11518652f, -0.41704002f, 0.00073828f, 0.15271960f, 
    -0.11425936f, 0.03223415f, -0.22920930f, 0.09752513f, 0.05781842f, 0.15326177f, 0.13575429f, -0.41774592f, 
    -0.11201930f, 0.10095365f, -0.55931753f, -0.33344942f, 0.17079970f, -0.43205631f, -0.11014932f, -0.07322254f, 
    -0.04823459f, -0.09013356f, 0.01635451f, -0.07810695f, 0.17916375f, 0.04371152f, 0.06169878f, -0.07289407f, 
    -0.34048429f, -0.02152471f, 0.09579182f, 0.17844570f, -0.12112886f, 0.04782296f, -0.18711340f, -0.23857267f, 
    0.07885017f, -0.51554936f, -0.17474756f, -0.16212329f, -0.17048083f, 0.08063692f, -0.10083800f, 0.03394152f, 
    -0.01684749f, -0.48262545f, 0.12050830f, -0.00279429f, 0.07490771f, 0.09790175f, 0.13205469f, 0.12880321f, 
    -0.40694800f, 0.11964230f, 0.00121363f, 0.01764868f, -0.28162891f, 0.13217616f, -0.56694889f, -0.02270751f, 
    0.00593374f, 0.19727978f, -0.06438972f, -0.09280505f, -0.06325039f, 0.18235764f, -0.00365261f, -0.90020460f, 
    -0.80504745f, -0.11095359f, 0.10814442f, -0.11325043f, -0.12363068f, -0.09132338f, 0.33379439f, -0.00399084f, 
    -0.07426605f, 0.20884836f, 0.01761047f, -0.22256881f, 0.09472840f, 0.20931189f, -0.26252958f, 0.09100429f, 
    -0.12216285f, -0.04059445f, -0.11801073f, 0.06514626f, -0.03112752f, 0.12844905f, -0.04322701f, 0.03329308f, 
    -0.68972880f, -0.09739226f, -0.51746058f, -0.16648056f, -0.22380376f, 0.08627732f, 0.09517416f, 0.05579821f, 
    0.16881454f, -0.08553179f, -0.40105003f, 0.09526512f, -0.59718072f, 0.01313057f, 0.09684895f, 0.01395519f, 
    0.04172577f, 0.17803262f, -0.06214117f, -0.53675443f, 0.07035217f, -0.35834631f, 0.14393292f, -0.04570566f, 
    -0.05271479f, -0.09766580f, 0.07610510f, -0.08763952f, -0.08509017f, -0.64344114f, -0.15271175f, 0.09050161f, 
    0.21180557f, 0.04433860f, 0.19895846f, -0.13361092f, -0.06702915f, 0.11473064f, 0.04372918f, -0.27381396f, 
    -0.13701214f, 0.03887551f, 0.12406070f, -0.08127200f, 0.05270419f, 0.19353761f, -0.32818121f, -0.02757775f, 
    0.05092324f, -0.14157523f, -0.00637917f, 0.04912955f, -0.04429448f, -0.46573454f, -0.08746440f, 0.10896564f, 
    -0.01143517f, -0.04940053f, -0.11600525f, -0.07808820f, 0.04169839f, 0.10531472f, 0.02357941f, 0.06442332f, 
    -0.34664893f, 0.07284583f, -0.21417998f, -0.37287676f, 0.13636860f, -0.11446296f, 0.11206064f, -0.09621942f, 
    -0.02914755f, 0.21637411f, -0.15507396f, 0.05638881f, 0.22294198f, -0.01097528f, 0.15674300f, 0.13862778f, 
    -0.06947668f, -0.08386736f, -0.16949327f, -0.14685227f, -0.14558154f, 0.18464825f, -0.02215328f, -0.03198235f, 
    -0.01010845f, 0.06645176f, 0.12975883f, -0.10213531f, 0.17963776f, 0.22956975f, 0.15456250f, 0.15045245f, 
    0.08250933f, 0.00636359f, -0.16314597f, 0.18213622f, -0.01204359f, -0.16023996f, -0.02271337f, -0.37483484f, 
    0.08042983f, -0.03578003f, 0.02446138f, -0.06360276f, 0.05646419f, 0.21696740f, -0.05458232f, 0.16395390f, 
    -0.05991554f, -0.10249010f, 0.02965973f, 0.06112474f, -0.14786443f, 0.06696842f, -0.36858565f, -0.19901367f, 
    -0.26098037f, -0.06575957f, -0.09354217f, -0.00152636f, 0.10509869f, 0.10411408f, -0.01319967f, -0.03171322f, 
    -0.12676524f, 0.00180885f, -0.03445319f, 0.17814426f, -0.09933572f, 0.02307958f, 0.28786930f, -0.00112540f, 
    -0.22099257f, -0.37220234f, 0.00206328f, 0.09079002f, -0.04150204f, -1.04232860f, -0.29253572f, 0.08513716f, 
    0.32276934f, -0.43312636f, -0.48489445f, 0.29806578f, 0.02752381f, -0.09773046f, -0.50206065f, 0.22009115f, 
    0.02569979f, -0.99966526f, -0.27293435f, -0.34053996f, -0.38982049f, -0.12846281f, -0.07617955f, -0.61579466f, 
    -0.32534361f, -0.51011992f, 0.25708151f, -0.10184012f, -0.04858078f, -0.35690644f, 0.13778289f, 0.30276999f, 
    0.05141747f, -0.00491397f, -1.11037767f, -0.02327188f, 0.02021786f, 0.14146411f, -0.08928499f, -0.34428701f, 
    -0.06371313f, -0.02725795f, -0.91613650f, -0.03494026f, -0.26399061f, 0.08018443f, 0.05476487f, -0.28962991f, 
    -0.09397046f, 0.11446066f, -0.02629889f, -0.02797423f, 0.19700100f, -0.69744116f, -0.04137848f, 0.06626716f, 
    -0.15422487f, 0.06111290f, 0.06038173f, -0.11442060f, -0.04474688f, 0.07272889f, -0.52500117f, -0.26433352f, 
    -0.22809507f, 0.19198373f, -0.24451326f, -0.45940810f, -0.11726276f, -0.57998550f, 0.00381686f, -0.11293894f, 
    -0.16998166f, 0.06547822f, -0.02673589f, -0.26754546f, -0.01856027f, -0.02012780f, 0.06111966f, -0.01446447f, 
    0.12858817f, -0.70006901f, 0.17066188f, -0.32846823f, 0.06688334f, 0.27655846f, 0.06320181f, -0.25648561f, 
    -0.42150542f, -0.15284149f, 0.07373216f, -0.13459450f, -0.11642707f, -0.30562538f, 0.43215355f, -0.20862867f, 
    0.08433142f, 0.11307627f, -0.43508691f, -0.04313734f, 0.07663739f, -0.32506675f, 0.12261637f, 0.23807178f, 
    -0.08827017f, -0.43465760f, 0.30500543f, -0.14600235f, 0.16643615f, 0.06172877f, -0.26170543f, 0.35064274f, 
    -0.12192781f, -0.10758292f, -0.10760722f, -0.04723433f, -0.58762360f, -0.48598865f, -0.10692903f, -0.07493410f, 
    -0.09122416f, -0.05704957f, -0.09772119f, -0.09189676f, 0.16474703f, 0.00108649f, -0.03506660f, 0.15022542f, 
    -0.32279816f, -0.29543784f, 0.19983855f, 0.02401513f, 0.28822622f, -0.02683704f, -0.58990133f, -0.08004349f, 
    -0.68658751f, -0.10668420f, 0.20650347f, 0.02139693f, -0.23142053f, 0.20168048f, -0.86624432f, -0.29039156f, 
    0.17384630f, -0.12090036f, -0.05149819f, 0.13004684f, 0.15122063f, 0.25816083f, 0.15808178f, 0.03336461f, 
    -0.53694546f, -0.44118890f, -0.20467286f, 0.25131190f, 0.05665396f, -0.44448334f, -0.66837835f, -0.03286272f, 
    -0.00294567f, -0.03249260f, -0.27479947f, 0.05842329f, 0.12374952f, -0.68050903f, 0.22052929f, 0.26815891f, 
    0.05367310f, 0.24851759f, 0.10389109f, -0.64906186f, 0.05068658f, -0.25757706f, 0.14896445f, -0.01539853f, 
    -0.15068936f, 0.03687708f, -0.06367684f, 0.06732722f, 0.06133871f, -0.08880379f, 0.06450828f, -0.11698315f, 
    -0.31728259f, -0.12148242f, -0.30571166f, 0.15734722f, -0.47361541f, -0.14732321f, 0.14675297f, -0.23235096f, 
    -0.18729109f, -0.11848960f, -0.52442616f, 0.00539188f, -0.25232300f, 0.13856648f, -0.23569942f, 0.07402815f, 
    0.03111744f, -0.20065010f, -0.47048461f, 0.08071595f, 0.21697059f, 0.19432250f, 0.24779339f, 0.23356526f, 
    -0.09739249f, -0.15420876f, -0.02954774f, -0.40305018f, -0.34799618f, -0.14486302f, -0.21846156f, -0.20842990f, 
    -0.11444166f, -0.01506516f, 0.18189353f, 0.15818684f, 0.06059427f, -0.36405087f, 0.19069487f, -0.03283429f, 
    -0.28224394f, 0.02287540f, 0.21970178f, -0.12410687f, 0.03386202f, 0.16761905f, 0.13319527f, -0.51520616f, 
    0.00143102f, -0.12855272f, -0.29017222f, -0.73192030f, 0.06679619f, 0.14889683f, -0.10871903f, -0.35151362f, 
    -0.16211173f, 0.03386623f, -0.07063777f, -0.08926007f, 0.11648395f, -0.09819714f, -0.07419493f, 0.02632392f, 
    -0.03064776f, 0.07211562f, 0.09815396f, -0.20510624f, -0.08985479f, -0.17382875f, 0.10407604f, 0.30373228f, 
    -0.29523119f, -0.30986300f, 0.26723310f, 0.16924056f, -0.13796689f, -0.38714170f, 0.09917785f, -0.39778695f, 
    -0.02698271f, -0.71093690f, 0.20188226f, -0.18241613f, -0.37474716f, -0.40617058f, 0.06440496f, -0.55204868f, 
    -0.49973625f, -0.06799164f, 0.06062322f, 0.28098315f, 0.14419121f, -0.22275689f, 0.28004760f, 0.05704715f, 
    0.21403210f, 0.03700902f, -0.20673318f, -0.09068189f, -0.10359050f, -0.09479187f, -0.58354700f, -0.31788573f, 
    -0.58825296f, -0.06700228f, -0.35232106f, 0.02179142f, 0.12291438f, -0.45037636f, -0.33407393f, -0.01079161f, 
    -0.11299394f, 0.14133918f, 0.17916183f, -0.24831802f, 0.21929103f, -0.42410776f, -0.49961159f, 0.06849080f, 
    -0.13275626f, 0.12064791f, -0.03071828f, -0.01126348f, 0.18483643f, -0.03992289f, 0.10535388f, -0.12761340f, 
    -0.16748442f, 0.04019566f, 0.23520787f, 0.15465157f, -0.31488222f, -0.09965868f, -0.05097908f, 0.19857961f, 
    -0.42769167f, -0.35375696f, 0.23373169f, 0.11292616f, -0.30820110f, 0.01575761f, -0.67983836f, 0.07226336f, 
    -0.04316920f, -0.22461987f, 0.24086167f, -0.07171609f, -0.14373845f, -0.17702201f, 0.11441845f, -0.05341104f, 
    0.00398766f, -0.08881024f, 0.21675548f, 0.05660065f, 0.14314422f, 0.22571801f, -0.25541970f, -0.19105653f, 
    -0.33190611f, 0.05795911f, 0.18490088f, -0.48871475f, 0.02698221f, -0.67284960f, -0.29973918f, 0.17565374f, 
    0.03863851f, 0.09261415f, -0.12574501f, 0.02999485f, 0.00621728f, -0.14542338f, -0.44810981f, 0.01901349f, 
    -0.02539016f, -0.28440660f, -0.01665083f, -0.40790531f, 0.18426368f, 0.11322397f, -0.15479310f, 0.31334138f, 
    0.01230570f, 0.00293839f, 0.08936220f, -0.03076481f, -0.03485395f, -0.07861153f, 0.08558624f, 0.06115889f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.37232736f, -0.01183556f, -0.14553909f, -0.09005414f, 0.01983640f, -0.17045774f, -0.08832759f, -0.04490670f, 
    -0.13206482f, 0.25483111f, 0.04772453f, -0.15817890f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
