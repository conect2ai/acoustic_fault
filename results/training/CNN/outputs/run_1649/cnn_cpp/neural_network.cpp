#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.19603930f, 0.11404763f, 0.13755327f, -0.20878407f, -0.28887978f, -0.05950725f, 0.26905036f, 0.14527830f, 
    -0.08614738f, -0.13753057f, -0.33777222f, 0.49856225f, -0.30685365f, 0.02869781f, -0.29969820f, 0.07404877f, 
    0.16331199f, -0.15471032f, 0.17693990f, -0.05572144f, 0.24542803f, -0.00546626f, -0.39799190f, 0.13525511f, 
    0.46942642f, -0.42444167f, -0.66379875f, 0.12113411f, 0.69221550f, 0.05865630f, 0.54520482f, 0.86488205f, 
    -0.33324638f, -0.57649386f, 0.06580878f, 0.02124625f, -0.08549715f, -0.03846594f, -0.16498093f, -0.01185973f, 
    -0.31760564f, 0.31900764f, -0.03837097f, -0.06541662f, -0.04939945f, 0.32142982f, -0.19071075f, -0.09743255f, 
    0.23254147f, -0.05507169f, -0.00689611f, -0.57614952f, -0.90542156f, -0.46331033f, -0.35613984f, 0.08945528f, 
    0.38236719f, 0.42172736f, -0.23334429f, -0.38840523f, 0.18861708f, 0.04431063f, 0.27763700f, -0.19559665f, 
    -0.02547325f, -0.04748376f, 0.14858907f, -0.18334606f, -0.00715875f, 0.04698950f, -0.31865841f, -0.06402859f, 
    0.00107604f, -0.38992566f, -0.36640075f, 0.45066541f, 0.05967221f, 0.25924930f, 0.27059296f, 0.03869417f, 
    0.32861489f, 0.32222325f, 0.07089921f, 0.12198594f, -0.12718630f, -0.10913149f, -0.00686221f, 0.14923975f, 
    0.02471862f, 0.19096760f, 0.07981130f, -0.25479767f, -0.12030599f, 0.22421981f, 0.21250650f, 0.28207928f, 
    0.38133240f, 0.04490488f, -0.27834117f, 0.23238398f, 0.66451621f, 0.87079483f, 0.03375603f, -0.12978573f, 
    0.24686655f, -0.17815685f, -0.60887849f, -0.38609302f, 0.54614472f, -0.52984297f, -0.07451731f, 0.10220567f, 
    0.11992283f, -0.21240287f, -0.33430472f, -0.13379565f, 0.17727074f, -0.16323665f, 0.03709803f, 0.12136593f, 
    0.12282612f, 0.00857558f, -0.12751335f, -0.04133476f, 0.03709361f, -0.54567701f, -0.33509833f, -0.87679255f, 
    -0.74995244f, -0.02772322f, 0.11035064f, -0.15049532f, 0.06238297f, 0.18967330f, -0.15035124f, -0.40440273f, 
    -0.49847534f, -0.53746307f, -0.18843219f, -0.11356819f, -0.37690499f, -0.34590849f, 0.45493466f, -0.00609684f, 
    -0.53176475f, 0.01039825f, 0.19451213f, 0.15329622f, -0.25381961f, 0.06154049f, 0.92403865f, -0.72464067f, 
    -0.15218319f, -0.06987204f, 0.52273923f, 0.58626741f, -0.07058109f, -0.11918253f, -0.00841506f, 0.10977807f, 
    -0.14090993f, 0.22834539f, -0.08330398f, -0.42727041f, -0.09789228f, -0.06676947f, -0.12823179f, -0.00550207f, 
    0.04527915f, -0.14210401f, -0.15863526f, -0.02046749f, -0.14002739f, 0.01598177f, 0.16332711f, 0.16136375f, 
    0.25845042f, 0.26492968f, 0.38493410f, 0.08902758f, -0.26997930f, -0.03861007f, 0.14341788f, 0.32963157f, 
    -0.12305109f, -0.12299477f, -0.01441038f, -0.05000597f, 0.09565289f, -0.11727820f, -0.17275804f, -0.13273570f, 
    -0.08768526f, -0.01073990f, 0.13499774f, -0.40844035f, 0.06182234f, -0.16636151f, -0.30258295f, -0.59370351f, 
    -1.10416543f, -0.41275463f, -0.27566436f, 0.34939000f, 0.43794152f, 0.08467414f, -0.01267424f, 0.13788435f, 
    0.22515294f, 0.25967801f, -0.16566934f, 0.27645355f, -0.04291474f, 0.62832862f, -0.71471590f, 0.01323573f, 
    0.28769511f, -0.16188008f, 0.02352003f, 0.15877908f, -0.09401352f, 0.07388382f, 0.17426479f, 0.08096016f, 
    -0.30821320f, 0.21519099f, -0.28285959f, 0.02935602f, 0.34869570f, 0.24472810f, 0.05628427f, 0.28014684f, 
    -0.20068286f, 0.12532373f, 0.48293114f, 0.26181808f, -0.02316565f, 0.24257137f, 0.01044866f, -0.08179332f, 
    0.09773751f, -0.20458260f, 0.28849092f, 0.03466000f, 0.07955021f, -0.17104554f, -0.24426201f, -0.04781125f, 
    -0.10558861f, 0.49466529f, -0.54911119f, 0.07678284f, 0.55529183f, -0.05045787f, 0.21798584f, -0.18899870f, 
    -0.13995804f, -0.05795135f, 0.20633794f, -0.00000448f, 0.17052114f, -0.37924013f, -0.15587509f, 0.49884331f, 
    -0.12980627f, 0.04132045f, -0.31012359f, 0.22689863f, -0.09568711f, -0.15831038f, 0.00411347f, -0.05097462f, 
    -0.19553529f, 0.20648848f, 0.27593312f, -0.86278951f, 0.29114038f, 0.01567909f, 0.18266833f, 0.38276538f, 
    -0.63988453f, -0.05818057f, -0.36723953f, 0.45748273f, 0.60397667f, -0.05073622f, 0.19828677f, -0.08104346f, 
    -0.13794932f, 0.10457566f, -0.04841647f, -0.25143939f, 0.05514761f, -0.33917686f, -0.01436216f, 0.06068703f, 
    0.03921395f, 0.13554227f, 0.22707114f, 0.25429219f, 0.58264768f, -0.04792653f, -0.10869752f, -0.29160255f, 
    -0.06152013f, -0.55148691f, -0.56251383f, -0.50791663f, -0.75953889f, -0.89670110f, 0.04527920f, 0.34701031f, 
    0.25507781f, 0.07501948f, 0.39176083f, 0.03834759f, -0.17881168f, 0.04458669f, 0.02994065f, 0.17654572f, 
    -0.18953294f, -0.01791536f, 0.07915702f, 0.09310720f, 0.02506186f, 0.62212694f, 0.40310344f, -0.71740544f, 
    -0.44398007f, 0.07572129f, -0.48307866f, 0.03469945f, -0.12567545f, -0.02784847f, 0.11211415f, -0.10762469f, 
    0.37352872f, 0.33957353f, -0.57558703f, -0.08726865f, 0.02721128f, 0.20886047f, -0.44623384f, -0.30948991f, 
    -0.18050778f, -0.00750395f, -0.23265848f, -0.23020050f, -0.19347198f, -0.24167408f, -0.96258003f, -0.49800479f, 
    -0.51782417f, -0.09393302f, -0.42944622f, 0.81751478f, -0.20780656f, -0.01947643f, 0.58753639f, 0.91228235f, 
    0.17637835f, -0.03420715f, -0.11875530f, 0.10344051f, 0.03804733f, -0.10285735f, -0.11997715f, -0.17377129f, 
    0.15656903f, -0.15710884f, -0.01549452f, 0.04834578f, 0.22858694f, -0.06498918f, 0.21768674f, -0.43604761f, 
    -0.66747755f, -0.25518247f, 0.09502848f, 0.45396420f, -0.42514339f, -0.18953615f, -0.18256013f, -0.56321990f, 
    0.03039131f, 0.02545468f, -0.02052257f, 0.30709445f, -0.08522181f, -0.23620735f, 0.29848826f, -0.02991514f, 
    -0.14284170f, -0.18720101f, -0.13329546f, 0.19706066f, 0.16293831f, 0.25484765f, 0.18326582f, 0.43082088f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12370300f, 0.26406139f, 0.02362359f, -0.04817461f, 0.19710723f, -0.27934095f, 0.22000447f, 0.15428989f, 
    0.11825208f, -0.07666969f, 0.21725689f, 0.10909684f, -0.14054370f, 0.29590788f, 0.37424463f, 0.16254711f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00804853f, -0.06093468f, 0.00672630f, 0.09707515f, 0.17837226f, -0.01204602f, 0.09196045f, -0.26429665f, 
    -0.08764565f, -0.05541757f, -0.03570742f, -0.02210666f, 0.29312479f, 0.25856671f, 0.12053404f, -0.10049296f, 
    -0.10068635f, 0.19384708f, 0.18705465f, -0.04223143f, 0.09465077f, 0.14885029f, 0.18336977f, 0.17464547f, 
    -0.24280997f, -0.14925326f, -0.09287313f, -0.20781569f, -0.11700605f, -0.03001177f, 0.07210187f, 0.04466864f, 
    -0.03023739f, -0.00953803f, -0.06298874f, -0.00949199f, 0.16805613f, 0.22397447f, 0.07542515f, 0.07985320f, 
    0.01081268f, 0.05949022f, -0.01736478f, 0.01707027f, 0.12872680f, 0.06960759f, -0.02141134f, -0.00364204f, 
    0.38092142f, 0.46134785f, 0.08336116f, 0.06263888f, -0.12826571f, -0.12106346f, -0.00246343f, -0.06043173f, 
    -0.01656205f, 0.13785778f, 0.08546720f, -0.04999996f, 0.04888549f, -0.37640640f, -0.52164721f, -0.22234108f, 
    0.14899431f, -0.00932429f, -0.09910603f, 0.22140434f, -0.11829456f, 0.02220769f, -0.12358516f, 0.11042038f, 
    0.32223028f, 0.15439776f, 0.04865566f, 0.08845587f, -0.03374803f, 0.00158874f, 0.00304109f, -0.00547517f, 
    0.08234241f, 0.14550371f, 0.04152502f, 0.16598983f, 0.09399639f, 0.12973280f, 0.14041232f, -0.01441097f, 
    -0.03925162f, 0.02926202f, -0.09161225f, -0.03074224f, 0.24730650f, 0.09727621f, 0.20768744f, 0.12327266f, 
    0.26183367f, 0.04121962f, 0.11451136f, -0.39120406f, -0.11515608f, 0.11686254f, -0.05536129f, -0.04265204f, 
    -0.11692652f, -0.14707042f, -0.09443288f, 0.01829341f, 0.11734832f, 0.07159600f, -0.03355785f, 0.06069930f, 
    0.05487565f, -0.04064276f, 0.01863430f, -0.06237437f, 0.06924944f, -0.11872762f, 0.02811095f, 0.03234368f, 
    0.21320997f, 0.21101530f, 0.13452029f, 0.06307642f, -0.10621621f, 0.04029850f, 0.01066497f, -0.16212533f, 
    0.05510482f, 0.01869600f, -0.07966244f, 0.09563173f, 0.55438894f, -0.03271605f, -0.01488310f, 0.05014003f, 
    0.05047844f, -0.01346059f, -0.01850252f, 0.06342028f, 0.07618059f, -0.11117772f, -0.01810727f, 0.02116454f, 
    -0.05786718f, -0.17659767f, 0.04034955f, 0.12801267f, 0.01863258f, -0.04974943f, 0.10831916f, 0.19205573f, 
    -0.10312736f, -0.09559008f, -0.09248318f, -0.06901508f, 0.03193511f, -0.00493051f, -0.06766441f, -0.05628597f, 
    -0.02642838f, 0.07770272f, 0.01353166f, 0.03585199f, -0.06897219f, 0.10498878f, 0.09796306f, 0.07446608f, 
    0.00259402f, -0.21097820f, -0.55579394f, -0.43335947f, -0.05264290f, -0.04835839f, -0.01154696f, 0.21720770f, 
    0.07510728f, 0.10090541f, 0.09942115f, -0.04605554f, 0.12184763f, -0.27261257f, -0.23918745f, -0.10257288f, 
    0.09261335f, -0.01604625f, -0.09918161f, -0.00945739f, -0.13447626f, 0.02881027f, -0.01248146f, 0.02530203f, 
    -0.03506957f, -0.01827257f, -0.05119557f, 0.01261812f, -0.04703914f, -0.00972385f, 0.00273919f, 0.03905824f, 
    -0.00660587f, -0.06357563f, 0.02830281f, -0.00006176f, 0.02692812f, 0.03778536f, 0.06309339f, 0.00301621f, 
    -0.07678880f, 0.03342573f, 0.05840148f, -0.03538019f, 0.00189312f, -0.03625333f, -0.05147949f, 0.05915159f, 
    0.00363509f, -0.06855812f, -0.01627971f, -0.02597742f, -0.02425244f, 0.03678581f, -0.01425418f, 0.00364697f, 
    -0.03212589f, -0.00930602f, 0.02302752f, -0.04865633f, -0.04960519f, -0.01781769f, -0.00465031f, -0.01342150f, 
    0.04463871f, -0.04335472f, 0.06133055f, 0.01837283f, 0.05515473f, -0.06575189f, -0.01490672f, -0.00603061f, 
    -0.00866312f, -0.06027509f, 0.06282001f, 0.02567878f, -0.05797534f, -0.02630040f, -0.00085480f, -0.06575236f, 
    0.06513593f, 0.02842797f, -0.04360451f, 0.02865056f, -0.06665475f, 0.00231614f, -0.05994293f, -0.03213984f, 
    0.02480611f, 0.00109802f, 0.00987251f, -0.02683069f, 0.01080496f, -0.03283663f, 0.02275750f, -0.04359107f, 
    -0.02642556f, -0.06549493f, -0.06990238f, -0.04967504f, -0.07633659f, -0.05976189f, -0.03082453f, 0.00167601f, 
    0.05151968f, 0.01944092f, -0.03010431f, -0.06237578f, -0.02556492f, -0.05735474f, -0.05379206f, -0.04663891f, 
    0.04112512f, 0.01226358f, 0.00532689f, -0.06470090f, 0.04223814f, -0.00575449f, 0.05171091f, 0.01310724f, 
    -0.05019196f, -0.02025257f, -0.04344125f, -0.02802601f, -0.01610017f, -0.02091522f, 0.05227150f, -0.05520951f, 
    0.00200459f, 0.06621903f, 0.03915815f, -0.00110838f, 0.04055357f, 0.01687409f, -0.00291942f, -0.02954708f, 
    -0.03739879f, 0.03816903f, 0.03058283f, -0.01834145f, -0.05807093f, -0.00922129f, 0.03592249f, -0.01243445f, 
    0.02264841f, -0.04459281f, -0.04214292f, 0.00088842f, 0.06237708f, 0.02944120f, -0.00146161f, -0.01583068f, 
    0.05419439f, -0.00027746f, -0.05744884f, -0.07203488f, -0.07513510f, -0.06202765f, -0.02639116f, 0.03138851f, 
    -0.05583236f, -0.01626949f, 0.02678330f, -0.02313154f, -0.02381990f, 0.04484415f, -0.07382575f, -0.00996169f, 
    -0.06641505f, -0.01421774f, -0.06725137f, 0.04160276f, -0.04459901f, -0.06526142f, -0.03383021f, 0.01991474f, 
    0.06299894f, -0.05238033f, 0.01927580f, 0.02706949f, -0.04741731f, -0.06636181f, 0.05356619f, -0.01387370f, 
    0.05080310f, 0.02359823f, -0.07492922f, 0.02328940f, -0.01080811f, -0.02666288f, -0.05531738f, -0.01605432f, 
    -0.04416296f, 0.00326016f, -0.01072494f, -0.04485420f, -0.00903465f, -0.04886528f, 0.00692551f, -0.01667183f, 
    -0.02725530f, -0.01105985f, 0.03056986f, 0.04390338f, -0.02113438f, 0.00467116f, 0.03082627f, 0.00579374f, 
    0.04946663f, 0.03329600f, -0.03354428f, -0.06479561f, 0.01021186f, 0.01388873f, -0.00557204f, -0.05749908f, 
    0.12581064f, 0.05224789f, 0.04051178f, -0.13350412f, -0.07371442f, 0.01505666f, 0.16830629f, 0.05131011f, 
    -0.04132336f, 0.00229688f, 0.05136764f, 0.06823505f, -0.15592121f, 0.23453026f, 0.03379384f, 0.09767679f, 
    0.13575868f, 0.05115014f, -0.09603452f, 0.14891951f, -0.20908946f, -0.02864519f, 0.14721787f, 0.10482772f, 
    -0.03498936f, -0.24639572f, -0.10502014f, -0.01300951f, 0.06554922f, -0.05236601f, 0.02707685f, 0.14972037f, 
    -0.07663269f, 0.10846152f, 0.07552188f, -0.09751925f, 0.08004789f, 0.11775881f, 0.00930229f, -0.08215982f, 
    -0.05830773f, -0.03048032f, 0.04364189f, -0.03645376f, -0.04556916f, 0.02963731f, 0.03797650f, -0.04874896f, 
    0.13684450f, 0.02871460f, 0.10906678f, 0.18165798f, -0.08807626f, -0.23194121f, -0.12538503f, 0.04811909f, 
    -0.03230767f, 0.03520449f, -0.01212774f, -0.01822623f, 0.15157419f, -0.08380010f, -0.22573519f, -0.05739156f, 
    0.09796437f, 0.04587608f, 0.00532630f, 0.05520761f, 0.06462805f, 0.10772879f, -0.00516923f, 0.14726253f, 
    -0.02564282f, 0.26801258f, 0.04649983f, 0.22258046f, -0.04474015f, -0.04204088f, -0.00270792f, 0.05122231f, 
    -0.01937635f, 0.04094068f, 0.09252211f, 0.08276019f, 0.09018749f, 0.04162041f, 0.12989120f, -0.06021269f, 
    -0.09024329f, 0.07520618f, -0.00506709f, -0.01049654f, 0.05476342f, 0.08430763f, 0.07483281f, 0.13063435f, 
    0.15201122f, 0.31309643f, -0.37212810f, -0.22811420f, 0.01187224f, 0.07561585f, -0.18953532f, 0.05234495f, 
    -0.09431562f, -0.03484569f, 0.02569158f, 0.02735879f, -0.02765408f, 0.09627502f, 0.01176939f, -0.02382602f, 
    -0.02442406f, 0.01557896f, -0.06277320f, -0.06316305f, 0.11891650f, 0.08136573f, -0.00502716f, -0.04020573f, 
    0.18331957f, 0.17680135f, 0.02351761f, 0.07458007f, -0.02999189f, 0.06117767f, -0.00821229f, 0.04900298f, 
    0.02258801f, 0.13169329f, -0.06316083f, -0.01687390f, 0.34718102f, 0.05042813f, 0.10510519f, 0.01855940f, 
    0.09758029f, 0.15287742f, -0.08621557f, 0.01517146f, -0.00991974f, -0.11206965f, 0.01907708f, -0.08846330f, 
    0.03477942f, -0.06733628f, 0.03764217f, -0.03537516f, 0.02422267f, 0.06118181f, 0.10091545f, 0.27318457f, 
    -0.06741361f, 0.04490407f, 0.03840740f, -0.02008444f, -0.25657365f, -0.00777676f, 0.21376404f, 0.09373081f, 
    -0.09955745f, -0.11777296f, 0.05212793f, 0.08129591f, -0.13989617f, -0.03445606f, 0.02360673f, 0.06767190f, 
    0.37835512f, -0.00846165f, -0.05272354f, -0.21223094f, 0.02149991f, -0.14898847f, -0.03806566f, 0.00288198f, 
    -0.05002480f, -0.04083295f, 0.04902021f, -0.07230118f, -0.11981746f, 0.07409489f, -0.05754140f, -0.11383077f, 
    -0.01488185f, 0.04526947f, -0.05682913f, -0.08634578f, -0.11024611f, -0.07155772f, 0.13180266f, -0.04321867f, 
    0.12127318f, -0.10272024f, 0.07222189f, -0.08133679f, -0.02109968f, -0.06941230f, 0.09738272f, 0.01430643f, 
    -0.05269141f, -0.01238179f, -0.06082584f, -0.18856429f, -0.11494504f, -0.03621595f, 0.07510453f, 0.24205522f, 
    0.19962361f, -0.04289671f, 0.01146437f, -0.15179542f, -0.08916718f, -0.07632776f, 0.06074080f, 0.08143737f, 
    -0.02618878f, 0.00784897f, 0.24506702f, 0.30638039f, 0.06921778f, -0.07325749f, -0.00452779f, -0.03297951f, 
    0.07157239f, 0.10986266f, 0.12770680f, 0.03109107f, 0.06554101f, -0.06339929f, -0.03576470f, -0.14558823f, 
    0.08667006f, 0.04186237f, -0.00678163f, 0.09516971f, -0.03568330f, -0.05673897f, -0.06701195f, -0.07604813f, 
    0.18371034f, -0.15883663f, 0.05830652f, 0.14181532f, -0.11732219f, 0.03235298f, -0.00509337f, 0.09976492f, 
    0.03448215f, -0.01157857f, -0.12814398f, -0.03415275f, -0.06534244f, -0.00328210f, 0.13058020f, 0.15784088f, 
    0.08696599f, 0.22516975f, -0.06031854f, -0.04928959f, -0.03684883f, -0.00996448f, -0.06256799f, -0.07186177f, 
    -0.07035330f, 0.04593587f, -0.03139975f, 0.15982662f, -0.09809706f, -0.04025472f, -0.07592771f, -0.01199526f, 
    -0.10684327f, 0.10137744f, -0.00700496f, 0.01224005f, -0.06320399f, 0.06380913f, -0.04496706f, -0.10725014f, 
    0.00372585f, -0.02277103f, -0.01992135f, 0.04726471f, -0.01140557f, 0.08512962f, 0.12622464f, 0.29560652f, 
    -0.26993489f, -0.03611584f, 0.04800452f, 0.16734584f, -0.00110482f, 0.03782092f, 0.08740847f, -0.02596405f, 
    -0.00161607f, -0.04590166f, 0.04287029f, 0.06904928f, -0.14541033f, 0.04702856f, 0.03531954f, 0.10144313f, 
    0.02133558f, 0.05095707f, 0.03276825f, -0.06938876f, 0.05722918f, 0.04587936f, 0.08457375f, -0.02851449f, 
    -0.13459565f, -0.14349070f, -0.12121886f, 0.05241601f, 0.05680421f, 0.02333131f, -0.04986561f, -0.01845217f, 
    0.00424129f, 0.02147427f, 0.01500983f, -0.07628874f, -0.31142029f, 0.15474993f, -0.17998488f, -0.06773702f, 
    0.16023517f, 0.07460945f, -0.08878607f, -0.02036536f, -0.05305293f, 0.08170641f, -0.08132669f, 0.04870579f, 
    0.26157442f, -0.12717822f, 0.01735752f, 0.03841313f, -0.08936338f, 0.07382543f, 0.13958389f, -0.06354031f, 
    -0.04455610f, 0.11819712f, -0.02919100f, -0.04636866f, -0.05988736f, 0.03877400f, 0.09111815f, 0.00721417f, 
    -0.01332474f, 0.16362332f, -0.08605618f, 0.07096974f, 0.12754528f, 0.18286014f, 0.03926260f, 0.22463354f, 
    0.23245625f, 0.56679893f, 0.11224620f, 0.15436424f, -0.00308679f, -0.08046682f, 0.01720540f, -0.04297877f, 
    -0.06449700f, -0.04832500f, 0.02981556f, 0.01733097f, -0.09030481f, 0.13349429f, -0.06522904f, 0.07637838f, 
    -0.09226266f, 0.06850427f, 0.05829655f, -0.06019343f, -0.03835243f, -0.04221741f, 0.05000681f, -0.12185550f, 
    -0.01543680f, 0.01429570f, 0.01684588f, 0.02262396f, 0.06876104f, 0.09044778f, 0.17288314f, 0.27142346f, 
    0.05910853f, -0.02867769f, -0.13758592f, -0.06841057f, 0.05736890f, -0.53481644f, 0.15954962f, 0.23805229f, 
    0.02321410f, -0.06384527f, 0.04783929f, 0.00479552f, 0.26682097f, 0.10136566f, -0.01446712f, 0.07944503f, 
    0.01754642f, 0.14545080f, 0.19199090f, -0.06344330f, -0.12337197f, -0.04307934f, 0.04960908f, -0.01320044f, 
    0.19592996f, -0.03731211f, 0.17209387f, 0.00786148f, -0.05853213f, 0.06966367f, -0.10555536f, -0.08416515f, 
    -0.08140362f, 0.06674431f, -0.05622576f, 0.07201274f, -0.01579496f, 0.02888256f, -0.05219005f, -0.05755528f, 
    0.04051911f, -0.01167689f, -0.08221037f, -0.12170915f, -0.02296187f, 0.12739681f, 0.15322277f, 0.18798555f, 
    0.00862048f, 0.04034000f, 0.05190950f, 0.01088069f, -0.31662503f, 0.07094300f, 0.07126465f, -0.22151862f, 
    -0.13429797f, -0.00930346f, -0.11341770f, 0.07069928f, -0.07884681f, -0.00201385f, -0.07304303f, -0.09881060f, 
    0.48909664f, -0.41145429f, -0.00810349f, 0.07179417f, -0.03819561f, 0.07763813f, -0.04364367f, 0.02665586f, 
    -0.01423719f, 0.05989090f, -0.08261368f, -0.20320280f, 0.17426330f, 0.22737971f, -0.07470782f, 0.03962266f, 
    0.08656839f, 0.00507391f, 0.02687455f, -0.02478863f, 0.11279768f, -0.13566527f, 0.00031783f, 0.15974700f, 
    0.06848355f, -0.14421000f, 0.11581329f, 0.40178144f, 0.00854186f, -0.02498004f, 0.10705408f, -0.06720129f, 
    0.29987031f, -0.10968734f, 0.12008674f, -0.04413385f, -0.02543559f, 0.01073730f, 0.04839616f, 0.01413929f, 
    0.04578625f, 0.00631157f, -0.05127340f, -0.06167400f, -0.04308204f, 0.03828459f, 0.11791232f, -0.16498958f, 
    -0.03175459f, -0.06192857f, -0.18013749f, 0.16620310f, 0.15680633f, 0.11571765f, 0.04440643f, 0.12660016f, 
    -0.01762765f, 0.05365245f, -0.02887136f, 0.06435572f, -0.17270282f, -0.35049552f, -0.31229791f, 0.24798675f, 
    0.19289923f, 0.34325463f, 0.04240006f, 0.01227937f, -0.03107641f, -0.04751028f, 0.03861761f, -0.17386393f, 
    -0.01635938f, -0.02286194f, -0.21556287f, -0.19239816f, -0.13236915f, -0.08093158f, -0.07980558f, -0.20241538f, 
    0.05889049f, -0.04467908f, -0.06570832f, 0.03930388f, 0.10483211f, -0.17254657f, -0.02973552f, -0.14533226f, 
    0.08477385f, 0.14826110f, -0.00317556f, 0.22970691f, 0.18172294f, 0.10233638f, 0.06331009f, 0.11870218f, 
    0.03875600f, 0.38935053f, 0.10921703f, 0.31927487f, 0.00566019f, -0.03829952f, 0.03907793f, 0.11029585f, 
    -0.03047858f, 0.02337435f, 0.01804162f, 0.06933677f, 0.00208600f, -0.22716752f, 0.04164240f, -0.00129747f, 
    0.03514042f, -0.06434111f, -0.02853688f, 0.01545888f, -0.00036927f, -0.07582570f, 0.03887607f, -0.09071169f, 
    -0.04501199f, -0.07352454f, -0.15302570f, -0.09352510f, -0.01596237f, 0.13043216f, 0.03937735f, 0.02840352f, 
    -0.03648376f, 0.07568415f, 0.05821734f, 0.11055903f, 0.38973528f, -0.21570411f, 0.26933816f, -0.07655318f, 
    0.11080060f, 0.16009159f, -0.22324350f, 0.13200533f, 0.07768923f, 0.13414194f, -0.03669786f, -0.25519705f, 
    0.05253050f, 0.00505671f, 0.16854127f, -0.08089928f, 0.04640389f, -0.16786736f, -0.01700795f, 0.10174593f, 
    -0.03068360f, -0.10179707f, 0.09619532f, 0.09779827f, 0.14666373f, 0.01986728f, 0.00189147f, 0.06097686f, 
    0.08726929f, 0.00486540f, -0.04549629f, 0.07254376f, 0.14097476f, 0.06620173f, -0.02792366f, -0.07799347f, 
    -0.02711958f, 0.04228045f, -0.19962475f, 0.02411115f, 0.02247976f, 0.00120146f, -0.08499249f, -0.05500574f, 
    0.13113369f, 0.01274432f, -0.04223287f, 0.05558348f, -0.20298374f, 0.19873860f, 0.24915963f, 0.10018006f, 
    0.08538919f, -0.13132858f, 0.04943123f, 0.17206016f, -0.06495766f, -0.14035271f, -0.01132244f, -0.08862437f, 
    0.17187944f, -0.09846498f, 0.20930935f, -0.19212443f, 0.06542058f, 0.03917212f, 0.04351223f, -0.05417794f, 
    0.11631211f, 0.01976531f, -0.05463937f, -0.03321913f, 0.07419542f, -0.02627142f, -0.05995143f, 0.08064851f, 
    0.02065299f, 0.02143381f, -0.01583274f, -0.02018359f, 0.15498342f, 0.14113492f, 0.17500068f, 0.08980882f, 
    0.14708839f, -0.04760575f, -0.00698077f, 0.16690145f, -0.11331762f, -0.03850489f, -0.11043682f, -0.14048569f, 
    -0.06801765f, -0.03801883f, 0.08472537f, 0.09811649f, 0.12948476f, -0.05134064f, 0.11483285f, -0.00520225f, 
    -0.08196005f, -0.03317105f, -0.13760179f, -0.05567919f, 0.00696329f, -0.05471182f, 0.08145977f, 0.08875721f, 
    -0.02897797f, -0.00714554f, -0.00344459f, 0.19315183f, -0.00236172f, 0.03344672f, -0.00624630f, -0.06497014f, 
    -0.14243135f, -0.06249517f, 0.00585598f, -0.09021221f, -0.06171713f, -0.14099036f, 0.23375179f, 0.15819187f, 
    0.04255553f, 0.00770535f, 0.00165644f, -0.08277837f, -0.09004289f, -0.04487699f, -0.22820954f, 0.01199831f, 
    -0.17526600f, 0.15227453f, 0.05804866f, -0.05241695f, 0.08036654f, 0.10836610f, 0.14201643f, -0.03612809f, 
    -0.03467962f, -0.01573315f, 0.00790740f, -0.14685975f, 0.03825102f, 0.13002552f, 0.21123028f, 0.05094229f, 
    -0.01692994f, -0.13357913f, 0.08501997f, -0.19152986f, 0.08793245f, -0.06915693f, -0.06869407f, 0.05919121f, 
    0.55038625f, -0.14563753f, 0.22475809f, -0.22414330f, -0.20823225f, 0.01410934f, -0.21238266f, 0.03304042f, 
    -0.00628747f, -0.09042947f, 0.09936649f, 0.05534663f, 0.10912180f, 0.04292619f, 0.16882798f, 0.04090243f, 
    0.15849063f, 0.10836729f, 0.05356596f, 0.02346555f, 0.14118834f, -0.04661285f, 0.02460753f, 0.05174046f, 
    -0.00446832f, -0.03119763f, 0.01857761f, -0.02430538f, 0.04861845f, 0.04174464f, -0.02078894f, -0.08210687f, 
    0.00942902f, 0.03594742f, 0.01868893f, -0.05716683f, 0.04151830f, -0.04523821f, 0.05165767f, 0.00229635f, 
    0.00310926f, -0.02624448f, 0.02203019f, 0.04708837f, 0.03082392f, -0.05488148f, -0.02996861f, -0.06710299f, 
    -0.04713683f, -0.00797942f, 0.05470732f, -0.07586180f, -0.00545253f, -0.04707412f, -0.04409455f, -0.04795674f, 
    -0.06043937f, 0.00762473f, 0.00226846f, 0.02317357f, -0.03122245f, -0.01175032f, 0.02784106f, 0.00930616f, 
    0.00073307f, 0.00060045f, -0.00292459f, 0.00237792f, -0.02574644f, 0.00008582f, -0.04678979f, 0.04506938f, 
    -0.07326234f, -0.04250503f, -0.02166122f, 0.04959837f, 0.01226318f, 0.06105776f, 0.00750800f, -0.01063388f, 
    -0.03331561f, -0.02640925f, 0.05467936f, 0.04145597f, 0.06497092f, -0.05271280f, -0.05956331f, -0.06583127f, 
    0.00018265f, -0.04964635f, 0.04514891f, -0.02870874f, -0.04567251f, 0.04329897f, -0.05953467f, 0.00528789f, 
    -0.05422259f, 0.02620999f, -0.04452544f, 0.02575736f, 0.00334867f, 0.01816852f, -0.06030510f, 0.03563095f, 
    -0.00336163f, -0.07433947f, -0.07184133f, -0.02454560f, -0.04973904f, -0.01858566f, -0.05649546f, -0.04367669f, 
    0.01522621f, 0.00761321f, -0.04771385f, 0.00001870f, -0.01449292f, -0.06885446f, 0.06206590f, -0.04671798f, 
    -0.02216753f, 0.00499244f, 0.04393562f, -0.06595618f, 0.06018298f, -0.01611399f, 0.04570405f, 0.02288103f, 
    0.02210009f, 0.00617010f, -0.06817640f, -0.08136673f, 0.00148679f, 0.00670938f, -0.02866437f, -0.05859513f, 
    -0.01174810f, -0.06519298f, -0.00710918f, -0.04393880f, 0.01691299f, -0.00300870f, 0.02823142f, -0.02245725f, 
    0.02260507f, -0.02722788f, -0.04440098f, 0.00068241f, 0.05766649f, -0.02246432f, 0.03096935f, -0.04106181f, 
    -0.02938548f, 0.02570314f, -0.07333231f, -0.04346002f, 0.03817277f, -0.01713867f, 0.00906971f, 0.01654756f, 
    0.00251753f, 0.01510310f, 0.02400792f, -0.02908767f, -0.03842366f, 0.04803244f, 0.01927520f, 0.04445533f, 
    -0.02754824f, -0.01925748f, 0.00488905f, 0.00560022f, 0.05035086f, 0.05601766f, 0.02903166f, -0.01744635f, 
    -0.02605691f, -0.02952398f, -0.01475059f, 0.02204183f, 0.01494723f, -0.03749948f, -0.05185566f, -0.06590415f, 
    -0.00209657f, -0.00033071f, -0.05725450f, 0.01318425f, -0.04115460f, -0.00975758f, 0.02444180f, 0.01222415f, 
    -0.07508231f, 0.05623356f, 0.02006365f, -0.05233937f, -0.00408209f, 0.05476937f, 0.04230925f, -0.04269033f, 
    -0.06310941f, 0.02529294f, -0.06195571f, 0.04553973f, -0.06418318f, -0.08079641f, -0.02761310f, -0.07030064f, 
    -0.02374350f, -0.01251646f, -0.07711716f, 0.04836541f, 0.04574855f, 0.01900153f, 0.00861642f, 0.04901678f, 
    -0.00633601f, 0.10584222f, 0.13119544f, 0.10769909f, 0.06115469f, 0.02797180f, -0.01350994f, 0.05797699f, 
    -0.01020975f, -0.00113099f, 0.14060633f, -0.11330026f, 0.19280402f, -0.17336047f, 0.05739940f, -0.06389122f, 
    -0.16328059f, -0.14346823f, -0.02904123f, 0.04542563f, 0.11619576f, 0.21869281f, 0.03216152f, -0.04067669f, 
    0.32374355f, 0.01994579f, -0.03356003f, -0.09118466f, 0.11908629f, 0.05390896f, 0.06436019f, 0.11891707f, 
    -0.02843023f, -0.06023361f, -0.06017932f, -0.06974027f, -0.07840216f, 0.00725349f, 0.04605430f, -0.00227989f, 
    0.01512418f, -0.04988816f, 0.04703240f, -0.09568431f, 0.04893456f, 0.05211169f, -0.03919425f, 0.07473660f, 
    -0.02543720f, 0.34901190f, -0.32091686f, 0.04435771f, -0.10191414f, 0.06182209f, 0.03822192f, 0.06953096f, 
    -0.03673664f, -0.00726117f, 0.09425925f, -0.13626528f, -0.04047624f, 0.00566318f, -0.06996497f, -0.02020152f, 
    0.07539334f, 0.01470012f, 0.02048809f, 0.04679668f, -0.06574607f, 0.03073047f, -0.03235831f, -0.00623956f, 
    -0.20387763f, -0.05726177f, -0.04729234f, 0.16097477f, -0.09828250f, -0.00659621f, -0.00708529f, 0.10173137f, 
    0.06345820f, -0.12410475f, 0.08112608f, 0.06822965f, -0.20385297f, -0.18283696f, -0.03371416f, -0.00853947f, 
    -0.06825215f, 0.02272501f, -0.00291981f, -0.02552414f, -0.06176195f, 0.00008290f, -0.07025333f, -0.17042415f, 
    0.09929814f, 0.17874864f, 0.07834793f, -0.10904827f, 0.09165146f, -0.03572643f, -0.00028927f, -0.05019230f, 
    -0.01675794f, 0.12858318f, 0.08781704f, -0.09815313f, -0.06754267f, -0.05367855f, -0.06069517f, -0.01963744f, 
    -0.05749268f, -0.01074382f, 0.02489868f, 0.07005308f, 0.01419082f, -0.20175017f, -0.04183854f, 0.12821603f, 
    0.05091807f, 0.15526773f, 0.13074745f, -0.06969902f, 0.12820801f, 0.01502887f, 0.02244198f, -0.02471773f, 
    0.08638392f, 0.08250679f, -0.10322516f, 0.14103597f, -0.05203605f, 0.13899508f, 0.00457242f, 0.00449677f, 
    -0.11279599f, -0.11044176f, 0.06204716f, -0.05434715f, -0.06215585f, -0.06464736f, 0.14198335f, 0.05974030f, 
    -0.07241841f, 0.19330797f, 0.04880179f, -0.04489392f, 0.06496737f, -0.03131549f, -0.11527149f, 0.17396149f, 
    -0.05472134f, 0.03046807f, -0.02414859f, -0.13935505f, 0.09935306f, 0.13229983f, 0.08196951f, 0.00500358f, 
    -0.01725731f, -0.06808133f, -0.02645926f, 0.05367880f, -0.04130547f, -0.14667132f, -0.02723673f, -0.17803727f, 
    -0.11523456f, 0.08811691f, -0.02078629f, -0.02450457f, -0.01774492f, 0.05405083f, 0.14317104f, 0.11017178f, 
    0.16953909f, 0.15440425f, -0.07968549f, -0.02431246f, 0.17651665f, 0.06480511f, 0.05931614f, -0.05771619f, 
    0.12580432f, 0.08745239f, -0.03675032f, 0.12107580f, -0.00372488f, -0.11132897f, -0.06743166f, 0.13870618f, 
    -0.03960324f, -0.04442454f, -0.08079863f, -0.07450288f, 0.00110655f, 0.05703947f, -0.01490314f, 0.03169844f, 
    0.01318351f, 0.04937818f, -0.01632361f, 0.03797118f, -0.06217218f, -0.04296935f, -0.07551412f, -0.03003684f, 
    0.02907006f, -0.06583349f, 0.03520356f, 0.01701102f, -0.07244962f, -0.03365740f, 0.02700088f, -0.05986718f, 
    -0.07520494f, 0.02605318f, -0.04082924f, 0.02500868f, 0.06378458f, -0.01794823f, 0.05701737f, -0.05559982f, 
    0.03187563f, 0.02725827f, 0.04037388f, 0.03007699f, 0.01449407f, -0.01290107f, -0.03329036f, -0.04202645f, 
    0.01001326f, -0.03795410f, 0.06090693f, 0.01728440f, -0.06430232f, 0.06195356f, -0.04588023f, 0.05656136f, 
    0.03572449f, -0.04160105f, -0.04642637f, -0.03962126f, -0.04051372f, -0.00870980f, 0.03363421f, -0.01630853f, 
    -0.02083734f, -0.01840704f, 0.02873532f, -0.04454931f, -0.00148391f, 0.03595961f, -0.01680581f, 0.04346737f, 
    -0.02005001f, -0.06532606f, -0.04647214f, 0.00992010f, -0.05504693f, -0.01347106f, -0.06057899f, 0.01646606f, 
    -0.01951234f, 0.02168882f, -0.01245830f, -0.05433930f, -0.07098663f, 0.04629244f, 0.00902674f, -0.00422768f, 
    -0.04146963f, 0.05709960f, -0.00044156f, 0.04752379f, -0.04695307f, -0.04288202f, 0.03918473f, 0.00550484f, 
    -0.06836578f, 0.00401533f, 0.02960686f, -0.00296536f, -0.02352324f, 0.01879569f, -0.04968566f, -0.06434551f, 
    -0.05899447f, -0.00786690f, -0.02955493f, -0.01557619f, -0.04266036f, 0.04662487f, -0.00276400f, 0.01266525f, 
    -0.05076025f, 0.05306716f, 0.05030953f, -0.01753022f, -0.00779657f, 0.02653026f, -0.07931592f, 0.02137854f, 
    0.01750399f, -0.07120311f, -0.02611433f, -0.07794159f, 0.03592534f, 0.05159904f, 0.02555185f, 0.01108941f, 
    0.06161555f, -0.05020907f, 0.00794518f, -0.00947868f, -0.05218629f, 0.04692625f, 0.02963949f, 0.02125402f, 
    -0.01101170f, -0.05657370f, -0.04719994f, 0.05064351f, 0.04500345f, 0.04883678f, 0.00275126f, 0.04131833f, 
    -0.00852804f, 0.04125829f, -0.02668439f, -0.03079557f, -0.03071478f, 0.04559752f, 0.05135318f, 0.03095865f, 
    0.02411364f, -0.04165465f, 0.01742462f, 0.03161818f, 0.04812166f, -0.02443848f, -0.00348370f, -0.02447972f, 
    -0.02251910f, -0.01701139f, -0.07820083f, -0.00062846f, -0.07343102f, -0.01058774f, -0.02252007f, 0.06534908f, 
    -0.07748631f, -0.04022535f, -0.05763492f, -0.06718198f, -0.03107839f, -0.03737103f, 0.02104329f, 0.05581762f, 
    0.01470523f, 0.04741831f, -0.00510823f, -0.02087951f, 0.05433795f, 0.04897146f, -0.07090569f, 0.02607714f, 
    -0.05544990f, -0.07477909f, -0.00330393f, -0.04899399f, -0.03109635f, -0.07610549f, 0.00310139f, 0.02819654f, 
    0.00338243f, -0.04502427f, -0.04728939f, -0.04245200f, 0.04135610f, -0.02458211f, -0.05572751f, -0.04134791f, 
    0.01000267f, -0.06882038f, 0.06834444f, 0.16104814f, -0.02578632f, 0.09370918f, -0.06652122f, 0.14461473f, 
    -0.01267549f, 0.02712466f, 0.14290498f, 0.07101952f, 0.27707186f, 0.00854689f, 0.33654076f, -0.10633224f, 
    -0.09838878f, 0.07512964f, -0.04071335f, 0.14742604f, 0.10671999f, 0.07209828f, 0.33200341f, 0.09121349f, 
    0.03388057f, 0.00074184f, -0.08880998f, -0.03509510f, 0.04771322f, 0.13175680f, 0.05669710f, 0.10202202f, 
    0.09226191f, 0.10516977f, -0.18384840f, -0.17123988f, -0.11487382f, -0.01358084f, -0.05974039f, -0.00572771f, 
    -0.18545255f, -0.11360816f, -0.06065474f, -0.15577851f, -0.07115882f, 0.10045988f, 0.07510263f, 0.13558653f, 
    -0.21454801f, 0.18528599f, 0.03599914f, -0.07230622f, -0.15188931f, -0.19783077f, -0.09715606f, -0.18855426f, 
    -0.09490746f, 0.00965965f, 0.01747166f, 0.04102571f, -0.02307156f, 0.26007611f, -0.09770278f, -0.01028253f, 
    -0.02051415f, 0.02923224f, 0.17721917f, 0.06784658f, 0.03520919f, 0.07517967f, -0.15244548f, -0.11789689f, 
    0.30060816f, 0.41678512f, -0.08025300f, 0.24142145f, -0.01874634f, -0.14816174f, -0.07465751f, -0.09664979f, 
    0.23918286f, -0.06762806f, 0.12800035f, 0.14982717f, -0.10562254f, 0.16914405f, 0.07410492f, -0.11662927f, 
    -0.10451256f, -0.00389346f, -0.10937836f, -0.10583202f, -0.12960234f, -0.01047690f, -0.17380762f, -0.15250544f, 
    -0.13835147f, 0.21012349f, -0.02489571f, -0.06165571f, 0.01770155f, -0.01902424f, 0.10062736f, 0.07459530f, 
    -0.11297784f, 0.06306455f, -0.04756589f, -0.05115924f, -0.12801556f, 0.03783000f, 0.03557699f, -0.01622300f, 
    -0.05757377f, 0.03457174f, -0.06288049f, -0.11155936f, 0.06509590f, -0.16715463f, 0.27577937f, 0.08492707f, 
    0.01352793f, 0.05312383f, 0.02033125f, -0.13885634f, 0.03753372f, 0.08327939f, 0.01482456f, 0.07660682f, 
    0.05977804f, 0.02504196f, 0.10453518f, 0.26567176f, 0.09000863f, 0.03013015f, 0.22397919f, -0.09720214f, 
    -0.11451231f, 0.05967319f, -0.04377006f, 0.12335518f, 0.09001413f, 0.03027911f, 0.11783828f, 0.04004283f, 
    -0.26552731f, -0.21483628f, -0.17314510f, -0.05837217f, 0.11724904f, -0.04145040f, -0.19258016f, -0.02160697f, 
    -0.14975680f, -0.04973546f, -0.05230131f, 0.02644154f, 0.11340813f, -0.11313635f, -0.19187586f, 0.18028033f, 
    0.07899466f, 0.00982730f, 0.01352534f, 0.18133017f, -0.02492363f, -0.13850768f, -0.07147603f, 0.03311706f, 
    -0.13487811f, 0.04273179f, -0.06355678f, -0.08313679f, -0.05611100f, 0.07326665f, 0.08768729f, 0.09707808f, 
    -0.01333516f, 0.19108398f, 0.08785876f, -0.10240704f, -0.06401597f, -0.12930505f, -0.05859802f, 0.03441178f, 
    0.08213943f, 0.00400261f, 0.14372730f, 0.05832604f, 0.00606315f, 0.07412101f, 0.00003323f, 0.16305788f, 
    0.03231857f, -0.11946268f, 0.07936166f, 0.12227111f, 0.03033606f, 0.01216002f, 0.10129105f, -0.06119790f, 
    0.04898432f, -0.02989899f, -0.04397353f, -0.13003367f, -0.33225045f, 0.17619042f, -0.07935715f, 0.22336848f, 
    0.12115353f, 0.01384777f, 0.05452649f, -0.29495016f, 0.04046294f, -0.08889397f, 0.02113979f, 0.19909495f, 
    -0.31339538f, 0.01320799f, 0.03327835f, 0.18510097f, 0.00184125f, 0.08357327f, -0.10812362f, -0.07365187f, 
    0.08976267f, 0.02343653f, 0.11396116f, -0.04251908f, -0.11414171f, -0.01633267f, -0.01975647f, -0.00844827f, 
    0.07482333f, 0.13831550f, -0.06786699f, -0.09469336f, 0.03296543f, 0.01524313f, 0.13192065f, 0.05384712f, 
    0.19301540f, -0.17571145f, 0.24447031f, 0.04883352f, 0.04425791f, -0.01023444f, 0.09094006f, -0.15636788f, 
    -0.04587936f, 0.01658065f, -0.09264171f, -0.13263032f, -0.11959998f, -0.24077879f, -0.12210987f, 0.14143085f, 
    0.02953772f, 0.04829017f, -0.10094208f, -0.03923259f, -0.06615310f, 0.09788541f, 0.02487544f, 0.14361118f, 
    0.13223119f, 0.13917096f, -0.04745565f, -0.12539276f, -0.10608774f, -0.03056713f, -0.09714554f, -0.03390163f, 
    -0.10876665f, 0.09922323f, -0.01565564f, 0.18359788f, -0.05138921f, 0.04565465f, 0.02869730f, -0.15855663f, 
    -0.19596885f, -0.08925905f, -0.06799223f, -0.07132068f, 0.10276235f, 0.06408941f, 0.05631482f, 0.20440969f, 
    -0.07253867f, -0.10594385f, 0.18722817f, -0.07756513f, -0.09394793f, 0.08666839f, 0.00192691f, 0.02255614f, 
    0.06529061f, 0.03748617f, -0.05758363f, 0.17270321f, -0.00779722f, -0.06875958f, -0.04150145f, 0.02590993f, 
    0.15023658f, 0.05126777f, 0.13651024f, 0.11392144f, 0.17232932f, 0.23448561f, 0.06507608f, -0.07926802f, 
    0.03961339f, -0.08959464f, -0.23515722f, 0.11593948f, 0.00396663f, -0.18577668f, -0.04412694f, -0.16232882f, 
    0.19668441f, 0.02808957f, 0.16134417f, 0.17250948f, 0.17005748f, 0.01328855f, -0.39079210f, 0.06808062f, 
    0.07393700f, -0.14702888f, -0.03248118f, -0.07378858f, 0.02590981f, 0.03947961f, 0.07013009f, 0.26599640f, 
    0.06657332f, -0.09731445f, 0.12396187f, 0.28251809f, 0.04410160f, 0.09599617f, 0.18780711f, 0.09419763f, 
    0.03355242f, -0.14779684f, -0.02442413f, 0.01490804f, 0.03436129f, -0.01776992f, -0.16637798f, -0.14820965f, 
    -0.05976314f, 0.19640367f, 0.06533397f, 0.08718385f, 0.04410071f, 0.14879684f, 0.07355053f, 0.10192934f, 
    -0.08903287f, 0.08280803f, -0.09807294f, 0.26903546f, 0.00773592f, -0.09475190f, 0.18766041f, 0.15869714f, 
    -0.06174757f, 0.12612680f, 0.04499437f, 0.09675442f, -0.03595442f, -0.08384545f, -0.13509680f, 0.22361359f, 
    -0.11710934f, -0.07331838f, -0.16280086f, 0.00005294f, -0.16754422f, -0.02259723f, 0.00126484f, -0.03437201f, 
    0.00190800f, 0.01172168f, -0.07328393f, -0.03421848f, -0.00024212f, 0.04488881f, 0.04489502f, -0.01635945f, 
    0.02960242f, -0.04247057f, -0.02954150f, -0.00412837f, -0.01832397f, -0.04780980f, 0.00480261f, -0.01961534f, 
    0.03127680f, 0.03415802f, -0.06912564f, -0.00626829f, 0.02753245f, 0.00772198f, 0.05522176f, -0.03293049f, 
    0.00493550f, 0.05380601f, 0.04546226f, -0.02481170f, -0.06393393f, 0.02270114f, 0.03783377f, 0.02364553f, 
    -0.01360221f, 0.01112214f, -0.02023854f, 0.03375167f, -0.00776112f, 0.00267883f, 0.06135326f, 0.02574696f, 
    0.02219920f, -0.01474987f, -0.08077614f, 0.00773173f, -0.02508967f, -0.02222475f, 0.04129667f, -0.01616029f, 
    -0.00588437f, -0.03143070f, -0.01297255f, 0.06011131f, -0.03998490f, -0.03034659f, 0.06231919f, -0.01956249f, 
    0.00228302f, -0.00413699f, -0.01023199f, 0.02381076f, 0.03541489f, -0.08064231f, 0.00810987f, 0.02633069f, 
    -0.06918439f, 0.04240080f, -0.01740656f, -0.04884972f, -0.02818864f, -0.06568486f, -0.07309468f, -0.04230332f, 
    0.05763226f, -0.05798399f, 0.03388984f, 0.03945865f, 0.00379586f, -0.00869260f, -0.01958290f, -0.03864872f, 
    -0.07152296f, -0.05788720f, -0.00162785f, -0.01174109f, 0.06511767f, -0.05137547f, -0.07101747f, -0.06484740f, 
    0.01421831f, 0.06018050f, 0.05345122f, -0.07365150f, -0.02611323f, -0.03638767f, 0.03834095f, 0.00432330f, 
    -0.00754964f, 0.02620818f, -0.05468714f, -0.05464930f, 0.00264278f, -0.01241521f, -0.00494902f, -0.00260124f, 
    0.02610998f, -0.00890732f, -0.05201546f, 0.01686491f, -0.00465521f, 0.00131210f, -0.01021556f, -0.05080462f, 
    0.02645834f, 0.03280967f, -0.03421449f, -0.00671002f, -0.07400838f, 0.04918811f, 0.00093960f, 0.05095857f, 
    -0.06834469f, 0.03829851f, -0.02850726f, -0.06182660f, -0.08188526f, 0.01396011f, -0.00477412f, -0.06649145f, 
    0.02703539f, -0.05940918f, 0.02734085f, 0.01557044f, 0.00832372f, -0.00367884f, 0.06073730f, -0.02613196f, 
    -0.01684601f, -0.08163513f, -0.04795656f, 0.05767706f, -0.01769567f, 0.02096119f, -0.00630561f, 0.03938458f, 
    -0.00686714f, 0.01351627f, -0.07181656f, -0.02438797f, 0.02958697f, 0.03314999f, 0.04564568f, -0.03152560f, 
    0.03789306f, 0.01028599f, -0.06009822f, -0.04571211f, 0.04345473f, 0.05545009f, -0.06088719f, 0.05535261f, 
    -0.03154245f, -0.01253100f, -0.04345632f, -0.04459079f, -0.05145190f, -0.01185751f, -0.06318409f, -0.03366373f, 
    0.02999974f, 0.00965042f, -0.06037229f, 0.05595662f, -0.03416284f, -0.01600835f, 0.02042583f, -0.05628102f, 
    -0.06979141f, -0.06361465f, 0.01293508f, -0.03043230f, 0.05109081f, -0.05227350f, -0.05259761f, -0.07546514f, 
    0.00467735f, 0.05514530f, -0.02702097f, -0.02541229f, -0.03621035f, -0.04017375f, -0.02450650f, -0.04785751f, 
    0.01890665f, -0.00998821f, 0.05886636f, 0.09636461f, -0.03844042f, -0.15104395f, -0.01810252f, 0.09032216f, 
    -0.17574340f, 0.03582635f, 0.10278381f, 0.11704013f, 0.10304423f, 0.39667049f, 0.28436372f, -0.26279774f, 
    -0.03885928f, -0.04641679f, -0.25502411f, 0.08546301f, -0.15602577f, 0.15360390f, 0.06147422f, -0.06934362f, 
    -0.07070562f, 0.14631255f, 0.11326413f, 0.15836209f, 0.16779725f, -0.09421486f, -0.02444578f, 0.09826543f, 
    -0.02592718f, 0.04147057f, 0.04183184f, 0.06576084f, -0.14035654f, -0.01484751f, 0.00726288f, 0.00048288f, 
    0.17800681f, -0.23648180f, 0.13470562f, -0.01849910f, -0.05268187f, -0.07598265f, -0.09797826f, -0.19417179f, 
    -0.26413053f, 0.16059463f, 0.02747711f, -0.08892622f, 0.12502541f, -0.11617894f, 0.09583532f, -0.01042315f, 
    0.10312455f, -0.03122183f, 0.05846387f, -0.17275812f, 0.10034361f, -0.17046542f, -0.14928602f, 0.17223963f, 
    -0.00757154f, 0.01693697f, -0.08007766f, 0.00579704f, 0.03738378f, -0.05624050f, 0.12454419f, 0.12138122f, 
    -0.18002589f, 0.26151359f, 0.14584902f, -0.11307281f, 0.08965892f, -0.10518846f, -0.07905831f, -0.10191824f, 
    0.12536383f, 0.09917734f, 0.08174478f, 0.02529070f, -0.07773393f, -0.17737359f, -0.13142599f, 0.09560058f, 
    -0.05157880f, -0.02357593f, 0.11974712f, 0.00498545f, 0.21824776f, 0.04690043f, -0.06339442f, 0.15007009f, 
    0.05371870f, 0.39982265f, 0.23838690f, 0.00060518f, 0.03024433f, 0.20547365f, -0.02220566f, 0.13675542f, 
    -0.01821595f, 0.00300977f, -0.06811214f, -0.10543092f, -0.06794064f, -0.12426501f, 0.06158016f, -0.13311395f, 
    -0.15587035f, -0.12250445f, 0.14910135f, 0.01525895f, -0.01454781f, -0.02216456f, -0.10684987f, -0.06438687f, 
    -0.01199775f, 0.18588495f, 0.04561027f, -0.16264525f, -0.26803553f, 0.28954044f, -0.07076487f, -0.04645864f, 
    -0.12817636f, -0.09844086f, -0.06898402f, -0.00142756f, 0.07067625f, 0.07583614f, -0.01812598f, -0.12108048f, 
    0.01783629f, 0.02463048f, 0.10110233f, -0.05116335f, -0.06543317f, -0.14997108f, -0.06088584f, -0.18978477f, 
    -0.51315188f, -0.16148907f, 0.04314540f, 0.23841763f, 0.22382468f, 0.06769454f, -0.10095878f, -0.19583412f, 
    0.16869590f, 0.00618322f, -0.02019370f, -0.12108797f, -0.00589611f, 0.28223884f, -0.02134732f, 0.12783691f, 
    0.06743591f, -0.11479171f, 0.25739571f, -0.08877181f, 0.10059804f, 0.05904724f, -0.07785115f, 0.07304076f, 
    0.22086784f, 0.02492919f, 0.22366880f, 0.13503742f, -0.09991109f, 0.05870136f, -0.00511706f, 0.14950241f, 
    0.02602512f, -0.04055623f, -0.04583300f, 0.12844063f, -0.04531999f, -0.04364775f, -0.09671476f, 0.05303174f, 
    0.13251393f, 0.05143404f, -0.11698212f, 0.05772394f, 0.14094761f, -0.10515819f, -0.13428675f, 0.05631787f, 
    -0.01289073f, 0.00358116f, 0.11457120f, 0.18385106f, 0.15912455f, 0.06929003f, 0.04557277f, 0.01456294f, 
    0.04280583f, -0.07268341f, 0.23314381f, 0.22005491f, -0.01290629f, 0.02942632f, -0.19869091f, 0.16977647f, 
    -0.16159925f, -0.00781378f, 0.06065626f, 0.08156797f, 0.17833920f, 0.19060293f, 0.10659098f, 0.06845879f, 
    0.12307706f, -0.10016625f, -0.09089921f, 0.04812348f, -0.07275006f, 0.17447488f, -0.16883288f, 0.19967777f, 
    -0.12777446f, -0.13484985f, -0.14199565f, -0.11860634f, -0.22923097f, -0.18295291f, -0.10715765f, -0.05077085f, 
    -0.12469223f, -0.09564945f, -0.06784150f, -0.21257378f, 0.13713604f, 0.06807384f, 0.02701456f, -0.01547296f, 
    0.34522748f, 0.35060504f, 0.14742765f, -0.18886615f, -0.25273505f, -0.09415547f, -0.15590663f, -0.02832320f, 
    -0.06958481f, -0.18103673f, 0.00351486f, -0.00738822f, -0.01138983f, 0.12053687f, 0.00325849f, 0.03861541f, 
    -0.06132555f, -0.10756322f, 0.03623660f, 0.14713736f, 0.00903920f, 0.01950950f, -0.01391051f, 0.03137833f, 
    -0.05974823f, -0.09319694f, 0.09705792f, 0.03979839f, -0.17561281f, -0.03486372f, 0.03016513f, -0.04644775f, 
    0.11680603f, -0.14356954f, 0.09379089f, 0.01219534f, -0.16368064f, -0.10285549f, -0.08602951f, 0.06283206f, 
    -0.00111053f, -0.07983934f, 0.02889564f, 0.01133044f, 0.02752433f, 0.01957346f, -0.11046864f, -0.11605764f, 
    -0.07447471f, -0.00783248f, -0.10512356f, -0.16630480f, 0.03014830f, 0.01192378f, -0.06429214f, -0.10215355f, 
    -0.00975343f, 0.13540246f, 0.09478381f, 0.05863164f, -0.09284447f, -0.05443939f, -0.15176189f, -0.12103958f, 
    -0.04043058f, -0.09922784f, -0.15028994f, -0.11564741f, 0.10219987f, -0.03197711f, 0.04877047f, 0.05547376f, 
    0.25866848f, 0.05594026f, 0.01960518f, -0.01962135f, 0.06474363f, -0.01831661f, 0.03242110f, -0.12083549f, 
    0.09972114f, 0.00072247f, 0.07588588f, 0.24507667f, 0.11033155f, 0.08934610f, 0.01950471f, -0.02323953f, 
    -0.05749359f, -0.16665384f, 0.13561155f, -0.04558447f, 0.09949869f, 0.05301299f, 0.01504064f, 0.12530950f, 
    -0.31391448f, -0.00446205f, 0.25028327f, 0.00139249f, 0.04682926f, 0.01958648f, -0.00328406f, 0.04886536f, 
    -0.05461585f, -0.06025570f, 0.07731886f, 0.05607480f, 0.21270423f, 0.01850649f, 0.21306726f, 0.07103902f, 
    0.03071649f, -0.06322844f, 0.08231019f, 0.06782206f, -0.07495053f, -0.06136303f, -0.03861630f, -0.07116020f, 
    -0.30912012f, -0.19430521f, -0.24907136f, -0.04409987f, -0.03291878f, 0.11797757f, 0.11422339f, 0.06185246f, 
    0.11465679f, -0.01692892f, 0.05624897f, 0.00743448f, 0.09194031f, -0.04926756f, 0.13594081f, 0.16358328f, 
    0.06454717f, 0.17451188f, 0.01375815f, 0.19667530f, 0.15198688f, 0.03873153f, 0.09111261f, 0.17393413f, 
    -0.11999865f, -0.16483733f, -0.11142042f, 0.00859984f, 0.13220279f, -0.05885916f, 0.20617999f, -0.10895159f, 
    -0.00667775f, -0.13583243f, -0.00878571f, -0.03898050f, 0.21852164f, -0.03595033f, 0.19447561f, 0.22912467f, 
    0.01518788f, 0.13191736f, 0.01319774f, -0.11457007f, 0.09856990f, 0.12354507f, 0.17129040f, 0.00238768f, 
    -0.02499831f, -0.24920602f, 0.03098650f, -0.10253441f, 0.12771867f, 0.13406274f, 0.07293689f, 0.11658340f, 
    0.17212848f, 0.17675155f, -0.10914148f, 0.06553034f, 0.15436700f, 0.08368085f, 0.07729954f, 0.09871890f, 
    0.07452046f, 0.02448298f, -0.08755437f, -0.03948691f, -0.04542712f, 0.00652335f, 0.01035103f, -0.00060054f, 
    0.50404644f, 0.31479457f, 0.06273601f, 0.01197702f, -0.03289386f, 0.01258442f, -0.03696309f, -0.16639726f, 
    -0.10469504f, 0.03583845f, -0.03752343f, 0.01507788f, -0.29516038f, -1.17922318f, -0.76994902f, -0.46477848f, 
    0.10628153f, -0.18899120f, 0.01318286f, 0.34075925f, -0.06456766f, 0.10561660f, 0.10252847f, 0.16348471f, 
    0.50169653f, 0.31798699f, 0.01999000f, 0.21263003f, -0.01701727f, -0.09049384f, -0.02922674f, -0.02395705f, 
    0.13123329f, 0.12460435f, -0.03677010f, 0.29705936f, -0.00809403f, 0.08086589f, 0.07741851f, 0.09050608f, 
    0.03857023f, -0.00207856f, 0.00040794f, -0.02817053f, 0.07491560f, 0.03060957f, 0.28800339f, 0.28189260f, 
    -0.12996079f, 0.02652609f, 0.11253182f, -0.16751343f, -0.14632490f, 0.14463207f, 0.02693120f, -0.16618720f, 
    -0.07430109f, -0.01511160f, -0.07921267f, -0.04789133f, -0.02089893f, 0.08537109f, 0.08958124f, 0.02968725f, 
    -0.05032426f, -0.06852119f, 0.01828039f, -0.08065160f, 0.15083084f, 0.10749133f, 0.07461988f, -0.00697824f, 
    0.03551632f, 0.09625425f, 0.09353656f, -0.00976657f, -0.02602169f, -0.07496867f, 0.05955455f, -0.14869449f, 
    -0.04685429f, 0.05563499f, 0.07897414f, -0.09873631f, -0.22258301f, 0.20680773f, 0.20309769f, -0.00668231f, 
    -0.16366486f, 0.00754740f, 0.04510680f, -0.13752906f, -0.07742586f, -0.06678588f, -0.15824021f, 0.02592713f, 
    0.19304505f, -0.25782955f, -0.32886779f, 0.13780238f, 0.09301002f, 0.00996097f, 0.29112655f, 0.19025627f, 
    -0.11424073f, -0.03030052f, -0.00505753f, -0.07382938f, 0.20870182f, -0.06515536f, 0.07999018f, 0.01471408f, 
    0.05444412f, 0.22789365f, 0.16810191f, 0.07189862f, 0.22952516f, -0.03913171f, -0.03249447f, 0.09008104f, 
    -0.45711711f, 0.12003782f, -0.24244393f, -0.27531689f, -0.13121702f, -0.11670224f, -0.09384094f, -0.01643519f, 
    -0.07822230f, 0.06831388f, 0.24759102f, -0.01127846f, -0.20469050f, -0.34473935f, -0.38688150f, -0.26297933f, 
    0.14364824f, 0.09612650f, -0.08291600f, -0.17034882f, -0.12744905f, 0.04694897f, -0.07193656f, -0.00755923f, 
    -0.04205670f, -0.04902580f, 0.05171284f, -0.07078277f, 0.02200545f, -0.02529840f, -0.02726339f, -0.04205769f, 
    -0.07348878f, 0.02571561f, -0.00512658f, -0.02068700f, 0.00249263f, 0.00300127f, 0.03002429f, -0.04374778f, 
    0.00418636f, 0.00104278f, -0.06226015f, 0.03314928f, -0.01332301f, 0.05945708f, 0.01937493f, 0.04620724f, 
    -0.03192701f, -0.03279642f, 0.06147804f, -0.07429885f, 0.03289499f, -0.05049165f, 0.01724668f, 0.04081374f, 
    -0.06894857f, 0.05702379f, -0.01719673f, 0.00115300f, -0.02366443f, 0.01497137f, -0.01963631f, 0.03871220f, 
    -0.06805174f, -0.00301395f, 0.00692295f, 0.00907904f, 0.06425525f, -0.04847075f, -0.06862332f, -0.06986626f, 
    -0.06052151f, 0.04227326f, 0.01775316f, 0.01152116f, 0.02713567f, 0.02527812f, 0.01990876f, 0.03374038f, 
    0.00226217f, 0.02946841f, -0.03893895f, 0.03225344f, -0.05784833f, -0.04358775f, -0.03027314f, -0.01590703f, 
    0.03622345f, -0.06232876f, 0.02183475f, 0.01831521f, -0.05525536f, -0.05147563f, -0.05795586f, -0.02231322f, 
    -0.05832896f, 0.02409067f, 0.00602895f, -0.04603900f, -0.00990022f, 0.02789500f, 0.04338650f, -0.00710850f, 
    -0.02355430f, 0.05870076f, -0.00257580f, -0.02689102f, -0.00994139f, -0.05084562f, -0.05799557f, -0.07414804f, 
    -0.03016794f, 0.03005480f, 0.05794206f, 0.00709518f, 0.03820660f, 0.00313807f, 0.02899344f, 0.00550092f, 
    0.06496561f, 0.04918345f, -0.07383973f, -0.04858098f, 0.04969731f, -0.02684499f, -0.04969946f, 0.00201660f, 
    -0.05404400f, -0.00880805f, 0.02302802f, -0.01262341f, -0.04941238f, 0.01577387f, -0.05573360f, -0.07586130f, 
    -0.06740482f, -0.04058959f, 0.01371863f, -0.04314325f, -0.01175676f, -0.05942314f, 0.00384802f, -0.06638542f, 
    0.01500815f, 0.00889873f, -0.03688508f, -0.03885680f, -0.04818382f, -0.05551389f, 0.01056589f, 0.06455279f, 
    -0.06781434f, 0.00247332f, 0.01957947f, -0.02419541f, -0.07017447f, 0.03613315f, 0.06588893f, -0.03455782f, 
    -0.03685391f, -0.02359543f, 0.03878141f, -0.05950719f, 0.03420684f, -0.05168796f, 0.03110124f, -0.05048553f, 
    -0.00339735f, 0.02818071f, 0.06079296f, -0.06668061f, 0.03883773f, 0.04346834f, -0.03200526f, 0.02021907f, 
    0.02537767f, 0.02391223f, -0.06948416f, 0.04397252f, -0.05200960f, -0.05461400f, -0.06377568f, 0.01178186f, 
    0.02301334f, -0.04542064f, -0.05527535f, -0.04148963f, 0.00203856f, 0.03684138f, -0.06868707f, 0.04092545f, 
    -0.05115499f, 0.05510496f, 0.00164936f, -0.04218328f, -0.04354297f, 0.01402797f, -0.07654679f, -0.02761738f, 
    0.02389005f, 0.03405412f, -0.02421085f, 0.01649993f, -0.06159320f, -0.03077071f, -0.05385830f, -0.04690624f, 
    0.02736374f, 0.00002185f, -0.04077066f, -0.03729633f, -0.01122488f, 0.02825229f, -0.02634135f, 0.03777051f, 
    0.06761377f, 0.16004927f, 0.02223580f, 0.10318350f, 0.01403008f, 0.04837331f, -0.11186276f, -0.10856052f, 
    -0.02869302f, -0.00618651f, 0.06889773f, 0.08555298f, -0.31463501f, 0.48918799f, -0.28456822f, -0.04035446f, 
    0.05502562f, -0.06198978f, 0.07164681f, 0.03117218f, -0.09244546f, 0.16388306f, 0.13562505f, 0.18468602f, 
    0.13077033f, -0.14181562f, -0.33474609f, 0.01986455f, 0.09872697f, 0.14861092f, 0.01912535f, -0.00298708f, 
    -0.14030105f, 0.06257297f, -0.15713364f, -0.10058886f, -0.02764446f, 0.05676876f, 0.02836374f, -0.03526636f, 
    -0.06786678f, -0.03228373f, 0.07639862f, -0.03885394f, -0.10208491f, -0.02732791f, -0.05701840f, -0.02582683f, 
    0.08065323f, 0.08848388f, 0.36614221f, 0.17297854f, -0.05253065f, 0.01025030f, -0.24042827f, 0.02880182f, 
    -0.05667231f, 0.04547570f, -0.00156751f, 0.01462759f, 0.33004251f, 0.10283574f, -0.20082645f, -0.14492229f, 
    0.03648539f, 0.09547012f, 0.10493328f, -0.00057043f, 0.09478451f, 0.07720496f, 0.05978182f, 0.17377056f, 
    -0.33213836f, 0.32506165f, -0.16215433f, 0.40863207f, -0.12253115f, 0.04973181f, -0.07119481f, 0.09338733f, 
    0.04444606f, -0.13902332f, 0.02720474f, 0.19215025f, -0.11995101f, -0.05686930f, 0.04868512f, -0.05715456f, 
    -0.00218551f, -0.01177378f, 0.00085820f, -0.00207068f, -0.00451820f, 0.19301969f, -0.11774512f, -0.14811288f, 
    -0.06956843f, 0.12269989f, -0.12331451f, -0.21841685f, 0.24224411f, 0.05880518f, 0.18248056f, 0.19127569f, 
    -0.16162533f, 0.26037797f, -0.03614809f, -0.04593467f, 0.06070420f, 0.04528167f, -0.06126250f, -0.05874958f, 
    0.03010211f, -0.00899870f, 0.05190196f, -0.01473396f, 0.12530977f, -0.04257202f, -0.05876663f, 0.19325891f, 
    0.05399557f, 0.12262744f, 0.19817385f, -0.04298254f, 0.14220574f, -0.10514455f, 0.02439549f, 0.05975970f, 
    0.08492835f, 0.13819119f, 0.06660880f, 0.10376954f, -0.02079050f, 0.48812750f, 0.39100024f, -0.11837358f, 
    -0.20575151f, -0.01779601f, 0.05468232f, -0.00299164f, 0.11778624f, -0.01020064f, 0.21485308f, 0.01144701f, 
    0.12791976f, 0.05459707f, 0.08607779f, 0.12856202f, 0.06016149f, -0.02018976f, -0.19859061f, 0.11696167f, 
    0.02267024f, 0.05027846f, 0.02099256f, -0.08384185f, 0.00191012f, -0.00156909f, 0.04559200f, 0.17302598f, 
    -0.09616342f, -0.05661255f, -0.05354505f, 0.06107885f, -0.11980713f, -0.11398914f, -0.03074873f, -0.08830377f, 
    -0.29184702f, -0.07940089f, -0.08374154f, -0.23766179f, 0.12428341f, 0.12762651f, 0.08625561f, 0.07980905f, 
    0.01658832f, 0.05431300f, -0.00485389f, -0.13704355f, 0.10525031f, 0.31100762f, -0.04135492f, -0.10536414f, 
    0.06263015f, 0.10391951f, -0.01767367f, -0.07483220f, 0.05043996f, 0.00802840f, -0.01588602f, 0.07214634f, 
    -0.11577656f, -0.02878154f, 0.00201785f, 0.10790826f, 0.07607020f, -0.09281337f, -0.00955342f, -0.01812894f, 
    -0.08833277f, -0.09322080f, -0.18071254f, 0.07432816f, -0.08734953f, 0.23583978f, -0.15620415f, 0.09430374f, 
    0.16157559f, -0.01216799f, 0.09912480f, -0.09166317f, 0.09574781f, 0.10072632f, 0.06951717f, -0.03758504f, 
    -0.08470508f, 0.30143657f, 0.11639080f, 0.06028168f, -0.12798046f, 0.03012171f, 0.04361504f, -0.07481591f, 
    0.01745125f, 0.06372266f, -0.02776074f, -0.04457320f, -0.06416468f, 0.06076846f, -0.09479727f, 0.09904661f, 
    -0.02088525f, 0.03562029f, 0.05943452f, 0.00273853f, -0.18625133f, -0.07423732f, -0.05255207f, 0.00569040f, 
    0.11208641f, -0.07767363f, 0.45206529f, -0.00687390f, 0.01188324f, 0.02935870f, -0.11390303f, -0.04337981f, 
    -0.03210459f, -0.00695403f, -0.03760071f, 0.08351982f, -0.02923649f, 0.11755661f, 0.20465682f, -0.11210275f, 
    -0.12189017f, -0.00066916f, -0.12356061f, -0.01982218f, -0.07401041f, 0.00034565f, -0.04618346f, 0.05242752f, 
    0.10277321f, 0.10042761f, -0.13472977f, 0.11225933f, -0.14887041f, -0.04814291f, -0.07815486f, 0.00942877f, 
    -0.04877077f, 0.04144130f, 0.00282309f, 0.07068674f, -0.03800636f, 0.07425063f, 0.00215946f, 0.02800814f, 
    -0.04172228f, -0.03608593f, -0.11554094f, 0.01361259f, 0.01220552f, 0.00863402f, 0.06132738f, 0.06614445f, 
    -0.06702492f, -0.25865713f, 0.04316780f, 0.00589864f, -0.10816507f, 0.04924361f, 0.05974357f, 0.04562200f, 
    0.06506832f, -0.06021162f, 0.00710766f, 0.09616376f, -0.06194536f, 0.09234563f, -0.02030196f, 0.02490863f, 
    -0.03989742f, -0.03386710f, 0.01582584f, -0.01424405f, 0.08736806f, 0.05979026f, 0.08168089f, -0.01795373f, 
    0.06637494f, -0.12887792f, -0.00358070f, -0.07719126f, 0.14279340f, -0.17965637f, -0.01236286f, 0.04481611f, 
    -0.03189840f, -0.07143486f, 0.19098936f, 0.15522861f, 0.14699934f, 0.03494279f, -0.08880997f, 0.14242162f, 
    0.05283982f, -0.01421374f, -0.20466220f, 0.13708991f, -0.04986731f, 0.07883368f, -0.09616667f, 0.15140039f, 
    -0.11827473f, -0.33586630f, -0.13451768f, -0.03972824f, -0.05184285f, -0.06772634f, -0.06081610f, -0.21914487f, 
    0.08389900f, -0.07659576f, -0.05744803f, -0.06693466f, 0.16057228f, -0.17392668f, -0.23651670f, 0.11755768f, 
    -0.00266202f, 0.19876145f, 0.01933041f, 0.13981068f, 0.08290046f, 0.23026444f, 0.01874464f, 0.12947267f, 
    -0.17664120f, 0.16204041f, 0.14390069f, 0.36503154f, 0.01262277f, 0.01608300f, 0.10303134f, 0.17652076f, 
    -0.07911097f, 0.03377751f, -0.00011832f, 0.06795818f, 0.07294854f, -0.04080531f, -0.09018259f, 0.07212930f, 
    -0.07752302f, -0.10288738f, -0.02937021f, -0.15427731f, -0.09222021f, -0.01296406f, -0.06174217f, -0.09111074f, 
    -0.20876135f, -0.03485196f, 0.07641204f, 0.05985374f, -0.01326462f, -0.01193596f, 0.04557434f, -0.08112233f, 
    0.06167743f, 0.02029186f, -0.17835452f, -0.04052150f, -0.05310543f, -0.17826539f, -0.04214447f, 0.43478930f, 
    0.10431927f, 0.22441381f, -0.10075740f, -0.03554902f, 0.19989626f, -0.03654217f, 0.12949249f, 0.17421977f, 
    -0.27448535f, -0.07598531f, 0.08592154f, -0.03087959f, -0.17817603f, 0.03601586f, -0.00068384f, 0.18955034f, 
    -0.00249111f, 0.17494246f, 0.06825414f, -0.08174825f, 0.00319428f, 0.14844362f, -0.02860117f, 0.01634090f, 
    -0.03722664f, 0.06029036f, -0.05683614f, -0.08529661f, -0.01076614f, -0.13074003f, -0.03498282f, -0.03519238f, 
    0.33948722f, 0.19220999f, 0.16296712f, 0.22223458f, -0.06634095f, 0.01181123f, 0.10213304f, 0.03748408f, 
    -0.02588021f, 0.07666383f, -0.12319931f, 0.00189859f, -0.34225208f, -0.33817053f, -0.14488442f, -0.29197255f, 
    0.00400312f, -0.18418615f, 0.03486208f, 0.06122748f, -0.13493797f, 0.09660000f, 0.01679523f, 0.14384565f, 
    0.39133978f, -0.01973304f, 0.15656365f, 0.22579439f, -0.02019317f, -0.02423568f, -0.07616933f, 0.03706346f, 
    -0.01434364f, 0.19319315f, 0.17218226f, -0.04274523f, 0.04057641f, 0.16230834f, 0.05080204f, -0.06013492f, 
    -0.03355745f, 0.10242514f, 0.03286020f, -0.04166444f, 0.14641780f, -0.05591416f, 0.24412021f, 0.20099507f, 
    -0.06481463f, -0.13696522f, 0.13475856f, 0.11403802f, 0.04079525f, 0.02493691f, -0.05064686f, 0.10960104f, 
    0.09713683f, -0.07845505f, 0.08026707f, 0.03592150f, -0.07061270f, 0.03041940f, -0.03349038f, 0.01692640f, 
    0.06140714f, 0.00625254f, -0.05720983f, -0.02847481f, 0.16407484f, 0.15479493f, -0.00692502f, -0.14990823f, 
    0.01180444f, -0.00207197f, 0.00443456f, 0.14113364f, 0.13062097f, -0.13854630f, 0.12234356f, -0.03008400f, 
    -0.02504984f, 0.11857465f, 0.07678407f, 0.01206342f, 0.01676426f, 0.06383705f, -0.05486278f, 0.09831026f, 
    -0.01416908f, -0.03278894f, -0.11576682f, 0.02949532f, 0.01238148f, -0.01098577f, -0.03286270f, -0.03355116f, 
    0.16137698f, -0.30214623f, -0.14434592f, -0.13437201f, -0.11744037f, -0.20677321f, 0.08317539f, 0.01333206f, 
    0.00733682f, -0.12979877f, -0.07568449f, -0.05613447f, 0.02186660f, -0.11022332f, 0.07282314f, -0.03166188f, 
    0.15284048f, 0.19229165f, 0.08399504f, 0.18473302f, 0.21742079f, 0.39324874f, 0.01037597f, 0.14951415f, 
    -0.24886222f, 0.20746742f, 0.18962118f, 0.27873343f, 0.01040114f, -0.19990231f, 0.07147133f, 0.03439828f, 
    -0.07597683f, 0.03046709f, 0.14871792f, -0.09725623f, -0.19130057f, -0.30413008f, -0.20951901f, -0.10707033f, 
    -0.15347120f, -0.13247190f, -0.26906148f, -0.14099377f, -0.14399230f, -0.01570330f, 0.04735880f, -0.19150969f, 
    -0.02657984f, 0.19458839f, -0.08885999f, -0.10091485f, 0.11860351f, -0.20359664f, 0.13965765f, -0.16253050f, 
    0.00034517f, -0.01596627f, -0.15226506f, 0.00072215f, -0.00182763f, -0.30819196f, -0.27018589f, -0.03115190f, 
    0.09618573f, 0.01145073f, 0.07986687f, 0.04654157f, -0.02486754f, 0.13749348f, -0.06065331f, 0.00801142f, 
    0.27213636f, 0.03036862f, -0.04422179f, -0.01821374f, 0.16025886f, 0.12257171f, 0.02479526f, 0.10535885f, 
    0.02875016f, 0.07105143f, 0.10242213f, 0.22601180f, -0.09424876f, -0.15645337f, -0.21113473f, -0.04284224f, 
    0.09333219f, 0.12730804f, 0.12302773f, 0.01969305f, 0.12543094f, 0.03768534f, 0.00041863f, 0.06951393f, 
    0.30245081f, -0.36187980f, -0.28808501f, 0.14749870f, -0.02947385f, 0.01754946f, -0.05978228f, -0.13362876f, 
    0.00213451f, -0.05816638f, 0.07313122f, -0.04509034f, 0.08572866f, 0.19625033f, 0.21844061f, -0.10758936f, 
    0.07809177f, 0.12303971f, 0.05606121f, 0.08227804f, -0.06528098f, -0.04776184f, 0.08238997f, 0.19479884f, 
    -0.28630656f, -0.67396671f, -0.06561804f, -0.16367286f, 0.05843377f, 0.07574515f, -0.04546732f, 0.00902492f, 
    -0.06381509f, 0.08300877f, -0.19496857f, 0.04341388f, -0.12764186f, -0.40764970f, -0.11066110f, 0.07594047f, 
    0.00728729f, -0.07256754f, -0.07561086f, -0.01741203f, 0.03792668f, 0.01199408f, 0.08525346f, -0.02293224f, 
    -0.06822600f, -0.27294618f, 0.08400206f, -0.03704285f, 0.12908892f, 0.09702263f, 0.01083872f, 0.09782361f, 
    0.06671519f, 0.03326613f, -0.04319744f, 0.15548238f, -0.07618252f, -0.19848436f, -0.08148635f, -0.01551201f, 
    0.03786377f, -0.01139203f, 0.02153380f, -0.05831647f, 0.11897030f, 0.03497114f, -0.05902450f, 0.17657578f, 
    -0.32506579f, -0.11083388f, 0.25774580f, 0.06588788f, 0.15959187f, -0.08187413f, 0.01373152f, -0.12897679f, 
    0.10289183f, -0.18940666f, -0.04000701f, -0.04800879f, -0.32509321f, 0.08403359f, 0.26429069f, 0.09741065f, 
    -0.08549500f, -0.12395420f, 0.00796217f, -0.07508371f, -0.00213423f, -0.06057815f, -0.10424658f, 0.10511045f, 
    0.61403829f, 0.53190559f, 0.31840396f, 0.03551109f, 0.02140475f, 0.02616251f, 0.04278459f, 0.20401198f, 
    0.00908141f, 0.04395317f, -0.08267394f, -0.03841267f, 0.07192725f, 0.16772726f, 0.15560512f, 0.02807587f, 
    -0.01370617f, -0.08201367f, 0.10917040f, -0.17902286f, 0.11428659f, -0.02064132f, 0.11405565f, 0.20600986f, 
    -0.01603863f, -0.12798668f, 0.21136911f, -0.13544075f, 0.06655294f, 0.04350956f, 0.04621584f, 0.01069753f, 
    0.06796640f, -0.05706681f, 0.16269509f, 0.04456234f, 0.34873661f, 0.39884245f, 0.39767084f, 0.08773702f, 
    0.03218559f, -0.10747755f, -0.05033553f, -0.00580889f, 0.10455223f, 0.05927002f, 0.01422750f, -0.08879322f, 
    0.04122185f, 0.10836018f, 0.14106192f, -0.02129314f, -0.02765419f, -0.02849111f, 0.09657172f, 0.01690010f, 
    -0.07270814f, 0.01375890f, 0.05460838f, -0.00302040f, -0.27858391f, -0.14043960f, -0.18738706f, 0.23877952f, 
    0.06221893f, 0.10760733f, -0.06281611f, 0.05584043f, 0.00732395f, 0.12713216f, -0.03926633f, 0.05658696f, 
    0.02371238f, -0.11254996f, 0.28490153f, 0.02436210f, 0.00910913f, 0.05326366f, -0.02469667f, 0.22385882f, 
    -0.10318966f, -0.09906727f, 0.03445805f, -0.03443084f, -0.15534995f, -0.15783845f, -0.02805674f, -0.13748755f, 
    0.15432639f, -0.01716064f, 0.04131842f, 0.03599391f, 0.22105062f, -0.11617318f, -0.01960370f, -0.03741144f, 
    0.24728377f, 0.02457864f, -0.27618495f, 0.13605760f, -0.17918245f, 0.14771511f, 0.07567793f, 0.08907565f, 
    -0.04972132f, -0.07845974f, 0.06581507f, -0.08772555f, -0.10479710f, -0.18027407f, -0.10815060f, -0.06224182f, 
    0.00981685f, -0.10643853f, -0.01657784f, 0.08258806f, -0.06427421f, -0.04834281f, 0.11630022f, 0.09559445f, 
    -0.18670060f, -0.37034297f, 0.01462955f, -0.02930875f, 0.04995870f, 0.07976369f, 0.02880505f, 0.12185815f, 
    0.02382873f, -0.05587665f, -0.04908563f, -0.05461638f, -0.00030514f, -0.19916390f, -0.19248766f, 0.00630719f, 
    0.05370061f, 0.10223849f, 0.11782606f, 0.00458170f, 0.01957470f, -0.00369004f, -0.05508095f, 0.11120500f, 
    0.01002188f, 0.00609366f, 0.09387063f, 0.04975669f, 0.15018347f, 0.09691452f, -0.05391669f, -0.14047651f, 
    -0.00967595f, 0.09028565f, 0.12555283f, -0.04401212f, -0.10936181f, -0.17999847f, 0.02170153f, 0.04293662f, 
    0.06671482f, -0.08199596f, 0.05903389f, 0.09640019f, -0.02520479f, 0.04010770f, -0.06716812f, 0.04394040f, 
    -0.03378780f, 0.04111576f, 0.00371795f, 0.16114062f, 0.05401731f, 0.13162234f, 0.21179569f, -0.13598976f, 
    -0.04226008f, 0.12058721f, -0.14412130f, -0.04815067f, -0.25011155f, 0.16722453f, 0.00173345f, 0.13047473f, 
    -0.11610786f, -0.15752786f, 0.21890964f, -0.13239594f, -0.04091460f, -0.06482513f, 0.13556378f, -0.03560993f, 
    -0.07713286f, 0.23247837f, 0.20593856f, 0.05649371f, 0.01767767f, 0.14097594f, 0.03277434f, 0.14706427f, 
    -0.03543019f, -0.01625365f, -0.05928060f, -0.06277115f, 0.02514417f, 0.27111629f, 0.29273474f, -0.13022240f, 
    0.03125557f, -0.04659870f, 0.05876048f, -0.03708593f, -0.01904405f, -0.07948822f, 0.08689156f, -0.19648160f, 
    -0.13338366f, 0.03102805f, 0.06045689f, 0.10846759f, -0.02811035f, -0.12733756f, 0.15537392f, -0.03254460f, 
    -0.03533269f, -0.10357066f, -0.06650110f, 0.05614673f, 0.03458533f, 0.03741269f, 0.12404198f, 0.06362147f, 
    -0.03392120f, 0.17633431f, -0.14568788f, 0.09179571f, 0.06275091f, 0.03455929f, 0.09972464f, -0.03903652f, 
    -0.06539212f, 0.06087688f, 0.03128641f, 0.04090731f, 0.00130896f, -0.04372327f, 0.03647780f, 0.04608701f, 
    0.00397567f, 0.02379119f, -0.04073365f, -0.01897182f, -0.03902724f, -0.06564172f, -0.00823648f, 0.01005033f, 
    -0.03386812f, -0.00264607f, 0.01312004f, 0.02702581f, -0.00667970f, 0.04198653f, 0.05594901f, 0.03552201f, 
    -0.05057967f, -0.03117072f, 0.02996891f, 0.05676069f, -0.06575525f, 0.03792229f, 0.00388603f, -0.02671822f, 
    0.03375717f, 0.04789414f, 0.00594761f, -0.02298175f, -0.05064904f, -0.04842924f, 0.01668954f, -0.07313085f, 
    -0.01136245f, -0.03858529f, -0.03020155f, -0.01966121f, -0.05785850f, 0.02223435f, -0.02590905f, -0.04394583f, 
    0.01590795f, 0.02332240f, -0.01832678f, -0.04513735f, 0.00630297f, 0.02824495f, -0.05517659f, -0.04800116f, 
    0.05789129f, -0.04804094f, 0.05998307f, -0.03572857f, -0.01881248f, 0.04793826f, -0.00348449f, 0.01214319f, 
    -0.04534134f, 0.00330847f, 0.02381678f, -0.07437445f, -0.01458398f, -0.02400288f, 0.05537738f, -0.04729494f, 
    0.05052605f, -0.05247126f, -0.04048084f, -0.06814179f, -0.00606723f, -0.04446664f, 0.03534754f, -0.01355148f, 
    -0.05838068f, 0.00883246f, 0.02312474f, 0.01476520f, 0.00266091f, 0.01038580f, -0.06345005f, -0.08750016f, 
    -0.08302346f, -0.02479859f, -0.01025809f, 0.01104182f, 0.02274419f, 0.00260019f, -0.03564831f, -0.04236971f, 
    0.04892782f, 0.05362877f, 0.05538229f, 0.05898993f, 0.02719066f, 0.05840691f, 0.02072579f, 0.05808543f, 
    0.05350078f, -0.04796009f, -0.06794958f, -0.00529914f, 0.02334275f, 0.04771252f, 0.05949930f, -0.01006142f, 
    -0.02283878f, 0.03269055f, -0.04674290f, -0.04157488f, -0.02707395f, -0.07278822f, -0.04623644f, 0.04388238f, 
    -0.07040364f, -0.07721029f, -0.01996795f, -0.08812689f, -0.06818984f, 0.02240447f, -0.05376801f, 0.02437312f, 
    0.01686946f, -0.01822457f, 0.02286235f, 0.07050001f, 0.05057189f, 0.02186709f, 0.05926735f, -0.03688014f, 
    0.03583703f, -0.02689583f, -0.05745593f, -0.07294964f, 0.00030181f, -0.05240879f, -0.05214319f, -0.00823391f, 
    0.00996710f, -0.07095763f, -0.02681081f, 0.03079418f, -0.02205513f, -0.05152364f, 0.00144716f, -0.07059958f, 
    0.03714018f, 0.04024612f, 0.00485522f, -0.05469437f, 0.07287339f, -0.05634722f, 0.04949071f, 0.04373254f, 
    0.01865672f, 0.04397932f, -0.04076891f, 0.05460984f, 0.00029476f, -0.02900491f, 0.01485981f, 0.03051365f, 
    -0.09393064f, 0.02336328f, -0.07638361f, -0.07758634f, -0.00626218f, -0.05857008f, 0.06065472f, 0.02383069f, 
    -0.01879097f, -0.03653261f, -0.04309525f, -0.07796542f, 0.00745755f, -0.01654299f, -0.00637805f, -0.03955656f, 
    -0.05406630f, -0.03862054f, 0.05519112f, 0.03169763f, -0.01905344f, 0.01016994f, -0.02546016f, -0.04589969f, 
    0.08812019f, -0.09609081f, 0.14550433f, 0.19047929f, -0.07092499f, 0.06732349f, 0.05325036f, -0.04144565f, 
    -0.01822945f, -0.00470211f, 0.05688972f, -0.04638860f, -0.49788672f, 0.64121264f, -0.08522159f, 0.07484811f, 
    0.12270740f, -0.00579720f, 0.15562572f, -0.00824687f, -0.08696683f, 0.02745553f, 0.05755303f, 0.23821761f, 
    -0.19811316f, -0.01305313f, 0.07105596f, 0.24419996f, -0.00968828f, -0.08349092f, 0.05910639f, -0.04027257f, 
    0.01530403f, 0.10602406f, -0.03291222f, 0.02826484f, -0.21236430f, 0.05518674f, -0.12434558f, -0.25327399f, 
    -0.20828402f, 0.02010020f, -0.13728587f, 0.00301421f, -0.04745691f, -0.10747990f, -0.00700570f, -0.16678607f, 
    -0.08297517f, 0.01703777f, 0.58898616f, -0.04503237f, -0.02464553f, -0.14307377f, -0.12974872f, 0.07254156f, 
    -0.06062518f, 0.07912144f, 0.00348726f, 0.03199187f, 0.01671497f, -0.19754058f, -0.10052678f, 0.18792906f, 
    0.03246134f, 0.02816551f, -0.03991825f, 0.00967141f, 0.10969248f, 0.07114893f, 0.09510019f, -0.01774022f, 
    -0.29682341f, 0.55024421f, -0.02270070f, 0.10102086f, 0.05222902f, -0.03928525f, -0.05421781f, 0.08335912f, 
    0.04209409f, -0.00019576f, 0.09664524f, 0.05933759f, 0.07649659f, 0.24469352f, 0.12571120f, -0.14634448f, 
    -0.09583339f, -0.05280311f, -0.08331531f, 0.10313363f, -0.05845790f, 0.02161219f, -0.02592646f, 0.12324321f, 
    0.05619958f, 0.30909109f, -0.08361391f, -0.25491023f, 0.04254336f, 0.08929358f, 0.12087718f, 0.22872017f, 
    -0.16685617f, 0.07585412f, -0.06970885f, -0.01083169f, -0.24571186f, 0.03570693f, -0.15799496f, -0.15381889f, 
    -0.04588791f, -0.07341306f, 0.10351386f, -0.08154269f, 0.21396658f, 0.04564583f, 0.13771732f, -0.10896064f, 
    0.21451446f, -0.00149080f, -0.18615183f, -0.13177150f, -0.06234805f, 0.03243490f, 0.15965225f, -0.00641065f, 
    0.05887897f, 0.17584135f, 0.11095123f, 0.04926902f, 0.46546012f, 0.09010192f, -0.13349673f, -0.14848840f, 
    0.09900793f, -0.00303641f, 0.09321307f, 0.03909906f, 0.11592697f, 0.13881670f, 0.08893618f, 0.07275021f, 
    -0.25373158f, -0.37504214f, 0.04943507f, 0.25479063f, 0.06979651f, 0.00900854f, 0.06224098f, 0.09747151f, 
    -0.01635866f, 0.00331244f, 0.10694709f, 0.03977172f, -0.04183485f, -0.01393531f, -0.07082865f, 0.17812955f, 
    -0.08058914f, 0.08915488f, -0.05289402f, 0.10408334f, -0.11105358f, 0.08253131f, -0.08800429f, 0.00889036f, 
    0.07707905f, -0.02537390f, -0.10263991f, 0.16378534f, 0.15079953f, -0.01048316f, 0.03012222f, 0.04814435f, 
    -0.10060702f, 0.08033028f, 0.04565271f, 0.08000859f, -0.10209744f, -0.13791445f, -0.12739372f, 0.16662470f, 
    -0.03399391f, -0.00852069f, -0.09290637f, -0.03556944f, -0.04997011f, 0.05433023f, 0.04910060f, 0.01636115f, 
    0.03063694f, 0.01922332f, 0.18265800f, 0.12166523f, 0.10678928f, 0.06198433f, -0.07584752f, 0.02780737f, 
    -0.26946682f, 0.04640871f, 0.02501595f, 0.15263182f, -0.33038917f, 0.25822130f, -0.17883657f, 0.19273181f, 
    0.24420603f, 0.01148940f, 0.01640766f, 0.09604533f, 0.02634865f, 0.18972400f, -0.06466448f, -0.03095075f, 
    -0.18473929f, 0.19119482f, 0.16593243f, -0.08902351f, -0.14169572f, -0.11732399f, -0.07829640f, 0.12776683f, 
    -0.01120829f, -0.04396635f, 0.01114720f, 0.06307379f, -0.19530216f, -0.04960720f, -0.29409382f, 0.11515447f, 
    0.05655989f, -0.02170909f, 0.06120708f, -0.05353918f, -0.03068195f, -0.08889643f, -0.05003810f, -0.19602382f, 
    0.50615728f, -0.02505074f, 0.34825855f, -0.09397372f, -0.03637599f, 0.13359420f, -0.12172069f, 0.21867277f, 
    -0.06082247f, -0.11914118f, 0.07130793f, -0.06482214f, -0.19764203f, -0.05058188f, 0.08321971f, 0.03318266f, 
    -0.07040404f, -0.09851637f, -0.06584870f, -0.09364208f, -0.00659923f, 0.01109996f, 0.07469139f, 0.10581683f, 
    -0.20962524f, 0.18468176f, 0.06119993f, 0.14662340f, -0.07329015f, 0.04679468f, -0.12001484f, 0.04699027f, 
    0.07776603f, -0.20507878f, -0.05223601f, -0.04543073f, 0.15679272f, -0.22835605f, -0.22385000f, 0.11247817f, 
    0.01254566f, 0.05499693f, 0.01285592f, 0.04886394f, 0.07900265f, 0.12849207f, -0.03270433f, -0.09410237f, 
    -0.05471968f, -0.09893090f, 0.22433601f, 0.03927849f, 0.11607565f, 0.09946841f, 0.02507288f, -0.00999548f, 
    0.00795726f, 0.11881342f, 0.17384352f, 0.00792532f, -0.18001182f, 0.15207174f, -0.08299606f, -0.06812029f, 
    0.01623010f, -0.03366119f, 0.06429782f, 0.12164973f, -0.03543545f, 0.07345535f, -0.12220043f, 0.04790294f, 
    0.27257365f, -0.09707027f, 0.02119543f, 0.01077314f, 0.07318867f, 0.17267425f, 0.09294057f, -0.01575560f, 
    -0.00297574f, 0.08315238f, -0.05696984f, 0.18856063f, -0.14463940f, -0.01788960f, -0.05670967f, 0.18908881f, 
    -0.11560931f, -0.04428283f, 0.05300847f, 0.12874298f, -0.02761519f, -0.02071291f, 0.10311360f, -0.02823563f, 
    -0.53044242f, -0.07857037f, 0.16565719f, 0.05536014f, 0.13786945f, 0.01754674f, -0.02649745f, -0.12160815f, 
    -0.02017085f, -0.02474103f, -0.02376464f, -0.11645043f, 0.24493712f, -0.07199012f, -0.00810632f, 0.03253176f, 
    0.03683039f, -0.00516629f, -0.00538755f, 0.03553930f, 0.05564236f, 0.02676572f, 0.11374208f, 0.04933102f, 
    -0.34606883f, -0.05913976f, 0.07303006f, 0.27398807f, -0.08786410f, -0.01367038f, 0.01616727f, 0.06358425f, 
    0.04029471f, 0.01620625f, -0.04023129f, 0.08201710f, -0.06564329f, -0.02539156f, 0.16625473f, -0.01834921f, 
    0.01493585f, 0.11582767f, -0.14530516f, 0.08453356f, 0.11272717f, -0.09528455f, -0.16176306f, 0.00220123f, 
    0.00954122f, 0.01923530f, 0.10997068f, 0.05178420f, 0.05442711f, 0.17153683f, 0.15681210f, 0.11648455f, 
    0.01697360f, 0.01501877f, 0.13442042f, 0.01831618f, -0.08462045f, 0.22324884f, 0.15566508f, 0.15369719f, 
    -0.02893198f, 0.10732251f, -0.06233801f, 0.16108140f, 0.08834289f, -0.01326091f, 0.09801651f, 0.19520855f, 
    -0.16676599f, -0.10370140f, 0.15178894f, 0.13867806f, -0.10317082f, -0.17311558f, -0.08984384f, -0.02407034f, 
    0.06136822f, -0.00390104f, -0.00968059f, -0.11009391f, 0.03583301f, 0.10148073f, 0.01842029f, -0.14951444f, 
    -0.13428932f, -0.00450405f, -0.06353088f, -0.05670071f, 0.12338761f, 0.12661548f, 0.07240125f, -0.01046098f, 
    -0.07815885f, 0.13904195f, 0.01045733f, 0.01044881f, -0.04183056f, -0.12059223f, -0.00469038f, 0.02011643f, 
    -0.02196893f, 0.02143107f, 0.05478610f, -0.11058339f, -0.04038798f, -0.09572639f, -0.19410719f, 0.19536497f, 
    0.05971834f, -0.01772715f, 0.03637972f, 0.10689474f, 0.01475442f, -0.02035323f, -0.04968483f, 0.00397701f, 
    0.17776887f, 0.22339763f, 0.13820399f, 0.00403675f, -0.07309060f, -0.04270712f, -0.03938068f, 0.02285301f, 
    -0.05200613f, 0.00176062f, 0.01489024f, 0.03360252f, 0.10820323f, 0.02969258f, 0.04992826f, -0.12635407f, 
    -0.01966649f, 0.00312240f, -0.06790227f, -0.02405607f, 0.12236174f, 0.21090899f, 0.05145641f, 0.07521895f, 
    -0.00891933f, 0.37727398f, -0.19157982f, -0.16280226f, -0.06538752f, -0.03721507f, -0.07899608f, 0.01761063f, 
    -0.10279667f, 0.04685514f, 0.01612532f, 0.00245954f, -0.04830214f, -0.01346828f, -0.05463854f, -0.16787307f, 
    0.02303296f, 0.11892176f, -0.04032470f, -0.06012609f, 0.06831041f, 0.08367516f, 0.24822183f, 0.06000915f, 
    0.12828697f, 0.11367559f, -0.17654867f, -0.00835881f, 0.01338579f, 0.07648193f, 0.04976426f, -0.02639597f, 
    0.02905582f, 0.12598889f, 0.06557295f, -0.02253766f, 0.33915204f, -0.04191214f, -0.01012060f, 0.08129930f, 
    0.01493037f, 0.15140299f, -0.10523088f, -0.01461952f, 0.06828171f, -0.01251104f, 0.09733643f, -0.01735171f, 
    -0.24713081f, -0.08808494f, -0.03537352f, 0.03091858f, -0.10884326f, 0.11024398f, -0.03381621f, 0.04122420f, 
    -0.14738497f, -0.05306997f, -0.02307906f, 0.01526505f, -0.15393028f, 0.01315945f, 0.28981385f, 0.09487157f, 
    -0.04306311f, 0.00628990f, 0.06210280f, 0.11111850f, -0.05554072f, -0.06602145f, 0.05071117f, -0.03562660f, 
    0.35382307f, 0.07690127f, -0.26109043f, -0.01985806f, 0.02092933f, -0.05002223f, 0.00264057f, 0.08203881f, 
    0.00683910f, 0.13947101f, 0.05555411f, -0.10922938f, -0.18020089f, -0.18228489f, 0.02346139f, 0.28038403f, 
    -0.20927975f, 0.01936194f, -0.01202961f, 0.16713223f, -0.04212903f, -0.06466167f, 0.11186122f, -0.02756457f, 
    -0.09396753f, -0.05367000f, -0.19297266f, 0.03547509f, 0.01066343f, 0.13644809f, -0.00409068f, -0.11643612f, 
    -0.00483627f, -0.02233258f, 0.11180460f, 0.16962162f, 0.16517615f, 0.30418938f, 0.02658379f, -0.12052098f, 
    -0.09445520f, 0.03236539f, -0.06763944f, 0.00728633f, 0.14467786f, 0.10326678f, 0.07438268f, 0.10830135f, 
    0.00008174f, 0.00281163f, -0.23392950f, -0.15700194f, 0.17169088f, 0.09915669f, 0.00359688f, 0.09472312f, 
    -0.09109329f, 0.02341488f, -0.09933376f, 0.06606140f, -0.07944845f, -0.04926663f, 0.00533129f, 0.10295947f, 
    -0.08365711f, -0.16636214f, -0.01892318f, -0.08738352f, -0.04314654f, -0.01383942f, -0.04555387f, -0.01747672f, 
    -0.02461195f, 0.02906575f, -0.04557906f, 0.09737796f, 0.06310087f, 0.00834072f, 0.02670210f, -0.14179519f, 
    -0.05358252f, -0.01026790f, -0.01469744f, 0.02869201f, 0.40851769f, 0.11198611f, -0.05287303f, -0.07182635f, 
    0.07901278f, -0.09303804f, 0.13828039f, 0.01436283f, -0.01361660f, -0.05531413f, 0.11292647f, 0.17392077f, 
    -0.01649985f, 0.29715833f, 0.19315270f, 0.10976924f, 0.04629411f, -0.03136218f, 0.03345867f, -0.19794571f, 
    0.01926460f, -0.08355924f, 0.05991841f, 0.15604647f, -0.06795725f, -0.04231631f, 0.05578045f, 0.17077896f, 
    0.00667842f, -0.05267655f, -0.09320381f, 0.04233330f, -0.10167409f, -0.03935254f, -0.14473400f, -0.22512081f, 
    0.10547266f, 0.07286894f, -0.15070775f, -0.22578739f, 0.18162565f, 0.06603484f, -0.10946218f, -0.14214326f, 
    0.02342772f, 0.01549873f, 0.06991880f, -0.02244762f, 0.11630763f, -0.10081691f, -0.03981291f, -0.02522450f, 
    -0.14946768f, -0.15259314f, -0.03991920f, -0.19732375f, 0.11193406f, -0.10273118f, 0.03103719f, 0.22197971f, 
    0.04682087f, 0.10854208f, 0.13217919f, -0.02523017f, -0.11512684f, 0.02602814f, -0.09596306f, -0.10585964f, 
    0.07880791f, -0.03596947f, 0.05225551f, 0.12954739f, 0.27457708f, 0.12787437f, 0.38659820f, -0.13237421f, 
    -0.22911070f, -0.20244756f, 0.05700566f, -0.05688372f, 0.01611188f, -0.01529134f, -0.08182117f, 0.06144502f, 
    0.15654930f, -0.08103612f, 0.05216731f, 0.01877490f, 0.20479622f, 0.02656060f, -0.02862765f, 0.15333650f, 
    -0.11565175f, -0.06608047f, -0.05609494f, 0.04426030f, 0.09809358f, 0.13379046f, 0.11918940f, 0.18201008f, 
    0.00432436f, -0.05235318f, 0.06662831f, -0.01851065f, -0.02116933f, -0.14563024f, -0.00178968f, -0.01766041f, 
    -0.23166096f, -0.48264459f, 0.07052515f, -0.27251786f, 0.08099038f, 0.05299462f, -0.09109925f, -0.07071859f, 
    0.15224376f, 0.12173933f, 0.15311156f, 0.06419392f, 0.07157834f, 0.02225669f, -0.04009126f, -0.05547155f, 
    0.15815672f, 0.04589666f, 0.06039957f, 0.08981863f, 0.10038673f, 0.06606602f, -0.02636170f, 0.18941660f, 
    0.10709617f, 0.08107144f, -0.02166377f, 0.01123825f, 0.09065007f, 0.05722556f, -0.02906139f, 0.07242757f, 
    0.08505323f, 0.00913920f, 0.03587975f, 0.06721016f, 0.12964867f, -0.14689083f, 0.08698428f, -0.23855959f, 
    0.00077417f, 0.03280063f, 0.00813666f, -0.04193631f, -0.08828525f, 0.13570470f, 0.00584880f, -0.07503617f, 
    0.16585806f, 0.24674799f, 0.14569363f, 0.23734778f, 0.07319786f, -0.01678385f, -0.01907952f, -0.11695860f, 
    0.09956986f, 0.04846561f, 0.08878184f, 0.01500738f, 0.00967791f, -0.15461965f, -0.28870666f, -0.14834660f, 
    -0.02805199f, 0.04724660f, -0.02429173f, 0.06644572f, 0.11419111f, 0.11042133f, 0.04887747f, -0.04169839f, 
    -0.38796335f, -0.39186287f, 0.04337725f, -0.08038592f, -0.06580670f, -0.03272497f, -0.22059618f, -0.02743017f, 
    0.01395336f, 0.04427172f, 0.00087421f, 0.03502168f, -0.11439463f, 0.45692495f, 0.36255899f, 0.14526357f, 
    0.10328522f, 0.07029279f, 0.00124305f, -0.04283221f, -0.01252451f, -0.06824364f, 0.05694934f, -0.14803290f, 
    0.08173224f, -0.27543369f, -0.26749071f, -0.28407508f, -0.06486925f, -0.08586948f, -0.00225439f, -0.11571712f, 
    -0.09204168f, -0.06056073f, -0.32219344f, -0.04796913f, -0.18223584f, -0.18974075f, -0.14139794f, -0.01397240f, 
    -0.06559425f, -0.05028943f, -0.07447623f, -0.10795599f, 0.08564934f, 0.09525762f, 0.04528096f, 0.01580712f, 
    -0.18125249f, -0.14993276f, 0.02015187f, 0.19605777f, 0.01329548f, 0.06685390f, 0.07953615f, 0.03725055f, 
    0.00253764f, -0.07969163f, 0.04277604f, 0.06830972f, -0.17834376f, -0.04888693f, -0.07749353f, -0.10454629f, 
    -0.06679058f, 0.00868819f, -0.00479792f, -0.00002313f, 0.00813081f, 0.12759729f, 0.06799319f, 0.03616285f, 
    -0.25856936f, -0.11609937f, -0.08947104f, -0.00641778f, 0.08603783f, 0.01845852f, 0.00285519f, 0.08808647f, 
    0.08608899f, -0.04352512f, 0.07936447f, -0.02839630f, -0.26485711f, -0.07308035f, 0.11390871f, 0.10296047f, 
    0.24203341f, 0.02497295f, -0.17766377f, 0.14098729f, -0.00321086f, 0.01284755f, -0.12938173f, 0.04178083f, 
    0.06157773f, 0.25959435f, 0.29670677f, 0.06043906f, -0.08065499f, 0.08867323f, 0.10956428f, -0.08772198f, 
    -0.07358132f, 0.00291118f, 0.03782156f, -0.01681963f, 0.00095689f, -0.21117969f, -0.06651422f, 0.10322844f, 
    0.06916682f, 0.06894087f, -0.14255457f, -0.07822558f, -0.05073147f, -0.00594467f, -0.13165823f, 0.18277264f, 
    0.30316862f, 0.34040830f, 0.14122291f, 0.14004838f, 0.04948520f, 0.14348897f, 0.01871838f, 0.01872212f, 
    -0.02059592f, 0.01308498f, 0.02346395f, 0.04708364f, 0.22008017f, 0.37162521f, 0.36067262f, 0.29290250f, 
    0.03211811f, -0.04010357f, 0.19725938f, 0.06730106f, 0.12432041f, 0.01213602f, -0.05006968f, 0.01363388f, 
    -0.04818794f, 0.05324976f, 0.05305848f, 0.04400829f, 0.03838289f, 0.03063522f, -0.00826609f, 0.00693700f, 
    0.03298679f, -0.03150080f, -0.01075801f, -0.01407301f, -0.04837382f, 0.01389531f, -0.01316745f, -0.01732511f, 
    0.03211854f, -0.05382438f, -0.02785136f, 0.05565814f, -0.01093689f, 0.05768717f, -0.00222764f, -0.03677264f, 
    0.05243611f, -0.04947678f, 0.01636437f, 0.00563315f, -0.00690032f, 0.02906826f, -0.05891579f, -0.00863511f, 
    -0.00691460f, -0.04364617f, -0.05420575f, 0.00738011f, -0.00364051f, -0.07641962f, 0.03531612f, 0.03630072f, 
    -0.07389162f, -0.03646456f, -0.00824053f, 0.00074516f, -0.02943256f, 0.03309641f, -0.05147973f, -0.03155763f, 
    0.05005459f, -0.05021567f, 0.02084893f, 0.01053554f, -0.00264641f, -0.00857999f, -0.02398387f, -0.00262835f, 
    0.04760695f, 0.00480692f, 0.01130083f, 0.01925423f, -0.03049141f, -0.01439541f, -0.00259329f, 0.06311973f, 
    -0.02134312f, -0.01204151f, -0.01681104f, 0.06244683f, -0.04716636f, -0.00916118f, -0.03459321f, -0.01817437f, 
    -0.05685035f, 0.00711622f, 0.00970861f, -0.00738588f, -0.07151286f, 0.03858525f, -0.05726804f, 0.03445140f, 
    -0.04063150f, -0.01892708f, 0.00030034f, 0.03116226f, 0.00775405f, 0.04319156f, -0.03058643f, -0.02939459f, 
    0.04855777f, 0.05155618f, -0.04512377f, 0.04028874f, -0.06300428f, 0.00810089f, 0.00297726f, 0.02600699f, 
    0.00683048f, -0.05050109f, -0.03755724f, 0.01829090f, 0.03563339f, -0.04255983f, -0.00575229f, -0.04377962f, 
    0.02892302f, 0.04746520f, -0.04403305f, -0.00536729f, 0.04877860f, -0.05486077f, -0.01580922f, 0.06276099f, 
    -0.03184986f, -0.01592910f, 0.03476266f, -0.08026560f, -0.00370436f, 0.00354240f, -0.05193598f, 0.03082136f, 
    0.00448265f, -0.06040685f, 0.04907706f, 0.00085164f, -0.01204003f, 0.04260612f, -0.00394620f, -0.08121870f, 
    -0.02493489f, -0.01816810f, -0.03206223f, -0.02814359f, -0.05347136f, -0.02382738f, -0.01734003f, 0.03344071f, 
    -0.00250048f, 0.01521729f, -0.05009253f, -0.02787643f, 0.04683840f, -0.05739989f, -0.07015757f, -0.02421662f, 
    0.00305763f, -0.03476705f, 0.00735985f, -0.04244374f, 0.00473960f, -0.02353265f, -0.05149584f, 0.06545993f, 
    0.05670438f, 0.03142036f, 0.04307608f, 0.00986230f, 0.01806641f, -0.05611181f, 0.00747266f, -0.03206580f, 
    -0.05763913f, -0.03243750f, 0.01151017f, 0.03491965f, -0.04254400f, -0.07146376f, 0.04711701f, -0.00842599f, 
    -0.07028072f, -0.03223594f, 0.02396118f, -0.01506938f, -0.05803769f, -0.07526940f, -0.00878171f, 0.01977187f, 
    -0.03871343f, -0.01214206f, -0.04697329f, 0.04551908f, 0.02423490f, -0.07324813f, -0.07480182f, -0.02754780f, 
    -0.04990881f, -0.01210077f, -0.01984145f, -0.00131497f, -0.00794377f, -0.00774077f, -0.03435935f, -0.03541671f, 
    -0.01947833f, 0.00487029f, -0.09616659f, -0.07203509f, 0.11902438f, 0.07138012f, -0.05626925f, 0.01472754f, 
    0.02130761f, 0.05739615f, -0.01786196f, 0.06803060f, -0.08513349f, -0.08129931f, 0.04417742f, 0.05507961f, 
    0.08284738f, 0.02535642f, -0.07233307f, 0.00167137f, 0.07148677f, 0.09267598f, -0.03078063f, 0.01583716f, 
    -0.20342122f, 0.08651811f, 0.17463179f, -0.10389576f, -0.08261061f, -0.00787986f, 0.06554203f, 0.04674944f, 
    0.05935222f, -0.13411669f, 0.16298331f, 0.01889602f, 0.00264635f, -0.07829408f, 0.01403631f, -0.07903841f, 
    0.08144446f, 0.08681364f, 0.09835110f, 0.00378030f, 0.04351338f, 0.04137466f, -0.03690067f, 0.06525618f, 
    0.02736265f, 0.04507649f, 0.08150353f, -0.02269944f, 0.02804179f, 0.05415889f, 0.07310498f, -0.05369876f, 
    -0.03600780f, -0.02623129f, 0.00886954f, -0.04490180f, -0.11388882f, -0.08817969f, -0.00057167f, 0.10010599f, 
    -0.04436467f, -0.12511624f, -0.04412921f, -0.02223831f, -0.06052832f, -0.07745849f, 0.06671993f, 0.09501472f, 
    -0.03090360f, -0.23813611f, 0.24360766f, -0.35115039f, -0.07470720f, -0.04773210f, -0.02922751f, -0.04412606f, 
    0.02110383f, 0.00295908f, 0.00009020f, -0.01479215f, 0.02463957f, -0.00171622f, -0.10628438f, 0.01996141f, 
    0.05475426f, 0.03232344f, -0.02339945f, -0.07728798f, 0.03991484f, -0.09892414f, 0.07006878f, 0.01392689f, 
    0.09107555f, -0.10191149f, -0.11888091f, -0.03355209f, 0.03942795f, -0.09958986f, -0.14117849f, -0.04260528f, 
    0.28251815f, 0.14515270f, 0.05550996f, 0.00500974f, 0.04089619f, -0.05288778f, -0.06402794f, -0.13411313f, 
    0.04761455f, -0.08995885f, 0.03122773f, 0.01552963f, 0.03746807f, 0.20468533f, 0.00728556f, 0.05184727f, 
    0.16526091f, -0.00586481f, -0.12202842f, 0.13406324f, 0.09359160f, -0.07778272f, -0.04487635f, -0.07337363f, 
    0.01530202f, -0.03698375f, -0.03043428f, 0.02275755f, 0.31275597f, -0.23084360f, -0.15410872f, 0.08572136f, 
    0.14546740f, -0.19818139f, -0.06470182f, -0.09100305f, -0.08891828f, 0.03206738f, 0.03835208f, 0.02201693f, 
    -0.15794976f, -0.01437325f, 0.15910594f, -0.06039526f, 0.08968426f, 0.01711806f, 0.09261496f, -0.10916451f, 
    0.01128961f, -0.14701283f, -0.04965372f, -0.03082856f, 0.09108889f, 0.10590662f, 0.20603171f, -0.05370891f, 
    0.01360934f, -0.07693933f, 0.15162435f, -0.00144643f, 0.05339058f, 0.13894308f, 0.16456190f, -0.10894731f, 
    0.05718907f, -0.38939053f, 0.09968190f, 0.21021476f, -0.16580740f, -0.00699284f, -0.08518504f, 0.02461336f, 
    0.06361714f, -0.05139817f, -0.02431336f, 0.17136070f, -0.12973779f, -0.22169147f, 0.01650381f, -0.01087133f, 
    0.03557466f, 0.05529838f, -0.04648690f, 0.06482437f, 0.08541796f, 0.02280636f, -0.12958492f, -0.07465999f, 
    0.00980700f, 0.01684976f, -0.05020048f, -0.01792708f, -0.03824669f, 0.02836174f, 0.04834267f, -0.06329808f, 
    -0.06461226f, 0.03147666f, -0.01902125f, -0.00415889f, 0.03574984f, -0.06361035f, -0.04472678f, -0.01296948f, 
    -0.00915862f, 0.01030721f, 0.00537961f, 0.05493424f, 0.05045469f, 0.04107783f, -0.06406831f, 0.01194089f, 
    -0.03496117f, -0.00157652f, 0.00716879f, -0.00621097f, -0.05447782f, -0.06749458f, -0.07456303f, 0.05763868f, 
    -0.00409513f, 0.02052962f, -0.05111011f, -0.01002709f, -0.01664609f, -0.04140220f, -0.01696298f, -0.03640183f, 
    0.04668554f, -0.01245569f, 0.00247274f, 0.02110309f, 0.01460892f, 0.04158372f, -0.07356521f, -0.03198336f, 
    -0.07454357f, 0.04419341f, 0.00001485f, 0.01572917f, -0.06312627f, 0.06137014f, -0.05902154f, -0.07615102f, 
    -0.06948949f, 0.03074830f, 0.06178435f, 0.00857656f, 0.03425527f, -0.03491499f, 0.06142779f, -0.04386854f, 
    0.04616427f, 0.00489336f, -0.07396156f, 0.03884696f, 0.02342733f, -0.03119447f, 0.02623238f, 0.02313890f, 
    0.03278180f, -0.05953114f, -0.05714156f, -0.07552122f, 0.04652628f, 0.01131646f, -0.01389613f, 0.06505467f, 
    0.04470256f, -0.00699320f, -0.03240514f, -0.06675889f, -0.03863410f, -0.06470436f, 0.04963201f, -0.02163002f, 
    -0.07235829f, 0.00286907f, -0.06987148f, -0.02708763f, 0.06026729f, -0.03993653f, -0.02375594f, -0.03238203f, 
    0.04418673f, -0.01027163f, 0.05599397f, -0.06993505f, -0.01293913f, -0.06496949f, -0.02324480f, -0.07481685f, 
    0.03648435f, -0.05260445f, -0.07682943f, 0.05762788f, -0.03424099f, 0.01934910f, -0.04505344f, 0.00406446f, 
    -0.05132145f, -0.06903882f, 0.02269947f, 0.03511996f, 0.05245610f, 0.01597394f, -0.06400749f, -0.04015319f, 
    -0.02919989f, -0.06858757f, 0.00768621f, -0.00316106f, -0.03686241f, 0.02645052f, -0.00836152f, -0.02763856f, 
    -0.07670148f, 0.03674864f, -0.02955336f, -0.01836512f, -0.00059813f, -0.00689631f, 0.05316510f, -0.00879795f, 
    -0.03718020f, -0.02637121f, 0.04986777f, 0.00963778f, -0.07326169f, -0.00149372f, -0.02261926f, 0.00596864f, 
    -0.01707190f, -0.06985386f, 0.02463470f, 0.02732132f, 0.01018821f, -0.01362947f, 0.04764626f, 0.04549956f, 
    0.04984971f, -0.06086706f, 0.04486319f, -0.03956944f, -0.01345063f, 0.01153768f, -0.05884777f, -0.02919661f, 
    -0.05281490f, 0.05062569f, -0.02816412f, -0.07329457f, 0.06506871f, -0.02578817f, 0.05685730f, 0.01985253f, 
    -0.04670449f, 0.02366764f, -0.03462394f, 0.04802744f, -0.01506162f, -0.06999686f, -0.05563846f, -0.06416962f, 
    -0.00246869f, -0.05330219f, -0.03936635f, -0.03724506f, -0.06002896f, -0.00185799f, 0.05809550f, 0.05825840f, 
    -0.03962230f, -0.04953940f, -0.06586307f, 0.04831271f, -0.05283639f, -0.03679157f, -0.00110651f, -0.07748631f, 
    0.00882287f, 0.01394814f, -0.07238656f, -0.21862267f, -0.00862095f, -0.05995870f, 0.17870727f, -0.02428439f, 
    0.03549121f, -0.11974605f, -0.10306154f, -0.29594436f, -0.08274422f, -0.10666912f, 0.15139282f, 0.00434579f, 
    0.03264429f, 0.10118743f, -0.28810298f, 0.16497974f, 0.05391990f, -0.14970079f, 0.22207032f, 0.15167844f, 
    -0.12203500f, 0.04459574f, 0.07035066f, 0.01482985f, -0.02368129f, -0.01786071f, 0.06200546f, -0.00554085f, 
    -0.03324478f, 0.17386322f, 0.12831512f, -0.03929352f, -0.06126418f, 0.05826718f, 0.11044859f, -0.11292358f, 
    -0.01666002f, 0.09318440f, -0.06447583f, 0.05722946f, -0.03528504f, 0.07861049f, 0.05483267f, 0.14727885f, 
    -0.26669574f, -0.07099206f, -0.06536778f, 0.22991313f, 0.06660528f, -0.05417652f, 0.14382122f, -0.02674286f, 
    -0.20157194f, 0.01853497f, -0.09424023f, -0.03433695f, 0.13737383f, -0.15258703f, 0.05839532f, 0.10511274f, 
    0.06388939f, 0.05024059f, -0.00813732f, -0.02240960f, 0.00822627f, 0.08863736f, -0.03238111f, 0.05154243f, 
    0.09433778f, -0.07278262f, 0.09451031f, 0.01673102f, -0.07605322f, -0.11072578f, 0.01444321f, 0.02321310f, 
    -0.03237584f, 0.22151171f, 0.12734050f, 0.14030887f, -0.05511806f, 0.14844289f, 0.02971991f, -0.12195551f, 
    -0.08594403f, 0.13241959f, 0.09994791f, 0.14180624f, 0.08034969f, 0.14142402f, 0.10907106f, 0.24911763f, 
    -0.04668362f, 0.28335983f, -0.16829890f, 0.21833734f, 0.08501838f, 0.02303701f, 0.01266060f, 0.18718116f, 
    0.06212255f, -0.14420515f, 0.04092867f, 0.01954124f, -0.11043829f, -0.10010508f, 0.02592686f, -0.10291034f, 
    0.04453506f, 0.24282002f, 0.01705812f, -0.10394344f, 0.17534761f, 0.14663339f, 0.13597193f, -0.08113685f, 
    -0.08307815f, 0.06291424f, -0.16109017f, 0.04408849f, -0.01964476f, -0.03421182f, -0.03726737f, 0.02662405f, 
    0.14328653f, 0.10621399f, 0.01098958f, -0.06096341f, 0.11923506f, -0.01620917f, -0.09219375f, -0.07425637f, 
    0.30765578f, 0.19240104f, -0.16372046f, -0.16889097f, 0.14104709f, -0.05204837f, -0.01315780f, 0.02712262f, 
    0.22291450f, -0.16410013f, -0.28487915f, -0.31082347f, -0.09966281f, -0.08017616f, 0.00581193f, 0.02569085f, 
    0.07453760f, 0.02745273f, -0.08523751f, 0.03446880f, -0.23738045f, -0.01575078f, 0.17015754f, -0.05959785f, 
    -0.00647374f, 0.11594887f, 0.07946469f, 0.19393715f, -0.02860769f, 0.20667881f, -0.03215238f, 0.19965468f, 
    0.27178651f, 0.22186022f, 0.17640816f, 0.06902822f, 0.02241604f, -0.19645463f, 0.00246080f, -0.08802150f, 
    -0.07300167f, -0.03589647f, 0.07390825f, -0.01537702f, -0.17858653f, -0.00062013f, -0.13654138f, -0.05525397f, 
    -0.08927539f, -0.07978138f, -0.01755312f, -0.01162905f, -0.30545026f, -0.06857972f, 0.15787388f, -0.18832690f, 
    0.02163852f, -0.05560103f, -0.02693746f, -0.02912159f, -0.02410204f, 0.13589543f, -0.09151650f, 0.19962107f, 
    0.13258508f, -0.07435016f, 0.14970589f, 0.07408247f, 0.16615741f, 0.31259850f, -0.11982316f, -0.12733257f, 
    -0.10011983f, -0.11442048f, 0.12787949f, 0.17141967f, 0.07069399f, 0.09076596f, 0.21656460f, 0.03852463f, 
    0.38071811f, 0.04071757f, -0.13926253f, -0.03431849f, -0.00118472f, 0.12083899f, 0.02539267f, -0.05585691f, 
    -0.11550926f, 0.00699953f, -0.20791575f, 0.02040701f, -0.13406445f, -0.02254369f, -0.06679164f, 0.01686744f, 
    -0.17848311f, -0.15813781f, -0.01364229f, -0.18049030f, -0.11924181f, -0.03822487f, -0.15829289f, 0.04972295f, 
    -0.13142490f, 0.21201652f, 0.40168250f, 0.11728805f, -0.07011764f, 0.05721843f, -0.14922881f, -0.00811647f, 
    0.04188756f, -0.04172946f, -0.01712826f, 0.02842213f, 0.21574712f, 0.23309532f, -0.03776169f, -0.05327003f, 
    0.04107910f, -0.00116958f, 0.15751666f, 0.01356738f, -0.01776272f, -0.01170928f, -0.08611026f, -0.09321639f, 
    -0.10992852f, 0.16768697f, -0.13743708f, 0.28878522f, -0.04235582f, 0.03991792f, 0.01308082f, -0.11054192f, 
    0.12775441f, -0.11187174f, -0.12741791f, 0.06850007f, -0.16088368f, 0.01461041f, 0.18624227f, 0.07427318f, 
    0.08277653f, -0.03585090f, -0.17272322f, -0.09066823f, -0.22560222f, -0.10123716f, -0.14036110f, -0.20244990f, 
    0.03138611f, -0.09720895f, -0.10494607f, -0.00104705f, 0.13167663f, -0.01413514f, 0.09845218f, -0.03220436f, 
    -0.02822164f, 0.01434003f, 0.01076086f, 0.05253397f, -0.03365012f, 0.04555860f, -0.01482003f, 0.05747455f, 
    -0.14339188f, -0.17973658f, -0.08760187f, -0.15733671f, -0.00647501f, -0.05462810f, 0.14043255f, 0.18355565f, 
    0.16911864f, 0.01433445f, 0.16607042f, -0.11358421f, 0.14216182f, -0.03875848f, -0.03270329f, 0.19460304f, 
    0.02965259f, -0.08952528f, 0.07235054f, 0.17607602f, 0.09307684f, 0.20551743f, 0.18949829f, -0.01672742f, 
    -0.00254611f, 0.04307591f, 0.04848800f, 0.08889592f, -0.09133145f, -0.11012817f, 0.01732798f, 0.16919246f, 
    -0.05088203f, -0.12468971f, -0.10293331f, -0.15668648f, 0.02017660f, -0.04803012f, -0.13395682f, 0.07019304f, 
    -0.09544366f, 0.03751996f, 0.02561000f, 0.00533641f, 0.15952817f, 0.01178988f, -0.06884530f, 0.28401786f, 
    -0.03094022f, 0.07599848f, 0.02627191f, -0.00372198f, -0.07367089f, -0.10918206f, -0.11602834f, -0.02304893f, 
    -0.07290757f, 0.05827834f, -0.03240110f, 0.06967176f, 0.09197852f, 0.14158988f, 0.16680345f, -0.07786007f, 
    -0.01976479f, 0.11232878f, 0.15561773f, -0.01190141f, 0.22604354f, 0.13518891f, -0.05450576f, -0.10662528f, 
    0.24449094f, 0.07125598f, 0.15473548f, 0.02920945f, 0.09267057f, -0.07348945f, -0.03913037f, 0.07569557f, 
    -0.02776848f, -0.03698908f, -0.19183734f, -0.07451724f, -0.03791376f, 0.04083372f, 0.02982570f, -0.02910230f, 
    0.07913253f, -0.03450568f, 0.00292462f, 0.12887666f, -0.15831463f, 0.43205655f, -0.12163150f, 0.12482099f, 
    0.03313746f, 0.09698974f, 0.04400888f, 0.00333230f, 0.06729531f, -0.12296220f, 0.02004869f, 0.00775656f, 
    -0.05675005f, -0.10000511f, -0.14325136f, 0.12609558f, 0.03314746f, 0.01266515f, 0.00689876f, -0.03438937f, 
    -0.00858215f, 0.11740627f, -0.03367738f, -0.03259338f, 0.06756381f, 0.09230066f, 0.08946265f, 0.00575223f, 
    -0.03329948f, 0.04504973f, -0.18225655f, -0.00519242f, -0.06479397f, 0.02209725f, 0.01603088f, -0.07114124f, 
    0.18370257f, -0.05448136f, 0.49744517f, 0.29050937f, -0.03676909f, -0.04821941f, -0.21156383f, 0.04262939f, 
    -0.12234218f, 0.05265437f, -0.13248754f, 0.02783460f, 0.22034796f, 0.12444828f, 0.05058723f, 0.04959518f, 
    0.07313100f, -0.09577902f, 0.07163749f, -0.02713640f, 0.08473890f, 0.04271722f, -0.02258869f, -0.08129869f, 
    0.17271142f, 0.32007512f, 0.05547255f, 0.06139812f, -0.05831656f, 0.01261006f, 0.04332660f, -0.11387851f, 
    -0.11518950f, 0.16838744f, 0.03277727f, 0.08894181f, 0.04558372f, 0.23159614f, 0.07068093f, -0.05911442f, 
    0.08981162f, 0.03748186f, -0.07661555f, -0.00309443f, 0.01309391f, -0.00699569f, 0.10146023f, 0.04229029f, 
    -0.13684367f, -0.04092610f, -0.45558029f, -0.06022261f, 0.07909890f, -0.06816614f, -0.05785093f, 0.04661595f, 
    0.01301898f, -0.07626368f, -0.05272524f, 0.14834760f, 0.02108349f, 0.06088746f, -0.12617679f, -0.10463132f, 
    -0.01232949f, 0.10520290f, -0.09905575f, -0.11036743f, 0.16495962f, 0.13767155f, 0.11272096f, -0.09888981f, 
    0.13635495f, -0.03835308f, -0.04373119f, 0.11093643f, 0.06228224f, -0.22868145f, 0.02169421f, 0.07488178f, 
    0.08883134f, -0.08802201f, 0.10638362f, -0.12389370f, 0.09847342f, 0.07855496f, 0.03424336f, 0.01015619f, 
    0.17120668f, -0.06175148f, -0.24688911f, -0.12385269f, 0.10022574f, 0.15505090f, -0.03211630f, -0.01032939f, 
    0.10310500f, -0.07356247f, 0.13612826f, 0.00701752f, -0.10523871f, 0.00496828f, 0.06715396f, 0.04051387f, 
    -0.11756509f, 0.01218158f, 0.04553438f, 0.07300631f, -0.12321651f, -0.14035299f, 0.20192786f, 0.10024100f, 
    0.08422964f, 0.09682151f, 0.02374764f, 0.08828748f, -0.05248466f, 0.05982196f, 0.01679730f, -0.00072096f, 
    0.24203327f, -0.09594028f, -0.19658630f, -0.15386043f, 0.09908029f, -0.04034698f, -0.04864487f, -0.01003375f, 
    -0.09327619f, 0.00001131f, 0.05924067f, 0.03273920f, -0.06503849f, 0.07251991f, -0.12780175f, 0.06516302f, 
    -0.12148958f, -0.00700361f, 0.15221308f, 0.00551726f, 0.01017632f, 0.00373541f, 0.00850294f, -0.12782079f, 
    -0.14573510f, -0.00418323f, -0.04589281f, 0.04588062f, 0.04613294f, 0.08535544f, 0.03695646f, 0.01390538f, 
    0.03068167f, 0.02490294f, -0.07836087f, -0.12022368f, 0.43139955f, -0.43610325f, 0.40270814f, 0.00454905f, 
    -0.07877365f, -0.01305623f, -0.07657482f, -0.00406636f, 0.23349907f, 0.00586248f, 0.01734287f, -0.05452789f, 
    0.10013800f, 0.04164202f, -0.03012565f, -0.10494033f, -0.02118884f, 0.05253924f, 0.06646734f, -0.00514906f, 
    0.12585372f, -0.02393269f, 0.04834328f, 0.05201726f, 0.13478135f, -0.05442327f, -0.01580655f, 0.03853561f, 
    -0.09338234f, -0.01820360f, 0.00269802f, 0.01244628f, -0.04398267f, 0.10774259f, 0.05834791f, -0.02221275f, 
    -0.03402518f, 0.05069850f, -0.37352115f, 0.03671899f, 0.01305011f, 0.11466576f, 0.14218581f, -0.02376127f, 
    -0.01623117f, -0.04308743f, 0.01701472f, -0.02261763f, -0.08057567f, 0.20550814f, 0.14157286f, -0.13018757f, 
    0.05866041f, -0.00229693f, 0.00299249f, 0.16865106f, -0.03567598f, -0.02732170f, -0.16259280f, 0.03146281f, 
    0.43294537f, -0.24481985f, 0.00293353f, 0.15249470f, 0.01340996f, -0.02652151f, 0.03014309f, 0.07293873f, 
    -0.00882198f, -0.03183298f, 0.00412549f, -0.04726908f, 0.07638347f, 0.09872719f, -0.04731349f, -0.08676426f, 
    0.01992306f, 0.00616176f, 0.09335364f, -0.07631877f, 0.01767688f, 0.03276431f, 0.04975347f, 0.01843202f, 
    -0.01109711f, -0.08480324f, 0.23390383f, 0.08107209f, -0.04946790f, -0.13610974f, -0.02885504f, -0.13579087f, 
    0.15306920f, 0.04539726f, 0.03856581f, -0.01665164f, -0.01609207f, -0.03457542f, 0.02436611f, -0.03507347f, 
    0.00066287f, -0.03817907f, -0.09568777f, -0.12364010f, -0.03266747f, -0.14342704f, -0.02233387f, -0.01986187f, 
    -0.22734064f, 0.05311989f, -0.01069566f, 0.11143546f, 0.20681156f, 0.01370655f, 0.04764310f, 0.04055897f, 
    0.02181432f, 0.00792820f, -0.02738049f, 0.00161958f, -0.30882776f, -0.13048409f, 0.08302760f, -0.01160571f, 
    -0.04240499f, 0.15368076f, -0.02843859f, -0.05931736f, 0.06455487f, 0.00146172f, -0.03894517f, -0.01964625f, 
    0.30117187f, 0.12298074f, -0.26533237f, -0.18383041f, -0.02346324f, 0.01157727f, -0.02892428f, -0.05279771f, 
    -0.04103773f, -0.08231510f, -0.00423626f, -0.01295463f, 0.12553838f, 0.02096367f, -0.10187082f, -0.07706926f, 
    0.03815250f, -0.02029727f, -0.07207287f, 0.04094550f, 0.11384667f, -0.06394336f, -0.01706154f, 0.05258555f, 
    -0.03091128f, 0.25586975f, 0.11615336f, -0.08358739f, -0.05829271f, 0.04033709f, -0.04359677f, 0.06805868f, 
    0.08242264f, 0.10220076f, 0.05949168f, -0.00090670f, 0.05142585f, 0.03568857f, 0.15293460f, -0.00244030f, 
    0.00179138f, -0.01403358f, 0.21112272f, 0.04686803f, -0.12177337f, -0.01755128f, 0.02275568f, -0.03454607f, 
    0.00464700f, -0.07513165f, -0.02927139f, -0.05865646f, 0.02185036f, -0.04927229f, -0.01201071f, 0.05328066f, 
    -0.00440718f, -0.00601386f, -0.00095979f, -0.03832243f, 0.06560109f, -0.06544171f, 0.01054746f, -0.01177221f, 
    0.00701202f, 0.01199956f, 0.04276993f, 0.04949559f, 0.04376923f, -0.07330525f, 0.01670221f, 0.04567145f, 
    0.02227753f, -0.02096618f, 0.00228420f, -0.01722603f, -0.05710491f, -0.07560918f, 0.03506569f, -0.07121984f, 
    0.00247509f, -0.00325036f, 0.00767639f, 0.03204370f, 0.05139750f, -0.00334812f, -0.02578908f, -0.02689950f, 
    -0.03415083f, 0.00271642f, -0.01557425f, -0.01288439f, 0.03942498f, -0.01438244f, -0.02025171f, -0.06128851f, 
    -0.01961322f, 0.00114813f, 0.06214458f, 0.02328136f, -0.04377518f, 0.03485197f, -0.03488483f, -0.01312358f, 
    -0.03805828f, -0.01953661f, 0.01473086f, -0.05840671f, 0.02599080f, -0.01710401f, -0.03146943f, -0.06799714f, 
    0.00914860f, -0.04174514f, -0.04352195f, 0.05824495f, -0.01242286f, -0.01081411f, -0.02447434f, 0.02146501f, 
    0.04690245f, -0.03872913f, -0.03318067f, -0.00851208f, 0.00993239f, -0.03442257f, -0.05946886f, 0.01834174f, 
    0.05495203f, -0.06324625f, 0.06082328f, 0.06191755f, -0.03256836f, 0.00142603f, -0.02931296f, -0.04173054f, 
    0.05482842f, -0.00835776f, -0.04589948f, -0.03864791f, -0.03020576f, -0.07430237f, 0.04884475f, -0.06340908f, 
    -0.04588591f, -0.00852415f, -0.07280635f, -0.01849736f, -0.06414671f, -0.00377560f, -0.06049430f, 0.05816689f, 
    -0.00664731f, -0.07498939f, -0.02618328f, 0.01719757f, -0.04634127f, 0.00877510f, 0.01779765f, -0.00402537f, 
    -0.00874458f, -0.00648757f, 0.02141606f, 0.00717333f, 0.03837251f, -0.00771396f, 0.06446672f, -0.05826363f, 
    -0.00480514f, 0.03033651f, -0.01846994f, 0.00157072f, -0.06586564f, -0.00447886f, -0.05111504f, -0.07072359f, 
    0.03588938f, -0.04426046f, 0.05493039f, -0.03007907f, 0.05687497f, 0.02603098f, 0.06565795f, 0.00974429f, 
    0.04540246f, 0.06331795f, -0.05425557f, 0.01776215f, 0.03324652f, -0.01102764f, -0.07085301f, -0.02281024f, 
    -0.00025932f, -0.03799767f, 0.06067446f, 0.05747160f, -0.00199047f, -0.05454537f, 0.00572163f, -0.01370281f, 
    -0.03344172f, -0.01723505f, -0.01721847f, -0.05545095f, -0.02833918f, -0.05322064f, -0.04541896f, 0.00400556f, 
    0.02866926f, -0.04582354f, 0.00115282f, 0.04983185f, -0.03679338f, 0.04367764f, -0.02271784f, -0.06799333f, 
    -0.01676751f, -0.01475799f, 0.02550140f, -0.01866897f, 0.05704024f, -0.03962207f, -0.02160926f, -0.05463353f, 
    0.04294472f, -0.04601428f, 0.05656600f, -0.05274257f, 0.01455221f, 0.03004725f, -0.02329353f, -0.05291692f, 
    0.00982408f, 0.01490892f, -0.02055723f, -0.03623673f, 0.00323464f, -0.02379600f, -0.04378802f, -0.07612740f, 
    0.03248857f, -0.00249401f, -0.04381758f, 0.01571344f, -0.01069178f, -0.03557124f, 0.04003555f, 0.01495807f, 
    0.04726760f, -0.03789717f, -0.04705092f, -0.06292245f, -0.05237871f, -0.06381756f, 0.05634661f, 0.03304926f, 
    -0.00235635f, -0.01730409f, 0.03242306f, 0.06492808f, 0.06555837f, -0.04800750f, 0.00371024f, -0.07232656f, 
    0.06148606f, 0.01797235f, -0.02466312f, 0.05101101f, 0.00144285f, -0.07199065f, 0.01681195f, -0.07030005f, 
    0.01838154f, 0.04954499f, 0.01959660f, 0.05426838f, -0.01516969f, 0.04401529f, -0.05830391f, 0.03741241f, 
    -0.00941962f, 0.05659119f, 0.00045784f, -0.06346303f, -0.02690597f, 0.00229508f, -0.04548179f, -0.03003759f, 
    0.01958163f, -0.05148128f, -0.03354030f, -0.05194547f, -0.07276181f, -0.00496384f, -0.04907019f, 0.03890215f, 
    0.00432836f, -0.01315159f, -0.01095923f, -0.04690608f, -0.02477481f, -0.05946489f, 0.02182489f, 0.05295502f, 
    0.04970764f, -0.06563531f, -0.04327089f, -0.05689586f, 0.05976312f, -0.03449745f, -0.07259794f, 0.02080343f, 
    -0.06214335f, -0.07308719f, -0.04103116f, 0.04159966f, 0.06499325f, -0.02234142f, 0.06234637f, 0.06115856f, 
    0.02257591f, 0.05396612f, 0.02557371f, -0.02794353f, -0.02118401f, -0.00852400f, 0.01590681f, -0.01997562f, 
    0.05741798f, -0.06112447f, -0.00989463f, -0.05096951f, -0.04645452f, -0.04216150f, -0.01204163f, -0.07782833f, 
    -0.07745124f, -0.05161098f, -0.00491112f, 0.01161991f, -0.02963616f, -0.04252240f, -0.06724285f, -0.04981697f, 
    0.00315805f, 0.03248431f, -0.05745554f, -0.02139086f, -0.00024412f, -0.02294916f, -0.06437725f, 0.02782818f, 
    -0.00417812f, 0.02607163f, -0.06962980f, 0.00820063f, 0.05241766f, -0.03980662f, -0.05628193f, -0.03446185f, 
    0.02529138f, 0.04053700f, 0.06466306f, -0.05663069f, -0.03789232f, 0.05569271f, 0.06418904f, 0.04291452f, 
    0.06038004f, -0.00600917f, -0.01375704f, -0.05453832f, -0.04177216f, 0.05934631f, -0.05681343f, 0.03665255f, 
    -0.05069269f, 0.02157904f, -0.03793972f, 0.04984219f, -0.06663474f, -0.01685662f, -0.02114470f, -0.07410897f, 
    -0.02154240f, 0.02959831f, 0.00267152f, 0.00193921f, -0.02815523f, -0.02440322f, 0.04159274f, -0.07104855f, 
    -0.01574756f, -0.04038730f, 0.00854316f, -0.02070243f, 0.01470320f, -0.00652146f, -0.02924889f, -0.02512705f, 
    -0.06847172f, 0.03797451f, -0.05748341f, -0.06378566f, 0.03242338f, -0.00199287f, -0.03747132f, 0.04927456f, 
    -0.05449247f, 0.01069417f, -0.05944254f, -0.00134410f, 0.00732765f, 0.03784556f, 0.04727261f, -0.07184438f, 
    0.04566977f, 0.00165501f, 0.01210480f, -0.07160188f, -0.02384945f, -0.02976772f, 0.04670799f, 0.03299310f, 
    -0.03977561f, -0.00853362f, -0.07143472f, -0.04845750f, 0.02295230f, -0.03784773f, -0.04863120f, -0.04884635f, 
    0.04125036f, 0.17283851f, 0.14940181f, -0.00480353f, 0.05384497f, -0.08969394f, -0.04831985f, -0.01746639f, 
    -0.04456897f, -0.04602742f, -0.00681668f, 0.13329239f, -0.29669598f, 0.11412013f, 0.12074025f, 0.26278466f, 
    -0.01727009f, 0.15460871f, -0.34207389f, 0.12462540f, 0.09632733f, 0.15132315f, -0.06140780f, -0.04317519f, 
    -0.23804180f, 0.10278307f, 0.19480503f, -0.00968511f, 0.01535899f, -0.11977533f, -0.03506489f, 0.24076423f, 
    -0.02267226f, -0.15354967f, -0.00074433f, 0.01567657f, -0.05211363f, -0.16709307f, -0.17994016f, -0.16396634f, 
    0.11426931f, 0.00583391f, -0.14107530f, -0.31916776f, 0.15609522f, -0.06895487f, 0.08571244f, -0.09571796f, 
    0.17686634f, 0.08561697f, -0.07329448f, 0.10174249f, 0.01220686f, 0.01074280f, -0.03251650f, -0.06804806f, 
    0.06827601f, 0.24052572f, 0.05885771f, -0.02811050f, 0.08360455f, -0.13069141f, -0.05627881f, 0.08808807f, 
    -0.03582865f, -0.26692495f, -0.06612475f, 0.01413090f, 0.07668275f, 0.01463998f, 0.18383990f, 0.09157964f, 
    -0.14038086f, 0.24475420f, 0.27574733f, 0.07036839f, 0.07975598f, 0.03706951f, -0.08546518f, -0.05886512f, 
    0.14856748f, -0.06336354f, 0.09693303f, -0.06394024f, 0.04760962f, -0.22091600f, -0.23133181f, 0.05333181f, 
    0.08661157f, 0.10580506f, -0.07284013f, 0.02449742f, 0.01154214f, -0.05262692f, 0.00513950f, 0.02215167f, 
    -0.35637954f, 0.28640056f, -0.08475725f, 0.05533227f, 0.20144728f, 0.09453833f, -0.05186517f, 0.10815900f, 
    0.05787992f, 0.09523486f, 0.07912343f, -0.05163293f, -0.14770916f, -0.03779854f, -0.11637415f, -0.31449983f, 
    0.08350770f, -0.06103550f, 0.03450248f, 0.15583816f, 0.07309277f, -0.02693279f, -0.18533109f, 0.03115953f, 
    0.21793889f, -0.04925241f, -0.01208341f, 0.06570914f, -0.15830025f, 0.11186177f, 0.06108495f, -0.18484901f, 
    0.00628295f, 0.07664439f, -0.04919983f, -0.06767227f, -0.20542987f, -0.06436464f, 0.08863675f, 0.20022117f, 
    -0.18691820f, -0.20031382f, -0.09776273f, -0.22563736f, 0.06484797f, 0.09087370f, -0.07419635f, -0.11522171f, 
    -0.20229371f, 0.08450308f, 0.13339970f, 0.07888082f, 0.01061261f, 0.08279600f, 0.00588806f, 0.08137280f, 
    -0.14659539f, -0.10563212f, -0.03085428f, -0.21524595f, 0.01922598f, 0.25681192f, 0.36405674f, 0.15054214f, 
    0.05297118f, -0.21715690f, 0.13793065f, 0.09889261f, 0.09613630f, -0.01596407f, -0.00669845f, 0.00094097f, 
    -0.16635318f, -0.30926317f, 0.02660036f, -0.08815969f, -0.05893437f, 0.00000617f, -0.04985273f, -0.09550998f, 
    -0.05103872f, 0.07066432f, 0.01410263f, 0.11097658f, -0.16580117f, 0.04770385f, 0.25787175f, 0.19645873f, 
    0.13497610f, -0.02600137f, -0.19236504f, 0.10205116f, 0.13729429f, -0.16853142f, -0.02885731f, -0.06475454f, 
    0.04909310f, 0.10947915f, 0.19059682f, 0.01642472f, -0.03879709f, 0.08947185f, 0.11451478f, 0.09221047f, 
    0.04602785f, 0.03535511f, 0.09457346f, 0.06544495f, 0.16013677f, -0.14899409f, 0.27158526f, -0.13550439f, 
    -0.14120266f, 0.04963083f, 0.06421193f, 0.15278149f, 0.20709984f, 0.12904344f, 0.20636505f, -0.00201382f, 
    0.30733451f, 0.07972412f, -0.10228278f, 0.09378114f, 0.10100059f, 0.06726131f, 0.03716959f, 0.06272449f, 
    -0.01349579f, -0.02467442f, -0.08403147f, -0.16343534f, 0.01786147f, -0.21770397f, -0.32400167f, -0.34175047f, 
    -0.08715912f, -0.17260064f, 0.01292278f, 0.03660445f, -0.10281044f, 0.04914803f, 0.11751716f, 0.00298156f, 
    -0.27594921f, -0.21743403f, -0.51981550f, 0.02151614f, -0.23792900f, -0.22472884f, 0.07720234f, -0.08256605f, 
    -0.05451974f, 0.10220957f, 0.00870047f, 0.00553291f, 0.09579196f, 0.36322293f, 0.18585591f, -0.04909992f, 
    0.11320125f, 0.14762579f, 0.20491600f, 0.12630200f, 0.03664134f, -0.03271332f, -0.09972635f, -0.19483037f, 
    -0.05285848f, -0.26935023f, -0.24215028f, 0.12554660f, -0.11451542f, -0.02484693f, 0.01562297f, -0.05716712f, 
    -0.05689120f, -0.18304619f, -0.08034054f, -0.06440375f, -0.20182945f, -0.07553530f, -0.10800965f, -0.16794924f, 
    -0.08830057f, -0.08451778f, 0.02600669f, -0.16557895f, -0.27536434f, -0.03591891f, -0.16797633f, -0.21101269f, 
    -0.19288328f, 0.30256891f, -0.00786612f, 0.04082398f, 0.11999702f, 0.00584008f, -0.03771833f, -0.01008782f, 
    0.03754733f, 0.05277050f, 0.04392818f, -0.07204935f, -0.15378466f, -0.12544252f, -0.18599822f, -0.23969503f, 
    0.00134503f, 0.10730641f, -0.19587202f, -0.20356256f, 0.00412272f, -0.14961299f, 0.08321366f, 0.16196212f, 
    -0.30481356f, 0.09459446f, 0.03120417f, -0.04769327f, 0.00815712f, 0.18233936f, 0.06785472f, 0.16975138f, 
    0.23678973f, 0.12113329f, -0.07503694f, 0.06044350f, -0.33261207f, 0.00238298f, 0.37345368f, 0.02850531f, 
    -0.00992299f, 0.21877101f, 0.03803466f, 0.09792299f, 0.16444573f, -0.10794435f, 0.08148100f, 0.00122892f, 
    0.30266318f, 0.14781268f, 0.03364108f, -0.11405214f, -0.12265076f, -0.05558601f, -0.04703171f, 0.07868616f, 
    -0.00084814f, 0.12843528f, 0.03946902f, 0.00223629f, 0.00146408f, -0.02694323f, 0.07130586f, 0.12250821f, 
    0.09724137f, 0.03413141f, -0.14311580f, 0.11101533f, -0.09155320f, -0.20381527f, -0.10581248f, -0.06535349f, 
    0.17072736f, 0.27120852f, 0.05000675f, -0.16870657f, 0.11648639f, 0.07327407f, -0.02594589f, 0.02077017f, 
    0.00947258f, 0.16252521f, -0.00661686f, 0.02058752f, 0.08201192f, 0.11971130f, 0.24981923f, 0.11053293f, 
    0.10237373f, -0.03802942f, 0.20301305f, 0.04989142f, -0.10996163f, -0.01187142f, 0.05437336f, 0.13819186f, 
    -0.04711782f, -0.01586876f, 0.00808545f, 0.10682257f, -0.00640269f, 0.15881963f, 0.03598712f, 0.18113181f, 
    0.00315698f, -0.03250009f, 0.14452687f, -0.09196001f, 0.32369429f, -0.33102396f, 0.37207529f, 0.01377345f, 
    -0.18808685f, 0.21968415f, -0.05356058f, 0.02825001f, 0.18950573f, 0.03096902f, 0.22639416f, 0.08760871f, 
    0.08177622f, -0.07796177f, 0.18781342f, 0.01809667f, -0.02552331f, 0.05486914f, -0.01558501f, 0.04075373f, 
    0.17536114f, -0.00217393f, 0.00771896f, -0.04565938f, 0.00744035f, 0.00664119f, 0.07872435f, -0.16161998f, 
    -0.09780611f, -0.04372454f, -0.11721642f, -0.01009399f, 0.00850293f, 0.10113658f, 0.15112984f, 0.08841493f, 
    -0.36141148f, 0.33027402f, -0.41394007f, -0.00604048f, -0.05325796f, -0.18480232f, 0.17388582f, -0.10533539f, 
    -0.03927872f, 0.07759582f, -0.00142270f, -0.12740286f, -0.27596903f, -0.07653432f, -0.11694649f, 0.11175781f, 
    -0.06016586f, 0.09061264f, 0.10100901f, 0.23917039f, 0.06006302f, 0.07415380f, -0.19478877f, -0.05211635f, 
    0.40255579f, -0.08354275f, 0.01904347f, -0.16165990f, -0.01307462f, -0.08339619f, 0.03885444f, -0.04603149f, 
    0.05951855f, -0.07938121f, -0.02783149f, 0.11713947f, -0.02428104f, 0.15247576f, 0.02426204f, -0.14306261f, 
    -0.05462888f, -0.03509649f, -0.00996715f, -0.00785301f, 0.06967916f, -0.02726793f, -0.06771472f, 0.00150041f, 
    0.11063869f, 0.32944611f, 0.12296726f, 0.05852313f, -0.09388041f, -0.03148469f, 0.05043779f, 0.00697652f, 
    0.03135467f, -0.09091299f, 0.07741783f, 0.02948551f, -0.03129547f, -0.00107334f, -0.04484166f, -0.09739825f, 
    0.01410777f, 0.10921691f, -0.04507526f, -0.06911983f, -0.05633973f, 0.05679876f, 0.16919141f, 0.01370324f, 
    -0.04503971f, 0.24087912f, -0.19258328f, -0.05875902f, -0.10340814f, 0.12605448f, 0.15131135f, 0.05259786f, 
    0.02326862f, 0.13203946f, 0.00863636f, -0.09229168f, 0.10958380f, -0.18217084f, -0.11989228f, 0.02843597f, 
    0.12356937f, 0.17837745f, 0.08972886f, 0.00230537f, 0.08886553f, -0.00330247f, -0.03683729f, -0.10195036f, 
    -0.10939878f, -0.04250327f, -0.09944263f, -0.15126552f, -0.12689205f, -0.08535198f, 0.02883076f, 0.03467898f, 
    -0.06755621f, -0.12090559f, 0.10796116f, 0.08223002f, 0.02175885f, 0.03972796f, 0.04700676f, -0.07052328f, 
    0.06313619f, 0.01424577f, -0.03957504f, 0.18258151f, 0.13115016f, -0.03541359f, -0.03530251f, -0.04609719f, 
    0.36599326f, 0.34833553f, 0.01135805f, -0.04649007f, -0.08921362f, -0.04838620f, -0.05644965f, 0.02422974f, 
    0.03508835f, 0.11127983f, 0.04146633f, -0.09563103f, -0.06715567f, -0.13661960f, 0.01587260f, 0.08141039f, 
    0.00792312f, -0.01616558f, 0.12008378f, 0.16406073f, -0.14731362f, -0.04001425f, 0.06689746f, 0.17256397f, 
    -0.06328007f, 0.08788417f, -0.09005179f, -0.05905979f, 0.16127168f, 0.03234505f, -0.07373651f, 0.05995246f, 
    -0.16357785f, 0.02933259f, -0.18475397f, -0.04950104f, -0.07866215f, 0.47573170f, -0.06295296f, -0.21560413f, 
    -0.06781000f, -0.07571561f, 0.03283606f, -0.03951264f, -0.02970410f, -0.10758145f, -0.09989958f, 0.05894531f, 
    0.19369063f, 0.11493953f, -0.29545417f, 0.04537255f, 0.21103041f, -0.05038080f, 0.17612141f, 0.26766428f, 
    0.02212875f, 0.11111701f, 0.03584047f, 0.04813806f, 0.02002330f, 0.03393251f, -0.08744603f, 0.19621024f, 
    0.19279842f, -0.05385263f, 0.01930416f, -0.13473096f, -0.09116479f, -0.22786078f, -0.10268801f, -0.24619113f, 
    0.10459800f, -0.07578184f, 0.12708727f, 0.03615021f, 0.06684306f, 0.03578047f, -0.08854252f, -0.10800657f, 
    0.06291195f, -0.17256711f, -0.04568877f, -0.14236315f, 0.38411981f, 0.12348085f, -0.06605588f, -0.01156798f, 
    0.01519527f, 0.12670751f, 0.13797070f, -0.00424235f, -0.03509982f, -0.05151222f, 0.17400214f, 0.19008078f, 
    -0.29635009f, 0.29310843f, 0.22787099f, 0.26563132f, 0.06000371f, -0.04199786f, -0.01142648f, -0.11985844f, 
    0.05464895f, -0.09386232f, 0.14892361f, -0.03089737f, 0.03571752f, -0.14776136f, 0.09372400f, 0.11302105f, 
    0.08776876f, -0.12686013f, -0.17165360f, 0.05951117f, -0.03006290f, -0.00173173f, -0.12020604f, 0.02045474f, 
    0.11350667f, 0.23253559f, -0.17177422f, -0.49853814f, 0.29657599f, 0.09941334f, -0.04582735f, -0.05004847f, 
    0.02444091f, 0.07454450f, -0.00484971f, -0.25733539f, 0.00842437f, 0.07856863f, 0.08492238f, 0.02708857f, 
    -0.04628710f, -0.13030748f, 0.04161179f, -0.35149312f, 0.25000784f, -0.01286917f, -0.06129899f, 0.02582558f, 
    0.01688910f, 0.09922234f, 0.33315739f, -0.06681465f, -0.17414092f, 0.18974966f, 0.00871061f, -0.20454241f, 
    -0.16311423f, -0.10093913f, -0.14292242f, -0.11472660f, -0.02367903f, 0.20014101f, 0.14838415f, -0.07365368f, 
    -0.15236531f, 0.04068909f, 0.08774740f, -0.10005172f, 0.00087100f, 0.12036155f, -0.00282498f, -0.21697459f, 
    0.16351220f, 0.10664828f, 0.03486639f, 0.20842451f, 0.08849578f, -0.03974888f, -0.06515109f, 0.27613267f, 
    -0.10186905f, 0.06923957f, -0.04551904f, -0.07996198f, 0.03595406f, 0.21730684f, 0.10193843f, 0.21835825f, 
    0.04138956f, -0.09231611f, 0.12171563f, 0.05784326f, -0.03607454f, -0.05415277f, 0.07177281f, 0.06242469f, 
    -0.06747360f, -0.30667818f, 0.04214449f, -0.22158721f, 0.14538266f, 0.05898013f, -0.07093735f, -0.10929497f, 
    0.13584204f, 0.10247944f, -0.01208521f, 0.02580287f, 0.10671964f, 0.21577555f, 0.06726588f, -0.05686911f, 
    0.25012982f, 0.12190960f, -0.03027947f, -0.08493344f, -0.06527542f, -0.24629462f, -0.16952187f, -0.19792442f, 
    -0.03078151f, 0.09469680f, 0.06152776f, 0.05523204f, 0.01471656f, 0.12263954f, 0.12664372f, 0.14917290f, 
    0.00791309f, -0.05230569f, 0.03473411f, -0.12633187f, 0.14972486f, -0.32238707f, 0.28972900f, 0.24041462f, 
    -0.25486732f, 0.10294174f, -0.08304530f, 0.04000686f, 0.27875665f, 0.05871622f, 0.07823095f, 0.11486416f, 
    0.04750790f, -0.04918614f, 0.09604618f, -0.10698695f, -0.04877940f, 0.18594220f, -0.16390178f, 0.17419507f, 
    0.07987781f, -0.05319099f, -0.05472777f, -0.05161330f, -0.04892433f, -0.08227841f, 0.05433727f, -0.04773305f, 
    -0.02838165f, -0.01642550f, 0.10201994f, -0.14305054f, 0.07758652f, 0.01650478f, 0.00105661f, 0.19509329f, 
    -0.04242292f, 0.28204596f, -0.25340363f, 0.21261232f, 0.03763462f, 0.12202943f, 0.32240307f, -0.07766321f, 
    -0.12425613f, -0.06563697f, -0.01749524f, -0.18021947f, -0.14980495f, 0.04663073f, -0.07151787f, -0.04986293f, 
    -0.02082919f, 0.03640130f, -0.04282349f, 0.13217019f, -0.09797665f, 0.04344461f, -0.13849872f, 0.15882793f, 
    0.28743473f, -0.32505602f, 0.07581447f, -0.06441834f, -0.16509354f, -0.02234754f, 0.00854154f, 0.09712747f, 
    -0.06600142f, -0.07145711f, 0.07292423f, 0.20219412f, -0.16779318f, 0.04027026f, -0.04511036f, -0.03800166f, 
    -0.05946250f, 0.02990798f, 0.06215969f, -0.20341019f, 0.01453765f, -0.12377008f, -0.04388293f, 0.01296098f, 
    0.05116580f, 0.03063035f, 0.25350541f, 0.10217425f, -0.04931734f, -0.10056708f, 0.00862917f, -0.05571632f, 
    0.08304622f, -0.00621793f, 0.03390988f, 0.00772402f, -0.03307364f, -0.14014168f, 0.06327345f, -0.00236132f, 
    0.08555149f, 0.00212664f, 0.02137027f, -0.01253290f, 0.07183946f, 0.12831114f, 0.13338700f, 0.14652497f, 
    -0.07328784f, 0.10496090f, -0.10678815f, 0.01869684f, 0.12545933f, -0.16390818f, 0.00347154f, 0.03082668f, 
    0.16005963f, 0.09346762f, 0.02606004f, 0.17821094f, -0.01991139f, -0.06332737f, -0.12659310f, -0.04938787f, 
    0.09418856f, -0.06067418f, 0.10930044f, -0.08667604f, 0.01370737f, -0.06146400f, 0.11402948f, 0.12094395f, 
    0.08689170f, 0.02530889f, -0.10599069f, -0.10969578f, -0.04510772f, -0.03560624f, -0.06671949f, -0.05092119f, 
    -0.05441162f, -0.10210261f, -0.11994616f, -0.07835671f, 0.06222750f, 0.18477207f, -0.04534736f, -0.05354048f, 
    0.04042323f, 0.11353237f, -0.02875300f, 0.14600235f, 0.09539817f, -0.01952090f, 0.06006742f, -0.02611798f, 
    -0.14631088f, 0.18041524f, 0.07496783f, 0.13377908f, -0.08576125f, -0.03716322f, 0.11854549f, -0.01899005f, 
    0.06096154f, 0.09609774f, -0.00875979f, 0.03328448f, 0.06230068f, -0.03924935f, -0.01070692f, -0.02724540f, 
    0.04847163f, -0.02027209f, 0.09156004f, 0.13224694f, -0.05231533f, -0.03911132f, 0.00761154f, 0.11102124f, 
    -0.00747117f, 0.00444070f, -0.03655193f, 0.00443043f, -0.06891928f, -0.03816010f, 0.20547727f, 0.21615998f, 
    0.03002843f, -0.01008535f, -0.05874372f, -0.01533464f, -0.06614378f, -0.03074382f, 0.05938478f, -0.14726281f, 
    0.04726267f, -0.06786093f, 0.00934361f, -0.02311278f, -0.18270373f, 0.00750321f, -0.01872832f, -0.03405114f, 
    0.00373449f, 0.21264805f, -0.08408026f, 0.02713153f, 0.07206696f, -0.03428597f, 0.01178983f, -0.10810472f, 
    0.02437066f, 0.10593506f, 0.08611704f, 0.13971342f, -0.13281578f, -0.19128919f, -0.03910746f, -0.06894346f, 
    0.08022244f, 0.05082581f, 0.05519230f, 0.14523554f, -0.04033737f, -0.05986460f, 0.01630700f, 0.00584410f, 
    -0.60137331f, -0.50209630f, -0.22468288f, -0.12429176f, 0.22985135f, 0.06739993f, 0.22201690f, 0.00564825f, 
    -0.04542575f, 0.05327005f, -0.02001776f, 0.08079506f, 0.19983503f, 0.06854637f, 0.25046632f, -0.02405976f, 
    -0.04542100f, 0.06986134f, -0.09172332f, -0.21325171f, -0.04159192f, -0.06793866f, -0.13868396f, -0.14030735f, 
    0.11412448f, -0.00997099f, -0.04055432f, 0.08219821f, 0.09252719f, -0.02576156f, -0.00313625f, -0.02594964f, 
    -0.03319183f, 0.09008106f, -0.02991939f, 0.00088932f, -0.11993123f, 0.09065152f, 0.01788144f, 0.10617750f, 
    0.09238745f, -0.00453160f, 0.04075883f, 0.09564707f, -0.09766900f, -0.11974405f, -0.03527328f, 0.15538102f, 
    0.11223324f, 0.07087833f, 0.20895681f, 0.33274037f, 0.05440855f, 0.09866677f, -0.00082304f, 0.15079457f, 
    0.04716406f, -0.16709068f, 0.21697171f, 0.08447497f, -0.02389448f, -0.04853171f, 0.07863574f, 0.01677405f, 
    -0.09797982f, 0.01370696f, 0.03671248f, 0.07893952f, 0.13257936f, 0.00570242f, 0.04729562f, -0.00744713f, 
    -0.10464977f, -0.11487394f, -0.10441008f, 0.02548186f, -0.08903579f, 0.06869482f, -0.04768405f, 0.12146398f, 
    -0.04178412f, -0.01040677f, -0.06504326f, -0.11594135f, -0.09831915f, -0.30983573f, 0.11262437f, -0.03507262f, 
    0.28156561f, 0.15718921f, 0.00637262f, 0.02057416f, -0.01418966f, 0.02840476f, -0.09582330f, -0.06479821f, 
    0.15519358f, -0.12014712f, -0.35503057f, -0.12212790f, -0.15181594f, -0.07790948f, -0.00920564f, -0.22156826f, 
    0.02702071f, 0.03248510f, -0.04858928f, 0.00821247f, -0.06393334f, -0.03000936f, -0.22476710f, 0.01744496f, 
    -0.12890324f, -0.08232694f, -0.19445463f, -0.07999121f, -0.08022616f, 0.08000570f, -0.08044555f, 0.25226396f, 
    0.15464187f, 0.13525079f, 0.40458706f, 0.19809289f, 0.01479923f, 0.09766624f, 0.01369775f, 0.05998852f, 
    -0.06572049f, 0.15007266f, 0.10681024f, 0.21760304f, 0.06885806f, 0.09377386f, -0.10294698f, -0.12917487f, 
    0.04460838f, -0.03285256f, 0.12064900f, -0.10708902f, -0.13068897f, -0.03353977f, -0.13099605f, -0.05902819f, 
    0.10076087f, -0.09944213f, 0.07617985f, 0.16892515f, 0.04122055f, 0.15468563f, -0.08826861f, -0.00770970f, 
    0.11015962f, 0.06310020f, 0.24144232f, 0.16885109f, 0.18555079f, 0.01141526f, 0.40995941f, -0.00600553f, 
    -0.08746347f, 0.00612348f, -0.07826491f, -0.00195920f, 0.20586418f, 0.03524167f, 0.09388915f, 0.05990747f, 
    -0.16301431f, -0.12012421f, 0.17256704f, 0.14283060f, -0.07894094f, 0.07185700f, -0.01724565f, 0.04539533f, 
    0.11415058f, -0.09540164f, -0.20148161f, -0.01205528f, -0.07281299f, -0.13922115f, 0.06107469f, -0.08857746f, 
    -0.21618620f, 0.02739159f, -0.17654292f, -0.03065544f, 0.02504328f, 0.16730930f, 0.09287800f, 0.08547079f, 
    -0.07538335f, 0.34138420f, -0.04970396f, -0.12967350f, -0.04382453f, -0.17392096f, -0.01888012f, -0.06695188f, 
    -0.07418339f, 0.01956884f, -0.02670146f, 0.01103336f, -0.16285937f, 0.05050686f, 0.03183633f, 0.22141527f, 
    -0.02032417f, -0.05088082f, -0.03299073f, 0.23828362f, 0.15723568f, 0.07913501f, -0.13669211f, -0.07363462f, 
    0.41126558f, 0.28578833f, -0.11267686f, -0.23503695f, -0.06072518f, -0.04514837f, 0.08885808f, -0.11828075f, 
    0.08441373f, 0.04258173f, -0.11829473f, 0.14657909f, -0.05733340f, 0.03378061f, -0.06890075f, -0.04375056f, 
    -0.12612326f, -0.06148733f, 0.03472291f, -0.08315556f, 0.04797109f, 0.06285005f, 0.06696653f, -0.03230710f, 
    -0.10186657f, 0.00494010f, -0.09630539f, -0.19758780f, -0.14689115f, -0.03524657f, -0.00472273f, -0.07126954f, 
    -0.06598788f, 0.05296049f, -0.03755126f, 0.11494902f, -0.10071523f, 0.05340831f, -0.05533649f, -0.14864774f, 
    -0.00468754f, 0.08434138f, -0.11219167f, -0.07061683f, -0.01196838f, 0.10046408f, 0.21210395f, -0.02076765f, 
    0.01819725f, -0.04167450f, -0.28995469f, -0.14194016f, -0.06278878f, -0.13880679f, 0.01345929f, 0.02479106f, 
    0.08392539f, 0.04493881f, 0.14503904f, 0.22615704f, 0.09503044f, -0.08247422f, -0.04291271f, -0.11294895f, 
    0.03181062f, -0.14475395f, 0.00078873f, 0.00047834f, 0.01699021f, 0.05151528f, 0.06668004f, 0.17738421f, 
    -0.18844420f, -0.00605752f, 0.13761730f, 0.16144082f, -0.00433532f, 0.16544181f, 0.03640801f, 0.08210172f, 
    0.00683707f, -0.19014332f, -0.02528360f, 0.05433492f, 0.01534501f, -0.08467057f, -0.06053672f, 0.02808569f, 
    0.14133796f, 0.10887432f, -0.11643112f, 0.10290278f, -0.07058384f, -0.04178184f, -0.15932520f, -0.04394216f, 
    0.14862248f, 0.02370082f, -0.32699674f, 0.10394324f, -0.01013600f, 0.17975041f, 0.14168645f, 0.09860685f, 
    -0.06994890f, 0.00356071f, -0.01171074f, -0.00819738f, -0.13148117f, -0.15248394f, 0.09726129f, 0.30664316f, 
    -0.08893057f, 0.15287256f, 0.05446163f, 0.29015955f, 0.02780448f, 0.06616646f, 0.09663855f, 0.23022535f, 
    -0.06416709f, 0.00373533f, -0.01000902f, -0.01233705f, 0.10178898f, 0.07422411f, 0.10196123f, 0.22311120f, 
    0.01736939f, 0.04977109f, 0.04038398f, 0.03156786f, 0.04337579f, -0.14039542f, 0.23884912f, 0.24299917f, 
    0.25734508f, 0.04097943f, 0.02943550f, 0.11209937f, 0.01948475f, 0.11103195f, -0.06288888f, 0.00150116f, 
    -0.20021446f, 0.01457105f, 0.33743250f, -0.03822740f, -0.04957415f, -0.15795873f, 0.15183312f, 0.06455277f, 
    0.24399783f, -0.02714442f, 0.22051515f, 0.08324244f, 0.12631939f, 0.03008330f, 0.02455765f, -0.04086834f, 
    0.04410835f, 0.06597104f, -0.00657383f, -0.12025294f, 0.01698525f, -0.10204680f, -0.02335722f, -0.00254931f, 
    0.15987250f, 0.23680332f, -0.14029662f, 0.00544474f, 0.13280573f, 0.01079439f, 0.25290152f, 0.01072373f, 
    0.04549313f, -0.02447374f, -0.04233956f, -0.00217595f, -0.31786206f, -0.17922091f, -0.05713721f, 0.03048971f, 
    -0.09539088f, -0.02971084f, -0.00047153f, 0.04941931f, 0.09527728f, 0.12018146f, 0.13374226f, 0.00084111f, 
    0.10566910f, -0.08051874f, 0.30773667f, -0.15748979f, 0.03603791f, -0.06376420f, 0.02520739f, 0.02600738f, 
    0.07091554f, -0.04364364f, 0.04587527f, -0.27238512f, 0.28249747f, 0.19477817f, -0.00033378f, 0.07861839f, 
    0.01186372f, 0.06120277f, 0.05477038f, -0.02134009f, 0.13264896f, -0.01693283f, 0.03139531f, 0.13344377f, 
    0.21858941f, -0.00684787f, 0.08030218f, 0.07604227f, -0.02798022f, -0.11791684f, -0.19924270f, -0.05742761f, 
    0.16979709f, 0.24543177f, 0.14042455f, 0.03523468f, -0.04486193f, -0.05101462f, 0.01097010f, -0.11169261f, 
    0.10048392f, -0.08071619f, 0.02536802f, -0.08480684f, -0.12273522f, 0.05453977f, -0.00737830f, -0.09215087f, 
    0.13654515f, 0.00971596f, -0.14045411f, 0.19456185f, 0.09954863f, 0.11498895f, 0.04185971f, -0.05512599f, 
    -0.12090586f, 0.12849449f, -0.14141355f, 0.04641547f, 0.12225346f, -0.32378265f, -0.26993352f, 0.23055045f, 
    0.11205651f, 0.08662384f, 0.01185882f, 0.00030373f, -0.10779960f, 0.01102108f, 0.09217524f, -0.09700667f, 
    -0.38116202f, 0.02119937f, 0.00224488f, -0.02814589f, 0.14935490f, 0.10844458f, 0.07818783f, -0.06259669f, 
    0.04631622f, -0.05497715f, 0.07157549f, 0.04440042f, 0.04962481f, 0.11582454f, 0.21757379f, -0.13462259f, 
    0.16054569f, 0.06738026f, 0.19991529f, 0.02772352f, 0.09689201f, 0.07286012f, 0.09641809f, -0.02150292f, 
    0.27584517f, 0.03754132f, 0.02576707f, 0.09178153f, -0.08229852f, -0.02344157f, -0.11457641f, 0.03966859f, 
    0.15160887f, 0.09314384f, 0.10736798f, 0.16377743f, -0.14903055f, -0.42221174f, 0.07993869f, 0.06611712f, 
    -0.02734664f, 0.01434842f, -0.08419476f, 0.24410906f, -0.01682925f, 0.00539875f, 0.02570646f, 0.07893141f, 
    0.00619359f, -0.02000774f, 0.02066729f, 0.01552223f, -0.07106884f, 0.00755506f, -0.06423411f, -0.07209626f, 
    0.05907733f, 0.01162125f, -0.00224161f, -0.02084051f, -0.03236884f, -0.00332964f, -0.04872869f, -0.01100572f, 
    -0.03580271f, 0.05075542f, -0.04388368f, 0.00493429f, 0.06143264f, -0.00767468f, -0.05380090f, 0.04821809f, 
    0.01946172f, -0.03474209f, 0.04309506f, -0.00007794f, 0.03840901f, 0.01220546f, -0.05489598f, -0.02187922f, 
    -0.04744235f, 0.01050451f, -0.01421699f, 0.03248255f, -0.00927971f, 0.00506281f, 0.04488935f, -0.07413258f, 
    -0.05812067f, -0.00805468f, -0.05911303f, 0.00751063f, -0.06417783f, -0.03980039f, -0.03385001f, -0.06560818f, 
    0.05995723f, 0.06049685f, -0.00765770f, -0.07291134f, -0.02197919f, -0.06876376f, 0.01064487f, 0.03907350f, 
    -0.06798600f, 0.03241460f, -0.01647198f, -0.01652172f, -0.02947833f, 0.00743724f, -0.03652681f, -0.07077468f, 
    0.05155423f, 0.01760422f, -0.06173132f, 0.00511671f, 0.04220776f, -0.06435566f, 0.02336059f, -0.02697926f, 
    0.05266324f, -0.07449038f, 0.04228245f, -0.00345416f, -0.05390092f, -0.07279605f, -0.07466795f, -0.03374825f, 
    0.01965045f, -0.06324957f, -0.07215748f, -0.01174550f, -0.03186022f, -0.02421337f, -0.07676354f, 0.05409124f, 
    -0.04740617f, -0.06600164f, -0.02151068f, -0.02174396f, 0.06208755f, -0.02796199f, -0.07653055f, -0.07344294f, 
    0.03370469f, -0.07154852f, 0.02767854f, 0.00675093f, 0.03170339f, 0.03717683f, 0.04676392f, 0.05345480f, 
    -0.07430441f, 0.01285475f, 0.01973364f, -0.04345896f, 0.02563482f, -0.05906572f, -0.06081452f, 0.06987233f, 
    -0.05650120f, -0.02399993f, -0.06780975f, -0.04445392f, -0.03604345f, 0.02444501f, 0.04758961f, 0.00989545f, 
    0.02483565f, 0.05242187f, 0.02533666f, -0.02332355f, -0.01938391f, -0.05657164f, 0.05263875f, -0.06551028f, 
    -0.07014813f, -0.02674812f, -0.07452502f, -0.05124184f, -0.01259363f, -0.00934475f, 0.06593142f, -0.06434094f, 
    -0.03671543f, 0.01758699f, -0.05163008f, -0.00778690f, -0.00004902f, -0.05302609f, -0.06413152f, -0.04925437f, 
    -0.03356026f, 0.00506775f, -0.05243447f, 0.01983521f, -0.04153482f, -0.02538636f, 0.02826660f, -0.03189960f, 
    -0.01390987f, -0.02102959f, 0.02277161f, -0.05127924f, 0.00310128f, -0.05181408f, 0.02891452f, -0.07218270f, 
    0.04006791f, 0.01500633f, 0.01716576f, 0.04508353f, -0.06939658f, -0.07015147f, 0.01514041f, 0.00375628f, 
    -0.07283197f, 0.03393793f, 0.00372546f, -0.05223475f, -0.00916100f, 0.01141572f, -0.03808158f, -0.02352903f, 
    -0.02801638f, 0.01307636f, -0.01412063f, -0.06623417f, -0.00696120f, -0.00983069f, 0.05219897f, 0.02997575f, 
    -0.00860829f, 0.02798291f, 0.05983537f, -0.00878596f, 0.05898202f, 0.02576294f, -0.04100946f, 0.06528239f, 
    0.05199327f, -0.01465420f, -0.05884651f, -0.04398206f, -0.06395260f, -0.04730526f, 0.03327185f, 0.08810848f, 
    0.04374985f, -0.02342934f, -0.12433267f, -0.28545094f, 0.18570548f, -0.01186221f, 0.09938291f, -0.31456253f, 
    -0.02987423f, -0.21479194f, 0.16234763f, -0.17875662f, -0.01148949f, -0.07574955f, -0.05434904f, 0.00767181f, 
    0.20246749f, 0.11603089f, 0.02409817f, 0.24132153f, 0.23688106f, 0.08740469f, 0.21998583f, -0.17425166f, 
    0.12319143f, 0.10930860f, 0.09023116f, 0.11318721f, 0.01278500f, -0.07672348f, -0.15907274f, -0.36375687f, 
    -0.01844481f, 0.16209757f, -0.16765872f, 0.09466355f, -0.08391906f, -0.03530171f, -0.02472515f, 0.00443226f, 
    -0.74913561f, -0.62703109f, 0.12297886f, -0.10886040f, 0.21826755f, -0.14341776f, -0.07143828f, -0.00662580f, 
    0.01573475f, 0.06872781f, 0.04300030f, -0.01144054f, 0.04792642f, 0.31321549f, 0.19224046f, 0.19335036f, 
    0.20471972f, 0.28785455f, 0.02133256f, -0.03341369f, 0.08329230f, 0.00004307f, -0.03840072f, -0.10745751f, 
    -0.15166958f, -0.11438107f, -0.34662774f, -0.16358089f, 0.01475177f, -0.01002251f, 0.04049644f, -0.16320521f, 
    -0.21645986f, 0.07753009f, -0.04579319f, 0.08104391f, -0.15294430f, -0.02793387f, 0.12230673f, -0.08972012f, 
    0.02084785f, -0.16884579f, -0.15521857f, -0.04396533f, -0.07633692f, 0.02953580f, 0.08770672f, 0.04940454f, 
    -0.01743443f, -0.24480064f, -0.17236137f, 0.07421352f, -0.10963395f, -0.04336135f, 0.18054932f, 0.01745952f, 
    -0.02028068f, -0.04778117f, -0.18480144f, -0.00930682f, -0.28590637f, -0.10579655f, 0.00252460f, 0.04386390f, 
    -0.10147634f, 0.16416267f, 0.01894422f, -0.16794659f, -0.06322750f, 0.09441078f, 0.12815137f, -0.10759156f, 
    -0.37640491f, -0.23933055f, -0.01288692f, -0.14566071f, 0.10298178f, -0.07146361f, -0.14949822f, 0.12272624f, 
    -0.01175769f, -0.17144708f, -0.01142122f, -0.23281775f, -0.02726702f, -0.12586886f, -0.07053392f, -0.03619203f, 
    0.23822215f, 0.12964016f, -0.17509077f, 0.11358324f, -0.01347978f, 0.00689085f, -0.13175412f, -0.06631374f, 
    0.42709470f, 0.16952485f, 0.08692025f, 0.13125579f, -0.18930623f, 0.08607662f, 0.05136163f, -0.02966508f, 
    -0.01479179f, 0.08767042f, 0.11903308f, 0.04503566f, -0.06773806f, -0.04084364f, -0.20235467f, 0.11550055f, 
    0.02591965f, 0.12396658f, -0.00093848f, -0.03845986f, -0.05312102f, 0.09486286f, -0.01855666f, 0.21186309f, 
    0.45515344f, 0.33952895f, 0.19031404f, 0.15826780f, 0.17605981f, 0.20723517f, -0.06396361f, -0.02840138f, 
    0.03245902f, 0.03702552f, 0.04785730f, -0.01771325f, 0.14424463f, 0.10777183f, 0.06826616f, 0.15198869f, 
    -0.09756629f, -0.10725251f, 0.26433730f, -0.00815337f, -0.13471462f, -0.05735646f, -0.01047720f, -0.01495671f, 
    0.04199055f, -0.03515160f, -0.01510215f, 0.02241439f, -0.00145719f, -0.08409593f, -0.02783457f, -0.03500710f, 
    -0.04235549f, 0.01882632f, -0.01211245f, -0.02398689f, 0.03063464f, -0.02605705f, -0.04547875f, -0.04898250f, 
    -0.08653137f, -0.03774125f, -0.05421675f, 0.03570608f, -0.06794788f, -0.05850865f, -0.08932897f, -0.04802733f, 
    -0.06200587f, 0.01992767f, -0.01870161f, -0.04995440f, -0.03886567f, 0.02744983f, -0.00003389f, -0.04909641f, 
    0.00646381f, 0.00260687f, 0.06031490f, -0.06522889f, 0.00010056f, 0.02712828f, 0.02966064f, -0.02151678f, 
    0.03913748f, -0.01939056f, 0.02833668f, -0.07872894f, 0.01650264f, -0.07935819f, 0.03619193f, 0.01685140f, 
    0.03829269f, -0.07686169f, -0.03086715f, -0.05571074f, -0.08080071f, 0.01208461f, -0.02755510f, -0.09336904f, 
    0.01315924f, 0.01638165f, -0.04499036f, -0.01495079f, -0.07546772f, -0.01924713f, 0.04901615f, -0.05997839f, 
    -0.01958269f, -0.05931077f, -0.03398551f, 0.05045597f, -0.06882145f, -0.02422394f, 0.04640352f, 0.04061472f, 
    -0.01803961f, -0.01160962f, -0.06985364f, 0.00208289f, -0.05756285f, 0.01573836f, -0.04170931f, 0.04081659f, 
    0.00478160f, -0.04923267f, -0.02702175f, -0.01433664f, -0.08719736f, 0.03589324f, 0.03708325f, -0.06353401f, 
    0.00898656f, -0.07191635f, -0.06811827f, 0.02505478f, -0.05775369f, -0.01064843f, 0.01452036f, -0.08134888f, 
    -0.04266234f, -0.02604036f, -0.04501378f, 0.01512650f, -0.04359753f, -0.06867240f, -0.09061895f, -0.07596471f, 
    -0.02576069f, -0.03375297f, 0.01543891f, 0.04632521f, 0.02398051f, -0.04123646f, -0.06954344f, 0.00421366f, 
    -0.04976306f, 0.01875366f, 0.02390138f, 0.03400964f, -0.04905266f, -0.01844062f, -0.03236451f, -0.03239590f, 
    0.03565894f, -0.02268670f, 0.01006139f, 0.04323695f, 0.00536367f, 0.02385619f, 0.01856843f, -0.05927544f, 
    -0.01314286f, -0.03875780f, 0.02443081f, -0.05900466f, -0.04580167f, -0.04655232f, -0.09086291f, 0.00162628f, 
    -0.04721685f, -0.02413100f, -0.00660384f, -0.03483593f, -0.09011056f, -0.02617675f, -0.07384116f, 0.00150066f, 
    -0.02298994f, -0.01414772f, -0.01864946f, -0.02826056f, 0.00543533f, -0.03330569f, -0.03062895f, -0.05273091f, 
    -0.05697480f, -0.07460455f, -0.02052666f, -0.02858376f, -0.05240884f, -0.04441715f, -0.02735158f, 0.03426587f, 
    -0.05489501f, -0.07393244f, -0.05057177f, 0.04437298f, 0.05191400f, -0.07184810f, 0.01400984f, -0.02756007f, 
    0.00980815f, 0.02707672f, -0.05831032f, 0.03855719f, -0.01456220f, -0.03294846f, -0.05995429f, -0.02599246f, 
    -0.03989356f, -0.04586031f, -0.00513475f, -0.03470300f, -0.03120182f, -0.00410422f, 0.02739543f, 0.04750081f, 
    -0.05488557f, -0.05159341f, 0.03941296f, -0.02921067f, -0.06299392f, -0.04419396f, 0.03488698f, 0.02513134f, 
    -0.01173365f, -0.12404217f, 0.05549828f, 0.06400737f, 0.15321317f, 0.13190207f, -0.10743696f, -0.07297575f, 
    -0.02345724f, 0.15390910f, 0.19529629f, 0.36446092f, 0.08224044f, 0.05117776f, 0.20084547f, 0.11032517f, 
    0.11782612f, -0.01085671f, -0.21836616f, 0.04505945f, 0.16364881f, 0.28524366f, 0.19554949f, -0.16458853f, 
    -0.00295123f, 0.10797085f, 0.07054432f, -0.03871492f, 0.06648620f, -0.03768718f, -0.02103877f, 0.06062001f, 
    -0.02276948f, 0.12309682f, -0.13763039f, -0.02264225f, 0.09977794f, -0.15467076f, -0.19342320f, 0.12584098f, 
    -0.11377040f, -0.02390442f, -0.10758825f, 0.01977663f, 0.12948257f, 0.05930583f, 0.04357171f, -0.08740065f, 
    0.24711651f, 0.07531264f, 0.07997797f, -0.03080962f, -0.15981190f, 0.01858335f, -0.23215844f, -0.04400197f, 
    -0.00577415f, -0.00375234f, 0.01554070f, 0.09285463f, -0.02760434f, 0.32923520f, 0.16315638f, -0.07712394f, 
    -0.15908942f, -0.17152616f, 0.05065946f, 0.07998248f, 0.08951982f, -0.01585494f, -0.01386605f, -0.10860796f, 
    0.23543301f, 0.28633431f, 0.00345255f, 0.09507867f, -0.14425869f, 0.06091803f, -0.06674102f, -0.05404386f, 
    0.17591247f, -0.11302183f, -0.12522404f, -0.11932320f, 0.05991237f, -0.15020849f, -0.15079722f, 0.14597690f, 
    0.04158549f, -0.06790252f, -0.10997175f, 0.06780741f, 0.05697567f, -0.07091166f, -0.17682543f, -0.18450144f, 
    -0.38710290f, -0.15288550f, -0.02877231f, 0.07380011f, 0.03512676f, 0.02222933f, -0.08515994f, -0.09247918f, 
    -0.07317468f, 0.08553871f, 0.07531628f, 0.05652791f, -0.12052879f, 0.02622255f, -0.08029031f, -0.04857812f, 
    -0.08867221f, -0.01081691f, -0.20056741f, -0.08580916f, 0.00307835f, 0.01991451f, 0.07820866f, 0.15113503f, 
    0.01719270f, -0.19379036f, 0.01748818f, 0.07840560f, 0.03559700f, 0.21968901f, 0.04951847f, -0.10240717f, 
    0.07423247f, -0.00582631f, 0.04409534f, 0.14852232f, -0.43262914f, -0.01179041f, 0.25279999f, 0.09057060f, 
    -0.30043042f, -0.01837957f, -0.06248733f, -0.01100818f, 0.11590268f, 0.11630983f, -0.09866709f, 0.01857277f, 
    -0.41276756f, -0.04941493f, 0.05759963f, -0.06012312f, 0.14233994f, 0.18539777f, -0.00958779f, -0.07757039f, 
    0.01377361f, -0.08445265f, -0.02182033f, -0.15192145f, 0.16773903f, -0.15437965f, 0.18394752f, 0.23324680f, 
    0.14876628f, 0.04669463f, -0.04811367f, 0.04057954f, 0.15221086f, -0.21644607f, -0.10117002f, -0.05063945f, 
    -0.16668104f, -0.05541672f, -0.05249536f, -0.19856247f, -0.04980043f, 0.02370571f, -0.08904526f, 0.04752224f, 
    -0.07672472f, -0.01336080f, 0.13764244f, 0.03627075f, -0.02109766f, 0.00393926f, 0.21981278f, 0.16229877f, 
    0.15411863f, 0.22534557f, 0.14146227f, 0.14021109f, 0.22152178f, -0.05835029f, -0.07301887f, 0.09221823f, 
    -0.20417202f, -0.02240199f, -0.18752624f, -0.03976930f, 0.15160939f, -0.07121312f, 0.13698009f, 0.01503221f, 
    -0.12463795f, -0.18018520f, -0.30035746f, -0.36190891f, 0.10290726f, -0.11057865f, 0.30219707f, -0.17518251f, 
    -0.12256023f, -0.01700661f, -0.31135133f, -0.22526829f, -0.09069892f, -0.05364579f, -0.05330443f, -0.09522796f, 
    -0.01022770f, 0.08052468f, 0.18869518f, 0.07486122f, 0.11860772f, 0.01755413f, 0.06321894f, 0.15738057f, 
    0.13785346f, 0.02522034f, 0.23603451f, 0.18097150f, 0.02390050f, -0.11478493f, 0.15833534f, -0.02051912f, 
    0.26515085f, -0.04023336f, -0.03782042f, -0.04935184f, 0.04827027f, -0.24922897f, -0.09690040f, -0.09493791f, 
    -0.16564937f, -0.10196936f, -0.12261327f, 0.05534518f, 0.24247326f, 0.13795957f, 0.23357110f, -0.19832671f, 
    -0.02840233f, -0.12628792f, 0.03643143f, -0.25711653f, 0.09051819f, -0.20841737f, 0.03735321f, 0.21910453f, 
    0.22029203f, 0.13047048f, -0.07936686f, 0.00818385f, -0.04614968f, 0.04445730f, 0.08144028f, 0.19193462f, 
    -0.08576309f, -0.19269373f, 0.20577295f, -0.23722507f, 0.15908431f, -0.11035834f, -0.01690021f, -0.01734272f, 
    -0.16160631f, 0.06841094f, 0.04386033f, 0.12654503f, 0.09654874f, -0.06522097f, -0.09083309f, 0.09974615f, 
    -0.05711817f, 0.14766943f, 0.08977313f, -0.13503830f, 0.14227760f, 0.04364160f, 0.28998744f, 0.29336506f, 
    0.16818735f, 0.12288108f, 0.24707605f, 0.05792494f, -0.04795888f, 0.00718199f, -0.10221930f, 0.07275527f, 
    0.01018647f, 0.05097644f, -0.09865932f, -0.06487823f, 0.07341284f, -0.14198929f, 0.13277659f, -0.05242365f, 
    0.06518065f, 0.00595733f, 0.09711368f, -0.06075631f, -0.02604076f, 0.06438526f, -0.09557348f, -0.09402847f, 
    -0.16739781f, 0.15629554f, 0.08520543f, 0.06815713f, -0.06117349f, 0.07692394f, -0.05093664f, -0.25344929f, 
    -0.28863055f, -0.16694251f, -0.01425874f, -0.22657557f, -0.05284296f, 0.06873796f, -0.21605176f, -0.06696561f, 
    0.13221107f, -0.02182258f, 0.04948160f, -0.20278658f, -0.07973355f, -0.17884380f, -0.02226317f, -0.16572493f, 
    0.16418476f, 0.18822546f, 0.08824129f, 0.14246330f, 0.06155891f, 0.10163537f, 0.20803741f, 0.04769578f, 
    0.13953158f, 0.00065319f, 0.00282068f, -0.11345080f, -0.13402520f, 0.29601613f, 0.16829170f, -0.06025930f, 
    0.03229087f, -0.17354947f, 0.13999595f, -0.07937759f, 0.18466996f, 0.15523545f, 0.20365064f, 0.13229765f, 
    0.20896450f, 0.03757700f, 0.20818642f, 0.24980880f, -0.23277326f, -0.12801051f, -0.07833775f, -0.09330735f, 
    0.09265742f, 0.00759672f, -0.05074205f, 0.17577350f, -0.00390935f, 0.08011963f, -0.00815961f, 0.01875601f, 
    0.05778665f, 0.06557778f, -0.06341044f, 0.09118969f, -0.10333718f, -0.12612267f, -0.04188574f, -0.11455037f, 
    0.11514755f, 0.02418935f, 0.05343784f, -0.10484960f, -0.01850880f, -0.09824919f, -0.06874488f, 0.19647412f, 
    -0.09293969f, -0.06535695f, -0.09079535f, -0.21967855f, -0.07793288f, -0.13653249f, -0.26039556f, 0.10017975f, 
    0.04185783f, -0.04574491f, 0.20517336f, -0.12892042f, -0.11418832f, -0.16722561f, -0.06008373f, 0.04562088f, 
    0.20067102f, -0.05739187f, 0.15568283f, 0.05562324f, 0.01768884f, 0.04489883f, 0.11115330f, 0.03197670f, 
    0.02910407f, 0.03713449f, 0.17701113f, 0.10989725f, 0.10950899f, 0.15212981f, -0.08396282f, -0.05473174f, 
    -0.06785336f, 0.07128648f, -0.10648962f, -0.00125399f, -0.14241080f, -0.01863514f, -0.09665509f, -0.10793711f, 
    0.28018495f, -0.05405036f, 0.44362205f, 0.09931669f, -0.09999625f, 0.07011146f, -0.23914598f, 0.12398702f, 
    -0.04365990f, -0.07193224f, -0.08132920f, -0.00057781f, -0.24633463f, 0.15807587f, 0.20147204f, -0.02953340f, 
    0.05558150f, 0.17902744f, -0.08256698f, -0.01647566f, 0.02267478f, 0.06598985f, -0.01061745f, 0.08349056f, 
    0.00991609f, -0.14544095f, -0.18645291f, 0.21883282f, -0.13723633f, 0.03860538f, 0.06242796f, 0.04954634f, 
    -0.08679010f, 0.06420954f, -0.01777785f, 0.05031428f, -0.01512142f, -0.00073649f, 0.09601088f, 0.08569194f, 
    -0.02127406f, -0.06967553f, -0.04368655f, -0.09594947f, 0.11554941f, 0.14635791f, 0.12454205f, 0.21211082f, 
    -0.15205683f, -0.42548358f, -0.16510418f, 0.12921742f, -0.10209870f, 0.01343000f, 0.10154823f, 0.02361437f, 
    0.08143785f, -0.01832795f, -0.04386815f, 0.01509345f, -0.00583796f, 0.10147583f, -0.09337495f, 0.16614947f, 
    0.03789861f, 0.10582550f, -0.01478270f, 0.01280939f, -0.04109967f, 0.10847726f, 0.00319678f, -0.12675117f, 
    -0.03510463f, -0.29593465f, 0.07572930f, 0.08039354f, 0.16557264f, -0.01575289f, 0.02054727f, 0.14193091f, 
    -0.04296879f, -0.11304083f, -0.06018221f, -0.24408601f, -0.13715588f, 0.01597612f, -0.23126285f, 0.07367487f, 
    0.21315224f, 0.06822525f, -0.18779026f, 0.02702738f, -0.11075059f, 0.00610660f, -0.07309510f, 0.00562726f, 
    0.19440247f, 0.17428635f, 0.12324088f, 0.00237658f, -0.18456928f, 0.08537970f, 0.00834792f, 0.06294469f, 
    0.02688675f, 0.16542953f, 0.00456421f, -0.01038727f, 0.08583272f, -0.11595504f, 0.00231507f, 0.05014670f, 
    0.09674460f, 0.19380006f, -0.04947039f, -0.02536227f, 0.05302989f, 0.10941869f, 0.04591471f, 0.18694170f, 
    0.12407489f, 0.38857672f, -0.18427026f, 0.23366335f, 0.11050759f, 0.01456111f, 0.11816761f, 0.06571956f, 
    0.07174515f, -0.08004102f, -0.01719134f, -0.01707284f, 0.18723911f, 0.17020421f, 0.06254695f, -0.00773035f, 
    -0.05606880f, -0.00438185f, 0.01861225f, -0.20667253f, -0.00722959f, -0.05993209f, -0.04848837f, -0.21411073f, 
    -0.05696540f, -0.03118477f, -0.02528882f, 0.01645154f, -0.00883536f, 0.04624902f, 0.05672734f, -0.07376543f, 
    -0.01683236f, 0.04165737f, -0.02179799f, -0.01122092f, 0.06359283f, 0.05899886f, -0.06015957f, 0.05034496f, 
    0.02293687f, 0.00181502f, -0.02841682f, 0.04356288f, -0.07312773f, 0.04603773f, -0.02238013f, -0.03291892f, 
    -0.05694047f, -0.04373965f, -0.06653964f, 0.05155757f, 0.04350520f, 0.01819711f, -0.05020743f, 0.02009270f, 
    -0.07708555f, -0.02289684f, -0.00868645f, 0.02765081f, -0.04622632f, 0.01461481f, -0.02938816f, -0.07582186f, 
    0.00924246f, -0.01275419f, -0.01815975f, -0.01405682f, -0.05406157f, -0.05601620f, 0.02809498f, -0.07669894f, 
    -0.02134626f, 0.05701786f, 0.03283037f, 0.05750449f, -0.01933928f, -0.04180495f, 0.01630566f, 0.02679516f, 
    -0.03084951f, -0.05165479f, -0.05340417f, -0.02163592f, 0.00808728f, 0.05663143f, 0.02656134f, 0.03330136f, 
    -0.02088838f, -0.01164074f, -0.03262130f, 0.04829312f, -0.03975503f, 0.02984001f, 0.06060812f, -0.07003929f, 
    0.03120000f, 0.00674539f, 0.06657191f, 0.03571778f, -0.01861869f, 0.00932963f, 0.03843272f, -0.00542108f, 
    -0.04017564f, -0.05352006f, 0.03658203f, -0.07089612f, 0.06144534f, -0.06161632f, -0.01460693f, -0.06106305f, 
    -0.06075715f, 0.02104704f, -0.00367620f, 0.03931848f, 0.02114175f, -0.06800084f, -0.06772427f, -0.06092642f, 
    0.01617190f, 0.05827063f, 0.05928687f, -0.07668503f, -0.04003197f, 0.03743488f, -0.01066047f, -0.01474699f, 
    -0.05670988f, -0.05214470f, 0.00622302f, -0.02977711f, 0.05781530f, 0.05416159f, -0.04257929f, 0.04380744f, 
    -0.01450142f, -0.06147540f, -0.03043791f, -0.02593761f, -0.03860299f, -0.06413533f, 0.05179868f, -0.00217684f, 
    -0.06686101f, -0.05057133f, -0.00305249f, -0.03678628f, -0.06372064f, -0.01797296f, -0.06244400f, -0.01171774f, 
    0.05725572f, 0.04353261f, 0.04553476f, -0.03877596f, -0.07482423f, 0.04268821f, -0.00875208f, 0.01992136f, 
    -0.00246360f, -0.04432730f, -0.02358817f, -0.00267478f, -0.07099847f, 0.01048650f, -0.03711133f, -0.01172150f, 
    0.02531932f, 0.02271827f, 0.03876900f, 0.05921472f, -0.05714719f, 0.05394742f, 0.02400424f, -0.04087442f, 
    -0.06846001f, 0.00606435f, -0.06540428f, -0.02983096f, -0.04513824f, -0.02280460f, 0.04116008f, 0.06610379f, 
    -0.00954518f, 0.01315307f, -0.03764323f, 0.04637778f, -0.06120189f, -0.01553924f, 0.04751715f, -0.05766311f, 
    -0.04754215f, -0.05532893f, 0.02541498f, -0.06249086f, 0.04481415f, 0.03041345f, 0.00020494f, -0.01713908f, 
    -0.00186976f, -0.05713914f, 0.02771023f, -0.06450354f, -0.03270165f, -0.07703185f, 0.06661508f, -0.07750341f, 
    -0.02171662f, 0.00901481f, 0.01617750f, -0.07237049f, 0.00515166f, -0.06910156f, -0.05101470f, 0.05790905f, 
    -0.05806851f, 0.05989118f, 0.05603926f, 0.04312330f, -0.00798419f, 0.04062968f, 0.03908531f, -0.03230025f, 
    0.04041720f, -0.03570599f, -0.03667106f, -0.02727324f, 0.00329979f, 0.00884611f, -0.01304722f, -0.00611742f, 
    0.02218383f, 0.05010414f, -0.03561648f, 0.05620748f, -0.04958110f, 0.05484790f, 0.05952168f, -0.07850981f, 
    -0.07247514f, -0.05916586f, -0.02027245f, 0.03054364f, 0.05602344f, 0.00607441f, -0.06294021f, 0.06764413f, 
    0.06143826f, 0.07856116f, 0.03745646f, 0.01340739f, -0.04952828f, 0.02115596f, 0.01751359f, 0.01269772f, 
    0.02911321f, -0.00033695f, 0.01315869f, 0.01437963f, -0.02258946f, 0.05834125f, 0.02587921f, -0.07089666f, 
    0.00748694f, 0.01222870f, -0.07959723f, 0.02602623f, -0.05750304f, -0.00546040f, -0.00940651f, 0.05217947f, 
    -0.04728119f, 0.02045226f, -0.06197653f, -0.07059389f, -0.00106949f, -0.05989811f, 0.04600190f, -0.06617013f, 
    -0.01190159f, -0.04528474f, -0.04002942f, -0.06614006f, 0.01144841f, 0.02225199f, -0.00022977f, -0.00035969f, 
    -0.08611155f, 0.02779209f, 0.04888635f, -0.04315719f, -0.05681754f, 0.03307860f, -0.05352777f, -0.07471073f, 
    -0.07322995f, -0.00831958f, -0.00992443f, 0.00501921f, -0.01088551f, -0.01190166f, -0.05854272f, 0.00293087f, 
    -0.08326115f, 0.03473499f, -0.03908294f, -0.06153383f, 0.02488229f, 0.01141393f, 0.04470000f, -0.01210909f, 
    0.00512498f, 0.04639600f, 0.00335034f, 0.03879553f, -0.01334790f, -0.02111356f, -0.03334511f, -0.05363156f, 
    -0.04157056f, -0.06865849f, 0.00740126f, -0.03211842f, 0.02629280f, 0.02941893f, -0.00356944f, 0.00526389f, 
    0.05613038f, 0.04149366f, 0.02474740f, -0.01730614f, -0.01789770f, -0.06484335f, -0.05156616f, -0.05819099f, 
    -0.00466872f, -0.01642058f, -0.04758976f, -0.03431046f, -0.00926870f, -0.08679928f, 0.05314662f, 0.00938597f, 
    -0.00434303f, -0.04704725f, -0.03369610f, 0.01464013f, 0.03818398f, -0.01787346f, 0.02743253f, 0.04125604f, 
    0.01244066f, 0.03453772f, -0.06196909f, 0.05078615f, -0.06809232f, 0.05171359f, -0.04768695f, 0.00650914f, 
    -0.04024544f, -0.04891971f, -0.01420259f, 0.03608685f, -0.05165752f, -0.05655548f, -0.00652366f, -0.02380531f, 
    0.03784759f, 0.04041089f, 0.03846608f, 0.00721589f, 0.01155773f, -0.01714197f, -0.05913902f, -0.06035308f, 
    0.03984775f, 0.03060577f, 0.02074736f, -0.08131830f, -0.03573450f, -0.04185897f, -0.03577752f, 0.01776409f, 
    -0.06894757f, 0.01659586f, 0.02466877f, -0.03737248f, 0.05118058f, -0.04315354f, -0.05766855f, -0.00494994f, 
    -0.03985793f, -0.06605136f, 0.02256029f, -0.07547815f, -0.02852016f, 0.06677663f, -0.06733569f, -0.05509665f, 
    0.01299999f, 0.00902539f, 0.02060272f, -0.07517838f, 0.00789886f, -0.01141334f, -0.00392157f, 0.06602522f, 
    -0.00166221f, -0.06691045f, -0.02239605f, -0.10602211f, 0.03373456f, 0.13975294f, 0.04058932f, 0.18375431f, 
    0.08732361f, 0.08305563f, 0.13064611f, 0.20362699f, 0.16569474f, 0.00344508f, 0.38216442f, -0.08038115f, 
    -0.07713109f, 0.09872902f, -0.12399380f, 0.12888385f, 0.04989325f, 0.00479174f, 0.19670679f, -0.04479390f, 
    0.34763360f, 0.07667542f, 0.08289489f, 0.21575683f, 0.07930683f, -0.13909991f, -0.02157914f, -0.01299587f, 
    -0.00099604f, 0.01851380f, -0.03991942f, -0.01142838f, -0.16939242f, -0.26047862f, -0.17494589f, -0.17824475f, 
    0.04601713f, -0.03913795f, -0.12143158f, 0.14686674f, 0.13996749f, 0.12588139f, 0.02364641f, 0.09226881f, 
    -0.67985320f, -0.25371408f, 0.08488007f, 0.12392323f, -0.12008563f, -0.12430588f, -0.02060665f, 0.02063142f, 
    -0.01120025f, -0.05702216f, -0.01063965f, 0.01949839f, 0.24777737f, 0.27719808f, 0.25162330f, 0.29201353f, 
    0.05630718f, -0.10031042f, -0.00468480f, -0.05342064f, 0.09799385f, 0.06270462f, -0.06441807f, -0.32732973f, 
    0.00552370f, -0.02758536f, 0.00053285f, -0.13248125f, -0.13784072f, -0.04348125f, -0.07193495f, -0.06193751f, 
    -0.04213574f, -0.06090090f, -0.08261580f, 0.04838319f, -0.25693503f, -0.03456460f, 0.01600156f, 0.08750751f, 
    -0.02456266f, -0.03104611f, -0.03995936f, -0.03326552f, -0.00459205f, -0.05400427f, -0.06335928f, -0.07309823f, 
    -0.28665802f, 0.15608904f, -0.25590613f, 0.15040779f, -0.06972394f, 0.06989738f, -0.04586823f, 0.04673671f, 
    0.11517246f, -0.24678616f, -0.00186910f, 0.32499179f, -0.08238487f, -0.13323030f, -0.01128660f, -0.04979730f, 
    0.04989618f, 0.12444150f, -0.20923345f, -0.14377731f, 0.11414921f, 0.10926490f, 0.08774982f, 0.01739869f, 
    -0.20567316f, -0.02265989f, -0.05888445f, 0.04189947f, -0.02040684f, 0.09173524f, 0.00722526f, 0.13009673f, 
    0.06413379f, -0.00581430f, 0.05600758f, -0.10913921f, -0.14063753f, 0.00553377f, 0.26981536f, -0.06017132f, 
    0.07251494f, -0.07382332f, -0.03217775f, 0.06414248f, 0.01623071f, 0.09159470f, -0.22433424f, 0.19560903f, 
    -0.09858922f, -0.19176796f, 0.10815088f, -0.11915229f, 0.00157260f, 0.12329966f, 0.09365293f, 0.11001024f, 
    -0.05644790f, 0.09237877f, 0.05106733f, 0.05616133f, -0.17475158f, 0.06131842f, 0.26097491f, 0.10401575f, 
    0.04461153f, 0.04600820f, -0.04396403f, -0.06748123f, 0.12992190f, -0.09790059f, -0.07432418f, 0.12442071f, 
    0.39317697f, 0.17724568f, 0.20255990f, -0.02517384f, -0.06557557f, 0.05330958f, -0.02501637f, 0.00267634f, 
    -0.09912088f, -0.04251280f, 0.09404199f, 0.03225335f, 0.04436018f, 0.11530243f, 0.07656879f, 0.22556858f, 
    -0.08082899f, 0.14617401f, 0.21232449f, 0.18494533f, 0.01608134f, 0.02965345f, 0.14417791f, 0.13439037f, 
    -0.06137866f, 0.00629329f, -0.11365103f, 0.10245801f, 0.10438395f, -0.01228817f, -0.02555982f, -0.13756722f, 
    0.00690755f, 0.00807509f, -0.00601746f, 0.02481160f, -0.13727196f, 0.21298853f, -0.32156217f, 0.12716953f, 
    0.08950402f, -0.04814930f, 0.03343827f, -0.01773565f, 0.07276610f, -0.02210549f, -0.05610811f, 0.13490249f, 
    -0.03449201f, -0.04077001f, -0.05971421f, 0.08898686f, 0.17649910f, 0.26183245f, 0.00638861f, 0.00632468f, 
    -0.12954916f, -0.07713456f, -0.00568897f, 0.06099463f, -0.18017417f, 0.01521571f, 0.07404624f, 0.04932833f, 
    0.01252071f, 0.03461284f, 0.07732267f, -0.02641064f, -0.02641927f, -0.09958098f, -0.05294813f, 0.16284178f, 
    0.15750046f, -0.05766361f, 0.33729073f, 0.06904229f, -0.00062945f, -0.00782381f, 0.02792934f, -0.02719380f, 
    -0.06520642f, -0.06784178f, -0.10801043f, -0.04583092f, 0.16368257f, -0.02026647f, -0.02702294f, 0.05034027f, 
    0.05967731f, -0.10233218f, -0.02769581f, 0.01225421f, 0.00793055f, 0.04092008f, 0.10231533f, 0.19262141f, 
    -0.27666315f, -0.11483170f, -0.09937074f, -0.07929242f, -0.08254750f, -0.00408461f, -0.06082980f, -0.11858429f, 
    -0.02257233f, 0.06997209f, 0.02067092f, 0.08279804f, -0.14122500f, -0.10227324f, 0.00047633f, 0.03204072f, 
    0.03430175f, -0.06824391f, -0.11188134f, -0.00162975f, 0.03833373f, -0.10681266f, 0.04887743f, -0.00486864f, 
    -0.05858230f, -0.27218297f, -0.13337335f, -0.25726467f, 0.07047592f, 0.03590821f, 0.11954330f, -0.04283978f, 
    0.11805106f, 0.13625169f, 0.01709889f, 0.06852596f, 0.03963616f, -0.11361755f, 0.02598039f, -0.04761499f, 
    0.00549479f, -0.17817803f, -0.02028642f, 0.05236681f, 0.16796471f, 0.17157701f, 0.09362032f, 0.11383031f, 
    0.09309472f, -0.09947661f, 0.05912014f, -0.02368378f, 0.08129271f, -0.26560870f, 0.03145963f, -0.12271702f, 
    0.10576119f, -0.06031771f, 0.19502980f, 0.01240849f, 0.26831323f, 0.09309889f, -0.17793389f, -0.10113965f, 
    0.01063486f, -0.24510136f, 0.00658216f, -0.16544083f, -0.00582713f, 0.02873189f, 0.07154584f, 0.21565507f, 
    0.17683206f, 0.07194430f, 0.19535121f, 0.26308551f, -0.02324951f, -0.01601029f, 0.10667422f, 0.10251903f, 
    0.00124932f, -0.03675696f, 0.03207160f, 0.00071387f, 0.11752698f, 0.04830669f, -0.00789834f, 0.05374085f, 
    -0.02447648f, 0.05609218f, 0.02244637f, 0.00143618f, -0.11618038f, 0.09699461f, 0.05860000f, -0.07857296f, 
    -0.45562339f, -0.41686109f, -0.05582891f, 0.14753102f, 0.14942642f, 0.06838834f, 0.19482037f, -0.07885997f, 
    0.06839449f, 0.02852504f, 0.05678995f, 0.04507440f, 0.15184087f, 0.02414270f, -0.12360506f, -0.12580831f, 
    0.04353039f, -0.05423933f, -0.10346843f, -0.05482338f, 0.08453609f, 0.14343405f, 0.02243864f, -0.01506031f, 
    -0.09673876f, 0.03985479f, -0.02060908f, 0.15878734f, 0.03791619f, -0.00259130f, -0.03630587f, -0.03519100f, 
    -0.15811679f, -0.06601075f, -0.07330911f, 0.18360354f, -0.32049212f, 0.20426269f, -0.02325504f, 0.05446888f, 
    0.14494473f, -0.02866876f, -0.10493748f, 0.11360567f, 0.06571221f, 0.17709227f, 0.03501973f, 0.00293940f, 
    -0.30772865f, 0.11754001f, 0.19085410f, -0.12786877f, -0.06841215f, 0.04213203f, -0.07727112f, 0.08703973f, 
    -0.05350323f, -0.09625123f, 0.05555739f, 0.07047919f, -0.39900914f, -0.18467893f, -0.20570411f, 0.12884022f, 
    0.13841701f, 0.05544814f, 0.04941832f, -0.18412422f, 0.05704908f, -0.00623548f, -0.07514372f, 0.00846356f, 
    0.11885830f, 0.02575137f, 0.22417703f, -0.19557588f, -0.10854954f, 0.22056548f, 0.06270514f, -0.00836270f, 
    0.06264850f, -0.10457224f, -0.01401037f, 0.00709921f, -0.01444089f, -0.12964669f, 0.02418198f, 0.04563871f, 
    -0.10891461f, -0.25353912f, -0.10229177f, -0.03560925f, -0.00269529f, 0.02626748f, 0.22905226f, 0.26075789f, 
    -0.05217833f, -0.08391377f, 0.29893064f, -0.26286608f, 0.04190714f, -0.01630721f, -0.06084318f, 0.05849823f, 
    0.09733023f, 0.05129120f, 0.22145475f, -0.02644526f, -0.01478023f, -0.22985019f, -0.30223951f, 0.16150378f, 
    0.07217672f, 0.13013516f, -0.03099727f, -0.00031266f, 0.19265719f, -0.04144430f, 0.12880988f, 0.11808667f, 
    0.04413103f, -0.16569139f, 0.25420853f, 0.11841308f, -0.02035974f, 0.21298428f, -0.01880044f, 0.08062816f, 
    -0.00498690f, -0.01794168f, 0.04995614f, -0.01907487f, -0.09680372f, -0.22729479f, -0.15427846f, -0.14443454f, 
    0.09345837f, -0.10293283f, 0.10434857f, 0.12070383f, 0.06483079f, 0.08506454f, -0.10461465f, 0.14261578f, 
    0.23349795f, -0.04521268f, -0.12937827f, 0.01935435f, -0.06085869f, -0.00833509f, 0.06855059f, -0.13523009f, 
    -0.03688416f, 0.07081307f, 0.08888724f, 0.10025232f, 0.40938559f, -0.13800673f, -0.08573282f, 0.07564235f, 
    -0.09541292f, -0.25372627f, 0.07519961f, 0.03115131f, -0.04615509f, 0.08922560f, -0.05455584f, 0.09200522f, 
    -0.29340184f, -0.07444754f, 0.11584754f, 0.05886218f, 0.18065777f, -0.00900689f, -0.01357110f, -0.19648054f, 
    -0.00226683f, -0.21203342f, -0.07658718f, -0.14740065f, 0.10158850f, 0.20728044f, 0.02407566f, 0.02759959f, 
    -0.02253131f, 0.01478585f, 0.13498785f, 0.09029637f, 0.17414294f, 0.13614658f, 0.16653655f, -0.02481274f, 
    -0.25678000f, -0.31753400f, 0.26178837f, 0.24263993f, -0.09803972f, -0.11723718f, 0.12591973f, 0.17294683f, 
    -0.02361370f, 0.04295293f, 0.05271175f, 0.13440689f, 0.04901455f, -0.14695992f, -0.02446816f, 0.00166751f, 
    0.10661139f, 0.12509041f, -0.10463811f, 0.00636571f, 0.12731794f, 0.07240056f, -0.10613175f, -0.00720423f, 
    -0.01897155f, -0.00181151f, -0.02856249f, -0.00644656f, -0.04865395f, -0.05330627f, -0.04236663f, 0.03835277f, 
    -0.02337493f, -0.02722456f, -0.07126402f, -0.03419094f, 0.02616222f, -0.05657663f, -0.00515163f, -0.05276799f, 
    0.02141543f, -0.05613662f, -0.03899856f, 0.02527924f, -0.03409663f, 0.04360458f, -0.06262717f, -0.07199142f, 
    0.06123745f, 0.06196060f, 0.00870223f, 0.01754821f, -0.03622070f, 0.03026782f, -0.07090845f, -0.03172325f, 
    -0.02264809f, 0.02704917f, 0.05089799f, 0.05812195f, -0.04824652f, -0.03691406f, -0.00760517f, -0.04376999f, 
    0.04771281f, -0.06859512f, 0.00618003f, -0.03359767f, -0.03367963f, -0.03950399f, -0.03911498f, 0.00787011f, 
    0.01426335f, -0.07702901f, 0.02796015f, -0.01154477f, -0.03752588f, -0.04876940f, -0.03962125f, 0.03520337f, 
    0.02574885f, -0.00864863f, 0.02464802f, -0.06669907f, 0.06143923f, 0.01860265f, 0.05598086f, 0.01518206f, 
    -0.00356394f, -0.04575697f, -0.05295692f, -0.05445824f, -0.05577460f, -0.00405578f, -0.05237588f, -0.06818592f, 
    0.00817139f, -0.03372562f, -0.00965287f, 0.03635074f, -0.00901303f, -0.07498457f, -0.06961238f, 0.03227457f, 
    -0.01518527f, -0.06779889f, 0.02137377f, -0.03580058f, -0.04271669f, 0.03809714f, 0.04253027f, 0.01149083f, 
    0.01180024f, 0.05436701f, 0.01560411f, -0.05814084f, -0.07019206f, 0.04859756f, 0.04269717f, -0.02679344f, 
    0.03272711f, 0.03747803f, -0.03226822f, -0.01860785f, -0.06102555f, 0.03900521f, 0.04007850f, -0.05140742f, 
    0.01669716f, -0.06107868f, 0.02096397f, -0.05207141f, -0.02599834f, 0.05718579f, 0.05513989f, -0.06594764f, 
    -0.02931897f, 0.00087517f, -0.04100352f, 0.04092839f, -0.03296290f, -0.06258920f, -0.05522053f, -0.01807860f, 
    -0.04631784f, 0.02327054f, -0.06744078f, -0.07587291f, 0.06176859f, 0.04598524f, -0.07001490f, -0.02860825f, 
    0.04715617f, -0.02173468f, 0.02792642f, 0.03222254f, -0.02813470f, 0.02994901f, -0.01404699f, -0.06676964f, 
    0.04613921f, -0.00067072f, -0.03331405f, 0.03963077f, -0.04485745f, 0.02055866f, -0.02650512f, -0.05817932f, 
    0.03810051f, -0.04704729f, 0.01542987f, 0.06254985f, 0.05684591f, -0.02740427f, 0.06454888f, 0.03617847f, 
    0.01003812f, 0.06286999f, -0.06884265f, 0.05074294f, 0.00929883f, -0.01796107f, 0.04921816f, -0.01171829f, 
    -0.02061165f, 0.02304845f, 0.03332170f, -0.04952324f, -0.07433815f, -0.05095623f, -0.07260215f, -0.03365069f, 
    -0.01185597f, 0.01066525f, -0.01011298f, 0.01939897f, 0.00109673f, -0.00720653f, -0.03393931f, 0.02708753f, 
    -0.07355960f, -0.07146724f, -0.04916399f, 0.04126050f, -0.02406999f, -0.07187302f, -0.06881771f, 0.00860225f, 
    0.02886103f, 0.00893946f, 0.02821347f, -0.05905237f, 0.06560092f, 0.03832263f, -0.04900870f, 0.04464604f, 
    -0.07422733f, -0.09008583f, -0.00953146f, 0.00742296f, 0.10646605f, 0.22086632f, 0.03190235f, 0.08447123f, 
    0.03727411f, 0.02060663f, -0.03465129f, 0.29254815f, -0.00681639f, -0.00314026f, 0.05276391f, 0.11476018f, 
    0.07145692f, -0.00772229f, 0.04451105f, 0.19204466f, 0.33079162f, 0.18362612f, 0.06256187f, 0.04410438f, 
    -0.15087591f, 0.10706674f, 0.03779256f, -0.08148804f, -0.13333087f, 0.08419997f, 0.06678724f, 0.07674703f, 
    0.01451500f, 0.06399156f, 0.05877581f, -0.15307583f, -0.12167588f, 0.05141892f, -0.08401941f, -0.01479418f, 
    -0.16210638f, -0.08751501f, -0.04906916f, -0.09192009f, -0.04510408f, 0.11064880f, -0.12827747f, 0.03824866f, 
    0.16041517f, 0.30671206f, 0.28055444f, -0.09391557f, 0.04017299f, 0.03845753f, -0.20805331f, 0.02724229f, 
    -0.09997799f, 0.07230707f, -0.09837018f, 0.18680036f, -0.10844009f, 0.12070987f, 0.11234170f, -0.17595446f, 
    -0.13682283f, -0.21082665f, 0.09559274f, -0.08438617f, -0.01716233f, 0.05215635f, 0.06777376f, 0.01310057f, 
    0.32345596f, 0.13570800f, 0.16513154f, 0.16662204f, -0.01906088f, 0.02719998f, 0.00165925f, -0.06186282f, 
    0.13257515f, -0.11448837f, 0.02345308f, 0.01770832f, 0.07848619f, 0.14985423f, -0.07805126f, -0.06828792f, 
    -0.00107941f, -0.05939485f, -0.07354097f, -0.04739204f, -0.09218112f, 0.03304750f, -0.04033903f, -0.19051051f, 
    -0.11806572f, -0.03785243f, -0.27869555f, 0.05856269f, 0.10985643f, 0.05763072f, 0.03041930f, 0.01795296f, 
    0.12751728f, -0.02548508f, 0.05134201f, 0.05554902f, -0.11759293f, 0.00256582f, -0.06222502f, -0.16183220f, 
    -0.08017435f, -0.03524628f, -0.22603983f, -0.08285436f, -0.01080658f, 0.05749611f, 0.07396572f, 0.03905798f, 
    0.21344972f, -0.10137317f, -0.08679768f, 0.01894532f, 0.07047463f, -0.15775892f, -0.05902053f, 0.04286066f, 
    0.04790078f, 0.12067942f, 0.10205882f, 0.22413442f, 0.17510599f, -0.22009574f, -0.03272688f, 0.12539721f, 
    -0.04129782f, -0.08914361f, -0.15122870f, 0.06928856f, 0.03263145f, 0.11668467f, 0.01982366f, 0.11082545f, 
    -0.20966862f, -0.10871196f, -0.07793493f, -0.18279836f, 0.03792335f, -0.03215603f, -0.14615771f, -0.22331193f, 
    -0.09891845f, -0.08406793f, -0.05700222f, 0.04873123f, 0.06815416f, -0.17804888f, 0.00011995f, 0.19796941f, 
    0.12921728f, 0.13033038f, 0.02617350f, 0.13260707f, 0.01809481f, 0.13041274f, -0.00476288f, 0.02502163f, 
    -0.13187170f, -0.23508468f, -0.05786107f, 0.01185707f, 0.01184865f, 0.00481208f, 0.10743307f, 0.15446499f, 
    0.10367317f, 0.03862298f, 0.15196532f, 0.09757276f, -0.06106544f, -0.17051508f, 0.08017944f, 0.12019511f, 
    -0.04410353f, -0.03302538f, 0.19280489f, 0.12963952f, 0.09757552f, -0.02521457f, -0.02635968f, -0.04790153f, 
    -0.04334952f, 0.10114701f, 0.04354601f, 0.08872560f, 0.04511539f, 0.14439841f, -0.04470266f, 0.18561354f, 
    -0.04794619f, -0.12734458f, -0.02382305f, -0.07031212f, -0.23829579f, -0.16300240f, -0.08256495f, 0.35614896f, 
    0.07255793f, 0.12015194f, -0.06131335f, 0.03775262f, 0.15571195f, 0.10576919f, -0.05924550f, 0.23775986f, 
    -0.29105085f, -0.05358629f, 0.33357921f, -0.06040916f, -0.18945040f, 0.09755611f, -0.16497345f, 0.09823336f, 
    0.00420545f, -0.10166182f, 0.08011659f, 0.02443035f, -0.17397238f, -0.03496538f, 0.06856775f, -0.10598262f, 
    0.02866143f, 0.03266945f, 0.05791161f, -0.00780549f, 0.05687252f, 0.06534143f, 0.06115419f, 0.00903593f, 
    0.09798385f, 0.12991457f, 0.14741591f, 0.18230233f, -0.03583271f, 0.06744912f, 0.10974643f, 0.15094368f, 
    -0.08550389f, -0.16221549f, 0.01717413f, -0.07313681f, -0.26192787f, -0.19347817f, 0.06941731f, 0.09612553f, 
    0.00132002f, -0.04195578f, -0.04998594f, 0.00323732f, -0.09220206f, 0.06076867f, 0.09106199f, 0.14220978f, 
    0.13175213f, -0.27776361f, 0.01370674f, -0.20947918f, -0.08713503f, -0.02532492f, -0.00392854f, 0.07851785f, 
    -0.12792397f, -0.01062285f, -0.01871700f, 0.08281547f, -0.11495230f, 0.04959311f, -0.11966072f, -0.14175417f, 
    -0.08877999f, 0.06446844f, 0.01580019f, -0.16097619f, 0.13258289f, -0.00325325f, 0.10496366f, 0.12716544f, 
    -0.00712836f, -0.10997087f, -0.02081337f, 0.18309321f, 0.03378906f, -0.09065830f, 0.08699103f, 0.08908124f, 
    0.25543562f, 0.03799523f, 0.06105253f, 0.10236484f, -0.09568951f, -0.07263310f, -0.02785416f, -0.04727847f, 
    0.07308908f, 0.04952465f, 0.08600236f, 0.10587269f, 0.04748072f, 0.11725100f, 0.11391173f, -0.05923497f, 
    0.10722845f, -0.07285415f, -0.13846783f, 0.18390885f, 0.14067982f, -0.12468241f, -0.02755589f, 0.05404067f, 
    0.08934806f, 0.14459710f, 0.11288941f, 0.01229389f, 0.25847596f, -0.10509659f, -0.36186856f, 0.19419147f, 
    0.22510736f, -0.12994938f, 0.02792149f, -0.13736834f, -0.04946566f, -0.03548299f, 0.10578179f, 0.06096116f, 
    -0.24984784f, -0.00019385f, 0.12830693f, -0.00766118f, -0.09733024f, 0.06611138f, 0.00449085f, -0.06198281f, 
    -0.02044378f, -0.13138004f, -0.09065870f, -0.09112445f, 0.06096328f, 0.03181905f, 0.23752210f, -0.11140272f, 
    0.06002202f, 0.12727877f, 0.06124017f, 0.10578841f, 0.03250156f, 0.15670486f, 0.11122482f, 0.00915429f, 
    -0.03849587f, -0.00006535f, -0.02215009f, 0.41001904f, -0.06693553f, -0.08539316f, 0.12482062f, 0.00489040f, 
    0.01870024f, 0.05325003f, -0.13704506f, 0.13509123f, 0.03184756f, -0.21735638f, 0.02743774f, 0.15672974f, 
    -0.02029751f, 0.08534761f, -0.05858764f, 0.07586038f, -0.02376822f, 0.00043041f, -0.02467573f, 0.01851719f, 
    0.06742339f, -0.13832591f, -0.01086163f, -0.27848831f, 0.00338587f, 0.00988556f, -0.05848294f, 0.11567576f, 
    -0.08661255f, -0.12719510f, -0.16706489f, -0.40406123f, 0.28373244f, 0.08877877f, -0.16390558f, -0.25510886f, 
    0.14473216f, -0.27078894f, 0.17242536f, -0.18292315f, -0.17765145f, -0.01854509f, 0.00387897f, 0.06040634f, 
    0.14333189f, 0.14346179f, -0.03566771f, 0.22404031f, 0.16587849f, 0.02223471f, 0.09594946f, -0.07355780f, 
    0.06429729f, -0.02050518f, 0.00255441f, 0.22154427f, 0.15559484f, -0.10268936f, -0.14109312f, -0.02762816f, 
    0.17617454f, 0.08364647f, -0.22352897f, 0.07690576f, -0.34013626f, -0.06448393f, -0.01759482f, -0.08587082f, 
    -0.22903633f, 0.00842770f, 0.38182262f, 0.03209722f, 0.09423683f, 0.04933507f, -0.02240912f, 0.04720308f, 
    -0.18381418f, -0.29050675f, 0.03419767f, -0.08755469f, -0.06145277f, 0.01454064f, 0.17377569f, 0.21987768f, 
    0.18425071f, 0.38400194f, 0.02864603f, 0.00333299f, 0.03451383f, -0.02439704f, -0.00346202f, -0.04763159f, 
    -0.20904152f, 0.25292501f, -0.23593566f, 0.03717995f, -0.13803478f, -0.21117157f, -0.08228090f, -0.20063861f, 
    -0.16084789f, 0.17652793f, -0.09779517f, 0.14174707f, -0.08564289f, -0.01785357f, 0.22577901f, 0.03062616f, 
    -0.13711362f, -0.11280300f, -0.01334388f, 0.04117374f, 0.11303408f, 0.13999031f, 0.07156985f, 0.22928150f, 
    0.30547062f, -0.23148744f, 0.00042183f, -0.07916823f, -0.14841320f, -0.12898973f, 0.11077657f, 0.12039510f, 
    -0.09168335f, 0.06981644f, -0.16283792f, 0.13125104f, -0.27910814f, 0.05656504f, -0.22726762f, 0.21389423f, 
    -0.21227816f, -0.00726207f, 0.25141647f, -0.06841353f, 0.06517483f, 0.03319278f, 0.17447205f, -0.11103938f, 
    -0.19401406f, -0.10488722f, 0.15296851f, -0.19044393f, -0.06748391f, 0.00254479f, -0.17667663f, 0.08738597f, 
    -0.15139829f, -0.08135783f, 0.13061658f, -0.22914191f, 0.01698740f, 0.07702573f, -0.10596777f, -0.01877710f, 
    0.31519058f, -0.02100365f, -0.19630335f, -0.04573205f, -0.19121867f, -0.00369344f, -0.16072996f, 0.01116387f, 
    0.02650917f, 0.07064569f, 0.07871818f, 0.13400231f, -0.05813855f, 0.14322226f, 0.14774399f, -0.02082313f, 
    0.02242498f, 0.00589875f, 0.03985765f, -0.16924892f, 0.02080919f, 0.13149792f, -0.23867455f, 0.13364035f, 
    -0.14044784f, 0.07277241f, 0.12003019f, -0.00288568f, 0.05333080f, 0.09789889f, 0.01653219f, 0.25892845f, 
    0.24571896f, 0.36475059f, 0.21064426f, 0.25857830f, 0.04544608f, 0.11922742f, 0.06091641f, -0.06980542f, 
    0.04928783f, -0.05095669f, 0.00568067f, -0.01792502f, 0.06498482f, 0.16662359f, -0.14536513f, -0.06990671f, 
    -0.02145421f, -0.01266638f, 0.14195257f, 0.00047387f, -0.06945991f, 0.13514407f, -0.06962696f, -0.09295443f, 
    0.01978566f, -0.03985587f, 0.00196349f, -0.04391615f, -0.08910759f, 0.04993320f, 0.00673553f, 0.04627988f, 
    -0.06451593f, -0.02725522f, -0.00403133f, -0.13102736f, -0.15539794f, 0.08129732f, -0.12574802f, 0.18752816f, 
    0.18066855f, 0.06019902f, 0.05100218f, -0.22356409f, 0.01493181f, -0.01809347f, 0.12725812f, 0.11904919f, 
    0.07485932f, -0.25221795f, 0.00003402f, 0.21314964f, 0.11258469f, -0.11650000f, -0.15136634f, -0.11129519f, 
    0.10240714f, 0.05696407f, -0.05288955f, -0.14331920f, 0.07252575f, 0.03566552f, 0.03371879f, -0.08279511f, 
    0.00420447f, 0.09318960f, -0.12600191f, 0.09393959f, 0.06770176f, -0.11398056f, -0.06591815f, -0.02596088f, 
    0.28292301f, 0.02344211f, 0.15358530f, 0.20786542f, 0.04674460f, -0.07090994f, -0.11266806f, -0.03864597f, 
    -0.14019395f, 0.02366688f, -0.06168074f, -0.13859320f, 0.03968363f, 0.00974349f, -0.09801839f, 0.21650687f, 
    0.06248882f, 0.21918692f, 0.07200136f, 0.07804076f, 0.10272840f, 0.09158695f, 0.00659321f, -0.05758227f, 
    -0.03822364f, 0.09651957f, -0.08590710f, 0.20893991f, -0.01646513f, -0.07323229f, -0.04188648f, 0.06654132f, 
    -0.07460614f, 0.03097409f, -0.13056149f, -0.03484751f, -0.02883729f, -0.06247092f, 0.11719496f, -0.07972910f, 
    -0.08140811f, -0.00557215f, -0.13713077f, -0.09399138f, -0.02340124f, 0.16163087f, 0.00465484f, 0.04144128f, 
    -0.12745491f, 0.04567077f, -0.02968134f, -0.16418725f, 0.00576274f, -0.12696935f, -0.02608596f, -0.14513059f, 
    -0.10065287f, 0.02497609f, 0.02043219f, 0.12787104f, -0.09952030f, 0.02946751f, -0.08290412f, 0.07600077f, 
    -0.04103783f, -0.04710182f, -0.01447717f, 0.03905297f, 0.07253157f, 0.02951100f, -0.07088084f, -0.01757280f, 
    -0.02886244f, -0.01418756f, -0.02606780f, 0.04706512f, 0.10190336f, -0.03262744f, 0.07837300f, 0.07291301f, 
    0.16928242f, 0.16827342f, -0.07426234f, -0.01474818f, -0.24730314f, 0.25787956f, -0.10302277f, 0.08031379f, 
    0.03107468f, -0.03142998f, 0.02258506f, -0.03742689f, -0.01555384f, -0.01967239f, -0.08417202f, 0.09296095f, 
    0.17759986f, 0.08858531f, 0.10723901f, 0.13897906f, 0.04204900f, 0.13560906f, 0.11389984f, 0.22729161f, 
    0.03152358f, 0.04001192f, 0.12908112f, 0.03528969f, -0.03347623f, -0.07158884f, 0.16991325f, -0.06828326f, 
    0.05763859f, 0.00873777f, -0.06027647f, 0.06504528f, -0.04991921f, -0.11676665f, -0.05826110f, -0.07237510f, 
    0.22118570f, 0.29075187f, -0.34656686f, -0.03503782f, 0.13804638f, -0.07139790f, 0.06137392f, -0.12040096f, 
    0.05517895f, 0.04420452f, 0.01801934f, -0.10775986f, -0.12469500f, 0.05858045f, 0.01510231f, 0.16647014f, 
    -0.18113545f, 0.05293812f, 0.00167289f, 0.06863108f, -0.04765429f, -0.04217742f, 0.07652941f, 0.02973180f, 
    0.09939495f, -0.13793108f, 0.01983608f, -0.04263418f, -0.02525198f, 0.15719621f, -0.10848585f, 0.15457112f, 
    0.07400394f, -0.04113205f, 0.00511387f, 0.10658298f, 0.37573564f, 0.04992327f, 0.20778731f, -0.21915823f, 
    -0.02199985f, -0.22171001f, -0.08417223f, 0.08324735f, -0.02605952f, 0.09148778f, 0.11748159f, -0.14392364f, 
    0.28993064f, 0.12686221f, 0.10515285f, 0.15599851f, 0.00497491f, -0.07679775f, 0.08713908f, -0.15820825f, 
    0.09005497f, 0.09022151f, -0.00543495f, 0.12208249f, -0.06775794f, -0.05102638f, -0.32615107f, -0.24805936f, 
    -0.04570153f, -0.16132684f, -0.11839200f, 0.20734873f, -0.24576227f, 0.09481192f, 0.00567999f, -0.02665560f, 
    -0.71090382f, -0.25625673f, 0.41297880f, 0.01265953f, 0.02371273f, -0.04215623f, -0.24597938f, 0.07241999f, 
    0.03497658f, 0.02982853f, 0.01844296f, 0.14540684f, -0.07394435f, 0.33705926f, 0.23035292f, 0.05777885f, 
    -0.00137158f, 0.18488719f, 0.04880251f, -0.03736023f, 0.17768143f, -0.02529665f, -0.07714844f, -0.25955454f, 
    0.09473810f, -0.04321919f, -0.13798580f, 0.11395612f, -0.18882941f, -0.13768274f, -0.10029998f, -0.10741428f, 
    -0.01996146f, 0.00349786f, 0.00767795f, -0.07112645f, -0.31911376f, 0.20528418f, -0.10908785f, -0.09059145f, 
    -0.01056180f, -0.05775862f, -0.18640487f, -0.08681774f, 0.00581139f, 0.03149965f, -0.08314051f, -0.04411326f, 
    -0.07706551f, -0.19414823f, -0.16478720f, 0.37847638f, -0.07746043f, -0.03894779f, 0.00303666f, 0.16632758f, 
    0.05229699f, 0.01786157f, -0.00015742f, 0.17527993f, -0.27218989f, 0.01822885f, -0.13292748f, -0.25486985f, 
    -0.14778890f, 0.24153705f, -0.29795516f, -0.06943941f, -0.02808451f, -0.02385344f, 0.20362635f, 0.01865570f, 
    -0.00277965f, -0.17390256f, -0.06224061f, -0.09746606f, 0.12205061f, -0.00828291f, -0.02234790f, 0.24975759f, 
    -0.11804629f, -0.06257326f, 0.02697323f, -0.07841271f, 0.15255654f, -0.03890469f, 0.18715751f, 0.02524547f, 
    0.22016743f, 0.06892243f, -0.34213454f, 0.17500705f, -0.10133575f, 0.12054423f, -0.21638644f, 0.05529400f, 
    -0.23968303f, -0.14228617f, -0.18581057f, -0.21420826f, -0.10817698f, 0.02916971f, -0.05585019f, -0.07343687f, 
    -0.08321381f, 0.09947906f, 0.05036508f, -0.04952293f, 0.02958904f, -0.18739705f, -0.10654582f, 0.19365269f, 
    0.05724097f, 0.15309024f, 0.08372270f, -0.13596953f, 0.02606658f, -0.02463337f, -0.11184081f, 0.18342479f, 
    0.37123775f, 0.30366838f, 0.28745839f, 0.12869993f, -0.01380990f, 0.17626539f, -0.14226972f, 0.08082580f, 
    -0.01864213f, -0.07410064f, 0.04662896f, 0.12164028f, 0.14418583f, 0.17328230f, 0.07391813f, 0.06582365f, 
    0.01325389f, -0.03027109f, 0.19026749f, -0.04218805f, 0.00636294f, -0.10535473f, -0.06698703f, -0.06942050f, 
    0.05914997f, -0.04616777f, -0.09956599f, 0.04624985f, 0.11263716f, 0.09572702f, -0.00133498f, 0.01330612f, 
    -0.00320831f, 0.02038017f, 0.00616664f, 0.22573553f, -0.24198805f, 0.53351599f, -0.20453654f, -0.14117809f, 
    -0.04443630f, -0.07073820f, 0.14869814f, 0.09051980f, -0.06593127f, 0.09625397f, 0.07373205f, 0.18486777f, 
    -0.10661667f, 0.03256379f, -0.11676797f, 0.22449905f, 0.02678109f, 0.15365493f, 0.11972211f, 0.00482042f, 
    0.06535935f, -0.00477179f, -0.05272274f, -0.01862824f, -0.16570020f, 0.04787966f, -0.10477397f, -0.20699741f, 
    -0.18822730f, -0.17869894f, -0.18065891f, -0.09746177f, -0.13748389f, -0.03730636f, 0.03344446f, -0.10479088f, 
    -0.03267577f, 0.08740745f, 0.53013408f, -0.08374003f, -0.02339852f, -0.17064615f, -0.11811623f, -0.01704578f, 
    -0.01368493f, -0.02114043f, 0.05652693f, 0.16142464f, 0.02882166f, -0.11098803f, -0.02876633f, 0.13519946f, 
    -0.10279246f, -0.17175248f, 0.00562914f, 0.11618962f, 0.03785983f, 0.09072307f, 0.10494586f, 0.04223651f, 
    -0.00845415f, 0.51412421f, 0.10348120f, 0.01791620f, -0.08661269f, -0.03113292f, -0.05465996f, -0.06350176f, 
    0.09533790f, -0.02787548f, 0.02555871f, 0.02267286f, -0.08294988f, 0.07903109f, 0.12584791f, 0.01961547f, 
    -0.08115940f, 0.01829453f, -0.12521932f, -0.00890181f, -0.04912068f, -0.00808436f, 0.02127462f, -0.09201512f, 
    0.15019234f, 0.03581257f, -0.31853294f, -0.22714433f, 0.09566788f, 0.09114826f, 0.06580617f, 0.08852018f, 
    0.02360488f, 0.08782227f, -0.08732911f, -0.05516243f, -0.11662666f, -0.08385338f, -0.14843500f, -0.20680651f, 
    -0.12344174f, -0.13698636f, -0.09674665f, -0.16894580f, 0.04214419f, 0.15101142f, 0.08478367f, -0.03483946f, 
    0.32380122f, 0.04440796f, -0.13997470f, -0.10568594f, -0.06631693f, -0.15211284f, 0.09623118f, -0.00066997f, 
    0.09623258f, 0.04471602f, 0.11542477f, 0.03817203f, 0.50657588f, 0.01839749f, -0.00048179f, -0.14669628f, 
    0.02786827f, -0.10228425f, -0.03014595f, -0.01589637f, 0.11476769f, 0.21274202f, 0.11693035f, 0.12933366f, 
    -0.22050186f, -0.03423034f, 0.16579765f, 0.32370862f, 0.05986388f, 0.12696813f, -0.01069556f, 0.06625617f, 
    0.02265744f, -0.01330919f, 0.06600244f, 0.11686409f, -0.03744994f, -0.08330240f, -0.05663979f, 0.13167334f, 
    -0.03949934f, 0.03477800f, 0.07050966f, -0.02038728f, -0.07088199f, 0.00501320f, -0.09104938f, -0.02962532f, 
    0.03598655f, -0.38389552f, -0.20742065f, -0.11811876f, 0.22857195f, 0.18464106f, 0.12988465f, 0.01690395f, 
    0.07854796f, 0.02005868f, 0.05085704f, 0.05477448f, 0.03919302f, -0.07393759f, -0.00915844f, 0.09349826f, 
    0.09160140f, 0.14539835f, 0.06100858f, -0.00787161f, 0.12814884f, 0.20338333f, 0.10028641f, 0.15395360f, 
    -0.00648041f, -0.08148430f, 0.01405104f, -0.07948213f, 0.05449859f, -0.07009984f, -0.06585610f, 0.03532690f, 
    -0.07679339f, 0.03312816f, -0.02769875f, 0.03844012f, 0.01955772f, -0.01630802f, -0.04848769f, 0.03494836f, 
    -0.04248340f, 0.04672438f, 0.01929795f, -0.04117862f, -0.07248515f, 0.02226399f, 0.00414345f, 0.01944051f, 
    -0.09796729f, -0.01772223f, -0.07891746f, -0.09023026f, -0.07108357f, -0.02758126f, -0.08532403f, -0.06999803f, 
    -0.05660570f, -0.01340551f, 0.01223652f, 0.00383937f, 0.02164640f, 0.03553439f, -0.03968912f, 0.01242708f, 
    0.03577084f, -0.09544708f, -0.00104085f, -0.07996412f, -0.01611821f, -0.08253338f, -0.00966130f, -0.07745150f, 
    -0.00604698f, -0.05540224f, -0.05114982f, -0.02179226f, -0.04782997f, -0.06974122f, -0.07556918f, -0.04991838f, 
    -0.05516234f, -0.04484646f, 0.02340014f, -0.00638853f, 0.10996342f, 0.07003322f, 0.06362087f, -0.05287681f, 
    -0.03464416f, -0.01523174f, 0.07306972f, -0.06509203f, -0.05078662f, -0.02080609f, -0.00692732f, -0.01646776f, 
    0.02102436f, -0.03229059f, 0.08302418f, -0.00513079f, 0.00582707f, -0.01350806f, -0.06306092f, 0.00507012f, 
    -0.06539786f, 0.05344008f, 0.05985942f, -0.06103198f, -0.04846497f, 0.03979746f, -0.07224835f, 0.04827952f, 
    0.03661617f, -0.05583567f, 0.00164899f, -0.02871506f, 0.04241833f, -0.02304767f, -0.06565631f, 0.05865926f, 
    -0.05391389f, -0.04935561f, -0.09134916f, -0.02688769f, -0.03489958f, -0.02577277f, -0.04219644f, -0.05604460f, 
    0.04596817f, 0.00455716f, 0.02537078f, -0.06138332f, -0.01114856f, 0.01474418f, -0.02596706f, -0.04758799f, 
    -0.04168495f, -0.08105671f, -0.03761149f, 0.02645550f, 0.01069900f, -0.05732993f, 0.07361789f, -0.02784426f, 
    -0.05902210f, 0.01180982f, 0.06175103f, -0.04906093f, 0.03532817f, -0.04052545f, -0.02033810f, -0.06516504f, 
    -0.07152168f, -0.08625851f, 0.03032653f, 0.01512806f, -0.10020346f, 0.10413167f, 0.08742604f, 0.00092355f, 
    -0.02528847f, 0.03492903f, -0.03145185f, 0.04795485f, 0.05412642f, 0.03289508f, 0.04089747f, 0.02370810f, 
    -0.09077024f, -0.01483571f, -0.02830557f, -0.03613014f, -0.01592042f, 0.08120252f, -0.04598990f, 0.05059709f, 
    0.03333708f, 0.04388380f, 0.02613914f, -0.00278501f, -0.05361556f, -0.03813580f, 0.05213397f, -0.01354969f, 
    -0.03859389f, -0.01068591f, -0.06553235f, -0.08423905f, -0.06874824f, -0.11754695f, 0.09295438f, -0.00954753f, 
    -0.05385032f, 0.07433248f, -0.06050491f, -0.07981557f, -0.03437713f, -0.02452386f, 0.04054052f, 0.04239253f, 
    -0.00383471f, -0.01155288f, 0.02472969f, -0.05760478f, 0.01918151f, -0.08318496f, -0.08659147f, -0.10662811f, 
    0.09080042f, 0.12256800f, -0.01185608f, 0.08515165f, -0.01003550f, -0.07940763f, -0.00847699f, 0.02281836f, 
    -0.15162541f, 0.02056919f, -0.04469940f, -0.01806438f, 0.17093036f, 0.07925265f, 0.09637289f, -0.00515843f, 
    -0.08218685f, -0.05972304f, -0.04065234f, 0.06144895f, -0.10152302f, 0.05720755f, -0.17810090f, 0.18159968f, 
    0.08100282f, -0.07816558f, -0.01707844f, 0.01291498f, 0.16908860f, 0.22239131f, 0.00697952f, 0.04637571f, 
    -0.00951980f, 0.14660753f, 0.01180993f, -0.22881961f, -0.12199594f, 0.09426167f, -0.04576523f, 0.08527026f, 
    -0.05731861f, 0.19514155f, 0.15395223f, -0.00062717f, -0.07954164f, -0.02417641f, -0.10760903f, 0.16797112f, 
    0.03925486f, -0.03737167f, 0.08108984f, -0.10975789f, 0.02030639f, -0.02464671f, -0.09688327f, -0.00825268f, 
    0.34050512f, -0.16493487f, 0.18675284f, 0.17160490f, -0.04061198f, 0.22010337f, -0.06972038f, 0.01246337f, 
    -0.11219506f, -0.12894119f, -0.00439031f, -0.02119742f, -0.03975168f, 0.25407022f, 0.16552635f, -0.36511013f, 
    -0.09867784f, -0.00211487f, 0.02724685f, -0.02012918f, -0.04245400f, 0.00680184f, 0.09948971f, 0.03740940f, 
    0.04821887f, -0.00482708f, 0.03510658f, 0.20456499f, -0.03098903f, 0.02139672f, -0.07297137f, -0.06190993f, 
    0.11835328f, -0.19496964f, -0.12337191f, -0.00365822f, 0.08614837f, -0.08132236f, -0.12781309f, 0.16633575f, 
    0.03865649f, -0.05718412f, -0.08277485f, -0.02329702f, 0.01115564f, -0.05992946f, -0.01175561f, -0.08241332f, 
    -0.11973447f, -0.30778307f, 0.19694623f, 0.26079202f, 0.17705379f, 0.00078562f, 0.11125960f, 0.04674427f, 
    0.05093113f, 0.08869319f, 0.11973371f, 0.04740436f, -0.00285481f, -0.03410934f, -0.01937787f, 0.06388597f, 
    -0.00918312f, -0.01008067f, 0.00080458f, 0.08326533f, 0.06644984f, 0.06169271f, 0.00486115f, 0.20171942f, 
    0.07739992f, -0.17761722f, 0.13533401f, 0.06097802f, 0.22257282f, 0.07072657f, 0.00775546f, 0.01066319f, 
    -0.03590553f, -0.10213614f, 0.03751605f, 0.10107608f, -0.34416312f, 0.05896712f, 0.10570353f, 0.20589554f, 
    -0.17538098f, -0.01275408f, 0.01000868f, 0.15415525f, 0.01434577f, 0.06750184f, -0.13017800f, 0.09909330f, 
    0.01770379f, -0.22286491f, -0.09980581f, -0.27003098f, 0.07743120f, -0.10228617f, -0.07453352f, -0.21175213f, 
    0.03447470f, -0.02325059f, 0.00117716f, 0.02395283f, 0.35471773f, -0.05356628f, -0.10708068f, 0.04461776f, 
    0.00354405f, -0.00570213f, 0.02689523f, 0.08258904f, 0.02966216f, 0.03219298f, 0.02056400f, 0.12174959f, 
    -0.56734520f, -0.03069505f, 0.15090846f, 0.13366294f, 0.09505194f, -0.06213531f, 0.05793472f, 0.07300341f, 
    0.03451337f, 0.09012123f, 0.07067330f, 0.05811582f, -0.04984020f, -0.00476378f, -0.01235818f, -0.18875462f, 
    0.16714197f, 0.07159111f, 0.08755989f, 0.04775697f, 0.04850321f, -0.08817749f, -0.04921782f, 0.03907633f, 
    0.04501087f, -0.16676457f, -0.01100243f, -0.11087739f, 0.03904726f, 0.01706675f, -0.06395958f, 0.01912405f, 
    0.02936492f, -0.01086735f, -0.17968328f, -0.20177436f, 0.21368831f, -0.11112508f, 0.07312781f, -0.07005379f, 
    0.08077356f, -0.00183049f, -0.03817908f, -0.23468772f, -0.07108329f, 0.06341618f, -0.06051962f, 0.03669225f, 
    0.04194377f, 0.16632707f, 0.22050175f, 0.12612928f, 0.02636558f, -0.00455382f, 0.00674288f, 0.06573453f, 
    0.18357702f, 0.01650500f, 0.07347285f, 0.23007986f, 0.07325684f, -0.09588835f, -0.12785986f, -0.07958388f, 
    0.08537842f, 0.15284090f, -0.07176671f, 0.02272304f, -0.09429113f, -0.03060449f, 0.02772639f, -0.04269093f, 
    -0.07329278f, -0.28451911f, -0.06550784f, -0.12557842f, 0.00844428f, 0.11985929f, -0.04238844f, -0.05102849f, 
    -0.01582976f, -0.09241420f, -0.07677089f, 0.04194122f, -0.13127196f, -0.00033375f, 0.16972972f, 0.16904968f, 
    0.11276795f, 0.15559202f, -0.09140928f, 0.00036120f, 0.02200109f, 0.03416383f, 0.01506366f, 0.08342952f, 
    0.05992905f, -0.05907138f, -0.16653147f, -0.14713298f, -0.11706877f, -0.01445364f, 0.00236053f, -0.10128506f, 
    -0.15239966f, 0.14214170f, -0.11570832f, 0.10470873f, 0.07252463f, 0.01090883f, -0.07324418f, 0.00928363f, 
    -0.08238031f, -0.01306912f, 0.06991348f, -0.08723391f, 0.17183039f, 0.13170739f, 0.28260478f, 0.35381281f, 
    0.15533616f, -0.27780551f, 0.35883150f, 0.22367831f, -0.08807591f, -0.04790939f, 0.06432717f, 0.15329719f, 
    -0.03619211f, 0.12138347f, -0.03975772f, 0.10252435f, -0.04550105f, 0.01533032f, 0.00247477f, 0.02499548f, 
    -0.00418165f, 0.17279832f, 0.06417398f, 0.03084968f, 0.04990346f, 0.08076052f, 0.08280880f, -0.03956376f, 
    -0.07596377f, -0.23240787f, -0.05908776f, 0.10146731f, 0.06104436f, -0.04553736f, -0.02933700f, -0.10212011f, 
    -0.14743985f, -0.03414947f, 0.10749747f, -0.16258536f, -0.18843606f, -0.17340559f, -0.24072328f, -0.01150746f, 
    0.30671468f, -0.04005274f, -0.06266590f, -0.04723869f, -0.01490251f, 0.12620384f, -0.20461459f, -0.06571471f, 
    0.04766580f, 0.08176897f, 0.03534773f, -0.00961285f, 0.04806216f, 0.13335307f, 0.16462883f, -0.10750134f, 
    0.04280161f, -0.10818461f, -0.03398297f, -0.12476000f, 0.08926640f, -0.03725863f, -0.13418308f, 0.02771825f, 
    -0.01011810f, 0.13684601f, -0.11277196f, 0.02630058f, 0.06756592f, 0.13256860f, 0.13380642f, 0.28795084f, 
    0.35006261f, 0.47103003f, 0.11528560f, 0.25983703f, -0.05547106f, 0.04439740f, 0.02950828f, 0.09693808f, 
    0.00048349f, -0.13079195f, -0.01463383f, 0.04163046f, 0.06581865f, -0.03324457f, -0.01552701f, 0.12434890f, 
    0.01285074f, 0.05793047f, 0.07177132f, -0.13220692f, -0.04668939f, -0.04887501f, -0.04383181f, -0.14590412f, 
    -0.05062892f, -0.02282605f, -0.09693461f, 0.06424320f, 0.17761026f, 0.03616150f, 0.14108372f, -0.07747512f, 
    -0.01512249f, -0.05236279f, -0.00792519f, 0.10897569f, -0.29796669f, 0.50009125f, -0.21224636f, 0.07076051f, 
    0.10184300f, -0.05478859f, 0.01703260f, 0.04364294f, 0.13227098f, 0.07706080f, -0.03990771f, 0.14486176f, 
    -0.13302003f, -0.08311565f, -0.15698296f, -0.02415175f, -0.00548181f, 0.10892079f, 0.00614092f, 0.06483366f, 
    -0.11189757f, -0.02158198f, -0.01209563f, -0.00747066f, -0.11138438f, -0.02346826f, 0.04151002f, -0.01629515f, 
    0.01193012f, 0.03692114f, 0.09482389f, -0.10414974f, 0.05353307f, 0.01921387f, -0.04934212f, 0.11283696f, 
    0.15263213f, -0.06625517f, 0.26577082f, 0.02220383f, 0.06269186f, 0.09459704f, -0.02547115f, -0.09382237f, 
    -0.04571527f, 0.02881547f, -0.05486406f, -0.00968529f, 0.13932934f, -0.07311936f, -0.07761533f, -0.05284586f, 
    0.04167926f, -0.20415755f, 0.06360717f, -0.06242355f, 0.02655018f, 0.01872835f, 0.04778576f, 0.13800313f, 
    -0.17879972f, 0.23059674f, 0.17234194f, 0.10794669f, -0.01239519f, -0.08803895f, -0.05337150f, -0.09923571f, 
    0.00054203f, -0.08145112f, -0.04133261f, 0.05165277f, 0.10624135f, 0.03070715f, -0.03873865f, 0.04015091f, 
    -0.05657708f, 0.04681299f, -0.04729524f, 0.09974867f, -0.01604337f, 0.01938560f, -0.06886382f, -0.05837925f, 
    0.14614037f, -0.00173093f, -0.10386012f, -0.14493302f, 0.18032804f, 0.20084724f, 0.05387104f, 0.01839279f, 
    0.10712905f, 0.15106072f, 0.06759079f, 0.06619110f, 0.07618384f, 0.01117423f, 0.03295840f, -0.12548998f, 
    -0.05851511f, -0.08398603f, 0.01945030f, -0.04772761f, 0.05553451f, 0.08222522f, -0.01506179f, 0.13251939f, 
    0.26585722f, 0.00817562f, -0.06136795f, -0.09088412f, 0.11166354f, -0.13744842f, -0.02095665f, -0.10977474f, 
    0.10663000f, 0.07018962f, 0.10374118f, 0.04982804f, 0.42147762f, -0.00897813f, 0.06084687f, -0.08461827f, 
    0.05292278f, -0.13509132f, -0.07432252f, -0.10281940f, 0.12279557f, 0.04037949f, -0.00757563f, 0.07049380f, 
    -0.03213963f, -0.13595568f, 0.06498269f, 0.08937638f, 0.17278537f, 0.01631954f, 0.02786430f, 0.01340639f, 
    0.04937974f, -0.06359773f, -0.02769885f, -0.06427652f, 0.01358829f, 0.03291257f, 0.03071244f, 0.10400145f, 
    0.04821836f, -0.03882848f, 0.06505247f, -0.02457409f, -0.03563677f, 0.02810626f, 0.08984420f, -0.05020553f, 
    -0.05783156f, -0.45347741f, 0.07048728f, -0.02132706f, 0.12595469f, 0.01590380f, 0.06571086f, 0.04639418f, 
    0.10812280f, 0.08357015f, 0.16158888f, 0.08011207f, 0.00393674f, -0.06101297f, -0.11514097f, -0.01051520f, 
    -0.00376428f, 0.06224247f, -0.04181575f, 0.10251604f, 0.06814457f, 0.09074764f, -0.06550641f, -0.04855677f, 
    0.03449639f, -0.08959861f, -0.27077797f, -0.30056277f, -0.00910757f, 0.07769402f, 0.04933094f, 0.13948619f, 
    0.12138084f, -0.04727997f, -0.09920584f, -0.07098461f, 0.07082175f, 0.02875182f, -0.00826091f, -0.06412429f, 
    -0.00767518f, 0.03251573f, -0.07945549f, -0.08054478f, 0.01238166f, -0.13912003f, 0.10007261f, 0.01065435f, 
    0.18203622f, -0.08729672f, -0.17596447f, 0.18240248f, 0.26328734f, -0.02219316f, 0.02334762f, 0.02486726f, 
    0.07322053f, 0.17022300f, -0.02571772f, -0.04560179f, 0.23331325f, -0.03851632f, -0.04446465f, -0.13761330f, 
    0.07032780f, -0.04960711f, -0.21205662f, 0.20402654f, -0.02568362f, -0.03957974f, 0.05666048f, 0.01969498f, 
    -0.02952020f, -0.15592419f, -0.01368472f, 0.24944985f, 0.00671151f, -0.14502358f, 0.02459003f, 0.07050294f, 
    -0.03077406f, 0.06675219f, -0.19192399f, -0.06099427f, 0.41361740f, 0.10396061f, 0.14028879f, 0.09896593f, 
    0.26343733f, 0.19409019f, 0.14746857f, 0.07723088f, 0.07841415f, 0.05281535f, -0.05448403f, -0.08336763f, 
    -0.04155831f, 0.20763725f, 0.17089297f, 0.14412370f, -0.09722530f, -0.15860683f, -0.07944579f, -0.23314776f, 
    -0.02086194f, 0.13363653f, -0.01601252f, -0.04867386f, 0.00450694f, -0.00574730f, 0.11460595f, 0.01806587f, 
    0.05863766f, -0.00060254f, -0.03658618f, 0.06953117f, -0.00170651f, 0.04054249f, 0.03389645f, 0.05912884f, 
    -0.08280385f, 0.14198890f, -0.40487325f, -0.09972519f, 0.07385758f, -0.01525504f, -0.04481965f, -0.08136563f, 
    0.05939171f, -0.07817897f, -0.09268888f, 0.05462483f, 0.04641695f, 0.05170070f, 0.08708049f, -0.02385916f, 
    -0.09286053f, 0.01404056f, -0.25560212f, -0.18865202f, 0.07301518f, 0.03185705f, 0.05499380f, -0.04281012f, 
    -0.10873123f, -0.01829250f, 0.11850163f, -0.00417670f, -0.02882252f, -0.00174775f, 0.03746116f, 0.15569128f, 
    0.13456436f, -0.01489718f, -0.12577851f, -0.34777126f, -0.16507995f, 0.22720937f, 0.20010810f, -0.17327711f, 
    0.20209602f, 0.10659374f, -0.22640660f, -0.19146197f, 0.04918743f, 0.08470970f, -0.13130982f, -0.12884502f, 
    0.50253284f, 0.13430141f, 0.00524918f, 0.08795989f, 0.00881735f, 0.05249714f, 0.14615926f, 0.31708646f, 
    0.01003116f, 0.13425562f, 0.10797984f, -0.02839972f, -0.20650582f, 0.07998088f, 0.28713691f, 0.15664682f, 
    0.06459521f, 0.06466667f, -0.00117576f, -0.06941312f, -0.00731498f, -0.05504933f, 0.04828347f, 0.05445439f, 
    0.43851966f, 0.09718220f, 0.00522658f, -0.33701485f, 0.15669192f, 0.11594743f, -0.09695713f, -0.20366062f, 
    0.10256280f, -0.04382548f, 0.06906643f, 0.02850473f, -0.02858245f, 0.23855035f, 0.08326795f, 0.00567683f, 
    -0.01102841f, 0.06622192f, 0.14166118f, 0.06989682f, -0.05542423f, -0.07578322f, 0.01159494f, -0.13044333f, 
    -0.14434144f, -0.02488161f, -0.00800354f, -0.04968968f, 0.11773934f, -0.05252925f, 0.01048772f, -0.06086859f, 
    -0.14915313f, -0.05398991f, -0.06215283f, 0.02167743f, 0.18286860f, -0.12565231f, 0.15237209f, 0.12072168f, 
    -0.08970517f, 0.13632441f, 0.02512395f, -0.05846165f, 0.08460904f, -0.07224894f, 0.10420855f, 0.04887863f, 
    0.35484225f, -0.57121289f, -0.06196250f, -0.27786449f, 0.02496401f, -0.14870432f, -0.10273412f, -0.07370798f, 
    0.21160069f, 0.15911062f, -0.07386319f, 0.03555116f, 0.14514983f, -0.01168426f, 0.12537105f, 0.14528452f, 
    -0.01069732f, -0.05307773f, -0.01313430f, 0.08354414f, 0.02982968f, 0.01597383f, 0.07667603f, 0.04489852f, 
    0.33826420f, 0.34483463f, -0.00101628f, 0.22840391f, -0.07727177f, -0.02362199f, -0.00770107f, -0.07475170f, 
    -0.09130607f, -0.04845815f, -0.07472406f, -0.03646289f, -0.07623686f, -0.41837513f, -0.50971186f, -0.27390647f, 
    0.37392861f, 0.06511926f, -0.05897405f, 0.10804292f, -0.12321586f, -0.01473538f, 0.00491095f, -0.07543968f, 
    0.48179445f, 0.15504666f, 0.17681654f, 0.14645308f, 0.02676112f, -0.01911935f, -0.03805464f, -0.11062305f, 
    0.15618899f, 0.20870686f, 0.07336475f, 0.06500535f, 0.05073784f, 0.11503307f, 0.08514748f, 0.06747644f, 
    0.04074369f, 0.02135736f, 0.01018809f, 0.01113170f, 0.15451679f, 0.05797551f, 0.10368396f, 0.36674103f, 
    -0.13855204f, 0.06356325f, -0.00793470f, 0.12294123f, 0.02342857f, 0.10287644f, 0.00514098f, -0.12602124f, 
    0.04717535f, -0.08811408f, -0.09789177f, 0.06183828f, 0.01417589f, 0.05505500f, 0.10592782f, 0.07570473f, 
    0.02479885f, -0.03975636f, -0.05507028f, -0.05400788f, 0.14242388f, 0.07492122f, 0.05589790f, -0.02408779f, 
    0.02429743f, 0.03925163f, 0.16151117f, 0.14808105f, -0.04454941f, -0.07610729f, 0.03478727f, 0.07526746f, 
    -0.07440197f, -0.06362610f, 0.05226687f, -0.20031847f, -0.24604784f, 0.19963947f, 0.16451851f, -0.00529745f, 
    0.06254031f, 0.01650669f, -0.00697367f, -0.22656283f, -0.13737968f, -0.13345933f, -0.09274081f, 0.18411693f, 
    -0.01834968f, -0.08216426f, -0.19307160f, -0.10660670f, -0.03309824f, 0.05094053f, 0.17881513f, 0.30183926f, 
    -0.09977181f, -0.03856505f, -0.17003527f, -0.16304386f, -0.22990969f, 0.03482839f, 0.24415882f, 0.02778555f, 
    0.10379921f, -0.00913523f, -0.10403769f, -0.20578015f, 0.08317901f, -0.19618548f, -0.21410875f, -0.07283471f, 
    0.14909081f, 0.06173285f, -0.05853651f, -0.25178769f, -0.15856487f, 0.05803442f, -0.09978553f, -0.12859878f, 
    -0.10899097f, -0.13620186f, 0.15575935f, 0.09441564f, -0.13197722f, -0.01507481f, -0.24681307f, -0.11433371f, 
    0.23689197f, 0.16939589f, -0.02051931f, -0.07507739f, -0.10455131f, -0.06135492f, -0.00917246f, 0.03163340f, 
    0.08113377f, -0.05226875f, -0.01138171f, 0.04841845f, -0.01437982f, 0.05234482f, -0.03125251f, -0.10305156f, 
    -0.02449861f, 0.01763734f, -0.05808010f, 0.08115840f, 0.07313699f, 0.06571749f, 0.01895656f, -0.22099632f, 
    -0.09830151f, 0.15083458f, 0.11321716f, 0.02858123f, -0.03452732f, -0.01430337f, -0.15428916f, 0.12350266f, 
    0.07725611f, -0.28385752f, -0.10403892f, -0.12224761f, -0.01956117f, -0.02727666f, 0.17468974f, 0.12533656f, 
    -0.12468585f, 0.04755271f, 0.05996488f, -0.01212631f, 0.17022645f, 0.03948980f, 0.04719044f, 0.09385384f, 
    0.01470867f, 0.04156652f, -0.04065363f, 0.01058879f, 0.06428696f, 0.10818391f, -0.02804446f, -0.00293545f, 
    0.35478207f, 0.25141084f, 0.24912167f, 0.05464709f, -0.21444017f, 0.02812518f, -0.11165097f, 0.00089952f, 
    0.04837707f, 0.05270374f, 0.08073668f, 0.06934427f, -0.36320367f, -0.07137816f, -0.29501194f, -0.22811620f, 
    0.10975454f, -0.00671396f, 0.08035817f, 0.12469018f, -0.09618394f, -0.11676513f, -0.08670700f, -0.11054937f, 
    0.34953541f, 0.22715572f, 0.17436957f, 0.18870245f, 0.05480090f, 0.01849748f, 0.06572100f, 0.06689871f, 
    0.16654141f, 0.05079466f, 0.12205676f, -0.01248796f, 0.05406098f, 0.09225404f, 0.10843999f, 0.04958253f, 
    0.03378495f, 0.02123400f, 0.00323320f, 0.07044753f, 0.14821295f, 0.17030212f, 0.13814047f, 0.05262477f, 
    0.08288631f, -0.16430533f, -0.09039347f, -0.01530329f, 0.04179431f, 0.16365859f, 0.12556137f, -0.03749402f, 
    -0.17225169f, -0.14101292f, 0.05036056f, -0.12329730f, 0.05499169f, 0.14354908f, 0.02065571f, 0.11844856f, 
    0.02717069f, 0.13002214f, -0.08044954f, 0.07507451f, -0.01518194f, -0.15362434f, -0.03291502f, -0.03703538f, 
    0.06468118f, 0.06074489f, 0.08859815f, 0.13692227f, -0.08354123f, 0.07205062f, 0.04364538f, -0.07598888f, 
    0.00411049f, 0.02506085f, 0.00844830f, -0.14188205f, 0.09280308f, -0.03922018f, 0.04443744f, 0.11545426f, 
    -0.05263004f, 0.14012738f, 0.00730110f, -0.00763483f, -0.04398867f, -0.09227900f, 0.01250180f, -0.32870176f, 
    0.06297181f, 0.06623557f, 0.17970654f, 0.15345687f, -0.01098842f, -0.06938224f, -0.05563878f, 0.11604984f, 
    0.06099257f, 0.06185257f, -0.05697107f, -0.06168700f, -0.00695351f, -0.16732669f, 0.07070657f, 0.16165103f, 
    -0.10805956f, -0.02716325f, -0.09356719f, -0.11070355f, 0.11319681f, -0.02228237f, 0.11991926f, 0.08373159f, 
    -0.11327985f, -0.44449627f, -0.60166007f, -0.08388187f, 0.00862709f, -0.04753310f, -0.01032726f, -0.00865122f, 
    -0.02452106f, -0.17878227f, 0.17107241f, -0.09920731f, 0.12851653f, 0.13621932f, 0.06519273f, 0.10341928f, 
    0.10302631f, 0.03343628f, 0.09721062f, -0.04231894f, 0.04905399f, -0.11069581f, -0.10994484f, -0.05665051f, 
    -0.01888491f, -0.19648165f, -0.15384278f, -0.05333925f, -0.03102271f, -0.23505884f, 0.00596092f, -0.05827761f, 
    -0.04689513f, -0.22530961f, -0.13604152f, -0.40831828f, 0.08559874f, 0.35617995f, 0.03633699f, -0.09164706f, 
    0.07678775f, -0.13526185f, -0.07814407f, -0.12365794f, -0.16671342f, 0.02959509f, 0.01604605f, 0.16565149f, 
    -0.09795910f, 0.13790283f, 0.05441512f, 0.13205056f, 0.19050625f, 0.07247237f, 0.08019279f, 0.00280690f, 
    0.00398095f, 0.12492500f, 0.09809499f, 0.08457872f, -0.17041190f, -0.08829641f, 0.15015200f, -0.04444814f, 
    0.23093195f, 0.15340881f, 0.05864793f, 0.01580356f, -0.19385704f, -0.22393088f, -0.15488628f, -0.13834056f, 
    -0.50840670f, -0.18051773f, 0.18687585f, 0.05183542f, 0.07054618f, 0.10752322f, 0.21441506f, 0.01023892f, 
    0.09797299f, -0.14228880f, -0.10393599f, -0.17840455f, 0.26674330f, -0.29882893f, -0.13810655f, 0.16700353f, 
    0.18762971f, 0.16147713f, -0.01501274f, -0.10268976f, -0.03378384f, 0.05170647f, 0.09446753f, 0.19999109f, 
    -0.36931276f, 0.04414137f, 0.11506192f, 0.02152243f, 0.06409181f, -0.20588146f, -0.15967344f, -0.04315099f, 
    -0.04411712f, 0.24168599f, 0.18055545f, 0.24192777f, -0.11673538f, 0.08709744f, 0.08862794f, 0.01290610f, 
    0.01470103f, 0.04565293f, 0.02861249f, 0.10416470f, 0.04898875f, 0.07518101f, 0.13816351f, 0.24586582f, 
    0.28584376f, 0.10136529f, 0.13826573f, -0.05860993f, -0.00194919f, 0.14187010f, 0.03274932f, 0.28345561f, 
    -0.10746235f, 0.02671285f, -0.05238661f, 0.12192686f, -0.07183528f, -0.11982404f, 0.03741071f, 0.04138754f, 
    0.04475316f, -0.08961508f, 0.17169264f, -0.04087391f, -0.01780391f, 0.02817868f, -0.03825824f, -0.04828595f, 
    0.04373484f, 0.06156855f, 0.04897401f, -0.08721198f, -0.09803788f, 0.10311794f, -0.13687307f, -0.11715979f, 
    -0.16543363f, -0.11563955f, 0.07231562f, -0.25873750f, 0.50932759f, 0.19094865f, -0.14526841f, -0.16612130f, 
    0.13993581f, -0.01892084f, 0.11261025f, -0.14177369f, -0.06245160f, -0.06403677f, -0.00477718f, 0.04833116f, 
    0.05978072f, -0.21406755f, -0.07423908f, 0.26983693f, 0.05167634f, -0.00889374f, 0.16877307f, 0.13048463f, 
    0.12040716f, -0.02258611f, -0.01871958f, -0.04528145f, -0.16636537f, 0.20304964f, -0.10773514f, -0.01953644f, 
    0.02070803f, -0.06638841f, 0.16919759f, -0.12784752f, 0.06533945f, 0.18938373f, 0.13349731f, 0.23686810f, 
    0.05119120f, 0.11740877f, 0.31840187f, 0.25816834f, 0.04471853f, -0.02382570f, 0.06234244f, 0.02845795f, 
    -0.06366342f, 0.10425092f, -0.00735616f, 0.09866218f, 0.04414089f, -0.02315097f, -0.26822627f, -0.09740032f, 
    0.01274088f, 0.05777825f, -0.03163522f, -0.14512217f, -0.22309124f, 0.06003752f, -0.03640691f, -0.21758698f, 
    0.02663573f, 0.12323101f, 0.08786275f, 0.05212760f, -0.07099015f, 0.12198073f, 0.04116494f, 0.03260259f, 
    -0.03430166f, 0.03305486f, -0.00372072f, -0.08517861f, -0.01460845f, 0.11759406f, -0.01944366f, -0.00327421f, 
    -0.20206803f, 0.06662892f, -0.02702490f, -0.04628044f, -0.03265764f, -0.24060318f, 0.15022759f, 0.15160942f, 
    0.19596152f, -0.22759540f, -0.02960017f, 0.23828082f, 0.10474595f, 0.03553429f, -0.08580942f, -0.11003615f, 
    0.08868939f, 0.10224359f, -0.00763391f, 0.06891753f, -0.02572636f, -0.06211498f, 0.03899702f, -0.14659278f, 
    -0.04599225f, 0.01905003f, -0.11106773f, 0.12371966f, -0.07011167f, 0.22179626f, 0.15400484f, 0.07186073f, 
    -0.25429100f, -0.15318760f, 0.03737948f, 0.09165065f, -0.05368157f, -0.19472252f, -0.10689420f, -0.03130454f, 
    -0.09109794f, 0.07887623f, 0.04640408f, 0.00990496f, 0.32643387f, -0.03991580f, -0.07218981f, 0.13523367f, 
    0.16707757f, 0.13649775f, 0.03823220f, 0.08135760f, -0.04043144f, 0.07052737f, -0.08129217f, 0.01527319f, 
    0.08829524f, 0.12621586f, -0.16186936f, 0.10810197f, -0.00490320f, -0.00964496f, 0.07193224f, -0.05001896f, 
    -0.14193934f, 0.11426045f, -0.09240141f, 0.25517023f, -0.20426600f, 0.00656596f, 0.14551422f, -0.14025044f, 
    -0.05191312f, 0.01566296f, -0.07289712f, 0.02264271f, 0.00673100f, 0.08850819f, -0.01967072f, 0.09360241f, 
    -0.09540792f, 0.16845419f, -0.08507472f, -0.11504645f, -0.14515205f, 0.10282543f, 0.05683364f, 0.02659904f, 
    0.01328245f, -0.27918431f, -0.07908746f, 0.07071587f, -0.03833694f, 0.05004903f, -0.07135499f, 0.05519616f, 
    0.04867418f, 0.16486162f, -0.06581970f, -0.06988894f, 0.15933943f, 0.18014519f, 0.26820755f, -0.05944424f, 
    -0.11612128f, 0.10260120f, -0.07224417f, -0.13733764f, -0.10664985f, 0.03565464f, 0.10847051f, -0.00656294f, 
    0.21210437f, -0.11192058f, 0.20771399f, -0.25104174f, 0.03261170f, 0.33693299f, -0.06056424f, -0.07292162f, 
    0.13754292f, 0.08670447f, -0.07522437f, 0.05980530f, 0.14406550f, 0.08063802f, -0.02725078f, 0.00738281f, 
    0.37119588f, -0.00741455f, 0.03330013f, 0.07206769f, -0.18859147f, 0.03758270f, 0.03977843f, 0.11260018f, 
    -0.10760536f, 0.09364793f, 0.00512376f, 0.05140104f, -0.17156109f, -0.12664945f, 0.01009625f, 0.10524176f, 
    0.05285448f, 0.09260097f, -0.19705532f, 0.12468643f, -0.01839103f, 0.13703434f, -0.12019363f, 0.13395631f, 
    0.30213189f, 0.34316847f, -0.28085366f, -0.12856327f, 0.06298990f, -0.01212295f, 0.07336858f, -0.06547995f, 
    -0.08771533f, -0.13799655f, -0.02187467f, -0.15204553f, 0.18030572f, 0.25125149f, 0.05403373f, 0.21950909f, 
    -0.13089117f, -0.01854957f, 0.10029791f, -0.05907035f, -0.01474302f, -0.02120895f, 0.10581210f, -0.01556737f, 
    0.10075022f, -0.05016400f, 0.13323820f, 0.01311270f, 0.02583792f, 0.01250989f, -0.00819590f, 0.05568595f, 
    -0.06416273f, 0.01856342f, 0.01554056f, -0.00249116f, -0.35532576f, 0.05926900f, 0.07410667f, 0.19422352f, 
    0.22867411f, 0.17976889f, -0.03470586f, -0.01859303f, -0.12663795f, -0.08626970f, -0.13219908f, -0.01133874f, 
    -0.18959855f, 0.02535740f, 0.32511356f, 0.22571543f, -0.03350212f, -0.13219912f, -0.02927206f, 0.01854888f, 
    0.01805774f, 0.07592064f, 0.10839921f, -0.02046707f, 0.08922642f, -0.00130458f, -0.16661017f, -0.26275343f, 
    -0.02731154f, 0.14489125f, -0.09225617f, 0.06157349f, 0.04831546f, 0.03183296f, -0.01140468f, -0.14470422f, 
    0.39507678f, 0.09037942f, 0.27768943f, 0.07985473f, -0.16214530f, -0.03440606f, -0.07915743f, 0.09586082f, 
    0.05479828f, -0.05533036f, -0.04509068f, -0.14154771f, -0.21708152f, -0.19394185f, 0.05172725f, 0.26936454f, 
    -0.01772108f, 0.00644765f, -0.08554573f, -0.01393380f, 0.09249967f, 0.15479593f, 0.05992914f, -0.08293041f, 
    -0.15521306f, 0.21831423f, -0.04069288f, -0.13283205f, -0.02938263f, 0.03903243f, 0.00680470f, 0.07190126f, 
    -0.12018818f, 0.06975399f, -0.12859032f, -0.10720594f, 0.15950777f, -0.06556639f, 0.04157301f, -0.16372541f, 
    -0.01861683f, -0.06978186f, -0.01022221f, -0.02840316f, 0.04606950f, 0.16593909f, 0.08616037f, 0.21137373f, 
    -0.23793781f, 0.00518109f, -0.06067266f, 0.06232576f, -0.01100120f, 0.01694225f, 0.09820348f, -0.02208477f, 
    -0.03677934f, 0.08194286f, -0.13896945f, 0.01362217f, -0.15874135f, 0.01687941f, -0.08278251f, -0.07797209f, 
    0.03993436f, 0.00570482f, -0.05004762f, 0.08405443f, 0.10428289f, 0.27246395f, 0.03395133f, -0.13614346f, 
    0.05547474f, -0.04239533f, -0.20784271f, 0.10794759f, -0.05183763f, 0.05925057f, -0.02917732f, -0.00045039f, 
    0.02260373f, 0.09748819f, -0.09395454f, -0.10931063f, -0.19938998f, -0.00554878f, -0.29520029f, 0.18067968f, 
    -0.00546434f, 0.06316812f, -0.00846421f, -0.05095907f, -0.13408260f, 0.05438477f, -0.02221627f, -0.11949047f, 
    -0.28558058f, 0.09771271f, 0.30700064f, 0.18029845f, 0.06309571f, 0.22199050f, 0.19022527f, 0.01753400f, 
    -0.02027573f, -0.02204995f, 0.00351967f, -0.06704652f, -0.01010033f, -0.06718759f, 0.20988883f, -0.01705465f, 
    0.12587030f, 0.11168390f, -0.06636161f, 0.00462590f, 0.08833650f, 0.05121506f, 0.07617356f, -0.04524725f, 
    0.38724452f, 0.24048276f, -0.18504564f, 0.24891889f, -0.07521352f, 0.02527764f, -0.00283728f, 0.05504831f, 
    -0.05379405f, -0.00168402f, -0.04118038f, 0.10176613f, -0.09596665f, 0.02461000f, 0.09546262f, 0.26871440f, 
    -0.16772352f, 0.03293772f, -0.03972222f, 0.01545861f, 0.02264852f, -0.01173721f, 0.10917129f, 0.01143405f, 
    0.05164555f, 0.02896456f, 0.14090720f, 0.03606876f, -0.17730130f, 0.01461763f, -0.19933446f, 0.24778306f, 
    -0.02922200f, -0.08818846f, 0.07693370f, 0.03840256f, -0.26001289f, -0.04481308f, -0.15942435f, -0.00485815f, 
    0.02574216f, -0.06706237f, 0.12135383f, 0.09366994f, 0.03407360f, 0.21520153f, 0.14950396f, -0.01778106f, 
    0.35918733f, -0.04269940f, -0.01315969f, 0.04123764f, 0.07839126f, 0.03981527f, -0.04712131f, 0.00047853f, 
    -0.12661374f, -0.01314533f, 0.00216528f, -0.09746969f, -0.01241242f, 0.01801724f, -0.02368127f, -0.07090543f, 
    0.03172771f, 0.00525120f, 0.08658293f, 0.16924351f, -0.07675553f, -0.03740822f, 0.06391443f, 0.03255851f, 
    0.05565455f, 0.01188994f, 0.23845372f, 0.11443487f, -0.01468902f, 0.06709306f, -0.03043021f, 0.17424397f, 
    -0.03451896f, -0.03426221f, -0.01278036f, 0.07265610f, 0.02166957f, 0.05790516f, 0.09966616f, -0.16678379f, 
    0.04043116f, 0.13294969f, 0.09184060f, -0.08209407f, -0.08854685f, -0.18537067f, 0.00690059f, -0.10124397f, 
    -0.13387387f, -0.01316310f, -0.16349322f, 0.43766409f, -0.10521992f, 0.00976755f, -0.02294858f, 0.02549854f, 
    -0.05941245f, -0.08962061f, 0.23264591f, -0.08035608f, -0.19700339f, -0.09510753f, -0.00008331f, -0.04855658f, 
    0.02858735f, 0.04483933f, -0.03682095f, 0.03220792f, -0.01266352f, 0.08666271f, -0.18712425f, -0.01162485f, 
    -0.09780034f, 0.13903111f, -0.12718379f, 0.09382375f, 0.21831666f, 0.11990530f, 0.29047611f, 0.12110566f, 
    0.07881181f, -0.10430892f, 0.08384775f, -0.04547980f, 0.03102202f, 0.09441338f, -0.03498833f, 0.10701388f, 
    -0.02639042f, 0.03438877f, 0.07038842f, 0.07043111f, 0.02555453f, -0.07215916f, 0.15201485f, 0.04518995f, 
    0.01392094f, -0.15591016f, 0.02429595f, 0.01352382f, 0.14585353f, 0.09105346f, 0.09910948f, 0.10085207f, 
    0.08210244f, -0.01366643f, -0.15784843f, 0.03119108f, -0.21987061f, 0.28272033f, 0.08090933f, 0.01190409f, 
    -0.09187740f, 0.10186285f, 0.00540544f, 0.10981812f, -0.06101029f, -0.06819244f, -0.01109152f, 0.09479950f, 
    0.27766004f, 0.03286001f, -0.02903797f, -0.11033752f, -0.07515898f, -0.04996026f, -0.21210909f, 0.00072260f, 
    0.00977252f, 0.06234343f, -0.01701699f, -0.05895123f, 0.03050665f, -0.00536500f, 0.08321268f, 0.11585091f, 
    -0.09784864f, 0.09598736f, -0.20923372f, -0.13871001f, -0.04337733f, -0.12611338f, 0.02109879f, 0.01378396f, 
    -0.11318969f, 0.29519144f, -0.02835160f, 0.17639053f, 0.08624686f, 0.16648172f, 0.16142792f, 0.02356403f, 
    0.19976278f, -0.05744739f, -0.14548182f, 0.08054326f, 0.32604128f, 0.29393524f, 0.06468835f, -0.01684467f, 
    0.05847645f, -0.05182463f, 0.09302919f, -0.09605832f, -0.05852655f, -0.19876297f, -0.00327405f, -0.11124967f, 
    -0.01962514f, 0.00274470f, 0.03783074f, 0.00883388f, 0.10788023f, -0.11111639f, 0.01542077f, -0.07660238f, 
    -0.19411263f, -0.04667966f, -0.07246760f, -0.22249506f, 0.09213728f, -0.05373910f, -0.01349857f, 0.03646468f, 
    0.03617511f, -0.11401628f, 0.23941909f, -0.18890114f, 0.15464118f, 0.04651495f, 0.06059751f, 0.10085201f, 
    0.14644876f, 0.03733407f, -0.07708698f, -0.12668283f, -0.05667453f, -0.02001184f, 0.20941260f, -0.01993494f, 
    0.12891492f, -0.03223684f, 0.18107390f, 0.02865115f, 0.23645940f, 0.09709983f, -0.11721159f, 0.01544381f, 
    0.05439894f, -0.01806535f, -0.01853956f, -0.01103435f, -0.07933824f, -0.07620006f, 0.00711498f, -0.18357074f, 
    0.44410217f, 0.07861544f, -0.20805448f, -0.03463074f, 0.03196306f, 0.04016035f, 0.09280086f, -0.09549333f, 
    0.03259656f, -0.10117371f, 0.07189888f, -0.01056555f, -0.12999013f, 0.06363527f, 0.01183143f, -0.18674693f, 
    -0.03147481f, 0.12703486f, 0.02606371f, 0.06659964f, -0.15760574f, -0.07032628f, 0.03041170f, 0.12722574f, 
    0.15727605f, 0.01592504f, 0.04182552f, 0.27266768f, 0.00080906f, -0.00664583f, 0.01125070f, 0.03375938f, 
    0.02661981f, -0.03612675f, -0.02265296f, -0.09599653f, 0.27913266f, 0.06016035f, 0.03796820f, -0.03371419f, 
    -0.07343125f, -0.12143424f, 0.05771504f, -0.03227742f, 0.04190194f, 0.19452991f, 0.01927829f, 0.05921564f, 
    0.19070898f, -0.06939807f, 0.14829347f, -0.23966342f, -0.02820146f, -0.04496630f, -0.03669443f, -0.04523343f, 
    -0.05481121f, 0.18008798f, -0.01613722f, -0.21271443f, 0.02506421f, 0.13865273f, -0.10286735f, -0.06530429f, 
    -0.04526478f, -0.07269055f, 0.07890636f, 0.00560468f, -0.00724668f, -0.12111388f, -0.08947381f, 0.10293491f, 
    -0.11302034f, 0.04043772f, 0.21493281f, 0.06850309f, 0.07325090f, 0.04759712f, 0.01427406f, -0.05205845f, 
    -0.04565754f, 0.06505949f, -0.20260683f, 0.18746287f, -0.27307627f, -0.10764822f, -0.03439344f, 0.29310516f, 
    -0.04394921f, 0.11997349f, 0.07329211f, 0.13955645f, 0.10316433f, -0.00450244f, -0.02649378f, -0.06555688f, 
    0.24983791f, 0.31100130f, 0.00231116f, 0.09485289f, 0.06001311f, 0.01393879f, 0.03914152f, 0.04314044f, 
    -0.08639668f, -0.07488082f, -0.07234045f, -0.07832015f, 0.10838860f, -0.09492551f, -0.23574518f, -0.03303040f, 
    -0.02354126f, -0.00664792f, -0.04020232f, 0.08815520f, 0.02318423f, 0.03301982f, 0.11901110f, -0.00241172f, 
    -0.03476174f, 0.20182444f, -0.13101624f, -0.17570885f, 0.01883166f, -0.06820128f, 0.03471223f, 0.16286834f, 
    0.17625588f, 0.06939632f, 0.01538744f, -0.03785878f, 0.12665424f, -0.00691317f, 0.07397661f, 0.04818157f, 
    0.06201657f, 0.03975432f, 0.07263266f, -0.02592266f, -0.03930429f, -0.12232716f, -0.14984238f, -0.02053658f, 
    0.02006368f, -0.03625045f, -0.15032497f, -0.08205770f, 0.01291520f, 0.08167911f, -0.02985850f, 0.05391542f, 
    0.09492642f, -0.02450255f, 0.04704652f, 0.23224086f, 0.06030669f, 0.10453579f, -0.17917147f, 0.06697686f, 
    0.00357019f, -0.02647835f, 0.08778981f, 0.17261516f, 0.13871747f, -0.12705015f, 0.05782508f, -0.03233403f, 
    0.30725133f, -0.11467119f, -0.20948082f, -0.11102023f, -0.04006610f, 0.02320168f, 0.03868272f, 0.13117601f, 
    0.00690235f, -0.08393565f, -0.17070609f, -0.09105343f, -0.01353953f, -0.01272981f, 0.03601810f, 0.02885032f, 
    -0.09680232f, -0.07570620f, 0.00566176f, -0.07099497f, -0.13580586f, 0.01645676f, 0.01672455f, 0.13720340f, 
    0.17496495f, 0.12049814f, 0.46528617f, 0.17910230f, -0.10992168f, 0.00183581f, -0.24906544f, 0.05212791f, 
    -0.02248419f, -0.08271765f, -0.09049472f, 0.02098376f, 0.19530064f, 0.28223327f, 0.22032192f, -0.14722262f, 
    0.07515213f, 0.02509039f, 0.10123730f, -0.01455883f, 0.01325837f, 0.01343133f, -0.11236034f, -0.05876273f, 
    0.32235423f, 0.04464157f, 0.14351451f, 0.21773238f, -0.00018562f, 0.01059125f, -0.05637436f, -0.05584537f, 
    0.10287995f, -0.02778071f, 0.02168033f, 0.12142850f, 0.09549019f, 0.05000185f, 0.06000203f, -0.05655552f, 
    0.03277046f, -0.07449978f, -0.13968913f, -0.02909106f, -0.09078575f, -0.13516074f, -0.05835127f, -0.11124714f, 
    0.14495173f, -0.27522460f, -0.44022319f, -0.01878738f, 0.08506473f, 0.01108121f, 0.06610517f, 0.02921189f, 
    0.04563277f, -0.00213594f, -0.00159901f, -0.04920194f, 0.11141887f, -0.03681963f, -0.07145019f, 0.02966349f, 
    -0.09718514f, -0.02441247f, 0.01737899f, -0.08126454f, 0.09576597f, 0.13296466f, 0.04600171f, 0.02973104f, 
    0.19451723f, -0.06727585f, 0.06122416f, -0.00171867f, 0.14600085f, -0.15462337f, 0.05160755f, 0.14342017f, 
    0.05417051f, 0.04628618f, 0.22572422f, 0.04426550f, 0.30186719f, 0.02840936f, 0.17055285f, -0.03047885f, 
    0.10092615f, 0.02685675f, -0.10555473f, 0.00672773f, 0.06992464f, 0.12595733f, 0.05730441f, 0.01126441f, 
    0.16503307f, -0.04289797f, 0.08060271f, -0.04292682f, -0.08864327f, -0.01600329f, -0.03849802f, 0.03726957f, 
    -0.12608394f, 0.06706402f, -0.04013807f, 0.11910369f, 0.12029854f, -0.20423074f, 0.00989080f, 0.10043254f, 
    0.08931623f, 0.05114070f, 0.05926283f, 0.05234918f, -0.01668249f, -0.00614992f, 0.04567608f, 0.02399684f, 
    0.06146175f, -0.34024310f, -0.12332914f, -0.19675854f, 0.06052043f, 0.03681299f, -0.00704795f, 0.00387580f, 
    -0.03394930f, -0.10256270f, 0.00920060f, -0.16440029f, 0.23160464f, 0.05344847f, -0.01160057f, 0.02030852f, 
    0.06184462f, 0.03367633f, 0.13909017f, -0.01063281f, 0.14402848f, 0.13144901f, 0.06211432f, -0.01624541f, 
    0.07354006f, 0.04068315f, 0.07611297f, -0.13452150f, 0.04201555f, 0.08137888f, 0.03745374f, -0.01995807f, 
    -0.15350023f, -0.07139342f, -0.04781854f, -0.02647099f, -0.46366069f, 0.25015190f, -0.35004851f, 0.26591775f, 
    0.19278467f, 0.07594045f, 0.13991444f, -0.16004816f, -0.01753568f, 0.08486241f, 0.14332719f, 0.14073998f, 
    -0.18866830f, -0.05360471f, 0.04123328f, 0.19603290f, -0.15199605f, -0.11819214f, 0.03701906f, -0.04255592f, 
    0.01973237f, -0.02302790f, 0.04723897f, 0.01743484f, 0.02102200f, 0.15628760f, -0.11716296f, -0.21453959f, 
    0.03975309f, 0.14453596f, -0.07998861f, 0.06972118f, 0.00118244f, -0.07512816f, -0.04370083f, -0.11119614f, 
    0.27902502f, 0.09232142f, 0.32854930f, 0.04511759f, 0.13463156f, -0.08871211f, -0.18283525f, 0.07811430f, 
    -0.16244808f, 0.07184373f, -0.12284651f, -0.06114166f, -0.06960328f, -0.12374376f, -0.01890802f, 0.08515844f, 
    -0.09598864f, -0.10606512f, -0.12947500f, 0.05126192f, -0.19808044f, -0.04231946f, -0.06074628f, 0.04903980f, 
    -0.01553252f, 0.30118722f, -0.11239872f, 0.10481119f, -0.09295874f, -0.15483011f, -0.06771898f, 0.11864224f, 
    -0.17693393f, 0.01878170f, -0.00659778f, -0.02937085f, 0.14997089f, 0.11285182f, 0.16447827f, -0.12129942f, 
    -0.20293550f, -0.21234563f, -0.03463643f, 0.10931214f, 0.05562903f, 0.19520944f, -0.02691644f, -0.00312559f, 
    -0.05108046f, -0.04907849f, -0.06328139f, -0.04743557f, 0.08926847f, 0.05478146f, 0.14900948f, 0.06678801f, 
    0.01036294f, 0.07962983f, -0.06149404f, 0.13167226f, -0.10108753f, 0.16741252f, -0.14165731f, -0.08527796f, 
    0.05291410f, 0.15355147f, 0.18292117f, 0.11092096f, 0.11550874f, 0.14762847f, 0.01467890f, -0.20108600f, 
    0.15087651f, -0.07794847f, -0.12538135f, 0.01678874f, 0.03873299f, -0.12281255f, -0.01514481f, 0.12188581f, 
    0.06977285f, 0.14610127f, 0.00606607f, -0.03916497f, 0.01775071f, 0.04659526f, -0.24875037f, 0.12013718f, 
    0.21737543f, 0.00102261f, -0.00193868f, 0.02846541f, 0.10972511f, 0.08891516f, -0.16092002f, 0.03061225f, 
    -0.07374699f, -0.16049486f, 0.09965349f, 0.07405659f, -0.03971472f, 0.05021970f, 0.01400572f, -0.07289737f, 
    -0.01846003f, -0.05922014f, 0.00343912f, 0.15210530f, -0.03387842f, -0.21297483f, 0.03073834f, 0.10352485f, 
    -0.21777560f, 0.03952381f, -0.03070638f, 0.22951931f, -0.10426559f, 0.18138641f, 0.20099114f, 0.05612632f, 
    0.15644762f, 0.29887629f, -0.08691640f, 0.33523867f, 0.20799616f, -0.09881026f, 0.16218713f, 0.11796144f, 
    0.07489561f, -0.03061348f, -0.07430165f, 0.01794210f, -0.08405437f, -0.01473888f, -0.04711860f, 0.23003283f, 
    -0.17649788f, 0.05198061f, -0.00024410f, -0.01398978f, -0.12511408f, -0.05067789f, -0.07330070f, -0.12006517f, 
    -0.02568352f, -0.07606897f, -0.01923389f, 0.00153784f, 0.06262290f, -0.02483769f, 0.06190979f, 0.02539650f, 
    0.02811845f, 0.04526792f, -0.06458424f, 0.03371642f, -0.02852115f, -0.04961807f, -0.04367545f, -0.01061898f, 
    -0.06835036f, -0.05656544f, -0.05613204f, -0.05344151f, -0.01276844f, 0.00238071f, 0.04280245f, -0.02586097f, 
    -0.05599681f, -0.04778881f, 0.05061501f, -0.07355931f, -0.05201535f, -0.02302622f, -0.04151906f, -0.01705919f, 
    -0.03642775f, -0.03320371f, -0.03523982f, 0.00388428f, -0.01163285f, -0.02247945f, -0.03194207f, 0.03945135f, 
    -0.04359000f, -0.03269669f, -0.04202849f, 0.04906974f, -0.04711459f, 0.03174101f, -0.00713069f, -0.07203098f, 
    -0.04949960f, -0.02883583f, -0.00780328f, 0.06048227f, 0.02551843f, -0.04947137f, -0.02762518f, -0.03001573f, 
    0.03391734f, -0.04736144f, -0.02503327f, -0.05308478f, -0.03678945f, 0.04553082f, -0.01444257f, -0.00155652f, 
    -0.03227696f, 0.00960658f, 0.01238224f, 0.05292694f, 0.04419948f, -0.04588548f, 0.00243418f, -0.00381127f, 
    -0.04578936f, 0.05606470f, -0.06913806f, 0.03054873f, -0.05048807f, 0.00188342f, -0.02438440f, 0.06644003f, 
    0.02488717f, -0.01575547f, 0.03639233f, -0.03199995f, 0.00572898f, -0.00401704f, -0.07914722f, -0.01782008f, 
    0.01310852f, 0.04843485f, -0.07469369f, 0.02129239f, 0.00318900f, -0.07715920f, -0.07971734f, -0.00291863f, 
    0.05329055f, -0.01742459f, 0.02560033f, 0.04612656f, 0.02894809f, 0.02716187f, -0.01242523f, -0.07584446f, 
    -0.06489455f, -0.01538960f, -0.04781620f, -0.00157667f, 0.05660978f, -0.01253653f, -0.05954506f, 0.03310032f, 
    -0.07102522f, 0.05919847f, -0.07714269f, -0.04564003f, 0.03542938f, 0.02673477f, 0.02200841f, 0.02553387f, 
    -0.01460530f, -0.04523155f, 0.03505760f, -0.02259354f, -0.05587152f, 0.05078241f, -0.07865642f, -0.02867168f, 
    -0.00955460f, -0.06783524f, 0.00083287f, -0.02353740f, -0.04752892f, -0.02952836f, -0.05198679f, -0.00412158f, 
    0.03000187f, 0.00586445f, 0.05160350f, -0.05328823f, 0.01853388f, -0.06258312f, 0.02983820f, -0.05646072f, 
    -0.05372652f, -0.03455968f, -0.00898231f, 0.01437209f, -0.02871633f, -0.06220926f, 0.01439400f, -0.07642791f, 
    0.03220515f, 0.03564145f, 0.06266350f, -0.02553096f, -0.01941928f, 0.00765254f, -0.07563623f, 0.05217402f, 
    0.05601419f, -0.00933994f, 0.02821131f, -0.04113825f, 0.00736016f, 0.05106517f, 0.01419776f, 0.01987489f, 
    0.06163728f, -0.05616440f, 0.03030410f, 0.04214502f, -0.05359845f, 0.04706540f, -0.07352591f, 0.03327975f, 
    -0.03461269f, -0.07047524f, 0.05484292f, 0.00944426f, -0.05499475f, -0.02954474f, 0.05266096f, 0.02706755f, 
    0.04839750f, -0.05365574f, 0.03167057f, -0.01667488f, 0.01930014f, 0.04474294f, -0.02303937f, -0.05723465f, 
    -0.05283112f, -0.00013086f, 0.02685894f, 0.01670963f, 0.18299872f, -0.11060537f, 0.12339874f, -0.05059821f, 
    -0.07755142f, -0.08701192f, -0.15193807f, -0.07630840f, -0.05944778f, 0.09633701f, -0.08179163f, 0.09014543f, 
    0.08175092f, 0.02163061f, -0.01355230f, -0.10041622f, 0.09271303f, 0.06045831f, 0.01829521f, 0.19890563f, 
    -0.46034661f, -0.04783765f, -0.17356759f, -0.18898669f, -0.11134627f, 0.08496476f, 0.06993705f, 0.05374254f, 
    0.03481819f, 0.09258162f, 0.13428077f, -0.03507498f, 0.05964163f, 0.10016010f, 0.03098590f, 0.08025152f, 
    -0.01935967f, 0.04783756f, 0.01021260f, -0.14146838f, -0.01603005f, -0.08095226f, -0.05459230f, -0.05402927f, 
    0.48460418f, 0.01510041f, 0.09134112f, 0.13283665f, 0.07121401f, 0.07663715f, 0.08023916f, -0.13408250f, 
    -0.02986478f, 0.02280354f, -0.01056684f, 0.06747504f, -0.25242159f, -0.22719261f, -0.30036244f, -0.40527731f, 
    0.03151906f, -0.13839562f, -0.12736146f, -0.07995769f, -0.08167441f, 0.09379679f, 0.10498955f, 0.11986455f, 
    0.40744132f, 0.13365418f, 0.08378407f, 0.27195117f, -0.05409482f, -0.08970223f, -0.08204561f, 0.05587756f, 
    -0.01349828f, 0.09094094f, 0.18511640f, -0.01375702f, 0.16578786f, 0.18950784f, -0.04104843f, -0.01713065f, 
    0.04189929f, 0.05683322f, -0.04320339f, -0.04268824f, 0.13890219f, 0.14466944f, 0.13388687f, 0.24230492f, 
    -0.01468299f, -0.08762723f, 0.04361864f, -0.06999048f, 0.07394774f, 0.04969227f, 0.00538939f, 0.10052705f, 
    -0.02425768f, 0.06449949f, 0.05899639f, -0.02528969f, 0.05139495f, 0.06269103f, -0.00347773f, 0.01099999f, 
    -0.07052416f, -0.04235688f, 0.01774291f, -0.04739298f, 0.22115208f, -0.01583807f, -0.03809325f, -0.06907123f, 
    0.12452384f, 0.09881846f, 0.01004119f, 0.07169074f, 0.07517302f, -0.06082898f, -0.00541260f, -0.01600854f, 
    0.13069762f, 0.11251578f, 0.04186120f, 0.15446889f, 0.08529352f, 0.00274273f, 0.03232750f, 0.18882640f, 
    -0.00802865f, -0.01310131f, 0.01382612f, -0.05350205f, 0.12301096f, -0.07520705f, 0.02370303f, -0.03337980f, 
    0.20067991f, -0.12446091f, -0.04237583f, 0.04701230f, 0.01530320f, 0.03762682f, 0.09054980f, -0.04692308f, 
    -0.05619268f, -0.05520698f, -0.12595667f, -0.04195535f, 0.16278759f, -0.05723330f, -0.18214345f, -0.11693422f, 
    0.07420707f, 0.07402102f, 0.12963027f, 0.23558360f, -0.06160088f, 0.17482710f, 0.18671443f, -0.04475462f, 
    -0.37770215f, -0.04131753f, -0.03676571f, -0.09566814f, -0.04100408f, -0.21978235f, 0.02353317f, 0.09562511f, 
    0.00182584f, 0.07076158f, 0.10840650f, 0.01722071f, -0.22035748f, -0.15504944f, -0.01985377f, -0.10492223f, 
    -0.05577778f, -0.08123789f, -0.07815618f, 0.04690911f, -0.09972271f, -0.05456880f, -0.08899679f, -0.15467763f, 
    -0.01344969f, 0.06244799f, -0.04211802f, 0.09296963f, 0.11894432f, 0.13174333f, -0.06809796f, 0.06532374f, 
    -0.05645691f, -0.06644865f, 0.11763801f, 0.35038954f, -0.16859819f, 0.38926229f, -0.10910255f, 0.02581877f, 
    -0.05990756f, -0.04924351f, -0.04637818f, 0.12642695f, 0.18175225f, 0.14070457f, 0.04582804f, 0.06233592f, 
    0.00641924f, 0.08348560f, -0.07569266f, -0.13413899f, 0.04474668f, 0.06852608f, 0.03151025f, 0.16054431f, 
    -0.12132149f, -0.13020192f, -0.10071237f, -0.03535793f, -0.38167191f, -0.13095777f, -0.12014219f, -0.02490910f, 
    -0.12441482f, -0.11165736f, 0.04903445f, -0.26993653f, 0.02536114f, -0.05628470f, -0.02779120f, -0.02310374f, 
    0.05624196f, 0.20892534f, 0.38707921f, 0.05660440f, 0.07165785f, 0.05085845f, -0.00638850f, 0.05204983f, 
    -0.02607840f, -0.03717423f, 0.00294075f, -0.06397378f, 0.05217963f, 0.03207608f, -0.11621759f, -0.16766061f, 
    -0.09271075f, -0.23764960f, 0.03959137f, -0.01764043f, -0.10503887f, -0.07541313f, 0.11846022f, 0.05281666f, 
    -0.10800499f, 0.23187345f, 0.17464612f, 0.04916944f, -0.08695904f, 0.06525828f, -0.05768710f, -0.05673440f, 
    0.17119813f, -0.09473280f, 0.07455946f, 0.09614651f, -0.12257964f, -0.14258762f, -0.21083876f, 0.08498469f, 
    0.10025152f, 0.00760617f, -0.12180358f, 0.07366275f, -0.14656921f, -0.00027093f, -0.17163497f, -0.13908832f, 
    -0.03180942f, -0.03267640f, -0.02109156f, 0.02187647f, 0.24313478f, 0.10047661f, 0.01757602f, -0.03822465f, 
    0.07946869f, 0.04431539f, 0.18178044f, 0.02003914f, 0.00528279f, -0.20048913f, 0.03800317f, -0.04753594f, 
    -0.11390386f, -0.17851065f, -0.08455409f, -0.00020410f, 0.04360722f, 0.02594298f, 0.03323725f, 0.05926192f, 
    0.33631480f, 0.07540131f, 0.05184444f, -0.08494207f, 0.11662281f, 0.03426676f, 0.12818216f, 0.02996176f, 
    0.15122695f, 0.00833065f, 0.13237831f, 0.16491331f, 0.33459175f, -0.03308645f, 0.15669189f, -0.03209184f, 
    -0.20936747f, -0.09021314f, 0.08439416f, 0.11752661f, 0.07912017f, -0.04216351f, 0.16517857f, 0.01168684f, 
    -0.32149452f, -0.19076991f, 0.12533584f, 0.02356593f, 0.15974279f, -0.04158251f, -0.12439464f, -0.02924852f, 
    -0.04752209f, -0.03062465f, -0.05173042f, 0.00916994f, 0.22071043f, 0.08867346f, 0.12026875f, 0.14785096f, 
    0.01128448f, 0.03981851f, 0.00943929f, 0.06105609f, 0.01679873f, -0.04371035f, 0.02790960f, -0.19969049f, 
    -0.35731900f, -0.39913997f, 0.12675305f, 0.00945811f, 0.00572383f, 0.03604399f, 0.06272595f, 0.12035589f, 
    -0.00960465f, 0.06156940f, 0.10694364f, 0.01667670f, -0.02996268f, -0.03381364f, 0.00020710f, -0.01899895f, 
    0.17352828f, 0.13638295f, 0.05679492f, 0.17401639f, 0.24720752f, -0.00745336f, -0.04852982f, 0.10924110f, 
    0.01585156f, 0.05855236f, -0.04115734f, -0.06948701f, -0.04249016f, -0.06198272f, -0.07743101f, -0.01391204f, 
    -0.05439465f, -0.03901122f, 0.04831054f, -0.00892754f, -0.03722517f, 0.04354447f, -0.07361093f, -0.04558652f, 
    0.04793606f, -0.04625938f, -0.01274001f, -0.01985837f, 0.02045064f, 0.03788055f, 0.04536437f, -0.03543019f, 
    -0.06907985f, -0.01320305f, 0.04847968f, 0.01888756f, -0.02703073f, -0.07437075f, -0.06953942f, -0.05619489f, 
    0.04457255f, -0.00541813f, -0.00348294f, -0.01849267f, -0.04648617f, 0.05352584f, -0.07821262f, 0.03327028f, 
    -0.03728554f, -0.06372268f, -0.01598694f, -0.00107434f, -0.01205184f, -0.07623840f, 0.01922955f, 0.05621409f, 
    -0.06145677f, -0.01708256f, 0.00618924f, 0.06206761f, 0.01683554f, 0.03836725f, -0.01753618f, -0.06516353f, 
    -0.04820492f, -0.04167239f, 0.00066904f, -0.02113839f, -0.05262684f, -0.04753982f, 0.05494425f, 0.04491599f, 
    -0.05839982f, 0.01240321f, -0.04280889f, -0.07450198f, 0.05224713f, 0.03435442f, -0.07311986f, -0.06014373f, 
    -0.02822583f, -0.02224227f, -0.01767748f, 0.04410088f, -0.04177083f, 0.04028306f, -0.04671552f, -0.00094864f, 
    0.01973227f, -0.02967228f, -0.00957296f, -0.04662431f, 0.01172097f, -0.03502796f, 0.02266660f, 0.04659465f, 
    0.01524578f, 0.04892424f, 0.01465483f, -0.00474164f, -0.05974393f, -0.03973885f, -0.07724708f, -0.04028110f, 
    -0.01637354f, 0.03375011f, -0.03647571f, -0.06403820f, 0.04212511f, -0.02928133f, -0.00427051f, 0.05641574f, 
    -0.01955977f, 0.00969903f, 0.03413782f, -0.05013467f, -0.01788456f, -0.04550546f, -0.02570975f, -0.00172607f, 
    0.00538471f, -0.00864267f, -0.06627986f, 0.03845688f, 0.00242634f, -0.05595073f, -0.01209497f, -0.04189308f, 
    0.01114171f, -0.02861752f, -0.05907620f, -0.06243137f, -0.05824965f, -0.05725035f, 0.05056671f, 0.06055610f, 
    0.02223689f, -0.01412018f, -0.04376649f, 0.02410527f, 0.03200464f, 0.04390304f, -0.06042428f, 0.04216329f, 
    -0.06566011f, -0.01843656f, 0.01429336f, 0.01061595f, -0.01004282f, 0.03958333f, -0.07209026f, -0.04632931f, 
    -0.06823894f, 0.00257824f, 0.04443231f, 0.02452719f, -0.07037444f, -0.05749159f, 0.04886548f, -0.05023776f, 
    -0.00174096f, -0.01780538f, -0.00952967f, 0.01753654f, 0.04394592f, -0.02723085f, 0.01338653f, 0.05624114f, 
    -0.00718505f, 0.05723875f, -0.02883544f, 0.01236410f, -0.05810378f, 0.02124077f, 0.03203401f, 0.02708569f, 
    0.02847532f, 0.02973483f, -0.00231898f, -0.04076973f, 0.02085779f, -0.04188491f, 0.02868733f, -0.05024988f, 
    0.01549433f, 0.04597856f, -0.04467446f, 0.04220513f, -0.00607082f, -0.06143057f, -0.07169104f, -0.04770391f, 
    -0.03656961f, 0.01129219f, -0.07069643f, 0.01039739f, 0.00504210f, -0.02168089f, -0.00361588f, -0.01687957f, 
    -0.04919745f, 0.02601269f, 0.01997130f, 0.00665679f, -0.00299837f, 0.01191226f, -0.02563624f, -0.07934576f, 
    0.05171028f, -0.05896942f, -0.07248480f, 0.02632594f, -0.04754846f, 0.02026025f, -0.04939702f, 0.04157139f, 
    -0.00913906f, 0.04158583f, 0.01585678f, 0.00955286f, -0.04141119f, -0.06057554f, 0.05172161f, -0.03727715f, 
    0.03388612f, -0.00301688f, 0.04847334f, -0.05637952f, -0.04461753f, -0.01187852f, -0.02756045f, -0.01392538f, 
    0.00383036f, 0.01487020f, 0.03610458f, -0.02424055f, -0.01082196f, 0.05704864f, 0.03823356f, -0.06872218f, 
    0.04016314f, -0.00006833f, 0.04900940f, 0.03339461f, -0.01260730f, -0.07259133f, -0.03074210f, 0.00172736f, 
    -0.05405795f, -0.03375854f, 0.01462704f, -0.04058850f, -0.03848122f, -0.03193233f, -0.01247694f, 0.01506005f, 
    0.02777262f, 0.06044985f, 0.04597840f, -0.00257796f, 0.03716872f, 0.04317328f, 0.03274794f, -0.06967193f, 
    0.01657256f, 0.01465495f, -0.00523935f, 0.03768642f, 0.05982053f, -0.04386438f, 0.05536696f, -0.01097591f, 
    0.03142247f, 0.00255440f, 0.01677766f, -0.04549368f, 0.04570681f, 0.01220927f, 0.02915092f, 0.05336336f, 
    0.06081377f, -0.01477342f, 0.01305690f, -0.00462875f, 0.00490834f, -0.04447757f, -0.02139620f, -0.07110032f, 
    -0.07278425f, -0.07821678f, -0.07682859f, -0.00624280f, 0.04884170f, -0.02080019f, 0.03886154f, -0.00421942f, 
    0.03217183f, -0.04719317f, 0.01559177f, 0.00692114f, -0.06834074f, -0.05544839f, -0.06501100f, -0.02220437f, 
    0.00320072f, -0.07446723f, -0.05743060f, 0.05223649f, -0.05483583f, -0.05129762f, 0.00444456f, -0.06840822f, 
    -0.01652681f, -0.01107656f, 0.00812728f, -0.00339640f, -0.07090265f, -0.00875448f, -0.04677382f, -0.00807994f, 
    -0.06284209f, -0.06286482f, 0.06069653f, 0.04849751f, 0.04952433f, -0.03465423f, 0.04036538f, -0.03466221f, 
    -0.01579645f, -0.00967784f, -0.07681838f, 0.02878436f, -0.05312455f, -0.00384604f, 0.04585272f, -0.04680139f, 
    -0.02099238f, 0.05578207f, 0.04383022f, -0.00578913f, 0.04334487f, 0.04352107f, 0.02249214f, -0.06759582f, 
    -0.02622754f, -0.01959093f, 0.02230795f, -0.05083766f, -0.05045924f, -0.00049113f, -0.04325392f, -0.01046582f, 
    -0.00517525f, 0.01811552f, 0.00004550f, 0.03687889f, -0.06037497f, -0.05404389f, -0.02020227f, 0.04573757f, 
    -0.04144799f, -0.00994791f, -0.07408533f, 0.01342236f, -0.02139044f, 0.00160148f, -0.00854711f, 0.05882356f, 
    -0.02607621f, -0.02632788f, -0.00673819f, -0.04849067f, 0.04846704f, 0.03660096f, -0.07336334f, -0.07410120f, 
    -0.01925947f, -0.06400838f, -0.03192400f, -0.03243106f, 0.05182132f, 0.02060863f, -0.06859110f, -0.06973326f, 
    0.06743929f, -0.02487680f, -0.07488788f, 0.00196891f, -0.01573181f, 0.05845454f, -0.01339359f, -0.03102179f, 
    -0.00422832f, -0.02671979f, 0.14553963f, 0.12202571f, 0.05128286f, -0.04091351f, 0.07109468f, -0.00739382f, 
    -0.17277800f, -0.02859258f, 0.01032098f, -0.06346654f, -0.46054325f, 0.16331759f, -0.05540015f, 0.18261233f, 
    0.37021664f, -0.07233126f, -0.03051249f, -0.10056749f, -0.10097510f, 0.09272210f, -0.18614440f, 0.01844365f, 
    -0.14658368f, 0.06954216f, 0.29816240f, 0.10284204f, 0.00216900f, -0.00819128f, 0.03576424f, 0.15102561f, 
    -0.04973472f, 0.13073221f, 0.21974424f, 0.09252462f, -0.11312640f, -0.04816736f, -0.14353035f, -0.08249667f, 
    0.07365704f, 0.01141683f, 0.01179445f, -0.08454988f, -0.01444391f, -0.16690518f, -0.06723931f, -0.05040187f, 
    0.56337363f, -0.04605372f, -0.08548475f, -0.01275714f, 0.00517580f, 0.31282786f, 0.07908171f, 0.06642336f, 
    0.02349414f, -0.08672749f, 0.01346302f, -0.08453656f, -0.14906025f, -0.08389091f, 0.01854873f, 0.02809546f, 
    0.00982408f, 0.00859656f, -0.10744834f, -0.04672694f, -0.01423518f, 0.06421703f, 0.15300265f, 0.26106486f, 
    -0.32514015f, 0.00497236f, 0.10971943f, 0.03259218f, -0.00076406f, 0.05418430f, -0.02872121f, 0.08966735f, 
    -0.04228028f, 0.03274772f, 0.08192663f, -0.02834120f, 0.08515818f, -0.22165957f, -0.07441488f, 0.10101269f, 
    -0.07137418f, 0.07609449f, -0.01935077f, -0.02472023f, 0.08007044f, -0.00608881f, -0.00274658f, 0.17770596f, 
    -0.11058611f, -0.15897608f, 0.42331016f, -0.06651569f, 0.02942945f, 0.04354651f, 0.00546766f, 0.05115634f, 
    -0.06795752f, 0.21700728f, -0.00877147f, -0.01825835f, -0.16601837f, 0.02313613f, -0.00164607f, -0.06689171f, 
    0.12721257f, -0.17779361f, 0.06157390f, 0.03597526f, 0.09440830f, 0.08226357f, -0.22816816f, 0.05965160f, 
    -0.01912139f, -0.10719357f, 0.05270017f, 0.10510512f, 0.01074480f, 0.08942283f, 0.11159179f, -0.19264482f, 
    0.01571480f, -0.03262206f, -0.08922192f, 0.03820466f, -0.22797792f, 0.02196457f, -0.19376159f, 0.19328073f, 
    -0.15321235f, -0.08080795f, 0.13765067f, 0.09790593f, 0.00769500f, -0.05290151f, 0.09205182f, -0.04876065f, 
    -0.11772804f, 0.14155008f, 0.23397039f, 0.16799612f, 0.10836328f, 0.06066380f, 0.04147261f, -0.05417092f, 
    -0.05970375f, -0.08664539f, -0.09778283f, -0.00567990f, 0.22317937f, 0.16714177f, 0.05096937f, -0.00130753f, 
    0.12187748f, -0.00260351f, 0.11311377f, 0.02177735f, 0.17106958f, 0.06615182f, 0.14494003f, -0.05894845f, 
    -0.15622732f, 0.04920568f, 0.12806240f, 0.27823299f, 0.01371754f, -0.18831737f, 0.07026426f, 0.17755526f, 
    -0.08396178f, 0.04086022f, -0.05239532f, 0.13896857f, -0.06538753f, -0.03317297f, 0.07824349f, 0.13244228f, 
    0.02818049f, 0.03771716f, -0.17890920f, 0.00461400f, -0.00240552f, -0.03771979f, -0.16435671f, -0.11050514f, 
    -0.07687264f, -0.03288094f, -0.07523827f, -0.06878527f, 0.05472365f, 0.14138098f, 0.09240197f, 0.15635149f, 
    0.02788996f, -0.05885021f, -0.13641746f, 0.15398949f, -0.27698213f, 0.10541535f, -0.13679887f, 0.25547197f, 
    0.18551858f, -0.04957759f, 0.02812173f, 0.13685842f, 0.01897876f, 0.00677293f, -0.13846315f, 0.17017548f, 
    -0.16872545f, 0.04781413f, 0.10033240f, 0.01653346f, -0.12757258f, -0.04096393f, 0.13166955f, 0.06437138f, 
    0.21801412f, -0.03801730f, 0.18836537f, 0.00577415f, 0.01918511f, -0.06398113f, -0.00777745f, -0.04023201f, 
    -0.01625394f, 0.04896312f, -0.06542923f, -0.04294155f, -0.07226346f, -0.03367695f, -0.01232619f, -0.04889497f, 
    -0.05454418f, -0.03079861f, 0.28017423f, 0.14961867f, 0.00615013f, 0.08942799f, 0.01720923f, 0.04788391f, 
    -0.04857031f, 0.04560504f, -0.04122230f, -0.03632240f, -0.06089321f, -0.08929470f, 0.04699568f, -0.00493603f, 
    0.01138276f, -0.24701993f, -0.04905307f, -0.15018262f, -0.02117887f, 0.12488325f, 0.10924175f, -0.00582076f, 
    0.06769097f, -0.01345308f, 0.10973356f, 0.01666828f, -0.05690301f, -0.05018134f, 0.02919529f, -0.01901769f, 
    0.02085397f, -0.01563286f, -0.07704078f, -0.11178608f, 0.19346674f, 0.20483963f, -0.00130048f, 0.06626341f, 
    0.08160312f, -0.01556913f, -0.05947874f, -0.02766099f, -0.00352804f, -0.12720358f, -0.00975639f, 0.22388098f, 
    0.17407480f, -0.14031993f, -0.22958083f, 0.13359657f, 0.13874133f, -0.04406084f, 0.02958120f, 0.00491939f, 
    0.30482897f, -0.06732129f, 0.08100339f, 0.04148611f, 0.04578440f, 0.03578084f, 0.02185306f, 0.00633133f, 
    -0.02625409f, 0.03425262f, 0.03122745f, 0.01785221f, 0.04062751f, 0.27928561f, 0.05898463f, -0.04537449f, 
    0.16458374f, -0.01062839f, -0.22296800f, 0.17246960f, 0.15948790f, -0.05266318f, 0.11869908f, 0.04123184f, 
    -0.06354974f, 0.09562136f, 0.10013169f, -0.05780823f, 0.25690639f, -0.39134422f, -0.09492597f, 0.14364739f, 
    0.26184615f, 0.10611612f, -0.04442621f, -0.07775533f, -0.04819831f, 0.09313816f, -0.01724288f, -0.14222957f, 
    -0.15797512f, -0.18192625f, -0.04487834f, -0.10303202f, -0.07533373f, -0.02866704f, -0.02113245f, -0.12566599f, 
    -0.00569418f, 0.04096578f, -0.04151728f, 0.04306404f, -0.04332458f, -0.02046912f, 0.06786627f, 0.08141153f, 
    0.02824596f, 0.09022320f, 0.05272169f, 0.00117589f, 0.06392084f, 0.18345867f, 0.14237759f, 0.04424984f, 
    0.08837952f, -0.23655953f, 0.25407273f, 0.12410832f, 0.09101924f, -0.08527853f, -0.03084868f, -0.03744957f, 
    -0.08284950f, 0.06547537f, 0.10395794f, 0.16125371f, -0.25558913f, -0.25475138f, -0.16140616f, 0.00716290f, 
    -0.05423417f, 0.05244053f, -0.01526583f, -0.00807316f, -0.03150711f, 0.10548162f, 0.06399527f, -0.10136582f, 
    0.00847516f, -0.04922482f, -0.05145252f, -0.10184138f, -0.07909954f, 0.18013151f, -0.00894769f, 0.17202647f, 
    0.18577431f, -0.00381911f, 0.07527728f, -0.00316353f, 0.28312585f, 0.09585895f, 0.08282348f, -0.10165036f, 
    -0.03680729f, -0.05010125f, 0.02183696f, 0.06103060f, -0.00973193f, 0.04947218f, 0.15270658f, 0.07359077f, 
    0.31605151f, -0.05857412f, -0.18556938f, 0.10986216f, 0.08673143f, 0.01506116f, 0.01251700f, -0.13032503f, 
    -0.03125321f, 0.18796653f, -0.17985159f, 0.04340823f, -0.05949559f, -0.17816162f, 0.01339004f, -0.17699344f, 
    -0.15189673f, -0.16062914f, -0.13187292f, 0.02907919f, -0.19652215f, 0.08426930f, 0.02024305f, 0.09195344f, 
    -0.44217768f, 0.09135546f, -0.13462189f, 0.11746912f, -0.13887472f, -0.03413341f, 0.05548394f, 0.11841130f, 
    0.02888551f, -0.03261242f, -0.08394182f, -0.00628616f, 0.28298205f, 0.10518031f, -0.05205498f, 0.00242286f, 
    0.10519685f, 0.20551474f, 0.11988973f, 0.08406772f, 0.01641515f, -0.01584521f, -0.19472398f, -0.04947773f, 
    -0.09857907f, -0.01837423f, -0.16145195f, 0.14518549f, -0.17285107f, -0.07718963f, -0.07741697f, -0.08215334f, 
    0.01187886f, 0.04413572f, 0.00860350f, 0.04574745f, -0.28486219f, -0.01074973f, 0.19911137f, 0.06324225f, 
    -0.01333496f, -0.07200398f, -0.09321298f, -0.01954676f, -0.09397094f, -0.06232749f, -0.16560230f, -0.12159558f, 
    -0.14557475f, 0.28518862f, -0.15062018f, -0.03150360f, 0.03832860f, -0.09874482f, 0.07835157f, 0.01680892f, 
    -0.04956951f, -0.01078555f, 0.05426287f, 0.02412314f, -0.04300363f, -0.10358532f, -0.02342691f, 0.04018552f, 
    -0.18637772f, 0.02180026f, -0.24450397f, -0.15365161f, 0.02930783f, -0.08012598f, 0.21587530f, 0.06780774f, 
    -0.01602503f, 0.01862491f, 0.06258981f, 0.02807259f, 0.14097054f, 0.12299339f, -0.04092716f, 0.20886879f, 
    0.09282071f, -0.00931558f, 0.07123121f, 0.00264290f, 0.01292802f, 0.26656538f, 0.20662846f, -0.21902941f, 
    0.05592960f, 0.08286960f, -0.02134448f, -0.03581117f, -0.03238453f, -0.12853545f, 0.04995589f, 0.15416738f, 
    0.21072641f, -0.12877773f, -0.15415369f, -0.14324841f, 0.08798444f, -0.04252692f, 0.01173214f, 0.20449291f, 
    -0.07966315f, 0.12175808f, 0.03332842f, 0.05712496f, -0.03005254f, 0.08175344f, 0.12596591f, 0.11302839f, 
    0.07559235f, 0.05366788f, -0.03576253f, -0.04702679f, -0.09070546f, -0.03992788f, -0.12406723f, 0.09577256f, 
    0.26798129f, 0.22911245f, -0.00461321f, -0.02111031f, 0.13256872f, 0.10609562f, 0.08719373f, -0.14789653f, 
    -0.04360418f, 0.07593770f, 0.03857199f, 0.04782801f, 0.04519715f, 0.17414819f, 0.03612708f, -0.07805558f, 
    0.10915828f, 0.09030307f, 0.12220519f, 0.15165633f, -0.00443136f, 0.00030508f, 0.14133002f, 0.08273900f, 
    -0.15466918f, -0.00820265f, -0.08038808f, 0.10099515f, 0.18489335f, 0.05035972f, 0.09135495f, 0.03364498f, 
    0.02344109f, 0.00171854f, 0.02536835f, 0.16940898f, 0.04011679f, 0.03085302f, 0.07085408f, 0.04094122f, 
    -0.11093208f, -0.07322232f, -0.03233684f, 0.08981844f, 0.09508771f, 0.24948330f, 0.00097773f, 0.02401117f, 
    -0.06314539f, 0.23879597f, -0.17784947f, -0.17662768f, -0.01499028f, 0.16703828f, 0.00996216f, 0.15631440f, 
    -0.06664105f, 0.00765240f, 0.07078801f, -0.00998813f, -0.11246431f, -0.11154228f, 0.08013503f, 0.04692566f, 
    -0.01493707f, -0.02726698f, 0.10229331f, -0.08640721f, -0.06102474f, 0.00911680f, 0.04568806f, 0.13187148f, 
    -0.18626986f, 0.05887184f, -0.26395178f, -0.12544225f, 0.16254912f, -0.01371963f, 0.16531713f, -0.20453104f, 
    -0.03511529f, -0.03464368f, 0.02124674f, -0.05467856f, 0.07610773f, 0.02200173f, -0.07899322f, -0.14613727f, 
    -0.01992428f, -0.19604288f, 0.18141131f, 0.04217703f, 0.03596366f, 0.03170826f, 0.06254923f, 0.21522550f, 
    -0.01677109f, -0.09739105f, 0.21181063f, -0.05079657f, 0.03713320f, -0.06210843f, -0.02796744f, -0.10823987f, 
    0.09300254f, -0.01527723f, 0.08049880f, -0.03610181f, 0.00695863f, 0.00324627f, -0.01860934f, 0.14610586f, 
    -0.04794355f, -0.03110035f, -0.03315574f, -0.00312158f, -0.06920063f, -0.16700047f, 0.00775233f, -0.16701229f, 
    0.20799068f, -0.03594953f, 0.10761230f, -0.01292652f, 0.06731453f, -0.03900066f, -0.14402944f, 0.03815542f, 
    0.10426816f, 0.19567499f, 0.11262830f, -0.10347120f, 0.06527887f, -0.11406409f, 0.05583694f, -0.00572979f, 
    0.01986260f, -0.13941719f, 0.01177939f, -0.00585601f, 0.04259036f, -0.03541109f, -0.04208138f, 0.12166321f, 
    0.14209126f, 0.06317437f, 0.05072659f, -0.01547864f, 0.09553960f, -0.03652622f, -0.05319188f, -0.02528933f, 
    0.02292498f, -0.00724572f, 0.09696540f, 0.10058727f, 0.24156271f, -0.09082192f, 0.14970963f, -0.10575868f, 
    -0.07096159f, -0.14124961f, 0.02606368f, -0.00116432f, 0.10762317f, 0.06919898f, 0.08258288f, 0.03078208f, 
    -0.03928357f, -0.03304417f, -0.13069560f, -0.10258747f, 0.09531596f, 0.01438051f, -0.13629369f, -0.04421267f, 
    0.10174848f, -0.08310068f, -0.06130542f, 0.00058214f, 0.06130828f, 0.17639749f, -0.08559017f, 0.00834534f, 
    0.00656444f, -0.01212326f, 0.17555694f, 0.03327726f, 0.05400147f, 0.08091674f, -0.05648023f, 0.00573851f, 
    -0.29638651f, -0.45607683f, 0.22303589f, -0.05616699f, -0.08187886f, -0.07797623f, 0.06352922f, 0.02388326f, 
    0.17682417f, 0.18718360f, 0.03226671f, 0.15228015f, 0.07740767f, -0.14913069f, -0.05332118f, -0.21716148f, 
    0.20006794f, -0.05030609f, -0.02498819f, 0.15885350f, 0.00101569f, 0.15039994f, -0.07097997f, 0.12803383f, 
    0.07763616f, 0.01359213f, 0.11586922f, 0.00372018f, -0.02490443f, 0.10909902f, 0.04083993f, 0.04061747f, 
    0.04314138f, 0.08724661f, 0.04532701f, -0.06228649f, 0.18662858f, 0.06614313f, 0.13915829f, -0.09329092f, 
    0.00472868f, -0.01248638f, 0.11361779f, -0.13356860f, -0.04918510f, 0.09444069f, 0.02749379f, 0.04882542f, 
    0.30936182f, -0.16707274f, -0.10671478f, 0.16525419f, 0.10988660f, 0.09646819f, 0.04976198f, -0.01547015f, 
    0.06592693f, 0.00912569f, 0.01693817f, 0.05316079f, -0.14424996f, -0.13298261f, -0.03828085f, -0.22180282f, 
    -0.06740534f, -0.12053628f, -0.01831179f, 0.04501410f, 0.02972010f, -0.00184197f, 0.02101548f, 0.03981685f, 
    -0.18209177f, 0.00297916f, -0.52641940f, 0.06209514f, -0.14033484f, -0.17164619f, 0.07752960f, -0.03067674f, 
    -0.01406015f, -0.05937553f, 0.03674866f, -0.19456089f, 0.15538266f, 0.04136525f, -0.12558931f, 0.07950556f, 
    0.09718977f, 0.28808126f, 0.02947542f, 0.10621551f, 0.09251379f, -0.00115757f, -0.07226690f, 0.02198534f, 
    -0.16614789f, -0.15243256f, -0.16498230f, 0.03202178f, 0.02647383f, 0.04716443f, 0.00613066f, 0.06095377f, 
    0.03062627f, -0.05926116f, 0.05302621f, 0.09796125f, -0.23953275f, -0.14318104f, 0.07937527f, -0.05977117f, 
    -0.09877976f, -0.00084169f, 0.01053836f, -0.12468614f, -0.10498134f, 0.04312056f, -0.08367835f, -0.09079009f, 
    0.05721454f, 0.21379334f, 0.07824062f, -0.18425955f, 0.00346184f, 0.02856107f, -0.00356394f, -0.09575836f, 
    -0.11689702f, 0.09572330f, -0.08294001f, -0.13377358f, -0.10489938f, -0.10052627f, -0.12559552f, -0.05307657f, 
    -0.04134429f, -0.08354320f, -0.01875137f, -0.06754731f, 0.02564134f, -0.14362927f, 0.02839336f, 0.04896232f, 
    -0.23275423f, 0.09866501f, 0.13428439f, -0.04605212f, 0.00864402f, 0.05370203f, 0.03629551f, 0.01514116f, 
    0.05995085f, 0.05680519f, -0.07640599f, -0.03196032f, -0.09042285f, 0.14816187f, 0.21750817f, -0.14008611f, 
    -0.04061443f, 0.02487369f, 0.06226154f, 0.06973801f, -0.01888410f, -0.06492933f, 0.09205135f, -0.07752167f, 
    0.38091543f, 0.27301592f, 0.18708646f, 0.19892101f, 0.05388385f, 0.11133669f, 0.07629951f, 0.25259879f, 
    0.02052176f, 0.07109614f, 0.04230619f, -0.02045917f, 0.05186623f, 0.09001828f, 0.09952535f, 0.08556953f, 
    -0.00320673f, -0.04630432f, -0.01657285f, 0.02529071f, 0.00517002f, -0.15700717f, -0.12287083f, -0.12252533f, 
    0.30354887f, 0.27467987f, -0.20064782f, -0.14979306f, 0.05143021f, 0.06735358f, 0.01069286f, -0.04658544f, 
    0.08053280f, 0.07204638f, 0.03464122f, 0.01637999f, 0.14056802f, 0.30805299f, 0.18568252f, 0.08411480f, 
    0.02981436f, 0.06458873f, 0.05153606f, 0.04270234f, -0.04589055f, -0.04200675f, 0.04678551f, 0.10591231f, 
    0.07362392f, -0.09806569f, 0.12427045f, 0.23666458f, -0.03571449f, -0.09019521f, 0.02618971f, -0.01211410f, 
    -0.06353913f, 0.02626063f, 0.03281840f, 0.06533152f, -0.38321322f, 0.49599010f, -0.03002003f, 0.01678128f, 
    0.18716572f, 0.02677668f, 0.11633877f, -0.04069593f, -0.22596028f, 0.03933855f, 0.02038168f, 0.13117278f, 
    -0.17634206f, 0.03292016f, 0.00744463f, 0.31845623f, 0.03254890f, -0.00240024f, 0.16326635f, -0.04024195f, 
    0.07490577f, 0.10210779f, -0.01574505f, -0.00088467f, -0.14337732f, 0.00348921f, -0.05258965f, -0.23153462f, 
    -0.13014777f, 0.00866005f, -0.13925400f, -0.15453355f, -0.07843447f, -0.07571925f, -0.08743657f, -0.14545934f, 
    0.05065228f, 0.05443493f, 0.50526947f, -0.21420336f, -0.01717264f, -0.07486917f, -0.08936641f, 0.13661516f, 
    0.00393737f, 0.00897252f, 0.08537876f, 0.03422610f, -0.10694657f, -0.20954618f, -0.23233312f, 0.20017031f, 
    0.01414845f, 0.03544956f, -0.04105223f, 0.02813542f, 0.02738800f, 0.03196087f, 0.05913239f, 0.02298690f, 
    -0.18802114f, 0.45270893f, -0.01501642f, 0.00914687f, -0.01426318f, -0.08216029f, -0.04401786f, 0.05993708f, 
    0.02879719f, 0.03312340f, 0.12866402f, -0.02062117f, 0.06752834f, 0.09576112f, 0.08038126f, -0.13463125f, 
    -0.13290979f, -0.00746261f, -0.06707609f, 0.07104734f, 0.02291297f, 0.11455020f, 0.02921478f, 0.16271432f, 
    0.06764607f, 0.10869553f, 0.03511848f, -0.28213581f, 0.02695340f, 0.16917112f, 0.00719414f, 0.17426066f, 
    -0.18301338f, 0.17078455f, -0.09362163f, 0.03165842f, -0.19209290f, -0.00734391f, -0.24139611f, -0.18844855f, 
    -0.07154671f, -0.08663331f, 0.00921991f, 0.04877752f, 0.05461583f, 0.03194978f, 0.07484209f, -0.08076815f, 
    0.15034927f, 0.08780428f, -0.17025590f, -0.19106254f, -0.13332997f, 0.02779343f, 0.06874809f, -0.02444388f, 
    0.06952795f, 0.07176928f, 0.03097188f, 0.13418572f, 0.46067131f, 0.05323333f, -0.22484517f, -0.03679419f, 
    0.12782091f, -0.02406129f, 0.09627828f, 0.13724822f, -0.02926245f, 0.02882194f, 0.18360579f, 0.01267235f, 
    -0.37690082f, -0.20844395f, 0.22377974f, 0.40114483f, 0.18800721f, 0.09344386f, 0.12592383f, 0.03593048f, 
    0.06900378f, 0.04742112f, 0.01208029f, 0.03874980f, -0.08314542f, -0.01054540f, -0.12783684f, 0.17272924f, 
    0.01052067f, 0.14555289f, 0.04589243f, 0.13824810f, 0.00571691f, 0.10386495f, 0.03881695f, 0.04453475f, 
    0.09232987f, 0.11550274f, -0.23155363f, 0.22198111f, 0.03184323f, -0.01901266f, 0.08489005f, 0.11018772f, 
    0.02791856f, 0.02565635f, -0.05425173f, 0.09475028f, -0.17972356f, -0.01579051f, -0.06934681f, 0.16614753f, 
    -0.11782116f, 0.08748557f, -0.20929785f, -0.06054241f, -0.04620849f, 0.12106920f, 0.08723639f, -0.00636490f, 
    -0.02154263f, -0.08515234f, -0.10887425f, -0.01173959f, 0.19934754f, -0.04331499f, 0.02775450f, 0.01449389f, 
    -0.33660603f, -0.09314985f, -0.13612385f, -0.04000862f, 0.15506545f, -0.04313046f, 0.21676631f, 0.06835192f, 
    0.02596519f, -0.12950601f, -0.16114865f, 0.00174206f, 0.01760832f, 0.11834191f, -0.12480276f, -0.00131097f, 
    -0.10217115f, 0.17538592f, 0.22256507f, -0.05988971f, 0.02443992f, -0.02607639f, -0.05440458f, 0.04912697f, 
    -0.01804392f, 0.00090553f, 0.23739086f, 0.25768098f, -0.13234365f, -0.18191406f, -0.03056805f, 0.27658913f, 
    0.29367784f, -0.01497993f, 0.14654961f, -0.11148969f, -0.02335742f, -0.17086607f, -0.02924826f, -0.03375407f, 
    -0.20627338f, -0.15526214f, 0.05525529f, 0.01235035f, 0.13035606f, 0.21359940f, 0.04765183f, -0.08567305f, 
    0.01411278f, -0.18794724f, -0.11400151f, -0.09709010f, 0.00787476f, -0.15037911f, -0.00450608f, 0.09571065f, 
    0.02605596f, -0.11566239f, -0.01255183f, -0.03062539f, 0.11334451f, -0.01311293f, 0.15816951f, 0.19761160f, 
    -0.13655533f, -0.15452583f, 0.27707660f, -0.14648023f, 0.05579673f, 0.00087931f, -0.08797286f, -0.08101676f, 
    0.12153291f, 0.04532407f, 0.05170473f, -0.00359862f, 0.03892041f, -0.07111125f, -0.14988735f, 0.29526645f, 
    0.12702639f, 0.04692974f, 0.13645165f, -0.02548143f, 0.22492108f, -0.09794344f, 0.09937745f, 0.29415831f, 
    0.01413687f, -0.07116200f, 0.28665936f, 0.22507858f, -0.00633492f, 0.05099036f, -0.01700011f, 0.00967182f, 
    0.05795509f, -0.01456180f, 0.02484748f, 0.05288365f, 0.04409863f, -0.37239760f, 0.07577513f, -0.01712648f, 
    -0.07774273f, -0.09445164f, -0.02796190f, 0.09693689f, 0.07772227f, 0.11166605f, -0.03620344f, 0.08218332f, 
    0.02697875f, -0.02387275f, 0.03477129f, 0.20429201f, 0.00782290f, 0.00470036f, 0.02497217f, -0.17716745f, 
    -0.18214601f, -0.15845485f, -0.06698534f, -0.12471000f, -0.14278856f, -0.05199413f, -0.10244564f, 0.00603569f, 
    -0.02807319f, -0.12522216f, 0.03545157f, -0.12039798f, -0.20335299f, -0.08789298f, -0.14587837f, -0.15335114f, 
    -0.35159653f, -0.00832058f, 0.02081579f, -0.04074082f, 0.04801329f, -0.00136804f, 0.09788240f, -0.05344682f, 
    0.06390530f, -0.01951892f, -0.02802684f, -0.13755795f, 0.09326252f, 0.27865472f, 0.06761812f, -0.01601709f, 
    -0.00681184f, -0.14573313f, 0.06821592f, -0.01091129f, 0.20477337f, 0.17104957f, 0.10040078f, 0.18522410f, 
    -0.01829825f, -0.11592447f, 0.34981567f, 0.22706594f, -0.16273828f, -0.03879004f, -0.00769315f, -0.01099906f, 
    0.16172422f, -0.07424498f, 0.02612510f, 0.19755313f, 0.00614611f, 0.01756366f, 0.03712604f, -0.05964104f, 
    0.19534685f, 0.17222790f, -0.03252742f, 0.06411825f, 0.11317137f, -0.12029865f, -0.10465671f, -0.06410425f, 
    -0.04833368f, -0.11347873f, 0.03623465f, 0.01336610f, -0.05770695f, -0.10406556f, 0.14417545f, -0.04520616f, 
    -0.00704337f, -0.01502723f, -0.13033886f, -0.00713722f, 0.03436629f, 0.00601654f, 0.16083108f, 0.12033863f, 
    0.17713103f, 0.13980439f, 0.17501782f, -0.03457985f, -0.05628564f, 0.08787659f, 0.05234163f, 0.01053962f, 
    -0.14715880f, 0.10363217f, 0.21886398f, 0.18738106f, -0.15478480f, -0.09439919f, 0.00361209f, -0.12676412f, 
    0.14063430f, 0.15954804f, -0.08346180f, 0.01414127f, 0.10066440f, 0.00134241f, 0.01584260f, 0.02617163f, 
    0.01241005f, -0.01953774f, -0.06272617f, 0.08303080f, 0.00274290f, -0.04809526f, -0.02708181f, 0.03828794f, 
    0.06670130f, 0.00463255f, 0.19678734f, -0.05444770f, -0.07754550f, -0.10024776f, -0.00407512f, -0.02970327f, 
    -0.01780478f, 0.09659629f, -0.06880599f, 0.11531980f, -0.13764141f, 0.11250999f, 0.17883863f, 0.09287612f, 
    -0.04636805f, 0.17643476f, 0.02545303f, 0.14036341f, -0.11235417f, -0.05732582f, -0.10296904f, -0.11685187f, 
    0.37566239f, 0.25165907f, -0.19975846f, 0.11546870f, -0.09444603f, -0.00091068f, 0.02690940f, 0.04206552f, 
    -0.12674618f, 0.15552172f, -0.09728447f, -0.05212678f, -0.05860332f, 0.15118057f, 0.05122740f, -0.06864988f, 
    -0.15923128f, -0.02613680f, -0.01751921f, 0.04021431f, 0.12238660f, 0.13020693f, 0.14714208f, 0.15754886f, 
    -0.22017567f, 0.06853223f, 0.03433088f, 0.12234087f, -0.13608763f, 0.05683344f, 0.13506831f, 0.12547809f, 
    -0.11495032f, -0.05810771f, 0.02532705f, 0.06469541f, -0.04011463f, 0.11193634f, 0.05703034f, 0.08375623f, 
    -0.03531802f, 0.12526205f, -0.04102224f, 0.02797211f, 0.02356378f, 0.12073279f, 0.11692377f, -0.08540858f, 
    -0.17924410f, 0.05076235f, -0.00072996f, 0.01672581f, -0.12481605f, 0.03071463f, 0.01380418f, 0.03285350f, 
    0.02813961f, 0.03074810f, 0.01047483f, -0.01386612f, -0.20201866f, -0.00657915f, -0.15274923f, 0.18565381f, 
    0.15094133f, 0.21238248f, -0.00700585f, -0.00826017f, -0.02321267f, 0.07292972f, 0.00260790f, -0.04923946f, 
    -0.06618590f, -0.13677107f, -0.13853472f, -0.13285965f, -0.15249932f, -0.00835617f, 0.12166085f, -0.16211933f, 
    -0.07191076f, -0.04461146f, 0.04659326f, -0.01115909f, 0.01668973f, -0.24353889f, -0.20854653f, -0.02828245f, 
    0.00420122f, 0.12464076f, -0.10210296f, 0.18804859f, 0.05643709f, 0.26380518f, 0.01230614f, 0.28232056f, 
    0.22379614f, 0.47037292f, -0.11304156f, 0.12331836f, 0.08731779f, -0.04388897f, -0.04719559f, 0.12874353f, 
    -0.18603317f, -0.00140108f, 0.07632378f, -0.06746479f, -0.13982023f, -0.11316106f, 0.01549203f, 0.19359998f, 
    -0.22698218f, -0.08278978f, 0.04234528f, -0.09287059f, -0.22632389f, -0.04876171f, -0.06047047f, -0.04282832f, 
    -0.13536093f, -0.06875107f, -0.14583372f, -0.16745842f, 0.11419342f, 0.11725201f, 0.00337602f, 0.04525253f, 
    -0.07918486f, 0.02083852f, -0.01797799f, 0.14819671f, 0.03394797f, -0.08122861f, -0.16646984f, 0.22258131f, 
    0.04060800f, -0.03265785f, 0.04800420f, -0.03675848f, 0.15231343f, 0.01937804f, 0.02026195f, -0.07810931f, 
    0.20381898f, -0.06376833f, -0.16726328f, -0.24704081f, -0.08961865f, 0.05970213f, 0.08150610f, 0.07641608f, 
    -0.05946828f, 0.04848092f, 0.04250439f, 0.08832826f, 0.05947568f, -0.02799085f, -0.00432304f, 0.13525988f, 
    -0.00645843f, -0.01602039f, -0.08095193f, 0.02094306f, -0.00034660f, 0.03023413f, -0.03685529f, -0.04252756f, 
    0.55427277f, 0.05340127f, 0.10738644f, 0.31670266f, -0.05212637f, 0.00948731f, -0.13416545f, -0.00166196f, 
    -0.09710644f, -0.11546165f, -0.04628272f, 0.08144536f, -0.02916474f, 0.32484195f, 0.14776801f, -0.19403973f, 
    -0.02536278f, -0.07480404f, 0.07332141f, 0.06533053f, -0.00746487f, 0.04627423f, 0.15156028f, 0.10128514f, 
    0.33805528f, -0.10726032f, 0.13539784f, 0.26974738f, -0.09593893f, 0.00573284f, -0.01095096f, -0.05383844f, 
    -0.02268302f, -0.08330951f, -0.05745126f, -0.04637672f, 0.04867670f, -0.01955944f, 0.03838704f, 0.14171661f, 
    0.07287275f, -0.05439348f, 0.03366737f, -0.02135146f, 0.07702493f, 0.13597350f, 0.09306326f, -0.05188837f, 
    -0.05311959f, -0.24051462f, -0.18886977f, 0.02408593f, 0.06322795f, -0.07740078f, -0.03729014f, -0.17307584f, 
    0.09558590f, 0.00072832f, -0.00129003f, -0.04747541f, -0.01549058f, 0.05788533f, 0.04928578f, 0.02326237f, 
    0.01466520f, -0.07587219f, -0.01080594f, -0.12639101f, -0.04687675f, -0.00578192f, -0.07427784f, 0.11007832f, 
    -0.02481352f, -0.09027154f, 0.07411393f, 0.15728442f, 0.17045173f, -0.03072921f, -0.02250171f, -0.07578446f, 
    0.04711903f, -0.05600604f, -0.08858105f, 0.05821959f, -0.33275878f, 0.11107235f, 0.29100627f, 0.19884136f, 
    -0.06324894f, 0.09918454f, -0.15485169f, -0.01808324f, -0.01802312f, 0.00105410f, -0.15079141f, 0.06882784f, 
    0.14516304f, 0.12836942f, 0.09996549f, -0.22270046f, -0.02182981f, -0.01007453f, -0.09501680f, -0.00824982f, 
    -0.02251002f, 0.13174480f, -0.02890746f, -0.06812010f, 0.11372846f, -0.15370956f, 0.20253478f, 0.08474371f, 
    0.12063459f, 0.09582423f, -0.02936611f, 0.03941361f, 0.15526859f, -0.10689724f, 0.00143503f, -0.03249972f, 
    -0.20039666f, -0.09264583f, -0.19686288f, -0.30164239f, -0.05394285f, 0.05711088f, -0.01905533f, 0.00186767f, 
    0.07428405f, -0.08503062f, 0.04877260f, -0.07461923f, 0.10560816f, 0.09721320f, 0.26134807f, -0.00317763f, 
    0.13053282f, -0.00021681f, 0.11365177f, 0.09079599f, 0.09239726f, -0.00761255f, 0.06975821f, -0.03020404f, 
    -0.09449846f, 0.14706805f, -0.22674744f, -0.05909484f, 0.10417225f, -0.08580115f, 0.01198212f, 0.19166543f, 
    -0.13656867f, -0.12596400f, -0.19152193f, -0.15076271f, 0.02150374f, -0.12936348f, 0.03916426f, -0.06235280f, 
    -0.23649281f, -0.04862145f, -0.05388452f, -0.18558125f, 0.03040205f, -0.15749368f, -0.17747127f, -0.14859983f, 
    0.21237090f, 0.00222119f, 0.13094941f, -0.09284037f, 0.12438433f, 0.01863922f, 0.09478461f, 0.13016190f, 
    0.09418326f, 0.00518286f, 0.18460000f, 0.00666121f, 0.03658711f, -0.01521304f, 0.26455638f, 0.03771224f, 
    0.39233300f, 0.01902296f, 0.06940039f, -0.03410728f, 0.07503735f, -0.28806850f, -0.16236778f, -0.09308238f, 
    -0.05912162f, -0.04080084f, -0.12720792f, 0.02073736f, 0.28591841f, 0.08683952f, 0.08344145f, -0.10875990f, 
    -0.08516909f, -0.15086818f, 0.01408796f, -0.26081643f, 0.19151427f, -0.05870478f, 0.05620050f, 0.19722202f, 
    0.17431737f, 0.04002643f, 0.09963318f, 0.05239788f, -0.05627099f, 0.00456507f, 0.12134071f, 0.22770612f, 
    0.00834722f, -0.13510136f, 0.29551899f, -0.18322349f, 0.15935728f, 0.01555236f, 0.03583182f, -0.08102058f, 
    -0.10407275f, 0.12031334f, -0.02556202f, -0.07580854f, 0.11850512f, -0.12225700f, -0.08060011f, 0.14023699f, 
    0.18950847f, 0.06077504f, 0.17546178f, -0.08543772f, 0.16171521f, -0.10613846f, 0.23950164f, 0.34502926f, 
    0.12380783f, -0.08429472f, -0.13635772f, -0.08720903f, 0.02274950f, 0.02022746f, -0.22397375f, -0.12984520f, 
    0.19822441f, -0.03512656f, -0.00378955f, -0.14653724f, 0.26671535f, -0.17120562f, 0.14194079f, 0.07286863f, 
    0.00133861f, 0.02539192f, 0.01211427f, -0.06420192f, -0.06519855f, 0.03613165f, -0.14304826f, 0.00635359f, 
    -0.10097486f, 0.06660487f, 0.07536341f, 0.10552669f, -0.02118429f, 0.02105059f, -0.19491129f, -0.21743305f, 
    -0.27093259f, -0.01519519f, -0.21332049f, -0.23135051f, 0.12292942f, -0.01902788f, -0.06669274f, 0.00920956f, 
    0.15062368f, -0.10790056f, 0.09717552f, -0.34015539f, -0.08923385f, -0.22551081f, -0.05336004f, -0.20608322f, 
    0.29607400f, 0.39443287f, 0.13677712f, 0.17539234f, -0.06783316f, 0.08355568f, 0.17092364f, 0.16091701f, 
    0.09323676f, 0.07832443f, -0.10757104f, -0.14760943f, -0.04014206f, 0.30194890f, 0.31931144f, -0.11616730f, 
    -0.06329302f, -0.12099084f, 0.16499546f, -0.11884528f, 0.16302708f, 0.08374316f, 0.19990931f, -0.00390445f, 
    0.21037073f, -0.11594278f, 0.12523709f, 0.05407057f, -0.17753598f, 0.01295385f, -0.18746695f, -0.12981044f, 
    0.08903474f, -0.05472443f, -0.03836937f, 0.18961008f, 0.19160350f, 0.13453774f, 0.14108236f, 0.00614096f, 
    0.15783747f, 0.01769241f, -0.09352734f, 0.12080596f, -0.08013522f, -0.10153104f, -0.09083475f, -0.09684696f, 
    -0.01860087f, -0.09354538f, -0.31691194f, -0.01432407f, 0.04153005f, -0.11153013f, -0.06353299f, 0.08229888f, 
    -0.01741579f, -0.06528825f, 0.01299111f, 0.07020646f, 0.16346730f, 0.41234142f, 0.00519403f, -0.29975548f, 
    -0.08938626f, -0.02374031f, 0.02333906f, 0.08193235f, -0.08308623f, 0.08427998f, 0.02657145f, 0.02999264f, 
    0.02508891f, -0.00530198f, -0.10566126f, 0.14516851f, 0.06526349f, -0.02097440f, 0.12261079f, 0.05402902f, 
    0.04493167f, 0.10814040f, -0.05901138f, 0.01492172f, 0.04330077f, 0.10965104f, -0.03608287f, -0.00319592f, 
    0.04408284f, -0.16302714f, -0.03263748f, -0.01200087f, -0.17149526f, -0.07052109f, -0.12045293f, -0.02016789f, 
    -0.36281070f, 0.08900915f, 0.33156836f, -0.05391371f, 0.12337079f, -0.32418755f, -0.06810696f, -0.00389095f, 
    0.15175065f, 0.00143808f, 0.00795483f, 0.07974503f, 0.23076794f, -0.15384386f, 0.01392421f, 0.12215459f, 
    0.06264373f, -0.01952658f, 0.10001378f, -0.03110561f, 0.07009834f, -0.01811145f, 0.06190562f, 0.01706818f, 
    -0.15040368f, 0.28804147f, 0.20054266f, -0.03469894f, 0.16685686f, -0.26528254f, -0.06767152f, -0.28808320f, 
    -0.06041586f, 0.16106261f, 0.18379597f, -0.05275863f, -0.00847287f, -0.00847664f, 0.07664233f, 0.10794322f, 
    -0.02357160f, -0.12637080f, -0.10965297f, 0.09011389f, 0.07753088f, 0.04528154f, 0.03280023f, 0.09594934f, 
    0.20734692f, 0.13999677f, -0.44321632f, -0.20077713f, 0.03738262f, 0.18987478f, -0.03760414f, 0.25453565f, 
    -0.05938696f, -0.13038322f, -0.13084106f, 0.03517371f, 0.08495621f, -0.07217877f, 0.00459376f, -0.16059443f, 
    -0.16063085f, 0.04994841f, 0.10277565f, -0.12697931f, 0.09740651f, 0.00110503f, 0.12828435f, -0.11194644f, 
    0.08919053f, 0.08958277f, -0.00266156f, -0.26046878f, -0.34723261f, 0.06609651f, -0.10149437f, 0.10790163f, 
    -0.15344027f, -0.07022014f, 0.12045570f, -0.21844062f, 0.43554065f, -0.01085905f, 0.02461691f, -0.13580289f, 
    0.22372927f, -0.10678698f, -0.09528559f, -0.13750315f, -0.07214909f, -0.05907784f, -0.05829881f, -0.13275571f, 
    -0.34975487f, -0.18578899f, 0.12308685f, 0.25149015f, 0.07615706f, 0.02583665f, 0.11493620f, 0.06987127f, 
    0.03043790f, -0.02720061f, 0.05223231f, -0.01490205f, -0.14448319f, 0.11963970f, 0.04757147f, 0.19337437f, 
    -0.09083007f, -0.03443027f, 0.14616382f, -0.03653951f, -0.02254108f, 0.06875398f, -0.00857458f, 0.13972804f, 
    0.30147368f, -0.27230838f, 0.19096804f, -0.01359004f, 0.02833590f, 0.21223307f, -0.07544510f, 0.01020891f, 
    0.10764425f, 0.00873321f, 0.05592360f, 0.08043190f, -0.01240698f, -0.00204453f, -0.14143273f, 0.00114341f, 
    0.12952627f, 0.02823169f, 0.03182798f, 0.04299565f, 0.05361564f, 0.02080928f, -0.05039312f, -0.07461837f, 
    -0.14681806f, -0.06973410f, -0.11427563f, -0.04216330f, 0.18711187f, -0.00028957f, 0.18945318f, -0.04767090f, 
    -0.05586848f, 0.06699609f, -0.06777035f, -0.00404023f, 0.15317632f, -0.34900913f, 0.09109698f, 0.18612312f, 
    -0.00663521f, 0.01544477f, -0.15472530f, -0.09904041f, 0.09333689f, 0.15066634f, -0.03399320f, -0.07287244f, 
    0.00776172f, 0.17603697f, -0.03088809f, -0.37167951f, -0.02208934f, 0.02858956f, -0.15699978f, 0.14826667f, 
    0.12840572f, 0.08605628f, 0.10923232f, 0.09133073f, 0.03391727f, -0.12913299f, 0.08143563f, 0.11255500f, 
    0.10936114f, -0.03351684f, -0.01168186f, -0.08467906f, 0.11444637f, -0.00936981f, -0.00565068f, -0.00997733f, 
    0.11557761f, -0.01761310f, -0.54866964f, 0.18542378f, 0.13309634f, 0.15427698f, 0.23818694f, -0.14439134f, 
    -0.00499796f, -0.03373159f, -0.07282784f, 0.02077275f, 0.17103203f, 0.09211078f, 0.09971493f, -0.28039330f, 
    0.01935961f, 0.03500787f, 0.14310792f, -0.05967776f, -0.08698417f, -0.03057974f, 0.16577157f, 0.11497393f, 
    0.06217014f, -0.35367167f, 0.25942761f, -0.09488715f, 0.00750091f, 0.00380606f, 0.01286349f, -0.00358063f, 
    0.06141891f, 0.06006796f, 0.03873252f, -0.01654764f, 0.07688657f, -0.02133200f, -0.00630509f, 0.10775144f, 
    0.01606725f, -0.01060080f, 0.13694739f, 0.06356563f, 0.05775534f, -0.11143457f, 0.12273222f, -0.05126493f, 
    0.01940576f, -0.06412304f, 0.27726114f, 0.17627379f, -0.00651540f, -0.13567899f, -0.14627728f, -0.03638076f, 
    0.06934157f, 0.02392423f, 0.05754694f, 0.00186818f, 0.05778536f, -0.10876358f, 0.10221992f, 0.11862186f, 
    -0.05690918f, -0.10695486f, -0.03879016f, -0.06224422f, 0.09215605f, 0.05880732f, -0.06880349f, 0.13497505f, 
    -0.14590648f, -0.00041463f, 0.22495233f, 0.09434634f, 0.01009885f, 0.10075735f, -0.04966590f, -0.07762212f, 
    0.08523866f, -0.11223152f, -0.01952567f, 0.13672653f, -0.36463025f, 0.07973894f, 0.16744936f, 0.16332935f, 
    -0.12928343f, -0.11330687f, 0.15453434f, 0.02467547f, 0.04040304f, -0.03302704f, -0.11874641f, 0.07427794f, 
    0.09214526f, 0.11260977f, -0.13635856f, -0.23524795f, 0.11197089f, 0.05882362f, -0.03936654f, -0.12456625f, 
    0.02191573f, -0.07732362f, -0.01354942f, -0.01371054f, 0.11796225f, 0.16155785f, 0.07498068f, -0.19398996f, 
    0.12954772f, 0.04790442f, 0.08856748f, 0.04863011f, 0.05842140f, 0.08331314f, 0.02333643f, -0.09906935f, 
    -0.37798932f, -0.13762426f, 0.27132362f, -0.06056928f, -0.17294690f, -0.08741640f, -0.15637650f, -0.00113538f, 
    0.10985772f, 0.02241730f, 0.11675692f, 0.13645419f, -0.05943063f, -0.09867315f, 0.06560428f, -0.22769502f, 
    0.14930786f, 0.06021003f, -0.07382803f, 0.12448957f, 0.03217623f, -0.04041260f, -0.04976979f, 0.01965906f, 
    -0.02418207f, 0.00655778f, 0.04138257f, 0.04032381f, -0.05891234f, -0.06385845f, -0.01383121f, -0.06426862f, 
    0.02736291f, 0.00821900f, 0.01890177f, -0.05703803f, -0.06269380f, -0.01972601f, 0.03007761f, 0.03628832f, 
    0.03997055f, 0.02679646f, -0.00616122f, -0.03228131f, -0.07019220f, 0.04899619f, -0.07166862f, 0.05015513f, 
    0.01440296f, -0.00324642f, -0.06599107f, 0.06020128f, 0.03921577f, -0.06051819f, 0.03222575f, -0.02843417f, 
    -0.02964488f, -0.01478703f, -0.02283161f, -0.00328639f, -0.01271329f, -0.01798232f, -0.03476324f, 0.06261978f, 
    -0.01482491f, -0.05693898f, -0.00653310f, -0.06049742f, -0.02254763f, -0.04395128f, 0.00798167f, 0.02989146f, 
    0.05719616f, -0.04649159f, 0.07461020f, -0.02700788f, 0.02800847f, -0.04475093f, -0.05010456f, -0.00023174f, 
    0.03294853f, -0.02415991f, 0.03024317f, -0.07352626f, 0.00333263f, -0.08024789f, 0.01416080f, -0.03619939f, 
    -0.05140459f, -0.05066770f, -0.04825861f, -0.05050970f, -0.05625604f, 0.00834973f, -0.03379802f, 0.01855577f, 
    -0.05603085f, 0.03621405f, 0.05104829f, 0.00433516f, -0.02828726f, 0.01700578f, 0.02857231f, 0.03414558f, 
    -0.05077057f, 0.04679725f, -0.07894278f, 0.06433135f, 0.04907284f, 0.01987395f, 0.06172974f, 0.04482568f, 
    -0.05149024f, 0.00532916f, 0.01024900f, 0.03374531f, 0.03816580f, -0.00984182f, -0.02394680f, 0.03147727f, 
    0.06074999f, 0.02447999f, 0.04443971f, -0.02288812f, -0.03945043f, -0.05505555f, -0.07064069f, 0.05492334f, 
    -0.02608805f, -0.05713504f, -0.04802689f, -0.07577845f, -0.04579238f, -0.05867903f, -0.01511243f, -0.02963300f, 
    -0.00208034f, 0.07018355f, 0.00187149f, -0.03432389f, 0.04114877f, -0.08177053f, -0.00395176f, -0.00561829f, 
    -0.07213457f, 0.00492854f, 0.04520632f, -0.05453648f, 0.00586698f, -0.05304148f, -0.06114697f, -0.00259137f, 
    -0.00448651f, -0.00546133f, -0.06488390f, 0.01818430f, -0.04411010f, -0.00448757f, 0.03780404f, 0.06050316f, 
    0.01840812f, 0.07208937f, 0.05385671f, -0.06596079f, 0.05587465f, 0.01937667f, -0.02990806f, -0.05114461f, 
    -0.05218188f, 0.04768249f, -0.05050935f, 0.02869126f, 0.02120676f, -0.06876869f, -0.07077970f, -0.00113042f, 
    0.03010942f, -0.04887250f, -0.02837954f, 0.02269845f, -0.00151544f, -0.06243216f, 0.05918429f, -0.00598628f, 
    -0.00785703f, -0.01701586f, -0.01694738f, -0.02688308f, -0.01234269f, 0.01264510f, 0.02676442f, 0.06268797f, 
    -0.07502963f, -0.04910334f, 0.00119354f, -0.07047190f, -0.00255151f, 0.00724527f, 0.04329803f, -0.07155426f, 
    -0.04278885f, -0.00239290f, 0.00978139f, 0.05439253f, -0.01122229f, -0.04499271f, 0.03486083f, -0.00464315f, 
    0.04500318f, 0.00845640f, -0.02989948f, 0.03826550f, 0.01183815f, 0.02214891f, 0.01658974f, -0.02368531f, 
    -0.03326882f, 0.10198022f, -0.06484274f, -0.04169187f, 0.18966499f, 0.11192362f, 0.16312018f, -0.09555537f, 
    -0.03758117f, -0.08595997f, -0.15286365f, 0.05558023f, -0.05356930f, -0.60300124f, 0.17024407f, 0.28797805f, 
    0.00307484f, 0.08701374f, -0.02938438f, 0.11108682f, 0.28585491f, 0.01568500f, 0.11438859f, 0.00200619f, 
    -0.00912830f, 0.07038191f, 0.17768621f, 0.00643031f, -0.15113321f, 0.01075126f, 0.03182398f, 0.14190499f, 
    0.19172987f, -0.07099022f, 0.09597258f, 0.02996555f, 0.06327232f, -0.35443068f, -0.32884818f, -0.55096018f, 
    -0.09830684f, 0.08476880f, -0.13202702f, -0.16414644f, 0.16496713f, 0.32470262f, 0.07884872f, -0.04454289f, 
    0.29246011f, 0.03081259f, -0.34399667f, -0.11599129f, -0.12765190f, -0.12397905f, -0.02907142f, -0.12585077f, 
    -0.11092710f, 0.11044113f, -0.06221233f, 0.03201423f, -0.15672588f, 0.31068489f, 0.27742964f, 0.19748408f, 
    0.03511175f, -0.00720081f, 0.11562390f, 0.08556356f, 0.10831790f, -0.06618982f, 0.10189683f, 0.01941643f, 
    0.56053311f, -0.62433600f, 0.20084196f, -0.52653211f, -0.07532521f, 0.11705250f, 0.07041617f, 0.02426447f, 
    -0.03192919f, -0.05076977f, -0.03024040f, -0.08636644f, 0.11463948f, -0.11207299f, -0.43525577f, -0.14276996f, 
    0.05966917f, -0.00999112f, -0.00387607f, -0.13071932f, 0.13188331f, 0.04878099f, 0.12171909f, 0.02304176f, 
    -0.24381804f, -0.24794860f, -0.02481319f, 0.26250690f, -0.21635108f, -0.19203091f, -0.06075500f, -0.01007067f, 
    0.15683688f, 0.01037952f, 0.00580401f, 0.07719400f, -0.23863147f, -0.34454909f, -0.33109426f, -0.26742390f, 
    -0.04585689f, 0.26140046f, -0.22562006f, -0.04727911f, -0.16425507f, 0.17065477f, 0.02863078f, -0.21853112f, 
    -0.17112471f, -0.30328572f, -0.35421640f, 0.08751553f, 0.06430131f, -0.13414639f, 0.12598200f, 0.10550579f, 
    0.05769644f, 0.10892305f, -0.07921388f, 0.17234313f, -0.33745033f, -0.37665698f, -0.11852623f, 0.20867454f, 
    0.03111572f, -0.06310014f, -0.15091836f, 0.00033438f, 0.10264180f, 0.05220863f, -0.00692104f, -0.05439300f, 
    -0.03802445f, 0.21199095f, 0.17800522f, -0.16280586f, -0.05999589f, 0.15918887f, -0.01976207f, -0.21145283f, 
    -0.03321774f, -0.10688560f, 0.01281259f, 0.05301394f, 0.02635951f, -0.00130782f, 0.12778401f, -0.03820699f, 
    0.13046294f, 0.11371166f, 0.07026391f, -0.08220321f, 0.07623798f, 0.13593419f, 0.17617865f, -0.03176703f, 
    0.20758645f, 0.01110846f, -0.03878151f, -0.04785644f, -0.08017365f, -0.02839634f, -0.05467385f, 0.12703183f, 
    0.02165880f, -0.12403631f, -0.05532413f, -0.01459636f, 0.06754983f, -0.05046649f, 0.16242206f, 0.23624539f, 
    -0.10650044f, -0.00238031f, 0.16127296f, 0.22627871f, 0.06783114f, 0.05113536f, 0.07899912f, -0.01664995f, 
    -0.04344101f, -0.06565998f, -0.03685478f, 0.00304646f, 0.05177028f, 0.04788940f, -0.10041159f, 0.00203722f, 
    -0.05150547f, -0.03932932f, 0.07191917f, -0.01495617f, 0.12128223f, -0.20836054f, -0.05258786f, -0.04006515f, 
    -0.04353535f, -0.16141734f, -0.05966004f, -0.02276698f, -0.10269286f, 0.22047088f, -0.09445250f, -0.08853752f, 
    0.19678953f, 0.11382666f, 0.01586616f, -0.27279449f, -0.03359976f, 0.00779356f, 0.09105060f, 0.08915202f, 
    -0.01705434f, -0.03043988f, 0.08174627f, -0.04361873f, -0.09695690f, -0.07517274f, -0.09761946f, 0.08981536f, 
    0.04996728f, -0.11036881f, 0.08576263f, -0.04148836f, -0.07801033f, -0.14351822f, -0.07048158f, -0.04318977f, 
    0.24874495f, 0.16240956f, -0.25565067f, 0.02860798f, 0.11457842f, 0.10426570f, -0.00697936f, -0.06554423f, 
    -0.04434417f, -0.12258548f, -0.08614468f, -0.08775679f, -0.07614859f, 0.03344696f, -0.04962705f, -0.21405225f, 
    0.01800509f, 0.02022731f, -0.00598033f, -0.10526209f, -0.00609304f, -0.10142435f, 0.15563567f, 0.17285737f, 
    -0.24442613f, -0.26069325f, 0.04667776f, 0.03246183f, -0.05472808f, 0.07653184f, -0.07209720f, -0.01739892f, 
    0.03734852f, -0.02502102f, 0.01964469f, -0.02831458f, -0.03766808f, -0.14017554f, -0.08591019f, 0.18962835f, 
    -0.02219327f, 0.01580074f, 0.03076568f, -0.01390841f, 0.04782167f, -0.13096146f, -0.12914214f, -0.10186647f, 
    0.05551580f, -0.16291781f, 0.09172189f, -0.07123069f, -0.00952441f, -0.14485085f, 0.01429194f, -0.02336035f, 
    0.04033101f, 0.24019991f, 0.02324294f, -0.11599901f, -0.05560936f, -0.02502079f, 0.02752424f, -0.01364458f, 
    -0.06747996f, -0.17636082f, 0.05692468f, 0.05590054f, -0.10869954f, -0.18968433f, -0.13353723f, 0.15151452f, 
    -0.07088483f, -0.01287321f, 0.14537308f, 0.06216763f, 0.05195105f, 0.04968746f, -0.05313702f, -0.05978934f, 
    -0.03108264f, -0.12624618f, -0.15503050f, 0.11965426f, -0.14786284f, 0.02456855f, 0.17039490f, 0.07503112f, 
    -0.09169451f, -0.07736026f, 0.01056140f, 0.04769128f, -0.06593683f, -0.10630850f, 0.03380926f, 0.03225088f, 
    -0.00325944f, 0.15226711f, -0.05225533f, -0.04369338f, 0.09410325f, 0.06399827f, -0.01248137f, 0.02606032f, 
    0.03656171f, -0.09373255f, -0.08407380f, -0.04284556f, 0.13879083f, 0.09918708f, -0.04303949f, -0.06043324f, 
    -0.00229900f, -0.00042236f, 0.06233361f, -0.08357242f, -0.00414105f, 0.00010228f, 0.13390970f, -0.13696897f, 
    -0.33290711f, -0.11884240f, 0.17120226f, 0.01318530f, -0.08981832f, 0.02848596f, 0.06489952f, 0.07873334f, 
    0.01866379f, -0.01059542f, -0.03779760f, 0.03983904f, 0.10500737f, 0.05720253f, 0.05794430f, -0.22104438f, 
    0.21592459f, 0.09801589f, -0.15183426f, -0.03656315f, 0.00775628f, -0.06811806f, -0.06785943f, 0.07501923f, 
    -0.08079710f, 0.05821146f, 0.05112794f, -0.13024202f, -0.07939468f, 0.06967163f, 0.09252649f, 0.07959022f, 
    -0.04655468f, -0.08082999f, -0.02524738f, 0.04191410f, 0.16291331f, -0.00955252f, 0.04146581f, 0.20119138f, 
    -0.06013602f, 0.04863665f, 0.05691410f, 0.09652413f, 0.13041683f, 0.10228328f, 0.22741397f, 0.02502744f, 
    0.25040203f, -0.12462506f, 0.04035749f, 0.06189493f, 0.03050951f, -0.07826131f, 0.00177202f, -0.07068291f, 
    -0.04176205f, 0.07817399f, -0.13253608f, -0.05489149f, 0.12818585f, 0.07961596f, 0.03255931f, 0.05619117f, 
    -0.06545571f, -0.04870410f, -0.03935156f, 0.04686362f, -0.09605570f, 0.00767894f, -0.00758837f, -0.03329078f, 
    0.19716604f, 0.19700967f, 0.02840812f, 0.30134407f, -0.09072114f, -0.05311709f, -0.10329867f, 0.02620183f, 
    -0.03444472f, -0.04857215f, -0.11405211f, 0.00195445f, 0.11733150f, 0.31151560f, 0.15004732f, -0.11417740f, 
    0.04841170f, 0.06338537f, 0.10192526f, 0.05444393f, 0.01817274f, -0.05288918f, -0.08548114f, -0.22604829f, 
    0.18125820f, 0.13974491f, -0.06828436f, 0.31559467f, -0.15369123f, 0.00651251f, 0.01444022f, -0.01549163f, 
    -0.00466756f, -0.07435416f, -0.05331429f, 0.02667213f, -0.01048685f, 0.04662137f, -0.01686469f, -0.07356527f, 
    -0.00767325f, -0.05477209f, -0.11761557f, -0.02545431f, 0.02874285f, 0.04126637f, -0.00146305f, -0.06814303f, 
    -0.21194632f, 0.05306897f, -0.21717101f, 0.12235989f, 0.11622255f, -0.09765040f, -0.02865038f, -0.04591487f, 
    -0.04742119f, -0.11311713f, -0.04056495f, -0.01776037f, -0.08108900f, -0.01674341f, -0.04181884f, -0.00861304f, 
    0.01118679f, 0.02758332f, -0.05132420f, -0.09201679f, 0.06081015f, 0.02851198f, 0.07832468f, 0.06178177f, 
    -0.02360650f, -0.02773771f, 0.16263838f, 0.11768725f, 0.17193131f, 0.11869806f, 0.05128206f, 0.12821849f, 
    0.08245184f, 0.00211266f, 0.00673060f, -0.10275103f, -0.37506229f, 0.21699592f, 0.19098184f, -0.00006381f, 
    -0.07269256f, 0.16366808f, 0.00218649f, 0.00855258f, 0.02501736f, -0.07172344f, -0.03612478f, 0.01949885f, 
    0.10480506f, -0.10043147f, -0.19007418f, -0.21860488f, -0.13393718f, 0.00354515f, -0.07157558f, 0.04997876f, 
    -0.08874372f, 0.02351268f, -0.07681651f, -0.09845874f, 0.07679563f, -0.12826113f, 0.23068862f, 0.13872775f, 
    0.02228127f, 0.00876381f, -0.02223486f, 0.06191511f, 0.04251726f, -0.18560772f, -0.06143390f, -0.01136828f, 
    0.01536728f, 0.19729514f, -0.03810009f, -0.13013922f, -0.05758273f, 0.01218560f, -0.01678941f, -0.01579457f, 
    -0.04859933f, -0.09451576f, 0.03943562f, 0.00045020f, -0.07828835f, 0.17552799f, 0.17136288f, -0.03418445f, 
    -0.00205308f, 0.02097879f, 0.25858748f, -0.00118544f, -0.10846071f, -0.08415161f, -0.02546421f, 0.01674149f, 
    0.01502328f, -0.10216132f, 0.10248422f, -0.11074723f, -0.10366869f, -0.13120650f, -0.18658331f, -0.06474901f, 
    0.05375591f, 0.06191906f, 0.04092131f, -0.05823584f, 0.25373802f, -0.23889504f, 0.04011169f, -0.02605509f, 
    -0.00480989f, 0.08305299f, -0.05904346f, -0.08652996f, 0.12970880f, 0.26454872f, -0.01274449f, -0.00891370f, 
    -0.14729083f, 0.00927462f, -0.02472297f, -0.20565028f, 0.01158984f, 0.19579807f, 0.15005268f, -0.01211351f, 
    -0.44899589f, -0.16500083f, -0.09090282f, 0.00119108f, 0.08349498f, -0.00533692f, -0.03495523f, 0.05604575f, 
    0.10949349f, 0.09348141f, 0.09271338f, -0.00415909f, 0.13656493f, 0.02341973f, -0.05272448f, 0.03083793f, 
    0.25003266f, 0.22354592f, -0.16689582f, 0.01612244f, 0.06588357f, -0.01779860f, 0.05911754f, -0.09681699f, 
    0.06768479f, 0.11243201f, 0.08488423f, 0.05409220f, -0.11836643f, -0.06259188f, 0.01242513f, 0.00978480f, 
    -0.12104966f, -0.18219392f, -0.01636073f, 0.05132618f, -0.10871244f, -0.12114591f, 0.12346227f, 0.09722128f, 
    -0.26997867f, -0.34612650f, 0.04834171f, -0.34838676f, -0.00586330f, -0.01416820f, 0.05898083f, -0.02239537f, 
    0.10878055f, -0.03135909f, 0.02983117f, -0.17810459f, -0.04540662f, -0.08332051f, 0.05841460f, 0.10447107f, 
    0.00822232f, -0.08208808f, 0.00714565f, -0.01458371f, 0.02795122f, 0.01427150f, 0.17355515f, -0.07024193f, 
    0.18436207f, -0.07606200f, 0.05952661f, -0.00000613f, 0.01035258f, -0.09481621f, -0.13043462f, 0.20422305f, 
    -0.07033101f, 0.06166883f, -0.06305172f, 0.15145281f, 0.04677435f, -0.01935769f, -0.00867076f, 0.03780388f, 
    -0.04109612f, -0.06854831f, -0.00742247f, 0.07979929f, -0.18187924f, -0.24172859f, -0.13969323f, 0.10108162f, 
    0.02730761f, -0.05297415f, 0.09872054f, 0.05480241f, 0.16916974f, -0.03147938f, -0.18520105f, -0.06902291f, 
    -0.09664760f, -0.04217314f, -0.01303449f, 0.27950040f, 0.15037262f, -0.03322014f, -0.07041305f, 0.06820602f, 
    -0.07585171f, -0.41262150f, 0.04707566f, -0.05830498f, -0.07026042f, -0.05832175f, -0.11009467f, 0.40754023f, 
    0.10028739f, 0.20892185f, 0.07961360f, 0.04453302f, 0.08754925f, 0.05029121f, 0.22262762f, 0.11959001f, 
    0.06194462f, -0.10043310f, -0.00157625f, -0.05201468f, 0.15053484f, 0.32263771f, -0.00433611f, -0.13613680f, 
    -0.12181149f, 0.09215752f, 0.14654076f, -0.19480690f, -0.06819776f, 0.01109571f, 0.11631635f, -0.17394412f, 
    0.05062895f, -0.24928010f, 0.10455523f, -0.09439781f, 0.00275062f, 0.07391528f, 0.05876781f, 0.00466110f, 
    0.13707839f, -0.01969141f, 0.11374195f, 0.35309696f, 0.16669253f, 0.02911508f, -0.05870704f, 0.01673195f, 
    -0.03154065f, -0.01111232f, -0.18278866f, -0.00323740f, 0.06133117f, 0.10304263f, 0.04950700f, 0.08825302f, 
    -0.12249823f, -0.02694239f, -0.02436887f, 0.11649830f, 0.21736915f, 0.15553075f, 0.00234306f, -0.08216104f, 
    -0.02848830f, 0.06203887f, 0.03450625f, 0.08819053f, 0.20334280f, 0.06594937f, 0.12883049f, -0.06770157f, 
    -0.11581668f, 0.09058164f, 0.10902265f, -0.03635013f, 0.21248122f, 0.18177648f, 0.05468059f, -0.04281461f, 
    0.02275501f, -0.00788093f, -0.18142982f, -0.12464720f, 0.12527998f, 0.19189824f, 0.03067807f, 0.08343626f, 
    0.00525605f, -0.09007870f, -0.00634067f, 0.02383845f, 0.01482954f, -0.03372029f, -0.04041740f, 0.05444175f, 
    -0.05972145f, -0.10906500f, -0.06145718f, -0.07148645f, 0.10490490f, 0.07851952f, -0.00890309f, 0.07873572f, 
    0.10714327f, 0.19029088f, -0.07781430f, -0.00635257f, 0.09808034f, -0.06288126f, 0.00790181f, -0.12812331f, 
    0.00531242f, 0.00776981f, 0.04250371f, -0.04668198f, 0.11583636f, 0.14955020f, -0.11240394f, -0.05555646f, 
    -0.14265306f, -0.15935832f, 0.18762013f, 0.12783951f, -0.03176689f, 0.08372032f, -0.00465553f, 0.22176534f, 
    0.33274791f, 0.11678209f, 0.23305714f, -0.01960670f, -0.00379579f, 0.00788440f, -0.05874515f, -0.05190559f, 
    0.04238704f, -0.10299517f, -0.09633574f, 0.22174734f, 0.03401919f, -0.03052579f, 0.06795567f, 0.09725483f, 
    0.01644059f, -0.10616519f, -0.01773916f, -0.10428695f, -0.03004476f, -0.06199464f, 0.02267674f, -0.25413594f, 
    -0.05301981f, -0.00622690f, -0.00599270f, -0.17943494f, 0.02767786f, 0.01970094f, -0.05776760f, -0.14125521f, 
    0.02424930f, 0.01196820f, -0.06268636f, -0.02038910f, 0.08070561f, -0.07160442f, 0.02820744f, 0.01712969f, 
    -0.12410661f, -0.04345692f, -0.00926849f, -0.09316993f, 0.04530963f, 0.01181454f, 0.09982231f, 0.18842560f, 
    0.00925563f, 0.10622998f, 0.01831247f, 0.01455032f, -0.03515283f, -0.07803094f, -0.08880757f, -0.13156991f, 
    0.12909615f, -0.03903915f, 0.11222688f, 0.06203763f, 0.12998185f, 0.03245450f, 0.12583038f, -0.06399562f, 
    -0.18616813f, -0.16087851f, 0.01629919f, -0.03135573f, 0.00931074f, -0.06398417f, -0.16275939f, 0.01959865f, 
    0.05032026f, 0.12947038f, 0.12620361f, 0.03757744f, 0.08158483f, 0.04942903f, 0.08389194f, 0.05001404f, 
    -0.03504371f, -0.12257644f, -0.08638042f, 0.02244975f, 0.19694656f, 0.03165061f, 0.03226702f, -0.04336611f, 
    0.05201705f, -0.05101204f, 0.05576373f, 0.11064401f, 0.03610521f, -0.04055305f, -0.01920697f, -0.04906914f, 
    -0.10987227f, -0.38026914f, -0.26262853f, -0.26155272f, 0.05972763f, 0.14606561f, 0.02048474f, 0.06672231f, 
    0.07220045f, 0.09771605f, 0.00116035f, 0.02521258f, -0.07820396f, -0.07228258f, 0.06991272f, -0.00161418f, 
    0.07129198f, 0.05631740f, 0.10796903f, 0.11434341f, 0.08059678f, -0.01329522f, 0.00926175f, 0.09119613f, 
    0.00292605f, -0.05113646f, 0.04378209f, -0.04419552f, -0.02970573f, 0.05202357f, 0.06380715f, -0.06699132f, 
    -0.05958772f, -0.06372292f, -0.01628487f, -0.05394279f, 0.03135712f, -0.07119049f, -0.03536588f, 0.05481859f, 
    -0.03418660f, -0.03136194f, 0.06354323f, -0.06944180f, 0.03336558f, 0.01736979f, -0.07533763f, 0.01317660f, 
    0.05103606f, -0.04184645f, 0.04602987f, 0.02747338f, -0.05929738f, -0.07699901f, -0.00713782f, -0.06947473f, 
    -0.05321135f, 0.00421475f, -0.02480392f, -0.05584931f, 0.03381234f, 0.02253036f, -0.01981381f, -0.05296004f, 
    0.00867407f, 0.03331586f, -0.06961794f, -0.00922938f, 0.02112880f, -0.03601078f, 0.01244400f, 0.06127468f, 
    -0.07082669f, -0.01647772f, 0.02326104f, 0.01240977f, -0.02741549f, -0.02589442f, 0.05963081f, -0.00970935f, 
    -0.02867323f, -0.07084861f, -0.05690803f, -0.00953399f, -0.02883893f, -0.01363059f, -0.02681696f, 0.03782217f, 
    -0.05560998f, 0.04187456f, -0.01494636f, 0.04913210f, -0.04608239f, -0.04187040f, -0.06999279f, -0.02215776f, 
    0.02582534f, -0.05480314f, -0.04372011f, -0.06260439f, -0.05707649f, 0.03960267f, 0.05138753f, -0.02914789f, 
    0.03739438f, -0.07087659f, -0.07562470f, 0.00216285f, -0.07759208f, 0.06090723f, -0.01180025f, 0.02459227f, 
    0.00028951f, -0.00395577f, 0.05134694f, -0.06415368f, 0.02136421f, -0.03031521f, -0.00030541f, -0.01663842f, 
    0.05225601f, 0.02312735f, -0.01623658f, -0.07175787f, 0.03472187f, 0.04495636f, -0.05233939f, 0.01325802f, 
    -0.03529792f, -0.02139486f, -0.00949920f, 0.00873687f, -0.00090797f, 0.03744007f, -0.03088256f, 0.05976243f, 
    0.01657922f, -0.05554820f, -0.07662204f, -0.06820289f, 0.01259837f, 0.05774476f, -0.06020182f, -0.04055455f, 
    0.04278579f, -0.07710367f, 0.04436073f, -0.02498888f, -0.03337866f, -0.07681203f, -0.07058597f, 0.05081560f, 
    0.04374122f, 0.06603856f, -0.02195602f, -0.06002899f, -0.03127512f, 0.04153810f, -0.07695310f, -0.07203595f, 
    -0.05949778f, -0.01671005f, 0.06004762f, 0.01958045f, -0.06116258f, -0.02934931f, 0.00521103f, -0.04822548f, 
    -0.04878233f, -0.04788839f, 0.05254710f, -0.02528944f, 0.06596754f, 0.04407947f, -0.06051026f, 0.02110713f, 
    -0.02761639f, -0.05537991f, -0.06898294f, -0.05904370f, -0.03193114f, -0.01015227f, -0.05192519f, -0.06777428f, 
    -0.01085890f, -0.00815994f, 0.00770133f, -0.06502383f, 0.00128950f, -0.01078239f, 0.02223602f, -0.00768472f, 
    0.06038053f, -0.03551850f, 0.04120376f, 0.01302160f, -0.07304443f, 0.00615612f, -0.07049414f, -0.06205276f, 
    -0.02211719f, -0.01195741f, 0.03771831f, -0.00389251f, -0.05759301f, 0.06348328f, -0.00045773f, 0.06053407f, 
    0.01594935f, 0.06126825f, -0.02300779f, -0.04791946f, -0.01177113f, -0.02139668f, 0.02301539f, 0.00087511f, 
    -0.09436590f, -0.07127709f, -0.02650561f, 0.28797537f, 0.06163291f, -0.03559484f, 0.13691987f, -0.12755117f, 
    -0.06420193f, -0.08864845f, -0.14249760f, -0.10237130f, -0.19721723f, 0.21620020f, 0.16868299f, 0.06758349f, 
    0.06156111f, 0.07056329f, -0.03529715f, 0.01793130f, 0.07628866f, 0.14916931f, 0.08060643f, 0.07579549f, 
    -0.45960405f, 0.16030376f, 0.04364759f, 0.02120079f, -0.08833507f, 0.00571958f, 0.04619702f, 0.04804238f, 
    0.06104025f, 0.03468177f, 0.13685291f, 0.04476559f, -0.23611933f, -0.00324170f, -0.02911866f, 0.00474754f, 
    0.06700505f, 0.12847212f, 0.10886085f, -0.20628439f, -0.04731619f, -0.05644719f, -0.07785336f, -0.10778351f, 
    -0.35423493f, -0.06658275f, 0.16257805f, -0.21768488f, 0.10934541f, -0.00987772f, 0.19394429f, -0.07421625f, 
    -0.04962474f, 0.02292324f, -0.01652225f, 0.02501596f, 0.03119761f, -0.31952432f, -0.08612320f, 0.06002267f, 
    -0.05388371f, -0.16247280f, -0.07875144f, -0.05546409f, -0.06722224f, -0.03959726f, 0.19689211f, 0.21468449f, 
    -0.05077606f, 0.12100866f, 0.18519418f, -0.05934698f, 0.00407290f, -0.12748684f, -0.03154346f, 0.11087287f, 
    -0.08312376f, 0.12474645f, 0.26183867f, 0.16919567f, -0.05731961f, 0.02461720f, -0.01201461f, -0.12553512f, 
    -0.10173744f, -0.00156070f, -0.01019612f, 0.02806227f, 0.24959469f, 0.11537861f, 0.23972355f, 0.26358309f, 
    0.17079414f, 0.16207854f, 0.18301831f, -0.06829307f, 0.01548239f, 0.28286651f, -0.03486091f, 0.26890451f, 
    0.01250120f, -0.03032618f, -0.03726752f, 0.01650026f, -0.03092791f, -0.10761492f, -0.04249931f, -0.05309371f, 
    -0.01244491f, 0.00793570f, 0.02831888f, -0.02203244f, 0.09031622f, 0.04297449f, -0.11825027f, -0.09487022f, 
    0.18446001f, 0.09649362f, -0.06939667f, -0.05081636f, -0.09508864f, -0.05489691f, -0.05770721f, -0.05493192f, 
    -0.04685203f, 0.06444877f, 0.12733822f, 0.08732028f, 0.60595375f, -0.19295441f, -0.22010623f, 0.05979755f, 
    0.14057730f, -0.06582782f, -0.01222035f, -0.06545460f, 0.06998616f, -0.06885276f, -0.00876592f, 0.13115039f, 
    -0.30234888f, -0.30132303f, -0.04544171f, 0.04670239f, 0.08396955f, 0.03992479f, 0.17750061f, 0.01313277f, 
    0.07371817f, -0.17921227f, -0.05683699f, -0.03631539f, -0.14238356f, -0.00275308f, -0.07698757f, 0.08050039f, 
    -0.06105632f, -0.06445649f, 0.16099870f, 0.09308941f, 0.03566268f, 0.30406016f, 0.20987380f, 0.14795776f, 
    0.07442285f, -0.13182765f, 0.27941108f, 0.21618138f, -0.00979086f, -0.07931539f, 0.05783657f, 0.23523366f, 
    0.05259692f, 0.13911590f, 0.03902289f, 0.19188197f, -0.19824313f, -0.17691214f, -0.16798459f, 0.10479491f, 
    0.07088170f, -0.03386073f, -0.09158217f, 0.04420468f, -0.17370994f, -0.09168401f, -0.20005782f, -0.09491017f, 
    -0.07863509f, -0.05619227f, 0.06004509f, -0.04150365f, 0.04285929f, -0.02851303f, -0.05079494f, 0.00321852f, 
    -0.00262444f, -0.05689112f, -0.01945054f, -0.06296384f, -0.04004532f, 0.01957355f, 0.01815296f, -0.02862218f, 
    -0.05424954f, -0.06106194f, -0.04722458f, 0.03875773f, -0.04370565f, 0.04543428f, -0.07651916f, -0.06455605f, 
    -0.02774200f, 0.01448771f, -0.03068976f, -0.06383377f, 0.02196430f, 0.02912849f, 0.01447105f, -0.02139583f, 
    0.03379550f, -0.08118578f, 0.03680085f, 0.01707767f, -0.04907838f, 0.03900806f, 0.05555483f, 0.04040428f, 
    0.04665069f, -0.04811221f, -0.06719014f, 0.03768343f, -0.02766922f, -0.05538744f, -0.03312385f, 0.03247398f, 
    -0.02792524f, -0.07034267f, -0.04748600f, 0.02582963f, 0.01070968f, 0.05480479f, -0.00837483f, 0.04532399f, 
    -0.03390395f, -0.02304146f, 0.01653093f, 0.00983903f, -0.00125271f, -0.00949120f, -0.03901638f, -0.00276560f, 
    0.03358537f, 0.01556749f, 0.00622385f, -0.06261482f, 0.04725386f, -0.05937833f, 0.00417176f, 0.05293687f, 
    0.03761091f, 0.05132844f, -0.07562851f, -0.06861232f, -0.04075500f, 0.05032480f, -0.00386454f, 0.01810225f, 
    -0.02658399f, -0.06254414f, 0.02655352f, -0.05495534f, -0.03804919f, 0.01144197f, -0.00778183f, -0.06312150f, 
    -0.07315429f, 0.06064085f, 0.04608721f, -0.02683727f, -0.00569243f, -0.06824770f, 0.04536298f, -0.05396867f, 
    -0.01452901f, 0.05295662f, 0.04171091f, -0.05451018f, -0.04928900f, -0.05390159f, 0.04931849f, 0.04238351f, 
    0.01540633f, -0.01301831f, 0.03250409f, -0.03423678f, 0.05762218f, 0.01937550f, 0.05490391f, 0.00547849f, 
    -0.02581690f, -0.01632585f, -0.03979412f, 0.03103084f, -0.02370748f, 0.03081975f, 0.04092456f, 0.01012741f, 
    0.04622430f, -0.02310098f, -0.03347666f, -0.01989903f, 0.02443382f, -0.01750621f, -0.06245533f, -0.03148865f, 
    0.00998123f, -0.03792664f, 0.05079941f, 0.01419331f, -0.02531762f, -0.03233592f, 0.05348790f, -0.06544098f, 
    -0.07180358f, -0.05492289f, -0.01156341f, 0.01955815f, 0.01568401f, -0.00581995f, -0.01512065f, -0.04106333f, 
    -0.02211753f, 0.00380038f, -0.03361681f, -0.00339992f, -0.04433911f, 0.04695810f, -0.05412322f, 0.01146275f, 
    0.00472575f, -0.06386435f, -0.05949103f, -0.05285739f, 0.05149807f, 0.02854106f, -0.01518558f, 0.01220604f, 
    0.04200547f, 0.02249268f, -0.00311840f, 0.05209130f, -0.04622462f, 0.01835427f, 0.05021104f, -0.01313117f, 
    -0.00424790f, 0.01070878f, -0.01798946f, -0.02605609f, -0.05288550f, -0.08014585f, -0.03081211f, 0.02342752f, 
    -0.07335372f, 0.02542800f, -0.07608806f, -0.02922103f, -0.07315231f, 0.00493773f, -0.06573471f, -0.02201165f, 
    -0.00647328f, -0.00021164f, -0.01136524f, -0.01710618f, -0.04651627f, -0.03989742f, 0.05859728f, -0.05449515f, 
    0.02679314f, -0.08311843f, -0.36579943f, -0.53366262f, 0.02307626f, 0.06492145f, 0.04165474f, 0.15089947f, 
    -0.04299561f, -0.15971263f, -0.27408040f, -0.22791873f, 0.12380566f, -0.15619351f, 0.03430845f, -0.10228373f, 
    -0.05618165f, -0.02046035f, -0.29007229f, 0.04667034f, -0.05391581f, -0.05481605f, -0.00639133f, 0.01381032f, 
    0.20716809f, -0.14341483f, 0.04792800f, 0.10770582f, 0.19269033f, 0.00091901f, 0.07988334f, 0.11886550f, 
    0.04795677f, 0.10572587f, 0.03713516f, 0.16176985f, 0.21605612f, 0.08737751f, 0.01041431f, -0.16872571f, 
    0.24953711f, -0.06304859f, -0.18415609f, 0.20671479f, -0.14270701f, -0.22619800f, -0.10476781f, -0.01814739f, 
    -0.08899307f, 0.10542569f, 0.06317920f, 0.06127816f, 0.08417084f, -0.06139926f, -0.00587653f, 0.11768899f, 
    -0.11920088f, -0.18144181f, -0.04453752f, -0.15462215f, 0.04090017f, -0.10522571f, 0.13683720f, 0.14230244f, 
    0.25825772f, 0.22633116f, 0.02043787f, 0.05715020f, 0.08183357f, -0.04281663f, 0.06376461f, 0.12070493f, 
    0.05073255f, -0.02936756f, 0.25134686f, 0.00160580f, -0.01331681f, -0.19722646f, -0.03834704f, -0.24697673f, 
    -0.12847456f, 0.25930715f, 0.02574603f, -0.09754473f, -0.01151334f, 0.00783074f, 0.16119905f, 0.10100165f, 
    -0.03574651f, 0.00209742f, 0.08980109f, 0.00608165f, 0.14550340f, 0.10523037f, 0.15971693f, 0.25799027f, 
    0.31251419f, 0.13413297f, -0.36520913f, 0.08723566f, -0.07023674f, -0.08183526f, -0.18697931f, -0.02451644f, 
    0.17051254f, 0.00301551f, -0.00532279f, 0.12160290f, 0.06748049f, -0.08341738f, 0.09036331f, -0.20998371f, 
    -0.01846058f, 0.11391596f, -0.04007624f, -0.27438498f, -0.03610236f, 0.02038939f, 0.02313318f, -0.17725874f, 
    -0.08386683f, 0.06072145f, 0.12964948f, -0.06541988f, -0.13642853f, -0.01436162f, -0.00059492f, 0.00658599f, 
    -0.33533108f, -0.09845518f, -0.10496928f, -0.50957972f, 0.10927976f, 0.05028401f, -0.07631515f, -0.06290973f, 
    0.33058488f, -0.14168358f, -0.22189716f, -0.36237213f, -0.21181494f, -0.17656721f, -0.08329250f, -0.24549866f, 
    0.06397547f, 0.31035775f, 0.10505950f, 0.00071382f, -0.11210726f, 0.06315085f, 0.28518650f, 0.23646203f, 
    -0.01120585f, 0.04543794f, 0.04186369f, -0.17628831f, -0.17232636f, 0.27303880f, 0.16438615f, 0.10557538f, 
    -0.07191303f, -0.00715899f, 0.00737656f, -0.04153053f, 0.05778744f, 0.14803234f, 0.12066707f, 0.13770065f, 
    0.53959155f, 0.14542085f, 0.24753478f, -0.06284180f, -0.18359089f, -0.00478770f, -0.19685474f, -0.21545067f, 
    0.13909718f, -0.08363809f, 0.11253723f, 0.12498159f, 0.13457894f, 0.15815532f, -0.07779647f, -0.06645148f, 
    0.03623243f, 0.10277965f, 0.12050558f, 0.07818498f, -0.10525053f, 0.02393408f, 0.05444969f, -0.17323646f, 
    -0.10611415f, 0.07159577f, -0.14405786f, -0.00242922f, 0.15274489f, 0.06579567f, -0.00620195f, 0.02500036f, 
    -0.12835053f, 0.02063382f, 0.05351265f, 0.17089534f, 0.13856553f, -0.14562219f, 0.23654273f, -0.10016772f, 
    -0.14976555f, 0.02987183f, -0.14755201f, 0.18316345f, 0.11703411f, 0.16297023f, 0.05600687f, 0.02468087f, 
    -0.08883479f, 0.07158353f, -0.04420577f, -0.25350222f, 0.09228340f, 0.01577053f, 0.08568584f, 0.21816696f, 
    -0.00957768f, -0.06010364f, 0.11874042f, -0.02459846f, -0.24088417f, -0.11448917f, -0.04928196f, 0.16102989f, 
    0.05631135f, -0.12971185f, 0.20837417f, -0.11644914f, 0.16136013f, 0.05504918f, -0.01064485f, 0.12636024f, 
    -0.02362398f, 0.13244611f, -0.29777083f, -0.00302215f, 0.10522903f, 0.11597252f, 0.25122187f, -0.01819474f, 
    0.00869032f, -0.04348208f, 0.03701228f, -0.04621376f, 0.00151465f, 0.04020982f, -0.03628284f, -0.17854728f, 
    -0.13019837f, -0.19786468f, 0.06584974f, -0.05235300f, -0.03225130f, -0.04106015f, 0.13108514f, 0.15092857f, 
    0.09268071f, -0.06368991f, 0.35430461f, -0.02942159f, 0.05462181f, -0.04481006f, -0.00281661f, -0.09241358f, 
    0.12320858f, -0.11302365f, 0.05586673f, -0.05447717f, -0.04067209f, -0.20952062f, -0.18259877f, 0.21799639f, 
    0.11678390f, 0.13007279f, 0.06249120f, 0.03157272f, -0.04084038f, -0.14286779f, -0.01665088f, -0.13869217f, 
    0.06684797f, 0.11779334f, 0.07254811f, 0.05060934f, 0.16216291f, 0.11068074f, -0.08060380f, 0.04859456f, 
    0.11420160f, 0.10651572f, 0.18192971f, -0.09587982f, 0.06121049f, -0.18925090f, 0.03278877f, -0.11918116f, 
    -0.08783238f, -0.21956517f, -0.04631261f, 0.03657870f, 0.01819658f, -0.02112220f, -0.02232579f, 0.17018250f, 
    0.14716008f, 0.19827883f, 0.03822975f, 0.03941921f, 0.07439594f, 0.10823043f, 0.00912023f, -0.17803545f, 
    -0.00707788f, -0.06447428f, -0.08078706f, 0.16214013f, 0.02221172f, -0.16942926f, 0.27335429f, -0.01639235f, 
    -0.07863058f, -0.13045616f, 0.10318886f, -0.05995443f, 0.01706253f, -0.19574563f, 0.06123497f, -0.03680959f, 
    -0.17209408f, 0.11709514f, -0.04443171f, -0.23479652f, 0.18070200f, 0.00920368f, 0.01556616f, -0.01100267f, 
    0.01076403f, -0.06273905f, -0.13275768f, -0.06863414f, 0.08669046f, 0.32082450f, 0.14674513f, -0.03286741f, 
    0.11898444f, -0.14178196f, 0.15698335f, 0.03150799f, 0.14723732f, -0.02758146f, 0.06974465f, -0.09246212f, 
    -0.20805334f, -0.39818859f, 0.32681021f, -0.04644735f, -0.06881811f, 0.09363323f, -0.06645835f, 0.15508530f, 
    0.15565173f, 0.06972779f, 0.03447303f, 0.05731256f, -0.00429025f, -0.03744461f, 0.06325587f, -0.15403266f, 
    0.22313079f, 0.09197001f, 0.02195864f, 0.20814879f, 0.03607314f, -0.09094075f, -0.12965408f, 0.03650971f, 
    -0.03808023f, -0.07552887f, 0.05453048f, 0.03049083f, 0.05823949f, 0.04113900f, -0.06448757f, 0.05203602f, 
    0.01704004f, -0.06335764f, 0.03211965f, -0.03988155f, 0.03729305f, -0.07116701f, -0.06676653f, 0.04447790f, 
    -0.06441799f, 0.05052122f, -0.00762508f, -0.06077199f, -0.04502773f, 0.03480247f, -0.01347306f, -0.07437985f, 
    -0.00190051f, -0.07736314f, -0.05743273f, -0.00099298f, 0.05869495f, 0.02679663f, 0.04399818f, 0.03490574f, 
    -0.01973326f, 0.01648102f, 0.02359669f, 0.02243641f, -0.01831762f, 0.06937305f, -0.04828717f, 0.02018804f, 
    -0.04911323f, 0.03810838f, -0.02327420f, 0.01685963f, -0.01163780f, 0.03901872f, -0.00228178f, 0.03570200f, 
    -0.02269640f, 0.06201372f, -0.03298027f, 0.04004782f, -0.00742214f, 0.06044500f, 0.03436425f, -0.04251165f, 
    0.05325783f, 0.04173663f, -0.00732857f, -0.01338980f, 0.01891061f, -0.01811670f, 0.00463909f, -0.03889553f, 
    0.00143315f, -0.02436451f, 0.05582018f, 0.00768429f, -0.02359806f, -0.04065899f, 0.01650497f, -0.05322485f, 
    0.04049680f, 0.00610831f, 0.01547998f, 0.05993163f, -0.00016660f, 0.02839957f, -0.04293638f, 0.02118654f, 
    0.03392231f, -0.02020369f, 0.00832236f, 0.03383911f, 0.00424022f, -0.03202264f, 0.05666355f, -0.02468681f, 
    -0.01204051f, 0.02250745f, -0.05501159f, -0.00528746f, -0.04909882f, 0.00344140f, -0.00788078f, 0.04128136f, 
    -0.03818028f, 0.02864871f, -0.04844585f, -0.06390685f, -0.06176857f, -0.06131933f, -0.04910383f, -0.01417487f, 
    -0.02743816f, -0.02418475f, -0.03558378f, 0.03189414f, -0.03416228f, -0.07191465f, -0.00114751f, -0.05839417f, 
    -0.02556586f, -0.05611151f, 0.06445237f, -0.01952873f, -0.01813462f, -0.07953292f, 0.04153138f, -0.01285774f, 
    -0.07281715f, -0.05394578f, -0.02620659f, -0.04380604f, -0.02125131f, -0.01503955f, -0.04067704f, -0.07068936f, 
    -0.05218037f, -0.04183951f, -0.07251129f, -0.01933268f, 0.05320120f, 0.03775935f, -0.04919505f, -0.06385472f, 
    -0.06741352f, -0.04282723f, -0.05234993f, 0.01749445f, 0.02528675f, 0.03155788f, -0.00974525f, 0.00123205f, 
    -0.01742345f, 0.02311987f, 0.04065381f, 0.03910228f, -0.06801964f, -0.02665761f, -0.07249382f, 0.04038602f, 
    -0.07347289f, 0.03078735f, -0.01410532f, 0.00234367f, -0.00731487f, -0.02962731f, 0.03170318f, 0.05204022f, 
    -0.01431278f, 0.03610973f, -0.05380204f, 0.00036364f, 0.05818597f, -0.04563222f, -0.06651118f, -0.07709038f, 
    0.00159326f, 0.01798017f, -0.05548762f, -0.03391535f, 0.00390314f, 0.00881106f, 0.00466787f, 0.03855014f, 
    -0.01728627f, -0.05566840f, -0.02363799f, -0.06696777f, -0.08539792f, 0.03209582f, 0.02346133f, -0.07520354f, 
    -0.04815742f, -0.06317403f, 0.01166215f, -0.00399056f, 0.00930265f, -0.06035395f, 0.00435633f, 0.05698293f, 
    -0.13686733f, 0.03312754f, 0.04838012f, -0.10380790f, 0.04292145f, -0.00299291f, 0.05727608f, 0.05753756f, 
    -0.23435037f, -0.19283290f, -0.28615877f, -0.41383934f, 0.18681076f, -0.39643541f, 0.06718234f, 0.20642266f, 
    0.00231648f, 0.03072450f, -0.11986937f, -0.09468430f, 0.14463179f, 0.08728516f, -0.02628773f, 0.02924339f, 
    -0.06210360f, 0.04854029f, 0.16837339f, -0.09126031f, -0.04372670f, -0.02494710f, 0.09076265f, 0.17284369f, 
    0.16457950f, 0.02742241f, 0.18510281f, 0.12607549f, 0.21195412f, 0.06063883f, 0.01716362f, -0.07623421f, 
    0.06633471f, 0.10996304f, -0.03307298f, -0.01951438f, -0.00634718f, -0.14579663f, 0.02975250f, -0.02348284f, 
    0.25079313f, 0.05130186f, -0.24006769f, 0.08689361f, 0.02172421f, 0.05279232f, 0.14759067f, -0.11453820f, 
    -0.22006793f, -0.08207767f, -0.08258959f, -0.07976256f, -0.20484252f, -0.05894829f, 0.03904248f, 0.03060357f, 
    0.03061361f, 0.06733557f, 0.01271553f, 0.09755383f, -0.00408469f, 0.00154099f, -0.01665791f, 0.15444955f, 
    0.23103961f, -0.25606039f, 0.17260036f, 0.02137795f, -0.13651428f, -0.05786075f, -0.01231969f, 0.11940614f, 
    -0.18987373f, 0.18815066f, -0.00183499f, -0.03203924f, 0.22513701f, -0.03007242f, -0.02973030f, -0.02795054f, 
    -0.01010871f, 0.04372721f, 0.08115108f, -0.11734808f, 0.26237884f, 0.22944206f, 0.19379938f, 0.26785883f, 
    0.24361615f, 0.00181107f, 0.17496239f, 0.06193352f, -0.10263682f, -0.10948440f, 0.01762566f, -0.00295888f, 
    0.15994523f, 0.10446776f, -0.00981716f, -0.09136923f, 0.00242342f, -0.04455430f, -0.06170088f, -0.15981171f, 
    0.07033721f, 0.08749990f, 0.15847859f, 0.09173746f, 0.01056606f, 0.11681087f, -0.10729478f, -0.18765335f, 
    -0.05516007f, 0.09511727f, -0.02780826f, 0.20575388f, 0.09247433f, -0.01494191f, 0.00142016f, -0.15414311f, 
    -0.14055198f, 0.03874889f, -0.13679910f, -0.09731992f, -0.24390377f, -0.06097746f, -0.19216791f, 0.21427348f, 
    0.33029246f, -0.03079137f, -0.00700263f, -0.10428761f, -0.07304061f, -0.08774607f, -0.10083763f, -0.15476048f, 
    0.23162091f, 0.28364676f, 0.02379491f, -0.07869777f, 0.00414061f, 0.17293105f, 0.09402806f, 0.04640045f, 
    -0.02579457f, -0.14946508f, -0.12550594f, -0.07897568f, -0.00252544f, 0.03073111f, 0.14963691f, -0.12853846f, 
    0.04918968f, -0.03650830f, 0.04303184f, 0.06281935f, 0.05038780f, 0.14232530f, 0.18760173f, 0.05852419f, 
    0.39006042f, 0.26625416f, 0.11131421f, 0.08592307f, -0.13663013f, -0.19122304f, -0.01929232f, 0.06775266f, 
    0.12915702f, -0.13190050f, 0.03713416f, 0.11374673f, 0.07583136f, 0.03381500f, 0.10983101f, 0.04854798f, 
    0.00664010f, -0.07567012f, -0.02672146f, 0.06311247f, -0.21244857f, -0.10537416f, -0.08786809f, -0.15557899f, 
    0.04392341f, 0.02668493f, 0.04977589f, 0.09006451f, 0.15010308f, 0.14814071f, -0.00494608f, -0.07270439f, 
    -0.01281340f, 0.08997600f, 0.08686508f, 0.19796738f, -0.43860713f, 0.38738930f, -0.30109355f, 0.23159413f, 
    0.10140827f, 0.06802807f, 0.16931808f, 0.01519833f, 0.18520547f, 0.05537739f, 0.13801619f, 0.19866180f, 
    -0.18430337f, -0.09461604f, -0.07864188f, 0.15426035f, -0.08928400f, -0.04279156f, -0.16749677f, -0.05371218f, 
    -0.02324119f, 0.01780907f, -0.04824094f, 0.00207359f, -0.15330350f, 0.03772971f, -0.05803645f, -0.11482204f, 
    -0.02768690f, 0.02518347f, -0.05977942f, -0.07893992f, 0.09620889f, -0.03873416f, 0.01730293f, -0.16246961f, 
    0.48582852f, -0.06426625f, 0.24005249f, 0.20054691f, -0.01382205f, 0.01135081f, -0.17520584f, 0.07528652f, 
    -0.11405636f, -0.04143858f, -0.02584680f, -0.09315470f, 0.13435638f, 0.09682117f, -0.04327609f, 0.03634328f, 
    -0.01492026f, -0.14735037f, 0.00950324f, -0.06228059f, -0.07669809f, 0.05987212f, 0.00915079f, 0.01921726f, 
    -0.13322979f, 0.35715756f, -0.02494926f, 0.27118963f, -0.13229296f, 0.00120788f, -0.06819497f, -0.00991649f, 
    -0.08734708f, -0.11927395f, -0.04591877f, -0.06635750f, 0.05442789f, -0.11562300f, 0.01432811f, -0.01613386f, 
    -0.08713426f, -0.00464241f, -0.07539884f, 0.07610786f, -0.14921774f, -0.04912686f, -0.08756512f, -0.15723333f, 
    -0.15005453f, 0.10705791f, -0.13231687f, -0.08442468f, 0.09844133f, 0.10737254f, 0.00578155f, -0.14449266f, 
    -0.08126562f, 0.09732718f, 0.01757056f, 0.00976403f, -0.00972486f, 0.13592625f, -0.13373643f, 0.08277301f, 
    -0.01424893f, -0.01410401f, 0.07172512f, -0.05969466f, 0.16195241f, 0.03999513f, -0.08839089f, 0.06855416f, 
    0.19661613f, -0.12711972f, 0.04511480f, 0.04438895f, 0.15105985f, 0.02548084f, 0.12464308f, -0.06605890f, 
    0.14155705f, 0.09178122f, 0.11186273f, 0.19061498f, -0.02648706f, 0.21399756f, 0.07190759f, 0.11308346f, 
    -0.14256866f, -0.01753388f, -0.04838706f, 0.08009687f, 0.08046978f, 0.02523547f, 0.04557490f, 0.19614179f, 
    -0.08419168f, -0.20372975f, 0.05749891f, 0.14973958f, 0.01681324f, 0.10957941f, -0.07787904f, 0.02529704f, 
    -0.00248662f, 0.03552829f, 0.02527763f, -0.02734046f, 0.09670210f, -0.06820041f, 0.21341614f, 0.12219280f, 
    -0.04875202f, 0.08835473f, -0.05180668f, 0.19556691f, -0.09512577f, -0.10303678f, -0.02231513f, -0.01579568f, 
    -0.31483909f, -0.12643726f, -0.27744955f, 0.07749744f, 0.14847238f, 0.01689934f, 0.06296519f, -0.07909575f, 
    0.03402247f, 0.06471342f, 0.09498507f, -0.04421946f, -0.13002034f, 0.06126215f, 0.04849541f, 0.17722142f, 
    -0.00004867f, 0.11300493f, 0.03975889f, 0.05815245f, 0.14493018f, -0.02501423f, 0.03692467f, 0.05230042f, 
    -0.07584757f, 0.00602931f, -0.03796865f, -0.01511300f, 0.12728703f, 0.00381439f, 0.01812299f, 0.03361569f, 
    0.02539398f, -0.00084215f, 0.01477625f, 0.05089316f, 0.15133162f, -0.44645360f, -0.03984317f, -0.11612678f, 
    -0.13708481f, -0.14955854f, 0.02650109f, 0.05073493f, 0.27830929f, -0.02029798f, 0.28772280f, -0.05944939f, 
    0.25857604f, 0.06919476f, 0.01017666f, -0.15702829f, 0.04718801f, 0.22496696f, 0.00328589f, 0.00269066f, 
    0.06020876f, -0.02950977f, -0.03892696f, 0.00144077f, 0.03052222f, -0.10161154f, -0.10500855f, -0.02256605f, 
    -0.07018002f, -0.11352909f, 0.01700042f, -0.02075025f, -0.07130773f, -0.02813078f, 0.08269911f, 0.05913094f, 
    0.02081692f, -0.12291621f, -0.42827636f, -0.15925978f, 0.07765931f, -0.06694984f, -0.08341060f, -0.05657785f, 
    -0.06461866f, 0.03457660f, -0.07397217f, 0.01110825f, -0.00209937f, 0.23128031f, 0.27746484f, 0.03010905f, 
    -0.11502076f, 0.10128905f, 0.14202090f, 0.07533760f, 0.10165926f, 0.04177445f, -0.01301531f, 0.05021409f, 
    0.28336570f, -0.49334064f, -0.09741564f, -0.12108129f, 0.04026202f, 0.10598624f, 0.10491608f, -0.03741934f, 
    -0.02719496f, 0.13500383f, -0.05279646f, 0.00995148f, -0.13638003f, -0.12680204f, -0.07644045f, 0.04338717f, 
    0.03455877f, -0.06334642f, 0.09679149f, 0.07855869f, -0.21472813f, -0.16233295f, -0.13699515f, -0.25277212f, 
    -0.24784991f, -0.22485341f, 0.10880949f, 0.03322783f, -0.04104052f, -0.07416207f, 0.00463629f, 0.09273417f, 
    0.13440391f, -0.16236998f, 0.01027059f, -0.07720660f, 0.03473546f, -0.13913092f, -0.00129603f, -0.00266030f, 
    -0.05539677f, -0.02601886f, -0.03714759f, 0.03594749f, 0.04648726f, -0.05351679f, -0.01974749f, -0.07991780f, 
    -0.22820896f, -0.07035020f, 0.14555375f, -0.06826605f, -0.10469626f, -0.00213174f, 0.05983381f, 0.10131495f, 
    0.03869493f, -0.04902818f, 0.02987133f, 0.01764761f, -0.47618255f, 0.04979691f, 0.13473837f, 0.19775693f, 
    -0.16684099f, -0.02611403f, 0.07344398f, 0.11469553f, 0.11274406f, 0.09623642f, -0.05108154f, 0.06397952f, 
    0.32491863f, 0.19491729f, -0.12110252f, -0.09383387f, -0.15810013f, -0.11474298f, -0.10899551f, -0.14904901f, 
    -0.04686506f, 0.13153471f, -0.01190201f, 0.16047704f, 0.05698651f, -0.03655782f, -0.10337853f, 0.04964449f, 
    0.13268892f, 0.05285970f, 0.09319884f, 0.17918789f, 0.03743977f, 0.05101445f, 0.06709985f, 0.08592271f, 
    -0.23016061f, 0.05675251f, 0.08545469f, 0.00777013f, -0.04124071f, 0.01588812f, 0.03716379f, 0.09396397f, 
    0.11475597f, -0.17533636f, -0.07337987f, -0.06773126f, 0.14192601f, 0.22624858f, 0.24987668f, -0.01529326f, 
    0.07326932f, -0.07187561f, 0.16117555f, 0.07837491f, 0.08914992f, 0.10745703f, 0.00936513f, 0.07495517f, 
    0.01687779f, 0.13028251f, -0.19543655f, -0.09170565f, 0.08069211f, 0.05480251f, 0.15959191f, -0.02240104f, 
    -0.02938391f, -0.01827145f, -0.09449503f, -0.00697427f, -0.02338764f, -0.00405255f, -0.17878392f, 0.00508205f, 
    -0.00704776f, -0.13057655f, -0.01154579f, 0.00923351f, 0.07593402f, 0.05536443f, -0.07569227f, 0.06057030f, 
    0.29409534f, 0.02267941f, -0.13924666f, -0.17539467f, 0.14101553f, 0.08061676f, 0.00856681f, 0.13403115f, 
    -0.04600088f, 0.12651710f, 0.01614068f, 0.15915222f, -0.16991077f, -0.21387891f, -0.00780278f, 0.11618746f, 
    0.14417922f, -0.03365944f, 0.05675465f, -0.00117227f, 0.09653667f, -0.08220889f, -0.06528084f, -0.04363548f, 
    -0.05478592f, -0.35584843f, -0.33753034f, 0.28888586f, 0.00583853f, 0.13201849f, 0.17331451f, -0.03162448f, 
    0.07582878f, -0.14743659f, 0.01781298f, -0.14150369f, 0.40664932f, 0.02006691f, 0.10998353f, -0.06595270f, 
    0.14985028f, 0.06530117f, 0.01868176f, 0.05986989f, -0.02619841f, -0.05728045f, 0.07233591f, 0.21540292f, 
    -0.25232694f, -0.29665047f, 0.07337194f, 0.04101822f, -0.03071372f, 0.07008033f, -0.02696178f, -0.13711701f, 
    0.11892666f, -0.00801011f, 0.09427286f, 0.05841536f, -0.16596761f, -0.22363208f, -0.02320698f, 0.21947244f, 
    0.07837617f, -0.00546617f, -0.02063733f, 0.06536838f, -0.01356771f, -0.01249107f, -0.09878594f, -0.01960612f, 
    -0.03447995f, -0.04128127f, -0.01796154f, 0.11323426f, 0.14898436f, 0.04006694f, -0.10683435f, -0.07107680f, 
    -0.00391631f, -0.02957944f, 0.03282730f, -0.12565498f, 0.04435144f, -0.38839504f, 0.08730610f, 0.09903307f, 
    0.07708774f, -0.15977751f, -0.01767388f, -0.09541310f, 0.06855386f, 0.05939023f, -0.11528406f, 0.13639534f, 
    -0.13151008f, -0.00272655f, 0.29562661f, 0.03478151f, 0.15368822f, 0.05337849f, 0.07738626f, -0.13905033f, 
    0.13950364f, -0.17751458f, -0.11024004f, -0.09362633f, -0.08961443f, 0.15435451f, 0.38087165f, -0.09883751f, 
    -0.02910266f, -0.26316071f, 0.12403800f, -0.11853696f, 0.01132140f, -0.10800764f, -0.24710041f, -0.09869710f, 
    0.35322991f, 0.05139009f, 0.03897326f, -0.01481573f, 0.19751513f, -0.00304970f, 0.05565913f, -0.00460812f, 
    0.03850386f, 0.05836875f, -0.06081775f, -0.12090047f, 0.06965146f, 0.34663624f, 0.27299970f, 0.00230884f, 
    -0.04955456f, -0.02162082f, 0.10589387f, -0.08248659f, 0.00964814f, 0.02924457f, 0.05703491f, -0.01777733f, 
    -0.21487920f, -0.30929834f, 0.32365665f, -0.19580065f, 0.07314190f, -0.01613292f, -0.02639423f, -0.05022888f, 
    0.09326477f, 0.03009357f, 0.05002244f, 0.09346700f, 0.12787816f, 0.18922402f, 0.02358052f, -0.26684362f, 
    0.25359324f, 0.04495362f, -0.00273164f, 0.09928661f, 0.08288652f, -0.13062598f, -0.10624846f, 0.01469518f, 
    0.00030282f, -0.07125617f, 0.05714471f, 0.01689203f, 0.05168564f, -0.05175764f, -0.02036523f, -0.00294922f, 
    0.02247110f, 0.02385349f, 0.01735718f, 0.02641664f, 0.03211422f, 0.01076009f, -0.04694316f, 0.04778157f, 
    0.00473084f, -0.04815688f, 0.00022068f, -0.02502402f, 0.01748634f, -0.01409945f, -0.01994068f, -0.08113507f, 
    0.05117043f, -0.05354980f, -0.09095042f, -0.04627789f, 0.01225948f, -0.06641160f, -0.06632401f, -0.06640925f, 
    0.01675986f, -0.03480617f, 0.02465141f, -0.00857546f, -0.02889143f, 0.05401237f, -0.03846843f, -0.03201685f, 
    0.00314309f, -0.05340880f, -0.03022035f, -0.03032107f, -0.00536746f, 0.06220790f, -0.05332160f, 0.04287972f, 
    0.05484822f, -0.05615862f, -0.01988925f, -0.07678673f, -0.00002115f, -0.03382672f, 0.01406792f, -0.07742183f, 
    0.05233485f, -0.04632753f, -0.02284695f, 0.02281362f, 0.04761962f, -0.03535768f, -0.02698186f, -0.08929489f, 
    0.04310203f, -0.00560227f, -0.06057234f, -0.02551233f, -0.08122481f, -0.06885342f, -0.06772657f, -0.05494651f, 
    -0.02030943f, 0.05001886f, 0.01961783f, -0.05820751f, -0.07606210f, -0.04929181f, -0.04884203f, 0.00543885f, 
    -0.05645933f, 0.07265623f, 0.01286670f, -0.00796079f, -0.02548741f, -0.06908575f, -0.08393177f, -0.01333505f, 
    0.03001281f, -0.07794093f, -0.06262942f, -0.05297758f, 0.00758181f, -0.02199388f, -0.05176382f, -0.07636518f, 
    -0.06936647f, -0.00415642f, -0.02783085f, -0.02036517f, 0.01707053f, -0.06592523f, -0.07554181f, -0.01637609f, 
    -0.06235416f, 0.00073369f, -0.01116860f, 0.04473315f, 0.01044876f, 0.03819120f, 0.04846041f, 0.03846703f, 
    -0.02096720f, -0.04371799f, -0.04073527f, 0.05651765f, 0.03375030f, 0.03937268f, 0.01120968f, -0.06796074f, 
    -0.08130539f, 0.00725590f, 0.00802061f, 0.01265854f, 0.03246723f, -0.02404797f, -0.05957559f, 0.03526831f, 
    -0.03668028f, 0.03132702f, -0.00907204f, -0.00284440f, 0.02283347f, 0.05981334f, 0.00102812f, 0.00095601f, 
    -0.00322382f, 0.04675275f, -0.06487915f, -0.08472915f, 0.01409136f, -0.03864069f, -0.02419595f, 0.06081009f, 
    0.03274229f, -0.04613751f, -0.04515546f, -0.04720541f, 0.06171784f, 0.03667324f, -0.03412321f, -0.03499418f, 
    -0.07119208f, 0.02422720f, -0.01173632f, 0.05128612f, -0.04119400f, -0.08639303f, -0.01124433f, 0.02540014f, 
    -0.02054490f, -0.07632419f, 0.03856229f, -0.05871249f, -0.03380742f, 0.01990422f, 0.03066538f, -0.05868892f, 
    0.03813723f, -0.05180000f, -0.08309042f, -0.03075938f, 0.01866593f, 0.06686739f, 0.04347124f, -0.05303015f, 
    0.00465263f, 0.05177964f, -0.03812722f, 0.02212794f, 0.03546914f, 0.01192132f, -0.04883953f, -0.00884331f, 
    -0.04295113f, -0.04754111f, -0.08765214f, -0.00681921f, 0.04220120f, -0.00658990f, 0.03211202f, 0.02713181f, 
    -0.11462838f, -0.06470093f, -0.01928422f, 0.02109809f, 0.00812800f, 0.00392068f, -0.05395893f, -0.15925106f, 
    -0.04654364f, -0.04618089f, -0.04460578f, 0.03543132f, 0.08715903f, 0.03468487f, 0.05418561f, 0.01291962f, 
    -0.02585338f, 0.09044658f, 0.00112069f, 0.06634599f, 0.08208011f, -0.02594138f, 0.09149173f, -0.11593742f, 
    0.02266256f, -0.50092369f, -0.10544668f, -0.38155371f, -0.05138394f, -0.03762743f, 0.03001086f, -0.02732305f, 
    0.05785745f, 0.00743802f, -0.05769600f, 0.03213299f, 0.11585607f, 0.03044486f, 0.06135406f, 0.12994105f, 
    0.01687892f, -0.03899983f, -0.08151799f, 0.08053849f, -0.04489227f, 0.07257791f, -0.07647766f, -0.01256529f, 
    0.33897194f, 0.29631901f, 0.11019534f, 0.19528170f, -0.01338151f, -0.01812214f, -0.12084039f, 0.06102382f, 
    -0.00201494f, 0.00169862f, 0.00036420f, 0.13741161f, -0.01521204f, -0.34785423f, -0.53520930f, -0.43634388f, 
    0.18056399f, -0.18520425f, -0.00965966f, 0.05610816f, -0.07830844f, 0.04226614f, -0.03180700f, -0.03633936f, 
    0.33775881f, 0.25556770f, 0.06058487f, 0.22965924f, -0.06261391f, -0.00399066f, 0.00097505f, 0.06680759f, 
    0.01537184f, 0.21692367f, 0.05649514f, 0.21083923f, 0.04593238f, 0.08458003f, 0.11804649f, 0.09011323f, 
    -0.02481050f, 0.02248066f, 0.06221323f, -0.01422980f, 0.18647198f, 0.07719407f, 0.11262573f, 0.07617139f, 
    -0.04463768f, -0.12169091f, -0.07309469f, 0.01285474f, -0.12198448f, 0.09363465f, 0.05967259f, -0.04234474f, 
    -0.08780826f, -0.11830311f, -0.00971063f, -0.01302504f, 0.04859361f, 0.03107161f, 0.07995027f, 0.09252930f, 
    -0.04058043f, 0.01974626f, -0.09725406f, -0.04795216f, 0.04870841f, 0.14052036f, 0.03825387f, -0.02467461f, 
    -0.06271261f, 0.05919987f, 0.12888794f, 0.08274772f, -0.08059819f, 0.11194704f, 0.10684480f, 0.04083034f, 
    0.05613774f, -0.04649542f, 0.06528336f, -0.01232400f, -0.14003794f, 0.35189629f, 0.18277787f, -0.01337585f, 
    -0.15625076f, 0.21878900f, 0.06018802f, 0.02267637f, 0.04621611f, -0.02013802f, 0.02616829f, -0.04859205f, 
    0.04479733f, -0.04984364f, -0.04248008f, -0.08921694f, -0.00100164f, 0.07435526f, 0.25078890f, 0.23099613f, 
    -0.01120977f, 0.05311383f, 0.00205914f, 0.05224657f, 0.03621081f, -0.02607820f, 0.37843761f, -0.07210389f, 
    0.05885552f, 0.10212122f, -0.05629964f, 0.05850430f, 0.26509428f, -0.06998166f, 0.00454717f, 0.04024478f, 
    -0.31874520f, -0.06306773f, -0.44842243f, -0.35309520f, -0.14954400f, -0.01018503f, -0.06979293f, -0.02195137f, 
    -0.03882790f, -0.24096346f, -0.04109573f, -0.27224818f, -0.04379921f, 0.07594830f, -0.10687060f, -0.09064341f, 
    0.16563019f, 0.21314263f, 0.15771838f, -0.14658986f, 0.04658480f, 0.03892675f, 0.10928764f, -0.00686436f, 
    0.06718799f, -0.04164159f, -0.10734209f, 0.07055976f, 0.01843726f, 0.12553324f, 0.21798183f, 0.22781414f, 
    0.01929170f, 0.03416960f, -0.07385717f, 0.04104668f, -0.10724041f, -0.00255009f, 0.05007872f, 0.17659958f, 
    0.02739728f, -0.02086622f, 0.13247566f, 0.08480456f, 0.11779986f, -0.05903112f, -0.03057226f, 0.21954821f, 
    -0.03532925f, 0.14859904f, 0.07882959f, -0.00026812f, -0.17590043f, -0.00800747f, 0.12459928f, -0.01611074f, 
    0.23037168f, 0.15046377f, 0.09182818f, -0.03478436f, 0.08622258f, 0.02140757f, -0.05181361f, -0.05321557f, 
    -0.04758611f, -0.04672548f, -0.08767461f, 0.07063704f, -0.06864002f, 0.01571323f, 0.09611326f, -0.02024580f, 
    -0.16463298f, -0.00438152f, 0.09875818f, -0.06689658f, 0.06479773f, 0.02146065f, -0.07622821f, -0.05654513f, 
    -0.07212443f, -0.05844331f, 0.04291903f, 0.01946086f, -0.25820437f, 0.04226986f, 0.04178398f, -0.01296655f, 
    -0.05738536f, 0.03001853f, 0.03975799f, 0.01464605f, 0.00699073f, 0.09752722f, -0.12930608f, -0.26823568f, 
    0.52969402f, 0.06276190f, 0.04075675f, 0.17247145f, 0.02220487f, -0.11673202f, -0.02148820f, -0.02959073f, 
    0.00771403f, -0.00742042f, -0.13416348f, 0.10672702f, 0.06152557f, 0.16439529f, -0.05047223f, -0.11807865f, 
    -0.03374127f, -0.03669625f, -0.05910171f, 0.06321700f, -0.08440749f, -0.13712774f, -0.02772530f, 0.18707742f, 
    0.15655714f, -0.00172694f, -0.00401301f, 0.13067468f, 0.05883913f, 0.04932344f, 0.12856677f, -0.05964105f, 
    0.02537645f, -0.17592038f, 0.08886799f, -0.05441491f, 0.00172949f, 0.05354263f, 0.06205709f, 0.02514616f, 
    -0.08334515f, 0.12674817f, 0.00417775f, -0.08263946f, 0.11662889f, 0.09771837f, 0.27710596f, -0.10743012f, 
    0.12440259f, 0.06233836f, -0.18416122f, -0.01704976f, 0.03323077f, 0.05132414f, 0.12489315f, 0.08302827f, 
    -0.03981088f, 0.09958339f, 0.18558459f, -0.17105617f, 0.07581902f, -0.38510460f, -0.04293950f, 0.19086811f, 
    0.25325817f, 0.24832891f, -0.05475082f, 0.03195852f, 0.10435752f, 0.04933684f, 0.06506142f, -0.23554066f, 
    -0.08513375f, -0.14076303f, -0.13584520f, -0.14644136f, -0.13400629f, -0.08282850f, -0.09238821f, -0.24657188f, 
    -0.03944425f, 0.02885651f, 0.01559207f, 0.10368679f, -0.06289389f, -0.29815766f, -0.15461902f, 0.11410176f, 
    0.08403361f, 0.06597566f, -0.00173076f, 0.17817375f, 0.02128293f, 0.12293947f, -0.05696780f, 0.23572290f, 
    0.23395620f, 0.23518968f, 0.04962068f, 0.09777515f, 0.01628105f, -0.05134816f, -0.00732542f, -0.00721383f, 
    -0.09341690f, 0.07438766f, 0.10835311f, -0.12975198f, -0.06735279f, -0.16814230f, -0.01328800f, 0.12323250f, 
    -0.13907148f, -0.08640473f, 0.14705971f, 0.11454572f, -0.10180859f, 0.05795180f, -0.02472777f, -0.07754163f, 
    0.05050106f, 0.04233055f, 0.07088818f, -0.05515978f, 0.04486630f, -0.01045814f, 0.10627627f, 0.13081376f, 
    0.03967686f, -0.02427750f, 0.08093527f, 0.04956150f, 0.01147386f, -0.33552495f, 0.03795523f, 0.16816106f, 
    0.07576530f, 0.14096989f, -0.14737797f, 0.07076901f, -0.05329841f, 0.13987200f, -0.08155758f, -0.07769375f, 
    0.21337150f, -0.07599075f, 0.14241560f, -0.00079622f, -0.00182590f, -0.07656888f, -0.08955378f, 0.14578182f, 
    -0.07143910f, -0.07793131f, 0.05033228f, 0.00247494f, -0.04718002f, -0.24257463f, -0.13295443f, -0.14294183f, 
    0.12888627f, 0.05264902f, -0.02355102f, 0.09319443f, 0.22831723f, -0.05329634f, -0.04627332f, -0.04795492f, 
    0.18565197f, -0.06293812f, -0.32907209f, 0.18783478f, -0.08411916f, 0.01235367f, 0.09176107f, 0.13687588f, 
    -0.02397313f, -0.14417903f, -0.03699075f, -0.12255638f, -0.04562405f, 0.00050329f, 0.06249353f, -0.08157336f, 
    0.05101505f, 0.02006518f, 0.02681050f, 0.06343410f, -0.01505841f, -0.11543819f, 0.10930810f, 0.10297289f, 
    -0.17116500f, -0.41654283f, 0.02139929f, -0.07283781f, 0.03017928f, 0.01896120f, 0.07804339f, 0.04126242f, 
    -0.09529796f, -0.06609609f, -0.01499256f, 0.03205732f, -0.18010846f, -0.34395105f, -0.21103752f, 0.02445131f, 
    0.02884971f, 0.03693433f, 0.08569670f, -0.13415265f, 0.11474834f, 0.04997898f, 0.02666199f, 0.07593624f, 
    -0.15634952f, 0.00323106f, 0.02761666f, 0.17025091f, 0.03187663f, -0.05496475f, -0.01684290f, -0.02018899f, 
    0.12389168f, 0.07894462f, -0.01069801f, 0.08625562f, -0.13521139f, -0.18879509f, -0.05395375f, -0.11428300f, 
    0.10806306f, 0.04524455f, -0.06727615f, -0.08430869f, -0.02112096f, 0.00722333f, -0.11479791f, 0.11743087f, 
    -0.20077874f, -0.00088461f, 0.16341083f, 0.12772557f, 0.03961705f, 0.02463990f, 0.11646023f, -0.04087678f, 
    -0.03879761f, 0.03021259f, -0.15451077f, -0.09540094f, -0.41833207f, 0.10437743f, 0.19208480f, 0.15908948f, 
    -0.02198029f, -0.12352052f, 0.17829145f, -0.04554468f, -0.07937650f, -0.14627875f, -0.09786556f, 0.00896360f, 
    0.15321591f, 0.38293779f, 0.22514017f, -0.16196631f, 0.13488498f, 0.21846524f, -0.00612556f, 0.13460007f, 
    -0.12355465f, 0.08916044f, -0.04412625f, -0.02128546f, 0.05478882f, 0.13193583f, 0.40731007f, 0.05611472f, 
    0.05003078f, -0.13222075f, 0.08910883f, -0.07828809f, 0.10033154f, -0.11638170f, -0.00492719f, 0.03302284f, 
    0.13652007f, 0.13066266f, 0.14973797f, 0.02050332f, -0.07360404f, -0.05875778f, -0.00797887f, -0.01221307f, 
    0.09737855f, -0.06509247f, 0.07419048f, 0.13711132f, 0.14003746f, 0.26860777f, 0.26144779f, 0.02405946f, 
    0.04463350f, 0.03052477f, 0.01806027f, 0.06027873f, 0.12817720f, -0.10354012f, 0.08797350f, -0.06170128f, 
    -0.04624117f, -0.03279877f, 0.04612389f, 0.03363873f, 0.04930612f, -0.08300261f, -0.08550982f, -0.03612815f, 
    -0.07241914f, 0.03396479f, -0.04501601f, 0.13389528f, 0.07870111f, -0.08709305f, 0.04371181f, 0.01039437f, 
    -0.07475038f, -0.02620109f, 0.05858608f, 0.03323193f, 0.14908306f, 0.16258222f, 0.09899001f, -0.07418632f, 
    0.12790217f, 0.15384468f, -0.08761552f, -0.09116290f, -0.02561157f, 0.05205971f, 0.18647960f, 0.01653522f, 
    -0.00434688f, 0.07349636f, -0.04739546f, -0.12250860f, 0.12903382f, 0.01453537f, 0.01204578f, 0.14315917f, 
    -0.07277762f, -0.04828594f, -0.03642598f, 0.03403702f, -0.00143338f, 0.00071631f, 0.01760064f, -0.03296283f, 
    0.28352150f, 0.11733113f, 0.04664829f, 0.00341368f, -0.11594095f, 0.00566983f, -0.15176089f, -0.04605372f, 
    0.02148808f, -0.03161483f, -0.01086691f, 0.10077242f, -0.03604428f, 0.41016051f, 0.16850808f, -0.22541144f, 
    -0.17173773f, 0.01840348f, 0.13044149f, 0.08849231f, -0.01742530f, 0.02462863f, -0.05614326f, -0.18884504f, 
    0.23021977f, 0.02906688f, -0.10517534f, 0.26606420f, -0.10591361f, 0.05036782f, -0.04680134f, 0.02814342f, 
    0.01545752f, -0.01822510f, -0.06517768f, -0.03056377f, 0.04607171f, -0.05053124f, -0.11593750f, 0.02103304f, 
    0.03801057f, 0.05317898f, 0.00443093f, 0.03112537f, 0.02963795f, 0.06383634f, -0.14592519f, -0.16196831f, 
    -0.11186268f, -0.06133521f, -0.05872063f, 0.07634281f, 0.13926645f, -0.03109067f, 0.17698583f, 0.05395769f, 
    -0.01694955f, -0.03044000f, 0.13031343f, -0.05202307f, -0.01789564f, 0.04953982f, -0.02812599f, -0.00520278f, 
    -0.10192678f, 0.03404249f, -0.02411186f, 0.04211257f, 0.08431125f, 0.05937526f, 0.03972547f, 0.01465982f, 
    -0.08985965f, 0.01993935f, 0.17964445f, -0.01754347f, 0.04640128f, 0.05978779f, 0.08266193f, 0.05601873f, 
    0.00097744f, -0.08568902f, 0.05210684f, 0.06892716f, -0.46737683f, 0.05728505f, 0.18772778f, 0.26807639f, 
    -0.08723117f, 0.13860215f, -0.08870504f, 0.08430345f, -0.00619929f, -0.03590620f, -0.02298255f, -0.04868463f, 
    0.05168035f, -0.00897358f, -0.10500277f, -0.14298981f, -0.09222774f, -0.01895483f, -0.08338340f, -0.14752473f, 
    -0.04169585f, 0.07429399f, -0.06361902f, -0.00569093f, 0.25011298f, -0.24567087f, -0.01420863f, 0.14731707f, 
    0.02824369f, 0.00635556f, -0.06240803f, 0.00715722f, 0.08012763f, -0.06136859f, -0.03260583f, 0.09787050f, 
    -0.23788777f, 0.25308239f, -0.06796991f, -0.05503585f, 0.01341671f, 0.04734653f, 0.09425756f, 0.14261976f, 
    -0.00117564f, -0.00275694f, 0.00782128f, -0.09390659f, -0.07229365f, 0.08716508f, 0.22096519f, 0.09274444f, 
    0.12202606f, -0.03908449f, 0.19313580f, -0.06821691f, 0.06678743f, -0.02589851f, -0.02435339f, 0.05352228f, 
    0.12268304f, 0.00088547f, 0.01060570f, 0.16459927f, 0.07901561f, 0.11602309f, 0.09687882f, -0.10126046f, 
    0.08954260f, 0.05910330f, 0.04461755f, 0.19993816f, -0.00343280f, 0.63773632f, 0.15298782f, -0.17823257f, 
    0.23026405f, 0.04527804f, 0.08107454f, 0.08719181f, -0.18916501f, 0.11979810f, -0.04050613f, 0.02137882f, 
    -0.15108891f, 0.05681641f, -0.03831717f, 0.14378795f, 0.00767448f, -0.06351695f, 0.02782161f, -0.01902606f, 
    -0.02551492f, 0.11515755f, -0.19331592f, -0.10077347f, 0.08111619f, -0.02934612f, -0.03106035f, 0.00036821f, 
    -0.04634595f, -0.03333514f, 0.05335244f, -0.02267344f, 0.05724261f, 0.08608399f, 0.01140048f, -0.00287654f, 
    -0.27444217f, -0.04522853f, 0.27038288f, -0.11805101f, -0.06316786f, -0.15237644f, -0.19585109f, -0.08265430f, 
    0.05401657f, 0.05114754f, 0.00714109f, 0.10719822f, 0.10887098f, -0.02414515f, -0.03114198f, 0.06572501f, 
    0.00170997f, -0.12774639f, 0.07566920f, 0.05069063f, -0.03883757f, 0.05888451f, -0.06402674f, -0.00694537f, 
    -0.09533812f, 0.51998299f, 0.04943300f, 0.00470029f, 0.10945033f, -0.07593717f, -0.07246851f, -0.12553318f, 
    0.14648151f, -0.02070100f, -0.06606874f, 0.09705288f, -0.06586741f, 0.10608353f, 0.02962564f, -0.00628106f, 
    -0.07643339f, -0.03415983f, -0.15574269f, 0.02320618f, -0.01805878f, 0.05577448f, 0.04936351f, 0.01010957f, 
    0.20605367f, 0.14136033f, 0.05616568f, -0.12442750f, -0.04470132f, 0.09522915f, -0.03098503f, 0.04710614f, 
    -0.28770980f, 0.09356350f, -0.01404630f, -0.01582343f, -0.06645959f, 0.02689729f, 0.03362768f, -0.05367179f, 
    -0.09576114f, 0.00827161f, -0.04372780f, -0.10159816f, 0.10054587f, -0.05542324f, 0.11137304f, 0.00463882f, 
    0.20300156f, 0.18485484f, -0.10082517f, -0.01919533f, -0.12374445f, -0.01648233f, 0.05583115f, -0.01725932f, 
    -0.03424409f, 0.11275684f, 0.18138753f, 0.01261368f, 0.36844808f, -0.05478438f, 0.25141302f, -0.01406227f, 
    -0.00303662f, 0.02677895f, -0.12311909f, -0.07185858f, -0.06112960f, 0.07948821f, 0.03979310f, -0.05637097f, 
    -0.38523325f, -0.27641454f, 0.04928664f, 0.23239338f, 0.22384810f, 0.05522116f, 0.01138550f, -0.04756863f, 
    0.04617562f, -0.03569457f, -0.03578376f, -0.05306688f, 0.02836111f, -0.10558745f, -0.13328457f, 0.17103973f, 
    -0.11973750f, -0.12992655f, 0.04718933f, -0.14327934f, -0.06873561f, 0.02244083f, -0.06424436f, 0.11607200f, 
    0.15580715f, -0.07808606f, -0.05332362f, -0.04786311f, -0.00283216f, 0.06840120f, -0.09891942f, 0.12878178f, 
    -0.22930910f, 0.11619772f, 0.19454390f, -0.05886243f, -0.08414029f, -0.07726474f, -0.07670774f, 0.05487411f, 
    0.00011822f, 0.01803583f, 0.07115388f, 0.07761700f, 0.01786601f, 0.07923648f, -0.04825949f, 0.10829657f, 
    -0.07425656f, -0.11076556f, -0.13732097f, 0.00665452f, 0.16762808f, -0.03956050f, 0.20631938f, -0.20737562f, 
    -0.07170843f, 0.03727233f, -0.12245062f, 0.13512757f, -0.25407076f, 0.21827830f, -0.02522242f, 0.31138355f, 
    0.05087396f, -0.06497233f, 0.05379332f, -0.05723828f, 0.07232651f, 0.02070334f, 0.03222565f, 0.07202040f, 
    -0.23976637f, 0.06728084f, -0.09775595f, -0.15764800f, -0.03587507f, 0.15577152f, -0.11610813f, 0.12238874f, 
    0.01966713f, 0.14536379f, 0.04436801f, 0.05802670f, -0.08274731f, -0.05754704f, 0.04454304f, 0.01127816f, 
    -0.05230020f, -0.05117310f, -0.05243811f, -0.00930856f, -0.03838906f, -0.16135453f, -0.08667029f, 0.05666205f, 
    0.22731841f, -0.23717828f, -0.02649146f, 0.02667141f, 0.09932721f, 0.14586407f, 0.13972455f, -0.09825832f, 
    -0.06223626f, 0.03613389f, -0.02925850f, -0.00967471f, 0.22476873f, 0.06077251f, 0.02759258f, -0.00631569f, 
    0.00565485f, -0.13457210f, 0.02484094f, -0.07240263f, 0.03042652f, 0.12648362f, 0.17025548f, 0.13308896f, 
    0.09124418f, -0.07828397f, 0.11545353f, -0.08158228f, 0.07331616f, -0.02075119f, 0.01357504f, -0.05894601f, 
    0.02564698f, 0.03920466f, -0.01135950f, -0.01955387f, 0.17632864f, 0.01560396f, -0.06140070f, 0.10652492f, 
    0.04550776f, 0.08829804f, 0.05544482f, 0.01768941f, -0.01678875f, -0.11159641f, -0.03297535f, 0.02816029f, 
    -0.16804160f, -0.12747948f, 0.12691729f, 0.06390051f, -0.02313967f, -0.09546100f, -0.11967643f, 0.04906947f, 
    0.02308891f, 0.09143113f, 0.09064050f, 0.00969901f, 0.03836703f, 0.00967187f, 0.07005296f, -0.02747739f, 
    0.01178195f, -0.03530254f, -0.07599948f, -0.03588491f, 0.22013512f, 0.19456193f, -0.10776936f, 0.08998062f, 
    -0.08282522f, -0.11062770f, 0.02263273f, 0.09597354f, 0.08103616f, -0.14924543f, 0.00134573f, -0.01386226f, 
    0.07896523f, -0.01920951f, 0.08788263f, 0.20721844f, -0.12047680f, -0.00835853f, 0.09171513f, 0.08485681f, 
    -0.13957964f, -0.12603529f, 0.02904657f, 0.04588682f, 0.03016627f, 0.15149927f, -0.05486178f, 0.12800367f, 
    0.11461274f, -0.13549300f, -0.04593515f, 0.05885341f, 0.02097466f, 0.03172167f, 0.07708155f, -0.11866308f, 
    0.03255572f, -0.07809224f, -0.07076655f, 0.04328630f, 0.18038075f, 0.00694747f, 0.01103562f, -0.06933422f, 
    0.12894110f, 0.04708384f, 0.09527531f, 0.16863288f, -0.02252650f, 0.22925587f, 0.00285281f, -0.00380047f, 
    -0.39037237f, -0.23216055f, 0.12506555f, -0.10930748f, 0.06540497f, -0.05292883f, -0.07045535f, 0.04238493f, 
    0.07268946f, 0.09620452f, 0.19101205f, 0.08500734f, -0.22234400f, -0.14280461f, 0.00635419f, -0.09013058f, 
    -0.03160309f, -0.01235788f, -0.06592181f, 0.00611882f, 0.00112680f, 0.02636789f, -0.01482511f, -0.02042499f, 
    -0.17578351f, 0.10884332f, 0.02660843f, -0.02241268f, 0.04665651f, 0.16634499f, 0.04494168f, 0.07222796f, 
    0.00484161f, 0.01063885f, 0.19835855f, 0.36924097f, 0.01351348f, -0.10507713f, 0.09518624f, 0.14828278f, 
    -0.04799199f, -0.03621776f, -0.13958967f, 0.08424615f, 0.10357653f, 0.18539619f, 0.03304981f, -0.03108662f, 
    0.14407094f, -0.00344007f, 0.03084588f, -0.19323178f, -0.01857671f, 0.04700153f, -0.12333301f, 0.12725559f, 
    -0.09348365f, -0.12085241f, -0.12508735f, 0.03446330f, -0.22234589f, -0.24058637f, -0.11005848f, -0.12440959f, 
    -0.08242890f, -0.27168348f, -0.02274094f, -0.06773651f, 0.14647625f, 0.05062585f, 0.03628843f, 0.05583396f, 
    -0.05826752f, 0.11313228f, -0.14413977f, 0.12543298f, -0.12392864f, 0.13038799f, 0.03659033f, 0.09098826f, 
    0.05095652f, -0.11301868f, -0.07485483f, -0.11589116f, 0.00717136f, 0.20517644f, 0.04630874f, 0.02495196f, 
    -0.04069231f, -0.13748431f, 0.11405885f, 0.07027027f, -0.02319117f, -0.01815642f, -0.01033926f, -0.02904887f, 
    0.07256429f, -0.16764778f, 0.09334616f, 0.01613134f, -0.12033866f, 0.03728797f, 0.06806935f, 0.02273671f, 
    0.02111302f, -0.21943830f, -0.05525531f, -0.03276376f, -0.11001164f, -0.21054813f, -0.16012539f, 0.16652906f, 
    0.16279322f, 0.03657968f, -0.08063000f, -0.11491030f, -0.07118078f, -0.15878357f, -0.10904822f, -0.27845293f, 
    -0.07773908f, -0.05425681f, 0.01951590f, 0.20240496f, 0.13647696f, 0.04051536f, -0.02677719f, -0.05436877f, 
    0.14786950f, 0.07406446f, 0.18615979f, 0.06265635f, -0.04376869f, -0.12868653f, 0.00063396f, -0.12570944f, 
    -0.11379843f, -0.06992280f, -0.15956448f, -0.02044861f, -0.01264143f, -0.01636294f, -0.01318231f, 0.24555822f, 
    0.00789738f, -0.01222704f, 0.02750192f, 0.03646477f, 0.16971980f, 0.07262731f, 0.04490188f, 0.05660672f, 
    0.13693549f, -0.02226025f, 0.12475461f, 0.12186310f, -0.15693139f, 0.03906519f, 0.24391928f, -0.04736266f, 
    -0.21139164f, -0.08187904f, 0.16391128f, 0.00244822f, 0.05761353f, 0.07154955f, 0.01389970f, 0.04931239f, 
    -0.32763511f, -0.07739200f, 0.03535889f, -0.29733065f, 0.13002537f, 0.09659280f, -0.06322177f, -0.00358916f, 
    -0.06666134f, 0.02677424f, -0.01721649f, -0.04541752f, 0.08022729f, 0.22881813f, 0.20735289f, 0.01371276f, 
    0.05807796f, -0.00784746f, 0.01168169f, -0.01938408f, 0.05152029f, -0.18868916f, -0.00381255f, -0.13171080f, 
    -0.12211151f, -0.24888347f, 0.10671838f, 0.04961395f, -0.02277517f, 0.03116214f, 0.05079211f, -0.00583422f, 
    0.04366708f, -0.01231307f, 0.08651764f, 0.02118924f, 0.09374532f, 0.01569742f, 0.21780567f, 0.03257691f, 
    0.19837710f, 0.23637630f, 0.11927209f, 0.19768351f, 0.17283444f, -0.03229536f, 0.01285588f, 0.23165095f, 
    -0.07795458f, -0.00200613f, -0.06722313f, -0.06589622f, 0.08291658f, -0.17349641f, 0.22039643f, -0.08205461f, 
    -0.13640375f, -0.07627101f, -0.09662038f, -0.16574658f, -0.03445626f, -0.15553115f, 0.06874868f, 0.32499993f, 
    0.05019410f, 0.17899287f, -0.13034411f, -0.02662126f, 0.09133646f, -0.08696740f, 0.15890764f, 0.16846703f, 
    -0.32136908f, -0.14654464f, 0.06435093f, -0.06125055f, -0.14218666f, -0.01821919f, -0.09817409f, 0.09666102f, 
    -0.00381646f, 0.07365577f, 0.07258578f, -0.01006641f, 0.06492683f, 0.08685524f, 0.08569390f, 0.01880152f, 
    0.01397023f, -0.05845624f, -0.01169454f, -0.04995584f, 0.04164701f, -0.03799229f, 0.11188349f, 0.04575635f, 
    0.37315243f, 0.03659756f, -0.15888894f, 0.18995441f, -0.02460968f, 0.08366586f, 0.08618682f, -0.00116139f, 
    -0.12167892f, 0.03248568f, -0.07217591f, -0.01576786f, -0.06938961f, -0.35620579f, -0.07171690f, -0.25776640f, 
    0.06579532f, -0.11390345f, -0.10556175f, 0.09970384f, -0.09456542f, 0.06489094f, 0.10610464f, 0.15589707f, 
    0.26123354f, -0.08108374f, 0.07861045f, 0.18778196f, -0.01945184f, 0.04352914f, 0.03902753f, 0.07853199f, 
    0.04217918f, 0.20202537f, 0.08113684f, 0.10013222f, 0.06897415f, 0.12709203f, 0.00752949f, -0.03453698f, 
    0.05122863f, 0.14022134f, 0.10195734f, 0.05092758f, 0.20753083f, 0.06727447f, 0.17792660f, 0.25791031f, 
    0.01281442f, 0.12513690f, 0.06451696f, 0.06890723f, 0.10361215f, 0.12929869f, -0.07037398f, 0.05354239f, 
    -0.02146450f, -0.14540713f, -0.01464166f, 0.06604584f, 0.00266439f, 0.07864685f, 0.03903984f, 0.08617622f, 
    0.04729181f, -0.00010371f, 0.03933327f, -0.07636133f, 0.21629493f, 0.15264031f, -0.02149478f, -0.11949556f, 
    0.05953955f, 0.03516982f, 0.05486102f, 0.08057679f, 0.02767085f, -0.09439809f, 0.07056167f, 0.00119319f, 
    -0.03480979f, 0.00832919f, -0.06485799f, -0.11920250f, -0.18148117f, 0.09103069f, 0.01646546f, 0.10501578f, 
    -0.09756551f, 0.09622210f, -0.03574966f, -0.14539695f, 0.01316342f, -0.14204229f, -0.03745962f, -0.12818527f, 
    0.13000318f, -0.19413882f, -0.18940166f, 0.01188156f, -0.07182397f, 0.04620688f, 0.08283694f, 0.12065379f, 
    -0.17274052f, -0.02767210f, -0.11039902f, 0.05133675f, -0.07201427f, 0.00616189f, 0.10685387f, -0.10761754f, 
    -0.00335012f, -0.05367508f, 0.05936839f, 0.17484152f, -0.03934393f, 0.16721949f, 0.04844613f, 0.02807827f, 
    -0.04856612f, 0.11980626f, 0.24082379f, -0.08885482f, -0.07845481f, -0.30928624f, 0.03088651f, 0.05529539f, 
    -0.06045144f, -0.00908267f, 0.08264525f, -0.02969956f, -0.17702152f, -0.08898219f, -0.03675422f, -0.04469077f, 
    -0.12875600f, -0.11659500f, 0.03841049f, 0.01469098f, -0.17611037f, -0.11674631f, -0.02664346f, -0.16624896f, 
    0.09015033f, -0.18824621f, 0.20946626f, 0.04565572f, 0.00367800f, -0.00380018f, 0.01348554f, -0.04138049f, 
    -0.09069677f, 0.00930720f, -0.01166664f, -0.05909136f, -0.11521571f, 0.21706450f, 0.01952068f, 0.11912195f, 
    0.28865868f, 0.07181396f, 0.14255105f, -0.13347740f, -0.02957307f, -0.07077110f, 0.08319155f, 0.10845910f, 
    -0.20843548f, 0.04264165f, 0.13535781f, 0.34659767f, -0.13357094f, -0.00415262f, 0.01559575f, -0.19104406f, 
    0.05733654f, 0.08160008f, 0.07569983f, 0.00503716f, 0.09304958f, 0.12784101f, -0.11163712f, -0.15773211f, 
    -0.00993866f, 0.16481251f, -0.13451019f, 0.00078305f, -0.03192816f, 0.01967615f, 0.04974937f, -0.13197450f, 
    0.27592534f, 0.06495107f, 0.41115165f, -0.07133744f, -0.01232355f, -0.10719612f, -0.13942403f, 0.05377865f, 
    -0.01640567f, 0.10406937f, -0.02235062f, -0.00224721f, -0.14902751f, -0.01962021f, 0.08851310f, 0.11737490f, 
    -0.10206655f, 0.08791705f, -0.06448598f, 0.09206668f, 0.05421547f, 0.12634057f, -0.00554730f, -0.19189547f, 
    0.08220375f, 0.33945799f, -0.18649299f, 0.13834813f, -0.15797108f, -0.06107858f, -0.08118685f, 0.00580753f, 
    -0.10254429f, 0.00647482f, -0.15224251f, 0.02687190f, 0.02163000f, 0.21477488f, 0.16012168f, -0.28458181f, 
    -0.19460812f, -0.05569998f, -0.12444089f, -0.06873193f, 0.07880917f, 0.10514488f, 0.04131112f, 0.08688211f, 
    -0.20425627f, 0.02042532f, 0.11840931f, -0.04584747f, -0.16229039f, 0.03438858f, 0.09857041f, 0.12207741f, 
    -0.09894380f, 0.02854758f, -0.03186139f, 0.26600084f, -0.16553336f, 0.19196463f, -0.13952956f, -0.09024762f, 
    -0.04263856f, 0.03563730f, -0.00256862f, 0.06041415f, 0.14455648f, 0.14284605f, 0.10610560f, -0.14891639f, 
    -0.03411143f, -0.16102749f, -0.11024565f, -0.05900914f, 0.03389154f, -0.10058179f, 0.02606017f, 0.16999486f, 
    0.06936412f, 0.08423951f, 0.03996568f, 0.06788241f, -0.04955205f, 0.02971981f, -0.20035459f, 0.03426956f, 
    0.07326774f, 0.02822238f, -0.12924813f, 0.15277930f, -0.07462773f, 0.06215822f, -0.05342409f, 0.08136201f, 
    -0.20411663f, -0.16065757f, 0.08149954f, 0.10418011f, -0.05408883f, 0.04853388f, 0.02554979f, -0.00024380f, 
    0.00450278f, -0.01575882f, -0.03588845f, -0.06178466f, 0.12045535f, -0.21339823f, -0.01322470f, 0.03799171f, 
    -0.06054527f, 0.22076963f, -0.10344116f, 0.06117004f, -0.05191767f, 0.15254875f, -0.04602105f, 0.18048304f, 
    0.13931406f, 0.47613201f, -0.22509049f, 0.26463112f, 0.05289451f, -0.02215753f, 0.08689064f, -0.02923824f, 
    -0.07667310f, 0.00053945f, 0.09167990f, 0.04335077f, -0.17774546f, -0.10607697f, -0.11582690f, 0.19989647f, 
    -0.17597581f, 0.00151549f, 0.06659499f, -0.04376681f, -0.07367681f, -0.00497645f, 0.03430726f, -0.11785695f, 
    -0.09731273f, 0.12023930f, 0.15047376f, -0.03446320f, 0.01273761f, 0.06478216f, 0.09185440f, 0.02434833f, 
    -0.09584731f, -0.09398472f, 0.09443755f, 0.07882861f, -0.18960060f, -0.23867103f, 0.03922222f, 0.42143831f, 
    0.06860574f, 0.04792662f, -0.13589410f, -0.00194361f, 0.09775159f, 0.12616862f, -0.01672827f, -0.03341027f, 
    -0.07867713f, 0.03313878f, 0.26132593f, -0.13164714f, -0.01082126f, -0.00967139f, -0.09064347f, 0.17083278f, 
    -0.03080824f, 0.02020138f, 0.06157848f, -0.02391442f, -0.07766937f, -0.10692354f, -0.08279084f, 0.00417269f, 
    0.05159527f, -0.01762717f, -0.00844802f, -0.01898699f, 0.15101513f, 0.00850156f, 0.00036758f, -0.08518802f, 
    0.42799076f, 0.00925855f, -0.18166290f, 0.25212514f, -0.06252863f, 0.22593854f, 0.00127898f, 0.14493787f, 
    -0.05103159f, -0.08346929f, 0.05619725f, -0.07785442f, -0.21896435f, 0.04548538f, 0.08011772f, -0.11764667f, 
    -0.16617256f, -0.08988746f, 0.07048370f, 0.05144629f, -0.08744011f, 0.00431360f, 0.07479215f, 0.02043389f, 
    0.05036797f, -0.23874310f, 0.08482999f, 0.16726498f, -0.10500047f, 0.10273421f, -0.07355130f, 0.10614544f, 
    -0.01848407f, -0.18067761f, -0.04111842f, -0.06783047f, 0.22045797f, -0.21414074f, -0.12455530f, 0.04427116f, 
    0.00444892f, 0.07462948f, 0.08581037f, -0.04817427f, 0.00378157f, 0.07459116f, 0.02019406f, 0.04733678f, 
    -0.26457930f, 0.07355995f, 0.09910232f, 0.30381081f, 0.15814143f, -0.03199218f, -0.03041216f, -0.20328094f, 
    0.09565855f, 0.07776248f, 0.15160081f, -0.10259365f, -0.03254142f, -0.06069723f, -0.06361020f, -0.00929951f, 
    -0.02391146f, 0.02055410f, 0.00826378f, 0.06271792f, -0.02410671f, 0.06486616f, -0.14392269f, 0.01679676f, 
    0.06780687f, -0.00243554f, 0.02916716f, 0.19340430f, 0.21503554f, 0.16103771f, 0.12093004f, -0.07710136f, 
    0.03862456f, 0.08308277f, -0.09408671f, 0.12447007f, -0.43461189f, 0.10532299f, 0.08746759f, 0.29286876f, 
    -0.28912652f, 0.05043285f, 0.24254391f, 0.00856823f, -0.02557537f, 0.06224668f, -0.06274903f, -0.06182081f, 
    -0.07153622f, 0.03190540f, -0.03027980f, -0.12168444f, 0.09772955f, 0.11599177f, 0.02474471f, 0.00085396f, 
    -0.12062688f, -0.00357258f, 0.00208718f, -0.06887485f, 0.17828980f, 0.03306164f, 0.28019431f, -0.07231676f, 
    0.10508400f, -0.09264454f, -0.11722169f, 0.10250757f, 0.04337981f, -0.18383747f, 0.07638250f, -0.10042591f, 
    -0.27941924f, 0.15621768f, 0.08038475f, 0.10037741f, -0.09351756f, -0.03395975f, -0.05154485f, -0.06582139f, 
    0.03283819f, -0.06242553f, -0.05996720f, -0.01279695f, -0.03951770f, 0.08529211f, 0.25665125f, 0.09217957f, 
    0.02791844f, 0.16035719f, -0.02556844f, 0.09008832f, 0.15113544f, -0.18344377f, -0.00297281f, 0.00212362f, 
    -0.04789155f, -0.05708683f, 0.03737223f, -0.01152457f, -0.07243633f, 0.03072250f, -0.03297262f, 0.04092317f, 
    -0.06662466f, 0.02358744f, 0.02235820f, -0.01015709f, 0.04271321f, 0.04234939f, 0.02723614f, -0.03620049f, 
    -0.03334364f, 0.02240038f, 0.02124120f, 0.02646703f, -0.00648428f, 0.04885739f, -0.05541844f, -0.05778622f, 
    0.07420017f, -0.00573221f, 0.01007779f, 0.05188386f, -0.07215749f, -0.03674101f, -0.07764287f, -0.03125288f, 
    -0.00927097f, -0.06667022f, -0.00484044f, -0.02532556f, 0.01204673f, 0.02325859f, -0.03080530f, -0.05685547f, 
    -0.00183285f, -0.05734444f, 0.01445183f, -0.00019901f, -0.07285538f, 0.01544001f, -0.01455327f, 0.02775558f, 
    0.07018653f, -0.06985609f, 0.00640703f, -0.07153004f, 0.04443366f, 0.04567035f, 0.01711584f, 0.03157194f, 
    -0.01401047f, -0.04921452f, -0.04365860f, -0.01425937f, 0.07031824f, 0.06140800f, -0.01798784f, 0.06215657f, 
    0.04958631f, -0.03856104f, -0.02788530f, 0.04432115f, -0.00292795f, -0.05705643f, -0.02275939f, -0.02555394f, 
    -0.01476193f, 0.02174840f, -0.01365663f, -0.03241486f, 0.02328608f, 0.00074534f, -0.02370652f, -0.01614140f, 
    0.02103696f, 0.01594961f, -0.02402055f, 0.04188254f, 0.02344770f, 0.00603470f, 0.00485864f, -0.00030781f, 
    0.04595171f, -0.04995092f, 0.00326673f, 0.03782455f, -0.02415810f, 0.02264161f, 0.03577539f, 0.04457330f, 
    0.04912353f, -0.04740583f, 0.06263488f, 0.02055041f, -0.08370449f, 0.06147866f, -0.06833609f, 0.01439862f, 
    -0.07295283f, -0.06588228f, 0.00430906f, 0.02359553f, -0.00671163f, 0.02124028f, -0.04125306f, -0.02873491f, 
    0.01871248f, -0.04594263f, 0.04362973f, -0.05552743f, -0.04278297f, 0.04591375f, -0.04682607f, 0.00365277f, 
    0.04852977f, -0.06328347f, 0.04276579f, 0.02575778f, -0.01213331f, -0.05689367f, 0.05253494f, -0.05650786f, 
    -0.05088710f, -0.05092518f, 0.04221468f, 0.04843806f, -0.05236948f, -0.00021601f, -0.06633323f, 0.01192880f, 
    0.04890036f, -0.04166100f, -0.05776542f, -0.06827516f, -0.00906685f, -0.00748422f, -0.06384495f, 0.01116093f, 
    0.04993337f, 0.00150820f, 0.00204371f, -0.01813681f, -0.05113170f, 0.00907576f, -0.05610635f, 0.00533221f, 
    -0.04201296f, -0.04688895f, -0.07288342f, -0.07449522f, 0.02087940f, 0.03553514f, -0.07287919f, -0.00116799f, 
    -0.05599691f, -0.04091838f, 0.04448904f, 0.03588412f, 0.00768469f, -0.02001703f, 0.02493038f, 0.05456004f, 
    -0.08637054f, -0.05741462f, -0.04631596f, -0.06316826f, 0.05569800f, -0.05219233f, -0.00048454f, -0.03046640f, 
    0.04416031f, -0.06713880f, 0.03516531f, -0.05138189f, -0.04474416f, 0.02655162f, -0.05236533f, -0.03367037f, 
    -0.03013778f, -0.03959318f, -0.07208876f, 0.00251775f, 0.01678909f, 0.05580666f, 0.04877470f, 0.01388247f, 
    -0.02338620f, -0.04621549f, 0.00224307f, 0.05460444f, 0.01500012f, 0.09158057f, -0.05231633f, 0.00620696f, 
    -0.03636685f, 0.03633247f, -0.03815515f, 0.01659969f, 0.03224023f, 0.35582200f, -0.24044490f, -0.01001738f, 
    0.13990802f, -0.14877243f, 0.00810763f, 0.06848209f, -0.07264007f, 0.07251015f, -0.01604233f, 0.00364276f, 
    -0.02189521f, -0.03220255f, -0.19753626f, -0.10623987f, 0.09639153f, 0.05221912f, -0.01979088f, 0.10888851f, 
    -0.26914951f, -0.14773715f, -0.18298869f, -0.00072751f, -0.06248300f, -0.01340585f, 0.03341420f, 0.00320957f, 
    0.08394895f, 0.08186384f, 0.09999906f, -0.11597078f, 0.00462702f, -0.03776622f, -0.09634560f, 0.07801735f, 
    0.19053167f, 0.01285178f, 0.03691929f, 0.04641924f, 0.12567218f, 0.05458190f, -0.05147184f, 0.06711448f, 
    -0.02233417f, 0.05901369f, 0.03171197f, -0.04688896f, 0.24636501f, -0.09924901f, -0.02515316f, -0.05882048f, 
    0.08920461f, -0.01011605f, -0.03951992f, -0.14838909f, 0.07748996f, -0.08196185f, 0.03468822f, 0.25504628f, 
    -0.25964245f, 0.01067581f, 0.04382716f, 0.06770375f, 0.03084960f, 0.01036786f, -0.05675440f, -0.05537962f, 
    0.06860818f, -0.04704643f, 0.05008223f, 0.08939030f, -0.00989286f, -0.00207462f, -0.08405644f, 0.06313182f, 
    0.04946299f, 0.07129413f, -0.06174085f, -0.02410264f, -0.04972566f, 0.11149109f, 0.03608222f, -0.18507950f, 
    0.11852736f, -0.04964200f, 0.01588492f, -0.02496101f, 0.18719770f, -0.03061264f, -0.03883327f, 0.06565583f, 
    -0.07161687f, 0.37509128f, 0.04858320f, 0.00045495f, -0.01178947f, -0.01475923f, -0.08579838f, -0.03339267f, 
    0.04029980f, -0.11777455f, 0.08655786f, -0.03729150f, -0.12451666f, -0.14963947f, -0.13568902f, 0.18701845f, 
    0.12925170f, 0.08927009f, 0.06460648f, -0.01974418f, 0.13947794f, -0.10460044f, -0.04187158f, 0.04389489f, 
    -0.04094229f, 0.03191678f, 0.00646368f, 0.16234057f, 0.37694898f, 0.18456405f, 0.10137557f, -0.06056487f, 
    -0.03514539f, -0.15808870f, 0.00753677f, 0.02152468f, -0.09247952f, 0.02669669f, 0.07986426f, 0.02392392f, 
    -0.01496359f, 0.12162828f, 0.18666627f, 0.02109606f, 0.09863845f, -0.04823012f, -0.17383417f, 0.09148794f, 
    0.11423264f, 0.07158855f, -0.04563611f, -0.04684210f, 0.06890029f, 0.06043930f, -0.00910366f, 0.09110860f, 
    -0.08185665f, -0.05178947f, 0.07205962f, -0.15936008f, -0.00612229f, -0.07755246f, 0.16567229f, -0.18591024f, 
    -0.21419109f, -0.44539890f, 0.13466789f, -0.04701917f, 0.04803174f, -0.04446462f, 0.09366654f, -0.05298973f, 
    0.18678856f, 0.08016232f, 0.08029590f, 0.00136575f, 0.17050096f, 0.12776154f, -0.01111779f, -0.15149353f, 
    0.17145662f, 0.13043986f, -0.14094935f, -0.01386868f, 0.07049989f, 0.00140551f, -0.01096217f, -0.04214849f, 
    -0.08809221f, 0.03232038f, -0.08472552f, 0.05434442f, -0.01637874f, 0.08070331f, -0.06579041f, 0.07754076f, 
    0.08578020f, 0.01668074f, -0.04394558f, 0.13712510f, 0.41722304f, 0.07019687f, 0.03097137f, -0.13510013f, 
    -0.17594662f, -0.09137002f, 0.13054749f, 0.02421187f, 0.18177429f, 0.12103543f, 0.14318511f, -0.08441933f, 
    0.28236371f, 0.06576503f, -0.32148784f, -0.12551883f, 0.11899143f, 0.14075550f, 0.13195209f, -0.11805713f, 
    -0.01288975f, 0.05689520f, -0.08077945f, -0.03837520f, -0.14519787f, -0.01950790f, -0.06807911f, 0.10925130f, 
    -0.11658517f, -0.17214884f, 0.04478619f, -0.23897584f, -0.24781148f, 0.01531887f, -0.08176642f, 0.06298295f, 
    -0.35683465f, -0.03853449f, 0.15022083f, -0.03976860f, 0.02981279f, 0.02437331f, -0.00116288f, -0.16039938f, 
    0.08202229f, -0.04564967f, -0.03696793f, 0.19386294f, 0.18535763f, 0.28526551f, 0.05717444f, -0.16842481f, 
    -0.03368847f, 0.09793802f, 0.01695992f, 0.05644844f, -0.04801888f, -0.00441664f, -0.08111202f, 0.07739338f, 
    0.18506384f, -0.00443626f, 0.00231713f, 0.20034298f, -0.01344585f, -0.11967596f, 0.03146147f, -0.19214119f, 
    0.14985150f, 0.03180250f, 0.02447000f, 0.01680899f, -0.07410864f, 0.05319721f, 0.03685714f, 0.06667595f, 
    0.09450684f, -0.11871155f, -0.20491414f, 0.04306711f, -0.18023159f, -0.08615649f, -0.10260998f, -0.23243797f, 
    0.19778635f, -0.15073550f, 0.03670171f, -0.13030162f, -0.03330292f, 0.02285328f, 0.14136732f, -0.06097315f, 
    0.01918792f, 0.12089759f, 0.01009325f, -0.03533790f, 0.07019509f, -0.14663503f, 0.11313044f, 0.03532157f, 
    -0.22717790f, -0.18035321f, -0.17939202f, -0.19605699f, 0.02595434f, -0.04410291f, 0.16240136f, 0.14134878f, 
    -0.07561160f, -0.05553136f, 0.13929006f, -0.12517932f, 0.06559668f, 0.03335963f, 0.01606689f, 0.04249407f, 
    0.13584629f, -0.03163977f, 0.19241206f, 0.08417580f, 0.25904396f, 0.05668838f, 0.34126908f, -0.19707140f, 
    -0.00090310f, 0.05865945f, -0.08048256f, 0.13671517f, 0.08588494f, 0.01852412f, -0.07782331f, 0.12497469f, 
    0.15282610f, -0.20425335f, -0.30001736f, -0.02546752f, -0.03212571f, -0.09913056f, -0.12259523f, -0.03241596f, 
    -0.01364353f, -0.05568113f, -0.06081027f, 0.02475894f, 0.21518841f, -0.12615311f, -0.31204462f, 0.14024490f, 
    0.06442201f, 0.12274337f, -0.04224663f, 0.00010190f, 0.00057476f, 0.04918030f, -0.11036265f, 0.04021144f, 
    -0.16772418f, -0.04274393f, 0.20099156f, -0.06760105f, 0.10315639f, 0.12802851f, 0.07177310f, 0.12751509f, 
    0.01518604f, 0.04874320f, 0.14469948f, 0.07603262f, 0.26075238f, 0.10578117f, -0.04624007f, -0.21590637f, 
    0.23537117f, -0.06172642f, 0.09293940f, 0.02602673f, -0.06520489f, -0.04602044f, -0.15470490f, 0.10389735f, 
    -0.02818582f, 0.01456900f, 0.03798000f, 0.03956106f, 0.04614063f, 0.11429525f, 0.05623756f, 0.11658441f, 
    0.04942702f, 0.03429726f, 0.03386318f, -0.12732482f, 0.13014562f, -0.18082049f, 0.41086355f, 0.03051618f, 
    0.01407877f, -0.00007014f, -0.22689880f, -0.06845457f, -0.07567925f, 0.11815219f, 0.07007236f, 0.02321499f, 
    -0.01572853f, 0.11432458f, 0.30481696f, -0.00791188f, 0.16880365f, -0.03614429f, -0.14346759f, 0.04871202f, 
    -0.01999529f, 0.12121993f, 0.09506539f, 0.10184285f, -0.03880570f, -0.23996533f, -0.07525718f, -0.07352269f, 
    0.05345486f, -0.00318182f, -0.04320983f, 0.02102925f, 0.03504392f, -0.10050877f, 0.01798336f, -0.01325009f, 
    -0.10272916f, -0.12503400f, -0.52616334f, 0.10531641f, 0.00554060f, 0.02648187f, 0.18508391f, 0.03663297f, 
    0.04286991f, -0.05080007f, 0.02910245f, -0.12960929f, -0.10816613f, -0.15020147f, -0.04696688f, 0.17214841f, 
    -0.02961922f, 0.06759410f, 0.01520135f, 0.01884127f, -0.01109315f, -0.00284935f, -0.05404529f, -0.07058381f, 
    -0.04614319f, -0.00592961f, 0.02080631f, -0.06760966f, 0.08859117f, -0.02682975f, 0.01317782f, 0.05110151f, 
    0.08318380f, -0.02097739f, -0.03807970f, 0.11602563f, -0.12296750f, -0.03832819f, -0.01990232f, -0.02611111f, 
    -0.02174001f, 0.09218182f, 0.14848629f, -0.03424332f, 0.05720868f, -0.01111103f, -0.07476857f, 0.10602999f, 
    -0.20401041f, 0.17282006f, 0.36269319f, 0.28846827f, -0.00086580f, 0.00634220f, -0.07569817f, -0.03731426f, 
    -0.05815073f, 0.06831176f, 0.07522487f, 0.04300806f, -0.02899239f, 0.02462778f, 0.01773022f, -0.00361595f, 
    0.05107852f, -0.04020697f, -0.05317866f, 0.08520506f, 0.04964393f, -0.08482166f, 0.03035898f, 0.05154828f, 
    -0.17733012f, -0.01450784f, 0.03215529f, 0.02183085f, 0.01635363f, 0.16400853f, 0.03628708f, 0.01502893f, 
    -0.05708772f, -0.13411877f, -0.11242710f, 0.04117380f, -0.41273203f, 0.02130234f, -0.00245191f, -0.13328537f, 
    -0.09708890f, -0.00580442f, 0.20414126f, -0.04225250f, -0.04408045f, -0.12084269f, -0.06498659f, 0.04873427f, 
    -0.07405133f, -0.03967696f, -0.16234607f, -0.10154615f, 0.10050474f, 0.12585227f, 0.16366158f, -0.14207828f, 
    -0.01744398f, 0.01906337f, 0.08891737f, 0.00619582f, 0.11132548f, 0.33792418f, 0.11957017f, -0.09826342f, 
    0.04178020f, -0.04417353f, -0.04654320f, 0.07284779f, 0.15988380f, -0.07558459f, 0.05942936f, 0.12769526f, 
    0.13170044f, 0.51017338f, 0.40308160f, 0.22979803f, -0.06084915f, -0.06587280f, -0.05881683f, -0.05616661f, 
    -0.00586023f, 0.14979973f, -0.02715687f, 0.01268946f, -0.19223298f, 0.03761000f, 0.04459012f, 0.01952960f, 
    0.07254028f, 0.18013901f, -0.01357374f, 0.10832532f, -0.02207652f, -0.09022566f, -0.00448915f, 0.06472954f, 
    -0.00502233f, -0.09719231f, -0.02024332f, -0.03579016f, 0.10522749f, -0.06025041f, 0.08235332f, 0.09352192f, 
    -0.19653626f, -0.14238486f, -0.12844703f, -0.17271225f, -0.05524129f, 0.15913901f, 0.04898097f, -0.07291700f, 
    0.09119173f, -0.10931041f, -0.13974585f, -0.05209905f, -0.11983691f, 0.13630301f, -0.08542503f, 0.00917248f, 
    -0.06520563f, -0.00055197f, 0.28016490f, 0.23212883f, 0.14714889f, -0.04920891f, 0.10592636f, 0.05244971f, 
    0.05372611f, 0.04660112f, 0.05764253f, 0.16609775f, -0.09223823f, -0.04805077f, -0.19443829f, -0.14150578f, 
    0.25947940f, -0.05225016f, -0.27452487f, -0.01470493f, 0.03764266f, -0.12629241f, -0.21119140f, -0.35743654f, 
    0.02809568f, 0.18803488f, 0.25434732f, -0.00481469f, -0.05711493f, 0.00002209f, 0.04463765f, 0.04778238f, 
    0.04803650f, -0.09287612f, 0.02883138f, -0.20938432f, -0.06763767f, -0.17782344f, -0.00472842f, 0.25077507f, 
    0.15964815f, 0.07403584f, -0.08948047f, 0.03467237f, 0.06934708f, -0.06356569f, 0.20841223f, 0.15587059f, 
    -0.25475794f, 0.14594473f, 0.17518137f, -0.12476708f, 0.08626474f, -0.09792196f, 0.02436215f, -0.07930909f, 
    -0.08216841f, 0.04607802f, 0.06771591f, 0.08540619f, 0.04720795f, -0.16198099f, -0.08807958f, 0.14330061f, 
    -0.11516877f, 0.01300983f, 0.05493785f, -0.09971240f, 0.29515046f, 0.00566239f, 0.10440588f, 0.26187873f, 
    0.05075683f, 0.03145886f, 0.05036008f, -0.11808743f, -0.00701733f, 0.10730758f, -0.03397268f, 0.09321677f, 
    -0.12029677f, 0.05478073f, -0.01062307f, 0.05452942f, -0.23701794f, -0.04760390f, -0.05130982f, -0.21011342f, 
    -0.02665897f, -0.03479490f, 0.10794345f, 0.02672572f, 0.08495244f, 0.01879295f, -0.21289523f, -0.02020503f, 
    0.12964332f, 0.03188255f, 0.01043699f, 0.03230136f, -0.19344968f, 0.18893868f, -0.07472731f, -0.12305128f, 
    -0.39186487f, -0.08101650f, -0.12190516f, -0.15856266f, 0.08139569f, 0.04312909f, -0.18876877f, -0.03440023f, 
    0.11139836f, -0.04959751f, 0.07820546f, -0.16754246f, -0.24336371f, -0.08993343f, 0.04821371f, -0.08453013f, 
    -0.40573192f, 0.13782062f, 0.18764880f, 0.32412404f, 0.09829048f, 0.03154961f, 0.11373755f, 0.09646498f, 
    0.04356952f, -0.09884550f, -0.09028559f, -0.16634491f, 0.03459356f, 0.18231583f, 0.16049874f, 0.05679899f, 
    0.00862818f, -0.00731901f, 0.09878854f, -0.08835491f, 0.03812182f, 0.11740054f, 0.14273328f, 0.20752713f, 
    0.05529789f, 0.03906395f, 0.06665349f, 0.24500166f, -0.09689941f, -0.02869963f, 0.05752854f, -0.03878793f, 
    -0.06082236f, -0.00838220f, -0.02472759f, 0.28163177f, -0.00747861f, 0.08253451f, 0.05000672f, -0.00898709f, 
    0.05869221f, 0.16567485f, -0.10031427f, -0.06130054f, -0.04986316f, -0.08756527f, -0.02753597f, -0.01042592f, 
    0.07865540f, -0.02799497f, -0.10792236f, -0.18686138f, 0.06820601f, -0.16363475f, 0.12475763f, 0.02232174f, 
    -0.10232090f, -0.15077005f, -0.30984128f, -0.29784909f, -0.43358815f, 0.17613062f, -0.22245860f, 0.25476760f, 
    0.22938040f, 0.03783267f, 0.03786356f, -0.12054244f, -0.13387489f, 0.04700066f, -0.06953420f, 0.20127170f, 
    -0.23736185f, -0.01416465f, 0.14722709f, 0.13323727f, -0.03949505f, 0.00921829f, 0.00136518f, 0.11550117f, 
    -0.04772686f, 0.04797984f, 0.20716713f, 0.05475119f, -0.08632745f, 0.09538276f, -0.05253838f, -0.25555259f, 
    0.06447008f, 0.18860815f, -0.10696955f, -0.10179635f, -0.00870929f, -0.25586194f, -0.14437580f, -0.26749137f, 
    0.27953601f, -0.07126476f, 0.32417047f, 0.19100821f, 0.01724758f, 0.16224150f, -0.11240061f, 0.07300280f, 
    -0.07111841f, -0.06790077f, -0.07648333f, -0.12170459f, 0.03093874f, -0.30451044f, -0.00942848f, 0.16035604f, 
    0.07251589f, 0.06475177f, -0.08683214f, -0.10112440f, 0.00942129f, 0.02069430f, 0.12251490f, 0.19004160f, 
    -0.18429944f, 0.00054996f, 0.07648909f, 0.08635950f, 0.01236674f, -0.01431721f, -0.05667516f, -0.03773561f, 
    -0.22543991f, 0.07546857f, 0.15256655f, 0.01102963f, 0.16775522f, 0.00835639f, 0.00167294f, -0.04966975f, 
    -0.11705555f, 0.04182542f, -0.04217634f, 0.03045012f, 0.18508309f, 0.21057367f, 0.15114592f, 0.32873940f, 
    -0.03549154f, -0.01018551f, 0.07133060f, 0.06295852f, 0.13902056f, 0.16351324f, 0.02540362f, 0.16006742f, 
    0.07356779f, -0.08542660f, -0.05400911f, 0.06125583f, -0.08194724f, -0.03907880f, -0.14460377f, -0.13271242f, 
    0.11492748f, 0.00913671f, 0.06231260f, 0.05559291f, 0.07874343f, 0.12313783f, -0.21415222f, -0.25676540f, 
    0.07075965f, -0.11973196f, -0.12768745f, 0.11704349f, -0.06126499f, -0.02984950f, -0.03691550f, -0.09381778f, 
    -0.07278734f, 0.10359107f, -0.07775475f, -0.25055012f, 0.09368737f, 0.02846412f, -0.37863198f, 0.17978615f, 
    0.24641040f, -0.13031329f, -0.03683047f, -0.07691258f, -0.10438362f, 0.10008824f, -0.10770017f, -0.09470443f, 
    -0.05550523f, -0.04391962f, 0.19801143f, 0.21984519f, 0.02497057f, 0.04246927f, 0.13339324f, 0.03120036f, 
    -0.00961194f, -0.06016891f, -0.08263719f, -0.04284919f, -0.11501428f, 0.17043224f, 0.11069556f, 0.01345550f, 
    -0.03739847f, 0.09281769f, 0.05506532f, 0.06828834f, 0.00699119f, 0.32864958f, 0.24837647f, 0.23380172f, 
    0.11751267f, 0.05920277f, 0.22311036f, 0.33398941f, -0.03422755f, -0.13014497f, -0.03261226f, -0.12653463f, 
    -0.01414613f, -0.03314913f, 0.05776270f, 0.21542634f, -0.12338898f, 0.04060195f, -0.09986102f, 0.05016127f, 
    0.01160697f, 0.00368910f, -0.17021441f, -0.12511568f, -0.10051750f, -0.02988646f, -0.01297814f, -0.25167903f, 
    -0.16373236f, 0.07801080f, 0.10359364f, 0.02343145f, 0.19070624f, 0.08213505f, 0.04832270f, 0.10796958f, 
    -0.06153444f, -0.11900038f, 0.01032285f, -0.00902389f, 0.28858605f, -0.60764205f, 0.00453992f, 0.26686853f, 
    -0.14713122f, 0.01735946f, 0.08813883f, 0.09416219f, 0.25942424f, 0.13684283f, -0.05429165f, 0.00505171f, 
    0.08711246f, -0.05189881f, 0.18051836f, -0.16347024f, -0.09713309f, 0.04672088f, 0.15382555f, 0.09782961f, 
    0.03921706f, -0.08484049f, 0.06666229f, 0.03979128f, 0.17787939f, 0.16404860f, 0.02319689f, -0.02610114f, 
    0.00458938f, -0.06764355f, 0.04806237f, 0.01718753f, 0.02928060f, 0.06220928f, 0.02828155f, 0.12292370f, 
    0.44556960f, 0.47833690f, 0.00605667f, -0.05205229f, -0.10160282f, -0.05959748f, -0.09316886f, -0.02092126f, 
    -0.14341627f, -0.13243878f, -0.02269412f, 0.02748961f, -0.32795569f, 0.17604463f, 0.10546780f, -0.04759119f, 
    -0.00313994f, -0.02037598f, 0.04858087f, 0.10156235f, -0.05800869f, -0.08364736f, -0.12412463f, -0.02728916f, 
    0.66243166f, -0.48284680f, 0.02424680f, -0.07024975f, -0.05514531f, 0.02294949f, -0.05793664f, 0.08609691f, 
    -0.00502884f, -0.10281914f, -0.00588339f, -0.10103890f, 0.26019910f, 0.08505811f, -0.09976818f, -0.04571926f, 
    0.00591499f, -0.07331468f, 0.06567054f, -0.17460634f, 0.01774324f, -0.03474243f, 0.12905879f, 0.00100052f, 
    0.06098003f, -0.37291983f, -0.03390451f, 0.22409755f, -0.06584647f, -0.16338676f, 0.01949574f, -0.03554810f, 
    0.23069404f, 0.10405402f, 0.03110959f, 0.02249324f, -0.00281795f, 0.00379818f, -0.04050012f, -0.06527770f, 
    0.00735380f, 0.12858525f, -0.00314545f, 0.10059956f, -0.10788459f, 0.06819173f, 0.12391869f, 0.07699452f, 
    -0.07164606f, 0.03036618f, -0.02801488f, 0.09601787f, 0.28964084f, -0.02900989f, 0.11092857f, 0.08000398f, 
    0.05984538f, 0.08564063f, -0.01267266f, 0.11537372f, -0.18732296f, -0.19744582f, -0.07537142f, 0.37590295f, 
    0.23512314f, -0.01678722f, -0.08042786f, 0.02054586f, 0.08840779f, 0.07443728f, -0.00430580f, -0.04880722f, 
    0.05204161f, 0.19559410f, -0.01425242f, -0.23225202f, -0.14902373f, 0.10482205f, -0.09719224f, 0.02471890f, 
    -0.03008267f, -0.08810347f, -0.10092151f, -0.15788679f, 0.12205698f, -0.08510919f, 0.03262567f, 0.04146343f, 
    0.03237852f, 0.09097103f, 0.02620787f, 0.13812509f, 0.09604423f, 0.06944882f, 0.10797149f, 0.01698037f, 
    0.01655928f, 0.12672719f, 0.01139755f, 0.10308644f, -0.09403215f, 0.05764330f, 0.05507893f, 0.14407299f, 
    0.15410225f, 0.02000399f, -0.03891334f, -0.03494564f, 0.12771955f, -0.10336703f, 0.10779746f, 0.04386248f, 
    -0.00085336f, -0.00522431f, 0.13090639f, 0.09540125f, 0.01472063f, -0.01038684f, -0.02203265f, 0.02565732f, 
    -0.02463583f, -0.07545267f, -0.06004624f, -0.07380475f, 0.00423034f, -0.07574506f, -0.00041079f, -0.07577938f, 
    0.03648473f, 0.05534866f, 0.03866536f, 0.01399412f, 0.03054497f, 0.03805544f, 0.00219799f, -0.03243637f, 
    -0.01064396f, -0.05703226f, -0.05229170f, -0.02626567f, 0.03968766f, 0.03314731f, 0.03087342f, 0.04267769f, 
    -0.04305376f, 0.04606687f, 0.07508415f, -0.01861009f, -0.02881502f, -0.02612877f, -0.06876782f, 0.03048249f, 
    -0.04908571f, 0.00885947f, -0.02998185f, -0.02509710f, -0.04845037f, -0.04385594f, 0.05782457f, -0.07251598f, 
    -0.06987618f, 0.02040163f, 0.00465142f, -0.03831439f, -0.08606558f, 0.04989055f, -0.03944126f, -0.05876435f, 
    -0.00994650f, 0.00042935f, -0.01363153f, -0.05397415f, 0.02810309f, 0.01103216f, 0.02740194f, -0.09452907f, 
    -0.02792475f, -0.03002100f, -0.02156200f, -0.04134708f, -0.07542191f, -0.04113783f, -0.00376140f, 0.06281374f, 
    -0.08000966f, -0.04861279f, 0.04594741f, 0.02136531f, -0.06376072f, 0.02711929f, 0.01326706f, -0.06371178f, 
    -0.07241188f, -0.02157926f, -0.00344269f, -0.07720769f, -0.03189102f, 0.02739821f, 0.05851040f, 0.02234885f, 
    -0.06558776f, 0.04816191f, -0.01302355f, -0.02470814f, -0.07705037f, -0.07602902f, 0.00656455f, -0.08513247f, 
    -0.00667071f, -0.01604204f, -0.04489575f, -0.07188064f, -0.02310265f, -0.05694193f, -0.07981428f, 0.01311151f, 
    0.02170697f, -0.03640696f, 0.02152456f, -0.07552908f, 0.03350771f, 0.00890759f, -0.00755872f, -0.04546039f, 
    0.00367840f, -0.07550058f, -0.01485162f, 0.03614463f, -0.03142032f, 0.04569577f, 0.04864219f, -0.00065101f, 
    -0.02608552f, -0.04208944f, -0.06475823f, 0.00300706f, -0.07574434f, -0.05077841f, 0.03105031f, 0.05326198f, 
    0.01619272f, -0.01171087f, -0.08299316f, -0.00416213f, -0.07039890f, -0.01916939f, -0.07829605f, 0.03504690f, 
    0.04304710f, -0.07859889f, -0.02742353f, -0.06419165f, -0.04837282f, -0.05724327f, -0.05310550f, -0.04214052f, 
    -0.00409787f, -0.07369945f, -0.06283535f, 0.03452430f, 0.02117358f, 0.01084774f, 0.03637296f, 0.03805408f, 
    0.01923171f, -0.03404731f, -0.04839989f, -0.00243598f, -0.03499481f, 0.01481431f, -0.02161245f, 0.02410935f, 
    -0.06085452f, 0.02737405f, 0.03344613f, -0.05109430f, 0.03515834f, 0.01188919f, -0.00501217f, -0.07094453f, 
    0.01930444f, 0.05287150f, -0.02789721f, -0.03101840f, -0.03390976f, 0.04794831f, -0.03582862f, -0.06508942f, 
    0.02059152f, 0.01187593f, -0.08811061f, -0.06881547f, -0.00266304f, 0.02936609f, -0.07241990f, -0.00149634f, 
    -0.05636882f, 0.00130536f, 0.04713682f, 0.04440001f, -0.04174948f, 0.02232862f, 0.03349800f, -0.02736220f, 
    0.02966860f, -0.06396933f, 0.00023893f, 0.04045698f, 0.01292171f, 0.02582750f, -0.04061026f, 0.03876460f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.13229711f, 0.05521029f, 0.01513759f, 0.05262570f, 0.11609448f, 0.01506156f, -0.04803453f, 0.08864436f, 
    -0.03295458f, 0.17793426f, 0.09001507f, -0.00009482f, 0.07076344f, 0.21560696f, 0.20930535f, -0.06526285f, 
    0.03018360f, 0.18521917f, 0.23393811f, -0.01996741f, 0.01131122f, 0.01052399f, 0.01401377f, 0.19096097f, 
    0.10398056f, 0.02951429f, -0.00880698f, 0.06120963f, 0.05685555f, 0.00354157f, 0.08964941f, 0.12290530f, 
    0.08593331f, 0.05341433f, -0.01142645f, -0.04762735f, 0.06345316f, 0.02664447f, 0.12106153f, -0.16454342f, 
    0.17730622f, -0.06672329f, 0.16768092f, 0.14778289f, 0.05495164f, -0.10745492f, 0.03825362f, 0.20424874f, 
    -0.13214909f, 0.06683459f, 0.01158650f, 0.00828423f, 0.03339874f, 0.03817097f, 0.21264610f, -0.07184060f, 
    0.19789012f, 0.21222231f, 0.00742602f, 0.03266283f, 0.08766586f, 0.05557943f, 0.00115803f, 0.14516823f, 
    0.00747629f, 0.04682191f, -0.07782794f, 0.12917255f, 0.03769767f, 0.01477292f, -0.04396947f, -0.05746155f, 
    0.04888740f, 0.06769212f, -0.01522775f, -0.04392366f, -0.07213373f, 0.13484044f, 0.09914593f, -0.02459239f, 
    -0.06425226f, 0.10989302f, 0.05122852f, 0.11921385f, 0.09141780f, -0.04917422f, 0.07789172f, 0.13974378f, 
    0.03021576f, 0.10937376f, -0.08495628f, -0.11718445f, 0.13901086f, -0.07340900f, 0.16539991f, -0.03287818f, 
    0.05558361f, -0.07638662f, 0.06434698f, -0.01424164f, 0.12266216f, -0.05453050f, -0.09105477f, 0.15564258f, 
    -0.00875271f, 0.07273448f, 0.04566333f, -0.00789584f, 0.09458628f, 0.06115853f, 0.09521552f, 0.17974745f, 
    0.05923817f, 0.12819004f, 0.04961088f, 0.16811875f, 0.17050484f, 0.16059136f, 0.04567581f, 0.20294768f, 
    0.01987726f, -0.10168041f, 0.02237194f, 0.01582157f, 0.00805455f, -0.00905684f, 0.14703716f, -0.05386414f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.44502124f, 0.05513264f, 0.03121267f, 0.04680316f, -0.08161169f, -0.00838548f, 0.07701906f, 0.10156432f, 
    0.03784182f, 0.00807382f, -0.33034411f, -0.07828657f, 0.00094208f, -0.06620613f, -0.60780036f, -0.00263965f, 
    0.12082589f, -0.02294903f, -0.03815688f, 0.12712058f, -0.07114293f, 0.05754656f, -0.27487034f, -0.40982670f, 
    -0.25107965f, 0.13477682f, 0.07915972f, 0.04157312f, -0.30811626f, 0.03907834f, -0.05083711f, 0.17329000f, 
    -0.16231607f, 0.07489881f, 0.06971194f, 0.05657725f, -0.37747261f, 0.19436437f, -0.08107335f, 0.27939969f, 
    -0.03723049f, 0.14229301f, -0.34727371f, -0.35270381f, -0.08976915f, 0.15548904f, 0.00420765f, -0.20062640f, 
    0.07769571f, 0.07771536f, 0.07722285f, 0.05950648f, 0.03932311f, -0.05504721f, -0.52383232f, 0.05129220f, 
    -0.35971910f, -0.44136226f, 0.23373853f, -0.00036011f, 0.16297378f, -0.31122556f, -0.08850621f, -0.00863296f, 
    0.02403627f, -0.18124868f, 0.21772407f, -0.15434210f, 0.08698290f, 0.20170565f, 0.11852624f, -0.37788138f, 
    0.20091672f, 0.13511513f, 0.06038878f, -0.29866776f, -0.02530066f, -0.01709939f, -0.18725812f, -0.07767657f, 
    -0.07138097f, -0.12354172f, -0.23013121f, 0.19294731f, -0.00214421f, 0.10536068f, -0.22953014f, -0.02981872f, 
    -0.18048263f, 0.02875668f, 0.14346339f, 0.07616220f, 0.04728654f, -0.03166800f, -0.45545965f, 0.18373743f, 
    0.08415321f, 0.00695190f, -0.06348256f, 0.01122052f, -0.28535566f, 0.01908179f, 0.19268821f, -0.10409972f, 
    -0.02139104f, -0.02495894f, -0.21083926f, 0.11263316f, 0.25184134f, -0.06642795f, -0.07759561f, -0.19370498f, 
    0.02409754f, 0.06492084f, -0.11193626f, -0.17303188f, -0.06627608f, -0.00283083f, -0.28239918f, -0.10940249f, 
    0.05291078f, 0.07250537f, 0.33009225f, 0.01603647f, -0.00854609f, -0.10042379f, -0.11159980f, 0.00349670f, 
    0.11830917f, 0.07952227f, -0.04951194f, 0.07615090f, -0.00622175f, 0.04826294f, -0.03991132f, -0.10158035f, 
    -0.03037171f, 0.15520926f, -0.03639450f, -0.01389874f, -0.48006147f, 0.02790823f, 0.49982291f, -0.00430287f, 
    -0.03386150f, 0.10679782f, 0.25359979f, 0.03548314f, -0.24442822f, 0.06670777f, -0.22771318f, -0.29627576f, 
    -0.00823525f, -0.02494714f, 0.23075654f, -0.00038821f, -0.10386106f, 0.07103419f, -0.05860813f, 0.02522709f, 
    0.15190421f, 0.20482463f, -0.03160999f, -0.03385010f, -0.33663809f, 0.25952041f, -0.01647936f, -0.34862956f, 
    0.00013388f, 0.07720362f, 0.18354064f, -0.11105249f, 0.04037556f, 0.27430353f, -0.00047074f, 0.18250978f, 
    -0.46426892f, 0.12043419f, -0.07279555f, -0.02766720f, 0.17048441f, -0.15359396f, -0.49074173f, 0.01827347f, 
    0.11166729f, -0.14952137f, -0.00707650f, 0.08630326f, 0.28844941f, -0.07935705f, 0.00509633f, 0.04371809f, 
    0.07044511f, -0.12331618f, 0.19296911f, 0.31576237f, 0.05343330f, -0.62315118f, 0.13838178f, -0.02946989f, 
    0.01309857f, 0.12514612f, 0.15210219f, -0.07874402f, 0.00281352f, 0.07820424f, -0.20731685f, 0.04069114f, 
    0.00555929f, -0.23513789f, -0.08097780f, 0.06311407f, -0.15471114f, -0.01838411f, -0.23645310f, -0.36661550f, 
    0.26475075f, 0.15754430f, -0.53493690f, -0.24339205f, -0.07326905f, -0.05656611f, 0.33801508f, -0.13632545f, 
    0.16278087f, -0.15838306f, 0.13613324f, 0.03603512f, -0.31990319f, 0.07063495f, -0.18192080f, -0.24363001f, 
    -0.01431512f, -0.02090590f, -0.01100249f, 0.15936370f, -0.16523325f, -0.02786189f, 0.14479360f, 0.03904276f, 
    -0.04556586f, 0.13108712f, 0.01885434f, 0.02165764f, 0.00080354f, 0.09003340f, 0.18896258f, 0.01483503f, 
    0.05517607f, -0.14513977f, 0.14135136f, 0.00371991f, -0.49608389f, -0.44798964f, 0.12017225f, -0.04937525f, 
    -0.40259573f, 0.02796044f, -0.14783928f, 0.07534812f, 0.13690953f, 0.10134321f, -0.06060003f, -0.06718765f, 
    -0.02846085f, 0.11344427f, -0.23682813f, 0.05536926f, 0.31658658f, -0.06246021f, -0.48210335f, 0.01609562f, 
    -0.16451846f, 0.23192438f, -0.05277072f, -0.43255138f, -0.07842224f, 0.01637314f, 0.00323530f, 0.29351884f, 
    -0.03250762f, -0.42892545f, 0.08968803f, 0.01735808f, 0.09303554f, -0.06393278f, 0.05897785f, 0.13906974f, 
    -0.08168033f, -0.14119244f, 0.05167358f, -0.05240261f, 0.13584676f, -0.62274140f, -0.00574446f, -0.54707861f, 
    -0.11971378f, 0.16032310f, 0.03637248f, 0.07298592f, -0.03531338f, -0.23943335f, -0.03496434f, 0.28513780f, 
    -0.07851314f, 0.04212734f, -0.06744447f, -0.05770179f, 0.18301705f, -0.25053400f, 0.21284959f, -0.00165685f, 
    0.18717566f, 0.12050261f, 0.24398117f, -0.34067661f, 0.58920443f, 0.08192020f, -0.03942130f, 0.08521012f, 
    0.16678190f, -0.14853081f, -0.38313863f, 0.03398661f, 0.01659421f, 0.04366669f, -0.18203190f, 0.11926515f, 
    0.11766918f, -0.37239182f, 0.01849706f, 0.03859954f, -0.02372241f, -0.20401298f, 0.09120726f, -0.00985092f, 
    -0.03429127f, -0.08307341f, 0.07484313f, -0.05681074f, -0.07895021f, -0.57557476f, 0.00757607f, 0.26585805f, 
    0.17767119f, -0.08077233f, -0.24410765f, 0.20798762f, -0.15102014f, -0.03691227f, 0.03593235f, -0.00385273f, 
    0.06721009f, -0.01575093f, -0.35285711f, 0.02309171f, 0.06551852f, -0.06240752f, 0.11853609f, -0.04261540f, 
    -0.04290714f, -0.06417279f, -0.24978602f, -0.03091858f, -0.55470467f, 0.03636327f, -0.25122076f, 0.05549546f, 
    -0.03318118f, 0.07280935f, 0.00860028f, -0.11070833f, 0.05856548f, -0.16819713f, 0.29424450f, 0.01291343f, 
    0.01612908f, -0.08788428f, 0.02395540f, 0.00335392f, 0.40133342f, 0.14963838f, 0.15626247f, -0.06957003f, 
    0.03109332f, -0.00848150f, 0.12446811f, 0.07181319f, -0.58632892f, -0.03695742f, -0.02397063f, -0.13215730f, 
    0.05082464f, -0.04157535f, 0.19537428f, -0.01182167f, 0.16233972f, 0.01500731f, -0.20456007f, 0.01217733f, 
    0.09097440f, 0.07430574f, -0.54493827f, -0.00352893f, -0.07296313f, 0.05699934f, 0.34485856f, -0.02125622f, 
    -0.03341756f, 0.16608588f, 0.05197496f, 0.07729255f, 0.02993246f, 0.00183589f, -0.08685389f, 0.01828519f, 
    0.15978920f, -0.43339998f, 0.07889073f, 0.00432684f, 0.09974109f, -0.16210786f, -0.27038541f, 0.16758922f, 
    -0.29241940f, -0.01542702f, 0.03903997f, -0.18025178f, 0.06468065f, 0.05274653f, 0.07307315f, -0.01114228f, 
    0.05242127f, -0.02321887f, -0.06202168f, -0.00491703f, 0.09316813f, 0.18482804f, 0.06860374f, 0.01102379f, 
    -0.17103785f, -0.18356764f, 0.14342593f, 0.08941931f, -0.04189578f, 0.24696282f, -0.06936179f, -0.10220011f, 
    0.04659414f, 0.16007839f, 0.14377943f, -0.03851524f, -0.52008337f, 0.23939478f, 0.12056126f, 0.12615982f, 
    -0.10279645f, -0.12020487f, -0.05230255f, 0.10442670f, 0.04491134f, -0.44838801f, -0.01654458f, -0.02221024f, 
    0.03672560f, 0.07747722f, -0.07723062f, -0.00810998f, -0.09506641f, -0.03304739f, 0.30147108f, 0.07953171f, 
    -0.05177036f, -0.18190089f, 0.04786110f, 0.26562381f, -0.30747536f, -0.04108001f, -0.32082528f, -0.09831896f, 
    -0.13427424f, -0.02691105f, 0.02830835f, 0.01808072f, 0.09531537f, 0.00523032f, 0.03558716f, -0.29055074f, 
    -0.07980897f, -0.24431844f, 0.11367975f, -0.23781826f, 0.06839992f, 0.00162201f, -0.27976319f, -0.24970798f, 
    -0.11921932f, -0.16793424f, 0.32495925f, 0.08933632f, -0.14648925f, -0.20862263f, 0.13119049f, -0.20093897f, 
    0.03261466f, 0.05843037f, -0.06437624f, -0.01159858f, 0.13964617f, 0.12580587f, -0.50081915f, 0.01470750f, 
    0.23717690f, 0.05997514f, -0.17371842f, 0.08182299f, -0.00780417f, 0.11464067f, -0.04847857f, 0.01088374f, 
    -0.05730272f, -0.43323690f, 0.12019264f, 0.02699910f, -0.01522897f, 0.00935533f, -0.42651454f, 0.07045190f, 
    -0.17486364f, -0.02656772f, -0.61117738f, 0.17343555f, 0.14477730f, 0.03321896f, -0.21022113f, 0.00586799f, 
    -0.10184157f, -0.32669318f, 0.15470880f, -0.02054538f, 0.05304747f, -0.05437272f, -0.19317377f, -0.11372098f, 
    -0.22636907f, -0.00719650f, 0.06639316f, 0.02013912f, -0.13632260f, -0.10172752f, -0.04312808f, -0.07794083f, 
    0.01929469f, -0.21303129f, 0.02571307f, 0.06508809f, -0.06546354f, 0.06490599f, -0.03514085f, -0.17054124f, 
    0.17977983f, 0.17235172f, -0.00336871f, 0.05701757f, -0.04475189f, 0.03226569f, -0.05147828f, -0.06807721f, 
    -0.29200113f, 0.09688240f, 0.19184901f, 0.09061167f, -0.06551055f, -0.20541833f, -0.02318838f, -0.10267278f, 
    0.20092523f, -0.19918141f, -0.07011316f, -0.04888202f, 0.09711888f, 0.00952635f, -0.04295655f, 0.23045741f, 
    -0.07041939f, 0.17132150f, -0.13128518f, 0.02175080f, -0.07939644f, -0.05422045f, -0.36319211f, -0.02256959f, 
    0.03136384f, 0.19389674f, -0.18201357f, -0.12512630f, -0.18874462f, 0.03422229f, 0.03568036f, 0.13541345f, 
    -0.03205386f, 0.02946483f, 0.23515955f, -0.17880437f, -0.00593335f, 0.03611504f, 0.13606317f, 0.11151209f, 
    -0.11828889f, 0.15126279f, -0.03301650f, 0.03953216f, -0.11365737f, 0.01974173f, 0.14234853f, -0.21473391f, 
    -0.04888652f, 0.26164028f, -0.11967448f, 0.02616330f, -0.03794942f, -0.06916123f, 0.13101308f, -0.22515994f, 
    0.15298426f, -0.00373072f, -0.20184833f, -0.08674438f, -0.10881288f, -0.24846865f, 0.03064574f, 0.05469207f, 
    -0.02529284f, -0.05926652f, -0.25815850f, 0.06413110f, 0.15065558f, 0.08189297f, 0.20238079f, 0.04288921f, 
    -0.21175703f, 0.06675270f, -0.28959006f, -0.14264409f, -0.12419809f, 0.09853487f, -0.06772824f, 0.09015419f, 
    0.02507578f, 0.04308064f, -0.20399767f, -0.02284635f, -0.01192767f, 0.19232789f, -0.15117134f, -0.06228682f, 
    0.10282059f, 0.00609305f, -0.25214425f, 0.16901401f, 0.12774943f, 0.08073498f, -0.29299113f, 0.20612188f, 
    -0.10900887f, 0.30250394f, 0.04747621f, -0.00002665f, 0.08291395f, -0.01696686f, -0.42862648f, 0.09114025f, 
    -0.12141401f, 0.01137745f, -0.02323055f, 0.02889791f, 0.25801226f, 0.09255454f, -0.16146149f, 0.11626916f, 
    0.00003104f, -0.10594694f, 0.00549526f, -0.01390944f, 0.03746637f, -0.23808257f, -0.00051755f, 0.29298484f, 
    -0.10170257f, -0.11016926f, 0.04977698f, -0.02714398f, 0.00480076f, 0.09876409f, 0.20455870f, 0.05882458f, 
    0.07508052f, -0.10151653f, -0.37215820f, -0.06545247f, -0.02844050f, -0.02392455f, 0.09179260f, 0.26427549f, 
    -0.13828613f, 0.09404328f, -0.08177229f, -0.21334048f, -0.04507908f, -0.37412179f, -0.32890615f, -0.20495865f, 
    -0.02137504f, 0.08595879f, 0.10005512f, -0.25180966f, 0.00673215f, -0.03305910f, 0.26798677f, 0.01866288f, 
    0.00164850f, 0.07537103f, -0.06576655f, -0.04181086f, 0.16660230f, -0.07074896f, -0.24951492f, 0.09216025f, 
    -0.39132038f, 0.23732382f, 0.07734241f, -0.20383161f, 0.28284475f, -0.04409163f, 0.13301960f, 0.25328648f, 
    0.04724863f, 0.11690553f, 0.18951084f, -0.02325441f, -0.24551460f, 0.05818412f, -0.32979053f, 0.36587042f, 
    0.01149855f, -0.17590544f, 0.09770017f, 0.09229690f, 0.22254825f, -0.04243615f, 0.03909373f, -0.21254021f, 
    0.09000012f, 0.10104693f, -0.01016807f, 0.16712791f, 0.25897411f, -0.19176893f, -0.30054545f, 0.23477685f, 
    -0.08753589f, 0.17471553f, 0.16213490f, -0.00077146f, -0.15129863f, -0.33509338f, 0.06477182f, -0.02591388f, 
    -0.03989690f, 0.06863533f, -0.18674628f, 0.06228218f, 0.11687300f, -0.17990786f, -0.03789528f, -0.05003180f, 
    0.06585682f, 0.13138756f, 0.32127842f, 0.07395696f, 0.03850894f, -0.38304797f, -0.02290335f, -0.05791806f, 
    -0.23595838f, 0.30907369f, 0.23377864f, -0.61738777f, -0.12958422f, 0.07669069f, 0.08671135f, 0.21460928f, 
    -0.07137802f, -0.22177947f, -0.68953049f, -0.01826105f, 0.07316963f, -0.05003439f, 0.07319973f, -0.30539557f, 
    -0.39086756f, 0.15130012f, 0.05356764f, -0.06808298f, -0.11429104f, -0.40935400f, 0.00628793f, -0.11904063f, 
    0.17141198f, 0.18453829f, -0.08957299f, 0.16844693f, -0.07602686f, -0.50431311f, -0.03636347f, -0.36954486f, 
    0.06827486f, -0.24892695f, 0.07318779f, 0.02282739f, -0.75344169f, -0.13021520f, 0.33438846f, -0.08964120f, 
    0.03233061f, 0.07505711f, -0.00745487f, -0.33372653f, -0.64241177f, -0.28411072f, -0.06275777f, 0.22646391f, 
    0.18672101f, 0.00342894f, -0.79962832f, -0.52683717f, -0.13936155f, 0.21762338f, -0.33491352f, -0.12918732f, 
    -0.34641233f, 0.20516574f, -0.42980120f, 0.10917780f, -0.06165157f, 0.17324749f, -0.02623113f, -0.02146070f, 
    -0.05777496f, 0.26859364f, 0.05670184f, -0.53422236f, 0.16836108f, -0.50220835f, 0.15974717f, 0.11360104f, 
    0.11453877f, -0.28275266f, -0.28598329f, -0.31566179f, 0.21048956f, 0.01521346f, -0.50936872f, 0.06155383f, 
    -0.31382668f, 0.01065135f, -0.04282978f, -0.05268336f, 0.34068948f, -0.04336796f, -0.59810001f, 0.08284245f, 
    -0.01938474f, 0.14008565f, -0.15151872f, 0.10558915f, -0.45726234f, -0.02785156f, -0.21113454f, 0.08468157f, 
    -0.51771784f, -0.01227729f, 0.02022278f, 0.23774083f, -0.31083363f, 0.10006183f, 0.15966189f, 0.06902711f, 
    -0.00047521f, -0.11428272f, 0.17824237f, 0.11685535f, -0.04579373f, 0.12726746f, -0.01222580f, -0.08960500f, 
    0.21316724f, 0.05094516f, 0.16359487f, -0.52359045f, -0.03431780f, 0.27650768f, 0.00367066f, -0.10367153f, 
    0.01551931f, 0.05276531f, -0.32755998f, -0.00940091f, 0.22481339f, -0.37413508f, -0.20666671f, -0.05575633f, 
    -0.14435223f, -0.31747991f, -0.22698829f, -0.31155702f, -0.14526966f, 0.01767382f, 0.07118768f, -0.20733850f, 
    0.12579574f, 0.14539292f, -0.25773627f, -0.06607863f, 0.14837758f, 0.03510212f, -0.07864444f, -0.30986962f, 
    -0.06045678f, -0.01576314f, -0.01491836f, 0.03825403f, 0.28375712f, -0.23433569f, 0.03641719f, 0.25848827f, 
    -0.19954969f, -0.00888539f, 0.10204273f, 0.16000290f, -0.00552269f, -0.28472850f, -0.00494962f, -0.10166388f, 
    0.12163327f, -0.35482439f, 0.05105839f, 0.04822878f, -0.35649276f, -0.40957743f, 0.06856124f, 0.03871716f, 
    0.08126422f, -0.18709236f, -0.21417162f, -0.30594343f, -0.33371189f, 0.21175498f, -0.04471380f, -0.47515953f, 
    -0.31844082f, 0.08952387f, 0.11461748f, -0.07566801f, 0.09511460f, -0.12720956f, -0.12221612f, -0.14336008f, 
    -0.29716340f, 0.14657769f, 0.10021611f, -0.06743093f, 0.06865449f, -0.02100403f, -0.00897194f, -0.07306612f, 
    0.03041381f, -0.30669037f, 0.07312065f, -0.53775960f, 0.04761020f, -0.22862963f, 0.19538528f, -0.05948556f, 
    -0.13256010f, -0.10077955f, 0.32168490f, 0.41738173f, -0.12016236f, -0.01088579f, -0.27638882f, -0.09145442f, 
    -0.14781164f, 0.02561104f, 0.12393375f, -0.02579023f, 0.14165105f, 0.02350588f, 0.30745390f, 0.22039153f, 
    -0.07029729f, 0.12569430f, -0.22905575f, -0.43174762f, -0.41202882f, -0.04590024f, -0.03139548f, 0.05802087f, 
    -0.35223159f, -0.15037568f, 0.19051735f, -0.11898937f, -0.38537240f, -0.01889858f, -0.39590418f, -0.09562414f, 
    -0.06289225f, 0.08927146f, -0.04516071f, -0.36431584f, 0.11945138f, -0.07458888f, 0.06767146f, -0.00767449f, 
    0.10317821f, -0.01707404f, -0.02219485f, -0.35182986f, -0.06183014f, -0.28543186f, -0.09930044f, 0.08261679f, 
    0.03862077f, 0.19520874f, 0.18085131f, 0.05591261f, -0.26147753f, 0.22315255f, -0.01322044f, 0.02034490f, 
    0.04659643f, 0.13547230f, 0.11323718f, -0.65417516f, -0.16292968f, 0.02223993f, 0.18189254f, -0.39214188f, 
    0.06910596f, 0.23239043f, -0.42317277f, 0.03166427f, 0.16889341f, -0.04617332f, -0.01147544f, 0.27381203f, 
    0.11336611f, -0.25205436f, 0.02203546f, -0.01143218f, -0.60575563f, -0.43560684f, 0.08895840f, -0.53279126f, 
    0.23062237f, -0.14616583f, 0.24476889f, -0.06439682f, -0.06097981f, -0.23529138f, -0.03196044f, -0.45263338f, 
    -0.35731247f, -0.07711483f, 0.01763409f, 0.04698815f, -0.01073343f, 0.31873298f, 0.15851273f, 0.01808755f, 
    0.14801586f, 0.27268785f, 0.10078239f, -0.05513651f, -0.17324957f, 0.33159330f, -0.01885312f, -0.18375406f, 
    -0.52345419f, 0.16958675f, -0.27330238f, 0.01575446f, -0.15257163f, 0.15562606f, 0.22167572f, -0.31052846f, 
    -0.07537383f, -0.32263100f, 0.23296115f, 0.00856303f, -0.02227786f, 0.01515416f, 0.26370484f, 0.02610117f, 
    -0.06915884f, -0.65958381f, 0.02546960f, 0.14964083f, 0.15092137f, -0.10063886f, 0.15497138f, -0.24988747f, 
    -0.18128824f, -0.12480759f, -0.16156793f, 0.04509146f, -0.24538375f, 0.04894295f, -0.41363782f, -0.04539048f, 
    -0.12794058f, -0.13562918f, 0.16919602f, 0.08131459f, 0.06343768f, 0.02619463f, -0.37949491f, 0.00018662f, 
    -0.01404810f, -0.52227360f, -0.00572514f, -0.00257511f, -0.22206247f, -0.00883776f, -0.19204630f, 0.01617107f, 
    -0.50399339f, -0.21921341f, -0.01136717f, 0.00625261f, 0.06878929f, -0.06797054f, -0.11231177f, -0.25034311f, 
    -0.05825692f, 0.06179171f, 0.36716259f, -0.30093917f, -0.37571323f, -0.34899783f, 0.13419732f, -0.08831020f, 
    -0.24180537f, 0.06442585f, 0.07485840f, 0.11844337f, 0.06869710f, 0.24196249f, 0.07084503f, -0.25333992f, 
    -0.01593857f, -0.43518594f, -0.02029241f, -0.08112165f, -0.04331847f, -0.19631377f, -0.00898889f, 0.05657339f, 
    -0.62711835f, -0.19810595f, 0.10520310f, 0.11674007f, 0.15969798f, -0.07844073f, -0.36591160f, -0.38604984f, 
    0.01861466f, -0.07391642f, -0.20393273f, -0.00313243f, 0.16837791f, -0.02442454f, 0.38457474f, -0.45346209f, 
    0.09137198f, 0.08505285f, -0.05643960f, -0.05191865f, 0.24650328f, -0.20000011f, 0.12172224f, -0.21377631f, 
    0.13006009f, 0.14854559f, -0.22809827f, 0.10151383f, -0.02484100f, -0.24020033f, 0.01402095f, -0.34855920f, 
    0.24593049f, -0.20596224f, -0.05206750f, -0.00145525f, 0.16201499f, -0.08326293f, 0.06963147f, 0.03853704f, 
    -0.09043020f, 0.13758510f, -0.31304240f, -0.02842960f, -0.40637967f, -0.43550342f, -0.09672262f, -0.09813051f, 
    0.00696991f, -0.05755145f, 0.16399089f, 0.17119420f, -0.38753444f, 0.14158286f, 0.09718281f, -0.04327953f, 
    -0.25155780f, -0.28668520f, -0.13807811f, -0.12766451f, 0.03194317f, -0.04016477f, -0.19539984f, 0.07352602f, 
    0.03371852f, -0.09179136f, 0.07221141f, -0.10233451f, 0.01955252f, -0.22849225f, -0.45134720f, 0.20863178f, 
    -0.05628081f, -0.08359235f, 0.28585428f, -0.09084807f, 0.30126551f, -0.00906180f, 0.58476222f, -0.12975490f, 
    -0.02793494f, -0.08125835f, -0.12814198f, -0.03795446f, 0.06745975f, 0.07785499f, 0.23771238f, 0.16816668f, 
    0.00417163f, 0.21554005f, -0.33864677f, 0.19865541f, 0.34998307f, -0.09231759f, 0.00078473f, -0.04554579f, 
    0.14706902f, -0.23969743f, -0.28961229f, 0.13199006f, 0.09089658f, 0.21551152f, -0.33103237f, 0.09773186f, 
    -0.05307219f, -0.20764005f, -0.50838643f, 0.20388357f, 0.00177135f, 0.20557523f, 0.02321207f, 0.05370612f, 
    -0.14995334f, -0.08015011f, 0.19884290f, 0.01722101f, -0.13054334f, -0.11719428f, -0.04551796f, 0.26455626f, 
    -0.04834669f, 0.30874148f, -0.03027785f, -0.00230177f, 0.27904287f, 0.13169220f, -0.10214168f, 0.00763217f, 
    0.22067577f, -0.35787371f, -0.26665550f, -0.45254445f, 0.21622050f, 0.05276048f, 0.25627857f, 0.08631094f, 
    0.27957803f, 0.00124369f, -0.07554082f, 0.01118517f, -0.19828089f, -0.08849794f, 0.08450982f, 0.04382113f, 
    -0.25803846f, -0.04630328f, -0.03268554f, -0.01853874f, 0.28382072f, 0.30930179f, 0.27691954f, -0.08537176f, 
    0.13230336f, -0.39023697f, 0.23325874f, 0.14845635f, -0.08853764f, -0.38737202f, 0.00899464f, 0.13569464f, 
    -0.16708857f, -0.36722162f, -0.02635731f, -0.00818498f, 0.15200281f, -0.38392350f, -0.24221672f, 0.00420342f, 
    -0.07322609f, 0.02496863f, -0.53839505f, 0.25509462f, -0.22728412f, -0.00227111f, 0.06213337f, -0.22508496f, 
    -0.30764022f, -0.13422979f, 0.01361621f, -0.15348522f, -0.40004882f, -0.33553019f, 0.09750077f, 0.28158501f, 
    0.07546408f, -0.07782288f, -0.45934975f, 0.06810549f, -0.06267508f, -0.06362067f, 0.04044152f, -0.08237216f, 
    0.02638934f, 0.01862425f, -0.21796143f, 0.19205455f, -0.15552713f, 0.21863119f, 0.29454514f, -0.44695368f, 
    0.04805979f, -0.33040091f, -0.47121185f, -0.11005095f, -0.37446284f, 0.07318831f, -0.50686669f, -0.08644346f, 
    0.20425062f, -0.33915454f, 0.00088510f, 0.05685312f, -0.14214523f, -0.00221233f, -0.30477983f, 0.02604046f, 
    -0.03404202f, -0.21839869f, 0.15259904f, -0.26804918f, -0.34557778f, -0.04552399f, -0.48810709f, -0.05925966f, 
    0.07061291f, 0.01936419f, 0.15171696f, -0.20737217f, 0.14615130f, -0.00203536f, 0.22611429f, 0.20158204f, 
    0.04829794f, -0.11239614f, -0.37851933f, 0.30664149f, -0.01488275f, -0.49944705f, -0.09729797f, 0.00341629f, 
    -0.08020836f, -0.00799626f, 0.21957122f, 0.13768406f, 0.06079175f, -0.38607094f, 0.06382091f, -0.20571731f, 
    -0.02214944f, -0.30845246f, 0.12991586f, -0.04716532f, -0.46951130f, -0.07893619f, -0.21398620f, 0.00692069f, 
    0.19044861f, 0.23796923f, 0.20797211f, 0.05608525f, 0.11005719f, 0.03047941f, 0.17109716f, 0.34212726f, 
    0.03648300f, -0.28714898f, -0.28001451f, 0.05868888f, 0.02780451f, -0.00511968f, 0.03435353f, 0.03387530f, 
    0.22748494f, -0.28622144f, -0.05905389f, 0.02341462f, 0.15693849f, -0.24851440f, -0.27063215f, 0.11852014f, 
    -0.20804806f, -0.21478690f, -0.48498690f, 0.00711038f, 0.01423752f, -0.36225042f, 0.00074452f, -0.25477153f, 
    -0.38110152f, 0.27480525f, -0.05863861f, -0.07842132f, -0.41018009f, 0.03131823f, -0.05428359f, 0.02765410f, 
    0.07661388f, 0.13435835f, -0.29147455f, 0.26354694f, -0.64051449f, -0.00148719f, 0.01334077f, 0.14597543f, 
    -0.15402141f, 0.10990872f, 0.01501995f, -0.28419083f, -0.03733820f, -0.26020500f, 0.01367934f, 0.24428369f, 
    0.25978500f, 0.11014173f, 0.19730687f, 0.56550235f, 0.06582503f, 0.13451234f, 0.08129235f, -0.08005132f, 
    -0.03302449f, 0.15730464f, 0.19381233f, -0.21949346f, -0.26908675f, -0.31858513f, 0.16327754f, -0.36803445f, 
    0.02987156f, 0.13557073f, -0.19618440f, -0.25726217f, -0.19068490f, 0.07558718f, -0.02732287f, -0.06658719f, 
    0.13054578f, -0.38405567f, -0.20103917f, 0.04858598f, -0.10032436f, 0.00372772f, -0.21434341f, -0.38771203f, 
    0.06559736f, 0.03857286f, 0.38586688f, -0.26410136f, -0.13597058f, -0.07428164f, -0.02133393f, 0.02260280f, 
    0.03655430f, 0.02244335f, -0.21164401f, 0.11625064f, -0.24770296f, 0.08263908f, 0.32689294f, 0.24262814f, 
    0.03800414f, 0.11264972f, -0.39676529f, -0.34457788f, -0.10248495f, 0.29770383f, 0.08222511f, 0.01856542f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.16660911f, 0.03713348f, -0.00045711f, -0.00436150f, -0.07334945f, 0.09963860f, 0.14616285f, -0.12077465f, 
    0.10693069f, 0.07316311f, 0.09908111f, -0.07860761f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
