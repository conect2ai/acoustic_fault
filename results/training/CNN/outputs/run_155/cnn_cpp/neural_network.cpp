#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.63927811f, 0.62065375f, 0.80721080f, -0.42660946f, -0.17498547f, 0.14942347f, 0.09715171f, 0.01763585f, 
    -0.46175984f, -0.48908001f, -0.34976104f, -0.57249373f, -0.14952692f, -0.55578864f, 0.11491807f, -0.43758872f, 
    0.05505971f, -0.13286413f, -0.70138264f, 0.68875259f, -0.48564568f, 0.17356879f, 0.18904971f, -0.59841931f, 
    -0.13202776f, 0.14945687f, -0.00857192f, -0.49111146f, -0.13018970f, -0.39003289f, 0.61665362f, 0.28029028f, 
    -0.51592433f, -0.21406752f, 0.21783514f, 0.03866739f, 0.34756577f, 0.09571145f, 0.31239882f, 0.54034549f, 
    0.57683945f, -0.14714724f, -0.29663494f, -0.22831388f, -0.00712360f, -0.05971431f, -0.49361429f, 0.02044805f, 
    -0.01483489f, -0.11335298f, -0.62513793f, -0.30472520f, -0.42840055f, -0.43980184f, -0.25743538f, -0.26678029f, 
    -0.59523708f, -0.41796979f, -0.69576472f, 0.06136887f, 0.20739016f, 0.38214481f, 0.33720765f, -0.15033633f, 
    0.54271680f, -0.20890009f, 0.41171601f, -0.38152868f, -0.29709068f, -0.29609421f, -0.21480700f, -0.23755310f, 
    0.68210864f, -0.38090953f, 0.66541886f, 0.29082730f, -0.21083488f, 0.14705972f, -0.30035803f, -0.31736591f, 
    0.06395914f, -0.23433731f, 0.71206099f, 0.49831650f, -0.17233366f, 0.36194476f, 0.38587084f, -0.38363773f, 
    0.14530404f, 0.05303286f, -0.04006632f, -0.10418110f, 0.44883600f, -0.06407196f, -0.77486211f, 0.56918973f, 
    -0.07825970f, 0.18353215f, 0.16747406f, 0.75068361f, 0.60755002f, 0.55206060f, 0.08950581f, -0.38400838f, 
    -0.13410845f, 0.29699036f, 0.20513631f, 0.18855786f, 0.47402993f, 0.85100919f, -0.64990979f, 0.41857970f, 
    0.12776683f, -0.23953874f, 0.38218409f, -0.08649667f, -0.01863799f, -0.10982977f, -0.85748655f, -0.10584157f, 
    0.49827302f, -0.19581066f, 0.61082286f, -0.05634353f, -0.17041703f, -0.17668532f, 0.03763038f, 0.48688328f, 
    -0.05908407f, 0.20649101f, -0.04314734f, 0.79213035f, 0.32763878f, -0.16333263f, 0.40436757f, -0.81797433f, 
    0.25939170f, 0.46594378f, 0.32448924f, 0.51324654f, 0.44789752f, 0.37033096f, 0.44016045f, 0.29612598f, 
    0.54822326f, -0.66498786f, 0.03886908f, -0.63263130f, -0.03104369f, 0.14047369f, 0.03720542f, 0.28331527f, 
    0.21785703f, 0.67442060f, 0.13658254f, -0.76418686f, 0.21185271f, -0.22539596f, 0.06081032f, 0.25768220f, 
    0.36848494f, -0.29519776f, 0.75566196f, 0.51555371f, 0.22240971f, 0.13924742f, 0.47216117f, -0.38023108f, 
    -0.20264797f, 0.29099691f, 0.10904422f, 0.19567804f, 0.34734207f, -0.03308825f, -0.60417736f, -0.84865564f, 
    -0.71547049f, -0.10826427f, -0.11266866f, 0.26825848f, 0.24972856f, -0.01884562f, 0.04164188f, -0.34185472f, 
    -0.00220841f, -0.72829556f, 0.07824583f, 0.45269141f, 0.17102540f, 0.04924890f, -0.69990742f, 0.80895030f, 
    -0.10807173f, -0.43746606f, -0.37335649f, -0.11102218f, 0.26733226f, 0.20265861f, 0.16116835f, -0.01032063f, 
    0.75101358f, 0.96121430f, 0.12399215f, -0.26831928f, 0.11377530f, 0.24517947f, -0.15729292f, -0.51650012f, 
    -0.15982164f, 0.41061249f, 0.58763027f, 0.36185917f, 0.54937756f, -0.27023742f, -0.62945026f, 0.11118873f, 
    -0.56036794f, -0.18116663f, -0.59365463f, 0.11813143f, 0.81662136f, 0.16308920f, 0.33292878f, -0.49288753f, 
    0.09706620f, -0.51179236f, 0.81179631f, 0.05872228f, 0.35182706f, 0.13314734f, -0.39882821f, -0.11313022f, 
    -0.07601842f, 0.30489364f, -0.37123340f, 0.08356100f, 0.35188043f, -0.32874647f, -0.27261299f, 0.10391686f, 
    -0.41765544f, 0.56196326f, -0.05691443f, 0.53362942f, 0.32301864f, -0.01699856f, -0.75366610f, 0.59613526f, 
    -0.51914632f, 0.22662283f, 0.10797276f, 0.06213911f, 0.30454624f, 0.01084575f, 0.38786137f, 0.18800864f, 
    -0.60508543f, 0.02781395f, 0.53245312f, 0.25078967f, 0.22805719f, -0.65735888f, -0.71367383f, -0.70745057f, 
    -0.39734372f, 0.00448478f, 0.53068751f, -0.02137649f, -0.05249196f, 0.20243542f, -0.53248715f, -0.44858536f, 
    -0.56465292f, 0.39609280f, 0.69651812f, 0.04579023f, -0.09193499f, 0.08241523f, -0.61959881f, -0.59728396f, 
    -0.22114410f, -0.16374657f, -0.52720487f, 0.08926990f, -0.30990985f, 0.28852007f, 0.55854994f, -0.21255718f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18077099f, 0.03002096f, -0.15245205f, -0.12041840f, 0.06332327f, -0.08614814f, -0.12854464f, -0.12568514f, 
    0.02008476f, -0.09341045f, 0.08052645f, 0.06868318f, -0.24709940f, -0.09997885f, -0.28276953f, 0.11722147f, 
    0.17581303f, -0.17337568f, -0.13657655f, -0.11658200f, 0.10449394f, -0.33146042f, -0.41620684f, -0.16931573f, 
    -0.14063588f, -0.03309732f, -0.23684591f, -0.37417030f, 0.21651749f, -0.13215175f, -0.06485237f, 0.14657168f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03143517f, 0.03760400f, 0.04090943f, 0.04752299f, -0.06174057f, 0.03058182f, -0.02801998f, -0.04094059f, 
    0.00651481f, 0.03881475f, 0.01107872f, -0.01094867f, -0.01169277f, 0.02770163f, 0.04082550f, 0.00777919f, 
    -0.02680406f, 0.01608179f, 0.03590086f, 0.03776003f, 0.03100436f, -0.05635842f, -0.04632162f, -0.04165453f, 
    -0.03930166f, -0.05405754f, 0.00823703f, 0.03111901f, -0.04612088f, -0.01907779f, -0.02468059f, -0.00111582f, 
    -0.03354207f, 0.04844132f, -0.00076332f, 0.03329080f, 0.00230002f, -0.03316512f, -0.06027396f, -0.01160802f, 
    -0.02395649f, -0.04925117f, -0.02972127f, 0.03780327f, 0.00232103f, -0.02447836f, -0.00172015f, -0.00175216f, 
    0.01864694f, -0.04536482f, -0.02467564f, 0.05083966f, 0.01511572f, 0.03961031f, 0.01582808f, -0.01019969f, 
    0.00426389f, -0.04905162f, 0.01704598f, -0.01642376f, -0.01907969f, 0.01195361f, -0.01131313f, 0.02970288f, 
    -0.01570200f, 0.03997294f, 0.00152210f, -0.02855260f, 0.03531172f, -0.00957249f, -0.03699881f, 0.02211600f, 
    -0.05843890f, -0.04362009f, 0.00251699f, 0.03545632f, -0.05854629f, -0.01543359f, 0.01996952f, 0.00588071f, 
    -0.03451534f, -0.06127090f, -0.06195897f, -0.00003883f, 0.01369209f, -0.05176022f, -0.03698255f, -0.01464446f, 
    0.03873260f, -0.06035452f, 0.03320305f, 0.01038164f, -0.04005344f, 0.02904795f, -0.00943798f, -0.03570468f, 
    -0.01624441f, -0.02932557f, 0.01198612f, 0.03873236f, 0.03967223f, -0.06194777f, 0.03610158f, 0.01850867f, 
    -0.00343746f, -0.04936395f, 0.04344090f, 0.00882450f, -0.06467663f, 0.02386810f, 0.04854381f, -0.01423079f, 
    0.01982890f, -0.02367405f, 0.00908263f, -0.03929183f, 0.04451207f, -0.04818641f, -0.05998234f, 0.01108278f, 
    -0.03158358f, -0.06380708f, -0.04726397f, -0.05493867f, -0.04282726f, -0.05129706f, -0.05246235f, 0.04116708f, 
    0.01598168f, 0.04458434f, -0.01824050f, -0.03709460f, 0.03875087f, -0.03562560f, -0.06671506f, -0.05235040f, 
    -0.06290688f, 0.01784442f, -0.02090647f, -0.04953757f, -0.03041072f, -0.06162293f, -0.05097272f, 0.04465044f, 
    0.04187657f, -0.03526070f, -0.04019701f, -0.02766039f, -0.04364028f, -0.00135160f, -0.02313468f, 0.00844759f, 
    0.00365007f, -0.05671686f, -0.01314525f, -0.00507095f, 0.01879628f, 0.02009489f, -0.04161804f, -0.06611508f, 
    0.02680453f, 0.02732922f, -0.05571043f, -0.01190942f, -0.03675434f, -0.03280899f, -0.04447229f, -0.01287199f, 
    0.00526876f, 0.00349378f, -0.00821155f, 0.03571875f, 0.04813243f, 0.00713827f, -0.02990911f, 0.03577545f, 
    -0.02576079f, 0.01512506f, -0.05364262f, 0.05109699f, 0.04822030f, 0.01706540f, 0.04679842f, -0.00679958f, 
    -0.05049483f, -0.04560991f, -0.01761576f, -0.00889731f, -0.03756718f, -0.06285188f, -0.06225773f, -0.00397551f, 
    -0.00638192f, -0.03034469f, 0.03974440f, -0.05500814f, -0.04290719f, -0.05375135f, 0.03462819f, -0.06247757f, 
    -0.04997053f, -0.00328645f, -0.02237684f, 0.04717914f, -0.01166232f, 0.01747763f, -0.04220177f, -0.05919059f, 
    0.00126773f, -0.03859704f, -0.04307795f, 0.00594640f, -0.05010278f, -0.02700971f, 0.01775751f, 0.03900933f, 
    -0.02909890f, -0.05896335f, 0.03684130f, 0.01151043f, 0.00643003f, -0.04167515f, 0.02760155f, -0.03268207f, 
    -0.01041886f, -0.00861794f, -0.03600467f, -0.01039490f, -0.06076054f, -0.05726078f, -0.03834753f, 0.02222367f, 
    -0.06032244f, 0.01824674f, 0.00589268f, 0.02238993f, 0.02051369f, -0.03977228f, 0.01243390f, 0.03002464f, 
    -0.03900657f, 0.01917458f, 0.05093671f, -0.05610394f, -0.02075182f, -0.00806383f, 0.00518752f, -0.01133034f, 
    0.03558720f, -0.05488828f, -0.05765248f, 0.03965195f, -0.05644968f, -0.06689174f, -0.05128809f, 0.02683393f, 
    -0.04611383f, 0.04891171f, -0.04776398f, 0.00679734f, -0.00482814f, -0.06194142f, -0.05883485f, -0.05537353f, 
    0.03862185f, -0.02555961f, 0.01176977f, -0.06210598f, 0.04058123f, 0.04139932f, -0.03715067f, 0.01177600f, 
    0.01710545f, -0.03447530f, -0.04729763f, -0.03879751f, -0.00226859f, -0.03593232f, -0.01520044f, -0.03924611f, 
    -0.00678486f, 0.02233292f, 0.02755202f, -0.01776486f, 0.03992936f, 0.04161773f, 0.02902983f, 0.00922706f, 
    0.20677873f, 0.12834288f, 0.17969251f, -0.18501328f, 0.00551141f, -0.14511441f, -0.06376633f, 0.03877323f, 
    0.15869792f, -0.02197011f, -0.06979555f, -0.08086699f, -0.14558437f, 0.02778363f, -0.07174449f, 0.16723765f, 
    0.10639542f, 0.11248849f, 0.35868332f, -0.26382363f, -0.07479834f, -0.09937084f, -0.09218384f, -0.09997736f, 
    -0.06503013f, 0.09880700f, 0.05916706f, 0.29805899f, 0.06726065f, -0.00605375f, 0.09466258f, -0.06432892f, 
    -0.00008990f, 0.24223702f, 0.03613820f, -0.02667594f, -0.14821027f, 0.12036175f, -0.03085606f, -0.03478397f, 
    -0.21165270f, 0.06767246f, 0.07640532f, 0.03149978f, 0.06689279f, -0.09464432f, -0.06439868f, -0.15583047f, 
    -0.08103681f, -0.10810827f, 0.29357180f, 0.11857264f, -0.14367965f, 0.09395027f, -0.36239448f, -0.09042191f, 
    -0.08838937f, 0.04187830f, 0.05485550f, -0.18250854f, -0.12138991f, -0.10716935f, -0.00109848f, -0.14163275f, 
    0.00590690f, 0.23682241f, 0.05182097f, 0.17647305f, -0.10026319f, 0.08082643f, 0.17864123f, -0.01776613f, 
    0.25897732f, -0.04333121f, 0.10994297f, -0.01741261f, -0.01416230f, -0.07618764f, 0.06297506f, 0.01254062f, 
    -0.08369179f, 0.21377368f, -0.00946098f, 0.03200480f, 0.02435559f, 0.03345002f, -0.06533108f, 0.09878872f, 
    -0.07926764f, -0.10810417f, -0.12828319f, 0.05990702f, 0.03686935f, -0.00713109f, -0.01016981f, 0.01589860f, 
    0.07736579f, 0.13009815f, 0.06674954f, 0.37419495f, 0.09630328f, 0.14213507f, -0.18459338f, -0.11672819f, 
    0.02995271f, -0.05539900f, 0.04556373f, -0.11465480f, 0.02248666f, 0.11485771f, 0.44089973f, -0.07637690f, 
    -0.00174408f, 0.06892715f, 0.06052292f, 0.02577533f, 0.08837729f, 0.39266551f, 0.09250144f, -0.44836453f, 
    0.24045901f, 0.20356937f, 0.16560934f, -0.11621665f, 0.00626504f, 0.02325977f, -0.60547775f, -0.15273497f, 
    -0.15846834f, -0.01651481f, 0.22320315f, 0.10157146f, -0.01890965f, -0.12554088f, -0.16322030f, 0.08801274f, 
    -0.20040081f, 0.27063516f, 0.00580690f, 0.04133786f, 0.09570830f, 0.03326888f, -0.03884616f, -0.11639237f, 
    0.31065369f, -0.09877009f, 0.06502187f, -0.03037210f, 0.04833936f, 0.03213780f, 0.04247136f, 0.05973371f, 
    -0.13728753f, 0.12435514f, -0.08463180f, 0.29345796f, -0.18177196f, -0.05440901f, -0.12422628f, -0.10551903f, 
    0.10310949f, 0.18289509f, -0.05040653f, 0.19452938f, -0.07684526f, -0.00744753f, -0.03972631f, -0.12602831f, 
    0.05536004f, -0.00860547f, -0.05513773f, 0.12252229f, 0.01582572f, -0.03317721f, -0.03046187f, 0.04378660f, 
    0.03308020f, -0.15718645f, 0.06015090f, 0.11807831f, 0.11211598f, -0.05973984f, -0.18072405f, 0.01013695f, 
    -0.10205819f, -0.08639993f, -0.03388581f, 0.16131930f, -0.25092942f, -0.09919233f, 0.02618022f, 0.03231182f, 
    0.03467571f, 0.01372420f, 0.09664863f, 0.02057061f, 0.08006949f, -0.04102191f, -0.30327371f, -0.07361257f, 
    -0.05250439f, 0.00914209f, 0.08397545f, -0.01806960f, 0.06526506f, 0.00324031f, 0.10904597f, -0.00193737f, 
    -0.03116057f, 0.04977186f, 0.11979108f, 0.17820506f, -0.03614129f, -0.01008527f, 0.03296480f, 0.02115660f, 
    0.25903106f, 0.07683048f, -0.02812250f, 0.02278734f, 0.03196491f, 0.05572025f, -0.05601863f, 0.03279081f, 
    -0.05054004f, 0.28256595f, -0.05709978f, -0.11943191f, -0.25922075f, -0.10237323f, -0.11704297f, -0.16148031f, 
    0.03581117f, -0.10750694f, -0.59483993f, -0.16883643f, 0.10375822f, -0.14162548f, -0.13229331f, -0.16673097f, 
    0.04562934f, -0.06061066f, 0.06954770f, 0.08941983f, -0.14202534f, -0.05092222f, 0.02443672f, 0.07188314f, 
    -0.08851702f, -0.13559631f, -0.08184203f, -0.03326962f, 0.21490756f, 0.16763708f, -0.10981373f, -0.05901998f, 
    -0.01814106f, 0.14038761f, -0.04065187f, 0.08020326f, -0.11876201f, -0.05375285f, 0.07268576f, -0.48532879f, 
    0.04392082f, 0.11284718f, 0.07804240f, -0.05151132f, 0.04679741f, -0.07436665f, -0.01520665f, 0.01107385f, 
    -0.25557083f, 0.21203089f, 0.18669756f, 0.15263230f, 0.03688777f, -0.03027171f, -0.05751131f, -0.34102345f, 
    -0.14900100f, -0.13259141f, 0.07958979f, 0.06900137f, -0.10608847f, -0.06298213f, -0.11691789f, -0.08875703f, 
    -0.00363615f, 0.01907418f, -0.00967359f, -0.04227103f, 0.03396858f, -0.01241127f, 0.03439774f, -0.00856847f, 
    0.02551234f, -0.02470626f, -0.00512242f, -0.00669157f, -0.00466852f, -0.04339122f, -0.06494191f, 0.02563172f, 
    -0.02903073f, -0.01337493f, 0.00292368f, -0.02050196f, -0.02898936f, 0.02974604f, -0.05492314f, 0.02035077f, 
    0.01918371f, -0.07408581f, 0.03725981f, -0.04325897f, -0.01165246f, 0.00077421f, 0.00429838f, 0.00995401f, 
    -0.03435404f, 0.00729858f, -0.01512935f, 0.02308238f, -0.01633563f, -0.03564395f, 0.04068176f, 0.03887037f, 
    0.03574143f, -0.01371706f, 0.01268012f, -0.01596469f, 0.03811287f, 0.03907225f, -0.03270602f, -0.02239495f, 
    0.00084068f, 0.01278530f, 0.00903159f, 0.03907749f, 0.00508414f, -0.01508520f, -0.01430251f, -0.07608629f, 
    -0.06193422f, 0.02323994f, 0.02646849f, 0.03903615f, -0.00328461f, -0.04334967f, -0.01833563f, 0.03383856f, 
    0.00917085f, -0.00059786f, -0.04957126f, 0.03735383f, -0.00521807f, 0.00681061f, -0.02481163f, -0.03049466f, 
    -0.07288153f, -0.03790484f, 0.04278298f, -0.05214751f, -0.04994327f, 0.02764933f, 0.00105538f, 0.03023174f, 
    0.00391820f, -0.03364446f, -0.02345686f, -0.02014666f, 0.05523793f, -0.05180525f, 0.05258268f, -0.00924195f, 
    0.02133140f, 0.01236477f, -0.01374183f, 0.02877994f, 0.02673490f, 0.01773944f, -0.02672935f, 0.01020907f, 
    0.01941055f, -0.05725392f, 0.01644244f, -0.07088535f, -0.05801100f, -0.01372551f, 0.00260257f, 0.03127170f, 
    -0.03896360f, 0.02459573f, 0.01874367f, -0.03750382f, -0.07249084f, 0.00384091f, 0.00391125f, 0.00513201f, 
    0.01189270f, -0.01160296f, -0.05665517f, 0.00863472f, -0.03717114f, -0.04581734f, -0.06968650f, 0.01483779f, 
    -0.01616989f, 0.00230656f, -0.02521576f, -0.01398272f, -0.02132867f, -0.01991758f, -0.02214338f, -0.00554074f, 
    0.00220843f, 0.04236697f, 0.00886379f, 0.03529036f, 0.04387183f, -0.06580168f, -0.05271560f, -0.00881244f, 
    -0.04413632f, -0.02970538f, -0.04203105f, -0.01788729f, -0.02696453f, 0.04034976f, 0.00356861f, -0.02285447f, 
    -0.00203863f, 0.02389697f, -0.06675025f, -0.01072106f, -0.05978459f, -0.04343323f, 0.00179995f, -0.01080531f, 
    -0.04277804f, -0.02012296f, 0.03447338f, -0.00068735f, -0.06407494f, -0.04110777f, -0.04978568f, 0.03335585f, 
    0.02604332f, -0.02499702f, -0.07777349f, 0.04980160f, 0.03190804f, -0.02086234f, 0.05578642f, 0.04772070f, 
    -0.05097523f, 0.04477791f, 0.01675688f, 0.01744313f, -0.03615215f, -0.00769009f, 0.04076240f, -0.05903586f, 
    0.03007670f, 0.03095307f, -0.06288908f, 0.02130104f, -0.06548543f, -0.05682417f, -0.01644480f, -0.03441393f, 
    -0.00128174f, 0.01004854f, 0.02056929f, -0.01700234f, -0.00980249f, 0.04405071f, -0.04933238f, 0.03613851f, 
    -0.03554739f, 0.00236909f, -0.04415743f, -0.03031474f, -0.00653821f, 0.02601775f, 0.02134029f, -0.01538561f, 
    0.00393818f, -0.01655093f, -0.00722414f, 0.04421425f, 0.02237876f, -0.00085156f, 0.00848869f, -0.04248390f, 
    0.02476244f, -0.07625271f, 0.03631242f, 0.03029174f, -0.04957334f, -0.05926746f, -0.01622619f, -0.05253635f, 
    -0.02212449f, 0.02338041f, -0.00566161f, -0.00095913f, -0.04383991f, -0.01176582f, -0.04251442f, 0.02544745f, 
    0.03499264f, 0.01265645f, -0.01891795f, -0.00496570f, -0.04496868f, -0.00223892f, 0.01803746f, -0.04054226f, 
    -0.04233867f, 0.02500692f, 0.02466059f, -0.02195200f, -0.02337614f, -0.02533555f, -0.00318191f, -0.03762777f, 
    0.00204845f, -0.02355585f, 0.04920748f, 0.01817064f, -0.02182867f, 0.04919159f, 0.04516082f, 0.06284445f, 
    0.03277035f, -0.01476259f, -0.01247812f, -0.01936187f, -0.07276841f, 0.00619883f, -0.04070982f, -0.05076225f, 
    0.02636529f, 0.03753730f, -0.04753975f, -0.01500530f, 0.00927551f, -0.04587134f, -0.05279608f, -0.01327473f, 
    -0.04215289f, 0.02409977f, -0.05729813f, 0.04802741f, 0.00047645f, 0.02814561f, -0.04307520f, 0.01021585f, 
    -0.04460178f, 0.01129400f, -0.00240039f, -0.05132036f, -0.02437953f, -0.01196693f, -0.03425087f, 0.00514229f, 
    0.02987439f, -0.04625165f, -0.02297466f, 0.00087150f, 0.00005613f, 0.03944541f, -0.02286486f, -0.05703179f, 
    0.02333483f, -0.04926556f, -0.03066988f, -0.01326783f, 0.00214203f, 0.04594861f, -0.03651541f, -0.03426566f, 
    -0.05362905f, -0.03551470f, 0.03799171f, -0.02846576f, 0.02301748f, 0.01357556f, 0.00223988f, 0.04689260f, 
    -0.03305795f, 0.00209845f, -0.01454542f, 0.00962682f, -0.02684683f, -0.01924182f, -0.06047807f, -0.06166278f, 
    0.01691031f, 0.02831864f, -0.03342436f, 0.02167218f, 0.04117161f, -0.03536587f, -0.06346044f, -0.05896605f, 
    -0.06343126f, -0.02318439f, -0.01043996f, 0.00895282f, -0.04163166f, -0.00033927f, -0.02302067f, 0.04485960f, 
    0.00999917f, -0.00836791f, 0.00988341f, 0.04190696f, 0.02004605f, -0.00509398f, 0.04410224f, 0.03162257f, 
    0.04951517f, -0.05296211f, 0.00565382f, 0.04743955f, 0.03810928f, 0.04665195f, -0.06203852f, -0.02032139f, 
    0.02977292f, -0.04851267f, 0.00880130f, -0.03269378f, -0.03946891f, -0.05713360f, 0.00702659f, 0.00998355f, 
    0.02318862f, 0.02860577f, -0.02626702f, -0.06462300f, -0.05068513f, -0.03447958f, -0.02387246f, -0.05078616f, 
    -0.01684839f, 0.01825939f, -0.04970980f, -0.06149241f, 0.01042661f, -0.00277039f, 0.02923610f, 0.02300539f, 
    0.02692432f, 0.04018524f, -0.04345501f, 0.04051907f, -0.04815315f, 0.00048735f, -0.05174566f, 0.01498539f, 
    -0.04566735f, -0.05005308f, -0.04818850f, -0.02320981f, -0.04058369f, 0.04241982f, -0.05280665f, -0.01384085f, 
    -0.06309839f, -0.03821595f, 0.04063523f, 0.03070605f, 0.04816572f, 0.04763643f, 0.02127779f, -0.04945711f, 
    -0.02703454f, 0.01395977f, -0.01306122f, 0.00006934f, 0.03027165f, -0.05481476f, -0.00264049f, 0.01424016f, 
    -0.03523914f, 0.00855964f, -0.00692555f, 0.01178517f, -0.03384273f, 0.01041260f, 0.01681703f, 0.04261459f, 
    0.03050355f, -0.00259899f, 0.01194074f, -0.02192176f, 0.04348479f, -0.03035151f, -0.05194097f, 0.03737839f, 
    -0.05183093f, 0.01710575f, -0.01613158f, -0.00911530f, 0.00234783f, 0.02541129f, 0.00656727f, -0.03774651f, 
    -0.06469122f, -0.06504139f, -0.05735211f, 0.03922446f, 0.03192262f, -0.02907218f, 0.01378207f, 0.00405397f, 
    -0.03614628f, -0.06123345f, 0.01088887f, -0.04724644f, 0.04394183f, -0.06239202f, -0.00493207f, -0.02843421f, 
    -0.03693181f, 0.04528548f, -0.03691172f, -0.01622422f, 0.02704006f, 0.00937146f, -0.03318816f, 0.03579076f, 
    -0.00070808f, 0.01250373f, 0.01508992f, -0.05324401f, 0.01483066f, -0.00123894f, -0.03973818f, -0.01834011f, 
    0.03900549f, 0.01167954f, -0.02293448f, -0.01688034f, 0.02989242f, 0.03397638f, 0.04568499f, 0.00538822f, 
    0.03834554f, -0.01126536f, -0.00589370f, 0.02262834f, 0.01948637f, -0.05745815f, 0.01320558f, -0.01134272f, 
    0.01364044f, 0.03034345f, 0.00377133f, -0.06575467f, -0.02755619f, 0.02947811f, 0.00088648f, -0.02566040f, 
    -0.04879419f, -0.01078798f, -0.04869682f, -0.02791676f, -0.03645956f, 0.01074295f, 0.01140220f, -0.01545255f, 
    0.02514756f, 0.02682591f, 0.04649233f, -0.02951532f, -0.05151969f, -0.00898593f, 0.03005369f, -0.04231254f, 
    0.04542839f, -0.03498604f, 0.00529777f, -0.02795577f, -0.04914320f, -0.05085275f, -0.00777873f, 0.04595857f, 
    -0.06407007f, 0.01070415f, -0.01680156f, -0.04117436f, 0.02576889f, 0.03868169f, -0.01133770f, 0.00910086f, 
    -0.05799383f, 0.00102857f, -0.04045280f, -0.03262382f, -0.03972084f, -0.00638188f, 0.03788271f, -0.05717963f, 
    -0.06240824f, -0.04855536f, -0.01746571f, -0.01817429f, 0.03504434f, 0.02035785f, 0.00330396f, 0.01109345f, 
    0.01517273f, -0.00766095f, 0.02659152f, -0.00649987f, -0.03020586f, -0.03091789f, 0.02900408f, -0.04613775f, 
    0.00255205f, -0.00543894f, -0.04916082f, 0.02530733f, -0.04964535f, -0.05267964f, 0.02289951f, 0.03192731f, 
    0.03137174f, 0.04801995f, 0.02298447f, 0.03725633f, -0.00799250f, -0.05700975f, 0.02395318f, -0.05600810f, 
    0.02080986f, -0.06191232f, -0.05677091f, -0.02985416f, 0.00789968f, 0.03315627f, -0.03728103f, 0.03380065f, 
    0.01031296f, -0.06510700f, -0.05155720f, 0.02499816f, -0.05818495f, -0.05514149f, -0.06099454f, 0.01131046f, 
    -0.00775349f, -0.06532852f, -0.04055594f, -0.02473691f, 0.04418468f, -0.02462538f, 0.00842033f, 0.00284400f, 
    0.06068390f, 0.19478062f, 0.25865826f, 0.06807167f, 0.19610046f, -0.03440218f, 0.02337980f, 0.13657920f, 
    -0.00404182f, 0.05268099f, -0.07736357f, -0.27350098f, -0.05516936f, 0.11751959f, 0.06079208f, 0.07456777f, 
    -0.00119018f, 0.09089074f, -0.33708677f, 0.15195449f, 0.10514247f, 0.05983594f, 0.05357377f, -0.02679570f, 
    0.09591147f, 0.05664575f, -0.08553609f, -0.12944387f, -0.08817700f, -0.18770392f, 0.18072565f, -0.03343794f, 
    -0.10179959f, 0.09710121f, 0.10869289f, -0.03248596f, -0.05778226f, 0.07696763f, 0.15746686f, 0.10816340f, 
    0.02124066f, 0.13019298f, 0.06375713f, -0.00785387f, 0.13308223f, 0.08489893f, -0.11912558f, -0.12062541f, 
    0.04269532f, 0.09113885f, 0.01208957f, 0.01084782f, 0.15218318f, 0.12762910f, -0.02548918f, -0.04939419f, 
    -0.41121030f, 0.03042354f, 0.06309773f, 0.17441747f, 0.02675314f, 0.03997808f, 0.12265601f, 0.13553511f, 
    0.09898902f, 0.17866597f, -0.01168138f, 0.08417824f, 0.01983322f, -0.07129916f, 0.11560010f, 0.04716218f, 
    -0.19620006f, 0.16156067f, 0.03105102f, 0.03408248f, 0.06382281f, 0.04446325f, 0.09934221f, -0.04161682f, 
    0.05545507f, 0.02167179f, 0.19668549f, 0.19623882f, 0.07575029f, 0.14797887f, 0.15106772f, -0.12187637f, 
    -0.07845790f, -0.03562240f, -0.04335935f, -0.04488585f, 0.11346541f, -0.03966904f, 0.12898728f, 0.05123094f, 
    -0.02962868f, -0.04801654f, -0.08955525f, 0.29162061f, 0.16852847f, 0.23643459f, 0.06027323f, 0.10161941f, 
    0.05124815f, 0.08316959f, 0.01086845f, 0.13593803f, -0.10502946f, -0.17056061f, 0.00264556f, 0.04667373f, 
    0.09186389f, -0.11217398f, -0.13633904f, -0.08912714f, -0.10888651f, -0.37967560f, -0.04556907f, -0.18181345f, 
    0.04088632f, -0.01263513f, 0.21113910f, -0.15101615f, -0.06477346f, -0.12854926f, 0.04127299f, -0.13068117f, 
    -0.01828997f, -0.01651749f, 0.06668916f, -0.14916487f, 0.07727087f, -0.17303888f, -0.33523783f, -0.03241027f, 
    -0.17624593f, 0.00502586f, 0.09149325f, 0.11458590f, 0.02176805f, 0.13458879f, -0.00741580f, 0.10038542f, 
    0.04220826f, 0.08878900f, -0.07356958f, 0.07848343f, -0.21920846f, -0.02038830f, 0.23511165f, 0.03771310f, 
    0.12046224f, 0.07567316f, -0.07587756f, -0.20768943f, -0.15231641f, -0.07865170f, -0.17516094f, -0.09340933f, 
    -0.02069600f, -0.02249417f, -0.13020067f, 0.09766298f, 0.20634574f, 0.03640807f, 0.10828424f, 0.05259046f, 
    0.02367595f, -0.01671680f, 0.17777579f, 0.15568615f, 0.23153166f, 0.01959739f, -0.23826514f, -0.11196294f, 
    0.13113236f, -0.02592956f, 0.13297473f, 0.23410332f, 0.06749661f, 0.06841329f, 0.03987068f, -0.09054409f, 
    -0.01725884f, 0.09823162f, 0.12497629f, -0.01061393f, 0.16162150f, -0.13713719f, -0.34111568f, 0.03763098f, 
    0.06356939f, -0.19032045f, 0.00060662f, -0.11497841f, 0.07531571f, 0.04056143f, -0.26935798f, -0.37687054f, 
    0.13380218f, 0.06371086f, 0.07206627f, -0.08345950f, -0.06941818f, -0.07418463f, -0.15636879f, 0.07989430f, 
    -0.01586833f, -0.01217373f, 0.17278291f, 0.05131961f, 0.10809116f, -0.00341669f, -0.08086397f, -0.03505902f, 
    -0.49823439f, -0.09738788f, -0.01749188f, 0.05466133f, 0.12339573f, -0.02632977f, 0.07737870f, -0.12747975f, 
    -0.06741804f, -0.15199034f, 0.19207290f, 0.08810585f, 0.04089330f, -0.09708489f, -0.01714808f, 0.15053128f, 
    0.12057547f, -0.01687768f, -0.11562330f, -0.01802034f, -0.15047681f, -0.24566154f, 0.03409037f, 0.08289508f, 
    -0.08262962f, -0.04347229f, -0.03382147f, -0.10332452f, -0.08581093f, 0.14429197f, -0.15946436f, 0.09078627f, 
    0.08893496f, -0.09049559f, -0.06610242f, -0.28413469f, -0.02073711f, 0.06761294f, 0.17467204f, 0.07216634f, 
    0.06082691f, 0.14411630f, 0.07309327f, 0.15564378f, 0.01142141f, -0.35725683f, -0.05115597f, -0.28578621f, 
    0.21577802f, 0.06734397f, 0.03935967f, 0.08355529f, -0.20172349f, 0.11362907f, 0.03015498f, -0.05871956f, 
    -0.35695109f, 0.09798546f, 0.00136473f, 0.19519836f, -0.07121675f, -0.09212126f, -0.17408331f, 0.08166534f, 
    0.12259826f, -0.18633004f, 0.08169324f, 0.16026792f, 0.00645224f, 0.16467060f, -0.03964501f, 0.02992215f, 
    -0.02856898f, 0.00060976f, 0.01576736f, 0.05257291f, -0.06119956f, 0.00892497f, -0.05594260f, -0.04707183f, 
    0.03741709f, -0.00153900f, 0.01625619f, -0.07058199f, 0.04429951f, 0.04775572f, 0.02301321f, -0.02733864f, 
    -0.03169507f, -0.03237358f, 0.02486366f, 0.03401385f, -0.03939097f, -0.00486353f, -0.01825555f, 0.02143191f, 
    0.04667219f, -0.00558501f, -0.04869326f, -0.02424050f, -0.04638107f, 0.02079613f, 0.01081743f, -0.06756476f, 
    -0.04298232f, 0.02911968f, -0.03355634f, -0.02743229f, -0.05886772f, -0.03097522f, -0.02003219f, -0.02687121f, 
    -0.01019555f, -0.04498801f, 0.04932812f, 0.02015090f, -0.00414327f, -0.05483888f, 0.01416620f, 0.01231305f, 
    -0.02764281f, -0.06208064f, -0.03512090f, 0.04825047f, -0.04686008f, 0.01662666f, -0.00599202f, -0.04241537f, 
    0.00060614f, -0.00596443f, 0.01427846f, 0.00362297f, -0.03694183f, 0.03607370f, -0.00567885f, 0.04769033f, 
    -0.05753545f, -0.05749240f, -0.02276474f, -0.06151196f, 0.02398490f, -0.03740571f, -0.00086097f, 0.03205898f, 
    0.00373536f, -0.02919870f, 0.00080931f, -0.04728517f, -0.00313109f, 0.03960842f, 0.01693838f, 0.02286991f, 
    0.02293907f, -0.04899640f, -0.05396664f, -0.01415396f, 0.04806916f, -0.06353028f, -0.02062875f, 0.04989562f, 
    -0.04493983f, -0.03918358f, -0.02457396f, 0.02954360f, -0.03281007f, -0.03690639f, 0.01048814f, 0.02706908f, 
    0.00682260f, -0.03056186f, -0.02028693f, 0.05506563f, 0.03827505f, -0.01511235f, -0.04965646f, 0.02376305f, 
    -0.02742205f, -0.03893571f, -0.02163184f, 0.00451708f, -0.01068060f, -0.00259360f, -0.03238132f, -0.00494807f, 
    -0.00734296f, 0.01170901f, -0.05521212f, -0.00885211f, 0.02421369f, -0.02513686f, 0.04780014f, -0.01618601f, 
    0.04953477f, -0.05640471f, -0.04016164f, -0.04619464f, 0.00604217f, -0.01363371f, -0.04038641f, 0.01409374f, 
    0.05036244f, 0.03493260f, 0.01907659f, -0.05153131f, 0.03686592f, 0.01902284f, -0.01780254f, -0.05595990f, 
    -0.03071114f, 0.00122220f, 0.02391836f, -0.03300675f, -0.06402821f, 0.00368461f, -0.02655347f, -0.05168381f, 
    -0.02876379f, -0.01771985f, 0.03547469f, -0.05980469f, -0.03222109f, -0.04391859f, 0.04316427f, -0.00866151f, 
    0.04588537f, 0.05030701f, 0.05080553f, 0.02561755f, 0.04107890f, -0.01306250f, 0.04386785f, -0.05045507f, 
    -0.02810609f, 0.01280861f, 0.04812295f, -0.01678943f, -0.02306782f, -0.04415603f, -0.03735860f, 0.00165313f, 
    -0.01643874f, 0.03590405f, 0.01289965f, 0.00906410f, -0.01843044f, 0.02726604f, 0.03612982f, -0.06186204f, 
    0.00665464f, 0.00734306f, 0.02581158f, -0.00980704f, 0.01264322f, 0.02110175f, 0.00507968f, -0.06685188f, 
    0.02314809f, -0.04825234f, -0.02821541f, -0.05276246f, -0.04235398f, -0.00905183f, 0.03948152f, -0.02726790f, 
    0.02963102f, 0.03034227f, -0.04634085f, -0.05326362f, -0.00039314f, 0.01858700f, 0.03362194f, 0.00891763f, 
    -0.01481312f, 0.01765505f, -0.06104251f, -0.05794223f, -0.05986305f, -0.06020987f, -0.00375753f, -0.04501783f, 
    0.01141074f, -0.04488837f, -0.01883863f, 0.02771034f, -0.05984779f, 0.01211217f, 0.01371595f, 0.00455465f, 
    0.02754093f, 0.03897390f, 0.01699908f, -0.00551533f, -0.02234185f, 0.03836771f, 0.00614837f, 0.00286367f, 
    0.01719163f, -0.05040711f, 0.01275169f, -0.01639418f, -0.01849049f, -0.00879407f, 0.04855325f, -0.03206111f, 
    -0.03848011f, 0.04587327f, -0.01022217f, -0.03620936f, -0.05105872f, 0.00225760f, 0.01822815f, 0.03715214f, 
    -0.03414336f, 0.02591567f, -0.04229972f, -0.01640582f, -0.06286947f, -0.01102838f, -0.04668006f, -0.01276729f, 
    0.01385964f, -0.01175821f, 0.03814045f, -0.00238823f, 0.00046347f, -0.01870585f, 0.03246644f, -0.00247404f, 
    -0.05777879f, 0.03889113f, -0.03889621f, -0.01562062f, 0.04339444f, -0.01287997f, 0.00527844f, 0.02628593f, 
    -0.06727247f, 0.00998906f, -0.05504962f, -0.03553030f, -0.05161886f, -0.02916803f, -0.03539572f, 0.04796597f, 
    -0.02939484f, 0.01599329f, -0.06119920f, -0.01800017f, 0.02181071f, 0.05340067f, 0.00187090f, 0.03752279f, 
    0.05394813f, 0.03115102f, -0.05712102f, -0.01970764f, 0.01686864f, -0.05045266f, -0.04940405f, 0.04408746f, 
    -0.03813856f, -0.05315907f, 0.05322234f, 0.04559776f, -0.02489637f, -0.00444120f, -0.03401611f, -0.00499662f, 
    -0.04772310f, 0.02620083f, -0.03795381f, -0.00291186f, -0.00591800f, 0.00577022f, 0.00599588f, 0.03142663f, 
    -0.02607330f, -0.04472830f, 0.04921483f, -0.04215903f, -0.03885720f, 0.04275277f, 0.03419463f, 0.00211952f, 
    -0.02951481f, 0.01666323f, -0.00134906f, 0.00941588f, 0.02160691f, -0.04189794f, -0.03784698f, -0.00976034f, 
    -0.05964864f, 0.00481610f, -0.04862944f, -0.02235088f, -0.00322981f, -0.04211972f, 0.01917429f, 0.02547481f, 
    -0.05509845f, -0.05368616f, -0.01396943f, 0.02308047f, -0.03330234f, -0.00448546f, 0.01107610f, -0.04775757f, 
    -0.00084727f, -0.04470603f, 0.04028538f, -0.06075905f, 0.01384773f, -0.00258209f, -0.01898210f, 0.00034687f, 
    -0.00475618f, -0.04536769f, 0.00376192f, 0.02903314f, -0.03268781f, 0.05552340f, 0.05053917f, 0.01465056f, 
    0.03515420f, -0.02264223f, -0.02865938f, 0.04466798f, -0.04422062f, 0.04833435f, 0.01873584f, 0.01134406f, 
    -0.04051179f, 0.03370149f, 0.03448449f, -0.00922012f, -0.03339268f, 0.00009170f, -0.01562825f, -0.00577424f, 
    -0.01717685f, -0.05121482f, 0.04214071f, 0.02996184f, -0.04412715f, -0.02950930f, 0.04861238f, -0.04430059f, 
    -0.02653672f, -0.05663240f, 0.05072656f, -0.05175652f, -0.03750258f, 0.04108657f, -0.00209610f, -0.02854020f, 
    -0.05305843f, 0.04830115f, -0.05543810f, 0.03151581f, 0.03058926f, 0.00586201f, 0.01322553f, 0.04946274f, 
    -0.01936356f, 0.02417432f, 0.02877327f, -0.03569341f, -0.03722592f, -0.00356431f, 0.00699979f, -0.05875178f, 
    -0.00072617f, -0.00124360f, -0.04831438f, 0.04512896f, -0.04423490f, -0.02625055f, -0.03909215f, -0.04165376f, 
    0.03868830f, -0.01321917f, 0.00837641f, -0.03995691f, -0.04957635f, 0.00548186f, -0.03883473f, 0.02541496f, 
    -0.04582465f, -0.00467041f, 0.00102060f, -0.05539647f, -0.05504158f, 0.02594299f, 0.03742889f, 0.05057371f, 
    -0.01100726f, -0.00953029f, -0.01055000f, -0.03435802f, -0.02798598f, 0.03087505f, 0.03960278f, -0.04938424f, 
    -0.00011741f, 0.02401419f, -0.02896901f, 0.02492982f, 0.02711505f, -0.03831840f, -0.00011120f, 0.03966784f, 
    -0.05773045f, -0.00346542f, -0.00422930f, 0.02754074f, 0.00850504f, -0.02240968f, -0.05021515f, 0.03128011f, 
    0.00023454f, -0.06551494f, -0.00764133f, -0.04045415f, 0.03143142f, -0.03574734f, -0.05210002f, -0.02713111f, 
    -0.06243069f, -0.03573141f, -0.02076724f, -0.02917671f, -0.00902448f, -0.04702282f, -0.03536014f, -0.00878958f, 
    -0.03925692f, 0.00199298f, -0.02561513f, -0.06060711f, 0.05167112f, -0.01816033f, 0.01776679f, -0.04099526f, 
    -0.01668707f, -0.02279774f, -0.05368219f, 0.00649225f, 0.01062754f, 0.00907428f, -0.06190705f, 0.04153808f, 
    0.01907669f, -0.00890281f, -0.00144928f, 0.02226524f, -0.00676512f, -0.02805391f, -0.05887301f, -0.00059596f, 
    -0.01957368f, -0.05597171f, -0.03176450f, -0.01684550f, 0.00502971f, 0.04033784f, 0.00752923f, -0.01170645f, 
    -0.03240032f, 0.04067713f, 0.04132283f, -0.04315167f, -0.03618945f, 0.05504650f, -0.00170417f, 0.00017556f, 
    -0.05651439f, 0.00137108f, -0.05226948f, 0.04613027f, 0.00251851f, 0.05399826f, 0.02950783f, 0.01294750f, 
    -0.00200208f, 0.02791263f, -0.04018794f, 0.01024229f, -0.02026341f, 0.02805244f, -0.03781526f, 0.04139391f, 
    -0.04301520f, -0.02949941f, 0.02146377f, -0.00732428f, -0.03774788f, -0.03359007f, -0.03859998f, 0.00831064f, 
    -0.03984987f, -0.03401285f, -0.01904469f, 0.03426749f, 0.00785737f, 0.03061557f, -0.04877535f, 0.00328132f, 
    0.03017100f, 0.00774350f, 0.00367184f, 0.04681540f, 0.05390348f, 0.03783443f, -0.02388006f, 0.01396436f, 
    0.04784272f, -0.03584384f, -0.01640099f, -0.03907396f, -0.01224317f, -0.04230668f, 0.00805812f, 0.03115041f, 
    0.04613413f, 0.05347896f, -0.03631802f, -0.03195577f, 0.04313787f, -0.02654716f, -0.00886117f, -0.04169301f, 
    -0.04058103f, 0.02675303f, 0.01761613f, -0.01595248f, -0.05296420f, -0.02559834f, -0.02700783f, -0.00306635f, 
    -0.00047254f, -0.05202445f, 0.02434043f, -0.04642282f, -0.02446311f, -0.05404407f, 0.03141026f, -0.05296264f, 
    -0.00021196f, -0.08038442f, -0.14569320f, -0.08548382f, -0.04520056f, 0.07187805f, 0.10165241f, 0.05002877f, 
    0.09377696f, 0.23266380f, 0.03487187f, -0.08138145f, 0.03679892f, 0.09324399f, 0.03275612f, 0.09791217f, 
    0.12940627f, -0.07713258f, 0.08325750f, -0.04861325f, 0.16674584f, -0.03577840f, 0.03952774f, -0.21390058f, 
    -0.11576998f, 0.13712288f, -0.07352954f, -0.08295458f, 0.03026224f, 0.15008689f, -0.01852971f, 0.07148280f, 
    -0.02863147f, -0.01858876f, 0.13823868f, -0.07013415f, -0.22282025f, -0.01713357f, -0.25613174f, 0.11246818f, 
    0.01648530f, 0.04672474f, 0.02742349f, 0.09050242f, 0.16629897f, -0.06654965f, -0.01554602f, 0.10353719f, 
    0.14288731f, 0.05712299f, 0.02097449f, 0.05945003f, -0.00857721f, -0.08162873f, 0.06554730f, -0.22111307f, 
    -0.19701163f, -0.03978301f, -0.01206019f, -0.16072226f, 0.16781864f, -0.12531246f, -0.01366236f, -0.09477761f, 
    0.07172411f, 0.19929270f, -0.02708092f, 0.07680899f, 0.04715867f, -0.05572848f, -0.03008505f, -0.04731148f, 
    -0.37934861f, -0.10868271f, -0.27142173f, 0.06486055f, 0.13431549f, -0.02027081f, 0.02657977f, -0.11059475f, 
    0.19044802f, -0.27354375f, -0.03088111f, -0.10709385f, -0.04298352f, -0.06757147f, 0.05375735f, 0.07753119f, 
    0.15435462f, -0.11744352f, 0.09903923f, -0.08172130f, -0.16269058f, -0.03218291f, 0.05851432f, 0.06079469f, 
    -0.11362445f, 0.17798607f, 0.03332099f, 0.00571952f, 0.08956351f, 0.02206839f, 0.00877982f, 0.00811710f, 
    0.08988854f, 0.21084365f, -0.02975287f, 0.09741978f, -0.41900441f, -0.01105316f, 0.01672219f, -0.01050506f, 
    -0.19676025f, -0.18318574f, 0.06836677f, 0.09257912f, 0.01748500f, 0.12811306f, 0.17337543f, -0.07774521f, 
    -0.00196533f, 0.23416829f, -0.01667460f, 0.11823413f, 0.11133257f, -0.04333781f, -0.25321215f, -0.05283161f, 
    0.01161556f, 0.25296929f, -0.07978910f, 0.11585914f, -0.08266330f, -0.07870363f, -0.06505434f, -0.01530568f, 
    0.02269885f, -0.00828228f, 0.23799898f, 0.09636789f, 0.05356263f, 0.10131863f, 0.03637647f, 0.15749125f, 
    0.00689905f, -0.00192342f, -0.10147645f, -0.23318237f, -0.13789867f, 0.07328289f, 0.03307721f, 0.10074210f, 
    0.07196826f, -0.04386611f, -0.02677276f, 0.06602285f, -0.03563480f, -0.11163202f, -0.18383725f, 0.17223418f, 
    -0.00124735f, -0.06723459f, -0.04987838f, -0.20709485f, -0.14181234f, -0.02148812f, 0.18219882f, 0.07503578f, 
    0.06166020f, 0.05660374f, -0.03373984f, 0.35161272f, -0.17685117f, 0.09528538f, -0.17427185f, -0.04088734f, 
    0.10202686f, -0.07373329f, 0.16859663f, 0.11191833f, 0.03752590f, -0.18208735f, 0.16649868f, -0.05352224f, 
    0.06767816f, 0.09711681f, 0.02568682f, 0.02999465f, -0.02302367f, -0.06880085f, -0.16762401f, 0.02008447f, 
    -0.09636208f, -0.18282890f, 0.07474174f, -0.08616193f, -0.05178594f, -0.05489613f, -0.30357379f, 0.08379098f, 
    -0.10544705f, 0.27274501f, -0.10583499f, 0.05211837f, 0.01017907f, -0.01300882f, -0.06712521f, -0.14646192f, 
    -0.08560458f, -0.13259067f, 0.18313679f, 0.12222345f, 0.05962026f, -0.08729600f, 0.08941770f, -0.00795138f, 
    0.13973460f, 0.19579212f, 0.01328499f, 0.09777850f, 0.00680605f, -0.03811804f, 0.05897421f, 0.06836154f, 
    -0.04112506f, -0.07774843f, -0.10199931f, 0.04548790f, 0.09216246f, -0.01642898f, -0.06942004f, -0.12497267f, 
    -0.01165189f, -0.00734331f, 0.08510745f, -0.09926484f, -0.21311933f, -0.07916536f, -0.05595995f, 0.02144422f, 
    0.04463622f, 0.14246376f, 0.02063283f, -0.13664645f, -0.13447484f, 0.13531820f, -0.14273663f, 0.08681228f, 
    0.02646631f, 0.03521018f, -0.06875878f, -0.13224354f, -0.33367816f, 0.12501314f, -0.02362256f, 0.03574701f, 
    -0.12256984f, 0.03407531f, 0.01126558f, 0.07192133f, 0.12397164f, -0.00445490f, -0.02276769f, -0.13104288f, 
    -0.10174130f, 0.04122595f, -0.21204907f, 0.07932661f, 0.01869386f, 0.03907958f, 0.12356947f, 0.19579680f, 
    0.23798545f, -0.19839659f, 0.02388868f, -0.12314230f, -0.10809816f, 0.25431269f, 0.04377417f, 0.08416774f, 
    0.00872306f, 0.02717853f, 0.09556369f, -0.01069252f, -0.10739878f, 0.06082186f, -0.03679588f, -0.19063441f, 
    -0.01199166f, -0.00983001f, -0.06232250f, 0.04271232f, -0.06101793f, -0.06587609f, 0.05312378f, 0.03660753f, 
    -0.00421544f, 0.02708451f, 0.04911139f, -0.00838897f, -0.03320165f, -0.03511738f, 0.01323141f, -0.05040095f, 
    0.03108622f, -0.02049094f, -0.03105168f, 0.00097334f, -0.00774740f, -0.03203897f, -0.01024225f, 0.02260746f, 
    0.03404241f, -0.02709727f, -0.01298670f, -0.01373840f, -0.03677810f, -0.00085007f, -0.01369688f, 0.00976080f, 
    -0.04617286f, -0.08480615f, -0.00495668f, -0.02214899f, -0.04988067f, 0.00205775f, -0.03418951f, -0.03525267f, 
    0.00402239f, -0.05649785f, 0.02785739f, 0.02340981f, 0.02329046f, 0.04035089f, -0.01031902f, -0.03845192f, 
    0.01236062f, -0.01061806f, 0.03739872f, -0.07203047f, 0.00118916f, -0.06257256f, 0.02050625f, 0.02902501f, 
    -0.05822513f, -0.05016008f, -0.00185623f, -0.01066868f, 0.02263937f, 0.00776066f, -0.01000646f, -0.01203071f, 
    -0.04983395f, -0.00237400f, -0.07726175f, -0.04754228f, 0.01566986f, 0.00559199f, 0.04485066f, -0.06067311f, 
    -0.04777159f, -0.08921069f, -0.03720207f, -0.03714943f, -0.08480415f, -0.03569322f, -0.04633519f, -0.01013877f, 
    -0.08163661f, 0.04191833f, -0.06791603f, -0.01115808f, -0.07927357f, -0.02042666f, 0.05731155f, 0.05007703f, 
    -0.06141635f, 0.03842217f, -0.00367479f, 0.01365112f, 0.02765133f, 0.03242702f, 0.01467474f, 0.04353580f, 
    0.03795016f, -0.06342893f, 0.02596807f, 0.02493049f, -0.00647467f, 0.03747552f, -0.00598391f, -0.07019114f, 
    -0.09699589f, -0.03539887f, 0.02464159f, 0.04145150f, 0.03676827f, -0.02032815f, -0.07292028f, -0.04166247f, 
    0.01336195f, -0.05640735f, 0.00654985f, -0.04035474f, -0.02978398f, 0.01290489f, 0.00653694f, -0.00422177f, 
    0.03317428f, -0.05211541f, -0.01713418f, 0.03124028f, -0.09309368f, -0.06997454f, -0.01628527f, 0.04360546f, 
    0.02348228f, -0.01974090f, 0.02893431f, -0.03288065f, 0.01683316f, 0.04126980f, 0.03475783f, -0.04504281f, 
    -0.08076089f, -0.04079408f, 0.04102841f, 0.04146034f, -0.01819779f, -0.06701900f, 0.01323009f, 0.05654921f, 
    0.03301164f, -0.00008490f, 0.02057059f, 0.00953078f, 0.01212500f, -0.01851353f, -0.05658947f, 0.04498645f, 
    0.03630954f, -0.00926283f, 0.02012645f, -0.04001600f, 0.00180874f, 0.04891586f, 0.01062185f, -0.04262122f, 
    -0.05094346f, -0.03584962f, -0.08578477f, -0.05968292f, 0.02796094f, 0.02013498f, -0.00708509f, -0.01539386f, 
    0.00071624f, -0.04447988f, -0.01035568f, -0.08573522f, -0.01207354f, 0.01463028f, -0.01871035f, 0.02445693f, 
    0.02677498f, 0.02974369f, -0.04863849f, -0.02786258f, -0.03333464f, -0.01206415f, -0.07764389f, -0.03774167f, 
    0.01886646f, 0.00728964f, 0.01669414f, -0.06432904f, -0.00203520f, -0.04268450f, 0.03343127f, -0.05567531f, 
    0.01829754f, 0.00740808f, 0.03206466f, 0.01078454f, 0.00440721f, -0.02317173f, -0.01915826f, -0.04876809f, 
    -0.00312171f, -0.03388760f, -0.02769903f, -0.07551847f, -0.03437722f, -0.02608571f, 0.01649734f, -0.03072100f, 
    -0.06397907f, 0.03828874f, -0.00991699f, -0.08550560f, 0.03322397f, -0.00405178f, -0.00639496f, -0.05961680f, 
    -0.04816069f, -0.04110116f, -0.04381329f, 0.04198228f, 0.03928561f, -0.03576811f, -0.03972077f, -0.05069491f, 
    -0.01763294f, 0.04445568f, -0.02119027f, -0.02385370f, 0.04243779f, -0.07197313f, 0.01539134f, -0.00674362f, 
    -0.04856179f, 0.04339704f, 0.02957120f, -0.04364484f, -0.01437495f, 0.03743330f, -0.00832741f, 0.02601338f, 
    -0.04897825f, 0.01579457f, 0.02222008f, -0.10920958f, -0.03318802f, 0.02526882f, -0.00392967f, -0.04192533f, 
    -0.04963541f, -0.00478313f, 0.02432923f, 0.02312248f, -0.01342348f, -0.00348539f, -0.01396155f, -0.05827601f, 
    0.03209741f, -0.01653551f, -0.01627778f, -0.01941230f, -0.04952550f, 0.01323344f, -0.01023145f, 0.00786284f, 
    0.01017133f, 0.03452284f, -0.01561293f, -0.09391972f, -0.02425807f, 0.01201233f, -0.05315886f, 0.01061529f, 
    0.04710127f, -0.05830476f, 0.00834022f, -0.05955986f, -0.08229636f, -0.07014617f, -0.01628001f, 0.01573852f, 
    -0.02228671f, -0.06750101f, -0.04104220f, 0.01141856f, 0.04379006f, -0.05428670f, 0.01448889f, -0.03233128f, 
    0.24223584f, -0.27445275f, 0.22641915f, 0.17518394f, 0.03942800f, 0.08610320f, -0.05942085f, 0.01766664f, 
    -0.20854913f, 0.06209413f, -0.08948705f, 0.00370752f, -0.00777642f, 0.07859955f, 0.00147642f, 0.04838266f, 
    0.02631812f, -0.13135688f, -0.07790077f, -0.06101064f, -0.23846945f, -0.10290320f, -0.03646605f, -0.05023262f, 
    -0.00325772f, -0.01182997f, 0.03706052f, -0.00031812f, 0.12530705f, -0.11593664f, 0.00279526f, -0.13822179f, 
    0.06687873f, 0.00986966f, 0.08708794f, -0.07030798f, 0.03139286f, -0.18058029f, -0.12339995f, -0.19449599f, 
    0.03433483f, -0.20878358f, 0.06728181f, 0.09092328f, -0.13322337f, -0.46379295f, 0.12073572f, -0.05499306f, 
    0.01159239f, 0.12829646f, 0.09309270f, -0.15170224f, -0.06427458f, -0.00813884f, 0.42099687f, 0.19555257f, 
    -0.12841019f, -0.02916214f, -0.03234539f, 0.15607387f, -0.11430956f, 0.04889070f, 0.04449031f, 0.07290044f, 
    -0.12047692f, 0.05959949f, 0.10349058f, 0.00355523f, 0.03987990f, -0.19512562f, -0.13905114f, 0.03324948f, 
    -0.12058005f, -0.10832741f, 0.16525313f, 0.09124862f, 0.02013388f, 0.03300418f, 0.00113121f, 0.00091936f, 
    -0.04192008f, -0.14077698f, -0.08317699f, 0.21115823f, 0.11818342f, -0.05594452f, 0.02186841f, -0.05088509f, 
    0.06271316f, -0.00662585f, -0.24263465f, -0.11145281f, -0.07072367f, 0.00151218f, -0.10570124f, 0.14848003f, 
    -0.05369285f, 0.12804137f, -0.02962730f, 0.27596167f, -0.25592503f, 0.28082111f, 0.13409729f, 0.09541053f, 
    0.03849236f, 0.04964856f, -0.01548884f, 0.01265538f, 0.25213769f, -0.14696090f, -0.05491875f, 0.13525568f, 
    0.07077233f, -0.02747543f, -0.08931340f, -0.02795681f, 0.18904686f, -0.17745103f, 0.17277890f, 0.06392612f, 
    0.03381465f, -0.02093558f, -0.12702176f, -0.15452172f, 0.04329176f, -0.14758557f, 0.07838864f, -0.00039832f, 
    0.04784562f, 0.01685493f, -0.00622972f, 0.08533973f, 0.13041292f, -0.05510450f, -0.05152708f, -0.02284945f, 
    0.15389022f, 0.02467762f, 0.08992583f, 0.01365579f, -0.02226926f, -0.00481686f, 0.13267058f, 0.13574792f, 
    0.05804469f, 0.07401481f, -0.09430441f, 0.13480407f, -0.01725872f, 0.06953012f, 0.12388511f, -0.09002819f, 
    0.07923158f, 0.10296901f, 0.20198016f, -0.18086547f, 0.04229305f, -0.15621388f, -0.10205051f, -0.09560819f, 
    -0.08769487f, 0.04299080f, -0.17500621f, -0.49751863f, 0.07705694f, -0.21901400f, 0.14547738f, 0.02894329f, 
    -0.12305772f, -0.05018084f, -0.01962710f, 0.36228162f, 0.03270009f, 0.15395328f, 0.15146396f, 0.05623692f, 
    0.00978438f, 0.06019161f, -0.04370630f, -0.04266363f, 0.24033847f, 0.05063907f, -0.16370645f, -0.16501363f, 
    -0.10436382f, 0.09591149f, 0.07549902f, 0.07548839f, 0.13510685f, 0.16611819f, 0.18954857f, -0.03876919f, 
    -0.11645754f, -0.06425481f, 0.05243179f, -0.06469245f, 0.04831940f, -0.09640397f, -0.08106866f, 0.11838210f, 
    -0.00828285f, -0.18013448f, -0.13520475f, -0.06634526f, 0.00424796f, -0.06374665f, -0.05450637f, 0.05144906f, 
    0.21124938f, -0.08266257f, -0.11083241f, -0.00656136f, -0.23797801f, 0.15016049f, -0.05639170f, -0.09728681f, 
    0.04879593f, 0.12286153f, -0.01790216f, -0.16372706f, -0.06390266f, -0.06053449f, 0.04539309f, -0.06903481f, 
    0.00874323f, 0.05416957f, -0.08322445f, -0.13564317f, -0.02287248f, -0.06031339f, 0.03308153f, -0.07199433f, 
    -0.04103208f, -0.01212781f, 0.08551632f, 0.02452953f, 0.05702044f, -0.03575296f, -0.21586359f, 0.04263180f, 
    -0.05102125f, 0.08342185f, 0.03611074f, -0.06565923f, -0.23906879f, 0.01229234f, 0.09290914f, 0.09188990f, 
    -0.06667673f, 0.02736759f, -0.21786746f, 0.14807542f, 0.12661937f, 0.02159246f, 0.09161196f, 0.00454599f, 
    -0.05690742f, 0.07534296f, -0.03599692f, 0.08690238f, 0.12886012f, 0.06947555f, 0.22287674f, 0.04165713f, 
    -0.06708717f, 0.02388863f, -0.02572695f, -0.01430336f, 0.09766426f, -0.13539211f, -0.00925262f, 0.17874821f, 
    0.12382724f, -0.18760894f, 0.01757061f, -0.11016838f, -0.08071601f, 0.02602542f, -0.09939410f, -0.03606084f, 
    0.13950613f, 0.01066811f, 0.02193668f, -0.17311864f, 0.07399472f, -0.05417892f, 0.00319518f, 0.05897578f, 
    -0.27841580f, -0.02139597f, 0.14874132f, -0.05680935f, 0.00610359f, 0.05366070f, -0.05434297f, -0.11194148f, 
    -0.03299687f, 0.23139727f, 0.37672096f, 0.12397061f, -0.02341043f, -0.09624279f, 0.06972771f, -0.07245956f, 
    0.07532162f, -0.12415919f, 0.16643043f, -0.04150197f, 0.02341778f, -0.10674456f, 0.12453961f, 0.10727822f, 
    -0.06528361f, -0.04752942f, -0.09042715f, 0.20441584f, 0.04825712f, -0.06572995f, -0.13650905f, 0.05869962f, 
    0.01073864f, 0.06881511f, 0.21047829f, -0.17069668f, 0.06416034f, 0.00309295f, -0.12229184f, 0.08279943f, 
    0.03838240f, 0.01872515f, 0.08546086f, -0.04469334f, 0.08516736f, 0.23397624f, 0.02605819f, 0.09082323f, 
    -0.03946273f, -0.03936711f, -0.02357899f, -0.10786637f, 0.02103189f, -0.11376484f, 0.05447640f, 0.15168484f, 
    0.00787421f, -0.13129538f, 0.03476695f, 0.05066806f, 0.01796020f, 0.05013945f, -0.13054918f, 0.14604542f, 
    -0.14226785f, -0.01596105f, -0.08594645f, 0.06567165f, -0.11253352f, -0.03664741f, 0.05927845f, -0.03567152f, 
    0.03934558f, -0.17647041f, -0.02735461f, 0.02928435f, 0.02633645f, 0.03676642f, -0.23485197f, -0.00467946f, 
    0.17956933f, -0.08969022f, 0.08790375f, 0.10075931f, -0.07484370f, 0.02279974f, -0.11608656f, -0.04542074f, 
    -0.02873110f, 0.10120831f, 0.25322178f, -0.19956025f, -0.11966017f, -0.22144420f, -0.07908973f, -0.05593292f, 
    0.00764358f, -0.02009383f, 0.14616434f, 0.04701238f, -0.06249703f, -0.06414235f, -0.06750615f, -0.12892362f, 
    0.00928999f, -0.13126905f, 0.12145954f, 0.02925373f, 0.21617691f, 0.05252608f, -0.06298310f, -0.17737444f, 
    -0.07488875f, -0.04988400f, -0.01487331f, -0.01821439f, -0.02648092f, 0.18770184f, 0.05288773f, 0.23944688f, 
    0.07793378f, 0.12998445f, -0.09746506f, 0.12107099f, 0.00469700f, 0.09393477f, 0.05997989f, 0.01013822f, 
    0.00671928f, 0.07263739f, 0.08804372f, 0.02856211f, -0.11744270f, -0.08304240f, 0.14234848f, -0.00888748f, 
    0.16087990f, 0.06523395f, 0.07795595f, 0.01527964f, -0.23952800f, -0.01448502f, 0.05077327f, 0.24586514f, 
    0.03867607f, -0.06132048f, 0.04738260f, -0.00330029f, -0.10867122f, -0.14137784f, -0.19310668f, -0.10079166f, 
    0.11579318f, -0.05721317f, -0.06610623f, 0.17783834f, -0.06597067f, -0.08252345f, -0.05446261f, 0.10370092f, 
    -0.09408480f, -0.10138609f, 0.22180264f, -0.11216681f, 0.06835472f, -0.01570944f, -0.19256175f, 0.00812917f, 
    0.03736823f, 0.10983145f, 0.09090861f, -0.15783933f, -0.21352883f, -0.02543712f, -0.11790677f, 0.05088704f, 
    0.02348658f, -0.00583626f, -0.08790334f, -0.09785715f, -0.25411674f, -0.07155179f, 0.11713465f, 0.01173419f, 
    0.04581024f, 0.03757353f, -0.18769366f, -0.13228676f, -0.13254787f, -0.08956979f, 0.10499912f, 0.01834389f, 
    -0.01265793f, -0.00434216f, 0.06061324f, -0.10164029f, 0.05987144f, 0.03863851f, -0.05677096f, 0.02972469f, 
    -0.14292355f, 0.03984242f, 0.00604674f, -0.05550210f, 0.12027486f, 0.17171109f, -0.03288307f, -0.06034813f, 
    -0.09830253f, 0.06260802f, 0.08747873f, 0.03937955f, -0.10292181f, 0.11735135f, 0.10238438f, 0.01689738f, 
    0.32163611f, 0.25065920f, 0.11247043f, 0.05801446f, 0.07707418f, 0.01389404f, 0.14056246f, 0.07318116f, 
    -0.23315151f, 0.08489442f, -0.06133467f, 0.06190209f, -0.03946332f, -0.06181242f, 0.04595055f, 0.10438371f, 
    -0.04843147f, 0.01468636f, 0.05985351f, -0.16673890f, 0.14271812f, -0.14555098f, 0.00619798f, -0.12762696f, 
    0.01870766f, -0.02202857f, 0.00578205f, -0.51231468f, -0.43826091f, -0.06550832f, 0.15161689f, 0.07117105f, 
    0.07013162f, -0.18434222f, -0.17587163f, 0.08961146f, 0.01915791f, -0.20754498f, -0.23025501f, 0.07746100f, 
    -0.07724458f, -0.01599527f, 0.01176666f, 0.02764639f, -0.01873766f, 0.02941209f, 0.30460685f, 0.04556557f, 
    0.05553682f, -0.04487229f, -0.11152314f, 0.16771755f, 0.02640044f, -0.04750665f, 0.30209115f, 0.28476432f, 
    0.08485109f, 0.15135209f, -0.07574955f, -0.04679451f, 0.14668970f, 0.05418902f, 0.06877757f, -0.07270575f, 
    0.06792928f, 0.14355297f, -0.04122067f, -0.03747502f, -0.07302078f, -0.08204663f, -0.15099762f, -0.06263516f, 
    0.08104066f, 0.17064011f, -0.06825056f, 0.14052947f, -0.13581425f, 0.10330112f, -0.00428004f, 0.00638813f, 
    -0.10650612f, -0.26842698f, -0.09529774f, 0.01042444f, 0.09089576f, 0.04306374f, 0.14715853f, 0.11283799f, 
    -0.04345749f, 0.02215174f, 0.01077703f, -0.19811986f, -0.47266069f, 0.06076082f, 0.02952906f, 0.19459672f, 
    0.09350002f, -0.14032680f, 0.07223368f, -0.13583422f, -0.17127141f, -0.32806972f, -0.02254132f, 0.06806096f, 
    -0.12355801f, -0.05401454f, -0.06745687f, 0.13412616f, 0.22276135f, 0.21556327f, 0.28719980f, -0.08257961f, 
    0.02410896f, -0.14986484f, 0.10593235f, 0.14491637f, 0.07670379f, -0.08263648f, -0.13206537f, 0.07532077f, 
    0.00620070f, 0.15882890f, 0.10301892f, -0.03499285f, 0.21753451f, -0.17411649f, -0.12899928f, -0.06064808f, 
    0.02311335f, -0.09839673f, -0.04701349f, -0.01776843f, 0.03031816f, 0.00014796f, 0.13321219f, -0.02307574f, 
    -0.20416620f, -0.12686856f, 0.04313272f, -0.11144552f, 0.12619494f, 0.08506812f, -0.02725359f, -0.11051940f, 
    0.06168726f, 0.02097082f, 0.02131433f, 0.04146775f, 0.03182710f, 0.01374025f, 0.12725922f, 0.07709208f, 
    0.06161860f, 0.07665585f, 0.30542567f, -0.11946892f, 0.11096080f, 0.09404552f, -0.09475608f, 0.01561601f, 
    -0.00544258f, -0.06008674f, -0.15972823f, 0.01597943f, -0.11895265f, 0.07984243f, -0.03284398f, 0.01272219f, 
    -0.10615611f, -0.14637022f, 0.17072888f, 0.04941415f, 0.19269465f, 0.09481108f, 0.05332494f, -0.04003873f, 
    -0.01702109f, -0.01861928f, 0.02235661f, 0.08342210f, -0.04027351f, -0.49056280f, -0.03379096f, -0.08471191f, 
    -0.02706861f, 0.01962512f, -0.08656444f, -0.09593210f, -0.04427334f, 0.06068589f, 0.11925381f, 0.01904014f, 
    0.16539565f, 0.00212233f, -0.09836538f, 0.06540992f, -0.06738316f, -0.03418389f, 0.13421124f, -0.04879482f, 
    -0.28669685f, 0.05983503f, -0.08427150f, 0.10088401f, 0.04537978f, -0.00605834f, 0.08028226f, -0.27446112f, 
    0.22098260f, 0.07020212f, -0.05685515f, 0.03726884f, 0.06590938f, 0.10758623f, -0.03763295f, -0.00116819f, 
    -0.18278483f, -0.30834427f, 0.03107251f, -0.01795732f, 0.12559690f, -0.04932836f, -0.01156815f, 0.08570208f, 
    0.15922758f, -0.02006158f, -0.22120665f, -0.10474369f, 0.00000482f, 0.04135060f, -0.00345243f, 0.15522622f, 
    -0.24023640f, 0.05578886f, 0.18437685f, 0.10088959f, 0.06042256f, -0.02176455f, 0.00583878f, -0.08416972f, 
    -0.17621107f, 0.03137576f, -0.00196066f, -0.10200435f, -0.18416280f, 0.02695713f, -0.02705113f, -0.01564054f, 
    0.05707733f, -0.05291380f, -0.07601468f, 0.21519655f, -0.07444850f, -0.17603190f, 0.02181032f, -0.05211655f, 
    0.04334588f, 0.05127408f, -0.03303681f, -0.01006840f, 0.04420013f, -0.45503056f, -0.16951324f, 0.05634572f, 
    -0.05590034f, 0.02827596f, 0.15928213f, 0.02344220f, 0.11857732f, -0.00146485f, -0.24188499f, -0.27423215f, 
    0.35334855f, 0.07017452f, 0.15693556f, -0.17886239f, -0.10699604f, -0.04200158f, 0.14704101f, -0.05795309f, 
    0.32904020f, 0.15056024f, -0.04728420f, -0.12451039f, -0.21997467f, 0.04300490f, 0.07336658f, -0.01251289f, 
    0.45387307f, 0.11699103f, -0.15755385f, 0.00345294f, 0.11224010f, -0.02346900f, 0.11826097f, -0.05985247f, 
    -0.21022478f, 0.05715048f, 0.02525416f, 0.11344869f, -0.07063876f, 0.04974080f, 0.04047525f, -0.01796259f, 
    -0.00314656f, -0.02865367f, -0.07799324f, 0.05849962f, -0.18595095f, 0.14915884f, -0.00562499f, -0.04794229f, 
    -0.00977360f, -0.05058888f, 0.06954189f, 0.38259509f, -0.31824717f, -0.35649344f, 0.05072317f, -0.00925935f, 
    -0.07119478f, -0.08486566f, -0.07657132f, -0.06717848f, -0.20082399f, 0.01972170f, 0.07953547f, 0.09596403f, 
    0.03764473f, -0.03849670f, 0.06896792f, 0.02954633f, -0.03314158f, 0.24374366f, 0.28111896f, 0.05003368f, 
    0.13247019f, 0.01527553f, 0.00143200f, 0.07864216f, -0.05365729f, 0.11761208f, 0.22696006f, -0.07112107f, 
    -0.33021042f, -0.02332721f, -0.08036385f, -0.05038477f, 0.19241118f, 0.09691613f, -0.11489774f, -0.16584539f, 
    -0.17974931f, -0.09108478f, -0.06444912f, 0.03874015f, 0.20279913f, 0.07879661f, 0.00268388f, 0.03612470f, 
    0.01135732f, 0.03204538f, -0.02568255f, -0.03123637f, -0.00232586f, 0.00772221f, 0.03140299f, 0.05280175f, 
    -0.00955834f, -0.02479252f, 0.05401057f, 0.01881793f, -0.01823812f, -0.00971606f, -0.05790158f, -0.00239147f, 
    -0.00353782f, 0.05221919f, 0.00239730f, -0.05708688f, -0.00628187f, -0.02178564f, -0.03566591f, -0.05330779f, 
    -0.03843746f, -0.02004075f, -0.00481947f, 0.05234959f, -0.04327830f, 0.03594955f, -0.04684686f, -0.05709633f, 
    0.00943389f, -0.03610049f, 0.04461765f, -0.03291766f, -0.05365556f, -0.05652440f, -0.04622865f, 0.02177029f, 
    -0.00574555f, 0.00973031f, -0.03830689f, -0.04040698f, -0.02791554f, 0.05889922f, -0.04370510f, -0.04813199f, 
    -0.00063172f, -0.05668064f, 0.01892641f, 0.00723506f, 0.00287453f, 0.00880435f, -0.00868265f, 0.02370790f, 
    0.01681381f, 0.04166182f, -0.05625497f, -0.04867984f, 0.05183104f, -0.05554155f, -0.00006648f, 0.01067205f, 
    0.01614892f, 0.04261384f, 0.04296383f, -0.05260459f, -0.00437190f, 0.01468560f, -0.00316973f, -0.06590766f, 
    0.02909967f, 0.00600946f, 0.01615576f, -0.05620008f, -0.00473761f, 0.01166141f, 0.04593258f, 0.02697064f, 
    -0.02153812f, -0.05911976f, 0.02772306f, 0.04834922f, -0.03830648f, 0.02857384f, 0.01216911f, 0.01694970f, 
    -0.04797650f, 0.00628087f, -0.00553735f, 0.03733937f, -0.04569129f, 0.02558700f, 0.02294641f, -0.01284914f, 
    0.01595373f, 0.02369337f, -0.06076434f, -0.04943274f, -0.05877144f, 0.02353488f, -0.00429189f, -0.00699072f, 
    0.02950915f, -0.03296929f, 0.01236208f, 0.02997943f, -0.05578611f, 0.00533203f, -0.03548476f, -0.03058060f, 
    -0.04074159f, 0.00359642f, -0.02354486f, -0.03600286f, -0.04605769f, -0.04081464f, -0.02724401f, 0.00540538f, 
    -0.04282866f, 0.01111815f, 0.02483758f, 0.00467268f, -0.04158586f, 0.02400225f, -0.00700026f, -0.01775695f, 
    -0.00177578f, -0.05445442f, -0.05840413f, -0.03797996f, 0.04705906f, 0.03579872f, -0.04195501f, -0.06056876f, 
    -0.04290587f, -0.01032930f, -0.01253098f, 0.00335924f, -0.06293057f, 0.00754080f, -0.04244196f, -0.06008423f, 
    -0.06107713f, -0.00653018f, -0.04987097f, -0.04741817f, -0.03475424f, -0.02154075f, 0.04087424f, 0.00438340f, 
    0.04684790f, 0.01697209f, -0.06378836f, -0.03674318f, 0.00337441f, -0.02642077f, 0.02720251f, -0.05400082f, 
    0.02538980f, 0.01405087f, 0.04438611f, -0.03788508f, -0.02352851f, 0.02715140f, 0.01843174f, -0.06540648f, 
    0.04198376f, -0.00956358f, 0.03313373f, -0.02970235f, 0.06223717f, -0.04010470f, -0.03532680f, -0.04711964f, 
    0.01559177f, 0.05410467f, -0.02936599f, -0.03799013f, 0.02049062f, -0.03433698f, -0.00418806f, 0.04389743f, 
    -0.02790178f, -0.03298735f, 0.02675081f, -0.01791585f, 0.00273037f, 0.02415635f, -0.06289237f, 0.02236030f, 
    -0.04156516f, -0.06108911f, -0.00002009f, -0.06212841f, -0.05413044f, -0.00614946f, 0.01757076f, 0.04288821f, 
    0.02764910f, -0.02836049f, 0.04040555f, -0.03193740f, -0.02274045f, -0.03091443f, 0.05091022f, 0.01395708f, 
    -0.05000093f, 0.04834498f, 0.04050937f, 0.03492169f, 0.01316424f, 0.03493555f, -0.03664598f, -0.04537011f, 
    -0.03478721f, -0.01592050f, 0.02224559f, -0.01798226f, 0.02568219f, 0.02693208f, -0.05652907f, 0.01766455f, 
    0.02367608f, 0.03288776f, 0.02816702f, 0.02070293f, -0.01417752f, -0.04233396f, 0.04397632f, -0.06411677f, 
    0.03634446f, -0.05806490f, -0.01445748f, -0.00917460f, 0.03030845f, 0.00216309f, 0.03192735f, -0.02899486f, 
    0.01545778f, -0.05551589f, -0.04423817f, 0.01635421f, 0.00420927f, -0.05931449f, -0.05571951f, 0.01229641f, 
    0.04390322f, -0.06333700f, -0.01340526f, -0.07067552f, -0.01340203f, 0.04766313f, 0.00948397f, 0.02659262f, 
    0.00823761f, 0.01089264f, -0.02000645f, -0.02537316f, -0.01427812f, -0.00720513f, -0.01772279f, -0.03781460f, 
    0.00681802f, 0.03218785f, 0.01775989f, -0.03042294f, 0.00887432f, 0.00064074f, 0.05897575f, 0.00485580f, 
    0.02400398f, -0.04746013f, -0.01425966f, 0.05012833f, -0.05289653f, 0.04328784f, 0.01934764f, 0.03716830f, 
    -0.03804329f, 0.00830252f, -0.04131890f, 0.00061131f, -0.03358148f, -0.03662070f, -0.02257034f, 0.02419269f, 
    0.01746180f, 0.00263477f, -0.05665877f, 0.04723175f, -0.05101015f, -0.00595919f, 0.00025830f, 0.04076658f, 
    -0.07693361f, -0.00276752f, 0.00300291f, -0.04496728f, -0.04962039f, 0.00245820f, 0.00051911f, -0.04066152f, 
    0.00159997f, -0.04679505f, 0.04292267f, -0.04635661f, -0.04982700f, -0.03749697f, -0.05339003f, -0.05463985f, 
    0.01042149f, -0.04744764f, -0.01008284f, -0.03817680f, -0.01451349f, -0.01784926f, -0.04041103f, -0.01370244f, 
    0.00743245f, 0.02700263f, 0.01122073f, 0.04486602f, 0.02538227f, 0.03102974f, -0.02688067f, -0.02430269f, 
    -0.02728664f, 0.03549953f, -0.00230937f, 0.01578696f, -0.00659802f, -0.03065856f, -0.05912460f, 0.02017852f, 
    0.01736169f, 0.02640315f, -0.03880171f, -0.01847522f, 0.00333877f, 0.03997792f, -0.00982104f, 0.00255997f, 
    0.00543684f, -0.06385957f, -0.03667546f, -0.02876462f, -0.02511944f, 0.04431095f, -0.02738011f, 0.02935315f, 
    0.02433301f, 0.01000918f, -0.06946103f, 0.04151509f, -0.03992943f, 0.00403026f, -0.00594486f, 0.00286966f, 
    0.02122063f, 0.00909564f, 0.00665907f, 0.01644409f, 0.00295226f, 0.02594233f, -0.02041257f, 0.03879442f, 
    0.02356565f, -0.00167902f, -0.00959071f, 0.05999521f, -0.03557222f, -0.02398846f, -0.01701281f, 0.01129817f, 
    -0.00518461f, 0.02320240f, -0.03448591f, -0.00107926f, -0.00640879f, -0.01181220f, -0.02086969f, -0.03433982f, 
    -0.04171621f, 0.01068753f, -0.06380295f, 0.04230171f, -0.04055924f, 0.00101828f, -0.04773334f, -0.00309441f, 
    0.00596625f, -0.05896604f, 0.00901949f, 0.04134367f, 0.01242511f, 0.03478026f, -0.03996212f, -0.05606227f, 
    0.02236906f, 0.01703251f, -0.05906519f, 0.03152605f, -0.02408134f, -0.07852053f, 0.00244298f, -0.01327463f, 
    0.03698256f, 0.05006939f, 0.04752743f, -0.00716003f, -0.04437809f, 0.00425219f, 0.01692157f, 0.00603643f, 
    -0.05175684f, -0.04168515f, -0.04375147f, -0.03179679f, -0.01353983f, 0.03270091f, -0.00711161f, -0.01085538f, 
    0.00328312f, 0.02549336f, 0.00391015f, 0.04320472f, -0.06498794f, -0.03985969f, 0.00319781f, -0.02794040f, 
    0.02249890f, 0.02651137f, 0.02796610f, 0.03466020f, -0.01541015f, -0.02854631f, -0.05265360f, -0.02875408f, 
    0.01379634f, 0.02350458f, -0.03042750f, -0.03547460f, 0.03729773f, 0.02632108f, -0.00209880f, 0.04973068f, 
    0.02959948f, -0.05102816f, 0.02623107f, -0.03689991f, -0.02609254f, 0.04793754f, 0.00515499f, 0.02695696f, 
    -0.02027326f, 0.03011644f, -0.03902321f, -0.06604652f, 0.02112809f, -0.05112196f, -0.01483383f, -0.01135283f, 
    0.04562423f, -0.01042820f, 0.01120870f, 0.03291514f, -0.04514740f, -0.04578149f, 0.03261556f, -0.00368766f, 
    0.00531554f, 0.02730850f, -0.01702956f, 0.00594973f, -0.06212752f, -0.04815384f, 0.03371203f, 0.01030713f, 
    -0.00223224f, 0.01336875f, 0.05313680f, -0.03915257f, -0.00166346f, 0.02857761f, 0.00362731f, 0.00982769f, 
    -0.04647579f, 0.03726304f, -0.03766713f, -0.05628347f, 0.00165362f, -0.01277889f, -0.04354639f, -0.04190848f, 
    0.04269560f, -0.03986659f, 0.03975058f, -0.00128889f, 0.03318613f, -0.04830381f, 0.01217059f, -0.04400587f, 
    -0.01414040f, 0.02537955f, 0.03452658f, -0.03267088f, 0.04337720f, -0.00452575f, 0.05181916f, 0.03807900f, 
    0.02054043f, -0.02254042f, 0.00380678f, -0.06081595f, -0.05774561f, -0.05600866f, 0.02032292f, -0.02799593f, 
    -0.03959770f, 0.02416216f, 0.00280111f, -0.03127421f, 0.02517903f, -0.02525210f, -0.05073464f, -0.05699607f, 
    -0.04102430f, -0.01944358f, -0.06409597f, 0.00187213f, 0.00898014f, -0.01472330f, 0.04500852f, 0.00443843f, 
    -0.01889831f, 0.03556533f, 0.03756281f, 0.04356132f, -0.04471935f, -0.04479144f, 0.03471244f, -0.02385333f, 
    0.04770880f, 0.00765938f, 0.00125203f, 0.01346779f, 0.01516730f, -0.00101469f, -0.04507317f, -0.02616685f, 
    0.03393164f, 0.05603764f, -0.01439625f, -0.02417675f, 0.03464015f, -0.05569965f, 0.00559659f, 0.01708538f, 
    -0.00704108f, 0.00853220f, 0.03015097f, 0.02233458f, 0.03058175f, -0.04291268f, -0.02346560f, -0.03980821f, 
    -0.04002929f, 0.02998470f, -0.03193541f, 0.00184078f, 0.01298899f, 0.01596155f, -0.05753628f, 0.00250437f, 
    0.03411436f, -0.03273568f, 0.00916297f, 0.03604406f, -0.05853476f, -0.01445449f, -0.02207494f, -0.02392742f, 
    0.02406251f, 0.00055628f, -0.01863911f, 0.02530436f, -0.02854247f, -0.04165088f, -0.02292683f, -0.00901814f, 
    -0.06279775f, 0.00914560f, -0.05052790f, -0.04925233f, -0.03100300f, 0.05509636f, 0.04824054f, -0.00935759f, 
    0.04843623f, 0.05246465f, 0.01679255f, -0.03370758f, -0.04945856f, 0.00885978f, -0.05106520f, -0.05163626f, 
    0.00704037f, 0.04580808f, 0.01759087f, -0.05441534f, 0.03448544f, -0.05022941f, 0.00192325f, -0.03081194f, 
    0.05165954f, 0.04110030f, -0.04040614f, -0.01010078f, 0.03498497f, -0.03067654f, 0.02304768f, -0.06520773f, 
    -0.00541551f, -0.04786954f, -0.01315197f, -0.02230592f, 0.00056628f, 0.00861735f, -0.02166971f, -0.02536704f, 
    -0.04028332f, -0.04939323f, -0.01903959f, -0.05079051f, 0.03598588f, -0.02279503f, 0.03531581f, 0.01777451f, 
    -0.05730650f, -0.05716837f, 0.03108835f, -0.00648632f, -0.05953243f, 0.01583515f, -0.02822486f, 0.04852373f, 
    -0.05144694f, 0.04428033f, 0.02259208f, 0.00692372f, -0.05330208f, -0.04955025f, 0.03608714f, 0.03772563f, 
    -0.03657802f, -0.04986964f, -0.01465922f, 0.02630932f, -0.01051207f, -0.00728362f, -0.00793833f, 0.05825819f, 
    0.00811274f, 0.02970951f, -0.01085110f, 0.01159884f, 0.02096442f, 0.05378705f, 0.01506765f, -0.03507144f, 
    -0.06018388f, -0.03554318f, 0.00440689f, 0.02021640f, 0.02110932f, 0.01875854f, -0.00065287f, -0.01403453f, 
    -0.01256334f, -0.01852706f, -0.05507778f, -0.01819162f, -0.03924010f, 0.03007663f, 0.05122896f, -0.02800133f, 
    -0.03217569f, -0.04410243f, -0.03717320f, -0.02470074f, -0.05270770f, -0.01608778f, -0.00153771f, -0.04081011f, 
    0.03290761f, 0.00805826f, -0.00116794f, 0.04251613f, 0.00796309f, -0.03477602f, -0.03829554f, -0.04602238f, 
    -0.03060607f, -0.04325343f, -0.05351797f, -0.04493104f, 0.06100711f, -0.02689537f, 0.02305537f, -0.04829120f, 
    -0.01052109f, 0.03101871f, 0.05031222f, 0.03111449f, -0.00196608f, 0.04615698f, 0.04272474f, -0.03305848f, 
    0.00879845f, -0.04447807f, -0.01335094f, -0.04171544f, -0.01316654f, -0.00412444f, 0.00297657f, -0.00697788f, 
    0.05803123f, -0.05228098f, -0.03776986f, 0.02607438f, 0.02225279f, 0.01714090f, -0.03878945f, 0.00573166f, 
    -0.02277344f, 0.03472489f, 0.01332123f, 0.05552777f, -0.03909575f, -0.00837833f, -0.01204264f, -0.01489796f, 
    -0.03077295f, 0.00678327f, -0.03681048f, -0.05373897f, -0.03284696f, -0.01386520f, 0.01373648f, -0.03958434f, 
    0.01074038f, -0.04293279f, -0.05415095f, -0.05578521f, -0.02801969f, 0.05911270f, -0.05663026f, 0.05421212f, 
    0.05040199f, 0.02011812f, -0.00929001f, 0.03904668f, -0.03041754f, 0.03163363f, -0.01661947f, -0.00248557f, 
    0.05301611f, -0.00853187f, 0.01727029f, -0.05434940f, -0.00005910f, 0.04181756f, -0.05021009f, 0.00120661f, 
    -0.01896038f, -0.06588684f, -0.03515406f, -0.04481675f, -0.01033182f, -0.01757375f, -0.00259116f, 0.02412483f, 
    -0.01314810f, -0.05254325f, 0.03080188f, 0.01213002f, -0.03205567f, 0.03363753f, 0.02556188f, -0.04454328f, 
    -0.06094811f, -0.06245800f, 0.01037926f, -0.04705414f, 0.03579320f, -0.04457449f, -0.02237969f, 0.05111026f, 
    -0.05148661f, -0.05313713f, -0.02957123f, -0.05790026f, -0.02291299f, 0.02323841f, -0.00720244f, 0.03646319f, 
    0.01855759f, -0.01818530f, 0.04052722f, 0.03004554f, -0.01808701f, 0.02036969f, 0.03628461f, 0.04204089f, 
    0.04071975f, 0.03629789f, -0.03635062f, 0.02950354f, -0.01257806f, 0.05213339f, 0.02470577f, -0.05431966f, 
    0.00612275f, 0.05475263f, -0.04564945f, -0.04923715f, -0.00082131f, -0.04831914f, 0.00191408f, 0.01614064f, 
    -0.03875001f, 0.02413370f, -0.05507207f, 0.02153084f, 0.02612168f, -0.03673794f, 0.01346010f, -0.04194006f, 
    0.05305515f, 0.04380074f, 0.03696447f, -0.04445225f, -0.04990532f, -0.01848750f, 0.00366108f, 0.02050256f, 
    0.00019149f, -0.02281090f, -0.02973484f, -0.01324116f, 0.03970214f, 0.01816094f, 0.02772077f, 0.02909803f, 
    0.02808422f, 0.03981488f, -0.05656089f, -0.05061519f, 0.01135898f, -0.00273659f, -0.02919352f, -0.05489063f, 
    0.04402631f, 0.03140060f, -0.02865710f, -0.06647030f, 0.02879039f, 0.01346269f, -0.01733736f, -0.01325043f, 
    -0.02125004f, -0.01840376f, 0.04032218f, 0.04502930f, 0.01461880f, -0.04978536f, 0.02905048f, 0.04939830f, 
    0.02324650f, -0.04683974f, 0.01890524f, -0.01153923f, 0.03904585f, 0.01267875f, -0.03960793f, -0.04334649f, 
    -0.02634090f, 0.00206336f, -0.04343663f, -0.05851710f, -0.03795179f, -0.04333888f, -0.05447949f, 0.01734344f, 
    -0.05535763f, -0.04100775f, 0.02383886f, -0.02101447f, 0.02588944f, 0.01167397f, 0.02143776f, 0.01472677f, 
    0.03790295f, -0.06026959f, 0.01378457f, -0.01537491f, 0.04235071f, -0.06530623f, -0.06460916f, -0.02655674f, 
    0.01705298f, -0.00716755f, 0.02354253f, -0.00071693f, 0.00416763f, -0.00870798f, -0.01416929f, -0.00944358f, 
    -0.01749013f, -0.00804653f, 0.02636785f, 0.01237062f, -0.05412532f, -0.00788069f, -0.04153273f, -0.03754163f, 
    -0.05759275f, 0.00261401f, -0.02493403f, -0.04079904f, -0.03769660f, -0.01011091f, 0.02004823f, -0.06617305f, 
    0.03046760f, 0.03621529f, 0.02768164f, -0.02166836f, 0.01287850f, 0.02138205f, 0.01015232f, -0.04212432f, 
    0.05127104f, 0.02121817f, -0.02196631f, 0.01696834f, -0.01622045f, 0.00397772f, -0.05376586f, -0.04028247f, 
    -0.00678396f, -0.00395598f, -0.00552413f, -0.04731691f, 0.03476762f, 0.04517163f, -0.04958915f, -0.03484964f, 
    0.02239314f, -0.00236172f, -0.03783153f, 0.03728533f, -0.05681865f, -0.01906078f, -0.04202220f, 0.01839546f, 
    0.00144407f, 0.00386161f, -0.04551153f, -0.04620307f, 0.04927079f, -0.02988149f, 0.00342988f, 0.04302748f, 
    0.01296348f, -0.03432554f, 0.01517620f, 0.03489264f, -0.00924777f, 0.04238103f, -0.01727184f, -0.06364165f, 
    0.00522634f, -0.01099811f, 0.02965838f, 0.02201501f, -0.04562394f, 0.00883284f, -0.04531518f, -0.03640632f, 
    -0.06227064f, -0.05734886f, 0.02081442f, -0.02232928f, 0.01415244f, -0.06004300f, -0.01685504f, -0.01799259f, 
    -0.04205177f, 0.02922859f, -0.03756738f, -0.02079567f, 0.04899283f, 0.03422190f, -0.05736512f, 0.00013387f, 
    -0.01660328f, 0.04499773f, 0.03301888f, 0.02773976f, 0.03605485f, -0.00589750f, -0.01233820f, -0.06676593f, 
    0.02501994f, 0.02413022f, 0.04246524f, -0.04936521f, 0.04001612f, 0.02881315f, -0.03200338f, -0.02423857f, 
    0.02073585f, -0.03491729f, 0.03360082f, 0.01253415f, -0.01977810f, 0.04205076f, -0.00299133f, -0.01148800f, 
    0.04327197f, 0.00075525f, -0.01690750f, -0.04774798f, -0.06103060f, -0.03623123f, -0.04385562f, -0.01900942f, 
    -0.00001209f, 0.00727073f, -0.01823184f, -0.03918339f, 0.05324424f, 0.02857029f, -0.05406589f, 0.01336634f, 
    0.00112397f, -0.01877216f, -0.05304520f, -0.03126539f, -0.05278344f, -0.00352669f, 0.04168423f, 0.00930363f, 
    0.02238783f, 0.00726497f, 0.04182967f, 0.03700462f, 0.01693949f, 0.02541226f, 0.02856859f, -0.04524961f, 
    -0.03883036f, 0.02951785f, -0.05891280f, -0.05537751f, 0.01971641f, 0.02810360f, -0.04744988f, -0.04097854f, 
    -0.03029487f, -0.00720760f, -0.02671971f, -0.05707818f, 0.01814231f, -0.01998748f, -0.03689554f, -0.05082517f, 
    -0.03577397f, -0.00722996f, -0.05116366f, 0.04406707f, 0.05283880f, 0.02548774f, 0.04539438f, -0.01773489f, 
    -0.01074724f, 0.03710368f, -0.06069853f, 0.04524434f, -0.03323195f, -0.03653194f, 0.01712178f, -0.06233671f, 
    0.05184010f, 0.03322171f, 0.00607307f, -0.00407872f, -0.04127826f, 0.00682310f, -0.02867944f, -0.06107810f, 
    0.04189207f, -0.03421130f, 0.02434462f, -0.00453751f, -0.01000306f, -0.00848625f, 0.03911414f, -0.02236262f, 
    0.00940185f, 0.00780379f, -0.00627494f, 0.03711930f, 0.00047526f, -0.04026042f, -0.04434820f, -0.01016739f, 
    -0.01818533f, -0.00711739f, 0.01525867f, 0.02989107f, 0.03590616f, 0.00018963f, 0.02465135f, -0.00615811f, 
    0.01023182f, -0.01813785f, 0.02409798f, -0.04357541f, -0.01171831f, -0.02279682f, 0.00784703f, 0.00889608f, 
    0.03230024f, 0.01775450f, 0.04621926f, -0.06942049f, -0.05527378f, 0.00785925f, -0.03007559f, 0.01307785f, 
    -0.02094251f, 0.01877273f, -0.04098744f, -0.05595919f, 0.00508478f, 0.00459498f, -0.05121956f, -0.00056801f, 
    -0.26404873f, 0.06422299f, 0.08104750f, 0.10602368f, 0.07490084f, 0.09902107f, 0.10939192f, 0.10291778f, 
    -0.03683270f, -0.15136690f, -0.03459929f, 0.28037712f, 0.13460153f, -0.00901829f, -0.08625387f, 0.16174354f, 
    0.05990650f, 0.11511394f, -0.26691583f, -0.14949410f, -0.33949491f, 0.09137485f, 0.02942544f, -0.04424492f, 
    0.01696284f, 0.10072111f, -0.02854739f, -0.02072925f, -0.33269790f, 0.14391595f, -0.00843573f, -0.05703967f, 
    0.11654996f, 0.10424986f, -0.11502939f, 0.00673520f, 0.16709144f, -0.03792665f, -0.17349946f, 0.02298364f, 
    -0.10487255f, -0.07821801f, -0.05045509f, 0.09243026f, 0.02360904f, -0.05394937f, -0.14012964f, 0.05409615f, 
    0.06254765f, -0.00342767f, 0.10301317f, 0.06292908f, 0.06964805f, 0.27838218f, 0.00260882f, 0.11857647f, 
    0.08116253f, -0.04270303f, -0.06662054f, 0.00047958f, -0.03771300f, 0.03900858f, -0.04694811f, -0.26626217f, 
    -0.22044753f, -0.37791395f, -0.05214470f, -0.08786201f, -0.25155056f, 0.09962410f, -0.09162910f, -0.01516914f, 
    -0.02456811f, 0.06776971f, 0.03569344f, 0.03544344f, 0.09102421f, -0.02603155f, 0.09788014f, -0.01261865f, 
    -0.10738768f, -0.24207592f, 0.12716167f, 0.08044050f, 0.04813476f, 0.01001897f, 0.05600569f, 0.02862492f, 
    0.16792938f, 0.05186949f, 0.07100428f, -0.01366348f, -0.01351007f, 0.02301135f, -0.03428847f, 0.01021983f, 
    0.09121098f, 0.09704408f, 0.13644974f, 0.02904989f, 0.13576771f, 0.00530600f, 0.03034206f, -0.02384888f, 
    -0.03182814f, -0.01974853f, 0.05379713f, -0.02569535f, 0.04134482f, 0.36657777f, -0.11547296f, -0.01949772f, 
    -0.05469965f, -0.22062394f, 0.01938135f, 0.04098122f, 0.00504975f, 0.08211873f, 0.13457482f, 0.04601613f, 
    -0.05988077f, -0.14424370f, -0.01871734f, -0.14001556f, 0.08606697f, 0.03923121f, 0.12944618f, 0.32951799f, 
    0.13303442f, 0.12658255f, -0.04953796f, -0.09544456f, 0.05061779f, 0.12226807f, -0.03276876f, 0.14891279f, 
    -0.01660021f, 0.15032642f, -0.04649612f, -0.03498032f, 0.05877819f, -0.02454270f, -0.03822919f, 0.07269277f, 
    0.16375537f, -0.00401323f, -0.05359551f, 0.11377662f, 0.06863797f, 0.07890435f, 0.05747817f, -0.09731841f, 
    0.03387879f, 0.01099105f, 0.03917652f, 0.23135124f, 0.00053107f, -0.08074517f, -0.11051855f, 0.00155817f, 
    0.01846001f, -0.09106640f, 0.31121942f, -0.06669251f, -0.12152340f, 0.03284687f, -0.09769618f, -0.04895259f, 
    0.00582669f, -0.00638473f, 0.00480184f, -0.27023050f, -0.12357553f, -0.33258310f, 0.12409918f, -0.01260923f, 
    -0.01362540f, 0.04132423f, 0.08790135f, -0.03449361f, 0.17122948f, 0.01961253f, -0.28967562f, 0.06091207f, 
    -0.01954601f, -0.06431098f, -0.04559284f, 0.05210824f, 0.05908672f, -0.06455663f, -0.00029234f, -0.17367060f, 
    0.02583875f, -0.10563140f, -0.12542728f, -0.00506958f, -0.02596861f, 0.08993015f, 0.11184563f, 0.12839450f, 
    -0.25538495f, -0.18961471f, -0.21498781f, 0.06577955f, 0.17964107f, -0.01324993f, 0.05287462f, 0.24967510f, 
    0.02895666f, 0.09126463f, -0.14015986f, 0.10695445f, 0.00948945f, -0.00698105f, 0.07373139f, 0.04930151f, 
    -0.15499374f, -0.16276103f, 0.29473799f, -0.02571937f, -0.03301887f, 0.09287427f, -0.04640284f, -0.04101404f, 
    0.09299242f, -0.33990917f, -0.05187306f, -0.51979780f, 0.10370625f, -0.08874022f, -0.06989385f, 0.03290666f, 
    -0.02863772f, 0.12536444f, -0.27175462f, 0.03304203f, -0.05204518f, -0.06129221f, -0.03621832f, 0.01317074f, 
    0.06401872f, -0.14789870f, -0.09739629f, -0.02826679f, 0.06798092f, -0.66246903f, 0.08119275f, 0.08808608f, 
    0.01364745f, -0.02368108f, -0.18975982f, -0.01432020f, 0.24217425f, 0.19794370f, 0.08754314f, -0.03933052f, 
    0.04621344f, -0.00168117f, 0.05221827f, 0.04700048f, -0.12115461f, -0.18719703f, 0.00180202f, 0.46786201f, 
    -0.13784222f, 0.07387453f, -0.11163252f, -0.10104977f, 0.14756832f, 0.12432393f, -0.05476101f, -0.07195300f, 
    0.14400002f, -0.01280236f, -0.01746899f, -0.02770802f, -0.03546723f, -0.00896915f, -0.06131894f, -0.23879303f, 
    0.01985135f, -0.06502343f, 0.01363560f, 0.01439022f, -0.02813980f, -0.00923404f, 0.07398538f, -0.11979894f, 
    0.01636752f, 0.03907193f, -0.00880850f, 0.02048588f, -0.03963005f, 0.01717447f, -0.02263700f, -0.04375113f, 
    0.02214201f, 0.03106803f, -0.02927447f, 0.02331736f, -0.02765599f, -0.03562385f, -0.01474664f, -0.03060164f, 
    0.02331291f, -0.02102624f, 0.01591463f, -0.04211148f, -0.02686079f, -0.05685773f, -0.03205442f, -0.06398904f, 
    -0.04392479f, -0.04731325f, -0.00800669f, 0.00123517f, 0.02793835f, -0.02627771f, 0.02207592f, -0.01406721f, 
    0.02808989f, -0.02647756f, -0.05603259f, -0.01737507f, 0.00680044f, -0.01099660f, 0.04588932f, 0.05456312f, 
    0.03611713f, 0.02840426f, 0.04054759f, -0.01269047f, -0.00269771f, 0.04174272f, 0.00730015f, -0.04406783f, 
    -0.02485957f, -0.04207912f, -0.00156223f, -0.06687281f, 0.03902999f, -0.03277726f, -0.05860702f, 0.05802379f, 
    -0.03739147f, 0.04399616f, -0.00959726f, -0.00775171f, -0.04334778f, 0.01245839f, -0.05720885f, -0.02801508f, 
    -0.01241729f, 0.04170066f, -0.03669842f, 0.02792758f, 0.00044146f, 0.00095405f, 0.00696686f, 0.01981092f, 
    0.04537002f, -0.02299430f, -0.05248666f, 0.04192233f, -0.03235417f, -0.01482125f, -0.02546880f, -0.05242167f, 
    -0.03597608f, -0.01171412f, -0.06989832f, -0.05900237f, 0.03127298f, -0.03938377f, -0.03223032f, -0.05184777f, 
    -0.02254732f, 0.03835358f, 0.03650380f, -0.03162392f, 0.02535167f, 0.05134915f, -0.00481270f, -0.04780049f, 
    -0.00266689f, -0.04360131f, -0.02036279f, -0.02733739f, -0.01739692f, -0.04231139f, -0.04691596f, -0.01124614f, 
    -0.00345582f, 0.03529141f, -0.02834592f, 0.04069919f, -0.00307039f, 0.01924239f, -0.04621621f, 0.01580302f, 
    -0.00947923f, -0.04151357f, 0.03453401f, -0.01214894f, 0.02625361f, 0.00867076f, 0.02160225f, -0.00026847f, 
    -0.06255692f, -0.04476551f, 0.05042405f, -0.00220695f, -0.04867000f, -0.02330401f, 0.02814220f, 0.03259290f, 
    0.02660312f, 0.01489497f, -0.01256252f, 0.01462705f, -0.05041768f, -0.04930291f, 0.04324953f, 0.05710739f, 
    0.00407799f, 0.02531788f, 0.04898464f, 0.02421101f, -0.06088905f, -0.04217584f, -0.04390230f, -0.05278999f, 
    -0.04500187f, -0.02970261f, -0.05210757f, -0.00752514f, 0.05135386f, 0.03255519f, 0.03016513f, -0.04397836f, 
    -0.05413586f, -0.02183927f, 0.06658726f, 0.03442368f, 0.03095086f, 0.04708835f, -0.04656020f, 0.00232421f, 
    0.03423105f, 0.00736750f, 0.01224842f, -0.03583819f, -0.01777199f, -0.02472393f, -0.06115514f, 0.02477220f, 
    -0.00215340f, -0.04120565f, -0.03980223f, 0.00351065f, 0.00438365f, 0.02489036f, 0.04782943f, 0.05823074f, 
    0.01239784f, -0.03949857f, -0.06202630f, 0.00451812f, -0.05715849f, 0.00948395f, -0.05222473f, -0.05697654f, 
    0.02839359f, -0.01666238f, 0.01074338f, -0.01754651f, 0.02756305f, 0.04985936f, 0.05091164f, -0.04300654f, 
    -0.02391379f, -0.01938171f, -0.05165787f, -0.00209669f, 0.05033844f, -0.01363794f, -0.04650140f, -0.04799600f, 
    -0.00673061f, -0.04952500f, 0.04259268f, 0.01236894f, 0.00355752f, -0.00367211f, 0.01835352f, -0.01655941f, 
    -0.01751925f, 0.05480462f, 0.04431095f, 0.02729137f, -0.02143856f, 0.01251568f, 0.02989285f, -0.06253486f, 
    0.04029689f, 0.03575588f, 0.04307416f, -0.02227231f, -0.04794003f, -0.05030302f, -0.01236153f, -0.05762823f, 
    -0.06077012f, -0.04384599f, 0.05619304f, 0.02717522f, 0.00889443f, -0.04938986f, -0.01295573f, -0.01337303f, 
    -0.06220926f, -0.01736648f, 0.00130500f, 0.01174670f, -0.05615171f, 0.01585522f, 0.04618471f, 0.05556564f, 
    0.01347931f, 0.01568112f, 0.02824166f, -0.03982312f, 0.04249302f, 0.00885047f, -0.00967823f, -0.03663841f, 
    0.00906948f, -0.02290205f, 0.02599530f, 0.03745545f, -0.02067889f, 0.03923108f, 0.04119429f, -0.00379469f, 
    -0.00919082f, -0.00264810f, 0.00299370f, 0.01464655f, -0.02595018f, -0.01931724f, 0.02536149f, 0.00624311f, 
    0.02292212f, -0.02493464f, -0.03740955f, 0.02101435f, -0.04092158f, -0.04666043f, 0.00269519f, 0.00578079f, 
    -0.01514060f, 0.04656855f, -0.01177042f, -0.05422663f, -0.04895248f, 0.01885775f, -0.05198021f, 0.03194281f, 
    0.05502562f, 0.00769483f, 0.01833695f, -0.02821496f, 0.03818283f, 0.04991877f, -0.03378885f, -0.02604566f, 
    -0.12133685f, 0.01048956f, -0.26149678f, 0.06529742f, 0.07261546f, 0.09800392f, -0.14312443f, 0.04204722f, 
    -0.03629894f, -0.28725618f, -0.07486617f, -0.09266491f, 0.01885883f, 0.04763734f, 0.14231832f, -0.04668986f, 
    0.15745902f, 0.01353712f, 0.01735889f, -0.06550402f, -0.17071541f, -0.02772939f, 0.03731457f, 0.10651725f, 
    -0.00911486f, 0.07031403f, 0.06795649f, 0.24171002f, -0.12042318f, 0.03453522f, -0.12141279f, -0.00432262f, 
    0.04793332f, 0.06043154f, 0.11485406f, 0.07942677f, -0.17809449f, -0.09550580f, -0.01529691f, 0.07762562f, 
    0.12303454f, -0.03333541f, 0.02675281f, 0.09404542f, -0.01218833f, -0.35224631f, -0.05262857f, 0.00767690f, 
    -0.09743608f, 0.16259289f, 0.19302377f, -0.18846689f, -0.24656998f, -0.08733276f, 0.21228446f, -0.04118482f, 
    -0.04410946f, 0.02090870f, -0.03637115f, 0.00472736f, 0.08785123f, -0.05619887f, -0.09144094f, 0.10625783f, 
    -0.29003426f, -0.11944195f, 0.00488397f, 0.08311195f, 0.00297054f, -0.20771649f, -0.06608123f, -0.16220927f, 
    -0.49377078f, -0.13334969f, 0.03144269f, 0.11846852f, 0.09642456f, -0.04915613f, -0.17360885f, -0.00695643f, 
    -0.05487224f, -0.09866598f, 0.14240551f, -0.14094019f, 0.10805985f, 0.10690632f, 0.02691555f, -0.09518858f, 
    -0.08262105f, -0.00308438f, -0.14994675f, 0.07080302f, -0.00656336f, 0.11014801f, 0.10827854f, -0.02217132f, 
    0.02045207f, 0.11032447f, 0.08596193f, -0.36455718f, 0.05147297f, -0.11803430f, 0.15934244f, -0.00478853f, 
    0.03236675f, -0.15775795f, -0.03648960f, 0.03673188f, -0.14950192f, -0.27882835f, -0.09093057f, -0.15433918f, 
    -0.12548791f, 0.01990892f, 0.09400996f, 0.08243513f, -0.03209346f, 0.07412508f, 0.22220673f, 0.05126532f, 
    0.10249737f, 0.02485152f, -0.04284638f, -0.06311303f, 0.16835956f, 0.02145394f, -0.02131083f, -0.02439204f, 
    -0.14736059f, 0.08762962f, -0.00704576f, 0.05128423f, 0.08238463f, -0.02596546f, 0.04177168f, 0.07639364f, 
    0.11244885f, 0.05143518f, -0.02166791f, 0.10099939f, 0.02335212f, 0.14868426f, 0.00777894f, 0.07715665f, 
    -0.00434580f, 0.09008415f, 0.11179221f, 0.02867851f, 0.06139460f, 0.11356699f, 0.02562536f, -0.05529282f, 
    -0.06896665f, -0.31862667f, -0.28081885f, -0.05216359f, 0.08339362f, -0.06631960f, 0.05908490f, 0.05482265f, 
    -0.04030039f, -0.13504709f, -0.30436420f, -0.12383742f, -0.05950100f, 0.02899506f, 0.06709567f, 0.01254919f, 
    -0.09057231f, -0.07921241f, 0.04045241f, 0.22566815f, 0.13021022f, 0.03297412f, 0.07226364f, 0.06225813f, 
    0.16382301f, -0.13436997f, -0.01195779f, 0.06898866f, 0.04198305f, 0.14760697f, -0.13231759f, 0.00726699f, 
    0.04417541f, 0.20746045f, -0.02135161f, -0.00740042f, -0.01865114f, -0.07086179f, 0.20313740f, 0.05621970f, 
    -0.07811365f, -0.12101151f, 0.00411520f, -0.05681860f, 0.01876498f, -0.00600043f, -0.40481710f, -0.08291721f, 
    -0.05126736f, -0.09516617f, 0.11733689f, -0.16521901f, 0.11499738f, -0.05309063f, 0.05026295f, 0.12131154f, 
    0.26468107f, -0.11044223f, 0.02415835f, -0.02193603f, 0.06019219f, -0.01860412f, -0.02743142f, 0.01404271f, 
    0.39172086f, -0.05785900f, 0.03812040f, -0.11356153f, 0.17253125f, -0.08070581f, 0.05531070f, -0.00947787f, 
    0.01410637f, -0.04759350f, -0.01155160f, -0.15657204f, 0.00349351f, 0.04568650f, 0.00598966f, -0.06990351f, 
    0.11659613f, 0.16403753f, -0.07640620f, 0.19164558f, -0.08530590f, -0.07048716f, -0.22476009f, -0.16391627f, 
    0.07403735f, 0.08692472f, -0.05966979f, -0.19263026f, -0.11553817f, -0.04902816f, 0.10197479f, 0.02641180f, 
    0.03917225f, 0.14161254f, -0.01261774f, -0.15081726f, -0.14014980f, 0.15402497f, 0.12370927f, 0.02911013f, 
    0.03295785f, -0.05172030f, -0.05053355f, 0.04805440f, 0.03253734f, 0.15340556f, -0.06629398f, 0.06017692f, 
    -0.04921670f, -0.04908914f, -0.01135118f, -0.00165642f, 0.06157233f, 0.08298682f, 0.33481076f, -0.07813833f, 
    -0.08548456f, -0.05616720f, 0.06500675f, -0.03509775f, 0.16040513f, 0.21811567f, -0.12347794f, 0.03231341f, 
    -0.04874963f, 0.10874406f, 0.05421700f, 0.05802229f, -0.00569142f, 0.07146098f, 0.20676157f, -0.10960006f, 
    0.05881648f, -0.04537412f, -0.13046908f, -0.01423800f, -0.02109107f, -0.00988879f, 0.01804859f, -0.09601482f, 
    0.05893801f, 0.12353081f, 0.07090160f, 0.23640373f, 0.21985343f, 0.12714559f, -0.00863175f, -0.10830396f, 
    -0.04309472f, 0.06523358f, -0.01073018f, -0.09975274f, -0.00213005f, 0.00280021f, -0.07872727f, -0.08341338f, 
    0.04940591f, 0.07040054f, 0.02093122f, -0.18150066f, 0.03857355f, 0.13535532f, -0.07103997f, -0.03070974f, 
    0.04485972f, 0.09420568f, 0.04888476f, 0.14249420f, 0.19346029f, 0.18742740f, 0.11896565f, 0.06563465f, 
    -0.01946840f, 0.12628867f, 0.07433366f, 0.06986093f, -0.13035721f, 0.04973613f, 0.04884925f, 0.09845328f, 
    -0.00553139f, -0.08544964f, 0.12954202f, -0.02878400f, 0.04219867f, -0.05130074f, -0.21485791f, -0.01679293f, 
    0.06144565f, 0.04927767f, 0.08317501f, -0.03381026f, -0.07370536f, 0.05399411f, -0.03072045f, 0.03677065f, 
    0.25151512f, 0.11331695f, -0.06852215f, 0.08008125f, -0.02515615f, -0.07070697f, -0.05716289f, 0.16243376f, 
    0.23413213f, 0.06139675f, -0.23759021f, -0.03672810f, 0.00049707f, 0.01180374f, -0.05261420f, 0.02895074f, 
    -0.05116876f, 0.07594823f, -0.05508118f, -0.01241804f, -0.06055154f, 0.08462489f, 0.18455946f, 0.05206630f, 
    -0.01378321f, -0.26501969f, 0.04226134f, 0.04128489f, -0.04691355f, -0.12298273f, -0.00340571f, -0.18755509f, 
    -0.09015322f, 0.04329311f, -0.01062719f, -0.16964096f, -0.01362907f, 0.03266995f, -0.03085938f, 0.00707045f, 
    0.01733144f, -0.00430090f, 0.03116246f, 0.10399242f, -0.39708066f, 0.15715198f, 0.19234246f, 0.05537828f, 
    -0.05277780f, 0.00323860f, 0.13850901f, 0.17578460f, 0.04077360f, 0.12471694f, 0.09162891f, 0.06362957f, 
    -0.01906600f, 0.03068627f, 0.12075296f, 0.05856711f, -0.10249332f, -0.14340428f, -0.20183210f, 0.10570918f, 
    -0.07063688f, 0.13253029f, 0.02939454f, -0.05004847f, 0.04166538f, 0.02581758f, -0.14092243f, 0.36000696f, 
    0.18075228f, -0.15419896f, 0.10460521f, 0.05637338f, 0.03993429f, 0.15556407f, -0.00725872f, -0.00395316f, 
    0.13130136f, 0.20893380f, 0.09205268f, -0.25146776f, 0.04904805f, -0.16162768f, -0.11089889f, 0.02892617f, 
    -0.02343563f, -0.22628261f, 0.07180580f, 0.02309770f, -0.14536524f, 0.07057514f, -0.07069676f, 0.01026573f, 
    -0.07883108f, 0.08145510f, -0.07453002f, -0.07850029f, -0.03353691f, 0.11314586f, 0.05695351f, 0.10122769f, 
    0.09747455f, -0.04945645f, -0.13871698f, 0.01070033f, 0.07787155f, -0.01385495f, 0.04385784f, 0.03925455f, 
    -0.08643843f, -0.28009313f, -0.00691717f, -0.02824784f, -0.00258698f, 0.00703695f, 0.03584327f, 0.09742482f, 
    0.05678969f, -0.03892416f, -0.09841616f, -0.03296813f, 0.02229107f, 0.26877883f, -0.13652825f, -0.22174670f, 
    -0.06268071f, -0.12239233f, -0.08131912f, 0.08197845f, 0.11873757f, 0.00566525f, 0.03873619f, 0.01974614f, 
    -0.23478290f, 0.07683671f, -0.06958517f, 0.06712735f, 0.13646856f, 0.15305054f, -0.06322938f, 0.24703941f, 
    0.01630605f, -0.00838024f, -0.05995302f, 0.08092299f, -0.07209560f, 0.05614864f, -0.05432396f, -0.11956296f, 
    -0.12016716f, 0.20653465f, 0.10735512f, -0.09964289f, -0.05161085f, 0.03586123f, 0.09192211f, -0.00542174f, 
    -0.02744193f, -0.03966482f, 0.13595767f, -0.01586594f, -0.09362847f, -0.10849366f, -0.02871732f, -0.04578233f, 
    0.08027102f, 0.09834205f, 0.05506152f, -0.02528930f, 0.04832600f, -0.05305574f, -0.03171650f, 0.01247890f, 
    -0.07591829f, 0.10768931f, -0.12021066f, -0.12762663f, -0.09230334f, -0.08719549f, -0.00460462f, 0.10464228f, 
    -0.06516336f, 0.06705859f, -0.14921550f, -0.07881009f, -0.17602709f, 0.06285462f, -0.10610476f, 0.00329351f, 
    0.04808927f, -0.08917046f, -0.11577044f, 0.07504473f, -0.07968152f, 0.12799448f, -0.18756579f, 0.08257154f, 
    0.03491361f, 0.15381882f, -0.05175231f, -0.03643871f, -0.18670782f, 0.10511388f, -0.05896092f, 0.22290760f, 
    0.19785737f, -0.02426283f, 0.00487311f, 0.14459477f, -0.04867456f, 0.02255716f, 0.05660299f, 0.09769663f, 
    -0.07193440f, 0.22228545f, -0.09457052f, 0.02369124f, 0.07923874f, -0.12984557f, -0.06725339f, -0.04679730f, 
    0.32309067f, 0.06910027f, 0.05007195f, 0.09614522f, -0.02001071f, -0.01761769f, 0.04642264f, -0.11987082f, 
    0.04112382f, 0.07299433f, 0.20313011f, -0.08457652f, 0.02787605f, -0.07686439f, -0.05019131f, -0.09256842f, 
    -0.10696473f, -0.12724504f, -0.53671062f, -0.14517072f, 0.04060483f, 0.01371594f, 0.02934152f, 0.10530123f, 
    -0.05796395f, -0.03290705f, -0.01906973f, -0.17647615f, 0.09611424f, -0.03437983f, 0.10550276f, -0.10506887f, 
    -0.03382383f, -0.08260546f, 0.00113719f, -0.03781303f, -0.06750515f, -0.05497131f, -0.03761326f, 0.11704858f, 
    -0.09400367f, -0.12638378f, 0.08849271f, -0.04723428f, 0.07495040f, 0.07617176f, -0.13660040f, -0.07891546f, 
    0.12187944f, 0.16794443f, 0.15844722f, 0.04492040f, -0.08410610f, 0.12260052f, 0.01021549f, 0.33296898f, 
    -0.12552254f, 0.12172827f, -0.05145876f, 0.01341469f, 0.02169808f, -0.05631980f, -0.22126354f, -0.13684569f, 
    -0.02844656f, -0.09622989f, 0.08325439f, -0.01647756f, 0.02853087f, -0.12810443f, -0.04007808f, -0.08444628f, 
    0.01003184f, 0.11961757f, 0.07453317f, 0.06087984f, 0.01807461f, -0.01752971f, 0.03572196f, 0.02306312f, 
    -0.02741260f, 0.11476878f, 0.04840884f, 0.00517358f, 0.15461545f, 0.08670802f, -0.26001391f, -0.06467205f, 
    0.04392913f, 0.02504488f, -0.05689545f, 0.11586864f, 0.06921946f, 0.06192980f, -0.01376215f, 0.10674432f, 
    0.14447747f, 0.09350757f, 0.23850016f, 0.32000750f, 0.09814885f, -0.00457990f, 0.06382746f, -0.04437458f, 
    -0.05087977f, 0.02551048f, -0.00872120f, 0.01264855f, 0.22864799f, 0.05197542f, 0.01937408f, 0.16287622f, 
    -0.07454208f, 0.00391094f, 0.00602711f, -0.06902923f, 0.10328929f, 0.05903354f, 0.20392177f, -0.06986919f, 
    -0.05343968f, 0.10363275f, -0.09458806f, -0.03766272f, -0.02296660f, 0.08396211f, 0.02252832f, -0.01413487f, 
    0.00317075f, 0.04359024f, 0.07844047f, -0.01432296f, 0.14956766f, 0.08293367f, 0.03939813f, -0.37070477f, 
    -0.25076196f, 0.00270310f, -0.05495317f, -0.03383660f, -0.17681311f, 0.08194616f, 0.02369727f, -0.00253920f, 
    0.29611450f, 0.01032038f, 0.11251114f, 0.11636568f, -0.05667365f, 0.00240947f, -0.03154372f, 0.14339669f, 
    -0.03324938f, 0.21685642f, 0.17096178f, 0.12902062f, 0.16573127f, 0.07782488f, -0.13701890f, -0.06378904f, 
    -0.00978459f, -0.06398822f, 0.21165122f, 0.30096871f, 0.01869849f, -0.00157425f, -0.04421373f, 0.03638496f, 
    -0.06598817f, 0.10948104f, 0.04056810f, 0.12442117f, 0.00170264f, -0.45714530f, 0.10258558f, 0.10051596f, 
    0.20012243f, -0.00697251f, -0.04638853f, -0.11977468f, 0.10252959f, 0.05969789f, -0.40314153f, 0.09453630f, 
    -0.02148094f, 0.08142290f, 0.03940931f, -0.02286846f, 0.01954079f, -0.10722967f, -0.12335996f, -0.29326224f, 
    -0.10675518f, 0.17911592f, 0.22282703f, 0.14175932f, -0.04844809f, -0.06648085f, -0.03656423f, -0.18969172f, 
    0.10997224f, -0.00517066f, -0.04139741f, 0.04132910f, -0.04615436f, -0.02390470f, 0.05076604f, -0.19200531f, 
    -0.02987871f, 0.01527147f, -0.09596564f, 0.12574479f, 0.01583628f, 0.09729227f, -0.14553611f, 0.00703685f, 
    -0.18806031f, -0.16636263f, -0.09417118f, -0.10447033f, 0.10761323f, 0.11648767f, -0.07986081f, 0.01597831f, 
    -0.15285391f, -0.50866735f, -0.20471641f, -0.00271614f, 0.03519798f, 0.05294257f, 0.08719610f, 0.05024518f, 
    -0.03375227f, 0.05587293f, -0.06924748f, -0.01596074f, -0.14571647f, 0.07447217f, -0.00461147f, 0.05901995f, 
    -0.08450352f, 0.12713045f, -0.06524391f, 0.17294152f, 0.16655780f, -0.06236204f, 0.07913103f, -0.05007381f, 
    0.10604473f, -0.11694103f, -0.10163306f, 0.12167475f, 0.23665574f, 0.06049854f, 0.14904834f, 0.02960943f, 
    0.06828207f, 0.03384563f, 0.13761564f, 0.13444595f, 0.06945815f, -0.17502865f, 0.22705463f, -0.09327028f, 
    0.00330019f, 0.06393363f, 0.07819246f, -0.02972287f, -0.00764793f, 0.00007789f, -0.23005429f, -0.32447794f, 
    -0.25435182f, 0.04933141f, -0.04869692f, -0.03013324f, 0.02737511f, 0.02223252f, -0.18688881f, 0.02849603f, 
    -0.02209054f, -0.14876077f, -0.04914284f, 0.26088983f, 0.06479750f, 0.03510552f, 0.05098940f, -0.05072800f, 
    -0.01484583f, -0.04135907f, -0.03315965f, -0.06126777f, 0.04421538f, -0.05728573f, -0.02884455f, -0.00238973f, 
    0.01864461f, -0.04949898f, 0.00006303f, -0.00377313f, 0.02300639f, -0.04904999f, -0.03257059f, -0.05498805f, 
    -0.02108954f, -0.06285829f, 0.02239123f, 0.02290430f, 0.01902468f, -0.03647564f, 0.02482070f, 0.01457852f, 
    0.02779764f, -0.03914898f, 0.04997005f, -0.05405994f, -0.05751831f, -0.02737376f, -0.01306733f, -0.03596994f, 
    0.04698021f, -0.02921844f, 0.01994065f, 0.01974704f, 0.04641252f, -0.05548456f, -0.00395781f, -0.05063958f, 
    -0.00174141f, -0.06432199f, 0.00672355f, 0.05186973f, 0.01165031f, -0.03239611f, 0.02318686f, -0.01282390f, 
    0.00960462f, -0.03660699f, -0.01931415f, 0.04392952f, -0.02922661f, 0.03930370f, 0.03446276f, -0.04969786f, 
    -0.06390009f, -0.02950557f, -0.02533211f, 0.02938729f, 0.03022207f, -0.05038759f, -0.04180255f, 0.04790033f, 
    -0.06069730f, -0.06106691f, -0.05582811f, -0.03985017f, -0.05032733f, -0.06032673f, 0.01109486f, -0.02508892f, 
    0.01520036f, -0.00371202f, 0.04906619f, -0.04010259f, 0.04062850f, 0.00783398f, 0.01356172f, -0.01304053f, 
    0.03836141f, -0.06383345f, 0.04944060f, -0.01754661f, -0.01981794f, -0.00152359f, -0.02100586f, -0.05324271f, 
    -0.05785035f, -0.03706685f, -0.04278872f, -0.05603189f, -0.05233741f, 0.03880259f, 0.04978224f, 0.01750584f, 
    -0.02294363f, 0.03409830f, 0.05242249f, 0.02667130f, -0.01529781f, 0.05263148f, -0.05305482f, -0.03734742f, 
    -0.04868400f, -0.00011147f, -0.02397402f, 0.00800202f, -0.00723915f, -0.05484306f, -0.03312430f, 0.03318063f, 
    0.00455297f, -0.02931486f, 0.01496763f, 0.00846938f, 0.03409705f, -0.00154940f, 0.03225882f, 0.01743247f, 
    -0.01491861f, 0.01871003f, 0.04720721f, 0.04946910f, 0.03947742f, 0.00796329f, -0.01785698f, 0.00130476f, 
    0.03081516f, -0.00415932f, 0.04985525f, -0.03056844f, 0.04015774f, -0.04700134f, -0.02081085f, -0.02013670f, 
    0.03552153f, -0.05529926f, 0.00532221f, -0.06396744f, 0.05207007f, -0.00895019f, 0.02547979f, -0.01520740f, 
    0.04637069f, 0.03042145f, -0.01514084f, -0.01865645f, -0.01403997f, -0.05632683f, -0.05452995f, -0.01537399f, 
    -0.00411152f, 0.01864844f, -0.00139562f, -0.04309973f, -0.03349635f, -0.05931671f, 0.00813839f, 0.01069470f, 
    -0.01181788f, -0.03300208f, -0.00516480f, 0.00723522f, 0.01718893f, -0.02294327f, -0.03989254f, -0.01958823f, 
    -0.02011904f, -0.04991608f, -0.04158172f, -0.05842172f, -0.00566280f, -0.04478178f, 0.03551368f, -0.05814337f, 
    -0.02057660f, -0.03905186f, -0.05773300f, -0.05544769f, 0.04979581f, -0.01549180f, 0.02234646f, 0.03661043f, 
    -0.04679972f, 0.01611302f, -0.01285463f, 0.02276377f, -0.04923994f, 0.02442381f, -0.03261645f, -0.01006594f, 
    -0.00342978f, -0.05194045f, 0.03961412f, -0.01200393f, 0.03050869f, -0.02196040f, 0.03119285f, -0.04744241f, 
    -0.01350718f, 0.04158179f, 0.01851869f, 0.04217879f, -0.05919706f, 0.02650183f, -0.03996691f, 0.02410742f, 
    -0.01427195f, 0.01859736f, -0.03525453f, -0.01346685f, -0.02130774f, -0.02458076f, 0.02908353f, 0.00811198f, 
    0.01852712f, -0.02683762f, 0.04749883f, 0.04108751f, 0.03213105f, 0.04684535f, -0.04391140f, 0.03234336f, 
    -0.04110382f, 0.04403190f, -0.05960523f, -0.05412094f, 0.03675493f, -0.03174596f, 0.01850082f, -0.04333526f, 
    -0.05326534f, 0.01571445f, -0.01869790f, -0.01021591f, 0.02896699f, 0.01567252f, 0.04070280f, -0.05197359f, 
    0.02198550f, 0.00296013f, -0.05670030f, -0.04756659f, -0.02855844f, -0.00145619f, -0.01459496f, -0.03566582f, 
    -0.05139836f, -0.02171915f, -0.05053553f, 0.05106012f, -0.05046029f, -0.03410038f, -0.00948161f, -0.02206873f, 
    -0.01574066f, -0.05445784f, -0.01660699f, 0.01311911f, -0.00301228f, -0.04344064f, 0.02583824f, -0.02164358f, 
    -0.03791419f, 0.04164605f, -0.05647014f, -0.02624035f, -0.01450878f, -0.01662552f, -0.05529376f, -0.01008255f, 
    -0.03877676f, -0.02888824f, 0.03341418f, 0.05101912f, 0.01947990f, 0.04219299f, 0.00620812f, 0.02652848f, 
    0.02552616f, -0.03120819f, 0.01976779f, -0.02653183f, -0.01583847f, -0.00566160f, -0.01978821f, -0.04799889f, 
    -0.00576159f, -0.57702935f, 0.13388675f, 0.16400744f, 0.02633901f, 0.03345848f, 0.15149684f, -0.05264169f, 
    0.07733107f, -0.19029567f, -0.05530376f, -0.01389170f, 0.01303263f, -0.02636866f, -0.06064038f, -0.10671645f, 
    0.05518186f, 0.10229861f, 0.45328218f, -0.15747210f, 0.01351503f, -0.10689399f, -0.12246340f, -0.08817457f, 
    -0.13197255f, 0.04845599f, -0.08254146f, 0.14753889f, -0.01539093f, 0.02447153f, 0.08519254f, 0.06850456f, 
    0.08778435f, -0.00249408f, -0.11094159f, 0.01782388f, -0.39308000f, -0.12092023f, 0.01996116f, 0.08883639f, 
    0.09058896f, 0.09544637f, -0.10098333f, 0.13038664f, 0.21008161f, -0.43122888f, 0.02812262f, -0.02676733f, 
    -0.04963381f, 0.03608641f, 0.10989427f, 0.07289619f, 0.00968920f, 0.05426836f, 0.10540030f, -0.03740271f, 
    -0.26975384f, -0.12404692f, 0.11742324f, -0.11789460f, -0.00145251f, 0.11942171f, 0.08337577f, 0.38683680f, 
    -0.28858313f, -0.14015621f, 0.06203114f, 0.00544987f, 0.06771359f, 0.04504776f, -0.01358225f, 0.10353561f, 
    -0.15879773f, -0.27298525f, 0.03444789f, -0.06611876f, 0.17404249f, 0.01148204f, 0.03216781f, -0.02396681f, 
    -0.00756400f, -0.08502397f, -0.08318099f, 0.19872576f, 0.01124163f, -0.11232391f, -0.02935727f, -0.09475731f, 
    -0.02753568f, -0.00882015f, 0.01217206f, -0.12110329f, 0.09840546f, 0.04022452f, 0.23994732f, 0.10338726f, 
    0.02796763f, -0.06157179f, -0.03070652f, -0.26842368f, -0.55907959f, 0.05733394f, 0.02500224f, 0.06980264f, 
    0.06395756f, -0.00645508f, 0.03502890f, -0.03729943f, 0.18618350f, -0.37785497f, -0.00840453f, 0.06835684f, 
    -0.01566089f, -0.07710240f, 0.01687596f, 0.13141604f, -0.04022244f, 0.24454911f, 0.17652573f, -0.07263775f, 
    0.02780798f, 0.16228122f, 0.02428100f, -0.08231729f, 0.02664858f, 0.15024939f, -0.09216391f, -0.11947072f, 
    -0.05746461f, 0.04969759f, 0.12390282f, 0.16034003f, 0.04871625f, -0.00993389f, -0.15263939f, -0.09581224f, 
    0.07394429f, 0.05652043f, -0.10123812f, 0.03456524f, 0.00588466f, 0.22064748f, 0.02398212f, -0.00117833f, 
    -0.15373324f, 0.06726445f, -0.09823833f, 0.01499004f, 0.09401076f, 0.09276391f, 0.13638268f, 0.08390991f, 
    -0.04562288f, 0.13075036f, -0.08589981f, -0.11616057f, -0.16430183f, -0.10503759f, 0.00783425f, -0.01878431f, 
    0.20391379f, -0.02728676f, -0.10408775f, -0.55480975f, -0.07353038f, -0.15934587f, -0.04824010f, 0.01410559f, 
    -0.12426374f, 0.13306770f, -0.02915979f, 0.31159738f, 0.27510688f, -0.10103160f, 0.13455704f, 0.19040646f, 
    -0.05709058f, 0.18425210f, -0.03303835f, 0.11274275f, 0.03376416f, 0.10881200f, 0.01649645f, 0.02630110f, 
    0.05960435f, -0.05258619f, -0.03605615f, 0.01204913f, 0.01956992f, 0.13068733f, 0.07717678f, 0.12616828f, 
    0.11347612f, 0.07142315f, -0.13270077f, 0.03783924f, -0.13325402f, -0.00420211f, -0.12097912f, 0.07438839f, 
    -0.11236201f, 0.08554113f, -0.09873699f, -0.00487948f, 0.07363810f, -0.00286098f, 0.06805890f, -0.09243008f, 
    -0.14723545f, -0.01945919f, -0.04427099f, 0.04138521f, 0.06821459f, -0.03726498f, 0.11177909f, 0.06032019f, 
    0.00485331f, 0.05475859f, -0.00952845f, 0.04953717f, 0.05970112f, 0.05899209f, 0.06361752f, -0.06171378f, 
    0.10384396f, 0.47845930f, -0.24775696f, -0.01786239f, 0.08732212f, -0.17273186f, -0.04321341f, -0.00545778f, 
    -0.02445774f, -0.09842826f, -0.29763633f, 0.05375331f, 0.03206503f, 0.06920920f, 0.04622347f, -0.09216084f, 
    0.04330042f, 0.00193518f, -0.05659335f, -0.09079261f, 0.05396623f, -0.06578434f, -0.22667792f, -0.07835144f, 
    -0.12404875f, 0.03267870f, -0.05165125f, -0.03171921f, 0.00390289f, -0.19039798f, 0.03336819f, 0.13963285f, 
    0.05760445f, 0.11940496f, -0.11629035f, -0.00335950f, -0.03366449f, 0.05223478f, 0.05122337f, -0.22589433f, 
    -0.00068309f, -0.02751944f, -0.04327832f, -0.04821440f, -0.03807735f, 0.00851285f, -0.13034146f, -0.01178586f, 
    0.05041766f, -0.09301198f, 0.02032431f, 0.06192634f, -0.01559291f, 0.06226090f, 0.01844859f, -0.11550487f, 
    0.11158284f, -0.01395475f, -0.05418896f, 0.10373627f, -0.02323071f, -0.07372325f, 0.09641535f, -0.07546789f, 
    -0.03586615f, -0.04443748f, 0.01804679f, -0.06487738f, -0.06678348f, -0.05606747f, -0.01095220f, 0.03275632f, 
    -0.04234184f, 0.01990711f, -0.06092460f, -0.00946075f, 0.04702153f, -0.03307828f, 0.03295039f, 0.03867288f, 
    0.00030475f, -0.03016367f, 0.00568339f, -0.05925503f, -0.06028277f, 0.01022546f, 0.04527027f, 0.02521076f, 
    -0.05567464f, -0.04518870f, -0.02879303f, 0.00487401f, -0.05732399f, 0.03013641f, -0.06399329f, 0.03882713f, 
    -0.00387205f, 0.04652136f, -0.05826073f, -0.02333996f, 0.04292737f, 0.04526899f, 0.03707332f, -0.00038073f, 
    -0.03916952f, -0.02855721f, 0.00823743f, -0.04823400f, 0.04478868f, -0.02374975f, -0.02697191f, -0.05487952f, 
    -0.06742807f, 0.05641558f, -0.00460537f, -0.04034851f, -0.03495381f, -0.02936615f, -0.02662558f, 0.01676284f, 
    -0.04583532f, 0.04947836f, -0.01802719f, 0.02642234f, -0.03961790f, 0.01159958f, -0.06545438f, -0.03515711f, 
    -0.02163023f, 0.04287494f, 0.04832820f, -0.02718943f, 0.04281392f, 0.00533594f, 0.04682240f, -0.04558823f, 
    -0.00587367f, -0.00854906f, 0.03257756f, -0.01858852f, -0.05270295f, -0.02088320f, -0.05205548f, 0.00194101f, 
    -0.02801266f, 0.01680653f, -0.00157251f, 0.03915259f, -0.03783933f, 0.03644371f, -0.02620917f, 0.00782021f, 
    -0.05471861f, -0.02326461f, 0.00469533f, 0.03740104f, 0.00710422f, 0.00796424f, -0.01137729f, -0.00783468f, 
    0.02307742f, -0.00742162f, -0.01957458f, -0.05412398f, -0.06658866f, -0.06068620f, -0.00283963f, 0.01699468f, 
    0.00566903f, -0.00380688f, -0.01051148f, -0.05706399f, 0.03380528f, 0.04581494f, -0.01645430f, 0.03163797f, 
    0.01206748f, 0.03478458f, -0.05696490f, -0.04254844f, 0.02469628f, -0.04828629f, -0.01067388f, 0.03904715f, 
    0.03749404f, 0.01314119f, -0.06701181f, 0.00050433f, -0.01815679f, -0.06807462f, 0.04698166f, 0.03026303f, 
    0.04080299f, 0.04739072f, -0.01814420f, 0.01784814f, 0.02071324f, -0.02099505f, 0.01099076f, 0.02669493f, 
    -0.02558530f, 0.00691587f, 0.01336664f, -0.05380672f, 0.01202536f, -0.01216983f, -0.00846268f, -0.00951584f, 
    -0.02799197f, -0.05677772f, -0.02683846f, -0.05110083f, -0.01045036f, -0.02241758f, 0.03004495f, 0.03858801f, 
    0.01992116f, -0.02535361f, -0.03240699f, -0.04761113f, 0.02772689f, 0.02451479f, 0.00359946f, 0.02797615f, 
    -0.02271440f, 0.03138173f, -0.05764971f, -0.06105548f, -0.06126817f, -0.03209203f, 0.01865331f, -0.03123445f, 
    -0.01633115f, 0.03261439f, 0.00806329f, -0.02851668f, 0.00006770f, -0.04611218f, -0.04251556f, 0.02510212f, 
    0.00978663f, 0.02899447f, -0.00514174f, 0.01753436f, 0.03581718f, -0.01758274f, 0.02633691f, -0.01496105f, 
    -0.02080856f, -0.04438583f, -0.04861163f, -0.06214900f, -0.04159348f, 0.04483881f, -0.00611620f, -0.00043311f, 
    0.03845671f, -0.00965410f, 0.00943407f, -0.05172474f, -0.04234513f, 0.04651108f, 0.04022329f, -0.01972731f, 
    0.04083898f, 0.01508726f, 0.02525900f, -0.02480539f, -0.06611846f, 0.03611860f, 0.02764806f, 0.03323564f, 
    0.02061224f, 0.04052577f, -0.06322307f, -0.02803322f, -0.04264362f, -0.04974654f, 0.00587492f, 0.01669986f, 
    -0.04144945f, -0.00389224f, 0.01849889f, -0.06043535f, 0.01836108f, -0.02520893f, -0.00111491f, -0.04159504f, 
    -0.03945607f, -0.05054713f, -0.03138274f, 0.01541720f, 0.02966708f, -0.02983229f, 0.02922781f, -0.06072988f, 
    -0.06518020f, -0.05070040f, -0.03586250f, -0.05350601f, 0.04836247f, -0.02180047f, -0.04731114f, 0.04101948f, 
    -0.03079806f, 0.04442599f, 0.04732995f, 0.02660676f, -0.00423574f, -0.05507319f, -0.00552329f, -0.01951321f, 
    0.03576712f, -0.02868082f, 0.00969240f, -0.04514949f, -0.01675623f, 0.00664389f, -0.00723024f, -0.05130469f, 
    -0.01666112f, -0.00144451f, -0.00622711f, 0.01569965f, 0.00691933f, -0.06775422f, -0.03560970f, 0.02040334f, 
    -0.03961696f, -0.04505788f, -0.05366194f, -0.06622982f, 0.02003982f, -0.04782736f, -0.01934577f, 0.04692024f, 
    -0.05291265f, 0.00848805f, 0.04860247f, -0.06713985f, 0.03692837f, -0.04722929f, -0.04658786f, -0.05373091f, 
    -0.00931148f, 0.01920803f, 0.00443825f, 0.01479341f, 0.01250192f, -0.02767650f, -0.05815448f, 0.00573645f, 
    -0.48302674f, -0.14047103f, 0.27804488f, 0.00681106f, 0.12597778f, 0.04588998f, 0.09556340f, -0.00302940f, 
    -0.06087432f, 0.00906290f, -0.07225031f, 0.14218937f, 0.02349097f, -0.01418737f, -0.06631552f, -0.06518574f, 
    0.06286232f, -0.00850945f, 0.24376911f, 0.05529947f, 0.01271272f, -0.13023929f, 0.03084856f, -0.07829475f, 
    0.13976590f, 0.05421209f, 0.00516641f, 0.03560095f, 0.07851837f, -0.01398656f, -0.08228390f, 0.04381970f, 
    0.01042706f, 0.05951341f, 0.13974908f, 0.03220019f, 0.02618841f, -0.06754164f, -0.17236552f, 0.06069977f, 
    -0.01758646f, 0.16470243f, -0.00606058f, 0.02454903f, -0.08169860f, 0.02724790f, -0.03840859f, 0.23800781f, 
    -0.00317519f, 0.02214502f, 0.04414491f, 0.14024647f, -0.07616471f, 0.02895450f, 0.05587757f, 0.00421516f, 
    0.03814383f, -0.18399020f, 0.03010586f, 0.03341585f, -0.01671895f, 0.01354874f, 0.07660718f, 0.28825271f, 
    0.18803878f, -0.26949447f, 0.02974871f, 0.16403966f, 0.10700762f, -0.09265938f, 0.09586886f, -0.04180596f, 
    0.01653302f, 0.05190958f, -0.10224636f, 0.02049055f, -0.04121273f, -0.00319473f, 0.10778301f, 0.04015319f, 
    -0.00179445f, -0.15780298f, 0.11456194f, 0.17315668f, 0.01740314f, -0.17921397f, 0.08454442f, 0.08617187f, 
    0.01768726f, -0.26355693f, 0.21637526f, -0.44813982f, 0.17554636f, -0.09706829f, 0.10464802f, 0.05071999f, 
    0.04685353f, 0.10741063f, 0.08109088f, -0.37729359f, -0.24939552f, 0.18426013f, 0.08341351f, 0.08404031f, 
    0.02596839f, -0.06842963f, 0.10530930f, -0.01972056f, -0.03998866f, 0.05222958f, -0.26036805f, 0.10075906f, 
    -0.08554006f, -0.07845608f, -0.02676408f, 0.03992122f, -0.05694631f, 0.09912597f, -0.02076961f, 0.03969638f, 
    0.00609056f, 0.11852246f, -0.10411819f, -0.03056750f, 0.13100299f, -0.01156182f, 0.06073469f, -0.15154356f, 
    0.08674108f, 0.10152370f, -0.05519620f, 0.04749198f, -0.03881635f, -0.03574091f, 0.08311958f, 0.00882372f, 
    0.07998244f, -0.02780863f, -0.02279802f, -0.18613781f, -0.00317015f, 0.11567304f, 0.03293640f, 0.01491811f, 
    -0.05516724f, -0.03199390f, 0.04545509f, -0.01888411f, -0.09819418f, -0.10113779f, -0.11500764f, 0.00582396f, 
    0.04214090f, -0.03380288f, 0.04650939f, -0.08015553f, -0.19987394f, -0.18120287f, -0.07924797f, -0.11727703f, 
    0.09390905f, 0.16878964f, -0.31534839f, -0.06818958f, 0.14217176f, -0.10218173f, -0.02552031f, 0.16262788f, 
    0.02665034f, -0.05798155f, -0.09351993f, 0.18202373f, -0.02735592f, 0.03096687f, 0.06965950f, 0.02559572f, 
    -0.19207378f, -0.03912903f, -0.07066484f, -0.01264304f, -0.00201321f, 0.00244637f, 0.20100841f, 0.06716375f, 
    -0.12910284f, 0.05445031f, -0.00287319f, -0.20475826f, 0.04354992f, 0.26625016f, -0.19478856f, 0.09770078f, 
    -0.03587970f, -0.23900509f, -0.07128449f, 0.14443707f, 0.00099792f, 0.05372155f, 0.12971061f, -0.09430306f, 
    -0.27820551f, 0.09943242f, -0.18359409f, 0.11245268f, -0.04780770f, 0.11066100f, 0.07244032f, 0.27939498f, 
    -0.39292002f, -0.22075498f, -0.13691229f, -0.01745144f, 0.07732915f, -0.00100540f, 0.10646697f, -0.08120365f, 
    -0.22375652f, 0.17706054f, -0.08216029f, -0.05940203f, 0.03391550f, 0.23561619f, -0.07200524f, 0.10366506f, 
    0.05790728f, 0.14312710f, 0.06253432f, 0.01584708f, 0.11292922f, -0.05241560f, -0.11826276f, -0.09327059f, 
    0.06644279f, -0.27825862f, 0.16320367f, 0.13990712f, 0.03463119f, 0.17925076f, -0.01337814f, -0.08346388f, 
    -0.06925277f, 0.17313273f, 0.08722715f, -0.37378713f, 0.18827127f, 0.09097499f, 0.00883048f, 0.01498863f, 
    -0.07296330f, -0.01388247f, -0.05957979f, 0.04990231f, 0.02604260f, -0.14215615f, -0.05644163f, 0.02450847f, 
    0.08866787f, -0.10446782f, -0.20054491f, 0.03059357f, 0.07746500f, -0.02817250f, -0.08342493f, 0.18136930f, 
    0.07658710f, -0.12173817f, -0.10977824f, -0.01940031f, 0.10943845f, -0.11871977f, -0.04549453f, 0.10633840f, 
    -0.00296243f, -0.04436143f, -0.11174084f, 0.09801216f, -0.01238151f, 0.07251737f, 0.03620913f, -0.01360658f, 
    0.18810372f, 0.09705257f, 0.00761664f, -0.07323940f, -0.04894815f, -0.08522668f, -0.07808435f, 0.08808839f, 
    0.21359375f, 0.14418927f, -0.20584947f, 0.07264867f, -0.02750832f, 0.02868804f, 0.02627832f, 0.07442562f, 
    -0.08788261f, 0.07733788f, 0.06634726f, 0.32965708f, -0.08621385f, 0.01173631f, 0.09136164f, -0.01896529f, 
    0.02324719f, 0.08481236f, -0.01184121f, 0.28368089f, 0.12021894f, -0.00835826f, 0.06799774f, -0.01899258f, 
    0.06852222f, -0.13500695f, 0.15976976f, -0.04487514f, -0.05215757f, 0.29297546f, 0.02061501f, 0.03140417f, 
    0.01795400f, 0.00288947f, -0.08766648f, 0.09295980f, -0.05760410f, -0.09717692f, -0.04942567f, 0.11408924f, 
    -0.17343551f, 0.30992129f, -0.04780095f, 0.07125359f, -0.11022549f, 0.17321226f, -0.16725938f, -0.07109257f, 
    -0.12163817f, -0.07492567f, 0.15371616f, -0.10442475f, -0.07743722f, 0.01558354f, 0.08800787f, 0.06822482f, 
    0.03360467f, 0.10233893f, 0.08804852f, 0.17086191f, 0.07729714f, 0.10137987f, -0.17947064f, 0.04828817f, 
    0.06999731f, -0.15908365f, -0.14245535f, -0.11756458f, -0.04856720f, -0.03639778f, -0.02522460f, -0.08338787f, 
    0.29850265f, 0.18929423f, -0.14449501f, 0.07670604f, -0.16311213f, 0.14349514f, -0.01840978f, -0.10208953f, 
    -0.01849387f, -0.15838207f, 0.16151674f, -0.06051528f, -0.02948601f, -0.06210487f, 0.04788703f, -0.00635346f, 
    -0.01340139f, -0.01041428f, -0.09160979f, -0.05439863f, -0.15411763f, 0.07921150f, 0.11803671f, 0.04137046f, 
    0.01118139f, -0.08590841f, 0.05219664f, -0.04664729f, -0.11589511f, -0.01703771f, -0.03819033f, -0.05058228f, 
    -0.08936021f, -0.06677674f, -0.00741452f, -0.12424397f, 0.06788811f, 0.07428414f, 0.11778720f, 0.13294852f, 
    -0.04163068f, -0.14822835f, -0.07508719f, -0.07424841f, -0.07443962f, -0.00744082f, -0.17910191f, 0.15600355f, 
    -0.03715687f, 0.07867680f, 0.00225983f, -0.00665558f, -0.02754693f, -0.05492786f, -0.27028292f, -0.01558689f, 
    0.05056012f, 0.05442337f, 0.13678747f, 0.02973795f, -0.09242899f, -0.02740024f, -0.29767615f, 0.05678489f, 
    0.07700272f, 0.07206506f, -0.12797153f, 0.04836866f, 0.15517500f, 0.01526150f, 0.11434122f, -0.22794402f, 
    0.00057713f, -0.13119812f, -0.03475955f, -0.04952218f, -0.02637355f, -0.09229413f, 0.05102824f, 0.08774313f, 
    -0.02439703f, 0.11206382f, 0.21264425f, -0.04504514f, 0.13061130f, 0.11734478f, -0.20555341f, -0.05204632f, 
    0.06285591f, -0.05127630f, 0.15700391f, -0.06707425f, -0.02580724f, 0.14618096f, -0.06821521f, 0.13649787f, 
    0.02364237f, -0.19565725f, 0.08226080f, 0.15979384f, 0.05942971f, -0.04609911f, 0.03771042f, 0.07064476f, 
    -0.14250521f, 0.02602165f, 0.09171308f, -0.12287171f, 0.15929203f, -0.00600178f, -0.03403374f, 0.02382561f, 
    -0.05057453f, -0.13003302f, -0.02993798f, 0.02441282f, -0.05902934f, -0.01699547f, -0.12517233f, -0.26443115f, 
    0.00717465f, -0.10412059f, -0.13158236f, 0.21455359f, -0.08962046f, 0.00402405f, -0.09717596f, -0.33490732f, 
    -0.31190750f, 0.08150533f, 0.03298312f, 0.12886745f, -0.08861388f, -0.09153938f, -0.17218219f, -0.03688871f, 
    -0.10934257f, -0.24230658f, 0.05844443f, -0.00137405f, 0.19285218f, -0.10702498f, -0.04028227f, 0.13331684f, 
    -0.33047923f, -0.19280796f, 0.18590313f, 0.09973805f, 0.21306179f, -0.01263034f, -0.24033803f, 0.05717349f, 
    0.09786546f, 0.02872271f, 0.08470851f, -0.02031813f, 0.15005487f, 0.01755385f, -0.04675139f, -0.08656810f, 
    -0.04592907f, 0.02126128f, -0.18679842f, 0.11890598f, 0.00833058f, 0.02635652f, 0.04819928f, -0.04200152f, 
    0.12175541f, -0.19962998f, 0.15248977f, 0.29294631f, 0.11748646f, 0.00607795f, -0.16723777f, -0.07206524f, 
    -0.05024085f, 0.04495956f, -0.05878016f, 0.17059498f, -0.07760560f, -0.03565637f, 0.00726559f, 0.01456913f, 
    0.03664722f, -0.14124073f, -0.01910411f, -0.04115271f, -0.09864119f, 0.07705253f, 0.02603922f, 0.12185758f, 
    -0.01208743f, 0.10783491f, -0.05091619f, -0.00266029f, -0.07085593f, 0.12405136f, -0.25000182f, -0.09786204f, 
    0.27179575f, 0.09451356f, -0.10837755f, 0.14829826f, -0.06808501f, 0.13544862f, 0.13417472f, 0.19564614f, 
    0.21119919f, 0.06249088f, 0.01401139f, -0.06642431f, 0.01507572f, -0.16537437f, 0.08266594f, -0.03257881f, 
    -0.05654451f, 0.00683900f, -0.03656036f, 0.02966589f, 0.03797074f, 0.03402659f, 0.02042257f, -0.04750342f, 
    -0.05957618f, 0.02694061f, 0.00676725f, 0.00844229f, -0.01745623f, -0.06226829f, -0.05966692f, 0.04508461f, 
    0.05096481f, 0.04507785f, -0.02779021f, -0.05210169f, 0.01876787f, -0.00070444f, 0.03878491f, 0.03666847f, 
    -0.01097135f, -0.01396898f, -0.05480716f, 0.03247269f, -0.05873714f, -0.03122944f, 0.00345877f, 0.03053222f, 
    0.03565340f, -0.05814699f, -0.03561715f, 0.03745528f, 0.00065761f, 0.02450928f, 0.01323955f, -0.07150962f, 
    -0.04759055f, -0.02055417f, -0.06491687f, 0.01292067f, -0.02339057f, -0.02545280f, -0.05836361f, 0.02793771f, 
    -0.00056068f, 0.02616691f, 0.04628556f, 0.04464762f, 0.02052409f, -0.01348368f, -0.00543643f, -0.01746119f, 
    0.02728721f, 0.01021586f, -0.01129669f, -0.01915048f, 0.04604020f, -0.04721971f, 0.04418328f, -0.04696716f, 
    -0.05664212f, 0.01368709f, -0.04341751f, 0.01284519f, 0.00924413f, 0.00179918f, -0.01319564f, 0.02152966f, 
    -0.03547895f, -0.04288951f, -0.04892116f, -0.05638263f, -0.01007759f, -0.03106422f, 0.04117105f, 0.04185925f, 
    -0.04583076f, -0.02981811f, 0.02154352f, 0.02545746f, -0.00251480f, 0.05039192f, 0.00271998f, 0.04114809f, 
    -0.03963067f, -0.02841472f, -0.00735532f, 0.04381460f, -0.04077175f, -0.03008401f, -0.02569098f, 0.00725395f, 
    0.03011486f, -0.00301185f, -0.02313969f, -0.06712379f, -0.01957583f, 0.01889778f, -0.04956672f, -0.00885575f, 
    0.01757988f, 0.03252513f, -0.00282153f, -0.00885760f, -0.03812829f, -0.04455041f, -0.00582593f, -0.01814133f, 
    -0.06170557f, -0.05531800f, 0.03968949f, 0.00386618f, 0.03595502f, -0.00949019f, 0.00990604f, -0.00248921f, 
    -0.06556226f, 0.01675747f, 0.04624132f, -0.02123767f, -0.04277874f, 0.01522105f, 0.04961552f, -0.02114821f, 
    -0.06570269f, -0.03875754f, -0.03715813f, 0.01486698f, -0.02527389f, 0.01350897f, -0.01749124f, -0.04481586f, 
    -0.01217119f, -0.06757422f, 0.03597056f, -0.00436743f, 0.00072336f, -0.02726464f, 0.03752331f, 0.04257149f, 
    -0.06881228f, -0.02793385f, -0.03168293f, -0.00345471f, -0.06848758f, -0.03221909f, -0.04878955f, -0.03600485f, 
    -0.03710710f, -0.03099147f, -0.04481206f, -0.05568418f, 0.03387290f, 0.02708944f, -0.03025763f, -0.06106514f, 
    0.03307638f, -0.02200777f, 0.04914211f, -0.01018881f, -0.04369128f, 0.01597357f, -0.05060208f, -0.05878561f, 
    -0.02647405f, 0.05456343f, 0.00364539f, 0.03374026f, 0.04556003f, 0.00144546f, -0.05939757f, -0.00957323f, 
    -0.01432160f, -0.04449109f, 0.00481559f, 0.01955102f, 0.00569787f, 0.00171774f, 0.03801411f, -0.02884382f, 
    0.01085102f, -0.06178029f, -0.00675232f, -0.06571697f, -0.02172803f, 0.03096973f, 0.00367086f, -0.06366008f, 
    0.03010714f, -0.02622901f, -0.03609343f, 0.03778990f, -0.01249625f, -0.03227374f, -0.05323732f, -0.04422116f, 
    -0.02132057f, 0.01509175f, 0.04542293f, -0.05811143f, 0.04590834f, -0.00369998f, 0.00459000f, -0.05283819f, 
    -0.01203333f, 0.02354748f, -0.01845188f, -0.02954111f, -0.02292025f, -0.00190848f, 0.03149051f, -0.05481214f, 
    0.02984488f, -0.00579385f, 0.02568079f, -0.00528289f, -0.05957701f, 0.03135696f, -0.06705163f, -0.00387803f, 
    -0.00457100f, -0.05676472f, 0.03769619f, -0.03894743f, 0.03598872f, -0.02051383f, 0.02273254f, -0.01043705f, 
    -0.02814269f, -0.01250579f, -0.06629121f, 0.01926330f, -0.00495458f, -0.01598294f, -0.05380442f, -0.03317831f, 
    0.02366541f, -0.02344916f, 0.03586892f, -0.00474734f, 0.05082693f, -0.01100328f, -0.06797343f, -0.02344079f, 
    0.04515513f, 0.03285471f, 0.05461388f, -0.04642643f, -0.04018159f, -0.05513220f, -0.01494644f, 0.03750006f, 
    0.00096194f, 0.02821736f, -0.05684794f, 0.01198186f, -0.01668105f, -0.01654860f, 0.02628507f, -0.05662944f, 
    0.01191697f, 0.01253979f, -0.01753409f, -0.02225387f, 0.04656385f, -0.02509690f, 0.01209187f, -0.06247860f, 
    -0.03120642f, -0.05749931f, 0.01756117f, -0.00567769f, 0.01113851f, 0.00433458f, -0.01392214f, -0.01905007f, 
    0.05341348f, -0.02490481f, 0.00220267f, 0.00487628f, -0.03748557f, -0.01737185f, -0.06354734f, 0.03647011f, 
    -0.05014500f, -0.02098490f, 0.01304125f, 0.04267972f, -0.01453701f, 0.04793523f, 0.00991805f, -0.00324677f, 
    0.03258117f, 0.00376358f, 0.05157398f, 0.04776022f, 0.04108532f, -0.03188540f, -0.00832310f, 0.04724598f, 
    -0.05298747f, 0.01652086f, 0.02831818f, 0.01771341f, 0.04943646f, 0.00595392f, 0.00946305f, -0.06170584f, 
    0.04489455f, 0.00306071f, -0.02369984f, -0.05419626f, -0.05943391f, -0.03541069f, 0.03555604f, 0.00769057f, 
    0.04897196f, -0.05710856f, -0.05316470f, 0.02474387f, -0.01276386f, 0.00646091f, 0.00978838f, -0.06230117f, 
    0.04912584f, -0.01659241f, 0.01773251f, -0.06379855f, -0.00769937f, -0.04395688f, -0.00945360f, 0.04462088f, 
    -0.04766657f, 0.05078894f, 0.01345769f, 0.01275693f, 0.05198110f, 0.01995217f, -0.02640089f, 0.04049658f, 
    -0.04602322f, -0.01320717f, -0.00305285f, -0.05153000f, 0.01263866f, 0.03493060f, -0.06256068f, -0.03958229f, 
    -0.02774161f, -0.04652247f, -0.01060979f, -0.04060847f, 0.02319120f, -0.03967416f, 0.03655523f, -0.01222771f, 
    0.02969988f, -0.03394338f, -0.00464214f, 0.03141193f, 0.01210300f, -0.05876499f, -0.02398052f, 0.03132810f, 
    0.01265323f, -0.05976647f, -0.01063731f, -0.00418790f, 0.02197976f, -0.02283058f, 0.04746491f, -0.05150420f, 
    -0.06145040f, -0.06295609f, 0.00879728f, -0.02062462f, 0.01156809f, -0.06338967f, 0.00165942f, -0.06247723f, 
    0.04444033f, -0.04623996f, -0.00222080f, 0.02473713f, -0.05063943f, -0.05864819f, -0.00401010f, -0.03613114f, 
    -0.00129197f, 0.04850028f, 0.00184294f, -0.05904255f, -0.03012714f, -0.06175112f, -0.03573997f, -0.02923475f, 
    -0.02810634f, -0.04616631f, 0.03377754f, 0.01271430f, -0.02694950f, -0.04821872f, -0.04483165f, -0.01137866f, 
    0.01470296f, -0.01758455f, 0.03452842f, 0.05086821f, 0.00882684f, -0.03283888f, 0.03089263f, -0.05535263f, 
    0.01085534f, 0.01647716f, 0.04015357f, -0.02130960f, 0.04383634f, 0.02329726f, 0.03925504f, -0.01123342f, 
    0.04148079f, -0.05342819f, 0.04051156f, 0.00406667f, 0.03003458f, -0.05332977f, -0.00726379f, 0.00792887f, 
    -0.04080412f, 0.04750433f, 0.03789629f, -0.06394291f, -0.02599180f, -0.05090619f, -0.05429331f, -0.03387862f, 
    0.02259068f, 0.02167853f, -0.03227700f, 0.02404901f, -0.05362944f, 0.04889916f, -0.01493620f, -0.03304932f, 
    -0.02591187f, -0.00578482f, -0.04520197f, -0.02225732f, -0.05946207f, -0.03710621f, -0.06451575f, -0.05990034f, 
    -0.02048386f, 0.04749895f, 0.04354442f, -0.01945557f, 0.02594523f, 0.04118035f, -0.02930291f, 0.00104765f, 
    -0.05381840f, 0.01869572f, -0.00471417f, 0.03729732f, -0.02692717f, -0.03348213f, 0.03363540f, -0.02065889f, 
    -0.05034129f, 0.02572807f, -0.00141641f, -0.04773230f, -0.04617557f, 0.04136733f, -0.00260158f, 0.04718438f, 
    -0.01631059f, -0.04712245f, -0.03500563f, -0.03934675f, -0.01805094f, 0.03077857f, -0.01522221f, 0.04664991f, 
    0.01374219f, 0.04732714f, 0.01938749f, -0.01313520f, -0.04054362f, -0.02757592f, -0.00149510f, -0.03229079f, 
    0.02738650f, -0.00813451f, -0.02124513f, -0.05031358f, 0.02422598f, 0.02870040f, -0.06137393f, -0.00363497f, 
    0.01780809f, -0.02690060f, -0.05903679f, -0.02481590f, -0.03801757f, 0.03937549f, -0.04577041f, -0.03471169f, 
    -0.02859460f, -0.01226693f, -0.05828300f, -0.00368053f, -0.03973561f, 0.01632894f, 0.00967119f, -0.02113930f, 
    0.02286930f, -0.01372537f, -0.01643344f, 0.03145793f, 0.00462900f, 0.03228134f, -0.05389740f, 0.04224059f, 
    0.05187453f, -0.03212629f, -0.05283492f, 0.05174408f, -0.03326411f, -0.03023848f, -0.05588028f, 0.03938113f, 
    -0.01299915f, -0.01665891f, 0.00543697f, 0.02325261f, 0.05081398f, 0.01373499f, -0.02061526f, 0.01686186f, 
    -0.04259884f, -0.00225454f, 0.05274455f, 0.04068522f, 0.02575371f, 0.02049764f, 0.01658838f, -0.04866493f, 
    0.00941420f, -0.00957415f, 0.03155066f, -0.02444915f, -0.04177237f, -0.02354038f, 0.01702713f, -0.02452044f, 
    -0.02476957f, -0.01037950f, -0.06403376f, 0.00025634f, -0.04924902f, -0.04507145f, 0.01161050f, -0.04380273f, 
    -0.01533130f, -0.03317175f, -0.02098718f, 0.04150975f, -0.01728819f, -0.03828074f, -0.04418379f, 0.01401963f, 
    -0.04558213f, 0.13720471f, -0.05808475f, -0.00080779f, 0.02688333f, -0.06462606f, 0.09217022f, -0.03489311f, 
    -0.01107610f, -0.17090718f, -0.36540228f, -0.17495602f, -0.09957989f, -0.00744043f, -0.07324756f, 0.07919349f, 
    0.05709526f, 0.16394928f, 0.14643340f, -0.33248770f, -0.02789341f, -0.00355177f, -0.08189052f, -0.09134452f, 
    0.14536992f, -0.01966570f, -0.01238225f, 0.24005823f, -0.16298445f, 0.14017825f, 0.08362864f, -0.08826483f, 
    -0.12944464f, -0.03541334f, -0.02365844f, 0.09218410f, -0.12682076f, 0.00073488f, 0.08181321f, 0.01909124f, 
    0.05206031f, -0.05323730f, 0.09750028f, 0.03422670f, 0.19878303f, -0.36722401f, -0.12628870f, -0.00203507f, 
    0.06388360f, 0.04831942f, -0.21812314f, 0.03903607f, -0.16570210f, 0.16057472f, -0.00448862f, -0.07893014f, 
    -0.07774097f, -0.01809292f, -0.00054124f, -0.09174927f, 0.13691713f, 0.03013650f, -0.16561851f, 0.06116458f, 
    -0.33351150f, 0.17022286f, -0.07469507f, 0.06222920f, 0.05851243f, 0.02632517f, -0.07765943f, 0.03190362f, 
    -0.51907748f, 0.03148168f, -0.08489901f, 0.03856718f, 0.11930235f, 0.12062338f, 0.04538029f, 0.02553540f, 
    0.01604134f, 0.33892679f, -0.01159911f, -0.02323578f, -0.16070987f, 0.05562764f, 0.19423918f, -0.00965050f, 
    -0.09536728f, -0.02223702f, -0.37299329f, 0.08676663f, -0.41416997f, -0.07726382f, 0.04575462f, 0.08415806f, 
    -0.05600452f, -0.06336653f, -0.03526629f, -0.04626729f, 0.05160188f, 0.02468827f, -0.09895202f, 0.07015397f, 
    0.04467262f, -0.01236746f, 0.04703976f, -0.08611593f, 0.49091038f, -0.01533445f, 0.05883818f, -0.06720493f, 
    -0.02971443f, 0.06691746f, -0.13342230f, 0.09062733f, -0.01176405f, 0.10681465f, 0.16267075f, 0.13944933f, 
    -0.09914326f, 0.04740516f, 0.06161154f, -0.05007957f, -0.02744192f, 0.06743589f, -0.12014773f, 0.06813017f, 
    -0.21328819f, 0.03238199f, 0.06818205f, -0.04892137f, -0.11248249f, 0.00793212f, -0.05589328f, 0.38632903f, 
    0.05235188f, 0.08377749f, -0.15788469f, -0.20280041f, 0.13866831f, -0.04401049f, -0.00905042f, -0.20038040f, 
    0.31772330f, 0.16208141f, -0.07338979f, 0.03876411f, 0.05029014f, 0.08973977f, -0.10288203f, 0.01602319f, 
    0.00317620f, 0.16572832f, -0.17265879f, -0.03699123f, -0.06557811f, 0.04617390f, -0.17256956f, -0.02493494f, 
    -0.06621793f, 0.00966220f, -0.16766928f, 0.06195252f, -0.01579753f, -0.00439236f, 0.00215592f, 0.03817258f, 
    -0.00733310f, 0.01033176f, 0.05887700f, -0.05885180f, 0.14335527f, -0.00380776f, -0.04682033f, -0.03916376f, 
    -0.06845961f, 0.21413028f, 0.21275878f, -0.17182669f, -0.01704235f, 0.13687508f, -0.03093072f, 0.04376718f, 
    -0.01709731f, -0.07552452f, 0.02372648f, -0.00604064f, -0.14040436f, 0.17035462f, -0.19399041f, 0.01702789f, 
    -0.08159408f, -0.00158428f, -0.18979120f, -0.15756743f, 0.12836018f, -0.03962375f, -0.16815071f, -0.22024231f, 
    -0.02769600f, -0.16616553f, 0.17310895f, 0.05037041f, 0.01514031f, 0.11410899f, -0.03488623f, 0.27642241f, 
    0.02014285f, 0.09500772f, -0.02261291f, -0.13419715f, 0.12676784f, 0.19154370f, 0.04551831f, -0.00104377f, 
    0.22151320f, 0.10748760f, 0.25535941f, -0.05033908f, -0.28744218f, 0.02617267f, 0.06963286f, 0.01677820f, 
    0.14820959f, 0.22628824f, 0.02606292f, -0.09789676f, -0.13443792f, -0.01509057f, 0.01947179f, 0.04199921f, 
    0.03007544f, -0.13473803f, 0.00921892f, 0.15825149f, 0.07112417f, -0.29855740f, -0.08104321f, 0.01081691f, 
    -0.19997342f, 0.06062194f, 0.05291001f, 0.14878330f, 0.30327821f, -0.12392343f, -0.01567022f, 0.14544603f, 
    0.10975854f, -0.10022946f, -0.14569867f, -0.04535184f, -0.10120997f, -0.01795053f, -0.02359839f, -0.03072385f, 
    0.18274324f, 0.01553992f, -0.10838306f, -0.08035511f, -0.02600585f, 0.39224920f, -0.05411602f, -0.13707477f, 
    -0.03231478f, 0.07251135f, -0.15081787f, -0.04315452f, -0.05960111f, 0.14041403f, 0.18675295f, 0.05773182f, 
    0.19749881f, -0.04053020f, -0.08817857f, -0.04306778f, -0.03054597f, 0.07237010f, 0.12866029f, 0.14660330f, 
    -0.17040931f, 0.03678084f, 0.09177844f, 0.07592934f, -0.12954997f, -0.15467216f, -0.00792647f, 0.04902187f, 
    -0.03923139f, -0.04282524f, -0.04849680f, 0.01917297f, 0.00397595f, 0.02629221f, -0.04110511f, -0.02560790f, 
    0.01317019f, 0.04855562f, 0.01622996f, 0.01319581f, 0.03430202f, 0.03618337f, 0.03498506f, -0.04861519f, 
    -0.03633883f, 0.01596415f, -0.01435930f, 0.00488948f, 0.02738416f, 0.03357921f, 0.04660893f, -0.02105087f, 
    0.03942146f, -0.04525579f, -0.02940555f, -0.00225323f, -0.05623360f, -0.03234556f, 0.01274707f, -0.06086750f, 
    -0.06214697f, -0.05730478f, -0.00919400f, -0.04896995f, -0.02336302f, 0.04046469f, 0.00255730f, -0.01428456f, 
    0.03789857f, -0.01413718f, 0.00472400f, 0.00977264f, -0.01496305f, -0.05128620f, 0.03249073f, -0.05449053f, 
    -0.06066753f, 0.04383601f, -0.03913003f, -0.02110690f, -0.01488248f, 0.01428406f, 0.04618851f, -0.03861557f, 
    0.01714369f, -0.04079637f, 0.02472957f, 0.03604050f, 0.01220564f, -0.01787511f, 0.03589109f, -0.05604536f, 
    0.00200561f, -0.06464978f, 0.01839702f, 0.03021025f, -0.01241126f, -0.06261036f, -0.02574382f, -0.06022019f, 
    0.00563125f, 0.00760850f, 0.02261483f, 0.00196901f, -0.02671271f, -0.05755118f, -0.04207514f, 0.01118907f, 
    0.01426834f, 0.00109872f, -0.04179581f, -0.02450818f, 0.03105222f, -0.00423041f, 0.03660627f, 0.01386632f, 
    -0.02981365f, 0.00269395f, 0.02469205f, -0.05789192f, 0.00049157f, -0.00979576f, -0.05308814f, -0.05651620f, 
    -0.02442494f, -0.02203070f, 0.01429493f, 0.03116829f, 0.02852150f, 0.01914600f, -0.06143618f, -0.06337801f, 
    -0.06481355f, -0.05292085f, -0.05719235f, -0.04593469f, -0.00199568f, -0.05684923f, -0.05678484f, -0.04444560f, 
    -0.01180203f, -0.01735372f, -0.05578917f, 0.04125617f, -0.04646850f, -0.00604366f, -0.04474090f, 0.03437773f, 
    0.03928224f, 0.05285287f, -0.06407829f, 0.03397119f, 0.01733850f, -0.04019783f, 0.01361769f, -0.06434482f, 
    0.02603572f, -0.03926298f, 0.01851516f, -0.05420426f, -0.01361697f, -0.05714256f, -0.01080690f, 0.02532172f, 
    0.04688330f, -0.01530886f, 0.00739264f, -0.03392415f, -0.02398564f, -0.02509913f, 0.04173323f, 0.03413136f, 
    -0.06268001f, -0.05887973f, 0.00997665f, -0.06453878f, 0.04778060f, 0.01228788f, -0.00831766f, 0.02151489f, 
    -0.01493938f, 0.03569060f, -0.00459634f, -0.01603943f, -0.05113450f, 0.05073287f, 0.03707408f, 0.00674487f, 
    -0.03761346f, -0.05084300f, 0.02908690f, 0.01076691f, -0.00901858f, -0.05854464f, -0.06001201f, 0.00016611f, 
    -0.00315932f, -0.05149349f, 0.01656120f, 0.01234486f, 0.03473196f, -0.04681130f, 0.05012158f, -0.04169797f, 
    0.01859775f, -0.01324777f, 0.01603309f, -0.02225937f, 0.01149724f, -0.04350565f, 0.00886123f, 0.00151719f, 
    -0.01675289f, -0.02872073f, -0.06218649f, 0.02743679f, -0.05476993f, -0.00836848f, 0.02406402f, -0.04226394f, 
    0.00592890f, -0.04683671f, 0.04781876f, 0.01698853f, -0.06343406f, 0.02926477f, -0.00322534f, 0.05227788f, 
    -0.00478859f, 0.03784615f, 0.02593547f, 0.01599836f, -0.01590092f, 0.03781067f, 0.02238458f, 0.00901388f, 
    0.00471453f, -0.01623435f, 0.00083244f, -0.01954826f, 0.04036394f, -0.06220710f, -0.03699153f, -0.03965773f, 
    -0.00309875f, -0.01601071f, 0.02511281f, 0.05098531f, -0.04732778f, -0.04063629f, -0.03773264f, -0.04207658f, 
    -0.05250000f, 0.00966596f, -0.05929257f, -0.03180541f, 0.03367490f, 0.04712474f, -0.00602392f, -0.02547852f, 
    -0.00435621f, -0.06393161f, -0.01928763f, 0.04200831f, 0.05118493f, 0.02471903f, -0.00807634f, -0.02532645f, 
    -0.03868168f, -0.03552962f, 0.03300535f, -0.04566814f, 0.04737873f, -0.04846193f, 0.00653759f, 0.01652340f, 
    0.03724413f, -0.02373482f, 0.04664478f, 0.01730673f, -0.05674764f, 0.03667091f, 0.00194399f, 0.02482749f, 
    -0.04407020f, -0.00855698f, -0.05505546f, 0.01335260f, -0.05256021f, 0.01813820f, 0.03067384f, 0.03594213f, 
    0.04070658f, 0.00819309f, -0.02657986f, -0.03424776f, 0.01381606f, -0.00796010f, -0.01776701f, 0.01971675f, 
    -0.03560925f, -0.04755292f, -0.01135959f, -0.02174041f, 0.00861307f, 0.03365392f, 0.04459582f, 0.01534294f, 
    0.00012578f, -0.03103349f, -0.03826762f, 0.00073476f, -0.02304852f, -0.00903166f, 0.02993627f, -0.05547233f, 
    0.01159088f, -0.05477408f, 0.02502977f, -0.02080466f, 0.03221867f, -0.07582306f, 0.03274013f, -0.00779664f, 
    -0.02642509f, 0.01354440f, 0.05827274f, 0.04261424f, -0.02736054f, 0.00046001f, -0.06218309f, 0.00322975f, 
    -0.05094964f, -0.07410318f, -0.01101417f, 0.03642252f, -0.04763109f, -0.03893172f, 0.00085804f, 0.00539283f, 
    -0.05301819f, -0.05008221f, -0.02044917f, -0.01325361f, 0.05825830f, 0.03900411f, -0.04225699f, -0.01141764f, 
    0.00659980f, 0.03625344f, -0.02379429f, -0.07513230f, -0.06152503f, 0.04054364f, -0.03403877f, -0.05433444f, 
    -0.05007719f, 0.00766142f, -0.06461693f, -0.02237292f, 0.06124026f, 0.00262601f, 0.05739989f, -0.02252926f, 
    0.00387146f, -0.05552216f, -0.04574093f, 0.02704726f, 0.02669203f, 0.05029166f, 0.02843606f, -0.03630148f, 
    0.03872807f, 0.00485913f, -0.01693161f, -0.03258848f, -0.05017581f, -0.01037583f, -0.03061901f, -0.02635928f, 
    -0.03255749f, -0.04162753f, -0.02942324f, 0.02227627f, -0.06326408f, 0.02913361f, -0.07529189f, 0.00531531f, 
    0.02246560f, 0.02303748f, 0.00081108f, -0.05569126f, -0.06230021f, -0.04000341f, 0.01640963f, 0.01696613f, 
    -0.01339877f, 0.04088893f, -0.02558565f, -0.05951208f, 0.04139244f, -0.02662571f, -0.02711142f, 0.02559638f, 
    -0.03140882f, 0.01285423f, 0.01660678f, -0.03649760f, -0.02628957f, -0.01920900f, -0.08167037f, 0.01051669f, 
    -0.03096479f, -0.03926784f, -0.02734463f, 0.02533015f, -0.00218623f, 0.01858446f, 0.02556428f, -0.07420603f, 
    0.01347797f, -0.06872731f, 0.00014904f, -0.03471987f, -0.05403813f, -0.04804573f, 0.00814988f, 0.03258925f, 
    0.03482927f, -0.01867462f, 0.03081155f, -0.07552684f, -0.03472297f, 0.01665925f, 0.03567911f, -0.01262232f, 
    0.04980803f, 0.00345139f, -0.03381911f, -0.01184947f, -0.00163702f, 0.01997638f, -0.00775462f, -0.03495108f, 
    -0.04332983f, -0.01994403f, 0.01552987f, 0.01302104f, 0.01517713f, -0.00814348f, 0.04457258f, 0.03189740f, 
    0.00459569f, -0.04025698f, 0.00232207f, -0.01379816f, -0.06079102f, -0.01211151f, 0.04463056f, -0.04797578f, 
    0.03717110f, -0.04275374f, -0.02880655f, 0.00203505f, -0.05374973f, -0.05801496f, -0.04170803f, 0.00674281f, 
    -0.00938902f, 0.01729247f, 0.00754027f, 0.03047416f, -0.06921234f, -0.02456911f, -0.02303711f, -0.01855068f, 
    -0.08806003f, -0.03424804f, 0.01795801f, -0.05816605f, -0.03178294f, -0.03329361f, -0.01178114f, 0.01418783f, 
    -0.03675042f, -0.06852563f, 0.04847141f, -0.04979575f, 0.02196305f, 0.01578546f, -0.03340468f, -0.01788561f, 
    -0.01608913f, 0.03590860f, 0.03425592f, 0.01757697f, -0.00550394f, 0.01750344f, 0.02070888f, -0.04679056f, 
    -0.05669996f, -0.05914115f, -0.02681307f, -0.04242300f, -0.07577998f, 0.01349644f, -0.03769961f, -0.03240205f, 
    -0.05038579f, -0.05601018f, 0.00737640f, -0.00690276f, -0.06253824f, -0.08004170f, -0.03165043f, -0.03631995f, 
    0.01944471f, 0.01014442f, -0.01103160f, 0.02909493f, -0.07133970f, 0.00776074f, -0.05282298f, 0.04622422f, 
    0.00721915f, 0.00014927f, 0.00901848f, -0.02877145f, -0.07187506f, 0.00032393f, -0.03415161f, -0.06128924f, 
    -0.05847796f, 0.00932557f, -0.00981186f, -0.03656187f, -0.04689523f, 0.03631728f, 0.04398805f, 0.01960782f, 
    0.03201204f, -0.06231627f, 0.00656327f, -0.06987806f, 0.02212784f, -0.04391097f, -0.00507995f, -0.06081488f, 
    0.03185851f, -0.02666688f, -0.00289070f, 0.00817581f, -0.02837167f, -0.04376097f, -0.03460503f, -0.02597844f, 
    0.00141984f, 0.01462716f, -0.01189329f, -0.05063604f, 0.05222480f, -0.03617017f, 0.00897011f, -0.03332168f, 
    -0.01737783f, -0.00348620f, -0.00672287f, -0.05886857f, 0.02119091f, -0.07183677f, -0.00045383f, 0.02282908f, 
    -0.07794455f, 0.03411384f, 0.01245779f, -0.04472763f, -0.01066090f, -0.04066610f, -0.02927594f, 0.06737215f, 
    -0.03130377f, -0.07240553f, -0.01546267f, -0.06258886f, -0.02014058f, -0.04691173f, 0.01915405f, 0.03114981f, 
    0.02210341f, -0.04406882f, 0.00289265f, 0.04343279f, -0.02952823f, -0.07022429f, 0.00673519f, -0.03825674f, 
    -0.05341505f, 0.02880645f, -0.01031060f, -0.03066926f, -0.03856999f, 0.00458654f, 0.00850192f, -0.07427019f, 
    -0.00122017f, -0.01019222f, 0.35412711f, 0.00055465f, 0.13396102f, 0.03018736f, 0.14162284f, 0.04315775f, 
    0.03115757f, -0.18376493f, -0.10900942f, 0.17597324f, 0.09911593f, 0.05563844f, -0.12434673f, -0.08612842f, 
    -0.00935957f, 0.02921006f, -0.21052825f, -0.24352445f, 0.16549215f, 0.11522782f, 0.14586441f, -0.09048589f, 
    -0.02618419f, -0.09729452f, 0.10613606f, -0.47097212f, -0.24015275f, 0.06773190f, 0.13670664f, -0.03230159f, 
    -0.04890153f, 0.14893034f, 0.07832394f, 0.06740247f, -0.03180593f, 0.02881688f, -0.05691797f, 0.02469136f, 
    -0.09208436f, -0.05424662f, 0.10674331f, 0.14543428f, 0.04290771f, 0.01602048f, 0.10463278f, -0.20476136f, 
    -0.05923482f, 0.00666844f, 0.18702695f, 0.17199335f, 0.06922132f, 0.03429642f, -0.20883378f, -0.20075755f, 
    -0.04790533f, 0.07107283f, 0.07244752f, 0.00000425f, 0.02145926f, 0.03139558f, 0.01615170f, 0.02696136f, 
    -0.10051701f, 0.21515149f, 0.08305649f, 0.12560904f, -0.01406785f, -0.00841330f, -0.13530004f, 0.01089880f, 
    0.28758058f, 0.02751070f, 0.09279062f, 0.03479798f, -0.08029574f, -0.11360745f, 0.01543302f, 0.03580470f, 
    0.13954175f, 0.28699332f, -0.03764805f, 0.10002290f, -0.03381744f, -0.02519571f, -0.05357994f, -0.04604224f, 
    0.21713480f, 0.00469128f, -0.03697401f, -0.10477964f, -0.10429434f, 0.06832237f, 0.01936732f, 0.05363875f, 
    -0.00868014f, 0.08137950f, 0.15863310f, -0.12203144f, 0.09345943f, 0.25961879f, -0.07919146f, 0.13894743f, 
    -0.02406807f, -0.09793629f, 0.04881174f, -0.03784062f, -0.09538896f, -0.10697279f, 0.08540235f, 0.02108308f, 
    -0.19282928f, -0.12776525f, -0.01128923f, -0.05098756f, -0.13781483f, 0.25126788f, -0.06779066f, 0.07871480f, 
    0.02528819f, 0.01201300f, -0.04844836f, 0.04202346f, -0.08628582f, -0.03683148f, -0.13973093f, -0.00856452f, 
    -0.32388860f, 0.09005724f, -0.00379416f, 0.10014605f, -0.02975591f, 0.01100297f, -0.14391431f, 0.13205649f, 
    -0.07060641f, -0.13691312f, -0.10223909f, 0.13043952f, 0.03490860f, -0.10413410f, -0.09131496f, 0.15088171f, 
    -0.00324555f, -0.17057513f, -0.13562101f, -0.25312251f, 0.07619523f, 0.03220016f, -0.07425723f, -0.07166470f, 
    0.16622563f, -0.13087127f, -0.09754008f, 0.02765971f, -0.15435745f, -0.00255576f, -0.06369508f, -0.03317951f, 
    0.06672628f, 0.09072675f, -0.17300640f, 0.07769659f, 0.09574899f, 0.08048142f, -0.03944915f, 0.01588160f, 
    0.00234820f, 0.06789457f, -0.05369746f, -0.04257654f, 0.00003114f, 0.19926247f, -0.07369672f, 0.01319112f, 
    -0.06881861f, 0.04943528f, 0.08710286f, 0.05491290f, 0.18115005f, 0.07704131f, 0.02487356f, 0.00666861f, 
    0.23269220f, 0.04717311f, -0.04115257f, 0.07288411f, -0.13511783f, 0.13835895f, -0.04864766f, -0.05117790f, 
    0.00996121f, -0.04543734f, -0.06749244f, -0.14392972f, 0.00488683f, 0.05655687f, 0.01634296f, -0.23490134f, 
    -0.27486131f, -0.06412458f, -0.13554463f, 0.08951805f, 0.21394467f, -0.05358617f, -0.01075172f, 0.32974955f, 
    -0.00218617f, -0.18901271f, 0.01523897f, 0.03943660f, -0.04569497f, 0.21240562f, 0.01600811f, -0.00675546f, 
    -0.24730451f, -0.08387957f, -0.02124492f, 0.11449604f, 0.15665586f, -0.01009168f, -0.02097826f, 0.02286061f, 
    0.11225101f, 0.07507410f, -0.07012494f, -0.04234859f, 0.16243210f, 0.13852069f, 0.04115478f, -0.03760937f, 
    0.00044301f, -0.02938779f, -0.12592386f, -0.22509398f, -0.05954200f, -0.04829907f, 0.18149921f, -0.07739659f, 
    0.06451342f, -0.03415785f, 0.03110564f, -0.29428643f, 0.14081207f, -0.00952978f, -0.10699412f, -0.11468667f, 
    0.02403282f, -0.20266987f, -0.07969861f, 0.07465598f, 0.07769562f, 0.02347161f, 0.06418206f, -0.09829151f, 
    -0.02914736f, 0.00240040f, -0.11663443f, 0.06701503f, 0.06917867f, -0.39858547f, -0.23009549f, -0.14730945f, 
    0.20795430f, 0.11526491f, 0.05970398f, 0.06460318f, -0.13523567f, -0.11077157f, -0.29712456f, -0.14014560f, 
    -0.12627639f, 0.26977095f, 0.08145244f, 0.00341878f, 0.09639891f, 0.03164982f, -0.05243121f, -0.19302189f, 
    -0.17479140f, 0.21249709f, 0.10937132f, 0.15791865f, -0.09340792f, 0.10815763f, 0.01784032f, -0.18081886f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.05857287f, 0.12191369f, 0.03462977f, -0.06595721f, 0.25735268f, -0.06033910f, 0.05600297f, 0.14005603f, 
    -0.02903287f, 0.00841143f, -0.11384065f, 0.07212234f, -0.06106097f, 0.02715658f, -0.01088756f, -0.00848799f, 
    0.01859228f, -0.05288463f, 0.08783558f, -0.04949327f, 0.05928217f, 0.05269472f, 0.13747780f, -0.05009974f, 
    -0.03568911f, 0.08033165f, 0.00022269f, -0.02314696f, -0.06313986f, -0.03987317f, -0.01062430f, 0.14589210f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.11122747f, 0.31012326f, 0.03362513f, 0.16703282f, 0.26582462f, -0.13971025f, -0.00532232f, -0.02232196f, 
    -0.04714416f, -0.21251723f, -0.18713477f, -0.20707777f, 0.13263644f, -0.16896260f, 0.10503351f, 0.05954111f, 
    -0.38242653f, -0.15304795f, -0.18346491f, 0.09074305f, 0.18313108f, 0.09235124f, -0.02672098f, 0.16337627f, 
    -0.12633537f, -0.09245824f, -0.00958153f, 0.04398984f, 0.16443965f, -0.03534173f, 0.06059340f, 0.37394762f, 
    -0.13399786f, -0.11547979f, 0.01914335f, 0.09692620f, -0.13650537f, 0.16035460f, 0.16161186f, 0.15506187f, 
    -0.09174271f, 0.07622671f, -0.15692705f, 0.06795664f, 0.02711678f, -0.02803429f, 0.06370557f, 0.17657003f, 
    -0.06122056f, 0.08699805f, -0.17026584f, -0.00001917f, -0.13005160f, -0.15849341f, 0.02164074f, 0.16113570f, 
    -0.12952782f, -0.15358774f, 0.17472407f, 0.11700407f, -0.01948997f, -0.16670009f, 0.02199119f, -0.09576624f, 
    -0.00798908f, 0.03111725f, -0.18371782f, -0.15711194f, -0.17701483f, -0.14309752f, 0.01046165f, -0.12728272f, 
    0.10323980f, 0.01340705f, 0.05311650f, -0.03934015f, -0.09188535f, 0.09326435f, -0.14808665f, -0.10807884f, 
    -0.02215501f, -0.02640620f, -0.04378120f, -0.08766340f, -0.02376311f, 0.04768737f, 0.06597565f, 0.16972205f, 
    -0.12409668f, -0.10265601f, -0.01629075f, -0.09568591f, -0.00380978f, -0.04692131f, -0.02661222f, -0.04873661f, 
    -0.00591116f, 0.40911198f, 0.07357603f, -0.07297379f, 0.02502439f, -0.05726437f, 0.16268618f, -0.22557189f, 
    -0.04273212f, 0.15745486f, -0.14551875f, -0.42968443f, 0.05868362f, -0.16636056f, -0.17070125f, -0.01009449f, 
    0.09716407f, 0.01115368f, -0.24689613f, -0.15972298f, 0.28861257f, 0.04908386f, 0.14983734f, -0.01330093f, 
    0.10956726f, 0.06331766f, -0.01093272f, 0.04890676f, -0.27145433f, -0.15702911f, 0.07519720f, 0.39672542f, 
    -0.02330461f, -0.36323115f, 0.00592464f, -0.12818033f, 0.25101551f, -0.10923599f, 0.03360603f, 0.18865709f, 
    0.02391156f, 0.25628781f, 0.24779999f, -0.11785176f, -0.06790683f, -0.03406554f, 0.02688177f, -0.14781947f, 
    -0.06621590f, 0.06496908f, -0.25321323f, -0.03843405f, 0.15159474f, 0.13830078f, -0.16418500f, 0.01122016f, 
    0.08853141f, 0.18910256f, -0.06132259f, -0.14783795f, -0.09280752f, 0.17763394f, 0.03014184f, 0.21075524f, 
    -0.01005040f, -0.13284966f, 0.15189463f, -0.10985565f, -0.16655129f, 0.07970747f, 0.05267414f, -0.10968601f, 
    0.14163736f, -0.16994345f, -0.10845081f, -0.02268569f, 0.08259937f, -0.02282286f, 0.16174757f, 0.08227132f, 
    -0.09625268f, 0.14422487f, -0.04336103f, -0.04854404f, 0.02297162f, -0.09886687f, 0.13971320f, 0.16190204f, 
    0.06089986f, 0.01304016f, 0.10999025f, 0.03615976f, -0.13290994f, -0.01202747f, -0.08955156f, -0.15524933f, 
    0.13505104f, 0.03259609f, -0.10511711f, 0.13813521f, -0.12606926f, -0.13224155f, -0.09468625f, 0.02809284f, 
    0.01076349f, -0.01641800f, -0.15351734f, 0.29092833f, -0.02511148f, 0.00197953f, -0.11757670f, -0.08995970f, 
    -0.44254899f, 0.01404417f, 0.40246421f, 0.27417114f, -0.21403328f, -0.01569516f, 0.31702608f, 0.01918363f, 
    0.47072256f, -0.28115237f, -0.03645389f, 0.06698140f, 0.51966727f, 0.15269876f, -0.15626603f, -0.09618342f, 
    -0.16486153f, 0.16425461f, -0.06832682f, 0.05339957f, -0.15196562f, -0.01227746f, 0.13548782f, -0.06186022f, 
    0.10552981f, -0.14705649f, -0.20009328f, -0.13087349f, 0.08282211f, -0.17436692f, -0.15798460f, -0.01316794f, 
    -0.09355273f, -0.09836958f, -0.06435344f, -0.02810823f, -0.00647308f, -0.17032763f, -0.02752978f, -0.11058620f, 
    -0.02646473f, 0.07864691f, 0.16406575f, 0.14884526f, -0.00936401f, 0.03754342f, 0.01361874f, -0.07599854f, 
    0.01039938f, -0.09231421f, -0.00621789f, 0.04231433f, 0.31119841f, 0.10268141f, -0.11348804f, -0.08937378f, 
    0.11471013f, 0.17086540f, -0.48227084f, -0.27065709f, -0.14363705f, 0.01158691f, 0.07397780f, -0.07265663f, 
    0.09670790f, -0.10338091f, -0.19978498f, 0.05663655f, -0.14299627f, 0.10849704f, 0.24256533f, 0.13494322f, 
    -0.16856851f, 0.08542715f, 0.09567767f, -0.00879950f, -0.09823165f, 0.04385357f, -0.11103617f, 0.35445529f, 
    -0.09186618f, 0.35104957f, 0.14572686f, 0.07099614f, 0.13760172f, 0.03656098f, -0.01483830f, -0.09248649f, 
    -0.08370759f, -0.08934257f, 0.05954237f, -0.35160711f, -0.02591382f, 0.06842415f, -0.08944644f, -0.04084882f, 
    0.28207949f, -0.11878823f, -0.28291246f, 0.05374027f, -0.03299534f, -0.09983699f, 0.18858342f, 0.09181646f, 
    -0.11167891f, 0.22932564f, 0.00270486f, 0.11892749f, -0.11448202f, 0.14569338f, -0.08998235f, 0.29422119f, 
    -0.10638168f, -0.10564218f, -0.09468035f, -0.11577071f, -0.18869852f, 0.17234588f, -0.13864806f, 0.00782095f, 
    0.02089554f, -0.10263101f, 0.01612484f, -0.03916819f, 0.02066030f, -0.07306531f, 0.02373970f, -0.14963087f, 
    -0.12579674f, 0.12852803f, 0.14149836f, -0.11496709f, -0.19579767f, 0.02711281f, -0.02704409f, 0.02746999f, 
    -0.01914832f, 0.03290608f, 0.16942333f, -0.12119859f, 0.11065406f, -0.10798609f, -0.11575840f, -0.11022994f, 
    0.12585765f, 0.20622522f, -0.09393240f, 0.11982888f, -0.03290311f, -0.05004432f, 0.12006045f, -0.10550150f, 
    -0.09565295f, -0.16289324f, 0.40284517f, 0.26860279f, -0.17102085f, -0.15452705f, -0.16229641f, -0.05913558f, 
    0.05273124f, 0.08325383f, -0.21947566f, 0.09744229f, -0.49212608f, -0.01319523f, 0.40939075f, 0.10865977f, 
    0.42878950f, 0.09806756f, 0.03709135f, 0.16889100f, 0.03609007f, 0.14832793f, 0.11340892f, 0.19367725f, 
    -0.14687602f, 0.17940074f, -0.02908960f, 0.12695776f, 0.15786497f, -0.11994905f, 0.05252327f, 0.05109816f, 
    0.05451438f, 0.22274303f, 0.26455384f, -0.01866752f, 0.01399728f, -0.03616492f, 0.17085870f, -0.12279986f, 
    -0.08270572f, -0.06877050f, -0.33410802f, -0.16268331f, 0.12473135f, 0.02451507f, 0.09407949f, 0.16836147f, 
    -0.20045029f, 0.29306132f, 0.14309219f, -0.11207991f, -0.25044298f, -0.13156597f, 0.03736873f, 0.02329586f, 
    -0.05079414f, 0.14250603f, -0.02674841f, -0.02134316f, -0.20653735f, 0.15328248f, -0.11451119f, 0.10216081f, 
    -0.03586658f, -0.06348498f, 0.36866483f, 0.31688762f, -0.12755741f, -0.10930371f, -0.04367214f, -0.07630718f, 
    -0.02983975f, 0.09585307f, -0.13186567f, 0.22233175f, -0.14799513f, -0.04526177f, 0.23864746f, -0.11031567f, 
    0.06404968f, 0.07810864f, 0.03098940f, -0.04251365f, 0.10881913f, -0.08312144f, 0.08114320f, -0.41029224f, 
    -0.03216444f, 0.15598366f, 0.00578346f, 0.02348164f, 0.03877141f, -0.17132118f, 0.09024175f, 0.18122223f, 
    -0.06771630f, 0.14963374f, 0.10626010f, 0.28929284f, -0.04347641f, 0.03315489f, -0.09501085f, -0.08645531f, 
    -0.09897112f, -0.15402713f, 0.12890829f, -0.15901095f, 0.25809526f, -0.16775440f, -0.17251760f, -0.16264449f, 
    -0.07615323f, -0.54187816f, -0.16929783f, -0.08349743f, -0.42790103f, -0.15058161f, -0.11122164f, 0.17361642f, 
    0.08507536f, -0.18719538f, -0.08985991f, -0.14963672f, -0.18062559f, 0.12537019f, 0.09073170f, 0.10298941f, 
    0.13279180f, 0.00301365f, -0.07023194f, -0.30246323f, -0.17707397f, 0.11006340f, -0.01514286f, -0.02717708f, 
    -0.02472619f, -0.16128993f, 0.24923772f, 0.21312216f, -0.10362954f, 0.09362572f, 0.18171489f, -0.06347393f, 
    0.49346957f, -0.14999123f, 0.07933739f, 0.06048140f, 0.23503816f, -0.11758794f, 0.00138753f, 0.28939891f, 
    0.05496630f, 0.20249771f, 0.15998863f, 0.15447082f, 0.29568839f, -0.07534727f, -0.13672225f, 0.17940961f, 
    -0.09740020f, 0.19346781f, -0.42938006f, -0.32295164f, 0.02992209f, 0.06010434f, -0.13245319f, -0.06741162f, 
    -0.09045628f, 0.13693927f, -0.38874978f, -0.07876563f, -0.02966990f, -0.02617759f, 0.31785983f, 0.13165404f, 
    -0.05145660f, 0.33698776f, 0.13946570f, 0.04286197f, 0.32217517f, -0.06432062f, -0.09604557f, -0.14212587f, 
    0.09506882f, 0.16468485f, -0.09821140f, -0.09014651f, 0.07812703f, 0.00906215f, -0.03800114f, -0.11042942f, 
    -0.13666949f, -0.29695255f, 0.18097655f, 0.31860170f, -0.01208042f, -0.17363173f, -0.01111272f, -0.01772266f, 
    -0.11472037f, -0.12596300f, -0.10207647f, 0.08922607f, -0.31055611f, -0.16448164f, 0.31921348f, 0.01007525f, 
    0.05783013f, -0.06540192f, 0.04601908f, 0.06544231f, 0.04273140f, 0.02753024f, 0.11185725f, 0.11811028f, 
    -0.11515421f, 0.25602686f, -0.07320970f, -0.05249906f, -0.18106909f, 0.08706972f, 0.04232047f, 0.23672196f, 
    0.01203484f, -0.18075402f, 0.10518307f, 0.12255504f, 0.15842377f, -0.06958719f, -0.02282589f, 0.10531034f, 
    -0.11256649f, 0.15975980f, 0.15544406f, 0.05495372f, -0.18190205f, 0.07599171f, -0.10969359f, -0.06440172f, 
    0.23648947f, -0.12990673f, 0.08919283f, -0.02965891f, 0.16908000f, -0.12863740f, 0.07580136f, -0.29685563f, 
    0.00229877f, 0.08986859f, -0.15659466f, 0.16280532f, 0.08342119f, 0.01014990f, -0.07604046f, -0.01991678f, 
    0.05668171f, 0.41438234f, -0.22627279f, 0.03456306f, 0.00707977f, 0.07905564f, 0.03517625f, -0.10990631f, 
    0.00671598f, -0.16073225f, -0.01722137f, -0.25387296f, 0.41816321f, 0.12098766f, 0.26798102f, -0.16143146f, 
    -0.05704208f, 0.28374583f, 0.14478321f, -0.05259029f, -0.34412500f, -0.04608609f, -0.10176552f, -0.08841234f, 
    -0.13427942f, 0.15979007f, -0.06481079f, 0.00940857f, 0.05668694f, 0.11873590f, 0.02862127f, 0.22035502f, 
    -0.19551235f, 0.01621851f, -0.30936453f, -0.09719621f, -0.01175615f, -0.06958119f, -0.14141256f, 0.03908024f, 
    -0.32855159f, -0.04937435f, 0.08100373f, 0.24724887f, -0.04726158f, -0.12460836f, 0.28424305f, 0.05584995f, 
    0.29654139f, 0.07165277f, 0.01066819f, 0.01046241f, 0.28932297f, 0.01712698f, -0.05231657f, -0.25956842f, 
    0.01187903f, -0.60928005f, -0.13850266f, -0.03754528f, 0.22456560f, -0.12915058f, -0.10717304f, 0.01409655f, 
    0.07146797f, 0.33633721f, -0.09149875f, 0.29107037f, -0.16582991f, 0.08003605f, 0.00371752f, -0.09592654f, 
    0.20573676f, 0.03472263f, 0.16772783f, -0.11217651f, 0.01248312f, 0.01470031f, -0.02918214f, -0.07582358f, 
    0.10735301f, -0.00163471f, -0.01288141f, -0.02736250f, 0.30530035f, -0.04373140f, 0.04431905f, 0.08440758f, 
    -0.09159660f, 0.17033599f, -0.07069585f, 0.07772901f, -0.24990205f, -0.13668478f, -0.04292588f, -0.07825020f, 
    0.01822143f, 0.13629296f, 0.21784607f, 0.08972467f, 0.02546330f, -0.05495917f, 0.05241236f, -0.02348247f, 
    0.50980866f, -0.14152509f, -0.25828671f, 0.13041374f, -0.12977621f, -0.10935763f, 0.09577636f, 0.04974287f, 
    -0.32451966f, 0.36391032f, 0.03485357f, 0.06250516f, 0.47766051f, 0.15661845f, -0.03907168f, -0.00288578f, 
    0.02761941f, 0.22547533f, 0.13999018f, 0.11245306f, 0.10008219f, 0.09241356f, -0.01622564f, -0.21117072f, 
    0.06899779f, -0.24098147f, -0.21695295f, 0.59193343f, 0.13234173f, -0.00175107f, -0.03224300f, 0.02971014f, 
    0.20119123f, -0.05095948f, 0.03637581f, 0.01179457f, -0.04648905f, -0.16865078f, 0.12517652f, -0.02907943f, 
    -0.22549535f, -0.25222772f, -0.15659545f, 0.09443635f, 0.01228247f, 0.17812613f, 0.09922940f, -0.12333825f, 
    0.08893190f, -0.32418770f, 0.05840913f, 0.16597769f, -0.15912607f, 0.03208698f, 0.02847401f, 0.40387389f, 
    0.13639277f, 0.26830772f, 0.19136748f, -0.27305865f, 0.08738795f, -0.12825139f, 0.02441552f, -0.09997900f, 
    0.50689715f, 0.16384384f, 0.07734056f, 0.09862108f, 0.17647247f, -0.07650070f, 0.22744350f, 0.13864423f, 
    -0.12620974f, 0.34281939f, 0.06297527f, -0.08481465f, 0.07617182f, 0.11644042f, 0.06224857f, 0.05862970f, 
    0.12652087f, -0.15793334f, 0.12312271f, 0.11629148f, -0.20002207f, -0.15601231f, -0.02122286f, 0.09378175f, 
    -0.09398267f, -0.04039339f, 0.06653298f, 0.10701035f, -0.05159207f, -0.07240994f, 0.14927095f, -0.04732539f, 
    0.01485110f, -0.02798827f, -0.08705150f, -0.15826267f, -0.12213767f, 0.06816114f, -0.02328757f, -0.03992253f, 
    -0.06279089f, -0.20441246f, 0.07383230f, 0.11658514f, -0.03039990f, -0.11164713f, 0.09009919f, 0.00846697f, 
    0.01980832f, 0.14940757f, 0.03457184f, -0.09318091f, -0.25635824f, -0.02302055f, -0.13646361f, 0.07016367f, 
    -0.11143083f, 0.12267952f, 0.22071120f, 0.11053067f, 0.08634925f, -0.03663151f, -0.07260684f, 0.09189950f, 
    0.37271965f, -0.09311465f, -0.04302177f, -0.08254832f, 0.00986422f, 0.00647952f, -0.01964660f, 0.11107282f, 
    -0.01940664f, 0.16559584f, 0.12940016f, -0.06709458f, 0.36715004f, -0.12438662f, 0.15548700f, -0.07189934f, 
    -0.08094458f, 0.26413399f, -0.13344772f, -0.12961669f, 0.10044532f, -0.12298745f, -0.15816304f, -0.38853776f, 
    -0.06970514f, -0.21291433f, -0.37307933f, -0.44373813f, -0.02236101f, -0.16235127f, 0.15630423f, -0.12555736f, 
    0.14935876f, -0.10926522f, -0.24909674f, 0.12914526f, 0.28891215f, 0.08188123f, -0.00793688f, 0.05579223f, 
    -0.24121322f, 0.24216174f, -0.06963120f, -0.12728359f, -0.08615763f, -0.00533927f, 0.04721785f, 0.36333537f, 
    -0.00311108f, 0.43247095f, 0.15589805f, 0.04146270f, 0.21122918f, -0.07272445f, 0.04761810f, 0.30448255f, 
    -0.07848885f, -0.06376768f, -0.21931931f, -0.09754948f, -0.15758936f, 0.04218928f, -0.12830944f, 0.04899079f, 
    -0.50390542f, -0.02030796f, -0.38142005f, 0.18229116f, -0.12336344f, 0.09129042f, 0.02735120f, -0.02641901f, 
    0.25664258f, 0.30741119f, -0.13807236f, 0.05950756f, -0.06307006f, -0.06430826f, 0.14653350f, 0.05775861f, 
    -0.01910377f, 0.03310894f, 0.15692681f, -0.09903679f, -0.17668955f, 0.00116456f, -0.12815483f, 0.08953765f, 
    0.08060499f, -0.05135568f, 0.03604887f, -0.13618395f, -0.05631068f, -0.05843559f, -0.12455799f, -0.15753090f, 
    -0.13782902f, 0.16304696f, -0.19465120f, -0.13659029f, -0.18144900f, -0.11134898f, -0.10267917f, 0.04255957f, 
    0.12802947f, -0.17468989f, -0.16633303f, 0.08297277f, -0.03866826f, 0.07111929f, 0.16933908f, 0.03654694f, 
    -0.12935117f, 0.37454918f, -0.05048366f, 0.02164785f, 0.04568677f, 0.04886807f, -0.12649937f, -0.21940269f, 
    0.00094294f, 0.30571717f, -0.50911212f, -0.39213359f, 0.07930489f, 0.14584634f, -0.06604431f, -0.02679147f, 
    -0.16404602f, -0.13677871f, 0.23633151f, -0.14675485f, 0.32613540f, 0.13757369f, 0.36676013f, -0.03592897f, 
    0.28584790f, -0.08908968f, -0.09471457f, 0.05950011f, 0.10577612f, 0.10472550f, -0.08041721f, -0.27781999f, 
    0.13389933f, -0.15978402f, -0.04936599f, -0.10420509f, 0.32084116f, -0.09858919f, -0.08851190f, -0.21134882f, 
    -0.04148371f, -0.12722008f, -0.29727611f, 0.17645271f, -0.18304107f, 0.01485461f, 0.13811560f, -0.08838453f, 
    -0.16229635f, 0.00903652f, -0.14251977f, -0.11840056f, -0.03068395f, 0.17555954f, 0.33525354f, -0.09696139f, 
    0.20089154f, 0.33565751f, -0.11528493f, -0.00311638f, 0.21960913f, -0.09447899f, 0.03062672f, 0.18596807f, 
    0.02416748f, -0.09068802f, -0.08902700f, 0.06314623f, -0.18667851f, 0.01527875f, 0.00251258f, -0.40247652f, 
    -0.06569964f, -0.13182160f, 0.07544730f, 0.02757592f, -0.16018404f, -0.09321991f, -0.04506909f, -0.01558390f, 
    0.18620403f, 0.12076336f, 0.44237688f, 0.18162657f, 0.04703604f, 0.07968917f, 0.12800926f, 0.01459399f, 
    0.31811258f, 0.03873611f, 0.04885268f, 0.02727182f, 0.39774147f, 0.02755543f, -0.10107858f, -0.00220330f, 
    0.07884337f, -0.13723916f, -0.15687424f, -0.01484064f, -0.09950099f, -0.14090447f, 0.04533499f, 0.15329461f, 
    0.15691967f, -0.00691868f, 0.01604213f, -0.25690183f, -0.04884166f, 0.16830862f, 0.08318552f, -0.04690518f, 
    0.54940796f, -0.16189390f, -0.31401756f, 0.11411741f, -0.00615460f, 0.10011785f, 0.07968175f, -0.15013896f, 
    -0.28384623f, 0.05688679f, 0.06106130f, -0.01788158f, -0.00367049f, 0.08625175f, -0.02144075f, 0.30776644f, 
    0.03659621f, -0.16478850f, 0.13195567f, -0.05227601f, 0.22876702f, 0.02436714f, -0.15436281f, 0.05814157f, 
    -0.01926901f, 0.34158108f, -0.23472156f, -0.29974735f, -0.00393603f, 0.13555266f, 0.16000734f, 0.13801225f, 
    -0.06276664f, -0.08452106f, 0.38137594f, -0.18453203f, 0.19713174f, 0.13608393f, 0.03656951f, -0.05372608f, 
    0.21722646f, 0.32881427f, -0.14024100f, 0.06348088f, -0.22078754f, 0.03992244f, -0.12214347f, -0.13686086f, 
    0.02701154f, -0.12527050f, 0.17780478f, 0.07423206f, 0.02572188f, -0.08833378f, -0.06263535f, 0.44559035f, 
    -0.02600302f, 0.19141509f, 0.32345727f, -0.20193228f, 0.02413465f, -0.09213755f, 0.05881897f, 0.05319265f, 
    0.01393830f, -0.14637767f, -0.09759378f, 0.27964824f, -0.20491488f, 0.14095090f, 0.30252224f, 0.09002627f, 
    0.21830291f, -0.19199449f, 0.11982565f, 0.04189793f, -0.10593179f, 0.17059426f, -0.12994283f, -0.06783740f, 
    0.00941909f, 0.30047965f, -0.00261530f, 0.06502248f, -0.00295403f, -0.02304736f, 0.10378487f, -0.07619161f, 
    -0.03844591f, -0.13543418f, -0.12347598f, -0.04153542f, -0.02927137f, 0.01579853f, 0.14483503f, -0.02971608f, 
    0.15379548f, -0.01381052f, -0.33246535f, 0.16238138f, -0.22375281f, 0.07299142f, 0.27656150f, 0.15421456f, 
    -0.11037324f, 0.43946782f, 0.04056980f, 0.09998373f, 0.36777896f, -0.13071427f, 0.02073032f, 0.12601741f, 
    0.03747961f, 0.11200762f, 0.01972550f, 0.09091559f, -0.22962758f, 0.11806089f, -0.14186142f, 0.08994192f, 
    0.11761291f, 0.04427842f, 0.00638015f, -0.17592114f, -0.09745130f, 0.15669526f, 0.01018540f, -0.06901276f, 
    -0.12642144f, -0.13794015f, 0.43619496f, 0.15414914f, 0.15338403f, 0.03285427f, 0.13425133f, 0.04600763f, 
    0.29227051f, 0.05082536f, -0.12035380f, -0.07802575f, 0.27326131f, -0.04769267f, -0.16230369f, -0.29903415f, 
    0.00364718f, -0.10334501f, -0.08149369f, -0.11309976f, 0.38216820f, -0.09031225f, 0.04469883f, 0.01661251f, 
    0.11710902f, 0.02078331f, 0.13662657f, 0.14257888f, -0.14593048f, -0.16276132f, -0.11929886f, -0.00412231f, 
    -0.31894863f, 0.17489305f, -0.22775023f, -0.00372542f, 0.19206877f, -0.13313916f, -0.18921851f, 0.01875889f, 
    -0.04268307f, 0.03966562f, 0.09893890f, 0.15345399f, -0.34631827f, 0.11234121f, 0.14341137f, 0.32727861f, 
    0.05040154f, -0.14962779f, -0.08273073f, -0.10016599f, 0.12755634f, 0.07508136f, -0.01560568f, -0.13312404f, 
    0.14891224f, 0.26365754f, 0.01353809f, 0.30404115f, 0.08904946f, -0.04968217f, -0.11971745f, 0.17476802f, 
    -0.24810621f, -0.01539675f, 0.35802418f, -0.17602506f, 0.31711742f, -0.18256344f, 0.01294348f, -0.16163176f, 
    -0.17525281f, -0.23635963f, -0.13971719f, 0.09678049f, -0.00821116f, -0.08990615f, -0.14067926f, 0.00966882f, 
    0.12176085f, 0.39047641f, -0.04948660f, -0.06390798f, -0.11148366f, -0.08197355f, -0.09225964f, -0.27119845f, 
    0.10990881f, 0.12821555f, 0.03631986f, -0.20608376f, -0.08530365f, -0.04583098f, -0.04411338f, -0.16580008f, 
    0.40606442f, 0.02225514f, -0.31133491f, 0.00243930f, -0.00189673f, -0.06358581f, 0.35452199f, 0.15652815f, 
    0.31323141f, -0.07789975f, -0.15780483f, 0.01859852f, -0.24948849f, 0.02185982f, 0.14192212f, 0.24483863f, 
    -0.13830268f, -0.24768209f, -0.15790501f, -0.09508674f, -0.02543111f, -0.11787631f, 0.13687313f, -0.21296591f, 
    -0.02038494f, 0.00035581f, 0.13291399f, -0.21588796f, 0.12577732f, 0.05933066f, 0.04850094f, 0.17580847f, 
    0.53042197f, 0.14159518f, 0.04117321f, 0.11228918f, -0.09304415f, 0.14183921f, -0.15781224f, -0.10034462f, 
    -0.12706907f, 0.38812873f, -0.14704844f, -0.02038822f, 0.13516760f, 0.05063158f, 0.03597617f, 0.30885816f, 
    -0.02681979f, 0.01370879f, -0.01135460f, -0.12414182f, 0.09286720f, -0.13995063f, -0.10619406f, 0.17239103f, 
    -0.06765682f, -0.06057428f, 0.25134146f, 0.29572684f, -0.13115151f, 0.01804376f, 0.16597259f, -0.14281167f, 
    -0.32230598f, 0.08553817f, 0.08098407f, 0.28031543f, -0.28629041f, -0.01548973f, -0.21719195f, 0.06888524f, 
    0.22399701f, -0.20217749f, 0.00463003f, 0.01558816f, -0.03373940f, -0.06648649f, -0.07235228f, 0.17799914f, 
    -0.05495515f, -0.22945622f, -0.01037106f, 0.04900871f, -0.14220354f, 0.08537234f, -0.14392541f, 0.42326570f, 
    -0.08440182f, 0.27577239f, 0.22431073f, -0.26720157f, -0.05857391f, -0.13362889f, -0.08659931f, 0.01323531f, 
    -0.17075373f, -0.10034513f, 0.42090017f, 0.13927263f, -0.29118949f, -0.01496881f, 0.16291781f, -0.17571568f, 
    0.20690650f, 0.33005539f, -0.11039162f, 0.03254654f, -0.01170052f, 0.01601110f, -0.05192373f, -0.02398423f, 
    -0.12387004f, 0.04958002f, -0.04232161f, -0.13809456f, 0.38793337f, -0.11828434f, 0.08922200f, -0.03341495f, 
    -0.14939353f, 0.27971104f, -0.15444461f, 0.10594435f, 0.03797533f, 0.17986330f, -0.09314997f, 0.09313727f, 
    0.09318835f, 0.10141166f, -0.18059605f, -0.19507305f, 0.20584136f, -0.07649510f, -0.08862821f, -0.01823884f, 
    0.04332745f, -0.05517388f, -0.12779544f, -0.15394318f, -0.32647586f, -0.14858446f, -0.05027311f, 0.17107938f, 
    0.03006027f, -0.22153163f, 0.10733181f, -0.07064965f, 0.25175703f, -0.07657973f, -0.05261458f, 0.50850534f, 
    0.17075296f, 0.25877956f, 0.13569142f, -0.15102577f, -0.07210201f, 0.01432177f, 0.17738351f, 0.12739067f, 
    -0.35720530f, 0.11520029f, -0.22983903f, 0.34551322f, -0.27545720f, -0.16157831f, 0.19546901f, -0.01452275f, 
    0.28939494f, 0.00812834f, 0.13786060f, -0.06934499f, -0.04338194f, -0.02942004f, -0.00704537f, -0.12190139f, 
    -0.15961543f, -0.09616514f, 0.06130331f, -0.08208599f, -0.20694700f, 0.01901484f, -0.15106189f, 0.06384362f, 
    0.00596046f, -0.28874633f, 0.40707526f, 0.34243378f, 0.14425482f, 0.17399693f, -0.16752979f, -0.11702516f, 
    0.25164697f, -0.10142898f, 0.18104118f, 0.38724062f, -0.30774266f, -0.11160773f, 0.01057736f, -0.05076993f, 
    -0.07577972f, 0.07703433f, -0.11599768f, -0.07745621f, 0.29684010f, -0.08218009f, 0.17810133f, 0.02532434f, 
    -0.01275325f, -0.18820463f, 0.11992838f, 0.03127645f, -0.11040598f, 0.07181920f, 0.12103728f, -0.12566298f, 
    0.13204630f, -0.09407657f, 0.17895180f, 0.23236680f, 0.16003028f, 0.04408075f, 0.16674773f, -0.17467934f, 
    0.31214187f, 0.06059795f, 0.31812182f, 0.37504196f, -0.11135942f, 0.15481058f, -0.22659256f, 0.05139765f, 
    -0.07909259f, -0.21196003f, 0.16551264f, -0.02011986f, -0.07552961f, 0.02445823f, 0.09680969f, 0.40274030f, 
    -0.06727414f, -0.22124925f, -0.04813157f, 0.13846083f, -0.23119557f, -0.01853207f, -0.00978175f, -0.12773131f, 
    -0.16646828f, -0.02504259f, 0.10002525f, -0.25546560f, 0.06816712f, 0.03866459f, -0.15924658f, 0.01918164f, 
    -0.22714530f, -0.07491431f, 0.17573200f, 0.20643075f, -0.21579620f, -0.03291738f, 0.32538822f, 0.05875465f, 
    0.36978284f, 0.20258096f, -0.06948336f, 0.06287466f, -0.05965126f, -0.14149339f, 0.02000201f, -0.27561107f, 
    0.15382950f, -0.02958361f, -0.05002275f, 0.12584141f, -0.01035231f, 0.10637568f, -0.11447065f, -0.14360252f, 
    -0.13006809f, 0.08153597f, -0.07441246f, 0.02012240f, -0.18124074f, 0.06380443f, -0.15141793f, -0.07985979f, 
    -0.01490298f, -0.11701550f, 0.01462427f, -0.08049043f, -0.13279669f, 0.04572691f, -0.09760635f, -0.02998819f, 
    -0.09164237f, -0.14072539f, -0.10404053f, -0.01105143f, 0.09471593f, -0.10112236f, -0.17545478f, 0.07774758f, 
    0.15930572f, -0.13257036f, -0.05288571f, -0.04116838f, -0.07280923f, -0.07509765f, -0.17101677f, 0.08161293f, 
    -0.12596697f, -0.10509273f, -0.05121065f, -0.01008957f, 0.08190066f, -0.05587674f, -0.13411640f, 0.00146269f, 
    -0.11622531f, -0.08484536f, 0.08568478f, -0.09523468f, -0.14970009f, 0.06921892f, 0.05553230f, 0.03266272f, 
    -0.15325199f, -0.04367200f, -0.05953505f, 0.12898508f, 0.04750803f, 0.04770090f, -0.09829115f, 0.06121138f, 
    0.06647231f, 0.07290754f, -0.01381417f, -0.04299746f, -0.21797447f, 0.13577671f, 0.00814987f, 0.25647193f, 
    -0.13194038f, -0.07197136f, 0.11196417f, 0.15886761f, 0.01897086f, 0.11891786f, -0.15467808f, -0.12517016f, 
    0.18197599f, 0.03345909f, 0.07271262f, 0.39103279f, -0.33587706f, -0.12555605f, -0.03150665f, 0.12282494f, 
    -0.03470931f, 0.46899185f, 0.15138637f, -0.06077508f, 0.27340898f, -0.07098814f, 0.14821076f, -0.18362552f, 
    -0.04158756f, 0.31373796f, -0.08814731f, 0.16462147f, -0.04976548f, -0.01632518f, -0.12605867f, -0.29671741f, 
    0.12520744f, -0.09612893f, 0.05970443f, 0.02541883f, -0.03113583f, -0.11602186f, -0.16290095f, -0.02087794f, 
    0.46917254f, -0.04184574f, -0.15443107f, -0.07445818f, 0.02707130f, -0.10232608f, 0.02702405f, 0.04695670f, 
    0.02423026f, 0.01916211f, 0.14625148f, 0.12123401f, 0.10329908f, 0.10299992f, 0.12112255f, 0.20181240f, 
    0.12654014f, 0.48059425f, -0.02001322f, 0.04975117f, -0.14705816f, -0.03766039f, 0.14610903f, 0.07946587f, 
    0.11589982f, 0.20019756f, -0.30403563f, -0.01378077f, 0.05693588f, 0.01593941f, -0.16776066f, -0.04877815f, 
    0.01678761f, -0.02550464f, -0.24103718f, 0.05440157f, -0.04231908f, 0.03750337f, 0.32215169f, -0.09597430f, 
    0.04469791f, 0.19137172f, 0.02916896f, 0.03894323f, 0.31001768f, 0.16761139f, 0.15983750f, -0.31146890f, 
    -0.08061086f, 0.07212811f, 0.02567833f, 0.00934802f, -0.15312450f, 0.08848073f, 0.13373016f, 0.25586691f, 
    0.11925580f, -0.04982764f, 0.10511915f, -0.38112974f, 0.03952872f, -0.08041485f, 0.09398446f, 0.13709560f, 
    -0.19195040f, -0.01490327f, 0.03323675f, 0.25982299f, -0.18072605f, 0.16497451f, 0.34757674f, -0.11459137f, 
    0.35607043f, 0.22628435f, -0.09959994f, 0.15606883f, 0.28971770f, 0.04009395f, -0.15749422f, 0.14565010f, 
    0.00916772f, 0.08113261f, 0.14351608f, 0.08609269f, -0.08237030f, -0.07707501f, 0.03771133f, -0.15662445f, 
    -0.05278942f, -0.04900722f, -0.19276342f, -0.16324110f, -0.06705862f, -0.00691893f, 0.00613822f, -0.12991254f, 
    -0.06094244f, 0.08694454f, 0.03554133f, -0.10935094f, -0.17297298f, -0.16379315f, -0.04276011f, -0.07095557f, 
    0.12572633f, 0.01455060f, 0.05319123f, 0.08125731f, -0.11685397f, 0.05124233f, -0.17195533f, 0.07490503f, 
    0.09012949f, -0.05692366f, 0.04894584f, -0.14242712f, 0.26482874f, -0.00055015f, -0.12680247f, 0.09127414f, 
    0.11040378f, 0.06389011f, 0.28627855f, 0.48666340f, 0.05585584f, -0.11723062f, 0.04048112f, 0.09269985f, 
    0.01869248f, -0.15775923f, 0.36380517f, -0.23700351f, -0.04399965f, -0.10877391f, 0.04467496f, -0.10192092f, 
    0.02171085f, -0.48468274f, -0.00734444f, -0.04825641f, -0.33080095f, -0.05286054f, 0.00867477f, 0.01832538f, 
    -0.05318654f, -0.19174407f, 0.14676096f, -0.06289756f, 0.01626896f, -0.11451013f, 0.00496406f, -0.04200275f, 
    0.17882319f, 0.51120698f, 0.12196519f, -0.02683811f, 0.02459977f, 0.12460790f, 0.10526547f, -0.03704067f, 
    0.40724593f, 0.00814752f, -0.06172089f, -0.13770780f, -0.01054687f, 0.14006577f, 0.33158749f, 0.16771005f, 
    0.08511920f, -0.06370637f, -0.15874650f, 0.15414408f, 0.11396918f, -0.13210376f, 0.10011472f, -0.38573545f, 
    0.06749269f, 0.42458266f, 0.11662884f, -0.10430176f, -0.05547668f, 0.13799368f, 0.10725111f, -0.10285336f, 
    -0.09889399f, -0.03761111f, -0.36542100f, -0.09979172f, -0.10425209f, 0.16505226f, 0.13898183f, 0.00128135f, 
    -0.20095050f, -0.10823497f, 0.32164964f, -0.20161077f, 0.15988714f, 0.03968908f, 0.39869887f, -0.10826412f, 
    0.16876718f, 0.20627011f, 0.12645142f, 0.16380547f, 0.19629329f, -0.07262834f, -0.10465363f, -0.13900538f, 
    0.15289560f, -0.07906535f, -0.11046135f, -0.14257833f, -0.11544205f, 0.08546124f, -0.14764450f, -0.13130866f, 
    0.12023661f, -0.10104803f, -0.11843426f, -0.10605064f, -0.03873966f, 0.08534520f, -0.06384721f, 0.04624328f, 
    0.08284932f, -0.04043707f, 0.05202765f, -0.11673121f, -0.17650527f, -0.07531420f, -0.18593740f, -0.09198665f, 
    0.04953728f, 0.09397063f, -0.09905098f, 0.08105893f, 0.03048289f, -0.14936721f, 0.17081268f, -0.02774077f, 
    0.11573719f, 0.25309879f, 0.05779735f, -0.13720602f, -0.28426528f, -0.16157417f, 0.05609671f, -0.11941313f, 
    0.03694733f, -0.19312876f, 0.20049372f, -0.09206488f, 0.14716299f, 0.15999241f, 0.06507448f, -0.10811374f, 
    0.57757020f, -0.13449784f, 0.18614037f, 0.09878792f, 0.02408810f, 0.12757292f, 0.12448225f, 0.16186570f, 
    -0.25097477f, 0.20388995f, -0.09900391f, 0.03416027f, 0.01293655f, 0.17435460f, 0.02394865f, 0.07295750f, 
    -0.04545255f, 0.26774618f, -0.02041654f, -0.02606345f, 0.13798009f, -0.11158712f, 0.17140587f, 0.01654794f, 
    -0.11154430f, -0.12308925f, 0.11804834f, 0.32590640f, 0.01720059f, 0.10954084f, -0.00008955f, 0.03590522f, 
    -0.02853194f, 0.15933646f, 0.02981700f, 0.02488932f, 0.32292706f, -0.04735669f, -0.22107477f, -0.18010993f, 
    -0.33424836f, 0.15269820f, 0.02156049f, 0.13780357f, 0.02594383f, -0.06778375f, 0.01698879f, 0.21401212f, 
    -0.01900393f, 0.05024825f, 0.11622000f, -0.17290999f, 0.38594022f, 0.04205975f, 0.05619255f, -0.17295797f, 
    -0.04156895f, -0.14927606f, -0.20709080f, 0.21245620f, -0.11015850f, -0.12086341f, 0.02029841f, -0.05432410f, 
    -0.12257847f, 0.00345864f, -0.11309333f, 0.06105988f, -0.02610290f, -0.15708108f, -0.09192453f, 0.03398836f, 
    -0.33053160f, 0.12057308f, -0.06179650f, 0.06180718f, 0.25968239f, -0.09188749f, -0.13638015f, 0.25466943f, 
    -0.01395971f, -0.05437431f, 0.14443792f, 0.01954448f, -0.15630098f, 0.08761719f, -0.14594243f, -0.19340107f, 
    0.06308537f, -0.12763375f, -0.13594417f, -0.09182749f, -0.05661244f, -0.07830739f, -0.04372611f, -0.06561904f, 
    0.08501924f, 0.02846914f, -0.03322175f, -0.06146636f, -0.15236302f, -0.14008467f, 0.07346697f, 0.14059027f, 
    -0.01463456f, -0.02117259f, -0.15239657f, 0.06238241f, -0.14184062f, -0.12972371f, 0.05258627f, 0.06469034f, 
    -0.04173834f, -0.00967153f, 0.08119971f, -0.02699343f, 0.30299124f, -0.00350228f, 0.13299026f, 0.13157709f, 
    0.06150362f, -0.01223142f, 0.09563345f, -0.24313855f, 0.16558777f, 0.11240879f, -0.13686927f, 0.04027940f, 
    0.06542437f, 0.13730814f, -0.46727413f, 0.08622584f, 0.13721143f, -0.10472117f, -0.33559304f, -0.11897458f, 
    0.04196417f, 0.27850795f, -0.15151082f, -0.10243358f, 0.20295373f, -0.10821924f, -0.15289050f, 0.27274853f, 
    -0.15385284f, -0.26516822f, -0.14403321f, -0.07856012f, 0.07409452f, -0.06667028f, -0.01730050f, 0.33815804f, 
    0.06518749f, -0.21866842f, -0.02135735f, -0.42022747f, -0.03853586f, -0.14297207f, 0.06257681f, 0.02029870f, 
    0.25286472f, -0.11959247f, 0.37217996f, 0.22616962f, 0.01413640f, 0.08284119f, -0.01967286f, 0.01236083f, 
    0.10741626f, 0.19302355f, -0.01692308f, -0.16831778f, -0.36660448f, -0.17005965f, 0.14400208f, -0.09915067f, 
    0.07676236f, 0.10251104f, 0.12605911f, -0.13863835f, -0.07142404f, 0.15264751f, 0.00210451f, 0.16019829f, 
    0.11530352f, 0.26540762f, 0.49512491f, 0.40868342f, 0.03050906f, 0.05029250f, -0.16153701f, 0.13712509f, 
    -0.02949704f, -0.01597884f, -0.05247310f, 0.20359482f, 0.02841413f, -0.02783115f, -0.05099212f, -0.06667173f, 
    0.24760951f, -0.03841575f, 0.02940632f, -0.04136008f, -0.37147024f, 0.07434605f, 0.12220645f, -0.23827896f, 
    0.06955071f, 0.12958710f, -0.16530955f, -0.07415675f, 0.28749394f, -0.08894290f, -0.08476344f, -0.21739998f, 
    0.18125263f, 0.16699243f, 0.16658309f, -0.10034634f, -0.05876610f, -0.05646181f, -0.03732160f, 0.15311609f, 
    0.29570106f, 0.06792428f, -0.33081564f, -0.24504125f, 0.24925017f, -0.09375183f, -0.12869740f, -0.03610208f, 
    0.03265528f, -0.17411666f, -0.07297207f, -0.02681143f, -0.24727874f, -0.01506689f, 0.03368741f, 0.28800300f, 
    -0.01677520f, -0.01843715f, 0.12188809f, 0.10200532f, -0.06558487f, 0.00773464f, 0.02600463f, -0.10631174f, 
    -0.11934455f, -0.12375566f, -0.13438728f, -0.10758217f, 0.01925869f, 0.06554431f, 0.08288492f, -0.15541911f, 
    0.17662100f, 0.03935892f, -0.08450723f, 0.12725356f, -0.06619830f, -0.14083903f, -0.06550439f, -0.02445642f, 
    -0.11592314f, -0.06203350f, 0.01934964f, 0.14468820f, -0.11023227f, 0.08836213f, 0.02994087f, -0.08216690f, 
    0.05061234f, -0.06668494f, 0.13491471f, -0.08551151f, -0.20453896f, -0.17408423f, 0.01665142f, 0.27381295f, 
    0.07817651f, 0.14733337f, 0.08450022f, -0.16272835f, -0.03294807f, -0.11939809f, 0.09116115f, -0.13060702f, 
    0.20795189f, -0.10090569f, -0.14258848f, 0.17947534f, 0.09424914f, 0.00294718f, -0.03309748f, -0.17114204f, 
    -0.01682439f, 0.44059730f, -0.11438905f, -0.11249921f, -0.14679335f, 0.06267590f, -0.07902818f, -0.09770259f, 
    0.08354014f, 0.25904363f, -0.02738462f, -0.01539890f, -0.08598705f, 0.00794385f, -0.06430673f, 0.26989818f, 
    0.04959253f, 0.28208277f, 0.27016380f, 0.22200306f, 0.11159457f, -0.03175696f, 0.00666695f, 0.14642055f, 
    -0.07992541f, -0.14329086f, -0.02043905f, -0.17068604f, 0.29221421f, 0.13516566f, 0.31050828f, 0.10753257f, 
    0.24489580f, -0.26651600f, 0.07913045f, 0.04804354f, -0.22674979f, -0.15098296f, 0.16974685f, -0.17191114f, 
    0.09601662f, 0.02507456f, -0.08204290f, 0.05334407f, 0.16670768f, -0.08805072f, -0.03890992f, -0.28680718f, 
    0.07035729f, -0.35158470f, -0.19081809f, -0.07247415f, 0.05474972f, 0.04373394f, -0.13264219f, 0.05716168f, 
    -0.13042232f, -0.08896928f, 0.03201821f, 0.10994142f, -0.14904127f, 0.11640303f, 0.30541736f, -0.01867257f, 
    0.43292835f, 0.35871753f, 0.02152420f, -0.06963107f, -0.03078420f, 0.16112426f, -0.09517282f, 0.22303922f, 
    0.02658370f, -0.39269662f, 0.07481317f, -0.05848644f, -0.08314405f, -0.14060505f, 0.13414358f, 0.05453307f, 
    0.03488638f, 0.39162105f, -0.01625002f, -0.03915008f, 0.00406528f, -0.13703303f, 0.00910030f, -0.13315278f, 
    0.48406199f, 0.13509366f, 0.10951095f, -0.16392027f, 0.09488878f, 0.12880713f, 0.37318125f, 0.05917885f, 
    0.27044180f, -0.00274765f, 0.12581512f, -0.04754508f, -0.04522121f, -0.00339815f, 0.01637730f, -0.02616683f, 
    0.08266932f, -0.27804095f, 0.00767748f, 0.01344767f, 0.03759253f, -0.17017432f, -0.10576569f, -0.16079873f, 
    -0.14268060f, 0.21273999f, 0.14035532f, 0.23807204f, -0.13735847f, 0.15859213f, 0.13992085f, 0.07618225f, 
    0.13971028f, -0.01845764f, 0.15683104f, -0.30757442f, 0.39860567f, -0.14210822f, -0.34539419f, 0.01657433f, 
    -0.45992765f, 0.03710977f, -0.05315371f, 0.07152236f, 0.12759805f, -0.09815275f, -0.14043394f, -0.00178903f, 
    0.00050446f, -0.41151357f, 0.01659208f, -0.11906595f, 0.19088010f, -0.01140123f, 0.11778128f, -0.02890020f, 
    -0.12174533f, 0.32324216f, 0.30169407f, 0.10998729f, -0.07060701f, 0.13799684f, -0.05527187f, 0.04948876f, 
    0.13467865f, -0.04671911f, 0.24197344f, 0.01235414f, 0.20632738f, 0.12794480f, -0.04567402f, 0.09083535f, 
    -0.15395953f, -0.33964860f, 0.16576475f, -0.10310997f, 0.26205984f, -0.05651476f, -0.05501930f, -0.17819037f, 
    0.00515946f, -0.03078653f, -0.00299175f, -0.11684522f, 0.33707201f, 0.10388634f, 0.08325016f, 0.13488792f, 
    -0.06745793f, -0.07354987f, 0.15629397f, 0.33794942f, -0.02313349f, 0.12108842f, -0.02235226f, 0.02697870f, 
    -0.32071656f, -0.10112239f, -0.08563786f, 0.11356690f, -0.23551387f, 0.00647470f, -0.15313096f, 0.10260770f, 
    0.40279600f, -0.23104972f, 0.05733198f, -0.03170322f, -0.19350603f, 0.06388804f, -0.05527583f, 0.26097041f, 
    0.14332099f, 0.40691233f, -0.11390849f, 0.15832521f, 0.15135495f, -0.08720829f, 0.06860081f, -0.24908544f, 
    0.12075092f, -0.19429262f, 0.12253947f, 0.11675455f, 0.12781313f, -0.08804300f, -0.06463695f, -0.16185026f, 
    0.18062301f, -0.07612104f, -0.12664491f, 0.19651753f, -0.16527717f, -0.09448345f, -0.19363157f, 0.10661948f, 
    0.11089290f, -0.06731614f, 0.07275551f, 0.17244853f, -0.10431514f, -0.06223972f, 0.05525567f, 0.39236924f, 
    -0.13246360f, 0.13708758f, 0.17531706f, 0.06919432f, 0.02488230f, 0.07050672f, 0.03775188f, -0.12230858f, 
    -0.09794416f, -0.04789654f, -0.07199620f, -0.19408801f, 0.16102476f, 0.00881107f, 0.12012240f, -0.09113061f, 
    0.07390042f, 0.12502070f, 0.06340768f, -0.03762357f, -0.05697836f, 0.13384718f, -0.18329152f, -0.06236669f, 
    -0.07762705f, -0.11090679f, -0.14291613f, 0.09587097f, -0.15429981f, 0.02366531f, 0.04111122f, -0.16081659f, 
    0.08463140f, -0.01228188f, 0.03921956f, 0.14318126f, -0.15917641f, -0.10357510f, -0.07039276f, -0.06132094f, 
    0.15695031f, 0.11929169f, -0.11468477f, -0.08881004f, 0.02332712f, -0.05100521f, 0.00280371f, -0.06235179f, 
    -0.14214124f, -0.03028000f, -0.11075918f, -0.12554467f, 0.06781042f, 0.15970625f, -0.11525877f, 0.09622083f, 
    0.05340052f, -0.02460175f, -0.16517809f, 0.17056483f, 0.02731458f, -0.06504057f, -0.10241621f, -0.15449570f, 
    -0.10931265f, 0.03839354f, -0.03714488f, -0.13860410f, 0.11235433f, -0.11924968f, 0.03292476f, -0.01728506f, 
    -0.07614070f, -0.45988208f, -0.18637666f, -0.03766969f, 0.04596375f, 0.13537817f, 0.00940673f, 0.16278568f, 
    0.36316249f, 0.06591272f, -0.40934107f, -0.10509500f, 0.12816781f, -0.11792599f, -0.36175141f, -0.16505818f, 
    -0.24835825f, 0.09785718f, 0.11826068f, 0.13686787f, -0.21946803f, -0.04689408f, 0.05402124f, 0.29868773f, 
    0.01595777f, 0.11842643f, -0.05611020f, 0.11025400f, -0.08467788f, -0.12071928f, 0.11409219f, -0.12872355f, 
    0.00612822f, -0.05002141f, 0.01573184f, -0.03353775f, 0.15886748f, 0.07832235f, 0.07454880f, 0.10562990f, 
    -0.14608574f, 0.10090865f, 0.07052632f, -0.11352815f, -0.17780004f, -0.09474571f, -0.01985202f, 0.12013882f, 
    -0.16316801f, 0.05330903f, -0.03261293f, 0.07194905f, -0.02450776f, -0.07230283f, -0.00902977f, -0.01544656f, 
    -0.15570268f, -0.07003249f, 0.02361643f, 0.12384208f, -0.18186243f, -0.05407514f, 0.02408686f, -0.11206499f, 
    -0.03990049f, 0.08688006f, 0.65588570f, 0.35738358f, 0.07392369f, -0.02402616f, -0.08002558f, 0.09626733f, 
    0.50100154f, -0.10112457f, 0.13244575f, 0.13334851f, 0.09114881f, 0.09704845f, 0.02215165f, 0.10896138f, 
    0.07945566f, -0.27938169f, -0.00871038f, 0.05523231f, -0.23251648f, -0.05492322f, 0.03122878f, 0.06687129f, 
    0.01096776f, -0.27074257f, 0.03339909f, -0.05013086f, -0.02671247f, 0.15641022f, 0.08658314f, 0.09964214f, 
    -0.14992519f, 0.10494210f, -0.16507246f, 0.22062778f, 0.04239627f, 0.06685970f, -0.01410596f, 0.12218764f, 
    0.22874919f, -0.10226464f, 0.34968728f, 0.07066055f, 0.17529085f, -0.02096244f, -0.11019990f, 0.15128173f, 
    -0.48582289f, 0.09734042f, 0.06885701f, -0.00269011f, 0.04618140f, -0.09321558f, -0.00320496f, -0.18434772f, 
    -0.05920348f, 0.44548923f, 0.00683187f, 0.07285949f, 0.11366075f, -0.06288666f, -0.08719709f, -0.14357468f, 
    0.04190730f, 0.05790230f, -0.00716266f, 0.33892491f, -0.04305612f, 0.01887790f, 0.05030419f, -0.07019559f, 
    -0.16159071f, 0.02660811f, 0.09446108f, -0.05619780f, 0.39438003f, 0.03943833f, -0.26353288f, -0.11925714f, 
    -0.25471148f, 0.19515300f, -0.15342423f, 0.08139420f, -0.15946734f, 0.08461266f, -0.09046394f, 0.08130334f, 
    -0.16321263f, 0.39138561f, -0.13475509f, -0.10646030f, -0.03779877f, -0.05011746f, 0.01906194f, 0.12258513f, 
    -0.13088068f, 0.05166544f, -0.28101820f, 0.34553140f, -0.11250015f, 0.08252092f, 0.08756369f, 0.14185704f, 
    -0.12815793f, 0.08984842f, 0.10098317f, -0.13523535f, 0.14183505f, -0.10278090f, 0.09819230f, 0.02931964f, 
    -0.19664203f, 0.07999521f, 0.00460404f, 0.01183153f, 0.21304375f, 0.11815295f, 0.17511295f, -0.29341698f, 
    0.04965010f, -0.01546974f, -0.08376831f, 0.11423985f, -0.10012332f, 0.09808785f, 0.11571628f, -0.16829960f, 
    -0.00589166f, 0.14080836f, 0.35151359f, 0.05816100f, 0.05843965f, -0.13911261f, 0.17541969f, -0.09465709f, 
    0.42851859f, -0.06008726f, 0.20041576f, -0.00689907f, 0.23460859f, 0.02176463f, -0.12133409f, 0.07391647f, 
    0.01122225f, -0.23055314f, -0.03424431f, 0.12548271f, -0.29534543f, -0.12108412f, -0.02311271f, 0.32317027f, 
    0.00339071f, -0.20170501f, -0.09996118f, 0.06592479f, -0.00556145f, -0.16627039f, 0.09914393f, -0.03570801f, 
    0.00511673f, 0.00285359f, -0.14154151f, -0.12168258f, -0.07030796f, -0.01088447f, -0.03567244f, -0.04872108f, 
    -0.17265591f, 0.15539607f, -0.09392420f, 0.02452536f, 0.03603201f, 0.08443135f, -0.02788149f, 0.09680775f, 
    -0.14412133f, -0.09587046f, -0.02314163f, -0.02682190f, 0.07829783f, 0.12258177f, -0.08339003f, -0.18959630f, 
    -0.08013490f, -0.54444456f, 0.08498637f, -0.00876596f, 0.08189796f, -0.12792414f, 0.10801008f, -0.21997824f, 
    0.07592103f, 0.19524790f, 0.11260305f, 0.19517595f, -0.04473938f, 0.02453991f, 0.08768657f, -0.05046812f, 
    0.20582072f, 0.02938495f, 0.16285075f, -0.00795529f, -0.14922918f, -0.01317468f, 0.31029162f, 0.07619829f, 
    0.44883212f, 0.09853490f, 0.13939074f, 0.08547115f, -0.13918039f, 0.11969283f, -0.08797847f, -0.13131723f, 
    -0.06093907f, 0.20535158f, -0.05138522f, 0.11677155f, 0.29483378f, 0.03300226f, -0.02941709f, -0.10103303f, 
    0.02957214f, 0.17067665f, -0.25449923f, 0.00424494f, 0.02614285f, -0.11557283f, -0.07146050f, -0.09987680f, 
    -0.28095496f, -0.02981526f, 0.04236753f, -0.12724455f, 0.31703034f, -0.12857264f, 0.23063190f, -0.11462066f, 
    -0.00814725f, 0.03263950f, 0.15804398f, 0.08687441f, -0.29571396f, -0.03805636f, -0.09091841f, 0.01672930f, 
    0.03317694f, -0.16822110f, -0.08828136f, -0.14668170f, -0.09551363f, 0.10589332f, 0.04040124f, -0.09156889f, 
    0.17772134f, 0.09165239f, 0.23283480f, 0.27349311f, -0.13306582f, 0.00168698f, -0.06344572f, -0.03576604f, 
    0.40151384f, 0.00846852f, 0.02181856f, -0.06887440f, 0.06121107f, 0.04447148f, 0.26828530f, -0.11123702f, 
    -0.11447588f, 0.20166691f, 0.06388846f, 0.07062884f, 0.06621538f, 0.04514539f, 0.02247464f, -0.24656111f, 
    -0.03869700f, -0.35308906f, -0.06997010f, 0.05683258f, -0.00586319f, 0.02311194f, -0.02938286f, -0.10695025f, 
    0.00192444f, 0.16130109f, 0.00726371f, 0.18355224f, -0.06716962f, 0.05135388f, 0.17451246f, 0.07189947f, 
    0.10475805f, 0.02248451f, 0.26711661f, -0.08080960f, 0.34810784f, 0.15644678f, 0.09367175f, -0.16720550f, 
    -0.27854860f, -0.31455457f, -0.16013084f, 0.05526745f, 0.22525235f, -0.06354278f, 0.00079002f, -0.14355940f, 
    0.10918572f, 0.50902992f, -0.03108141f, 0.05508656f, 0.03176449f, 0.05987038f, -0.06735007f, 0.02031855f, 
    0.15888515f, -0.02249999f, 0.16745082f, 0.14725210f, 0.16456419f, -0.12338103f, -0.16553676f, 0.16363145f, 
    -0.13689576f, -0.00047557f, 0.19169120f, -0.03898852f, 0.39856777f, -0.05106423f, -0.20749286f, 0.07773883f, 
    -0.25998929f, -0.16494870f, -0.03067016f, -0.12482893f, -0.30032703f, -0.08197813f, -0.13093182f, -0.03440659f, 
    -0.03153848f, 0.27305177f, -0.16264556f, -0.00153092f, 0.06492862f, -0.17306410f, -0.15659592f, 0.20748940f, 
    0.02103704f, -0.36815369f, 0.25944087f, 0.14469837f, -0.15539025f, -0.03892906f, -0.16988695f, -0.01517790f, 
    -0.25405666f, -0.16475920f, -0.07600520f, 0.23045085f, -0.01869755f, 0.03294205f, -0.05796666f, 0.17859206f, 
    -0.07286400f, 0.14543931f, -0.09409123f, 0.01781654f, -0.20668975f, 0.12175132f, 0.07115471f, -0.07290696f, 
    -0.09902787f, 0.17190395f, -0.00181104f, 0.09203839f, -0.28915355f, 0.14233929f, 0.15270415f, 0.16664484f, 
    0.02966260f, -0.19583838f, -0.01203922f, -0.28787452f, 0.10746540f, 0.03272527f, 0.12640722f, 0.15914083f, 
    0.05897952f, -0.01701203f, 0.15097618f, 0.19280180f, 0.13001066f, 0.03286635f, 0.25192550f, -0.05191896f, 
    0.05116042f, 0.39883769f, 0.12752226f, -0.10436185f, 0.48170206f, 0.11593186f, 0.03943194f, -0.18916526f, 
    0.12733109f, 0.04763835f, -0.10277366f, -0.09719108f, 0.06600755f, -0.02895977f, 0.09341927f, 0.10692175f, 
    0.09559446f, 0.14167593f, -0.19439903f, 0.00901595f, -0.17007576f, -0.11888077f, -0.00751531f, 0.02959285f, 
    0.31527165f, 0.05271930f, -0.14860548f, 0.04034271f, 0.04316819f, -0.03189093f, -0.12905872f, -0.04664260f, 
    -0.44803682f, 0.18709683f, -0.04764719f, -0.16689138f, 0.29740086f, 0.05534324f, 0.06441598f, 0.07964822f, 
    -0.09227184f, -0.09952477f, -0.10295130f, 0.07445485f, -0.22716327f, 0.05355975f, -0.07661184f, 0.22510451f, 
    -0.07839178f, -0.08187878f, -0.05401115f, 0.38917214f, -0.11131544f, 0.01944141f, 0.10780041f, 0.08894856f, 
    0.26484019f, 0.07306772f, 0.30346811f, 0.13927653f, -0.06078555f, 0.03175999f, 0.12964454f, 0.02918823f, 
    -0.10767556f, 0.30678317f, 0.08765336f, -0.14401577f, 0.17111003f, 0.15222046f, 0.16129535f, -0.25813058f, 
    0.15867235f, -0.00993169f, -0.03314611f, -0.06468450f, -0.01175894f, -0.15648586f, 0.12092586f, 0.27340421f, 
    0.15519464f, -0.03010104f, 0.64649451f, -0.40188682f, 0.15239993f, -0.14444628f, -0.12690069f, -0.08095174f, 
    -0.16092531f, -0.02798714f, 0.13731588f, -0.01201389f, -0.15878740f, -0.15319124f, -0.01369040f, 0.17511351f, 
    0.16731857f, 0.18614441f, 0.12354179f, -0.15409410f, -0.14845136f, -0.03416242f, -0.10250726f, -0.00463185f, 
    0.03273405f, 0.16572689f, -0.01786099f, -0.13310355f, 0.22243208f, 0.15447053f, -0.10373415f, 0.49168777f, 
    0.13633360f, 0.22844456f, -0.39865756f, -0.27191886f, 0.13699073f, 0.06921627f, 0.12210727f, -0.07016051f, 
    -0.05160061f, -0.16019684f, -0.00702947f, 0.06974609f, 0.18830089f, -0.01566414f, -0.29329747f, -0.16217895f, 
    -0.32788497f, 0.11716905f, -0.05083413f, 0.11368778f, -0.07349499f, 0.08972773f, 0.05789492f, -0.01368890f, 
    0.14374448f, -0.03832793f, 0.13281009f, -0.07201322f, -0.14208625f, 0.14327495f, 0.09713264f, -0.18740322f, 
    0.15403226f, 0.06191229f, 0.00370640f, -0.05868926f, -0.09687556f, 0.02156776f, 0.01109887f, -0.06420903f, 
    -0.03043757f, 0.09482013f, -0.16418867f, -0.10757235f, -0.17603640f, 0.03616857f, -0.09496998f, 0.13585585f, 
    -0.08525097f, 0.00300502f, 0.03543564f, 0.14571555f, -0.15153182f, 0.10968447f, -0.07444704f, -0.15699363f, 
    -0.06575317f, -0.11126986f, 0.08245865f, -0.11932100f, 0.06576025f, 0.15561067f, 0.00906450f, 0.02381961f, 
    -0.14762992f, -0.10150085f, -0.06275837f, -0.15957981f, -0.01413896f, 0.01498020f, 0.08035944f, -0.06441503f, 
    -0.09386995f, -0.16139106f, 0.04542149f, -0.09837966f, -0.13594039f, 0.16579609f, -0.07227554f, -0.00112279f, 
    -0.09513371f, 0.06454922f, 0.03462605f, -0.03960508f, 0.00902423f, 0.07260163f, 0.00229739f, 0.10487571f, 
    0.02047648f, -0.03959846f, -0.02625104f, 0.03974924f, -0.03925334f, -0.02710974f, -0.10854695f, -0.00764277f, 
    -0.14319336f, -0.09244236f, -0.03470247f, -0.21377318f, 0.11928751f, 0.11022642f, -0.08778641f, 0.05976322f, 
    0.02561474f, 0.07409251f, -0.17598334f, -0.21038608f, -0.01043513f, 0.14807105f, 0.09272303f, 0.07986724f, 
    -0.17253539f, -0.20390268f, -0.11550942f, 0.13947052f, -0.03432212f, -0.00360073f, 0.11051627f, -0.18304393f, 
    -0.12272912f, -0.16753705f, -0.06858891f, 0.09035732f, 0.05610479f, 0.17768779f, -0.03943112f, -0.05343629f, 
    -0.04092502f, 0.14100976f, -0.32352093f, 0.08460019f, -0.07766192f, -0.13174935f, -0.06328700f, -0.10938789f, 
    0.53166264f, 0.14682813f, 0.00636496f, -0.07796047f, -0.06919014f, 0.14250045f, 0.17584057f, -0.06730854f, 
    -0.05836435f, 0.25611755f, 0.03894217f, -0.17558844f, -0.04265299f, -0.15079141f, 0.00183122f, -0.00594957f, 
    0.07970382f, -0.57955271f, -0.07719765f, -0.02222252f, -0.00443369f, -0.00442459f, -0.08655804f, 0.28922784f, 
    -0.11896577f, 0.30917498f, -0.11850123f, 0.23962779f, 0.05964078f, 0.02588613f, -0.03475196f, -0.06384099f, 
    0.26984447f, 0.05920000f, -0.05788074f, 0.22985841f, 0.27979392f, -0.04158383f, 0.00610452f, 0.14772671f, 
    0.06747397f, 0.11547992f, 0.04146117f, 0.11078716f, -0.17872715f, 0.09824102f, 0.11218663f, -0.11814465f, 
    0.07425990f, -0.03766143f, 0.00441771f, -0.12871034f, 0.02086885f, 0.13753673f, -0.14764310f, -0.11314518f, 
    -0.11403877f, -0.12809013f, -0.10397217f, -0.26041308f, -0.06449730f, -0.14944811f, -0.01999057f, 0.02070526f, 
    0.39564401f, -0.08102314f, 0.12295713f, 0.20621693f, -0.31673175f, 0.12609468f, -0.07156714f, -0.15079623f, 
    0.07216036f, 0.21380936f, 0.14964063f, 0.07147165f, -0.21425429f, -0.08249314f, -0.00184730f, 0.19214791f, 
    -0.00952877f, -0.18356442f, -0.05075030f, 0.03330364f, 0.28252876f, 0.02803374f, -0.07250311f, 0.09014413f, 
    -0.08504351f, 0.19892856f, 0.04871087f, 0.31606933f, -0.12198665f, 0.09533380f, -0.08266930f, 0.04535344f, 
    -0.27539840f, 0.01560029f, 0.33968854f, -0.29298487f, 0.42943382f, -0.16607513f, 0.12561853f, 0.12678012f, 
    0.12472031f, -0.24889819f, -0.16495539f, -0.15597777f, -0.26573905f, 0.00831730f, -0.02447557f, -0.23833407f, 
    0.01335927f, -0.02596802f, 0.15005074f, 0.09418079f, 0.00002945f, 0.03524999f, -0.17158645f, 0.06182680f, 
    -0.14360563f, 0.06394809f, 0.55705124f, 0.30016688f, -0.04471957f, -0.16082738f, -0.16449116f, -0.02796475f, 
    0.32533139f, 0.06173291f, 0.19971950f, 0.12104212f, -0.26367179f, 0.04456419f, 0.14959124f, 0.13118961f, 
    0.06794523f, -0.48030975f, 0.13983288f, -0.13767378f, -0.15433392f, 0.12854175f, 0.08460014f, 0.00215488f, 
    0.15863712f, 0.12036041f, 0.03773214f, -0.08528570f, 0.16378872f, 0.06559137f, 0.04021752f, -0.12783787f, 
    0.02833393f, -0.07978842f, -0.27485693f, -0.19266403f, 0.12178903f, -0.16077860f, -0.17123714f, -0.02282825f, 
    -0.21987042f, -0.05450362f, -0.09476431f, 0.19050376f, -0.22252223f, -0.12172340f, 0.31074566f, -0.04586312f, 
    0.37934935f, 0.18792902f, 0.14605397f, -0.16773911f, 0.16440989f, -0.04784005f, 0.11046825f, 0.19093055f, 
    0.06289166f, 0.27042079f, 0.00814274f, 0.04344292f, -0.09325434f, 0.01533440f, -0.16687685f, 0.09552143f, 
    0.12298673f, 0.02308577f, -0.18782893f, 0.20401473f, 0.03696094f, -0.01038193f, 0.05353408f, 0.04885271f, 
    -0.31939593f, -0.03520937f, 0.43269423f, 0.12503232f, 0.31797168f, 0.08592284f, -0.15081264f, -0.07761697f, 
    0.01686629f, -0.30705920f, 0.12815350f, 0.05118329f, -0.32823452f, 0.14028502f, 0.00069022f, -0.05186828f, 
    -0.14987318f, -0.14377162f, 0.17977762f, -0.05470560f, 0.13571139f, 0.02131884f, -0.05746728f, 0.16304031f, 
    -0.04360972f, 0.01822601f, 0.43408015f, 0.15511180f, 0.13046394f, -0.10566070f, 0.01019169f, -0.08781350f, 
    -0.00017025f, 0.02712791f, 0.19402863f, -0.11153658f, -0.39669156f, -0.08980286f, -0.00333803f, -0.03633872f, 
    -0.21484928f, 0.18200704f, -0.10828774f, -0.13419634f, -0.25103003f, 0.05560257f, 0.03220953f, 0.24384072f, 
    0.04666309f, 0.21187747f, 0.15844160f, -0.06969723f, -0.00076726f, -0.09437313f, 0.07468878f, -0.29314521f, 
    -0.06884018f, 0.01108463f, -0.14669761f, -0.18118763f, -0.17676114f, -0.06833700f, 0.01173512f, 0.16767237f, 
    -0.06411201f, 0.05049038f, 0.10189403f, -0.33507946f, 0.36037090f, 0.02156468f, 0.36600018f, 0.07572019f, 
    0.27437332f, -0.00219104f, 0.13070735f, 0.07884775f, -0.08794964f, -0.07645967f, -0.12846373f, 0.00451911f, 
    0.11478521f, 0.47418478f, 0.04050477f, -0.12202935f, 0.34653613f, -0.10564564f, 0.05883432f, -0.04799436f, 
    -0.05401296f, -0.03744790f, 0.05080996f, 0.12885375f, -0.03813116f, -0.09268352f, -0.15760846f, -0.08881928f, 
    -0.01155861f, -0.00085332f, -0.41865668f, 0.13397208f, 0.01212186f, 0.00473718f, -0.18771699f, 0.00462235f, 
    -0.28498095f, 0.13857336f, 0.08493714f, -0.10931154f, -0.19818054f, 0.04146426f, 0.05180700f, 0.24754089f, 
    0.01964524f, -0.06677958f, -0.17199966f, 0.07211470f, -0.17927253f, -0.11401416f, -0.03521316f, 0.29359275f, 
    -0.02698405f, 0.24831183f, -0.13824871f, -0.23992886f, -0.18264234f, 0.00456460f, 0.12655723f, -0.11006127f, 
    0.38321981f, -0.03795196f, -0.07125079f, -0.07227846f, 0.34791431f, 0.11236234f, -0.12201814f, 0.00372399f, 
    -0.17703179f, 0.03668133f, 0.15250699f, -0.05963353f, 0.03221317f, 0.01892183f, 0.08658087f, 0.16435553f, 
    -0.11692349f, 0.15314357f, -0.09823238f, -0.10582376f, 0.20942211f, 0.10339635f, 0.04376164f, 0.03650288f, 
    0.08265949f, -0.06198723f, 0.40207979f, 0.22786514f, -0.00682756f, 0.01041676f, -0.10886167f, 0.07551873f, 
    -0.34816143f, -0.04407693f, -0.29770827f, 0.28363752f, -0.37009308f, -0.05629238f, 0.21885116f, 0.17431885f, 
    0.36783636f, -0.21664459f, -0.06501321f, -0.08718192f, -0.24864766f, -0.06924820f, 0.11191500f, 0.14336798f, 
    -0.07194667f, 0.16385463f, -0.00388682f, 0.05582704f, 0.21982528f, 0.13826346f, 0.14971428f, 0.22377501f, 
    0.01968111f, -0.02305209f, -0.00636761f, 0.12295481f, 0.09310217f, -0.01645008f, 0.01326018f, 0.06819735f, 
    -0.30258942f, 0.14037082f, 0.23306981f, -0.27923357f, 0.50687385f, 0.09594572f, -0.18257350f, -0.05264555f, 
    -0.38389951f, 0.01406622f, -0.01092094f, -0.15601096f, -0.05113096f, -0.01877352f, -0.08093936f, -0.15186451f, 
    0.06042972f, 0.20340544f, 0.11933148f, -0.12673707f, 0.01298008f, 0.06217423f, -0.06877516f, 0.25426835f, 
    -0.07592025f, -0.16090104f, 0.38233322f, 0.26401633f, -0.14577822f, -0.15317738f, -0.01333194f, 0.13708432f, 
    -0.00871127f, -0.02316638f, -0.06789728f, 0.26585624f, 0.17261969f, -0.02172265f, -0.30718771f, 0.15297908f, 
    -0.38550067f, 0.11569759f, -0.04062816f, -0.08482757f, -0.32554629f, -0.07719614f, -0.02200059f, -0.05771777f, 
    -0.15309747f, -0.33312455f, 0.16869687f, -0.14534174f, 0.02642834f, 0.06762619f, 0.07076260f, -0.44640785f, 
    0.07250839f, 0.02780882f, -0.19064580f, 0.42614007f, -0.16164391f, -0.11781909f, 0.14345485f, -0.10780790f, 
    0.12452690f, 0.03749300f, 0.11540207f, 0.20453580f, 0.13160665f, 0.11972041f, -0.19507225f, -0.11702634f, 
    0.02961734f, -0.05659300f, -0.15279378f, -0.08428460f, 0.24408251f, -0.13800599f, -0.03231724f, 0.42331335f, 
    -0.02357281f, 0.02784630f, 0.14238018f, 0.01494489f, -0.08436564f, -0.03564866f, -0.02996454f, 0.01823287f, 
    0.09442427f, -0.12612844f, -0.07881641f, -0.06355407f, -0.06622232f, 0.05893524f, -0.08664735f, 0.10225030f, 
    -0.05555538f, -0.09754688f, -0.07110792f, -0.23067401f, -0.03929115f, -0.04109035f, 0.00697993f, -0.02607696f, 
    -0.00652236f, 0.06364901f, -0.09301894f, 0.02359669f, -0.11841657f, -0.02295345f, 0.05875397f, -0.02740950f, 
    -0.14727326f, 0.33586264f, 0.13392082f, -0.02996428f, 0.17792287f, 0.13318729f, -0.17393848f, -0.11822253f, 
    0.00936542f, -0.01076664f, -0.25076649f, -0.25080323f, 0.04091838f, 0.04599282f, -0.02342722f, 0.16911887f, 
    -0.04075843f, 0.06378120f, -0.00541987f, -0.15067534f, 0.39716586f, -0.04560812f, 0.02291114f, 0.11830693f, 
    -0.19126625f, 0.28380072f, 0.10988096f, -0.16059256f, 0.02993136f, -0.11879310f, -0.13096517f, 0.19976346f, 
    0.00369551f, 0.10296427f, 0.08851271f, -0.11898156f, 0.16557808f, 0.14241223f, -0.10020418f, -0.15394363f, 
    0.21529892f, 0.34621480f, -0.24437129f, -0.27182373f, -0.15451364f, -0.13293836f, 0.03801790f, 0.00251846f, 
    0.25164089f, 0.04353692f, -0.12737049f, -0.22630295f, 0.32816440f, 0.12485618f, 0.21630353f, 0.12746425f, 
    -0.24372134f, 0.16170131f, 0.05271910f, 0.13079655f, 0.02338970f, 0.04943762f, -0.08455563f, -0.00161712f, 
    0.17545845f, 0.02554258f, 0.05444498f, 0.05782238f, -0.20080557f, 0.07618545f, -0.06046408f, -0.48084149f, 
    0.14896160f, -0.19372277f, 0.11017721f, 0.33842468f, -0.08204278f, 0.14427821f, 0.15336391f, 0.11965182f, 
    0.28470027f, 0.00346940f, 0.34812447f, 0.15144034f, 0.10032825f, 0.13766697f, -0.02815044f, -0.17639107f, 
    -0.44239399f, 0.07972134f, 0.02534905f, -0.03237929f, 0.36397019f, -0.01307142f, -0.11236089f, 0.07874582f, 
    0.09351100f, -0.09709696f, -0.06300434f, 0.06065203f, 0.25111628f, 0.00278494f, 0.14865951f, 0.48223579f, 
    0.05168350f, 0.14162858f, -0.01475075f, -0.19701587f, 0.08593486f, -0.04662295f, -0.08894473f, 0.04835647f, 
    -0.15911196f, 0.04480528f, -0.34100881f, 0.17554314f, -0.20511000f, 0.00577966f, 0.12836491f, -0.02615893f, 
    -0.02002770f, 0.16026379f, -0.12314108f, 0.00582535f, 0.18574098f, -0.06566601f, 0.19179629f, -0.09993964f, 
    -0.07908491f, 0.21533468f, -0.00267389f, -0.07940350f, 0.05769917f, -0.06060276f, -0.15454765f, 0.10094906f, 
    0.15077402f, -0.13928139f, 0.11166165f, 0.03278036f, 0.17466281f, 0.07028222f, -0.06950988f, -0.11142553f, 
    -0.12139440f, -0.05197664f, -0.33936152f, 0.25051928f, -0.38152552f, -0.15095149f, 0.33867267f, 0.07463637f, 
    0.30622005f, -0.08424911f, -0.07884815f, -0.00066895f, -0.06125831f, -0.08075698f, 0.09759054f, 0.32213047f, 
    0.07764018f, -0.08652223f, -0.12537062f, -0.05751353f, -0.00509731f, -0.16565084f, 0.08199446f, 0.34461701f, 
    0.14075398f, 0.17618564f, -0.35224304f, -0.46115279f, 0.02633555f, 0.16401717f, -0.09022444f, -0.06491801f, 
    0.39666879f, -0.01655786f, 0.10517097f, -0.16579250f, 0.33459759f, 0.17315885f, 0.22603041f, 0.11910415f, 
    -0.19203222f, 0.24162041f, 0.13692220f, -0.00714051f, 0.11787742f, 0.07321592f, 0.10010572f, -0.18798280f, 
    0.12061592f, 0.09501272f, -0.10068159f, 0.03035845f, -0.14159864f, 0.10455680f, 0.16368188f, -0.62474024f, 
    0.07539260f, 0.13591368f, 0.15439108f, 0.48608211f, 0.12960216f, 0.00980251f, 0.00992746f, -0.11498570f, 
    0.42794096f, -0.05534831f, 0.16763979f, -0.21953349f, 0.12224397f, -0.09227955f, -0.10706306f, -0.02538756f, 
    -0.21562906f, -0.34083322f, -0.00623183f, -0.12535404f, 0.28465122f, -0.15961306f, 0.05921333f, 0.31580320f, 
    0.11100104f, -0.12407161f, -0.01949583f, 0.07534494f, 0.01345517f, 0.06811557f, -0.00298265f, 0.36543626f, 
    -0.07542096f, 0.23869339f, -0.23432262f, -0.10892559f, 0.15195252f, 0.16260648f, -0.05114222f, 0.09689818f, 
    -0.18585207f, 0.11666780f, 0.06983570f, 0.10642539f, -0.03572218f, -0.01318870f, 0.18605436f, -0.08563428f, 
    0.52731675f, 0.03747555f, -0.12652501f, -0.05682940f, -0.12181931f, 0.11329620f, -0.06964287f, -0.03856748f, 
    0.00766768f, 0.33359140f, 0.11935563f, 0.04076361f, 0.20597784f, -0.13024603f, -0.15749869f, -0.01208281f, 
    0.02556927f, -0.20607845f, 0.02536917f, -0.10390184f, -0.11448883f, 0.16974103f, 0.03121397f, -0.17786513f, 
    0.15981737f, 0.09474175f, -0.35132626f, 0.14174280f, 0.18119466f, 0.08170497f, -0.16225696f, -0.04101929f, 
    -0.10904197f, 0.28883252f, -0.06422063f, 0.18206175f, -0.26973090f, -0.15996893f, -0.03520809f, 0.29773402f, 
    -0.02229895f, -0.25597900f, 0.04883154f, -0.12875202f, 0.25606239f, -0.16939260f, 0.08252079f, 0.00095240f, 
    0.11479428f, -0.16180512f, -0.01604423f, 0.04050912f, 0.12342300f, 0.11266656f, -0.13167185f, -0.01163865f, 
    0.26851976f, 0.16583392f, -0.04164441f, 0.29948032f, -0.25118145f, 0.11431047f, -0.20840654f, -0.09345277f, 
    0.18101116f, 0.06105121f, 0.00084664f, 0.09404739f, -0.27279782f, -0.08093014f, -0.17850378f, 0.07205989f, 
    0.16431260f, -0.21792252f, -0.02017798f, 0.16297528f, -0.05794857f, 0.10120088f, 0.11475872f, -0.24145612f, 
    -0.14765987f, -0.16300006f, -0.22021827f, -0.16271611f, -0.15042509f, 0.14350908f, 0.12156501f, -0.02502828f, 
    0.06532285f, 0.03703744f, 0.25730601f, 0.22738767f, -0.15516555f, -0.05892069f, -0.12444320f, 0.09358485f, 
    0.16890323f, 0.24526080f, 0.13424480f, 0.14794439f, 0.49526733f, -0.07954065f, 0.01394217f, 0.29833853f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.23761268f, -0.02971076f, -0.02890109f, -0.26281908f, 0.15528755f, -0.05591161f, 0.17283475f, -0.15743203f, 
    0.42701063f, -0.13784401f, -0.11073386f, -0.16665745f, 0.14900026f, -0.23181866f, 0.30837587f, 0.29170525f, 
    0.13624221f, 0.18129554f, 0.05997428f, 0.18696241f, 0.18429066f, 0.12630828f, -0.17861895f, 0.04866439f, 
    -0.05093044f, -0.11443243f, -0.37160751f, -0.01153943f, -0.07977889f, -0.07731793f, 0.09856864f, 0.01888482f, 
    -0.12740491f, -0.05309940f, 0.32303014f, 0.25941494f, 0.18439034f, 0.01851206f, 0.31233460f, 0.20487297f, 
    -0.31860301f, -0.10691575f, 0.17329833f, 0.04695380f, 0.07921610f, 0.33596420f, 0.01702392f, 0.20259020f, 
    0.11544847f, -0.02277513f, 0.07709206f, -0.03897808f, -0.15683891f, 0.17025490f, 0.20998473f, -0.13496375f, 
    0.04713337f, -0.11742295f, 0.06441541f, 0.03541572f, -0.12944470f, 0.21053290f, 0.34471089f, 0.07725979f, 
    -0.26774600f, 0.24966727f, -0.00813035f, -0.08668042f, -0.04678312f, -0.26103085f, 0.15036489f, -0.02479412f, 
    0.13675489f, -0.12686665f, -0.29319403f, 0.20313074f, 0.11363664f, -0.19302693f, -0.00736940f, 0.26680243f, 
    -0.01345388f, -0.30793974f, 0.32899779f, 0.01696164f, -0.18035127f, -0.05177401f, -0.13627051f, 0.29050574f, 
    0.43577081f, -0.06704411f, 0.14235401f, 0.21854486f, 0.25106096f, 0.06426162f, 0.33841369f, -0.12084977f, 
    -0.32821810f, 0.34485582f, 0.08003466f, 0.16959219f, -0.15367943f, 0.49708986f, -0.05213792f, 0.23311177f, 
    0.20330049f, 0.21795687f, 0.00230949f, 0.20669435f, 0.03764727f, 0.07653724f, 0.37214348f, 0.36657748f, 
    0.13635027f, 0.11434980f, 0.09088250f, 0.12704295f, -0.01641093f, 0.28236133f, -0.11085092f, 0.16351070f, 
    0.06940761f, 0.06675022f, 0.27205089f, -0.03963996f, 0.12726149f, 0.06015731f, 0.44586816f, -0.01945270f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.02358440f, -0.04262239f, -0.07403265f, -0.11823289f, -0.36816293f, 0.02323567f, 0.22931574f, 0.07493067f, 
    -0.03621015f, -0.15873975f, -0.12361886f, 0.22549571f, -0.11879059f, 0.27760813f, 0.06094853f, 0.04179349f, 
    -0.15188950f, 0.20506649f, 0.35782769f, -0.18248163f, 0.19177479f, -0.39947063f, 0.03556115f, 0.24283430f, 
    -0.34774369f, -0.01205188f, 0.02824841f, -0.56652206f, 0.14751782f, -0.06919320f, 0.01544620f, -0.24016452f, 
    0.01168510f, -0.19925304f, -0.45880413f, 0.05878834f, 0.18067379f, 0.08778003f, -0.16728885f, -0.19482243f, 
    0.15306120f, -0.39226103f, 0.17150730f, -0.15549226f, -0.14126289f, 0.03107238f, 0.30432481f, 0.05326957f, 
    -0.31274813f, 0.00861824f, 0.06366841f, 0.22202928f, 0.05116386f, 0.26571262f, 0.08334035f, -0.09773258f, 
    0.04798411f, -0.35422581f, 0.13892202f, 0.05702368f, 0.10064272f, 0.04801071f, -0.04462847f, 0.00579398f, 
    -0.21247888f, -0.43137643f, 0.15509157f, -0.46437180f, -0.06528730f, -0.22144887f, 0.09842528f, -0.02665569f, 
    -0.36872637f, -0.42246091f, -0.36294138f, 0.12876880f, 0.22915275f, -0.05456011f, -0.08814959f, -0.31021655f, 
    -0.06615010f, 0.00327955f, -0.16198841f, 0.06086387f, 0.24204521f, -0.18241049f, -0.07274601f, -0.48697603f, 
    -0.04865579f, -0.07318109f, -0.23325838f, 0.16168256f, 0.17573023f, 0.11838254f, -0.06542882f, 0.10276505f, 
    -0.45862013f, -0.01050462f, -0.02821949f, 0.05511587f, 0.05423754f, -0.17503643f, -0.54195207f, -0.24134633f, 
    -0.23749648f, 0.25529599f, 0.04768962f, 0.24538296f, -0.20555572f, -0.13701561f, 0.13256474f, -0.28076223f, 
    0.18327668f, -0.12541144f, 0.12705222f, -0.12738970f, 0.06013276f, -0.06923470f, -0.21106079f, 0.03584591f, 
    -0.05814594f, 0.28590101f, -0.41043583f, -0.04752253f, 0.07154541f, -0.04147292f, -0.04909923f, -0.10928330f, 
    -0.11785573f, -0.04746553f, 0.07537892f, -0.59832156f, -0.06616569f, -0.03716222f, -0.03488205f, 0.08532424f, 
    -0.23789380f, -0.44314396f, -0.02248878f, 0.04477202f, -0.09459084f, 0.06009627f, 0.08947634f, -0.35712200f, 
    -0.75431746f, 0.13489431f, -0.36653665f, -0.03555249f, -0.30106643f, 0.10725885f, -0.12607583f, 0.52731025f, 
    -0.24070424f, -0.01562681f, -0.09972838f, -0.63926750f, -0.28184849f, -0.05477193f, -0.31689325f, 0.04653150f, 
    0.09083814f, -0.40098649f, -0.16789861f, -0.26764953f, -0.21830198f, -0.12409391f, 0.10411991f, 0.17335351f, 
    -0.27560258f, -0.01279134f, 0.03949572f, -0.08665066f, 0.02396508f, -0.30845532f, 0.20974521f, 0.15967578f, 
    -0.20915914f, -0.00139072f, 0.04705931f, 0.00070929f, 0.02986856f, -0.45926777f, -0.30745733f, -0.04681024f, 
    0.33329022f, -0.18767534f, -0.10747637f, 0.05501731f, 0.11469819f, 0.19164129f, 0.07384625f, 0.08066114f, 
    -0.20013951f, -0.00908524f, 0.10838227f, -0.06353778f, 0.12664378f, 0.11551377f, -0.01789044f, 0.00123226f, 
    -0.21113980f, 0.25615272f, 0.05740742f, 0.04376337f, 0.04708579f, -0.07331274f, -0.09070180f, -0.60508144f, 
    0.04093312f, 0.28766161f, 0.21530236f, 0.21996620f, 0.11539242f, 0.18446071f, 0.01585893f, 0.26115099f, 
    -0.01247862f, 0.17227085f, 0.13038121f, 0.22960334f, 0.06818066f, -0.20292620f, -0.08318570f, 0.11949910f, 
    0.08839910f, -0.24018469f, 0.03316069f, 0.05777900f, -0.03091167f, 0.01974248f, 0.04723401f, -0.11208019f, 
    0.17862444f, 0.15565249f, -0.26770449f, 0.19870834f, 0.18166049f, -0.03356982f, 0.05310692f, -0.38278911f, 
    0.01196690f, 0.12474687f, 0.25381747f, 0.21119642f, -0.09891137f, -0.05015593f, -0.09524240f, 0.38338581f, 
    -0.45825800f, -0.15521666f, -0.47347990f, 0.33267698f, -0.14855501f, 0.00093299f, -0.00534867f, -0.14920454f, 
    0.11909134f, 0.02716638f, 0.00792867f, -0.47759089f, -0.17234944f, -0.06323324f, 0.23463738f, -0.00570170f, 
    0.03583115f, -0.37247479f, -0.07195188f, -0.35880578f, -0.62617290f, -0.18211761f, -0.32183117f, 0.04181048f, 
    0.25265619f, -0.01105036f, -0.07908623f, -0.34797925f, 0.08115327f, 0.26188883f, 0.36367100f, -0.05622325f, 
    -0.05002881f, 0.03416139f, 0.26450413f, -0.17755805f, -0.27741539f, -0.01773877f, 0.05860288f, 0.12710518f, 
    0.36204737f, -0.07041592f, -0.14790379f, -0.48973849f, 0.25592992f, 0.11271160f, -0.35079467f, 0.09945130f, 
    -0.63083363f, 0.20413938f, -0.14272401f, -0.15896158f, -0.10220571f, -0.36759248f, 0.22829375f, 0.08441997f, 
    -0.00797816f, 0.02889928f, -0.04013108f, 0.17514209f, 0.08085945f, 0.14884071f, -0.05638713f, -0.02441166f, 
    -0.47160384f, 0.02643011f, 0.12917040f, 0.02650481f, -0.01300347f, 0.12240028f, 0.24926470f, -0.00786657f, 
    0.08697675f, -0.34440532f, -0.84334975f, -0.47530541f, -0.04210550f, -0.48100701f, -0.50281197f, -0.10035381f, 
    -0.19956131f, 0.22897127f, 0.29211795f, -0.45541304f, -0.02039825f, 0.02658137f, 0.00548879f, -0.64020526f, 
    0.07446150f, -0.38589323f, 0.21222678f, 0.06435703f, 0.18940118f, -0.26293844f, -0.02840800f, -0.40416962f, 
    -0.21804015f, -0.01188810f, 0.27610087f, -0.18257675f, -0.18746413f, 0.28596443f, 0.21452835f, 0.19200134f, 
    -0.64473295f, 0.07524526f, 0.02932309f, 0.00511969f, -0.03670353f, -0.01992193f, -0.23271544f, -0.22039649f, 
    -0.28643307f, -0.34481815f, 0.01557015f, -0.32816055f, -0.13897638f, -0.11966249f, -0.15893668f, -0.00012832f, 
    -0.57097507f, 0.03915371f, -0.34476492f, 0.25204206f, -0.07769749f, 0.08806454f, 0.11616129f, 0.45847538f, 
    -0.04421417f, -0.41484860f, 0.07962694f, 0.25501382f, -0.24421197f, -0.26374874f, -0.26571295f, 0.51511359f, 
    -0.36147410f, 0.05040232f, 0.04975517f, 0.09153439f, -0.10244954f, -0.01229469f, 0.24334292f, 0.05757371f, 
    -0.16629885f, -0.05998189f, -0.10306013f, 0.29984090f, 0.04542707f, 0.18145815f, -0.14969440f, 0.10014828f, 
    0.19316867f, 0.20982219f, 0.15818010f, 0.03585123f, 0.21132562f, 0.03908188f, -0.01433306f, -1.49838793f, 
    -0.00223495f, 0.04954612f, 0.06630910f, -0.43323377f, -0.04922357f, -0.08823609f, 0.16992758f, 0.13314876f, 
    0.20194544f, -0.36165437f, 0.13180691f, 0.20016624f, -0.01132772f, 0.15829025f, -0.48597392f, 0.00370232f, 
    0.25417349f, -0.36071852f, -0.12319793f, 0.14383088f, -0.14256243f, 0.15554693f, -0.12686545f, -0.49251586f, 
    0.40279433f, 0.00194721f, -0.02558642f, -0.03143382f, -0.01609013f, 0.26176164f, 0.19649309f, 0.04972972f, 
    0.10651620f, 0.39327627f, 0.32142881f, -0.02246548f, -0.02161692f, -0.48583549f, -0.31555656f, 0.05866205f, 
    -0.35953802f, -0.28803965f, -0.01068040f, -0.09131543f, -0.06670713f, -0.20469713f, 0.18369514f, 0.07826094f, 
    0.28571075f, -0.13594310f, 0.09130552f, -0.14997862f, -0.29381573f, -0.05268937f, 0.07926840f, -0.37537456f, 
    -0.04061122f, -0.00530339f, -0.23170809f, -0.46152335f, -0.03761590f, -0.28241807f, -0.00661452f, 0.31681994f, 
    -0.00872504f, 0.16861178f, 0.06480789f, -0.43854952f, -0.09099384f, 0.10361651f, -0.31766027f, -0.07845066f, 
    -0.07279812f, -0.47987586f, 0.03059443f, 0.04124603f, -0.07546030f, -0.09590599f, -0.13095582f, 0.00886389f, 
    0.16671373f, 0.15915999f, 0.14636542f, -0.30270940f, -0.29738820f, 0.21057254f, -0.51284808f, -0.43940201f, 
    0.13573520f, -0.16234948f, -0.68618357f, -0.35983935f, -0.06378456f, -0.28402296f, 0.05416941f, -0.68671179f, 
    0.07235318f, 0.12917334f, -0.01047683f, -0.30570939f, 0.13169882f, -0.42228320f, -0.29328290f, -0.15816601f, 
    -0.00945736f, 0.00151313f, -0.05071646f, -0.30518112f, 0.15086827f, -0.07220872f, -0.02046718f, -0.06428079f, 
    0.31965628f, -0.00509861f, 0.03995375f, 0.13828702f, -0.08937966f, -0.29388857f, -0.46035537f, 0.12549558f, 
    0.17015806f, 0.05115045f, -0.49859795f, -0.10231958f, 0.06241360f, 0.30240667f, -0.02065518f, -0.09984276f, 
    0.02406920f, -0.03358891f, -0.23598768f, -0.18918869f, 0.01753394f, -0.00617560f, -0.30601436f, 0.31433630f, 
    -0.03760643f, 0.16225828f, 0.15577701f, 0.05522795f, 0.20148894f, -0.17398994f, 0.11066994f, -0.15729123f, 
    -0.07288231f, 0.23809716f, 0.06711375f, 0.01320281f, 0.04862280f, 0.22210237f, 0.07301871f, 0.09246233f, 
    -1.03319621f, -0.00480040f, -0.01013519f, 0.11312742f, -0.02035069f, -0.10679787f, 0.03541399f, -0.05599774f, 
    -0.07536194f, -0.09856843f, -0.25483659f, 0.00754191f, -0.28260961f, -0.04658352f, 0.12397556f, -0.01800102f, 
    0.13194326f, 0.16548248f, -0.19816698f, -0.19428517f, -0.03687487f, -0.07745497f, -0.24267006f, 0.15385070f, 
    0.11865650f, -0.33839265f, -0.07360444f, 0.14899255f, 0.05028847f, 0.03502167f, 0.03555992f, -0.40174839f, 
    -0.02110415f, -0.23669057f, -0.06957640f, -0.24454431f, -0.25286502f, -0.19285837f, -0.04993806f, 0.19189388f, 
    -0.01519612f, -0.02006540f, -0.16618997f, -0.55582553f, -0.01939673f, -0.10022697f, 0.00085652f, -0.04390691f, 
    -0.04898550f, -0.00497215f, 0.02542247f, -0.07591756f, 0.01803944f, 0.22198209f, 0.12051615f, 0.21893315f, 
    -0.19143061f, -0.04253478f, 0.21484424f, -0.49773622f, 0.23604959f, -0.26710758f, 0.07617885f, -0.10422586f, 
    0.13058013f, -0.33198556f, -0.16245569f, 0.17049451f, 0.07839539f, -0.05004951f, -0.05787441f, -0.08738405f, 
    0.20608409f, 0.22582453f, -0.07149293f, -0.23819533f, 0.10948023f, 0.09534945f, 0.47305423f, 0.34368205f, 
    0.17328128f, 0.08762238f, 0.06306627f, -0.11887524f, 0.20724049f, 0.05324028f, -0.09368789f, 0.02095634f, 
    0.11501494f, -0.14908169f, -0.11313172f, -0.07403555f, 0.16882156f, -0.06027725f, 0.26542723f, -0.08489616f, 
    -0.12694715f, 0.07073326f, -0.01867009f, -0.06487047f, -0.15396824f, 0.02233776f, -0.31032348f, -0.07278728f, 
    -0.25744167f, 0.00281117f, -0.36410797f, -0.12935252f, 0.05757501f, 0.03108920f, -0.29815531f, -0.07452798f, 
    -0.49849811f, -0.19444668f, -0.04957996f, 0.14555660f, -0.25213659f, -0.25097716f, 0.29341099f, 0.05254618f, 
    -0.26590171f, -0.28159419f, 0.10182386f, -0.02406569f, 0.16885522f, 0.18825512f, -0.18918733f, 0.04570216f, 
    0.13847327f, -0.04376214f, 0.00714881f, -0.20804502f, -0.12857345f, -0.46258634f, -0.15766640f, -0.06202626f, 
    0.29918185f, 0.05232366f, -0.47379670f, -0.01992436f, -0.77022344f, 0.07080465f, 0.09673304f, -0.08872178f, 
    0.17598008f, -0.40178123f, 0.08197724f, 0.26903635f, 0.05669250f, -0.39137962f, 0.03614829f, -0.16874206f, 
    -0.36463001f, 0.08716234f, 0.22262499f, 0.25526938f, 0.14461437f, -0.00286476f, -0.00094570f, 0.61249179f, 
    0.00336083f, -0.05902777f, 0.02679390f, 0.10137559f, -0.25350323f, 0.01927041f, -0.06332668f, -0.09753709f, 
    0.03323857f, -0.19101143f, 0.06429574f, 0.13761917f, 0.10208939f, -0.49263814f, -0.02406898f, -0.49499086f, 
    0.19550671f, 0.15004788f, 0.03639457f, -0.05346158f, -0.08587436f, -0.08889433f, 0.00499240f, -0.20312312f, 
    0.17031257f, 0.17970905f, -0.10898644f, 0.03555570f, 0.25146365f, -0.21465738f, 0.24102895f, 0.05439437f, 
    0.22693269f, 0.13384271f, 0.19811936f, 0.03347622f, -0.00373067f, -0.06891064f, -0.03394801f, -0.31562841f, 
    0.16007428f, 0.04274587f, -0.22953403f, -0.16659369f, 0.03582235f, 0.09654582f, 0.24838309f, -0.42844477f, 
    0.27672508f, 0.04062497f, 0.01971283f, 0.49087158f, 0.00448189f, -0.01847243f, 0.00226629f, -0.04676917f, 
    0.17780295f, 0.07622201f, -0.07184247f, -0.20002635f, 0.07756888f, -0.53758419f, -0.00549967f, -0.05302232f, 
    0.25091749f, -0.05689279f, -0.10010464f, 0.24021108f, 0.06724924f, -0.20334183f, -0.44888979f, -0.18393576f, 
    -0.46145338f, -0.06711248f, -0.43159682f, 0.26325142f, 0.26929536f, 0.00825795f, 0.31779015f, 0.27209327f, 
    -0.08818904f, -0.36574841f, 0.24620809f, -0.22781323f, 0.04735155f, -0.04952277f, 0.15507051f, 0.06191612f, 
    0.09607168f, -0.24522495f, -0.04588293f, -0.58100975f, 0.16388987f, -0.05066520f, -0.75732183f, -0.31057051f, 
    0.12034380f, -0.07923914f, -0.04791407f, -0.49146789f, 0.03576995f, 0.01948555f, -0.05990109f, -0.04059325f, 
    -0.14123355f, -0.21907981f, 0.30337673f, -0.05102772f, -0.36847278f, 0.08903668f, 0.07001171f, 0.06289170f, 
    0.16013826f, -0.54230362f, -0.14401659f, 0.14849013f, -0.02757283f, -0.29719174f, 0.05374162f, 0.13483791f, 
    -0.08999749f, -0.10411923f, -0.26443577f, 0.07392476f, 0.12107449f, -0.10768123f, -0.09917616f, -0.47041860f, 
    -0.06326228f, -0.46605995f, -0.31962052f, 0.17672735f, 0.11680074f, -0.17549373f, 0.01350620f, -0.20069981f, 
    0.31730440f, -0.26341987f, -0.17480585f, 0.17406864f, 0.00056877f, -0.11085057f, -0.09703979f, -0.59251982f, 
    -0.51051605f, 0.05526278f, -0.05848770f, 0.08295339f, -0.09217113f, -0.09397770f, -0.25304484f, -0.44390011f, 
    0.09301553f, -0.50536710f, 0.15812141f, 0.13812344f, -0.71579981f, 0.35822779f, 0.21021153f, -0.15052174f, 
    0.01573985f, 0.12212935f, -0.13909957f, 0.03090052f, 0.03944351f, 0.28605813f, 0.14677116f, -0.34381446f, 
    -0.09679922f, 0.06048308f, -0.12426680f, -0.29932216f, 0.07730614f, 0.17098570f, -0.25467983f, -0.01959798f, 
    -0.33902532f, 0.08275811f, -0.06475809f, -0.10345703f, 0.08964877f, -0.02402298f, 0.10663410f, -0.00718620f, 
    -0.67345357f, 0.05797225f, 0.00690524f, 0.23928109f, -0.17261705f, 0.23189640f, -0.31888279f, 0.13059460f, 
    -0.47302246f, -0.02987600f, -0.07807676f, -0.61078966f, 0.01091497f, -0.12463620f, 0.13371354f, -0.87629074f, 
    0.17724155f, -0.00987293f, 0.19912075f, -0.02280329f, 0.06356377f, 0.00331287f, -0.59384805f, -0.23558491f, 
    0.24274586f, 0.18712005f, -0.27748826f, 0.09912275f, -0.04849637f, 0.05438574f, -0.14739741f, -0.36028042f, 
    0.06031854f, 0.17885630f, 0.14823334f, 0.15765665f, -0.36042738f, 0.10105610f, 0.35468724f, 0.14381257f, 
    0.20891975f, 0.00777314f, -0.06521285f, 0.27910265f, -0.04659710f, -0.20091943f, 0.16290049f, 0.07110884f, 
    -0.31932282f, -0.09890489f, -0.32056296f, 0.02235693f, 0.11774318f, -0.20175584f, -0.39057103f, -0.03755175f, 
    0.24218634f, -0.05068497f, 0.20396775f, 0.08684117f, -0.05081981f, 0.27161697f, -0.06866965f, 0.05888947f, 
    -0.16651192f, -0.02478640f, 0.08414628f, 0.05373631f, -0.03359066f, -0.08116671f, -0.07026263f, 0.10867706f, 
    -0.02695378f, 0.30829105f, -0.32080284f, -0.29378682f, -0.33891356f, 0.00353353f, 0.00007906f, -0.06338245f, 
    -0.73310816f, -0.01322984f, -0.18296567f, -0.31514052f, 0.05755725f, 0.16069762f, -0.32052988f, 0.08250174f, 
    0.27396604f, -0.41237652f, 0.05985568f, -0.00202332f, -0.03495954f, -0.76388180f, 0.07519423f, -0.10073908f, 
    -0.29053825f, 0.05545159f, 0.13514259f, -0.30107185f, -0.10225583f, -0.52525592f, -0.26088145f, -0.09967753f, 
    0.13998161f, -0.37895778f, 0.13814543f, 0.05601227f, -0.05116216f, -0.54133159f, -0.43548554f, -0.06444520f, 
    0.08196294f, 0.18445079f, -0.48629478f, 0.19185208f, 0.04831007f, 0.02493755f, -0.07447916f, 0.31066698f, 
    -0.45139921f, -0.07387000f, -0.00381951f, 0.18105319f, 0.00092665f, 0.08058202f, -0.48843813f, 0.05619530f, 
    0.03035218f, -0.03906343f, -0.07484458f, -0.02422190f, 0.07433008f, -0.13361214f, 0.15233432f, -0.47536600f, 
    -0.28245035f, -0.26496309f, -0.26343781f, 0.18643814f, -0.75853652f, 0.15768777f, 0.23270771f, -0.08663214f, 
    0.15149431f, 0.07686703f, 0.24574693f, -0.24275374f, -0.52065039f, -0.01833088f, -0.11605416f, -0.43978679f, 
    -0.07393328f, 0.33843264f, -0.21795720f, -0.09531775f, -0.12477214f, -0.31853145f, -0.05640699f, 0.08150549f, 
    0.42288584f, 0.20412603f, -0.17550915f, -0.56519520f, 0.18145034f, -0.42789569f, -0.07943559f, 0.03027121f, 
    -0.23356760f, -0.06701317f, 0.03331191f, -0.20614524f, 0.21907899f, -0.04351274f, -0.52797049f, 0.07639530f, 
    0.22785805f, 0.40022820f, -0.53414452f, 0.07320640f, 0.20397045f, 0.01960338f, -0.18547004f, -0.03102416f, 
    0.02481387f, -0.69335276f, 0.14011468f, 0.43510297f, 0.03396760f, -0.00018715f, 0.15009861f, -0.67549729f, 
    0.35198188f, 0.19216965f, 0.17712665f, -0.27504671f, -0.01540516f, -0.00933447f, -0.07595307f, -0.39667073f, 
    0.00920879f, 0.49846905f, -0.04307306f, 0.04519334f, -0.02954573f, 0.40105227f, 0.02046916f, -0.02947048f, 
    -0.08626099f, 0.18105622f, 0.13843203f, -0.00414663f, -0.26067495f, -0.25535813f, 0.06909569f, -0.02688535f, 
    -0.20151491f, -0.15776031f, -0.00180266f, 0.07308684f, -0.01084665f, 0.11777209f, 0.09635791f, -0.22886686f, 
    -0.02876611f, 0.25858122f, -0.79547727f, -0.21463311f, 0.20136273f, -0.04428559f, -0.03346533f, 0.29111671f, 
    -0.12833588f, -0.13684720f, -0.08811095f, 0.05337998f, -0.03801543f, -0.01530533f, 0.20404787f, -0.08350903f, 
    -0.43039936f, -0.19810893f, 0.04029307f, 0.38819394f, -0.19629510f, -0.03523319f, -0.29425314f, -0.31640229f, 
    0.09533859f, 0.03214289f, 0.05183987f, 0.46266207f, -0.05552090f, -0.03301543f, -0.34961390f, 0.06109189f, 
    0.11737151f, 0.43659657f, 0.04339657f, -0.03037877f, 0.09080017f, -0.27761567f, -0.14599261f, 0.06138805f, 
    0.01834905f, -0.00451750f, 0.25336176f, -0.00538777f, -0.16750541f, -0.43813607f, 0.14757039f, -0.29150715f, 
    0.11750118f, -0.02802618f, 0.00102703f, 0.45550084f, -0.00849232f, -0.11228297f, -0.10600204f, -0.13790624f, 
    -0.06967805f, 0.33275980f, -0.04148488f, -0.00127007f, 0.20822123f, -0.01378251f, -0.06611040f, -0.38116810f, 
    0.32820001f, 0.25597256f, -0.17792702f, 0.08968604f, -0.03438652f, -0.15514423f, -0.14991832f, 0.00264423f, 
    0.10412581f, -0.12051047f, 0.09446760f, -0.01416806f, 0.13870645f, -0.03083924f, 0.12015039f, 0.01072533f, 
    -0.42794138f, -0.60695082f, 0.05195872f, -0.00341074f, 0.52310902f, 0.07121955f, -0.04788988f, 0.01231904f, 
    0.08988678f, 0.03961113f, -0.26732960f, 0.12817258f, -0.03638136f, 0.01928237f, -0.17033635f, 0.01705262f, 
    -0.26145902f, -0.16750507f, -0.50709701f, -0.32306316f, 0.16873837f, -0.03333654f, -0.01883669f, 0.53972518f, 
    0.08868025f, -0.11158343f, -0.02928136f, 0.03591266f, -0.23808646f, 0.08619186f, 0.00323416f, -0.81378210f, 
    -0.06526215f, -0.07400697f, -0.32524678f, 0.11341945f, 0.07843205f, 0.14786105f, 0.02244265f, -0.22338514f, 
    0.48899576f, 0.07400432f, -0.05356712f, 0.08787300f, 0.05341439f, 0.07343896f, -0.31373009f, 0.13735913f, 
    -0.44838390f, -0.19966619f, 0.03602630f, -0.13757248f, -0.07049561f, 0.13786176f, 0.17285977f, 0.35331133f, 
    -0.11302570f, -0.07788844f, 0.11512299f, -0.17712103f, 0.06767984f, 0.15031312f, 0.11763550f, 0.12417073f, 
    -0.12261510f, 0.06947307f, 0.19938569f, -0.11402282f, -0.07656442f, 0.29149303f, 0.00320621f, 0.01572776f, 
    -0.28515190f, -0.05504932f, -0.01695257f, -0.32786608f, -0.01839885f, -0.00898942f, 0.18501845f, 0.04497333f, 
    -0.07291815f, -0.87763369f, 0.01027181f, -0.52927989f, -0.32074222f, -0.18359779f, 0.25091347f, 0.30053994f, 
    -0.41242883f, -0.33605063f, 0.07416972f, 0.06850483f, 0.04920099f, 0.15681073f, -0.46160138f, -0.22165407f, 
    0.24350715f, 0.03860085f, -0.12542954f, -1.47600746f, -0.32307333f, 0.05715948f, 0.10517717f, -0.42402533f, 
    0.19335838f, -0.08211900f, 0.34064806f, 0.12484690f, -0.64184332f, 0.26478979f, -0.10508259f, 0.13143484f, 
    -0.32545239f, -0.09364219f, 0.02592709f, 0.19151531f, -0.11606210f, 0.07814648f, -0.04139950f, 0.17457965f, 
    0.00885255f, 0.07971083f, 0.00855714f, -0.04979706f, -0.24097551f, -0.15032613f, 0.04943470f, 0.01840242f, 
    0.10486781f, 0.08690070f, 0.12139308f, -0.05527008f, -0.10049852f, -0.16377462f, -0.36483163f, 0.05855478f, 
    -0.46582922f, 0.52893543f, 0.02216215f, -0.32889232f, 0.04243097f, 0.01066948f, 0.10801750f, -0.17352980f, 
    0.28546187f, 0.00441931f, 0.13398799f, -0.11471175f, -0.47190976f, 0.02314953f, -0.01452232f, -0.54403526f, 
    0.05663789f, 0.08448198f, 0.23554254f, -0.16396898f, -0.07516503f, 0.22064927f, -0.00215827f, 0.19114764f, 
    0.01839277f, -0.05071212f, 0.24987258f, 0.05483624f, -0.06619723f, 0.09520778f, -0.16842479f, 0.09858079f, 
    0.02011442f, 0.13169992f, 0.06381061f, -0.05845685f, 0.05362015f, -0.00845258f, 0.24452095f, 0.04037541f, 
    0.22086596f, 0.11818764f, -0.21036969f, 0.49290392f, -0.34382460f, 0.03477211f, -0.80423534f, 0.22802113f, 
    -0.26339355f, 0.09104981f, -0.16891371f, 0.09059779f, 0.05386700f, -0.10846855f, -0.02574979f, 0.07549345f, 
    -0.14773946f, -0.38168702f, 0.25200927f, 0.25411361f, 0.21691827f, -0.55043584f, 0.21105757f, 0.19707249f, 
    -0.11177626f, 0.06159478f, 0.01660493f, -0.23791374f, 0.10466544f, 0.01747635f, -0.13455182f, 0.03352244f, 
    -0.00437326f, -0.35257506f, -0.01697818f, -0.45281747f, 0.30880696f, 0.13704596f, -0.09777950f, -0.42693695f, 
    0.38998991f, -0.32268155f, -0.25947675f, 0.33244196f, 0.18244778f, -0.00535197f, 0.12358345f, -0.35263267f, 
    0.23073083f, 0.02668817f, 0.13096242f, -0.55369312f, 0.18138804f, 0.05310984f, 0.07019859f, -0.07255574f, 
    -0.29052785f, 0.01408545f, 0.25651473f, 0.00750263f, 0.03138999f, 0.01714709f, 0.02382408f, -0.01750333f, 
    -0.48320195f, -0.21923602f, -0.16039310f, 0.03853205f, 0.00858022f, 0.10470141f, -0.20552176f, -0.56860626f, 
    -0.47737616f, 0.04898201f, 0.02039155f, 0.21263772f, -0.28360900f, 0.29471615f, -0.09694472f, -0.04621129f, 
    -0.26014650f, 0.19574924f, 0.09074198f, -0.01664967f, -0.13761415f, -0.01340483f, -0.07182128f, -0.03874877f, 
    0.08253098f, -0.10985197f, 0.05154463f, -0.38050440f, 0.02575469f, 0.40341547f, 0.07903142f, -0.23251621f, 
    0.06220160f, 0.09622657f, -0.00731558f, -0.34778795f, -0.56868422f, -0.07379134f, -0.00359968f, -0.31711105f, 
    -0.01005264f, -0.31723851f, 0.21689205f, 0.11095352f, 0.26572156f, -0.44225138f, 0.05245435f, -0.45089784f, 
    0.12556320f, 0.11835985f, -0.07880837f, 0.09128635f, 0.07964975f, 0.16589054f, 0.07175756f, 0.23629203f, 
    -0.30259922f, 0.30348262f, 0.02278300f, -0.01464445f, -0.01437196f, 0.12472657f, 0.21030436f, -0.61818582f, 
    0.09815730f, -0.34828886f, -0.10944629f, 0.03437229f, -0.11129728f, -0.07223111f, -0.02228528f, 0.20882715f, 
    -0.26952547f, 0.23356420f, 0.21697094f, -0.33293453f, -0.04718617f, 0.09542137f, 0.19866630f, -0.48039770f, 
    0.25430065f, -0.37507340f, 0.34949097f, -0.69441545f, 0.10428935f, 0.04221362f, -0.64628905f, -0.38651612f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.12681906f, -0.11900571f, -0.05295908f, -0.16849670f, 0.07624356f, 0.05420192f, -0.13906974f, -0.41829687f, 
    -0.19875619f, -0.00279548f, 0.11063164f, 0.07484996f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
