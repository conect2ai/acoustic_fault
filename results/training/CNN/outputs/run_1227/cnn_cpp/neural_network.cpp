#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.88854313f, -0.31102467f, -0.19087927f, 0.29779577f, -0.13550109f, -0.36842555f, 0.34242991f, -0.94713873f, 
    -0.85003310f, 0.17103188f, -0.64329988f, 0.17381126f, -0.72576559f, 1.48385537f, -1.34642887f, 0.12050224f, 
    0.18866517f, 0.08057409f, -0.10063325f, 0.34336469f, 1.07497954f, -1.07235420f, -0.02857219f, 0.51012892f, 
    -0.59369487f, 0.21430184f, 0.41051769f, -0.13768023f, 0.15457843f, 0.60700125f, 0.42720369f, -0.66993099f, 
    0.62545657f, -0.03244327f, -0.22593632f, -0.55307788f, -0.36565870f, 0.58871746f, 0.12386464f, 0.49378029f, 
    0.43826076f, -0.09272379f, 0.11151945f, 0.56185883f, 0.44396469f, -0.15902513f, 0.79335606f, -0.41226560f, 
    -0.07304090f, 0.14991568f, 0.37878573f, 0.68347704f, 0.03811194f, -0.25623026f, 0.75617242f, -0.76199400f, 
    -0.30760461f, -0.54421455f, -0.72421539f, -0.97717941f, -0.34857228f, 0.06030295f, 0.09395511f, -0.54333109f, 
    -0.40131497f, 0.18556315f, 0.17889090f, 0.75584126f, 0.73962194f, -0.59015250f, -0.91854411f, -0.72173977f, 
    -0.28674373f, 1.25241482f, -0.19689417f, 0.54010707f, -0.66443807f, -0.13116489f, -0.28456324f, -0.27684474f, 
    0.71694583f, -0.41379777f, -1.29467940f, -1.20314419f, -0.05711509f, 0.91149753f, 0.37877434f, -0.11749940f, 
    -0.12617455f, -0.56826639f, -1.46739399f, -0.51091909f, -0.14662009f, -0.52793396f, -0.41222322f, -0.38244489f, 
    0.30539614f, -0.21514863f, -0.71452147f, 0.64473677f, -0.12412211f, -0.19608398f, 0.69295424f, 0.56658882f, 
    0.74522126f, -0.57606626f, 0.62970167f, -0.37354803f, -1.41645288f, -0.35168174f, -1.22318220f, 0.88212460f, 
    0.44076142f, 0.61866397f, 0.00594262f, 0.39807963f, 0.14776497f, 1.24162674f, 1.06765938f, 0.58966506f, 
    -0.38469407f, -0.29409942f, -0.74647474f, 0.16514735f, 0.14473200f, 0.57543695f, 0.89576882f, 0.56063229f, 
    -0.24332742f, -0.95562261f, -0.74193567f, -0.80534953f, -0.45867962f, -0.88094926f, -0.30507603f, 0.67552495f, 
    -0.77666271f, -0.25452211f, -0.43013418f, -0.34267339f, 0.93526578f, 0.25465775f, -0.27204135f, 0.50510949f, 
    0.61359221f, 0.36246216f, 0.81783921f, -0.58789855f, 0.49112120f, 0.02264799f, 0.42064503f, 0.45740190f, 
    -0.12465636f, -1.12440121f, 0.02946469f, -0.22935040f, -0.17737558f, -0.52640545f, -0.93462527f, -0.52724326f, 
    -0.82887715f, -0.26252684f, -1.51443732f, 1.34679866f, -0.15322921f, -0.08282522f, 0.80557948f, -0.50143635f, 
    -0.28612280f, 0.02841499f, -0.06145638f, -0.06335355f, -0.10273632f, 0.07703461f, -0.79544288f, -1.14594889f, 
    -0.89095652f, 0.07434164f, 0.87875879f, -0.29188293f, 1.01882482f, 0.70554233f, -0.94084060f, -0.29101014f, 
    0.31294003f, -0.09596809f, -0.18882288f, 0.19493182f, 0.16044752f, 0.31701538f, 0.78017890f, 0.62632805f, 
    -0.37003097f, -0.11912154f, -0.21816045f, -0.26026684f, -0.72729450f, -0.33941615f, 0.93089253f, -1.29986060f, 
    0.66555464f, -0.87495387f, -0.24302985f, 0.26046956f, -0.82016855f, 0.13171032f, -0.21333453f, -1.14166141f, 
    -0.70443779f, -0.57880634f, 0.30421907f, -0.53707355f, 0.12412663f, 0.36804646f, 0.44854084f, 0.67291451f, 
    -0.65271461f, -0.19968762f, -0.12106445f, 0.57457232f, 0.58092868f, 0.87587821f, 0.36452711f, 0.30948645f, 
    0.42936540f, -0.60980672f, -0.49768284f, -0.81829756f, 0.10935640f, -0.77457190f, -1.18533421f, -0.42455661f, 
    -0.31294519f, -0.20206964f, -0.18302113f, -0.57589811f, 0.53451383f, 0.42034104f, -0.18485782f, 0.95003033f, 
    0.77515000f, -0.36617696f, -0.25477940f, 0.44723114f, 0.12962946f, -0.77963835f, -0.77470273f, -0.06245421f, 
    -0.38104698f, 0.42664698f, 0.45891219f, 0.95999676f, 0.01302752f, -0.62483793f, 0.49439761f, -0.02269662f, 
    -0.74238056f, -0.48001572f, 0.22601011f, 0.57084417f, 0.73264629f, 1.26384509f, -0.81922948f, -1.17036903f, 
    0.63286978f, 0.05679664f, 0.23926340f, 0.12160579f, 0.10032448f, -0.35746062f, 0.42487618f, 0.58374357f, 
    -0.70841676f, 0.32572076f, 0.45276949f, 0.36164805f, -0.50888145f, 0.51694083f, -0.30894348f, -0.36236319f, 
    0.65983266f, -0.59246087f, 0.65858710f, -0.16365686f, 0.84936500f, -0.39640510f, -0.36886528f, -0.08397599f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.10269359f, -0.13446470f, 0.43996310f, 0.34298924f, -0.11024343f, 0.64394414f, 0.67888570f, 0.04348166f, 
    0.03976917f, 0.72184175f, 0.10201114f, 0.16406669f, 0.44175380f, 0.17846599f, -0.27915332f, -0.00517296f, 
    0.17635520f, 0.03873301f, -0.04284643f, 0.42131159f, 0.63070238f, 0.17940898f, 0.29442227f, 0.35214135f, 
    0.46490511f, -0.60903615f, 0.18313436f, 0.07161684f, -0.03817410f, 0.34153065f, 0.57664222f, 0.07802923f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.15274136f, -0.03472241f, -0.13852067f, -0.04236459f, 0.07772426f, 0.02123796f, 0.28378138f, 0.01394711f, 
    0.05085076f, -0.72997350f, -0.73265922f, 1.02018106f, 0.02849463f, -0.05332475f, -0.00661783f, 0.23961306f, 
    0.32214648f, 0.30227518f, -0.01010612f, -0.15067732f, -0.28924841f, -0.00873726f, 0.11915798f, 0.08049180f, 
    0.21528897f, 0.17234786f, 0.23171043f, -0.00715148f, 0.02369702f, 0.00748864f, -0.00271074f, 0.01857620f, 
    -0.05684302f, -0.05378016f, -0.15238535f, 0.06547808f, -0.13346012f, -0.08977804f, -0.17206462f, 0.09957938f, 
    -0.00330812f, 0.10327254f, -0.04650525f, 0.15048207f, 0.12548116f, 0.06855139f, -0.00503892f, 0.05737404f, 
    0.21803129f, 0.11637699f, 0.23589589f, 0.03252085f, 0.24082433f, 0.28841904f, -0.14001988f, -0.32005993f, 
    -0.09465656f, 0.13048299f, 0.04131570f, 0.10300805f, 0.12015482f, -0.02992006f, 0.22916606f, -0.18687047f, 
    -0.10100321f, -0.16517559f, 0.02151345f, -0.08514921f, -0.08856333f, -0.09169327f, -0.09191903f, 0.15903893f, 
    -0.01905260f, -0.09891192f, 0.30237794f, -0.26865667f, 0.17473324f, 0.16557018f, 0.50187433f, 0.18799575f, 
    0.20539916f, -0.32509816f, 0.10997807f, 0.19497514f, -0.05554727f, 0.02717045f, 0.23198427f, 0.04003568f, 
    0.09042645f, 0.20466420f, -0.51626128f, -0.19529848f, 0.07790273f, -0.05460878f, 0.01481173f, -0.03038226f, 
    -0.11076942f, -0.00190168f, -0.16298175f, -0.08508710f, -0.16144420f, -0.20041527f, 0.03388174f, -0.17697896f, 
    -0.11862462f, -0.11841881f, -0.01415587f, 0.17483719f, -0.33877942f, 0.11031406f, -0.20984542f, -0.00307614f, 
    -0.09563573f, -0.01510662f, -0.11278026f, -0.02846851f, 0.16413289f, 0.06063426f, -0.52713019f, -0.18405826f, 
    -0.15330975f, -0.02620796f, 0.03870887f, -0.05191008f, 0.07850271f, 0.14336836f, -0.10024475f, -0.58384001f, 
    -0.41766325f, -0.04923411f, 0.15538286f, 0.09208824f, 0.16497752f, -0.14984302f, 0.06470574f, 0.16480967f, 
    0.21248788f, -0.09418415f, -0.41177154f, 0.36586359f, 0.12251543f, 0.39360157f, 0.17767982f, 0.19265097f, 
    0.05322953f, -0.20772313f, 0.03295373f, -0.08796021f, -0.12708217f, -0.16509308f, -0.07318152f, 0.18827140f, 
    0.18087059f, -0.17166576f, -0.30678537f, 0.16780031f, 0.07201038f, -0.00809344f, 0.10594888f, 0.12880866f, 
    0.01268626f, 0.00343624f, -0.06347444f, 0.19141404f, 0.43294919f, -0.04749437f, -0.01726579f, 0.26240155f, 
    -0.01935396f, 0.04174108f, 0.03045557f, -0.72684914f, -0.58401251f, -0.31147224f, 0.15315756f, 0.19213875f, 
    0.07253424f, 0.13625446f, 0.02636223f, 0.07371519f, 0.25939456f, 0.08571602f, 0.05288185f, 0.02454806f, 
    0.17722236f, 0.19379774f, 0.03012622f, 0.40201476f, 0.10567391f, -0.16397153f, -0.15000452f, -0.19740054f, 
    -0.08246155f, 0.10711834f, 0.00245273f, 0.01676136f, -0.28714561f, -0.06814605f, 0.02527323f, -0.12276153f, 
    -0.33915034f, 0.03063840f, 0.12377049f, 0.33843389f, 0.01445091f, -0.06285283f, 0.19672056f, -0.39443171f, 
    0.39977813f, -0.00514943f, 0.01126531f, 0.02640596f, -0.09212822f, 0.05476504f, -0.02569466f, 0.10599075f, 
    -0.06937249f, -0.01959550f, -0.17064275f, -0.06741622f, -0.04504031f, 0.05973906f, -0.04381013f, 0.07173118f, 
    0.17124280f, -0.17177902f, -0.64912987f, -0.17321043f, -0.06346577f, -0.20844862f, -0.10127299f, 0.05518251f, 
    0.00821230f, 0.16686039f, 0.07995080f, -0.05901257f, 0.11129063f, -0.11518724f, -0.01067532f, -0.11649750f, 
    0.00521549f, 0.05081518f, 0.11042649f, 0.04548714f, -0.04345158f, -0.33199418f, -0.26934367f, 0.00636560f, 
    -0.05402816f, 0.14265415f, 0.04972444f, 0.02086796f, -0.27331352f, 0.12299934f, 0.06938921f, -0.18393449f, 
    -0.04056402f, 0.02422811f, 0.15842879f, -0.06581007f, 0.29945979f, 0.17413008f, 0.42751971f, 0.27376032f, 
    -0.09751849f, 0.15066451f, 0.19759236f, 0.01638133f, 0.14521877f, 0.32940021f, 0.11214153f, -0.04416888f, 
    -0.06467365f, 0.12037993f, 0.14229456f, 0.08027799f, -0.03683878f, -0.05900167f, 0.14036754f, -0.10376436f, 
    -0.03038622f, -0.27958933f, -0.08755181f, -0.35446131f, -0.15760446f, 0.12050225f, -0.21162854f, 0.25007728f, 
    -0.04829206f, -0.04118637f, -0.06418797f, 0.00158866f, -0.00025165f, 0.03741947f, -0.04082836f, -0.03881997f, 
    -0.00554948f, -0.04321163f, 0.03065310f, -0.03663304f, -0.03796494f, -0.02024098f, 0.05525030f, 0.02078067f, 
    -0.06117588f, -0.03738035f, -0.01295813f, 0.04673427f, 0.00410812f, 0.03585838f, 0.02641535f, 0.01111163f, 
    0.00009743f, -0.00598940f, 0.04836372f, 0.02997741f, -0.04973099f, 0.00421402f, -0.00005018f, 0.00734358f, 
    0.02904654f, 0.05436865f, 0.00493244f, 0.01272260f, -0.02074365f, 0.02140775f, -0.00014351f, -0.02364427f, 
    0.03724007f, -0.04835953f, 0.00767074f, -0.06739233f, 0.00740553f, -0.04935944f, -0.06449932f, -0.04856138f, 
    -0.06552072f, 0.03207825f, -0.02099252f, -0.01991834f, -0.01910789f, -0.06282346f, 0.02914473f, 0.02424775f, 
    0.01317861f, -0.01202237f, 0.04286005f, -0.00420605f, -0.00712517f, -0.03254260f, -0.05666493f, 0.00035910f, 
    -0.05779904f, 0.03334896f, 0.03949092f, -0.01916423f, 0.01080836f, -0.05669135f, -0.03932295f, 0.02802576f, 
    0.02357497f, -0.01379432f, -0.05568626f, -0.03826186f, -0.05671735f, -0.02252594f, 0.03697756f, 0.03053193f, 
    0.04664111f, 0.03222363f, 0.04013052f, 0.03152980f, -0.02790678f, -0.02095185f, -0.00231926f, 0.03167085f, 
    0.00947668f, -0.03758726f, -0.03047175f, 0.03345549f, 0.00313658f, -0.00666148f, -0.01654678f, -0.05069468f, 
    -0.06030595f, -0.00777775f, 0.03298760f, 0.03185505f, -0.03561662f, 0.03707873f, -0.04371190f, 0.00912374f, 
    0.05097837f, 0.01511636f, -0.04032235f, -0.01188594f, 0.00261241f, -0.06112725f, -0.04561036f, 0.04701078f, 
    -0.00528248f, -0.00262370f, -0.04497394f, -0.04201772f, -0.03876521f, 0.04433128f, -0.00158970f, -0.00852349f, 
    0.02147872f, -0.03262255f, 0.03409968f, -0.05132620f, 0.03091278f, 0.00751523f, 0.02730933f, 0.04214765f, 
    0.00260930f, 0.04066670f, -0.00766553f, 0.01252424f, 0.01849746f, -0.03628800f, -0.02168237f, -0.00933231f, 
    -0.06895857f, -0.01170742f, 0.04894944f, 0.03171788f, -0.00853950f, -0.01172123f, 0.03342527f, 0.03340789f, 
    -0.03075582f, -0.03665147f, -0.02669539f, 0.04984189f, 0.00752353f, -0.05441750f, -0.00909753f, -0.04553201f, 
    -0.01552241f, 0.04689677f, -0.03556009f, -0.00553411f, -0.06379791f, 0.03069516f, -0.05321204f, 0.05123350f, 
    -0.01285083f, 0.01774357f, -0.02254237f, -0.05387944f, 0.04076592f, 0.01868114f, 0.01936329f, 0.00809524f, 
    -0.01631187f, -0.03914016f, 0.01169302f, 0.02540132f, -0.01577187f, -0.02455502f, -0.05807772f, 0.00443054f, 
    0.00335131f, 0.04796457f, -0.00046781f, -0.00610659f, -0.04848292f, -0.01310460f, 0.05394359f, -0.05976715f, 
    0.00473476f, -0.01785352f, -0.01536227f, -0.06189893f, 0.01278275f, -0.04379536f, -0.02891718f, -0.02653343f, 
    0.00097239f, -0.05206241f, -0.04870324f, -0.04981954f, -0.04781308f, 0.03491615f, 0.00105609f, -0.05754977f, 
    -0.01146958f, -0.01618577f, -0.07071116f, -0.04426618f, 0.00180063f, -0.05966013f, -0.04021197f, -0.05612844f, 
    -0.02468069f, -0.01808095f, 0.00554247f, -0.02757028f, 0.03054366f, -0.00778756f, -0.02672944f, 0.03899311f, 
    -0.02194027f, 0.02236133f, -0.06192169f, 0.02033505f, -0.06207226f, -0.06176142f, 0.00673951f, 0.03841736f, 
    -0.04644633f, 0.03198273f, -0.03202953f, -0.04070965f, -0.01431586f, -0.00265083f, 0.02428645f, 0.00790783f, 
    -0.00080682f, -0.00202065f, -0.02744789f, 0.03749773f, 0.04956088f, 0.03696159f, 0.04053812f, -0.02920683f, 
    -0.04455100f, -0.02079315f, -0.04608596f, 0.02287862f, 0.03060150f, 0.03245117f, -0.00063525f, -0.03515699f, 
    -0.05293680f, -0.04295944f, -0.06496941f, -0.00759484f, 0.05051898f, -0.01882262f, -0.02520973f, -0.01619689f, 
    -0.04098480f, 0.04153460f, 0.03343350f, 0.00550100f, -0.01932970f, -0.05888783f, -0.04569666f, -0.02494009f, 
    -0.03617661f, 0.03208865f, 0.03317345f, 0.04516398f, -0.02334833f, 0.04549552f, -0.02901850f, 0.04956796f, 
    0.00207634f, -0.05468447f, -0.03888543f, -0.03575829f, -0.05540458f, 0.05166126f, -0.03595765f, -0.05980546f, 
    -0.02797516f, 0.05895564f, 0.01935180f, -0.04719204f, -0.05245811f, -0.02682163f, -0.04721334f, 0.01292995f, 
    0.08178154f, -0.42500505f, 0.00662867f, -0.12489026f, -0.02893849f, 0.19614327f, 0.08194102f, -0.14572276f, 
    0.03310325f, -0.21488531f, -0.13514327f, 0.22730878f, -0.21107948f, -0.04690939f, -0.29062709f, 0.11485758f, 
    0.14618188f, -0.15439682f, -0.56191224f, -0.14804299f, -0.43598485f, -0.00345916f, 0.03052858f, -0.04451124f, 
    -0.25139248f, 0.14417593f, 0.02404248f, -0.30915314f, -0.19864798f, -0.16939902f, -0.04195649f, 0.11852467f, 
    -0.11381897f, -0.04097027f, 0.12927800f, 0.17233922f, -0.02486804f, -0.07633185f, -0.03166167f, -0.05473145f, 
    0.01968113f, -0.00718127f, 0.23849024f, 0.06246291f, 0.01376283f, -0.22195958f, -0.16306788f, -0.07868674f, 
    -0.07428171f, 0.06426475f, 0.13431634f, 0.12334546f, 0.09664439f, 0.19558994f, 0.04270810f, 0.22015727f, 
    0.14874656f, -0.09987779f, -0.09549702f, 0.12505531f, -0.02580190f, -0.08939324f, 0.05381213f, 0.05913906f, 
    0.29402769f, -0.24775988f, -0.21339592f, -0.34299269f, -0.33045927f, -0.05289092f, 0.09426868f, 0.04024742f, 
    -0.59895128f, 0.02690468f, -0.32590020f, -0.07745626f, 0.01066249f, -0.03452872f, 0.12410985f, 0.12291029f, 
    0.17959630f, -0.00899018f, 0.14936052f, 0.18054922f, 0.01537748f, -0.32288510f, -0.05904031f, -0.03353607f, 
    -0.01724050f, 0.04658123f, -0.11654949f, -0.10709403f, 0.10741544f, -0.09889513f, -0.03255883f, -0.04751975f, 
    0.14590684f, -0.01214709f, 0.14098626f, 0.22001883f, 0.24837017f, 0.17235291f, -0.16430013f, -0.37596494f, 
    -0.11563316f, -0.04107342f, 0.00406019f, -0.03103532f, 0.11761263f, 0.22210345f, 0.19682719f, -0.15080367f, 
    -0.13367207f, 0.00180089f, 0.04312059f, -0.09137688f, -0.06908417f, -0.02503084f, 0.06496210f, -0.06709766f, 
    0.20031399f, 0.21116798f, 0.06647979f, 0.11012595f, -0.00145148f, 0.00806598f, 0.34584936f, 0.08021131f, 
    0.40494722f, 0.02450242f, -0.01812271f, 0.16294640f, -0.13679031f, 0.03206725f, -0.05501377f, -0.63170177f, 
    0.28872436f, -0.19435398f, -0.12728076f, -0.06858372f, -0.10129309f, -0.14480568f, 0.04385759f, -0.10957539f, 
    -0.16278139f, 0.02817697f, -0.16080406f, -0.02117536f, 0.16935037f, 0.01905355f, 0.25829181f, 0.16336930f, 
    -0.16363968f, -0.13359047f, -0.02351431f, -0.10239912f, 0.00344553f, 0.12454717f, 0.06177799f, 0.14184175f, 
    0.12065437f, 0.04381100f, -0.51574296f, -0.59832191f, -0.06603937f, -0.70220184f, 0.14925385f, 0.08564065f, 
    -0.26923299f, -0.24214770f, -0.00359501f, 0.31369469f, 0.39841187f, 0.44549131f, -0.11106864f, 0.02565936f, 
    0.11810233f, 0.00020796f, -0.00822052f, -0.13545981f, -0.39626032f, -0.10844830f, -0.06085858f, 0.12822273f, 
    -0.02032415f, -0.12316267f, 0.01857250f, 0.27944055f, 0.01525366f, -0.11244912f, -0.29653493f, -0.09109236f, 
    0.06203494f, 0.10921891f, -0.01680626f, -0.11166369f, -0.17477305f, 0.02573881f, -0.30775508f, -0.08695200f, 
    -0.17699145f, 0.06080541f, 0.00487807f, 0.22866416f, 0.02814643f, 0.14519550f, 0.00772281f, 0.25993204f, 
    0.06834205f, 0.32292783f, -0.10519578f, -0.18761644f, -0.02188230f, 0.15394305f, -0.12822056f, 0.02701510f, 
    0.01936591f, 0.18197247f, 0.06597091f, -0.18864411f, -0.13329236f, -0.10081436f, 0.14249139f, 0.04370319f, 
    -0.02970904f, -0.01748110f, 0.13098074f, 0.26722088f, -0.02713810f, -0.04874151f, 0.13103014f, 0.09463635f, 
    0.14195326f, -0.04497212f, -0.16950664f, 0.35373801f, 0.07268273f, -0.18853977f, 0.03834734f, 0.05654423f, 
    0.07058402f, 0.00329336f, -0.09488248f, 0.20679261f, 0.72991323f, 0.41502780f, 0.17746428f, -0.04056167f, 
    0.04308927f, 0.13282558f, -0.09708229f, -0.01588239f, 0.39182201f, 0.39598086f, -0.03557446f, -0.04256996f, 
    0.10658005f, 0.08028001f, 0.13545275f, -0.10190041f, -0.20214622f, -0.38008386f, -0.59600180f, 0.24179959f, 
    -0.03890413f, -0.18557441f, 0.24502791f, -0.11010256f, 0.02870531f, 0.12748080f, -0.05148151f, -0.02124755f, 
    0.07536054f, -0.12927499f, -0.35891256f, -0.08160188f, -0.06917181f, 0.06083895f, 0.03582072f, -0.08691597f, 
    0.17208895f, 0.19729966f, -0.01311935f, -0.31055966f, 0.13269967f, -0.10153495f, 0.01669751f, 0.22432843f, 
    0.01708107f, -0.02328432f, -0.00665999f, -0.05951370f, -0.03840230f, -0.03425499f, 0.00760545f, 0.01619355f, 
    -0.04497205f, -0.03550521f, -0.05430724f, 0.02487569f, 0.04900172f, 0.00041492f, -0.04779225f, -0.00651152f, 
    -0.03971063f, 0.05863204f, -0.05374642f, 0.05411615f, 0.02092220f, -0.00137260f, 0.00226578f, 0.03475135f, 
    -0.04760104f, -0.00507824f, -0.02091256f, -0.04343639f, -0.06189132f, -0.06230128f, 0.01243982f, 0.04484031f, 
    0.03888018f, 0.03106993f, 0.02308506f, -0.00536443f, 0.03341174f, -0.01685806f, -0.02099517f, 0.03686342f, 
    0.00086432f, -0.02373907f, -0.00378931f, 0.04220347f, 0.00181433f, -0.00830760f, 0.04185980f, -0.05385688f, 
    -0.02606299f, 0.00891611f, 0.04085848f, -0.03152910f, -0.05031433f, 0.03070195f, 0.03011652f, 0.02098163f, 
    0.04838826f, 0.05337392f, -0.05503067f, 0.02655188f, 0.01328746f, -0.03361570f, 0.03225743f, -0.02371117f, 
    0.03534643f, -0.02134346f, -0.00894834f, 0.00476528f, -0.06353445f, 0.02149452f, -0.04665386f, -0.00403738f, 
    -0.06713009f, 0.00390939f, 0.03353478f, -0.00566672f, -0.05675173f, -0.04352353f, -0.03195386f, 0.00373980f, 
    0.00574283f, -0.04455304f, -0.04535183f, 0.01553681f, 0.01671149f, 0.04961813f, -0.06066024f, -0.01914851f, 
    -0.03618541f, 0.04265755f, -0.05388007f, 0.04046952f, 0.01761958f, -0.01596341f, 0.04236449f, 0.02693829f, 
    -0.04073062f, -0.03037410f, -0.06136775f, -0.04643749f, 0.01307093f, 0.01950544f, 0.01480869f, 0.03409427f, 
    0.03894012f, 0.00514058f, 0.02598476f, -0.04622510f, 0.01427160f, -0.05478894f, -0.01719548f, 0.04463410f, 
    -0.03310648f, 0.05101531f, 0.02217990f, 0.01530558f, 0.02472596f, -0.02424807f, 0.00860139f, -0.00417815f, 
    0.00361881f, 0.02676414f, -0.03919946f, 0.00501923f, 0.00938735f, 0.01281838f, 0.03908770f, 0.05174201f, 
    0.00100654f, 0.01284610f, 0.01303374f, -0.01546440f, -0.05948089f, 0.04588187f, 0.03800601f, 0.02298368f, 
    0.01955255f, 0.02739486f, -0.01976312f, -0.06803037f, -0.06625078f, 0.02238544f, -0.00374038f, 0.00657485f, 
    0.04295829f, 0.02466994f, -0.03320595f, 0.02149613f, 0.01889673f, -0.06749457f, 0.03247209f, -0.03517698f, 
    -0.01394373f, 0.02585880f, -0.05569860f, 0.00355534f, 0.04929502f, 0.04272407f, -0.04016130f, -0.03004837f, 
    0.00417055f, -0.05704745f, 0.03674164f, 0.01668348f, 0.04985948f, -0.02203120f, 0.02226507f, 0.03835660f, 
    -0.01821440f, -0.04941463f, -0.03614880f, 0.05225939f, 0.03720541f, -0.01912911f, 0.00308152f, -0.02607347f, 
    -0.02966026f, 0.01645540f, 0.02051862f, -0.06539118f, 0.03068995f, 0.03352243f, 0.00341010f, -0.01829439f, 
    -0.00146584f, -0.03852513f, -0.02708847f, 0.01332003f, -0.01243887f, -0.05500413f, 0.02854864f, 0.04886818f, 
    0.00920734f, 0.05177967f, -0.05042076f, 0.00683498f, -0.01584201f, -0.00222079f, -0.06013788f, 0.00479592f, 
    -0.00779956f, -0.05162658f, -0.04715152f, 0.02391057f, -0.05653726f, 0.00881648f, -0.03789903f, 0.00189717f, 
    0.01889742f, -0.04036148f, 0.01212936f, -0.03400637f, -0.04949532f, -0.01839671f, -0.03469738f, 0.01281323f, 
    -0.00875378f, -0.04470542f, -0.05528686f, -0.06398483f, 0.02082915f, -0.01959110f, -0.05951640f, 0.00627803f, 
    -0.01367300f, 0.05251545f, 0.02359556f, 0.00680560f, -0.01713415f, 0.00645208f, 0.02380848f, -0.03350287f, 
    0.02933361f, -0.04641043f, -0.05266042f, -0.05740792f, -0.04278200f, -0.01716565f, -0.03815839f, 0.03399480f, 
    -0.04524841f, -0.06144176f, -0.03033767f, 0.01982648f, -0.03520777f, 0.03490829f, -0.03931427f, -0.03276229f, 
    0.04493692f, -0.03546109f, 0.02640913f, -0.06931543f, -0.05745165f, 0.01535515f, -0.01152756f, -0.02489453f, 
    -0.04302547f, -0.06839731f, 0.03005637f, -0.01934208f, 0.02782690f, 0.00679872f, -0.06248580f, 0.01046136f, 
    0.00652673f, -0.02503263f, -0.04326514f, 0.01437610f, -0.05096518f, -0.02713200f, 0.01201491f, -0.05734287f, 
    -0.05538343f, 0.00501562f, 0.00539771f, -0.02672124f, 0.03801800f, 0.02590200f, 0.00235012f, 0.00495374f, 
    0.03725365f, -0.00141780f, -0.03417412f, 0.01373453f, 0.02022947f, -0.06782343f, -0.04352467f, -0.04018823f, 
    0.07056154f, -0.17807145f, 0.14529729f, 0.09382074f, 0.05028834f, 0.02850978f, -0.00957996f, -0.39220861f, 
    -0.19541983f, 0.58578557f, 0.41849622f, 0.67468297f, -0.18610457f, -0.04405947f, -0.07279171f, -0.08436953f, 
    0.17232443f, 0.14087230f, -0.40196565f, 0.36454937f, -0.07838020f, -0.00664269f, -0.02325627f, -0.08349767f, 
    0.09845044f, 0.01185055f, 0.12269101f, -0.17225808f, 0.15559384f, 0.12694526f, 0.14073788f, 0.11498799f, 
    -0.11890140f, -0.27697659f, 0.22242348f, -0.03668271f, 0.14701584f, -0.08204653f, 0.05396428f, 0.10126676f, 
    0.07446874f, -0.09391804f, -0.15965092f, -0.05359010f, -0.01598219f, -0.02028346f, 0.08589341f, 0.04839833f, 
    -0.07863607f, -0.14467591f, 0.10489187f, -0.03264612f, 0.01079005f, -0.11213207f, 0.04708898f, -0.01129058f, 
    0.52779430f, -0.09390626f, 0.00337701f, 0.19493687f, 0.09764161f, -0.23032792f, -0.07343294f, 0.10915720f, 
    -0.04499617f, -0.20420809f, -0.05098209f, -0.02959311f, 0.23434480f, 0.16625145f, -0.15322384f, -0.21045016f, 
    -0.12661265f, 0.55990952f, -0.17253405f, -0.09084134f, 0.38441038f, -0.04595847f, -0.16654539f, 0.47780195f, 
    0.09274108f, 0.24881306f, -0.17085032f, 0.13403159f, -0.04541652f, -0.14924030f, -0.17351705f, 0.19112276f, 
    0.12859362f, 0.11020713f, 0.32692945f, -0.10474421f, -0.08534060f, 0.18186499f, 0.09941824f, 0.13401346f, 
    0.05007825f, -0.20114543f, 0.04783507f, -0.11351725f, -0.28505811f, 0.04056522f, -0.13124385f, -0.13815622f, 
    0.06963846f, -0.09784913f, 0.09183006f, 0.12353103f, -0.15599734f, -0.13258134f, 0.01086459f, 0.04913796f, 
    -0.00500866f, -0.19543643f, 0.07819788f, -0.01301326f, 0.10354058f, -0.29294163f, 0.12684885f, -0.11809582f, 
    0.01038819f, 0.02329501f, 0.08883326f, -0.12762690f, -0.09587451f, -0.07422500f, -0.20612843f, 0.00227174f, 
    0.22677408f, 0.05701116f, 0.08996043f, 0.08920260f, -0.08282890f, -0.03658495f, -0.10498444f, -0.40737525f, 
    0.11614804f, 0.33535028f, -0.22388937f, -0.17110668f, 0.30404198f, 0.18562987f, -0.08582049f, 0.15004626f, 
    -0.32781774f, 0.32145429f, 0.08043066f, -0.13500915f, 0.13374676f, -0.02625779f, 0.02959085f, -0.04189319f, 
    -0.19231141f, 0.30165657f, 0.31860250f, -0.03128637f, 0.02067230f, 0.05078675f, -0.04546075f, 0.08644585f, 
    -0.09326907f, -0.32524779f, 0.27219740f, 0.43631563f, -0.10954884f, -0.37126771f, 0.47963318f, 0.02184323f, 
    -0.06039565f, 0.22549807f, 0.25617379f, 0.08971788f, 0.22223522f, 0.03148449f, -0.09618953f, 0.07214236f, 
    0.00398323f, 0.01862968f, -0.18188119f, 0.06804857f, 0.00683151f, 0.09625986f, 0.29836497f, -0.05954797f, 
    0.03030814f, 0.02385774f, -0.32997525f, 0.02529961f, 0.00530515f, -0.20275708f, 0.18390474f, -0.03967689f, 
    0.19933380f, 0.04835789f, -0.00066651f, -0.31127745f, -0.02000156f, 0.14466760f, -0.03245189f, 0.02675648f, 
    0.50212991f, 0.11745089f, 0.13571945f, 0.12448421f, 0.27823731f, -0.37225339f, -0.12974694f, -0.00327341f, 
    0.13268039f, 0.25002167f, 0.12912942f, 0.10784870f, -0.01277927f, 0.09869865f, -0.18210831f, 0.19845054f, 
    -0.01050256f, -0.09191895f, 0.13260326f, -0.05813504f, -0.05531511f, -0.34845904f, -0.08205241f, -0.01252781f, 
    0.04532007f, 0.25555608f, -0.12508185f, 0.16943783f, 0.05303236f, -0.04944987f, -0.04497256f, 0.10771970f, 
    -0.32987013f, -0.16799529f, -0.28216130f, 0.35313606f, 0.05693301f, -0.03974205f, 0.02266551f, -0.09963369f, 
    -0.02869321f, 0.17008629f, -0.17207150f, 0.34562176f, 0.16634753f, 0.45088527f, -0.24449071f, 0.00427796f, 
    0.02849209f, 0.05588976f, -0.12074965f, 0.00204365f, 0.01137296f, 0.08580716f, -0.00841971f, -0.20370868f, 
    -0.05530882f, 0.07395323f, 0.01232167f, -0.19662878f, -0.11910511f, 0.18040724f, 0.07189863f, 0.16311002f, 
    -0.13838427f, -0.02898660f, 0.11473069f, -0.07015470f, 0.09497872f, 0.03176581f, -0.01059099f, -0.07708813f, 
    -0.04985588f, 0.13954739f, -0.15640108f, 0.07227209f, -0.21775673f, 0.15417510f, 0.01078397f, -0.04070443f, 
    0.02862667f, -0.08589631f, 0.24746639f, 0.03475533f, 0.14029999f, -0.18251792f, 0.19310001f, 0.09155556f, 
    -0.03202540f, -0.01379135f, 0.04787408f, 0.00485320f, -0.00846498f, -0.01585362f, 0.04537019f, -0.00161588f, 
    0.01418813f, -0.01538349f, 0.04352206f, -0.03001661f, 0.03773018f, 0.02522022f, -0.05733426f, 0.01109426f, 
    0.05577029f, -0.01764692f, 0.01993622f, 0.00127887f, -0.06224028f, 0.01529705f, -0.00811295f, -0.04892401f, 
    0.04235101f, 0.04124188f, 0.04518234f, 0.03399891f, 0.00017427f, -0.05891858f, -0.03123385f, -0.02589508f, 
    0.03402886f, 0.03625273f, 0.00124150f, 0.03463991f, -0.00067373f, -0.05138566f, -0.05425288f, 0.05240813f, 
    0.02303243f, -0.00998824f, 0.03847034f, -0.04858009f, -0.04098096f, -0.06416621f, 0.03494542f, -0.04376091f, 
    0.04233468f, -0.02449407f, -0.05171189f, 0.01636942f, -0.05285629f, -0.03335481f, 0.04493527f, -0.06006695f, 
    0.03504585f, -0.06768645f, 0.03996597f, -0.05942036f, 0.04645468f, -0.02954095f, 0.01348294f, -0.03354357f, 
    -0.02993229f, 0.00510250f, 0.04499629f, 0.03299607f, -0.06203245f, 0.01141162f, -0.04493582f, -0.04829508f, 
    0.00119132f, 0.01023728f, 0.04979368f, -0.05956456f, 0.03215907f, 0.02732221f, -0.04845979f, 0.04045664f, 
    -0.03252753f, -0.00295247f, 0.03375375f, -0.00011806f, -0.01244421f, 0.01120145f, -0.02353354f, -0.03725114f, 
    0.02962671f, -0.04783483f, 0.04619736f, -0.03667937f, -0.06005463f, -0.02788158f, 0.01877538f, -0.02599256f, 
    0.04098157f, 0.01414170f, -0.02614388f, -0.04793004f, -0.01029982f, 0.02200132f, -0.01363172f, -0.01705080f, 
    0.01326695f, 0.03728056f, 0.03171498f, -0.05218441f, 0.04136390f, -0.03726650f, 0.01670172f, -0.05709248f, 
    -0.01535612f, 0.03013135f, -0.00377608f, -0.01823925f, 0.00693810f, 0.04478665f, -0.02952352f, 0.02100458f, 
    0.02321336f, -0.05088793f, 0.02617760f, -0.03560061f, -0.04455256f, -0.00985930f, -0.00056252f, -0.03230006f, 
    0.01559414f, -0.04287448f, -0.04205856f, -0.06363407f, 0.04574398f, -0.01079887f, -0.02437042f, 0.00242463f, 
    0.02993571f, 0.00245449f, -0.04078465f, 0.05381060f, 0.00767379f, -0.04548807f, 0.04286091f, -0.01437559f, 
    0.00960352f, -0.02625610f, 0.01648271f, 0.01990973f, -0.05506664f, -0.01659546f, -0.00187277f, 0.04470068f, 
    0.04105205f, -0.04490687f, -0.02720245f, 0.04381040f, 0.03167930f, -0.04458183f, 0.02413887f, -0.02634920f, 
    0.00383242f, 0.03331001f, -0.02366110f, -0.02234177f, -0.02531662f, 0.03932357f, -0.02909613f, 0.04332091f, 
    0.00694013f, -0.00598848f, -0.01805077f, -0.00990309f, 0.02185413f, -0.02728953f, 0.00365256f, -0.05471684f, 
    -0.00068627f, -0.03193373f, -0.01273872f, -0.01094357f, -0.01018492f, 0.04534281f, 0.03946152f, -0.04843460f, 
    0.02713007f, -0.04701027f, 0.04881409f, 0.02120962f, -0.04309381f, 0.03880382f, -0.05315024f, -0.00100989f, 
    -0.02171800f, -0.00137260f, -0.02629094f, -0.04549949f, -0.03654554f, -0.04907106f, 0.01515712f, -0.02003024f, 
    0.02401415f, -0.04485007f, -0.03930374f, -0.00749794f, -0.00500621f, -0.06412112f, -0.03608670f, 0.03073452f, 
    -0.04683293f, 0.03494444f, 0.01442769f, -0.00177708f, 0.01096041f, -0.03543413f, -0.00036149f, -0.06016777f, 
    -0.00713430f, -0.03112183f, -0.03613413f, 0.01529648f, -0.03477220f, -0.05597717f, 0.02892954f, -0.05402783f, 
    -0.03479420f, -0.05793251f, 0.03990452f, 0.04574619f, 0.02031310f, 0.00141554f, 0.04017481f, 0.04323853f, 
    -0.03171642f, 0.05216530f, 0.01714124f, 0.02374940f, 0.03393717f, 0.03889595f, 0.03426524f, 0.03680852f, 
    -0.00556207f, -0.00375723f, -0.04328852f, -0.04515418f, -0.03398631f, 0.02659215f, 0.03306776f, -0.04438877f, 
    0.04560613f, -0.01745962f, -0.04608596f, -0.05990924f, 0.02884069f, 0.01693919f, 0.04595641f, -0.03331649f, 
    0.04623141f, 0.03646811f, -0.00092111f, 0.03084120f, -0.03294291f, -0.01354321f, -0.00530527f, -0.00357270f, 
    -0.00773304f, -0.05968418f, 0.01694832f, 0.01269588f, 0.01932343f, -0.01418804f, 0.00833287f, -0.02555472f, 
    0.01778328f, -0.03902999f, 0.04097775f, -0.05604816f, -0.06323133f, 0.04344569f, 0.00116057f, -0.01619552f, 
    0.01110940f, 0.00294720f, -0.06086865f, -0.04374834f, 0.00866148f, -0.01060169f, -0.03449822f, 0.01580068f, 
    -0.01460885f, -0.12011211f, 0.08204408f, 0.01017910f, 0.10615042f, 0.10242172f, 0.18839011f, -0.34698534f, 
    -0.15486577f, -1.19496310f, 0.26773596f, 0.32688457f, -0.08436827f, 0.06374005f, 0.29715759f, 0.00984249f, 
    -0.08207517f, -0.13860847f, -0.17280230f, -0.00730498f, -0.04158235f, -0.01293975f, 0.09137738f, 0.12896045f, 
    -0.19547698f, 0.38395673f, 0.10715214f, 0.12681931f, -0.01379349f, 0.15038961f, 0.02215912f, 0.22168924f, 
    -0.09479158f, -0.03203885f, -0.03335227f, 0.23750797f, 0.18053328f, 0.22363910f, 0.08584665f, -0.08837181f, 
    -0.11576712f, -0.12992509f, 0.05093729f, -0.05617104f, -0.03820138f, 0.03721942f, 0.13171734f, 0.07777627f, 
    -0.14025477f, -0.15078749f, 0.12072847f, 0.20862751f, -0.03956093f, -0.06870198f, -0.73511893f, -0.24950549f, 
    -0.23512150f, 0.01324948f, -0.00587016f, -0.06127004f, 0.03940766f, -0.04122951f, -0.08119185f, -0.11952034f, 
    0.00429415f, 0.05929134f, 0.08191349f, 0.07821088f, -0.24040017f, 0.17880765f, 0.05911316f, 0.18271428f, 
    -0.14506829f, 0.15611550f, -0.02907591f, -0.09174810f, 0.30543497f, 0.18772002f, 0.30268759f, 0.05950604f, 
    0.02696649f, 0.23326276f, -0.11290899f, -0.50371861f, -0.08857793f, -0.31645536f, 0.02237204f, -0.00141605f, 
    0.06776797f, 0.00450742f, 0.63862419f, -0.10221019f, 0.03530987f, -0.06126449f, -0.12964377f, -0.00274298f, 
    -0.01626575f, 0.07562631f, -0.03998427f, 0.29179046f, 0.13700895f, 0.23040409f, -0.21578228f, -0.42272279f, 
    -0.25698200f, 0.02327557f, -0.20716873f, 0.07443289f, 0.58180022f, -0.17015231f, -0.59435028f, -0.22512127f, 
    0.05902338f, -0.22275829f, 0.11329934f, -0.04040606f, 0.06452733f, -0.11865808f, 0.01783436f, 0.18305345f, 
    0.03564203f, 0.06259678f, 0.07513904f, 0.13743010f, 0.00149285f, 0.24076556f, -0.26868337f, -0.22748451f, 
    -0.26304454f, 0.02891016f, 0.06129363f, 0.12139734f, 0.02074713f, -0.11499773f, -0.19277708f, 0.15100315f, 
    -0.25369009f, -0.24084803f, 0.24373458f, 0.19974196f, 0.01228758f, -0.19259283f, 0.11892918f, -0.25894985f, 
    0.00345570f, -0.02824995f, 0.27201587f, 0.13657406f, 0.03538191f, 0.08015055f, 0.16768210f, 0.15566012f, 
    0.20421135f, 0.25728506f, -0.24163976f, 0.14532523f, -0.04584805f, -0.00456222f, -0.06828374f, 0.13004763f, 
    -0.01663693f, 0.06833391f, 0.93204510f, 0.47410798f, -0.15244253f, 0.02376544f, -0.11282978f, -0.13934734f, 
    0.15693647f, -0.13319212f, -0.01083282f, -0.75246620f, -0.61172032f, -0.15298690f, 0.06271475f, 0.04838722f, 
    0.12200906f, 0.00359426f, -0.22456256f, 0.10766448f, 0.04289769f, 0.19762667f, 0.14759819f, -0.04579790f, 
    -0.14002371f, 0.24924208f, 0.10333761f, 0.11909073f, 0.13521810f, 0.07159282f, 0.02530774f, 0.08281191f, 
    0.01094174f, 0.08287715f, 0.09331322f, 0.03125026f, -0.31823045f, -0.25611091f, -0.31031147f, -0.10373469f, 
    -0.42084077f, -0.01386178f, -0.16600782f, -0.07503700f, -0.19226538f, 0.41133893f, -0.23760621f, 0.83359718f, 
    -0.14360918f, -0.25039393f, -0.15070771f, 0.18645902f, 0.03820832f, 0.12748811f, -0.09759699f, -0.17341439f, 
    0.30263767f, 0.14632206f, -0.10446315f, -0.28674835f, -0.18237177f, -0.23747703f, 0.12433915f, -0.07350895f, 
    -0.10738993f, -0.07449756f, 0.04617791f, 0.35174751f, -0.15881042f, -0.01792186f, 0.06733638f, -0.00408934f, 
    -0.02453112f, 0.22347575f, 0.17771551f, 0.02363302f, -0.03431750f, -0.34220591f, -0.16936883f, -0.07850921f, 
    0.17778032f, -0.01645437f, -0.22844759f, -0.42537346f, 0.00810760f, 0.02445409f, 0.16259220f, 0.26068562f, 
    0.30699366f, -0.06998457f, -0.13418621f, 0.00542935f, -0.57839239f, 0.28349474f, 0.66163605f, 0.39254874f, 
    0.35838529f, 0.15295766f, 0.06317049f, -0.09213714f, -0.00939479f, 0.49214134f, -0.06519322f, -0.20703985f, 
    0.05420364f, -0.35662511f, 0.20613517f, 0.09457962f, -0.16661817f, 0.12110034f, 0.29970887f, 0.09364465f, 
    0.12634952f, -0.08737738f, -0.39539421f, 0.00088740f, 0.09000372f, -0.16542484f, 0.01455093f, 0.05104273f, 
    0.11169065f, -0.07420564f, -0.04254491f, -0.08363690f, -0.15683712f, -0.02883679f, -0.09245906f, 0.19499628f, 
    0.05418073f, 0.18047228f, 0.20277464f, 0.00020914f, 0.13309312f, -0.15116356f, -0.15959387f, -0.01909334f, 
    -0.15641697f, 0.26270074f, 0.34536746f, -0.21366936f, 0.00787988f, -0.14703357f, 0.04244138f, 0.17133905f, 
    0.06634312f, -0.03269972f, 0.25748801f, 0.15372080f, 0.16696189f, -0.21278879f, 0.05844251f, -0.13024512f, 
    0.07017774f, 0.13849707f, -0.00948001f, -0.17907244f, 0.41333273f, -0.11906499f, -0.14982870f, -0.00859872f, 
    0.06808161f, -0.01371201f, -0.03705531f, -0.30596408f, -0.15632504f, -0.14720288f, -0.06354507f, 0.08190338f, 
    -0.08893665f, -0.05379099f, -0.05275613f, 0.16525528f, -0.06475822f, -0.42110845f, -0.33682421f, -0.00609456f, 
    0.07451168f, -0.01369587f, -0.16154076f, -0.10122526f, -0.17178087f, -0.07154330f, -0.13166809f, 0.18618590f, 
    -0.00514800f, -0.28434500f, -0.17435656f, -0.25202048f, 0.03380825f, 0.04714663f, -0.05174587f, 0.19479428f, 
    -0.10583103f, 0.18611936f, -0.00860217f, 0.08981252f, 0.16249880f, -0.09171186f, 0.07430089f, -0.00647164f, 
    -0.30708835f, -0.05937292f, -0.13896298f, 0.07263837f, -0.24257512f, -0.09339238f, -0.02334666f, 0.08395412f, 
    0.14620885f, 0.28780937f, -0.12727560f, 0.02110470f, 0.04165481f, 0.07106025f, 0.13298948f, -0.10895724f, 
    0.10873494f, 0.12350541f, 0.40017948f, 0.30121985f, 0.10137580f, 0.10954952f, -0.02403985f, 0.01322261f, 
    -0.03411669f, 0.00226182f, 0.05192375f, 0.23924066f, -0.30896300f, -0.11896423f, -0.07317360f, 0.06332658f, 
    -0.08619254f, 0.03449818f, -0.15689538f, -0.14933312f, 0.24066055f, -0.33505005f, -0.20764801f, 0.17275544f, 
    0.18089122f, 0.02353403f, -0.22665758f, 0.12343813f, 0.05651381f, 0.20687404f, 0.34965423f, 0.04263315f, 
    -0.25687152f, -0.24064215f, -0.15466097f, -0.02454514f, 0.25405350f, 0.18395577f, -0.27657238f, 0.10346510f, 
    0.22857586f, -0.43545941f, -0.05636978f, -0.27070221f, -0.03519708f, -0.02455667f, 0.05149411f, -0.18098252f, 
    0.05588612f, 0.09776660f, 0.09939905f, 0.03805328f, -0.19917940f, 0.17727920f, 0.13544232f, 0.00056362f, 
    0.24771844f, 0.07602645f, -0.06913826f, -0.07605337f, 0.18763073f, -0.17667668f, -0.02930484f, 0.00140345f, 
    0.03586954f, 0.40725321f, 0.30994850f, -0.00712891f, -0.08160983f, 0.23825713f, 0.02864417f, -0.03699075f, 
    -0.07366066f, -0.11574278f, -0.56939381f, 0.06155160f, -0.21336654f, 0.50224173f, -0.00531362f, 0.16526136f, 
    -0.26013750f, -0.00433805f, -0.03077329f, 0.23006120f, 0.16713262f, -0.23448192f, -0.12666656f, -0.27006128f, 
    -0.13437442f, -0.15461038f, 0.01425874f, 0.10212018f, 0.13277291f, -0.06121334f, 0.34464371f, -0.02306908f, 
    -0.07218335f, 0.08362031f, 0.10085694f, -0.04143053f, -0.10764135f, -0.19704001f, 0.23838809f, 0.20072556f, 
    -0.14076588f, -0.07005499f, -0.05395212f, -0.01595459f, -0.08244748f, -0.05681541f, -0.04260217f, 0.35009655f, 
    0.11428876f, -0.08400698f, 0.02730625f, -0.21402715f, -0.10028405f, -0.21565631f, -0.11809040f, 0.00531975f, 
    0.09006808f, 0.16373320f, 0.07098588f, 0.10446703f, 0.01713402f, -0.11909626f, 0.04104606f, 0.12336147f, 
    -0.14389570f, -0.37134823f, -0.25519949f, 0.09192739f, -0.02659944f, -0.12779719f, 0.06353302f, -0.00705500f, 
    0.07121029f, 0.46107036f, 0.27400795f, 0.01003896f, 0.07572503f, 0.25729057f, 0.11084201f, 0.00588889f, 
    0.08583541f, 0.02486181f, -0.15982912f, -0.22018974f, 0.05235039f, 0.10293199f, 0.07485819f, -0.01689471f, 
    0.17523910f, -0.13932408f, -0.27161860f, 0.04626173f, 0.22195372f, -0.04644888f, 0.06570311f, 0.03229474f, 
    0.23801357f, 0.11353648f, 0.30185711f, 0.13572575f, -0.10114405f, 0.21449926f, -0.14216237f, -0.17427318f, 
    0.19549753f, -0.02370596f, -0.09031720f, 0.13547999f, 0.06528432f, 0.55531335f, 0.20463446f, -0.11378372f, 
    -0.13495982f, 0.00440459f, 0.04575711f, -0.02429893f, 0.24491456f, -0.12815993f, 0.42263412f, -0.33875141f, 
    -0.10870652f, 0.00657702f, 0.06585165f, -0.17892644f, -0.01921636f, -0.13496025f, -0.12591754f, -0.06953663f, 
    -0.14348213f, -0.40363082f, 0.04901452f, 0.16556266f, 0.17288707f, -0.08203283f, 0.13896857f, -0.03205197f, 
    0.03127797f, 0.04701305f, -0.04317683f, 0.02324047f, 0.03399248f, -0.04368725f, 0.00107641f, 0.00409476f, 
    0.02709186f, 0.03768970f, 0.00282156f, 0.04133451f, -0.06297988f, -0.03999567f, 0.00227539f, 0.02976787f, 
    -0.04509711f, 0.05155424f, -0.04816688f, 0.03592179f, 0.01951880f, -0.06735147f, 0.00826016f, -0.03687294f, 
    0.01507473f, -0.01281099f, -0.01953657f, -0.01551018f, 0.04749249f, -0.05915054f, 0.03303414f, -0.02780166f, 
    -0.05293948f, 0.04268857f, 0.04128441f, 0.02418994f, -0.06322335f, -0.04694958f, -0.05212856f, 0.01310564f, 
    -0.05070714f, 0.00012290f, 0.00442504f, 0.03453360f, -0.05475759f, 0.00204013f, -0.03447757f, 0.00817426f, 
    0.01403430f, 0.02772436f, 0.01937120f, -0.00979113f, -0.03347425f, 0.01942750f, -0.02474864f, -0.02811990f, 
    -0.02171584f, -0.00491993f, 0.04362360f, 0.02284444f, -0.06995507f, -0.05776419f, -0.00339528f, 0.00903812f, 
    0.04308148f, -0.06498573f, -0.05285093f, 0.04233722f, -0.00428312f, 0.01250180f, -0.00530390f, -0.06033046f, 
    -0.04551890f, -0.05219878f, 0.05453438f, 0.03815647f, 0.01678519f, 0.01714240f, 0.01775710f, -0.04180026f, 
    -0.01663418f, -0.03198072f, -0.02170591f, 0.03874371f, 0.01687956f, -0.04184969f, -0.03129099f, -0.04629934f, 
    0.02270585f, -0.00146700f, 0.01484305f, -0.05093671f, -0.05639169f, -0.03035071f, -0.04306390f, 0.02129131f, 
    0.03379887f, 0.01642091f, -0.03653544f, -0.02914645f, 0.02324988f, -0.01548056f, -0.03880948f, -0.05558550f, 
    -0.03213524f, -0.04674991f, 0.01097391f, 0.03204860f, -0.00767636f, -0.00823802f, 0.00108082f, 0.02810134f, 
    0.01719507f, 0.01295944f, -0.03442462f, 0.03912002f, -0.04472349f, -0.00091144f, -0.00415483f, -0.06335113f, 
    -0.01203575f, -0.02036686f, -0.02619498f, -0.05838829f, -0.03303565f, -0.03961483f, -0.04917935f, 0.05982748f, 
    0.00332856f, -0.03589607f, 0.03834879f, -0.05591158f, 0.03649148f, 0.03195296f, 0.05283761f, -0.03122718f, 
    0.05768586f, -0.02411216f, 0.01737314f, 0.05199576f, 0.04302581f, -0.02552109f, 0.04287883f, -0.02482393f, 
    -0.06896129f, -0.06562676f, -0.00065449f, 0.01105354f, -0.05523545f, -0.03861768f, 0.02053954f, 0.03562002f, 
    -0.02674749f, 0.04727162f, -0.01404919f, -0.03791390f, 0.01860486f, -0.03637832f, 0.03079699f, -0.02224896f, 
    -0.04154261f, -0.03556060f, 0.03257386f, 0.02761893f, 0.01342446f, 0.03989100f, -0.03991656f, -0.01583364f, 
    -0.06057643f, 0.04813825f, 0.02905543f, 0.00613405f, 0.04795593f, 0.00665758f, 0.01259213f, 0.00575331f, 
    0.01766783f, 0.03498235f, 0.04850544f, -0.02889017f, -0.01653366f, 0.01338815f, 0.00371255f, -0.00367255f, 
    -0.05078766f, 0.03056036f, -0.02541973f, 0.00846115f, -0.01100158f, -0.05294087f, -0.05031195f, -0.03413792f, 
    -0.00144311f, -0.00959754f, 0.03216740f, 0.02387060f, 0.04891964f, -0.05052370f, 0.04564323f, 0.02302570f, 
    0.02223577f, -0.05927369f, -0.02380412f, 0.00897520f, 0.02545481f, -0.01837101f, 0.04955476f, 0.02261923f, 
    -0.00933846f, -0.04641770f, -0.02111742f, 0.02353039f, 0.04624479f, -0.06259765f, -0.01920480f, -0.01975141f, 
    0.03114278f, 0.03694402f, 0.03142907f, -0.02841435f, -0.02928530f, 0.02778718f, -0.03609830f, -0.04269587f, 
    -0.05915214f, -0.04312768f, 0.01047316f, -0.01386027f, 0.01805550f, -0.02818537f, 0.01095544f, -0.00078148f, 
    -0.03374949f, -0.02396794f, 0.00174758f, -0.02803261f, -0.05033015f, -0.03647408f, -0.06065195f, -0.04835050f, 
    -0.02700633f, 0.00511334f, -0.00185315f, -0.03713302f, -0.03924888f, 0.00298184f, -0.02449200f, -0.02028615f, 
    0.02717671f, 0.03606841f, -0.01870384f, -0.01455947f, -0.05346042f, 0.05011571f, -0.01040606f, 0.00966867f, 
    0.03050208f, -0.01241644f, -0.02663617f, 0.01566651f, -0.01374958f, -0.06265681f, -0.03956817f, 0.02019324f, 
    0.01831061f, 0.00986660f, -0.02728289f, -0.03837463f, -0.02148951f, -0.05158832f, -0.00835513f, 0.04112254f, 
    0.01427789f, 0.01084112f, -0.00142120f, 0.01346410f, -0.01179262f, -0.04583598f, 0.00165137f, 0.04573714f, 
    -0.03877153f, -0.01859483f, -0.02272513f, 0.02679045f, -0.06727245f, -0.06824805f, -0.00902483f, -0.03787272f, 
    -0.02228470f, 0.00611613f, -0.01110016f, -0.02996377f, 0.05563941f, -0.03199746f, -0.01536854f, 0.02765468f, 
    0.05194218f, 0.03083739f, -0.01859310f, -0.05844700f, 0.02057293f, 0.02953785f, -0.06372300f, -0.03019438f, 
    -0.02454155f, -0.05158010f, -0.05441976f, -0.00291722f, 0.02592860f, -0.00449354f, 0.02898586f, -0.00214940f, 
    -0.05997686f, 0.00814904f, 0.02816912f, -0.05072974f, -0.00783438f, -0.02771179f, -0.05551137f, 0.00147801f, 
    -0.04181685f, 0.03666597f, -0.04548569f, 0.04516513f, -0.00531947f, -0.05717213f, -0.01436221f, 0.03493626f, 
    -0.03130160f, -0.00253449f, 0.01842584f, 0.01638760f, 0.04097991f, -0.06292990f, -0.01692033f, -0.01246016f, 
    0.01777504f, -0.05817707f, 0.03890879f, -0.04872960f, -0.02382399f, -0.04325700f, 0.04035565f, -0.03236651f, 
    -0.03375665f, -0.02214382f, 0.01227349f, -0.01360065f, 0.04647543f, -0.05677482f, -0.03085423f, -0.00400528f, 
    -0.00553304f, 0.04147360f, -0.05084976f, 0.04663890f, 0.01168410f, 0.02213265f, -0.02423945f, -0.04822169f, 
    -0.05143520f, 0.00832530f, 0.03134438f, -0.02082033f, -0.00459964f, -0.04290657f, -0.01508887f, 0.04771041f, 
    0.01357817f, 0.05289476f, 0.02567960f, -0.04422265f, 0.03906733f, -0.05110523f, -0.01746381f, 0.04226256f, 
    0.04380081f, 0.00663476f, -0.02115459f, -0.06240200f, -0.02626146f, 0.02173769f, 0.04114909f, -0.05370549f, 
    0.00326709f, 0.01108426f, -0.05985820f, 0.00835733f, 0.04432086f, -0.05475404f, 0.02565734f, 0.03027169f, 
    0.04375520f, -0.03619400f, -0.03255315f, 0.05166162f, 0.00947730f, -0.01536513f, 0.04766481f, -0.02121170f, 
    0.03327551f, -0.00698322f, -0.04035603f, 0.00334763f, -0.05084782f, 0.00951776f, -0.04199992f, 0.05086838f, 
    0.03692717f, -0.06415880f, 0.01411310f, 0.01152131f, -0.02023547f, -0.04625917f, 0.01848806f, 0.01342213f, 
    -0.04493091f, -0.00776090f, 0.05734934f, -0.03026026f, -0.02772333f, -0.02736347f, 0.00595908f, 0.01869916f, 
    0.03121154f, 0.00798687f, -0.02433857f, -0.05017362f, -0.00267371f, -0.00093187f, 0.04596787f, -0.02646820f, 
    0.00120396f, -0.05939543f, -0.01177662f, -0.04341033f, -0.02614308f, 0.01291606f, -0.00036869f, -0.05799826f, 
    0.00983813f, -0.00504275f, 0.03110080f, -0.00795105f, -0.05452823f, 0.00400383f, -0.04720170f, 0.00872066f, 
    -0.03030350f, -0.03655336f, -0.06043696f, 0.00374772f, 0.02466575f, 0.02841396f, 0.03286649f, -0.02891180f, 
    0.05132421f, -0.03236661f, -0.05747903f, -0.00006922f, -0.04305719f, 0.01563836f, -0.03408108f, 0.04393371f, 
    -0.02674740f, 0.02212672f, 0.02085779f, 0.03272170f, 0.04902888f, 0.03214714f, 0.02027921f, -0.01694439f, 
    0.01707404f, -0.06325913f, 0.00054461f, -0.04453923f, -0.00025857f, -0.00354085f, -0.03877000f, 0.03574556f, 
    0.04802126f, -0.06163308f, -0.02235952f, 0.05174654f, -0.00549732f, -0.00846923f, 0.00373215f, -0.02004337f, 
    0.03256094f, 0.01092536f, -0.01940349f, -0.06310749f, 0.00816197f, 0.00969059f, -0.02793605f, -0.05360885f, 
    -0.05284089f, -0.03578568f, -0.04624641f, 0.05090450f, 0.02561851f, -0.05211816f, 0.03984229f, 0.05177044f, 
    0.01858483f, -0.00498997f, -0.03342595f, -0.01834236f, -0.05191595f, -0.04243824f, -0.03001774f, 0.03726111f, 
    -0.05436924f, 0.03591867f, -0.00225176f, -0.00576278f, -0.00248874f, -0.00193963f, 0.01807857f, -0.00258352f, 
    -0.00552240f, 0.03514600f, 0.02799849f, -0.05435193f, 0.03463065f, 0.03027078f, -0.00779836f, 0.01965982f, 
    0.04216358f, 0.04918562f, -0.05654761f, 0.05042795f, -0.00534143f, -0.00995763f, 0.03971638f, 0.00643048f, 
    -0.04417637f, 0.00931148f, 0.01128353f, -0.02590408f, 0.02284630f, -0.03079951f, 0.00657273f, -0.03099560f, 
    -0.01735455f, 0.02052525f, -0.02522011f, 0.00762052f, 0.01358979f, -0.01193565f, 0.00424725f, 0.04460456f, 
    -0.01840756f, 0.04180674f, -0.05997934f, -0.00582948f, -0.03658259f, -0.04926231f, -0.04614050f, 0.03154362f, 
    -0.01685463f, -0.03609663f, -0.01876027f, -0.01677463f, -0.05982623f, 0.03207753f, 0.00631107f, -0.03281498f, 
    -0.05761851f, -0.03859047f, 0.04774866f, -0.03347653f, -0.02668789f, -0.04328456f, 0.03128165f, 0.00403016f, 
    -0.06125199f, 0.01304028f, -0.00040473f, 0.00209206f, -0.04786799f, -0.01757999f, -0.03101712f, 0.03158464f, 
    -0.05417999f, 0.02633463f, -0.00804115f, 0.03338184f, 0.00396083f, -0.00627243f, -0.03044008f, 0.04314328f, 
    0.03277121f, -0.04348870f, -0.05410845f, -0.00849969f, 0.01556108f, 0.01694741f, -0.02107883f, 0.04124841f, 
    -0.04306351f, 0.03020389f, 0.01455353f, -0.04211646f, -0.00103618f, -0.03641983f, -0.04112499f, -0.05425616f, 
    -0.01086679f, 0.03512890f, -0.00694826f, 0.03531152f, 0.01292059f, -0.05837516f, 0.03521425f, -0.06508104f, 
    -0.01968447f, -0.01795624f, -0.00750222f, -0.06706128f, -0.02465787f, -0.00429735f, 0.04406862f, -0.01760873f, 
    -0.01242476f, 0.00899968f, 0.04572944f, 0.02014073f, 0.04126545f, -0.04605734f, 0.00185861f, 0.03932678f, 
    0.03340475f, 0.04379449f, 0.03654588f, -0.02281368f, 0.00333492f, -0.00731442f, -0.01956839f, -0.04071460f, 
    -0.06057243f, -0.04728775f, 0.03165760f, 0.02395606f, -0.01577282f, 0.04508254f, 0.01458394f, 0.02180306f, 
    -0.05525802f, -0.00504061f, 0.02225525f, -0.00961569f, 0.01512086f, -0.01008532f, -0.00912396f, -0.00183915f, 
    0.05225817f, -0.00988410f, -0.02954911f, -0.00696988f, 0.05069088f, 0.00892836f, 0.03276992f, -0.03775546f, 
    -0.02164349f, 0.04536584f, 0.04546630f, -0.01087448f, -0.03463825f, 0.01161781f, 0.05898880f, 0.02576944f, 
    -0.01402118f, 0.01675197f, -0.05941758f, -0.02899162f, 0.04384600f, 0.01914658f, 0.02995686f, 0.01370948f, 
    -0.04562471f, -0.04194728f, 0.02374565f, 0.03888821f, 0.03834168f, -0.05669935f, -0.03675434f, -0.04230950f, 
    0.00996112f, -0.01965615f, 0.00928371f, -0.02019898f, -0.04144930f, -0.05554215f, -0.05984910f, -0.01394446f, 
    -0.01941268f, 0.01633705f, -0.05090927f, -0.00422637f, 0.03504224f, -0.00135630f, 0.03138318f, -0.01573202f, 
    0.02094625f, 0.03269725f, -0.04484708f, -0.02654064f, 0.04375305f, -0.00909621f, 0.03090652f, -0.03347800f, 
    0.01497920f, 0.01256534f, -0.04188208f, 0.02941103f, 0.03583508f, -0.07204501f, -0.01993730f, -0.03737788f, 
    -0.04624388f, -0.01933726f, -0.01642619f, -0.01147155f, 0.00743086f, 0.00153847f, -0.05287735f, 0.01103942f, 
    -0.01775563f, -0.02930267f, -0.02335973f, -0.01725724f, -0.02450627f, 0.01052424f, 0.04903042f, 0.04034455f, 
    -0.04467243f, -0.04554900f, -0.00205164f, -0.05042972f, -0.04041736f, 0.03192523f, -0.03272805f, 0.03021238f, 
    -0.05151368f, -0.03889683f, 0.02760996f, 0.02014213f, -0.01793547f, -0.01278844f, -0.04928993f, 0.02533585f, 
    0.05119521f, 0.04036159f, -0.05862789f, -0.00879227f, 0.00110029f, 0.01428589f, 0.01995914f, -0.06722444f, 
    0.02384364f, 0.04282680f, 0.04382557f, 0.01040150f, 0.03697313f, 0.01720162f, -0.02473379f, -0.04651239f, 
    -0.01181206f, -0.03906011f, -0.05252592f, 0.02082060f, -0.05559559f, -0.04166621f, 0.04615910f, -0.05351311f, 
    0.01848125f, -0.06382891f, 0.03587595f, 0.02641506f, 0.04544387f, 0.03584367f, 0.02846031f, 0.04489088f, 
    -0.06343215f, -0.05368643f, -0.01483136f, 0.00455261f, 0.04362330f, -0.05071295f, -0.01552428f, 0.05117185f, 
    -0.02734757f, -0.03530564f, -0.01579894f, -0.03684497f, 0.03324603f, -0.05935857f, -0.03359509f, -0.00524204f, 
    0.00368217f, 0.03358833f, -0.03136188f, -0.05915510f, 0.02251223f, -0.03589051f, 0.02198734f, -0.03415182f, 
    -0.03954520f, -0.02477783f, -0.03857859f, -0.04697898f, 0.02746353f, -0.04846290f, 0.03920007f, -0.05413786f, 
    -0.00811805f, 0.02658194f, 0.01653899f, -0.03526295f, 0.03271205f, -0.02688691f, -0.01653862f, -0.03101414f, 
    -0.03123933f, -0.01920737f, 0.02073723f, -0.00874748f, -0.01448167f, -0.01926381f, -0.02197951f, -0.03006149f, 
    -0.04156160f, -0.02706566f, 0.00468249f, -0.03750294f, -0.05523909f, -0.06625804f, -0.00782506f, -0.00375826f, 
    -0.02951415f, -0.00646649f, -0.04193797f, -0.02866581f, -0.05008605f, 0.01399164f, -0.02572511f, 0.00438247f, 
    -0.02794961f, 0.03280402f, -0.03977480f, 0.02851687f, -0.05861318f, -0.06408542f, -0.04164080f, -0.01757259f, 
    0.02245896f, 0.01887854f, 0.02726977f, 0.03937162f, 0.02836057f, 0.02758247f, -0.00918602f, -0.04547542f, 
    -0.29595119f, -0.38119343f, 0.01413642f, 0.17212202f, -0.10377965f, -0.07298547f, 0.09319285f, -0.04097066f, 
    0.16950084f, -0.10617106f, -0.66067713f, -0.04792448f, -0.15165760f, 0.43029717f, 0.14284582f, 0.10526896f, 
    0.02978934f, 0.03583249f, 0.29223269f, 0.04464706f, -0.07731725f, 0.09748507f, 0.19914435f, 0.01709008f, 
    -0.01987287f, 0.15282466f, 0.01616230f, 0.13016309f, 0.07038177f, 0.09220707f, 0.09228390f, 0.06416405f, 
    0.04998552f, 0.08249294f, 0.17592508f, 0.18762854f, -0.14556248f, 0.00875390f, 0.12561919f, 0.02233609f, 
    0.05934957f, -0.12955214f, -0.04689166f, -0.20546062f, -0.02784931f, 0.05497207f, 0.00799026f, 0.31414017f, 
    0.20013914f, 0.12841497f, 0.04164374f, 0.16276975f, 0.02752350f, 0.09532298f, -0.16693094f, -0.27313185f, 
    -0.76118177f, 0.19566317f, 0.11156989f, 0.04802455f, 0.24502042f, 0.00849686f, -0.02474131f, -0.16732787f, 
    -0.01200381f, -0.24402504f, -0.08149598f, 0.12356479f, -0.06450449f, 0.15689246f, 0.18489100f, 0.32427892f, 
    0.08111051f, -0.67723680f, 0.40963039f, -0.14535420f, -0.02549577f, 0.20140304f, 0.25869030f, 0.05199846f, 
    -0.08590925f, -0.20639408f, 0.27918068f, 0.29930377f, -0.02405605f, 0.15535456f, -0.18392269f, 0.09398029f, 
    -0.04914852f, 0.04230879f, -0.47500789f, -0.12824106f, -0.22265273f, -0.08599006f, 0.02711715f, 0.23498283f, 
    -0.05884140f, 0.11538326f, 0.15252826f, 0.07068626f, 0.00304593f, 0.01042687f, 0.08008917f, -0.07776074f, 
    -0.00806052f, -0.08149337f, 0.26854792f, -0.08175853f, -0.87534183f, 0.14876910f, 0.38882682f, 0.22462262f, 
    0.11469886f, 0.06261367f, -0.06981514f, 0.13423559f, -0.06049746f, 0.50867409f, -0.25354877f, -0.09929900f, 
    -0.09581289f, 0.09960634f, 0.18673673f, -0.11448732f, -0.07867479f, -0.13415828f, -0.05187694f, -0.53742367f, 
    -0.75002074f, -0.17562570f, -0.01087805f, 0.09082069f, 0.06419419f, 0.00947100f, 0.00432534f, 0.36629611f, 
    0.29434466f, 0.01924876f, -0.43843174f, 0.07634904f, 0.02378420f, 0.14013898f, -0.05826139f, -0.17022027f, 
    0.28297684f, 0.02616666f, 0.06150514f, 0.01255728f, 0.04702972f, -0.09917542f, -0.07822298f, -0.01635375f, 
    0.02009487f, 0.00998124f, -0.28292453f, -0.29629689f, 0.17751098f, -0.00217041f, 0.01928275f, 0.00145196f, 
    0.07333519f, 0.04089007f, -0.37473470f, -0.30290130f, 0.45681790f, 0.07457602f, -0.13439806f, 0.14912128f, 
    0.21053502f, 0.09769169f, 0.01021799f, -0.20187409f, -0.52182162f, -0.56303442f, 0.05208325f, 0.03216008f, 
    0.25322863f, 0.02585965f, 0.02897332f, -0.02787618f, 0.40923655f, 0.03221054f, 0.13919945f, 0.22643858f, 
    0.00052100f, 0.07420278f, -0.03512511f, 0.10926349f, -0.02921153f, 0.10085596f, 0.02179909f, -0.14397736f, 
    -0.08298370f, 0.06820877f, 0.00040799f, -0.01113023f, 0.12511966f, 0.09182207f, 0.27102345f, 0.13817605f, 
    -0.39885604f, -0.19414175f, 0.23776054f, 0.20698060f, -0.04706428f, 0.00104772f, 0.02936956f, -0.55237067f, 
    0.54652816f, 0.28941923f, -0.14839450f, 0.13949622f, -0.03934915f, -0.01683814f, -0.08968659f, -0.11376047f, 
    -0.18232284f, 0.15157086f, 0.18263495f, 0.02826332f, 0.00331652f, 0.03785166f, -0.04153503f, -0.00743072f, 
    -0.14092979f, -0.17732699f, -0.18463358f, -0.40460524f, 0.07123709f, -0.16971917f, -0.40338826f, 0.12975653f, 
    0.10664264f, 0.08224606f, -0.05163105f, -0.09484790f, 0.07204738f, -0.08471972f, 0.04096571f, 0.05376793f, 
    0.13422768f, -0.08993434f, 0.13285099f, 0.26562628f, -0.01623963f, -0.56192559f, -0.10301298f, 0.13825139f, 
    0.07933498f, -0.14048325f, -0.35394907f, -0.27556092f, 0.02996732f, 0.13975918f, -0.39850822f, -0.06635918f, 
    -0.24124523f, -0.04808481f, -0.17797336f, -0.30545172f, -0.05660763f, 0.26936212f, 0.43917495f, -0.05507755f, 
    0.21808121f, -0.05245277f, 0.01392967f, 0.35036793f, 0.18831329f, -0.15766686f, 0.15696736f, -0.06555098f, 
    0.19350110f, 0.16686796f, -0.00942142f, -0.00625321f, -0.15062129f, 0.20041646f, 0.07142366f, -0.28466278f, 
    -0.06930205f, -0.01679508f, -0.18951596f, -0.07594451f, -0.06919106f, 0.03986439f, 0.19981410f, 0.25118053f, 
    0.03034142f, -0.09678544f, -0.09344514f, 0.05532973f, 0.25561535f, 0.19111028f, 0.18913956f, -0.09727428f, 
    0.12292814f, -0.18962368f, 0.38747150f, 0.28736588f, 0.07801049f, 0.04465659f, -0.13600647f, -0.42781657f, 
    -0.12329447f, 0.16350703f, -0.38551721f, 0.06332065f, -0.48433831f, -0.09709469f, -0.27874458f, -0.32734674f, 
    -0.33698761f, 0.07975823f, 0.13109063f, -0.04086508f, -0.35836560f, -0.15744685f, -0.01969608f, 0.18195318f, 
    -0.28159323f, 0.11169420f, 0.06244934f, 0.13133083f, -0.10101488f, 0.11830949f, -0.15008228f, 0.02753738f, 
    -0.14083727f, -0.06466576f, -0.05027064f, -0.04622592f, -0.12874141f, -0.25735939f, -0.00698517f, -0.17984007f, 
    -0.10184803f, 0.07328761f, -0.26426306f, -0.11274637f, -0.00688181f, -0.09715965f, 0.06609562f, 0.00506365f, 
    0.04977601f, 0.07404385f, 0.06433353f, 0.02004658f, -0.02850762f, -0.30547801f, -0.08926123f, 0.05304138f, 
    0.15741444f, -0.36152548f, 0.12566978f, 0.20673332f, 0.19635004f, 0.00710938f, 0.09549804f, 0.24173924f, 
    -0.07875407f, 0.43934080f, -0.15869121f, -0.39058712f, 0.33566457f, 0.02320361f, 0.25185725f, 0.32854885f, 
    -0.12417005f, -0.16884834f, 0.39771214f, 0.00936425f, 0.02134517f, -0.02258350f, -0.06197716f, 0.11816487f, 
    0.09997426f, 0.14673020f, 0.18572241f, -0.12305086f, 0.03850703f, -0.03346526f, -0.21858481f, -0.08837693f, 
    0.07704836f, -0.03225655f, 0.12522049f, 0.15360168f, 0.10585939f, -0.04313393f, -0.01858399f, 0.00550332f, 
    0.20043963f, 0.22813331f, 0.11782323f, -0.03214711f, -0.25299850f, 0.21365568f, 0.55258799f, 0.01303473f, 
    0.04388063f, 0.12066056f, 0.00773136f, 0.09309261f, 0.17609130f, -0.44994184f, -0.34356338f, 0.14041550f, 
    0.09975930f, 0.14304492f, -0.26818568f, 0.08525655f, -0.18040192f, -0.17311171f, 0.19748999f, 0.38343835f, 
    0.51846212f, 0.06344682f, -0.03432935f, -0.01909343f, 0.04133950f, -0.02602703f, -0.02132238f, -0.36884889f, 
    0.66795689f, -0.26576144f, 0.04734184f, -0.04375843f, 0.07730783f, 0.03304416f, 0.13883252f, -0.13863336f, 
    -0.61320734f, -0.00477115f, -0.30613708f, -0.19239089f, -0.12156381f, -0.50019073f, 0.12300268f, -0.07765544f, 
    0.09652764f, -0.11864685f, 0.03147007f, 0.10176462f, 0.04274851f, -0.09705373f, -0.05119491f, 0.00584444f, 
    0.08092658f, 0.02879449f, 0.10122935f, 0.30668414f, -0.06196479f, -0.46584252f, 0.28897759f, -0.03753090f, 
    -0.08171690f, 0.06094344f, 0.02087093f, 0.18831666f, 0.12650374f, 0.23821683f, 0.04520928f, 0.14677100f, 
    0.02110473f, -0.06175412f, -0.14463602f, -0.11111622f, -0.67740095f, -0.07524305f, -0.08916435f, -0.11766583f, 
    0.25688320f, -0.32630181f, -0.05334492f, -0.01393189f, -0.18103252f, 0.04829199f, -0.18564843f, 0.04035834f, 
    -0.02476701f, -0.17529212f, 0.02084238f, 0.11193559f, -0.01761456f, 0.03008635f, -0.25941795f, 0.16636842f, 
    -0.12667502f, 0.13916032f, 0.10237075f, 0.32142153f, 0.04119711f, 0.03952628f, -0.07530881f, 0.26137370f, 
    0.06851127f, 0.21508080f, 0.16455401f, -0.12192538f, 0.13752034f, 0.27634424f, -0.01189623f, 0.07410224f, 
    -0.33974475f, 0.18073100f, 0.21999562f, -0.16128014f, -0.03500598f, 0.06717475f, 0.01424413f, -0.05569751f, 
    -0.06235044f, 0.14694323f, 0.11776785f, 0.13224618f, 0.04468987f, -0.17684284f, -0.25792155f, 0.06129704f, 
    0.10922253f, 0.05000739f, 0.03945037f, 0.19212449f, -0.10804640f, -0.04899573f, -0.00451041f, -0.20555021f, 
    -0.00904199f, 0.02190676f, 0.23792472f, -0.05445195f, 0.11202276f, -0.06842758f, 0.13432725f, 0.29088646f, 
    -0.06570265f, -0.21122944f, -0.24224943f, -0.53295434f, 0.27622077f, 0.04427515f, -0.27995062f, 0.22280651f, 
    0.04248125f, -0.02891847f, 0.04916522f, -0.28874990f, 0.00564414f, -0.27851674f, 0.44639724f, -0.13175216f, 
    0.05610392f, 0.08549188f, 0.05724278f, 0.00232356f, 0.09171747f, 0.08786460f, -0.27186692f, -0.01637206f, 
    -0.35209957f, -0.03209830f, 0.00129476f, 0.02229325f, -0.01230237f, 0.07966335f, 0.10919200f, -0.18241946f, 
    0.28135625f, 0.18551040f, 0.23276135f, 0.20201316f, 0.33521685f, 0.13026933f, 0.30084598f, 0.13920626f, 
    -0.09668870f, 0.12269498f, 0.14379755f, -0.09583490f, -0.11192205f, -0.28484699f, -0.07423183f, 0.20023942f, 
    0.15871385f, 0.00776523f, 0.06694571f, -0.59067851f, 0.26583445f, 0.19425640f, -0.16211255f, 0.00408602f, 
    -0.20907521f, -0.40120316f, 0.28073800f, 0.08872084f, -0.21556279f, 0.14663444f, 0.00171768f, -0.00266637f, 
    0.11767513f, 0.06499179f, -0.05433481f, 0.01627485f, 0.25795031f, -0.05311486f, -0.00003347f, -0.07693085f, 
    0.06010164f, 0.29312804f, 0.32382596f, 0.04891503f, 0.06395894f, -0.03087922f, 0.00392863f, 0.07161289f, 
    -0.02965308f, 0.01225052f, 0.14793827f, -0.06725805f, -0.03690831f, -0.00247131f, 0.11662903f, -0.13776876f, 
    -0.14099494f, 0.11281230f, -0.12749016f, 0.12974603f, 0.06535596f, -0.26699498f, -0.22491919f, -0.03060445f, 
    -0.23928660f, 0.02764309f, 0.08292287f, -0.03746447f, -0.12417153f, 0.13860252f, -0.12160388f, -0.01337927f, 
    0.03657180f, 0.02241761f, -0.03485085f, -0.10981209f, -0.07580522f, 0.20648018f, -0.02052318f, 0.36186305f, 
    0.04727828f, 0.09403014f, -0.04890698f, 0.00908900f, -0.16723551f, 0.08803648f, 0.01700570f, 0.07028838f, 
    -0.05806160f, 0.15775159f, -0.50209266f, -0.46116430f, -0.03922113f, 0.06563853f, -0.02050675f, 0.06473365f, 
    -0.04471572f, -0.11813118f, 0.26650274f, -0.20948069f, -0.07121170f, 0.25091517f, -0.09608684f, 0.16033287f, 
    0.10301135f, -0.02473073f, -0.07670580f, 0.07305852f, 0.15714131f, 0.21535726f, -0.16487542f, 0.09172523f, 
    0.00022152f, 0.30841917f, -0.29109797f, 0.03893018f, 0.36366770f, -0.15263596f, -0.34299263f, -0.27168232f, 
    0.06677687f, -0.10005610f, 0.18531285f, -0.07670563f, -0.04456605f, 0.27938792f, 0.28860512f, 0.07737867f, 
    0.11484958f, -0.00376504f, 0.13359857f, -0.10009062f, 0.00322682f, -0.16059685f, -0.02496522f, 0.02262974f, 
    0.08842543f, -0.00657680f, 0.09393877f, -0.00401978f, -0.07737958f, -0.01933744f, 0.02011635f, -0.01888081f, 
    -0.32584974f, -0.26604450f, 0.13361877f, 0.05815245f, -0.09718710f, 0.14143719f, 0.09440728f, -0.32623026f, 
    0.10690458f, 0.25370342f, 0.03691375f, 0.02727917f, 0.09972370f, -0.02657921f, 0.16128331f, -0.13951246f, 
    0.00591606f, 0.17003928f, -0.00002767f, -0.21424913f, 0.23975664f, -0.07906649f, -0.01890063f, -0.00131725f, 
    -0.07333947f, 0.24403483f, 0.19249327f, -0.19181731f, -0.37124592f, 0.14282580f, 0.10401225f, -0.04912015f, 
    0.36529902f, -0.11007982f, -0.17143832f, -0.20505546f, 0.01245027f, 0.05875188f, -0.13548104f, -0.04410164f, 
    -0.17512427f, -0.10207918f, -0.04008846f, -0.07159001f, 0.00696125f, 0.12630764f, 0.11340982f, 0.00128790f, 
    -0.08522560f, 0.17236988f, 0.11994802f, 0.18034343f, -0.04003088f, 0.02878341f, 0.14896087f, 0.13676363f, 
    -0.02786581f, 0.03051620f, -0.15598467f, 0.05247278f, 0.06994261f, 0.24414031f, 0.33581173f, 0.11847956f, 
    0.01226154f, 0.02334791f, -0.06876474f, 0.01872648f, 0.03125083f, -0.05478774f, -0.03201598f, 0.06373176f, 
    -0.23209199f, -0.21300645f, -0.13731888f, 0.06099815f, -0.03990114f, 0.10744694f, -0.13034375f, -0.10086158f, 
    0.04482207f, -0.07864939f, -0.14680991f, -0.07721139f, -0.02182639f, -0.10159598f, 0.12583393f, -0.06759614f, 
    -0.08283484f, 0.16512664f, 0.18821535f, -0.04896794f, 0.01672698f, 0.02445568f, -0.05649190f, 0.01955952f, 
    -0.00857688f, 0.08745693f, 0.02059569f, 0.11103134f, -0.31372288f, 0.26066822f, -0.00315598f, 0.09820416f, 
    0.21261911f, 0.00487776f, -0.28915173f, -0.13856447f, 0.15112191f, -0.01237409f, 0.13356437f, 0.09205720f, 
    0.06021071f, -0.07442272f, -0.11213215f, -0.15245050f, 0.00473046f, 0.23595701f, -0.11022789f, 0.08138663f, 
    -0.03452195f, -0.13256301f, -0.03479290f, -0.00292029f, -0.20908092f, -0.04279248f, -0.28341818f, 0.14321472f, 
    -0.07348050f, 0.07656092f, -0.00490494f, 0.10815569f, 0.01690428f, -0.11039766f, 0.09889131f, -0.03304363f, 
    0.15072985f, -0.22804779f, 0.03140900f, 0.07331908f, 0.11124936f, 0.06338669f, -0.13160816f, -0.00145971f, 
    -0.09377185f, 0.10138238f, -0.08774512f, 0.01645613f, -0.03405836f, 0.07324895f, 0.12189738f, 0.01774406f, 
    0.13064899f, -0.00929229f, -0.13817604f, -0.01885975f, 0.04930357f, 0.08928180f, -0.13255176f, -0.02843264f, 
    0.18981947f, -0.34106261f, -0.99137503f, -0.11771528f, -0.25750723f, -0.42850038f, 0.06166372f, 0.21333270f, 
    0.07078359f, -0.14244933f, 0.50897729f, -0.30135688f, 0.25874794f, 0.04588316f, 0.06806661f, 0.04026559f, 
    -0.13093673f, 0.22084403f, -0.09858000f, 0.12200225f, -0.18851693f, 0.36017156f, -0.09876990f, -0.07852099f, 
    -0.02251964f, 0.09009218f, -0.07170863f, 0.05735723f, -0.01545198f, -0.01973677f, -0.03393454f, -0.07044935f, 
    0.13588086f, 0.04910164f, 0.10934924f, 0.17410663f, -0.07334574f, -0.01724063f, -0.19486199f, -0.10596705f, 
    -0.02624245f, -0.08519174f, -0.01703451f, 0.05885917f, 0.06014558f, 0.27365047f, -0.05967686f, 0.11106320f, 
    -0.12463007f, 0.14258896f, -0.04677048f, -0.01837485f, -0.15414202f, 0.05747326f, 0.17114513f, -0.13782069f, 
    0.22101948f, 0.05840454f, -0.04972712f, 0.13337268f, -0.09846900f, -0.03173554f, 0.05560254f, 0.04352610f, 
    0.25898170f, -0.23883221f, 0.48278359f, -0.21525474f, -0.15129644f, -0.04806789f, -0.11962956f, -0.03541835f, 
    0.02892690f, 0.13244434f, 0.16281803f, 0.11698410f, 0.06183855f, 0.21839358f, -0.10968800f, -0.01519937f, 
    -0.03132474f, 0.10656291f, 0.10812525f, -0.30464351f, 0.03584728f, -0.24524631f, -0.10354067f, -0.12694262f, 
    -0.00307939f, 0.02716745f, 0.09953567f, -0.28748301f, -0.07738667f, -0.11410049f, -0.06109279f, 0.04641462f, 
    -0.12061663f, 0.07779034f, 0.14975108f, 0.06318954f, -0.30933011f, 0.14505000f, 0.16163972f, -0.04320086f, 
    0.27182478f, 0.08194642f, 0.04178376f, -0.27364370f, -0.08641985f, 0.45368662f, 0.16553530f, 0.21389088f, 
    -0.15083721f, 0.10903026f, 0.01072164f, 0.06785156f, 0.22023800f, 0.06151890f, 0.38423127f, 0.30836478f, 
    0.06966830f, 0.05875676f, -0.13519602f, -0.06308128f, -0.06149553f, 0.03769267f, 0.25614044f, 0.18269774f, 
    0.07225467f, 0.25591823f, 0.06183480f, 0.06446592f, -0.35491255f, -0.17254683f, 0.18222196f, 0.15900517f, 
    0.34313798f, 0.01062543f, 0.28501704f, -0.18655066f, -0.06213592f, 0.03966935f, 0.01267694f, 0.06416029f, 
    0.09843259f, -0.11047632f, -0.12222715f, 0.13377535f, -0.24627076f, -0.31900996f, 0.00011654f, 0.02668458f, 
    0.02842199f, 0.02304882f, -0.36243767f, -0.34895739f, -0.55956298f, -0.06648551f, -0.49507093f, -0.07571212f, 
    -0.07111097f, 0.23886119f, -0.07491138f, -0.21217819f, -0.32420528f, -0.07802998f, -0.05972501f, 0.01349818f, 
    -0.15630285f, -0.09499003f, 0.16097419f, 0.24799992f, 0.41311800f, 0.08262011f, -0.03983689f, -0.11541430f, 
    0.03300214f, -0.01437048f, -0.01206961f, 0.02842303f, 0.08929644f, 0.35722679f, -0.11768633f, 0.09591221f, 
    0.03739791f, -0.10515095f, 0.01368940f, -0.04652578f, 0.21573657f, 0.04986984f, 0.28001028f, -0.07463600f, 
    -0.02774021f, 0.11183268f, -0.41950336f, -0.05098577f, -0.28131917f, 0.07776102f, 0.03611954f, -0.00383154f, 
    0.08332569f, 0.00404302f, -0.07415263f, 0.07010113f, -0.10946571f, 0.23979034f, 0.03224760f, -0.17766826f, 
    -0.18375719f, 0.10059769f, 0.14742012f, 0.11853971f, 0.23927392f, 0.07116634f, 0.04173768f, 0.07671391f, 
    0.15097719f, -0.21257769f, -0.00827259f, -0.04849822f, -0.14639100f, -0.42780951f, -0.09345909f, 0.14318541f, 
    0.08514174f, 0.17065287f, -0.09526343f, -0.02600686f, 0.34132591f, -0.06026154f, -0.01682694f, 0.09974486f, 
    0.07977087f, -0.09657944f, 0.39047697f, 0.11167413f, -0.20771807f, -0.32575282f, -0.32723197f, 0.11258473f, 
    -0.03897543f, 0.26732153f, 0.38361090f, -0.15609938f, -0.08811704f, -0.22931023f, -0.29108512f, -0.22157121f, 
    0.16288242f, -0.24331971f, 0.09636255f, 0.16836946f, -0.07469112f, -0.53116727f, 0.05881734f, -0.01141397f, 
    -0.12885016f, -0.12181038f, -0.01929928f, -0.09250005f, 0.10007491f, 0.24979791f, 0.15601616f, -0.18245777f, 
    -0.16810206f, -0.05149921f, -0.04296903f, -0.16463175f, -0.08752625f, 0.09859278f, 0.12019167f, -0.30672747f, 
    -0.29655623f, 0.04733199f, -0.02884423f, -0.08389031f, -0.28425941f, -0.01781715f, 0.03702834f, -0.19321375f, 
    -0.25943553f, -0.15122290f, 0.11953885f, 0.08471417f, -0.06730867f, -0.09460193f, 0.01820525f, 0.20241345f, 
    0.00336609f, -0.14545681f, 0.69084758f, -0.11590602f, -0.04767837f, -0.23237962f, 0.08463547f, 0.08287892f, 
    -0.00784316f, -0.16462734f, -0.63222969f, -0.26707482f, -0.05934057f, 0.01367166f, -0.13939269f, -0.24632162f, 
    0.13231564f, 0.05152960f, 0.05925843f, -0.21125408f, 0.12062345f, 0.17794253f, -0.02939114f, -0.00871265f, 
    0.05685482f, 0.02821125f, 0.12756406f, -0.21029951f, 0.07339845f, 0.12876529f, 0.00187988f, 0.09610105f, 
    0.11201888f, -0.00873424f, 0.04526393f, 0.20265894f, -0.10239884f, -0.00217581f, -0.01097493f, -0.00319218f, 
    0.13379440f, 0.11252002f, -0.15377998f, 0.04313575f, 0.09306660f, 0.04365789f, 0.09196916f, 0.15220337f, 
    0.04501214f, 0.05634125f, -0.04116751f, 0.31139606f, -0.06663138f, -0.05961264f, -0.00040401f, 0.16700943f, 
    -0.07479871f, -0.01206987f, -0.07352419f, -0.10116152f, 0.03572459f, -0.08827439f, 0.13151291f, 0.05145078f, 
    -0.72397506f, -0.29481059f, 0.03310697f, 0.11720409f, 0.32483119f, -0.02815971f, 0.09617456f, -0.10892291f, 
    0.02750663f, 0.26219854f, -0.29129916f, -0.31823194f, 0.12969854f, -0.06598235f, 0.22962295f, 0.09082013f, 
    -0.00962542f, 0.06461526f, 0.50425136f, 0.11922307f, 0.11937002f, 0.14942387f, 0.13714284f, 0.23522703f, 
    0.03240944f, 0.03029790f, -0.09405525f, -0.22453381f, 0.17467675f, -0.00163244f, 0.08873291f, -0.00952372f, 
    -0.09219079f, -0.07455502f, -0.00669793f, 0.24422301f, -0.07301963f, -0.37550008f, -0.50417465f, 0.09532528f, 
    0.17154828f, 0.08223042f, -0.05003607f, -0.01299204f, -0.10523246f, -0.33811894f, -0.02812807f, -0.10354605f, 
    -0.03468387f, 0.14455438f, 0.18524770f, 0.11761884f, 0.03684208f, -0.10008486f, -0.23122616f, 0.20774826f, 
    0.23911658f, -0.08016744f, -0.26168534f, -0.17329165f, 0.03150874f, 0.03697348f, 0.06430347f, -0.08700433f, 
    -0.09809694f, -0.03154241f, 0.13005297f, -0.38782197f, 0.13774000f, 0.24192123f, 0.05500332f, 0.14083280f, 
    -0.14439033f, 0.12450057f, -0.08139701f, 0.00879996f, 0.14935911f, 0.00468446f, 0.10617017f, 0.05891378f, 
    0.00979997f, 0.11366006f, 0.33845916f, -0.01727061f, -0.07855329f, -0.09576250f, -0.10533443f, 0.02718698f, 
    0.05503666f, 0.13467711f, 0.32811543f, 0.61868787f, -0.45120612f, -0.29260224f, 0.30609187f, -0.04709207f, 
    0.13260320f, 0.02164087f, -0.23208956f, 0.11373787f, 0.21889415f, -0.07399711f, 0.29710054f, 0.22753847f, 
    -0.05077904f, -0.04366633f, 0.03853284f, -0.03795783f, -0.15902069f, -0.00449316f, -0.22057439f, 0.01807142f, 
    -0.06075122f, 0.23438302f, 0.07047030f, -0.00758370f, -0.02849662f, -0.73673737f, -0.04799959f, 0.24011743f, 
    0.15172963f, 0.14264797f, 0.00888862f, 0.08165236f, -0.05288910f, 0.10042981f, -0.29427043f, -0.16648808f, 
    0.18155777f, -0.06652489f, -0.16244306f, 0.11428072f, -0.06899320f, 0.13430662f, -0.07913624f, 0.19901249f, 
    0.22510597f, -0.13510939f, 0.20946437f, -0.07370213f, -0.04849759f, 0.19789800f, -0.06616103f, -0.03226441f, 
    0.05964705f, 0.07653860f, -0.06605931f, 0.22435114f, 0.03134583f, 0.03314507f, 0.01263329f, -0.02657211f, 
    0.11627436f, 0.28723559f, 0.19178317f, -0.11275070f, -0.10829577f, -0.03864157f, -0.04671944f, -0.01616253f, 
    -0.03550122f, 0.06334767f, -0.12301660f, 0.17702176f, 0.00928794f, 0.09277584f, 0.12262753f, -0.01829066f, 
    0.17332737f, -0.30678445f, 0.12917021f, 0.10855035f, 0.19148207f, -0.01360350f, 0.13437496f, -0.17329642f, 
    -0.06246220f, 0.14649007f, 0.09842601f, -0.01892295f, 0.17777666f, 0.15936866f, 0.00652924f, 0.24252321f, 
    0.10244865f, -0.14487292f, 0.15298995f, -0.12998366f, 0.00554435f, -0.09749073f, -0.07625949f, -0.52900529f, 
    -0.23703800f, -0.13457395f, -0.02636526f, 0.05021446f, 0.03863574f, -0.27001405f, -0.13842030f, -0.02167272f, 
    -0.09084513f, 0.05823646f, 0.02682787f, 0.03020021f, -0.10859520f, -0.07163388f, 0.23461200f, -0.10073113f, 
    -0.38625133f, -0.10547946f, 0.01265140f, 0.10534042f, -0.09912422f, -0.03443896f, -0.21686819f, 0.05741763f, 
    -0.02330720f, 0.06201126f, -0.09514535f, -0.07036405f, -0.05721463f, -0.07661033f, -0.23062831f, -0.07174045f, 
    -0.28518105f, 0.22619098f, -0.10140674f, 0.41895661f, -0.15564965f, 0.29251662f, 0.35925949f, 0.01180372f, 
    0.26755905f, 0.16144061f, 0.04875912f, 0.03845366f, 0.30352315f, 0.05615613f, 0.07109866f, 0.01963946f, 
    0.17481709f, -0.11762641f, 0.30112723f, -0.21157753f, -0.10008594f, 0.05182634f, 0.04717156f, 0.09818677f, 
    0.07656546f, -0.06369633f, -0.17167890f, 0.09353995f, -0.00188256f, -0.00286215f, 0.03092713f, 0.02109523f, 
    -0.22620869f, -0.01578119f, 0.01055217f, 0.07565301f, 0.16757016f, 0.20238507f, 0.03983748f, 0.03992252f, 
    0.13048834f, 0.05682366f, 0.29260007f, -0.20704444f, 0.02692592f, 0.15991956f, 0.35357380f, 0.21873006f, 
    0.14005189f, 0.15247063f, 0.22201389f, 0.14444053f, 0.03408229f, 0.06105988f, 0.06289059f, -0.12294554f, 
    -0.18825063f, 0.01941839f, 0.00866518f, 0.08958761f, 0.00937497f, 0.24036705f, -0.17769340f, -0.49096832f, 
    -0.25994432f, -0.17546448f, 0.31507823f, 0.04936205f, 0.27480438f, -0.08596342f, 0.28289062f, -0.12785643f, 
    -0.00570922f, 0.24525324f, 0.40056199f, 0.19255607f, -0.23624401f, 0.02034158f, -0.14667973f, -0.15888321f, 
    -0.17968245f, -0.10395742f, 0.19537230f, 0.03415326f, -0.13427170f, -0.13044187f, 0.02664866f, 0.09626341f, 
    0.01148920f, 0.17248172f, -0.23370619f, 0.03954089f, 0.01763373f, 0.00169789f, 0.19995295f, 0.06337550f, 
    0.14346954f, -0.05847811f, -0.09481278f, -0.08575588f, 0.12565036f, 0.41723001f, 0.29687741f, -0.05303986f, 
    0.00737391f, -0.01362185f, -0.07236455f, -0.03701492f, -0.00156755f, -0.41305023f, -0.23576698f, -0.08041051f, 
    0.13796711f, 0.15567818f, 0.10492048f, 0.08423497f, 0.05816625f, 0.12826002f, -0.23691280f, 0.18938525f, 
    -0.18165006f, -0.13424399f, 0.07228256f, -0.07005800f, -0.29491436f, -0.24381620f, -0.24574231f, 0.05495961f, 
    0.02560049f, -0.20129803f, 0.18920822f, 0.20737535f, -0.00735833f, -0.27267206f, 0.28415844f, -0.05676182f, 
    -0.08173051f, -0.18362504f, 0.10966009f, 0.11700850f, 0.08482651f, 0.10828760f, 0.01515386f, 0.01218905f, 
    0.24208955f, 0.14902964f, 0.07135864f, 0.14897907f, 0.03967670f, 0.02787701f, -0.05276585f, -0.00002213f, 
    -0.01043731f, -0.46498251f, 0.35545304f, -0.10678367f, 0.36362281f, 0.08758234f, -0.35303906f, 0.12226941f, 
    0.07778057f, -0.26607934f, 0.12784338f, 0.25954396f, -0.00939883f, 0.22847366f, 0.06249611f, 0.12473878f, 
    0.18685187f, 0.10726267f, 0.17520222f, 0.02757594f, -0.05321231f, -0.21734586f, 0.07557890f, 0.20397899f, 
    0.04137212f, 0.31751302f, 0.08143678f, 0.11816001f, 0.30232623f, -0.23541178f, -0.10847150f, -0.00355075f, 
    -0.05047911f, -0.01695403f, 0.00438948f, -0.12846588f, -0.16376166f, -0.19641960f, 0.44471133f, -0.14305115f, 
    0.22860420f, -0.05950907f, 0.06119181f, -0.04674089f, 0.09897622f, 0.24011481f, -0.18048032f, 0.21046863f, 
    0.28481469f, 0.34822175f, -0.15876685f, 0.03505754f, -0.00084982f, 0.18144195f, 0.10320232f, 0.01658384f, 
    0.11572025f, 0.13758615f, 0.16463862f, 0.18632971f, 0.17630385f, 0.02603109f, 0.01470984f, 0.04103363f, 
    0.11275783f, -0.11749819f, -0.24481550f, -0.44243085f, -0.07720143f, 0.01909990f, 0.01104865f, -0.01279184f, 
    -0.00540740f, -0.16166785f, -0.04432818f, -0.10543738f, 0.08845770f, 0.12345982f, 0.11308832f, 0.14306317f, 
    -0.13301924f, 0.02118723f, 0.16515259f, -0.21576607f, -0.31331515f, -0.08883226f, 0.07469251f, 0.20541959f, 
    0.14177804f, 0.22501899f, 0.14570621f, 0.37449124f, 0.05524005f, -0.01216723f, -0.07120779f, 0.21284209f, 
    0.09169067f, 0.16595425f, 0.22676945f, 0.30823845f, 0.20540096f, 0.12483513f, 0.36324474f, -0.15448126f, 
    -0.01818579f, 0.11098765f, 0.00333181f, -0.25270173f, 0.12853147f, -0.08338467f, -0.01257149f, 0.02278987f, 
    0.14229807f, 0.18413827f, 0.12368293f, 0.19504136f, -0.06491644f, -0.03377362f, 0.13081394f, -0.11075468f, 
    0.06496219f, 0.06568582f, 0.02032441f, 0.00509987f, -0.11679107f, 0.03674856f, -0.02880872f, -0.20850892f, 
    -0.03656887f, -0.05339183f, 0.03495081f, -0.05833616f, 0.01147106f, 0.02244501f, -0.00750974f, -0.01724058f, 
    -0.02164019f, 0.02003529f, -0.03860256f, -0.00513742f, -0.02555944f, -0.01885533f, 0.04419250f, 0.00182112f, 
    0.00917787f, -0.01374064f, -0.04181742f, -0.03579716f, -0.02597703f, -0.01765920f, -0.01764908f, -0.03676311f, 
    -0.04354808f, -0.06291804f, 0.01304283f, 0.01749380f, -0.01892694f, -0.04684825f, -0.01554829f, -0.02879469f, 
    0.01440307f, -0.03392230f, -0.02598732f, 0.05059954f, 0.05313060f, 0.04102920f, -0.05044038f, -0.01425139f, 
    0.00388230f, -0.06007563f, 0.03972855f, 0.04998390f, 0.02111599f, -0.05696521f, -0.00990556f, -0.01178101f, 
    0.02266728f, 0.00291740f, 0.01113496f, -0.00101179f, 0.01038707f, 0.00237077f, -0.01528142f, -0.03224364f, 
    0.04328795f, -0.03780384f, 0.02533180f, -0.01579144f, 0.01069727f, -0.04202800f, -0.01496741f, -0.01069302f, 
    0.01396336f, 0.01423580f, -0.03949799f, -0.04543229f, -0.05581831f, 0.00050589f, 0.04195140f, -0.00047751f, 
    -0.02282963f, -0.02566936f, 0.00881000f, -0.02519747f, -0.01658169f, -0.00494686f, 0.03218578f, -0.01790742f, 
    -0.04788181f, 0.00746568f, -0.01269059f, -0.03498428f, -0.00706722f, -0.00061441f, -0.03057757f, 0.02649323f, 
    -0.03040912f, 0.03396276f, -0.03541789f, 0.02017907f, -0.01068417f, -0.01744694f, 0.01423379f, 0.02648840f, 
    -0.01853479f, 0.02789142f, 0.00156532f, -0.06335312f, -0.06005678f, 0.03661764f, -0.05928370f, -0.04588952f, 
    0.04253803f, 0.02272413f, -0.05854205f, 0.01059685f, 0.00227624f, -0.02130187f, 0.00533047f, 0.01512350f, 
    -0.02558973f, -0.06254414f, -0.06064720f, 0.03397392f, -0.05705788f, 0.00403471f, 0.03888819f, -0.00142230f, 
    -0.00571109f, 0.00686348f, 0.02244957f, -0.02650704f, -0.06650233f, -0.00093970f, -0.05892740f, 0.04100300f, 
    0.04501118f, -0.04296194f, -0.01505014f, 0.04562772f, -0.02319664f, -0.00076309f, -0.05801853f, 0.00028849f, 
    -0.05819532f, 0.02476454f, 0.03215676f, -0.03353668f, 0.02978880f, 0.02182317f, 0.03102540f, -0.01304095f, 
    -0.05234528f, -0.04011362f, 0.01785693f, 0.02837278f, -0.03107148f, -0.01160027f, 0.02045200f, -0.03648922f, 
    -0.01826496f, -0.01884396f, -0.02267615f, -0.05502073f, -0.00133548f, 0.00578540f, -0.06685429f, -0.03077502f, 
    -0.02467510f, -0.01650603f, -0.00455390f, 0.02838685f, -0.01267596f, -0.05292472f, 0.02891479f, -0.01024320f, 
    0.00814503f, 0.02192672f, -0.04446487f, -0.03171812f, 0.02697332f, 0.01254922f, 0.03542382f, -0.01793152f, 
    0.02786515f, -0.06088972f, -0.01887108f, 0.00812105f, -0.03427152f, -0.04536920f, 0.04264345f, 0.01395179f, 
    -0.03232795f, -0.04109823f, -0.03810438f, 0.01634861f, -0.04766142f, -0.05188495f, 0.04582748f, -0.04156277f, 
    -0.03399499f, -0.03982183f, -0.00876969f, -0.01305211f, -0.01959316f, 0.05059559f, -0.02399349f, -0.01600285f, 
    -0.06101044f, -0.05892532f, -0.03183299f, -0.00103908f, 0.03567924f, 0.01992600f, -0.02950311f, 0.00298043f, 
    -0.03127739f, 0.01799227f, -0.03361921f, 0.04195875f, -0.05073461f, 0.01587739f, -0.00783228f, -0.01994236f, 
    0.04806763f, -0.03409200f, -0.06447434f, 0.02271847f, 0.02015773f, -0.05246346f, 0.00714125f, -0.02910975f, 
    -0.00096705f, -0.04148135f, 0.04087341f, 0.01121350f, -0.04467591f, -0.06529975f, 0.03673726f, -0.04952611f, 
    -0.01630853f, -0.03133447f, -0.06203271f, 0.04707131f, -0.02933874f, 0.00973253f, -0.03742085f, -0.01177848f, 
    -0.01205566f, -0.04688905f, -0.03077455f, -0.03078643f, 0.03768910f, -0.06533279f, -0.02121488f, -0.01134520f, 
    -0.02629801f, -0.03241646f, 0.05013313f, -0.04188960f, 0.03852715f, 0.01476097f, -0.02361422f, 0.00519854f, 
    -0.03535588f, -0.04546425f, -0.01330614f, 0.04726769f, -0.06075061f, -0.04773140f, -0.05391816f, -0.01809976f, 
    -0.01963612f, -0.03212489f, -0.04456873f, -0.00898442f, -0.01068162f, 0.00268063f, 0.00721676f, 0.01617266f, 
    -0.02589838f, -0.02721484f, -0.03610831f, 0.03602714f, 0.03946082f, 0.01304628f, 0.03239558f, 0.01846762f, 
    0.02186573f, -0.00499660f, -0.06325664f, -0.04760959f, 0.02938486f, -0.06602352f, -0.02151829f, -0.05606552f, 
    0.04696154f, -0.00533183f, -0.01888711f, -0.02191508f, 0.00432327f, -0.04747275f, -0.04093494f, 0.03882486f, 
    0.01242089f, 0.01185278f, 0.00569871f, -0.02579346f, 0.05179790f, -0.03216486f, -0.04871967f, 0.03051567f, 
    0.04471268f, -0.03105567f, 0.03740530f, -0.05925458f, 0.03114855f, 0.04174425f, -0.01699776f, -0.03725995f, 
    -0.05963320f, 0.02770644f, 0.03053955f, -0.01019136f, 0.03111843f, -0.01909534f, -0.06588761f, 0.00232091f, 
    -0.02834567f, -0.04077542f, 0.00756749f, 0.05169935f, 0.00634380f, 0.02370377f, -0.00712892f, -0.03992943f, 
    0.02120327f, -0.01008552f, -0.06161394f, 0.00865482f, 0.03844603f, 0.01314260f, -0.04672841f, 0.02785207f, 
    0.00637274f, -0.06043422f, 0.01105596f, -0.04370761f, -0.02339470f, 0.02606093f, 0.00216125f, -0.01699124f, 
    0.03907814f, 0.00209839f, -0.02074420f, -0.02450126f, -0.01871454f, -0.04568839f, 0.01346351f, -0.05481507f, 
    0.00228076f, -0.05021559f, -0.04287406f, -0.02184368f, 0.02304412f, -0.02496551f, 0.03053118f, -0.05915323f, 
    0.02172731f, 0.02681764f, 0.03097400f, -0.00339857f, 0.01168917f, -0.02987224f, -0.05244740f, 0.00479121f, 
    -0.02661420f, -0.01092533f, -0.01693636f, 0.01196760f, -0.05232843f, 0.00254770f, 0.01358372f, 0.03315594f, 
    -0.06525054f, 0.00514378f, 0.01538213f, -0.00996834f, -0.04867719f, 0.02039970f, 0.03558542f, -0.04909239f, 
    0.04146349f, -0.01342759f, -0.00394564f, -0.02724804f, 0.03364874f, -0.00437784f, -0.01609120f, -0.04125338f, 
    0.00115257f, 0.04967590f, -0.03547259f, -0.02700401f, 0.04779806f, -0.02819855f, -0.04364620f, -0.02388679f, 
    -0.02903164f, -0.00165811f, 0.02235185f, 0.01469732f, 0.03180676f, -0.06567487f, 0.01652092f, -0.06319265f, 
    -0.04659199f, 0.04689620f, -0.04122859f, -0.06184042f, 0.00290353f, -0.05684035f, 0.04681233f, 0.03244298f, 
    -0.03431676f, -0.00077212f, -0.04391000f, 0.02798706f, -0.02982242f, -0.01342821f, 0.03413574f, -0.04442250f, 
    0.04513477f, -0.02737587f, 0.00542966f, -0.03145562f, 0.04745373f, -0.03586917f, 0.01415771f, 0.02411900f, 
    0.02324308f, -0.05275325f, 0.02250917f, -0.04147060f, 0.02689548f, -0.05716338f, 0.01198401f, 0.03246906f, 
    -0.02870582f, 0.04693241f, -0.04919568f, -0.06088079f, 0.00828280f, -0.01566162f, 0.02825328f, 0.03920287f, 
    -0.03036391f, -0.05394770f, -0.06028801f, 0.03480749f, -0.04149202f, 0.02486558f, -0.06146476f, 0.01248787f, 
    -0.00869023f, -0.01276575f, -0.04033266f, -0.03466100f, -0.05271459f, -0.04123877f, -0.04694227f, 0.03447305f, 
    -0.04271301f, -0.04743619f, 0.00282045f, -0.01745611f, 0.02820869f, -0.03323731f, 0.03943777f, 0.00620403f, 
    0.00383974f, -0.02436652f, 0.01495173f, -0.03131801f, -0.04427077f, -0.00322637f, -0.05462125f, -0.04013143f, 
    -0.04130107f, -0.01859922f, 0.03018288f, -0.06127376f, -0.03290585f, 0.02821350f, 0.00082344f, 0.03850499f, 
    -0.03021447f, 0.02095942f, -0.05549070f, 0.03923103f, -0.03598607f, 0.03481317f, 0.02404138f, -0.05941499f, 
    -0.06262599f, -0.03655530f, 0.02275784f, 0.04118255f, -0.05914507f, -0.04105882f, -0.01195437f, -0.02395356f, 
    0.01462254f, 0.02765170f, -0.04251291f, 0.02549357f, 0.02946470f, -0.03708369f, -0.01370911f, 0.00138242f, 
    -0.01587554f, 0.01459367f, 0.02754546f, 0.01419783f, -0.00993710f, -0.00066772f, -0.05538963f, -0.03195759f, 
    -0.00049006f, -0.05600544f, -0.03660128f, -0.00189850f, 0.03935222f, -0.04043028f, 0.00775383f, -0.04550045f, 
    0.03944423f, -0.00928232f, -0.05612880f, 0.00594751f, -0.06076615f, 0.02585043f, 0.01665805f, -0.03805609f, 
    0.00616530f, 0.00601095f, -0.06087281f, -0.05502412f, 0.00160206f, 0.05179386f, -0.01201814f, 0.03391397f, 
    0.00063474f, -0.04218734f, 0.03330453f, 0.02131966f, 0.02399587f, -0.01565948f, 0.02509970f, -0.02355114f, 
    -0.04388681f, 0.01695484f, -0.03683833f, 0.02043558f, -0.01395319f, -0.00863444f, 0.01479308f, -0.05805350f, 
    -0.03846735f, -0.05061769f, 0.00490592f, 0.04683512f, 0.00097920f, -0.02519569f, 0.02830999f, 0.01676719f, 
    -0.06366892f, 0.02843039f, 0.03832368f, 0.00765038f, 0.00961123f, -0.02732661f, 0.01073339f, 0.04067819f, 
    0.47171190f, 0.02072804f, -0.11860719f, 0.12275763f, 0.11465000f, 0.14624496f, 0.16518579f, -0.04438182f, 
    -0.39944354f, -0.45483008f, 0.31967801f, 0.28014022f, 0.13620616f, -0.02342508f, 0.02145278f, 0.22459151f, 
    0.25504336f, 0.11999539f, -0.40239838f, -0.52379614f, 0.12163263f, 0.08603671f, 0.10118383f, -0.03377659f, 
    -0.04200318f, 0.02029598f, -0.08087122f, 0.01472342f, -0.09752792f, 0.03807344f, -0.02415744f, -0.08616991f, 
    0.19223030f, -0.15866381f, -0.38460049f, -0.50146681f, 0.28390676f, 0.12212352f, 0.07883294f, -0.42146233f, 
    -0.37596887f, 0.03016559f, 0.12610728f, 0.17584974f, 0.07809957f, 0.32330549f, 0.11101023f, 0.00853841f, 
    -0.01275218f, -0.02069303f, 0.16178904f, 0.02832868f, 0.28203991f, -0.01585541f, 0.15741597f, 0.23159724f, 
    -0.02989518f, 0.05575940f, -0.00384453f, 0.06376491f, 0.02293884f, -0.06666933f, -0.09343898f, -0.24745761f, 
    -0.30512804f, -0.01758537f, -0.05850447f, 0.17056558f, 0.10502459f, -0.22531596f, -0.31922683f, -0.17870483f, 
    0.07455759f, -0.25876117f, -0.28404710f, -0.07168867f, -0.06595931f, 0.26066056f, -0.05668787f, 0.15793703f, 
    0.29739514f, -0.07852754f, -0.36032835f, -0.30200985f, 0.04770180f, -0.01600632f, -0.11880001f, -0.12570314f, 
    -0.11608743f, 0.09050735f, -0.02281491f, 0.28215188f, 0.16176310f, -0.07239778f, -0.18474926f, 0.09664673f, 
    0.05573496f, -0.07499765f, -0.11827417f, 0.11685380f, 0.18644983f, -0.01048383f, 0.25317883f, -0.18281500f, 
    -0.34897667f, -0.05753450f, 0.12997830f, -0.08382565f, -0.00252001f, 0.12128016f, -0.13936725f, 0.00983135f, 
    0.01083727f, -0.05979425f, 0.04067766f, -0.01030511f, -0.02149963f, 0.05193930f, -0.22702517f, -0.11085966f, 
    0.03693603f, 0.04944963f, -0.12802695f, -0.22904392f, -0.00256717f, 0.17569622f, 0.30199963f, 0.45666078f, 
    -0.08696076f, 0.11232905f, 0.07449608f, -0.03638484f, 0.02628063f, -0.10400727f, -0.49902290f, -0.01972970f, 
    -0.08514795f, 0.23897587f, -0.04832796f, -0.03669205f, -0.39991608f, 0.16669296f, 0.03555690f, -0.03988395f, 
    0.16699457f, -0.04325251f, -0.00713814f, 0.20709552f, 0.01375107f, 0.03478787f, -0.16187873f, 0.18250796f, 
    -0.02553228f, -0.09029136f, 0.28937048f, 0.32024640f, -0.05538938f, -0.04580033f, 0.09674519f, -0.04591060f, 
    -0.16742159f, -0.06786633f, -0.47257712f, -0.07437346f, 0.69159639f, -0.15677935f, 0.05634144f, 0.61405903f, 
    0.38757557f, 0.34091809f, 0.05221801f, -0.19954097f, 0.16011663f, 0.00784537f, -0.09443203f, 0.06458854f, 
    -0.07937890f, -0.06308453f, 0.10373848f, 0.01105480f, 0.03394572f, 0.05337872f, -0.19731604f, 0.00548835f, 
    0.09921329f, 0.04322294f, 0.00695674f, -0.21046728f, 0.12711965f, 0.01561524f, -0.05477503f, -0.24097498f, 
    0.17055534f, -0.04532836f, 0.08061650f, -0.25248313f, 0.01466553f, -0.06399319f, 0.31464052f, 0.04441616f, 
    -0.12280042f, 0.17676432f, 0.16254716f, 0.06685060f, 0.05183703f, 0.01793245f, -0.18561380f, 0.20842560f, 
    0.27380991f, -0.01972163f, -0.11222944f, -0.20219980f, -0.00866304f, 0.11554459f, 0.10077643f, -0.00920438f, 
    0.02822486f, 0.07875220f, 0.10041765f, -0.19947885f, -0.17608029f, 0.10249376f, 0.16316277f, 0.08250918f, 
    -0.00481027f, 0.30528191f, 0.61986637f, 0.05343717f, -0.07662553f, -0.09977030f, 0.08289992f, -0.00356477f, 
    -0.23058955f, -0.15488710f, 0.07586283f, 0.02050944f, 0.02022540f, 0.09805575f, -0.10263766f, -0.04048210f, 
    -0.19450043f, -0.04678277f, -0.06646922f, -0.11894834f, -0.15091975f, -0.02525500f, -0.15453230f, 0.09647218f, 
    -0.08087857f, 0.07882996f, 0.09754230f, 0.04784556f, -0.17659175f, 0.13291608f, 0.25158170f, -0.39625651f, 
    -0.01899520f, 0.00471844f, 0.32466730f, 0.13949730f, 0.07459577f, -0.08009420f, -0.12969044f, -0.45498881f, 
    0.20863101f, 0.02108791f, -0.23251334f, 0.00294761f, -0.20353962f, -0.26921606f, 0.09326749f, 0.22946790f, 
    -0.01287771f, 0.24599634f, -0.00411039f, 0.17157620f, -0.09009697f, 0.11923424f, -0.05726295f, -0.10299330f, 
    -0.08340789f, -0.04339345f, 0.08605320f, 0.05649085f, -0.15571804f, -0.24099161f, 0.17033419f, -0.22382756f, 
    -0.04311775f, -0.05799714f, 0.01556953f, 0.04340179f, -0.05040041f, 0.00912692f, 0.04112692f, -0.02388537f, 
    -0.06125068f, -0.04704953f, 0.01081715f, -0.01321617f, 0.03269848f, -0.04771657f, -0.03093426f, -0.03222168f, 
    -0.06295882f, 0.03949641f, 0.02995519f, -0.02642551f, -0.03543644f, -0.03209731f, 0.04456408f, -0.06316672f, 
    0.00121603f, -0.04467389f, -0.01452929f, -0.07337289f, 0.04136095f, -0.03759666f, 0.00954106f, 0.00279054f, 
    -0.03341960f, -0.00656540f, -0.04735662f, -0.02987843f, 0.01215771f, -0.01865976f, -0.04323274f, 0.03421102f, 
    0.00830085f, -0.00459989f, 0.03982744f, -0.05979109f, 0.03657299f, 0.01752647f, -0.00391750f, 0.02499008f, 
    -0.00401936f, -0.07023395f, -0.03270703f, 0.02903653f, -0.00450534f, -0.04694772f, -0.00241858f, 0.03960533f, 
    -0.02210753f, 0.02509217f, -0.02179487f, -0.02277664f, -0.01471243f, 0.01781079f, 0.03691490f, 0.00178170f, 
    -0.00325622f, -0.00309956f, -0.05374081f, 0.02809199f, -0.04785739f, -0.01548996f, -0.00676821f, -0.02860417f, 
    0.01089979f, -0.07264312f, -0.00849830f, 0.02462474f, -0.04286922f, 0.01531922f, -0.01696025f, -0.00839900f, 
    -0.03396772f, 0.01861375f, -0.02258079f, -0.05148236f, -0.00796132f, 0.01120903f, 0.02223994f, 0.02085062f, 
    0.00748593f, -0.02916998f, -0.05070740f, -0.02472122f, -0.05591713f, 0.02283069f, -0.03319640f, -0.03944916f, 
    -0.03169101f, -0.00160242f, 0.00059184f, -0.00458145f, -0.06564333f, 0.03647584f, 0.04491355f, 0.01024125f, 
    0.02622078f, -0.04602847f, -0.00142474f, 0.03283105f, -0.05144414f, -0.00196989f, 0.01827761f, 0.00124857f, 
    -0.01225134f, -0.03489619f, 0.00481456f, 0.02557207f, -0.05603324f, 0.03288180f, 0.03585410f, 0.01595877f, 
    0.03242137f, 0.03692264f, -0.00204619f, -0.05706234f, 0.01455608f, -0.06010692f, -0.02919174f, -0.02967520f, 
    -0.04181191f, -0.01852759f, -0.00294831f, -0.05173812f, -0.06896513f, -0.04706446f, -0.05638580f, 0.01864309f, 
    -0.02801220f, -0.07043868f, -0.00932422f, -0.06259914f, 0.04046766f, -0.02913132f, 0.03473243f, -0.05929430f, 
    0.03313371f, 0.04411588f, -0.01722136f, 0.02764135f, 0.02588846f, -0.05471976f, -0.01464819f, -0.03220369f, 
    -0.04508571f, -0.05051633f, 0.00996578f, -0.05572825f, 0.00640825f, -0.06651827f, -0.05468277f, -0.03876671f, 
    -0.01344223f, -0.03636418f, -0.01952567f, 0.01362928f, 0.02982071f, -0.04424463f, -0.02524487f, 0.04160663f, 
    -0.05463086f, -0.01512219f, -0.03673309f, -0.06346662f, -0.02618261f, -0.03597403f, -0.06046164f, 0.01053058f, 
    -0.06356789f, 0.03193744f, -0.02289104f, 0.02497267f, 0.01930887f, -0.00893423f, -0.05095863f, -0.01702616f, 
    -0.02602483f, -0.06087508f, 0.02391354f, -0.05575607f, -0.01938858f, 0.02805351f, -0.05886944f, -0.02116225f, 
    0.03721466f, -0.05221955f, 0.04081609f, 0.00500328f, -0.00361557f, -0.05314476f, 0.01214011f, 0.01579818f, 
    -0.00331891f, 0.02551837f, -0.04735835f, -0.03051845f, -0.00082049f, 0.04016678f, -0.06684583f, -0.05395935f, 
    -0.04368750f, 0.04194634f, -0.05192751f, -0.02818640f, -0.02569686f, 0.03256172f, -0.01054510f, 0.02068325f, 
    -0.03214932f, -0.00103911f, 0.01532220f, 0.02380836f, 0.03656071f, -0.03761807f, 0.03272307f, 0.04512369f, 
    0.04586235f, -0.04145240f, 0.00596198f, -0.03113351f, 0.00612507f, -0.06546353f, -0.06454790f, -0.04474711f, 
    -0.05236347f, 0.01514348f, -0.06990623f, -0.00213560f, -0.01296461f, -0.03180402f, -0.03552995f, 0.04654496f, 
    -0.06709520f, 0.03220676f, -0.02321499f, -0.00250816f, 0.04395727f, -0.00733403f, -0.00199873f, 0.04257576f, 
    0.01586687f, 0.00207672f, -0.06469458f, -0.06565768f, -0.00040372f, -0.00873031f, -0.05722611f, -0.03861153f, 
    0.01503593f, -0.00812411f, -0.02442245f, -0.06521659f, 0.00684444f, -0.02688340f, 0.01725234f, 0.03724298f, 
    0.02274342f, 0.04189388f, 0.02358604f, -0.03350036f, 0.04366020f, -0.02815535f, -0.07096440f, 0.00849283f, 
    0.00631330f, 0.00590601f, 0.04688447f, 0.02222780f, 0.01302873f, 0.03176161f, 0.02563128f, 0.04168165f, 
    -0.05966840f, -0.02450631f, -0.03128700f, -0.00857139f, 0.02658094f, -0.03150994f, -0.05004134f, 0.00539259f, 
    0.05091201f, 0.03506908f, 0.04077787f, -0.02518540f, -0.05806576f, 0.02083703f, -0.05745963f, 0.01050631f, 
    -0.04942391f, 0.04071076f, 0.04695270f, -0.00523150f, -0.03667020f, -0.00706673f, -0.02012343f, -0.00777076f, 
    -0.02824266f, -0.02288717f, 0.04718261f, 0.00618652f, 0.00885585f, 0.00494991f, -0.01228272f, 0.03835322f, 
    -0.04739110f, -0.03817906f, -0.02792407f, 0.04406596f, 0.01027140f, 0.01039190f, -0.03546192f, 0.00537983f, 
    -0.03720021f, -0.03796547f, 0.01330424f, 0.01182955f, 0.02635358f, -0.05837604f, 0.02199922f, 0.01260836f, 
    -0.00066603f, 0.03183989f, -0.00964141f, -0.00532866f, -0.04786588f, 0.04348527f, -0.00396678f, 0.03877096f, 
    -0.01484551f, -0.00705606f, -0.03789365f, -0.04039204f, -0.04174405f, 0.02948530f, -0.05136438f, -0.06260587f, 
    0.03810812f, -0.04558776f, -0.01890376f, -0.04438155f, 0.04334494f, 0.03560849f, -0.05346147f, -0.01994295f, 
    0.02024056f, -0.02233345f, -0.04406828f, -0.00979692f, 0.03360998f, -0.03662161f, 0.00123424f, -0.04845381f, 
    0.05220233f, 0.02980871f, -0.05265822f, -0.01642493f, 0.00592490f, 0.04394801f, -0.04268699f, 0.04077935f, 
    -0.01967770f, -0.03640939f, -0.04398549f, 0.03275092f, 0.02904072f, 0.03300769f, -0.01032002f, 0.03669906f, 
    0.00865400f, -0.03330896f, -0.03669542f, -0.00574170f, -0.04413367f, 0.00151152f, -0.04167677f, 0.00094484f, 
    -0.03287708f, -0.05119039f, -0.02695172f, -0.03209613f, 0.01226636f, -0.04125745f, -0.00533021f, -0.05443941f, 
    0.00651189f, 0.01380641f, 0.03761636f, -0.00652699f, -0.05213064f, 0.02543268f, -0.02921858f, -0.02065964f, 
    -0.02733670f, 0.05178823f, 0.03966944f, 0.04036304f, -0.02186748f, -0.02854527f, 0.04929780f, -0.05671882f, 
    -0.01048666f, 0.00799166f, -0.02654778f, -0.04794607f, 0.03029324f, 0.00505415f, -0.01357992f, 0.05588015f, 
    0.00499763f, -0.01825466f, -0.05986338f, 0.04026006f, 0.00920578f, -0.04612120f, -0.02162564f, 0.00036825f, 
    0.02211887f, 0.01312923f, 0.04597202f, 0.04585845f, -0.03005058f, 0.04120768f, 0.04506339f, -0.02452845f, 
    -0.03339345f, 0.02872775f, -0.03800050f, -0.06321917f, -0.00192686f, 0.04144315f, 0.01046728f, 0.04124033f, 
    -0.01649950f, 0.00406702f, 0.00436580f, 0.03657751f, -0.01311648f, 0.05324807f, 0.03997462f, -0.04951773f, 
    -0.02618178f, 0.00191570f, -0.03201604f, 0.00051516f, -0.04337473f, -0.01679528f, -0.00811411f, -0.00569423f, 
    0.04836935f, -0.03746459f, -0.01117800f, 0.00475718f, 0.00721220f, 0.03766821f, -0.01804257f, 0.04072459f, 
    0.04117222f, 0.00183237f, -0.05276558f, -0.05541645f, -0.03733956f, 0.04264023f, -0.01911490f, -0.04571092f, 
    -0.01514126f, -0.03596701f, -0.04360989f, -0.02001649f, 0.01790892f, -0.01439086f, -0.00871224f, -0.00965206f, 
    -0.00257566f, -0.01974857f, -0.01619098f, 0.04979321f, -0.00734894f, 0.00224654f, -0.00218391f, -0.03038629f, 
    -0.04487639f, -0.04373280f, -0.06302272f, -0.04543124f, -0.01098713f, -0.00697371f, 0.03268962f, -0.01977031f, 
    0.02984075f, -0.03460493f, -0.04087783f, 0.03393967f, 0.03067535f, -0.00023069f, -0.05624931f, -0.04374037f, 
    -0.04947937f, -0.06533237f, 0.05064412f, -0.04682658f, -0.04626773f, -0.05909213f, 0.01095855f, 0.04173111f, 
    0.02075435f, -0.00748804f, 0.05690387f, -0.02495837f, 0.00188733f, -0.04248059f, 0.02761956f, -0.05458087f, 
    -0.04809727f, -0.04380774f, -0.03373670f, 0.00790890f, -0.00827547f, 0.04335401f, -0.00695476f, 0.03721376f, 
    -0.01711465f, -0.01370237f, -0.02091069f, -0.02651487f, -0.02819922f, 0.04745177f, -0.05982256f, 0.04989821f, 
    0.01905884f, 0.03553657f, -0.01658324f, 0.02798520f, 0.04688041f, 0.00840946f, 0.02208539f, 0.04757969f, 
    0.00191615f, 0.01178476f, -0.03098944f, -0.04277368f, -0.05307405f, 0.04316042f, -0.05814502f, -0.04030435f, 
    0.04813099f, 0.03872304f, -0.00216151f, 0.00043553f, 0.04630371f, -0.03444645f, -0.06497867f, -0.02362496f, 
    -0.01516008f, 0.00405456f, -0.05470238f, -0.04948777f, 0.00873615f, 0.01548250f, -0.03818252f, -0.04404779f, 
    -0.03431630f, -0.01653262f, 0.01427266f, -0.04550707f, -0.03415903f, -0.01980863f, -0.01603609f, 0.04995228f, 
    -0.32635495f, -0.21503121f, -0.21874657f, -0.13550214f, -0.02510778f, -0.09551772f, 0.21440347f, 0.06061721f, 
    0.26644385f, -1.73223603f, -0.04745039f, -0.67680341f, 0.14967093f, -0.45263612f, -0.32491428f, -0.11759943f, 
    -0.32310265f, -0.13180898f, 0.00649324f, -0.31377798f, -0.00097461f, -0.02141937f, 0.05008953f, -0.20835580f, 
    0.04099777f, -0.01462351f, -0.03581283f, 0.15330915f, -0.04727129f, -0.00229443f, 0.04622073f, 0.07056140f, 
    -0.14744401f, -0.03676919f, 0.26874489f, 0.22043000f, -0.03273168f, -0.04490020f, -0.01514600f, -0.10402591f, 
    -0.20696102f, -0.07948153f, 0.19694938f, 0.11016985f, 0.12200522f, 0.17018168f, 0.01686187f, 0.04487963f, 
    0.03635883f, 0.11563750f, 0.07442233f, 0.38801467f, -0.01713837f, 0.12323435f, -0.16256349f, 0.06717239f, 
    -0.33068970f, -0.10702800f, -0.02483135f, -0.20225924f, 0.00572694f, -0.00355182f, -0.12893884f, 0.18421742f, 
    0.15159081f, 0.29704511f, 0.02463549f, 0.05229926f, 0.08521461f, -0.02130211f, 0.27119592f, 0.42530614f, 
    -0.18397366f, -0.49823439f, -0.15819283f, -0.11472157f, 0.04964954f, -0.33530933f, 0.00548888f, -0.04939822f, 
    0.23198870f, -0.03443948f, 0.74399012f, 0.75411147f, -0.04482561f, 0.10794780f, 0.02368456f, 0.11749490f, 
    0.12393558f, 0.21320680f, -0.35088041f, 0.46232381f, 0.23528783f, -0.12532108f, -0.02666178f, 0.00055463f, 
    -0.06914771f, -0.07468045f, 0.03222664f, 0.11306793f, 0.01100001f, -0.12613574f, -0.45782804f, -0.10665233f, 
    -0.10840535f, 0.30167183f, 0.22666471f, 0.24058118f, 0.10599967f, 0.44644287f, 0.44992083f, 0.24772434f, 
    -0.05503164f, 0.21709067f, 0.11725310f, 0.15841240f, 0.14990561f, 0.03608334f, -0.26969460f, -0.06963785f, 
    0.12149928f, 0.16634016f, -0.07821199f, 0.12833685f, -0.14615268f, -0.41648582f, -0.35891885f, -0.52229029f, 
    0.18220419f, -0.10704160f, 0.01170535f, -0.17183517f, 0.24215861f, 0.11420695f, 0.06885829f, 0.03002567f, 
    0.15205278f, -0.25429547f, -0.23619601f, 0.02522142f, -0.18784288f, 0.10189655f, 0.21662498f, 0.05043540f, 
    -0.15275618f, -0.24750219f, -0.12483765f, 0.17875341f, 0.07376114f, -0.08702329f, 0.21447857f, -0.17849165f, 
    -0.06496529f, -0.12089479f, -0.53722924f, -0.24598974f, -0.04067674f, -0.06710474f, 0.09484133f, -0.10423534f, 
    0.04516345f, -0.05495423f, -0.56229752f, 0.09878890f, -0.13825195f, -0.31438750f, -0.03470160f, -0.16068310f, 
    -0.27357736f, -0.15799582f, 0.02073195f, 0.00424751f, -0.23355390f, 0.05767040f, -0.07564209f, -0.03041022f, 
    -0.22273462f, 0.05591124f, 0.00259996f, -0.05412494f, 0.29242700f, 0.11870206f, -0.36691940f, -0.01130418f, 
    0.10317611f, -0.01389309f, 0.05720945f, -0.04563196f, -0.19130920f, -0.16061124f, -0.08981050f, -0.03163930f, 
    0.12437160f, 0.06775758f, -0.02491290f, 0.05779226f, -0.02200800f, 0.27537087f, -0.55746782f, -0.54798847f, 
    -0.08758913f, -0.10454428f, 0.16879670f, -0.09570245f, -0.14876105f, 0.01242123f, 0.13965185f, -0.18848878f, 
    0.50751376f, -0.25373209f, 0.01488143f, -0.14658287f, -0.03883922f, -0.11088363f, 0.00232543f, 0.06914631f, 
    0.12333903f, 0.26151818f, 0.36677593f, -0.19282496f, -0.29765129f, -0.17708348f, 0.15823610f, 0.14579231f, 
    0.19662532f, -1.18803596f, -0.49286035f, -0.36038390f, -0.14376186f, -0.13568777f, -0.09147847f, -0.07229134f, 
    0.07823748f, -0.13159804f, 0.18018380f, 0.18449922f, 0.20957862f, -0.04221721f, -0.08763561f, 0.34492096f, 
    0.16798678f, 0.06777222f, 0.19657016f, 0.56205899f, 0.14252467f, -0.66590768f, 0.02497689f, -0.21778046f, 
    0.03281752f, -0.02497232f, -0.06066258f, -0.08652595f, -0.30686870f, -0.21584940f, -0.33015302f, -0.00126401f, 
    -0.18730444f, -0.09476641f, -0.07990898f, -0.08031201f, -0.10563085f, -0.25714812f, 0.37670636f, -0.51607478f, 
    -0.19559695f, 0.09290547f, -0.00918233f, 0.29843134f, 0.10565441f, 0.11116266f, 0.09244223f, 0.08955460f, 
    -0.12051367f, -0.22135217f, 0.02385268f, 0.09564082f, 0.22558443f, 0.23210847f, 0.06659469f, 0.11199545f, 
    -0.09233336f, 0.07499546f, -0.19289899f, 0.06740100f, 0.09847478f, 0.10825305f, 0.06330000f, 0.08464520f, 
    -0.27499193f, 0.23650283f, -0.16907258f, 0.00056473f, 0.09994743f, 0.13483113f, 0.12634677f, 0.26633230f, 
    0.11278571f, 0.23530874f, -0.02843606f, -0.48963487f, 0.35485849f, 0.06900175f, 0.04807885f, 0.23542386f, 
    -0.18172868f, -0.20553155f, 0.49384615f, 0.13286197f, -0.27240205f, -0.21422070f, -0.01242059f, -0.08137251f, 
    -0.04580941f, 0.01705258f, -0.07579353f, 0.22770502f, 0.12615553f, -0.27566767f, 0.04921792f, 0.07610496f, 
    0.13948619f, 0.21750320f, 0.28219199f, -0.10041531f, 0.08276985f, 0.04883910f, 0.04656687f, 0.05544625f, 
    -0.00428066f, 0.13399851f, -0.11303332f, -0.13178678f, -0.19105235f, 0.06722233f, 0.04561210f, -0.27282643f, 
    0.00320603f, 0.17631616f, 0.02769433f, 0.23406187f, -0.11673842f, -0.15389884f, 0.11193234f, 0.18362172f, 
    0.29039013f, 0.28604320f, 0.25197473f, 0.01405009f, 0.07575200f, 0.08119007f, 0.00284457f, 0.04735721f, 
    -0.13132329f, -0.18807593f, -0.03386405f, 0.05759614f, 0.13587199f, 0.13256836f, 0.11712338f, -0.12382568f, 
    0.24464175f, -0.31255987f, 0.20022129f, 0.17750405f, 0.09202690f, 0.15129493f, 0.09170535f, 0.03268019f, 
    -0.25747073f, -0.06407803f, 0.03928804f, 0.32703540f, -0.07866668f, 0.11943233f, 0.22306828f, 0.03440166f, 
    0.22163020f, 0.31112465f, -0.00533576f, 0.07007749f, 0.24484414f, 0.05915581f, -0.00034289f, 0.25836977f, 
    -0.02033582f, 0.00824516f, 0.13364616f, -0.11436193f, 0.10595313f, 0.09812598f, 0.07791990f, 0.04511611f, 
    0.11124703f, -0.00643761f, -0.11011157f, -0.04174824f, 0.19326288f, -0.25319988f, 0.19026200f, -0.10918623f, 
    -0.07199904f, 0.08548315f, -0.03636225f, 0.07238460f, 0.15996476f, 0.13718899f, 0.06227266f, 0.01099227f, 
    -0.12964107f, -0.10621510f, 0.15847299f, 0.06095494f, 0.06718977f, -0.11810491f, 0.40620968f, 0.14317064f, 
    0.53804666f, 0.04366158f, -0.12825850f, -0.09554423f, 0.05836241f, 0.14408118f, 0.14051117f, 0.22689202f, 
    -0.17703457f, -0.08419089f, 0.27202147f, 0.21440864f, -0.13412128f, -0.01508815f, 0.19368905f, -0.28160390f, 
    0.18015112f, 0.12862268f, -0.08539419f, 0.03936082f, -0.03581723f, 0.13525796f, -0.00373579f, -0.08453286f, 
    -0.06120693f, 0.12470999f, 0.05001881f, 0.45139432f, 0.04399154f, -0.19569442f, 0.06779832f, 0.05999366f, 
    0.09432866f, 0.22074614f, 0.87825292f, -0.36664459f, -0.48577958f, 0.04276042f, 0.20140314f, 0.49640334f, 
    0.02241362f, -0.13755232f, 0.31229037f, -0.03963780f, -0.00399970f, 0.10492370f, 0.34449089f, 0.24823202f, 
    0.20263048f, 0.15991060f, -0.20310222f, -0.01998584f, -0.12401620f, 0.17059432f, 0.22879361f, -0.07699714f, 
    -0.04068303f, -0.05189972f, -0.07294676f, 0.10964913f, 0.00606733f, 0.11970975f, -0.02685933f, 0.22101754f, 
    0.03354005f, 0.01445152f, 0.00787001f, 0.07709075f, 0.04806811f, -0.01404104f, 0.04342608f, -0.07077089f, 
    -0.02781491f, 0.36710024f, -0.24694623f, 0.18129274f, 0.22684105f, 0.22218621f, 0.07529297f, 0.01327620f, 
    -0.34272090f, -0.09994122f, 0.14420493f, -0.21637022f, -0.10805395f, -0.11825527f, -0.05168898f, -0.19939408f, 
    0.12989420f, -0.00152797f, 0.07959832f, 0.08807824f, 0.09536998f, 0.03550744f, 0.03571611f, -0.40525514f, 
    -0.17547770f, -0.21646786f, 0.20026018f, 0.47031835f, -0.00980134f, 0.05058741f, 0.19442713f, 0.00926233f, 
    0.17388736f, 0.15105771f, 0.33484298f, 0.01596429f, 0.07052266f, 0.08370083f, 0.19183290f, 0.12925763f, 
    0.33780548f, -0.05187023f, -0.28951281f, -0.19746938f, 0.05606702f, 0.07215416f, 0.07956684f, 0.08599938f, 
    -0.53216255f, -0.35135692f, -0.39346802f, -0.21599095f, -0.06946558f, -0.13593340f, -0.08907571f, -0.00961585f, 
    -0.19303475f, -0.28211030f, -0.21333258f, -0.51757133f, -0.40313184f, -0.49243951f, 0.43212602f, 0.41535571f, 
    -0.15833092f, 0.06584788f, 0.19747362f, -0.16870531f, 0.29894647f, 0.39488828f, -0.17985126f, -0.10235991f, 
    0.00782877f, 0.08351903f, 0.06656920f, 0.17871101f, -0.05568948f, 0.26764825f, -0.02161362f, 0.17280786f, 
    -0.44159308f, -0.32710940f, 0.06358792f, 0.09787602f, 0.14988130f, 0.29573292f, 0.17322890f, 0.16211751f, 
    0.17931420f, 0.18337317f, 0.12897150f, -0.06296292f, 0.43256009f, -0.11042055f, 0.13343616f, 0.09346543f, 
    0.15896222f, 0.05248725f, -0.29875544f, -0.04661926f, -0.51680887f, -0.38160697f, 0.07487619f, -0.07325143f, 
    0.16566555f, -0.10582305f, -0.07668756f, -0.40646476f, -0.41313314f, -0.10470062f, 0.04417530f, 0.24718489f, 
    0.19856559f, 0.29022229f, 0.08710734f, -0.43038854f, 0.04601245f, -0.27409095f, 0.04637658f, -0.24029568f, 
    -0.00381409f, -0.07398096f, 0.11544105f, 0.04876846f, -0.15829499f, -0.74454743f, -0.49657285f, 0.10525517f, 
    -0.20166214f, 0.15260519f, -0.00304190f, 0.04087099f, 0.12597550f, -0.20225562f, -0.82892948f, 0.01462091f, 
    0.04443125f, -0.04585648f, 0.14058040f, -0.08784906f, 0.06071807f, -0.03550651f, -0.09092402f, 0.11506894f, 
    0.07803722f, -0.11433609f, 0.00041838f, -0.15172291f, 0.19373007f, -0.19392133f, -0.05686824f, 0.14417540f, 
    -0.12917466f, 0.52568686f, 0.22169617f, -0.11434671f, -0.20994353f, 0.30828947f, 0.18653640f, 0.22806683f, 
    -0.45172134f, -0.62848181f, -0.49308139f, -0.00594999f, -0.53747416f, -0.31949461f, 0.05696352f, 0.16832905f, 
    0.06695545f, 0.35010111f, -0.16750200f, 0.22742286f, 0.02551701f, 0.05194369f, 0.20239031f, 0.27075133f, 
    0.14564344f, -0.14385149f, 0.42667377f, 0.23119994f, 0.43211573f, 0.12922244f, 0.04774096f, -0.01163854f, 
    0.04259384f, 0.15589851f, 0.01219614f, 1.00819826f, -0.11751461f, -0.39114329f, -0.05514377f, -0.04813683f, 
    -0.09369280f, 0.13960035f, 0.01691141f, 0.12921712f, 0.08516373f, -0.12449384f, 0.06276068f, 0.04699952f, 
    -0.02145895f, 0.25786981f, 0.14031236f, -0.00700380f, -0.03391434f, -0.07593283f, -0.66239095f, -0.06451615f, 
    -0.04210602f, -0.22538151f, -0.31653878f, 0.01780602f, 0.08833028f, 0.05197601f, -0.36663333f, 0.16337900f, 
    0.21788284f, -0.08617033f, -0.19614851f, -0.09173510f, 0.03882729f, -0.13921347f, 0.09691432f, 0.30665866f, 
    -0.00722108f, 0.01017486f, -0.39277416f, 0.20474203f, 0.10891962f, 0.13629092f, 0.17288393f, -0.04194370f, 
    0.15298094f, -0.62477511f, -0.32288435f, -0.12411387f, 0.10774318f, -0.31911090f, 0.02110285f, -0.14720792f, 
    0.12207194f, 0.35566956f, 0.21880677f, 0.21571238f, 0.08459738f, 0.13810499f, 0.06812462f, 0.22793087f, 
    -0.03527545f, -0.05046860f, -1.40825450f, -0.58748889f, -0.45356065f, 0.01486622f, -0.11875398f, -0.13544011f, 
    0.33682269f, 0.09977292f, -0.04132124f, 0.00132780f, 0.01358387f, 0.19888054f, -0.18554299f, -0.06826580f, 
    -0.16276202f, -0.04994632f, -0.08756875f, -0.02908597f, -0.17488514f, -0.88304055f, -0.61123276f, -0.11017483f, 
    -0.31112123f, 0.22719069f, 0.02485398f, 0.18427816f, -0.15323283f, -0.60092533f, -0.20330967f, -0.26429695f, 
    0.04940051f, -0.02266299f, -0.03140490f, 0.12821437f, -0.06246691f, -0.14653786f, -0.01215266f, 0.15064953f, 
    -0.05569417f, 0.01499819f, 0.06097419f, -0.02383371f, -0.08420799f, -0.00733453f, -0.06501523f, 0.10078431f, 
    0.24905479f, 0.23303254f, 0.12883033f, 0.20265189f, 0.07266091f, -0.19096224f, -0.09212420f, 0.03168534f, 
    -0.49625599f, -1.03345680f, -0.38730913f, -0.23850210f, -0.04173449f, 0.26659060f, 0.11159617f, 0.12868086f, 
    0.20842886f, 0.51772201f, 0.45682722f, 0.36244264f, -0.09359664f, 0.15158662f, 0.10740934f, 0.18080370f, 
    0.00208849f, 0.20958766f, -0.27587512f, -0.82140243f, -0.11208187f, -0.15516128f, 0.23604946f, -0.03829147f, 
    0.13544881f, 0.12251753f, -0.21882680f, 0.39187053f, 0.21268152f, -0.20205435f, 0.04221825f, 0.05824339f, 
    0.21019694f, 0.07723761f, -0.28003034f, 0.03896468f, -0.16954941f, 0.56598526f, -0.08462487f, -0.14308135f, 
    0.24509321f, -0.13268074f, -0.15036118f, -0.12558290f, 0.11521988f, 0.96497124f, -0.12029271f, -0.22583883f, 
    -0.25629726f, 0.11060917f, -0.13487665f, 0.03055260f, 0.13776389f, -0.25234386f, 0.38719693f, -0.50586283f, 
    -0.23698337f, -0.08474823f, -0.17122936f, 0.05527517f, -0.05092168f, 0.08355068f, -0.08891893f, -0.18866143f, 
    0.08617456f, 0.06784572f, -0.11264614f, -0.17884731f, -0.06735743f, -0.29867911f, 0.07029564f, -0.09171074f, 
    -0.06055999f, 0.03340909f, 0.06865066f, -0.02804516f, -0.00937293f, 0.05092124f, -0.01837991f, -0.05219996f, 
    0.03166875f, -0.01124838f, -0.00987312f, -0.00484663f, 0.02630583f, -0.04981897f, 0.00853458f, -0.02136413f, 
    0.06596816f, -0.02797351f, 0.02408820f, 0.05299732f, -0.06942859f, -0.00550608f, 0.00559468f, -0.03120214f, 
    -0.03578711f, -0.07428940f, -0.07670156f, -0.03805593f, -0.00438718f, -0.04451538f, -0.04702884f, -0.01517755f, 
    -0.01850018f, -0.06751675f, -0.05550040f, -0.02395873f, -0.03383458f, 0.00423047f, -0.04872889f, -0.01712042f, 
    -0.01432101f, 0.01710109f, -0.06802838f, -0.05687653f, 0.05231396f, -0.02353066f, -0.06053247f, -0.03702833f, 
    -0.04929562f, -0.03386696f, 0.00268756f, -0.02888184f, 0.03120345f, -0.05469220f, -0.04126239f, -0.04818196f, 
    0.00820104f, 0.02910616f, -0.05616682f, 0.00594188f, 0.01989390f, -0.06949753f, -0.02145169f, 0.02013547f, 
    -0.03075523f, -0.02886725f, -0.01593514f, -0.04553282f, -0.04179855f, -0.03714192f, -0.03306073f, -0.07283759f, 
    0.02410724f, -0.02108949f, -0.06137008f, -0.00346599f, 0.00305476f, 0.02383790f, -0.04828461f, -0.00031616f, 
    0.01600309f, 0.03988781f, 0.02237137f, 0.00964715f, -0.02453582f, -0.04929716f, 0.00420772f, 0.00336836f, 
    -0.00917573f, 0.01567573f, -0.04522796f, -0.02915727f, -0.05963611f, -0.05895368f, -0.05387816f, -0.03545995f, 
    -0.07769810f, 0.02749997f, 0.01717934f, 0.03238346f, 0.00900210f, 0.03431718f, -0.03879999f, -0.00594764f, 
    0.01959889f, -0.06631803f, 0.02271864f, -0.01422876f, 0.05262814f, -0.02072177f, -0.04035501f, -0.05717663f, 
    -0.04054303f, -0.04394006f, -0.00648307f, -0.01963728f, 0.01906350f, -0.05436340f, -0.03275299f, 0.04310097f, 
    0.02836746f, 0.01251522f, -0.04706079f, -0.00396011f, -0.02269198f, -0.06912596f, -0.05856776f, 0.03761245f, 
    0.05625997f, -0.03339033f, -0.04756784f, 0.02812532f, -0.01767917f, -0.04257625f, 0.00204138f, 0.02894361f, 
    0.02803953f, -0.01295513f, 0.04319613f, -0.02872071f, 0.00200132f, 0.03855161f, 0.01360261f, 0.04348713f, 
    0.03838910f, -0.05371642f, -0.01428397f, -0.04675255f, 0.02143528f, -0.02386667f, -0.01511256f, -0.01858104f, 
    -0.04601668f, 0.00350526f, 0.04143600f, -0.06051541f, -0.04208105f, -0.04725400f, -0.00780170f, -0.04026861f, 
    -0.04580097f, -0.07713608f, 0.03029662f, 0.03078852f, -0.07503196f, -0.06692185f, -0.00701759f, -0.02201652f, 
    0.01376845f, 0.02044878f, 0.02811275f, -0.05450755f, 0.01250431f, -0.05891895f, -0.04989151f, -0.00750039f, 
    -0.05140050f, -0.06842021f, -0.04256017f, -0.07267618f, 0.00998581f, -0.03691437f, 0.00107413f, -0.06590492f, 
    0.03009488f, -0.01104195f, 0.00217562f, -0.05624158f, -0.06277657f, 0.03418804f, 0.02037708f, 0.02379703f, 
    -0.03840975f, 0.01803750f, -0.03459997f, -0.00436084f, -0.01613368f, 0.01185906f, -0.06821802f, -0.04872935f, 
    0.04744118f, 0.03359476f, -0.04116980f, -0.05872442f, 0.00302460f, 0.01455310f, -0.07153607f, -0.05705887f, 
    -0.04656498f, -0.05002711f, 0.02702106f, -0.01202134f, 0.04696220f, -0.04428947f, 0.01908576f, 0.03579931f, 
    -0.00902402f, -0.03662489f, -0.01017770f, -0.03894070f, -0.00986625f, 0.02165186f, 0.02683506f, 0.01680569f, 
    -0.00180870f, -0.01353778f, -0.02902552f, 0.03299770f, -0.01944068f, -0.02897954f, 0.03266853f, -0.02072842f, 
    0.02123042f, 0.02745204f, 0.03505626f, 0.01751860f, -0.02763897f, -0.01719177f, -0.00104987f, -0.03627431f, 
    -0.02304290f, 0.03095561f, 0.00440253f, 0.03619095f, 0.02919744f, -0.00302642f, -0.05354409f, -0.04735617f, 
    -0.06190463f, -0.04984664f, -0.06962806f, -0.05619984f, 0.02134390f, 0.02377840f, 0.04486929f, 0.00876400f, 
    0.00463149f, -0.00911983f, -0.02230067f, -0.06683017f, -0.02898202f, 0.03275655f, -0.05399288f, -0.03650409f, 
    -0.03137327f, -0.06286576f, 0.03185242f, -0.01982417f, -0.03281198f, -0.00808646f, 0.02589684f, -0.03417703f, 
    -0.02173507f, 0.04006524f, -0.05725228f, -0.05341114f, 0.01064184f, 0.02043543f, 0.02480198f, -0.03930447f, 
    -0.03788606f, -0.01642957f, -0.01637573f, 0.04180870f, -0.05688697f, -0.03462096f, 0.00853140f, 0.02709245f, 
    -0.05120887f, 0.03513075f, -0.03633620f, 0.04184556f, -0.03369109f, -0.05445033f, 0.00720211f, -0.05380337f, 
    -0.00748094f, 0.00364213f, 0.05087516f, 0.03691487f, 0.00934170f, -0.03077381f, -0.05597338f, 0.01087336f, 
    0.01783154f, 0.02824328f, -0.05773592f, -0.00904688f, -0.01552412f, -0.04542448f, 0.01329320f, -0.02704910f, 
    -0.04551624f, -0.02401174f, -0.05761416f, -0.03386643f, -0.05503752f, 0.03798128f, -0.04644351f, 0.02411374f, 
    0.02085822f, 0.04326058f, -0.03054152f, -0.02377662f, -0.03667036f, -0.02303517f, -0.00560681f, 0.01329151f, 
    -0.06370429f, -0.04400115f, 0.03165212f, -0.02134028f, -0.01827855f, -0.03985320f, -0.03177729f, -0.02113377f, 
    0.04263061f, -0.01681346f, -0.04127596f, 0.04510538f, -0.05622941f, -0.00268623f, 0.00083140f, -0.02201410f, 
    -0.02936504f, 0.01677524f, 0.00460852f, -0.00323223f, 0.04392891f, 0.00378606f, -0.00601661f, 0.00651753f, 
    -0.04906640f, 0.03173972f, 0.05163970f, 0.04245454f, -0.04247116f, 0.01787345f, -0.04392320f, -0.00572965f, 
    -0.02193874f, 0.05739452f, -0.01549655f, -0.01819506f, -0.03787683f, -0.04310118f, -0.03766333f, -0.04382847f, 
    -0.01605380f, -0.06181751f, -0.01027512f, -0.04865739f, 0.00716882f, 0.00643360f, -0.04948682f, -0.00374529f, 
    0.04668751f, 0.02043715f, -0.01745030f, 0.02881265f, 0.05192975f, -0.03250805f, 0.00346340f, -0.04644440f, 
    -0.01930306f, -0.04775921f, 0.04442594f, 0.02420761f, -0.04603336f, 0.05291504f, 0.01704507f, 0.03386102f, 
    -0.03070412f, 0.00404337f, -0.02036922f, 0.02621186f, 0.01779377f, -0.03600385f, -0.04430057f, -0.02670061f, 
    0.02228370f, -0.02492483f, -0.04894110f, 0.03108946f, 0.02028316f, -0.01080399f, 0.00507000f, -0.03523515f, 
    -0.05412021f, -0.04945375f, -0.02964956f, 0.04472474f, 0.04677452f, -0.05097628f, -0.02780494f, 0.04768497f, 
    0.04192002f, -0.00158513f, 0.03112995f, 0.00293466f, -0.00556161f, -0.01589748f, 0.00688139f, 0.01432789f, 
    -0.00111335f, -0.04747104f, -0.01087694f, -0.00494848f, 0.01982794f, -0.03795905f, -0.01644533f, -0.01330279f, 
    -0.06433508f, -0.04898807f, 0.01170664f, 0.00280204f, 0.00479093f, 0.05307943f, 0.02107737f, 0.03359810f, 
    -0.03162504f, 0.03950693f, 0.04903081f, 0.01827811f, 0.04037987f, -0.03139358f, 0.03699486f, -0.03185193f, 
    0.01876532f, -0.02736343f, -0.04260073f, -0.02880854f, -0.04223613f, 0.02785708f, 0.04367430f, -0.02497211f, 
    -0.06297932f, -0.00481024f, 0.04053160f, -0.03934768f, -0.06298874f, -0.05212118f, 0.04415257f, 0.03950046f, 
    0.00834056f, -0.00376511f, -0.03605707f, -0.04368899f, -0.06056215f, -0.04835682f, 0.05081346f, -0.01702708f, 
    0.01383967f, -0.00556577f, 0.04751458f, 0.00098936f, -0.00387388f, -0.02179127f, -0.06075794f, -0.00572372f, 
    -0.05529241f, -0.00707765f, 0.02992733f, 0.01551432f, 0.01423431f, 0.00881088f, -0.06102833f, -0.04239861f, 
    0.00320286f, 0.06048069f, 0.04073181f, 0.03003466f, -0.03259641f, -0.01802193f, -0.02129766f, 0.01205571f, 
    -0.05331929f, 0.04597748f, -0.06243017f, 0.01607397f, -0.00716676f, 0.02416330f, -0.04523813f, -0.06067792f, 
    -0.05359687f, -0.02896955f, -0.04500208f, 0.00017163f, 0.02531922f, -0.05045531f, 0.01122670f, -0.02784417f, 
    -0.03076600f, 0.05927392f, -0.03502621f, 0.03266259f, 0.01776419f, 0.02980261f, 0.01705062f, 0.02477900f, 
    -0.04797523f, -0.02186210f, -0.03599543f, -0.04144690f, -0.02471944f, 0.00898997f, 0.04067623f, 0.03959255f, 
    -0.03163798f, -0.02377549f, -0.06217277f, -0.00852979f, 0.01680270f, 0.02572765f, -0.00853207f, 0.05615542f, 
    0.04430498f, -0.00069178f, -0.02225918f, -0.05975177f, 0.04907040f, -0.00562057f, 0.03114609f, -0.00814981f, 
    0.01181531f, 0.02858626f, 0.03522069f, 0.03843535f, -0.01299412f, 0.02848792f, -0.01972044f, -0.05879496f, 
    -0.04126971f, -0.05283160f, 0.01507663f, 0.05218504f, 0.02326641f, 0.00270596f, -0.04642816f, 0.01273240f, 
    -0.03960003f, -0.02543763f, -0.01693378f, 0.02723940f, -0.00283037f, 0.00367974f, 0.03331712f, -0.05845024f, 
    -0.04107563f, 0.00159414f, -0.01992715f, -0.04428425f, -0.00672126f, -0.03113854f, 0.03000287f, 0.00137261f, 
    -0.26369143f, -0.39844397f, -0.11077198f, 0.00950207f, 0.10820679f, 0.12686504f, 0.19127497f, -0.05018118f, 
    -0.23277266f, 0.34807187f, 0.04620085f, -0.24326077f, 0.34092721f, 0.29626754f, -0.10998999f, 0.20374866f, 
    0.30083039f, 0.06868857f, -0.19275948f, -0.38708061f, -0.07325912f, 0.29940155f, 0.14792062f, 0.01329359f, 
    0.33251289f, 0.10965527f, -0.04542187f, -0.10592639f, -0.07378308f, -0.01793160f, -0.11339156f, 0.05108426f, 
    0.02721702f, 0.00464097f, -0.24313815f, -0.12558199f, 0.03861786f, 0.09415121f, -0.05130139f, -0.02623319f, 
    -0.11682492f, -0.02330568f, -0.04419401f, -0.00225835f, 0.00400512f, 0.03361697f, 0.09768909f, 0.05718892f, 
    0.22240497f, 0.12781896f, 0.00192027f, -0.10086852f, 0.29240039f, -0.00336822f, -0.05435909f, -0.31425929f, 
    -0.22475362f, 0.09774505f, 0.28968772f, 0.17857617f, 0.20688203f, 0.17178077f, -0.02074862f, 0.06763175f, 
    0.02519224f, -0.08476178f, -0.02200929f, -0.27531424f, 0.10561737f, 0.01015160f, -0.24093923f, -0.19772476f, 
    -0.06256916f, -0.08203302f, 0.24340488f, 0.01261177f, 0.04165449f, 0.03513896f, 0.42829645f, -0.23708156f, 
    -0.14265414f, 0.02754691f, -0.33515534f, -0.66806310f, -0.24533339f, -0.22729446f, 0.09525204f, -0.11976866f, 
    -0.06212796f, 0.08551569f, -0.22141710f, 0.20407596f, -0.06378008f, 0.00328682f, -0.11492488f, 0.00012933f, 
    0.04103868f, -0.05892742f, 0.00354975f, 0.22433028f, 0.10101856f, 0.11935738f, -0.18590981f, -0.18897828f, 
    0.05194429f, -0.27953967f, -0.17336227f, -0.03925720f, 0.05323487f, -0.22860304f, -0.83908916f, -0.25666463f, 
    -0.20650582f, -0.00005542f, -0.05616164f, 0.02614314f, 0.02412806f, 0.23668678f, -0.16514194f, -0.03001938f, 
    0.05439536f, -0.05417877f, -0.02322628f, 0.18260945f, 0.30820072f, 0.03251180f, -0.13260755f, -0.79693729f, 
    -0.31013894f, 0.12448747f, 0.01833834f, 0.12025428f, 0.02878765f, -0.00999601f, -0.32599944f, 0.17249556f, 
    -0.24495424f, -0.30243960f, 0.19379818f, 0.05396207f, -0.03971246f, 0.23674741f, 0.09055368f, 0.00501236f, 
    -0.04216567f, -0.00060966f, 0.03342055f, -0.03107373f, 0.15773414f, -0.18674235f, 0.12182486f, 0.30821854f, 
    0.14143053f, 0.03228929f, 0.01353084f, -0.07861023f, 0.14638990f, -0.01880474f, -0.02879340f, 0.10943533f, 
    -0.20107038f, -0.20726490f, -0.97962224f, 0.30378261f, 0.23720126f, 0.21802902f, 0.02980866f, 0.29617664f, 
    0.20408040f, -0.13188964f, -0.01539515f, -0.00884782f, -0.11300413f, -0.25370041f, 0.08818915f, 0.21877027f, 
    0.15823875f, 0.07242174f, 0.15106383f, 0.02636602f, 0.22795112f, 0.01762439f, 0.03433191f, -0.04856089f, 
    0.13081047f, 0.19639310f, 0.19575095f, 0.12713955f, 0.00336663f, -0.19407460f, -0.27043983f, 0.04366500f, 
    0.00106046f, 0.09937317f, 0.02897020f, -0.19953354f, -0.06849324f, -0.05388961f, 0.15056312f, -0.19199626f, 
    -0.40858975f, 0.26156476f, 0.13498177f, 0.09464327f, 0.29519424f, 0.00946133f, -0.11928401f, 0.02243081f, 
    0.08022264f, -0.31312034f, 0.02653454f, -0.18723010f, -0.04789104f, 0.10820274f, 0.02915175f, 0.10104875f, 
    0.10130049f, -0.06312244f, -0.28222254f, -0.11740921f, -0.11298585f, 0.00828408f, -0.01868463f, 0.08843973f, 
    -0.01539419f, 0.24924247f, 0.42707488f, -0.10769705f, -0.07900337f, 0.03328153f, -0.03523253f, -0.01295845f, 
    -0.00390660f, 0.00527625f, 0.08028318f, 0.17543140f, -0.06651966f, 0.06206789f, 0.07979123f, -0.13886389f, 
    -0.18633997f, -0.07778717f, -0.01520104f, 0.08727719f, 0.29821315f, 0.10075001f, 0.33810785f, 0.13386267f, 
    0.02220043f, 0.14276266f, 0.18966275f, 0.28374782f, 0.13580067f, 0.27712369f, 0.26846057f, 0.40183681f, 
    0.18639620f, -0.08225164f, 0.31061310f, 0.17112462f, 0.25398690f, 0.28967342f, -0.37530756f, -0.16715914f, 
    -0.16482486f, 0.12755874f, 0.15007634f, 0.06089674f, -0.13024780f, -0.32115132f, 0.18892059f, 0.16235434f, 
    0.08833551f, -0.14766304f, 0.14433044f, 0.03033645f, -0.06488737f, -0.01828263f, 0.07954756f, 0.11423859f, 
    0.11110848f, -0.16246477f, 0.00445266f, -0.12160928f, -0.08981778f, 0.11016974f, -0.22397344f, 0.04083071f, 
    -0.36567107f, -0.02186707f, 0.37413093f, -0.13937506f, 0.10588914f, 0.01321133f, -0.03579504f, 0.15075301f, 
    0.16736686f, -0.42985219f, -0.41212097f, 1.08858693f, 0.05849225f, -0.07566191f, -0.46147171f, 0.12873615f, 
    0.04919913f, -0.37351999f, 0.28249326f, 0.30509183f, -0.43615922f, 0.08949982f, 0.23265390f, -0.05087518f, 
    0.12217528f, 0.08021224f, 0.18312290f, -0.28062478f, 0.18613526f, 0.22964118f, -0.06979395f, -0.01898743f, 
    -0.16274861f, -0.03026324f, 0.16241242f, 0.15360977f, -0.07561067f, 0.12820703f, -0.08891579f, -0.07740861f, 
    0.00302448f, 0.02743318f, 0.20737892f, -0.16017066f, 0.10261682f, -0.09810381f, 0.14226685f, 0.00325835f, 
    0.02342420f, 0.04270455f, 0.27227515f, 0.01067680f, 0.17756070f, -0.16462339f, -0.10805602f, -0.68358761f, 
    0.33223259f, -0.14933158f, 0.04502637f, 0.29312184f, 0.06541064f, 0.09293246f, 0.06436973f, -0.01947373f, 
    -0.04373458f, -0.13228354f, 0.17542396f, -0.06360035f, -0.07355679f, -0.05019068f, 0.03248098f, 0.23035908f, 
    -0.19736275f, 0.42732742f, -0.00960800f, -0.21619143f, 0.01662485f, 0.36006862f, 0.22035584f, 0.09952665f, 
    -0.16914271f, -0.13098367f, -0.63868564f, -0.45835775f, 0.34347242f, 0.13748220f, 0.19395150f, -0.08646147f, 
    -0.11101629f, 0.01820591f, 0.11404499f, -0.34084865f, -0.47209054f, -0.20580238f, -0.10362615f, 0.03618195f, 
    0.03136356f, -0.00847925f, 0.00171115f, -0.11427122f, -0.05615948f, 0.12358892f, -0.08743757f, 0.02219006f, 
    -0.03986765f, -0.19220002f, -0.05368764f, -0.00952369f, 0.56352115f, -0.36716640f, -0.33154848f, -0.03913004f, 
    -0.08022302f, 0.01952015f, 0.12868577f, -0.05879501f, -0.08446626f, 0.12186896f, 0.41709819f, -0.09740625f, 
    0.06380226f, -0.14281881f, 0.00418438f, 0.06718963f, 0.05324822f, 0.10241921f, -0.50676793f, 0.10837165f, 
    -0.06418555f, -0.00317533f, -0.20191807f, -0.15029038f, 0.00773914f, 0.05059855f, 0.00414590f, -0.23913227f, 
    -0.07218303f, -0.15627843f, 0.05388821f, -0.05146232f, -0.01503400f, -0.17278482f, 0.17474249f, 0.17641768f, 
    0.26708433f, 0.22154573f, -0.07262234f, -0.09754433f, 0.03632826f, -0.06318422f, 0.03003348f, 0.07717896f, 
    -0.08095256f, 0.24136075f, -0.12524220f, -0.24323513f, -0.25861681f, 0.15935139f, -0.10334101f, 0.10851116f, 
    0.11911266f, -0.05493101f, 0.31510153f, -0.80665743f, -0.47875410f, 0.02014139f, 0.29339615f, 0.32046878f, 
    0.35522169f, 0.09390765f, -0.15920199f, -0.12676254f, -0.30429572f, 0.45532498f, -0.26590505f, 0.11448974f, 
    0.02601796f, 0.13849887f, 0.12415350f, 0.07550586f, -0.31455621f, 0.24352057f, 0.21573812f, -0.11362760f, 
    0.08071965f, 0.21890241f, 0.15922259f, -0.00594422f, 0.07369464f, -0.21922216f, 0.23986740f, -0.17182143f, 
    -0.17094886f, -0.02753127f, -0.18875320f, -0.05992560f, 0.06861348f, 0.07620738f, 0.33175689f, -0.17435524f, 
    0.05831031f, -0.18150990f, 0.07524349f, 0.36531317f, 0.06377329f, 0.11165491f, 0.09898004f, -0.19049528f, 
    -0.50884038f, -0.27146375f, -0.07450113f, 0.05856704f, -0.09400816f, -0.03781335f, -0.08305421f, -0.10541984f, 
    -0.10774615f, 0.02214816f, -0.29836586f, -0.07895769f, -0.00211444f, -0.09359600f, 0.29008511f, -0.06543943f, 
    0.09980902f, -0.06567374f, -0.21526717f, 0.40171295f, -0.48006138f, 0.04013664f, -0.40208820f, -0.02178313f, 
    0.02504804f, -0.12792754f, -0.24979250f, 0.10347509f, 0.12534873f, 0.02291601f, 0.09457777f, -0.07972749f, 
    0.06876651f, -0.02765122f, -0.08625853f, -0.35801235f, -0.29469988f, -0.16018917f, 0.03272336f, 0.15785162f, 
    0.07904778f, 0.12114680f, 0.02942223f, 0.11839079f, -0.32437545f, -0.45163640f, 0.12768783f, 0.01047183f, 
    0.00483585f, -0.29260519f, 0.30724487f, 0.09649707f, 0.15371832f, -0.52405423f, -0.67418343f, 0.24535935f, 
    -0.11603358f, 0.39032820f, 0.59480333f, -0.06344544f, 0.09241088f, 0.16237907f, -0.24712999f, 0.09007459f, 
    0.19429652f, 0.02526382f, 0.00682696f, 0.00018352f, 0.02550757f, 0.02349730f, 0.01641793f, -0.16924271f, 
    -0.06477582f, -0.25405276f, 0.03390272f, -0.03781388f, 0.10398052f, -0.13964655f, -0.04387097f, -0.15898347f, 
    0.04392581f, -0.09958739f, -0.01609358f, 0.08520661f, 0.19463708f, -0.01678488f, 0.23631723f, -0.13997382f, 
    -0.04472664f, -0.29975736f, -0.32456261f, -0.34331730f, -0.30679432f, -0.10666078f, 0.09380621f, -0.07360912f, 
    0.03590585f, 0.03617465f, 0.57300866f, -0.15209062f, -0.36734265f, -0.09748446f, -0.04337367f, -0.09820534f, 
    -0.06491840f, 0.30877715f, 0.00570901f, -0.14497416f, -0.00074630f, -0.13707508f, -0.16054621f, 0.16394480f, 
    -0.17206094f, -0.07952966f, -0.15600191f, -0.12508821f, -0.45376852f, -0.30218980f, -0.44082886f, 0.19196193f, 
    -0.14376357f, -0.37351036f, 0.17939560f, 0.03619476f, -0.05022256f, 0.25377536f, -0.14978671f, -0.23572110f, 
    0.02886266f, -0.13462476f, -0.08285826f, 0.03494433f, 0.27520716f, 0.05222139f, 0.02066943f, 0.10597166f, 
    0.16532801f, 0.12867457f, 0.19521505f, 0.19002654f, 0.06275325f, 0.12370902f, 0.01743284f, -0.05475389f, 
    0.23030469f, -0.19051647f, 0.25889227f, -0.14413705f, -0.12605233f, -0.07475533f, 0.04945337f, -0.28185338f, 
    0.45604575f, -0.16205671f, 0.08109555f, -0.33149049f, 0.48610818f, -0.40741247f, 0.01703570f, 0.17588916f, 
    0.10756541f, -0.01658911f, 0.32504544f, 0.40841922f, -0.04535184f, -0.01043480f, -0.07385209f, 0.02733985f, 
    0.06761178f, -0.11487681f, -0.34110814f, -0.00878999f, 0.18606673f, 0.05640992f, 0.01715451f, 0.06560255f, 
    0.23704189f, 0.04354373f, 0.02039385f, -0.14653297f, -0.34277752f, -0.14091145f, -0.02160559f, -0.00683859f, 
    0.03623849f, 0.15453401f, 0.01631586f, -0.07303412f, -0.26492995f, 0.17712998f, 0.07757007f, 0.02950130f, 
    -0.07662693f, 0.18980533f, 0.16093023f, -0.13745877f, 0.16769636f, -0.88786763f, -0.28432012f, 0.13611430f, 
    -0.19780043f, 0.00833184f, 0.01800208f, 0.14915027f, -0.07504300f, 0.07735872f, 0.06177114f, -0.29783794f, 
    0.17710847f, -0.10734064f, -0.26489392f, 0.08070753f, 0.00061839f, 0.02118594f, 0.04723733f, -0.22987857f, 
    0.37583801f, -0.19408835f, 0.08290070f, 0.03049082f, -0.16382152f, 0.23201168f, 0.05307604f, -0.10688247f, 
    -0.77799594f, -0.36998674f, -0.02949368f, 0.10803109f, -0.06284817f, -0.15606840f, -0.05762547f, 0.00816665f, 
    0.12728640f, -0.32559752f, -0.06184460f, 0.29421932f, 0.08272496f, -0.04957298f, 0.01321635f, 0.27299127f, 
    0.16772154f, -0.09271545f, 0.35783839f, -0.13933046f, -0.24356781f, -0.08252250f, -0.11021510f, -0.29315624f, 
    -0.08281385f, -0.19848937f, -0.01777191f, 0.03579456f, -0.05151701f, 0.28460056f, -0.13800333f, 0.18422046f, 
    -0.06667768f, -0.15476246f, -0.14798898f, 0.03764410f, 0.28174186f, -0.04182391f, 0.02899367f, -0.16589725f, 
    -0.01830178f, 0.28485027f, 0.13913089f, 0.21674351f, -0.00237589f, 0.01063930f, -0.26788411f, 0.30297381f, 
    -0.08252093f, -0.15084517f, -0.07779551f, -0.19430459f, -0.09829994f, -0.06014759f, 0.44614843f, -0.15326250f, 
    -0.33288544f, 0.07240319f, 0.16305143f, -0.03997760f, 0.05695591f, -0.02116452f, -0.00936484f, -0.04236863f, 
    -0.13598780f, 0.16541079f, 0.02219466f, 0.16694944f, 0.15373479f, 0.10315671f, 0.03396254f, 0.29455075f, 
    -0.34014660f, -0.22957951f, -0.16440631f, 0.22134362f, 0.04935184f, 0.21157657f, 0.09046705f, 0.15907606f, 
    0.14892009f, -0.39063838f, -0.12356372f, 0.18334264f, -0.10476854f, -0.07624838f, -0.13681871f, 0.14520210f, 
    -0.05036115f, -0.23046528f, -0.23155890f, -0.38128546f, -0.61148757f, 0.03794379f, 0.01415734f, -0.16329601f, 
    0.18028748f, 0.33574834f, -0.02359541f, -0.19284178f, 0.02771043f, 0.10714439f, -0.15816861f, -0.03279034f, 
    0.34756812f, -0.07582607f, 0.06332937f, 0.14615540f, 0.16839896f, -0.07910180f, -0.37937132f, -0.11520099f, 
    0.03199961f, -0.09512410f, -0.24747956f, 0.03081441f, 0.19239336f, 0.19436923f, 0.40234488f, 0.51614642f, 
    -0.00463236f, -0.01526423f, -0.17417544f, 0.16206233f, 0.09302806f, 0.03482316f, 0.40549856f, -0.43342209f, 
    -0.30389112f, -0.05514956f, 0.27545944f, 0.04547351f, 0.11133510f, -0.02550372f, 0.07329314f, 0.42807937f, 
    0.16993293f, -0.46850070f, 0.20922334f, -0.06463192f, 0.00457334f, -0.18662556f, -0.10861643f, -0.13672793f, 
    -0.13547549f, -0.22799549f, -0.07062493f, 0.00980149f, 0.08188699f, 0.14404747f, -0.16989657f, 0.15353653f, 
    -0.11691740f, -0.16101772f, 0.55902529f, -0.44381112f, -0.05754852f, 0.09268626f, -0.12627341f, -0.01198652f, 
    0.29779395f, 0.02829543f, -0.06125822f, -0.23351425f, -0.10285696f, -0.03950452f, 0.09339245f, -0.10223968f, 
    -0.08404729f, 0.18630292f, 0.34779236f, -0.36268407f, -0.11833701f, 0.02160678f, -0.14433800f, 0.03901074f, 
    -0.05659445f, -0.09572234f, -0.03080069f, -0.01036037f, -0.07984700f, -0.04238709f, -0.06725119f, -0.11396751f, 
    -0.07123882f, 0.04755323f, -0.12404816f, 0.09491370f, 0.16810890f, -0.09139020f, 0.05967113f, 0.00601132f, 
    0.02429001f, 0.15070623f, 0.16766350f, -0.19262445f, -0.01434749f, 0.01551930f, 0.16055515f, 0.30971688f, 
    -0.08007007f, 0.04524704f, 0.15529995f, 0.15674843f, 0.17163129f, 0.15883717f, -0.10775706f, -0.34187344f, 
    -0.01117826f, -0.00329279f, 0.01993430f, -0.06205946f, -0.33943704f, 0.16194332f, -0.07917326f, -0.04962451f, 
    -0.10248311f, -0.37004387f, 0.02932340f, -0.23119369f, 0.10264321f, 0.05480768f, -0.15486486f, -0.40291417f, 
    0.14059408f, -0.26766637f, -0.04086233f, 0.01121128f, -0.04546987f, -0.23398474f, -0.09744084f, 0.06321087f, 
    -0.05295586f, -0.00969768f, 0.04488219f, 0.13017555f, 0.34173372f, -0.02918383f, -0.07143179f, 0.10729185f, 
    0.00163388f, 0.03095769f, 0.11514227f, -0.04211849f, 0.02934234f, 0.07912947f, 0.07271659f, -0.00022512f, 
    -0.07581954f, 0.17131269f, 0.07827409f, -0.10845755f, 0.23163331f, 0.17673641f, 0.02905639f, -0.10124526f, 
    -0.18223347f, -0.12335294f, -0.02402612f, 0.15151550f, -0.05500746f, -0.20210238f, -0.24241780f, -0.14573421f, 
    -0.02948601f, -0.05029860f, -0.09810621f, -0.12743202f, 0.10333566f, 0.28985760f, 0.63429779f, -0.08777232f, 
    -0.34684509f, -0.00202568f, 0.04190303f, 0.03115912f, 0.05925668f, -0.11465134f, -0.11543859f, -0.06090243f, 
    0.05134568f, -0.26338652f, 0.02550401f, 0.07608914f, 0.17777069f, -0.11908942f, -0.32430395f, 0.15485889f, 
    -0.28313121f, -0.07404742f, -0.19647972f, 0.05159947f, -0.00456724f, -0.00429418f, 0.03874645f, 0.22945631f, 
    -0.09848235f, 0.08620274f, 0.07692910f, 0.06949149f, 0.03110464f, 0.07581002f, 0.13011591f, 0.12009583f, 
    -0.01436386f, 0.13939355f, -0.62068403f, -0.09536240f, -0.02667319f, 0.00720132f, 0.20130065f, 0.23644300f, 
    -0.30069113f, -0.04157311f, -0.07269096f, 0.13316588f, 0.23540118f, 0.25562388f, -0.06971326f, 0.07691927f, 
    0.09388204f, 0.17183989f, 0.26083332f, 0.08667800f, -0.38781634f, -0.25429690f, -0.44649416f, -0.23648207f, 
    -0.01436850f, 0.17559265f, -0.04441345f, 0.08306705f, 0.06901797f, -0.02427772f, -0.43337533f, -0.03413905f, 
    -0.10598309f, 0.02293047f, -0.02771038f, 0.22615561f, -0.02917311f, 0.02604291f, 0.24017009f, -0.00313316f, 
    -0.56498712f, -0.00793612f, 0.10517959f, 0.09454007f, -0.17969407f, 0.17770058f, -0.08167346f, 0.26135787f, 
    0.11508955f, 0.14603555f, -0.24416901f, -0.08426546f, -0.02335029f, 0.00457546f, 0.21839681f, 0.05211966f, 
    0.00606333f, -0.00202103f, 0.05189500f, -0.02774420f, -0.15079071f, -0.18404818f, -0.00801281f, 0.06692871f, 
    0.08335012f, 0.30126241f, 0.40894148f, 0.20626318f, -0.02579780f, -0.07356455f, 0.08908048f, -0.00318104f, 
    0.02703381f, 0.10236942f, -0.15629321f, 0.12409706f, 0.10255428f, -0.06929886f, -0.08115146f, 0.05206272f, 
    -0.16771765f, -0.23287085f, -0.01939319f, -0.23372748f, 0.07952069f, -0.21440154f, 0.13822027f, 0.17799313f, 
    0.15145281f, -0.04872091f, 0.24245508f, 0.18942124f, -0.14655243f, 0.38808814f, -0.15725991f, 0.16362655f, 
    0.36871657f, 0.07735828f, 0.15015659f, 0.30944121f, 0.21217708f, -0.33217114f, -0.48281676f, -0.04393088f, 
    0.07874133f, -0.02641268f, 0.30809069f, -0.05747624f, -0.02224147f, -0.14798941f, -0.26807460f, 0.11478376f, 
    -0.02633646f, -0.17844442f, 0.22472245f, 0.03871581f, 0.20817591f, 0.09936163f, -0.15875192f, -0.18498053f, 
    0.11483917f, 0.19057716f, -0.14566335f, -0.06231936f, -0.22608842f, 0.07336771f, -0.01268857f, -0.42760214f, 
    0.47936863f, -0.18676302f, 0.04498976f, -0.14938569f, 0.21838479f, 0.01218814f, -0.20495151f, -0.00368603f, 
    -0.08156386f, -0.62581480f, -1.18034780f, 0.68989056f, 0.06718417f, -0.04781228f, -0.08937519f, -0.07362636f, 
    -0.05954659f, -0.05975778f, -0.25494173f, -0.15225217f, -0.16059732f, 0.19733265f, -0.04398743f, 0.02437696f, 
    0.04251638f, 0.04369954f, -0.16943449f, -0.26246169f, 0.06347842f, 0.28385702f, -0.04705825f, -0.11236681f, 
    -0.04410611f, -0.07468846f, -0.20289242f, 0.11288094f, 0.05444024f, -0.01346938f, -0.07102706f, 0.11556821f, 
    -0.04639608f, -0.11338659f, 0.18663916f, 0.07242555f, 0.21527906f, 0.07199244f, 0.13461961f, -0.04807297f, 
    0.17596552f, -0.10220727f, 0.11281098f, -0.08611611f, 0.15546411f, 0.05941312f, 0.10627622f, -0.01503517f, 
    0.15733752f, -0.00302650f, 0.08756641f, 0.25310925f, -0.01767757f, 0.10354400f, -0.08694873f, -0.42328873f, 
    -0.08605105f, -0.06932452f, -0.05975109f, 0.05514722f, -0.09905303f, 0.02931033f, 0.01711380f, 0.00452962f, 
    0.32099089f, 0.00283157f, -0.13779871f, 0.03362923f, 0.07608043f, 0.20958588f, -0.01563164f, -0.33541247f, 
    -0.03305841f, 0.03411263f, -0.40305787f, -0.14623916f, -0.04138264f, -0.01608465f, 0.10549355f, 0.01226830f, 
    0.14014146f, 0.14344546f, -0.10855579f, 0.01858366f, 0.40382966f, -0.13996823f, -0.14897844f, -0.06146153f, 
    0.07700866f, 0.13618280f, 0.01091785f, -0.02328695f, -0.17013441f, -0.07021596f, -0.09829094f, -0.07951611f, 
    -0.14456628f, 0.21579590f, -0.03881700f, 0.18918128f, -0.43172872f, 0.15761589f, -0.59175617f, -0.10690602f, 
    0.01070848f, -0.03111611f, 0.05586258f, -0.07104348f, 0.00661920f, 0.49327463f, 0.25495014f, 0.00199586f, 
    0.05386324f, 0.11880237f, -0.08558962f, 0.07534557f, -0.09456465f, 0.01765246f, 0.49653068f, 0.20814992f, 
    -0.33151862f, -0.15077370f, -0.22781610f, -0.13137090f, 0.12286747f, -0.01765910f, 0.09192000f, -0.26880729f, 
    -0.11459818f, 0.16400623f, 0.17383093f, -0.22711451f, 0.16139963f, 0.02301936f, 0.16963784f, -0.16045672f, 
    0.16813119f, 0.21036544f, 0.01780193f, 0.25824425f, 0.05550895f, -0.09207203f, 0.07830587f, -0.01940937f, 
    -0.08144461f, -0.25482541f, -0.02985960f, 0.36907831f, -0.23309307f, 0.06627993f, 0.02092547f, 0.11636531f, 
    0.05665804f, 0.08690496f, -1.61610973f, 0.05201944f, -0.11295908f, -0.02753761f, -0.15391940f, 0.17347959f, 
    0.25868872f, -0.05222762f, -0.09204353f, 0.04607774f, -0.05517615f, 0.29753762f, -0.24751955f, 0.15686826f, 
    0.07480834f, -0.01013604f, -0.07128377f, 0.17491530f, 0.53242803f, -0.13269655f, -0.34892976f, 0.07836948f, 
    0.05355723f, 0.10709611f, 0.33340105f, 0.11740076f, -0.03278751f, 0.44918281f, 0.13536435f, 0.09241176f, 
    0.00006619f, -0.00430004f, -0.08552933f, -0.02216938f, 0.04996613f, 0.05110828f, 0.65129513f, -0.19164622f, 
    0.19645526f, 0.20735723f, 0.08640780f, 0.26734227f, 0.19781236f, 0.01559436f, -0.09903396f, -0.04461040f, 
    -0.12782405f, 0.10013528f, -0.17703846f, -0.01832480f, -0.07267103f, -0.00914448f, -0.02915139f, -0.16899329f, 
    -0.11387002f, 0.02639242f, -0.13598731f, -0.04322949f, 0.01049346f, -0.11964086f, 0.00954087f, 0.08458209f, 
    0.08277598f, 0.03046249f, 0.19891901f, 0.42230129f, -0.33571166f, -0.20742744f, -0.12628041f, 0.09379662f, 
    0.04022345f, -0.06826844f, -0.18888600f, 0.07754087f, 0.25788417f, 0.04552614f, 0.03107249f, -0.03121412f, 
    -0.12815633f, -0.30192348f, 0.14957914f, -0.02278941f, -0.03227575f, -0.05038128f, 0.30786109f, -0.17346692f, 
    -0.00594587f, 0.03373572f, 0.16988489f, -0.20661956f, 0.10015826f, -0.14273600f, 0.47917956f, -0.34763885f, 
    0.15879083f, -0.13459465f, 0.01760145f, -0.05207513f, 0.04269660f, 0.16690280f, -0.45227861f, -0.30763307f, 
    0.04203634f, -0.14114787f, 0.31109145f, -0.03070132f, -0.08068518f, -0.04059094f, 0.26996431f, -0.15079288f, 
    -0.18108210f, 0.07000296f, -0.00525742f, -0.01766898f, 0.15506060f, -0.09510551f, 0.20526940f, -0.31571785f, 
    0.38721761f, -0.51584488f, -0.01532806f, -0.06323043f, -0.08533427f, 0.13581601f, -0.35361135f, 0.06293859f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.39721963f, -0.06393434f, -0.02932598f, 0.01734676f, -0.02948693f, 0.04153585f, 0.13956684f, -0.11980605f, 
    -0.01525498f, -0.02672719f, 0.03525707f, 0.36953712f, -0.19600776f, -0.00761044f, 0.02913955f, -0.11744978f, 
    0.18109567f, -0.06129451f, -0.04398175f, 0.01765674f, -0.06363799f, -0.00346140f, 0.33951062f, -0.00551115f, 
    0.00154541f, -0.04415065f, -0.04980108f, 0.23289715f, 0.09319682f, 0.34756550f, 0.02170012f, 0.21133834f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.33204705f, -0.08278827f, 0.00388078f, 0.03210867f, -0.00163837f, -0.16111274f, 0.13327582f, 0.53106612f, 
    0.11293248f, -0.16604640f, -0.13770288f, 0.05653540f, -0.12264653f, 0.14815971f, -0.32349375f, 0.41057706f, 
    -0.13771950f, 0.13231687f, 0.12014572f, 0.38537541f, -0.07782407f, 0.04793331f, 0.09189735f, -0.25482520f, 
    0.64091450f, 0.16199504f, 0.12598544f, 0.03054702f, -0.46330857f, -1.08592498f, 0.17746891f, -0.22045165f, 
    0.09370378f, -0.12892941f, -0.21708012f, -0.14170769f, -0.17742436f, -0.02743441f, 0.24002400f, 0.24973272f, 
    -0.12978227f, 0.08909810f, -0.16233815f, 0.24277326f, -0.29127714f, 0.11004503f, -0.17209579f, -0.38519812f, 
    0.16731119f, 0.12645902f, 0.08169297f, 0.01449912f, -0.15656085f, -0.14041802f, -0.43393376f, -0.35129580f, 
    0.66829097f, -0.08645672f, 0.07288989f, 0.25396907f, 0.00537933f, 0.33557862f, 0.13985921f, 0.07808384f, 
    0.22943448f, 0.15054569f, -0.91354972f, 0.12627767f, -0.03612083f, -0.04383416f, -0.00298294f, -0.83531862f, 
    0.06755823f, 0.03324974f, 0.14732894f, 0.10718260f, 0.26187378f, -0.20306270f, 0.10346633f, 0.07404564f, 
    0.15044205f, 0.10054102f, 0.02727163f, -0.09852030f, 0.08895407f, 0.00672753f, 0.39381582f, 0.22734469f, 
    -0.17986031f, -0.12780772f, -0.08960444f, -0.38473555f, -0.62976664f, 0.62820810f, -0.34425977f, -0.45363310f, 
    -0.26537913f, -0.11720108f, 0.20946352f, 0.05205471f, 0.41857374f, 0.13683324f, -0.10820343f, 0.22016725f, 
    -0.03867606f, -0.06679018f, 0.08634965f, -0.72690707f, 0.23670818f, 0.29576159f, -0.40484545f, 0.29454282f, 
    0.03974983f, -0.01820377f, 0.03890283f, -0.57271737f, -0.00796528f, 0.06499080f, -0.06670211f, 0.24283187f, 
    -0.10413951f, -0.01989697f, 0.09039032f, 0.07997514f, 0.05019663f, 0.26102528f, -0.48870996f, -1.06252551f, 
    -0.52804428f, 0.11446132f, 0.62413675f, 0.07650859f, -0.11188203f, 0.02482879f, 0.11276238f, -0.29279658f, 
    0.00269027f, -0.05146841f, -0.02039823f, 0.03535764f, 0.49490651f, 0.08870997f, -0.02669152f, -0.10425192f, 
    -0.09711803f, 0.07105676f, -0.07419778f, 0.15957034f, 0.01051158f, 0.17130348f, 0.18095441f, -0.01614540f, 
    0.13595015f, -0.08616405f, 0.00343938f, -0.19367225f, -0.12260741f, 0.03175177f, 0.32621598f, 0.27655086f, 
    0.09572982f, -0.10182806f, -0.26173753f, -0.04378385f, 0.09551888f, -0.01206029f, -0.21238729f, -0.05229281f, 
    -0.08935615f, 0.12449818f, -0.07887825f, -0.34584409f, -0.04384187f, -0.30644318f, 0.31017271f, 0.31583580f, 
    -0.12291979f, -0.14433727f, 0.09936474f, 0.43745610f, -0.11916856f, -0.07547194f, -0.25791326f, -0.17574139f, 
    0.06094789f, 0.00487696f, 0.05825091f, 0.35860029f, -0.49282014f, 0.37390453f, 0.00512262f, 0.75363863f, 
    0.53337175f, 0.13233480f, -0.51873946f, -0.09891739f, -0.40189263f, -0.04228831f, -0.25490230f, -0.05665201f, 
    -0.08221190f, -0.04529451f, -0.16779335f, 0.77932280f, 0.03819402f, -0.18631569f, 0.08908362f, -0.06386042f, 
    -0.33455265f, 0.16919294f, -0.15343030f, -0.07735463f, -0.03365562f, -0.04348856f, 0.35912180f, 0.23398626f, 
    -0.90856928f, -0.13212381f, 0.10687921f, -0.03349765f, -0.29668868f, -0.89557451f, -0.56482422f, -0.24971458f, 
    0.07845615f, -0.14971125f, -0.00870079f, 0.00892372f, -0.19337282f, 0.10638558f, 0.49511588f, 0.10659352f, 
    -0.00788115f, -0.00033913f, -0.08760400f, -0.60684276f, 0.49201810f, 0.28756136f, -0.18199857f, -0.29634702f, 
    -0.16072632f, 0.13981649f, -0.13830446f, 0.01546558f, -0.01429261f, 0.13572197f, -0.22621328f, 0.10288314f, 
    -0.13549933f, 0.08438902f, 0.08720082f, 0.07360620f, 0.38421714f, -0.42442548f, 0.02974709f, -0.09551250f, 
    -0.03466630f, 0.02379450f, -0.62806034f, -0.11166019f, -0.39594316f, 0.13714932f, -0.50684202f, -0.18146734f, 
    -0.02031686f, 0.07411967f, -0.14905839f, -0.06133495f, -0.78391540f, 0.09125862f, -0.10098308f, 0.11072755f, 
    0.46360114f, 0.15165435f, 0.15547827f, 0.05687783f, -0.05612720f, 0.13234901f, -0.51917678f, -0.04217902f, 
    -0.50459576f, -0.07611370f, 0.04354620f, 0.24679965f, 0.69541663f, 0.02465970f, 0.66322041f, -0.37819883f, 
    -0.05276339f, 0.03233062f, 0.40246695f, 0.02419707f, 0.07595830f, -0.00911332f, -0.24681561f, -0.08869214f, 
    -0.11234485f, -0.09370024f, -0.03738895f, -0.17808782f, -0.46673524f, 0.35109970f, -0.44068462f, -0.19548039f, 
    -0.38451406f, -0.14343196f, 0.16312347f, -0.62366515f, -0.12004407f, -0.07535920f, 0.74157262f, 0.42860425f, 
    0.01104300f, 0.03337483f, 0.15181237f, 0.19084807f, -0.29477859f, -0.27369988f, 0.16565616f, 0.40312341f, 
    0.49274173f, -0.09902604f, -0.01164178f, 0.11053934f, 0.57486248f, 0.07541405f, -0.05708328f, -0.43580139f, 
    0.10188512f, 0.10873972f, -0.03542632f, -0.12801638f, 0.25305757f, -0.78606266f, -0.46258935f, 0.48009259f, 
    0.24487604f, -0.08760607f, -0.12409949f, 0.39036286f, -0.06897207f, -0.07401196f, -0.33055532f, -0.52010065f, 
    -0.61676931f, 0.07063182f, 0.00710377f, -0.10843227f, -0.02611125f, -0.07094352f, 0.20604658f, -0.58946288f, 
    0.22415812f, -0.03455727f, 0.15629706f, 0.13284260f, 0.28805143f, 0.06781205f, -0.66530246f, 0.42761895f, 
    0.14547493f, 0.10809555f, 0.03875960f, 0.08020394f, -0.52334112f, -0.21065943f, 0.63992476f, -0.25003168f, 
    -0.15868580f, 0.03037924f, -0.06873541f, -0.85780799f, 0.04790231f, -0.17277020f, -0.80591136f, 0.20163694f, 
    -0.06770846f, -0.02730725f, -0.06919645f, 0.03443171f, 0.50822520f, -0.49628100f, -0.35446766f, 0.50752443f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13048074f, 0.20063730f, 0.30676040f, -0.10588408f, -0.33761674f, -0.10261149f, 0.07739270f, -0.22572328f, 
    0.26757026f, 0.17057054f, 0.10834029f, 0.01670043f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
