#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.20192647f, 0.13295078f, -0.15108649f, 0.21855727f, 0.19625123f, -0.63369316f, -0.68710047f, 0.18624271f, 
    0.69690263f, 1.51397049f, -0.56831640f, -0.21294980f, -0.44877335f, -0.38352361f, 0.12451009f, 0.12487969f, 
    -0.22907265f, 0.46559632f, 0.89038283f, -0.42548582f, 0.59782356f, 0.65529847f, 0.60635734f, 0.60249966f, 
    -0.10500577f, -0.48522472f, -0.17243217f, 0.92797530f, 1.13348353f, 0.54868102f, 0.35150579f, 0.25048167f, 
    0.67382067f, -0.12311547f, -0.28564283f, 0.20033906f, 0.99337429f, 0.16810437f, 1.01204956f, 0.85402369f, 
    -0.69406933f, -0.13065846f, -0.44116265f, -0.13125892f, -0.31259760f, -0.77303904f, -0.18991725f, -0.03375566f, 
    -0.80477339f, -0.71427065f, -0.64910394f, 0.69349766f, -0.20653947f, 0.21384479f, 1.39915705f, 0.52872181f, 
    -0.44925272f, 0.35268980f, 0.65362370f, -0.39778066f, 0.50032729f, 0.10248079f, -0.42784199f, -0.02299283f, 
    1.27977836f, -0.27098629f, -1.08223355f, 0.80064511f, 0.59549499f, 0.48792186f, 0.48350319f, -0.55146015f, 
    0.07222922f, -1.30864155f, -0.65844512f, 0.04169547f, 1.16147912f, -0.66963106f, -0.61175060f, 0.34238350f, 
    -0.21693440f, 0.01485199f, 0.09623775f, -0.96210164f, -0.24787797f, 0.98590702f, -0.71250910f, 0.50896198f, 
    0.28568301f, -0.40470639f, -0.70527780f, 0.44856456f, 0.97042328f, 0.62174189f, 0.74843276f, 0.92087489f, 
    -0.48914674f, -0.40982190f, 0.09574702f, -0.79413843f, -0.73401386f, -0.96099681f, -0.85219342f, -0.35368580f, 
    0.07419915f, 0.04727948f, -0.32632989f, 0.40153062f, -0.94859016f, -0.90633070f, -0.46044680f, 0.93055660f, 
    0.30046767f, 0.76164627f, -0.04142758f, 0.10246219f, 0.32440576f, -0.78573924f, -0.82714087f, 0.29659966f, 
    -1.04579723f, -0.52273184f, -0.81038600f, -0.09700379f, 0.21173477f, 0.04074118f, 1.11232924f, 1.15996385f, 
    -0.10048068f, -0.48937577f, 0.35944068f, 0.67857403f, -0.39878964f, -0.09935277f, 0.41675922f, 0.54503739f, 
    -1.38861394f, -0.06465357f, -0.67068589f, 0.81716478f, 0.77768117f, 0.56030738f, 0.75249332f, -0.29166642f, 
    -0.14670062f, 0.76457685f, 0.93773735f, -1.54718876f, 0.18339705f, -0.22466223f, 0.38203576f, -0.22236916f, 
    -0.24106297f, 0.95608580f, 0.29531583f, 0.68714148f, -1.00738251f, 0.35573074f, -0.78333068f, -0.11520891f, 
    -0.22427945f, -0.31620225f, 1.20066738f, 0.89924848f, 0.87937993f, -0.92259741f, -1.07181132f, -0.15164430f, 
    0.61000997f, 0.12742668f, -0.00559001f, -0.41801795f, -0.79538685f, -0.69808954f, -0.83942908f, -0.09413974f, 
    0.76446557f, 0.39910507f, -0.10188048f, 0.70868146f, 0.21270745f, 0.05719925f, 0.70774215f, 0.92799425f, 
    -1.02569747f, 0.54260939f, -0.01355389f, 0.18306944f, -0.31648716f, -0.08876574f, -1.13714015f, -0.37113616f, 
    -0.22215028f, -1.06431031f, -0.52509391f, -0.33415312f, -0.00888170f, -0.41874498f, 0.79891205f, -0.75526708f, 
    -1.07018578f, -0.69176412f, -0.52190030f, -0.31245238f, -0.59317845f, -0.04076054f, -0.31400388f, -0.19712110f, 
    1.74351943f, -0.95730847f, 0.78666997f, 0.31978539f, -0.47014749f, 0.30149066f, -0.17059529f, -0.02762199f, 
    0.20343585f, 0.48033878f, -1.00958622f, -0.65760601f, -0.41382223f, -0.75449181f, 0.75977355f, 0.17707305f, 
    0.26192063f, -0.88588744f, -1.28937805f, -0.77048028f, -0.04538567f, 0.88720256f, 0.74055922f, -0.08998353f, 
    -0.39706719f, -0.31715685f, 1.07858467f, -0.43273747f, 1.00817657f, 0.12122015f, -0.18738656f, 0.39655456f, 
    0.55582529f, 0.41419435f, -0.31716347f, 0.28196087f, -0.48671615f, -0.78540498f, 1.17109883f, -0.47757688f, 
    -0.97767067f, -0.24108326f, -0.03768192f, 0.20144045f, -1.34380412f, 1.11114287f, 0.92505765f, -0.56655294f, 
    0.54115361f, 0.32573569f, -0.47679996f, 0.42080343f, 0.09175316f, -1.22533178f, -0.06050767f, 0.80059046f, 
    -0.26901537f, 1.10260165f, -0.22863033f, -0.12452485f, 0.11532921f, 0.51459640f, -0.77565306f, -1.54558051f, 
    0.43724760f, 0.47087619f, 0.74218392f, 0.59328312f, -0.34687445f, -0.32985783f, -0.51839852f, 1.20884717f, 
    -0.43444848f, -1.23867142f, 0.78580451f, -0.54438078f, 0.27621469f, -0.39806807f, 0.12569055f, -0.18722984f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09530620f, -0.13414681f, 0.32080692f, 0.44384688f, 0.21690272f, 0.17225845f, 0.07904651f, 0.17143756f, 
    0.04610509f, 0.18646708f, 0.13763489f, 0.29729143f, 0.02023145f, 0.22036289f, 0.44211313f, 0.09323944f, 
    0.18165573f, 0.10577577f, -0.03056070f, 0.15720195f, -0.05620728f, 0.47045824f, 0.28750759f, 0.01302437f, 
    0.22902803f, -0.01679127f, 0.02428345f, 0.31234202f, 0.10644526f, 0.16306810f, 0.01706351f, -0.08616850f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.14459167f, -0.06694775f, 0.11971477f, -0.05142933f, 0.22809908f, -0.03993147f, -0.22051366f, -0.03800664f, 
    0.11971778f, 0.07023270f, -0.13228196f, 0.08580888f, -0.01237093f, 0.03991980f, -0.13680728f, -0.10959850f, 
    -0.02666242f, -0.16029625f, 0.00099816f, -0.04633569f, 0.19092618f, -0.36945620f, 0.26543286f, 0.20126309f, 
    -0.08613794f, 0.09214848f, 0.02098127f, 0.00426616f, 0.07879166f, -0.01021272f, -0.25977257f, 0.05699867f, 
    0.01085354f, 0.01166103f, -0.04030766f, 0.02792427f, -0.13074748f, -0.04639566f, 0.15688738f, -0.00279515f, 
    0.13971716f, 0.01304422f, 0.06222508f, -0.06193604f, -0.03504645f, 0.00799100f, -0.09868213f, 0.07278147f, 
    -0.06510708f, -0.05990204f, -0.00947431f, -0.01441321f, -0.04542657f, -0.12753148f, -0.04978572f, -0.00186030f, 
    0.01717714f, -0.02378026f, 0.00773692f, 0.03097576f, 0.04749015f, 0.01024140f, -0.07416118f, -0.21785286f, 
    0.21670578f, -0.13522850f, -0.25637493f, 0.03534053f, 0.00752083f, -0.07290216f, 0.01825471f, 0.05807710f, 
    -0.06472612f, -0.03115293f, 0.03249316f, 0.05888518f, 0.09858262f, -0.06716023f, -0.10695164f, 0.07436905f, 
    0.24648030f, -0.23387495f, 0.10384914f, -0.05238844f, -0.12714615f, -0.07653923f, -0.23810437f, 0.03482771f, 
    0.01099001f, 0.03291197f, -0.13253866f, 0.01371381f, -0.16752712f, 0.08044465f, -0.04566349f, 0.08859708f, 
    0.00139986f, 0.06664193f, -0.03764057f, 0.01355103f, -0.26762214f, -0.28864253f, -0.04003886f, 0.08817191f, 
    -0.08991817f, -0.02987145f, -0.06705480f, -0.14778611f, 0.09837580f, 0.02487372f, 0.11204173f, -0.00442047f, 
    0.00491153f, -0.02238927f, -0.03998586f, -0.01102987f, 0.08884800f, -0.01762270f, 0.00518962f, -0.14220163f, 
    -0.12731829f, 0.10562834f, 0.07340714f, 0.04186979f, 0.46919906f, -0.12813658f, 0.03197772f, 0.01969277f, 
    0.18687145f, -0.07712368f, 0.05845006f, -0.00710326f, -0.02566526f, -0.05733825f, 0.00236816f, 0.04462353f, 
    -0.12696441f, 0.02572670f, 0.02570415f, -0.05127856f, -0.14631474f, 0.04777985f, 0.13178733f, -0.16409570f, 
    0.35094383f, -0.02156131f, -0.08035099f, -0.02149891f, -0.16759104f, 0.01228700f, -0.05249948f, -0.07553199f, 
    0.06503343f, 0.00225616f, 0.05894282f, -0.14934660f, -0.04195142f, -0.13838309f, -0.00179875f, -0.17518562f, 
    -0.41340476f, -0.06205774f, -0.03768628f, -0.16813998f, -0.31316730f, 0.03932857f, -0.08952233f, 0.06009414f, 
    -0.08336826f, 0.10288544f, 0.05791948f, 0.12100024f, 0.05458275f, -0.05114928f, 0.06271024f, -0.11698967f, 
    0.12584509f, 0.13499208f, -0.11697654f, 0.06451251f, -0.01800049f, 0.08276303f, 0.11111266f, -0.02153428f, 
    0.05562078f, 0.04854107f, -0.12141623f, -0.04978756f, -0.00816420f, -0.01886896f, -0.01216278f, 0.11324961f, 
    -0.08306584f, 0.06826255f, 0.12242442f, 0.06681298f, 0.04650506f, 0.06215870f, 0.04324282f, -0.09302924f, 
    -0.00519547f, 0.10844212f, 0.20061874f, 0.15232956f, 0.21339335f, -0.04382991f, 0.02648242f, 0.06627696f, 
    -0.01075853f, -0.01460324f, -0.02685796f, -0.12026612f, -0.00185912f, -0.02622226f, 0.06258340f, 0.05089419f, 
    0.07797073f, -0.06993632f, 0.07190891f, 0.15692067f, -0.28621277f, -0.05655380f, -0.09658138f, 0.03502527f, 
    -0.09432280f, 0.06460846f, -0.05000338f, 0.03918202f, 0.10688806f, 0.02764825f, 0.02159687f, -0.07747759f, 
    -0.11080278f, 0.00708937f, 0.05638437f, -0.04462252f, -0.05124952f, -0.01605158f, 0.02906970f, -0.03372949f, 
    0.12527888f, 0.08058842f, -0.03536721f, -0.29182085f, -0.41422963f, 0.14383531f, 0.18143898f, -0.03321622f, 
    0.13473015f, -0.01943170f, -0.03870748f, 0.02070480f, -0.04414100f, 0.04345324f, -0.00509185f, 0.15752059f, 
    0.00939012f, 0.07957356f, 0.01024680f, -0.07447840f, -0.01894536f, -0.60964674f, -0.22851668f, 0.14771748f, 
    -0.15583760f, 0.00568046f, 0.09245010f, -0.04895131f, 0.13546558f, -0.01420539f, 0.01955756f, 0.10104806f, 
    -0.14618368f, -0.05979642f, -0.03877314f, 0.07019573f, 0.00531465f, -0.07328992f, 0.03983948f, 0.01970536f, 
    0.04264840f, 0.09179732f, -0.08770499f, -0.18388864f, 0.30960733f, -0.21985069f, -0.15965652f, -0.11301716f, 
    0.10410243f, -0.04703060f, -0.04311708f, -0.07894609f, 0.11445114f, 0.04863140f, 0.01714004f, 0.03300910f, 
    0.08357413f, -0.04081347f, -0.03872013f, 0.04823168f, -0.12302414f, 0.14808862f, -0.24266994f, 0.02386531f, 
    -0.35750455f, -0.22015369f, 0.04881069f, -0.08711790f, -0.15931904f, 0.08327191f, 0.06373982f, 0.05482619f, 
    0.00857542f, 0.00234371f, 0.06737826f, 0.01506197f, -0.06583453f, -0.02932658f, -0.17328817f, 0.02656663f, 
    0.05723161f, 0.09924493f, -0.14191169f, 0.02500601f, 0.14436284f, -0.25254121f, -0.06316477f, -0.15867119f, 
    -0.06948233f, 0.00868086f, 0.03678825f, 0.03824561f, -0.02198563f, -0.05511531f, 0.00640000f, 0.04030063f, 
    -0.04826625f, -0.02621339f, 0.05398849f, 0.06010922f, 0.25043365f, 0.05620373f, -0.06020840f, 0.13109799f, 
    -0.05935433f, -0.19332784f, -0.02777580f, -0.15431190f, 0.01704772f, 0.04285505f, 0.01619509f, 0.04284830f, 
    -0.12265033f, -0.08042140f, 0.04416532f, 0.01695318f, -0.01885043f, -0.06182183f, -0.00677133f, 0.04647916f, 
    0.33026958f, 0.22202492f, -0.04306034f, -0.10398525f, 0.23657337f, -0.23697819f, -0.28118029f, -0.19849108f, 
    -0.03221453f, 0.00645961f, -0.03671677f, -0.06270181f, 0.01296541f, -0.15164708f, 0.03456946f, 0.06030218f, 
    0.01262868f, 0.01375700f, 0.08716322f, 0.08227055f, -0.42159560f, 0.01192965f, -0.16167507f, 0.05709323f, 
    -0.20146710f, 0.03067360f, -0.06723102f, -0.03007486f, 0.02822791f, -0.01219974f, 0.08202294f, 0.01032695f, 
    0.00914855f, 0.02922021f, 0.04520459f, -0.08204748f, -0.14801784f, 0.04935561f, 0.02438166f, -0.12793088f, 
    -0.08065286f, -0.20125517f, 0.21523669f, 0.07787384f, -0.26284692f, -0.14131083f, 0.07600022f, 0.06633250f, 
    -0.15882699f, 0.13415129f, -0.05426006f, -0.02778885f, -0.01509837f, 0.07228684f, -0.15172754f, -0.05200414f, 
    -0.00963819f, -0.14114742f, 0.01344900f, 0.01594089f, 0.02843804f, -0.65851837f, 0.17916705f, 0.16357897f, 
    -0.22360176f, 0.06827826f, -0.08044093f, 0.01158557f, 0.01627352f, 0.05815649f, -0.16324255f, -0.11133114f, 
    -0.11139226f, 0.04814634f, 0.02213367f, 0.06159112f, -0.03285346f, 0.04301310f, -0.07041384f, -0.01836025f, 
    0.12364648f, -0.42808375f, 0.15360390f, 0.22095565f, -0.04130658f, 0.00161425f, -0.04029864f, -0.04321810f, 
    0.05963097f, -0.05905834f, -0.05575969f, -0.14046772f, 0.09633751f, -0.02499584f, -0.02404300f, -0.11435885f, 
    0.01610679f, -0.05127363f, 0.05055192f, -0.01644385f, 0.59051901f, -0.00787050f, 0.02748822f, -0.29063064f, 
    0.33616975f, -0.13660716f, -0.04346326f, 0.04764055f, -0.00403106f, -0.05394634f, 0.06718172f, 0.08139750f, 
    -0.10836616f, 0.15630317f, 0.08685097f, 0.01400486f, -0.02119940f, 0.12459522f, -0.11400416f, -0.10952093f, 
    -0.25302842f, -0.15651952f, 0.12464977f, 0.10245049f, 0.05402687f, -0.00483349f, 0.02519542f, 0.01161735f, 
    0.10329052f, 0.10847759f, 0.17785317f, -0.09569167f, 0.01132222f, -0.06302183f, 0.01225198f, 0.10485578f, 
    -0.09823672f, 0.02264043f, 0.00904649f, -0.13284247f, -0.18653356f, 0.32575071f, 0.03348942f, -0.35765713f, 
    -0.46919939f, 0.02469148f, 0.14291300f, -0.01269591f, 0.09962966f, -0.07247909f, -0.00003833f, -0.02692569f, 
    -0.05557352f, 0.15281171f, -0.08394796f, 0.06356009f, -0.00652879f, -0.03813701f, 0.04820401f, 0.02043913f, 
    0.32392916f, -0.13034534f, -0.21141383f, -0.09153539f, -0.29437158f, -0.12377450f, 0.02361153f, 0.02452567f, 
    -0.02071394f, -0.04650290f, -0.14006504f, 0.10925729f, -0.03277362f, 0.07606892f, -0.02191401f, -0.02582064f, 
    -0.14696074f, 0.09974881f, 0.02526191f, 0.12638125f, 0.10647134f, -0.28491485f, 0.01010149f, 0.15309232f, 
    0.00381978f, 0.03243227f, -0.01732007f, 0.07857353f, -0.14352831f, -0.03744089f, -0.04672068f, 0.05354747f, 
    0.00452434f, 0.11915375f, 0.02246445f, 0.02802716f, 0.03446960f, 0.00405283f, -0.12804469f, -0.05861912f, 
    -0.33002675f, 0.17140554f, 0.15192075f, 0.13753091f, 0.31402025f, 0.00775334f, 0.00036898f, 0.00308176f, 
    0.03061152f, -0.09572554f, 0.04009326f, -0.02051680f, -0.00882077f, 0.10630117f, -0.08488082f, -0.00092723f, 
    -0.05384360f, 0.06106052f, -0.02349423f, 0.02439633f, 0.17698443f, -0.03669678f, 0.22753832f, 0.11300400f, 
    -0.22518890f, -0.01394061f, -0.04292447f, 0.09670432f, 0.04324784f, -0.10952488f, -0.00303138f, 0.00623559f, 
    -0.01039978f, 0.00512880f, -0.02315882f, 0.09089150f, 0.00678266f, 0.01430824f, -0.02243393f, 0.00141545f, 
    -0.16108456f, 0.23135383f, 0.22852096f, -0.03828034f, -0.40982905f, 0.12567721f, 0.12992536f, 0.03587082f, 
    0.13200463f, -0.06703398f, 0.05961401f, 0.01063860f, 0.00447190f, -0.06898712f, -0.12277201f, -0.00870444f, 
    0.07325189f, -0.08707217f, -0.03566022f, 0.02954842f, 0.48994109f, -0.55038381f, 0.14352067f, 0.00952218f, 
    0.09742175f, 0.03545304f, 0.09742988f, 0.00041631f, 0.13548216f, -0.14695323f, -0.15689796f, -0.04787258f, 
    -0.02006012f, 0.06544808f, 0.00240763f, 0.03958620f, 0.07464641f, 0.13875450f, -0.10883549f, 0.06054451f, 
    0.31300652f, -0.08265037f, 0.04117610f, 0.00884694f, -0.13572639f, -0.01862350f, -0.02803123f, -0.01380328f, 
    0.00029361f, -0.04330708f, 0.11154296f, -0.09532756f, 0.00968095f, -0.11991527f, 0.14876178f, -0.11588543f, 
    0.01003544f, -0.03759554f, -0.00396254f, -0.07128146f, 0.09958886f, -0.50998998f, 0.04715846f, -0.15851955f, 
    -0.10156319f, 0.09160488f, -0.13483143f, 0.06974202f, -0.04211008f, -0.02146995f, 0.09646494f, 0.15184318f, 
    -0.08348702f, 0.00160328f, -0.00500126f, -0.02216463f, -0.13669840f, -0.00720941f, -0.09661838f, -0.11778292f, 
    0.15593643f, -0.02534466f, 0.10254824f, 0.09084787f, 0.08427791f, 0.04871929f, 0.05830352f, 0.01102498f, 
    0.00057780f, 0.07806913f, 0.12137131f, 0.13101624f, 0.03148247f, -0.06912444f, -0.06897486f, 0.02360523f, 
    0.08083526f, 0.03178164f, 0.10406914f, 0.07541572f, 0.29506585f, 0.18611461f, 0.16635552f, 0.21514779f, 
    0.28649747f, -0.03179143f, -0.05617435f, 0.06978720f, 0.04778428f, 0.03509793f, -0.04291669f, 0.03009437f, 
    -0.00329225f, 0.02752899f, -0.03812423f, 0.00064170f, 0.06687338f, 0.12929803f, 0.01205739f, -0.08262909f, 
    0.12479787f, 0.21754150f, 0.08714854f, -0.02239850f, 0.12286243f, -0.28751814f, 0.04377638f, 0.09928525f, 
    0.00803138f, 0.05500915f, -0.02867392f, -0.12018348f, 0.15052953f, -0.04138235f, -0.00133144f, 0.00074328f, 
    -0.08933154f, -0.14568189f, 0.03073493f, 0.19089285f, -0.00181307f, -0.19207646f, -0.07412956f, -0.06756832f, 
    -0.21836869f, 0.14648451f, -0.07998537f, 0.04678610f, 0.06052866f, -0.03499014f, -0.07317336f, -0.04817792f, 
    0.04588047f, 0.02582561f, -0.02178874f, 0.04746315f, 0.00170123f, -0.10403976f, -0.10744791f, -0.06747549f, 
    0.44099355f, -0.41868228f, 0.17869602f, -0.07961564f, -0.05327617f, -0.18669082f, -0.10178779f, -0.02920514f, 
    -0.06858584f, -0.06020024f, -0.16844542f, -0.06300199f, -0.11071731f, 0.14732397f, 0.00329467f, -0.14684992f, 
    0.11343460f, -0.17441009f, 0.00412404f, 0.07070823f, 0.12871477f, 0.15984674f, -0.06209885f, -0.13900824f, 
    0.11739296f, -0.16326310f, 0.02823570f, 0.00974977f, 0.10726506f, -0.05903161f, 0.17931391f, 0.01617259f, 
    -0.02349123f, 0.17602818f, -0.06682941f, 0.05103134f, 0.00025256f, 0.15175150f, -0.10896008f, 0.06130278f, 
    0.45973009f, -0.37885520f, -0.22755176f, -0.10887916f, -0.26636267f, -0.02255222f, 0.04685943f, 0.04217938f, 
    -0.00854933f, 0.13989684f, 0.06798466f, -0.02182041f, 0.01038984f, -0.00160278f, -0.09297300f, 0.16662730f, 
    0.14304608f, -0.05813253f, -0.08011063f, 0.10758436f, 0.32195193f, -0.19033031f, -0.45783421f, -0.00752169f, 
    -0.01732206f, -0.04880122f, -0.05207785f, -0.00867591f, 0.05295397f, 0.25914735f, 0.10047645f, -0.09563994f, 
    -0.02853562f, -0.06704772f, 0.08777351f, 0.07610326f, 0.05522330f, -0.00575482f, -0.03149809f, 0.00600571f, 
    -0.08395668f, 0.11281256f, 0.02621058f, 0.05590198f, 0.09396631f, 0.02805859f, 0.09925508f, -0.03696229f, 
    -0.08523300f, 0.09696459f, -0.01133208f, 0.18098913f, 0.03939492f, -0.07340959f, -0.06024971f, -0.02365267f, 
    -0.15194403f, 0.12576726f, -0.02695606f, -0.05711932f, 0.12451898f, 0.01605383f, 0.00226384f, -0.02155600f, 
    -0.08362952f, 0.04540450f, -0.05859215f, 0.03706040f, 0.00795803f, 0.06496446f, -0.05948251f, -0.12598625f, 
    -0.02781742f, 0.09179854f, -0.00642552f, 0.07092361f, -0.01051893f, -0.01197851f, -0.03930997f, -0.15240589f, 
    0.06349035f, 0.21850798f, -0.23146793f, 0.14466831f, -0.35364163f, -0.03184756f, 0.03931804f, -0.01998653f, 
    -0.12165690f, 0.11995462f, 0.09287181f, 0.02143623f, 0.00288151f, 0.11936720f, 0.03713132f, 0.12391906f, 
    0.18267411f, -0.11117582f, 0.02424225f, 0.07094206f, -0.18854837f, -0.06634945f, 0.04700202f, -0.06216824f, 
    -0.25906894f, -0.07951388f, -0.08387784f, 0.01133462f, 0.03951669f, 0.06972952f, -0.04968185f, -0.12491395f, 
    0.09782551f, 0.04154416f, -0.01931338f, -0.16740832f, 0.02392969f, -0.08635068f, -0.15770787f, -0.11728644f, 
    0.29729503f, 0.08814865f, 0.18515001f, 0.04654238f, 0.07231255f, 0.07037542f, -0.02079820f, -0.00217770f, 
    0.05273917f, -0.07588409f, -0.03250987f, -0.04047455f, -0.13459884f, 0.06773277f, 0.00483311f, -0.04806090f, 
    0.02706141f, 0.11586582f, -0.03359446f, -0.02833270f, 0.23145507f, -0.42359135f, -0.01530862f, 0.17147639f, 
    0.01046320f, -0.14985520f, -0.00682173f, 0.10629211f, 0.14273188f, -0.00797597f, 0.07779520f, -0.06771295f, 
    -0.06165235f, 0.03248302f, -0.25891763f, 0.07815616f, -0.12156846f, 0.02899068f, -0.03719660f, 0.05159921f, 
    -0.26411164f, 0.13864924f, -0.34702945f, -0.14440751f, -0.10376885f, 0.17335962f, 0.10937579f, -0.01770733f, 
    0.02760196f, 0.07559764f, 0.02604860f, -0.04424478f, -0.01258456f, 0.02367260f, -0.08187044f, -0.01633534f, 
    0.00800657f, 0.00328577f, -0.08614735f, 0.02288302f, 0.36395437f, -0.00752263f, -0.24070343f, 0.05281102f, 
    0.25524026f, 0.11434017f, -0.14573093f, 0.06799629f, -0.03807592f, -0.04470155f, 0.17653997f, -0.06690719f, 
    -0.02698496f, 0.02461562f, -0.08649870f, -0.06519768f, 0.10144805f, -0.00407527f, -0.05018937f, -0.01097779f, 
    -0.05602387f, 0.01633116f, 0.03748712f, 0.11100196f, 0.00652268f, -0.02046920f, -0.04594320f, 0.04332724f, 
    0.00458361f, -0.00145342f, -0.00479612f, 0.01651319f, 0.02573220f, 0.23150881f, -0.05068991f, 0.14180475f, 
    -0.05073054f, -0.07307892f, -0.13484442f, -0.09802563f, 0.10577764f, -0.15885553f, 0.01623093f, 0.02377399f, 
    -0.05177769f, 0.04957287f, 0.01667945f, 0.04197107f, 0.12156444f, 0.13315757f, -0.07322102f, -0.00994150f, 
    -0.04585323f, -0.01822574f, -0.01728730f, 0.11362480f, -0.08207613f, -0.00814955f, 0.06818684f, 0.04573856f, 
    0.08269258f, 0.24545401f, 0.10520887f, 0.03487726f, 0.22874281f, -0.02132800f, 0.01388594f, 0.02435842f, 
    -0.10085662f, 0.24276693f, 0.07823829f, -0.06802715f, 0.11297322f, -0.00228290f, 0.04626412f, 0.02414805f, 
    0.06715546f, 0.12709408f, 0.13082200f, 0.16731967f, -0.19474913f, 0.10949670f, 0.07542744f, -0.12811397f, 
    0.00365578f, -0.06493233f, 0.01759405f, 0.06608116f, -0.01376648f, -0.04702259f, -0.02053441f, -0.06811923f, 
    0.17294514f, 0.16524354f, -0.04560245f, -0.13114442f, -0.00396475f, -0.22149451f, -0.14303041f, -0.07093228f, 
    0.01547970f, -0.33012754f, 0.10465773f, -0.28588405f, 0.02467344f, -0.09041736f, 0.06305749f, 0.04155064f, 
    0.04657575f, 0.09081030f, -0.11476988f, 0.02595874f, -0.02127653f, 0.10424858f, -0.10298777f, -0.03684415f, 
    -0.04399951f, -0.07171419f, -0.07115465f, -0.06020981f, -0.30903882f, -0.21925390f, -0.01627122f, -0.17003293f, 
    0.22676972f, -0.11738849f, -0.04682553f, -0.02435184f, -0.09149698f, 0.02735635f, 0.12116431f, -0.00123532f, 
    0.01477062f, -0.10986297f, 0.05426108f, -0.10294422f, 0.03222411f, -0.13685958f, 0.01789367f, -0.01631660f, 
    0.21333379f, -0.31826401f, -0.21180050f, -0.05077688f, -0.03254971f, -0.10190038f, -0.11026295f, 0.08620930f, 
    0.02747751f, -0.02994723f, -0.01012619f, 0.09887359f, 0.10474510f, -0.06089713f, 0.09437117f, 0.02793705f, 
    -0.14409281f, -0.15903179f, -0.03030064f, 0.09941927f, 0.31977198f, -0.05038966f, -0.13927346f, 0.04252480f, 
    -0.26165247f, -0.10201620f, -0.07136401f, -0.06902968f, 0.00203950f, 0.08408536f, 0.08516350f, 0.08264395f, 
    -0.12558076f, -0.01611408f, 0.09299143f, 0.02855779f, 0.03961872f, -0.03970303f, -0.11738496f, 0.02127022f, 
    -0.01929663f, 0.17754158f, 0.17424917f, 0.09017989f, -0.03796935f, -0.16307253f, -0.13278207f, 0.02093138f, 
    -0.00340640f, 0.05213355f, -0.00272192f, -0.06056500f, -0.01748070f, -0.06124149f, -0.02883551f, 0.07914507f, 
    0.03261287f, 0.00721198f, -0.03087021f, 0.08858614f, -0.08763032f, -0.08698528f, 0.04139808f, -0.07418546f, 
    0.04907432f, 0.12118240f, -0.04147825f, 0.01631762f, -0.01785192f, -0.03887902f, -0.06643476f, -0.00235419f, 
    0.02217776f, -0.08584723f, -0.00360026f, -0.04097687f, -0.00987820f, -0.33551091f, 0.04739076f, -0.00477122f, 
    -0.40212989f, 0.15518810f, -0.25826839f, -0.36392343f, -0.14881650f, 0.07751525f, 0.19155750f, 0.00429801f, 
    -0.13674648f, 0.02136585f, -0.06528591f, -0.02636851f, 0.08776568f, -0.05659146f, -0.05518620f, -0.09099982f, 
    -0.02298788f, 0.11249902f, -0.07667422f, 0.06409270f, -0.53647941f, 0.07133789f, -0.10528841f, -0.12061094f, 
    0.21490473f, -0.20478937f, 0.10040212f, -0.06212944f, -0.01123043f, 0.03576814f, -0.04194881f, -0.05938223f, 
    -0.06373703f, -0.09134939f, -0.01804934f, -0.04842721f, -0.05069959f, 0.06103238f, -0.16056682f, 0.01671207f, 
    0.08278640f, -0.00706099f, -0.13773005f, 0.08434396f, -0.33743155f, -0.05093910f, 0.03098310f, -0.03619604f, 
    -0.07038180f, 0.04676694f, 0.00725268f, 0.10688443f, -0.17387962f, -0.01874960f, 0.04853387f, -0.06757435f, 
    0.02739619f, 0.03380251f, -0.02165102f, -0.00151992f, 0.06553703f, -0.74518895f, 0.20717585f, -0.44684350f, 
    -0.03025952f, -0.04394974f, 0.04322803f, -0.06608982f, -0.03581917f, -0.01554931f, 0.04489572f, -0.01975539f, 
    -0.05674934f, -0.00884943f, -0.11188167f, -0.10145525f, 0.02732749f, -0.15260434f, 0.13375169f, -0.15111597f, 
    -0.17617698f, -0.04315750f, 0.11255119f, -0.24181055f, -0.12457130f, 0.07762755f, -0.05053708f, 0.06145965f, 
    -0.00124576f, -0.01919487f, -0.16523165f, 0.06528299f, -0.01258099f, -0.02540915f, 0.00127968f, 0.01580789f, 
    -0.04727971f, 0.07547463f, -0.07520121f, -0.02195098f, -0.19838341f, 0.22403239f, -0.12538525f, -0.32362401f, 
    -0.26703826f, 0.03215158f, -0.02896662f, 0.19341989f, 0.10821666f, 0.09035813f, -0.09843404f, -0.10598792f, 
    -0.05587093f, -0.04076120f, -0.15636280f, -0.10593886f, 0.05787165f, 0.09638451f, 0.13019775f, 0.05644539f, 
    -0.18559651f, 0.08005899f, 0.10829438f, -0.11822388f, 0.09980419f, 0.06011696f, -0.03143703f, 0.03439244f, 
    0.06835399f, 0.04216430f, -0.07684571f, -0.03193014f, 0.03140956f, -0.05126606f, -0.03301230f, -0.11081397f, 
    -0.04077343f, -0.08064929f, -0.06813846f, -0.02636905f, 0.03580515f, -0.04317274f, 0.03760200f, -0.11081860f, 
    -0.03920855f, 0.15601577f, -0.05155965f, 0.11450225f, 0.03364142f, -0.02644259f, -0.06594164f, 0.05187820f, 
    0.04466834f, 0.03864143f, -0.08578604f, -0.09993937f, -0.00376366f, -0.00955372f, -0.10878258f, 0.01538139f, 
    -0.26324916f, -0.04143989f, 0.00440300f, -0.06166912f, -0.00007830f, 0.16626766f, 0.11014260f, -0.07171459f, 
    -0.01218629f, -0.01985648f, -0.04288061f, 0.04547762f, -0.04838214f, -0.06622393f, -0.06373925f, -0.03445569f, 
    0.01118766f, 0.04880907f, -0.17810702f, -0.02719967f, 0.13255925f, -0.04769954f, -0.04713071f, 0.08036868f, 
    -0.21612461f, -0.03662978f, 0.09078091f, -0.12057197f, 0.04332216f, 0.06965158f, -0.02893993f, 0.00190673f, 
    -0.00867451f, -0.02694896f, -0.01187724f, 0.01270481f, -0.05991191f, 0.03255200f, 0.02467618f, -0.03705906f, 
    0.22781794f, -0.13861161f, 0.11712762f, -0.17717950f, 0.07993424f, 0.05071126f, -0.09377271f, 0.12613523f, 
    0.02310460f, -0.01863916f, 0.00389948f, 0.06384365f, 0.12062287f, -0.01419810f, 0.01784017f, 0.02414337f, 
    -0.09536687f, 0.06429596f, 0.04530990f, -0.02756287f, 0.11496228f, 0.07913149f, -0.02359125f, -0.13768230f, 
    -0.12180251f, 0.04209832f, 0.07051063f, 0.07595410f, -0.13178749f, -0.02068521f, -0.12979023f, -0.01248906f, 
    0.13642949f, 0.00777829f, -0.04757971f, -0.02815447f, -0.06518946f, -0.06606961f, -0.03567763f, 0.02980934f, 
    0.20209661f, -0.18837926f, 0.16937265f, -0.20603275f, 0.17806964f, -0.15727480f, -0.05026161f, -0.00717207f, 
    0.03978954f, -0.00450802f, 0.08678645f, -0.14298317f, 0.03545048f, 0.10144944f, 0.00034741f, -0.02899670f, 
    0.03842389f, 0.09838033f, -0.09031741f, -0.06320977f, 0.14502519f, -0.15388490f, 0.16587034f, -0.17772976f, 
    -0.13660380f, -0.01187869f, 0.02841556f, -0.05432702f, -0.08251700f, -0.04568768f, -0.04253443f, -0.07279385f, 
    0.06273501f, -0.03115753f, 0.01654012f, 0.02766840f, -0.10307959f, -0.00011050f, 0.02473578f, -0.01977676f, 
    0.17016539f, 0.04621486f, -0.05804006f, 0.04313057f, 0.04490950f, -0.08994122f, -0.01617706f, 0.06341510f, 
    0.14184955f, 0.05769607f, 0.08332413f, 0.09178486f, 0.00506396f, 0.04167236f, 0.03746793f, -0.08471232f, 
    -0.05010708f, -0.13154060f, 0.00914702f, -0.00566906f, 0.30647957f, -0.39234382f, -0.08888523f, 0.07839990f, 
    -0.27106050f, -0.07336980f, -0.03534149f, -0.07860748f, -0.10244082f, 0.07864686f, 0.04314243f, 0.02622380f, 
    0.07310849f, -0.06471261f, -0.02740713f, -0.08707277f, -0.01325090f, 0.00909852f, 0.08699291f, 0.06401492f, 
    0.19697592f, 0.11178056f, 0.26223207f, 0.13700330f, 0.37777337f, -0.11234559f, -0.19709109f, -0.27245632f, 
    0.09477785f, 0.08938716f, 0.04057438f, -0.03642216f, -0.05000857f, -0.09402234f, -0.00847918f, 0.00047855f, 
    -0.04503081f, 0.00102355f, 0.08553675f, 0.00804944f, 0.33257863f, -0.24593633f, -0.14589934f, -0.18706605f, 
    -0.30362949f, -0.17030722f, 0.07492372f, -0.14767167f, 0.08780833f, 0.01448141f, 0.05564978f, -0.03635965f, 
    -0.08024745f, -0.03159625f, -0.01759248f, -0.04184204f, 0.02224669f, 0.08075866f, 0.03433478f, -0.10059831f, 
    -0.00203670f, -0.00485187f, -0.11730009f, -0.06764787f, 0.00217164f, 0.03334416f, -0.03446603f, 0.11445019f, 
    0.03044837f, 0.02125655f, -0.01491536f, 0.00025911f, 0.06646713f, 0.06821672f, -0.07110662f, -0.11037447f, 
    0.01830134f, -0.00164676f, -0.08717529f, 0.01279250f, 0.41120663f, 0.07253251f, 0.17855294f, -0.02043011f, 
    -0.03092654f, 0.00103085f, 0.02816216f, 0.10375245f, -0.04184749f, -0.00279740f, -0.02673360f, -0.06624507f, 
    0.03486817f, -0.00121414f, -0.07025670f, 0.12018590f, -0.04718931f, -0.06908628f, 0.06669305f, 0.03955480f, 
    0.18774679f, 0.08270703f, -0.25844976f, 0.03023342f, -0.09762288f, 0.03096270f, 0.10289931f, 0.04038302f, 
    -0.10363395f, -0.08036711f, -0.13298965f, 0.00185467f, -0.03519560f, 0.00378572f, 0.00127290f, 0.03250081f, 
    -0.00730735f, -0.13641687f, -0.02192681f, -0.06196226f, -0.10955099f, 0.24631439f, -0.05994273f, -0.17677416f, 
    0.01461308f, 0.00659908f, 0.05346962f, -0.01143492f, 0.03319708f, -0.10961290f, -0.09357636f, -0.04742692f, 
    -0.08649269f, -0.10672928f, -0.07038505f, 0.01845889f, 0.05281379f, -0.02684978f, 0.00322721f, -0.05806966f, 
    -0.21346842f, 0.18492332f, -0.17382097f, -0.08393112f, 0.09976244f, 0.03987782f, 0.15498662f, 0.12334817f, 
    -0.00738189f, -0.12638538f, -0.15855999f, 0.05339563f, -0.09935728f, -0.01786020f, -0.05779496f, 0.01647729f, 
    0.01390491f, -0.02068118f, -0.08626232f, -0.02365527f, 0.54115444f, -0.15476112f, -0.11641265f, 0.08784625f, 
    -0.37668508f, -0.20475371f, 0.02128389f, -0.05257307f, -0.11577404f, 0.07727550f, 0.01310647f, -0.02545471f, 
    0.04358062f, -0.12072708f, -0.07817132f, 0.00585567f, -0.01073989f, 0.00343205f, 0.13726500f, 0.03404200f, 
    -0.17642254f, 0.17079008f, 0.12227351f, -0.01285827f, 0.02697600f, -0.03293386f, 0.00246086f, -0.09738424f, 
    -0.03637719f, 0.08695549f, -0.00349169f, 0.03160234f, 0.02288141f, -0.06072420f, 0.12965988f, 0.03704870f, 
    0.03581768f, -0.16382049f, -0.03430294f, 0.01598559f, -0.40057072f, -0.36852920f, -0.16461164f, -0.09348106f, 
    -0.39053163f, -0.06200576f, 0.09349517f, -0.11023889f, -0.00747619f, -0.13355002f, 0.06399739f, -0.00681707f, 
    -0.02102905f, 0.01595888f, 0.01172203f, -0.09128541f, -0.02604674f, 0.05679465f, 0.03459243f, -0.09890196f, 
    0.12276253f, -0.30928034f, -0.25613204f, -0.01889160f, -0.33450890f, -0.03864016f, -0.00947666f, 0.08532545f, 
    0.09028425f, -0.00747953f, 0.07679033f, 0.00611009f, -0.03155581f, -0.00476211f, -0.06225574f, 0.01879862f, 
    0.02220097f, 0.07697643f, 0.03265052f, -0.08350991f, 0.33199504f, -0.05723720f, -0.03510797f, -0.23095146f, 
    -0.14670588f, 0.01945294f, -0.07475063f, 0.12013184f, -0.17710634f, -0.03453450f, -0.15240230f, 0.03423596f, 
    0.00262544f, -0.03877610f, -0.03739794f, -0.02627145f, -0.16768098f, 0.13472679f, 0.01435486f, -0.02935871f, 
    -0.00973898f, -0.09113897f, 0.00376962f, -0.12032176f, -0.25425461f, 0.11773869f, 0.01142887f, 0.02066947f, 
    -0.01302709f, 0.07965860f, -0.07040831f, 0.09701549f, -0.04936781f, -0.03986752f, -0.04582724f, 0.03846502f, 
    -0.06493605f, 0.14466067f, 0.00658639f, -0.00511837f, 0.30689600f, -0.03862881f, 0.17027055f, 0.18727219f, 
    0.24580893f, -0.09303916f, -0.03403351f, -0.14013664f, 0.11958935f, 0.06637576f, 0.13199759f, -0.02452312f, 
    0.00779745f, 0.01338253f, -0.02598672f, 0.08226059f, -0.12974310f, 0.04801677f, 0.03620223f, -0.04760064f, 
    -0.50387669f, 0.21592706f, 0.06955949f, -0.03006469f, 0.12995701f, 0.05817085f, 0.10859861f, 0.04866619f, 
    0.05280852f, -0.06887414f, -0.02912976f, -0.09263995f, 0.04054695f, -0.02178318f, 0.08934723f, 0.00746612f, 
    -0.04357300f, -0.12094874f, 0.12738825f, 0.03104247f, -0.22055051f, -0.44742543f, 0.12302563f, -0.07159232f, 
    -0.03357749f, 0.09049023f, -0.10172365f, -0.07933196f, 0.04086986f, 0.09559187f, -0.04587546f, -0.01779927f, 
    -0.06937937f, -0.01868955f, -0.02895109f, -0.03909464f, -0.10645238f, 0.00317408f, 0.02667549f, 0.10035457f, 
    0.37370312f, 0.07791138f, -0.51095241f, 0.00680268f, -0.12538503f, -0.08574105f, 0.04864184f, 0.04269778f, 
    -0.04616268f, -0.09293848f, -0.02593162f, 0.07912275f, 0.01224696f, -0.04168310f, -0.01979784f, -0.03351846f, 
    0.03886200f, -0.17410097f, 0.01131021f, 0.10251056f, 0.37834185f, -0.09128594f, -0.09653180f, -0.11764371f, 
    -0.13609403f, -0.08359546f, 0.03345687f, 0.05952214f, 0.00508458f, -0.00777784f, 0.08519228f, -0.03540233f, 
    -0.02019745f, -0.08553200f, 0.00828933f, 0.07002067f, -0.10028739f, -0.01932773f, 0.12238879f, -0.05869839f, 
    0.24325590f, -0.04801244f, 0.07504700f, 0.06730796f, 0.15963179f, -0.08008715f, -0.04925026f, 0.00978702f, 
    0.04469080f, 0.01138021f, 0.08836130f, 0.00737963f, -0.00667049f, -0.03312658f, 0.05392588f, 0.02451002f, 
    -0.07050134f, -0.08990832f, -0.00625467f, -0.01987845f, -0.10721289f, -0.27802840f, 0.01457407f, 0.03783958f, 
    -0.20479743f, 0.05812513f, -0.12423345f, 0.08745497f, 0.12125070f, 0.19527788f, -0.06497325f, -0.00687407f, 
    -0.05357962f, 0.00537263f, -0.04653899f, 0.12484266f, 0.05114953f, 0.00606086f, -0.01043409f, -0.14781326f, 
    -0.04238745f, -0.11366161f, -0.00241370f, 0.06364826f, -0.09325173f, 0.05122416f, -0.03337139f, -0.01148926f, 
    0.01528612f, -0.03930060f, 0.00713379f, -0.06630285f, -0.07228656f, 0.05215939f, -0.06046870f, 0.03435049f, 
    -0.05536434f, 0.05850745f, -0.13729075f, 0.03409231f, 0.19069272f, 0.17207365f, 0.16030450f, 0.00916531f, 
    0.21385098f, -0.01589495f, 0.11020522f, 0.05936982f, 0.12285491f, 0.00410183f, -0.00039450f, -0.00005579f, 
    -0.09216262f, -0.03425240f, -0.10606064f, 0.01742878f, 0.02548764f, 0.03072437f, 0.06322239f, 0.05784320f, 
    -0.33115414f, -0.29843196f, -0.14355278f, -0.16546823f, -0.25105169f, -0.11412177f, -0.04347398f, -0.06439478f, 
    -0.01960945f, -0.05165668f, -0.08804119f, -0.00266445f, 0.09272360f, 0.01363266f, -0.02132363f, 0.05694421f, 
    0.00368390f, -0.01176141f, -0.04352890f, 0.08204759f, -0.28320193f, -0.69858909f, -0.19938953f, -0.08519209f, 
    -0.13889556f, -0.19381972f, -0.05464291f, 0.00831104f, 0.00035592f, -0.04355332f, 0.01187190f, -0.06894555f, 
    0.10504057f, 0.08145660f, 0.05363238f, 0.01200707f, -0.06766355f, -0.05319147f, -0.08033702f, 0.02897075f, 
    -0.18759397f, -0.41227484f, -0.51832068f, 0.22799438f, 0.04127872f, -0.03831739f, 0.07774589f, -0.00109725f, 
    0.00900213f, -0.09062972f, 0.03972795f, -0.04044591f, -0.02779093f, -0.01489769f, -0.06343856f, 0.00244627f, 
    0.05891668f, 0.12818530f, -0.08016571f, -0.01376130f, -0.04089919f, 0.26075202f, 0.04277724f, 0.08502416f, 
    -0.05297383f, 0.12091335f, 0.11292098f, 0.01389010f, 0.03008040f, 0.05000693f, -0.09722860f, -0.03680553f, 
    -0.03003068f, -0.10540705f, -0.02091067f, 0.01055244f, 0.00193901f, 0.01891613f, 0.07264438f, -0.04648191f, 
    -0.19033919f, -0.10918725f, -0.33373424f, 0.05258227f, 0.01978300f, -0.14282677f, -0.06281945f, -0.06806347f, 
    0.09182702f, 0.07732974f, -0.08873314f, -0.02595130f, 0.13443133f, 0.03940753f, 0.08556522f, -0.05433553f, 
    0.02541056f, -0.05135543f, -0.09742949f, -0.01239141f, -0.42679846f, 0.07767811f, 0.06148107f, -0.20061450f, 
    0.13199207f, -0.01753855f, 0.08922721f, 0.03650693f, 0.07314052f, -0.04933356f, -0.03085406f, 0.14596106f, 
    -0.02848934f, -0.01990552f, -0.00615659f, -0.08013310f, 0.03614628f, -0.16791792f, 0.16173531f, 0.02054439f, 
    -0.00514248f, 0.09284958f, -0.05923215f, 0.07799162f, -0.06312329f, -0.07368422f, -0.14493695f, -0.00217695f, 
    0.01146928f, 0.14568934f, -0.02733572f, 0.11113826f, 0.14949572f, 0.02438448f, 0.03540947f, 0.11310540f, 
    -0.03586704f, 0.00839419f, 0.07073911f, 0.10071798f, 0.09783435f, 0.13904822f, -0.05570778f, 0.00307992f, 
    -0.03139887f, 0.01841154f, -0.02393949f, 0.08530123f, 0.05064391f, 0.00022354f, -0.06733929f, 0.06914909f, 
    0.02424192f, 0.03235646f, -0.04973441f, -0.06031612f, 0.07886003f, -0.10738817f, 0.06098252f, -0.08392758f, 
    -0.47573012f, -0.18153007f, -0.02331187f, -0.19173017f, -0.21310456f, -0.08622877f, -0.17139596f, 0.07861844f, 
    -0.01843997f, -0.05826978f, 0.01480105f, -0.12141283f, 0.04111704f, 0.06548300f, -0.00804925f, 0.08972119f, 
    0.03848325f, 0.04983545f, 0.06160492f, 0.10589974f, 0.12349924f, 0.02067815f, -0.06654815f, 0.02407856f, 
    -0.01359132f, -0.09825408f, -0.12896240f, 0.09339603f, -0.07355886f, -0.03091811f, -0.06926362f, -0.02114372f, 
    -0.04351992f, -0.03100901f, 0.11363057f, -0.02888095f, -0.02813567f, 0.17287123f, 0.05670816f, 0.06445138f, 
    0.15007171f, -0.10101122f, -0.13323990f, -0.16570146f, -0.11162318f, -0.12291991f, -0.14446221f, -0.06083036f, 
    0.00268715f, -0.07586180f, -0.08883929f, -0.02643789f, 0.09990195f, -0.00180458f, 0.01883976f, -0.11498352f, 
    -0.06948674f, -0.00364061f, -0.07494429f, 0.05218132f, -0.14270334f, 0.29263279f, 0.10621496f, 0.15613209f, 
    0.05600727f, 0.05304885f, -0.01293671f, 0.05897911f, -0.09107140f, 0.01049439f, -0.03102857f, -0.05245483f, 
    -0.02740469f, 0.03557091f, -0.16416995f, -0.06659106f, 0.01348660f, 0.10475962f, 0.07367983f, -0.05653045f, 
    0.08160277f, -0.60526073f, -0.29684639f, -0.12151939f, 0.03216774f, -0.12761731f, -0.03842184f, -0.01445692f, 
    0.02438050f, 0.01352855f, 0.00803067f, 0.04865095f, 0.02810953f, 0.00105454f, 0.04083192f, 0.02554392f, 
    -0.08257707f, -0.02513491f, -0.10926447f, 0.07112379f, -0.03190990f, -0.06590441f, 0.08414418f, 0.01589611f, 
    -0.16438156f, 0.09271589f, -0.02559585f, -0.13448039f, -0.02601732f, -0.14678402f, 0.06161080f, 0.07887868f, 
    -0.05103542f, 0.04213725f, 0.08212475f, -0.04028009f, 0.05020581f, -0.14965844f, -0.06659320f, -0.08712982f, 
    -0.53550762f, 0.33953959f, -0.04578968f, 0.12030590f, 0.23275740f, 0.15995942f, 0.09385398f, 0.00233236f, 
    -0.00451599f, 0.02416767f, -0.09251329f, -0.01158517f, 0.01837391f, -0.07384274f, 0.00660273f, -0.07083361f, 
    0.05597608f, -0.03288882f, 0.02653359f, -0.01414784f, -0.35845897f, 0.25697926f, -0.10111006f, 0.01412352f, 
    0.24470548f, -0.00422974f, 0.19694319f, 0.01229261f, -0.05456588f, 0.09215290f, -0.03377325f, -0.01369358f, 
    0.11393896f, -0.00658457f, 0.01736681f, 0.05483758f, 0.04096218f, 0.04042955f, 0.08363826f, 0.12726189f, 
    -0.02435627f, -0.60200852f, -0.28789079f, 0.18470006f, 0.31278241f, -0.04302607f, 0.17931052f, 0.05393921f, 
    0.02236615f, -0.04705591f, 0.00078239f, 0.03793966f, -0.07574810f, -0.25484559f, -0.05374371f, -0.01178340f, 
    0.00720344f, 0.08176398f, 0.04437461f, -0.06488632f, 0.11633839f, -0.09904067f, 0.02672707f, 0.04067460f, 
    -0.06255137f, -0.05593337f, -0.09262804f, -0.00248514f, -0.09956571f, -0.02814972f, -0.09890398f, 0.04474309f, 
    0.09966671f, -0.04964950f, 0.05889737f, 0.01847696f, 0.11774437f, 0.05766070f, -0.01551750f, 0.04462448f, 
    -0.18339536f, -0.14475755f, -0.48839593f, 0.21728778f, 0.06195427f, 0.05206543f, 0.07364420f, 0.03048124f, 
    -0.09109986f, -0.00270648f, -0.01520889f, 0.03841978f, -0.00465031f, -0.00886069f, -0.02989678f, 0.02804784f, 
    0.01741187f, -0.03353407f, 0.00382847f, -0.03201396f, 0.14145143f, 0.16976416f, 0.05622956f, 0.06995711f, 
    -0.03007793f, -0.01221063f, 0.02787328f, 0.01348206f, -0.00226513f, 0.02403144f, 0.01907177f, 0.03244146f, 
    -0.04228866f, -0.10053066f, -0.03268886f, -0.01846195f, 0.07474110f, 0.10060682f, 0.07885746f, 0.00880231f, 
    0.17153640f, 0.13944767f, 0.16508862f, 0.12011507f, 0.05650004f, -0.02589876f, 0.04557434f, -0.04763032f, 
    -0.08053636f, 0.05620975f, 0.09498034f, 0.04494778f, -0.12887244f, -0.02844037f, -0.01644675f, 0.04645800f, 
    0.00812856f, 0.00096468f, 0.10877802f, 0.11489734f, 0.55625898f, 0.31449383f, -0.15733716f, -0.04007334f, 
    -0.11153061f, -0.12166858f, 0.01586487f, 0.07043661f, 0.21105255f, -0.03096214f, -0.08440631f, -0.11064215f, 
    -0.08173056f, 0.09218393f, -0.09358145f, -0.10418584f, -0.01332774f, 0.00031512f, 0.08575379f, 0.08452168f, 
    0.26083916f, 0.16029683f, -0.06566419f, 0.03101584f, -0.00436419f, 0.01425257f, 0.08369871f, 0.08403143f, 
    -0.10210019f, -0.01000370f, -0.03141402f, -0.05210235f, -0.01602712f, -0.14728501f, 0.02020083f, -0.02899769f, 
    0.02541144f, 0.09968685f, -0.00210096f, -0.00909862f, 0.02385162f, -0.15932311f, -0.02273486f, -0.02941309f, 
    -0.06564004f, -0.02985593f, -0.20989853f, 0.15004832f, -0.01870431f, 0.02837512f, -0.14640529f, 0.05658734f, 
    0.02063638f, -0.07524835f, -0.02184647f, -0.02474870f, -0.05497117f, 0.06466839f, 0.09056568f, 0.01961351f, 
    -0.19414012f, -0.40072072f, -0.22935311f, 0.06446365f, 0.04526332f, -0.08551516f, 0.03650895f, 0.03920704f, 
    0.04958787f, -0.15520944f, -0.06906465f, 0.14763094f, -0.08655537f, -0.10936078f, -0.00498785f, -0.03894860f, 
    -0.13738656f, 0.05747864f, 0.11141423f, -0.15068673f, 0.10525820f, 0.21043931f, -0.10750936f, 0.13943480f, 
    0.04617846f, 0.08256965f, -0.04984571f, -0.02928252f, -0.01258627f, -0.07941101f, -0.05476370f, -0.00988534f, 
    -0.03014682f, -0.07522792f, 0.09228875f, 0.07965581f, -0.01146616f, 0.11026025f, -0.04322710f, -0.07815742f, 
    -0.31473571f, 0.26893786f, 0.00317910f, -0.07260299f, 0.00123066f, -0.05853435f, 0.02837946f, -0.03726182f, 
    0.09158237f, -0.05647782f, 0.00164883f, 0.01377249f, -0.11889074f, 0.07637911f, -0.03648425f, -0.07062102f, 
    0.03714756f, -0.12531966f, 0.04191698f, -0.01524884f, -0.26660883f, 0.30259776f, 0.08475601f, 0.09631312f, 
    -0.09805801f, 0.03918019f, -0.08519929f, -0.00245580f, 0.01435053f, -0.16319695f, -0.02351847f, -0.06240846f, 
    -0.14562199f, 0.07681111f, -0.07207558f, -0.06751360f, 0.01624361f, -0.08501820f, 0.10176895f, -0.04508938f, 
    0.20721030f, -0.18915743f, 0.11389656f, -0.09879986f, -0.16998902f, -0.06018868f, -0.15849125f, -0.07795893f, 
    -0.01223745f, 0.04384884f, -0.00495727f, -0.06051769f, 0.07760049f, -0.06745252f, 0.03730655f, -0.02066893f, 
    0.03204162f, 0.02910018f, 0.08159067f, 0.09981369f, 0.07950923f, 0.18164252f, -0.01422348f, 0.26040372f, 
    -0.09142105f, -0.03959285f, 0.05125588f, -0.00616552f, 0.08123486f, 0.03498328f, -0.06061709f, 0.01281250f, 
    -0.04765648f, 0.03624370f, 0.07014616f, 0.08218222f, -0.03354772f, -0.04930606f, -0.06391773f, 0.01604709f, 
    0.10821254f, 0.04102188f, 0.02988159f, 0.10817983f, -0.25285408f, -0.10698987f, 0.06758849f, -0.13086241f, 
    0.03428645f, -0.15234737f, -0.01301149f, 0.00460690f, 0.01259191f, 0.05781596f, -0.04499121f, -0.05791525f, 
    0.02405842f, -0.05962374f, 0.01880031f, 0.00448133f, 0.19246861f, 0.14782812f, -0.10973591f, -0.08485986f, 
    -0.33911759f, -0.21127874f, -0.01324995f, -0.13517001f, -0.13104437f, -0.11036907f, 0.01951002f, -0.00461798f, 
    0.05337555f, -0.00247821f, -0.01945191f, -0.24179788f, 0.02509088f, 0.10620511f, -0.00062490f, 0.06177301f, 
    -0.17121916f, 0.14153151f, 0.03254314f, -0.05657013f, -0.04367837f, 0.01413392f, 0.00110912f, -0.08984601f, 
    0.04176065f, 0.08147246f, 0.05725535f, -0.05076849f, 0.08264318f, 0.08583225f, 0.13056758f, -0.00668667f, 
    0.09367847f, -0.03305600f, -0.02353568f, 0.01072498f, 0.17623971f, 0.01018409f, 0.08964600f, 0.03089156f, 
    -0.02396737f, -0.03107339f, -0.05271392f, -0.00451658f, 0.12376396f, 0.15509121f, -0.05473819f, 0.02066347f, 
    0.09699763f, -0.02216270f, 0.00055808f, -0.00850864f, 0.02859409f, -0.07415382f, 0.11877381f, 0.04420900f, 
    -0.24050580f, 0.16688134f, 0.14213638f, -0.00180753f, -0.02986287f, 0.18162106f, 0.08858065f, -0.00419676f, 
    0.05145789f, 0.02519963f, 0.05898033f, -0.00172112f, 0.04298854f, 0.07422382f, -0.17045604f, -0.08817194f, 
    0.03198459f, 0.07634937f, -0.09963176f, -0.06712643f, 0.02478950f, -0.07941354f, 0.14526419f, 0.15113352f, 
    -0.01738250f, 0.07477176f, 0.11626960f, 0.05313012f, -0.10129072f, -0.00933338f, 0.13285211f, 0.03901412f, 
    -0.09315363f, -0.03348076f, 0.12300424f, -0.06144777f, -0.05107933f, -0.00558823f, -0.11828793f, 0.13865414f, 
    0.01608039f, 0.02999016f, 0.20608068f, -0.25580841f, -0.20252492f, 0.04006632f, 0.02582776f, -0.09773143f, 
    0.05014291f, 0.04591465f, 0.03845761f, -0.04435312f, -0.07010888f, 0.01324213f, 0.01773686f, 0.05528059f, 
    -0.02898529f, -0.04023086f, -0.20334803f, 0.07558329f, -0.18240514f, -0.16331483f, -0.00477312f, 0.09929752f, 
    0.02617181f, -0.04507003f, -0.00097486f, 0.20387840f, -0.15007317f, -0.10944040f, -0.00352167f, 0.02229430f, 
    -0.20219120f, -0.03697491f, 0.11116258f, 0.10064114f, -0.01283826f, 0.05920846f, -0.15652117f, -0.05415231f, 
    -0.45153883f, 0.45648146f, 0.20374303f, 0.15836465f, -0.04517141f, 0.14880545f, -0.19594523f, -0.06248171f, 
    0.08185064f, -0.13731682f, -0.09831207f, 0.07402931f, -0.10066836f, 0.08391173f, 0.08654378f, -0.04478502f, 
    -0.08466247f, 0.03449460f, 0.05622628f, -0.06028814f, -0.23288314f, 0.06940485f, 0.10800624f, -0.15583171f, 
    0.04892429f, 0.00340561f, 0.09997965f, 0.03174806f, -0.02655420f, -0.15889576f, -0.03335077f, -0.02437481f, 
    -0.01679654f, -0.04099667f, -0.07860503f, -0.06669744f, -0.05008416f, -0.02087842f, -0.04154636f, -0.04202469f, 
    0.27520964f, 0.22807524f, -0.19674629f, 0.12483343f, 0.06058752f, 0.06662013f, -0.08196235f, 0.09342945f, 
    0.17284167f, -0.04231022f, -0.03300435f, 0.03834502f, -0.02753893f, 0.09734232f, 0.02726094f, -0.06053824f, 
    0.08671369f, -0.06009424f, -0.07371572f, 0.02786686f, 0.09733657f, -0.08848551f, -0.00957899f, 0.08744998f, 
    0.09095570f, 0.09439141f, 0.02018476f, -0.00774330f, 0.09011554f, -0.01477528f, 0.10701884f, 0.07551128f, 
    0.01054280f, -0.10903847f, 0.06683540f, 0.00148772f, -0.05935243f, 0.02168849f, 0.03392341f, 0.01965096f, 
    -0.43492064f, 0.09119282f, -0.22956084f, 0.03481133f, 0.25032324f, 0.09015568f, -0.01804085f, 0.10251787f, 
    0.04133432f, 0.00695175f, 0.09166349f, 0.02161501f, -0.04822138f, -0.04003101f, -0.04350623f, 0.10424583f, 
    -0.07958328f, -0.02906871f, 0.13499694f, -0.03846221f, -0.08483624f, -0.20929670f, 0.12877634f, 0.07490889f, 
    -0.04079691f, -0.00270451f, -0.06183502f, -0.03720106f, -0.00208044f, 0.02450486f, 0.07152340f, 0.03233963f, 
    0.04212716f, 0.00263451f, 0.01018090f, -0.06432619f, -0.01151896f, 0.06804436f, 0.15780011f, 0.03356222f, 
    0.26559648f, -0.18731853f, 0.24621157f, -0.05396257f, -0.11454989f, -0.09860238f, -0.03838705f, 0.05921043f, 
    0.01755966f, 0.05000969f, 0.01571525f, 0.04131652f, 0.05509260f, -0.11731088f, 0.05001559f, 0.03918002f, 
    0.05992462f, -0.10495411f, 0.07767776f, -0.08838032f, -0.58134997f, 0.22030820f, 0.03567865f, -0.10745902f, 
    -0.02298438f, 0.11653033f, 0.09293275f, -0.02992644f, 0.01619201f, 0.04017203f, -0.04624031f, 0.10244830f, 
    0.10974556f, -0.01138312f, -0.14365655f, 0.06420039f, 0.09990174f, 0.02785442f, 0.01557549f, -0.09337445f, 
    -0.43031931f, -0.12053019f, 0.11109912f, 0.22132468f, -0.04478242f, -0.00697242f, -0.16410705f, 0.09056464f, 
    -0.09045777f, 0.01939927f, 0.05205285f, 0.06209413f, -0.12387471f, -0.05653495f, -0.00867211f, -0.01897109f, 
    0.03850573f, -0.06331865f, 0.01512618f, 0.02095132f, -0.10797878f, 0.00808569f, 0.19758937f, 0.18505143f, 
    -0.04696935f, -0.05395807f, -0.00246048f, -0.02555760f, -0.00260818f, 0.02720971f, 0.09443628f, -0.10730387f, 
    0.09666672f, -0.11550520f, 0.07370974f, 0.05392139f, 0.07615699f, 0.01861933f, 0.04217355f, 0.07454798f, 
    -0.35713831f, -0.64710665f, 0.24085426f, 0.28961742f, 0.09287389f, -0.22176321f, -0.02449029f, -0.03932942f, 
    -0.08441395f, 0.05488490f, 0.02642102f, 0.06966074f, -0.10839636f, -0.11319197f, 0.00736498f, -0.01759857f, 
    -0.14795679f, 0.00764989f, 0.12561186f, 0.01655243f, 0.10145090f, 0.04625637f, -0.12387568f, 0.10702664f, 
    0.17041682f, 0.07636139f, 0.00273251f, -0.02989761f, 0.05857038f, 0.04726125f, 0.00674251f, 0.04546797f, 
    -0.10493951f, -0.04982384f, 0.01306520f, -0.13117406f, -0.17144200f, -0.03393771f, -0.01987504f, -0.14707592f, 
    0.16062209f, -0.01482540f, -0.17173322f, -0.23725973f, 0.11181641f, 0.03070558f, -0.04333886f, -0.10366681f, 
    0.01497871f, -0.23991187f, -0.02990139f, -0.13847061f, 0.02331150f, -0.09997827f, -0.12305682f, 0.08144549f, 
    -0.13296452f, -0.22026291f, -0.08528169f, -0.07065154f, 0.02182647f, -0.02610492f, -0.11965956f, 0.21954669f, 
    0.06127562f, 0.05149109f, 0.08833278f, 0.01212212f, 0.11421826f, 0.01253168f, 0.09465471f, 0.04925200f, 
    -0.05837173f, -0.05151797f, -0.00581301f, -0.00352786f, 0.03533004f, -0.01408360f, 0.17565975f, 0.11192255f, 
    0.02231681f, 0.19856574f, -0.26998886f, 0.11678639f, -0.12015498f, 0.06411843f, -0.08217674f, 0.05560800f, 
    0.04550230f, -0.09061780f, -0.05749176f, 0.00858893f, 0.01543448f, -0.05636813f, 0.05282714f, 0.21358868f, 
    0.05641915f, 0.02014714f, 0.07210052f, -0.02074049f, -0.08514394f, -0.04392861f, -0.18590213f, -0.00787306f, 
    -0.07938962f, 0.12213486f, -0.01779508f, 0.05388533f, 0.00503597f, -0.01578849f, -0.08658949f, -0.07875066f, 
    0.02291856f, -0.07283993f, 0.02956926f, 0.01470434f, 0.10500167f, -0.01736668f, -0.01426260f, 0.03581401f, 
    -0.02970699f, -0.11460477f, -0.11930817f, 0.11048834f, -0.20645860f, 0.04328999f, 0.04053651f, -0.02066066f, 
    -0.09945136f, -0.13977015f, -0.08443992f, 0.04968208f, -0.00002567f, 0.00475561f, 0.11916233f, -0.09939495f, 
    0.04740277f, 0.14673752f, -0.17047837f, 0.04748679f, -0.86058867f, -0.17857973f, -0.11575408f, 0.08926792f, 
    0.31613666f, -0.00442568f, 0.03020057f, 0.00108657f, 0.10224484f, 0.12267996f, -0.05556876f, -0.10954103f, 
    0.18787071f, 0.04178944f, 0.07790975f, -0.04997886f, 0.23446117f, 0.09339176f, 0.14406393f, -0.09851899f, 
    -0.17127894f, -0.16367728f, 0.12466746f, -0.22087957f, -0.02752285f, 0.01965814f, 0.01874264f, -0.10521031f, 
    0.00263354f, 0.06266405f, 0.13147232f, 0.02881339f, -0.04399314f, -0.08571806f, -0.04881734f, 0.03413694f, 
    -0.10378236f, -0.13745470f, -0.05655663f, -0.05649054f, -0.16125928f, 0.11879500f, 0.05355258f, 0.12017789f, 
    -0.12448572f, -0.05574862f, -0.04839197f, 0.06637214f, 0.09933972f, -0.06777991f, -0.03934672f, -0.14866672f, 
    0.00501106f, 0.01796192f, 0.05765461f, -0.01304347f, -0.07528394f, 0.13385421f, -0.10649081f, 0.20170560f, 
    0.18216704f, 0.31761888f, 0.13634312f, 0.02292159f, -0.00119339f, -0.07994934f, -0.07399584f, 0.14689757f, 
    0.08715270f, 0.00162040f, -0.05922010f, -0.00404108f, -0.08345430f, -0.04103390f, 0.05338499f, 0.03690014f, 
    -0.03015054f, -0.05430084f, -0.01191096f, -0.10196660f, -0.58437330f, 0.31248218f, -0.10901460f, -0.18022561f, 
    -0.17839941f, -0.00506090f, -0.14684717f, 0.04217356f, 0.13294111f, -0.04056196f, 0.03037471f, -0.03645666f, 
    -0.04501400f, 0.04940889f, 0.06166446f, -0.03054505f, 0.09926774f, -0.04917349f, -0.11393713f, -0.05094724f, 
    -0.49847332f, -0.03425095f, -0.11162420f, 0.04740913f, 0.27259257f, -0.04278594f, 0.03059581f, -0.01947590f, 
    0.03423999f, -0.01247463f, -0.00873971f, -0.09776998f, 0.01902947f, 0.13367848f, 0.04993482f, -0.01690024f, 
    0.13890871f, 0.07806274f, 0.05496283f, -0.02312860f, -0.08923797f, 0.12028355f, -0.53829956f, 0.16132738f, 
    -0.46690470f, -0.03576750f, -0.11392139f, 0.05869278f, -0.16988739f, 0.05050112f, -0.03955845f, -0.01288245f, 
    0.00795801f, 0.03201259f, 0.00024073f, 0.00358327f, -0.01472282f, 0.04641823f, -0.16351461f, 0.04895237f, 
    0.11011089f, 0.07503113f, 0.00488231f, 0.04461055f, 0.24573630f, -0.06797508f, -0.12900899f, 0.24944137f, 
    -0.04309896f, 0.09184290f, 0.12841614f, -0.04481041f, -0.00975871f, 0.05927677f, -0.09227639f, 0.02296600f, 
    0.05214834f, -0.08640824f, 0.04456521f, 0.15942322f, -0.01286994f, 0.00856726f, 0.06264754f, 0.15920864f, 
    0.34936553f, -0.15019047f, -0.17079438f, 0.03210817f, 0.06288400f, 0.06448125f, -0.00968307f, -0.20809636f, 
    -0.06687303f, -0.05491488f, 0.03993871f, 0.19467233f, -0.10654942f, -0.16208762f, -0.15052232f, -0.04892724f, 
    0.07152311f, 0.16729796f, 0.08662058f, 0.13553938f, -0.00872788f, -0.16318800f, 0.11123494f, -0.00172446f, 
    -0.05758858f, -0.08180008f, -0.03851881f, 0.04762401f, 0.00736306f, 0.01934265f, 0.07560288f, 0.04597452f, 
    -0.04629285f, 0.09302635f, 0.02544525f, -0.01416320f, 0.19121185f, 0.13871355f, 0.16989182f, -0.01561711f, 
    -0.07589326f, 0.08337503f, 0.07732487f, -0.01906120f, -0.14122877f, 0.01988725f, 0.00972284f, -0.02677158f, 
    0.05006000f, 0.00177972f, 0.03716061f, 0.14949839f, -0.07606579f, 0.11266273f, 0.14586243f, 0.08913613f, 
    0.05607492f, -0.17941618f, 0.12448115f, 0.24929704f, 0.05202453f, 0.10713795f, -0.17933208f, 0.08519311f, 
    -0.08509905f, -0.08767048f, 0.05676777f, 0.03859396f, 0.00794471f, 0.00764421f, 0.17318265f, -0.01910784f, 
    -0.05818652f, 0.05305132f, 0.03994866f, -0.18493733f, 0.02880678f, 0.07879808f, 0.01072943f, 0.14222197f, 
    0.18349551f, -0.06659210f, -0.04784200f, -0.07110684f, -0.02108610f, 0.06729627f, -0.02586054f, -0.00407020f, 
    0.11052739f, 0.11770494f, 0.05981147f, 0.04487174f, 0.00370522f, 0.01069470f, -0.34015408f, 0.03738253f, 
    -0.10671921f, -0.06304887f, -0.12117261f, 0.17730796f, 0.16130441f, 0.10904552f, -0.05050543f, 0.03754904f, 
    -0.13936406f, -0.06025885f, -0.12330748f, -0.07844198f, 0.04840380f, -0.11682089f, 0.07652456f, 0.00069614f, 
    0.08707839f, 0.06106997f, 0.06164636f, -0.03423753f, 0.10808279f, -0.04854900f, 0.05837782f, 0.04300314f, 
    -0.04186348f, -0.06972758f, -0.08714995f, -0.21023226f, 0.05625486f, 0.03655059f, 0.06946535f, 0.09861832f, 
    -0.07700188f, 0.03812784f, -0.02955190f, -0.02455855f, -0.10686783f, 0.11637090f, 0.10387705f, -0.01424531f, 
    -0.52128458f, 0.21675977f, -0.31000316f, -0.04998212f, 0.24929561f, 0.14521022f, 0.11801724f, -0.11220262f, 
    0.08702567f, -0.01539493f, 0.03493823f, -0.12590490f, -0.06700099f, -0.15485026f, -0.00545242f, -0.21969579f, 
    0.01759228f, -0.16784950f, 0.09107195f, -0.21059129f, -0.14438005f, -0.23016676f, 0.17036167f, -0.16899696f, 
    0.11376253f, -0.03817488f, -0.09672231f, 0.07401774f, 0.04704025f, -0.07953586f, 0.11514587f, -0.09260374f, 
    -0.07893202f, 0.01262854f, -0.02287165f, -0.06462920f, -0.03328611f, -0.12361231f, -0.04081168f, 0.05211228f, 
    0.00679011f, 0.12609453f, 0.12533773f, 0.02016963f, -0.20634934f, -0.03646106f, -0.03157842f, -0.06767175f, 
    -0.10298365f, 0.01204683f, 0.07328719f, -0.10505567f, -0.06195664f, -0.03808429f, -0.14769574f, -0.02305732f, 
    -0.04638918f, 0.17266406f, 0.12842375f, 0.01804033f, -0.42914104f, -0.12231046f, -0.13886693f, -0.10546094f, 
    0.09618633f, 0.05797582f, 0.12774184f, -0.06507225f, -0.04178027f, 0.05728434f, -0.00573005f, 0.00223613f, 
    0.08157717f, 0.15066734f, -0.05758842f, 0.00861540f, 0.11120600f, -0.02509292f, -0.22536579f, 0.12861568f, 
    -0.51600569f, -0.23211318f, -0.07619455f, -0.17293584f, -0.05565128f, 0.17843467f, 0.11034223f, 0.15944724f, 
    -0.01767879f, -0.14820062f, 0.04135721f, 0.05051931f, 0.06247181f, -0.10895485f, 0.02980426f, 0.15135603f, 
    0.02435019f, -0.06799475f, -0.02421013f, 0.04484649f, 0.09817296f, 0.13062786f, -0.02085159f, 0.06025046f, 
    0.22444639f, 0.10687272f, 0.00233470f, 0.05339964f, -0.01230229f, 0.00488119f, -0.02028211f, 0.08061046f, 
    0.14340380f, 0.12566072f, 0.20023955f, -0.00933088f, 0.02567519f, -0.04968080f, -0.27861083f, -0.01791281f, 
    0.03106750f, 0.07496987f, 0.07960627f, 0.02975852f, 0.04522230f, -0.00832817f, 0.07673217f, -0.09360762f, 
    -0.11208221f, 0.15460548f, -0.05007821f, -0.02173972f, 0.01598437f, -0.03917090f, -0.06942522f, -0.00839877f, 
    -0.03018600f, 0.02675801f, 0.14433408f, 0.01476203f, -0.56515026f, 0.01776929f, 0.08723360f, -0.10575672f, 
    -0.14308040f, -0.04249245f, -0.18969285f, 0.02924996f, -0.01837408f, -0.07349946f, -0.00138502f, -0.02727078f, 
    -0.10766496f, -0.11144269f, 0.04972906f, 0.04398600f, 0.00613486f, -0.00204881f, 0.06846798f, 0.06772906f, 
    0.24728896f, 0.06867109f, -0.03271221f, 0.10872493f, -0.28659204f, -0.24168003f, -0.06480665f, 0.03984617f, 
    0.10510007f, -0.05456499f, -0.04066450f, 0.01156089f, 0.13308612f, 0.12076814f, 0.17471567f, -0.15549056f, 
    0.04406356f, 0.10086264f, -0.12401671f, -0.03546979f, -0.10717729f, -0.08426155f, -0.04168205f, 0.02350640f, 
    0.16594347f, -0.10715006f, 0.05846521f, 0.09908708f, 0.01097958f, 0.05862550f, -0.13919695f, -0.03396927f, 
    0.11518908f, 0.07789704f, 0.11967703f, -0.19069664f, -0.08291864f, 0.01736310f, -0.05013067f, -0.01502627f, 
    0.08890443f, 0.09401955f, 0.06720436f, 0.18307485f, -0.03388823f, -0.14910951f, -0.04150265f, -0.00078111f, 
    0.05275129f, 0.07359463f, -0.07002450f, -0.18763466f, 0.09111442f, 0.10496673f, 0.20002213f, 0.00990660f, 
    0.11304729f, 0.02211951f, -0.08749634f, 0.10485952f, -0.41283789f, -0.33517504f, -0.13687041f, -0.09191239f, 
    0.07426231f, 0.05216348f, 0.02090241f, -0.06432917f, 0.07874082f, -0.09951485f, 0.09010646f, 0.02457574f, 
    -0.00301301f, 0.10788386f, -0.06319685f, 0.04278679f, 0.17818567f, 0.02508301f, -0.22604202f, 0.16214994f, 
    -0.29159346f, -0.15232602f, 0.13963102f, 0.28411311f, -0.28188327f, 0.00556241f, -0.09191843f, 0.06578694f, 
    0.00762048f, -0.08081444f, 0.04136756f, 0.00160974f, -0.02517948f, 0.09006393f, 0.04322173f, -0.04179139f, 
    -0.05162098f, 0.16653176f, -0.07263222f, -0.10814250f, -0.10682501f, 0.10695396f, -0.30228561f, 0.12924501f, 
    0.08257459f, 0.05465292f, -0.06747408f, -0.03250938f, -0.05657060f, 0.10322893f, 0.03025166f, 0.06870604f, 
    0.12139919f, 0.03542308f, 0.07439609f, -0.07024610f, 0.01715115f, 0.10410380f, -0.05268591f, -0.14131972f, 
    -0.18986288f, -0.24332809f, 0.01998209f, -0.00936866f, 0.02932733f, 0.08149119f, 0.04654459f, -0.08087276f, 
    0.02096876f, 0.14176008f, -0.00461216f, 0.01561101f, 0.02752516f, -0.04007209f, 0.02846565f, -0.21453859f, 
    -0.12449130f, 0.02299370f, -0.17797859f, -0.08539706f, -0.11023909f, 0.14214917f, 0.15524122f, 0.09566990f, 
    -0.26295969f, -0.00714739f, 0.05012091f, -0.02761564f, -0.03873064f, 0.18390939f, 0.02478187f, -0.03136197f, 
    0.03658938f, -0.06606892f, -0.06826138f, -0.05898152f, -0.04134627f, -0.10183832f, 0.10109510f, -0.01008067f, 
    -0.00921531f, -0.00363755f, 0.24037544f, 0.16907229f, 0.04816060f, -0.05502242f, -0.02463932f, 0.02080127f, 
    0.01709632f, 0.04427942f, -0.05567480f, -0.18148315f, -0.13315611f, 0.09359745f, -0.01062796f, 0.01446352f, 
    0.09542553f, -0.41670114f, -0.06455436f, -0.04158580f, -0.45130023f, 0.16814610f, -0.33351728f, -0.21116301f, 
    -0.07848551f, 0.13898151f, 0.06300478f, 0.11895565f, -0.18012306f, -0.21459539f, 0.00459218f, 0.01650491f, 
    -0.14800401f, -0.04409011f, -0.00635568f, 0.10879198f, -0.12054686f, -0.02947871f, -0.00241021f, -0.02849669f, 
    -0.16055724f, 0.03822271f, 0.16716601f, 0.28940004f, -0.02518983f, 0.01446276f, 0.12139903f, -0.02080655f, 
    0.02228799f, 0.08461867f, 0.09759842f, -0.10225248f, 0.12987824f, -0.04582518f, -0.01926690f, -0.00103730f, 
    0.20944600f, -0.02120429f, -0.06816769f, -0.12202170f, -0.02866924f, 0.09397008f, -0.20825863f, -0.12101720f, 
    -0.06007918f, -0.10125935f, 0.12288579f, -0.01145144f, 0.08810015f, 0.12912779f, 0.16062625f, 0.12496314f, 
    0.07367244f, -0.08759695f, -0.05396193f, 0.07121813f, 0.12601596f, -0.15624203f, 0.19465460f, -0.07760654f, 
    -0.16164827f, -0.25930771f, -0.01689654f, 0.17470732f, -0.28377420f, 0.03195369f, -0.02846908f, 0.01379074f, 
    -0.00077093f, -0.03365045f, 0.03690373f, -0.02932366f, -0.07059865f, 0.01347968f, 0.06270604f, -0.01941821f, 
    0.10237295f, 0.03062118f, 0.02570235f, -0.02136624f, -0.36691102f, -0.11420017f, -0.15909417f, -0.11425447f, 
    -0.28322369f, 0.25420502f, -0.05040975f, 0.00984078f, -0.03625112f, -0.08037311f, 0.06613427f, 0.04375389f, 
    0.09986976f, -0.01098138f, -0.09072790f, 0.07414585f, -0.07736270f, 0.04492649f, 0.11420660f, -0.06487155f, 
    -0.17873052f, 0.41311190f, -0.25975275f, -0.09268349f, -0.09307005f, 0.07102252f, -0.05137671f, 0.12771061f, 
    -0.11848195f, -0.10795171f, -0.05585409f, -0.02746946f, -0.01112280f, -0.02449953f, -0.15605511f, 0.01820038f, 
    -0.13181123f, -0.00025634f, 0.08670936f, -0.10476888f, -0.03995559f, 0.02881073f, -0.08289812f, -0.23157904f, 
    -0.02795896f, 0.00855618f, -0.06750217f, -0.13664617f, -0.04126333f, 0.08624872f, 0.07993376f, 0.14595166f, 
    -0.02136631f, -0.06926549f, -0.01154683f, -0.00063542f, -0.10943394f, -0.12902248f, 0.06842820f, 0.01060593f, 
    -0.16105248f, -0.09034419f, -0.02455315f, -0.01986731f, -0.02640323f, -0.03856412f, 0.16794099f, -0.12099182f, 
    -0.05625917f, 0.03932453f, -0.12197301f, -0.08500314f, 0.04469462f, 0.01511046f, -0.06200625f, 0.12762924f, 
    -0.13681035f, 0.08700518f, -0.00856057f, 0.05089888f, 0.16639097f, -0.18856256f, 0.10791390f, -0.08602859f, 
    0.19893080f, 0.13925257f, 0.18273355f, -0.12026474f, -0.09301851f, 0.05240565f, -0.05846706f, 0.04326822f, 
    0.20674269f, 0.04030154f, -0.06054198f, 0.16303360f, 0.14593939f, 0.00015407f, 0.09778195f, 0.08438893f, 
    -0.07862329f, -0.17644326f, -0.03530721f, 0.01967922f, 0.31124601f, -0.01851641f, -0.00997053f, -0.03975819f, 
    0.02507695f, -0.03295147f, -0.14859654f, -0.05579816f, 0.04147212f, 0.12623207f, 0.02002421f, 0.00043247f, 
    0.00339369f, -0.06562225f, -0.10630667f, -0.02995791f, -0.46512765f, 0.31320456f, -0.08909103f, 0.16789022f, 
    -0.25232786f, -0.12507084f, -0.05340352f, -0.02511739f, 0.03849304f, 0.04421048f, 0.04604788f, 0.04423605f, 
    -0.02276365f, -0.01657795f, 0.00612045f, -0.01652961f, 0.05727114f, -0.16753697f, -0.02208443f, -0.12074675f, 
    -0.27341145f, 0.37471858f, -0.02214908f, 0.04740763f, 0.05866589f, -0.06400342f, -0.05396341f, -0.02971294f, 
    0.10141693f, 0.09362510f, 0.00692490f, 0.06314061f, -0.07170772f, -0.02735280f, 0.08588587f, -0.08887756f, 
    0.03637394f, 0.05359958f, 0.00662536f, 0.09835780f, 0.06184991f, 0.01364948f, -0.13425907f, -0.17846231f, 
    0.13404104f, -0.05306486f, -0.06519676f, -0.04396790f, -0.09258459f, -0.00700214f, -0.05243813f, -0.03114017f, 
    -0.11566126f, -0.04747683f, -0.06050130f, -0.01159397f, 0.12380768f, -0.00610117f, 0.05870498f, -0.01145439f, 
    -0.14027542f, 0.16707659f, -0.24439180f, 0.10679389f, -0.05716461f, 0.00185794f, 0.04422615f, 0.01800317f, 
    0.07387956f, 0.13419145f, 0.04067831f, 0.01834548f, -0.03294257f, 0.04982428f, -0.15066375f, -0.05331771f, 
    -0.00883106f, -0.00094089f, -0.09768660f, -0.02253453f, -0.38774917f, 0.08656174f, 0.00502385f, 0.15998964f, 
    -0.04405905f, 0.17815357f, -0.04012230f, 0.09466200f, 0.02337343f, -0.15495646f, -0.03920932f, 0.03477454f, 
    0.17096245f, 0.00125766f, -0.06692609f, 0.01996825f, 0.18071522f, -0.00160058f, 0.01161814f, -0.04853339f, 
    0.21078090f, -0.45599431f, 0.05988505f, -0.43238273f, 0.13463585f, -0.02072146f, 0.10851326f, -0.07140333f, 
    -0.07198746f, -0.25224885f, 0.06999224f, 0.02098516f, 0.10647774f, 0.04622708f, -0.03087721f, 0.08217834f, 
    -0.06738182f, 0.02935402f, 0.03933182f, 0.18568067f, -0.23290414f, -0.03327648f, -0.10249095f, 0.24797456f, 
    0.01908975f, 0.11304488f, 0.06561875f, 0.13311972f, 0.10972394f, -0.05300051f, -0.07954048f, 0.00532912f, 
    0.05832016f, -0.09396093f, 0.13517353f, -0.05591360f, 0.07147342f, 0.19558811f, -0.05160560f, 0.04115662f, 
    0.20969076f, -0.47356933f, -0.11624406f, 0.06362438f, -0.13678038f, -0.02611789f, 0.08328638f, 0.07375839f, 
    0.03136361f, 0.13458376f, -0.06281919f, 0.04756784f, -0.11693686f, -0.04809257f, 0.12926684f, 0.11401750f, 
    0.06043853f, -0.21318381f, -0.17558579f, -0.10607737f, -0.33062902f, 0.12706532f, -0.03233685f, -0.20312738f, 
    0.06397729f, -0.01390193f, -0.01850914f, 0.12497271f, -0.15969001f, 0.04158225f, 0.01639911f, -0.02060939f, 
    0.05698443f, 0.03809151f, -0.00602889f, -0.06995041f, -0.07620354f, -0.06185059f, 0.16522586f, -0.00055310f, 
    -0.12152500f, -0.47687307f, -0.09706465f, -0.26603737f, -0.01635643f, -0.20974636f, 0.04448937f, 0.01641945f, 
    -0.03007327f, 0.05652624f, -0.14332052f, 0.02559346f, -0.11439319f, 0.13549100f, 0.03436467f, -0.19090572f, 
    0.07221514f, -0.05172275f, 0.01584271f, -0.08252410f, 0.03836163f, 0.01868719f, -0.22038554f, -0.12974750f, 
    0.04466677f, 0.06462839f, 0.04161540f, -0.01276410f, -0.16374764f, -0.07091115f, 0.03743075f, -0.00405912f, 
    0.04052917f, -0.07334290f, -0.02877881f, 0.02736957f, -0.07895856f, 0.01841970f, 0.07416604f, 0.09061877f, 
    -0.52147847f, 0.26948234f, -0.00922687f, 0.12553200f, -0.18760638f, -0.00647264f, -0.01804252f, -0.04439341f, 
    0.12239125f, -0.04000986f, -0.01268694f, 0.01352816f, 0.08220746f, 0.04233426f, -0.07954673f, -0.01815434f, 
    -0.05379624f, -0.10365979f, -0.08317355f, -0.07721508f, 0.69061184f, -0.04793892f, 0.12972774f, 0.02559250f, 
    0.30119160f, 0.00921771f, -0.01713127f, -0.09217542f, -0.01373065f, -0.11467163f, -0.04968639f, -0.05615735f, 
    0.10456589f, -0.08866213f, 0.05617575f, -0.18603535f, -0.00501757f, -0.03362546f, -0.08291607f, -0.02470377f, 
    0.18979764f, 0.01001933f, 0.23696980f, -0.18789090f, -0.13680376f, 0.13527359f, 0.02594366f, 0.04108866f, 
    -0.05832518f, -0.04155147f, -0.07346132f, -0.03421223f, -0.24867806f, -0.01285711f, -0.08304207f, 0.10054987f, 
    -0.04151814f, 0.01659707f, 0.09381224f, 0.00131830f, 0.05210869f, 0.25105715f, 0.29059333f, 0.00671679f, 
    -0.38031459f, 0.17376940f, -0.00109490f, 0.06884405f, 0.01224638f, -0.07265968f, -0.13462105f, 0.04785239f, 
    -0.00704308f, 0.12016550f, -0.02821647f, 0.19176580f, -0.14654376f, -0.07188473f, 0.07472743f, -0.00547387f, 
    -0.06866599f, 0.38072357f, 0.12578914f, -0.01422842f, -0.42442617f, 0.07599670f, 0.03791865f, 0.00575517f, 
    0.04181041f, 0.05435264f, 0.03663087f, 0.07170574f, -0.08686848f, -0.01613136f, -0.19120863f, -0.04677154f, 
    -0.04793879f, -0.09320609f, 0.02323563f, -0.04636343f, -0.34583768f, 0.03110765f, 0.03428049f, -0.15242487f, 
    0.02241676f, 0.04443963f, 0.02084753f, 0.10804858f, -0.12768070f, 0.11836715f, 0.12034082f, -0.11163839f, 
    0.02274051f, 0.05717701f, 0.10245130f, -0.08840102f, -0.01984252f, -0.15587007f, 0.15669096f, -0.06638841f, 
    -0.26736563f, 0.18604961f, -0.07035206f, 0.10702173f, -0.01011037f, -0.02635610f, -0.04390218f, 0.17903891f, 
    0.06731890f, -0.05781451f, -0.01061858f, 0.02743053f, -0.15278867f, -0.01462119f, 0.06690533f, -0.05800602f, 
    -0.02140963f, -0.08461834f, 0.01350548f, 0.10238325f, -0.14773270f, 0.14439616f, -0.16209210f, -0.38055620f, 
    0.08895327f, 0.04123408f, -0.05642812f, 0.05179912f, -0.02021947f, 0.04477011f, -0.05639950f, -0.06132205f, 
    -0.13004050f, -0.09090894f, -0.02471224f, 0.04467233f, -0.12461978f, 0.17896532f, 0.09309310f, 0.07220804f, 
    0.12673452f, -0.02775917f, -0.23996675f, -0.21960011f, 0.13982214f, -0.06609018f, 0.00775700f, 0.00712536f, 
    -0.04243771f, -0.08990229f, 0.01360650f, -0.09626166f, -0.07299695f, 0.01842370f, -0.09634056f, 0.04435815f, 
    0.09939756f, 0.07249547f, 0.11481932f, 0.08289929f, 0.03429838f, 0.01580070f, -0.15365683f, 0.37971741f, 
    -0.13637459f, -0.04582177f, 0.04310216f, -0.02006972f, 0.07861625f, 0.02441525f, -0.04876779f, 0.08612087f, 
    -0.04347483f, 0.07271575f, 0.00538249f, 0.09753770f, 0.00414868f, 0.06847578f, -0.11687171f, -0.07238311f, 
    -0.09374427f, 0.08745266f, -0.11288418f, 0.06330068f, 0.12110775f, 0.07044992f, 0.05695486f, -0.09849846f, 
    -0.01902930f, 0.02514720f, -0.05129211f, 0.01811800f, -0.11730838f, 0.03179395f, -0.04014359f, -0.00641413f, 
    0.11771170f, 0.13300328f, 0.08523551f, 0.00875492f, -0.06280523f, -0.40625414f, -0.05037269f, -0.35403654f, 
    0.05145692f, -0.03722591f, -0.04531405f, 0.01161666f, 0.01811454f, -0.03827076f, 0.01758603f, -0.01853573f, 
    0.20926696f, 0.12733106f, -0.02950403f, -0.02731427f, 0.00248863f, -0.08325632f, -0.09628704f, 0.08641557f, 
    0.16554408f, 0.19843975f, 0.04287230f, 0.19287801f, 0.23424335f, 0.05359662f, -0.08635406f, -0.03878153f, 
    0.01583990f, -0.15528740f, -0.09858935f, 0.09134746f, -0.08971426f, 0.01291960f, -0.00808465f, -0.07775167f, 
    -0.03262715f, 0.00038311f, 0.06879690f, -0.14890835f, 0.24216817f, -0.19528989f, -0.17596307f, -0.08722380f, 
    0.17365053f, -0.13630177f, 0.04345645f, 0.06667446f, -0.07028407f, -0.22855309f, -0.04966784f, 0.06582016f, 
    -0.09646719f, 0.00212746f, 0.10221163f, -0.13657920f, 0.04648012f, 0.18311132f, -0.10616337f, 0.06993249f, 
    0.20945983f, -0.12600657f, 0.05293851f, -0.01375580f, 0.06990620f, -0.05297341f, -0.13951968f, 0.02371843f, 
    -0.01772580f, 0.14924571f, 0.01801617f, 0.04568935f, -0.07415536f, -0.06694897f, -0.16760436f, -0.03604975f, 
    0.00026597f, 0.05622268f, 0.08172900f, -0.08563478f, 0.31914085f, -0.58917040f, -0.10319851f, 0.22323249f, 
    0.02042521f, -0.01674842f, 0.06815090f, 0.03043443f, -0.14336601f, -0.11808272f, 0.04021247f, -0.01193642f, 
    0.02555958f, 0.06547319f, 0.06114262f, -0.08980262f, 0.06069547f, 0.07426560f, -0.03766204f, 0.01867368f, 
    0.07553197f, -0.71720678f, -0.06207828f, -0.13566241f, -0.03544047f, 0.02442485f, 0.13522381f, -0.04651966f, 
    0.01361363f, 0.00947860f, -0.07069434f, -0.00504514f, 0.13457502f, 0.04051385f, 0.08716401f, 0.07534447f, 
    -0.03618822f, 0.00315073f, -0.15122047f, 0.03565434f, -0.07072564f, -0.23027894f, -0.20944259f, -0.16198270f, 
    0.22272699f, 0.00848145f, 0.08900113f, 0.16165936f, 0.10155041f, 0.02701679f, -0.00356326f, -0.13219558f, 
    -0.09921984f, 0.03766129f, -0.00534187f, -0.01797359f, -0.01213438f, 0.10542584f, 0.05555496f, 0.09285253f, 
    -0.10216720f, 0.06334864f, -0.13250512f, -0.00962554f, 0.00794092f, 0.00459641f, 0.01527811f, -0.11609681f, 
    -0.00472099f, -0.02020857f, -0.06212709f, 0.06801923f, -0.02530035f, -0.10208993f, -0.01473889f, -0.04863753f, 
    0.02176921f, -0.02474180f, -0.06288715f, -0.05341563f, -0.03218275f, 0.34937030f, -0.21738967f, 0.01768455f, 
    0.05717289f, -0.09642497f, 0.12976481f, -0.04487864f, 0.00277292f, -0.07238527f, -0.11925866f, -0.05210872f, 
    0.02093417f, 0.02120021f, -0.07530936f, 0.03994383f, -0.00503153f, 0.10935003f, -0.04084073f, 0.03242592f, 
    -0.13877946f, -0.07863890f, -0.09845047f, -0.19222412f, -0.09917181f, -0.12681177f, -0.09079381f, -0.09678217f, 
    -0.05736226f, -0.10636812f, 0.05258080f, -0.04967029f, -0.02056398f, -0.04612823f, -0.04878157f, -0.03422171f, 
    -0.09856410f, -0.04700738f, 0.00040102f, -0.03420212f, -0.20009409f, -0.05931356f, -0.01411272f, -0.20518139f, 
    -0.30596769f, -0.02363773f, -0.06946961f, -0.05125871f, -0.04219840f, -0.08208368f, 0.04416122f, -0.04992611f, 
    -0.02391200f, -0.05450399f, -0.02386962f, -0.03833584f, 0.05299914f, -0.01606830f, -0.02346400f, 0.00445905f, 
    -0.00582626f, 0.02829954f, -0.28820392f, -0.11955100f, 0.02785185f, 0.04058644f, -0.12414157f, -0.06055072f, 
    -0.02932175f, -0.07277410f, -0.22780505f, 0.09752275f, -0.10450462f, -0.00501117f, -0.07707037f, 0.02976155f, 
    -0.09802040f, -0.11536018f, 0.02737486f, -0.02792382f, 0.01479451f, -0.06927954f, 0.07749232f, 0.04848203f, 
    0.08212773f, 0.02635402f, -0.07342717f, -0.07255165f, -0.04639307f, -0.00563415f, 0.00657012f, -0.02459357f, 
    0.02459975f, -0.08123659f, 0.04905854f, -0.04588074f, -0.06982227f, 0.00301385f, 0.04847096f, 0.02665258f, 
    -0.35414791f, 0.08571129f, -0.13022876f, 0.02894432f, -0.16294369f, -0.06252746f, 0.04702708f, -0.11769893f, 
    -0.04327159f, -0.09729492f, 0.04404503f, 0.09332176f, -0.08578365f, 0.00349497f, 0.03940669f, 0.03298157f, 
    -0.02461307f, 0.01706340f, 0.01703156f, 0.06338710f, 0.15453982f, -0.23767425f, 0.10947825f, -0.12566008f, 
    -0.25946742f, 0.00777229f, -0.00966502f, -0.08248582f, -0.06161921f, -0.03168882f, -0.06278059f, -0.07115323f, 
    0.01058684f, -0.06711711f, -0.17431566f, -0.01602782f, 0.03741240f, -0.00209812f, 0.01673109f, -0.08581237f, 
    0.13108173f, 0.07696236f, 0.31181946f, -0.03593240f, 0.25796017f, -0.07384909f, 0.13353960f, 0.10600271f, 
    0.11966708f, 0.04954496f, -0.00486141f, 0.05609191f, -0.19635457f, 0.00290453f, -0.14622033f, -0.15117589f, 
    0.02371153f, 0.04692832f, -0.00420324f, -0.01899406f, -0.21202168f, 0.17747235f, 0.16616173f, 0.03631938f, 
    0.02676999f, -0.02646260f, -0.06001570f, 0.00410109f, 0.02052868f, -0.10600174f, 0.08093422f, 0.00425804f, 
    0.03214680f, 0.01370219f, -0.06189269f, -0.01542611f, -0.09577738f, 0.05394860f, 0.01131965f, -0.10441142f, 
    0.13008465f, -0.23052841f, -0.05280124f, -0.09965559f, -0.13534574f, -0.02287569f, -0.06604765f, -0.07168909f, 
    -0.16435774f, -0.00471466f, 0.09023786f, 0.03989218f, -0.06752682f, -0.03512266f, -0.10243760f, 0.05104484f, 
    -0.00468591f, -0.08404398f, -0.02583848f, -0.01918624f, 0.09174990f, 0.08471175f, 0.19043370f, 0.02089959f, 
    0.07323330f, 0.06523214f, 0.02573056f, -0.04608846f, -0.04377859f, 0.01782042f, -0.01853856f, -0.04452179f, 
    -0.00072633f, -0.05116630f, -0.07532599f, 0.04067416f, 0.01983594f, 0.04529801f, 0.12173144f, -0.06451361f, 
    -0.06008619f, 0.03998080f, 0.19925056f, 0.21116528f, 0.10805251f, 0.08917543f, 0.00371830f, 0.03697697f, 
    0.03714258f, -0.07435483f, -0.07836024f, 0.06013735f, 0.05409661f, -0.01928576f, 0.03297766f, -0.02536071f, 
    -0.06742194f, 0.01940424f, 0.03032330f, -0.03866587f, 0.17192253f, -0.09743504f, 0.15343410f, -0.04021258f, 
    0.12094513f, 0.00329791f, 0.04330615f, -0.01771596f, -0.02497335f, -0.00860654f, -0.05146012f, -0.00961981f, 
    -0.00448169f, -0.09360876f, 0.03235462f, -0.01119697f, -0.02515133f, 0.03343989f, 0.07333110f, -0.02287665f, 
    -0.27142465f, -0.06256238f, -0.00665437f, -0.20233577f, -0.21246415f, 0.01088457f, 0.04688741f, -0.02489352f, 
    -0.05923387f, -0.02880151f, -0.05946325f, -0.01932265f, 0.00945361f, -0.13569777f, -0.03969484f, 0.02901547f, 
    0.09028633f, -0.03922154f, -0.02312258f, -0.01506734f, 0.25555271f, 0.01633833f, 0.12543313f, 0.01403829f, 
    0.02384512f, -0.21990372f, 0.10698413f, -0.13472117f, 0.05231564f, 0.09463418f, 0.01878376f, 0.14613041f, 
    -0.08425014f, 0.09016800f, -0.05209073f, -0.05951304f, -0.04305395f, 0.08077262f, 0.07317895f, -0.13123029f, 
    0.20649923f, -0.54595584f, 0.16945532f, -0.04151063f, 0.05669050f, -0.00130309f, -0.08151855f, -0.03694335f, 
    -0.07159017f, 0.02775152f, -0.05536697f, -0.07955527f, -0.08087754f, -0.03576361f, -0.11610673f, -0.05097430f, 
    0.07905898f, -0.02180464f, 0.01146356f, -0.05978231f, 0.02138587f, -0.25792870f, -0.20270438f, -0.05690742f, 
    0.04531670f, -0.06766022f, -0.16843955f, -0.04343488f, -0.00027832f, -0.07572357f, -0.02720747f, -0.01626003f, 
    -0.02389896f, -0.05139248f, -0.01244620f, 0.01926898f, -0.05331738f, -0.06895318f, -0.03365667f, -0.04721468f, 
    -0.25779918f, -0.12984701f, -0.38817450f, -0.20659475f, -0.05446374f, -0.00439781f, -0.11204572f, -0.10815855f, 
    -0.05858257f, -0.05454267f, -0.04907319f, 0.08606475f, 0.08069117f, -0.10299964f, -0.00176354f, -0.09366540f, 
    0.07231940f, 0.01936081f, 0.06472228f, 0.08198430f, 0.18489017f, 0.06164907f, 0.20081307f, -0.03878208f, 
    0.06793793f, -0.01216147f, 0.03367612f, -0.09219589f, -0.02866880f, 0.01345207f, -0.02066506f, 0.04396442f, 
    -0.03643763f, 0.07871228f, -0.01422536f, -0.02118876f, 0.04934070f, 0.04607782f, 0.09167615f, -0.04415491f, 
    0.24834694f, 0.27526531f, -0.21422407f, -0.02859906f, 0.02681008f, 0.03043617f, -0.13630146f, -0.02437741f, 
    0.09316795f, -0.07248864f, -0.13677274f, 0.09210029f, -0.19848156f, -0.07225871f, -0.00151888f, 0.04773462f, 
    -0.11938442f, -0.01247680f, -0.00452570f, -0.01083345f, 0.05341895f, 0.12048490f, 0.11453963f, 0.17071523f, 
    0.19178809f, 0.03289015f, 0.04132293f, -0.02370875f, -0.01826341f, -0.07686371f, -0.10741203f, -0.00614231f, 
    -0.10676359f, -0.06220050f, -0.09720061f, -0.03206980f, 0.00592087f, -0.00569834f, 0.00351436f, -0.00300402f, 
    0.08927522f, 0.21067922f, 0.12850346f, 0.07520960f, 0.21100827f, -0.05561339f, 0.12328585f, -0.05349929f, 
    0.03246724f, -0.09905777f, -0.06012520f, -0.07026529f, -0.10126578f, -0.01108160f, -0.01543504f, 0.03459251f, 
    -0.00832286f, 0.08095167f, -0.02160810f, 0.00132017f, -0.53841782f, 0.17190322f, 0.26810780f, 0.01445210f, 
    -0.05052533f, 0.09543507f, -0.18466327f, -0.07857430f, 0.12160566f, -0.08399136f, 0.05993984f, 0.01902088f, 
    -0.00487179f, 0.06505782f, -0.11581966f, 0.11159624f, 0.04998571f, 0.08898857f, -0.05800394f, -0.07243258f, 
    -0.23365805f, 0.12127236f, 0.00999635f, -0.01915307f, 0.14036262f, -0.02732693f, -0.04903969f, -0.16236565f, 
    0.00772001f, -0.03175509f, 0.06064755f, 0.03623110f, 0.06033380f, 0.01460996f, -0.00930490f, -0.04831721f, 
    -0.14067486f, 0.06930391f, 0.02546562f, -0.05531611f, 0.15229192f, 0.11453187f, 0.33022952f, 0.13341899f, 
    0.14231461f, 0.06186700f, 0.11520714f, -0.01721989f, 0.04536409f, -0.04357458f, -0.06314935f, 0.07836021f, 
    0.04569511f, -0.03687086f, -0.07527889f, -0.01462247f, 0.01260547f, 0.01835570f, 0.06202438f, -0.06054921f, 
    -0.14827654f, 0.08557476f, -0.23975427f, -0.09502687f, 0.06786853f, -0.01639679f, -0.03394382f, -0.06804271f, 
    0.01296980f, -0.10493469f, -0.07849005f, -0.04862459f, -0.04098750f, 0.04152348f, -0.02033426f, -0.02814035f, 
    -0.07410821f, -0.01708282f, -0.01553325f, 0.02334405f, -0.01864310f, 0.16792785f, -0.04766246f, -0.02394963f, 
    0.10492682f, -0.03644120f, 0.04329083f, -0.02765172f, -0.03011824f, 0.01579681f, -0.13178924f, 0.00078724f, 
    -0.05919741f, -0.05651021f, -0.16274004f, 0.01622935f, -0.05127061f, 0.10535971f, 0.06389169f, -0.02698914f, 
    0.22027582f, -0.51881623f, 0.16021761f, 0.09225564f, -0.24233028f, 0.13614352f, -0.08624084f, -0.07569007f, 
    -0.15345450f, -0.00373824f, 0.01261372f, -0.06287879f, -0.05106227f, -0.02508001f, -0.10213244f, -0.00177132f, 
    0.14464156f, -0.01873767f, 0.00279182f, -0.05940166f, 0.24653977f, -0.11174437f, 0.15545183f, 0.03717598f, 
    -0.00329177f, 0.12597571f, 0.02661105f, -0.05992040f, -0.01476775f, 0.00394645f, -0.06185484f, 0.01257228f, 
    0.00050742f, -0.00241552f, -0.03537193f, -0.02348205f, 0.08070077f, 0.00726862f, 0.04867966f, -0.09448083f, 
    0.05142508f, 0.11054602f, 0.22747053f, 0.15708376f, 0.20737188f, 0.01782506f, 0.14626904f, -0.06111476f, 
    0.04939804f, -0.05755138f, 0.00686271f, 0.02018403f, 0.04823470f, -0.00190987f, -0.05297071f, -0.01639690f, 
    -0.00968973f, -0.02347108f, -0.01965630f, -0.02215050f, 0.07889454f, 0.12447309f, -0.01126618f, 0.13458787f, 
    0.17126207f, -0.05232000f, 0.21645524f, -0.15641223f, 0.09722866f, -0.04503244f, -0.08244099f, 0.11993721f, 
    -0.10577613f, -0.09678729f, 0.00007128f, 0.01704161f, -0.05673932f, 0.11734384f, 0.00750110f, -0.01801920f, 
    0.03284989f, -0.02678161f, -0.14915209f, 0.07616168f, 0.04142271f, -0.04242310f, 0.04324015f, 0.01890722f, 
    -0.08508626f, 0.00114874f, 0.05635580f, 0.03016081f, 0.05199053f, 0.04123271f, 0.03586451f, -0.11890353f, 
    -0.02677051f, -0.06806591f, 0.11215969f, 0.05378273f, -0.22322170f, 0.08057120f, -0.18309809f, -0.26535851f, 
    -0.22268970f, -0.05394142f, -0.07713280f, -0.07209422f, -0.03742350f, -0.14227818f, 0.19574200f, 0.01736140f, 
    -0.03837599f, 0.06439250f, -0.05460243f, -0.07299592f, 0.03238638f, -0.05167722f, 0.09858434f, 0.10418559f, 
    0.18559426f, 0.23105672f, -0.00377464f, 0.07467011f, 0.13288215f, 0.01480594f, -0.08213830f, -0.16925311f, 
    -0.09716522f, -0.11075769f, 0.05878573f, -0.03254326f, -0.00038043f, -0.00541239f, 0.02591866f, -0.08919670f, 
    0.01947140f, 0.12111937f, 0.03359265f, -0.12925434f, 0.12041470f, 0.14341249f, -0.08522387f, 0.13078077f, 
    0.13752553f, 0.07196698f, 0.10896777f, -0.15880495f, -0.02450191f, -0.01889037f, -0.02326683f, 0.02323880f, 
    -0.01937370f, -0.14166963f, -0.01110395f, -0.12667659f, 0.03859442f, 0.11578821f, 0.05833525f, 0.03221184f, 
    -0.03688775f, 0.06029834f, 0.10505905f, 0.03405394f, 0.10603434f, 0.04485579f, 0.02178233f, -0.11270487f, 
    -0.04530864f, -0.05000018f, 0.09657525f, 0.06230817f, 0.07193909f, 0.02303343f, 0.05548494f, -0.11435571f, 
    -0.00961960f, 0.03371901f, 0.10015757f, -0.05362056f, -0.15031320f, -0.17653652f, -0.02475343f, -0.34742323f, 
    -0.19626831f, 0.04008777f, -0.17989153f, -0.04647539f, 0.03416895f, -0.10907146f, 0.02020126f, 0.11306583f, 
    -0.02596434f, 0.05244571f, -0.03637110f, 0.05554507f, -0.11650869f, -0.06933978f, -0.15259828f, 0.00124879f, 
    0.10987330f, 0.11630635f, -0.08311158f, 0.09078287f, -0.01135200f, 0.06574763f, 0.06056788f, 0.00786789f, 
    -0.14532031f, -0.02324542f, 0.00663801f, -0.02154270f, 0.07965165f, 0.02570777f, -0.00432603f, -0.03105203f, 
    -0.05751877f, -0.01116688f, 0.09256872f, -0.01291420f, 0.00236511f, 0.19306998f, -0.24281478f, 0.04798625f, 
    -0.01261955f, 0.13096635f, -0.06747583f, -0.02167688f, -0.12382694f, 0.11636038f, -0.05468945f, 0.03349201f, 
    0.00107240f, 0.11703478f, -0.04446488f, 0.07392681f, -0.11942553f, -0.03456202f, 0.02831712f, -0.02651297f, 
    -0.03708522f, 0.09558236f, 0.00305198f, -0.08310118f, -0.16277604f, -0.19733205f, -0.00830513f, 0.01659806f, 
    -0.06335136f, 0.05480107f, 0.06018233f, -0.07479952f, -0.06599798f, -0.04187873f, 0.06101140f, 0.00949255f, 
    -0.09718079f, -0.15407404f, 0.06075288f, 0.06869244f, 0.08261686f, 0.12539315f, -0.31199038f, -0.02489971f, 
    -0.05373661f, 0.01104273f, 0.00449790f, -0.07818437f, -0.06098360f, -0.06089135f, -0.02829032f, -0.06662103f, 
    0.02171359f, 0.04698692f, 0.10978340f, 0.04598603f, -0.11847155f, -0.12345466f, 0.06901753f, 0.03415190f, 
    0.15484002f, 0.14832443f, 0.08613852f, -0.00452764f, 0.17054796f, -0.07975548f, -0.03184973f, -0.12732729f, 
    -0.06587333f, -0.14852986f, -0.02338533f, -0.04241904f, 0.02883106f, -0.17042486f, 0.04003597f, 0.01813869f, 
    -0.06443495f, 0.04883306f, 0.08006495f, 0.02998498f, -0.23609747f, 0.02534911f, 0.19841650f, -0.14468926f, 
    -0.05788537f, 0.00825615f, -0.01411790f, -0.03824626f, -0.02299508f, -0.06501374f, 0.03716780f, -0.03458146f, 
    0.07672158f, 0.05583188f, -0.08646660f, -0.00748000f, 0.01888479f, -0.07240098f, -0.24921176f, -0.01882411f, 
    -0.15647769f, -0.10742584f, 0.23925349f, 0.01085055f, 0.17836502f, -0.12824802f, -0.07085509f, -0.05929253f, 
    -0.01098681f, -0.04889219f, 0.02305484f, -0.00100116f, 0.05670759f, -0.11304589f, -0.02577621f, 0.00057982f, 
    0.03574338f, 0.02626476f, 0.00314840f, 0.11465003f, -0.19588260f, -0.02632790f, 0.06315845f, -0.25799459f, 
    -0.24270740f, -0.09307192f, -0.02626432f, -0.05084441f, -0.08961809f, -0.07510154f, 0.02764433f, 0.03740348f, 
    0.02913424f, 0.04416289f, 0.01449850f, -0.03081768f, -0.12196017f, -0.00635848f, -0.35173228f, 0.01016838f, 
    0.08846452f, 0.03486911f, -0.18908720f, 0.08011877f, 0.06359809f, 0.01792435f, 0.07673982f, -0.08371945f, 
    -0.04229206f, -0.04503489f, 0.03695483f, 0.02761367f, 0.02661521f, -0.03540503f, 0.06452322f, -0.12388878f, 
    -0.04275911f, 0.05472022f, 0.11758890f, 0.02357648f, -0.10750068f, 0.08584318f, -0.02253646f, -0.03189870f, 
    0.10664167f, 0.04059365f, -0.02081088f, -0.04010044f, -0.06176773f, 0.10737165f, 0.15816252f, -0.02430687f, 
    -0.06631991f, 0.08498885f, 0.03583471f, 0.01930941f, 0.02458829f, -0.00085492f, 0.01454441f, 0.08731899f, 
    -0.09747853f, -0.22182567f, -0.10154629f, -0.04349876f, 0.10358774f, 0.15952794f, -0.02916190f, 0.00188289f, 
    0.01126080f, -0.07389577f, 0.15366505f, 0.09094407f, 0.06172392f, -0.00631634f, -0.01208872f, 0.06672616f, 
    0.04797585f, 0.01277548f, -0.03879550f, -0.07770468f, -0.16243339f, -0.28347841f, -0.34061536f, -0.01530709f, 
    0.03307910f, 0.07027452f, 0.06366543f, -0.07076882f, -0.06912582f, -0.05998227f, 0.04459082f, 0.11666876f, 
    0.07738431f, 0.08502085f, 0.06764651f, -0.05158547f, 0.01063282f, 0.02267887f, 0.02767675f, -0.13401395f, 
    -0.05819827f, -0.21944270f, -0.16582070f, -0.09962317f, 0.11123707f, 0.21648706f, 0.09688808f, -0.06061629f, 
    0.01363039f, -0.10069647f, 0.03067526f, 0.08954490f, 0.03658070f, 0.00698362f, -0.03391644f, 0.00273338f, 
    0.09132981f, 0.15107486f, 0.03343173f, -0.08751472f, -0.12418675f, 0.03486537f, 0.15593629f, -0.12639849f, 
    -0.08940451f, -0.02286479f, 0.05150998f, 0.01888041f, 0.07797682f, -0.20835681f, 0.04508744f, -0.08155487f, 
    0.08918067f, 0.11298381f, 0.00878657f, 0.01592571f, 0.00784381f, 0.03707628f, -0.13565841f, 0.01449827f, 
    -0.10496926f, 0.11867961f, 0.01484094f, -0.04705768f, 0.03564228f, -0.01568255f, -0.12671274f, -0.10429121f, 
    -0.02523302f, -0.07283138f, 0.15420298f, 0.01753062f, -0.01237641f, 0.07135428f, 0.04219566f, 0.00259725f, 
    -0.05637234f, -0.00062810f, -0.03184695f, -0.08399718f, -0.24127479f, -0.11116081f, 0.29024848f, -0.28471923f, 
    -0.21939260f, 0.03782361f, -0.01426816f, -0.13697699f, 0.06279904f, -0.08823772f, 0.05724180f, -0.00705150f, 
    0.00379189f, 0.04738217f, -0.02792404f, -0.06289034f, 0.07349876f, -0.11220874f, -0.21001904f, -0.04774978f, 
    -0.15263660f, 0.25173667f, -0.09068549f, -0.39196271f, -0.38116080f, -0.03728172f, -0.05656713f, -0.05051441f, 
    0.01386015f, -0.18760028f, 0.09389690f, -0.02797634f, -0.03161199f, 0.04960174f, 0.01734960f, -0.09506566f, 
    0.02711600f, -0.10513643f, -0.05789848f, 0.05297680f, 0.04833743f, 0.23288360f, -0.28510556f, 0.08435373f, 
    -0.00411629f, -0.04771236f, -0.12378872f, -0.25549999f, -0.06901205f, -0.06023172f, 0.05321577f, -0.01614059f, 
    0.04871636f, -0.02772386f, 0.02757158f, 0.02213818f, 0.03792805f, -0.02161860f, 0.19187917f, -0.04428998f, 
    -0.10865600f, 0.20361106f, -0.11866107f, -0.25903705f, -0.18264295f, -0.00283925f, -0.06044218f, -0.05277799f, 
    0.11092746f, -0.04370204f, 0.00603640f, 0.08415496f, 0.07084081f, 0.03953600f, 0.01865714f, 0.13201819f, 
    -0.04200422f, -0.23810744f, -0.06211732f, 0.09211130f, -0.18085967f, -0.09635070f, 0.22636907f, 0.00821001f, 
    0.16265470f, -0.11071031f, -0.06268868f, 0.05212591f, -0.05825474f, 0.04028146f, 0.09654745f, -0.03810772f, 
    -0.20295854f, -0.07025103f, 0.07299741f, 0.04556417f, -0.03891067f, 0.00919677f, 0.02107135f, 0.03610740f, 
    0.08321581f, 0.11335164f, -0.06829137f, -0.06405523f, 0.00851151f, 0.11341593f, 0.04366216f, -0.08473945f, 
    -0.10127496f, -0.00520429f, 0.12585606f, -0.01342047f, 0.00240298f, 0.11190763f, -0.11378850f, 0.03829137f, 
    0.04853725f, 0.07619364f, -0.01158910f, -0.05117238f, -0.06619373f, 0.02653087f, 0.11966138f, -0.05244539f, 
    -0.24453628f, -0.16958049f, -0.03660269f, 0.02001983f, 0.01407348f, -0.03940243f, 0.13638611f, 0.04849895f, 
    -0.03915187f, -0.00898291f, 0.03498834f, -0.12380672f, 0.01096605f, -0.11666573f, 0.18634975f, -0.13897929f, 
    0.05897545f, 0.00270155f, 0.03650512f, 0.01357528f, 0.09145528f, 0.02802621f, 0.00393289f, -0.10623880f, 
    -0.05459695f, 0.05325534f, 0.02222046f, 0.07618923f, -0.06904814f, -0.03688288f, 0.02989316f, 0.03897737f, 
    0.02522466f, -0.00672509f, 0.01269761f, -0.02379899f, 0.01794100f, -0.26640645f, 0.13300359f, 0.00515402f, 
    0.03490750f, -0.11365306f, 0.04103042f, -0.06953128f, -0.21204306f, 0.06157332f, -0.01745385f, 0.01246119f, 
    0.03113414f, -0.05173494f, -0.02211806f, 0.07330707f, -0.01082989f, -0.07852520f, 0.11656854f, 0.10142416f, 
    -0.11458284f, -0.12187155f, 0.16803348f, -0.00497417f, 0.14198752f, -0.06513681f, -0.05760099f, -0.00868116f, 
    -0.11236201f, 0.05183494f, 0.08508854f, -0.02032065f, -0.08218808f, -0.09623141f, 0.02281220f, 0.00643131f, 
    -0.08763002f, 0.04658247f, 0.09299846f, -0.01259852f, -0.12832886f, 0.25000724f, 0.03882712f, -0.15144178f, 
    -0.20615861f, -0.14392902f, -0.00471517f, -0.10901810f, -0.06824962f, -0.11165352f, 0.11344393f, 0.03968171f, 
    -0.05687300f, 0.06207951f, 0.00712329f, -0.14012352f, 0.00623818f, -0.11477026f, 0.15086551f, 0.03314383f, 
    -0.53330022f, 0.31095073f, -0.12138034f, -0.10111643f, -0.02425071f, 0.03957427f, 0.12205620f, 0.04342438f, 
    0.07251030f, -0.05862223f, -0.04845846f, -0.01900100f, 0.01303975f, -0.07735036f, 0.11129562f, 0.05344056f, 
    -0.00941732f, 0.11162336f, 0.04687990f, -0.00629528f, -0.15121131f, -0.05242496f, -0.23367140f, 0.24504063f, 
    -0.38643166f, -0.03208847f, 0.04000795f, 0.02432624f, -0.11099078f, -0.07224430f, -0.22255805f, -0.09121430f, 
    -0.09245713f, 0.05117880f, 0.19918184f, -0.06121455f, -0.01817354f, 0.00401008f, 0.06753882f, 0.00542287f, 
    0.32273391f, 0.02722744f, -0.16257520f, 0.05964455f, -0.01796188f, 0.10525628f, 0.05898100f, 0.05473678f, 
    -0.03315420f, -0.05645891f, 0.02655510f, 0.01803910f, 0.02096672f, 0.06308448f, -0.12524918f, 0.05116308f, 
    0.03203187f, -0.10803352f, 0.02437366f, -0.00991927f, -0.14514500f, -0.19991292f, 0.07257195f, 0.11286621f, 
    -0.07796849f, 0.01023779f, 0.14908390f, 0.06917413f, -0.05088520f, -0.23794204f, 0.07249992f, 0.02544502f, 
    -0.18094167f, -0.10817944f, -0.02352431f, 0.04227118f, -0.02674890f, -0.08201129f, -0.19811040f, -0.06271657f, 
    0.34994215f, 0.06855121f, -0.01670695f, -0.29611516f, -0.18513863f, -0.03261523f, 0.07211142f, -0.06717687f, 
    -0.00712475f, -0.05041963f, -0.09571789f, 0.00534857f, -0.04713110f, -0.17659053f, -0.05769902f, 0.09207875f, 
    0.06418724f, -0.06628142f, 0.08476754f, -0.03459617f, -0.02056321f, -0.07727952f, -0.09882420f, -0.09099005f, 
    0.08562050f, -0.12792873f, -0.03323549f, 0.04115939f, 0.10809524f, 0.01027137f, 0.01616439f, 0.04627160f, 
    0.05619154f, -0.10997941f, -0.06797309f, 0.08437824f, -0.08943985f, 0.05551811f, 0.25683397f, -0.00836238f, 
    -0.35873091f, 0.24401793f, 0.13899501f, 0.14621644f, -0.00598865f, 0.07505762f, 0.06783330f, -0.02442144f, 
    0.02900800f, -0.04469693f, 0.03381694f, 0.03205788f, 0.13017985f, 0.05659989f, -0.01348415f, 0.11651006f, 
    -0.00452697f, 0.13915974f, -0.11961024f, -0.06269908f, 0.27714828f, -0.38016221f, 0.18641344f, 0.11488529f, 
    -0.22490337f, 0.00944982f, -0.10010770f, -0.08874379f, 0.07250717f, 0.05208883f, -0.12491014f, -0.03849587f, 
    0.05944842f, -0.23336801f, -0.01099391f, -0.00621964f, 0.01072180f, -0.11200605f, 0.02963619f, 0.05360438f, 
    -0.44875520f, -0.19402534f, -0.16761710f, 0.20976219f, -0.00480819f, -0.00461159f, -0.00192355f, -0.02106183f, 
    0.04187085f, 0.17941667f, -0.03754779f, 0.02848894f, 0.01681280f, 0.05365153f, 0.04673784f, 0.15058309f, 
    -0.13771351f, 0.07809563f, 0.06171936f, -0.02519150f, -0.50500107f, -0.02622434f, 0.09125517f, 0.12738782f, 
    0.05984240f, -0.02971303f, 0.06440662f, -0.08724068f, 0.01460426f, 0.00054040f, 0.02090769f, 0.10306100f, 
    0.05658288f, 0.05866814f, -0.15271778f, -0.00004938f, 0.00369559f, 0.06659598f, 0.03131977f, 0.08134797f, 
    0.01119080f, -0.03823285f, 0.14469898f, -0.05059470f, -0.03289810f, 0.13895465f, 0.02153136f, 0.04893920f, 
    -0.04295190f, -0.15038581f, 0.07732705f, 0.09173182f, 0.05144631f, 0.15672782f, -0.05896663f, -0.00777577f, 
    0.02876683f, -0.21300480f, 0.00583490f, -0.13893485f, 0.08289567f, -0.17575276f, -0.02543869f, 0.18566152f, 
    0.00808222f, -0.06317171f, -0.04371680f, -0.02621120f, 0.08539108f, -0.04377820f, -0.05001044f, -0.00340398f, 
    -0.09376234f, -0.00832520f, 0.04533850f, -0.01874496f, 0.00139078f, 0.09533419f, 0.02572633f, 0.04073115f, 
    0.12103956f, -0.20031168f, -0.08180017f, 0.21194871f, -0.03561105f, 0.12732901f, -0.10745549f, -0.14974432f, 
    -0.08476999f, 0.15202606f, -0.03791644f, 0.03629341f, 0.05776324f, 0.05916978f, 0.07061268f, -0.15237845f, 
    -0.05608998f, 0.08743793f, -0.09827977f, 0.01769622f, -0.01096647f, -0.12362862f, -0.08636652f, 0.08539318f, 
    0.13338737f, -0.11298835f, 0.10764638f, 0.06431573f, -0.04692919f, -0.05931099f, -0.01031853f, 0.00526850f, 
    -0.02567373f, -0.05600752f, -0.09594325f, 0.01490849f, 0.03145320f, 0.04525203f, 0.02241750f, 0.06056107f, 
    -0.04481579f, -0.20383194f, 0.06820346f, 0.06183057f, -0.09001016f, 0.06391042f, 0.10429932f, 0.15573804f, 
    0.01356014f, -0.09305480f, 0.02982723f, -0.04676445f, -0.02645470f, -0.02523499f, -0.03781158f, 0.08893598f, 
    -0.01775370f, -0.02678417f, -0.05983035f, -0.00918174f, 0.02911966f, -0.35965025f, -0.29632634f, 0.18512529f, 
    -0.15103267f, 0.10817666f, 0.00091063f, -0.08668443f, -0.04007261f, -0.03991004f, 0.02919424f, -0.05343555f, 
    0.04380655f, 0.08393201f, 0.19011228f, -0.07152158f, -0.00730648f, -0.05135220f, 0.08043559f, -0.04191605f, 
    0.02436786f, -0.15209082f, 0.16020390f, -0.21901715f, -0.07719536f, -0.12327699f, -0.05621653f, -0.06708276f, 
    0.03663580f, 0.13875529f, 0.03704276f, -0.01669003f, 0.24501517f, -0.11337284f, -0.08862846f, 0.06654081f, 
    -0.05258822f, -0.02013744f, 0.08164720f, 0.02852381f, -0.27620128f, -0.30568522f, 0.01106670f, -0.15664724f, 
    -0.36209211f, -0.07902953f, -0.02342018f, -0.06585594f, -0.01972619f, -0.02632074f, -0.02609591f, -0.06075002f, 
    -0.11934561f, 0.07887003f, 0.00445227f, -0.04605369f, 0.06792700f, 0.11614076f, 0.10067017f, -0.08639403f, 
    -0.02961305f, -0.08172188f, 0.28913379f, -0.22313786f, -0.57328111f, 0.02436369f, 0.00625353f, 0.12655212f, 
    -0.10774117f, 0.10344262f, -0.02831557f, -0.05139294f, -0.06887232f, -0.13039139f, -0.08419074f, -0.15297110f, 
    -0.03454610f, -0.06187033f, 0.02033261f, -0.06199365f, -0.03274525f, -0.02899035f, -0.11970214f, 0.19444008f, 
    -0.05535794f, -0.07394750f, -0.03807981f, -0.08383889f, 0.10999927f, -0.06974740f, -0.09792548f, 0.08128317f, 
    -0.05132835f, -0.14467624f, -0.06379908f, 0.01676085f, 0.05119540f, -0.05277502f, 0.14248639f, 0.07797305f, 
    0.41875312f, 0.03396563f, -0.12533526f, -0.33109644f, -0.04624407f, -0.04029715f, 0.04381695f, -0.02728893f, 
    0.19087239f, -0.20657814f, -0.04677954f, 0.09283683f, 0.08269370f, 0.00267042f, -0.03190437f, 0.08281102f, 
    0.15589441f, -0.08008492f, -0.03332545f, -0.14073011f, 0.16006549f, -0.10774495f, 0.02893789f, -0.08439232f, 
    -0.03239825f, -0.03881838f, 0.08426122f, 0.01658109f, -0.04571550f, 0.00181274f, 0.03199372f, -0.06624902f, 
    0.02559309f, 0.07127802f, 0.06039027f, 0.16510840f, 0.03857957f, -0.03657987f, 0.04629597f, 0.05568897f, 
    -0.13930812f, 0.07876596f, -0.03162089f, -0.00633725f, -0.17239064f, -0.03550208f, 0.03465356f, -0.08229777f, 
    -0.11126507f, 0.03656558f, 0.00158005f, 0.04039534f, 0.03882813f, 0.10972112f, 0.16776815f, 0.07678453f, 
    0.03123721f, 0.03708657f, -0.08021089f, 0.00796313f, -0.38437644f, -0.39734906f, 0.42660928f, -0.31338257f, 
    0.12647003f, 0.03244618f, 0.14244482f, 0.02349416f, -0.00637600f, -0.17742977f, -0.05820176f, -0.04562868f, 
    0.03039426f, -0.00984425f, 0.00065461f, 0.04552504f, 0.08091526f, 0.07332923f, -0.18945004f, 0.10181762f, 
    -0.28464314f, -0.03650206f, 0.17638150f, -0.12514210f, 0.04682522f, -0.07546072f, 0.01405440f, 0.04528784f, 
    0.04352168f, -0.06364677f, 0.05171874f, -0.03007045f, 0.02736231f, -0.11300581f, -0.12673455f, -0.03239460f, 
    0.09155832f, 0.08084572f, 0.13373753f, -0.03907778f, 0.16745742f, -0.11372299f, -0.12614745f, 0.17764595f, 
    -0.05934674f, 0.00471275f, 0.01840095f, -0.08159601f, -0.00943713f, 0.15415722f, -0.05425780f, 0.05198127f, 
    0.01938314f, -0.11567879f, 0.05948685f, -0.01069684f, -0.00526984f, 0.03959046f, 0.01388374f, 0.04086035f, 
    0.41950452f, -0.14144662f, -0.00787763f, -0.14074816f, -0.34122580f, 0.01696640f, 0.03529702f, 0.26661199f, 
    -0.04811190f, -0.12137481f, -0.07161550f, -0.09486597f, -0.00946949f, 0.11671671f, 0.13854559f, -0.03887779f, 
    0.09098015f, -0.10274484f, 0.11100771f, 0.11945505f, -0.28511247f, 0.18454899f, 0.09614246f, -0.07053211f, 
    -0.01783440f, 0.12316833f, 0.04327548f, -0.09846884f, 0.01101026f, 0.07270513f, -0.06150789f, 0.01045711f, 
    -0.04010312f, 0.03500231f, -0.02920837f, 0.09615242f, -0.04341128f, 0.06093866f, -0.11670593f, -0.03456143f, 
    0.35084429f, -0.67540127f, 0.26626003f, 0.04158440f, 0.05478524f, 0.00270623f, -0.01418072f, -0.08500104f, 
    0.03181361f, -0.08292481f, 0.01868123f, -0.06897148f, 0.00783243f, 0.04623301f, 0.10144679f, 0.04115835f, 
    -0.02240863f, -0.12587681f, -0.10306359f, -0.02257258f, 0.43923888f, -0.36722666f, 0.11132284f, 0.02354988f, 
    0.33219248f, -0.00779662f, 0.03088640f, -0.02196557f, 0.03061041f, 0.05776457f, -0.00645864f, -0.00126488f, 
    -0.12757598f, 0.02494275f, 0.01381995f, -0.08654559f, -0.06388927f, -0.04258194f, -0.04918886f, -0.03636865f, 
    0.35523948f, -0.06642798f, -0.14325234f, -0.00921545f, 0.03662023f, 0.12043075f, -0.10873301f, 0.05976380f, 
    -0.04399626f, 0.16692406f, -0.05416822f, -0.04116171f, 0.04722749f, 0.08733615f, 0.00651407f, 0.07901732f, 
    0.07146236f, -0.01529230f, 0.02380353f, -0.01429086f, -0.26297948f, 0.39818063f, 0.35494962f, 0.21766192f, 
    0.06186803f, 0.03260043f, 0.04860254f, 0.00793477f, -0.02718693f, -0.03522732f, -0.07452999f, -0.03610126f, 
    0.08760986f, 0.06518023f, 0.23674190f, -0.00401179f, 0.02588545f, 0.05954964f, -0.17640898f, 0.00471769f, 
    -0.35452211f, -0.28938541f, 0.09653543f, -0.03952811f, -0.04889850f, 0.12864423f, 0.04393851f, 0.03531033f, 
    0.02163714f, 0.04570359f, 0.04633205f, 0.03534005f, 0.03433089f, -0.01706657f, -0.05580829f, 0.04816721f, 
    -0.00208633f, -0.06265110f, 0.03377528f, -0.00209583f, -0.59328091f, -0.67792869f, 0.10000388f, -0.00516507f, 
    -0.00386801f, -0.03107884f, 0.00345466f, 0.06060105f, -0.14896123f, 0.03976817f, 0.07598545f, 0.04127750f, 
    0.00314032f, 0.06647263f, 0.11315980f, 0.01738768f, -0.05517064f, -0.18879209f, -0.16860437f, -0.07325576f, 
    -0.02227869f, -0.21200490f, -0.02781790f, -0.00002806f, -0.05185480f, 0.02095792f, 0.05717140f, -0.03064954f, 
    -0.03214326f, 0.00737780f, 0.06749537f, -0.00400603f, -0.00810209f, -0.13570482f, -0.00452107f, -0.10909058f, 
    0.01718458f, 0.10105095f, 0.11830515f, 0.04785640f, -0.44357762f, -0.40725794f, -0.26231700f, -0.21531847f, 
    -0.06632654f, 0.05081512f, 0.05003905f, -0.10832901f, -0.10085157f, 0.00144921f, 0.03732802f, -0.09512528f, 
    -0.08221709f, 0.05112393f, 0.05829097f, 0.04095142f, -0.05613746f, 0.11925792f, 0.06354254f, 0.05093421f, 
    -0.71617806f, -0.37401244f, 0.03904652f, -0.10062272f, -0.25573507f, 0.09997980f, -0.01729870f, 0.00807594f, 
    -0.09630116f, 0.09510123f, -0.02710210f, -0.04607448f, -0.02650981f, 0.09649607f, 0.07753476f, -0.08552806f, 
    -0.07681465f, -0.00167021f, 0.05864394f, -0.05127795f, 0.33636105f, 0.18765804f, 0.14591578f, -0.00761011f, 
    0.04908990f, 0.03225542f, -0.01042935f, 0.11880576f, 0.02874847f, 0.03538966f, 0.01623868f, -0.04157910f, 
    0.02891740f, -0.06209570f, -0.03607535f, 0.07288974f, 0.09831029f, 0.05538816f, -0.13005497f, 0.02006342f, 
    -0.34552795f, -0.37027052f, -0.22366218f, -0.05520661f, -0.25195152f, 0.07187171f, 0.07886096f, 0.02879412f, 
    -0.08959349f, -0.00914802f, 0.19346537f, -0.00886434f, -0.01830173f, -0.00503703f, 0.03660664f, 0.05195443f, 
    0.04563155f, 0.10319604f, 0.15387803f, 0.06314342f, -0.08577909f, 0.03185057f, -0.19380555f, 0.06777050f, 
    0.08832666f, 0.01046748f, 0.01282920f, -0.12904058f, 0.05198513f, 0.08251382f, -0.00091037f, -0.03261784f, 
    -0.08250868f, 0.04440845f, 0.08629718f, 0.03333941f, 0.11878603f, 0.14875090f, -0.01536058f, 0.06168174f, 
    0.32516536f, 0.02259693f, -0.17132320f, 0.14926864f, -0.15911746f, -0.16683513f, -0.02363133f, 0.01234610f, 
    0.11297879f, 0.01714328f, -0.05800612f, -0.05227561f, -0.02613031f, -0.24824341f, -0.10772555f, -0.07632248f, 
    0.07583617f, -0.18919988f, -0.04014618f, -0.01143612f, 0.08728687f, 0.04615079f, -0.09407783f, 0.09335741f, 
    -0.12530454f, -0.03858710f, 0.04808075f, -0.04190082f, -0.04937955f, 0.10664507f, 0.11079698f, 0.06908507f, 
    -0.02555062f, -0.02535830f, 0.13813296f, 0.05995768f, 0.06343731f, 0.03974881f, 0.10311459f, -0.02331927f, 
    -0.02625298f, -0.02188685f, -0.21687743f, -0.12484480f, -0.00704451f, -0.03251555f, 0.02187389f, -0.13706417f, 
    0.05705114f, -0.04927806f, 0.06325205f, -0.05315321f, 0.05687626f, -0.12776372f, 0.10736378f, -0.10406228f, 
    0.01892611f, 0.13162826f, 0.01774651f, 0.04475400f, 0.12774950f, 0.11421251f, 0.08503165f, -0.00282832f, 
    -0.03511723f, 0.09192502f, 0.05333439f, 0.02010218f, -0.01165318f, 0.02318712f, -0.05805043f, 0.03916258f, 
    -0.04234780f, 0.03672536f, -0.02137209f, 0.02090731f, 0.00417256f, -0.01524193f, -0.23717877f, 0.00682793f, 
    0.22616608f, 0.13310537f, 0.07039957f, -0.01288638f, -0.11924868f, -0.14188339f, -0.20166251f, 0.18299602f, 
    -0.00282158f, -0.02003762f, -0.03407844f, 0.03061588f, -0.09420837f, -0.03887537f, -0.08569678f, 0.01050884f, 
    0.08562620f, 0.09581674f, 0.00874016f, -0.05809361f, 0.31975707f, 0.16220188f, 0.00640390f, -0.00785377f, 
    -0.01446102f, 0.07667434f, 0.03309343f, 0.10537735f, 0.05139424f, 0.01679916f, -0.04306402f, -0.04182041f, 
    0.07094745f, -0.00146350f, 0.01440624f, 0.10885864f, 0.04916983f, -0.17784411f, -0.18635808f, 0.11809084f, 
    -0.48165599f, -0.30182558f, -0.05755109f, -0.08164966f, 0.02106374f, 0.09725282f, 0.08271822f, -0.06011561f, 
    -0.08614489f, -0.07231085f, -0.01480149f, 0.00307250f, -0.00363170f, 0.15079924f, 0.05426584f, 0.06256637f, 
    0.06974357f, 0.10152338f, 0.04618412f, 0.04592530f, 0.09380613f, -0.03510685f, -0.03602870f, -0.13273808f, 
    0.09710719f, 0.01318246f, 0.02579980f, -0.01618600f, -0.01825101f, 0.00339233f, -0.08409663f, -0.08193506f, 
    -0.03618264f, -0.10519286f, -0.04623788f, -0.07816644f, 0.10673050f, 0.12003294f, 0.06953113f, 0.14534855f, 
    -0.10241956f, 0.18490852f, 0.04859895f, -0.02778987f, 0.07972880f, 0.05467417f, -0.03136779f, 0.02166842f, 
    0.06927541f, 0.07626005f, -0.00449516f, 0.00965541f, 0.02888390f, 0.06172532f, -0.02552451f, 0.07542574f, 
    -0.05291010f, 0.06120838f, -0.13368271f, 0.00740911f, -0.37196171f, -0.16631998f, 0.20613490f, -0.03230659f, 
    -0.27000400f, 0.05933713f, 0.05035547f, 0.04247672f, 0.01939579f, 0.14788619f, -0.03406230f, 0.07220408f, 
    -0.02447048f, 0.00474607f, 0.03701759f, 0.03642524f, -0.02924306f, -0.04069464f, -0.17797810f, -0.07864996f, 
    -0.56053615f, 0.00977572f, -0.02279117f, -0.24719273f, -0.27570653f, 0.20178549f, 0.00643034f, 0.02692504f, 
    -0.08481919f, 0.02563584f, -0.10006515f, 0.02555318f, 0.09753983f, 0.27872616f, -0.01154127f, 0.03269864f, 
    -0.01583460f, 0.03601820f, -0.13778369f, -0.02696776f, 0.02472561f, 0.12289165f, 0.06207518f, -0.12277650f, 
    -0.03055800f, 0.00347856f, 0.10767803f, 0.07195742f, -0.00784701f, 0.00139683f, -0.06007847f, -0.02443901f, 
    0.03112709f, -0.00924809f, 0.02309113f, 0.07703195f, 0.13228282f, 0.02750828f, -0.10595123f, 0.08874281f, 
    -0.48269433f, -0.25449666f, 0.16233465f, -0.01981376f, -0.06417160f, 0.09415997f, 0.06588136f, 0.02328495f, 
    -0.08047242f, 0.14008389f, -0.10355113f, 0.02071094f, -0.02192678f, -0.02036606f, 0.06344518f, -0.15776573f, 
    0.05296768f, 0.24861997f, 0.08041478f, 0.06855562f, 0.21291594f, 0.08047383f, 0.11278939f, -0.02177412f, 
    0.03989751f, 0.10266577f, 0.03461730f, 0.06967661f, -0.05579040f, 0.04391618f, -0.03206395f, -0.04035747f, 
    0.04501665f, -0.01461403f, -0.02421587f, -0.01428883f, 0.02533713f, -0.23587888f, -0.10098312f, -0.06409238f, 
    -0.13462266f, -0.18451156f, 0.05974281f, 0.08462299f, 0.08407786f, 0.11376045f, 0.07617594f, 0.04776882f, 
    0.00326878f, 0.00636882f, 0.01399210f, -0.07237036f, 0.05441497f, 0.00016196f, -0.01430515f, -0.06194567f, 
    -0.07785717f, -0.18431838f, -0.10047787f, -0.02441739f, -0.41277006f, -0.14985345f, -0.27725878f, 0.04467741f, 
    0.00773194f, 0.02886290f, 0.03824824f, -0.08608920f, 0.00533474f, -0.04762828f, 0.09435958f, 0.11454897f, 
    0.00397977f, -0.06632918f, 0.16081806f, 0.03303584f, -0.02033398f, -0.00991789f, 0.00982211f, -0.07829057f, 
    0.16754751f, 0.00782241f, 0.11274207f, 0.01060994f, 0.01852388f, 0.13036278f, 0.11729593f, 0.07728446f, 
    0.07613297f, -0.13667245f, -0.00623190f, 0.05235170f, 0.09127527f, 0.03466409f, 0.08868616f, 0.01428978f, 
    0.05256487f, -0.09819230f, 0.06355170f, -0.05547870f, 0.28490227f, 0.02443124f, -0.02876213f, 0.03787914f, 
    -0.04785488f, -0.16075763f, -0.14785290f, -0.11219188f, -0.01985963f, -0.11067112f, -0.03139985f, 0.03831402f, 
    -0.13165365f, -0.02220105f, -0.09068412f, -0.17185391f, 0.03742214f, -0.06725804f, -0.18503363f, -0.04678508f, 
    -0.56243175f, -0.33532789f, -0.05481514f, -0.05190941f, -0.22419730f, 0.12094866f, -0.01285414f, -0.10496949f, 
    -0.09089137f, 0.04673568f, 0.01126824f, 0.03260732f, -0.00691024f, 0.04054613f, 0.09800220f, -0.00507277f, 
    0.03783968f, 0.12031430f, -0.05583714f, 0.14948149f, 0.10087631f, 0.17090483f, -0.01847276f, 0.12303454f, 
    -0.01646650f, 0.08817323f, -0.01042170f, 0.08917580f, -0.01470379f, 0.06686750f, 0.08373848f, -0.01771513f, 
    0.06130365f, -0.01013162f, 0.03313562f, 0.02673583f, -0.06250477f, -0.08445524f, 0.13621333f, 0.06062571f, 
    -0.50658816f, 0.08742068f, -0.30076966f, -0.06884453f, 0.13272947f, 0.12239371f, 0.04623102f, -0.06896225f, 
    0.00419771f, 0.11137199f, 0.02517022f, 0.05053093f, 0.13115394f, -0.08019029f, 0.10113702f, 0.05032315f, 
    -0.01653977f, 0.06321736f, -0.13864215f, 0.07669228f, 0.05092434f, 0.08868699f, -0.18782464f, -0.01187977f, 
    0.05980363f, -0.11641419f, -0.00793864f, -0.02430612f, 0.10332073f, 0.05899418f, 0.08628689f, -0.01189962f, 
    0.03017518f, -0.01549572f, 0.01376600f, 0.04221937f, 0.06798740f, 0.08287103f, -0.07915979f, 0.08403724f, 
    0.27809089f, 0.03844430f, -0.08996742f, 0.06327314f, 0.09967319f, -0.12761369f, -0.07153215f, -0.06826557f, 
    0.03366354f, -0.05222739f, 0.03516099f, 0.05626312f, -0.11243536f, -0.14356281f, -0.10064476f, -0.11265356f, 
    -0.08050720f, 0.03126026f, -0.15230018f, 0.01045168f, -0.37495282f, -0.29714438f, -0.03548179f, 0.03886073f, 
    0.27287406f, 0.06254967f, 0.05736663f, -0.00609236f, -0.05561729f, -0.11028552f, 0.08666848f, -0.13334846f, 
    -0.03247371f, -0.04890594f, -0.02999170f, -0.00511204f, -0.05523027f, -0.17017335f, 0.17715725f, 0.00715849f, 
    0.06195420f, 0.09048226f, -0.21371901f, 0.00746960f, -0.01307086f, 0.13488497f, 0.01759865f, -0.08496838f, 
    -0.00589977f, 0.00158465f, -0.00621333f, 0.12674958f, -0.06532497f, -0.02902624f, 0.09427800f, 0.01743412f, 
    0.12428245f, 0.12245666f, -0.06109126f, 0.02927990f, -0.27668244f, 0.48833412f, -0.03933215f, -0.03024101f, 
    0.29754069f, 0.19738561f, -0.10896705f, -0.01894805f, 0.12607789f, -0.00460559f, 0.08824665f, 0.14599310f, 
    -0.00581431f, -0.00737150f, 0.06111844f, -0.03123692f, 0.25337294f, 0.02722347f, -0.19634634f, 0.06200939f, 
    -0.40453255f, -0.40371376f, -0.10367470f, -0.19228919f, -0.21658488f, 0.05805257f, 0.01187022f, 0.16143118f, 
    0.03839307f, 0.10706984f, -0.07522102f, 0.05741951f, -0.01588649f, 0.02966781f, -0.09171301f, -0.04033546f, 
    -0.03546286f, -0.05091714f, -0.01264540f, -0.04876165f, 0.06108239f, -0.09297938f, -0.20812678f, -0.05138860f, 
    -0.34904933f, 0.08285624f, 0.04226331f, 0.04597244f, -0.01997786f, 0.05686771f, 0.01875744f, -0.04763712f, 
    -0.01555725f, -0.01494343f, 0.06683048f, -0.07784911f, -0.03774100f, -0.09372142f, -0.08813594f, 0.01745665f, 
    0.29687849f, -0.20411217f, -0.09906947f, -0.12143947f, -0.03489308f, -0.01565764f, -0.04503208f, 0.04178651f, 
    0.07560121f, 0.05745111f, 0.05540008f, 0.00490688f, 0.05486083f, 0.01321188f, -0.07217919f, 0.10751127f, 
    0.06102503f, 0.00097451f, 0.06026301f, 0.00821480f, -0.16582848f, -0.03330856f, -0.07808089f, -0.05629588f, 
    0.05334533f, -0.14821814f, 0.09991953f, 0.10792386f, 0.02686176f, -0.10197829f, 0.09466384f, -0.10840615f, 
    -0.08789926f, 0.08248559f, 0.08322243f, -0.01730194f, 0.04315804f, -0.02045330f, 0.19403307f, -0.04170594f, 
    0.16454218f, -0.10099966f, 0.02924211f, 0.02667628f, -0.18257470f, 0.00015710f, 0.06615634f, 0.02336262f, 
    0.06127480f, 0.06008668f, 0.06780525f, 0.05901085f, -0.03642309f, -0.04940213f, -0.08127643f, -0.12317633f, 
    -0.08048233f, -0.05818051f, -0.07789744f, 0.02565270f, 0.14804849f, 0.04025405f, -0.16750707f, 0.04151455f, 
    -0.17835964f, -0.05712668f, 0.21160626f, 0.03085621f, 0.02631456f, 0.02979123f, -0.02324662f, -0.06641337f, 
    -0.00035327f, -0.09916513f, 0.08380945f, 0.08848120f, -0.02009731f, 0.00061781f, -0.03634262f, 0.03347639f, 
    0.11974929f, -0.08990540f, -0.12447374f, 0.16657408f, -0.01333410f, -0.00888179f, -0.06064196f, 0.16675735f, 
    -0.16189408f, -0.03782074f, -0.08166926f, -0.04983307f, 0.09262428f, -0.08548273f, -0.08970678f, 0.01774473f, 
    -0.02582366f, 0.00723090f, -0.08656210f, -0.14518158f, 0.26329389f, 0.03506738f, 0.02877847f, 0.01843530f, 
    -0.13703181f, -0.03634670f, 0.01792737f, -0.00944413f, -0.11872419f, 0.07583533f, -0.07686838f, -0.07377573f, 
    0.12958241f, 0.01487658f, -0.20375831f, -0.03823559f, -0.09120765f, -0.06226691f, 0.00971554f, -0.08334188f, 
    -0.72842544f, -0.24062365f, -0.01211123f, -0.08434962f, -0.08063140f, 0.02193809f, -0.01663391f, -0.03211362f, 
    0.09554251f, 0.08490963f, -0.10035280f, 0.04080334f, 0.07449709f, -0.12755685f, -0.04477641f, -0.10814265f, 
    0.03267081f, -0.07527547f, -0.16066073f, -0.05158932f, 0.07163471f, 0.17465591f, -0.03443666f, -0.20630820f, 
    0.02957345f, -0.21046819f, -0.09670413f, -0.00265175f, -0.11036368f, -0.11538954f, 0.07274553f, 0.03193237f, 
    0.01751943f, -0.02620441f, -0.00600408f, -0.00976436f, 0.00350510f, -0.05121261f, 0.08227986f, 0.00566161f, 
    0.02165673f, -0.11408938f, 0.11688746f, -0.08464615f, 0.04450162f, -0.05461916f, 0.07531628f, 0.07571968f, 
    -0.02043203f, -0.14405613f, -0.03245746f, -0.19433080f, 0.07901645f, 0.03271585f, -0.14457861f, -0.16276374f, 
    -0.15522163f, 0.00266977f, -0.16389336f, -0.12638158f, -0.33282754f, 0.17407167f, -0.07512080f, -0.14919639f, 
    0.23848779f, -0.07497905f, -0.11810143f, 0.01889122f, 0.02828828f, -0.11229026f, 0.04925640f, -0.08901022f, 
    -0.08154363f, -0.03869909f, 0.09180467f, 0.09731330f, -0.04422255f, -0.00493747f, 0.15197179f, 0.02753838f, 
    -0.05211663f, 0.33220693f, -0.12192959f, 0.08995728f, -0.23880792f, 0.06559204f, 0.04386286f, 0.00232274f, 
    0.06779571f, 0.01139894f, 0.03789016f, 0.02643594f, -0.02872979f, 0.01486218f, 0.07483495f, -0.02062193f, 
    0.02933739f, 0.00464194f, -0.06773854f, 0.06630579f, -0.59445435f, 0.28995755f, -0.11921917f, -0.11629822f, 
    0.02620338f, 0.10209431f, 0.14235771f, 0.17105517f, 0.01155484f, 0.18472604f, -0.06406169f, -0.02653534f, 
    0.00989332f, 0.04107819f, 0.05450682f, -0.03260328f, -0.01120814f, -0.15847893f, -0.05760081f, -0.23924951f, 
    0.37329921f, -0.03194895f, -0.19484986f, -0.01584757f, 0.15875900f, -0.06896272f, 0.11144820f, -0.04119017f, 
    0.08443891f, -0.00733354f, 0.07936396f, -0.01848423f, -0.09265522f, 0.09093344f, 0.02764574f, 0.05343820f, 
    0.03416991f, 0.00416513f, 0.13335820f, -0.01691752f, 0.42779002f, 0.16960517f, -0.16333102f, -0.19947694f, 
    0.22422753f, 0.03127263f, -0.09972887f, -0.03224659f, -0.04935741f, -0.06689904f, 0.08553729f, 0.01112847f, 
    -0.05879060f, 0.01447044f, -0.16648297f, -0.03300268f, -0.00161584f, 0.01113768f, 0.05327034f, 0.02356085f, 
    0.55492699f, 0.22703405f, -0.30190238f, -0.30300680f, 0.07469441f, 0.11042336f, 0.02872879f, -0.04043446f, 
    0.08640460f, -0.02953555f, 0.14737889f, 0.03782142f, -0.01477789f, -0.00990187f, 0.04560430f, 0.06461850f, 
    -0.07034502f, -0.05286049f, 0.04514841f, 0.05631721f, -0.30276325f, 0.28417790f, 0.04706616f, -0.03153359f, 
    0.05406116f, -0.05365554f, -0.04419304f, 0.11450291f, -0.20910099f, -0.06631333f, -0.03793253f, 0.05804563f, 
    0.09418105f, -0.03449870f, -0.10941750f, -0.07980229f, 0.02926770f, -0.05463998f, 0.00767351f, -0.12368964f, 
    0.18111488f, -0.45156309f, 0.05044472f, -0.22793575f, -0.04197521f, 0.04560974f, 0.07556097f, -0.02095320f, 
    0.13964526f, 0.09286520f, 0.01506191f, -0.03837479f, 0.04271756f, 0.02659283f, 0.03999088f, 0.05847968f, 
    0.03133576f, -0.07852706f, 0.03961387f, -0.09036767f, 0.15525565f, 0.00125631f, -0.05499784f, -0.08149646f, 
    0.13678473f, -0.08960284f, -0.19353175f, 0.03179003f, 0.00668517f, -0.03284671f, 0.01655283f, 0.07918286f, 
    -0.01489981f, 0.01214875f, 0.06056619f, 0.13660917f, -0.02192390f, 0.05390896f, 0.09268605f, 0.03393378f, 
    -0.11758632f, 0.17333338f, -0.06870473f, -0.04105115f, 0.17429233f, 0.00393514f, -0.16130640f, 0.04677455f, 
    -0.10259850f, -0.11605647f, 0.07556614f, 0.14582901f, 0.04184501f, 0.02103417f, 0.04038125f, 0.06738007f, 
    0.12729737f, -0.08853181f, -0.03195181f, 0.02757057f, -0.02666369f, -0.27389032f, -0.16272637f, 0.16355105f, 
    -0.11421434f, 0.06417125f, 0.08094802f, 0.01960507f, -0.00575836f, -0.08600836f, 0.03569478f, -0.08549961f, 
    -0.02894117f, 0.10201123f, -0.07518391f, -0.03548006f, 0.02262342f, -0.05890848f, -0.18567303f, -0.09923702f, 
    0.11587241f, 0.02366819f, -0.12014046f, -0.04801384f, 0.12126257f, -0.02118551f, 0.03843720f, -0.08635252f, 
    -0.00638570f, 0.07087637f, 0.04182201f, 0.15831204f, -0.05211115f, 0.04507764f, -0.05009421f, 0.04738363f, 
    -0.10135616f, 0.07735987f, 0.06658382f, 0.06045396f, -0.15327683f, 0.12063149f, 0.08973357f, -0.04483099f, 
    -0.09026197f, 0.06718078f, -0.05777041f, -0.06339598f, -0.01494324f, -0.12958071f, -0.07997304f, -0.02538946f, 
    0.02749871f, -0.07049797f, -0.04486837f, -0.01572980f, -0.02638170f, -0.02724675f, -0.03069853f, 0.00505492f, 
    0.10003705f, 0.02419723f, -0.20658845f, -0.27011541f, 0.16526975f, 0.07342172f, -0.05418323f, 0.02331259f, 
    0.08787731f, 0.14934888f, 0.09463733f, -0.04496843f, 0.09788832f, 0.00915640f, 0.02611668f, 0.10173835f, 
    -0.02465535f, -0.00852617f, -0.04033006f, -0.08982487f, 0.20974834f, -0.33516911f, 0.11091917f, 0.18270449f, 
    -0.04249546f, -0.00023067f, -0.00038370f, -0.12689111f, -0.00505196f, -0.06098165f, 0.00775673f, -0.10548931f, 
    0.02194491f, 0.07094395f, -0.11085371f, -0.07022798f, -0.00870401f, -0.00969044f, -0.07861818f, -0.09979855f, 
    -0.42449456f, 0.13803446f, -0.00381837f, 0.07126389f, 0.02460257f, -0.09165939f, -0.01896761f, -0.05092242f, 
    0.06017986f, -0.02699305f, 0.07235576f, -0.04550208f, 0.10761064f, 0.03784985f, -0.05579272f, 0.12029152f, 
    -0.04691878f, -0.05966796f, 0.03824385f, 0.03272066f, -0.34484404f, 0.28896904f, 0.02063197f, 0.07346378f, 
    0.05937026f, -0.03659366f, 0.02106798f, -0.01564462f, -0.07789680f, 0.11125778f, -0.15064996f, 0.13446523f, 
    0.09640393f, 0.00120729f, -0.01382282f, 0.05175981f, -0.02727934f, 0.01765220f, -0.04429727f, -0.04456444f, 
    -0.51426625f, 0.09489127f, -0.01412340f, -0.08743165f, 0.01834428f, -0.01235649f, -0.03167428f, 0.00025165f, 
    0.10762152f, -0.05367080f, -0.10147227f, 0.00651997f, 0.09892906f, 0.01611409f, 0.04699077f, -0.08411505f, 
    -0.12878934f, 0.02748970f, -0.14630568f, 0.07256339f, 0.02578431f, 0.17973080f, -0.17533033f, 0.13124281f, 
    0.16897593f, 0.18444917f, -0.16805695f, -0.00354353f, -0.06242653f, -0.04137262f, 0.00803995f, 0.05466005f, 
    0.03044411f, -0.00555385f, -0.05339867f, -0.09679721f, 0.12086441f, 0.01030853f, -0.09622449f, 0.06704541f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06065771f, 0.01681996f, -0.07246578f, -0.00073535f, 0.04208013f, 0.05343455f, 0.01160222f, -0.05693613f, 
    -0.02085991f, 0.01506898f, 0.09739128f, -0.00924923f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
