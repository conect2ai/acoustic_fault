#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.42009553f, 0.66542727f, 0.48075387f, 0.48980001f, 0.36360770f, 0.68287855f, -0.23545176f, -0.23429421f, 
    0.12615369f, -0.65658617f, -0.89846283f, -0.57504880f, 0.70847577f, 0.69291830f, 0.65478367f, -0.43591848f, 
    0.17113437f, -0.40229192f, -0.87894422f, 0.37555552f, 0.21930727f, 0.41445237f, 0.89254063f, 0.40966853f, 
    -0.14347532f, 0.10110797f, 0.49954468f, 0.10723685f, 0.85700601f, -0.98939413f, 0.02801801f, -0.68394125f, 
    -0.23737946f, 0.46260282f, 0.01760729f, 0.44222447f, -0.71739799f, -0.62901258f, -0.28650984f, 0.08597936f, 
    -0.55211926f, 0.40484932f, -0.23447293f, -0.52440399f, -0.32108083f, 0.89209336f, 0.57658988f, 0.65175557f, 
    -0.47870487f, 0.44349417f, -0.26586130f, 0.00215044f, -0.06292576f, 0.12587449f, 0.06083124f, -0.76381546f, 
    -0.51047093f, -0.41994441f, -0.53560477f, -0.38074088f, -0.41481087f, 0.48370248f, 0.40061960f, 0.95276034f, 
    0.72438073f, 0.39933828f, -0.11142637f, -0.94449407f, -0.31785727f, 0.48996097f, 0.01284223f, -0.29555440f, 
    -0.59040111f, 0.18432844f, 0.05507826f, -0.92737484f, -0.23777099f, -0.96580100f, -0.02091085f, -0.33696103f, 
    0.10519071f, 0.16415747f, -0.17296489f, -0.89160621f, -0.25268131f, -0.53326148f, -0.29137614f, -0.57282305f, 
    0.00399730f, -0.38313562f, 0.74196804f, -0.21867672f, 0.53935617f, 0.88924015f, 0.12010234f, 0.40959239f, 
    -0.05696383f, 0.06877472f, -0.33464378f, 0.02327104f, 0.83690441f, -0.21721666f, -0.49407783f, -0.11241564f, 
    -0.37401697f, 0.13088447f, 0.06459374f, -0.44652155f, -0.30366865f, -0.74525243f, 0.02717252f, 0.79912913f, 
    0.70717448f, -0.44289014f, 0.24604747f, -0.16183454f, 0.15433048f, 0.75874496f, -0.14855915f, -0.52763367f, 
    -0.58853847f, 0.56309265f, -0.48933345f, 0.21867287f, 0.63043696f, 0.50977439f, -0.20029609f, -0.61283058f, 
    -0.96107978f, 0.08107298f, -0.53302228f, -0.29217741f, 0.23828875f, 0.07413641f, 0.30164093f, -0.65104878f, 
    0.05949150f, 0.27645156f, 0.77100533f, -0.45248321f, -1.03896606f, -0.50063902f, -0.16128445f, 0.13441853f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.52424747f, -0.10586166f, 0.16250633f, -0.12152799f, -0.20091596f, -0.06629304f, -0.12967877f, -0.07771337f, 
    0.51409173f, -0.05381324f, -0.29522339f, 0.32500860f, 0.10088527f, -0.30323181f, -0.00175313f, -0.53582299f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03311953f, -0.29256386f, -0.22260502f, -0.04965518f, 0.23722374f, 0.18280883f, -0.04832616f, -0.00120272f, 
    -0.11555076f, -0.08183942f, -0.00120837f, 0.02869817f, 0.02262566f, 0.05634322f, 0.00172604f, -0.02863021f, 
    -0.11714992f, 0.00349758f, -0.28951886f, -0.13287058f, -0.01493258f, 0.00800187f, 0.15356947f, 0.00896922f, 
    -0.09315621f, 0.17380804f, 0.09872001f, 0.04754756f, 0.22503650f, -0.03169447f, 0.31534258f, 0.03527372f, 
    -0.13849275f, 0.12831478f, 0.03352270f, -0.11894947f, 0.10337787f, 0.09518780f, 0.01536517f, -0.14244442f, 
    0.04324298f, 0.05290274f, -0.11317945f, 0.01983947f, -0.05861918f, 0.47776365f, 0.27549094f, -0.08427259f, 
    0.21518257f, 0.05271389f, 0.06987155f, 0.17323719f, -0.11070911f, 0.09002887f, -0.13100164f, 0.01763410f, 
    -0.26177362f, -0.06794252f, -0.26720849f, 0.00479036f, 0.30356291f, 0.13625230f, -0.11013205f, 0.78601545f, 
    0.05876235f, -0.08338249f, 0.19771543f, -0.16348903f, 0.06596630f, -0.06082513f, 0.13239774f, 0.06705703f, 
    -0.36919606f, 0.17865065f, -0.32084450f, -0.10366923f, 0.00473994f, 0.04291162f, -0.03411167f, -0.11643372f, 
    -0.09002615f, 0.17429572f, 0.28084368f, 0.00967254f, 0.07057264f, -0.10974850f, -0.05237313f, -0.13496287f, 
    -0.15126713f, 0.05650793f, -0.38754547f, -0.63719499f, 0.00229331f, 0.12394284f, 0.16722561f, -0.01511982f, 
    -0.06539727f, 0.03323924f, -0.05098535f, 0.29875535f, -0.10527068f, -0.15870336f, -0.09337604f, 0.13487662f, 
    0.01274685f, 0.05496000f, 0.02962022f, -0.00406951f, -0.17770810f, -0.15585361f, 0.06554312f, 0.00491596f, 
    0.02396584f, 0.17005353f, -0.18578288f, 0.13557637f, 0.01879113f, 0.11215478f, -0.01105618f, -0.10506321f, 
    0.04826111f, -0.01609483f, -0.14038990f, -0.07428588f, -0.02418530f, -0.12313313f, 0.13586082f, 0.07483443f, 
    -0.06351498f, -0.09560888f, 0.14863628f, -0.12631507f, 0.04305098f, 0.14807254f, -0.10901247f, -0.15544842f, 
    -0.08305497f, 0.10624005f, -0.21497090f, 0.18407463f, 0.22798985f, 0.10319299f, -0.08345106f, 0.06541886f, 
    0.09028751f, 0.07273425f, 0.00382094f, -0.00781356f, -0.08873174f, 0.08365466f, -0.19673511f, 0.23664300f, 
    0.04431007f, 0.37908050f, 0.39834380f, -0.02466439f, -0.16179852f, 0.09895848f, -0.15123880f, 0.15973569f, 
    0.13283557f, -0.05732152f, -0.13179256f, 0.27413702f, 0.06794691f, 0.04583476f, -0.05171967f, -0.12781772f, 
    0.09295136f, -0.03525819f, 0.10039981f, -0.00101981f, -0.17365496f, -0.05679690f, 0.14552383f, -0.10610910f, 
    0.12859027f, 0.14493565f, -0.27027410f, 0.00613392f, 0.13336514f, 0.39779508f, 0.14657900f, 0.09953642f, 
    -0.07248597f, 0.12694918f, -0.09210054f, 0.27657661f, -0.01448125f, 0.09553626f, -0.22412093f, -0.14038567f, 
    0.09138338f, -0.11329567f, 0.02613790f, -0.13872708f, 0.08780970f, 0.04749908f, -0.18120818f, -0.26180372f, 
    0.04258552f, 0.08499494f, 0.19122437f, -0.00171146f, 0.14235617f, -0.06318139f, 0.10350782f, -0.27140057f, 
    -0.15443601f, 0.06578907f, -0.01275458f, -0.10459307f, 0.12672669f, -0.10474390f, 0.05583027f, 0.06349104f, 
    0.10478130f, -0.31742349f, -0.33641455f, 0.10827527f, -0.06503160f, 0.27509403f, -0.16961956f, -0.01419940f, 
    -0.14312719f, -0.23089336f, -0.21036340f, 0.13047835f, 0.15548161f, -0.11775631f, -0.00199668f, -0.26024312f, 
    0.09369178f, -0.15202402f, -0.07314089f, -0.00589136f, 0.37050071f, 0.08449853f, -0.04338781f, -0.25653020f, 
    -0.01367546f, 0.02235649f, 0.19218916f, -0.20249760f, -0.13998403f, -0.10659456f, 0.07543546f, -0.22376041f, 
    0.00787089f, -0.01544318f, 0.00190272f, -0.08436841f, 0.14090192f, 0.27131560f, 0.04745794f, -0.07036530f, 
    0.01958815f, -0.12395372f, 0.13443279f, 0.03002076f, -0.14210348f, 0.24836983f, -0.23532905f, -0.02597102f, 
    0.09968235f, -0.14902423f, -0.04797425f, -0.00395219f, -0.09918877f, -0.06731424f, 0.08459139f, 0.09597988f, 
    -0.02028972f, -0.08408832f, -0.03079287f, 0.02007285f, 0.06063158f, 0.13296248f, -0.21008992f, -0.24039344f, 
    -0.27469769f, -0.14515287f, 0.00373287f, 0.23689216f, 0.05660878f, -0.05939642f, 0.12540677f, 0.01775563f, 
    -0.37819245f, -0.16422185f, 0.09623256f, 0.21053168f, 0.21819451f, 0.01379098f, -0.09076286f, 0.01711560f, 
    -0.03314733f, 0.24809457f, 0.38151872f, -0.02822918f, -0.02349491f, -0.03745200f, -0.14461182f, 0.02230886f, 
    0.16916876f, -0.03986653f, 0.09794033f, 0.20297071f, -0.01858343f, -0.12544577f, -0.16775586f, 0.06742601f, 
    0.04606714f, 0.04731944f, 0.12977424f, 0.46330979f, -0.10876234f, -0.36217710f, -0.07138146f, -0.02863138f, 
    -0.09380995f, 0.00774320f, 0.01037123f, -0.01925171f, -0.37248716f, 0.23942886f, -0.21937926f, 0.07366047f, 
    0.13522275f, 0.21661621f, -0.22083612f, -0.01124051f, -0.00173282f, -0.46111366f, -0.67515451f, 0.02506398f, 
    0.05422234f, 0.06214427f, 0.00693427f, -0.11716622f, 0.17421404f, 0.18441172f, 0.35126522f, -0.03407528f, 
    0.20901321f, -0.13126411f, -0.26232669f, 0.01731506f, 0.22419368f, -0.14946441f, -0.04908798f, 0.31103930f, 
    -0.35986775f, 0.03892904f, 0.16587847f, -0.07987814f, 0.08390763f, -0.01078915f, 0.07890049f, 0.12485006f, 
    0.05059290f, 0.06964431f, 0.17455415f, 0.09362834f, 0.11280163f, 0.21740153f, -0.04759542f, -0.01758545f, 
    0.05415312f, 0.00171545f, 0.19898055f, -0.02627143f, -0.02128725f, 0.01541920f, -0.16921622f, -0.13658835f, 
    -0.03435239f, -0.14254154f, -0.38998252f, -0.43252274f, -0.05576991f, 0.02323036f, 0.17571501f, 0.10669965f, 
    0.07813302f, 0.04236245f, 0.04904213f, 0.18036005f, -0.24101517f, -0.13986152f, 0.06146128f, -0.05445773f, 
    0.06781423f, 0.15423849f, 0.15905936f, -0.19169070f, -0.22839086f, -0.02065449f, -0.07710966f, -0.01550460f, 
    0.22215395f, -0.12507276f, -0.05947888f, 0.16728136f, 0.15658513f, -0.09644277f, -0.09497704f, -0.03209292f, 
    0.04899907f, -0.33537689f, 0.12164224f, 0.04154503f, 0.01885095f, -0.02239692f, 0.05519515f, 0.25671384f, 
    -0.21494216f, 0.09471235f, -0.03888303f, 0.04750820f, 0.00309920f, 0.37443960f, 0.06209097f, -0.20780188f, 
    -0.47692049f, -0.24057089f, -0.08353952f, -0.04835903f, 0.04757481f, 0.09153835f, -0.16415937f, 0.09902544f, 
    0.03859193f, -0.04612898f, 0.03055212f, -0.08400141f, -0.02160182f, -0.08605111f, -0.06332505f, -0.08962878f, 
    0.04387854f, 0.02503371f, -0.02259219f, -0.06100296f, -0.06917076f, -0.00724274f, -0.02164872f, -0.07499720f, 
    0.03463141f, 0.02584619f, 0.04757137f, -0.09139409f, 0.07229480f, 0.00512179f, -0.04668212f, -0.04502802f, 
    -0.01846221f, 0.05365520f, 0.06916997f, -0.08290470f, -0.05256706f, 0.00256189f, -0.06315079f, 0.04407841f, 
    0.04483200f, 0.00414359f, -0.06323642f, -0.04140254f, -0.01526495f, -0.07796723f, -0.03042059f, -0.06629599f, 
    0.04800078f, -0.05633718f, -0.07621239f, -0.02116547f, 0.02448209f, -0.05007348f, 0.00139360f, -0.08362913f, 
    0.00663969f, 0.05945369f, 0.06017023f, -0.06718607f, -0.03510295f, 0.04071817f, -0.06624302f, -0.04929454f, 
    -0.06594498f, 0.06060676f, 0.03701694f, -0.05504289f, -0.02817014f, -0.03637395f, 0.00766417f, -0.02565590f, 
    0.00465297f, -0.00878698f, 0.01719520f, 0.05248838f, 0.02903631f, 0.03841737f, 0.01818400f, -0.04759664f, 
    0.04032364f, 0.02085849f, -0.07215968f, -0.08861443f, -0.08536482f, -0.01610972f, 0.00953802f, 0.06122743f, 
    0.07411569f, -0.02688311f, 0.03147923f, -0.00123826f, 0.00237420f, -0.06613404f, 0.05160751f, 0.02848843f, 
    -0.05099653f, -0.02231481f, 0.03334565f, 0.00626444f, 0.01460260f, -0.00225748f, 0.02119436f, -0.03464350f, 
    0.01541813f, -0.00780929f, -0.07119043f, 0.04298578f, -0.09245513f, 0.06773316f, -0.04519404f, -0.02777818f, 
    -0.05514778f, 0.05126262f, -0.00198172f, 0.05643924f, -0.06147740f, -0.00247806f, -0.00128874f, -0.04472778f, 
    -0.02554581f, 0.03490379f, 0.05700853f, 0.01421846f, -0.02576628f, 0.04093454f, -0.08792808f, 0.02444107f, 
    0.06638482f, -0.00812057f, -0.00442173f, 0.02875827f, -0.03862138f, -0.05308182f, 0.04522697f, 0.04558613f, 
    -0.04559325f, -0.03902224f, -0.01514880f, -0.01325963f, -0.05293301f, -0.04423408f, -0.02700215f, -0.06792101f, 
    0.07416234f, -0.04333163f, -0.03735830f, 0.02133010f, 0.05958461f, -0.00694763f, 0.00210777f, -0.01557235f, 
    -0.39249545f, -0.03444580f, -0.04958306f, -0.04955751f, -0.09400083f, -0.06748757f, 0.08422772f, 0.23030773f, 
    0.04312769f, 0.35661855f, 0.20160948f, 0.35017782f, -0.15544964f, 0.06865126f, 0.08963087f, -0.00678121f, 
    0.02496863f, 0.01202652f, 0.50258303f, 0.25392759f, 0.05767535f, 0.12080525f, -0.13170770f, -0.03591238f, 
    -0.09200203f, 0.05588634f, 0.10191260f, -0.07569715f, 0.11037434f, -0.36082432f, 0.05613590f, 0.06288032f, 
    -0.09336949f, -0.09524485f, 0.11789852f, 0.05503947f, -0.09714180f, -0.02059641f, 0.08419079f, 0.13904244f, 
    0.03451670f, -0.17652789f, -0.09815320f, -0.06530257f, 0.27486840f, 0.13016546f, 0.20230702f, -0.46137184f, 
    0.10094484f, 0.00736578f, 0.05451702f, -0.14187594f, -0.20351176f, 0.00509997f, -0.17664433f, 0.22265226f, 
    -0.10209557f, 0.10534833f, -0.03134372f, -0.02265672f, 0.00995486f, 0.04791965f, -0.19274317f, 0.00948345f, 
    0.16898812f, -0.02852431f, -0.09724479f, 0.00780128f, 0.09264546f, 0.26173341f, -0.00330916f, -0.17223155f, 
    -0.21758576f, -0.41990963f, -0.17554604f, 0.02298379f, 0.06737481f, -0.14344788f, -0.01256722f, 0.07365425f, 
    -0.14448451f, -0.55923563f, -0.02219228f, 0.16267905f, 0.23547961f, -0.02463108f, -0.11698532f, -0.14800313f, 
    0.16047068f, 0.24384733f, -0.27136028f, 0.11466712f, -0.07762400f, 0.07190854f, 0.09603047f, 0.05400678f, 
    -0.05940630f, 0.00879024f, -0.05162877f, 0.05645438f, 0.02836353f, -0.42626822f, 0.02253800f, 0.14487591f, 
    0.04355128f, 0.16155171f, -0.00821153f, -0.24184547f, 0.12056029f, 0.03966096f, 0.11857536f, -0.18868022f, 
    -0.08998447f, 0.13387230f, 0.01553823f, 0.05635856f, 0.18881185f, 0.18566562f, 0.19480018f, -0.42212859f, 
    -0.09070317f, 0.29025549f, -0.14209467f, -0.05379184f, -0.14281435f, -0.10486692f, -0.26731977f, 0.13027526f, 
    0.11441913f, -0.02982639f, -0.07445513f, -0.12046640f, -0.02408258f, 0.05828184f, -0.07688829f, -0.03479793f, 
    -0.11612093f, -0.16714978f, -0.08357568f, 0.00478622f, -0.09648699f, 0.11474331f, 0.05898987f, 0.14453742f, 
    0.01723704f, 0.10509183f, 0.01080868f, -0.06424077f, -0.09279066f, 0.20881110f, 0.06132699f, 0.09825965f, 
    -0.35696402f, -0.22127202f, -0.22362621f, 0.22253245f, 0.05612209f, 0.15970789f, 0.37839660f, 0.01430639f, 
    0.01637551f, 0.10318824f, 0.14072385f, 0.10178110f, -0.02257029f, 0.02596021f, -0.02362070f, 0.01113635f, 
    0.17488410f, -0.01046726f, -0.43043253f, 0.20443849f, -0.01821098f, -0.10950968f, -0.01339349f, -0.03009118f, 
    0.03309225f, -0.06158284f, 0.04571791f, 0.09142674f, 0.09735063f, 0.07832530f, 0.39033782f, 0.12154817f, 
    0.02629468f, -0.09729368f, 0.13123642f, 0.02859295f, 0.18932892f, -0.21663174f, -0.15539764f, 0.05906567f, 
    0.01285323f, -0.16436122f, 0.07715637f, -0.11887842f, 0.08144321f, 0.15602550f, 0.29036736f, -0.14676394f, 
    0.27587458f, 0.13880560f, -0.01088319f, 0.22482559f, 0.21469335f, -0.11122038f, 0.13789970f, -0.37615648f, 
    -0.12785244f, -0.28517061f, -0.03891303f, 0.07749221f, -0.29165140f, 0.15659735f, -0.04003935f, -0.11894089f, 
    -0.17936637f, -0.00662974f, 0.13751967f, 0.07879956f, -0.11180606f, -0.17106533f, 0.02603986f, -0.15767714f, 
    0.08920436f, 0.29616314f, 0.09211636f, 0.02370230f, -0.20005107f, -0.08536316f, -0.02106280f, 0.00138652f, 
    -0.06362248f, 0.21592349f, -0.10033657f, 0.03282190f, -0.42983446f, 0.07956664f, 0.06494988f, 0.05070051f, 
    -0.04578499f, 0.03840928f, -0.36724678f, 0.03829378f, 0.01340130f, 0.00952323f, -0.07762869f, 0.00298766f, 
    0.03134282f, 0.06857382f, -0.10454391f, 0.06387303f, -0.03560912f, -0.01781018f, -0.08166422f, 0.35341549f, 
    0.02250334f, -0.00797627f, -0.26752770f, -0.06494720f, 0.01187321f, 0.12815332f, 0.17055234f, 0.15776978f, 
    -0.19362083f, -0.06530258f, -0.30068699f, -0.11650237f, 0.19162926f, -0.12277345f, 0.20962776f, -0.03956582f, 
    0.06406876f, 0.07359981f, 0.07739958f, 0.00354447f, 0.03223151f, 0.02530048f, -0.02414891f, 0.32582679f, 
    -0.00572718f, 0.04936168f, 0.11089180f, 0.00216911f, 0.03268881f, 0.00725580f, 0.14557824f, -0.00196402f, 
    -0.13307929f, 0.15146807f, -0.01064097f, -0.07912047f, 0.11937787f, 0.01757563f, 0.29636604f, 0.22473548f, 
    -0.03627615f, 0.51593703f, 0.30496535f, -0.76429993f, 0.13296132f, 0.10019156f, 0.24030496f, 0.02202715f, 
    -0.25507265f, -0.08729054f, 0.60343027f, 0.06324402f, 0.24310939f, 0.18435216f, -0.01400626f, 0.08741149f, 
    -0.12049589f, 0.17258172f, -0.11882980f, -0.15390348f, 0.17131801f, 0.36180368f, -0.02071353f, -0.05732686f, 
    0.00492206f, -0.21910645f, -0.13815010f, -0.09960175f, 0.14310765f, 0.28461561f, -0.38852227f, 0.22951657f, 
    0.11520027f, 0.05679551f, 0.12813690f, 0.09156076f, -0.02434404f, 0.01490871f, -0.12714124f, 0.11833259f, 
    -0.39141434f, 0.07839736f, -0.10174805f, -0.09614621f, -0.04732442f, -0.16017033f, -0.44620430f, -0.04691308f, 
    -0.16931087f, -0.22378023f, 0.21906482f, 0.05913020f, 0.06259926f, 0.10207717f, -0.11709730f, 0.18821554f, 
    0.06818855f, 0.12140711f, -0.17041047f, -0.15818529f, -0.02542142f, -0.12889837f, 0.07697999f, 0.05497109f, 
    -0.19645038f, -0.00327293f, -0.16483612f, 0.01431807f, -0.00050423f, 0.10239652f, -0.05172799f, 0.23716049f, 
    0.25030762f, -0.27823755f, -0.24553986f, 0.21221997f, 0.00641632f, -0.10809659f, 0.08137808f, -0.17023563f, 
    -0.02260952f, 0.31172940f, 0.38349444f, -0.08561515f, -0.10724106f, -0.06299973f, 0.04579809f, 0.39836538f, 
    0.09973805f, -0.31737337f, -0.00035851f, 0.19264920f, 0.29215449f, 0.15094532f, -0.16815375f, 0.01189755f, 
    -0.06672058f, 0.03880628f, 0.02097264f, -0.06917220f, 0.04474717f, -0.25821954f, -0.14176436f, 0.21585612f, 
    0.21444640f, -0.04961076f, 0.18578325f, -0.01579837f, -0.07666769f, -0.39376345f, -0.23834272f, -0.14237371f, 
    0.03186884f, -0.07383650f, -0.09994977f, -0.15853299f, -0.19679376f, 0.05889187f, -0.16860333f, -0.33390200f, 
    -0.10204270f, 0.12774213f, 0.10528103f, 0.03082509f, -0.25296080f, 0.06143005f, -0.22380573f, -0.51913667f, 
    0.05496008f, -0.15237008f, -0.09650993f, 0.06867711f, -0.29879192f, 0.12013020f, 0.04415121f, 0.17794344f, 
    0.40030751f, 0.30280280f, 0.14296122f, -0.00624845f, -0.05182099f, 0.03575488f, -0.07315106f, 0.23488255f, 
    -0.00500390f, 0.16442162f, -0.39550969f, -0.26784590f, -0.08198494f, -0.10174545f, -0.00132164f, -0.12276082f, 
    -0.10030530f, -0.13127656f, -0.35357016f, 0.11826505f, -0.08425488f, 0.16431926f, -0.02197431f, 0.08153077f, 
    0.18879305f, -0.03761748f, -0.00252001f, -0.08787662f, -0.20167439f, 0.15238544f, 0.29275671f, -0.08357278f, 
    -0.06461565f, -0.02619041f, -0.18645366f, 0.09367064f, -0.10246748f, 0.44115087f, -0.05448229f, -0.13285446f, 
    -0.03368051f, 0.01730863f, 0.19670756f, 0.06519299f, -0.03881541f, 0.38657206f, 0.36037934f, 0.16544949f, 
    -0.12522614f, 0.17587903f, 0.00564637f, 0.01658574f, 0.04820760f, 0.04245907f, -0.22614430f, 0.04557961f, 
    -0.20735456f, 0.10145771f, 0.09662410f, 0.40629390f, -0.29691708f, 0.00943937f, 0.09160247f, 0.28818759f, 
    0.25491878f, 0.02698912f, 0.06746822f, 0.08396364f, 0.07053437f, 0.11621214f, 0.01644287f, -0.18683361f, 
    0.20864609f, -0.05025113f, -0.20523205f, 0.04337350f, 0.03871376f, 0.19820537f, 0.14301766f, -0.03973361f, 
    0.08488327f, -0.19674897f, 0.06899048f, -0.10414816f, 0.08043947f, -0.07778968f, 0.08012503f, 0.00087536f, 
    -0.25257698f, -0.08834821f, -0.22444166f, -0.17815892f, 0.23865202f, -0.08996762f, 0.17979996f, 0.03582471f, 
    0.08605222f, 0.14562736f, -0.27379704f, 0.23483223f, -0.15473260f, -0.17309538f, -0.12776646f, 0.02397306f, 
    0.07302226f, -0.06120872f, 0.08717453f, -0.10152640f, -0.03900573f, -0.48312691f, -0.13814481f, -0.04635253f, 
    -0.04956711f, 0.04257901f, -0.05857801f, -0.00233400f, -0.03288595f, 0.18389866f, -0.23784204f, 0.05616916f, 
    0.00927195f, 0.00900860f, -0.06793705f, 0.03265377f, -0.29830119f, 0.00362669f, -0.11378407f, 0.34864828f, 
    -0.29758126f, -0.14898986f, -0.19030975f, -0.06203870f, 0.22296575f, 0.10866982f, -0.30663183f, -0.16864896f, 
    -0.00324973f, -0.03661972f, -0.00536898f, 0.25535867f, -0.10010997f, 0.13806860f, 0.18793729f, 0.10021007f, 
    -0.19385281f, -0.05886598f, -0.01509759f, -0.24313489f, -0.07494543f, 0.10198928f, -0.15116656f, 0.15773171f, 
    -0.01514269f, 0.28107166f, 0.19986719f, 0.26554784f, 0.13557397f, 0.08471645f, -0.18988468f, 0.02902667f, 
    0.09888611f, -0.01826797f, -0.12266870f, -0.07643592f, -0.21680160f, -0.14582780f, -0.09264986f, -0.18220660f, 
    -0.03277110f, 0.07620433f, 0.12733139f, 0.31956795f, 0.06943110f, -0.13597715f, -0.00974289f, -0.16133638f, 
    0.07833351f, -0.12556848f, -0.06960892f, 0.14038745f, 0.26636994f, 0.16827175f, 0.26560435f, 0.19684057f, 
    -0.01955795f, 0.04117114f, -0.02323475f, 0.10778053f, -0.05279012f, -0.48878029f, -0.16845427f, 0.23968743f, 
    -0.08401201f, 0.07270977f, 0.12638336f, 0.07629325f, -0.19354114f, 0.16743512f, 0.19808072f, 0.27656442f, 
    -0.02074432f, 0.04644693f, -0.17441525f, -0.06766672f, 0.13439108f, 0.17239840f, 0.02173218f, -0.16741592f, 
    -0.35992891f, -0.12576173f, -0.10730217f, -0.11947634f, 0.13704762f, -0.06562861f, 0.01678194f, 0.01460584f, 
    -0.19006735f, -0.07840985f, 0.06089874f, -0.01009878f, 0.06412048f, 0.11596103f, -0.28762871f, -0.11626798f, 
    -0.10552050f, -0.09884293f, 0.39974347f, 0.30247170f, -0.13439083f, -0.00679787f, -0.05731603f, 0.00246148f, 
    -0.06318336f, -0.11887705f, -0.06144983f, -0.26141390f, -0.26997516f, 0.07278744f, -0.04671249f, -0.09913309f, 
    0.33719838f, 0.13936439f, 0.03094766f, -0.17844559f, -0.05109480f, -0.38529810f, -0.20096976f, 0.07057913f, 
    -0.10189719f, -0.07378707f, -0.10359726f, -0.04672243f, 0.18877484f, 0.02427542f, -0.18082117f, -0.13902266f, 
    0.10222146f, -0.08762349f, 0.07774194f, 0.28569463f, 0.00868551f, 0.16350272f, 0.02418349f, -0.10670236f, 
    -0.21655099f, 0.23901737f, -0.22809397f, 0.03101720f, 0.02015238f, -0.16028096f, 0.15583783f, 0.30080566f, 
    -0.12564699f, -0.17120087f, -0.21209602f, -0.16875558f, -0.07860766f, 0.08983974f, -0.11230230f, 0.51264352f, 
    0.06528127f, 0.28685617f, 0.02641011f, -0.03719762f, 0.12664691f, -0.09285962f, -0.13101773f, -0.02568106f, 
    -0.44809115f, -0.25883031f, 0.08801101f, -0.08281340f, 0.12545507f, 0.22370654f, -0.07837839f, 0.00673322f, 
    0.00391640f, 0.42987451f, -0.09318175f, 0.01943227f, 0.16186552f, 0.07977217f, -0.07281706f, -0.05198207f, 
    0.03144189f, -0.03767848f, 0.20087095f, 0.13088630f, -0.15897328f, -0.25513136f, -0.06770226f, 0.14332181f, 
    0.12453664f, -0.01563300f, -0.17236020f, -0.02702586f, -0.25684887f, -0.11610769f, 0.18217400f, 0.00840602f, 
    -0.06080727f, -0.13779926f, 0.22307791f, -0.09787504f, -0.43538857f, -0.16810051f, -0.04236179f, -0.25966901f, 
    -0.07643110f, 0.00350048f, 0.04307013f, -0.19532509f, -0.14220165f, -0.50267589f, 0.40673864f, -0.12261605f, 
    0.08094394f, 0.18337335f, 0.07465052f, 0.20033970f, -0.21454725f, -0.07478021f, 0.28346208f, -0.12331300f, 
    0.19669543f, 0.00461544f, 0.03377930f, 0.09498525f, 0.07012545f, -0.12590581f, 0.07760788f, -0.42518178f, 
    0.21238850f, -0.01235950f, 0.22556034f, 0.04247348f, -0.02201505f, -0.16587749f, 0.07033220f, -0.10483880f, 
    0.55523568f, 0.17226997f, 0.29244334f, 0.02295423f, -0.08549187f, -0.24841227f, 0.04097803f, 0.01043791f, 
    0.15620901f, -0.43555421f, -0.14960799f, 0.09010786f, 0.19205484f, 0.29908472f, 0.33617818f, 0.03110237f, 
    -0.07713369f, 0.21603765f, -0.38340038f, -0.10351927f, -0.07136042f, 0.18140371f, -0.02390922f, 0.02617159f, 
    -0.05016781f, 0.09234197f, 0.09436894f, 0.16297531f, 0.18276353f, 0.14666983f, -0.03818190f, -0.02416432f, 
    0.12467637f, -0.00474926f, -0.05904320f, 0.08281020f, 0.45900303f, 0.00250183f, -0.14868502f, -0.12692799f, 
    -0.21988143f, -0.11991020f, 0.08080555f, 0.10302909f, -0.01072555f, 0.08297075f, 0.03708336f, -0.20873272f, 
    0.13812499f, -0.11386348f, -0.05300703f, -0.05886938f, 0.08150604f, 0.18016256f, 0.12065817f, -0.06464428f, 
    0.13798067f, -0.12050384f, 0.17779350f, 0.00179794f, -0.06891054f, 0.07297880f, -0.01379518f, 0.14985034f, 
    0.01540358f, -0.32886994f, -0.17257662f, -0.05818355f, -0.13502946f, 0.02090168f, -0.14805329f, -0.03156825f, 
    0.12915193f, 0.21027891f, 0.22389339f, -0.09584701f, -0.22079107f, -0.03196276f, 0.12303114f, 0.22380498f, 
    0.05615477f, -0.01131163f, 0.10040647f, -0.32751730f, 0.14013086f, -0.06055252f, -0.03233164f, -0.00346874f, 
    -0.07893316f, -0.04346693f, 0.05481849f, 0.31144348f, -0.05614131f, -0.20077801f, -0.12395773f, -0.36828187f, 
    0.03219867f, 0.24657999f, 0.00981946f, -0.26114118f, -0.14843099f, -0.25254816f, 0.17278028f, 0.16326338f, 
    -0.09939212f, -0.08035283f, -0.15815130f, 0.16542993f, -0.00065085f, 0.15340754f, -0.10566474f, 0.14841676f, 
    0.04402144f, 0.08304636f, 0.21748823f, -0.01482235f, 0.09187116f, -0.23580429f, 0.10427500f, 0.13315569f, 
    0.20630500f, -0.15867570f, -0.06062300f, -0.03457410f, 0.11283997f, 0.02286338f, -0.18828364f, 0.12491800f, 
    0.20878367f, -0.14805879f, 0.11887148f, 0.02389192f, -0.04634258f, -0.04295547f, -0.34005392f, -0.29741922f, 
    0.12759818f, 0.12102982f, -0.20024911f, -0.11277392f, -0.17849673f, 0.07720726f, 0.06972817f, 0.10220453f, 
    -0.01625115f, -0.15619202f, 0.12477793f, 0.03711263f, 0.13207279f, 0.08428781f, 0.14568122f, 0.01883830f, 
    -0.06031860f, 0.02244665f, 0.07101770f, -0.25751656f, -0.01812281f, -0.25378272f, 0.11177421f, -0.19971636f, 
    -0.21143870f, -0.21570852f, 0.14918871f, -0.16147868f, -0.13018310f, 0.05770409f, -0.01020633f, -0.18023372f, 
    0.16112468f, -0.10960234f, -0.00293544f, 0.15441157f, 0.03760030f, -0.15663978f, 0.14108440f, -0.02914578f, 
    0.11112366f, 0.01902566f, -0.13214563f, 0.01527872f, -0.13896400f, -0.08828294f, 0.00532015f, 0.23124982f, 
    0.14296497f, -0.17173339f, 0.01651497f, -0.06145989f, 0.01422588f, -0.15189429f, -0.18107438f, -0.22648905f, 
    0.00736846f, -0.01228152f, 0.02733608f, 0.27636695f, -0.20992701f, 0.09051719f, -0.08075833f, 0.12390633f, 
    0.17488587f, 0.26076958f, -0.02692390f, 0.20823587f, -0.10501847f, -0.04642942f, -0.03999215f, -0.40345934f, 
    0.31229895f, 0.11744657f, -0.06615733f, -0.17792214f, 0.08036534f, -0.14883751f, 0.31388545f, 0.14644578f, 
    0.19450918f, 0.17059019f, 0.25182036f, 0.07756363f, 0.14559358f, 0.09115176f, -0.01094287f, 0.00138895f, 
    0.01625346f, -0.20031513f, -0.37671030f, 0.17821112f, 0.15494598f, -0.16819431f, -0.01567103f, -0.10080043f, 
    0.00250089f, -0.02482086f, -0.23962197f, -0.20739534f, -0.12597531f, 0.02920528f, -0.13756028f, -0.05638978f, 
    0.02872452f, 0.05185169f, 0.05525530f, -0.36984453f, 0.28561524f, -0.46275258f, 0.04770776f, -0.01421614f, 
    0.08956788f, -0.02501151f, 0.09834357f, -0.05917308f, 0.41173020f, 0.20567518f, 0.30192706f, -0.09685878f, 
    -0.22167182f, -0.07588177f, 0.03814927f, 0.11987314f, 0.27662373f, -0.13489674f, 0.07843366f, -0.25424188f, 
    0.10066504f, -0.02984823f, -0.01146554f, 0.12260002f, -0.01627935f, -0.13834110f, -0.00828341f, -0.21655461f, 
    -0.20690039f, -0.00031300f, 0.00301341f, -0.08305488f, 0.15152040f, -0.12744083f, 0.01041770f, 0.15880328f, 
    0.37568983f, 0.04462129f, -0.11296920f, 0.17928109f, -0.19630450f, 0.05115734f, 0.02137977f, -0.01299061f, 
    -0.52144545f, -0.01197508f, -0.50388670f, 0.31107426f, 0.16623795f, 0.11874583f, 0.02016097f, 0.00256935f, 
    0.06745402f, 0.33019623f, 0.26296687f, -0.05505381f, 0.13034622f, -0.15828690f, -0.00668923f, 0.03120627f, 
    0.01542895f, 0.04786796f, 0.43938136f, 0.03445239f, 0.00950043f, 0.08611763f, 0.03015026f, -0.04735615f, 
    0.11615865f, -0.10377930f, 0.09878564f, -0.26277989f, 0.13026464f, -0.46244448f, 0.13613012f, -0.04328814f, 
    -0.08296125f, -0.04755387f, 0.09118741f, 0.06148949f, -0.08626807f, -0.29324320f, 0.17625810f, 0.05337640f, 
    -0.23338166f, 0.19821183f, 0.04284409f, -0.09462862f, 0.08158582f, 0.27975675f, -0.04195523f, -0.16271080f, 
    -0.12571774f, -0.01926748f, 0.02796315f, 0.02571812f, -0.16063942f, -0.07382474f, -0.13395943f, 0.26835182f, 
    0.56702602f, 0.14267597f, -0.05255530f, 0.05407298f, -0.19183443f, -0.10729536f, 0.02740464f, -0.19506694f, 
    -0.26908731f, -0.25246480f, -0.11224839f, -0.00685528f, -0.06349038f, 0.07048990f, 0.03200989f, 0.05153866f, 
    0.23799731f, 0.19211866f, 0.16009204f, 0.32604313f, 0.16039556f, -0.01307847f, 0.15090390f, -0.07861761f, 
    0.01140302f, -0.25739485f, 0.07570966f, -0.26336160f, 0.30332473f, -0.01230695f, 0.08403017f, -0.19914399f, 
    0.01606197f, 0.00508333f, -0.16839121f, -0.28818315f, 0.08921783f, 0.05888764f, 0.14587435f, 0.02259753f, 
    -0.02151704f, -0.12555909f, -0.02947282f, -0.07957865f, -0.31967092f, 0.13670760f, -0.20812722f, 0.08519340f, 
    -0.15921599f, -0.08136045f, -0.03257743f, -0.10542978f, -0.42042270f, -0.13364117f, -0.35407159f, 0.15386175f, 
    0.06304964f, -0.03964664f, -0.00100456f, -0.02756676f, -0.02174815f, -0.45052454f, 0.34977165f, 0.52201504f, 
    0.12099696f, 0.26007417f, -0.01420798f, 0.03804329f, -0.07535066f, 0.21881010f, 0.05925363f, 0.03466229f, 
    -0.13875709f, 0.09603392f, -0.03145885f, -0.04022050f, 0.01019096f, 0.09973468f, -0.09361543f, 0.09251238f, 
    -0.00963955f, 0.22022063f, -0.06488483f, 0.10897554f, -0.07156263f, 0.08527474f, 0.01956137f, 0.22529651f, 
    0.04196031f, 0.36278182f, 0.07432233f, -0.02692467f, 0.21071316f, -0.08787370f, 0.18008164f, 0.16300911f, 
    -0.00831274f, 0.09741509f, 0.06944093f, -0.00136900f, -0.07827508f, 0.02413547f, 0.01084913f, 0.04983433f, 
    -0.08786200f, 0.00021090f, -0.44637612f, 0.03163297f, -0.11586935f, 0.30692232f, 0.03744459f, 0.34459725f, 
    0.12311342f, -0.16792178f, -0.15546019f, -0.33691347f, 0.01338369f, 0.29399550f, -0.03983131f, -0.05034089f, 
    -0.14630480f, 0.01085462f, 0.29685700f, 0.25866416f, -0.60842746f, -0.46910244f, -0.34693792f, -0.01705140f, 
    0.06355137f, -0.11374991f, -0.03540824f, 0.00442636f, -0.18255448f, -0.11278741f, 0.35030082f, -0.11747811f, 
    -0.21378167f, -0.25742736f, -0.17547600f, -0.12951797f, 0.10797330f, -0.07652315f, -0.18576503f, -0.13929808f, 
    -0.16623978f, 0.22885020f, 0.23950985f, -0.14451963f, -0.25650635f, -0.00783795f, 0.15631379f, 0.09210584f, 
    -0.12996535f, -0.10194161f, 0.03905591f, 0.06585496f, -0.01946599f, 0.22994457f, -0.02938483f, 0.07090716f, 
    -0.07442598f, -0.12532191f, 0.03209553f, 0.34936422f, 0.12082531f, 0.14926934f, -0.24802721f, -0.01395048f, 
    -0.20031314f, -0.02147402f, -0.07145631f, 0.39615446f, -0.15075001f, -0.25557637f, -0.06311654f, -0.13519531f, 
    -0.11191081f, 0.05857085f, 0.01735601f, 0.13400330f, 0.10057172f, -0.20289759f, -0.07672487f, 0.20116423f, 
    -0.00181141f, 0.09192550f, -0.23859374f, 0.52679867f, 0.09214228f, 0.27455878f, -0.10449973f, -0.16604352f, 
    -0.02633585f, -0.07028539f, 0.01800779f, -0.03838472f, -0.10941525f, -0.29281273f, -0.12707530f, 0.08174878f, 
    0.04313308f, 0.01586464f, -0.05415989f, 0.06829012f, -0.07932271f, -0.10487605f, 0.02343502f, -0.09784440f, 
    0.24088240f, 0.19565293f, 0.19698328f, -0.01516566f, -0.10219512f, -0.22262317f, 0.15812950f, -0.08090685f, 
    -0.06258362f, 0.11449740f, -0.32918295f, 0.00443691f, -0.02028334f, -0.01035804f, -0.11125629f, 0.08026826f, 
    0.20507829f, 0.07747528f, 0.03894340f, 0.17279615f, -0.37665352f, 0.13044202f, -0.15993910f, 0.09199360f, 
    -0.06935316f, 0.13600691f, 0.07627703f, -0.09005607f, -0.03387605f, -0.16691658f, -0.00010915f, 0.01290492f, 
    0.06420448f, 0.20603447f, -0.12790261f, 0.25248471f, -0.08993150f, 0.15736058f, 0.02979107f, 0.20633818f, 
    -0.18986410f, 0.00817954f, 0.19881532f, -0.00888453f, -0.24965492f, 0.00428638f, -0.00380620f, 0.17657541f, 
    0.17019628f, -0.04008446f, -0.14572436f, 0.05109459f, 0.23654602f, -0.11725810f, 0.10763225f, -0.02531822f, 
    -0.03886736f, 0.14886613f, 0.00305656f, 0.10896664f, -0.07343081f, 0.03549286f, 0.07618979f, -0.04680981f, 
    -0.14567979f, 0.04038602f, 0.18410446f, 0.07429966f, -0.09507445f, -0.15974021f, 0.07902730f, -0.13718353f, 
    -0.34978500f, 0.21394618f, -0.05870242f, 0.24867000f, -0.19029950f, 0.02958957f, -0.03809034f, -0.10882985f, 
    0.04191582f, 0.06186031f, 0.08224676f, -0.10711920f, -0.07735433f, 0.20447111f, -0.01286633f, -0.04114727f, 
    -0.24192260f, -0.04697669f, 0.04599370f, -0.20969546f, 0.17585762f, -0.05639252f, 0.25138229f, -0.15996711f, 
    0.02779588f, -0.04987945f, 0.01829852f, 0.04008249f, -0.05701321f, -0.06207800f, -0.03654027f, 0.04354781f, 
    -0.08190849f, -0.07493911f, 0.01822723f, 0.06285444f, -0.08833846f, 0.01667291f, 0.03784167f, 0.03740672f, 
    -0.01390784f, -0.01412302f, -0.03646798f, -0.03466017f, -0.05570879f, 0.05792774f, 0.02386457f, 0.02948921f, 
    0.02815386f, 0.05024219f, 0.03944382f, 0.01041037f, -0.04781002f, 0.01241519f, -0.04224394f, -0.05185775f, 
    -0.08055441f, 0.00830679f, 0.01921372f, -0.04314874f, 0.06024213f, -0.02279755f, -0.03853703f, -0.06562706f, 
    -0.07605939f, -0.06684851f, -0.07053164f, 0.02120783f, -0.01898039f, -0.03758035f, -0.04215309f, 0.03905263f, 
    -0.06278464f, -0.03017942f, -0.00340483f, -0.05165182f, -0.07693993f, -0.04245899f, -0.07538451f, -0.04607789f, 
    0.04191869f, -0.03093221f, 0.06025956f, -0.05028627f, 0.06494203f, 0.04298104f, 0.00179311f, -0.05978350f, 
    0.05509777f, -0.05888624f, 0.00756422f, -0.02338043f, -0.00190736f, -0.03986606f, -0.08012905f, 0.06508117f, 
    0.00988596f, 0.04330257f, -0.08283604f, -0.04222613f, 0.02136243f, 0.03690513f, -0.06211845f, 0.06378813f, 
    0.04846550f, -0.07123934f, 0.00916617f, -0.05207144f, -0.06184911f, 0.06836320f, -0.00665468f, -0.05333345f, 
    -0.06162725f, 0.01581346f, 0.03017799f, 0.01895256f, 0.05920422f, -0.00275589f, -0.08038314f, -0.08419142f, 
    0.05396365f, 0.00250815f, -0.03498874f, 0.02849789f, -0.00184832f, 0.03765604f, -0.02096830f, 0.02871367f, 
    0.05475923f, 0.04161820f, -0.00137323f, -0.06249217f, -0.04343181f, 0.00089803f, -0.04108610f, 0.02255920f, 
    -0.02539214f, 0.03123467f, -0.09885154f, 0.02695110f, -0.03084627f, -0.01615783f, 0.04991769f, -0.05142229f, 
    0.05509878f, -0.07285295f, 0.03982855f, 0.00943987f, -0.05570155f, 0.04866366f, -0.07050999f, -0.05612200f, 
    -0.07730756f, -0.08923915f, 0.03626351f, -0.00503021f, -0.01989741f, 0.02099733f, -0.04790374f, 0.03035618f, 
    -0.02960158f, -0.07588517f, 0.04858431f, -0.01979015f, -0.06159126f, 0.05133696f, -0.07372168f, 0.00590863f, 
    0.35354990f, -0.05489616f, -0.37340397f, 0.24993914f, 0.13931005f, -0.08548321f, -0.16357650f, 0.16059515f, 
    0.12832890f, 0.34706175f, 0.17336392f, 0.08609573f, 0.01713112f, 0.14773150f, 0.10720653f, 0.03958236f, 
    -0.22289778f, 0.17636809f, -0.01655003f, 0.01767571f, -0.23686889f, 0.33898923f, 0.05465547f, -0.01627480f, 
    0.07000145f, 0.11620470f, -0.07347198f, -0.26199144f, -0.02279955f, -0.06147435f, -0.33519492f, -0.01188219f, 
    -0.16946222f, 0.12142812f, 0.10238834f, -0.02832016f, 0.40017992f, 0.22357652f, 0.20148896f, 0.10902002f, 
    0.11428731f, -0.11055434f, 0.01969848f, -0.22309598f, -0.08842847f, -0.12757671f, 0.10339484f, -0.02376130f, 
    -0.11771595f, -0.08834668f, 0.08166283f, -0.14252537f, -0.05106797f, 0.04417669f, 0.29071733f, 0.14330505f, 
    0.06185577f, -0.11254665f, 0.14055230f, 0.04355546f, -0.12672858f, 0.18558536f, -0.11726996f, -0.48108456f, 
    0.19883725f, -0.16523862f, 0.02590976f, 0.00637813f, -0.21766137f, -0.01441129f, 0.20520523f, 0.19577511f, 
    0.13541313f, -0.20378861f, 0.22081770f, 0.04151116f, -0.07389407f, 0.05830885f, -0.03908426f, 0.05905800f, 
    -0.04211951f, 0.02144923f, -0.20266680f, 0.16041948f, -0.05001188f, 0.18090811f, -0.00099847f, 0.08412418f, 
    0.00463036f, -0.16547321f, -0.00181449f, 0.00981930f, -0.04587868f, 0.30340019f, 0.06663893f, 0.11954092f, 
    0.29682499f, -0.11709503f, -0.03754248f, -0.13236645f, -0.10648396f, 0.11036508f, -0.09374405f, -0.08926029f, 
    -0.10636290f, 0.10241208f, 0.13399166f, 0.00492444f, 0.30564842f, 0.12479112f, -0.17483298f, -0.12140395f, 
    0.02058410f, 0.00896324f, 0.20627600f, 0.23646881f, -0.03591068f, -0.73533404f, -0.16708212f, 0.17281976f, 
    -0.05214715f, -0.02822261f, 0.00603430f, -0.22230226f, 0.06387542f, -0.22416295f, 0.20609184f, 0.40811074f, 
    0.22320946f, 0.08203484f, 0.12728490f, 0.24529383f, -0.07127314f, 0.25784421f, 0.23430780f, -0.03184127f, 
    0.08225153f, -0.62322837f, 0.16095367f, -0.08247847f, 0.09964307f, -0.01134579f, 0.29032645f, -0.15319876f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.10400533f, 0.02084991f, 0.13851717f, -0.08361158f, 0.06703963f, -0.16426387f, 0.18055591f, 0.11703204f, 
    -0.30759156f, 0.24154153f, 0.16147104f, 0.17892550f, 0.12300668f, -0.07104447f, -0.05350871f, -0.00519019f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.26381984f, -0.09597207f, 0.19327252f, 0.01581774f, -0.08110157f, 0.09788754f, -0.06942069f, -0.14651865f, 
    0.36711463f, 0.29436731f, -0.23665327f, -0.33396176f, 0.41334182f, 0.22589222f, -0.02918995f, -0.00832548f, 
    0.49308437f, -0.19246215f, -0.09652253f, -0.09889136f, 0.16631414f, 0.52431172f, 0.04414563f, -0.03835295f, 
    -0.43134770f, 0.31452313f, -0.40338063f, 0.26593086f, 0.29067254f, 0.30217752f, 0.14188874f, -0.27982765f, 
    0.05806041f, -0.28565416f, 0.10976510f, -0.06898750f, -0.38278657f, 0.42209974f, 0.35232732f, -0.22458968f, 
    0.28505510f, 0.01436333f, -0.26901072f, -0.04497618f, 0.14177968f, 0.11317445f, -0.00123513f, 0.20120357f, 
    0.60716957f, -0.21312484f, -0.06762791f, 0.22371240f, 0.33053115f, 0.46202102f, -0.10962007f, 0.10252962f, 
    -0.00654619f, 0.09115753f, -0.58785170f, 0.41396666f, 0.12330046f, 0.50222772f, -0.20661363f, -0.31572852f, 
    -0.12744242f, -0.19879754f, -0.34678397f, -0.18810895f, 0.20492063f, 0.17472728f, 0.74749190f, 0.21146871f, 
    0.10842621f, -0.13725606f, 0.55394411f, 0.34790850f, 0.24572061f, -0.27867612f, 0.22208077f, -0.02801467f, 
    0.21729901f, -0.04059358f, -0.32237464f, -0.16279934f, -0.36757037f, -0.15689917f, -0.32229170f, 0.33337179f, 
    -0.48173583f, 0.57417589f, 0.10226072f, -0.13364501f, 0.24279180f, -0.25945568f, 0.20871159f, 0.40659115f, 
    -0.13351755f, 0.00444723f, -0.35359818f, 0.14026178f, 0.32312372f, -0.19659057f, 0.28572184f, 0.25833777f, 
    -0.35754398f, 0.51434863f, -0.08065417f, -0.05626645f, 0.09777746f, -0.15944929f, 0.08104219f, 0.32521421f, 
    -0.04619139f, -0.23921496f, -0.09032559f, -0.15601547f, -0.25467119f, -0.40031832f, 0.35791355f, -0.06759064f, 
    -0.11257877f, 0.42131630f, -0.09364706f, -0.46416706f, 0.43508023f, 0.13398713f, -0.16501299f, 0.42959127f, 
    -0.43001130f, -0.16932152f, -0.21655378f, 0.15576972f, 0.31475809f, -0.11198132f, 0.32221347f, 0.41136962f, 
    -0.11665960f, -0.16661581f, 0.44301119f, 0.03987935f, 0.24522617f, -0.37266070f, -0.18817958f, 0.39628854f, 
    -0.16927429f, -0.06060632f, -0.22189417f, 0.11558065f, 0.08656348f, 0.05797644f, -0.23610149f, -0.01736465f, 
    -0.10921118f, 0.02255839f, -0.08997647f, 0.05967839f, -0.03709682f, 0.02260438f, 0.08159944f, -0.05520861f, 
    0.20819880f, 0.15537260f, 0.38693795f, -0.15703191f, -0.47157601f, -0.06764613f, 0.07488123f, 0.13138220f, 
    0.47367027f, -0.13924085f, -0.37765718f, -0.26973441f, 0.14625773f, 0.45419472f, 0.18356489f, 0.07447891f, 
    0.51953936f, 0.05949924f, -0.15857677f, -0.15870143f, -0.21739198f, 0.24522984f, 0.39593726f, 0.05758516f, 
    -0.76388764f, 0.18361475f, -0.31306195f, -0.37450758f, -0.05953056f, -0.41366309f, -0.14292893f, -0.02048919f, 
    -0.12738383f, -0.54930991f, 0.03709053f, -0.00332275f, -0.37740311f, 0.19681324f, 0.23814717f, -0.73615569f, 
    0.26586920f, 0.51570702f, -0.51529455f, 0.27177519f, 0.17388813f, 0.42872584f, 0.01985151f, 0.06678677f, 
    0.08122405f, -0.43433183f, 0.43234336f, 0.04143748f, -0.12240797f, 0.36678478f, -0.72651422f, -0.05068843f, 
    -0.04729998f, -0.11627832f, 0.04039383f, 0.14821817f, 0.38165122f, -0.11620151f, -0.23781073f, 0.06535262f, 
    -0.36258796f, 0.48624668f, -0.17971368f, -0.03210770f, 0.18145700f, -0.19222800f, -0.32773817f, 0.35366863f, 
    0.74338371f, -0.14164199f, 0.23438668f, 0.55413795f, -0.03415260f, 0.13210903f, 0.06153029f, 0.00504954f, 
    -0.32690445f, 0.19238007f, -0.06205659f, 0.20151863f, 0.65341401f, -0.24555625f, 0.16589090f, -0.19867814f, 
    -0.39881936f, -0.14517115f, 0.00316222f, 0.32068637f, -0.03966156f, 0.10224348f, -0.15481700f, 0.22898215f, 
    0.39528438f, 0.10890338f, -0.39951092f, 0.18861319f, 0.23351921f, -0.32717997f, -0.16653141f, 0.35186881f, 
    0.02088261f, -0.07636937f, -0.04967258f, 0.40926015f, 0.14366493f, 0.13510224f, -0.13170239f, 0.21039091f, 
    0.68745041f, -0.17721631f, 0.00125995f, -0.17371383f, 0.30532742f, 0.16425258f, 0.00769785f, -0.03806599f, 
    -0.27997607f, -0.71648216f, -0.15121493f, 0.23161578f, 0.13309206f, 0.61636865f, -0.02492395f, 0.03698885f, 
    -0.28192797f, 0.12948661f, -0.07313173f, -0.09825540f, -0.41985619f, -0.28024659f, 0.10796888f, 0.35112983f, 
    0.21239270f, -0.12661722f, 0.14704013f, 0.50441414f, 0.28287643f, -0.56237686f, 0.13063994f, 0.12058347f, 
    -0.40570679f, 0.51073664f, 0.51440489f, -0.07506058f, 0.64900929f, -0.15539536f, 0.13283305f, 0.14842513f, 
    -0.31153420f, 0.28065059f, 0.28893593f, 0.02972850f, -0.66876048f, -0.02867256f, -0.22190623f, -0.01018499f, 
    -0.38174641f, 0.08824121f, -0.23152673f, 0.20405285f, 0.30222613f, -0.21703222f, -0.12913230f, -0.44613066f, 
    -0.06368397f, 0.20026581f, 0.55831534f, 0.42186943f, 0.17285851f, 0.01763513f, -0.13705800f, 0.51653081f, 
    -0.32775274f, 0.63890994f, 0.23671384f, -0.12774850f, 0.39134461f, -0.23473638f, -0.04418992f, 0.02156980f, 
    0.64332974f, -0.16783901f, 0.42615506f, 0.27495676f, 0.00508455f, -0.53002197f, 0.04875886f, -0.01003847f, 
    0.74043190f, -0.16585200f, 0.41886270f, -0.16336650f, -0.27213725f, 0.02543904f, -0.24310105f, 0.15012641f, 
    -0.28999209f, 0.44526172f, -0.56567258f, 0.07724795f, 0.30251074f, -0.08876437f, 0.07405948f, -0.19294062f, 
    0.08825450f, -0.14178225f, 0.03137489f, -0.14433341f, -0.31547233f, 0.08223998f, 0.24255329f, -0.22588901f, 
    -0.22194947f, 0.24800187f, -0.21859720f, 0.45398873f, -0.39150122f, 0.37103155f, 0.08529216f, 0.13611272f, 
    -0.21187475f, -0.13530612f, 0.14324109f, 0.11034974f, -0.14836088f, 0.21321298f, -0.17330065f, -0.15042189f, 
    -0.07657611f, -0.01262956f, -0.17829765f, -0.21933465f, -0.10400016f, 0.07145961f, -0.03221968f, -0.21799199f, 
    0.33948025f, -0.51634008f, -0.45247707f, -0.08343586f, -0.06179322f, -0.00002437f, 0.39651233f, 0.25554463f, 
    -0.81945461f, 0.42372921f, 0.07939035f, 0.28840771f, 0.27114752f, 0.12064163f, 0.17502308f, -0.25156510f, 
    0.41151881f, 0.09487735f, -0.17269410f, 0.08558425f, -0.09355160f, 0.23052767f, -0.28160882f, -0.14634016f, 
    0.16265164f, -0.06516823f, -0.07810654f, -0.46790287f, -0.58795595f, -0.44669181f, 0.13646787f, 0.49521267f, 
    -0.22341707f, -0.32638839f, -0.27080402f, -0.11253421f, 0.08907815f, 0.09600557f, 0.06272651f, -0.19410719f, 
    0.43077219f, -0.04100129f, 0.04192201f, 0.18426000f, 0.37987173f, 0.44477770f, 0.05727267f, 0.18781328f, 
    -0.23275387f, 0.23627114f, -0.14018303f, -0.16098389f, -0.05692953f, -0.08670044f, -0.02531779f, -0.10492045f, 
    -0.08456326f, 0.23071659f, 0.06352952f, -0.04181045f, -0.16058689f, -0.22703058f, 0.15468335f, -0.18707302f, 
    -0.03941182f, 0.28109643f, -0.23885977f, -0.09504478f, 0.09594215f, 0.25890350f, 0.16369408f, -0.25888374f, 
    0.02308208f, -0.31384414f, 0.15582697f, -0.52287608f, 0.22045597f, 0.15488650f, -0.06197522f, 0.27083048f, 
    -0.17464025f, -0.13864249f, -0.52209830f, 0.13286535f, 0.07667874f, -0.01060607f, 0.51279420f, 0.20731761f, 
    -0.08453323f, 0.02252715f, 0.40362972f, 0.05024065f, 0.32066706f, -0.58462155f, -0.03787404f, 0.27537394f, 
    0.03151155f, -0.09202746f, -0.25342602f, 0.17232674f, -0.04633664f, 0.20040448f, -0.14305161f, 0.11959756f, 
    -0.05395800f, -0.14480332f, -0.21611905f, 0.01993984f, -0.08781333f, -0.13845372f, -0.23761791f, -0.09964529f, 
    0.03795864f, -0.45850787f, -0.26035503f, 0.04177530f, -0.07252035f, -0.06923495f, 0.36801553f, -0.11095511f, 
    -0.19007525f, 0.27377871f, 0.66877341f, 0.30534691f, 0.07554938f, -0.15919569f, -0.04583004f, 0.26380119f, 
    0.05510440f, 0.13320318f, 0.16182199f, 0.22807714f, -0.04627052f, -0.08395341f, -0.21343359f, -0.18015409f, 
    -0.23572326f, -0.24425226f, 0.17266178f, -0.18844932f, -0.08624765f, -0.20693198f, -0.13539341f, -0.20581910f, 
    0.01710465f, 0.05302017f, 0.07539408f, 0.07764927f, -0.41679639f, -0.32020697f, 0.28197193f, 0.13011202f, 
    -0.09568513f, -0.20411575f, 0.09081136f, 0.34417889f, 0.22471634f, -0.16136685f, -0.19274069f, -0.25175470f, 
    -0.00292304f, 0.21892652f, 0.30192450f, 0.11814189f, -0.03770821f, 0.28881240f, 0.09651791f, -0.63376546f, 
    0.33222473f, 0.51861215f, -0.32175690f, -0.33689857f, -0.39958167f, 0.19370750f, -0.14101350f, 0.25454700f, 
    -0.05921154f, 0.23779783f, 0.14157294f, 0.07867445f, 0.06457745f, -0.49189398f, -0.01714872f, 0.65699315f, 
    0.18289903f, 0.20313011f, 0.29029664f, -0.24017127f, 0.01274042f, 0.11950941f, -0.04492884f, -0.15078260f, 
    -0.20124763f, 0.26487118f, 0.02199661f, -0.02047220f, 0.25884536f, 0.05871858f, -0.20638509f, 0.34584987f, 
    0.24398984f, 0.50538236f, -0.27959162f, -0.03054261f, 0.16525720f, -0.02552031f, 0.23870535f, -0.20107639f, 
    -0.15666054f, -0.19806702f, -0.50336504f, -0.20452967f, 0.22222249f, -0.06559455f, -0.30580130f, -0.39075124f, 
    -0.62206870f, 0.28622550f, 0.25687966f, 0.21743250f, 0.26034260f, 0.25043663f, 0.04823643f, 0.16251153f, 
    -0.20111161f, 0.25613034f, -0.01836900f, -0.19874384f, -0.01788636f, 0.05970375f, 0.01563406f, -0.44829965f, 
    0.39206782f, -0.22065946f, 0.21744128f, -0.47182915f, 0.04219145f, 0.22375382f, -0.12869167f, 0.45093086f, 
    0.38334191f, 0.16550863f, 0.42843872f, -0.11396044f, -0.30196413f, -0.11494680f, 0.29150403f, 0.38782477f, 
    -0.20185795f, 0.36020935f, 0.07347715f, -0.46279421f, 0.11169527f, -0.44183156f, -0.18199405f, -0.05036738f, 
    0.33999306f, -0.25309983f, 0.07481336f, -0.12036595f, -0.01580205f, -0.08373714f, 0.41735557f, -0.20955746f, 
    -0.13447651f, 0.06636173f, 0.58817929f, 0.95060253f, -0.18216991f, 0.05424496f, 0.02275273f, -0.10752189f, 
    -0.18748710f, 0.44172552f, 0.32510766f, -0.20303181f, -0.42560369f, -0.13001226f, -0.23566397f, -0.18690558f, 
    -0.16094795f, 0.28145182f, 0.20280656f, -0.39051396f, 0.03586993f, 0.22979005f, 0.20752202f, 0.28011283f, 
    0.26595095f, 0.30748838f, -0.19061425f, -0.22324391f, 0.01325577f, 0.34856904f, 0.35313079f, 0.33612040f, 
    -0.69597143f, 0.00734959f, -0.02507901f, -0.70761603f, 0.03909561f, -0.02152130f, 0.12194970f, -0.02120439f, 
    -0.24726906f, 0.07342170f, 0.57218581f, 0.00952951f, 0.28773543f, 0.21008192f, -0.25177673f, -0.08503310f, 
    0.13982899f, 0.49709335f, -0.05904775f, -0.52909690f, -0.00731441f, 0.24395923f, 0.04776634f, 0.15393689f, 
    0.68859601f, 0.30001813f, 0.62658012f, 0.09262677f, 0.19583049f, -0.22160733f, -0.39064464f, 0.08556272f, 
    -0.20301864f, 0.22297615f, -0.50685900f, 0.42576125f, -0.39653921f, 0.54423189f, 0.14592378f, -0.01383167f, 
    -0.02954035f, -0.15234794f, -0.12209340f, 0.04383144f, -0.30226454f, 0.50673622f, 0.47706842f, -0.05219442f, 
    0.29534864f, -0.31137657f, -0.10035846f, 0.12579270f, 0.38958132f, 0.01001867f, -0.15768875f, 0.20307067f, 
    0.05385283f, -0.12394895f, 0.08184554f, 0.01316873f, 0.01582376f, -0.06664430f, 0.11110158f, -0.20016751f, 
    -0.20980179f, -0.24152435f, -0.15771566f, -0.10055123f, 0.07193751f, -0.09033821f, 0.17114069f, -0.07469340f, 
    -0.05820603f, -0.09931149f, 0.41454676f, -0.18548700f, -0.56112647f, -0.07974321f, -0.17786929f, 0.48117709f, 
    -0.13125777f, 0.44397509f, -0.12907052f, -0.07263926f, 0.34780902f, -0.18901983f, 0.06378976f, -0.00911769f, 
    0.02840483f, 0.00568419f, 0.21593343f, 0.04773114f, -0.04146424f, 0.23519100f, -0.11138838f, -0.09581762f, 
    -0.12124899f, -0.27887887f, -0.15650815f, -0.22361034f, -0.09962197f, -0.12658286f, -0.19720070f, -0.17640960f, 
    -0.28836253f, 0.63123131f, 0.14391531f, 0.13668828f, 0.45453885f, -0.39280942f, 0.03251418f, 0.28301004f, 
    -0.20185035f, -0.23486687f, 0.53181618f, 0.45212761f, -0.29700464f, 0.01326634f, 0.13234925f, 0.18295388f, 
    -0.23447716f, 0.17171001f, 0.10004319f, -0.12056963f, -0.07584147f, -0.15266380f, -0.11911184f, 0.11202678f, 
    0.17624184f, -0.32354429f, -0.11869300f, -0.11534321f, -0.23286298f, -0.08117389f, 0.06241475f, 0.10064509f, 
    -0.20641452f, 0.36477605f, 0.10114333f, 0.15150720f, 0.47450793f, 0.27265218f, 0.08498903f, -0.14077204f, 
    0.07446525f, -0.16816679f, 0.21014938f, 0.74435192f, -0.43143862f, 0.06027635f, 0.18618688f, 0.06706497f, 
    -0.42991471f, 0.30121160f, -0.55798072f, -0.14821492f, -0.24927346f, 0.11282291f, 0.02260314f, 0.20937921f, 
    0.19792898f, -0.41944665f, 0.53370041f, 0.28653118f, 0.25457007f, -0.09143415f, -0.08128171f, 0.54576737f, 
    -0.34028247f, -0.36194143f, -0.32985693f, 0.24642023f, 0.46296316f, 0.32317370f, 0.55137497f, -0.02640183f, 
    0.39357510f, 0.27496988f, -0.11912434f, -0.32110861f, -0.04255131f, 0.21682385f, 0.20565140f, 0.04712747f, 
    -0.14042351f, 0.16658950f, -0.03296687f, 0.17851344f, -0.59730279f, -0.30879819f, 0.07760680f, 0.52556646f, 
    0.14137933f, -0.02100869f, 0.19075078f, -0.00007152f, 0.12559657f, -0.55598360f, -0.08297290f, 0.13110022f, 
    -0.11648540f, 0.23738238f, 0.40442154f, 0.14485325f, 0.15969123f, -0.48453024f, 0.02958591f, -0.34202501f, 
    -0.01123987f, 0.00053548f, -0.21681501f, -0.06869142f, -0.07054950f, 0.18397406f, 0.03585113f, -0.08011588f, 
    0.28182459f, -0.07794268f, 0.64085531f, -0.09272642f, -0.29993463f, 0.04910310f, -0.18966505f, -0.00073216f, 
    0.72922885f, -0.23345518f, -0.14391054f, 0.26935822f, -0.15140629f, 0.31581262f, 0.09497188f, 0.30092916f, 
    -0.16705324f, 0.11231167f, 0.03983637f, 0.22966339f, 0.14707094f, 0.38502413f, 0.29983655f, -0.29052171f, 
    0.32818782f, 0.13632803f, -0.14427722f, -0.95774317f, -0.18665345f, -0.16001809f, 0.13710295f, 0.10123066f, 
    0.12944691f, 0.10022240f, -0.14140047f, -0.20315740f, -0.24785389f, 0.02826967f, 0.07644592f, -0.18419771f, 
    -0.04487086f, -0.18834862f, -0.04686391f, -0.02932282f, -0.27466640f, 0.06478200f, 0.09446472f, -0.06231106f, 
    0.42174649f, -0.52032852f, -0.01495912f, -0.25151846f, -0.70601135f, -0.11325657f, 0.57760113f, 0.11302945f, 
    -0.25936571f, -0.19132943f, -0.12925009f, -0.13727893f, 0.54765934f, -0.07613084f, 0.19237290f, 0.24801148f, 
    -0.20118132f, -0.17645684f, -0.15199050f, 0.23389059f, -0.04938385f, -0.01657271f, -0.03944194f, 0.01314691f, 
    -0.13823318f, 0.05477571f, -0.06720287f, -0.21807256f, -0.04441848f, 0.16412669f, -0.07855433f, -0.17670274f, 
    0.40554619f, 0.14829473f, 0.28435993f, -0.00471697f, -0.40992534f, 0.40729532f, 0.17243212f, -0.10791013f, 
    -0.46484226f, -0.14540341f, -0.05729683f, -0.17933245f, 0.43944606f, 0.42166483f, 0.21702507f, -0.21299975f, 
    0.09693098f, 0.11620876f, -0.18176836f, -0.05816787f, 0.01996586f, -0.22600713f, -0.14699456f, -0.15622512f, 
    0.02203012f, -0.06264722f, -0.11123925f, -0.07829949f, -0.12212351f, -0.22723597f, -0.15985471f, -0.07387361f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.30420452f, 0.03398493f, -0.37693158f, 0.23371243f, 0.29006073f, -0.00326163f, 0.27639991f, 0.51776046f, 
    0.26151624f, -0.26697296f, -0.00409839f, 0.14643690f, 0.15591332f, -0.20311154f, -0.22102931f, 0.41577998f, 
    0.09641053f, 0.07164922f, 0.22140643f, 0.16162665f, 0.13339582f, 0.23521477f, 0.34741378f, 0.07947633f, 
    -0.20574149f, -0.05856037f, -0.12136646f, 0.23329943f, -0.22847542f, -0.07113555f, 0.43421119f, -0.07912935f, 
    0.38744119f, 0.10502252f, 0.21457289f, -0.11653078f, 0.00712232f, -0.02831377f, 0.20161851f, -0.01137120f, 
    0.11867347f, -0.17122622f, -0.05451130f, -0.29209062f, 0.05957189f, 0.22522460f, -0.30838454f, 0.13395774f, 
    -0.08565901f, -0.12884910f, 0.24130806f, -0.12414370f, -0.11390731f, -0.01853376f, -0.13106884f, 0.33020681f, 
    -0.04742436f, -0.11925013f, -0.38312954f, 0.10015706f, -0.05005806f, -0.04429355f, -0.37533289f, -0.16863018f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.06737712f, -0.21712770f, 0.02087795f, -0.41433325f, 0.24686404f, -0.30769959f, 0.13145517f, 0.11621264f, 
    0.24211867f, -0.06161877f, -0.31912968f, 0.33593532f, 0.01975552f, 0.17097162f, -0.56889433f, 0.42858812f, 
    -0.50501031f, -0.00836418f, -0.40211073f, 0.31114990f, 0.17538922f, 0.20302729f, -0.50287014f, 0.10655994f, 
    0.05497908f, -0.65233201f, -0.47335538f, -0.09631217f, -0.00315329f, 0.26531717f, 0.18167894f, 0.00489155f, 
    0.20069793f, 0.03388438f, -0.46027350f, 0.19818564f, -0.35278490f, -0.29477096f, -0.17637406f, 0.02987718f, 
    0.17777772f, -0.09682982f, 0.00720629f, 0.23861080f, 0.16832428f, -0.65468401f, 0.06126638f, 0.10285602f, 
    -0.33415550f, 0.13311991f, 0.10097378f, -0.01267810f, 0.13507050f, -0.03485778f, 0.35103950f, -0.32795522f, 
    -0.45139018f, -0.48793772f, -0.13153900f, -0.11906309f, -0.03704926f, 0.11937203f, -0.15780631f, 0.03818685f, 
    -0.33427197f, -0.31145862f, -0.04228852f, -0.52460200f, 0.07272419f, 0.10483630f, 0.01980719f, -0.21128005f, 
    0.04879018f, 0.06916224f, -0.27801916f, 0.48558742f, -0.62582761f, -0.33892086f, 0.27395973f, 0.02994011f, 
    0.08757685f, -0.57359689f, 0.44896564f, 0.15121703f, 0.10312772f, 0.31220675f, -0.31660947f, -0.21193863f, 
    0.11071616f, 0.54659766f, 0.55165958f, -0.26171246f, -0.10122286f, -0.08578480f, 0.26237172f, 0.02496127f, 
    0.00334603f, 0.01536356f, 0.10754668f, 0.11912623f, 0.02418062f, -0.00146541f, -1.39568698f, -0.18805641f, 
    0.16998999f, -0.01501327f, 0.06686766f, 0.21596225f, -0.27402127f, -0.17122817f, -0.05695885f, 0.00169554f, 
    -0.04769173f, -0.11939781f, 0.27958265f, -0.09612034f, 0.18028551f, 0.24020289f, -0.31538153f, 0.47777876f, 
    0.09894470f, -0.01755557f, -0.36302471f, 0.06922764f, -0.15442257f, -0.02337942f, -0.29866976f, 0.05737913f, 
    -0.13524379f, 0.37737414f, -0.61317980f, 0.44594738f, 0.08077414f, 0.06769516f, 0.31888095f, -0.06057086f, 
    -0.00488935f, -0.03423022f, -0.50443953f, -0.35665533f, -0.76684737f, -0.39959356f, -0.07114600f, 0.14730188f, 
    0.18802744f, -0.06178197f, -0.30195069f, 0.29419881f, -0.08956880f, 0.00959556f, 0.16164406f, -0.23459961f, 
    -0.05308329f, 0.28283027f, 0.00697757f, -0.03249069f, -0.00232099f, -0.21881169f, 0.07428695f, 0.02255820f, 
    -0.04804035f, -0.04480304f, -0.21880700f, 0.10983586f, 0.02349634f, 0.49791542f, -0.11758696f, -0.79873657f, 
    -0.10645011f, -0.13280751f, -0.29307169f, 0.16766788f, -0.09616475f, 0.16707951f, -0.50849062f, 0.04894185f, 
    -0.34621263f, 0.02844129f, 0.06168231f, 0.03241166f, 0.04930354f, -0.21852952f, 0.50996351f, -0.79861116f, 
    0.29274035f, -1.21669185f, -0.05267458f, 0.04141324f, -1.09060109f, -0.04498936f, -0.32341254f, -0.03848666f, 
    0.26287717f, 0.05195268f, 0.16153412f, 0.14899258f, -0.20837393f, -0.48248860f, -0.41744485f, -0.08408029f, 
    -0.88921994f, 0.00342715f, 0.27055788f, -0.71316338f, 0.53874618f, 0.19052330f, -0.05419588f, -0.86199379f, 
    -0.62158686f, -0.14210650f, -0.03669053f, 0.16161406f, -0.74793857f, 0.01020804f, 0.19611847f, 0.22546194f, 
    -0.04773717f, -0.81465387f, -0.45221394f, 0.07393083f, -0.07599558f, -0.33318698f, -0.79089689f, -0.07953575f, 
    -0.25992781f, 0.05364268f, -0.19572993f, 0.21637921f, 0.20991060f, 0.37568262f, -0.20195451f, -0.22233574f, 
    0.17629966f, 0.16880766f, 0.10751533f, -0.29580325f, 0.26971775f, 0.13438062f, -0.03097970f, -0.07663394f, 
    0.25556603f, 0.07008744f, -0.31846640f, 0.06727429f, -0.09706907f, -0.90123415f, 0.19251563f, -0.27560607f, 
    -0.58461809f, 0.21733731f, 0.01770482f, 0.02453801f, -0.22843029f, 0.02108850f, 0.13105866f, 0.08038093f, 
    0.25952616f, 0.10667687f, -0.00296449f, -0.11287915f, -0.02454679f, 0.27292907f, -0.08887795f, 0.14432403f, 
    -0.11630628f, -0.05721648f, -0.08645403f, 0.16100821f, 0.10002214f, 0.51524252f, -0.03772224f, 0.03713025f, 
    -0.01165712f, -0.02548173f, -0.57641739f, -0.26720196f, 0.40403134f, -0.47020307f, -0.05040018f, 0.00586203f, 
    -0.03992274f, 0.04676727f, -0.48319998f, 0.24602583f, 0.05674256f, 0.25638598f, -0.00194947f, -0.07418334f, 
    0.16835926f, -0.00922324f, -0.36867604f, -0.15505879f, -0.31925148f, 0.00752271f, 0.79351652f, 0.23772885f, 
    -0.14042477f, 0.12236907f, 0.18348333f, 0.03266013f, 0.02254704f, -0.39995831f, 0.05597952f, -0.04499075f, 
    -0.02805475f, -0.01509293f, -0.13814287f, -0.02804457f, -0.09375750f, 0.09279123f, -0.12227751f, -0.52534020f, 
    -0.43094978f, -0.18060876f, -0.20909157f, 0.02880465f, 0.08703070f, -0.12262103f, 0.25737575f, -0.06198993f, 
    -0.03961723f, -0.44932011f, -0.13426408f, -0.21433316f, -0.00613402f, 0.19029739f, 0.00088444f, 0.36847422f, 
    0.24027118f, 0.12220674f, 0.23314938f, -0.74724102f, -0.66742963f, -1.00637364f, -0.24610329f, -0.09478083f, 
    0.19202197f, 0.27832627f, 0.37808087f, -0.41021869f, -0.08872616f, -0.10921047f, -0.14555778f, -0.40766415f, 
    -0.03383659f, -0.21863188f, 0.10876107f, 0.07553349f, -0.12232028f, 0.21937294f, 0.26131549f, 0.04290745f, 
    -0.01127159f, 0.04102756f, 0.08958080f, -0.16624352f, 0.09136553f, -0.14953758f, 0.03694176f, 0.14461349f, 
    0.18126263f, -0.45559922f, 0.04295021f, 0.00760364f, -0.18114223f, -0.14446907f, 0.03333423f, 0.06920648f, 
    0.02112905f, -0.04282624f, -0.01682365f, -0.15749331f, -0.63622218f, 0.24057227f, -0.02139856f, 0.42798716f, 
    -0.30473530f, 0.09598956f, 0.41067690f, -0.12796958f, 0.42304644f, 0.09666386f, -0.18122950f, -0.08340648f, 
    0.11433762f, 0.23767608f, -0.01123410f, 0.09289701f, 0.05730573f, 0.25591233f, 0.09546641f, 0.09994516f, 
    0.11662018f, 0.00788207f, -0.02865059f, 0.17512918f, -0.24809152f, 0.58311158f, -0.43231499f, -0.39078054f, 
    -0.15542170f, -0.34551173f, 0.17916302f, -0.44666862f, -0.24182320f, -0.32656506f, 0.32068878f, -0.21918377f, 
    0.03557304f, 0.18542172f, 0.32956007f, -0.00520202f, -0.08513956f, -0.10658349f, 0.13589038f, -0.05616966f, 
    0.01937328f, -0.01665296f, -0.70007664f, -1.25543332f, 0.12842493f, 0.24894223f, -0.19749145f, -0.71858013f, 
    0.11960480f, -0.20895272f, -0.19388556f, 0.22017063f, -0.06745331f, -0.44415519f, 0.11822612f, 0.00975917f, 
    0.44911465f, 0.09735120f, -0.55276513f, -0.12622809f, -0.55778188f, 0.03845757f, 0.19116287f, 0.12381616f, 
    -0.07964350f, -0.25302270f, -1.25174761f, -0.08970977f, 0.35084915f, -0.09905438f, 0.12731020f, -0.00811870f, 
    0.10068953f, -0.50733459f, 0.14596084f, 0.02325298f, -0.29454300f, -0.90217304f, -0.32032540f, -0.64791667f, 
    -0.12676616f, 0.11530402f, 0.14600526f, -0.13896602f, 0.14402920f, -0.17782438f, 0.43041202f, 0.35633582f, 
    0.14409816f, 0.10222823f, -0.52971262f, -0.17003530f, 0.04903603f, 0.21864001f, -0.98203844f, 0.03273180f, 
    0.02738285f, 0.29359856f, 0.33524367f, 0.23983133f, 0.01543245f, 0.28525302f, -0.38768607f, 0.11013870f, 
    -0.74892712f, 0.06845859f, -0.05524314f, 0.29480746f, 0.01121301f, 0.06824970f, -0.03698763f, 0.37750119f, 
    -0.66519916f, -0.90726304f, -0.01927954f, 0.07089961f, 0.11796104f, -0.25996026f, 0.22704665f, -0.08544187f, 
    -0.74886686f, 0.01296308f, 0.15947814f, 0.06879947f, 0.23039606f, 0.18674530f, 0.37606984f, -0.96044230f, 
    -0.01291384f, 0.18112062f, 0.20019245f, -0.03387284f, -0.68968171f, -0.07183333f, -0.05432684f, 0.04936862f, 
    -0.34130493f, -0.27307957f, -0.41435981f, 0.13621537f, 0.12171375f, -0.65080196f, -0.28587055f, -1.04581904f, 
    0.12598068f, -0.11465430f, -0.12159006f, -0.78538567f, -0.72298527f, 0.06888068f, 0.53280979f, 0.17482769f, 
    0.17122720f, 0.37367871f, 0.26980588f, 0.36022982f, 0.04216528f, 0.28316459f, -0.17976268f, -0.10329127f, 
    -0.04582171f, -0.60862535f, -0.86992222f, -0.16853839f, 0.01964881f, -0.61575603f, -0.30789801f, -0.03021968f, 
    0.06070954f, 0.07738222f, -0.16144498f, -0.77920252f, 0.15512216f, -0.27432698f, -0.56771511f, -0.06500682f, 
    -0.28802779f, 0.40847561f, -0.15727764f, -0.91223687f, -0.23262100f, 0.44913152f, -0.33575916f, -0.07612713f, 
    -0.30476344f, 0.06368443f, 0.40674463f, -0.20087734f, 0.48071077f, 0.01889838f, -1.32067692f, -0.07091635f, 
    -0.04529926f, 0.20821203f, -0.50942636f, 0.05365077f, -0.51306403f, 0.03368282f, -0.40589148f, -0.11758247f, 
    0.09894859f, 0.03919182f, 0.13486195f, 0.11089367f, 0.17233530f, -0.14030817f, 0.06174393f, 0.14130062f, 
    0.02261650f, -0.08152227f, -0.12763126f, -0.01403467f, 0.39797601f, -0.30046988f, 0.06055975f, 0.07074483f, 
    0.03564346f, 0.11754204f, 0.35343781f, -0.60473657f, 0.18087986f, 0.09424666f, -0.13347046f, 0.36784738f, 
    0.07443201f, 0.26733375f, -0.82655728f, 0.30752569f, 0.10710368f, 0.01024534f, 0.11486276f, -0.05409955f, 
    0.18361598f, 0.06256293f, 0.26767078f, -0.22205392f, -0.80320829f, -0.48418176f, -0.87506139f, 0.11605534f, 
    -0.27242509f, 0.34685269f, -0.10171328f, -0.33359358f, -0.29685578f, -0.37940753f, 0.21085089f, -0.02442500f, 
    -0.35143062f, -0.01580237f, -0.25445521f, -0.01523368f, 0.06348925f, 0.06813411f, 0.14199844f, -0.29616007f, 
    -0.92790502f, 0.13989092f, -0.82460892f, 0.07033469f, 0.26287362f, -0.10726596f, -0.17593019f, 0.06475350f, 
    0.06808971f, -0.34498367f, -0.13742353f, -0.35960764f, -0.82237279f, 0.43636000f, 0.13503903f, 0.31634215f, 
    -0.37518209f, -0.07373561f, 0.09292568f, -0.09909111f, -0.13871033f, -0.33917129f, -0.10459383f, -0.28159022f, 
    -0.00989310f, -0.81449556f, -0.16042407f, 0.29948950f, 0.32892966f, -0.00217697f, 0.11349902f, 0.25874373f, 
    0.01174677f, -1.26347280f, 0.40426502f, -0.18522327f, 0.03073344f, -0.21724217f, -0.73360145f, -0.01244895f, 
    -0.03424124f, -0.03825262f, -0.13944207f, 0.26155999f, 0.60645342f, 0.18380199f, -0.29755986f, -0.03551222f, 
    0.10429983f, -0.38940951f, 0.28112978f, -0.24887946f, 0.31744635f, 0.29847804f, -0.66997194f, 0.03394014f, 
    0.12199606f, -0.00224723f, 0.18126547f, -0.14598407f, -0.13998896f, -0.40399313f, -0.39694729f, 0.14605030f, 
    0.80559373f, 0.05207763f, 0.08480101f, 0.05205041f, -0.56766593f, 0.01162063f, -0.40823171f, -0.00100631f, 
    -0.15509219f, 0.44287914f, 0.09457573f, 0.54589438f, -0.37490085f, -0.07406058f, -0.19128622f, -0.22810642f, 
    -0.59770554f, 0.04937692f, 0.15728775f, 0.48954913f, -0.30341855f, 0.16643704f, -0.86663574f, -0.41615278f, 
    0.03413178f, 0.49028569f, -0.37747136f, -0.22436552f, -0.79215902f, -0.45840994f, 0.50452322f, 0.10253408f, 
    0.04414957f, -0.16511637f, 0.18125577f, -0.41866195f, -0.05902518f, 0.04100480f, -0.78963178f, -0.07158214f, 
    -0.26477200f, -0.01641078f, -0.61503279f, -0.11694001f, -0.40609384f, -0.35836601f, -0.45046383f, -0.49552444f, 
    0.26688030f, -0.03142110f, -0.00415225f, 0.37949580f, -0.05707033f, 0.43648103f, 0.05992652f, 0.00363460f, 
    -0.06910180f, -0.10269650f, -0.22116305f, 0.08269607f, -0.12838469f, -0.72753131f, -0.64160216f, -0.05895116f, 
    -0.36052668f, 0.07858943f, -0.17549902f, 0.13560794f, 0.34655854f, 0.02420059f, 0.58979756f, 0.02471429f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.00259351f, -0.06830908f, -0.02633183f, 0.16113824f, -0.08882380f, 0.11294221f, -0.20017347f, -0.37637496f, 
    0.15446758f, -0.09978264f, -0.07967217f, 0.05076677f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
