#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.69152445f, -0.81950301f, 0.06601287f, -0.16744427f, -0.33584452f, -0.40707886f, 0.00652819f, 0.22034267f, 
    -0.07577664f, -0.05009740f, 0.08066039f, -0.12064484f, -0.08918284f, -0.31250080f, -0.25250036f, 0.46290636f, 
    0.28675991f, 0.05824882f, -0.33278269f, -0.23637486f, -0.38865671f, -0.01264288f, 0.17358354f, 0.08894965f, 
    -0.24543658f, -0.51437968f, -0.67261297f, 0.30329069f, 0.67676294f, 0.03717212f, -0.45617276f, -0.20724702f, 
    0.36138141f, -0.42335626f, -0.22878790f, 0.30908984f, 0.28717524f, 0.38203630f, 0.10465498f, 0.25149915f, 
    -0.07112137f, 0.34501520f, 0.35064125f, -0.05360708f, 0.38864562f, -0.02444433f, -0.32338795f, -0.04355912f, 
    0.30690211f, -0.22826006f, 0.22081575f, 0.12129477f, -0.51713914f, 0.17750022f, -0.62708414f, 0.14020556f, 
    -0.88038409f, -0.29476991f, -0.04868030f, -0.05142550f, -0.50770438f, -0.10439084f, 0.11353941f, 0.15863810f, 
    -0.00176002f, 0.14056709f, 0.11429945f, 0.12906604f, -0.02990333f, 0.00707480f, 0.31894219f, 0.06041270f, 
    0.47020620f, -0.30915552f, -0.28518751f, 0.31891522f, 0.85210162f, 0.16421615f, -0.20918405f, 0.21133202f, 
    -0.68128991f, -0.65284735f, -0.40208903f, -0.99554718f, -0.27168441f, 0.32785273f, 0.36675873f, -0.02706682f, 
    0.07224198f, -0.15253058f, 0.02808354f, -0.01035283f, 0.04199632f, -0.22741841f, 0.27482688f, 0.22579832f, 
    0.03440706f, -0.18409744f, 0.01715684f, 0.04171460f, 0.71430790f, -0.37948617f, -0.87711412f, 0.53112638f, 
    -0.03369714f, 0.01673125f, -0.03095848f, -0.27189124f, -0.06791729f, -0.25204772f, -0.11530884f, 0.47979814f, 
    -0.06969971f, 0.37261358f, -0.27507704f, 0.02097841f, -0.11080690f, -0.21505454f, -0.05557275f, -0.20182689f, 
    0.19397075f, -0.11261953f, 0.11665133f, -0.04853200f, 0.04989187f, 0.99376369f, 0.22680221f, 0.26837713f, 
    0.85526443f, 0.78310859f, -0.54253834f, 0.06028952f, -0.17353088f, -0.19636935f, 0.18841662f, 0.24227609f, 
    0.14364634f, 0.13113637f, -0.05484627f, -0.01692559f, 0.02444029f, 0.15022194f, 0.26731378f, 0.15431088f, 
    0.06985237f, 0.01846033f, 0.06991480f, -0.02418854f, -0.01115263f, 0.07777956f, -0.04711100f, -0.40639421f, 
    -0.63567352f, -0.70532775f, -0.28114831f, 0.04105127f, 0.37985474f, 0.55544335f, 0.16995843f, 0.38174191f, 
    0.00209822f, -0.13921040f, -0.54460442f, -0.41956076f, -0.03255676f, -0.02719033f, -0.00964576f, 0.11281291f, 
    0.04805413f, 0.40171096f, -0.10025769f, -0.07955293f, -0.45076877f, 0.07288489f, -0.16644751f, 0.37506568f, 
    -0.11467785f, -0.51493192f, -0.38599277f, 0.11405739f, 0.02431034f, -0.41518316f, 0.03467941f, 0.33748239f, 
    -0.38523138f, -0.58746272f, -0.10143223f, 0.20600340f, -0.27475777f, -0.55928683f, -0.23577021f, 0.25095969f, 
    0.14273350f, 0.48432255f, -0.05697915f, -0.27142194f, -0.02867801f, -0.33316714f, -0.16470891f, -0.00689464f, 
    0.70533752f, 0.45447582f, 0.94699103f, 0.21603113f, -0.21646288f, -0.47029468f, -0.50155777f, -0.27463716f, 
    0.38161805f, -0.29826906f, -0.19429839f, 0.05613616f, -0.10470001f, -0.02084424f, -0.25040391f, -0.07457230f, 
    -0.02252507f, -0.05977163f, -0.32900062f, -0.20082945f, 0.04878058f, 0.10636245f, 0.02496666f, 0.02039791f, 
    0.09966199f, -1.17262185f, 0.67770332f, 0.27582273f, -0.15427390f, 0.07386927f, -0.52204102f, 0.65686631f, 
    0.27290505f, 0.01122114f, 0.07671969f, -0.29658633f, 0.00695077f, 0.34296095f, -0.06318571f, -0.02789840f, 
    0.15083726f, -0.13030477f, 0.18319060f, -0.03759701f, -0.29984471f, 0.15870343f, 0.17659368f, 0.02318863f, 
    0.18759973f, -0.00744297f, -0.42201746f, 0.27508357f, 0.30301666f, -0.81418419f, 0.51969022f, -0.45692083f, 
    -0.01654777f, -0.02453665f, -0.43443400f, -0.42923585f, 0.20608671f, 0.17138307f, 0.12411502f, 0.16485763f, 
    0.02637050f, 0.18043227f, -0.18349178f, -0.22058052f, -0.06878550f, 0.12572759f, 0.07296541f, 0.15721321f, 
    0.40906182f, 0.29229712f, 0.06261344f, -0.66374213f, 1.05607557f, 0.09025587f, -0.52545601f, -0.56497204f, 
    -0.02545816f, 0.40547219f, -0.32393703f, 0.15555853f, -0.59917241f, -0.11842115f, 0.05055602f, -0.23662594f, 
    -0.16823876f, 0.12471201f, 0.01477916f, 0.14322421f, 0.08603729f, 0.04938932f, 0.03374266f, -0.01124760f, 
    -0.14372237f, -0.16592430f, 0.04548003f, 0.12447901f, 0.04210496f, 0.73974103f, 0.47241935f, 0.82590228f, 
    0.03968236f, 0.35116526f, 0.34222585f, 0.43712965f, 0.30134353f, 0.33037081f, -0.39282894f, 0.11894850f, 
    0.00306543f, -0.03071438f, -0.04839522f, -0.11006314f, 0.11834358f, 0.11814770f, 0.15168735f, -0.12435480f, 
    -0.11953194f, -0.27239725f, -0.45661601f, -0.21120428f, 0.03353408f, -1.01223779f, -0.63737947f, -1.07510364f, 
    -0.26059839f, -0.49198955f, 0.37609455f, 0.20788151f, -0.04699258f, 0.22825767f, -0.00460254f, 0.02962310f, 
    0.09027353f, 0.20078506f, 0.17453700f, 0.17342706f, 0.00828070f, 0.04383716f, -0.10085919f, -0.24309698f, 
    0.01309411f, 0.16182396f, 0.03512210f, 0.25564051f, -0.05662301f, -0.04705955f, 1.13985527f, 1.06032085f, 
    -0.39669466f, 0.13793916f, -0.13931540f, 0.05485242f, 0.50024837f, -0.18229805f, 0.25601301f, 0.19357249f, 
    0.08344039f, -0.02406116f, -0.01243313f, -0.10825508f, 0.15348393f, -0.16757308f, -0.00721016f, -0.10926272f, 
    -0.05786891f, 0.14436257f, -0.07088541f, 0.19738519f, 0.06654921f, 0.10491545f, 0.07847928f, 0.64076662f, 
    -0.40304515f, -1.05741084f, -0.17622814f, 0.17534725f, -0.69365162f, 0.27108067f, 0.77582788f, -0.07644073f, 
    0.01286089f, -0.08030265f, -0.20290004f, 0.21934901f, -0.27902928f, 0.24572226f, 0.04121010f, -0.35011250f, 
    -0.18976432f, 0.02487335f, -0.01762605f, 0.15054345f, 0.15643650f, -0.11715883f, 0.13542739f, -0.10149140f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01663889f, 0.26062652f, 0.14778535f, 0.11660251f, 0.10089502f, -0.12247162f, -0.07988731f, -0.10909826f, 
    0.20390841f, 0.28695303f, 0.05154737f, 0.08335431f, 0.06271406f, -0.00075237f, 0.23462103f, 0.01114824f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.30513865f, -0.02120985f, -0.24328177f, 0.27604795f, -0.05391499f, 0.10712922f, 0.01204704f, -0.01958990f, 
    -0.03682967f, 0.07231076f, 0.15815085f, 0.09527589f, 0.15352090f, 0.21120813f, -0.06755202f, 0.18834640f, 
    -0.14910211f, -0.08469447f, -0.22614966f, 0.08970875f, -0.11597407f, -0.09982137f, -0.06000266f, -0.18618628f, 
    -0.17677900f, -0.13189189f, 0.00416857f, -0.24331763f, -0.06043938f, 0.15726435f, 0.23412779f, -0.06474450f, 
    0.12647805f, -0.11535300f, 0.00396552f, 0.06137911f, -0.13750769f, -0.16779660f, 0.00702050f, -0.02200887f, 
    -0.02442551f, 0.10555257f, 0.03722454f, -0.07757613f, -0.01856473f, 0.14048937f, -0.00871671f, -0.06990290f, 
    -0.39928567f, 0.01543402f, -0.13101423f, -0.22316405f, 0.17107718f, -0.00413811f, 0.00307742f, 0.06332970f, 
    0.10363390f, 0.25146046f, -0.07742932f, 0.04289218f, -0.05360380f, 0.00474662f, -0.08424748f, 0.07093921f, 
    0.32174465f, -0.10265084f, 0.16062194f, -0.08839347f, 0.00957595f, -0.12216759f, -0.06141034f, 0.01451288f, 
    0.01899880f, -0.12371486f, 0.24331255f, 0.47933650f, 0.03977653f, -0.12771600f, 0.03857950f, 0.20587495f, 
    -0.06888080f, 0.09932277f, 0.19244881f, -0.06717648f, -0.47436267f, -0.08086994f, -0.20281342f, 0.23789996f, 
    -0.02644251f, -0.02011821f, -0.02639206f, 0.01555092f, -0.07139156f, 0.07234988f, -0.07138186f, -0.03699848f, 
    0.20762135f, 0.17129236f, 0.16527958f, -0.24737997f, 0.02877034f, 0.19468018f, 0.05503036f, -0.05347065f, 
    -0.00284928f, 0.10496687f, 0.28233156f, 0.00138352f, 0.43926236f, 0.07203660f, -0.22198246f, -0.03298881f, 
    -0.02212603f, 0.12342560f, 0.14002520f, 0.16083869f, -0.05640076f, -0.06653176f, 0.02985118f, 0.00977114f, 
    0.03843121f, 0.05728020f, -0.32840917f, -0.04769758f, -0.23447463f, -0.09910800f, 0.01518663f, -0.17950094f, 
    -0.22074965f, -0.01587885f, 0.12777025f, -0.09232946f, -0.38767105f, -0.20665199f, -0.27074814f, -0.46795169f, 
    0.06807879f, 0.03148015f, 0.02026547f, 0.13260415f, 0.09708499f, 0.04531987f, 0.00539166f, 0.08792391f, 
    0.10759487f, -0.23961444f, 0.03861639f, -0.08257011f, 0.13288504f, 0.11721501f, 0.10109359f, 0.14044710f, 
    0.08651424f, 0.03851257f, 0.08745126f, 0.20790811f, -0.08700520f, -0.12535535f, 0.12971231f, 0.36690465f, 
    0.05740573f, -0.02049941f, -0.29640204f, 0.14892310f, 0.04535142f, -0.05737792f, -0.07704370f, 0.00240010f, 
    0.61389840f, -0.02789398f, 0.40991575f, -0.18678680f, 0.26622328f, 0.05923828f, 0.10452299f, -0.02385115f, 
    -0.01635116f, 0.03923173f, 0.04107466f, 0.23187582f, 0.48861462f, 0.15628205f, -0.27586663f, 0.33967164f, 
    0.08383922f, 0.11130472f, -0.08944352f, 0.17186102f, -0.00957182f, 0.11110163f, -0.05161053f, -0.01774979f, 
    0.02731270f, 0.14090842f, 0.06534993f, -0.28639901f, -0.08831185f, -0.07953893f, 0.16754000f, -0.16690293f, 
    -0.06360428f, -0.08425844f, 0.19297777f, 0.12474313f, 0.26398453f, 0.30075574f, 0.17652914f, 0.14221372f, 
    0.04344293f, 0.12485959f, 0.04675639f, 0.01593423f, 0.06699901f, 0.00630263f, -0.04247838f, -0.14244381f, 
    -0.17216188f, 0.04508934f, 0.11432390f, 0.09761447f, 0.17654477f, 0.18060891f, -0.04119115f, 0.00495034f, 
    -0.08857261f, 0.01735200f, -0.09637596f, 0.02395985f, 0.45378435f, 0.35402790f, -0.21627928f, -0.32256314f, 
    0.28491098f, 0.14988361f, 0.03786960f, 0.07223437f, 0.02976592f, 0.06061324f, 0.03717608f, -0.04675190f, 
    0.16391872f, -0.37926140f, 0.00051300f, -0.24140367f, 0.06719294f, 0.03873621f, -0.13487759f, 0.13319966f, 
    -0.02659659f, 0.05435897f, -0.02927210f, 0.03197161f, 0.33307344f, 0.27075788f, -0.05253881f, -0.00207299f, 
    0.02547756f, 0.01041478f, 0.00840953f, 0.01486844f, -0.18124090f, -0.03694612f, 0.00812532f, -0.03973854f, 
    -0.11288948f, -0.14717636f, 0.02742035f, -0.10823516f, -0.07900934f, -0.11569557f, 0.11630539f, 0.09141129f, 
    -0.04621073f, -0.09268181f, -0.13892999f, -0.10369884f, -0.30486691f, -0.15033814f, -0.08516813f, -0.18726234f, 
    0.10262872f, 0.08482894f, 0.18953823f, -0.12039643f, 0.09977675f, 0.09139777f, -0.02716970f, 0.01474364f, 
    -0.41212261f, 0.23541746f, 0.00640468f, -0.22868797f, 0.18058448f, 0.02111342f, 0.00306086f, 0.03033569f, 
    0.03451166f, 0.06482794f, 0.00746582f, -0.00148850f, 0.10201310f, 0.05309378f, -0.19805463f, 0.00564670f, 
    0.01164650f, 0.13121670f, 0.02204615f, 0.06560813f, -0.07145066f, 0.09297384f, 0.05732630f, 0.05259945f, 
    0.08830914f, 0.12850052f, -0.27155513f, -0.08065785f, 0.15945770f, 0.23690321f, 0.03086112f, -0.16054580f, 
    0.07604112f, 0.04880537f, -0.14796804f, 0.03098881f, 0.07123745f, -0.10056707f, -0.43168443f, 0.16076499f, 
    0.00023297f, 0.05783120f, -0.05281761f, -0.03188024f, -0.12772357f, -0.02033761f, -0.15701798f, -0.07669637f, 
    -0.05752443f, 0.04068603f, -0.13195336f, -0.21314828f, -0.13485636f, -0.18828005f, -0.10909776f, -0.05401678f, 
    0.10445672f, 0.08466820f, -0.00382060f, 0.07377195f, 0.49026394f, 0.05698514f, 0.15182386f, -0.13719828f, 
    -0.37782627f, -0.12132034f, -0.02949596f, -0.13233785f, -0.02937360f, -0.02749362f, 0.00266807f, -0.07801378f, 
    -0.11459373f, 0.07835404f, -0.13572152f, 0.25554848f, 0.10929734f, 0.01403155f, 0.17121814f, -0.03304258f, 
    0.08042319f, 0.02109385f, 0.08810506f, 0.12076335f, 0.04390062f, 0.01068492f, -0.01127833f, 0.16921589f, 
    0.16828214f, -0.04096804f, 0.14097823f, 0.11743237f, 0.09231515f, -0.01631387f, 0.04848104f, 0.14099741f, 
    0.06675430f, -0.04697778f, 0.07216538f, -0.03485559f, -0.07646577f, 0.05475171f, 0.01924253f, 0.05735540f, 
    0.05389380f, 0.01052357f, 0.00186186f, -0.04598303f, 0.05712099f, 0.04472779f, -0.06009888f, -0.04022949f, 
    0.06181722f, -0.01735416f, -0.05954879f, 0.02478757f, -0.01628822f, -0.06659120f, -0.05184158f, 0.02168701f, 
    -0.01732371f, -0.04737253f, 0.06593089f, -0.07102177f, -0.02789721f, -0.01109252f, -0.05416899f, 0.02428881f, 
    -0.05662782f, -0.07374126f, -0.04527014f, 0.06407101f, -0.06375489f, 0.01433253f, -0.01465276f, 0.02250361f, 
    0.05758442f, -0.02341490f, -0.06602454f, 0.04379738f, -0.03768204f, -0.01577625f, -0.01943677f, -0.01938947f, 
    -0.05969954f, -0.02829118f, 0.06223210f, -0.00299920f, -0.06020620f, -0.04204936f, -0.07336285f, 0.05586502f, 
    0.05267694f, 0.02797529f, -0.03240068f, -0.05826835f, -0.03973846f, -0.04213070f, -0.02259853f, 0.06593869f, 
    0.04261626f, -0.03325380f, -0.05215939f, -0.01156034f, 0.03497435f, 0.00458049f, -0.03632984f, -0.04542549f, 
    0.03507632f, 0.01892772f, 0.04996933f, -0.05668333f, -0.07600711f, -0.02363343f, 0.04188927f, -0.02366795f, 
    -0.03821260f, -0.03468994f, -0.01147317f, -0.04694239f, -0.03043067f, -0.01352798f, 0.00909952f, 0.00281749f, 
    -0.01114442f, 0.04567855f, -0.05576103f, -0.00475447f, -0.00910236f, -0.00422479f, -0.03062842f, -0.00182424f, 
    -0.03607430f, 0.00822491f, 0.02777904f, -0.05181030f, 0.03984680f, 0.06268983f, -0.05919119f, -0.03017807f, 
    0.04028231f, -0.03530805f, -0.06273472f, 0.01979331f, 0.02095848f, -0.00805561f, 0.05918896f, -0.02772867f, 
    -0.02924719f, 0.00303788f, -0.01377574f, 0.02186617f, -0.00521506f, -0.06367156f, -0.05359247f, -0.03316681f, 
    0.00841193f, 0.05784730f, -0.05946967f, -0.04278674f, -0.07263465f, 0.00507925f, -0.04549896f, -0.06576874f, 
    -0.00494847f, 0.06302246f, -0.07553721f, -0.02219814f, 0.02207912f, -0.00308206f, -0.03376601f, 0.06293602f, 
    -0.00594904f, 0.01620580f, -0.03259027f, -0.01681699f, -0.04588368f, -0.05241186f, 0.02447980f, -0.05453519f, 
    -0.03929348f, -0.02261460f, 0.03088333f, 0.04646917f, -0.01038291f, -0.02747737f, 0.00927275f, -0.06840094f, 
    -0.01487305f, -0.04492586f, -0.00847268f, -0.07573991f, 0.00521298f, 0.03747560f, -0.03824145f, 0.01006970f, 
    -0.00878585f, 0.00812895f, 0.04173663f, -0.02313198f, 0.02577125f, 0.01584215f, 0.00171405f, 0.06058557f, 
    0.02872718f, -0.05531363f, 0.06023310f, -0.06050590f, -0.06682542f, 0.01025000f, -0.05970860f, 0.04712733f, 
    0.00626470f, -0.05523957f, -0.00078705f, 0.03017672f, 0.00812675f, -0.00871987f, 0.05848821f, -0.07098918f, 
    0.00741543f, 0.04789636f, -0.05744435f, -0.04169591f, -0.07162489f, -0.03525275f, 0.01783796f, -0.03375524f, 
    0.00789036f, -0.03284099f, 0.00407993f, 0.06357595f, -0.02791694f, -0.02220092f, -0.07621209f, -0.01864287f, 
    0.05564828f, -0.02954500f, -0.03536001f, -0.01463775f, -0.03168926f, -0.05751198f, -0.00858172f, 0.06161974f, 
    0.01365131f, 0.04605155f, 0.01891542f, 0.05966344f, 0.01145871f, 0.00286151f, -0.01790462f, -0.07837307f, 
    0.05808309f, -0.02410270f, -0.04337782f, 0.03908670f, -0.00110011f, -0.02880635f, -0.06450968f, -0.03631879f, 
    0.04149904f, -0.01110450f, 0.02689484f, -0.02820386f, 0.00054120f, -0.02194572f, 0.05887619f, -0.04590852f, 
    -0.05038636f, 0.04002701f, 0.06061287f, 0.03660793f, -0.05325956f, -0.07582015f, -0.08462891f, -0.01724569f, 
    0.05762807f, -0.05903108f, -0.05724997f, 0.00412461f, -0.06788514f, -0.07616691f, -0.05222892f, -0.08082445f, 
    0.03930669f, -0.05157069f, -0.04456565f, -0.01415415f, 0.02970360f, 0.00113877f, 0.03128833f, 0.00638136f, 
    0.05448837f, 0.05013569f, 0.02697678f, -0.05013695f, -0.06869385f, -0.00344352f, -0.01866546f, 0.05695877f, 
    -0.06515194f, -0.01219215f, -0.03507530f, -0.00487356f, -0.05646785f, -0.06739702f, 0.01573057f, 0.06106530f, 
    0.00869859f, -0.00781923f, -0.06280765f, -0.04552003f, 0.01632430f, -0.02948338f, 0.04887564f, -0.04970204f, 
    -0.04930377f, 0.05274922f, -0.07639934f, -0.07725274f, 0.00060503f, -0.00471107f, -0.05114735f, 0.04770929f, 
    -0.06856267f, 0.02090539f, -0.00798547f, 0.04237402f, 0.00010989f, -0.00356506f, -0.01769755f, 0.05044462f, 
    0.03257353f, 0.03301751f, 0.02406168f, -0.00744989f, 0.05744443f, 0.05560848f, -0.05937840f, -0.04971737f, 
    -0.01991033f, -0.05679084f, 0.04771793f, -0.05872980f, 0.05470867f, -0.04222801f, 0.05449689f, 0.01495249f, 
    0.05829258f, -0.07904475f, -0.00459198f, -0.04769263f, -0.07445875f, -0.06088915f, -0.03847722f, -0.03832427f, 
    -0.02543874f, -0.07384229f, -0.05713393f, 0.01991372f, -0.06441652f, -0.05351821f, 0.02511833f, -0.00891952f, 
    -0.06218835f, -0.06193544f, -0.02644016f, -0.00481981f, 0.02536645f, 0.00511101f, 0.02951890f, 0.06044114f, 
    -0.01000971f, 0.01967225f, 0.00012829f, 0.03948431f, -0.04840500f, -0.03990552f, -0.08262213f, -0.06250777f, 
    0.05569680f, -0.05942985f, 0.02360174f, -0.05616088f, 0.02234874f, 0.04251755f, 0.05028407f, -0.05458191f, 
    -0.00656996f, 0.00386315f, 0.03466612f, -0.02242445f, -0.01369532f, 0.04862765f, -0.06742024f, -0.00835507f, 
    -0.02558197f, 0.00845912f, -0.02644151f, 0.03668379f, -0.00569639f, -0.04496460f, 0.01576114f, -0.06204779f, 
    -0.05938418f, 0.03169887f, 0.04562619f, -0.02037414f, -0.06548624f, 0.05869593f, -0.05058222f, 0.06239188f, 
    0.00662362f, -0.00724855f, -0.00586681f, 0.00324642f, 0.00688478f, 0.00045636f, -0.03592389f, -0.02772495f, 
    0.19226025f, -0.25853711f, 0.20435438f, 0.18427198f, 0.07357293f, 0.07261188f, -0.04738429f, 0.10544126f, 
    -0.08808705f, 0.09831142f, -0.10720407f, 0.07233321f, 0.22510457f, -0.06073757f, -0.18045920f, 0.19672048f, 
    0.00393941f, -0.07856163f, -0.00757491f, 0.02385342f, -0.02448604f, 0.03377942f, -0.12201847f, -0.09460352f, 
    -0.20078823f, -0.16546169f, 0.03768362f, -0.17267533f, -0.04601704f, 0.05216447f, 0.03294688f, -0.06590910f, 
    0.04955983f, 0.00927465f, -0.01125945f, -0.02732657f, -0.25820905f, 0.12360314f, 0.16873616f, -0.48770291f, 
    -0.03473910f, 0.08768386f, 0.03946931f, -0.06559265f, 0.12165186f, 0.09800723f, -0.06269462f, -0.09037409f, 
    0.28391847f, 0.13011971f, 0.08470593f, 0.27849817f, -0.06846150f, 0.05633749f, 0.02969621f, 0.06827915f, 
    -0.15473478f, -0.03313570f, -0.00568979f, -0.07703257f, 0.17099093f, -0.06317294f, 0.02252244f, 0.45066798f, 
    0.08398467f, 0.04869279f, -0.09872700f, 0.03938228f, -0.11112842f, -0.04883894f, 0.02965620f, -0.14501593f, 
    0.21890165f, 0.11502656f, 0.29398021f, 0.01011741f, -0.11035417f, 0.12489881f, 0.04097195f, 0.17140982f, 
    0.03981863f, -0.15479669f, 0.07821093f, 0.04518358f, -0.02284200f, -0.04717429f, 0.15369402f, -0.24720033f, 
    0.08439872f, 0.03640619f, -0.12987198f, 0.14206831f, 0.05298973f, 0.00072391f, 0.01455340f, 0.02879600f, 
    -0.06829659f, -0.10759997f, -0.08958449f, 0.17075124f, 0.03951149f, -0.00310637f, -0.07753408f, -0.14422350f, 
    -0.07557907f, 0.06063848f, -0.15377566f, -0.04338134f, 0.38350120f, -0.11561556f, 0.32067806f, 0.03470669f, 
    0.09108251f, 0.15541375f, 0.02432961f, -0.03123868f, -0.04471610f, -0.02692372f, -0.08954970f, -0.02004160f, 
    0.08749151f, 0.04757801f, -0.08117943f, -0.37633359f, 0.16505432f, 0.04367778f, -0.04594452f, -0.04402445f, 
    0.21659677f, 0.10105319f, 0.05963109f, 0.04139598f, 0.27873597f, 0.28669742f, 0.02687251f, -0.48287469f, 
    -0.02755223f, 0.17855026f, 0.00559707f, 0.00812420f, -0.11082792f, 0.04705722f, -0.07990500f, 0.02707771f, 
    0.13873124f, -0.21035172f, -0.21001670f, 0.55247420f, -0.09476610f, -0.04757337f, -0.01330382f, -0.12706602f, 
    -0.08042714f, 0.06414692f, -0.01525623f, 0.11526890f, 0.40278709f, 0.22433682f, 0.36328980f, -0.00654757f, 
    -0.04400403f, -0.02997108f, -0.07276396f, 0.04676616f, -0.10218637f, -0.16205645f, -0.07944220f, 0.07545171f, 
    0.24466072f, 0.07793061f, 0.01867205f, 0.00829897f, -0.00964436f, -0.08873114f, 0.09787544f, 0.05844431f, 
    0.07674105f, -0.03234989f, -0.03458610f, 0.05999869f, 0.42849219f, 0.19540615f, 0.08466354f, 0.05763947f, 
    -0.07466022f, -0.02354153f, 0.03129665f, 0.08447310f, -0.06167893f, 0.06536794f, -0.10097536f, 0.09296794f, 
    -0.42373347f, 0.01333511f, 0.32253850f, -0.04993284f, 0.12399156f, 0.02826581f, 0.09766952f, -0.11365283f, 
    0.09112088f, -0.04252917f, -0.28527755f, 0.02449246f, 0.03874599f, -0.06849051f, -0.03354765f, -0.15788390f, 
    0.11041337f, -0.11413685f, -0.04019731f, -0.10532455f, 0.05243764f, 0.19353959f, 0.27915850f, 0.25496998f, 
    -0.00576433f, 0.05164108f, -0.09254930f, -0.23428389f, 0.02391020f, -0.14890899f, 0.01758580f, 0.05794101f, 
    0.16569774f, 0.12945336f, 0.06813147f, 0.01049970f, 0.17686808f, 0.05826209f, -0.45324594f, 0.35078970f, 
    -0.09140976f, -0.09035245f, -0.08625473f, 0.08497247f, -0.00256422f, 0.16122285f, 0.06619554f, 0.10080256f, 
    -0.03140654f, -0.03059383f, 0.20573489f, 0.03352529f, 0.00806665f, -0.10964429f, 0.09845901f, -0.10469011f, 
    0.02901989f, -0.18054029f, -0.11974981f, 0.08276508f, -0.19640853f, -0.28433487f, -0.20314580f, 0.20183621f, 
    0.31730255f, -0.02477550f, 0.00954063f, -0.05557553f, 0.06953609f, 0.03116003f, 0.09880151f, 0.08548792f, 
    0.44575107f, 0.49218610f, -0.04734883f, -0.12966113f, -0.09149558f, -0.16511779f, -0.04640012f, -0.26800856f, 
    -0.05157515f, 0.14068285f, -0.33696148f, -0.05933628f, 0.09344132f, 0.23613961f, -0.00470992f, 0.09577647f, 
    0.10236181f, 0.05332282f, -0.15414511f, -0.08913676f, -0.03567667f, -0.13386910f, 0.18258740f, -0.14956468f, 
    0.20573981f, -0.23753609f, -0.12595031f, 0.05907983f, 0.12915234f, 0.11083837f, -0.01942273f, -0.03726320f, 
    0.02726295f, -0.17431538f, -0.00683069f, 0.06858542f, -0.23817520f, -0.01256190f, 0.08707293f, 0.03835396f, 
    0.08090549f, 0.07972907f, -0.11814276f, -0.02491611f, 0.14133349f, 0.05647678f, 0.24128909f, 0.02875743f, 
    0.04572383f, -0.01280631f, 0.32807386f, 0.28120625f, -0.02637555f, -0.10335489f, 0.18759108f, 0.01845532f, 
    -0.04430750f, 0.15882435f, -0.04798261f, 0.12989445f, -0.10389624f, 0.06139340f, 0.04862107f, 0.04129686f, 
    -0.02510393f, -0.13294083f, -0.22820072f, -0.02259828f, 0.02350258f, -0.01966058f, 0.24474345f, 0.14240013f, 
    0.06552687f, -0.04871176f, 0.06818338f, 0.02279554f, 0.31348571f, 0.17020299f, -0.25005984f, 0.00943395f, 
    0.01662754f, -0.05583771f, 0.13310723f, -0.14079858f, -0.07146199f, 0.30302516f, 0.22608300f, 0.00716848f, 
    0.04320383f, 0.05580040f, 0.21320303f, -0.01128800f, -0.07530110f, -0.10005050f, 0.04960994f, 0.01572423f, 
    0.24429286f, 0.09347866f, -0.03825949f, 0.07017322f, 0.06537101f, 0.06136372f, -0.06169078f, -0.14888909f, 
    0.07669678f, 0.04961356f, 0.00088322f, -0.20247826f, -0.19557226f, 0.45721054f, 0.13566451f, -0.14269590f, 
    -0.06087676f, 0.10108774f, 0.04656773f, 0.19018622f, -0.09897903f, 0.17086034f, -0.19742630f, 0.08580918f, 
    0.00135107f, 0.06633897f, -0.00935826f, -0.05261112f, -0.07634851f, 0.00033327f, 0.03187739f, 0.04406852f, 
    -0.06030621f, -0.05215553f, 0.00316698f, -0.00416177f, -0.05788761f, -0.01544035f, -0.00157601f, 0.00239005f, 
    -0.00542338f, -0.06448855f, 0.00260038f, -0.06147818f, 0.01163888f, -0.05737286f, 0.05349585f, -0.04342926f, 
    -0.05297593f, -0.01978412f, -0.04626782f, -0.07287485f, 0.03773655f, -0.03059079f, 0.01295474f, 0.02457011f, 
    -0.01273991f, -0.01562500f, -0.03657470f, -0.06406457f, -0.02953717f, 0.00904194f, 0.01084072f, -0.00000248f, 
    -0.02827360f, -0.04095839f, -0.06577905f, 0.00672804f, 0.06130858f, -0.06882185f, 0.02423469f, 0.03988903f, 
    -0.07255492f, -0.05295986f, -0.03872513f, -0.03297780f, -0.04507901f, -0.01999480f, -0.01478430f, -0.01304401f, 
    -0.02657865f, 0.05031366f, -0.02876263f, 0.03880867f, 0.06648998f, -0.02397336f, 0.04210455f, 0.06561246f, 
    -0.06593475f, -0.05898267f, -0.03903256f, 0.01391747f, -0.00387068f, -0.06159421f, -0.07019981f, 0.03152279f, 
    0.04789531f, 0.04324215f, 0.02348563f, 0.05606259f, 0.02539423f, 0.02605993f, 0.02551099f, -0.07480785f, 
    0.00780299f, -0.01379632f, 0.02773491f, 0.05455837f, -0.05301311f, -0.02490684f, -0.04789718f, 0.01743471f, 
    0.00325841f, 0.06181431f, 0.04366650f, -0.00331078f, 0.01916249f, 0.04255881f, -0.01210028f, -0.05923770f, 
    -0.07709017f, -0.03727820f, -0.04501009f, -0.06073625f, -0.02444637f, -0.01111616f, 0.04406874f, -0.07211811f, 
    -0.05323657f, -0.04315463f, -0.04901406f, -0.06462541f, -0.07024148f, -0.07331785f, 0.01793730f, -0.01053471f, 
    -0.03227229f, 0.02980642f, 0.03680791f, -0.03128991f, -0.07612563f, 0.06052993f, -0.06982621f, 0.04678568f, 
    -0.00993404f, -0.02160671f, -0.05363030f, -0.03301486f, -0.01090296f, 0.02295148f, -0.05505954f, -0.04024827f, 
    0.03703807f, -0.02748692f, -0.01563707f, 0.05195271f, 0.03669416f, -0.04725070f, 0.02135774f, -0.04340960f, 
    0.03519163f, 0.00377069f, -0.03739625f, 0.05490865f, -0.04203397f, 0.03735818f, -0.00532261f, -0.03892612f, 
    0.06137086f, -0.05326912f, 0.06197273f, 0.03390056f, 0.04931032f, -0.01438997f, 0.06384901f, -0.06836163f, 
    0.05675827f, 0.00543331f, 0.01343609f, 0.01263976f, -0.06937265f, 0.06599075f, -0.07580078f, 0.01703325f, 
    0.03535409f, -0.02507609f, 0.05704003f, -0.00574303f, 0.04018837f, 0.04856784f, 0.04044986f, -0.05520405f, 
    -0.06745432f, -0.04460231f, -0.07124752f, -0.07440385f, 0.04663177f, 0.05114848f, -0.02183522f, -0.00443670f, 
    -0.01755650f, -0.07727255f, -0.00549565f, 0.05057657f, -0.05300086f, 0.05565128f, 0.04633621f, -0.07444623f, 
    0.03589832f, -0.02400672f, -0.05090365f, -0.03469746f, -0.05778095f, 0.02076313f, 0.04717349f, -0.02432407f, 
    -0.10345056f, 0.02525056f, 0.17046770f, -0.00314842f, 0.10362097f, 0.08689674f, -0.02746821f, 0.02799273f, 
    -0.06244191f, 0.06044904f, -0.00756696f, 0.03572217f, -0.12424318f, -0.09142394f, 0.05278572f, -0.28032336f, 
    0.28074694f, -0.13695030f, 0.03652252f, 0.12891905f, 0.14351194f, 0.16677462f, -0.14616379f, -0.06407755f, 
    0.22938040f, 0.18731891f, 0.08696181f, 0.03387687f, -0.01340159f, 0.11562324f, -0.01560242f, 0.12242996f, 
    0.12552778f, 0.08861359f, 0.03534931f, 0.08916035f, 0.03748784f, -0.21199231f, -0.03712285f, 0.06133305f, 
    -0.09452769f, -0.12018704f, -0.13095756f, 0.02389793f, -0.02307310f, -0.00560933f, 0.01915544f, -0.02198131f, 
    -0.05024639f, 0.48636767f, 0.00759185f, 0.05939989f, 0.10649642f, -0.03029348f, 0.10304248f, -0.04074206f, 
    0.01641268f, 0.01721554f, 0.21837078f, 0.10832271f, -0.09190960f, 0.10165773f, 0.14214295f, -0.21880651f, 
    0.01376079f, -0.15275536f, -0.00385506f, -0.03996500f, 0.19139603f, -0.06695537f, 0.06015726f, -0.02438020f, 
    -0.16931033f, 0.00927923f, -0.04318498f, 0.12613609f, 0.13302600f, 0.04817472f, 0.15700063f, 0.08789360f, 
    0.10149084f, 0.20328942f, 0.21223357f, 0.04291723f, 0.25071988f, 0.27838930f, -0.04794307f, 0.26869419f, 
    -0.18119141f, -0.03027338f, 0.14122149f, 0.19398017f, -0.09246127f, 0.05280729f, 0.03834025f, 0.19498450f, 
    0.29867402f, -0.17251422f, 0.35089791f, -0.13167509f, -0.10288177f, 0.00206846f, -0.05666967f, 0.05537333f, 
    0.03870040f, 0.08109837f, 0.21930096f, 0.11281382f, 0.15843219f, -0.05757112f, 0.16459492f, 0.22666487f, 
    0.04964147f, -0.00821836f, 0.04165706f, -0.01444026f, 0.03104806f, -0.01004742f, -0.03458372f, 0.00257914f, 
    -0.06448875f, -0.25357148f, 0.08937519f, 0.27857471f, -0.11719112f, -0.04129782f, -0.05908286f, 0.08231360f, 
    -0.09179866f, -0.04315259f, 0.09776708f, 0.07873198f, 0.05493320f, -0.07202563f, 0.31809551f, 0.24767244f, 
    0.12425163f, -0.00899980f, 0.01561969f, -0.01994811f, 0.14475818f, -0.01560157f, 0.03096038f, 0.18993445f, 
    0.32429901f, 0.11063767f, 0.24061638f, 0.03929770f, 0.12965995f, -0.11688374f, -0.07493346f, -0.02451076f, 
    0.00869703f, 0.08384674f, 0.05153184f, 0.02974515f, -0.43176764f, 0.01158698f, 0.02103572f, 0.12825139f, 
    0.32359168f, 0.12685873f, 0.15411744f, 0.06496073f, -0.02194129f, 0.03022977f, 0.00460433f, 0.01161708f, 
    -0.06781808f, 0.38334405f, 0.02443761f, 0.29907432f, 0.10297703f, 0.18147418f, -0.25095385f, -0.02613293f, 
    0.07303523f, -0.00628492f, -0.04470623f, -0.02978380f, -0.19023491f, 0.02418873f, -0.00191552f, -0.10195582f, 
    0.19490518f, 0.14778645f, -0.07636611f, 0.10320333f, -0.02685421f, 0.14935711f, 0.05562614f, -0.06669463f, 
    0.01773120f, -0.00662172f, -0.04462761f, -0.04841766f, -0.04816055f, 0.03069395f, -0.04824097f, 0.05034985f, 
    0.05192459f, -0.01719823f, -0.06090031f, 0.00868306f, -0.00030328f, 0.02719510f, 0.05689943f, -0.06647214f, 
    0.00735363f, -0.01853290f, -0.02559532f, -0.05291139f, -0.00281190f, -0.03542560f, -0.07103157f, -0.06388278f, 
    -0.05121953f, 0.06819548f, 0.03297814f, -0.04223929f, -0.00500306f, -0.00191536f, 0.00374687f, 0.03838016f, 
    -0.05355868f, -0.06492955f, -0.06174203f, -0.01230227f, -0.03604783f, -0.02814536f, -0.00284865f, 0.02998753f, 
    -0.04890488f, -0.04295126f, -0.05903761f, -0.05891690f, 0.00061498f, -0.03719383f, 0.01262011f, -0.06537694f, 
    0.03834426f, 0.03775925f, -0.04442428f, -0.03554201f, 0.05764904f, 0.02436538f, 0.02619279f, 0.03194756f, 
    0.00882098f, -0.00642406f, 0.06138620f, -0.06367794f, -0.06349010f, 0.00305816f, -0.03421566f, -0.02357641f, 
    -0.02226578f, 0.04264818f, 0.02552057f, 0.00305947f, 0.03685025f, 0.00720872f, -0.02416854f, -0.02606104f, 
    -0.03340796f, -0.05389149f, 0.01420028f, 0.02517377f, 0.00426027f, 0.00489996f, -0.02628093f, 0.07085357f, 
    -0.02032689f, -0.02557367f, -0.01744043f, -0.02583989f, -0.01979006f, -0.03998262f, -0.02764294f, -0.04081962f, 
    -0.05632695f, -0.03788671f, -0.03536876f, 0.06242361f, -0.06578480f, 0.05681946f, -0.02136063f, -0.04310808f, 
    0.07104886f, 0.00033335f, 0.06495526f, 0.05963938f, 0.00764757f, -0.04036538f, -0.04700314f, -0.04460040f, 
    0.06696656f, 0.01144805f, -0.01655095f, 0.01720800f, 0.01793125f, -0.05289087f, -0.03444336f, 0.03283793f, 
    -0.03894798f, -0.04433614f, 0.00969936f, -0.03637860f, -0.01115588f, 0.03308598f, -0.01599485f, -0.05695878f, 
    -0.03455158f, 0.05998730f, 0.06630332f, -0.01921144f, -0.05210029f, -0.01175420f, -0.02174767f, 0.03230365f, 
    0.02356880f, 0.05730391f, 0.04643096f, -0.03579903f, -0.02909644f, 0.01516472f, -0.05468449f, -0.03532520f, 
    -0.00467749f, -0.00114861f, -0.06413694f, -0.00704054f, 0.06422818f, -0.02653387f, 0.04264202f, 0.04357944f, 
    0.03572808f, 0.04308178f, -0.06384853f, 0.03864437f, 0.03857322f, 0.00749840f, -0.03973269f, -0.03089619f, 
    -0.04335367f, -0.00936652f, 0.01505820f, -0.02929495f, 0.02576354f, -0.06348985f, -0.03597096f, -0.05674234f, 
    -0.05768061f, -0.03418469f, -0.04556797f, 0.01599735f, 0.00098994f, 0.03135368f, 0.01101621f, 0.03287286f, 
    0.02030770f, 0.04967746f, 0.06464167f, -0.05291900f, -0.01218441f, -0.00124660f, 0.05489240f, -0.03952036f, 
    0.01937232f, -0.00651435f, -0.04613774f, -0.00378277f, 0.04687877f, -0.05295724f, -0.02707493f, -0.00129114f, 
    -0.05394599f, 0.01856662f, 0.03168750f, -0.04760520f, -0.04945352f, 0.03667279f, 0.05241393f, -0.04153252f, 
    0.22169368f, 0.03047399f, 0.18698122f, 0.23675598f, -0.08246693f, 0.17444953f, 0.02980223f, 0.03214802f, 
    -0.13100503f, 0.04020178f, 0.08470747f, -0.06110346f, 0.41786900f, -0.14159018f, -0.01142116f, 0.04502138f, 
    -0.02125861f, -0.13913524f, 0.11076830f, 0.08855349f, 0.05033196f, -0.15266539f, -0.18329802f, -0.15118606f, 
    -0.11542081f, 0.20574123f, 0.04208308f, 0.08519229f, -0.02806835f, 0.09874275f, -0.04481353f, -0.01985788f, 
    -0.10007639f, -0.09712592f, -0.07973316f, -0.05183602f, -0.31387359f, -0.25087902f, -0.15120898f, -0.26747406f, 
    0.22496472f, 0.24332252f, -0.13657738f, 0.02816618f, -0.13580775f, -0.05018950f, 0.01573331f, -0.01190889f, 
    0.19869667f, -0.18894684f, -0.05593644f, 0.34897119f, 0.01356776f, 0.12852967f, -0.03139271f, -0.14373767f, 
    -0.25692126f, -0.06683471f, -0.00492205f, -0.04162611f, 0.02525805f, 0.10040495f, -0.31706211f, -0.41754416f, 
    0.14093016f, 0.06058597f, -0.01259793f, 0.01579311f, -0.12847702f, 0.00904589f, -0.09679145f, -0.13707447f, 
    0.24136767f, 0.19268602f, -0.00352364f, -0.15930533f, 0.13554581f, -0.05334789f, 0.04123709f, 0.40311673f, 
    0.02586264f, -0.15382552f, 0.13319716f, -0.05173053f, 0.45371845f, -0.08496760f, 0.12420093f, 0.06961819f, 
    -0.04805075f, 0.12318025f, 0.06052946f, 0.09851979f, -0.01225229f, -0.07226504f, 0.02757143f, 0.07691535f, 
    -0.16017543f, -0.32242426f, -0.24999614f, -0.12483554f, 0.05350637f, 0.05089612f, 0.02422690f, 0.07188155f, 
    -0.17812064f, -0.02972212f, 0.01758908f, 0.22497541f, 0.13145432f, -0.55829895f, 0.11560775f, 0.03593227f, 
    0.17332935f, 0.04604059f, -0.09219744f, 0.04573509f, -0.08608117f, -0.01667867f, -0.00605244f, 0.04583302f, 
    0.03302099f, -0.49940372f, 0.03060219f, 0.00547307f, -0.03485860f, 0.13532278f, -0.11639496f, -0.06026245f, 
    -0.02108889f, 0.03340929f, -0.12013835f, -0.08917694f, -0.01524528f, -0.18478675f, 0.21058422f, 0.33389017f, 
    0.07226167f, 0.00325768f, 0.03210543f, 0.11624333f, 0.20156340f, 0.01826976f, -0.08171425f, 0.03236278f, 
    0.10290452f, -0.02501235f, -0.02610358f, 0.09152559f, -0.05897426f, -0.02187563f, 0.07405023f, -0.10038378f, 
    -0.01565234f, -0.02824023f, -0.09214243f, 0.01584107f, 0.49167135f, 0.37585628f, 0.24844092f, 0.19707544f, 
    -0.21599969f, 0.09427188f, -0.11669062f, -0.19265895f, -0.09349594f, -0.01461850f, -0.04788066f, 0.13685976f, 
    -0.27781633f, 0.31584802f, -0.15827844f, 0.13026774f, 0.14675255f, -0.18199417f, -0.06152143f, 0.08708423f, 
    0.04420474f, -0.02073066f, 0.08691452f, 0.04531549f, 0.38037789f, -0.18501787f, 0.37664798f, -0.03755919f, 
    -0.04788627f, -0.14661579f, 0.15392269f, 0.07278550f, -0.12868883f, 0.09301582f, 0.11437489f, 0.12328538f, 
    -0.13466465f, 0.06784248f, 0.19556840f, -0.19323663f, -0.15419082f, -0.13593568f, -0.16641419f, 0.04207769f, 
    -0.06866480f, 0.07946460f, -0.05061707f, -0.04316315f, -0.01734933f, 0.02830528f, 0.07574604f, 0.06031647f, 
    0.13469878f, 0.05290662f, 0.05133870f, -0.11755866f, 0.00595280f, 0.09085836f, 0.00022631f, -0.21085787f, 
    0.00654495f, -0.05071805f, -0.14638679f, 0.10302680f, 0.01209161f, 0.26704666f, 0.02921611f, 0.07562909f, 
    -0.02725183f, 0.07489428f, 0.00553576f, 0.02659728f, 0.27835360f, 0.14166041f, -0.07809026f, -0.17610437f, 
    0.18264760f, 0.10682628f, -0.08304378f, 0.24429017f, 0.16296801f, -0.01184282f, 0.01756484f, -0.03300377f, 
    0.30789274f, 0.04806692f, 0.07708336f, 0.23053192f, -0.03701837f, -0.06003288f, -0.01159105f, 0.00357575f, 
    -0.12741360f, 0.09527057f, 0.05981268f, 0.00024233f, 0.13144900f, -0.02826786f, -0.18284515f, 0.33442652f, 
    0.06281221f, -0.07944130f, -0.04962829f, -0.00855850f, 0.01599344f, 0.05134171f, 0.05848129f, -0.09023013f, 
    -0.15398830f, -0.01673456f, 0.15961628f, -0.06505274f, -0.05143372f, 0.09209951f, 0.11995198f, -0.12863107f, 
    -0.06414223f, -0.09039841f, -0.05535147f, -0.01550119f, -0.16838510f, 0.02649166f, 0.16492677f, -0.03068781f, 
    0.05539762f, 0.17191163f, 0.15885295f, 0.04865416f, 0.21014023f, 0.10111687f, 0.13043456f, 0.12163410f, 
    0.05452263f, 0.06851685f, -0.06475231f, -0.09059411f, 0.10641650f, -0.11472967f, -0.07220330f, 0.02330371f, 
    0.11570932f, 0.17024925f, -0.03347591f, 0.08058869f, -0.19580190f, 0.19007260f, 0.01742128f, -0.02755127f, 
    -0.03604326f, -0.04250100f, 0.03716649f, 0.03457731f, -0.12282796f, 0.08665113f, -0.16992413f, -0.05905694f, 
    -0.12659939f, 0.05392805f, -0.09288419f, -0.05600551f, 0.14723575f, 0.02933521f, -0.08978165f, 0.01621790f, 
    0.17771369f, -0.03478079f, 0.03533249f, -0.08368393f, 0.33267441f, 0.37915674f, 0.05486301f, -0.09639277f, 
    -0.04742057f, 0.05966637f, 0.11252431f, 0.12240928f, -0.13857867f, 0.01646383f, -0.10231043f, 0.05655398f, 
    -0.27388909f, 0.04140478f, -0.31337991f, -0.12247849f, -0.18103446f, -0.11363191f, -0.05312953f, -0.03450101f, 
    0.24921222f, 0.08359183f, -0.05529332f, 0.11126170f, 0.65493804f, 0.03437463f, 0.02479895f, -0.26914948f, 
    -0.24552417f, -0.08595885f, 0.06560351f, 0.03990377f, -0.00090650f, -0.04277781f, 0.01703944f, 0.00924137f, 
    -0.11773033f, -0.19129924f, -0.26433408f, 0.07731429f, -0.08447013f, 0.09431252f, -0.05633697f, -0.02212279f, 
    0.01816688f, 0.04369564f, 0.01461965f, 0.15535495f, -0.27289012f, 0.44335768f, -0.04980911f, 0.22682658f, 
    0.01966822f, -0.11527760f, 0.16901642f, -0.00181606f, 0.01585503f, -0.12217300f, 0.14600386f, 0.06898434f, 
    0.02257140f, -0.21265317f, 0.13328452f, -0.09975878f, 0.02917318f, -0.02177806f, 0.17874989f, -0.00310155f, 
    0.23345304f, 0.00849940f, -0.25911447f, 0.11789768f, -0.03477670f, -0.28800696f, -0.00905677f, -0.00437723f, 
    -0.09550019f, 0.08088247f, 0.00493843f, 0.14279252f, -0.19023006f, 0.11956228f, 0.22541235f, 0.37564731f, 
    -0.04784053f, -0.16058633f, -0.01496852f, -0.05799671f, 0.11481897f, -0.25397581f, -0.02041343f, -0.03701893f, 
    0.23579915f, 0.21488430f, 0.06766322f, -0.06098062f, -0.12570278f, 0.19764629f, 0.01075081f, 0.29547906f, 
    -0.08712925f, 0.10875557f, -0.00630917f, -0.14822689f, -0.06587271f, 0.12211617f, 0.07408903f, 0.18653853f, 
    -0.05399066f, -0.30161837f, 0.02778033f, -0.17444059f, 0.06499577f, -0.01954064f, -0.08018243f, 0.11631894f, 
    0.22538801f, -0.15045060f, -0.03686527f, 0.08100992f, 0.11779395f, -0.15481670f, 0.22131494f, 0.31854835f, 
    -0.05687386f, -0.00472858f, -0.00908915f, 0.01307531f, 0.05006629f, -0.05683500f, -0.00681737f, 0.21849629f, 
    -0.06403074f, -0.05639739f, -0.09652063f, 0.13918397f, -0.04458790f, -0.14063419f, -0.09198803f, -0.05789281f, 
    0.01506393f, -0.09879408f, -0.16354978f, 0.00601852f, -0.27591407f, -0.19056933f, 0.04139372f, -0.04490983f, 
    0.07465296f, 0.06676967f, -0.16129646f, -0.04429889f, -0.03878495f, -0.02738873f, 0.08820165f, -0.03154588f, 
    -0.21798833f, 0.11693802f, 0.08631385f, 0.41299018f, 0.08213430f, -0.01396857f, 0.03958833f, -0.09298960f, 
    0.08757979f, -0.12565579f, 0.03679040f, -0.07041394f, -0.15134123f, 0.45116523f, -0.00311151f, -0.07943022f, 
    -0.00970799f, 0.11408159f, 0.02933123f, -0.10623444f, 0.13895725f, 0.00053224f, 0.10385477f, -0.03241855f, 
    -0.02741786f, 0.51860726f, 0.30040994f, -0.09398389f, 0.18456803f, -0.04737533f, 0.19480050f, -0.06649522f, 
    -0.01498800f, 0.22636914f, -0.14953776f, 0.19007467f, -0.24746563f, 0.15925570f, -0.06992801f, -0.28824884f, 
    0.04050008f, -0.00018478f, -0.06314167f, 0.07097907f, 0.10156546f, 0.07179295f, 0.08206924f, -0.03192135f, 
    0.26117146f, -0.01741685f, 0.03641697f, 0.20356117f, 0.14505604f, 0.07480342f, -0.20274462f, 0.07810880f, 
    -0.08909488f, 0.01368545f, 0.20080435f, 0.01513130f, -0.30932498f, 0.00818503f, -0.08172227f, -0.32178536f, 
    0.19688635f, 0.14653808f, 0.08785836f, -0.02302249f, -0.01604256f, 0.04480282f, 0.06235953f, -0.05032808f, 
    0.36591822f, -0.42857572f, -0.07935847f, -0.16936535f, -0.12971412f, -0.09084234f, 0.10384230f, -0.18002050f, 
    0.00563040f, 0.03784849f, 0.05887248f, -0.02675270f, 0.18485221f, -0.20615508f, -0.12548684f, -0.07792634f, 
    -0.13712266f, 0.12180329f, 0.08742148f, 0.09228969f, 0.00728117f, 0.05219188f, -0.03654737f, -0.01402985f, 
    0.01576036f, 0.02469869f, -0.04083990f, -0.03210833f, -0.03218099f, -0.05302200f, -0.05303920f, -0.06786199f, 
    -0.02146286f, 0.00694340f, 0.02945088f, -0.03597586f, -0.01795232f, 0.00681138f, -0.06172602f, 0.01861261f, 
    -0.00106442f, -0.02925177f, 0.02833333f, -0.05986743f, 0.06405675f, -0.06864280f, -0.02856995f, -0.05003225f, 
    0.02440578f, -0.00919429f, -0.04360233f, 0.01209699f, -0.08435933f, 0.03301236f, 0.01893031f, 0.00661818f, 
    0.07618725f, 0.02724155f, 0.00569830f, 0.05637586f, -0.05311020f, -0.02716430f, -0.04282326f, -0.02607882f, 
    -0.06564368f, -0.08198190f, -0.04781016f, -0.03543822f, -0.02702013f, -0.06292137f, -0.07837604f, 0.06305376f, 
    -0.00161263f, 0.03681324f, -0.06536344f, -0.06294457f, 0.03868702f, -0.04129206f, -0.02555885f, 0.02817083f, 
    0.01473570f, -0.03972169f, -0.06844315f, 0.05247768f, 0.02749977f, 0.04941103f, -0.01311424f, -0.02767159f, 
    -0.03392302f, 0.04620392f, 0.05426443f, 0.05386641f, -0.00049516f, -0.02553644f, -0.00659437f, -0.02919665f, 
    -0.01060534f, -0.02375103f, 0.00235681f, -0.02392099f, -0.00201645f, -0.02408509f, 0.00681635f, -0.06597672f, 
    0.03355820f, -0.01344327f, -0.07912534f, -0.05409361f, 0.02531115f, -0.00095533f, -0.06302942f, 0.01986569f, 
    -0.03879663f, 0.03014676f, 0.04660865f, 0.04600902f, 0.03801200f, 0.02379192f, -0.04383474f, 0.05131203f, 
    -0.08106120f, 0.00983668f, -0.06568034f, 0.03177384f, 0.03014141f, 0.05963120f, 0.02544004f, -0.07646634f, 
    -0.04757639f, -0.05669522f, 0.02958921f, -0.00301981f, -0.02837530f, -0.06465241f, 0.01868184f, -0.03288204f, 
    0.03733596f, -0.05161287f, 0.04918853f, -0.05660193f, 0.02488998f, -0.03267492f, -0.06494486f, 0.05897260f, 
    -0.02378320f, -0.02333444f, -0.05703647f, 0.03639644f, -0.00885177f, -0.02058391f, 0.02806523f, -0.06910575f, 
    0.06603328f, -0.04272683f, 0.03790552f, -0.02325275f, -0.02738287f, -0.04995618f, 0.03406912f, -0.01245201f, 
    -0.06714295f, 0.03867979f, -0.00688941f, -0.03827509f, -0.03927000f, -0.07327030f, 0.04357607f, -0.00182612f, 
    -0.06007416f, -0.03948835f, -0.04973216f, -0.06881881f, -0.05048982f, 0.06101135f, -0.00655201f, 0.02119237f, 
    -0.04445379f, 0.02108408f, -0.04044785f, -0.05371309f, 0.02785482f, 0.03773936f, -0.01748053f, -0.01547574f, 
    0.02296061f, -0.06405465f, 0.05646473f, -0.04423493f, -0.04319556f, -0.04418289f, 0.05364749f, 0.05957978f, 
    -0.03512402f, 0.04388276f, -0.02153928f, 0.03948998f, 0.01859906f, -0.00168786f, 0.00123930f, 0.06317195f, 
    0.01276136f, -0.03346511f, -0.03964237f, -0.05815205f, 0.05169378f, -0.04401671f, 0.01864906f, 0.00306052f, 
    -0.07573045f, -0.03364284f, -0.01558590f, -0.02514788f, 0.00730780f, -0.04455492f, 0.05770569f, 0.04956927f, 
    -0.01495770f, 0.05056559f, 0.00140775f, 0.02864036f, 0.06153043f, 0.03195339f, 0.05580756f, -0.05862149f, 
    0.04516667f, -0.06292886f, 0.04133146f, 0.05241147f, -0.07250613f, 0.06201396f, -0.01261786f, -0.03923165f, 
    0.04865396f, 0.02148874f, -0.04368579f, 0.03640831f, 0.04582554f, -0.00578610f, -0.07507548f, -0.03972030f, 
    0.05893836f, -0.02710229f, -0.06685484f, -0.08159838f, -0.07750810f, -0.05638671f, -0.06284875f, 0.03934205f, 
    0.03621712f, 0.04830698f, 0.03395427f, -0.03745295f, -0.00493653f, 0.04910037f, -0.01077240f, -0.06524970f, 
    -0.04392811f, -0.03501268f, 0.02521961f, 0.04763232f, -0.07664037f, -0.02541484f, 0.02103502f, -0.08396273f, 
    0.04245090f, 0.00830620f, -0.00234003f, -0.06091214f, -0.05348668f, -0.06666039f, -0.01975578f, 0.05130424f, 
    -0.03159853f, -0.03693677f, -0.03305263f, -0.04383549f, 0.01238018f, 0.02497382f, -0.07183999f, -0.07455419f, 
    -0.00274767f, -0.03146722f, -0.00654086f, -0.06714982f, 0.03042610f, -0.00997931f, -0.03583470f, 0.05517172f, 
    -0.00231651f, 0.00653203f, -0.03826578f, -0.02099397f, 0.03576501f, 0.00061519f, -0.02982161f, -0.06104550f, 
    0.00430283f, 0.04434644f, -0.01130651f, -0.07126381f, 0.03502397f, -0.04932643f, 0.01687521f, 0.03648275f, 
    0.02710805f, 0.03913487f, -0.01792902f, 0.02897552f, 0.00706370f, -0.01788892f, 0.03002466f, -0.06233694f, 
    -0.08519758f, -0.08019322f, 0.02671326f, -0.06652765f, -0.01521171f, -0.01793187f, -0.05884053f, 0.03354925f, 
    -0.01375539f, -0.03137460f, 0.05483483f, -0.01243593f, -0.05878726f, -0.05569353f, 0.00980675f, -0.00599126f, 
    -0.05537661f, -0.02073733f, 0.02642543f, -0.06894586f, 0.02171915f, 0.02592651f, -0.02173726f, -0.07014848f, 
    0.05496895f, -0.03931347f, -0.05089203f, -0.00379820f, 0.00458196f, -0.07721973f, 0.02084883f, 0.05239663f, 
    -0.08419418f, 0.02317283f, -0.03222892f, 0.00363010f, 0.02111501f, -0.01244077f, -0.07958526f, 0.05651814f, 
    -0.01054937f, -0.00302600f, 0.04243572f, 0.00885342f, -0.07226193f, -0.01715837f, -0.02241173f, -0.00677279f, 
    -0.05974037f, -0.03562590f, 0.02055424f, -0.00819605f, 0.00286770f, -0.00451877f, 0.01932387f, 0.00086594f, 
    -0.00673458f, -0.05016572f, 0.00548951f, 0.02015691f, 0.02924832f, 0.06387196f, -0.05887073f, 0.03743453f, 
    -0.01466117f, 0.03842793f, 0.01043422f, -0.04594421f, -0.04138998f, -0.07977041f, -0.06779293f, -0.03399817f, 
    -0.04466246f, -0.04647156f, 0.05136768f, 0.01107922f, -0.05097974f, 0.06057892f, -0.07117000f, -0.06976198f, 
    -0.03359549f, 0.05842992f, 0.04583629f, -0.07442535f, -0.05542269f, 0.04588892f, 0.01625664f, -0.03042825f, 
    0.03495759f, 0.04845075f, -0.05094758f, 0.03328244f, -0.04970631f, -0.02018538f, 0.05843467f, 0.03210144f, 
    0.01648171f, 0.31122774f, -0.16802792f, 0.00312885f, -0.02052960f, 0.07056574f, -0.02925841f, 0.04959419f, 
    0.02951720f, 0.11783066f, 0.05574742f, -0.25051153f, 0.10859028f, 0.34263080f, -0.07458981f, -0.03784432f, 
    -0.01297994f, 0.07542332f, -0.09315666f, 0.06599227f, 0.19454613f, -0.13849460f, 0.02522833f, -0.05763097f, 
    0.28879398f, 0.22914246f, -0.04290732f, 0.22362983f, 0.16965146f, 0.09022107f, -0.05403482f, -0.00169578f, 
    -0.13847330f, -0.04918417f, -0.01589165f, 0.13666916f, 0.44689703f, 0.02995207f, 0.30413228f, 0.36892506f, 
    -0.02636287f, -0.03945636f, 0.09557843f, 0.02351520f, -0.06790135f, -0.03909808f, -0.13563958f, 0.07076523f, 
    -0.16193311f, 0.13249797f, 0.01624271f, 0.09877425f, 0.03936331f, -0.04411165f, 0.11584182f, -0.15333326f, 
    0.06333213f, 0.19988124f, 0.05963729f, 0.06984069f, -0.03840999f, 0.02467515f, -0.03145652f, -0.20557536f, 
    -0.07000093f, 0.06460401f, 0.17357075f, -0.01405107f, -0.07424616f, 0.10663468f, 0.03795626f, 0.03333758f, 
    0.39769024f, 0.05743625f, -0.10846275f, -0.12261389f, 0.00113940f, -0.00104820f, 0.04454358f, -0.06757811f, 
    -0.02772843f, 0.01541403f, -0.03652800f, 0.09049904f, 0.27459469f, 0.38077921f, 0.11423352f, 0.29034382f, 
    0.02520290f, 0.05975808f, 0.03596408f, -0.19590253f, 0.01227088f, -0.01539259f, -0.07660414f, 0.13774517f, 
    0.23298429f, 0.26402256f, -0.09070748f, -0.08462144f, -0.03683800f, -0.06295926f, -0.08590056f, 0.10081115f, 
    -0.07770773f, 0.04475844f, -0.05489730f, 0.05854750f, -0.12993009f, -0.06610332f, -0.02544638f, 0.05120001f, 
    0.01013102f, -0.10356913f, -0.05239935f, 0.17776714f, 0.00834380f, 0.10019623f, -0.04467469f, 0.20661347f, 
    0.09591223f, -0.22327194f, -0.02455449f, 0.25565481f, 0.07767677f, 0.06065788f, -0.23504610f, 0.09556923f, 
    0.00196472f, -0.19202885f, 0.07340337f, 0.10689047f, 0.09070852f, 0.07843009f, 0.36778200f, 0.46787560f, 
    -0.20815922f, -0.01908406f, 0.10677587f, -0.10970271f, -0.13041255f, 0.14011534f, 0.06148093f, -0.13988622f, 
    -0.40169320f, 0.05366322f, -0.08052091f, -0.33518082f, 0.05155970f, 0.18494084f, 0.07580115f, 0.04212522f, 
    0.15118934f, 0.02064886f, -0.17623937f, 0.05643718f, 0.27002165f, -0.05842342f, -0.35072911f, 0.01820070f, 
    -0.01800808f, 0.08537023f, 0.00147613f, 0.13746814f, 0.08958458f, 0.12581401f, -0.02021363f, -0.09676108f, 
    -0.38383347f, -0.13757326f, 0.02056783f, -0.19492622f, -0.12191500f, 0.09910957f, 0.10188891f, 0.11937036f, 
    0.01325322f, 0.04390418f, 0.10252569f, -0.01209376f, -0.20849812f, 0.22810754f, 0.00854353f, 0.20813423f, 
    0.10992477f, -0.10026159f, 0.20185030f, -0.10757887f, 0.01147059f, -0.05263392f, 0.21495010f, 0.00424320f, 
    0.40332070f, -0.13753614f, -0.02750328f, 0.20478356f, -0.06212485f, 0.05069233f, -0.15901251f, 0.07877471f, 
    -0.07907537f, 0.06159334f, 0.13754615f, -0.06613527f, 0.02575638f, -0.17862915f, -0.03004483f, 0.04096385f, 
    0.03666718f, 0.10817017f, 0.02634996f, 0.00704269f, -0.03568365f, -0.13056843f, -0.30940732f, -0.15070577f, 
    0.06232186f, -0.12358430f, -0.03028338f, 0.18639138f, 0.01210566f, 0.12450539f, 0.13129447f, -0.07774011f, 
    -0.11404639f, -0.04041393f, -0.00673354f, -0.06385230f, -0.34751669f, 0.00321448f, 0.40456137f, -0.13971059f, 
    -0.10434283f, 0.09625229f, 0.03271335f, -0.19156449f, -0.05158993f, -0.09700456f, -0.09355379f, -0.14303187f, 
    0.20056961f, 0.24302207f, 0.04714312f, 0.16149129f, -0.12149674f, 0.14224897f, -0.02304474f, 0.01093727f, 
    -0.08607763f, 0.06215423f, 0.09499570f, -0.01467624f, 0.14821868f, 0.00658525f, 0.24234267f, -0.00492453f, 
    -0.10449465f, 0.04907785f, -0.11051574f, -0.04993068f, 0.12175760f, 0.03632709f, -0.07834715f, -0.04263488f, 
    -0.19977857f, -0.17381006f, 0.17367725f, 0.06160701f, 0.01363922f, 0.21195990f, -0.04257250f, 0.28758547f, 
    0.10281236f, -0.09429312f, 0.26011392f, 0.13179010f, 0.20351778f, -0.11350609f, 0.10675520f, -0.07661092f, 
    0.02061998f, -0.13926823f, 0.07290676f, 0.20315425f, 0.03148747f, 0.16226219f, -0.08633877f, 0.22607374f, 
    -0.12382726f, 0.08889887f, 0.00683059f, 0.07288232f, -0.07764847f, -0.13570671f, 0.06019430f, -0.04550411f, 
    -0.10346285f, 0.22850065f, -0.02085551f, -0.02089096f, 0.36120763f, -0.11711646f, 0.13796787f, 0.05483269f, 
    0.02115679f, -0.02148190f, 0.11860301f, -0.04675501f, 0.00302047f, -0.04398528f, -0.28399974f, -0.03646750f, 
    -0.05084147f, -0.04974407f, 0.02138557f, -0.05711039f, 0.05358917f, -0.04200077f, -0.10034710f, -0.00904907f, 
    0.05157854f, -0.12442496f, 0.21636775f, -0.06974722f, 0.36405888f, 0.27399179f, 0.07244569f, -0.26254791f, 
    0.06651025f, 0.10988096f, 0.25873792f, -0.03989629f, 0.09329852f, 0.16093589f, -0.08523327f, 0.01427367f, 
    -0.02681901f, -0.04876452f, -0.13068928f, 0.15166955f, -0.16288610f, -0.02110130f, 0.31480080f, -0.07278492f, 
    -0.11287207f, 0.13357642f, -0.06529684f, 0.08345932f, 0.13958371f, -0.07068014f, -0.14915687f, 0.01855032f, 
    0.10380209f, -0.05589845f, -0.10187808f, 0.14138317f, 0.03161682f, 0.09248472f, 0.04279561f, -0.03523849f, 
    -0.22901626f, -0.08121621f, 0.00917564f, -0.14828582f, -0.02970591f, 0.05794759f, 0.03593214f, 0.17083237f, 
    -0.07768846f, -0.08640409f, 0.04334928f, 0.08088943f, 0.28542584f, -0.19583412f, -0.07282007f, 0.01770716f, 
    0.00257582f, -0.02625711f, -0.03571159f, -0.04739745f, 0.00300671f, -0.09240145f, 0.20391189f, -0.03612828f, 
    0.09252226f, -0.22406670f, -0.02404043f, 0.08618745f, -0.02616789f, -0.09795518f, 0.04699762f, 0.26984948f, 
    0.15450272f, 0.10150587f, -0.03750068f, 0.15262206f, -0.01847748f, -0.15495631f, -0.15003946f, 0.13202704f, 
    -0.02467597f, 0.13835338f, -0.17339069f, 0.03473196f, -0.13886575f, -0.01247427f, 0.10772245f, 0.09811425f, 
    -0.03867872f, -0.31867331f, -0.05742352f, -0.12398009f, -0.05060139f, -0.09772106f, 0.16139624f, -0.05871448f, 
    0.14605242f, 0.01880078f, -0.02769124f, 0.01420735f, -0.30000061f, 0.05436068f, 0.20690803f, -0.03203020f, 
    -0.01047151f, 0.11532390f, 0.13002458f, -0.11257399f, -0.02898983f, 0.08683224f, -0.04049778f, 0.05019332f, 
    0.14133784f, -0.27911392f, -0.05703083f, -0.02213387f, -0.08269676f, 0.02707004f, -0.16170570f, 0.20641066f, 
    0.08236133f, -0.01266739f, -0.11518668f, 0.07951692f, 0.41860393f, -0.00122266f, 0.22420093f, 0.56933349f, 
    -0.11814603f, 0.06772778f, 0.00872027f, 0.08683611f, 0.04189995f, 0.00716428f, -0.04005883f, 0.04523682f, 
    0.10650186f, -0.11875974f, 0.08734772f, -0.04769734f, -0.09905364f, -0.08013139f, -0.03282556f, 0.09216171f, 
    0.12895378f, -0.02449050f, 0.02630457f, 0.12466127f, -0.24317236f, -0.34733573f, 0.22181581f, -0.14850134f, 
    0.18860511f, -0.03398294f, -0.02913747f, 0.06533676f, 0.06601351f, -0.00855174f, 0.15123488f, -0.02360016f, 
    -0.17214295f, 0.13770169f, -0.13480316f, 0.46392128f, 0.05269666f, 0.04643010f, 0.05393338f, -0.00666569f, 
    -0.08308280f, 0.03636916f, -0.06058910f, -0.06101347f, -0.14493394f, 0.33526409f, -0.00713515f, -0.23482080f, 
    -0.03739640f, 0.07584206f, 0.07382957f, -0.12820902f, 0.02331972f, -0.04302900f, -0.04691064f, -0.02977386f, 
    -0.10097544f, 0.26860929f, 0.11753020f, -0.32393166f, 0.18119319f, 0.11671548f, 0.14477943f, 0.12517013f, 
    0.06214622f, 0.12633771f, 0.10006264f, 0.04157937f, -0.05572036f, 0.36936119f, -0.03475390f, -0.47269431f, 
    0.10544548f, 0.09300686f, 0.13585314f, 0.00367174f, 0.02973921f, 0.04936723f, 0.00342330f, 0.00758782f, 
    0.09444354f, 0.05582809f, -0.07130399f, 0.42027551f, -0.02288676f, 0.21464139f, 0.02293032f, 0.04579237f, 
    -0.15300699f, 0.06428160f, 0.13477561f, 0.13177660f, 0.06059026f, 0.00064645f, -0.10699175f, -0.21184041f, 
    0.16513391f, 0.07271442f, -0.12226061f, 0.16539989f, 0.00684034f, -0.00672995f, 0.09501650f, 0.02126335f, 
    0.48381445f, -0.34564474f, 0.05005330f, -0.25568551f, -0.09503577f, -0.12592764f, 0.20664416f, -0.01318268f, 
    -0.06779411f, -0.01233665f, 0.04916550f, 0.00817702f, 0.28905916f, -0.17493978f, -0.11565109f, -0.00315055f, 
    -0.09241015f, 0.05301679f, 0.14096104f, 0.00070808f, -0.03492132f, -0.10191976f, 0.08913776f, 0.01807594f, 
    0.04798745f, 0.05290195f, -0.13600431f, -0.09431991f, 0.02538940f, 0.10303708f, 0.13225839f, 0.02498227f, 
    0.11235893f, 0.05004090f, -0.09095790f, -0.03432366f, -0.05476116f, -0.12388833f, 0.05921565f, -0.10884994f, 
    -0.01222971f, 0.03212583f, 0.02917702f, 0.12519652f, 0.05425951f, 0.10440315f, 0.02594044f, 0.32902864f, 
    0.24605812f, 0.13543040f, 0.05858331f, 0.18201546f, 0.03488091f, -0.18330690f, -0.08202179f, -0.14884284f, 
    0.03980472f, 0.05596125f, -0.00348408f, -0.08657436f, -0.20267780f, -0.00766189f, 0.16086990f, 0.42701200f, 
    -0.10858648f, -0.14332981f, -0.03531357f, -0.18631966f, -0.13794485f, -0.01944190f, 0.03933406f, 0.22076073f, 
    0.12662674f, 0.07512663f, -0.13026187f, -0.02908471f, 0.08855554f, 0.05843256f, 0.09886772f, -0.03498353f, 
    -0.03112064f, -0.18433407f, -0.05972670f, 0.15606442f, 0.15030967f, 0.08366583f, 0.38100100f, -0.28769189f, 
    -0.22520533f, 0.02795609f, 0.06909990f, 0.06658506f, 0.17080563f, 0.08482269f, -0.05809483f, 0.15929674f, 
    0.11924563f, 0.04699058f, -0.15261224f, 0.05507948f, 0.10356367f, 0.09323097f, -0.04022424f, -0.06257796f, 
    0.16161823f, 0.09769190f, 0.01492746f, -0.00134078f, 0.33060461f, -0.00847369f, -0.07700127f, -0.11556388f, 
    -0.03589005f, 0.01171656f, -0.01445335f, -0.05909824f, -0.15425065f, -0.15341811f, -0.03685976f, 0.00188285f, 
    -0.22883675f, 0.03637428f, 0.38796726f, 0.30355757f, -0.15981169f, -0.07061925f, -0.03165361f, 0.03596123f, 
    -0.09859996f, -0.11021076f, -0.10698625f, -0.07987985f, -0.24385884f, 0.06857518f, -0.02231658f, 0.03351284f, 
    0.02203714f, -0.04475058f, 0.04406799f, -0.10932948f, 0.06461089f, 0.06451534f, -0.01769419f, 0.11040718f, 
    0.04238165f, 0.17772208f, 0.44310519f, 0.05675645f, -0.13792330f, -0.08404708f, 0.07923915f, 0.06509083f, 
    0.01700219f, 0.11275206f, -0.03563736f, 0.21074042f, -0.06792805f, -0.14037719f, 0.10925359f, 0.20290446f, 
    0.07091621f, -0.15299185f, 0.09881645f, -0.11101276f, 0.18161865f, 0.14000684f, -0.02830785f, 0.00741018f, 
    0.10740270f, 0.18873097f, 0.26490968f, 0.08460943f, 0.03507200f, 0.15521818f, 0.05977673f, 0.19148660f, 
    -0.14783995f, -0.12515490f, 0.08718327f, -0.12752964f, -0.35738808f, 0.07459108f, -0.15932548f, -0.15296052f, 
    0.19995409f, 0.26636717f, 0.17522663f, -0.20774695f, 0.09295599f, 0.10087827f, 0.02722272f, 0.05244929f, 
    -0.31861547f, -0.01815465f, 0.13553789f, 0.15895954f, -0.04058198f, -0.19738963f, -0.12836020f, -0.04559403f, 
    0.10655243f, 0.01768080f, -0.01029029f, -0.17949398f, 0.11217491f, -0.40268120f, 0.08364849f, -0.22904986f, 
    -0.12688486f, 0.11621623f, -0.02837516f, -0.05832186f, 0.00202651f, -0.02490161f, -0.01610280f, -0.11058445f, 
    -0.07618688f, 0.11675464f, -0.12003612f, 0.21817799f, 0.01803338f, 0.14505166f, 0.14685349f, 0.18995006f, 
    0.10746852f, 0.06565161f, -0.01033781f, -0.09058661f, -0.07753376f, 0.18349414f, -0.53709632f, 0.32728410f, 
    -0.06754574f, 0.07087231f, -0.23050758f, 0.10215340f, -0.04597622f, -0.17265856f, 0.29400390f, 0.08469475f, 
    -0.06719769f, -0.03413473f, -0.07814574f, -0.26287428f, 0.06426395f, -0.10507866f, 0.11351560f, -0.10766286f, 
    0.02651859f, -0.11872824f, 0.08308397f, 0.07823918f, 0.23398077f, 0.14605966f, 0.24267954f, -0.09927232f, 
    -0.06383592f, -0.11484574f, 0.07112372f, -0.07603320f, 0.01739589f, 0.12761098f, 0.10909406f, 0.06150445f, 
    -0.17063382f, -0.32755047f, 0.06614945f, 0.08620706f, 0.01898943f, 0.00480685f, -0.06502935f, 0.08942435f, 
    0.05276395f, 0.21637608f, -0.07792656f, -0.12291856f, 0.52484041f, -0.07852376f, -0.28470203f, 0.40546733f, 
    -0.11330643f, -0.14560722f, -0.07260056f, 0.05060769f, 0.11651844f, 0.04854939f, -0.04013539f, 0.07476198f, 
    0.62296015f, 0.22424082f, 0.10974284f, -0.02764332f, 0.21425916f, -0.02466807f, 0.02315501f, -0.05712926f, 
    -0.03699380f, 0.03852456f, -0.19547695f, 0.11348122f, -0.31691569f, -0.11060870f, 0.03377169f, 0.00909244f, 
    0.15563762f, 0.06000895f, -0.11450827f, -0.12437248f, -0.01107549f, -0.17551965f, -0.02934179f, -0.21961261f, 
    0.32016674f, 0.34256682f, -0.11827463f, 0.11312675f, -0.15759864f, -0.07787167f, -0.10992528f, -0.05614971f, 
    -0.00869116f, -0.10843373f, -0.07062881f, -0.04229266f, -0.08508538f, 0.13730793f, -0.03493342f, -0.25838503f, 
    0.08403184f, 0.07451105f, -0.10399620f, 0.10422773f, 0.01119010f, 0.04623203f, 0.09710129f, 0.00336640f, 
    -0.18929324f, 0.17364976f, -0.01101451f, -0.32343096f, 0.14704305f, 0.00843659f, 0.10731804f, 0.19553930f, 
    -0.07624304f, -0.07286581f, -0.04013671f, 0.03098894f, -0.21318693f, 0.12545720f, 0.06110516f, -0.23183776f, 
    -0.08103396f, 0.01009923f, -0.00164064f, -0.10665318f, 0.06551653f, 0.03404923f, -0.00048914f, -0.07737297f, 
    -0.09468862f, 0.02776618f, 0.03014294f, 0.16246396f, 0.12597790f, 0.14392313f, -0.02168298f, 0.03093366f, 
    -0.01451898f, -0.04821008f, -0.02811811f, 0.00840615f, 0.12669140f, -0.01859104f, -0.08717620f, 0.02778242f, 
    0.21834941f, 0.24685508f, 0.03274472f, 0.21253248f, 0.04836684f, -0.05177856f, -0.07899000f, 0.01440842f, 
    0.52885699f, -0.22639205f, 0.30205685f, -0.15943353f, 0.03256499f, -0.27386156f, 0.21128565f, -0.09501660f, 
    -0.00327431f, 0.00622802f, 0.02591709f, 0.13369764f, 0.13160655f, 0.22035955f, -0.18290657f, 0.00733787f, 
    -0.07721546f, 0.00172828f, -0.00902099f, 0.01886901f, 0.02187511f, -0.10925889f, -0.05266582f, 0.06927248f, 
    -0.10468476f, 0.22767718f, 0.02140275f, 0.01833128f, -0.08587144f, -0.05455669f, -0.35563552f, 0.15233919f, 
    -0.03177588f, 0.23717384f, 0.07391681f, -0.16751678f, -0.33807680f, -0.16483663f, 0.14464784f, 0.11598714f, 
    0.08265930f, 0.01499538f, -0.14714703f, -0.00108460f, -0.03125968f, -0.11453621f, -0.22324096f, -0.25278816f, 
    0.55779916f, 0.23604034f, -0.23408672f, 0.23736085f, -0.21978420f, 0.14713518f, 0.05610485f, -0.00689361f, 
    -0.09646211f, -0.06283062f, -0.05361585f, 0.03590962f, 0.01111692f, -0.02063924f, 0.13453822f, 0.35369158f, 
    -0.08915196f, -0.06997448f, 0.01804299f, -0.05196581f, 0.04289226f, -0.18176720f, 0.10251145f, -0.17423315f, 
    0.42324483f, 0.07680262f, -0.10974517f, 0.05034279f, -0.10619993f, 0.01292468f, -0.02687006f, -0.01423328f, 
    -0.18033968f, 0.16724235f, -0.10165314f, -0.05447442f, 0.60160494f, 0.20779933f, 0.19973092f, 0.25259319f, 
    -0.22878136f, 0.07741164f, 0.01224398f, 0.01299890f, 0.10091150f, 0.06811909f, -0.16343541f, -0.13768438f, 
    -0.25127518f, -0.08555156f, -0.01476835f, 0.03626249f, -0.02658033f, 0.12495828f, 0.08858491f, -0.02036904f, 
    -0.03481157f, 0.00869245f, 0.02701914f, 0.15626036f, 0.37670574f, 0.06720388f, 0.02823312f, 0.09399579f, 
    -0.20256551f, 0.06797982f, 0.15811096f, 0.02215570f, -0.03834200f, 0.13847454f, 0.00728607f, 0.28651869f, 
    0.22401898f, 0.17976862f, -0.25491807f, 0.11509950f, -0.14361465f, -0.25183710f, 0.04981560f, -0.00737078f, 
    0.13772735f, 0.18011251f, -0.07225497f, 0.02287263f, -0.42160305f, 0.35737228f, 0.17048323f, 0.02555555f, 
    0.01268750f, -0.18044214f, 0.03624237f, 0.03860916f, 0.02338908f, 0.01509557f, -0.37511966f, -0.04679609f, 
    -0.25404808f, 0.03406585f, 0.17784366f, 0.45523086f, 0.00562924f, -0.07220703f, -0.19628291f, 0.08757082f, 
    -0.09418704f, -0.21811800f, 0.06875539f, -0.07766422f, 0.51387352f, 0.58565611f, 0.14469354f, 0.04654039f, 
    -0.13215579f, 0.15047827f, 0.20607784f, 0.05927609f, 0.03547200f, 0.04400772f, -0.06127172f, 0.02784668f, 
    -0.27465311f, 0.19382527f, -0.15089199f, -0.08092266f, -0.21670707f, 0.05368177f, 0.37018651f, 0.23899414f, 
    0.15866572f, 0.15182726f, -0.15454915f, 0.03016350f, 0.21987747f, 0.05843986f, -0.19019349f, -0.26135662f, 
    0.14066787f, 0.09519217f, -0.03022344f, -0.03070703f, -0.00328461f, 0.00561468f, 0.17332782f, 0.00809716f, 
    0.22599079f, -0.07925332f, -0.23183273f, 0.05315449f, -0.07199411f, -0.07036907f, -0.13899174f, 0.22803921f, 
    -0.16232757f, 0.03192244f, -0.02549353f, 0.12244602f, -0.02121552f, 0.08521926f, 0.06287327f, 0.02558266f, 
    0.11149801f, -0.25240877f, 0.18097042f, -0.12180387f, -0.05293994f, -0.08312219f, 0.17449310f, 0.10050471f, 
    0.00169985f, -0.00405730f, -0.19076361f, -0.04679764f, 0.00138241f, 0.01535091f, 0.07288145f, 0.00193149f, 
    0.06270469f, -0.01578644f, -0.02731583f, 0.12000658f, 0.26676548f, 0.20062907f, 0.08826423f, 0.00769785f, 
    -0.05807848f, 0.09322869f, 0.04738462f, 0.06407356f, 0.10108206f, 0.06393202f, 0.02975762f, 0.09507993f, 
    -0.16174032f, 0.12950322f, 0.20090546f, 0.12262314f, 0.12431125f, -0.06546632f, -0.14068708f, 0.05126662f, 
    0.01961196f, -0.04337206f, 0.08929250f, 0.17731148f, 0.15722291f, 0.13427950f, 0.04447283f, -0.16262028f, 
    0.07764322f, 0.09728647f, -0.03658753f, 0.07480371f, -0.05368648f, 0.05552656f, 0.06634866f, 0.12227655f, 
    -0.32026550f, 0.05355120f, 0.03688521f, -0.19435738f, 0.11180887f, -0.03347483f, 0.11200704f, -0.03715909f, 
    0.14585397f, 0.11451078f, 0.14993653f, 0.03913542f, -0.11742345f, 0.23327950f, 0.14607699f, -0.16106518f, 
    0.13775313f, -0.02496929f, 0.16515450f, -0.04293887f, 0.08343985f, -0.01209109f, 0.16887720f, 0.14608227f, 
    -0.19313604f, -0.04056581f, -0.06815664f, 0.05397911f, 0.04136480f, -0.06764273f, -0.08008382f, 0.15455139f, 
    -0.17471257f, 0.02034289f, -0.00100017f, 0.00706871f, -0.41331273f, -0.04131008f, -0.11387169f, 0.09541595f, 
    -0.02195184f, -0.00990774f, 0.19028451f, -0.08524750f, -0.03328752f, 0.09172462f, 0.02691254f, 0.01917296f, 
    -0.07147728f, 0.11681177f, 0.24292029f, -0.05218399f, 0.02869568f, 0.24536394f, -0.02202522f, -0.02077903f, 
    0.05565514f, 0.04910036f, 0.10528626f, 0.06210922f, 0.41696560f, -0.19797045f, -0.05388572f, 0.10483542f, 
    0.10742661f, -0.00780071f, 0.05577322f, 0.05537130f, -0.07070594f, 0.02808973f, 0.08678050f, -0.04174978f, 
    -0.04580867f, 0.03128996f, -0.24471197f, -0.06674312f, 0.05881028f, 0.04645120f, 0.04207785f, -0.05695446f, 
    -0.09044756f, -0.04760091f, -0.11831610f, 0.06669702f, 0.01889692f, -0.19816540f, 0.01247941f, 0.11205855f, 
    0.05723616f, -0.23660688f, -0.15532412f, -0.05727653f, -0.07703759f, 0.04365570f, 0.01825575f, -0.00987336f, 
    0.05824890f, -0.06387062f, 0.01384669f, 0.09117217f, 0.12837806f, -0.09612205f, -0.04303607f, -0.03080498f, 
    -0.04351652f, 0.15058114f, 0.05843675f, 0.11836790f, -0.26627570f, -0.26315147f, -0.09646490f, 0.03442548f, 
    -0.08832027f, 0.01490953f, -0.13906933f, -0.07532075f, 0.01296849f, 0.04964790f, -0.08867481f, -0.08512641f, 
    0.09561217f, 0.23484586f, 0.09820388f, -0.06945983f, 0.10185060f, 0.13451716f, 0.22566125f, -0.06576627f, 
    0.07797588f, -0.00270291f, 0.05062388f, -0.01079682f, -0.38579276f, 0.24442688f, -0.22377026f, 0.19831368f, 
    0.20565704f, 0.04516038f, -0.07629322f, 0.10394873f, 0.05111680f, -0.00627934f, 0.09419952f, -0.03718024f, 
    0.14846909f, 0.11570770f, -0.17949602f, 0.19216344f, 0.14107700f, 0.01218114f, 0.12195207f, -0.04156958f, 
    -0.07997698f, 0.01751759f, 0.08345022f, -0.10312531f, 0.38109368f, 0.21019223f, -0.14814551f, -0.10125657f, 
    0.03424633f, 0.05085373f, 0.09295709f, -0.01460502f, 0.12474214f, -0.01858684f, 0.16799411f, 0.21190639f, 
    0.05241612f, -0.06571553f, 0.10242207f, 0.02813474f, 0.22612725f, 0.14990009f, 0.07772002f, -0.17317763f, 
    0.11900775f, 0.02661552f, 0.03696262f, 0.06210742f, 0.16892733f, 0.09189428f, 0.32247320f, 0.06134997f, 
    0.01421003f, -0.03605053f, 0.06057589f, 0.10594527f, -0.01087406f, 0.01521998f, -0.16868334f, -0.01024558f, 
    -0.20497604f, 0.27028254f, 0.16200484f, 0.19114783f, -0.02084189f, -0.06152691f, 0.16282098f, -0.05227189f, 
    0.11399289f, -0.12192670f, 0.10921117f, 0.12353100f, -0.76498950f, -0.29675061f, -0.05506880f, -0.39135668f, 
    0.03229686f, -0.00041939f, 0.00002662f, -0.07787332f, -0.11904919f, 0.18317181f, 0.22082917f, 0.01813249f, 
    0.26382974f, -0.05943564f, 0.03562269f, -0.06587762f, -0.02961249f, 0.11885510f, -0.10505639f, -0.04936143f, 
    0.00967747f, -0.02395526f, 0.07266697f, 0.02515546f, 0.19731236f, 0.15746483f, 0.30480158f, 0.12826855f, 
    0.09381800f, 0.07055391f, -0.20898579f, 0.12847513f, -0.02418475f, 0.00683935f, -0.08974328f, -0.04853940f, 
    0.00531057f, -0.13187170f, 0.29422808f, -0.11945297f, -0.01144267f, 0.07469314f, -0.03194828f, -0.01072609f, 
    -0.19917136f, 0.06101703f, -0.12094454f, 0.15458396f, 0.11345530f, -0.29530245f, -0.00656852f, -0.05808437f, 
    0.04094420f, -0.07596583f, -0.01833705f, 0.04845858f, 0.01464787f, 0.07286788f, 0.15532640f, 0.14608662f, 
    0.36712241f, -0.14455074f, 0.04431872f, -0.27340573f, 0.09337306f, 0.01848882f, -0.03556007f, 0.06889017f, 
    0.00247215f, -0.10811424f, 0.05038969f, 0.15675618f, -0.22295442f, 0.04285724f, 0.25193697f, 0.11662336f, 
    -0.01886238f, -0.06303672f, -0.06972096f, 0.01119162f, -0.03487222f, 0.00555876f, -0.01405304f, -0.01384975f, 
    -0.42963749f, -0.17908204f, -0.04114828f, -0.11694776f, 0.02200070f, 0.09640129f, -0.02826533f, -0.12730435f, 
    0.02204919f, 0.07013840f, -0.07120842f, 0.02239798f, 0.14037259f, -0.09282568f, -0.10479324f, 0.26373318f, 
    -0.02322470f, -0.10688590f, 0.10178278f, 0.18628421f, 0.04810793f, 0.05419623f, 0.05604277f, -0.03237986f, 
    -0.76558053f, -0.09768239f, 0.05392698f, -0.17659071f, -0.06622899f, 0.11871324f, 0.04656775f, 0.01529980f, 
    0.08357718f, -0.03459206f, 0.06048663f, 0.03532615f, -0.05792810f, 0.00298826f, 0.08232127f, 0.10848435f, 
    -0.01154068f, 0.06206957f, 0.08403789f, -0.02909259f, -0.08457856f, 0.07916068f, -0.06367917f, -0.04943677f, 
    0.16773660f, 0.22979461f, 0.20420934f, 0.12495036f, -0.07746617f, 0.00017027f, 0.07411058f, -0.04192455f, 
    0.01547952f, 0.01581578f, 0.10260274f, -0.15928671f, -0.00840634f, 0.15399028f, -0.04613241f, 0.03162968f, 
    -0.08060514f, -0.10280721f, -0.09687387f, 0.00759031f, -0.10745763f, -0.00842290f, 0.12386543f, 0.06461187f, 
    0.08598795f, -0.02949024f, 0.04607868f, -0.01381506f, -0.08319137f, 0.28662959f, 0.22734749f, -0.30244496f, 
    -0.05817813f, 0.05724591f, -0.00554307f, 0.11165855f, 0.08028574f, -0.08424461f, -0.05021963f, 0.29387128f, 
    -0.04166590f, -0.07659608f, -0.02510417f, -0.00680461f, 0.03743651f, 0.09699913f, -0.04787363f, -0.04176964f, 
    0.24762680f, -0.15866040f, -0.09676076f, -0.14307842f, 0.12135553f, -0.03130255f, -0.03258621f, 0.05677944f, 
    -0.06494005f, -0.06712310f, -0.04889933f, 0.17265353f, -0.26806703f, -0.18354525f, -0.17725299f, 0.01098156f, 
    0.04081047f, -0.05754241f, -0.05714136f, -0.01962025f, -0.03511306f, 0.23433821f, -0.00771324f, -0.12384759f, 
    0.12329218f, -0.11425518f, 0.25863126f, 0.38835353f, -0.07977422f, -0.01446902f, 0.10686440f, -0.05467486f, 
    0.07085290f, 0.00183234f, -0.02270764f, 0.06512158f, -0.02669997f, 0.05725314f, -0.16357419f, 0.02683510f, 
    -0.07854361f, 0.01108759f, -0.10573918f, 0.01757543f, -0.09188504f, -0.10691705f, -0.01669169f, -0.06864700f, 
    -0.15275511f, 0.01055806f, 0.17240562f, -0.13147533f, 0.08066570f, -0.19548635f, 0.05410001f, 0.03345548f, 
    0.06230965f, 0.09863073f, 0.01641498f, 0.16071594f, -0.36294872f, 0.50546634f, -0.16129118f, -0.08242070f, 
    -0.09144595f, 0.18524252f, -0.00188723f, 0.05866423f, 0.17814952f, 0.04407803f, 0.04482995f, 0.02974994f, 
    0.23868999f, 0.32817858f, 0.22108060f, 0.08251389f, -0.01433136f, -0.09486660f, 0.06206317f, -0.12644239f, 
    0.02634574f, 0.20222555f, 0.02760944f, 0.09678680f, -0.20472483f, 0.12637548f, -0.17959623f, -0.08096761f, 
    0.21118881f, 0.06011624f, 0.13670038f, 0.04058671f, -0.04858558f, -0.02267663f, -0.13385652f, 0.13902819f, 
    -0.30961579f, -0.05633951f, -0.19447066f, -0.27787700f, -0.02677022f, 0.18585721f, -0.10935195f, 0.06792761f, 
    -0.03364734f, 0.01057958f, 0.03940586f, 0.06957465f, 0.47143614f, 0.04291241f, 0.14829431f, 0.20575759f, 
    -0.14325643f, 0.01523705f, 0.16179492f, 0.07198677f, -0.08455776f, -0.15978129f, 0.23136912f, 0.00072087f, 
    -0.26939517f, -0.22313067f, 0.15898658f, 0.02248579f, -0.00167249f, 0.07300752f, -0.17368087f, -0.03764708f, 
    0.15533270f, 0.12628366f, 0.02751143f, 0.15897694f, 0.53892422f, -0.11570865f, -0.05688718f, 0.09152932f, 
    -0.12891780f, 0.17147283f, -0.03119640f, 0.11156172f, 0.04029652f, 0.09502115f, -0.06996219f, -0.03944843f, 
    -0.10054387f, 0.12511054f, 0.30929032f, -0.15254842f, -0.14992176f, -0.16602343f, 0.06906503f, -0.11401801f, 
    0.17377771f, 0.01569990f, -0.04603269f, 0.03284727f, -0.13270259f, -0.09642752f, 0.53527039f, -0.16738957f, 
    -0.01972491f, -0.14435205f, -0.08932003f, -0.07469475f, -0.14175671f, -0.03360654f, 0.09814472f, 0.05793051f, 
    0.28158686f, 0.13390841f, -0.07887375f, 0.00623604f, 0.03028144f, 0.06953087f, -0.13637212f, 0.04553732f, 
    0.10165776f, 0.21027851f, 0.01031307f, 0.01438623f, 0.29014912f, 0.18693464f, -0.49423122f, 0.25474116f, 
    0.05328716f, 0.23553270f, -0.01166100f, 0.10004621f, 0.10596267f, -0.00064320f, 0.06733768f, -0.05564325f, 
    0.40815693f, -0.26719415f, -0.19358277f, -0.10268430f, 0.11805074f, 0.07922330f, 0.01499915f, 0.03153554f, 
    0.06412732f, -0.18099540f, -0.15027902f, 0.08145806f, -0.13440330f, -0.00250719f, -0.14226362f, -0.02195139f, 
    0.14831622f, 0.05331095f, -0.04460282f, 0.00287070f, -0.03167440f, 0.03472893f, -0.09958778f, 0.00906943f, 
    -0.10087785f, 0.08443562f, -0.07454487f, 0.18300436f, -0.14087512f, -0.01883801f, -0.02285273f, -0.16265726f, 
    0.01972697f, 0.09200343f, -0.13877931f, -0.00575339f, -0.05768532f, -0.06272950f, -0.04715668f, 0.21040027f, 
    -0.11144467f, 0.17705773f, -0.04179267f, -0.14717141f, -0.00564636f, -0.13403162f, 0.12798622f, -0.00623234f, 
    -0.04496901f, -0.12053929f, -0.07530113f, -0.05679446f, 0.20528600f, 0.16786949f, 0.25749645f, 0.07357520f, 
    0.27306584f, 0.00073017f, -0.01948635f, 0.05221911f, -0.53593439f, 0.41792437f, -0.04180495f, -0.20092644f, 
    -0.00219647f, 0.09978296f, -0.00619460f, -0.00793188f, 0.01609677f, 0.13377772f, -0.03915539f, 0.06038933f, 
    0.14919807f, 0.40474182f, 0.23101673f, 0.26864719f, 0.19705127f, -0.06629532f, 0.14467314f, -0.11809286f, 
    -0.08470011f, 0.24217740f, -0.07833979f, 0.06695648f, 0.00822387f, -0.01976765f, 0.01029946f, 0.16642597f, 
    0.04543185f, -0.07314533f, -0.14054063f, 0.24195069f, 0.04394068f, 0.05307075f, 0.03386603f, 0.11870520f, 
    -0.03827724f, -0.01402502f, -0.05813169f, -0.30236629f, -0.00764020f, -0.03455915f, -0.12834173f, 0.18335284f, 
    0.05099758f, -0.11957609f, 0.03127691f, -0.16290055f, 0.13569936f, 0.09204558f, 0.12409570f, -0.05059781f, 
    -0.14872006f, -0.00025968f, 0.09401724f, -0.24215224f, 0.00992013f, 0.13282211f, 0.27738789f, 0.08515830f, 
    0.21465132f, -0.23710595f, -0.39546481f, 0.14949584f, 0.11091551f, 0.07123832f, -0.17856027f, 0.07357497f, 
    0.01178424f, 0.22600664f, 0.05336381f, -0.00406688f, -0.07500569f, 0.04875452f, 0.07988725f, 0.18484811f, 
    -0.02314941f, 0.03245815f, 0.04711198f, 0.04886345f, 0.06047154f, 0.00095986f, -0.03374233f, 0.01719911f, 
    0.03195941f, -0.06679841f, -0.03398226f, -0.05168634f, -0.05893966f, 0.00848379f, -0.03586331f, -0.00133829f, 
    -0.01073839f, 0.01716057f, -0.00111157f, 0.04486182f, -0.01319382f, 0.04716434f, 0.02956345f, -0.01493173f, 
    -0.02317718f, -0.05205467f, -0.01463131f, -0.04335326f, -0.02647466f, -0.07301337f, 0.05025196f, -0.06632362f, 
    0.06461736f, 0.03295273f, 0.01991745f, -0.04215828f, 0.00723628f, 0.00943356f, 0.06358790f, -0.00755887f, 
    -0.05828843f, -0.03231054f, -0.05869446f, 0.01840489f, -0.05214271f, -0.05140620f, 0.01598181f, 0.00890027f, 
    0.05196440f, -0.06323194f, 0.05058783f, 0.00437708f, -0.00180936f, -0.05040596f, 0.01707538f, -0.05517441f, 
    -0.05655880f, -0.04504322f, 0.04293793f, 0.05832723f, -0.06177161f, -0.02950198f, -0.03878076f, -0.02860027f, 
    -0.03444538f, 0.05620643f, 0.06558507f, -0.02213517f, -0.05146104f, 0.02160673f, -0.03447162f, 0.02670454f, 
    -0.05964882f, 0.00258419f, -0.00757780f, 0.04376118f, -0.00772078f, -0.00500887f, 0.05067182f, 0.05614717f, 
    -0.04407494f, 0.06897096f, -0.01939013f, -0.03754788f, 0.03188238f, -0.00528340f, 0.02496126f, -0.04659041f, 
    -0.05275600f, 0.04155941f, 0.01708041f, -0.06264521f, 0.00537629f, -0.00270244f, 0.05488876f, 0.06671149f, 
    -0.07103694f, -0.07062230f, -0.03969825f, 0.02552949f, -0.06366897f, -0.03159978f, -0.01773164f, -0.03495668f, 
    -0.04732588f, 0.04386605f, -0.02957152f, -0.01831419f, 0.03899267f, 0.03707578f, 0.01260446f, 0.00092581f, 
    0.01087431f, -0.06281222f, -0.05681847f, 0.00968808f, 0.02315593f, -0.02857012f, 0.01747137f, 0.05948935f, 
    0.01397271f, 0.00958667f, 0.01040148f, -0.07439601f, -0.03519367f, 0.01851322f, -0.03196923f, -0.06392974f, 
    0.06356256f, -0.05836630f, 0.03920331f, 0.02128333f, -0.00811414f, -0.04845430f, -0.00151714f, -0.06915054f, 
    0.01919550f, -0.04035026f, 0.05974639f, -0.02684684f, 0.04285499f, 0.01458573f, 0.02918837f, -0.02501004f, 
    -0.02344161f, 0.03563626f, -0.01147062f, -0.00838517f, -0.04281575f, 0.00032744f, -0.04566956f, -0.04379343f, 
    -0.02227116f, 0.00265846f, 0.01868110f, 0.00829474f, -0.03588000f, 0.03866248f, -0.02041038f, -0.00134970f, 
    -0.04321809f, 0.06667289f, -0.02705695f, 0.03593419f, -0.04829910f, -0.05187263f, -0.03780515f, 0.01941801f, 
    -0.02413823f, -0.00830961f, 0.01304371f, 0.07237320f, -0.05533995f, -0.03352259f, 0.05858536f, -0.01215133f, 
    0.01600944f, 0.00039404f, -0.04916190f, -0.03927916f, 0.00368409f, -0.03218100f, -0.01064004f, -0.03507487f, 
    0.03841866f, -0.03432934f, -0.04956704f, 0.01403789f, -0.00325792f, 0.05903980f, 0.02852619f, 0.01453759f, 
    -0.06492195f, -0.02157077f, -0.03000242f, -0.01284281f, 0.04225253f, 0.03352743f, 0.00088484f, -0.04955584f, 
    0.00816600f, -0.08254599f, 0.00798307f, 0.02472598f, 0.05167433f, -0.09353871f, 0.20358004f, 0.11988679f, 
    -0.01622444f, -0.07050326f, -0.01753984f, 0.12629709f, -0.16803984f, 0.11918173f, -0.11533070f, 0.03962386f, 
    0.09527918f, 0.10714541f, 0.00293849f, 0.03298763f, -0.07182287f, 0.06393281f, 0.18019438f, 0.28286770f, 
    0.03470595f, -0.20718999f, -0.01767130f, -0.12623399f, -0.02821442f, -0.05339570f, 0.16009523f, -0.06412606f, 
    0.11337954f, 0.21821482f, -0.03085640f, -0.00615917f, 0.00910632f, -0.08639023f, 0.01152618f, -0.03826374f, 
    -0.02523739f, 0.06347311f, 0.04015684f, 0.05838313f, 0.01007516f, 0.14198193f, 0.08046313f, 0.12053389f, 
    0.32623109f, -0.39574081f, -0.09483621f, 0.07749393f, 0.04606538f, 0.09559105f, -0.05964871f, 0.08849652f, 
    0.09802240f, -0.15681234f, -0.17827919f, 0.12122389f, -0.11183154f, -0.20568091f, 0.12155153f, 0.19846937f, 
    -0.12428734f, 0.00347030f, -0.24477653f, -0.07121865f, -0.03971975f, 0.05057701f, 0.06140349f, 0.00483190f, 
    0.25818875f, -0.28314310f, -0.13461472f, -0.12064505f, 0.06515816f, -0.12366019f, -0.08906589f, -0.10372587f, 
    0.15340225f, 0.02078910f, -0.08751231f, 0.17816253f, 0.03279054f, -0.33236489f, 0.11910801f, -0.06487316f, 
    0.17585693f, -0.02712472f, -0.15168968f, 0.03171992f, -0.00844000f, -0.00500705f, -0.00316390f, -0.06139321f, 
    -0.09112846f, -0.19485755f, 0.02698353f, 0.42636311f, 0.05357100f, -0.03216636f, 0.03632436f, 0.04625915f, 
    0.03867068f, -0.01197134f, -0.11533699f, 0.11775644f, -0.45988712f, 0.22030389f, -0.09537716f, -0.22570482f, 
    0.02116199f, 0.16779268f, -0.04792849f, -0.02590536f, 0.09911684f, 0.10754538f, -0.01942382f, 0.02685206f, 
    0.02797248f, 0.15440653f, 0.34831786f, -0.27378789f, 0.17235607f, 0.13473012f, 0.22154213f, 0.14238702f, 
    0.16976629f, 0.11780453f, -0.04174491f, 0.14810984f, -0.61034763f, 0.03771855f, 0.06113438f, -0.01934898f, 
    -0.00940858f, 0.16442287f, 0.10956433f, 0.20413221f, 0.16334465f, 0.02010854f, -0.12063329f, 0.10053831f, 
    0.02024234f, 0.02593471f, 0.14120090f, 0.11502055f, 0.11760772f, 0.03878485f, -0.22348538f, -0.01271240f, 
    -0.02657284f, -0.08786174f, 0.14656065f, 0.03804939f, 0.04804785f, 0.08622254f, -0.15782842f, -0.12988928f, 
    -0.06332812f, 0.09899651f, 0.16351493f, 0.15860502f, -0.05147215f, -0.00647456f, 0.08376716f, 0.07387447f, 
    -0.15188089f, -0.30268532f, -0.00917188f, 0.00148609f, -0.05484389f, -0.04136225f, -0.03052794f, -0.03462266f, 
    0.18381456f, 0.04132988f, -0.01265705f, 0.06183976f, 0.28535911f, -0.62099040f, 0.10463432f, -0.20206821f, 
    -0.18533511f, 0.05966717f, 0.20860067f, 0.03950797f, -0.06094386f, -0.02094166f, -0.10321597f, -0.00125044f, 
    -0.09002209f, -0.11299968f, -0.15568753f, -0.25420699f, 0.01818660f, -0.01838984f, 0.24364808f, 0.01576403f, 
    -0.01681843f, -0.21035193f, 0.11373634f, 0.18981832f, 0.16433054f, 0.32527849f, 0.19809569f, 0.19450678f, 
    0.08917928f, 0.19943270f, 0.20071656f, 0.12883058f, 0.08128878f, -0.02045111f, 0.01828432f, -0.06192653f, 
    -0.16750216f, 0.10122667f, 0.25770694f, 0.20674296f, 0.10320593f, -0.05069900f, -0.13362423f, 0.20351349f, 
    -0.05408312f, 0.05857932f, 0.03024645f, 0.06948388f, 0.17246071f, 0.31867310f, -0.01667771f, -0.41237643f, 
    0.19088975f, 0.02117105f, 0.03911852f, 0.04324838f, 0.04934725f, -0.00018462f, 0.02985984f, 0.12859458f, 
    -0.08803891f, -0.27809486f, 0.02451488f, -0.10283746f, 0.09371322f, 0.12965223f, -0.16477992f, 0.14132351f, 
    0.13165134f, 0.00670972f, 0.03526191f, -0.03381737f, 0.45983303f, 0.46577623f, 0.23101760f, -0.05867399f, 
    -0.25708526f, 0.01090053f, 0.00654423f, 0.12798050f, 0.04574227f, 0.03486446f, -0.00578072f, 0.06278414f, 
    -0.28262818f, -0.22852951f, -0.06694917f, -0.30851194f, 0.06683283f, 0.02909776f, 0.01775198f, 0.14519884f, 
    0.15901135f, -0.00850457f, -0.03750498f, -0.06580885f, -0.27076393f, -0.31653795f, -0.06489711f, -0.21412368f, 
    0.11644346f, 0.04907061f, 0.27790862f, -0.02760658f, 0.04821620f, 0.16091254f, -0.07277614f, 0.01581594f, 
    -0.27450991f, 0.24364239f, 0.19087896f, 0.11026771f, 0.12737378f, 0.00285483f, 0.05018499f, 0.07636477f, 
    -0.07631782f, 0.03707753f, 0.13747112f, 0.03620003f, 0.30978972f, -0.15072782f, -0.15145910f, 0.05212349f, 
    0.11477598f, 0.22906597f, 0.06957307f, -0.08696976f, -0.14720936f, 0.04163758f, 0.07837183f, -0.02831484f, 
    -0.04890188f, 0.06575231f, -0.28565577f, -0.15512073f, 0.03253473f, 0.23620912f, 0.01700136f, -0.12925741f, 
    0.10569520f, 0.01273265f, -0.03346052f, -0.00741795f, -0.04827313f, -0.33077633f, -0.29358101f, 0.23887503f, 
    0.01214114f, -0.09099726f, 0.06642939f, 0.02704892f, 0.08958486f, -0.09720533f, 0.02334136f, -0.13878298f, 
    0.24916552f, 0.24056134f, 0.11733283f, 0.08615810f, 0.00619052f, -0.08177288f, -0.06430009f, -0.02963108f, 
    0.14498655f, 0.04453244f, 0.07776002f, 0.01725311f, -0.09446733f, -0.05296267f, -0.05464426f, -0.24729986f, 
    -0.06547681f, 0.00622152f, 0.03256803f, -0.10787643f, 0.00462524f, 0.11913931f, -0.12828183f, 0.07745501f, 
    -0.16175570f, 0.24412848f, 0.14523102f, 0.32762992f, 0.09175938f, 0.03057597f, 0.16580404f, 0.07077689f, 
    0.06058599f, -0.02174857f, 0.00699881f, 0.10316297f, -0.05365976f, -0.29714623f, 0.03660572f, -0.02988275f, 
    0.09746537f, -0.01237321f, 0.05963210f, 0.00491016f, 0.12557046f, 0.03583307f, 0.11819831f, 0.11053094f, 
    -0.01560035f, 0.02956406f, -0.02527033f, 0.04655097f, -0.02771330f, -0.03349926f, 0.04134862f, 0.04900860f, 
    -0.01357432f, -0.07014176f, 0.00672346f, 0.02568809f, 0.03449728f, -0.01315292f, 0.02653844f, -0.04365931f, 
    -0.01595920f, 0.03551321f, -0.08142783f, -0.06903346f, 0.04933649f, -0.04362424f, -0.05628034f, -0.05779749f, 
    0.03091219f, 0.04790076f, -0.06848208f, -0.06268010f, -0.07577468f, -0.01057385f, -0.00565750f, -0.01185316f, 
    0.05837265f, -0.06717964f, -0.00515833f, -0.02345039f, -0.01378286f, -0.07202989f, -0.04571309f, -0.02812918f, 
    -0.06180913f, -0.00017360f, 0.05250911f, 0.02635044f, -0.06787052f, 0.00851824f, -0.01934262f, -0.06163033f, 
    0.04594456f, -0.03939650f, -0.04039406f, -0.03495446f, 0.02446979f, 0.02926262f, 0.00088552f, 0.05910305f, 
    -0.01028085f, -0.01848394f, -0.01310432f, 0.04286346f, -0.01731606f, -0.07109118f, -0.03897014f, -0.04515928f, 
    -0.04869840f, -0.07979783f, -0.02181069f, -0.00487708f, -0.04866523f, -0.07204230f, -0.06509784f, 0.03532160f, 
    0.03377892f, -0.00524733f, -0.07229263f, -0.02758818f, -0.00375688f, 0.05960190f, 0.01552533f, -0.01431363f, 
    -0.07055049f, 0.00734487f, -0.01554901f, 0.05931181f, 0.00699004f, 0.02371207f, -0.06772408f, -0.07778649f, 
    0.04474590f, -0.02094552f, 0.04733412f, -0.05033689f, -0.04159782f, -0.05616605f, 0.00770257f, 0.05732694f, 
    -0.03724815f, -0.04648163f, -0.03079725f, -0.02380522f, -0.01881619f, -0.00679114f, 0.02826078f, 0.05624252f, 
    -0.01283052f, 0.02641740f, -0.01906380f, 0.00332768f, -0.06454682f, -0.07602578f, 0.00273629f, -0.03148294f, 
    -0.02243621f, -0.02924365f, 0.01120902f, -0.02522257f, 0.05259021f, 0.02329839f, 0.01499169f, -0.05345363f, 
    -0.08009166f, -0.07945034f, 0.04174139f, -0.06183222f, 0.04084482f, -0.00662881f, 0.06179261f, -0.01026596f, 
    0.00495563f, -0.02281308f, 0.05985409f, -0.01671454f, -0.06720205f, 0.03644985f, -0.02965372f, -0.04893706f, 
    -0.00300948f, -0.02294689f, -0.02833324f, -0.03500094f, 0.04830465f, 0.02846162f, 0.05678733f, -0.01624301f, 
    0.05885714f, -0.07770564f, -0.02962273f, -0.01957357f, -0.05625780f, -0.02069843f, 0.01724062f, -0.00478505f, 
    0.02740207f, -0.05629625f, -0.00899870f, 0.05163789f, -0.03385561f, -0.07911820f, -0.07795244f, 0.06207279f, 
    0.01589222f, 0.05815484f, -0.03778316f, -0.03118575f, 0.03531722f, -0.02172149f, 0.01879745f, -0.04980139f, 
    0.05705552f, 0.00390166f, -0.05842632f, 0.05380158f, -0.02756256f, 0.05860300f, 0.04181347f, 0.00239170f, 
    0.01221403f, -0.00019009f, -0.00629507f, -0.01112595f, -0.02348908f, -0.05726667f, -0.07621451f, 0.05145002f, 
    -0.03949898f, -0.04893291f, 0.03030959f, -0.01474485f, 0.01985870f, -0.01937372f, -0.02536475f, -0.02785392f, 
    0.00978332f, -0.02132482f, 0.05800632f, -0.06533052f, 0.04190382f, -0.01052112f, -0.06741302f, 0.00928279f, 
    -0.05390155f, -0.00763361f, 0.01595178f, 0.04603093f, -0.01091910f, -0.04700170f, -0.01797305f, 0.04666556f, 
    0.03314819f, 0.00349375f, -0.05905581f, -0.04627663f, 0.03669022f, -0.06442126f, 0.00473551f, 0.04845703f, 
    -0.01882535f, 0.06290539f, -0.04701580f, -0.07111004f, -0.06068644f, 0.04842629f, -0.04613243f, 0.05911295f, 
    0.05906960f, -0.00036033f, 0.06440052f, -0.01558607f, 0.04131471f, -0.06816164f, 0.05770169f, -0.03606494f, 
    0.02144263f, -0.07176036f, -0.02619047f, -0.04115145f, -0.04927760f, -0.02124564f, -0.05604637f, 0.06666458f, 
    -0.03759547f, 0.04823904f, 0.02575027f, 0.01483284f, -0.02896392f, 0.00137753f, -0.01501632f, 0.06697027f, 
    -0.02674301f, 0.06564847f, 0.05665898f, 0.04300452f, 0.06655859f, 0.00878229f, -0.01947252f, -0.02124367f, 
    0.06416693f, 0.06401508f, -0.01973944f, -0.01543970f, 0.00546500f, -0.03094210f, 0.03619243f, -0.06598263f, 
    0.06557961f, -0.04909126f, -0.04086682f, -0.04951164f, -0.07040244f, 0.00480304f, -0.06508999f, -0.03654685f, 
    0.07074998f, 0.04289500f, -0.05744195f, 0.01669498f, -0.00290386f, 0.03716306f, -0.05522222f, 0.04739830f, 
    0.05573333f, 0.02207466f, -0.06357113f, 0.06678068f, -0.06443492f, -0.04237935f, -0.00251275f, 0.02495978f, 
    -0.05878024f, -0.04569252f, -0.01531610f, -0.02228225f, -0.05725675f, 0.02154147f, -0.05972948f, -0.05631858f, 
    0.06647220f, 0.00834673f, 0.06242427f, -0.05846257f, -0.01061694f, -0.05060265f, 0.02659198f, 0.04526442f, 
    -0.07045514f, -0.03031954f, -0.01581252f, 0.03119246f, 0.06168902f, -0.05124069f, -0.04556539f, -0.05700412f, 
    0.00882816f, 0.02717168f, -0.06438056f, -0.02075793f, -0.04351553f, -0.03429845f, 0.03762543f, -0.00415595f, 
    0.02827857f, -0.04273083f, 0.01068386f, 0.02374268f, -0.04069396f, 0.03827586f, 0.03866280f, -0.03830858f, 
    -0.06656487f, -0.01556185f, 0.02554032f, -0.03281950f, -0.04289461f, -0.04296951f, 0.05839319f, -0.01102326f, 
    -0.05639993f, -0.02168079f, 0.07064213f, 0.01881760f, -0.02545894f, 0.06524448f, -0.06455030f, -0.04691217f, 
    -0.01558468f, -0.04412149f, -0.03733735f, -0.04772917f, 0.02831279f, 0.01484595f, 0.00009453f, -0.06424125f, 
    -0.03617883f, -0.05470672f, -0.03345576f, 0.01043619f, -0.06311472f, -0.05943641f, -0.06575669f, -0.01469404f, 
    -0.00379747f, 0.00084443f, -0.00254184f, -0.01857769f, -0.04078494f, -0.05302107f, -0.03899150f, -0.01070473f, 
    -0.02990031f, -0.06091259f, -0.05039484f, 0.06000268f, -0.04924314f, 0.05504204f, 0.07085812f, -0.01727645f, 
    -0.00906098f, -0.00019986f, -0.03932229f, 0.02944977f, -0.06517927f, -0.05499620f, 0.02176493f, -0.04987683f, 
    -0.22952349f, -0.00037031f, -0.13717559f, -0.19301845f, 0.05968980f, 0.05470550f, 0.04255730f, 0.10834254f, 
    -0.04086742f, -0.01700826f, 0.15418231f, 0.10207230f, -0.10532048f, 0.20546840f, -0.14458248f, 0.00821656f, 
    0.20757799f, 0.21039642f, 0.17423630f, 0.06253190f, 0.35634011f, 0.12749012f, -0.02942771f, 0.04712269f, 
    -0.09426437f, 0.16547818f, 0.13753308f, 0.07856199f, 0.08556503f, -0.13482931f, -0.08243351f, 0.26036832f, 
    -0.05949331f, 0.14845660f, 0.12099247f, 0.14863367f, 0.00489538f, -0.06402641f, 0.27321205f, -0.26894853f, 
    0.00205742f, 0.00220268f, -0.01509492f, 0.14972429f, 0.01810893f, 0.04878439f, 0.10158782f, 0.18844968f, 
    -0.31978735f, 0.08635466f, 0.09378956f, -0.01523020f, 0.11554418f, -0.00049717f, 0.12219582f, 0.02399418f, 
    0.12251865f, 0.02200071f, 0.17296448f, 0.12760097f, 0.25960425f, 0.32858276f, 0.09257586f, -0.15041670f, 
    -0.07250759f, 0.04598295f, 0.03253882f, 0.08677147f, 0.18933138f, 0.06596000f, 0.18902411f, 0.16200842f, 
    -0.26358557f, 0.01803654f, -0.19098145f, -0.26447198f, 0.03075306f, 0.01822847f, 0.01448513f, 0.02364433f, 
    -0.03748952f, 0.11787601f, 0.05980398f, 0.10528308f, -0.09402612f, -0.13770369f, -0.10536106f, -0.06474557f, 
    0.04670925f, 0.00292851f, 0.33089361f, 0.01264173f, 0.04896001f, 0.05217430f, 0.18598935f, 0.09054321f, 
    0.06247078f, 0.01899524f, 0.23440006f, 0.00249645f, -0.04854474f, 0.02925851f, -0.07517716f, 0.04608653f, 
    0.00429241f, -0.11098147f, 0.16979784f, -0.02261574f, 0.17388515f, -0.24548189f, 0.05397911f, 0.13827667f, 
    0.11093504f, -0.06900352f, 0.15991525f, -0.02411443f, 0.00812961f, 0.08718958f, 0.10442691f, 0.00379359f, 
    -0.31057739f, -0.34880745f, -0.14246951f, -0.01137989f, -0.06924584f, 0.12791210f, 0.04770547f, 0.11263783f, 
    0.18045726f, -0.09390830f, -0.05736339f, -0.02932263f, 0.01370996f, -0.24506414f, 0.17861973f, 0.27386472f, 
    0.02125603f, -0.09609602f, 0.03386560f, -0.06626114f, 0.06292458f, 0.05246372f, 0.15121859f, 0.03961184f, 
    0.16984113f, 0.25079784f, 0.25329760f, 0.09111632f, 0.12049713f, -0.00331328f, -0.01908481f, -0.11286275f, 
    0.09274434f, 0.09289391f, 0.06072218f, -0.03534081f, -0.38774428f, -0.18885058f, -0.22304614f, -0.17220661f, 
    -0.00959303f, 0.00884871f, 0.11149642f, 0.18399248f, 0.05682864f, 0.15188721f, -0.01511813f, 0.08987888f, 
    -0.08425770f, 0.43153283f, 0.16172223f, 0.23893313f, -0.03837857f, 0.23950140f, 0.07592731f, 0.07163869f, 
    0.10633244f, -0.08355548f, 0.07486921f, -0.08625618f, -0.66948271f, 0.00105203f, -0.18882093f, -0.17373903f, 
    0.07650741f, -0.06376588f, -0.10319025f, -0.00147983f, -0.05805369f, 0.02302529f, 0.12916745f, 0.14214772f, 
    0.15136306f, 0.15300860f, 0.05509156f, -0.00279037f, 0.05970853f, 0.07887764f, -0.07795405f, -0.07246390f, 
    0.02723782f, 0.18360993f, 0.05376835f, -0.07680068f, 0.02580810f, 0.00967359f, 0.02080038f, -0.30624634f, 
    -0.06517594f, 0.03295745f, 0.03515746f, 0.10196639f, 0.04126741f, 0.10944921f, -0.10758279f, -0.05708415f, 
    0.25757441f, 0.16659135f, 0.03045682f, 0.21052752f, 0.01927140f, 0.06740153f, 0.07287761f, -0.08070493f, 
    0.11083430f, -0.10138398f, 0.12750021f, -0.02900571f, -0.10893870f, 0.03668480f, 0.21420537f, 0.33003655f, 
    -0.11542854f, -0.07885737f, 0.02471636f, -0.08739101f, -0.07668031f, -0.08967507f, -0.18267742f, -0.03568659f, 
    -0.06004436f, 0.57124549f, -0.05346585f, -0.00748524f, 0.06083268f, -0.07170475f, 0.13812421f, -0.16966711f, 
    0.11630671f, -0.02859667f, 0.10969368f, 0.15111968f, -0.49826041f, 0.06752063f, 0.14525920f, -0.40335411f, 
    0.04768408f, 0.01611153f, 0.16154416f, -0.11468325f, 0.06743516f, -0.00262903f, 0.04219864f, -0.03165919f, 
    -0.25830340f, -0.11399751f, 0.00579449f, 0.27906927f, -0.03663220f, 0.05973146f, -0.01725869f, -0.00047463f, 
    -0.02930162f, 0.02667806f, 0.16881180f, -0.07556641f, 0.22080870f, 0.31499338f, -0.13598467f, 0.19053940f, 
    -0.11325011f, -0.01826990f, 0.06171906f, -0.00297476f, -0.06328695f, 0.08783947f, -0.01600684f, 0.15771820f, 
    0.07817163f, 0.04532336f, 0.36423132f, -0.18478656f, 0.03871831f, 0.05541131f, 0.08635733f, -0.08245943f, 
    0.04903056f, 0.15112460f, 0.06093641f, 0.01344753f, 0.22197860f, -0.06354270f, 0.09462972f, 0.15863040f, 
    -0.06941804f, -0.15070087f, 0.03209574f, 0.05494308f, -0.01328494f, -0.04888676f, -0.06972816f, 0.11646306f, 
    0.21589345f, -0.19397290f, 0.05310722f, 0.19601637f, -0.05956019f, -0.14063543f, -0.10848984f, -0.01734824f, 
    -0.18052126f, -0.16742545f, 0.00576536f, -0.04083065f, 0.17273836f, -0.13533531f, 0.17795026f, 0.06602872f, 
    0.02788031f, -0.05053522f, 0.10344662f, -0.01746640f, 0.08575095f, 0.19183174f, 0.02548536f, -0.04251555f, 
    -0.13729145f, -0.03165717f, 0.05518427f, -0.12885772f, -0.03890362f, 0.05683672f, 0.08443536f, 0.05054018f, 
    -0.05107968f, 0.04208224f, -0.09852479f, -0.03621915f, -0.20686804f, -0.15777676f, -0.18778001f, 0.15852369f, 
    0.20284146f, 0.04508320f, 0.00019774f, -0.09551191f, 0.03356391f, 0.02223483f, 0.04225551f, -0.08592564f, 
    -0.46316803f, 0.06186872f, 0.04424116f, -0.05467993f, 0.11206754f, 0.12060466f, -0.09952798f, -0.02859298f, 
    0.11732527f, -0.09611581f, -0.01938322f, -0.02147410f, 0.00410882f, 0.01290825f, -0.14206791f, 0.05724598f, 
    0.02623552f, 0.09668365f, -0.06407727f, -0.00960018f, 0.00235295f, -0.01842896f, 0.13035625f, 0.01860116f, 
    0.39909735f, -0.00285859f, 0.08396206f, 0.06757246f, -0.00298309f, 0.07847666f, -0.14767706f, 0.00937738f, 
    0.02394775f, 0.18902998f, 0.11141818f, 0.02082223f, 0.23358700f, -0.12465860f, 0.08817193f, -0.27324873f, 
    -0.02116049f, -0.07058581f, -0.00965981f, 0.00469574f, 0.01281721f, 0.01176072f, -0.30918384f, -0.19800302f, 
    0.09697354f, -0.15006736f, -0.03032023f, 0.16142090f, 0.10244276f, 0.21023032f, 0.12317845f, -0.07448179f, 
    0.03158132f, -0.10578314f, 0.02148969f, -0.05066950f, -0.32769552f, -0.04621881f, 0.19171488f, 0.15871575f, 
    -0.02763711f, 0.10555441f, 0.03794535f, -0.12966684f, 0.00481410f, -0.13938351f, -0.20878837f, -0.11207758f, 
    0.07613365f, 0.43148518f, -0.13786025f, 0.01270276f, -0.04683970f, 0.06347032f, 0.16693896f, 0.00137129f, 
    -0.10233852f, -0.03320738f, 0.22989579f, 0.06198772f, -0.40598264f, 0.03020200f, 0.09628350f, -0.21222952f, 
    0.11360506f, 0.05321851f, 0.09956994f, -0.08805304f, 0.04605366f, 0.02086867f, 0.04244226f, -0.11473890f, 
    -0.31287095f, 0.01360047f, 0.21341881f, 0.35024449f, -0.03806802f, 0.08314890f, 0.03339350f, 0.28695154f, 
    0.05052690f, -0.07813873f, 0.31502205f, 0.04978085f, 0.11058747f, 0.14276721f, -0.06074688f, 0.10927729f, 
    -0.17864048f, 0.03870848f, 0.11531612f, 0.10305687f, -0.02191634f, 0.22391228f, -0.10081530f, 0.21855386f, 
    -0.13136491f, 0.05334387f, 0.25335106f, -0.12288424f, 0.09843519f, 0.09889170f, 0.10223999f, -0.05566211f, 
    0.01565096f, 0.22530377f, 0.10076440f, 0.06378643f, 0.33864975f, -0.04238247f, 0.12034308f, 0.14583050f, 
    0.00487773f, -0.14999333f, 0.09163594f, 0.07623157f, 0.02302151f, -0.02459229f, -0.18048073f, 0.01893701f, 
    0.14695743f, 0.00485176f, -0.14680906f, 0.13094112f, -0.04037533f, -0.09947623f, -0.13201849f, -0.04214416f, 
    0.00038890f, -0.09185899f, 0.12671271f, 0.02975565f, 0.34212932f, 0.10668199f, 0.08273792f, -0.31535286f, 
    0.13194101f, -0.00800482f, 0.13298143f, -0.08446030f, 0.00953286f, 0.07399766f, -0.04046990f, 0.04727814f, 
    -0.14066103f, -0.07871711f, -0.08798530f, -0.08165687f, -0.06699581f, -0.06515535f, 0.28753573f, 0.11487264f, 
    0.01523697f, 0.12830321f, -0.09326379f, 0.10540579f, 0.16079235f, 0.01918158f, 0.04570913f, 0.15270977f, 
    -0.08009401f, -0.14954937f, -0.07692580f, 0.17127983f, -0.01934165f, -0.04532141f, 0.01143179f, 0.00393974f, 
    -0.31964418f, 0.01681401f, 0.07463197f, -0.18241917f, 0.00486662f, 0.11376353f, 0.00334493f, 0.06740434f, 
    0.03003317f, -0.04335942f, 0.00619795f, 0.03392697f, 0.37812227f, 0.06527485f, -0.08287690f, 0.18358886f, 
    0.03977492f, 0.16296040f, -0.05983974f, -0.00717232f, -0.01587281f, 0.06554276f, 0.01716702f, 0.01526289f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.09062940f, 0.15192047f, 0.04148369f, -0.02718597f, -0.12157415f, 0.06011576f, 0.01566200f, 0.00460488f, 
    0.00846285f, 0.00078535f, 0.02976823f, 0.04454649f, -0.08158393f, 0.01331715f, 0.01146448f, -0.12457308f, 
    -0.06656066f, -0.04628313f, -0.03770121f, -0.12820768f, 0.17820805f, 0.12764156f, 0.16389379f, 0.11710754f, 
    -0.02660416f, 0.09401565f, 0.17797099f, -0.04848174f, -0.00250945f, 0.01729819f, 0.05324698f, 0.02437150f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.03372660f, -0.09665454f, -0.04686445f, 0.14288554f, 0.41600093f, 0.16457315f, -0.14381360f, 0.22500129f, 
    -0.01361179f, 0.55515957f, 0.09175719f, -0.31781593f, -0.02854194f, -0.06101298f, 0.12938280f, -0.03423944f, 
    -0.17215146f, 0.07708840f, -0.13594492f, 0.33529109f, -0.32656467f, -0.10711255f, -0.04476092f, 0.06064630f, 
    -0.11863280f, 0.07703377f, -0.23544124f, 0.15830337f, 0.07529168f, -0.40469432f, 0.01130125f, 0.26320934f, 
    0.30847859f, 0.45397756f, -0.04405378f, -0.09251624f, -0.22823483f, 0.19235131f, -0.07334297f, -0.07890078f, 
    0.01215342f, 0.18224990f, -0.19752894f, 0.04373138f, 0.10159137f, 0.08793084f, 0.02505663f, -0.09987909f, 
    -0.01645519f, -0.17428343f, 0.05842999f, 0.07612043f, 0.10063712f, -0.28693822f, 0.27626184f, 0.46472645f, 
    0.05315004f, -0.19846632f, 0.22390841f, -0.00859494f, 0.13667287f, -0.17384787f, -0.27790415f, -0.11875328f, 
    0.67815214f, 0.14069258f, 0.07336607f, 0.16611657f, 0.21116608f, 0.11159577f, -0.00189041f, -0.11950921f, 
    0.01063121f, 0.01185387f, -0.12468079f, -0.00724676f, 0.11356761f, -0.07650589f, -0.25814793f, -0.00663108f, 
    0.17949301f, -0.30235031f, -0.03483889f, -0.58433139f, 0.02501189f, 0.07450353f, 0.21537919f, -0.31769061f, 
    -0.10086659f, 0.16422273f, 0.07965398f, -0.00215842f, -0.12516563f, 0.04453505f, -0.07101145f, 0.38896343f, 
    -0.20848690f, -0.35786009f, 0.15625274f, 0.07598966f, -0.04395194f, 0.41750607f, 0.11819039f, 0.21415164f, 
    0.04880329f, -0.29068023f, -0.08638579f, 0.24297102f, 0.00019387f, 0.14143260f, 0.12199462f, -0.08556642f, 
    -0.08855975f, 0.28258637f, 0.13834776f, -0.08994890f, -0.08386531f, 0.45500064f, 0.37135586f, 0.12148297f, 
    -0.13113533f, 0.06523874f, -0.21490446f, -0.04983730f, 0.10051096f, -0.27086592f, 0.41231054f, 0.08319823f, 
    -0.12536491f, 0.13252719f, 0.05434837f, -0.17773266f, 0.22994716f, -0.01486510f, 0.14266479f, -0.16054213f, 
    0.12246566f, 0.18554261f, 0.08461410f, -0.30305389f, 0.03045512f, 0.14011420f, -0.08379842f, -0.00732182f, 
    -0.21126305f, -0.27548158f, 0.08484085f, -0.21471912f, -0.28061330f, 0.23289104f, 0.21071917f, 0.01934089f, 
    -0.05354097f, 0.23999201f, -0.17229635f, -0.17610702f, -0.00985798f, -0.15707597f, 0.02077710f, 0.13926199f, 
    -0.01196243f, 0.03885663f, 0.02857063f, -0.05911500f, 0.29536530f, 0.24533717f, -0.02225352f, 0.10521997f, 
    0.01110432f, 0.68195397f, -0.18164721f, -0.52046466f, -0.02044706f, -0.09594116f, -0.19656016f, -0.08667140f, 
    -0.10617419f, -0.05193899f, -0.08264425f, -0.20119230f, -0.26574937f, -0.08660413f, -0.02133936f, 0.08374258f, 
    0.09274222f, 0.01043582f, -0.01100678f, 0.14636730f, 0.13069522f, 0.01630861f, -0.27081963f, 0.09205107f, 
    0.08627623f, 0.44968429f, -0.11782149f, 0.03170652f, -0.01138246f, -0.00493050f, -0.15195097f, 0.10880496f, 
    0.10988208f, -0.29654622f, 0.16974652f, 0.25943545f, -0.15744151f, 0.14570908f, -0.19755609f, -0.14971370f, 
    -0.22858371f, 0.22818717f, -0.44607595f, -0.35332772f, 0.07159427f, 0.24162647f, 0.39522552f, 0.45040154f, 
    0.02931950f, 0.21243495f, 0.25539273f, 0.01611105f, -0.08347480f, -0.13662831f, 0.23404735f, 0.22464298f, 
    -0.39744639f, 0.18281944f, 0.16172005f, -0.11693438f, -0.09556744f, 0.08171031f, -0.17163992f, 0.11668901f, 
    0.02884225f, 0.06547797f, -0.12580499f, -0.15859942f, -0.03861597f, -0.11815233f, 0.30422750f, 0.01917112f, 
    -0.40100771f, 0.51506716f, -0.07651597f, 0.09549010f, -0.13449936f, 0.15106651f, 0.40355435f, 0.04118466f, 
    -0.12915556f, 0.08096308f, 0.14965563f, 0.11920371f, 0.16154999f, -0.09794880f, 0.39422753f, 0.08625892f, 
    -0.25156161f, -0.04682095f, -0.06242010f, 0.13773066f, 0.32795870f, 0.25265247f, 0.12366942f, -0.17409168f, 
    0.03769911f, 0.29128373f, -0.12792951f, 0.29254407f, -0.15252344f, 0.12462933f, 0.33654842f, 0.33318707f, 
    0.35679916f, 0.18928561f, 0.23898239f, 0.07118420f, -0.11820511f, 0.37679908f, 0.08640703f, -0.29335901f, 
    -0.06604513f, 0.42588487f, -0.05475958f, 0.07467220f, 0.10475190f, -0.24350028f, -0.17625315f, 0.06153092f, 
    0.29661572f, 0.16102070f, 0.17566039f, 0.16277552f, 0.01104593f, -0.08442625f, 0.06614570f, 0.34716991f, 
    -0.06724032f, -0.12023071f, 0.07414668f, -0.06789193f, -0.03801367f, 0.09843081f, -0.10590084f, 0.27365375f, 
    -0.25327331f, -0.24046256f, -0.24837248f, 0.12418278f, 0.22616106f, -0.09480172f, -0.20889892f, 0.03406811f, 
    0.09685684f, -0.40772030f, -0.00304838f, 0.07822385f, -0.09021461f, 0.05557430f, 0.34156859f, 0.43554798f, 
    -0.16454726f, -0.04771244f, -0.13864462f, 0.14712535f, 0.17156878f, 0.03566526f, 0.07346112f, 0.03927692f, 
    0.01861357f, -0.16570230f, 0.00211401f, -0.07434783f, 0.02441999f, 0.08824273f, -0.13407865f, -0.02315550f, 
    0.09818681f, 0.12976064f, 0.19235504f, -0.03260997f, -0.03322998f, -0.08896033f, 0.10482854f, -0.20293212f, 
    0.04322071f, -0.04645544f, 0.08534840f, -0.01827028f, 0.12045784f, -0.18135031f, 0.02721482f, -0.11932278f, 
    0.27353120f, -0.18129590f, 0.14500891f, -0.05651002f, 0.02621341f, 0.49606070f, 0.01067370f, 0.12931591f, 
    0.03993715f, -0.21338853f, -0.23128882f, 0.29946595f, 0.04147330f, 0.08243973f, 0.18511909f, -0.36862326f, 
    0.18386298f, -0.15220430f, 0.40071028f, -0.39549133f, 0.27636158f, -0.00232322f, -0.33215252f, 0.13779251f, 
    0.11414888f, 0.00705359f, -0.08687528f, -0.05683082f, -0.11717041f, 0.19156848f, -0.18626313f, -0.31925255f, 
    -0.13082939f, -0.11274254f, 0.12807380f, 0.17332838f, -0.02012171f, 0.02254160f, -0.05789477f, 0.11673534f, 
    0.08982090f, 0.12475115f, -0.01989871f, 0.11201838f, 0.09924798f, -0.06981381f, -0.12609717f, 0.06980442f, 
    -0.19569497f, -0.07380340f, 0.05113855f, -0.14456168f, -0.11912198f, -0.09405538f, -0.13798144f, -0.13631290f, 
    0.16469136f, -0.18408659f, -0.00617787f, 0.05991606f, -0.10965347f, -0.04470378f, 0.15502448f, -0.13158047f, 
    0.30630371f, -0.45535564f, 0.07201310f, 0.11192103f, -0.27351230f, 0.02221892f, -0.07306060f, 0.16147605f, 
    0.13542657f, -0.22311528f, -0.23938556f, 0.31410286f, 0.12418185f, 0.16033949f, -0.06897675f, 0.07466221f, 
    0.18009979f, 0.21811955f, 0.25383618f, 0.41495821f, -0.23934512f, -0.38778099f, 0.25408113f, 0.32866994f, 
    -0.05740476f, 0.42759246f, -0.05912231f, 0.03303004f, 0.09757157f, -0.06398121f, -0.00248069f, -0.05706266f, 
    0.04680806f, 0.08069826f, -0.00634801f, -0.15091425f, -0.47927549f, 0.24419762f, -0.00536692f, 0.28326011f, 
    -0.06210216f, -0.50656551f, 0.03635797f, 0.12094134f, -0.03824373f, -0.15136033f, 0.18644179f, -0.34303606f, 
    -0.17483315f, 0.27180529f, 0.07269215f, 0.40179089f, 0.27988347f, -0.41459608f, -0.27726796f, 0.08670493f, 
    0.04167844f, -0.50921261f, 0.16276859f, -0.06427332f, -0.01034031f, 0.36684000f, 0.11441533f, -0.15827321f, 
    -0.01302831f, -0.12179282f, 0.09312346f, -0.14179289f, -0.02922637f, 0.02584448f, -0.00948637f, 0.20474470f, 
    -0.09486389f, -0.19479018f, 0.32906094f, -0.16305496f, 0.06566619f, 0.05051767f, 0.01617208f, 0.01740382f, 
    0.26861906f, -0.07811289f, 0.39618164f, 0.11095686f, -0.03441532f, 0.00278534f, -0.12720402f, -0.15404068f, 
    -0.01095951f, 0.23681480f, -0.23755875f, -0.15705872f, -0.00143651f, 0.11428887f, -0.22619349f, -0.10427900f, 
    -0.02734882f, 0.02597344f, 0.12480366f, -0.06130001f, -0.26337588f, 0.22035345f, -0.05268135f, 0.31218281f, 
    -0.14500515f, -0.31203035f, -0.15227273f, -0.30828518f, -0.09817195f, 0.04093702f, 0.26393554f, -0.15999313f, 
    -0.42358816f, 0.22380961f, -0.16909617f, -0.02832934f, 0.03260028f, 0.16728398f, 0.17408587f, 0.01545799f, 
    0.09430296f, -0.22665836f, -0.11041758f, -0.11497974f, 0.00569393f, 0.18390474f, 0.52249885f, 0.26349863f, 
    -0.12885438f, 0.06235919f, 0.06892008f, -0.13916397f, 0.50549841f, 0.05086068f, 0.05012518f, -0.09517820f, 
    0.02820817f, -0.09407001f, -0.00283692f, 0.60123461f, 0.01190905f, -0.09179460f, -0.33395061f, 0.32060051f, 
    0.63449544f, 0.29858163f, 0.04993030f, -0.13100666f, 0.22236750f, -0.08338445f, -0.11840912f, 0.16593176f, 
    0.13506138f, 0.00613596f, 0.21717821f, -0.13209268f, 0.06991907f, 0.10870627f, -0.11748870f, 0.25960019f, 
    0.08138236f, 0.36485389f, -0.14153148f, -0.14324015f, 0.16945046f, -0.37107530f, -0.04432276f, -0.16523294f, 
    -0.06151817f, -0.22915599f, 0.66488278f, 0.13731347f, -0.02434286f, 0.13990982f, 0.23739783f, 0.20721766f, 
    0.55813980f, -0.16763590f, 0.25741306f, 0.53312135f, -0.04054183f, -0.08173928f, 0.31942475f, 0.09414948f, 
    0.05869454f, 0.25783855f, 0.08173911f, 0.10550225f, 0.13799991f, -0.10187440f, -0.29595754f, 0.00807304f, 
    0.48657751f, -0.19316299f, 0.13099745f, 0.02134963f, -0.05833666f, -0.36309361f, -0.07313742f, 0.23985602f, 
    -0.00438456f, -0.27030453f, -0.20426084f, -0.11190759f, 0.14974611f, 0.09078445f, 0.24562007f, 0.44177443f, 
    0.07230908f, 0.07173745f, -0.28301582f, 0.27840647f, 0.01114610f, 0.06536420f, 0.12158444f, -0.13079569f, 
    0.13200077f, -0.15689063f, -0.01431731f, 0.15473197f, -0.09437044f, 0.05808014f, 0.58231378f, 0.60737604f, 
    -0.00829644f, -0.44669700f, 0.02033133f, 0.07139543f, 0.02940098f, 0.32886514f, 0.01247187f, 0.13479777f, 
    0.03008636f, -0.42940250f, 0.21175958f, -0.11183775f, 0.10039455f, -0.03723454f, 0.29943115f, 0.02911066f, 
    -0.00118564f, 0.06387796f, 0.31170008f, 0.23863547f, 0.00861454f, 0.26201811f, 0.14268838f, -0.17036483f, 
    0.11237066f, -0.19555415f, -0.24952522f, 0.12960696f, -0.12471608f, 0.14068301f, 0.15847115f, 0.16378474f, 
    0.27127531f, -0.17054798f, -0.12801254f, 0.04285797f, 0.32988539f, 0.36174110f, 0.15708549f, 0.22534399f, 
    0.14973827f, -0.45380712f, -0.07289220f, 0.28507560f, -0.00005028f, -0.04906900f, -0.59668821f, -0.24402069f, 
    0.25458384f, -0.04148038f, -0.09057786f, -0.26333466f, 0.15270512f, -0.34686577f, 0.05052675f, -0.09124850f, 
    0.14108525f, 0.08505370f, 0.06788266f, 0.12666103f, -0.17343818f, 0.06903282f, -0.18516698f, -0.22932798f, 
    -0.00884216f, -0.05076581f, 0.12083786f, 0.14421184f, -0.44288835f, -0.06781110f, -0.06677506f, 0.06781476f, 
    0.05111479f, 0.15989447f, -0.56150836f, 0.32865644f, -0.08792419f, -0.06174256f, 0.14886382f, -0.26162878f, 
    0.17281580f, 0.32747912f, -0.02292090f, -0.28562477f, 0.13510746f, 0.06519388f, -0.38344359f, -0.20890310f, 
    -0.08257950f, 0.40481639f, 0.31342289f, -0.09371785f, 0.03943390f, 0.25331455f, 0.02437182f, -0.33386457f, 
    -0.01306757f, -0.17176408f, 0.14777181f, 0.00776966f, 0.01745317f, 0.10930292f, -0.16763309f, -0.06161966f, 
    0.06496637f, -0.15832123f, 0.03227444f, 0.05711817f, 0.08643970f, -0.08023300f, 0.05597039f, 0.01510607f, 
    -0.13965850f, 0.05083055f, 0.03885551f, -0.14484711f, 0.01361174f, -0.02948063f, -0.04264199f, -0.13242379f, 
    0.01635521f, 0.12460547f, -0.08547361f, -0.07865592f, 0.04614614f, -0.12907486f, 0.13274708f, -0.14922887f, 
    0.51426452f, 0.32258815f, 0.12178986f, 0.00850181f, -0.33558360f, -0.12510318f, 0.15428200f, -0.05099766f, 
    0.13380317f, -0.24456483f, -0.18236059f, 0.06284299f, 0.11554124f, 0.01563309f, 0.23792796f, -0.28097448f, 
    -0.22463973f, -0.11582189f, 0.31975645f, -0.28269362f, 0.34142455f, 0.40263888f, 0.22733404f, 0.06824244f, 
    -0.03447611f, 0.18033546f, 0.25537491f, 0.08761302f, 0.02952574f, 0.20433505f, 0.13506992f, -0.11703730f, 
    -0.35547838f, 0.05345775f, 0.03187304f, -0.09327780f, 0.18110089f, 0.11931732f, -0.03681114f, 0.26541996f, 
    -0.03193987f, 0.26757389f, 0.39066988f, -0.31896117f, -0.16490716f, -0.00370203f, 0.07683977f, -0.01301026f, 
    -0.29585934f, -0.24198794f, -0.32031882f, 0.11871897f, 0.04845778f, 0.26024503f, 0.02902361f, -0.02569315f, 
    -0.16078199f, 0.11236567f, 0.22823033f, 0.15413074f, -0.04869057f, 0.22731240f, -0.03526910f, 0.06280166f, 
    -0.53266013f, 0.49054265f, 0.11290707f, 0.08100199f, -0.04854169f, 0.33662769f, -0.02352479f, -0.07467242f, 
    -0.09257498f, -0.29100287f, 0.57961148f, 0.18297061f, -0.15434408f, 0.02309332f, 0.17670527f, -0.31321377f, 
    0.09163900f, -0.08127280f, 0.17051019f, 0.20085634f, -0.05158591f, -0.26734456f, -0.00977786f, 0.25855744f, 
    0.01875701f, 0.11145712f, 0.18834588f, 0.16733222f, -0.14342804f, 0.19344130f, -0.11962708f, -0.19034745f, 
    0.12901479f, -0.07365670f, -0.13621554f, -0.11385492f, 0.11225006f, -0.41762421f, 0.00661087f, 0.09039040f, 
    0.14545968f, -0.00722708f, -0.41176355f, 0.34804338f, 0.15927596f, -0.07045522f, -0.06588592f, 0.32173988f, 
    0.41079563f, 0.41133484f, 0.24048156f, 0.04497344f, 0.14644112f, -0.35844582f, -0.15853000f, -0.32067323f, 
    -0.01205336f, -0.02493024f, 0.24019431f, -0.05210154f, -0.12717079f, 0.07484982f, 0.21446760f, 0.23505181f, 
    0.50631571f, 0.38619354f, 0.14339542f, 0.09519597f, 0.17692402f, -0.18414646f, -0.15261753f, 0.21981056f, 
    0.08609048f, 0.36929348f, -0.02429820f, -0.29345936f, 0.05411996f, -0.06164214f, -0.00540010f, 0.07278712f, 
    -0.15298386f, 0.00376764f, 0.60887015f, -0.30769151f, 0.14511694f, -0.07218510f, 0.14362364f, -0.37658003f, 
    0.02283677f, -0.28259316f, 0.34726319f, -0.10783594f, 0.17503528f, 0.19587362f, -0.16545704f, -0.11491825f, 
    -0.33939800f, -0.16261658f, -0.04978837f, -0.04434439f, 0.12805961f, -0.06965367f, 0.07982084f, 0.30327377f, 
    -0.03497638f, 0.42762500f, -0.18238907f, -0.08139882f, -0.03451667f, 0.08765603f, -0.09972432f, 0.28777516f, 
    -0.02017775f, 0.12821966f, 0.05988212f, 0.14730279f, -0.00764049f, -0.05590698f, -0.30492520f, -0.20205535f, 
    0.02077396f, 0.04982269f, 0.38426483f, -0.10147418f, -0.14604402f, 0.43696156f, -0.09184733f, -0.26868889f, 
    -0.17010731f, 0.04221223f, -0.07560442f, 0.03889424f, -0.19250630f, 0.24564634f, 0.06692403f, 0.23221664f, 
    -0.02908832f, 0.26850381f, -0.25707597f, 0.41238102f, -0.01171397f, 0.10413039f, -0.34993210f, -0.15665384f, 
    0.24602209f, 0.46277857f, -0.01514640f, -0.06399775f, -0.03680057f, -0.36179695f, 0.25239435f, 0.07291105f, 
    -0.12405028f, 0.60650641f, 0.04902915f, 0.05227792f, -0.15565413f, 0.21972369f, -0.31633422f, -0.25037578f, 
    -0.37829629f, -0.03417981f, -0.15657333f, -0.15030472f, -0.40424281f, -0.13827786f, 0.03542110f, 0.28011492f, 
    0.01005402f, 0.17268375f, -0.08121965f, -0.18633454f, 0.01651722f, -0.02109706f, 0.35826236f, 0.21833666f, 
    -0.13042212f, 0.45301113f, -0.37831286f, -0.12874238f, 0.11811870f, 0.44526067f, 0.02287205f, 0.11963779f, 
    -0.07604841f, 0.32219055f, 0.00007213f, -0.09058110f, 0.11401675f, 0.31951201f, 0.23560779f, 0.17364743f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.10429864f, 0.00439452f, 0.09767673f, -0.08735162f, 0.11827805f, -0.25977597f, 0.18323226f, 0.16113675f, 
    0.05364144f, -0.08544374f, 0.17237118f, 0.14756560f, -0.04085618f, 0.15214738f, 0.23110564f, 0.14151187f, 
    0.12680689f, 0.12021068f, 0.28503868f, -0.04730080f, 0.02477205f, 0.01906880f, -0.04175819f, -0.01298993f, 
    0.34531003f, 0.19751170f, -0.01693837f, -0.00588825f, 0.12204166f, 0.05354166f, 0.13273211f, 0.21330822f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.58822131f, -0.42299345f, -0.70716393f, -0.54193687f, -0.27846789f, 0.13378525f, -0.64014417f, -0.08992971f, 
    0.27502620f, -0.26311964f, -0.01740434f, 0.07848760f, -0.13817276f, -0.16827220f, 0.00457685f, 0.31452724f, 
    -0.36127466f, 0.14440994f, 0.36478966f, -0.08185290f, 0.32472044f, -0.35162842f, -0.09939532f, -0.02406082f, 
    -0.21034677f, 0.18245898f, 0.27279419f, 0.13929729f, 0.17261750f, 0.31351548f, -0.23556343f, -0.07507905f, 
    0.39820626f, 0.24979615f, -0.16771023f, -0.22329156f, 0.20580173f, 0.21337570f, -0.28303289f, -0.24408075f, 
    0.06564253f, -0.57440430f, -0.10394519f, 0.15700671f, -0.10763139f, 0.46055302f, -0.05302750f, 0.05753457f, 
    -0.70565253f, 0.04367526f, 0.10194181f, -0.34232789f, -0.20974286f, 0.20999531f, 0.35806990f, 0.08898059f, 
    0.01925690f, -0.27976966f, -0.12338536f, 0.24480152f, 0.16906413f, 0.10771453f, 0.28151333f, -0.29364333f, 
    -0.65789127f, 0.51452029f, 0.40878576f, -0.67012578f, -0.65170246f, -0.14262091f, -0.02872786f, -0.24856138f, 
    0.14843300f, 0.06813728f, -0.03343390f, 0.18329181f, -0.14109917f, -0.31410551f, -0.31219348f, -0.42457095f, 
    -0.36204749f, 0.22578901f, 0.24952784f, 0.16257490f, -0.06772605f, -0.21860540f, -0.10590022f, -0.16948615f, 
    0.16657995f, -0.55894983f, -0.19513677f, 0.30172893f, 0.29744914f, -0.50080693f, -0.60651195f, -0.69326580f, 
    0.04227607f, 0.11038528f, -0.42620182f, 0.09833566f, -0.55505210f, -0.70958203f, 0.15982492f, -0.02301602f, 
    0.18881689f, 0.09499923f, 0.02174635f, -0.38445073f, 0.09592415f, 0.14771105f, -0.85172826f, -0.02549072f, 
    -0.06325966f, 0.11704800f, 0.39042774f, 0.20208286f, 0.05757381f, -0.29634333f, -0.52467316f, -0.10515050f, 
    -0.45925876f, 0.15803494f, 0.07349983f, -0.39147598f, -1.04263532f, -0.20215786f, -0.15129665f, 0.17907979f, 
    -0.33520076f, -0.56557667f, -0.00156081f, 0.06685554f, -0.19754960f, 0.09969306f, -0.03399180f, 0.00297979f, 
    -0.03259404f, 0.19064274f, -0.03272939f, -0.27671233f, -0.03290220f, 0.45749915f, -0.00876914f, -0.03264864f, 
    0.13803260f, 0.12693825f, -0.01994244f, 0.40540019f, 0.18728127f, 0.31883857f, -0.50820738f, 0.06126065f, 
    -0.11205011f, -0.23142149f, -0.49571696f, 0.33270150f, -0.17435591f, -0.13799761f, -0.05845748f, 0.03325455f, 
    0.35906741f, -0.02542690f, -0.02326968f, 0.18887803f, -0.53957558f, -0.54925042f, -0.18443751f, -0.10236935f, 
    0.12744763f, -0.25358760f, 0.16208662f, 0.31060457f, -0.00799403f, 0.14225210f, 0.28752926f, -0.08302350f, 
    0.05830361f, 0.02144868f, -0.41579640f, -0.07931554f, 0.16278464f, -0.07611569f, 0.36406127f, -0.09091985f, 
    0.10062356f, -0.15696916f, -0.06997880f, 0.08404288f, -0.23079680f, 0.11046630f, 0.06072523f, 0.20651232f, 
    -0.41216713f, 0.04292373f, -0.87886083f, -0.98523003f, -0.21517451f, -0.01629414f, 0.13466540f, 0.11497828f, 
    -0.35838133f, 0.27255052f, -0.14326674f, -0.43087268f, -0.08014316f, -0.38932908f, 0.23183824f, -0.58952475f, 
    0.00098481f, 0.02788666f, -0.01282060f, 0.14368208f, -0.30962583f, -0.77972639f, 0.14013699f, 0.05653946f, 
    -0.03585706f, 0.29465228f, 0.12727310f, 0.24652891f, 0.14919172f, 0.34385780f, -0.08050206f, 0.24345814f, 
    0.28449327f, -0.02622490f, 0.00697781f, 0.23361397f, 0.01033362f, 0.19462831f, -0.38859102f, 0.27899531f, 
    0.16803651f, 0.06467970f, -0.08395526f, -0.41000926f, -0.05396064f, -0.04278455f, -0.23146529f, -0.24173334f, 
    0.25662592f, -0.53457546f, -0.42840934f, 0.16875216f, 0.24302459f, -0.05773829f, -0.17896914f, -0.16619818f, 
    -0.79570132f, 0.13839239f, -0.48530504f, -0.25568870f, -0.07507995f, 0.07730815f, 0.21724550f, 0.15135475f, 
    0.02885461f, 0.12177513f, 0.12023596f, 0.19170941f, -0.07864943f, -0.05381560f, 0.22552924f, -0.18713133f, 
    -0.25333321f, 0.39079383f, -0.06410894f, 0.35439035f, -0.16915299f, -0.03840815f, 0.18819778f, -0.23588644f, 
    -0.08897192f, 0.31491944f, -0.39475733f, -0.69681090f, -0.11854097f, 0.66295886f, -0.51973164f, -0.00700695f, 
    -0.28607938f, 0.13741449f, 0.23509067f, -0.13972092f, -0.15723774f, -0.03216139f, 0.23942700f, -0.39125863f, 
    -0.07550374f, -0.24943908f, 0.40652558f, -0.02210855f, -0.36651561f, -0.54482901f, -0.08871430f, -0.15246095f, 
    -0.11427565f, 0.30570459f, -0.09243189f, 0.13957609f, 0.00664366f, -0.51814020f, -0.18758777f, -0.10028045f, 
    0.15606275f, -0.15989049f, -0.35565796f, 0.23366283f, 0.09148286f, -0.16633408f, 0.09847685f, -0.14789332f, 
    0.26895940f, 0.20287886f, -0.67682999f, -0.00322809f, 0.38431183f, 0.20653234f, -1.00500417f, 0.11494300f, 
    -0.41104907f, -0.01170689f, 0.25574949f, 0.24063468f, 0.08670786f, -0.44488931f, 0.45731464f, 0.32122007f, 
    0.21524915f, -0.80309004f, -0.16149232f, 0.00444440f, -0.09400745f, -0.37894410f, -0.43177080f, -0.36081797f, 
    0.09043434f, -0.02197683f, 0.06279682f, -0.32899246f, -0.05961042f, -0.26773027f, 0.07118540f, 0.04581810f, 
    0.35266370f, 0.11193579f, 0.06829634f, -0.45032725f, -0.00481850f, -0.83806270f, -0.00593319f, 0.23539704f, 
    -0.37239343f, 0.44433814f, -0.45928052f, -0.08079507f, -0.74059147f, -0.70782095f, -0.03890132f, 0.05245958f, 
    -0.31599697f, 0.03408586f, 0.14498243f, 0.10405479f, -0.16140252f, 0.24569438f, 0.44820899f, 0.17803022f, 
    0.24277121f, -0.47570193f, 0.19308835f, -0.03376947f, 0.24213962f, -0.31968927f, -0.62318772f, 0.12543128f, 
    0.26088089f, 0.07362758f, 0.26313344f, -0.63618928f, 0.01483101f, -0.47028676f, -0.42415491f, -0.08034529f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.03467559f, 0.15002578f, -0.05395650f, -0.05112426f, 0.10566677f, -0.02411754f, -0.21400546f, -0.24394386f, 
    -0.22447036f, 0.15454355f, 0.00061852f, 0.12240770f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
