#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.41605273f, 0.81768167f, 0.88699412f, 0.40752727f, 0.21688750f, 0.18127498f, -0.67919761f, -0.72955608f, 
    0.00827175f, -1.24501264f, 0.60042012f, 0.22367594f, 0.95016021f, 0.83200645f, 0.73496741f, -0.63380432f, 
    -0.02663205f, -0.06557054f, 0.95727521f, -0.27028009f, 0.28623891f, 1.50612462f, 0.76894242f, 0.63717824f, 
    0.09673324f, -0.14280993f, -0.01373517f, -0.78734082f, -0.79392087f, -0.25932327f, -1.47806859f, 0.94207048f, 
    -0.62952101f, -0.13890949f, -0.02566807f, -0.42411116f, -0.16777100f, -0.65884721f, -0.89630610f, 0.37904191f, 
    -0.62870830f, 0.17906722f, -0.46576643f, -0.04515929f, 0.91812676f, 0.27322653f, -1.29849970f, -0.64962840f, 
    -0.83099490f, -0.46781656f, -0.63409030f, 0.17077106f, 0.45753324f, -0.11789209f, 1.35698855f, 0.68487978f, 
    0.78132212f, 0.29458046f, -0.79201603f, -0.28384769f, -0.52124047f, -0.32307282f, -0.35391709f, -1.30292821f, 
    -1.32669866f, -1.02226603f, 0.54571462f, 0.17532152f, -0.44238794f, 0.04297571f, -0.29702339f, -0.00815973f, 
    -1.02979398f, -1.10521972f, -1.00626755f, -0.34850726f, 0.85727507f, 1.43972278f, 0.52276707f, -0.02003677f, 
    0.39967689f, -1.28662539f, 0.81054688f, 1.39365137f, -0.13397804f, 0.08206661f, -0.27625224f, 0.07134197f, 
    0.14545403f, 0.16064659f, 0.28021738f, 0.19122225f, 0.16914836f, -0.08454156f, -1.59738898f, 0.66783881f, 
    -0.34069976f, 0.01073325f, -0.16500126f, 1.11016536f, 1.73146045f, -0.00900570f, -0.37499568f, -0.48610961f, 
    -0.30866036f, 0.50927109f, 0.29605618f, 0.15680256f, 0.02392914f, 0.48486447f, -0.25493363f, -1.08446598f, 
    -1.26517999f, -0.96482718f, -0.11937478f, -0.37336853f, 0.05878639f, 1.05324638f, 0.96913964f, 1.35347998f, 
    0.25950059f, 0.41954789f, 0.39070982f, 0.48775655f, 0.18554303f, 0.00463204f, -0.06727073f, -1.37187302f, 
    -0.49409693f, 0.04282010f, 0.25669074f, 0.90893334f, -0.45567212f, -0.27684191f, -0.83748209f, 0.17291149f, 
    0.50343496f, 0.44436646f, -0.60925215f, -0.45797691f, 1.09870791f, 0.07906015f, 0.16232871f, 0.47675577f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.18221091f, 0.45973426f, -0.04234020f, 0.50354099f, -0.45989954f, -0.14362919f, 0.86401796f, 0.34893677f, 
    0.33120197f, -0.28563344f, 0.43298414f, -0.01547297f, 0.90041357f, 0.59940481f, -0.18628773f, 0.61065358f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.12133963f, -0.48599619f, 0.18698135f, -0.06567690f, -0.12231489f, 0.16050778f, -0.23594379f, 0.19517896f, 
    0.02843157f, 0.29973716f, 0.25948036f, 0.14705825f, -0.27427727f, -0.19708224f, 0.19635932f, -0.07103664f, 
    0.13002017f, -0.21133396f, -0.06721288f, 0.20404294f, 0.08944034f, -0.13445301f, -0.04960202f, 0.04802886f, 
    0.08729023f, -0.09725466f, -0.15057288f, -0.40933165f, -0.14432071f, -0.02212622f, -0.16841505f, -0.03337730f, 
    -0.02176660f, -0.01102164f, -0.12349390f, -0.05614577f, 0.19251384f, 0.09924269f, -0.20789087f, -0.00450603f, 
    0.06467704f, 0.34957427f, 0.25593209f, 0.30216143f, -0.25160110f, 0.44285461f, 0.48891264f, -0.35976574f, 
    0.08272004f, -0.14902978f, 0.00156087f, 0.05147673f, 0.22417356f, 0.26539570f, -0.05915926f, -0.10565431f, 
    0.36040148f, 0.44421622f, 0.29652563f, 0.09003176f, 0.05629661f, 0.01722770f, 0.05327347f, -0.55603588f, 
    0.31139761f, -0.17346351f, -0.41189966f, -0.10699254f, 0.01291227f, -0.27219558f, -0.04364380f, -0.12135434f, 
    -0.06638954f, 0.24169475f, 0.15704054f, -0.14767018f, -0.02630210f, -0.24802427f, 0.08156329f, 0.33654678f, 
    0.10983422f, 0.13334614f, 0.02316596f, -0.24749339f, -0.13932972f, -0.33279625f, -0.03177799f, 0.27341554f, 
    -0.21145709f, 0.04582154f, -0.08256520f, -0.25542396f, -0.13168715f, 0.41711608f, -0.05447688f, -0.15379296f, 
    -0.07782327f, -0.05401612f, 0.00148404f, 0.44049916f, -0.68735224f, 0.26244852f, 0.25968495f, 0.02568947f, 
    -0.02505045f, -0.01708987f, -0.15238832f, 0.30221632f, 0.53277361f, 0.28635597f, 0.22066598f, 0.06015903f, 
    0.01723674f, -0.02086241f, 0.26574147f, -0.17324342f, 0.12073500f, -0.32264897f, -0.47692743f, 0.22645167f, 
    0.17135639f, 0.32482377f, -0.02081714f, -0.01894416f, 0.17272036f, -0.13573566f, 0.25095427f, 0.07989274f, 
    -0.13039634f, -0.34968895f, 0.01392231f, -0.17253722f, 0.01383537f, -0.19557124f, -0.15982687f, -0.20659363f, 
    -0.30103016f, -0.18522534f, 0.01048913f, 0.26339477f, 0.01322678f, 0.14431338f, 0.09468105f, -0.12731126f, 
    0.02781578f, -0.00185820f, 0.06523763f, -0.10320581f, 0.05021854f, 0.04452324f, -0.08032237f, 0.04457996f, 
    0.06123734f, -0.04490070f, 0.08689617f, 0.03221708f, 0.04869155f, -0.02137122f, 0.00481422f, -0.05910929f, 
    0.05743482f, -0.07454555f, -0.05831844f, 0.03502345f, 0.04466544f, -0.02999668f, 0.04193643f, -0.08238047f, 
    0.01032725f, 0.02801481f, 0.03401821f, -0.04356683f, 0.02003223f, -0.01369090f, -0.08284122f, -0.09321964f, 
    -0.05460324f, -0.04201266f, 0.03580941f, -0.06391860f, -0.04420646f, 0.08288177f, -0.05245570f, 0.00730922f, 
    -0.08943314f, 0.05576598f, -0.00857654f, -0.01598389f, 0.00215956f, 0.05033264f, -0.05880427f, -0.06129280f, 
    0.00233294f, -0.05633656f, -0.01695397f, -0.10321505f, 0.05058490f, 0.03435113f, 0.04826280f, -0.01358993f, 
    0.02421593f, -0.01333753f, 0.01241124f, 0.02964683f, -0.07129121f, -0.02960111f, -0.01582853f, -0.06276453f, 
    0.02610995f, -0.03607022f, -0.09051623f, -0.04820421f, 0.07437728f, -0.09632371f, 0.00405795f, 0.03877771f, 
    -0.05443873f, 0.00947708f, -0.08098847f, 0.06618881f, 0.07268208f, -0.08046783f, -0.04828430f, -0.06370873f, 
    0.01153260f, -0.09156149f, -0.03410805f, 0.10270101f, -0.09773743f, 0.08006666f, -0.07751952f, -0.05698555f, 
    0.01606073f, 0.00993457f, -0.03477103f, -0.06618341f, -0.09154537f, -0.02202919f, 0.04298065f, -0.04789501f, 
    -0.07272568f, 0.04532451f, -0.02178589f, -0.06706466f, 0.00195244f, 0.00420341f, -0.02604427f, 0.05995388f, 
    -0.04481701f, -0.05723871f, -0.00182004f, -0.04561270f, -0.04611712f, 0.04469480f, -0.06234992f, 0.01140891f, 
    -0.04613628f, -0.05852882f, -0.07640445f, -0.06305847f, -0.02351139f, 0.01949686f, 0.01702153f, -0.04868158f, 
    -0.07088380f, 0.03781291f, -0.00505760f, 0.06676927f, -0.06009923f, 0.03153107f, -0.05883117f, -0.01409217f, 
    0.01751205f, -0.02813865f, 0.02278191f, 0.04669117f, -0.01149329f, -0.02689642f, -0.04890529f, 0.02587800f, 
    -0.06481375f, 0.01256750f, 0.04464585f, -0.07252993f, -0.09265528f, -0.02058969f, -0.01389640f, 0.04095878f, 
    0.01369841f, -0.19242148f, -0.24651688f, -0.27886984f, 0.11690222f, 0.13825919f, -0.14559609f, 0.17812788f, 
    -0.31603783f, -0.01225627f, -0.13328898f, -0.20505829f, 0.14186764f, 0.24867690f, -0.22408758f, 0.04082730f, 
    0.09376267f, -0.09793437f, -0.41530320f, -0.01465313f, -0.24954037f, 0.16095924f, -0.10425834f, -0.06836087f, 
    0.34663507f, 0.01491030f, 0.25648212f, -0.42927024f, -0.04887027f, 0.26751631f, 0.04822489f, 0.02673372f, 
    0.22931817f, -0.09075533f, 0.07998248f, -0.33568889f, 0.31663015f, 0.42466030f, -0.11786067f, 0.05802803f, 
    -0.31254470f, 0.18279611f, 0.14909612f, 0.38763595f, 0.14692520f, 0.22541688f, 0.22976632f, 0.03570428f, 
    -0.08203867f, -0.29448566f, -0.20306386f, -0.20178625f, -0.04299756f, -0.02907175f, -0.67163658f, -0.06219404f, 
    0.26388115f, -0.01600744f, -0.11044828f, 0.28703102f, -0.32034191f, -0.06518269f, 0.03000105f, 0.33433646f, 
    -0.00126134f, 0.15518771f, -0.18004791f, 0.00018395f, 0.32914022f, 0.05264362f, 0.04529639f, 0.00059592f, 
    0.34967834f, 0.15262747f, -0.10032417f, 0.04835604f, 0.03936682f, 0.00726695f, 0.03542360f, -0.01249795f, 
    0.04621962f, -0.24432921f, 0.10498660f, -0.34100950f, -0.12347981f, -0.28866071f, -0.12145631f, -0.05833630f, 
    0.07870920f, 0.32547325f, 0.25668138f, -0.21753557f, 0.05522131f, -0.01991899f, 0.17034343f, -0.01555997f, 
    0.12043154f, -0.01849175f, 0.05356447f, -0.50527984f, 0.20024347f, -0.19522519f, 0.19644724f, -0.22326797f, 
    -0.03620484f, 0.16526023f, -0.10749350f, -0.12081844f, 0.27260771f, 0.13570678f, -0.21299958f, 0.05169793f, 
    0.07990416f, 0.05173962f, -0.45330796f, 0.05771645f, -0.20425434f, -0.84662855f, -0.15755929f, -0.00046176f, 
    -0.00174071f, 0.04437136f, 0.09559292f, -0.16696306f, 0.03281443f, 0.28248063f, 0.61003083f, 0.09274542f, 
    0.31445777f, 0.13466120f, 0.04694501f, -0.35047516f, -0.05664070f, 0.14622416f, -0.02055829f, -0.07865878f, 
    -0.38278347f, 0.06650844f, -0.11028273f, 0.06828792f, -0.08713984f, -0.02193307f, -0.02640829f, 0.29993755f, 
    -0.24888565f, -0.38219321f, 0.09234254f, -0.09527620f, -0.09711418f, -0.05830012f, 0.11327255f, 0.00215828f, 
    0.13076036f, 0.68421203f, 0.04845399f, -0.07502162f, -0.20187087f, 0.11978529f, 0.09398673f, 0.06343477f, 
    0.10373122f, -0.09002795f, -0.34219891f, 0.03882845f, 0.29429984f, -0.12913430f, 0.02636265f, 0.10096946f, 
    -0.08370727f, 0.09581792f, 0.03299110f, 0.04271329f, -0.31888545f, -0.42308816f, 0.16388389f, -0.07648909f, 
    0.07240622f, -0.13049369f, 0.01645645f, -0.03804223f, -0.41762617f, -0.29472718f, 0.02438616f, -0.51339418f, 
    0.02965094f, -0.30266085f, -0.00470279f, 0.02912643f, -0.00921246f, -0.01243053f, -0.67170906f, -0.33391222f, 
    0.00618014f, 0.28805298f, 0.02932210f, -0.03688370f, 0.13128200f, 0.02872065f, -0.02906428f, 0.20488581f, 
    0.36091095f, 0.10769312f, 0.20072299f, 0.13188183f, -0.28788045f, 0.01768223f, 0.16926335f, 0.20709774f, 
    -0.10277113f, 0.03857438f, -0.29579881f, -0.02200560f, -0.26719913f, 0.08722419f, -0.02349854f, 0.02604983f, 
    0.98916483f, 0.25834835f, 0.13628092f, -0.15173618f, -0.02216287f, -0.09194403f, -0.10417680f, 0.01573881f, 
    0.11315900f, 0.41946447f, 0.00180158f, -1.32384515f, -0.15527637f, 0.06733184f, 0.11430972f, 0.10312087f, 
    0.04649495f, -0.05868426f, -0.73291272f, 0.31273249f, -0.36709410f, 0.18868454f, 0.03331338f, 0.18787561f, 
    -0.19203269f, 0.08327976f, 0.06166361f, 0.19522500f, -0.15479425f, -0.01113607f, 0.09634054f, 0.16739663f, 
    0.09371029f, -0.22652225f, -0.05885560f, -0.09937456f, 0.01487184f, 0.16199562f, -0.10376424f, 0.24309185f, 
    0.19766013f, 0.28461966f, -0.00729548f, 0.11018169f, 0.09686640f, -0.72781700f, -0.22101521f, -0.04627743f, 
    0.11367000f, 0.25764659f, 0.00478433f, 0.12891260f, 0.04803456f, 0.08770146f, -0.08852994f, 0.00645861f, 
    0.08489620f, -0.05256335f, -0.17155135f, -0.17501646f, 0.22963677f, 0.00525746f, 0.09162160f, -0.12448046f, 
    0.06395470f, -0.06492109f, 0.14968340f, 0.07360916f, 0.17254001f, -0.03231461f, -0.04092193f, 0.21886079f, 
    -0.04005493f, -0.19733715f, -0.25953969f, -0.02834910f, -0.03801009f, 0.09133725f, 0.05259484f, 0.03284411f, 
    0.06445333f, 0.10180731f, -0.41043162f, 0.09013327f, 0.09021090f, -0.05368518f, 0.00355244f, 0.10809986f, 
    0.01422602f, 0.02883141f, 0.25683579f, -0.04627704f, 0.28970549f, -0.18858266f, -0.03174865f, -0.10349993f, 
    -0.16862497f, 0.00677673f, 0.14586131f, -0.48752508f, 0.11922735f, -0.02246299f, 0.08217777f, 0.08671763f, 
    -0.07475302f, -0.14917068f, 0.04677971f, 0.03933747f, -0.12107432f, 0.11995707f, 0.25997680f, -0.12529600f, 
    0.00947823f, -0.21979737f, 0.07567542f, -0.18265329f, -0.05090192f, 0.48898414f, 0.54154444f, 0.16809858f, 
    0.16268240f, 0.03721840f, 0.03340744f, -0.18611251f, -0.08592459f, -0.24003726f, 0.26321417f, 0.08974566f, 
    -0.03288399f, -0.10256982f, 0.17156942f, -0.10753472f, -0.14059722f, -0.05697295f, 0.01701883f, -0.45169115f, 
    -0.10671972f, 0.63840449f, 0.27862269f, 0.02115574f, -0.02171788f, -0.11901760f, -0.08805771f, 0.16534995f, 
    0.08550148f, -0.47728208f, 0.39020187f, -0.20971957f, 0.02525117f, 0.00611925f, -0.09874342f, 0.05917978f, 
    0.01162797f, 0.16838862f, 0.03034363f, -0.28895205f, -0.14960691f, -0.27892038f, -0.14390458f, 0.23041177f, 
    0.02868907f, -0.00891532f, -0.00293813f, -0.21421534f, -0.48489416f, -0.06995104f, 0.10530731f, 0.07528929f, 
    0.08729903f, 0.10566893f, 0.25116429f, -0.18332458f, 0.42005292f, -0.14712600f, 0.01198558f, -0.09544460f, 
    -0.34789637f, -0.02987449f, -0.04053901f, -0.16340922f, -0.27758941f, -0.02369729f, -0.75474840f, 0.23402262f, 
    -0.04332800f, -0.09244658f, -0.07481553f, 0.08974192f, 0.09083578f, -0.09372497f, 0.26688135f, 0.03681286f, 
    0.35830149f, -0.04954224f, -0.13168541f, 0.00015186f, -0.03488038f, 0.01525209f, 0.05480119f, -0.05672494f, 
    0.47783896f, 0.07488874f, 0.07281122f, 0.05072793f, 0.04000341f, 0.01352324f, 0.19917488f, -0.01066794f, 
    0.12784658f, 0.22831394f, 0.25029621f, 0.14218260f, -0.29317272f, -0.09700198f, 0.16294548f, 0.13983630f, 
    0.11042658f, 0.16727179f, 0.22993824f, 0.49444389f, -0.02718296f, -0.13448484f, 0.25229269f, 0.29790479f, 
    -0.16719775f, -0.09603756f, -0.05585106f, -0.06539524f, 0.19765507f, 0.22433609f, 0.18601386f, -0.11503083f, 
    -0.06563160f, 0.09604212f, -0.19491409f, 0.19023670f, -0.09807461f, 0.23526244f, -0.09004724f, 0.26107433f, 
    0.20345022f, -0.03783242f, -0.14683381f, -0.15670545f, -0.19595520f, -0.16062625f, 0.01233495f, 0.30743155f, 
    0.17409398f, 0.13965435f, -0.14516972f, -0.15828873f, -0.24263197f, -0.26673412f, -0.05350277f, 0.30933100f, 
    0.01738701f, -0.26425880f, 0.02937704f, -0.18652979f, 0.04528133f, -0.37428701f, -0.38010231f, -0.13749601f, 
    0.25779215f, 0.10196222f, -0.19642568f, 0.23223674f, -0.31243524f, -0.02896665f, -0.13349730f, 0.23582385f, 
    0.47891140f, -0.09715226f, 0.21647455f, 0.19338728f, 0.14869343f, 0.13981494f, 0.14088440f, -0.67889577f, 
    -0.37458444f, 0.15278170f, 0.31398436f, -0.04272398f, 0.10940427f, 0.12437119f, 0.19174150f, 0.20591727f, 
    -0.54999918f, -0.52153671f, -0.46185312f, 0.18063040f, 0.09700270f, 0.30641940f, 0.14511818f, -0.29664141f, 
    -0.22553909f, -0.42265859f, -0.57831812f, 0.09768129f, -0.17202671f, -0.06741819f, -0.38362959f, -0.09938966f, 
    0.09807576f, 0.07835823f, -0.25200003f, -0.37836200f, 0.31169358f, -0.01346407f, 0.32484716f, 0.17653729f, 
    0.11198965f, 0.02596033f, 0.26899862f, -0.28932005f, 0.07359382f, 0.13395469f, -0.27748063f, -0.29969895f, 
    -0.09858365f, -0.17361154f, -0.17969999f, -0.20931982f, 0.47672862f, 0.28882709f, 0.37690815f, -0.17023639f, 
    0.14922558f, 0.39269966f, 0.03221508f, 0.45797610f, 0.65310115f, 0.04386163f, 0.16644402f, 0.61549991f, 
    0.34538803f, 0.36982879f, 0.20032701f, 0.15350731f, 0.10406689f, 0.07756886f, 0.49317083f, 0.02930545f, 
    -0.60342377f, 0.09999990f, -0.13223183f, 0.06702715f, 0.02284306f, -0.42560223f, -0.01656455f, -0.09925074f, 
    0.26614806f, 0.34033915f, 0.17846839f, -0.07067264f, 0.16950718f, 0.02894012f, 0.08427163f, 0.02225527f, 
    -0.20703840f, 0.43221822f, -0.20199472f, 0.00304720f, 0.23887984f, 0.21946174f, -0.24267584f, 0.00625553f, 
    -0.01578236f, -0.58152294f, 0.29836383f, 0.03449449f, 0.04850068f, 0.15922591f, -0.01739576f, -0.04091357f, 
    -0.02065075f, 0.13299458f, -0.88216043f, -0.53520894f, -0.22213036f, 0.16282327f, 0.07690417f, 0.00267522f, 
    0.14074308f, 0.05079551f, -0.11353102f, -0.15976243f, 0.51146078f, -0.40883860f, -0.04973632f, -0.17651148f, 
    0.14971638f, -0.08203454f, -0.05881632f, -0.09152562f, 0.62621576f, 0.22849749f, 0.17495081f, 0.23720431f, 
    -0.02851624f, 0.02949557f, 0.32602865f, -0.02652990f, -0.02869315f, -0.19183598f, 0.29440519f, -0.17410871f, 
    0.16721667f, -0.26873034f, -0.15801378f, 0.15731613f, 0.22737993f, -0.33944336f, 0.50656909f, -0.52579820f, 
    0.12672772f, 0.03995030f, 0.00190243f, 0.31638128f, -0.11438033f, -0.04235328f, 0.35258132f, 0.20847845f, 
    0.45189765f, 0.04745104f, -0.08973970f, 0.15876018f, 0.05104387f, -0.02549939f, 0.02068953f, 0.06027960f, 
    -0.12417047f, 0.18775271f, -0.07399784f, 0.11130458f, 0.06449595f, -0.29957816f, -0.01456057f, -0.04579223f, 
    0.01049786f, 0.05013377f, -0.00125889f, 0.00122605f, 0.01305676f, -0.14688195f, -0.16525097f, -0.18573265f, 
    -0.08332139f, 0.25908142f, -0.14248897f, -0.45433843f, 0.00664321f, -0.05059675f, -0.23353183f, 0.12304469f, 
    -0.08812595f, -0.13780293f, -0.04390567f, 0.80961609f, -0.07037917f, 0.03184170f, 0.30426243f, -0.25535682f, 
    0.18594861f, -0.08835957f, 0.14429583f, -0.07414939f, -0.03044196f, -0.03588916f, -0.28170177f, -0.15509260f, 
    -0.02479215f, -0.12691957f, 0.07270636f, -0.09990827f, -0.27681518f, 0.33362409f, -0.21853304f, -0.19091827f, 
    -0.00112060f, -0.22010241f, 0.05269450f, 0.17730498f, 0.22272456f, -0.04483055f, 0.03864299f, 0.37348378f, 
    0.24916008f, 0.16143267f, -0.02535572f, -0.12592641f, -0.11385492f, 0.23535451f, 0.04532813f, -0.24514720f, 
    -0.39176765f, 0.02690478f, -0.06666010f, -0.15456615f, 0.03384709f, -0.13606900f, -0.02796328f, -0.06952330f, 
    -0.03179527f, 0.01298897f, -0.06932090f, 0.05217337f, 0.02926802f, -0.04827667f, -0.02420839f, 0.01346535f, 
    -0.04582916f, -0.04233948f, 0.01878057f, 0.04486392f, 0.06510529f, -0.07874507f, 0.07346074f, -0.08174689f, 
    0.01112569f, -0.05053126f, -0.07532346f, -0.00597415f, -0.03710507f, -0.05832997f, -0.04332325f, 0.03437188f, 
    -0.07266506f, -0.07521926f, 0.01913749f, 0.00161439f, -0.02424801f, 0.05247879f, 0.03563105f, -0.02650115f, 
    -0.05494766f, 0.07726423f, 0.03167227f, 0.04977396f, 0.04953491f, 0.00673783f, -0.08441471f, -0.00129792f, 
    0.02252842f, -0.07560982f, -0.03876580f, -0.01450277f, -0.05451525f, 0.03733486f, -0.02625773f, 0.00226421f, 
    -0.01021797f, -0.00509125f, -0.01115083f, -0.03731009f, -0.06312674f, 0.00786013f, -0.03424069f, 0.05205550f, 
    -0.03724228f, -0.02989180f, 0.01776664f, -0.07800331f, -0.04274838f, 0.03442602f, -0.00058570f, 0.06069076f, 
    -0.03905775f, 0.00210448f, -0.01807769f, -0.08394556f, 0.02438236f, -0.07757511f, 0.02357763f, -0.05365385f, 
    -0.08002017f, 0.06510619f, 0.06116990f, -0.04746030f, 0.00858052f, 0.02825887f, 0.04141353f, -0.04121100f, 
    -0.08562490f, 0.00116116f, 0.00060998f, 0.03537500f, -0.02210918f, -0.02423603f, -0.03365033f, -0.06598874f, 
    0.04023784f, 0.01105388f, -0.07204653f, 0.02191914f, 0.07696985f, 0.07274396f, -0.07596428f, -0.02165504f, 
    0.07152197f, -0.02878641f, 0.02297394f, 0.00584669f, 0.03441818f, 0.02705749f, -0.00481890f, -0.07262080f, 
    -0.03768081f, 0.06428388f, -0.06662135f, -0.07767631f, -0.04846761f, -0.06017530f, -0.05144142f, 0.02182015f, 
    -0.08100297f, -0.02198835f, -0.06675462f, 0.07207356f, 0.05374762f, -0.03350616f, -0.07102626f, -0.05863716f, 
    -0.07858386f, -0.00469706f, -0.08096298f, 0.04102356f, -0.07078669f, -0.04697208f, -0.01442416f, -0.05103370f, 
    -0.01401479f, -0.05013024f, 0.07017249f, -0.07000601f, -0.03326762f, -0.08545148f, 0.00524934f, -0.02422946f, 
    -0.07364263f, -0.07606015f, -0.07474601f, -0.08727229f, 0.05760991f, 0.02754490f, -0.01580861f, 0.07416453f, 
    -0.20881377f, -0.06287909f, -0.03349546f, 0.19161202f, -0.28898707f, 0.31230170f, 0.05233091f, -0.05545528f, 
    -0.28670833f, 0.03186128f, 0.08948781f, 0.04742640f, 0.00525572f, 0.05145902f, 0.30383426f, 0.09656545f, 
    0.09628569f, -0.11871599f, -0.22556648f, 0.14607885f, -0.12500612f, 0.14376369f, 0.12656936f, 0.19630274f, 
    -0.24211013f, 0.24724527f, -0.22777109f, -0.17269617f, 0.26227227f, 0.25351667f, -0.02329800f, -0.25276822f, 
    -0.12832652f, 0.06819825f, 0.00448374f, 0.40903109f, 0.28500640f, -0.22938719f, 0.02747195f, 0.14813606f, 
    -0.05648779f, -0.05030167f, -0.12544604f, -0.05827192f, 0.00380222f, 0.11101139f, -0.46914575f, 0.22056778f, 
    -0.09757703f, -0.11186969f, -0.37136307f, 0.04572259f, 0.04761398f, 0.12682931f, -0.10422271f, -0.20863873f, 
    -0.40151039f, 0.27691790f, -0.02844062f, 0.19162390f, -0.09545861f, -0.10982206f, 0.19580685f, -0.21117452f, 
    -0.21305065f, 0.15973534f, 0.09423590f, 0.03316296f, 0.26607418f, -0.29127818f, 0.21737698f, 0.22904550f, 
    0.10878685f, -0.09393176f, 0.25547022f, 0.02509064f, 0.00863571f, 0.00446634f, -0.00053235f, 0.13364674f, 
    -0.10508116f, 0.41357353f, 0.28481090f, 0.29029679f, 0.08764958f, -0.59744930f, 0.20087357f, 0.12882636f, 
    0.11499831f, -0.38858312f, 0.42492640f, 0.08201187f, -0.05551099f, 0.08369461f, 0.22939165f, 0.11581614f, 
    0.10861673f, 0.00030720f, -0.60341752f, -0.41872469f, -0.21020320f, 0.07392169f, 0.13306326f, -0.08292922f, 
    -0.23143619f, -0.16374913f, 0.14543775f, -0.03874028f, 0.46628764f, 0.21703863f, 0.14804332f, 0.25787500f, 
    0.26851663f, -0.02491922f, 0.33747587f, -0.11228523f, 0.19837560f, -0.44931656f, -0.30161452f, -0.14224935f, 
    0.08195994f, -0.10358527f, 0.21501705f, 0.08015388f, -0.22501528f, -0.28443801f, 0.12538560f, -0.20007409f, 
    0.22133483f, -0.16494678f, 0.23864223f, 0.04447490f, -0.08687501f, 0.03952134f, 0.23612435f, -0.25255951f, 
    -0.27730179f, -0.33053610f, 0.04802612f, 0.19270951f, 0.09552503f, 0.24351370f, -0.10952201f, -0.47968972f, 
    0.25561535f, 0.33967689f, 0.21475258f, 0.18542975f, -0.12201405f, 0.05261515f, 0.20848303f, 0.31065556f, 
    0.04981533f, 0.28872210f, 0.20420013f, -0.06733026f, 0.25378525f, -0.08478734f, -0.18000172f, 0.13026363f, 
    0.14071029f, 0.17195174f, -0.00776360f, 0.11906889f, -0.10088115f, -0.06892634f, 0.03953984f, -0.28059155f, 
    0.15678599f, -0.09496537f, -0.18620166f, -0.34282795f, -0.11239589f, 0.00303793f, 0.51881367f, -0.17278181f, 
    0.16345142f, 0.15895306f, -0.31969428f, -0.30574769f, -0.04039601f, 0.22429666f, -0.02189113f, 0.07076380f, 
    -0.01167305f, 0.07274849f, 0.30504769f, 0.17815441f, -0.16555910f, -0.49922758f, 0.04345203f, 0.25005949f, 
    -0.08611547f, 0.25106075f, 0.03243545f, 0.02281864f, 0.20192215f, -0.26892009f, -0.13741261f, 0.19050395f, 
    0.34485531f, -0.15109350f, -0.06295156f, 0.13186760f, 0.14899261f, -0.08022999f, 0.33411881f, 0.32849434f, 
    0.58407795f, -0.01353446f, 0.29024422f, 0.12808171f, 0.03485260f, 0.19909041f, 0.07573584f, -0.07578705f, 
    0.20529313f, 0.26204395f, -0.25687402f, 0.20337331f, -0.02032491f, -0.02264901f, 0.01547384f, -0.21845746f, 
    0.15603450f, -0.26102266f, 0.36079964f, -0.35378495f, -0.11397333f, 0.13182177f, -0.26423702f, -0.09406643f, 
    0.13316864f, -0.07902121f, 0.03055015f, -0.12839338f, -0.12608609f, 0.05412499f, -0.03137002f, -0.02642373f, 
    0.14142978f, -0.17052203f, 0.23600319f, -0.36331195f, -0.25099939f, 0.06733274f, -0.45599940f, -0.45663458f, 
    0.05511228f, -0.14888863f, 0.03843722f, 0.04510965f, -0.20665215f, -0.34489834f, -0.11063113f, -0.00630567f, 
    -0.19414242f, 0.08179402f, -0.13442753f, 0.01641438f, -0.01156334f, -0.06371246f, -0.08744810f, 0.12149106f, 
    0.23000477f, -0.20489492f, -0.05852007f, -0.04383647f, 0.03943443f, 0.16638666f, -0.30886269f, 0.32235131f, 
    -0.06602747f, 0.19607277f, 0.18492088f, -0.14512174f, 0.07538039f, -0.06883740f, 0.03016732f, 0.02426729f, 
    -0.19429964f, -0.09283368f, -0.10239871f, -0.15268698f, -0.12203439f, -0.03145239f, -0.13325174f, 0.07834626f, 
    -0.06148346f, -0.01587203f, -0.08810364f, -0.03089697f, -0.02329566f, -0.02523823f, -0.00171769f, 0.05076383f, 
    -0.03227108f, 0.03372787f, -0.04000675f, -0.08410718f, 0.00373828f, -0.03911036f, -0.05839339f, -0.08298000f, 
    0.02742876f, 0.02443307f, -0.03408353f, -0.00075255f, -0.03240516f, -0.05011568f, -0.07243572f, -0.05734225f, 
    0.01552537f, 0.03405715f, -0.09256126f, -0.05482965f, -0.06872849f, -0.08125836f, 0.06073573f, 0.01134296f, 
    -0.01480734f, 0.01320629f, 0.03810378f, -0.08355420f, -0.06669381f, 0.02239935f, -0.02094365f, -0.08680891f, 
    -0.05996589f, -0.03778213f, 0.06690426f, -0.03720764f, -0.04252891f, -0.02999085f, 0.02160769f, -0.04541496f, 
    0.02054957f, -0.04618068f, -0.04359104f, 0.00040727f, -0.02468387f, -0.07462221f, -0.00329595f, -0.03052716f, 
    -0.08165500f, 0.03180145f, -0.02396500f, -0.02780947f, 0.03632207f, 0.00309871f, 0.00132793f, -0.02448851f, 
    0.04822636f, -0.05897052f, 0.02319579f, 0.03218855f, -0.06951711f, -0.06996554f, 0.05804555f, 0.06852520f, 
    0.07234427f, -0.08075397f, 0.02227044f, -0.03615148f, 0.03131614f, 0.03881998f, 0.05513754f, -0.01154977f, 
    -0.08622864f, 0.00356409f, -0.07655940f, 0.01857760f, -0.04466715f, 0.00050738f, -0.01654254f, 0.01830027f, 
    -0.07691135f, 0.07697006f, -0.06339546f, 0.00236040f, -0.04096228f, 0.03433343f, 0.00537150f, -0.06290346f, 
    -0.03362610f, -0.01173376f, -0.02443668f, -0.00871660f, -0.06083748f, -0.06214025f, 0.06880702f, 0.01392623f, 
    0.02402060f, -0.02462278f, -0.04326341f, 0.03707456f, -0.07045862f, -0.06908515f, 0.01544609f, 0.04047172f, 
    0.05130598f, 0.01603417f, -0.08486181f, -0.02241400f, -0.00302016f, 0.05642381f, 0.01883906f, 0.07017952f, 
    -0.07805317f, -0.05844988f, 0.04360607f, 0.03504542f, 0.05170427f, 0.00045823f, -0.01995509f, 0.04478872f, 
    -0.03237236f, -0.05451899f, -0.01604181f, -0.00518345f, -0.00206087f, -0.02695375f, 0.01415286f, -0.05376430f, 
    0.02645479f, 0.06740882f, -0.07669329f, 0.03391343f, -0.06442636f, -0.08424354f, 0.03424067f, -0.07727617f, 
    -0.08275194f, -0.01947247f, -0.01612520f, 0.05229440f, 0.06403534f, -0.07270581f, -0.06276704f, -0.08029632f, 
    -0.02705922f, -0.01599236f, -0.08084746f, -0.07932352f, -0.03753364f, -0.03653669f, 0.05824734f, 0.05415814f, 
    -0.03547976f, -0.06919838f, -0.03424091f, -0.05211454f, 0.06859089f, -0.04173321f, -0.01631581f, 0.07314780f, 
    -0.04096508f, -0.01632594f, 0.01414156f, 0.04896758f, -0.01267722f, -0.06527326f, -0.02428963f, -0.01168738f, 
    -0.00306040f, -0.02575484f, -0.05017838f, -0.06354402f, 0.02642835f, -0.08655633f, -0.06121532f, -0.05766114f, 
    -0.03825222f, 0.03504090f, -0.01274094f, -0.03443957f, 0.03249517f, -0.00499207f, 0.05781932f, 0.07027694f, 
    -0.04583678f, 0.02362935f, -0.08954371f, -0.02032096f, 0.02009777f, 0.05501936f, -0.06456006f, -0.03721326f, 
    0.03487615f, -0.08186889f, -0.05902008f, -0.03538888f, -0.03631416f, 0.03070238f, 0.07035254f, -0.08099680f, 
    0.01141354f, 0.05736127f, -0.04729399f, 0.00795591f, -0.07672713f, 0.05715269f, 0.01102674f, -0.07376965f, 
    -0.06827492f, -0.02087431f, -0.00132925f, -0.04322877f, 0.04843736f, 0.00366941f, -0.08842234f, -0.08107653f, 
    0.04565850f, -0.04060177f, 0.00561949f, -0.02400318f, -0.05451378f, -0.02846442f, -0.01021220f, -0.07682692f, 
    0.07170228f, -0.03322035f, 0.05592455f, -0.01001174f, 0.02286626f, -0.06932109f, -0.07534857f, 0.05374312f, 
    0.04489208f, 0.00904021f, 0.04055979f, -0.08336637f, -0.06235984f, 0.01656891f, 0.04100509f, -0.03883019f, 
    0.06433244f, 0.00341162f, 0.04632076f, -0.01767395f, -0.01745927f, -0.01939536f, -0.08492541f, 0.04584553f, 
    -0.07823526f, 0.01220901f, -0.08491118f, 0.05893125f, 0.06265663f, 0.04003499f, 0.06552559f, 0.04512314f, 
    0.06959312f, -0.05919694f, 0.05896069f, 0.02961508f, 0.03308766f, -0.07484792f, 0.01366094f, -0.00644751f, 
    -0.02522203f, -0.06610459f, -0.00035250f, -0.03299547f, -0.00804216f, -0.00976922f, 0.05843240f, 0.05610342f, 
    0.05603165f, -0.07187802f, -0.06159374f, -0.03979677f, 0.02500599f, 0.04189545f, -0.02387226f, -0.07588126f, 
    -0.29849750f, 0.33439592f, -0.02800738f, -0.11880744f, -0.08640061f, 0.13049129f, 0.00942706f, 0.20331880f, 
    -0.13859123f, 0.22494625f, 0.00416752f, 0.12950601f, 0.13009414f, -0.10911553f, -0.38868678f, -0.08232514f, 
    -0.12032947f, -0.09985248f, 0.35062364f, -0.07704965f, -0.15612209f, -0.02230251f, 0.17055885f, 0.07972648f, 
    -0.03470778f, -0.06323642f, 0.09427340f, -0.22150768f, -0.41458812f, -0.23783542f, 0.12936367f, 0.06403578f, 
    -0.05789415f, 0.05368887f, 0.03401075f, -0.44497272f, -0.32388982f, -0.03420141f, -0.39256620f, -0.02897304f, 
    0.42918012f, 0.08956937f, -0.30313471f, 0.57047170f, 0.04391694f, 0.04334686f, -0.48355931f, 0.11407243f, 
    -0.19786684f, 0.09004981f, 0.01494581f, 0.15490675f, 0.15782897f, -0.16734952f, 0.13100696f, 0.12154663f, 
    -0.08851205f, -0.24379209f, -0.14351685f, 0.01408108f, -0.01032666f, 0.08470081f, 0.03849057f, 0.07917639f, 
    -0.02793956f, -0.17959021f, 0.01724139f, 0.14462575f, 0.04617982f, -0.02322447f, 0.00214062f, -0.20626853f, 
    -0.38081121f, 0.53933597f, -0.21434590f, 0.11268982f, 0.06617390f, 0.08186328f, -0.01712594f, 0.01525404f, 
    0.01280907f, -0.80164838f, -0.40321955f, 0.29888499f, 0.01244535f, -0.41356826f, -0.31187168f, -0.10086650f, 
    0.13404080f, -0.19563581f, 0.03894287f, 0.23186140f, 0.12437711f, 0.14346668f, 0.00830809f, 0.15072311f, 
    0.07783646f, 0.27699924f, 0.38090247f, 0.79404771f, 0.34024286f, -0.05054725f, 0.11490340f, 0.01242125f, 
    0.17589375f, -0.22290884f, -0.10059880f, 0.01477771f, 0.12250624f, -0.00052721f, -0.02785689f, 0.13421059f, 
    0.03282639f, 0.15359740f, -0.18369544f, 0.01274755f, 0.23136216f, 0.18259530f, 0.31368542f, -0.11103175f, 
    -0.18830194f, -0.08643612f, 0.04238942f, 0.05179194f, 0.10420027f, -0.00678798f, 0.54843271f, 0.18046643f, 
    -0.81878871f, -0.04008054f, 0.11404379f, -0.15640137f, 0.14551418f, -0.22796763f, -0.13629141f, -0.11963556f, 
    0.26471657f, -0.11797148f, 0.18724583f, -0.22345605f, 0.08268720f, 0.22560656f, 0.11531850f, 0.12308028f, 
    -0.01476792f, 0.05126509f, -0.09147436f, -0.03985668f, -0.01282108f, -0.07953272f, -0.02371222f, -0.04548619f, 
    -0.01217703f, 0.03371689f, -0.04873166f, 0.04698443f, -0.04807939f, 0.06483560f, -0.08247540f, -0.08866975f, 
    -0.02847404f, 0.02101335f, 0.04970252f, 0.04329104f, -0.04100620f, -0.03208365f, -0.02264572f, -0.03200062f, 
    0.00971216f, -0.05019449f, -0.04281796f, -0.07885390f, -0.02833896f, 0.03948401f, -0.03214958f, -0.03893976f, 
    0.03805494f, -0.01506858f, -0.02612760f, -0.02444222f, 0.02223164f, -0.03748302f, -0.00199086f, 0.01553021f, 
    0.07286651f, 0.04595427f, 0.01813227f, -0.03478854f, -0.07249091f, -0.01285368f, 0.01200622f, -0.01169913f, 
    -0.08793923f, -0.07278173f, -0.06272367f, -0.03608822f, -0.05150981f, -0.00065688f, -0.05146888f, 0.04222419f, 
    -0.00291861f, 0.00926219f, 0.06805639f, -0.07864552f, -0.00360126f, -0.00902563f, 0.02993012f, 0.05617255f, 
    -0.02860333f, 0.01616558f, 0.07482014f, -0.00306032f, 0.00839061f, -0.06013160f, -0.03210555f, -0.07453072f, 
    0.04144463f, 0.02421246f, 0.00938560f, -0.03237129f, 0.07200367f, -0.05990519f, 0.05619721f, 0.00262864f, 
    0.04885839f, -0.04093201f, 0.05023547f, -0.10190287f, 0.06828887f, 0.04292491f, -0.03556712f, -0.07220062f, 
    0.06409115f, -0.08205520f, -0.01198303f, -0.04533657f, -0.07435492f, -0.01798481f, 0.06491062f, 0.04320319f, 
    0.05758670f, 0.06443480f, 0.02203544f, -0.03407465f, -0.06874380f, -0.04432213f, 0.04418939f, -0.03385625f, 
    0.01076079f, -0.08753303f, -0.01012107f, -0.02697170f, -0.01656226f, -0.05753410f, -0.07765866f, -0.00979050f, 
    -0.01760845f, 0.05736640f, -0.02563371f, 0.03140929f, 0.03640987f, -0.09629499f, -0.03177093f, 0.04215656f, 
    0.02361835f, -0.05387520f, -0.00436276f, 0.02105792f, -0.01093186f, -0.05707083f, -0.05130546f, 0.03018744f, 
    -0.03539964f, 0.05808738f, 0.00494563f, 0.06008406f, 0.02925459f, -0.04663472f, 0.06463744f, -0.01931078f, 
    -0.01019453f, 0.04998351f, 0.04936831f, -0.08884431f, 0.04055116f, -0.06535563f, 0.00300954f, -0.06242800f, 
    0.13794462f, 0.53598356f, 0.18445137f, 0.13886468f, 0.24119623f, 0.12510498f, 0.18068828f, 0.15380640f, 
    0.09543481f, 0.71579474f, -0.23281021f, -0.08256444f, 0.02041323f, 0.11745080f, 0.20810673f, 0.09045389f, 
    0.09044099f, -0.03608418f, 0.03876544f, -0.69560111f, -0.20367391f, -0.03364138f, 0.10658610f, 0.13763474f, 
    -0.15809067f, -0.20490210f, 0.03141420f, 0.00722004f, 0.16775388f, -0.17961438f, -0.00626456f, 0.19252399f, 
    0.13607235f, -0.33017182f, -0.05360561f, 0.15395093f, 0.09961840f, -0.26322249f, 0.17137790f, 0.11205048f, 
    -0.02012563f, -0.03479909f, -0.01133845f, 0.06320308f, -0.31829661f, 0.44682476f, 0.00472693f, 0.09631833f, 
    -0.08437245f, -0.03488239f, -0.03371448f, 0.07870491f, -0.04799296f, -0.14068277f, 0.14380117f, 0.25732979f, 
    0.11559572f, -0.15175268f, 0.08477253f, -0.15487149f, 0.11726624f, 0.06145893f, -0.16310564f, -0.10164378f, 
    0.10803013f, 0.00554472f, -0.04375457f, -0.14980751f, -0.03588986f, 0.04279499f, -0.10630365f, 0.11596230f, 
    0.18559445f, -0.11868762f, -0.02490934f, 0.02207762f, 0.09211069f, 0.07967114f, 0.03284916f, -0.00580929f, 
    -0.08979990f, 0.92865688f, -0.15682282f, 0.06639890f, -0.07724550f, -0.20168208f, -0.10182363f, -0.08839747f, 
    -0.00170460f, 0.00293656f, -0.19131438f, -0.22808859f, 0.12151008f, -0.19680111f, 0.07027126f, 0.22516596f, 
    -0.11990318f, 0.00000532f, -0.06024457f, -0.41054431f, 0.54841781f, -0.17201772f, -0.09784622f, -0.16780238f, 
    -0.12899135f, -0.10962726f, -0.02396427f, -0.09298406f, -0.29247352f, -0.02395681f, -0.20620964f, 0.22300771f, 
    -0.04054470f, -0.12125229f, -0.03813329f, -0.01440009f, -0.01233797f, -0.37125260f, 0.21903397f, 0.49900547f, 
    -0.13814850f, -0.04016707f, -0.04540830f, -0.12236223f, 0.16000287f, -0.13827682f, 0.09194232f, -0.21212149f, 
    0.01729422f, 0.16144753f, -0.00823888f, 0.14337321f, -0.07026480f, -0.03301479f, 0.15280795f, -0.41856462f, 
    -0.12936938f, -0.05115931f, -0.20711954f, -0.13173836f, -0.19621237f, -0.00195993f, 0.15915035f, -0.06788477f, 
    -0.07870409f, 0.00391626f, -0.09624516f, 0.00937726f, -0.08075260f, -0.04523005f, -0.03948406f, 0.07270405f, 
    -0.08764225f, 0.04684756f, -0.02216064f, 0.00494326f, -0.02877354f, -0.03235473f, -0.05011882f, 0.03412218f, 
    0.02578537f, 0.04927061f, -0.07970335f, -0.01347818f, 0.00458991f, -0.03467469f, -0.07337188f, -0.03456501f, 
    -0.08908451f, 0.02757072f, -0.05966312f, 0.05709684f, 0.01779219f, -0.04701227f, 0.01869873f, -0.03386942f, 
    0.04145764f, -0.01920463f, -0.01902749f, -0.07325856f, 0.02963441f, 0.06883907f, -0.03980159f, -0.07046781f, 
    -0.01647477f, -0.02795880f, -0.05902673f, 0.01604651f, -0.00256498f, -0.08094477f, 0.06539944f, -0.07485887f, 
    -0.06788372f, -0.00944148f, -0.06055140f, -0.07716856f, 0.03227501f, -0.02901359f, 0.07162791f, -0.03074452f, 
    -0.05734163f, 0.06846164f, 0.04560411f, 0.01212546f, 0.07095923f, -0.04757265f, -0.06274007f, -0.02568975f, 
    -0.00757511f, -0.05450137f, 0.01215118f, -0.02137891f, -0.06754757f, 0.06289353f, -0.05674860f, 0.01150149f, 
    -0.09062023f, -0.03106301f, 0.00451012f, -0.03600894f, -0.06421614f, -0.05708293f, 0.06891757f, -0.00396380f, 
    -0.01219742f, -0.08481495f, 0.05719166f, -0.01058838f, -0.09146823f, 0.02237290f, -0.04632171f, -0.02441575f, 
    -0.00408447f, 0.02783852f, 0.04831676f, -0.01578483f, -0.00072374f, 0.01757308f, 0.05146864f, -0.01676513f, 
    -0.06486783f, 0.01657353f, 0.07576247f, 0.01756660f, -0.02600174f, 0.06428057f, 0.02598772f, 0.01807422f, 
    0.04040682f, 0.06026546f, -0.06979008f, -0.01520059f, 0.02923908f, -0.06390706f, -0.03458706f, 0.05586957f, 
    -0.03885166f, -0.06871460f, 0.01437880f, -0.07047084f, -0.00799340f, 0.05130999f, 0.06122497f, 0.02795132f, 
    -0.00602093f, 0.04008976f, 0.01645775f, 0.00929214f, -0.09229557f, -0.07680982f, -0.00588482f, -0.07962508f, 
    -0.00160318f, 0.03975829f, -0.06349623f, 0.00063004f, -0.05433024f, 0.02491438f, 0.06591141f, -0.00990542f, 
    0.02791336f, 0.04548385f, 0.05986556f, -0.07516390f, -0.03141028f, -0.06961267f, 0.03763550f, -0.00928662f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.19273978f, -0.05827054f, -0.05647024f, 0.20633572f, -0.07883935f, 0.40935346f, -0.14359629f, 0.00448566f, 
    0.33745259f, 0.00648905f, 0.01779869f, -0.01367460f, 0.04239403f, 0.01311217f, -0.22107166f, -0.04061227f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.23706250f, -0.20567423f, -0.11539365f, -0.23716794f, -0.60697204f, -0.16979465f, -0.48987177f, -0.04777646f, 
    0.10417583f, 0.27789664f, 0.10074583f, 0.11087982f, 0.65640610f, 0.10668687f, 0.13071787f, 0.09857067f, 
    -0.63001257f, 0.21795371f, 0.26993504f, 0.34039110f, -0.10684686f, 0.05175004f, -0.26810151f, -0.23988125f, 
    -0.45866489f, 0.48956484f, 0.04046889f, 0.22052154f, 0.11049777f, -0.06872611f, -0.16060431f, 0.08165425f, 
    -0.15474957f, 0.05644660f, -0.92050487f, 1.04597974f, 0.06011255f, -0.36531135f, -0.24586487f, -0.02795549f, 
    -0.18789251f, -0.66329867f, -0.15322357f, 0.23781092f, -0.05451125f, -0.05344162f, 0.35636353f, 0.15809307f, 
    0.62155223f, -0.00810653f, 0.30701795f, -0.13683349f, -0.33839116f, -0.31828174f, 0.24338090f, -0.10581347f, 
    0.50975841f, -0.43852285f, 0.01939082f, -0.08826460f, -0.59735501f, -0.05854846f, -0.34225142f, -0.17310022f, 
    0.08622427f, 0.15366456f, -0.14333048f, -0.17409937f, 0.19338256f, 0.15596206f, -0.36719662f, 0.05592320f, 
    0.18562146f, 0.23431641f, 0.22626865f, 0.06794250f, -0.79290193f, -0.16334122f, 0.04015671f, -0.02450121f, 
    -0.34038451f, -0.09389261f, 0.30708990f, -0.29328594f, -0.75429577f, 0.43268195f, -0.13873377f, 0.16998562f, 
    -0.54413277f, 0.26824763f, -0.05698052f, 0.07525259f, 0.13601391f, 0.09028072f, -0.42389420f, 0.14779954f, 
    -0.16343918f, 0.13321003f, -0.39662400f, -0.44898507f, -0.53944802f, 0.24420497f, -0.31264338f, -0.15679276f, 
    0.03074380f, -0.69267470f, -0.05473371f, -0.14867868f, 0.24052750f, -0.03477466f, 0.98122007f, 0.18860593f, 
    -0.43059665f, 0.13685769f, 0.41814399f, -0.12245202f, 0.81044203f, -0.65156657f, 0.48181599f, 0.23956470f, 
    0.28615725f, 0.15136181f, -0.11771016f, -0.07788932f, -0.44575313f, -0.07355964f, 0.47124347f, 0.12451860f, 
    0.77941912f, -0.22726025f, -0.35816863f, -0.29379925f, 0.84695870f, -0.20041375f, -0.19969301f, -0.08560636f, 
    -0.71071285f, 0.45809403f, 0.10696010f, -0.21723756f, -0.02597986f, -0.22277443f, -0.48075116f, -0.21688265f, 
    -0.17883649f, 0.09385864f, -0.13903330f, -0.36188501f, 0.56490999f, 0.21793146f, -0.34997493f, -0.09127419f, 
    0.09479102f, -0.55043173f, -0.20062701f, -0.08120929f, 0.07926489f, 0.18601480f, 0.12907398f, 0.04946533f, 
    0.57638264f, -0.19077922f, 0.87334788f, 0.40742582f, -0.21844824f, -0.52092308f, -0.77741957f, 0.06654570f, 
    0.04347878f, 0.03823451f, -0.01331570f, 0.22279523f, -0.13067453f, 0.12724754f, -1.13418853f, -0.07831299f, 
    0.38790870f, 0.26275927f, -0.99207217f, 0.04660340f, -0.60630810f, -0.34604686f, 1.06378591f, -0.05736548f, 
    0.35354581f, -0.49521735f, 0.13803361f, 0.23657498f, 0.00184023f, -0.07420491f, -0.37578011f, -0.13689639f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15206751f, 0.36633849f, -0.29912421f, 0.13303898f, 0.27992487f, -0.06153137f, -0.18392727f, -1.06776178f, 
    -0.82773232f, 0.27571210f, 0.30380967f, 0.52714491f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
