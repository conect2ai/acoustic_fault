#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.34422958f, -0.55026263f, -0.73402697f, -0.64843076f, -0.54463142f, -0.09448978f, -0.30074826f, 0.23289204f, 
    0.06680411f, -0.15643537f, -0.18203282f, -0.15746145f, -0.14832953f, 0.29839936f, -0.11127976f, 0.12512703f, 
    -0.15149438f, 0.17605312f, -0.05386287f, 0.05838301f, -0.23170872f, 0.29934865f, -0.30906746f, -0.10497066f, 
    -0.02606939f, 0.92993528f, 0.45366564f, -0.54953462f, 0.55923975f, 0.27235574f, 0.22716254f, 0.40397930f, 
    -0.47374049f, 0.13493878f, -0.01940811f, 0.03004214f, -0.44757047f, 0.02678911f, 0.08548981f, 0.09250555f, 
    0.25079194f, -0.02746429f, 0.13495024f, -0.09818405f, 0.09158202f, 0.42887977f, 0.19489895f, -0.04405411f, 
    0.06090173f, 0.30571017f, -0.12434892f, -0.41543934f, 0.19649497f, 0.59043396f, 0.40515772f, -0.79290164f, 
    0.14582574f, -0.43578991f, -0.56792849f, -0.18697895f, 0.14616515f, 0.17696919f, 0.33571139f, 0.15856288f, 
    -0.22055097f, -0.39085957f, 0.48076311f, 0.23377343f, -0.12993033f, -0.29262698f, -0.18530913f, -0.04387273f, 
    -0.02582193f, -0.23277116f, 0.31541815f, 0.81989241f, 0.21131964f, -0.08046465f, -0.26348260f, -0.91725343f, 
    -0.39012849f, 0.24543552f, 0.00389661f, 0.35091716f, -0.51163810f, 0.55215549f, 0.17768453f, -0.17989111f, 
    0.44598663f, 0.00313323f, 0.00421965f, -0.05092387f, 0.07941490f, -0.34462863f, -0.05146413f, 0.19189282f, 
    0.44615188f, -0.00705493f, 0.25952876f, 0.10823472f, 0.83325607f, 0.67660785f, 0.11710407f, 0.11710382f, 
    0.88160783f, 0.34460965f, 0.01817163f, 0.40928853f, 0.30114952f, 0.26595291f, -0.41322181f, 0.18341306f, 
    0.22339155f, 0.22479150f, 0.27400485f, 0.07107666f, 0.00290082f, 0.00646759f, -0.00613197f, 0.33668193f, 
    -0.00996953f, 0.00473727f, 0.05188967f, 0.07045023f, 0.10626470f, 0.25678641f, 0.11445946f, -0.10022662f, 
    -0.17626266f, 0.41031957f, -0.63035417f, -0.70379359f, -0.43435931f, 0.26532316f, -0.59245050f, 0.06409661f, 
    -0.03328792f, 0.40779167f, -0.22474048f, 0.11392780f, -0.02407641f, -0.02684651f, -0.11583695f, 0.00450102f, 
    0.06796376f, 0.03289590f, 0.20777217f, -0.14838377f, -0.15603416f, 0.11186256f, -0.54494500f, 0.76710171f, 
    -0.13821851f, -0.27800101f, 0.58365905f, 0.76876342f, 0.07620250f, -0.73488867f, 0.34491208f, -0.66271311f, 
    0.25689706f, 0.35031989f, -0.16107830f, 0.17358962f, 0.16692467f, -0.32368082f, -0.30299625f, -0.08465739f, 
    -0.38341969f, 0.36370963f, 0.25286806f, -0.25573760f, 0.02185172f, 0.21430221f, -0.23833182f, 0.73528779f, 
    0.29863387f, -0.69683808f, 0.33063728f, -0.35670906f, -0.64021128f, 0.12504235f, 0.33676094f, 0.17366318f, 
    0.34602326f, -0.10388249f, -0.13315432f, 0.48801672f, -0.24386276f, -0.33055875f, 0.06800238f, 0.31272253f, 
    0.16283341f, -0.51654047f, -0.16379696f, -0.44663990f, -0.22791934f, 0.46272069f, 0.40492925f, 0.14460653f, 
    0.21522292f, 0.30964407f, 0.19346027f, 0.62190241f, 0.83696657f, -0.34777454f, -0.23608087f, 0.20962313f, 
    -0.45093048f, 0.34499180f, 0.48112041f, 0.09803849f, 0.02683940f, 0.39577267f, -0.15113281f, 0.11165379f, 
    0.03683247f, 0.31986800f, 0.38680995f, 0.30509654f, 0.48789293f, -0.01402470f, 0.10370950f, -0.24830744f, 
    -0.44470173f, 0.69511902f, 0.41943559f, 0.12740785f, 0.10511705f, 0.16014598f, -0.11405406f, 0.22783889f, 
    -0.45965785f, 0.02866477f, 0.07432567f, -0.14603841f, -0.24526700f, -0.10481109f, -0.22813629f, 0.16281296f, 
    0.16989718f, 0.44364923f, -0.10325162f, 0.24675424f, 0.58704585f, -0.08051114f, -0.13675104f, -0.44438165f, 
    -0.40123183f, -0.36280072f, -0.26003417f, -0.32144499f, -0.62572962f, -0.37019345f, -0.21452175f, 0.25986704f, 
    -0.65708023f, -0.47137514f, -0.21100335f, -0.38626117f, 0.25701550f, -0.01776737f, -0.08331328f, 0.17835890f, 
    -0.40522593f, 0.16767506f, 0.49698296f, -0.01346093f, 0.02106561f, 0.45827714f, -0.11977152f, -0.21428229f, 
    0.07090095f, 0.41235900f, -0.02227619f, -0.40555963f, -0.58365220f, -0.62830901f, -0.57898450f, 0.10190024f, 
    -0.84231037f, 0.38550895f, 0.80692112f, -0.72617215f, 0.12669918f, 0.23042592f, 0.15846321f, 0.14622313f, 
    -0.02630604f, 0.24415573f, -0.15847766f, 0.04012320f, -0.32687122f, 0.15978827f, 0.10061326f, -0.09175997f, 
    -0.07573222f, -0.02172279f, 0.01514450f, 0.00895937f, 0.61272943f, 0.88200885f, 0.75082487f, -0.87299156f, 
    -0.87562263f, -0.35288379f, -0.38078377f, -0.00453638f, -0.34395421f, -0.16267820f, 0.21571568f, 0.21505764f, 
    -0.17725876f, 0.26589751f, 0.23917013f, 0.03691813f, 0.05062427f, -0.06954528f, 0.11557697f, -0.05859833f, 
    -0.04035498f, 0.26036724f, 0.03625434f, -0.03354626f, 0.07912710f, 0.00273366f, 0.16396344f, -0.00704414f, 
    0.52611816f, 0.50453204f, 0.31569096f, 0.29903051f, 0.59072638f, 0.41293442f, 0.49079123f, 0.20289032f, 
    -0.50853145f, -0.25060731f, -0.50708449f, 0.25450653f, 0.23374426f, -0.32857624f, -0.30154985f, -0.25106958f, 
    0.32423115f, -0.24759766f, -0.02623172f, -0.14161423f, 0.28108874f, -0.44851983f, -0.37653312f, -0.55305576f, 
    -0.77775300f, -0.55305189f, -0.20550986f, -0.21635613f, 0.75051188f, 0.28589568f, 0.13874014f, 0.58839977f, 
    -0.01848872f, -0.15430908f, -0.03114440f, -0.34277043f, -0.19280960f, -0.14337867f, 0.33681780f, 0.10935076f, 
    -0.03006908f, 0.07693888f, 0.02684837f, -0.00172925f, -0.20166515f, 0.02494127f, 0.32054821f, -0.67475235f, 
    -0.98943067f, 0.01546232f, 0.37451127f, -0.31610033f, 0.50669700f, -0.27788010f, 0.57095587f, 0.13844535f, 
    -0.61292845f, 0.05545753f, -0.41945219f, -0.19727418f, 0.03642264f, 0.03983793f, 0.08455408f, 0.11613608f, 
    -0.45850766f, -0.23757061f, 0.02620437f, -0.23730171f, 0.13571687f, 0.27638650f, 0.13287288f, 0.11718495f, 
    0.07945192f, -0.46536282f, -0.23224604f, 0.67097431f, 0.09658651f, -0.77671534f, -0.41560578f, 0.25148883f, 
    -0.21103469f, -0.09176610f, 0.08755002f, -0.38513187f, -0.02158786f, 0.27384517f, 0.40462306f, 0.14905581f, 
    -0.06060847f, 0.15960591f, -0.44244742f, 0.24566627f, -0.23675916f, 0.09925064f, -0.12503813f, -0.01455197f, 
    -0.36392620f, 0.50323373f, 0.53760970f, 0.28079867f, -0.31625441f, 0.66767824f, 0.46136382f, -0.49492928f, 
    -0.68256980f, 0.09401916f, 0.22519504f, -0.20164363f, -0.52918994f, -0.32764956f, -0.05781760f, -0.00639001f, 
    0.09778250f, 0.21304445f, 0.00749157f, -0.25890818f, 0.03018177f, 0.00228348f, 0.13408929f, -0.03080982f, 
    -0.41626015f, -0.37382668f, -0.23064643f, 0.14994562f, -0.43805352f, -0.65624911f, -0.49858013f, 0.11181155f, 
    -0.19287187f, 0.23211761f, -0.05307579f, 0.02762069f, 0.58314919f, 0.25553286f, -0.05254635f, 0.16970091f, 
    0.10661742f, -0.07079691f, 0.07638837f, 0.09978898f, 0.08797467f, 0.46538621f, -0.15182962f, 0.10579780f, 
    0.15089692f, -0.46123707f, 0.25320965f, 0.80981266f, 0.33414257f, -0.16819489f, 0.87008941f, 0.84426945f, 
    -0.56791753f, -0.06036200f, -0.06839518f, 0.37774503f, 0.31206504f, -0.14471185f, -0.06714050f, 0.00035949f, 
    -0.25088403f, 0.16880102f, -0.27271399f, 0.14425021f, 0.13812195f, -0.21772924f, 0.24594317f, 0.32418334f, 
    0.14656034f, 0.10085608f, 0.22318874f, 0.32809418f, -0.36427614f, 0.23711720f, 0.28310171f, -0.87936556f, 
    -0.28306666f, 0.47449407f, -0.61337554f, -0.13515869f, 0.29771137f, -0.38374677f, 0.16610083f, -0.19422129f, 
    0.24169284f, -0.17568119f, -0.20542863f, -0.10077696f, 0.07773713f, -0.28701666f, 0.31951517f, -0.66750401f, 
    -0.05348358f, 0.06655612f, 0.26180682f, 0.26862320f, 0.45156032f, 0.27213180f, -0.15169445f, -0.63768154f, 
    -0.31810367f, -0.20534655f, -0.12056012f, 0.04600609f, 0.29015115f, 0.29374984f, 0.14239180f, 0.16090749f, 
    0.29482684f, 0.18224822f, -0.07065133f, -0.43381730f, 0.31211802f, 0.15436213f, -0.11592696f, -0.48306203f, 
    0.15737365f, 0.03411632f, 0.02939528f, -0.35896042f, 0.57591075f, -0.37878311f, 0.75433362f, 0.03139443f, 
    -0.39733496f, 0.13316062f, -0.35631031f, 0.71631479f, 0.12291043f, 0.17608243f, 0.28010046f, 0.54045707f, 
    -0.39128932f, -0.37546530f, -0.17331627f, -0.42298305f, -0.38482201f, -0.06470843f, 0.24931766f, 0.13012597f, 
    -0.28667027f, 0.11720618f, -0.10524243f, -0.47842425f, 0.38228610f, 0.17769194f, -0.08178191f, -0.03783339f, 
    0.57520819f, -0.59385812f, -0.41943052f, -0.40612039f, -0.07690227f, -0.35599431f, 0.23189975f, 0.04291862f, 
    -0.44135049f, -0.49578884f, -0.01152494f, -0.27834538f, -0.05564225f, 0.20839775f, 0.32713977f, 0.01745239f, 
    0.51330066f, -0.07740331f, 0.03152812f, 0.55819094f, -0.09445067f, -0.02299200f, 0.44426909f, 0.23205878f, 
    0.22981732f, -0.94044983f, 0.31824729f, 0.89925176f, -0.16252084f, -0.59786838f, -0.10792425f, 0.68106955f, 
    -0.29375097f, -0.23905922f, 0.31595811f, 0.26461372f, 0.05972453f, 0.00195851f, 0.40633476f, -0.04876433f, 
    0.09022568f, 0.19301952f, 0.10316767f, -0.06622081f, 0.22041029f, 0.11863843f, -0.07551115f, 0.01968173f, 
    0.09726416f, -0.49850219f, -1.12619066f, -0.54518378f, -0.05061785f, -0.36632305f, 0.24621993f, 0.89012754f, 
    0.50217056f, 0.00133801f, 0.49687216f, 0.01164088f, -0.23859589f, -0.19672130f, 0.04189599f, 0.01838936f, 
    0.14097708f, 0.20966779f, -0.08491945f, -0.15040882f, 0.23646222f, -0.01340780f, 0.14977250f, 0.06280650f, 
    0.00943229f, 0.17067410f, 0.19890973f, -0.90370196f, -0.71130365f, -0.01990090f, 0.34882054f, -0.94384378f, 
    0.21675916f, 0.22938725f, -0.21283658f, -0.03996047f, 0.28728884f, 0.42812255f, 0.21632591f, -0.36943424f, 
    0.37104470f, 0.01273451f, 0.11416550f, -0.00895509f, -0.17841797f, -0.05370364f, 0.19799283f, -0.19833879f, 
    0.05786443f, -0.08376606f, 0.32895875f, -0.49782509f, 1.18101764f, 0.53809303f, -0.62756538f, 0.23742656f, 
    -0.94122845f, 0.55897784f, -0.08314462f, -0.66564512f, -0.13748702f, 0.16332668f, 0.20356995f, -0.07737819f, 
    0.18477479f, -0.08123927f, -0.02026290f, -0.35774240f, -0.09389392f, -0.13377963f, -0.07035657f, 0.11127076f, 
    0.13195619f, 0.09640425f, 0.13974549f, -0.11863041f, -0.81788957f, 0.15287334f, 0.78376162f, -0.63256937f, 
    0.66947055f, 0.56200653f, -0.36828610f, 0.39999259f, -0.66202790f, -0.62818706f, 0.19242257f, -0.12292773f, 
    0.13835604f, 0.03349536f, -0.08758930f, 0.05580152f, 0.22371157f, -0.08365810f, 0.18035445f, 0.19680308f, 
    0.40867046f, 0.20841824f, 0.24133016f, -0.06276892f, 0.34426817f, -0.11550695f, -0.29100621f, -0.10203007f, 
    0.07524881f, -0.39179662f, -0.34401989f, -0.31624052f, 0.44705707f, 0.52079082f, -0.59599197f, -0.42483845f, 
    -0.24725023f, -0.14663324f, -0.19951132f, 0.10762204f, -0.41826835f, -0.06433720f, -0.53523022f, 0.00251146f, 
    -0.16157465f, -0.19492470f, 0.14511096f, 0.07153116f, -0.50390828f, -0.24644999f, -0.32848492f, 0.13608749f, 
    -0.03429966f, 0.49336860f, -0.31423345f, -0.08806653f, 0.52191281f, -0.51841193f, -0.27478611f, 0.10385378f, 
    0.14458856f, -0.25812644f, 0.09727505f, -0.49954173f, 0.52793282f, -0.27309150f, -0.47631720f, 0.44722977f, 
    -0.37872216f, -0.36887366f, -0.12519984f, 0.12691653f, -0.21293136f, 0.35420975f, -0.26909542f, -0.11947054f, 
    -0.71646303f, 0.17016669f, 0.72213632f, 0.64713496f, 0.24962494f, 0.67880046f, 0.30788761f, 0.37184778f, 
    0.14477956f, -0.43824682f, -0.16316363f, -0.13841048f, 0.54230726f, -0.27415347f, -0.13741933f, -0.31142429f, 
    0.09113397f, -0.15436468f, -0.36415550f, 0.10167230f, -0.15738572f, -0.27880311f, -0.08790680f, -0.19357802f, 
    -0.02639998f, -0.48277903f, 0.52755845f, 0.55039060f, 0.62823170f, 0.44180509f, -0.29833069f, -0.47433615f, 
    -0.40970153f, -0.47828692f, 0.44732767f, 0.31451434f, -0.06483923f, 0.29082465f, 0.09115920f, -0.18540411f, 
    -0.23694035f, -0.12175053f, 0.23189956f, 0.41783187f, 0.12513576f, 0.40899569f, 0.15026942f, 0.18499722f, 
    -0.06991227f, 0.89391190f, -0.18023929f, -0.06591611f, 0.38801309f, -0.00546682f, 0.40891466f, 0.30483234f, 
    -0.27024299f, -0.54286194f, 0.18426153f, -0.35189316f, 0.04685882f, -0.37965032f, 0.23352937f, 0.30098236f, 
    -0.06422469f, -0.11401554f, -0.22024643f, 0.28599322f, -0.15110910f, 0.23872067f, -0.44262865f, 0.13588710f, 
    0.18998273f, -0.03956839f, 0.41801131f, -0.48294643f, -0.35257211f, 0.41510376f, -0.31253460f, 0.05415975f, 
    0.88047272f, 0.38285282f, -0.02216244f, -0.46312678f, -0.00455531f, -0.44100350f, -0.26541135f, -0.65412778f, 
    0.28555563f, -0.50872487f, -0.29607126f, -0.03510356f, 0.11554379f, 0.01767916f, -0.17186405f, -0.00018172f, 
    0.02643926f, -0.00339820f, -0.16492304f, -0.12328764f, -0.26428765f, 0.55930954f, 0.46053100f, 0.38559169f, 
    -0.84653938f, -0.09763689f, -0.61954588f, -0.57582146f, 0.37172997f, 0.28763127f, 0.54491025f, -0.44002095f, 
    -0.06991357f, -0.03501372f, -0.01349980f, 0.12508592f, -0.22169186f, -0.31718332f, 0.01514096f, 0.01537126f, 
    0.08152658f, 0.25749972f, 0.01070769f, -0.13656144f, 1.07313299f, 0.33212820f, -0.15408318f, 0.73723477f, 
    0.60158569f, 0.68488848f, 0.30246040f, -0.23630112f, -0.13185175f, -0.50483334f, -0.45236030f, -0.16261201f, 
    -0.33987606f, -0.08852150f, -0.20454653f, -0.11683774f, 0.01307099f, -0.02218460f, 0.24746799f, 0.08709712f, 
    0.07400673f, 0.30040091f, 0.02847322f, -0.42229673f, -0.00631337f, -0.35380569f, -0.88456619f, -0.60457975f, 
    -0.27033481f, -0.31194124f, 0.20703724f, 0.24184477f, -0.29479361f, 0.25551879f, 0.59008849f, -0.16636434f, 
    0.24838881f, -0.03802910f, 0.06533388f, -0.01061931f, -0.29841056f, 0.05164789f, 0.41387403f, 0.06239047f, 
    -0.18343592f, -0.26446074f, 0.01521426f, -0.10258232f, -0.28408840f, -0.09740886f, -0.40603927f, 0.33102110f, 
    0.73869973f, 0.54737967f, -0.82674360f, 0.32855400f, 0.76891649f, -0.03276896f, 0.47665361f, 0.18386270f, 
    0.24475674f, 0.21988906f, 0.18532655f, -0.26728898f, -0.18704933f, 0.10266186f, -0.11063077f, -0.00179031f, 
    -0.23239921f, 0.05056690f, 0.00112660f, 0.29314119f, -0.28155872f, 0.01122845f, -0.21864754f, 0.39373878f, 
    0.49914312f, 0.84016514f, 0.64770758f, 0.53275555f, 0.01365760f, 0.33151066f, -0.35344103f, -0.63989866f, 
    -0.23879720f, 0.34440896f, 0.31683081f, 0.00242327f, -0.02805760f, 0.08644271f, 0.04998901f, 0.14354351f, 
    0.27085993f, -0.13154574f, 0.31422457f, -0.00787506f, -0.03782171f, 0.30894870f, -0.00120845f, 0.10663234f, 
    0.43238354f, 0.27362964f, -0.21651635f, 0.07312896f, -0.42939362f, -0.46295872f, -0.49063557f, 0.17804313f, 
    -0.35199201f, -0.36610955f, -0.07543252f, -0.24562265f, -0.18495007f, -0.36003023f, -0.54019719f, 0.12807038f, 
    0.45029652f, -0.26135382f, -0.29144040f, -0.07707479f, -0.33895350f, 0.11810943f, -0.11956027f, -0.31783459f, 
    -0.37687054f, 0.38492203f, 0.54772961f, 0.53698617f, 0.67979455f, 0.03628202f, -0.34985435f, -0.01480770f, 
    0.33486062f, 0.24383357f, 0.15494585f, 0.36637691f, -0.30314422f, -0.40033984f, -0.13825041f, -0.38320044f, 
    -0.02175945f, -0.21900004f, 0.41317570f, -0.23612250f, -0.27655727f, 0.22131996f, 0.22881058f, -0.27691716f, 
    -0.07724851f, 0.02588753f, -0.25744462f, 0.04542299f, -0.46619421f, 0.13498709f, -0.31172565f, -0.55935472f, 
    -0.02462510f, -0.25901502f, -0.46864796f, -0.68778706f, -0.20492432f, 0.47595549f, 0.01698582f, 0.29400283f, 
    -0.02811489f, -0.10100020f, -0.03907248f, -0.25855479f, -0.20467301f, 0.24450786f, 0.25299335f, -0.32775712f, 
    0.47632486f, 0.08827545f, 0.04072785f, -0.07430267f, -1.38893497f, -0.50994760f, 0.24097474f, -0.12348764f, 
    0.00616011f, 0.84477812f, -0.26776093f, 0.44066498f, 0.10554772f, -0.26778746f, 0.25657880f, -0.25945666f, 
    0.55707532f, 0.24292991f, -0.12268808f, -0.08972523f, -0.31623363f, 0.06860681f, 0.10059153f, 0.02482283f, 
    -0.00067344f, 0.00838260f, 0.27484775f, -0.05233272f, 0.49301189f, 0.69251186f, 0.53148746f, 0.71907067f, 
    0.72891337f, 0.13791651f, 0.41321942f, 0.51043135f, -0.20210230f, 0.25450650f, -0.28090724f, -0.20722677f, 
    0.31868476f, 0.14206807f, -0.17642651f, 0.26338810f, -0.17768480f, -0.01917473f, -0.12815779f, 0.20280704f, 
    0.13444999f, -0.19337136f, -0.02848674f, 0.24065757f, 0.33969468f, -0.37772086f, -0.63399148f, 0.52121425f, 
    0.67336309f, -0.20514986f, -0.26680490f, 0.19495854f, 0.68599087f, -0.47881833f, -0.40208957f, 0.30762568f, 
    -0.22084644f, 0.22992450f, 0.18085966f, -0.21172726f, -0.06215499f, 0.37009814f, -0.07834409f, -0.19552600f, 
    0.18226539f, -0.41142878f, 0.01086113f, -0.05126408f, 0.15951273f, -0.11772292f, -0.06486453f, -0.20871694f, 
    -0.38991013f, 0.03392421f, -0.28310996f, -0.28188172f, -0.34409797f, -0.60607892f, -0.09965856f, -0.34993973f, 
    0.33288226f, 0.45592853f, 0.42480719f, 0.25043690f, -0.04190318f, -0.04946702f, 0.11339092f, 0.21485133f, 
    0.29745778f, 0.45128471f, 0.03656071f, 0.27245957f, 0.07675915f, 0.20218454f, -0.10281070f, 0.96149474f, 
    0.23567286f, 0.46802381f, 0.21761687f, 0.69721508f, -0.30189735f, 0.23327543f, -0.32928333f, 0.38372180f, 
    0.11090348f, -0.01008679f, 0.62666917f, -0.12059372f, 0.18593407f, -0.31096137f, -0.13121670f, -0.01333189f, 
    -0.23507392f, -0.07225248f, -0.32677457f, 0.21353669f, 0.00671158f, 0.17080677f, 0.14462946f, -0.01742322f, 
    -0.41739333f, -0.37012413f, -0.29680136f, 0.92733431f, 0.50485748f, 0.36793333f, 0.57759047f, 0.54203302f, 
    0.05104812f, -0.38903686f, 0.31202409f, -0.11233293f, -0.02341020f, 0.02433801f, 0.37261522f, -0.05616590f, 
    0.08307229f, 0.33939770f, -0.45335388f, 0.21114686f, 0.20816214f, 0.20158119f, -0.49964979f, 0.25130188f, 
    0.06772646f, 0.92499405f, 0.20232432f, -0.82471853f, -0.93935066f, 0.03487552f, 0.63921696f, -0.38513556f, 
    0.29381338f, 0.18770449f, 0.21085228f, -0.20307638f, 0.22675154f, -0.15649360f, 0.21832655f, 0.18428291f, 
    -0.05127405f, -0.16657509f, -0.22329845f, 0.11299930f, 0.24307875f, 0.17200352f, 0.20848210f, -0.18927602f, 
    -0.11976124f, 0.17933571f, -0.78862274f, -0.15487494f, 0.55673051f, 0.63268220f, 0.37909767f, 0.64162177f, 
    -0.01722210f, -0.25630522f, 0.38485032f, -0.50624943f, -0.08482455f, -0.27415898f, 0.15023851f, -0.28521028f, 
    -0.38440883f, -0.30214760f, 0.17710528f, 0.25206348f, -0.15192550f, -0.17686516f, -0.17462340f, 0.10787493f, 
    -0.34132734f, -0.11723150f, -0.07574709f, -0.53936625f, -0.25341892f, -0.39593324f, 0.22573400f, -0.63904715f, 
    -0.03487528f, 0.73154217f, 0.16172810f, 0.55894905f, -0.16107616f, -0.20321201f, -0.28966773f, 0.25220299f, 
    -0.03797169f, -0.29512629f, 0.14641190f, -0.16098486f, -0.07545795f, 0.12010521f, -0.33531836f, 0.21996088f, 
    -0.05418280f, -0.15067506f, 0.22098327f, 0.49823713f, -0.93944573f, 0.74404961f, 0.67341542f, -0.56208861f, 
    -0.20705350f, 0.64283597f, -0.48255354f, -0.53712857f, -0.55368215f, -0.43969584f, -0.07693519f, 0.07725213f, 
    0.28020620f, 0.56333989f, 0.11910862f, -0.15811861f, 0.01581407f, 0.17778723f, 0.07095532f, -0.06968846f, 
    -0.10771306f, -0.22542413f, -0.11075341f, 0.18860461f, 0.00328460f, 0.75301582f, 0.38062590f, -0.61846322f, 
    0.21668708f, -0.35014731f, 0.68237787f, 0.34074566f, 0.53349018f, 0.84199053f, 0.35587260f, -0.43274164f, 
    -0.02321167f, -0.39705238f, -0.07061289f, 0.11083363f, -0.05857295f, -0.37585574f, -0.03496557f, 0.24177967f, 
    0.28263903f, 0.12933370f, -0.06665543f, -0.21041231f, -0.03923213f, -0.07274991f, 0.77300680f, 0.63156760f, 
    0.60826969f, -0.02940615f, -0.20163578f, 0.24642973f, -0.27756757f, 0.01882141f, -0.10954143f, 0.50325310f, 
    0.31689560f, 0.47309402f, -0.25196868f, -0.22314967f, 0.23629235f, 0.21996239f, 0.14516293f, 0.10137642f, 
    0.21310879f, 0.38827023f, -0.31318021f, -0.36509740f, -0.29512250f, -0.11806864f, 0.53800189f, -0.30986607f, 
    -0.07138539f, -0.31436998f, -0.61378789f, -0.02150041f, 0.39024198f, -0.05409861f, -0.71173239f, -0.07963242f, 
    0.06945777f, 0.13520989f, -0.21293481f, -0.30212593f, -0.11852553f, -0.14156854f, -0.25490603f, 0.49082705f, 
    0.15480343f, -0.51565534f, -0.29646692f, -0.02917166f, 0.06091384f, 0.44095761f, 0.58069855f, -0.09187388f, 
    0.58137435f, 0.38902232f, 0.52212113f, -0.10183261f, 0.44085640f, -0.56898814f, -0.71116465f, -0.39445612f, 
    -0.29292268f, -0.48972449f, 0.28645286f, 0.31458759f, -0.05835979f, 0.27606851f, -0.28482926f, 0.14974423f, 
    -0.35790622f, 0.17451058f, -0.19321777f, 0.17696603f, -0.32411125f, 0.23198411f, 0.39364636f, 0.09073543f, 
    0.10590488f, 0.49316016f, 0.16352624f, 0.85662729f, 0.87251675f, -0.06423089f, -0.05534577f, -0.03390369f, 
    -0.26690561f, -0.49617299f, 0.09803545f, -0.15212344f, -0.10017543f, -0.22873636f, 0.20703019f, 0.18885171f, 
    -0.01672274f, -0.28339690f, -0.14582235f, 0.11936690f, -0.35187721f, 0.14583066f, 0.24682307f, 0.01173063f, 
    0.25651538f, 0.38611123f, -0.24769253f, 0.41626650f, -0.59901190f, -0.76196182f, -0.58369422f, 0.86108440f, 
    0.54714787f, -0.35202080f, 0.61071455f, 0.25860956f, 0.10616451f, -0.14072813f, 0.00969475f, 0.12954466f, 
    -0.35299799f, 0.30079341f, -0.06593644f, -0.14952540f, -0.06718174f, -0.08677907f, -0.16016588f, -0.45120129f, 
    -0.02349417f, -0.13825147f, 0.01398921f, 0.22488315f, -0.14046979f, 0.19712682f, 0.29849216f, 0.46141639f, 
    -0.76305938f, -0.45377961f, -0.29318964f, -0.45743203f, -0.23011066f, 0.39234954f, -0.15781483f, 0.25395116f, 
    0.22250982f, 0.29220065f, 0.34359384f, 0.24541116f, -0.29445630f, 0.29817078f, -0.12496316f, -0.24036507f, 
    -0.16787592f, -0.23993875f, 0.42859954f, 0.31067973f, -1.01929224f, 0.03831335f, 1.09002495f, -0.35478938f, 
    0.37597039f, 0.49382278f, 0.05392162f, 0.23125458f, 0.25036371f, 0.05373628f, -0.37169871f, -0.12403988f, 
    -0.13741189f, 0.07262461f, -0.19130917f, 0.25611049f, -0.27066064f, 0.06576498f, -0.41506317f, -0.03067453f, 
    -0.26289207f, 0.10430327f, -0.08605957f, -0.13315120f, 0.08812233f, -1.47647178f, 0.91005909f, 0.10444897f, 
    -0.45317677f, -0.54882300f, 0.23772724f, 0.81674701f, -0.35644063f, 0.46814331f, 0.43878430f, -0.43662789f, 
    0.05934884f, 0.20074205f, -0.08562564f, 0.42189416f, 0.01700866f, -0.20500541f, 0.02539190f, 0.14891095f, 
    -0.15699835f, 0.08114729f, -0.02860816f, 0.23679624f, 0.35355002f, 0.35508096f, 0.98530269f, -0.29016694f, 
    0.16663259f, 0.79348314f, 0.42852154f, 0.57650357f, -0.67744088f, 0.20486878f, 0.27273184f, 0.14439678f, 
    0.26973620f, 0.13869816f, -0.00169171f, -0.12718427f, -0.00426260f, 0.36331299f, 0.26243865f, 0.24221973f, 
    -0.00801358f, -0.02218512f, -0.18740229f, -0.10087558f, 0.12357594f, -0.09636784f, 0.13223913f, 0.24585804f, 
    0.36409584f, 0.51096243f, 0.36187375f, 0.48438868f, 0.65746784f, -0.14847112f, -0.84417629f, -0.18905005f, 
    -0.02507762f, 0.13765347f, 0.12016953f, -0.14912809f, -0.12319744f, -0.51237845f, 0.12090303f, -0.15547234f, 
    -0.13697670f, 0.11834440f, -0.18044524f, 0.41560155f, -0.15140255f, 0.21770172f, -0.01823182f, 0.23236300f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.00723778f, 0.14146893f, 0.12649065f, 0.24094626f, 0.27530751f, 0.01309645f, 0.20605978f, -0.03587982f, 
    0.11543359f, -0.07865189f, 0.28104299f, 0.14996959f, 0.15968254f, 0.03552199f, 0.22753379f, 0.02200425f, 
    0.08544724f, 0.07080147f, 0.02545941f, 0.11888231f, 0.18193693f, 0.19194907f, -0.04309442f, 0.20682439f, 
    0.00871485f, 0.14770170f, 0.18881008f, 0.23453218f, 0.05836485f, 0.19937387f, 0.09950326f, 0.16732199f, 
    0.01157513f, 0.15998890f, -0.05969366f, 0.17875905f, -0.00016775f, -0.02690081f, -0.00400398f, 0.05337655f, 
    0.06075942f, 0.27978760f, 0.07299650f, 0.25442225f, 0.09132174f, 0.12176558f, 0.25733796f, 0.12945627f, 
    0.27284801f, 0.22772552f, 0.09014412f, -0.04745057f, 0.17181498f, 0.27660879f, -0.03129798f, 0.15889901f, 
    0.06247848f, 0.04414813f, 0.01564178f, 0.01870246f, 0.06171496f, 0.01658453f, 0.02228385f, 0.07611646f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.06097654f, -0.10703197f, -0.13068429f, -0.20566237f, -0.07864861f, -0.07410689f, 0.10241472f, -0.02907415f, 
    0.05299971f, -0.03230283f, -0.06460221f, -0.00566293f, 0.11903086f, 0.03159346f, 0.01158382f, 0.21113129f, 
    -0.20762342f, 0.01448273f, 0.04367325f, 0.06855609f, 0.01436812f, 0.03069276f, 0.03223729f, -0.03081665f, 
    0.06889194f, -0.04475773f, -0.13374503f, 0.13249780f, -0.11187401f, 0.02318849f, 0.08012807f, -0.09374432f, 
    -0.04538626f, 0.06254029f, -0.20410208f, -0.00086028f, -0.22891860f, 0.01909522f, -0.10446808f, 0.03525031f, 
    -0.09425350f, -0.02283500f, -0.09536587f, -0.10078193f, 0.04869866f, 0.03930003f, -0.09618737f, 0.08906699f, 
    0.17123356f, -0.16232236f, 0.04640714f, -0.10616443f, -0.11219994f, -0.00497330f, -0.04030137f, 0.07035454f, 
    0.05922337f, -0.00150274f, -0.00358086f, -0.00147492f, 0.06501869f, 0.05428124f, 0.16907160f, -0.08027433f, 
    0.01822026f, -0.04474192f, 0.04295715f, 0.08731082f, 0.06199412f, -0.09900251f, -0.02045540f, -0.05561708f, 
    -0.04877225f, 0.02966419f, 0.23194578f, -0.21960713f, -0.07210685f, -0.00927506f, 0.10116218f, -0.13954838f, 
    0.10890355f, -0.07796364f, -0.01454201f, 0.01155460f, -0.10059562f, 0.03153842f, 0.02825636f, 0.09768754f, 
    -0.06398948f, -0.00315457f, -0.03081664f, 0.00831820f, 0.00876947f, 0.17546159f, 0.16642798f, -0.04320066f, 
    0.19562152f, 0.06187234f, 0.05885901f, -0.00464767f, -0.07643068f, 0.08304548f, -0.03619327f, -0.08929802f, 
    0.00881116f, -0.09813409f, -0.01932737f, -0.04762767f, 0.15412974f, -0.03651804f, -0.00427195f, -0.10728606f, 
    -0.14824104f, 0.00118051f, 0.00471181f, 0.12880699f, 0.03392289f, -0.02937829f, 0.03619324f, 0.14515798f, 
    -0.25994557f, -0.22000231f, 0.00737338f, -0.05850729f, 0.01772398f, -0.00439396f, 0.09751872f, 0.07360755f, 
    0.07618290f, -0.05357264f, 0.03859361f, -0.08109243f, -0.48136875f, 0.06299600f, -0.12360756f, -0.05373355f, 
    -0.00443383f, 0.01952866f, -0.02858970f, -0.00414937f, 0.07156349f, -0.06159060f, -0.01648589f, 0.06412987f, 
    -0.35870603f, 0.25152871f, 0.09801383f, -0.15348564f, 0.00961176f, 0.05333687f, -0.04515068f, -0.04448516f, 
    -0.12298620f, -0.08455133f, 0.03645764f, 0.01475810f, -0.02666100f, 0.05054743f, 0.10501444f, 0.10242695f, 
    -0.16162471f, 0.08891237f, -0.00967580f, -0.02935855f, -0.10465810f, -0.00202672f, -0.00535287f, 0.04504858f, 
    0.03323701f, 0.17861226f, 0.04790344f, -0.42576280f, 0.09579344f, -0.00400043f, 0.07635405f, 0.04092230f, 
    0.00859059f, -0.04526997f, -0.06091716f, 0.07148697f, -0.03340629f, -0.04677818f, -0.09703869f, 0.10503869f, 
    -0.00352021f, 0.03946448f, -0.08736635f, 0.05451068f, -0.04299323f, -0.07538835f, 0.05019683f, -0.17705305f, 
    0.12785488f, -0.00350880f, -0.23541366f, 0.20321138f, -0.05735601f, -0.00393064f, -0.11118102f, -0.01993793f, 
    -0.01573829f, -0.17245355f, -0.04395233f, 0.02466077f, 0.07906176f, -0.12403113f, 0.20667507f, -0.13736536f, 
    -0.07624996f, 0.01019192f, 0.06775459f, 0.00188121f, 0.07397750f, 0.02206466f, 0.05705852f, 0.00249962f, 
    -0.07288103f, -0.16711195f, -0.06718890f, -0.03150209f, 0.02498029f, 0.02159357f, 0.10490661f, 0.05517283f, 
    -0.03225636f, -0.08876105f, -0.03614973f, 0.06205945f, 0.22688803f, -0.02018519f, 0.01274384f, 0.29790649f, 
    -0.06888331f, -0.06702773f, -0.01064943f, -0.00254868f, -0.03873188f, 0.04520229f, -0.04230937f, -0.00789467f, 
    -0.03131920f, -0.02056431f, 0.02966118f, -0.14727122f, -0.02945361f, 0.01477337f, -0.07553954f, -0.12799203f, 
    -0.00954939f, 0.05957925f, -0.00399765f, -0.05880495f, -0.05713022f, 0.00269789f, -0.08633139f, -0.16751327f, 
    -0.11064601f, 0.06230482f, -0.05467887f, 0.00753417f, -0.03948705f, 0.00624281f, -0.00878148f, -0.10629839f, 
    0.07781093f, 0.01808234f, 0.02269202f, 0.06722642f, 0.00924806f, 0.07017590f, -0.08726908f, 0.07049878f, 
    -0.20630495f, 0.07546315f, 0.02338799f, 0.02678953f, -0.12522940f, 0.10595016f, -0.00473801f, -0.15701613f, 
    0.04335340f, 0.04664715f, -0.04168968f, -0.00506606f, -0.12360726f, 0.14609723f, -0.00682853f, 0.00460905f, 
    0.14496061f, -0.04262730f, -0.10033852f, 0.20994201f, -0.01092411f, 0.05813991f, 0.00266628f, -0.15543172f, 
    0.02671699f, 0.01618349f, 0.03501306f, 0.02821521f, 0.03485261f, 0.14520369f, 0.01074682f, -0.15961374f, 
    0.05012275f, 0.07790662f, 0.04838724f, 0.05293974f, -0.01660216f, 0.03697248f, 0.05472412f, 0.07566418f, 
    -0.26654267f, -0.08577303f, -0.01077942f, 0.01822264f, -0.00412205f, -0.04215467f, 0.02463570f, -0.01702073f, 
    -0.02851341f, 0.02689848f, -0.09176757f, -0.00680749f, -0.26699549f, -0.01310737f, 0.10532405f, -0.17134134f, 
    0.06323581f, 0.04425597f, -0.00097729f, -0.04922121f, -0.05129673f, -0.11993198f, 0.04841078f, -0.06433357f, 
    -0.51596975f, -0.06546506f, 0.17182666f, -0.34651867f, 0.03595590f, 0.08869463f, -0.03515727f, -0.02307522f, 
    0.07056970f, -0.13005048f, 0.12487928f, 0.03119035f, -0.00560395f, 0.01520911f, -0.11340021f, 0.14642446f, 
    0.02089233f, -0.11574187f, 0.03373457f, -0.03658951f, 0.08242057f, -0.01907346f, 0.12494853f, 0.05847334f, 
    0.00715700f, 0.16735911f, -0.05329013f, 0.09461603f, -0.08798128f, 0.03613686f, 0.07589578f, -0.16462149f, 
    0.00837291f, 0.05088706f, 0.03483187f, -0.10556722f, -0.16998674f, 0.07196709f, -0.05815672f, 0.19954804f, 
    0.03533399f, 0.01774967f, 0.08031222f, -0.04403190f, -0.00751194f, -0.05752076f, -0.03524126f, 0.01775817f, 
    -0.01317500f, -0.07006542f, -0.06624185f, 0.03712434f, 0.05135312f, 0.00326119f, 0.04013186f, -0.08184705f, 
    0.02061908f, -0.08911386f, 0.01238433f, -0.07508316f, 0.21634486f, -0.02197718f, 0.01060161f, 0.02257858f, 
    -0.08611635f, -0.15989617f, -0.10245895f, 0.05780377f, -0.08775838f, -0.02416352f, 0.02559708f, -0.03393380f, 
    -0.24025777f, 0.21541861f, 0.02444303f, 0.05022035f, -0.17631052f, 0.01704758f, -0.06643251f, -0.01894361f, 
    0.03143458f, -0.00867628f, 0.04419012f, 0.04604503f, 0.05170751f, -0.08601493f, -0.12168766f, 0.23576777f, 
    -0.04810157f, -0.09763337f, -0.05828644f, -0.07093286f, -0.02833220f, 0.02775599f, 0.04387577f, 0.03854691f, 
    0.20036185f, -0.11750364f, -0.04639672f, 0.08766210f, -0.18924719f, 0.01384428f, -0.11121082f, 0.07965547f, 
    -0.09766523f, -0.06739379f, 0.01620142f, -0.01548277f, 0.14619145f, -0.15883020f, -0.01464010f, -0.11708532f, 
    0.03667513f, -0.04107971f, 0.11154192f, -0.00718497f, 0.00447427f, 0.06913343f, -0.01757176f, 0.02268850f, 
    0.19328815f, 0.12748514f, -0.00006463f, 0.18571599f, -0.15928379f, 0.11802249f, -0.00812260f, -0.05710258f, 
    -0.06587464f, 0.11569838f, -0.03066047f, -0.06241223f, 0.04498354f, 0.02127709f, -0.09845185f, -0.06415855f, 
    -0.19133291f, -0.11465753f, -0.00395768f, 0.02884765f, 0.11263514f, -0.01570077f, -0.05769202f, -0.01343935f, 
    -0.01522377f, 0.12732390f, 0.03388945f, 0.07542813f, 0.00987991f, -0.04295465f, -0.06684217f, -0.00663679f, 
    -0.11279701f, 0.00957073f, 0.07822642f, -0.14310288f, 0.01573653f, 0.09767811f, -0.08304383f, 0.05943532f, 
    -0.13030550f, -0.03922819f, 0.01584116f, -0.10052637f, -0.13976845f, -0.05729157f, 0.00740587f, -0.12474409f, 
    -0.21066684f, 0.05248772f, 0.10633874f, 0.02025224f, 0.02491957f, 0.04037542f, 0.04579409f, -0.06905927f, 
    -0.02491480f, -0.07681151f, 0.02636120f, -0.15048951f, -0.16403782f, -0.00481212f, -0.06076148f, -0.02262011f, 
    -0.04091606f, 0.04919892f, -0.07235520f, 0.09067653f, 0.00455907f, -0.03370240f, 0.00006185f, -0.12408008f, 
    0.02579230f, 0.04881966f, -0.00555235f, 0.09596510f, -0.06056016f, -0.04249112f, -0.02287941f, 0.00247350f, 
    -0.01722227f, 0.00090051f, 0.14999075f, -0.01785338f, -0.07242003f, 0.13556552f, -0.13684452f, 0.14959468f, 
    -0.08320619f, 0.09073792f, 0.01663905f, -0.03219071f, 0.01767619f, -0.09295473f, 0.05773745f, -0.06426495f, 
    -0.11020499f, -0.29356259f, 0.06271335f, 0.01369086f, -0.03860202f, 0.02289919f, 0.03699722f, -0.02603403f, 
    0.03603884f, -0.09026291f, -0.09111320f, -0.04890977f, 0.22641657f, -0.06877796f, -0.00874105f, -0.06588800f, 
    -0.11843015f, -0.09120116f, -0.08249030f, 0.04143416f, -0.05529404f, 0.07338394f, 0.09038074f, -0.11709455f, 
    -0.25485685f, 0.12887557f, -0.09123755f, 0.11517387f, -0.00483783f, 0.02229864f, -0.04659937f, -0.02194317f, 
    -0.00246704f, -0.06097165f, -0.05733868f, -0.01297920f, 0.28477272f, -0.29271433f, 0.07886988f, -0.34909841f, 
    0.05160751f, -0.13682851f, 0.15574439f, -0.01259246f, -0.01695430f, -0.05843495f, 0.04964437f, 0.06516077f, 
    -0.16596262f, -0.10381591f, 0.07903799f, 0.21494891f, 0.04180061f, 0.01166144f, 0.04727628f, -0.04795044f, 
    0.03112093f, -0.01526382f, -0.17434625f, 0.00949310f, 0.22929887f, 0.28039107f, -0.07372661f, -0.00777167f, 
    0.08188482f, -0.03234163f, 0.01826033f, -0.02605925f, 0.00148042f, -0.08206633f, -0.10772696f, 0.02477639f, 
    -0.52716970f, 0.21586837f, 0.09506605f, -0.03687574f, 0.00288537f, 0.03204297f, 0.07152179f, -0.06089250f, 
    -0.01036892f, 0.04690248f, 0.06144462f, 0.06278544f, 0.13328229f, 0.02597618f, -0.13196960f, -0.01680654f, 
    -0.06103666f, -0.05381363f, -0.00738532f, -0.02072976f, -0.03030577f, -0.02273501f, 0.02218240f, 0.01452590f, 
    0.05902182f, 0.01371133f, 0.12505127f, -0.14538261f, 0.04939600f, 0.00258630f, 0.01652527f, 0.07040346f, 
    0.14474626f, 0.04274848f, -0.01524247f, 0.09408306f, -0.07580144f, -0.12705812f, 0.03796364f, -0.17068453f, 
    0.03223239f, 0.05417337f, 0.07002566f, 0.01634749f, -0.00129696f, -0.01965846f, 0.00437789f, -0.01823526f, 
    0.18024601f, 0.04235029f, 0.08282913f, -0.09296434f, -0.06377549f, -0.01838328f, -0.10527922f, 0.11726237f, 
    0.05236673f, -0.08998819f, 0.00778172f, -0.05364130f, 0.11539960f, 0.06646235f, -0.21998304f, 0.18107750f, 
    -0.04023799f, -0.01816088f, 0.08837032f, -0.04104711f, -0.14307389f, 0.03354491f, -0.00261303f, -0.03147044f, 
    0.41950658f, 0.13970405f, -0.06191212f, -0.29942843f, -0.03645861f, 0.03783033f, 0.06817434f, -0.00332780f, 
    0.03376434f, 0.04553250f, -0.05706400f, 0.00623461f, 0.16179399f, -0.12089220f, 0.06812891f, 0.17862678f, 
    0.07694473f, -0.07980014f, 0.01678601f, 0.00324713f, 0.05446720f, -0.01842164f, 0.08682083f, -0.12490578f, 
    -0.14008568f, -0.15134437f, 0.13109836f, 0.15085606f, 0.06908984f, -0.01996266f, 0.00926723f, 0.00677354f, 
    -0.00463847f, -0.06209156f, -0.12966943f, -0.05305326f, 0.61825019f, 0.02631798f, 0.03677869f, -0.11498768f, 
    -0.07031729f, 0.10044557f, -0.03421380f, -0.00353500f, 0.04831400f, 0.02169511f, -0.00033046f, 0.03679803f, 
    0.24848284f, -0.35757118f, -0.02730734f, 0.35209686f, -0.13013515f, 0.14312226f, -0.02544456f, 0.06580664f, 
    0.02858902f, 0.01289646f, -0.07632151f, -0.01931490f, -0.10747236f, -0.05104867f, 0.08255657f, 0.08698341f, 
    -0.05171898f, -0.10471092f, -0.10205541f, -0.02592649f, -0.06273725f, -0.09676080f, -0.08317664f, -0.01930529f, 
    0.09785819f, 0.03369434f, 0.05906772f, -0.02918576f, 0.05076012f, -0.02404859f, -0.07227261f, 0.09258307f, 
    -0.05823505f, 0.07534206f, 0.07717505f, -0.04344843f, 0.18483452f, -0.17476484f, -0.01773976f, -0.08570519f, 
    -0.25717628f, -0.04162873f, -0.10146946f, 0.04342489f, -0.12726258f, 0.05539304f, -0.06365264f, 0.00425537f, 
    -0.07596627f, -0.03132985f, -0.07739725f, -0.04833899f, -0.00480720f, -0.02083564f, -0.09599531f, 0.09273631f, 
    0.12381124f, -0.07001443f, 0.20147204f, -0.14339490f, 0.29470521f, -0.16017956f, -0.15570134f, -0.02498236f, 
    0.06310263f, 0.08001532f, -0.06734861f, 0.07335251f, -0.00082945f, -0.10600844f, -0.05573253f, 0.01327737f, 
    0.16883110f, 0.03687143f, 0.01941296f, 0.08556281f, -0.03931919f, -0.06523697f, 0.01816874f, 0.00944439f, 
    -0.00149171f, 0.00415297f, -0.02076942f, 0.04681574f, -0.11878303f, -0.22905813f, -0.02180008f, 0.02436068f, 
    -0.01117899f, 0.08779560f, -0.01474124f, -0.12596522f, -0.14355530f, 0.06386066f, -0.11233620f, 0.03131783f, 
    -0.12430727f, -0.08922645f, -0.03788104f, 0.00749820f, -0.09624053f, -0.02011924f, 0.03298432f, -0.03746000f, 
    -0.08473682f, 0.04648824f, -0.11522936f, -0.09400733f, 0.29407951f, -0.05092134f, -0.01886541f, 0.06185711f, 
    0.00999447f, -0.03024234f, -0.05541510f, 0.03089167f, -0.16273883f, -0.22835948f, 0.02004225f, -0.05855878f, 
    -0.03030895f, -0.05839312f, 0.10259595f, 0.05372905f, -0.09322868f, -0.07585535f, -0.10936878f, 0.07303389f, 
    -0.01449420f, 0.05450889f, 0.01429771f, 0.08750417f, 0.25351119f, -0.20845081f, -0.13006349f, 0.01225634f, 
    0.16381125f, -0.12751934f, -0.03476997f, -0.06404503f, -0.12530130f, 0.07873429f, -0.04007303f, -0.13821569f, 
    0.01630342f, -0.05547813f, 0.00860264f, -0.06650035f, -0.03012550f, 0.03106208f, 0.13307716f, 0.03424759f, 
    -0.07990287f, 0.05046562f, 0.01374032f, 0.04587853f, 0.31329513f, -0.06007475f, 0.12189662f, -0.00657182f, 
    -0.06964745f, -0.07251244f, -0.03120355f, 0.02369897f, -0.07384019f, 0.04152848f, -0.01435110f, -0.16945873f, 
    -0.08690523f, 0.10309862f, -0.24238510f, -0.11455786f, 0.01978908f, -0.09635606f, 0.04110539f, 0.01921887f, 
    -0.00726447f, 0.00030097f, -0.00748008f, 0.04314030f, 0.17486858f, 0.10345937f, 0.11277322f, 0.10437687f, 
    0.09758747f, 0.07467844f, -0.06571731f, -0.02289978f, 0.11255562f, -0.00143677f, -0.08492355f, 0.13213411f, 
    0.26293117f, -0.11665318f, -0.11576512f, -0.19067997f, 0.08260160f, -0.00106108f, -0.03022897f, 0.00135082f, 
    0.11607180f, -0.03174767f, 0.00053298f, -0.02442267f, -0.28412020f, 0.21895100f, 0.00539079f, 0.14245436f, 
    -0.09705531f, -0.00093289f, 0.05556080f, -0.05098301f, 0.08476041f, 0.09441266f, -0.12217668f, 0.10991152f, 
    -0.24807531f, 0.02641864f, 0.02820292f, 0.15472892f, -0.08257103f, 0.00324137f, -0.07834300f, 0.05418226f, 
    0.00339056f, 0.04681008f, -0.03057419f, 0.18141438f, -0.01609600f, -0.14424865f, -0.04199750f, -0.08963289f, 
    -0.01990259f, -0.05907474f, -0.10310131f, -0.00133805f, -0.07405896f, -0.14326973f, -0.01318583f, -0.08474082f, 
    -0.04209230f, 0.00397900f, -0.05151710f, -0.06090045f, -0.07498250f, 0.04276743f, -0.04747877f, 0.01636520f, 
    0.10930272f, -0.00843421f, 0.08255585f, 0.05664843f, 0.19581991f, -0.03293683f, -0.05012319f, 0.21334973f, 
    -0.03378517f, 0.04854354f, 0.02501841f, 0.01537079f, -0.05763708f, 0.00489182f, -0.05272371f, 0.04734023f, 
    -0.31056172f, -0.25330073f, 0.00275946f, -0.10512972f, -0.06381412f, 0.01978497f, 0.01717202f, 0.11127506f, 
    0.07639579f, 0.05308949f, -0.01554991f, 0.01419068f, 0.19473498f, -0.20368859f, -0.02927744f, -0.16547412f, 
    -0.02229533f, -0.05153234f, 0.02445851f, -0.05526501f, 0.02146390f, -0.05667005f, -0.02573414f, 0.12850776f, 
    0.20660391f, -0.15419292f, 0.10955828f, 0.04517439f, -0.09131774f, -0.01403812f, -0.00939870f, 0.00369918f, 
    0.11731771f, -0.03800516f, 0.03774315f, 0.02688571f, -0.07702676f, -0.06733651f, -0.05381722f, -0.05823670f, 
    -0.07700074f, -0.00363365f, 0.05103322f, 0.01092994f, 0.02627606f, 0.02101460f, -0.01858319f, -0.00662909f, 
    -0.47917143f, -0.03342510f, -0.10002808f, 0.19748631f, -0.16159083f, -0.06951071f, -0.01994039f, -0.02867363f, 
    -0.03808764f, 0.00567247f, 0.03581109f, 0.10882964f, 0.10830630f, -0.01381853f, -0.16381246f, -0.03388742f, 
    -0.09890426f, -0.03194135f, 0.00054490f, -0.03247706f, 0.11851744f, 0.05222322f, -0.05904565f, -0.01556557f, 
    0.15627515f, -0.16862297f, 0.04114563f, -0.00044652f, 0.01011835f, 0.10295032f, -0.03042710f, 0.07201951f, 
    -0.02590600f, -0.05157178f, 0.13307039f, -0.05252312f, -0.26881245f, 0.31568319f, -0.26643443f, -0.41170520f, 
    0.03900106f, 0.12667817f, 0.02371415f, -0.04050632f, 0.10673476f, 0.07737781f, -0.04148604f, 0.05731951f, 
    0.21464512f, 0.10603576f, -0.25805411f, -0.02332798f, -0.07164386f, 0.05837191f, 0.01003850f, -0.10176451f, 
    0.05802123f, 0.11399493f, -0.10085654f, 0.02746111f, -0.24261066f, -0.03445981f, 0.01993735f, -0.11039570f, 
    -0.07595405f, -0.15426220f, -0.07185002f, -0.13111766f, -0.12268326f, -0.05598220f, -0.08122813f, -0.25656420f, 
    0.15394516f, -0.05808629f, -0.09082593f, 0.04976881f, -0.13137524f, 0.12511665f, 0.06581526f, 0.08405855f, 
    -0.09195240f, -0.19592796f, 0.11529005f, 0.29814541f, 0.27319220f, 0.01007022f, 0.00258279f, 0.05807520f, 
    0.04650357f, 0.13494447f, -0.10953166f, 0.01989128f, -0.03964582f, 0.07696971f, 0.02764874f, -0.19051281f, 
    -0.02191217f, -0.03587569f, 0.00446550f, -0.08397798f, -0.02057438f, 0.03648920f, -0.04361907f, 0.06001014f, 
    -0.14146458f, 0.08248264f, 0.03444074f, -0.05678568f, 0.24082513f, -0.07573104f, -0.10910806f, 0.01865626f, 
    -0.11232521f, 0.08406419f, 0.12911555f, -0.01751554f, 0.00204045f, 0.01245051f, -0.07338540f, 0.12807584f, 
    0.21836880f, -0.11019831f, 0.00107523f, 0.03305649f, -0.02880757f, 0.03967096f, -0.07469768f, 0.06847087f, 
    0.02710577f, -0.05119569f, -0.16950072f, -0.04142496f, -0.26345456f, -0.14588766f, 0.08396288f, 0.00042483f, 
    0.03347087f, 0.01133258f, 0.08538384f, 0.04250144f, 0.01034657f, -0.11398669f, 0.00941577f, -0.01895424f, 
    0.18589035f, -0.13200200f, 0.17479508f, 0.08273916f, -0.05216698f, 0.01614635f, -0.10771046f, 0.06214477f, 
    -0.07940046f, 0.10265980f, -0.03230907f, 0.01444152f, 0.18406568f, 0.02226712f, -0.03605719f, 0.07337838f, 
    0.07830022f, 0.00033099f, 0.03236413f, 0.00019051f, -0.10805900f, -0.09288821f, 0.05388801f, -0.06383101f, 
    -0.12383227f, 0.01363171f, 0.04151603f, 0.04871588f, -0.03943475f, -0.00111648f, 0.02470241f, -0.11384748f, 
    -0.06469546f, -0.06410228f, 0.00493937f, 0.01431775f, 0.05424367f, 0.12426320f, 0.17147988f, 0.11689001f, 
    -0.14205384f, 0.07408424f, 0.02521982f, -0.02311035f, -0.00905765f, -0.03570508f, 0.04294456f, 0.05427140f, 
    0.10730960f, -0.12665355f, -0.25066173f, -0.15144946f, -0.05454440f, -0.08806485f, -0.00207394f, 0.00529631f, 
    -0.05354508f, -0.09116752f, -0.13146298f, 0.00192932f, 0.08093431f, 0.06315085f, 0.04869479f, 0.21516582f, 
    0.01060467f, -0.02837179f, 0.04776379f, 0.03386634f, 0.07670515f, -0.01547341f, -0.05353491f, 0.06098627f, 
    -0.16044210f, -0.19232635f, -0.04869877f, -0.16226210f, -0.06767362f, 0.00066990f, -0.05484637f, 0.07218671f, 
    -0.01137724f, -0.06394740f, -0.00605745f, 0.10552937f, 0.42110834f, -0.23201825f, -0.19374143f, -0.03637169f, 
    0.01985021f, -0.06370292f, 0.07936028f, -0.04485198f, 0.04352043f, 0.03827734f, -0.09161980f, 0.17411470f, 
    0.27065909f, 0.14169973f, 0.07620706f, 0.18419714f, -0.07870473f, 0.03001238f, 0.00158646f, 0.00791202f, 
    -0.04971207f, 0.09426513f, -0.00160322f, -0.00887306f, -0.28973773f, -0.04163035f, -0.10105886f, 0.09536319f, 
    0.01039713f, 0.01078430f, -0.04424757f, -0.15237570f, -0.06652322f, -0.01946614f, -0.04831043f, -0.02162652f, 
    -0.01187199f, -0.14906202f, -0.07458406f, -0.00242240f, 0.09778418f, -0.06263167f, -0.00688395f, 0.01872703f, 
    -0.03100251f, 0.11091613f, 0.13509910f, -0.02975548f, 0.25260937f, 0.08745568f, 0.12414157f, 0.30753255f, 
    -0.02582111f, -0.00349312f, 0.04578591f, 0.06536321f, 0.11889255f, -0.06484743f, -0.17536949f, -0.00741437f, 
    0.04604706f, 0.13032980f, -0.06277278f, 0.23563114f, 0.06122954f, 0.00420034f, -0.12138565f, -0.02813638f, 
    -0.00045364f, 0.06194964f, 0.11739308f, 0.00867640f, 0.08050840f, -0.28660911f, 0.15309900f, -0.34471470f, 
    -0.06123400f, -0.01388693f, -0.06265016f, 0.03788785f, -0.12115398f, -0.04013593f, 0.06417450f, -0.03054181f, 
    -0.02082981f, 0.08668528f, -0.24110320f, 0.07532248f, 0.10091211f, 0.13848600f, -0.02036729f, 0.00740743f, 
    -0.04835615f, -0.02378240f, 0.08481860f, -0.06292302f, -0.20743570f, -0.15150540f, -0.17306280f, 0.01262179f, 
    -0.02921026f, -0.02192743f, -0.06436488f, 0.16009535f, 0.04169066f, -0.05435209f, -0.07581056f, -0.05566421f, 
    -0.03575071f, 0.00049419f, -0.02327294f, -0.06015183f, -0.12031614f, 0.05346481f, 0.03833016f, -0.05992500f, 
    0.06767448f, 0.03584568f, -0.03076731f, -0.05377933f, 0.17591415f, -0.10769339f, 0.14683403f, 0.00056460f, 
    0.07971422f, -0.16245300f, -0.03247355f, 0.01657126f, 0.03047411f, 0.13698611f, -0.06994013f, 0.03285624f, 
    0.15222502f, -0.03720336f, -0.02641117f, 0.04299523f, -0.14445838f, -0.06731174f, -0.08438811f, -0.01178355f, 
    -0.05806045f, -0.01226452f, 0.06686909f, 0.03713452f, -0.07832684f, -0.05799580f, -0.07581230f, -0.12513678f, 
    0.11629967f, -0.14175268f, -0.01966041f, -0.13497916f, 0.12026862f, -0.20229416f, 0.05567002f, 0.04663610f, 
    0.06034126f, 0.00598764f, 0.14150316f, 0.07288244f, 0.17575493f, 0.01020096f, 0.13559628f, -0.01326444f, 
    0.08500798f, 0.02981033f, -0.03231362f, 0.12197548f, 0.00054859f, 0.05955070f, 0.00816317f, 0.15512146f, 
    -0.23730665f, 0.07514690f, 0.05914987f, 0.04393341f, 0.09970331f, 0.05999300f, -0.06130376f, -0.07785366f, 
    -0.34223121f, -0.25461859f, 0.07054245f, -0.17134283f, 0.08131587f, 0.01820157f, -0.09733784f, 0.04418446f, 
    -0.03988106f, 0.06387155f, 0.02536082f, -0.03874243f, -0.19299872f, -0.00936239f, -0.11435305f, -0.04330633f, 
    0.06577835f, 0.09484062f, -0.01418660f, 0.06584098f, 0.09856679f, 0.11932501f, -0.06596275f, 0.12369186f, 
    -0.21071695f, 0.06331617f, -0.24170186f, -0.20700674f, -0.03132991f, 0.06463361f, 0.05488743f, -0.15397093f, 
    -0.02542399f, 0.14678051f, -0.01169962f, -0.06357297f, -0.61064935f, 0.00889328f, -0.04719295f, -0.20458491f, 
    0.03578857f, -0.04734384f, -0.08648443f, 0.00750624f, 0.12157524f, 0.06443746f, 0.10099149f, 0.04565042f, 
    0.12640186f, 0.08070988f, 0.11372350f, 0.13986023f, -0.08080212f, -0.01828010f, -0.08821544f, -0.00243090f, 
    0.07884002f, 0.00763623f, 0.09389853f, 0.02352061f, 0.16244692f, -0.03422627f, 0.14371206f, 0.06836015f, 
    -0.09421570f, 0.06715053f, 0.00922553f, 0.02745914f, -0.00972850f, 0.08057554f, -0.09939354f, 0.07031036f, 
    -0.29460284f, 0.09347575f, -0.08097859f, 0.20048304f, -0.09995041f, -0.15922980f, 0.06113844f, 0.01504674f, 
    0.04147924f, -0.01218119f, -0.00826923f, -0.05537392f, 0.20401472f, -0.13247499f, 0.03168725f, -0.13835409f, 
    0.13859746f, -0.12653130f, -0.02080485f, -0.04684746f, 0.03974643f, 0.01703790f, 0.02246655f, 0.05514199f, 
    0.34961081f, 0.00161827f, -0.15770832f, 0.02116862f, -0.00384260f, 0.01961109f, -0.06313813f, -0.00427638f, 
    -0.14492862f, 0.11007174f, -0.12938368f, -0.05689025f, -0.15003702f, 0.07413921f, -0.02142982f, -0.08582953f, 
    0.00286062f, -0.01759184f, 0.10282701f, -0.01854378f, -0.11832976f, -0.00431722f, 0.00280908f, 0.02316791f, 
    0.09637064f, 0.03224179f, 0.00904499f, -0.01201441f, 0.12428521f, 0.06015107f, 0.06540442f, -0.03967628f, 
    -0.04502805f, 0.02422530f, 0.00235591f, 0.06686161f, -0.08670110f, -0.02392007f, -0.14702332f, -0.28667581f, 
    0.04741690f, 0.01376365f, 0.14800504f, 0.01010644f, 0.07888238f, 0.07535978f, 0.03831320f, -0.10898647f, 
    0.13214222f, -0.06667057f, -0.04290707f, -0.03706349f, 0.00630525f, -0.02481460f, 0.03942481f, -0.04253320f, 
    -0.06708571f, -0.04242494f, 0.08645536f, 0.04172245f, 0.10495123f, -0.00077049f, 0.00338895f, 0.13904762f, 
    -0.00799460f, -0.05085012f, 0.08327329f, 0.03857850f, -0.07533809f, 0.01598589f, -0.01042405f, -0.12106580f, 
    0.01446966f, 0.09167479f, -0.04030237f, 0.14210768f, 0.02371327f, 0.03656584f, 0.01561514f, -0.15941581f, 
    -0.16508496f, -0.07479345f, -0.00305510f, -0.02531841f, -0.01971132f, 0.04207023f, 0.06878881f, -0.02740466f, 
    0.01770417f, 0.08960824f, -0.02712699f, -0.01308129f, -0.00187886f, -0.15244310f, -0.12206312f, -0.06063734f, 
    -0.28909990f, -0.13487703f, 0.03812138f, -0.14733849f, -0.06588060f, -0.00100378f, -0.10418643f, -0.05653857f, 
    -0.04494868f, -0.06039389f, 0.09630390f, -0.06522720f, 0.46621373f, -0.03798684f, -0.20244895f, 0.06229613f, 
    0.00502696f, -0.06795307f, 0.00424056f, -0.03300831f, -0.06305460f, 0.00322161f, 0.02606711f, -0.03096111f, 
    -0.52024192f, -0.04675505f, -0.08341473f, -0.35898724f, -0.04420431f, 0.10383729f, 0.07213388f, -0.07612420f, 
    -0.02903201f, -0.07174852f, -0.07128213f, -0.08213612f, 0.03512211f, 0.04317151f, -0.07088837f, 0.01228034f, 
    -0.02050682f, -0.03870213f, 0.02431333f, -0.02016701f, 0.01920516f, 0.01186104f, 0.01178689f, -0.10438439f, 
    0.19175430f, -0.03512329f, 0.12534371f, 0.26649576f, -0.08808968f, -0.11646751f, -0.00318308f, -0.02308809f, 
    -0.07011343f, -0.02493680f, -0.02645439f, 0.07176602f, -0.19075890f, -0.10361172f, -0.04389907f, -0.07282281f, 
    -0.05267469f, -0.00517660f, -0.25737709f, -0.02298247f, 0.12193821f, 0.00918880f, 0.08518213f, -0.08860248f, 
    0.20033160f, -0.10255250f, -0.24257398f, -0.03603860f, -0.01978715f, 0.07907389f, -0.02322308f, 0.00535961f, 
    0.01683222f, 0.05171269f, -0.01146318f, -0.03303101f, -0.02451555f, -0.15542555f, 0.02100715f, -0.09118175f, 
    0.04878622f, 0.05572715f, 0.00221070f, -0.08288595f, 0.03095589f, -0.02361524f, -0.03437676f, -0.02753887f, 
    -0.13268140f, 0.11094711f, 0.19534957f, 0.06518667f, -0.09564190f, -0.06409446f, 0.09825537f, -0.04882861f, 
    -0.04625488f, -0.06673499f, 0.00126721f, -0.06394729f, 0.14370562f, 0.02937337f, -0.05687554f, -0.05017157f, 
    0.03954772f, -0.00288529f, 0.03314377f, -0.04188217f, 0.06067490f, 0.01150982f, -0.04078340f, 0.04262397f, 
    -0.25521353f, -0.06625260f, 0.00017292f, -0.00418703f, 0.05055649f, -0.01678770f, -0.20549387f, -0.05491573f, 
    -0.07801333f, 0.17884369f, 0.00731119f, 0.00196427f, -0.06053605f, 0.05524375f, 0.13112521f, 0.08312698f, 
    -0.06769955f, 0.02235126f, 0.01262307f, -0.01000623f, 0.01353642f, 0.00569096f, -0.01833069f, -0.10047819f, 
    0.00257698f, -0.01310044f, 0.07783953f, 0.00697910f, 0.11383485f, -0.08972573f, 0.02430644f, 0.09070574f, 
    -0.09540422f, 0.03581116f, -0.09604738f, -0.04191459f, -0.36624563f, -0.01494660f, -0.23030114f, -0.13857476f, 
    -0.01701484f, -0.07563548f, -0.03349379f, 0.07497326f, 0.01093409f, -0.02806626f, -0.00954010f, 0.00286007f, 
    0.37293684f, -0.06470281f, -0.05012153f, -0.10118312f, -0.04285668f, 0.10050385f, 0.04146277f, 0.00532987f, 
    0.02354428f, 0.03842558f, -0.01002975f, -0.14750229f, 0.25583100f, 0.05933831f, 0.24431172f, 0.22405457f, 
    -0.16719005f, -0.07607149f, -0.01611644f, 0.10195510f, -0.02329790f, -0.04035671f, 0.02951435f, -0.01314789f, 
    0.51227570f, -0.07046741f, 0.00263537f, -0.09418321f, -0.00034237f, 0.05281164f, 0.01597300f, -0.09189963f, 
    -0.08268337f, 0.03784138f, 0.02360406f, -0.07521265f, 0.20809858f, -0.00729227f, -0.33962280f, -0.10426790f, 
    0.12750585f, 0.08110174f, 0.03136905f, -0.14962070f, 0.02078136f, -0.04649694f, 0.02316439f, -0.06601489f, 
    0.12692076f, -0.02708503f, -0.13131183f, 0.06300206f, -0.05267911f, -0.09577382f, 0.02297781f, -0.03764954f, 
    0.03096205f, -0.08115637f, -0.07690188f, -0.00348387f, -0.11692743f, 0.03370396f, -0.18970467f, 0.01657898f, 
    -0.03388826f, -0.02112524f, 0.01638194f, 0.03581954f, 0.06241408f, 0.06142853f, 0.07248950f, -0.05558431f, 
    0.19899020f, -0.03048449f, 0.00805067f, -0.15411432f, 0.09784810f, 0.02024165f, -0.06531432f, 0.04342655f, 
    0.00213096f, 0.05156927f, 0.01680947f, -0.04924929f, 0.02985750f, -0.06244659f, 0.01483918f, -0.05217910f, 
    0.01688611f, 0.03589427f, 0.03643490f, 0.00756322f, 0.01983032f, 0.03788389f, -0.01569293f, -0.03012796f, 
    0.00875529f, 0.03957558f, -0.01929941f, 0.00428273f, -0.01099211f, 0.01564745f, -0.04220523f, -0.06895764f, 
    0.04671765f, -0.17951912f, -0.02953660f, -0.08660895f, -0.17788668f, -0.14710779f, -0.01689820f, -0.21945241f, 
    -0.00760708f, 0.00366668f, -0.03793317f, -0.02499828f, -0.04734031f, -0.03468025f, 0.06042284f, -0.05717267f, 
    0.16698940f, 0.12885912f, 0.00015664f, 0.00783640f, 0.00022497f, -0.05631028f, -0.04217861f, 0.13215613f, 
    0.06037160f, 0.01557978f, 0.06374773f, 0.08410799f, 0.18540122f, 0.03001741f, -0.10899316f, 0.02768552f, 
    -0.03820389f, 0.04072125f, -0.03721398f, -0.02607885f, -0.03948940f, -0.05965723f, 0.09428920f, 0.00970495f, 
    -0.06704573f, -0.17939873f, 0.05792620f, -0.24682669f, 0.08944713f, -0.07932877f, -0.04098490f, -0.00287122f, 
    0.00203096f, 0.09453357f, -0.04509330f, 0.04621997f, 0.10080028f, -0.11432425f, 0.13958915f, 0.11774094f, 
    -0.13075960f, 0.03611904f, 0.06943639f, 0.05672703f, 0.00202386f, -0.03942470f, -0.05406535f, -0.04608684f, 
    0.15804593f, -0.01051610f, 0.03425190f, -0.13515735f, -0.06514611f, 0.03410656f, 0.11272187f, 0.04274508f, 
    -0.08955951f, 0.01022562f, 0.01992630f, -0.01869428f, 0.13245381f, 0.02518950f, -0.05419791f, 0.14909041f, 
    0.12108172f, 0.06148757f, 0.00205014f, -0.02362106f, 0.03640438f, -0.02853565f, -0.09421276f, -0.00155552f, 
    -0.21211779f, 0.00074394f, -0.10244960f, -0.14001282f, -0.01754386f, -0.05916267f, 0.03710990f, 0.03521015f, 
    -0.03091968f, 0.06286487f, 0.01003335f, -0.11546508f, -0.02635753f, 0.07163918f, -0.02874683f, -0.04543132f, 
    0.02974675f, 0.01672352f, 0.05952854f, 0.03786512f, 0.01309876f, 0.00688848f, 0.03198255f, -0.00512189f, 
    -0.07171734f, 0.13789250f, -0.19870792f, -0.34232584f, -0.01177731f, 0.06464114f, 0.04032591f, -0.03506148f, 
    -0.01910758f, -0.03124687f, -0.01414510f, -0.10911585f, 0.23990057f, -0.17689903f, 0.05509566f, -0.05955720f, 
    -0.21014270f, 0.05443525f, -0.08405761f, 0.00444640f, -0.02006891f, -0.13687967f, 0.06211130f, -0.00767257f, 
    0.04554313f, -0.01710970f, -0.06847747f, 0.04114490f, 0.11008107f, -0.00356685f, 0.03322309f, -0.11260623f, 
    0.03357460f, 0.09732274f, 0.01374395f, 0.05427052f, 0.16979682f, -0.06929167f, -0.03045852f, -0.02671633f, 
    -0.05662126f, 0.07797801f, -0.07594749f, -0.00326232f, 0.05720171f, 0.02824327f, -0.03709209f, -0.12761897f, 
    -0.18898703f, -0.02357306f, -0.07731766f, -0.13222492f, -0.03979467f, 0.02278208f, -0.01457701f, -0.06851301f, 
    -0.01929294f, -0.12826265f, -0.02820331f, 0.00805721f, -0.02364304f, 0.20689060f, 0.00077864f, -0.09003921f, 
    0.04411095f, -0.02951271f, -0.02581577f, -0.03647565f, -0.03046377f, -0.00298464f, 0.01421496f, -0.04490380f, 
    0.08410040f, -0.07608376f, 0.04923236f, 0.02608027f, -0.01932419f, -0.03750321f, 0.01146774f, 0.00167447f, 
    0.04219518f, -0.12051447f, 0.04966806f, -0.05997508f, -0.11524402f, 0.11861741f, 0.01337807f, 0.03643849f, 
    0.00900843f, -0.13351658f, 0.09366696f, -0.03244996f, -0.05940483f, -0.07861344f, -0.06471170f, 0.00013963f, 
    0.06816790f, -0.22773473f, 0.03614935f, 0.08280603f, -0.15935369f, 0.00118905f, 0.01454447f, -0.00793064f, 
    -0.00694690f, -0.02178186f, -0.07555428f, 0.04301510f, 0.15124898f, 0.14358164f, -0.08035194f, 0.14936826f, 
    -0.09394751f, -0.08604071f, 0.00942552f, 0.10285279f, 0.06716079f, 0.08587937f, 0.03589515f, -0.10213549f, 
    0.13287874f, 0.18372077f, -0.16490923f, -0.12741941f, 0.06446557f, 0.02760046f, 0.03094248f, 0.02288249f, 
    -0.17433597f, -0.02462842f, -0.11266711f, 0.03764416f, 0.09628732f, 0.06297834f, -0.07512805f, 0.17519449f, 
    -0.04997428f, -0.01399930f, 0.08451957f, 0.09104427f, -0.08309383f, -0.11268673f, 0.04993150f, -0.02816775f, 
    -0.01510748f, 0.05911393f, 0.08156136f, -0.02274586f, -0.06967984f, 0.07031652f, 0.02349807f, 0.12233154f, 
    -0.05860098f, -0.07345870f, 0.04384701f, -0.07220645f, -0.09982245f, -0.17146021f, 0.06697328f, -0.12724625f, 
    -0.01641333f, 0.04621553f, -0.02877381f, -0.07437538f, -0.01209725f, -0.00381517f, 0.06846755f, -0.00576884f, 
    -0.27913037f, 0.15261811f, -0.22392488f, -0.03577464f, 0.06914570f, 0.05758530f, 0.07829572f, -0.09629281f, 
    -0.07400714f, 0.06836983f, 0.02459998f, -0.07396579f, -0.13370281f, 0.02327908f, -0.24274614f, -0.09198538f, 
    -0.07094485f, 0.09178468f, -0.02894940f, -0.06554086f, -0.05168607f, 0.14646268f, -0.05024083f, 0.00804577f, 
    0.22107784f, 0.14848249f, 0.04999741f, 0.20697211f, 0.09542548f, -0.07932529f, 0.07439390f, 0.08034900f, 
    -0.07159691f, 0.12201530f, 0.04252954f, -0.07109477f, 0.24340086f, 0.05713106f, -0.14335148f, -0.06312650f, 
    0.02178675f, 0.04091573f, -0.05164399f, -0.01327824f, -0.11497715f, -0.07976663f, 0.03057941f, -0.19618736f, 
    0.28657469f, -0.14879979f, -0.21659479f, 0.14851852f, -0.11163747f, -0.05055755f, 0.07702325f, 0.04183383f, 
    -0.08020943f, 0.09170438f, -0.05784291f, 0.02735495f, 0.29846376f, 0.04477460f, -0.19256257f, -0.06581071f, 
    -0.01612707f, 0.02232513f, -0.06235521f, 0.08261572f, -0.04284577f, 0.02264794f, 0.01217325f, -0.06768026f, 
    -0.04751040f, 0.09858777f, 0.01247042f, 0.00936639f, 0.01572076f, 0.00437987f, -0.12216789f, 0.09783662f, 
    -0.03456495f, 0.05785276f, -0.06206964f, -0.09797612f, 0.03048036f, -0.10399855f, -0.08733010f, 0.01018064f, 
    0.00586070f, -0.00499122f, -0.02571454f, 0.03079002f, 0.06803086f, 0.01747316f, 0.02508092f, 0.00295328f, 
    0.08238447f, -0.08766039f, -0.10153691f, -0.06240840f, -0.13216871f, -0.03739788f, 0.05396109f, 0.06936976f, 
    -0.04079552f, -0.01892967f, -0.03827192f, 0.06454983f, 0.15139042f, -0.24016589f, -0.18735048f, -0.11078077f, 
    -0.01635332f, -0.02578003f, -0.01153593f, -0.00931165f, -0.11194777f, -0.05937617f, 0.06100953f, -0.00610688f, 
    -0.32827464f, 0.07272612f, 0.20035234f, 0.16234209f, -0.00898426f, 0.05500975f, 0.10181768f, 0.02148566f, 
    -0.13468777f, 0.02892181f, -0.16163567f, 0.04881110f, 0.08195215f, -0.13395880f, -0.00073201f, -0.01713110f, 
    0.07476725f, -0.00783733f, -0.02296471f, 0.01386222f, -0.01141562f, -0.01167529f, 0.00862320f, -0.02845793f, 
    -0.45970896f, -0.32144380f, -0.31891987f, -0.15327519f, -0.12302921f, -0.02621389f, -0.04708600f, -0.03544411f, 
    -0.04021600f, -0.09120138f, -0.02401590f, 0.02354655f, 0.10239205f, 0.10559721f, 0.18918200f, 0.01710224f, 
    -0.05987078f, 0.02668393f, 0.06166835f, -0.08588322f, 0.07672185f, 0.01721393f, 0.06259172f, -0.03765766f, 
    0.59792352f, 0.18565126f, 0.07337160f, -0.03851101f, 0.01833654f, 0.00759837f, -0.02284508f, -0.01750163f, 
    0.01127109f, -0.05675476f, 0.05031330f, -0.11493911f, 0.20528597f, -0.27877906f, -0.02718456f, 0.02530699f, 
    -0.06399644f, 0.09151334f, -0.10738972f, 0.04651457f, 0.03331000f, -0.03735287f, -0.09097220f, 0.02339687f, 
    -0.32469451f, -0.11895042f, 0.14276615f, 0.14141952f, -0.04496068f, 0.13462755f, 0.02162943f, -0.06748151f, 
    -0.04781119f, 0.01530112f, -0.00404832f, -0.04753788f, -0.12769949f, -0.09656651f, 0.01068913f, 0.00899743f, 
    -0.08195356f, -0.00058427f, 0.09956860f, 0.02181332f, 0.08946750f, 0.00549513f, 0.03114622f, 0.11294363f, 
    0.14071310f, 0.07719027f, -0.02136653f, -0.05204931f, 0.01783649f, -0.07876854f, 0.03965875f, -0.03285300f, 
    0.03013053f, -0.02640481f, 0.00520553f, -0.07662956f, 0.02081873f, -0.10091953f, 0.10103747f, -0.03228209f, 
    0.09707499f, -0.06120388f, 0.05302535f, 0.03511998f, 0.04305994f, 0.00831574f, -0.08870901f, 0.08252291f, 
    -0.06506022f, -0.03283146f, -0.06989523f, -0.00733160f, -0.03607970f, -0.04451449f, -0.03183074f, 0.05273626f, 
    -0.00910567f, 0.04290406f, 0.00109912f, -0.08453748f, -0.45161569f, 0.08715717f, -0.00226092f, -0.09069113f, 
    -0.07360871f, -0.04279688f, 0.00692021f, -0.09374762f, 0.00139461f, 0.02611154f, 0.16367082f, -0.00314860f, 
    -0.08736916f, 0.00145300f, -0.06900118f, -0.12288545f, -0.11393150f, -0.03299145f, -0.04226144f, -0.02764985f, 
    -0.02462428f, -0.04483537f, -0.03249856f, 0.08180834f, 0.21103309f, 0.04815599f, -0.02651396f, 0.01124631f, 
    -0.03863417f, -0.10351593f, -0.07855579f, -0.00212417f, -0.05784744f, -0.02400875f, 0.16001181f, -0.02410921f, 
    0.24143237f, -0.03318062f, 0.16410178f, 0.02214864f, 0.01029811f, 0.00539383f, 0.13107941f, -0.00179984f, 
    0.02228043f, -0.04751813f, 0.02463089f, -0.04797230f, 0.24834137f, 0.02149750f, -0.06359486f, 0.12255028f, 
    -0.05717678f, 0.03347372f, 0.03287654f, -0.10863717f, -0.01091046f, -0.01344210f, -0.00092478f, 0.00003764f, 
    -0.05694316f, -0.02240645f, -0.07131208f, -0.25274184f, -0.03376367f, -0.06335106f, -0.05695201f, -0.02066373f, 
    0.13721284f, -0.06057091f, -0.06260744f, 0.03006098f, -0.14299494f, -0.16287452f, -0.12630105f, -0.00943772f, 
    0.04859826f, -0.00036770f, -0.01751381f, -0.14626735f, -0.05163195f, -0.06705332f, 0.02530167f, 0.00782623f, 
    0.12089640f, 0.04628848f, 0.03038891f, 0.06114043f, 0.00819162f, 0.03149157f, 0.02731310f, -0.01208341f, 
    0.06680033f, -0.01274175f, -0.06573030f, -0.05499082f, 0.10179579f, -0.12223588f, -0.01384274f, 0.00190328f, 
    -0.11074353f, -0.05257695f, 0.06102841f, -0.05636612f, -0.10245467f, -0.01913724f, 0.07035021f, -0.01778969f, 
    -0.22316056f, -0.14008544f, -0.07829609f, 0.09650116f, -0.10474138f, 0.06456145f, -0.00147919f, -0.05030520f, 
    0.03869329f, 0.02669195f, 0.00456652f, 0.00763750f, 0.10813638f, -0.03054709f, 0.06321836f, -0.10566987f, 
    0.03556598f, -0.01952571f, 0.01557763f, -0.00769955f, 0.02095562f, -0.00217150f, 0.02110648f, 0.03284798f, 
    -0.01870121f, -0.01045419f, 0.16445611f, 0.03074387f, -0.10869039f, 0.07650859f, -0.02216602f, 0.00968238f, 
    -0.00141186f, -0.01498317f, 0.05057111f, -0.08863361f, 0.09479906f, -0.13298263f, -0.06490673f, -0.12568705f, 
    -0.09098898f, -0.09667402f, 0.00487611f, -0.02567896f, -0.16046755f, -0.08447213f, 0.02239604f, -0.15382481f, 
    0.12606829f, 0.02751481f, 0.11007298f, 0.12273688f, 0.02212291f, -0.10447552f, 0.03535016f, -0.05395039f, 
    0.05980145f, 0.01720274f, -0.02759992f, 0.06489865f, -0.15211765f, 0.24281257f, 0.22322871f, 0.00894640f, 
    0.11077932f, 0.05133683f, -0.04329227f, -0.01450419f, -0.00883378f, 0.03352867f, 0.05963568f, -0.01190536f, 
    0.08355251f, -0.12863158f, 0.12838690f, 0.11561118f, 0.08168770f, -0.04698989f, 0.08687403f, 0.01504229f, 
    0.06191623f, -0.14829916f, -0.06460077f, -0.02061922f, 0.05123984f, 0.04655705f, 0.14465691f, 0.10866112f, 
    -0.03399708f, 0.00764749f, 0.02499459f, 0.07840254f, 0.03341326f, 0.02009732f, 0.03915565f, 0.02517298f, 
    -0.05006208f, 0.03775863f, -0.00657712f, 0.03581083f, 0.00996117f, -0.02938954f, -0.02760886f, 0.03986200f, 
    -0.05242302f, -0.00528249f, 0.03758344f, 0.02265543f, -0.11879269f, -0.00046299f, -0.04053802f, -0.00046841f, 
    -0.03309027f, 0.03986637f, 0.06398059f, -0.10097548f, -0.00135986f, 0.01634198f, 0.01488298f, 0.01965402f, 
    -0.04282000f, -0.13423651f, 0.04331797f, 0.21870467f, -0.00292021f, 0.09067053f, -0.04571848f, -0.02513849f, 
    0.01998870f, -0.07211410f, 0.10849454f, -0.06417350f, -0.01470389f, -0.24435996f, 0.11634380f, -0.02663205f, 
    -0.02119567f, -0.00196535f, -0.01914726f, -0.03870470f, -0.04897245f, -0.06162037f, 0.09289040f, 0.06530655f, 
    0.05291772f, -0.21707368f, 0.02113451f, -0.06697388f, -0.05058158f, 0.04119794f, 0.06160973f, -0.02069883f, 
    -0.02924227f, -0.07020932f, 0.07804266f, 0.08852738f, -0.37504792f, 0.12046999f, 0.07327969f, 0.24546871f, 
    0.12858965f, 0.10982319f, -0.02905026f, -0.05799436f, -0.04675282f, 0.10466237f, 0.09503254f, 0.00002060f, 
    -0.10052078f, -0.40002239f, -0.02046613f, 0.07614437f, -0.10972949f, -0.01394895f, -0.01602795f, 0.00288948f, 
    0.06779940f, -0.07761253f, 0.08606946f, 0.14090444f, 0.04788893f, 0.00102926f, -0.07207871f, -0.11849745f, 
    -0.13769154f, -0.02002086f, -0.01787039f, 0.07312078f, -0.02556428f, -0.03512641f, 0.04423049f, 0.04424862f, 
    -0.49089378f, 0.01422181f, -0.07176908f, -0.12576631f, -0.04004883f, 0.04314015f, -0.00692800f, 0.01942978f, 
    0.11135442f, -0.07183245f, 0.02977299f, -0.06722034f, -0.49003303f, -0.34502593f, 0.15244833f, 0.12970665f, 
    0.01138842f, -0.04229026f, -0.01974468f, 0.07427079f, -0.01108134f, -0.03426707f, -0.07509108f, -0.05681559f, 
    0.23971713f, -0.03834265f, 0.04512243f, 0.06340532f, -0.06048023f, 0.10305824f, 0.05023226f, 0.05970944f, 
    0.02658540f, 0.00303598f, 0.03494906f, -0.05951523f, -0.15955931f, -0.14902133f, -0.09256354f, 0.10901581f, 
    -0.06267896f, 0.02534606f, 0.04648702f, 0.02757248f, -0.02557110f, 0.05606581f, 0.03677106f, -0.08149455f, 
    0.09832472f, 0.09654609f, 0.18932006f, -0.05526038f, 0.05123185f, -0.02085548f, -0.02456987f, 0.01937324f, 
    0.06713187f, 0.08949320f, 0.00100145f, 0.04759530f, 0.17855535f, 0.00826386f, -0.07150514f, 0.12921226f, 
    -0.10365706f, -0.08836547f, -0.00796423f, -0.04568342f, -0.04851091f, -0.06615452f, 0.14389074f, -0.00947794f, 
    -0.49697044f, -0.37820086f, -0.11587062f, -0.04199129f, -0.14523590f, -0.05345713f, 0.00166786f, -0.00141047f, 
    0.00550770f, -0.01702658f, 0.00075207f, 0.00387611f, 0.11429142f, -0.11367695f, 0.26530668f, -0.00013185f, 
    0.03868761f, 0.08522574f, 0.00334888f, 0.05329139f, -0.09693652f, -0.07917928f, -0.06206399f, -0.04583287f, 
    0.04673558f, 0.04628264f, 0.01716579f, 0.04086244f, -0.06172463f, 0.10890707f, -0.03521238f, 0.04599950f, 
    -0.02130804f, -0.07253974f, -0.06918537f, 0.02531601f, -0.20229666f, -0.19260521f, -0.15192868f, -0.04766821f, 
    -0.01656174f, 0.08773227f, -0.04279526f, -0.09240711f, 0.02282478f, 0.09498034f, 0.02631143f, 0.10539660f, 
    -0.08089326f, 0.03200247f, 0.04177658f, 0.04094172f, -0.04761653f, -0.16422056f, 0.12740666f, -0.02959952f, 
    -0.04320145f, 0.01197610f, -0.02530642f, -0.07840407f, -0.08923323f, -0.01323386f, -0.00932965f, 0.08165674f, 
    -0.07013252f, -0.02150995f, 0.03350898f, 0.04498393f, -0.04122377f, 0.00711047f, -0.01708583f, -0.05709888f, 
    0.06285393f, -0.12013348f, -0.02179653f, 0.23984553f, 0.05019599f, -0.05907163f, 0.05570145f, 0.11475853f, 
    0.02299217f, 0.15964937f, -0.00620309f, -0.00812347f, -0.02803814f, 0.08274543f, -0.00784749f, -0.08482415f, 
    0.04423380f, -0.06235841f, 0.09238154f, -0.07088384f, -0.05490452f, 0.04292469f, 0.01748620f, -0.02547330f, 
    0.30459127f, 0.08437688f, 0.05408080f, 0.01074487f, 0.07021825f, 0.03292232f, 0.04514013f, 0.12120993f, 
    -0.02128242f, 0.00173713f, -0.05278102f, 0.01938733f, -0.07768738f, -0.13479455f, -0.04784344f, -0.19812278f, 
    -0.01020917f, -0.01882010f, 0.04653046f, -0.03959043f, -0.08111139f, -0.01954566f, 0.08388141f, -0.07299976f, 
    -0.14819770f, -0.21454658f, -0.31549913f, 0.25137621f, -0.06346111f, 0.00478205f, 0.14544159f, 0.13447687f, 
    -0.08580761f, -0.07196876f, -0.08088917f, -0.01625051f, 0.27435076f, 0.07301901f, 0.00249859f, -0.00068651f, 
    -0.09922667f, -0.04659063f, -0.04382375f, 0.03699161f, 0.07141721f, -0.00354672f, -0.05150111f, 0.02223723f, 
    0.00468450f, -0.01477431f, -0.04709264f, 0.06039625f, 0.03959122f, 0.04510701f, 0.01196415f, 0.02553654f, 
    0.03008394f, 0.04700204f, -0.01172868f, -0.21083590f, -0.34045237f, -0.34682864f, -0.08734012f, 0.09113254f, 
    0.05100787f, -0.07799549f, 0.01754562f, -0.09975250f, -0.01718202f, -0.12698792f, -0.02640136f, 0.06218271f, 
    0.11471093f, 0.10920313f, -0.10042451f, -0.10986334f, -0.05739250f, 0.01768309f, 0.00778487f, -0.02922071f, 
    0.01034653f, -0.07833543f, -0.01849379f, -0.04287007f, -0.08003470f, -0.03253561f, 0.14374553f, 0.12464571f, 
    0.05395914f, -0.01217029f, 0.09805874f, -0.04843562f, 0.01573887f, -0.05554408f, -0.02107596f, -0.16785467f, 
    -0.08258030f, -0.22801457f, 0.04867820f, -0.04115236f, 0.04337434f, -0.14795454f, 0.02543213f, 0.07715697f, 
    0.04025412f, 0.00194031f, 0.05210097f, -0.06644963f, -0.25008544f, 0.29874653f, 0.13343363f, -0.21460502f, 
    -0.07265765f, -0.00944114f, 0.01722242f, 0.00411281f, -0.00797769f, -0.11902251f, -0.03288048f, 0.06199984f, 
    0.24528994f, 0.01445766f, -0.20782962f, 0.16011520f, -0.04586220f, 0.09453683f, 0.17896646f, -0.05500472f, 
    -0.00367748f, 0.00301662f, -0.15304327f, -0.00968002f, 0.23187219f, -0.21441685f, -0.11811755f, 0.15495428f, 
    0.10228273f, -0.03802351f, -0.04196990f, 0.07832641f, 0.02281739f, 0.04425274f, -0.01471288f, 0.00485864f, 
    0.02050691f, 0.05226898f, 0.04394407f, 0.20882107f, 0.06805296f, -0.01468762f, 0.10391511f, 0.15330553f, 
    -0.00955437f, -0.01318049f, 0.13217889f, 0.12395693f, 0.25937653f, 0.14629146f, 0.02853911f, -0.05251630f, 
    0.00020589f, 0.09491602f, -0.03775084f, -0.05053258f, 0.02414240f, -0.10546131f, -0.02369435f, -0.04714956f, 
    -0.24047521f, -0.03727304f, 0.19953473f, 0.01147682f, 0.00031303f, -0.00972894f, -0.12621059f, -0.05632536f, 
    0.04059152f, -0.02486708f, -0.02163900f, 0.11911770f, -0.05361716f, -0.09097026f, 0.05902448f, -0.14478894f, 
    -0.08445185f, 0.04513369f, 0.06336338f, -0.02551694f, 0.00172194f, 0.00901068f, -0.00733295f, 0.06329325f, 
    0.18391250f, -0.18980174f, -0.18862647f, 0.09288616f, -0.13005753f, -0.05129464f, 0.05078433f, 0.03068697f, 
    -0.02346734f, 0.05568419f, 0.05427962f, 0.05210256f, -0.06581793f, -0.18288365f, -0.08061164f, 0.21546984f, 
    -0.05444599f, -0.03445600f, 0.04607964f, -0.07757467f, 0.02813358f, 0.04091496f, -0.05596901f, 0.06356066f, 
    -0.10907526f, 0.13647123f, -0.15020664f, -0.28400797f, 0.04150883f, 0.10701559f, -0.00392171f, -0.14707425f, 
    -0.11360039f, -0.09310138f, 0.05390355f, 0.02340662f, 0.04819684f, -0.23674099f, -0.11698949f, 0.07319161f, 
    -0.02669492f, -0.11746706f, 0.09324139f, -0.01090303f, -0.00862946f, 0.08388764f, -0.05625031f, -0.09119046f, 
    -0.11044093f, -0.21674615f, -0.11819497f, 0.20242912f, -0.09444574f, 0.00726851f, 0.10691458f, -0.05039921f, 
    0.04190126f, -0.00669053f, -0.06441411f, -0.13271855f, 0.02369424f, 0.09444942f, 0.03849512f, 0.01261753f, 
    -0.03781952f, -0.02430657f, 0.10470864f, 0.07403692f, 0.05334817f, 0.02948063f, 0.09666382f, 0.01107835f, 
    0.05640694f, 0.03257229f, 0.05903332f, 0.14067008f, 0.00333709f, 0.01771294f, 0.07822262f, 0.04265088f, 
    -0.05291417f, 0.03140000f, 0.11278931f, 0.00931251f, -0.21674269f, -0.03453320f, -0.06503483f, 0.07399099f, 
    0.01664495f, 0.00203993f, 0.02360318f, -0.02343431f, 0.06462023f, -0.08249898f, -0.01770315f, 0.05869117f, 
    -0.02436088f, -0.30416745f, 0.18904820f, -0.12592201f, -0.14398588f, 0.03203819f, 0.07614814f, -0.10893682f, 
    0.03344138f, 0.06687302f, 0.02275280f, -0.02988811f, 0.24043021f, -0.05327353f, -0.06140379f, 0.07229534f, 
    -0.05719322f, 0.06149880f, 0.03424837f, 0.07083596f, 0.01017752f, -0.05327982f, 0.14582983f, -0.04579045f, 
    -0.36368075f, -0.03921612f, 0.15604836f, 0.23775394f, 0.00692844f, -0.00393529f, -0.00597438f, 0.09006637f, 
    -0.11957775f, 0.00566548f, 0.07775531f, -0.01134124f, -0.20714429f, -0.13947810f, -0.05290617f, -0.22915788f, 
    0.01175389f, 0.10549209f, -0.04868938f, 0.06353617f, -0.02692586f, -0.09708466f, -0.00650914f, -0.01181153f, 
    0.03753136f, -0.07938292f, -0.06852920f, 0.07112876f, 0.06834669f, -0.04049379f, 0.05475297f, -0.07913893f, 
    0.03961896f, -0.03663897f, -0.03438589f, -0.01482074f, -0.00902733f, -0.09280489f, -0.04305146f, 0.09410721f, 
    -0.00467625f, 0.03914551f, 0.01643055f, 0.04900626f, -0.02016159f, 0.06411619f, -0.00380423f, 0.07913016f, 
    0.15229447f, -0.03041390f, 0.01100444f, 0.07539018f, 0.03918337f, 0.06159741f, 0.06108040f, 0.07565240f, 
    -0.06636316f, 0.03075956f, 0.05031611f, -0.07681524f, 0.24323799f, -0.05104116f, 0.17773026f, 0.12268264f, 
    -0.07765079f, 0.04035078f, -0.00078773f, -0.04945960f, 0.04601729f, 0.06387310f, -0.09755893f, -0.02593515f, 
    0.25224695f, 0.07581119f, -0.07177310f, -0.11670394f, -0.00320250f, 0.01745619f, 0.03626420f, 0.04594014f, 
    -0.09583283f, -0.08110059f, -0.03999784f, 0.00167587f, 0.05464506f, 0.03992112f, -0.01368056f, 0.18860169f, 
    0.04472841f, 0.07729027f, -0.03809884f, 0.03741050f, 0.03170767f, 0.08796546f, 0.06712921f, 0.02480372f, 
    -0.21087793f, -0.04031562f, -0.01428453f, 0.23793235f, 0.06715992f, -0.08530297f, -0.04248168f, -0.05142295f, 
    -0.15764947f, -0.04276460f, 0.03643232f, -0.00691303f, 0.12229750f, -0.11665064f, -0.03607369f, -0.09578123f, 
    -0.08761986f, -0.11141326f, 0.17745836f, 0.04577985f, -0.02007452f, -0.03222466f, -0.01352739f, -0.03105262f, 
    -0.36850721f, -0.07616000f, 0.01302555f, -0.00068290f, -0.02272300f, -0.03007691f, -0.07848724f, 0.04594140f, 
    -0.03900826f, -0.00709711f, -0.10617118f, -0.07826889f, -0.66066653f, 0.02012479f, 0.01078191f, 0.16748033f, 
    0.06584734f, 0.08498868f, -0.04690253f, 0.13079047f, -0.02937820f, -0.01758055f, 0.05803924f, 0.04394657f, 
    -0.06001776f, 0.10653292f, -0.15260756f, -0.13281031f, 0.01569971f, -0.07598826f, 0.05436713f, 0.08541163f, 
    0.10070350f, -0.06789698f, -0.05133431f, -0.03479658f, -0.22173466f, 0.09967574f, 0.17454457f, 0.20123294f, 
    -0.18839984f, -0.17214777f, 0.12087689f, -0.15139744f, 0.01881085f, 0.00444663f, -0.02591942f, -0.01818361f, 
    0.21629390f, 0.28083676f, -0.19032568f, -0.16425017f, 0.04505651f, -0.07172144f, -0.08732375f, 0.03581832f, 
    -0.10247814f, -0.06958044f, 0.12057967f, -0.06741778f, 0.08016907f, -0.05113272f, -0.10300915f, -0.04713431f, 
    0.02428645f, 0.20236720f, 0.04508957f, 0.05485908f, -0.01856304f, -0.05397584f, 0.00039262f, 0.04803762f, 
    -0.20996930f, -0.09026430f, 0.04930359f, -0.23483525f, 0.00610174f, 0.01928711f, -0.03435810f, -0.17582780f, 
    -0.02032021f, -0.07527264f, -0.10082819f, 0.01233825f, -0.14098211f, 0.18560573f, -0.19729050f, 0.06747295f, 
    -0.04908844f, -0.04883381f, 0.09966726f, 0.04777922f, 0.04700006f, 0.02051075f, -0.00988082f, 0.07503037f, 
    -0.38261163f, 0.07013184f, 0.14219812f, -0.06972630f, 0.08461751f, -0.07103653f, -0.06847461f, 0.01787460f, 
    0.08103783f, -0.13975893f, -0.01939651f, -0.07561228f, -0.07962042f, 0.31080022f, 0.06797247f, -0.08430855f, 
    0.21335663f, -0.05670410f, -0.04055321f, 0.00035360f, 0.02259067f, 0.05732744f, 0.02261638f, -0.03251299f, 
    -0.12364135f, 0.02514385f, 0.03523411f, -0.10957012f, -0.01272347f, 0.11233771f, 0.03962171f, -0.10552358f, 
    -0.02034548f, -0.03573335f, 0.09439473f, 0.06332620f, -0.24127193f, -0.03393432f, 0.20737857f, 0.03420149f, 
    -0.07260850f, -0.04263717f, -0.16084166f, -0.04969013f, 0.01772338f, 0.09521492f, -0.07164829f, 0.06900395f, 
    0.30465734f, 0.10980587f, 0.00074993f, 0.06164499f, 0.02984275f, 0.01790794f, 0.05798221f, 0.08920122f, 
    0.04523207f, -0.09210624f, 0.06266823f, 0.02219511f, -0.19302733f, 0.08543622f, 0.04979069f, 0.21581855f, 
    0.04438715f, 0.00951028f, -0.05126770f, 0.04562198f, -0.03230912f, 0.10576754f, -0.00436423f, 0.04516167f, 
    -0.21915713f, 0.09020396f, -0.04397165f, -0.14847811f, 0.07999876f, -0.04604714f, 0.07513807f, 0.15112695f, 
    0.00701849f, -0.05681304f, 0.01373271f, -0.10762671f, -0.38071373f, -0.00519150f, 0.05041545f, -0.07908499f, 
    -0.03738014f, 0.02094082f, -0.01347021f, -0.01110734f, -0.02918169f, -0.05990504f, -0.13476169f, -0.11910807f, 
    -0.05587732f, -0.12214322f, 0.07524020f, 0.01351889f, -0.13398230f, 0.12160450f, 0.10489744f, -0.03657663f, 
    -0.03749610f, 0.10292066f, 0.11862319f, 0.14453343f, 0.03630852f, -0.06473733f, 0.13011660f, 0.08755398f, 
    -0.04625266f, -0.00860026f, 0.09125189f, 0.05965111f, 0.07632089f, 0.07794637f, -0.02725985f, 0.07000861f, 
    0.02006338f, 0.05934552f, 0.07160361f, -0.09235760f, 0.05465000f, -0.04666578f, 0.08843639f, -0.01216333f, 
    -0.12985973f, 0.05392808f, -0.03590995f, 0.08177502f, -0.58076620f, 0.41081268f, 0.05759832f, 0.07357864f, 
    0.10606496f, -0.13782020f, -0.12352312f, 0.10505372f, -0.03486085f, -0.01822841f, -0.09260742f, 0.01967216f, 
    0.15820916f, 0.08574154f, -0.10347474f, 0.08403993f, -0.06697933f, -0.02373400f, 0.03307012f, 0.10812661f, 
    -0.01832758f, -0.01853886f, -0.00600648f, -0.02787855f, -0.08845711f, -0.04648139f, -0.03313844f, -0.13398348f, 
    0.04218109f, -0.00529821f, -0.02383626f, 0.05322286f, -0.15777619f, 0.01341891f, 0.02405501f, 0.05677475f, 
    0.00431931f, 0.03913612f, 0.04946155f, 0.13072337f, 0.04951093f, 0.03712943f, 0.07154616f, 0.11858372f, 
    0.02361166f, -0.04546795f, -0.00486949f, 0.03470620f, -0.01512732f, -0.05237613f, 0.00671086f, 0.06513809f, 
    0.00862129f, -0.04507623f, -0.02618960f, -0.04054930f, 0.07182780f, 0.09824109f, -0.10725944f, -0.03983624f, 
    0.00831274f, -0.07926220f, -0.14055270f, -0.21427649f, -0.03364077f, -0.04889214f, 0.08638232f, -0.02442406f, 
    -0.07538549f, 0.06431595f, 0.07937641f, -0.08366834f, -0.08305486f, -0.31108013f, -0.21512625f, 0.15998374f, 
    0.01711769f, 0.01186297f, 0.06353538f, -0.09399701f, -0.01932542f, -0.01179229f, -0.02899564f, -0.10023710f, 
    0.07385282f, 0.29633021f, -0.23805763f, -0.27004877f, 0.04094570f, -0.04110358f, 0.07007051f, 0.00674478f, 
    0.03033691f, -0.00858788f, -0.00457143f, 0.10785594f, -0.29737830f, -0.08487310f, -0.06646175f, -0.08440935f, 
    0.03478756f, -0.04486618f, -0.03503168f, -0.02646705f, -0.04864215f, -0.09516520f, 0.07137545f, 0.09493764f, 
    0.13459271f, 0.10249312f, 0.10934702f, -0.26250958f, -0.01253966f, 0.08282259f, 0.03863435f, 0.05012532f, 
    -0.06720998f, 0.11544336f, -0.08584182f, -0.01474775f, -0.20118101f, -0.01414803f, -0.01357628f, 0.14511932f, 
    0.04053016f, 0.09909856f, 0.07744456f, -0.08469349f, 0.04230127f, -0.11282939f, -0.00941368f, 0.01622104f, 
    -0.18179610f, -0.26983592f, 0.03102284f, -0.13332669f, -0.11983642f, 0.05357695f, -0.07548919f, -0.04644730f, 
    0.00916417f, 0.01184272f, 0.02047432f, -0.19711059f, 0.01942209f, -0.01384558f, 0.03110092f, 0.06818348f, 
    -0.02071837f, 0.04183204f, -0.02733401f, 0.12651095f, -0.03028234f, 0.02444638f, -0.04882055f, 0.05393429f, 
    -0.26378176f, -0.12987618f, 0.17258829f, 0.11684697f, -0.10411418f, -0.01076892f, 0.01121408f, -0.10902023f, 
    -0.00166463f, 0.06068483f, 0.07046297f, -0.01109393f, -0.26028576f, 0.13976668f, 0.18651316f, -0.01878172f, 
    0.00076659f, -0.02989033f, -0.10251343f, 0.03014411f, 0.15206294f, -0.09278302f, 0.09690262f, 0.06039060f, 
    -0.13685521f, 0.00670369f, 0.07528280f, 0.22671777f, 0.00231149f, 0.02189592f, 0.06054359f, 0.08473881f, 
    0.07298036f, 0.00237109f, 0.07333595f, 0.01781007f, -0.10506995f, -0.12154007f, 0.14553823f, 0.17072628f, 
    -0.05921163f, -0.04284733f, -0.01267975f, 0.02500989f, 0.10132241f, 0.07988109f, 0.01595291f, -0.09676589f, 
    0.33548653f, 0.35815835f, -0.20369232f, -0.22157255f, 0.04128417f, 0.00609889f, -0.04373763f, 0.13597612f, 
    -0.02964806f, -0.05005476f, -0.01543347f, 0.13773742f, -0.01449075f, 0.01584993f, 0.03965146f, -0.09330627f, 
    0.01548813f, -0.07147207f, -0.02621085f, -0.10869153f, 0.07859927f, -0.02717756f, -0.17150509f, 0.00556250f, 
    -0.01957329f, 0.03272665f, -0.16464528f, -0.02889224f, -0.07975817f, 0.06706487f, 0.04848913f, -0.01208747f, 
    0.09899427f, -0.17095129f, -0.13907051f, 0.01261173f, -0.16931255f, 0.14564958f, -0.00012785f, -0.04947344f, 
    -0.10026525f, -0.01632944f, 0.00004605f, 0.00856371f, -0.09367909f, -0.05587452f, 0.04126063f, 0.02389503f, 
    -0.06101603f, -0.21102244f, -0.23098019f, 0.02406698f, 0.12547024f, 0.16905069f, -0.08112353f, -0.03353295f, 
    0.06955901f, 0.04794728f, -0.02890353f, -0.01304762f, -0.07232817f, 0.05105464f, 0.15859739f, -0.03114551f, 
    0.02087447f, 0.05362742f, 0.05163011f, -0.03373940f, 0.16055134f, 0.01448186f, -0.06292813f, 0.07648909f, 
    0.02187867f, 0.00244044f, 0.09444214f, -0.00087826f, 0.03125546f, -0.07687088f, 0.04214988f, 0.01259000f, 
    -0.06640542f, -0.18668489f, 0.11187998f, 0.06901454f, -0.11216284f, 0.15588710f, -0.07881282f, 0.10006981f, 
    0.00267994f, -0.02707304f, 0.08220366f, 0.00745840f, -0.02960242f, 0.05243028f, 0.04278119f, -0.07841523f, 
    0.09968384f, 0.11978682f, 0.26143083f, -0.11939327f, 0.06752185f, 0.05663245f, -0.00298054f, -0.03812763f, 
    -0.02450247f, 0.03893252f, 0.03233599f, 0.10278111f, 0.08509708f, 0.03672315f, 0.03181300f, -0.02263908f, 
    0.06312449f, -0.14646800f, 0.03044329f, 0.04968586f, -0.16815975f, -0.03539157f, 0.09342126f, 0.14872520f, 
    -0.11027966f, -0.18569823f, 0.07403128f, 0.01351542f, -0.13238138f, -0.04832817f, -0.09200642f, 0.07592966f, 
    -0.04853036f, 0.03374441f, -0.09150745f, -0.02150390f, 0.05708534f, 0.10174555f, -0.05594853f, -0.14478435f, 
    -0.05991884f, 0.11293912f, -0.03522768f, -0.07880052f, 0.09144042f, -0.26237702f, -0.06691375f, 0.17258556f, 
    -0.01810483f, 0.04431577f, 0.07042442f, -0.12707295f, 0.05498415f, -0.04969609f, -0.00096743f, 0.04433744f, 
    0.03612050f, 0.05975284f, 0.03953301f, 0.11961218f, 0.05187773f, 0.00475972f, 0.09953182f, 0.04163008f, 
    -0.05191406f, -0.14193025f, -0.02303782f, -0.08467884f, -0.07729302f, 0.15074411f, 0.10429287f, 0.15036784f, 
    -0.16913354f, -0.11809535f, 0.05670697f, 0.08705363f, 0.06017042f, -0.07765316f, -0.06480229f, -0.06884676f, 
    0.12533243f, 0.04259928f, -0.04262485f, 0.08727012f, -0.43360218f, -0.17298651f, -0.07210881f, -0.08010721f, 
    0.04144281f, -0.09367333f, -0.09987174f, 0.00430645f, -0.00441174f, 0.12272064f, 0.01871620f, 0.11083704f, 
    -0.03705197f, 0.10896702f, 0.01367995f, 0.07570203f, -0.08802567f, -0.19134133f, 0.07371134f, 0.14592122f, 
    -0.00102988f, 0.01257907f, 0.09549347f, -0.00726532f, 0.00447826f, 0.17890173f, 0.06737280f, -0.06873822f, 
    0.12152106f, -0.11408050f, 0.12791309f, -0.20844963f, -0.02688071f, 0.04947067f, -0.23335251f, -0.07829615f, 
    -0.11600833f, 0.00379940f, -0.25909692f, -0.09081397f, -0.04748911f, 0.11528850f, -0.08755989f, -0.03190398f, 
    0.01018785f, 0.03553958f, -0.00689102f, -0.00859953f, -0.20256354f, -0.20121969f, -0.15825890f, -0.07950770f, 
    0.05662964f, 0.08505996f, 0.26175833f, -0.09260648f, -0.01913381f, 0.03468545f, -0.10291309f, 0.01109049f, 
    0.03338623f, -0.09502237f, 0.02603679f, -0.10876005f, 0.09423190f, -0.01742120f, -0.09944192f, -0.00897503f, 
    -0.03556921f, 0.09902724f, 0.05002163f, 0.06223764f, 0.08677831f, 0.03605209f, 0.06477582f, 0.13511255f, 
    0.10088301f, -0.08510911f, 0.10766217f, -0.06089161f, 0.10142078f, 0.04230145f, -0.00674823f, 0.05216948f, 
    -0.16022579f, -0.09507025f, -0.14653763f, 0.08989245f, 0.04244075f, -0.15039976f, -0.01856621f, -0.11971688f, 
    -0.04205297f, 0.12272554f, -0.11134434f, 0.17725822f, -0.03400001f, -0.04688150f, 0.03341320f, -0.51932639f, 
    -0.07300606f, -0.01631633f, -0.06473444f, 0.03140894f, 0.06794714f, -0.00552816f, 0.09806681f, -0.05456959f, 
    -0.08420198f, -0.08116283f, 0.08918741f, 0.23565836f, 0.13921149f, 0.02235280f, 0.07974891f, 0.04682513f, 
    -0.00035223f, -0.25918883f, -0.03971668f, -0.03308724f, -0.12363251f, 0.00935669f, -0.10438769f, -0.00945545f, 
    -0.06375515f, -0.08142355f, 0.00264925f, -0.06534006f, 0.00738432f, -0.08988935f, -0.17335857f, -0.06850075f, 
    0.28031760f, 0.08712777f, -0.04421448f, -0.18216856f, 0.02136043f, -0.03592071f, -0.00031044f, -0.07449012f, 
    0.02253914f, -0.02608362f, -0.09711014f, -0.14980979f, 0.04233862f, -0.14783645f, 0.06582007f, 0.05514033f, 
    0.14645270f, 0.14119783f, -0.01298816f, 0.07883308f, 0.08026543f, 0.08349092f, 0.03176194f, 0.00102500f, 
    -0.06374530f, 0.01053074f, -0.08120964f, -0.04132921f, -0.01375903f, -0.03659229f, -0.14848481f, 0.11438341f, 
    0.07721891f, -0.04073051f, 0.09588005f, -0.01993430f, -0.39568514f, 0.05974029f, -0.26782796f, -0.02945276f, 
    0.10443536f, 0.00022637f, -0.00269738f, -0.09855363f, 0.03731211f, 0.09850410f, -0.10541245f, 0.05453910f, 
    -0.36926401f, -0.19680150f, -0.00895943f, -0.05630887f, 0.05274133f, -0.02218852f, -0.02822471f, -0.01889518f, 
    -0.00513476f, -0.05359134f, -0.05677936f, 0.08335726f, 0.08759929f, -0.03439650f, 0.05899976f, 0.30218810f, 
    -0.09620924f, -0.16511348f, -0.05175576f, 0.09073676f, 0.04003733f, 0.08247436f, -0.06411570f, 0.02364147f, 
    -0.29830644f, -0.28399718f, 0.28188327f, 0.15505557f, 0.06147751f, -0.02419797f, 0.10451883f, -0.01086114f, 
    -0.01278383f, 0.17391822f, 0.04592317f, -0.04857882f, 0.09571055f, 0.00846247f, -0.05695432f, 0.09974150f, 
    0.04727717f, 0.09824574f, 0.06657832f, 0.12433093f, -0.18961670f, 0.00775371f, -0.19441830f, -0.06698468f, 
    -0.14416815f, 0.09269582f, 0.13588516f, -0.00179212f, 0.05429232f, -0.13375771f, -0.08643810f, 0.13716629f, 
    0.00654943f, -0.03433171f, -0.18293206f, -0.33210021f, -0.14273667f, 0.28289598f, 0.10112087f, -0.25494906f, 
    0.14759250f, -0.02244531f, -0.05758854f, -0.10398668f, -0.01261246f, -0.16525339f, -0.04559247f, -0.12749134f, 
    -0.02498751f, -0.04314508f, 0.05025857f, 0.01627385f, -0.07656086f, 0.10644452f, 0.03239952f, -0.08506705f, 
    -0.04774191f, 0.20465608f, 0.01315315f, 0.20463723f, -0.08592465f, -0.03082861f, 0.10556851f, 0.07000860f, 
    -0.00210439f, 0.05070417f, -0.05364521f, 0.15676266f, 0.02882244f, -0.00557492f, -0.00861273f, -0.10536218f, 
    0.05835996f, 0.18430498f, -0.07480623f, 0.02635078f, -0.03147905f, -0.05909951f, -0.05451142f, -0.04082677f, 
    -0.16792609f, 0.01992225f, 0.00609654f, -0.29557776f, 0.18171416f, 0.03676244f, 0.07569113f, -0.08125257f, 
    0.00603281f, -0.06281655f, 0.08746931f, 0.03368322f, -0.00647553f, -0.05106368f, -0.17457882f, 0.04125646f, 
    -0.02478823f, 0.15487020f, 0.09171765f, 0.00566219f, -0.06772635f, -0.10603005f, 0.03187398f, -0.08449161f, 
    0.06819774f, 0.00304537f, 0.00496100f, 0.03406662f, -0.32191616f, -0.00242538f, -0.30702174f, -0.03927462f, 
    0.07969302f, 0.03585253f, -0.00115487f, -0.07274417f, 0.08152872f, -0.17201750f, 0.05410222f, -0.05373530f, 
    -0.14347474f, 0.05252761f, -0.07055002f, 0.07093923f, 0.00166094f, -0.24442708f, -0.14065599f, 0.03775837f, 
    0.13184687f, 0.00831228f, 0.02308089f, 0.04870671f, 0.04543913f, -0.07082369f, 0.14504258f, 0.05895522f, 
    -0.03298111f, 0.06160346f, 0.04260636f, -0.00687390f, -0.04266660f, 0.06569601f, 0.07424381f, 0.14420485f, 
    0.07858983f, -0.03752027f, 0.07343996f, 0.10140751f, -0.00750471f, -0.03295103f, 0.01520613f, 0.04595146f, 
    -0.00241842f, -0.03466463f, -0.12364071f, 0.04795856f, -0.01596200f, -0.04999827f, -0.06449980f, -0.00583199f, 
    0.03622620f, 0.04320621f, -0.11837640f, 0.06206540f, -0.01374909f, 0.01024984f, 0.14038813f, 0.05965841f, 
    0.04804594f, -0.11591598f, 0.02500807f, 0.14246798f, 0.02469651f, -0.08792721f, 0.01879915f, 0.06152892f, 
    0.06424260f, -0.04796925f, 0.07872111f, 0.03351630f, -0.70540446f, 0.03530191f, -0.16299248f, -0.11809903f, 
    0.11224131f, 0.12075976f, 0.03675539f, 0.00955916f, 0.02341380f, 0.04553778f, 0.02350354f, -0.09303834f, 
    0.03929785f, 0.02300809f, 0.20598496f, -0.07750000f, -0.00981665f, 0.10224287f, 0.03540781f, -0.04068640f, 
    0.03171386f, -0.05835376f, -0.05358994f, 0.08445893f, -0.10909290f, -0.06170391f, -0.01321325f, -0.10597125f, 
    0.04672990f, -0.02232543f, 0.07866104f, -0.00513536f, -0.00915321f, -0.02115069f, 0.08597139f, 0.11809055f, 
    -0.00441739f, 0.08531210f, 0.11596096f, 0.06117370f, -0.07113907f, -0.15882432f, 0.01357422f, -0.03188924f, 
    0.04731695f, 0.14460380f, 0.12370386f, 0.17355406f, -0.13651910f, 0.01952977f, 0.10066912f, -0.12461612f, 
    0.06735183f, -0.07478431f, 0.03066710f, -0.04623325f, 0.07233605f, -0.14085679f, -0.04514955f, -0.02791655f, 
    -0.29082799f, 0.15842183f, 0.09448170f, -0.36918509f, -0.00287202f, 0.08213899f, -0.00913897f, 0.00058155f, 
    0.07718531f, 0.01285834f, -0.03405799f, 0.12110487f, -0.03975905f, 0.11829817f, 0.01794798f, -0.04389648f, 
    -0.04514742f, -0.03768589f, -0.12643073f, -0.04978509f, 0.11461329f, 0.14539294f, -0.04457318f, 0.00908938f, 
    -0.20404544f, -0.09878805f, 0.28061789f, -0.04153704f, -0.00521520f, 0.01872306f, -0.03042683f, -0.12693815f, 
    -0.01902356f, -0.06918123f, 0.05244116f, -0.14045602f, -0.02476300f, 0.05115357f, -0.07573490f, 0.05433026f, 
    0.15964599f, 0.13523781f, -0.05968431f, -0.04329289f, 0.11442201f, -0.06307531f, 0.09748349f, -0.02659891f, 
    -0.29292369f, -0.30756879f, 0.14021899f, 0.12996720f, -0.05397933f, -0.02494101f, -0.00510257f, 0.02239626f, 
    -0.07981006f, -0.05743360f, 0.15246305f, -0.01018688f, 0.27834338f, 0.10756624f, 0.06628115f, -0.18331295f, 
    0.06233719f, 0.03390282f, -0.27470317f, -0.11816034f, -0.05637572f, 0.03636740f, -0.02198126f, 0.04905507f, 
    0.04654232f, 0.02468608f, 0.02618843f, -0.04100846f, -0.01421262f, 0.17648874f, 0.08354360f, -0.04363628f, 
    -0.13743979f, 0.06055891f, 0.01495181f, 0.05651827f, -0.11817013f, -0.07334449f, 0.05900169f, 0.15787300f, 
    0.10267441f, 0.07982678f, 0.14457455f, 0.04034978f, 0.10196526f, -0.00155639f, -0.09793362f, -0.14133027f, 
    0.02043717f, 0.00281421f, 0.01771120f, 0.22883509f, -0.33311567f, -0.01377010f, -0.06353047f, -0.06419335f, 
    -0.04591421f, -0.18339159f, 0.06810128f, 0.12065634f, 0.11276996f, -0.02275051f, 0.10655694f, 0.07935035f, 
    -0.00185953f, 0.03165164f, -0.10096923f, 0.06621432f, -0.12089960f, -0.03323100f, 0.00672492f, 0.00900442f, 
    0.06945171f, -0.00706783f, -0.22654541f, -0.12700464f, -0.00680618f, 0.05085608f, -0.01415432f, -0.27522209f, 
    -0.02115159f, -0.12756139f, -0.01588573f, -0.14085895f, 0.11074404f, 0.11902990f, 0.12665936f, -0.08644168f, 
    0.02004453f, -0.00770720f, -0.07593640f, -0.03644818f, -0.12391026f, -0.09755422f, 0.04090326f, 0.13803357f, 
    -0.04766281f, 0.07985763f, 0.31636956f, 0.16795062f, 0.04554918f, 0.04751243f, -0.01988911f, -0.08683125f, 
    0.07277150f, -0.08314966f, -0.10259777f, -0.05605927f, -0.39863503f, -0.18524525f, 0.01440420f, 0.06809267f, 
    -0.06331605f, -0.04012786f, 0.05529282f, -0.05342116f, 0.02638751f, -0.01365577f, 0.11828532f, -0.01809687f, 
    -0.15360340f, -0.03018395f, 0.01851677f, -0.00887386f, 0.10333481f, -0.03918457f, -0.04827789f, -0.07634408f, 
    0.05582691f, 0.04215646f, 0.08460928f, 0.15116227f, 0.00327141f, -0.14771274f, 0.11421962f, 0.09542807f, 
    0.06553184f, 0.04755170f, 0.13516355f, 0.06757032f, 0.13353166f, 0.10250584f, -0.03965848f, 0.03347643f, 
    -0.33384791f, 0.01370848f, -0.20427431f, -0.09764422f, -0.14164527f, -0.10617843f, 0.06218773f, -0.09047480f, 
    0.11382067f, -0.02768151f, -0.02923415f, 0.13458751f, -0.20144458f, 0.12826417f, -0.07762520f, 0.08115838f, 
    -0.05360023f, 0.02980172f, -0.16577089f, 0.04677645f, -0.03762654f, -0.02412516f, 0.12143227f, -0.09326412f, 
    0.26164588f, 0.02740085f, -0.05201790f, -0.09518619f, 0.02753439f, 0.13101003f, 0.04278884f, 0.10013082f, 
    0.11422703f, 0.02554371f, -0.09432998f, -0.04082367f, -0.40701208f, 0.09711787f, -0.01007608f, 0.13852642f, 
    0.12844709f, -0.01428860f, -0.01065602f, -0.15597019f, -0.05429281f, -0.05840867f, 0.09177773f, -0.05069681f, 
    -0.36929828f, 0.13475478f, 0.22076581f, -0.04457542f, -0.16964877f, -0.02371325f, 0.04284829f, 0.03509544f, 
    0.02074327f, -0.01391814f, -0.05109178f, -0.04711438f, -0.04940940f, 0.12268067f, -0.07081662f, -0.04159851f, 
    -0.01558161f, 0.12288824f, -0.05502645f, -0.03409853f, -0.03677492f, -0.03863321f, 0.00284839f, 0.01682660f, 
    0.02831888f, -0.13610089f, 0.02415344f, 0.15056391f, 0.05724292f, 0.04879696f, -0.09598882f, 0.02806664f, 
    0.11020010f, -0.04819258f, -0.05811283f, 0.17429316f, -0.25439587f, 0.13999215f, 0.05554730f, 0.07374973f, 
    0.10929292f, -0.03095235f, -0.00940982f, 0.07021336f, 0.00716803f, 0.15829639f, 0.07164162f, -0.09117576f, 
    0.28183809f, 0.16814016f, 0.13846894f, -0.30533594f, -0.10693683f, 0.05443798f, 0.02478580f, -0.02790194f, 
    0.00934259f, -0.04415038f, -0.02017064f, -0.06937587f, -0.03061606f, 0.11706747f, 0.08664973f, -0.07926623f, 
    -0.07136899f, 0.03502512f, 0.05754055f, 0.12692595f, -0.08325633f, -0.22038554f, 0.04874482f, -0.18357377f, 
    0.01653282f, -0.02735470f, -0.22049537f, -0.07315364f, -0.08173120f, 0.03657883f, -0.01153790f, 0.05542710f, 
    -0.06032751f, -0.07445858f, -0.06813546f, -0.03574869f, -0.28484860f, 0.00998955f, -0.04562007f, -0.01318955f, 
    -0.02676436f, 0.06208526f, 0.04206619f, -0.01254437f, 0.10763324f, -0.15309891f, 0.04949904f, -0.07753975f, 
    -0.24891081f, -0.04580863f, -0.13519990f, 0.32004973f, 0.02642872f, 0.10741502f, -0.08521056f, 0.05145120f, 
    0.00471740f, -0.04170572f, -0.15394780f, -0.06700303f, -0.02549104f, -0.20064819f, -0.01624693f, -0.09973338f, 
    -0.04353466f, -0.04553389f, 0.01718851f, 0.13449846f, -0.01779712f, -0.01271185f, 0.10778310f, 0.02488459f, 
    -0.29378676f, -0.16261433f, -0.14535210f, -0.24570934f, 0.09534977f, -0.01296980f, 0.11726215f, -0.11999747f, 
    -0.00843558f, -0.06252295f, 0.07526371f, 0.10510828f, -0.04798188f, -0.19991100f, 0.02951591f, -0.23175098f, 
    -0.11692346f, 0.03402949f, -0.01921432f, -0.14341469f, 0.08094794f, 0.00461937f, -0.00917915f, 0.01534136f, 
    -0.05585350f, 0.20564045f, 0.04544151f, -0.10482420f, -0.00724455f, 0.01543617f, 0.05980003f, 0.04854362f, 
    -0.00287409f, -0.01409810f, 0.03926830f, 0.00508504f, -0.19117555f, 0.21055730f, -0.00819069f, -0.03839058f, 
    -0.02961473f, 0.07955185f, 0.07917465f, 0.17508276f, 0.00196106f, 0.03838115f, -0.00746946f, -0.01537542f, 
    0.01996135f, -0.00863458f, -0.28934449f, 0.13659054f, -0.04899424f, -0.00298432f, 0.15585712f, 0.00692884f, 
    0.03901704f, -0.17669360f, 0.09068365f, -0.07819144f, -0.06113992f, 0.26838639f, 0.07392164f, -0.25728706f, 
    -0.01959247f, 0.08325297f, 0.04323656f, -0.00243067f, -0.19735959f, -0.06294597f, 0.01808603f, -0.01295638f, 
    0.06497245f, -0.05214279f, -0.22407761f, 0.09335096f, -0.22585078f, -0.07007611f, -0.06531826f, -0.09285346f, 
    -0.22131389f, 0.08465834f, 0.05795931f, -0.06707729f, -0.13073720f, -0.00834748f, 0.05416698f, 0.00514599f, 
    0.00456168f, 0.03712573f, -0.06633978f, 0.05010799f, 0.03283888f, 0.13706316f, 0.12236568f, -0.02200858f, 
    -0.26001844f, 0.04616228f, -0.03469007f, 0.02940674f, -0.02387748f, 0.07732292f, 0.01481496f, 0.12197939f, 
    0.04417009f, -0.03075485f, 0.03691001f, 0.14600055f, -0.04347797f, 0.05747975f, -0.05129422f, 0.17866157f, 
    -0.11509445f, -0.13540000f, 0.01491386f, -0.13111718f, 0.00816384f, -0.19833124f, -0.04379904f, -0.00656177f, 
    0.27155969f, -0.10015801f, 0.27977663f, -0.15378486f, 0.07738481f, 0.06004760f, 0.13857262f, 0.03163037f, 
    -0.01590280f, 0.05074539f, -0.05389060f, -0.01562162f, 0.00927077f, -0.38126743f, -0.03485825f, -0.20021081f, 
    0.01561661f, -0.02033762f, 0.02682450f, -0.07293929f, -0.02101612f, -0.07524721f, 0.10905349f, 0.01903378f, 
    0.13498190f, -0.03277544f, 0.09353343f, -0.00906382f, -0.06255589f, -0.08290946f, 0.03861217f, 0.04263806f, 
    0.04414910f, 0.06896079f, 0.03908140f, -0.11712264f, -0.09694369f, -0.12558886f, 0.02429536f, -0.05607062f, 
    0.15148720f, -0.00910100f, -0.00243676f, 0.06153048f, -0.10857897f, -0.01556278f, -0.00911551f, 0.03013215f, 
    0.08288424f, -0.18057050f, -0.08220556f, 0.20644704f, -0.00672053f, 0.09764927f, 0.01302004f, 0.02522577f, 
    -0.03424289f, -0.06743231f, -0.17124750f, -0.08668415f, -0.13425367f, -0.06353416f, 0.08303960f, -0.16304490f, 
    0.03250805f, -0.10849448f, 0.05026977f, -0.08396694f, 0.03437561f, 0.02546977f, 0.09334965f, 0.18759237f, 
    0.17154895f, 0.04755840f, 0.01668217f, -0.11606532f, -0.06157009f, -0.03744022f, 0.06262773f, 0.02580559f, 
    -0.01097365f, -0.01518508f, 0.10118082f, 0.18828312f, 0.14537083f, -0.40740395f, 0.13949363f, -0.03058707f, 
    0.01114915f, -0.02250429f, -0.05511405f, 0.11198976f, 0.06962787f, -0.01876700f, 0.05963873f, 0.07621426f, 
    0.12789333f, -0.03516151f, -0.10617302f, -0.16333188f, -0.01553258f, 0.04409164f, 0.03237555f, -0.02039718f, 
    0.11325049f, -0.11880880f, 0.00466938f, -0.25967661f, 0.14109223f, -0.06568074f, 0.04576571f, -0.22972521f, 
    -0.08283200f, -0.00308565f, -0.09602093f, 0.01184585f, 0.03150422f, 0.06477664f, -0.07179971f, 0.02074734f, 
    0.29923332f, -0.23778312f, -0.01342690f, -0.03835707f, 0.12324884f, -0.00054953f, 0.02486196f, -0.06776328f, 
    0.02552148f, 0.03262822f, -0.06407654f, 0.21388397f, 0.16404383f, 0.08076532f, -0.12241088f, -0.06429649f, 
    0.08586062f, 0.12401327f, 0.01481365f, -0.04998366f, -0.06069413f, -0.02713702f, 0.03786570f, 0.04661747f, 
    -0.11147110f, -0.06984996f, -0.12722994f, -0.21290462f, 0.01375143f, 0.05815164f, -0.02094859f, 0.05604608f, 
    0.05807378f, -0.02185683f, 0.02937824f, -0.03019725f, -0.13388768f, -0.10578964f, -0.06277398f, -0.23750778f, 
    -0.08194582f, -0.03152584f, -0.10728320f, 0.02521026f, 0.00075134f, 0.18361229f, -0.07535870f, 0.15291394f, 
    0.29641786f, -0.12815271f, 0.27698928f, 0.11339541f, -0.06502903f, 0.02387179f, 0.09653445f, -0.07174975f, 
    -0.10913984f, 0.00186472f, 0.07382419f, -0.11033889f, 0.20784700f, 0.13616891f, 0.14689583f, -0.20597312f, 
    0.01540171f, -0.02975614f, -0.03901402f, -0.00832070f, -0.00486919f, -0.09717187f, -0.02977193f, -0.17887616f, 
    -0.12369499f, -0.02804938f, 0.02193256f, -0.02672064f, 0.06532902f, 0.03652790f, -0.13985017f, -0.00548931f, 
    0.00582530f, 0.01839324f, 0.00886261f, 0.06981687f, -0.04377164f, 0.15043941f, 0.13643338f, -0.17818783f, 
    0.05043077f, -0.06214180f, 0.01496363f, 0.01195199f, 0.04554534f, -0.09311158f, 0.04990844f, 0.05369311f, 
    -0.05875400f, -0.06767629f, -0.00995047f, 0.09832385f, 0.00664354f, 0.02937792f, -0.04547695f, -0.09971689f, 
    -0.07325076f, 0.02682412f, 0.04371736f, -0.05359317f, 0.28137246f, -0.15007111f, 0.06780466f, -0.14253013f, 
    -0.02071092f, 0.07189544f, 0.09283325f, -0.15699708f, -0.03854441f, -0.02945758f, 0.16818240f, 0.03032190f, 
    -0.10061342f, 0.07826915f, 0.22041339f, -0.09408668f, -0.02512328f, -0.15672950f, 0.04002745f, 0.01204027f, 
    -0.01495223f, 0.05257897f, 0.09009648f, -0.03834587f, 0.15032437f, -0.19000562f, 0.08949353f, -0.10034460f, 
    0.05331464f, -0.02870596f, 0.05758839f, 0.10835511f, 0.08532879f, -0.04622037f, -0.02935603f, -0.04096026f, 
    -0.17487235f, -0.01860558f, -0.05117849f, 0.07607266f, -0.01116106f, 0.09983736f, -0.01056380f, -0.04744390f, 
    -0.05802169f, -0.26094478f, -0.08419103f, -0.07900913f, -0.06852882f, 0.12571867f, 0.12803502f, 0.01159219f, 
    -0.04432816f, 0.00168211f, -0.14859414f, 0.00266430f, -0.07787286f, 0.04090390f, 0.16340712f, 0.15485060f, 
    0.18496364f, -0.27176949f, 0.13673653f, 0.06425531f, -0.04341798f, 0.02650817f, 0.10555429f, 0.03870142f, 
    0.17293040f, -0.01376814f, -0.00503206f, -0.06638029f, -0.12276777f, 0.01498006f, -0.19551206f, 0.06691826f, 
    -0.01606255f, 0.03776845f, 0.02284955f, 0.02056549f, 0.06571047f, -0.09177741f, 0.02719786f, 0.03555550f, 
    0.29655632f, -0.20965964f, -0.05499419f, -0.20060511f, -0.06588074f, 0.12137911f, 0.01056713f, 0.03747606f, 
    0.07366990f, 0.09756134f, 0.03791688f, 0.14884123f, -0.04362864f, -0.10981207f, 0.14245433f, -0.11761378f, 
    -0.05446336f, -0.02435299f, 0.11464988f, -0.13485466f, -0.06308753f, 0.08368614f, 0.12915657f, 0.06633746f, 
    0.25491625f, -0.09094412f, 0.06056718f, 0.05866041f, -0.04320867f, -0.17042041f, -0.02528055f, 0.06759311f, 
    0.00107559f, -0.09483439f, -0.04610109f, -0.02726232f, -0.21324240f, -0.04165753f, 0.00709135f, 0.07956671f, 
    -0.14176133f, -0.06583303f, 0.10107679f, 0.10877889f, 0.05031147f, -0.05362216f, -0.04004154f, -0.05290155f, 
    -0.10991388f, 0.29938674f, 0.07948466f, 0.19298622f, 0.06489509f, -0.18508585f, -0.07764373f, 0.00882798f, 
    0.22154808f, -0.03856146f, -0.02431537f, -0.25287694f, 0.22115242f, -0.02917175f, -0.15864617f, -0.20463158f, 
    -0.05633532f, -0.03654827f, -0.07683752f, 0.07534268f, -0.14609146f, 0.16571142f, -0.01636254f, 0.09549169f, 
    -0.04772584f, 0.09950086f, -0.02250316f, -0.13546853f, 0.02511847f, -0.01779951f, -0.05450324f, 0.06923450f, 
    -0.02682955f, 0.03933413f, -0.14252529f, 0.06567118f, 0.00626707f, 0.05970748f, 0.04236981f, -0.26922327f, 
    0.14046568f, -0.12603810f, 0.00917917f, 0.04480438f, -0.05631173f, 0.03787033f, -0.00025275f, -0.04171695f, 
    -0.11355586f, -0.23586507f, -0.14264002f, 0.20881687f, 0.00329778f, 0.11577511f, 0.00986861f, 0.05204054f, 
    -0.01749110f, 0.11112710f, 0.03124105f, 0.16187410f, 0.10285039f, 0.10904039f, -0.03650422f, -0.11732645f, 
    -0.12304627f, 0.00645394f, 0.05617475f, -0.01866410f, 0.02636302f, -0.00231768f, -0.08595645f, -0.15191823f, 
    0.11711755f, -0.22867812f, -0.16032790f, 0.15755834f, -0.08704656f, -0.06566157f, 0.06833951f, 0.08061840f, 
    -0.02644217f, 0.01555824f, 0.05766487f, -0.00273768f, 0.22228087f, -0.05378353f, -0.03100982f, 0.18723331f, 
    -0.07652602f, 0.07834099f, 0.00845509f, -0.06086147f, -0.16469745f, 0.05536645f, -0.13773537f, -0.06461433f, 
    0.07293944f, 0.00724981f, 0.17179911f, -0.39894646f, -0.13013566f, 0.03995036f, 0.06784315f, -0.03866533f, 
    0.03872787f, 0.07900898f, -0.06690758f, -0.09282773f, 0.00699517f, 0.06291368f, -0.02731087f, -0.13041015f, 
    -0.00930110f, -0.06280543f, -0.00273578f, 0.02372878f, 0.02866908f, -0.12398903f, 0.06823727f, 0.06829915f, 
    0.09276568f, 0.16307725f, 0.13453254f, 0.20189677f, 0.08380217f, 0.06486072f, 0.10066522f, -0.03647756f, 
    -0.02282180f, -0.01293834f, -0.04802289f, -0.06752355f, -0.37421963f, 0.16152050f, -0.10625494f, -0.04312957f, 
    -0.00919591f, 0.02062168f, -0.05001413f, -0.06376448f, -0.01846474f, -0.01256214f, -0.02729953f, 0.00490843f, 
    0.13507968f, -0.24594790f, 0.05461457f, -0.04818529f, -0.02848649f, 0.03457202f, -0.02725853f, -0.04784384f, 
    0.01558624f, 0.02021991f, -0.08651453f, -0.05951693f, 0.02892309f, 0.03632190f, 0.02103078f, -0.00117308f, 
    -0.13509133f, 0.00652604f, 0.03227011f, -0.08397678f, 0.03141420f, -0.07535369f, 0.12105693f, 0.01949384f, 
    -0.01886231f, 0.17284910f, -0.01892876f, 0.01244087f, -0.01713757f, 0.03692727f, -0.03716869f, 0.00542795f, 
    -0.09534460f, 0.01579102f, -0.01020589f, -0.12019634f, 0.03664645f, -0.06004181f, -0.06192373f, 0.04445709f, 
    0.03728826f, -0.04110069f, -0.08843479f, 0.02180750f, -0.01410801f, 0.01323773f, -0.01453163f, -0.03439151f, 
    -0.30694345f, 0.09388830f, -0.01350074f, 0.00541388f, -0.02607412f, -0.07830068f, 0.02716877f, 0.04243527f, 
    -0.06262836f, -0.08773955f, -0.02591749f, -0.01879645f, -0.05765874f, 0.06373697f, -0.03859410f, -0.27619272f, 
    -0.04184534f, 0.07238460f, -0.02071869f, -0.02055034f, -0.06655348f, 0.10753464f, -0.00249227f, -0.11060482f, 
    -0.13357012f, -0.02220724f, -0.24172620f, -0.07592621f, 0.02276309f, -0.00100313f, 0.03372616f, -0.05964509f, 
    -0.06526461f, -0.08299194f, 0.01713502f, -0.02181057f, -0.12860675f, 0.03566878f, -0.02757858f, 0.07840291f, 
    -0.00452625f, 0.01317838f, 0.01347547f, -0.01586918f, 0.00874472f, -0.04518880f, -0.03898208f, 0.03979475f, 
    0.01217730f, 0.13511923f, 0.02707003f, 0.15930419f, 0.03889247f, 0.04902155f, -0.04461558f, 0.00094058f, 
    -0.01379708f, -0.04017336f, 0.01893508f, -0.08812407f, 0.22454569f, -0.06725774f, 0.17647211f, 0.11193917f, 
    -0.00306248f, 0.02615913f, -0.02646430f, -0.00042062f, -0.05257789f, -0.03548046f, -0.15006541f, -0.05833931f, 
    0.00291699f, -0.15614778f, -0.02924364f, 0.10425565f, 0.07756410f, -0.06228885f, -0.05936733f, 0.02048283f, 
    -0.07764429f, -0.06216860f, -0.00293338f, -0.04556193f, -0.08253907f, -0.03742629f, -0.06576242f, -0.10122879f, 
    -0.03653085f, -0.02311112f, -0.07495866f, -0.05654019f, 0.01803868f, -0.03198216f, -0.01645274f, -0.09591249f, 
    0.08317094f, 0.14604221f, 0.14687796f, 0.10652463f, 0.02570217f, 0.02864502f, 0.12285341f, -0.05523317f, 
    0.03817256f, 0.04832796f, 0.00033176f, -0.06140268f, 0.07994114f, 0.12007739f, 0.14575984f, 0.18735223f, 
    0.11653165f, 0.01474517f, 0.00526251f, 0.05715159f, -0.02103582f, -0.00756675f, 0.02527294f, -0.06619030f, 
    0.18368238f, 0.03667989f, 0.00021084f, -0.15630308f, -0.09698226f, -0.01746467f, 0.02910604f, -0.03927610f, 
    -0.02221552f, -0.02192635f, -0.01325161f, -0.08261707f, 0.03001763f, 0.08477432f, -0.10707077f, 0.01550199f, 
    -0.00651341f, 0.04956819f, -0.02146550f, -0.03765945f, -0.11494302f, -0.00966117f, 0.01725935f, 0.03316446f, 
    0.07573599f, 0.15430826f, 0.00124040f, 0.10439066f, 0.04862715f, -0.05084164f, 0.01606389f, -0.06604388f, 
    0.06022494f, 0.00670720f, -0.03362033f, -0.02640918f, -0.30063507f, 0.00845431f, -0.04275572f, -0.18967402f, 
    0.08413708f, -0.01334193f, -0.06171804f, -0.00759967f, -0.05884218f, -0.00110518f, 0.04517731f, -0.05378227f, 
    0.09117638f, 0.17629267f, -0.06195628f, 0.17862265f, 0.08391619f, -0.02658825f, -0.01377431f, -0.01215941f, 
    0.00516222f, 0.01430171f, -0.07380574f, -0.08792754f, 0.05501714f, 0.10809933f, 0.04354979f, 0.01808861f, 
    -0.03784469f, 0.02768984f, -0.05598929f, -0.01622393f, 0.01707894f, 0.06245571f, -0.04736894f, -0.10934839f, 
    -0.05204618f, 0.03284303f, -0.07214358f, -0.09381370f, -0.04057669f, 0.00650354f, -0.03171169f, -0.03982480f, 
    -0.01694177f, 0.01775097f, -0.11372008f, -0.07591102f, 0.12862609f, 0.11093678f, -0.03192984f, 0.10954839f, 
    0.04275509f, -0.02382681f, -0.05503709f, -0.03212854f, -0.07045881f, -0.04402336f, -0.04081754f, -0.01826199f, 
    0.38684294f, 0.19812343f, -0.03690641f, -0.02250138f, -0.09612457f, -0.01934243f, 0.02520302f, -0.03342105f, 
    -0.01770227f, -0.02808433f, -0.01991836f, -0.01972894f, -0.02735144f, 0.14437009f, 0.19217533f, 0.12071635f, 
    0.05732222f, 0.09880260f, 0.04118858f, 0.00739547f, -0.01336887f, 0.05395760f, 0.00779876f, -0.01773357f, 
    0.18174645f, 0.00828867f, 0.10183506f, 0.00871823f, -0.07287379f, -0.02009045f, -0.06156841f, -0.04056667f, 
    -0.01180645f, 0.01836975f, -0.06657044f, 0.01956409f, 0.28430057f, -0.32213649f, 0.20147710f, 0.18996115f, 
    0.03082970f, -0.04548481f, -0.03476975f, -0.06673957f, -0.10652126f, -0.08661202f, -0.06038378f, 0.01675557f, 
    0.07761354f, 0.09367619f, -0.04103842f, 0.20464243f, 0.03949963f, -0.09127777f, -0.04354895f, 0.03345625f, 
    -0.02701264f, -0.05508008f, -0.04430055f, -0.08260334f, 0.12481232f, 0.03594147f, 0.01745570f, 0.08030728f, 
    0.00087410f, 0.09323208f, 0.00362685f, -0.05833168f, -0.05872172f, 0.01152609f, -0.02703022f, -0.00218785f, 
    -0.03863316f, 0.04723015f, 0.04257195f, -0.02501824f, -0.05391119f, -0.04702148f, -0.06369007f, -0.04063652f, 
    -0.04837139f, -0.00331468f, -0.07889682f, -0.06709775f, -0.13392894f, -0.13053064f, 0.00440199f, -0.15661460f, 
    -0.10969877f, -0.02402671f, -0.01945348f, -0.17225379f, -0.02238509f, 0.00072532f, -0.06189671f, -0.01299429f, 
    -0.06871934f, -0.10235462f, -0.20613627f, 0.02342859f, -0.06044302f, -0.04986198f, 0.01175316f, -0.06504576f, 
    -0.05264383f, -0.02798759f, -0.04586899f, 0.03711467f, -0.08892005f, 0.06239234f, -0.14899495f, -0.03898630f, 
    -0.08033624f, -0.06470793f, 0.01888797f, -0.05128261f, -0.02079695f, -0.03478489f, -0.10545190f, -0.02958989f, 
    0.14349687f, 0.09657592f, 0.13996695f, -0.09238479f, -0.13429384f, -0.02125273f, -0.00174708f, 0.01084321f, 
    0.03491438f, 0.08649398f, 0.00540351f, -0.01603119f, 0.06546739f, -0.18930414f, -0.06565259f, -0.01189924f, 
    -0.02372940f, -0.03707920f, -0.08992452f, -0.02840903f, -0.05682341f, 0.00553413f, -0.01325239f, -0.03856192f, 
    -0.05113755f, 0.20129217f, 0.05717332f, 0.00649643f, -0.11174601f, 0.04554209f, 0.02699555f, -0.04116258f, 
    -0.02381403f, 0.01962952f, -0.03418451f, -0.05568862f, -0.03367516f, 0.19662842f, 0.08804931f, 0.07093879f, 
    0.08878352f, 0.11590109f, 0.09049806f, -0.04290770f, -0.03762478f, -0.01967782f, -0.09657010f, -0.03024163f, 
    0.03376853f, -0.01366784f, -0.01425301f, -0.06148130f, 0.04477746f, -0.00490493f, -0.00007975f, -0.06617306f, 
    -0.00627708f, -0.04496979f, -0.02009690f, 0.01876420f, -0.11117002f, -0.18773372f, -0.12012093f, -0.07914625f, 
    -0.04155775f, -0.00775362f, 0.02600740f, -0.05598761f, 0.02025586f, -0.01383059f, 0.05647692f, -0.03675208f, 
    0.03918232f, 0.03084472f, 0.02023810f, 0.13538940f, -0.06015060f, -0.01952734f, -0.02564118f, -0.00475092f, 
    -0.08159869f, -0.00993450f, 0.00133291f, -0.06499115f, 0.01362633f, -0.06492487f, -0.13393283f, -0.13844942f, 
    -0.04633908f, 0.05758044f, -0.05757136f, -0.10406465f, -0.02487379f, -0.03814658f, -0.00349446f, 0.00339632f, 
    0.15153132f, -0.01439988f, 0.02750263f, 0.13392945f, -0.06997856f, -0.06568299f, -0.00560819f, 0.02409258f, 
    0.01965553f, -0.05083569f, -0.04208127f, -0.02788712f, 0.05553084f, 0.07620632f, 0.15552922f, -0.04164299f, 
    -0.07541258f, 0.07214533f, -0.02011167f, -0.00605721f, -0.02054618f, -0.01282544f, -0.08580108f, 0.05807757f, 
    -0.08418141f, -0.09201903f, -0.01339987f, -0.05978877f, -0.03144450f, -0.01742793f, -0.03085469f, -0.06506559f, 
    -0.04604683f, -0.04950762f, -0.00458061f, -0.05269019f, 0.18146746f, -0.19240965f, -0.02284784f, 0.01901210f, 
    -0.09394686f, -0.01743017f, -0.02729437f, -0.01908893f, 0.03845616f, 0.01593719f, 0.01469248f, -0.02053177f, 
    0.04331039f, 0.08343472f, 0.02548844f, 0.04611524f, -0.08879280f, -0.03756443f, -0.01809635f, -0.04934667f, 
    0.01890620f, -0.00541563f, -0.03334868f, -0.08141717f, -0.26749182f, -0.10490147f, -0.22157949f, -0.09304136f, 
    -0.03891390f, 0.05964354f, 0.03401570f, -0.03834749f, -0.15858665f, -0.06409415f, 0.04896377f, -0.07579230f, 
    0.05482775f, -0.28730220f, 0.03108441f, -0.09632151f, -0.05469516f, -0.04297936f, -0.00508090f, -0.01278539f, 
    0.07216711f, 0.03775823f, 0.00038312f, -0.00627144f, 0.05281865f, 0.09441878f, -0.18071862f, 0.04762097f, 
    -0.00612362f, -0.00943911f, -0.06256176f, -0.08036949f, 0.06971185f, 0.00948760f, 0.02205782f, -0.03446140f, 
    -0.14095464f, 0.05339926f, 0.08757624f, -0.09246124f, -0.01561767f, 0.02954573f, 0.00849032f, -0.09188519f, 
    -0.07823149f, 0.02571421f, 0.07376224f, -0.08147112f, -0.01713043f, -0.03610935f, 0.15356611f, 0.02555729f, 
    0.00828366f, 0.02225472f, -0.00271142f, -0.12590471f, -0.00080124f, 0.03675764f, -0.00515563f, -0.09108478f, 
    0.14026760f, -0.02644142f, 0.03396844f, 0.17096779f, 0.06248621f, -0.03777381f, 0.01811381f, -0.05350824f, 
    -0.03885898f, 0.03746284f, -0.04034939f, -0.09883469f, 0.05607893f, 0.02597261f, -0.03426367f, -0.11651861f, 
    -0.08074423f, 0.00031302f, -0.02000917f, -0.07044617f, 0.04474619f, 0.04921198f, 0.01725330f, -0.02622874f, 
    -0.38653833f, 0.00366916f, -0.06412354f, -0.13431226f, -0.01327717f, -0.04498884f, 0.02217409f, 0.00870067f, 
    0.03213021f, 0.01484370f, -0.06094411f, -0.04379287f, -0.03468144f, 0.14155348f, 0.05804531f, 0.10254093f, 
    0.02739710f, 0.04774518f, -0.08931560f, 0.05919546f, -0.02995259f, 0.05409141f, 0.00375363f, 0.00129734f, 
    -0.05937092f, -0.23319006f, -0.07439350f, 0.12584573f, 0.00043131f, -0.08046403f, -0.04448676f, -0.01483061f, 
    -0.07179530f, 0.01838199f, 0.08622035f, 0.01416866f, 0.07855008f, -0.09110341f, -0.07809018f, -0.08218928f, 
    0.01841300f, -0.16259432f, 0.01038023f, -0.09428075f, -0.02297457f, 0.04549117f, 0.01667863f, 0.00719147f, 
    -0.11186077f, 0.18612322f, -0.01791936f, 0.12216858f, 0.06372186f, -0.04980220f, -0.00265677f, 0.06254063f, 
    0.04902421f, 0.03775442f, 0.01902704f, -0.01046100f, 0.10858161f, -0.08397847f, -0.00691257f, 0.00438492f, 
    -0.04811964f, -0.03846206f, -0.06674237f, 0.00999986f, 0.07837063f, 0.02576134f, 0.07849395f, -0.00756596f, 
    0.07919239f, 0.03451978f, -0.00828599f, 0.02589036f, 0.03960852f, 0.08202926f, -0.07518252f, -0.07221312f, 
    -0.09751458f, 0.06536888f, -0.06143215f, -0.03938057f, 0.23589385f, -0.04418552f, 0.01024529f, 0.08786577f, 
    0.19639164f, 0.02702533f, 0.00748966f, 0.04269064f, 0.03418655f, -0.00059523f, -0.02086850f, 0.00744923f, 
    -0.27214843f, 0.17714691f, -0.04343818f, -0.06913486f, -0.00461274f, 0.05729568f, -0.07534210f, -0.01240083f, 
    -0.14872546f, 0.00723782f, -0.07010567f, -0.12031786f, -0.23391442f, 0.06585408f, -0.17070548f, -0.05493658f, 
    -0.03704862f, -0.02061054f, -0.00063111f, -0.06273545f, -0.03708192f, 0.05977327f, 0.05108691f, 0.02308567f, 
    -0.31093025f, 0.03290285f, 0.13318899f, -0.23076451f, 0.07932684f, 0.09451209f, -0.18638662f, 0.03343501f, 
    -0.03780426f, -0.02088889f, -0.05152799f, -0.12869519f, 0.09479502f, 0.01586605f, 0.03680702f, 0.12746055f, 
    0.03954763f, 0.02939194f, 0.07550086f, -0.05399911f, 0.02793644f, -0.00891269f, 0.07513522f, 0.00707420f, 
    -0.17769524f, -0.17074329f, -0.11409252f, -0.07017466f, -0.04331610f, -0.01585453f, -0.01442131f, -0.03844695f, 
    0.02905730f, -0.09573535f, 0.06447437f, 0.05284705f, 0.18129887f, 0.00576497f, -0.12447548f, -0.10580140f, 
    0.07393948f, 0.00376577f, 0.02835135f, 0.02363900f, 0.06812072f, -0.01267663f, 0.04908314f, 0.03451078f, 
    0.12096626f, -0.01066779f, -0.02120424f, 0.11119273f, 0.03648189f, -0.00518770f, -0.07709784f, -0.09459863f, 
    -0.07694011f, 0.02207627f, -0.00126895f, -0.01500215f, -0.33232421f, -0.16780970f, -0.08641441f, -0.19895811f, 
    0.00522195f, -0.01351237f, -0.21675768f, 0.09079506f, 0.06027000f, 0.03265480f, 0.03810329f, -0.05472542f, 
    0.07681531f, -0.04563794f, -0.12164501f, 0.05413671f, 0.12980208f, -0.04364786f, -0.07037537f, -0.01566061f, 
    0.11426409f, 0.05688278f, -0.02917561f, 0.03597812f, 0.04430708f, -0.00594755f, -0.06466984f, 0.08233244f, 
    0.03734023f, 0.00968361f, 0.05881378f, -0.02959211f, 0.01123226f, -0.16895017f, 0.03823813f, 0.23839505f, 
    0.01846557f, -0.04997522f, -0.09893493f, 0.08088602f, 0.11608654f, -0.01087818f, -0.02839642f, 0.02798346f, 
    0.02794016f, 0.07312430f, 0.13132440f, 0.01092893f, -0.04614834f, -0.04172312f, -0.03270158f, 0.11136637f, 
    0.13098893f, 0.03119260f, -0.05250261f, -0.01601068f, -0.08643881f, 0.12191179f, -0.00763156f, 0.01094544f, 
    -0.20169097f, 0.09665307f, 0.05270140f, -0.18502003f, -0.03556129f, -0.04968519f, -0.01371662f, -0.09345597f, 
    -0.01829659f, -0.00189628f, 0.00083774f, 0.07550547f, -0.11714052f, 0.11069784f, 0.05542204f, -0.13777657f, 
    0.09738703f, 0.03149471f, 0.06645545f, -0.16442071f, 0.09336986f, 0.08778775f, 0.07273435f, 0.11986051f, 
    0.30820069f, 0.15601343f, -0.24875179f, -0.16195098f, 0.02263781f, 0.00593958f, -0.03835173f, -0.00814171f, 
    0.11779806f, 0.05109219f, -0.03023968f, 0.08737662f, 0.07527968f, 0.00582021f, -0.00405447f, 0.12374213f, 
    -0.08450020f, -0.14200994f, -0.02711773f, -0.11055271f, -0.05374919f, 0.00305504f, -0.14048296f, 0.02963711f, 
    -0.16570677f, 0.09631109f, 0.13306114f, 0.09448332f, -0.07097934f, 0.05809537f, -0.16238403f, -0.06649721f, 
    0.04381242f, 0.03103078f, -0.08234748f, -0.07278749f, -0.19478220f, -0.05981221f, 0.19802445f, -0.21816187f, 
    -0.11176264f, -0.12040142f, 0.11446746f, -0.21707478f, -0.04536526f, 0.04703198f, -0.15175943f, 0.01876300f, 
    -0.19777599f, -0.18066718f, -0.02561460f, -0.17083879f, 0.00631340f, -0.11440405f, 0.03237396f, 0.06267501f, 
    0.01126884f, 0.02972046f, 0.03864422f, -0.17020041f, -0.20664746f, 0.03933337f, 0.02417613f, 0.00315879f, 
    0.04678312f, -0.12164594f, -0.06342127f, 0.02755509f, 0.06611466f, 0.10905398f, -0.03797460f, -0.01799527f, 
    0.02228942f, 0.19644012f, -0.02528306f, -0.14603896f, 0.03375151f, -0.04921429f, -0.19910181f, 0.01385258f, 
    -0.13883635f, 0.06066850f, 0.03530744f, 0.06429970f, -0.06643410f, -0.04609739f, 0.03265776f, 0.13411981f, 
    0.12742919f, 0.00607543f, 0.00172481f, 0.01025526f, 0.09932096f, -0.00948140f, -0.01678579f, -0.01735142f, 
    -0.04174429f, 0.23051918f, -0.05648389f, -0.13394946f, -0.03843516f, 0.09479588f, 0.06272572f, -0.04181160f, 
    0.09498171f, -0.14780861f, 0.01371956f, 0.02782323f, -0.18473981f, 0.11493055f, 0.03514425f, -0.02100518f, 
    -0.02285784f, -0.13762198f, -0.01791036f, 0.02918322f, 0.01526978f, -0.14293094f, -0.06852101f, 0.13145810f, 
    0.13729674f, 0.10731155f, 0.00727812f, -0.03132166f, -0.05040153f, -0.00669399f, 0.04446118f, -0.09622437f, 
    0.05945582f, -0.06641783f, -0.09153362f, 0.09960257f, -0.17763138f, 0.08092168f, -0.18636896f, -0.30496877f, 
    0.03884916f, -0.00309525f, -0.07090141f, 0.08558390f, -0.01330409f, 0.03455237f, 0.04269949f, 0.00304817f, 
    0.11321750f, -0.17093842f, 0.08163394f, -0.11015862f, 0.02710441f, -0.05009657f, 0.01791178f, 0.04993812f, 
    -0.00029562f, 0.08561862f, 0.00978405f, 0.14651309f, -0.10785002f, -0.05995182f, 0.18156722f, 0.08691743f, 
    -0.09939192f, -0.06779628f, 0.04242761f, 0.03493015f, -0.02998669f, -0.02844884f, -0.13223489f, -0.02057700f, 
    -0.24835974f, 0.12942456f, -0.07820908f, -0.17640683f, -0.05446839f, -0.00446479f, -0.05288265f, 0.01314235f, 
    -0.02357416f, -0.00365383f, -0.06426854f, 0.05568326f, 0.01492323f, 0.02680829f, -0.13526551f, 0.06888381f, 
    0.02217852f, -0.01706027f, 0.00585057f, -0.00130216f, 0.05874437f, 0.04808933f, 0.02107159f, 0.02901059f, 
    0.10134493f, 0.09516444f, 0.10402749f, -0.10827702f, -0.01620143f, -0.03780425f, -0.11357383f, -0.08697838f, 
    0.08879808f, 0.00782608f, 0.01101072f, -0.02674438f, -0.23467247f, -0.10698644f, 0.02180883f, -0.16129474f, 
    0.00017945f, -0.09275770f, -0.07256680f, 0.12997121f, 0.02102577f, 0.00962473f, -0.06870890f, -0.09562472f, 
    -0.03077962f, -0.12795441f, -0.13768858f, 0.00329337f, 0.01018181f, 0.01336404f, 0.02606604f, -0.01891201f, 
    0.00589698f, -0.06997784f, -0.04710122f, -0.10552500f, 0.13943635f, -0.13771191f, 0.08608687f, 0.10445783f, 
    -0.09311084f, 0.02270068f, -0.07058401f, 0.02722459f, 0.05381734f, -0.12958735f, -0.00231403f, -0.12420484f, 
    -0.20625336f, -0.06822809f, -0.00749837f, 0.10224395f, -0.07640778f, 0.02297622f, 0.02610039f, -0.02704614f, 
    0.08234326f, 0.12254740f, -0.02772735f, 0.03439007f, 0.06498545f, 0.06574702f, -0.02255660f, -0.01416298f, 
    -0.05719166f, 0.03136938f, 0.03675237f, 0.04074058f, -0.02659218f, -0.02244373f, 0.01307083f, -0.10787135f, 
    0.02715028f, -0.01390593f, -0.13124236f, -0.14185539f, -0.19143426f, -0.10474903f, 0.07718009f, -0.04063013f, 
    0.05015723f, 0.06610987f, 0.04774291f, -0.14535019f, -0.29215422f, -0.09346819f, -0.23998123f, -0.13180953f, 
    -0.03636580f, -0.02795368f, 0.05140425f, 0.00082383f, 0.10204057f, 0.01079232f, -0.00712208f, 0.03433326f, 
    0.10776501f, 0.02765770f, 0.01861867f, 0.21924496f, 0.04730936f, -0.00504780f, -0.00391448f, -0.01658992f, 
    0.09888723f, -0.00415253f, 0.07458930f, -0.08559268f, -0.04209963f, 0.02515132f, 0.22926886f, -0.01418355f, 
    -0.12010349f, -0.02480749f, -0.09992759f, -0.06782031f, 0.05063710f, -0.08076124f, 0.05877666f, -0.06068648f, 
    0.23567617f, -0.15278815f, -0.10273673f, 0.05868425f, 0.06811816f, -0.15804966f, -0.11997012f, 0.00416221f, 
    0.05570888f, -0.02101194f, 0.00655773f, 0.05471470f, 0.07631731f, -0.07441314f, 0.01023895f, 0.13565402f, 
    0.13081899f, 0.01222460f, -0.03717501f, -0.01229735f, -0.04592849f, 0.06268485f, -0.07246429f, 0.06741565f, 
    -0.12622313f, -0.04685014f, -0.10052320f, -0.20823705f, 0.01870275f, -0.00306980f, -0.09928681f, 0.05116048f, 
    0.12683210f, -0.04958640f, -0.11990714f, 0.01907348f, 0.11081501f, -0.15448679f, 0.01399405f, 0.05594812f, 
    0.13705464f, -0.05903440f, -0.05235426f, 0.03993305f, 0.04497981f, -0.03400791f, -0.01206009f, -0.11938311f, 
    0.03099651f, -0.04735120f, -0.17038807f, -0.22548504f, 0.07279470f, -0.04267498f, -0.00241994f, -0.03948529f, 
    0.06032469f, 0.12146166f, -0.05702157f, -0.00326825f, -0.05940534f, 0.08995265f, 0.18751930f, -0.05857521f, 
    0.01730045f, -0.03569740f, -0.05425809f, 0.02696248f, -0.03345640f, -0.04353104f, 0.01285753f, -0.13847296f, 
    0.20617510f, -0.05891485f, 0.04490728f, 0.14842221f, 0.05860520f, 0.00156787f, -0.10539687f, -0.03877974f, 
    -0.00486731f, -0.04809181f, 0.01322520f, -0.01227549f, 0.05613597f, -0.16694002f, 0.05075338f, -0.02088109f, 
    0.02097706f, -0.19494794f, 0.09944320f, -0.12538595f, -0.05767998f, -0.00761830f, -0.00550546f, 0.10727588f, 
    0.05435682f, 0.03684801f, -0.11745205f, -0.16826826f, -0.00504636f, -0.10864548f, -0.01637600f, 0.00971082f, 
    -0.01293742f, 0.07741726f, 0.07795202f, 0.00342795f, -0.00638505f, -0.21280770f, -0.12361115f, 0.00813047f, 
    0.09444670f, -0.00543597f, 0.06494492f, -0.06331775f, 0.01781934f, -0.09733734f, 0.04245482f, 0.00697852f, 
    0.09127690f, -0.16695666f, 0.12192450f, 0.03567811f, -0.09981610f, -0.07665198f, 0.01029434f, 0.07675172f, 
    -0.04202323f, 0.05364165f, -0.13459998f, 0.05907241f, -0.08443702f, 0.22675729f, -0.10543457f, 0.02115178f, 
    -0.08104136f, 0.03929544f, -0.15523459f, 0.04306694f, 0.07404399f, 0.08374671f, -0.05664245f, 0.01168372f, 
    -0.10312790f, -0.14726262f, 0.17160821f, 0.06595693f, -0.04639903f, -0.06064472f, -0.06886091f, 0.00463857f, 
    0.05825004f, -0.10441676f, 0.01310838f, -0.09047952f, 0.13741235f, -0.27219477f, 0.14057150f, -0.02161254f, 
    -0.04293185f, 0.08549643f, -0.04797514f, 0.01772669f, -0.05010867f, -0.08750133f, 0.01736382f, -0.02107666f, 
    0.09944972f, 0.00109431f, -0.14185721f, -0.15611249f, 0.02055986f, -0.05603605f, 0.02529098f, -0.06309342f, 
    0.03721086f, 0.03882513f, 0.01620597f, -0.06665897f, 0.12672982f, 0.10598455f, -0.06664619f, 0.02461226f, 
    -0.10128348f, -0.03837273f, -0.06091775f, 0.05486663f, -0.03545645f, 0.00810659f, -0.02372178f, -0.08080159f, 
    0.11663631f, 0.12645513f, -0.18153362f, -0.00570387f, 0.03412515f, 0.03567952f, -0.07257950f, -0.09224202f, 
    -0.13539174f, -0.03228404f, 0.00637458f, 0.21207611f, -0.03056458f, 0.05722467f, -0.00458849f, -0.10168727f, 
    0.06554990f, -0.02215463f, 0.12561257f, -0.15165047f, -0.01435153f, -0.05204078f, -0.04062166f, 0.02835424f, 
    -0.04762396f, -0.07104649f, -0.15118419f, -0.11497907f, 0.10851425f, 0.08428238f, 0.00137617f, -0.01411575f, 
    -0.02247420f, 0.02109594f, -0.01483486f, 0.03885180f, -0.03172943f, -0.12317200f, 0.03112508f, 0.17234291f, 
    0.00861505f, -0.08276433f, -0.03317995f, 0.01006321f, 0.09226813f, 0.00837572f, 0.04856606f, -0.01930878f, 
    -0.02009450f, 0.15962718f, 0.09109956f, 0.09107056f, -0.06248257f, -0.01523564f, -0.19438328f, 0.03279252f, 
    -0.06783101f, -0.13459697f, 0.04948530f, 0.08055394f, -0.17978878f, -0.06827899f, -0.15095240f, -0.06310705f, 
    0.00407941f, -0.04479903f, 0.07978350f, -0.05414347f, 0.03026965f, -0.01695237f, 0.04286585f, 0.09016877f, 
    0.11575913f, -0.12764230f, 0.09758810f, 0.01598997f, 0.01310276f, -0.05921428f, -0.15328045f, -0.12985903f, 
    -0.05082338f, -0.06723332f, 0.06451423f, -0.05383725f, 0.11587167f, -0.00096593f, -0.04271071f, 0.07604910f, 
    0.05863399f, 0.04217504f, 0.05647480f, 0.02627938f, 0.04746794f, 0.00421577f, 0.05934579f, 0.04643729f, 
    -0.06218466f, 0.05261715f, 0.13823824f, 0.10262786f, -0.00010725f, 0.01636305f, -0.03347615f, -0.12808132f, 
    0.04146534f, 0.03751331f, 0.08373725f, 0.06005589f, 0.01316966f, -0.09521908f, 0.00919516f, 0.10327673f, 
    0.04293475f, 0.05787355f, -0.01903283f, -0.03697430f, 0.01166313f, -0.04869522f, 0.00981282f, -0.06692802f, 
    -0.13109566f, -0.20927438f, 0.12201510f, 0.08443914f, -0.07000611f, 0.02486241f, -0.00452992f, 0.06743471f, 
    -0.07745155f, -0.07586558f, -0.15064727f, -0.02647556f, -0.47088072f, 0.24722059f, 0.05114168f, -0.15607412f, 
    0.15683070f, 0.03812863f, 0.14158396f, 0.00385609f, -0.07048930f, -0.08618126f, -0.03575176f, -0.08325718f, 
    -0.14600590f, 0.08656521f, -0.04048700f, -0.19340667f, -0.03168852f, -0.14472315f, -0.01464616f, 0.06157310f, 
    -0.07125041f, 0.08858883f, 0.06019058f, -0.05530528f, 0.18144104f, 0.08429506f, 0.17770548f, 0.12846187f, 
    0.01203789f, 0.06977677f, 0.03517261f, -0.01473320f, -0.00409389f, 0.00297799f, -0.05789245f, -0.03022176f, 
    -0.14399976f, 0.15794060f, -0.24799955f, 0.00589444f, 0.03983626f, 0.07930642f, -0.01887634f, -0.00231504f, 
    0.08104558f, -0.09606820f, -0.02642367f, -0.10270020f, -0.08026214f, -0.05799988f, -0.02126722f, -0.21557091f, 
    -0.17525958f, -0.02462337f, 0.11417623f, -0.06366953f, 0.07030016f, 0.03378900f, 0.06958503f, -0.13262393f, 
    -0.23972890f, 0.11203571f, -0.04829425f, 0.11428552f, -0.00012961f, -0.09623906f, -0.00684739f, 0.12009064f, 
    -0.02631847f, 0.00715184f, 0.21480750f, -0.09697280f, -0.06405803f, 0.12794109f, 0.16324440f, -0.02430249f, 
    -0.15649442f, -0.01850424f, -0.00221114f, -0.08975801f, -0.01191517f, 0.06237317f, 0.11163654f, 0.02505788f, 
    -0.14407471f, 0.08599095f, 0.03768177f, -0.09987454f, 0.11043271f, 0.01164496f, -0.03409325f, 0.01245379f, 
    -0.03010765f, 0.01198379f, -0.10437922f, -0.04059058f, -0.15394725f, 0.10071750f, -0.03603904f, 0.10692009f, 
    -0.01784198f, 0.09450605f, -0.02666097f, 0.05897145f, 0.14018779f, 0.05320070f, -0.12264801f, 0.09808639f, 
    -0.11485869f, -0.07293387f, 0.05590526f, 0.03543465f, 0.09356943f, 0.05539291f, -0.10668578f, 0.08171412f, 
    -0.03186119f, 0.02722204f, -0.05122143f, -0.06483555f, 0.06615980f, -0.33147767f, -0.18617027f, 0.13737004f, 
    -0.00534384f, 0.04874850f, -0.05268184f, -0.02063748f, -0.11269499f, 0.09868789f, 0.03878331f, -0.16135870f, 
    0.30294156f, -0.14161867f, 0.27408248f, -0.04501786f, 0.04403197f, 0.08977767f, -0.09121787f, -0.01968868f, 
    -0.03929655f, -0.02779509f, 0.01847825f, 0.01188658f, -0.02376703f, 0.09396707f, -0.05653815f, -0.14362137f, 
    0.11127468f, 0.04957176f, -0.10377169f, 0.04311980f, 0.10929661f, -0.08354399f, 0.10775145f, 0.00293723f, 
    0.05973482f, -0.31235802f, -0.01294578f, -0.00037098f, 0.01893869f, -0.05548855f, 0.01088080f, 0.11578315f, 
    -0.08951923f, 0.09759155f, -0.08149321f, 0.00204584f, 0.47553232f, 0.19418579f, -0.16994798f, 0.18709242f, 
    0.06120649f, -0.07524755f, -0.07148285f, 0.26915056f, -0.07871298f, -0.02858322f, 0.13100053f, 0.05646889f, 
    -0.08925689f, 0.04705000f, 0.13324021f, -0.10485730f, -0.11930644f, 0.02242552f, 0.04507334f, -0.02828489f, 
    0.04807746f, -0.01834378f, 0.02203460f, -0.04978890f, -0.13527571f, 0.05864082f, 0.00950758f, -0.20882916f, 
    -0.09269452f, 0.14008103f, -0.14404480f, 0.04618214f, -0.07970401f, -0.09042940f, -0.01152426f, -0.00923279f, 
    -0.17576033f, -0.19597214f, 0.29324067f, -0.11317401f, -0.01184521f, 0.06235565f, -0.11245821f, 0.04428708f, 
    0.00433826f, -0.04025262f, -0.08982661f, -0.16883869f, -0.28383374f, -0.07820024f, -0.02610499f, -0.18917575f, 
    0.06912947f, -0.17135642f, -0.00902174f, -0.19791879f, 0.10608085f, -0.12273661f, 0.06415056f, -0.04558612f, 
    -0.10752245f, 0.07440374f, 0.12837745f, -0.12902418f, 0.09372867f, -0.17565277f, 0.00551880f, 0.00424368f, 
    0.04782905f, 0.03865925f, 0.13414997f, 0.16268684f, -0.11729860f, -0.01624588f, 0.05075820f, 0.08162924f, 
    0.14114887f, -0.07515334f, 0.02558526f, 0.11541031f, -0.07396095f, -0.05247882f, 0.03945658f, 0.01092915f, 
    0.00733196f, 0.19128841f, -0.02562242f, 0.02169610f, -0.01471032f, 0.05331846f, -0.00512750f, 0.04652217f, 
    0.15552424f, 0.05737703f, 0.11650871f, 0.05900577f, -0.14882408f, -0.10823873f, 0.21712911f, 0.01040054f, 
    -0.02967808f, 0.04524916f, -0.00191070f, 0.00599368f, 0.00036349f, -0.11950292f, -0.00490902f, 0.00579515f, 
    0.12148590f, 0.12627339f, -0.18309583f, -0.08282689f, 0.03018497f, -0.13166535f, 0.01942581f, -0.04576674f, 
    -0.04007729f, -0.02465171f, -0.06847483f, -0.01844703f, 0.17562307f, -0.11618660f, -0.11208159f, -0.07472686f, 
    0.07755099f, -0.05174763f, 0.02487159f, -0.04321836f, -0.05720245f, 0.00381790f, -0.02179199f, -0.05890478f, 
    -0.28512117f, -0.07756720f, -0.15987435f, 0.21465166f, 0.03659296f, 0.08043472f, 0.00450427f, -0.02177450f, 
    0.03551833f, -0.06237784f, -0.04420472f, 0.03059613f, 0.35564056f, -0.47539902f, 0.06894185f, -0.21516348f, 
    -0.03855572f, 0.00403805f, -0.05347116f, 0.02184817f, -0.06808857f, -0.03671284f, 0.06205153f, -0.01711542f, 
    0.12984076f, 0.00823642f, -0.31120676f, -0.33481577f, 0.02183263f, -0.12660274f, -0.05996116f, 0.04462560f, 
    -0.15490054f, -0.11120806f, 0.00855297f, 0.13067888f, 0.04754170f, 0.06520368f, -0.00965565f, 0.18050079f, 
    -0.07448030f, -0.11997335f, -0.01676296f, 0.02551330f, 0.03229076f, 0.04549207f, 0.06049032f, 0.03796541f, 
    0.01720285f, 0.02625747f, -0.03188255f, -0.00759938f, 0.01720156f, 0.16732372f, 0.11530889f, 0.07345422f, 
    0.09486515f, 0.21105897f, 0.04092196f, 0.09438401f, 0.05248660f, 0.03315709f, -0.14492616f, 0.04962724f, 
    -0.00030576f, -0.02979042f, 0.03620625f, -0.04058693f, 0.01787650f, 0.06026677f, 0.03966497f, 0.13966191f, 
    0.07094770f, 0.23765354f, -0.29648101f, -0.09596368f, -0.01309086f, -0.09420570f, -0.04459292f, 0.07996149f, 
    0.00339302f, -0.06256568f, -0.01309414f, 0.05555746f, -0.30366307f, 0.17754436f, -0.16479258f, 0.11916333f, 
    0.00996990f, -0.00156978f, 0.10571951f, 0.07275229f, -0.02198126f, -0.02411191f, 0.03684420f, 0.02979874f, 
    -0.34953082f, 0.19278719f, -0.12463698f, 0.11868571f, 0.08207075f, 0.07719556f, -0.04578394f, 0.04428769f, 
    0.00989961f, -0.07427482f, 0.05615512f, 0.11644294f, -0.15869156f, -0.01271656f, 0.12777732f, -0.27298626f, 
    -0.08016664f, 0.07184598f, 0.01149732f, -0.05790570f, 0.07250345f, -0.01508467f, 0.05838475f, -0.14029104f, 
    -0.49017936f, 0.33414954f, -0.25595683f, 0.00927348f, 0.13266152f, -0.00106885f, 0.12994418f, -0.05781998f, 
    -0.18462610f, -0.00537579f, -0.05290491f, 0.00508179f, -0.19274475f, -0.42378548f, -0.01555867f, -0.10742401f, 
    0.00811742f, 0.08586595f, -0.00795444f, 0.06152182f, 0.05269151f, 0.08388785f, 0.02276246f, 0.04448092f, 
    -0.01534555f, 0.17550707f, -0.11645553f, 0.03404475f, 0.01521682f, 0.06306127f, 0.08704893f, -0.11168628f, 
    0.08094290f, 0.09483433f, -0.05127554f, 0.08479727f, -0.12416096f, 0.17718193f, -0.16359228f, -0.26405501f, 
    0.10261245f, -0.06215068f, -0.05325887f, 0.13201131f, 0.02863437f, 0.03036454f, -0.03358959f, -0.07333556f, 
    0.03868818f, 0.02929017f, 0.06086566f, -0.03647866f, 0.00477338f, -0.01103985f, 0.09361248f, 0.06204973f, 
    0.04102102f, 0.03985030f, 0.01774313f, 0.01324770f, -0.08539397f, -0.01653228f, 0.07445749f, 0.06795201f, 
    -0.07473125f, -0.04013727f, 0.03624757f, -0.05716563f, 0.02500254f, 0.12214653f, -0.02297440f, -0.02140986f, 
    -0.14871557f, -0.03617154f, 0.00653589f, 0.19852854f, -0.07605299f, 0.05123003f, -0.02156992f, 0.07779280f, 
    0.05359824f, -0.00300353f, -0.04358592f, -0.06708228f, -0.18220474f, -0.11466525f, 0.05395262f, 0.03507138f, 
    -0.04255435f, 0.07029908f, -0.06221884f, -0.07083147f, -0.00580797f, 0.02188545f, -0.01007544f, 0.05505184f, 
    -0.03389902f, -0.03526116f, -0.19176099f, -0.14622478f, 0.05267881f, 0.09473927f, 0.03390315f, -0.05478896f, 
    0.01511542f, -0.18264094f, -0.03412159f, -0.04734962f, 0.31303716f, 0.27861547f, -0.13239957f, -0.00189685f, 
    0.00988252f, 0.03126404f, -0.02348766f, 0.14202985f, 0.10436700f, 0.06434488f, -0.05289548f, 0.08620396f, 
    -0.16685992f, 0.03053712f, -0.01561424f, -0.09132414f, -0.00924782f, 0.02624898f, -0.04926765f, -0.07493058f, 
    -0.07419983f, 0.04673563f, -0.16191714f, -0.10523785f, -0.35331473f, 0.21811277f, -0.00970691f, -0.26038751f, 
    0.03661552f, 0.02603399f, -0.04611358f, -0.10435076f, -0.12299390f, -0.07949208f, 0.05624120f, -0.00130857f, 
    0.10634312f, 0.11868636f, -0.16649799f, 0.20483221f, 0.12846385f, 0.04708264f, -0.04185544f, -0.01243844f, 
    -0.07837402f, -0.10895114f, -0.07234656f, 0.04509107f, -0.06625709f, 0.41000861f, 0.23744403f, 0.20756178f, 
    0.04207409f, 0.08346715f, -0.00318839f, 0.11033617f, 0.01514928f, 0.01643509f, -0.02338345f, -0.01188226f, 
    0.01656084f, 0.19145276f, -0.03981650f, 0.08632644f, -0.00873864f, -0.08614340f, -0.03684664f, 0.02740424f, 
    -0.08740669f, 0.00592040f, 0.02714284f, -0.00778444f, -0.06779103f, 0.00813166f, 0.08870956f, 0.12498824f, 
    0.09208300f, -0.14347430f, -0.05444073f, -0.05978610f, -0.09898275f, 0.17278437f, -0.10575549f, 0.10418804f, 
    -0.06106978f, 0.00200163f, -0.02345016f, -0.18190660f, 0.06982343f, -0.01420912f, -0.14496142f, -0.07152273f, 
    0.00773574f, -0.14905535f, -0.05155793f, 0.07277554f, -0.26731804f, 0.15698247f, 0.21289608f, 0.03450800f, 
    0.13481355f, 0.02382505f, 0.08482651f, 0.08185387f, 0.03069289f, 0.00439210f, -0.01594559f, 0.04250611f, 
    0.12262656f, -0.01636815f, 0.08581383f, 0.01603034f, 0.04320506f, -0.05938492f, 0.02815678f, -0.02748300f, 
    -0.02165600f, 0.04464909f, 0.03529574f, -0.04957873f, -0.39637968f, -0.10374783f, 0.00335056f, 0.03724435f, 
    -0.01964491f, 0.08546427f, -0.09547016f, -0.07614712f, 0.01087299f, -0.02254201f, 0.09398291f, 0.02263804f, 
    0.04308008f, -0.00587236f, -0.02404834f, -0.34464562f, -0.02580882f, 0.02260314f, 0.02962303f, -0.06405170f, 
    0.02554636f, 0.07325821f, -0.01722862f, -0.12622744f, 0.00634264f, 0.03986005f, -0.02131870f, -0.26563334f, 
    0.06951092f, 0.06458018f, -0.05895070f, -0.12081724f, -0.12244386f, -0.05899547f, -0.08958524f, 0.05589380f, 
    -0.44311598f, -0.08929299f, 0.29170388f, -0.05267063f, 0.03059496f, -0.06709369f, 0.03663620f, 0.14300261f, 
    0.13104539f, -0.02637524f, 0.00144536f, -0.04870777f, -0.09477771f, -0.04206208f, -0.15492193f, -0.21341068f, 
    -0.01794283f, -0.00238278f, -0.11111567f, -0.02018780f, -0.01755468f, -0.05431588f, 0.13694876f, -0.01316925f, 
    -0.04157841f, -0.28006664f, -0.00128000f, -0.14969593f, 0.08471803f, -0.02258843f, -0.02482542f, -0.05234389f, 
    0.09170192f, -0.01760497f, 0.11942750f, 0.12983459f, 0.20596829f, -0.35967791f, 0.24647236f, -0.01975153f, 
    0.06163443f, -0.00677986f, 0.02788481f, -0.07351080f, 0.03924390f, -0.10546952f, 0.10114306f, 0.04165391f, 
    0.12755235f, 0.22147153f, -0.18151960f, -0.15291643f, 0.09815577f, -0.06278741f, 0.08523089f, 0.03812746f, 
    -0.09598380f, 0.03594774f, 0.13365345f, -0.08085918f, -0.17496760f, 0.26654202f, -0.00048056f, -0.29764181f, 
    0.06326238f, -0.06995157f, 0.00882165f, -0.07211967f, -0.07496299f, 0.05535370f, 0.08104799f, -0.13667972f, 
    0.23190919f, 0.02129882f, 0.03015291f, -0.23439398f, -0.04140146f, 0.04947078f, -0.10531501f, -0.02687656f, 
    -0.01051219f, -0.01962665f, -0.01492267f, -0.10102026f, -0.30275530f, -0.44713169f, -0.00147307f, 0.03580281f, 
    -0.01233968f, 0.06151594f, 0.07141901f, 0.10015101f, 0.13421784f, 0.12601531f, 0.08869547f, 0.01516152f, 
    0.22225143f, 0.13317700f, -0.05362172f, -0.01009402f, -0.03977779f, 0.07792410f, -0.02176899f, -0.00180968f, 
    -0.03564249f, 0.04835182f, 0.12492514f, -0.06360423f, -0.20458345f, -0.07593785f, 0.16661669f, 0.03208671f, 
    0.00182045f, -0.01305486f, -0.01827821f, 0.04296071f, 0.07875028f, 0.03354749f, 0.02420374f, 0.09487867f, 
    -0.37900490f, -0.29078779f, -0.10747626f, -0.01830633f, 0.03061833f, 0.03621307f, 0.04334904f, -0.01057652f, 
    0.03019241f, 0.05738712f, 0.07828092f, 0.05646860f, 0.07947459f, 0.03906273f, 0.12332182f, 0.00953856f, 
    0.16887046f, 0.06935211f, -0.00098845f, 0.13466412f, -0.19982906f, -0.04055846f, -0.02175931f, 0.10883829f, 
    -0.11459872f, 0.01755162f, -0.05782256f, -0.02551689f, 0.09973502f, -0.01978313f, -0.04913156f, 0.13255361f, 
    0.06446123f, 0.07908763f, -0.07388240f, 0.01924797f, -0.42301875f, -0.21445206f, -0.04911483f, 0.02594547f, 
    0.08214255f, 0.01599711f, 0.11338317f, -0.09573524f, 0.14216542f, -0.17855082f, 0.13349465f, 0.02291551f, 
    -0.01271372f, 0.02641876f, -0.13078274f, -0.22444578f, 0.06407592f, -0.13499719f, -0.04836242f, 0.12531820f, 
    0.08304938f, 0.03031829f, 0.13007212f, 0.12752022f, -0.48771149f, -0.33203301f, -0.03472559f, -0.20650147f, 
    0.07677084f, -0.03629308f, -0.13244522f, -0.11623519f, 0.01395054f, 0.05010903f, -0.02651307f, -0.01111242f, 
    0.13247034f, 0.01540305f, 0.00229906f, -0.01955896f, 0.00652292f, 0.02841035f, 0.08481997f, 0.02971911f, 
    0.03818706f, 0.10571898f, 0.01943046f, 0.05084750f, 0.21759358f, 0.12237569f, -0.00503659f, -0.17249537f, 
    0.00053576f, 0.15814032f, -0.07787029f, 0.10296450f, -0.00411598f, 0.05207796f, -0.07255151f, 0.01240788f, 
    -0.37910047f, -0.00886233f, 0.10609215f, 0.05322814f, 0.12873928f, -0.05111954f, 0.04660367f, 0.02810673f, 
    -0.02718702f, 0.01361821f, -0.09349758f, 0.15294529f, -0.00301892f, -0.10794602f, -0.19879013f, -0.07423344f, 
    0.01711519f, -0.05774640f, -0.11312644f, -0.00478626f, 0.03898716f, -0.05250366f, -0.12041474f, 0.10627121f, 
    0.22084953f, 0.02869550f, 0.00743870f, -0.03822536f, -0.07886635f, -0.01535943f, -0.12891315f, -0.05149712f, 
    0.04972769f, 0.03334803f, -0.02628836f, -0.03616940f, 0.16367751f, -0.00458848f, 0.04081600f, -0.04495976f, 
    -0.06736845f, -0.06551418f, 0.11270391f, -0.07467847f, 0.05657121f, 0.09381793f, -0.17098725f, 0.00080357f, 
    -0.19942081f, 0.03998285f, -0.01874162f, 0.16267166f, 0.04247387f, -0.03102723f, -0.09791704f, -0.06879145f, 
    -0.05261648f, 0.04855872f, 0.00340607f, 0.07856480f, -0.50651920f, -0.10657088f, -0.06375171f, -0.15864430f, 
    0.12043724f, -0.18561049f, -0.00078254f, -0.04512743f, 0.03064862f, -0.10475769f, -0.09095278f, 0.03923109f, 
    0.08797631f, 0.03610200f, -0.00809759f, -0.04903478f, 0.03810661f, -0.02418471f, 0.02471598f, 0.02593460f, 
    0.01289379f, 0.09248265f, -0.04040262f, 0.05900960f, -0.22746262f, -0.23687221f, -0.14961404f, 0.04623127f, 
    0.00715391f, 0.00007552f, 0.08809440f, 0.17223087f, 0.04097188f, 0.12543237f, 0.02674454f, 0.12535575f, 
    -0.09751705f, 0.01647670f, 0.03145774f, 0.00972614f, 0.11219508f, -0.00289262f, 0.05024838f, 0.01941866f, 
    0.03072382f, 0.06539554f, 0.02597255f, 0.06134559f, 0.03101318f, -0.04969112f, 0.03306851f, -0.01378174f, 
    -0.01333529f, -0.04491913f, -0.03386664f, 0.02627456f, 0.07362098f, -0.22890091f, 0.01081395f, 0.10109114f, 
    -0.40146068f, -0.17454150f, -0.07391617f, -0.09527539f, 0.07591745f, -0.01710332f, 0.04030912f, -0.16945694f, 
    0.09463972f, -0.13833915f, -0.00375475f, 0.02839679f, 0.04766979f, -0.08914963f, 0.04085197f, 0.06410492f, 
    -0.01036463f, 0.07994902f, -0.12424002f, 0.03072282f, 0.06949846f, 0.11003907f, -0.03065055f, 0.06320462f, 
    -0.22070670f, 0.07490064f, -0.00452460f, 0.05357713f, 0.02852629f, -0.01757906f, 0.03876339f, -0.00747338f, 
    -0.11090342f, 0.12551433f, 0.00587067f, 0.14477938f, 0.24788716f, 0.04879726f, -0.06919874f, -0.05379027f, 
    -0.11146605f, -0.06650557f, -0.03766276f, -0.01320110f, 0.04602396f, 0.07170728f, 0.00156064f, 0.07509128f, 
    0.02942946f, -0.08203992f, -0.00802775f, 0.00728620f, 0.08306638f, 0.11187340f, -0.05074195f, 0.12765428f, 
    -0.04952856f, -0.01503596f, 0.00207634f, 0.00726999f, -0.18092948f, 0.12574504f, -0.14153248f, -0.15810233f, 
    0.05352651f, 0.02773538f, 0.02176340f, 0.05087525f, 0.07474601f, 0.01841200f, -0.09520568f, 0.04160752f, 
    -0.04820492f, 0.26103243f, -0.07999083f, -0.24466063f, 0.12426564f, 0.03064767f, 0.00894841f, 0.13608277f, 
    0.13904095f, 0.07127127f, 0.07887812f, 0.07676130f, 0.04213290f, -0.00982354f, 0.08420520f, -0.15011971f, 
    -0.02923938f, 0.02184138f, 0.00189311f, -0.02121137f, -0.02474502f, 0.01220517f, -0.19290145f, -0.12419672f, 
    -0.06252377f, 0.03897285f, -0.06033529f, 0.20517792f, 0.03816114f, 0.02150251f, -0.02142163f, -0.03654746f, 
    0.02909204f, -0.04167804f, 0.01574437f, 0.02388252f, 0.13734905f, 0.01392908f, -0.06512274f, 0.10426809f, 
    -0.11258457f, -0.11988859f, -0.12334187f, 0.10746650f, -0.04764917f, -0.10670864f, -0.10679685f, -0.09656128f, 
    0.18471707f, 0.28653127f, -0.04175881f, -0.08480663f, 0.01956982f, -0.06272469f, 0.04455181f, 0.09732644f, 
    0.13138811f, 0.09453890f, 0.03952943f, 0.09531790f, -0.21582370f, -0.12592563f, -0.00685856f, 0.15844342f, 
    0.06445605f, -0.01194597f, 0.01724254f, -0.00720569f, 0.07576901f, 0.03491442f, 0.01932643f, -0.00998725f, 
    0.07983700f, -0.17409936f, 0.05581921f, 0.10949930f, -0.13629070f, -0.03252223f, 0.02941566f, -0.00905502f, 
    0.04558249f, 0.02477564f, -0.27326041f, -0.12455560f, 0.22759424f, 0.11839227f, 0.10481906f, -0.12432878f, 
    -0.00969368f, -0.02832949f, 0.11524811f, 0.00392766f, 0.02955921f, -0.08126511f, -0.00348629f, 0.02796086f, 
    -0.29533160f, -0.24363393f, -0.06760036f, -0.22987717f, 0.02411946f, -0.08292123f, -0.00662388f, -0.02226919f, 
    -0.02809143f, -0.03005959f, -0.04216106f, -0.07489512f, 0.18899837f, 0.14163432f, -0.11933898f, 0.07498718f, 
    0.03135996f, -0.09496100f, 0.02535318f, -0.08216921f, 0.00396098f, 0.03712372f, -0.01417376f, -0.07391011f, 
    -0.21580954f, -0.16942163f, -0.08538567f, -0.11954914f, 0.05888637f, -0.03152605f, -0.10340856f, -0.06132798f, 
    -0.07958417f, -0.12059739f, -0.05135326f, 0.07439295f, -0.35751387f, -0.04118716f, -0.14061232f, -0.19112588f, 
    -0.00202538f, 0.00884840f, -0.06464650f, 0.05259983f, 0.03141087f, 0.06515350f, 0.07783622f, 0.07450507f, 
    -0.27005294f, 0.02935287f, 0.06149254f, 0.05836476f, 0.12852263f, -0.02830103f, 0.03157621f, -0.12076358f, 
    -0.02294151f, -0.19500610f, -0.03514305f, 0.05014047f, -0.31802741f, -0.04953294f, -0.08527040f, -0.10081771f, 
    0.12433672f, -0.01528530f, -0.06638693f, -0.06653820f, -0.03424667f, -0.04706864f, -0.02150634f, 0.07514253f, 
    0.23339282f, 0.00494746f, -0.07377150f, -0.00251809f, 0.02053550f, 0.05724797f, 0.05813463f, -0.02952015f, 
    0.07100959f, 0.13529357f, -0.01205309f, 0.02712856f, 0.24944049f, -0.12195863f, -0.06625467f, 0.08074583f, 
    -0.04176987f, -0.02662383f, 0.10616256f, 0.11162370f, 0.05673296f, -0.00873609f, -0.04902585f, -0.06724121f, 
    -0.29703718f, -0.17777087f, -0.21379779f, -0.29901144f, 0.03601411f, 0.02846504f, -0.07625994f, 0.01080665f, 
    0.02617853f, 0.01646491f, -0.02719183f, 0.00270952f, -0.23897390f, 0.11137616f, -0.01878499f, 0.02597873f, 
    0.05264053f, -0.04169109f, 0.06737690f, -0.09530661f, 0.05249631f, 0.00861399f, 0.05783237f, 0.07253959f, 
    0.25265455f, 0.14594449f, 0.00616120f, -0.04098380f, 0.08728717f, 0.01205059f, -0.01567332f, 0.01187852f, 
    0.05285319f, 0.08365753f, 0.16795194f, 0.05201570f, -0.33436042f, -0.41622460f, -0.01568323f, -0.03372086f, 
    0.04920020f, 0.04081021f, 0.02679158f, 0.02178590f, 0.06906097f, -0.04571505f, -0.04786629f, 0.01540856f, 
    0.19119069f, -0.03164078f, -0.11880900f, 0.12109279f, -0.02915498f, -0.07675415f, -0.03375854f, 0.16743445f, 
    -0.06718203f, 0.07406396f, 0.05398880f, 0.07236392f, -0.13718584f, -0.20663071f, 0.03824883f, 0.03420763f, 
    0.02632376f, 0.07380827f, 0.04691537f, 0.05044551f, 0.04690142f, -0.01761011f, -0.03756665f, 0.05818870f, 
    0.03310062f, 0.17561069f, -0.00484234f, -0.13878380f, 0.05181425f, -0.01133359f, -0.07473581f, 0.03101491f, 
    0.01627115f, -0.13452183f, -0.04967429f, -0.06925955f, 0.24220742f, -0.03908350f, 0.03138363f, -0.03116229f, 
    -0.19602972f, 0.08895355f, -0.01764548f, 0.08357400f, 0.05200589f, -0.04425305f, 0.06126174f, -0.06511842f, 
    -0.15045086f, 0.03726452f, -0.18861789f, 0.03456486f, 0.08783764f, -0.02964483f, -0.05391974f, -0.04075928f, 
    0.02954333f, 0.08034204f, 0.09176763f, -0.06803499f, -0.11589828f, -0.19356433f, -0.08305578f, -0.05731887f, 
    0.02258234f, 0.06062189f, -0.01333265f, -0.05714827f, 0.00313725f, 0.06484448f, -0.13101038f, 0.04171779f, 
    -0.46123922f, -0.14433043f, 0.00364557f, 0.01622267f, 0.09065790f, -0.03390588f, -0.05118279f, -0.12808406f, 
    0.05901936f, 0.04789560f, 0.04830437f, 0.19074982f, -0.06738938f, 0.05141574f, -0.01973173f, -0.00877401f, 
    -0.02253525f, 0.01013082f, 0.08183148f, -0.06514873f, 0.11238794f, 0.02155152f, 0.04846036f, 0.00459007f, 
    0.09828319f, 0.12444399f, 0.15551355f, -0.19757982f, 0.06606589f, 0.01345828f, 0.05937061f, 0.05409491f, 
    0.08705650f, 0.03561789f, -0.00757023f, 0.08785839f, -0.29334486f, -0.02981143f, 0.08882675f, 0.03053096f, 
    0.06626540f, 0.01148212f, -0.03950281f, 0.01131666f, 0.15507387f, 0.02271767f, -0.01847114f, 0.00862439f, 
    0.04132924f, -0.09056280f, -0.03915581f, -0.07720041f, -0.11861804f, -0.05090212f, 0.00316005f, -0.04015318f, 
    -0.02544116f, -0.12572668f, -0.00983645f, -0.06082262f, 0.04468410f, 0.06805187f, -0.06308658f, -0.07927969f, 
    0.00020910f, 0.07273535f, 0.01644123f, 0.07591275f, -0.04560545f, 0.06799977f, 0.01114266f, 0.16020660f, 
    -0.20448892f, 0.31593347f, -0.05219729f, -0.08078699f, -0.01142910f, -0.01330346f, -0.11614851f, 0.03091777f, 
    0.02955752f, 0.00100219f, 0.02976471f, -0.05945938f, -0.15243368f, 0.15445034f, -0.17783983f, 0.11504754f, 
    0.02444495f, -0.01414996f, -0.06169703f, -0.07130252f, -0.03246639f, 0.06352718f, 0.07515524f, -0.05902580f, 
    -0.57434726f, -0.35374770f, -0.13558264f, -0.03663262f, 0.05545612f, -0.12946215f, -0.04070136f, -0.06206539f, 
    -0.03569342f, 0.01736040f, 0.03525570f, 0.06317432f, -0.07801020f, 0.04632350f, 0.02083262f, -0.14369282f, 
    0.06836643f, 0.02707718f, 0.03609295f, -0.02293568f, 0.05479249f, -0.02475522f, 0.04325442f, 0.03002389f, 
    0.15334706f, 0.04446092f, -0.06331052f, -0.01851079f, -0.01951494f, -0.03357263f, -0.13583510f, -0.20535748f, 
    0.03818004f, -0.01643573f, 0.10856684f, -0.04303090f, 0.08198652f, -0.04211957f, 0.02061059f, 0.05697485f, 
    0.06754407f, 0.00160908f, 0.03364472f, -0.03930365f, -0.00267665f, -0.03663864f, -0.09579670f, -0.03443289f, 
    -0.26740348f, 0.09498932f, -0.11219943f, -0.02761062f, 0.04965222f, -0.11746851f, 0.00455674f, -0.06023034f, 
    0.01483667f, 0.00652297f, -0.05158851f, 0.07937869f, 0.16234474f, 0.01798869f, 0.10396270f, -0.22618544f, 
    0.13869508f, -0.05867242f, -0.10456201f, -0.01612353f, -0.05956082f, -0.02964284f, -0.03915161f, -0.10155863f, 
    0.00759137f, 0.03137987f, -0.16211888f, 0.05346180f, 0.08964464f, -0.04232053f, -0.02610431f, 0.01661440f, 
    0.01492161f, -0.01166075f, 0.01671000f, -0.08524781f, 0.07062226f, 0.15120925f, -0.15052614f, 0.13149157f, 
    -0.06030984f, -0.02461252f, 0.00518764f, 0.05740666f, 0.11295854f, -0.01441174f, -0.11582894f, -0.11858108f, 
    0.12712178f, -0.01137198f, -0.02868944f, 0.30659279f, 0.05404112f, 0.10498922f, 0.05074770f, 0.07001846f, 
    0.07303602f, 0.04423625f, 0.01879070f, 0.06534681f, -0.12519173f, 0.23509409f, 0.11051641f, -0.02566953f, 
    0.11319283f, -0.02879646f, 0.00982614f, 0.03440863f, 0.05687348f, 0.10034786f, -0.08864400f, -0.00946441f, 
    -0.03830128f, 0.07862464f, -0.19042459f, 0.00153440f, 0.17939876f, 0.00285127f, 0.02689441f, 0.08763278f, 
    -0.05894751f, -0.09532380f, 0.00539233f, -0.09681209f, 0.17276260f, 0.01737574f, -0.02327260f, 0.07310361f, 
    -0.03180559f, 0.01925005f, 0.05996713f, -0.12716888f, 0.03695847f, -0.13055652f, -0.04945930f, -0.04681134f, 
    0.20868526f, -0.04214603f, -0.11297671f, 0.11582209f, -0.13676296f, 0.02031613f, -0.14813213f, -0.09425306f, 
    -0.13455686f, -0.01881413f, -0.08155651f, -0.07938272f, -0.32781875f, 0.19987629f, -0.09582777f, 0.08868786f, 
    0.04718907f, -0.06949271f, 0.13912812f, 0.04474267f, -0.00145350f, -0.01308098f, -0.00306523f, -0.08103067f, 
    0.43834293f, 0.02723917f, -0.00951825f, 0.05686773f, -0.09154992f, -0.01134432f, -0.02840896f, -0.05608168f, 
    0.12266476f, -0.05287918f, 0.05801844f, 0.05326158f, -0.26503229f, -0.30757877f, -0.04250755f, -0.19250420f, 
    -0.00981816f, 0.09704895f, 0.04973174f, 0.16917805f, -0.08944892f, 0.03380825f, -0.05560883f, -0.07315355f, 
    0.08537489f, 0.10677830f, -0.04875170f, 0.13433331f, -0.13940206f, -0.01826518f, 0.09163132f, -0.09987140f, 
    -0.03346298f, -0.03637775f, 0.02902005f, -0.12146670f, -0.02937898f, -0.07752705f, 0.12907743f, -0.18498498f, 
    0.03344269f, -0.13333942f, -0.11019079f, 0.06752868f, -0.02858490f, -0.08558736f, 0.12254673f, 0.00429112f, 
    -0.23668419f, 0.11474710f, -0.01774952f, -0.29422969f, 0.00709596f, 0.09524181f, -0.02920882f, 0.14056872f, 
    0.04877459f, -0.06148494f, -0.05950046f, -0.04356531f, 0.29974762f, 0.04015353f, -0.09331712f, 0.13980548f, 
    -0.04252673f, -0.00497880f, 0.02003285f, 0.07874445f, 0.01766438f, -0.00740661f, 0.12853293f, 0.06139034f, 
    0.07304137f, -0.07227636f, -0.00153649f, 0.05316715f, 0.01037510f, 0.03524525f, -0.05563384f, -0.05707942f, 
    -0.09550644f, 0.02418698f, -0.01922206f, -0.19419061f, 0.01416633f, 0.23188676f, -0.12587705f, -0.01657443f, 
    0.04181941f, 0.01400800f, -0.00670962f, 0.04271183f, 0.06204114f, -0.06865319f, -0.10777488f, -0.05580026f, 
    0.04987842f, -0.24944389f, -0.01740718f, -0.00552720f, -0.14632854f, 0.14525975f, 0.01143721f, -0.14841411f, 
    0.01344630f, 0.09188810f, -0.04038041f, 0.01292181f, 0.05988341f, 0.05299531f, -0.05397939f, -0.00718610f, 
    0.11572173f, 0.06400926f, 0.11566434f, -0.08432834f, 0.03392379f, 0.15805535f, 0.00658449f, -0.09277426f, 
    -0.01755355f, -0.14800625f, -0.00934371f, -0.23286614f, 0.04518517f, -0.07210043f, 0.04532514f, 0.11711729f, 
    -0.12133625f, 0.02612439f, -0.06479949f, -0.10409382f, 0.05958441f, 0.21879028f, -0.01006447f, 0.09250776f, 
    0.02191102f, 0.07816160f, 0.02828673f, -0.08544930f, -0.08480805f, 0.00606300f, -0.02225158f, -0.01294443f, 
    -0.41709793f, 0.03984106f, 0.00084559f, -0.07132620f, 0.08017731f, 0.02611797f, 0.01813447f, -0.04052788f, 
    -0.01990165f, -0.14443325f, 0.01151855f, -0.06652201f, -0.04861415f, 0.06179675f, 0.04579119f, -0.00225145f, 
    0.01674617f, 0.02581792f, 0.01489950f, -0.00282955f, -0.04642957f, -0.09496860f, -0.01064492f, -0.16690545f, 
    -0.19948952f, 0.26830268f, 0.03448638f, -0.01342850f, 0.12654203f, -0.01747494f, 0.03100903f, -0.18264174f, 
    -0.03386180f, 0.00020534f, 0.00520140f, -0.05233116f, 0.16183528f, 0.03655961f, -0.14600334f, 0.15408470f, 
    -0.14566331f, -0.00041280f, 0.01632513f, 0.16037245f, 0.03918869f, -0.05881306f, 0.14880817f, 0.01311183f, 
    -0.14248966f, -0.10524648f, 0.19696283f, 0.19776019f, -0.27661604f, 0.00234302f, -0.00257392f, 0.03731152f, 
    -0.07615703f, 0.02500347f, 0.01656715f, -0.05742075f, -0.14506787f, 0.11664554f, 0.02523936f, -0.13577154f, 
    0.06773736f, 0.06543168f, -0.06135851f, 0.02266276f, 0.10664584f, 0.01510975f, 0.11730386f, 0.10396418f, 
    0.10508422f, -0.19441366f, -0.03915621f, 0.09031293f, 0.04342598f, 0.01338022f, -0.04602117f, -0.07431022f, 
    0.06511489f, 0.04923250f, 0.00970818f, -0.08057683f, -0.22309254f, -0.05261656f, -0.02470626f, -0.21121509f, 
    -0.01077860f, 0.00954081f, 0.06651811f, 0.01869743f, 0.00037926f, 0.12863392f, -0.03238415f, 0.18356162f, 
    0.09296126f, -0.14782479f, 0.06500693f, 0.19806890f, 0.02778973f, -0.01635043f, 0.06623793f, 0.01402232f, 
    -0.02449494f, -0.00427428f, -0.03078927f, 0.01016830f, 0.11127468f, -0.19524609f, 0.01859343f, 0.10788258f, 
    0.01982837f, -0.04999545f, 0.05881521f, -0.06949516f, 0.03777033f, -0.04414895f, 0.00812039f, 0.05369501f, 
    -0.42409778f, -0.39829823f, 0.08943549f, 0.06379123f, 0.21609709f, 0.00486282f, 0.14290805f, 0.07549021f, 
    0.10299116f, -0.00432387f, 0.01539547f, 0.04250979f, 0.25015259f, 0.00138202f, -0.17893355f, -0.04183470f, 
    0.00972524f, -0.04592193f, -0.02997211f, 0.14399508f, -0.00552925f, 0.03800014f, 0.02495210f, 0.00772471f, 
    -0.04994427f, -0.26646227f, 0.02343067f, -0.14647289f, 0.04116878f, 0.12403087f, 0.06282066f, -0.09185474f, 
    0.04104046f, -0.03577601f, -0.03030680f, 0.02681605f, 0.13814245f, -0.00752600f, -0.06999107f, -0.11081149f, 
    0.03396277f, -0.05366943f, -0.01651220f, -0.11743677f, -0.01668933f, -0.02808066f, -0.03290204f, 0.00664781f, 
    0.03549320f, -0.20320468f, 0.00031853f, -0.11139280f, -0.01054346f, 0.03719040f, -0.01175352f, 0.07589851f, 
    -0.03283265f, 0.06460286f, -0.01597945f, 0.01865404f, 0.41370097f, -0.10849419f, -0.25766569f, 0.08332565f, 
    0.05452621f, -0.04693666f, -0.02709099f, -0.03255560f, -0.01465456f, -0.03043452f, 0.01903363f, -0.07616712f, 
    -0.02816514f, 0.19127673f, -0.06395503f, -0.18028998f, 0.08375037f, -0.07256610f, -0.11247861f, -0.00850267f, 
    0.06769494f, 0.04828691f, 0.12123092f, -0.03960824f, 0.22925816f, -0.04078329f, -0.14712617f, -0.32841504f, 
    0.05495958f, 0.08371836f, 0.00576482f, 0.02505345f, 0.05150139f, 0.07147915f, -0.03752916f, 0.02318976f, 
    -0.01599256f, 0.04630974f, -0.07208402f, -0.03039695f, 0.02930400f, 0.01682829f, -0.01111164f, 0.10844478f, 
    -0.01789170f, -0.08567329f, -0.05676091f, -0.06876499f, 0.00867685f, -0.05608269f, 0.03858122f, 0.01760722f, 
    -0.00458382f, -0.05600642f, 0.00836289f, 0.01708229f, -0.01763571f, 0.05833567f, 0.00332291f, -0.01151739f, 
    -0.18432048f, -0.14747618f, -0.25098976f, -0.16604458f, 0.02991850f, -0.04814751f, -0.02742059f, 0.04172787f, 
    -0.00359824f, -0.00269795f, -0.07280162f, -0.02647771f, -0.19119288f, 0.12952900f, -0.02674518f, -0.06233234f, 
    -0.04477992f, 0.00023099f, -0.07497310f, -0.04196161f, 0.07064680f, 0.08925720f, 0.03030147f, -0.11457424f, 
    0.04557547f, -0.06600943f, -0.08576985f, -0.06562532f, 0.00539850f, 0.02164320f, -0.02956947f, -0.03491231f, 
    -0.00236500f, -0.10371640f, -0.05848261f, -0.05863684f, 0.29966474f, 0.02799943f, -0.30093187f, 0.07579514f, 
    -0.07888047f, -0.02398827f, 0.08599976f, 0.05782307f, 0.03468649f, 0.03895049f, -0.00234546f, -0.02263709f, 
    -0.04577382f, -0.03627496f, 0.21049434f, -0.07048258f, -0.02487700f, 0.02141493f, -0.05419925f, -0.13472947f, 
    -0.02029968f, -0.03554342f, 0.09576073f, 0.04512602f, 0.04668282f, 0.04173540f, -0.06793676f, 0.13905202f, 
    0.14102340f, 0.04008339f, 0.06255945f, -0.18302092f, -0.02834332f, 0.00557402f, 0.01655614f, 0.02906677f, 
    -0.03563311f, -0.13222077f, 0.03100757f, -0.18191372f, -0.09518883f, -0.05769857f, -0.01534457f, 0.05201753f, 
    0.05024633f, 0.00207978f, -0.05116018f, 0.04921638f, -0.14142045f, 0.02859717f, 0.02288915f, -0.07033334f, 
    -0.14298202f, -0.04196195f, -0.01019514f, -0.05589526f, -0.07951511f, 0.05854494f, 0.00719367f, -0.14718078f, 
    -0.12938939f, -0.20967744f, -0.06659590f, 0.17961060f, -0.12814994f, 0.04580960f, -0.05231104f, -0.04564318f, 
    0.11952119f, -0.09902152f, -0.03534800f, 0.14758965f, -0.24906972f, -0.13533705f, -0.09559716f, 0.00761660f, 
    0.06926530f, 0.08738733f, 0.03555394f, 0.11850679f, -0.00323285f, -0.02038908f, -0.01294823f, 0.02984486f, 
    0.35420299f, -0.04000382f, -0.01755707f, -0.10271519f, 0.06926246f, -0.05398466f, 0.00000512f, 0.02794498f, 
    -0.01992996f, 0.04813616f, -0.01208567f, 0.00006740f, 0.19309005f, -0.13720131f, -0.03158747f, 0.18832701f, 
    -0.15959361f, -0.03932984f, -0.02414629f, 0.01333782f, -0.14038962f, 0.01682599f, -0.02347838f, -0.03184211f, 
    0.21216740f, 0.02751270f, -0.29663691f, 0.08406340f, 0.03238639f, -0.12776963f, 0.03048404f, 0.04668084f, 
    -0.03659560f, -0.03524438f, 0.03463243f, -0.08258854f, 0.35440752f, -0.06821299f, -0.04187615f, -0.09191525f, 
    0.01891404f, -0.14037909f, 0.03811458f, 0.00066333f, 0.09721719f, 0.05353111f, 0.06026377f, 0.00178045f, 
    0.08930936f, -0.32627854f, -0.07669427f, 0.06052389f, -0.01279838f, -0.04954234f, 0.04090694f, -0.02710903f, 
    0.00725203f, 0.05655871f, -0.09696296f, 0.01463908f, -0.11637332f, 0.00378660f, -0.04678388f, 0.05113264f, 
    0.07636034f, 0.01565165f, 0.05155674f, -0.00987130f, -0.04717204f, -0.00187496f, -0.09300414f, 0.09777227f, 
    -0.35355312f, 0.04918044f, 0.08610526f, 0.04737684f, -0.05564106f, 0.09679269f, 0.00224094f, 0.13525753f, 
    -0.02433320f, 0.00889872f, 0.08327200f, 0.07589097f, -0.15118232f, 0.01463351f, -0.03735987f, 0.07758190f, 
    -0.11184755f, 0.04812025f, -0.09879191f, 0.19349827f, -0.08509754f, 0.13038334f, -0.06608152f, -0.04648444f, 
    -0.02894564f, -0.22189888f, -0.02558870f, -0.24645656f, 0.03822966f, -0.10210207f, -0.07851351f, 0.14770254f, 
    -0.08876320f, -0.02593399f, 0.02204779f, 0.03323249f, 0.27622762f, -0.16817784f, -0.19672692f, 0.08239857f, 
    -0.01976509f, -0.08838595f, -0.01904021f, 0.01609533f, 0.01095365f, 0.02108378f, -0.00214119f, -0.00735684f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05234619f, 0.03833367f, -0.03469726f, -0.03103082f, 0.00843175f, 0.03222224f, -0.01621147f, -0.02316477f, 
    -0.03397567f, -0.01535159f, 0.06154839f, 0.05022321f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
