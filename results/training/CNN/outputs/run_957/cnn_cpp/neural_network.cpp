#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.24274278f, 0.92875224f, 0.09121950f, -0.94608265f, -0.17462453f, 0.07472211f, 0.01850159f, 0.15989059f, 
    0.55547184f, 0.06436054f, 0.00646520f, -0.18336041f, -0.24799259f, 0.28318319f, -0.07487503f, 0.16977313f, 
    0.06159148f, -0.19037931f, 0.13891816f, 0.19533686f, 0.12527674f, 0.20123070f, 0.21415275f, 0.53288800f, 
    0.13512787f, 0.64500427f, -0.18927197f, -0.66618323f, 0.41711617f, -0.19619028f, -0.01525494f, 0.55364436f, 
    -0.38185433f, 0.35470632f, -0.50167030f, -0.08053137f, -0.32611603f, 0.25024599f, -0.23682660f, 0.09207378f, 
    -0.09354225f, 0.32948589f, -0.28349572f, 0.18875641f, 0.18239145f, -0.47338650f, -0.00054303f, -0.02464480f, 
    -0.17076255f, 0.04579680f, 0.07352380f, 0.35349563f, 0.41300124f, 0.50749487f, 0.16467458f, 0.27602759f, 
    0.35033318f, 0.37617654f, 0.06642521f, 0.31379649f, -0.37270203f, -0.34580627f, -0.77813298f, -0.39784378f, 
    -0.04831508f, -0.31794178f, -0.03765211f, -0.38539410f, -0.20212844f, -0.26371872f, 0.04550791f, -0.02942851f, 
    0.01966913f, -0.37803155f, -0.17334163f, -0.62430108f, -0.33093274f, -0.13199018f, 0.08589728f, -0.35575286f, 
    0.63296378f, 0.86571765f, -0.41471183f, 0.48485851f, 0.55420327f, -0.18461736f, -0.42255363f, 0.29540780f, 
    -0.24716242f, -0.39696425f, -0.31323326f, 0.25157788f, 0.02684547f, -0.01392802f, -0.20749857f, -0.00386156f, 
    -0.47020641f, -0.41010559f, -0.32621232f, 0.18072034f, 0.29145509f, -0.25241819f, -0.90095609f, -0.79023659f, 
    0.04374139f, 0.74031347f, -0.38244671f, -0.00344017f, 0.27165794f, 0.35944429f, -0.51696980f, -0.32470503f, 
    0.02941852f, -0.23100878f, -0.21806227f, -0.16474755f, 0.07361952f, 0.26277700f, 0.24256061f, -0.36019969f, 
    0.23267134f, 0.14261064f, -0.42081550f, 0.23180409f, 0.27051675f, -0.76419258f, -0.64708930f, -0.41839632f, 
    -0.23497023f, -0.21842465f, -0.06718208f, -0.30300954f, 0.17207544f, 0.02623309f, 0.23761596f, 0.24418855f, 
    0.31563431f, 0.05612309f, 0.20608608f, -0.21141735f, -0.22184786f, 0.23716202f, -0.05238978f, 0.13423778f, 
    -0.23076180f, 0.03639420f, -0.33553606f, 0.19136016f, 0.00096146f, -0.22288948f, 0.72585458f, 0.57144117f, 
    0.54214174f, 0.01896199f, 0.85246193f, 0.63154203f, -0.19500507f, -0.43732294f, 0.08942979f, -0.16019537f, 
    0.33748209f, 0.30444017f, 0.09995380f, 0.35131681f, -0.28060880f, -0.24782741f, 0.13141854f, 0.23437402f, 
    0.23167646f, 0.09283181f, -0.00101240f, 0.04776267f, 0.14301284f, 0.02127678f, 0.15544584f, 0.94035590f, 
    0.61240005f, -0.20120758f, 0.36799961f, 0.39044932f, -0.25794590f, -0.22078615f, 0.01575210f, 0.08530960f, 
    0.35934758f, -0.17383924f, 0.17910910f, 0.29960266f, -0.14610645f, 0.19594809f, 0.13806789f, -0.21445918f, 
    0.31905031f, -0.21009986f, 0.13955002f, 0.46190861f, -0.11595175f, 0.34786576f, 0.11019432f, 0.22412521f, 
    0.93350029f, 0.14480190f, -0.43658879f, 0.49965900f, 0.91736805f, 0.70689845f, 0.13816860f, 0.15149124f, 
    0.30041167f, 0.00164169f, -0.32910812f, 0.29588637f, -0.15639243f, -0.10208713f, 0.22696909f, 0.03245905f, 
    -0.22209926f, 0.11911679f, -0.09199312f, -0.01502972f, -0.14494896f, -0.19385508f, -0.18769044f, 0.35003102f, 
    -0.03010578f, -0.24567138f, -0.03295134f, -0.21747196f, 0.27568442f, 0.48610666f, -0.83044487f, -0.39815244f, 
    -0.20551430f, -0.14372402f, -0.34251475f, 0.22476073f, 0.26961839f, -0.04865731f, -0.27735150f, 0.35090169f, 
    0.02747635f, 0.13691917f, -0.21675397f, 0.05552353f, 0.21823798f, 0.19713148f, -0.08954787f, -0.19079196f, 
    -0.41843420f, 0.34429625f, 0.39755946f, -0.64594549f, 0.12005752f, 0.31973657f, 0.69380820f, -0.58497494f, 
    -0.01846886f, -0.38636634f, -0.73287868f, 0.16439642f, 0.35779881f, 0.66407758f, -0.12929410f, 0.10608529f, 
    -0.24170335f, 0.12133996f, -0.37852541f, -0.05638242f, 0.29254168f, -0.37959647f, -0.21616592f, -0.10212629f, 
    -0.00921979f, 0.20461880f, -0.15837757f, -0.49758098f, -1.22350323f, -0.31193143f, 0.22083753f, -0.40555719f, 
    0.31362125f, 0.70453835f, 0.55099350f, -0.19991231f, 0.18526430f, -0.33021846f, -0.19439134f, -0.36250004f, 
    -0.14778998f, -0.32264221f, -0.13941395f, 0.17041704f, 0.23514658f, -0.05838573f, -0.27360898f, -0.15590097f, 
    -0.07518309f, -0.02853690f, -0.12157267f, -0.05316697f, -0.13035208f, 0.37079245f, -0.27523965f, -0.23277514f, 
    0.17533815f, 0.19083525f, 0.84170848f, 0.33799502f, 0.48924553f, 0.69295514f, 0.09871782f, -0.49235982f, 
    0.05835542f, -0.12147208f, 0.04752688f, 0.27986857f, -0.21198604f, -0.49249235f, -0.02874002f, -0.09791563f, 
    0.21913819f, -0.32885647f, 0.15907229f, -0.07977126f, -0.12971644f, 0.41516033f, 0.14517553f, 0.37256080f, 
    0.72647667f, -0.09306367f, -0.22117876f, -0.68799138f, -0.57484275f, -0.64743245f, 0.34231800f, 0.31748822f, 
    0.67509884f, 0.06499856f, 0.33556774f, -0.37808242f, -0.15707536f, 0.12632628f, -0.15137063f, -0.12208631f, 
    -0.01396925f, 0.15812249f, -0.09686674f, -0.20032516f, 0.05022190f, -0.00276230f, 0.38946512f, 0.82717913f, 
    0.80516571f, 0.33970588f, 0.15599447f, 0.33192369f, -0.14138082f, -0.40856302f, 0.03083739f, -0.25827870f, 
    0.23950127f, 0.10824841f, -0.12435439f, 0.25642443f, -0.16227612f, 0.37347761f, 0.29560316f, 0.14678754f, 
    0.08714536f, -0.30753431f, -0.28491363f, 0.01059861f, -0.05121872f, 0.27634725f, 0.02509459f, -0.09438489f, 
    0.05756761f, -0.42666122f, -0.12565275f, -0.03694285f, -0.80591786f, -0.47753525f, -0.54579949f, 0.05684967f, 
    -0.36560881f, -0.05835141f, 0.52792478f, -0.19735634f, -0.15527759f, 0.42946202f, -0.14974730f, -0.40950781f, 
    -0.48267338f, -0.33431235f, -0.06365859f, 0.43682519f, 0.00211572f, 0.02980519f, -0.02038856f, -0.00943824f, 
    0.89717901f, -0.64972717f, 0.75462896f, 0.45118329f, -0.41292983f, 0.22790922f, -0.49040523f, 0.14017271f, 
    0.13681981f, 0.02898875f, 0.03930769f, -0.30470937f, -0.04217860f, 0.11956286f, 0.16956536f, -0.02463534f, 
    0.20495059f, -0.10874832f, 0.00976442f, 0.41259575f, 0.23494682f, -0.05865541f, 0.28702232f, 0.16677062f, 
    0.19813634f, 0.80100763f, 0.60571939f, 0.77237290f, 0.26151216f, 0.32879689f, 0.37791750f, -0.18401049f, 
    -0.13648452f, -0.19356035f, 0.34811646f, -0.08582361f, 0.26449558f, -0.05251192f, 0.18922405f, 0.10379186f, 
    -0.02470685f, 0.05836037f, 0.33979028f, -0.13720937f, -0.20834139f, 0.05274196f, 0.26704937f, -0.10280900f, 
    -0.23845674f, 0.39075601f, -0.49175620f, -0.66085452f, -0.57712591f, -0.53316301f, -0.16061336f, 0.04799821f, 
    -0.56053823f, -0.50629514f, -0.07804785f, -0.19025193f, 0.01872107f, 0.03389337f, 0.38467059f, 0.28012723f, 
    0.09850563f, 0.43665755f, 0.16650802f, 0.38196346f, 0.06147464f, 0.15979336f, -0.13439858f, 0.10097753f, 
    0.10861924f, -0.07382267f, 0.15183230f, 0.85818887f, -0.06701886f, -0.83070248f, -0.77647769f, 0.12897460f, 
    -0.26388541f, 0.39709154f, 0.30770475f, -0.16808218f, -0.15877697f, -0.05991496f, 0.04889357f, 0.40588135f, 
    -0.13117823f, -0.25854641f, 0.10977887f, -0.25097206f, -0.00692071f, -0.25972307f, -0.14429249f, 0.10143527f, 
    -0.15080640f, 0.26391974f, 0.18339758f, -0.22838488f, -0.68308371f, 0.43125033f, 0.95630300f, 0.28830150f, 
    -0.18497646f, 0.24824496f, -0.32583058f, -0.00357585f, -0.11202717f, -0.21826577f, 0.10713859f, 0.36273304f, 
    -0.41847357f, -0.06811028f, 0.41166100f, 0.09863839f, -0.15330268f, -0.17473711f, 0.04041646f, 0.08939753f, 
    0.02598090f, 0.18008728f, -0.04863255f, -0.15205343f, 0.39342749f, -0.59297866f, 0.42590949f, 0.20580219f, 
    -0.77423006f, -0.11107872f, -0.18361609f, 0.70143527f, 0.40300772f, -0.13766502f, 0.44967616f, -0.02472063f, 
    0.36568296f, -0.16188064f, -0.08474074f, 0.23286945f, 0.26092979f, -0.07773113f, 0.10473887f, 0.29036650f, 
    -0.10817830f, 0.05485667f, 0.35714376f, 0.23436718f, -0.05880528f, 0.26232323f, 0.03462907f, -0.56633061f, 
    -0.68991911f, -0.71486616f, -0.39348412f, 0.15868144f, 0.77415663f, 0.50385809f, 0.38741708f, 0.42345223f, 
    -0.54591817f, 0.13712066f, -0.30929235f, -0.07063477f, 0.08516958f, -0.12991153f, -0.12938423f, -0.04370067f, 
    0.03518639f, -0.04267431f, -0.09407986f, -0.08258832f, 0.11169707f, -0.19189927f, 0.12790404f, -0.00834816f, 
    -0.49494219f, 0.52276373f, -0.14261359f, 0.80370462f, -0.66403913f, 0.59431159f, 0.34461728f, -0.24141526f, 
    0.18964998f, 0.18124817f, 0.24381272f, 0.13094383f, -0.19355239f, -0.16277149f, -0.28631514f, -0.47888932f, 
    -0.29201281f, 0.22610229f, 0.06162612f, 0.04932027f, 0.05916223f, 0.05492012f, -0.07774875f, 0.15205507f, 
    -0.64077711f, -0.15848194f, 0.39710554f, 0.51026738f, -0.08672105f, -0.52300990f, -0.22107010f, -0.35158920f, 
    -0.28496903f, -0.60519600f, 0.05076553f, 0.50518835f, -0.09669635f, 0.05413992f, -0.27452487f, 0.01069421f, 
    0.06117747f, -0.00483001f, 0.04298155f, 0.54516077f, -0.29604286f, -0.33512402f, -0.13646489f, 0.45595938f, 
    -0.31903672f, 0.16945882f, 0.02013121f, 0.95468241f, 0.67032748f, -0.30993691f, 0.20128328f, 0.46292979f, 
    -0.20590672f, -0.48878536f, 0.70420682f, -0.29076716f, 0.06504559f, 0.14763169f, 0.46549663f, 0.00408644f, 
    -0.14986038f, -0.36256608f, -0.12485744f, -0.07419319f, -0.04440877f, 0.25554916f, -0.05606576f, 0.00561011f, 
    0.54898077f, -0.04255452f, -0.32315069f, -0.36411721f, -0.22138926f, 0.66892213f, -0.47973371f, -0.68919498f, 
    0.55925596f, 0.65887105f, -0.61462814f, -0.04749149f, 0.21095353f, 0.35750782f, -0.21690273f, 0.00283838f, 
    -0.31216171f, -0.22778723f, -0.10616250f, 0.03501866f, 0.24367355f, 0.10247747f, -0.04242133f, 0.05881805f, 
    0.36826989f, 0.55372995f, -0.05090989f, 0.81297046f, -0.17203592f, 0.47332230f, 0.94837141f, 0.55658901f, 
    0.54903167f, 0.49847555f, 0.11915183f, -0.05926556f, 0.28446403f, -0.45110777f, -0.34907204f, -0.05674036f, 
    -0.02957743f, -0.14974238f, -0.13414980f, 0.12371436f, 0.31708062f, 0.36645317f, -0.11417492f, -0.07419459f, 
    -0.06283881f, -0.01485943f, -0.05883072f, 0.10419163f, 0.00498043f, -0.26693279f, -0.36635011f, -0.59638906f, 
    -0.35192338f, 0.74632448f, -0.43087155f, 0.18954676f, 0.34708020f, 0.16893186f, 0.46899405f, 0.07196978f, 
    -0.19064045f, 0.31246564f, -0.21959426f, -0.24544922f, 0.14865685f, 0.14489520f, -0.32495114f, 0.40845713f, 
    0.24544795f, 0.32674628f, 0.41729441f, 0.23711938f, 0.01276088f, 0.90504080f, 0.26646718f, 0.59886450f, 
    0.15122022f, 0.01677272f, 0.38976386f, 0.30304971f, 0.29560038f, -0.33437607f, -0.65247470f, 0.05162936f, 
    -0.23291893f, -0.06318302f, -0.09583837f, -0.27539477f, 0.10471261f, -0.15199745f, -0.02714834f, -0.22750723f, 
    -0.20224683f, -0.05071306f, -0.12044917f, 0.02420559f, 0.07182978f, -0.20907593f, -1.01861131f, 1.21023989f, 
    -0.73118711f, 0.28336966f, 0.02531152f, -0.05958411f, 0.21505973f, -0.37541950f, 0.48706809f, -0.10082884f, 
    -0.31072554f, -0.07048963f, -0.21623002f, -0.28634200f, 0.13128951f, -0.16982698f, 0.07508951f, 0.01919278f, 
    0.08129507f, -0.14326884f, 0.07477365f, -0.12294600f, -0.24981125f, -0.15501830f, -0.03663959f, 0.62755644f, 
    0.03207017f, 0.47593507f, 0.40705881f, 0.31513000f, 0.74422812f, 0.54737550f, -0.32965964f, 0.06460372f, 
    0.24775235f, -0.41715318f, 0.34705809f, 0.10974968f, 0.10635911f, -0.40119547f, -0.15737413f, 0.26017311f, 
    0.10334441f, -0.60888070f, -0.16194032f, -0.06581686f, -0.08565167f, -0.02338112f, 0.19941831f, -0.03291035f, 
    -0.19813128f, -0.03027631f, 0.89998055f, 0.16427004f, -0.84250748f, 0.10943530f, -0.14837192f, -0.27633405f, 
    -0.01466875f, -0.47186613f, 0.16752070f, 0.46278194f, 0.29947743f, -0.21951833f, -0.14118776f, 0.01112833f, 
    0.27085009f, 0.32462078f, 0.09938107f, -0.12624341f, 0.11946361f, -0.01721060f, -0.38026598f, 0.17477554f, 
    -0.36692780f, -0.61610365f, 0.02279330f, 0.51608992f, 0.55836046f, 0.76001000f, 0.68563336f, 0.72215801f, 
    0.62187332f, -0.21034616f, 0.21856050f, -0.06950758f, -0.30851197f, 0.44731665f, 0.34817281f, 0.21238069f, 
    0.20010652f, 0.08190588f, -0.12989748f, 0.04719088f, -0.09389532f, 0.08555157f, -0.27007633f, -0.03651115f, 
    0.30406284f, -0.18330334f, -0.62017739f, -0.41294202f, 0.01756010f, -0.39027527f, 0.24011064f, 0.17534097f, 
    0.54670686f, -0.37478328f, -0.44768375f, -0.38750362f, -0.34609991f, -0.23468493f, -0.48467752f, -0.33538502f, 
    -0.48746106f, 0.12695856f, 0.11357579f, 0.32972091f, 0.17415939f, -0.13182966f, 0.32489508f, -0.21610558f, 
    0.16649039f, -0.22468048f, 0.06971866f, 0.85010457f, 0.68349153f, -0.61570060f, 1.12452352f, 0.43998763f, 
    0.34828922f, 0.07164122f, -0.41598260f, 0.51588833f, -0.23337989f, -0.05747074f, -0.19300948f, -0.32357296f, 
    0.19460839f, -0.02499079f, -0.02069218f, -0.04628269f, -0.24254352f, -0.07256251f, -0.11606704f, 0.13935518f, 
    -0.21417546f, -0.30138779f, 0.03667574f, -0.05451829f, 0.46085745f, -0.36814389f, -1.16426241f, -0.41792968f, 
    -0.00217113f, -0.81725365f, 0.33197629f, 0.50048459f, -0.03409674f, 0.37955719f, 0.48379341f, -0.28433120f, 
    0.18723781f, -0.32259262f, 0.48736399f, 0.02779607f, 0.14802845f, -0.07185705f, 0.09496418f, 0.08752139f, 
    -0.09308110f, -0.05389263f, 0.03059614f, 0.37242746f, 0.04150308f, 0.18601669f, -0.55577672f, 0.76101452f, 
    0.43808901f, -0.57462966f, 0.31464717f, -0.31474096f, -0.04419443f, 0.36446398f, 0.31973672f, 0.36241361f, 
    -0.04776472f, -0.33415720f, -0.14871024f, -0.07008306f, 0.28866690f, -0.33199945f, 0.25035501f, -0.10139701f, 
    -0.12761988f, 0.36787659f, 0.49563825f, 0.33641002f, 0.12035240f, 0.07535793f, 0.38532186f, 0.88621628f, 
    -0.26881561f, -0.34939215f, -0.80024415f, -0.17842892f, -0.51963019f, -0.30993521f, -0.41546524f, -0.17503785f, 
    0.35086405f, 0.10054076f, 0.30756009f, -0.14848559f, -0.13684027f, -0.28235725f, -0.29086661f, 0.23835814f, 
    0.02647582f, -0.28796637f, 0.03007652f, -0.10204044f, 0.14710593f, 0.35840321f, -0.18088239f, -0.41133556f, 
    -0.21442068f, 0.40035787f, 0.43582737f, -0.03974939f, -0.45279375f, 0.14142983f, 0.35411257f, 0.45167482f, 
    0.25937113f, 0.21744013f, -0.14185405f, 0.40361613f, -0.13107178f, -0.38634706f, -0.13069242f, 0.11695735f, 
    -0.12758330f, -0.35597748f, -0.10357858f, -0.34918925f, 0.12262319f, -0.14349939f, -0.26412046f, 0.65124190f, 
    0.17617063f, 0.71537340f, -0.58463931f, -0.44376853f, 0.24860154f, 0.61660129f, -0.13748245f, -0.34454393f, 
    -0.08984489f, -0.45880678f, 0.45824170f, 0.06961526f, 0.03700574f, 0.35496399f, 0.25265208f, -0.23132049f, 
    -0.49543807f, 0.10123833f, -0.22306326f, 0.29543054f, 0.21751459f, 0.27422443f, -0.21117437f, 0.09854060f, 
    -0.24414697f, 0.86061275f, -0.62810856f, 0.19794334f, -0.06266741f, -0.21709083f, 0.64693373f, 0.32159024f, 
    0.49791145f, 0.35959023f, 0.36585543f, -0.11920293f, -0.23787986f, -0.10355365f, 0.44183642f, 0.11312203f, 
    0.11832736f, 0.07738255f, -0.32491857f, 0.33804703f, 0.08262244f, -0.02376973f, -0.27732211f, -0.16081499f, 
    -0.22996646f, -0.19242965f, 0.00488786f, 0.05071192f, 0.13842717f, 0.08900195f, 0.64714003f, -0.19431598f, 
    -0.48753032f, -0.47856212f, -0.00859804f, 0.25612772f, -0.07379713f, 0.17835991f, 0.09214641f, 0.62001777f, 
    -0.24711274f, -0.43418270f, -0.40099105f, 0.06967063f, 0.47187012f, -0.19433969f, 0.18194769f, 0.27853045f, 
    -0.56153572f, 0.07441203f, -0.09209088f, 0.19379157f, 0.77615136f, 0.55826992f, 0.46109253f, 0.33235443f, 
    0.21554348f, 0.53018993f, -0.14496288f, -0.42818752f, 0.56792551f, -0.28190926f, 0.13768949f, 0.20024037f, 
    -0.56350398f, -0.13195908f, -0.18393390f, -0.07810541f, -0.20013516f, -0.01449809f, 0.02268481f, 0.07892608f, 
    0.29227832f, -0.11658772f, -0.01811533f, 0.14725424f, 1.03072214f, 0.83281559f, 0.43818879f, -0.41549808f, 
    -0.32327119f, -0.14451525f, 0.40845633f, -0.39057717f, 0.29244068f, 0.37803304f, 0.08410346f, -0.03112369f, 
    -0.30524421f, -0.30601296f, 0.15679561f, 0.14687207f, 0.05265928f, -0.01649386f, 0.32845736f, 0.05637664f, 
    -0.44774169f, -0.16967560f, -0.10692856f, -0.20851558f, 0.18991555f, -0.50880998f, -0.31691509f, -0.55069959f, 
    -0.76302719f, -0.04465018f, -0.28891471f, -0.04431606f, 0.13262196f, 0.04268362f, 0.48123500f, 0.07046667f, 
    -0.30899498f, 0.26473880f, -0.52212203f, -0.03731639f, -0.14303522f, -0.07291519f, 0.07342802f, -0.32261920f, 
    -0.12353610f, 0.10200658f, -0.38903376f, 0.19755644f, 0.30386066f, 0.05108666f, -0.30158737f, -0.45003510f, 
    -0.53862655f, -0.05037037f, -0.27546224f, 0.06378669f, -0.01353330f, 0.04419624f, -0.07244386f, -0.80357164f, 
    -0.49448630f, -0.13008071f, 0.08781826f, 0.44245145f, 0.52910262f, 0.29057041f, -0.00072956f, -0.09302270f, 
    -0.09482870f, -0.16844226f, 0.34259248f, 0.19942875f, -0.16937749f, -0.11506337f, -0.06294523f, 0.86155963f, 
    -0.47329953f, -0.51366967f, -0.33113030f, -0.40277866f, 0.60186023f, 0.67009443f, 0.59119564f, 0.59341729f, 
    -0.08962696f, 0.31543660f, 0.03583888f, -0.41749367f, 0.06432641f, -0.13092108f, 0.16285589f, 0.16238917f, 
    -0.02628044f, 0.16279185f, -0.05744299f, 0.35600653f, -0.31855860f, -0.14717813f, -0.22654809f, 0.06561315f, 
    0.13041763f, 0.83464277f, -0.20162888f, 0.31392622f, 0.36501190f, 0.48873988f, -0.08406974f, -0.91064721f, 
    -0.34615889f, -0.49328297f, 0.17593220f, 0.11217640f, 0.00091948f, 0.21300244f, -0.15043847f, 0.33420017f, 
    0.15969799f, 0.05384481f, 0.28478143f, -0.01252843f, 0.24800050f, -0.10972410f, -0.12157117f, -0.29809457f, 
    0.33779266f, 0.42045680f, 0.09457321f, 0.30546233f, 0.68767548f, 0.34264830f, -0.55663002f, -0.22991979f, 
    0.29966614f, -0.51111931f, 0.01876585f, -0.24512079f, -0.10600773f, 0.32332057f, 0.39633948f, 0.18836753f, 
    0.42535925f, 0.13192225f, 0.29661116f, -0.23135842f, 0.22475141f, 0.16147713f, 0.20476611f, -0.28350455f, 
    0.24414402f, 0.33425352f, 0.25863162f, 0.46267951f, -0.16887751f, -0.78206295f, -0.74749678f, 0.61674988f, 
    -0.30984968f, -0.51218575f, -0.60477364f, -0.07710347f, 0.07866500f, -0.03880331f, -0.39344743f, 0.29667303f, 
    0.04272855f, -0.20157261f, 0.02974813f, 0.07930973f, -0.20712058f, -0.03544218f, -0.09518931f, -0.09190413f, 
    -0.17726448f, 0.04947300f, 0.13420545f, 0.40901133f, -0.36561170f, -0.45019272f, -0.30881044f, 0.47033620f, 
    0.42716312f, -0.59397423f, -0.52514106f, -0.19630432f, 0.09346440f, -0.59820479f, 0.35701546f, 0.18216492f, 
    -0.23911759f, -0.07934627f, -0.17745122f, -0.19245027f, 0.01285497f, -0.30703479f, -0.36051691f, 0.18651418f, 
    -0.10158217f, -0.11771921f, -0.14122556f, 0.12786014f, -0.19967037f, 1.00302720f, 0.67475027f, 0.05799990f, 
    0.45533368f, -0.57257867f, 0.06477456f, -0.14891264f, -0.51433194f, -0.49922946f, 0.21688205f, -0.37621307f, 
    -0.25413784f, 0.31870562f, 0.01674463f, -0.00942863f, -0.10389490f, -0.07188222f, -0.08807780f, 0.03116927f, 
    0.11577918f, -0.14507487f, 0.11134002f, 0.06684571f, 0.20634399f, -0.88797104f, -0.61722702f, -0.07712010f, 
    0.15362047f, 0.45467576f, -0.79818374f, 0.15874629f, 0.40541574f, -0.35155085f, -0.18575764f, 0.36358386f, 
    -0.04594919f, -0.02403068f, -0.12607221f, 0.33436108f, -0.03144316f, -0.11446881f, 0.47255552f, -0.12436106f, 
    -0.27155575f, -0.18587574f, -0.24778607f, -0.25718993f, 0.01206479f, -0.03221361f, 0.67662871f, 0.71046609f, 
    0.88822156f, 0.75897819f, 0.59141392f, -0.69582927f, -0.41378888f, -0.47705606f, 0.24424569f, -0.00323628f, 
    0.03888096f, 0.43313375f, -0.12450887f, -0.09667578f, -0.29131919f, 0.01160814f, 0.07140499f, -0.08308400f, 
    -0.13221696f, -0.05246757f, -0.13895412f, 0.03377346f, 0.34716138f, -0.17492254f, -0.22742568f, 0.79048204f, 
    0.63585222f, 0.14644097f, -0.88101900f, -0.83789247f, -0.32465842f, -0.63149285f, -0.29246214f, -0.35818124f, 
    0.09115670f, 0.30142537f, 0.15457702f, 0.00724780f, -0.07826515f, 0.00048099f, -0.14248554f, 0.09664995f, 
    -0.38688123f, 0.14407185f, 0.45714235f, 0.12158809f, 0.25832158f, -0.06685388f, -0.01127369f, 0.18350244f, 
    -0.11332190f, -0.52428633f, -0.35768151f, -0.15228078f, -0.46647504f, -0.25025019f, 0.62322193f, -0.48225945f, 
    -0.75327790f, 0.34909785f, 0.39320508f, -0.08240391f, 0.09537459f, -0.36734337f, 0.32785091f, -0.32324550f, 
    -0.08308895f, 0.02417064f, 0.28354615f, -0.35262105f, 0.04641679f, 0.09953950f, 0.15878765f, 0.16959253f, 
    0.10376504f, -0.56409776f, -1.17095077f, -0.68312359f, 0.43356943f, -0.22631200f, 0.28748652f, 0.11072677f, 
    -0.20084265f, 0.51999128f, 0.20018850f, -0.14306547f, 0.19688469f, -0.20512319f, 0.53408557f, 0.34932816f, 
    -0.04852960f, -0.02827347f, 0.01090980f, -0.17207904f, 0.07912517f, -0.05256152f, -0.03866767f, -0.38445848f, 
    0.20855540f, -0.12502047f, -0.95388877f, -0.34528661f, 0.25818443f, -0.14610194f, 0.05958277f, 0.79590648f, 
    0.32894742f, 0.11397175f, 0.19244008f, -0.62393022f, -0.04922496f, -0.22140087f, 0.53197521f, 0.01177121f, 
    0.05200084f, -0.08469070f, 0.07620133f, 0.36656609f, -0.11723448f, 0.02609619f, -0.18390073f, -0.24618021f, 
    -0.02060809f, 0.12560007f, -0.22199315f, 0.68889588f, -0.50474751f, -0.56149685f, 0.96785605f, -0.45146805f, 
    -0.67804062f, 0.61291456f, 0.45512801f, 0.43006358f, 0.14102319f, -0.08692552f, 0.22616553f, 0.10649494f, 
    -0.40236014f, 0.12695245f, -0.69885296f, -0.28093150f, 0.21836311f, -0.07800741f, -0.34368125f, 0.41467443f, 
    0.07399707f, -0.21568869f, 0.03522651f, 0.07440829f, -0.15078847f, -1.47095191f, -0.40586454f, 0.51107299f, 
    0.67997140f, -0.54185998f, 0.81682932f, 0.36264083f, -0.37736595f, 0.28765231f, 0.36428851f, 0.15891199f, 
    -0.15237626f, -0.21202746f, -0.02421430f, -0.08447903f, 0.07418823f, -0.16933209f, -0.20971285f, -0.01735910f, 
    0.00256641f, -0.01054515f, 0.00372368f, -0.00902998f, -0.03121114f, -0.86258507f, -0.01963161f, -0.43861267f, 
    -0.42516714f, -0.66268951f, 0.37300998f, 0.73962164f, -0.22534984f, 0.21232864f, 0.63005942f, 0.25681022f, 
    0.04360592f, -0.04322973f, -0.29444343f, -0.11111629f, 0.21978073f, 0.25539491f, 0.15591416f, -0.12444099f, 
    -0.01598925f, -0.07126506f, -0.14346196f, 0.03569322f, -0.14655443f, 0.30901271f, -0.52426535f, -0.40944234f, 
    0.02537673f, -0.40123919f, -0.60886031f, -0.44962493f, -0.43069115f, -0.46903032f, -0.18162349f, 0.33946943f, 
    -0.28059497f, 0.40209413f, -0.11663668f, 0.44226921f, -0.25599036f, 0.09484075f, -0.06536058f, 0.29809195f, 
    0.04079681f, -0.03316567f, -0.16079991f, 0.02944328f, 0.02745469f, -0.11672263f, 0.12174448f, 0.06544851f, 
    -0.17915292f, -0.42307857f, -0.44200543f, -0.40405831f, 0.33678156f, -0.22161116f, -0.14041652f, -0.20668612f, 
    -0.05264459f, -0.41652477f, 0.05340711f, -0.43592501f, -0.04005658f, 0.06151530f, -0.32432213f, -0.28921396f, 
    -0.38004360f, -0.07849675f, -0.39379227f, 0.10623797f, -0.15531813f, 0.25799352f, 0.01177471f, 0.16779310f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22547776f, 0.04956934f, 0.22987926f, 0.11267089f, -0.04690634f, 0.25661600f, -0.06870677f, 0.34110466f, 
    0.14912166f, 0.21587609f, 0.06626562f, 0.15891324f, 0.08614992f, 0.00980407f, 0.05582279f, 0.24409932f, 
    0.21917978f, 0.08702796f, 0.13336848f, 0.03515070f, -0.06210773f, 0.10967539f, 0.21212564f, 0.11162053f, 
    0.04247028f, 0.05250805f, 0.20047887f, 0.20833670f, 0.03525420f, 0.07041769f, -0.08133789f, 0.24892969f, 
    0.32919240f, -0.11842172f, 0.11881573f, 0.00459742f, 0.11611927f, -0.06081933f, 0.16471852f, 0.16501790f, 
    0.11207031f, 0.31804839f, 0.09387513f, 0.19169727f, 0.17455822f, 0.08692775f, 0.10374247f, 0.07276335f, 
    0.15170559f, 0.06316384f, 0.00579787f, 0.29387969f, 0.24223389f, 0.15235658f, 0.00611791f, 0.18023717f, 
    0.29462859f, 0.04038218f, 0.06732659f, 0.19478634f, 0.08981998f, 0.09902297f, 0.05558482f, 0.06956702f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.25624177f, 0.01992895f, -0.02167132f, -0.17055278f, -0.07129273f, 0.11680353f, 0.02282804f, 0.03874934f, 
    0.03980751f, 0.05248646f, -0.01515434f, -0.05342384f, -0.01407356f, -0.08440277f, 0.12239125f, 0.05422270f, 
    -0.10960519f, 0.03997567f, 0.00735250f, -0.00872500f, 0.00076421f, 0.04259235f, 0.01511321f, -0.08196997f, 
    -0.01811698f, 0.02133211f, 0.08999339f, 0.12135608f, -0.13502330f, 0.01138348f, 0.03325206f, -0.04821131f, 
    -0.07407260f, -0.09437697f, 0.07819462f, 0.01025953f, 0.35405207f, 0.19636542f, 0.00000410f, 0.08868697f, 
    0.03384781f, 0.01694203f, 0.00676281f, -0.02732683f, 0.06192436f, -0.10620894f, -0.14345591f, 0.07519063f, 
    0.31281361f, -0.14908439f, -0.02725325f, -0.19944118f, 0.12523252f, -0.03167850f, 0.13531117f, 0.06244185f, 
    -0.07076720f, 0.06844317f, 0.04568199f, 0.10883849f, -0.16097268f, -0.05675948f, -0.15429632f, -0.05041445f, 
    0.05907408f, -0.00613090f, -0.01971340f, 0.07697349f, 0.05749267f, -0.00151335f, -0.10223060f, -0.11362202f, 
    0.12147053f, -0.09480254f, 0.09356547f, -0.11890262f, -0.09878701f, 0.06462032f, 0.00562945f, 0.00465576f, 
    0.13963982f, 0.06342176f, -0.04338468f, 0.01993008f, 0.20801483f, -0.08834599f, -0.00942913f, 0.02366285f, 
    -0.18846458f, -0.02869961f, -0.03448691f, 0.00274060f, -0.08584104f, 0.00202988f, -0.03564641f, -0.05166613f, 
    0.26102561f, -0.09398990f, 0.03844010f, 0.15423295f, -0.03781789f, 0.05505019f, -0.03220686f, 0.04323368f, 
    -0.06470872f, -0.04599173f, -0.02106650f, -0.12661886f, -0.03497981f, 0.01666772f, 0.04354143f, 0.06538279f, 
    0.01143688f, -0.00624667f, -0.08141311f, -0.03677233f, 0.02249391f, 0.00212418f, 0.01207458f, -0.08634914f, 
    0.18756734f, -0.26046333f, 0.04094478f, 0.18205380f, -0.06769916f, -0.04270542f, -0.01514645f, 0.13032179f, 
    -0.01833860f, 0.08425198f, 0.03651035f, -0.05378544f, -0.07977993f, 0.13537772f, 0.10353877f, -0.07527058f, 
    0.07955904f, 0.11230407f, 0.04567948f, 0.05732689f, -0.03268285f, -0.01639078f, 0.02672244f, 0.06916887f, 
    0.21311176f, 0.09023392f, 0.04118475f, -0.11619423f, -0.05741388f, 0.09760330f, 0.02391151f, -0.15210949f, 
    -0.02868080f, 0.05331438f, 0.04249446f, -0.02498115f, 0.06159009f, 0.03312735f, 0.07255036f, 0.14620990f, 
    -0.12521257f, -0.09567609f, 0.01851487f, 0.00093580f, -0.06203434f, 0.05588534f, -0.01579735f, -0.00669537f, 
    -0.11435288f, 0.05738043f, -0.13241696f, -0.08132037f, -0.14930721f, -0.07532720f, 0.03852824f, 0.06805103f, 
    0.05488601f, 0.01555748f, -0.17091444f, -0.04442594f, -0.23552735f, -0.11728387f, 0.12820889f, -0.01069842f, 
    0.03755092f, 0.03847787f, -0.02263816f, -0.09163786f, 0.06085725f, 0.01070477f, 0.13031675f, -0.08046274f, 
    0.21082234f, -0.24320887f, -0.20895043f, 0.31095490f, -0.05691787f, -0.06733896f, -0.00139702f, -0.08849657f, 
    -0.09799438f, 0.01804146f, -0.11467387f, 0.06533731f, 0.06012819f, -0.06888876f, -0.01667900f, -0.04482886f, 
    -0.18829265f, -0.15070811f, 0.06901710f, 0.05419785f, -0.00551857f, 0.05265642f, -0.10802013f, -0.02077234f, 
    -0.04350597f, -0.29505336f, 0.01906413f, 0.05689390f, 0.05996149f, -0.03980929f, 0.02249580f, 0.00803320f, 
    0.02857547f, -0.14404693f, -0.10294313f, 0.01477562f, -0.32575291f, 0.09360316f, 0.07128641f, -0.44890624f, 
    0.00243814f, -0.04609463f, -0.05965176f, -0.01655722f, -0.08456456f, 0.01624184f, 0.05752454f, 0.02635201f, 
    -0.45011577f, 0.19789590f, 0.14050147f, 0.16089018f, -0.08814915f, -0.06084218f, 0.03853166f, -0.08241005f, 
    0.05547565f, 0.05639841f, 0.11503679f, 0.05394802f, 0.06033757f, -0.03453499f, 0.10258075f, -0.19640152f, 
    0.08926278f, -0.01861370f, 0.07287522f, -0.06504630f, 0.04583986f, -0.08144334f, -0.06275817f, 0.08923731f, 
    0.09899216f, 0.04726425f, -0.03052865f, -0.34807086f, 0.01101626f, 0.01752313f, 0.09094600f, -0.07436800f, 
    0.03282894f, -0.06193170f, -0.01124532f, 0.07948083f, -0.04655515f, 0.01991146f, -0.04586388f, -0.09297786f, 
    -0.14215091f, 0.04775580f, -0.04070079f, 0.00849318f, 0.02402660f, 0.05904954f, -0.10782237f, 0.05209571f, 
    -0.13681552f, -0.05064205f, 0.01818600f, 0.18533744f, 0.08367303f, 0.01132588f, 0.09634922f, 0.04115113f, 
    0.13148090f, -0.05885906f, -0.01788040f, -0.09354652f, -0.07068072f, 0.21558022f, -0.09272826f, 0.19938150f, 
    -0.04411686f, -0.13895424f, 0.00248839f, -0.06427905f, -0.07800589f, 0.01292874f, -0.03354332f, 0.07938316f, 
    -0.34220803f, 0.02581464f, 0.01098450f, 0.09891398f, -0.11767170f, 0.05142187f, -0.05651475f, -0.02234300f, 
    0.14436163f, -0.04939840f, 0.11387407f, -0.02997141f, 0.08343484f, -0.05727267f, -0.06018767f, 0.29360461f, 
    -0.10393681f, 0.04170077f, 0.03862015f, 0.04672176f, -0.08260053f, 0.06144740f, -0.07106414f, 0.04338497f, 
    0.17331541f, -0.18662305f, -0.06594580f, -0.24057360f, 0.10801645f, 0.06597304f, 0.12382584f, -0.02274958f, 
    -0.13026319f, 0.01333428f, 0.02815530f, 0.05433140f, 0.08203167f, 0.05273693f, -0.03545401f, -0.05368492f, 
    -0.18982507f, -0.14080878f, -0.07166979f, 0.07702540f, -0.05028789f, 0.03746422f, 0.06167796f, -0.11370485f, 
    0.43614477f, 0.11624410f, -0.00078006f, -0.06295634f, -0.05075850f, -0.03544340f, 0.12414537f, -0.16548827f, 
    -0.12097979f, 0.01078380f, -0.04091960f, 0.00200000f, 0.03795249f, 0.04479210f, -0.03981084f, 0.16295899f, 
    -0.12404621f, -0.20179522f, 0.07726276f, 0.01954895f, -0.08654018f, 0.06498697f, 0.00528194f, 0.03133049f, 
    -0.21965180f, 0.04807320f, 0.01332519f, 0.23798661f, -0.02074297f, 0.01115716f, 0.14174950f, -0.13375019f, 
    -0.07950316f, 0.09143479f, -0.08768934f, -0.07035111f, -0.24982984f, 0.03045293f, 0.06722759f, 0.07679599f, 
    0.07648533f, 0.03936590f, 0.00479764f, -0.13320929f, 0.10968375f, 0.02888914f, 0.05041010f, -0.05930082f, 
    -0.23944172f, -0.03313268f, 0.20030677f, -0.20910956f, -0.03470328f, -0.00950050f, -0.00146697f, 0.07452440f, 
    -0.02537234f, -0.07064484f, 0.03547020f, 0.12424747f, 0.05628639f, 0.08809613f, 0.00255836f, 0.25719631f, 
    -0.15793116f, 0.02303294f, 0.08533429f, 0.05745999f, 0.01739235f, 0.04914345f, 0.09192767f, -0.04639567f, 
    -0.31808397f, 0.15205887f, 0.04093937f, -0.07944147f, 0.12970228f, -0.06284318f, 0.08489382f, -0.08634730f, 
    -0.00149488f, -0.11705692f, -0.06876670f, 0.05125105f, 0.01381680f, 0.01218801f, -0.13551271f, 0.26102248f, 
    0.06128015f, 0.12217533f, -0.03230867f, -0.01925124f, 0.01955299f, -0.06620838f, -0.07726923f, 0.05271044f, 
    -0.18414417f, 0.11254729f, 0.07630208f, -0.06891534f, -0.13131182f, 0.08786791f, 0.05612364f, -0.13480955f, 
    -0.04263422f, -0.03528887f, -0.03033923f, -0.02466715f, -0.01611987f, 0.11657213f, -0.12650551f, 0.10543595f, 
    -0.07179946f, -0.00824433f, 0.00827906f, -0.05551787f, 0.01451277f, -0.01624882f, -0.09052194f, 0.01580107f, 
    -0.02154370f, 0.10358929f, 0.15342766f, -0.17063583f, -0.23385391f, -0.02015866f, 0.11450730f, -0.04998988f, 
    0.17649455f, -0.07931516f, 0.02818325f, 0.12094705f, 0.10982070f, -0.10780441f, -0.11435644f, -0.01704727f, 
    0.04302759f, -0.05953065f, -0.02211537f, -0.04535604f, -0.02563649f, -0.03669059f, 0.00044431f, -0.00310472f, 
    0.09064461f, -0.12694062f, 0.11018898f, -0.19523887f, 0.02671328f, 0.12747736f, -0.01723897f, -0.11574598f, 
    -0.10733024f, 0.01859264f, -0.07475102f, 0.00060968f, 0.00170068f, 0.14212847f, 0.07903320f, 0.02389006f, 
    -0.11229142f, -0.15291010f, -0.01439035f, -0.07682916f, -0.01480083f, 0.01608895f, -0.08816911f, 0.11086313f, 
    0.06292779f, 0.14103658f, 0.07501616f, -0.21783680f, -0.06349175f, -0.10521836f, 0.05521910f, 0.09772845f, 
    0.12016147f, 0.02046596f, -0.01094302f, -0.02188715f, 0.05533401f, 0.04935706f, -0.12316731f, -0.25172174f, 
    -0.04747577f, -0.03112711f, -0.10633301f, 0.09177000f, 0.04828874f, 0.01056312f, -0.08068253f, -0.02876227f, 
    -0.15197571f, -0.02330413f, 0.02806696f, 0.05706399f, 0.06415781f, -0.02341144f, -0.02386071f, 0.09742682f, 
    0.07416341f, 0.05634346f, -0.03569342f, -0.06534904f, 0.09238836f, 0.14529823f, -0.00877316f, -0.16806230f, 
    0.00014020f, -0.03291918f, -0.06190035f, -0.09833772f, -0.14620396f, -0.00842105f, -0.07990937f, -0.01702902f, 
    -0.06581326f, 0.05897168f, 0.07655148f, -0.18337265f, -0.15522616f, -0.00755569f, 0.02723571f, 0.08808053f, 
    0.01335725f, -0.01036776f, -0.00984024f, 0.05057276f, 0.09005892f, -0.00906681f, -0.18378113f, 0.07870227f, 
    -0.07844431f, -0.03515030f, 0.03992421f, 0.03380096f, -0.09913667f, -0.02773667f, -0.01225082f, -0.01421384f, 
    -0.21190424f, 0.10517520f, 0.04812235f, -0.35866293f, -0.03047215f, -0.00674971f, 0.11487910f, -0.07405130f, 
    -0.13866393f, 0.02696308f, -0.07247239f, 0.05307468f, 0.06374475f, -0.32096058f, 0.12697995f, -0.10171855f, 
    0.01538876f, 0.02888462f, 0.07542913f, -0.09355564f, -0.17546432f, 0.00212821f, -0.00512116f, 0.01339738f, 
    -0.07109642f, 0.13111812f, 0.02962461f, -0.12827757f, -0.09202176f, -0.10495140f, -0.00238715f, 0.00630689f, 
    -0.01706918f, -0.11819076f, 0.01143082f, -0.10595926f, -0.29979542f, 0.07177136f, -0.27130249f, 0.12094557f, 
    -0.05597299f, -0.12593313f, -0.06105803f, 0.03176665f, -0.03613682f, 0.00805835f, 0.00238469f, 0.13009796f, 
    0.10316902f, -0.02614891f, -0.06014867f, 0.08681346f, -0.12817334f, -0.11502907f, -0.08781538f, 0.04673299f, 
    0.07182959f, -0.00155112f, 0.04104925f, -0.05833478f, -0.23526125f, 0.15789449f, 0.12834039f, -0.28890631f, 
    0.11426465f, 0.00779784f, 0.07118640f, 0.06024035f, -0.03708168f, -0.25065264f, -0.03622519f, 0.07085110f, 
    -0.21915227f, -0.09909482f, 0.23309191f, -0.07923762f, 0.02376035f, -0.06769434f, 0.01227039f, -0.06701429f, 
    0.06826872f, 0.05540485f, -0.13499577f, -0.04415543f, -0.08106283f, -0.04854679f, -0.13695960f, -0.03861439f, 
    0.09852110f, -0.04851256f, 0.00427643f, -0.01770318f, -0.01330350f, -0.15403104f, -0.01648951f, 0.00227246f, 
    0.02872237f, -0.06978944f, 0.08279952f, -0.16855541f, 0.17682730f, 0.02490909f, -0.08573979f, -0.05829075f, 
    0.05666625f, 0.02815566f, 0.01865081f, -0.01193495f, -0.15521127f, 0.10841157f, -0.16888267f, 0.20633954f, 
    -0.00402537f, -0.00045949f, -0.01500131f, -0.10578951f, 0.10875022f, -0.00400894f, 0.00019050f, 0.10192160f, 
    -0.34853232f, 0.30544391f, -0.04195933f, 0.22634046f, -0.08039145f, 0.04719972f, -0.09861532f, -0.04225675f, 
    -0.06476918f, 0.09163075f, -0.05891604f, -0.02760973f, 0.54041207f, 0.17619111f, 0.11907700f, -0.30815211f, 
    0.00376267f, 0.00390436f, -0.07973669f, 0.03324636f, -0.03144179f, 0.00596312f, -0.05513450f, -0.01131262f, 
    -0.34771508f, -0.11626042f, -0.02891282f, 0.01008277f, -0.03351846f, 0.08839130f, 0.05701488f, 0.11888678f, 
    -0.02825652f, 0.04338735f, -0.17896348f, -0.00869275f, 0.09361536f, -0.25439128f, -0.00038028f, -0.17061795f, 
    0.03523644f, 0.01138256f, 0.09677953f, 0.02650460f, -0.07617244f, 0.04764365f, -0.01533886f, -0.04106620f, 
    -0.47208795f, 0.03182387f, -0.10772815f, -0.30206370f, 0.02715161f, -0.00822850f, -0.07127507f, 0.09911795f, 
    0.03963834f, 0.09886340f, 0.02478816f, 0.01216683f, 0.19243564f, -0.34839460f, -0.12554149f, -0.06510787f, 
    0.10194758f, 0.06657626f, -0.08135597f, 0.01964071f, -0.14723201f, 0.03598946f, 0.00308599f, -0.10506926f, 
    0.17162059f, 0.04265202f, -0.00428923f, 0.13365701f, -0.03076138f, 0.06351937f, -0.00418767f, 0.02187031f, 
    -0.00708514f, 0.09298299f, -0.11160052f, -0.13239604f, -0.22368519f, -0.04452298f, -0.04092902f, 0.04189787f, 
    0.16786879f, 0.00761992f, -0.03958985f, 0.05697452f, -0.05624899f, 0.03744513f, 0.08535182f, -0.12709446f, 
    -0.03482387f, -0.16045994f, 0.18026257f, -0.26716563f, 0.03826850f, 0.01794801f, -0.03865751f, -0.04565497f, 
    0.11337814f, -0.10746796f, 0.12302975f, -0.05107576f, 0.15901092f, 0.01729004f, -0.05532030f, 0.11301457f, 
    -0.07994564f, -0.12055037f, 0.04628661f, 0.00036184f, -0.05454425f, -0.13002668f, 0.00076854f, 0.00836115f, 
    0.03856746f, 0.00886165f, 0.17685740f, 0.11412553f, -0.12923989f, -0.06530150f, -0.05191746f, 0.04944601f, 
    -0.16439225f, -0.08817854f, 0.09209730f, -0.05592529f, 0.13790503f, 0.01085359f, 0.18230161f, 0.16057482f, 
    -0.10287996f, -0.05710157f, -0.00323603f, 0.02272910f, 0.04467898f, 0.03720153f, -0.08300900f, 0.12916093f, 
    0.10604008f, -0.06122961f, 0.06315841f, 0.11685094f, 0.05198173f, 0.04838242f, -0.08239820f, -0.04451516f, 
    -0.03196361f, 0.09527703f, -0.08639722f, 0.15570678f, -0.10058448f, -0.16409500f, -0.12695080f, -0.09278958f, 
    0.09517253f, 0.03881421f, -0.18378156f, -0.03656590f, -0.13870202f, 0.03611922f, 0.08538947f, -0.02192460f, 
    -0.10889529f, -0.21401140f, 0.00600241f, 0.10266042f, 0.04702311f, 0.04211650f, 0.04752820f, 0.09101474f, 
    0.06020023f, -0.00577760f, -0.21961051f, 0.05423002f, 0.05995316f, 0.03090865f, -0.19511649f, 0.12652530f, 
    0.05260613f, -0.01072689f, -0.05430172f, -0.06091427f, 0.09915958f, -0.03034247f, -0.01114111f, -0.03663313f, 
    0.03450719f, 0.03025857f, 0.04817435f, -0.05619625f, 0.07242517f, 0.03855010f, -0.16035792f, -0.03722229f, 
    0.12430331f, 0.08605234f, -0.04565242f, 0.14783911f, -0.26446107f, 0.02006804f, 0.08008222f, 0.01580176f, 
    0.00874960f, -0.00197940f, 0.02142743f, -0.02209694f, 0.11025074f, 0.03712200f, -0.02791016f, -0.02388894f, 
    0.15657395f, 0.07164728f, 0.17773390f, 0.09815043f, -0.05062625f, 0.05130157f, -0.00012890f, -0.05679764f, 
    0.13612856f, 0.03157545f, 0.03607063f, 0.03859825f, -0.18463451f, -0.14020172f, -0.03555279f, -0.18420951f, 
    0.04987621f, -0.02958212f, -0.00586597f, -0.03396342f, -0.10735333f, 0.03271272f, -0.12462002f, -0.02920042f, 
    0.01827097f, 0.17045806f, 0.01479672f, 0.04162412f, -0.06130269f, 0.01892222f, 0.00687741f, 0.06618821f, 
    0.05715912f, 0.10195839f, 0.12915978f, 0.06595470f, 0.25712636f, 0.05751293f, 0.05126264f, 0.11420287f, 
    -0.07558829f, -0.05635336f, 0.09035163f, -0.05486626f, -0.02329547f, -0.09380274f, 0.10492159f, 0.02394295f, 
    -0.03148295f, 0.14692642f, 0.03782710f, -0.04422208f, 0.01623717f, -0.00815914f, 0.19062926f, 0.10009683f, 
    -0.01340672f, 0.16181692f, 0.04879646f, 0.09867922f, 0.31763452f, -0.30098730f, 0.23187248f, -0.44522238f, 
    -0.03345040f, -0.04793327f, -0.01357394f, -0.05431259f, -0.03252741f, -0.20513558f, -0.06478588f, -0.05014569f, 
    -0.03661517f, -0.07317040f, -0.20074172f, -0.05123163f, -0.04279230f, 0.01764633f, 0.05089354f, 0.02051910f, 
    0.01894197f, 0.00698227f, -0.09643451f, 0.00668934f, -0.18312630f, 0.09219623f, -0.19923605f, -0.34217203f, 
    -0.00769028f, -0.00899286f, -0.04404416f, 0.00853451f, 0.13637990f, 0.05037349f, -0.02032846f, -0.06511541f, 
    0.10056125f, -0.25580007f, 0.05479217f, -0.17003846f, 0.13319440f, -0.03535727f, 0.05557276f, 0.00166057f, 
    -0.00411909f, 0.09011037f, -0.04318699f, -0.03934304f, -0.09158143f, 0.11974549f, 0.05556957f, 0.16040322f, 
    0.04542321f, -0.04822822f, 0.07367927f, 0.10938592f, 0.05028924f, 0.02197567f, -0.07029667f, -0.06068346f, 
    -0.25554442f, -0.09751145f, -0.31134275f, -0.14122567f, -0.01911625f, 0.01236237f, -0.11500164f, -0.18227457f, 
    -0.12673999f, 0.00498180f, 0.03237052f, 0.02563625f, -0.02847698f, 0.23073839f, 0.09178558f, 0.15352386f, 
    -0.06456541f, -0.03683401f, 0.07765719f, -0.02202818f, 0.04028393f, -0.09402332f, -0.01002921f, -0.07591171f, 
    -0.10215788f, -0.08256236f, -0.25663784f, 0.17335081f, -0.15739258f, -0.01485576f, -0.12507164f, -0.04520505f, 
    0.01093715f, -0.02312743f, -0.06082043f, 0.08498884f, 0.29998183f, 0.04326444f, 0.03969080f, 0.18781833f, 
    -0.07740080f, 0.04628148f, -0.03323868f, 0.01001803f, 0.08309787f, 0.00930270f, 0.05307354f, -0.07656164f, 
    -0.09131605f, -0.12272016f, -0.01580098f, -0.09514232f, 0.05546088f, 0.08895941f, -0.08958518f, 0.03249960f, 
    0.16181470f, -0.08080669f, -0.01085916f, -0.00986464f, 0.10876939f, 0.00321240f, 0.09440812f, 0.12546720f, 
    -0.07329386f, 0.06700077f, 0.03214464f, 0.00845217f, 0.03860415f, -0.05948272f, -0.14905198f, 0.03074395f, 
    -0.29545158f, -0.13490568f, -0.37306157f, -0.29660586f, 0.16443309f, -0.00696888f, -0.08009157f, 0.05633150f, 
    0.08785103f, -0.07669403f, -0.00037065f, -0.01167262f, 0.16821235f, 0.11505567f, 0.04795882f, -0.00608061f, 
    -0.10527714f, 0.05487714f, -0.03375431f, -0.03533749f, -0.00031151f, -0.16599809f, 0.10730068f, -0.11968689f, 
    -0.37934804f, -0.02868543f, -0.18674110f, 0.04608037f, -0.07875103f, -0.08274054f, -0.05235510f, -0.08827873f, 
    0.11460376f, -0.07244280f, 0.01453539f, 0.03977299f, 0.15432483f, 0.17708027f, -0.09109365f, 0.08526762f, 
    -0.05704082f, 0.07288189f, -0.00346298f, -0.04364418f, -0.09114964f, 0.15316507f, -0.01114360f, -0.00439732f, 
    0.01584665f, -0.00901949f, -0.23021245f, -0.06656177f, 0.06023047f, -0.04412341f, -0.01688089f, 0.01969104f, 
    0.03721199f, 0.14576882f, -0.06349298f, -0.05915369f, 0.04265449f, -0.25180504f, -0.06090933f, 0.06325574f, 
    -0.04246243f, -0.03839469f, -0.13204297f, 0.06302620f, -0.05191370f, 0.04308539f, -0.16594405f, -0.04522686f, 
    0.45343474f, -0.31690809f, -0.01223096f, -0.08665324f, -0.17711380f, 0.09877215f, 0.04591672f, 0.08956075f, 
    0.01375907f, 0.02540392f, 0.00044786f, 0.07978618f, -0.25049308f, 0.08186654f, 0.07932035f, 0.15230902f, 
    -0.18562172f, -0.00981039f, 0.06690085f, 0.01913843f, -0.10527464f, -0.04482691f, 0.02026160f, 0.00468581f, 
    0.06916220f, -0.19203833f, -0.03734829f, -0.22955772f, -0.01186918f, -0.00869680f, 0.03620246f, 0.08693542f, 
    0.08754861f, 0.13206394f, 0.10920556f, 0.01333686f, -0.08850082f, 0.08761586f, -0.06738152f, 0.07629013f, 
    0.01090018f, -0.05550009f, -0.09210703f, 0.06213186f, -0.05517055f, -0.02788796f, 0.09607381f, -0.12715767f, 
    0.03081878f, -0.27062753f, -0.02505354f, -0.11147103f, 0.01163252f, -0.17894900f, 0.02747333f, -0.02533841f, 
    -0.10875070f, 0.12770203f, -0.11319393f, -0.05231240f, 0.27287975f, -0.06175934f, 0.09150270f, -0.04174559f, 
    -0.00558405f, 0.06470522f, -0.05335503f, -0.00498928f, 0.12513998f, 0.09555332f, -0.06678024f, -0.03316756f, 
    -0.05224706f, -0.04473606f, 0.01254714f, 0.06929566f, -0.11955419f, -0.03673267f, 0.02357571f, 0.16296396f, 
    -0.06164055f, -0.08314091f, -0.03030923f, -0.15304992f, 0.23448581f, 0.17057897f, 0.09815547f, 0.13423307f, 
    0.04616208f, 0.09607624f, 0.07151407f, 0.02281217f, -0.08058330f, -0.06276549f, 0.17148134f, -0.16981101f, 
    0.31372368f, 0.07916582f, -0.00854969f, -0.03402020f, -0.00604113f, -0.12905706f, -0.08223753f, -0.07390114f, 
    -0.06314988f, -0.10184415f, -0.16239399f, 0.03806081f, 0.27190864f, -0.10065909f, 0.07628381f, -0.17503864f, 
    -0.00224985f, 0.03986026f, 0.00387277f, 0.09363306f, 0.04088384f, -0.17420048f, 0.00553215f, -0.00186382f, 
    -0.10158533f, 0.02906036f, -0.02847887f, 0.00165355f, -0.18742503f, 0.00888553f, -0.00144165f, -0.00135697f, 
    -0.03602868f, 0.06958371f, -0.04513101f, 0.02257959f, 0.29834199f, -0.42849776f, 0.04103129f, -0.07537688f, 
    0.12198227f, 0.06966120f, -0.07619125f, 0.09608863f, 0.08620106f, 0.00292314f, -0.00969290f, -0.03897964f, 
    -0.00771047f, -0.23725934f, 0.03014272f, -0.11380138f, -0.07818520f, 0.02153815f, -0.03867968f, 0.04115470f, 
    0.05411929f, 0.09973458f, -0.07774747f, -0.03341779f, -0.01236005f, 0.04924705f, -0.00108672f, 0.10518879f, 
    -0.12910439f, 0.03844876f, -0.08011811f, 0.02057631f, 0.05425750f, 0.09458798f, 0.03812767f, 0.12991489f, 
    0.01274121f, 0.01691921f, -0.09657121f, -0.17076777f, -0.01166467f, -0.03257621f, 0.10673081f, -0.01615099f, 
    -0.07405237f, -0.03258475f, 0.04565805f, -0.08812974f, 0.05751630f, -0.00860229f, 0.09625068f, -0.28795657f, 
    -0.02531319f, -0.04425462f, -0.06557318f, -0.04322451f, 0.01033708f, -0.22562283f, -0.06290521f, -0.09769199f, 
    0.04027376f, 0.12989014f, -0.12309295f, -0.07343445f, -0.01184664f, 0.15404919f, 0.07692367f, 0.00216768f, 
    0.01290520f, 0.07653760f, -0.06782714f, 0.17768908f, 0.09610717f, -0.07495147f, 0.15624721f, -0.04747418f, 
    0.01348823f, 0.10281620f, -0.22424732f, 0.01316091f, -0.14650424f, -0.21761614f, 0.04612805f, 0.05610665f, 
    0.19090110f, -0.00534472f, 0.03635901f, 0.23713908f, -0.01674935f, -0.10127203f, 0.07803261f, -0.01218451f, 
    -0.00203022f, -0.11983847f, -0.02289545f, -0.01111256f, 0.14355168f, -0.11530801f, -0.14632463f, -0.21116728f, 
    -0.09564687f, 0.03791651f, 0.02541965f, 0.01029295f, -0.10617115f, 0.12978587f, 0.10443568f, 0.10050564f, 
    0.22072768f, 0.00108550f, -0.36669698f, 0.06794150f, -0.09458401f, 0.04067456f, 0.01134562f, 0.09848353f, 
    0.06294235f, -0.05855349f, 0.01771297f, -0.05428408f, 0.28038600f, 0.05375152f, -0.14861552f, 0.08894648f, 
    0.10370759f, -0.00817066f, 0.02782537f, 0.06315058f, -0.10856393f, 0.06143513f, 0.05810256f, 0.10073720f, 
    -0.17371953f, 0.10784928f, -0.11101779f, 0.13606982f, 0.02078107f, 0.04229563f, 0.02906054f, -0.10900911f, 
    -0.06208751f, 0.06608996f, -0.03954579f, 0.06106750f, 0.14041284f, -0.22017804f, -0.08901814f, 0.13917796f, 
    0.02531105f, 0.10192078f, 0.00449325f, -0.02764480f, 0.04154306f, -0.14808291f, -0.07041217f, 0.04932542f, 
    0.26565245f, -0.21161954f, -0.05073506f, -0.00033576f, -0.08505905f, 0.02788310f, -0.04415929f, 0.01771547f, 
    0.01636750f, -0.05986438f, 0.13931674f, 0.02433690f, -0.22706403f, -0.14399630f, -0.18796802f, -0.18271345f, 
    -0.01302813f, -0.11421695f, 0.02820602f, -0.02041054f, 0.09610450f, 0.00378265f, 0.07639834f, 0.04746258f, 
    -0.17478268f, 0.01215857f, 0.00934827f, -0.02087542f, -0.04627938f, -0.02562722f, 0.04747046f, 0.04616703f, 
    -0.02223767f, 0.01682525f, 0.01786377f, 0.00217596f, -0.00650711f, 0.04895063f, 0.03386566f, -0.08943907f, 
    -0.01290417f, -0.05984515f, -0.07369798f, -0.00366155f, -0.08293003f, -0.04587750f, -0.17066345f, -0.14169492f, 
    0.21539742f, 0.09382619f, -0.01576778f, 0.06356205f, -0.01683011f, 0.05059855f, -0.08373179f, -0.06185520f, 
    -0.11464895f, -0.00427090f, 0.09877409f, 0.00794010f, -0.06716723f, -0.12913941f, -0.04954383f, -0.11207398f, 
    -0.09302091f, -0.14083685f, -0.06330197f, 0.11258756f, -0.04049648f, 0.01782839f, -0.00124129f, 0.04715253f, 
    0.02923782f, -0.00075117f, -0.04868437f, -0.12369628f, 0.11274938f, -0.02677466f, 0.02546711f, -0.00590846f, 
    0.02621402f, 0.03630685f, 0.00839580f, -0.01615870f, 0.22075216f, -0.02899759f, 0.09288338f, 0.04562659f, 
    -0.04350907f, -0.00564347f, 0.09691675f, 0.02866896f, -0.00044151f, 0.09122612f, 0.00813401f, -0.01889227f, 
    -0.23183085f, 0.06308967f, -0.00569683f, 0.26277322f, -0.04232966f, -0.07942132f, 0.03187324f, -0.09143111f, 
    -0.06393292f, 0.04655800f, -0.17439497f, 0.18010989f, 0.10348933f, -0.06221619f, 0.12041885f, 0.00804042f, 
    -0.20699233f, 0.03535190f, -0.02251722f, 0.02913324f, -0.05390434f, 0.02506015f, 0.02145074f, -0.02953551f, 
    0.09758836f, 0.06247679f, -0.00268081f, -0.00434338f, 0.04807257f, 0.01580328f, 0.07102565f, -0.02748398f, 
    -0.06828751f, 0.05620456f, -0.00988684f, -0.00802423f, 0.04029648f, -0.02967406f, -0.01917825f, -0.09367847f, 
    0.05205670f, 0.00631629f, 0.06816893f, -0.06924046f, -0.05229836f, -0.04237683f, 0.04124849f, -0.07202893f, 
    -0.03193778f, -0.03816263f, 0.05218975f, -0.07831272f, 0.09789576f, -0.06169638f, -0.01323204f, 0.06246334f, 
    0.02991091f, -0.07084496f, 0.05154051f, -0.04983990f, 0.18049537f, -0.09335449f, -0.09025466f, -0.04179693f, 
    0.00636909f, 0.00781152f, 0.03065230f, -0.01279181f, -0.07073102f, -0.00359158f, 0.05047776f, -0.09589390f, 
    0.29047483f, 0.03165579f, 0.00955554f, -0.18086769f, -0.06588084f, 0.11473496f, -0.01055822f, 0.01423724f, 
    -0.06471749f, -0.00272011f, 0.04187372f, -0.15391341f, 0.17726938f, -0.15052825f, 0.05081449f, 0.13435946f, 
    -0.14901926f, -0.10536595f, 0.00834364f, 0.06412410f, 0.08656748f, 0.05039610f, -0.06028607f, 0.00626471f, 
    0.15124755f, 0.03994345f, 0.05133829f, 0.07282828f, -0.07890715f, -0.07979933f, 0.04062049f, 0.03098628f, 
    -0.01684716f, 0.04765850f, 0.04897110f, -0.11262857f, -0.15236193f, 0.00098827f, -0.05282632f, -0.10072114f, 
    -0.08046596f, 0.15754598f, 0.00504634f, 0.02398019f, -0.04510555f, 0.10971041f, -0.00601225f, -0.05568134f, 
    0.19603914f, -0.01459342f, -0.15251890f, 0.09122524f, 0.01305763f, 0.08061501f, 0.05184302f, -0.07893088f, 
    -0.08313733f, -0.06133399f, -0.11983562f, -0.13302019f, 0.08000679f, -0.12318633f, 0.09130509f, -0.29627705f, 
    -0.03466924f, 0.01585552f, 0.04285594f, -0.05424672f, 0.14297518f, 0.08025370f, 0.08147924f, -0.12780960f, 
    -0.23467495f, -0.00852960f, -0.11921259f, -0.04647682f, 0.01057573f, 0.07424489f, -0.06316628f, -0.01891700f, 
    -0.00217078f, -0.07580650f, 0.02402058f, -0.07317716f, 0.00315330f, 0.01861778f, 0.03821783f, -0.07700613f, 
    0.06878055f, 0.10027431f, 0.01896432f, 0.01061246f, 0.01978184f, 0.09580876f, -0.04045060f, -0.00705100f, 
    -0.21178119f, -0.26427665f, -0.13973449f, -0.13771771f, -0.04160783f, -0.10117128f, -0.06372436f, -0.07586310f, 
    -0.12521340f, -0.04880874f, -0.08212238f, -0.02848111f, -0.06766082f, 0.11356329f, -0.15743253f, -0.06630748f, 
    -0.05101708f, -0.08518675f, 0.02984512f, -0.04717904f, -0.07954375f, -0.03880050f, -0.14097674f, -0.03625401f, 
    0.16798326f, 0.04147173f, -0.08946022f, 0.03529908f, -0.02170512f, 0.07314756f, -0.04588523f, -0.08592349f, 
    -0.01931067f, 0.00112075f, -0.01879995f, 0.03975021f, 0.25800803f, 0.00442252f, 0.01437463f, 0.13415141f, 
    -0.04516258f, -0.10518603f, -0.02980205f, 0.01759505f, -0.08910944f, -0.11038816f, 0.03136525f, -0.04539933f, 
    0.13644396f, 0.15940961f, 0.05076649f, 0.31516415f, -0.10454335f, -0.11190283f, -0.00452633f, 0.11489691f, 
    -0.00967417f, -0.04556036f, -0.00829275f, 0.03833903f, 0.24277708f, 0.01798796f, -0.07253686f, 0.03476286f, 
    0.10503587f, -0.03823998f, -0.06304484f, -0.08089674f, 0.04489935f, -0.04174249f, -0.00772813f, 0.05613457f, 
    0.17355776f, -0.07761081f, -0.16482152f, 0.00722678f, -0.06171897f, 0.04744834f, -0.03648103f, -0.06832104f, 
    -0.05799311f, -0.08067274f, 0.00884828f, -0.10107298f, 0.00587868f, 0.00160622f, -0.10882925f, -0.16379158f, 
    -0.09911579f, 0.04319216f, 0.02100861f, 0.09202661f, 0.05292989f, 0.11319834f, -0.04240246f, -0.05698194f, 
    0.35942066f, 0.02675708f, -0.07280558f, -0.04491568f, -0.04483778f, -0.05265866f, -0.05506375f, -0.08288076f, 
    -0.06628277f, -0.03469726f, 0.07400791f, 0.00948326f, -0.19924459f, -0.07072084f, 0.14274307f, -0.06638480f, 
    0.05474988f, 0.08157340f, -0.04519897f, 0.03923528f, 0.00142617f, -0.01220002f, -0.10521502f, 0.01409002f, 
    0.02444547f, 0.19855742f, 0.19402693f, 0.09775573f, -0.10363837f, -0.07321642f, -0.04910902f, -0.02824912f, 
    -0.01505273f, 0.01100709f, 0.05837169f, -0.04721138f, -0.22013552f, -0.04088550f, -0.00675102f, -0.21940172f, 
    0.11905123f, -0.11244956f, 0.04363940f, 0.01320674f, -0.03672184f, 0.05419299f, 0.02339521f, -0.02918135f, 
    0.03463399f, -0.15817615f, -0.36980751f, -0.14932573f, -0.04662189f, -0.01279666f, 0.03541156f, -0.06460067f, 
    -0.10835876f, 0.00117825f, -0.01514335f, 0.01480254f, -0.02744171f, -0.13452888f, 0.12213673f, -0.03678393f, 
    0.08916660f, -0.00282236f, 0.00506066f, -0.02146314f, -0.00834499f, 0.04292663f, -0.08174948f, -0.02379331f, 
    0.02253485f, -0.14202052f, -0.02560206f, -0.08954761f, -0.12343386f, 0.06824087f, 0.04129769f, 0.00711898f, 
    0.00780561f, -0.07567947f, -0.08896584f, -0.09631370f, 0.13386196f, -0.08818989f, 0.06507057f, -0.03296164f, 
    0.00611544f, -0.10283571f, -0.02913649f, -0.02392541f, 0.06220397f, -0.01000998f, 0.03451734f, -0.02271411f, 
    0.05949875f, -0.14244922f, -0.06700560f, -0.05961776f, -0.04887472f, -0.03035312f, 0.02647337f, -0.07300050f, 
    0.03942395f, 0.01698900f, 0.01765180f, 0.10874497f, 0.29280767f, -0.21906118f, -0.15129499f, -0.05873712f, 
    0.14271548f, -0.06240908f, 0.02121698f, -0.00338077f, 0.07214593f, 0.10103305f, 0.06186837f, 0.04931710f, 
    0.30217573f, -0.04705969f, 0.02884588f, 0.18323891f, -0.03740270f, -0.08788140f, 0.05629868f, 0.05117526f, 
    -0.05664751f, -0.00149367f, 0.01246825f, -0.03890909f, -0.14241970f, -0.12585053f, 0.02889988f, -0.16194546f, 
    -0.17300026f, 0.08394039f, 0.06499105f, 0.01602035f, 0.03305233f, 0.04850357f, 0.09130307f, 0.12853883f, 
    -0.32553932f, 0.00056369f, -0.02176965f, -0.25239280f, 0.00038541f, 0.09575097f, 0.04485803f, -0.07943834f, 
    -0.10942230f, -0.06456555f, 0.00784982f, -0.10766617f, 0.11941851f, 0.00570161f, -0.07085241f, 0.12144462f, 
    -0.12707098f, 0.03770425f, -0.04257715f, -0.04476194f, -0.02847276f, 0.03535235f, 0.00077400f, -0.01753945f, 
    0.00200137f, -0.06666470f, -0.04144534f, -0.08064406f, -0.04769062f, -0.13391447f, 0.07874020f, -0.11728282f, 
    0.04227528f, -0.03933799f, 0.00126655f, -0.02386829f, -0.05562328f, 0.08232050f, -0.01892941f, 0.07175390f, 
    -0.01755672f, -0.09445012f, 0.06226523f, 0.08374895f, -0.01027440f, -0.09798466f, 0.00501552f, -0.07136244f, 
    -0.06234870f, -0.06767969f, 0.01492511f, 0.04932711f, 0.05733784f, 0.00956651f, 0.10728323f, -0.07289647f, 
    -0.00219524f, -0.02624775f, -0.03493403f, 0.06101543f, 0.10858035f, -0.07481579f, 0.00790708f, 0.05119772f, 
    0.00349866f, -0.01030088f, 0.00051394f, -0.08263440f, 0.08084789f, 0.12949330f, -0.02271094f, 0.07384046f, 
    0.00788243f, -0.06550041f, 0.05889839f, -0.12791096f, -0.03977271f, -0.03118350f, 0.01453400f, 0.09072635f, 
    -0.07520057f, -0.01488927f, 0.06831000f, -0.08116007f, 0.14230084f, -0.06360613f, 0.11613117f, 0.12203679f, 
    -0.00547529f, 0.00211470f, -0.11577416f, 0.05804614f, 0.02731524f, 0.14445214f, -0.02636299f, 0.06098993f, 
    -0.00957326f, 0.00142550f, -0.11388558f, -0.14717887f, -0.15813528f, -0.09611391f, -0.03006025f, 0.04450505f, 
    0.08002140f, -0.06829859f, -0.07250844f, -0.01087168f, -0.00205404f, 0.04039665f, 0.05363957f, 0.09081056f, 
    -0.00826037f, -0.16832891f, 0.01495604f, 0.10826123f, -0.02450098f, -0.01294600f, 0.05000145f, -0.07276961f, 
    0.05673866f, -0.28444162f, -0.02728244f, -0.10372391f, 0.06968808f, -0.05298759f, 0.04558374f, -0.09183164f, 
    -0.00090308f, -0.00363736f, -0.03017432f, -0.13848205f, 0.05639124f, -0.01621400f, -0.15217529f, 0.01527347f, 
    0.07518343f, 0.05565396f, 0.02798684f, -0.06926863f, -0.06414784f, -0.04246342f, -0.10211402f, 0.01206068f, 
    -0.36707047f, -0.08975728f, -0.02343380f, -0.40001494f, 0.07844134f, 0.00410488f, 0.11454973f, 0.01789420f, 
    0.02210284f, -0.05922194f, 0.00224781f, -0.02242564f, -0.27526852f, -0.15397921f, -0.00644124f, -0.15290777f, 
    0.00578847f, 0.01200314f, -0.05801500f, -0.00168885f, 0.00435306f, 0.15669209f, -0.08980054f, -0.07388568f, 
    0.14293833f, 0.03142328f, -0.33585811f, 0.05075131f, 0.11121079f, -0.02029143f, -0.05108533f, -0.05097383f, 
    -0.09686638f, 0.04620702f, -0.04195087f, 0.08282605f, 0.44084409f, -0.16908102f, -0.21059850f, 0.04616736f, 
    0.01860340f, 0.01955307f, -0.02664393f, -0.01650734f, -0.03391425f, -0.00495265f, -0.02488307f, -0.00547017f, 
    0.00660058f, 0.16950551f, -0.11227874f, 0.13430871f, 0.05758870f, 0.05194210f, -0.00209312f, -0.01411550f, 
    -0.09377026f, 0.04132783f, -0.01559939f, -0.10122183f, -0.43611127f, -0.00211757f, 0.11513846f, -0.26986343f, 
    0.02247692f, -0.01352857f, 0.11036001f, -0.03574094f, -0.02596709f, -0.06495327f, 0.05617518f, -0.05517328f, 
    0.25145185f, -0.08733892f, 0.13649668f, -0.18620466f, 0.04702865f, -0.11652164f, -0.09534706f, 0.02801000f, 
    -0.00637102f, 0.01765864f, 0.03591352f, -0.01653715f, 0.18886788f, -0.11287840f, 0.09823307f, 0.00824293f, 
    -0.15676954f, -0.09490384f, -0.06599914f, 0.09421200f, 0.03481347f, 0.04282551f, -0.06077628f, -0.09950124f, 
    0.12102250f, -0.07532921f, 0.12464188f, -0.07881594f, -0.12787886f, 0.03984860f, -0.14559813f, 0.02762946f, 
    -0.02249148f, -0.02695659f, 0.00831095f, -0.06898886f, 0.31541643f, 0.09947312f, -0.11873051f, 0.11046527f, 
    0.02704184f, -0.04975303f, 0.04058685f, 0.04238623f, 0.01742294f, 0.06648272f, 0.04377967f, -0.07951038f, 
    0.49186370f, -0.29453573f, 0.12138098f, 0.02520239f, -0.05192479f, 0.04502476f, -0.06446490f, -0.00326801f, 
    0.01281777f, 0.00819098f, -0.00242420f, -0.00489690f, 0.25538868f, -0.03439728f, 0.19366412f, 0.08851989f, 
    0.04951737f, -0.02446589f, -0.02739474f, 0.08244240f, -0.01800494f, 0.01574913f, -0.01418887f, -0.12262750f, 
    -0.13974388f, -0.09652396f, -0.09166237f, -0.24307553f, -0.11343431f, -0.05000478f, -0.09700152f, 0.08692000f, 
    0.01543287f, 0.08394108f, -0.07559544f, -0.05470647f, -0.15288198f, -0.02268558f, -0.03214897f, -0.09049101f, 
    -0.02408931f, 0.07208237f, -0.00853272f, -0.05413433f, -0.00100222f, 0.03279437f, 0.10920829f, -0.00986476f, 
    0.05302513f, 0.28607947f, 0.09559981f, -0.15758756f, 0.00590032f, 0.02226604f, 0.02506666f, 0.07299494f, 
    0.05388635f, -0.08756665f, -0.00561730f, 0.01936531f, 0.14375378f, -0.06291544f, 0.13306482f, 0.04339863f, 
    -0.19701178f, -0.03325537f, 0.10610202f, -0.02571226f, -0.00058957f, -0.05568496f, -0.00802101f, 0.12473096f, 
    -0.44272652f, -0.22507720f, -0.00158798f, -0.02222878f, -0.10725679f, -0.01927629f, -0.05694413f, -0.01894104f, 
    -0.02187243f, 0.07992126f, 0.08724491f, -0.02937697f, -0.16959147f, -0.03469473f, -0.09829164f, -0.02213989f, 
    -0.02346985f, 0.00601021f, 0.04652847f, 0.03178954f, 0.06476481f, 0.00746049f, -0.03171263f, -0.04503642f, 
    -0.08429223f, 0.02079230f, 0.01895947f, -0.06903650f, -0.17265674f, -0.11302361f, 0.07540195f, -0.01456582f, 
    -0.10084796f, 0.07672148f, -0.10640004f, 0.04901057f, 0.06057203f, 0.03365595f, -0.00132211f, -0.06174849f, 
    -0.11377697f, -0.03434516f, -0.03248876f, 0.06216309f, -0.01840130f, 0.04523670f, 0.11312453f, 0.03799375f, 
    0.22170982f, -0.21209376f, -0.11879260f, 0.06230251f, -0.03936196f, -0.01692924f, -0.02346873f, -0.04346063f, 
    -0.03965420f, -0.07392763f, -0.02196968f, 0.01153697f, 0.08554620f, -0.30396309f, -0.19350092f, -0.05823655f, 
    -0.00146593f, -0.02504273f, -0.01710781f, -0.06204236f, 0.02901128f, -0.07950522f, -0.02764280f, -0.00682793f, 
    -0.17868716f, 0.05158394f, -0.12943967f, -0.02165430f, -0.05852089f, -0.01056892f, 0.01992920f, -0.01758658f, 
    0.06751069f, 0.00175550f, 0.07557708f, -0.01445131f, 0.04817550f, 0.07658728f, 0.09498808f, 0.11155752f, 
    0.01411297f, -0.01136833f, 0.05913035f, -0.03734923f, -0.01648510f, 0.02284510f, -0.07686330f, -0.07650658f, 
    -0.14149421f, 0.09323872f, 0.16180231f, 0.19734392f, 0.07769225f, 0.07059208f, -0.10093635f, 0.00664560f, 
    0.02234831f, 0.11788271f, 0.00364629f, 0.04506173f, 0.02568424f, -0.17020975f, 0.06483942f, -0.12966776f, 
    -0.06747858f, 0.00187747f, 0.04790293f, 0.06716126f, -0.05046562f, 0.03775541f, -0.04354587f, -0.05884859f, 
    -0.43406618f, 0.18803470f, -0.14231284f, -0.13437599f, 0.04668912f, -0.08495337f, -0.04756306f, -0.00852787f, 
    -0.06161660f, -0.07473087f, 0.05832969f, -0.09987769f, -0.09066324f, -0.06659736f, -0.13737790f, 0.27880630f, 
    0.08872867f, 0.05822825f, 0.11879355f, 0.02523811f, -0.04121158f, 0.01598696f, -0.00550180f, 0.08428165f, 
    0.15966317f, -0.30375049f, -0.25485504f, 0.22619618f, -0.09133314f, -0.04867066f, 0.01911958f, 0.09795799f, 
    0.03138139f, 0.02026415f, 0.02868834f, -0.12058543f, 0.14961132f, 0.15664315f, 0.08930369f, 0.08291331f, 
    -0.01655586f, -0.00919505f, -0.02223475f, -0.06844935f, 0.02168387f, 0.02664852f, 0.11555861f, -0.00490876f, 
    0.08036213f, -0.19583035f, -0.27058160f, -0.01926087f, -0.03363646f, 0.12681109f, -0.02576410f, 0.01967700f, 
    0.03601542f, 0.03672050f, -0.01716662f, -0.06117313f, -0.42808500f, -0.42501292f, -0.26332766f, 0.14168695f, 
    0.02035369f, 0.02271998f, -0.02297073f, -0.09393171f, -0.01185375f, -0.09589838f, -0.08493373f, 0.03665950f, 
    0.05343553f, -0.05833859f, -0.03436523f, -0.00805833f, -0.09391782f, -0.06215934f, -0.00551497f, -0.05222177f, 
    0.04681370f, 0.03857843f, 0.01436380f, -0.05827378f, 0.03603756f, -0.06710562f, 0.00628618f, 0.07645769f, 
    -0.02612425f, 0.00071617f, 0.02855654f, 0.13637988f, -0.03307063f, 0.17209794f, 0.08602957f, 0.03651476f, 
    -0.26652801f, 0.05386266f, -0.13500436f, 0.11386194f, 0.02862423f, -0.14698182f, 0.00731165f, 0.02342326f, 
    -0.00542864f, 0.05548073f, -0.00473925f, -0.05929930f, -0.14796326f, 0.07740451f, 0.12695025f, -0.19582696f, 
    0.02097571f, -0.02749994f, -0.12864481f, -0.04807321f, 0.05524059f, -0.06178541f, -0.09462649f, 0.03478563f, 
    -0.03622615f, -0.01010353f, -0.10192674f, -0.06828341f, -0.04730546f, 0.00638335f, 0.05776769f, -0.09202475f, 
    -0.12388299f, -0.00349229f, 0.02018833f, 0.02241711f, -0.35769698f, 0.19728118f, 0.18977691f, 0.17219278f, 
    0.09124451f, 0.05820775f, -0.02892022f, -0.00700449f, 0.03752796f, 0.03787898f, 0.08200705f, -0.00483058f, 
    -0.17316473f, 0.14537190f, 0.13375811f, 0.10422133f, 0.14326486f, 0.00673025f, 0.02307898f, 0.04743521f, 
    -0.03445185f, 0.00390315f, -0.02788435f, -0.06955840f, -0.45735577f, -0.08826610f, 0.11672250f, -0.07236559f, 
    0.00343747f, -0.00141765f, 0.08077393f, -0.09536690f, -0.01625887f, -0.10507812f, -0.02911552f, 0.03911856f, 
    -0.09950123f, 0.09256538f, 0.25642836f, -0.11419599f, 0.07332014f, 0.00334549f, 0.05265398f, 0.04994819f, 
    -0.02884727f, -0.01011863f, -0.02763467f, 0.07988438f, -0.47231302f, -0.31897941f, -0.19627903f, 0.05787326f, 
    -0.11344603f, -0.03489322f, 0.03923117f, -0.07761586f, 0.08295427f, 0.02382599f, 0.11128870f, 0.12170830f, 
    -0.00681822f, 0.03949068f, -0.15081184f, -0.05560790f, -0.01128972f, -0.03129089f, 0.05934156f, 0.00540718f, 
    -0.02919224f, -0.07699811f, 0.01380720f, 0.01167951f, -0.26981011f, -0.25566542f, 0.04237866f, 0.07322000f, 
    -0.08253915f, -0.08693482f, -0.05343811f, 0.07198597f, -0.06428525f, -0.06384761f, 0.09957075f, 0.05840218f, 
    0.32479769f, 0.35661462f, -0.02387912f, -0.04354651f, -0.01243841f, 0.11808255f, 0.00291960f, 0.15748116f, 
    -0.00576007f, -0.00474775f, 0.04069526f, 0.05847023f, -0.19737250f, -0.30302554f, -0.20407644f, -0.05959333f, 
    -0.01904510f, -0.01868950f, -0.01224717f, 0.06810687f, -0.00705262f, 0.00715051f, -0.11729312f, 0.05692683f, 
    -0.07689649f, -0.01617861f, 0.01249660f, 0.06935062f, 0.11592391f, -0.01532832f, 0.08874991f, 0.06386780f, 
    -0.08629424f, 0.04376938f, -0.10929986f, 0.00314782f, -0.27281031f, 0.03059919f, 0.05844242f, -0.13944247f, 
    -0.04053296f, -0.05643345f, -0.01877501f, -0.01151206f, 0.08348151f, -0.04500186f, -0.20442426f, -0.03516639f, 
    -0.07873966f, 0.15871178f, 0.10067379f, 0.10563310f, -0.03512137f, -0.14305918f, 0.10755562f, 0.12451291f, 
    0.05977475f, -0.03194409f, 0.05906510f, -0.02354523f, 0.29853988f, -0.18663295f, -0.38262808f, -0.05125353f, 
    0.05919223f, -0.02314915f, 0.15453307f, -0.13730800f, 0.11058717f, -0.12689365f, 0.11528277f, -0.05768234f, 
    0.10946535f, -0.15699974f, -0.07121256f, -0.01597448f, -0.03428905f, -0.02995430f, 0.04967040f, -0.01898689f, 
    -0.07255097f, 0.00020209f, -0.01913614f, -0.01861127f, -0.16790667f, -0.14265059f, -0.04205748f, -0.12749670f, 
    0.03544932f, 0.11627983f, -0.08043180f, -0.00867453f, 0.00612752f, 0.02383784f, -0.05181410f, -0.15114464f, 
    0.17228505f, -0.13561830f, -0.10603997f, 0.13964313f, -0.02078241f, 0.07050513f, 0.02241503f, -0.00161669f, 
    -0.06717104f, 0.02898280f, -0.06130646f, -0.02373037f, -0.09075319f, 0.01280136f, -0.05117457f, -0.10832074f, 
    -0.01518474f, -0.01869677f, 0.05215799f, -0.04466855f, -0.08780403f, -0.03753449f, 0.02426976f, 0.02356009f, 
    0.30218497f, 0.26048058f, 0.04119907f, -0.00247932f, -0.07431663f, -0.00612762f, -0.07072093f, 0.07752205f, 
    -0.05823250f, -0.08150246f, 0.06358373f, -0.13255334f, -0.12915726f, -0.03554986f, -0.13552058f, -0.10971608f, 
    -0.02206331f, -0.03822208f, -0.14548309f, -0.00892069f, -0.02738297f, 0.10027188f, 0.09207604f, -0.00084971f, 
    0.18087345f, 0.10811669f, 0.04843972f, 0.22386903f, -0.07828403f, 0.08370005f, -0.00569623f, -0.14942750f, 
    -0.05059331f, -0.07807412f, 0.02182653f, 0.03211131f, -0.35533318f, -0.39806566f, -0.09678076f, 0.05747006f, 
    -0.04027373f, -0.03253543f, -0.10089158f, -0.03242610f, -0.03534828f, 0.02476724f, -0.02713649f, 0.11115390f, 
    -0.35870355f, 0.02333639f, -0.22715661f, -0.04256209f, -0.15173994f, 0.01311639f, 0.01374925f, 0.03209135f, 
    -0.03070334f, 0.03446572f, 0.10954026f, 0.03577545f, 0.05830991f, 0.02476594f, 0.07480138f, -0.05240882f, 
    -0.05463422f, 0.01071791f, -0.06294946f, 0.01693670f, 0.03763761f, 0.01801121f, -0.00731252f, -0.00110505f, 
    0.13312881f, 0.00758683f, 0.02227271f, 0.10898134f, 0.00498580f, -0.02176394f, -0.01638600f, -0.10461478f, 
    -0.09833045f, -0.01975084f, -0.00481397f, 0.00852923f, 0.04794248f, -0.23588397f, -0.03934247f, 0.02967593f, 
    -0.09456030f, -0.03142517f, -0.04283532f, 0.08562885f, -0.03426136f, 0.01263184f, -0.02763071f, 0.01810242f, 
    0.44189072f, -0.03159590f, -0.04070139f, 0.18429196f, -0.03022027f, -0.00735647f, -0.00340084f, 0.05551337f, 
    -0.10149559f, -0.05644959f, -0.04405106f, -0.02272294f, -0.07738082f, -0.27957165f, 0.14950210f, 0.15691930f, 
    -0.03111603f, -0.02804471f, 0.04277922f, -0.07573254f, 0.00122524f, -0.16011006f, -0.08099526f, 0.02457661f, 
    0.15393138f, 0.12068497f, 0.17605248f, -0.03707887f, 0.01228039f, -0.03692530f, 0.02812683f, 0.00363928f, 
    0.00599583f, 0.03145912f, -0.09199309f, -0.03873928f, 0.09921315f, 0.12088592f, 0.01179208f, 0.13831781f, 
    -0.00148877f, 0.03689585f, -0.05843457f, -0.00591936f, 0.03415707f, 0.05723773f, -0.05460279f, 0.03497231f, 
    0.00545237f, 0.03053702f, 0.10935602f, 0.10655475f, 0.06311062f, -0.02597253f, 0.00537726f, -0.05206294f, 
    -0.04881310f, -0.05599860f, 0.10297316f, -0.13552558f, -0.09718619f, 0.10002046f, 0.15100582f, 0.07920121f, 
    0.00139622f, -0.06540389f, 0.07208421f, -0.02041271f, 0.07330098f, 0.02340541f, -0.09096718f, 0.03253666f, 
    -0.08711588f, -0.08930989f, -0.17712587f, 0.21778810f, 0.00988190f, 0.12953582f, 0.09954896f, -0.01252138f, 
    -0.04260639f, 0.00139645f, -0.07265396f, -0.04331189f, 0.04706243f, -0.05306222f, -0.06831686f, 0.04111146f, 
    0.00264773f, 0.10957862f, -0.00947511f, 0.09402259f, 0.01367301f, 0.08129301f, -0.08216228f, 0.02641289f, 
    0.06374205f, -0.00541229f, 0.12485238f, 0.01231214f, -0.07092883f, -0.00883346f, -0.08157675f, 0.00233348f, 
    -0.00247762f, -0.03120788f, 0.02900186f, 0.04149858f, 0.13390891f, -0.02476953f, -0.06417572f, -0.09546051f, 
    -0.05653046f, -0.11919954f, 0.07694819f, -0.02962488f, 0.01963428f, -0.02615431f, 0.09284741f, -0.08530569f, 
    0.05472067f, -0.05889957f, 0.00427265f, -0.01646693f, -0.02383596f, -0.14758818f, -0.00183999f, 0.03403438f, 
    -0.07411777f, -0.01938146f, -0.04502652f, -0.03565980f, 0.22680223f, -0.22270377f, -0.00220544f, -0.03352273f, 
    -0.07944931f, -0.00494700f, 0.02586922f, -0.04456658f, -0.06108627f, 0.11468171f, -0.06181573f, 0.02245294f, 
    -0.00245965f, 0.05637980f, 0.05043673f, 0.14949013f, 0.01318758f, 0.06127554f, 0.07483148f, -0.03523716f, 
    -0.01509117f, 0.12409686f, -0.03916347f, 0.01728121f, -0.24149089f, 0.05294305f, -0.02197537f, -0.15987863f, 
    -0.03059925f, 0.01839515f, -0.01970143f, -0.01275714f, 0.04577610f, -0.06890847f, -0.00294862f, 0.01577913f, 
    -0.08487693f, 0.20751728f, 0.14179933f, -0.04205756f, -0.06741685f, 0.02431583f, -0.05299124f, 0.00116214f, 
    0.00018322f, -0.00212103f, 0.08527755f, 0.07129209f, 0.08422716f, -0.03100874f, 0.09591804f, 0.10545751f, 
    -0.02840978f, 0.01603648f, 0.04090116f, 0.06704690f, -0.03333670f, 0.07613385f, 0.05591793f, -0.00214511f, 
    0.48316336f, 0.09696174f, -0.15581621f, -0.06440733f, -0.00563461f, -0.06994772f, 0.05683954f, -0.01947209f, 
    0.09661108f, -0.04562478f, -0.07450506f, 0.03034543f, 0.04704316f, 0.21432625f, -0.09376481f, -0.03178512f, 
    0.01151081f, -0.02600248f, 0.00736834f, 0.12046375f, -0.03109166f, -0.12610286f, 0.01318823f, 0.01991110f, 
    0.06262984f, 0.08292299f, 0.09062859f, 0.03904579f, 0.08369503f, 0.05269414f, 0.12480690f, 0.05121613f, 
    0.00796436f, 0.00730967f, 0.08938113f, 0.07327983f, -0.37810376f, -0.03260105f, 0.03899941f, 0.06419180f, 
    -0.04104969f, -0.06759078f, 0.02614251f, -0.02012549f, 0.02785647f, 0.09264725f, 0.14748272f, 0.08093380f, 
    -0.22627191f, -0.32835573f, -0.12023035f, 0.25213695f, 0.07767252f, -0.10925659f, 0.07386302f, -0.03071558f, 
    -0.20759256f, 0.01317686f, -0.08582183f, -0.05188720f, 0.11314125f, 0.07162645f, 0.01103370f, 0.00402690f, 
    0.10246556f, 0.04204553f, 0.00697385f, 0.10962942f, 0.03101252f, 0.11504876f, 0.00411170f, -0.06346758f, 
    -0.17253475f, -0.03267170f, -0.08641969f, -0.05414395f, -0.00336685f, -0.03660324f, -0.04098307f, 0.12864591f, 
    0.08252384f, -0.12772219f, -0.02256902f, -0.07470540f, 0.15668441f, -0.20154670f, 0.00224534f, 0.09966362f, 
    -0.18381228f, -0.05128643f, 0.03982152f, -0.11706840f, 0.00454837f, -0.01229189f, -0.09542224f, -0.06951509f, 
    0.21906795f, -0.14510177f, -0.26711333f, -0.05340784f, -0.04321635f, -0.07221142f, 0.06193146f, 0.04662477f, 
    -0.00802565f, -0.09256609f, 0.08903634f, -0.02073556f, -0.13789932f, -0.05812497f, 0.05048368f, 0.09692893f, 
    0.01142814f, -0.07709718f, -0.04332905f, 0.04448947f, 0.06561766f, -0.11998715f, 0.00603117f, -0.05845473f, 
    -0.28163069f, -0.11772433f, 0.19382299f, 0.04928011f, 0.15423900f, -0.16034366f, -0.02713414f, -0.08518436f, 
    0.11829963f, 0.04894567f, -0.00873052f, -0.11975063f, -0.64796174f, -0.00783937f, 0.00429823f, 0.10287979f, 
    0.05437853f, 0.01578212f, -0.01713661f, 0.05511753f, -0.01082875f, 0.18934579f, 0.05117513f, 0.12971175f, 
    -0.25817579f, -0.09307197f, -0.00579654f, 0.11959772f, 0.00165238f, 0.07609002f, 0.01498590f, 0.16356155f, 
    -0.01085976f, -0.11985470f, 0.10335261f, 0.01574854f, -0.32414320f, -0.23908094f, 0.15097365f, 0.11430947f, 
    0.01228932f, 0.12848344f, -0.03322062f, -0.11006232f, -0.00530056f, 0.02959060f, -0.00876288f, 0.03027278f, 
    -0.09593683f, 0.07103354f, 0.06527644f, -0.07041986f, -0.08354526f, 0.01976936f, -0.04318806f, 0.14023207f, 
    0.05320834f, -0.00496570f, 0.07534322f, -0.01278387f, 0.04560098f, 0.02221714f, 0.06315763f, 0.09931456f, 
    -0.03704863f, -0.09195177f, -0.01701911f, -0.00023492f, -0.15709984f, -0.01320430f, -0.01956451f, 0.05723873f, 
    -0.24036920f, 0.09250548f, 0.17692447f, -0.05894015f, 0.05679892f, -0.01119782f, -0.07169571f, -0.18727966f, 
    0.04479605f, -0.11101145f, -0.10344638f, -0.06697667f, -0.23020196f, -0.12872878f, 0.09326480f, 0.09701513f, 
    0.02470837f, -0.06818911f, -0.07251155f, 0.03646059f, 0.10238926f, -0.03574843f, -0.04409337f, 0.06432968f, 
    0.02632660f, 0.06903582f, 0.14449175f, 0.24279152f, 0.04348818f, 0.04636852f, 0.00014552f, 0.11819091f, 
    0.14353237f, -0.13280275f, 0.04943506f, -0.04007395f, 0.19948015f, -0.02425706f, -0.14560999f, -0.03376751f, 
    -0.04105326f, -0.02064596f, 0.06093974f, -0.02013378f, -0.02739411f, 0.00172626f, -0.03848514f, -0.05473900f, 
    0.16252829f, -0.03766964f, 0.08929383f, -0.24095018f, -0.08684476f, -0.01008840f, -0.07455533f, -0.01003292f, 
    -0.01572225f, -0.09826829f, 0.03759655f, -0.17297213f, -0.09424651f, 0.03951721f, 0.04998668f, 0.01796502f, 
    -0.05424256f, -0.04154896f, -0.00925332f, -0.04133520f, -0.04278475f, -0.05862195f, -0.05159997f, 0.05069935f, 
    -0.42152095f, 0.02874580f, 0.13247412f, 0.18772709f, 0.10247701f, 0.03166541f, 0.03427650f, 0.02201257f, 
    0.02753088f, -0.02027728f, -0.02157121f, 0.02314052f, -0.30335298f, 0.05958257f, -0.12468441f, -0.16916209f, 
    -0.07644585f, -0.12320412f, 0.09093112f, -0.02400511f, -0.07763537f, -0.08840399f, 0.11022841f, -0.02695955f, 
    -0.05006399f, 0.01017261f, 0.08456939f, -0.03642699f, -0.04322400f, 0.00417699f, 0.04409162f, 0.00158599f, 
    -0.08469697f, 0.00210764f, -0.01302075f, -0.02671194f, -0.43616506f, 0.13824446f, -0.01190027f, -0.24571183f, 
    0.00001411f, -0.03859584f, -0.20661801f, 0.08032429f, 0.09046079f, -0.03242401f, -0.01391255f, 0.07299910f, 
    -0.24320467f, -0.06033423f, -0.04832644f, -0.01119514f, 0.08816084f, -0.00137105f, 0.11319409f, 0.04366553f, 
    -0.19393408f, 0.07189050f, -0.10458012f, -0.18019418f, 0.01617975f, 0.22653826f, -0.10605538f, -0.07273356f, 
    -0.02498571f, -0.03172008f, -0.00482018f, 0.05586842f, -0.05644650f, -0.06179950f, 0.02339155f, 0.06012958f, 
    0.04686729f, 0.04131247f, -0.12809195f, 0.06772041f, 0.03258928f, -0.02074094f, -0.09168879f, -0.01678581f, 
    -0.06361831f, -0.05540018f, 0.01093195f, -0.00537051f, 0.21890159f, 0.20351441f, 0.19757839f, -0.06024191f, 
    -0.00849689f, 0.05955839f, -0.03523194f, 0.13277316f, -0.00144381f, 0.01702726f, 0.04509619f, 0.08203363f, 
    0.08941682f, -0.02106971f, 0.13556884f, -0.21425034f, 0.00415505f, 0.07449855f, 0.05650716f, -0.00422565f, 
    0.08418622f, 0.07474542f, -0.12155343f, 0.07136275f, 0.00701672f, 0.12368043f, -0.03166150f, -0.03538603f, 
    -0.03258977f, 0.01973993f, -0.09338611f, 0.11254407f, 0.03617458f, 0.06443930f, -0.05490620f, 0.06656139f, 
    0.17215264f, -0.05663667f, 0.01184494f, -0.20525815f, -0.02268973f, 0.08218353f, -0.00057080f, 0.06469177f, 
    -0.04817426f, 0.01680220f, 0.02140103f, 0.03815505f, -0.11149639f, 0.07481600f, -0.25884768f, -0.07216049f, 
    0.01712907f, -0.15075611f, 0.00024719f, 0.15318714f, 0.01084879f, -0.08192258f, 0.05153353f, -0.00442789f, 
    0.04614029f, 0.08236834f, 0.10046430f, -0.06838898f, -0.01931335f, -0.01111997f, -0.04391180f, 0.00397125f, 
    0.07148386f, 0.07473782f, 0.02891035f, 0.05944594f, 0.42123157f, 0.04985705f, 0.04979382f, 0.06294529f, 
    -0.04526408f, 0.14139622f, 0.08496421f, 0.01358208f, -0.01059587f, -0.01216901f, 0.04318878f, 0.00030568f, 
    0.11609580f, -0.02297718f, -0.26974317f, 0.01006187f, -0.01403924f, -0.02033669f, -0.01172072f, 0.07266577f, 
    0.00373471f, 0.00975060f, 0.01423766f, -0.11816927f, -0.17059872f, 0.11947930f, 0.03682695f, -0.34244722f, 
    -0.02636054f, -0.02152238f, -0.14194298f, 0.10402222f, -0.06282299f, -0.13696474f, -0.09327179f, -0.04411779f, 
    -0.17603526f, -0.22558288f, -0.05479989f, -0.08334544f, -0.09472752f, 0.03816452f, 0.01050570f, -0.09707089f, 
    0.05442192f, -0.04702966f, -0.10842013f, 0.01878497f, -0.01556667f, -0.11096427f, -0.03880120f, -0.11244164f, 
    0.09597572f, 0.08584855f, 0.08655534f, 0.04146348f, -0.06894454f, 0.05266428f, 0.09725157f, -0.10197927f, 
    -0.02187128f, 0.06809711f, -0.17543623f, -0.14208263f, 0.14858431f, 0.03697185f, -0.08850988f, -0.15844834f, 
    -0.20022304f, -0.01392985f, 0.00722695f, -0.04974415f, -0.37013426f, 0.15111756f, 0.11594632f, 0.04725953f, 
    0.00868374f, -0.00332382f, -0.03476528f, 0.17280710f, 0.10636433f, -0.00305999f, -0.00527758f, -0.02889022f, 
    -0.07633863f, -0.01207189f, -0.14805159f, 0.14468712f, 0.10305274f, -0.10505236f, -0.21267454f, 0.01797352f, 
    0.18504596f, -0.04698218f, -0.03248982f, 0.05659169f, -0.20528886f, 0.14125869f, -0.01563843f, 0.11093348f, 
    -0.02122809f, -0.01318881f, -0.03139029f, 0.10130771f, -0.02622302f, -0.04110232f, 0.03050248f, -0.02140283f, 
    -0.22890697f, -0.06157273f, 0.14262557f, -0.21286291f, -0.03739625f, 0.00224082f, 0.07621571f, -0.04174858f, 
    0.00041774f, 0.04526896f, 0.05872425f, 0.02316987f, -0.07285462f, -0.05642785f, -0.09048612f, 0.17381090f, 
    0.05694719f, -0.11084949f, 0.10469765f, 0.09255746f, -0.08669970f, -0.00475103f, -0.01457359f, 0.01158926f, 
    -0.02347574f, 0.07140346f, 0.02994743f, -0.11975113f, 0.10754059f, -0.01103899f, 0.07315008f, 0.04026140f, 
    -0.01679560f, -0.10933936f, -0.01906677f, 0.08465109f, -0.32612166f, 0.11637583f, 0.19346768f, 0.08151921f, 
    -0.13549659f, 0.03791144f, -0.03180240f, -0.11345892f, 0.01403694f, -0.03755073f, 0.09658180f, 0.09029763f, 
    -0.06473611f, 0.13630350f, 0.04224690f, -0.00543345f, -0.05768359f, 0.00993333f, 0.00526296f, 0.06912294f, 
    0.04395438f, -0.05778858f, 0.09875842f, -0.07003430f, 0.04345049f, -0.02057906f, 0.10578337f, 0.26487792f, 
    -0.09040822f, -0.05101060f, -0.00502974f, -0.09691878f, 0.11774620f, 0.11448703f, -0.09418241f, -0.07709603f, 
    0.06431647f, -0.04742611f, 0.13977797f, 0.08594912f, 0.13214435f, 0.02856921f, 0.09324764f, 0.03983007f, 
    0.04138670f, 0.01790787f, 0.03255984f, 0.06788587f, -0.05354773f, -0.04860757f, 0.05768482f, 0.12397858f, 
    -0.03347749f, 0.02013435f, 0.01549513f, -0.04477875f, -0.03236297f, -0.08704332f, -0.07243621f, 0.07288413f, 
    -0.08837102f, 0.15711525f, 0.11627796f, 0.16273844f, 0.01114579f, -0.02718215f, -0.00739241f, -0.06598688f, 
    -0.01504755f, 0.00525422f, 0.01986754f, -0.06778808f, -0.24807648f, 0.04935716f, -0.13119778f, -0.00085363f, 
    0.10494661f, -0.08001161f, 0.11624352f, 0.00292939f, 0.00152851f, 0.09146015f, -0.02418051f, 0.06996469f, 
    -0.14052896f, -0.08148295f, 0.16554518f, 0.16760245f, -0.07462706f, 0.05749360f, -0.00840777f, 0.04280582f, 
    0.00830732f, 0.08427009f, -0.00491210f, 0.02722025f, -0.08908881f, -0.29198855f, 0.07978217f, 0.05283866f, 
    -0.13669972f, 0.01706432f, 0.07437635f, -0.13805319f, 0.02986011f, -0.04399182f, -0.04534058f, -0.12653446f, 
    -0.33752432f, -0.05242661f, 0.11044593f, -0.05354453f, 0.09063297f, -0.02730480f, -0.09506923f, -0.02735631f, 
    0.00092248f, 0.01552957f, -0.00033375f, 0.07124195f, -0.31116235f, 0.19846484f, 0.07608605f, 0.15297790f, 
    0.03594566f, 0.03349237f, -0.10350282f, 0.15622193f, 0.01955134f, -0.18019301f, -0.06802246f, 0.04816001f, 
    -0.02624272f, 0.30272338f, -0.15374550f, -0.22075513f, 0.07857443f, -0.15471658f, 0.13814633f, -0.02831464f, 
    -0.06914510f, 0.01762564f, -0.05187825f, 0.05979552f, -0.03963342f, 0.05932058f, 0.06045384f, -0.01454921f, 
    -0.04517653f, 0.07710431f, -0.03804273f, -0.06348222f, -0.12252837f, -0.04435644f, 0.08336618f, -0.00433305f, 
    -0.58680111f, 0.10417631f, -0.07337634f, -0.07655143f, 0.09579378f, -0.05904645f, -0.04380450f, 0.02404148f, 
    0.06805541f, 0.04289334f, 0.05493606f, 0.02554912f, -0.21711560f, -0.04833639f, 0.08663370f, 0.16329016f, 
    0.04489152f, 0.04663860f, 0.06497149f, 0.07598485f, -0.12602228f, 0.02080959f, 0.11784690f, 0.08954138f, 
    0.33417246f, -0.09305350f, 0.15942523f, 0.06353769f, 0.03163286f, 0.05059578f, -0.04404169f, 0.00160380f, 
    0.07398700f, 0.04870947f, -0.03721506f, 0.13304892f, -0.11448807f, -0.07230645f, -0.03715979f, -0.01650479f, 
    0.04268719f, 0.01964001f, 0.05453527f, 0.03707942f, -0.06477827f, -0.07285415f, -0.07810985f, 0.05984512f, 
    -0.01584118f, -0.18981597f, 0.08418725f, 0.22428775f, 0.02030217f, -0.05799513f, 0.02107933f, -0.09676532f, 
    0.03875116f, 0.10051665f, -0.02264959f, -0.02719125f, 0.01597540f, 0.23018120f, -0.17366773f, 0.05266206f, 
    -0.11022201f, -0.04231713f, -0.00380930f, -0.07863303f, -0.03701550f, -0.01107453f, -0.01189909f, 0.03836370f, 
    0.02185940f, 0.08989112f, 0.06547915f, 0.02457417f, -0.01318277f, -0.05730372f, -0.08198255f, 0.06938092f, 
    0.03549730f, 0.02798839f, -0.17574073f, -0.12649216f, -0.08768503f, 0.06664068f, -0.04520927f, -0.09658918f, 
    -0.01538142f, 0.04670661f, -0.06532966f, -0.14804356f, -0.07162323f, -0.24386697f, -0.00070863f, -0.12780003f, 
    0.20612328f, -0.17483443f, -0.08099981f, -0.11367488f, 0.09146801f, 0.12744829f, -0.15945934f, 0.08970938f, 
    0.20458721f, -0.20655513f, 0.02888160f, -0.13381104f, -0.27580681f, -0.20868613f, -0.16486855f, -0.03049319f, 
    0.17079864f, 0.02569070f, 0.07192725f, -0.01391933f, 0.06343770f, 0.09435555f, -0.01729973f, 0.13754787f, 
    -0.04306483f, 0.02329569f, 0.06897209f, 0.02344360f, 0.00175140f, 0.08008464f, 0.14841647f, -0.06166996f, 
    0.02984539f, -0.02353929f, -0.04418000f, 0.12278710f, -0.01716866f, -0.01506149f, 0.02429834f, -0.11295767f, 
    -0.06168938f, 0.02089841f, 0.08846397f, 0.04213213f, 0.03335424f, -0.04119576f, 0.07627837f, 0.05013094f, 
    -0.09523358f, 0.09629555f, 0.21664056f, -0.20361829f, 0.11530181f, 0.00360394f, -0.05151674f, -0.20505470f, 
    0.00203514f, 0.00320471f, 0.00994272f, 0.00275272f, 0.10218387f, -0.03751865f, -0.00502287f, -0.03916116f, 
    -0.04081899f, -0.02483183f, 0.03001088f, -0.06289624f, -0.05717888f, 0.01336229f, -0.06544588f, 0.17141870f, 
    0.04662281f, 0.08707213f, 0.08716460f, -0.06071578f, -0.07673386f, -0.02313772f, 0.00741254f, -0.10851128f, 
    -0.01760280f, -0.18954080f, 0.07323316f, 0.10794902f, -0.03631743f, 0.36148906f, -0.20382984f, -0.18073899f, 
    0.09836634f, 0.00068930f, -0.05888611f, -0.09931074f, -0.00931879f, -0.13303623f, 0.00605516f, -0.15590902f, 
    0.01668544f, 0.14753863f, -0.11445081f, -0.20259383f, -0.05353858f, -0.04138888f, 0.02743616f, -0.08076856f, 
    0.12344729f, 0.07031090f, -0.11801846f, -0.09095705f, 0.24639069f, 0.00855850f, -0.02119101f, 0.11795519f, 
    -0.09023517f, -0.03179312f, 0.11559036f, 0.00406615f, -0.08916225f, -0.08560686f, 0.09699537f, 0.10078269f, 
    -0.08816769f, 0.07371338f, 0.05516148f, 0.17517509f, 0.01549850f, 0.05054471f, 0.04241638f, -0.03812277f, 
    -0.09990178f, -0.03303954f, 0.06354055f, 0.11510226f, 0.02546740f, -0.07414632f, 0.15474592f, 0.16885081f, 
    -0.07024819f, -0.05804479f, 0.04570376f, 0.14125626f, -0.08550230f, -0.01449450f, -0.15918930f, 0.07854996f, 
    -0.02379731f, -0.01165671f, 0.02741788f, 0.05098387f, -0.04302043f, -0.01909866f, -0.00488892f, 0.04742369f, 
    0.01617849f, 0.06374531f, 0.01115264f, 0.06284904f, 0.04965033f, 0.00069682f, 0.04030342f, 0.05018697f, 
    0.03002776f, 0.07189851f, 0.01851152f, 0.04652834f, -0.10896637f, -0.01121249f, 0.06583744f, 0.03472240f, 
    -0.18565245f, -0.04287098f, -0.03081849f, 0.03272036f, -0.01212386f, 0.09308968f, -0.11810473f, 0.00400020f, 
    0.02872959f, -0.01151707f, 0.20960191f, 0.16801064f, -0.05585172f, -0.15262926f, 0.06105524f, -0.07050651f, 
    0.06796844f, 0.02221450f, 0.08770467f, -0.00976538f, 0.09817807f, -0.04333367f, -0.07333178f, -0.00357411f, 
    -0.06891802f, -0.10790148f, 0.01083305f, 0.22090910f, -0.11585820f, -0.02297078f, -0.05996839f, 0.04288870f, 
    0.02693588f, 0.01892413f, -0.04530899f, 0.07923945f, -0.02614173f, -0.19366582f, -0.07513101f, -0.06375124f, 
    -0.06287702f, 0.13317399f, 0.04347164f, 0.13001572f, 0.16625087f, 0.10381654f, 0.03182849f, 0.08892318f, 
    -0.02268785f, 0.01801089f, -0.26129124f, -0.07522015f, 0.01118383f, 0.05460944f, -0.02969635f, -0.06555142f, 
    0.00276556f, -0.02022300f, -0.02332618f, -0.00010955f, 0.01832708f, 0.03110995f, 0.17713588f, -0.32130888f, 
    0.00284741f, 0.05263317f, -0.07935142f, -0.08949690f, -0.03264757f, 0.05524884f, 0.03560752f, -0.05896983f, 
    0.06261785f, -0.00728617f, -0.05785027f, -0.05990780f, -0.03775740f, -0.15593855f, 0.05735364f, 0.04579974f, 
    0.06302908f, 0.09998598f, 0.02712688f, 0.25203797f, 0.19130245f, -0.11204483f, 0.00562112f, -0.11942159f, 
    0.01405152f, 0.06308009f, -0.02183432f, 0.11364512f, -0.24003942f, 0.06624575f, 0.01490710f, -0.13764629f, 
    -0.03701938f, 0.09564470f, -0.03124114f, -0.25241151f, 0.06125613f, -0.15575285f, 0.02461846f, 0.16325417f, 
    0.04916622f, -0.00057491f, -0.03406116f, 0.02968361f, 0.03099470f, 0.09807496f, 0.17661573f, -0.07290260f, 
    -0.00167360f, -0.00910535f, -0.09773677f, -0.01966104f, 0.09117223f, 0.01355016f, 0.07465696f, -0.03784056f, 
    -0.12469664f, -0.03648015f, -0.05819587f, 0.05214079f, -0.00561945f, -0.10662229f, 0.04801446f, 0.00808345f, 
    0.05496205f, -0.01628730f, 0.01903380f, 0.02800629f, -0.05159704f, 0.01145227f, 0.04929621f, 0.30604911f, 
    -0.03244130f, 0.07462641f, 0.03135173f, -0.11685269f, 0.04624252f, -0.06108684f, -0.10187436f, -0.05410920f, 
    -0.18236296f, 0.07966792f, 0.24437788f, 0.02618050f, -0.01921197f, 0.01309332f, -0.09171295f, -0.05888629f, 
    -0.03937140f, 0.02607649f, 0.08386417f, -0.23641489f, 0.08523711f, -0.06779808f, 0.19461413f, 0.10753311f, 
    0.13322461f, -0.07160078f, 0.14099771f, -0.05122777f, 0.02005675f, -0.09327065f, -0.08139324f, -0.00019984f, 
    -0.13634092f, 0.07012141f, -0.00600868f, 0.13267934f, -0.01066796f, 0.01150854f, -0.13819161f, 0.10909700f, 
    0.09459123f, -0.04176469f, 0.18458678f, 0.04752780f, -0.28745610f, 0.21938366f, 0.28444889f, -0.10900121f, 
    0.10047141f, 0.12741116f, 0.05535487f, 0.05643264f, 0.09904552f, -0.09186538f, -0.00884620f, 0.07848176f, 
    0.11749344f, 0.00266767f, -0.09751847f, 0.06846369f, 0.05233594f, 0.10844654f, 0.10137597f, -0.06413940f, 
    0.12342793f, -0.14678353f, 0.07061470f, -0.10837151f, 0.02143645f, 0.05674441f, 0.20448802f, -0.28479046f, 
    -0.00394868f, -0.12338920f, -0.04944767f, -0.19749275f, -0.07330742f, -0.03627729f, -0.10266007f, 0.02368160f, 
    -0.38343748f, -0.03028050f, 0.02772167f, -0.04807014f, 0.05626639f, -0.05777706f, -0.09007315f, -0.08211971f, 
    -0.07375847f, -0.01933151f, -0.13041939f, 0.08470700f, -0.23112048f, -0.01592400f, -0.26185933f, 0.19434828f, 
    0.11986313f, -0.19455723f, 0.07116226f, 0.15615772f, 0.27113381f, 0.00588762f, -0.06121331f, -0.03151004f, 
    -0.08858668f, 0.17819227f, 0.03873481f, 0.20000279f, -0.02517933f, -0.09475432f, 0.05794937f, 0.12175689f, 
    -0.05233672f, -0.26364934f, -0.00119021f, -0.10622650f, -0.05334795f, -0.02733265f, 0.01118372f, 0.01938958f, 
    -0.03118848f, 0.15043186f, -0.09950605f, -0.13319269f, -0.00372954f, -0.21520017f, 0.01580881f, 0.13198453f, 
    -0.07346292f, 0.03546787f, 0.09600384f, 0.12603861f, -0.10679099f, -0.00593991f, -0.02121641f, 0.11054619f, 
    0.00865859f, 0.10565590f, -0.05782205f, 0.02680747f, 0.03549056f, 0.15208378f, 0.00938263f, 0.00005595f, 
    -0.04932971f, 0.03880627f, -0.10546388f, -0.15952845f, -0.02716152f, 0.07280829f, 0.01067339f, 0.07631242f, 
    0.08318485f, 0.00910009f, -0.11959523f, 0.04103080f, 0.00537156f, -0.04695981f, 0.13087969f, 0.01724361f, 
    -0.09294987f, 0.00757684f, 0.00946414f, -0.02116361f, -0.12125194f, -0.22740284f, 0.13226271f, -0.04019440f, 
    -0.15134881f, 0.00833988f, 0.05633709f, 0.08627082f, -0.05566828f, 0.08431543f, -0.01904477f, -0.10069597f, 
    0.16282955f, -0.05879073f, -0.08635537f, -0.00040765f, 0.04144768f, 0.03125931f, -0.06343508f, -0.03021151f, 
    -0.19001642f, 0.03553389f, 0.08088780f, 0.03234089f, -0.34060076f, -0.13720016f, -0.10730092f, -0.02560868f, 
    0.11572499f, 0.14895858f, 0.03439619f, -0.07417689f, -0.01084458f, -0.20376216f, -0.04660444f, -0.13147691f, 
    -0.11400111f, -0.06042285f, -0.13941225f, -0.04714224f, 0.08566169f, 0.15204820f, -0.01535861f, 0.08953439f, 
    0.08887971f, 0.20218612f, 0.16816747f, -0.04253182f, 0.06172092f, 0.17011423f, -0.20307288f, 0.04870198f, 
    -0.01080347f, -0.05553802f, -0.00140034f, -0.22727796f, 0.02163980f, 0.02781989f, -0.17517577f, 0.11024529f, 
    -0.02590146f, -0.04818663f, 0.03499277f, 0.12256826f, -0.06409886f, 0.04023832f, 0.10296308f, -0.13770396f, 
    0.00814403f, -0.00809776f, 0.08193067f, 0.25946686f, 0.16952205f, 0.03956257f, 0.05906014f, -0.24256319f, 
    0.04653062f, 0.04000174f, -0.05424786f, -0.01586054f, -0.09456476f, 0.00967356f, 0.10535977f, 0.09774191f, 
    -0.15528446f, -0.10920153f, -0.01855330f, 0.02554744f, 0.05187316f, 0.05139011f, -0.20577669f, 0.09338424f, 
    0.02886093f, 0.06422453f, 0.05201316f, -0.10251228f, 0.00559403f, -0.15303758f, -0.00108231f, 0.09704462f, 
    0.04722663f, 0.03534951f, 0.04777750f, 0.14445572f, 0.07066090f, 0.14196977f, 0.10754576f, -0.10079092f, 
    0.02972564f, -0.10642836f, 0.05709260f, 0.38907120f, -0.20323238f, -0.03686956f, -0.00764345f, 0.04524716f, 
    -0.00183389f, 0.13820739f, 0.04190254f, 0.06528445f, 0.00346256f, -0.05044639f, -0.10414271f, -0.18856257f, 
    0.07170329f, -0.04051889f, -0.02050067f, -0.02756611f, 0.08285514f, -0.01494217f, -0.07261244f, -0.07991366f, 
    0.04886817f, 0.00288265f, -0.03823774f, -0.06130728f, -0.00820863f, -0.05389935f, 0.05688935f, 0.02429210f, 
    0.00837998f, -0.00046868f, -0.04112468f, 0.12826103f, 0.06124363f, 0.11541604f, 0.06033703f, 0.11173098f, 
    0.00104242f, -0.24427462f, -0.03221003f, 0.05562102f, 0.05007150f, 0.01712236f, 0.03676074f, 0.00886538f, 
    -0.30350667f, 0.01632300f, 0.06004443f, 0.14577064f, 0.01040328f, -0.06358603f, 0.00329009f, 0.10519575f, 
    -0.06829140f, -0.10071828f, 0.07159747f, -0.06783126f, -0.79963166f, -0.04425165f, -0.15517904f, -0.09681667f, 
    0.07293086f, 0.11791220f, 0.05178761f, -0.12912722f, 0.04279390f, 0.17816100f, 0.11361080f, -0.07115387f, 
    -0.48663801f, -0.13458042f, 0.16768678f, 0.07279082f, -0.01724351f, 0.04214609f, 0.04088056f, -0.16703621f, 
    0.05792949f, -0.10428541f, -0.01644695f, 0.01233968f, 0.01989795f, -0.02120469f, 0.07541545f, -0.09513642f, 
    -0.08295045f, -0.04027240f, -0.12691368f, 0.10806054f, 0.01782830f, -0.06819709f, 0.04076232f, -0.32201284f, 
    -0.56365967f, 0.02260857f, -0.09881320f, -0.38016656f, 0.07138979f, -0.02580410f, 0.02374000f, -0.02970697f, 
    -0.00782980f, 0.02784735f, -0.10677238f, -0.02703811f, -0.26018363f, -0.03000528f, -0.14622161f, 0.01140667f, 
    0.12473797f, 0.09652239f, -0.04657616f, -0.10300261f, 0.09896388f, -0.12743139f, -0.04359694f, -0.00467221f, 
    -0.07293276f, 0.07227550f, -0.14164497f, 0.15467757f, 0.04874621f, -0.00755636f, -0.03496296f, 0.08284507f, 
    -0.01936231f, -0.17536233f, 0.12835701f, 0.00805207f, -0.07954128f, -0.12480147f, 0.05464526f, -0.00125941f, 
    0.08423454f, 0.01599960f, -0.00415092f, 0.08318046f, 0.12946203f, 0.05808989f, 0.07119899f, -0.11250135f, 
    -0.05465472f, -0.10582398f, -0.05431815f, 0.05242667f, -0.06969171f, 0.00515703f, 0.00039683f, -0.10838471f, 
    -0.14515126f, -0.07866799f, -0.02943002f, -0.03386221f, 0.03888354f, 0.05557702f, 0.10068789f, 0.01812167f, 
    0.08665280f, 0.00594778f, 0.03716307f, -0.00735576f, 0.02476645f, -0.11591703f, 0.03950578f, 0.03425391f, 
    0.03393734f, -0.00478489f, 0.05806202f, -0.02456142f, -0.00706127f, 0.01521556f, -0.02569368f, 0.08944193f, 
    -0.11867234f, -0.09234935f, 0.07412808f, 0.13539937f, 0.14942361f, -0.17934634f, -0.06339076f, -0.06961212f, 
    -0.13762881f, 0.02861729f, 0.00742604f, -0.02387962f, 0.13559337f, 0.05138025f, 0.05478813f, 0.13647822f, 
    -0.14097463f, 0.05916443f, -0.15229517f, -0.11417656f, -0.12508376f, -0.02425712f, 0.00872250f, -0.13252217f, 
    -0.19151996f, 0.11829133f, 0.02966443f, -0.02176272f, -0.07660982f, 0.05111409f, 0.01043664f, -0.13437510f, 
    -0.04282090f, 0.05682416f, 0.01913836f, 0.02230709f, 0.04972506f, 0.08327545f, -0.03339684f, 0.04794920f, 
    -0.08896403f, 0.05620992f, 0.02876099f, -0.05511290f, -0.20258138f, 0.00237648f, -0.07398513f, 0.01040677f, 
    0.13260904f, 0.04662708f, -0.06481669f, -0.02838954f, -0.21867129f, 0.21462029f, 0.08390237f, -0.07028482f, 
    -0.05005317f, 0.01763634f, -0.11850690f, 0.04160519f, 0.02806373f, -0.03659155f, 0.00696245f, 0.00527563f, 
    -0.20090048f, -0.14493172f, 0.03104740f, -0.26747906f, -0.15219986f, 0.04623314f, 0.13406855f, 0.10937896f, 
    0.01160836f, 0.00596383f, -0.02748415f, 0.01265396f, 0.08003815f, 0.09309571f, 0.01697134f, 0.11309068f, 
    -0.06399336f, 0.15097068f, 0.01426892f, 0.01174100f, -0.02650641f, -0.03741013f, 0.02634815f, -0.00835935f, 
    0.28167248f, 0.11129562f, -0.04791237f, -0.19991939f, 0.02243491f, 0.01942883f, -0.07416574f, 0.01635326f, 
    0.01033381f, 0.02203333f, 0.01113139f, 0.00500299f, 0.03630518f, -0.50869739f, -0.02118198f, -0.28175172f, 
    -0.03318404f, 0.01827358f, 0.00309956f, 0.10022898f, -0.03731168f, 0.07247039f, 0.06574943f, 0.23477353f, 
    -0.29911703f, -0.19184148f, 0.09231216f, 0.12495625f, 0.06571393f, -0.01961766f, 0.08388773f, -0.01608112f, 
    -0.10291585f, -0.13878721f, 0.07472858f, 0.11939801f, 0.21955408f, 0.12947837f, 0.04353095f, -0.21146517f, 
    -0.10548756f, 0.04951013f, -0.20952725f, -0.05892764f, 0.06455307f, -0.06741504f, -0.12464038f, -0.08656673f, 
    0.06408301f, 0.18268503f, 0.04263503f, -0.13649002f, -0.01157977f, -0.12652665f, 0.03818370f, 0.00155227f, 
    -0.02146378f, 0.12960003f, -0.15169953f, 0.00660827f, -0.15311617f, 0.00932419f, -0.12692890f, -0.00859153f, 
    -0.00907058f, 0.02880027f, -0.06193614f, -0.03497566f, -0.05777341f, -0.16790281f, 0.18788236f, 0.08399567f, 
    -0.04381830f, -0.07467451f, 0.06256282f, -0.07289008f, 0.02066689f, 0.06984527f, 0.00499812f, 0.05474163f, 
    -0.04741232f, -0.09509285f, -0.07841112f, -0.14438483f, -0.05518826f, 0.27374980f, 0.09397362f, 0.01228599f, 
    -0.05744654f, -0.05474949f, -0.03157822f, 0.10498395f, 0.08881700f, 0.00830648f, -0.02986014f, -0.14890149f, 
    -0.11284581f, -0.06271552f, -0.14418863f, -0.22741209f, -0.09569030f, 0.01109225f, -0.01911069f, -0.09823596f, 
    -0.07742682f, 0.09613144f, -0.14628807f, -0.05483421f, -0.15113026f, -0.06597836f, -0.18837062f, 0.16168290f, 
    -0.04413663f, -0.07530376f, -0.12438829f, -0.00085772f, 0.03197990f, -0.01705191f, 0.02002302f, 0.05279365f, 
    0.12626989f, 0.04592992f, 0.11843073f, -0.16907275f, 0.07316770f, -0.06699209f, 0.01274040f, 0.16834910f, 
    0.01051630f, 0.03434808f, 0.13242126f, -0.19337644f, -0.16169608f, -0.09075619f, -0.12209560f, 0.22627379f, 
    -0.02384049f, -0.01039903f, -0.03453053f, -0.07323389f, -0.11888731f, -0.14799625f, -0.06878646f, -0.19017904f, 
    -0.08797532f, -0.12843104f, -0.04895736f, -0.02529400f, 0.04901185f, -0.05705341f, -0.05394428f, -0.13683698f, 
    0.06250217f, 0.05911680f, 0.03928053f, 0.07499862f, 0.44167137f, -0.05081620f, 0.07468900f, 0.20362797f, 
    -0.00685525f, 0.04008351f, -0.04604609f, 0.09331638f, 0.14804895f, -0.24168545f, 0.05739040f, 0.06413173f, 
    0.04227143f, 0.01160874f, 0.03667677f, -0.10847647f, 0.04530575f, 0.23705061f, 0.02991761f, 0.06510859f, 
    0.04394545f, -0.06834612f, 0.11241271f, -0.04743435f, 0.17238644f, -0.09472718f, 0.13258503f, 0.15795365f, 
    0.07111922f, -0.05922643f, -0.01213203f, -0.03034268f, -0.03768745f, 0.15133992f, -0.00890512f, 0.05112433f, 
    0.19959612f, -0.05943929f, 0.09278791f, 0.05798792f, 0.05319026f, 0.14651763f, 0.08627864f, -0.03333168f, 
    0.08075865f, 0.00738577f, -0.01589499f, -0.14242236f, 0.10598944f, -0.07321595f, 0.12302001f, -0.17018856f, 
    -0.00739199f, -0.01570214f, 0.07522383f, 0.12810470f, 0.05705434f, 0.02534482f, -0.09755047f, 0.05136812f, 
    -0.15715282f, 0.13832504f, -0.15690684f, 0.03138810f, -0.10038988f, 0.12967210f, 0.05883643f, -0.11607230f, 
    -0.08761263f, 0.04985982f, -0.11108094f, -0.05837476f, -0.19165735f, 0.01983069f, -0.07211100f, -0.03837010f, 
    0.10118289f, -0.06257276f, -0.00451042f, 0.10039169f, -0.12350246f, 0.15363033f, 0.12513268f, 0.10677312f, 
    0.05382356f, 0.10676733f, 0.25870490f, 0.35034588f, -0.01237646f, 0.00993794f, 0.09222724f, -0.00110867f, 
    -0.00158337f, 0.02231309f, -0.05846902f, 0.08393553f, -0.03479045f, -0.07414327f, 0.07906532f, 0.04606166f, 
    -0.10640854f, 0.02550885f, 0.00500095f, 0.00437748f, -0.08261901f, 0.06635726f, 0.12161840f, 0.09751382f, 
    0.05780301f, -0.20264587f, 0.20928344f, -0.04128031f, 0.10323536f, -0.10599706f, 0.07306407f, 0.01245707f, 
    -0.05585171f, 0.00427085f, -0.05382317f, 0.01055062f, 0.23729123f, -0.51460803f, 0.04085813f, 0.01142278f, 
    -0.14615507f, -0.04755196f, 0.15926108f, -0.06482393f, -0.01908618f, 0.05687913f, -0.11791163f, -0.03972628f, 
    0.10375550f, -0.25774181f, -0.28153089f, -0.14038981f, -0.00674402f, 0.05041143f, -0.11228726f, 0.05865595f, 
    -0.00805053f, 0.12137014f, -0.11014773f, 0.09375133f, -0.19964966f, 0.21821913f, -0.08864432f, 0.04591622f, 
    0.02286090f, 0.07191762f, 0.07890853f, 0.05547713f, 0.12565120f, 0.03173121f, 0.01862289f, -0.04883036f, 
    -0.33483291f, -0.12544788f, 0.04036041f, -0.07760945f, 0.18068704f, 0.03984492f, 0.00161942f, -0.01916029f, 
    0.07877596f, -0.03130663f, 0.09032223f, -0.15529516f, 0.00738240f, -0.02151628f, 0.16370603f, 0.03287067f, 
    -0.06187374f, -0.02486582f, -0.13482812f, -0.25511542f, -0.25540349f, 0.04532076f, 0.12424161f, -0.16217108f, 
    0.01473948f, -0.13491909f, -0.04238400f, 0.27095184f, 0.07447480f, -0.03847269f, -0.09345944f, -0.01825957f, 
    -0.04946575f, 0.12178206f, -0.11257486f, 0.09027844f, 0.20739678f, -0.19445129f, 0.06032350f, 0.04811323f, 
    0.00459242f, -0.01385593f, 0.13146120f, -0.02244266f, 0.07632478f, 0.00280778f, 0.00884755f, -0.04421877f, 
    0.00246383f, -0.10509384f, -0.08828104f, 0.10572483f, -0.02787339f, 0.11461826f, -0.13072544f, 0.02142034f, 
    0.04620185f, -0.07163849f, 0.01783198f, 0.01944516f, -0.23093215f, -0.11393657f, -0.01120820f, 0.04198373f, 
    0.06384851f, 0.04710098f, 0.09355231f, -0.01888972f, -0.02522981f, -0.12262817f, -0.04601746f, 0.07524024f, 
    0.08854768f, 0.05807202f, 0.18746956f, -0.14107107f, 0.01173682f, 0.08057448f, -0.02976883f, -0.12304784f, 
    0.00989150f, 0.05942331f, 0.03930730f, 0.03157988f, -0.00677953f, 0.19461094f, -0.05815406f, -0.02551898f, 
    0.01570587f, 0.02245709f, 0.03807852f, -0.00719059f, -0.02608858f, -0.06480042f, 0.06878328f, 0.00675171f, 
    -0.17609085f, 0.18107978f, -0.03293005f, 0.30091843f, 0.01531604f, 0.00397198f, 0.10969778f, 0.06108350f, 
    0.13840616f, -0.05343498f, -0.03322880f, -0.09862468f, -0.24590553f, 0.05382837f, -0.17187315f, -0.16176860f, 
    -0.09488603f, -0.05087496f, -0.23420617f, -0.15751053f, -0.06427443f, 0.10738790f, 0.07983303f, 0.15154162f, 
    -0.09896760f, -0.09779232f, 0.10376919f, 0.06309628f, 0.04572395f, -0.11337239f, -0.14247750f, -0.19720298f, 
    -0.14325447f, -0.10288697f, 0.04694888f, -0.01472988f, -0.16297092f, -0.02880812f, -0.13028140f, 0.01224909f, 
    0.16957511f, -0.08516192f, 0.11927218f, 0.09749551f, -0.01564215f, 0.06332504f, 0.07580901f, -0.07598551f, 
    0.12541784f, 0.05097095f, -0.05167723f, -0.00176647f, 0.05962728f, 0.01785900f, -0.05746010f, 0.01503128f, 
    -0.00419647f, -0.03137214f, -0.15724798f, -0.07102554f, 0.03164760f, 0.19316715f, 0.17740504f, -0.18430176f, 
    0.07651211f, 0.03806097f, 0.00739077f, -0.05479347f, 0.04391295f, -0.12490981f, 0.01603279f, -0.24561100f, 
    0.24579810f, -0.04928077f, -0.25426078f, 0.33868980f, -0.08462524f, 0.04795538f, 0.08493983f, 0.01716004f, 
    -0.05625914f, -0.10474130f, -0.00229450f, 0.03568658f, -0.01921105f, -0.07511208f, -0.16211267f, -0.09697694f, 
    -0.02380793f, 0.03845557f, 0.01601775f, -0.06896511f, -0.06469846f, 0.00800854f, -0.00382817f, 0.10781401f, 
    0.08353946f, 0.10197691f, 0.12564050f, -0.31670389f, 0.08411597f, 0.03070193f, 0.06218606f, 0.08532287f, 
    0.05919895f, -0.12024797f, -0.09937459f, -0.07928123f, 0.03140605f, 0.01910052f, 0.11335694f, -0.12413014f, 
    -0.09040017f, 0.03196071f, 0.02931306f, 0.05484470f, 0.02712643f, 0.03695804f, -0.03359286f, 0.09502278f, 
    0.00435807f, 0.30933669f, 0.08940036f, -0.39662468f, -0.04223526f, 0.10898877f, 0.05354964f, -0.01229352f, 
    -0.04715905f, 0.09787090f, 0.03914933f, -0.02218051f, -0.21615112f, -0.15798073f, -0.31173900f, 0.19801663f, 
    0.08786914f, 0.19427973f, -0.01969533f, 0.14763081f, -0.02485191f, -0.11963242f, -0.09515055f, -0.18434982f, 
    -0.05274079f, 0.00504177f, -0.15767135f, -0.16662042f, -0.03752898f, 0.10875951f, 0.03243499f, -0.05238450f, 
    -0.03554444f, 0.05480792f, -0.02829395f, 0.07656952f, -0.08644291f, -0.12404083f, 0.04141672f, -0.17062891f, 
    -0.08793567f, 0.01421981f, 0.04598105f, -0.09366515f, -0.07558133f, -0.04932356f, -0.05381992f, -0.05202109f, 
    0.28842139f, -0.32941741f, -0.29575422f, -0.04364658f, -0.18963537f, 0.14154170f, -0.12090489f, 0.14175941f, 
    -0.00101661f, 0.10211487f, -0.05910307f, 0.07309896f, 0.17221066f, 0.02616525f, 0.25974113f, -0.26111659f, 
    0.07444346f, -0.01761544f, 0.13178396f, -0.06145529f, -0.17582777f, 0.06645462f, 0.02488050f, 0.08873188f, 
    0.59221643f, -0.12943962f, 0.11040710f, 0.01107143f, -0.07373502f, -0.02321854f, 0.04536275f, 0.04224651f, 
    0.02733851f, -0.03029692f, 0.09554080f, 0.06808535f, 0.04110307f, -0.16866842f, -0.25253350f, 0.00395356f, 
    -0.09393294f, -0.05611290f, 0.04126779f, -0.04615594f, -0.11668143f, 0.14019080f, 0.02072470f, -0.06822194f, 
    -0.19654141f, -0.05667974f, -0.16634554f, 0.03645434f, 0.01527577f, -0.02455224f, 0.00642229f, -0.06198616f, 
    0.05414051f, 0.15282278f, -0.02045609f, -0.04216770f, 0.00431897f, 0.01813517f, -0.23562095f, -0.12516677f, 
    -0.12121507f, 0.02403245f, -0.00969415f, -0.01221120f, -0.09315845f, 0.06420217f, 0.02545611f, -0.01203324f, 
    0.00176864f, 0.04452221f, 0.09316981f, 0.11895013f, 0.11536977f, 0.04938905f, 0.01123637f, -0.05541898f, 
    -0.05264020f, -0.02263851f, -0.03176304f, -0.04845919f, 0.02556148f, 0.10873348f, 0.03468691f, -0.07227813f, 
    0.00895636f, -0.02517401f, 0.05177193f, 0.02516379f, -0.06322425f, -0.00625715f, -0.01924686f, -0.16235873f, 
    0.04748878f, -0.08870713f, -0.09335884f, -0.15914850f, -0.04086015f, 0.00189072f, -0.07340903f, -0.11696309f, 
    0.00561178f, -0.02946416f, -0.00828211f, 0.03383197f, -0.16617750f, 0.10673148f, 0.00407894f, -0.00699102f, 
    0.02463021f, -0.03561694f, -0.00965372f, 0.05183556f, -0.09968327f, 0.04785022f, -0.05258090f, -0.01782047f, 
    0.21123049f, 0.16756910f, -0.04744333f, 0.12124588f, 0.06055629f, 0.09573521f, 0.06492392f, 0.04636851f, 
    -0.03894890f, 0.06423018f, 0.00962374f, -0.02773661f, -0.03010915f, 0.05293113f, 0.12133022f, 0.12626678f, 
    0.08701000f, 0.03796287f, 0.02156381f, -0.09755427f, -0.05152206f, 0.01827117f, -0.03731124f, -0.04795580f, 
    -0.41779724f, 0.23269625f, -0.07846719f, -0.05899005f, 0.06386686f, -0.00680926f, 0.04328476f, -0.02934673f, 
    -0.12377612f, -0.02020791f, 0.01565649f, 0.00391414f, -0.34896347f, 0.17148595f, -0.11785513f, -0.19044968f, 
    0.07909960f, -0.04960050f, -0.08119430f, -0.02123127f, -0.12785487f, -0.05104262f, 0.01182381f, -0.04811922f, 
    0.02754090f, 0.15945356f, -0.00690296f, 0.01029712f, -0.06661514f, -0.04059753f, -0.04051607f, -0.07182503f, 
    -0.05688306f, -0.00186781f, -0.15046525f, -0.09004965f, 0.04706237f, -0.12152417f, 0.07334138f, -0.03142716f, 
    -0.00482900f, -0.10602558f, -0.00031419f, -0.00550855f, -0.03822429f, 0.03465799f, 0.01667570f, 0.03936704f, 
    0.08406754f, -0.02264963f, -0.03054257f, -0.00937824f, -0.16099499f, -0.02873949f, 0.01605344f, 0.04233182f, 
    0.03322735f, 0.00860295f, 0.00416707f, -0.04236249f, 0.07761233f, 0.10659081f, 0.14478131f, 0.08113946f, 
    0.07563315f, 0.04199778f, 0.05494810f, 0.05709160f, -0.06921944f, 0.10912190f, 0.02942352f, -0.00277125f, 
    -0.11742169f, -0.01736416f, -0.01024340f, -0.07124779f, 0.00183400f, 0.00261994f, -0.07526074f, -0.08052248f, 
    0.04137618f, -0.07940640f, -0.04869366f, -0.01489430f, -0.03088703f, 0.13952374f, -0.16745730f, -0.02517181f, 
    -0.05777082f, -0.05145166f, -0.05241460f, -0.00592269f, -0.02219426f, 0.02422373f, 0.00449698f, -0.05432978f, 
    -0.36375567f, -0.10613801f, -0.05153926f, 0.00899248f, 0.04823552f, 0.02225167f, 0.01478975f, -0.03076784f, 
    -0.03994185f, 0.00098336f, 0.01549956f, 0.06928417f, 0.05289306f, -0.05382515f, -0.00794387f, 0.09503338f, 
    -0.04008187f, -0.09496424f, -0.04692369f, -0.01186065f, -0.01566694f, -0.01489611f, 0.13772191f, 0.00943145f, 
    0.03649430f, 0.10031234f, -0.10848347f, -0.11827971f, -0.13879475f, -0.07295939f, -0.04049952f, -0.05443707f, 
    -0.01819959f, -0.02501359f, -0.00625481f, -0.01997222f, -0.15637404f, -0.05465221f, -0.08231581f, -0.14669709f, 
    0.09811692f, -0.00623983f, -0.01521953f, -0.02955785f, -0.15465358f, 0.03409477f, -0.02476424f, -0.09577093f, 
    0.02081602f, 0.12592366f, 0.11867555f, 0.09273350f, 0.11441909f, 0.05201659f, 0.05008371f, -0.05274677f, 
    0.00943350f, -0.04548718f, -0.00788587f, -0.05235094f, 0.03538539f, 0.04625020f, -0.00939594f, 0.20562744f, 
    -0.07513789f, 0.09709832f, -0.09164480f, -0.01546255f, -0.00703494f, 0.01927423f, -0.09080917f, -0.06118063f, 
    0.11212778f, -0.15264267f, -0.07565977f, -0.01044287f, 0.11173886f, 0.03633532f, -0.01984463f, -0.05398291f, 
    -0.04482749f, 0.01373316f, -0.02107062f, -0.12544651f, 0.15472187f, 0.12769035f, 0.12612781f, 0.15164746f, 
    0.13865228f, 0.05946115f, 0.08127027f, -0.04423655f, 0.03256724f, -0.14961347f, 0.06252775f, -0.05316061f, 
    0.04400589f, 0.01900212f, 0.10319611f, 0.08024686f, -0.00942898f, 0.07897124f, 0.05297115f, -0.06530615f, 
    0.07269515f, -0.04137099f, -0.04213074f, -0.00160547f, 0.13969487f, -0.38101000f, -0.09907962f, 0.08132327f, 
    -0.06484371f, -0.02002705f, 0.04413743f, -0.09949133f, -0.04426006f, 0.07457748f, -0.06617176f, 0.03762717f, 
    0.15110293f, -0.19416115f, 0.11362455f, 0.02841216f, -0.01589175f, -0.05709262f, 0.04441356f, -0.03706104f, 
    0.01278658f, 0.01074407f, 0.01630599f, -0.19422086f, 0.06542343f, -0.25038224f, -0.16188522f, -0.11142561f, 
    -0.00093345f, -0.00250765f, 0.00351590f, 0.03918664f, 0.05624411f, 0.01976098f, -0.09655033f, 0.05443930f, 
    0.28946537f, -0.07231335f, 0.13806753f, -0.05363355f, 0.04181238f, -0.00140764f, -0.04309878f, -0.02101534f, 
    0.00451691f, 0.04116073f, 0.03173713f, -0.04441751f, -0.03913688f, 0.00351308f, -0.08189598f, -0.12803108f, 
    -0.05032605f, -0.03958121f, -0.04277579f, -0.11267083f, -0.05769907f, -0.02804524f, -0.09057441f, -0.10045086f, 
    -0.15832454f, 0.20473720f, 0.05825723f, 0.08255838f, 0.06737108f, -0.00853474f, 0.00276830f, -0.02463894f, 
    -0.00661901f, 0.06167180f, 0.01890854f, -0.12088504f, -0.07629745f, -0.07434354f, -0.00819200f, -0.01279998f, 
    -0.14132771f, -0.06076394f, 0.03180228f, -0.06619114f, 0.03810576f, -0.06532872f, 0.02007584f, -0.02128115f, 
    -0.17549238f, -0.01564887f, 0.07550008f, -0.07278908f, 0.08369150f, -0.11397165f, -0.00443795f, -0.01520793f, 
    -0.02073953f, 0.03110310f, 0.00175187f, 0.00838978f, -0.08368306f, 0.02792863f, -0.07968150f, -0.12054143f, 
    -0.07204245f, -0.03616475f, -0.08804290f, -0.07162884f, 0.03052814f, 0.05795869f, -0.05340546f, -0.12598383f, 
    0.14342527f, -0.13110057f, 0.03323456f, 0.07167146f, 0.05610600f, -0.05024976f, 0.01319214f, -0.00340516f, 
    -0.02470870f, -0.04235344f, 0.01656310f, -0.11468295f, 0.02033676f, -0.20786409f, 0.04670516f, -0.01598981f, 
    -0.02261190f, 0.04158186f, -0.00455891f, -0.00695084f, -0.01980472f, 0.00231735f, 0.00897092f, -0.01890316f, 
    0.04365600f, 0.06612622f, 0.17209829f, 0.13589925f, 0.02934188f, 0.07070117f, -0.01450577f, 0.01441354f, 
    -0.01927472f, 0.03973710f, 0.05506513f, -0.06543466f, -0.33467278f, 0.28008655f, 0.06519988f, -0.11036703f, 
    -0.05837924f, 0.04723731f, -0.05435469f, -0.03013415f, -0.05561488f, -0.04983639f, -0.02328835f, -0.03493433f, 
    0.03280528f, 0.09318252f, 0.10822437f, -0.04870454f, -0.04055700f, -0.03271746f, -0.01823405f, -0.08264737f, 
    -0.01321624f, 0.02127039f, 0.02106850f, -0.06015204f, 0.08145473f, 0.10632793f, 0.01851322f, 0.00651297f, 
    -0.00633599f, 0.11108799f, 0.00352370f, -0.01854612f, -0.04165364f, -0.08788901f, -0.03717803f, -0.05032465f, 
    -0.09913700f, -0.04965088f, -0.00093907f, 0.10320052f, -0.04438118f, -0.09249683f, -0.12198915f, -0.03031030f, 
    -0.07517084f, -0.02213225f, -0.02015751f, 0.00744693f, 0.06227503f, -0.04473206f, -0.05345919f, -0.12368211f, 
    -0.01215821f, -0.02909758f, -0.01997985f, -0.06982005f, -0.04203603f, -0.03050845f, -0.04524580f, -0.03378785f, 
    -0.27253166f, 0.08746945f, -0.13805725f, 0.07720726f, -0.11331037f, -0.00057545f, 0.02516638f, -0.02824222f, 
    -0.03677744f, -0.00220618f, -0.05583331f, -0.01089650f, -0.21582475f, -0.06386604f, -0.03045607f, -0.13166635f, 
    -0.12578323f, 0.02147627f, -0.01028436f, -0.02037326f, -0.03689767f, -0.06830055f, -0.11342278f, -0.10964324f, 
    -0.15388067f, 0.04530957f, -0.07663259f, -0.03724189f, 0.03318591f, -0.03835113f, 0.00307526f, -0.16903412f, 
    -0.08328609f, 0.06079448f, 0.05622054f, 0.01374711f, -0.11337706f, -0.02212680f, -0.03483547f, -0.13515849f, 
    0.02393822f, 0.01074135f, -0.02264885f, -0.07483796f, -0.09274816f, -0.03050008f, -0.12662289f, -0.00288664f, 
    -0.27470323f, -0.15803528f, -0.09918560f, -0.00790322f, -0.01179943f, 0.03437519f, 0.00033627f, -0.00765700f, 
    -0.03394419f, -0.04298854f, -0.09426848f, -0.02950598f, 0.01084026f, 0.09785260f, 0.08125643f, 0.22333418f, 
    0.06616186f, -0.00474683f, 0.13280107f, 0.02571623f, -0.04736219f, 0.01111606f, -0.04085934f, 0.01343842f, 
    0.09819213f, 0.07627764f, 0.11498385f, 0.09613921f, 0.01250517f, 0.06034462f, 0.05561996f, -0.01967227f, 
    -0.00952895f, 0.01053681f, -0.05223042f, -0.02851941f, -0.06713650f, 0.14092906f, -0.08287857f, -0.03711067f, 
    -0.08113825f, 0.00296829f, -0.00355744f, -0.03608845f, 0.03221642f, 0.07032388f, 0.00222594f, -0.02552496f, 
    -0.41788396f, 0.17000598f, -0.04585079f, 0.07430514f, -0.01954809f, -0.10969722f, 0.05096510f, 0.03449632f, 
    -0.00556113f, 0.05654905f, 0.07463307f, -0.01364371f, 0.09037263f, -0.03062588f, -0.01888257f, -0.15269174f, 
    -0.03800829f, -0.01910180f, -0.00885975f, -0.04840475f, 0.00319659f, 0.00871559f, 0.03119116f, -0.00291299f, 
    -0.01279923f, 0.11737599f, -0.17302369f, 0.26294068f, 0.00177543f, -0.04884845f, -0.03581328f, 0.01024421f, 
    0.04996644f, 0.04032653f, -0.00050181f, -0.01296145f, 0.08762624f, 0.00437835f, -0.06236870f, 0.06869907f, 
    -0.04788035f, 0.01192475f, -0.00599139f, -0.05274200f, -0.04697009f, 0.01738037f, -0.00409777f, -0.00757301f, 
    0.00054580f, -0.35459316f, 0.17778942f, 0.10288016f, -0.03201483f, -0.09553462f, -0.00803698f, -0.10380881f, 
    -0.01746376f, -0.02509917f, -0.02970440f, 0.00009859f, 0.13189572f, -0.20724533f, 0.14174388f, -0.00847296f, 
    -0.02100183f, 0.04105020f, -0.06809331f, -0.05977039f, -0.03286069f, 0.02132797f, -0.02680409f, -0.04668067f, 
    -0.25409120f, -0.18034138f, -0.21503970f, -0.05330674f, -0.05500825f, 0.04960563f, -0.03885419f, -0.05943732f, 
    -0.15430240f, 0.00234356f, 0.10952941f, -0.09497499f, -0.11757807f, -0.03635266f, -0.06644989f, 0.15368865f, 
    -0.06860685f, -0.12727879f, -0.09558564f, -0.04665954f, -0.01589537f, -0.04859631f, -0.04614576f, -0.14734311f, 
    0.15770584f, 0.18237418f, 0.15266956f, 0.04453387f, -0.03449187f, -0.01514433f, 0.02556753f, -0.03006312f, 
    -0.01720432f, 0.03835852f, -0.08289665f, -0.05495568f, -0.11250678f, 0.09451667f, 0.14548080f, 0.04626256f, 
    0.09653205f, 0.09227158f, 0.00635012f, 0.01190620f, -0.03702484f, 0.03973002f, -0.06925873f, -0.09449513f, 
    0.01739030f, 0.10443701f, 0.06359848f, 0.07909179f, 0.06701109f, 0.03770835f, 0.05692063f, 0.01316996f, 
    -0.03042665f, 0.01608715f, 0.03421143f, -0.05611468f, 0.11673788f, 0.15944062f, 0.01475265f, -0.18965450f, 
    -0.18598637f, -0.04121380f, 0.03616068f, -0.06895261f, -0.04408608f, 0.10812595f, 0.05313806f, 0.00388837f, 
    0.11293155f, -0.18374972f, 0.12174038f, -0.16625555f, -0.02397891f, -0.00283902f, -0.04503058f, 0.01063746f, 
    0.00778696f, 0.07679598f, -0.05385739f, 0.03395182f, 0.05591208f, 0.19988985f, 0.18113253f, 0.13530552f, 
    0.13227580f, -0.02959860f, 0.11106902f, 0.06716572f, 0.01445532f, -0.01263655f, 0.01988314f, -0.11695261f, 
    0.12669286f, 0.08010338f, 0.09155789f, 0.18295379f, 0.12728116f, -0.04000602f, 0.06796398f, -0.04512542f, 
    0.04237670f, -0.00166977f, -0.03913001f, -0.05118583f, 0.11832167f, 0.08346636f, 0.01277628f, 0.25249195f, 
    -0.01492601f, 0.06450834f, 0.05419503f, 0.04170476f, -0.03328533f, -0.01690215f, -0.02448102f, 0.00804041f, 
    0.00606886f, 0.06644007f, -0.01678410f, -0.01760775f, 0.00923339f, -0.08782469f, 0.12516910f, -0.02208235f, 
    0.06082255f, -0.04458178f, -0.03130588f, 0.01530808f, 0.01764641f, -0.12325302f, -0.08020802f, -0.12894799f, 
    -0.08523047f, -0.01764886f, -0.03055944f, -0.07463304f, 0.09840199f, -0.01508439f, 0.03004169f, 0.00486488f, 
    0.11222447f, 0.05237259f, -0.02038404f, 0.08056742f, 0.02441111f, -0.11458765f, -0.05545842f, -0.01657298f, 
    -0.01785561f, 0.00634904f, -0.14130576f, -0.12977205f, 0.10918708f, -0.12108990f, 0.03267980f, 0.07925484f, 
    -0.07213027f, 0.01435202f, -0.04759200f, -0.03512824f, -0.02363446f, -0.16467822f, -0.03870542f, 0.00617907f, 
    -0.18947025f, 0.15946913f, 0.05452374f, 0.02485875f, -0.10036851f, 0.04184422f, -0.06151750f, 0.15065123f, 
    0.08177216f, -0.09254708f, 0.04352812f, -0.07741817f, -0.26534143f, -0.10316181f, 0.18108834f, 0.00569931f, 
    -0.11334216f, -0.00045597f, 0.03011214f, -0.21591608f, 0.02895690f, -0.06822400f, 0.10199104f, 0.04451891f, 
    0.06951349f, 0.03492165f, -0.06145502f, 0.14089422f, 0.12941504f, 0.10775442f, -0.02056633f, -0.08703750f, 
    0.07303235f, 0.01760270f, 0.05190255f, 0.01907799f, -0.00413578f, -0.00512117f, -0.15614213f, 0.08932233f, 
    0.11602660f, 0.01009696f, -0.07901198f, -0.04104074f, -0.01990152f, -0.00612567f, 0.08711434f, -0.11426918f, 
    0.05629002f, -0.01786597f, 0.03372031f, 0.13465714f, -0.07234752f, 0.00237236f, 0.07907673f, -0.06585676f, 
    -0.02625172f, 0.09005538f, -0.01159986f, -0.03271696f, -0.12697579f, 0.01229049f, 0.02043011f, -0.16082175f, 
    -0.09705565f, -0.01641459f, -0.07452770f, 0.09846725f, 0.03420774f, 0.05654001f, -0.07511277f, 0.07828826f, 
    -0.18387853f, 0.02399706f, -0.29810682f, -0.17238179f, -0.04593538f, -0.05417443f, 0.07705663f, -0.17756228f, 
    -0.03230633f, -0.08560532f, 0.13047962f, 0.07065535f, -0.15540335f, -0.11967427f, 0.21033333f, -0.01165940f, 
    -0.10277816f, -0.08748705f, -0.00421519f, -0.03019277f, 0.05696205f, -0.10447226f, -0.06950886f, -0.06343000f, 
    0.21428667f, 0.07715348f, -0.02280893f, 0.11470810f, -0.02491589f, -0.01531675f, -0.02837490f, -0.04247361f, 
    -0.08397099f, -0.01862578f, -0.09628522f, -0.09401503f, 0.00065121f, -0.15481013f, -0.16611139f, -0.07081570f, 
    -0.05712080f, 0.02528186f, 0.02844035f, 0.03423967f, 0.01050701f, 0.00312138f, 0.15787838f, 0.00267515f, 
    0.01785973f, -0.09110182f, -0.09114584f, 0.13936861f, 0.06823036f, -0.04806767f, -0.07796735f, 0.03810077f, 
    0.04351299f, -0.01035418f, 0.06412657f, 0.08767125f, -0.04880058f, 0.12522486f, -0.21602492f, -0.27342755f, 
    0.00162049f, 0.01199204f, -0.14671336f, 0.10582589f, 0.05212573f, 0.04340306f, -0.11168851f, 0.07644220f, 
    -0.07970590f, 0.03245781f, 0.05829910f, -0.03260530f, -0.06101638f, 0.01715173f, 0.03292982f, -0.04288052f, 
    0.03963436f, 0.07520422f, -0.04347412f, 0.03851266f, 0.05012541f, -0.02772104f, 0.00454212f, 0.09341968f, 
    0.03546054f, 0.08554143f, -0.06263350f, -0.03333426f, 0.07837486f, 0.02689945f, 0.07500298f, -0.10731243f, 
    -0.25571123f, 0.01106515f, 0.06534458f, -0.18208143f, -0.08300385f, -0.01252758f, -0.03956261f, -0.14543416f, 
    -0.01573319f, 0.09105785f, 0.10058475f, -0.02931741f, -0.20776774f, 0.22191557f, -0.21094050f, -0.12508121f, 
    -0.00717718f, 0.01970829f, 0.01238266f, -0.12026387f, 0.10293131f, 0.05071989f, -0.01882088f, 0.06897048f, 
    -0.06635308f, -0.24511485f, 0.04778521f, -0.01332193f, 0.03450403f, -0.05471614f, -0.03116489f, -0.02549936f, 
    0.12313762f, 0.00969938f, -0.14250626f, 0.09638810f, 0.14448738f, 0.13012315f, -0.02102529f, 0.17414215f, 
    0.01396395f, -0.05085389f, 0.09736603f, -0.00080665f, -0.00100613f, 0.04378073f, 0.08129650f, 0.07209264f, 
    0.05541198f, 0.11463060f, -0.02833992f, 0.07773706f, -0.08214372f, -0.00422565f, 0.00836169f, 0.00267166f, 
    -0.01478041f, 0.01857180f, -0.01859896f, -0.08456758f, 0.11154947f, -0.02843603f, 0.06782960f, 0.04715250f, 
    0.00642845f, -0.02321089f, -0.08181243f, -0.06182969f, -0.02688550f, 0.07265560f, 0.05361000f, 0.00685582f, 
    -0.05956142f, -0.28928569f, -0.06899194f, -0.16199103f, 0.04619399f, -0.03976887f, -0.01002560f, -0.05011147f, 
    -0.02770693f, 0.02183955f, -0.06781404f, 0.06710956f, 0.12733820f, -0.12795112f, -0.06869993f, 0.02255281f, 
    -0.02976263f, -0.01436210f, -0.00744000f, -0.00649174f, 0.01336855f, -0.05563684f, 0.08377524f, -0.16158643f, 
    0.06377602f, -0.09406185f, -0.00419775f, -0.03554036f, 0.04234380f, -0.04772436f, 0.06010898f, -0.07027409f, 
    0.05311976f, -0.01896990f, 0.01195486f, 0.14283024f, 0.16414301f, 0.11328460f, 0.06133588f, 0.12218856f, 
    0.05942799f, -0.06731450f, -0.01961974f, -0.09090924f, 0.02444083f, -0.07688543f, 0.11925126f, -0.05741706f, 
    -0.01667402f, 0.07827511f, 0.11295331f, 0.05057871f, -0.05684885f, 0.05240621f, 0.11665838f, 0.05173691f, 
    -0.05316990f, 0.01035187f, 0.05915677f, 0.08914655f, 0.12107464f, 0.18866849f, -0.02970615f, 0.11533563f, 
    0.04066285f, 0.03591256f, -0.04413145f, -0.10532771f, 0.07287689f, -0.02958376f, -0.08911230f, -0.00522879f, 
    0.04673878f, -0.02790578f, -0.32315460f, 0.00284576f, 0.04950078f, -0.09548574f, -0.29932031f, -0.15140598f, 
    0.08697590f, 0.00048534f, 0.06603421f, -0.16617621f, 0.21880326f, -0.00799950f, 0.09677465f, 0.02350717f, 
    -0.03718629f, -0.00930191f, -0.03374670f, -0.08542652f, 0.08086397f, -0.09138750f, -0.01419707f, -0.01219599f, 
    0.15190877f, -0.05235443f, 0.01829745f, -0.18370435f, 0.02892363f, -0.04547430f, -0.00091369f, 0.02329924f, 
    -0.08240691f, -0.04874568f, 0.04987697f, 0.05234836f, 0.17646655f, -0.08633588f, 0.04907051f, 0.13017024f, 
    -0.07676464f, -0.01137078f, -0.03665416f, -0.06516177f, -0.03959434f, -0.01617427f, -0.02915204f, -0.07280364f, 
    -0.17316601f, -0.07413793f, -0.07026890f, -0.08572116f, -0.10140389f, -0.08325313f, 0.03655985f, -0.06803988f, 
    0.04544241f, -0.05067788f, -0.03666585f, -0.02399844f, 0.20458588f, -0.18823917f, 0.03602812f, 0.21396013f, 
    0.00240118f, -0.05914759f, -0.07555620f, -0.00808602f, -0.03278995f, -0.00973424f, 0.06899846f, -0.03874625f, 
    -0.21253899f, 0.22805883f, 0.00777847f, -0.05109047f, -0.07029156f, 0.07091250f, -0.02156503f, 0.03938489f, 
    0.03633806f, 0.03068350f, 0.04034734f, -0.01972423f, 0.10236785f, -0.05923104f, 0.12282360f, -0.01742711f, 
    0.11682900f, -0.00172660f, -0.04504813f, 0.09815752f, 0.06184262f, 0.00794973f, -0.13018295f, 0.07015505f, 
    0.14250264f, 0.21559244f, -0.20706126f, -0.18284205f, 0.06822060f, -0.07372663f, -0.04003898f, 0.02773078f, 
    0.03227860f, -0.06070499f, 0.09528960f, 0.02588271f, 0.04467338f, -0.13886952f, 0.11539561f, 0.01464105f, 
    -0.02687234f, -0.00732348f, -0.08395827f, -0.06665234f, -0.02731891f, -0.07640909f, -0.02078214f, 0.03085624f, 
    -0.06303226f, 0.11599661f, -0.10719686f, 0.02149352f, 0.00947719f, -0.01116646f, -0.10508055f, 0.04357493f, 
    0.06768727f, 0.02627171f, 0.03701390f, 0.03109368f, 0.00115970f, 0.14284062f, 0.06975719f, 0.07189645f, 
    -0.04055386f, 0.01454455f, -0.06869152f, -0.01743923f, -0.03095936f, -0.02667746f, 0.03588442f, -0.04174398f, 
    -0.11952514f, -0.09349318f, 0.00780003f, -0.04774839f, -0.00797646f, -0.00881940f, -0.07551773f, 0.11178547f, 
    0.01072798f, 0.01681690f, 0.11091933f, -0.08820856f, 0.17767154f, -0.01107771f, -0.15083927f, 0.08831217f, 
    0.04389694f, -0.04441872f, -0.10168237f, -0.04638566f, -0.04124881f, -0.09731190f, -0.08176647f, -0.08918800f, 
    0.08429912f, 0.10295225f, -0.27250844f, 0.06320660f, 0.02353724f, 0.06739677f, -0.09935684f, -0.06302483f, 
    -0.11596593f, -0.07673537f, -0.02004651f, 0.07091807f, -0.07890998f, 0.06927799f, 0.03967619f, -0.03930391f, 
    0.04036278f, 0.05940396f, 0.13973980f, -0.16137409f, 0.00919150f, -0.02142311f, -0.01314187f, -0.04874988f, 
    -0.19703600f, -0.07170332f, -0.05031229f, -0.25118244f, 0.04766041f, -0.06369676f, -0.08013513f, 0.05337372f, 
    0.00674707f, 0.06030921f, 0.01813027f, -0.09254777f, 0.05252551f, 0.18750903f, 0.02410718f, 0.07173511f, 
    -0.14946966f, 0.07720016f, -0.07158243f, 0.01844562f, -0.00662890f, -0.03573872f, 0.03604906f, 0.02543903f, 
    -0.00494847f, -0.00101245f, -0.21379682f, 0.05290764f, -0.02431490f, -0.06638350f, -0.08086746f, -0.03563195f, 
    0.10795067f, -0.04473294f, 0.12699530f, 0.02280383f, 0.10101926f, -0.14671144f, -0.00625153f, 0.11596446f, 
    0.03873967f, -0.03063591f, -0.00093598f, 0.00292503f, 0.17174008f, 0.00019059f, 0.02114376f, 0.04214252f, 
    0.08256651f, 0.14576955f, -0.25353256f, -0.28790870f, -0.13298872f, -0.03724917f, -0.01028851f, -0.11367378f, 
    -0.01223558f, -0.03036407f, -0.04602821f, 0.06400483f, -0.17929232f, 0.03436329f, -0.05868710f, -0.11845588f, 
    -0.05240864f, 0.04512743f, -0.08140820f, -0.04170345f, 0.04175704f, 0.04652128f, -0.09286461f, -0.04647567f, 
    -0.15821914f, -0.11984207f, -0.02270966f, 0.07952355f, 0.03497950f, 0.06248709f, -0.07583082f, 0.06373583f, 
    0.04177141f, 0.10340299f, 0.15021344f, 0.01423203f, -0.17088383f, -0.12436454f, 0.05471909f, -0.04432422f, 
    0.02502168f, 0.00853631f, 0.00781351f, -0.12689991f, -0.06781861f, 0.04746337f, 0.02235307f, -0.00611759f, 
    -0.20317028f, -0.18559207f, 0.07148195f, 0.06654148f, 0.11236945f, 0.01115577f, 0.00788342f, -0.02676487f, 
    0.01038704f, 0.05437893f, -0.02688803f, 0.00938289f, 0.06648912f, 0.16334635f, -0.28583264f, -0.29850852f, 
    -0.04736192f, -0.03621236f, -0.04328232f, -0.05684966f, 0.09221280f, 0.07909611f, 0.00891407f, 0.11462162f, 
    0.01954661f, 0.02224169f, -0.08368777f, -0.12290570f, -0.10036787f, 0.10406200f, 0.07853821f, -0.04922125f, 
    -0.08187839f, -0.03350018f, 0.03024154f, 0.03485773f, -0.01930833f, -0.05372749f, 0.24037045f, 0.07151725f, 
    -0.05672531f, -0.05203361f, -0.03994485f, -0.02948253f, -0.04790014f, -0.00731195f, 0.02042769f, -0.07228540f, 
    -0.14481729f, -0.05691779f, 0.05174069f, -0.15363368f, -0.11308365f, -0.07651883f, -0.02812691f, -0.12551154f, 
    -0.03863858f, 0.04263773f, 0.08687489f, -0.05865743f, 0.10631277f, 0.02346381f, -0.00732057f, -0.01199544f, 
    -0.00777573f, -0.00075956f, -0.08035494f, 0.13207768f, 0.04136959f, -0.02155038f, -0.06301734f, -0.02302850f, 
    -0.23169678f, 0.08403379f, 0.11729306f, 0.05106516f, -0.04147716f, -0.01463559f, -0.02171193f, -0.00187025f, 
    0.08362258f, 0.01069490f, -0.15065193f, 0.08971568f, -0.04978860f, 0.05108463f, 0.04570565f, 0.09721602f, 
    -0.07068561f, 0.02675510f, -0.00370773f, -0.00742539f, -0.03715356f, -0.06865348f, -0.04247986f, 0.09987830f, 
    -0.11427270f, -0.13425682f, 0.04309968f, -0.14395396f, -0.05746859f, -0.09555475f, 0.04725146f, -0.11789661f, 
    0.06274843f, -0.08879043f, 0.12031450f, 0.07454523f, -0.09661596f, 0.06127416f, 0.05633989f, -0.18508843f, 
    0.03304538f, 0.06370299f, 0.05494516f, -0.01762180f, -0.01088963f, -0.03637097f, -0.14575189f, -0.10529035f, 
    -0.13298965f, -0.49866256f, 0.04909978f, -0.13581428f, 0.05898929f, -0.03012849f, -0.06625193f, 0.01010492f, 
    -0.09376021f, -0.15846643f, 0.13458684f, -0.00579831f, -0.21278651f, 0.05346020f, -0.09685498f, 0.04940763f, 
    0.01205864f, -0.05139782f, -0.03315954f, -0.02088664f, 0.07366270f, 0.02435394f, -0.03165880f, 0.05129917f, 
    -0.02891332f, 0.01152360f, -0.05793629f, 0.03037094f, 0.00986655f, 0.04433561f, 0.00042198f, -0.12630728f, 
    0.02896708f, 0.06612366f, 0.05627796f, 0.09559417f, -0.07038910f, -0.05650659f, 0.12467274f, -0.06690048f, 
    0.12394241f, -0.06742005f, 0.02799268f, 0.12831816f, -0.00131883f, 0.19483224f, 0.00842472f, 0.14733434f, 
    -0.27584374f, 0.23107570f, 0.27054399f, 0.03585646f, -0.05598509f, 0.02456181f, 0.00163277f, 0.02689325f, 
    0.02754642f, -0.03485533f, -0.01896750f, 0.20506196f, -0.06256163f, -0.31942868f, -0.10667109f, 0.00773419f, 
    0.02783701f, 0.01942643f, -0.11707070f, -0.09635397f, 0.00574306f, -0.05546104f, -0.00406809f, -0.03892650f, 
    -0.08531402f, 0.36980635f, -0.11155415f, -0.38423732f, 0.14790873f, 0.00539685f, -0.00409149f, 0.06512030f, 
    -0.09010912f, -0.09963558f, -0.05796415f, -0.15637933f, -0.21813542f, 0.08104751f, 0.07744578f, 0.00652967f, 
    0.03241435f, 0.01218500f, -0.00990226f, -0.04713986f, -0.08001872f, 0.01052396f, 0.03869120f, -0.02967260f, 
    -0.24378482f, 0.38877407f, -0.27357769f, 0.16689295f, 0.08309463f, -0.04388789f, -0.04317122f, 0.08844659f, 
    0.06783646f, 0.06612562f, 0.06437181f, -0.00376979f, -0.02119151f, -0.14578292f, -0.03094855f, -0.14492282f, 
    -0.02157578f, 0.00575167f, 0.10822143f, -0.11364351f, 0.15562342f, 0.01429160f, 0.04699609f, -0.08021325f, 
    -0.23719409f, 0.15031219f, -0.15428083f, -0.09654639f, -0.03794875f, 0.05145568f, -0.03567497f, 0.02543936f, 
    -0.00682331f, 0.12068158f, 0.11740362f, -0.04536304f, 0.33919960f, -0.02868521f, -0.12711687f, 0.07906446f, 
    -0.01473325f, 0.02022287f, 0.06038456f, -0.04974949f, -0.08037200f, -0.02207783f, -0.06268996f, 0.09473746f, 
    0.02654949f, -0.03607983f, 0.10662615f, 0.02712580f, 0.11740699f, -0.11193934f, -0.02848794f, 0.01499666f, 
    -0.03429057f, 0.04869310f, -0.06489137f, -0.01895923f, -0.25842831f, 0.24677253f, -0.03024237f, -0.34857368f, 
    0.14352477f, -0.05196619f, 0.01775216f, 0.00300889f, -0.03794988f, -0.04769242f, 0.04758026f, -0.11440962f, 
    0.01587082f, -0.01575140f, 0.12731542f, -0.25369030f, 0.11585099f, 0.02174248f, -0.09037693f, 0.01488648f, 
    -0.04021928f, -0.07182112f, 0.09123600f, -0.21951163f, -0.07947087f, -0.10869526f, -0.10215706f, 0.03896809f, 
    -0.13639218f, -0.00978628f, 0.06869960f, -0.06577188f, 0.15931913f, -0.00981214f, -0.01696322f, -0.08963296f, 
    0.37066999f, 0.06849404f, -0.05422385f, -0.16640615f, 0.02502169f, 0.08697350f, 0.05228003f, 0.07164966f, 
    -0.12044979f, -0.15220918f, 0.01823373f, -0.03107089f, -0.04431950f, 0.12814221f, -0.04879236f, -0.23430355f, 
    0.07633535f, 0.08662320f, -0.07842454f, 0.00284551f, -0.12392298f, 0.04381481f, -0.02707939f, -0.07640257f, 
    0.04993217f, -0.32904500f, -0.20442316f, -0.00530907f, 0.05773669f, 0.02675017f, 0.02300864f, 0.03575815f, 
    0.01065571f, -0.15000743f, -0.26797888f, -0.04673900f, -0.28144836f, 0.07316723f, -0.07196281f, 0.35694820f, 
    0.05486032f, 0.12268256f, -0.10158675f, 0.13450791f, -0.01502322f, 0.06596669f, 0.05788176f, 0.05305089f, 
    -0.03755909f, 0.05130671f, -0.01534127f, -0.08177165f, 0.15916020f, -0.01782917f, 0.04014880f, -0.00861586f, 
    -0.14652438f, -0.06506597f, -0.01349938f, 0.02684365f, 0.11113608f, -0.45828936f, 0.10020548f, 0.01293109f, 
    0.10342030f, -0.11072367f, -0.08310639f, -0.05860831f, -0.13119850f, 0.03902569f, -0.00081411f, -0.04808974f, 
    -0.16904001f, -0.02112788f, 0.13899711f, 0.01359079f, 0.03407561f, -0.01604245f, -0.06876129f, 0.10628682f, 
    0.05142754f, -0.04598882f, -0.05348782f, -0.05897430f, -0.11904980f, -0.26200759f, -0.09517217f, 0.00552649f, 
    0.12523034f, -0.04675066f, 0.02745045f, -0.09086140f, -0.06301219f, 0.04132447f, -0.09051391f, 0.01964828f, 
    0.03654638f, 0.04898860f, 0.10022010f, 0.06362896f, -0.02183745f, -0.02719858f, -0.12326539f, 0.09336395f, 
    0.11840694f, 0.02483332f, -0.04321644f, -0.01119390f, -0.03214335f, -0.03205096f, 0.05021295f, -0.20329566f, 
    0.04973438f, 0.22420894f, 0.02947312f, -0.07266062f, -0.00005764f, -0.09910204f, -0.08678477f, 0.16087227f, 
    -0.09835203f, -0.07135241f, 0.11234020f, 0.03904923f, -0.06247204f, -0.05150048f, -0.06989099f, 0.01265769f, 
    -0.09228166f, -0.02266395f, 0.03592894f, 0.06963798f, -0.10845402f, 0.07886388f, -0.17308335f, -0.00642273f, 
    0.11045382f, -0.01575051f, 0.04472253f, -0.08836994f, -0.08740172f, 0.01264730f, -0.03891268f, -0.06768449f, 
    0.07316191f, -0.10187763f, 0.19120158f, -0.08488003f, 0.00322771f, -0.00485772f, -0.05800716f, 0.09395614f, 
    0.05330395f, -0.11677963f, 0.02028786f, -0.03507244f, 0.10244024f, -0.04537804f, -0.11374664f, -0.00992166f, 
    -0.04475705f, 0.01347986f, 0.01424318f, 0.05571787f, 0.12592599f, -0.06956583f, 0.01115144f, -0.01442072f, 
    0.17015478f, -0.38693136f, 0.03227682f, 0.16657397f, -0.06770280f, 0.04348068f, 0.16477719f, 0.04657901f, 
    -0.04530602f, -0.02710659f, -0.02398002f, 0.04003162f, -0.21694964f, 0.19749628f, -0.13710934f, -0.05152302f, 
    0.08219258f, 0.10595303f, -0.16863562f, 0.08274671f, 0.07250408f, 0.05775182f, 0.07380747f, 0.01346762f, 
    0.21733214f, 0.21078894f, -0.14008646f, -0.10644119f, -0.00271646f, -0.03748447f, 0.00733885f, 0.07580216f, 
    -0.01820442f, 0.07630981f, -0.03926791f, -0.03729694f, 0.30681100f, 0.06057951f, -0.24515384f, -0.18485719f, 
    0.06191481f, 0.11487077f, -0.15962738f, 0.03767013f, -0.04279066f, -0.03268355f, -0.06156902f, 0.04786820f, 
    -0.02914921f, -0.11854088f, -0.14136596f, 0.13757533f, 0.12789449f, 0.02332507f, 0.03418640f, -0.07423935f, 
    -0.18090647f, -0.08903296f, 0.05751985f, -0.10236178f, -0.71530342f, 0.19047834f, 0.05135680f, -0.05324659f, 
    -0.01451434f, 0.02699026f, 0.03894030f, 0.02484741f, -0.02548969f, -0.02962502f, 0.01244754f, 0.06298491f, 
    -0.08553874f, -0.05494379f, 0.00097844f, 0.14402835f, -0.10230433f, -0.08097742f, -0.05621435f, 0.09990311f, 
    -0.03290757f, -0.01729062f, 0.05241216f, 0.04725270f, 0.39588723f, 0.12172631f, -0.13308716f, -0.21697032f, 
    -0.04643806f, -0.06360582f, 0.09360354f, -0.20233138f, 0.03275732f, 0.19570099f, -0.00144582f, 0.00428662f, 
    0.07299611f, 0.02085328f, 0.27344853f, -0.17403322f, -0.01765018f, 0.03021925f, 0.03249761f, 0.00519014f, 
    -0.06760371f, 0.01543514f, 0.05406651f, 0.01521440f, 0.02934173f, 0.00502251f, 0.12422812f, 0.05714637f, 
    -0.02718277f, -0.17698690f, -0.03448158f, 0.01458577f, 0.04066396f, 0.15000060f, -0.05995699f, 0.13806663f, 
    -0.25981754f, 0.09205616f, 0.23963480f, 0.00284775f, 0.14065690f, -0.02064695f, 0.07745744f, 0.09711278f, 
    0.03211576f, -0.05876275f, 0.09574422f, -0.01453923f, 0.34802443f, 0.05803119f, 0.02988964f, 0.01090843f, 
    0.01251196f, 0.06554963f, 0.10124604f, 0.05336779f, -0.02521806f, -0.05096635f, 0.07119720f, -0.09181701f, 
    -0.23276556f, 0.05602454f, -0.07775028f, -0.29024705f, -0.09388477f, -0.00392501f, 0.10092305f, -0.01684250f, 
    -0.05598663f, 0.01032241f, -0.08401957f, 0.10449264f, 0.17477867f, -0.09637001f, -0.02117025f, -0.15264326f, 
    -0.04636027f, 0.05710870f, 0.00319224f, -0.06321208f, 0.08644571f, 0.01070531f, -0.05735036f, 0.11596444f, 
    -0.03578197f, 0.01581579f, 0.14696962f, 0.11846811f, 0.08102641f, -0.04529081f, -0.16179587f, 0.14960751f, 
    0.05312823f, 0.01865210f, -0.06188484f, -0.10216510f, 0.03818873f, -0.16120060f, 0.02899163f, 0.02604902f, 
    0.00795780f, -0.01441907f, 0.04698962f, 0.06095868f, 0.05026773f, 0.02124725f, -0.01795905f, 0.02256451f, 
    -0.01518674f, 0.04277141f, -0.05511220f, 0.29027802f, -0.03002228f, -0.04347368f, 0.04179025f, 0.03079138f, 
    0.07078362f, -0.04428056f, -0.15747494f, 0.00249923f, 0.21285193f, 0.09346452f, 0.06862231f, 0.17139822f, 
    0.09613647f, 0.04238522f, 0.06994086f, 0.07665703f, 0.03079094f, -0.06469226f, 0.07957495f, -0.05853863f, 
    -0.18206535f, 0.20081736f, 0.01124553f, -0.22756012f, 0.01222560f, -0.07615542f, -0.01154194f, 0.07431243f, 
    -0.11020569f, 0.07978968f, -0.11114434f, -0.17266226f, -0.09540484f, -0.00225331f, -0.14190857f, -0.16924314f, 
    -0.01354488f, 0.02124421f, 0.06649156f, -0.03021494f, -0.07240306f, -0.15898615f, -0.05674182f, -0.03440478f, 
    -0.09836161f, -0.01009025f, 0.26323938f, -0.09215797f, 0.05173668f, -0.02310472f, -0.14289698f, 0.06430727f, 
    0.05484093f, -0.08621880f, -0.01972414f, 0.07543364f, -0.13771720f, 0.36215296f, -0.01144550f, -0.00926448f, 
    -0.09857178f, 0.02336098f, 0.02049121f, -0.01274133f, 0.05064318f, 0.00937308f, 0.03822794f, 0.07475603f, 
    0.02338090f, -0.27502295f, -0.08673723f, -0.39627868f, -0.05546188f, -0.04270505f, -0.08493711f, 0.01338173f, 
    -0.04567183f, -0.06113568f, 0.00096135f, -0.07710163f, 0.14352641f, -0.12406582f, 0.00261703f, 0.17015071f, 
    -0.09320364f, 0.06006547f, 0.06781685f, -0.06462506f, 0.11867525f, -0.03901063f, 0.09194478f, -0.18234083f, 
    -0.17626452f, -0.07914454f, 0.25987825f, -0.32318848f, -0.03287553f, 0.06958597f, -0.06596539f, 0.07561035f, 
    0.03075237f, -0.00774380f, 0.00803879f, -0.07603331f, 0.21274045f, 0.02743803f, 0.16565454f, 0.03415270f, 
    0.01962858f, -0.01693399f, -0.04956650f, -0.13611580f, -0.10552094f, -0.03946717f, -0.03698765f, 0.04280094f, 
    -0.15453716f, -0.18792473f, -0.12244415f, -0.03114641f, -0.03642052f, 0.09018123f, -0.02899210f, -0.09162679f, 
    -0.00150709f, 0.10055211f, 0.01260897f, 0.03736607f, -0.13519873f, -0.23417568f, -0.00767182f, -0.08952957f, 
    0.05711164f, 0.01809742f, 0.01426359f, -0.04237384f, 0.09541973f, 0.04818762f, -0.06264104f, 0.05036711f, 
    0.15814464f, 0.02162464f, -0.03766482f, 0.17032349f, 0.12685788f, 0.02701899f, 0.00747880f, 0.11354571f, 
    0.08662819f, -0.07062478f, 0.01507273f, -0.08969657f, -0.41976312f, 0.06055797f, -0.04190356f, 0.07708480f, 
    0.12567851f, 0.02729329f, 0.07678705f, -0.10710543f, 0.04493310f, 0.06373675f, -0.06318440f, 0.12836656f, 
    -0.08090796f, -0.11015669f, -0.05027620f, 0.11629762f, 0.06160831f, 0.06082262f, -0.00576445f, -0.01624566f, 
    0.07569269f, 0.09526820f, 0.04414127f, -0.05174214f, -0.16294762f, -0.38672867f, -0.01390298f, -0.02834291f, 
    -0.00057205f, 0.00972882f, -0.01972192f, 0.02528155f, 0.08008967f, 0.02622297f, -0.02234324f, 0.02801258f, 
    -0.08382435f, -0.22727050f, 0.01184895f, -0.23996493f, 0.01624832f, 0.04210893f, 0.00408689f, 0.02310831f, 
    -0.16902474f, 0.01785494f, -0.05334418f, -0.01224301f, -0.10525662f, 0.12124734f, 0.13333352f, 0.05453840f, 
    0.03957903f, -0.11571404f, -0.10412298f, -0.02008163f, 0.02487493f, -0.00262971f, 0.13087539f, 0.26638252f, 
    -0.21005054f, -0.02921961f, -0.01952248f, -0.03531455f, 0.04330120f, 0.03353050f, 0.00478778f, 0.00072770f, 
    0.05225013f, 0.20464462f, 0.02914252f, 0.11559211f, -0.18080971f, -0.13485624f, 0.07032073f, 0.05506168f, 
    0.16040328f, 0.05878893f, 0.03075395f, 0.05082348f, 0.14801054f, 0.10473588f, -0.02780011f, 0.04163693f, 
    -0.08956424f, -0.02750883f, -0.16027322f, -0.21008433f, 0.05310171f, 0.06071369f, -0.03035536f, -0.01284970f, 
    -0.01803227f, -0.18578009f, -0.23735447f, -0.13557103f, 0.16901504f, 0.14073527f, -0.05983542f, -0.00838692f, 
    -0.10910683f, -0.04426334f, -0.01930710f, -0.02232473f, 0.01985367f, -0.12508033f, -0.07008555f, -0.03777267f, 
    -0.06957815f, -0.01598304f, -0.08735547f, 0.09078293f, 0.01574667f, 0.03290243f, -0.02511570f, -0.07130347f, 
    0.07488611f, -0.01156182f, 0.09252491f, -0.06159389f, 0.04998323f, 0.12778309f, 0.09158745f, 0.00047732f, 
    -0.03611572f, -0.05821218f, 0.05845017f, 0.02858696f, -0.00971858f, -0.11655909f, -0.00217923f, -0.00274602f, 
    -0.53952312f, -0.39417556f, -0.25933337f, -0.24452625f, 0.06727426f, -0.05381555f, -0.03845003f, -0.01781179f, 
    0.07816396f, 0.09902779f, 0.02974634f, 0.04382956f, -0.24350320f, -0.22289935f, 0.01873271f, 0.09153990f, 
    0.10563622f, 0.03085412f, 0.06384581f, 0.12937838f, 0.09957268f, 0.18419309f, 0.11932681f, 0.14556129f, 
    -0.19435276f, -0.20511311f, -0.01848217f, -0.04037917f, -0.01273682f, -0.02330311f, -0.06484054f, 0.00958712f, 
    0.01679976f, 0.00244961f, -0.03400886f, 0.07628291f, 0.15460087f, 0.10717052f, 0.02565587f, 0.07524185f, 
    0.04888670f, 0.02254765f, -0.02252094f, 0.14939496f, -0.02031948f, 0.01639770f, 0.07765028f, 0.12010602f, 
    0.23183434f, -0.08855256f, 0.01606461f, -0.08505175f, 0.09881181f, -0.00435047f, -0.02715874f, 0.02581064f, 
    -0.02205069f, -0.06368770f, -0.12420341f, -0.00343011f, 0.17571805f, 0.10078344f, -0.00144183f, 0.00663555f, 
    -0.12526782f, -0.06753993f, -0.05750409f, -0.07863035f, 0.00160261f, -0.09093306f, 0.00122702f, -0.09231511f, 
    0.20114490f, -0.07257916f, -0.11525956f, -0.03738036f, -0.02609927f, 0.05073276f, -0.04657291f, 0.01557311f, 
    -0.04505572f, 0.02947486f, -0.06346681f, 0.10627291f, 0.18371218f, -0.11627263f, 0.05434128f, 0.04424784f, 
    0.07406042f, -0.00648899f, 0.00732269f, -0.00334385f, -0.04563094f, -0.04246262f, -0.09592197f, -0.01093520f, 
    -0.58404547f, -0.23037691f, -0.09114315f, -0.27273372f, 0.04930449f, -0.05877535f, -0.10721622f, -0.08563241f, 
    -0.01945949f, -0.03639267f, 0.04859297f, 0.11565860f, 0.27376822f, 0.00333174f, 0.02499164f, 0.04015699f, 
    0.12580937f, 0.09489048f, -0.05102536f, 0.10979839f, -0.03489001f, 0.01255739f, -0.20065603f, 0.04557497f, 
    -0.43002638f, -0.06642134f, 0.18992794f, 0.09439456f, 0.08086447f, -0.06743106f, 0.11702470f, 0.01952762f, 
    0.10096342f, 0.19950426f, 0.03965652f, 0.15538722f, -0.51739031f, -0.22972740f, -0.05561547f, -0.12959296f, 
    0.07780378f, -0.01562721f, -0.07361267f, -0.00016087f, -0.00370655f, 0.01134731f, 0.11727265f, 0.01656836f, 
    0.21103710f, 0.19414668f, -0.09514717f, -0.15085414f, 0.06744342f, 0.05987984f, 0.03065355f, 0.00754995f, 
    -0.14412636f, 0.07070559f, 0.12637602f, 0.04815409f, -0.10756163f, -0.18802774f, 0.13598095f, 0.01205703f, 
    -0.08515783f, 0.03143561f, 0.07570399f, -0.05646768f, -0.00243429f, -0.19981281f, 0.03140158f, -0.07817667f, 
    -0.25707126f, 0.17379506f, -0.03973924f, -0.05534194f, 0.03618963f, 0.09881286f, -0.01288913f, 0.00568480f, 
    0.05952132f, -0.00447563f, -0.09292682f, 0.11146385f, 0.04352789f, 0.03686432f, -0.06502438f, -0.05363108f, 
    -0.13182315f, 0.11088955f, -0.00341737f, 0.02847366f, 0.04482109f, 0.17462426f, 0.01533812f, 0.10313660f, 
    0.24756964f, 0.04356476f, 0.02569430f, -0.07099278f, -0.21284202f, 0.01073328f, 0.03044248f, 0.10672408f, 
    0.09153510f, -0.05306049f, -0.07114789f, -0.11339858f, 0.22581130f, 0.08363331f, -0.05301140f, -0.10782126f, 
    -0.05124632f, -0.01267382f, -0.05839995f, -0.03011313f, -0.00681411f, 0.03023687f, -0.13401079f, -0.07306669f, 
    0.22514935f, 0.19072311f, -0.00030056f, 0.04810745f, -0.01387365f, -0.19380301f, 0.05993737f, 0.06575135f, 
    0.06004720f, -0.03804266f, -0.05936223f, 0.25652102f, -0.30585405f, -0.05298535f, 0.02758817f, 0.15644130f, 
    0.06486483f, -0.04099013f, -0.03420449f, -0.00935957f, 0.06492081f, 0.05009885f, 0.06172866f, -0.04076504f, 
    0.06014168f, 0.05339133f, -0.13640197f, -0.02864238f, 0.00842597f, 0.01351967f, 0.08036736f, 0.02297139f, 
    0.12239861f, 0.02072271f, 0.03393237f, 0.05706684f, -0.22250745f, -0.18596640f, -0.07976472f, -0.10460813f, 
    0.03617982f, -0.01756187f, -0.04658469f, -0.07372438f, 0.00752365f, -0.06146836f, 0.08711860f, -0.13567089f, 
    0.02582390f, -0.03363277f, 0.02984459f, 0.04194544f, -0.05025875f, -0.02053952f, 0.01572603f, 0.00847558f, 
    0.18070759f, 0.19832151f, 0.08176139f, 0.08057589f, -0.42703569f, -0.26488560f, -0.06341626f, -0.30595648f, 
    0.02375254f, 0.04210407f, 0.00598103f, -0.18075210f, 0.01769774f, -0.09439062f, -0.10763215f, -0.04380103f, 
    -0.32201195f, -0.17474897f, -0.01687996f, 0.18780220f, -0.03747512f, -0.04744969f, -0.25276387f, -0.05846816f, 
    0.05060970f, 0.02681275f, -0.04058396f, -0.16404238f, -0.17096049f, -0.00998436f, -0.09367351f, -0.06302595f, 
    0.01831094f, -0.03394631f, 0.00758926f, -0.05305761f, 0.09260295f, -0.09052188f, 0.10302676f, 0.00168820f, 
    -0.14267980f, 0.11134881f, 0.00154484f, 0.02110469f, 0.01068618f, 0.04648935f, 0.02638021f, -0.03854665f, 
    -0.03042059f, -0.00700802f, 0.09137730f, 0.09583984f, -0.21356578f, 0.13378395f, -0.25152254f, 0.05426786f, 
    0.05924974f, -0.11059710f, -0.04551917f, 0.01352597f, -0.03113077f, -0.05515014f, 0.03084545f, 0.00067990f, 
    0.10103875f, 0.05669656f, -0.01305613f, 0.03215022f, -0.08232892f, -0.03912752f, -0.05388089f, 0.00250386f, 
    0.04153959f, -0.05535993f, -0.02848573f, -0.04538946f, -0.52332687f, -0.45289624f, 0.04451694f, -0.11918812f, 
    -0.03456482f, -0.13756776f, -0.13573617f, 0.01954034f, 0.09361646f, 0.06984311f, -0.19428024f, 0.09727483f, 
    -0.02146738f, -0.12681997f, 0.04737430f, -0.06526856f, -0.07122795f, 0.15898778f, 0.06203154f, 0.01376060f, 
    0.05779072f, 0.01227920f, 0.02224853f, -0.01874939f, -0.12429067f, -0.01524580f, 0.02480177f, 0.14322568f, 
    0.03296282f, 0.04061772f, 0.06126466f, -0.05347105f, 0.02648373f, 0.15591078f, 0.05890696f, 0.18886214f, 
    -0.03955495f, 0.16690892f, 0.05713684f, -0.00670137f, 0.09602945f, -0.02076899f, -0.00406733f, 0.05657218f, 
    0.02328897f, 0.17544022f, 0.01045243f, 0.01957133f, 0.05589757f, 0.02533657f, 0.00951867f, -0.01445420f, 
    0.07908034f, 0.00547517f, -0.01730897f, 0.06853047f, 0.08359729f, 0.06533878f, -0.00325902f, 0.01605803f, 
    0.04545357f, -0.23810224f, -0.08524558f, -0.03658852f, 0.11191073f, 0.05773408f, 0.01004674f, 0.15103282f, 
    0.17026494f, 0.10451815f, -0.07185458f, 0.05338971f, 0.04920541f, -0.12515138f, 0.02598588f, 0.06718446f, 
    0.07381947f, 0.03624292f, 0.14815161f, 0.03957001f, -0.04042498f, -0.03354048f, 0.03801579f, 0.00115723f, 
    0.16279989f, -0.02963864f, 0.07498122f, -0.05822176f, -0.00564271f, 0.01525065f, -0.11658216f, 0.12948817f, 
    0.11228608f, 0.15968621f, 0.08790262f, -0.02330218f, -0.24329469f, 0.00297966f, -0.21533492f, -0.14648841f, 
    0.07566246f, 0.03165217f, -0.09081789f, -0.00282563f, 0.10054123f, -0.04198311f, -0.00098501f, -0.01410188f, 
    -0.65133560f, -0.41063192f, 0.04774873f, 0.11251560f, 0.08914448f, 0.02363776f, -0.03051233f, -0.19693103f, 
    0.05471185f, -0.05145454f, -0.08685555f, 0.06161276f, 0.01745445f, 0.01402620f, -0.04047687f, 0.02021125f, 
    -0.05123538f, -0.02288529f, -0.05139868f, -0.20406654f, -0.01357474f, -0.01109572f, -0.05866052f, -0.09981044f, 
    0.13683556f, -0.12877874f, -0.01431260f, 0.01554414f, 0.00560142f, 0.00342113f, 0.01155849f, 0.00239189f, 
    -0.06316964f, 0.06189952f, 0.04652419f, -0.02225490f, -0.07681359f, -0.05352092f, 0.02534943f, -0.08043349f, 
    -0.07570029f, 0.02278769f, 0.00638080f, -0.04421616f, 0.07830303f, -0.07440284f, -0.02037746f, -0.06149642f, 
    -0.11732281f, -0.03895885f, -0.08039559f, -0.10009863f, 0.10531206f, -0.01423217f, -0.01554375f, 0.05759222f, 
    0.06964831f, -0.03186260f, 0.10526957f, 0.06332514f, -0.21794121f, -0.06253868f, -0.14752242f, -0.10516216f, 
    0.02879656f, -0.07870390f, -0.07171782f, 0.09034978f, 0.07549303f, 0.10242089f, 0.15413055f, 0.13113466f, 
    -0.20813438f, -0.15252937f, -0.19052473f, 0.11680564f, 0.03246088f, 0.04270109f, -0.02644706f, -0.05356755f, 
    0.04180045f, 0.02196780f, -0.11675756f, 0.03942626f, 0.09532416f, 0.04768653f, 0.05284842f, 0.01742228f, 
    0.05777801f, -0.06325823f, 0.05498660f, 0.03128638f, -0.06768433f, -0.14330000f, 0.09574906f, -0.10174194f, 
    -0.26797721f, 0.19351013f, -0.11793175f, -0.33108100f, 0.02531936f, 0.06049108f, -0.02359519f, 0.11752387f, 
    0.12772937f, 0.02544108f, -0.03757269f, 0.06347977f, 0.08562525f, 0.09414163f, -0.05939024f, 0.05314595f, 
    0.01422878f, 0.12645273f, 0.01835517f, 0.01349727f, -0.08483464f, 0.03568013f, -0.04307722f, 0.01428949f, 
    -0.17843944f, -0.10404111f, 0.04972878f, -0.34536666f, 0.08701184f, -0.14936946f, -0.07736618f, -0.05601673f, 
    -0.09082080f, -0.02922146f, -0.01903092f, 0.00234719f, -0.24994405f, 0.05880944f, 0.17368495f, 0.09331084f, 
    0.14695051f, 0.01476124f, 0.01132846f, -0.01984694f, 0.06478731f, 0.04904349f, -0.04203589f, 0.15129955f, 
    0.16593020f, 0.08393721f, -0.11931387f, 0.08760215f, 0.01786856f, 0.05176140f, 0.04165231f, -0.03585754f, 
    0.00421665f, 0.05112506f, -0.08572169f, -0.01500478f, 0.17236035f, 0.04510497f, -0.06006822f, 0.05054690f, 
    -0.04905230f, -0.08818898f, -0.09260753f, 0.08193696f, 0.02193716f, -0.00539465f, -0.04960274f, 0.10939356f, 
    0.08695969f, 0.13004117f, -0.07194479f, 0.03980118f, -0.01783066f, -0.02992121f, 0.08275543f, 0.01076983f, 
    0.06109812f, 0.00633174f, 0.03799659f, -0.02840382f, -0.15846339f, -0.28249124f, -0.07742082f, -0.01459576f, 
    0.02916690f, 0.07655688f, 0.01156379f, 0.07154729f, 0.03687883f, -0.02159481f, 0.03907098f, 0.02234690f, 
    0.14755037f, -0.01099167f, -0.10573360f, 0.09346753f, -0.04754788f, -0.10019065f, -0.04734131f, -0.02820636f, 
    -0.09122745f, -0.09759175f, -0.11484039f, -0.02671214f, 0.04799858f, 0.13357237f, -0.02842979f, 0.04225714f, 
    -0.15015902f, -0.11395974f, 0.01053321f, -0.10696936f, -0.06454609f, -0.00108101f, 0.09052441f, 0.05279856f, 
    0.22421665f, 0.03113888f, -0.18333313f, -0.01849860f, -0.00012469f, -0.02772814f, 0.03138790f, -0.02779044f, 
    -0.06633136f, -0.04982589f, 0.08706586f, -0.04904424f, -0.00769903f, 0.03847053f, 0.01761886f, -0.02659856f, 
    0.01132750f, 0.03461183f, -0.00584194f, -0.07988976f, 0.10098457f, -0.03553016f, -0.08224732f, -0.11293609f, 
    -0.14688745f, 0.10405700f, -0.02165341f, 0.11945842f, -0.14889471f, 0.11024392f, -0.15344152f, 0.05548365f, 
    -0.06021571f, 0.01687619f, -0.04746138f, 0.07214952f, -0.11104815f, -0.12246490f, 0.13247812f, -0.07241827f, 
    0.11544053f, 0.05847575f, 0.06883840f, -0.07635567f, -0.00022841f, 0.07742803f, 0.03658082f, -0.10480548f, 
    -0.12837613f, -0.08546875f, -0.10698067f, -0.28088316f, 0.01293338f, -0.07213742f, 0.05394556f, -0.03537823f, 
    0.06532105f, 0.09927227f, 0.09562294f, 0.05345647f, 0.12210084f, -0.16596201f, 0.03049471f, -0.06850930f, 
    0.04486379f, 0.02026932f, 0.12485547f, 0.11237612f, -0.10326277f, -0.11070207f, -0.13379990f, -0.01215842f, 
    0.17934543f, -0.01515859f, -0.16573495f, 0.08900627f, -0.05372940f, -0.01986538f, -0.06031152f, -0.02324701f, 
    0.05101338f, -0.00670832f, -0.05664220f, -0.07181647f, 0.04165678f, 0.12713605f, -0.10688800f, -0.10046596f, 
    -0.12233113f, 0.07568937f, -0.01386946f, -0.06927034f, -0.03387940f, 0.04404500f, 0.02801609f, -0.02370244f, 
    0.28079659f, -0.29343784f, -0.30020148f, 0.30415845f, -0.03673209f, 0.01045348f, -0.04202261f, -0.10460442f, 
    0.01801486f, 0.06832444f, 0.05834070f, -0.04377320f, 0.07060629f, 0.23928510f, -0.10963906f, 0.02968308f, 
    0.25532359f, 0.03835961f, -0.06675250f, 0.03919188f, 0.01782312f, 0.02477189f, -0.05629215f, -0.03868058f, 
    0.02688138f, -0.25422463f, 0.14580686f, 0.05696821f, 0.12188067f, 0.01193011f, 0.03088144f, 0.01678117f, 
    0.02753458f, 0.00660192f, -0.02097131f, -0.02822758f, -0.30698675f, 0.13493061f, -0.12461444f, -0.02111355f, 
    -0.01073992f, 0.03144534f, 0.01616932f, -0.06326137f, -0.01815152f, -0.06692190f, -0.07914284f, -0.06146523f, 
    0.03083696f, -0.00623201f, -0.23925665f, 0.06822248f, 0.08306603f, -0.00871216f, 0.05681109f, 0.06997331f, 
    -0.06022617f, -0.01351879f, -0.03833154f, 0.08602075f, -0.11641806f, -0.00461002f, -0.01634210f, 0.05329867f, 
    -0.10369275f, -0.00868023f, 0.01727062f, -0.03443498f, 0.10844202f, -0.01064693f, -0.00942883f, -0.08594013f, 
    -0.21132000f, -0.25897869f, -0.09977663f, 0.07592946f, -0.04253227f, -0.01140124f, 0.03620774f, 0.14807808f, 
    -0.10557999f, -0.00258255f, 0.00758301f, 0.00084943f, 0.27262107f, -0.10794802f, -0.12809105f, -0.11225829f, 
    0.08133370f, -0.11083121f, 0.03325153f, 0.10313303f, -0.01511124f, 0.07906129f, 0.05930151f, 0.00571370f, 
    0.21855842f, -0.12108137f, -0.11662817f, -0.01113755f, -0.05769405f, -0.01811193f, -0.01187522f, -0.05862134f, 
    -0.00056966f, -0.10119588f, -0.06835371f, -0.05865760f, -0.04959199f, 0.13274229f, -0.10477225f, -0.06852883f, 
    -0.05168485f, 0.11498486f, -0.00012730f, -0.03936550f, -0.00129823f, 0.14513718f, -0.10498642f, -0.05185893f, 
    0.02847923f, 0.05753345f, 0.06745842f, -0.13731694f, 0.13824674f, -0.14438428f, -0.01222531f, 0.09191810f, 
    -0.01077952f, -0.04151989f, 0.07209439f, -0.01683014f, 0.37045529f, -0.08515842f, -0.11015475f, -0.09462988f, 
    -0.06403472f, -0.01919416f, 0.03361878f, -0.02120892f, 0.05698425f, -0.01610161f, -0.00091561f, -0.00944848f, 
    0.15811028f, 0.01174095f, -0.12645365f, 0.00968303f, -0.20428753f, -0.11390316f, -0.00698590f, 0.02718541f, 
    0.00314331f, -0.04806204f, -0.07504819f, -0.11174132f, -0.15124224f, 0.20269670f, 0.01553891f, 0.07975397f, 
    0.19376168f, -0.08383998f, 0.01503400f, -0.07991283f, 0.00746593f, 0.07660118f, 0.05501763f, 0.15925419f, 
    0.25986120f, -0.20258349f, 0.05649129f, -0.00935645f, -0.06429111f, 0.09324813f, 0.03572900f, -0.05404366f, 
    -0.04351850f, -0.03101854f, 0.10686682f, 0.07418530f, -0.07565013f, 0.18381335f, -0.06339779f, 0.01164926f, 
    -0.06885077f, -0.01354920f, -0.00288969f, 0.13884273f, -0.11574230f, 0.06218093f, 0.15352528f, -0.10798825f, 
    -0.15797207f, 0.04633041f, -0.09581167f, 0.12937188f, -0.03035584f, -0.01294630f, -0.06161592f, -0.05461981f, 
    -0.08650619f, -0.00762649f, 0.07451309f, -0.03309115f, -0.27809969f, 0.03539630f, -0.32895559f, -0.00866662f, 
    -0.07355911f, -0.00148554f, 0.08260181f, 0.10256770f, -0.01429961f, -0.01021637f, 0.02342553f, -0.05256344f, 
    -0.08255488f, 0.00563765f, -0.04558114f, 0.01046939f, -0.05718455f, 0.04940226f, -0.06689786f, -0.05594477f, 
    -0.02384772f, 0.04392235f, -0.08916253f, -0.20406438f, 0.36023378f, -0.18229976f, -0.07279038f, 0.13618751f, 
    0.05416080f, 0.01822530f, -0.04169536f, -0.00344841f, 0.05744120f, -0.01520767f, 0.05022331f, 0.00602634f, 
    -0.03640535f, 0.06247285f, -0.00460489f, 0.10533386f, 0.00618845f, 0.00481982f, -0.03595090f, -0.09807776f, 
    -0.02676471f, -0.00424312f, -0.05881206f, -0.19522798f, -0.13587463f, -0.28769076f, -0.08430289f, -0.32023370f, 
    0.06434862f, 0.01610793f, 0.07026774f, -0.01518679f, -0.03320407f, -0.04342372f, -0.11743639f, 0.01291157f, 
    0.14508992f, -0.22298478f, -0.03636875f, -0.00045948f, 0.00651048f, 0.02963823f, -0.12717724f, -0.00571378f, 
    -0.15481000f, 0.00460569f, 0.00281911f, -0.02790898f, 0.02442231f, -0.10727964f, -0.18044630f, -0.17428918f, 
    0.09747150f, -0.04178119f, 0.07177251f, -0.09703449f, -0.01821247f, 0.05993816f, 0.04465434f, -0.05906205f, 
    -0.16121687f, 0.06312787f, -0.16581415f, 0.02078835f, -0.10409790f, -0.02771620f, 0.05312750f, 0.08093127f, 
    0.02347584f, -0.11374372f, 0.06880940f, 0.02796676f, -0.06761185f, -0.11345510f, -0.22494163f, -0.09419960f, 
    0.07668760f, 0.00278523f, 0.09526590f, -0.01092554f, -0.06023532f, 0.00336378f, -0.11695045f, -0.08335041f, 
    0.02817452f, 0.02435871f, 0.05928238f, 0.01573305f, 0.03063695f, 0.12429817f, -0.12500118f, -0.14612938f, 
    0.01974830f, -0.01620359f, -0.03121987f, -0.15076092f, -0.21150942f, -0.23006848f, 0.06305771f, -0.06020957f, 
    0.01101469f, -0.04362150f, -0.03088668f, -0.02829635f, -0.15359916f, -0.07386588f, 0.08716194f, 0.17716748f, 
    -0.12222436f, -0.02493183f, -0.00117917f, 0.16358750f, -0.06385227f, 0.04296198f, -0.02524799f, -0.15157357f, 
    -0.07893248f, -0.03622719f, 0.00065601f, -0.02847545f, 0.13498133f, -0.10020274f, 0.02199857f, -0.13711798f, 
    0.01686717f, 0.09318694f, 0.02081635f, -0.02013752f, -0.03664191f, 0.09533036f, 0.05346938f, 0.02587289f, 
    -0.10026053f, 0.19499573f, 0.12215823f, 0.11643741f, 0.15662210f, 0.00552768f, 0.11250890f, -0.05385064f, 
    -0.01216476f, 0.08138707f, -0.03153320f, 0.01577266f, 0.16490190f, -0.20985891f, 0.09829669f, -0.27770323f, 
    0.16977678f, 0.05479586f, -0.06377700f, 0.03482813f, -0.03268753f, -0.06410321f, 0.04291615f, -0.05783982f, 
    0.22421370f, 0.04864211f, -0.11724816f, -0.00051612f, 0.05607004f, -0.01465054f, -0.09943173f, 0.01974740f, 
    0.14902286f, 0.09990388f, 0.01300512f, 0.00901294f, -0.29464090f, 0.07877711f, 0.07436304f, -0.22119448f, 
    -0.02311836f, -0.01166633f, -0.02625713f, 0.10758213f, 0.08552618f, 0.05617708f, -0.07378068f, -0.02100807f, 
    0.22569118f, -0.09335504f, 0.04489053f, 0.24753205f, 0.08239154f, 0.02477701f, 0.02657125f, -0.02905767f, 
    0.10616115f, -0.08424830f, 0.13062008f, 0.08136855f, -0.29477546f, -0.12679408f, 0.04066547f, -0.01699341f, 
    0.02102469f, -0.05638834f, 0.03725776f, 0.04213978f, 0.02699524f, 0.01644331f, -0.04317584f, 0.00358002f, 
    0.10023459f, 0.01687088f, -0.07422589f, 0.07943136f, 0.06581353f, -0.07408586f, 0.13899463f, 0.07244069f, 
    0.03647942f, -0.10843936f, -0.17484741f, -0.00203153f, 0.23031814f, -0.09066334f, -0.13624462f, -0.04461323f, 
    0.08277850f, -0.06580660f, 0.03746556f, 0.01643026f, 0.03692092f, -0.08024063f, -0.01722099f, -0.03777497f, 
    0.36058250f, 0.13200641f, 0.02228275f, 0.11274973f, -0.00558271f, -0.04114950f, 0.10603295f, -0.06019231f, 
    0.01375501f, 0.09821407f, 0.00464841f, 0.06617828f, 0.05077001f, 0.07124133f, 0.10950337f, -0.01705365f, 
    -0.09953102f, -0.01808313f, -0.03825387f, -0.00068278f, 0.10892649f, 0.04945437f, 0.02062902f, 0.06041789f, 
    0.05707475f, 0.03554939f, 0.05624719f, -0.02723598f, -0.04611854f, 0.03194032f, 0.05601178f, 0.00569590f, 
    -0.05557414f, -0.11949590f, 0.11792770f, 0.04609567f, -0.34848580f, -0.21043319f, 0.03046406f, -0.06448032f, 
    0.09120046f, -0.00603328f, 0.06888307f, 0.02534188f, -0.10624865f, 0.02692264f, 0.02921651f, -0.01172967f, 
    0.06077129f, -0.05375601f, -0.03267797f, 0.14199069f, 0.07042199f, 0.03424357f, 0.01915690f, -0.11643064f, 
    -0.04266234f, 0.01649274f, 0.05045664f, -0.02995159f, -0.23657402f, 0.14215313f, -0.04443634f, -0.03753417f, 
    0.01354172f, 0.03815255f, 0.02159317f, 0.10737842f, -0.04333543f, -0.04060978f, -0.12520492f, -0.02460041f, 
    0.09956528f, -0.28500798f, -0.14849249f, 0.02201254f, -0.09385148f, -0.03600112f, -0.06666427f, -0.09436691f, 
    0.20371501f, 0.05503563f, 0.06727259f, 0.03444071f, 0.07684292f, -0.02644028f, -0.22849676f, 0.10942608f, 
    0.07536391f, -0.06562046f, -0.05100976f, 0.05995433f, 0.13424410f, 0.11088285f, 0.02354428f, 0.06046293f, 
    0.18808138f, -0.08828378f, -0.07525681f, 0.10305752f, 0.00123102f, 0.00915615f, -0.06449974f, -0.00422736f, 
    0.01277100f, -0.06806699f, -0.02556257f, 0.05887701f, -0.31349358f, 0.12160509f, 0.03658026f, -0.23682809f, 
    -0.00424245f, 0.01983836f, 0.07710543f, -0.01809128f, -0.05387873f, -0.06341083f, 0.06926426f, 0.01162741f, 
    0.39519545f, 0.04820729f, -0.29560927f, -0.09504411f, -0.07273469f, -0.02574435f, 0.03862876f, 0.04442496f, 
    0.03530949f, -0.00241336f, 0.07513043f, 0.01553388f, 0.29721847f, 0.07626254f, -0.10837708f, 0.06160560f, 
    -0.04263073f, -0.02375603f, -0.08565041f, 0.02241681f, 0.05508375f, 0.15153399f, 0.00494027f, 0.03778747f, 
    0.09598146f, -0.05934063f, 0.00733023f, 0.18508741f, 0.13006440f, 0.00163283f, -0.01707589f, -0.03329188f, 
    -0.00068330f, -0.02686453f, -0.00197538f, 0.04103506f, 0.25550228f, 0.00183791f, -0.02798679f, -0.10069754f, 
    -0.01262506f, 0.01725271f, 0.01568938f, -0.02137553f, -0.06449022f, 0.04433386f, -0.03554335f, -0.00349387f, 
    0.07402427f, -0.24771941f, 0.09233708f, 0.05083783f, -0.08899198f, -0.00104695f, -0.01561487f, 0.00993104f, 
    -0.09442696f, -0.05297879f, 0.04278065f, 0.04324358f, -0.48709035f, 0.25126424f, -0.01325618f, -0.00175753f, 
    0.14231795f, -0.09542782f, -0.03695176f, -0.01327464f, 0.10639297f, -0.03267974f, 0.00163439f, -0.00754520f, 
    -0.20165445f, 0.11865488f, -0.07316549f, -0.06311115f, 0.06342348f, -0.05672926f, 0.13993323f, -0.03113245f, 
    -0.01240353f, -0.13234332f, 0.08460611f, -0.02274862f, 0.09603828f, -0.01578241f, 0.01225518f, 0.04402154f, 
    -0.06668417f, 0.01392320f, -0.00799660f, 0.00810291f, -0.10013919f, 0.01049122f, -0.10819215f, -0.15597920f, 
    0.02453922f, 0.00871949f, -0.06333850f, -0.05596665f, -0.10710222f, 0.03931386f, -0.03413821f, -0.01041167f, 
    0.05246148f, -0.03922031f, -0.07341079f, -0.12070292f, -0.03420911f, -0.00867481f, -0.05290349f, 0.03026710f, 
    -0.02889316f, -0.01509869f, -0.08777966f, -0.13606204f, 0.02535729f, -0.00086842f, 0.06140233f, 0.13077275f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04710436f, -0.00088860f, -0.02029469f, -0.02229457f, 0.03305044f, 0.04037287f, -0.00397027f, -0.03448433f, 
    -0.02371941f, 0.01204232f, 0.06874539f, 0.02314687f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
