#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.66686243f, -0.50847048f, -1.21146059f, -0.34110296f, -0.62118053f, 0.70698887f, 0.94160563f, 0.10032053f, 
    0.09198693f, 0.93175566f, -0.17970940f, -0.16286111f, -0.15094838f, -0.18756999f, -0.81079334f, -0.36511680f, 
    0.38871124f, 0.80505478f, 0.12600440f, 0.06917174f, -0.35640064f, -0.24105982f, -0.06489626f, -0.31327170f, 
    0.07300312f, -0.52044547f, 1.53294635f, 0.60215324f, 0.12040216f, 1.04581726f, -0.22699264f, 1.22825181f, 
    0.61146480f, -0.70933855f, 0.91296268f, -0.82680762f, -0.13670397f, 0.44862282f, -0.39874899f, -0.06406278f, 
    -0.22131568f, -0.21642879f, 0.02360011f, -0.01584012f, -0.36951077f, 0.26507577f, 0.16704910f, 0.04118099f, 
    0.06452686f, 0.02438940f, 0.78089017f, 0.80944890f, 1.62207913f, 0.14619963f, -1.00682318f, -0.04052948f, 
    0.74716234f, -0.16177095f, -0.09066008f, -0.62804389f, 0.23593502f, 0.48196447f, -0.19786878f, -0.30438173f, 
    -0.06145258f, 0.00441542f, -0.05163094f, 0.08063191f, 0.12142341f, -0.14254865f, -0.16856882f, 0.40197408f, 
    0.20188518f, 0.60374135f, -0.42789999f, 1.63741446f, 0.02348660f, -0.30823213f, 1.10988688f, 1.46124685f, 
    0.81608570f, 0.01173528f, -0.49339420f, 0.77796477f, 0.21271366f, -0.23365355f, 0.35964948f, -0.01373822f, 
    0.10152301f, 0.36792067f, -0.16680832f, -0.03541471f, 0.62882012f, 0.03995485f, -0.10022186f, 0.30949539f, 
    0.31835338f, 0.46126685f, 0.04361714f, 0.18632217f, 0.42714480f, -0.44046161f, 1.06047642f, 1.35139322f, 
    -0.09065873f, -0.79148769f, -0.45916235f, -0.81944644f, -0.30948830f, -0.44734377f, -0.66295606f, -0.18957891f, 
    -0.10728352f, 0.73990798f, 0.14922455f, -0.19540964f, -0.59172601f, 0.20998077f, -0.04912886f, 0.29517046f, 
    -0.57748681f, 0.12403978f, -0.00868728f, 0.08084890f, -0.26118296f, 0.83818442f, 0.59910274f, 0.62812304f, 
    -0.37356311f, 1.17008805f, -0.42368379f, 0.36327809f, 0.24360730f, 0.03715431f, -0.07895634f, 0.10168655f, 
    -0.15177591f, -0.26761672f, 0.36150324f, 0.27108526f, 0.02564134f, 0.97140908f, 0.43863478f, 0.96497726f, 
    0.89502150f, -0.13114963f, -0.02662414f, -0.02457942f, -0.07525948f, 0.06560840f, -0.05840891f, -0.91300863f, 
    -0.75898921f, -0.76914680f, -0.42267627f, -0.29659629f, 0.01361792f, -0.44397578f, -0.57987720f, -0.42315945f, 
    -1.01217818f, -0.37594435f, -0.20060107f, 0.25475633f, -0.92535925f, -0.55919832f, 0.03196022f, 0.00865474f, 
    0.22482544f, 0.45774761f, 0.25208077f, 0.53476167f, -0.38122010f, -0.01200235f, -0.03807519f, -1.38885367f, 
    -0.51021981f, -0.93616307f, -0.87252057f, -0.63051033f, 0.30905804f, -1.44156158f, 0.03415637f, 0.47160926f, 
    -0.86422259f, -0.23565984f, -0.04234503f, -0.28915143f, 0.57426107f, 0.45792240f, -0.07442649f, 0.36965269f, 
    -0.15331106f, 0.20194870f, -0.22017260f, 0.12590463f, 0.20750052f, 0.10612682f, -0.11681730f, -0.03457838f, 
    0.89646041f, 0.59577990f, -1.49092329f, -1.67418134f, -0.80700165f, 0.52140874f, -0.58417428f, 0.93321884f, 
    0.67377913f, 0.50517905f, -0.10493562f, -0.44314188f, -0.24106470f, 0.06728056f, -0.21455044f, 0.11698398f, 
    0.01290080f, -0.35464975f, 0.02202055f, 0.22809331f, 0.00485846f, 0.08643181f, 0.01995916f, 0.27367929f, 
    0.16617912f, 1.28120351f, -1.75076210f, 0.27789894f, 1.18846440f, 1.07367027f, -1.18932354f, 0.82630771f, 
    0.06782822f, -0.36435485f, 0.63263756f, 0.40618682f, 0.21705641f, -0.44860083f, -0.18629120f, 0.07269900f, 
    -0.42491907f, -0.12791300f, -0.03495432f, 0.08253290f, -0.16412656f, -0.27780733f, -0.01081926f, 0.02410458f, 
    -0.19175763f, -0.04598010f, -0.88124943f, -2.11585689f, -0.82626915f, 0.13813348f, 0.74220693f, -0.71903878f, 
    1.14624786f, 0.50092548f, -0.85800946f, 0.11248750f, 0.19131087f, -0.27092376f, -0.07795596f, -0.18076433f, 
    0.23708236f, -0.28269035f, -0.06686565f, -0.09319627f, -0.30878475f, -0.21381177f, 0.07621009f, 0.00448297f, 
    -0.04349744f, 0.04810539f, -0.13541190f, -0.30438825f, -0.47335857f, -0.50307572f, -1.17410052f, -0.76052904f, 
    0.86815816f, 0.69114906f, -0.31776020f, -0.88349837f, 0.78492236f, 0.26961806f, 0.21833715f, 0.22342646f, 
    0.32646230f, 0.38921684f, -0.07649121f, -0.10366292f, -0.17311272f, 0.01760063f, 0.15938190f, 0.16467851f, 
    0.22803140f, 0.06349427f, -0.32401583f, 0.59542000f, -0.24249414f, -0.43368030f, 0.48363820f, 0.12383607f, 
    1.28552949f, -0.58316636f, -0.80985546f, -1.10686946f, -1.42302358f, 0.07735587f, 0.51144534f, 0.51227325f, 
    0.29196590f, 0.39429680f, -0.10927272f, 0.51022416f, -0.29566231f, 0.20728263f, 0.45958117f, 0.11244801f, 
    0.40159738f, 0.16210979f, -0.41580871f, 0.29702452f, 0.04974056f, 1.22513187f, 1.58137023f, 1.12662148f, 
    0.76497763f, 0.75107706f, 0.49257407f, -0.90507764f, -0.65644437f, -0.89389366f, -0.33125362f, 0.42971131f, 
    0.41406068f, -0.21800213f, 0.47974578f, -0.51691097f, 0.29515904f, -0.14746808f, -0.02343565f, 0.01793477f, 
    -0.19520776f, 0.04561650f, -0.00116850f, 0.37577665f, -0.00976495f, 0.49885333f, -1.23547280f, -1.61105120f, 
    0.04395911f, 0.05295185f, -0.54481220f, 0.54559165f, 0.51059037f, 1.06735802f, 0.52189445f, 0.30415431f, 
    0.27101731f, -0.41951993f, -0.28235808f, 0.16594112f, -0.16510527f, 0.09457622f, 0.19075097f, -0.27994034f, 
    -0.32639599f, -0.28393608f, -0.01055404f, -0.03375907f, 0.13237128f, -0.11177794f, 0.06043454f, 1.73774755f, 
    0.70967102f, 0.32672924f, 0.79360765f, -0.28784972f, 0.32864276f, -0.28442860f, 0.84413832f, 0.42719367f, 
    0.24015152f, -0.92264867f, 0.22984856f, 0.06317332f, -0.38332051f, -0.37390223f, -0.03859093f, 0.19929478f, 
    -0.37139192f, 0.01266339f, 0.23277430f, -0.50319272f, 0.04028663f, -0.23772718f, -0.63235354f, -0.28000927f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04520444f, 0.02814530f, 0.38359585f, 0.00457007f, 0.59630251f, 0.05699907f, -0.14140981f, 0.67280561f, 
    0.44222811f, -0.11713561f, 0.38251188f, 0.44652137f, 0.60229361f, 0.18314759f, 0.20052849f, 0.09406956f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.45469892f, 0.25752941f, -0.06316750f, -0.46034297f, 0.39547461f, -0.08003270f, 0.04670352f, 0.06144915f, 
    -0.01452192f, -0.01981228f, -0.08207921f, 0.11538284f, -0.14002937f, -0.07845325f, 0.37132066f, -0.08898101f, 
    -0.24085774f, -0.04760319f, 0.07109167f, -0.26491895f, 0.10779789f, -0.11351217f, -0.23286957f, 0.08850127f, 
    -0.10270475f, 0.20802210f, 0.06043404f, 0.40950871f, -0.14962959f, 0.12201890f, -0.11987889f, 0.03513488f, 
    -0.19016232f, -0.00055239f, -0.11427491f, -0.28557536f, 0.48330608f, -0.17094776f, -0.13806249f, 0.47382516f, 
    -0.12684250f, 0.14356130f, 0.10889426f, 0.14471921f, -0.13127422f, 0.24109262f, 0.00157913f, -0.07171230f, 
    0.46841604f, 0.16651322f, -0.30953750f, 0.26999539f, -0.04661511f, -0.03894022f, 0.05167462f, 0.21519075f, 
    -0.04380043f, -0.14552069f, -0.04291433f, 0.05988322f, 0.01761711f, 0.18515554f, -0.15755060f, -0.56948417f, 
    -0.56309086f, 0.33008465f, -0.07415789f, 0.05784100f, 0.15223145f, -0.12306054f, 0.12739576f, -0.02726593f, 
    -0.59253746f, -0.42953289f, 0.12218237f, -0.05571087f, 0.01295555f, 0.15011559f, 0.33577082f, -0.11732189f, 
    -0.28213960f, -0.10453483f, 0.08810389f, 0.03923284f, -0.06264681f, -0.30815232f, -0.17636150f, -0.04647499f, 
    0.15224959f, -0.01009194f, 0.02526212f, 0.03452750f, 0.02512758f, -0.21053226f, -0.16236365f, -0.07698523f, 
    0.21632172f, -0.27214408f, -0.05675504f, -0.86667264f, -0.06457811f, -0.09108447f, 0.21367311f, -0.27869558f, 
    -0.05784468f, 0.15014981f, -0.03654511f, 0.04224775f, 0.63220876f, -0.30964720f, -0.07014343f, 0.61698586f, 
    -0.65299881f, -0.17816620f, 0.10442218f, 0.06063002f, 0.01798560f, 0.08917236f, -0.10241763f, -0.03926311f, 
    -1.06939530f, 0.54168087f, 0.00669661f, -0.00299702f, 0.18116452f, -0.04230291f, -0.24327472f, -0.13233803f, 
    -0.13703886f, -0.12106346f, -0.08218285f, 0.00031030f, 0.15691960f, -0.09116719f, 0.28227749f, -0.59060168f, 
    0.19800824f, -0.11036342f, 0.05334644f, 0.17244469f, 0.17291082f, 0.04558016f, -0.00869414f, 0.31026012f, 
    -0.18002857f, -0.38014609f, 0.21130833f, 0.15029003f, -0.11318530f, 0.11364525f, -0.16587158f, -0.04381450f, 
    -0.02389672f, -0.00314921f, -0.04660583f, -0.01580644f, 0.30299523f, -0.12840207f, 0.28631401f, -0.33666182f, 
    -0.45862532f, -0.24494353f, -0.08288561f, 0.23291470f, 0.11462001f, -0.01420055f, -0.04136452f, -0.10439159f, 
    -0.25115627f, 0.06923290f, 0.05242555f, -0.20314944f, 0.14615725f, 0.17348263f, 0.07805531f, 0.13577403f, 
    -0.02940679f, -0.03468775f, -0.04326503f, -0.14894085f, 0.47233418f, -0.37136707f, -0.24163023f, 0.09438363f, 
    -0.04251325f, -0.05380968f, -0.24041437f, 0.13038388f, 0.02617287f, 0.03158115f, -0.04970144f, 0.10223802f, 
    0.01249395f, -0.26908606f, -0.27654627f, -0.14570946f, 0.17140193f, -0.11121580f, 0.06913141f, -0.33413044f, 
    0.28513032f, -0.19416079f, 0.04130469f, -0.03579482f, 0.33045477f, 0.68861157f, -0.00556003f, -0.05063335f, 
    -0.04435690f, 0.28902912f, 0.00699691f, 0.13043569f, -0.01513748f, 0.11769286f, 0.22763848f, -0.18003640f, 
    -0.19869919f, -0.11494654f, -0.08626415f, 0.05699230f, -0.39578965f, -0.23839238f, 0.01659871f, -0.04382609f, 
    -0.00795810f, -0.20379688f, 0.01065604f, 0.03483099f, 0.34657645f, -0.42394471f, 0.25309879f, 0.36017287f, 
    -0.23492554f, -0.13361081f, -0.42084023f, 0.11604992f, -0.08104190f, 0.03201106f, 0.06926230f, 0.06007062f, 
    -0.05932976f, -0.25933126f, -0.59082818f, 0.00722669f, -0.07352185f, -0.03923823f, -0.06955763f, -0.11209121f, 
    0.04196369f, -0.18984863f, 0.15076964f, -0.10777591f, 0.33433327f, 0.12053525f, -0.11774302f, 0.06645530f, 
    0.21126601f, -0.04031793f, -0.13445482f, 0.09918508f, 0.03492625f, 0.06810620f, -0.07839907f, 0.10683089f, 
    0.13988504f, -0.14289410f, -0.09828509f, -0.28078526f, 0.03476832f, -0.30040568f, -0.39214790f, 0.14449649f, 
    0.08043998f, 0.21448843f, 0.00309903f, -0.14098279f, -0.30503497f, 0.26473293f, 0.09671333f, -0.13458714f, 
    -0.18957606f, -0.00561398f, 0.23637669f, 0.01434906f, 0.14426760f, 0.15276620f, -0.01273945f, 0.05780765f, 
    0.21299221f, -0.48365963f, 0.13074127f, -0.82276273f, -0.14058298f, -0.34292611f, 0.12203821f, 0.15403251f, 
    0.07594047f, 0.11528702f, 0.20806684f, -0.06401028f, -0.09642752f, -0.76989764f, 0.20435567f, 0.00970433f, 
    -0.14583053f, 0.06084848f, -0.01865674f, 0.06411456f, -0.04529230f, -0.08778565f, -0.01217614f, -0.12886690f, 
    0.65468854f, -0.23600923f, -0.20010662f, 0.02099843f, -0.14220420f, 0.14071022f, -0.09730433f, -0.13545111f, 
    0.00492417f, -0.14296633f, 0.03604112f, -0.12702624f, -0.00493584f, -0.16314454f, -0.19193587f, -0.15334271f, 
    0.04547000f, -0.09615549f, 0.18955950f, -0.12211578f, -0.23830894f, 0.03595190f, -0.00645255f, -0.03598875f, 
    -0.13076875f, -0.14686808f, -0.03513450f, -0.19468930f, 0.01154983f, 0.05890777f, 0.00337973f, 0.18099825f, 
    -0.00628299f, 0.22990330f, -0.10027243f, 0.10979011f, 0.29596844f, 0.06642631f, 0.29651922f, 0.33128038f, 
    0.07948575f, 0.05523273f, 0.18932118f, 0.03045338f, -0.03499901f, 0.02977750f, -0.00196392f, 0.09788938f, 
    -0.18592866f, 0.41372880f, -0.11744592f, 0.22929612f, -0.11626285f, -0.13676360f, -0.02598589f, 0.09157456f, 
    0.02363391f, 0.05014315f, -0.25726396f, 0.03670148f, 0.52187860f, -0.07316244f, 0.38292933f, 0.32134321f, 
    0.15510733f, -0.39186376f, -0.07951729f, -0.03892316f, 0.02793635f, -0.30731118f, -0.04772572f, -0.38053250f, 
    0.52881086f, -0.03969144f, 0.35217851f, 0.18187916f, -0.03894691f, -0.16945243f, 0.09485052f, 0.08438737f, 
    -0.15020902f, -0.11207739f, -0.06357936f, 0.21623494f, 0.30530581f, -0.24327923f, -0.20192108f, -0.05460339f, 
    0.24803255f, -0.05929523f, 0.01002705f, -0.24615546f, 0.02066493f, 0.03260069f, -0.00370096f, 0.15436076f, 
    -0.24964361f, 0.08148409f, -0.36553261f, -0.36427581f, -0.24272290f, 0.13383336f, 0.15216091f, 0.15143511f, 
    -0.10229832f, -0.13123007f, -0.18570608f, -0.17079842f, 0.03449486f, -0.06323638f, 0.21065494f, -0.26710123f, 
    0.27240795f, 0.02946856f, -0.26500782f, -0.07138672f, -0.00988871f, 0.01136011f, 0.03063759f, -0.00480060f, 
    -0.50028265f, -0.06179946f, -0.50132084f, -0.19027548f, 0.00894105f, 0.22680014f, -0.28915507f, -0.04609597f, 
    0.04286466f, 0.22985314f, -0.27178854f, -0.25063860f, -0.27316517f, 0.11530336f, -0.01302869f, 0.17555490f, 
    0.03651749f, 0.15605095f, -0.09257816f, -0.12251452f, -0.36088905f, -0.35595694f, -0.14294530f, 0.18299325f, 
    -0.77844280f, 0.11643633f, -0.47324306f, -0.45850793f, -0.15564629f, 0.05854729f, -0.07118004f, -0.20313230f, 
    0.21796657f, 0.03826291f, -0.03840727f, 0.08034156f, -0.87860519f, -0.01579203f, -0.35541734f, -0.23537163f, 
    0.06622593f, -0.23909770f, -0.28306010f, -0.13747193f, -0.09060614f, -0.08925609f, -0.11928517f, 0.10515772f, 
    -0.49457347f, 0.23980199f, 0.21218728f, 0.29100680f, 0.01704884f, -0.19095312f, 0.20743003f, -0.19278985f, 
    -0.23334245f, -0.15759045f, 0.10329654f, -0.04916146f, 0.72985119f, 0.01561843f, 0.20415477f, -0.24362032f, 
    0.21140972f, 0.10866832f, 0.10649998f, 0.17894308f, -0.00063012f, 0.00888015f, 0.00580240f, 0.02785046f, 
    1.10974741f, -0.44419819f, 0.02043147f, 0.04757785f, -0.23677242f, 0.19075915f, 0.00806156f, 0.07234593f, 
    0.07027080f, 0.05349940f, 0.09486330f, -0.01246491f, 0.45296657f, 0.24527636f, 0.47728577f, -0.14580014f, 
    0.00211926f, -0.28807461f, -0.19029789f, 0.08184776f, 0.00795351f, -0.06232374f, 0.05030631f, -0.21472487f, 
    0.32445124f, -0.14425628f, -0.14736630f, 0.02356354f, -0.02014823f, -0.04352570f, -0.09277384f, -0.04992845f, 
    -0.15789951f, -0.11683304f, -0.02900865f, -0.18010451f, 0.01189129f, 0.18648034f, -0.22528280f, 0.08899961f, 
    0.23831350f, 0.12795064f, 0.10999640f, -0.31145427f, -0.06598371f, 0.08955877f, -0.04658287f, -0.10101634f, 
    0.41075727f, 0.04860746f, 0.12990952f, 0.21044226f, -0.37353376f, -0.22423340f, -0.01842107f, 0.15579019f, 
    0.11771040f, 0.04092444f, 0.13042703f, -0.21866937f, -0.16994184f, 0.02853671f, -0.10170885f, -0.25729188f, 
    0.11483821f, 0.10609028f, 0.03566765f, 0.01055011f, 0.01534397f, 0.14187908f, -0.13472058f, -0.12855765f, 
    -0.36395776f, 0.04742869f, -0.14929044f, -0.26529819f, -0.33806422f, -0.01764639f, 0.10731784f, 0.02028614f, 
    -0.01575923f, -0.11371131f, 0.08881526f, 0.06625989f, -0.99133879f, -0.55830878f, 0.07863380f, -0.14430539f, 
    -0.00694291f, 0.03537785f, -0.15115686f, 0.10885470f, 0.19710320f, 0.13139737f, -0.19532780f, 0.26188254f, 
    -0.95893717f, 0.09227718f, -0.07933588f, -0.06675969f, -0.19739825f, -0.00948322f, -0.14869855f, 0.08377539f, 
    -0.10156549f, 0.05054387f, 0.03552615f, -0.13028650f, 0.20271316f, 0.05583289f, -0.18709520f, -0.08831866f, 
    0.11534557f, 0.28469345f, -0.15610510f, -0.32557034f, 0.03337501f, -0.13235493f, -0.04488821f, -0.00879261f, 
    -0.20828386f, 0.26977032f, 0.28513643f, 0.34297383f, 0.09392145f, 0.12148291f, 0.02907917f, -0.00412974f, 
    0.10098551f, -0.01439092f, 0.08726751f, 0.10919335f, -0.62275285f, -0.27185801f, 0.13474841f, -0.33314857f, 
    -0.02079887f, -0.00022312f, 0.21610203f, -0.00289095f, 0.00015846f, -0.20571332f, 0.03360325f, 0.22530654f, 
    -0.10045602f, 0.08078141f, 0.24222396f, -0.11104371f, -0.13255282f, 0.14039265f, 0.32291356f, 0.26271793f, 
    -0.08731551f, 0.10122482f, -0.12541398f, 0.14410996f, 0.24808249f, -0.01594055f, -0.12377930f, 0.13800496f, 
    -0.08476569f, -0.08781336f, -0.07695819f, -0.00372492f, -0.04632259f, 0.02766829f, 0.01724441f, 0.21694924f, 
    -0.08523757f, -0.34858540f, -0.06350832f, 0.19332613f, -0.21171898f, 0.19394834f, 0.03829698f, 0.12699734f, 
    -0.17558257f, 0.22084600f, -0.16521405f, -0.08764452f, -0.71947497f, 0.14306323f, 0.16042218f, 0.19541730f, 
    -0.01654928f, 0.32486400f, -0.01622889f, -0.09825423f, -0.00858319f, 0.32064855f, 0.10754509f, -0.06839129f, 
    0.17705755f, -0.01934128f, 0.22881933f, 0.32954594f, 0.03435812f, 0.01314635f, 0.27481896f, 0.13290772f, 
    -0.00574688f, 0.14913315f, -0.17117766f, 0.12838486f, 0.09846471f, -0.07093485f, -0.08146425f, -0.20909068f, 
    -0.08943690f, 0.10073280f, -0.15574870f, -0.05959106f, -0.11955577f, -0.16193829f, -0.08306819f, 0.10963021f, 
    0.00085392f, 0.33494332f, 0.37072384f, 0.53826171f, 0.19817327f, 0.34665814f, 0.09015042f, -0.30137464f, 
    -0.06234942f, 0.12975186f, -0.07483483f, -0.28550556f, 0.30736789f, -1.03898704f, -0.63056016f, 0.26437658f, 
    -0.28521445f, -0.13758963f, -0.07244880f, -0.10001820f, 0.07230712f, -0.10609211f, -0.13316183f, -0.10441072f, 
    0.61307240f, -0.20676540f, 0.06003442f, -0.41797349f, -0.02768644f, -0.05887969f, -0.15749191f, -0.11928263f, 
    -0.08996566f, -0.05462700f, 0.07882177f, -0.17961206f, 0.03900639f, -0.61205000f, -0.32802466f, 0.09006559f, 
    -0.22439225f, -0.13740534f, 0.12915117f, -0.05555247f, 0.04814329f, 0.23890391f, -0.12941542f, 0.24817620f, 
    -0.41376993f, -0.16798599f, 0.20182468f, 0.43619478f, -0.11851186f, 0.17290601f, -0.05557048f, -0.03714760f, 
    -0.16561483f, 0.22504693f, 0.18592319f, -0.03398886f, -0.02298115f, 0.29855436f, -0.10918973f, 0.36849052f, 
    -0.18145923f, -0.20638321f, 0.12300903f, 0.17201822f, -0.05419696f, -0.09912514f, -0.25036114f, -0.03731201f, 
    -0.24229175f, 0.12382455f, 0.26306584f, -0.70199019f, 0.14196149f, -0.13844284f, 0.01351462f, 0.15965116f, 
    0.11935203f, 0.10186387f, 0.02155482f, 0.02337296f, 0.22766528f, -0.13460296f, -0.04687557f, 0.04672388f, 
    -0.05536669f, -0.03430599f, 0.14053774f, 0.03023468f, -0.08222501f, -0.08412477f, -0.23984177f, 0.12003079f, 
    -0.31519791f, 0.22746663f, 0.45462856f, 0.15094766f, -0.02232786f, 0.27315912f, -0.05036800f, -0.00430621f, 
    0.13672569f, -0.17078179f, -0.15127760f, 0.14672580f, -0.16415022f, 0.04737315f, -0.12817734f, -0.31039381f, 
    0.01927632f, -0.23445606f, 0.21100655f, -0.06819530f, 0.19674900f, -0.09647206f, 0.06936964f, -0.17942894f, 
    -0.06159340f, 0.17887972f, 0.21375678f, 0.32947597f, -0.06380221f, -0.15110077f, -0.01910127f, 0.23214020f, 
    -0.12279812f, -0.18403129f, 0.24113218f, 0.14644732f, 0.55061734f, 0.12927592f, -0.13988848f, -0.13121429f, 
    0.12013150f, 0.10370405f, -0.02489317f, 0.04672513f, 0.08681230f, -0.20650429f, 0.04179609f, -0.10828358f, 
    -0.00932911f, -0.45859516f, -0.28367293f, 0.29576704f, 0.07452069f, 0.04126853f, -0.12548789f, 0.00191281f, 
    -0.11512136f, -0.01548088f, -0.17077364f, 0.08389346f, -0.63888252f, 0.40338194f, 0.02535954f, -0.21121992f, 
    0.07140724f, -0.02397469f, -0.08727832f, 0.00837193f, -0.04459934f, 0.02535164f, 0.06830026f, -0.15804239f, 
    -1.00198841f, 0.18211018f, -0.09768558f, -0.14267483f, 0.00134742f, -0.18718664f, 0.00355869f, 0.14282408f, 
    0.04845887f, -0.08986805f, 0.02676043f, 0.16359395f, -0.21576774f, -0.15783429f, 0.15615816f, 0.17234954f, 
    0.34659836f, 0.09583388f, -0.11132824f, -0.01662087f, 0.01950489f, -0.13477735f, -0.17355302f, -0.01871875f, 
    -0.54727471f, -0.12231492f, 0.32248798f, 0.02132486f, 0.00546905f, -0.39202192f, -0.21130066f, -0.02464049f, 
    0.39289242f, -0.18686406f, -0.05778407f, -0.19949132f, -0.56455439f, 0.10521603f, 0.32041976f, -0.00578175f, 
    -0.34847566f, -0.06332695f, -0.12844938f, 0.13499355f, 0.03393538f, -0.03146063f, 0.01328571f, -0.05695992f, 
    -0.39104342f, -0.03485844f, -0.29430419f, -0.00190971f, 0.17063366f, 0.25410873f, -0.09027129f, 0.19221289f, 
    -0.03704888f, 0.01058545f, 0.05542099f, 0.11325098f, -0.00966662f, 0.05813126f, 0.07358199f, -0.04330766f, 
    -0.09916931f, 0.21381027f, 0.10248628f, 0.12907648f, -0.05611681f, 0.15003216f, 0.27458519f, 0.20612451f, 
    0.13704075f, 0.34896111f, -0.37392548f, -0.11771501f, 0.13152874f, -0.18245058f, -0.02367281f, -0.01831570f, 
    -0.03697195f, -0.27575463f, 0.04778166f, -0.09751328f, -0.39258659f, -0.21881041f, 0.34295240f, -0.01688551f, 
    -0.08111932f, -0.10768793f, 0.14596033f, -0.05874034f, 0.08903252f, -0.06526202f, 0.02479949f, -0.20729952f, 
    0.05544353f, 0.26059270f, -0.01280124f, 0.48716643f, -0.02503354f, 0.08530398f, 0.11537624f, 0.14454184f, 
    0.12198071f, 0.02100508f, -0.11067428f, -0.04544052f, -0.16635695f, -0.07689235f, -0.01718744f, -0.61002564f, 
    0.03898669f, -0.17431919f, -0.00231887f, 0.04420330f, 0.30583730f, -0.00185003f, 0.14383197f, 0.03838613f, 
    0.13758187f, -0.08104429f, -0.03934338f, -0.01244939f, -0.00724430f, -0.01024123f, 0.07875723f, 0.07904910f, 
    -0.31906387f, 0.29623181f, 0.23309651f, -0.09303851f, 0.16112193f, -0.01061898f, 0.32432082f, -0.30137148f, 
    -0.05838742f, 0.01484634f, 0.05171556f, -0.12543485f, -0.08421744f, 0.29707786f, 0.24327961f, 0.20997885f, 
    0.35446101f, -0.18435436f, -0.28431532f, 0.08918843f, 0.24752280f, 0.01400737f, -0.04693835f, 0.00744972f, 
    0.02822441f, -0.00761686f, 0.22106214f, -0.17130516f, -0.80549181f, -0.50133812f, 0.02611637f, 0.25724447f, 
    0.21711281f, 0.10187827f, -0.02148817f, 0.19934654f, 0.03468213f, 0.12225011f, -0.07347421f, -0.00006122f, 
    0.31475016f, 0.21034324f, 0.01941166f, -0.22465368f, 0.13994724f, -0.01402489f, -0.25110978f, -0.07765289f, 
    0.06690931f, -0.02831494f, -0.02251670f, 0.08312446f, -0.50728571f, 0.15446231f, 0.14792278f, -0.19642641f, 
    -0.01065583f, -0.09200671f, -0.03616955f, -0.06527538f, 0.13488992f, -0.31172872f, 0.08291502f, -0.08622275f, 
    -0.81626320f, 0.19464079f, -0.31286415f, -0.54321229f, 0.25353107f, -0.04396306f, -0.08038031f, 0.11694456f, 
    -0.21152191f, -0.00159942f, -0.18302254f, -0.07559178f, -0.59186453f, -0.23141307f, -0.20703861f, 0.29783362f, 
    -0.06682339f, 0.03550285f, -0.16074272f, 0.16000466f, 0.11723651f, 0.11839408f, 0.26223519f, 0.05416097f, 
    0.27112365f, -0.08198105f, 0.03234566f, 0.06151030f, -0.15691255f, -0.05237294f, 0.02409751f, -0.04728074f, 
    -0.40677831f, 0.09647284f, 0.17918701f, 0.32842106f, -0.01699306f, 0.08232018f, 0.12268298f, 0.55421329f, 
    -0.03891439f, 0.09381926f, 0.24167041f, -0.00221066f, -0.07590207f, -0.13212076f, -0.04401165f, 0.28247684f, 
    -0.75588119f, -0.36546084f, -0.61063480f, -0.07915587f, 0.14760707f, -0.04820913f, 0.13939455f, -0.30442148f, 
    0.14794040f, 0.02256379f, -0.29894897f, 0.02123246f, 0.28933370f, 0.34166172f, 0.09891541f, 0.08820990f, 
    -0.25707144f, -0.08312907f, -0.02861569f, -0.21325406f, -0.15242472f, 0.05136764f, -0.10841991f, -0.09269235f, 
    -0.30451763f, -0.16224116f, -0.26840910f, -0.09633563f, -0.02100633f, 0.11708080f, -0.14580405f, 0.09531561f, 
    -0.00113741f, 0.12442136f, -0.09503537f, 0.22178124f, -0.45401958f, -0.17644466f, 0.06309705f, -0.02231511f, 
    -0.06964966f, -0.00794338f, 0.09061994f, -0.01789550f, -0.01350376f, -0.08332304f, -0.07435960f, 0.08104718f, 
    0.08512194f, -0.13066597f, 0.32195276f, 0.12153325f, 0.30821866f, -0.05948734f, -0.00862596f, -0.12786622f, 
    -0.09461252f, 0.25749892f, 0.16001841f, 0.02135211f, -0.20806266f, 0.26781616f, 0.07401326f, -0.50949466f, 
    -0.39330927f, 0.06079865f, 0.25829253f, 0.08601270f, 0.04132851f, -0.09741081f, -0.06503040f, -0.00144240f, 
    -0.06326837f, 0.22442636f, 0.00917384f, -0.58498126f, 0.28437722f, -0.23451646f, 0.20098451f, 0.01712878f, 
    -0.12854239f, 0.00243330f, -0.03153887f, -0.10549938f, 0.11712033f, 0.13556001f, 0.38049239f, -0.10236794f, 
    -0.09118199f, -0.19665267f, 0.02218321f, 0.04061096f, -0.07643383f, 0.00332206f, -0.35659066f, -0.29025695f, 
    -0.07194017f, -0.18958244f, -0.26119456f, -0.25949353f, -0.22594857f, -0.05982234f, 0.29029492f, -0.50645161f, 
    0.12886824f, -0.05565253f, -0.01494163f, 0.17819400f, -0.14915563f, -0.10117003f, 0.06140012f, 0.06928758f, 
    -0.02980107f, -0.08132450f, -0.20999451f, -0.30445614f, -0.32765147f, 0.06473462f, -0.05389756f, -0.04588258f, 
    -0.51735854f, 0.12823011f, -0.41402382f, 0.43879879f, 0.11539879f, 0.14066075f, 0.05584737f, -0.01553483f, 
    0.14803538f, -0.20502582f, -0.04501690f, -0.12038941f, 1.16213071f, 0.11114017f, 0.32425880f, -0.04791479f, 
    -0.12068049f, 0.01485889f, -0.01268998f, 0.09636633f, 0.02539571f, 0.06776672f, 0.11534556f, 0.26537406f, 
    0.13007611f, -0.12896831f, 0.06518361f, -0.03141100f, 0.07344805f, -0.06776387f, 0.09970290f, 0.01572060f, 
    0.15090550f, -0.15968785f, 0.23531742f, 0.12340797f, 0.06053565f, 0.07639012f, -0.73774254f, 0.01974613f, 
    -0.10214087f, 0.19826096f, 0.26945156f, -0.09591769f, 0.00853008f, -0.04984268f, -0.05990748f, -0.10979952f, 
    0.13836814f, 0.20498888f, -0.07425660f, -0.21195932f, 0.16715278f, 0.22852287f, -0.01247170f, -0.19018005f, 
    -0.11681708f, -0.43299672f, -0.21700698f, -0.17970718f, 0.05010513f, 0.26887289f, 0.00968959f, -0.34244254f, 
    -0.28508419f, 0.00747493f, 0.03382693f, 0.04446605f, 0.08850020f, 0.13599075f, -0.00680635f, -0.00596071f, 
    -0.05026911f, -0.64884174f, 0.01627025f, -0.23511107f, -0.15642457f, -0.09040235f, -0.04442948f, -0.03129283f, 
    -0.14854470f, -0.00001820f, 0.15287745f, 0.29159552f, -0.48515311f, 0.29064381f, 0.26977953f, -0.01223729f, 
    -0.14250426f, 0.05644052f, -0.03591429f, 0.19772223f, 0.00058682f, 0.05324428f, 0.07823867f, 0.17310649f, 
    -0.18131311f, 0.38144428f, 0.14036806f, 0.00049657f, 0.09863165f, 0.16204579f, 0.09286869f, -0.03401914f, 
    -0.15849350f, 0.10245695f, 0.05877651f, -0.10754032f, 0.29548198f, -0.26090530f, 0.11888491f, 0.22600448f, 
    0.12381940f, -0.09875327f, -0.23882045f, -0.10364229f, -0.15117003f, -0.09340001f, -0.12777425f, 0.10698424f, 
    0.09291296f, -0.82331645f, -0.21222675f, -0.33227634f, -0.02186436f, 0.04978439f, 0.12963384f, -0.17753565f, 
    -0.01739201f, 0.05029140f, -0.14336260f, -0.01616256f, -0.64987838f, 0.33350840f, -0.30288252f, 0.13781756f, 
    -0.10683341f, -0.02717785f, -0.20353654f, -0.22858852f, -0.27674687f, -0.00695058f, -0.07424638f, -0.54766673f, 
    0.40908301f, -0.10360792f, 0.00667960f, 0.19994263f, -0.22163334f, -0.20661594f, 0.07585769f, -0.01291980f, 
    -0.13047566f, 0.09521542f, -0.12349349f, -0.18315957f, -0.09022561f, -0.18512145f, 0.01368544f, 0.14842720f, 
    -0.05858407f, 0.08537760f, 0.17340878f, -0.10634591f, 0.11275730f, -0.02502989f, 0.04598358f, -0.13792799f, 
    0.15040228f, 0.11838536f, 0.36652783f, 0.47881281f, 0.07854741f, -0.00591235f, -0.01991599f, -0.07860170f, 
    -0.04584128f, -0.16724998f, -0.35885289f, -0.29767451f, 0.01466872f, 0.32704270f, 0.01520800f, 0.42697355f, 
    0.05907346f, 0.01510407f, 0.06633233f, -0.02711531f, -0.01677195f, -0.18139306f, -0.18684141f, -0.24925375f, 
    -0.16428201f, 0.24715044f, -0.18695803f, 0.29440871f, 0.07974147f, -0.01322330f, -0.13796581f, 0.11108515f, 
    -0.01456120f, 0.09085463f, 0.05005258f, -0.00124064f, 0.41675270f, 0.12095197f, -0.33713284f, -0.19298850f, 
    -0.31182063f, -0.00628804f, 0.04946861f, -0.09168661f, -0.10509020f, -0.10350403f, 0.03378017f, -0.09416548f, 
    0.26873088f, -0.30506089f, 0.44657785f, -0.30935675f, -0.07429904f, 0.10162560f, -0.19374087f, -0.09061461f, 
    0.06149694f, 0.13568500f, -0.14662795f, 0.00776695f, 0.14737628f, 0.52906609f, 0.03814699f, 0.13993236f, 
    -0.02802271f, 0.04436667f, 0.11722296f, 0.03070212f, -0.08186013f, -0.03226905f, 0.01781924f, -0.23705003f, 
    -0.09290680f, -0.31146809f, -0.09090228f, 0.10349586f, -0.31114143f, -0.28691441f, -0.11954226f, -0.22846933f, 
    0.09262189f, -0.08526378f, -0.13157712f, -0.14343852f, -1.16435468f, 0.08294591f, -0.36042055f, 0.00295561f, 
    0.07969404f, -0.16630922f, -0.04087556f, -0.16665164f, -0.09057134f, 0.21990038f, 0.01497087f, 0.07806374f, 
    -0.02031658f, 0.05288480f, 0.21234997f, 0.37428874f, 0.29564792f, 0.15178394f, 0.17632852f, -0.06761371f, 
    -0.04656608f, 0.05669423f, -0.02098686f, 0.04035665f, -0.05271000f, 0.27094558f, -0.08597029f, -0.30207103f, 
    -0.16957816f, 0.30303809f, -0.00094597f, -0.08936957f, 0.00311729f, 0.12415113f, -0.11130594f, -0.08918152f, 
    -0.11643568f, -0.01554747f, 0.23845823f, 0.01932655f, -0.18362625f, -0.05004208f, -0.30188850f, -0.00553611f, 
    0.09724015f, -0.25112122f, 0.14949425f, 0.14651476f, 0.45443490f, 0.23076944f, -0.28104416f, 0.38533708f, 
    -0.08608719f, -0.02753982f, -0.20614310f, -0.30419552f, -0.32801998f, 0.05161396f, 0.00786435f, -0.53128296f, 
    0.53254580f, -0.20363550f, -0.23937394f, -0.06782263f, 0.21426024f, 0.02093404f, 0.01540812f, -0.15092756f, 
    -0.00519110f, -0.12756172f, -0.11657243f, 0.11460433f, -0.21696913f, 0.01648668f, 0.31249329f, 0.35334009f, 
    -0.03510008f, 0.07475567f, 0.08647989f, 0.03327996f, 0.00525017f, -0.05737933f, -0.06916849f, 0.01931044f, 
    -0.15805818f, -0.77428782f, -0.24061631f, -0.00821664f, -0.05875730f, -0.13328536f, -0.00616061f, -0.31873930f, 
    0.05760130f, 0.08664781f, 0.24927868f, -0.09101474f, -0.11918972f, -0.24470259f, -0.20028123f, 0.40405563f, 
    0.25484279f, -0.31092444f, -0.24952368f, -0.09761950f, 0.03186310f, 0.15578552f, 0.33946636f, 0.03641498f, 
    -0.42863443f, 0.00733303f, 0.04030036f, -0.58206385f, 0.25273672f, -0.05904662f, -0.26341963f, 0.20876655f, 
    0.17117444f, -0.05034500f, 0.11146621f, -0.54984665f, -0.38871321f, -0.22979064f, 0.30538628f, -0.62502223f, 
    0.18797620f, 0.07516588f, -0.28211936f, -0.06527440f, 0.00650358f, 0.09701153f, 0.01450855f, -0.18128043f, 
    -0.04572518f, 0.65829265f, -0.05917598f, 0.01597058f, -0.18196492f, 0.07083482f, -0.06341630f, -0.02634034f, 
    0.09112816f, -0.13836902f, -0.15968935f, 0.12503228f, -0.06544814f, 0.09919867f, -0.26059005f, 0.14449276f, 
    0.27003211f, -0.07712783f, -0.07505208f, -0.24640405f, 0.02691083f, -0.27379358f, 0.13419688f, 0.07167427f, 
    -0.51633978f, 0.07337419f, 0.22131461f, -0.10468372f, -0.10570242f, -0.02759023f, 0.00918046f, -0.22935790f, 
    0.25220615f, -0.13862744f, -0.12702779f, -0.07877612f, 0.06530598f, 0.33696586f, 0.23524421f, 0.01552790f, 
    -0.07408851f, 0.20761169f, 0.00982925f, 0.02178623f, -0.06577136f, -0.00730290f, 0.35536632f, 0.30483589f, 
    -0.34551534f, -0.11691816f, -0.36694524f, -0.26943120f, -0.28988916f, -0.12815420f, -0.09432126f, -0.19036666f, 
    0.07641555f, 0.04104174f, 0.14327750f, 0.10633201f, -0.20725083f, -0.05830187f, -0.15997325f, 0.39341751f, 
    0.23803858f, 0.26434144f, -0.07439020f, 0.02200176f, 0.10012192f, 0.03558202f, 0.09463949f, -0.13815233f, 
    -0.23278885f, -0.44084135f, 0.46357840f, -0.00940229f, -0.03663569f, -0.11394630f, 0.17846215f, -0.28368476f, 
    -0.04810648f, 0.00988878f, -0.10482743f, -0.14891663f, 0.03519900f, 0.04455962f, 0.06350131f, 0.04764926f, 
    0.22910063f, -0.15323770f, -0.11558454f, -0.09229773f, 0.03954379f, 0.18397830f, 0.02749771f, -0.06469589f, 
    -0.30190876f, -0.68239945f, 0.24359740f, -0.00760817f, 0.12805815f, 0.35220546f, 0.14623633f, 0.40350682f, 
    -0.01069069f, 0.29914495f, -0.14781904f, 0.09418006f, 0.77018774f, -0.62637734f, -0.07517757f, -0.23515791f, 
    0.05071305f, -0.01545885f, 0.09979469f, -0.02656511f, -0.07230893f, -0.00881660f, -0.00646009f, 0.31943908f, 
    0.43150666f, 0.12841624f, 0.20197961f, -0.10143945f, 0.10534820f, 0.12263297f, -0.07196935f, -0.04352446f, 
    -0.08715200f, 0.00064657f, 0.07162382f, 0.17609330f, -0.49246350f, 0.92267984f, -0.56793010f, -0.35005039f, 
    0.29899299f, 0.05187850f, 0.03475406f, -0.13486883f, -0.14666109f, 0.01864781f, 0.04662760f, 0.02405796f, 
    -0.03419016f, -0.13780104f, 0.01174360f, -0.50487769f, -0.40862271f, -0.08249865f, 0.07697969f, 0.10266125f, 
    -0.01542513f, -0.04045033f, -0.08436041f, 0.18895760f, 0.11512800f, -0.20104544f, -0.19946942f, 0.11661802f, 
    -0.12569343f, 0.04758626f, -0.03955107f, 0.02494762f, -0.05683420f, -0.22895694f, -0.07639045f, -0.28930631f, 
    0.25468430f, 0.02034815f, -0.06216449f, -0.20305336f, 0.12399741f, 0.25904456f, -0.17228717f, 0.11818039f, 
    -0.20900109f, -0.02120751f, -0.18852644f, 0.16176239f, -0.13611820f, -0.29898149f, -0.06825757f, 0.08745009f, 
    -0.33690619f, -0.11053050f, 0.08612608f, 0.18470997f, 0.05927883f, -0.46940985f, 0.01812761f, 0.13284309f, 
    0.03536874f, 0.38196248f, 0.55897123f, 0.02920388f, 0.05234346f, 0.01112862f, 0.01254723f, 0.39035368f, 
    -0.15880398f, -0.14735833f, 0.10256168f, 0.05532450f, -0.70640367f, 0.01511847f, 0.00332263f, -0.25235724f, 
    0.21699433f, -0.10760800f, 0.00968633f, 0.01894020f, -0.10351498f, 0.03019969f, 0.05665773f, 0.29890567f, 
    0.11942764f, -0.34601879f, -0.25906783f, 0.15789613f, -0.03491242f, 0.03056269f, -0.20546673f, -0.08900939f, 
    -0.05071035f, 0.17013182f, 0.07706265f, -0.12749240f, -0.53874993f, -0.24034555f, -0.09548942f, -0.03762306f, 
    -0.04824596f, -0.08741493f, -0.13396615f, -0.26094931f, 0.00222787f, -0.05159203f, -0.10743989f, -0.20486784f, 
    -0.20532578f, 0.34426218f, -0.22289360f, -0.25630245f, -0.04727649f, 0.18336618f, 0.13075119f, 0.01601227f, 
    0.00943995f, 0.19683462f, -0.07812887f, -0.04981882f, -0.45470050f, 0.33997563f, -0.00883952f, -0.84517258f, 
    0.11296208f, 0.08718076f, -0.24832423f, -0.00164503f, -0.26822355f, -0.14291616f, -0.04227255f, -0.32343858f, 
    0.84130019f, 0.03295924f, -0.13510230f, 0.00525756f, 0.15977775f, -0.16740596f, 0.02584664f, 0.06951914f, 
    0.07118878f, 0.12948740f, 0.21856694f, -0.11015678f, -0.28858465f, 0.04030658f, 0.00843588f, 0.12729079f, 
    0.28095490f, -0.12128007f, 0.41540888f, 0.05653783f, 0.09691784f, 0.00854842f, -0.03853041f, 0.06284282f, 
    0.21859723f, 0.18871830f, -0.07987591f, 0.03402197f, -0.19063219f, -0.10759359f, -0.07187930f, -0.18997909f, 
    -0.05283889f, -0.26413015f, 0.12032614f, -0.14376445f, -0.49347576f, 0.33625418f, -0.36654720f, -0.44277430f, 
    0.06017722f, 0.06868682f, -0.31877309f, 0.00959885f, 0.14844725f, 0.22417139f, 0.11725905f, -0.20843066f, 
    -0.91579342f, -0.01264252f, 0.01945417f, -0.17469954f, 0.18512322f, 0.06089266f, 0.03858440f, -0.11723194f, 
    0.09393161f, -0.06550620f, -0.20041950f, 0.17263061f, -0.54237223f, -0.73046368f, -0.11646301f, -0.17411745f, 
    0.11780854f, -0.15863910f, 0.26887709f, 0.08825465f, 0.10870712f, 0.16367945f, 0.36282554f, 0.24409571f, 
    -0.07352657f, 0.10017262f, 0.15091263f, -0.06583798f, 0.13924164f, -0.22413951f, -0.04624300f, 0.13882336f, 
    0.07451227f, 0.22273782f, -0.04715964f, -0.01391510f, -0.93528920f, -0.20488332f, 0.08625244f, -0.11303753f, 
    0.19766085f, -0.07255310f, -0.04211500f, 0.03170433f, -0.15288989f, 0.42035577f, 0.13176648f, 0.05092904f, 
    0.34351951f, 0.01007240f, -0.00724868f, 0.09730723f, -0.04716993f, 0.17564219f, -0.28799069f, 0.02575932f, 
    0.13791218f, -0.21780969f, 0.22143461f, -0.01480085f, 0.24439482f, -0.03075852f, 0.09410720f, -0.27307731f, 
    0.20836374f, 0.30520731f, 0.19695322f, -0.09706680f, -0.23537405f, 0.44796348f, -0.09073801f, -0.26962540f, 
    -0.39832774f, -0.25321674f, -0.01265385f, 0.05785753f, -0.00454663f, 0.29509923f, 0.10308063f, -0.16001847f, 
    0.11015981f, 0.11496736f, -0.20327653f, -0.04674609f, -0.20773639f, -0.57705867f, -0.19394170f, -0.09129682f, 
    -0.02814335f, -0.02309525f, -0.01178679f, 0.09066889f, 0.03730807f, -0.06056096f, -0.08785482f, -0.03886466f, 
    0.40777761f, -0.03453029f, -0.15946269f, 0.29636139f, -0.22270313f, 0.06732897f, -0.06595601f, -0.01659135f, 
    -0.06375913f, -0.06661137f, -0.13414107f, 0.03658938f, 0.02086997f, 0.08281932f, -0.15538646f, 0.17585848f, 
    -0.28101242f, -0.11259106f, 0.08145677f, 0.26859090f, 0.23583788f, 0.12985185f, 0.23841089f, 0.09207745f, 
    0.68127722f, 0.26710579f, 0.07012825f, -0.19741811f, 0.08729219f, -0.01765115f, 0.02972657f, 0.28017437f, 
    0.11314861f, 0.17430234f, 0.42081681f, 0.44617668f, -0.74963725f, -0.33822969f, -0.24732035f, -0.68770146f, 
    0.22949512f, -0.00993171f, -0.12100596f, -0.04912935f, 0.03935299f, 0.12362951f, 0.03581109f, 0.06263389f, 
    0.25629264f, 0.00848582f, -0.00924311f, -0.15151241f, -0.24337719f, -0.17489085f, 0.18332389f, 0.16631289f, 
    -0.02065936f, -0.11846493f, -0.01920296f, 0.19296819f, -1.59315681f, -0.82391578f, -0.26415703f, -0.30857328f, 
    0.24466729f, 0.13264583f, -0.11088390f, -0.29320288f, 0.15856659f, -0.37816423f, -0.08853187f, -0.26811153f, 
    0.16959330f, -0.15414049f, -0.22848745f, 0.15041295f, -0.23752415f, -0.03704392f, 0.28504789f, -0.07575757f, 
    -0.08207412f, -0.03479584f, -0.35683757f, -0.15166105f, -0.77837050f, 0.21699993f, -0.41280013f, -0.29881757f, 
    0.12781164f, -0.02729911f, 0.03471806f, 0.23385666f, 0.02017872f, -0.08486981f, 0.34332159f, -0.02479257f, 
    0.74916440f, -0.13846047f, -0.14113361f, 0.07113857f, -0.09069090f, -0.00063290f, 0.01826150f, -0.08334580f, 
    0.13740580f, -0.02194182f, -0.09706523f, -0.19004482f, 0.04566218f, -0.38414457f, 0.19912687f, -0.02873927f, 
    0.20252180f, 0.04190897f, 0.11213229f, -0.17849490f, 0.02998695f, -0.14088166f, -0.14408602f, 0.02635179f, 
    0.08887887f, -0.01089541f, -0.05332640f, 0.00035152f, 0.03319817f, 0.23753816f, 0.01227969f, 0.11943331f, 
    0.25146711f, -0.11171928f, -0.17536190f, 0.08569074f, 0.17665294f, 0.15025747f, -0.34435987f, 0.67102337f, 
    0.05693780f, 0.15998232f, -0.11098523f, -0.24086899f, 0.05254644f, -0.07053542f, -0.32291973f, -0.21044128f, 
    -0.01652505f, -0.02903214f, -0.21091451f, 0.18221468f, -0.14063191f, 0.02210503f, -0.20255512f, -0.33946937f, 
    0.07831723f, -0.11956423f, -0.12512928f, -0.04067037f, 0.63394338f, 0.16601188f, -0.09332997f, 0.07857741f, 
    -0.33189425f, 0.17592086f, 0.01361760f, -0.07619359f, -0.04785519f, -0.21450044f, 0.17306550f, 0.09341002f, 
    -0.00632106f, 0.19935440f, -0.13577291f, 0.29853809f, 0.10713441f, -0.07898176f, -0.07536107f, -0.21732293f, 
    -0.00284687f, 0.16332306f, 0.12744229f, 0.00846893f, -0.49701661f, 0.35257167f, -0.42486265f, -0.24283229f, 
    0.22197674f, -0.08421417f, 0.13059825f, -0.00675885f, -0.05075633f, 0.15205064f, -0.13073234f, -0.00514373f, 
    -0.16434123f, 0.07278643f, -0.07779962f, 0.09820735f, 0.14282911f, -0.01672655f, 0.17531960f, -0.11267129f, 
    0.00797144f, 0.09838009f, 0.21426484f, 0.04536490f, 0.19079874f, -0.37755817f, -0.07044962f, 0.13668931f, 
    0.05290010f, 0.07943941f, -0.09522937f, 0.17762741f, -0.01433140f, 0.09139206f, -0.12290166f, -0.31481010f, 
    -0.02078786f, -0.19999737f, -0.36938867f, 0.36422214f, 0.03358359f, -0.19124046f, 0.22250205f, 0.15580726f, 
    -0.10004818f, -0.10431914f, -0.12164800f, -0.03347501f, 0.80461246f, -0.26988867f, -0.45418546f, 0.00133882f, 
    0.08242054f, -0.34157485f, 0.11303882f, 0.01380755f, 0.07597005f, 0.18267404f, 0.12115808f, 0.00654146f, 
    -0.62275815f, 0.15134563f, 0.09596232f, -0.20901620f, -0.10258538f, 0.01732667f, -0.18363173f, 0.01422793f, 
    0.00690828f, 0.02762040f, 0.09782266f, -0.09309495f, -0.56998163f, 0.14738186f, -0.29364565f, -0.35271806f, 
    -0.07594664f, 0.04007875f, 0.02044525f, 0.07819401f, 0.08683459f, -0.10576408f, 0.02477656f, -0.08050413f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.21292512f, 0.07179762f, -0.07298809f, 0.08369435f, 0.02309135f, -0.03237552f, 0.06879249f, -0.20029861f, 
    -0.04721908f, 0.02950839f, 0.27896848f, -0.00188446f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
