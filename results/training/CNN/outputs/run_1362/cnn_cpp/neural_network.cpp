#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.51866782f, 0.35290864f, 0.32965234f, -0.45003098f, -0.58296186f, -0.10932525f, 0.23742810f, 0.14656112f, 
    -0.30837861f, -0.10688171f, -0.20241056f, -0.10844403f, 0.41974857f, -0.29538584f, -0.13518140f, -0.01549479f, 
    -0.00490512f, -0.06777126f, -0.38855940f, 0.35947913f, 0.20191857f, -0.06642438f, -0.23263755f, 0.07252011f, 
    0.24504812f, -0.65911549f, -0.38713714f, -0.18130457f, -0.29736477f, -0.01156322f, 0.02405235f, 0.12199368f, 
    -0.20193535f, 0.33979824f, 0.09667610f, -0.11344018f, -0.45339534f, 0.00058976f, -0.43690032f, 0.25710753f, 
    -0.10135577f, 0.00320586f, -0.30031890f, 0.33033434f, 0.25832754f, -0.04552409f, -0.04865317f, -0.26456848f, 
    -0.33001947f, -0.34426251f, -0.07304115f, 0.49622136f, 0.53383017f, -0.67986280f, -0.56965554f, -0.25165084f, 
    -0.16777033f, 0.29375184f, -0.09912253f, 0.33249363f, -0.27345616f, -0.04836307f, 0.54435700f, 0.03665400f, 
    -0.12218887f, -0.17599583f, -0.18244369f, 0.17252350f, 0.26562774f, 0.00953678f, -0.24489217f, 0.06109671f, 
    -0.00385393f, 0.15845889f, 0.08762180f, 0.28336224f, -0.01377368f, -0.05337127f, 0.00771140f, -0.90246302f, 
    0.03186150f, -0.41090247f, -0.35286734f, -0.58260608f, -0.35384312f, 0.08564514f, -0.20135969f, -0.15881561f, 
    -0.33329713f, -0.17407195f, -0.12162043f, 0.26128837f, 0.27044570f, -0.12553866f, -0.20535845f, -0.10626131f, 
    -0.10204150f, 0.00553520f, 0.22272864f, 0.05069123f, -0.63671422f, 0.05120341f, 0.07574300f, 0.30076087f, 
    0.10118529f, 0.63572639f, 0.01853500f, -0.70551360f, -0.40036687f, 0.04884824f, 0.25044981f, 0.29140186f, 
    -0.08774459f, -0.06243296f, 0.08378197f, -0.28017655f, -0.31017578f, 0.17908952f, -0.07016847f, -0.14412351f, 
    0.24736331f, 0.33725172f, -0.44887426f, -0.03640487f, -0.01615543f, -0.66809064f, -0.34486759f, -0.48386356f, 
    0.21384278f, -0.09853696f, 0.33473706f, 0.49142459f, -0.04971505f, -0.27735344f, 0.59111309f, 0.27634475f, 
    -0.22598951f, 0.01106536f, -0.12286985f, -0.16679469f, -0.05253836f, 0.02953109f, -0.21798418f, 0.06560093f, 
    0.07735768f, 0.19186476f, -0.25455007f, -0.08131672f, -0.08839637f, -0.02568692f, 0.26667973f, -0.20901826f, 
    0.07108785f, -0.02962818f, 0.30876985f, -0.37747040f, -0.07606998f, 0.34347370f, -0.01567345f, -0.22606237f, 
    -0.15418603f, -0.10704482f, 0.26864898f, -0.03786366f, 0.30294326f, -0.00556996f, 0.04372479f, -0.21296327f, 
    0.04338919f, 0.13235800f, 0.28725040f, -0.26204818f, 0.27337775f, 0.34238982f, 0.07633547f, 0.27205101f, 
    -0.45133337f, -0.52301186f, 0.02642841f, -0.29877287f, -0.01804233f, 0.11338942f, 0.36068767f, 0.06236566f, 
    -0.32435298f, -0.34368581f, -0.40721112f, -0.24194911f, 0.23070078f, 0.02873450f, 0.22511652f, 0.39816803f, 
    0.03847764f, -0.02558592f, 0.27928746f, -0.21958926f, -0.05241235f, -0.05191203f, -0.30427438f, -0.20871036f, 
    -0.27859333f, -0.35328868f, -0.27300048f, -0.08258539f, 0.04034496f, -0.30535024f, 0.61336309f, -0.44025365f, 
    -0.46658224f, -0.65638334f, -0.02042330f, 0.02506796f, -0.00376962f, -0.17686498f, -0.30271596f, 0.02459892f, 
    -0.15517259f, -0.21875221f, 0.11409047f, 0.08918420f, -0.10055465f, -0.22468051f, 0.21010098f, 0.20700751f, 
    -0.30236444f, -0.39375231f, -0.79187620f, 0.38308594f, 0.53653312f, -0.20892923f, 0.05440282f, -0.33176452f, 
    -0.54165214f, -0.35448506f, -0.46558556f, -0.20497368f, 0.16277751f, -0.21659914f, -0.41011244f, -0.17206331f, 
    0.07581384f, -0.33505321f, -0.06569681f, -0.04066790f, 0.05268604f, -0.11111122f, 0.01820940f, -0.08868545f, 
    0.08068903f, -0.08336150f, -0.39866996f, 0.16401137f, 0.25988543f, -0.43791646f, -0.05778316f, -0.03767056f, 
    0.55923355f, -0.03033461f, -0.01899400f, -0.42747590f, -0.38450894f, -0.34326336f, -0.37359959f, 0.12358693f, 
    0.35522249f, 0.29912585f, -0.06609752f, -0.30626872f, -0.19416063f, -0.20202975f, -0.12524912f, -0.34133217f, 
    0.12917021f, -0.23570436f, -0.39766276f, 0.57208216f, -0.02817577f, -0.68538266f, -0.75256222f, -0.65683794f, 
    0.21248430f, 0.23843966f, 0.22463673f, 0.30755916f, -0.09865455f, 0.17550015f, 0.31756848f, -0.08353908f, 
    0.27073807f, -0.15817532f, -0.09497248f, -0.13707113f, 0.05222406f, -0.20389159f, -0.10983379f, 0.15606289f, 
    -0.13105658f, -0.26759782f, 0.20515440f, 0.26528066f, -0.82337517f, -0.98772216f, -0.15648662f, 0.01161398f, 
    -0.00682708f, 0.22608815f, 0.41577646f, -0.18290442f, 0.28721476f, -0.06332003f, -0.04997019f, -0.07607076f, 
    0.21338655f, 0.23863038f, -0.01817182f, 0.04560933f, 0.16230310f, -0.48901591f, -0.25112006f, -0.06985306f, 
    -0.09366308f, -0.18385124f, 0.12308503f, 0.07590298f, 0.19876824f, -0.55431724f, 0.12288327f, -0.38744846f, 
    -0.56093061f, -0.26304346f, 0.37842610f, -0.03671514f, 0.33100578f, -0.06702633f, 0.14630477f, 0.40611747f, 
    0.36053753f, 0.22397867f, 0.03860210f, 0.23549388f, -0.33132362f, -0.10969698f, -0.05370555f, -0.08259623f, 
    -0.28353155f, -0.05364361f, 0.14161666f, 0.16500589f, 0.05769659f, 0.23081641f, 0.07122989f, -0.02926153f, 
    0.14662549f, 0.10753857f, 0.11517211f, -0.21446717f, -0.21486056f, 0.04875460f, -0.35446423f, 0.12777105f, 
    0.14223853f, -0.07037880f, 0.50871843f, -0.00772517f, -0.41491854f, -0.20574601f, 0.23922674f, -0.23922919f, 
    0.22138393f, -0.35898450f, 0.27727625f, 0.09844007f, -0.28152895f, 0.40542269f, 0.24303956f, 0.58976829f, 
    0.33652982f, -0.00216542f, -0.24297042f, 0.19331023f, 0.12157132f, 0.18659876f, -0.04715896f, 0.02457510f, 
    0.44711429f, -0.12781991f, -0.00835709f, -0.12167364f, -0.15301508f, -0.25292251f, 0.47734791f, -0.15703471f, 
    -0.19286047f, 0.02675135f, -0.17440370f, -0.13262424f, 0.35985002f, -0.05047148f, -0.04145294f, -0.12530616f, 
    -0.77218610f, 0.11165968f, -0.32635984f, -0.84218830f, -0.75573826f, 0.89590865f, -0.06899055f, 0.34366438f, 
    0.08844668f, 0.10929208f, -0.21469653f, -0.42161861f, 0.00810094f, -0.38180146f, -0.03390449f, 0.19882694f, 
    0.23549263f, 0.02142697f, -0.00982702f, -0.05528827f, -0.20402272f, 0.13713653f, 0.20499933f, -0.04863891f, 
    -0.05788829f, -0.22989500f, -0.16757615f, -0.13025464f, -0.01040676f, -0.57789868f, -0.34378344f, -0.60007256f, 
    -0.64893675f, -0.17864965f, -0.64794511f, 0.29132205f, -0.22632962f, 0.43206561f, 0.36190698f, 0.61592066f, 
    0.00391480f, 0.07324589f, -0.21315141f, -0.46931130f, -0.21491025f, 0.16485116f, -0.01656905f, 0.05009841f, 
    0.07258043f, 0.01032243f, -0.62912226f, 0.39979255f, 0.28673396f, -0.17476176f, -0.33966893f, -0.16972354f, 
    0.31908920f, 0.72115886f, -0.30291373f, -0.23063774f, -0.09662515f, 0.12982541f, -0.08104373f, 0.23896478f, 
    -0.42350984f, 0.02497009f, -0.16549577f, -0.64139706f, 0.18035889f, 0.19916993f, 0.06874511f, 0.21108273f, 
    0.09422828f, -0.21174607f, 0.10610481f, 0.18302462f, -0.90249509f, 0.12793258f, 0.17678259f, 0.59280568f, 
    0.32977232f, 0.11557218f, 0.08071328f, 0.17275539f, -0.01319501f, -0.03179038f, 0.05722527f, -0.27253073f, 
    -0.21394403f, 0.22083145f, -0.23571736f, 0.06774895f, 0.00331956f, -0.19618194f, -0.11587701f, -0.31980255f, 
    0.34918866f, -0.37612101f, -0.19883931f, 0.04392682f, 0.55970603f, 0.64371026f, 0.51622891f, 0.22042605f, 
    -0.04982929f, -0.46817088f, -0.39616910f, 0.02553511f, 0.17954281f, 0.09735795f, 0.37844750f, -0.01448399f, 
    -0.14550343f, -0.12446771f, 0.25169376f, 0.10123080f, 0.13852291f, 0.02184963f, 0.12102595f, -0.23878556f, 
    0.09068574f, 0.04906561f, -0.14222576f, 0.22933580f, 0.01101743f, -1.18266904f, -0.52371162f, -0.24946624f, 
    0.69210970f, 0.91581380f, -0.06371660f, -0.36443520f, 0.05889123f, 0.29987988f, 0.42491654f, -0.34199196f, 
    0.00286775f, -0.37878236f, 0.30850881f, 0.18786594f, -0.17331916f, 0.00883633f, 0.17599458f, 0.08533910f, 
    0.13822138f, -0.03122669f, -0.19563641f, -0.02417558f, 0.21708477f, -0.06766782f, -0.61845857f, 0.02698363f, 
    0.03782360f, -0.13826735f, 0.07286198f, -0.14273500f, -0.34632361f, -0.45004383f, -0.17258810f, -0.13908322f, 
    -0.10619971f, -0.42951766f, -0.09205651f, -0.37355900f, -0.18462576f, -0.06042098f, -0.35102499f, -0.32849020f, 
    -0.11208197f, -0.01282142f, 0.12103628f, -0.10717086f, -0.22155297f, -0.06012806f, -0.05902271f, 0.52346402f, 
    -0.61564028f, -0.10157824f, -0.29827219f, 0.01837576f, 0.35171184f, 0.34850228f, 0.31386054f, -0.10508037f, 
    -0.53589112f, -0.18854320f, 0.06670320f, 0.53249383f, -0.56173217f, 0.12849347f, 0.35991937f, -0.11739296f, 
    -0.00396314f, -0.30266157f, -0.07338431f, -0.37429160f, -0.41030020f, -0.16447167f, 0.29420161f, 0.10749656f, 
    0.10723963f, -0.38882917f, 0.46988332f, 1.02714682f, 0.25861767f, 0.48961687f, -0.39509463f, -0.69454712f, 
    -0.66033876f, -0.27891305f, -0.17333083f, -0.17228714f, 0.00458670f, -0.07929917f, -0.15917070f, -0.21771437f, 
    0.12533741f, 0.14579053f, -0.02185008f, 0.33833966f, 0.13091357f, -0.18055503f, -0.14564136f, -0.04075915f, 
    -0.00478743f, 0.40940154f, 0.36536187f, 0.11682683f, 0.26100811f, 0.03646458f, 0.18430787f, 0.14988317f, 
    -0.00716292f, 0.17125058f, -0.09489226f, -0.01675246f, 0.03677613f, -0.29554659f, -0.14987302f, 0.39200687f, 
    -0.06602167f, -0.17961124f, -0.09203280f, 0.20475480f, -0.22612786f, 0.12918718f, -0.24266694f, 0.07482111f, 
    0.04284433f, -0.26616657f, -0.22020559f, -0.39826238f, -0.38919827f, -0.29959899f, -0.03537274f, -0.24430078f, 
    0.07612887f, -0.14202935f, 0.16909626f, -0.24122578f, -0.18695305f, -0.24417286f, 0.04515443f, -0.21038589f, 
    0.01845499f, -0.23464614f, 0.03298872f, -0.09265795f, 0.01031490f, 0.09431600f, 0.25834149f, 0.18972003f, 
    0.03130251f, 0.44337201f, 0.35701030f, -0.29602563f, 0.23518109f, -0.09077330f, 0.49604332f, 0.23428610f, 
    0.07715416f, 0.04715677f, 0.00439196f, 0.20688120f, 0.04764099f, 0.00150614f, 0.09714298f, 0.28840116f, 
    -0.38808817f, -0.00707231f, 0.09119742f, 0.06410634f, -0.25758314f, 0.04607857f, -0.13135993f, -0.15323317f, 
    -0.10869128f, 0.09649294f, -0.12476031f, -0.35062051f, -0.53666550f, -0.45684186f, -0.56800801f, -0.65045696f, 
    -0.22189936f, 0.27643213f, -0.05609775f, -0.19669423f, -0.09338749f, -0.06833880f, 0.17791685f, 0.36092958f, 
    -0.07194655f, -0.11799240f, -0.28121692f, -0.08993150f, -0.20592599f, 0.00373730f, -0.10851307f, 0.07495205f, 
    -0.24268554f, 0.26245639f, 0.05801762f, -0.25296941f, -0.21842128f, -0.41540885f, 0.58868438f, 0.75694901f, 
    -0.78968728f, -0.34233299f, -0.13448910f, 0.06103865f, -0.01401230f, -0.12721519f, 0.22755064f, -0.47739303f, 
    0.13009492f, -0.14796156f, -0.03140093f, 0.31823969f, 0.38872471f, 0.43245661f, -0.18449773f, -0.24304280f, 
    -0.31822935f, 0.19993976f, 0.01765109f, -0.08401653f, -0.34697899f, -0.41403207f, 0.61820453f, -0.09665009f, 
    0.20004253f, -0.36566004f, -0.80981356f, -0.13473713f, 0.09379653f, -0.22811110f, -0.08977516f, -0.13917023f, 
    -0.05128853f, 0.20118433f, 0.05562866f, 0.31525722f, 0.27478027f, -0.00007554f, -0.24100445f, 0.21481484f, 
    0.14622134f, -0.00796407f, 0.30456549f, -0.31440046f, -0.28173032f, -0.23414414f, -0.17327075f, 0.18620518f, 
    0.45718828f, 0.02077790f, 0.13634109f, -0.35749090f, -0.09898353f, -0.31701428f, -0.26422003f, 0.10360309f, 
    -0.16887116f, 0.23228306f, -0.15961216f, 0.01472241f, 0.07397177f, 0.02494895f, 0.13888866f, -0.19605187f, 
    -0.09959699f, -0.13435052f, -0.29782796f, 0.15002717f, 0.19281910f, 0.21663257f, 0.29637265f, 0.07472976f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12146152f, -0.03793687f, 0.16543189f, -0.01404950f, 0.18516625f, 0.24408811f, 0.20232102f, -0.04175359f, 
    0.10429362f, 0.24062726f, 0.11153740f, 0.28188008f, -0.01502160f, 0.10764749f, 0.05326566f, 0.17597559f, 
    -0.03537207f, 0.01766015f, 0.15459453f, 0.26695207f, -0.00521393f, 0.19264488f, -0.25422505f, 0.05492449f, 
    0.12237655f, -0.11542037f, -0.06296674f, 0.10415571f, -0.24849692f, 0.29515612f, 0.07961963f, 0.16240999f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01257433f, -0.02064171f, 0.04419317f, 0.01329749f, 0.03864945f, 0.02734078f, 0.02937371f, 0.03289087f, 
    -0.00235259f, 0.00110502f, 0.00067980f, -0.02132940f, 0.00999557f, 0.00788914f, -0.02799380f, -0.04311221f, 
    -0.03793930f, -0.00394498f, -0.00024105f, -0.01498431f, -0.00459588f, -0.01572237f, 0.03714058f, -0.02434235f, 
    -0.05154946f, -0.05124589f, -0.04791960f, -0.03104930f, -0.01674293f, -0.01700479f, -0.04523728f, 0.02350148f, 
    0.01293093f, -0.04995536f, 0.02066784f, -0.01497456f, 0.02634433f, 0.03656915f, -0.05184826f, 0.04282381f, 
    0.01989135f, 0.01783551f, -0.01661423f, 0.02097226f, -0.04658206f, 0.03676461f, -0.05282530f, 0.00475410f, 
    0.00182320f, -0.02548500f, -0.03522615f, 0.00134952f, 0.04480270f, -0.02914391f, -0.01584158f, -0.02983930f, 
    -0.05673049f, -0.03811895f, 0.02448954f, -0.04607825f, -0.01252531f, -0.01731064f, -0.01266485f, 0.04184070f, 
    -0.05605366f, 0.03796483f, 0.01947454f, 0.02407369f, 0.04374665f, -0.04714122f, -0.02200206f, -0.01299722f, 
    0.01291985f, -0.04407226f, -0.00928599f, -0.02108506f, -0.03931828f, -0.02831214f, -0.01330301f, 0.03252678f, 
    0.00379573f, -0.01105138f, 0.03342499f, 0.02804896f, -0.05087289f, 0.04039733f, 0.01669032f, -0.03467282f, 
    -0.04378164f, 0.00014689f, 0.02098881f, 0.02073482f, -0.01091733f, 0.03278190f, -0.04219944f, 0.04479870f, 
    -0.04340511f, 0.01504775f, -0.03840557f, -0.02790206f, 0.00051391f, -0.00197013f, 0.00754867f, -0.05054289f, 
    -0.04755602f, -0.02161521f, -0.00159240f, -0.03217958f, 0.01284368f, -0.02303502f, 0.02555573f, -0.00563277f, 
    -0.01973462f, -0.01470785f, -0.00343931f, -0.03748770f, -0.02037582f, -0.04441105f, 0.00105544f, 0.04118763f, 
    0.03766194f, 0.03448224f, 0.03516296f, 0.02153050f, 0.04130254f, -0.00879711f, -0.04923024f, 0.03483405f, 
    0.04247917f, -0.04007247f, 0.01541588f, -0.01200539f, 0.00171510f, -0.03994315f, -0.05582241f, -0.05011093f, 
    -0.01637667f, 0.02385015f, 0.02353971f, -0.04923513f, -0.02108525f, -0.02968607f, -0.03004935f, 0.04063854f, 
    -0.00818762f, -0.05410789f, 0.05568708f, -0.03369907f, 0.02972586f, -0.04291151f, 0.05205841f, 0.04041411f, 
    -0.00469726f, -0.01740337f, 0.02358511f, 0.00563487f, 0.03641943f, 0.02058285f, -0.00588647f, -0.00619956f, 
    -0.00569233f, 0.04009747f, -0.01257757f, -0.03060417f, 0.00191462f, -0.04268098f, 0.03572188f, 0.02521908f, 
    -0.04078852f, 0.02989403f, -0.02225094f, 0.02735615f, -0.00116825f, 0.05499780f, 0.00584298f, -0.01898545f, 
    -0.00007223f, -0.01425528f, -0.01714909f, 0.01191270f, -0.00272026f, -0.04795960f, -0.05059665f, 0.03727437f, 
    -0.03792802f, -0.03771887f, -0.03683591f, -0.00610876f, -0.03800215f, 0.03532659f, 0.02437260f, -0.00974831f, 
    0.04058672f, 0.01577752f, -0.05452060f, -0.03257539f, -0.03003806f, -0.00985927f, 0.01225085f, -0.00278239f, 
    -0.00044570f, -0.02457580f, -0.03567987f, -0.00066137f, -0.03674046f, -0.01959725f, 0.00640751f, -0.00169728f, 
    0.00859843f, -0.04220341f, 0.02019316f, -0.03431256f, -0.00239624f, 0.02858949f, -0.02484936f, -0.01413585f, 
    -0.01584359f, 0.01401822f, 0.00146243f, 0.01367893f, -0.03643875f, -0.01036218f, 0.00811774f, -0.01543877f, 
    0.02102385f, 0.02126329f, -0.01734718f, 0.04937649f, 0.02353884f, -0.05162544f, 0.03249230f, -0.04510001f, 
    -0.00574776f, 0.01344944f, -0.00417703f, -0.03929224f, -0.05536623f, -0.05523721f, 0.01251766f, -0.04220467f, 
    -0.03021060f, -0.00294913f, -0.01701627f, -0.01089175f, -0.05481756f, 0.04175901f, 0.03548155f, -0.00391916f, 
    -0.03370146f, 0.03063403f, 0.00676632f, -0.02438039f, -0.03272584f, 0.01322330f, -0.03328322f, 0.02238906f, 
    0.02536341f, -0.04194289f, 0.00669468f, 0.01015239f, 0.01771065f, -0.04189657f, -0.03590088f, 0.03281704f, 
    -0.03103837f, 0.00833227f, 0.01416832f, -0.02705976f, -0.04461338f, -0.03430583f, 0.01104010f, -0.00425865f, 
    -0.04087411f, 0.02557092f, -0.00811628f, 0.03040301f, 0.00226041f, -0.04840743f, 0.02058648f, 0.03865131f, 
    0.02021729f, -0.05587856f, -0.02844396f, -0.02904811f, 0.01088666f, 0.04202196f, -0.04190453f, 0.01641911f, 
    -0.02699778f, 0.02667581f, 0.01703940f, -0.05582251f, -0.05435566f, 0.03212665f, -0.02486714f, 0.03038002f, 
    0.03822035f, 0.04343903f, 0.02344627f, 0.01788916f, 0.02511316f, -0.01807803f, 0.01103231f, 0.04256486f, 
    0.00686798f, -0.05139693f, -0.04059206f, 0.01248366f, 0.03537211f, -0.00152027f, 0.00971542f, -0.03328110f, 
    -0.01219038f, -0.02409327f, -0.00808709f, -0.01002847f, 0.05422748f, 0.03242257f, -0.00179592f, -0.02010066f, 
    -0.00112013f, -0.05052397f, -0.00547395f, -0.00427825f, -0.00524001f, 0.03744116f, -0.02477845f, -0.00492638f, 
    0.02948446f, -0.04384463f, 0.03773605f, 0.01933865f, 0.05795035f, -0.01765551f, -0.03615551f, -0.04505863f, 
    -0.03067119f, 0.03275782f, 0.04162499f, 0.00755842f, 0.01453560f, 0.04340430f, -0.03577972f, 0.00978417f, 
    0.03434506f, 0.03381465f, 0.01869437f, 0.03220009f, -0.02844192f, 0.04178370f, -0.00545816f, 0.02139871f, 
    -0.04773606f, 0.03160084f, -0.02486405f, -0.05505653f, 0.03587215f, -0.05212759f, -0.05025573f, -0.03857219f, 
    -0.01224758f, 0.02448552f, -0.05155819f, -0.02537520f, -0.02646109f, -0.02398195f, 0.01616919f, -0.02332366f, 
    -0.01074823f, -0.05337458f, -0.00390609f, -0.03410291f, -0.00114676f, 0.00042367f, 0.02196247f, 0.01663705f, 
    0.02764972f, -0.01681850f, -0.00946281f, -0.01991284f, -0.00367745f, -0.01295223f, -0.02873690f, -0.04774193f, 
    0.00121678f, 0.01125347f, -0.02581719f, -0.04608002f, -0.00492159f, 0.04721211f, -0.04746426f, -0.00373147f, 
    0.03216815f, -0.04625364f, 0.04692298f, 0.02936641f, -0.05236941f, -0.00507869f, -0.03772206f, 0.00489851f, 
    0.04516145f, -0.01701697f, 0.00329918f, 0.04024667f, -0.01473821f, -0.00138109f, 0.03909604f, 0.03590936f, 
    0.02968179f, -0.03604972f, 0.00459188f, -0.01217240f, 0.03223922f, 0.00247285f, -0.00683950f, 0.01406838f, 
    -0.04540559f, 0.00565637f, -0.04099901f, 0.01124708f, -0.05212996f, -0.02872985f, -0.05513533f, -0.00334533f, 
    -0.01102612f, 0.03051656f, -0.00845412f, 0.03661893f, -0.00264917f, -0.03901992f, 0.01251126f, 0.01163392f, 
    -0.02046033f, -0.02190808f, -0.01838250f, 0.03752157f, 0.01224595f, -0.03049304f, -0.01918028f, 0.02004904f, 
    -0.00634248f, 0.03530516f, 0.03919967f, 0.03399234f, -0.01555728f, -0.02934663f, 0.00217749f, -0.05078975f, 
    -0.04926041f, -0.04840296f, -0.04181540f, -0.02766144f, 0.02398811f, -0.03469042f, -0.03398068f, 0.03759880f, 
    -0.03554070f, -0.03200084f, 0.04567688f, -0.01302178f, 0.01510437f, 0.01948472f, -0.00665596f, 0.03453139f, 
    0.00836774f, -0.04490427f, -0.04173742f, -0.05188690f, -0.01769955f, 0.00416542f, 0.03319019f, -0.01207741f, 
    -0.03731832f, 0.01900406f, 0.03155433f, -0.04510653f, -0.01078918f, 0.00999895f, -0.00569237f, 0.03735658f, 
    0.02397656f, 0.01976572f, 0.03716336f, 0.03666184f, -0.03059084f, -0.03514894f, -0.00047076f, -0.04846295f, 
    -0.04605877f, -0.03661401f, 0.00642127f, -0.04396030f, 0.02447554f, -0.03470217f, -0.02321552f, -0.02463999f, 
    -0.05232073f, -0.05169996f, 0.00597052f, 0.01548968f, 0.00794799f, 0.00842881f, 0.00032189f, -0.03787091f, 
    -0.04972664f, -0.00214787f, -0.03146142f, -0.06559409f, -0.00833010f, -0.00921710f, 0.04435717f, -0.02634474f, 
    -0.03178881f, -0.01228856f, -0.02016247f, 0.00855304f, 0.00095808f, -0.00693972f, -0.04436463f, -0.00030851f, 
    -0.01462912f, 0.04398309f, 0.00816531f, 0.02349928f, 0.03655216f, 0.01155266f, -0.05370590f, -0.02388701f, 
    -0.02879522f, 0.00519523f, 0.01329877f, 0.02244390f, 0.01852536f, -0.01620524f, 0.01317937f, 0.02093814f, 
    -0.01260146f, -0.02871977f, -0.03115205f, -0.05554702f, 0.04868992f, -0.00597373f, 0.01759695f, -0.01603273f, 
    0.02099835f, -0.04228699f, -0.01901779f, -0.01844242f, -0.06134251f, 0.00639332f, -0.02292888f, 0.03745717f, 
    0.01529703f, -0.00305186f, -0.02342764f, -0.03360540f, -0.03910558f, 0.03987525f, -0.00177960f, 0.02633565f, 
    -0.04689722f, -0.02328882f, 0.00020928f, -0.04796579f, 0.02945167f, -0.01911052f, 0.05410699f, -0.00615907f, 
    -0.03208002f, -0.00143023f, 0.03953512f, 0.03530025f, -0.02516344f, -0.02023883f, -0.03193788f, 0.04646896f, 
    -0.03191564f, 0.04300529f, 0.03531823f, -0.02304600f, 0.00255171f, -0.05026058f, -0.01481921f, -0.03886835f, 
    -0.03888556f, -0.00636492f, -0.00904885f, 0.02937647f, -0.01175143f, 0.02005413f, -0.04822847f, 0.02016520f, 
    0.03785943f, 0.01845500f, -0.04399483f, -0.02582914f, -0.00483955f, 0.02884880f, -0.04422488f, 0.02486029f, 
    -0.02069630f, 0.05682740f, 0.04387115f, 0.04582460f, 0.02967224f, 0.04361899f, -0.01796529f, 0.00030264f, 
    0.03227012f, 0.00271179f, 0.01687638f, 0.02875833f, -0.00454790f, 0.03272505f, -0.04690054f, 0.03852630f, 
    -0.00148411f, -0.01013800f, -0.02864778f, 0.01546946f, -0.03771896f, -0.00739580f, -0.03954805f, -0.02858600f, 
    -0.03007267f, 0.00505107f, -0.02155453f, 0.00892919f, -0.01128704f, -0.03267597f, -0.00192140f, 0.02149915f, 
    0.00658777f, 0.01792188f, 0.00719433f, 0.00250395f, -0.01875347f, 0.03742409f, 0.00832527f, 0.01140694f, 
    -0.01991410f, 0.04549354f, 0.00783854f, 0.02833930f, 0.02071087f, -0.02229187f, -0.00294156f, -0.03835402f, 
    0.01654152f, 0.00781519f, 0.00264449f, 0.01904710f, -0.03564572f, -0.00361525f, -0.04177265f, 0.00638803f, 
    -0.00065626f, 0.02586075f, 0.02770887f, -0.00937843f, 0.03297439f, 0.00571687f, -0.02982291f, 0.02276208f, 
    -0.04942615f, -0.03115519f, -0.02974842f, -0.00823465f, -0.04298298f, -0.04040886f, -0.05417077f, -0.03057456f, 
    -0.02926377f, 0.03719086f, -0.02729842f, -0.04726155f, -0.02430402f, -0.04097622f, -0.00391948f, 0.03460006f, 
    0.01084661f, -0.04216209f, 0.04766228f, 0.01298299f, 0.04397537f, -0.02512245f, 0.01212083f, -0.00735296f, 
    -0.04019581f, -0.04527862f, 0.04084609f, 0.04130930f, 0.03101389f, -0.01530834f, 0.03374500f, -0.04191251f, 
    0.00799325f, -0.02294929f, -0.01364638f, -0.04263411f, -0.01416278f, -0.01457898f, -0.04823567f, -0.05895551f, 
    0.02562247f, 0.02647032f, -0.04876266f, 0.02813217f, 0.05466472f, -0.04016786f, -0.00407640f, -0.00114708f, 
    -0.05748228f, -0.02695285f, -0.02287604f, -0.02881113f, -0.04354178f, -0.00093547f, -0.04161935f, -0.04027361f, 
    0.02810010f, -0.05705028f, -0.00141810f, 0.01053530f, -0.06102994f, 0.01283220f, 0.01453159f, 0.00137087f, 
    0.03702984f, -0.03112920f, 0.03048141f, 0.01634629f, -0.02883551f, -0.01836748f, 0.04141730f, 0.00399800f, 
    -0.01938071f, -0.01791485f, -0.03759866f, 0.03475804f, 0.03661712f, 0.01324834f, 0.00732787f, -0.05367580f, 
    -0.06163050f, -0.04655849f, -0.04329474f, -0.01092545f, 0.02499412f, -0.04565909f, 0.00757801f, -0.01477391f, 
    0.00040388f, -0.05293824f, -0.04242406f, 0.02170226f, 0.02133529f, 0.02619137f, 0.04795418f, 0.02205404f, 
    0.02245471f, -0.03721425f, -0.05176292f, 0.03432582f, -0.04650886f, -0.04266259f, 0.00784593f, 0.01424070f, 
    -0.11946484f, 0.14301588f, 0.09454936f, 0.32584158f, 0.02798754f, 0.15956129f, -0.18882874f, -0.05443699f, 
    -0.15415704f, 0.05614220f, -0.02852714f, 0.03991383f, 0.18198790f, -0.25398248f, -0.11822772f, -0.29502854f, 
    0.15774287f, 0.04466710f, 0.15908477f, 0.03986664f, 0.01939637f, 0.06298260f, 0.07790878f, 0.06860680f, 
    -0.07166450f, -0.09604666f, 0.02561673f, -0.02363466f, -0.02492012f, 0.22144443f, 0.16659448f, 0.03780567f, 
    0.02648774f, 0.01253534f, 0.22271444f, 0.00436695f, 0.08655804f, 0.07544816f, 0.10998426f, 0.31551781f, 
    -0.14575206f, -0.07218761f, -0.01194102f, 0.11468585f, -0.03961726f, 0.00161842f, 0.07300731f, 0.04951216f, 
    -0.00274820f, 0.43360388f, -0.19050415f, 0.01989121f, -0.11861368f, 0.11510232f, -0.08191580f, -0.17566170f, 
    -0.08296436f, 0.05796114f, 0.00481081f, -0.05640529f, 0.01051043f, 0.21401843f, -0.42400825f, -0.08554241f, 
    0.05192875f, -0.03069605f, -0.00867410f, 0.12090376f, -0.12838849f, -0.09424514f, 0.00807261f, -0.06994633f, 
    0.07157558f, -0.03212224f, 0.05250417f, -0.10674308f, 0.26207039f, -0.06368995f, -0.04777958f, -0.02821817f, 
    0.01780476f, 0.03336062f, -0.09487889f, -0.05315430f, 0.25166714f, -0.14879622f, 0.04028945f, 0.07907552f, 
    -0.12111966f, -0.04867643f, 0.15738110f, 0.14949721f, -0.14730544f, -0.03826812f, -0.12618935f, 0.12894237f, 
    0.11051241f, 0.13229385f, -0.30243933f, 0.05690610f, -0.05120498f, -0.12294344f, 0.03618947f, 0.03088820f, 
    -0.00605663f, 0.05122543f, -0.08982948f, 0.11965327f, 0.04087032f, 0.02456688f, 0.19064489f, 0.16107519f, 
    -0.02287274f, -0.14256306f, -0.00776475f, 0.03498146f, -0.03280582f, 0.08879568f, -0.07322640f, 0.03123803f, 
    -0.04418015f, 0.04045708f, -0.31193304f, 0.12098728f, -0.09274643f, 0.06607834f, 0.11472777f, 0.01173255f, 
    -0.04090844f, 0.09444463f, 0.13721965f, 0.14477843f, -0.50036353f, -0.44318905f, -0.11333634f, 0.34536749f, 
    0.09672518f, 0.00279006f, 0.07139206f, 0.11632697f, -0.18626828f, 0.05775933f, 0.21423811f, 0.03803809f, 
    0.04531168f, -0.30844238f, -0.39772552f, -0.17516620f, 0.12236293f, -0.00805410f, -0.04662468f, 0.04768088f, 
    0.04978016f, 0.10047732f, -0.08312064f, 0.12092914f, 0.14972971f, -0.13321543f, -0.16504648f, -0.07096085f, 
    0.03500249f, 0.01138581f, 0.13914199f, 0.06672668f, 0.13623698f, -0.01644335f, 0.00606105f, -0.11126564f, 
    0.22765137f, 0.11666925f, 0.14291035f, -0.07151221f, 0.28081697f, -0.13948674f, -0.02658288f, -0.14378858f, 
    0.00359562f, 0.03705570f, -0.08865430f, -0.04750171f, -0.07908662f, 0.30245960f, 0.12142594f, 0.03836441f, 
    0.06276504f, 0.04085352f, -0.06432760f, -0.05490173f, 0.01698700f, 0.03813083f, 0.13885322f, 0.02224975f, 
    0.09470553f, -0.39441693f, -0.21399888f, -0.21350583f, -0.03907131f, 0.06410491f, 0.01388851f, 0.09275018f, 
    -0.04031991f, -0.00531499f, 0.02274933f, 0.11729358f, 0.42334428f, 0.02160846f, 0.20392877f, 0.08819122f, 
    0.04947658f, 0.18123893f, 0.01647291f, 0.11413867f, 0.18868120f, -0.03749740f, -0.02993621f, -0.02537060f, 
    0.30155697f, 0.18484053f, 0.17202553f, 0.27889800f, 0.02960319f, 0.09890398f, -0.07965446f, 0.05486963f, 
    -0.25153551f, -0.00641515f, -0.01564236f, 0.09527212f, -0.01542042f, 0.02396868f, 0.00196787f, -0.27719834f, 
    0.09222364f, -0.02458186f, 0.03855707f, -0.08872075f, 0.16906296f, 0.13336287f, -0.03848550f, 0.06343924f, 
    0.27084932f, 0.33817381f, 0.18946399f, 0.04918930f, 0.03010187f, -0.13732918f, -0.14915729f, 0.05006238f, 
    0.01769138f, 0.08709805f, -0.05302675f, -0.01888420f, 0.76153380f, 0.09058335f, -0.21491560f, -0.47884610f, 
    0.09779254f, -0.08167510f, -0.02827878f, -0.12958007f, -0.06694497f, 0.06652965f, -0.03911895f, 0.06301270f, 
    0.09606716f, -0.09491210f, 0.10570587f, -0.06936891f, 0.16570556f, -0.01675764f, 0.08770601f, 0.11186328f, 
    -0.01706231f, -0.01421024f, -0.11834765f, 0.03213144f, -0.37625542f, -0.08977076f, -0.00283074f, 0.12061302f, 
    -0.04224145f, 0.11981484f, 0.02312029f, 0.12473097f, -0.09542543f, -0.04079772f, -0.08138496f, -0.16858749f, 
    0.28841829f, 0.27363470f, 0.23688665f, -0.05845552f, -0.17363168f, -0.23448659f, 0.20068376f, -0.00804170f, 
    -0.07902492f, -0.06065512f, 0.03185552f, 0.03377062f, 0.17762683f, 0.31785977f, -0.01905105f, 0.02301046f, 
    0.02034445f, -0.02266229f, -0.00303965f, -0.04756317f, -0.04919021f, 0.06681263f, 0.05130609f, 0.10729303f, 
    0.22541076f, -0.13181484f, -0.16754752f, -0.14779423f, 0.12377739f, -0.03712814f, -0.20506638f, 0.11795906f, 
    -0.01737594f, 0.03851668f, 0.01344443f, 0.03288491f, 0.22278602f, 0.19053927f, -0.04832536f, -0.09927247f, 
    0.02931566f, -0.04652495f, -0.02044444f, -0.08522489f, 0.06434425f, 0.06432529f, -0.13618737f, -0.01538348f, 
    0.05178000f, -0.27589998f, -0.31161341f, -0.10611854f, 0.02174763f, 0.09614896f, 0.15900104f, -0.06701536f, 
    0.09803907f, 0.05119894f, 0.13348468f, 0.11469407f, -0.22807428f, 0.30932885f, 0.11291458f, 0.12317722f, 
    -0.02314177f, 0.16918096f, 0.11446940f, 0.01723104f, -0.00219527f, 0.05062349f, 0.15763657f, 0.03939597f, 
    -0.18520121f, -0.20905884f, 0.07876842f, 0.21257393f, -0.02519456f, 0.06071613f, 0.12907825f, 0.02583162f, 
    0.06465038f, 0.05387317f, 0.00736338f, -0.09997614f, 0.02807423f, 0.16752893f, 0.20898417f, 0.10378762f, 
    0.02311895f, 0.02374631f, -0.15283905f, -0.04942784f, -0.04187060f, -0.02458561f, 0.06756373f, -0.06703953f, 
    -0.15696564f, -0.02111250f, -0.49243233f, 0.26220083f, 0.08988803f, 0.00567827f, -0.04559371f, 0.09271448f, 
    0.01742609f, -0.04889231f, 0.02559349f, -0.03484959f, -0.15295273f, 0.08538206f, 0.09959269f, -0.07741333f, 
    0.09718851f, -0.00534823f, 0.06456799f, 0.18078576f, 0.03968122f, -0.02652158f, -0.15960285f, 0.04513485f, 
    -0.36349061f, 0.10659760f, -0.34951177f, 0.11182950f, 0.06765461f, 0.01019022f, -0.05726282f, -0.03982166f, 
    0.03733006f, 0.06351022f, -0.01975091f, 0.01852572f, 0.24222359f, 0.30769858f, 0.01046950f, 0.01434957f, 
    0.17809291f, 0.20381606f, -0.05556244f, 0.18770762f, -0.08456057f, -0.06769930f, 0.22197454f, -0.01532945f, 
    0.24488905f, 0.15730192f, 0.23694624f, -0.14934474f, 0.03312296f, 0.05183806f, 0.00870155f, 0.07371031f, 
    0.02869787f, -0.06549320f, 0.02163452f, 0.14670281f, -0.00964949f, 0.09483884f, 0.02452245f, -0.10869391f, 
    0.04944312f, -0.01775395f, -0.11020823f, 0.25901479f, 0.10480593f, 0.20481004f, -0.12301357f, 0.00811301f, 
    -0.12476301f, -0.17381851f, -0.14448944f, 0.01561676f, 0.13722205f, 0.01848573f, 0.03981714f, 0.05118236f, 
    -0.00391817f, 0.05004928f, -0.22966962f, -0.09157244f, 0.00642819f, -0.09987765f, -0.01208460f, -0.13510065f, 
    -0.06303699f, 0.03581291f, 0.13636358f, 0.19267438f, 0.03990868f, 0.11388975f, 0.15575950f, 0.01906040f, 
    0.11269386f, 0.29876366f, 0.08670834f, -0.18063338f, 0.20133370f, -0.04164466f, 0.13933967f, 0.13289165f, 
    0.10627890f, 0.10121599f, 0.03627384f, 0.05786729f, 0.32143119f, 0.19683374f, 0.32744411f, -0.15501811f, 
    0.23847228f, 0.17180076f, 0.04685341f, -0.03863519f, 0.03390459f, -0.09896327f, 0.03079592f, -0.01007473f, 
    -0.08940459f, 0.21334907f, -0.08890962f, 0.08782357f, 0.04519704f, 0.03149519f, 0.04078937f, 0.10434026f, 
    0.03533108f, -0.02729492f, -0.00157850f, -0.02128758f, -0.04646842f, 0.03398015f, -0.20603581f, -0.17056495f, 
    -0.07328939f, 0.12560891f, -0.13751787f, 0.06031297f, 0.09347771f, 0.02494906f, 0.00326109f, 0.07695502f, 
    0.14899430f, -0.15293014f, -0.07626218f, -0.00119627f, -0.00853077f, 0.12262034f, -0.14292827f, 0.23938364f, 
    0.28810233f, 0.03031336f, -0.15083535f, -0.01461718f, 0.10278132f, 0.15505978f, -0.03519426f, -0.04064924f, 
    0.00494354f, 0.07807408f, 0.08079569f, -0.14563043f, 0.18949802f, 0.02560763f, 0.10372317f, -0.12668516f, 
    -0.03694271f, -0.10989153f, -0.00909473f, 0.02390756f, 0.01679185f, 0.09635958f, -0.07125979f, 0.05000607f, 
    -0.07253186f, -0.03977729f, -0.08332515f, -0.09151904f, 0.05976104f, -0.16449261f, -0.10440870f, 0.08976477f, 
    -0.02790283f, -0.16835743f, -0.00804115f, -0.06197951f, 0.27175561f, -0.13889575f, -0.11860690f, -0.06420458f, 
    -0.21458595f, -0.02571760f, -0.21998599f, -0.19344313f, 0.12223403f, -0.10462463f, 0.08916261f, 0.07944825f, 
    0.13122976f, -0.15608469f, -0.02175729f, -0.02032170f, 0.30975240f, 0.25258401f, -0.03342200f, -0.02662719f, 
    0.10266297f, 0.18530506f, 0.03459115f, 0.11852245f, 0.02864801f, -0.03061410f, -0.08290869f, 0.00047879f, 
    -0.10772464f, 0.23225906f, -0.21858263f, 0.27869257f, 0.03869684f, -0.00681211f, 0.07625766f, 0.02580186f, 
    0.11596865f, 0.12920210f, 0.07129873f, 0.07378252f, 0.32824582f, -0.26233077f, 0.28688389f, 0.01834293f, 
    -0.19511147f, -0.05518552f, -0.00661374f, -0.01746001f, 0.10987733f, 0.01567973f, 0.08946970f, -0.00540969f, 
    -0.69123703f, -0.43763325f, 0.01683317f, 0.17945442f, 0.30479935f, 0.11225717f, 0.01660629f, 0.03447029f, 
    -0.04269630f, -0.08798681f, -0.04410824f, 0.04646084f, 0.21426752f, -0.11643881f, 0.45062512f, 0.10787523f, 
    0.08570118f, -0.07304611f, 0.00084537f, -0.01828214f, 0.15538727f, 0.05051294f, -0.04765965f, -0.06981802f, 
    0.00739135f, 0.36572841f, 0.28490204f, 0.01063844f, 0.11582363f, 0.01091964f, 0.06436025f, 0.21233223f, 
    0.02787381f, -0.13817336f, -0.00279561f, 0.09949641f, 0.25599352f, -0.19282913f, -0.05662628f, -0.01932474f, 
    -0.13206114f, -0.00020686f, -0.10526101f, -0.00090845f, 0.13122460f, -0.18342265f, -0.04188647f, 0.09000258f, 
    0.49648535f, -0.24552089f, 0.30170923f, -0.18963347f, 0.01531718f, 0.07151847f, 0.16286704f, 0.20377226f, 
    0.04176081f, 0.01365445f, -0.06345372f, -0.10933995f, 0.00656840f, -0.06173675f, 0.06206966f, 0.01848399f, 
    0.11114489f, -0.03733158f, -0.03360801f, 0.00585689f, -0.01326331f, -0.03280828f, 0.02514274f, 0.05860934f, 
    -0.03737017f, -0.03483987f, 0.06402860f, 0.05999378f, 0.07108328f, 0.31367576f, 0.15050723f, -0.04243050f, 
    0.01881729f, -0.00529183f, -0.01076680f, 0.06677619f, 0.17375548f, 0.00063503f, 0.01226631f, 0.12859221f, 
    -0.02732665f, -0.07768308f, -0.12671302f, 0.03963135f, 0.05007452f, -0.15571551f, 0.15524614f, 0.04394383f, 
    0.06719317f, 0.07784066f, 0.06671666f, -0.11326405f, 0.01674818f, 0.12630188f, 0.12403119f, -0.15823221f, 
    0.08289296f, -0.19335394f, 0.05388990f, -0.07668899f, -0.26434222f, 0.09936459f, -0.15056312f, 0.13260670f, 
    0.10009407f, 0.00137949f, 0.07469217f, 0.04099155f, 0.00965466f, 0.08605380f, -0.03315393f, -0.05024514f, 
    0.02602637f, 0.11424150f, -0.19668490f, 0.12484576f, -0.10685489f, -0.11557903f, 0.07939913f, 0.09988496f, 
    0.01911558f, 0.27150396f, 0.03767473f, -0.21947865f, -0.13644743f, 0.02464602f, -0.11343195f, -0.00489431f, 
    0.02750138f, 0.16276065f, 0.04442658f, 0.05190443f, -0.04082241f, -0.05273239f, -0.09142249f, -0.04017080f, 
    -0.00858369f, -0.06747436f, 0.38817671f, -0.13422327f, 0.08743699f, 0.02713559f, -0.03519271f, -0.01416311f, 
    -0.16877535f, 0.05280185f, 0.04122038f, 0.08850087f, 0.17165330f, 0.02639593f, 0.04712041f, 0.01453965f, 
    0.07252356f, -0.06099178f, 0.03340842f, -0.05040978f, -0.05545536f, 0.15587607f, 0.07978990f, -0.03472492f, 
    0.35686430f, 0.02879100f, 0.44059703f, 0.08508526f, 0.10524052f, 0.08240975f, 0.08927746f, 0.11061473f, 
    0.01061935f, 0.02157523f, -0.05360705f, 0.01417167f, -0.13742237f, -0.16602400f, 0.13242050f, 0.09295638f, 
    -0.08644959f, -0.02247638f, 0.05724442f, -0.12411402f, 0.03554347f, -0.01601475f, -0.15873457f, -0.00356176f, 
    -0.18058066f, 0.10256112f, -0.14228353f, 0.17983937f, -0.09284387f, -0.05789715f, 0.01065754f, -0.02733185f, 
    -0.03490854f, -0.05577800f, -0.01765944f, 0.00041131f, -0.21722996f, -0.01469443f, -0.00875064f, 0.15589751f, 
    0.07841551f, 0.09074815f, 0.03641608f, -0.15243265f, 0.09285377f, -0.03673934f, 0.20315707f, 0.08271916f, 
    0.14792140f, 0.04957347f, -0.01354178f, -0.12348835f, 0.08490908f, 0.12896836f, -0.08069255f, 0.14293100f, 
    0.04998222f, -0.00707791f, 0.17681839f, 0.06974331f, 0.13294382f, 0.05499054f, -0.08982963f, 0.01342227f, 
    0.11342043f, 0.06176706f, -0.05728493f, 0.08157334f, -0.01738302f, -0.18854469f, -0.11114563f, -0.02995031f, 
    -0.04584856f, -0.11422483f, 0.02661542f, 0.16404341f, -0.07045972f, 0.16301738f, -0.03946982f, -0.04431612f, 
    0.00052738f, -0.12074900f, -0.06767185f, 0.03463297f, -0.17699571f, -0.08678009f, -0.19951808f, 0.24608533f, 
    -0.10348125f, 0.03672158f, 0.01978595f, 0.10975483f, 0.02097131f, 0.03480137f, -0.07457959f, 0.09809083f, 
    0.18939278f, -0.05790504f, 0.20028859f, 0.00552758f, 0.07998139f, -0.00274832f, 0.03171389f, 0.02239170f, 
    0.08451894f, 0.10381601f, 0.01399494f, 0.00313550f, 0.06517501f, -0.00341969f, 0.26921049f, 0.23804855f, 
    0.07529911f, -0.04173904f, 0.08704886f, 0.02187085f, -0.00753301f, -0.04500184f, 0.10183413f, 0.00879119f, 
    -0.27130631f, -0.01775930f, 0.16026391f, -0.00938391f, 0.19127657f, 0.05082854f, 0.15418252f, -0.10804785f, 
    0.01067248f, 0.06816414f, 0.10641515f, 0.05475477f, -0.05858091f, -0.11749214f, -0.04128489f, 0.01600722f, 
    -0.00946490f, 0.04184058f, -0.08362499f, 0.10735251f, -0.00182483f, 0.14732552f, 0.04182459f, 0.00524539f, 
    0.08516068f, 0.02701503f, 0.05127157f, -0.12464308f, 0.09769064f, 0.04842751f, 0.02768224f, 0.02979507f, 
    0.12365241f, 0.05208810f, 0.17885900f, 0.06867914f, -0.17894997f, 0.23274998f, 0.15071929f, -0.08089639f, 
    -0.09058844f, 0.02480063f, -0.08755676f, -0.07740300f, -0.22272846f, 0.06078374f, 0.15567486f, 0.00983596f, 
    0.24666174f, 0.06248168f, 0.19953004f, 0.24815284f, 0.06296901f, 0.24406180f, -0.01828676f, 0.03179124f, 
    -0.09913465f, -0.02139884f, -0.02964224f, 0.00702963f, -0.29144356f, -0.05224965f, 0.16813338f, 0.07217797f, 
    0.02254634f, -0.06960961f, 0.05067701f, 0.01588611f, 0.02197598f, 0.05466712f, -0.05326394f, 0.00804145f, 
    0.16560392f, 0.02041258f, 0.33512154f, -0.05615200f, 0.09175699f, 0.13093743f, -0.00579997f, 0.00708522f, 
    -0.03103223f, -0.05077797f, 0.01595334f, 0.02355906f, -0.32914996f, 0.24448586f, -0.21661392f, 0.08943214f, 
    0.00055658f, -0.04425161f, -0.09513433f, -0.04906114f, 0.07523750f, 0.01553836f, -0.00021239f, 0.10392915f, 
    0.23479661f, 0.22389339f, 0.10933716f, -0.08460396f, -0.01719527f, -0.03266894f, -0.00126149f, 0.03429400f, 
    -0.05353298f, 0.04977520f, -0.02252541f, -0.12414669f, -0.18201554f, 0.13176592f, -0.35515094f, -0.01427609f, 
    0.09700085f, 0.01099394f, 0.10293238f, 0.04658235f, 0.05300510f, -0.02531255f, 0.06619332f, 0.13056152f, 
    0.03146381f, -0.22903599f, -0.15190749f, -0.03986454f, -0.05143361f, -0.04864852f, 0.07490703f, -0.09839188f, 
    0.01156034f, 0.06852860f, -0.00112637f, -0.03906358f, -0.10611394f, 0.10519489f, 0.15968665f, 0.08206461f, 
    0.12026635f, -0.05405679f, -0.06069775f, 0.05504644f, -0.00828555f, 0.05441347f, 0.14519650f, -0.04601592f, 
    -0.39978787f, 0.35059491f, -0.22580665f, 0.18090501f, 0.00315528f, -0.10814667f, -0.05428911f, -0.06460764f, 
    -0.06411414f, -0.15176572f, -0.06033723f, -0.10967630f, -0.16197166f, 0.14994706f, -0.02512390f, -0.09872083f, 
    -0.03638993f, 0.00430882f, -0.10634145f, -0.03989324f, -0.11639566f, -0.07127286f, -0.11792610f, 0.00082330f, 
    0.07850228f, 0.06907918f, 0.00663569f, -0.05516206f, 0.02716366f, -0.09640490f, -0.06434780f, 0.07215067f, 
    -0.12346467f, -0.08549323f, -0.07409762f, -0.05910181f, -0.17029044f, -0.04919683f, -0.06999177f, -0.23126468f, 
    -0.05154123f, 0.00892969f, -0.00852943f, -0.06943861f, -0.01444966f, 0.14506872f, -0.05546512f, -0.12409030f, 
    -0.05430264f, -0.09953406f, -0.02214686f, 0.15523571f, 0.02435173f, -0.06741975f, 0.03467736f, 0.01307477f, 
    -0.18701321f, 0.13982943f, 0.05353351f, -0.06372090f, 0.22440951f, 0.06941684f, 0.33801207f, 0.04614173f, 
    0.07023959f, 0.03109364f, 0.08841302f, 0.11988990f, -0.03314485f, 0.00419627f, 0.08133188f, 0.08661927f, 
    -0.12044372f, -0.14151646f, 0.12013393f, -0.00677695f, -0.05526971f, -0.03144691f, -0.07796364f, 0.01138021f, 
    -0.07709281f, -0.12590919f, -0.03616140f, -0.05288492f, 0.12670706f, 0.03127726f, 0.12584622f, -0.13988715f, 
    0.16564350f, -0.04559009f, 0.10341442f, -0.06695720f, -0.07918622f, 0.14935923f, 0.07913233f, 0.13952219f, 
    0.40079018f, -0.12969723f, -0.03053924f, -0.19969799f, -0.03651064f, -0.01149096f, 0.05044047f, -0.03262034f, 
    0.12430774f, -0.00207707f, 0.00272057f, -0.05186457f, -0.04866225f, 0.11975494f, 0.09206326f, 0.13624616f, 
    -0.13615187f, -0.01567804f, -0.16785321f, -0.05768827f, 0.01102087f, -0.04250393f, -0.13234933f, -0.12658124f, 
    0.05277725f, -0.31153417f, 0.28262377f, -0.20579158f, 0.02089388f, -0.12415322f, -0.09278335f, -0.00907069f, 
    0.06017320f, -0.01416093f, -0.10507413f, -0.05592425f, 0.15752700f, 0.22974958f, -0.00254075f, -0.31575826f, 
    0.20146771f, -0.00539123f, -0.07981970f, 0.02975170f, 0.06067545f, 0.10191156f, 0.11295690f, 0.09649871f, 
    0.03860518f, -0.13316123f, 0.09688231f, 0.17632319f, 0.05764937f, -0.20767114f, 0.05191195f, 0.21692862f, 
    0.05290375f, -0.07749849f, 0.06704370f, 0.05816862f, 0.17044970f, -0.08266677f, 0.06458358f, -0.05457316f, 
    -0.14973214f, -0.00083211f, 0.10810571f, 0.03580878f, 0.10321695f, 0.07918905f, -0.06975101f, 0.14870514f, 
    0.02132145f, -0.02064367f, 0.06725527f, 0.08570576f, -0.11625635f, 0.10338537f, 0.03059690f, -0.01082045f, 
    -0.02038953f, -0.00530851f, -0.01019919f, 0.05196287f, -0.09459291f, 0.12021356f, 0.15291819f, -0.12310307f, 
    -0.00941664f, 0.09394256f, -0.07636844f, -0.09989336f, 0.11916943f, 0.00117852f, 0.03560028f, -0.09118625f, 
    0.17070806f, 0.01944252f, 0.23877515f, -0.00554935f, -0.01920119f, 0.03282687f, 0.05728579f, -0.01581106f, 
    0.05154421f, 0.08437028f, 0.07192643f, -0.00958220f, 0.30291432f, 0.10532154f, 0.00984752f, -0.21382987f, 
    -0.00134599f, 0.07282294f, 0.11388159f, 0.09355218f, 0.13698778f, -0.02295871f, 0.06688020f, 0.06134206f, 
    0.01145496f, -0.04268101f, 0.13497587f, -0.12999585f, 0.10692500f, -0.05512130f, -0.08786711f, 0.02167062f, 
    0.04247802f, 0.08731980f, -0.10081760f, -0.14477296f, 0.38548425f, 0.03264201f, -0.09217752f, -0.46264321f, 
    -0.02606653f, 0.13409795f, 0.07135332f, -0.07604585f, 0.21702629f, -0.04477713f, -0.26805699f, 0.00063470f, 
    0.18120925f, 0.05652912f, 0.24027485f, 0.04412165f, -0.19532216f, -0.02820987f, 0.21824448f, -0.00814229f, 
    0.02977064f, -0.04421417f, 0.08627843f, -0.23708495f, -0.25287685f, -0.13791822f, -0.02075758f, -0.12554093f, 
    -0.08296554f, 0.07306708f, -0.07581346f, -0.01053611f, -0.02872122f, 0.01093337f, -0.04607849f, -0.03068976f, 
    -0.16016616f, 0.07871877f, -0.07731842f, 0.02168410f, -0.07765730f, 0.07367833f, 0.01324435f, 0.08938242f, 
    -0.01105373f, -0.07794610f, 0.04401955f, 0.08884814f, 0.24583901f, -0.20670271f, 0.01306032f, 0.10802750f, 
    -0.03302519f, -0.01835335f, 0.01147718f, 0.08494611f, -0.02603056f, 0.04646323f, -0.09501044f, 0.13742785f, 
    -0.19516137f, 0.43661344f, 0.18409492f, 0.01232703f, -0.03849892f, -0.05944475f, 0.07371311f, -0.08185737f, 
    -0.01965308f, -0.00342355f, 0.03587747f, -0.18175912f, -0.19510157f, 0.09336017f, 0.08750751f, -0.07081441f, 
    0.01937881f, -0.10369211f, 0.01920608f, -0.06631313f, -0.00992070f, 0.05898114f, 0.06936079f, 0.09714276f, 
    -0.21914291f, -0.39083752f, 0.10520553f, -0.21360083f, 0.03399922f, -0.07744501f, 0.15194134f, -0.11585827f, 
    0.17979668f, 0.02429619f, -0.11544187f, 0.02387382f, 0.16509654f, -0.18946807f, -0.05724755f, 0.31946540f, 
    -0.03511963f, 0.00339176f, 0.05647223f, -0.01933606f, 0.02179779f, -0.13455151f, -0.15032193f, 0.00246367f, 
    -0.12249056f, -0.02722958f, 0.11404274f, 0.10807271f, 0.06477678f, 0.04777769f, -0.08036333f, 0.01560008f, 
    -0.08649070f, -0.02845318f, 0.06646585f, 0.04145354f, -0.57768041f, -0.10565579f, 0.17266980f, 0.32782620f, 
    -0.24572875f, -0.01768453f, 0.04049236f, 0.14734164f, 0.04147497f, -0.09998395f, -0.03675786f, -0.02516133f, 
    0.04107604f, 0.23602389f, -0.03224497f, 0.11413909f, -0.07100964f, -0.16388503f, -0.13603492f, -0.04870320f, 
    0.04385186f, 0.00200687f, 0.19743434f, -0.00558978f, 0.71043760f, -0.26892886f, 0.17252769f, -0.11976609f, 
    0.07455986f, -0.12089267f, 0.10942379f, -0.13078016f, 0.20675369f, -0.04827812f, 0.12059154f, 0.12307819f, 
    -0.01600181f, -0.00834802f, -0.25769156f, -0.19730979f, 0.00016869f, -0.00987044f, -0.04776681f, 0.10429924f, 
    0.05219920f, 0.01660648f, 0.03699444f, 0.04766469f, 0.12961361f, -0.08035803f, 0.05769975f, 0.19412099f, 
    0.05486645f, -0.00627562f, 0.08715321f, -0.00405464f, 0.03147143f, 0.06046969f, -0.01344178f, -0.01169114f, 
    -0.07719329f, 0.13071622f, 0.13334291f, 0.12350710f, 0.13154076f, 0.19620872f, 0.21165863f, -0.18879002f, 
    0.07973985f, 0.02676002f, 0.04225376f, -0.04296472f, -0.03911128f, -0.11549064f, 0.10529909f, 0.23953392f, 
    -0.01949019f, -0.07237154f, 0.02737887f, 0.00557265f, -0.17056717f, -0.02716123f, 0.23373179f, 0.09949526f, 
    0.07101522f, 0.26672265f, 0.13828073f, 0.05601577f, -0.09757224f, 0.00267279f, -0.01399908f, -0.04644616f, 
    0.04016262f, 0.04503649f, -0.10624485f, -0.05696930f, -0.08862592f, -0.18853113f, 0.00414213f, -0.04275073f, 
    0.10586263f, -0.03551393f, -0.09011459f, 0.08443813f, -0.04148313f, -0.01306610f, -0.10644004f, -0.12756951f, 
    0.16959439f, -0.04863523f, 0.01079636f, -0.27638909f, 0.09996399f, 0.07171390f, -0.06433456f, -0.00562521f, 
    0.09612827f, -0.03939504f, -0.04221436f, 0.15774272f, -0.10348730f, -0.08122264f, -0.04417695f, 0.00329607f, 
    0.05670456f, 0.00582729f, 0.00418112f, 0.01656594f, 0.00386290f, 0.04744224f, -0.02736602f, 0.07568600f, 
    -0.42163137f, -0.09317024f, -0.19703290f, -0.06610125f, 0.02768990f, 0.10513636f, 0.00816302f, 0.07879951f, 
    0.05164988f, -0.17111565f, -0.11619908f, -0.10467046f, 0.02539542f, -0.00686397f, -0.05119711f, -0.15915626f, 
    -0.00606342f, -0.03511273f, -0.05946516f, -0.01312432f, 0.20994365f, -0.05365308f, 0.04323816f, 0.14884353f, 
    -0.33486336f, 0.12429346f, -0.09291331f, -0.25950482f, -0.05146502f, -0.15378118f, 0.14349155f, -0.12068018f, 
    0.06511673f, -0.06098652f, -0.00392434f, 0.17875192f, 0.20735063f, 0.10489348f, -0.13566722f, 0.08510593f, 
    -0.10221387f, -0.00910390f, 0.08767908f, 0.26440161f, -0.09955149f, 0.12485486f, 0.12771474f, 0.04537166f, 
    -0.05164115f, 0.06510786f, 0.02283551f, 0.17929590f, -0.14931335f, 0.06876935f, 0.04234245f, -0.23055013f, 
    -0.12040878f, 0.08738416f, -0.02335772f, -0.04126761f, 0.09773523f, 0.19325614f, -0.15708955f, 0.14205679f, 
    -0.11460667f, -0.09569150f, -0.10873114f, -0.21312465f, 0.04253540f, -0.03948125f, 0.04985344f, -0.13715345f, 
    -0.18094146f, -0.03461035f, 0.18833157f, -0.33814010f, 0.15324783f, -0.02603606f, -0.13208754f, -0.17067933f, 
    -0.11080775f, -0.18467361f, -0.35309428f, -0.52254695f, 0.02837241f, -0.13012421f, 0.03456746f, 0.00864750f, 
    -0.06155694f, -0.03093413f, -0.07512814f, 0.14042592f, 0.04900939f, 0.16809434f, 0.09418329f, 0.13553153f, 
    0.13433142f, 0.02736796f, -0.13267241f, -0.13240393f, -0.03844758f, -0.11479855f, -0.10127416f, 0.20830791f, 
    0.05625193f, 0.05019800f, 0.05013743f, -0.01691618f, 0.21261980f, 0.01847943f, -0.01192213f, -0.11053082f, 
    -0.09779900f, -0.06412147f, 0.12352524f, 0.11779415f, -0.04805531f, 0.03995173f, -0.05200858f, -0.04040302f, 
    0.05846617f, 0.04518107f, -0.10398150f, 0.09408665f, 0.01841865f, 0.05089786f, -0.04646922f, 0.08977047f, 
    0.01845279f, 0.02520310f, 0.17315666f, 0.15469235f, 0.01273961f, -0.22905880f, 0.26559335f, -0.09023234f, 
    0.06990839f, -0.04714284f, -0.10149057f, 0.04249739f, -0.09614206f, 0.00884491f, 0.00954043f, -0.09254800f, 
    0.20682050f, 0.34559014f, -0.12443862f, 0.08539008f, -0.01995265f, -0.03286206f, -0.00202199f, -0.09726537f, 
    0.03796712f, -0.06992714f, 0.03884807f, -0.07922445f, 0.29785889f, 0.03955168f, -0.01812029f, 0.06386903f, 
    0.05204377f, -0.03427655f, 0.11522795f, -0.18185459f, -0.09794926f, 0.00491566f, -0.16921519f, -0.03037885f, 
    -0.08453369f, 0.03328580f, -0.06638206f, 0.11230437f, 0.15151578f, -0.06640657f, 0.03135820f, -0.09716527f, 
    -0.11593981f, -0.20018987f, -0.30144954f, -0.37634391f, -0.23917997f, -0.07702992f, -0.04426877f, 0.06446453f, 
    0.09292322f, 0.10191526f, 0.12940802f, -0.14519830f, -0.00488031f, 0.06444818f, 0.02981258f, 0.16609211f, 
    0.28565526f, -0.19588865f, -0.21135652f, -0.06844031f, -0.10225189f, 0.05507406f, -0.10509174f, 0.03944464f, 
    0.07938302f, 0.10842419f, 0.01774807f, 0.11330874f, 0.46348688f, 0.32387179f, 0.07305834f, -0.06532349f, 
    -0.08281610f, 0.01618098f, 0.09079152f, 0.25916779f, 0.05251095f, -0.04697117f, 0.01612883f, 0.08265473f, 
    -0.20388591f, -0.17746934f, 0.17974873f, 0.01276642f, -0.02865709f, 0.00184751f, -0.00133491f, 0.18166110f, 
    0.02133827f, -0.23858935f, -0.10023458f, -0.04090353f, -0.08862563f, -0.01906854f, 0.28267363f, 0.21667862f, 
    -0.05251180f, 0.04091297f, 0.01417805f, -0.20095180f, 0.00849098f, 0.11145339f, 0.05631942f, 0.02811507f, 
    -0.13937280f, 0.09469060f, -0.31725749f, 0.21207708f, 0.11904208f, 0.17915536f, 0.13750564f, 0.11376057f, 
    0.11872004f, -0.03232374f, 0.07348642f, -0.13522920f, 0.19595550f, 0.21634644f, 0.31582099f, 0.00348429f, 
    0.13733132f, 0.02784637f, -0.07195433f, -0.14166090f, 0.10942723f, -0.02414593f, 0.07499690f, -0.00828887f, 
    0.17690389f, 0.18131915f, 0.01269326f, 0.04176658f, 0.11975345f, 0.19346167f, 0.14061233f, 0.11713190f, 
    0.02154544f, 0.04217265f, 0.06157399f, 0.01356220f, -0.10661464f, -0.11712866f, 0.08991659f, -0.03083814f, 
    0.04560324f, -0.03881741f, -0.13101931f, -0.06287229f, -0.08383930f, -0.02366014f, -0.04280965f, 0.00183265f, 
    0.47441259f, -0.43567771f, 0.10873742f, -0.09819219f, 0.02056782f, 0.06097040f, 0.01345891f, 0.02892826f, 
    -0.02960142f, -0.02630561f, 0.01257700f, -0.00709689f, -0.06642909f, -0.13712415f, -0.12669505f, 0.11068210f, 
    0.12358677f, 0.08965502f, 0.10937526f, -0.04635655f, -0.10760970f, -0.01443391f, 0.14540702f, 0.14069943f, 
    0.10599369f, 0.13999395f, -0.00042165f, -0.16865964f, 0.11666523f, -0.02350323f, -0.06880977f, 0.11349358f, 
    -0.09289072f, -0.14819950f, -0.03260909f, -0.30185461f, -0.15642606f, 0.03328846f, 0.14344178f, 0.27807686f, 
    0.03760461f, 0.04568990f, -0.20293880f, -0.21367744f, 0.05406160f, 0.07060735f, 0.04581896f, 0.22549163f, 
    0.30928028f, 0.01526691f, -0.09098733f, -0.08783722f, 0.04277874f, -0.05128095f, 0.03115884f, 0.04628089f, 
    0.26106668f, 0.13696526f, 0.09271991f, 0.10036536f, -0.25993964f, 0.22538899f, -0.32849556f, -0.13944186f, 
    0.03200387f, -0.05096448f, 0.01143261f, -0.09495918f, 0.12090251f, 0.02627229f, 0.04041459f, 0.13349506f, 
    -0.14504465f, 0.07390187f, 0.15216631f, -0.11523681f, 0.02032010f, 0.01171621f, 0.14219035f, -0.06826865f, 
    0.18127698f, 0.17830200f, 0.01423953f, 0.12907852f, 0.01750141f, 0.07505175f, 0.00855058f, 0.14770566f, 
    0.05627635f, 0.03926159f, -0.14828877f, 0.02335080f, -0.15165976f, -0.28002673f, -0.12923370f, -0.18840349f, 
    0.05534922f, -0.07283664f, -0.09148807f, -0.15182841f, -0.08632719f, 0.11627898f, -0.01336522f, -0.08006594f, 
    0.07005427f, -0.09834322f, -0.16572805f, -0.16675059f, 0.25181723f, 0.06123353f, -0.03774903f, 0.00562751f, 
    0.02490297f, 0.26087680f, 0.13096611f, -0.03183467f, 0.16745490f, 0.05315464f, -0.00579878f, 0.10659447f, 
    0.14338952f, -0.28306118f, 0.16623211f, -0.09729640f, -0.11373807f, -0.05485988f, 0.01675409f, 0.08426377f, 
    0.19025031f, -0.06886294f, 0.16819854f, -0.02291941f, 0.09452171f, 0.04066452f, 0.01366358f, -0.22663079f, 
    -0.05319105f, -0.17860509f, 0.03032696f, 0.06256534f, -0.04584696f, 0.15729731f, -0.03191648f, 0.11489214f, 
    -0.09968541f, 0.09456391f, -0.14544147f, 0.14539933f, 0.08052219f, -0.01740930f, 0.06419393f, 0.01411154f, 
    -0.18224809f, 0.01607349f, 0.10433242f, -0.01435760f, 0.46551898f, -0.00313835f, -0.03570837f, 0.00170644f, 
    -0.00409445f, 0.03531790f, 0.15894438f, -0.15956053f, -0.00881054f, -0.06831710f, 0.03601381f, -0.01684637f, 
    -0.25774002f, -0.01935512f, 0.04753841f, 0.06223189f, -0.11013513f, -0.01206205f, 0.02796822f, -0.29215637f, 
    -0.12795988f, -0.18392003f, -0.07451969f, -0.19947027f, 0.08762202f, 0.01087111f, 0.33434933f, 0.16564301f, 
    0.07825226f, 0.15682600f, 0.12839854f, -0.10427807f, 0.07807881f, 0.01192120f, -0.05987551f, 0.28062338f, 
    0.15268247f, -0.10785991f, -0.11854289f, 0.03860629f, -0.07773745f, -0.16143316f, 0.11433373f, -0.03590516f, 
    -0.13009699f, -0.02691850f, 0.01477878f, -0.00187448f, 0.10529334f, 0.11880755f, -0.15096028f, -0.12911150f, 
    -0.03055786f, -0.12136777f, 0.11710936f, 0.10199349f, -0.07946231f, -0.06829754f, -0.02900930f, -0.05016260f, 
    0.05709535f, -0.09059386f, -0.02868505f, 0.00379228f, 0.02847975f, 0.09721980f, -0.08221942f, 0.01620346f, 
    -0.03637630f, 0.11418220f, 0.20496716f, 0.16351719f, 0.15435541f, -0.16733031f, -0.03189006f, 0.11211055f, 
    0.05352852f, 0.02604135f, 0.17175321f, -0.03783845f, -0.04925428f, 0.04406863f, 0.00309059f, -0.05497234f, 
    0.39479750f, 0.19295877f, -0.00935690f, -0.00528794f, -0.04952832f, 0.00416125f, 0.23496884f, -0.11084392f, 
    -0.20316544f, -0.01113856f, 0.17272182f, -0.02498573f, 0.31598353f, -0.01561104f, -0.04069889f, -0.00392642f, 
    0.15311877f, 0.09729034f, -0.00780318f, -0.08059859f, -0.15686888f, -0.08204754f, -0.11498708f, -0.04166592f, 
    -0.35833451f, 0.15620187f, -0.00487486f, -0.03608379f, 0.12867463f, -0.10553873f, 0.06160093f, 0.04163792f, 
    0.00577077f, -0.23805469f, -0.10296114f, -0.17938785f, -0.21696956f, -0.36297953f, 0.02216021f, -0.02177533f, 
    0.07674988f, 0.07741453f, -0.03749042f, -0.00585547f, -0.24657570f, -0.06399155f, 0.13147163f, 0.13485825f, 
    0.26739368f, 0.15400329f, 0.09479640f, 0.03664029f, -0.03793184f, 0.21753813f, -0.08618103f, 0.11744317f, 
    -0.10699227f, 0.07655440f, 0.05906292f, 0.02378537f, 0.12011091f, 0.02240032f, 0.01912759f, -0.18556745f, 
    -0.13516703f, -0.00808004f, 0.09399825f, 0.16051163f, 0.09017231f, 0.11063582f, 0.09135026f, 0.02565741f, 
    0.04585748f, -0.26010600f, 0.16428328f, -0.20559163f, 0.01126066f, 0.06533935f, -0.08663001f, 0.08829894f, 
    -0.14748248f, -0.20805007f, -0.12428482f, -0.11109843f, -0.19795820f, 0.04284009f, -0.25718990f, 0.12375350f, 
    -0.02049337f, 0.04816295f, 0.15834367f, -0.11714254f, -0.04875970f, 0.18026294f, -0.06821910f, -0.01768679f, 
    -0.01631154f, 0.10473652f, 0.19199991f, 0.08673858f, -0.18248339f, 0.19024123f, -0.12009080f, -0.08455592f, 
    -0.02634305f, -0.03171877f, 0.06321337f, 0.05681079f, 0.24300823f, 0.11857340f, -0.04526821f, -0.03719537f, 
    -0.00124438f, 0.07121792f, 0.02309209f, -0.07214437f, 0.01034073f, -0.00485814f, -0.06634771f, -0.00348775f, 
    0.16290851f, 0.16016209f, -0.18726519f, -0.08425523f, -0.03751179f, 0.09658251f, 0.07236525f, -0.03738822f, 
    -0.10147717f, -0.08137047f, -0.02081733f, -0.03221174f, 0.08831245f, -0.02711014f, -0.24626151f, 0.18819518f, 
    0.01743576f, -0.07292534f, 0.27445540f, 0.00606410f, -0.08123515f, 0.20927306f, 0.12239408f, -0.11049191f, 
    0.12705791f, 0.07316912f, -0.19023396f, -0.13891113f, 0.15137622f, -0.11765700f, -0.12405989f, -0.13284446f, 
    0.03175989f, 0.02337013f, 0.12848866f, 0.19558796f, -0.11017004f, -0.21105516f, -0.17591821f, 0.16870785f, 
    0.02576891f, 0.00475436f, 0.25597599f, -0.14408146f, -0.24376744f, -0.13076049f, -0.00960120f, 0.06054057f, 
    0.02793035f, 0.15202835f, 0.05001559f, -0.04827077f, 0.05090904f, -0.04638628f, 0.05477644f, 0.06851908f, 
    -0.22043978f, -0.12185023f, -0.18138687f, -0.36304113f, -0.26609290f, -0.07825287f, -0.03336613f, 0.04869736f, 
    -0.08072878f, -0.09415047f, -0.02132614f, -0.11206195f, -0.07237267f, 0.15180001f, 0.03534106f, 0.11815096f, 
    0.28839642f, 0.11383747f, -0.10443573f, 0.12578730f, 0.03367617f, 0.04593514f, 0.10031014f, 0.16020511f, 
    0.09110599f, 0.10188676f, -0.01251141f, 0.28492916f, 0.08692193f, -0.06024021f, -0.00521656f, -0.03550098f, 
    -0.09933116f, 0.05602283f, -0.08102775f, -0.02970516f, 0.14598419f, 0.12142725f, -0.04532485f, 0.09982701f, 
    -0.08117842f, -0.31509793f, 0.20649438f, -0.20672034f, 0.01155488f, 0.05215443f, 0.07042924f, -0.17724267f, 
    0.27661562f, 0.14178906f, 0.13360192f, 0.26547128f, -0.14049974f, -0.00114788f, 0.14956015f, -0.02416380f, 
    0.10357616f, 0.06807201f, 0.03819831f, 0.01794941f, -0.20332111f, -0.18945351f, -0.01791362f, -0.07812688f, 
    0.27485499f, 0.12750871f, -0.08467975f, -0.09170292f, 0.00213836f, -0.04156496f, 0.11722109f, -0.16100609f, 
    0.00078008f, 0.04168523f, -0.05634975f, -0.09839303f, -0.08203996f, -0.07340993f, 0.01123629f, 0.10839005f, 
    0.05200282f, 0.08523066f, -0.13552149f, -0.02032523f, 0.08123493f, -0.15561435f, 0.09046868f, 0.08022768f, 
    0.04193806f, -0.13836424f, 0.04440222f, -0.37589639f, 0.15569492f, 0.17541473f, 0.17868912f, 0.16498525f, 
    0.09393822f, 0.08072153f, 0.13126238f, -0.10460836f, 0.07828858f, 0.30348399f, -0.04796128f, -0.23504746f, 
    0.01717002f, -0.05749400f, -0.04845592f, -0.01419026f, -0.04198245f, -0.03687812f, 0.05420266f, 0.04718684f, 
    0.03720206f, 0.05400219f, 0.12806240f, 0.35056657f, 0.04963763f, 0.04818750f, -0.06086647f, 0.13429144f, 
    -0.01395510f, 0.19442733f, 0.00476983f, 0.04033457f, -0.00007167f, 0.10937115f, 0.00489579f, 0.05093909f, 
    -0.06432675f, -0.06398241f, -0.03678552f, 0.08775240f, 0.18047900f, 0.08701970f, 0.08744382f, 0.10888032f, 
    0.09457232f, 0.03320976f, 0.03646367f, 0.03246414f, 0.08602711f, -0.00594097f, 0.16586617f, -0.11663929f, 
    -0.08107811f, -0.11358031f, -0.11872943f, -0.11978213f, 0.05707889f, 0.10913511f, 0.14940517f, -0.05298471f, 
    0.10807756f, 0.00706180f, 0.00580719f, 0.07034322f, 0.05107115f, -0.08775458f, 0.11858115f, 0.04791135f, 
    0.15209429f, 0.02006676f, 0.07278319f, -0.09453958f, -0.03478384f, -0.01059819f, 0.20560008f, 0.17610064f, 
    -0.00917022f, -0.01586080f, -0.03689482f, -0.04439750f, 0.21846120f, 0.00360066f, 0.16837549f, -0.09561978f, 
    0.09573443f, -0.03995983f, -0.01225436f, 0.03988230f, 0.01795563f, 0.01963033f, -0.00171586f, -0.07990442f, 
    -0.22101626f, -0.00231996f, -0.01665111f, 0.02184664f, 0.09030443f, 0.06436161f, 0.02459817f, 0.05529696f, 
    0.12386855f, 0.08799664f, 0.14847130f, 0.05083656f, 0.11658867f, 0.04959056f, 0.06323583f, -0.29576820f, 
    -0.12660828f, 0.01708253f, 0.05054161f, 0.21377295f, 0.04721577f, 0.12911175f, 0.01368916f, 0.04349358f, 
    0.04968124f, -0.18727387f, 0.15317841f, 0.21709076f, -0.13364014f, -0.07879549f, -0.15288103f, -0.04419360f, 
    0.12356998f, 0.02255733f, -0.05986170f, -0.04476530f, -0.25523207f, 0.10730302f, 0.02501855f, -0.18265237f, 
    -0.16309923f, -0.09658663f, -0.05171153f, 0.08018490f, 0.00903550f, -0.03185879f, 0.06646133f, -0.06582503f, 
    0.10327715f, 0.01266507f, 0.06150439f, -0.10507854f, 0.02910263f, -0.07105400f, 0.09045406f, 0.04505296f, 
    -0.10400079f, -0.16960359f, -0.22693591f, -0.05322112f, 0.45383370f, -0.12076411f, 0.06455828f, 0.09182178f, 
    -0.04012261f, -0.07246232f, 0.01332884f, 0.09389414f, 0.23666026f, 0.12978865f, -0.04144971f, 0.12575190f, 
    -0.52680075f, 0.38995606f, 0.05121051f, -0.31683809f, -0.10312174f, -0.13196865f, 0.10109422f, 0.07157548f, 
    0.03674521f, -0.10600221f, -0.02774117f, -0.08560957f, -0.16996571f, -0.03797123f, 0.05099358f, -0.09074249f, 
    0.11706702f, -0.07639509f, 0.02345398f, -0.20102201f, 0.01026104f, -0.09126942f, 0.09018412f, -0.09643599f, 
    -0.31362039f, -0.18716669f, -0.13164084f, 0.16714911f, 0.06723333f, 0.03874484f, 0.09448976f, -0.14366670f, 
    0.27710950f, 0.15292339f, 0.16650099f, 0.23683077f, 0.33970749f, -0.31869614f, 0.18255813f, 0.20506077f, 
    0.07557866f, 0.00074391f, -0.02937384f, 0.04817807f, 0.14564055f, 0.09931222f, 0.01089457f, 0.06057288f, 
    0.24864507f, 0.15186588f, 0.12634864f, 0.08943154f, 0.03897675f, 0.00048011f, 0.01934336f, -0.05929480f, 
    -0.08653742f, -0.02410882f, -0.06959932f, -0.01272288f, 0.13286009f, -0.25447771f, 0.16166711f, 0.33130908f, 
    0.10567052f, 0.13819794f, 0.15278444f, 0.04070766f, 0.11849595f, -0.01315771f, -0.08898458f, 0.15520740f, 
    -0.14866275f, -0.00012639f, 0.08166920f, 0.05981869f, 0.14256509f, -0.10177805f, 0.05299698f, -0.03857084f, 
    0.00937347f, -0.02858510f, -0.01784489f, 0.05515051f, 0.37912345f, -0.25123984f, 0.29782546f, 0.03499394f, 
    -0.11516923f, -0.01450324f, 0.24413390f, -0.08369673f, 0.12440404f, 0.14584297f, 0.07109550f, 0.06435169f, 
    0.30895075f, 0.02129558f, 0.14643599f, -0.39694265f, -0.08863236f, -0.15302318f, 0.11627614f, 0.14261109f, 
    -0.04674193f, 0.03172415f, 0.02500981f, 0.01903370f, 0.29918790f, 0.14131202f, -0.00085673f, 0.13934399f, 
    -0.17362969f, -0.03927629f, -0.03404864f, -0.06228575f, 0.07758138f, 0.09222966f, 0.20005393f, -0.01923137f, 
    -0.10267305f, -0.17218262f, 0.03723824f, -0.09956332f, 0.16168040f, -0.05305034f, 0.15636319f, -0.02641581f, 
    -0.05445944f, -0.03375491f, -0.07659863f, -0.14723279f, 0.01762896f, 0.07078856f, 0.00730364f, 0.14851703f, 
    -0.01544595f, 0.04892334f, 0.01224878f, 0.03277748f, 0.11776929f, 0.09766129f, 0.24360348f, 0.15720639f, 
    -0.16276318f, 0.20834200f, 0.32905826f, -0.06883161f, -0.14213154f, 0.02249425f, 0.01938444f, -0.02113759f, 
    0.10411875f, -0.07330195f, -0.04721219f, 0.08488756f, -0.20426708f, 0.28332433f, -0.09580742f, -0.04596610f, 
    0.19628537f, 0.32322177f, 0.18265003f, 0.19099814f, 0.26555154f, 0.12907813f, 0.17532802f, 0.08197919f, 
    0.16781324f, 0.04979069f, -0.09288635f, -0.13040170f, 0.09680843f, 0.16912238f, 0.10975619f, -0.00582520f, 
    0.10160806f, 0.10540082f, -0.01780393f, 0.10260986f, 0.12706466f, 0.11768598f, -0.00072197f, -0.08606837f, 
    -0.05987671f, -0.04417271f, 0.12512110f, 0.11687414f, 0.01907536f, -0.13912286f, -0.13885257f, -0.11517388f, 
    0.00261824f, 0.00492812f, 0.00868660f, -0.24428889f, 0.10428134f, -0.04535559f, -0.02195290f, -0.00692467f, 
    -0.11090589f, -0.05971474f, -0.03864076f, -0.03873216f, -0.24873237f, -0.07254282f, 0.08469546f, 0.03827614f, 
    -0.03699869f, -0.00752411f, -0.05136140f, 0.01876363f, 0.08951543f, -0.05380340f, 0.22523232f, 0.21824628f, 
    0.14387582f, 0.25122482f, 0.06104008f, -0.12170003f, 0.18522404f, -0.06243130f, 0.11140816f, 0.09024452f, 
    -0.01605824f, 0.06044911f, -0.11164237f, 0.00648525f, -0.11928985f, -0.00778704f, -0.10612731f, 0.07516052f, 
    -0.02519900f, -0.03769558f, 0.05562350f, -0.07981856f, 0.00377241f, -0.03747523f, 0.01761336f, -0.11544532f, 
    -0.05309800f, -0.10494947f, 0.11180642f, 0.33717954f, 0.12942103f, -0.00476368f, 0.01406561f, -0.08752339f, 
    -0.00042680f, 0.20737584f, 0.00100018f, -0.02395719f, -0.24033886f, 0.13708816f, 0.28904587f, 0.16488139f, 
    -0.05204200f, -0.10841077f, -0.01351395f, 0.02524078f, 0.08126652f, 0.15113105f, 0.05115608f, 0.25274673f, 
    0.10154292f, -0.01753016f, -0.00507080f, -0.08654018f, 0.12323098f, 0.15023668f, -0.12458854f, 0.21643920f, 
    -0.02655450f, -0.11826957f, -0.09728331f, -0.07705117f, -0.18968403f, 0.11325455f, -0.07281076f, -0.21180485f, 
    0.01953848f, -0.00619744f, -0.03604550f, 0.13927121f, 0.07981027f, -0.04449429f, 0.10702257f, 0.06437186f, 
    -0.16342014f, -0.08918530f, 0.14180748f, 0.08126112f, 0.02647488f, 0.09009138f, -0.06108595f, 0.09732718f, 
    0.05909691f, -0.05269804f, -0.03111247f, -0.09786323f, -0.09528804f, -0.15812227f, 0.06510574f, 0.07905613f, 
    0.04442314f, 0.08227745f, 0.00022084f, -0.02582297f, 0.10474001f, 0.05071036f, 0.05162190f, 0.03515758f, 
    -0.15722565f, -0.01583614f, 0.04055795f, -0.03240401f, 0.03584767f, -0.06207776f, 0.11460108f, 0.08077371f, 
    0.21067011f, 0.11017565f, 0.11990338f, 0.24357048f, 0.19979823f, 0.28274202f, 0.25536206f, -0.20315906f, 
    -0.07008185f, -0.09917893f, -0.03767199f, 0.10982408f, 0.02767384f, -0.04115726f, 0.04495088f, -0.05022057f, 
    -0.15326920f, 0.00244537f, 0.19379234f, 0.32853946f, -0.04512528f, -0.14813413f, -0.18924408f, -0.01752047f, 
    0.07330589f, 0.03321550f, -0.01221216f, 0.02289321f, -0.09644648f, 0.33665407f, 0.25482842f, -0.09298515f, 
    -0.04320272f, -0.13284791f, -0.07120408f, 0.02790531f, -0.02165816f, -0.03002899f, -0.00084229f, 0.04565473f, 
    0.08033815f, -0.04851636f, -0.02281500f, -0.08343654f, -0.02767538f, 0.13968633f, 0.11262920f, 0.08129107f, 
    -0.01433489f, -0.10943637f, -0.08766622f, -0.19128481f, 0.26496360f, -0.06485393f, 0.03982408f, -0.07609755f, 
    -0.01525493f, -0.04709290f, -0.03440086f, 0.08576211f, 0.08145297f, 0.04983184f, 0.08710917f, -0.02676236f, 
    -0.31443125f, -0.05085018f, 0.07298074f, -0.00648793f, 0.00001462f, -0.10160118f, -0.02379450f, -0.03129434f, 
    0.07757904f, -0.08185869f, 0.10264758f, 0.00708742f, -0.21454191f, 0.04413235f, 0.02030808f, 0.12720978f, 
    -0.03762377f, -0.08681498f, -0.06667405f, -0.15874241f, 0.06272365f, -0.00284244f, -0.03306210f, -0.02660030f, 
    -0.18069012f, -0.11446849f, 0.15621056f, -0.14641665f, 0.06409439f, 0.04326654f, -0.06130797f, -0.06322419f, 
    0.12242708f, -0.02166650f, 0.11381051f, 0.03882062f, -0.02877924f, -0.01844849f, 0.12720236f, 0.15795688f, 
    0.04834020f, 0.01692876f, -0.09111701f, 0.04251346f, 0.10962375f, -0.00594343f, 0.18416500f, 0.16841778f, 
    0.18397722f, -0.07490461f, -0.12302983f, -0.03113983f, 0.06441616f, -0.01346081f, 0.14916551f, 0.08240052f, 
    0.07882114f, 0.04761901f, -0.05968075f, -0.12089763f, -0.31699502f, -0.20761356f, 0.15649417f, 0.50754249f, 
    0.09264909f, 0.00553547f, 0.05802672f, 0.14517963f, 0.01500209f, 0.07180308f, 0.13579044f, 0.05234320f, 
    -0.20225373f, -0.16188420f, -0.04690443f, -0.00643137f, 0.02922480f, 0.01539412f, -0.01697242f, -0.12801993f, 
    0.14016984f, 0.00081327f, 0.03011499f, 0.15742098f, -0.10623597f, 0.11454139f, 0.37935334f, -0.04278326f, 
    0.02376497f, -0.01177081f, -0.12365550f, -0.06224888f, 0.02969990f, 0.19982430f, 0.08117636f, 0.16788127f, 
    -0.10561445f, -0.16807912f, 0.13380541f, 0.12817496f, -0.01232126f, -0.04019354f, 0.07960939f, 0.06441722f, 
    0.01923533f, 0.04258611f, 0.00082072f, 0.03352070f, 0.07454535f, -0.03636587f, -0.07667797f, 0.01323912f, 
    -0.02671884f, 0.00118625f, -0.01747584f, 0.04316434f, 0.04061650f, -0.00981757f, 0.03605248f, 0.02979878f, 
    -0.11998653f, -0.13000178f, 0.02456295f, -0.05668546f, 0.01355940f, 0.00315659f, -0.00747731f, -0.02924870f, 
    -0.01662056f, -0.08587226f, -0.07164399f, -0.09014350f, -0.07279995f, -0.15677969f, -0.03784609f, 0.10073429f, 
    0.03372775f, -0.01268919f, 0.00142785f, 0.08411634f, 0.25796410f, 0.14136332f, 0.10509740f, 0.12456198f, 
    -0.22955182f, -0.01729910f, 0.28372443f, 0.02107281f, -0.10667580f, -0.11715392f, -0.07408182f, -0.09334745f, 
    0.14064816f, 0.08253741f, 0.07574551f, 0.05104190f, 0.21012065f, 0.04376350f, -0.07201708f, -0.15611093f, 
    0.10213482f, 0.04513144f, 0.12388695f, 0.05285471f, 0.15766749f, 0.02705996f, 0.17415585f, 0.05438462f, 
    0.01193920f, 0.24356921f, -0.05201793f, 0.00935585f, 0.03762519f, 0.02335537f, 0.17252998f, 0.01210606f, 
    -0.01417440f, 0.17115642f, -0.03250242f, 0.11832694f, 0.23320934f, 0.03433769f, -0.13088308f, -0.17169334f, 
    0.12693839f, 0.01689424f, 0.17558002f, 0.09797776f, -0.02108640f, -0.04798980f, -0.06504123f, -0.08697271f, 
    -0.04567714f, -0.24629004f, -0.36394614f, 0.02711875f, 0.05410779f, -0.05966479f, -0.07939739f, 0.05428215f, 
    0.23195718f, -0.00305394f, 0.16539519f, 0.02038960f, 0.20015457f, 0.20833592f, 0.13218662f, -0.11117107f, 
    0.08176202f, -0.05807759f, 0.11937029f, 0.12711683f, -0.08914678f, 0.00222328f, -0.02518974f, -0.04852271f, 
    -0.23296539f, 0.21383376f, -0.02629376f, -0.00478710f, 0.12104202f, -0.03333249f, -0.07184530f, -0.09287384f, 
    0.10806286f, 0.14525996f, -0.06697534f, -0.01293606f, 0.34241691f, 0.45014247f, 0.16435479f, 0.25637734f, 
    0.08879424f, 0.15549351f, 0.00130274f, 0.17437580f, -0.05084903f, 0.01052129f, 0.05784416f, -0.01756060f, 
    0.07243647f, 0.37062240f, 0.12409355f, -0.05987516f, -0.05223067f, 0.00211298f, -0.01452487f, -0.08598319f, 
    -0.06014919f, -0.13030367f, -0.00252473f, 0.09329993f, -0.11445510f, 0.29802024f, -0.09083795f, 0.07531242f, 
    0.10832156f, 0.00738177f, -0.00416214f, 0.08867423f, -0.00243710f, 0.09391605f, -0.10671064f, 0.00695507f, 
    -0.09340075f, -0.16250721f, 0.03242863f, -0.13786976f, 0.04370618f, 0.08620626f, -0.03992073f, 0.05368602f, 
    0.08257372f, 0.09444629f, -0.03532208f, -0.01733410f, 0.22121450f, 0.15518403f, 0.23416162f, 0.02826455f, 
    -0.04709384f, 0.00677435f, -0.02760869f, 0.13512398f, -0.10689118f, 0.13799669f, -0.06754192f, 0.03903279f, 
    0.12721759f, 0.56816685f, 0.18419826f, 0.05578787f, 0.15891077f, -0.07876822f, 0.02938097f, 0.11114262f, 
    0.00857530f, 0.12459330f, -0.01825385f, -0.03139588f, 0.15226249f, 0.44629669f, 0.32663932f, -0.00736591f, 
    -0.01002758f, 0.09470230f, 0.20403865f, 0.06946848f, 0.01087334f, -0.03506576f, -0.12016411f, 0.00821768f, 
    0.00441825f, 0.25734237f, 0.03003292f, 0.12607320f, 0.01036651f, -0.03154434f, 0.10592932f, 0.08551972f, 
    -0.07022808f, -0.10202549f, -0.00471009f, -0.01517144f, 0.11991727f, -0.24375233f, -0.04147606f, -0.02492386f, 
    -0.00045062f, 0.05644250f, -0.04766709f, 0.03666771f, 0.04718403f, -0.02097090f, -0.02481119f, -0.03908096f, 
    0.00627965f, 0.27524155f, -0.00164589f, 0.11940311f, 0.18495013f, 0.07525534f, -0.02471526f, 0.07381351f, 
    0.02128485f, 0.05160953f, -0.12173822f, 0.03808549f, 0.13334081f, 0.02737146f, -0.09321952f, 0.14940257f, 
    0.01324630f, 0.07587159f, 0.03456620f, -0.05158661f, -0.02088866f, 0.11365266f, -0.00382567f, -0.10013296f, 
    -0.03347439f, 0.12262792f, 0.18915889f, 0.07047805f, -0.06671557f, 0.02812113f, 0.01464273f, 0.06685431f, 
    0.00997825f, 0.08862946f, 0.07621204f, -0.05780401f, -0.22743079f, -0.25942412f, -0.27489653f, -0.11583265f, 
    -0.06399240f, -0.09161438f, -0.01298370f, -0.03629883f, 0.11977805f, -0.08059096f, 0.00422234f, 0.00153297f, 
    0.32187444f, 0.10425399f, 0.01272534f, -0.10288328f, 0.18949322f, 0.07887506f, 0.14013503f, 0.10082729f, 
    -0.04053218f, -0.05701162f, -0.02670296f, -0.04658562f, 0.66726118f, 0.52733058f, 0.37168497f, 0.09672987f, 
    -0.04484109f, 0.07057951f, 0.05727913f, 0.24329385f, -0.03323460f, -0.05338033f, -0.05725617f, 0.05496781f, 
    0.11552361f, -0.12924437f, 0.06757355f, 0.06144695f, -0.05071511f, 0.00373867f, 0.03305751f, 0.15478630f, 
    0.08973189f, -0.13310891f, -0.00734278f, 0.26614439f, -0.18322815f, -0.17877832f, -0.05957105f, -0.02196194f, 
    0.03687778f, 0.02502310f, -0.00900899f, -0.02121314f, -0.09654111f, -0.01972564f, -0.03738173f, 0.03368798f, 
    -0.40504670f, -0.28048709f, -0.12085720f, 0.04462020f, 0.13331807f, 0.02322877f, -0.12867387f, -0.03238350f, 
    0.02810904f, 0.02684543f, 0.09232738f, 0.04869379f, -0.37596488f, 0.15648977f, 0.46100911f, 0.08157566f, 
    0.08792595f, -0.06236964f, -0.05111117f, -0.02926092f, -0.04299344f, -0.00524758f, -0.08379738f, -0.00480311f, 
    -0.02821199f, 0.35175279f, 0.35918072f, -0.04704659f, -0.04596995f, -0.01105048f, 0.03438062f, 0.15308109f, 
    0.01440111f, -0.01205119f, -0.15793806f, -0.04574250f, 0.14012052f, -0.13515031f, -0.20411414f, -0.06127490f, 
    0.15253665f, 0.04444133f, -0.06229782f, -0.05461134f, -0.11801237f, -0.09924322f, -0.05733756f, 0.02780573f, 
    0.34305006f, 0.10506750f, 0.06498086f, 0.05338622f, -0.07006853f, -0.14664903f, 0.02798316f, 0.16934161f, 
    0.06265821f, -0.04743037f, -0.02700096f, -0.05581689f, -0.46360224f, -0.34919178f, -0.38842180f, -0.01918866f, 
    0.11065837f, 0.03656145f, -0.05244982f, 0.00680865f, 0.07697358f, 0.09453151f, 0.04333776f, 0.07830986f, 
    0.22339614f, 0.24112402f, 0.28836966f, 0.22504374f, -0.04120119f, 0.13187686f, -0.03196765f, -0.07639538f, 
    0.09517647f, 0.08750492f, 0.01832866f, -0.05140393f, -0.30503982f, -0.26474631f, -0.05094118f, 0.05306801f, 
    0.06575897f, -0.04588276f, 0.00501239f, -0.01886969f, -0.11281855f, -0.11190969f, 0.05252628f, 0.08213962f, 
    0.21046829f, 0.11737669f, -0.03252024f, -0.01783386f, -0.09204289f, 0.09615470f, 0.06074715f, 0.04282004f, 
    -0.03201186f, -0.05216142f, -0.04551987f, 0.00522943f, -0.12845126f, 0.11505593f, 0.01031012f, 0.07330841f, 
    -0.03361607f, -0.13105960f, 0.03926538f, -0.06195610f, -0.04074942f, -0.07392169f, 0.05004298f, 0.13290417f, 
    -0.10902363f, 0.01256878f, 0.03302460f, 0.06792277f, 0.10588333f, -0.01689824f, 0.17963022f, 0.14166605f, 
    -0.03885594f, -0.01185195f, 0.12538026f, -0.10945330f, 0.06742503f, 0.14088517f, 0.20839778f, -0.00652579f, 
    -0.05855224f, 0.14084168f, -0.04433648f, 0.12737894f, -0.04162570f, 0.01668418f, 0.00926589f, 0.05344252f, 
    0.03050422f, -0.03538423f, 0.03970170f, 0.01093872f, 0.03686160f, -0.04443138f, 0.00202017f, 0.01262235f, 
    0.03101662f, -0.04651424f, 0.04834278f, -0.02294482f, -0.01152825f, -0.02015836f, -0.00888723f, -0.04451744f, 
    0.04486322f, 0.00254547f, -0.03031769f, -0.00148460f, 0.03332603f, 0.05098133f, 0.01261400f, 0.01267194f, 
    -0.02385456f, -0.03265214f, -0.03735569f, -0.04001731f, -0.03588889f, -0.02979954f, -0.01968031f, -0.03893444f, 
    -0.02970262f, -0.04613226f, 0.04287728f, -0.02661629f, -0.01773965f, -0.00214528f, 0.03619440f, 0.02976241f, 
    0.05525546f, 0.00611892f, -0.02862551f, 0.03319345f, -0.03385172f, -0.02705745f, 0.00843111f, 0.03452185f, 
    0.05504414f, 0.03002357f, -0.02429089f, -0.02018229f, 0.04749683f, 0.01109719f, 0.03819432f, -0.00100106f, 
    -0.00016766f, -0.04093946f, -0.00864342f, -0.00739739f, -0.04078863f, 0.05167958f, 0.03744662f, 0.02215653f, 
    -0.01463820f, 0.02248040f, 0.02385672f, -0.02973722f, -0.01185174f, -0.03090907f, 0.00069314f, -0.00744244f, 
    -0.03395270f, -0.00004531f, -0.01026964f, -0.03114613f, -0.00807122f, 0.00279305f, 0.03584736f, 0.00668145f, 
    0.03015417f, -0.01809722f, -0.04152843f, -0.00073674f, -0.04054839f, 0.03808771f, 0.02729050f, -0.04136301f, 
    0.04223101f, 0.05130675f, 0.00103815f, 0.03591566f, -0.00796744f, -0.01936256f, 0.01629522f, -0.02725924f, 
    -0.02672275f, 0.00233337f, -0.03356501f, -0.05128338f, 0.03491613f, -0.02327293f, 0.00923620f, -0.04826316f, 
    -0.03570761f, -0.03410104f, -0.02439448f, -0.04600321f, 0.04012238f, 0.02088021f, -0.01661102f, 0.04631265f, 
    -0.04279295f, -0.05793182f, 0.01537279f, -0.04589214f, 0.04174991f, 0.00937425f, 0.00530417f, 0.00886540f, 
    -0.02043766f, -0.01204581f, -0.03609641f, 0.02926665f, -0.04543653f, 0.04667865f, 0.03104026f, -0.04219670f, 
    -0.01413395f, -0.03015657f, 0.00826803f, 0.00818060f, 0.00154633f, 0.00048010f, 0.00332970f, 0.04399529f, 
    -0.03037674f, 0.00727704f, 0.00154758f, 0.01239303f, -0.01987376f, -0.04547861f, -0.00442747f, 0.02947185f, 
    0.03796589f, -0.01864818f, 0.03237598f, 0.04270208f, 0.00680363f, -0.04667412f, -0.00434943f, -0.02250856f, 
    -0.03699838f, -0.01500428f, -0.03282943f, 0.03229951f, -0.00321349f, 0.01597451f, -0.04420616f, -0.01512154f, 
    -0.02945627f, -0.00616367f, -0.04816866f, 0.01092962f, -0.00526291f, -0.01064686f, -0.04631170f, -0.03083682f, 
    0.05001385f, 0.04184838f, 0.02719214f, 0.02273036f, -0.04241909f, -0.04730140f, -0.02316489f, 0.00425658f, 
    -0.00729324f, 0.04089786f, 0.02358443f, -0.02155286f, -0.04485815f, -0.02761439f, -0.03661985f, -0.02056139f, 
    0.03570129f, 0.00293036f, 0.02946950f, -0.02700417f, 0.03545484f, 0.03303364f, 0.01049652f, -0.04502424f, 
    -0.02913186f, -0.02725211f, -0.03280018f, -0.02856264f, -0.00567806f, 0.02420405f, 0.00815145f, 0.04083645f, 
    0.03939757f, -0.01201525f, 0.00247967f, 0.00046204f, -0.03309397f, -0.01679476f, -0.02435290f, 0.01980016f, 
    0.03884807f, -0.01793428f, -0.02675937f, -0.01187452f, 0.01722879f, -0.02465150f, -0.04397332f, -0.01465148f, 
    0.04751118f, -0.02632349f, 0.02197521f, -0.01901949f, -0.00106167f, -0.05629468f, -0.03914076f, 0.01413428f, 
    0.04676488f, 0.04031858f, -0.00588470f, 0.04142470f, -0.02364904f, 0.03884844f, 0.01220741f, 0.03690518f, 
    0.04760361f, 0.01548170f, -0.00842659f, -0.04866562f, 0.05017014f, 0.00184957f, 0.01019683f, -0.04755175f, 
    -0.04855204f, -0.01372186f, 0.04459518f, 0.02343286f, 0.03037870f, -0.04176909f, -0.03357167f, 0.02217759f, 
    -0.03272199f, 0.02976811f, -0.00570577f, -0.05481150f, -0.01618767f, -0.02463463f, -0.02925110f, -0.03666586f, 
    0.01770165f, 0.01478775f, 0.02205826f, 0.01120425f, 0.03951592f, 0.00304871f, -0.02019131f, 0.01307695f, 
    -0.01067823f, 0.02268770f, -0.00475940f, 0.00357834f, -0.04278255f, 0.01964669f, 0.00540643f, 0.00752611f, 
    -0.01000705f, 0.00072603f, -0.00620100f, -0.04740275f, -0.02489391f, 0.04551573f, -0.00332353f, -0.03480306f, 
    -0.03972122f, 0.04361970f, -0.00646815f, -0.00065405f, -0.02714867f, -0.03200204f, -0.03348238f, -0.02424775f, 
    -0.02268326f, 0.00584040f, 0.04376470f, -0.02322723f, -0.01367986f, -0.02627120f, -0.03725433f, -0.01610689f, 
    0.03625505f, 0.00043155f, 0.04218834f, -0.03659804f, 0.01901872f, 0.05125519f, -0.02872372f, -0.02884304f, 
    0.04097759f, -0.02403303f, -0.03763879f, -0.00412036f, 0.01421741f, -0.02042276f, -0.02529635f, 0.05065228f, 
    0.04249560f, -0.03136160f, -0.05383190f, 0.01388308f, 0.03378437f, 0.00534521f, -0.05580124f, -0.00447719f, 
    0.00620602f, -0.02326948f, 0.01042246f, -0.00606985f, -0.01036452f, 0.01649970f, 0.01662568f, -0.00923044f, 
    -0.00448529f, 0.00813144f, -0.03569456f, 0.00359800f, -0.01078507f, -0.02958211f, -0.00412804f, 0.02390024f, 
    0.00023743f, -0.01465851f, -0.03681408f, 0.01953520f, 0.01778024f, -0.01757125f, 0.04480976f, 0.05502731f, 
    -0.02041013f, -0.02789408f, -0.03158082f, 0.00551535f, 0.03057714f, -0.02709444f, -0.03388623f, -0.02542846f, 
    -0.03821267f, 0.00501634f, -0.00320358f, -0.04125070f, -0.01776181f, 0.01529694f, 0.02786284f, -0.05637588f, 
    0.04008780f, -0.01183053f, 0.00528154f, -0.01004989f, -0.05376936f, -0.00463388f, -0.00955302f, 0.01553074f, 
    0.00192287f, 0.02139351f, 0.01479744f, 0.00837299f, 0.01495051f, -0.02460847f, -0.04766354f, -0.00886718f, 
    0.01852444f, -0.00633879f, -0.01967299f, 0.00978632f, -0.03776990f, -0.04092984f, -0.02154390f, -0.03818997f, 
    0.10270045f, -0.08225056f, 0.07401231f, 0.23855364f, 0.12164250f, -0.07033401f, 0.04284956f, -0.07641309f, 
    -0.08702997f, 0.02728864f, 0.19747175f, 0.22101283f, -0.07774683f, -0.10695737f, -0.01431474f, -0.02939167f, 
    0.16911854f, -0.02443600f, 0.06767205f, 0.14550367f, -0.06560920f, 0.01018012f, 0.01716808f, -0.08554444f, 
    0.21805356f, -0.20628306f, 0.03961393f, 0.09677041f, 0.11668906f, 0.18112592f, 0.12639980f, 0.20369989f, 
    0.10578623f, 0.19097532f, -0.10226984f, 0.06843121f, -0.03105798f, 0.04224448f, 0.13493758f, 0.02677224f, 
    0.09670663f, 0.19586422f, 0.09786288f, -0.09771170f, 0.05426979f, 0.01069789f, 0.07302814f, 0.07936221f, 
    0.12927921f, 0.10511316f, 0.18405782f, -0.00651894f, -0.10915899f, -0.00792063f, 0.17813495f, 0.22606395f, 
    0.14754732f, -0.03904291f, 0.04613997f, -0.09497722f, -0.31231883f, -0.02175166f, -0.03174238f, -0.12823325f, 
    0.06976441f, 0.06605649f, 0.10829853f, 0.18419732f, 0.10523262f, 0.06667455f, 0.11433329f, 0.09677298f, 
    0.08693878f, -0.02706764f, -0.08803740f, 0.04705373f, 0.21600161f, 0.02212849f, 0.13041297f, 0.06234349f, 
    0.03110209f, 0.04573533f, 0.09756576f, 0.10635833f, 0.01761824f, -0.09224367f, -0.33671457f, -0.13243045f, 
    0.06913286f, 0.09320721f, 0.16525723f, 0.16158958f, -0.04763411f, -0.14603084f, -0.10429343f, -0.09318438f, 
    0.01009676f, 0.09397490f, 0.07249436f, -0.01571894f, -0.00906065f, 0.29118916f, 0.18182105f, -0.05277820f, 
    0.04596447f, 0.09868220f, -0.04901334f, 0.01422330f, 0.04875195f, 0.02144692f, 0.10598759f, 0.20252958f, 
    0.20826972f, 0.17963344f, -0.04976967f, -0.07236844f, 0.07202138f, 0.20643182f, 0.05450282f, 0.04876807f, 
    -0.04913538f, -0.00625853f, 0.08503294f, -0.09185272f, 0.03995357f, 0.16544552f, 0.07729371f, 0.12269638f, 
    0.13179709f, 0.01819806f, -0.02239632f, -0.07663062f, 0.03839443f, 0.08648034f, -0.11297239f, -0.01961374f, 
    -0.00071547f, 0.05899671f, 0.14596146f, 0.13573632f, 0.24234436f, 0.12696430f, -0.08829562f, 0.04259810f, 
    -0.42737031f, -0.28695360f, 0.02767229f, -0.06658635f, 0.00213089f, 0.08018793f, 0.04304964f, 0.17678241f, 
    0.21889901f, 0.15670893f, -0.10626812f, 0.02394025f, -0.27473265f, -0.04799458f, -0.02470503f, -0.15481107f, 
    -0.09076707f, 0.03130297f, -0.01396437f, 0.10355355f, 0.18273292f, 0.22309317f, -0.03544075f, -0.10226535f, 
    0.13218172f, -0.05169388f, -0.06416786f, -0.04890251f, 0.06544955f, -0.11185924f, 0.07187299f, 0.05072456f, 
    -0.01371931f, 0.14380567f, 0.04493938f, 0.03168235f, 0.01244206f, 0.20227715f, 0.08038123f, 0.09226295f, 
    -0.07296973f, 0.00156781f, -0.08854984f, -0.09933887f, 0.01712190f, 0.06938701f, 0.12067456f, 0.10096465f, 
    -0.25079447f, 0.08697443f, -0.09710255f, -0.09366711f, 0.01584912f, 0.02283273f, 0.14264964f, -0.01955423f, 
    -0.09226092f, -0.03825239f, -0.03848619f, -0.10197892f, -0.16347159f, -0.15396661f, -0.06284215f, -0.00197791f, 
    0.09479303f, 0.05403603f, 0.00934840f, -0.21887901f, -0.02229085f, -0.08777058f, -0.00366612f, -0.00053109f, 
    -0.05903997f, 0.02915138f, -0.05091660f, 0.28491175f, -0.06111645f, -0.07773742f, 0.16755392f, -0.04103161f, 
    0.14067759f, 0.10827496f, 0.27869400f, 0.28258151f, 0.15145679f, 0.10075992f, -0.00981705f, -0.17667745f, 
    -0.05387561f, -0.06687488f, -0.04363967f, 0.05266237f, 0.24969462f, 0.02406948f, 0.05917715f, 0.12016967f, 
    0.22945324f, 0.10512999f, 0.14301015f, -0.04482567f, 0.01390128f, -0.02410160f, 0.04685308f, 0.01246775f, 
    -0.18535571f, -0.04954053f, 0.06262305f, -0.03360524f, 0.07763267f, -0.10863113f, -0.17617224f, -0.05023369f, 
    0.08683547f, -0.08931877f, 0.27335143f, 0.26299027f, 0.11587594f, 0.09605559f, 0.21222022f, 0.11462960f, 
    -0.14465365f, -0.13544756f, 0.14902575f, -0.02312730f, 0.00877505f, -0.18807004f, -0.03165033f, 0.07323445f, 
    0.13224278f, 0.08779120f, 0.08065478f, 0.01806829f, 0.01647934f, 0.21280794f, 0.07008605f, -0.08569162f, 
    -0.06798697f, -0.02445306f, 0.10660450f, 0.15039229f, 0.23190105f, 0.07277016f, 0.06813072f, 0.15885161f, 
    0.01141334f, 0.30333039f, 0.00987854f, 0.16289872f, -0.00552870f, -0.04730587f, -0.02412529f, -0.16495021f, 
    -0.04014687f, 0.00861351f, -0.03425540f, -0.05976357f, 0.10608017f, 0.18622400f, 0.12157833f, 0.04984859f, 
    -0.05798427f, 0.01193525f, -0.04790139f, -0.06813718f, 0.06804565f, -0.03411165f, 0.01993518f, 0.04061090f, 
    -0.22719344f, -0.26296180f, -0.08546919f, -0.12273412f, 0.01145142f, 0.12157580f, 0.11307696f, -0.04971015f, 
    -0.07084472f, 0.04568176f, 0.04393917f, 0.02254310f, 0.14377934f, -0.00946377f, -0.04757275f, -0.05636980f, 
    0.00797747f, -0.01094812f, 0.02585149f, 0.07623610f, 0.10592975f, 0.13508201f, 0.03215681f, -0.08778982f, 
    -0.21049872f, -0.10502566f, 0.00179909f, -0.13427471f, -0.05317372f, 0.08649214f, 0.02559972f, -0.08811112f, 
    -0.12847884f, -0.01912274f, -0.08721279f, -0.23453312f, 0.02532308f, -0.14744891f, 0.28108183f, 0.25957766f, 
    0.16439277f, 0.18726407f, 0.26179114f, 0.40551281f, 0.01160684f, 0.07746195f, 0.03946580f, 0.00097418f, 
    0.04509006f, -0.10461473f, -0.20604537f, -0.03164409f, -0.03692286f, 0.20087780f, 0.17897506f, 0.25692686f, 
    -0.05791921f, -0.34581059f, -0.07523060f, -0.12694719f, -0.01674378f, 0.07778040f, 0.02034815f, -0.15635705f, 
    -0.00160081f, 0.06462284f, 0.03936258f, -0.05896163f, -0.01481971f, 0.09804327f, 0.07286128f, 0.05478422f, 
    0.01051469f, 0.03887373f, 0.02361429f, -0.00444014f, 0.02932925f, 0.00592967f, 0.00280227f, -0.03311493f, 
    -0.00361828f, -0.04481427f, -0.00710218f, 0.01916449f, -0.03322292f, 0.03863062f, 0.03618468f, 0.01646100f, 
    0.02325056f, 0.02632436f, 0.04027752f, -0.00062778f, -0.05392428f, -0.04309701f, 0.00087498f, 0.03263346f, 
    0.02280206f, 0.02950449f, 0.02412978f, -0.05357143f, 0.02302895f, -0.00734202f, -0.04728441f, -0.03628225f, 
    0.02122311f, 0.03353909f, -0.00230836f, 0.01784542f, -0.04691187f, 0.01670340f, -0.02589045f, 0.04342890f, 
    0.01954535f, 0.03737365f, -0.02641898f, -0.04457341f, 0.00984560f, 0.02249496f, 0.04497374f, -0.01102195f, 
    -0.00196396f, -0.00918084f, -0.00749039f, -0.04923806f, 0.00045640f, -0.01636421f, 0.03830580f, -0.02051299f, 
    0.01424853f, -0.02550616f, -0.00968270f, -0.00938019f, -0.05341838f, -0.04051965f, -0.04020650f, -0.05564431f, 
    -0.00728477f, 0.03548465f, 0.03018225f, -0.02642586f, 0.03489146f, -0.01391472f, 0.02408656f, -0.00422860f, 
    -0.04494077f, -0.03058710f, 0.00136456f, -0.00815329f, -0.04719541f, -0.01659364f, 0.03360092f, 0.01765366f, 
    -0.01795241f, 0.03927555f, -0.04300618f, 0.03566782f, 0.03707540f, 0.04388453f, 0.03097620f, -0.02571455f, 
    0.02762609f, -0.05449964f, -0.04565821f, 0.02442806f, 0.00558500f, -0.04310261f, -0.01264739f, -0.01782847f, 
    -0.02017693f, -0.04540559f, 0.03490502f, 0.02008214f, -0.03245131f, -0.00637766f, -0.00344563f, -0.02467292f, 
    -0.00617925f, -0.04303944f, 0.00009870f, -0.00293345f, -0.01878768f, 0.03174651f, -0.05529172f, -0.00283203f, 
    -0.02251717f, -0.00497377f, 0.00010159f, 0.03436008f, 0.03298549f, -0.00783444f, 0.00378371f, 0.01893396f, 
    -0.01615197f, -0.01494292f, 0.04300226f, 0.03378916f, -0.01392432f, -0.00600048f, -0.02344187f, 0.04447006f, 
    0.02146896f, 0.00335200f, 0.01431579f, -0.05409448f, -0.04871317f, 0.03823484f, 0.01606523f, -0.05476149f, 
    -0.04874548f, 0.02677661f, -0.05135709f, 0.03522108f, -0.04491225f, -0.00409105f, 0.03596022f, -0.01033855f, 
    -0.03704820f, 0.03133952f, 0.03544408f, -0.02968843f, -0.02185773f, -0.01544136f, -0.04114923f, 0.03354386f, 
    0.04052918f, -0.04407369f, -0.01325120f, 0.03595340f, -0.04184183f, -0.03509827f, -0.04474571f, -0.03776115f, 
    0.01912954f, -0.01658726f, -0.03841228f, -0.01373453f, -0.03020865f, -0.02944225f, 0.04122617f, 0.00226584f, 
    0.02332066f, 0.02722646f, 0.00519741f, -0.05083012f, 0.00227862f, 0.01419431f, 0.04316949f, -0.01467160f, 
    -0.03498128f, -0.03971247f, 0.00421054f, -0.02723026f, -0.03315052f, -0.04099067f, -0.04321976f, -0.05180662f, 
    -0.00813929f, -0.01198140f, 0.02828838f, -0.05718730f, 0.02012542f, -0.04087695f, 0.03410700f, -0.01294787f, 
    0.03597750f, -0.02921872f, 0.00854495f, 0.03705852f, -0.05049343f, 0.02560762f, -0.02729547f, 0.00181266f, 
    0.01845134f, -0.04187130f, 0.00066199f, 0.01204449f, 0.02622634f, -0.05524769f, -0.03163799f, -0.02505404f, 
    -0.02253292f, 0.01296096f, -0.02016481f, -0.05846655f, 0.02691508f, 0.02476572f, 0.03860869f, -0.00549535f, 
    0.00875621f, 0.02471624f, 0.02374308f, -0.02201996f, 0.00432796f, -0.05302637f, -0.01900653f, -0.02704995f, 
    -0.00873522f, 0.02193747f, -0.03387028f, 0.01160422f, -0.02149971f, -0.00051897f, -0.00486037f, 0.02026876f, 
    -0.02919005f, -0.04756098f, -0.04429376f, 0.00038344f, 0.01082731f, 0.03907953f, -0.02069099f, -0.01897329f, 
    0.00620020f, -0.02444129f, 0.04120684f, 0.05180183f, 0.05466006f, -0.00966301f, -0.00911752f, 0.02785315f, 
    -0.01871090f, 0.03744411f, 0.01064938f, 0.00557483f, 0.03007009f, -0.01196940f, -0.02779092f, -0.05045918f, 
    0.00802938f, 0.04166633f, 0.04010408f, -0.03542248f, 0.04201348f, 0.00871547f, -0.05238636f, 0.00642126f, 
    -0.05076955f, 0.01117581f, 0.01539916f, -0.02285734f, 0.00234989f, 0.04264912f, -0.00373613f, 0.01171372f, 
    0.03485305f, -0.02864890f, -0.04119772f, 0.03289530f, 0.00537537f, 0.01932361f, -0.05358431f, -0.02667764f, 
    0.04277682f, -0.04700329f, 0.03200359f, 0.01472710f, -0.00625406f, -0.03510199f, -0.00022712f, -0.00277533f, 
    0.02728826f, -0.02187413f, 0.01004720f, 0.03106228f, -0.02416714f, -0.02491872f, 0.02418847f, -0.03682169f, 
    -0.02670839f, -0.05008285f, -0.02490263f, -0.00615638f, -0.05627829f, -0.02102025f, -0.03196354f, 0.01121270f, 
    0.01405234f, -0.01773727f, -0.01294366f, 0.01408109f, 0.04140505f, -0.04464185f, -0.01860783f, -0.04089395f, 
    -0.02847309f, 0.01765088f, -0.03336710f, -0.04613220f, -0.04871851f, 0.03330543f, 0.01955167f, -0.00913983f, 
    -0.03842598f, -0.03104708f, -0.04217900f, -0.01878086f, 0.03074331f, -0.03988229f, 0.01814889f, -0.01360471f, 
    0.01034229f, -0.01380784f, -0.00365262f, 0.01349388f, -0.00262477f, 0.02967337f, 0.04667386f, -0.04768042f, 
    0.02156029f, -0.04138435f, -0.00790562f, 0.00532581f, 0.03800469f, -0.05639474f, -0.03450183f, -0.00396321f, 
    -0.03999942f, -0.04106574f, 0.01981266f, 0.00316076f, 0.03899118f, -0.04461711f, 0.00670363f, -0.04517092f, 
    -0.02819048f, -0.02213983f, -0.02444911f, 0.03852325f, -0.02914132f, -0.03091458f, 0.03797425f, -0.02014993f, 
    0.01187877f, -0.05570835f, 0.04102358f, -0.03424040f, -0.03143682f, 0.03090087f, 0.00300803f, -0.02748021f, 
    0.04083941f, -0.02110317f, 0.00182929f, -0.03580334f, 0.00734149f, -0.05386280f, -0.01221174f, 0.00846568f, 
    -0.03469289f, -0.01217146f, 0.03879725f, -0.02770055f, 0.00451304f, -0.03260722f, 0.01993455f, 0.01722135f, 
    0.48303697f, -0.07490810f, 0.34226942f, -0.10606845f, -0.05875829f, -0.07255310f, 0.15082866f, -0.04222518f, 
    0.00638828f, 0.01331606f, -0.01224261f, 0.02248864f, 0.18236864f, 0.04885002f, -0.04567328f, 0.03036779f, 
    -0.03013602f, 0.18282746f, -0.03390238f, -0.11783034f, -0.04623001f, 0.11082808f, -0.02584804f, -0.07330573f, 
    0.34922287f, -0.33406070f, 0.45755619f, -0.11066282f, 0.08327031f, 0.05286155f, 0.13698238f, 0.15860848f, 
    0.10298210f, 0.13584489f, 0.04150021f, 0.00279741f, -0.02740016f, -0.15259632f, 0.07981432f, -0.30954763f, 
    0.05719887f, -0.06710776f, 0.01024509f, -0.17193975f, -0.02666673f, -0.00745017f, -0.10341784f, 0.09066901f, 
    -0.06193827f, 0.02256679f, -0.10852934f, 0.18825038f, -0.02317603f, -0.26266393f, 0.19558121f, 0.17785764f, 
    0.06777567f, -0.05631297f, 0.16322568f, 0.06478427f, 0.11319815f, -0.08296546f, -0.16803907f, -0.08190665f, 
    -0.11684249f, 0.04117651f, 0.23366176f, -0.08092728f, 0.05031280f, 0.04732794f, 0.02742466f, 0.05450344f, 
    0.10634035f, 0.09218603f, 0.09200177f, -0.00601965f, -0.14606266f, 0.12117203f, 0.10465091f, -0.01798257f, 
    -0.11163089f, -0.11094482f, 0.02442105f, 0.04380080f, 0.14267561f, 0.15940511f, 0.02387574f, -0.10664224f, 
    0.05125465f, 0.13959289f, -0.03298389f, -0.13147779f, -0.01318184f, -0.12664410f, -0.03248474f, -0.06416002f, 
    0.09624936f, -0.22023308f, 0.10911753f, 0.24388102f, -0.07139539f, 0.14250468f, 0.03887670f, -0.07121798f, 
    -0.02142274f, -0.04288506f, -0.00337381f, 0.05776719f, 0.01272984f, -0.14872466f, -0.12220199f, 0.03093717f, 
    -0.01412619f, 0.03095304f, 0.08708926f, 0.04494732f, -0.00256670f, 0.03275451f, 0.02549192f, 0.11233647f, 
    0.20545928f, -0.09325883f, 0.22163543f, -0.04156348f, 0.08919276f, -0.02946761f, 0.03736831f, 0.05199662f, 
    0.06572910f, 0.17218761f, -0.06224787f, -0.07168865f, 0.23693971f, -0.20325319f, -0.15679933f, -0.10090011f, 
    -0.01832775f, 0.03588983f, 0.10921036f, -0.00831404f, 0.16481550f, 0.02690526f, -0.02982818f, -0.00507556f, 
    -0.06112827f, -0.08143692f, 0.12742609f, -0.21037367f, -0.06773248f, 0.00947167f, 0.27140480f, -0.12680833f, 
    -0.06486765f, -0.07243428f, 0.09362993f, -0.06217244f, -0.29086691f, -0.23978432f, -0.15819290f, 0.04007450f, 
    -0.03945775f, -0.03196779f, -0.09177158f, 0.20317125f, -0.05829985f, 0.09811637f, -0.07727231f, 0.04885112f, 
    -0.06525875f, 0.10773345f, 0.13515103f, -0.12220027f, 0.00256792f, 0.00849382f, 0.08120450f, 0.04892955f, 
    -0.00840040f, -0.02569829f, 0.02936646f, 0.07648489f, 0.23806886f, 0.10466528f, 0.10119554f, 0.12151004f, 
    -0.07960133f, 0.00210329f, -0.03582156f, 0.03988858f, -0.10241751f, 0.00347115f, 0.02168945f, 0.09092417f, 
    -0.06662387f, 0.29710332f, 0.28104854f, 0.08966251f, -0.01197270f, 0.04814415f, -0.02471092f, -0.01579759f, 
    -0.16854186f, 0.09252986f, -0.00335564f, -0.15794297f, -0.43309686f, -0.13843091f, 0.10323861f, -0.09117401f, 
    0.04066395f, -0.07057219f, -0.07638438f, -0.17243867f, -0.12982807f, -0.06901222f, 0.02351416f, -0.00732839f, 
    0.12988399f, -0.26828009f, 0.29503584f, -0.19582874f, -0.02884184f, -0.04958498f, 0.11488374f, -0.13497289f, 
    0.18759067f, 0.03380005f, 0.00297032f, 0.01940437f, -0.03128159f, 0.11773893f, -0.16661227f, 0.05610676f, 
    0.08136002f, 0.06895025f, 0.03264302f, 0.06584080f, 0.06284849f, 0.01390106f, -0.04083194f, 0.07638541f, 
    0.39807901f, 0.27332938f, 0.21575101f, 0.09822990f, -0.13340455f, -0.02934148f, -0.01327820f, 0.00271152f, 
    -0.17341168f, -0.01112579f, -0.02216299f, -0.03706602f, -0.37989664f, 0.16183989f, -0.26875883f, -0.05091555f, 
    0.00182937f, 0.29837161f, 0.12123177f, 0.05401079f, 0.06779087f, -0.05545881f, 0.04509590f, 0.04199162f, 
    0.03178905f, -0.08583257f, -0.17516464f, 0.05501312f, 0.01518325f, -0.03473934f, -0.07846458f, -0.04637749f, 
    -0.09257495f, -0.01117042f, 0.06567986f, -0.03465379f, 0.29770476f, -0.00480428f, 0.03218738f, 0.00162400f, 
    -0.03283734f, -0.09505375f, 0.22846699f, -0.12477674f, 0.08969282f, 0.14255710f, 0.14539436f, -0.05310652f, 
    -0.26843122f, 0.40188208f, -0.21174856f, 0.08831764f, 0.13061309f, 0.09269841f, -0.14103127f, -0.11774768f, 
    -0.02498840f, -0.05451755f, -0.00392189f, 0.03478754f, 0.18617719f, 0.24623117f, 0.03803684f, 0.21072258f, 
    -0.11918762f, -0.07344118f, -0.02518906f, -0.04311339f, -0.06522735f, 0.03355588f, -0.03418601f, -0.15814705f, 
    -0.11581973f, 0.07384603f, 0.05771659f, -0.08724203f, 0.07093703f, 0.05348028f, -0.00284680f, 0.04948428f, 
    -0.16351689f, -0.00153432f, -0.04079423f, -0.06881215f, -0.02117986f, 0.08635081f, 0.12994841f, 0.05485099f, 
    -0.03881408f, -0.02172258f, 0.06524543f, 0.08054038f, -0.03940220f, 0.19806072f, 0.12262287f, -0.02200041f, 
    0.01094346f, 0.07932524f, -0.00860376f, 0.17515118f, -0.03190733f, -0.01105414f, -0.00694539f, 0.14241794f, 
    -0.15328424f, 0.08508442f, -0.19662727f, -0.06390008f, 0.15705988f, -0.20064694f, 0.29059210f, -0.04982319f, 
    0.15565847f, 0.11684915f, 0.16366038f, 0.13013604f, 0.11175364f, -0.02822737f, 0.02871794f, -0.02073758f, 
    0.10114736f, -0.24250041f, 0.05841658f, -0.15519631f, 0.04511061f, 0.14042294f, -0.07094122f, -0.01909839f, 
    0.03117032f, -0.13774139f, -0.06667206f, 0.14802910f, 0.04861663f, -0.04862027f, 0.08907470f, -0.06963907f, 
    0.05212022f, 0.00716633f, 0.17234585f, 0.01117025f, -0.15151344f, 0.02523616f, 0.04024528f, 0.02185880f, 
    0.30184174f, 0.02273921f, -0.04998204f, -0.19903885f, -0.04759127f, -0.01668049f, -0.09085214f, 0.05379250f, 
    0.13704190f, 0.13630441f, -0.08289988f, -0.14544846f, 0.17859425f, 0.15950701f, 0.04637751f, 0.23504908f, 
    0.00054516f, 0.15675798f, -0.08827358f, 0.01763563f, -0.11818894f, -0.04287614f, -0.11226635f, -0.00089171f, 
    0.04890867f, -0.15096042f, 0.36376652f, -0.14439531f, 0.06477856f, -0.09749951f, -0.13492547f, 0.05076946f, 
    0.08462116f, -0.07933738f, 0.20281884f, -0.07434496f, 0.08473334f, 0.22291523f, 0.11283354f, -0.36541161f, 
    0.08384517f, -0.00257768f, -0.07214912f, 0.15940841f, -0.05906039f, -0.01362852f, -0.01309981f, -0.11046262f, 
    0.04255553f, 0.20447412f, -0.05301756f, 0.08805867f, 0.14183708f, -0.13629016f, -0.13725875f, 0.16548152f, 
    -0.08405872f, -0.11322397f, 0.12426685f, 0.13382253f, 0.37937444f, -0.05186177f, -0.13113622f, 0.12167344f, 
    -0.09389034f, 0.00850618f, 0.09383539f, 0.07242496f, 0.06373040f, 0.00839815f, 0.00747474f, 0.20021942f, 
    0.04431109f, -0.04509025f, 0.12492967f, 0.10443351f, -0.11502554f, 0.08488964f, 0.07467832f, -0.05747451f, 
    0.06097493f, 0.05363136f, -0.00316322f, 0.00891274f, 0.18329020f, 0.18039607f, 0.35691506f, 0.02735561f, 
    0.00170394f, 0.01762980f, 0.04261444f, -0.18325037f, -0.02992524f, 0.07001454f, -0.07038340f, -0.12456992f, 
    0.21217518f, 0.02686647f, 0.07885970f, -0.02436111f, -0.00386677f, -0.08083668f, 0.18762925f, 0.06364392f, 
    -0.06948927f, -0.02474874f, -0.03576954f, -0.01884933f, 0.21258897f, 0.21036364f, 0.01849531f, -0.19052097f, 
    -0.10167861f, 0.04492193f, 0.14968884f, 0.21867858f, -0.00616549f, -0.14756855f, -0.08931075f, -0.15687379f, 
    0.12005039f, 0.06290133f, 0.11495113f, 0.03781583f, 0.09988017f, -0.07779575f, -0.09181345f, -0.10057516f, 
    -0.04726751f, 0.13376002f, -0.04398543f, -0.16481818f, 0.08152911f, -0.15653522f, 0.03881520f, -0.07350361f, 
    0.04100390f, 0.17483166f, 0.01581644f, -0.03734395f, 0.02418397f, 0.04535025f, -0.08381696f, 0.06112332f, 
    0.35450393f, -0.00922319f, 0.22371079f, 0.10394747f, -0.04792360f, 0.15616333f, 0.17215027f, -0.09886213f, 
    0.01118738f, -0.20271455f, 0.09996626f, -0.12375570f, -0.08820398f, -0.13911831f, -0.09440378f, 0.01875611f, 
    0.14106688f, 0.24007957f, 0.02968709f, 0.14359553f, -0.05831601f, -0.00450507f, -0.00844011f, -0.06297373f, 
    -0.12332145f, 0.21346428f, 0.18840109f, 0.03607543f, 0.00962784f, 0.04702990f, -0.06181128f, 0.05280823f, 
    -0.03382152f, -0.11020558f, 0.07027359f, 0.05623955f, 0.09050157f, -0.22407793f, -0.03441826f, -0.04618805f, 
    0.00682579f, 0.04762710f, 0.03791722f, 0.15045473f, 0.06320121f, 0.06537992f, 0.03586056f, 0.23597138f, 
    -0.02683910f, 0.42934480f, 0.27634546f, 0.03177036f, 0.02072318f, 0.07899833f, 0.10181383f, -0.00481766f, 
    -0.04522055f, 0.00965832f, -0.07974850f, -0.16483079f, -0.03208338f, 0.04701391f, 0.20257457f, -0.01661033f, 
    -0.00271843f, -0.02153302f, -0.01330370f, 0.09820668f, -0.05374651f, 0.03591311f, 0.03743583f, 0.00769574f, 
    0.22102319f, -0.23762733f, -0.02545983f, -0.08265946f, 0.06534410f, 0.00342337f, 0.10598462f, -0.10215015f, 
    0.06609634f, 0.09621735f, -0.29208395f, 0.02015442f, 0.06424017f, -0.24468808f, -0.29901716f, 0.13842683f, 
    -0.03060342f, 0.10830212f, 0.00800056f, -0.05534293f, -0.02885999f, 0.08530916f, -0.25237378f, 0.07595324f, 
    -0.15478873f, -0.00651000f, 0.20860530f, 0.13785006f, 0.10538527f, -0.04747092f, -0.09384506f, -0.04389831f, 
    0.08872878f, 0.02824249f, 0.02118752f, 0.15850155f, -0.25329438f, 0.07723881f, 0.11313016f, 0.13200702f, 
    -0.12443604f, 0.22823842f, -0.05672343f, -0.01210196f, -0.00975785f, -0.09116659f, -0.18156445f, 0.11796805f, 
    0.10257437f, 0.26385722f, 0.02599253f, 0.05142770f, 0.03202539f, 0.13024497f, -0.05931839f, 0.02853363f, 
    -0.04943767f, -0.01436077f, -0.10873817f, -0.07413320f, 0.49395928f, -0.43838137f, 0.01129666f, -0.07553948f, 
    -0.02956547f, -0.03666695f, 0.19983247f, -0.24155737f, 0.13469474f, 0.01573511f, 0.15146267f, -0.03902117f, 
    0.12435959f, 0.32973021f, -0.15536867f, -0.27776414f, -0.26093879f, -0.29313114f, 0.08466849f, 0.23350494f, 
    0.08121317f, -0.01602555f, 0.00880574f, -0.03934850f, -0.05238773f, -0.06838866f, -0.20063193f, 0.10357505f, 
    0.03380415f, -0.00905857f, 0.02129442f, -0.05498891f, 0.09984786f, 0.21857610f, 0.11328294f, 0.11773930f, 
    0.20313656f, 0.36299917f, 0.32010999f, 0.30814892f, 0.03397441f, 0.08936712f, 0.12162486f, -0.06769740f, 
    -0.03813693f, 0.01863817f, -0.04197593f, -0.09373214f, -0.09416906f, -0.20507532f, 0.02058538f, -0.01132474f, 
    -0.00683061f, -0.05392480f, 0.03032992f, -0.04873849f, -0.12582584f, -0.07092601f, 0.20282128f, 0.20330018f, 
    0.21192226f, 0.30528525f, 0.12940277f, 0.20473543f, 0.05315934f, -0.00538596f, 0.03471898f, 0.08044363f, 
    -0.02624927f, -0.08913846f, -0.08109021f, -0.03517501f, -0.09230217f, 0.04071169f, 0.03733143f, 0.05961904f, 
    0.16261780f, 0.02463004f, -0.11324418f, -0.05520466f, -0.02513877f, 0.19823657f, -0.18888657f, 0.06946972f, 
    0.04415984f, -0.12741815f, 0.11164474f, -0.11535992f, 0.26563215f, 0.04168142f, -0.12720761f, -0.03797368f, 
    0.22603531f, 0.20162368f, 0.09783758f, 0.05357026f, -0.00186990f, 0.08678301f, 0.21326773f, 0.11199085f, 
    0.07776443f, -0.07892130f, -0.07895812f, 0.10252045f, -0.02770404f, -0.02851478f, 0.06403241f, 0.10339744f, 
    -0.10869519f, 0.15238754f, -0.09853455f, -0.35798728f, 0.12090537f, 0.03338439f, -0.00976001f, 0.11960505f, 
    0.06503498f, 0.09527142f, -0.12483018f, -0.10185437f, -0.20361492f, -0.07838509f, 0.18020709f, 0.16071945f, 
    -0.04703126f, -0.07824637f, -0.02486846f, 0.02386886f, 0.17080359f, -0.04768118f, 0.13690028f, 0.23941872f, 
    0.05676770f, 0.60535967f, 0.05090431f, -0.04246194f, 0.08054614f, -0.02641919f, 0.07625035f, -0.04191360f, 
    -0.07886378f, 0.10391914f, -0.04714992f, -0.01522890f, -0.11076974f, 0.02098621f, 0.05313653f, 0.22274107f, 
    -0.16702379f, -0.04738448f, 0.01794513f, 0.04651070f, 0.03802446f, -0.06586213f, -0.02604828f, -0.11729126f, 
    -0.03156578f, -0.08040818f, 0.12146395f, 0.23809196f, 0.21578015f, -0.02849758f, -0.05061863f, -0.03987677f, 
    -0.01414120f, 0.06816928f, 0.01556215f, 0.06701163f, -0.27764130f, 0.10916726f, 0.34192625f, 0.28127646f, 
    0.07696804f, -0.00717495f, -0.04023894f, 0.04254596f, 0.04424591f, 0.09160329f, -0.05541926f, 0.21971840f, 
    0.02950551f, 0.00774020f, -0.08838852f, -0.08870736f, 0.05270980f, 0.08324933f, 0.05098056f, 0.12888786f, 
    0.00002045f, 0.03430205f, -0.05789470f, -0.07530729f, -0.16046920f, 0.18346058f, 0.02288906f, -0.11215235f, 
    0.02639736f, -0.04893646f, -0.11023271f, 0.06883903f, 0.14866555f, 0.04133468f, 0.15941335f, 0.12860127f, 
    -0.17457591f, 0.03116424f, 0.22858380f, 0.09271803f, -0.05944222f, -0.01091059f, -0.08666688f, 0.11205804f, 
    0.00501397f, -0.05675943f, -0.02034570f, -0.10881858f, -0.23729345f, -0.17707922f, 0.09752857f, 0.24271230f, 
    0.00403092f, -0.04780427f, 0.02056479f, -0.00169423f, -0.00433842f, -0.06026690f, 0.03718990f, 0.06168117f, 
    -0.09361944f, 0.04307198f, 0.05560818f, 0.06707201f, -0.01683967f, -0.03444153f, 0.15444705f, 0.01687449f, 
    0.14867678f, 0.01814491f, 0.09892658f, 0.17944807f, 0.10133074f, 0.38153270f, 0.38201180f, -0.06671927f, 
    -0.09758722f, -0.00990923f, -0.06155471f, 0.03971048f, -0.17252697f, -0.00138961f, 0.00279208f, 0.06224525f, 
    -0.06516438f, 0.04576691f, 0.17297322f, 0.48724005f, 0.02667592f, -0.12305284f, -0.18247513f, -0.06412972f, 
    -0.00705372f, -0.03695705f, 0.05105134f, 0.07301909f, -0.03656180f, 0.35043323f, 0.17487924f, 0.03060134f, 
    -0.02189979f, -0.04781565f, -0.01082561f, 0.00749548f, -0.09370784f, -0.09015321f, 0.02920945f, 0.03669164f, 
    0.02675785f, -0.09057243f, -0.07649797f, -0.02161152f, -0.09173155f, 0.10487542f, 0.11215049f, 0.08843841f, 
    -0.02372387f, -0.05846949f, -0.00029113f, -0.15235566f, 0.13645965f, -0.21025838f, 0.00034282f, -0.08466137f, 
    0.03292327f, -0.05132920f, 0.01612326f, 0.01299426f, 0.13465054f, -0.06116191f, 0.07407283f, -0.01430314f, 
    -0.06438569f, -0.05631249f, 0.22135235f, 0.05292905f, 0.02353582f, -0.06893948f, -0.04627680f, -0.08341549f, 
    0.15645695f, -0.01432908f, 0.12660000f, 0.02762010f, -0.11967731f, 0.04592541f, 0.06313612f, 0.26880750f, 
    -0.03810009f, -0.03187531f, 0.02103947f, 0.02079836f, 0.01959978f, 0.00189130f, 0.00355778f, -0.08163917f, 
    -0.11793812f, 0.12384627f, -0.02950606f, -0.07795689f, 0.09190734f, 0.16421643f, -0.05271843f, 0.06324250f, 
    0.12512887f, -0.03925020f, 0.01573930f, -0.03512508f, -0.06735163f, -0.04226744f, 0.15980613f, 0.16985540f, 
    0.03025766f, -0.00402724f, -0.01425465f, 0.10347713f, 0.00989311f, -0.07454879f, 0.10541862f, 0.13771205f, 
    0.02906500f, -0.05194288f, -0.07738268f, -0.05463647f, 0.00508475f, 0.08277097f, 0.16521908f, 0.02282592f, 
    0.11780257f, -0.02081494f, -0.06627148f, -0.04368440f, -0.24131387f, -0.28833050f, 0.15810227f, 0.54874116f, 
    0.17004959f, -0.03078808f, 0.01644293f, 0.02810964f, -0.03115898f, 0.05929193f, 0.12159409f, -0.00616952f, 
    -0.22826330f, -0.18860354f, 0.01952087f, 0.10279214f, 0.06612973f, 0.08008958f, 0.00489631f, -0.04451913f, 
    0.02601853f, 0.01272375f, 0.09091867f, 0.08411779f, -0.16778526f, 0.21575890f, 0.25085682f, 0.04369296f, 
    -0.02167806f, 0.00212888f, -0.11918288f, 0.00314629f, -0.17217453f, 0.12434798f, 0.03945301f, 0.08777458f, 
    -0.14064734f, -0.12381699f, 0.16430256f, 0.16209728f, 0.05747071f, 0.07461894f, 0.08964896f, 0.11960182f, 
    0.05808979f, 0.02123269f, -0.03008037f, -0.03075219f, -0.00182370f, -0.14715792f, -0.10791412f, -0.11826705f, 
    0.01392122f, -0.04867734f, -0.01499183f, 0.04930166f, 0.04887411f, -0.07947151f, -0.04178647f, 0.03450809f, 
    -0.15037282f, -0.10141559f, 0.06115373f, 0.02824060f, -0.12784685f, -0.08502331f, -0.03320828f, 0.14958905f, 
    0.06578390f, -0.01759547f, -0.04127700f, -0.03289510f, -0.13537292f, -0.12398288f, -0.12120401f, 0.10162793f, 
    0.03286453f, 0.06791566f, -0.02561582f, 0.03930954f, 0.16651633f, 0.09955484f, 0.09046067f, 0.06967381f, 
    -0.29475549f, -0.03268450f, 0.33959025f, 0.12471911f, 0.01098247f, -0.18817793f, -0.05753872f, -0.05166615f, 
    0.20738229f, 0.12339431f, 0.10451321f, 0.07278728f, 0.21750408f, 0.32260406f, -0.11596857f, -0.20165494f, 
    -0.01548604f, -0.03640021f, 0.08718936f, -0.16075313f, 0.10827094f, 0.08496484f, 0.03173849f, 0.16693649f, 
    -0.12511663f, 0.27053556f, 0.06060524f, -0.05189068f, -0.04721038f, -0.05160913f, 0.04042170f, -0.07508218f, 
    0.00712622f, 0.21368662f, -0.02287773f, 0.07473747f, 0.08901060f, -0.00893686f, -0.06403977f, -0.04600141f, 
    0.03445077f, -0.00792615f, 0.10060752f, 0.11947183f, 0.04094609f, -0.07003789f, -0.06551760f, -0.05810684f, 
    -0.15448132f, -0.10206180f, 0.31252143f, -0.05381889f, 0.07507922f, 0.06184805f, -0.08521322f, 0.01551932f, 
    -0.04508520f, -0.05412023f, -0.07880658f, -0.06037401f, -0.18096398f, -0.06211985f, 0.07047978f, -0.08874488f, 
    -0.06528390f, -0.01392656f, 0.12989704f, -0.06095210f, 0.10905176f, 0.08350292f, 0.11583642f, 0.15503818f, 
    0.07164878f, 0.24136734f, 0.12969576f, 0.06660652f, 0.14365621f, -0.02663537f, 0.13105194f, -0.08819172f, 
    -0.07313855f, 0.12611303f, -0.06457467f, 0.06736184f, -0.09204122f, -0.10771783f, -0.08921974f, 0.40479979f, 
    -0.02043489f, -0.08144344f, -0.01017057f, -0.09775456f, 0.00756205f, -0.01183410f, -0.04863747f, -0.07736190f, 
    -0.06446125f, 0.04933036f, -0.04644400f, 0.23048915f, 0.01927650f, -0.00881223f, 0.10565319f, -0.12234411f, 
    -0.00648565f, 0.06719171f, -0.06280360f, 0.02745382f, -0.21503569f, 0.18094456f, 0.13877925f, 0.05351978f, 
    -0.04158517f, 0.08402554f, 0.10724936f, 0.07474907f, -0.07809519f, 0.06686230f, -0.09456403f, 0.00238197f, 
    0.10862175f, 0.00182971f, 0.02120844f, -0.15624118f, -0.00368718f, 0.08911482f, -0.31037340f, 0.25455815f, 
    -0.15432328f, -0.13184497f, -0.06057031f, -0.02813442f, -0.28388539f, 0.13232294f, -0.01529799f, -0.09157829f, 
    -0.00636939f, -0.02273242f, -0.18247272f, 0.06143260f, -0.06443944f, -0.10089371f, -0.03134821f, 0.19018970f, 
    -0.25962368f, -0.06147158f, 0.12977317f, 0.23758923f, -0.06706280f, 0.01659512f, -0.19376093f, -0.01509374f, 
    0.01156781f, 0.06374475f, -0.07874188f, -0.05739613f, -0.17380229f, -0.25403148f, -0.01063676f, 0.30049285f, 
    -0.01045721f, -0.01024931f, -0.00173274f, -0.16199978f, -0.01194648f, 0.05331431f, 0.06168267f, 0.14558139f, 
    0.02779680f, 0.03901425f, 0.02911092f, 0.05689926f, -0.03489864f, -0.04387864f, 0.25715613f, 0.07288767f, 
    0.14085786f, 0.06047396f, 0.04023949f, 0.25730771f, 0.04706077f, 0.14045942f, 0.10599763f, 0.21438794f, 
    -0.02247285f, -0.04718590f, 0.03562634f, 0.06783897f, -0.10104198f, -0.11436442f, 0.07534209f, -0.02977474f, 
    -0.10742816f, 0.14698932f, 0.04171491f, 0.17766593f, 0.06937602f, -0.06116547f, -0.01293025f, -0.05244601f, 
    -0.04333273f, 0.07351099f, -0.05084645f, 0.04814072f, 0.26900697f, 0.12419747f, 0.09599075f, 0.17929955f, 
    -0.02922310f, -0.05096326f, 0.02719562f, 0.05542583f, -0.02880022f, 0.01503782f, 0.01315583f, 0.06790375f, 
    0.06714087f, -0.08088686f, 0.12140360f, -0.05323531f, 0.02307414f, 0.09399796f, 0.06236193f, -0.09679131f, 
    -0.08608063f, 0.12144110f, 0.02284403f, -0.20981194f, 0.02375062f, 0.09819306f, 0.01417395f, -0.16353317f, 
    -0.10574432f, 0.03774275f, -0.04715429f, 0.05510206f, -0.02585586f, -0.06670184f, 0.06401318f, -0.09014214f, 
    0.08421966f, -0.40916821f, 0.11855257f, 0.30333370f, 0.05476778f, -0.04856063f, -0.07123724f, 0.01321736f, 
    -0.07514006f, -0.03475579f, 0.00250472f, 0.01932661f, -0.04604201f, 0.11696661f, 0.15078169f, 0.34175766f, 
    0.01119659f, -0.04046198f, -0.07956959f, 0.11800890f, 0.12201944f, -0.00236169f, -0.06213690f, 0.00109600f, 
    0.39606425f, 0.09199409f, 0.36258343f, -0.33552957f, 0.07369754f, 0.05310542f, 0.01035757f, 0.09620688f, 
    0.03616469f, -0.04708809f, -0.08130158f, -0.17532505f, -0.27462366f, 0.25314915f, -0.06061803f, -0.08630142f, 
    0.05633811f, -0.04384146f, -0.02178006f, 0.09718299f, 0.07672833f, -0.01921948f, 0.20657519f, 0.11531930f, 
    0.21603175f, -0.02886019f, -0.10429656f, -0.07590920f, -0.01259814f, -0.07705487f, 0.00221783f, 0.06748096f, 
    -0.02045789f, 0.13102037f, -0.08964375f, -0.19333693f, -0.33498016f, -0.01586102f, -0.00310815f, 0.19878060f, 
    0.07984734f, 0.11701773f, -0.09016312f, 0.00602525f, -0.10117585f, 0.10566016f, 0.24783352f, -0.03287899f, 
    -0.02158116f, -0.24278823f, -0.10627774f, 0.03889182f, 0.02380150f, 0.12571384f, 0.09139972f, -0.10333364f, 
    0.06380959f, 0.07308210f, 0.02352380f, 0.21264805f, -0.44181544f, 0.35971311f, 0.20159654f, -0.07216122f, 
    0.11560654f, 0.03106130f, -0.20073870f, 0.16915680f, -0.16690879f, 0.13289869f, 0.05719218f, 0.03826877f, 
    -0.23048578f, -0.13261543f, 0.21138003f, 0.51712501f, 0.16564497f, 0.10003453f, -0.07925250f, 0.02583332f, 
    -0.00131379f, 0.00066714f, 0.00630993f, 0.08727803f, -0.15486464f, 0.09977343f, -0.08559807f, -0.07797611f, 
    0.05016169f, -0.05623452f, -0.03736308f, 0.00888391f, -0.04641487f, 0.01395841f, -0.21559842f, 0.04807014f, 
    -0.00836508f, 0.06150679f, 0.00356892f, 0.09825744f, -0.04754505f, -0.05834395f, -0.22902551f, 0.00517965f, 
    0.06049041f, -0.02278270f, -0.00195477f, 0.03841421f, -0.11352946f, -0.04745368f, -0.08764075f, -0.28069580f, 
    -0.06264783f, 0.01065363f, -0.03839000f, 0.08255903f, 0.24505669f, 0.12341423f, 0.00657937f, 0.10078390f, 
    -0.13101050f, -0.19132039f, 0.01057936f, 0.05150138f, 0.01264365f, -0.23197046f, -0.05523962f, 0.02807536f, 
    0.08973708f, 0.14738345f, 0.11012885f, -0.02384415f, 0.30927610f, -0.04922043f, -0.06266028f, -0.06493174f, 
    -0.04418534f, -0.06012724f, 0.11554534f, -0.19868121f, -0.04652646f, -0.08261922f, 0.12580697f, 0.09391388f, 
    -0.15188947f, 0.16982315f, 0.14297344f, 0.24468213f, 0.12543672f, -0.08861130f, 0.07605948f, 0.06036025f, 
    -0.08154208f, -0.04621681f, -0.13752694f, -0.04131282f, 0.16694990f, 0.03383410f, 0.16628976f, 0.07549059f, 
    0.12850989f, 0.18111850f, 0.03282944f, 0.09038347f, -0.05455486f, 0.04380842f, 0.02935877f, -0.03748851f, 
    0.01943099f, 0.02722641f, -0.03139148f, -0.01348289f, -0.03105633f, -0.05862598f, 0.02675064f, -0.03168307f, 
    -0.04231995f, -0.04522720f, 0.01392426f, -0.00982703f, -0.05392736f, -0.01927244f, -0.02226393f, -0.02079448f, 
    -0.01841861f, -0.03256934f, -0.05717405f, 0.01909429f, -0.02099489f, 0.02208701f, 0.01124587f, 0.03968634f, 
    0.03793594f, -0.02976693f, 0.02204587f, -0.00231265f, 0.00802380f, 0.02145100f, -0.00833370f, 0.02698123f, 
    0.02345520f, 0.02821847f, 0.00042323f, -0.01446570f, -0.03737860f, -0.00732605f, -0.04640177f, -0.04662333f, 
    0.02410459f, -0.00360857f, 0.04042817f, 0.01564632f, 0.00585160f, 0.03639470f, -0.01062772f, 0.02267437f, 
    0.00817050f, -0.05679836f, -0.02670958f, 0.03268047f, -0.00035333f, -0.04377089f, -0.04828335f, -0.01106435f, 
    -0.04797257f, 0.04408732f, 0.01459650f, -0.00708564f, 0.01144514f, -0.01515138f, -0.02360775f, -0.05254247f, 
    0.02762834f, -0.03593585f, -0.01219305f, -0.02611796f, -0.04174218f, 0.01996613f, 0.01378221f, 0.02419605f, 
    -0.02512806f, -0.03594622f, -0.03308371f, -0.00582262f, -0.05033497f, 0.02095570f, -0.05299266f, 0.00639300f, 
    -0.02674696f, 0.04071442f, -0.01128840f, -0.00927136f, -0.02853091f, 0.02445153f, -0.00344638f, 0.04544927f, 
    0.01213710f, 0.01915524f, -0.06247119f, -0.02697956f, -0.04830410f, -0.01559108f, -0.01220581f, -0.04642054f, 
    -0.03440268f, -0.01240793f, -0.02648160f, -0.05969081f, -0.02181197f, 0.01772681f, 0.02534880f, 0.01847493f, 
    -0.02297559f, -0.03305260f, -0.02101430f, 0.00556169f, -0.04762517f, -0.01558330f, 0.02905132f, -0.01035781f, 
    0.03864416f, 0.02309378f, -0.03399747f, -0.00073900f, -0.00135785f, 0.01475052f, -0.01998479f, 0.02175001f, 
    0.00905667f, -0.02149468f, -0.01882805f, 0.03713894f, 0.01541471f, -0.04345032f, 0.01650070f, -0.04994677f, 
    -0.03575931f, -0.05064243f, -0.00831394f, 0.03172830f, -0.05382619f, -0.04667917f, 0.04242133f, -0.00253046f, 
    -0.05768507f, -0.01109021f, -0.01359826f, -0.03687993f, -0.01691601f, -0.02158832f, 0.01034360f, -0.04476541f, 
    0.01010993f, 0.03315736f, -0.02303424f, -0.04162395f, -0.04666818f, -0.02003449f, 0.03816465f, -0.02346116f, 
    0.01895617f, -0.05726583f, -0.03653990f, -0.03386475f, 0.03829395f, -0.01336826f, 0.01550457f, -0.01285819f, 
    -0.03567747f, -0.04654480f, 0.03919689f, -0.04742090f, -0.00723608f, 0.00248056f, -0.00298887f, 0.04169280f, 
    0.00916600f, 0.02611664f, -0.02026615f, -0.01602683f, -0.04941048f, -0.05200595f, 0.02661383f, 0.03616468f, 
    0.04706603f, -0.05245052f, 0.04179363f, -0.04417704f, 0.03760027f, -0.01613621f, 0.01075419f, -0.03640535f, 
    -0.02923896f, -0.01278453f, 0.05260167f, 0.03930383f, -0.02029767f, -0.01544003f, -0.00620411f, 0.01401037f, 
    0.00305488f, 0.00488107f, -0.01696541f, -0.03663220f, -0.01015039f, 0.00399103f, -0.05516301f, -0.03433514f, 
    -0.01486378f, 0.04380199f, -0.00563172f, -0.05533929f, -0.03576160f, -0.02536752f, -0.00218360f, -0.05682101f, 
    -0.00095432f, 0.00630455f, 0.02293573f, 0.02547162f, -0.01929373f, 0.04849409f, 0.03276204f, -0.00421657f, 
    -0.02286218f, 0.00837199f, 0.00129962f, 0.03423665f, -0.00394790f, -0.03879470f, 0.00643310f, 0.00554682f, 
    0.02052112f, 0.04128167f, 0.03652323f, -0.02732260f, -0.01490942f, -0.04083653f, 0.00509706f, -0.00256929f, 
    0.02829547f, -0.02646800f, -0.04992164f, -0.02384426f, 0.03560659f, 0.03282981f, -0.02867099f, 0.02423468f, 
    -0.04638392f, -0.03684931f, -0.00266099f, 0.03602698f, 0.00544120f, -0.00434964f, 0.01395031f, -0.04704598f, 
    -0.00399547f, 0.02999005f, 0.01387046f, 0.03474270f, -0.04555592f, 0.04814700f, 0.04267266f, -0.02506805f, 
    -0.00225311f, -0.05479434f, -0.00241687f, -0.03514975f, -0.00521587f, -0.02691195f, -0.02730521f, -0.01436539f, 
    -0.01910437f, -0.03500954f, -0.03712557f, 0.02466316f, 0.03227063f, 0.00107462f, 0.04333179f, 0.00383936f, 
    0.04572424f, 0.04544118f, 0.01022099f, 0.03037614f, 0.01442630f, -0.00758091f, -0.02752460f, -0.03334596f, 
    -0.02134510f, -0.04209665f, 0.02987690f, 0.01191399f, -0.00676207f, -0.01422777f, -0.00726285f, -0.04941871f, 
    0.01200576f, -0.05659588f, 0.02932720f, -0.03143548f, -0.01912042f, 0.02581847f, -0.03244771f, 0.03382203f, 
    0.03114332f, -0.00697989f, -0.02448938f, 0.00917983f, 0.00214687f, 0.00895891f, -0.04002836f, -0.05396238f, 
    0.04195519f, -0.01432069f, -0.04617573f, 0.03866668f, -0.04146167f, 0.03759229f, -0.04646328f, 0.03256396f, 
    -0.03037965f, -0.01423856f, -0.00879972f, -0.05042781f, -0.00062683f, -0.04712074f, -0.00440487f, 0.01454595f, 
    0.04549199f, 0.00072878f, 0.02450476f, 0.00206777f, 0.01602011f, 0.02378140f, 0.03995410f, 0.00288082f, 
    0.00097215f, 0.01958738f, -0.01531349f, 0.04306068f, 0.02781013f, -0.01221449f, 0.02499783f, -0.05226495f, 
    -0.01981368f, -0.00971090f, 0.03906446f, 0.04059788f, 0.01628748f, -0.01667823f, -0.04749078f, 0.01771183f, 
    -0.03630283f, -0.03496962f, -0.00731262f, 0.02468363f, -0.02428998f, 0.00387286f, 0.03157196f, -0.01283963f, 
    0.02220842f, -0.00488916f, -0.06126182f, -0.05023999f, -0.03141788f, 0.01194199f, -0.03175389f, 0.00444856f, 
    -0.02364247f, -0.04606936f, 0.01226781f, 0.01711895f, 0.03068810f, -0.00335714f, -0.04849115f, -0.00358028f, 
    0.01632335f, 0.03763013f, 0.04584169f, -0.04322127f, -0.04446854f, 0.03439457f, -0.04616092f, 0.02127926f, 
    -0.04405179f, -0.01113368f, -0.03376642f, -0.03782255f, -0.03775203f, -0.01291280f, -0.02547046f, 0.03499429f, 
    -0.18979812f, -0.14764670f, 0.13044843f, 0.21329036f, 0.05398058f, -0.17360385f, -0.07635941f, 0.11432234f, 
    0.10126615f, 0.01481014f, 0.08206707f, 0.11010193f, 0.15328591f, 0.06524557f, 0.00172294f, 0.07947692f, 
    0.05533361f, -0.06131974f, 0.06788308f, 0.07805249f, -0.07811290f, 0.17794055f, -0.17446944f, -0.14035966f, 
    0.09846043f, 0.08485928f, 0.02927119f, 0.43446404f, -0.10411379f, -0.09810112f, -0.20904924f, 0.02425206f, 
    0.09485424f, -0.00745539f, 0.06652288f, -0.01989494f, -0.12970239f, -0.26677281f, 0.05978574f, 0.17055684f, 
    0.10226834f, 0.21491891f, 0.07938243f, 0.14607701f, 0.00231598f, 0.01464958f, -0.05816319f, 0.07398603f, 
    0.26874506f, -0.01708785f, 0.07468534f, -0.15851349f, 0.06066275f, 0.07420114f, 0.05312099f, 0.14165083f, 
    0.00715543f, -0.06362610f, 0.01266211f, 0.05070297f, 0.17332837f, -0.16461305f, 0.16153708f, -0.01640487f, 
    0.06673434f, 0.15687424f, 0.01046467f, 0.02964176f, 0.07596253f, 0.02749371f, 0.03049839f, 0.04792252f, 
    -0.16296577f, 0.03915143f, -0.05939918f, -0.04942302f, -0.16130905f, 0.01806544f, -0.08352648f, -0.00219999f, 
    -0.02265488f, 0.08266499f, 0.11035295f, 0.10437168f, 0.04834298f, -0.04755193f, -0.13538447f, 0.14136499f, 
    0.14423855f, 0.06060468f, -0.04454624f, -0.06095239f, -0.06850062f, 0.05640608f, -0.12350165f, -0.12737179f, 
    -0.10559911f, -0.06251261f, 0.05237439f, 0.01232854f, 0.17361058f, 0.10070013f, 0.01419588f, -0.08456148f, 
    0.00739110f, 0.00806694f, 0.07917814f, 0.06528525f, -0.09853071f, 0.15334673f, -0.25741071f, 0.15306358f, 
    0.05723477f, 0.05298850f, 0.01838296f, 0.10817467f, -0.04590273f, -0.00521198f, -0.07655229f, 0.03627833f, 
    0.33281374f, 0.00790025f, 0.18446147f, -0.03728745f, 0.06885504f, -0.03851758f, -0.08687277f, 0.00901858f, 
    0.00259921f, 0.00476903f, -0.15503007f, -0.12093840f, 0.02701818f, 0.23384289f, 0.01531931f, 0.31792057f, 
    0.13922086f, -0.01640964f, 0.05153511f, 0.05544506f, 0.20218143f, -0.06015806f, 0.09492368f, 0.08640324f, 
    0.02803697f, 0.19343527f, 0.06155377f, -0.11410700f, 0.13797887f, 0.20064715f, 0.21985847f, 0.20228101f, 
    0.04019425f, 0.05659638f, 0.04935718f, -0.00047970f, 0.18317471f, -0.05450619f, -0.00352264f, 0.18573856f, 
    0.01882266f, 0.08935932f, 0.01607696f, 0.04236270f, -0.00034854f, 0.06649555f, 0.17019565f, 0.08726547f, 
    -0.17660095f, -0.07341905f, -0.13039486f, 0.08287618f, -0.04184738f, 0.16180027f, -0.05570461f, -0.07861587f, 
    0.08100663f, 0.09270414f, 0.20166601f, 0.10825470f, -0.30270204f, 0.15465921f, -0.05011744f, -0.06491377f, 
    -0.07742445f, -0.04246428f, -0.07033233f, -0.01939915f, -0.10476814f, 0.07075077f, -0.04775643f, 0.14576332f, 
    0.40083933f, -0.24390993f, 0.05646199f, 0.43405098f, 0.20371802f, 0.04074986f, 0.00422345f, -0.00011752f, 
    -0.03585421f, 0.04308535f, -0.01407434f, 0.09806463f, -0.01032305f, -0.00413369f, -0.07469929f, 0.04438189f, 
    0.12563536f, 0.13625497f, 0.16151546f, 0.28374377f, -0.13066249f, -0.01188945f, -0.09586982f, 0.02450526f, 
    0.39028645f, 0.32867834f, 0.05241964f, 0.07040067f, -0.01665361f, -0.07028534f, 0.07793169f, 0.12030076f, 
    -0.02867300f, 0.08526040f, -0.00127232f, -0.01734023f, 0.00617503f, 0.48721918f, -0.05848752f, -0.10811765f, 
    -0.16213946f, -0.01581898f, 0.03328772f, -0.07235923f, -0.09524574f, 0.12580346f, -0.06995974f, 0.01315841f, 
    -0.54426026f, -0.18790807f, -0.14956202f, -0.12685619f, -0.06629904f, -0.13713086f, -0.08098733f, -0.10285861f, 
    -0.00860196f, 0.00565218f, 0.00902219f, 0.06255528f, -0.13603045f, 0.35012355f, -0.02356075f, -0.19388537f, 
    -0.05165065f, 0.06871811f, -0.06693590f, 0.03340719f, -0.04127615f, -0.10855301f, -0.07895187f, -0.05843640f, 
    0.14971243f, 0.04650190f, -0.10592162f, 0.01423256f, -0.04741475f, 0.10226346f, 0.05328475f, 0.16362491f, 
    -0.00691872f, 0.09361233f, -0.06413797f, -0.05390907f, 0.12419850f, 0.13349748f, -0.18875115f, 0.02890003f, 
    0.13615237f, -0.03763726f, -0.13949612f, 0.07191940f, 0.11289804f, -0.15016648f, 0.05948212f, 0.03774114f, 
    -0.22369619f, 0.17804867f, -0.20813312f, 0.42089844f, 0.02425902f, 0.13227616f, -0.08651347f, 0.05535212f, 
    0.02502730f, -0.03682465f, -0.01076446f, 0.04359433f, -0.41133735f, 0.03517480f, 0.17621984f, -0.14038776f, 
    -0.02374293f, -0.04829376f, -0.14035991f, -0.02554337f, 0.04868982f, 0.02188038f, -0.05009977f, 0.09188913f, 
    0.07906952f, 0.25219572f, 0.10607211f, 0.26228747f, -0.15590303f, 0.15378554f, 0.17328976f, 0.07525532f, 
    -0.00843201f, 0.08671112f, 0.11853936f, 0.09206145f, -0.04872632f, -0.10072476f, 0.04781827f, -0.10273915f, 
    -0.05287683f, 0.02431665f, -0.03920238f, -0.06514230f, -0.01268118f, 0.04696734f, -0.03190763f, -0.03499726f, 
    0.05487212f, -0.18609753f, -0.10639606f, 0.19805220f, 0.17454094f, 0.02336504f, -0.05046078f, 0.13132228f, 
    -0.14415328f, -0.03956641f, -0.05224038f, 0.01350972f, 0.28590900f, -0.13734095f, 0.29972008f, 0.21959025f, 
    0.06082409f, -0.19649237f, -0.01857561f, 0.00213435f, -0.08447222f, -0.00933941f, -0.09732442f, 0.08769058f, 
    -0.10556234f, -0.14372410f, -0.00016561f, 0.10932127f, 0.04276969f, 0.01216723f, -0.05991856f, 0.20392220f, 
    -0.01940699f, -0.11343467f, 0.11079704f, -0.13452172f, -0.09154937f, -0.06329622f, -0.01394609f, -0.01072420f, 
    0.05019208f, 0.03286422f, -0.03086498f, -0.07475418f, -0.00321683f, 0.12085737f, 0.09120721f, 0.19070031f, 
    -0.01961855f, 0.03123096f, 0.01005208f, -0.02165117f, -0.04299088f, 0.01665262f, 0.00001916f, -0.00989813f, 
    0.02954903f, 0.02249385f, 0.02630804f, -0.05066852f, -0.00789533f, 0.02264988f, -0.01885414f, 0.00211593f, 
    -0.01591869f, -0.00264893f, -0.04839725f, 0.01330218f, -0.04184156f, 0.02505712f, -0.03947970f, -0.01902777f, 
    -0.04231343f, 0.01502027f, -0.03039083f, 0.04528715f, -0.01779753f, 0.01422503f, 0.00841249f, -0.03946340f, 
    -0.01577368f, 0.02951854f, -0.02172643f, 0.01291864f, 0.04862714f, 0.01976349f, 0.03413022f, 0.01757878f, 
    -0.03525387f, -0.04204557f, -0.05196881f, 0.03309460f, 0.00603912f, -0.03224396f, -0.01897485f, 0.02666396f, 
    -0.04930115f, 0.01210493f, -0.00419333f, 0.00974129f, 0.04001985f, -0.00676177f, -0.00918411f, 0.03883689f, 
    -0.01796813f, 0.03305729f, -0.03249548f, 0.01469458f, 0.04230342f, -0.00031588f, -0.02240772f, -0.05009262f, 
    -0.04410982f, 0.00012268f, -0.02887825f, -0.04533382f, 0.00102736f, 0.01713441f, 0.02638934f, -0.04092759f, 
    0.00529246f, 0.03365823f, 0.00324788f, 0.00679665f, -0.02471714f, -0.02809170f, 0.02129736f, -0.01854423f, 
    -0.03401501f, 0.00380645f, -0.03368493f, -0.01717311f, -0.04197077f, -0.01084910f, -0.03581150f, -0.03118980f, 
    0.01021116f, 0.03678021f, 0.00055259f, 0.00742559f, -0.03197939f, -0.02862011f, -0.02778766f, 0.01964121f, 
    -0.04958455f, 0.00755806f, -0.03087963f, -0.01331936f, -0.00671826f, -0.01995188f, -0.02688175f, 0.01181994f, 
    0.02802069f, -0.04639523f, -0.03893575f, -0.03829513f, 0.00030341f, -0.02864880f, 0.04255720f, 0.00095213f, 
    -0.05483244f, -0.00821143f, 0.00066397f, 0.03145678f, -0.04818653f, 0.03547108f, -0.03080490f, 0.03350580f, 
    -0.02966089f, -0.02559610f, -0.02983027f, 0.00008753f, 0.01172715f, -0.04846553f, 0.03249397f, -0.01989410f, 
    -0.03474480f, 0.03882436f, 0.02699533f, -0.02066615f, 0.00145163f, 0.03880768f, 0.03542034f, -0.03786867f, 
    0.00077148f, 0.02959662f, 0.03859984f, 0.01184414f, 0.03659988f, 0.02576728f, -0.01717933f, -0.01647815f, 
    -0.02404389f, 0.02925869f, 0.04443107f, 0.01228879f, 0.03241208f, 0.04194302f, -0.05260517f, 0.00497819f, 
    0.04526183f, -0.05560496f, -0.01591230f, -0.01906109f, -0.04860387f, 0.00684660f, -0.01545644f, -0.02110558f, 
    -0.04313768f, 0.03502847f, 0.01418989f, -0.00445055f, -0.02189511f, -0.00360613f, -0.04650506f, -0.00450398f, 
    -0.02295987f, 0.01637677f, -0.04510044f, -0.01505085f, -0.02157209f, -0.02683520f, 0.01707607f, -0.02421110f, 
    0.00147694f, -0.00350051f, 0.02177141f, -0.00688631f, -0.03391328f, -0.01786128f, 0.03597512f, -0.01955044f, 
    -0.02955593f, -0.05016902f, 0.04310800f, 0.02894557f, -0.03367374f, -0.04951481f, 0.02329126f, -0.05116095f, 
    -0.03487505f, 0.03985561f, -0.00011702f, -0.03904033f, -0.01872796f, 0.01352595f, -0.01550726f, -0.05242403f, 
    0.00781083f, -0.04347397f, -0.05077224f, -0.03024375f, -0.02490972f, -0.04597414f, -0.02308534f, -0.05292542f, 
    0.00557872f, -0.04778585f, 0.04131937f, 0.03760055f, -0.03229786f, -0.03288297f, -0.04935585f, 0.04140511f, 
    0.04012596f, 0.01608738f, -0.04820150f, -0.04170419f, 0.01890213f, -0.05069695f, 0.04044533f, -0.05144429f, 
    -0.02372864f, -0.04054524f, -0.02835902f, 0.03614200f, 0.02273603f, 0.03129968f, -0.02940254f, 0.04481984f, 
    0.03305034f, -0.04066467f, -0.01959854f, -0.02747166f, -0.02254292f, 0.02381178f, -0.05599255f, 0.01443061f, 
    -0.00705402f, 0.01749456f, 0.04404279f, 0.03966147f, -0.04335454f, -0.05547438f, -0.04567983f, 0.04026705f, 
    0.00720022f, 0.03112120f, 0.00852110f, -0.01873927f, 0.00728152f, 0.01342406f, 0.02645571f, 0.03539344f, 
    -0.04475595f, 0.03943814f, 0.03051529f, -0.04031541f, 0.04080332f, -0.04274568f, 0.04034929f, 0.04249055f, 
    0.00641503f, -0.04124265f, 0.02191771f, 0.03063173f, 0.01520207f, -0.03218857f, -0.04459106f, 0.03581196f, 
    -0.00454523f, -0.05649860f, 0.03341513f, -0.02847670f, -0.02699048f, -0.05646554f, -0.01299253f, -0.02184775f, 
    0.00850238f, 0.02060520f, -0.00928549f, -0.04702389f, 0.01050329f, 0.01490273f, 0.01878076f, 0.02198412f, 
    -0.01575666f, 0.02661512f, 0.00700963f, -0.04727910f, 0.01394519f, 0.00245340f, -0.03067036f, 0.01799275f, 
    -0.03607329f, -0.02299612f, 0.01007105f, 0.03580149f, -0.02743363f, 0.02883608f, -0.03206608f, 0.03258727f, 
    -0.04974956f, 0.03867052f, -0.03457703f, -0.04758877f, 0.01489658f, -0.00640478f, -0.01879849f, -0.03118082f, 
    0.04475364f, -0.02325911f, 0.02294470f, -0.00479680f, -0.01783390f, -0.03227798f, 0.00242681f, -0.00532516f, 
    -0.04758041f, -0.04655042f, -0.03092846f, -0.03922108f, -0.04837064f, -0.00670001f, -0.05164894f, 0.01970712f, 
    -0.01101759f, 0.01238215f, 0.04438346f, -0.01494211f, 0.01950685f, 0.00828781f, 0.01853363f, -0.01274845f, 
    0.03200170f, -0.02007184f, -0.00605083f, -0.02173883f, 0.04003964f, 0.00721864f, -0.01168785f, -0.04927616f, 
    -0.01894661f, -0.05568202f, -0.01625249f, -0.04054504f, -0.03182786f, -0.04970229f, -0.00958570f, 0.04063205f, 
    0.00558200f, -0.02035350f, -0.05447667f, -0.01751903f, -0.03834366f, -0.01560001f, 0.02283021f, -0.00603407f, 
    -0.03662265f, -0.00004365f, -0.02346377f, -0.03348869f, 0.00774610f, 0.00935309f, -0.04390017f, -0.04381319f, 
    -0.01293996f, -0.01862665f, 0.02489049f, 0.04268716f, -0.05283641f, -0.05271801f, -0.04649784f, -0.02623014f, 
    -0.03943057f, 0.02198993f, -0.00023242f, 0.00486340f, -0.00470449f, 0.04086852f, 0.03020811f, -0.01205494f, 
    -0.22228493f, 0.14709739f, -0.24462168f, 0.10762243f, -0.00221056f, 0.11284196f, 0.04785730f, 0.11251447f, 
    0.05305034f, -0.03171015f, 0.05488957f, 0.07645077f, -0.18169890f, -0.03552469f, 0.05635005f, -0.09987722f, 
    0.04614374f, -0.09840963f, 0.11612616f, 0.11962369f, -0.02801089f, -0.12317044f, 0.00636320f, 0.02591087f, 
    -0.14553693f, 0.16445155f, -0.52790934f, 0.11293033f, -0.06232829f, 0.00066888f, -0.04167205f, 0.23135646f, 
    -0.00938386f, -0.02731431f, -0.00055131f, 0.21808007f, 0.06830121f, 0.19800276f, -0.18195596f, -0.06375396f, 
    0.01686482f, 0.11367641f, 0.01233766f, -0.00687607f, -0.00055261f, -0.00448733f, 0.03541965f, 0.05293142f, 
    -0.01267754f, -0.27843857f, 0.16193244f, -0.10355030f, 0.10427083f, 0.31794840f, 0.08673075f, -0.10590235f, 
    -0.05767529f, 0.22054699f, -0.04825677f, 0.07053239f, -0.02749515f, -0.01558443f, 0.36041087f, -0.00266646f, 
    0.07577953f, 0.04217932f, -0.07180317f, 0.06991193f, 0.03835103f, 0.02876128f, -0.00313231f, -0.14984010f, 
    -0.05013689f, 0.05379857f, -0.05761053f, 0.06327266f, 0.15334950f, -0.07603669f, 0.08602266f, 0.05498954f, 
    0.17322667f, 0.09726669f, 0.02085440f, 0.04111200f, -0.09454356f, -0.16361535f, -0.16362770f, -0.05478780f, 
    0.03523394f, -0.01055433f, 0.20839466f, 0.13442262f, 0.07517451f, 0.06278972f, 0.00901198f, -0.00066717f, 
    0.00849618f, 0.09310400f, -0.12504493f, -0.20179546f, -0.09285866f, -0.02061184f, -0.05860488f, -0.04680175f, 
    -0.04699843f, -0.01476110f, 0.03107519f, 0.03773422f, 0.22669405f, -0.18945001f, -0.03020781f, -0.16870216f, 
    0.07810245f, 0.06477240f, -0.09417980f, -0.25153303f, -0.11319904f, 0.00249923f, 0.01383298f, 0.01487623f, 
    -0.25666338f, -0.10449996f, -0.17191002f, -0.08416940f, -0.11785015f, 0.00301918f, -0.03791166f, 0.07975770f, 
    0.01292489f, -0.09078861f, 0.05036957f, 0.03716341f, -0.06623645f, 0.23050383f, 0.12589714f, 0.12575082f, 
    0.05965350f, -0.03313912f, 0.01313720f, 0.03280053f, 0.01013559f, 0.10345070f, 0.19566436f, 0.02575092f, 
    -0.09549765f, 0.09945901f, -0.24997588f, -0.11131340f, -0.05241807f, 0.01543599f, -0.23641604f, 0.14784424f, 
    0.01959133f, -0.03210631f, -0.02986015f, 0.10954463f, 0.09770837f, 0.28479952f, 0.29760596f, -0.10189319f, 
    0.06978713f, -0.13681136f, 0.02046005f, -0.06664076f, 0.11473446f, -0.01636444f, 0.19812624f, 0.11020069f, 
    0.11522368f, -0.19871938f, -0.17027675f, 0.13207269f, -0.02829355f, 0.11260494f, 0.07967205f, -0.01237684f, 
    0.11409292f, 0.07197994f, -0.08742819f, 0.04150226f, -0.02155921f, 0.08025505f, -0.05483231f, -0.07441702f, 
    0.12346789f, -0.00829426f, 0.09370922f, -0.02541616f, 0.13811021f, 0.10496598f, 0.01637384f, -0.07356787f, 
    -0.17133135f, -0.31426132f, -0.35965434f, -0.31685227f, -0.08752392f, -0.03394159f, -0.06360502f, 0.04065574f, 
    0.12372644f, -0.06848731f, -0.03513438f, 0.15188451f, 0.37490878f, 0.17596798f, -0.30956680f, -0.23524174f, 
    0.00205366f, 0.08209448f, 0.11406979f, 0.01569773f, -0.03836929f, 0.01141138f, 0.00463870f, -0.05935569f, 
    -0.38052797f, 0.15238221f, -0.20204911f, 0.23461650f, -0.22102055f, 0.11756717f, -0.14820951f, 0.12221763f, 
    0.05077093f, 0.06790246f, 0.28341261f, 0.07210767f, 0.16018176f, 0.00166578f, 0.32506719f, -0.04084982f, 
    0.00785136f, -0.03181240f, -0.01493443f, -0.02792989f, 0.15787868f, 0.13606402f, 0.26851332f, -0.07725061f, 
    -0.00719228f, -0.11702126f, -0.30055293f, -0.08079048f, 0.05683167f, 0.09345366f, 0.23531263f, 0.00883579f, 
    0.06799380f, 0.07295929f, 0.00365281f, 0.05715068f, 0.46069869f, -0.19143564f, 0.13943008f, 0.01948503f, 
    0.05465331f, -0.19004753f, 0.01085733f, 0.09615963f, -0.00236734f, -0.04402689f, 0.11567676f, 0.04944970f, 
    -0.08737608f, 0.09777678f, 0.04944252f, -0.14766444f, 0.00242472f, 0.04744919f, 0.11352997f, -0.01880458f, 
    -0.01292299f, -0.13295837f, -0.04236680f, 0.05994216f, -0.34820193f, -0.00314063f, -0.09810436f, 0.14070427f, 
    -0.01893308f, 0.19342521f, -0.14248908f, 0.17808223f, 0.05475040f, -0.07749029f, -0.13680996f, 0.21656272f, 
    0.35470694f, -0.78961086f, 0.15913592f, 0.02290574f, 0.14376371f, 0.26598135f, 0.21589655f, -0.11768560f, 
    0.02199039f, -0.02122751f, 0.10917024f, 0.04366656f, -0.02952269f, -0.12037247f, 0.11630690f, -0.04725905f, 
    0.06720633f, 0.06601143f, 0.01546247f, 0.06074763f, 0.07292813f, 0.00777446f, 0.15005057f, 0.04009870f, 
    0.03677410f, -0.21005669f, -0.11958226f, -0.04403149f, 0.03265701f, -0.05469864f, 0.00560462f, 0.13999824f, 
    0.05081689f, -0.04626684f, 0.05342742f, 0.11959422f, 0.07368875f, 0.09162623f, -0.00445268f, 0.12340542f, 
    0.02000252f, 0.08393163f, -0.02309451f, 0.07238147f, 0.20209526f, -0.03655799f, -0.12170557f, -0.11614210f, 
    -0.09558719f, -0.08713058f, 0.06092319f, -0.33644351f, -0.01638306f, 0.13880830f, 0.04268287f, -0.12945753f, 
    -0.02964358f, -0.08621673f, 0.17536035f, -0.00784979f, -0.18661095f, 0.10316700f, -0.27855942f, -0.07691893f, 
    -0.07534292f, 0.10155381f, -0.01456167f, -0.00854649f, 0.09662666f, 0.11146932f, 0.07316196f, -0.08857612f, 
    0.10355040f, 0.23168153f, -0.16922094f, 0.03203265f, -0.04478114f, -0.04359788f, 0.15130378f, -0.04846967f, 
    -0.07843076f, 0.14321147f, -0.07572758f, -0.02256670f, 0.15992045f, 0.07750235f, -0.17164248f, -0.03156516f, 
    -0.03433172f, 0.03051406f, 0.05695056f, 0.10074911f, 0.13257858f, 0.02155587f, 0.02214829f, -0.01560269f, 
    -0.18895300f, 0.36928725f, -0.27000925f, 0.16411494f, 0.14549267f, -0.03812835f, -0.16595557f, -0.02675010f, 
    -0.07671084f, 0.09286316f, -0.22616915f, -0.08231697f, 0.02688606f, -0.14652781f, -0.06133381f, 0.13845724f, 
    0.03745553f, -0.00910687f, 0.15034929f, 0.18335553f, 0.15460163f, -0.06115229f, 0.06204117f, 0.18031888f, 
    -0.12737048f, 0.35063100f, -0.24667615f, 0.27430466f, -0.00778868f, 0.07055818f, -0.10623969f, -0.09521557f, 
    -0.01124443f, 0.13694127f, 0.13640426f, 0.02454110f, -0.15519278f, 0.07081880f, 0.07617574f, 0.20149775f, 
    -0.16983961f, 0.08985932f, 0.04766913f, 0.10742438f, -0.11779056f, -0.03919262f, -0.00322003f, -0.08431543f, 
    0.20202169f, 0.28505775f, 0.01395769f, -0.20313525f, 0.20263140f, 0.03000242f, -0.11434887f, 0.19235761f, 
    -0.01235447f, 0.06774826f, 0.02734625f, -0.00426177f, 0.08025784f, 0.04517199f, 0.14820242f, 0.02306415f, 
    0.12004238f, 0.06538083f, 0.04338229f, 0.26778996f, -0.02931960f, 0.00857070f, 0.07287603f, 0.07229001f, 
    -0.03932485f, 0.03482525f, -0.20012082f, 0.00551949f, 0.11214957f, -0.17250209f, 0.16011426f, -0.15061189f, 
    -0.17779328f, -0.00757383f, -0.23523319f, -0.27548656f, 0.00598473f, -0.01389155f, 0.00899360f, 0.15430443f, 
    -0.02958731f, -0.04331702f, 0.21006861f, 0.09624435f, -0.20971043f, -0.10552210f, 0.08784548f, 0.24880427f, 
    -0.16003743f, 0.15866293f, -0.20169088f, -0.15562181f, 0.05870001f, -0.10646112f, 0.16226542f, 0.19461726f, 
    0.03803361f, -0.02200176f, -0.08029335f, -0.01760035f, -0.09809150f, 0.23739189f, 0.14907928f, 0.10219456f, 
    0.11769010f, -0.08077325f, -0.06545299f, 0.04902888f, 0.00063846f, -0.06069233f, -0.03652317f, -0.05577363f, 
    -0.04958553f, 0.18153924f, -0.19473167f, 0.21177264f, -0.04588415f, 0.15379615f, 0.20591357f, 0.02936805f, 
    0.00988638f, 0.04983648f, 0.15430534f, 0.18542065f, -0.41103694f, 0.23340693f, -0.04986767f, 0.23317666f, 
    0.00627640f, 0.03550225f, 0.01785283f, 0.05799293f, -0.11219525f, 0.20127676f, -0.04874698f, 0.06399278f, 
    0.31737554f, -0.23994674f, -0.02941938f, 0.21182695f, 0.06831609f, 0.12732050f, -0.12651263f, 0.11135496f, 
    0.10214362f, 0.05113201f, -0.22827427f, 0.12737145f, 0.02640921f, 0.10364182f, -0.12135832f, -0.03198348f, 
    0.02145111f, -0.00913950f, 0.10981073f, -0.02435417f, 0.15794472f, 0.00374879f, -0.15313226f, -0.21756157f, 
    0.07064733f, -0.12850778f, 0.14979972f, -0.08626971f, 0.14816043f, -0.17521654f, -0.10107581f, -0.03786978f, 
    -0.19966920f, -0.11496212f, -0.15668947f, -0.27464658f, -0.07262766f, -0.17034626f, 0.00508042f, 0.01726326f, 
    0.05988010f, -0.08230052f, -0.22128561f, 0.02222532f, 0.29487148f, -0.05480126f, 0.13475092f, 0.06747878f, 
    0.00958746f, -0.14148396f, -0.00121733f, -0.06008219f, 0.12635277f, 0.04570197f, 0.13465302f, 0.12547679f, 
    0.06672081f, -0.09614297f, -0.01817226f, 0.25621966f, 0.14559606f, -0.30451286f, -0.02523427f, 0.16774212f, 
    0.03715063f, 0.19358467f, -0.08668970f, -0.08037975f, 0.08876713f, 0.03405518f, -0.13847499f, -0.14530168f, 
    0.12608388f, 0.39777228f, -0.38154736f, 0.23884533f, 0.17213871f, 0.00094889f, -0.10776830f, 0.06429058f, 
    -0.01354177f, 0.05723147f, 0.19531396f, 0.03861419f, 0.13579443f, -0.09592125f, 0.01198881f, -0.17801826f, 
    0.03576800f, -0.07355006f, -0.07441932f, 0.00612650f, 0.07544065f, 0.17099762f, 0.18887086f, 0.11258750f, 
    -0.24688917f, -0.14317527f, 0.11759208f, 0.05930851f, -0.12589948f, -0.05441447f, -0.14907594f, 0.05023282f, 
    0.08954101f, -0.07019327f, -0.10259004f, -0.08715438f, 0.47622335f, 0.05936815f, 0.16413032f, 0.00772280f, 
    0.10886043f, -0.04593255f, 0.05245584f, -0.02938394f, 0.02023492f, 0.12308259f, 0.11136947f, -0.02951557f, 
    -0.09674126f, 0.01661062f, 0.18420584f, -0.09512020f, 0.07587352f, -0.03932898f, 0.01733886f, 0.12939973f, 
    -0.00855070f, -0.02836834f, -0.09090013f, 0.10252071f, -0.35006389f, 0.17361628f, -0.15966791f, -0.03585857f, 
    -0.11025210f, 0.08442444f, 0.03119822f, 0.07231350f, 0.00639930f, 0.09397268f, -0.09821571f, -0.01500428f, 
    0.25481448f, 0.40707672f, 0.27601042f, -0.03460198f, -0.07221390f, -0.22103977f, 0.16170087f, 0.11235224f, 
    -0.06004974f, 0.14744787f, -0.07724234f, -0.00699579f, -0.00649180f, 0.02202089f, -0.08772294f, -0.20079045f, 
    -0.14494476f, -0.24554615f, -0.19688019f, 0.01438916f, 0.00550390f, -0.06856737f, 0.02613245f, 0.23760909f, 
    -0.02442336f, -0.20473206f, -0.09243141f, -0.01832806f, -0.10159628f, -0.06094662f, 0.04206446f, -0.10573284f, 
    -0.09207165f, -0.07022299f, -0.20377964f, -0.02652450f, 0.16998839f, 0.09212841f, -0.28370073f, -0.09302936f, 
    -0.00737841f, -0.07707330f, -0.08051421f, 0.04789106f, 0.15640467f, 0.02174489f, 0.07357370f, 0.00715245f, 
    -0.11969166f, 0.02461467f, 0.05848537f, 0.01312498f, 0.06736124f, 0.03389014f, 0.09903552f, 0.00570026f, 
    0.19377248f, 0.02436624f, 0.01436545f, 0.06114729f, 0.04604925f, 0.25007311f, -0.07827313f, 0.18747234f, 
    -0.04943735f, 0.19014108f, 0.10422118f, -0.04805980f, 0.09977828f, 0.14030932f, -0.01465630f, 0.28661653f, 
    -0.35711843f, 0.23353998f, 0.15379465f, 0.32345206f, -0.14539561f, 0.00534057f, 0.12870285f, -0.12829128f, 
    0.11982819f, 0.10189009f, 0.12147950f, -0.08384656f, -0.08209632f, 0.07180429f, 0.11070728f, 0.19039202f, 
    -0.01908717f, 0.00168689f, -0.03616001f, 0.01989189f, 0.00147595f, -0.31670392f, 0.00598669f, -0.28700799f, 
    0.02829687f, -0.01138411f, 0.13266006f, 0.02583589f, -0.11572243f, -0.00913041f, 0.14962788f, 0.03073864f, 
    0.07657279f, 0.10005105f, 0.12784788f, 0.11944770f, 0.33044085f, 0.08263507f, -0.00905226f, 0.07296288f, 
    0.14754564f, -0.04695924f, -0.01585644f, -0.03884370f, -0.02663677f, 0.09004965f, 0.01418919f, -0.19892541f, 
    0.13969180f, -0.07429857f, 0.06365895f, 0.03083625f, -0.12964647f, 0.04332922f, 0.09817608f, 0.10125490f, 
    0.13342610f, 0.02389163f, 0.20433407f, 0.06800843f, -0.12860437f, -0.12938997f, 0.07276794f, -0.15703422f, 
    -0.03265856f, 0.03629829f, 0.01516440f, 0.03116043f, -0.00799227f, 0.10126916f, 0.01913642f, 0.13861972f, 
    0.08373041f, 0.07467663f, -0.04471160f, -0.03052207f, -0.07963502f, 0.02664874f, -0.05072103f, 0.13687856f, 
    0.03739551f, -0.08168457f, 0.04051327f, 0.04340087f, 0.14628427f, -0.06581552f, -0.12042405f, 0.08535845f, 
    0.02702907f, 0.10128343f, -0.09563474f, -0.03447948f, 0.12989253f, -0.11083190f, 0.17481527f, 0.02051104f, 
    -0.03580976f, -0.03841369f, -0.00246762f, 0.05258743f, 0.13747482f, -0.00162312f, 0.22029053f, -0.12503110f, 
    0.05406338f, 0.11881851f, 0.19032431f, 0.03429372f, 0.31601143f, -0.01112786f, -0.09131890f, 0.15388595f, 
    0.08233926f, -0.05250617f, -0.04106073f, -0.03080966f, -0.00548944f, 0.06858888f, -0.08800006f, -0.18244976f, 
    0.07275865f, -0.12826094f, -0.09096342f, -0.12422696f, -0.03188970f, 0.09974036f, 0.13126637f, -0.00651114f, 
    0.02034614f, -0.05632443f, 0.00351173f, 0.07807701f, -0.09799615f, 0.11227994f, -0.19639106f, 0.05265728f, 
    0.01857245f, 0.05217085f, 0.03034972f, 0.17918082f, -0.01039432f, 0.04345445f, -0.00453389f, -0.00701665f, 
    0.14067972f, -0.07218022f, 0.09809922f, -0.01158605f, 0.07147203f, 0.16967121f, -0.05879109f, 0.09739867f, 
    -0.09120433f, 0.09744720f, -0.07824778f, -0.20617075f, -0.06102200f, -0.08843417f, 0.11051661f, 0.04227686f, 
    0.09413917f, -0.02648029f, 0.12621479f, -0.04269936f, 0.05527569f, 0.08603849f, 0.05526419f, 0.10085026f, 
    -0.01104151f, -0.04809010f, -0.02463781f, -0.19386762f, 0.10212190f, 0.01047945f, 0.03776087f, 0.02740109f, 
    0.01857121f, -0.08326461f, 0.15300049f, 0.04427185f, -0.16273721f, -0.24553758f, -0.05887017f, 0.00978870f, 
    -0.05582534f, 0.05323522f, -0.04121024f, 0.00025561f, -0.04160484f, 0.15911478f, 0.04888703f, 0.13579182f, 
    -0.17883928f, 0.08555682f, -0.04406190f, -0.03747551f, 0.12080523f, 0.03777250f, 0.11340065f, -0.01498435f, 
    0.07797424f, 0.00385708f, 0.08403076f, 0.16310605f, -0.06227051f, 0.26121610f, 0.14021839f, 0.18350352f, 
    -0.13544571f, -0.05352820f, 0.01418615f, -0.13042313f, -0.08740010f, 0.11086366f, -0.11308607f, 0.15088469f, 
    0.29423079f, 0.18185578f, -0.01029575f, 0.04295084f, -0.04092889f, 0.05578308f, 0.06696484f, 0.01373549f, 
    0.01781506f, 0.10102130f, -0.00013782f, -0.03022414f, -0.13098179f, -0.10644368f, -0.10929151f, -0.17033789f, 
    0.05974064f, -0.02307234f, 0.14699437f, 0.07618591f, -0.15932554f, 0.01424045f, 0.00465462f, 0.00017648f, 
    0.07513855f, 0.12791425f, 0.04258209f, 0.28949162f, -0.08487585f, -0.02628667f, 0.00405179f, 0.00553447f, 
    0.07540637f, 0.09706531f, 0.12425052f, 0.11024035f, 0.14801164f, 0.44045284f, -0.02048727f, 0.06551836f, 
    -0.02462525f, -0.00996097f, -0.09429833f, -0.17329998f, -0.12543158f, 0.05221880f, -0.05200790f, -0.05538065f, 
    -0.08291653f, 0.22468945f, 0.09589224f, -0.01178897f, -0.16308269f, -0.04253639f, -0.05548825f, -0.03553424f, 
    -0.00017786f, -0.09882727f, -0.06033515f, 0.02568431f, 0.22076821f, 0.27706322f, -0.22859173f, -0.26221722f, 
    0.12371047f, -0.02927908f, -0.04066633f, -0.11057825f, 0.18670344f, -0.08395121f, -0.03501650f, 0.05054698f, 
    0.00889311f, -0.04383828f, -0.14823093f, -0.05605789f, 0.16877057f, 0.12416160f, 0.08658227f, 0.08522923f, 
    0.00299080f, 0.07199573f, 0.03917100f, -0.10468293f, 0.26075771f, 0.02298191f, -0.02077487f, 0.06624548f, 
    0.00898092f, -0.10017525f, 0.16458988f, -0.06309409f, 0.05744014f, -0.14041035f, 0.08594115f, -0.06732807f, 
    -0.10138997f, 0.32344690f, -0.22936597f, 0.04612990f, 0.05366351f, 0.03340031f, 0.02518214f, -0.08479436f, 
    -0.08631972f, -0.17353001f, -0.09207263f, -0.01907431f, 0.08334017f, 0.20224394f, 0.15165788f, 0.08486122f, 
    -0.15662184f, -0.03950454f, -0.09213672f, -0.13582359f, -0.02366737f, 0.00202685f, -0.04327219f, -0.13472234f, 
    -0.00385432f, 0.06542302f, -0.07529113f, -0.09034973f, 0.00713702f, -0.04786457f, 0.13811313f, 0.16549040f, 
    -0.09311748f, -0.03278503f, 0.03069750f, 0.00198723f, 0.00350401f, 0.17944251f, 0.16255435f, 0.04416884f, 
    0.01682196f, 0.03377735f, -0.10021719f, -0.09429946f, -0.11991049f, 0.12739612f, 0.00723599f, -0.10824078f, 
    0.02443205f, 0.03745447f, -0.14022788f, 0.02552949f, -0.02825880f, 0.10595891f, 0.04762363f, 0.11346522f, 
    -0.13195457f, 0.04248624f, -0.05145430f, 0.10733844f, -0.09851167f, 0.09562626f, 0.36704171f, 0.05706682f, 
    0.10927100f, 0.05421693f, -0.01155992f, 0.28574872f, -0.04433407f, 0.12629183f, -0.05534609f, 0.11107145f, 
    -0.11502768f, -0.29734758f, -0.07248871f, -0.17349964f, -0.06491139f, 0.13983783f, -0.09887625f, 0.15334043f, 
    0.00981304f, -0.12247275f, 0.15575090f, -0.02337213f, -0.07436152f, -0.04654825f, -0.07549257f, 0.02423290f, 
    -0.04077531f, -0.06276189f, 0.13517515f, 0.02847430f, 0.01839996f, 0.03763870f, 0.02394510f, 0.13996126f, 
    -0.20265818f, -0.01555963f, 0.33251777f, 0.09009771f, 0.02833701f, -0.08816519f, -0.07609341f, 0.00881132f, 
    -0.01655385f, 0.12641536f, 0.11546836f, 0.10828367f, 0.28423688f, 0.00740948f, -0.01071348f, 0.13187778f, 
    0.04921371f, 0.01555447f, 0.15914482f, 0.02749721f, -0.09269183f, 0.11032689f, 0.00109901f, -0.11165507f, 
    0.38553905f, 0.00084614f, 0.15538432f, 0.52783662f, -0.01388077f, 0.02045034f, -0.05676094f, 0.15292348f, 
    0.12739179f, 0.04680573f, -0.00563298f, 0.11692323f, -0.19685458f, -0.27808842f, 0.05266035f, -0.01913638f, 
    0.05622233f, 0.03772471f, 0.08216662f, -0.12639287f, 0.05901383f, 0.04026439f, -0.09476899f, 0.09857411f, 
    0.09807685f, 0.08158488f, -0.14744395f, -0.18461709f, 0.00635776f, -0.03999621f, 0.07027552f, 0.15064061f, 
    0.03582869f, -0.05476002f, 0.04748545f, -0.04331463f, 0.10143688f, -0.13650487f, 0.15375009f, 0.05962231f, 
    0.13541453f, 0.14182577f, 0.11020610f, -0.02672920f, 0.07109517f, -0.02431806f, 0.20822813f, -0.03599672f, 
    -0.07506683f, -0.07053734f, -0.03231634f, -0.00354220f, -0.13723756f, -0.03179762f, -0.03218718f, -0.05837190f, 
    0.00980190f, 0.03638692f, 0.05707953f, 0.09024370f, 0.07285325f, -0.04804189f, -0.15195660f, 0.04908438f, 
    0.01760799f, 0.17724529f, 0.09325764f, -0.07217493f, -0.02419216f, -0.07409202f, -0.10822947f, -0.11638770f, 
    0.05761676f, -0.11485262f, -0.10485321f, 0.08938254f, -0.00175988f, 0.21744224f, 0.01631040f, -0.13374007f, 
    -0.03895147f, -0.10297449f, -0.01338150f, -0.00220575f, -0.09856814f, 0.16034819f, -0.26870015f, 0.09941974f, 
    -0.08593084f, 0.05790952f, -0.01948638f, -0.02067911f, -0.03673952f, 0.02440711f, -0.01358378f, 0.08001152f, 
    0.25415334f, -0.14815924f, 0.15601008f, -0.12169315f, -0.01943527f, 0.07495253f, -0.00021751f, 0.04835999f, 
    0.02247570f, 0.15158391f, -0.04910169f, -0.12630576f, -0.08722851f, 0.21070513f, 0.10381357f, 0.39591673f, 
    0.21312402f, -0.05966450f, 0.02983526f, -0.00106963f, 0.13034208f, -0.00771732f, 0.04014519f, 0.11403762f, 
    -0.06769431f, -0.03751943f, 0.04156502f, -0.13205621f, 0.12449279f, 0.17629968f, 0.17126232f, 0.12870586f, 
    -0.00481565f, 0.03407884f, 0.03590863f, 0.10258979f, -0.12378281f, -0.18632279f, -0.00365958f, 0.15001702f, 
    -0.02278355f, -0.00410581f, -0.05301429f, 0.05729420f, -0.00849783f, 0.07496591f, 0.03085645f, 0.03329261f, 
    -0.05912632f, -0.10119506f, -0.12267810f, -0.03614703f, 0.08313093f, 0.02439263f, 0.01558254f, 0.06176263f, 
    -0.02269770f, 0.10135127f, 0.16332647f, 0.09419506f, -0.37171960f, 0.25178194f, 0.08637326f, 0.01763731f, 
    -0.12109362f, -0.02238787f, -0.17798266f, -0.01950481f, -0.19663443f, 0.08911667f, 0.05933022f, 0.05285996f, 
    0.27070069f, 0.05700864f, 0.11262659f, 0.34414837f, 0.10065362f, 0.16159360f, -0.02253599f, -0.04364403f, 
    -0.19815557f, 0.09912989f, -0.02544587f, 0.08550540f, -0.19598448f, -0.28093055f, -0.12886772f, -0.14125440f, 
    0.05596097f, 0.07425401f, 0.05551172f, -0.03355659f, -0.09270828f, -0.03305948f, -0.11471253f, 0.01190389f, 
    0.40964240f, 0.17134500f, 0.07692191f, -0.02491818f, -0.02661678f, 0.02479383f, -0.08588349f, 0.10625693f, 
    -0.04183083f, 0.08563204f, 0.26897573f, -0.03806706f, -0.16654062f, 0.38622278f, -0.20249447f, -0.09357937f, 
    -0.08159517f, -0.06462301f, 0.00272884f, -0.00371636f, 0.02232683f, 0.13222674f, 0.07050945f, 0.18475267f, 
    -0.20241018f, 0.03152926f, 0.02649206f, -0.14250165f, -0.12773593f, -0.14386901f, -0.18060969f, -0.08891992f, 
    -0.15182155f, -0.14007357f, -0.11225271f, -0.02804460f, 0.10264339f, 0.31872398f, -0.44253123f, -0.14356814f, 
    0.09507598f, -0.10400742f, 0.09924868f, 0.08435494f, 0.08082800f, -0.07301876f, 0.10455893f, 0.13219692f, 
    0.10140818f, -0.17487818f, -0.21140599f, -0.16807944f, -0.07882424f, -0.02626444f, -0.08426046f, -0.02507344f, 
    -0.03061952f, 0.09452959f, 0.00868454f, -0.06541814f, -0.04452676f, 0.19812581f, -0.19982165f, 0.02954754f, 
    0.08725728f, -0.01338330f, 0.02011701f, 0.08347373f, 0.12158670f, 0.11403089f, 0.09161232f, 0.08274728f, 
    -0.33267477f, 0.58426088f, -0.20792735f, 0.30208403f, 0.09873286f, -0.04587580f, -0.00682094f, -0.13742571f, 
    -0.02795676f, -0.04195294f, 0.00189740f, 0.04443873f, -0.31032410f, 0.13744052f, 0.19939800f, -0.11917834f, 
    -0.01202296f, 0.02057485f, -0.14640360f, -0.06946025f, -0.03038594f, -0.06171119f, -0.08670542f, 0.03448918f, 
    0.01356897f, -0.03002977f, -0.06889145f, 0.03613623f, -0.02715722f, -0.01795731f, 0.11337692f, 0.10477825f, 
    -0.02317668f, 0.05998458f, 0.06392125f, 0.03090158f, -0.04178124f, -0.00450611f, 0.00744615f, -0.15720278f, 
    0.03267275f, -0.07208003f, 0.02377002f, -0.05631603f, 0.06894492f, 0.18579312f, -0.09453181f, -0.02552118f, 
    0.06413981f, -0.16267189f, -0.22603863f, 0.12161304f, 0.00608990f, 0.01792996f, -0.08918466f, 0.04811417f, 
    -0.24027810f, 0.01258459f, -0.02417276f, -0.08969416f, 0.31639561f, -0.20838900f, 0.31952223f, 0.12694900f, 
    -0.02148866f, -0.03011126f, -0.08258478f, 0.16133936f, -0.12782304f, 0.08798469f, -0.04323570f, -0.00375911f, 
    -0.09931143f, -0.28496110f, 0.00767221f, 0.11878916f, -0.00806753f, 0.09069534f, -0.04396723f, 0.08374833f, 
    0.03458020f, -0.20336306f, 0.08090934f, 0.00930109f, -0.08027793f, -0.18628342f, 0.01679986f, -0.06859586f, 
    0.05129720f, -0.06115470f, 0.06260792f, -0.15101086f, 0.02901883f, 0.21764483f, 0.05807513f, 0.12325709f, 
    -0.00208357f, -0.00461425f, -0.05399274f, 0.01853950f, -0.03196781f, -0.05523024f, -0.04859971f, -0.01785747f, 
    0.00562731f, -0.05061385f, -0.00757510f, -0.02206514f, -0.01712942f, -0.04452400f, -0.01665696f, -0.07202701f, 
    0.02173367f, -0.05132638f, -0.04029313f, 0.00038996f, -0.04085115f, -0.00721730f, -0.01600984f, -0.03852699f, 
    0.01032656f, -0.08267001f, 0.02472660f, -0.06945240f, -0.03616839f, -0.05352887f, 0.00454310f, -0.03970679f, 
    -0.00810241f, 0.00952397f, 0.00801433f, -0.07262214f, 0.01213669f, -0.03141860f, -0.04815407f, 0.00313872f, 
    -0.05658738f, -0.02555208f, 0.00274334f, -0.02318709f, -0.02348397f, -0.02750278f, -0.01684546f, -0.01204399f, 
    -0.02756606f, -0.05767383f, -0.03282077f, 0.01822463f, -0.04613503f, -0.05405873f, -0.07152348f, -0.03257528f, 
    -0.08529511f, -0.04641283f, -0.02568877f, -0.06235478f, -0.05746910f, -0.04024931f, -0.00404664f, -0.04354796f, 
    0.00071655f, 0.01628790f, -0.00930369f, -0.04926741f, -0.04707469f, -0.06267939f, 0.00381647f, -0.02410254f, 
    -0.00188836f, 0.03679586f, 0.00738015f, -0.05391838f, 0.03139009f, -0.04641426f, -0.03573330f, 0.00346315f, 
    -0.02493732f, -0.01736246f, -0.01582735f, -0.02760015f, -0.02058902f, -0.06372873f, 0.01674955f, -0.00634225f, 
    -0.00579100f, -0.05557510f, -0.05420076f, 0.01692078f, -0.05558683f, 0.00659440f, 0.00891756f, -0.07884552f, 
    0.01104385f, 0.02913691f, 0.01235740f, -0.00018891f, -0.00977514f, 0.01433556f, -0.00010109f, -0.03677531f, 
    -0.03781210f, 0.00461705f, 0.00472012f, -0.04536850f, -0.03599931f, -0.02400165f, -0.01198860f, -0.03339072f, 
    -0.01496251f, -0.02158630f, 0.02912353f, -0.01220826f, -0.01214275f, 0.00276740f, -0.04590155f, -0.00617092f, 
    -0.04537774f, -0.05211191f, -0.03898777f, -0.06218433f, -0.07414776f, 0.02300536f, 0.01091429f, 0.02486137f, 
    -0.02245612f, -0.05415348f, -0.03674148f, -0.01865625f, -0.07116190f, -0.00218444f, -0.01706550f, -0.07117552f, 
    -0.00080201f, -0.07042150f, -0.07874479f, -0.04419520f, -0.06946747f, 0.02537422f, 0.03036269f, -0.05126720f, 
    -0.06154675f, 0.00992395f, -0.05850602f, 0.00285556f, -0.04644735f, -0.01196483f, -0.01103663f, 0.02017415f, 
    -0.00769278f, -0.02982755f, -0.05336053f, -0.07027253f, -0.05711724f, -0.02286400f, -0.01345181f, -0.02443275f, 
    -0.05904176f, -0.01684549f, -0.02488956f, -0.02597855f, -0.01902566f, 0.01564517f, -0.06854633f, -0.00262068f, 
    -0.02198932f, -0.02091179f, -0.06432880f, 0.01955777f, -0.00147906f, -0.00712906f, 0.03034627f, -0.03756262f, 
    -0.01582452f, -0.05687768f, 0.01583721f, -0.04521628f, -0.05094361f, -0.07387833f, -0.02078177f, -0.03909012f, 
    -0.02721041f, 0.02143498f, 0.01296655f, 0.01957911f, -0.02002951f, 0.01681764f, -0.05238152f, -0.00598809f, 
    -0.06100649f, -0.04760745f, 0.01212128f, -0.02540250f, -0.01964358f, -0.06443790f, -0.06469703f, -0.02210972f, 
    -0.00239575f, -0.02417201f, -0.02504571f, -0.00166270f, -0.05073432f, 0.01080952f, -0.06395834f, 0.00931314f, 
    -0.06332625f, -0.06328950f, -0.05420649f, 0.00533133f, -0.00091602f, -0.03277881f, -0.03083627f, -0.04410255f, 
    -0.04854360f, -0.01535886f, -0.02822421f, -0.01526192f, -0.04042471f, -0.03460917f, -0.04983434f, -0.00350765f, 
    -0.06465971f, -0.04982270f, -0.02786942f, -0.00637975f, -0.07947065f, 0.01031504f, -0.02033185f, -0.03615202f, 
    -0.08315436f, -0.01501866f, -0.02964123f, -0.04984710f, 0.02252612f, -0.01389182f, -0.02275627f, 0.00689426f, 
    -0.03278257f, -0.03084328f, -0.01066673f, -0.05775360f, 0.01039308f, 0.03911356f, 0.01923604f, 0.00563197f, 
    -0.06185418f, 0.01773199f, 0.00361394f, 0.00108931f, 0.00081919f, -0.06013345f, 0.00728551f, -0.04231517f, 
    -0.01678861f, 0.02146916f, -0.04592829f, -0.05018140f, -0.06493707f, -0.07956321f, -0.05319280f, -0.06557999f, 
    0.00428467f, 0.02531538f, -0.00893390f, -0.01456465f, -0.05942096f, -0.06100332f, -0.01394485f, -0.01179520f, 
    0.01583325f, -0.00406537f, -0.00764010f, -0.06611597f, -0.05604816f, -0.05010385f, -0.01181177f, -0.04334013f, 
    -0.07189545f, -0.06293447f, -0.06944967f, -0.03996619f, -0.01476821f, 0.02413510f, 0.01471644f, -0.04308397f, 
    -0.01006870f, 0.03215272f, 0.00398109f, 0.00031331f, -0.00031945f, -0.04240615f, -0.07271164f, 0.01656470f, 
    -0.00030377f, -0.08899627f, 0.00912495f, -0.06252177f, -0.02173407f, -0.02893908f, -0.04426590f, 0.01116049f, 
    -0.01935372f, -0.05318990f, -0.01121241f, -0.02348452f, 0.02719620f, 0.01435387f, 0.01428681f, 0.00598065f, 
    -0.00437346f, -0.00255155f, 0.01400170f, -0.01792032f, -0.01515587f, -0.03369018f, -0.05595614f, 0.04519011f, 
    -0.07563565f, -0.03529880f, -0.07321071f, -0.06510197f, -0.01253626f, -0.04863227f, -0.04262767f, -0.04127245f, 
    -0.04994541f, -0.04002036f, 0.01475193f, -0.01289040f, -0.06193622f, 0.03727353f, 0.03310901f, 0.00633962f, 
    -0.04422693f, -0.01554384f, 0.01446418f, -0.01047169f, -0.04333613f, -0.02739307f, -0.00837169f, -0.00504188f, 
    -0.08638440f, -0.03567480f, -0.00706823f, -0.05590334f, -0.03980415f, -0.03992724f, -0.03298201f, -0.00800115f, 
    -0.08015582f, 0.00059581f, -0.00850814f, -0.05201436f, -0.00859082f, -0.00499516f, 0.02387642f, -0.06106902f, 
    -0.02284970f, -0.03421825f, -0.02633316f, -0.01943339f, -0.02700277f, -0.05627827f, -0.07569883f, -0.00051872f, 
    0.01855025f, -0.05018431f, 0.00708420f, -0.03251059f, 0.01558014f, 0.00115668f, 0.00024776f, -0.06172726f, 
    -0.04903068f, -0.04161179f, -0.05736149f, -0.01590879f, -0.06351804f, -0.02653466f, 0.00294375f, -0.00529956f, 
    0.01354807f, -0.00438913f, -0.05353593f, 0.04078289f, 0.04232283f, 0.00989577f, 0.02524575f, -0.00856038f, 
    0.02047670f, -0.03879410f, 0.00188678f, -0.02886178f, 0.00982967f, -0.00638835f, 0.02954202f, 0.01640979f, 
    -0.03719997f, 0.02315367f, 0.03992558f, 0.02979043f, -0.01921795f, -0.05390107f, 0.03494430f, -0.01452154f, 
    -0.02490505f, -0.00848513f, 0.04234403f, -0.04297582f, -0.04135364f, 0.03854864f, -0.02083505f, -0.01542584f, 
    -0.01147550f, -0.01746810f, -0.03262405f, -0.01422155f, 0.01816959f, -0.02841506f, -0.02386458f, -0.04432302f, 
    -0.04138239f, 0.03467042f, 0.01009527f, 0.02606479f, -0.04990590f, -0.04648027f, -0.05809617f, -0.05570562f, 
    -0.04994638f, 0.01114385f, -0.01178468f, -0.04272040f, 0.00539037f, -0.03177190f, -0.04450645f, -0.05063313f, 
    -0.05118239f, -0.00006304f, -0.03578694f, 0.01220128f, -0.01964563f, -0.00975874f, 0.04809966f, -0.03228556f, 
    -0.02392667f, -0.00817943f, -0.01104324f, -0.00995467f, 0.01735532f, -0.03168674f, -0.04224955f, 0.01064063f, 
    -0.03477606f, -0.03523307f, 0.00379240f, -0.01977010f, 0.03966947f, -0.01663584f, 0.00921976f, 0.04109877f, 
    -0.03837848f, -0.05492200f, -0.03055439f, 0.03761362f, -0.04809537f, 0.00294745f, 0.00514752f, -0.00490664f, 
    0.01313375f, 0.00217920f, 0.01250547f, 0.01271143f, 0.03767593f, -0.04833868f, -0.04532694f, -0.01722388f, 
    -0.05650131f, 0.00237440f, 0.02657747f, 0.02622476f, 0.02383006f, -0.05205681f, 0.00875566f, -0.03478045f, 
    -0.02744992f, -0.00543755f, 0.02864943f, 0.02315122f, -0.00507602f, 0.03747794f, -0.01610531f, -0.03568817f, 
    -0.01329691f, -0.00600410f, -0.02778624f, -0.03597595f, 0.02640309f, 0.02271209f, 0.01943401f, 0.02842112f, 
    -0.01673130f, -0.04446937f, 0.01133128f, -0.03321111f, -0.00257518f, 0.02108264f, 0.03244705f, 0.01214904f, 
    0.02076739f, -0.00740150f, 0.00019327f, -0.00388407f, -0.02896798f, 0.03239328f, -0.01653543f, 0.03820371f, 
    -0.03540601f, -0.03093336f, 0.01647903f, -0.02372663f, -0.05776627f, -0.04198108f, -0.00818515f, -0.05036053f, 
    0.00427835f, -0.02646834f, -0.04759286f, -0.04282143f, 0.02513999f, 0.02482355f, 0.02149125f, -0.01656645f, 
    -0.02300715f, 0.02190907f, -0.01132645f, 0.02469387f, 0.00012202f, -0.03387308f, -0.02911020f, 0.02015443f, 
    0.01427559f, 0.00334376f, -0.05607261f, -0.04234670f, -0.03693402f, -0.03842499f, 0.02765752f, -0.00046343f, 
    -0.04828956f, 0.00536169f, -0.04959039f, -0.03566329f, 0.01002238f, -0.05155133f, 0.03929964f, 0.00518280f, 
    -0.03100606f, -0.02952772f, -0.00163209f, -0.00902883f, -0.05571673f, -0.00260238f, -0.04526055f, -0.04400088f, 
    0.02275796f, 0.04109094f, 0.00087846f, -0.03043862f, -0.05236770f, 0.04023523f, -0.04130964f, 0.01026460f, 
    0.01775968f, 0.00229406f, -0.03983150f, 0.03098122f, -0.05044248f, -0.01131953f, 0.01168822f, 0.03119925f, 
    -0.04162741f, -0.04492176f, -0.04105210f, -0.03301666f, -0.02050796f, 0.04120382f, -0.04781687f, -0.04652307f, 
    -0.03375640f, 0.04167786f, -0.05789043f, 0.03938644f, -0.03041682f, 0.03534424f, -0.03080712f, -0.03049682f, 
    -0.02319987f, 0.04888199f, 0.02644436f, -0.03975455f, -0.01896802f, -0.01689355f, 0.02374364f, 0.04170094f, 
    -0.01849150f, -0.00288091f, 0.02730472f, -0.04621397f, -0.05527082f, 0.02994249f, 0.03070357f, 0.00850883f, 
    -0.01772168f, 0.02077850f, 0.01698221f, -0.05484559f, 0.02822432f, 0.00214134f, -0.03290937f, 0.00923266f, 
    -0.04780486f, 0.00682130f, 0.02597912f, 0.01382792f, 0.03568374f, 0.03729792f, -0.03661800f, 0.00680007f, 
    -0.01668169f, 0.00655128f, -0.01190923f, 0.03096304f, 0.03717704f, 0.00118825f, -0.03562122f, 0.03288502f, 
    -0.04587072f, -0.05495764f, -0.02483735f, 0.03389612f, -0.04273086f, 0.03160878f, -0.02669348f, -0.04456062f, 
    -0.04564904f, -0.05213879f, -0.03558924f, -0.01090330f, 0.00026377f, -0.05341745f, 0.01367122f, -0.02392753f, 
    -0.03726583f, -0.01875628f, -0.01732362f, -0.01126788f, -0.01917024f, 0.02115833f, 0.00946309f, 0.00713432f, 
    0.00463512f, 0.04081498f, -0.03295418f, -0.01089297f, -0.05645349f, -0.00835672f, -0.02115489f, 0.02619001f, 
    -0.05518791f, -0.05564056f, -0.01841488f, 0.01011837f, 0.00306502f, -0.02340144f, 0.01405580f, 0.02909152f, 
    -0.03023983f, -0.01399359f, 0.00341317f, 0.02844384f, 0.01800594f, 0.00279433f, -0.00573678f, -0.01465090f, 
    -0.03759740f, -0.01543698f, -0.02444421f, -0.00184101f, 0.02045904f, -0.01080739f, -0.05063975f, -0.04844123f, 
    -0.00496945f, -0.03145324f, -0.02761563f, 0.00580101f, 0.01564534f, 0.01405765f, -0.02677745f, 0.04613934f, 
    -0.04351858f, -0.04900218f, -0.05323953f, -0.04200038f, -0.04188377f, 0.00739478f, 0.03833297f, 0.02677649f, 
    0.00809328f, -0.00608435f, -0.02593767f, 0.01117604f, 0.02755299f, 0.01062175f, -0.01554359f, 0.02629722f, 
    -0.01625100f, -0.00091360f, -0.02308710f, -0.02225750f, -0.00205269f, 0.02949560f, -0.01789525f, -0.02173144f, 
    -0.03051007f, -0.04786228f, -0.01508311f, -0.03883301f, -0.01379578f, -0.02835117f, -0.02375791f, -0.02857899f, 
    0.02503452f, 0.00443299f, 0.03938532f, -0.04873226f, -0.04782558f, 0.02081881f, 0.03196147f, -0.00429650f, 
    -0.01701657f, 0.00876150f, 0.02746956f, 0.04137865f, -0.02373766f, -0.01789841f, 0.02708376f, 0.03860094f, 
    0.02975221f, -0.00602331f, 0.01787477f, 0.03049026f, 0.02776506f, -0.03642755f, -0.00737134f, 0.03306536f, 
    -0.00356633f, -0.02738553f, 0.03994044f, -0.02616892f, -0.04851230f, -0.03922009f, 0.02998547f, -0.00846104f, 
    -0.02984384f, -0.01868273f, -0.04975657f, -0.03113487f, 0.02357783f, -0.02407037f, -0.05546212f, 0.01420918f, 
    -0.00100780f, -0.02820511f, -0.00201575f, -0.00510161f, 0.00872137f, -0.00515590f, 0.03592224f, 0.02413936f, 
    0.01771010f, -0.02735843f, -0.01299651f, -0.02052783f, 0.01724751f, 0.02215216f, -0.00729516f, 0.02061371f, 
    -0.04934868f, -0.02182303f, -0.03318711f, -0.05570382f, 0.04631480f, 0.01785835f, -0.03506797f, 0.03550344f, 
    0.00666357f, -0.00167482f, 0.01312990f, -0.04791529f, 0.01355231f, -0.04879868f, -0.00839501f, -0.02189829f, 
    0.00117477f, 0.01844718f, 0.02463639f, -0.03850938f, 0.02956535f, 0.00509175f, 0.04054762f, 0.01902639f, 
    -0.02639963f, 0.03129303f, 0.04380779f, -0.05552466f, -0.02570840f, -0.03400510f, -0.04887815f, 0.00429256f, 
    -0.00355827f, -0.02948773f, -0.04539061f, -0.02750225f, 0.00381248f, -0.01489417f, 0.01049881f, 0.03220821f, 
    0.00715020f, 0.01352145f, -0.02836363f, -0.04492166f, 0.03017066f, 0.01152229f, -0.05680742f, -0.01748668f, 
    -0.03465950f, -0.04822341f, -0.05260094f, -0.01561945f, -0.04395844f, -0.03753856f, 0.04042065f, 0.02940011f, 
    -0.02463829f, -0.03679654f, -0.04022714f, -0.01803908f, -0.04707696f, -0.04807485f, -0.02982116f, 0.02698117f, 
    -0.01558096f, 0.01871499f, -0.03002052f, 0.02837370f, 0.04094034f, 0.01054105f, 0.01462915f, -0.05366387f, 
    0.02263681f, -0.04810013f, -0.02146177f, 0.00151380f, -0.05305225f, 0.02277373f, -0.01513424f, 0.00536287f, 
    -0.02154360f, -0.02455035f, -0.03857117f, -0.01971782f, 0.04075614f, -0.03561999f, 0.03403858f, 0.02645456f, 
    -0.05528317f, 0.03870617f, 0.04235724f, 0.03219646f, -0.04216766f, 0.01585639f, -0.01496395f, -0.04581767f, 
    0.00636373f, 0.00049765f, -0.03135323f, -0.00417519f, -0.04269620f, -0.01380987f, -0.04730110f, 0.04192992f, 
    0.01435695f, -0.02724795f, -0.02494695f, -0.05324715f, -0.05077376f, 0.00824940f, 0.03299810f, 0.04264652f, 
    0.01602326f, 0.00449570f, -0.02628386f, -0.01789483f, -0.00138757f, 0.02038848f, -0.02534837f, -0.00030708f, 
    0.04080976f, -0.04298922f, -0.04166384f, -0.02962283f, -0.01998059f, 0.01955200f, 0.02194428f, 0.00663523f, 
    0.00289449f, -0.01509586f, 0.01323899f, -0.00016101f, 0.01010907f, -0.04148001f, -0.03823557f, -0.00509380f, 
    -0.00048453f, -0.00880309f, -0.01579781f, -0.03546227f, -0.03115790f, -0.00782157f, 0.02832270f, 0.04064013f, 
    -0.03271000f, -0.03215429f, -0.02175139f, -0.03984126f, -0.01416713f, -0.04098475f, 0.01470983f, -0.01873825f, 
    -0.03252832f, -0.00642470f, 0.02828170f, 0.03083659f, 0.03535117f, -0.03052661f, 0.02755805f, -0.03717328f, 
    0.04124143f, -0.02068327f, 0.04085818f, -0.01629986f, -0.00628977f, -0.04544787f, 0.03686023f, 0.01560272f, 
    0.02803445f, 0.01969025f, -0.01273504f, -0.04319671f, -0.01565664f, -0.04441267f, -0.05313179f, 0.02523430f, 
    -0.00746651f, 0.02170487f, 0.02749477f, -0.03277990f, 0.02686233f, 0.01996775f, -0.05700377f, -0.01178018f, 
    -0.00156020f, 0.02817452f, -0.01145728f, -0.00311339f, -0.00291319f, -0.04559713f, -0.04378314f, 0.04366281f, 
    -0.02288475f, 0.01150120f, -0.05024000f, 0.02379199f, -0.03564066f, -0.01312967f, 0.04328523f, -0.00082160f, 
    0.03145451f, -0.03821252f, -0.02390903f, 0.02816049f, 0.01236297f, -0.03876613f, 0.00991552f, 0.00087382f, 
    -0.00878816f, -0.05282779f, -0.03145608f, -0.01497470f, -0.04052553f, -0.05102549f, -0.00122861f, 0.00615529f, 
    -0.03217103f, 0.04282947f, -0.03467468f, 0.01260841f, 0.00111166f, -0.04381782f, -0.04518927f, -0.02337513f, 
    0.00397641f, -0.00667545f, -0.03285652f, 0.00733202f, -0.02855757f, 0.04191343f, 0.03736957f, 0.00317737f, 
    -0.00326340f, 0.03359219f, -0.04635886f, 0.04140222f, 0.01493027f, 0.02496756f, -0.00308117f, -0.03063228f, 
    -0.02644320f, -0.01665059f, -0.03405751f, -0.01465608f, -0.00605488f, 0.04201053f, 0.04482464f, 0.03670203f, 
    0.01871208f, -0.02556432f, 0.04012229f, -0.03979357f, -0.02009578f, 0.00234547f, -0.00501460f, -0.05231286f, 
    -0.04994603f, -0.01349150f, -0.02998515f, -0.03559737f, 0.01059976f, -0.00074867f, 0.00045286f, 0.00374345f, 
    -0.03961872f, 0.00173700f, -0.01312687f, 0.00119381f, 0.03785817f, 0.02148049f, -0.04988360f, -0.02636702f, 
    -0.02668243f, -0.05696623f, 0.04126438f, 0.00214833f, -0.03951211f, -0.01589228f, -0.00252608f, -0.00566301f, 
    -0.05043028f, -0.03375884f, -0.00414158f, 0.00731175f, 0.00619676f, 0.03017633f, 0.01701926f, -0.04927208f, 
    0.00254205f, -0.00586918f, 0.00267320f, 0.01550633f, -0.05320393f, -0.04679049f, -0.02349996f, -0.02405987f, 
    -0.01016862f, -0.03029720f, 0.01500063f, 0.01376409f, 0.02106758f, 0.01401641f, -0.03935620f, 0.03215948f, 
    -0.00227313f, 0.01475445f, -0.01775488f, 0.01153708f, -0.00714443f, -0.04336443f, 0.03292491f, -0.02736733f, 
    -0.01078249f, 0.02537243f, 0.01665973f, 0.03444693f, 0.00925132f, -0.03573614f, 0.01087889f, 0.01509065f, 
    -0.02125372f, -0.04398463f, -0.00763068f, -0.03542294f, 0.03970317f, 0.02527861f, -0.01136170f, -0.00725359f, 
    -0.01662261f, -0.03196236f, -0.00752654f, -0.04907142f, -0.04633069f, 0.03419707f, 0.03363783f, -0.00136003f, 
    -0.05694343f, -0.04080810f, -0.00807677f, -0.01689800f, -0.03302315f, -0.03466442f, 0.04436555f, -0.01104247f, 
    0.03521110f, -0.00209301f, -0.03974224f, -0.02337619f, 0.00098294f, 0.02443333f, 0.00132886f, 0.03575600f, 
    -0.02877025f, -0.02702607f, -0.01360400f, -0.01057651f, -0.03964704f, 0.03370924f, -0.02372328f, -0.05291736f, 
    -0.04543709f, 0.01924574f, -0.03044165f, -0.02461686f, -0.02363735f, -0.02413364f, 0.02340673f, 0.01727299f, 
    0.04316159f, 0.02010164f, 0.01081518f, 0.01621565f, 0.03713143f, -0.01345609f, -0.00089778f, -0.04587772f, 
    0.01490542f, -0.03458729f, -0.03616685f, -0.03527826f, 0.00788034f, -0.04658855f, 0.01731767f, 0.01955050f, 
    -0.01994535f, -0.05334645f, -0.05138424f, -0.01824792f, -0.02826087f, 0.03428783f, -0.02861130f, 0.03935968f, 
    0.00605853f, -0.01849861f, 0.04605177f, -0.00440387f, -0.02657160f, 0.00140531f, -0.00812819f, -0.03148145f, 
    0.04286068f, -0.00729759f, -0.03057435f, 0.00015942f, 0.03438852f, -0.02581192f, 0.00541132f, 0.04055810f, 
    -0.03031981f, -0.03488036f, 0.01723952f, -0.04508162f, -0.01228237f, 0.01199226f, 0.01515828f, 0.01449263f, 
    0.03093724f, -0.05559634f, 0.00577318f, 0.00631630f, -0.01918596f, 0.03216338f, -0.04513120f, -0.03994340f, 
    -0.03439527f, 0.04052600f, -0.02914462f, 0.02323078f, 0.00367915f, 0.04318507f, -0.03025858f, -0.04910976f, 
    0.00118674f, -0.01855201f, 0.01456263f, -0.00769470f, -0.04133137f, -0.05372534f, 0.04359550f, 0.04232789f, 
    -0.05064330f, 0.04264474f, -0.05669975f, 0.02202205f, -0.01745279f, 0.00984131f, 0.01984697f, 0.00905632f, 
    -0.04792110f, 0.03674701f, -0.00631565f, 0.03695854f, -0.02403327f, -0.05293128f, 0.00812032f, -0.03824550f, 
    0.00153293f, -0.05583872f, -0.03160727f, -0.02032320f, -0.05277433f, 0.00632467f, -0.05067473f, -0.04231685f, 
    0.01672408f, -0.04634725f, -0.01235362f, 0.03666136f, -0.01521797f, -0.01795367f, 0.02089997f, -0.02173327f, 
    0.00224815f, 0.03895396f, 0.03194668f, 0.00396148f, 0.00416474f, -0.05061258f, -0.00933751f, -0.05861726f, 
    0.03865578f, 0.00947762f, -0.05163925f, -0.00890043f, -0.00004785f, -0.01943522f, 0.02569849f, 0.02486475f, 
    0.04133058f, -0.03049763f, 0.03328591f, 0.03492614f, -0.04219319f, 0.04909503f, -0.03348520f, -0.02365522f, 
    0.02399092f, 0.01320980f, 0.02352670f, 0.02604959f, -0.02947465f, -0.05309063f, -0.02730271f, -0.04697091f, 
    -0.00501003f, -0.04338022f, 0.04322679f, -0.04797589f, 0.01552897f, 0.00282723f, 0.00607699f, -0.03066418f, 
    -0.03046184f, -0.03857108f, 0.04407574f, 0.02444113f, -0.00101408f, -0.00803631f, 0.03086989f, -0.04190322f, 
    -0.04648559f, -0.02173830f, -0.04517994f, -0.02873715f, -0.00097040f, -0.02734856f, 0.00084546f, -0.01646888f, 
    0.03754209f, 0.02912837f, -0.02699680f, 0.02705208f, -0.04158081f, -0.05698470f, -0.03172971f, 0.04039060f, 
    -0.02788818f, -0.02543171f, -0.04274280f, 0.02252419f, -0.00910688f, -0.00536078f, -0.05197133f, -0.01530124f, 
    -0.05212917f, -0.04632242f, 0.01265545f, 0.03800419f, -0.01299023f, 0.02614233f, -0.00972932f, 0.02321402f, 
    -0.00114389f, 0.00326698f, -0.02007615f, -0.01490853f, -0.01809523f, -0.00421468f, -0.03709251f, 0.02286926f, 
    -0.02848754f, 0.00407193f, 0.03275184f, 0.00732324f, 0.02359008f, -0.05059381f, 0.02045543f, -0.00400294f, 
    -0.05268135f, 0.02831365f, -0.01484881f, 0.03170112f, 0.04782607f, -0.04132736f, 0.00743337f, 0.01235074f, 
    0.04181015f, -0.02406626f, 0.01557065f, 0.03292053f, 0.05301046f, -0.04415062f, 0.00405378f, -0.02618728f, 
    0.03567394f, -0.00492862f, 0.04186060f, -0.05089526f, 0.04156787f, 0.04447327f, -0.03330266f, 0.01783231f, 
    -0.02204418f, 0.02926037f, 0.01997234f, -0.04054612f, -0.00303245f, 0.01790660f, 0.01147426f, -0.05171670f, 
    -0.04650318f, 0.01110017f, -0.02481828f, 0.02864541f, 0.03935731f, -0.03727030f, 0.03195406f, -0.03670282f, 
    -0.02464209f, -0.03668718f, -0.04107402f, 0.01488909f, -0.00866388f, 0.03542315f, 0.02684586f, 0.01492580f, 
    0.02243814f, -0.03462520f, -0.01300191f, 0.01830982f, 0.00598412f, -0.03574454f, -0.04945783f, 0.00417912f, 
    0.00137232f, -0.02575027f, -0.02660400f, 0.02148207f, -0.05067817f, 0.02431271f, 0.03627559f, 0.03273098f, 
    0.03110688f, -0.03003711f, -0.02128142f, -0.00919671f, -0.03132056f, 0.03048891f, 0.01307305f, -0.04688962f, 
    -0.02704677f, -0.01000047f, -0.01248157f, -0.00212540f, 0.01872828f, -0.01475023f, 0.04602379f, 0.02220451f, 
    0.02805823f, -0.00945086f, -0.01645322f, 0.03645993f, -0.05431876f, 0.01662677f, -0.01826940f, -0.03736009f, 
    -0.02231525f, 0.02404004f, 0.03262638f, -0.01900552f, 0.02913447f, 0.04467066f, 0.00781626f, -0.04869879f, 
    -0.03904930f, 0.00625323f, 0.00357377f, 0.04061001f, -0.00935444f, 0.02606370f, -0.02593185f, 0.01816828f, 
    -0.05493002f, -0.00036327f, 0.02247706f, -0.01035183f, 0.02249131f, 0.03484575f, -0.04190946f, 0.02667043f, 
    0.02733315f, -0.00066731f, 0.01109069f, 0.02569986f, 0.02649145f, -0.04783383f, 0.04243756f, 0.04052795f, 
    -0.00783040f, -0.04694219f, -0.03907808f, -0.04528882f, 0.04471565f, -0.01406569f, 0.01444535f, 0.00134329f, 
    -0.02945917f, 0.02829217f, -0.03605257f, -0.01452156f, -0.01127523f, -0.00300857f, -0.04159198f, 0.03740261f, 
    -0.01328877f, 0.02812344f, 0.00207689f, -0.00428577f, -0.00755212f, -0.01243470f, 0.00689124f, -0.02491012f, 
    -0.01602008f, -0.04688667f, 0.02985564f, 0.03135669f, -0.01041492f, 0.04431561f, -0.04427424f, -0.05016382f, 
    -0.01652272f, -0.00068099f, -0.05673235f, -0.03188860f, -0.05058357f, -0.02045768f, -0.03114966f, -0.00950755f, 
    -0.00317660f, 0.01033201f, -0.01647022f, -0.05482205f, -0.00980095f, -0.05632283f, -0.00970866f, 0.02312946f, 
    -0.03112432f, -0.02430231f, 0.00342541f, 0.02926430f, -0.04653144f, -0.04417512f, 0.03451596f, 0.00533180f, 
    0.01923352f, -0.01532626f, -0.00989587f, 0.02165897f, 0.01618956f, 0.01413885f, -0.00434820f, 0.00065989f, 
    -0.03570697f, 0.03033169f, 0.02542152f, 0.00952609f, -0.02256315f, -0.03761536f, -0.04658867f, -0.01227888f, 
    -0.05285474f, -0.04161292f, -0.01943623f, -0.05218221f, 0.03848235f, -0.04884592f, -0.00283577f, 0.01355385f, 
    -0.05765755f, 0.01304681f, -0.02040633f, 0.03154046f, -0.00756754f, -0.03647917f, 0.04277182f, 0.02929705f, 
    -0.03080170f, -0.02841015f, 0.02594434f, 0.03518746f, -0.03516873f, 0.03913979f, -0.02686706f, -0.00530488f, 
    0.00332514f, -0.00262076f, 0.03836942f, 0.03757340f, 0.00545808f, -0.02082116f, 0.02848109f, -0.00080030f, 
    0.04055500f, 0.00492895f, 0.00117486f, 0.02957958f, -0.00482686f, -0.03762925f, 0.02489815f, -0.04183201f, 
    -0.02530423f, -0.01096135f, -0.01246655f, -0.00459589f, 0.01918854f, 0.01358979f, -0.03860085f, 0.02296254f, 
    0.01142034f, -0.03500269f, -0.03932255f, 0.00184559f, 0.00033715f, -0.00715927f, -0.00045714f, -0.03448786f, 
    0.01945961f, 0.02403777f, 0.02178440f, -0.01057710f, 0.02066658f, 0.02808754f, 0.04376328f, -0.01195742f, 
    0.02125729f, 0.03029444f, -0.02760740f, -0.05543259f, -0.02336740f, -0.04710435f, -0.00784913f, -0.04687095f, 
    -0.01687373f, -0.01646881f, -0.04904900f, -0.01656419f, 0.02296095f, 0.01071174f, 0.00471103f, 0.02829581f, 
    -0.01468247f, -0.05511513f, 0.03392131f, 0.02699419f, -0.00740039f, -0.00702074f, 0.02511376f, -0.04745115f, 
    -0.04633804f, -0.03943435f, -0.03910905f, -0.03720456f, -0.02196084f, -0.05092435f, -0.00540706f, -0.03671464f, 
    0.03665430f, -0.02128364f, -0.05460059f, -0.00846615f, 0.03818494f, -0.05817728f, -0.02634672f, -0.00492999f, 
    -0.04543886f, -0.00320405f, 0.04547528f, -0.04522557f, -0.00550772f, -0.02870560f, -0.02195266f, -0.02841378f, 
    -0.00903123f, 0.03051813f, -0.03246133f, 0.03202487f, -0.03819773f, -0.02074044f, 0.03931781f, -0.00258800f, 
    0.02598457f, -0.04604724f, 0.00310647f, -0.00453656f, 0.00835332f, -0.02015541f, 0.00980709f, -0.01671103f, 
    -0.02733282f, 0.03127214f, -0.00960452f, 0.01593663f, 0.04641416f, -0.02700705f, -0.04793301f, -0.00220345f, 
    0.01094833f, -0.03355721f, 0.03942993f, 0.02514313f, -0.00259688f, 0.01740682f, 0.02736948f, -0.05302463f, 
    -0.01936971f, -0.00206909f, -0.02959242f, -0.00240876f, -0.05464774f, -0.01705585f, 0.01182197f, 0.00998622f, 
    0.01086671f, -0.03602298f, 0.02544502f, 0.01598286f, 0.03891909f, 0.01853679f, 0.04662621f, -0.00842483f, 
    -0.04249653f, -0.03503019f, 0.00374368f, -0.01486896f, -0.04276678f, -0.04138817f, -0.01804564f, 0.03500634f, 
    0.04362779f, -0.04617070f, -0.01535184f, 0.01332424f, 0.02664034f, -0.04128869f, -0.04508293f, 0.01230982f, 
    -0.05056435f, 0.04823424f, -0.00636881f, 0.00109608f, -0.01124109f, -0.03203579f, 0.03544343f, -0.01751346f, 
    -0.04474384f, -0.03644299f, 0.02926322f, 0.02926863f, 0.02768338f, -0.03404868f, 0.02096042f, -0.00762351f, 
    0.02174296f, -0.02259309f, -0.00355250f, -0.01721353f, 0.02541940f, 0.02862206f, -0.04494790f, 0.04463325f, 
    0.00491161f, 0.01291440f, 0.02561299f, -0.00615329f, 0.03404658f, -0.02963736f, 0.00240483f, -0.00247073f, 
    0.02928356f, -0.01645900f, 0.02620946f, 0.04081565f, 0.05320599f, -0.02864957f, -0.03134608f, -0.04777005f, 
    -0.02447797f, -0.01370725f, -0.05204603f, 0.01818107f, -0.05707807f, -0.00548020f, 0.00628416f, -0.03835709f, 
    -0.03839625f, -0.02423310f, 0.01247173f, -0.04806580f, -0.05047582f, -0.00736618f, 0.01992882f, 0.02335817f, 
    0.03393137f, -0.02200177f, 0.01829708f, -0.05684525f, -0.01891874f, -0.00994942f, 0.02555585f, -0.01647791f, 
    0.03710615f, -0.05103071f, 0.00187231f, -0.01212413f, -0.04541784f, 0.05288307f, -0.03922192f, -0.05460491f, 
    -0.04934668f, -0.03025530f, 0.00094800f, 0.02209506f, 0.00743278f, 0.03807453f, -0.02796127f, 0.01385296f, 
    -0.03761946f, -0.02604791f, -0.05411303f, -0.02700125f, -0.00163490f, -0.03154223f, -0.02460391f, -0.05085230f, 
    -0.03226453f, 0.00614943f, -0.03270353f, -0.00518231f, 0.01926820f, 0.00492443f, -0.00221694f, 0.00255869f, 
    0.03225011f, -0.00953254f, -0.02055409f, -0.02498130f, 0.04251742f, 0.02168424f, 0.00995662f, 0.04300143f, 
    -0.01329484f, -0.02417647f, -0.01201252f, -0.01334432f, 0.01144312f, -0.04542985f, 0.00653941f, 0.02275912f, 
    0.03918485f, -0.03884454f, 0.03822913f, -0.00860415f, -0.00625116f, -0.04550321f, 0.02171469f, 0.02020815f, 
    -0.05053631f, 0.03339491f, 0.02440244f, -0.02294162f, 0.00726013f, 0.01051689f, -0.03124345f, 0.04310937f, 
    -0.06005370f, 0.00576032f, -0.03812102f, -0.00753029f, -0.02823065f, 0.03930617f, -0.00702604f, -0.02308576f, 
    0.02820241f, 0.03523865f, -0.01559370f, -0.00377929f, 0.02531043f, -0.03287019f, -0.02957332f, 0.01188622f, 
    0.04451131f, -0.04311083f, -0.02281250f, 0.02641307f, -0.01149430f, -0.05262158f, -0.01421717f, 0.01331102f, 
    0.03304353f, -0.01809966f, -0.02846245f, 0.01436828f, 0.02405083f, 0.03072290f, 0.03198091f, -0.04385207f, 
    0.01283802f, -0.04750843f, 0.02517701f, -0.00850573f, 0.03907765f, -0.02419344f, -0.01547971f, -0.02053622f, 
    -0.05187197f, 0.04871110f, -0.01151727f, -0.01182897f, -0.05151864f, 0.03973141f, -0.00601712f, -0.00340788f, 
    -0.03542510f, 0.04137866f, -0.02971735f, 0.01746794f, -0.01817895f, -0.02662499f, 0.04516863f, -0.00867937f, 
    -0.02725019f, -0.05166130f, -0.00891245f, 0.01988799f, 0.03562634f, 0.01834768f, 0.03198252f, -0.04260789f, 
    -0.01092277f, -0.03362801f, 0.02097223f, -0.02196003f, -0.02350631f, -0.00500940f, -0.02863129f, -0.05233470f, 
    0.02273100f, -0.00008948f, 0.04901040f, -0.01492894f, 0.04154762f, 0.00134010f, 0.02435807f, 0.01250597f, 
    0.01811288f, -0.01889947f, 0.00552079f, -0.01628821f, 0.03489561f, 0.00180045f, -0.00409655f, 0.01227195f, 
    0.04429362f, -0.04622756f, 0.00223502f, -0.05430084f, 0.03225789f, -0.04148472f, 0.02100817f, -0.01732453f, 
    0.01543108f, -0.01244103f, 0.02631876f, 0.00021417f, 0.00039068f, 0.00990180f, 0.04274192f, -0.04700472f, 
    -0.04933220f, -0.01527265f, -0.01312240f, -0.01571479f, -0.03073586f, 0.04648595f, -0.01769547f, 0.00086618f, 
    -0.02710816f, -0.04040821f, 0.03285611f, -0.02182918f, 0.03053352f, 0.03605835f, -0.03411035f, -0.00581531f, 
    -0.00770501f, 0.03601386f, -0.04796947f, -0.01256824f, -0.01327968f, 0.03206921f, 0.04483180f, 0.00742905f, 
    -0.04399559f, 0.00148338f, 0.02290861f, 0.03425744f, 0.05480981f, -0.04422919f, 0.03172024f, 0.03966862f, 
    0.03337085f, 0.03996885f, 0.02510916f, 0.01449982f, -0.01288443f, -0.02580317f, -0.02279393f, -0.04697052f, 
    0.03489203f, -0.03063148f, -0.03322904f, -0.02903301f, 0.03233797f, -0.00818536f, -0.03778416f, 0.05094694f, 
    -0.03220213f, -0.00743889f, 0.03819278f, -0.00567146f, -0.01667327f, 0.02944058f, -0.00580787f, -0.04199367f, 
    -0.00764293f, 0.04742924f, -0.02221649f, -0.01532065f, -0.04880146f, -0.01276449f, 0.03213922f, -0.01760802f, 
    -0.04896040f, -0.04840468f, 0.01898031f, 0.02775348f, -0.02829441f, -0.01271386f, -0.02233746f, 0.00517785f, 
    0.03171029f, 0.03706599f, 0.03720817f, 0.00859513f, 0.05147376f, -0.03282744f, 0.03012888f, -0.04870026f, 
    -0.03138112f, -0.03732928f, -0.02209699f, 0.01235234f, 0.02750349f, -0.03516419f, -0.05241452f, 0.04576436f, 
    0.00446980f, -0.01055049f, -0.02262202f, -0.01015223f, -0.05460258f, -0.03340106f, 0.01981684f, -0.04421626f, 
    -0.04783655f, 0.00893959f, -0.03149855f, -0.03384292f, 0.04600716f, 0.03184774f, 0.02627158f, -0.02320734f, 
    -0.02286158f, 0.03639000f, 0.03732475f, -0.04166542f, -0.01516262f, 0.04158135f, 0.03631911f, 0.03976123f, 
    0.03422838f, -0.01891975f, 0.04134697f, -0.02987932f, 0.00654247f, -0.02952259f, -0.02951339f, 0.01543505f, 
    -0.02138056f, 0.00494924f, 0.04892355f, 0.00610950f, -0.02102287f, -0.03544390f, -0.04478533f, 0.04024618f, 
    -0.03097902f, 0.03587873f, -0.03966924f, -0.00177645f, -0.03065759f, 0.01155516f, -0.01623518f, 0.02846586f, 
    -0.03221560f, 0.02387915f, -0.02831368f, -0.04804245f, -0.05159466f, -0.00289049f, -0.02764663f, -0.03938697f, 
    0.03554909f, -0.04128230f, -0.00702033f, 0.00483475f, -0.00250151f, 0.04026258f, -0.01702005f, -0.05484521f, 
    0.04637967f, -0.03845386f, 0.00106461f, -0.01081525f, -0.02182906f, -0.01710449f, 0.00947724f, 0.01664819f, 
    0.00927620f, 0.03517861f, 0.01234299f, -0.00807439f, 0.01950869f, 0.01945714f, 0.00551805f, -0.01195836f, 
    0.00030989f, 0.01614816f, 0.03330129f, 0.02929133f, -0.04827086f, -0.04146926f, 0.02308633f, -0.00628967f, 
    0.00700730f, -0.00146016f, 0.02847756f, 0.01975849f, 0.01493099f, -0.01773215f, 0.02794686f, 0.01652992f, 
    -0.02415228f, -0.04285772f, -0.02105186f, 0.05270069f, 0.01318347f, -0.04049531f, -0.04689080f, -0.05290012f, 
    0.01305393f, 0.03286436f, 0.00781699f, 0.02148257f, -0.02867591f, -0.04485866f, -0.04683603f, 0.02535379f, 
    0.03388320f, -0.03376745f, -0.03473749f, 0.00181109f, 0.02212753f, -0.04969056f, -0.04501614f, -0.03156981f, 
    -0.04991471f, 0.00285533f, 0.02411461f, -0.02553192f, -0.02867621f, -0.01710664f, 0.00026179f, -0.04001067f, 
    -0.02200945f, -0.01050183f, -0.01813728f, 0.03042290f, 0.00329916f, -0.02346942f, 0.02654463f, 0.02265716f, 
    -0.04086026f, -0.02509929f, -0.00303059f, -0.04704289f, -0.01380167f, 0.01066988f, -0.03469134f, 0.00846952f, 
    -0.04041566f, 0.00259452f, -0.05349300f, 0.00010542f, 0.03674956f, 0.01748532f, -0.02168251f, -0.04823397f, 
    -0.00731102f, -0.00595218f, -0.04800137f, -0.04179077f, -0.00412699f, -0.04792254f, -0.05877462f, -0.05274518f, 
    -0.03219077f, 0.00185057f, 0.01566517f, 0.01487898f, 0.02255612f, -0.04257332f, 0.00049052f, 0.02085884f, 
    -0.03988973f, -0.01718315f, 0.00673096f, 0.04377374f, -0.01857768f, -0.02111078f, 0.00354446f, -0.00412588f, 
    0.00740678f, 0.03821151f, -0.02190880f, 0.03222353f, -0.00265399f, -0.01896271f, 0.04646057f, -0.01681876f, 
    -0.04643600f, 0.01038029f, -0.01665940f, -0.05804316f, -0.00388694f, -0.00934173f, -0.05255710f, 0.00581485f, 
    -0.00726042f, 0.03941362f, -0.03197505f, 0.02901304f, -0.04370240f, -0.01315373f, 0.02245269f, 0.01606482f, 
    0.03973428f, -0.02875982f, 0.03650025f, 0.03267905f, 0.02726546f, -0.01573701f, 0.01073862f, 0.03893472f, 
    -0.03505962f, -0.06280022f, -0.04729403f, 0.04003160f, 0.02884902f, -0.03788096f, 0.00424657f, 0.02208981f, 
    -0.04357165f, -0.02095074f, -0.00482632f, -0.02951874f, -0.00223577f, -0.01830430f, 0.00634935f, -0.00016119f, 
    0.04180235f, 0.02233016f, -0.03073429f, -0.03145631f, 0.03996035f, 0.00368036f, -0.03117561f, 0.04406860f, 
    0.01122860f, -0.02377546f, -0.02216907f, -0.05148688f, -0.01651114f, -0.03959877f, -0.03794211f, -0.06212945f, 
    -0.04698770f, -0.00951407f, -0.00831145f, 0.00896790f, 0.02049659f, 0.04278002f, -0.03394717f, 0.02949602f, 
    0.03977722f, -0.05209212f, -0.01895048f, 0.03503197f, 0.02608632f, 0.03273220f, -0.02625296f, 0.01742746f, 
    0.09986674f, 0.21315166f, 0.08703052f, -0.00515110f, 0.05086902f, 0.06748563f, -0.02244931f, -0.02174476f, 
    -0.11136208f, -0.10879879f, -0.25917667f, -0.24941622f, -0.15629655f, -0.12307423f, -0.06052415f, 0.17030825f, 
    -0.09731642f, 0.17660479f, 0.01423434f, -0.06977244f, 0.19656476f, 0.00746250f, 0.09822756f, 0.27655730f, 
    0.22135945f, 0.34812361f, -0.30019787f, 0.07356717f, -0.02452906f, 0.09626991f, -0.11650684f, -0.10374012f, 
    -0.00782611f, -0.07315963f, -0.01344860f, -0.06986798f, -0.20597830f, -0.24388695f, -0.06277255f, 0.22428447f, 
    0.06920697f, -0.03313451f, 0.08484744f, 0.06887551f, 0.03734380f, -0.06248660f, -0.10653394f, -0.10864135f, 
    0.13501082f, -0.23490961f, 0.20767432f, 0.25024888f, 0.32067993f, -0.01011707f, -0.01770823f, 0.04450508f, 
    -0.01098347f, 0.21468374f, -0.03211358f, 0.14864743f, 0.25962430f, 0.00105449f, 0.37602872f, 0.06401356f, 
    -0.00765700f, -0.07573593f, 0.09178043f, 0.01232442f, -0.05229164f, 0.15034723f, -0.03673005f, 0.03140480f, 
    -0.16568209f, 0.10492070f, -0.26784000f, -0.03146847f, 0.02001821f, -0.01511951f, 0.04060416f, -0.00366498f, 
    -0.15645202f, -0.27784565f, -0.16202408f, -0.39860755f, -0.45906177f, -0.08347613f, -0.00900090f, 0.04368456f, 
    0.09774053f, 0.06389899f, 0.03397456f, -0.14410326f, 0.14632930f, -0.08684637f, 0.01137669f, 0.16611131f, 
    -0.31025568f, -0.20467703f, -0.04043270f, 0.03996691f, -0.05049785f, -0.07293927f, -0.08159233f, 0.06273199f, 
    -0.05529276f, -0.07909805f, 0.04778237f, -0.08717458f, -0.23410779f, -0.18221995f, -0.14423093f, 0.15707962f, 
    0.08066455f, 0.05533175f, 0.06901958f, -0.02936212f, 0.00950262f, -0.01051385f, 0.03484194f, 0.01098628f, 
    0.01701443f, -0.17924716f, 0.08052146f, 0.10706300f, 0.04756359f, 0.10752372f, 0.06310021f, 0.02487175f, 
    0.18586612f, 0.18953511f, 0.30990139f, 0.37256864f, 0.30019167f, 0.49467978f, 0.15716673f, 0.19466068f, 
    -0.11161370f, -0.11270252f, 0.17067099f, -0.02077926f, 0.07661261f, 0.07078389f, 0.06371554f, -0.05714403f, 
    0.16537817f, 0.22847494f, 0.21797866f, 0.22898793f, -0.11722874f, -0.06495445f, 0.05198288f, 0.04281424f, 
    -0.07677556f, 0.10979443f, -0.02760645f, -0.04619103f, 0.32323366f, 0.30197984f, 0.29617450f, 0.05656005f, 
    -0.13047688f, -0.34185538f, -0.08227839f, -0.00920963f, -0.01319677f, -0.15173790f, -0.02192330f, -0.07152258f, 
    -0.05589416f, -0.34250584f, -0.20004357f, 0.01050977f, -0.00281198f, 0.13704699f, -0.04626267f, -0.10267162f, 
    -0.21169437f, -0.32287872f, -0.31688160f, -0.54250973f, 0.16804703f, -0.09777124f, 0.03726671f, -0.12189858f, 
    -0.00977333f, -0.05290417f, -0.03792298f, 0.25483471f, 0.06701526f, 0.12436587f, 0.16963939f, 0.06899732f, 
    -0.03715606f, -0.27747166f, 0.13808949f, 0.29637012f, 0.14112087f, -0.07843238f, -0.09326971f, 0.06179140f, 
    -0.03279999f, 0.04476841f, 0.03496630f, 0.25993726f, -0.12544367f, -0.17031971f, -0.15572827f, 0.09866168f, 
    -0.02572937f, -0.11984497f, -0.08019393f, 0.00859957f, 0.05167956f, 0.05549077f, 0.00038423f, -0.06064659f, 
    -0.03265056f, 0.11308970f, -0.00791524f, -0.24739879f, 0.06418023f, -0.04536340f, 0.06609420f, -0.04017561f, 
    0.05416802f, 0.02184917f, 0.03693618f, -0.14822306f, 0.07633356f, 0.26744041f, 0.07038221f, -0.02257890f, 
    0.00043154f, -0.04495787f, -0.16338794f, -0.03302450f, 0.09667578f, 0.14243986f, 0.16597611f, 0.09335249f, 
    0.18220235f, -0.34643483f, -0.23097166f, -0.12186899f, -0.05168886f, 0.09464720f, 0.24280442f, -0.03305830f, 
    0.01204802f, -0.04103128f, -0.07512037f, -0.19819450f, 0.04857599f, 0.06449955f, -0.09296182f, 0.15163296f, 
    -0.07447463f, 0.14473629f, -0.03205192f, 0.16652097f, 0.01542522f, -0.05515568f, 0.04160747f, -0.07246054f, 
    -0.04232226f, -0.24477297f, -0.24403925f, 0.12889546f, 0.11792672f, 0.06328315f, 0.11050936f, 0.01216295f, 
    0.00636508f, 0.03896939f, 0.02887155f, 0.13093372f, -0.05668595f, 0.45333695f, -0.04469120f, -0.06185896f, 
    0.00288277f, 0.04805217f, 0.15437430f, -0.04393191f, 0.12160718f, 0.26824695f, -0.02763418f, 0.12381259f, 
    -0.12008413f, -0.10278956f, 0.18070100f, 0.22921781f, 0.14404368f, 0.21670902f, -0.07315587f, -0.08245546f, 
    0.06211643f, 0.00656817f, 0.00117730f, 0.09811454f, 0.00336917f, -0.06603348f, 0.10060975f, 0.06255522f, 
    -0.04473823f, -0.20062517f, 0.09861022f, -0.09599187f, -0.01978800f, -0.00080800f, -0.01231006f, 0.20531859f, 
    -0.26202485f, -0.12853050f, -0.10181028f, 0.10001168f, -0.09996277f, -0.10810056f, 0.07058481f, -0.06237004f, 
    -0.21369848f, -0.20199299f, -0.12829015f, -0.27621502f, -0.01077191f, -0.00294468f, 0.03845737f, -0.04932683f, 
    -0.04107454f, 0.06710544f, -0.12051513f, -0.04222388f, 0.22614062f, 0.13154836f, 0.07566331f, 0.27750412f, 
    -0.18537366f, -0.05055299f, 0.22049768f, 0.22655980f, 0.12979656f, -0.16281717f, -0.04234910f, 0.15804556f, 
    0.09125066f, -0.03262538f, -0.01436781f, 0.24971585f, 0.41316170f, -0.22390416f, -0.07532058f, -0.02655725f, 
    0.05857444f, 0.02005331f, 0.00159909f, -0.18415847f, 0.08847945f, 0.10470666f, 0.06020297f, 0.31435597f, 
    -0.00964157f, 0.37952447f, 0.02344822f, 0.06045518f, 0.14824997f, 0.11881663f, 0.14626424f, -0.14333783f, 
    0.10545255f, 0.10466298f, 0.00387659f, 0.11063579f, 0.07763706f, 0.04605585f, -0.07008319f, 0.02222463f, 
    0.03495691f, 0.05275191f, 0.11830286f, -0.01283245f, -0.17546313f, -0.30405211f, -0.13427810f, -0.46043199f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05260250f, 0.01949585f, -0.13098216f, 0.02818709f, 0.06434897f, 0.07491210f, -0.09429776f, -0.18982230f, 
    0.22537577f, 0.10924755f, -0.03385632f, -0.02276162f, 0.19518234f, 0.01277415f, 0.15061380f, 0.05984231f, 
    0.03459064f, -0.07724647f, -0.02012831f, 0.04158662f, -0.01362022f, 0.03878891f, 0.01709232f, 0.12893021f, 
    0.12076375f, -0.04282225f, 0.00625871f, -0.00752677f, 0.02752697f, -0.05106376f, -0.02734943f, 0.06408426f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.02558750f, 0.16317779f, -0.01656383f, 0.08401724f, -0.30940741f, 0.09708244f, -0.01658128f, 0.61571968f, 
    0.25410080f, -0.06263036f, 0.03088591f, 0.13108741f, -0.06785689f, -0.16280165f, 0.10677688f, 0.36688519f, 
    0.09348373f, -0.30064613f, -0.11642124f, 0.00772469f, 0.03426020f, -0.04660573f, 0.32836917f, -0.13397759f, 
    -0.17740642f, -0.05931791f, 0.09040103f, 0.11682974f, -0.00871251f, -0.05603931f, -0.06645850f, 0.30867597f, 
    -0.04442612f, -0.06080153f, -0.23560825f, -0.04338399f, 0.44393346f, -0.04254709f, -0.48393986f, -0.27378601f, 
    0.03310023f, 0.32611528f, -0.11557263f, 0.13459058f, 0.34967002f, -0.03737814f, 0.12419590f, -0.16281208f, 
    0.10251819f, 0.10999474f, 0.03966286f, 0.09936633f, -0.10968672f, -0.20868152f, 0.23310538f, 0.36326033f, 
    0.38976133f, -0.13220243f, -0.14275876f, -0.01089353f, 0.04195722f, 0.15982911f, 0.04571851f, 0.10873652f, 
    0.14576432f, -0.01987409f, 0.24027745f, -0.02912340f, 0.14395505f, -0.19785550f, 0.43238476f, 0.01538475f, 
    0.09007892f, 0.28932589f, -0.06990757f, 0.17291868f, 0.14761485f, -0.07140247f, 0.05596986f, -0.51926321f, 
    0.12165295f, 0.06110755f, 0.06036942f, -0.10863716f, 0.08839387f, 0.32676354f, 0.01715119f, 0.09558627f, 
    -0.42285898f, 0.12569526f, -0.12975116f, -0.04688970f, -0.04011735f, 0.08444733f, -0.01673789f, 0.09952455f, 
    -0.16461563f, -0.02761872f, -0.15677780f, 0.22706236f, 0.05843865f, 0.17212892f, 0.33775538f, 0.27040192f, 
    -0.06847721f, -0.28177628f, 0.25546071f, 0.11000826f, 0.02245145f, 0.07257638f, 0.01226548f, 0.37137142f, 
    -0.19511899f, -0.11347812f, -0.15304844f, 0.23034923f, -0.06058886f, -0.34647548f, -0.17043473f, 0.11973388f, 
    -0.00306474f, -0.03153915f, -0.02170392f, 0.15654428f, -0.13719290f, 0.16707131f, 0.02696572f, -0.25780064f, 
    -0.10585243f, -0.10833311f, -0.40010706f, 0.15577346f, 0.03167131f, -0.03877195f, -0.07453419f, -0.41630530f, 
    0.04050107f, 0.08475836f, -0.05940542f, 0.05039204f, 0.13303837f, -0.00763897f, 0.18585072f, 0.16960783f, 
    0.02566180f, -0.16341804f, -0.06463739f, 0.25110203f, -0.15666865f, -0.00588115f, -0.12631829f, 0.11915764f, 
    0.29370862f, -0.15371430f, 0.16077173f, 0.15141089f, 0.10712067f, -0.03433546f, -0.09255626f, -0.11078262f, 
    0.08382826f, 0.13170590f, 0.03503022f, -0.15568352f, 0.21857253f, 0.11080667f, 0.43427834f, 0.34287325f, 
    0.26617458f, 0.27063403f, 0.22040118f, 0.06430944f, -0.18491997f, 0.10513988f, 0.16588026f, 0.28077173f, 
    0.28766122f, 0.20823303f, 0.12036065f, -0.11041294f, 0.02315574f, -0.15522002f, -0.20995633f, 0.13074026f, 
    -0.38672665f, 0.07069644f, -0.10207421f, -0.17508213f, 0.10880856f, 0.11562965f, 0.01329788f, 0.23984149f, 
    0.00447563f, 0.17256857f, 0.21722922f, 0.00088591f, 0.47816595f, -0.31886780f, -0.21472166f, 0.06856198f, 
    -0.09295233f, -0.16301951f, 0.15764044f, -0.10568283f, 0.14672755f, 0.02373522f, 0.35192713f, 0.10748658f, 
    -0.12639965f, 0.10617334f, -0.00799890f, 0.33293763f, -0.02050598f, -0.27804589f, -0.22764668f, 0.24588196f, 
    0.45177662f, -0.03748221f, 0.09488071f, -0.00923378f, -0.07117506f, -0.06416541f, 0.14970908f, 0.07903673f, 
    -0.06464766f, -0.15905474f, 0.33056164f, 0.30054861f, -0.09243249f, 0.08910067f, 0.27548668f, -0.00708934f, 
    0.15036759f, 0.08367591f, 0.18716376f, -0.07088018f, 0.05938346f, -0.00865212f, -0.33641258f, 0.05601142f, 
    -0.06757648f, 0.04774407f, -0.14722732f, -0.11561880f, -0.07289659f, 0.02227204f, 0.24556296f, -0.32103825f, 
    -0.42793983f, 0.04606381f, 0.04423022f, 0.10994691f, 0.11001348f, 0.18195364f, -0.14914863f, -0.09053575f, 
    -0.12045853f, -0.13594492f, -0.35708827f, -0.05262158f, 0.03341916f, 0.05667776f, -0.04132558f, -0.23676787f, 
    -0.11294824f, 0.23505181f, 0.05370697f, 0.03648515f, -0.13855207f, -0.01929804f, -0.08277820f, -0.10979190f, 
    0.32611731f, 0.44117743f, -0.07561381f, 0.35845304f, -0.15605092f, -0.18473236f, -0.04918106f, -0.13388838f, 
    0.09544984f, -0.14064766f, 0.12154046f, 0.03651073f, -0.07084229f, 0.10178611f, 0.00748785f, 0.56125683f, 
    0.15166500f, 0.08249902f, 0.00598442f, -0.04023350f, 0.04267150f, -0.03796691f, -0.16465883f, -0.08926624f, 
    -0.08455354f, -0.16482200f, 0.03220328f, -0.02741761f, -0.09013993f, 0.16195108f, -0.16360129f, 0.01748199f, 
    0.02882743f, -0.13033228f, 0.14336106f, -0.08617588f, -0.03694096f, -0.08176781f, 0.07707816f, -0.11088819f, 
    0.00959185f, -0.02364718f, -0.03545609f, -0.06649870f, -0.15678738f, -0.15743843f, 0.13192864f, 0.13799635f, 
    -0.04627667f, -0.08564427f, 0.36365518f, -0.25361744f, 0.37938425f, -0.17001455f, -0.32883701f, 0.17784740f, 
    -0.00603402f, -0.16200741f, -0.15851900f, -0.13186882f, 0.19197141f, 0.12161524f, 0.47589031f, 0.09848578f, 
    0.01890431f, 0.00358705f, 0.07372151f, 0.21366045f, 0.05804745f, -0.47571689f, 0.16702710f, 0.26134095f, 
    0.30724439f, 0.06824761f, -0.04727592f, -0.05952383f, 0.07874227f, -0.10545243f, -0.11953168f, 0.12561643f, 
    0.14200610f, -0.14725690f, -0.03881872f, 0.04222632f, -0.00556261f, -0.12859583f, 0.02821092f, 0.13339035f, 
    -0.15476245f, 0.05695859f, 0.23099311f, 0.06350289f, -0.09642077f, -0.16272737f, -0.43411630f, 0.18706211f, 
    0.15387213f, -0.15825586f, -0.17105728f, 0.05155206f, -0.05946994f, 0.03981258f, 0.24766548f, -0.23105752f, 
    0.12122969f, -0.12652165f, -0.16456445f, -0.08853245f, 0.05608700f, 0.11922725f, 0.05960078f, 0.19300011f, 
    -0.10616456f, -0.14753599f, 0.02750892f, 0.06416100f, -0.29630187f, 0.15004176f, 0.00454085f, 0.24626078f, 
    0.22640789f, -0.21592453f, -0.14353088f, -0.14001407f, -0.00594049f, -0.03787588f, 0.02977809f, 0.23700657f, 
    -0.13614252f, -0.41509125f, -0.00737897f, 0.20116046f, -0.04551139f, 0.08534589f, 0.11507052f, 0.26433226f, 
    -0.18430273f, 0.01894893f, 0.02682244f, -0.04780506f, -0.05402984f, -0.05888884f, 0.15879700f, 0.18520592f, 
    -0.08835538f, 0.10579988f, 0.08677042f, 0.14118960f, 0.02591303f, 0.05563262f, -0.18388444f, -0.23204854f, 
    0.28664267f, -0.00109164f, 0.08895238f, -0.06800767f, 0.02914307f, -0.01024309f, 0.06181674f, -0.05800503f, 
    -0.01612981f, -0.42024395f, -0.09075048f, 0.02492117f, 0.15707551f, -0.21592443f, 0.33998990f, 0.42719531f, 
    0.15942377f, -0.08780851f, -0.15335308f, 0.00741929f, 0.14716652f, -0.04090161f, -0.14237584f, -0.26796487f, 
    -0.00455447f, 0.14175758f, 0.31190127f, -0.21255274f, 0.03436623f, -0.22236119f, 0.25516912f, 0.26568761f, 
    0.24620673f, -0.06284148f, 0.03245680f, -0.16227874f, 0.09832165f, 0.02235170f, -0.29528150f, 0.10080178f, 
    0.20061781f, -0.20073698f, -0.06402414f, -0.18771936f, -0.12962666f, -0.06747617f, 0.29480469f, 0.34033695f, 
    0.09882826f, -0.01441878f, -0.08302166f, 0.16779311f, -0.01516429f, -0.08325586f, -0.02195495f, -0.19511746f, 
    -0.06013120f, -0.10911889f, 0.11019901f, 0.52907711f, -0.09559740f, 0.09926489f, 0.09102469f, -0.41835323f, 
    -0.06146105f, -0.06864859f, 0.34917289f, 0.11307053f, 0.23414560f, -0.03116595f, -0.28946903f, -0.11655024f, 
    -0.15855530f, -0.16630740f, 0.04471797f, 0.27892318f, -0.00797943f, 0.10755324f, -0.01160217f, 0.16295469f, 
    0.01281318f, 0.01312182f, 0.15628776f, -0.00993968f, 0.10123252f, 0.03701194f, -0.00280633f, -0.19061707f, 
    -0.14033268f, 0.13051373f, 0.51676017f, 0.06157535f, 0.22082722f, -0.16046782f, 0.21358936f, 0.31257424f, 
    -0.08027546f, 0.13589260f, 0.12484811f, 0.12209427f, -0.23620479f, -0.01702365f, 0.24267606f, -0.16614486f, 
    0.03706715f, 0.54042995f, 0.05467252f, -0.13155928f, -0.16036290f, -0.52442020f, 0.38499498f, -0.21633670f, 
    -0.06581753f, -0.00248240f, -0.06405167f, -0.06545077f, -0.12873696f, 0.02565467f, -0.14896427f, 0.16389021f, 
    0.05631293f, 0.03011567f, -0.14017950f, -0.22183287f, 0.00698603f, 0.21326734f, 0.53968060f, 0.46768442f, 
    0.00872221f, 0.29375634f, 0.03084152f, 0.08694882f, -0.08824345f, -0.06114791f, -0.17766148f, -0.16974249f, 
    0.09591594f, 0.21137755f, -0.03897378f, 0.11121268f, 0.07485822f, 0.16684821f, -0.02058650f, -0.00927383f, 
    0.04365907f, 0.08286218f, 0.11148579f, 0.01698010f, -0.00922407f, -0.17027575f, 0.12935862f, 0.37215981f, 
    -0.03741407f, 0.11162393f, -0.45862252f, 0.16070786f, 0.11254728f, 0.26288888f, 0.01298407f, -0.05865148f, 
    0.46199083f, 0.24099348f, 0.22628051f, -0.03023840f, 0.01572659f, -0.04570214f, 0.06478275f, 0.19922248f, 
    0.18026356f, -0.45914158f, -0.00371071f, -0.05971963f, 0.15053950f, -0.19537909f, -0.02429011f, 0.01626550f, 
    -0.08990558f, 0.08558565f, 0.15607937f, 0.14323911f, -0.12757052f, 0.05830310f, -0.00449182f, -0.36850235f, 
    0.16999157f, 0.13731876f, 0.02114919f, -0.06815189f, 0.21504268f, -0.06318086f, -0.02124264f, 0.11103583f, 
    -0.36737633f, -0.18511778f, 0.23086476f, -0.06601621f, 0.00931181f, -0.03526597f, 0.15566841f, -0.08798302f, 
    -0.17594710f, 0.05403375f, -0.11766012f, 0.27895388f, -0.02143133f, -0.13749813f, -0.25850824f, 0.36681631f, 
    0.34386086f, -0.04737869f, 0.09470693f, 0.08497308f, 0.12641063f, -0.16408691f, -0.16144620f, -0.00228505f, 
    0.11699771f, -0.10157026f, -0.02956779f, -0.07081138f, -0.30830839f, -0.25825870f, 0.08702993f, 0.04805495f, 
    0.32024339f, 0.12247377f, -0.14257680f, 0.07525979f, 0.15351923f, -0.00687490f, 0.29252091f, -0.26184234f, 
    -0.06595268f, 0.00416355f, 0.02071326f, -0.22258194f, 0.17615831f, 0.09067748f, 0.05974884f, 0.01590830f, 
    -0.20228595f, 0.08473732f, 0.03451317f, -0.17662904f, 0.07349584f, 0.11998431f, 0.13041703f, 0.39255497f, 
    -0.08710781f, 0.05693176f, -0.05339858f, -0.01698362f, 0.14663781f, 0.10000405f, -0.72982311f, -0.06205291f, 
    0.18011168f, 0.13747172f, -0.56134391f, 0.07939634f, 0.06151265f, -0.16399013f, -0.07858428f, -0.10288886f, 
    0.06085173f, -0.24648882f, -0.10298978f, 0.01640417f, -0.09650170f, 0.24313140f, 0.35088125f, 0.17627223f, 
    0.37167543f, -0.13654581f, 0.16413870f, -0.07805210f, -0.13248295f, -0.03073796f, 0.05942224f, 0.38632572f, 
    -0.16471922f, -0.02510815f, -0.16073354f, 0.05118456f, 0.14411415f, 0.31192082f, -0.35845369f, -0.53258789f, 
    0.07207514f, 0.12569773f, 0.13497892f, -0.03486973f, 0.26154223f, 0.12958157f, 0.46377698f, 0.04354258f, 
    0.19407780f, 0.23910585f, -0.11916560f, 0.03941704f, -0.02855019f, -0.15800159f, -0.02141232f, -0.13044310f, 
    0.01099793f, -0.03554501f, -0.10400424f, 0.11724587f, 0.10359848f, 0.00769606f, 0.13658378f, -0.22797371f, 
    -0.07536229f, -0.07026952f, 0.33069044f, -0.22654481f, 0.48286319f, -0.03989515f, 0.04304270f, -0.01728764f, 
    0.05451490f, 0.04594324f, 0.06552459f, 0.09852744f, 0.20485330f, -0.09182645f, 0.13998927f, -0.20116207f, 
    -0.23377195f, 0.26506177f, -0.05356455f, 0.19333458f, 0.03449119f, -0.14422809f, -0.05125044f, 0.15376465f, 
    0.36378577f, 0.07725840f, -0.05141038f, -0.17409581f, -0.03582582f, 0.14099810f, 0.04867563f, -0.54517943f, 
    -0.08482435f, -0.09982067f, 0.47100735f, 0.10469151f, -0.12158729f, -0.20293026f, 0.30649731f, 0.00097445f, 
    -0.16359323f, -0.18776624f, 0.09050670f, 0.12221577f, -0.03336777f, -0.12060653f, -0.22695298f, 0.12624107f, 
    -0.02908414f, 0.26177475f, -0.18176427f, 0.03127076f, -0.04437425f, 0.20843621f, 0.50609684f, -0.17394367f, 
    0.30470896f, 0.05960250f, -0.10090031f, 0.09318503f, 0.03841496f, 0.15428106f, -0.07714829f, 0.01209088f, 
    -0.13746038f, 0.09949569f, 0.06278370f, 0.07343990f, 0.05394272f, -0.29122117f, -0.10011714f, -0.54680860f, 
    0.11855536f, 0.23290218f, 0.17778347f, 0.05989670f, 0.23035030f, 0.08355065f, -0.40994054f, -0.16434617f, 
    0.35174417f, 0.36131495f, -0.01220676f, -0.01311819f, 0.13199088f, 0.07375118f, 0.25536633f, -0.19353452f, 
    -0.17952298f, 0.00551788f, -0.11274062f, 0.16832797f, 0.17170437f, 0.05613093f, 0.05703958f, 0.13213022f, 
    -0.07029726f, -0.15038583f, -0.15260434f, -0.20565391f, -0.04295022f, 0.09798405f, -0.57080275f, 0.26424918f, 
    0.22699544f, 0.20641743f, -0.43060246f, 0.04802480f, 0.14155179f, -0.00201860f, 0.27622804f, -0.26355317f, 
    0.20902759f, 0.29184401f, -0.00151116f, -0.26599792f, -0.06821832f, 0.15185669f, 0.01324188f, -0.21028523f, 
    -0.01960477f, -0.16435347f, 0.15517282f, -0.04585739f, 0.02154482f, -0.02732077f, -0.14614782f, 0.36464161f, 
    -0.04217976f, 0.05579267f, 0.16012619f, 0.52553403f, -0.41122124f, -0.27184033f, 0.42964140f, -0.05141683f, 
    0.09296415f, 0.03641216f, 0.31683490f, 0.17219651f, -0.05872018f, 0.09628096f, -0.58034188f, -0.02874390f, 
    0.17489831f, 0.02621843f, -0.12567592f, 0.06504519f, 0.03956221f, 0.11793217f, 0.36428371f, -0.08596636f, 
    -0.41398793f, -0.06939837f, 0.00670413f, -0.14602551f, 0.01314570f, -0.15717031f, 0.15596373f, 0.16211355f, 
    0.09243481f, -0.13777402f, 0.45295942f, -0.01319594f, -0.14822930f, -0.12252120f, -0.36698896f, -0.44484293f, 
    0.26583079f, -0.10558700f, -0.57795787f, 0.04790181f, 0.30335891f, 0.05436375f, 0.19135256f, -0.07313682f, 
    -0.32630661f, -0.02198641f, 0.03433238f, -0.01016647f, -0.18232362f, 0.12409833f, 0.11796719f, 0.22754525f, 
    -0.23414519f, 0.04778951f, 0.12384246f, 0.10409100f, 0.11546391f, 0.02298114f, -0.08969190f, 0.13104761f, 
    -0.07201167f, -0.11910853f, -0.22807199f, -0.23282950f, 0.03864485f, 0.05847570f, -0.08980317f, 0.03228757f, 
    -0.14560534f, 0.17381892f, 0.18185237f, -0.13006932f, -0.10036775f, -0.09333139f, -0.00699336f, 0.06506272f, 
    0.19116673f, 0.40421042f, 0.09814747f, 0.15774548f, 0.08359767f, -0.51926821f, 0.29556215f, 0.09884206f, 
    0.09233091f, -0.14079480f, 0.00008069f, -0.05413409f, -0.11114834f, 0.12452504f, -0.08042943f, 0.28430006f, 
    -0.09211836f, 0.10865631f, -0.34333569f, 0.09893899f, 0.25104603f, -0.20127581f, -0.28237823f, -0.08689028f, 
    0.08719904f, 0.27319452f, -0.28393799f, -0.04954956f, 0.09069625f, -0.04479473f, -0.18581308f, -0.11238604f, 
    0.14892231f, 0.30262423f, -0.09062923f, 0.21306439f, -0.16282505f, -0.03307960f, 0.18684150f, -0.15731771f, 
    0.19157034f, 0.04475693f, 0.13639238f, -0.17440936f, 0.09518311f, -0.06120317f, 0.15402204f, 0.45195347f, 
    -0.03477236f, -0.12380664f, 0.16980219f, 0.21820791f, -0.02494825f, 0.27388358f, -0.09585175f, -0.11013764f, 
    0.35238943f, 0.23254910f, 0.10958450f, 0.12329295f, 0.18375292f, 0.12841576f, 0.32922405f, 0.17607731f, 
    -0.15652436f, -0.04450019f, 0.03277052f, -0.24301441f, -0.11876792f, -0.22827381f, -0.19635518f, -0.16467609f, 
    -0.14400895f, -0.05849116f, -0.09331355f, 0.11623283f, -0.07656348f, -0.08587023f, -0.05283619f, -0.27466983f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.10304985f, 0.32190728f, 0.06220667f, 0.01822506f, 0.23247960f, 0.20907293f, 0.02121967f, 0.10616174f, 
    0.21593790f, 0.07425570f, -0.10007060f, 0.13978046f, -0.03214753f, 0.21695203f, -0.00767228f, 0.16783004f, 
    -0.06848338f, -0.06238491f, 0.06637160f, 0.02004833f, -0.01267937f, 0.29512021f, 0.15128762f, -0.00514855f, 
    0.16795841f, 0.12752160f, -0.12361735f, -0.05667473f, 0.24329259f, -0.03060399f, -0.11076918f, 0.14635961f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.22471569f, -0.61613464f, -0.22460307f, 0.25644526f, -0.11275958f, 0.11666629f, 0.05513878f, 0.06189041f, 
    -0.38054320f, 0.17614982f, -0.23276901f, 0.13248523f, 0.21267734f, -0.11252359f, -0.07519619f, 0.15257642f, 
    0.01500871f, 0.14643967f, -0.10893238f, 0.03252665f, -0.08679934f, -0.26853088f, -0.33333760f, -0.03274439f, 
    0.17456900f, -0.67700219f, -0.25267345f, 0.18234655f, -0.50212985f, -0.10921051f, -0.66194206f, 0.02182490f, 
    0.07710467f, -0.04812931f, -0.03345556f, 0.33383381f, -0.00185430f, 0.16799164f, 0.13106640f, -0.21259257f, 
    -0.02195293f, 0.04327723f, 0.21928416f, -0.03171674f, 0.05757647f, 0.14395368f, -0.02243456f, -0.06761457f, 
    -0.49436289f, -0.17649199f, 0.29373419f, 0.02542519f, 0.43313569f, -0.09142942f, 0.06089305f, -0.09045550f, 
    -0.75595671f, -0.49448812f, -0.05221859f, -0.36325210f, 0.30756798f, -0.04098027f, -0.32622907f, 0.26199180f, 
    0.34535274f, 0.27420667f, -0.49623394f, -0.45954841f, 0.09180264f, 0.09024858f, -0.17768694f, -0.31214172f, 
    -0.01148721f, 0.02613128f, 0.05186640f, 0.03661771f, 0.12151720f, 0.28422061f, -0.00050376f, -0.24896424f, 
    -0.05032553f, 0.03289933f, -0.03713082f, -0.51465726f, -0.26113927f, 0.15492956f, 0.16514650f, -0.52833253f, 
    -0.22305760f, -0.03589807f, -0.04109431f, -0.17068611f, -0.47825676f, 0.22860847f, 0.28437370f, -0.12683718f, 
    -0.16798075f, -0.09119427f, -0.01397673f, 0.05777936f, -0.15139751f, -0.09090278f, 0.20687929f, -0.16845484f, 
    0.11294129f, -0.03168371f, 0.32371825f, 0.23486418f, -0.15463038f, -0.04667140f, 0.05053000f, 0.10851648f, 
    0.15007365f, 0.04766813f, -0.42022604f, 0.23812462f, -0.09240437f, -0.40536252f, -0.32265449f, -0.01758626f, 
    0.24165158f, 0.02739712f, -0.46720383f, 0.05351381f, -0.33405370f, 0.19757994f, -0.09449457f, -0.58472663f, 
    0.09745630f, -0.43561721f, -0.32781783f, -0.02657656f, -0.14063644f, 0.23049626f, -0.09854705f, 0.21201564f, 
    0.28768909f, 0.00328219f, -0.24229401f, 0.09995488f, -0.09513837f, -0.45637038f, -0.21676788f, -0.01838069f, 
    0.23058723f, 0.11318958f, -0.26077420f, -0.44790789f, -0.55569690f, -0.24142459f, 0.02590226f, -0.31489345f, 
    0.09742913f, 0.12920988f, -0.04859696f, 0.28514171f, 0.26208529f, 0.00493273f, -0.13191189f, 0.13095149f, 
    -0.26154441f, -0.02083272f, -0.00029689f, 0.06898017f, 0.09365073f, -0.22395705f, -0.06410564f, 0.16680713f, 
    -0.20121160f, 0.11741540f, -0.33329237f, 0.05327917f, -0.09807135f, 0.27991787f, -0.10932179f, 0.43588361f, 
    -0.37478212f, -0.10503485f, 0.10105234f, -0.28389418f, -0.37393096f, -0.14115186f, 0.24580659f, -0.05214852f, 
    -0.04860016f, 0.26377112f, -0.08459669f, 0.25050974f, -0.08497136f, -0.21811038f, -0.23309262f, 0.22844583f, 
    -0.15557422f, 0.16023625f, 0.17430818f, -0.08129573f, 0.03588642f, -0.13019910f, -0.13994664f, -0.23877294f, 
    0.16341527f, 0.13195504f, -0.05096801f, -0.39982027f, -0.22770566f, -0.30123577f, -0.30875480f, -0.47450593f, 
    -0.38003913f, 0.20144543f, -0.47773930f, 0.00412767f, 0.21405126f, 0.28049111f, 0.06338104f, -0.22973102f, 
    -0.49517080f, -0.01812069f, 0.45663425f, -0.38289523f, -0.10213831f, -0.12031186f, 0.35976875f, -0.08796094f, 
    0.25325030f, -0.14893481f, 0.11640560f, -0.20690054f, -0.44733712f, -0.45520744f, -0.38460699f, 0.21599859f, 
    -0.48136243f, -0.01849674f, 0.01247387f, -0.35573310f, 0.10427947f, 0.12987834f, 0.19023107f, -0.02871718f, 
    0.28672844f, -0.63824224f, -0.27621603f, 0.19049506f, 0.04173103f, -0.06490102f, -0.33835435f, -0.16289866f, 
    0.15948717f, 0.05459639f, -0.03812859f, 0.39477137f, 0.29830617f, -0.24438760f, 0.04287478f, -0.07945808f, 
    -0.65202039f, 0.10363109f, -0.06860697f, -0.11388354f, 0.02973639f, -0.61889344f, 0.28185877f, -0.31623176f, 
    -0.43131179f, 0.08983254f, 0.20094121f, -0.40451768f, -0.18925540f, 0.12462721f, 0.19795033f, 0.09460881f, 
    -0.45065400f, -0.05644301f, -0.57520115f, 0.12864545f, -0.26787171f, 0.11797902f, 0.01683465f, 0.36431950f, 
    0.11964694f, -0.10129380f, -0.33461183f, -0.42949679f, 0.10596634f, -0.75863671f, -0.20158881f, 0.08289561f, 
    -0.03916943f, 0.00043234f, 0.28451696f, -0.77267301f, -0.15814024f, 0.40499741f, -0.51059848f, 0.12639359f, 
    0.02078840f, 0.07786736f, -0.71410465f, -0.01686200f, -0.08576819f, -0.06229509f, 0.23246980f, -0.12175984f, 
    -0.23853278f, 0.35094041f, 0.15122898f, -0.29037255f, -0.05622779f, -0.13202578f, -0.33001438f, -0.22203939f, 
    -0.26883045f, 0.20846900f, -0.03863715f, 0.34568322f, -0.34188625f, -0.14348821f, 0.06238234f, -0.32992759f, 
    -0.82357246f, 0.10846701f, -0.11597049f, 0.18298763f, 0.10340746f, 0.09060494f, 0.32506248f, -0.53081739f, 
    0.31728962f, 0.04934240f, 0.08417894f, -0.31885251f, -0.31687078f, -0.39762127f, -0.43815011f, 0.03248648f, 
    0.10245219f, 0.05183158f, -0.36919579f, 0.37155402f, -0.43611878f, -0.42215493f, 0.20729190f, 0.16126704f, 
    -0.38731000f, 0.04700286f, -0.26556760f, -0.48429790f, -0.44403964f, 0.24109091f, 0.15216143f, -0.18385591f, 
    -0.34866735f, 0.10136805f, 0.17228208f, -0.19486886f, -0.26772800f, 0.37932968f, 0.05015467f, -0.00827171f, 
    -0.47912949f, 0.11152942f, 0.30283701f, -0.13819844f, -0.80331558f, 0.03932010f, 0.22907342f, -0.62047821f, 
    0.53118050f, -0.07014650f, -0.04004865f, -0.38761273f, -0.10716771f, -0.25702396f, 0.19925225f, 0.16610141f, 
    -0.26022449f, 0.13327301f, 0.11791278f, -0.56406009f, -0.16883415f, -0.13811415f, -0.15178700f, 0.27573320f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.14240827f, 0.17231177f, -0.04456268f, -0.07844873f, 0.07142228f, 0.18591467f, -0.12356019f, -0.31701499f, 
    0.23525725f, 0.20453398f, 0.00242540f, -0.10135429f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
