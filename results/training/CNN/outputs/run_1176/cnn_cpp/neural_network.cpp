#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.34365672f, 0.14980088f, -0.49444655f, -0.12024672f, 0.19594219f, -0.02349725f, -0.56105626f, -0.41572866f, 
    -0.07709631f, -0.46239007f, 0.00533881f, 0.22523473f, 0.09833406f, -0.20722483f, -0.21831599f, -0.02905710f, 
    0.23008116f, 0.18664813f, 0.04510759f, 0.06080849f, 0.09902846f, -0.01944995f, -0.28388241f, 0.02763344f, 
    0.22440527f, -0.08608047f, 0.09730173f, -0.20666024f, -0.18094693f, 0.00807393f, -0.26111788f, -0.20318231f, 
    -0.22179149f, -0.25521851f, -0.17259151f, -0.00306783f, -0.42325908f, -0.03958938f, 0.20124041f, 0.10233704f, 
    -0.17277400f, -0.20415220f, -0.27191478f, -0.14085507f, -0.42555231f, -0.30182138f, -0.11505448f, 0.03188667f, 
    -0.36469793f, -0.40683544f, -0.63248456f, 0.05055256f, 0.07490924f, 0.67721194f, -0.48260781f, -0.18348357f, 
    -0.60882801f, -0.23856227f, 0.28844136f, 0.60922593f, 0.04761988f, 0.32142141f, -0.16148050f, -0.16974801f, 
    -0.17875051f, 0.26290229f, -0.20007905f, 0.20244943f, -0.32217699f, 0.22773537f, 0.36670634f, -0.36037183f, 
    -0.16004732f, 0.18664728f, 0.08991298f, 0.42687288f, 0.18920189f, -0.14785235f, -0.20229714f, -0.02543556f, 
    0.09217983f, -0.33279371f, 0.10910539f, -0.15949577f, -0.48580804f, -0.16193080f, 0.10739978f, -0.08074549f, 
    0.52549314f, -0.22798830f, -0.03598814f, 0.01180466f, -0.11537665f, 0.15185584f, 0.05588086f, 0.30619925f, 
    -0.14735119f, -0.30788633f, -0.29790118f, 0.21541907f, 0.38830909f, -0.83340174f, -0.34191224f, 0.31013513f, 
    0.43046147f, 0.15453772f, 0.34562227f, 0.30565232f, -0.01560978f, -0.55339074f, -0.31381270f, -0.08486961f, 
    -0.18791920f, 0.16529496f, -0.14569978f, 0.28415325f, -0.30611369f, -0.16740327f, 0.42803144f, -0.13359290f, 
    0.10541628f, 0.13993949f, -0.12842557f, -0.16171381f, 0.08240953f, 0.40329531f, -0.28369308f, -0.51915795f, 
    -0.16143127f, -0.57441425f, 0.06616687f, 0.05146354f, -0.31987619f, -0.24125053f, -0.46526724f, 0.08462549f, 
    -0.25073358f, 0.08823261f, -0.21621534f, -0.38433492f, -0.30269545f, -0.26298624f, 0.36259228f, -0.39623362f, 
    -0.20449200f, -0.17672934f, -0.22345623f, 0.16058791f, 0.24288328f, 0.13108839f, 0.36384058f, 0.36180425f, 
    0.27510285f, 0.00174999f, -0.42236072f, -0.44881070f, -0.08856554f, -0.44352743f, 0.16724560f, 0.14703950f, 
    0.40819329f, -0.10762992f, -0.19765666f, -0.23161504f, 0.35886797f, 0.21336195f, -0.09163442f, 0.11552572f, 
    0.16430728f, -0.29468814f, -0.04088393f, 0.17585336f, 0.21691093f, 0.00528987f, -0.31545067f, 0.28622103f, 
    -0.08470383f, 0.06908727f, -0.41050321f, 0.10169461f, 0.08699121f, 0.42509300f, -0.11455010f, -0.46359384f, 
    -0.37678903f, 0.26739302f, -0.04498103f, 0.04982036f, 0.02873412f, -0.33542165f, -0.25517535f, -0.32045683f, 
    0.10335345f, -0.19250374f, -0.15406546f, 0.42475390f, -0.06402814f, -0.24651614f, -0.31815377f, -0.23164879f, 
    0.14449346f, -0.19781333f, -0.02228479f, 0.22282518f, 0.13151537f, -0.43891001f, -0.09391365f, 0.22442147f, 
    0.10057575f, 0.00229995f, 0.28438732f, -0.38921928f, -0.01609207f, 0.16435261f, 0.16084081f, -0.11996278f, 
    0.38776514f, -0.33937359f, -0.14600649f, -0.34574172f, 0.06199089f, 0.09314641f, 0.20716991f, 0.00701611f, 
    0.05830539f, 0.23890638f, 0.28448263f, -0.11599092f, 0.50940335f, -0.69617206f, -0.39377293f, -0.40085942f, 
    -0.08862105f, 0.02314577f, -0.12830408f, -0.18991727f, -0.04060619f, 0.16550532f, 0.28200689f, 0.45352009f, 
    0.06916412f, 0.21388920f, 0.16458839f, -0.31064963f, -0.10598730f, -0.07994319f, -0.24548402f, -0.21991684f, 
    -0.10987943f, -0.07112382f, 0.38357809f, -0.34589693f, -0.36168459f, 0.49552900f, 0.44661739f, -0.25778255f, 
    -0.12867564f, -0.24822803f, 0.37618628f, -0.29967248f, -0.24577828f, -0.36882678f, 0.26753259f, 0.21545336f, 
    0.05742244f, 0.27680251f, -0.02518881f, 0.22597003f, -0.30511656f, -0.13166487f, -0.26612222f, 0.12315172f, 
    -0.17505404f, -0.07235794f, -0.05692950f, 0.07403303f, 0.23635553f, 0.35513860f, 0.07860280f, -0.06000308f, 
    0.01124647f, -0.02948536f, 0.21182534f, 0.23973563f, -0.24679105f, -0.24544376f, -0.12122500f, -0.31144705f, 
    0.34813964f, -0.20113650f, 0.36908251f, 0.25816315f, 0.00913525f, -0.21767792f, -0.37727654f, -0.25142193f, 
    -0.08055764f, -0.19019377f, -0.17446619f, -0.00241727f, -0.51687616f, 0.38156831f, 0.05395433f, -0.10251101f, 
    0.19468129f, 0.31033844f, -0.05316595f, -0.03709397f, 0.01706483f, -0.31996244f, -0.07771416f, 0.01096696f, 
    -0.00388735f, -0.16158190f, 0.17064305f, 0.60473168f, -0.13871774f, -0.31028122f, -0.07937331f, -0.14682660f, 
    -0.49979085f, 0.34287834f, -0.17564167f, 0.22622550f, 0.27953690f, 0.55874735f, 0.88251269f, 0.33047253f, 
    -0.68561709f, -0.52252990f, -0.52891165f, -0.22924894f, 0.18782741f, -0.18101519f, -0.22325131f, 0.03364016f, 
    0.48266783f, 0.02307674f, 0.25122830f, -0.11221097f, -0.04524910f, 0.12572342f, -0.31228724f, -0.18617480f, 
    -0.28512803f, -0.10373534f, 0.00477753f, 0.03092088f, 0.16678455f, -0.12894513f, -0.65527242f, -0.38482049f, 
    -0.43648285f, -0.28112978f, -0.25228304f, 0.00224668f, -0.23181865f, 0.29214847f, 0.52292871f, 0.46623725f, 
    0.37930399f, -0.06822689f, 0.18384312f, 0.06653493f, 0.15258795f, 0.12769943f, 0.12138245f, 0.05033276f, 
    0.04783902f, -0.07274324f, -0.02605698f, -0.17377323f, 0.13331297f, -0.07067052f, -0.32364929f, 0.25205332f, 
    0.73967957f, -0.12088267f, -0.52055311f, 0.08654605f, -0.21879785f, 0.13176093f, 0.09032431f, -0.15696056f, 
    -0.26328292f, -0.03412384f, 0.20112279f, 0.32398751f, 0.03213616f, -0.42104453f, -0.12645039f, -0.37329867f, 
    0.07897648f, 0.50247484f, -0.08204497f, 0.01055543f, 0.13688786f, -0.15598294f, 0.16089723f, -0.33306134f, 
    -0.04588124f, -0.26346326f, -0.23017429f, -0.24252288f, -0.09891622f, -0.25985676f, 0.18148774f, 0.12611660f, 
    0.01579776f, 0.30205530f, 0.09258246f, 0.05276793f, -0.14282089f, 0.11816360f, 0.34409535f, -0.31433687f, 
    -0.15263641f, -0.16783936f, -0.25080782f, -0.26865882f, -0.11974397f, -0.13621832f, -0.16358620f, -0.24205260f, 
    -0.10525381f, -0.11334922f, 0.37981361f, 0.02798439f, 0.32116601f, 0.14229791f, 0.11319052f, -0.35225800f, 
    -0.16586946f, -0.45431641f, -0.58586532f, -0.01393531f, 0.33768952f, -0.09915145f, 0.13661952f, 0.24745403f, 
    0.13861346f, -0.13719822f, 0.16339153f, -0.19369446f, 0.18223482f, -0.20094386f, 0.04935940f, 0.18495651f, 
    0.03343610f, -0.11861870f, 0.10463531f, 0.22074257f, -0.25720537f, 0.16447525f, 0.23616825f, 0.11926397f, 
    -0.18595640f, -0.25300884f, -0.19532520f, -0.02185144f, 0.41158298f, -0.04624858f, 0.06216333f, -0.19320977f, 
    0.27096370f, -0.17830056f, 0.01610521f, 0.07085011f, 0.11541177f, 0.22374785f, 0.07917139f, 0.00693866f, 
    -0.08386125f, 0.02633020f, 0.22194842f, 0.99527222f, -0.51013732f, -0.71749490f, -0.23783702f, -0.66910499f, 
    0.26275745f, -0.02637161f, 0.07424867f, 0.18004173f, -0.05707621f, 0.24844386f, 0.25280315f, 0.06259185f, 
    -0.18435575f, 0.39829412f, 0.08951938f, 0.14045875f, 0.00331349f, -0.26451701f, -0.22881426f, 0.14213715f, 
    -0.33366033f, -0.11836037f, 0.17253062f, 0.32463410f, 0.19852370f, -0.08020021f, -0.14625236f, 0.31494442f, 
    0.40512177f, -0.58338517f, -0.49889079f, -0.12901521f, 0.01394942f, 0.57663292f, 0.02172230f, 0.05098776f, 
    -0.13913278f, 0.00285990f, -0.05356954f, 0.04722527f, 0.08467437f, -0.19500221f, 0.04129536f, -0.08782890f, 
    -0.00086597f, 0.26755685f, -0.20154203f, -0.01716452f, -0.25827932f, 0.06128068f, -0.47177958f, -0.05089780f, 
    0.09848741f, -0.31080335f, -0.57173610f, -0.33189026f, -0.28838006f, -0.13485502f, -0.29316381f, -0.23849533f, 
    0.06889725f, 0.00792971f, 0.05597681f, 0.15499505f, -0.17338379f, 0.01806423f, -0.27609974f, -0.21825857f, 
    -0.30330917f, 0.04001943f, -0.25614938f, -0.33400694f, -0.33542648f, -0.41353810f, 0.08057909f, -0.59235752f, 
    -0.09588459f, 0.28766051f, 0.46895748f, -0.30991495f, 0.19094372f, 0.09293105f, 0.11327606f, -0.02359530f, 
    0.00644757f, -0.42178065f, 0.27534187f, -0.38087451f, 0.25572351f, -0.08285632f, 0.08050218f, 0.05957689f, 
    -0.04444853f, 0.07394531f, 0.31865653f, -0.24600348f, -0.04301843f, -0.14143507f, -0.33555302f, -0.07725887f, 
    0.76137674f, 0.43619183f, -0.58145744f, -0.50748199f, -0.38932785f, 0.01699243f, 0.13141072f, -0.40032440f, 
    -0.59434605f, 0.02861720f, 0.31905699f, 0.17939024f, -0.33213285f, 0.15569919f, 0.21414474f, 0.30232540f, 
    -0.19944355f, -0.12492459f, 0.17239599f, 0.11505833f, -0.17058535f, -0.11120892f, -0.43997934f, 0.16145362f, 
    0.44372031f, 0.05578576f, 0.17591506f, 0.15890729f, 0.08243059f, -0.33096978f, 0.27487320f, -0.03860563f, 
    0.05954207f, -0.26355273f, -0.19918130f, 0.01691311f, -0.00313455f, -0.16763903f, -0.14147769f, -0.13368537f, 
    0.05274068f, 0.21499874f, -0.05173071f, 0.09394531f, 0.23789211f, -0.15409905f, -0.18856110f, -0.32743439f, 
    -0.19655840f, -1.37195790f, -0.33552718f, -0.29206371f, 0.62999320f, 0.60692877f, -0.27969244f, 0.15210834f, 
    0.51765847f, 0.02944714f, 0.06501439f, -0.00885466f, -0.07767882f, -0.13323975f, 0.65055501f, -0.45767200f, 
    0.08698154f, 0.17622118f, -0.15463865f, -0.10928658f, -0.02701160f, 0.05195923f, -0.06248454f, 0.18521900f, 
    0.20406774f, -0.24551074f, -0.00279399f, -0.38933957f, -0.55277234f, -0.18434024f, -0.26561284f, 0.18376942f, 
    0.35621238f, 0.33318496f, 0.12810683f, 0.13923615f, -0.16677578f, 0.30601344f, 0.30988872f, 0.05081346f, 
    0.16993222f, -0.17396869f, 0.20646307f, -0.09325157f, -0.39962205f, -0.23333174f, -0.17885438f, -0.01596061f, 
    0.05997251f, 0.02232238f, -0.26446971f, 0.17799209f, 0.31252190f, 0.22962128f, 0.21818949f, 0.12799239f, 
    0.31442243f, 0.28992337f, -0.06921233f, 0.14180611f, 0.00182830f, 0.08288947f, 0.12850702f, -0.04771773f, 
    -0.32759655f, 0.01397548f, 0.06117147f, -0.09736288f, -0.06153427f, -0.08419421f, -0.15096183f, 0.03286467f, 
    -0.04239278f, 0.06471293f, -0.16606121f, 0.11024544f, -0.36710674f, -0.29657882f, -0.08992626f, 0.04065496f, 
    -0.23213537f, 0.39108041f, -0.31628484f, 0.16791676f, 0.45689699f, 0.23927277f, -0.12023277f, 0.26692709f, 
    -0.30685592f, 0.09052533f, -0.12467747f, -0.08467004f, -0.02243575f, 0.11153872f, -0.25764966f, 0.13453551f, 
    0.33190361f, 0.02941520f, 0.04296849f, -0.08951438f, 0.07447469f, 0.49215358f, -0.07346546f, 0.34035981f, 
    0.19254301f, -0.16744591f, -0.63778377f, 0.09694721f, 0.16853565f, -0.30975199f, -0.04569544f, -0.06573766f, 
    -0.10940823f, 0.48398551f, -0.25199020f, -0.38300496f, -0.10975111f, -0.09222767f, 0.15982598f, 0.22738290f, 
    -0.00409698f, -0.01738589f, 0.01287454f, -0.12303050f, 0.18136641f, 0.22286259f, -0.80546254f, 1.07595706f, 
    0.16110322f, -0.98944026f, 0.49314636f, -0.36623967f, 0.06770597f, 0.62832689f, -0.27456534f, -0.19088821f, 
    -0.44072434f, -0.09998515f, -0.08196715f, 0.02566152f, 0.03815356f, 0.23258747f, -0.03120886f, -0.27798808f, 
    0.22956929f, -0.05504715f, 0.06062089f, 0.05172773f, -0.27966666f, 0.18576697f, -0.31644073f, -0.43197000f, 
    -0.00130734f, -0.72110415f, -0.70164073f, -0.13282689f, 0.19085552f, 0.31549093f, 0.02917085f, -0.11264561f, 
    0.12019206f, 0.21074466f, 0.42848548f, -0.10872793f, -0.17114650f, 0.25746226f, -0.63691562f, -0.36313888f, 
    0.10964643f, -0.10404849f, -0.46169463f, 0.34027812f, -0.06442934f, 0.14819413f, -0.00394768f, 0.41546506f, 
    0.21886109f, 0.80489868f, 0.47375768f, -0.39737830f, -0.62085390f, -0.56330669f, -0.49141222f, -0.07105872f, 
    -0.19131805f, -0.17585674f, 0.29499239f, 0.19263707f, 0.04731509f, 0.34744725f, -0.25730810f, -0.26046956f, 
    0.03980730f, 0.27833152f, 0.27227777f, -0.28594559f, 0.32099620f, 0.10895507f, -0.24243067f, -0.40380955f, 
    -0.14334230f, -0.44708905f, -0.76156884f, -0.18267924f, 0.01453330f, 0.34677991f, 0.43878865f, -0.02039690f, 
    -0.28422827f, -0.30132970f, 0.24120869f, 0.18079866f, 0.15471770f, 0.25620541f, -0.42297226f, 0.25689206f, 
    -0.10120860f, 0.16398442f, -0.24677452f, -0.24298689f, 0.36209986f, 0.15477692f, -0.44005355f, -0.12821053f, 
    0.17410511f, 0.01978904f, -1.02638125f, -0.59584397f, -0.04253743f, 0.44981670f, 0.12487726f, 0.47892350f, 
    -0.08665406f, 0.33637857f, 0.08484969f, 0.39521024f, 0.00494651f, -0.18778513f, -0.50701451f, -0.15115812f, 
    0.07054609f, 0.24784669f, 0.03929930f, -0.06049950f, 0.14717934f, 0.27774817f, -0.08854742f, -0.24137934f, 
    -0.10356698f, 0.11399173f, 0.01551978f, -0.31278536f, -0.21305580f, -0.66897416f, -0.52781636f, -0.12833898f, 
    -0.21361428f, -0.41072661f, -0.57535762f, -0.54516643f, -0.29823557f, 0.52623844f, 0.60635751f, 0.48746264f, 
    0.06099091f, 0.02336702f, -0.06280232f, 0.02435428f, -0.27813253f, -0.18148880f, -0.18686630f, -0.06558583f, 
    -0.12986122f, -0.13063350f, 0.17605928f, -0.40842363f, -0.35637742f, -0.14374545f, 0.04704232f, 0.20606770f, 
    0.28003493f, -0.34424767f, -0.16049853f, -0.28529066f, -0.17116338f, 0.43001437f, 0.37469572f, -0.25844124f, 
    0.02195777f, 0.10680117f, 0.21118996f, -0.22990143f, 0.24713697f, -0.06278785f, -0.43104628f, -0.23233317f, 
    0.11840643f, 0.25472268f, 0.18868704f, 0.15560579f, 0.31542325f, -0.30143937f, -0.36538127f, -0.42826515f, 
    0.14925951f, 0.12880602f, -0.25430211f, 0.35405380f, 0.01156789f, -0.03027044f, 0.01373856f, -0.01744075f, 
    -0.10029674f, -0.16699061f, -0.22836836f, -0.05710644f, -0.41259155f, -0.04680708f, 0.33586952f, -0.01409139f, 
    -0.38066304f, 0.03646910f, 0.29842475f, 0.29066586f, -0.23082852f, 0.18565232f, 0.65390933f, -0.81561589f, 
    -0.84602952f, -0.83022064f, -0.84186357f, 0.35922423f, 0.27291110f, 0.46954361f, 0.44923201f, -0.04241435f, 
    -0.00066076f, 0.00053054f, 0.11157072f, -0.15834688f, 0.05512632f, 0.19261543f, -0.16895267f, 0.00412983f, 
    0.07127659f, 0.06627841f, -0.07264964f, -0.09326131f, -0.12703729f, -0.09346722f, -0.19357264f, -0.47546262f, 
    0.00586922f, -0.37145296f, 0.41359347f, 0.29208073f, -0.38214853f, -0.33573523f, 0.13049591f, 0.37632924f, 
    0.35542420f, 0.12198323f, -0.28470692f, 0.05982812f, 0.50124878f, -0.27574465f, -0.28758660f, -0.02722597f, 
    0.38142854f, 0.19795787f, -0.38980111f, -0.26538119f, 0.19484068f, 0.14658950f, -0.00759037f, 0.12726022f, 
    -0.58296895f, -0.04396170f, -0.21085465f, -0.72419399f, -0.39601645f, 0.14040330f, 0.44718224f, -0.09855949f, 
    -0.05069422f, 0.23225687f, 0.12512334f, -0.01993999f, -0.23715489f, -0.38174433f, -0.35230178f, -0.01635661f, 
    -0.00235493f, 0.10004006f, -0.03958666f, -0.25366187f, -0.24186566f, -0.04053537f, -0.42126140f, -0.35798341f, 
    -0.24338841f, 0.05078525f, -0.77205050f, -0.15336971f, 0.34956491f, 0.64635491f, 0.10686487f, 0.41119322f, 
    0.05467333f, -0.26842287f, -0.31420437f, -0.37920779f, -0.36057416f, 0.64905137f, -0.45939523f, 0.00165678f, 
    -0.08872462f, -0.15808919f, -0.05445749f, 0.27174243f, 0.19131938f, -0.09128327f, -0.26156789f, -0.05382016f, 
    0.08692346f, 0.32437471f, -0.86224896f, -0.01569580f, -0.18441634f, 0.11950351f, 0.37801728f, 0.15766595f, 
    -0.08032589f, 0.23018521f, 0.41082475f, 0.16248527f, -0.10486297f, 0.12600186f, 0.19678925f, -0.24551056f, 
    -0.01559826f, -0.17296149f, 0.14804073f, -0.06948991f, -0.23417677f, 0.07255644f, 0.07246263f, 0.05778375f, 
    0.11035973f, -0.07826608f, 0.01448052f, 0.63279462f, 0.74701548f, 0.31843179f, 0.29113796f, -0.40659070f, 
    -0.56086785f, -0.53704315f, -0.21558988f, -0.11253199f, -0.24584340f, 0.04684335f, 0.19222821f, 0.04169884f, 
    -0.21779318f, 0.09645961f, -0.12448494f, 0.13027160f, -0.30351880f, 0.00836700f, -0.00225990f, -0.12503731f, 
    0.17523885f, -0.11226234f, -0.03606397f, 0.00459314f, 1.07314289f, -0.60829538f, -0.19511241f, -0.59839392f, 
    -0.50280035f, -0.02408612f, -0.14853267f, 0.38795114f, 0.24075575f, 0.14884745f, -0.17176072f, 0.46132019f, 
    -0.29854476f, -0.23488699f, 0.09999143f, -0.19655733f, 0.31026843f, 0.16544761f, -0.16982895f, -0.26906765f, 
    0.07620223f, 0.13810612f, -0.09881292f, -0.04938260f, 0.11761694f, 0.13627946f, 0.58904696f, 0.07615420f, 
    0.21601143f, 0.07191015f, -0.46510968f, -0.40420079f, -0.15714735f, 0.19524434f, 0.03188515f, 0.00548839f, 
    -0.32083535f, -0.28744495f, -0.03942006f, 0.14523904f, 0.30665833f, 0.36534700f, 0.24746317f, -0.09373973f, 
    -0.45545149f, -0.28384113f, -0.08756629f, -0.29174784f, -0.29201722f, -0.30262294f, -0.32825655f, -0.27706218f, 
    -0.49511722f, -0.41008502f, -0.02706200f, 0.04408867f, -0.00078070f, -0.42738318f, 0.04596236f, -0.47111061f, 
    -0.09172496f, -0.29882795f, 0.34738287f, 0.19957855f, -0.38818139f, 0.08165591f, -0.27085438f, 0.22710882f, 
    -0.20573510f, 0.09987511f, 0.11785837f, 0.39461631f, 0.11979578f, 0.11545023f, 0.09218325f, 0.21670981f, 
    -0.20630392f, -0.00179586f, 0.05133174f, -0.07553219f, -0.24263795f, 0.14890619f, 0.16008356f, -0.05400858f, 
    0.04245712f, -0.11760473f, -0.11002097f, 0.08411501f, 0.30827746f, -0.17155522f, -0.13100231f, 0.11004627f, 
    -0.25470522f, 0.13569908f, -0.26795498f, 0.11101925f, 0.08321454f, 0.11813038f, -0.17193870f, 0.18981211f, 
    -0.66039181f, 0.57137650f, -0.21070434f, -0.18010728f, 0.21230333f, -0.31538239f, 0.13582885f, 0.24658516f, 
    0.37208766f, -0.18373147f, -0.14600958f, -0.16144094f, 0.00880587f, 0.09267333f, 0.01153648f, 0.15829001f, 
    0.04195211f, -0.31401598f, 0.01609459f, -0.13699709f, 0.20743644f, -0.32919866f, 0.07879509f, 0.35125902f, 
    0.00130375f, -1.24174178f, -0.34203863f, 0.16435656f, -0.97345525f, -0.79794967f, 0.75467211f, 0.35296011f, 
    0.21374133f, 0.03991257f, 0.70065701f, 0.14030458f, -0.20181164f, 0.18219952f, -0.29016906f, -0.17772926f, 
    0.03309675f, 0.05984100f, 0.03765782f, -0.14009534f, 0.08380598f, -0.00330369f, 0.28358483f, 0.00354243f, 
    0.13955522f, -0.09834706f, 0.38328636f, 0.31966031f, 0.16337146f, -0.27850902f, 0.19147980f, -0.25419286f, 
    0.25063220f, -0.01800909f, -0.07200442f, -0.07558337f, -0.02655259f, -0.04771944f, 0.24233761f, -0.06612208f, 
    -0.06183534f, 0.01307856f, -0.31444693f, -0.10374320f, -0.11589953f, 0.28609881f, 0.06316298f, 0.41354132f, 
    0.27193034f, -0.24624482f, -0.28519723f, -0.13013971f, -0.43625635f, -0.29749507f, -0.17658946f, -0.60704207f, 
    0.25278962f, 0.21106483f, -0.36090472f, -0.41576988f, 0.61901391f, -0.17374143f, -0.34982783f, -0.41957104f, 
    0.07899176f, 0.20692883f, -0.31815135f, -0.31390730f, -0.38214710f, -0.29116499f, -0.29703984f, -0.13081084f, 
    -0.39517680f, 0.30007389f, 0.24858640f, -0.08536503f, -0.24476910f, 0.08015595f, -0.12741479f, -0.19788346f, 
    -0.47367573f, -0.42616466f, -0.31476817f, -0.31045258f, -0.49114138f, -0.50834423f, -0.15729053f, -0.13875273f, 
    0.31896260f, -0.13682733f, 0.17826927f, 0.00701166f, -0.45087770f, -0.04987581f, -0.21320398f, -0.42838392f, 
    0.10762838f, 0.03778092f, -0.12124143f, -0.05302035f, 0.31024462f, 0.35266554f, 0.02197131f, 0.05781265f, 
    -0.06454242f, 0.20925476f, 0.34987575f, 0.19907618f, 0.15175098f, 0.18267351f, -0.14366975f, 0.13380389f, 
    -0.13048545f, -0.00299372f, 0.20315653f, 0.13701424f, -0.04045664f, -0.13447070f, -0.10047083f, -0.16995679f, 
    0.12837115f, -0.19544479f, 0.18214104f, 0.05041984f, -0.03828568f, -0.01020745f, 0.72773492f, 0.21189277f, 
    -0.00769115f, -0.56003475f, -0.68038267f, 0.35519215f, 0.20244217f, 0.04456540f, -0.24438110f, -0.15534581f, 
    0.21920946f, 0.50705457f, -0.27440900f, -0.18451628f, -0.18652639f, -0.15097970f, -0.21618381f, 0.14568517f, 
    -0.32246497f, -0.04025047f, 0.19945699f, -0.07186139f, 0.04007155f, 0.21604535f, 0.22704762f, 0.51849067f, 
    -0.24860948f, 0.15892024f, 0.19804107f, -0.44034240f, -0.51860577f, -0.21718369f, 0.37671760f, 0.47225401f, 
    -0.40905130f, -0.16233166f, -0.40610999f, -0.00887409f, 0.62621111f, -0.25590736f, -0.21618697f, 0.10694481f, 
    0.20943518f, -0.06291911f, -0.13846821f, -0.15511499f, 0.06984614f, -0.35029101f, 0.12227257f, 0.02664847f, 
    -0.64368343f, 0.00695467f, 0.07324351f, 0.15453848f, 0.05369378f, -0.19837558f, 0.40373448f, -0.23131999f, 
    0.43356347f, -0.00014402f, 0.09155523f, 0.07938695f, -0.13026011f, 0.07991165f, 0.00549105f, -0.12189537f, 
    -0.02238053f, -0.15110525f, -0.09561327f, -0.33592016f, -0.05197863f, 0.03479154f, 0.02516556f, 0.29934248f, 
    0.28682011f, 0.34487653f, 0.05964818f, -0.36244565f, -0.18727115f, -0.27279204f, -0.11881964f, -0.14777426f, 
    0.41871667f, -0.31473678f, -0.30284354f, -0.27380493f, -0.07606749f, -0.08703775f, 0.30158073f, -0.07550500f, 
    0.42296356f, -0.10794815f, -0.19006510f, 0.06928410f, -0.35063961f, -0.32361913f, -0.04449454f, -0.22353142f, 
    -0.37553144f, -0.48288047f, -0.57976645f, -0.43222111f, -0.24008125f, -0.29810423f, 0.16659176f, -0.10803998f, 
    -0.37087110f, -0.48865968f, -0.16341421f, -0.10499088f, -0.20208298f, -0.17755601f, -0.04847926f, -0.14548674f, 
    -0.26348603f, -0.08133534f, -0.10905679f, -0.10658053f, 0.09403887f, 0.08335178f, -0.06591800f, 0.13012925f, 
    -0.08572201f, -0.32689348f, -0.08135876f, 0.27109873f, 0.08541477f, 0.01058889f, -0.08441333f, 0.14101984f, 
    -0.23560382f, -0.32907841f, -0.12143921f, 0.25097072f, 0.20810483f, 0.24921432f, -0.03774101f, -0.18871953f, 
    -0.15823352f, 0.10325865f, -0.35686454f, 0.12054306f, 0.12566227f, 0.23852040f, -0.04749315f, 0.12168406f, 
    0.04062806f, -0.22073978f, 0.21702302f, 0.07437947f, 0.70806962f, -0.04065318f, -0.13719636f, -0.33251897f, 
    -0.52030897f, 0.24643129f, 0.71909469f, -0.24346992f, -0.25024468f, 0.17628384f, 0.08273862f, -0.07853219f, 
    -0.09537207f, 0.06744098f, 0.11594693f, 0.05680871f, -0.02808972f, -0.32115379f, 0.20593844f, 0.10213903f, 
    -0.05392147f, -0.14237992f, -0.21340604f, 0.05359452f, 0.13609357f, 0.29568946f, -0.28927264f, -0.46758085f, 
    -0.16806068f, 0.31421572f, -0.32798153f, 0.00020800f, 0.44222036f, 0.05544320f, -0.39193839f, 0.18959077f, 
    0.34603420f, 0.08963449f, 0.11765707f, -0.47032210f, 0.29566455f, -0.06197893f, -0.37126678f, -0.18022862f, 
    -0.04707434f, 0.27208725f, 0.07511539f, 0.06445539f, 0.34548104f, -0.02560374f, -0.25550294f, -0.20540234f, 
    -0.18953229f, 0.31258446f, 0.30357760f, 0.36743894f, 0.51456636f, 0.27626249f, 0.23422897f, -0.06079581f, 
    0.17988545f, 0.00030908f, 0.21082090f, -0.17741984f, -0.00277664f, 0.14533319f, 0.11386686f, -0.02902364f, 
    -0.22942708f, -0.09324542f, -0.10516857f, 0.03385882f, -0.02776114f, 0.26001486f, 0.12060934f, -0.82372373f, 
    -0.68573976f, 0.12211420f, -0.17973402f, 0.40558058f, 0.17711467f, -0.15105329f, -0.06960878f, -0.47391534f, 
    -0.06817639f, -0.22223151f, -0.24848585f, -0.25384659f, -0.23366171f, -0.16839644f, 0.09802957f, 0.07372288f, 
    -0.00543067f, 0.27056342f, 0.16426586f, 0.22918336f, -0.08629297f, 0.01003232f, 0.15052365f, 0.02436001f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12163273f, -0.20732291f, -0.04794929f, 0.09010838f, 0.20137535f, -0.00744239f, 0.03141369f, -0.30484930f, 
    -0.03841093f, -0.23078983f, -0.06843416f, -0.13972288f, 0.17067248f, 0.03242105f, 0.09736864f, 0.17199163f, 
    -0.17160097f, -0.07441637f, -0.13599190f, -0.01619305f, 0.14737643f, -0.20496824f, -0.08075709f, -0.00445188f, 
    0.04937503f, 0.14631540f, 0.06656071f, -0.39817071f, -0.21406196f, 0.00684430f, 0.07280575f, -0.01009006f, 
    -0.07169110f, 0.31500497f, -0.17030025f, -0.19656628f, 0.05411740f, 0.12240008f, 0.16878581f, 0.10636680f, 
    -0.20573851f, 0.11389270f, 0.07262758f, 0.10428514f, 0.21453680f, -0.17790523f, -0.12532607f, 0.01467729f, 
    0.12741509f, -0.06240186f, 0.00807880f, -0.15522857f, -0.15432461f, -0.31421155f, 0.14524071f, 0.27991438f, 
    0.04859714f, -0.04914437f, -0.34155622f, 0.21059453f, 0.08669768f, -0.03237923f, -0.25460920f, -0.22741616f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02254402f, 0.01153262f, 0.00489373f, -0.03456405f, 0.00911481f, -0.00277948f, -0.01673020f, 0.00686487f, 
    0.01412944f, -0.03607355f, -0.00944573f, 0.01367040f, -0.02189628f, -0.00863414f, -0.01609042f, 0.00729429f, 
    0.01378529f, -0.01236140f, -0.01930337f, -0.01757981f, 0.02897472f, 0.01993491f, 0.01726962f, 0.02234035f, 
    -0.01253067f, 0.02350196f, 0.02500609f, -0.01603452f, 0.02728009f, 0.01449762f, -0.03925109f, -0.00166300f, 
    0.02844373f, -0.01014120f, 0.01173705f, -0.02615434f, 0.01265689f, 0.02203381f, -0.01423355f, -0.00670886f, 
    0.01116832f, 0.00950956f, -0.03506637f, -0.02833778f, -0.03615937f, 0.01796529f, -0.01905779f, -0.04186519f, 
    -0.02819486f, 0.00452215f, 0.01612168f, -0.02138242f, -0.03927663f, 0.00680102f, 0.01690992f, 0.02438909f, 
    -0.03562073f, -0.03352585f, 0.01065299f, 0.01928956f, -0.00349632f, -0.00903570f, -0.03366343f, -0.01026797f, 
    -0.01541763f, -0.00884769f, -0.00972411f, 0.01083878f, -0.02841119f, -0.02031155f, -0.02153477f, 0.02763223f, 
    -0.01663473f, -0.00537640f, -0.02916982f, -0.00857240f, -0.00140542f, -0.01276516f, 0.01655096f, -0.03327710f, 
    -0.02216652f, -0.02640064f, -0.01369138f, -0.03268450f, -0.01605647f, 0.00800694f, 0.01932752f, 0.00902351f, 
    -0.03290259f, 0.00796254f, -0.01141890f, -0.04088712f, -0.04155485f, -0.00270075f, -0.04075417f, 0.02624943f, 
    0.00108545f, -0.02977240f, -0.02823451f, 0.00341002f, -0.01049742f, -0.02687198f, -0.02570792f, -0.01835775f, 
    -0.00616762f, -0.00125453f, 0.00565999f, 0.01278977f, -0.00400601f, -0.00171532f, 0.02009113f, -0.00668095f, 
    0.02629424f, -0.01866422f, 0.02784799f, 0.01989198f, -0.03913721f, -0.03964361f, 0.02118156f, 0.00826938f, 
    0.01035423f, -0.00212528f, -0.02990365f, -0.04083365f, -0.01960536f, -0.03135178f, -0.03712198f, -0.00287170f, 
    0.03009538f, -0.00977200f, -0.01712915f, -0.00930468f, -0.00363822f, 0.00448694f, -0.02318370f, 0.00575451f, 
    -0.01620280f, 0.01684656f, 0.02136689f, 0.00212565f, -0.01524283f, -0.01486140f, -0.03360942f, 0.00574265f, 
    -0.00476258f, 0.01794763f, -0.02072430f, -0.03853124f, 0.02517834f, -0.03710145f, -0.00608225f, -0.01594566f, 
    -0.03100275f, -0.01238570f, -0.00340102f, 0.01051568f, -0.03216522f, -0.00106995f, -0.00421713f, 0.02358422f, 
    -0.00774982f, 0.00996049f, -0.00372643f, -0.00775496f, 0.03090794f, 0.01940849f, 0.01875390f, -0.02274746f, 
    -0.04052003f, -0.00908512f, 0.00160794f, -0.03152283f, 0.00482600f, 0.01591737f, -0.01876304f, -0.01824179f, 
    0.02884643f, -0.02088152f, 0.01593926f, -0.04045468f, -0.01479022f, -0.02707180f, -0.03592625f, -0.03348847f, 
    0.01468306f, -0.00594410f, -0.02230953f, 0.01089756f, -0.03538815f, -0.04157438f, -0.03061758f, -0.01718705f, 
    0.02429458f, -0.01479209f, 0.01651677f, 0.02623710f, -0.03853162f, 0.03173870f, 0.01732046f, -0.02611751f, 
    -0.03592313f, 0.02691633f, -0.00823552f, -0.00406633f, -0.02835931f, -0.02064132f, -0.00413516f, -0.03961010f, 
    -0.00200702f, -0.02409379f, 0.02516012f, -0.04166679f, -0.03068924f, 0.01719333f, -0.02534918f, -0.00167679f, 
    -0.01940210f, -0.03425785f, 0.02122161f, 0.00435316f, 0.01026538f, -0.00336699f, 0.03325319f, -0.01391438f, 
    0.02819932f, -0.01170248f, -0.01906513f, -0.01271419f, 0.02620498f, -0.03883296f, -0.00308217f, -0.02118474f, 
    -0.02820628f, 0.00275000f, -0.04000648f, 0.00297743f, -0.00615405f, -0.03819703f, -0.00562669f, -0.02297419f, 
    0.02647955f, -0.01225911f, -0.02853986f, -0.03527982f, -0.00678161f, 0.02385595f, 0.02286506f, 0.00203595f, 
    0.01285655f, -0.03567917f, -0.01212672f, -0.02247835f, -0.02849952f, 0.01356829f, -0.00185186f, -0.01228731f, 
    -0.03394636f, -0.02479563f, 0.01513563f, 0.01490270f, 0.02497726f, 0.00138351f, -0.03004895f, 0.00122724f, 
    0.01039580f, 0.01593078f, -0.03165260f, -0.00163102f, 0.02671400f, -0.01857335f, -0.00615074f, -0.01799037f, 
    0.02653144f, -0.02832094f, -0.02807291f, -0.01117506f, -0.00537557f, 0.00229218f, -0.00021923f, 0.00604714f, 
    0.01096060f, -0.01754043f, -0.02617501f, 0.02157424f, -0.01112750f, 0.01184525f, 0.02456252f, -0.03077168f, 
    0.02411541f, -0.00212192f, -0.03014369f, 0.00650409f, -0.01732613f, -0.01362671f, -0.01475297f, -0.03494773f, 
    -0.02484301f, -0.03577408f, 0.00162801f, -0.03610032f, 0.01371427f, -0.02438934f, -0.00883341f, -0.00208109f, 
    0.01036331f, -0.01668615f, -0.01940130f, 0.01850705f, -0.01637698f, 0.00095767f, 0.01382756f, -0.00938273f, 
    0.02966126f, -0.02496962f, 0.00544421f, 0.03113819f, -0.03759328f, 0.02796836f, -0.00567294f, 0.00302448f, 
    0.02524724f, -0.04123290f, 0.01122438f, -0.03136730f, 0.00193929f, 0.00725901f, -0.00589680f, -0.00267956f, 
    0.02441661f, -0.02786160f, -0.01226098f, -0.03232786f, -0.02550999f, 0.02488633f, 0.00024475f, -0.01751267f, 
    0.00479251f, -0.03344101f, -0.03588199f, -0.02918335f, -0.02615525f, 0.02917792f, 0.00785731f, 0.01725636f, 
    0.00348096f, -0.00309181f, 0.00017673f, 0.00468224f, -0.03907355f, 0.03131571f, -0.00193031f, -0.02965130f, 
    -0.01606704f, 0.01022962f, 0.02094603f, -0.01845213f, -0.01014921f, 0.00095279f, -0.01412648f, -0.02508193f, 
    0.00341845f, -0.01426102f, -0.02601088f, 0.00094340f, -0.02517924f, 0.03389220f, 0.00212174f, -0.00374841f, 
    0.01878738f, 0.02160929f, 0.01127212f, -0.02764296f, -0.01904617f, 0.00358195f, 0.01692232f, 0.01118827f, 
    -0.03953375f, 0.02778814f, -0.00351010f, 0.01012102f, -0.03892217f, 0.02959311f, 0.02894095f, -0.03438591f, 
    0.01715580f, 0.00468192f, 0.00441094f, -0.03983541f, -0.02005241f, 0.00552992f, 0.00682745f, -0.02856685f, 
    -0.03389021f, -0.00179870f, 0.01889468f, 0.01163416f, -0.03889610f, -0.00860409f, -0.00686420f, 0.01001666f, 
    0.00382257f, -0.03637407f, -0.03893350f, -0.00299052f, 0.01234339f, 0.02302877f, -0.03277394f, -0.02509490f, 
    -0.00738177f, 0.02096773f, -0.01808836f, 0.00097352f, -0.02675947f, -0.03528013f, -0.01746040f, -0.03522573f, 
    -0.03516476f, 0.01431222f, -0.01068891f, 0.02792107f, 0.01918485f, -0.01133670f, -0.01059913f, 0.02420575f, 
    0.01609661f, 0.02635245f, -0.00829675f, -0.02930547f, 0.00559731f, -0.02173228f, -0.00171248f, -0.00539219f, 
    -0.00625821f, 0.01617433f, 0.00283367f, -0.02169728f, -0.01551152f, -0.03472604f, 0.00660446f, -0.03311668f, 
    -0.03054326f, 0.01848137f, 0.00758604f, 0.01996883f, 0.02654563f, -0.02621158f, 0.01735400f, 0.02749129f, 
    -0.01232338f, 0.02949515f, 0.01700253f, 0.00683084f, 0.01655094f, 0.00101274f, -0.03538686f, 0.02194087f, 
    -0.03893247f, 0.02462443f, 0.00454839f, -0.00883433f, -0.03604973f, -0.03720458f, 0.02518482f, 0.00113561f, 
    -0.00994879f, -0.03167535f, -0.01999007f, 0.01943095f, 0.02554157f, -0.03174817f, -0.01416094f, -0.02046725f, 
    -0.04020541f, 0.01398058f, 0.01096553f, 0.00505363f, 0.01956189f, -0.02113015f, -0.02394026f, -0.01304629f, 
    -0.00290259f, -0.00648738f, -0.00081335f, -0.01158362f, 0.02474736f, 0.02790160f, 0.01083103f, 0.00356891f, 
    -0.00742425f, 0.01935301f, 0.01622149f, -0.02170397f, 0.01979144f, -0.00684449f, -0.00688153f, -0.03611195f, 
    -0.02250647f, -0.00384058f, -0.02793495f, 0.02528059f, 0.01492868f, 0.03195153f, 0.01646648f, 0.01792662f, 
    0.00998427f, -0.00910399f, -0.01296507f, -0.02121300f, 0.00772867f, -0.02757865f, 0.01507249f, -0.02173462f, 
    -0.02263504f, -0.00886312f, -0.03100665f, -0.00512453f, 0.00744743f, 0.00810321f, -0.03004876f, -0.02954703f, 
    -0.01974932f, 0.00201897f, -0.03577400f, 0.02527674f, -0.01248844f, 0.01472388f, -0.01798665f, 0.01290744f, 
    0.00015436f, 0.00864161f, -0.01069309f, 0.01896748f, 0.01240736f, -0.01138043f, -0.00248936f, -0.03778081f, 
    0.00527934f, 0.00416343f, 0.01322396f, -0.01451060f, 0.00898967f, -0.03923505f, -0.03146193f, -0.01224635f, 
    -0.01147919f, 0.01904815f, 0.01676589f, -0.03836964f, -0.03617164f, 0.02379236f, -0.03221834f, -0.00272387f, 
    -0.01691426f, -0.01151298f, -0.02754714f, -0.02253701f, 0.02936831f, 0.00798324f, -0.02014815f, -0.00581246f, 
    -0.03761791f, -0.00618090f, -0.00714577f, 0.01627684f, 0.01319192f, -0.01200892f, -0.01217190f, -0.02800376f, 
    -0.01377334f, 0.00545186f, 0.00583330f, -0.01790537f, 0.02591891f, -0.03359321f, -0.00413059f, 0.03550322f, 
    0.01124053f, 0.02074421f, -0.00807316f, -0.03691832f, 0.01177064f, 0.01628565f, 0.00825364f, -0.02662282f, 
    0.02388754f, -0.01642554f, 0.02520471f, -0.03504724f, -0.01885362f, -0.01369042f, 0.01408525f, -0.01680177f, 
    0.00870213f, 0.03005575f, -0.01865927f, 0.02241763f, -0.00729669f, -0.03426569f, -0.02696425f, -0.01877812f, 
    0.01848084f, 0.02454255f, -0.03654408f, -0.00535989f, -0.02351504f, 0.00862499f, 0.01019237f, 0.02154108f, 
    0.02532157f, -0.01766624f, 0.02885746f, -0.00243857f, -0.02697621f, -0.01559810f, 0.02686344f, 0.01407205f, 
    -0.03523139f, 0.01403441f, -0.00288836f, -0.02383112f, -0.00543831f, -0.03203085f, -0.00672928f, 0.01162966f, 
    0.02419475f, 0.01215790f, 0.01457651f, 0.00353369f, -0.01883214f, 0.01187930f, -0.02314769f, 0.00093510f, 
    -0.02549840f, -0.03669931f, -0.02777331f, 0.01112976f, -0.00098250f, 0.03278303f, -0.01667568f, -0.03065044f, 
    0.01407921f, -0.02013494f, -0.00713747f, 0.01577444f, -0.01277738f, -0.00017440f, -0.01084207f, -0.02819537f, 
    -0.02559530f, -0.04033009f, -0.00995587f, 0.01093276f, -0.01424893f, 0.01565347f, 0.00935910f, -0.03578283f, 
    -0.03715552f, -0.02354303f, 0.00801727f, -0.02045175f, -0.00858962f, 0.00647511f, -0.02539652f, 0.02891926f, 
    -0.04111215f, -0.03368791f, -0.00219563f, 0.00157891f, -0.02581505f, -0.02665067f, 0.02334600f, 0.00703116f, 
    -0.03957452f, -0.01663293f, -0.01402056f, -0.00323859f, -0.02673089f, -0.00207871f, -0.01098421f, -0.04164243f, 
    -0.02752142f, -0.00620605f, -0.02784448f, -0.04195783f, 0.01817187f, -0.00598717f, -0.00556915f, -0.01411653f, 
    0.01233255f, 0.00396375f, -0.03708532f, -0.02319992f, -0.00167222f, -0.03917238f, 0.02277950f, -0.01185460f, 
    -0.04077078f, -0.03312233f, -0.00472918f, -0.02228157f, -0.00994689f, 0.01748192f, -0.02960683f, -0.00569676f, 
    0.02478857f, -0.03781921f, -0.01937311f, 0.02455441f, -0.00310424f, 0.03388223f, -0.02907358f, 0.02519658f, 
    0.02016256f, -0.01138084f, -0.02547332f, 0.01843027f, -0.02730660f, -0.00817359f, 0.03229517f, -0.02533686f, 
    -0.02815947f, -0.00481363f, -0.02792614f, -0.01463698f, -0.01946395f, -0.03125975f, 0.02451897f, 0.01246758f, 
    -0.02496632f, 0.02821828f, 0.01663326f, 0.00353974f, -0.01886566f, -0.02631990f, 0.00470629f, -0.02086710f, 
    -0.01933014f, -0.03289807f, -0.02044446f, 0.01123965f, -0.00091434f, -0.03868905f, -0.00154449f, -0.01304128f, 
    -0.00333377f, 0.00153046f, -0.02953109f, -0.01807730f, 0.00759428f, 0.02073824f, -0.00500437f, 0.00153963f, 
    -0.00767046f, 0.02184131f, 0.02393432f, 0.01609372f, 0.01904011f, 0.02511238f, 0.00438875f, 0.02264827f, 
    -0.03819210f, 0.01883058f, 0.01199038f, 0.00066947f, -0.03678075f, -0.01096819f, -0.00816794f, -0.00145633f, 
    0.03675853f, -0.07480327f, 0.01134129f, 0.12040657f, 0.01334926f, 0.09319831f, -0.14254111f, -0.03022737f, 
    -0.03519789f, -0.07366803f, 0.05035393f, 0.02720582f, -0.02044751f, -0.01400604f, 0.07816641f, -0.01713818f, 
    0.09480796f, -0.03029690f, 0.01797013f, -0.00977898f, -0.00295009f, -0.00247576f, -0.16063905f, -0.01083808f, 
    -0.09377151f, 0.12414933f, -0.11096681f, -0.09696122f, 0.09625298f, 0.07930964f, -0.22556743f, 0.17934941f, 
    -0.11220495f, -0.06281468f, 0.09884847f, 0.22342743f, 0.17094237f, 0.15216787f, 0.23684943f, 0.03667019f, 
    0.03948170f, 0.12597591f, -0.08560536f, 0.18853426f, 0.00877145f, -0.05507214f, 0.01981037f, -0.04910397f, 
    0.25368834f, 0.45092550f, -0.06863555f, 0.36351314f, -0.16006850f, 0.11111785f, -0.01732186f, -0.01258585f, 
    0.16347402f, 0.10226096f, 0.11936744f, -0.05652897f, -0.10856286f, 0.11402486f, 0.23281465f, 0.21619785f, 
    0.10550763f, 0.10236809f, 0.16921827f, -0.07976054f, 0.05951829f, -0.08620407f, 0.07501919f, -0.00516643f, 
    -0.25759038f, 0.05377242f, 0.33304891f, 0.07469054f, 0.10730943f, 0.08860552f, -0.08461136f, -0.03351085f, 
    -0.05944995f, -0.05490320f, 0.03687546f, 0.02594006f, 0.29749656f, 0.04045884f, -0.18056141f, -0.26491618f, 
    0.04769838f, -0.01554920f, -0.01032715f, 0.09172649f, -0.05603575f, -0.22302905f, -0.09344493f, -0.20605397f, 
    0.00469341f, 0.06724116f, 0.01822085f, 0.21701857f, -0.24269138f, 0.00015083f, 0.06391227f, 0.00463299f, 
    -0.09129768f, -0.09059173f, 0.06790960f, 0.17770775f, -0.40993905f, -0.12149871f, 0.14189440f, -0.12258828f, 
    -0.01138168f, 0.10424814f, -0.02299655f, -0.16606231f, 0.04472300f, 0.08304785f, -0.03380679f, -0.06360911f, 
    -0.14100599f, 0.33410338f, -0.02141693f, 0.20538840f, -0.19612691f, 0.02524082f, 0.03015353f, 0.04362883f, 
    -0.13417998f, 0.11376795f, 0.07871886f, -0.04125646f, 0.24149050f, 0.06136297f, 0.06551483f, -0.03496312f, 
    -0.06227407f, -0.08589194f, -0.06106256f, -0.11337074f, 0.03964385f, -0.09780419f, -0.06664764f, 0.07072699f, 
    0.39284468f, -0.07905551f, -0.10143578f, 0.20096351f, 0.11373701f, -0.04416932f, -0.01168338f, 0.08846144f, 
    -0.06587823f, 0.10646287f, 0.11618507f, 0.24628109f, -0.01653900f, -0.48068595f, 0.52400249f, -0.14357471f, 
    0.10003989f, 0.01373394f, -0.17798710f, -0.06191926f, -0.16514188f, -0.06795479f, -0.02502965f, 0.28135598f, 
    -0.27962402f, -0.08507195f, -0.24400485f, 0.01233667f, -0.05269728f, -0.06937010f, 0.10428502f, 0.09356632f, 
    0.01052237f, 0.01584001f, -0.08012544f, -0.02351102f, 0.39043951f, -0.12426833f, 0.18798754f, 0.24386235f, 
    0.04215682f, 0.10334642f, 0.00831769f, 0.10639322f, -0.00067386f, -0.11453920f, 0.09087446f, -0.01347109f, 
    -0.18704449f, -0.08141562f, -0.13470462f, -0.14788793f, -0.09609640f, 0.03436843f, -0.04776076f, 0.02271789f, 
    -0.05064401f, -0.07548457f, -0.22273296f, -0.13846514f, -0.25713611f, 0.03060029f, 0.03016419f, -0.15234531f, 
    0.04747006f, -0.16372350f, -0.05966340f, 0.07421535f, -0.07585707f, 0.04572297f, -0.00430668f, 0.08632720f, 
    -0.14204834f, 0.09124666f, -0.07304659f, 0.01115818f, 0.06252652f, -0.00113754f, 0.00918513f, -0.04102159f, 
    -0.10019917f, -0.03966137f, -0.06215954f, 0.04188326f, -0.29874760f, 0.21326379f, -0.01328084f, 0.26889819f, 
    0.00124755f, 0.19147541f, 0.03112930f, -0.00461315f, 0.23785236f, -0.03738250f, 0.00765837f, 0.04004965f, 
    -0.20251919f, 0.09969468f, 0.16201310f, 0.18419747f, 0.01682222f, -0.13994722f, -0.12412877f, 0.17047328f, 
    -0.01350806f, -0.12039540f, -0.03427750f, 0.10009655f, -0.07613526f, -0.04083787f, 0.04185356f, 0.03645840f, 
    -0.01465015f, 0.09921012f, 0.00496380f, 0.12721275f, -0.04562521f, 0.05541097f, -0.08761519f, -0.05835710f, 
    -0.01305915f, 0.17509930f, -0.05873675f, 0.02426700f, -0.06319120f, -0.02151551f, -0.01773102f, 0.05056491f, 
    -0.01804763f, 0.03138484f, -0.02693389f, -0.08297573f, 0.41200656f, -0.26569587f, 0.31654826f, -0.16640638f, 
    0.16470638f, 0.08231465f, -0.01569811f, -0.08961163f, -0.00914101f, 0.02207555f, -0.05961160f, 0.06867816f, 
    0.25154445f, 0.29584208f, 0.09391810f, 0.01198840f, -0.10516203f, -0.11671054f, -0.16791905f, 0.01278449f, 
    -0.05686813f, -0.06298133f, -0.07740387f, -0.09799327f, -0.23554049f, 0.06353702f, 0.01516353f, -0.25779825f, 
    -0.03854465f, 0.10131405f, 0.21163923f, 0.01713073f, -0.00105945f, -0.05115949f, -0.01339775f, 0.13714361f, 
    0.01755122f, -0.05587722f, 0.18861948f, -0.19515485f, -0.00537563f, 0.01186700f, 0.08107297f, 0.02667340f, 
    -0.11471009f, -0.02606116f, -0.05211354f, -0.06501073f, 0.16569203f, 0.09237942f, 0.09703588f, 0.11801288f, 
    -0.06672246f, -0.05478267f, -0.09670368f, -0.06724397f, -0.05897664f, -0.05265373f, -0.14061177f, -0.02094803f, 
    -0.23868635f, 0.03592607f, -0.09501323f, -0.06717857f, -0.09533521f, 0.03892840f, -0.05763939f, 0.10150733f, 
    -0.15107141f, -0.00302937f, 0.00433196f, 0.01922284f, 0.13172351f, 0.17161830f, 0.34421498f, 0.08620727f, 
    -0.12231931f, -0.03307070f, -0.17393272f, -0.06791133f, -0.03365770f, -0.07422377f, 0.13939370f, -0.06483691f, 
    0.94768482f, -0.42122635f, 0.37746927f, -0.04837599f, 0.07199857f, -0.06465297f, 0.14032809f, 0.16123751f, 
    -0.01194749f, 0.06297221f, -0.12184416f, -0.02939233f, -0.00797221f, 0.06141698f, 0.09119444f, 0.25059420f, 
    -0.09071350f, 0.21924540f, 0.15477039f, 0.32270873f, 0.12519415f, 0.05760788f, -0.00763738f, -0.09211726f, 
    0.07912843f, -0.37950027f, 0.33402365f, -0.08541448f, 0.16124678f, -0.01401400f, -0.20123120f, 0.02235102f, 
    -0.01223326f, -0.06311022f, 0.14365883f, -0.01042420f, -0.02646464f, -0.08505751f, -0.10899742f, 0.11131966f, 
    0.14297998f, 0.01458080f, 0.01531069f, 0.03442244f, 0.13181974f, 0.22547622f, -0.05477720f, 0.11612528f, 
    -0.12444505f, -0.04122623f, -0.09885498f, -0.14825554f, -0.00133780f, -0.00675139f, -0.00703840f, 0.08219046f, 
    -0.13819660f, 0.00096204f, -0.18536715f, 0.09552556f, -0.18605916f, -0.47171116f, -0.05870363f, 0.32178703f, 
    0.20017514f, 0.02427537f, 0.18251185f, -0.04827029f, 0.08177389f, -0.01141626f, -0.04246368f, 0.04521268f, 
    -0.18537608f, -0.01250075f, -0.18248628f, -0.08537440f, 0.08191046f, 0.02436121f, 0.04055259f, -0.01893535f, 
    -0.01592752f, -0.00793598f, 0.08362169f, 0.04198989f, -0.22928815f, 0.16612291f, 0.19203272f, 0.00133419f, 
    0.10646839f, 0.13475485f, 0.15368688f, 0.01387742f, 0.01538415f, -0.00257604f, 0.14033838f, -0.02774031f, 
    -0.01765129f, 0.26588777f, 0.06255395f, 0.24706295f, -0.02487354f, 0.01760180f, 0.10867173f, -0.03803280f, 
    0.19102219f, 0.11111390f, -0.13697296f, -0.08062150f, -0.24731076f, 0.12706877f, -0.14684388f, -0.09511471f, 
    -0.05788787f, 0.06449978f, 0.05124131f, -0.04927251f, -0.00532676f, 0.03897167f, 0.14674629f, 0.09722389f, 
    0.24016427f, 0.07606095f, 0.08218776f, 0.11826652f, 0.03298701f, -0.14280033f, -0.09810603f, -0.03958194f, 
    0.03805190f, -0.21824631f, -0.20325696f, -0.11491992f, 0.04048054f, 0.15998231f, -0.07519344f, 0.18379253f, 
    -0.14901879f, 0.12119140f, 0.06595138f, -0.04806572f, 0.13249579f, -0.05110325f, 0.16469029f, -0.12424444f, 
    -0.05998177f, -0.08727186f, -0.09164359f, -0.07702120f, -0.03954118f, -0.05479031f, 0.01767603f, 0.02469143f, 
    0.01292049f, 0.03409811f, -0.01343165f, 0.10352749f, -0.41205671f, -0.16134512f, 0.66137785f, 0.05566839f, 
    0.11333095f, -0.08822007f, -0.28139052f, -0.16099714f, -0.18289363f, -0.04331695f, -0.10765028f, 0.05833128f, 
    0.04599511f, 0.40288424f, -0.00018679f, 0.25681683f, -0.03308848f, 0.19273815f, -0.03119476f, 0.07415425f, 
    -0.01424286f, 0.06131856f, -0.08517047f, 0.12805815f, -0.08488585f, -0.08947824f, 0.09876332f, -0.04549864f, 
    0.03213856f, 0.06134898f, -0.11608925f, -0.11224875f, 0.04870751f, -0.04681838f, -0.17110486f, 0.04525932f, 
    -0.10316820f, 0.08476135f, 0.18839021f, 0.31943312f, 0.03054514f, -0.11442953f, 0.21141598f, 0.11924196f, 
    -0.08746874f, -0.02920427f, 0.03653924f, -0.07071444f, 0.01352474f, 0.10009667f, -0.03167019f, 0.06381939f, 
    -0.10208754f, -0.00025088f, -0.02461994f, -0.04573765f, -0.08595987f, -0.00738239f, 0.16151859f, 0.01149626f, 
    0.17778160f, -0.13734110f, 0.07232705f, 0.10907475f, -0.04441042f, -0.00968163f, 0.06274947f, -0.01410227f, 
    0.08838934f, 0.01238944f, -0.04653510f, 0.18379886f, 0.54483157f, 0.21671279f, 0.28264228f, 0.31490174f, 
    0.17720491f, -0.04201880f, -0.03884987f, 0.03626917f, -0.11730433f, -0.02448174f, 0.14209294f, -0.06727993f, 
    0.37253106f, 0.14336975f, 0.14465420f, -0.01490935f, -0.09038434f, -0.14196867f, -0.11962422f, 0.04290642f, 
    -0.04493569f, -0.06453799f, -0.08468954f, -0.03261783f, -0.08344218f, 0.11836166f, 0.41585892f, 0.19889206f, 
    0.07465655f, 0.09913739f, 0.15552597f, 0.07642756f, 0.10796294f, 0.10063533f, -0.12714513f, -0.21081695f, 
    -0.06901044f, -0.27102417f, 0.23457953f, 0.05629133f, 0.09436964f, 0.28581080f, -0.22158936f, -0.03124392f, 
    -0.04819686f, -0.03116742f, 0.02334086f, -0.01207878f, 0.07101353f, 0.01440721f, -0.04125112f, 0.06358182f, 
    -0.07693371f, -0.06601532f, -0.11327809f, -0.08100313f, -0.09453010f, 0.10712732f, -0.07505279f, 0.05353185f, 
    0.12362502f, 0.08515166f, 0.21672605f, -0.13212532f, -0.05962962f, 0.01297135f, -0.15821579f, 0.05476562f, 
    0.04089787f, -0.03682374f, 0.10314859f, 0.14495353f, 0.05553992f, 0.08703002f, 0.17161600f, 0.17922680f, 
    -0.10854065f, 0.13429524f, 0.03068581f, -0.05317429f, -0.10079953f, 0.01469401f, 0.11558728f, -0.15770288f, 
    0.09455968f, -0.00316897f, -0.07109389f, -0.04542556f, -0.02121274f, -0.05283274f, -0.02509879f, -0.00117400f, 
    0.03572020f, 0.01422169f, -0.03377242f, 0.24887785f, 0.18890539f, -0.05544819f, 0.17931134f, 0.04027402f, 
    0.02869343f, 0.02007725f, 0.03174233f, -0.08570930f, -0.07329461f, -0.16092113f, -0.16908921f, -0.00244858f, 
    -0.28690240f, -0.15764546f, -0.23519517f, 0.21209027f, 0.04926557f, -0.08555271f, -0.12077998f, -0.10639618f, 
    -0.10518216f, 0.00190197f, -0.03312517f, -0.11691774f, -0.08315924f, 0.14358079f, 0.19016308f, 0.08105759f, 
    0.03732213f, -0.05288690f, -0.10981786f, 0.03185051f, -0.01958451f, -0.00367339f, -0.00837898f, -0.02765009f, 
    0.05512429f, 0.09031643f, -0.05753409f, 0.00862761f, -0.02359071f, -0.00285128f, -0.11070764f, 0.00627725f, 
    0.14429961f, 0.01934715f, 0.22116984f, -0.04252065f, 0.06187631f, -0.07763810f, -0.09335352f, 0.04468060f, 
    -0.07810776f, 0.27778053f, 0.25847024f, -0.02454690f, 0.00693607f, 0.11464262f, -0.01465939f, 0.18233663f, 
    0.05158669f, -0.13438354f, -0.03053607f, -0.03564646f, -0.00598334f, -0.12338976f, -0.07367471f, -0.05800947f, 
    0.08974642f, 0.02379680f, 0.04798482f, 0.10457122f, -0.35460055f, -0.11767493f, 0.17440648f, 0.27313268f, 
    0.10657757f, 0.04683039f, 0.18566267f, 0.00489725f, -0.13338411f, -0.04790177f, -0.05308459f, -0.01942034f, 
    -0.02534417f, 0.18297473f, 0.02053312f, -0.05840040f, 0.12878628f, 0.07696176f, 0.16944858f, -0.01215655f, 
    0.01253640f, 0.06254260f, 0.08910479f, -0.01519880f, -0.03510830f, 0.10186909f, -0.07782292f, -0.09505316f, 
    -0.03554282f, 0.03847225f, 0.21304573f, -0.03423243f, 0.01378040f, -0.08917075f, -0.05696455f, 0.01940349f, 
    -0.05818588f, -0.19301040f, -0.07608017f, 0.13540021f, -0.05468351f, 0.20145755f, 0.11488945f, 0.11780287f, 
    -0.00415574f, -0.03193272f, 0.14882794f, -0.02632261f, -0.04599957f, 0.19095592f, -0.11772355f, 0.05931225f, 
    0.10376676f, 0.07791777f, 0.06958721f, 0.02888422f, 0.12719916f, 0.13187476f, -0.09807680f, 0.04713458f, 
    -0.28431112f, -0.14101148f, 0.31363499f, -0.24546775f, -0.01308345f, 0.02318226f, 0.01773421f, 0.15388064f, 
    0.05586229f, 0.13097365f, -0.04401852f, 0.00128940f, 0.08931411f, 0.03361588f, -0.05915508f, -0.10914286f, 
    0.00267940f, 0.01364649f, 0.00855381f, 0.05655485f, 0.04162790f, -0.02987053f, 0.08226718f, 0.00571302f, 
    0.05029960f, -0.12376782f, -0.29535452f, 0.04788440f, 0.13723020f, 0.02423927f, 0.19600211f, 0.11731531f, 
    0.04695943f, 0.10546498f, -0.12479539f, -0.02031181f, 0.04264199f, -0.16390271f, -0.05612209f, 0.01319361f, 
    0.08180001f, 0.04179041f, 0.20219934f, 0.00642811f, 0.03892824f, 0.06463951f, -0.13720626f, 0.12322117f, 
    -0.13315918f, -0.14334825f, 0.00526642f, 0.08614677f, 0.02826902f, 0.06643809f, -0.02809446f, -0.04993180f, 
    -0.04839697f, 0.05927126f, 0.01505302f, -0.00571837f, 0.12597077f, 0.10699710f, -0.18303156f, 0.09126414f, 
    -0.05341195f, -0.01332487f, 0.18988614f, -0.06083993f, -0.10378994f, -0.15347585f, 0.07592353f, 0.04968044f, 
    -0.06584524f, -0.00293355f, 0.06840612f, -0.07234895f, -0.09402256f, 0.19122277f, 0.20704177f, -0.11959007f, 
    -0.00434575f, -0.19353406f, -0.01308815f, 0.02203147f, -0.02014792f, 0.08136263f, -0.13406844f, 0.10123876f, 
    0.00438435f, 0.07584100f, 0.06614899f, -0.03898495f, 0.02825299f, 0.15704767f, 0.03517211f, -0.10508038f, 
    -0.15869686f, -0.02218125f, 0.10348089f, -0.06096469f, 0.02516630f, -0.00228788f, 0.02591537f, 0.00025962f, 
    0.22549808f, -0.08111811f, -0.09292013f, 0.05069199f, 0.11570174f, 0.21177010f, -0.45544073f, -0.01524615f, 
    0.09449220f, 0.00633322f, 0.22726318f, 0.03762057f, 0.06890196f, 0.00328813f, -0.02789359f, -0.12961109f, 
    -0.10328759f, 0.15570219f, 0.09276459f, 0.10615680f, -0.06876270f, -0.05270917f, -0.10981712f, 0.07059793f, 
    0.08303878f, -0.00803437f, 0.15775973f, 0.04334584f, -0.15377776f, 0.11590657f, -0.27682745f, -0.12870787f, 
    0.21721347f, 0.11912253f, 0.14736140f, 0.06976817f, 0.09123591f, 0.06921914f, -0.18936589f, -0.04172422f, 
    0.16139881f, 0.24929778f, 0.19683973f, -0.00621923f, -0.01628204f, -0.06671613f, 0.06488001f, 0.05415709f, 
    0.04501932f, -0.01683501f, 0.08581796f, 0.02241448f, -0.04183350f, -0.26554355f, -0.11334042f, 0.10322234f, 
    0.12201484f, 0.17997517f, 0.19484919f, -0.11454427f, 0.05938845f, -0.10320915f, 0.07150336f, -0.07953823f, 
    -0.06840036f, -0.17809837f, -0.01729833f, 0.05570173f, 0.10493659f, 0.11065607f, 0.02663723f, 0.01840374f, 
    0.06925817f, 0.00152287f, -0.01498094f, 0.05650514f, 0.19715661f, 0.27742463f, 0.05613637f, -0.23551166f, 
    0.05579919f, -0.10490124f, -0.19002527f, 0.11420485f, -0.02272645f, -0.09288808f, 0.09506306f, 0.00574869f, 
    0.04499063f, -0.07729839f, 0.02405339f, 0.14874706f, -0.08184267f, 0.12601362f, 0.15154019f, 0.00474957f, 
    0.03408657f, -0.00224296f, 0.02262434f, -0.09547697f, 0.08426048f, 0.06621622f, 0.00996546f, -0.04852624f, 
    0.02346221f, -0.02150832f, 0.06927374f, -0.14625342f, 0.05679600f, -0.08108776f, 0.00396621f, -0.01671842f, 
    -0.05759197f, -0.19471049f, 0.18510945f, 0.13771535f, -0.01178618f, -0.03642474f, -0.01697229f, 0.01108498f, 
    0.06198454f, -0.16373727f, 0.13676560f, -0.02694352f, 0.06461111f, 0.05311261f, -0.23153487f, 0.07551531f, 
    -0.02656741f, 0.02704759f, 0.06750830f, 0.09395859f, 0.06378911f, -0.06346720f, 0.13505408f, -0.07093365f, 
    -0.13027330f, -0.21362616f, -0.06420489f, 0.09865812f, 0.09666827f, 0.04973280f, 0.16380543f, -0.01883976f, 
    0.01869197f, -0.06456766f, -0.01635334f, -0.00211418f, -0.26345992f, -0.00397164f, 0.31963873f, 0.43451732f, 
    -0.00135631f, -0.13103661f, -0.16575426f, 0.12454067f, 0.24976434f, 0.19902252f, 0.00970831f, 0.04007087f, 
    0.20229147f, 0.36804974f, 0.03818861f, 0.08868289f, 0.01859212f, -0.08540800f, -0.09438509f, 0.02710133f, 
    0.07191371f, 0.06511516f, 0.16940740f, 0.08485361f, -0.02395116f, -0.06367494f, 0.00317461f, 0.09319599f, 
    0.05842924f, -0.02645328f, 0.01081314f, 0.01196122f, 0.07413427f, -0.14133741f, 0.02808796f, -0.04801593f, 
    -0.04760113f, 0.03819709f, 0.01198051f, 0.24005172f, -0.03729373f, 0.01914406f, -0.06601666f, -0.02692350f, 
    0.12408522f, -0.05795403f, 0.20224348f, -0.01393524f, -0.16315116f, -0.36248702f, -0.20063506f, -0.01475346f, 
    0.01254864f, 0.04572523f, 0.05865446f, 0.26362476f, 0.03558173f, 0.02624879f, -0.06086078f, 0.01535346f, 
    -0.64012402f, 0.47649536f, -0.27361986f, 0.06370963f, 0.14661758f, 0.12490658f, 0.04410555f, 0.12067410f, 
    0.11885403f, 0.13032497f, -0.15555511f, -0.11657814f, 0.16193303f, 0.13832450f, 0.30943701f, -0.25822088f, 
    -0.05602682f, -0.13580175f, 0.14750934f, -0.05948315f, 0.03419866f, -0.02051624f, 0.11849471f, 0.02456267f, 
    0.11580290f, 0.14667633f, -0.36830416f, 0.15960692f, 0.00636361f, -0.01558554f, 0.21988578f, -0.14150734f, 
    0.24847685f, 0.23074417f, -0.16629387f, -0.07887936f, 0.09536872f, 0.17578536f, 0.35305527f, 0.19902162f, 
    0.01555510f, -0.00972684f, -0.19967088f, 0.18397014f, -0.02803406f, 0.00463738f, 0.24949288f, -0.02171101f, 
    -0.27521193f, -0.23849510f, 0.28461644f, 0.25580916f, -0.14149272f, 0.08574586f, -0.07471246f, 0.15229498f, 
    -0.06187150f, 0.06469086f, 0.13707177f, -0.05119371f, -0.01564862f, 0.16690119f, 0.23652966f, -0.12092201f, 
    -0.00618146f, 0.03767810f, -0.22066030f, -0.10457613f, -0.08593345f, 0.01863365f, 0.13318364f, -0.08455814f, 
    -0.05966358f, -0.06229855f, 0.10121549f, 0.06523939f, -0.07180357f, 0.18669391f, 0.03276122f, 0.07255746f, 
    -0.06106004f, -0.04045214f, -0.01572776f, 0.07301606f, -0.01671895f, -0.07063700f, 0.00364366f, 0.19030707f, 
    -0.09902627f, 0.05471213f, -0.11753134f, 0.14154060f, 0.02634942f, -0.05107802f, 0.07108068f, 0.09141708f, 
    0.08782589f, 0.27346316f, 0.02889499f, -0.19637392f, 0.04470867f, -0.06497037f, -0.17361899f, 0.26068503f, 
    0.05709980f, 0.07884458f, 0.01319360f, 0.08048372f, -0.12780215f, -0.02866514f, 0.02626034f, 0.36463526f, 
    -0.06526741f, -0.07417124f, -0.03380491f, 0.12895702f, 0.10150144f, 0.07679225f, -0.19670592f, 0.15950435f, 
    -0.18894838f, 0.00016338f, 0.12949204f, -0.10705452f, -0.05357822f, -0.12705436f, 0.15836018f, 0.03535983f, 
    -0.09409072f, -0.12109117f, -0.00737433f, -0.01277132f, -0.03940624f, -0.41100344f, 0.43312430f, 0.06142914f, 
    -0.08381286f, -0.08586199f, -0.12914421f, 0.24649456f, -0.18671666f, -0.03388833f, -0.05878983f, 0.19571659f, 
    -0.08874267f, 0.05691316f, 0.16640215f, 0.22073813f, -0.00286806f, -0.06902074f, -0.07071908f, -0.00714629f, 
    0.13151519f, -0.07729061f, 0.10775102f, 0.00133332f, 0.21154794f, -0.08335110f, -0.57197249f, -0.03083838f, 
    0.05742113f, 0.21088476f, 0.43844762f, 0.06117349f, 0.05716448f, -0.07202047f, -0.01377774f, -0.12864406f, 
    0.02783990f, 0.04457316f, 0.03188441f, -0.19960026f, 0.09669393f, -0.10459403f, 0.08752262f, 0.15676735f, 
    0.20243819f, -0.13433668f, 0.18539074f, 0.03666665f, 0.09779889f, 0.05495691f, -0.22062844f, 0.07635698f, 
    0.01981309f, 0.02270071f, 0.26715726f, 0.01299903f, 0.02036977f, -0.07215166f, 0.04700345f, -0.17818770f, 
    -0.12337440f, 0.14323898f, 0.02073772f, -0.14664315f, -0.03550335f, 0.00230079f, 0.00741078f, -0.10260812f, 
    -0.00080869f, -0.00387191f, 0.02914003f, 0.07393093f, -0.01407580f, -0.03728864f, -0.16204655f, 0.05899056f, 
    0.04852081f, -0.03156907f, -0.00397016f, 0.02722460f, 0.05896396f, 0.11148386f, -0.05472682f, 0.05547807f, 
    -0.22665580f, 0.26680562f, 0.02382541f, 0.06703749f, -0.03100582f, -0.04960633f, 0.00156820f, 0.04616059f, 
    -0.05956323f, 0.05096605f, -0.08461276f, 0.04634577f, -0.57161796f, 0.00560544f, 0.27947742f, -0.05978734f, 
    -0.13085948f, -0.09304926f, 0.09358449f, 0.04688227f, 0.10279621f, 0.03054522f, 0.05880571f, 0.03500957f, 
    -0.08366217f, -0.11042215f, -0.26196966f, 0.27027622f, 0.05262460f, -0.00286819f, 0.11781601f, -0.01833271f, 
    0.07530186f, -0.03678818f, 0.01702163f, 0.10167208f, 0.07609870f, 0.11447742f, -0.23517130f, -0.22089234f, 
    0.02668746f, -0.04045129f, -0.04984557f, 0.19559149f, -0.16064106f, 0.02590370f, -0.07390477f, -0.09385137f, 
    -0.01574141f, 0.11022729f, -0.07403541f, -0.15064706f, 0.04128948f, -0.05919411f, 0.05024733f, -0.12311786f, 
    0.07277438f, -0.01451865f, 0.01920704f, 0.14394566f, -0.07016990f, -0.04781983f, 0.05503375f, 0.01698665f, 
    0.09771756f, -0.00447147f, -0.01351271f, -0.02183469f, 0.05646104f, -0.16620906f, -0.01706560f, 0.10657067f, 
    0.16938369f, -0.00432904f, -0.06725036f, -0.28379971f, 0.12279414f, -0.07294396f, 0.02421078f, -0.03516910f, 
    0.08463455f, -0.02902258f, -0.01393661f, -0.04113103f, -0.05484549f, 0.38588312f, -0.21831654f, 0.07610822f, 
    -0.03125487f, 0.08732980f, 0.02347385f, 0.04969727f, 0.02291406f, 0.03804801f, -0.05209715f, 0.10774208f, 
    -0.14476770f, 0.02326239f, 0.41495824f, 0.19022810f, -0.06965359f, -0.04694160f, -0.01924828f, 0.00558725f, 
    -0.00769845f, -0.02601863f, 0.01016254f, 0.10524298f, 0.03120802f, 0.18016984f, -0.01474774f, -0.23302513f, 
    -0.04578241f, -0.03185313f, 0.11764017f, -0.03847376f, -0.07287905f, -0.06660924f, -0.03703408f, 0.00122440f, 
    -0.13625191f, -0.04811775f, 0.09473513f, -0.04099305f, -0.05990886f, 0.02908803f, 0.00585315f, -0.04112089f, 
    0.04845129f, 0.10883690f, 0.04454547f, 0.09920345f, 0.00557058f, -0.12561421f, -0.25410751f, -0.02963606f, 
    0.07269599f, -0.04978472f, 0.07700791f, 0.07799765f, 0.13002455f, 0.04217705f, -0.01496272f, 0.06189940f, 
    0.21912296f, 0.03452577f, 0.11302748f, -0.17752719f, -0.02231075f, -0.07553763f, 0.04650730f, -0.05197477f, 
    -0.02337426f, 0.15886578f, -0.16185674f, 0.08052340f, -0.04914393f, 0.11305473f, 0.13262185f, -0.16709861f, 
    0.00587836f, -0.06886499f, -0.14077736f, -0.05391665f, 0.11404973f, -0.04891337f, -0.00897252f, -0.07229724f, 
    0.02199133f, 0.01731201f, 0.19145671f, 0.07887953f, 0.05606418f, -0.05161374f, -0.14319490f, -0.03777859f, 
    0.02238312f, -0.08214279f, 0.01731576f, 0.11738087f, -0.26899403f, -0.24739417f, 0.03877508f, 0.19222197f, 
    -0.04060049f, 0.04410851f, 0.03480568f, 0.06755916f, -0.02448556f, 0.06322763f, 0.04845703f, -0.00457135f, 
    0.04211548f, 0.21276122f, -0.17578703f, -0.11104829f, 0.13557133f, 0.14192262f, 0.03565894f, 0.02658813f, 
    -0.02664709f, 0.02567838f, 0.16697368f, 0.09842481f, 0.14116518f, 0.14666563f, 0.10359389f, -0.03678237f, 
    -0.03754224f, -0.04342034f, 0.11742291f, 0.08250240f, -0.03063962f, -0.09778969f, 0.02087136f, 0.01270657f, 
    -0.01769418f, 0.26112074f, 0.01991228f, 0.01359500f, 0.02756030f, 0.06607063f, 0.08209276f, 0.20588039f, 
    -0.09381831f, 0.03548214f, -0.04251728f, 0.06555799f, 0.17060205f, 0.11109643f, -0.19658539f, 0.01365904f, 
    -0.03268853f, -0.06390595f, 0.12849051f, 0.14483935f, 0.00191555f, -0.08384993f, -0.05577771f, 0.05547117f, 
    0.20143344f, -0.14320548f, 0.35855994f, -0.05827423f, -0.08103688f, -0.01662278f, 0.00434749f, -0.17307748f, 
    0.02626129f, 0.08621124f, 0.07201817f, 0.03212473f, 0.14355065f, 0.02149091f, 0.05095669f, -0.13876536f, 
    0.21062785f, 0.08903202f, 0.07836705f, -0.00651375f, 0.00713557f, -0.13429987f, -0.02676863f, 0.05059744f, 
    -0.07428806f, -0.02543101f, 0.02619565f, -0.09200567f, -0.02667999f, -0.02664325f, -0.07219005f, -0.11740753f, 
    -0.06635239f, -0.00958287f, 0.03395389f, -0.05620566f, 0.21534792f, -0.18981652f, -0.16496243f, -0.01325270f, 
    0.05194052f, 0.00495805f, -0.00880077f, -0.02244285f, -0.14368798f, -0.07982341f, -0.08301635f, 0.04071159f, 
    -0.06994741f, 0.04931213f, 0.03293728f, -0.11933012f, -0.01421352f, -0.00470215f, -0.00720739f, 0.01452478f, 
    -0.02380566f, 0.13738582f, 0.05437852f, 0.11747207f, -0.06354280f, -0.05501363f, 0.09534185f, 0.02083003f, 
    -0.02961898f, 0.00480988f, 0.04317619f, 0.10209645f, 0.11004481f, -0.18429829f, -0.05492242f, 0.16091296f, 
    -0.15148996f, 0.04089777f, 0.07760786f, -0.04429273f, -0.00907552f, 0.08822717f, 0.15434308f, -0.05513329f, 
    -0.00636320f, 0.06636468f, 0.12594311f, 0.07158481f, -0.28786540f, -0.09299652f, -0.04596794f, -0.03889613f, 
    0.08047033f, 0.06398956f, -0.00467735f, 0.07094238f, 0.00719680f, 0.02145860f, -0.24203704f, 0.05055184f, 
    0.04531945f, -0.03070073f, -0.10784115f, 0.18746734f, 0.12063035f, -0.08139495f, 0.07686657f, 0.05193470f, 
    0.13594995f, 0.07998445f, -0.01145320f, 0.07018363f, 0.05218890f, 0.03315285f, -0.15649521f, 0.05220442f, 
    -0.03879472f, 0.00164314f, -0.22739473f, -0.10033235f, 0.01458700f, 0.04111699f, -0.05592550f, 0.07213555f, 
    -0.19747980f, 0.07780711f, -0.02345403f, 0.10862084f, 0.08790882f, 0.24385646f, 0.13161469f, 0.23776272f, 
    -0.02237611f, -0.13091339f, -0.09719677f, -0.09321676f, -0.12644880f, -0.11358984f, -0.51472300f, 0.22366588f, 
    0.07879895f, 0.05043008f, -0.05777560f, -0.20824739f, -0.13171069f, -0.14957924f, -0.04571283f, 0.01826001f, 
    0.06943817f, -0.05494561f, -0.08561574f, -0.17172638f, -0.04317281f, 0.05084984f, 0.02742174f, 0.03393819f, 
    0.13821894f, 0.08835132f, 0.13041390f, 0.07726301f, -0.07880431f, -0.07973973f, -0.17481023f, 0.04417887f, 
    -0.11199386f, -0.03819167f, 0.04643326f, -0.12451777f, -0.01951752f, 0.01339380f, -0.06470082f, 0.04955612f, 
    -0.07516962f, -0.03354451f, -0.00282816f, 0.10040049f, -0.06068169f, -0.20209661f, -0.20202425f, -0.12066557f, 
    -0.08514284f, -0.07462567f, 0.01945982f, 0.04818902f, 0.28505391f, -0.07159761f, -0.21305780f, -0.22200078f, 
    0.16384733f, 0.12257151f, -0.06151707f, -0.23119056f, 0.19090229f, 0.03014966f, -0.00554501f, -0.03770257f, 
    -0.03339787f, 0.13257775f, 0.13242382f, 0.09248596f, 0.10229996f, -0.14123592f, -0.09001485f, 0.07871002f, 
    0.02913678f, -0.00826718f, 0.06045285f, -0.00440072f, 0.21434204f, 0.13193223f, 0.10908745f, -0.03784317f, 
    -0.20157583f, 0.00555223f, 0.11915343f, -0.04784910f, -0.11714483f, -0.15136664f, 0.03665917f, 0.03011609f, 
    0.07515765f, -0.18478441f, 0.10207137f, 0.07127915f, 0.02845763f, 0.02056130f, 0.03258479f, 0.12374796f, 
    -0.03571627f, -0.08947392f, -0.01723137f, 0.07563020f, 0.20036806f, 0.03518104f, -0.14142662f, -0.00588397f, 
    0.04462752f, -0.01988178f, -0.00300609f, 0.02561081f, -0.02898984f, 0.01670588f, -0.00706198f, 0.11049294f, 
    -0.11759872f, -0.12548283f, 0.00048724f, -0.08831588f, 0.02219265f, -0.02021501f, 0.02684559f, -0.03749314f, 
    0.05968241f, -0.07145592f, 0.01360531f, 0.03353741f, -0.08736084f, -0.37661701f, 0.19647349f, -0.12238782f, 
    -0.00812657f, 0.01961594f, 0.24174012f, 0.13859145f, 0.12316795f, 0.03337007f, -0.03627624f, -0.06461536f, 
    0.10339803f, -0.18499354f, -0.03279089f, 0.09161272f, 0.01452736f, 0.07174914f, 0.08701374f, -0.01684218f, 
    0.13459100f, 0.00316204f, 0.06398561f, 0.09117298f, -0.00190373f, 0.00008962f, 0.05905952f, 0.08654410f, 
    -0.00442803f, 0.00209274f, 0.02157080f, 0.04539259f, 0.04443227f, 0.04030189f, 0.06576064f, 0.10093112f, 
    -0.17902513f, 0.16659915f, -0.02775502f, 0.08695360f, -0.09088413f, -0.10429047f, 0.02265087f, -0.02352127f, 
    -0.07667623f, 0.05282577f, -0.04052476f, -0.01079305f, 0.14842796f, 0.04745170f, -0.08878300f, -0.11160385f, 
    -0.04294025f, -0.01412226f, -0.02391174f, 0.07331719f, 0.00974144f, 0.00018358f, -0.01715727f, 0.04865612f, 
    -0.64324290f, -0.03375627f, -0.24065924f, 0.33110106f, 0.26297715f, -0.05798244f, -0.02664807f, 0.07072576f, 
    0.10449097f, 0.06653576f, 0.01529436f, -0.38761953f, -0.09702598f, -0.03963482f, 0.08885321f, -0.15345535f, 
    0.05172988f, 0.24853182f, -0.00710272f, 0.01097004f, 0.26163408f, -0.02259763f, -0.15657991f, -0.09429698f, 
    0.18395457f, -0.07102837f, 0.06049787f, 0.03044089f, 0.09294631f, 0.06249792f, -0.04079484f, 0.08167328f, 
    0.00136917f, 0.01805323f, 0.00110540f, -0.03913212f, 0.32778913f, 0.01731637f, -0.10089955f, -0.02009921f, 
    0.00194388f, 0.07955543f, 0.19507235f, 0.07294966f, 0.12432054f, -0.04244183f, 0.15367992f, -0.02041935f, 
    0.01539017f, 0.02077604f, -0.02401651f, 0.21923120f, -0.21562782f, -0.05754273f, 0.21357681f, 0.01177144f, 
    0.00235169f, -0.05142597f, -0.17066175f, -0.07330003f, 0.24726743f, 0.33276188f, -0.05654529f, -0.04467745f, 
    -0.11519963f, 0.03167731f, -0.16143401f, 0.02064681f, 0.00279322f, -0.03497337f, -0.02035271f, 0.03233408f, 
    -0.07604093f, 0.02943984f, 0.07615916f, -0.03105186f, -0.04691443f, -0.01330376f, -0.16387884f, -0.04116828f, 
    -0.10972112f, 0.06168371f, 0.07293825f, 0.02472172f, 0.03854354f, 0.03561309f, 0.04707347f, -0.07492570f, 
    0.07776342f, -0.00403296f, -0.04768872f, 0.04985826f, -0.02437969f, 0.00329516f, -0.09826625f, 0.08669202f, 
    0.27088055f, 0.13972002f, -0.13750158f, 0.24810043f, 0.19318822f, 0.19503132f, -0.12210505f, -0.03686949f, 
    0.08457573f, -0.04799207f, -0.08544398f, 0.02723063f, -0.18921734f, 0.09475064f, 0.06689028f, -0.09517632f, 
    -0.11456087f, 0.00038721f, 0.01215659f, 0.17658219f, -0.04272972f, -0.10156740f, 0.02737634f, 0.04979231f, 
    0.04937436f, 0.09060743f, 0.12574494f, 0.03423094f, -0.13290270f, 0.03155508f, -0.04651310f, 0.06517158f, 
    -0.17602274f, -0.03367509f, -0.01339559f, 0.11954175f, 0.36401209f, -0.12527829f, 0.25137779f, 0.10249486f, 
    -0.22376928f, -0.06885227f, 0.02439400f, 0.11316638f, 0.04701822f, 0.08641694f, 0.05298927f, 0.09510132f, 
    -0.10147490f, -0.00351065f, 0.02128993f, 0.09458183f, -0.03306880f, -0.00129212f, 0.07745400f, 0.03736458f, 
    0.00476633f, -0.03491037f, 0.01694523f, 0.03471348f, -0.05890897f, -0.01003142f, 0.12149205f, -0.16513194f, 
    0.01448907f, -0.12620458f, -0.21365738f, -0.12705858f, -0.04136829f, -0.01299637f, 0.04054844f, 0.03837521f, 
    0.40877658f, 0.22777639f, -0.31463879f, -0.00371550f, 0.20143285f, 0.02211847f, -0.28265023f, -0.04408539f, 
    -0.01090041f, 0.05201617f, -0.08327013f, 0.01159610f, -0.24863626f, 0.04051009f, 0.06711066f, 0.01424476f, 
    0.14400429f, 0.09192624f, 0.07908110f, 0.12840030f, 0.05067976f, 0.15665665f, -0.04997620f, -0.10096775f, 
    0.11871822f, 0.15251510f, 0.02241035f, -0.05594467f, 0.14155887f, 0.07344305f, 0.25827494f, 0.03576307f, 
    -0.06161054f, -0.08576982f, 0.02538996f, 0.09352899f, -0.05183217f, 0.07438304f, 0.03588332f, 0.03572317f, 
    0.05602805f, -0.01284701f, -0.03765280f, -0.01388367f, -0.02445069f, 0.06911915f, 0.07249944f, 0.08477177f, 
    -0.16383463f, -0.00827626f, 0.17318426f, 0.15798439f, 0.01552185f, 0.02008352f, 0.04649761f, -0.00311520f, 
    0.24150860f, 0.09963011f, 0.14609663f, -0.02019892f, -0.19871169f, 0.09004328f, 0.15056323f, 0.19279066f, 
    0.06969003f, 0.09348854f, -0.08047393f, 0.17152229f, -0.09290946f, -0.07700922f, -0.11650907f, -0.09651658f, 
    -0.02881864f, -0.11858273f, 0.00293355f, 0.03168236f, 0.02617705f, -0.05954513f, 0.00439628f, -0.01421001f, 
    -0.07216700f, 0.04992184f, 0.04749782f, 0.13473800f, 0.19373459f, 0.01222818f, 0.06417869f, 0.01463087f, 
    0.01256958f, 0.03859658f, -0.05533303f, 0.23944624f, 0.03939642f, -0.19543704f, 0.04950064f, -0.12427831f, 
    0.08391099f, 0.11032835f, -0.06655052f, -0.11061814f, 0.17982979f, 0.06758654f, 0.06393462f, -0.02305307f, 
    -0.08686046f, -0.01955475f, 0.02011827f, 0.09517283f, -0.05285818f, -0.03954647f, 0.07205144f, 0.13876446f, 
    -0.06438316f, -0.00987211f, 0.00108446f, 0.02355226f, -0.10376818f, 0.10715627f, -0.09367636f, 0.03414924f, 
    0.18818966f, 0.05113687f, -0.12066929f, -0.21208885f, 0.08662383f, -0.08736279f, -0.10146222f, -0.03775571f, 
    0.05588924f, -0.07708536f, -0.01581110f, 0.01626710f, -0.00690851f, 0.15251189f, 0.04969162f, -0.28911519f, 
    0.08604521f, 0.17551635f, -0.11404808f, -0.06206243f, 0.13512242f, -0.08093421f, -0.12163106f, 0.16989903f, 
    -0.18294340f, -0.02931316f, 0.13449050f, -0.06817535f, -0.12768766f, 0.00039191f, 0.06324347f, 0.04506135f, 
    0.15468313f, 0.05045496f, 0.14262603f, 0.07224487f, -0.02737153f, -0.14311621f, -0.06524621f, 0.06518254f, 
    0.01136561f, 0.03924456f, 0.13241021f, -0.04291032f, 0.02059940f, -0.02432233f, 0.02416283f, 0.03420139f, 
    0.20674118f, 0.15805992f, 0.10657790f, 0.07295721f, 0.08208956f, 0.18045157f, 0.04230142f, -0.02975699f, 
    -0.03780697f, -0.05557154f, -0.04580784f, -0.04113341f, -0.06213402f, 0.11562800f, -0.04434084f, 0.05700104f, 
    0.08961403f, -0.06151361f, -0.06869606f, 0.05005769f, 0.00216345f, -0.08808595f, 0.04393299f, 0.06361627f, 
    0.07545800f, -0.08880384f, -0.03561885f, 0.06996384f, 0.04871959f, -0.03200992f, -0.19527736f, -0.15040918f, 
    0.23384731f, 0.06128241f, 0.12709323f, 0.01184831f, 0.09737663f, 0.03549120f, -0.19202337f, -0.05461591f, 
    -0.01571169f, 0.16723828f, 0.00534036f, -0.17002632f, -0.03943091f, 0.05220878f, 0.02054149f, 0.04769008f, 
    0.01272077f, -0.09610596f, 0.06830321f, 0.07803667f, -0.05554928f, -0.10725008f, -0.06069128f, 0.02575905f, 
    0.07637978f, -0.24084149f, -0.17648531f, -0.01572340f, 0.38207835f, 0.14647102f, -0.02321400f, 0.09049657f, 
    0.01763383f, 0.03340010f, 0.15983036f, 0.10997625f, -0.03127179f, 0.00034639f, 0.02680545f, 0.02969123f, 
    -0.00308483f, -0.04001306f, -0.02097130f, 0.01315018f, 0.02503190f, 0.01765370f, -0.02293319f, 0.03039896f, 
    -0.02069503f, -0.03848718f, -0.04374500f, -0.01451065f, 0.03436844f, 0.01011019f, -0.01776471f, 0.01646005f, 
    0.00756666f, 0.01042436f, 0.00846139f, 0.02451578f, -0.02892953f, 0.00807877f, 0.02119477f, 0.02925560f, 
    -0.01871083f, -0.00053162f, 0.00226198f, 0.01340651f, 0.01489306f, -0.01021609f, -0.01107957f, -0.02820228f, 
    -0.03217352f, -0.00771484f, -0.00249654f, -0.03370450f, -0.02200619f, -0.01794261f, -0.01601087f, 0.01821666f, 
    -0.00276535f, -0.01577784f, -0.03025124f, -0.01372987f, 0.01003377f, -0.02078023f, -0.01750953f, 0.00968265f, 
    0.03471298f, -0.03168800f, -0.02203843f, 0.03157373f, -0.03116857f, 0.00805953f, -0.03411919f, -0.00072854f, 
    -0.01701382f, 0.03315157f, 0.00171142f, -0.00079203f, 0.00058039f, -0.00905139f, 0.02738112f, -0.02392153f, 
    0.01186408f, -0.03195247f, -0.01051317f, -0.02145618f, 0.03088781f, -0.00757659f, 0.03278286f, -0.02807134f, 
    -0.00015279f, 0.00926943f, 0.01984551f, 0.00227322f, -0.01663563f, -0.03039400f, -0.03328400f, 0.01296346f, 
    -0.03274596f, -0.01836106f, -0.01667769f, 0.02205912f, -0.01688524f, -0.01695760f, -0.00838476f, 0.03114563f, 
    -0.02753882f, 0.03050387f, -0.02770353f, 0.00604328f, -0.00474740f, 0.02676289f, -0.01146329f, 0.03892205f, 
    -0.02282259f, 0.01229735f, 0.02363126f, 0.02466195f, 0.02372767f, -0.02983505f, -0.00476083f, -0.02953785f, 
    -0.00104569f, -0.02461751f, -0.01828504f, -0.00589162f, -0.02340429f, -0.02923405f, 0.01417827f, 0.01438800f, 
    -0.00619137f, -0.01555657f, -0.00486183f, 0.01405151f, 0.03405513f, -0.03038885f, -0.04064995f, -0.00448346f, 
    -0.01565053f, -0.02605756f, -0.02234173f, 0.00943064f, 0.00876781f, -0.04215332f, 0.02501654f, 0.02241015f, 
    -0.00630461f, 0.00959745f, -0.02343084f, -0.02982705f, -0.02002205f, -0.02329409f, 0.02070663f, -0.01844401f, 
    0.01785771f, -0.00572289f, -0.00158112f, -0.03797067f, 0.01826667f, 0.02857925f, -0.03101599f, -0.01850142f, 
    0.02030460f, 0.01049748f, -0.01193263f, 0.02430990f, -0.04277495f, -0.00255414f, -0.01481048f, -0.01701343f, 
    0.00295523f, -0.03619147f, -0.03607856f, -0.01090878f, -0.03427073f, 0.02023014f, 0.02299644f, 0.00194241f, 
    -0.03096571f, 0.02904532f, -0.02433996f, 0.01202878f, 0.01731941f, -0.01945858f, 0.03818931f, 0.00142531f, 
    0.02145751f, -0.00689704f, -0.04083094f, 0.00353344f, -0.00919424f, -0.00015008f, 0.02930094f, -0.02434991f, 
    -0.03684116f, -0.04376144f, 0.00012406f, -0.00535806f, 0.02404876f, -0.00739070f, -0.00004483f, 0.02334657f, 
    0.00998047f, -0.01616626f, 0.00861921f, 0.00942584f, -0.00903928f, -0.03056874f, -0.04446167f, -0.01902725f, 
    0.01289442f, -0.02399710f, -0.00520771f, -0.01845079f, 0.02025722f, -0.01402999f, 0.01700976f, -0.00941027f, 
    0.01657835f, 0.02385195f, 0.02637895f, 0.02108916f, -0.03160894f, 0.00902926f, -0.02081865f, 0.00135651f, 
    0.00358949f, -0.02139151f, -0.03551994f, -0.03868317f, 0.00134347f, -0.01106094f, -0.04440356f, 0.00436322f, 
    -0.03994711f, -0.03613118f, -0.00044129f, 0.02398773f, 0.01590494f, 0.00125950f, -0.04213966f, -0.03120008f, 
    0.01063021f, -0.02134225f, -0.04102594f, -0.02071887f, -0.02886667f, -0.03621546f, -0.02917924f, -0.00050099f, 
    0.00116575f, 0.02036601f, -0.01607392f, -0.01471954f, -0.02506085f, 0.01880526f, 0.02201689f, -0.03352844f, 
    0.01294010f, 0.03225232f, 0.02330602f, 0.04174536f, 0.00249524f, -0.02620129f, -0.00237549f, -0.02288436f, 
    0.00964813f, 0.03010220f, 0.00343398f, -0.02745542f, 0.00385678f, -0.01955630f, 0.01584474f, 0.02465502f, 
    -0.03793252f, -0.03396703f, 0.02739829f, 0.00115857f, 0.03336619f, 0.01971902f, -0.00609389f, -0.00936478f, 
    -0.02641664f, -0.03373914f, -0.02805868f, -0.00341489f, -0.02470347f, -0.00093480f, -0.01987232f, -0.00237299f, 
    0.01799284f, -0.03956731f, 0.01825694f, 0.02921510f, -0.00271696f, -0.02324064f, 0.02517994f, -0.00743445f, 
    -0.02343025f, 0.03347735f, -0.02724697f, 0.02018446f, -0.02004817f, 0.00180889f, -0.02894713f, 0.02036182f, 
    -0.00657420f, 0.00514706f, -0.01167605f, 0.01269955f, 0.00005750f, 0.02126154f, 0.00605533f, -0.01049336f, 
    0.02274858f, -0.02861992f, -0.04486658f, -0.03331116f, 0.01464814f, 0.00098042f, -0.02316477f, 0.01591169f, 
    -0.02036756f, 0.00935331f, -0.04533297f, -0.00200608f, 0.02178880f, -0.00340262f, 0.02284627f, 0.02081476f, 
    0.02099977f, -0.02411533f, -0.03823430f, 0.00287890f, -0.03600674f, -0.02271182f, -0.01021339f, 0.02361226f, 
    -0.00033646f, 0.02462872f, 0.03287604f, -0.00246781f, 0.00442432f, -0.00699230f, -0.02582301f, -0.01273165f, 
    0.00971868f, 0.01534772f, -0.01783773f, 0.01742418f, 0.00810682f, -0.00829000f, -0.02795047f, 0.00679245f, 
    0.00119065f, -0.02149046f, 0.01485849f, -0.03910264f, -0.02982622f, -0.03073951f, 0.00781697f, -0.02527387f, 
    0.01052573f, -0.03938162f, -0.01649749f, -0.03815544f, 0.02172871f, 0.01749341f, -0.03732965f, 0.00806318f, 
    0.00747042f, 0.00766697f, -0.01795589f, 0.01331146f, -0.04413578f, 0.00779585f, -0.03156026f, -0.00688455f, 
    -0.02540907f, -0.01951822f, -0.03046013f, 0.00078783f, 0.02678503f, -0.01051952f, 0.01438335f, 0.02241630f, 
    0.00801733f, 0.01070455f, 0.02275806f, -0.03112171f, 0.03092194f, 0.02377096f, -0.00861987f, -0.01164795f, 
    -0.04212156f, 0.02191778f, -0.01628021f, 0.01139887f, 0.01834556f, -0.00302895f, 0.01380282f, 0.01959535f, 
    0.01060510f, -0.00132517f, -0.01952105f, -0.00708386f, 0.03698368f, 0.01872924f, 0.00381013f, 0.02669166f, 
    0.03337812f, -0.01971664f, -0.01338677f, 0.01650335f, -0.02066889f, 0.01252548f, -0.00450496f, -0.01517586f, 
    0.02118635f, 0.01001358f, -0.01166175f, 0.00696956f, 0.01828058f, -0.04184622f, 0.00956079f, 0.02204064f, 
    -0.02687296f, 0.02687528f, -0.03396766f, -0.03934060f, 0.00888094f, -0.04444799f, -0.04338130f, 0.00250233f, 
    -0.02270108f, 0.01019486f, 0.01864131f, -0.00607072f, -0.04372263f, 0.00604835f, -0.02441272f, 0.02031845f, 
    -0.03402257f, 0.03927296f, 0.01201129f, 0.03482721f, 0.02603609f, 0.01696496f, -0.01635532f, -0.01018906f, 
    -0.00536736f, 0.01788253f, -0.03692197f, 0.01662219f, -0.00978901f, -0.00584658f, -0.00051524f, -0.00822903f, 
    -0.01708105f, -0.04485729f, -0.02651438f, -0.02289073f, -0.02876715f, -0.03580860f, 0.00674022f, -0.01382789f, 
    0.02716693f, 0.02253585f, -0.03048969f, 0.01149632f, -0.03216562f, -0.02715438f, -0.02465070f, -0.01586473f, 
    0.02044175f, -0.02318615f, -0.03130058f, -0.03116479f, -0.01109463f, -0.00287095f, -0.02997768f, -0.02471062f, 
    0.02443118f, 0.01529781f, 0.00775681f, -0.04069667f, 0.00123654f, -0.00329186f, -0.04641106f, -0.04516772f, 
    -0.02398010f, 0.02327881f, 0.01027627f, -0.04287448f, -0.03284728f, -0.03075198f, -0.03538202f, 0.01595925f, 
    0.00898865f, -0.01664861f, -0.03156238f, 0.01133896f, 0.00031044f, 0.00143251f, -0.00551163f, 0.01816696f, 
    0.03035694f, 0.01331999f, -0.02558840f, -0.00648238f, 0.02973562f, 0.02716636f, 0.01284892f, 0.00189607f, 
    -0.03006496f, -0.01693919f, 0.00921270f, 0.01482115f, 0.02407139f, -0.04110586f, -0.00221990f, -0.03005235f, 
    -0.03496147f, 0.02569876f, -0.03045645f, 0.02562281f, -0.02370504f, -0.01587875f, 0.00660992f, -0.00804756f, 
    -0.01529383f, 0.00695721f, 0.01841660f, 0.00651934f, -0.00808982f, -0.02277030f, 0.01097040f, -0.00821937f, 
    -0.00909327f, 0.03317804f, -0.02889224f, 0.01187876f, -0.00927249f, -0.03587903f, 0.01092988f, 0.02383860f, 
    -0.00860899f, -0.01062064f, -0.01716276f, -0.02353007f, -0.00195393f, -0.00697593f, -0.00040136f, -0.01682921f, 
    -0.00811654f, 0.02408294f, 0.00660122f, 0.00558376f, 0.00044737f, 0.02547019f, 0.02483205f, -0.04080155f, 
    0.03269806f, 0.01306167f, 0.00330781f, 0.02948440f, 0.00876654f, -0.00394665f, -0.01242002f, 0.01993936f, 
    0.01363565f, -0.02296597f, 0.01764732f, -0.01012059f, -0.03235383f, -0.02278570f, 0.00576895f, -0.02115871f, 
    -0.02058301f, -0.03597897f, 0.01689548f, -0.03276964f, 0.01985979f, -0.00086038f, 0.02503388f, -0.04530963f, 
    -0.00147944f, -0.04485111f, 0.00002379f, -0.02635168f, -0.03647914f, -0.02306172f, 0.02109571f, -0.00427058f, 
    -0.01910369f, -0.01662595f, 0.02369512f, -0.04102034f, -0.03701598f, 0.00860695f, 0.00309410f, -0.02468280f, 
    -0.00859776f, 0.00941857f, 0.00799735f, -0.01812817f, -0.03221501f, -0.03462544f, 0.02199308f, -0.00039459f, 
    -0.01022109f, -0.00355318f, -0.03048966f, -0.02116300f, -0.03227599f, -0.03849226f, -0.00600400f, 0.01956869f, 
    0.00795174f, 0.03488837f, -0.03257671f, -0.02412770f, -0.03507078f, 0.00503854f, -0.03301796f, -0.00268870f, 
    0.00720819f, -0.03428985f, 0.01082013f, -0.03713679f, 0.01869023f, -0.01323329f, -0.03323288f, -0.02443466f, 
    0.02287532f, 0.02795831f, -0.03804095f, -0.02912015f, 0.02705522f, 0.02520554f, 0.02553460f, -0.03720175f, 
    0.00275076f, 0.03062687f, -0.02222948f, 0.02109583f, 0.02118705f, 0.01655631f, -0.01310265f, 0.01767980f, 
    -0.02307250f, 0.01486391f, 0.00926634f, -0.00866830f, 0.02015535f, 0.01090532f, 0.01947296f, 0.01834920f, 
    0.01639863f, -0.03395018f, 0.01068631f, -0.03922232f, 0.02216455f, 0.00882445f, 0.00298661f, -0.01506138f, 
    -0.02662374f, -0.03418614f, -0.02014995f, -0.00488728f, -0.01284721f, -0.03165700f, 0.01954659f, 0.00363024f, 
    -0.02343364f, -0.00603355f, -0.04236026f, -0.00328154f, 0.00033904f, -0.00587996f, 0.01544188f, -0.05075882f, 
    -0.02214707f, -0.01600850f, -0.01745029f, -0.00750387f, 0.01587381f, 0.00665626f, -0.00299113f, 0.00976504f, 
    0.00708967f, 0.00400370f, 0.02755972f, -0.00790464f, -0.01963342f, -0.03675167f, -0.03458663f, -0.01989447f, 
    -0.04184080f, 0.02073603f, -0.00309770f, 0.01312360f, -0.03108653f, 0.00082436f, -0.01822640f, -0.01905834f, 
    -0.01234098f, -0.01886613f, -0.01399409f, -0.01528524f, -0.00954207f, -0.00458965f, 0.03593693f, -0.02779516f, 
    -0.00484405f, -0.03094262f, -0.01804039f, -0.00629688f, 0.01871849f, 0.03173916f, -0.02485678f, -0.01186680f, 
    0.01141677f, 0.01112985f, 0.00626589f, 0.01184479f, -0.04490011f, -0.00490676f, 0.01395285f, -0.02898477f, 
    0.01795888f, 0.00647684f, 0.00307536f, -0.04001065f, -0.02030767f, -0.01243392f, 0.01985057f, -0.00524892f, 
    -0.02394527f, -0.02485899f, -0.00264081f, 0.01919959f, -0.01037067f, -0.03118411f, 0.02126670f, -0.00122771f, 
    -0.01262619f, -0.00355066f, -0.03939365f, 0.00034149f, 0.01765797f, -0.02382509f, -0.02466175f, 0.01066200f, 
    -0.00736909f, 0.01554361f, 0.00264896f, -0.02224069f, -0.01195237f, -0.01104294f, -0.00978359f, -0.00201103f, 
    -0.03990656f, -0.00018044f, 0.01801466f, -0.01234268f, -0.03820645f, -0.01846351f, -0.03022886f, 0.02076517f, 
    -0.03770595f, -0.03315355f, 0.00995838f, -0.01921703f, -0.01046496f, -0.00880316f, -0.01003947f, -0.00026387f, 
    -0.02548026f, 0.01954219f, -0.03773707f, 0.00287527f, -0.01010823f, -0.01400544f, -0.03073748f, -0.01875655f, 
    -0.10975633f, -0.16895482f, 0.00110346f, 0.17659818f, -0.00936823f, 0.01468445f, -0.01166292f, -0.01074077f, 
    -0.03814509f, -0.02278000f, -0.06111485f, -0.06813568f, -0.08781576f, -0.11271381f, 0.00401426f, 0.15954177f, 
    0.07986331f, 0.08910838f, 0.13963372f, -0.04937952f, -0.02168607f, 0.05664829f, -0.08204360f, 0.12227403f, 
    -0.16415480f, 0.01462647f, -0.10132849f, -0.00553140f, -0.10583876f, 0.14320453f, -0.10903549f, 0.01989271f, 
    0.02911655f, 0.08942495f, -0.04034145f, 0.04005631f, -0.06912087f, 0.03800643f, -0.02779378f, -0.01518928f, 
    0.14122245f, 0.00289244f, 0.02433535f, 0.00019994f, 0.09464441f, -0.00549710f, -0.06260227f, -0.01238911f, 
    -0.20170224f, 0.26246256f, -0.04971951f, 0.31690934f, 0.13838676f, 0.10529849f, -0.24300231f, -0.01028212f, 
    0.16163260f, 0.02596270f, 0.10966261f, 0.11651961f, -0.12353355f, 0.00744570f, 0.16879764f, 0.10352610f, 
    -0.05767382f, -0.12278007f, 0.09581544f, 0.01608402f, -0.01296418f, 0.03079227f, 0.00663117f, -0.00614279f, 
    0.15904768f, -0.18176873f, 0.03736887f, -0.05134532f, -0.21054348f, 0.07897875f, 0.07090919f, -0.20895338f, 
    0.10879230f, -0.04189777f, -0.03183432f, -0.02594144f, 0.05991760f, -0.14788243f, 0.27075353f, -0.00522024f, 
    0.13137667f, -0.04143093f, 0.12637807f, 0.04448922f, 0.05943966f, 0.02362838f, -0.05361937f, 0.19909261f, 
    -0.06951407f, -0.19080453f, -0.16702729f, 0.34834662f, -0.07579735f, -0.06601604f, 0.11504174f, -0.03337442f, 
    -0.09425644f, -0.01337547f, -0.01099859f, -0.01486444f, -0.05009636f, 0.12973844f, -0.05057338f, -0.11863402f, 
    0.00995521f, 0.21941389f, -0.01429932f, -0.01048365f, -0.01922294f, 0.22265580f, -0.10125323f, 0.00338404f, 
    -0.08945754f, 0.31069836f, -0.33547428f, 0.02225310f, 0.11131264f, -0.00445601f, -0.03040822f, 0.28338328f, 
    -0.09436619f, 0.12097343f, 0.13118580f, 0.04148311f, 0.25695297f, 0.13603210f, -0.16926104f, -0.10540147f, 
    0.01717177f, -0.02261094f, 0.03422724f, 0.00467671f, 0.14427105f, 0.20211537f, 0.01293121f, 0.06821166f, 
    0.16155383f, -0.32620400f, 0.02241077f, 0.27071193f, -0.01943215f, 0.05272762f, -0.00545310f, -0.03825893f, 
    -0.09577984f, 0.04185362f, -0.02768043f, -0.13811840f, 0.00514153f, -0.13457270f, 0.17552172f, -0.30735096f, 
    -0.15773869f, -0.06415156f, 0.02172847f, -0.09046843f, 0.10989252f, 0.04229983f, -0.12517689f, 0.05797532f, 
    0.13332500f, 0.18001063f, 0.07697022f, 0.18493591f, -0.04526717f, -0.06601609f, -0.06426024f, -0.15347362f, 
    -0.01284793f, 0.19501041f, 0.08960571f, 0.17072228f, 0.10656900f, -0.19985013f, 0.38898653f, -0.08629807f, 
    0.21337488f, -0.04079815f, 0.07220997f, -0.03127779f, 0.16255163f, -0.10184626f, 0.08304214f, -0.00236186f, 
    0.03330028f, 0.14348564f, 0.17568135f, 0.03977683f, -0.06795888f, -0.00408676f, -0.02284222f, -0.03851694f, 
    0.14188017f, -0.00480066f, 0.13142304f, 0.10022338f, -0.05941950f, -0.12079451f, 0.07959295f, 0.10418255f, 
    0.13091254f, 0.13900730f, -0.07187793f, 0.22165795f, -0.07183773f, -0.03143321f, -0.09066273f, 0.03885134f, 
    -0.02358650f, -0.03606436f, -0.02592067f, 0.01820368f, 0.03828816f, 0.06938423f, 0.13969710f, 0.08822995f, 
    -0.03636894f, -0.08120140f, 0.00974038f, -0.00836781f, 0.17707753f, 0.26010013f, 0.37943402f, -0.02921505f, 
    -0.05754537f, 0.01250108f, -0.14361739f, -0.14530487f, -0.12589581f, 0.12254623f, -0.00461770f, -0.02511886f, 
    -0.24421097f, -0.13814557f, -0.28275624f, 0.14153396f, -0.03318917f, 0.07726447f, 0.01050329f, -0.04493020f, 
    -0.03852976f, -0.06134933f, -0.02994609f, 0.07345709f, -0.12009400f, -0.02560306f, -0.08516009f, 0.03430490f, 
    0.04312897f, 0.20601420f, 0.07229469f, 0.04728882f, 0.01148181f, 0.05373223f, 0.01030593f, 0.15074986f, 
    0.03470919f, 0.18819430f, -0.09915875f, 0.09971146f, 0.05500645f, 0.06855858f, -0.02559788f, -0.02140791f, 
    0.20146020f, -0.00778218f, -0.00813130f, 0.30600923f, 0.07481283f, -0.06586802f, 0.10754110f, -0.35099402f, 
    -0.04974958f, 0.11662111f, 0.15109313f, -0.08711997f, 0.04129998f, -0.00241859f, -0.10574906f, -0.05025649f, 
    0.17655471f, 0.09000970f, 0.09202017f, -0.08965410f, 0.00620852f, -0.00092529f, 0.08765838f, 0.11824030f, 
    0.12537111f, 0.02057938f, 0.04843597f, 0.10108113f, -0.11039754f, -0.06570992f, 0.22020219f, 0.15922561f, 
    -0.22528931f, 0.09413914f, -0.07229017f, -0.01992871f, -0.08536183f, -0.17192294f, 0.11542025f, -0.04701004f, 
    0.38667729f, 0.37348804f, 0.39008042f, -0.05312780f, -0.03001380f, -0.07232147f, 0.00792718f, -0.03914538f, 
    -0.14175816f, 0.03124886f, 0.04513287f, 0.04433486f, 0.18030491f, -0.11869031f, 0.00727133f, 0.04506987f, 
    -0.01410023f, 0.01039393f, -0.00555076f, -0.01291021f, 0.02324653f, 0.00940297f, -0.05780603f, -0.08598035f, 
    0.04213071f, 0.26054081f, -0.02736177f, -0.07944816f, -0.06172718f, 0.16001549f, -0.03190509f, 0.09771887f, 
    -0.03854224f, 0.22179900f, -0.25608346f, 0.06153010f, -0.24977261f, 0.05307204f, -0.21257226f, -0.25229508f, 
    -0.00910602f, 0.13339357f, 0.11092657f, 0.11286127f, -0.00307208f, -0.06835461f, 0.03852062f, -0.09768228f, 
    0.77257848f, -0.37014931f, -0.11459560f, -0.15077612f, -0.03077487f, -0.20392396f, 0.02538985f, -0.39476871f, 
    -0.01312638f, -0.06014223f, -0.05609997f, 0.18411031f, 0.28683892f, 0.15750800f, 0.35135582f, 0.20677733f, 
    0.00953201f, -0.12215617f, -0.01003645f, 0.14430462f, -0.09455521f, 0.16464227f, -0.14835548f, 0.12410653f, 
    0.00788161f, -0.01091600f, 0.11750856f, -0.21478325f, 0.10726918f, 0.16207331f, 0.01157059f, -0.16558945f, 
    0.29205558f, -0.18197423f, 0.09250165f, 0.17861322f, -0.00298543f, 0.04496664f, 0.08021756f, 0.03950742f, 
    0.06701706f, -0.02005929f, -0.07823488f, -0.07618147f, -0.17635220f, 0.17889333f, 0.08814063f, 0.07701281f, 
    0.01975464f, -0.01251961f, 0.04216942f, 0.16578713f, -0.04927135f, 0.07026679f, -0.11085229f, -0.02935985f, 
    -0.00462906f, 0.06447577f, 0.03019547f, -0.08202002f, -0.11169082f, -0.18125811f, 0.12482677f, 0.35501054f, 
    0.13901526f, 0.04956803f, 0.13365605f, 0.17600052f, 0.11928011f, 0.17663512f, -0.02428935f, 0.05586192f, 
    -0.05465841f, -0.16227181f, -0.08027019f, 0.12874313f, 0.02058936f, -0.13360460f, 0.06028353f, -0.15260401f, 
    -0.08666302f, -0.05203520f, -0.06596604f, -0.07470480f, -0.09642994f, -0.00401165f, 0.17683177f, -0.01610665f, 
    0.04389737f, -0.02427039f, 0.02179161f, -0.05709484f, 0.01051399f, -0.08027987f, 0.00202124f, -0.12149441f, 
    -0.13689096f, 0.44914514f, 0.36077750f, 0.17045762f, -0.13170463f, -0.12681918f, 0.08832697f, -0.05581690f, 
    0.10023790f, 0.10040288f, -0.01173634f, 0.15114357f, -0.17176227f, 0.06156242f, -0.14519897f, 0.15204459f, 
    -0.00408069f, 0.01586938f, -0.05467557f, -0.10643222f, -0.01250778f, 0.04210463f, -0.08604896f, -0.08253241f, 
    0.14195082f, -0.11724957f, 0.23844028f, 0.16127816f, 0.13849945f, -0.02520117f, 0.00542973f, 0.07524275f, 
    0.18822850f, 0.09968296f, -0.02110293f, 0.11709753f, -0.48635998f, 0.10778093f, 0.01663266f, 0.11678270f, 
    0.27439377f, 0.06147749f, -0.10435614f, 0.07131016f, 0.06280893f, -0.05443944f, 0.09346914f, -0.10738674f, 
    0.03346220f, 0.03884072f, -0.07853201f, 0.13811727f, 0.07532158f, 0.04844306f, -0.01308107f, 0.04433624f, 
    -0.03627281f, 0.03296989f, -0.22075792f, 0.03829027f, -0.14958827f, -0.15344919f, 0.12037779f, -0.15055835f, 
    -0.28673303f, 0.09242029f, 0.19241107f, 0.07078163f, 0.05100309f, 0.01552896f, -0.03514746f, 0.04789359f, 
    -0.07576083f, 0.49451819f, 0.17061809f, -0.20125724f, -0.09615178f, 0.09946968f, 0.15079530f, 0.03180359f, 
    0.01403444f, 0.19466484f, -0.36581686f, -0.02410015f, 0.12162335f, 0.00420975f, -0.13547958f, -0.02391029f, 
    -0.00733779f, 0.00541996f, 0.12158964f, 0.00368150f, 0.10488349f, -0.01960599f, -0.20103867f, 0.21227354f, 
    -0.08182921f, -0.03495463f, 0.09629340f, 0.16291212f, -0.11157055f, -0.15553029f, -0.12352291f, 0.13020065f, 
    0.01086301f, -0.03975673f, -0.01086065f, -0.10362253f, -0.00376665f, -0.01981973f, -0.14450584f, 0.06077535f, 
    0.01178592f, 0.02036044f, 0.02031208f, 0.01527142f, -0.05916775f, -0.07774920f, 0.01748880f, -0.14091648f, 
    0.08113050f, -0.03533745f, -0.07109194f, 0.04111853f, 0.02112094f, -0.15021704f, 0.02404595f, -0.04124573f, 
    0.00596430f, -0.04941646f, 0.03483264f, -0.05062757f, 0.88642323f, 0.36019513f, 0.48030764f, 0.31824440f, 
    -0.04867155f, -0.18597835f, 0.01941305f, -0.01256203f, 0.01593668f, 0.13124232f, 0.05963466f, 0.18468656f, 
    0.57237965f, 0.00003008f, -0.07348227f, -0.14322515f, 0.07206183f, 0.00805307f, -0.01822013f, 0.00010734f, 
    0.05611040f, -0.08953044f, 0.01645176f, -0.07113880f, 0.06450231f, -0.02226101f, 0.27834558f, 0.11256264f, 
    -0.09460026f, 0.04114905f, 0.15780561f, -0.07614870f, -0.25957701f, 0.00180952f, 0.05532027f, -0.02942750f, 
    -0.06387319f, -0.12003040f, 0.02388079f, 0.09873240f, -0.14204141f, 0.02995471f, 0.06463712f, -0.03105924f, 
    -0.01705915f, -0.07751200f, -0.08006421f, -0.04560024f, 0.13288493f, 0.05219769f, -0.02437341f, 0.00428312f, 
    -0.00204696f, 0.00661278f, 0.01671522f, -0.00539460f, -0.04914052f, 0.01564653f, 0.04905164f, -0.03024199f, 
    0.24969870f, 0.05950005f, 0.17566028f, -0.12675668f, 0.09289540f, -0.17715079f, 0.05092691f, 0.05683587f, 
    0.01106006f, 0.23276658f, -0.12719288f, 0.02412274f, -0.25140277f, 0.10572241f, -0.17590988f, 0.00310987f, 
    -0.04686971f, -0.13252153f, 0.24726933f, -0.02007088f, 0.02339949f, 0.05285837f, 0.09908459f, 0.01611673f, 
    0.21267289f, 0.10311632f, -0.08999325f, 0.01980195f, 0.04976172f, -0.02763593f, -0.03368837f, -0.06296856f, 
    -0.16358478f, -0.01402261f, -0.11692744f, 0.05868941f, 0.02192059f, 0.10541288f, 0.05201382f, 0.18855014f, 
    0.05268460f, 0.00783792f, 0.09682442f, 0.01324270f, -0.13030531f, 0.05837607f, 0.08004367f, 0.29154402f, 
    -0.28938517f, -0.20601800f, -0.16846347f, 0.09941068f, -0.01573884f, -0.07098062f, -0.12576731f, -0.02702480f, 
    -0.03104590f, 0.03079657f, -0.00246830f, -0.01350424f, -0.05616409f, 0.03502132f, -0.02461072f, -0.00880990f, 
    0.03875971f, 0.10423765f, 0.18155035f, -0.02526501f, 0.01014218f, -0.05822302f, -0.03049122f, -0.06128466f, 
    0.19221410f, 0.10914143f, 0.16929254f, -0.14848895f, 0.02313941f, -0.15353048f, -0.08988414f, -0.04655544f, 
    -0.05538237f, -0.07565859f, 0.17261350f, 0.02145177f, -0.06096380f, 0.08378679f, 0.07365418f, 0.01763667f, 
    -0.04038651f, -0.04776192f, -0.03276492f, -0.00494076f, -0.09084435f, 0.02683327f, 0.04455234f, -0.10955148f, 
    0.12018763f, 0.01087938f, 0.16066885f, 0.09356483f, 0.00289297f, 0.07785130f, -0.00799937f, 0.05020823f, 
    -0.02418269f, 0.05095895f, -0.03599032f, -0.02664300f, -0.31025442f, -0.20413728f, 0.05948788f, 0.25629207f, 
    -0.10597815f, -0.08505060f, -0.14075764f, -0.12249883f, -0.06658133f, -0.03640690f, 0.05431210f, -0.01208219f, 
    0.12311069f, 0.05076769f, -0.23806418f, -0.05811773f, 0.03929769f, 0.06443708f, 0.04474514f, -0.11218062f, 
    0.04944804f, 0.01718996f, -0.01817112f, -0.01575406f, 0.17009343f, -0.03335951f, -0.05433656f, -0.00719056f, 
    0.02815824f, 0.08727732f, 0.00476248f, 0.07004140f, -0.05448337f, 0.05167845f, 0.02668429f, -0.00071989f, 
    -0.08652813f, 0.17411362f, 0.06535305f, -0.16699930f, 0.05351239f, 0.15036520f, -0.00608553f, 0.02753223f, 
    0.03665765f, -0.01934615f, -0.01883651f, 0.03823367f, 0.03072778f, 0.01692024f, -0.03954678f, 0.02707412f, 
    0.09864077f, 0.00452139f, 0.12579188f, -0.08835421f, -0.02398673f, 0.00634491f, 0.02081753f, -0.04626717f, 
    0.19738568f, 0.14769648f, -0.09496073f, 0.14480083f, 0.12587777f, -0.03581554f, 0.14702484f, -0.14235704f, 
    -0.05041181f, -0.02933484f, 0.05776043f, 0.02096210f, 0.04542913f, -0.13223320f, -0.17143241f, 0.02490965f, 
    0.20068523f, 0.03523067f, 0.00376807f, 0.00598108f, 0.04796316f, 0.00553084f, -0.14713439f, 0.20173827f, 
    0.04961075f, -0.24985085f, 0.15004691f, -0.20692371f, -0.05911707f, -0.00908897f, 0.00538093f, -0.07269178f, 
    -0.10595539f, -0.02427916f, -0.05612143f, 0.06811128f, 0.08462304f, -0.02099076f, 0.06527629f, 0.16266407f, 
    0.02810615f, 0.02253144f, 0.01248210f, 0.06988215f, -0.08083576f, -0.10344514f, 0.05471222f, 0.04685079f, 
    -0.08518837f, 0.05926698f, 0.06790701f, -0.19411299f, -0.01916180f, 0.03875300f, 0.04576211f, -0.02343637f, 
    0.00869387f, -0.00789051f, 0.05460372f, 0.00978315f, -0.05454721f, -0.07604486f, 0.02594447f, -0.10083592f, 
    -0.03527397f, 0.12011087f, 0.12047690f, 0.18621150f, 0.11659457f, -0.02287444f, -0.08038080f, 0.03385311f, 
    -0.27341014f, 0.12499257f, -0.23359339f, 0.07943545f, -0.00963820f, -0.00648223f, 0.14391492f, -0.00686681f, 
    -0.10401700f, 0.11758047f, -0.14836425f, 0.06452240f, -0.01982207f, 0.22862786f, 0.10189938f, -0.10121362f, 
    -0.03989705f, -0.00111702f, -0.06062316f, 0.10347389f, -0.00349167f, 0.01485751f, -0.06905118f, 0.06390914f, 
    0.10203105f, 0.00874417f, 0.09104551f, 0.01668525f, -0.12051562f, -0.01432951f, 0.09013826f, -0.06603298f, 
    -0.10069200f, 0.16155626f, 0.04830536f, -0.17359804f, 0.16099015f, -0.15828145f, 0.15735500f, -0.08459552f, 
    -0.06697013f, -0.01272527f, 0.17689176f, 0.13834098f, -0.00900530f, 0.01621890f, -0.04618113f, 0.02803231f, 
    -0.00343524f, -0.03705138f, -0.06488731f, -0.13499416f, 0.06092554f, 0.15779780f, -0.09152675f, 0.03096971f, 
    -0.02001490f, 0.00350454f, -0.13476786f, -0.01439447f, -0.26071349f, -0.11239512f, 0.08057232f, 0.17174910f, 
    0.03323337f, -0.06265514f, 0.14345089f, -0.00574051f, -0.03677355f, -0.01750513f, 0.00115869f, 0.12821434f, 
    0.16646114f, 0.12451217f, 0.03569222f, -0.00259289f, -0.04552189f, 0.04265672f, 0.05245334f, -0.01212959f, 
    0.00628878f, 0.03908202f, 0.09647556f, -0.02241022f, -0.06163699f, -0.25635406f, -0.07864215f, 0.00815610f, 
    -0.01514847f, -0.02965390f, 0.06148942f, 0.07906821f, -0.03391349f, -0.02018812f, -0.03309521f, -0.02521905f, 
    -0.13081521f, -0.18071590f, 0.00769312f, 0.07331087f, -0.25224623f, -0.01305406f, 0.07747453f, -0.17781962f, 
    -0.05095062f, -0.14109643f, 0.04383394f, -0.08378416f, 0.27694488f, 0.05420391f, -0.35042706f, 0.17842959f, 
    -0.03417354f, -0.06890724f, -0.01117591f, -0.05981925f, -0.01791048f, 0.15736686f, 0.13712028f, -0.05255884f, 
    -0.12028318f, 0.28849277f, -0.25461835f, -0.15820937f, 0.00969623f, -0.03973568f, 0.01906765f, -0.14189233f, 
    -0.06915355f, 0.03641226f, -0.06187807f, -0.05620314f, 0.07956480f, 0.02098851f, -0.12462736f, -0.05230647f, 
    0.01388457f, 0.06777433f, 0.14950311f, 0.12616107f, 0.05476591f, 0.08064472f, -0.05702187f, -0.05857735f, 
    -0.03437231f, 0.30018404f, -0.05979987f, -0.04913159f, -0.07268535f, 0.03375993f, -0.09051618f, -0.08050695f, 
    -0.01393746f, 0.00492686f, -0.01249111f, -0.02349450f, 0.03788037f, -0.40132114f, 0.14967380f, 0.01068396f, 
    -0.12245069f, 0.11438756f, 0.10763649f, 0.07400733f, 0.05912386f, 0.11673876f, 0.05383546f, -0.05672790f, 
    -0.25098518f, 0.08086688f, 0.12148471f, -0.01520516f, -0.06337351f, -0.06717984f, -0.05043266f, -0.06073098f, 
    -0.12145794f, -0.04691731f, -0.00010274f, -0.00851410f, 0.28931931f, 0.52509791f, 0.11415403f, -0.47873321f, 
    0.00619267f, 0.12726040f, 0.02946273f, 0.01411616f, -0.00398043f, 0.07168312f, -0.09803881f, 0.00512786f, 
    -0.02938769f, 0.15770987f, -0.08907121f, 0.06442298f, -0.02187580f, 0.11167774f, -0.04362368f, 0.00743167f, 
    0.00261209f, 0.10697843f, -0.04401288f, 0.09836016f, 0.03853545f, -0.00504071f, 0.17250434f, -0.13073154f, 
    -0.02533117f, -0.04097649f, -0.00279900f, -0.05317622f, -0.10492154f, -0.03780453f, -0.03969411f, 0.06898117f, 
    -0.12476996f, 0.10695679f, 0.05964749f, -0.10963252f, 0.00990280f, -0.07875090f, -0.06213105f, -0.00141101f, 
    -0.09699637f, 0.18465532f, 0.01305582f, -0.00221993f, -0.17192641f, -0.09082770f, -0.13731433f, -0.02501187f, 
    0.06299461f, -0.03572926f, 0.02495855f, -0.15148139f, 0.03057624f, 0.09251759f, 0.04240023f, 0.07824012f, 
    0.10123701f, -0.18178661f, 0.15322158f, 0.29453176f, -0.14676292f, 0.26657668f, 0.18165040f, -0.06267243f, 
    0.09421396f, 0.12039068f, 0.16386174f, 0.10773526f, 0.13800214f, 0.03047292f, -0.05788622f, 0.04969261f, 
    0.12809443f, 0.04922511f, 0.04348591f, -0.03591034f, 0.04750761f, -0.04557261f, -0.02385288f, 0.06289420f, 
    -0.06886960f, -0.20972070f, -0.04576718f, -0.00161423f, -0.06078521f, 0.14502746f, 0.14868161f, 0.09555697f, 
    0.08881801f, 0.16702914f, 0.02483618f, 0.06605848f, -0.11516578f, 0.28402665f, -0.05100178f, -0.15193288f, 
    0.02113372f, 0.05882927f, 0.08444569f, -0.11674356f, -0.06560825f, -0.05081147f, 0.09221548f, -0.13640210f, 
    0.24078004f, 0.21194153f, 0.03183623f, -0.20306781f, 0.13464099f, 0.14963222f, 0.00296704f, -0.02741011f, 
    -0.04446914f, 0.01506674f, 0.09219306f, -0.13007070f, 0.05780695f, -0.00155199f, -0.32830453f, 0.02687786f, 
    0.09721632f, 0.11012732f, -0.04772120f, 0.16246529f, 0.04236855f, -0.05384012f, -0.02256371f, -0.00756428f, 
    -0.00752408f, -0.02717626f, -0.04703690f, -0.17514043f, -0.02623705f, -0.05999583f, 0.11879585f, -0.18330450f, 
    -0.02775432f, -0.04577547f, 0.11497397f, 0.08719884f, 0.17448123f, 0.13151699f, -0.02272488f, -0.16317537f, 
    0.13993748f, -0.04236902f, 0.08501004f, 0.04390913f, 0.03492160f, 0.10849334f, -0.04705080f, 0.21409589f, 
    0.14537750f, -0.06836620f, -0.28362158f, 0.18633373f, 0.04274441f, 0.11058183f, 0.03409314f, -0.00766647f, 
    0.07068670f, 0.00198577f, 0.06464063f, 0.08815264f, -0.00294046f, 0.32874113f, 0.02434550f, -0.27481705f, 
    -0.15451999f, -0.02976449f, 0.04805735f, -0.11365026f, 0.00543234f, 0.04214714f, -0.12741540f, 0.08443918f, 
    0.20150822f, -0.16165929f, -0.00872372f, 0.11060180f, 0.11898116f, 0.18124327f, -0.00372129f, 0.09168723f, 
    -0.01748182f, 0.18012051f, -0.08641462f, -0.11531185f, -0.00125858f, 0.24571687f, -0.14064774f, 0.22895136f, 
    0.13853756f, -0.05737562f, 0.06192097f, 0.02996601f, 0.14873204f, -0.05838633f, 0.12824722f, 0.02828545f, 
    0.19323969f, 0.06987163f, 0.10107825f, -0.17437299f, -0.05755650f, -0.02692077f, 0.05180415f, -0.10072196f, 
    -0.14045492f, 0.05974365f, 0.07599095f, -0.00698025f, -0.00378211f, -0.41188720f, -0.08099519f, -0.23591799f, 
    -0.08049380f, 0.10544916f, 0.10793669f, 0.01371310f, -0.03435048f, 0.02420184f, -0.02126779f, -0.01064812f, 
    -0.00324441f, -0.04520501f, -0.15262601f, 0.24850258f, 0.00712022f, -0.10609297f, 0.14087035f, -0.05290315f, 
    0.02692875f, 0.12291406f, 0.03626019f, 0.02153888f, -0.14669360f, -0.04734525f, 0.09226420f, -0.11568552f, 
    -0.10555591f, 0.15757321f, 0.12029856f, 0.16482058f, -0.14209968f, 0.09410697f, 0.00403190f, 0.05059760f, 
    0.19115670f, -0.03827795f, -0.18099922f, -0.04722121f, 0.11919395f, 0.12552975f, -0.10039695f, 0.07072834f, 
    -0.08280890f, 0.07669941f, -0.00543938f, 0.02011147f, -0.18043566f, 0.08064359f, -0.03228277f, -0.03543289f, 
    0.06393097f, -0.04122912f, -0.00307029f, -0.03863965f, 0.00285458f, 0.04373467f, -0.05443313f, 0.06315611f, 
    0.04069198f, 0.01047675f, 0.23637989f, -0.15565234f, -0.09339837f, 0.05842627f, 0.11250939f, -0.01630436f, 
    0.06138810f, 0.07669532f, 0.26977009f, -0.01626851f, 0.46897984f, -0.21958677f, 0.29186305f, 0.05082930f, 
    0.14886200f, 0.25363141f, -0.08018556f, 0.17451715f, -0.12681307f, 0.06127854f, 0.01129455f, 0.02220945f, 
    -0.18378633f, -0.00137543f, 0.09811071f, 0.03210652f, -0.04112962f, -0.11878763f, 0.05241830f, 0.08906607f, 
    -0.18031129f, -0.04457284f, -0.02444454f, -0.07584605f, 0.17210838f, -0.01306178f, -0.10221836f, -0.03246341f, 
    0.09371978f, 0.09462733f, -0.01879083f, 0.00162756f, 0.06377600f, 0.09122634f, 0.13357350f, -0.01348841f, 
    0.09539707f, -0.04988145f, -0.07771705f, 0.01405719f, 0.07570343f, 0.07892115f, 0.03730750f, -0.01555413f, 
    -0.06374722f, -0.03313166f, -0.04308323f, 0.00745797f, -0.10049471f, 0.03900253f, 0.01105435f, -0.08898622f, 
    -0.10369451f, -0.08693184f, -0.00259768f, -0.03109886f, -0.15045212f, -0.00013680f, -0.09322664f, -0.05426152f, 
    0.30273011f, -0.16255175f, 0.06360696f, 0.32728818f, -0.02685083f, -0.11029579f, -0.01185059f, -0.02749189f, 
    -0.01462604f, -0.07979079f, 0.03921841f, 0.00414731f, -0.01383243f, 0.20556255f, 0.11037122f, -0.23846839f, 
    -0.09203314f, -0.01549682f, 0.04512470f, 0.01958373f, 0.09354820f, 0.09571035f, -0.08761895f, 0.04078007f, 
    0.09745364f, 0.27433696f, 0.22964144f, -0.23470390f, -0.06240517f, 0.00594845f, 0.03816468f, 0.01533825f, 
    0.03166224f, 0.09935292f, 0.23615165f, 0.09082519f, 0.12426595f, -0.06302753f, -0.05058681f, 0.19217288f, 
    -0.03424533f, 0.06655122f, 0.01569441f, 0.08598743f, 0.02050887f, 0.16037117f, -0.07997346f, -0.03040185f, 
    0.39788297f, 0.24607041f, -0.20290661f, -0.10504659f, 0.17451337f, 0.16958387f, 0.05520957f, 0.00250668f, 
    0.02556702f, -0.02346835f, -0.05656002f, -0.05368752f, -0.05148738f, 0.03060375f, -0.10282055f, -0.14035331f, 
    -0.08712773f, -0.06865096f, 0.02994308f, -0.15311219f, -0.11802823f, 0.00192667f, 0.05803213f, -0.08058130f, 
    0.07418032f, -0.17103340f, 0.18709777f, 0.16942748f, -0.02295483f, -0.09866073f, 0.00281424f, 0.00476110f, 
    -0.09734160f, -0.12419675f, 0.01105364f, -0.15632518f, -0.13339470f, 0.14066868f, -0.10577400f, 0.04760634f, 
    -0.03666442f, -0.10192326f, 0.14099906f, -0.02003326f, -0.14369632f, 0.05626991f, 0.13665056f, 0.06419237f, 
    0.01878708f, 0.05277787f, -0.03754390f, -0.09293175f, -0.06642272f, 0.00088824f, -0.04965957f, -0.09815116f, 
    -0.05620761f, 0.00783003f, 0.06577916f, 0.04194334f, 0.42306671f, 0.30379096f, -0.19676323f, -0.17699231f, 
    0.12993129f, 0.08081704f, 0.02571446f, -0.03749756f, -0.01121521f, -0.03822207f, -0.02368490f, -0.07007585f, 
    0.03550905f, 0.13131715f, 0.20716047f, 0.12893124f, -0.07547384f, -0.04305637f, 0.06532890f, -0.02562598f, 
    -0.04704834f, -0.00260048f, -0.03349971f, 0.00606722f, -0.08699655f, 0.10038508f, -0.02672237f, 0.04811443f, 
    -0.04748644f, -0.01643987f, 0.02189478f, 0.04553630f, 0.13871597f, 0.05535360f, 0.02796335f, 0.06666060f, 
    -0.22009079f, -0.18448053f, 0.04341103f, 0.10737921f, -0.05610004f, 0.07491723f, 0.15158083f, 0.06693159f, 
    0.08947185f, -0.07053892f, 0.12280087f, -0.05573615f, 0.13548957f, 0.11613733f, 0.08695406f, -0.06738495f, 
    -0.07240472f, -0.01897958f, -0.15937226f, 0.01466842f, -0.01342191f, -0.02009113f, -0.01991390f, 0.02928294f, 
    -0.30510458f, -0.12241058f, 0.18958907f, -0.06497799f, -0.10036122f, 0.04869058f, -0.15382853f, 0.08198892f, 
    0.06205408f, 0.00786151f, -0.12442274f, 0.09384602f, 0.11658892f, -0.01527414f, 0.06719922f, 0.05903263f, 
    -0.09748113f, -0.02699753f, -0.04118987f, 0.15832359f, 0.03711973f, 0.02177551f, -0.01035540f, -0.01583267f, 
    0.15231094f, 0.19609264f, -0.15000899f, 0.15175948f, 0.04669889f, -0.12472782f, 0.12246228f, 0.06395648f, 
    0.02692727f, 0.08493375f, -0.02815913f, -0.04342043f, -0.06077141f, 0.03566403f, 0.01338442f, 0.17083307f, 
    -0.04279704f, 0.05646980f, 0.03569413f, 0.02730428f, 0.13652711f, 0.02622822f, -0.04119135f, 0.01638742f, 
    0.12234861f, -0.00776179f, 0.12515514f, 0.21699613f, 0.09113061f, -0.00291980f, 0.02766676f, 0.04716255f, 
    0.03565975f, -0.09151892f, 0.12243961f, 0.06814013f, 0.09671362f, 0.12149178f, -0.01762987f, 0.03377716f, 
    0.13093020f, 0.02032165f, 0.18989958f, 0.03615094f, -0.01778735f, -0.11260617f, 0.00357089f, 0.04084563f, 
    0.22090752f, -0.07976584f, 0.29222095f, -0.19974455f, -0.06484176f, 0.17008348f, 0.02779674f, 0.17678380f, 
    0.04504834f, -0.07363984f, -0.02995151f, 0.13250014f, 0.26391277f, -0.04934357f, 0.12528992f, 0.00031753f, 
    -0.02744152f, -0.03199950f, -0.04140146f, -0.09447708f, -0.01419830f, 0.08702023f, -0.06655964f, -0.05548036f, 
    0.06596329f, -0.09785882f, 0.20209919f, -0.07921328f, 0.06494093f, 0.08869015f, 0.11048942f, 0.06349835f, 
    0.10590824f, 0.00570291f, -0.00711753f, 0.15920639f, 0.17939991f, -0.18511319f, 0.01822908f, 0.11029458f, 
    0.16508108f, 0.17315155f, 0.08132681f, 0.06943352f, -0.03218575f, 0.00644804f, 0.17382689f, -0.06204971f, 
    -0.13432786f, -0.11117549f, -0.10182579f, -0.14887708f, -0.11221252f, -0.11335705f, 0.02783850f, 0.14683634f, 
    0.09254570f, 0.01496796f, -0.08569247f, -0.10734955f, 0.19343200f, 0.03977523f, 0.09873331f, -0.04450097f, 
    0.08337530f, 0.08738177f, -0.03220449f, -0.02465298f, -0.03578275f, 0.12269752f, -0.07182108f, -0.01447547f, 
    -0.04944212f, 0.01703316f, -0.09058748f, -0.05061050f, 0.00147199f, -0.09901174f, -0.01193807f, 0.04695742f, 
    -0.02343436f, -0.17742056f, -0.09621377f, -0.00557338f, 0.05292137f, -0.04649291f, -0.01230512f, -0.00743081f, 
    -0.08214336f, 0.22944124f, 0.10217797f, 0.02390317f, 0.00142389f, -0.03171156f, 0.08246810f, -0.02031213f, 
    0.10139117f, 0.16802566f, -0.07941658f, 0.00065620f, 0.09434702f, 0.05591414f, 0.12724757f, 0.05722326f, 
    -0.02900779f, 0.00708794f, -0.03659609f, -0.00830566f, 0.12589084f, -0.02869468f, -0.08588696f, 0.08581001f, 
    0.07502980f, -0.12204161f, 0.04412627f, 0.34887093f, -0.00441882f, -0.08317275f, -0.03929988f, -0.10838166f, 
    0.15665545f, 0.08965264f, 0.02670929f, -0.04170398f, -0.07985324f, 0.13520320f, 0.18649325f, 0.10825541f, 
    0.03765674f, 0.02793104f, 0.04626817f, -0.03138332f, -0.02000926f, 0.07267705f, 0.09176868f, -0.02701943f, 
    0.09105958f, -0.07311904f, 0.00338512f, -0.03458219f, 0.02574879f, -0.01279897f, 0.08460844f, 0.05729987f, 
    -0.05019182f, -0.08351199f, 0.09667026f, 0.00264621f, 0.00473572f, -0.00163351f, 0.02288208f, 0.07565701f, 
    -0.03357297f, -0.10279234f, 0.14266542f, 0.03847994f, -0.06096387f, 0.03461164f, 0.01062253f, 0.14425910f, 
    -0.01240644f, -0.01828286f, 0.14981942f, 0.12942024f, -0.04526954f, -0.09260017f, 0.13241230f, -0.02726043f, 
    0.19799839f, -0.07801390f, -0.07750606f, 0.13225801f, -0.00408704f, -0.05814698f, -0.06213298f, 0.02088394f, 
    -0.01104788f, -0.07515465f, 0.03872235f, 0.00671650f, -0.25937814f, 0.08051642f, 0.12817194f, 0.19689853f, 
    0.00062385f, 0.01276741f, -0.07364194f, 0.03787384f, 0.12048894f, 0.21989781f, -0.02970302f, -0.08324332f, 
    -0.03751468f, 0.00778736f, -0.20314755f, -0.24724145f, -0.01361531f, -0.07528669f, -0.08726876f, 0.07697690f, 
    0.03003426f, -0.10152648f, 0.11304562f, -0.02321919f, 0.15607886f, 0.09831157f, -0.05365515f, -0.02335801f, 
    -0.05760169f, 0.00605117f, -0.02067343f, -0.07472489f, 0.04075227f, -0.14856791f, -0.01620810f, -0.09769678f, 
    0.02177902f, -0.08033522f, 0.03965518f, 0.01138099f, -0.09626188f, -0.11338557f, -0.09480374f, 0.01485466f, 
    0.02831924f, -0.13125460f, 0.12071344f, -0.11557689f, 0.23875952f, -0.10423075f, 0.28814054f, -0.06120925f, 
    -0.08984744f, -0.06979892f, -0.04328802f, 0.19821605f, -0.05766808f, -0.00324354f, -0.03420415f, -0.07232684f, 
    -0.22353669f, 0.23815489f, 0.19398220f, -0.28260550f, 0.10521928f, 0.23820308f, 0.07167559f, 0.17492236f, 
    0.03217679f, 0.05719665f, -0.17085232f, -0.04562044f, -0.03621971f, 0.09752611f, -0.02260720f, 0.01148571f, 
    -0.10976581f, -0.02710895f, 0.10141515f, 0.18337220f, 0.04469353f, -0.03756531f, 0.04987765f, -0.01151357f, 
    0.09988587f, -0.03986518f, -0.05103967f, 0.14226492f, -0.00918793f, -0.28816170f, 0.16834672f, -0.02365861f, 
    -0.04836493f, 0.05041026f, -0.18169606f, -0.01303790f, -0.21035707f, 0.24430700f, 0.07631175f, 0.14406495f, 
    -0.02069065f, -0.07947256f, -0.15249810f, 0.03401346f, 0.03507160f, 0.00981755f, 0.03628434f, -0.06700017f, 
    -0.31887445f, -0.33292446f, -0.01862042f, 0.12545691f, -0.08132311f, 0.11221597f, -0.01572899f, 0.00986830f, 
    -0.09624975f, 0.00819367f, -0.05733132f, -0.05273892f, -0.12157211f, 0.09172740f, 0.30591232f, 0.07357894f, 
    0.00060099f, -0.01677996f, -0.14059924f, -0.13600695f, 0.01820217f, 0.03786932f, 0.07359978f, -0.08738685f, 
    -0.12157512f, 0.10984403f, 0.03554573f, 0.09799023f, 0.03230495f, 0.09597086f, 0.10273907f, 0.01733513f, 
    -0.03206111f, -0.00610566f, -0.07119736f, 0.00353235f, -0.05291943f, -0.10329616f, -0.06705914f, 0.16619775f, 
    -0.17264022f, 0.14939557f, 0.05094936f, -0.04774684f, -0.01068802f, -0.03878637f, 0.04279097f, -0.01920733f, 
    0.05218669f, -0.23238687f, -0.14024308f, -0.36367035f, -0.05754094f, -0.13846354f, -0.08476062f, 0.24107879f, 
    0.00251357f, 0.00679499f, -0.08076846f, -0.12198165f, 0.05887498f, -0.01754483f, 0.04941479f, 0.22386345f, 
    -0.07858672f, 0.03524875f, 0.08645251f, 0.06760083f, 0.10274213f, 0.17566869f, -0.13129333f, 0.01939208f, 
    -0.14014678f, -0.05698105f, -0.03042505f, -0.02339128f, -0.03298282f, -0.07143501f, 0.17547975f, 0.06853669f, 
    0.01415870f, -0.10882101f, 0.05121896f, -0.06351101f, -0.19354744f, -0.36038762f, 0.47501177f, -0.08950269f, 
    -0.08099834f, 0.05175776f, -0.11544871f, 0.11579741f, -0.04949105f, -0.02071482f, -0.10707120f, 0.15476234f, 
    -0.08984772f, -0.03795958f, -0.05223945f, -0.08436500f, -0.12755160f, -0.04480627f, -0.08142707f, -0.03966759f, 
    0.07190341f, -0.07418847f, 0.09302913f, -0.11144139f, 0.53379184f, 0.21132724f, -0.12279218f, 0.06401051f, 
    0.04607806f, -0.00721485f, 0.36159033f, 0.09907632f, -0.02043235f, 0.04320499f, 0.07631312f, -0.01984051f, 
    0.16995724f, -0.34196535f, 0.07359701f, -0.01020044f, 0.04431009f, -0.02381433f, 0.08926653f, 0.27911085f, 
    -0.05338937f, -0.17656542f, 0.11894535f, -0.07481553f, 0.24534246f, 0.12182719f, -0.20708564f, 0.00902676f, 
    -0.07987571f, -0.08206496f, 0.06282558f, 0.10292941f, 0.13909543f, -0.07678816f, -0.03112819f, -0.07221171f, 
    -0.03315799f, 0.21397385f, 0.29154938f, 0.04978951f, -0.00329674f, 0.00986712f, -0.12383736f, -0.06511702f, 
    -0.05279098f, 0.03392636f, -0.02319307f, -0.04065038f, 0.11073992f, -0.04029847f, 0.04167380f, -0.12338267f, 
    -0.06710161f, -0.06304409f, -0.01152038f, 0.07587329f, 0.01442760f, 0.06414173f, -0.01913044f, 0.00279754f, 
    -0.18711458f, 0.10904663f, 0.08411050f, -0.18965277f, 0.01864308f, 0.02560082f, -0.06959157f, 0.14524482f, 
    0.06249287f, 0.07639617f, -0.13232841f, 0.07381912f, -0.42826319f, 0.06626381f, -0.12287065f, -0.33149242f, 
    -0.18521644f, -0.21343425f, 0.20685230f, -0.14133826f, 0.00664173f, -0.01561318f, 0.01506660f, -0.05318012f, 
    0.12957175f, 0.01042781f, -0.06167593f, 0.08887174f, -0.11366709f, -0.00343341f, -0.00670936f, -0.00860568f, 
    0.01306895f, 0.01062552f, 0.03689619f, 0.00606835f, -0.00345809f, 0.31769806f, -0.37272501f, -0.09128770f, 
    0.00397459f, -0.07795251f, 0.08430053f, 0.17389518f, 0.07550339f, 0.03045598f, -0.03393492f, 0.12405375f, 
    0.03450089f, 0.14675763f, 0.26088113f, 0.15773909f, -0.12942638f, -0.10443292f, -0.05890221f, -0.05617375f, 
    0.04674588f, 0.03737063f, 0.02060173f, 0.09836309f, 0.12880544f, 0.02311954f, -0.06936170f, -0.02990909f, 
    -0.03378313f, 0.00437991f, -0.01240433f, -0.00276209f, 0.06230155f, -0.03435791f, 0.06337244f, 0.01376641f, 
    0.17033717f, -0.09685995f, 0.07304975f, 0.08780467f, 0.03096121f, 0.01690623f, 0.06634887f, 0.02175224f, 
    -0.06047906f, -0.10660858f, 0.09438356f, 0.01260571f, 0.35834289f, 0.08501457f, 0.05423804f, 0.15380566f, 
    0.13168034f, 0.03624973f, 0.03782613f, 0.20857489f, -0.01513836f, 0.08212584f, -0.07559352f, 0.08306481f, 
    -0.10926761f, -0.06643663f, 0.15688106f, 0.17784037f, 0.01352735f, 0.04302874f, 0.03400778f, -0.07544270f, 
    0.11008921f, -0.01737881f, -0.14903669f, -0.02329369f, 0.02880595f, 0.16222210f, 0.12333702f, -0.13861737f, 
    -0.01837378f, -0.07306667f, -0.01056382f, 0.04228493f, 0.01047164f, -0.03186832f, -0.12730680f, 0.01346268f, 
    -0.13192846f, 0.00175061f, 0.22219177f, 0.03524451f, -0.09817515f, -0.05603071f, -0.11265081f, -0.02194286f, 
    -0.00558932f, 0.01937782f, 0.07878248f, 0.02869492f, 0.14969593f, 0.01335635f, -0.08399541f, 0.01517395f, 
    -0.04024579f, -0.02176259f, -0.02676437f, -0.00998954f, -0.05675393f, 0.02995412f, -0.05979884f, -0.06884129f, 
    0.03024442f, 0.09689536f, -0.09191713f, 0.01932422f, 0.01409812f, -0.00182488f, 0.04664835f, 0.00147600f, 
    -0.02791784f, 0.05045791f, -0.08460761f, 0.10435127f, 0.00391546f, 0.05142962f, 0.29355755f, -0.14668748f, 
    0.06748417f, 0.19035751f, -0.15931156f, 0.15461856f, -0.01450335f, -0.15924156f, 0.11019387f, -0.04686017f, 
    -0.18301824f, -0.06079447f, -0.07056680f, 0.00148200f, -0.03350770f, -0.05199339f, -0.07006422f, -0.05352886f, 
    0.11031564f, 0.02684805f, 0.03608432f, -0.03095313f, -0.22253476f, -0.25350368f, 0.26208591f, 0.16423489f, 
    -0.10174447f, -0.02994509f, 0.16387373f, 0.00496627f, -0.02113782f, 0.03645391f, -0.00505634f, 0.00086726f, 
    -0.00046282f, 0.00141252f, 0.00214616f, -0.04446932f, -0.02125483f, -0.01311525f, 0.01695299f, -0.02744420f, 
    0.01863226f, 0.02129744f, 0.00170232f, -0.00960819f, 0.01551522f, -0.02064496f, 0.03388316f, 0.01517397f, 
    0.03418184f, -0.03403693f, -0.02685171f, -0.01603883f, -0.03192073f, -0.02129911f, 0.03474077f, -0.01401758f, 
    -0.00762388f, -0.02592986f, 0.01539752f, -0.01740071f, 0.00920817f, -0.04057418f, -0.02452058f, -0.03872627f, 
    -0.03237361f, -0.03056593f, 0.01018196f, 0.03274859f, 0.00719803f, -0.03883632f, -0.01369828f, -0.01639334f, 
    -0.00549740f, 0.01223742f, 0.00852350f, -0.04281108f, 0.01603988f, -0.02121990f, -0.01608456f, -0.02408184f, 
    -0.01131411f, -0.01184230f, -0.04117270f, -0.00923509f, -0.03587424f, 0.00014165f, -0.03300787f, -0.00825750f, 
    -0.01688633f, -0.02516851f, -0.03318162f, 0.00300855f, -0.03272991f, 0.03084550f, -0.01371768f, 0.00021622f, 
    -0.01174685f, 0.01906396f, -0.00502728f, -0.00428666f, 0.03016131f, 0.00688897f, 0.01271136f, 0.01281557f, 
    0.02306929f, 0.00007812f, -0.02673203f, -0.02104973f, 0.02726724f, -0.00214953f, -0.01540868f, 0.01284263f, 
    0.00506319f, 0.02601700f, -0.01530008f, -0.02614998f, -0.00107053f, 0.01748740f, -0.00544772f, 0.01973589f, 
    0.02996724f, 0.01130864f, 0.02226867f, 0.00195512f, -0.00965891f, -0.01674875f, 0.00548834f, -0.01324042f, 
    -0.03904603f, -0.01216017f, -0.04187715f, -0.03476086f, -0.04141892f, -0.03681403f, -0.03479505f, -0.00783756f, 
    -0.01191653f, 0.01038066f, -0.02688905f, -0.00850037f, -0.00221990f, 0.00791326f, 0.00689722f, 0.02670828f, 
    0.01101304f, 0.02570226f, 0.01262657f, -0.01073215f, 0.00479468f, -0.00713555f, 0.01350023f, -0.00854254f, 
    -0.01517998f, -0.03277678f, 0.02565481f, 0.02191818f, -0.00734392f, -0.03397316f, -0.01784390f, -0.02551684f, 
    0.00983017f, 0.00399938f, -0.00830296f, -0.00794442f, -0.00882199f, 0.02550058f, -0.03627334f, -0.02983764f, 
    0.00108672f, 0.02116326f, -0.02786298f, -0.04164313f, 0.02257151f, 0.01935106f, -0.00583015f, 0.01927878f, 
    -0.04543256f, -0.00865016f, -0.00472349f, -0.04361406f, 0.01087482f, -0.03984945f, -0.01503937f, -0.04256608f, 
    -0.01638408f, 0.01912662f, -0.01771543f, 0.00013086f, 0.01150916f, -0.04373265f, -0.04379613f, 0.00363383f, 
    0.01674202f, -0.01551892f, -0.00136187f, -0.02750875f, 0.02515874f, -0.02430839f, 0.01089039f, 0.01457824f, 
    -0.01064453f, -0.02915738f, 0.01560849f, -0.00879006f, 0.00744965f, -0.01076906f, -0.00587726f, -0.02631573f, 
    0.01405930f, -0.03387712f, -0.02160969f, 0.00869572f, -0.01819829f, -0.02414413f, -0.01851825f, -0.02275379f, 
    -0.01060989f, 0.02478151f, -0.00588580f, -0.04455109f, -0.00885995f, -0.00725510f, 0.00628245f, -0.03632040f, 
    0.01702479f, -0.00652426f, 0.02383625f, 0.02123139f, 0.01993275f, 0.00688361f, 0.02977658f, -0.02315707f, 
    -0.03194810f, 0.01043679f, 0.02510646f, -0.00154186f, -0.01549885f, 0.01852619f, -0.03251040f, 0.00556545f, 
    0.02262514f, -0.00750990f, 0.02036865f, -0.04183718f, -0.00540448f, -0.00129951f, 0.02038162f, 0.01332334f, 
    0.01384836f, 0.00228176f, -0.01852928f, 0.02746649f, -0.03429366f, -0.02056637f, -0.01106455f, -0.02714883f, 
    0.01328310f, 0.00408550f, 0.02244684f, 0.00999125f, 0.02364874f, 0.01459952f, 0.01350727f, 0.02687182f, 
    0.01861582f, -0.01691905f, -0.01591365f, 0.02795199f, -0.02427684f, 0.02913262f, 0.02396632f, -0.03379934f, 
    -0.01148870f, 0.00595400f, 0.02190611f, 0.03063023f, 0.02367845f, -0.03203301f, 0.00325931f, -0.01350556f, 
    0.00689830f, 0.02242637f, -0.02335360f, -0.01436992f, -0.02161654f, 0.01001939f, 0.02174655f, -0.00727342f, 
    0.00857757f, 0.01978387f, -0.02150390f, -0.00998346f, -0.00001359f, 0.03210624f, 0.00789876f, 0.00150440f, 
    -0.02763170f, 0.01133827f, -0.03570170f, -0.01585347f, 0.02663785f, -0.01711212f, -0.01512652f, 0.00172128f, 
    0.02701039f, 0.02747695f, -0.02811533f, -0.00897125f, -0.03419307f, 0.00917490f, 0.00932760f, 0.01854216f, 
    0.01139667f, -0.02170929f, 0.02243813f, 0.01922108f, 0.03482835f, 0.02129916f, 0.01965854f, 0.01050892f, 
    -0.00575245f, -0.01011067f, -0.01235102f, -0.02248588f, 0.02807554f, -0.03434038f, -0.00619999f, -0.00903121f, 
    -0.03153826f, -0.01753991f, 0.01628018f, -0.01282565f, -0.04292646f, -0.01096353f, -0.00833394f, 0.00294737f, 
    0.02175661f, -0.03077612f, 0.02388731f, -0.02489718f, -0.02107114f, -0.04047907f, 0.00434217f, -0.01029111f, 
    0.01997584f, -0.03615497f, -0.03906750f, 0.00389241f, -0.02725080f, 0.02384551f, 0.02706538f, -0.00885834f, 
    0.01740920f, -0.04020347f, 0.00008713f, 0.01510717f, 0.01814224f, -0.03806982f, -0.03066530f, -0.02112396f, 
    0.01354886f, 0.00454890f, -0.00089817f, -0.02873714f, -0.00314266f, 0.00774147f, -0.00079251f, 0.02551269f, 
    0.02652860f, 0.01680684f, 0.01277484f, -0.02336042f, -0.00466233f, -0.01700671f, 0.02662891f, 0.00370723f, 
    -0.02279533f, 0.01941909f, -0.01660406f, -0.02621418f, -0.01467812f, 0.00548941f, -0.00314505f, 0.02282738f, 
    0.02238691f, 0.00182902f, -0.01442967f, -0.02611268f, 0.02640740f, 0.02900217f, -0.03222116f, -0.03528071f, 
    -0.01310708f, 0.01602441f, 0.01227670f, 0.03349096f, -0.00954675f, 0.01160929f, -0.04143209f, 0.03100092f, 
    -0.01505308f, 0.02841750f, 0.00427656f, 0.00573825f, 0.01168558f, 0.00358130f, 0.00360417f, -0.00699223f, 
    0.00063304f, 0.00481437f, 0.01318023f, 0.00446946f, -0.02511459f, 0.00883409f, -0.02148016f, -0.01485866f, 
    0.02641650f, 0.00213657f, 0.02183537f, -0.04310408f, -0.03390431f, -0.00361619f, -0.00405021f, 0.00280186f, 
    -0.00004175f, 0.01287534f, -0.00889895f, 0.00244829f, -0.01259706f, 0.00605937f, 0.02464387f, -0.02337666f, 
    0.00689639f, -0.02075667f, -0.03685278f, -0.00705910f, -0.01103908f, -0.02858075f, 0.00913662f, 0.01667586f, 
    0.02563073f, -0.03453481f, 0.02686850f, 0.01599711f, 0.02731404f, -0.02501249f, 0.00923035f, -0.01807450f, 
    0.02016122f, -0.00888688f, -0.01733278f, 0.00057948f, 0.00163805f, -0.00154139f, 0.03677991f, 0.02302376f, 
    0.01833124f, -0.00330000f, -0.04030690f, 0.00520587f, -0.01362644f, -0.00425303f, -0.01822820f, -0.00236207f, 
    -0.04407199f, 0.01399133f, 0.02546070f, -0.04177679f, -0.02213277f, 0.01759277f, -0.01582628f, -0.00222741f, 
    0.01756728f, -0.03402220f, -0.04215990f, 0.03538822f, -0.03908453f, 0.01798717f, -0.00648076f, 0.00873888f, 
    -0.01069252f, 0.00823823f, 0.03066391f, -0.03679621f, -0.00717555f, -0.01176084f, -0.02309881f, 0.02074170f, 
    -0.04280421f, -0.00922479f, 0.01893957f, -0.02744756f, -0.04193996f, -0.03535235f, -0.03318456f, -0.01111283f, 
    0.00820385f, -0.00469839f, -0.01598464f, 0.02188444f, -0.02876188f, -0.03980887f, 0.02735194f, 0.01233592f, 
    -0.04218801f, -0.03276239f, 0.00016344f, 0.01193140f, -0.02317995f, 0.02466553f, -0.04022745f, -0.03513204f, 
    -0.02925649f, 0.00165476f, -0.00557322f, -0.00218912f, -0.02313564f, 0.01698232f, 0.01768264f, -0.03409855f, 
    -0.02468333f, -0.03800302f, -0.04311814f, -0.04286156f, 0.02854543f, 0.02197596f, -0.00287455f, -0.01595181f, 
    -0.04019000f, -0.03057658f, -0.02798133f, 0.00605651f, -0.02489468f, 0.00371364f, -0.01677257f, -0.01627872f, 
    -0.03450469f, 0.01077980f, -0.03563733f, -0.02964261f, 0.00915474f, 0.01741112f, 0.01816156f, 0.02105307f, 
    0.01655243f, -0.00496666f, -0.02445947f, -0.04125714f, -0.02940200f, 0.02450456f, -0.03330463f, -0.02791321f, 
    0.00960305f, -0.01444328f, 0.02726585f, -0.01638382f, 0.01232935f, -0.02277691f, -0.02009803f, 0.01131130f, 
    -0.03565724f, 0.00749050f, 0.01445175f, -0.02646927f, 0.01902745f, 0.02488790f, 0.02469380f, -0.01963855f, 
    0.00171434f, 0.00984187f, 0.00348089f, -0.02759355f, 0.00854217f, -0.01166680f, 0.01679150f, 0.01168139f, 
    0.02838067f, 0.02112450f, -0.03304138f, -0.00558462f, 0.02929878f, -0.03821637f, -0.03658163f, 0.01248343f, 
    0.00224498f, -0.00921746f, -0.01261767f, -0.01855406f, 0.01809211f, -0.00330013f, -0.00278609f, 0.02210370f, 
    -0.01569348f, 0.01366389f, 0.02934089f, -0.01608035f, 0.00501548f, -0.03499360f, -0.03854726f, -0.00803302f, 
    0.00844318f, -0.01811864f, -0.01442854f, -0.00900891f, -0.03639122f, 0.01137265f, -0.00603024f, 0.01863423f, 
    -0.02299277f, -0.03468614f, -0.03613625f, -0.00817220f, 0.01071464f, -0.03210878f, -0.04068792f, -0.03213369f, 
    0.02407083f, -0.03930784f, -0.02280151f, -0.03804095f, 0.03106385f, -0.03531244f, 0.00839469f, -0.02029724f, 
    -0.01416935f, -0.01172361f, 0.00344271f, -0.00623797f, 0.01508069f, -0.00364919f, -0.03107155f, -0.02852098f, 
    -0.04250092f, -0.00376622f, -0.03524347f, -0.01180103f, 0.01327081f, 0.01546657f, -0.02592048f, -0.00173669f, 
    -0.03221096f, -0.02388325f, -0.01159520f, 0.02720236f, -0.02678176f, -0.01567251f, 0.00568264f, 0.03662739f, 
    -0.03259913f, 0.01776686f, 0.03541038f, 0.01312220f, 0.02413784f, 0.03825377f, -0.00955970f, -0.00369026f, 
    -0.00131588f, -0.03110119f, -0.02463534f, -0.04320711f, 0.00163153f, 0.00680468f, -0.00392371f, 0.00932192f, 
    -0.02922427f, 0.03622575f, 0.00818997f, -0.03013106f, 0.00201269f, -0.00590638f, 0.01970161f, -0.03233172f, 
    -0.02272983f, -0.03432385f, 0.01201285f, -0.02004594f, -0.01042753f, -0.04195512f, 0.01680226f, -0.03181809f, 
    0.01793685f, -0.00594698f, 0.00124967f, -0.02753382f, -0.01668814f, -0.01456063f, 0.00425161f, 0.02582041f, 
    0.00311838f, -0.03538302f, -0.03047370f, 0.01483911f, 0.00758555f, 0.00732744f, 0.00894069f, 0.01428488f, 
    -0.00845914f, -0.01587484f, 0.01370287f, -0.03070148f, -0.04058194f, -0.04472689f, 0.01077517f, -0.02745390f, 
    0.01906249f, -0.03779642f, -0.00042942f, -0.03395076f, -0.03993670f, -0.03893883f, 0.01993008f, -0.01101633f, 
    0.00600609f, 0.00295816f, -0.03011549f, 0.02313381f, -0.02180890f, -0.01568923f, 0.03450006f, -0.00943028f, 
    -0.02414286f, 0.02921913f, -0.01414416f, -0.03530368f, -0.02321004f, -0.00074805f, -0.01060468f, -0.02911221f, 
    -0.02473543f, 0.00920720f, -0.02070876f, -0.01204365f, -0.03743210f, -0.04006093f, -0.04006606f, -0.00411133f, 
    0.01881975f, -0.00519044f, -0.02481202f, 0.03415963f, -0.01050806f, -0.02779884f, 0.02206385f, -0.00518497f, 
    -0.00945228f, -0.02952631f, -0.03992126f, -0.03851406f, -0.00949540f, -0.01599136f, 0.00565844f, 0.01145366f, 
    -0.02018899f, -0.03279560f, 0.02261329f, -0.00739531f, -0.03119221f, -0.03947878f, -0.01467186f, -0.00290534f, 
    -0.02437764f, 0.00935025f, -0.00509796f, -0.01492662f, -0.03566243f, 0.00906975f, -0.01029183f, -0.00209892f, 
    0.02626487f, -0.00138070f, -0.01081683f, -0.02980324f, -0.02893975f, 0.02836698f, 0.01402150f, 0.02651176f, 
    0.01426686f, -0.01586945f, 0.00144190f, -0.01411617f, -0.01174974f, -0.01300210f, 0.02632159f, 0.00636820f, 
    0.00726208f, -0.02211709f, 0.01905226f, 0.01495002f, 0.00374330f, -0.02954049f, 0.02036548f, -0.00464703f, 
    -0.00205241f, 0.02820823f, -0.02722964f, 0.00772108f, -0.00617968f, 0.00090522f, 0.02071796f, -0.03545360f, 
    -0.03906730f, 0.02085529f, -0.01416646f, -0.01304683f, -0.03369837f, 0.00764611f, -0.00315213f, 0.02998576f, 
    -0.00315211f, -0.03472085f, -0.00603945f, -0.01274792f, 0.00965925f, 0.01965314f, -0.01615310f, -0.01032910f, 
    -0.01225200f, -0.01971661f, -0.03270374f, 0.01730926f, -0.03001359f, -0.02077318f, 0.00557699f, -0.00390550f, 
    -0.02812594f, -0.03379473f, -0.00595580f, -0.03427938f, 0.02013294f, 0.00490394f, -0.02425726f, -0.02461715f, 
    -0.00840074f, 0.00889193f, 0.00142457f, 0.00091209f, -0.02642089f, 0.02348264f, -0.00620121f, -0.00228259f, 
    -0.00744308f, -0.01313821f, -0.03311717f, 0.00015093f, -0.02229644f, -0.00906211f, -0.01512265f, -0.02644727f, 
    0.01651389f, -0.00605925f, -0.02700595f, -0.00828024f, -0.03569340f, 0.02690391f, -0.02585666f, 0.02641829f, 
    -0.00617893f, 0.01367951f, 0.03020665f, 0.01995652f, 0.01351818f, -0.01961659f, -0.03166785f, -0.02687545f, 
    -0.01131000f, 0.00972313f, 0.01096344f, -0.00417492f, 0.01527842f, 0.02942205f, 0.01194550f, 0.02364530f, 
    -0.02734066f, -0.03067759f, -0.03815512f, -0.02732926f, -0.02803303f, 0.00161371f, 0.02742047f, 0.01215100f, 
    -0.03378469f, -0.03243317f, 0.01821902f, -0.01863189f, 0.02914834f, 0.03077891f, -0.03672964f, 0.01214754f, 
    0.01480552f, -0.03434585f, -0.02353759f, 0.01191779f, -0.02181185f, -0.00607625f, 0.00211037f, -0.00074727f, 
    -0.02668564f, 0.02952271f, 0.00553706f, 0.01900985f, -0.03131302f, 0.00888406f, -0.01482181f, 0.00118678f, 
    0.00817468f, 0.02699253f, -0.02307522f, -0.00133749f, -0.03706719f, -0.02711414f, 0.00033537f, 0.02054804f, 
    -0.03926807f, 0.02702208f, 0.00066800f, -0.02217120f, -0.00755231f, 0.01858331f, -0.03552597f, -0.02919015f, 
    -0.02683696f, -0.03617634f, 0.01998862f, -0.03353653f, 0.00374481f, -0.02294666f, 0.01421295f, -0.03190389f, 
    -0.02291825f, -0.03636460f, -0.03290054f, 0.01368640f, -0.03926783f, -0.02757221f, 0.00000921f, -0.00165667f, 
    0.02367874f, -0.00751288f, 0.00016004f, -0.01911121f, -0.01135063f, 0.02115915f, 0.02883514f, -0.00255614f, 
    -0.03508176f, 0.01734941f, 0.00479996f, 0.02801183f, 0.00980882f, -0.01737281f, 0.00668280f, 0.01558417f, 
    -0.02583109f, -0.04052923f, 0.00086069f, -0.01124683f, -0.02404555f, -0.00527642f, -0.02371588f, -0.01300514f, 
    -0.00187540f, -0.00630567f, -0.01243084f, -0.03252035f, -0.01761241f, -0.00563103f, -0.01775429f, 0.02654014f, 
    -0.00481266f, 0.01784919f, 0.03009505f, -0.01435383f, -0.02819157f, -0.00643844f, -0.00795843f, -0.03276024f, 
    0.02639386f, 0.01302717f, -0.01572070f, 0.00713923f, -0.03114993f, 0.02427485f, -0.03113878f, 0.00698279f, 
    0.02428411f, -0.03830453f, 0.02983683f, 0.02468880f, -0.00557422f, -0.03784000f, 0.02961183f, 0.02223110f, 
    -0.00298243f, -0.02937085f, -0.03428948f, -0.02705360f, -0.02441499f, -0.00690656f, -0.00193759f, -0.02374441f, 
    -0.02204134f, 0.00523643f, 0.00061600f, 0.00696423f, -0.03142920f, -0.03938828f, -0.01758033f, 0.00071087f, 
    -0.01519910f, 0.01980017f, -0.02509038f, 0.01396571f, 0.00591611f, -0.02143408f, -0.00167829f, -0.02745357f, 
    0.02170632f, -0.01160429f, 0.01008514f, -0.00016384f, -0.02694509f, 0.00667752f, 0.02550985f, -0.02715298f, 
    0.01221529f, -0.01637538f, 0.03372988f, 0.00526340f, -0.03872273f, -0.01202814f, -0.01665404f, 0.00370112f, 
    -0.02394819f, -0.04017478f, -0.03954225f, -0.01174563f, -0.04085831f, -0.02888364f, 0.01565875f, -0.01555694f, 
    -0.03845679f, 0.00644020f, -0.03084520f, -0.02865052f, -0.03338886f, -0.03421664f, 0.03004522f, -0.03802320f, 
    -0.02358182f, -0.02960204f, -0.02319458f, -0.00101321f, -0.01839460f, 0.01039407f, 0.00684777f, 0.01778087f, 
    0.02989115f, 0.00661226f, 0.02372672f, 0.00795390f, -0.01223790f, 0.01878118f, -0.00578591f, -0.00459867f, 
    -0.02773688f, 0.00384174f, 0.03379532f, 0.02379743f, -0.03565709f, -0.00853809f, -0.03031476f, 0.01578057f, 
    -0.00635839f, -0.02967558f, -0.03356052f, -0.02559935f, 0.00352647f, 0.02021478f, -0.03687787f, -0.02517145f, 
    -0.02387150f, -0.00057643f, 0.01372273f, -0.04091302f, -0.03954777f, -0.00283101f, 0.00196451f, 0.00823639f, 
    -0.00427155f, -0.03152907f, 0.02802156f, 0.02756806f, -0.01220569f, -0.01779026f, 0.02638028f, -0.03880038f, 
    -0.00336046f, 0.02900397f, 0.02660506f, 0.00921609f, 0.02952962f, 0.01786328f, -0.01707246f, 0.02494328f, 
    0.00845181f, -0.00880119f, -0.00517025f, -0.03931420f, -0.02526441f, -0.01393300f, -0.01930940f, -0.03825701f, 
    -0.02265077f, 0.00435613f, 0.00927687f, -0.00566849f, -0.03294521f, -0.03037645f, -0.03216086f, -0.02709244f, 
    -0.02068908f, -0.03541381f, -0.01978944f, 0.02774979f, -0.02236221f, 0.01322040f, 0.01433955f, 0.01129115f, 
    -0.02836907f, -0.01036050f, -0.02356834f, -0.00551120f, -0.03911914f, -0.03864832f, 0.01616755f, -0.02352745f, 
    0.00021250f, 0.00416899f, -0.00160449f, -0.00829942f, 0.01137723f, 0.00008355f, -0.04027536f, -0.03476835f, 
    -0.03952552f, -0.02766309f, -0.00689750f, -0.00186524f, -0.02041234f, 0.01662735f, -0.01223980f, -0.03943100f, 
    0.00448750f, -0.00126255f, -0.01443287f, 0.02667139f, 0.00745357f, -0.03539640f, 0.00227430f, -0.01754305f, 
    -0.02210646f, 0.02089849f, 0.03033648f, -0.00348794f, 0.02364372f, 0.01128813f, -0.02934233f, 0.01875694f, 
    -0.01041644f, -0.03053608f, -0.00933496f, -0.01970953f, -0.02230916f, 0.02543413f, 0.02434973f, 0.02284005f, 
    -0.03924687f, 0.01563489f, -0.03151353f, -0.01043808f, -0.01919996f, -0.02587653f, 0.00794749f, -0.01767593f, 
    -0.03221983f, -0.03222131f, -0.01608712f, 0.02891701f, -0.03214893f, -0.00393283f, -0.00705144f, -0.00178210f, 
    -0.02304651f, 0.02498515f, 0.00112532f, 0.01927316f, -0.03534613f, 0.02101729f, -0.04096248f, 0.01083614f, 
    0.03008095f, -0.02196727f, -0.01991840f, 0.02667838f, -0.02934308f, 0.02281612f, 0.00148736f, -0.01662909f, 
    -0.00590105f, 0.00813275f, -0.01377380f, 0.00389616f, 0.00718931f, -0.02623837f, 0.00145359f, -0.03627099f, 
    -0.01157362f, 0.01710383f, 0.02854523f, -0.01727940f, -0.03534223f, -0.02609672f, 0.02682517f, -0.01893320f, 
    0.01483464f, -0.00220754f, -0.02242708f, -0.02971916f, -0.00855688f, -0.01936043f, -0.02547791f, -0.01825171f, 
    -0.00350158f, -0.01847493f, 0.02625864f, -0.01124914f, -0.01843793f, -0.01292818f, -0.02825383f, -0.03978075f, 
    0.01634115f, 0.00426067f, 0.00403932f, 0.02109556f, -0.01246365f, 0.02789665f, 0.02543348f, 0.00256166f, 
    0.01640372f, 0.02374467f, -0.02001818f, 0.01682957f, 0.00792413f, -0.04000340f, 0.00342492f, -0.01078628f, 
    -0.01880158f, -0.02206756f, 0.00670605f, 0.00536351f, 0.00601314f, 0.00635861f, -0.03862670f, -0.01872800f, 
    0.00148842f, 0.01896102f, -0.01162569f, -0.03878002f, -0.00674169f, 0.03275112f, 0.00839538f, -0.02101911f, 
    0.03059719f, -0.00498624f, -0.03893410f, 0.02114776f, -0.00239771f, -0.03199754f, 0.01656386f, -0.03945563f, 
    -0.02393427f, 0.01872252f, -0.02563554f, 0.02244151f, 0.00739145f, 0.02874068f, -0.02949243f, 0.02304151f, 
    0.00526099f, 0.00396606f, -0.03155080f, 0.00989516f, 0.00701604f, -0.00856498f, -0.02463235f, -0.03796719f, 
    -0.02101570f, -0.03328574f, 0.02195230f, -0.01836851f, -0.00655042f, 0.01408892f, 0.00872800f, 0.01645726f, 
    0.02191344f, -0.01172231f, -0.03180913f, 0.02144594f, 0.02453152f, 0.02790063f, -0.04019903f, -0.02127978f, 
    -0.04038662f, -0.03435456f, 0.01747211f, -0.01961888f, -0.00952491f, 0.01720875f, -0.00686728f, -0.03803641f, 
    -0.00168489f, -0.02138312f, 0.00190195f, 0.02833116f, -0.02453538f, -0.02305224f, -0.00680112f, -0.02928247f, 
    0.01279241f, 0.00854526f, -0.03042865f, -0.01840481f, 0.00679506f, -0.02825635f, 0.00606472f, 0.01873110f, 
    -0.01668163f, 0.00107911f, -0.02768460f, -0.03673899f, -0.01649997f, -0.03599705f, -0.03093378f, -0.02789882f, 
    -0.01366548f, -0.03511412f, 0.02085594f, -0.01185507f, -0.04051071f, -0.01486344f, -0.04080435f, -0.00954340f, 
    -0.02291550f, -0.01414672f, -0.00780525f, -0.02996044f, 0.00732907f, -0.03756907f, 0.00855042f, 0.01798550f, 
    -0.03546826f, 0.00674235f, -0.03324292f, -0.03741988f, -0.00523640f, -0.03576626f, 0.00369530f, 0.02281582f, 
    0.02510118f, -0.00524883f, -0.00425608f, 0.02858556f, 0.00974097f, -0.02151249f, 0.01241930f, -0.02731371f, 
    -0.03926484f, 0.01347685f, -0.01948272f, -0.03593099f, -0.03681706f, -0.01823686f, -0.01152845f, 0.01831981f, 
    -0.01751555f, 0.01931148f, 0.00608433f, -0.02876299f, 0.00806017f, 0.02665010f, -0.02102478f, 0.01049363f, 
    0.02264641f, -0.00713076f, -0.00490494f, -0.03451958f, -0.03555608f, -0.00821266f, -0.03722245f, 0.01714538f, 
    -0.01815620f, -0.03549257f, -0.03105263f, 0.02658814f, -0.01103438f, 0.00689794f, 0.00891753f, 0.01654867f, 
    0.01467257f, -0.02925400f, 0.00831453f, -0.03640998f, 0.02988672f, -0.03415122f, 0.02783643f, 0.01649964f, 
    0.01561264f, -0.00377282f, -0.01556010f, -0.03271737f, -0.01897751f, -0.02588257f, 0.00164087f, 0.01064138f, 
    -0.03844921f, -0.01003891f, -0.00429163f, -0.01428617f, -0.02078692f, 0.02810933f, -0.00748332f, -0.02249315f, 
    0.00351700f, 0.00324711f, 0.00172050f, -0.01154479f, 0.02459457f, -0.02330391f, -0.03100753f, -0.00576806f, 
    -0.03230276f, 0.01866579f, 0.02477000f, 0.01606602f, 0.02365134f, -0.02086693f, 0.03078773f, -0.03791585f, 
    -0.00412912f, -0.00570754f, 0.02518484f, -0.01129176f, -0.00990898f, -0.00391649f, -0.03401635f, -0.03163086f, 
    0.02516143f, -0.03144563f, -0.03966343f, -0.03520095f, 0.02771006f, -0.03531345f, 0.02247281f, 0.00483314f, 
    0.01396202f, -0.03651175f, 0.02280196f, -0.01873710f, -0.04047248f, 0.01788996f, -0.04048071f, -0.02772242f, 
    0.00635649f, 0.01418070f, -0.01060628f, -0.02693561f, -0.02755334f, -0.01150858f, -0.02375077f, 0.01542337f, 
    -0.02557196f, -0.02028584f, -0.03182331f, -0.02698378f, 0.01132874f, -0.01874031f, 0.02919518f, 0.02081848f, 
    -0.03447947f, -0.03163080f, 0.01247815f, 0.00621705f, 0.00003735f, -0.00393949f, -0.03862087f, -0.00491201f, 
    -0.00342946f, -0.01927948f, -0.00505455f, 0.01196112f, -0.00568106f, 0.02419061f, 0.01461446f, -0.03519638f, 
    0.01904941f, 0.02581043f, -0.00724917f, 0.01586380f, 0.01636687f, 0.00304645f, -0.00103498f, -0.02125033f, 
    -0.00354442f, 0.03402246f, 0.00767221f, -0.03948428f, 0.00554352f, -0.01274971f, 0.00106462f, 0.02688361f, 
    -0.01322506f, -0.00473297f, 0.03166104f, 0.00024349f, 0.02767427f, -0.00251866f, -0.00057986f, -0.01626532f, 
    -0.02318885f, -0.00776536f, -0.00649499f, -0.00673732f, -0.00246027f, 0.00271477f, 0.02205634f, -0.01717358f, 
    -0.02467772f, 0.01408185f, -0.03689304f, 0.00639511f, 0.01972749f, -0.01077342f, 0.01574556f, 0.00645209f, 
    -0.01904328f, -0.02950269f, -0.02272022f, 0.01648086f, 0.01571393f, 0.02830177f, -0.00955750f, 0.02440349f, 
    -0.02483261f, -0.02751010f, -0.03641310f, -0.01413678f, -0.02707520f, 0.01389289f, 0.02232077f, -0.01941399f, 
    -0.00619382f, 0.01721286f, 0.00446115f, -0.02733503f, -0.00087310f, -0.00431384f, 0.02182340f, -0.01065431f, 
    -0.12995893f, -0.19508721f, 0.06440023f, 0.07509369f, 0.00240319f, -0.00927556f, 0.08466898f, 0.09767244f, 
    0.01292570f, -0.02829309f, -0.01161384f, -0.16850774f, -0.06778872f, -0.09020383f, 0.03720178f, 0.09596978f, 
    0.01925352f, 0.02359746f, 0.00777447f, 0.03256156f, 0.11643416f, 0.03550276f, 0.16401553f, 0.20499061f, 
    0.05090943f, -0.16615716f, -0.21186157f, 0.43792078f, -0.02235362f, 0.04917170f, 0.21382320f, -0.10625307f, 
    0.07188381f, 0.13326608f, -0.04909747f, -0.09980296f, -0.02780375f, 0.02151122f, 0.18155423f, 0.05434927f, 
    0.18459328f, 0.05442903f, -0.07085679f, 0.05841064f, 0.02898261f, 0.02106509f, 0.03001647f, 0.07721775f, 
    -0.23992746f, -0.07599299f, 0.08577459f, 0.07401597f, -0.01422666f, 0.05361667f, -0.20811954f, -0.03326174f, 
    0.18781982f, 0.01924797f, 0.05263858f, 0.09864575f, -0.21141861f, -0.05418891f, 0.14387351f, 0.06710573f, 
    -0.06025080f, -0.08750840f, 0.02764864f, 0.05309222f, 0.02173276f, 0.04590372f, -0.01251523f, -0.05768070f, 
    0.18336903f, -0.08549123f, -0.19647132f, 0.00127531f, 0.01473421f, 0.12039360f, 0.10487131f, -0.08746149f, 
    0.08140608f, -0.08874419f, -0.12936291f, -0.09104377f, -0.11559421f, -0.01620435f, 0.16669352f, 0.13248076f, 
    0.06619351f, -0.06553078f, 0.06957599f, -0.07823031f, 0.11053954f, 0.14950709f, 0.07921858f, 0.28988081f, 
    0.14411424f, -0.04671128f, -0.17688128f, -0.04236504f, 0.06874250f, -0.06506000f, -0.08132616f, 0.02465686f, 
    -0.13312025f, -0.22426155f, 0.03048011f, -0.18853627f, 0.04596866f, 0.03312188f, -0.11636046f, 0.13187528f, 
    0.04542708f, 0.11799325f, 0.14081882f, -0.01055593f, 0.04229126f, 0.07630511f, -0.05070610f, 0.05504707f, 
    0.04902994f, -0.12950777f, -0.03087428f, -0.10543166f, 0.09496844f, 0.12826459f, -0.03276028f, 0.06559275f, 
    0.06298257f, 0.11592829f, 0.16462944f, 0.23464216f, -0.07649188f, -0.11574097f, -0.08308714f, -0.26483616f, 
    0.05048049f, -0.02858111f, -0.02395531f, -0.13094890f, 0.08195030f, 0.33909953f, 0.18424328f, 0.18425538f, 
    0.01988227f, 0.04801756f, -0.00864417f, 0.04955941f, 0.17432144f, 0.01665193f, -0.21302688f, -0.04614784f, 
    -0.02829748f, 0.12223946f, 0.04053788f, -0.15509756f, 0.18634699f, 0.23620227f, -0.08368908f, -0.12801880f, 
    0.08540633f, 0.09567186f, 0.00443691f, -0.12935062f, 0.00149928f, -0.13383788f, 0.06837091f, -0.17102420f, 
    0.05341992f, 0.24714971f, 0.05177908f, 0.19324364f, -0.09928429f, -0.06755765f, -0.00405675f, 0.01508670f, 
    0.10230072f, 0.07197117f, 0.04374385f, 0.05379777f, 0.22762193f, 0.01191175f, 0.08723926f, -0.08350476f, 
    0.12523988f, 0.11113544f, 0.05442401f, 0.00061931f, 0.05624667f, -0.05958308f, -0.10934830f, -0.10823613f, 
    0.16056882f, 0.19456382f, 0.01894818f, 0.03803455f, -0.02803836f, -0.11953478f, -0.00345409f, -0.04250909f, 
    0.24424455f, 0.08226575f, 0.22386871f, 0.28562090f, -0.09996795f, 0.03869990f, 0.16437300f, 0.29243484f, 
    0.12239984f, 0.20996875f, -0.02507696f, -0.12014454f, -0.08223279f, -0.18264109f, -0.12426248f, -0.00195626f, 
    0.13346685f, -0.18118821f, 0.07089122f, -0.01917998f, 0.10405279f, -0.01868221f, 0.01278286f, 0.06305168f, 
    -0.26102960f, -0.23628919f, -0.15086827f, -0.24841082f, 0.20132746f, 0.22062448f, 0.29534346f, -0.03402895f, 
    -0.02942273f, -0.11808472f, -0.07578219f, 0.01099642f, -0.11650250f, -0.09367551f, -0.14160825f, -0.10811613f, 
    0.28949401f, -0.37412897f, -0.25536138f, 0.06063180f, -0.01027572f, 0.10973812f, 0.11154821f, -0.03228544f, 
    0.00739426f, 0.04937022f, 0.11037154f, 0.03595911f, -0.08571883f, -0.01795571f, 0.01185648f, 0.08936036f, 
    -0.03250530f, 0.04354811f, 0.06772777f, -0.04340718f, 0.14454924f, 0.11613082f, 0.14669432f, 0.24393700f, 
    0.01736997f, -0.03816948f, -0.16528289f, 0.03225153f, -0.00418887f, -0.01818831f, 0.03324583f, 0.03624085f, 
    0.33568645f, 0.15636753f, 0.06560864f, 0.34450921f, -0.01413215f, 0.17441741f, -0.09308852f, 0.05123174f, 
    0.07077354f, 0.10398207f, 0.12410943f, -0.03113337f, 0.07926127f, -0.14175031f, 0.00126938f, -0.08354701f, 
    0.02404413f, -0.00361109f, -0.02795250f, -0.08084601f, 0.05954463f, 0.00664986f, 0.14625829f, -0.08345439f, 
    0.21218099f, 0.13500781f, -0.02120809f, 0.15980476f, -0.05279387f, -0.31404632f, 0.16728659f, 0.03718157f, 
    -0.17807327f, -0.06456293f, -0.14793336f, 0.03290362f, -0.08436449f, 0.05717986f, 0.18636335f, 0.16392039f, 
    0.18461715f, 0.30761209f, 0.23676910f, -0.05759785f, -0.11069947f, -0.12589292f, -0.09093054f, 0.02503711f, 
    0.03202479f, -0.00780191f, 0.11578378f, 0.20878862f, -0.16386862f, -0.16821627f, -0.13771230f, -0.22094274f, 
    0.02451546f, -0.09551892f, -0.06909030f, -0.07500108f, -0.04565611f, 0.06231263f, 0.05502304f, -0.01812379f, 
    -0.02690756f, 0.08372615f, -0.04579352f, 0.15196687f, -0.10762791f, -0.00059003f, -0.00023792f, 0.00189236f, 
    0.00740700f, 0.04732943f, -0.24525455f, 0.00783638f, -0.07210493f, -0.03952235f, -0.10875431f, -0.07777353f, 
    0.04270748f, 0.11906245f, 0.16706699f, 0.13658379f, -0.10498384f, -0.17213096f, -0.29444358f, -0.24192426f, 
    0.38895264f, -0.10172024f, -0.21305479f, -0.14228961f, 0.13266365f, -0.18375008f, -0.03733614f, -0.12094086f, 
    0.02305748f, 0.04470023f, 0.11271847f, 0.03773576f, 0.06160052f, 0.12358035f, 0.26663440f, 0.17413735f, 
    -0.11878730f, -0.27181479f, -0.04769281f, -0.04191010f, -0.01818004f, 0.00577151f, -0.02763987f, -0.03833881f, 
    0.11038547f, -0.00071996f, 0.01773996f, 0.02077938f, 0.23121054f, 0.17834514f, 0.11051682f, -0.09828624f, 
    0.23648839f, 0.00902588f, 0.12753597f, 0.04904284f, 0.05738493f, -0.01389595f, 0.09035791f, 0.13284761f, 
    -0.03555776f, -0.05779142f, -0.03672179f, 0.03753184f, -0.08388982f, 0.06640441f, -0.00287250f, 0.04767966f, 
    -0.08058681f, -0.19317633f, -0.00508838f, 0.20061491f, -0.04065694f, -0.01052193f, 0.13293886f, 0.12984818f, 
    -0.04401938f, 0.08546090f, 0.17178592f, -0.01762838f, -0.04563186f, 0.01186178f, 0.18201682f, 0.12676051f, 
    -0.11793392f, -0.18842155f, -0.06690787f, -0.00337464f, 0.17303568f, 0.18093674f, 0.00444677f, -0.05364181f, 
    -0.02733273f, -0.07010105f, -0.09870406f, 0.15764374f, 0.08617349f, -0.04355236f, -0.12105089f, -0.02596935f, 
    -0.23938572f, -0.13800706f, -0.24005131f, -0.36225376f, -0.19567285f, -0.12245850f, 0.03007554f, 0.06762451f, 
    -0.01872773f, -0.00869128f, -0.05153724f, -0.08666345f, -0.00108468f, -0.03573808f, 0.05016866f, -0.05996239f, 
    -0.27559733f, 0.40797973f, 0.31637758f, 0.19774516f, -0.05613181f, 0.02703249f, 0.01973375f, 0.05427900f, 
    -0.02700922f, 0.03688313f, -0.00457174f, 0.17163962f, 0.10760230f, -0.13795327f, 0.00344083f, 0.05204991f, 
    -0.06878816f, -0.01135037f, -0.09551415f, 0.07786483f, -0.15754096f, -0.01277991f, -0.00886475f, -0.04285096f, 
    -0.08936770f, -0.10281429f, 0.14973161f, 0.17034678f, 0.00253823f, -0.07032612f, 0.08944602f, 0.01353700f, 
    0.16996373f, 0.12795101f, 0.29357949f, 0.22342576f, -0.20092458f, -0.11121593f, 0.09787628f, -0.07577592f, 
    -0.00314178f, 0.02880097f, -0.16146415f, 0.03719985f, -0.07312313f, 0.04319838f, -0.02923182f, -0.10061479f, 
    -0.03454636f, 0.02829879f, -0.05124561f, -0.08194524f, 0.01060998f, -0.00254923f, -0.07872464f, 0.06652107f, 
    0.11185882f, -0.00717461f, -0.10459171f, -0.06814858f, 0.23999342f, 0.10186387f, 0.11451778f, 0.13105075f, 
    0.03882682f, 0.13381885f, 0.17292841f, -0.04016305f, -0.03257716f, -0.13095374f, -0.00925696f, -0.03696311f, 
    -0.03809696f, 0.11870401f, 0.08540049f, -0.03422184f, 0.10498859f, 0.11632992f, 0.09058521f, 0.04379323f, 
    -0.04146223f, 0.00350311f, -0.11933885f, -0.02865868f, 0.14103243f, -0.01459524f, -0.25426701f, 0.07149501f, 
    0.07414617f, 0.13401267f, 0.05931564f, -0.04422995f, 0.15317841f, 0.05998832f, 0.13486701f, 0.16386726f, 
    -0.14690775f, -0.18760224f, 0.03065220f, 0.11224747f, -0.11870061f, -0.08724993f, -0.08161992f, -0.03904911f, 
    -0.12775826f, -0.11015104f, -0.15747403f, -0.14160447f, 0.04242100f, -0.11235871f, -0.01572680f, -0.06313413f, 
    0.06400756f, 0.07837507f, -0.14418444f, -0.04581548f, -0.17736888f, -0.25512308f, -0.06150439f, -0.22635600f, 
    0.11770104f, 0.03718694f, -0.06269840f, 0.03174688f, 0.05832940f, -0.02658041f, -0.17295398f, -0.03285947f, 
    -0.06345448f, 0.07411020f, -0.03586883f, 0.02959024f, -0.10208510f, 0.33353233f, 0.35710201f, 0.34397370f, 
    -0.08218814f, -0.29423505f, 0.02476945f, -0.11864349f, -0.12502880f, -0.08165668f, 0.01596825f, 0.09741433f, 
    0.18032068f, 0.02621096f, 0.04759171f, -0.15785009f, -0.03717352f, 0.07848518f, -0.11327371f, -0.22915503f, 
    0.00227448f, -0.13897634f, 0.02004012f, 0.01623377f, -0.06189789f, -0.05617603f, -0.01768481f, 0.15763083f, 
    -0.06214422f, -0.03325677f, 0.03098051f, 0.03795143f, -0.06901792f, -0.03028438f, 0.14108793f, 0.29406044f, 
    -0.07998674f, -0.04026178f, 0.01395078f, 0.07098804f, -0.11681154f, -0.12064052f, 0.12416556f, -0.02095777f, 
    -0.01299876f, 0.04030187f, -0.03493236f, -0.02660994f, -0.10569882f, -0.05275093f, -0.05051623f, -0.11203845f, 
    0.01787438f, -0.00810672f, -0.08993015f, 0.00653957f, 0.01459165f, -0.16187429f, 0.02696599f, -0.02676636f, 
    -0.01603962f, 0.10687605f, -0.00325983f, 0.10077318f, 0.08021202f, -0.15908675f, 0.03061113f, -0.18067886f, 
    -0.15280530f, 0.00379022f, -0.11890970f, -0.12834109f, -0.12441893f, 0.04172373f, -0.02168073f, -0.11783079f, 
    0.16773225f, 0.05322916f, 0.14915143f, -0.04831509f, -0.01248309f, 0.03527621f, 0.06108252f, 0.13082491f, 
    0.02200546f, 0.01368352f, -0.09008785f, 0.14305174f, 0.13804196f, -0.15940997f, -0.07726935f, -0.15413515f, 
    -0.15561216f, -0.05411556f, -0.06508638f, -0.10408609f, -0.12836234f, 0.04593726f, 0.07059731f, 0.04062349f, 
    0.10531979f, 0.03090227f, 0.05130130f, 0.01316024f, 0.13343056f, 0.12455648f, 0.25105718f, 0.30841839f, 
    -0.31837305f, -0.26405933f, -0.03467567f, 0.01387837f, -0.13228910f, 0.01873446f, -0.07442172f, 0.04419930f, 
    -0.00353187f, -0.00494044f, 0.01189324f, -0.01670421f, 0.09862623f, -0.15668663f, -0.11196022f, -0.04472323f, 
    0.16972786f, 0.03483387f, 0.12403714f, -0.00487975f, -0.09111878f, -0.08908208f, -0.21332696f, -0.14207391f, 
    0.02141494f, 0.26206440f, 0.00952693f, 0.02575309f, 0.13927257f, 0.05429079f, -0.01295108f, 0.11598998f, 
    -0.07164137f, 0.07312568f, 0.06113173f, 0.17634156f, 0.07991733f, -0.07859495f, 0.22591972f, 0.03511453f, 
    0.01595821f, -0.00518717f, -0.21582450f, -0.02143986f, -0.07118647f, -0.16788937f, -0.14013022f, -0.31479084f, 
    -0.10783850f, 0.06056618f, 0.14494899f, -0.16754676f, 0.01037891f, 0.04811527f, -0.08230909f, 0.06675896f, 
    0.01169613f, 0.10640883f, 0.01647726f, -0.14137706f, -0.44306532f, -0.31471759f, -0.11778837f, 0.15607691f, 
    -0.09467851f, -0.06920116f, -0.13403009f, -0.14042936f, -0.15461315f, -0.07001058f, -0.01792862f, 0.03014960f, 
    -0.03923707f, 0.01472424f, 0.01921508f, -0.04162093f, -0.01496880f, -0.00026237f, 0.01835752f, 0.00382531f, 
    0.00213158f, -0.03399530f, -0.01487429f, 0.01103105f, -0.04139927f, 0.00882077f, -0.01598433f, -0.00069770f, 
    0.02823834f, 0.02504846f, 0.01345525f, -0.01640601f, -0.00790187f, -0.00366933f, 0.02092902f, -0.00292324f, 
    -0.00823973f, 0.00143885f, 0.03963567f, -0.00743252f, -0.02923517f, -0.01173681f, 0.01643874f, -0.03926886f, 
    -0.00817628f, 0.01651518f, -0.03452657f, 0.01893528f, 0.01377575f, 0.00399827f, -0.00109580f, 0.00291461f, 
    0.02728619f, -0.00726542f, 0.01376730f, 0.02019273f, -0.02290278f, -0.02860156f, 0.00622475f, 0.02556955f, 
    0.02752679f, -0.01451289f, 0.02643968f, -0.01653824f, -0.02336068f, 0.00659149f, -0.00690723f, -0.03906900f, 
    0.02822493f, 0.01451584f, 0.00147118f, 0.00985384f, -0.03257445f, -0.01548504f, 0.00906052f, 0.00127322f, 
    -0.02462723f, -0.02295048f, 0.02677338f, -0.03291200f, -0.03106955f, 0.01149325f, -0.00567809f, 0.02805581f, 
    0.01938593f, 0.01512215f, -0.01977979f, 0.02848987f, -0.00440600f, 0.00059096f, -0.01127944f, -0.02245326f, 
    0.01865486f, 0.03577222f, -0.00001633f, 0.02768409f, -0.03790441f, 0.00068877f, -0.00220545f, 0.00028390f, 
    0.00937935f, -0.02236543f, -0.00423757f, 0.02280906f, 0.00812808f, -0.02345083f, -0.00773094f, 0.02718149f, 
    0.01595689f, -0.01772225f, -0.02521484f, 0.02074653f, 0.02889380f, -0.01632951f, 0.00934189f, 0.03073267f, 
    0.02140888f, 0.02612007f, -0.02964038f, 0.01842048f, 0.00059324f, -0.02331351f, -0.03667121f, -0.04075822f, 
    -0.03509713f, -0.02294060f, 0.00518390f, -0.03983705f, -0.01864058f, 0.02180351f, 0.02399985f, -0.00512047f, 
    -0.02978080f, -0.02565877f, -0.03143595f, -0.02541148f, -0.01018905f, -0.01274524f, -0.00650337f, -0.02462254f, 
    -0.01916415f, -0.00510960f, -0.02558416f, 0.00449509f, 0.01022175f, -0.01501133f, 0.01542874f, -0.04309896f, 
    0.01603315f, 0.00375739f, -0.01493654f, -0.03609637f, 0.00155687f, -0.03622094f, 0.02540261f, 0.02510825f, 
    -0.02340798f, -0.00910900f, 0.01631960f, 0.01706109f, -0.03065166f, -0.02599327f, -0.02409723f, 0.00455312f, 
    -0.03480279f, 0.01813620f, 0.02730969f, -0.01675232f, -0.04052620f, 0.00974455f, 0.01526541f, -0.04102835f, 
    -0.00877377f, -0.01865483f, 0.01069335f, 0.01394833f, 0.00851286f, -0.03930726f, 0.01598659f, 0.02263127f, 
    0.01971121f, 0.02352444f, -0.03522216f, 0.02686327f, -0.00791998f, -0.00814320f, 0.01652255f, 0.00444405f, 
    -0.01330458f, -0.00181788f, 0.02173654f, -0.00452591f, -0.02075752f, -0.02883370f, 0.00811221f, -0.02884741f, 
    0.01432900f, 0.00547467f, -0.01034372f, -0.01466795f, -0.00827561f, 0.01863904f, -0.02156164f, -0.02370429f, 
    -0.02058525f, -0.01389150f, -0.01073045f, -0.01991375f, 0.00717419f, -0.02363993f, 0.01153714f, -0.00654564f, 
    -0.01105302f, 0.01157082f, -0.00149137f, -0.03477750f, 0.00005061f, 0.02537595f, 0.00326108f, -0.03605326f, 
    -0.02419267f, 0.02829210f, -0.00315942f, -0.00339549f, -0.04003424f, -0.02812575f, 0.03259125f, 0.01733704f, 
    -0.01161581f, 0.03124573f, 0.02723926f, 0.00388860f, 0.01497631f, 0.02963334f, -0.00621121f, 0.02781502f, 
    -0.01860963f, 0.00137180f, -0.00864566f, 0.04078197f, 0.00305224f, -0.01049079f, -0.03305998f, -0.00511330f, 
    -0.03723330f, 0.03193578f, 0.00336839f, -0.02729000f, 0.01585425f, 0.01769013f, -0.02415003f, 0.02347450f, 
    0.00251840f, 0.02112668f, 0.00482261f, -0.03037117f, -0.00506587f, 0.00246313f, 0.00364470f, -0.00336566f, 
    0.01106830f, -0.01089147f, 0.01206347f, -0.02310851f, -0.00718452f, 0.02596147f, 0.02174839f, 0.01636257f, 
    -0.03430399f, 0.00945450f, 0.01623179f, -0.03994640f, -0.04086955f, -0.01978708f, -0.03353176f, -0.03635669f, 
    0.00758386f, -0.03677297f, 0.01110932f, -0.03836857f, 0.00220687f, -0.02970322f, -0.00319540f, 0.00366537f, 
    -0.01964677f, 0.01904557f, 0.00716502f, -0.02317049f, -0.02401348f, -0.01538630f, 0.01391789f, -0.03361669f, 
    0.01422620f, 0.02082469f, 0.01074776f, -0.00723358f, 0.00412550f, 0.00811910f, -0.01834489f, -0.00115470f, 
    -0.00601551f, -0.00822223f, 0.00611467f, 0.00724768f, 0.01746633f, -0.02131377f, -0.03898681f, -0.00978216f, 
    -0.02172601f, 0.00606599f, -0.01156257f, 0.02469447f, 0.01311005f, -0.02753556f, 0.01212953f, -0.03208630f, 
    -0.01202451f, 0.02270818f, 0.01331793f, -0.03098106f, -0.00406141f, -0.03792580f, 0.00502358f, 0.01378285f, 
    -0.02317447f, 0.01459173f, 0.00019203f, -0.00205126f, 0.00653080f, 0.00297815f, 0.01349960f, 0.01332985f, 
    -0.02496890f, 0.02165317f, 0.02585210f, -0.00050694f, -0.01386909f, -0.00215121f, -0.02987734f, 0.02010663f, 
    0.01736279f, -0.00984650f, -0.01806971f, -0.04011005f, 0.00570575f, 0.02393438f, 0.00077394f, 0.01223457f, 
    -0.03260276f, 0.01384700f, -0.00393326f, 0.02082905f, -0.02717479f, 0.03123236f, 0.00307466f, 0.01594528f, 
    -0.03564249f, 0.01610817f, -0.02869164f, -0.03408523f, -0.02244201f, 0.01893724f, -0.01925170f, 0.00062282f, 
    0.01987274f, -0.01927779f, 0.00178354f, -0.02555599f, 0.01038296f, -0.00219631f, 0.02628248f, -0.00797094f, 
    -0.00740491f, -0.00561518f, 0.04124599f, -0.03761427f, 0.03097671f, 0.00049488f, -0.01013972f, -0.04301709f, 
    0.02545524f, -0.01504576f, -0.02788771f, 0.00384623f, 0.00944333f, -0.00547416f, -0.03510197f, 0.00908083f, 
    -0.03349962f, -0.00626335f, -0.03374762f, -0.02698343f, 0.02498246f, -0.03266213f, -0.01252129f, 0.02130240f, 
    -0.01934006f, -0.02662701f, -0.01519089f, -0.02513329f, -0.03713634f, 0.02906838f, -0.03547311f, 0.01519407f, 
    -0.00154015f, -0.03101314f, -0.00169597f, -0.02417871f, -0.03059493f, -0.03097469f, 0.00266146f, -0.02235785f, 
    -0.01952217f, 0.01059855f, 0.00948516f, -0.03631964f, -0.02915479f, 0.01050627f, -0.02249951f, 0.02149697f, 
    0.02724810f, 0.00255789f, 0.00704393f, 0.01767067f, -0.00624223f, -0.00946824f, 0.00066843f, -0.02926566f, 
    -0.03956015f, -0.00348784f, -0.04251541f, -0.01200594f, -0.03046575f, -0.01784371f, -0.00267394f, -0.01370939f, 
    -0.02612486f, -0.01402486f, -0.01549645f, -0.01073700f, -0.02409909f, 0.02218288f, -0.02586357f, -0.02527293f, 
    0.00372796f, -0.03414540f, -0.01561769f, -0.00712071f, -0.01301097f, -0.04063453f, -0.01351224f, -0.04068757f, 
    -0.01874773f, -0.02373115f, -0.01553357f, -0.00624448f, 0.02862860f, -0.01041072f, -0.01466347f, 0.01978282f, 
    -0.00744592f, -0.00655177f, 0.00331572f, -0.03227177f, 0.00532439f, 0.02444614f, 0.02851741f, -0.02344365f, 
    0.00139026f, -0.01383038f, 0.02471676f, -0.02802145f, -0.01032016f, 0.00233220f, 0.01693339f, 0.02417627f, 
    0.01768078f, 0.00792694f, 0.01715641f, -0.01654775f, -0.03072803f, 0.03429598f, -0.03056178f, -0.03847407f, 
    0.01113460f, -0.04026712f, 0.00003142f, -0.03891075f, -0.00252066f, 0.01096038f, -0.01994475f, -0.02594515f, 
    0.00889799f, -0.02325060f, -0.02096069f, -0.00208429f, 0.01556898f, -0.00034306f, 0.00616341f, -0.02617671f, 
    -0.01062223f, -0.02900908f, -0.01288648f, 0.00123376f, -0.01834323f, -0.00672571f, 0.00853243f, -0.02791135f, 
    0.02870019f, -0.01965229f, 0.00683185f, -0.01673019f, -0.02551614f, 0.01905081f, -0.00183344f, -0.00407110f, 
    0.01677224f, -0.02962536f, -0.02976811f, 0.00748475f, 0.03557381f, 0.03407179f, -0.00994045f, -0.02703022f, 
    -0.04033377f, -0.02742930f, -0.03148031f, -0.00679702f, 0.02541149f, -0.04007934f, -0.01643874f, -0.02125288f, 
    0.01119768f, -0.01048159f, -0.01390210f, -0.01845118f, -0.02752130f, -0.01312119f, 0.00354750f, -0.03716491f, 
    -0.01736103f, 0.01942185f, 0.00035121f, 0.01934314f, -0.03944330f, -0.03138827f, 0.02071018f, -0.01081439f, 
    -0.04149155f, -0.01202404f, -0.03785770f, -0.04180742f, 0.00336208f, -0.02724531f, 0.00303461f, 0.00091862f, 
    -0.02294578f, 0.00878964f, 0.00118638f, 0.01630230f, -0.01906025f, 0.00331555f, -0.03546750f, 0.02849586f, 
    -0.02556310f, 0.01262979f, -0.01976057f, -0.01106898f, 0.00015141f, -0.04086236f, -0.04332459f, 0.01749616f, 
    -0.01237853f, -0.00174926f, 0.00858608f, 0.02047860f, -0.02713551f, 0.00768128f, -0.01755088f, 0.01931121f, 
    -0.03430869f, -0.04005081f, 0.02304781f, -0.03972178f, 0.01486201f, 0.01188678f, -0.01508285f, -0.03537510f, 
    0.00775409f, 0.00014416f, -0.01464912f, -0.02109603f, -0.00516594f, 0.02440325f, -0.03100514f, -0.01562945f, 
    -0.03556338f, 0.02677623f, 0.02226585f, -0.03171176f, 0.03026104f, -0.03057353f, -0.03364351f, -0.03407184f, 
    -0.02633235f, 0.00044713f, 0.00825747f, -0.02839752f, 0.02674461f, 0.01827185f, -0.03718745f, 0.00504369f, 
    0.00839652f, -0.03241785f, 0.02169682f, 0.00196201f, 0.00628693f, -0.04323217f, 0.01638153f, 0.00145884f, 
    -0.03598261f, -0.02266285f, -0.01049045f, -0.02580442f, -0.03083093f, 0.00670705f, -0.02385915f, 0.02080583f, 
    -0.02337624f, 0.01144628f, 0.01275591f, -0.02967883f, 0.02690299f, 0.02456667f, -0.02570201f, -0.01140335f, 
    0.01976921f, 0.00452191f, -0.03698964f, -0.03139004f, -0.03654059f, 0.00735514f, 0.00541536f, -0.00216977f, 
    -0.00939288f, -0.03778202f, -0.02873201f, -0.01588798f, -0.02952907f, -0.01937773f, 0.02170953f, -0.02373491f, 
    0.00398432f, -0.02123609f, 0.00801128f, -0.01452865f, -0.01977513f, 0.03790811f, 0.02080305f, 0.01208795f, 
    -0.03034556f, -0.00707580f, 0.02700921f, -0.02759814f, -0.03937663f, 0.01644143f, 0.00269459f, 0.00554801f, 
    -0.02398471f, 0.00376487f, -0.01205164f, -0.04408883f, 0.01868429f, 0.00348528f, 0.01644466f, -0.01626463f, 
    0.01457138f, -0.04156415f, -0.02626855f, -0.00396702f, -0.04052150f, -0.03635851f, -0.02523841f, 0.02853830f, 
    0.02792503f, -0.04169890f, -0.01992907f, -0.00932685f, -0.01326374f, 0.00018441f, 0.00553875f, -0.01329916f, 
    -0.02443985f, -0.01777830f, 0.00590984f, -0.01499280f, 0.02851611f, -0.03401035f, 0.02621684f, -0.02784540f, 
    0.01386095f, 0.02892713f, -0.01762823f, 0.01262276f, -0.01350785f, -0.03909611f, -0.01735178f, -0.01634637f, 
    0.00353417f, 0.01004979f, -0.00853578f, -0.02424144f, 0.00676876f, -0.01764645f, 0.01383119f, -0.03770519f, 
    -0.00452657f, 0.02336799f, 0.01961082f, 0.00913842f, 0.01631805f, -0.01968056f, 0.02658059f, 0.00306557f, 
    0.01547941f, -0.03556356f, -0.00051303f, 0.02177414f, -0.02441816f, 0.02802297f, 0.02787869f, -0.02374070f, 
    -0.04119574f, 0.01988195f, 0.00102607f, -0.01559468f, 0.02668844f, 0.00433586f, -0.02145347f, -0.01493688f, 
    -0.01312122f, -0.03161852f, 0.00394483f, -0.00438434f, -0.00658573f, 0.01946582f, 0.02493950f, -0.00541280f, 
    0.01430474f, 0.03517880f, -0.03785794f, 0.03068117f, -0.01686362f, -0.01221069f, -0.02715694f, -0.02313707f, 
    -0.03352586f, -0.01666522f, -0.00783387f, 0.02275418f, -0.03018115f, 0.03633823f, -0.02674823f, 0.00253231f, 
    0.01336275f, -0.02361806f, 0.02016069f, 0.01142368f, -0.01831174f, -0.02664886f, 0.01168314f, 0.03104347f, 
    -0.02246672f, -0.04022625f, -0.04015262f, -0.03997779f, 0.02476784f, -0.02255325f, -0.02055132f, -0.02916121f, 
    0.22705819f, 0.15000096f, 0.15297912f, -0.03155377f, 0.20235164f, 0.17434272f, -0.03236344f, 0.24351548f, 
    0.02336602f, -0.03423731f, 0.12391371f, 0.05261264f, 0.18402886f, 0.24439356f, 0.06709825f, 0.06964129f, 
    -0.05242431f, 0.02795953f, 0.01656770f, 0.05185540f, 0.05867908f, -0.13955398f, 0.04994595f, 0.11486311f, 
    0.29258734f, -0.09295965f, 0.07551723f, -0.01566924f, -0.00054665f, 0.10429248f, 0.18302637f, 0.06358615f, 
    -0.00676177f, 0.18887728f, -0.14160943f, 0.02825093f, 0.08277158f, 0.14291930f, 0.06618147f, -0.00733755f, 
    -0.00887693f, -0.00627739f, 0.01046529f, 0.16609856f, 0.05058305f, 0.09048671f, -0.02958676f, -0.05094896f, 
    -0.03760545f, -0.03330586f, 0.12494069f, -0.18357678f, 0.09978295f, -0.09102973f, 0.09954897f, 0.03533032f, 
    -0.04524844f, 0.09700598f, 0.01553156f, -0.03181616f, 0.15554497f, 0.13768183f, -0.02732318f, 0.03234716f, 
    0.08413975f, 0.12641986f, 0.01213837f, -0.06275439f, -0.04347816f, -0.10108560f, 0.05122979f, -0.01931116f, 
    -0.31904468f, 0.04393036f, -0.16421090f, 0.02764795f, 0.11248367f, 0.09774066f, 0.11338843f, -0.07101276f, 
    0.06184254f, -0.07083819f, -0.06409239f, 0.08800603f, 0.17065105f, 0.21861146f, 0.02009668f, 0.38391927f, 
    0.03751382f, -0.09747934f, 0.05344453f, 0.04362536f, 0.03948091f, 0.01356259f, 0.06674031f, 0.10884737f, 
    -0.02655941f, -0.37428620f, 0.34657389f, -0.02702803f, 0.00676955f, 0.00767925f, -0.11174741f, -0.09987176f, 
    -0.13414277f, 0.02095199f, -0.20033918f, -0.01263668f, 0.11670152f, -0.08009301f, 0.12130606f, 0.33599854f, 
    -0.18376453f, 0.10597153f, -0.05582657f, 0.06387895f, 0.06847864f, 0.04983319f, 0.01651801f, -0.01968118f, 
    -0.00005562f, -0.19607556f, 0.34720823f, -0.04157073f, -0.07667546f, 0.10151365f, -0.05413966f, -0.03689185f, 
    0.06335536f, 0.08964832f, 0.15556894f, -0.15044646f, -0.04034066f, -0.14686146f, -0.06360894f, 0.12523071f, 
    -0.09685979f, 0.09057941f, 0.03007381f, 0.01840707f, 0.15050709f, 0.14712277f, 0.11589068f, 0.03412364f, 
    -0.09098046f, 0.06737874f, -0.17915878f, -0.03513544f, -0.06809334f, -0.09476786f, 0.00627072f, 0.01472421f, 
    0.07864492f, -0.15514231f, -0.09703024f, 0.01988262f, 0.10591778f, 0.35374469f, -0.31141180f, 0.41100493f, 
    -0.05968224f, -0.11044946f, 0.02053703f, -0.11564104f, 0.02680233f, -0.00636647f, -0.09637301f, -0.08924053f, 
    0.23038021f, -0.00244250f, 0.01459186f, -0.02557467f, 0.08694051f, 0.13699438f, 0.05942106f, 0.10039768f, 
    0.05835378f, -0.00912699f, 0.10736392f, 0.13710992f, -0.28417388f, 0.11266239f, -0.38116330f, 0.09659257f, 
    0.08870791f, -0.09608896f, -0.08483754f, -0.02961356f, 0.16381055f, -0.00476612f, -0.03000858f, -0.21266784f, 
    0.21360914f, -0.04788670f, 0.00553514f, 0.23592702f, -0.00370025f, -0.07346075f, -0.02930395f, 0.00286433f, 
    0.09057099f, 0.21280590f, 0.05138200f, 0.11053520f, -0.08748403f, 0.18833852f, 0.07261366f, 0.13882838f, 
    0.00260383f, -0.06211033f, 0.19434200f, 0.00900442f, -0.00002141f, -0.04762042f, -0.03483761f, -0.15726033f, 
    -0.16104484f, -0.04632416f, 0.14269811f, -0.19270809f, 0.10489240f, 0.07406016f, -0.20846011f, 0.09807128f, 
    0.05211790f, 0.07706937f, -0.19372602f, -0.17763439f, -0.00945948f, -0.16695085f, -0.18122292f, -0.10487227f, 
    -0.04144410f, 0.03338974f, 0.05639471f, -0.03228666f, -0.06293188f, 0.03139773f, -0.13805531f, -0.02097224f, 
    -0.09998409f, -0.05529810f, 0.31625032f, -0.03052420f, -0.09372399f, -0.00083115f, -0.13697305f, -0.07506167f, 
    0.08717941f, -0.11010361f, -0.05135238f, 0.09396672f, 0.20144758f, 0.09954293f, 0.14732419f, 0.19311167f, 
    0.08721422f, -0.07901020f, -0.02535974f, 0.03789686f, 0.10963023f, -0.06530476f, 0.02486487f, 0.17650124f, 
    0.07668382f, -0.08767386f, 0.03664739f, -0.18889114f, 0.04329796f, -0.00666322f, 0.04181826f, 0.07161234f, 
    -0.03329892f, 0.09588692f, 0.06084525f, 0.13317828f, 0.14044701f, 0.24731532f, 0.05653814f, 0.37559798f, 
    0.20422484f, 0.03727012f, -0.07187667f, 0.10659533f, 0.11974929f, 0.04669783f, 0.08717159f, 0.04412051f, 
    -0.04245723f, -0.21258752f, -0.01393947f, 0.13853993f, 0.03669013f, -0.14587538f, 0.16383107f, -0.01303845f, 
    0.06818052f, -0.05553669f, -0.03337498f, 0.02332146f, 0.22661783f, 0.06399940f, 0.10252752f, -0.09253892f, 
    0.03007756f, -0.08938636f, -0.02098416f, 0.05924004f, -0.03303138f, 0.10422727f, -0.07442655f, -0.04312386f, 
    0.12703905f, -0.15072663f, -0.18247758f, 0.08254796f, -0.03614074f, -0.06719660f, 0.06482999f, -0.05724141f, 
    0.08044825f, -0.04160576f, 0.04624102f, -0.00272489f, 0.25697690f, 0.01599961f, -0.02033961f, 0.06533268f, 
    -0.02066212f, -0.14153601f, 0.01069202f, 0.04185631f, 0.08852468f, -0.01999627f, 0.07366484f, 0.09611268f, 
    0.16982883f, -0.20932294f, 0.05414778f, -0.15109120f, -0.10241318f, 0.11506135f, -0.05429575f, -0.15662476f, 
    0.06744784f, 0.05500784f, -0.02367870f, -0.02498106f, -0.22073764f, -0.13871460f, -0.14536174f, -0.05303963f, 
    0.21714573f, -0.12677550f, -0.04213824f, -0.03502440f, 0.14466353f, -0.04898020f, -0.11524589f, -0.09173010f, 
    -0.49202144f, 0.71563143f, -0.32085240f, 0.24350171f, -0.06247276f, 0.05426972f, 0.04255266f, 0.03331842f, 
    0.19149478f, 0.01374110f, -0.03220583f, 0.01670656f, 0.15441465f, 0.08069192f, -0.26151296f, 0.06252290f, 
    0.07541657f, -0.02018009f, 0.06679751f, -0.20110694f, -0.03248042f, -0.16859494f, -0.06222343f, -0.06962626f, 
    0.02891857f, 0.08133914f, 0.00177347f, 0.28577000f, 0.13084497f, 0.13932264f, 0.03179143f, 0.07905928f, 
    0.31062204f, 0.04324191f, 0.06454343f, 0.00170648f, 0.15083474f, 0.12301997f, 0.01740396f, -0.15086284f, 
    0.00219855f, -0.03810034f, -0.07812820f, 0.10794988f, 0.08742743f, 0.08046955f, -0.02720254f, -0.06623694f, 
    0.07988682f, -0.07716354f, 0.03697592f, -0.28834796f, -0.04030838f, -0.08563379f, 0.01905020f, 0.07135988f, 
    -0.01710780f, 0.03393425f, -0.02992200f, 0.16493167f, 0.40170252f, 0.37724754f, 0.03640498f, -0.02646140f, 
    0.19952260f, -0.06120184f, -0.07782529f, -0.02437158f, 0.05453577f, -0.00022422f, 0.09306807f, 0.04902377f, 
    -0.05921840f, -0.08463854f, 0.27193236f, 0.09830673f, -0.06913065f, 0.17637509f, -0.08897660f, 0.01060200f, 
    -0.17880373f, -0.28049591f, -0.33676431f, -0.21403766f, 0.19024888f, -0.03972578f, 0.05772179f, 0.03407044f, 
    -0.04816364f, -0.01165209f, 0.02516993f, 0.04503782f, -0.10370571f, -0.11050699f, -0.01313409f, 0.01931681f, 
    -0.01603333f, -0.04051824f, -0.18513609f, -0.03490407f, 0.09166501f, 0.10722019f, 0.04168678f, 0.07672332f, 
    0.05128887f, -0.06871384f, 0.02449414f, 0.15053743f, -0.02983885f, -0.20028993f, 0.24970132f, -0.07706087f, 
    -0.13627762f, 0.07592287f, -0.15929168f, -0.02512453f, -0.17762719f, -0.18766610f, 0.02402632f, -0.29063284f, 
    -0.07366891f, 0.05422438f, -0.08785430f, 0.04552662f, 0.10481216f, 0.10346083f, 0.28521025f, 0.11772208f, 
    0.19239199f, 0.04090315f, 0.17757905f, 0.28407052f, 0.17853919f, 0.25985119f, 0.03305664f, -0.17673491f, 
    0.00054773f, -0.11589929f, -0.13011636f, -0.03532563f, -0.25755751f, 0.15807201f, -0.17464447f, -0.12363540f, 
    0.19994698f, -0.06483465f, -0.04137380f, -0.03215961f, -0.17494418f, -0.00455267f, -0.02772517f, 0.01846726f, 
    0.07994129f, -0.07092246f, 0.03959262f, -0.11825378f, 0.06122489f, -0.03131748f, 0.10301241f, 0.24577026f, 
    0.01826011f, -0.08100553f, -0.07108996f, 0.01622574f, 0.11036030f, -0.14673509f, -0.01228852f, -0.07687020f, 
    -0.24676189f, -0.20539881f, -0.22571330f, -0.22198766f, -0.01581184f, -0.10026845f, -0.00844372f, 0.03263043f, 
    0.10649219f, -0.04833849f, 0.11146338f, -0.01884134f, -0.07275973f, -0.12074939f, 0.16599008f, 0.18739988f, 
    -0.00864848f, 0.17338483f, 0.08122712f, -0.02971061f, 0.20680262f, 0.11594588f, 0.23532429f, 0.01747997f, 
    0.13773692f, 0.08884797f, -0.05105928f, -0.11038125f, 0.13599896f, 0.16538955f, 0.04857185f, -0.10804130f, 
    -0.01636831f, -0.16547787f, 0.01315787f, -0.03337687f, 0.02357236f, -0.25598872f, -0.11655129f, 0.05534844f, 
    -0.01804222f, -0.13519382f, -0.07107206f, -0.04337409f, -0.03122407f, -0.02329151f, -0.18304570f, -0.14700969f, 
    -0.02423332f, 0.06570705f, -0.06171781f, 0.14554122f, -0.11651076f, -0.02590653f, 0.01348281f, 0.04446230f, 
    -0.12512584f, 0.10291678f, -0.08558784f, -0.03962445f, -0.21154830f, -0.19312997f, 0.07819644f, -0.07534344f, 
    0.08069184f, 0.02506546f, 0.06197895f, 0.21324043f, 0.17478353f, 0.02334286f, -0.14066625f, 0.05844138f, 
    -0.31045312f, -0.11418572f, -0.15017363f, 0.18932730f, 0.03526542f, -0.05963425f, 0.15420379f, -0.04199652f, 
    0.07699775f, -0.16505717f, 0.00709294f, 0.05369123f, 0.10043760f, 0.11547083f, -0.08202184f, 0.07123976f, 
    0.06446640f, 0.00817464f, -0.09087501f, 0.06348985f, -0.02440341f, -0.00201555f, -0.08266326f, 0.13271603f, 
    0.31980240f, 0.29221925f, 0.07841232f, 0.15319771f, 0.20110492f, 0.00285250f, 0.00525641f, 0.03777606f, 
    -0.03646985f, -0.11698204f, -0.07569442f, 0.04854845f, 0.18534149f, -0.00836020f, -0.13570684f, 0.02105798f, 
    0.05837469f, -0.06098804f, -0.02045756f, -0.07034271f, 0.07559779f, -0.07012636f, -0.01258998f, -0.05590324f, 
    0.00365735f, 0.18487850f, -0.39077592f, -0.03120407f, 0.14627880f, -0.08946854f, -0.11111866f, -0.09964006f, 
    -0.03559344f, -0.11526199f, -0.02976537f, -0.12879032f, -0.03014796f, -0.12670861f, 0.15831307f, -0.09835988f, 
    -0.08591307f, 0.09959223f, -0.00202127f, -0.02529400f, 0.06356214f, 0.14427981f, 0.05929480f, -0.00437091f, 
    -0.07285388f, -0.10742753f, 0.13770036f, 0.06404281f, -0.19475147f, 0.00722988f, -0.07629305f, -0.05683893f, 
    -0.13098404f, -0.05430613f, -0.05609095f, -0.13958272f, -0.01977020f, 0.07953314f, -0.05829166f, 0.02689129f, 
    0.03381964f, 0.02721829f, 0.21075909f, -0.00349025f, 0.15507604f, 0.00473878f, 0.17926754f, 0.12864095f, 
    0.23845053f, 0.19976789f, 0.26488751f, -0.03795901f, 0.14242364f, 0.26869074f, 0.11154394f, 0.18677084f, 
    0.03955165f, -0.02096649f, 0.06970838f, 0.11748435f, -0.23525055f, -0.31686914f, -0.07936113f, -0.09176254f, 
    -0.03892204f, 0.01989173f, -0.18833326f, -0.01515682f, 0.02358670f, -0.11830751f, -0.07195503f, -0.04364843f, 
    -0.12078299f, 0.10988652f, -0.26459813f, -0.07214448f, -0.02593335f, -0.17052127f, -0.03441586f, -0.05795895f, 
    0.12649021f, 0.13204446f, -0.20745446f, -0.05272574f, 0.05810488f, 0.07528266f, -0.13003510f, -0.11202691f, 
    0.03304026f, -0.08713233f, 0.05203569f, -0.10481676f, -0.05556176f, -0.14573538f, -0.12364869f, -0.14578958f, 
    0.34911767f, 0.03903497f, -0.27023712f, -0.37445387f, -0.14558236f, -0.07258758f, -0.06268472f, 0.03030945f, 
    -0.03567149f, -0.09925321f, -0.08967396f, -0.12151479f, 0.24204613f, 0.25297680f, -0.02586753f, -0.04199031f, 
    0.12725940f, 0.06262282f, 0.04945488f, 0.17596351f, -0.09023067f, 0.07220525f, -0.05561715f, 0.08027125f, 
    0.12964547f, 0.18757544f, 0.28571215f, 0.05915502f, 0.09084042f, 0.11188364f, 0.12337922f, 0.09200028f, 
    -0.08212699f, -0.00294365f, 0.01393586f, 0.08050098f, 0.16478555f, 0.15760352f, 0.10540557f, 0.09967383f, 
    0.02141798f, 0.06849778f, 0.04500809f, 0.05183853f, 0.03040192f, -0.01326337f, -0.01358289f, -0.02759527f, 
    -0.23884767f, 0.00758563f, 0.12751547f, -0.45752499f, -0.03822106f, 0.14956391f, -0.14602734f, -0.11607218f, 
    -0.00952931f, 0.01033489f, 0.06375451f, 0.00934992f, 0.06299751f, 0.00641147f, -0.03312806f, 0.20494060f, 
    -0.01255278f, 0.01124916f, 0.15302868f, -0.04754312f, 0.00274416f, 0.07570863f, -0.08832414f, -0.08666092f, 
    0.08812364f, 0.24013248f, 0.02713891f, -0.12263031f, 0.09801263f, -0.12341222f, 0.10828184f, 0.05780304f, 
    -0.08341295f, 0.02112417f, -0.06992196f, 0.01908388f, 0.19403027f, 0.18452299f, -0.03133793f, 0.21932890f, 
    0.02729039f, 0.22118478f, 0.03077147f, 0.14791559f, 0.02253391f, 0.03811185f, 0.00671006f, 0.02557771f, 
    -0.04370202f, 0.06067157f, -0.20275614f, -0.01048682f, 0.17664035f, -0.01118674f, -0.06129630f, 0.18632829f, 
    -0.09572288f, -0.02120498f, 0.05737365f, 0.09643299f, 0.01725130f, 0.19659385f, 0.13593505f, 0.24762522f, 
    -0.08128076f, 0.06086027f, -0.01920226f, 0.07256813f, 0.00305961f, -0.07085153f, -0.03322016f, -0.12561545f, 
    -0.01189163f, -0.24256447f, 0.34095031f, 0.10379265f, 0.01738553f, -0.07480269f, -0.05186582f, -0.09361698f, 
    -0.03749955f, 0.10585968f, 0.05752541f, 0.08690494f, 0.02199690f, 0.13028985f, 0.02425564f, 0.10268255f, 
    0.02200247f, -0.00549620f, 0.00599734f, 0.12192912f, -0.09236069f, 0.04479647f, -0.02076312f, 0.01411452f, 
    0.02589688f, 0.09165052f, -0.11080287f, 0.01305785f, 0.11487193f, -0.06107574f, -0.01299544f, 0.01850188f, 
    -0.05263518f, 0.00200882f, -0.12533776f, -0.08596817f, -0.03759038f, 0.08344565f, -0.07933083f, 0.28607190f, 
    -0.13315162f, -0.03017936f, 0.09761126f, 0.00365603f, 0.05116794f, -0.13375938f, 0.10166941f, -0.11671957f, 
    -0.05998611f, 0.09680122f, 0.00945451f, -0.06401002f, -0.15931827f, 0.12736934f, 0.14356586f, -0.02531856f, 
    0.01987271f, -0.21539775f, -0.05151980f, 0.04944039f, -0.23151325f, 0.43295062f, 0.07512973f, 0.45942932f, 
    -0.04913049f, -0.06313600f, 0.14261626f, 0.15918630f, 0.03282768f, -0.04079959f, -0.08654607f, -0.03797386f, 
    0.10462268f, -0.30767235f, 0.05646200f, -0.12387802f, 0.06075906f, -0.12148098f, -0.09993631f, -0.05464151f, 
    -0.11303914f, -0.05701352f, 0.00403038f, -0.02900991f, -0.24295200f, 0.28887329f, -0.03728736f, -0.06239915f, 
    0.02680651f, -0.03527102f, 0.03957815f, 0.07534426f, 0.16424800f, 0.02320448f, 0.01079303f, -0.01188167f, 
    0.03271086f, -0.12268119f, 0.06531773f, 0.09963237f, 0.04195010f, -0.09429065f, -0.10437801f, -0.12118252f, 
    -0.14432754f, -0.05120567f, -0.12576066f, -0.13180275f, 0.32493702f, 0.03076506f, 0.02005070f, -0.13606855f, 
    0.11007491f, 0.02805365f, 0.18214931f, 0.22670333f, 0.02133309f, -0.01883649f, 0.09677118f, -0.07199878f, 
    -0.13771588f, -0.10636929f, -0.16666578f, -0.29712752f, -0.04602282f, 0.01199372f, 0.05200963f, -0.08942340f, 
    0.26058078f, 0.16806269f, 0.00119658f, 0.07593451f, -0.21650612f, -0.02539579f, 0.13847347f, 0.12370536f, 
    0.01842017f, 0.08039568f, -0.03010484f, 0.12077687f, -0.05039893f, 0.08443485f, -0.01549246f, 0.03567518f, 
    -0.13575710f, 0.02096433f, 0.16412786f, -0.01742521f, 0.05110397f, 0.03263054f, 0.06433379f, -0.17024346f, 
    -0.03781222f, -0.06236489f, -0.14602737f, -0.00241398f, 0.07665745f, 0.12414431f, 0.11333758f, 0.22590607f, 
    0.11403073f, -0.01905129f, 0.02772556f, 0.18075991f, 0.03210079f, -0.01245101f, -0.01805181f, -0.06996618f, 
    -0.11459579f, 0.08299339f, 0.16041981f, -0.16274664f, 0.03104132f, 0.05160759f, -0.07217276f, -0.08472683f, 
    -0.14072628f, 0.04187064f, -0.04552625f, -0.16910006f, -0.02921993f, 0.14957905f, 0.15306012f, 0.17763668f, 
    0.12117413f, 0.01479272f, 0.07432932f, 0.16377237f, -0.08499893f, 0.01464903f, -0.02021413f, 0.05646613f, 
    -0.08364899f, -0.21944736f, -0.03375193f, 0.02360147f, -0.06691322f, -0.04811731f, 0.06686568f, 0.12891224f, 
    -0.01973930f, -0.09820646f, -0.08100859f, -0.06986072f, 0.08273620f, 0.45445627f, -0.12079291f, 0.25116143f, 
    0.19812232f, 0.02883612f, -0.10150098f, -0.06372298f, -0.02272802f, -0.07171320f, -0.04644738f, -0.12040683f, 
    0.11401159f, -0.06318592f, -0.17466527f, 0.11415906f, 0.01553227f, -0.12629487f, -0.10040998f, -0.10017116f, 
    0.00565904f, 0.01716234f, -0.08579219f, -0.03624528f, 0.09905924f, -0.04666296f, 0.00035817f, 0.17335856f, 
    -0.06062006f, -0.00351278f, -0.01957529f, -0.03478497f, 0.13448447f, 0.04595591f, 0.11248764f, 0.11721184f, 
    0.25718278f, -0.08580834f, -0.00402341f, -0.23842211f, 0.11764882f, 0.12521632f, 0.02895236f, -0.06186767f, 
    0.02709206f, -0.00346117f, 0.11010887f, 0.08842497f, -0.19523914f, -0.16647439f, -0.18240026f, 0.24863921f, 
    0.17345597f, -0.13375071f, -0.13996096f, -0.04251358f, 0.04628103f, 0.02269439f, 0.03724243f, 0.09949445f, 
    -0.12785751f, 0.39428493f, -0.01381584f, 0.10115568f, -0.12744112f, 0.00086044f, 0.12992798f, -0.16996120f, 
    0.13330542f, -0.04736311f, 0.03499825f, 0.11685905f, 0.32949182f, 0.04793743f, -0.08803246f, -0.02347738f, 
    0.01655609f, -0.06502371f, 0.09648389f, 0.03830716f, 0.06008292f, 0.01731098f, 0.14227270f, 0.06498946f, 
    -0.10427880f, 0.32643220f, -0.16964763f, 0.25873995f, -0.09489889f, -0.00722531f, 0.06486252f, 0.02162409f, 
    -0.09600046f, 0.11799164f, -0.11086415f, -0.00799007f, -0.17456259f, 0.15467930f, 0.02858496f, -0.27861208f, 
    -0.00210007f, 0.04562830f, -0.14472803f, -0.08654410f, 0.01019480f, 0.02761173f, -0.01804185f, -0.06239625f, 
    -0.16771320f, 0.15776782f, 0.13554254f, -0.23416276f, 0.09806740f, 0.10685095f, -0.17793965f, -0.11631446f, 
    0.04780409f, -0.01328559f, -0.05364265f, 0.03531855f, 0.09113575f, 0.16909732f, 0.19793543f, 0.02865861f, 
    0.25041768f, 0.19684793f, 0.20081231f, 0.21669815f, -0.04468531f, -0.08582892f, -0.01828124f, -0.02003774f, 
    0.12415064f, 0.01514206f, 0.22410025f, -0.04185969f, -0.07179973f, 0.14875440f, 0.13099024f, -0.01620783f, 
    0.07533899f, -0.02690923f, -0.03185814f, 0.15704480f, 0.26222786f, 0.08364698f, -0.02110776f, 0.04588066f, 
    0.01860093f, -0.01119310f, -0.02785918f, 0.03266344f, -0.04216143f, 0.02184892f, 0.04682341f, 0.08864380f, 
    0.13816765f, -0.32187197f, -0.14662981f, -0.23934752f, 0.10156394f, -0.10234749f, -0.01466224f, 0.07616358f, 
    -0.01165153f, -0.04148404f, -0.02555504f, -0.11657950f, 0.08840388f, -0.14394474f, 0.14597802f, 0.13493118f, 
    0.08396507f, -0.01716606f, -0.06643998f, -0.14902140f, 0.14610408f, 0.02992107f, 0.10450420f, 0.05419010f, 
    0.10888179f, -0.07745329f, -0.09018197f, 0.00160419f, 0.07010569f, 0.02841287f, 0.06410992f, 0.02515274f, 
    -0.00757329f, -0.03151456f, -0.10825290f, -0.02316397f, -0.07710562f, 0.27779379f, 0.05173200f, -0.02608569f, 
    0.02245964f, -0.05698253f, -0.07686388f, -0.14555690f, 0.01675613f, -0.01785632f, -0.07194208f, 0.07769459f, 
    0.07412611f, 0.12845588f, 0.14199048f, 0.06908388f, -0.13990170f, -0.04285454f, -0.03338236f, -0.22596470f, 
    0.02973882f, -0.00721848f, 0.03222269f, 0.00971573f, -0.00967075f, 0.08424049f, -0.16533582f, 0.29793450f, 
    0.15103793f, 0.07795068f, 0.08385483f, 0.22317497f, -0.04484346f, -0.08980813f, -0.05493123f, -0.15608151f, 
    -0.11037963f, -0.23848146f, 0.26564673f, -0.17135248f, -0.01036193f, -0.13188222f, -0.03961937f, 0.04160113f, 
    0.02800972f, -0.06358603f, 0.14277373f, 0.04125648f, -0.04996794f, 0.00578939f, -0.03962563f, 0.04005766f, 
    -0.09935738f, -0.00005975f, 0.04137599f, 0.08953597f, -0.07231964f, 0.07468522f, 0.10588351f, -0.02062431f, 
    0.15471436f, 0.28211492f, 0.00502023f, 0.07040169f, 0.01150313f, 0.12729341f, 0.01820209f, 0.15142043f, 
    0.07660414f, 0.03500065f, 0.04905359f, 0.08149333f, 0.00596636f, -0.11940559f, 0.05193285f, 0.06253082f, 
    0.01278076f, -0.09762056f, -0.04556920f, -0.06041352f, 0.11116359f, 0.21226989f, -0.07185153f, 0.10345367f, 
    -0.02546153f, 0.29105315f, -0.12058079f, 0.14493744f, -0.00280159f, -0.13310352f, 0.01989345f, -0.12623380f, 
    0.09349390f, 0.04252872f, 0.06198999f, 0.02778874f, 0.16714723f, -0.31680506f, -0.29121232f, -0.34699669f, 
    0.09314990f, 0.07109719f, -0.09869064f, 0.08493198f, 0.04766394f, 0.02629687f, -0.07368115f, -0.05426056f, 
    -0.24148038f, -0.10841881f, -0.11305578f, 0.06754000f, 0.01853444f, -0.08358131f, 0.03803368f, 0.01764652f, 
    0.04130122f, -0.05277241f, 0.01259517f, 0.06581366f, 0.07970600f, 0.03882514f, -0.12775001f, -0.03827308f, 
    0.04094458f, 0.06741413f, -0.03030932f, -0.04600882f, 0.09590185f, 0.04176314f, -0.12475994f, -0.03852376f, 
    0.22567630f, 0.17565344f, 0.13889292f, 0.15673193f, 0.11855596f, 0.25507241f, 0.07065258f, 0.30855298f, 
    -0.02303808f, -0.07460953f, 0.00345298f, 0.02347610f, 0.05424548f, -0.08713879f, -0.09231367f, -0.05298441f, 
    -0.03990059f, -0.13530704f, -0.05929409f, -0.15227365f, 0.11717212f, 0.08375207f, 0.07634763f, 0.04158818f, 
    -0.02983005f, 0.23949330f, 0.03667850f, 0.20431179f, -0.06093305f, 0.10912164f, -0.08373293f, 0.10984334f, 
    0.16820268f, 0.03678853f, 0.15255661f, 0.09692809f, 0.00162809f, -0.11688772f, -0.19023320f, 0.16651283f, 
    -0.03533057f, -0.08534499f, -0.06841800f, 0.15652005f, 0.05434274f, 0.09243073f, -0.00387318f, -0.04918318f, 
    0.06855724f, 0.17957792f, 0.20473915f, 0.10856460f, -0.13161850f, 0.08960219f, -0.04581103f, -0.07081082f, 
    0.06493315f, -0.00835832f, 0.14037704f, 0.14795910f, -0.01622613f, 0.04312848f, -0.01396067f, 0.05214351f, 
    0.02858122f, -0.02791493f, 0.02281028f, 0.12986721f, 0.06551825f, 0.08162877f, -0.12949429f, -0.09927543f, 
    0.16808279f, 0.16131853f, 0.18813503f, 0.07404620f, 0.16186376f, 0.07171294f, 0.08085036f, 0.16171348f, 
    0.04709008f, 0.01479059f, 0.02442890f, 0.02353131f, -0.21279201f, -0.17633362f, -0.11963176f, -0.16086958f, 
    -0.13073763f, 0.01724732f, -0.08902223f, -0.18992884f, 0.05667227f, 0.05619636f, 0.00887896f, 0.11013533f, 
    -0.14956349f, -0.11792506f, -0.04913815f, -0.29332826f, -0.07045758f, -0.10538217f, 0.01948328f, -0.05652885f, 
    0.15757123f, 0.08693181f, -0.10698608f, -0.10648729f, -0.10793824f, 0.09687953f, 0.04163440f, 0.13175078f, 
    0.11563356f, -0.11519281f, 0.09726804f, -0.01094517f, 0.08698043f, 0.06934382f, 0.04505353f, 0.02891943f, 
    0.24994104f, 0.21330874f, -0.10198396f, 0.09558255f, 0.08531649f, -0.00772483f, -0.05595303f, -0.15028034f, 
    -0.11336629f, -0.09077504f, -0.06193825f, 0.02713582f, -0.00061387f, 0.38447481f, 0.17395651f, -0.01061023f, 
    0.10043523f, 0.14735514f, -0.01738333f, 0.13849138f, 0.03528977f, 0.01825147f, 0.01057746f, 0.07594173f, 
    0.00262682f, -0.04190211f, -0.00323848f, 0.02197569f, -0.02047788f, -0.02517713f, 0.01586235f, -0.00763613f, 
    -0.02405489f, -0.02126075f, -0.03076813f, 0.01580568f, -0.04059185f, 0.01047329f, 0.02686171f, 0.02263163f, 
    0.00751253f, 0.00482795f, 0.00477314f, 0.01661956f, 0.01013644f, 0.01694632f, -0.01924985f, 0.01218557f, 
    0.00082275f, -0.00885337f, -0.04163837f, -0.01352342f, 0.01953016f, -0.01084661f, -0.02865205f, -0.02215848f, 
    -0.00211849f, -0.03336679f, -0.03321914f, 0.01528510f, 0.02586019f, -0.03017959f, 0.00769476f, -0.01767774f, 
    -0.00015530f, -0.00364624f, 0.02064346f, -0.02976383f, -0.00139809f, -0.02328577f, -0.03407412f, -0.01501024f, 
    -0.02988174f, -0.01165201f, 0.00766172f, -0.03780818f, 0.00468413f, -0.00211184f, 0.01784018f, -0.00050672f, 
    -0.01724064f, 0.00370584f, -0.02129051f, -0.00466202f, 0.00696386f, -0.02946658f, -0.01339073f, -0.00324198f, 
    0.01787446f, -0.01273151f, 0.00940321f, 0.00275921f, -0.03747688f, -0.03576805f, 0.02122610f, -0.02803369f, 
    0.02215580f, -0.02870443f, -0.03109592f, -0.03972952f, 0.01717520f, 0.02279102f, -0.02845897f, -0.01416024f, 
    -0.03581650f, -0.03498381f, -0.02071157f, -0.01014511f, 0.01207175f, -0.00234021f, -0.00921108f, -0.01072128f, 
    -0.04240055f, -0.02186829f, 0.01665485f, 0.00490391f, -0.02051324f, -0.00434487f, -0.00476868f, -0.00618100f, 
    0.02817120f, 0.02787931f, -0.03282322f, 0.01550927f, -0.01545227f, -0.03879213f, 0.00540385f, -0.03884332f, 
    0.01519452f, -0.01686340f, -0.02428141f, -0.03665970f, 0.01939289f, -0.02618503f, -0.00571681f, -0.03890789f, 
    -0.01633562f, -0.03772196f, -0.03175013f, 0.00534836f, -0.00104425f, 0.01907000f, -0.02880266f, -0.02078249f, 
    0.00620826f, -0.02114662f, -0.02951889f, 0.01435804f, 0.00084690f, -0.03140767f, -0.01154873f, -0.00151065f, 
    0.01841468f, 0.00106950f, 0.02438811f, 0.00371591f, -0.00875894f, 0.03209529f, -0.00547925f, 0.00304074f, 
    0.00949495f, 0.00552375f, 0.00952779f, -0.03034972f, -0.01511459f, -0.00289348f, -0.03950770f, 0.00853691f, 
    0.00769510f, -0.00929483f, -0.00369683f, -0.01519274f, -0.01101993f, -0.03808693f, -0.02536418f, -0.02175684f, 
    -0.02725223f, 0.00502429f, 0.01264334f, -0.03011216f, 0.00403629f, -0.03190934f, -0.04044597f, 0.02725556f, 
    -0.03920427f, 0.00676932f, 0.02558401f, 0.00892797f, 0.00352228f, 0.01358688f, -0.04192523f, 0.00929568f, 
    0.00400597f, 0.02241847f, 0.01747463f, 0.00575525f, -0.00675086f, -0.03883455f, -0.03053281f, 0.01003831f, 
    0.01437225f, 0.02896120f, 0.01277319f, 0.00424377f, -0.01074743f, -0.01244894f, -0.02818436f, 0.02496862f, 
    -0.02473952f, -0.00407152f, 0.02348728f, -0.01114058f, 0.02041152f, -0.01371568f, 0.00238735f, -0.02867847f, 
    0.01745956f, -0.01711447f, 0.00197824f, 0.00087721f, 0.02479501f, -0.01379623f, 0.01319901f, -0.00570229f, 
    -0.00376329f, -0.04229354f, -0.01734617f, -0.00716427f, 0.00547302f, 0.00725216f, 0.00435303f, -0.04225270f, 
    -0.01395949f, -0.04082170f, -0.00426964f, -0.02762146f, 0.01857256f, -0.01211027f, -0.00622237f, 0.02231576f, 
    0.02913657f, -0.03694302f, -0.04137208f, 0.00275699f, -0.03978637f, -0.02576808f, 0.02467950f, 0.01989172f, 
    0.01080953f, -0.03277342f, -0.01171419f, -0.03052642f, -0.02101604f, 0.01554945f, -0.01689370f, -0.03923646f, 
    -0.02953180f, 0.02728386f, 0.00905866f, -0.00300837f, -0.00418916f, -0.01000312f, -0.01334638f, 0.02371754f, 
    -0.00609508f, 0.01450532f, -0.00110072f, -0.00306414f, -0.03463156f, -0.03058866f, -0.01906509f, 0.00994743f, 
    -0.02062808f, -0.00581669f, -0.01278544f, 0.00175699f, -0.03048488f, -0.02164944f, 0.01517881f, -0.00981702f, 
    -0.04349019f, -0.01365566f, -0.04427322f, -0.01048551f, 0.00857223f, -0.01499048f, 0.01776193f, -0.03871034f, 
    0.00990598f, 0.00968281f, -0.03071583f, 0.02788360f, -0.01433473f, -0.02500319f, -0.01475751f, 0.01777333f, 
    -0.02046498f, 0.02452556f, 0.01418802f, -0.02822281f, -0.01761402f, 0.02460103f, -0.02361323f, 0.02303451f, 
    -0.00583109f, -0.00706971f, -0.04006290f, 0.00939731f, -0.01693267f, 0.00899028f, 0.00109305f, 0.00391286f, 
    -0.01329911f, 0.00402721f, -0.00697712f, -0.02323176f, -0.02641471f, 0.02158528f, -0.02321890f, -0.03648441f, 
    -0.00157251f, -0.02153795f, -0.01175304f, 0.02091016f, -0.02366193f, 0.01653598f, -0.02978990f, -0.02434202f, 
    -0.03679613f, 0.00323383f, -0.01563346f, -0.03887674f, 0.01283365f, 0.01328411f, -0.04345751f, -0.01665563f, 
    0.02149491f, 0.02270145f, 0.02389346f, 0.01989560f, -0.02435444f, -0.03698811f, -0.01482459f, -0.02173684f, 
    -0.00667067f, -0.00039270f, -0.03966939f, 0.01711348f, -0.01868934f, 0.03344993f, -0.00784289f, 0.00266703f, 
    -0.02426728f, -0.03689713f, -0.03190616f, 0.01411096f, -0.03875282f, -0.03579405f, -0.03782324f, 0.02291231f, 
    0.01883678f, 0.00792173f, -0.03088156f, -0.01174640f, -0.00162821f, 0.01519794f, 0.02965796f, 0.01630098f, 
    0.02203141f, -0.03345783f, 0.00620178f, -0.00478766f, 0.01762735f, -0.01933594f, -0.03660234f, -0.00215131f, 
    -0.02675035f, -0.01320038f, -0.00768925f, -0.00498569f, -0.02240213f, 0.00354059f, 0.02402873f, 0.00896437f, 
    0.02097786f, 0.03774999f, -0.02500300f, 0.01932027f, -0.03142896f, -0.00709043f, 0.02782761f, -0.00818686f, 
    -0.00627627f, 0.02344212f, -0.00820372f, -0.03683490f, 0.02464446f, -0.00434454f, -0.00222631f, 0.02029909f, 
    -0.01171134f, 0.02072065f, -0.02994101f, -0.04154810f, -0.03831002f, -0.03466726f, 0.00482417f, -0.04227147f, 
    -0.00759336f, 0.01200550f, -0.00945801f, 0.01587128f, -0.00565715f, 0.00779655f, -0.01184414f, 0.00691860f, 
    -0.00174074f, -0.04000211f, 0.02250306f, -0.04096657f, -0.02078158f, 0.01059065f, 0.02817753f, 0.02444657f, 
    0.02577825f, 0.01752362f, 0.01597700f, 0.02140031f, -0.03654505f, -0.01405422f, 0.01361205f, -0.03832405f, 
    -0.01147478f, -0.01590753f, 0.00290241f, 0.02871409f, -0.00257204f, -0.02592729f, 0.01459630f, -0.03148952f, 
    -0.04173732f, -0.04312466f, 0.01357678f, 0.02501209f, -0.01045921f, -0.00471486f, -0.01115889f, -0.00722505f, 
    0.02705573f, 0.00841102f, -0.00705872f, -0.03285724f, 0.01156380f, 0.01063136f, -0.02894445f, -0.01040816f, 
    0.01663921f, -0.00689250f, -0.02935630f, -0.00646962f, -0.00998108f, -0.02509652f, -0.00436820f, 0.01372787f, 
    0.01684358f, -0.00851427f, 0.00509587f, -0.00443848f, -0.03497006f, 0.00663343f, 0.02867852f, 0.00140503f, 
    0.02666369f, 0.02634519f, 0.00250489f, -0.04222343f, -0.01541900f, -0.03935356f, 0.00030174f, -0.01228452f, 
    -0.03813278f, 0.02853839f, -0.02430174f, -0.00999191f, -0.00548354f, -0.01418445f, -0.00676779f, 0.00453265f, 
    0.01754210f, 0.00292978f, -0.03914650f, -0.02027021f, -0.02044069f, 0.00248931f, 0.01738573f, -0.04255022f, 
    -0.02554056f, -0.00643395f, -0.01497958f, 0.00625608f, 0.00535549f, 0.01307090f, -0.03245541f, 0.02530952f, 
    0.02552997f, -0.02817707f, 0.01093594f, 0.00444856f, 0.00892187f, 0.02394973f, 0.01452810f, -0.03413652f, 
    -0.02381163f, -0.03245676f, -0.01672822f, -0.02385157f, -0.01621928f, -0.01162313f, -0.00671754f, -0.02034946f, 
    0.02034612f, -0.00350692f, -0.01709941f, -0.01991034f, -0.03276012f, 0.02465422f, -0.00122948f, -0.01140273f, 
    -0.01086706f, -0.02563334f, -0.00762131f, 0.00392932f, 0.00900666f, -0.01006778f, 0.02930412f, -0.01935986f, 
    0.01647336f, 0.00644722f, -0.01120275f, 0.01096958f, 0.00017292f, 0.00566498f, 0.02319073f, -0.02625105f, 
    0.01274261f, -0.03383453f, -0.00657205f, -0.01593444f, -0.03998734f, 0.00758914f, -0.04075572f, -0.01081793f, 
    -0.00258122f, 0.01116800f, -0.03690942f, -0.03001806f, -0.03781940f, -0.02754846f, 0.02726729f, -0.03697497f, 
    -0.00468274f, 0.01764715f, 0.00953407f, -0.02376565f, -0.00077363f, -0.03296244f, -0.00987891f, -0.03855588f, 
    -0.00681616f, -0.00149749f, 0.00029835f, 0.01987646f, -0.02289115f, 0.01577877f, 0.01863682f, -0.00777720f, 
    -0.04133947f, -0.00117407f, 0.02141970f, -0.01163951f, 0.01278279f, -0.03701558f, -0.03019329f, -0.03685843f, 
    0.02868379f, 0.02485046f, 0.01209066f, 0.01351511f, 0.01270373f, -0.02585089f, -0.03227499f, -0.04157879f, 
    0.01580621f, -0.00770941f, -0.00227775f, -0.02651124f, 0.01402835f, 0.01567285f, -0.00547108f, 0.00315229f, 
    -0.02478540f, -0.03244080f, -0.01109874f, 0.00220366f, 0.02464703f, 0.01610943f, -0.01288248f, -0.01679107f, 
    0.00945813f, 0.00306013f, -0.02178842f, -0.02372226f, -0.03467941f, -0.01862001f, 0.00501972f, 0.00083246f, 
    -0.04272342f, 0.02800982f, -0.00540385f, -0.02555221f, -0.03716149f, -0.01171839f, -0.03045248f, -0.02600888f, 
    0.01548927f, -0.00893814f, 0.00913940f, -0.00857880f, 0.01503260f, 0.00219042f, 0.00560606f, -0.03446446f, 
    0.02026616f, 0.02781732f, -0.03647665f, 0.01395234f, -0.00142034f, -0.02988194f, -0.00578458f, 0.00858624f, 
    -0.03807325f, -0.00261041f, 0.03222861f, 0.00383040f, -0.02550154f, -0.02618842f, -0.03775147f, 0.01309163f, 
    -0.00755869f, 0.00140231f, 0.00718366f, -0.00019096f, -0.03515642f, -0.01737584f, 0.02603309f, 0.01088678f, 
    -0.04173193f, -0.00891997f, -0.00081433f, -0.02211365f, -0.03243851f, 0.01045999f, 0.00757879f, 0.02017906f, 
    -0.02505168f, 0.01391798f, -0.02837621f, 0.01242336f, -0.01636093f, -0.03111871f, 0.01010429f, -0.02463615f, 
    0.02743169f, -0.00495184f, 0.00789790f, 0.02105813f, -0.02557747f, -0.02148180f, -0.00640686f, -0.02761419f, 
    0.02173986f, -0.02814464f, -0.02217296f, -0.01766763f, -0.00304206f, -0.01337077f, -0.03595867f, -0.01187397f, 
    0.02131302f, 0.01216815f, -0.02729236f, -0.02343790f, 0.01409635f, 0.02768491f, -0.03501647f, 0.01427043f, 
    0.01665877f, 0.02078009f, -0.01290360f, -0.00659902f, 0.02378287f, -0.01981699f, 0.01141930f, -0.03632778f, 
    -0.03401207f, 0.01846163f, 0.00504519f, -0.00503821f, -0.02738428f, -0.02777813f, -0.01054177f, 0.01328907f, 
    -0.00795814f, -0.04059732f, 0.01318857f, -0.03631322f, 0.02381725f, 0.01689429f, -0.01176539f, -0.01425767f, 
    0.01637450f, 0.00572227f, -0.02698287f, 0.02723138f, -0.02618894f, -0.02686133f, 0.01194628f, 0.01806032f, 
    -0.01857029f, 0.01683192f, 0.00029318f, 0.01291737f, -0.02873930f, 0.02728892f, -0.02825946f, 0.02816355f, 
    -0.00806243f, -0.00378436f, -0.00310124f, -0.02908845f, 0.01979072f, -0.00405900f, 0.00398835f, 0.00115386f, 
    -0.00646839f, 0.01653781f, -0.03602991f, -0.04048909f, -0.01396418f, -0.02213884f, -0.03324461f, -0.00983159f, 
    -0.00740258f, 0.00346255f, 0.00341976f, 0.02279978f, 0.01126540f, -0.00060462f, 0.01980763f, -0.01699809f, 
    -0.03603294f, -0.03561967f, -0.02630817f, 0.02518688f, 0.02829167f, -0.01155890f, -0.02163107f, 0.02262466f, 
    -0.00948065f, 0.02602964f, 0.01893615f, 0.01159894f, 0.02146165f, -0.01707451f, -0.03371655f, 0.02119233f, 
    -0.00316037f, 0.01627031f, -0.02250570f, -0.00221547f, 0.02253485f, 0.02184670f, 0.02935433f, -0.01523892f, 
    -0.00380181f, -0.01421630f, 0.00684934f, 0.01782011f, -0.01159156f, -0.03888077f, -0.00568989f, 0.02489297f, 
    -0.11838543f, -0.17410749f, 0.04355548f, -0.03952259f, -0.01640661f, -0.10891284f, 0.00229976f, 0.13606894f, 
    -0.00581521f, -0.00646621f, -0.09202293f, 0.04062236f, -0.11588188f, -0.19163905f, -0.03233655f, 0.07228367f, 
    -0.04525366f, 0.01629862f, -0.10487093f, 0.00748031f, -0.00452317f, 0.09368981f, 0.14761610f, 0.15890452f, 
    -0.08665802f, -0.10514393f, 0.21320531f, -0.13199483f, -0.02905910f, -0.09436857f, 0.08935568f, -0.01733115f, 
    0.11251687f, 0.14626306f, 0.13046269f, 0.00426511f, -0.08962505f, -0.07389168f, 0.10505462f, -0.05034621f, 
    0.02051563f, -0.02773954f, 0.06657910f, 0.00361446f, -0.01230284f, -0.03402775f, 0.05926802f, 0.12692681f, 
    0.01602848f, 0.07041366f, -0.05144686f, 0.20682381f, 0.19613473f, -0.07636105f, 0.13353050f, 0.12132446f, 
    -0.02795630f, 0.03775729f, 0.13117231f, 0.12563345f, -0.14184938f, -0.07452637f, -0.04770498f, -0.09456304f, 
    -0.06482618f, -0.02591539f, -0.04926901f, 0.10031363f, -0.04786367f, 0.09459375f, 0.04446655f, -0.03054719f, 
    0.14935026f, 0.13982043f, -0.09277942f, 0.09426840f, -0.21941046f, 0.09524012f, -0.05818167f, 0.04450926f, 
    -0.01386601f, -0.09042700f, -0.00639220f, -0.07650740f, -0.04970325f, 0.15936872f, 0.27225611f, -0.01541108f, 
    -0.09162213f, 0.10457378f, -0.09484759f, -0.02376197f, 0.08229873f, 0.09655733f, 0.30184317f, 0.17399202f, 
    0.09951677f, 0.05055971f, -0.03762339f, 0.08733275f, -0.01570340f, -0.04749824f, -0.04643867f, -0.06082100f, 
    0.06633575f, -0.05302608f, 0.04198891f, -0.12553862f, 0.07074483f, -0.00101951f, -0.00472499f, -0.13813868f, 
    0.03628922f, -0.05343834f, 0.11357346f, 0.00241254f, 0.19130667f, 0.16083965f, 0.02711625f, 0.18948784f, 
    0.29745287f, 0.03709889f, -0.11592222f, 0.07703705f, -0.04059993f, -0.16374131f, 0.13451059f, 0.18798712f, 
    0.15468237f, 0.08639672f, -0.06402917f, -0.07170489f, 0.15955611f, -0.03128539f, 0.05535455f, 0.02712929f, 
    -0.01846736f, 0.00136280f, 0.06785875f, 0.03257851f, 0.07615303f, 0.10417113f, 0.08956625f, -0.04479069f, 
    0.00093112f, 0.07791051f, 0.10752215f, -0.00603236f, -0.02637391f, 0.14539479f, -0.11602586f, 0.07031733f, 
    -0.13796793f, -0.03397589f, 0.11206745f, -0.01446108f, 0.20999520f, 0.01931429f, 0.35609394f, -0.04432556f, 
    -0.04603762f, -0.05640646f, 0.04097098f, 0.10327449f, -0.06010575f, 0.06357332f, 0.13075152f, 0.03369116f, 
    0.24424474f, 0.01420283f, 0.07255474f, -0.04887152f, -0.08503889f, -0.16606022f, -0.05998679f, -0.20624653f, 
    0.00463582f, 0.13671584f, 0.17922398f, 0.09469050f, 0.14919811f, 0.03110551f, 0.44632113f, -0.00490244f, 
    -0.03220366f, 0.10478439f, -0.07615771f, 0.09432691f, -0.03340980f, 0.05181616f, 0.04594015f, 0.10460868f, 
    -0.07449176f, -0.00666970f, -0.01377474f, 0.13415775f, 0.02299298f, -0.06784785f, -0.07658003f, -0.03994985f, 
    -0.05661577f, 0.06687023f, 0.08502408f, 0.19575241f, 0.10211276f, 0.05726233f, -0.04161362f, -0.17924964f, 
    0.00003943f, 0.02707209f, -0.09942389f, 0.06152073f, -0.04867547f, -0.07719553f, -0.02958349f, -0.07795888f, 
    0.05114621f, 0.06133442f, -0.11763132f, -0.10064226f, -0.06695491f, 0.06180755f, -0.07739912f, 0.07806557f, 
    -0.11659328f, -0.09085227f, -0.14057419f, -0.09579571f, -0.21484828f, -0.01655929f, 0.12617764f, -0.07869318f, 
    -0.01769849f, -0.09292123f, 0.09536467f, 0.12908915f, -0.08698460f, -0.04682155f, -0.03872319f, -0.03357768f, 
    0.13677999f, 0.01176459f, 0.01662522f, 0.04037656f, 0.13777678f, 0.23466980f, -0.01670834f, 0.08357861f, 
    0.01830553f, 0.02992295f, -0.06805437f, 0.01368632f, -0.22299218f, -0.12123134f, -0.06402785f, 0.04684277f, 
    -0.05558762f, -0.04052174f, -0.00068461f, 0.05070656f, 0.04415904f, 0.09410021f, 0.13834199f, 0.13075112f, 
    0.01448118f, 0.14933960f, -0.09025048f, 0.10101534f, 0.08924030f, 0.00863697f, 0.05483862f, -0.02679613f, 
    0.05969696f, 0.25512293f, 0.13135317f, 0.03591703f, -0.25054613f, 0.06804975f, 0.05017334f, -0.11412402f, 
    0.03723864f, -0.04366257f, 0.10450868f, 0.05493963f, -0.01154387f, 0.13727508f, 0.00611516f, 0.03324118f, 
    0.16275358f, 0.03272806f, 0.08638351f, 0.02900718f, -0.02471307f, 0.02686683f, 0.05848037f, 0.08346943f, 
    -0.00074592f, 0.04009863f, -0.05328418f, -0.01613325f, -0.05765986f, 0.11056679f, -0.11782557f, 0.30205855f, 
    0.21699116f, 0.07789554f, -0.05085757f, 0.00284668f, -0.06539004f, 0.06501675f, 0.12935159f, -0.01483794f, 
    0.01461102f, 0.10536551f, -0.00107516f, 0.02237209f, -0.04469195f, -0.05568723f, -0.05751053f, -0.03693257f, 
    -0.06638976f, 0.09470755f, -0.02748678f, 0.04532103f, -0.02618122f, -0.00624494f, -0.09474733f, 0.02481294f, 
    -0.14699411f, 0.02725101f, -0.08633336f, -0.06286030f, -0.21924984f, 0.09525175f, 0.03879447f, -0.07249600f, 
    0.05887243f, -0.14459512f, 0.08939612f, -0.07231721f, -0.06984544f, -0.03063298f, -0.11876573f, -0.03419236f, 
    -0.01463977f, -0.04117343f, -0.04492274f, 0.05312449f, 0.08478218f, 0.16213086f, 0.14532228f, -0.05072031f, 
    0.16154091f, -0.05213999f, 0.03499076f, 0.11406979f, -0.12366923f, 0.00262355f, -0.08954215f, -0.03130091f, 
    0.28776750f, -0.11104865f, 0.29937366f, -0.24630080f, -0.00484675f, 0.01186749f, 0.15237606f, 0.00721380f, 
    0.02319285f, 0.14570962f, 0.19760995f, 0.31636268f, -0.09918664f, -0.00618092f, -0.09802304f, -0.03737982f, 
    -0.04807946f, -0.14822550f, -0.13361409f, 0.04274772f, -0.19891576f, 0.05554616f, -0.01890921f, -0.07006148f, 
    -0.13805361f, 0.09562407f, 0.20039171f, -0.15584181f, -0.06880353f, 0.07362731f, -0.04173570f, -0.00236766f, 
    -0.06518404f, -0.11175784f, -0.01026260f, 0.08518697f, -0.07966147f, -0.06780104f, 0.08124847f, -0.02529694f, 
    -0.00664726f, -0.06029634f, -0.13635410f, -0.07616586f, -0.00997622f, 0.10251226f, -0.07303009f, 0.01639619f, 
    0.01141465f, 0.18910027f, -0.01724141f, -0.04039853f, 0.18959297f, 0.03058694f, -0.05721931f, -0.01352329f, 
    0.11633644f, -0.01092527f, 0.23922569f, 0.13799497f, -0.20412414f, -0.25442457f, -0.09128992f, -0.06900596f, 
    -0.11692593f, -0.12049035f, 0.11126222f, 0.05069571f, -0.05271869f, 0.07640098f, -0.00337109f, -0.00736128f, 
    -0.06011212f, -0.06638239f, -0.20463419f, -0.05349642f, 0.02589729f, 0.01965239f, -0.01752041f, -0.02038004f, 
    0.08624497f, -0.16220134f, -0.13027076f, -0.19566010f, 0.05528887f, -0.04978750f, -0.01111822f, -0.00843230f, 
    0.08104619f, 0.00077954f, 0.02896572f, -0.01373378f, 0.06657887f, 0.02639099f, 0.00289920f, -0.05761916f, 
    0.01779051f, -0.07966747f, 0.17428672f, -0.16117443f, -0.17747241f, -0.04633278f, 0.20133826f, 0.02617527f, 
    -0.00455337f, 0.07365021f, 0.12243202f, 0.09558589f, 0.16806059f, -0.17558119f, 0.03395163f, 0.07408658f, 
    0.20683466f, -0.04377390f, -0.06900268f, -0.13444392f, 0.11346498f, 0.04521526f, 0.04344849f, -0.13171853f, 
    0.01246146f, 0.06669112f, -0.00131083f, -0.00915396f, 0.02781507f, 0.05263085f, -0.01099466f, -0.02682365f, 
    0.07333936f, 0.23167981f, 0.17609294f, 0.18661854f, -0.09413500f, 0.32601520f, -0.17744027f, -0.02408199f, 
    0.16683066f, 0.03661174f, 0.06092717f, 0.01329578f, -0.01815441f, 0.03664425f, -0.12807314f, -0.07590693f, 
    -0.07040008f, 0.06987996f, -0.02931698f, 0.06191408f, -0.00055871f, 0.07172567f, -0.09279287f, -0.07869249f, 
    0.02427453f, 0.07098402f, 0.00462552f, -0.03239413f, 0.37722132f, 0.14447001f, 0.00393930f, -0.01462463f, 
    -0.02428172f, -0.05607683f, -0.06489617f, 0.08558393f, -0.06760123f, -0.03978624f, -0.06945641f, 0.07967114f, 
    -0.01168476f, -0.01941570f, 0.13510247f, 0.04424959f, -0.01937752f, 0.04338674f, 0.02472893f, -0.04550727f, 
    -0.06998064f, 0.04830507f, 0.01770633f, -0.04118073f, 0.20954716f, -0.06330416f, 0.10430467f, -0.09236336f, 
    -0.05359507f, -0.03415627f, -0.01765068f, 0.12099550f, 0.13601723f, 0.12410245f, 0.00244123f, -0.01425949f, 
    -0.07866286f, -0.17058943f, -0.11609463f, -0.09242062f, -0.04944546f, -0.00583004f, -0.05517667f, 0.04127709f, 
    0.01354846f, -0.01066678f, -0.08328325f, -0.17884824f, 0.03255586f, -0.01362424f, 0.03839540f, -0.05912445f, 
    -0.04607202f, -0.00795719f, 0.00854438f, -0.02686186f, 0.05583868f, -0.05640275f, 0.01955098f, -0.03416156f, 
    0.06309047f, -0.00086427f, -0.03598335f, 0.05884453f, 0.15273155f, -0.02404696f, -0.02130316f, -0.02764605f, 
    -0.05079003f, 0.06830638f, 0.01481508f, -0.04370886f, 0.10664365f, 0.06803021f, -0.23467113f, -0.17677739f, 
    -0.22297518f, -0.00129502f, -0.03000761f, 0.05956769f, 0.00188224f, 0.07714391f, 0.03659295f, 0.02853213f, 
    0.20933838f, 0.15992619f, 0.14838076f, -0.13344364f, 0.01615761f, 0.03246157f, -0.14518510f, 0.02465967f, 
    0.01918206f, 0.01301966f, 0.03033110f, -0.04753544f, -0.10849919f, -0.15300830f, 0.03828312f, -0.05192243f, 
    -0.04861389f, -0.03128256f, -0.00043750f, -0.08102506f, 0.04457244f, 0.03126200f, 0.11957213f, 0.23409478f, 
    -0.14802805f, -0.14645551f, -0.17682317f, -0.07609602f, -0.09062081f, -0.03390007f, 0.02160653f, 0.00851232f, 
    -0.04615309f, 0.04371123f, -0.00952215f, -0.01740614f, 0.05764015f, -0.02249261f, -0.00998410f, -0.03540550f, 
    -0.12580413f, -0.00953384f, -0.07709970f, -0.03664892f, -0.08323233f, -0.05184693f, 0.08172139f, 0.03566588f, 
    -0.03517488f, 0.06136123f, 0.06933512f, 0.02559494f, -0.06219135f, 0.04619289f, 0.12418555f, 0.12293988f, 
    -0.14693747f, 0.16908482f, -0.09754715f, -0.13395907f, 0.12836438f, -0.25385568f, 0.06103392f, 0.26864323f, 
    0.02820576f, -0.10810328f, 0.15170014f, 0.18070969f, 0.11054114f, -0.02883218f, 0.05030522f, 0.12149534f, 
    -0.03032711f, -0.09145568f, -0.16516247f, 0.02641886f, 0.09824020f, -0.06578710f, -0.06297179f, -0.00418817f, 
    -0.10536940f, 0.10699105f, -0.07271065f, -0.14111821f, -0.05477304f, -0.02132988f, 0.10123838f, 0.05363048f, 
    -0.02702842f, -0.04400221f, -0.01431050f, 0.19315492f, 0.05157602f, 0.23444945f, 0.18374415f, 0.18077302f, 
    -0.03692244f, -0.12631930f, -0.17026618f, -0.13650629f, -0.03373029f, -0.12838423f, 0.06022915f, 0.11647704f, 
    -0.00855558f, -0.00359108f, 0.09920634f, 0.06325636f, 0.07796983f, 0.02073718f, 0.05309537f, 0.02510154f, 
    -0.06963766f, 0.07710361f, -0.04239863f, -0.05338020f, -0.13354492f, -0.08280913f, -0.17411421f, -0.10212110f, 
    -0.12788838f, 0.05657187f, -0.09272725f, -0.04168157f, 0.04355694f, 0.02715028f, 0.06828483f, 0.04985212f, 
    -0.05476868f, -0.05052612f, 0.11385519f, 0.11693171f, -0.11668684f, 0.02453935f, -0.02302916f, 0.03666269f, 
    0.08100791f, 0.02173746f, 0.07033141f, 0.15871884f, -0.07133833f, 0.04404853f, -0.08463999f, -0.17399366f, 
    -0.23047498f, 0.03535288f, -0.10851328f, 0.01242922f, 0.01526500f, -0.09178886f, -0.00131353f, -0.02436252f, 
    -0.13713759f, 0.10810152f, 0.09745862f, -0.15737167f, -0.03158452f, 0.00558539f, -0.11278851f, -0.12951101f, 
    -0.02889178f, 0.01488126f, -0.16551252f, 0.02912963f, 0.03051732f, 0.03103069f, 0.09809654f, -0.01107510f, 
    -0.01171157f, 0.00073351f, -0.01570604f, -0.03905937f, 0.02154510f, -0.04145259f, -0.01071498f, 0.01974004f, 
    0.00122271f, -0.03790213f, -0.01135221f, -0.02052651f, -0.03743086f, -0.00478647f, -0.03988070f, -0.00015436f, 
    -0.00523698f, -0.01778616f, -0.03453096f, -0.01699173f, 0.00292057f, -0.00974956f, -0.02944578f, 0.02002325f, 
    -0.01508968f, -0.03297877f, -0.00650682f, 0.02587930f, -0.00034351f, -0.03688968f, -0.03487401f, -0.04377005f, 
    -0.01334825f, -0.01897627f, 0.02007332f, -0.03307761f, 0.02319911f, 0.02411632f, -0.03092979f, 0.01716552f, 
    -0.02333453f, 0.01259432f, 0.00005509f, -0.00518975f, -0.00789513f, -0.02561769f, -0.00310170f, 0.00355489f, 
    -0.01655374f, 0.01548864f, 0.02198104f, -0.03833122f, 0.02373048f, 0.02076752f, 0.02448234f, 0.02318911f, 
    0.02932262f, 0.00204370f, -0.03928369f, -0.02505844f, -0.00452089f, -0.02746343f, -0.00708049f, -0.01548159f, 
    -0.02650277f, 0.00126670f, 0.00985923f, 0.01091776f, -0.04270740f, 0.00003101f, -0.00132879f, 0.00555548f, 
    -0.00771083f, -0.03642477f, 0.00334864f, -0.03365332f, -0.00502033f, -0.00424983f, 0.02453086f, -0.02058361f, 
    -0.00209036f, 0.02568222f, 0.01921439f, -0.02752711f, 0.01824712f, 0.00904660f, 0.00106654f, 0.00836684f, 
    0.02075287f, 0.01031761f, 0.02960633f, 0.02015187f, 0.00377834f, -0.03180365f, -0.03213881f, -0.03911331f, 
    -0.01747929f, 0.02278865f, 0.00393372f, -0.01795566f, -0.03772622f, 0.01178628f, -0.00219487f, -0.01501428f, 
    -0.00794195f, 0.00605195f, 0.02799167f, -0.01530795f, 0.01735042f, -0.02729871f, 0.01725370f, 0.00168588f, 
    -0.00617302f, -0.01791454f, -0.00079356f, -0.01054798f, -0.03805017f, 0.00172930f, 0.01861605f, -0.01324677f, 
    0.01410118f, -0.02689510f, -0.00625599f, -0.02822732f, -0.00188312f, 0.01908321f, -0.01853481f, 0.00489874f, 
    -0.03156800f, -0.01401251f, -0.00631261f, 0.01013728f, -0.00898343f, 0.01697569f, -0.02949504f, 0.02077565f, 
    -0.02422192f, 0.01224814f, 0.00218806f, 0.00986236f, 0.01579241f, 0.02464587f, 0.01252335f, -0.01185882f, 
    0.02819353f, -0.00553954f, -0.01317135f, -0.02861862f, 0.02806641f, 0.00430537f, -0.03895282f, -0.00936745f, 
    -0.04093692f, 0.01409890f, 0.01262489f, 0.02156833f, 0.01347414f, 0.01745934f, -0.03092406f, -0.00787374f, 
    0.00375582f, -0.01090365f, -0.02745553f, -0.01582741f, -0.03515647f, 0.01242913f, -0.03696930f, 0.00649641f, 
    0.02183493f, -0.01600933f, -0.04247151f, -0.03976330f, 0.01887818f, 0.00680207f, 0.00440309f, 0.02888844f, 
    -0.02098367f, -0.03087711f, 0.02811498f, 0.01901390f, -0.03367736f, 0.00404725f, -0.02778287f, -0.04141948f, 
    -0.04273555f, 0.02785141f, 0.02142436f, -0.00013152f, -0.00676033f, 0.01859074f, 0.01658327f, -0.01803496f, 
    -0.00420329f, -0.03116653f, 0.00863748f, -0.02697476f, -0.03240218f, -0.01542839f, 0.02840072f, 0.00376262f, 
    -0.01959275f, -0.03621497f, -0.01003811f, -0.04239943f, 0.00842361f, -0.01915872f, -0.04200475f, -0.01745347f, 
    -0.04350192f, 0.00411882f, -0.04290807f, -0.02436329f, -0.02308722f, 0.02977628f, 0.00477406f, 0.02220179f, 
    0.00141993f, -0.01847207f, 0.00689430f, -0.03283762f, 0.00223370f, -0.02582601f, -0.00524068f, 0.03855922f, 
    -0.02268754f, -0.00468587f, -0.02259783f, -0.03030171f, 0.01807376f, 0.00008660f, -0.01111257f, -0.00673106f, 
    -0.02524300f, -0.00252284f, -0.03139210f, -0.01722865f, -0.03156302f, 0.00568857f, 0.01446310f, -0.00672110f, 
    -0.01388837f, 0.01825175f, -0.03714439f, -0.00844052f, -0.03324372f, 0.02096990f, -0.03407692f, 0.02676955f, 
    0.01668214f, 0.02632526f, -0.01099382f, -0.02107299f, -0.03268187f, -0.03666235f, 0.01555155f, -0.00731848f, 
    0.00424498f, -0.02144374f, 0.00926575f, 0.00667919f, -0.01273551f, 0.00219000f, -0.04115832f, -0.03530401f, 
    0.00309583f, 0.00106952f, 0.02485245f, 0.01211045f, -0.00611768f, -0.03805778f, 0.01241596f, -0.00264861f, 
    0.01432725f, -0.04250312f, 0.00357083f, 0.00198066f, -0.00151006f, 0.01754389f, -0.02870717f, -0.03339818f, 
    0.00916890f, -0.00527730f, 0.02404359f, -0.02175714f, -0.03129856f, 0.00153279f, -0.04001208f, 0.00935220f, 
    0.00823705f, -0.00774398f, -0.02437776f, -0.03009751f, -0.04155795f, -0.01029646f, -0.03011327f, -0.01417288f, 
    -0.02944846f, -0.02055501f, -0.00566956f, 0.00369291f, -0.04135245f, -0.04013745f, 0.02558767f, 0.01914355f, 
    0.02682868f, -0.01676153f, -0.02277561f, 0.01484467f, -0.02096207f, -0.01877165f, 0.02854587f, 0.02420478f, 
    -0.02276077f, 0.02535558f, 0.02207951f, 0.00987352f, -0.03333926f, 0.01336413f, 0.00565456f, -0.01854330f, 
    -0.04192736f, -0.00034811f, -0.03001466f, -0.02343335f, -0.00175083f, 0.00179399f, 0.00868460f, -0.01008892f, 
    -0.03812803f, 0.01849422f, -0.00635609f, 0.02471222f, 0.00285047f, -0.01706614f, -0.02500279f, 0.02856998f, 
    0.02106014f, 0.00629065f, -0.03890017f, -0.02514056f, -0.01643323f, -0.03404367f, -0.02820419f, 0.01757950f, 
    -0.02989715f, -0.02174859f, -0.00317165f, 0.01565825f, -0.02869656f, -0.01125937f, 0.01502645f, -0.00628964f, 
    -0.02267548f, -0.03376909f, 0.00754238f, -0.03295465f, -0.00697699f, 0.00399360f, -0.01953422f, -0.01634484f, 
    0.00737889f, -0.00457717f, 0.02719864f, -0.00030992f, -0.03133142f, 0.01697847f, -0.03311456f, -0.03333863f, 
    -0.00990375f, -0.01278087f, -0.02960130f, 0.01851108f, -0.03732190f, 0.00926777f, 0.00368795f, -0.04303002f, 
    -0.01798533f, 0.02841557f, 0.00964865f, -0.04237540f, -0.02809917f, -0.02895064f, -0.03613956f, -0.02574642f, 
    -0.03827103f, 0.02178429f, 0.02293317f, 0.00707581f, 0.01197590f, 0.01300848f, -0.01582720f, -0.04212265f, 
    -0.01067119f, -0.01339068f, -0.01350514f, -0.01031443f, -0.02969025f, -0.04113538f, -0.03362140f, -0.04130448f, 
    0.02512073f, 0.02799962f, 0.00426951f, -0.02075251f, -0.03300925f, 0.01417564f, 0.00990871f, -0.03454731f, 
    -0.02072200f, 0.01424185f, -0.04103056f, -0.03969585f, 0.02146039f, 0.02421285f, -0.02643380f, 0.00926251f, 
    -0.01529294f, 0.00233293f, 0.01759081f, -0.01698999f, 0.02530377f, -0.00861483f, -0.03676540f, -0.02376507f, 
    0.01101948f, -0.00131723f, 0.02162194f, 0.01955180f, 0.01860631f, -0.03972695f, 0.02236329f, 0.02425669f, 
    -0.02458627f, 0.02706910f, 0.01932985f, -0.00053995f, -0.03844346f, -0.04168021f, -0.02582169f, 0.02219381f, 
    0.02477567f, 0.00679991f, -0.00240824f, -0.03640397f, 0.01892602f, 0.00492489f, -0.03470528f, -0.02342734f, 
    -0.01135925f, 0.00455188f, 0.00184578f, -0.01547096f, 0.01647852f, -0.02678243f, -0.02035939f, 0.02384643f, 
    -0.04271198f, -0.03043314f, -0.02186297f, -0.01450097f, 0.00163849f, 0.00969339f, -0.03492242f, 0.00079413f, 
    0.01030552f, -0.00535212f, 0.01235847f, -0.02224515f, -0.03999611f, -0.03170401f, 0.01749252f, -0.03583468f, 
    0.00047247f, -0.00671282f, -0.03250841f, -0.04125459f, -0.03293548f, 0.00817682f, -0.02076496f, 0.01183293f, 
    0.01276588f, -0.03306859f, -0.03930449f, 0.01296220f, 0.01624437f, -0.00402274f, -0.02225679f, 0.01437867f, 
    0.00798063f, -0.02776751f, -0.04226625f, 0.01868650f, -0.01592931f, -0.01945894f, -0.03530810f, -0.02506345f, 
    0.00585046f, -0.02530815f, 0.00204157f, -0.01689945f, -0.03045057f, -0.01873370f, -0.01797363f, -0.02134601f, 
    0.01414451f, -0.03194068f, 0.02332198f, -0.02933117f, 0.02811925f, 0.02765817f, 0.00958500f, -0.01067531f, 
    0.01528613f, -0.03795763f, 0.01282267f, -0.02335108f, -0.02682249f, 0.01085658f, 0.00891711f, -0.00859353f, 
    -0.01582384f, 0.02264183f, 0.01685327f, -0.00897940f, 0.01436534f, 0.01524969f, -0.03875487f, 0.01940598f, 
    -0.00760255f, 0.01499297f, -0.02040736f, -0.02313973f, -0.01120328f, -0.01751742f, -0.01883198f, 0.01467494f, 
    -0.00592199f, 0.00786223f, 0.01972149f, -0.01066023f, 0.00781612f, 0.00111844f, -0.02605435f, 0.00158156f, 
    0.01972938f, 0.00286768f, -0.03970360f, -0.03615486f, 0.02073465f, 0.02433560f, -0.03801761f, 0.00108432f, 
    0.00428037f, 0.00613460f, 0.02007063f, -0.03601301f, -0.00630230f, 0.00713183f, 0.00066916f, -0.02452041f, 
    -0.00636193f, -0.03804564f, 0.01428812f, -0.02618163f, 0.00523915f, -0.02579170f, 0.01620385f, -0.03754704f, 
    -0.03265913f, -0.02570138f, 0.00447935f, -0.01482231f, -0.02908281f, -0.03888693f, -0.01864261f, 0.01106534f, 
    0.02205381f, 0.00335709f, -0.02654624f, 0.01914068f, -0.02587331f, -0.03182988f, -0.01089171f, 0.00314234f, 
    -0.00655391f, 0.00130472f, -0.01267682f, 0.01831436f, -0.01687325f, 0.00144537f, -0.02844226f, 0.02370696f, 
    -0.02361133f, 0.02408756f, 0.02830344f, -0.04422666f, 0.02532621f, 0.02714773f, 0.02674496f, 0.01125256f, 
    0.02723028f, 0.01881725f, -0.01885796f, -0.01277460f, 0.02174238f, -0.01838695f, -0.00292355f, -0.01921964f, 
    0.00637876f, 0.00139543f, 0.00658102f, -0.02088157f, -0.00014655f, -0.03900201f, 0.00275268f, -0.01231740f, 
    -0.03730074f, -0.00017520f, -0.01413812f, -0.01736086f, -0.01015043f, 0.02016233f, 0.01932444f, -0.01214538f, 
    -0.03863281f, 0.02117022f, -0.00456185f, -0.03417116f, 0.01445854f, -0.03626147f, 0.02441114f, -0.00035158f, 
    0.01740886f, 0.01323167f, 0.01684949f, -0.03397517f, 0.01756661f, -0.04317125f, 0.00050766f, -0.03422928f, 
    -0.01747697f, 0.02612052f, 0.02577216f, -0.03869915f, 0.00796347f, 0.01810142f, -0.02545820f, -0.03819161f, 
    0.01652483f, 0.01537095f, -0.04053452f, 0.01272043f, 0.01902770f, -0.03399676f, -0.01600181f, -0.03389066f, 
    0.02119918f, -0.03090026f, -0.01354878f, 0.02516634f, 0.00579973f, -0.03854874f, -0.00637573f, -0.04043538f, 
    -0.03842903f, -0.00761407f, -0.01257547f, -0.00646127f, -0.02691073f, -0.02895382f, 0.02619752f, 0.01510143f, 
    0.01028618f, -0.01937172f, -0.00109153f, -0.03020530f, 0.02517016f, -0.04067828f, -0.01246281f, 0.00347791f, 
    -0.03413983f, 0.00124108f, -0.04108115f, 0.01541970f, -0.00833627f, 0.00387329f, -0.00627724f, -0.03314845f, 
    -0.00452332f, -0.03368227f, -0.03497632f, -0.03887848f, -0.04070847f, 0.02115074f, -0.02274558f, 0.02615348f, 
    -0.03344791f, -0.02556022f, -0.04199238f, 0.00011678f, -0.00812790f, -0.01917070f, 0.00141947f, 0.00907003f, 
    0.00003407f, 0.01291944f, -0.03303751f, -0.03747049f, 0.00773697f, 0.00778029f, -0.01214530f, -0.03433827f, 
    -0.02452040f, 0.02188857f, -0.00410850f, 0.01208858f, -0.02354448f, -0.04301312f, -0.01708500f, 0.01791591f, 
    -0.02133243f, 0.00492473f, -0.02259533f, 0.02558748f, 0.01302158f, 0.02556999f, -0.02557854f, -0.01600757f, 
    0.02285584f, 0.02241701f, -0.03045989f, -0.02850188f, -0.02740802f, -0.01439160f, 0.00627637f, 0.01054290f, 
    0.01502250f, -0.00578031f, -0.00104443f, -0.03304606f, -0.02533390f, -0.02173832f, -0.03091342f, -0.04159808f, 
    -0.00593626f, -0.04199781f, -0.00916333f, -0.02620894f, 0.01565256f, -0.02783048f, -0.02832490f, -0.02154704f, 
    0.00473579f, 0.00436397f, 0.01376908f, 0.00383083f, -0.02777207f, 0.02073301f, -0.02253832f, -0.03250935f, 
    0.02474696f, -0.01810407f, -0.01922235f, -0.03946918f, -0.01009807f, -0.02196529f, -0.01726395f, -0.01734712f, 
    -0.00717319f, -0.01179160f, -0.01480219f, -0.03222452f, -0.02476663f, -0.01170433f, 0.01823050f, 0.01149364f, 
    -0.03764195f, 0.01122114f, -0.02093889f, 0.01163268f, -0.02279961f, 0.02237022f, 0.00934017f, 0.02153679f, 
    -0.01085737f, 0.02434355f, 0.00455151f, -0.02840935f, 0.01332420f, 0.00291907f, 0.02057772f, 0.02842975f, 
    -0.04162279f, 0.00229179f, 0.01818459f, -0.02674950f, -0.01644934f, 0.00979031f, -0.00663370f, -0.02613592f, 
    0.00409278f, -0.01440718f, 0.02129267f, 0.02335507f, 0.01667194f, -0.03019699f, -0.01038659f, 0.00533570f, 
    0.01120133f, -0.04104057f, 0.02494231f, 0.01771466f, -0.02792457f, -0.00886687f, -0.00191495f, -0.01147732f, 
    -0.02610106f, -0.03404928f, -0.00103977f, 0.01399591f, 0.02623486f, -0.04331403f, 0.02122222f, -0.03687954f, 
    -0.01684793f, 0.00448639f, 0.00449191f, -0.02403235f, 0.00998694f, -0.03870885f, -0.02691800f, -0.02882647f, 
    -0.02978889f, 0.00795786f, -0.02670717f, -0.03459320f, 0.01803381f, -0.01472527f, -0.00264559f, -0.03855211f, 
    -0.01420809f, -0.00025299f, 0.01025119f, -0.02548349f, -0.02460195f, -0.01385273f, 0.01714673f, -0.03526495f, 
    -0.03821123f, 0.00548234f, -0.00632393f, -0.03065650f, -0.02885081f, 0.00239526f, -0.03549977f, 0.01601406f, 
    0.02275324f, 0.00327381f, 0.01235256f, 0.00200313f, -0.02866940f, -0.02079472f, -0.00875528f, 0.00692079f, 
    -0.04016836f, -0.00314038f, 0.00613541f, -0.02562027f, 0.00481969f, -0.02723979f, -0.02548846f, -0.02205242f, 
    -0.03052146f, -0.02582186f, -0.01612423f, 0.02828726f, -0.02853667f, 0.02649174f, 0.00764314f, 0.02242165f, 
    0.01919925f, -0.00853738f, 0.01568989f, 0.00324244f, -0.03389295f, -0.03044252f, 0.02320154f, -0.03671514f, 
    0.00953345f, 0.02185460f, 0.00698698f, -0.01327628f, -0.02673830f, -0.00241905f, -0.02472350f, -0.01887857f, 
    0.01669285f, 0.00429618f, 0.00652391f, 0.01172112f, 0.00308967f, 0.00852181f, 0.00125366f, 0.01583264f, 
    -0.00409633f, 0.02823727f, -0.00527752f, -0.01880808f, -0.04216385f, 0.02347717f, 0.02408205f, 0.00721003f, 
    -0.03235982f, -0.01279952f, 0.00103775f, -0.01779424f, -0.03176177f, -0.02172211f, -0.02928381f, 0.02474803f, 
    -0.03337216f, -0.02086410f, -0.03545076f, -0.00742948f, -0.02624114f, 0.01087875f, -0.02651041f, -0.00020474f, 
    0.02302179f, 0.00869580f, -0.00156911f, -0.01694885f, -0.02014472f, -0.03398688f, 0.02504696f, -0.01548261f, 
    -0.01342870f, 0.01470850f, -0.03865235f, 0.01775325f, 0.00503993f, -0.02481491f, -0.02836496f, 0.02050073f, 
    0.02547883f, -0.04392624f, -0.04004629f, 0.02382151f, 0.00085040f, -0.00155686f, -0.02467172f, -0.02046034f, 
    -0.03643139f, -0.00834341f, -0.03912190f, -0.02164833f, 0.01364277f, -0.00606096f, 0.00031597f, -0.03194281f, 
    -0.02855538f, -0.00468200f, -0.00084686f, -0.00658850f, 0.00303630f, 0.00568036f, -0.00483224f, 0.02454185f, 
    -0.03639349f, -0.03632690f, -0.00114730f, -0.04184589f, 0.02026241f, -0.02988779f, 0.02029199f, -0.01671419f, 
    0.00034867f, 0.00867220f, 0.00459078f, 0.02469055f, -0.02653010f, -0.00523414f, 0.01658901f, -0.03767971f, 
    0.02439283f, 0.01906856f, 0.00363942f, 0.02315614f, -0.00306524f, -0.02749750f, -0.02938204f, -0.00786847f, 
    0.01169370f, -0.01036323f, 0.01801411f, -0.02629487f, 0.01247210f, -0.04148562f, 0.02234190f, 0.02438364f, 
    0.00247379f, -0.03857881f, -0.03515561f, -0.03046998f, -0.00390057f, -0.02237337f, -0.03159147f, 0.00740817f, 
    -0.00331220f, -0.02737912f, 0.02696666f, -0.01103224f, -0.01031359f, -0.01569776f, -0.00774606f, -0.02799881f, 
    0.00917494f, -0.04220312f, 0.01666345f, -0.01274269f, 0.01809598f, 0.02351460f, -0.00730506f, 0.01728386f, 
    0.00929977f, -0.00680772f, 0.02073964f, -0.01867586f, 0.01484469f, 0.01085602f, -0.00613190f, -0.03649804f, 
    -0.02488165f, 0.03833678f, -0.01386895f, -0.00548172f, -0.00707169f, -0.03328961f, 0.00137798f, 0.00958782f, 
    -0.00065931f, -0.03615755f, -0.01002419f, -0.02368134f, 0.02271062f, 0.02360790f, -0.00060598f, -0.04075867f, 
    0.02373265f, 0.01080705f, -0.03579735f, -0.02122347f, -0.03030554f, 0.02065557f, 0.00590175f, -0.03424772f, 
    -0.02684043f, -0.03927821f, -0.02258033f, 0.01278182f, -0.00378000f, -0.02363092f, -0.00818308f, -0.02210552f, 
    -0.02135657f, -0.04255677f, -0.03309725f, -0.02091330f, -0.02147498f, 0.01382994f, -0.03691819f, -0.03164363f, 
    0.02280318f, -0.02994093f, -0.01390824f, -0.04078422f, -0.01801996f, -0.01790544f, -0.03046340f, -0.01900762f, 
    -0.02009539f, -0.03668959f, -0.00386673f, -0.00600352f, 0.00748294f, 0.01221612f, 0.00768621f, -0.01629931f, 
    0.00529213f, -0.00325653f, -0.03489964f, -0.00607214f, -0.00429698f, -0.04207164f, -0.02130275f, -0.00452801f, 
    0.02541174f, -0.01359550f, 0.02711159f, 0.01713221f, -0.02865587f, -0.01261850f, -0.03008113f, -0.04409179f, 
    0.01008011f, -0.01579366f, -0.02894910f, -0.00473342f, 0.01451169f, 0.00132598f, 0.03057368f, 0.01066385f, 
    0.01909153f, 0.00550612f, 0.02483725f, 0.00165539f, -0.02606056f, -0.02925168f, -0.02282959f, -0.02681880f, 
    -0.01978805f, 0.02378828f, -0.01605203f, -0.00626188f, 0.01009431f, -0.03061402f, -0.00263307f, -0.01040347f, 
    0.01216554f, -0.03432308f, -0.01395634f, 0.00221650f, 0.02423284f, -0.01598959f, 0.02917247f, -0.02087840f, 
    -0.00788797f, 0.01384054f, -0.03801410f, -0.00362753f, -0.02447711f, 0.01367028f, -0.00039599f, 0.00930960f, 
    0.01062612f, -0.02223574f, -0.01684920f, -0.01024864f, 0.01314877f, -0.04124296f, -0.00756996f, 0.00903668f, 
    0.00408088f, 0.00318384f, -0.01428917f, -0.01131151f, -0.01610082f, 0.01349247f, 0.00656593f, 0.02441621f, 
    0.01316039f, -0.03702785f, 0.01359799f, 0.00569779f, -0.00580757f, -0.02968557f, -0.03632467f, -0.02186580f, 
    -0.02103346f, -0.00397884f, -0.01490940f, -0.00200888f, 0.02136550f, 0.01733824f, 0.01791226f, 0.02542671f, 
    0.00195608f, 0.00839969f, -0.02468417f, -0.00059261f, -0.01988934f, -0.04198800f, 0.01970447f, 0.01781712f, 
    -0.00055068f, -0.03940314f, 0.02034058f, -0.03841739f, -0.02569547f, 0.00217280f, 0.02791617f, 0.02479259f, 
    -0.01493391f, 0.01387323f, 0.01284844f, -0.02424136f, 0.01446030f, -0.04218807f, 0.00886059f, 0.00611774f, 
    -0.01556974f, -0.03812036f, 0.01002196f, 0.00408159f, -0.01514617f, 0.00790808f, -0.00190140f, -0.03156461f, 
    -0.00248546f, -0.02353489f, -0.03764215f, -0.03616701f, -0.01095963f, 0.01633519f, -0.02755615f, -0.00910669f, 
    -0.03544117f, -0.00475195f, -0.01760874f, 0.00061425f, -0.00113566f, -0.04284123f, -0.03587272f, 0.01605718f, 
    -0.03000290f, -0.02190875f, 0.01761902f, 0.00342253f, 0.02712427f, 0.01896642f, -0.02763431f, -0.00793130f, 
    -0.00235561f, -0.02078466f, 0.00968061f, 0.00386967f, -0.03072018f, -0.04212314f, -0.00333683f, 0.02147108f, 
    0.03401235f, -0.03451364f, 0.01586044f, 0.02738543f, 0.02180461f, -0.00754297f, 0.00277029f, 0.00303339f, 
    0.01243495f, 0.02388516f, 0.01360286f, -0.01880459f, -0.00468787f, -0.04253100f, 0.00833498f, -0.02950537f, 
    -0.02911985f, -0.01513887f, -0.00586537f, -0.01691372f, -0.01509609f, 0.00549139f, -0.00670283f, -0.00288319f, 
    0.01341927f, -0.02199459f, -0.01484809f, 0.01874131f, 0.02689059f, -0.02796326f, -0.00738446f, 0.02089237f, 
    -0.00109588f, -0.00214373f, 0.00156360f, -0.03777958f, 0.01440084f, -0.02258941f, -0.04059772f, 0.01974434f, 
    -0.01137307f, -0.01833186f, -0.01428709f, -0.01003371f, 0.02574021f, 0.01946567f, 0.02635941f, 0.00206185f, 
    -0.04149648f, -0.03585099f, -0.00079509f, -0.03222544f, 0.00375419f, -0.00970090f, -0.03526309f, 0.01585061f, 
    -0.02509966f, 0.02161074f, 0.01175517f, 0.01522164f, 0.01183731f, 0.02071575f, 0.02569158f, 0.00200769f, 
    -0.03204377f, 0.02113974f, -0.02518737f, -0.03636865f, -0.03475471f, 0.01534169f, -0.03804456f, -0.04201161f, 
    0.02022374f, -0.03020872f, -0.01831535f, 0.00418201f, 0.01752187f, -0.03117408f, 0.00569493f, -0.01281753f, 
    0.00139292f, -0.03284209f, -0.03406082f, 0.01150487f, -0.03264337f, -0.03909473f, -0.03498923f, -0.04342693f, 
    -0.00137445f, 0.02361642f, -0.03732997f, -0.02312409f, 0.00719159f, 0.02401686f, -0.02599706f, -0.01976379f, 
    -0.02307948f, -0.02853130f, 0.00251333f, -0.04242010f, -0.00746112f, -0.00385090f, 0.01660164f, -0.04055557f, 
    -0.03980229f, -0.01742009f, 0.01525325f, -0.01993131f, 0.01622107f, -0.03133631f, -0.03947312f, -0.03917486f, 
    -0.02168180f, 0.02126075f, -0.01096065f, -0.00069651f, -0.02386311f, 0.01403908f, 0.00528524f, -0.00775559f, 
    0.02005165f, 0.00814274f, 0.01970046f, -0.00387278f, -0.03598348f, -0.04253171f, -0.02273067f, -0.01497284f, 
    0.03974472f, -0.02132347f, 0.00615555f, -0.00712510f, 0.02650979f, -0.02093100f, 0.01407400f, 0.01006631f, 
    0.02273336f, 0.01865622f, -0.02640052f, -0.02215221f, 0.02324420f, -0.03200483f, 0.00146661f, -0.00948377f, 
    0.02632196f, -0.00195355f, 0.01263944f, 0.00360908f, -0.01058932f, -0.04250255f, 0.01290715f, -0.00169159f, 
    0.01983145f, 0.00096347f, 0.01258128f, -0.02820309f, -0.03713324f, -0.03178360f, -0.00688460f, 0.00172840f, 
    -0.00358832f, 0.01494616f, 0.01777508f, 0.01575965f, -0.02454416f, -0.02196340f, -0.00921408f, -0.00417064f, 
    -0.03133911f, 0.03262438f, 0.02817895f, 0.01692681f, -0.01864714f, -0.01818137f, -0.03385553f, -0.02843511f, 
    -0.00908723f, 0.01437744f, -0.04170497f, 0.02186128f, -0.01179511f, 0.02263008f, -0.03623866f, -0.03302466f, 
    -0.01210143f, 0.02283756f, -0.00609248f, -0.03609155f, 0.00523394f, 0.02300650f, 0.00807747f, -0.04281805f, 
    -0.02437702f, -0.03736204f, -0.01300614f, -0.01101387f, 0.02081225f, 0.00381443f, -0.00353914f, -0.00670505f, 
    0.00814725f, 0.02865305f, -0.02983859f, -0.00193390f, 0.00001214f, 0.00386461f, -0.00276249f, -0.01505072f, 
    0.00419064f, 0.00585492f, 0.00471776f, 0.02715224f, -0.03958414f, 0.00844102f, -0.02142459f, -0.02700563f, 
    0.00220615f, 0.02300737f, -0.02827353f, 0.00732489f, -0.03346614f, -0.01562488f, 0.01674695f, -0.00558058f, 
    -0.02652026f, 0.02432075f, -0.01524786f, -0.01202947f, -0.02202568f, -0.03752531f, 0.02480169f, 0.02134290f, 
    -0.01235149f, 0.02046538f, 0.00332024f, -0.03384490f, -0.00668233f, 0.01890762f, 0.00344213f, 0.02615835f, 
    0.01126194f, -0.02056703f, -0.03957176f, 0.00540559f, 0.01390172f, 0.01623493f, -0.00995998f, -0.00529284f, 
    -0.01857855f, 0.02863391f, 0.02135638f, 0.00692260f, 0.02241990f, -0.01300851f, 0.01559176f, -0.01325074f, 
    -0.02300477f, -0.00237662f, -0.02190955f, 0.01907052f, -0.00865307f, -0.02146941f, -0.02039627f, -0.00927092f, 
    -0.01402981f, 0.00390160f, -0.04354232f, -0.00912370f, 0.01710757f, -0.01385255f, -0.00270888f, -0.02975966f, 
    0.02460187f, 0.02084431f, -0.02174286f, -0.01228329f, -0.01165432f, 0.02365583f, -0.04378786f, 0.00864300f, 
    0.02475745f, 0.00761592f, -0.00722352f, -0.00314956f, -0.01110513f, 0.00440544f, -0.01274983f, -0.02839121f, 
    0.01365153f, -0.00996499f, 0.00269962f, 0.01615579f, 0.02827956f, -0.00858325f, -0.02206175f, -0.00409171f, 
    -0.36231619f, -0.11880853f, 0.07875477f, -0.00942433f, -0.01989225f, -0.05662832f, 0.03943621f, -0.02576777f, 
    -0.01115599f, 0.03442938f, 0.01738694f, 0.02111145f, -0.02432701f, -0.04973488f, -0.05071719f, 0.01390548f, 
    -0.04649201f, 0.04542567f, -0.09706765f, -0.05224226f, 0.02735209f, -0.00928877f, 0.02249937f, 0.05504080f, 
    -0.20404263f, -0.12238006f, 0.15367919f, 0.02976073f, -0.13161451f, 0.11507383f, -0.02721209f, -0.10157319f, 
    0.12478099f, -0.02786209f, -0.03024505f, -0.05698955f, 0.03347089f, 0.16257347f, -0.19245802f, -0.00595843f, 
    0.07142733f, -0.02673831f, 0.09697973f, -0.01576023f, -0.03179722f, 0.10348597f, 0.00169862f, -0.00797203f, 
    0.11975311f, -0.18959139f, 0.14611572f, 0.14953505f, 0.12639692f, -0.11545652f, 0.16453630f, 0.04581699f, 
    0.01273477f, 0.14915095f, -0.08706132f, 0.04566627f, 0.04590305f, -0.13167308f, -0.03309507f, -0.19439790f, 
    -0.02461259f, -0.02724008f, 0.04040318f, 0.10138293f, -0.01395477f, -0.00824521f, -0.12399259f, -0.06628363f, 
    0.24748349f, -0.00857932f, -0.12198527f, -0.02156790f, 0.11303910f, 0.09432036f, -0.00340901f, 0.07434935f, 
    -0.01753146f, -0.11283674f, 0.00573798f, -0.01998282f, 0.18668622f, 0.02438704f, 0.34603715f, 0.05462564f, 
    -0.05397565f, -0.07757255f, -0.09123852f, -0.02419088f, 0.03864671f, -0.03058440f, -0.13258128f, 0.06932312f, 
    0.11934702f, 0.14091945f, 0.22247303f, 0.10061134f, -0.01239289f, -0.01132265f, -0.00934915f, 0.02387901f, 
    0.04236184f, -0.03339104f, -0.13165689f, -0.09590081f, -0.00869086f, 0.01377551f, -0.13842134f, 0.00237976f, 
    0.00869929f, 0.03318980f, -0.03449575f, 0.10093765f, 0.12007182f, 0.10364062f, 0.00297644f, -0.09598047f, 
    0.01496460f, -0.15504260f, 0.12625228f, -0.05057914f, 0.11803769f, -0.17719252f, 0.21284813f, 0.04317280f, 
    0.12971672f, 0.07842905f, 0.09206580f, 0.04219321f, 0.18340629f, 0.06832290f, 0.06586120f, 0.16102372f, 
    0.01797181f, -0.04027063f, 0.05802139f, 0.01731010f, 0.24404588f, 0.22427559f, 0.00275187f, 0.09850772f, 
    -0.09232938f, 0.20098962f, 0.13728294f, 0.07637469f, -0.04032287f, 0.05727628f, 0.11979840f, -0.09358565f, 
    -0.09745898f, 0.18288006f, -0.10975611f, 0.01351953f, 0.05949445f, 0.36629900f, -0.22985332f, 0.11036238f, 
    -0.05601530f, -0.01634204f, 0.25637564f, 0.03832377f, 0.12695980f, -0.03288798f, 0.07040142f, -0.11381721f, 
    -0.00231211f, -0.12227607f, 0.08573949f, -0.11498430f, -0.07285362f, -0.04271687f, -0.12288922f, -0.00590819f, 
    -0.05141928f, 0.04750029f, 0.01783192f, -0.05081489f, 0.09018485f, 0.27869350f, -0.05384400f, -0.08796243f, 
    0.08164276f, -0.03419203f, 0.22568417f, -0.05280926f, 0.08098412f, 0.14003699f, 0.04822900f, 0.12307879f, 
    0.27803978f, 0.01983818f, 0.12515432f, 0.06486225f, -0.06223863f, -0.05447779f, -0.03444328f, 0.00521211f, 
    -0.03408926f, -0.09343560f, 0.08468314f, -0.03370854f, 0.03934612f, 0.00461946f, -0.01733703f, 0.01525891f, 
    0.08369093f, 0.15918326f, 0.14713909f, 0.21609935f, -0.09012347f, -0.08669049f, 0.05549765f, -0.09130907f, 
    0.04333216f, -0.01068423f, 0.02948093f, -0.01392027f, 0.09734166f, 0.02675287f, 0.02264973f, -0.08495026f, 
    -0.04817501f, 0.04385159f, -0.01600097f, -0.08568373f, 0.16544320f, -0.18839078f, 0.03391682f, -0.29541287f, 
    0.02018594f, -0.02529390f, 0.04268553f, 0.06709420f, 0.11350587f, 0.22610244f, -0.00076915f, -0.03401659f, 
    -0.03893068f, -0.12952296f, -0.02986922f, -0.02364401f, 0.07137407f, 0.03162470f, 0.13795750f, 0.12348574f, 
    0.01002467f, 0.02407343f, -0.02307403f, 0.00684787f, -0.15719029f, 0.01801100f, -0.09727358f, 0.04493301f, 
    0.10248680f, 0.02696121f, 0.01799410f, -0.08244727f, 0.13980336f, 0.04599617f, 0.09250200f, -0.00726483f, 
    0.01810587f, -0.02696412f, 0.13081121f, 0.05107353f, 0.00205657f, 0.01216894f, 0.00948195f, -0.10863172f, 
    -0.01801964f, -0.09185415f, 0.00800286f, -0.01833469f, -0.31434390f, 0.42801976f, -0.33484313f, 0.07028227f, 
    -0.05395776f, -0.06467238f, 0.09209914f, 0.06794918f, 0.04310920f, 0.07999949f, -0.03859137f, 0.09477281f, 
    0.21542877f, 0.08501839f, 0.10319778f, 0.11936253f, 0.03455944f, 0.05075546f, -0.00805029f, -0.02147934f, 
    0.12929672f, 0.11994995f, 0.08937733f, 0.12152210f, 0.37315512f, 0.14303982f, -0.12446754f, 0.14166065f, 
    -0.00345541f, -0.01497862f, -0.17378876f, -0.12222444f, -0.10864860f, 0.06610242f, 0.06236013f, 0.01583445f, 
    0.21237609f, -0.05467330f, -0.01897109f, -0.05909254f, -0.08609484f, -0.05176999f, -0.01978798f, -0.05783860f, 
    0.12954260f, 0.01460706f, 0.15911205f, 0.01078934f, 0.34828064f, 0.19850129f, 0.15230812f, 0.15897606f, 
    -0.00059542f, 0.05759310f, -0.00336058f, -0.01213983f, 0.08682650f, 0.06639218f, -0.01528672f, 0.02899432f, 
    0.27589983f, 0.03388738f, -0.00271875f, -0.08790411f, -0.05377969f, -0.05938466f, -0.20598479f, 0.06815013f, 
    -0.02499422f, -0.06568385f, 0.04096008f, -0.15192273f, 0.04345708f, 0.06465437f, -0.16116138f, 0.02922741f, 
    0.04755818f, 0.01586658f, -0.01244585f, -0.17193940f, -0.00183288f, 0.03862722f, -0.00305645f, 0.07721327f, 
    -0.49666640f, 0.30945349f, -0.40760353f, 0.25889978f, -0.08155398f, -0.10972747f, 0.08756299f, -0.15887627f, 
    0.07130873f, 0.05766210f, -0.09761985f, 0.20851392f, -0.18324862f, -0.25609344f, -0.09588303f, -0.41322449f, 
    -0.00779208f, -0.28989363f, -0.09001438f, -0.02119945f, -0.06339858f, 0.04073989f, 0.06950005f, 0.00156131f, 
    -0.12343927f, 0.23866017f, -0.28199387f, -0.19851342f, -0.16663300f, -0.03880280f, 0.11828284f, 0.02673211f, 
    0.03255989f, 0.10073231f, 0.10013548f, 0.13893466f, 0.02565417f, -0.19183053f, 0.09420078f, -0.04026141f, 
    -0.03345416f, 0.04456301f, -0.09527063f, -0.07170290f, 0.06117890f, -0.00732330f, -0.03146030f, 0.04599630f, 
    0.30970323f, -0.10749152f, 0.11420467f, 0.00619199f, 0.08352291f, 0.15284662f, -0.22668223f, -0.10709508f, 
    0.02142701f, -0.13490693f, -0.13387464f, 0.09515425f, -0.18160890f, -0.04399696f, 0.16712512f, -0.06007616f, 
    0.12070838f, 0.08252250f, -0.01594322f, 0.11793048f, 0.06223748f, -0.17486338f, 0.11915428f, 0.06395740f, 
    0.06920796f, -0.02280959f, 0.09347751f, 0.07264490f, -0.04907578f, -0.01956773f, 0.12951425f, 0.14647701f, 
    -0.06800774f, -0.12292930f, -0.09603421f, -0.03188210f, -0.02948913f, -0.26502731f, -0.20866893f, -0.26944315f, 
    0.08320989f, 0.01381658f, 0.05353446f, -0.03259949f, -0.00516363f, -0.04383270f, -0.08788610f, -0.15918274f, 
    0.03145119f, -0.28942576f, -0.01783234f, -0.30633056f, -0.17626053f, -0.19788574f, 0.08192485f, -0.10238261f, 
    -0.15414074f, -0.13070753f, 0.02034991f, -0.05711628f, 0.14754865f, -0.03983703f, 0.13395721f, -0.04115777f, 
    0.06806913f, -0.08328605f, -0.02747878f, -0.10245312f, -0.09921656f, -0.02793341f, 0.06452294f, -0.17504194f, 
    -0.23568581f, -0.32196829f, -0.00212770f, -0.25028872f, -0.02844299f, -0.00613720f, -0.06962357f, 0.04887084f, 
    0.18942329f, 0.14124891f, 0.00280236f, 0.17158303f, 0.08557168f, -0.11183862f, 0.05736279f, 0.01052171f, 
    0.05182833f, 0.03766688f, 0.02707654f, -0.05595614f, 0.08840965f, 0.11794798f, -0.02820517f, 0.02152386f, 
    0.26615736f, 0.17874606f, 0.14640467f, 0.02187106f, -0.06007076f, 0.02272355f, -0.04452223f, -0.10683384f, 
    -0.15199238f, -0.04179119f, -0.08356716f, -0.15293743f, 0.28967825f, 0.29876649f, -0.41119644f, 0.09605789f, 
    0.01523755f, -0.08024422f, 0.03974448f, 0.22715963f, 0.02713664f, -0.05384349f, 0.05450836f, -0.01039180f, 
    0.13915363f, -0.12465995f, 0.10623906f, -0.38126144f, 0.05570541f, -0.02840666f, 0.10485585f, 0.06677617f, 
    -0.05402710f, 0.18726699f, 0.10578072f, -0.13029674f, 0.02683741f, -0.01527781f, 0.01020051f, 0.02147750f, 
    -0.01113188f, -0.10489254f, 0.12169506f, 0.14031783f, 0.07818275f, 0.18128359f, 0.30344698f, 0.18934114f, 
    -0.41185117f, -0.23715447f, -0.25730690f, -0.29992068f, -0.01223980f, 0.05648757f, -0.09497970f, 0.06203511f, 
    -0.00763396f, -0.05618802f, 0.05040910f, -0.01429359f, 0.15050194f, 0.10207646f, 0.12084215f, 0.12657858f, 
    -0.02199863f, -0.02482849f, 0.04883213f, -0.01467184f, -0.01492230f, -0.01587124f, -0.15703654f, -0.07134403f, 
    -0.15989110f, 0.24369575f, 0.02968439f, 0.22041114f, -0.02616217f, 0.01871969f, 0.09982800f, -0.00028503f, 
    0.08868047f, 0.11095040f, 0.07157516f, -0.10259571f, -0.00130709f, -0.34689844f, -0.47298044f, -0.48212239f, 
    -0.26364133f, -0.20603897f, -0.20909473f, 0.01779986f, -0.05206230f, -0.00692726f, 0.02346223f, 0.02113311f, 
    0.27271625f, 0.19217557f, 0.12847918f, 0.21729846f, 0.04039678f, 0.01758973f, 0.01518453f, 0.04329966f, 
    0.12014446f, 0.04668606f, 0.02015312f, -0.01669556f, 0.05756484f, -0.18793914f, -0.21827072f, -0.46314207f, 
    -0.08049478f, -0.04747039f, -0.11125885f, -0.07707239f, -0.07437287f, 0.09730154f, 0.17483222f, 0.07048952f, 
    -0.14660177f, 0.20411715f, -0.11073071f, 0.20512708f, -0.00180478f, 0.02142877f, 0.05883570f, -0.06546518f, 
    -0.04243274f, -0.01115742f, -0.05105197f, -0.06155676f, 0.18063161f, 0.12726973f, 0.10583463f, 0.11999726f, 
    0.00952595f, -0.00137684f, -0.01039523f, -0.03970710f, 0.18565267f, 0.12380333f, 0.03701010f, -0.17481001f, 
    0.37953940f, 0.22155866f, 0.18275790f, -0.03176644f, -0.05937201f, 0.09788454f, 0.08546104f, 0.07407325f, 
    0.13194811f, -0.05711599f, 0.02570892f, 0.08691252f, -0.01403563f, 0.05526403f, -0.14320990f, -0.14047459f, 
    0.05902919f, -0.00401878f, 0.24470948f, -0.14393890f, 0.13033885f, 0.08851332f, 0.08767350f, -0.05462760f, 
    0.19034393f, 0.23526517f, 0.08672561f, 0.23925625f, -0.03569964f, 0.07292203f, 0.05750721f, -0.04279776f, 
    0.01787518f, -0.07223444f, -0.00858686f, -0.16223176f, -0.09805841f, 0.00662271f, -0.05109340f, -0.00584379f, 
    0.00218848f, -0.17614354f, -0.03447114f, 0.03691231f, -0.02300292f, 0.06492539f, -0.04294523f, 0.06032318f, 
    -0.21452114f, -0.07200041f, 0.12421854f, -0.16763297f, -0.09638332f, -0.10439809f, -0.05871752f, 0.10943566f, 
    -0.00071608f, -0.07306164f, -0.02606967f, -0.06745068f, 0.11844180f, 0.02983993f, 0.05675143f, 0.04964981f, 
    -0.02227721f, 0.05578742f, 0.01348133f, -0.07079913f, -0.05524486f, 0.03725865f, 0.01213955f, -0.02505793f, 
    0.15394756f, 0.06190705f, 0.07366114f, -0.01683631f, -0.08783106f, 0.00383271f, 0.16940917f, 0.14876665f, 
    0.06515811f, 0.05215373f, -0.04100205f, -0.14221050f, -0.03415585f, 0.06762476f, 0.12043609f, 0.18418667f, 
    0.26865733f, -0.19423264f, 0.05263489f, 0.17760590f, 0.08710509f, -0.06345582f, -0.04856857f, 0.06380221f, 
    0.23852375f, 0.15484208f, 0.08056163f, 0.00895155f, -0.02013652f, 0.05428159f, -0.00853413f, -0.09494396f, 
    -0.08011597f, -0.02432337f, -0.04376789f, -0.16549499f, -0.25544575f, -0.41280904f, -0.16131136f, -0.10267878f, 
    -0.04689813f, -0.14881712f, -0.30812800f, 0.06883535f, 0.01573667f, 0.00098776f, -0.01670023f, 0.00076223f, 
    -0.01955401f, -0.02124471f, 0.00644868f, 0.00833754f, -0.02155150f, -0.01717280f, 0.02067037f, -0.03691063f, 
    -0.02704955f, 0.00406645f, -0.00890340f, -0.00480154f, -0.01515308f, 0.02692073f, -0.02522525f, -0.00373035f, 
    -0.01492942f, 0.02380919f, 0.01833695f, 0.01396890f, 0.00285013f, -0.03238853f, -0.01144137f, -0.03063189f, 
    -0.00402805f, -0.02832735f, 0.02990120f, -0.00045783f, -0.03268982f, 0.00084912f, 0.00772026f, 0.01122107f, 
    -0.02468849f, 0.00707347f, -0.03761227f, -0.02710127f, 0.00659799f, -0.01953502f, -0.03524227f, -0.01144765f, 
    -0.00581673f, -0.01643642f, 0.01194332f, 0.00144456f, -0.01022898f, 0.01543841f, -0.00701063f, 0.02029234f, 
    -0.02138548f, -0.03586758f, 0.02917266f, -0.02493501f, -0.03672425f, -0.01575089f, 0.00032156f, -0.02718175f, 
    0.01874627f, 0.00492578f, -0.02813926f, 0.00113178f, 0.01208862f, 0.01523593f, -0.04012963f, -0.01137654f, 
    -0.03312734f, 0.01262329f, -0.01611416f, -0.02313997f, -0.02895793f, -0.03637005f, -0.00122155f, 0.00734401f, 
    -0.00092722f, 0.02635203f, -0.02740538f, -0.02580648f, -0.00506295f, -0.00274151f, -0.04181697f, 0.01581435f, 
    -0.03355896f, 0.00163053f, -0.02403737f, -0.01087357f, -0.03637616f, -0.02912070f, 0.02900473f, -0.01280483f, 
    -0.03161842f, -0.02223381f, 0.00557802f, -0.01653368f, -0.02300770f, 0.01320602f, 0.00194982f, -0.03476175f, 
    0.00796683f, -0.00896322f, -0.00081320f, -0.03022525f, -0.04013449f, -0.01984240f, -0.02491542f, 0.01101838f, 
    -0.03518165f, -0.02653283f, 0.00246014f, 0.00499792f, 0.01986855f, 0.00506670f, 0.01961368f, 0.02367795f, 
    -0.02796414f, -0.04052977f, -0.01284720f, -0.04110372f, 0.01169450f, -0.01552518f, -0.01469453f, -0.02178352f, 
    0.00693915f, -0.01158851f, 0.02943529f, -0.02852518f, 0.02903933f, 0.00924768f, 0.01497290f, -0.00902476f, 
    0.01681713f, -0.01187026f, 0.02143094f, -0.00929588f, 0.01503531f, 0.00511827f, 0.01867051f, -0.02782108f, 
    0.01966162f, -0.03333065f, -0.02382805f, 0.02025753f, -0.00389520f, -0.02391566f, 0.02928584f, 0.00722753f, 
    -0.04091088f, -0.02979291f, -0.00119417f, -0.00543991f, -0.00404398f, -0.01000950f, -0.04174020f, 0.00137762f, 
    0.01762502f, -0.01149796f, 0.01145851f, -0.02258879f, -0.03346439f, -0.04141940f, -0.01016380f, -0.00980948f, 
    -0.03929697f, 0.01498944f, 0.02778805f, 0.02913185f, -0.01979086f, 0.01770264f, -0.04205759f, 0.01039254f, 
    -0.03043730f, -0.03266045f, -0.03342210f, 0.02555210f, -0.00085150f, -0.01630722f, -0.02806177f, 0.02448321f, 
    0.02607654f, -0.00927137f, 0.01441849f, 0.00461439f, -0.01042120f, 0.01267320f, -0.04189492f, -0.04039464f, 
    0.01849582f, -0.00633243f, 0.00659633f, 0.02896789f, 0.02544824f, -0.03185125f, 0.01468521f, -0.01757066f, 
    -0.01538497f, 0.01330433f, -0.01878871f, -0.01396055f, -0.01282912f, -0.01576075f, -0.02157936f, -0.03252574f, 
    -0.01292157f, -0.02326688f, -0.01749602f, -0.03652725f, -0.03423721f, -0.00827233f, -0.01212753f, -0.00403180f, 
    0.02947671f, -0.02807061f, 0.02064642f, 0.00415241f, -0.03727232f, 0.01148752f, -0.02062892f, 0.01070892f, 
    0.02379437f, -0.02326894f, -0.00473375f, 0.00717269f, 0.00781933f, -0.02201445f, 0.00822539f, -0.01741646f, 
    -0.02457682f, -0.01516495f, 0.00656830f, 0.02350614f, 0.01192747f, -0.02636592f, -0.00257016f, 0.03113484f, 
    -0.03627524f, 0.00408290f, -0.02254169f, -0.02928241f, -0.00892325f, 0.02063629f, -0.02054610f, -0.00193479f, 
    -0.02754001f, -0.00214238f, 0.00983910f, -0.02365711f, 0.02291211f, 0.00548941f, 0.01068982f, -0.03036856f, 
    0.01052749f, -0.02644610f, 0.02861700f, -0.03944346f, -0.02197671f, 0.02636380f, -0.03682842f, 0.02564365f, 
    0.01627530f, -0.00542871f, -0.02659504f, -0.01771757f, 0.00048383f, -0.00196232f, 0.01764882f, 0.01706048f, 
    -0.02949599f, -0.01521664f, 0.00711170f, -0.02430924f, -0.02242986f, -0.02690538f, 0.03351336f, -0.04080477f, 
    -0.02324837f, -0.01543465f, -0.00387316f, 0.00884003f, -0.00457015f, -0.01511166f, -0.03573513f, 0.02036995f, 
    0.01097270f, -0.01748553f, 0.01512844f, -0.00871973f, 0.02931834f, -0.04136863f, -0.02745824f, -0.03394497f, 
    -0.01943804f, -0.01079574f, -0.01453238f, -0.03922858f, -0.03751954f, 0.01759745f, 0.02727662f, -0.01882717f, 
    0.02045264f, -0.02227256f, -0.01853811f, -0.03465277f, 0.00108927f, -0.03529938f, -0.02222760f, -0.00190559f, 
    0.00104562f, 0.00148152f, -0.03491821f, 0.01424194f, 0.02807584f, 0.00938719f, -0.01001936f, 0.02679958f, 
    -0.00526506f, -0.01148243f, -0.03846208f, -0.02224013f, -0.02987527f, -0.02562913f, 0.01112268f, 0.00328355f, 
    -0.00479172f, -0.00400874f, -0.02265490f, 0.01735976f, 0.02212849f, -0.03732230f, -0.00453943f, 0.00105798f, 
    0.02613092f, -0.01684736f, 0.00511146f, 0.00120224f, 0.00050173f, 0.02198195f, -0.00654044f, 0.00645072f, 
    0.01702034f, -0.02325963f, 0.02872001f, -0.02964210f, -0.04108305f, -0.01480913f, -0.02422610f, -0.01566767f, 
    0.01191701f, 0.02869977f, -0.03579064f, -0.00647002f, 0.00929410f, 0.00229526f, -0.03185748f, -0.03663334f, 
    0.01282606f, -0.01170863f, -0.02764787f, -0.02204266f, 0.01510066f, -0.02307132f, -0.03877383f, -0.02059242f, 
    -0.00870444f, -0.03314868f, -0.03240211f, -0.00949722f, 0.02673713f, 0.03050500f, -0.02121193f, -0.02411842f, 
    -0.02871767f, -0.03662353f, -0.02572193f, -0.00583215f, 0.01656910f, -0.00698739f, -0.03321572f, -0.01124534f, 
    0.02187845f, -0.03038342f, 0.00499349f, -0.02843423f, -0.03792510f, 0.02478866f, -0.02781024f, 0.01472129f, 
    0.01263723f, -0.00172364f, 0.02389224f, 0.00079769f, 0.02113955f, 0.01385929f, -0.03576355f, -0.03632652f, 
    -0.01836614f, 0.00144649f, -0.02886231f, -0.00067083f, 0.00582490f, -0.01381038f, -0.03121997f, -0.01680004f, 
    0.02812319f, -0.00343540f, -0.02838693f, -0.03934042f, -0.00669219f, -0.00385993f, -0.00920388f, -0.02127121f, 
    -0.02107254f, 0.01028357f, -0.03816088f, 0.01776538f, -0.00003515f, 0.01261189f, 0.00908597f, 0.00042504f, 
    0.02336429f, 0.01617017f, -0.00636650f, -0.03848517f, -0.03209664f, -0.02647966f, -0.02219880f, 0.02630991f, 
    -0.03356283f, -0.01453250f, 0.00477778f, -0.01668178f, -0.00932423f, 0.01976299f, -0.02189136f, 0.02408635f, 
    0.00628018f, 0.01216572f, 0.02675008f, 0.00497252f, -0.02285198f, 0.00707148f, 0.00566507f, 0.02997220f, 
    -0.00939240f, 0.03544386f, 0.02721510f, 0.01070053f, -0.00653754f, 0.00485900f, 0.02481174f, 0.02783003f, 
    -0.03931060f, 0.02500882f, -0.00492996f, 0.00722372f, 0.02216214f, 0.02119855f, -0.04044070f, -0.03981364f, 
    -0.01906986f, 0.02792472f, -0.00284838f, -0.00976933f, -0.03946802f, 0.02603846f, -0.02648558f, 0.00206398f, 
    -0.00263173f, 0.01095355f, 0.01092964f, 0.00724020f, -0.03722652f, 0.01863538f, -0.03304752f, -0.02595592f, 
    -0.03159673f, -0.03604423f, -0.03847378f, -0.02314165f, 0.00839937f, -0.01486613f, 0.01285142f, 0.01585556f, 
    0.01423460f, 0.03100921f, 0.01809671f, -0.03444889f, 0.02143506f, -0.00389290f, 0.00580021f, -0.02039738f, 
    0.01285335f, -0.00879454f, -0.00236900f, -0.03564643f, -0.03134798f, -0.01151084f, -0.02337555f, -0.01154038f, 
    -0.01707860f, 0.01160325f, -0.02662710f, -0.00521658f, -0.02380942f, 0.00893849f, -0.00597456f, -0.03128975f, 
    -0.00864405f, 0.02739923f, 0.00119862f, -0.01855611f, -0.03863070f, -0.04143894f, -0.01999311f, -0.03340468f, 
    -0.01394906f, -0.00406659f, -0.03677842f, 0.02338248f, -0.01975668f, -0.01736437f, -0.03474811f, -0.02489350f, 
    -0.02823856f, -0.00688232f, -0.03978372f, -0.01229521f, -0.00062970f, -0.01618409f, -0.03872124f, -0.02878622f, 
    -0.04072462f, 0.01447190f, 0.02302073f, -0.02303462f, 0.00566717f, 0.01587147f, 0.02747195f, 0.02780647f, 
    0.01618112f, 0.02781405f, 0.00791103f, -0.02377068f, 0.02983862f, -0.03224989f, -0.03362468f, 0.02558869f, 
    0.01832784f, -0.01460819f, 0.01491398f, -0.02803039f, -0.02283350f, 0.00057036f, 0.00075254f, 0.01402649f, 
    -0.02734688f, -0.01669512f, 0.01300787f, -0.00879683f, 0.00900875f, -0.01565845f, 0.00805998f, -0.03682682f, 
    -0.02245321f, -0.01677238f, 0.00763752f, -0.01396039f, 0.02167064f, -0.02613065f, 0.02063964f, 0.01090440f, 
    -0.02133562f, 0.01329712f, 0.00728478f, 0.01294356f, 0.01138317f, -0.02842720f, -0.02519847f, -0.03323982f, 
    -0.00217421f, 0.00033832f, -0.02590157f, 0.01947972f, -0.02853836f, -0.01815731f, 0.01191349f, 0.01948690f, 
    -0.01734760f, -0.02121534f, 0.00033013f, 0.01409514f, 0.03392732f, 0.01686779f, -0.03186213f, -0.01003080f, 
    -0.00237588f, 0.01862268f, 0.00454812f, 0.00706672f, -0.02794786f, -0.03506693f, 0.02261548f, -0.02071968f, 
    0.02932642f, -0.03892668f, -0.03894866f, -0.01389305f, 0.01414363f, -0.03319002f, 0.02689439f, 0.02795626f, 
    0.02323168f, -0.03584846f, 0.01363414f, -0.00052440f, -0.02126476f, 0.02447109f, 0.01979263f, -0.02140948f, 
    -0.01398196f, -0.04186131f, -0.03499166f, -0.00930286f, -0.03891245f, 0.00582500f, 0.02183467f, -0.00069246f, 
    -0.04167084f, -0.02806359f, 0.03042986f, 0.01719728f, -0.02652632f, 0.02302026f, -0.02475118f, -0.02217605f, 
    0.02015929f, -0.02060952f, 0.01221002f, -0.00815691f, 0.02042931f, -0.03188889f, -0.03889870f, 0.02981453f, 
    0.00279923f, -0.00195069f, 0.02797502f, 0.01125317f, -0.01755907f, 0.01002821f, 0.00514371f, 0.00887547f, 
    -0.03901184f, 0.02863401f, -0.00961292f, -0.02199921f, -0.00709316f, 0.01239418f, -0.03922836f, -0.02033489f, 
    -0.03722541f, -0.01324841f, -0.00460571f, 0.01415919f, -0.03998321f, -0.00734934f, -0.03258457f, -0.03206114f, 
    -0.00121184f, 0.01018605f, -0.02812700f, 0.01942122f, -0.01988892f, -0.03231989f, -0.01596960f, -0.01693792f, 
    -0.00741897f, 0.00340006f, 0.02575372f, 0.00635141f, -0.02227971f, 0.02619087f, 0.01008573f, -0.03268449f, 
    0.01755885f, -0.00157360f, -0.02495068f, -0.01460070f, 0.02050479f, -0.01542907f, -0.04162433f, 0.01129017f, 
    -0.00113047f, 0.02605206f, -0.01755080f, -0.00131211f, 0.02818158f, -0.01991942f, -0.00473688f, 0.02586767f, 
    0.01795756f, 0.00745819f, -0.03614636f, -0.02875138f, 0.01608766f, -0.01465974f, -0.03960654f, -0.00737717f, 
    -0.03159995f, -0.01721590f, -0.02498802f, -0.00563749f, 0.02810839f, -0.01594998f, -0.01802690f, -0.03917998f, 
    0.02938131f, -0.01963055f, 0.01165225f, -0.01562158f, -0.02807990f, 0.02209547f, 0.01922345f, 0.02398889f, 
    -0.04093119f, -0.03075452f, 0.00287778f, -0.03264700f, -0.01279705f, 0.02899554f, -0.02626100f, 0.00789903f, 
    0.01625758f, 0.01764576f, 0.02035918f, -0.04138462f, 0.02619642f, -0.02997979f, -0.02422881f, -0.04149460f, 
    -0.00119205f, -0.03032765f, 0.00158537f, -0.00906412f, -0.02257116f, -0.03482463f, -0.02243229f, -0.03611992f, 
    0.02106550f, -0.01703193f, -0.00940238f, 0.01589898f, 0.02252187f, -0.03472102f, 0.00535081f, -0.02069221f, 
    -0.00269610f, -0.03791486f, 0.01893122f, -0.04104773f, -0.02316718f, -0.02321053f, -0.00805260f, -0.01831749f, 
    0.02426961f, -0.03335990f, -0.03364598f, -0.02670396f, -0.03308785f, -0.03676464f, 0.02434644f, -0.00492924f, 
    0.01003265f, 0.03037835f, 0.01868157f, 0.00539165f, 0.01679197f, -0.01094796f, -0.01867794f, -0.01750456f, 
    -0.00054057f, -0.03753879f, 0.02210221f, -0.03667751f, -0.02269176f, 0.01650184f, 0.02252005f, 0.01467259f, 
    0.02691668f, -0.03377746f, -0.00945306f, 0.02144534f, 0.01641227f, -0.02811388f, -0.02549559f, -0.03878876f, 
    -0.02720324f, 0.00867389f, -0.00677547f, 0.02572972f, 0.00763176f, 0.00963582f, 0.02235849f, 0.03101313f, 
    -0.01709722f, -0.00080244f, -0.01253837f, 0.02715379f, 0.02996939f, -0.01757749f, 0.02686774f, 0.01182379f, 
    -0.03071515f, 0.01574345f, 0.00011126f, 0.01471523f, 0.02092429f, 0.00907328f, -0.02184123f, -0.03366242f, 
    -0.02450506f, -0.00334568f, -0.00738963f, -0.02143285f, 0.00519074f, -0.00030390f, -0.01713767f, -0.00779369f, 
    -0.02386922f, -0.00027045f, 0.03009809f, 0.02092081f, -0.03763527f, -0.01080840f, -0.03214251f, 0.02752883f, 
    0.00438613f, 0.02782079f, -0.01358884f, 0.02126954f, -0.03113764f, 0.00543970f, -0.00440133f, 0.03118716f, 
    -0.03057799f, -0.02467738f, -0.00708345f, -0.00081793f, 0.00963462f, 0.02403475f, -0.01738962f, 0.01523862f, 
    -0.04008387f, -0.03265574f, 0.01676864f, 0.00705941f, -0.01483232f, 0.01073816f, -0.03394907f, -0.02271201f, 
    -0.00332219f, 0.02860850f, -0.02968188f, 0.00674549f, 0.02357262f, 0.03043355f, 0.01829894f, 0.03260355f, 
    -0.02731506f, -0.02509006f, -0.02196785f, -0.00680085f, 0.02163853f, -0.03588631f, 0.02724209f, 0.02956235f, 
    0.00909770f, -0.01969509f, -0.02551273f, 0.03138487f, 0.02723567f, -0.03772058f, -0.01910987f, -0.00796079f, 
    -0.00644836f, 0.02316244f, -0.01696943f, -0.00393831f, 0.01665970f, -0.01604301f, 0.00252802f, -0.01713395f, 
    0.00464584f, -0.00902200f, -0.03035601f, -0.00082406f, -0.02243905f, -0.02587452f, -0.03152400f, 0.01412065f, 
    0.01695178f, -0.02766130f, 0.01230277f, -0.00752959f, 0.02950467f, -0.00952450f, -0.00802672f, 0.01105696f, 
    0.02176874f, -0.01404922f, 0.03016273f, 0.02976134f, 0.00982088f, 0.01731558f, -0.01397824f, -0.03068216f, 
    -0.01178228f, -0.02181546f, -0.03444809f, -0.01391378f, 0.00326714f, 0.02057502f, -0.03808962f, -0.02887913f, 
    -0.00399993f, 0.01224067f, 0.00020850f, -0.00496909f, -0.01446732f, 0.02288045f, 0.02409843f, 0.00818883f, 
    -0.02965131f, -0.01908963f, 0.01943428f, -0.01371536f, -0.01066354f, 0.02578026f, 0.03071692f, -0.01896119f, 
    -0.01451614f, -0.02098252f, -0.03513519f, -0.00971539f, -0.00214456f, 0.01835410f, -0.02677416f, -0.03320821f, 
    0.00270169f, -0.03626026f, 0.02833734f, -0.02055006f, -0.00127111f, 0.01999178f, -0.01254225f, -0.00305732f, 
    -0.03525038f, -0.00543470f, 0.00159734f, 0.00408429f, -0.03846614f, -0.04009856f, 0.01854566f, -0.01093206f, 
    0.00539188f, -0.01764345f, -0.00984475f, 0.01732281f, -0.02714004f, -0.00822566f, -0.02429489f, 0.00132957f, 
    0.00336653f, 0.00511713f, 0.00673066f, 0.01972258f, 0.00573737f, -0.01752219f, 0.02175838f, -0.04373556f, 
    0.01480035f, -0.01379083f, 0.01367592f, -0.03282125f, -0.02424752f, -0.00080531f, 0.00575543f, 0.01442473f, 
    0.02122579f, -0.01204472f, -0.01590278f, -0.02742358f, -0.03322681f, 0.02355264f, -0.00785539f, -0.00305758f, 
    0.01660641f, 0.01866032f, 0.00133835f, -0.01629373f, 0.01679566f, 0.00492673f, -0.02215929f, 0.00961589f, 
    0.02134971f, 0.02007238f, 0.02761482f, 0.02638083f, -0.00784466f, 0.00906257f, 0.02812684f, -0.02583303f, 
    0.00203869f, 0.00199741f, -0.01504176f, -0.02735635f, 0.02304267f, 0.02825718f, 0.01392662f, -0.03301908f, 
    -0.01782572f, -0.02881126f, -0.00945075f, 0.00340272f, -0.02993905f, 0.00251171f, -0.01652195f, -0.00223241f, 
    0.02260041f, 0.01765089f, -0.03551473f, -0.02404263f, -0.02773757f, -0.01659928f, -0.03405996f, 0.02718208f, 
    -0.02346065f, -0.00320532f, 0.01141460f, 0.01354851f, -0.00167439f, 0.01245888f, 0.00890997f, 0.01011092f, 
    0.00885680f, -0.03105171f, -0.00312440f, 0.02219761f, -0.03228751f, -0.03536528f, 0.02377312f, 0.01178402f, 
    -0.03564814f, -0.00304932f, 0.01320597f, -0.03430228f, -0.00512334f, -0.03211783f, -0.00538244f, 0.00670922f, 
    -0.03831396f, -0.02380634f, -0.00629919f, -0.00019650f, -0.04170622f, -0.02001911f, -0.02901169f, 0.00535304f, 
    -0.02138145f, 0.00063904f, 0.01075874f, 0.00405178f, 0.03238134f, -0.01162772f, -0.00791055f, -0.00609186f, 
    0.02054614f, -0.03280694f, 0.00888593f, -0.02030181f, -0.02410067f, 0.02212104f, -0.01080297f, -0.01138242f, 
    -0.02093199f, 0.02969406f, 0.01981229f, -0.03430859f, -0.01980235f, -0.00854138f, 0.02492785f, 0.02078914f, 
    0.03160405f, 0.02478500f, 0.00329076f, 0.01896156f, 0.00838597f, 0.01066046f, -0.00893608f, -0.00459181f, 
    -0.02773826f, 0.00463223f, 0.00128786f, -0.03848491f, -0.01923601f, -0.02048714f, -0.00357938f, 0.01625104f, 
    0.01296599f, 0.02267112f, -0.03017005f, 0.02846083f, -0.01901068f, 0.00313524f, 0.02024469f, -0.02985743f, 
    0.01823522f, -0.03189964f, -0.01540180f, 0.01461742f, 0.01458174f, 0.02927371f, 0.00117701f, 0.02498775f, 
    0.01021152f, 0.01504342f, -0.01687236f, 0.01193653f, -0.00256628f, 0.00151415f, 0.01063770f, -0.01263101f, 
    0.02153693f, 0.02026422f, 0.00000986f, 0.00590108f, -0.02050753f, -0.00519635f, -0.02040570f, -0.02419208f, 
    -0.01382930f, -0.00632218f, 0.01688022f, -0.03235851f, -0.00673609f, -0.02763788f, -0.01369587f, 0.01143356f, 
    0.02104138f, 0.01888248f, -0.01467798f, 0.02056582f, 0.02016911f, -0.02505734f, -0.00235835f, -0.01545872f, 
    0.02833157f, 0.00311357f, 0.02481191f, 0.02446843f, -0.00081433f, 0.02421463f, 0.00126246f, 0.01455087f, 
    -0.00427855f, -0.01423842f, -0.02448166f, -0.02840312f, 0.01916141f, 0.00717302f, -0.00722927f, -0.01293024f, 
    -0.00816353f, 0.03023585f, 0.00863896f, -0.01300504f, 0.03707771f, 0.00987097f, 0.02251061f, 0.00737770f, 
    0.00063204f, -0.02272303f, -0.01449888f, -0.02462178f, 0.01124675f, -0.03894436f, -0.02788979f, 0.01705712f, 
    0.03537492f, 0.01870473f, 0.00466213f, -0.01690094f, -0.04647917f, 0.02518464f, -0.03861124f, 0.02082754f, 
    -0.01269366f, -0.01335637f, 0.00069900f, -0.02626301f, -0.02343661f, -0.03992787f, -0.02755767f, 0.01009798f, 
    0.00601394f, -0.02218212f, 0.02004767f, -0.01967634f, 0.01877059f, -0.00350855f, -0.00723099f, -0.02368985f, 
    -0.00818475f, -0.00650582f, 0.02369852f, 0.00117829f, 0.02558099f, -0.01448830f, 0.02586238f, -0.02950700f, 
    -0.01972220f, -0.00560542f, -0.03158585f, 0.01474398f, -0.00626636f, 0.02489731f, -0.03197654f, -0.02825050f, 
    0.02964951f, 0.00326939f, -0.01107398f, 0.00172664f, -0.01706615f, 0.02903688f, -0.02503144f, 0.00937718f, 
    -0.03842738f, 0.01702101f, 0.00565236f, -0.01982245f, 0.01505184f, -0.00236595f, -0.01306977f, -0.01410480f, 
    0.02214352f, -0.02368600f, 0.00698961f, 0.00736362f, 0.00958841f, 0.01684711f, -0.02744469f, -0.01710439f, 
    0.00398117f, 0.01201292f, 0.00603931f, 0.01778053f, -0.00591883f, 0.00464904f, 0.02687463f, -0.01479170f, 
    -0.01149532f, -0.00432335f, 0.00245039f, -0.01630709f, 0.00083306f, 0.00602638f, -0.00140766f, -0.00775636f, 
    0.01150337f, -0.02509110f, -0.03900205f, -0.02522676f, 0.02658454f, -0.00496486f, 0.01303256f, -0.02575419f, 
    -0.04654985f, -0.02612331f, 0.00172439f, 0.02057018f, -0.03946732f, -0.00298501f, -0.01387236f, 0.00288860f, 
    -0.01454565f, -0.02677600f, 0.00793831f, 0.04048082f, -0.02791033f, 0.02620919f, -0.03140413f, -0.01317045f, 
    -0.01751061f, 0.02857172f, -0.01253385f, -0.03800398f, 0.01727786f, -0.01637194f, 0.00180366f, -0.02883919f, 
    0.02498280f, -0.00840839f, -0.01620438f, -0.01168797f, 0.01752432f, 0.01138731f, -0.02446142f, -0.01035556f, 
    -0.01992348f, 0.00148198f, -0.01596671f, 0.03392396f, -0.00361206f, -0.02626965f, 0.02187189f, -0.01003364f, 
    0.00353088f, 0.03275665f, 0.01608026f, 0.00946315f, 0.01804455f, 0.00811347f, -0.03371284f, -0.03501301f, 
    0.01612814f, 0.00763930f, -0.04225692f, -0.01673773f, -0.01216449f, -0.03732207f, 0.01475688f, -0.03170102f, 
    -0.03782049f, -0.00412534f, 0.01485878f, 0.00604961f, -0.04005691f, 0.02095537f, -0.01541359f, -0.01616887f, 
    -0.03484581f, -0.00409666f, 0.00296135f, -0.00874129f, -0.01455659f, -0.01344253f, -0.02520255f, -0.03397336f, 
    0.03527305f, 0.00398873f, 0.00174411f, -0.03932163f, 0.02101654f, 0.01314809f, 0.01340242f, 0.01512635f, 
    -0.00716309f, -0.00006372f, -0.01268140f, -0.01095938f, -0.04261803f, 0.00223111f, -0.00553467f, 0.00559595f, 
    0.01969874f, 0.03305751f, 0.00949729f, -0.00859726f, -0.01174884f, -0.01807946f, 0.00566919f, -0.03494980f, 
    0.00457876f, -0.00741468f, 0.00497555f, -0.00203583f, 0.01696042f, -0.02637775f, -0.01998736f, -0.00482248f, 
    0.00341860f, 0.02296192f, -0.02176460f, -0.02371542f, 0.00885972f, -0.01868900f, 0.01702598f, 0.00109122f, 
    0.02290007f, -0.01651015f, -0.02500367f, 0.00605043f, 0.01888128f, -0.01189567f, -0.01393667f, -0.03067226f, 
    -0.01322473f, -0.03222568f, -0.01535875f, -0.02120657f, 0.01108023f, -0.03159385f, -0.00951565f, -0.01579323f, 
    0.00601433f, -0.01349792f, 0.01059194f, 0.03271674f, -0.00612962f, 0.00889202f, -0.00530584f, -0.02980629f, 
    0.00773874f, -0.04069003f, 0.00297453f, 0.02440597f, 0.01128869f, -0.01925692f, 0.00752839f, 0.00536910f, 
    -0.01676363f, -0.01922826f, 0.02839532f, -0.03657328f, -0.00636205f, 0.00198451f, 0.01049488f, -0.02721389f, 
    -0.01431740f, 0.01245942f, 0.01411859f, -0.00116976f, -0.01027481f, 0.02174607f, -0.00676309f, 0.01531730f, 
    0.02805719f, 0.02310046f, 0.01131368f, 0.00294492f, -0.03205604f, -0.02712812f, 0.03179041f, -0.01182870f, 
    0.00940618f, -0.00745356f, -0.01768388f, 0.02833313f, -0.03466677f, -0.00236692f, -0.02120180f, 0.02916371f, 
    -0.00439922f, 0.02963788f, -0.00592294f, 0.03462229f, 0.00949528f, -0.01027930f, -0.02250360f, -0.03342200f, 
    0.01997913f, -0.00941885f, -0.03216127f, 0.00243052f, -0.02288829f, -0.03157332f, -0.00263569f, -0.00441993f, 
    -0.03494157f, -0.00913320f, -0.00942629f, 0.01993339f, -0.03349140f, 0.02279361f, -0.03841951f, -0.00591780f, 
    -0.03432314f, 0.02755257f, 0.01536760f, 0.02461070f, 0.02726635f, -0.01399127f, 0.01124563f, 0.02582811f, 
    0.00397012f, -0.00561414f, -0.02579824f, -0.01747290f, 0.02737064f, -0.03300377f, 0.01620315f, -0.03348279f, 
    0.00521918f, -0.04258252f, 0.01305101f, 0.02747517f, -0.01996429f, -0.02063643f, 0.02076289f, 0.02450122f, 
    0.00917277f, -0.02801864f, -0.02980908f, 0.01763780f, -0.02774641f, 0.02238852f, 0.02320752f, -0.03494558f, 
    -0.01570378f, 0.02463116f, 0.00775521f, -0.02534059f, -0.01023921f, -0.03761059f, 0.02036582f, 0.02108112f, 
    -0.01944892f, -0.02248424f, -0.02050472f, -0.03678536f, -0.00971751f, 0.01188721f, 0.01971254f, -0.02905052f, 
    0.01094107f, -0.00560664f, 0.01941412f, -0.01309583f, 0.00074282f, -0.02934914f, -0.00417270f, -0.01652456f, 
    -0.01450842f, -0.00211732f, -0.01079523f, -0.02583987f, -0.01682495f, -0.00152366f, -0.03106721f, -0.01028831f, 
    -0.03436266f, -0.02528810f, -0.02278804f, 0.01056297f, -0.01908909f, 0.01133422f, -0.02451103f, -0.02544658f, 
    -0.02777422f, -0.00986136f, 0.00614532f, 0.00827738f, -0.00728304f, 0.00235130f, -0.00861564f, 0.01952631f, 
    0.02130732f, -0.02139729f, -0.03563722f, -0.00880782f, -0.02942861f, 0.01168356f, -0.01042054f, -0.00422469f, 
    -0.01581369f, -0.03462160f, 0.00894902f, -0.02217959f, 0.02290593f, -0.00179382f, 0.02603895f, 0.02156484f, 
    -0.03707219f, -0.02567444f, -0.04081479f, 0.02431613f, 0.02360267f, -0.02415689f, 0.02413479f, -0.01821553f, 
    0.00411542f, -0.00601848f, 0.00556195f, -0.00790838f, -0.02315936f, -0.00124958f, 0.00323087f, -0.03643265f, 
    0.00714645f, -0.00248975f, -0.01045918f, 0.00818140f, -0.03392090f, -0.00777265f, 0.02500283f, -0.01782111f, 
    0.00749498f, -0.03564494f, -0.02682915f, -0.02680992f, -0.02449395f, 0.01875791f, 0.00967395f, -0.01884319f, 
    -0.00697518f, -0.02270888f, -0.03133458f, 0.03579754f, 0.01109368f, 0.02262826f, 0.02961694f, -0.02530890f, 
    0.02250660f, -0.03317696f, -0.02252061f, 0.00680547f, 0.01124693f, 0.01428847f, -0.03441399f, -0.01897028f, 
    0.02186437f, 0.00930506f, -0.03051787f, -0.02225507f, 0.03274760f, -0.03196717f, 0.00853692f, -0.01647655f, 
    0.00906534f, -0.02461012f, 0.02914707f, -0.00214190f, -0.02694573f, -0.03647618f, -0.04150890f, -0.02967904f, 
    0.02548623f, 0.03011156f, -0.00171209f, -0.02383811f, -0.02468752f, -0.01329372f, -0.02465297f, 0.02166420f, 
    0.00608919f, -0.01501822f, -0.02597283f, -0.01583001f, -0.00302238f, -0.01110688f, 0.01213406f, -0.03033631f, 
    0.00099929f, -0.03282345f, 0.00025811f, -0.03346153f, -0.02601793f, -0.02564740f, -0.00247026f, -0.02037867f, 
    0.01046590f, -0.02479093f, -0.01911782f, -0.00961327f, 0.00825617f, -0.03725547f, 0.02768563f, 0.00332542f, 
    0.02610472f, -0.00891149f, 0.01304066f, 0.01820235f, -0.02406814f, 0.02849657f, -0.01464103f, -0.00438671f, 
    0.02050422f, 0.01904652f, -0.00297041f, 0.02369687f, -0.03340532f, 0.01633555f, 0.01927654f, 0.01445596f, 
    -0.01009475f, 0.02260607f, 0.01016106f, -0.04077440f, -0.02455664f, -0.02518694f, 0.00746984f, 0.01235734f, 
    0.01290193f, -0.01034495f, -0.00567957f, 0.01254244f, 0.01363113f, -0.00347402f, 0.01956012f, -0.01975813f, 
    -0.02661429f, -0.03835185f, 0.01159754f, 0.02575604f, 0.01801962f, -0.01460249f, -0.01692776f, -0.02951440f, 
    -0.02992286f, -0.02807194f, 0.01399616f, -0.00083056f, -0.03306241f, -0.00531340f, -0.01021248f, 0.01693521f, 
    0.01735081f, 0.00840100f, 0.01325520f, -0.00403088f, -0.01279365f, 0.02987140f, -0.02033778f, -0.02630387f, 
    -0.02437360f, -0.01661584f, -0.03348694f, -0.03536093f, -0.01586440f, -0.04095557f, 0.02326844f, -0.03153541f, 
    0.00724884f, -0.01798701f, 0.00512160f, -0.01607946f, 0.02582628f, 0.01285521f, 0.01909239f, -0.03918517f, 
    -0.01348872f, -0.03708432f, -0.02575504f, -0.00684431f, -0.00099258f, -0.02988987f, -0.00777452f, 0.03008045f, 
    -0.00572665f, -0.02084877f, -0.00400390f, -0.00764332f, 0.01712029f, -0.03650033f, -0.00956563f, 0.00701424f, 
    0.01731489f, -0.04152311f, 0.02903737f, -0.03045458f, 0.02834307f, -0.02341671f, -0.02800699f, 0.00770269f, 
    -0.02142269f, 0.02137426f, 0.02120191f, -0.02540928f, -0.02961163f, 0.01886980f, 0.02983171f, -0.00588317f, 
    0.01920723f, -0.02067637f, -0.01130898f, 0.01143863f, 0.02274588f, -0.03523027f, -0.01703371f, -0.00670114f, 
    0.01135719f, 0.00525017f, -0.00367768f, -0.03088770f, -0.02691019f, -0.03151917f, -0.02206117f, -0.01145975f, 
    -0.01615901f, -0.04107672f, -0.02966329f, 0.01225654f, 0.02155755f, 0.00561402f, 0.02454686f, -0.02462502f, 
    0.00284724f, -0.00795407f, -0.01621556f, 0.00488182f, 0.02258479f, 0.00710523f, -0.02571314f, -0.02914955f, 
    0.01604270f, -0.02505468f, 0.03037602f, -0.02345944f, -0.03300522f, 0.00346980f, 0.00520688f, -0.00360172f, 
    0.03153782f, -0.03074660f, 0.01246771f, -0.00579368f, 0.02881821f, -0.02502065f, -0.01135162f, -0.00072235f, 
    -0.01147447f, 0.03294956f, -0.00473001f, -0.02726957f, -0.02488294f, 0.02875628f, 0.00027629f, -0.02679255f, 
    -0.03744693f, -0.01936445f, 0.02322410f, -0.03776101f, 0.02128148f, -0.02939396f, 0.02384224f, -0.00697399f, 
    0.01326878f, -0.03363526f, 0.02884241f, -0.00487066f, -0.00497545f, 0.00159843f, -0.01536327f, -0.01757113f, 
    -0.02291357f, 0.01802389f, 0.01333020f, -0.03247540f, -0.01218422f, 0.00045369f, 0.01332868f, -0.01523283f, 
    -0.00677666f, -0.00305677f, -0.01502613f, -0.00473987f, 0.02360650f, -0.01608977f, -0.00051489f, 0.02859864f, 
    0.03535832f, 0.01902348f, -0.01237985f, -0.00714028f, -0.02202300f, -0.02505434f, 0.02633397f, 0.02390506f, 
    -0.02534434f, 0.02777611f, -0.03227315f, 0.02021459f, 0.02700696f, -0.01670361f, -0.00827470f, 0.02854493f, 
    -0.00410545f, 0.00646152f, -0.00426605f, -0.02380053f, 0.01771999f, -0.02805523f, 0.01165990f, -0.01291917f, 
    -0.03470962f, -0.02914956f, -0.03483944f, -0.02751112f, 0.03042666f, 0.01135517f, -0.02189660f, -0.01405124f, 
    0.02647100f, -0.00288762f, -0.00723984f, -0.02843923f, -0.01649121f, -0.03821200f, -0.03758857f, -0.02406931f, 
    0.00280934f, -0.00698549f, 0.00526675f, -0.00477753f, -0.01881935f, -0.03971813f, -0.00784124f, 0.01050167f, 
    -0.02742193f, -0.01769021f, -0.03634967f, 0.02648604f, -0.02137087f, -0.01980358f, 0.02490225f, -0.00035842f, 
    -0.02254050f, -0.01390755f, 0.03030421f, -0.03647793f, -0.03656794f, 0.02039276f, 0.01094296f, -0.01299917f, 
    -0.02984516f, 0.00856674f, 0.02357972f, 0.00981372f, 0.01549436f, 0.00553530f, -0.01243619f, -0.01905541f, 
    -0.03934217f, 0.02704112f, 0.02408995f, -0.02822009f, 0.02833447f, 0.01904587f, 0.01851378f, -0.00375110f, 
    -0.02311557f, 0.02746801f, 0.01597819f, 0.01058893f, -0.03481404f, -0.00927675f, -0.01005119f, 0.01360262f, 
    0.01843604f, 0.00444574f, 0.00337056f, -0.01175291f, 0.00913435f, 0.00475279f, -0.00251127f, -0.02272350f, 
    -0.01484867f, -0.02804673f, 0.00308670f, 0.02443668f, -0.01483846f, 0.00053128f, 0.02824120f, 0.03444689f, 
    -0.03419046f, -0.00972316f, -0.02210937f, -0.02278210f, -0.00811261f, -0.00283062f, -0.02324472f, 0.00246511f, 
    -0.00953327f, -0.00546988f, 0.01099069f, -0.00436875f, -0.02050587f, 0.01566270f, 0.01084755f, -0.02669984f, 
    -0.03002022f, 0.02422966f, -0.01719171f, 0.00550306f, 0.00066834f, 0.02794386f, -0.02386563f, -0.01655476f, 
    -0.01900162f, -0.00346734f, -0.00317584f, -0.00911388f, -0.01833903f, -0.00731533f, 0.01074785f, 0.01715028f, 
    -0.02283401f, 0.01913867f, -0.00754924f, -0.01023189f, 0.03519345f, -0.00818265f, -0.00763894f, -0.02749114f, 
    0.00127659f, -0.00522855f, 0.00097019f, -0.02190490f, 0.02969156f, 0.00972653f, -0.03537621f, -0.00363677f, 
    -0.02858605f, 0.00854604f, 0.02438156f, 0.02834520f, -0.03635317f, 0.01872905f, 0.02981267f, -0.03578901f, 
    0.02287517f, -0.03255651f, -0.00517041f, -0.02124957f, 0.00284222f, -0.00361469f, 0.01486995f, 0.00832728f, 
    0.00533580f, 0.01846476f, 0.03508138f, -0.01990033f, -0.03437559f, 0.01847149f, 0.00669934f, -0.02789832f, 
    -0.00672655f, 0.02680078f, -0.01334463f, -0.02340359f, -0.02834574f, 0.01438391f, -0.03115091f, 0.00771722f, 
    0.02766682f, -0.02279858f, 0.02579644f, 0.00366008f, 0.00775035f, 0.00777010f, -0.00907152f, -0.00360389f, 
    -0.02855639f, -0.01841460f, -0.00307640f, -0.03817653f, 0.02582747f, -0.02154011f, 0.01655995f, -0.02918512f, 
    0.03019392f, -0.01008869f, -0.00960895f, -0.01742419f, -0.03669236f, 0.00123888f, -0.03241277f, 0.00401067f, 
    -0.02267651f, 0.00476029f, 0.00754268f, -0.02146705f, 0.00208997f, -0.00257596f, -0.03408207f, -0.00929129f, 
    -0.02851476f, 0.01599040f, 0.02156883f, -0.02243168f, -0.00687859f, 0.02101860f, 0.02722234f, 0.01596876f, 
    -0.00971115f, -0.03535691f, -0.00277397f, -0.01260397f, 0.01323159f, 0.02801674f, 0.01249600f, -0.02334723f, 
    -0.00527051f, -0.01290719f, 0.02896714f, 0.03558461f, -0.00916429f, -0.03420745f, 0.02286966f, -0.02207378f, 
    -0.03284990f, -0.02010050f, -0.00009467f, -0.03214824f, 0.01345069f, -0.03373545f, 0.00063649f, -0.00296184f, 
    0.01158087f, 0.02354529f, 0.01220325f, -0.02847379f, 0.01010985f, 0.01000804f, -0.02299392f, 0.02849622f, 
    0.03027983f, -0.01748972f, -0.02045114f, -0.01899227f, -0.01158338f, 0.01096819f, -0.00198471f, 0.01038469f, 
    -0.02995665f, -0.02521892f, -0.03627212f, 0.02119788f, -0.03072677f, 0.02380387f, 0.01356693f, 0.01661221f, 
    -0.03407236f, 0.00203443f, -0.01954616f, 0.00632299f, 0.00734588f, -0.04050098f, -0.02130848f, -0.03296220f, 
    0.01077822f, -0.01916730f, -0.02319993f, 0.01427039f, -0.02499382f, 0.01630619f, -0.00888810f, 0.01609409f, 
    -0.03250992f, 0.00790261f, 0.01290661f, -0.01424436f, 0.01748415f, 0.02077011f, 0.00398019f, -0.00709509f, 
    -0.03777746f, -0.03595218f, -0.02986327f, -0.02447391f, 0.02113390f, -0.00713198f, -0.01967380f, -0.02598746f, 
    -0.00184713f, -0.03155250f, -0.00411407f, -0.00753977f, -0.02771345f, 0.02060337f, -0.03269869f, -0.00219926f, 
    0.01932687f, -0.00276929f, 0.02252983f, 0.02431814f, -0.01938692f, 0.01096522f, 0.00050000f, -0.02867879f, 
    -0.04117394f, -0.02986040f, -0.01356181f, -0.00651922f, 0.01172153f, -0.01745745f, 0.02261608f, 0.01448754f, 
    0.02661584f, -0.01977840f, -0.02582038f, -0.04155086f, -0.02443038f, -0.01206489f, -0.02632148f, -0.02226479f, 
    0.01127646f, -0.03868949f, -0.02544124f, -0.02018492f, -0.04125592f, -0.03600054f, -0.01381473f, 0.00853471f, 
    -0.01184159f, -0.03730020f, -0.00163913f, -0.00959747f, -0.03228895f, 0.00307017f, 0.00023775f, -0.03687444f, 
    0.00651715f, 0.00995996f, 0.02753306f, 0.00046994f, -0.04118734f, -0.02060139f, -0.03325605f, 0.00135645f, 
    -0.04140156f, -0.00089325f, -0.03024357f, -0.00144320f, 0.02142443f, -0.02143717f, 0.02612051f, 0.01031343f, 
    0.02659765f, -0.02611365f, 0.01150982f, -0.02343121f, 0.01579376f, 0.00620841f, -0.02003243f, 0.02346498f, 
    -0.01091300f, 0.00044512f, 0.00782333f, -0.00228346f, 0.01069991f, 0.01402340f, -0.03212961f, 0.01062754f, 
    -0.03160825f, 0.02531580f, 0.01445727f, 0.03005925f, -0.00308022f, -0.01892019f, -0.03496070f, -0.01434887f, 
    0.00636313f, -0.03674930f, -0.01278760f, -0.02769969f, 0.00441047f, -0.01845363f, -0.02617060f, 0.00334948f, 
    -0.00877044f, -0.04098056f, -0.03798070f, 0.02213348f, -0.01527667f, -0.03705841f, -0.03963769f, -0.02242910f, 
    0.02090386f, -0.00696541f, 0.02029794f, 0.00085623f, 0.02322356f, 0.02848743f, 0.01878953f, -0.02519432f, 
    0.01784720f, -0.01895580f, -0.02361181f, 0.02471092f, -0.01210263f, 0.02591148f, -0.01372070f, -0.02460029f, 
    0.02192561f, -0.03343484f, 0.00307099f, 0.02116329f, 0.01203271f, 0.02607303f, 0.01066522f, -0.03336728f, 
    -0.01101259f, -0.03394485f, -0.01019478f, -0.02802593f, -0.01924295f, -0.00095484f, -0.00892337f, -0.03564440f, 
    0.00769358f, -0.01570386f, -0.03189166f, -0.02445067f, 0.00232042f, -0.00380463f, -0.02711036f, 0.00079686f, 
    0.09395553f, 0.03520256f, 0.08786663f, -0.00287248f, -0.02678101f, -0.06143363f, 0.04584440f, 0.15773539f, 
    -0.01280266f, 0.07573367f, -0.03915423f, -0.26265624f, -0.00890091f, 0.05093129f, -0.07267360f, 0.06488621f, 
    -0.03429620f, 0.06044275f, -0.02375162f, -0.01513553f, 0.12669088f, 0.00241961f, 0.09630069f, 0.12932256f, 
    0.01369138f, 0.02588256f, 0.04605042f, -0.18787529f, -0.06580439f, 0.07964321f, 0.01921144f, -0.05954111f, 
    -0.00739484f, 0.14778602f, 0.13569792f, 0.11115045f, -0.12101564f, -0.01880102f, 0.10766722f, -0.01032559f, 
    0.04434337f, -0.03785251f, -0.01774353f, 0.04789389f, 0.07286330f, -0.00760014f, -0.07864306f, -0.14521804f, 
    -0.26515424f, -0.16276562f, 0.04457492f, -0.04001417f, -0.03202679f, -0.04007795f, -0.11004684f, 0.14388008f, 
    0.08657473f, -0.04792831f, -0.10163946f, 0.11274812f, -0.05817904f, -0.07155355f, 0.03112275f, 0.03490152f, 
    -0.09755576f, -0.05026110f, -0.02212068f, 0.21239170f, -0.03343099f, 0.07354093f, 0.02255250f, -0.08418760f, 
    -0.09293415f, 0.28826874f, 0.00999124f, 0.13773368f, -0.00771762f, 0.01838079f, -0.07022343f, -0.00946086f, 
    -0.01929275f, -0.06164929f, -0.04878544f, 0.09759517f, -0.10324512f, -0.00270758f, 0.11522458f, 0.21409014f, 
    -0.08721068f, 0.08091369f, 0.14651990f, -0.04413514f, 0.25070357f, 0.05139919f, 0.03085619f, 0.10334309f, 
    0.09515141f, -0.15140459f, 0.08788331f, 0.31354734f, 0.02900255f, 0.02871408f, -0.14331068f, -0.11538515f, 
    -0.09137939f, -0.07077716f, -0.07868052f, -0.07585151f, -0.11682674f, 0.21047798f, 0.16286348f, -0.08038983f, 
    0.17246839f, 0.01327631f, 0.06400045f, 0.04510876f, -0.08224741f, 0.14135523f, 0.03920033f, 0.17268983f, 
    0.19149037f, -0.08247161f, 0.28349489f, -0.15804279f, 0.08942566f, 0.01037207f, -0.04129669f, 0.19746186f, 
    -0.05025546f, 0.14990386f, -0.03083186f, -0.02643120f, -0.06778201f, -0.14939295f, -0.11019009f, 0.08905866f, 
    -0.02428769f, -0.15764602f, 0.01248285f, 0.02777038f, 0.08937966f, 0.23990798f, 0.07320579f, -0.04294620f, 
    -0.00595730f, 0.00185304f, -0.01542931f, 0.02525244f, -0.12442343f, 0.03049327f, -0.09683769f, 0.03033673f, 
    -0.10318035f, -0.03353272f, 0.04423820f, -0.05931927f, -0.31626311f, 0.00168936f, 0.17671549f, 0.29210442f, 
    0.03057078f, 0.09127849f, -0.06295313f, -0.08419225f, -0.14184400f, -0.01962027f, 0.11281535f, 0.03260920f, 
    0.39052680f, 0.13626769f, 0.21344979f, 0.10813215f, 0.02583108f, -0.15868607f, 0.09046693f, -0.08598715f, 
    0.01837693f, 0.05843316f, 0.03635961f, 0.10576940f, 0.02934904f, 0.08240341f, 0.12869430f, -0.03345527f, 
    -0.01032768f, 0.04687558f, 0.00384039f, 0.01732492f, 0.10581173f, -0.06112291f, -0.09826017f, 0.03264946f, 
    -0.07182794f, 0.02990396f, 0.01152301f, 0.00782620f, -0.02766660f, -0.08689755f, -0.08853438f, -0.18751238f, 
    0.09613292f, 0.06976154f, 0.07366933f, 0.23669682f, 0.33939102f, 0.32467291f, 0.15744174f, -0.01027111f, 
    -0.01457470f, 0.04854482f, -0.06185001f, 0.22066423f, -0.04675207f, 0.02441375f, -0.03313961f, -0.15576644f, 
    0.06423039f, 0.22860134f, 0.02529615f, -0.11002918f, -0.12914865f, -0.07547234f, 0.07684778f, 0.09285861f, 
    -0.05998352f, -0.01878333f, -0.12568645f, -0.12803398f, -0.18604591f, 0.08040819f, 0.28336599f, 0.19821465f, 
    0.05526526f, -0.01684889f, -0.10262301f, 0.12569441f, -0.21347138f, -0.04659411f, -0.12828395f, 0.04873288f, 
    -0.01920042f, 0.15375453f, 0.16405027f, -0.05308206f, -0.00041442f, 0.23660745f, 0.11202710f, -0.19090401f, 
    -0.11830444f, -0.07983258f, 0.04221453f, 0.08552850f, -0.01043953f, 0.07366906f, -0.05208017f, -0.07175694f, 
    0.06426032f, -0.02605464f, 0.03943623f, 0.08200151f, 0.05958168f, 0.16146791f, -0.00757470f, 0.18173347f, 
    -0.12094699f, -0.07160307f, -0.02477451f, 0.01599097f, -0.01371339f, 0.08043654f, 0.10225441f, -0.02445660f, 
    0.17390099f, 0.05995638f, 0.02410655f, 0.32484677f, -0.07025534f, 0.21319906f, 0.04175987f, 0.01804558f, 
    0.01607643f, 0.01925179f, -0.01520812f, 0.14623395f, 0.01788291f, -0.13911414f, -0.02062383f, -0.08213349f, 
    0.03828809f, -0.09855061f, 0.03665965f, 0.00547619f, -0.07621115f, -0.10667551f, 0.06265478f, 0.17655855f, 
    0.18677494f, -0.00803796f, -0.02205768f, 0.03971708f, 0.13317059f, 0.19877988f, 0.05848159f, 0.36195695f, 
    0.03512426f, 0.13417098f, -0.07821333f, 0.01116007f, -0.06671998f, 0.03456588f, 0.04088851f, 0.11140393f, 
    0.07985469f, 0.06611011f, 0.06153655f, 0.13973193f, -0.14721268f, -0.16186160f, -0.08037283f, -0.20544243f, 
    -0.03108580f, -0.02873604f, 0.01588700f, -0.01126410f, -0.13302974f, -0.11915337f, -0.17020607f, -0.05939865f, 
    -0.04276259f, -0.10314593f, -0.04046475f, 0.04608717f, -0.00810811f, 0.00203976f, 0.12815210f, 0.06981281f, 
    0.24496818f, 0.15175989f, 0.17611885f, 0.03844622f, -0.07090400f, 0.07434055f, 0.07598270f, 0.10000220f, 
    -0.07273053f, 0.05972211f, -0.02853587f, 0.00128046f, -0.13993810f, 0.04703981f, 0.36869201f, 0.00539252f, 
    0.00503817f, -0.01180952f, -0.07867276f, 0.32693687f, -0.11824484f, -0.15260038f, -0.10865176f, -0.24255119f, 
    0.51542944f, -0.06866570f, 0.08835553f, -0.01378603f, -0.04211339f, 0.04568689f, -0.01913573f, -0.10282167f, 
    0.03715716f, -0.01209274f, -0.03164429f, 0.19331826f, 0.43148610f, 0.11656461f, 0.01491749f, 0.24499354f, 
    -0.00638630f, -0.14348973f, 0.00557210f, -0.02509008f, -0.05307722f, 0.03302303f, -0.02564701f, -0.07916139f, 
    -0.05602733f, 0.34107766f, 0.03238662f, 0.07206322f, 0.16507021f, -0.06012185f, 0.02105417f, -0.15705207f, 
    0.10508063f, -0.04883115f, 0.01554854f, 0.12513411f, 0.11310891f, 0.05550086f, -0.11189553f, -0.01243960f, 
    -0.01780951f, -0.03340370f, -0.10749998f, -0.13308363f, -0.15422189f, 0.06966396f, -0.07359505f, -0.04819043f, 
    0.05568099f, -0.20692860f, 0.32396075f, 0.05826972f, 0.11595335f, 0.16774526f, 0.06417917f, -0.00480264f, 
    -0.02215945f, 0.10437701f, 0.07561692f, 0.09974516f, 0.26579857f, 0.06788182f, 0.11593626f, 0.08960900f, 
    -0.01164492f, -0.09714773f, 0.05903376f, 0.07596254f, 0.20062701f, 0.21197852f, 0.05067380f, -0.08124732f, 
    -0.08928891f, 0.09753958f, 0.04651533f, 0.08670924f, 0.12180163f, 0.09403300f, 0.03070594f, -0.10657571f, 
    -0.08009911f, -0.04230329f, -0.17791526f, -0.21692406f, -0.04407933f, -0.12047781f, -0.02064255f, 0.10648515f, 
    0.04614054f, 0.08260236f, 0.01704516f, -0.10698779f, -0.01749248f, -0.05170583f, 0.00028809f, -0.05193908f, 
    -0.28386053f, -0.06248328f, 0.34789819f, -0.05855171f, -0.04083378f, -0.11515986f, 0.01655026f, 0.08892322f, 
    -0.04051531f, 0.08352112f, -0.04401395f, 0.03683306f, 0.04479925f, 0.00951782f, 0.07085569f, 0.30550057f, 
    0.08360382f, 0.17582269f, 0.04037694f, -0.07175648f, -0.07524458f, -0.05418995f, -0.01831786f, -0.01560225f, 
    0.10627086f, 0.04398625f, -0.02220506f, 0.10037862f, 0.06633990f, -0.02030427f, 0.05243628f, -0.00557603f, 
    0.15460193f, 0.03804049f, 0.11735681f, 0.09001610f, -0.12623738f, -0.14822626f, 0.19026454f, -0.24762294f, 
    0.03650860f, 0.10193525f, -0.13491838f, 0.02426890f, -0.09775428f, -0.02396873f, -0.07833442f, -0.08345917f, 
    0.02264240f, 0.09203256f, -0.01213210f, 0.03647364f, 0.02680827f, 0.04521398f, 0.04226849f, 0.02309362f, 
    0.04035679f, 0.03221798f, -0.14706811f, -0.14588556f, -0.11678530f, 0.40463409f, 0.25960052f, 0.17192778f, 
    -0.00706140f, 0.15124251f, -0.03140616f, 0.08061648f, -0.07164210f, -0.04317138f, 0.08618160f, -0.03306734f, 
    -0.36402291f, -0.05829759f, 0.39117432f, -0.18030451f, 0.05985950f, 0.10022800f, -0.05763475f, 0.08774107f, 
    -0.14161740f, -0.05514096f, -0.00822947f, -0.01446584f, 0.09133770f, 0.25040370f, -0.14701758f, 0.03298390f, 
    0.07672626f, 0.00608071f, -0.01838652f, 0.10681313f, 0.08276255f, 0.09009665f, -0.02794732f, 0.02868479f, 
    0.10456926f, 0.03685624f, 0.12279554f, -0.00316516f, -0.19080053f, -0.00100765f, -0.12117916f, 0.11839205f, 
    -0.07822996f, -0.02487406f, -0.08810020f, -0.17088746f, -0.06102134f, -0.07232276f, 0.07452729f, 0.06161281f, 
    0.05418169f, 0.05143399f, 0.01901053f, 0.11797798f, -0.09936218f, -0.17620642f, -0.05288317f, -0.22119126f, 
    0.14349855f, 0.09729625f, -0.06405446f, 0.05948806f, -0.01895902f, -0.00466153f, -0.12693200f, 0.05742168f, 
    -0.04535768f, -0.02323021f, -0.20494571f, 0.08359674f, 0.27697340f, 0.26642746f, -0.00479953f, 0.04507967f, 
    -0.18950516f, -0.07878704f, 0.11374495f, -0.05472781f, 0.01908544f, -0.04361598f, -0.03918185f, -0.03023862f, 
    -0.02121762f, -0.02586590f, 0.10922325f, -0.10827548f, 0.02309888f, 0.13537532f, -0.05660390f, -0.06299016f, 
    0.11213773f, -0.10891883f, -0.04333685f, 0.11599483f, 0.00750486f, 0.21516535f, -0.12081558f, 0.00669765f, 
    -0.14503679f, 0.01996987f, 0.10074250f, -0.11494990f, 0.03090820f, -0.03668534f, -0.10989449f, 0.18115473f, 
    0.05485747f, 0.02498111f, 0.03959301f, -0.03403135f, -0.17090252f, 0.03675354f, 0.07178976f, 0.16963872f, 
    0.02777053f, 0.05407058f, 0.01920075f, -0.05288948f, 0.01548485f, -0.10442378f, -0.16239382f, -0.13982305f, 
    -0.01229029f, 0.08797257f, 0.06510093f, 0.04481950f, 0.06609477f, 0.01928229f, 0.08641057f, -0.03363204f, 
    -0.20509291f, -0.02909146f, 0.03686539f, 0.19397315f, -0.05590560f, 0.08699791f, 0.01616094f, -0.01836951f, 
    -0.16216873f, -0.00272457f, -0.04963035f, -0.05945864f, -0.23679587f, -0.07945539f, 0.09567727f, 0.09126130f, 
    0.10792693f, -0.05970263f, -0.06976363f, 0.27799973f, -0.14340644f, 0.12602197f, 0.01402854f, 0.01044000f, 
    0.13451208f, 0.18971285f, -0.03798559f, 0.11099688f, 0.20555873f, 0.01400795f, -0.01921575f, -0.12560777f, 
    -0.10967501f, -0.11728016f, -0.14644416f, -0.09393399f, -0.20402616f, 0.00311710f, 0.08252093f, -0.05573181f, 
    0.03292245f, -0.00109937f, -0.03621902f, 0.02998601f, 0.06201668f, 0.09994151f, 0.05747807f, 0.27191758f, 
    -0.08606742f, -0.21776614f, -0.03079707f, -0.15262519f, -0.08751521f, 0.01260767f, -0.01636899f, 0.11664426f, 
    0.01521004f, 0.03249795f, 0.06008715f, 0.02602713f, 0.00534665f, -0.03949346f, 0.01435735f, -0.02028620f, 
    -0.00832255f, 0.09169035f, 0.07205705f, -0.07816827f, -0.12466465f, -0.10681861f, -0.19014624f, -0.09930654f, 
    -0.35683879f, 0.13949044f, 0.15207714f, -0.11080495f, 0.02843950f, 0.01650695f, -0.09845197f, 0.05632090f, 
    -0.11676249f, 0.00071451f, -0.05600805f, 0.12472939f, 0.06644849f, 0.07374179f, 0.14366463f, 0.01095096f, 
    -0.07064787f, 0.02882562f, -0.05349741f, 0.18239368f, -0.02177663f, -0.28159335f, -0.07817830f, -0.29957289f, 
    -0.04325650f, 0.10792797f, -0.11223831f, 0.01463701f, 0.04665429f, 0.07716973f, 0.12869200f, 0.03240441f, 
    -0.01046825f, 0.12000659f, -0.02217185f, -0.09536815f, -0.09361633f, -0.17955531f, -0.00584178f, 0.02585091f, 
    -0.06984100f, 0.01254862f, -0.04498326f, -0.01675928f, -0.11048381f, -0.05370078f, 0.04334403f, -0.02663582f, 
    -0.07201260f, -0.10773671f, 0.04265718f, -0.02241014f, 0.14118968f, 0.04709662f, 0.04041937f, 0.11859658f, 
    -0.08125676f, -0.05320672f, 0.02642987f, 0.06669996f, -0.07853435f, -0.07152185f, -0.00887967f, -0.05327386f, 
    -0.01597613f, -0.03999813f, 0.01766802f, -0.00398754f, 0.07907262f, -0.04058962f, 0.07398583f, -0.02585952f, 
    0.38773781f, -0.10698564f, -0.06290991f, 0.15622479f, 0.13163389f, 0.04363022f, 0.06608445f, -0.02064152f, 
    0.03904723f, 0.10993037f, -0.11650279f, -0.05251321f, -0.15324350f, 0.01356853f, 0.19324547f, 0.04386856f, 
    -0.00120655f, 0.07806441f, 0.06018322f, -0.00489710f, 0.04526291f, 0.12902004f, 0.10217904f, 0.07681279f, 
    0.03230496f, 0.37168488f, -0.17768367f, -0.00497928f, 0.21497867f, -0.05455089f, 0.15532242f, 0.12739541f, 
    0.03908568f, 0.09905498f, 0.22315837f, 0.02716264f, -0.17850968f, 0.05734022f, 0.00226170f, -0.00427382f, 
    -0.08758140f, 0.04601452f, 0.04909955f, -0.11962195f, -0.05591668f, 0.01147046f, 0.04139610f, -0.03530855f, 
    -0.16715364f, -0.04243083f, -0.12280224f, 0.01927379f, 0.15567113f, 0.08455407f, 0.04923484f, 0.05167173f, 
    0.02758140f, -0.08775260f, -0.01898666f, 0.10739020f, -0.11760499f, 0.27259356f, 0.09905592f, 0.01374615f, 
    -0.04795146f, 0.01562139f, -0.13877693f, -0.00546975f, -0.08506649f, 0.05434050f, 0.11262809f, -0.02358226f, 
    0.10348932f, -0.12734446f, 0.01462958f, -0.15702114f, 0.04876726f, -0.08255573f, -0.13759433f, -0.08820170f, 
    -0.02369971f, -0.00411335f, -0.01049895f, 0.08776119f, 0.00478730f, -0.16512677f, -0.06142288f, 0.21111242f, 
    -0.06673887f, 0.07689665f, -0.06970888f, -0.05018236f, 0.07997710f, 0.08764964f, -0.02156847f, -0.06949960f, 
    -0.08263344f, -0.07468952f, -0.22456770f, 0.18284589f, 0.01824689f, -0.00641163f, -0.05956105f, 0.01618273f, 
    0.07849720f, 0.10510361f, 0.06909805f, -0.10384516f, -0.13315818f, -0.04204749f, -0.06635339f, -0.07509841f, 
    -0.10817651f, 0.00729479f, -0.01140981f, -0.06342957f, 0.02720547f, -0.03034128f, 0.30105707f, -0.04600091f, 
    0.10354669f, 0.16764037f, 0.01063078f, -0.20870355f, 0.00348486f, 0.02009330f, -0.02818729f, 0.03469330f, 
    0.15046233f, -0.11009633f, 0.04028670f, 0.16521151f, -0.02048653f, 0.52300650f, -0.02026827f, 0.06846923f, 
    0.02497106f, -0.15050252f, -0.04066183f, -0.00858495f, -0.05095820f, 0.05843200f, -0.01239344f, -0.03629154f, 
    0.27784887f, -0.03842269f, 0.00963406f, 0.07113177f, -0.02948583f, 0.04481077f, 0.11869245f, 0.01069265f, 
    0.01055701f, -0.00974353f, 0.05879737f, -0.01454837f, -0.08448303f, 0.13817196f, 0.20321350f, -0.07919485f, 
    0.03504012f, -0.00225434f, -0.03244182f, 0.17245352f, -0.00568034f, 0.05990522f, 0.04519286f, -0.14992243f, 
    0.10747364f, -0.05388112f, 0.05808773f, 0.14581297f, 0.01490378f, -0.11065096f, -0.07392471f, -0.03061153f, 
    -0.02871859f, 0.17336498f, 0.00475154f, -0.07088295f, -0.25953332f, 0.03128168f, 0.15822858f, -0.06815430f, 
    0.10107002f, -0.08845804f, 0.03784735f, -0.06037625f, 0.11436727f, -0.05874423f, 0.07255299f, -0.00187742f, 
    -0.26690221f, -0.25806403f, 0.04765505f, -0.29421100f, -0.02652131f, 0.06056200f, -0.14300448f, 0.01285432f, 
    0.13279901f, 0.03932424f, 0.00921570f, -0.03627293f, -0.37235638f, 0.09408456f, 0.04804123f, -0.03122148f, 
    -0.07597334f, 0.12880020f, 0.04935693f, 0.06634440f, -0.01716425f, -0.04161721f, -0.07380330f, -0.01526243f, 
    0.28671992f, -0.26575434f, 0.06308683f, 0.05307637f, -0.02036580f, -0.02095694f, 0.02207836f, 0.00725871f, 
    0.07016923f, -0.02567676f, -0.11078288f, 0.09852811f, -0.13960883f, -0.09935112f, -0.06048074f, 0.19250961f, 
    -0.08694085f, -0.07722500f, -0.02492850f, -0.02227658f, 0.11621530f, -0.04892984f, -0.05546066f, -0.05066083f, 
    0.04914314f, 0.14177087f, -0.06014233f, -0.12674606f, 0.03605056f, -0.02917630f, 0.06507967f, -0.01353519f, 
    0.01638354f, 0.25551122f, 0.06727315f, -0.12836456f, -0.09774549f, -0.00310913f, 0.01544059f, 0.06827956f, 
    0.17484339f, 0.05761105f, -0.00512292f, -0.08899844f, -0.02584292f, 0.05013071f, -0.03097256f, 0.14151835f, 
    -0.13307010f, -0.02367242f, -0.05276929f, 0.03479389f, -0.03688741f, -0.01180298f, 0.14454034f, 0.01592145f, 
    -0.09457714f, 0.07571661f, -0.06140570f, -0.00939908f, 0.19134733f, 0.25079799f, -0.17184241f, -0.04206804f, 
    0.05985871f, -0.02548659f, -0.02870828f, 0.09321271f, 0.09019830f, -0.01141415f, 0.05711580f, -0.06733117f, 
    -0.04679769f, 0.09624371f, -0.02204574f, 0.16597886f, -0.02960573f, -0.05390798f, 0.03297899f, 0.00662146f, 
    0.07360034f, 0.06855629f, -0.02882632f, 0.06553962f, -0.13241553f, -0.08258272f, -0.00829150f, -0.19246545f, 
    -0.05895504f, -0.15520233f, -0.03523828f, -0.00021609f, -0.08924105f, -0.04342461f, 0.06236978f, -0.01166900f, 
    0.05106790f, -0.22903872f, -0.03861755f, 0.05393215f, 0.18134972f, 0.11919101f, 0.10833617f, -0.16792235f, 
    0.02670510f, 0.10085832f, 0.06249041f, 0.18981916f, -0.15354776f, -0.08487549f, -0.32939652f, 0.23284157f, 
    0.18398106f, -0.08434483f, 0.05263543f, -0.11918172f, 0.01811663f, 0.03156266f, -0.00046564f, 0.01455663f, 
    0.32440501f, 0.39338332f, -0.01581320f, 0.03819820f, -0.05110963f, -0.13303985f, 0.21827401f, 0.03378100f, 
    -0.00863288f, -0.03140208f, 0.08527295f, 0.13993877f, -0.08129805f, -0.00031588f, 0.01092374f, -0.06545330f, 
    0.00199514f, -0.02411767f, 0.08155959f, -0.08213944f, 0.04481183f, 0.02869029f, 0.21112381f, 0.01502699f, 
    -0.08228003f, 0.08386048f, -0.08532199f, 0.03518571f, 0.00775992f, 0.11749550f, -0.02697576f, 0.09374870f, 
    -0.01075398f, 0.10189667f, 0.03669722f, 0.01251022f, 0.00062783f, -0.01118059f, 0.26903680f, -0.09236333f, 
    0.04827069f, 0.10849416f, -0.00550687f, 0.14486261f, 0.05793339f, 0.07914060f, -0.06887747f, 0.06256226f, 
    -0.18001790f, 0.17931534f, 0.07791264f, -0.22348049f, 0.05385016f, -0.07594611f, -0.05888733f, 0.16520949f, 
    -0.03062301f, -0.09528272f, 0.04728815f, 0.17853998f, -0.21946159f, -0.18344197f, -0.05263608f, -0.12228243f, 
    0.06592806f, 0.02122829f, 0.15187721f, -0.07667635f, -0.00333458f, -0.10643668f, -0.07562621f, -0.03509551f, 
    0.20876502f, -0.13103443f, 0.06363726f, 0.06401860f, 0.00736360f, 0.07423597f, -0.10806336f, 0.08310076f, 
    0.04687978f, -0.08001709f, -0.14195895f, 0.09007423f, 0.06690840f, -0.00032810f, 0.03605525f, 0.03192091f, 
    0.03997182f, -0.01836131f, -0.00211043f, 0.05382852f, -0.11343250f, 0.04290784f, 0.19524859f, 0.12733693f, 
    -0.20366217f, 0.13367562f, 0.02846870f, 0.08027726f, -0.00475410f, 0.07965915f, 0.18832682f, 0.10737663f, 
    -0.05688798f, 0.01122672f, 0.06060115f, 0.02014344f, 0.32167995f, -0.21870673f, -0.00211584f, -0.11964750f, 
    0.07777196f, 0.02205094f, -0.18956421f, 0.07469999f, -0.04314700f, -0.08381391f, 0.24034363f, 0.04477703f, 
    -0.13779896f, 0.04981697f, 0.06573007f, -0.04872666f, -0.04059907f, -0.04143886f, 0.10324454f, 0.08337204f, 
    0.01625244f, 0.05775659f, 0.01194103f, -0.00800601f, 0.16364570f, 0.54925233f, -0.16986680f, 0.08664217f, 
    0.11467808f, -0.02553670f, -0.05151561f, -0.11653461f, -0.07170593f, 0.06061053f, 0.03227883f, -0.05659074f, 
    0.12277121f, -0.06868694f, -0.08279776f, -0.15379512f, -0.05821723f, -0.00642285f, -0.06738108f, -0.07140357f, 
    0.10330049f, 0.06743281f, 0.06651131f, 0.12971133f, -0.19035299f, -0.14222306f, 0.01332555f, 0.12519342f, 
    0.09327541f, -0.11279592f, -0.08447398f, 0.01580254f, -0.00930300f, -0.06908451f, -0.01163728f, 0.05205912f, 
    -0.23907052f, 0.09473053f, -0.13849500f, 0.08537913f, -0.11712288f, 0.03687498f, 0.02317337f, -0.04717147f, 
    0.02038165f, -0.02939006f, 0.09918062f, 0.08187824f, -0.09634807f, -0.32680690f, 0.04225786f, 0.03136118f, 
    -0.09262399f, -0.03364885f, -0.01763384f, -0.03357596f, 0.00287783f, 0.02854038f, 0.14014260f, -0.10660058f, 
    -0.16587348f, -0.08265267f, -0.15652367f, -0.06103092f, 0.07971347f, 0.02053363f, 0.12199106f, -0.09058546f, 
    0.05449684f, -0.02748845f, -0.04583289f, 0.02295354f, 0.03456231f, 0.01897548f, -0.05384125f, -0.01787307f, 
    -0.01839725f, -0.07963179f, -0.08932132f, -0.16936380f, -0.00591345f, 0.09635288f, -0.00179817f, 0.12793277f, 
    0.44615918f, 0.26926249f, -0.16525783f, 0.07077324f, 0.00769487f, -0.10960931f, 0.02267753f, -0.06575558f, 
    -0.02879485f, 0.02016955f, -0.01647123f, 0.03246960f, -0.07694123f, -0.14700301f, 0.07846425f, 0.17718759f, 
    0.13071114f, 0.02600192f, -0.08912674f, 0.11501259f, 0.09615967f, 0.05417288f, 0.04101320f, 0.02413694f, 
    -0.31457141f, 0.06830679f, 0.03197280f, 0.07436250f, -0.02260816f, -0.06266751f, -0.01426947f, -0.10729534f, 
    -0.04523912f, -0.05744810f, 0.00187119f, 0.02946967f, -0.15853131f, -0.21722540f, 0.14773130f, 0.04013741f, 
    0.11632075f, 0.07094361f, -0.07429393f, -0.01244712f, 0.13123208f, 0.03928913f, -0.00300456f, 0.11167575f, 
    -0.11431076f, -0.13903809f, -0.04883124f, 0.04136145f, 0.14300361f, 0.04797013f, -0.01948329f, 0.03702351f, 
    0.04791262f, 0.01651825f, -0.05631885f, 0.01241843f, -0.20155221f, -0.15161714f, -0.14622079f, -0.20685688f, 
    -0.02991064f, -0.17461713f, -0.15202580f, -0.09674403f, 0.03945728f, -0.06730089f, -0.03832546f, 0.02703437f, 
    -0.34584236f, 0.34808806f, -0.05496763f, -0.00591076f, 0.03571042f, -0.02583315f, -0.09527965f, -0.11756799f, 
    0.11207274f, 0.09377608f, 0.07813695f, 0.04897564f, -0.00368124f, -0.04726434f, -0.13101709f, 0.15068279f, 
    -0.01697187f, -0.00395708f, 0.03790483f, -0.02372966f, 0.03459109f, 0.02927720f, 0.10035990f, -0.08913519f, 
    0.22822225f, 0.05184868f, -0.01047679f, -0.07361476f, -0.09249069f, -0.02857539f, -0.10116916f, 0.02028982f, 
    -0.01317746f, 0.12912537f, 0.21499538f, 0.14002165f, -0.04523932f, 0.08004273f, -0.14435205f, 0.00706060f, 
    -0.04825638f, 0.02501354f, 0.14575945f, 0.07415111f, 0.12701900f, -0.06119546f, 0.16027337f, -0.08911047f, 
    -0.20251012f, -0.10608210f, -0.04178783f, -0.12300815f, 0.12663408f, -0.00368030f, -0.04240102f, 0.13149166f, 
    -0.05954253f, -0.09974524f, -0.02295898f, -0.02423181f, -0.17375979f, -0.25761047f, 0.00063317f, -0.16663189f, 
    -0.03878172f, 0.05660792f, -0.06839355f, -0.14176258f, -0.00336215f, -0.01795387f, -0.01641594f, 0.08499410f, 
    -0.28069696f, 0.11904766f, 0.02819998f, -0.11064076f, -0.02564381f, -0.06895879f, -0.06099277f, -0.07626300f, 
    0.07908118f, 0.12525587f, 0.02681537f, 0.01242706f, -0.02351541f, -0.00273495f, -0.11434666f, 0.04026112f, 
    0.12238469f, -0.07993954f, 0.18374760f, -0.06212769f, 0.01736881f, 0.12610440f, -0.12109249f, -0.09813406f, 
    -0.03160087f, 0.00884816f, -0.25321636f, -0.37742123f, 0.01356098f, -0.07123583f, -0.11773916f, 0.02650900f, 
    -0.15297200f, -0.07057958f, -0.01008324f, 0.06591965f, -0.20385252f, 0.06665807f, -0.08800647f, -0.08633301f, 
    0.11771769f, 0.02960634f, -0.06129759f, 0.08388704f, -0.06684474f, -0.01230536f, -0.02026586f, 0.13448785f, 
    0.01595714f, 0.00086532f, 0.00871900f, 0.01198145f, -0.00032956f, -0.00438796f, -0.03858449f, -0.01049664f, 
    -0.03141019f, -0.02454201f, -0.02264003f, -0.02193876f, -0.00138971f, -0.03072230f, -0.03164009f, 0.01261890f, 
    0.00956951f, -0.03889177f, 0.00692424f, -0.03718827f, -0.01190570f, -0.02142911f, -0.01873262f, 0.00489160f, 
    -0.01308345f, -0.02033657f, 0.00191097f, 0.01800690f, -0.01867912f, 0.03015537f, 0.00998748f, 0.02246065f, 
    -0.03459677f, 0.01135758f, -0.03315401f, 0.01318146f, 0.01538587f, -0.03931908f, -0.03983584f, -0.01511489f, 
    0.00260072f, -0.02859803f, 0.02910566f, 0.02251802f, 0.02739535f, 0.01691303f, -0.00688685f, 0.01844553f, 
    0.02699183f, 0.01809749f, -0.01201206f, 0.01514366f, 0.01449625f, -0.03575668f, -0.01892004f, 0.02393077f, 
    0.02009870f, -0.03239760f, 0.02854720f, 0.01720900f, -0.01404390f, -0.02042638f, -0.03256525f, -0.00328045f, 
    0.00080161f, 0.02327039f, 0.00989058f, -0.00901925f, -0.00876275f, 0.02980318f, 0.01695809f, -0.02997563f, 
    0.01257058f, -0.03972108f, -0.01030820f, -0.01655505f, -0.00885622f, 0.02657891f, 0.01222395f, -0.04017445f, 
    -0.00855742f, 0.03076861f, 0.02134377f, 0.02044038f, -0.04122830f, 0.00192115f, -0.00903845f, -0.00481827f, 
    -0.01154046f, 0.01160340f, -0.02206139f, -0.01727328f, -0.03559002f, -0.01369101f, 0.02719572f, -0.02259032f, 
    0.01768430f, -0.02773975f, -0.03183934f, -0.02900166f, -0.01890873f, -0.01114179f, -0.03543529f, 0.01520840f, 
    0.02145850f, -0.03876594f, 0.01290850f, 0.01853128f, -0.00624492f, -0.00490528f, -0.03218909f, 0.00201794f, 
    -0.00421151f, 0.02656558f, -0.02716271f, 0.00222704f, 0.02309650f, 0.01193458f, 0.00267642f, -0.01414740f, 
    0.00514876f, -0.00300135f, -0.01298591f, -0.00281971f, 0.00266458f, 0.00187216f, 0.02546528f, -0.01736870f, 
    -0.01848177f, 0.00335922f, -0.00271615f, 0.01984207f, -0.00101123f, 0.01201961f, -0.02259735f, -0.02169898f, 
    0.02643500f, -0.01387984f, -0.02910133f, 0.02376115f, -0.01738467f, -0.03887714f, -0.01475083f, -0.01219377f, 
    -0.01033910f, -0.03360820f, 0.00283658f, 0.00242022f, 0.00792282f, -0.00423992f, -0.01066706f, 0.00145946f, 
    0.00245873f, 0.00264308f, -0.00081730f, -0.00089401f, 0.03021650f, -0.01902238f, -0.01992401f, 0.01597974f, 
    0.01718320f, -0.01975964f, -0.02118696f, 0.00226217f, -0.03358554f, -0.01128765f, -0.03018963f, 0.00297734f, 
    -0.03186155f, 0.00096380f, -0.03838519f, 0.02492968f, -0.03106359f, 0.00091813f, 0.00013931f, 0.01960739f, 
    -0.02018665f, -0.02015239f, 0.00710814f, -0.04027344f, -0.03327783f, 0.01878126f, -0.03997842f, -0.01362013f, 
    -0.01372455f, 0.02966347f, -0.02005876f, 0.00159635f, -0.00917150f, -0.03733539f, -0.03584867f, -0.00074945f, 
    -0.03268429f, 0.02373385f, 0.02885193f, 0.02190387f, -0.01857258f, -0.02245510f, -0.01487656f, -0.01817285f, 
    -0.03506696f, -0.03773321f, -0.01864090f, -0.00612942f, -0.02909955f, -0.00884774f, -0.03779303f, -0.01203114f, 
    -0.01274095f, -0.02041082f, -0.01524856f, -0.01146331f, 0.02547607f, 0.02537158f, 0.02632291f, -0.03740200f, 
    0.01194989f, -0.00656468f, -0.01199764f, 0.01561266f, 0.00328781f, -0.02171271f, 0.02671267f, -0.02146088f, 
    -0.03358183f, 0.01186387f, -0.03758067f, 0.00833383f, 0.02034041f, -0.01091136f, -0.00251153f, 0.04053785f, 
    -0.03067675f, -0.00493933f, 0.00143222f, -0.04065509f, 0.01939151f, -0.03440587f, -0.03796705f, 0.00687147f, 
    -0.03457196f, -0.03173786f, -0.03525367f, 0.02770182f, -0.01589777f, -0.01651845f, 0.01894905f, 0.02132655f, 
    -0.00696077f, -0.03451185f, 0.01364998f, 0.02831389f, -0.01004440f, 0.02343779f, -0.01317563f, -0.01919961f, 
    -0.00477190f, -0.01482183f, -0.03647041f, -0.03198534f, 0.02403739f, 0.00810328f, -0.01005594f, -0.02029231f, 
    -0.01372430f, -0.02823460f, 0.00510902f, 0.01096284f, 0.02013588f, 0.00649084f, 0.01201347f, 0.02274936f, 
    -0.03423975f, -0.00781405f, -0.02971810f, 0.01665912f, 0.00585238f, -0.02800060f, 0.01373107f, -0.04065446f, 
    0.01759050f, 0.01495426f, -0.03573727f, 0.02776909f, 0.02418319f, -0.03107960f, 0.00028464f, 0.02009816f, 
    0.02526139f, -0.03516455f, -0.01082410f, 0.01915697f, -0.00986552f, -0.00857597f, 0.02060313f, 0.01087038f, 
    0.00226273f, 0.02302123f, -0.02571562f, -0.01383805f, 0.00292071f, 0.01464122f, 0.00112719f, 0.02851634f, 
    -0.01376859f, -0.00575899f, -0.03773715f, -0.01787409f, -0.02423799f, 0.01536641f, -0.03601991f, 0.01617272f, 
    -0.01814020f, -0.01273691f, -0.00417503f, -0.02918936f, 0.01435383f, 0.00850989f, -0.03402079f, -0.02709002f, 
    0.01353264f, 0.01541432f, -0.03131310f, 0.02708267f, 0.00847897f, 0.02375740f, -0.02444283f, 0.00926849f, 
    -0.00130597f, 0.02390000f, 0.02132218f, 0.02832628f, 0.02735431f, 0.02132263f, 0.02026593f, -0.03697260f, 
    -0.00957470f, 0.02200357f, -0.01433952f, -0.01049497f, -0.00333492f, -0.02659623f, -0.00128855f, 0.00067793f, 
    0.00944335f, -0.00870774f, 0.03154945f, -0.03086010f, 0.01587066f, 0.00586604f, -0.01331342f, -0.01201319f, 
    -0.02067232f, -0.04173892f, -0.00009012f, -0.03262781f, -0.01712169f, -0.02777502f, -0.04106503f, 0.02222251f, 
    0.00107050f, -0.03597262f, 0.00931611f, -0.02764534f, 0.02441747f, -0.00604156f, 0.01095108f, -0.01110503f, 
    0.00822704f, 0.02125663f, -0.00137983f, 0.00631976f, 0.00560245f, -0.00322490f, -0.01903611f, -0.00007506f, 
    0.00501980f, -0.00860387f, 0.00657646f, -0.01414739f, -0.00106983f, -0.03216191f, 0.00361328f, -0.00293178f, 
    0.00014392f, 0.00790439f, -0.02741448f, 0.02829027f, 0.01141073f, 0.01419218f, 0.01868623f, -0.03113610f, 
    0.01462997f, 0.00832891f, -0.03227820f, 0.01136580f, -0.00786608f, -0.01403718f, -0.02773798f, -0.01637268f, 
    -0.02440287f, 0.02128466f, -0.02459762f, -0.04150346f, 0.02485388f, 0.00135096f, 0.01137934f, -0.00423629f, 
    0.00065903f, 0.00473207f, 0.02797833f, -0.02258464f, -0.00364091f, 0.01637291f, -0.00138284f, -0.01431924f, 
    0.00831007f, -0.03713965f, 0.01092502f, -0.03946776f, -0.02582156f, 0.02794339f, -0.03940234f, -0.01853032f, 
    0.02213853f, 0.01751835f, 0.02486550f, -0.00179999f, 0.01859471f, -0.01532437f, -0.00041461f, -0.03010815f, 
    -0.00499224f, -0.00618347f, -0.03946115f, 0.00138396f, -0.02560813f, -0.00247149f, 0.02905833f, -0.02742202f, 
    -0.03324031f, 0.02107340f, 0.01149493f, 0.01252346f, 0.02503510f, -0.03448598f, 0.00932205f, -0.01350993f, 
    0.00713677f, -0.03153244f, -0.02909349f, 0.02674121f, 0.00846238f, -0.02362269f, -0.00415264f, -0.02467791f, 
    0.01846076f, -0.01378637f, -0.00552473f, -0.01654509f, 0.01153405f, 0.00442253f, -0.01279933f, -0.00964170f, 
    -0.01584249f, -0.03170402f, 0.01186401f, -0.00712842f, 0.02651049f, -0.00947157f, 0.02143480f, -0.00801894f, 
    0.02463446f, -0.04166010f, -0.00079449f, 0.00038571f, 0.02911843f, -0.02123325f, 0.01827443f, 0.02069821f, 
    -0.03002488f, 0.01889805f, -0.01354598f, -0.04166973f, -0.00937328f, 0.00832112f, -0.02506857f, 0.00614424f, 
    0.00905049f, -0.03694675f, 0.01865814f, 0.00140536f, 0.00101698f, -0.03502391f, 0.01535170f, -0.00529452f, 
    0.02849895f, -0.00415544f, -0.01930431f, -0.03946085f, -0.00486207f, 0.00092240f, -0.03322684f, 0.02481002f, 
    -0.02472661f, -0.01830751f, -0.01239669f, 0.00457914f, 0.02189194f, -0.01410108f, -0.01558435f, -0.00453501f, 
    -0.01636978f, -0.02519616f, -0.02303773f, -0.00236566f, 0.02462280f, -0.03106221f, 0.01030348f, 0.01104326f, 
    -0.03090038f, 0.00992603f, 0.01687022f, 0.02074234f, -0.03155560f, -0.02872165f, 0.01896398f, -0.01581504f, 
    0.02069456f, -0.00108260f, -0.00691908f, 0.00770151f, 0.00755792f, 0.02454292f, -0.00223110f, -0.00803102f, 
    -0.03066606f, -0.03655980f, 0.02057350f, -0.03591999f, 0.01990581f, -0.02613210f, 0.02783794f, 0.02488042f, 
    -0.01739855f, -0.02149953f, -0.02043911f, 0.00595385f, -0.00624957f, -0.02468543f, -0.00334155f, 0.00193183f, 
    -0.00667033f, -0.02946462f, 0.01361047f, -0.03078267f, -0.00297795f, -0.02138975f, -0.03145630f, -0.01143891f, 
    -0.01026857f, 0.02725008f, -0.02738645f, -0.03840958f, 0.02336950f, -0.00029852f, -0.01766946f, -0.03740107f, 
    -0.03952786f, 0.00294036f, -0.03780549f, -0.02666871f, -0.02423992f, -0.02943676f, -0.02658873f, -0.01806132f, 
    -0.03255192f, -0.02218297f, -0.01557553f, -0.03683940f, -0.03788779f, 0.00043063f, -0.03840737f, 0.01464365f, 
    -0.02802574f, -0.03877275f, 0.01276460f, -0.04008095f, 0.01138580f, -0.03795562f, 0.00544023f, -0.01942450f, 
    -0.00906631f, 0.00022223f, -0.02684597f, 0.01725874f, 0.00877955f, -0.00185863f, 0.01508230f, 0.01121544f, 
    0.02589528f, -0.01705663f, -0.01352621f, 0.01649012f, 0.00948289f, -0.01246812f, 0.00257303f, -0.02661671f, 
    -0.03735652f, 0.01131067f, -0.02204719f, -0.01687108f, 0.01248865f, -0.01840390f, 0.02817475f, -0.03504647f, 
    0.02116970f, -0.01699974f, -0.02000206f, -0.04159178f, 0.02885569f, 0.01885842f, -0.02406256f, -0.02109644f, 
    0.00380372f, -0.01080234f, -0.01346501f, -0.01800930f, -0.04128163f, 0.02839064f, -0.01888576f, 0.02195304f, 
    0.02170787f, 0.01654607f, -0.03464260f, -0.03319904f, -0.02401863f, -0.02995385f, 0.02433855f, -0.02851936f, 
    -0.02775321f, 0.01300685f, -0.02610801f, -0.01809016f, 0.02394977f, 0.00896464f, 0.01509284f, 0.03957809f, 
    0.00118866f, 0.00364607f, 0.02959393f, 0.02608078f, -0.04026790f, 0.02458840f, -0.02657698f, -0.02268074f, 
    0.03698716f, -0.00905395f, -0.00367829f, 0.01509008f, 0.01986052f, -0.02661827f, 0.00220571f, -0.02770755f, 
    0.00294444f, -0.00514392f, -0.01891385f, -0.01283007f, 0.01126134f, 0.01725992f, -0.03183310f, -0.04058090f, 
    -0.00281858f, 0.01100712f, -0.02419456f, 0.01441972f, -0.01919306f, -0.00526433f, -0.01725142f, -0.01329999f, 
    -0.04031002f, 0.00288827f, -0.00499081f, -0.02128906f, 0.02674700f, -0.00102399f, -0.03298717f, -0.03941510f, 
    0.01491211f, 0.00329667f, -0.02581230f, 0.00106615f, -0.04113717f, -0.03195965f, 0.02823233f, 0.01555668f, 
    -0.00102581f, -0.00629620f, 0.02730425f, -0.03146464f, 0.00764907f, 0.00660542f, -0.01678350f, -0.01981764f, 
    -0.03996116f, 0.02948502f, 0.01425980f, 0.01450635f, 0.02955924f, -0.02229789f, -0.00342263f, -0.01687646f, 
    0.02345775f, -0.00892053f, -0.03393793f, -0.00092307f, -0.01280179f, -0.02686721f, 0.00499144f, 0.00595643f, 
    0.02541776f, -0.04118410f, 0.00215662f, 0.02971227f, -0.02474528f, -0.02001867f, -0.02712801f, 0.00425397f, 
    -0.01658924f, 0.03585489f, 0.02569330f, -0.01302133f, -0.03670621f, 0.00756393f, 0.01185931f, -0.03573948f, 
    0.01116568f, -0.01090430f, 0.02594733f, -0.00717236f, -0.01767566f, 0.00035510f, 0.03246854f, 0.02087681f, 
    -0.02673533f, 0.00444505f, -0.02983344f, -0.00053774f, 0.00233354f, -0.02144405f, -0.00224111f, 0.01831063f, 
    0.01660957f, 0.03034355f, 0.01153081f, -0.03679356f, 0.01479417f, 0.00650110f, 0.01428538f, -0.02189123f, 
    0.02882914f, -0.00219990f, -0.00476486f, -0.03590724f, 0.00636661f, -0.00021333f, -0.02905001f, 0.01205774f, 
    -0.22279947f, -0.49672133f, -0.26210999f, 0.09126963f, -0.03263337f, -0.05745310f, 0.00160007f, -0.09638952f, 
    -0.04165162f, -0.00089807f, 0.02029675f, 0.02109925f, 0.05505437f, -0.29351979f, -0.21621069f, 0.06828889f, 
    -0.04817139f, -0.00159439f, 0.02644241f, 0.04323313f, -0.04792320f, 0.05818740f, 0.10160724f, 0.11753070f, 
    0.12187424f, -0.04118529f, -0.07430581f, 0.40570962f, 0.18283918f, 0.09675020f, 0.12425057f, 0.02394775f, 
    -0.17217727f, -0.09706130f, 0.03253194f, -0.25200513f, 0.00971216f, 0.27403805f, 0.26012257f, -0.00148772f, 
    0.10560072f, 0.01652315f, -0.00811136f, -0.06498762f, -0.05081517f, 0.00624776f, 0.04509821f, 0.04615763f, 
    0.25256023f, 0.03884538f, -0.11251659f, 0.03556053f, 0.01358893f, 0.05590304f, 0.13381779f, -0.05268616f, 
    -0.03484541f, 0.09385041f, 0.08974765f, 0.04434050f, -0.53883845f, -0.54963332f, -0.14740841f, 0.02337334f, 
    0.05869377f, -0.15069747f, 0.00274706f, 0.05016934f, 0.08126172f, 0.14203998f, -0.02021209f, 0.09978079f, 
    0.27080926f, 0.13391651f, 0.13204026f, 0.16970438f, -0.01381197f, 0.08017860f, 0.11327370f, -0.19472988f, 
    -0.05891484f, 0.01226842f, -0.01788147f, -0.08113404f, -0.00869760f, 0.19161946f, 0.26431051f, 0.07398727f, 
    0.10295326f, 0.05304982f, 0.01924449f, -0.12376295f, -0.01536498f, 0.08037195f, 0.15849718f, 0.11442930f, 
    0.25062037f, 0.21600606f, -0.07875362f, -0.16675712f, 0.00598045f, 0.01910148f, -0.12744664f, 0.01946513f, 
    0.03073684f, -0.08085944f, 0.19587553f, -0.00089615f, -0.10817993f, -0.22816500f, -0.09159152f, 0.08729918f, 
    -0.02870471f, 0.21368697f, 0.23573887f, 0.12752171f, 0.13665289f, -0.15624656f, -0.23103249f, -0.05406342f, 
    0.12150084f, -0.08962775f, -0.04097823f, 0.04824035f, 0.02264454f, 0.06625034f, -0.09255042f, 0.02950739f, 
    -0.13056742f, 0.09470227f, 0.03799895f, 0.05394495f, 0.05103891f, 0.18333289f, 0.19327530f, -0.13372478f, 
    -0.10062113f, -0.02341532f, -0.08551045f, -0.00044077f, 0.12941480f, 0.10271128f, 0.09298170f, 0.07110990f, 
    0.16414426f, 0.07587702f, 0.13971506f, -0.12144060f, -0.02786075f, -0.03161670f, -0.03618809f, 0.02247122f, 
    -0.04180498f, 0.30699393f, 0.12396605f, -0.08163717f, 0.44737282f, 0.12744085f, 0.09933542f, -0.07437035f, 
    0.00783113f, 0.02663772f, 0.15731673f, 0.02782175f, -0.06310591f, 0.00048632f, 0.15483351f, -0.09788190f, 
    -0.08731613f, -0.17478016f, -0.27783728f, -0.19600658f, -0.09269962f, 0.16870078f, 0.02169132f, 0.15279505f, 
    0.09080657f, -0.03087626f, -0.05371205f, -0.18826695f, 0.16932246f, 0.13859750f, 0.19735214f, 0.15380505f, 
    0.02001358f, 0.18112153f, 0.10142372f, -0.09286869f, 0.00481444f, 0.08640191f, -0.13490529f, 0.07418977f, 
    0.08613969f, 0.13932167f, -0.13023157f, -0.15178818f, -0.17710887f, -0.03881697f, 0.03934721f, 0.01974276f, 
    -0.04266176f, -0.10301320f, 0.05700485f, 0.08180999f, -0.19183299f, -0.08304005f, 0.24365219f, 0.05285830f, 
    -0.08908000f, 0.00799768f, -0.11009135f, -0.16392049f, 0.02037415f, -0.16021572f, -0.08379751f, -0.00891169f, 
    0.06472099f, 0.05941941f, 0.09523431f, 0.05394672f, 0.00530625f, 0.02904722f, 0.15872908f, -0.03401637f, 
    0.01690657f, -0.07757615f, 0.03187093f, -0.04414730f, 0.07271470f, -0.09271629f, -0.33214569f, 0.31981272f, 
    -0.03341383f, -0.05456886f, 0.18913044f, 0.16407767f, 0.24420753f, 0.03076489f, -0.06490389f, -0.22383833f, 
    0.34507176f, 0.01706434f, -0.27929404f, 0.01488630f, 0.06499907f, -0.01104876f, 0.09198641f, -0.06536261f, 
    -0.09994775f, 0.02259438f, 0.01826530f, 0.02015758f, -0.17579949f, -0.25228292f, -0.17058600f, 0.02656298f, 
    -0.00379280f, 0.06337264f, 0.12842600f, 0.05107427f, 0.00712232f, -0.03198793f, 0.01207820f, 0.01278633f, 
    0.25371489f, 0.05454184f, -0.09808417f, -0.18290116f, -0.00097513f, 0.04264620f, -0.04338733f, -0.05723695f, 
    0.05023087f, -0.00079490f, 0.13422529f, -0.00262776f, -0.04997961f, -0.31788272f, 0.01123591f, 0.29277459f, 
    -0.01551078f, 0.14352642f, 0.24223572f, -0.05245375f, 0.10479078f, 0.05995490f, 0.03836594f, 0.04549940f, 
    0.06788104f, 0.17859970f, 0.14082238f, 0.02773892f, -0.00404824f, 0.00435500f, 0.04831457f, -0.14520887f, 
    -0.00372469f, 0.05504763f, -0.07741863f, 0.02594509f, 0.40557030f, 0.07607921f, -0.13647592f, -0.49877647f, 
    0.00545929f, 0.16736996f, -0.03585064f, 0.03907714f, -0.01489517f, -0.04054840f, 0.22195207f, -0.01174139f, 
    -0.11414063f, 0.04878620f, -0.12320907f, -0.25798556f, -0.09569442f, 0.04536173f, 0.01170757f, 0.07077681f, 
    0.11203609f, 0.03803858f, 0.00290625f, 0.11158849f, 0.14425087f, 0.24007554f, 0.27760199f, -0.04730016f, 
    -0.02014707f, -0.02283932f, 0.01575824f, -0.08436828f, 0.11765312f, 0.06085195f, 0.02881580f, 0.00477208f, 
    -0.09814907f, -0.08776959f, -0.04819329f, 0.16681780f, 0.16143210f, 0.01073343f, -0.01905368f, -0.09879335f, 
    0.03013155f, -0.01614735f, 0.03342202f, -0.12130504f, 0.41830859f, 0.18372676f, 0.15917993f, -0.03562414f, 
    0.04303873f, -0.05956967f, 0.13015550f, -0.15296854f, -0.03920602f, 0.10337653f, -0.06650981f, 0.02432374f, 
    0.27777079f, -0.02950791f, 0.17999983f, -0.08926140f, -0.09469554f, 0.15834653f, 0.28287327f, 0.17686705f, 
    0.02997526f, 0.04956590f, 0.18576770f, -0.10532798f, -0.66211236f, -0.34057081f, -0.17890970f, 0.14455523f, 
    -0.19928251f, -0.18621956f, 0.06418966f, 0.14787549f, 0.01505535f, 0.06198989f, -0.02716399f, -0.03046642f, 
    0.09387255f, -0.29293656f, 0.00979682f, 0.00619922f, 0.07621055f, 0.18515378f, 0.12195913f, 0.02601834f, 
    -0.05711631f, -0.05303047f, -0.09725596f, -0.09820507f, -0.14168513f, 0.13429587f, -0.05461012f, -0.02140208f, 
    -0.00279232f, -0.08794273f, 0.14471467f, 0.02383409f, 0.07022992f, -0.04796445f, 0.13887396f, -0.04372745f, 
    0.16846247f, 0.00578725f, -0.23642233f, -0.33528605f, 0.08916937f, 0.08815016f, 0.07464132f, 0.17900404f, 
    -0.04553489f, -0.15999763f, 0.14049880f, -0.11987414f, -0.61170161f, -0.32105565f, -0.23502122f, -0.12711738f, 
    -0.08500921f, -0.10018857f, -0.11185654f, -0.01283673f, 0.02606508f, 0.05681407f, -0.00807370f, -0.16562650f, 
    0.06386246f, -0.10170741f, -0.15020856f, 0.05449336f, 0.04765874f, -0.17235599f, -0.22879247f, -0.06189515f, 
    -0.03617103f, -0.06511509f, 0.16863619f, -0.02192104f, -0.16991585f, -0.27279380f, -0.22691856f, -0.21625154f, 
    0.05111826f, -0.02646391f, -0.01826678f, 0.04256804f, -0.08956914f, 0.07805344f, 0.06409069f, 0.20364450f, 
    -0.01358666f, -0.15918809f, -0.36444521f, 0.08645406f, -0.11151626f, 0.09909029f, 0.16005766f, -0.03301281f, 
    0.00995713f, 0.00411096f, 0.03108969f, 0.04612836f, 0.18361382f, 0.15202473f, -0.03551256f, -0.21446972f, 
    0.01476212f, 0.04089165f, -0.10232714f, 0.09106212f, -0.08125406f, 0.15578052f, 0.09995646f, 0.10060952f, 
    -0.29071641f, -0.39490047f, 0.04545586f, 0.08170357f, -0.06755018f, 0.03714589f, 0.06273304f, 0.02980613f, 
    0.01036057f, 0.11785886f, 0.15070412f, -0.14544691f, 0.16255009f, 0.03868484f, 0.14812633f, 0.02965109f, 
    -0.00226054f, 0.01226249f, 0.00275597f, 0.04669591f, -0.02737358f, -0.05500427f, -0.01131405f, 0.02863026f, 
    0.22885649f, 0.08165497f, 0.00871260f, -0.18153031f, 0.00753855f, -0.04982758f, -0.01221259f, -0.02930202f, 
    0.11853399f, 0.08018344f, 0.24188733f, 0.11051867f, 0.42973235f, 0.10969013f, 0.22193760f, -0.03181819f, 
    -0.05912856f, -0.02510231f, 0.16053100f, -0.12937962f, -0.11533803f, 0.00596043f, 0.01704598f, 0.02966366f, 
    0.15257148f, -0.18150850f, -0.27196038f, 0.50113946f, 0.10236508f, 0.12558807f, 0.21103436f, -0.05239281f, 
    -0.05481704f, 0.00199846f, 0.03594375f, -0.10315920f, 0.01080710f, -0.16033067f, 0.01248567f, -0.01355199f, 
    -0.16507229f, -0.00979879f, 0.16280645f, 0.08211384f, -0.12473160f, -0.01434228f, -0.02956559f, -0.09576342f, 
    -0.01053017f, -0.57666802f, -0.48178005f, -0.19129904f, 0.14460403f, 0.00530342f, -0.08782130f, -0.12937783f, 
    -0.21218209f, 0.05765103f, -0.15134701f, -0.08496160f, 0.15224737f, 0.15371281f, 0.05150013f, -0.10443900f, 
    0.04191941f, 0.02083498f, -0.04615010f, -0.14734982f, -0.07035866f, -0.04435934f, -0.01194581f, 0.11139830f, 
    0.13532810f, 0.00423865f, 0.16006258f, -0.12990357f, -0.12073132f, 0.20757654f, -0.03411068f, 0.03136325f, 
    0.06987018f, 0.06103278f, 0.20655264f, -0.01690686f, -0.51119256f, -0.30560744f, 0.03639720f, 0.17694433f, 
    0.09272178f, 0.07711870f, 0.14775993f, 0.02439103f, -0.12874368f, 0.09193887f, 0.05116299f, 0.00611202f, 
    0.20477292f, 0.28585708f, 0.17937918f, -0.00003984f, -0.03183714f, 0.05358300f, 0.02209259f, -0.11719725f, 
    -0.10808071f, -0.01006668f, 0.02496579f, -0.00935983f, -0.54449046f, -0.39899069f, -0.37746036f, 0.10402147f, 
    -0.03231661f, 0.10118594f, 0.10394184f, 0.10649282f, 0.01082621f, 0.10862006f, 0.20440824f, 0.19586141f, 
    -0.34256864f, -0.47785157f, -0.26763630f, -0.07021010f, 0.00371742f, -0.17662396f, 0.02307090f, -0.11976486f, 
    0.05094189f, 0.06224872f, -0.04162145f, 0.07764086f, 0.05129182f, 0.21643779f, 0.14135318f, 0.02118958f, 
    -0.00492931f, 0.07384095f, 0.04709071f, 0.06338741f, 0.06330980f, 0.02926876f, -0.02957727f, 0.10984720f, 
    0.03551701f, 0.07457986f, 0.26749665f, 0.34664047f, 0.01087575f, -0.09025235f, 0.08101159f, -0.09286687f, 
    0.06038324f, -0.05068089f, -0.04759741f, -0.06431516f, 0.28266463f, 0.40626371f, 0.28005207f, -0.05483583f, 
    0.05573088f, 0.05536545f, 0.20311312f, 0.07911327f, 0.02068847f, 0.04987451f, 0.00335477f, 0.04230500f, 
    0.10521011f, 0.09851770f, -0.01795942f, -0.01683557f, -0.03133958f, -0.05571871f, -0.01839977f, -0.03250290f, 
    0.15020896f, 0.03883174f, 0.14207269f, 0.08861738f, 0.05866840f, 0.03564813f, -0.00529122f, 0.07678472f, 
    -0.08888913f, 0.07796552f, 0.05314179f, 0.12307467f, 0.01510344f, 0.02291757f, 0.04604529f, -0.02039111f, 
    0.32628885f, -0.11418239f, -0.42901105f, -0.32662818f, 0.03924781f, -0.09219453f, -0.13486847f, -0.01563534f, 
    -0.05762020f, 0.00430660f, 0.01285233f, 0.03959893f, 0.26606280f, 0.17505191f, 0.00124018f, 0.01053817f, 
    0.06872705f, -0.00648292f, 0.01801548f, -0.01397151f, -0.09313026f, -0.01043372f, 0.03921233f, 0.00521860f, 
    0.01059214f, -0.00522059f, 0.10819075f, 0.25847003f, -0.07101148f, 0.02706720f, 0.13952863f, 0.11411352f, 
    -0.00388769f, 0.05934040f, 0.10125457f, 0.01892951f, -0.01865012f, -0.03647566f, -0.03595864f, -0.12852333f, 
    0.13252288f, -0.05871547f, -0.05254303f, -0.01713565f, 0.02274798f, 0.13251597f, 0.06577085f, -0.13317578f, 
    -0.07070467f, 0.05946217f, 0.07246578f, -0.15591730f, 0.02324210f, 0.09150343f, 0.00607263f, 0.01555389f, 
    0.21623988f, 0.10406420f, 0.14497671f, 0.15648238f, 0.17582069f, -0.18514463f, -0.46226206f, -0.41196543f, 
    0.15164846f, -0.14177126f, -0.02711473f, 0.00446453f, -0.22644310f, -0.13504015f, -0.10816406f, -0.06202164f, 
    0.06673772f, 0.06979834f, -0.03704491f, 0.13839830f, -0.00977596f, -0.01761542f, -0.17723490f, -0.08672900f, 
    -0.03655513f, 0.03230809f, -0.05930557f, 0.08834530f, 0.03806897f, -0.05818504f, 0.31873661f, -0.03344096f, 
    0.06016200f, -0.05603453f, -0.17480625f, -0.02673819f, 0.10286917f, 0.06804264f, 0.19350564f, 0.04701607f, 
    -0.36211270f, -0.01523481f, 0.22942245f, -0.03145551f, 0.01632649f, -0.20881934f, 0.11391964f, 0.14402170f, 
    0.03257612f, 0.08873242f, -0.17371520f, 0.00765888f, 0.14566937f, -0.12612580f, -0.03717310f, -0.05240425f, 
    0.04679061f, -0.07699648f, -0.07220820f, 0.10647170f, 0.03973271f, -0.08657315f, 0.07941707f, 0.07265887f, 
    0.11742264f, 0.02999111f, 0.19509752f, 0.21292375f, 0.01140523f, 0.02078730f, -0.01135570f, -0.02230412f, 
    0.12714908f, 0.10084141f, 0.00816551f, 0.01575558f, 0.31920794f, 0.23505266f, 0.06007002f, -0.14234428f, 
    0.00135320f, 0.07775874f, -0.17264086f, -0.06303454f, 0.03422040f, 0.07848404f, -0.01462043f, -0.10850848f, 
    0.17089485f, -0.01576561f, -0.07371958f, 0.07088570f, -0.02627159f, 0.23293073f, 0.11119817f, 0.06069090f, 
    -0.01314047f, -0.06974013f, 0.02492688f, -0.10931418f, 0.09629469f, -0.23127291f, -0.04053522f, -0.16662391f, 
    0.05450275f, 0.10633261f, -0.03772477f, -0.03953939f, 0.02917795f, 0.06035449f, -0.00747344f, 0.14330576f, 
    0.07545494f, 0.06646948f, 0.12387887f, -0.02323296f, -0.03317675f, -0.03201854f, -0.01668295f, 0.10182181f, 
    -0.06472485f, -0.00699259f, -0.14526287f, -0.03684685f, 0.08438978f, -0.10961117f, 0.03772338f, -0.10500306f, 
    -0.00096067f, 0.04533847f, 0.04527137f, 0.18830654f, 0.17169245f, 0.05788116f, 0.03524810f, 0.22222379f, 
    -0.00042159f, 0.03291733f, 0.13061814f, 0.12649404f, 0.06232303f, 0.09099165f, 0.14677410f, 0.13248311f, 
    0.06969312f, 0.26783660f, 0.15668166f, 0.01536171f, 0.14429091f, -0.06735088f, 0.13004360f, -0.03600496f, 
    0.04353752f, -0.02694099f, 0.00167372f, 0.01852677f, 0.03705268f, 0.36840627f, 0.00572917f, 0.17171218f, 
    -0.03337400f, -0.10406778f, 0.10313946f, 0.04306972f, 0.21325217f, 0.02652782f, -0.07071047f, 0.09466762f, 
    -0.08729471f, 0.03586750f, 0.00556247f, 0.03786688f, 0.52162790f, -0.53663200f, 0.04955687f, -0.36202797f, 
    -0.03870710f, 0.17557581f, -0.06007445f, 0.08079888f, -0.09457165f, -0.00553943f, 0.00120595f, 0.07588757f, 
    -0.24523832f, -0.07807178f, 0.05256728f, -0.05913114f, -0.12249405f, -0.00942462f, -0.07443414f, 0.05701613f, 
    -0.03972383f, 0.16734508f, 0.14670096f, -0.06954655f, 0.19935009f, -0.10164627f, -0.05710288f, 0.02521926f, 
    0.18409185f, 0.15221338f, -0.09219105f, -0.05615314f, -0.01047240f, -0.13447057f, 0.00314464f, 0.05617158f, 
    -0.14497888f, 0.02359484f, -0.10522624f, -0.03320505f, -0.05391472f, -0.03375670f, -0.07037405f, 0.05421871f, 
    -0.07702799f, -0.08274532f, -0.03808321f, 0.13424742f, -0.01070812f, -0.00943124f, -0.09789313f, 0.01909430f, 
    0.07105278f, 0.13462111f, -0.06370871f, -0.09297663f, -0.09666116f, -0.01145056f, -0.03831603f, -0.05221138f, 
    0.04568285f, 0.09531666f, -0.04966684f, 0.04798028f, 0.20442483f, 0.15950243f, 0.03693499f, 0.00573461f, 
    -0.04434022f, -0.06433870f, -0.13929005f, -0.02695073f, 0.48596159f, -0.02608967f, -0.08412663f, -0.31282949f, 
    -0.02535759f, -0.03037629f, 0.21995908f, -0.03908062f, 0.22328255f, -0.08818881f, -0.11292876f, -0.09925963f, 
    -0.09246362f, 0.09597803f, 0.06255804f, 0.14238396f, 0.13837147f, 0.12182607f, -0.02934501f, 0.41929117f, 
    0.00349575f, -0.03184962f, -0.02134014f, 0.01686146f, 0.03005394f, 0.01808327f, 0.22902763f, -0.08422809f, 
    -0.05139146f, -0.10107635f, -0.08807003f, -0.09158089f, -0.02966009f, 0.02438845f, 0.21997184f, 0.08559741f, 
    0.01398482f, 0.00349523f, 0.03809527f, 0.12620187f, 0.01962094f, 0.06984322f, 0.04088471f, -0.01047971f, 
    0.02846051f, 0.11519694f, -0.06207187f, 0.24108368f, 0.06851081f, 0.14838012f, -0.14500527f, -0.34568235f, 
    -0.03846657f, -0.14393744f, -0.11539525f, 0.05948394f, 0.06415523f, 0.01119323f, -0.08704323f, 0.14892477f, 
    0.23528911f, 0.08464035f, 0.06633803f, 0.08847704f, 0.00152146f, 0.01954593f, -0.00575351f, 0.08037505f, 
    0.09299698f, 0.05075851f, 0.02858847f, 0.06234621f, -0.55448234f, -0.37484670f, 0.29783359f, 0.26694006f, 
    0.14020790f, 0.02136740f, 0.11779968f, 0.05523444f, -0.02584561f, -0.06973112f, 0.17117684f, 0.09311162f, 
    0.07378544f, -0.10315187f, 0.00797440f, -0.16775562f, -0.01098966f, -0.03822494f, 0.00732813f, 0.00867618f, 
    -0.04527276f, 0.05090657f, 0.10633944f, 0.07579530f, 0.21125689f, 0.09799216f, 0.05463549f, 0.28153059f, 
    -0.02551912f, 0.03889571f, -0.08182526f, -0.02718866f, -0.06558581f, 0.04189347f, -0.04850015f, -0.00962055f, 
    -0.11339607f, 0.02987449f, 0.10723971f, 0.04197540f, -0.05164007f, -0.06390424f, -0.05325085f, 0.01418340f, 
    -0.08086949f, -0.14730082f, -0.13294698f, -0.03336034f, 0.10259055f, 0.11472949f, 0.11997049f, -0.12151404f, 
    0.00296780f, -0.00036815f, 0.07211870f, -0.11432701f, -0.04910207f, -0.03018159f, -0.08850376f, -0.02102129f, 
    -0.48116273f, -0.07648661f, 0.34769690f, -0.17615977f, 0.28783351f, -0.01161723f, 0.00818539f, 0.15233421f, 
    0.15645677f, 0.08962459f, 0.10975185f, -0.10143825f, -0.36109632f, 0.06154881f, 0.02939172f, -0.07730942f, 
    -0.05483368f, 0.10726827f, -0.21512228f, -0.03495946f, 0.07165118f, 0.11452968f, -0.15051962f, -0.07179046f, 
    0.12728770f, -0.23848762f, 0.24458902f, -0.38807851f, -0.03079605f, 0.02439239f, -0.02585257f, 0.07847615f, 
    -0.05189555f, -0.14848703f, 0.12041381f, 0.06031322f, 0.02949554f, -0.07991457f, 0.00558412f, 0.23247473f, 
    0.00800101f, -0.15631156f, 0.14812541f, -0.00004304f, 0.18487984f, 0.04697591f, -0.09642522f, 0.05485371f, 
    -0.23601958f, 0.07120529f, -0.03353578f, 0.13231978f, 0.03103069f, -0.04475239f, 0.26411691f, -0.07420250f, 
    0.19825110f, -0.09528954f, -0.01268604f, 0.20369788f, 0.05001107f, 0.19367464f, 0.14076616f, -0.04083754f, 
    -0.15597697f, -0.12362997f, -0.08925107f, -0.15001690f, 0.05732137f, 0.08789822f, -0.04781900f, 0.06445371f, 
    -0.11610957f, 0.08491452f, 0.07057089f, 0.01768342f, 0.10486238f, -0.03452947f, 0.02125570f, 0.16486233f, 
    -0.06167291f, -0.12241774f, -0.04390900f, -0.20096973f, -0.04974822f, 0.14618589f, 0.08465925f, -0.01325002f, 
    -0.10302267f, 0.12607433f, 0.05763258f, 0.02772686f, 0.01498508f, 0.03680073f, -0.06441245f, -0.23842518f, 
    0.42145026f, 0.17260818f, -0.02163608f, -0.22331646f, -0.06240354f, 0.07713231f, -0.11232962f, -0.08106109f, 
    0.14047071f, 0.01171299f, 0.08800208f, 0.01723821f, -0.21256652f, 0.01076743f, 0.18176346f, 0.03709764f, 
    -0.10111455f, 0.01042513f, -0.04533022f, 0.13285466f, 0.01797104f, -0.07023454f, 0.17028391f, -0.22265203f, 
    0.09510585f, 0.27329019f, 0.05047137f, -0.03912923f, 0.10044879f, 0.13762523f, -0.20070776f, -0.10053375f, 
    0.08281619f, 0.16138414f, 0.15174177f, 0.28464246f, -0.08166612f, -0.02566296f, 0.02897569f, 0.16654921f, 
    -0.06644900f, 0.05191763f, 0.01614779f, 0.05582061f, 0.07658488f, 0.05606410f, -0.06065904f, 0.09035333f, 
    -0.18076108f, 0.06771822f, 0.04655113f, 0.18363868f, -0.02018198f, -0.01806032f, -0.06076522f, 0.02398769f, 
    -0.01374819f, 0.06316372f, 0.05911840f, 0.05503575f, 0.50161701f, -0.03262892f, 0.05043846f, -0.04778455f, 
    0.04306083f, 0.09368080f, -0.08596077f, 0.07059220f, -0.07841951f, -0.01809352f, -0.05376602f, 0.03179756f, 
    0.71030772f, 0.08289785f, -0.10986131f, -0.17943789f, 0.06676710f, 0.03211449f, -0.07849607f, 0.16136764f, 
    -0.06578840f, -0.01168083f, -0.09530910f, -0.11224559f, 0.10344257f, -0.02285503f, 0.05374463f, 0.03230393f, 
    0.11418887f, 0.02863211f, -0.11095546f, 0.33438462f, 0.16136296f, 0.32688501f, 0.14297168f, 0.02038611f, 
    -0.05503625f, 0.20374225f, 0.25230372f, 0.02486484f, 0.13212766f, -0.04817635f, 0.02171661f, -0.04058468f, 
    -0.07698896f, -0.10912944f, -0.00305190f, -0.10605141f, 0.03583746f, -0.03791811f, 0.10391651f, 0.03330829f, 
    -0.01532304f, 0.00342467f, 0.03964182f, 0.01430937f, -0.04478319f, -0.09040739f, -0.00017214f, -0.07736138f, 
    -0.39689469f, -0.19792359f, 0.17221217f, 0.13024107f, 0.08551592f, -0.03596852f, -0.00779371f, -0.03327708f, 
    0.03766527f, 0.16889724f, -0.02443698f, 0.06009048f, -0.33634263f, 0.47854128f, -0.22307128f, -0.27822235f, 
    -0.06524356f, -0.03195298f, 0.08224393f, -0.12555075f, -0.14850180f, -0.01009060f, -0.11305836f, -0.05013062f, 
    0.35380441f, 0.00923230f, -0.00846695f, 0.06728796f, -0.01176365f, 0.07906622f, -0.06204578f, 0.02061931f, 
    -0.05208099f, -0.02290421f, 0.00953419f, 0.00159207f, 0.22220966f, 0.08099155f, 0.03981287f, -0.04356843f, 
    0.12193538f, -0.04334318f, 0.04093696f, 0.12385073f, 0.10659260f, 0.05700793f, 0.22052504f, 0.08930311f, 
    0.07054851f, 0.32664135f, 0.08172977f, -0.11293509f, -0.01193738f, -0.20421982f, -0.10318945f, -0.20916456f, 
    -0.00296953f, 0.09599200f, 0.02623287f, 0.05451514f, 0.10891895f, 0.07898507f, 0.10709211f, 0.17555870f, 
    0.01446982f, 0.01068414f, -0.04004264f, 0.00579454f, -0.04378350f, -0.03550262f, 0.06167359f, 0.06212782f, 
    0.52030164f, -0.14197724f, -0.02397790f, -0.25515839f, -0.04613535f, -0.02677934f, 0.06057788f, 0.03700711f, 
    -0.02800697f, 0.09240992f, -0.15557139f, 0.00914803f, 0.38661507f, -0.16804741f, 0.13772996f, -0.04585019f, 
    0.06156181f, -0.02517862f, 0.13116974f, -0.09585690f, 0.10566067f, -0.12201346f, -0.01234887f, 0.16643944f, 
    -0.28583390f, -0.16587912f, 0.06638755f, 0.25447160f, -0.00811709f, -0.04730668f, 0.03877768f, 0.06550888f, 
    -0.07333425f, 0.05065334f, -0.10102953f, -0.07346257f, 0.23140430f, -0.05637499f, 0.14432435f, -0.17059962f, 
    0.06013777f, 0.11415455f, -0.10985111f, 0.01378019f, 0.00137757f, 0.10563958f, 0.09007233f, 0.12276061f, 
    0.17089567f, 0.27387074f, 0.32074496f, 0.23444028f, -0.06791899f, -0.05218876f, 0.14185998f, -0.18851966f, 
    0.07080153f, 0.00954674f, 0.03667294f, 0.00457538f, 0.03112073f, 0.08624578f, 0.01269716f, 0.13063855f, 
    0.04995135f, 0.00199970f, -0.01338976f, 0.03383255f, -0.01574544f, -0.08579206f, -0.08729844f, -0.00329979f, 
    0.21271631f, 0.02820608f, -0.22488855f, -0.01176440f, 0.06084160f, -0.02278228f, 0.06444641f, 0.00293107f, 
    0.27967367f, -0.05287734f, 0.10348547f, -0.01731328f, 0.16867428f, 0.03473733f, -0.01463488f, -0.06974719f, 
    0.16011371f, 0.23754616f, -0.02727931f, 0.18303904f, -0.02025311f, 0.01378306f, -0.11715233f, -0.13533498f, 
    -0.03049260f, 0.02424844f, 0.10232734f, 0.21616329f, -0.03620654f, -0.08840517f, 0.00539268f, -0.02248225f, 
    0.11201315f, 0.09613066f, 0.13226464f, 0.06464231f, 0.04215875f, 0.11741883f, 0.27705160f, -0.11314007f, 
    -0.04985799f, -0.02034101f, 0.10604991f, -0.11689271f, -0.01515257f, -0.01420661f, -0.01361331f, -0.01816173f, 
    -0.05322614f, 0.26562509f, -0.04827918f, -0.09180673f, 0.01551941f, 0.05158074f, 0.05630998f, 0.08360032f, 
    0.05175556f, -0.01013459f, 0.09410061f, 0.08815908f, 0.00548730f, 0.16511396f, 0.07363722f, -0.01418807f, 
    0.18718188f, 0.06955127f, 0.08929353f, 0.05654728f, 0.10380517f, 0.00824573f, -0.04600601f, -0.08811576f, 
    0.26867285f, 0.15214273f, 0.05029941f, -0.02073739f, 0.04477619f, 0.08252987f, -0.11402815f, 0.16279989f, 
    0.00495105f, -0.05076776f, 0.02525762f, 0.07581148f, 0.00239614f, 0.24501136f, -0.19757424f, -0.06081403f, 
    -0.01082111f, -0.03348174f, 0.11964624f, 0.10052549f, -0.10597478f, -0.00955476f, -0.06512389f, 0.01021709f, 
    0.23423651f, -0.37294900f, 0.25090373f, -0.08572036f, 0.01501046f, -0.06294468f, 0.23305036f, -0.04274797f, 
    0.00267979f, 0.07580268f, -0.07105576f, 0.07552887f, 0.13108036f, 0.04655546f, 0.09071922f, -0.24556272f, 
    0.07547093f, 0.04388014f, 0.10761672f, 0.04486750f, -0.01302021f, -0.09615754f, 0.06498840f, 0.08494107f, 
    -0.21542275f, 0.02025887f, 0.00956179f, -0.00064072f, 0.19121255f, 0.00173704f, -0.01755346f, 0.22412182f, 
    0.05655624f, -0.09462809f, 0.03386788f, 0.05759215f, 0.24889058f, 0.03593763f, 0.00793735f, -0.16047879f, 
    -0.05478942f, -0.06259245f, -0.07539736f, 0.06986432f, -0.08132929f, 0.02895231f, -0.06342674f, -0.10833806f, 
    -0.01035749f, 0.08447571f, 0.02146538f, 0.03157819f, 0.04591806f, 0.04156930f, -0.06703267f, -0.06302245f, 
    0.02692235f, 0.02856031f, -0.16608781f, 0.12945093f, -0.20412573f, -0.03578620f, -0.01771345f, -0.03606496f, 
    0.19113390f, -0.01765759f, -0.10924080f, -0.07986376f, -0.01166757f, -0.02219688f, 0.03248696f, -0.13770548f, 
    0.06616502f, -0.24473234f, 0.26532415f, -0.16046302f, 0.26534331f, 0.02754840f, 0.17520268f, -0.18051298f, 
    0.04925534f, -0.09962138f, 0.03063689f, -0.07920946f, -0.18078949f, -0.14380126f, -0.10186928f, 0.18396990f, 
    0.05643495f, -0.06716672f, -0.07925691f, -0.06314278f, 0.14040183f, -0.19125940f, -0.19502001f, 0.06533440f, 
    -0.19498557f, 0.28982291f, -0.14741494f, 0.13120948f, 0.03763274f, -0.03617336f, 0.08960000f, -0.04810562f, 
    0.05509639f, 0.18104525f, -0.15746461f, 0.08630338f, -0.34103918f, 0.24138471f, -0.31732443f, 0.41346526f, 
    0.10645896f, -0.08279132f, 0.03087632f, 0.01152764f, 0.09643389f, -0.10674098f, -0.02282161f, 0.02377482f, 
    0.04975503f, -0.03617615f, -0.00558713f, -0.03872184f, 0.02669430f, 0.03281301f, 0.06808681f, 0.04114637f, 
    0.09249093f, 0.02142778f, 0.08456597f, -0.03963608f, -0.12311029f, 0.20463011f, -0.35334682f, 0.06273529f, 
    -0.01827605f, -0.03888591f, 0.17522134f, 0.09148526f, -0.03733675f, -0.01195908f, 0.01484961f, 0.03549474f, 
    0.10173765f, -0.11193592f, 0.22222973f, 0.06280831f, 0.02368793f, 0.01591869f, -0.03364478f, -0.06863248f, 
    0.01613493f, 0.10273582f, 0.01143421f, 0.01772813f, -0.02521014f, 0.21584024f, -0.12890786f, -0.23111102f, 
    -0.10055325f, -0.20122264f, 0.04467966f, 0.03371878f, -0.02091184f, 0.04128470f, -0.08055436f, -0.01930121f, 
    -0.03361747f, -0.00134490f, 0.00349669f, -0.23314448f, 0.07248588f, -0.03146133f, 0.03742886f, 0.11155511f, 
    -0.01095959f, 0.07943580f, -0.04014426f, -0.01639390f, 0.04559550f, -0.17277250f, 0.10012426f, -0.32395184f, 
    -0.01612544f, 0.11657646f, 0.05673939f, -0.13382821f, 0.10243298f, 0.09215070f, -0.08999176f, 0.08889181f, 
    -0.05961145f, 0.03474660f, 0.27958742f, 0.01536962f, 0.14120796f, 0.09406246f, 0.00231055f, -0.04205871f, 
    0.08289724f, -0.02214645f, -0.03989913f, 0.00751268f, 0.05899212f, -0.01221091f, 0.09563704f, -0.06033906f, 
    0.15636554f, 0.04649919f, 0.03603815f, -0.05475392f, 0.10555746f, -0.03583208f, 0.01748824f, -0.03026069f, 
    0.15917750f, -0.37442407f, 0.11498323f, -0.00300843f, -0.02985243f, -0.02658070f, -0.01842862f, -0.00862129f, 
    -0.01359683f, -0.10892359f, -0.05957558f, -0.00894085f, -0.13587037f, 0.32855931f, -0.16430102f, 0.13059388f, 
    0.11094671f, -0.09741396f, -0.04091339f, 0.04601021f, -0.02797058f, 0.05961379f, -0.14071439f, 0.04045737f, 
    -0.00265635f, -0.07123972f, -0.04683366f, -0.04286615f, 0.00222880f, -0.07096475f, -0.05887345f, -0.00903485f, 
    -0.00816585f, -0.00916215f, -0.01459638f, -0.06048225f, 0.45961410f, -0.17022699f, -0.17440991f, 0.32682070f, 
    -0.02562865f, -0.08641127f, 0.05067263f, -0.09125943f, 0.30000970f, 0.01267449f, 0.06597916f, 0.07322843f, 
    0.19432895f, -0.19539727f, 0.11662532f, 0.09145918f, -0.07235423f, -0.02317104f, -0.02288434f, -0.10139074f, 
    0.16378704f, -0.00566378f, 0.11417203f, -0.07740773f, 0.02709316f, 0.02165011f, 0.08316068f, 0.00516205f, 
    -0.02893200f, -0.02311496f, -0.02935444f, 0.01386421f, 0.05250725f, -0.02371133f, 0.07346862f, 0.05661651f, 
    0.17044246f, 0.07088029f, -0.09273526f, -0.07515278f, -0.06758360f, -0.04350040f, -0.01066756f, -0.01051913f, 
    0.06004419f, -0.07396590f, 0.06292158f, 0.00456139f, 0.05174633f, 0.06573817f, -0.06968339f, -0.05640240f, 
    0.01914728f, 0.12022585f, -0.04521000f, -0.03265169f, -0.02075183f, 0.02023342f, 0.03376883f, -0.00898275f, 
    -0.74641669f, 0.19781072f, -0.42840081f, 0.44131577f, 0.02786368f, -0.06191443f, -0.11939265f, 0.04112033f, 
    -0.05850427f, -0.05118348f, -0.00501674f, -0.02265842f, -0.08389176f, -0.11319879f, -0.04524031f, -0.31187868f, 
    -0.00703201f, 0.09622189f, -0.04447525f, 0.06577364f, 0.08599103f, -0.00857088f, -0.04447566f, 0.04332347f, 
    -0.18404962f, 0.23235230f, -0.19834673f, 0.03750676f, 0.02203036f, -0.01051017f, -0.06676778f, 0.10336334f, 
    -0.11241698f, -0.05181754f, 0.01012311f, -0.00487612f, 0.51658678f, -0.33033726f, -0.01580682f, 0.09865036f, 
    -0.10178482f, 0.04830912f, 0.00860537f, 0.08198492f, 0.19090311f, 0.02414071f, 0.02489961f, 0.00110919f, 
    0.43086678f, -0.16575138f, -0.02987033f, 0.01384862f, -0.04394191f, -0.09355435f, -0.03957977f, -0.03480958f, 
    0.17626381f, 0.01357829f, -0.13722099f, 0.13979095f, 0.18484354f, 0.12236829f, 0.08620946f, -0.16002220f, 
    -0.03924029f, -0.01989659f, -0.02501505f, 0.06519371f, 0.07605694f, -0.10731359f, 0.07075597f, -0.03018692f, 
    0.05438371f, -0.06813010f, 0.03549469f, 0.02277439f, 0.00973236f, 0.03369902f, 0.02616185f, 0.06857499f, 
    -0.04813032f, 0.01046798f, 0.03124627f, 0.07283033f, 0.01088002f, -0.06915721f, 0.05761253f, -0.05895789f, 
    0.04491708f, 0.00998901f, 0.09569325f, 0.07794361f, 0.00070313f, -0.08185498f, -0.03273464f, 0.01984703f, 
    0.25239670f, -0.19657427f, 0.04722386f, -0.17479251f, -0.03901756f, -0.03356321f, 0.15840232f, -0.06516836f, 
    -0.04978811f, -0.09367011f, 0.08917034f, -0.03785666f, 0.04052822f, -0.03188789f, 0.02063173f, 0.02692783f, 
    0.14660923f, 0.11185586f, 0.04078520f, -0.00224492f, -0.01401701f, -0.05946752f, 0.19299562f, 0.11826140f, 
    -0.09527875f, 0.19211961f, -0.02284311f, -0.19849381f, -0.00646339f, 0.14002417f, -0.02373737f, 0.03348199f, 
    0.12993957f, -0.02522595f, -0.07139852f, 0.09899541f, 0.60180378f, -0.28170651f, 0.11814700f, -0.21587464f, 
    0.00703928f, 0.01924887f, 0.20580715f, -0.09024192f, 0.09789778f, 0.16799752f, -0.02431187f, -0.12089614f, 
    0.14212744f, 0.07591731f, 0.02728563f, 0.11880413f, -0.07521199f, -0.06495568f, -0.00759996f, -0.11344812f, 
    0.02383037f, -0.02192443f, 0.07966331f, 0.04786349f, -0.43727362f, 0.31473303f, -0.17002088f, 0.14437009f, 
    0.15148358f, -0.09876753f, -0.18783718f, 0.03919537f, 0.01872979f, -0.09078378f, -0.02684190f, -0.04784184f, 
    0.17674746f, 0.01890313f, 0.12219631f, -0.24092881f, 0.18393737f, 0.13876063f, -0.10710734f, -0.01765228f, 
    0.04213233f, 0.02208040f, 0.01105722f, 0.10052151f, -0.28287193f, -0.06225756f, 0.07560839f, -0.03016804f, 
    0.20134208f, -0.05490161f, 0.05919639f, -0.19162446f, 0.02756430f, -0.08806814f, 0.04108560f, 0.06303737f, 
    -0.06001438f, -0.00067897f, 0.01595045f, -0.12413337f, 0.01139661f, 0.10805480f, 0.26668841f, 0.18084674f, 
    0.01019217f, -0.13735744f, 0.04884727f, 0.00468261f, 0.00622405f, 0.03300996f, 0.05055116f, 0.09470724f, 
    -0.03506692f, 0.09923711f, 0.05423513f, -0.05907249f, -0.05002978f, 0.02165711f, -0.02509076f, 0.08472486f, 
    -0.17589161f, 0.15748782f, -0.04904290f, 0.31039834f, -0.09246226f, 0.04361619f, 0.07854721f, -0.12789305f, 
    0.12487985f, 0.05552437f, 0.03047961f, -0.03674345f, -0.17413983f, -0.04961472f, -0.37801161f, -0.07430428f, 
    -0.14075877f, 0.13517094f, -0.16272885f, 0.22708245f, 0.19900082f, -0.09178688f, -0.03297312f, 0.03705585f, 
    -0.03376144f, 0.05017606f, -0.03566998f, 0.02461223f, 0.03693603f, 0.02373710f, 0.05576604f, 0.00264437f, 
    -0.00697145f, 0.11820760f, -0.10474208f, 0.06915765f, 0.19351935f, -0.05370212f, 0.24330163f, -0.19543201f, 
    0.06925232f, 0.17174412f, -0.01769607f, 0.06245279f, 0.14021933f, 0.00262638f, 0.02596023f, -0.15062022f, 
    -0.11138847f, 0.19809315f, -0.16097216f, -0.07039025f, 0.08450218f, 0.05968562f, 0.00876981f, 0.06427991f, 
    -0.01611190f, 0.03598606f, 0.01912947f, -0.01361831f, -0.00727550f, 0.06007783f, 0.03681991f, -0.03457612f, 
    -0.04229027f, -0.01996026f, 0.01147566f, -0.11059533f, 0.02190469f, 0.13115889f, 0.02073284f, 0.12243443f, 
    -0.04729512f, 0.16336979f, -0.01653256f, -0.23087980f, 0.08808943f, 0.14095818f, -0.01873838f, 0.10385574f, 
    0.08231393f, -0.21621124f, -0.01130081f, 0.12935376f, -0.00548458f, 0.07814340f, 0.04449480f, -0.02483333f, 
    0.29011098f, 0.23370762f, 0.05695485f, -0.06385916f, 0.09493922f, -0.01230878f, 0.17456874f, 0.00975083f, 
    0.09389615f, 0.01714625f, -0.15157257f, 0.00468326f, -0.13675143f, 0.15427613f, -0.03320390f, 0.00842907f, 
    0.03945642f, -0.02361532f, 0.07993570f, -0.02844785f, 0.00690168f, 0.05357981f, -0.06725492f, 0.14425454f, 
    0.12743229f, -0.01225653f, 0.06961285f, -0.05870286f, 0.02705361f, -0.06303494f, -0.04680066f, -0.06525486f, 
    0.07720675f, 0.12236043f, 0.15824558f, -0.01255631f, -0.04589883f, 0.00266057f, 0.09731714f, 0.17085265f, 
    0.01684222f, -0.05104477f, -0.07609358f, 0.01672783f, -0.02579369f, -0.07557489f, 0.07730877f, -0.00655719f, 
    0.05115808f, 0.08636365f, -0.09074032f, 0.08009160f, 0.04393616f, 0.02356949f, 0.08823827f, 0.00301066f, 
    0.01480362f, -0.06476662f, 0.01660868f, -0.16930979f, -0.10601379f, 0.18838511f, -0.01292843f, 0.13697606f, 
    0.10568639f, 0.18497460f, 0.07950221f, 0.10480498f, 0.04239257f, -0.05583587f, -0.11596447f, 0.23555563f, 
    0.03509190f, -0.00262469f, 0.27421150f, -0.04654677f, 0.13853209f, -0.07432853f, -0.01676334f, 0.24438310f, 
    0.12097429f, -0.00054498f, -0.06444580f, -0.02179180f, -0.17501733f, -0.04801261f, 0.02563388f, -0.06857975f, 
    0.29138473f, 0.06116479f, -0.02972312f, 0.07469463f, 0.33222061f, -0.08733624f, -0.04095926f, -0.06944394f, 
    0.02005978f, 0.03317599f, -0.04347089f, 0.33122993f, 0.14711805f, -0.01911618f, -0.06730088f, 0.00879289f, 
    -0.19773869f, 0.00225333f, 0.00998743f, 0.05828370f, 0.09807022f, 0.05163956f, 0.10657287f, -0.07856314f, 
    -0.06093601f, 0.08620752f, 0.10401383f, 0.17232741f, -0.08097384f, -0.07353716f, 0.02415518f, -0.13611858f, 
    0.17154676f, 0.06371310f, 0.12433954f, 0.08672532f, 0.09928299f, 0.11286099f, -0.01183354f, -0.10444140f, 
    -0.24683011f, -0.14092270f, -0.21255112f, 0.04199030f, 0.13822646f, 0.04043657f, 0.06555629f, 0.08435631f, 
    0.03986311f, -0.17409332f, 0.08079829f, -0.05871211f, 0.13323265f, -0.00609149f, 0.01954528f, 0.15559147f, 
    0.00973251f, 0.17579129f, 0.07171962f, -0.01047680f, -0.10586446f, -0.06715880f, 0.11081625f, 0.11582055f, 
    0.14729592f, 0.19314915f, 0.13637231f, 0.13327773f, -0.04869732f, 0.01577627f, -0.06189474f, 0.10377745f, 
    0.08400670f, 0.08993199f, 0.18390313f, -0.01435261f, 0.04874593f, 0.06813638f, 0.05961786f, -0.11164509f, 
    -0.01786615f, 0.14942016f, 0.06762731f, 0.02477052f, 0.14378533f, 0.05328466f, 0.17423956f, 0.13468692f, 
    0.08693735f, -0.05416970f, -0.11196578f, 0.03549825f, 0.23416901f, 0.08858749f, 0.06678289f, 0.17191842f, 
    -0.01601452f, 0.03073972f, -0.00416548f, -0.12733878f, 0.08582492f, -0.19622119f, -0.12247072f, -0.32932240f, 
    0.04861176f, 0.08628786f, -0.02114970f, 0.12776498f, -0.09841224f, 0.02186981f, -0.05579590f, -0.14618789f, 
    0.01509522f, 0.18163072f, -0.21145399f, 0.04937016f, 0.01568844f, -0.03325607f, -0.01529198f, -0.01055810f, 
    -0.01575663f, 0.05405752f, 0.08819563f, 0.07868200f, -0.11726186f, -0.00971681f, -0.19103132f, -0.08298248f, 
    0.15749833f, -0.04167701f, 0.11881455f, -0.03470141f, -0.03503706f, -0.14121501f, 0.07337158f, -0.03302457f, 
    -0.13899171f, 0.17220119f, -0.18564579f, 0.16382186f, 0.07091641f, 0.02038439f, 0.13386013f, -0.00554185f, 
    0.06676921f, -0.20247467f, -0.02154863f, -0.07270341f, -0.00799676f, 0.03172945f, 0.05931306f, 0.01145242f, 
    -0.00713684f, -0.06791918f, -0.05595886f, -0.05032884f, -0.02642156f, -0.14455862f, -0.05657586f, 0.00445995f, 
    0.02027351f, -0.00015117f, 0.11177291f, 0.09624685f, 0.18166652f, 0.06722323f, 0.04094711f, -0.00400955f, 
    0.21362442f, -0.00175711f, 0.01489710f, 0.26461032f, 0.20342569f, -0.07649466f, 0.11282644f, -0.22764210f, 
    0.04702415f, -0.00914094f, 0.09113750f, 0.13103709f, 0.00817834f, 0.00464830f, -0.02473036f, 0.18213300f, 
    -0.43646839f, -0.09299698f, -0.07436411f, -0.01372810f, -0.11166311f, -0.12723714f, -0.01389210f, 0.06830350f, 
    -0.05619364f, -0.03371865f, 0.03066681f, -0.13333835f, 0.26530057f, -0.05183377f, 0.22236013f, -0.12658216f, 
    0.02891948f, 0.11880797f, 0.04615978f, 0.15078790f, -0.08353736f, 0.06175568f, -0.02949753f, 0.10989961f, 
    -0.08750660f, 0.07185722f, 0.13372837f, -0.12530622f, -0.04182634f, 0.01705506f, 0.04206901f, 0.09250552f, 
    -0.14507365f, -0.19378611f, -0.16027088f, -0.17046711f, -0.13673683f, -0.22585097f, -0.15542158f, -0.17760365f, 
    0.05002033f, 0.01845934f, 0.00717928f, -0.15724513f, 0.01080404f, -0.02806203f, -0.01966377f, 0.04364575f, 
    -0.03539661f, -0.11039481f, -0.15987039f, -0.08646440f, 0.17935689f, 0.03894787f, 0.00272125f, -0.06807274f, 
    0.01573626f, -0.03930395f, -0.06002940f, 0.07912916f, -0.06818717f, 0.18225446f, 0.07590428f, -0.20241098f, 
    0.08414652f, -0.00436194f, 0.06053522f, 0.14002202f, 0.21958940f, -0.07494896f, -0.00052910f, -0.09181526f, 
    0.22740252f, 0.08586082f, -0.03989610f, 0.22219600f, 0.16915371f, 0.01685569f, 0.11738410f, 0.24994011f, 
    0.00216030f, -0.03603454f, -0.04586360f, -0.04147653f, -0.07298982f, -0.02373277f, -0.00504030f, -0.01267138f, 
    0.00613254f, 0.09197844f, 0.09588242f, -0.00000320f, -0.01723374f, 0.01566165f, 0.03069181f, -0.17830092f, 
    -0.02830752f, 0.01528362f, 0.05752167f, 0.13676751f, -0.02304556f, -0.10775910f, -0.11542649f, 0.02803545f, 
    -0.03728537f, -0.10827170f, -0.00198084f, -0.21359974f, -0.02590954f, -0.10480054f, -0.02722312f, -0.09730770f, 
    0.04541363f, -0.01291915f, 0.07844603f, 0.02381999f, -0.09084383f, 0.00137963f, 0.03305582f, 0.19694987f, 
    0.06819808f, 0.08571558f, 0.08116610f, 0.08125895f, -0.06124077f, 0.02861982f, -0.13113607f, -0.00758224f, 
    -0.17447573f, -0.05627823f, -0.07101292f, -0.10618276f, -0.35099846f, -0.13599071f, 0.08077481f, 0.46952257f, 
    0.15751910f, -0.07133015f, 0.03563842f, 0.00704479f, 0.21062346f, -0.11030678f, 0.07889378f, -0.04891013f, 
    -0.03595293f, 0.12797348f, 0.12505549f, -0.12640974f, 0.01569318f, -0.02831720f, -0.09044702f, 0.06253438f, 
    0.05906456f, 0.04396519f, 0.05328474f, 0.12498874f, -0.01625756f, 0.04423738f, 0.08695234f, 0.10508212f, 
    -0.08495728f, -0.02507107f, -0.06616259f, -0.10581687f, -0.02975583f, -0.02865046f, -0.04540562f, -0.01891004f, 
    -0.21030977f, 0.02210738f, -0.08677928f, 0.14121430f, 0.07861001f, -0.10877308f, -0.03742781f, -0.02859807f, 
    -0.04973291f, -0.17253880f, 0.09258574f, 0.02965651f, 0.14033771f, -0.03430165f, -0.02152020f, 0.04381161f, 
    -0.05963158f, 0.06640177f, 0.02202440f, 0.00157700f, -0.01886548f, -0.04743352f, -0.02745559f, -0.01254612f, 
    -0.31009558f, -0.13070560f, 0.35186034f, -0.25590110f, 0.22193702f, -0.13889104f, 0.00751244f, 0.29216102f, 
    -0.02612999f, 0.14389791f, 0.02200949f, -0.06904264f, -0.20036858f, 0.02283542f, 0.33390054f, -0.23988856f, 
    -0.12050008f, 0.12654106f, 0.02115816f, 0.25968409f, 0.07655036f, 0.10799880f, -0.01545337f, 0.09629184f, 
    0.08189739f, -0.00610302f, -0.00878338f, -0.10677534f, -0.01159967f, -0.01479084f, 0.02106682f, 0.01551722f, 
    -0.23290108f, -0.01423240f, -0.12844281f, -0.08873608f, -0.04063061f, -0.15906493f, 0.15234205f, 0.24052864f, 
    0.01302617f, 0.05254402f, -0.04607886f, 0.07081307f, 0.17752723f, 0.02113160f, 0.09998907f, 0.10961772f, 
    -0.37818718f, -0.04282969f, -0.11645467f, 0.10341382f, -0.09980452f, -0.09429044f, -0.10131482f, -0.08396599f, 
    0.06845553f, -0.10018659f, -0.10732981f, 0.01618382f, -0.36951718f, -0.20345451f, 0.14546300f, -0.03296730f, 
    -0.04534302f, 0.03684585f, 0.01611447f, -0.09470621f, -0.15519086f, -0.16312355f, -0.00127545f, 0.00986063f, 
    -0.06220165f, -0.02755655f, -0.22015548f, -0.11099191f, 0.10656588f, 0.08040420f, 0.08949278f, 0.09716626f, 
    -0.02738675f, 0.02563284f, 0.07501768f, 0.16861036f, -0.03653786f, 0.15796059f, 0.09725859f, 0.19014239f, 
    -0.00757779f, 0.10533297f, 0.08218628f, 0.16451345f, 0.01684946f, 0.04042622f, 0.10718054f, 0.12887888f, 
    0.24108319f, 0.12235169f, 0.08404464f, -0.16380671f, -0.00894202f, -0.10028046f, -0.04683571f, 0.03742939f, 
    0.03211595f, 0.06363993f, 0.00175938f, -0.13566864f, -0.14189322f, 0.04063584f, -0.16057484f, 0.14311700f, 
    0.07466269f, -0.04499207f, 0.02235750f, 0.00126209f, 0.22092105f, 0.05080842f, 0.07132059f, 0.20598286f, 
    -0.08747082f, 0.19430575f, 0.16854769f, -0.12783657f, -0.10191412f, 0.01265715f, -0.10330345f, 0.01023302f, 
    -0.08366849f, -0.15165682f, -0.26141170f, -0.10388912f, 0.08560254f, -0.12197034f, 0.09137926f, 0.30513990f, 
    -0.20300242f, 0.02238973f, -0.03227448f, -0.01310342f, 0.09580474f, -0.02720550f, 0.04523794f, 0.12319840f, 
    -0.19508764f, 0.01504917f, 0.01592120f, 0.21208140f, -0.03695196f, -0.08539645f, -0.05552419f, -0.11135104f, 
    0.10466747f, 0.05754505f, 0.12027626f, 0.28931788f, 0.16006748f, -0.00256128f, -0.14592893f, -0.03589679f, 
    0.12534554f, 0.06043736f, 0.08457054f, -0.08068779f, -0.13316396f, -0.05888757f, -0.08154432f, 0.00819470f, 
    0.36355120f, 0.27105993f, 0.12346387f, 0.09845780f, 0.09853867f, 0.04573993f, -0.05254809f, 0.19692336f, 
    0.06165351f, -0.06717499f, -0.01872662f, 0.13722819f, -0.08097368f, -0.07781149f, -0.20259224f, -0.05769869f, 
    0.07731812f, -0.04538883f, 0.03239721f, 0.03214407f, -0.01702084f, -0.06145097f, -0.10931323f, -0.09540538f, 
    -0.22211631f, 0.03077766f, 0.16986524f, 0.06354169f, 0.09957193f, -0.06451577f, 0.16353321f, 0.07978728f, 
    -0.00989217f, -0.02346367f, 0.04779210f, 0.11532129f, 0.04184194f, 0.11480677f, -0.00957247f, -0.03826910f, 
    -0.05147657f, -0.04601000f, -0.00047757f, 0.00515342f, 0.05205270f, 0.09830494f, 0.10750476f, 0.11969693f, 
    -0.08381736f, 0.10042746f, 0.08139075f, 0.04886016f, 0.08875203f, -0.12236846f, -0.00814791f, -0.10454349f, 
    0.19226229f, -0.00957297f, 0.11061060f, 0.12192489f, -0.37346753f, 0.13430041f, -0.06799415f, -0.03371307f, 
    -0.00631170f, -0.09314849f, -0.08982602f, -0.05966647f, -0.11218810f, -0.09008179f, -0.02114924f, -0.04626193f, 
    0.25168842f, 0.07550258f, 0.06413198f, 0.04442681f, -0.02277760f, -0.02028196f, -0.02787920f, 0.05242064f, 
    -0.06597101f, 0.09853970f, -0.06805629f, -0.01334841f, -0.02596284f, -0.03510131f, 0.08335646f, -0.16776246f, 
    0.01759473f, 0.10688721f, 0.13211270f, 0.21724641f, 0.12006916f, 0.06478145f, 0.02284151f, -0.15531650f, 
    -0.23470062f, -0.10863616f, -0.00512112f, -0.14550070f, 0.05561483f, 0.07879421f, -0.02216482f, -0.03476591f, 
    0.05440405f, 0.16323948f, 0.19104718f, 0.18729046f, -0.03025657f, 0.02443123f, 0.06682856f, 0.01667878f, 
    -0.07577244f, -0.08391621f, -0.09499165f, -0.13009253f, -0.01691380f, 0.04390818f, 0.07191508f, 0.17366713f, 
    0.16584982f, -0.03159100f, 0.26736656f, -0.33092168f, -0.05709439f, -0.00894010f, 0.02093184f, 0.04214983f, 
    0.11594860f, 0.07584208f, 0.03689859f, 0.19394058f, 0.16553231f, 0.24666724f, -0.27101916f, 0.19791055f, 
    0.14001854f, 0.05622080f, 0.16694754f, 0.01525299f, 0.09120359f, -0.11433018f, 0.09433076f, 0.02232016f, 
    -0.10176484f, -0.07134047f, 0.10747536f, 0.12061427f, -0.09088503f, -0.04476955f, -0.02280053f, -0.00300656f, 
    0.16118129f, 0.05976780f, 0.10069945f, 0.24751262f, 0.09854940f, -0.01666259f, 0.09976207f, -0.08821809f, 
    0.08609603f, 0.05279762f, 0.01356185f, 0.06302638f, 0.00558236f, -0.00929239f, -0.14085159f, -0.21285266f, 
    -0.22110061f, -0.05189989f, 0.04700782f, 0.14605002f, -0.10433984f, -0.14554082f, -0.00923218f, -0.14064105f, 
    -0.02368429f, 0.10720189f, 0.05556516f, 0.03628914f, 0.04200483f, 0.13374703f, -0.03321094f, 0.04923205f, 
    0.12032881f, 0.00080263f, 0.00967934f, -0.01038292f, 0.06676280f, -0.01156595f, 0.02270947f, 0.02297599f, 
    0.12534030f, -0.09971040f, -0.02223668f, -0.18755274f, -0.08401420f, 0.02765572f, -0.00759335f, -0.01535844f, 
    0.33959755f, 0.14752960f, 0.10591946f, 0.09053160f, -0.07505704f, -0.12431929f, 0.00239488f, -0.11358128f, 
    0.17328446f, 0.15340261f, 0.00630906f, 0.03821012f, 0.05859965f, 0.01698622f, 0.02223045f, 0.08861203f, 
    -0.09454799f, -0.13870084f, 0.07606018f, 0.12864476f, -0.01365359f, -0.11122847f, -0.16676009f, -0.12089252f, 
    0.29550466f, 0.05298352f, 0.07103589f, 0.24784607f, -0.28994745f, -0.17564748f, 0.16884357f, 0.16251823f, 
    -0.04585494f, 0.00757712f, 0.17361183f, 0.02228301f, 0.01788766f, -0.00105007f, 0.06585467f, -0.01007135f, 
    0.51618189f, 0.25732651f, 0.26687062f, 0.26008633f, -0.11524046f, -0.04231287f, -0.22146446f, 0.04548362f, 
    -0.04088411f, -0.06632198f, -0.08079445f, -0.00127265f, 0.20270282f, 0.08507358f, 0.26949564f, 0.14146605f, 
    0.08374429f, 0.00037446f, -0.10427188f, 0.17049374f, 0.04931213f, 0.09555806f, 0.14175594f, 0.06571407f, 
    -0.09322955f, 0.16793294f, 0.09924336f, -0.22490619f, 0.11056856f, -0.14381607f, -0.03852431f, -0.03849974f, 
    0.00960560f, 0.00697213f, 0.08474252f, 0.00788210f, 0.13367139f, -0.06987856f, 0.17931865f, -0.00210060f, 
    -0.08556732f, 0.05144509f, -0.05717248f, 0.08403070f, -0.02117325f, -0.10991951f, 0.03899536f, 0.00910043f, 
    0.27190971f, 0.06452615f, -0.04148463f, 0.13537085f, -0.05881587f, 0.10147783f, -0.03494494f, 0.02910942f, 
    -0.07392694f, -0.03125278f, 0.11433306f, 0.01209152f, 0.14471483f, 0.13132700f, 0.08626163f, 0.22459087f, 
    0.15655312f, 0.01514771f, -0.00826001f, 0.09170023f, -0.04393673f, -0.01873838f, 0.05707024f, -0.00335566f, 
    -0.05249608f, 0.20618141f, 0.09341088f, 0.10790185f, -0.07324242f, 0.13244255f, -0.19571404f, -0.00761875f, 
    -0.04558230f, 0.05673051f, 0.04707931f, 0.00216379f, -0.02901850f, 0.06089365f, -0.19413392f, 0.00970344f, 
    -0.02667864f, 0.03486138f, -0.00697055f, 0.01533229f, 0.02162118f, -0.02638407f, 0.12930708f, -0.00816310f, 
    0.08991753f, 0.04824305f, 0.08909798f, -0.03693100f, -0.04937275f, -0.01514454f, 0.02455831f, 0.00383606f, 
    -0.02065935f, 0.00411156f, 0.08372366f, 0.00078386f, -0.06118697f, 0.01598345f, 0.21470520f, 0.05284470f, 
    0.16245408f, -0.03227212f, -0.09051523f, 0.04481388f, 0.16006288f, 0.08703481f, -0.00389436f, 0.05778330f, 
    0.20077540f, 0.04923491f, 0.26233155f, -0.16628155f, 0.00259759f, -0.14279756f, -0.03026191f, 0.07240686f, 
    0.05321095f, 0.15315133f, 0.05188163f, 0.02051510f, 0.00853274f, -0.00184240f, 0.05348012f, -0.05037390f, 
    -0.04438610f, -0.04054202f, 0.00583851f, -0.00232780f, 0.04840081f, -0.05262071f, -0.07845648f, 0.08580548f, 
    0.00943564f, -0.12668534f, -0.08063799f, 0.20378897f, 0.06509418f, -0.06922904f, -0.10042759f, 0.12480613f, 
    -0.05763860f, -0.00051215f, 0.17276204f, 0.01914810f, -0.00092737f, -0.35718471f, 0.35249308f, 0.06660926f, 
    0.15503217f, 0.17065887f, -0.24023326f, -0.00310035f, -0.08130537f, 0.08752698f, 0.09889345f, 0.18616295f, 
    -0.07268525f, -0.19322519f, -0.10319887f, -0.10403266f, 0.05097537f, 0.13302432f, 0.11865915f, 0.04766798f, 
    0.05496225f, 0.05707515f, 0.01639624f, 0.00620515f, 0.19685285f, -0.08163144f, 0.14790133f, 0.25467691f, 
    0.09045807f, 0.09966443f, -0.16958854f, -0.11724147f, -0.00974126f, -0.02146847f, 0.02718437f, 0.12921529f, 
    -0.26842773f, -0.13854608f, -0.15684861f, 0.00696561f, -0.04532730f, -0.00364880f, 0.02020260f, 0.00351831f, 
    -0.04032666f, -0.09149896f, -0.19299987f, 0.02873492f, 0.13993511f, 0.24926615f, -0.00481828f, -0.04210690f, 
    -0.05414953f, -0.09687571f, -0.15864123f, 0.15121488f, -0.01762071f, 0.04906797f, -0.01495152f, 0.03209673f, 
    -0.00085808f, 0.23222061f, -0.06340734f, 0.05885153f, 0.16422410f, 0.03026104f, 0.06176717f, 0.03026970f, 
    0.00075351f, -0.01995250f, -0.03223983f, 0.01381162f, 0.10037638f, -0.48089331f, 0.03889151f, 0.28051341f, 
    0.02887946f, 0.12022118f, 0.26643023f, -0.03590676f, -0.04673992f, -0.07194405f, 0.02322653f, 0.04985374f, 
    -0.02750683f, 0.23255001f, 0.13111749f, -0.05708604f, -0.07294105f, -0.07271361f, -0.19724169f, 0.05592497f, 
    -0.07844292f, -0.07099918f, 0.03654017f, 0.09325708f, 0.33304125f, 0.23302026f, 0.34996468f, -0.04102738f, 
    0.11625864f, 0.05139594f, 0.06917960f, 0.20977058f, 0.04234840f, 0.06287752f, 0.20599188f, 0.18038523f, 
    0.00291109f, 0.04347170f, -0.04236916f, -0.09660964f, -0.05806378f, 0.00985183f, 0.00689933f, -0.04599471f, 
    -0.02730361f, 0.12600061f, 0.07193118f, 0.05112270f, 0.07939581f, 0.10794934f, 0.31928998f, 0.04696034f, 
    0.07228709f, -0.01361697f, -0.20696293f, 0.06685201f, 0.04384400f, 0.02165322f, -0.01938361f, -0.05869644f, 
    0.22820988f, 0.09022279f, 0.13331604f, 0.05488367f, -0.04674824f, -0.03281265f, -0.08646151f, 0.01918739f, 
    0.06016343f, 0.00193760f, 0.01949060f, -0.01110349f, -0.09160790f, -0.29395875f, -0.18058822f, -0.23952578f, 
    0.02528310f, 0.08598079f, 0.19307905f, -0.00997674f, 0.08213332f, -0.11569691f, -0.04005387f, 0.05671818f, 
    -0.02658474f, -0.30911666f, -0.07354748f, -0.15170841f, 0.00525554f, 0.05224660f, 0.02013516f, 0.05409121f, 
    -0.01136899f, -0.05509732f, -0.06500405f, -0.04131896f, 0.15947001f, 0.24042931f, 0.03889247f, 0.03450875f, 
    -0.02640647f, -0.02453073f, -0.04733376f, 0.00955389f, -0.05187768f, 0.07961836f, 0.02324029f, 0.16857296f, 
    -0.04525574f, -0.07934503f, -0.03213871f, -0.09098667f, -0.08090400f, -0.03140318f, 0.09839809f, 0.09552374f, 
    -0.04588701f, -0.06956568f, -0.00895004f, 0.04012327f, 0.22456610f, 0.22954868f, 0.47835532f, 0.04488911f, 
    -0.15429993f, -0.13959716f, -0.11416371f, -0.04837390f, 0.03157788f, -0.06073255f, -0.02518792f, -0.05714782f, 
    0.33325738f, -0.18691660f, 0.37179759f, -0.05362628f, 0.32364789f, 0.00290221f, -0.20890076f, 0.07880057f, 
    0.18188311f, -0.02335512f, 0.10238506f, 0.00430756f, -0.13438883f, -0.11416116f, -0.39642066f, 0.45135209f, 
    0.08307994f, 0.22872254f, -0.05565861f, 0.09836896f, -0.03497776f, 0.04957414f, -0.01605838f, -0.09954374f, 
    -0.00026870f, -0.16275705f, 0.47540778f, 0.11626049f, 0.02576958f, -0.05789044f, -0.22063218f, 0.12483452f, 
    -0.05620978f, -0.11436974f, 0.02057079f, -0.04694506f, 0.05205050f, -0.08960127f, -0.33185872f, 0.02098658f, 
    0.03291147f, -0.03265742f, 0.12774007f, -0.08813673f, 0.08888774f, -0.05750593f, -0.12408439f, -0.02573663f, 
    -0.10762154f, -0.02234701f, -0.25224873f, -0.13226651f, 0.11041228f, 0.18207489f, 0.25175372f, -0.08890031f, 
    0.08911206f, -0.12263296f, -0.07519002f, 0.13267928f, 0.42079061f, 0.18171002f, 0.11141659f, 0.45237273f, 
    0.00835464f, 0.03437638f, 0.17814593f, 0.07377912f, 0.06237252f, 0.08076018f, -0.01603001f, -0.01175236f, 
    0.09176794f, 0.18456469f, -0.01813794f, -0.11757749f, 0.21191534f, 0.02360872f, -0.01256521f, 0.01799393f, 
    0.00205142f, -0.03222378f, 0.02836103f, -0.12897697f, 0.17557411f, 0.05746247f, -0.02976625f, -0.06795759f, 
    0.14052060f, 0.11714008f, 0.15699513f, -0.04811325f, 0.00962073f, 0.01432058f, -0.04452854f, -0.06307548f, 
    0.18081045f, -0.33638176f, 0.04941391f, 0.01513829f, 0.06117366f, 0.08781905f, 0.04260479f, -0.11560369f, 
    -0.01303213f, -0.06320913f, 0.03113759f, 0.06222649f, -0.00527248f, -0.03074170f, 0.08515272f, -0.13630764f, 
    0.09633032f, 0.03821959f, -0.02697901f, -0.00603160f, 0.05930075f, 0.01428100f, -0.01181867f, -0.11022432f, 
    0.34258077f, 0.22030482f, -0.08113360f, 0.25741118f, 0.13651247f, 0.16664192f, -0.04448425f, -0.02365444f, 
    0.07189585f, 0.13805729f, 0.07222447f, 0.06779249f, 0.01627686f, 0.08871580f, 0.06759267f, 0.04540982f, 
    -0.07220929f, 0.08968584f, 0.05461932f, -0.00415178f, 0.02386184f, -0.01575574f, -0.05409201f, 0.00127810f, 
    -0.13634430f, -0.03511765f, -0.14898746f, -0.14588510f, -0.02696719f, 0.02092690f, 0.04936321f, 0.08216520f, 
    0.08660723f, 0.08198199f, -0.03164661f, -0.07293218f, 0.03159297f, 0.26130620f, 0.57931548f, 0.07582658f, 
    0.01301520f, -0.08310064f, -0.25750098f, -0.05462198f, -0.03705503f, 0.06065717f, -0.00145475f, 0.14315009f, 
    0.18226275f, -0.17433780f, 0.01018893f, 0.02587063f, 0.04160508f, 0.05570697f, -0.06153585f, 0.02726533f, 
    -0.13039219f, 0.02979290f, 0.00125956f, 0.00139136f, 0.00214402f, 0.09955854f, 0.16321124f, 0.00767271f, 
    -0.05414980f, -0.11352929f, -0.09175982f, -0.03242780f, 0.16342890f, 0.15610337f, -0.05362190f, 0.04040037f, 
    0.41746315f, 0.19014230f, 0.32685617f, 0.30687526f, 0.06581896f, 0.01526717f, 0.05199512f, 0.03900260f, 
    -0.02002771f, -0.03061477f, -0.03185325f, -0.06108487f, 0.07335734f, 0.00216690f, 0.12641178f, -0.02927083f, 
    0.05290902f, -0.01037857f, -0.00917871f, -0.02057237f, -0.04407556f, -0.07097509f, 0.04428452f, -0.01503955f, 
    -0.02166920f, -0.30143416f, 0.03572732f, -0.02754364f, 0.17203668f, -0.03890991f, -0.04768111f, 0.05700605f, 
    0.11898521f, 0.00535119f, 0.09212711f, 0.12181573f, 0.32422233f, 0.21993344f, -0.34425327f, -0.22050530f, 
    0.03606342f, 0.15930153f, 0.32990119f, -0.05009444f, -0.12749811f, -0.03774897f, 0.07364807f, -0.05554051f, 
    0.23008236f, 0.19489139f, 0.21713105f, -0.02982549f, -0.06959981f, 0.04199280f, -0.09840135f, -0.01141171f, 
    0.00367542f, 0.04491415f, 0.00977111f, -0.04895972f, 0.06501018f, 0.17690206f, 0.19479580f, 0.30004743f, 
    0.10323860f, 0.01974662f, 0.16555387f, -0.07812107f, 0.10063099f, -0.00402013f, 0.01917473f, 0.11447223f, 
    0.27195072f, 0.30256394f, 0.26140070f, 0.18180533f, -0.05562804f, 0.03820305f, -0.05318913f, 0.11100668f, 
    -0.00940200f, 0.04493816f, 0.00905595f, -0.07215402f, 0.05931710f, 0.02368973f, -0.00970102f, 0.05072147f, 
    -0.01021733f, 0.02286573f, -0.04184254f, 0.05949005f, 0.10384569f, 0.11023571f, 0.13392313f, 0.21806778f, 
    -0.03338734f, -0.04295298f, -0.02517322f, 0.23107293f, -0.09608486f, 0.19123106f, -0.07143259f, 0.01268857f, 
    -0.10420217f, 0.08709076f, -0.03864329f, -0.02210523f, 0.33915865f, -0.26812720f, 0.35823435f, 0.02324056f, 
    0.06146773f, -0.12556443f, -0.07514681f, 0.06716294f, 0.07678064f, -0.04866503f, -0.05628708f, 0.00538311f, 
    -0.04753221f, -0.18133304f, -0.15466316f, 0.01236373f, 0.12984347f, -0.02744083f, 0.01900751f, -0.00703553f, 
    0.06561022f, -0.04268751f, -0.05693483f, -0.03899955f, 0.14327560f, -0.03045842f, 0.27565005f, 0.21233211f, 
    0.07652553f, 0.04496955f, -0.09625141f, 0.03795448f, 0.01930765f, 0.03556516f, 0.02744510f, 0.08773376f, 
    0.45067674f, 0.24393933f, 0.14242457f, 0.20247796f, 0.05632747f, -0.04064041f, 0.13759857f, -0.03237823f, 
    -0.00900054f, -0.07838473f, -0.00732152f, -0.02703561f, 0.02585448f, 0.10631809f, 0.16863196f, 0.08561774f, 
    -0.02188536f, -0.00998494f, -0.06576566f, 0.08821074f, -0.02705299f, -0.06083317f, -0.05121815f, -0.03127082f, 
    -0.16304044f, -0.01674478f, -0.23265222f, 0.09994449f, -0.01475151f, 0.08883382f, -0.05449890f, 0.13942005f, 
    0.03115747f, -0.08715970f, 0.18497509f, 0.12239593f, 0.14487924f, -0.03184570f, -0.03932105f, 0.00679698f, 
    -0.02712256f, 0.22960126f, 0.01362229f, 0.02423359f, -0.09425421f, -0.01711315f, 0.04931146f, 0.02775151f, 
    -0.01295725f, -0.02558254f, -0.07318702f, -0.02279082f, -0.00735088f, -0.04153498f, 0.00527234f, 0.08045677f, 
    0.10508992f, 0.12986529f, 0.09353847f, -0.07730030f, 0.42452863f, 0.34927803f, 0.28826371f, 0.11840124f, 
    -0.05068156f, 0.09542844f, 0.14156735f, -0.11128034f, -0.00538303f, -0.08113384f, -0.06873209f, -0.04848373f, 
    -0.13673560f, -0.18289228f, -0.16148856f, -0.01374392f, -0.12885006f, -0.05769260f, 0.01649625f, -0.10607863f, 
    0.06477759f, -0.01941575f, -0.00228165f, 0.00886940f, -0.12940684f, -0.24962039f, -0.26412392f, -0.12571785f, 
    0.14376920f, 0.10494398f, 0.04367551f, 0.09605850f, 0.00963270f, 0.10421400f, 0.00103177f, -0.02658974f, 
    0.01772838f, 0.01046564f, -0.13569371f, 0.15260819f, 0.05801547f, 0.12889710f, 0.11629367f, 0.10969111f, 
    -0.03383838f, -0.10159596f, 0.09603418f, -0.03190921f, 0.17381011f, 0.17940353f, 0.22675768f, -0.03546801f, 
    -0.01259370f, 0.07617882f, -0.18836045f, -0.02989731f, -0.07771172f, -0.03316889f, 0.01678329f, 0.08441295f, 
    0.21016012f, 0.03432595f, 0.03821645f, 0.11263441f, -0.00048725f, 0.03476681f, 0.12586606f, -0.04984321f, 
    0.14123769f, 0.03799318f, 0.09808007f, 0.12793210f, -0.25964642f, -0.25167438f, -0.05037576f, -0.05008259f, 
    0.06647437f, -0.04616805f, 0.01585512f, 0.06947509f, 0.09959349f, 0.00533738f, 0.01722685f, 0.10402753f, 
    -0.07723378f, -0.01845589f, 0.22365464f, 0.11210652f, 0.06797013f, -0.07983765f, 0.02177109f, 0.04772196f, 
    -0.07320110f, 0.02385187f, -0.02184390f, 0.04680467f, 0.01975139f, 0.13682115f, -0.00423966f, -0.21407002f, 
    0.01555219f, 0.05014578f, -0.02842070f, 0.07558265f, -0.02378589f, -0.08625142f, 0.05494449f, -0.02283853f, 
    0.09911700f, 0.24943073f, -0.11545331f, -0.07208774f, -0.03066663f, -0.01135920f, -0.00081795f, -0.01358932f, 
    0.02184364f, -0.06774766f, 0.08295344f, 0.09481176f, -0.13523415f, -0.02833568f, -0.01595369f, -0.14143570f, 
    0.17056662f, 0.11329532f, 0.06826618f, 0.07957636f, 0.08142793f, -0.04128533f, -0.05403537f, 0.00296151f, 
    0.01230143f, 0.04777839f, -0.03721904f, 0.03283383f, 0.03606594f, 0.15818296f, 0.03615540f, 0.07080751f, 
    -0.15801373f, -0.06179268f, 0.00604669f, 0.05183287f, 0.11183194f, 0.09225932f, 0.20576078f, -0.10015801f, 
    -0.05228168f, -0.02822481f, -0.09300501f, 0.01729059f, -0.06575162f, -0.12367303f, -0.02039500f, 0.06836189f, 
    0.27207550f, 0.07371710f, 0.07154875f, 0.02135885f, 0.00076962f, 0.02377482f, 0.07090954f, 0.01956890f, 
    0.02580079f, 0.15923154f, 0.18173814f, 0.08279712f, 0.17119148f, -0.21669389f, 0.24262927f, -0.05472986f, 
    0.12514731f, 0.08512115f, 0.09834357f, 0.14342722f, -0.09072047f, -0.04172292f, 0.11851747f, 0.11530282f, 
    -0.24859099f, -0.10477918f, -0.20032103f, -0.13366896f, -0.01733296f, 0.09361383f, 0.06345981f, 0.10929894f, 
    0.07297160f, 0.02856564f, -0.11521748f, -0.09741683f, 0.16301683f, -0.10433368f, 0.35769013f, 0.21353866f, 
    -0.04673860f, 0.07540645f, 0.05397231f, 0.12433468f, -0.17542297f, 0.05816302f, 0.00902395f, 0.15012695f, 
    -0.04483545f, 0.00137585f, -0.05758297f, -0.17609598f, -0.05265844f, 0.04794003f, 0.01764441f, 0.00109353f, 
    -0.07484865f, -0.07116762f, -0.05818095f, -0.08925854f, -0.17138220f, -0.07094590f, -0.01652132f, -0.14137498f, 
    -0.19645661f, -0.09924129f, -0.06875036f, -0.04750017f, -0.00872561f, -0.00570685f, 0.00161094f, 0.06932098f, 
    -0.12320331f, -0.03666189f, -0.05130087f, -0.02324775f, -0.07614258f, 0.02072878f, 0.03632908f, 0.00882122f, 
    -0.10168158f, -0.12369905f, 0.03090669f, -0.00824582f, -0.08986720f, 0.04175563f, -0.22980173f, 0.27125204f, 
    0.02483307f, -0.11309343f, 0.05420062f, 0.16062309f, 0.09069467f, -0.03835252f, 0.02509774f, -0.00189271f, 
    0.29343393f, 0.26289809f, -0.05963426f, -0.00331471f, 0.08790536f, -0.00772646f, 0.03360661f, 0.05452895f, 
    -0.09179531f, 0.14416283f, 0.02531274f, -0.07744668f, -0.08346435f, -0.14849608f, -0.26517764f, -0.18014358f, 
    0.12170344f, 0.16253093f, 0.10887007f, 0.11238861f, 0.04150910f, 0.08322147f, 0.00938787f, -0.10126977f, 
    0.15054803f, 0.10526596f, -0.12178844f, -0.09642644f, -0.05003399f, -0.01384041f, -0.04907747f, -0.04364775f, 
    0.00751013f, 0.05768435f, 0.10568924f, -0.09858830f, 0.02032773f, -0.40418282f, 0.17190292f, 0.19693866f, 
    -0.01200706f, 0.08292779f, 0.03893385f, -0.03665956f, 0.02130539f, 0.03264261f, -0.01679024f, 0.05114488f, 
    0.04886381f, 0.24458617f, 0.09397990f, 0.02934433f, -0.08199236f, -0.07082078f, -0.16112380f, -0.07043269f, 
    -0.20354411f, 0.00325831f, 0.00264461f, 0.01118501f, 0.16576928f, 0.15609431f, -0.04525504f, -0.28624457f, 
    -0.06868462f, 0.14097047f, 0.12831001f, -0.02578390f, 0.15377340f, 0.08689225f, 0.07219184f, -0.02326800f, 
    -0.24983980f, -0.05363224f, -0.02168640f, -0.06387310f, -0.03131871f, 0.07074527f, -0.01828560f, 0.06922925f, 
    0.01471350f, 0.03438957f, 0.00857968f, 0.01700394f, 0.03165486f, 0.17582384f, 0.08392484f, -0.17605048f, 
    -0.06453467f, -0.10215470f, -0.05574854f, -0.11697954f, -0.05629510f, -0.15960197f, -0.13930406f, -0.05877169f, 
    -0.18762799f, -0.04551955f, -0.08787223f, 0.10533987f, -0.07106298f, -0.15175305f, -0.08380440f, 0.04710338f, 
    -0.01240768f, -0.01623424f, 0.10315047f, -0.09292516f, 0.25170088f, 0.08847231f, 0.18399736f, -0.03692257f, 
    -0.02604540f, 0.06634020f, 0.00816175f, 0.04348243f, -0.01538629f, 0.01371140f, 0.06652955f, -0.01931271f, 
    0.35369357f, -0.23075338f, 0.38881019f, -0.08874173f, -0.00685867f, 0.30624658f, 0.14110970f, 0.22996306f, 
    -0.03095821f, 0.15400077f, 0.07512961f, 0.04222289f, -0.26453778f, -0.14598499f, -0.10092048f, 0.10448290f, 
    -0.11626853f, 0.10413410f, -0.02076916f, 0.26354414f, 0.12192901f, -0.02211634f, -0.10623793f, -0.00968163f, 
    0.03255663f, -0.29795012f, 0.10355242f, 0.06160608f, 0.05303943f, -0.06215407f, -0.05106971f, 0.14688078f, 
    -0.13426539f, -0.00294680f, -0.03833032f, 0.06908571f, -0.09472482f, 0.05907016f, -0.05513209f, 0.09159888f, 
    -0.02829449f, 0.01253259f, 0.12122483f, 0.04060615f, 0.06174167f, 0.06693048f, 0.07036345f, -0.00708646f, 
    0.01873257f, -0.15463559f, -0.18410449f, -0.18994761f, 0.03049947f, -0.02108427f, -0.06053600f, -0.05390935f, 
    -0.02467564f, 0.05167411f, 0.08024976f, -0.20051214f, -0.33326322f, -0.38125485f, -0.24111477f, 0.00723905f, 
    -0.00860228f, 0.03513620f, -0.04819786f, -0.03719856f, 0.07585285f, -0.03878385f, -0.01814544f, -0.03321759f, 
    -0.16248168f, -0.03064070f, -0.22491924f, -0.07289314f, 0.03479968f, -0.01212395f, 0.06948285f, -0.08006465f, 
    0.03837121f, 0.10782567f, 0.13712424f, 0.07750242f, -0.16134483f, -0.06734649f, -0.12614390f, 0.00207052f, 
    0.05356608f, 0.01715081f, 0.12295716f, 0.06199395f, 0.02756455f, 0.07209662f, 0.03350374f, 0.15579751f, 
    -0.08360243f, -0.11967160f, -0.15930018f, 0.17680745f, -0.04587283f, 0.00442197f, 0.08216231f, 0.05295121f, 
    0.07846861f, 0.05030939f, 0.01846000f, 0.00554275f, 0.06347298f, 0.22540560f, -0.16228454f, -0.27499560f, 
    -0.01682138f, 0.04491321f, 0.09435785f, -0.05165938f, 0.06694987f, 0.10821731f, -0.02395811f, 0.11614171f, 
    -0.05252078f, -0.11537156f, -0.04803703f, 0.07015516f, -0.01948550f, 0.12077202f, -0.03434644f, 0.07507972f, 
    -0.08079882f, 0.02710732f, -0.09114884f, -0.33066314f, 0.25818223f, 0.08030956f, 0.08422512f, 0.02636291f, 
    -0.00969605f, 0.11938632f, 0.07901102f, -0.01507763f, 0.12778488f, -0.00173782f, 0.09461942f, 0.05523130f, 
    0.12089898f, -0.03911680f, -0.10213937f, -0.25634480f, -0.12400232f, -0.06522187f, 0.00899615f, -0.10834542f, 
    0.03773531f, 0.06217584f, 0.14019190f, 0.05890970f, 0.12523915f, 0.07412681f, 0.24737962f, -0.06403794f, 
    0.07212967f, -0.03263520f, 0.03114756f, -0.07792050f, -0.12762709f, 0.00559591f, -0.03260199f, 0.03630220f, 
    0.13692163f, 0.06131730f, -0.05807544f, 0.58635879f, 0.02634631f, 0.04217898f, 0.15515830f, 0.18327405f, 
    -0.00971351f, 0.01909275f, 0.02019335f, 0.12355405f, -0.03645756f, -0.08531298f, -0.02455231f, -0.08325157f, 
    0.04203570f, 0.05318375f, 0.05079297f, 0.12852383f, -0.09509594f, -0.13691758f, -0.18169370f, -0.02296985f, 
    -0.10704860f, -0.23101716f, -0.06553132f, 0.07804565f, 0.06645358f, -0.03124619f, 0.02569783f, 0.04549278f, 
    -0.05002937f, 0.05879914f, -0.02803440f, 0.05860189f, 0.03773107f, 0.17525965f, 0.06275948f, -0.11519856f, 
    -0.04633906f, 0.05373915f, -0.02149700f, -0.00185283f, -0.00672522f, 0.02403854f, 0.06901748f, 0.11947009f, 
    0.18065846f, 0.01967694f, 0.20408031f, -0.20227127f, -0.04142136f, 0.10085483f, 0.05283311f, 0.05879615f, 
    0.16634281f, 0.08809984f, 0.23528653f, 0.10694584f, -0.04769855f, -0.04100135f, 0.11530528f, 0.26768768f, 
    0.02586524f, 0.07846034f, -0.07069651f, 0.02151737f, -0.04110724f, 0.00970873f, -0.03506411f, -0.02807309f, 
    0.14792919f, 0.21374452f, 0.20935223f, -0.01537696f, -0.12228112f, -0.02883083f, -0.06723794f, 0.03270681f, 
    -0.11544721f, 0.01051281f, -0.03471513f, -0.00362958f, -0.25900358f, -0.04899693f, -0.04108286f, -0.05711085f, 
    0.15898997f, 0.19688076f, 0.07434682f, 0.08798086f, 0.21726610f, 0.12970735f, 0.05331199f, -0.03102289f, 
    -0.30196282f, -0.37944049f, -0.04008397f, -0.05777051f, -0.05928366f, 0.00378730f, -0.12424802f, -0.21409945f, 
    0.06728117f, 0.08577777f, 0.03838636f, 0.08650330f, -0.05766918f, 0.06938799f, -0.01750597f, -0.14844519f, 
    -0.16270918f, -0.03531954f, -0.06285267f, -0.05940557f, -0.15253063f, 0.01060865f, -0.04878773f, 0.09902665f, 
    0.04729353f, 0.00902865f, 0.17180187f, 0.29778633f, 0.05395894f, -0.03527331f, 0.04947956f, 0.15034901f, 
    -0.03311110f, -0.20713121f, 0.05072472f, 0.20931782f, 0.31995714f, 0.30757040f, 0.27419168f, 0.08159530f, 
    0.15918285f, 0.14290261f, 0.18071637f, 0.11544139f, 0.06238708f, -0.01251013f, 0.02265528f, 0.08829170f, 
    0.11720396f, 0.02259179f, -0.09871779f, -0.14905405f, -0.01986515f, 0.00781157f, 0.00711146f, 0.00837210f, 
    0.20403570f, 0.10173814f, 0.11254972f, 0.08529561f, 0.10965158f, 0.01814782f, 0.05951996f, 0.11616965f, 
    0.02820851f, 0.10804778f, 0.03656418f, 0.13356450f, 0.09308371f, -0.03541587f, -0.09622706f, -0.16657878f, 
    -0.01870216f, -0.05456137f, -0.36999804f, -0.10287917f, -0.03264889f, -0.13614358f, -0.13980223f, -0.14349249f, 
    -0.03647495f, -0.02223877f, -0.06000635f, -0.06845906f, 0.06993831f, 0.09003660f, 0.03364149f, -0.07687242f, 
    -0.00999718f, -0.05451405f, -0.05135814f, -0.01050383f, -0.04919952f, -0.01643579f, 0.04275477f, -0.05980460f, 
    -0.07022952f, -0.04633960f, 0.19209740f, 0.13193294f, -0.00163018f, 0.02546397f, -0.06576609f, -0.00926330f, 
    -0.09256798f, 0.01192067f, 0.11041455f, 0.02292990f, -0.15211557f, -0.13202895f, 0.00055194f, 0.01254807f, 
    -0.01084598f, 0.14013872f, 0.08699234f, 0.13040070f, -0.05114261f, 0.04379201f, 0.09486596f, 0.12963480f, 
    -0.24689998f, -0.14695361f, -0.13408649f, -0.20137748f, -0.17553678f, -0.03906273f, -0.07054321f, -0.06902778f, 
    0.21036820f, 0.03510808f, 0.08005221f, 0.08466388f, 0.12779909f, -0.17022812f, -0.06121850f, -0.06672569f, 
    0.03957551f, -0.06039411f, 0.13197826f, -0.03562809f, 0.02307109f, 0.00029912f, -0.06539246f, -0.07566047f, 
    -0.06322254f, -0.16074228f, 0.16405515f, -0.03272029f, 0.06167827f, -0.02102302f, 0.02318564f, 0.08259761f, 
    0.00304812f, 0.01162634f, -0.05123999f, -0.01858213f, -0.10497046f, -0.08589091f, -0.02169923f, -0.10154890f, 
    -0.01602481f, 0.09937156f, 0.04404459f, -0.00637088f, 0.14704429f, 0.11366921f, 0.09659548f, -0.00501406f, 
    0.39021268f, -0.19543271f, -0.11263489f, 0.25930446f, 0.13808139f, -0.08415361f, 0.22287479f, -0.09006152f, 
    -0.08517424f, 0.08375860f, -0.05677712f, -0.05471908f, -0.01593639f, -0.13796732f, 0.35690609f, 0.16682281f, 
    0.02629836f, 0.27853811f, -0.03104300f, -0.08740192f, 0.04547525f, 0.06950624f, 0.04171935f, 0.04958605f, 
    -0.05561828f, 0.34562284f, -0.13990216f, -0.24090414f, 0.09007653f, 0.00396577f, -0.00375309f, 0.14738797f, 
    0.05239920f, -0.04045507f, 0.16441563f, -0.01880092f, -0.20088579f, -0.04447804f, -0.09290691f, 0.11741104f, 
    -0.17752469f, 0.08532020f, -0.03870949f, -0.10882365f, 0.06144091f, 0.11200295f, 0.04617082f, -0.11410924f, 
    -0.06136366f, 0.06058837f, -0.22485219f, 0.05510401f, 0.22268549f, 0.01759029f, 0.14250526f, 0.13795564f, 
    0.02526848f, 0.01965924f, -0.07099905f, -0.03496312f, -0.25059929f, 0.25411367f, -0.00376269f, 0.05047352f, 
    -0.03074814f, 0.02125767f, -0.05310090f, -0.05235606f, 0.04285260f, 0.12338908f, 0.08687925f, -0.08612062f, 
    0.23710267f, -0.03400702f, -0.09221981f, -0.17330594f, 0.08098974f, 0.02291367f, -0.15088554f, 0.02132778f, 
    -0.02403964f, -0.02035321f, 0.07224615f, 0.08012398f, 0.16934863f, 0.02141036f, -0.06921075f, 0.14976966f, 
    0.11528353f, -0.08752813f, 0.09741017f, -0.05873228f, -0.03414322f, -0.06677005f, 0.04876595f, 0.02862084f, 
    0.17693789f, -0.08951064f, -0.11002515f, 0.18493453f, 0.03851918f, 0.01316675f, -0.10901202f, 0.05016073f, 
    0.09965656f, -0.05692710f, 0.05588799f, -0.03185517f, -0.04964275f, -0.08594253f, -0.04151823f, -0.13033496f, 
    -0.05634444f, -0.00881000f, -0.04763428f, 0.01560225f, -0.00439246f, 0.07845100f, 0.49462235f, -0.11889610f, 
    0.05845905f, 0.06091275f, 0.04749159f, -0.36129630f, 0.08968410f, 0.07744525f, -0.11441168f, -0.00966481f, 
    0.17917478f, -0.18725479f, 0.06332824f, 0.19823319f, 0.11142077f, 0.52968627f, 0.09569789f, 0.14079367f, 
    0.08464720f, -0.07341535f, 0.05009833f, 0.05948668f, -0.08732311f, 0.00680841f, 0.02716327f, -0.05524984f, 
    0.10880148f, -0.06799809f, 0.01751944f, 0.07696046f, 0.02078142f, -0.05232394f, 0.14370210f, 0.05807311f, 
    0.07538914f, -0.02885989f, 0.07458059f, -0.05394824f, -0.03876437f, 0.11533623f, 0.37075552f, -0.17248879f, 
    -0.01385501f, 0.08692820f, -0.10395562f, 0.11686276f, 0.04822352f, 0.05033631f, -0.04340966f, -0.07200033f, 
    0.03891572f, 0.10852212f, 0.00846120f, 0.22294125f, 0.02655860f, -0.01429242f, -0.03418103f, 0.00809811f, 
    -0.03067438f, 0.10787138f, 0.02475353f, -0.00613762f, -0.00614954f, 0.06721856f, 0.13483754f, 0.05249068f, 
    0.13290241f, 0.04993517f, -0.00687866f, -0.18015061f, 0.10448951f, -0.08508170f, 0.00184662f, -0.01565590f, 
    -0.06954139f, -0.04121023f, -0.02740838f, -0.11592536f, 0.08153543f, 0.05458660f, -0.02134283f, 0.07727867f, 
    0.05708951f, -0.05194270f, -0.01997836f, -0.07044707f, -0.44055805f, 0.07925591f, 0.19272210f, 0.21616332f, 
    0.04270515f, -0.06047633f, 0.04419754f, 0.21909547f, 0.01519485f, -0.17019896f, -0.10450082f, -0.07183904f, 
    0.57697237f, -0.23432244f, 0.03868488f, 0.02372795f, 0.03860330f, 0.09073228f, 0.14790046f, 0.04871852f, 
    0.00311213f, 0.06141318f, 0.02377985f, 0.09845067f, -0.12094978f, -0.10460866f, -0.02896178f, 0.14459369f, 
    0.10723106f, -0.00646870f, 0.01328444f, -0.02699185f, 0.12679549f, 0.09822293f, -0.01059846f, -0.05464335f, 
    -0.00322485f, 0.06996977f, -0.08824903f, -0.08908574f, 0.00487402f, 0.03217788f, 0.04727143f, 0.06014777f, 
    0.11279463f, 0.25336608f, 0.13090774f, -0.16924673f, -0.05816816f, -0.00612844f, 0.08761538f, 0.23203264f, 
    0.15101077f, 0.14429863f, -0.03885866f, -0.03990514f, -0.03258795f, -0.06376603f, 0.00133084f, 0.02125032f, 
    -0.10147482f, -0.03612769f, -0.03273260f, 0.06830500f, 0.02107454f, 0.01780891f, 0.15052049f, -0.00967986f, 
    -0.05708993f, 0.04333446f, -0.08201506f, -0.03074059f, -0.04850572f, 0.09233059f, -0.06155645f, 0.12279768f, 
    0.09032556f, -0.00972546f, -0.05459967f, 0.08568660f, 0.04476691f, 0.05148508f, 0.13159946f, 0.09549192f, 
    -0.24033764f, 0.20641567f, -0.08443498f, 0.12836005f, 0.02365612f, -0.03995619f, -0.03688311f, 0.03826060f, 
    0.08498363f, 0.00460716f, -0.05186776f, 0.12727594f, -0.46872151f, -0.20830232f, -0.19805406f, -0.21566801f, 
    -0.03499089f, -0.05874418f, 0.01582962f, -0.03115344f, -0.02646095f, -0.06788123f, 0.06121954f, -0.08294965f, 
    -0.02297752f, -0.23988186f, -0.03384269f, 0.23633379f, 0.18422849f, 0.08243107f, 0.07364549f, -0.20179315f, 
    0.01944968f, -0.00594280f, 0.04888773f, 0.04799232f, 0.04622201f, -0.16200747f, -0.14120224f, 0.31956425f, 
    0.16475077f, -0.06425481f, 0.10601615f, 0.05075211f, -0.03325446f, 0.00107269f, -0.12571824f, -0.05867609f, 
    0.44516093f, 0.40108326f, 0.16405234f, -0.32593793f, -0.01929564f, 0.09833707f, 0.04726078f, 0.22245865f, 
    0.04239547f, -0.03981450f, 0.17700662f, 0.08433848f, -0.20991921f, -0.03866365f, -0.00857009f, 0.10093056f, 
    -0.03729707f, -0.04895339f, 0.08122599f, -0.05070546f, 0.14640550f, 0.06134448f, 0.24475069f, -0.08007915f, 
    0.00382120f, 0.07865263f, -0.00655751f, 0.11358294f, 0.03894993f, 0.11384609f, 0.10338151f, 0.03639212f, 
    -0.09183809f, 0.12968571f, -0.08517109f, -0.07943159f, -0.17812371f, 0.03291062f, 0.21692078f, 0.04765088f, 
    0.05447490f, 0.04922687f, -0.05360515f, 0.15998580f, 0.11116263f, 0.10107765f, -0.02890512f, 0.04596808f, 
    -0.34158987f, 0.12666003f, -0.12995730f, -0.08807039f, 0.12449600f, -0.03938960f, 0.08104127f, 0.18743283f, 
    -0.09786219f, -0.07599650f, 0.17854351f, 0.07673086f, -0.17992295f, 0.01367748f, 0.06400421f, -0.09435788f, 
    0.08725093f, -0.04533999f, 0.00730360f, -0.16051947f, -0.04892061f, 0.03213334f, -0.05425736f, -0.12912486f, 
    0.12022044f, -0.04855756f, -0.05294248f, 0.01216919f, 0.02873124f, 0.02861694f, -0.11384775f, 0.09141833f, 
    -0.02044760f, -0.03767152f, -0.08115848f, 0.00539831f, 0.06742041f, -0.01678737f, -0.07557624f, 0.16614078f, 
    -0.08042333f, 0.04182188f, -0.03042151f, 0.02414142f, -0.01072533f, 0.06392217f, 0.18253095f, 0.20715620f, 
    -0.24320650f, 0.04395267f, 0.08701006f, 0.07707493f, 0.03481674f, 0.10003405f, 0.09920384f, 0.30135673f, 
    -0.03156040f, 0.09254535f, 0.10199591f, -0.02248196f, 0.33607289f, -0.24312714f, -0.01923094f, 0.12425637f, 
    0.11425403f, 0.00803655f, -0.08055288f, 0.18176042f, 0.02006970f, 0.06269913f, 0.18301600f, 0.14701903f, 
    -0.22158308f, -0.01863563f, 0.01730856f, -0.00612979f, 0.04435782f, 0.01124239f, 0.17826043f, -0.04479904f, 
    0.06011203f, 0.02728236f, 0.11599438f, -0.04178180f, 0.07246801f, 0.40565810f, -0.02530550f, 0.03409244f, 
    0.05899613f, 0.02248125f, -0.15307441f, -0.06557857f, -0.13116868f, -0.00075347f, -0.02512991f, -0.03170137f, 
    -0.08110002f, -0.08509856f, -0.01636932f, -0.07985795f, -0.02189024f, 0.00487402f, -0.00575264f, 0.02308565f, 
    0.17104046f, 0.07490034f, 0.08299897f, 0.02948802f, 0.21113349f, 0.08630332f, -0.00014831f, 0.32776147f, 
    0.11526344f, 0.13302730f, 0.30105796f, -0.00867417f, -0.05294885f, -0.05275326f, -0.03950898f, -0.05647004f, 
    -0.21058404f, -0.18484269f, -0.08671717f, 0.37939239f, 0.04697053f, -0.03125013f, 0.01431404f, -0.00897425f, 
    0.08549991f, -0.19723161f, 0.14460810f, 0.06948207f, 0.07660183f, -0.08741073f, -0.08063667f, 0.05702354f, 
    -0.08979858f, -0.01375633f, 0.07363582f, 0.03496154f, 0.03651341f, 0.04266386f, 0.17211339f, -0.13642107f, 
    -0.06167779f, -0.09317096f, -0.09167016f, 0.07323658f, 0.08879634f, 0.01767582f, 0.00401146f, -0.26794761f, 
    0.06561849f, 0.09053354f, -0.07606339f, 0.07875630f, 0.03501263f, -0.09478461f, -0.06892577f, -0.15150759f, 
    -0.00892437f, -0.08418195f, -0.03398786f, -0.02960529f, -0.00433489f, 0.04872729f, 0.03339609f, 0.03764952f, 
    0.55848104f, 0.18541652f, -0.16113457f, -0.17489956f, 0.07670879f, -0.00117175f, -0.13080342f, 0.02557460f, 
    -0.09761587f, 0.06341156f, -0.04288459f, 0.11451101f, -0.59208548f, -0.16977012f, -0.04128682f, 0.21000348f, 
    0.12287992f, 0.00645492f, 0.17635351f, -0.00753035f, 0.10492519f, -0.00791365f, 0.01514935f, -0.05103862f, 
    -0.40080205f, 0.04721230f, -0.00156975f, -0.02928745f, -0.04898302f, 0.11402362f, -0.05488661f, -0.05730894f, 
    -0.06294917f, -0.05153980f, -0.03490069f, 0.06511877f, -0.26812711f, -0.13634501f, -0.16504857f, 0.11318564f, 
    0.08027656f, 0.03414544f, -0.00481388f, 0.04442161f, 0.22304396f, 0.09182921f, -0.03019041f, 0.16612236f, 
    -0.08166591f, -0.16145103f, 0.00649287f, 0.01282516f, 0.05335203f, -0.09286846f, 0.02223012f, 0.01170867f, 
    0.10606220f, 0.04707792f, 0.04829374f, 0.00447265f, -0.29010785f, -0.16647440f, -0.17108603f, -0.10904168f, 
    -0.02354392f, 0.04713682f, -0.00441608f, 0.00405925f, -0.00337539f, -0.11673385f, 0.00349988f, 0.10792474f, 
    -0.49351075f, 0.19276012f, -0.11264901f, 0.22716244f, -0.00309231f, -0.07602441f, 0.02860096f, -0.10286748f, 
    -0.01389910f, 0.15187253f, 0.11241565f, 0.05552096f, 0.13576938f, -0.13862438f, -0.04953005f, 0.25448331f, 
    0.06833851f, -0.08106001f, 0.05368569f, 0.18866517f, 0.06044533f, 0.07441042f, 0.09795526f, 0.00106022f, 
    0.05469177f, -0.13044694f, 0.00600656f, 0.06385086f, 0.00953573f, -0.06004764f, -0.02186130f, -0.06093327f, 
    -0.07316229f, 0.13807186f, 0.09026194f, 0.15642591f, -0.03156111f, 0.08785589f, -0.00369123f, -0.16444466f, 
    -0.02163537f, 0.09016436f, -0.01501072f, 0.08229558f, 0.13148160f, -0.03761519f, 0.20136678f, -0.21158706f, 
    -0.22056793f, -0.18937914f, 0.00217759f, -0.04731233f, -0.00881082f, -0.06499075f, -0.01209861f, -0.02260060f, 
    0.00357154f, 0.00048229f, 0.00023378f, -0.00717471f, -0.03743106f, -0.12348136f, -0.03239148f, -0.06607370f, 
    0.01663532f, -0.02300285f, 0.06059523f, -0.01978791f, -0.03927398f, 0.00563635f, -0.08226508f, 0.02980901f, 
    -0.31932607f, 0.11718155f, -0.10373753f, -0.00546010f, 0.02430165f, 0.01739662f, 0.02222068f, -0.04978062f, 
    0.10297161f, 0.11463951f, -0.03967125f, 0.11061955f, 0.12879965f, -0.16581327f, 0.04917524f, -0.11946233f, 
    0.06960426f, -0.09730630f, -0.13134196f, 0.02873503f, 0.04267956f, -0.00629940f, -0.12934721f, -0.17135175f, 
    -0.24645105f, -0.09053876f, -0.16418673f, -0.09487088f, 0.06608749f, -0.01253066f, -0.03624894f, 0.02629240f, 
    -0.08613594f, -0.00219043f, -0.02900341f, 0.02455237f, -0.23075008f, 0.06127827f, -0.04072185f, -0.01639129f, 
    0.02306372f, -0.01765677f, 0.02319390f, -0.08714253f, 0.00045412f, 0.02135153f, 0.00875157f, 0.08377054f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00806687f, 0.11717431f, 0.11232795f, 0.06192527f, -0.03211066f, 0.00609989f, -0.03928675f, 0.00120022f, 
    -0.03656949f, -0.02193892f, 0.01396041f, 0.01121298f, 0.00601113f, 0.03980093f, 0.02326411f, 0.04462385f, 
    0.02412547f, -0.01180346f, 0.06724063f, 0.01645203f, 0.03352435f, 0.00705865f, -0.03084336f, 0.03855338f, 
    0.02432962f, 0.01658166f, 0.12586004f, 0.13215685f, 0.21847795f, -0.00887081f, 0.02610745f, 0.10337199f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.02122696f, -0.20965530f, -0.06118890f, 0.29465702f, -0.02744744f, -0.15710361f, 0.31837994f, -0.18487842f, 
    -0.07801358f, 0.11988685f, -0.53477836f, -0.16898222f, 0.35651910f, 0.09803721f, -0.14624663f, -0.19362643f, 
    0.15499033f, -0.03669809f, -0.36291268f, -0.16959955f, -0.17020157f, 0.07502387f, 0.13324788f, -0.38147759f, 
    -0.07488724f, -0.17547333f, 0.02061215f, 0.12704870f, -0.50254804f, 0.16162267f, -0.24704055f, -0.52277166f, 
    0.09634198f, 0.29630992f, -0.19942100f, 0.17345938f, -0.15086299f, 0.05644516f, 0.06711597f, -0.00998893f, 
    -0.10627845f, -0.13227844f, -0.43968490f, 0.01611616f, -0.23012547f, -0.05436912f, -0.15982693f, -0.05526796f, 
    -0.06523626f, 0.10853142f, 0.10347717f, -0.15091996f, -0.01187633f, -0.14754832f, -0.48952171f, -0.57261688f, 
    0.00138704f, 0.23821831f, 0.35330215f, 0.22401102f, 0.22717029f, 0.15175518f, 0.09245671f, -0.59379929f, 
    -0.04690031f, 0.38406453f, 0.05308197f, 0.13549379f, -0.14058691f, 0.32368237f, -0.34285870f, -0.59476072f, 
    0.12930754f, -0.09139261f, 0.20202479f, -0.02494642f, -0.04584532f, -0.57418978f, 0.07029790f, 0.03660825f, 
    -0.10663298f, 0.03106343f, -0.33562690f, -0.14842124f, 0.06631205f, -0.07748429f, 0.13282661f, 0.37434271f, 
    -0.12772231f, -0.28768831f, -0.03845779f, 0.20284441f, 0.13591364f, -0.12351289f, -0.01078594f, -0.06275821f, 
    -0.02549188f, 0.14877693f, -0.66327596f, -0.13515447f, 0.15667935f, 0.22412713f, 0.15823686f, -0.32098293f, 
    -0.05829066f, -0.12074673f, 0.06317440f, -0.03926291f, 0.09971973f, 0.27714434f, -0.08626339f, 0.16884845f, 
    -0.03829795f, 0.00878732f, -0.42385188f, 0.16900642f, 0.07998664f, 0.11724778f, 0.04910864f, 0.28960454f, 
    -0.13388796f, -0.00006336f, -0.13786240f, -0.50247842f, -0.33276278f, 0.18682358f, -0.10365610f, 0.21784131f, 
    -0.16900940f, -0.05698147f, 0.13918148f, 0.06185371f, 0.13860142f, 0.10948065f, -0.32984686f, 0.18272553f, 
    0.02187943f, 0.06484416f, 0.39631179f, -0.02486628f, 0.15914790f, -0.08014555f, -0.16133025f, -0.57022935f, 
    -0.13365228f, -0.07539248f, 0.10167410f, 0.06958884f, -0.16074316f, -0.11377364f, 0.30644429f, -0.32507679f, 
    0.05775374f, -0.12459033f, -0.00510794f, -0.01736525f, -0.29458687f, 0.20069925f, -0.25435892f, -0.01439527f, 
    0.08399872f, -0.07303793f, 0.29916257f, 0.16086341f, 0.07825415f, -0.51623625f, -0.27161103f, 0.20651136f, 
    0.08503023f, -0.05208772f, -0.50154912f, -0.13188307f, 0.19916274f, 0.29530603f, -0.00192220f, -0.28325909f, 
    -0.14220890f, -0.08758617f, -0.00210362f, -0.10915860f, -0.01004836f, 0.07532609f, -0.40054968f, 0.17253061f, 
    0.00414075f, -0.38939375f, 0.13201983f, 0.15468068f, 0.21126731f, 0.05213608f, -0.06454417f, 0.22091708f, 
    -0.08149383f, -0.34483406f, 0.30759755f, 0.01648069f, 0.07814234f, 0.18580554f, 0.16782454f, 0.00588482f, 
    -0.13189860f, 0.13592637f, 0.40471131f, -0.04207027f, -0.17931080f, -0.80421042f, 0.03898031f, -0.01967561f, 
    -0.06572420f, 0.03635459f, 0.01937077f, 0.13021010f, -0.02151799f, 0.03931094f, -0.40031543f, 0.03260917f, 
    0.03488009f, 0.30044389f, 0.18589297f, -0.33836871f, 0.17724270f, -0.38460988f, 0.10967473f, 0.10613879f, 
    0.04924677f, -0.22972226f, -0.19001995f, -0.20131199f, 0.05754174f, -0.11379776f, 0.03650624f, 0.07677528f, 
    -0.16096111f, 0.13576131f, -0.12369933f, -0.08256260f, 0.26798853f, 0.17945030f, 0.15716104f, 0.06719998f, 
    -0.13187540f, 0.12976331f, 0.31273958f, -0.05649395f, -0.15284102f, 0.06676785f, -0.04462792f, 0.34510535f, 
    -0.13227609f, 0.14323461f, -0.39810964f, 0.35067391f, -0.39177808f, -0.02808353f, 0.10043136f, -0.09381386f, 
    -0.14637032f, -0.04849935f, -0.23367663f, 0.07768790f, 0.13722543f, -0.48269397f, 0.07825114f, -0.25756493f, 
    -0.11759394f, -0.14339721f, -0.17813566f, -0.01631195f, -0.51652908f, -0.13737158f, -0.04194982f, -0.13665463f, 
    -0.02746629f, 0.12994745f, -0.21662006f, 0.14619675f, 0.08460374f, -0.10800797f, -0.24644339f, 0.14933293f, 
    0.09572102f, 0.38907880f, -0.49954605f, 0.37042812f, 0.25721449f, 0.16196206f, 0.39125347f, 0.18048847f, 
    0.12914486f, -0.63689756f, 0.32666329f, -0.21747111f, 0.16344073f, 0.17016344f, -0.22877315f, -0.08965827f, 
    -0.15176073f, -0.00841387f, 0.18700805f, -0.13403486f, -0.12022845f, 0.24756990f, -0.07393455f, 0.16618264f, 
    -0.03599365f, -0.00622966f, 0.06319644f, -0.14771183f, 0.02403381f, -0.09087901f, 0.34082609f, -0.03469103f, 
    -0.16401818f, -0.26063895f, 0.03399340f, 0.20123026f, 0.17206931f, -0.20059247f, -0.29185125f, -0.02789891f, 
    0.12619947f, 0.35979903f, 0.20289022f, -0.15393108f, -0.06994955f, 0.14235464f, 0.28503296f, 0.35584110f, 
    -0.15385380f, -0.06447594f, -0.42246318f, -0.00356114f, -0.49253759f, 0.25637794f, 0.10998052f, -0.37068474f, 
    -0.12123331f, 0.03457418f, -0.37018186f, 0.15557338f, 0.05865857f, 0.04766836f, 0.25102741f, -0.29391789f, 
    0.12550817f, -0.10865070f, -0.39335224f, -0.45173490f, 0.22220325f, -0.07620151f, 0.33792835f, -0.17159060f, 
    0.12514985f, -0.02670655f, -0.33702701f, -0.40725267f, 0.08935586f, -0.13647810f, -0.32019094f, 0.32436010f, 
    -0.05334324f, -0.09507663f, -0.04427010f, 0.15843435f, -0.31120327f, -0.37415761f, 0.15212941f, 0.33686781f, 
    0.10248742f, -0.01778221f, -0.15067948f, -0.11539111f, 0.16240670f, -0.02789854f, 0.27059108f, -0.15032642f, 
    0.11050685f, 0.16446686f, 0.33085206f, -0.31641844f, 0.08789011f, 0.29747477f, 0.15228862f, 0.20738769f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.07166209f, -0.15355754f, 0.10613052f, 0.03853071f, 0.20494559f, -0.04461755f, 0.10409924f, 0.09863485f, 
    0.10390411f, -0.12469944f, -0.05776500f, -0.07435166f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
