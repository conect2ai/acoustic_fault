#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.12571515f, 0.07311950f, -0.10081090f, -0.57266217f, -0.48561373f, -0.03867857f, -0.05712476f, -0.04896619f, 
    0.77915817f, 0.41448700f, 0.59782839f, -0.25395462f, 0.32579285f, 0.52451855f, -0.00245171f, -0.17696883f, 
    -0.39859095f, -0.07772743f, -0.66492718f, -0.17619292f, -0.10561778f, 0.41863084f, 0.10365268f, -0.85649759f, 
    0.21646789f, 0.26084962f, 0.36611998f, 0.69996649f, -0.00255928f, 0.32204974f, -0.43647847f, -0.76074201f, 
    0.55765414f, 0.20275918f, 0.12160344f, -0.04596917f, -0.43301168f, -0.11653014f, 0.33580178f, 0.03936530f, 
    -0.73004293f, 0.85725564f, 0.20548493f, -0.15525156f, -0.21576864f, 0.18961726f, 0.15737210f, -0.15459339f, 
    -0.47773048f, 0.33420858f, 0.20789893f, -0.56182742f, 0.71244836f, -0.43447480f, 0.76672447f, 0.30710953f, 
    0.02959205f, 0.40904275f, 0.57252580f, 0.10180335f, 0.30053100f, 0.16756313f, -0.02213444f, -0.47036865f, 
    0.47130835f, -0.29030818f, 0.25395229f, -0.40036348f, -0.51183790f, -0.34026909f, 0.63801563f, -0.62489074f, 
    -0.45117289f, -0.49264193f, -0.72400397f, -0.24276926f, 0.49798715f, 0.47040510f, 0.51424646f, 0.47265702f, 
    0.44803888f, 0.06650852f, 0.31249470f, -0.26019111f, -0.18880171f, 0.60956109f, -0.59506387f, 0.35598162f, 
    0.35669392f, 0.33660373f, 0.51037389f, -0.54522264f, 0.58701158f, 0.13056906f, 0.36140892f, -0.10569370f, 
    -0.47627988f, -0.59841359f, -0.16847660f, 0.11905458f, -0.05277031f, 0.05885761f, 0.13093349f, -0.63927519f, 
    -0.49559650f, -0.06702528f, 0.42241007f, 0.36492130f, 0.16582598f, 0.05985732f, 0.25018466f, 0.39809337f, 
    -0.23959866f, 0.74924779f, 0.35321563f, -0.03128826f, -0.20215006f, 0.04359555f, 0.18171756f, 0.01232839f, 
    -0.41265860f, 0.16001719f, -0.08359540f, 0.53546476f, 0.30296233f, 0.57826680f, 0.38162827f, -0.65651256f, 
    0.02952592f, 0.61708128f, -0.39163747f, 0.14683446f, -0.16538323f, -0.29074216f, -0.08656552f, 0.04276580f, 
    -0.19584118f, -0.76856351f, -0.36327672f, -0.34223884f, -0.07940899f, -0.37155509f, -0.52334172f, 0.06754059f, 
    -0.36484712f, -0.11193192f, 0.13039020f, -0.12791891f, -0.44671786f, -0.57797581f, -0.28864840f, -0.21872249f, 
    -0.36948776f, -0.79479945f, 0.93428266f, -0.05324451f, 0.06557149f, 0.19698176f, -0.12599589f, 0.41941500f, 
    0.41340396f, 0.19423747f, -0.33463997f, 0.29011318f, 0.68407142f, 0.08424705f, -0.17026079f, 0.04753417f, 
    -0.12104405f, -0.36712238f, -0.14261639f, 0.70978236f, 0.58733958f, -0.23068768f, -0.30404627f, -0.00364646f, 
    0.59782040f, -0.03046930f, -0.05244808f, 0.36401433f, -0.24910995f, -0.01192406f, 0.40382829f, 0.91342229f, 
    0.62513030f, 0.70231712f, -0.27380008f, 0.02989456f, -0.12619388f, -0.68128735f, -0.70860767f, -0.28560588f, 
    0.18119794f, 0.42791787f, 0.16021127f, -0.31843060f, -0.22498433f, -0.41852754f, -0.70134091f, -0.22207347f, 
    0.43296355f, -0.37967321f, -0.63939220f, -0.56704074f, 0.18402661f, 0.38785869f, 0.07042399f, 0.70063990f, 
    0.59666353f, 0.60632038f, 0.44484991f, -0.34356835f, -0.72638750f, -0.05013932f, -0.06720202f, 0.02236686f, 
    -0.43561277f, 0.56810349f, 0.31801575f, 0.52703267f, -0.70500338f, 0.21514906f, 0.19134177f, 0.55935454f, 
    -0.57269901f, 0.34993231f, -0.57371527f, -0.12508255f, 0.90070361f, -0.59246916f, 0.25403348f, 0.36785483f, 
    0.25128654f, -0.64981449f, -0.36394754f, 0.43196210f, 0.11264236f, -0.62137681f, 0.35808873f, 0.32951322f, 
    0.59285372f, -0.61350530f, -0.33071503f, -0.55936939f, 0.03826614f, 0.39757031f, -0.01953306f, 1.20851099f, 
    -0.92874700f, -0.24448781f, 0.17930183f, -0.14940597f, -0.79444158f, -0.08802246f, 0.07280502f, 0.30615580f, 
    0.55226505f, 0.87149739f, -0.00576839f, 0.32650062f, 0.33545837f, 0.65108746f, 0.72180241f, 0.01058540f, 
    -0.69842625f, -0.10518268f, 0.07570506f, 0.13838226f, 0.30812430f, 0.47503218f, 0.43123701f, 0.23981752f, 
    0.58084506f, -0.10498147f, 0.03511247f, -0.65606397f, 0.56200790f, 0.10537197f, 0.17532021f, 0.31983894f, 
    -0.75871313f, -0.94081056f, 0.52795190f, 0.67909944f, 0.40260732f, -0.09223676f, -0.19768886f, -0.20695956f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.00909296f, 0.18271394f, 0.39123905f, 0.08976525f, 0.40095150f, 0.28088239f, 0.09768772f, 0.28710473f, 
    -0.00210082f, 0.09477033f, -0.17687246f, 0.32758224f, 0.09018968f, -0.04769280f, 0.26542032f, -0.16602041f, 
    -0.15956309f, -0.15148443f, 0.25366390f, 0.15225470f, 0.11571378f, 0.14899537f, 0.19904694f, -0.15670323f, 
    0.07148596f, -0.02671491f, -0.02650006f, -0.01997985f, 0.03780158f, 0.14097489f, -0.08034826f, -0.12972690f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.03144969f, -0.02959206f, -0.01923199f, -0.02694530f, -0.00447974f, -0.01519016f, 0.04819270f, -0.03849596f, 
    -0.06358173f, 0.05256782f, 0.01903988f, 0.01599753f, -0.01204251f, -0.01046231f, -0.00006830f, -0.03637380f, 
    -0.02861293f, 0.01523224f, 0.01576846f, -0.02075710f, 0.00349671f, 0.01062844f, -0.04813774f, 0.01782280f, 
    0.01383326f, -0.06111522f, 0.00896750f, -0.04533393f, -0.01002611f, -0.06148065f, -0.01350827f, -0.03081661f, 
    -0.02788667f, 0.00315755f, -0.02127109f, 0.03915166f, -0.03714266f, 0.02411384f, 0.05166327f, -0.05370187f, 
    -0.00784504f, -0.00418905f, -0.01453318f, -0.04061926f, -0.02896482f, -0.02704499f, -0.03640479f, -0.04736310f, 
    -0.00660263f, -0.03140808f, -0.02739627f, 0.04811691f, 0.02600509f, -0.00591120f, -0.01444862f, -0.01536998f, 
    -0.05473637f, -0.04479858f, -0.00728250f, 0.03287772f, -0.01066056f, 0.05144519f, 0.01097108f, 0.04883089f, 
    0.02294879f, 0.00385143f, -0.03668899f, 0.01748635f, -0.01828115f, 0.01282735f, -0.03276183f, -0.03829952f, 
    -0.00888262f, -0.00878582f, 0.02906553f, -0.05767249f, -0.03492765f, -0.06076687f, -0.01782172f, -0.04428767f, 
    0.00883863f, 0.01810055f, -0.00990868f, 0.02573384f, -0.04796069f, 0.00899193f, -0.00607552f, -0.05854641f, 
    -0.03076054f, 0.02872351f, 0.04586865f, 0.05111312f, -0.01032852f, 0.02181745f, 0.01687579f, -0.01513623f, 
    -0.03990865f, -0.05980283f, -0.02954561f, 0.04259247f, 0.04291683f, -0.01339629f, -0.00732517f, -0.01224558f, 
    0.04195998f, 0.01705529f, -0.00593041f, 0.01603390f, 0.01290014f, 0.03416146f, -0.00046624f, 0.01311309f, 
    -0.02608021f, 0.04492374f, -0.05141282f, -0.05323774f, -0.03196936f, -0.05688585f, -0.03730297f, 0.03452324f, 
    -0.00097520f, -0.00127470f, 0.01631449f, -0.02958653f, -0.05163518f, 0.00415324f, -0.02633427f, -0.03272529f, 
    -0.03684716f, 0.03263795f, 0.02162044f, -0.05161953f, -0.02172025f, -0.05152435f, 0.00463653f, 0.02160632f, 
    -0.02335114f, 0.03299576f, 0.02414184f, -0.01523633f, 0.00752367f, 0.00535906f, -0.03000209f, -0.01648001f, 
    0.05056790f, 0.01293450f, 0.00329694f, -0.02952672f, 0.03627594f, 0.02442918f, -0.05195474f, -0.01860209f, 
    0.04442627f, -0.04058632f, -0.03424963f, 0.04448894f, -0.02787560f, 0.00095127f, 0.00894846f, 0.00705262f, 
    0.00371879f, 0.02097115f, -0.02044171f, -0.00422732f, 0.03301156f, -0.06332055f, -0.01721487f, 0.00209206f, 
    -0.05198229f, -0.05232868f, -0.04640929f, -0.04488469f, 0.02302768f, 0.02269468f, 0.02831996f, -0.00069160f, 
    0.02228717f, -0.01174061f, 0.04150970f, -0.00246844f, 0.04028356f, -0.02224786f, -0.01485175f, 0.02870877f, 
    -0.05702282f, -0.02825881f, -0.04160840f, 0.03246189f, -0.01904815f, 0.03400415f, 0.03722182f, -0.04370948f, 
    -0.02531288f, 0.01230647f, -0.02287368f, -0.02307012f, 0.02104877f, 0.03753968f, 0.02813463f, -0.02766891f, 
    0.04433318f, 0.00466246f, -0.01228863f, -0.05706428f, 0.00170848f, 0.04740615f, -0.05867271f, 0.02077546f, 
    0.01726484f, 0.00608701f, 0.03643608f, -0.04230295f, 0.03255792f, -0.05073778f, -0.00485048f, -0.01174911f, 
    -0.03456308f, -0.05684804f, -0.06388973f, -0.05954424f, -0.03044350f, -0.03776376f, -0.04318687f, -0.03299396f, 
    0.03719371f, -0.03699207f, 0.02204621f, -0.02587960f, 0.00127083f, -0.04406058f, 0.01240156f, 0.03066362f, 
    -0.04544182f, 0.01494529f, -0.02346366f, -0.04618258f, -0.02184142f, -0.03494119f, -0.04007223f, -0.04584030f, 
    -0.04537542f, 0.03885176f, 0.03685503f, 0.05168942f, -0.01310785f, -0.02484613f, -0.03761016f, 0.05004136f, 
    0.01279213f, -0.02520023f, 0.02207267f, -0.04150793f, 0.01174926f, 0.05521082f, 0.01164985f, 0.01300875f, 
    -0.05322942f, 0.03281073f, -0.05588453f, -0.02320826f, 0.00257831f, 0.03245621f, 0.03954668f, -0.05793297f, 
    -0.02584798f, 0.00668406f, -0.04791152f, 0.01023158f, -0.02394926f, -0.04890838f, 0.00010951f, -0.04086022f, 
    -0.01512769f, -0.02393003f, 0.01787957f, -0.03776658f, -0.02735404f, 0.02668248f, -0.06031092f, -0.02764153f, 
    -0.06362107f, -0.02600994f, -0.03717383f, -0.00030896f, -0.02957143f, -0.01688005f, -0.05648748f, 0.02025684f, 
    -0.01824410f, -0.00839112f, -0.01449948f, -0.04710930f, -0.03335606f, -0.01514091f, 0.05683490f, -0.03491829f, 
    0.03806734f, -0.01549821f, -0.05007204f, -0.04173360f, -0.02435127f, 0.00586459f, -0.01877266f, 0.00190524f, 
    -0.04146004f, 0.02319425f, -0.02082849f, -0.03377942f, -0.03118543f, -0.00855830f, -0.00615516f, 0.00995462f, 
    -0.02830555f, -0.04041077f, -0.01687661f, -0.04844471f, 0.04762692f, -0.06161754f, 0.00323132f, -0.04735291f, 
    0.00998743f, 0.01097255f, -0.04793173f, 0.00688711f, 0.04399256f, 0.00898899f, -0.00856237f, -0.03566982f, 
    0.04225002f, -0.02915548f, 0.01702752f, -0.03933969f, -0.00269206f, 0.02687452f, -0.02075571f, -0.00670880f, 
    0.03492989f, -0.01897343f, 0.04560142f, 0.03901856f, 0.00687777f, -0.02847995f, 0.01021609f, -0.04335925f, 
    -0.05029830f, 0.01519017f, -0.02517142f, -0.02454436f, -0.03992553f, -0.02830403f, -0.00561894f, 0.00229867f, 
    0.00111263f, -0.00626178f, -0.00602589f, -0.01065029f, 0.02450161f, -0.04148588f, -0.00330124f, -0.01988108f, 
    0.00744229f, -0.03775294f, 0.00332812f, 0.04073483f, -0.00755354f, 0.03181750f, 0.02370852f, 0.02992931f, 
    0.02751306f, -0.02514324f, -0.02461351f, 0.03765597f, 0.05131640f, 0.00225798f, -0.03114755f, 0.01324620f, 
    -0.00154427f, -0.01848021f, 0.04295982f, -0.01012023f, -0.04257691f, -0.03768473f, 0.01588470f, -0.01788118f, 
    -0.01223283f, 0.01327914f, 0.01510425f, 0.03542183f, -0.05242636f, -0.01468526f, -0.05312550f, 0.01856580f, 
    -0.00596059f, 0.04793077f, -0.04866784f, -0.01750165f, 0.05706833f, -0.04750724f, 0.01301847f, -0.00678226f, 
    0.00104752f, -0.01401296f, 0.00332212f, -0.00680220f, -0.05025102f, 0.02393752f, -0.06472004f, -0.05788652f, 
    -0.05417278f, -0.01797473f, -0.04330664f, 0.02706498f, -0.04402512f, -0.02307274f, 0.02114128f, -0.01226184f, 
    0.03604726f, 0.04546957f, -0.04632369f, -0.03106624f, -0.05723536f, -0.00763641f, 0.01234740f, 0.04885761f, 
    0.02585952f, 0.00957931f, -0.03479733f, -0.02374712f, -0.03500977f, -0.05972813f, 0.03916658f, -0.05709882f, 
    0.02289936f, 0.01013964f, -0.01831821f, -0.03504864f, -0.03583616f, 0.03445882f, -0.05022696f, 0.04785533f, 
    0.03038143f, -0.05471796f, 0.00441330f, -0.02215766f, 0.03696692f, 0.02927718f, 0.01463164f, -0.06532798f, 
    -0.02773475f, -0.06390441f, 0.02145803f, -0.06465393f, -0.05415311f, -0.00896052f, 0.02166733f, 0.02984470f, 
    0.04463063f, 0.00178821f, 0.02359067f, 0.03620075f, -0.03340926f, 0.02292880f, -0.02152698f, -0.04923171f, 
    -0.05393149f, 0.00834764f, -0.03260923f, -0.03439370f, 0.04168919f, -0.03271439f, 0.04457745f, -0.02828268f, 
    -0.01529275f, -0.04000601f, -0.03726461f, 0.04803029f, -0.05822709f, -0.04332635f, 0.01122193f, 0.00420940f, 
    -0.04552401f, -0.06248908f, 0.02985222f, -0.02226405f, -0.05501054f, 0.05188347f, 0.02820817f, 0.03888527f, 
    0.04462960f, -0.04589979f, -0.06030305f, -0.05983108f, 0.04805683f, -0.03277285f, 0.01046225f, 0.02798242f, 
    -0.03785397f, 0.01428741f, -0.00846026f, -0.02560898f, 0.01446074f, -0.02643673f, -0.02652792f, -0.04192658f, 
    0.00904754f, -0.02875242f, 0.01051603f, 0.02343577f, 0.04875588f, -0.05147903f, 0.02082850f, -0.03046881f, 
    -0.05276231f, 0.00627285f, -0.01298722f, 0.03809432f, -0.03990032f, 0.00396124f, -0.00609603f, 0.01137707f, 
    -0.02608880f, -0.02241918f, -0.03128263f, 0.03054388f, 0.00823970f, -0.04403010f, -0.04147256f, 0.05403852f, 
    -0.04195359f, 0.04604824f, 0.01088004f, -0.05753195f, -0.00548825f, 0.02736520f, 0.00315914f, 0.00443049f, 
    0.01743341f, -0.04200579f, 0.00259908f, 0.01918382f, -0.05750999f, 0.04241418f, -0.02158509f, 0.04481184f, 
    0.03430878f, -0.03762294f, -0.06202555f, -0.04617238f, -0.03756859f, -0.05985960f, 0.00454499f, 0.01136562f, 
    0.00990030f, -0.02187723f, 0.04177821f, -0.04886241f, 0.04727758f, 0.02862355f, 0.00503231f, 0.03524102f, 
    0.03568006f, -0.02341356f, 0.00631804f, -0.00208923f, -0.00503711f, -0.00942484f, 0.01923382f, -0.02848186f, 
    0.04665615f, 0.00761832f, -0.02823496f, -0.00725945f, 0.02206355f, -0.05065859f, -0.06435923f, -0.04070744f, 
    -0.30607128f, -0.02423762f, 0.00099164f, -0.01546654f, 0.19525532f, -0.25017229f, -0.04535968f, -0.22393505f, 
    -0.34209237f, -0.13383937f, -0.20788038f, 0.07134106f, 0.20869999f, -0.00366685f, 0.02400284f, 0.03724475f, 
    -0.02748135f, 0.11066455f, -0.18050659f, 0.09042072f, -0.15698189f, 0.16819626f, -0.13387638f, 0.01329869f, 
    -0.09807862f, 0.13024689f, -0.15861055f, -0.03063319f, 0.41045171f, 0.14950758f, -0.11847542f, -0.07469143f, 
    0.01478638f, -0.25982082f, 0.01264497f, 0.01438672f, 0.02687180f, 0.24940433f, -0.09204324f, -0.00335590f, 
    0.04700928f, 0.05096866f, 0.04330887f, 0.12289491f, 0.07038090f, 0.06481221f, 0.04491657f, 0.08039249f, 
    0.00272182f, 0.00773543f, 0.09971692f, 0.11634002f, 0.01163352f, 0.06629116f, 0.01674331f, -0.15724128f, 
    0.12280800f, 0.05585246f, -0.08952669f, 0.13310848f, 0.05182291f, -0.09525776f, 0.02462564f, 0.13579930f, 
    0.01490433f, 0.16186309f, 0.10131977f, 0.03174071f, -0.10114583f, 0.13965893f, 0.21366236f, 0.19833304f, 
    0.03419003f, 0.04910512f, 0.09744434f, 0.04840860f, 0.11728008f, -0.06078520f, -0.03218669f, 0.02938518f, 
    -0.16177034f, 0.04577256f, -0.04846475f, 0.10572974f, 0.25023556f, -0.05748603f, -0.04195243f, -0.23193926f, 
    -0.36328834f, -0.06645107f, -0.28071541f, -0.04130001f, -0.05737076f, 0.03333956f, 0.02812388f, 0.09236939f, 
    0.09866016f, 0.19225575f, -0.08835697f, -0.04107885f, 0.05956583f, -0.09594296f, 0.12251796f, -0.04118049f, 
    -0.01353916f, 0.04412860f, -0.11324266f, -0.24572577f, 0.06335925f, 0.00463576f, -0.01625833f, 0.02683529f, 
    0.11472452f, 0.00297642f, 0.09748342f, 0.14379017f, -0.14406343f, -0.14847761f, 0.03788033f, 0.05066886f, 
    0.00084366f, 0.06370787f, -0.08087524f, -0.17291656f, -0.23922074f, -0.30433616f, -0.15719581f, 0.05570621f, 
    0.05639218f, 0.04766284f, -0.01455456f, 0.07640757f, -0.10864998f, 0.11163691f, 0.17447032f, -0.00496099f, 
    0.11574741f, 0.16179594f, 0.05185900f, 0.22261812f, 0.07526773f, -0.02089601f, -0.02051548f, 0.16509983f, 
    -0.02348996f, 0.05705649f, 0.04068606f, 0.02265069f, 0.29165852f, -0.01861419f, -0.04807327f, 0.04770732f, 
    0.07506888f, -0.00381899f, -0.11898518f, 0.25354037f, 0.24797525f, -0.12060068f, 0.13965353f, -0.19152616f, 
    -0.21590798f, 0.08214717f, 0.17341104f, 0.13567238f, 0.11589224f, -0.10209917f, 0.07060330f, 0.00991140f, 
    0.10267224f, 0.07494409f, -0.05506656f, -0.01677093f, -0.02030988f, 0.10845247f, -0.02171398f, -0.00308666f, 
    0.04169026f, 0.04126037f, 0.16371131f, -0.12786034f, -0.11072349f, -0.16359904f, -0.07340897f, -0.00446254f, 
    0.07557847f, 0.10739599f, -0.09972800f, 0.07318712f, -0.10147113f, -0.07927419f, 0.10927821f, 0.00580466f, 
    -0.10672586f, 0.10394725f, 0.05501664f, -0.07990453f, 0.08885688f, 0.33517164f, -0.09048501f, -0.08590175f, 
    -0.09918137f, 0.00437752f, 0.07074635f, 0.05038537f, -0.15858833f, -0.16948709f, -0.14756265f, 0.45998999f, 
    0.25001165f, -0.07656974f, -0.06524981f, -0.06867924f, -0.02108636f, 0.00221961f, -0.05404431f, 0.05818261f, 
    0.06895749f, 0.25045666f, 0.03742800f, -0.01210188f, -0.10989098f, -0.07585698f, 0.09812286f, 0.15491383f, 
    0.11296722f, -0.00339859f, 0.04600946f, -0.05947831f, 0.00165971f, -0.09898226f, 0.17220892f, -0.08831890f, 
    0.02056982f, 0.27624911f, 0.02350481f, 0.16030204f, 0.25787619f, 0.14020279f, 0.32748002f, 0.17205259f, 
    -0.03104712f, 0.07419506f, 0.15912688f, 0.25258008f, 0.11379931f, 0.12189493f, -0.02719618f, -0.01917464f, 
    0.06135418f, 0.03886535f, 0.13428418f, 0.28523788f, 0.06623856f, 0.02101798f, 0.10250563f, 0.05036967f, 
    0.00330295f, 0.01859038f, -0.36617944f, -0.08423895f, -0.06271357f, 0.03585278f, 0.23622240f, 0.01467652f, 
    -0.04577174f, 0.10958275f, -0.03313254f, -0.10558547f, -0.16620587f, -0.04589948f, 0.16185457f, 0.18810010f, 
    -0.05370980f, 0.02560429f, -0.04609955f, 0.02019879f, 0.02738128f, -0.05302052f, -0.03134587f, -0.08600701f, 
    -0.05730304f, 0.26116949f, -0.11431374f, -0.06665908f, 0.01988646f, 0.05616672f, -0.01597829f, 0.28048152f, 
    0.06325565f, 0.27405429f, 0.00953440f, -0.03297937f, 0.21870849f, -0.00150575f, 0.16369790f, -0.12244165f, 
    0.01737797f, -0.07283031f, -0.08327685f, 0.02058625f, -0.03066241f, 0.01158973f, -0.02697244f, 0.13669083f, 
    0.15381825f, -0.13531479f, -0.00220430f, 0.18696947f, 0.21445943f, 0.01050197f, -0.09053413f, 0.17306076f, 
    0.14401340f, 0.02643749f, 0.08251146f, 0.01783403f, 0.05684213f, 0.10564473f, 0.01485458f, -0.06732964f, 
    0.18217474f, -0.01014363f, -0.17451985f, 0.08043320f, 0.09705156f, 0.04707628f, 0.12798792f, 0.12181437f, 
    -0.04961652f, 0.08589856f, 0.00472421f, 0.14487788f, -0.09061246f, -0.09277172f, -0.02239703f, -0.01064559f, 
    -0.03485637f, 0.11267581f, 0.11861192f, 0.05246166f, -0.06154359f, -0.08569454f, -0.18943703f, -0.21230440f, 
    -0.05379028f, 0.09377248f, 0.04724697f, 0.18284336f, -0.09880311f, 0.09507526f, 0.08927773f, 0.13599886f, 
    0.26800668f, 0.19888359f, 0.19087823f, 0.15596111f, 0.06528457f, 0.02577561f, -0.07920233f, 0.03200590f, 
    -0.00591033f, 0.05487562f, 0.29115433f, -0.01175251f, -0.00533266f, -0.04089123f, 0.16957088f, -0.04687674f, 
    -0.08048070f, -0.05607713f, 0.13690145f, 0.11173494f, -0.01441807f, -0.05212563f, -0.02441645f, 0.11683489f, 
    0.05904325f, 0.12946448f, -0.20828526f, -0.05011070f, -0.07191926f, -0.09644097f, -0.00872502f, -0.09715957f, 
    0.17391129f, -0.03272422f, 0.05567583f, 0.02814146f, 0.10234779f, -0.03258080f, 0.00721591f, 0.17585300f, 
    0.10367308f, 0.01591459f, -0.04553928f, 0.02707323f, -0.17821194f, -0.07836767f, -0.21424535f, 0.08546698f, 
    0.05016383f, 0.17102334f, -0.01445256f, 0.12034956f, 0.09611962f, 0.05996325f, 0.09105314f, 0.01320713f, 
    -0.05741621f, 0.04669877f, -0.12420727f, -0.06776638f, 0.03110652f, -0.04914534f, -0.02844735f, 0.07331471f, 
    0.11964635f, 0.10623230f, -0.04311641f, -0.04496101f, 0.01255255f, -0.06941567f, -0.01982039f, -0.01852524f, 
    -0.08214958f, -0.06111769f, 0.02753233f, 0.22313045f, 0.22275825f, 0.04553680f, 0.00422728f, 0.00576877f, 
    -0.00489485f, -0.11326060f, 0.06665081f, 0.09891105f, 0.19404416f, 0.19181903f, -0.01529906f, 0.02998413f, 
    -0.39563888f, 0.07403892f, 0.21024212f, 0.16821571f, -0.11327732f, -0.02123241f, 0.03016743f, -0.21620272f, 
    0.10720322f, -0.04511780f, -0.30131820f, -0.16051760f, 0.06904437f, 0.04167806f, -0.00726866f, 0.05605898f, 
    -0.01011420f, 0.04322923f, -0.10297857f, -0.00705312f, -0.10343355f, -0.00736030f, -0.04325840f, -0.06680782f, 
    0.18364397f, 0.11768740f, -0.19494779f, -0.02529967f, -0.31637755f, -0.05843896f, -0.14291580f, 0.15583131f, 
    0.05189821f, -0.03824045f, -0.05676923f, 0.00869434f, 0.01283307f, -0.04598966f, 0.19670115f, 0.00164419f, 
    0.06707390f, -0.06451609f, 0.04830536f, -0.09904395f, -0.08288914f, -0.20649432f, 0.05125050f, 0.06910457f, 
    0.02205969f, -0.11150873f, -0.02353167f, 0.14273082f, 0.04670984f, 0.05156154f, -0.03443730f, -0.18013817f, 
    0.01806687f, -0.24663825f, -0.00169802f, 0.13710818f, -0.04267441f, -0.10175710f, 0.13526161f, -0.12245687f, 
    0.01995748f, -0.15868707f, 0.04568756f, 0.02449992f, 0.09519687f, 0.14544824f, -0.19003822f, 0.21144140f, 
    -0.02577685f, -0.04808002f, -0.00638361f, 0.13358882f, 0.33501172f, 0.05168020f, -0.06229978f, -0.08851212f, 
    0.09331122f, -0.05146872f, -0.06773571f, 0.02148120f, 0.16772276f, 0.03090311f, -0.17441362f, 0.21789826f, 
    0.00667327f, 0.05406309f, -0.10664506f, -0.07837339f, 0.01733504f, -0.06346209f, 0.07193703f, 0.09545738f, 
    0.13558118f, 0.08864781f, 0.28181022f, 0.03134866f, -0.25771537f, 0.15063632f, 0.07398032f, 0.09080010f, 
    0.03213004f, 0.08352251f, -0.00133522f, 0.09569842f, 0.08359669f, 0.02581703f, 0.06879029f, -0.04649195f, 
    -0.06873105f, -0.06607842f, 0.00835527f, 0.10289943f, -0.10019589f, 0.06143408f, -0.03592578f, 0.06873919f, 
    -0.32745206f, -0.12015873f, 0.07458827f, -0.03768929f, -0.11487389f, 0.04998379f, 0.08612783f, -0.12477037f, 
    0.09844623f, -0.30555966f, -0.01600915f, 0.05478982f, -0.00768587f, -0.23413648f, -0.11184961f, -0.30358925f, 
    0.02554264f, -0.04852694f, -0.01847601f, 0.09800661f, -0.03929203f, 0.04566336f, -0.02116786f, -0.05327654f, 
    -0.20787509f, -0.23152398f, -0.01642959f, 0.11337425f, -0.02334509f, 0.22902432f, 0.05962230f, 0.10829906f, 
    0.07882877f, 0.02932844f, 0.23059395f, -0.09118517f, -0.06183621f, 0.09539560f, 0.10101267f, 0.18256608f, 
    0.05692537f, -0.19876219f, -0.04533493f, 0.08331171f, 0.06804699f, -0.08046572f, 0.11105175f, 0.00125064f, 
    -0.18805856f, -0.03451991f, -0.17856354f, -0.00063356f, 0.23020747f, 0.03390467f, 0.01200921f, 0.05983346f, 
    0.20312074f, 0.13890503f, 0.20316894f, 0.14556962f, 0.17243381f, -0.05545345f, 0.05987574f, -0.06098741f, 
    -0.04178766f, -0.04354347f, 0.08689401f, 0.06688906f, 0.13495110f, 0.09048140f, -0.12505104f, 0.21196492f, 
    0.06480754f, 0.02875197f, 0.03498751f, 0.14251760f, -0.05997227f, 0.11082889f, -0.12055373f, 0.28225130f, 
    0.14557630f, 0.00900598f, 0.03294811f, 0.26317510f, -0.01248874f, 0.05630847f, -0.04317877f, 0.21765929f, 
    0.01681212f, -0.17712609f, 0.00490325f, 0.08789071f, 0.06715913f, 0.04217247f, -0.11627493f, -0.11068320f, 
    -0.21902570f, -0.09004565f, 0.05720622f, -0.30116215f, -0.09339201f, 0.00866339f, -0.12434267f, 0.02132837f, 
    0.03720553f, -0.31288984f, -0.13154411f, -0.03410151f, -0.14889483f, -0.09879237f, 0.02692279f, -0.10601137f, 
    0.17074926f, -0.09962320f, -0.12531537f, 0.11189062f, 0.00779936f, 0.04371852f, 0.04314832f, -0.01322550f, 
    0.12098924f, 0.08399747f, -0.04758789f, -0.05437697f, 0.28272006f, 0.06607515f, 0.10117864f, 0.04240735f, 
    0.02377110f, 0.01076305f, 0.13197693f, -0.03418066f, 0.00395651f, -0.17499562f, -0.05849991f, -0.29883304f, 
    -0.00735731f, -0.09608959f, -0.11856171f, -0.03573018f, -0.07962555f, -0.35811171f, 0.05873170f, 0.23660539f, 
    0.08974458f, 0.10893348f, 0.16965024f, 0.06227660f, 0.11891296f, 0.34993404f, 0.01196496f, 0.32539839f, 
    0.10879681f, 0.27860272f, 0.08420286f, 0.16133377f, 0.20720257f, -0.10321467f, -0.03888059f, 0.07088345f, 
    0.20213288f, 0.20927906f, 0.31158155f, 0.06495977f, 0.04046453f, 0.10115165f, -0.07307952f, -0.02066660f, 
    0.17295085f, 0.05475140f, 0.07790715f, -0.27659589f, 0.03898153f, -0.14352176f, -0.06573315f, -0.05750276f, 
    0.00682655f, -0.32753888f, 0.22895116f, 0.34742403f, 0.19190997f, -0.02563800f, 0.01122073f, 0.02713365f, 
    0.03257646f, -0.04836681f, -0.02232848f, -0.17053160f, -0.01212889f, -0.03869182f, 0.07500812f, 0.05092615f, 
    -0.19841006f, 0.04332150f, 0.02694152f, 0.19319713f, -0.13057548f, -0.27133581f, -0.36416116f, 0.17753069f, 
    -0.00603429f, 0.20388111f, -0.01259183f, 0.03368980f, 0.00589906f, -0.10418548f, -0.16458303f, -0.11927152f, 
    0.12717384f, 0.11507492f, 0.22730127f, -0.06981657f, 0.03362862f, 0.17542532f, 0.27765298f, 0.04043549f, 
    0.01559348f, 0.17251925f, 0.04065395f, 0.09180950f, 0.14135480f, 0.02226358f, -0.20771036f, 0.04248527f, 
    0.28801623f, -0.34463009f, 0.03363825f, -0.21863221f, -0.00114185f, -0.03464615f, 0.00967647f, -0.22532551f, 
    0.19982848f, 0.31081918f, -0.08543006f, 0.11415880f, 0.06786709f, 0.19378103f, 0.01100628f, -0.08389790f, 
    0.05127937f, -0.17768076f, 0.04413716f, 0.09525206f, 0.01600129f, 0.07483157f, 0.12750751f, 0.03982602f, 
    0.05992538f, -0.00474438f, 0.25009462f, 0.33487424f, -0.02006330f, 0.09158807f, 0.10446171f, 0.06645566f, 
    0.12870039f, -0.12689336f, 0.11949833f, 0.17237896f, -0.06416202f, -0.48822480f, -0.07092029f, 0.26774979f, 
    -0.00200908f, 0.06884263f, 0.14733094f, -0.07171333f, -0.13642921f, -0.35069349f, -0.26422092f, 0.07616828f, 
    0.13396753f, 0.16240808f, -0.18851353f, -0.06054080f, -0.07986993f, -0.14083754f, 0.11107187f, -0.11436360f, 
    0.00050379f, -0.23649485f, -0.20147237f, -0.04978641f, -0.08846097f, 0.02602958f, -0.03298444f, -0.00385082f, 
    -0.22664569f, -0.05909511f, -0.05428918f, 0.03469579f, -0.12833484f, 0.00701921f, -0.12691838f, -0.53673172f, 
    -0.18485841f, -0.00712883f, 0.07870243f, 0.17302860f, 0.07041240f, -0.08662954f, 0.10694534f, -0.00637972f, 
    -0.33453873f, 0.14901751f, 0.25992057f, -0.08701484f, 0.00443527f, -0.00382718f, 0.05780978f, -0.11171543f, 
    0.04924995f, 0.07234272f, -0.14266720f, 0.10431065f, -0.07085977f, -0.10183030f, -0.22019371f, 0.16508739f, 
    0.00642595f, -0.05557494f, 0.15572917f, 0.29619235f, 0.21821433f, 0.03061332f, 0.00811934f, 0.05354995f, 
    0.05633872f, 0.07709409f, 0.11519843f, -0.26022261f, -0.19546081f, -0.19798583f, -0.10268496f, -0.07358410f, 
    -0.05585029f, -0.10306561f, -0.02860846f, 0.04769479f, -0.22324325f, 0.21258554f, 0.19545147f, -0.05966032f, 
    0.09763516f, -0.03578512f, 0.01847699f, 0.09779970f, 0.10673159f, -0.21289580f, -0.03994499f, 0.44864115f, 
    -0.00941012f, 0.20782296f, -0.02157818f, 0.07948635f, 0.12569144f, 0.01568375f, 0.24490392f, -0.29099581f, 
    -0.09700014f, -0.04976901f, -0.04783782f, -0.09131646f, -0.05531253f, 0.01106926f, -0.01147293f, -0.05195932f, 
    0.11267304f, 0.19426900f, -0.09542438f, 0.00941199f, -0.05660280f, 0.08520297f, -0.00307859f, 0.15051268f, 
    -0.01708734f, -0.20464967f, 0.01666068f, -0.15309404f, 0.18239956f, -0.04363791f, 0.00061836f, 0.04436864f, 
    0.01543365f, -0.32955730f, -0.26785058f, 0.05102265f, 0.00587981f, -0.04892198f, -0.05112284f, 0.06670458f, 
    -0.04007433f, 0.08328123f, 0.20748304f, -0.35222423f, -0.13440290f, -0.27678931f, 0.08261294f, -0.02533314f, 
    -0.10714772f, -0.05893068f, -0.20589009f, -0.05620705f, 0.17033534f, -0.00749102f, -0.01698282f, 0.01991719f, 
    -0.04954803f, 0.09943280f, 0.07957488f, 0.17824689f, -0.03682259f, -0.22989783f, 0.29467800f, -0.04335265f, 
    0.04202450f, -0.08275869f, 0.02653626f, 0.22731692f, 0.08114585f, -0.40666804f, -0.16690174f, 0.12159679f, 
    -0.08735877f, 0.02750156f, -0.23651505f, -0.02463260f, 0.09593176f, -0.03652950f, -0.15948915f, -0.24998879f, 
    0.15535127f, -0.07795621f, 0.01300042f, 0.09873554f, 0.05632569f, -0.03779413f, -0.05693723f, -0.14295527f, 
    0.14420900f, 0.14361598f, -0.06155465f, 0.08589786f, -0.07749227f, 0.01815998f, 0.07762174f, 0.07158098f, 
    0.00362108f, 0.05539551f, 0.04297331f, -0.11913127f, 0.02337601f, 0.01476204f, -0.07239918f, -0.00873090f, 
    -0.00293872f, 0.08218709f, -0.66171581f, -0.25710857f, -0.08194923f, 0.14514643f, 0.27505982f, -0.04060989f, 
    -0.01427450f, -0.19816190f, -0.02296549f, -0.22205107f, -0.33714598f, 0.10153704f, 0.09221900f, -0.07883950f, 
    0.11411507f, -0.02434775f, 0.02978917f, 0.15460029f, 0.03228876f, 0.05129445f, -0.00955968f, -0.09202574f, 
    0.08570243f, 0.00391541f, -0.01884238f, -0.06132639f, 0.17219315f, -0.47556737f, 0.00485464f, -0.02448281f, 
    -0.02755834f, -0.12172718f, 0.03742830f, 0.05653198f, -0.04713360f, -0.19063948f, -0.09322496f, -0.07872634f, 
    -0.03377740f, -0.01108757f, -0.04386886f, 0.05843861f, 0.02442301f, 0.00956094f, -0.18886277f, 0.37283707f, 
    0.14846413f, -0.12729530f, 0.11363522f, -0.11137620f, -0.14139481f, 0.08439155f, 0.13788067f, 0.36364010f, 
    -0.12801424f, 0.41357255f, -0.02432498f, -0.10401782f, -0.10308468f, 0.02160996f, 0.07398212f, -0.05251623f, 
    0.16305414f, -0.11937793f, 0.13734888f, -0.18250820f, 0.07730638f, -0.18195868f, 0.01424843f, 0.09957043f, 
    0.08312643f, 0.09813736f, -0.03879798f, -0.03862730f, 0.06932699f, 0.20880491f, -0.17918551f, -0.16412057f, 
    -0.12352095f, -0.15920556f, -0.51184130f, -0.02540813f, 0.47247386f, 0.07369480f, -0.19820553f, -0.11983618f, 
    0.01175742f, 0.06015385f, -0.07539085f, -0.32536703f, -0.74792671f, 0.59172398f, 0.28584868f, -0.01418679f, 
    -0.06819534f, 0.00466525f, 0.18776841f, -0.15271665f, 0.50096875f, -0.09463536f, 0.12316994f, -0.02789130f, 
    -0.01441044f, 0.04586582f, 0.01379040f, -0.00443106f, 0.00789587f, -0.09566514f, 0.00947136f, 0.03446710f, 
    0.03309453f, 0.09867457f, -0.08589160f, -0.03994153f, 0.02345959f, 0.06432773f, 0.08657517f, 0.18634510f, 
    0.22411643f, -0.09361224f, -0.09349529f, -0.04585565f, 0.06761841f, 0.01325849f, -0.07434788f, -0.47430196f, 
    -0.56887567f, -0.40342954f, 0.16511364f, 0.00376794f, -0.04711889f, -0.01152666f, -0.01247387f, -0.03655618f, 
    -0.00855624f, -0.03526784f, -0.04884955f, 0.00630410f, 0.01538538f, -0.05620535f, -0.05409233f, 0.00735924f, 
    -0.05889665f, -0.04994916f, -0.01130488f, 0.01657935f, -0.00814442f, -0.00411377f, -0.07690366f, -0.08413572f, 
    -0.01608414f, 0.02501296f, -0.06915984f, -0.03065317f, -0.06885697f, -0.06645566f, -0.06527261f, 0.01725625f, 
    0.01159788f, -0.09802680f, -0.05573741f, -0.00732000f, -0.00633881f, -0.00832464f, -0.00727071f, 0.02126938f, 
    -0.03635448f, -0.07026754f, -0.03044228f, -0.07019816f, -0.04317736f, -0.04307668f, -0.02599603f, 0.00092153f, 
    -0.01450959f, 0.00119044f, -0.08325390f, -0.07099068f, -0.02120554f, -0.06452856f, -0.00618647f, -0.03544142f, 
    0.01199311f, -0.05416022f, -0.08329301f, -0.07431699f, 0.00632750f, 0.01388650f, -0.01196699f, 0.01329575f, 
    -0.02285358f, 0.00467130f, -0.06579416f, -0.00958042f, -0.08009037f, -0.00766285f, -0.06709077f, 0.01329973f, 
    -0.02893282f, -0.02877725f, -0.05789663f, -0.07852968f, -0.02042103f, -0.06050673f, 0.00656458f, -0.02934767f, 
    -0.08380789f, 0.00450548f, -0.01080623f, -0.05450297f, 0.00761169f, 0.02799604f, 0.02205796f, -0.05687232f, 
    -0.04329877f, -0.04816329f, 0.05290307f, -0.02871220f, 0.00637879f, -0.08835901f, -0.00027330f, -0.03787166f, 
    -0.02850045f, 0.02029855f, 0.03671577f, -0.03795956f, 0.00296586f, -0.04495717f, -0.07710855f, -0.04408334f, 
    -0.04081583f, 0.01016684f, -0.07449021f, -0.06744096f, -0.08895044f, -0.01476767f, 0.01431099f, 0.02060043f, 
    0.00017449f, -0.05008919f, 0.04353528f, -0.06049615f, -0.03045803f, 0.04377593f, -0.05387206f, -0.08392344f, 
    -0.04650140f, 0.01054891f, -0.05885651f, -0.03369798f, -0.00562157f, -0.03985469f, 0.01060747f, -0.02855045f, 
    0.00641464f, -0.00473394f, -0.07593872f, -0.06153467f, -0.02399428f, -0.08321495f, -0.09359691f, -0.05622172f, 
    -0.03322524f, 0.01284898f, -0.06786423f, 0.00010624f, -0.05846420f, -0.02809082f, -0.06364799f, -0.08395687f, 
    -0.03104527f, 0.01825865f, -0.05824679f, -0.05879634f, 0.00729014f, -0.05417651f, -0.05229444f, -0.02363126f, 
    -0.01647317f, -0.02608754f, 0.02430092f, -0.08701433f, -0.08544292f, 0.03895606f, -0.02328922f, -0.04495976f, 
    -0.06235389f, -0.04308135f, 0.01724965f, -0.04541889f, -0.05431894f, -0.07349273f, 0.02003191f, -0.02441571f, 
    -0.08320426f, -0.01674954f, -0.05226194f, -0.00842767f, 0.03666836f, -0.04599892f, 0.00954816f, 0.01312299f, 
    -0.05709897f, 0.00959440f, -0.02836866f, -0.06647936f, -0.00784312f, 0.02930603f, -0.03874473f, -0.08105797f, 
    0.00858413f, -0.01159205f, -0.04594229f, -0.05852624f, -0.02521864f, -0.04422187f, -0.03711072f, -0.02985598f, 
    0.00306100f, -0.01963547f, -0.05363914f, -0.01547289f, -0.00888202f, -0.02122838f, -0.03900638f, -0.07566557f, 
    -0.00069190f, -0.07893971f, -0.09125765f, 0.01497001f, -0.02621233f, -0.01109188f, -0.06241164f, 0.01361683f, 
    -0.02274462f, 0.00967030f, -0.09110458f, -0.08777387f, 0.01107245f, -0.02238335f, -0.06492481f, -0.00105359f, 
    -0.00281075f, 0.01610876f, -0.02535837f, 0.03882296f, -0.03825387f, -0.02753475f, -0.00422662f, -0.07669901f, 
    -0.00526066f, -0.07475282f, -0.03491345f, 0.03752231f, -0.02966288f, -0.08449902f, -0.09101630f, -0.00838390f, 
    -0.02033524f, 0.00447102f, -0.06774499f, -0.02170609f, -0.06225528f, -0.05709054f, -0.05056144f, -0.01157822f, 
    0.00330879f, 0.01584455f, -0.04380058f, -0.07033911f, -0.05164998f, -0.03807687f, 0.02528847f, -0.00430267f, 
    -0.07011282f, -0.03995575f, -0.01638390f, -0.04089268f, 0.01187596f, -0.02415545f, 0.01736946f, -0.01735492f, 
    -0.02899378f, -0.05236219f, -0.00812427f, -0.08569422f, -0.07128072f, -0.01443079f, -0.03391377f, -0.06141469f, 
    -0.06500405f, -0.08197886f, -0.02908960f, 0.01611916f, 0.00284835f, 0.04356438f, 0.01435376f, 0.02667991f, 
    -0.04990447f, -0.04723006f, -0.07654890f, 0.01215376f, 0.01517563f, -0.02302301f, -0.01582235f, -0.03762168f, 
    -0.01508165f, 0.01828790f, -0.08084387f, -0.06126003f, -0.03356949f, 0.01474503f, -0.05280929f, -0.00221529f, 
    0.00244848f, -0.05037551f, -0.06880695f, -0.06203167f, 0.02818129f, -0.04887085f, 0.01870333f, -0.03174352f, 
    -0.03059708f, 0.01618730f, -0.19763315f, 0.06707169f, -0.04195747f, 0.00164847f, -0.08729814f, -0.13179456f, 
    0.04614100f, 0.04197630f, -0.09899461f, 0.06378179f, 0.01607821f, -0.03997264f, 0.06828922f, 0.13293497f, 
    -0.05499601f, 0.02109360f, 0.09018659f, -0.08928964f, 0.09491778f, -0.27352270f, -0.12922369f, -0.21086255f, 
    0.11550590f, 0.09078075f, -0.01016688f, 0.22893989f, -0.33524740f, 0.02362872f, 0.07741683f, 0.01648235f, 
    0.16396628f, -0.06365151f, -0.11310194f, 0.00179103f, 0.14419138f, -0.02465660f, 0.11572468f, 0.05119091f, 
    0.14320922f, 0.02763456f, -0.06805829f, -0.10149820f, 0.03558733f, -0.10523819f, -0.01884043f, 0.07011648f, 
    -0.06038397f, -0.00102763f, -0.05420944f, 0.11364787f, 0.01514835f, 0.05880000f, 0.15769684f, 0.07194310f, 
    0.10601472f, -0.01824283f, -0.08810551f, 0.00304239f, -0.04269386f, 0.15039238f, -0.11882869f, -0.38734168f, 
    -0.29516646f, -0.03851604f, -0.05598694f, 0.06941297f, -0.22738321f, 0.09431237f, -0.05136883f, 0.12621775f, 
    0.23031805f, -0.28587884f, -0.18803185f, 0.03913102f, -0.02847179f, 0.10985238f, 0.03123474f, 0.08009521f, 
    -0.05058945f, 0.07414847f, 0.18821801f, 0.13102221f, 0.02769011f, 0.09553651f, 0.10213778f, 0.04230934f, 
    0.03304039f, -0.03229411f, 0.08288159f, -0.08581627f, 0.09254687f, 0.17379284f, 0.04083524f, -0.17409988f, 
    0.03683969f, -0.06270318f, -0.07194716f, -0.35674310f, -0.01761155f, 0.31062680f, 0.00452030f, -0.08368766f, 
    -0.07780196f, -0.00168694f, -0.01356657f, -0.06840873f, 0.06310024f, 0.22470827f, 0.09181996f, 0.02666073f, 
    0.14612707f, 0.03740283f, -0.06221662f, -0.05876272f, 0.00144084f, -0.03282563f, -0.02383613f, 0.06207189f, 
    0.18980654f, 0.10563729f, -0.01074067f, -0.25011104f, 0.01373165f, 0.04527472f, 0.02259316f, -0.33251968f, 
    0.00207174f, 0.15443578f, 0.16271223f, 0.06018401f, 0.19133891f, -0.03142315f, 0.00515486f, -0.02870361f, 
    -0.40400887f, -0.37276682f, 0.18499286f, 0.10660784f, -0.02223523f, -0.01199236f, -0.12845488f, 0.02635634f, 
    -0.20942432f, -0.46196762f, 0.04934204f, 0.05536938f, 0.16866766f, 0.08344546f, -0.21357512f, -0.07362409f, 
    0.09775266f, 0.23605803f, -0.09265170f, -0.15565801f, -0.02196717f, -0.04198944f, 0.03483310f, -0.05403262f, 
    0.02022792f, 0.04880938f, -0.18413144f, 0.17537752f, 0.12768456f, -0.02685815f, 0.15410091f, 0.09340087f, 
    0.02585756f, 0.02906818f, 0.06720589f, 0.13529114f, 0.05060779f, -0.13740434f, 0.09380718f, -0.13131014f, 
    0.27363583f, -0.05687618f, 0.17467232f, 0.00040113f, 0.00803246f, 0.33287227f, 0.16101424f, 0.02379169f, 
    -0.03405808f, 0.01366965f, -0.09238102f, 0.04226443f, -0.10072377f, 0.29218733f, -0.27738366f, -0.52408260f, 
    -0.04687505f, -0.03111266f, -0.14049058f, 0.00218900f, 0.06488194f, 0.01133674f, -0.09399252f, -0.16843186f, 
    0.39359480f, -0.08364681f, -0.00301424f, -0.20283328f, 0.03907695f, 0.04699031f, 0.12596105f, 0.24848531f, 
    0.09704346f, -0.19582082f, 0.06627925f, -0.01017672f, -0.00548515f, 0.13711058f, 0.05203544f, 0.10920262f, 
    -0.16564244f, 0.19240408f, 0.11391939f, -0.15172982f, 0.21953987f, -0.03387112f, -0.01890380f, 0.10669455f, 
    0.03114948f, 0.17728114f, -0.44159102f, 0.13409448f, 0.03951815f, 0.28665316f, 0.11489435f, 0.12938218f, 
    0.11095518f, 0.02670800f, -0.23276863f, 0.30117661f, 0.31556967f, 0.01142968f, -0.04648537f, 0.10734028f, 
    -0.24479823f, -0.03330532f, 0.05313220f, 0.05044681f, -0.05220853f, 0.20088154f, -0.17933188f, 0.15310442f, 
    -0.03960802f, -0.01373078f, -0.00467518f, -0.09839280f, 0.23247612f, 0.47881538f, -0.08575084f, 0.16531293f, 
    -0.02446005f, -0.02195298f, 0.01208464f, 0.00114376f, -0.16152225f, -0.00916028f, -0.02577611f, -0.15434010f, 
    0.10519946f, 0.02071057f, 0.22755834f, 0.00416622f, -0.07704264f, -0.05389905f, -0.03271180f, -0.06749058f, 
    -0.02700959f, 0.06623320f, 0.07713983f, -0.13113892f, 0.04181108f, -0.03387520f, 0.04595096f, -0.03247404f, 
    -0.38076305f, -0.37126607f, -0.07691942f, -0.07638678f, 0.17594995f, -0.15312643f, 0.02636579f, -0.00259575f, 
    0.24261583f, 0.23137212f, 0.03455107f, 0.07419822f, 0.05360980f, -0.13212448f, 0.05752238f, -0.05572408f, 
    -0.18902011f, -0.06804620f, -0.00045404f, -0.13238752f, 0.18973386f, -0.12938899f, -0.04558444f, 0.12097346f, 
    0.01479729f, -0.08070006f, 0.16047709f, 0.20961186f, 0.26029986f, 0.04375517f, 0.05109704f, -0.00111065f, 
    -0.03231300f, -0.06224881f, 0.05522430f, -0.17681822f, -0.28923228f, -0.09686714f, -0.03045565f, 0.05687417f, 
    -0.10984492f, -0.00247026f, -0.06106940f, 0.08849272f, -0.00733126f, 0.06578726f, 0.04968794f, 0.05216638f, 
    -0.03970682f, -0.12661777f, 0.14135712f, 0.04355266f, -0.03647078f, -0.12884529f, -0.12995912f, -0.01564563f, 
    0.16552223f, -0.07152312f, -0.07437500f, -0.08704657f, 0.08320101f, 0.08705002f, -0.22646709f, -0.14134850f, 
    -0.26118797f, 0.11047038f, -0.02650329f, 0.03012097f, -0.00700041f, 0.01751138f, 0.13113515f, -0.03306052f, 
    0.24598950f, -0.04258326f, -0.08551927f, 0.20115636f, -0.07186201f, -0.00068385f, 0.02490013f, 0.11583975f, 
    0.15483174f, -0.05942523f, 0.16778500f, -0.06762954f, 0.06016011f, 0.06662139f, 0.05461051f, -0.00491442f, 
    -0.14758651f, 0.03622307f, 0.09525841f, 0.04733147f, 0.01432421f, -0.03716891f, 0.10406734f, 0.01171868f, 
    -0.04456054f, 0.06005159f, -0.11892532f, -0.16893369f, -0.10491825f, 0.03064463f, -0.02062055f, -0.10201449f, 
    0.20044081f, -0.11375759f, -0.20472726f, 0.00114135f, 0.18142958f, -0.03603024f, 0.16661315f, 0.06556860f, 
    -0.09621035f, 0.06304159f, 0.00652732f, -0.05317849f, -0.29925877f, -0.09208573f, -0.19964750f, 0.06549868f, 
    -0.05099197f, -0.08195063f, 0.06760526f, -0.00725067f, 0.00255544f, 0.18986081f, 0.11334265f, 0.18335085f, 
    0.02836875f, 0.01544340f, 0.01361508f, -0.10562243f, -0.14809242f, 0.09223752f, 0.19666770f, -0.01107533f, 
    0.02438471f, 0.18165982f, 0.03674041f, -0.07254609f, 0.08012909f, -0.10765675f, -0.00585247f, 0.02515494f, 
    0.10733672f, 0.25961202f, 0.02532183f, 0.06023859f, 0.07353812f, 0.12097377f, -0.03890691f, -0.13353592f, 
    0.14321487f, 0.15554962f, -0.07966037f, 0.04414639f, 0.19795671f, 0.11722784f, 0.02604924f, -0.16899782f, 
    -0.13591774f, 0.20587353f, 0.11932845f, -0.00134577f, -0.09099670f, -0.17539445f, 0.04188789f, -0.11074509f, 
    0.12685950f, -0.00784410f, -0.32478374f, 0.02223213f, 0.04645146f, 0.05390247f, -0.07044520f, -0.03975537f, 
    0.14454702f, 0.00210834f, -0.06894886f, -0.15352972f, -0.27858239f, -0.41647679f, 0.06304330f, 0.12830165f, 
    0.08308983f, 0.03657712f, 0.06121316f, 0.09617496f, -0.08162179f, -0.05217114f, 0.02429971f, 0.06464394f, 
    -0.06096198f, -0.08842728f, 0.13357569f, 0.01805503f, 0.09152160f, 0.37411681f, 0.00796180f, 0.01288255f, 
    0.08429684f, 0.03107877f, 0.10162448f, 0.03334983f, -0.02325851f, 0.06689892f, 0.15519056f, 0.15976532f, 
    0.20872556f, 0.07188598f, -0.00114458f, -0.01218706f, 0.06065339f, 0.00314846f, 0.06051091f, -0.63373864f, 
    -0.41202083f, -0.03957070f, 0.10235110f, 0.05455285f, 0.16827713f, 0.03838535f, 0.01587843f, -0.01436879f, 
    -0.17331488f, 0.01304078f, -0.06815106f, -0.01131442f, 0.06180204f, 0.02077359f, 0.04585247f, 0.06748798f, 
    0.27078599f, 0.05875945f, 0.16142675f, 0.07114350f, 0.07753964f, 0.24271783f, 0.15825143f, 0.04693991f, 
    -0.11851981f, -0.00036729f, -0.06657917f, -0.10887580f, 0.02252355f, 0.07030158f, -0.18905783f, -0.00896125f, 
    -0.05356150f, 0.12371340f, 0.04749218f, 0.25194457f, -0.01242113f, -0.14717409f, 0.06078552f, 0.09929810f, 
    0.10469675f, -0.07389611f, 0.12722293f, 0.03715147f, -0.05979096f, -0.23261827f, -0.28016558f, 0.07582370f, 
    0.02111483f, 0.02209908f, 0.02845315f, 0.10015094f, 0.02215694f, -0.10246664f, -0.32327050f, -0.14585891f, 
    0.00192047f, 0.04963293f, -0.00814096f, -0.07063670f, 0.03047347f, 0.15811203f, -0.23482537f, -0.03646586f, 
    0.08488650f, 0.00813138f, 0.00964409f, 0.04054923f, 0.01414213f, 0.01953312f, 0.15110870f, 0.62931639f, 
    0.00097504f, -0.14932184f, 0.15030783f, -0.05118090f, -0.11133317f, 0.17852388f, 0.09909271f, 0.08902829f, 
    -0.18167096f, -0.12743531f, -0.11529615f, -0.00298917f, 0.15244102f, -0.04587852f, 0.08085045f, -0.15732375f, 
    -0.16734748f, -0.16555721f, -0.07879469f, 0.26842305f, -0.04790439f, 0.11937614f, 0.03041436f, -0.03805941f, 
    0.09896155f, 0.00002899f, -0.10390160f, -0.13260931f, -0.04239355f, 0.06768264f, 0.02081484f, 0.16998340f, 
    0.06764965f, -0.01928573f, -0.07497794f, 0.31169248f, 0.03818417f, 0.16168873f, 0.00020995f, -0.03770126f, 
    -0.17632756f, 0.05465272f, 0.00684191f, -0.05504264f, 0.13974032f, 0.10523807f, -0.05842553f, 0.25022838f, 
    0.21891980f, 0.14020069f, 0.29456070f, -0.00037399f, -0.02294037f, 0.11604466f, 0.12481484f, 0.10035976f, 
    -0.09952229f, 0.08086986f, 0.00682884f, 0.16034736f, -0.10731503f, 0.01953317f, 0.02016602f, 0.09772734f, 
    -0.04528253f, 0.07171574f, 0.03001568f, 0.11595280f, -0.12341098f, 0.02613820f, -0.12750232f, -0.05135073f, 
    -0.07667588f, -0.06419736f, 0.19508098f, -0.06440333f, 0.04908060f, 0.04307077f, 0.11800072f, 0.02045972f, 
    0.08976341f, -0.30662936f, -0.20939553f, 0.05473667f, 0.08749890f, 0.00909376f, -0.18633407f, 0.04482403f, 
    0.02535727f, -0.04167711f, 0.04613265f, -0.05628878f, -0.02184760f, 0.14468256f, 0.08856368f, -0.13742566f, 
    0.02599797f, 0.01215990f, 0.10938334f, 0.10971285f, 0.07852868f, -0.05298445f, -0.18542711f, -0.22826236f, 
    0.15143940f, 0.11087091f, -0.02887712f, -0.08806047f, 0.01718036f, 0.11664870f, -0.00591812f, -0.11224273f, 
    -0.07221089f, 0.11015289f, 0.02824563f, -0.22223930f, 0.07382495f, 0.14844294f, 0.10202966f, 0.08674169f, 
    0.07901081f, 0.02187837f, 0.16184540f, -0.02136006f, -0.13467388f, -0.06271648f, -0.13442983f, -0.07100456f, 
    -0.07095256f, 0.07786834f, -0.00090286f, -0.17385732f, -0.07685655f, 0.01802791f, 0.01696983f, 0.00597503f, 
    -0.12902501f, 0.05779789f, 0.11166103f, 0.04079896f, 0.20391312f, 0.12744887f, -0.02949423f, -0.01271526f, 
    -0.12032095f, -0.09690485f, 0.26374111f, 0.11743155f, 0.06595740f, -0.11571323f, -0.24382047f, -0.12839928f, 
    0.04507148f, -0.04357728f, -0.04585766f, 0.24640137f, 0.01027071f, 0.18840288f, -0.22459231f, -0.23569018f, 
    0.02675590f, -0.01583547f, -0.09879595f, -0.16295616f, 0.09317607f, -0.04544509f, -0.05754483f, -0.00781289f, 
    -0.06304441f, 0.00900386f, -0.00624200f, 0.36449519f, 0.05676341f, 0.04800045f, 0.03185199f, -0.04577226f, 
    0.01335872f, -0.03175611f, 0.15818691f, 0.06726082f, -0.12966481f, 0.11242750f, 0.06255864f, 0.04168989f, 
    0.12547977f, -0.02771059f, 0.01542945f, 0.00165709f, -0.01656577f, 0.07116405f, -0.08582536f, -0.01455048f, 
    0.06476103f, 0.11204645f, 0.10505960f, 0.04807865f, -0.18333718f, 0.10353842f, -0.37715241f, -0.39495328f, 
    0.01847843f, 0.06882287f, 0.14743060f, 0.14075832f, 0.09817450f, 0.07961629f, -0.03645537f, -0.21319942f, 
    0.00892477f, 0.04892864f, -0.00406879f, -0.05723201f, 0.09821259f, -0.02697602f, -0.08250391f, 0.16591696f, 
    0.09538111f, 0.00564798f, -0.04244152f, -0.26392245f, 0.00584075f, -0.07814559f, 0.12762320f, -0.01310303f, 
    0.04369660f, 0.35791826f, -0.06043260f, 0.03482395f, 0.11570968f, 0.09502606f, 0.08693694f, 0.12874269f, 
    -0.10828664f, 0.04939900f, -0.01781393f, -0.15529025f, 0.03901266f, 0.20493966f, 0.07414753f, 0.07144179f, 
    0.09585623f, -0.16388829f, 0.01196777f, 0.21757837f, 0.10494256f, 0.00021937f, 0.36929557f, 0.04743240f, 
    0.05246200f, -0.12776768f, -0.00590640f, 0.21182847f, 0.16230524f, -0.27158508f, 0.07638234f, 0.11272204f, 
    0.09322561f, 0.01402609f, 0.11576965f, 0.00703480f, 0.05091857f, 0.03336633f, -0.08056761f, 0.18286611f, 
    0.08405933f, -0.07015704f, 0.05137860f, -0.13808186f, -0.01638283f, 0.03394471f, -0.03348903f, 0.02195819f, 
    0.04799515f, 0.03404174f, -0.06292105f, -0.03528670f, -0.10152104f, -0.01858991f, -0.00621513f, 0.17522018f, 
    -0.01943691f, -0.02745995f, 0.03645768f, -0.09700852f, -0.00774572f, 0.01528414f, 0.03196963f, -0.27204886f, 
    -0.57508814f, 0.02146777f, -0.07548977f, 0.09847689f, 0.13198385f, 0.19829141f, 0.11652509f, 0.19290200f, 
    0.27914259f, 0.21641961f, -0.04375133f, -0.06678359f, 0.19590686f, 0.02371927f, -0.00338220f, -0.06067086f, 
    0.10505643f, 0.04199109f, 0.01193887f, 0.04886765f, -0.01886781f, 0.07585391f, 0.01898774f, -0.12450058f, 
    -0.13676237f, 0.06653897f, 0.27204403f, -0.03470019f, -0.10806052f, -0.10687085f, -0.07427505f, 0.04161055f, 
    0.10887961f, 0.03070611f, 0.16838960f, -0.12829432f, -0.09904492f, 0.27586460f, -0.06140113f, 0.11800978f, 
    0.19018263f, -0.11201528f, -0.11757921f, -0.04024487f, -0.11811228f, 0.00184591f, 0.12731878f, 0.01509013f, 
    0.02765458f, -0.06237505f, 0.03810804f, 0.11979467f, 0.09493493f, -0.10558120f, 0.14831056f, 0.12822522f, 
    0.04821869f, -0.15753676f, -0.02892808f, 0.08042277f, -0.01312547f, -0.21062244f, 0.17126070f, 0.12271596f, 
    0.21452388f, 0.02760974f, -0.00165050f, -0.16556002f, 0.10818896f, 0.07070767f, 0.10376654f, -0.21414053f, 
    -0.16810888f, -0.20616832f, -0.14536151f, 0.08370060f, -0.11573111f, -0.04545661f, -0.17008866f, 0.01932620f, 
    0.00702640f, -0.37412772f, -0.22378844f, 0.04402316f, -0.21324143f, 0.04076564f, 0.09212771f, 0.00622706f, 
    -0.17689648f, 0.12161792f, 0.29789144f, -0.03381252f, -0.00032967f, 0.14807230f, 0.04990979f, 0.14251666f, 
    -0.06670920f, 0.15182470f, -0.05196510f, -0.04393585f, 0.12711136f, 0.06211796f, -0.00192686f, -0.07242204f, 
    -0.01884944f, 0.30379051f, 0.09221675f, -0.04293733f, 0.12666339f, 0.14955902f, 0.11714183f, 0.20189013f, 
    0.15104368f, 0.02788184f, -0.04417382f, 0.15995266f, 0.10269899f, 0.00908310f, 0.17126359f, -0.05756187f, 
    0.04952786f, -0.16566518f, -0.07403716f, 0.07742313f, 0.03421574f, 0.00323618f, 0.07855018f, -0.05825096f, 
    0.12831013f, 0.17926292f, 0.13997814f, 0.17957257f, -0.04766513f, 0.12963618f, 0.05047821f, -0.16981030f, 
    -0.12692004f, 0.01400603f, 0.03361203f, 0.00835335f, 0.03052641f, -0.08779840f, 0.07674164f, 0.31783929f, 
    0.20465952f, -0.17036144f, -0.02945197f, 0.02061546f, -0.09789787f, 0.10035185f, 0.08175331f, -0.02906950f, 
    0.21254125f, -0.10187793f, -0.20709112f, 0.01387437f, 0.17626663f, -0.05828456f, -0.05720023f, 0.14539286f, 
    0.05929771f, 0.28689259f, 0.02002626f, 0.04981718f, -0.05779930f, 0.05192154f, -0.20650364f, 0.22179987f, 
    -0.02041825f, 0.02334880f, -0.15746497f, 0.09045889f, 0.15432175f, 0.08140954f, 0.10984162f, 0.01824586f, 
    -0.08080098f, 0.03329127f, 0.07555467f, -0.05491533f, -0.03536651f, 0.11738274f, 0.21979664f, -0.00168189f, 
    -0.08399831f, -0.24808365f, -0.08797207f, 0.04841805f, 0.16860408f, 0.07495109f, 0.35021341f, -0.20996550f, 
    0.00990969f, -0.22728090f, -0.02737463f, -0.12062749f, -0.02729632f, 0.13606846f, -0.11041143f, -0.13779016f, 
    -0.12982312f, -0.18114161f, -0.01487918f, 0.00268723f, -0.03908135f, -0.05714138f, 0.31636024f, 0.10512029f, 
    0.36657724f, -0.11549921f, -0.03932155f, -0.02888878f, 0.07038841f, -0.06774340f, 0.01231087f, 0.12521291f, 
    0.03642441f, 0.10805260f, 0.09037448f, 0.06900223f, 0.00702562f, -0.10611569f, -0.13331354f, 0.15276459f, 
    -0.07643032f, -0.09811879f, 0.14900681f, -0.05954687f, 0.19324045f, -0.15691006f, 0.06214101f, -0.02545517f, 
    -0.01816536f, 0.07659607f, -0.07171024f, -0.00104660f, -0.23655869f, 0.09265489f, 0.11096549f, -0.02050579f, 
    0.14895947f, 0.10057872f, -0.28233552f, 0.08695642f, 0.27874947f, 0.07982337f, -0.13141885f, 0.00000587f, 
    -0.04198474f, 0.04725894f, 0.01591018f, -0.03053541f, 0.01171374f, -0.22988777f, -0.06298807f, 0.14136805f, 
    0.09511973f, 0.03930945f, -0.25915456f, -0.27297395f, 0.16100268f, 0.12356185f, 0.14332965f, -0.02318339f, 
    -0.30493832f, -0.27964947f, 0.05301210f, 0.01656560f, -0.18776801f, -0.00156796f, 0.17681618f, 0.17679331f, 
    0.11831047f, 0.06603731f, 0.10056527f, 0.03072210f, -0.10708568f, 0.02992315f, 0.15896352f, 0.13973601f, 
    0.16911253f, 0.04767274f, 0.00974230f, 0.11621641f, 0.04406162f, 0.00992410f, 0.29907882f, 0.13897282f, 
    -0.36145765f, 0.05100691f, -0.20280538f, -0.23091045f, 0.02124707f, -0.08415816f, -0.22645760f, -0.33016586f, 
    -0.08917841f, 0.25029835f, 0.09248386f, 0.11703242f, -0.03209360f, -0.03820159f, -0.18306614f, -0.00852782f, 
    -0.23915981f, -0.11335514f, -0.02927643f, -0.16012320f, -0.03894779f, -0.07831277f, -0.03102430f, -0.00591082f, 
    0.09331764f, -0.04611062f, 0.23604511f, -0.08948464f, -0.08553012f, 0.07331140f, -0.06707826f, -0.06498388f, 
    0.13194852f, -0.14757088f, -0.12451141f, -0.25108108f, 0.03666731f, -0.07741693f, 0.16636987f, -0.03093134f, 
    0.00759088f, 0.07436567f, 0.06839666f, -0.12576064f, 0.00473035f, 0.04599167f, -0.13257900f, 0.02266097f, 
    -0.10289233f, -0.01795216f, 0.10992460f, 0.04420187f, -0.02533493f, -0.24208862f, -0.13444538f, -0.22553764f, 
    -0.02018750f, -0.04615838f, 0.14919847f, 0.18333313f, 0.06881599f, -0.17286032f, 0.06175816f, -0.07415649f, 
    -0.05373702f, 0.03263434f, -0.06920202f, 0.03113089f, -0.08455749f, -0.00808429f, -0.09368652f, -0.01999580f, 
    -0.06691944f, -0.07088383f, 0.09901392f, 0.11873724f, -0.14506079f, 0.03778555f, 0.02493029f, -0.00109508f, 
    0.20184442f, 0.00375788f, 0.06444167f, 0.10404782f, 0.09282022f, 0.06787959f, 0.16832158f, -0.04525156f, 
    -0.01430859f, 0.14014213f, 0.09256782f, 0.08617749f, -0.10398789f, -0.03560355f, -0.11873900f, -0.17137256f, 
    -0.33494681f, -0.31600955f, -0.18772770f, -0.24402833f, -0.07658926f, 0.17363295f, 0.07598310f, 0.02215981f, 
    0.20895192f, 0.02532476f, -0.02659547f, 0.16660906f, 0.08564930f, -0.04866605f, 0.09973536f, 0.00485495f, 
    -0.02213908f, -0.07552447f, -0.10649933f, -0.15230034f, 0.01393170f, -0.13456635f, -0.06388729f, 0.08276880f, 
    -0.08314248f, 0.07961275f, 0.02298530f, 0.07838257f, -0.14378674f, 0.03863841f, 0.13334613f, 0.16901338f, 
    0.07882395f, 0.08204565f, -0.08615123f, -0.25597838f, -0.39548591f, -0.31048363f, -0.13942303f, 0.02943763f, 
    -0.07658891f, 0.02666294f, 0.05725833f, 0.00843469f, -0.13391596f, 0.02860461f, -0.03480444f, 0.24831069f, 
    0.13588138f, -0.04357863f, -0.09677996f, 0.17300487f, 0.07205040f, -0.22039168f, -0.17369492f, 0.00485604f, 
    0.32330751f, 0.08987010f, -0.00726961f, 0.14394873f, 0.00455733f, -0.10317420f, -0.11273090f, -0.06569117f, 
    0.02528859f, 0.14831397f, 0.16763592f, -0.13255540f, 0.18545151f, 0.08553763f, -0.12744598f, -0.08091411f, 
    -0.09000940f, -0.19898254f, 0.12782323f, 0.19154820f, -0.15644762f, -0.07125431f, 0.03651145f, -0.05795548f, 
    0.14424813f, 0.04169127f, -0.10078128f, -0.12481283f, -0.15681824f, -0.24072623f, 0.18095990f, 0.05522136f, 
    0.02240488f, 0.05304129f, 0.18297869f, -0.25529975f, 0.17798704f, -0.05693850f, -0.01874505f, 0.02966712f, 
    0.07195643f, 0.01111652f, 0.04362998f, 0.04990410f, -0.01307998f, 0.17863664f, 0.03725881f, 0.15081210f, 
    -0.02207545f, 0.08947118f, 0.07741816f, -0.05417343f, 0.09525131f, 0.08527632f, 0.16645572f, 0.15869887f, 
    0.04834422f, 0.18342339f, 0.08444437f, -0.24390569f, -0.05949234f, 0.09734956f, -0.06839680f, 0.03905366f, 
    -0.10712197f, -0.25976670f, 0.07638539f, 0.13626805f, 0.05967325f, -0.02893351f, 0.01681877f, -0.07728405f, 
    -0.01183175f, 0.14529550f, -0.16425182f, 0.06304672f, 0.10771386f, 0.10699320f, -0.02260379f, -0.08313943f, 
    0.09385070f, -0.07012788f, -0.07295626f, 0.02754663f, 0.18741180f, 0.10743465f, 0.04291807f, -0.12508768f, 
    -0.14042768f, 0.21371546f, 0.02162926f, -0.05914018f, -0.11247359f, 0.25571930f, 0.23613423f, -0.04947058f, 
    0.05621944f, 0.05763939f, -0.06196821f, -0.00526828f, -0.15166011f, 0.15305260f, 0.02282636f, 0.03365920f, 
    0.03354514f, -0.09962295f, -0.00438411f, -0.05089186f, 0.05594639f, 0.03776361f, -0.05775533f, 0.05019621f, 
    0.13523765f, 0.02132925f, -0.01861356f, 0.14911580f, -0.05133331f, -0.09310742f, 0.07759276f, -0.13862780f, 
    0.04255154f, -0.02707471f, -0.00795878f, 0.06917345f, 0.10362216f, -0.09513368f, 0.14608026f, 0.14422323f, 
    0.04378252f, -0.02503847f, 0.04568126f, 0.13080953f, 0.06242191f, -0.19190611f, -0.08353253f, 0.11682687f, 
    -0.01610403f, -0.01751935f, 0.13844064f, -0.06027520f, -0.04833781f, 0.04946682f, 0.25337115f, -0.06335419f, 
    0.32816368f, 0.31044829f, -0.02705145f, -0.07620445f, 0.20408720f, -0.08848090f, -0.15590563f, 0.12165947f, 
    -0.52133268f, 0.02563003f, -0.23094910f, -0.21787828f, 0.33758241f, 0.03610155f, 0.13521035f, 0.07597692f, 
    0.20563070f, 0.05151290f, 0.03439416f, -0.17672531f, 0.19865991f, 0.06064177f, 0.03632986f, 0.17690326f, 
    0.17070293f, 0.00854846f, -0.07377963f, 0.04448979f, 0.10789338f, -0.30832890f, 0.08044682f, -0.05836008f, 
    -0.38758907f, 0.04988220f, -0.08816906f, -0.23047489f, 0.34328166f, 0.09898350f, 0.05181401f, 0.13044864f, 
    0.37328494f, 0.22415537f, 0.11706221f, 0.06856626f, 0.24061935f, -0.10123456f, -0.04217289f, -0.06183252f, 
    -0.07731667f, 0.34543431f, 0.05972837f, 0.14888397f, 0.11710213f, 0.17863260f, 0.06998759f, 0.04482517f, 
    -0.22700615f, 0.07145255f, -0.03070015f, -0.04299665f, 0.29260677f, 0.22674949f, 0.17348979f, 0.21060216f, 
    0.17970724f, 0.30820885f, 0.16003835f, 0.07850934f, 0.08748284f, 0.07096218f, 0.00602216f, 0.08961195f, 
    -0.05587175f, 0.05806087f, 0.52302223f, -0.23195164f, -0.02563195f, -0.13559693f, 0.04725252f, 0.12029491f, 
    0.07641643f, 0.09048285f, 0.03162786f, -0.22496744f, -0.18876256f, 0.04545866f, 0.15637769f, -0.06651802f, 
    0.07329171f, -0.18910354f, -0.19511129f, -0.24380776f, -0.38846412f, 0.14054783f, -0.15737495f, -0.18528116f, 
    -0.05059855f, 0.32841003f, 0.03800677f, 0.27779239f, 0.16875273f, 0.23204103f, 0.10390268f, 0.19572660f, 
    0.09139080f, -0.07390758f, 0.02345048f, 0.08641925f, 0.10005435f, 0.07204592f, -0.26005736f, 0.06843466f, 
    0.04334700f, -0.09751444f, 0.23262312f, 0.15873154f, 0.24196278f, 0.22205292f, -0.09865546f, -0.33589441f, 
    -0.23716746f, -0.08927789f, 0.09505858f, 0.05730222f, -0.06489985f, -0.11472519f, -0.09113773f, 0.35255656f, 
    -0.06393130f, 0.05495358f, 0.07166697f, 0.25866008f, 0.26112583f, 0.15156576f, 0.07088019f, 0.22026426f, 
    0.17947973f, 0.41008118f, 0.15564115f, -0.09750136f, -0.05023864f, -0.02336400f, 0.02006608f, -0.30254039f, 
    0.16982338f, 0.29387459f, 0.50052708f, 0.08506531f, -0.09040595f, -0.13379703f, 0.18040727f, 0.12542105f, 
    -0.29327306f, 0.11796696f, -0.24545367f, -0.26369995f, -0.08179957f, 0.08532590f, 0.05643537f, 0.08594763f, 
    -0.03850755f, 0.06070026f, 0.34846801f, 0.24105121f, 0.16212074f, -0.02307230f, 0.02867020f, -0.17861862f, 
    -0.18609084f, 0.22183836f, -0.15483235f, 0.25877810f, -0.02501711f, -0.45870760f, -0.01477795f, -0.00720722f, 
    -0.22639254f, 0.23412918f, 0.09296810f, -0.10457134f, 0.24819595f, -0.08058418f, -0.28591347f, -0.01184915f, 
    0.02214463f, 0.15628611f, 0.09396143f, 0.12768242f, 0.35614625f, -0.14984155f, -0.04689910f, 0.27737293f, 
    -0.14458781f, 0.17216580f, 0.16968545f, 0.15462421f, 0.04886412f, 0.11619667f, 0.32734329f, -0.02608330f, 
    0.25383350f, 0.03936717f, 0.02622131f, -0.08204632f, -0.15542053f, -0.16215935f, 0.01643089f, 0.15697171f, 
    0.02947423f, 0.13109410f, -0.14853701f, 0.04277423f, -0.18136130f, -0.03784445f, -0.13208494f, -0.18271248f, 
    0.08714123f, 0.20319539f, -0.21186833f, -0.16260572f, 0.19190286f, 0.12642260f, 0.15753497f, -0.11156087f, 
    0.19093879f, -0.38490525f, 0.26865974f, 0.03373702f, 0.05211300f, -0.10203794f, 0.02840488f, 0.13303956f, 
    -0.00104859f, 0.52494472f, 0.05333865f, 0.17528856f, -0.11698002f, 0.32497197f, -0.08607243f, 0.10021928f, 
    0.10171831f, 0.04721022f, -0.00843577f, 0.16737247f, -0.17053834f, 0.08901349f, -0.08031113f, 0.17233874f, 
    0.10268608f, 0.22494167f, 0.05773513f, -0.01218133f, 0.05655371f, -0.40672761f, -0.30046433f, -0.18727113f, 
    -0.07606226f, 0.05082796f, 0.00031753f, 0.08928838f, 0.17445388f, 0.27508464f, -0.10421590f, -0.60631222f, 
    -0.00402231f, 0.10847548f, -0.20065899f, 0.12927780f, -0.05086379f, -0.13211246f, 0.05186477f, -0.15918584f, 
    -0.22284918f, 0.01391323f, -0.03353998f, 0.10145865f, 0.07310915f, -0.17724636f, -0.14094698f, -0.35471973f, 
    -0.19490939f, 0.23249123f, -0.31567129f, 0.08370529f, 0.11082989f, 0.01473071f, 0.06275334f, 0.33144489f, 
    0.06934550f, -0.25632325f, 0.32958758f, 0.09753843f, 0.27806506f, 0.06467588f, 0.21828111f, 0.02502880f, 
    0.13867886f, 0.00267232f, 0.10473816f, -0.18973677f, 0.00948732f, 0.17423688f, -0.07030064f, -0.09039984f, 
    -0.17118384f, -0.08958539f, -0.05672412f, -0.00482502f, -0.01835796f, 0.00858496f, 0.10810129f, -0.02986012f, 
    0.23167326f, 0.07131716f, 0.05034567f, 0.16741633f, 0.02215595f, 0.14045791f, 0.15450975f, 0.10348734f, 
    0.18458912f, 0.02093419f, 0.08124267f, 0.12976332f, -0.07546822f, 0.01426869f, 0.06039063f, 0.00834201f, 
    -0.05809384f, 0.11957135f, -0.18009737f, 0.03341950f, -0.16453467f, 0.22871092f, 0.00169738f, -0.09848420f, 
    -0.02242689f, 0.17668420f, 0.02267553f, 0.00205967f, -0.19124503f, -0.02625093f, -0.00075731f, -0.02209082f, 
    0.10354741f, 0.15044959f, 0.06905204f, 0.06431529f, -0.13190052f, -0.05387714f, 0.00664119f, -0.01925737f, 
    0.14756106f, -0.03906723f, 0.05160575f, 0.07115985f, 0.06542392f, -0.00714354f, -0.12811711f, -0.03054043f, 
    0.08459149f, 0.03408420f, -0.06524742f, 0.02557766f, -0.01357063f, -0.09239529f, 0.05604805f, 0.13927279f, 
    0.05604745f, 0.07841349f, 0.01964937f, 0.07832184f, -0.02925749f, 0.13489497f, -0.01952806f, 0.14566061f, 
    0.20958367f, 0.05467189f, 0.06785718f, 0.07471932f, -0.14693463f, -0.01854182f, -0.04528117f, -0.02245241f, 
    -0.03694795f, -0.10968570f, -0.05704674f, -0.00112406f, -0.05435037f, -0.20712613f, 0.07548429f, 0.02523818f, 
    -0.00154411f, 0.21529710f, 0.15807663f, 0.19610715f, -0.20364057f, -0.03259273f, 0.09809048f, 0.13073646f, 
    0.00490029f, 0.23796409f, -0.16100095f, -0.07828645f, -0.00980710f, 0.09469935f, 0.08618501f, 0.07043114f, 
    -0.10780025f, 0.07229602f, -0.07034329f, 0.18061258f, 0.03521107f, 0.04291068f, -0.01329720f, -0.09144368f, 
    0.00072736f, 0.02082694f, -0.06025605f, 0.02787749f, -0.07646995f, -0.16174155f, -0.16243953f, 0.07988825f, 
    -0.12565006f, -0.05814619f, -0.00490156f, 0.08989446f, -0.11948676f, -0.08488104f, 0.03608706f, 0.03057238f, 
    0.00841484f, -0.14613995f, -0.01060144f, 0.01877959f, 0.02346069f, 0.00915218f, 0.00367049f, -0.10171235f, 
    -0.09271187f, 0.06795380f, 0.25285608f, 0.28076684f, -0.02425896f, -0.03389310f, -0.11775327f, 0.12613846f, 
    0.05336626f, 0.05730151f, -0.02101299f, -0.24139386f, -0.01637722f, 0.05949916f, -0.07899304f, 0.05185072f, 
    -0.02269148f, 0.04488995f, -0.13883610f, 0.25908324f, 0.10908157f, 0.16784692f, 0.18512970f, 0.10451737f, 
    -0.07763811f, 0.05722799f, -0.20550790f, -0.09726297f, -0.06464153f, -0.10122354f, -0.05232226f, 0.15140803f, 
    -0.01840366f, 0.07399664f, -0.05864470f, 0.11669589f, -0.12671313f, -0.13506000f, -0.05761319f, 0.19443296f, 
    -0.04828169f, -0.06226297f, -0.24677637f, -0.20808761f, -0.20386711f, -0.25986761f, -0.03149479f, -0.17755535f, 
    -0.24373654f, 0.05274687f, 0.18725754f, 0.04151945f, 0.23971093f, 0.08812403f, 0.20827252f, -0.14254095f, 
    -0.11657759f, -0.00070095f, 0.02258004f, -0.01673936f, 0.17337048f, -0.02759850f, 0.09791823f, 0.00935926f, 
    -0.07013333f, -0.02434537f, 0.04090752f, 0.04152437f, 0.09092229f, 0.00536448f, -0.08871759f, -0.17027135f, 
    -0.05143575f, 0.01651108f, 0.03295949f, -0.00319544f, -0.01317841f, -0.04125781f, 0.04569973f, -0.07901732f, 
    0.14718325f, -0.09625579f, 0.27257949f, -0.03880019f, -0.21804142f, -0.09522555f, -0.11004150f, 0.00052358f, 
    -0.18149661f, 0.01913621f, -0.05858587f, 0.16159216f, -0.11998326f, 0.05981547f, 0.07896965f, 0.26606041f, 
    -0.09805998f, 0.04027032f, 0.18881808f, -0.09322369f, -0.08994208f, 0.00352258f, 0.14622335f, 0.19062342f, 
    0.02029494f, 0.03753480f, 0.10507264f, 0.15439384f, 0.16046607f, 0.20690557f, 0.07340014f, 0.27615771f, 
    0.10145530f, 0.00185592f, -0.13823937f, -0.01592956f, 0.01788955f, 0.13477401f, 0.11090845f, 0.02731795f, 
    0.00448477f, -0.03266868f, 0.02813512f, 0.04455240f, 0.02273327f, -0.02523078f, 0.14676242f, -0.04644431f, 
    0.15559766f, -0.12593971f, -0.08153521f, 0.01661526f, -0.14433745f, -0.20353521f, -0.32624233f, -0.35844818f, 
    -0.08275316f, 0.22235112f, 0.06339283f, -0.09403348f, -0.11272715f, -0.26342773f, 0.09008437f, -0.04074932f, 
    0.22076064f, 0.42174596f, -0.04722437f, -0.12410054f, 0.04759621f, -0.16532491f, -0.18351097f, -0.00923852f, 
    -0.02042748f, 0.02786753f, 0.15217689f, 0.21579704f, 0.26900402f, -0.11318014f, -0.00358914f, 0.04701317f, 
    0.04488407f, -0.08649378f, 0.05880012f, -0.20472208f, -0.19238792f, 0.28181025f, -0.28617859f, 0.18542786f, 
    0.02632099f, -0.04362975f, 0.19258915f, -0.02229944f, -0.37098822f, -0.09330603f, 0.18612562f, -0.15218577f, 
    -0.03039603f, 0.02841855f, 0.18827321f, 0.09281060f, -0.01426815f, -0.10042427f, -0.35662651f, -0.10833062f, 
    0.07810642f, 0.19547741f, -0.05819656f, -0.09406339f, 0.00281530f, -0.10854015f, 0.28640953f, -0.12378119f, 
    -0.58840561f, -0.21606781f, -0.12963016f, 0.06186625f, 0.07813010f, 0.04689445f, 0.01669953f, -0.12827758f, 
    0.08694837f, -0.03026968f, -0.02303457f, 0.13951002f, -0.08335321f, 0.01354290f, 0.10049820f, 0.03326025f, 
    0.05856016f, -0.10082868f, -0.25532848f, -0.11566195f, 0.14562297f, 0.16455662f, -0.04095136f, 0.09614372f, 
    -0.00916961f, 0.01594770f, -0.24370122f, 0.08141125f, 0.09015197f, 0.01533458f, 0.01786409f, 0.11372914f, 
    0.06135130f, -0.04738508f, 0.07942629f, -0.51760429f, -0.14601606f, -0.21660893f, -0.18643446f, -0.05158731f, 
    0.19519964f, -0.04473325f, -0.17978662f, 0.06518332f, 0.06491254f, 0.02044440f, 0.03114661f, -0.04296177f, 
    -0.16050857f, 0.07858995f, -0.06363063f, 0.17976010f, 0.00198307f, -0.03439866f, 0.12461112f, -0.14724125f, 
    0.02760946f, -0.13493735f, 0.03716794f, 0.03641670f, 0.14211449f, 0.24527974f, 0.30765280f, 0.08281796f, 
    0.02164444f, 0.07555651f, 0.00781157f, 0.16109571f, 0.09302732f, 0.06413154f, 0.21381173f, -0.39047125f, 
    0.15920995f, -0.08160055f, -0.08019657f, 0.16154552f, 0.21892859f, 0.10626177f, -0.05668471f, -0.09371389f, 
    0.27994484f, 0.42281151f, -0.11102823f, 0.11521737f, 0.08393838f, -0.06662992f, -0.04417755f, 0.09937620f, 
    0.15223724f, 0.08693301f, 0.03495566f, -0.10859933f, 0.06380293f, 0.04764852f, 0.05788508f, 0.05032284f, 
    0.17888504f, -0.09264655f, -0.09769950f, -0.25520465f, 0.12876445f, -0.29017296f, -0.01647903f, 0.10456555f, 
    0.27510166f, 0.06609801f, -0.70045531f, -0.21898420f, -0.28760985f, 0.02907154f, -0.02370020f, -0.11478256f, 
    0.16110513f, 0.04278433f, -0.15968239f, -0.26982820f, 0.01213447f, -0.07819597f, -0.03483141f, 0.00277132f, 
    0.16367869f, 0.09077430f, -0.00348689f, 0.02180468f, -0.02209234f, -0.14717348f, -0.15905054f, -0.21386342f, 
    -0.08780629f, -0.15221332f, 0.02001324f, 0.09204782f, 0.10186002f, 0.18421115f, -0.01267182f, 0.21425550f, 
    -0.01605931f, -0.01368712f, 0.15670861f, 0.12505315f, -0.01283782f, -0.05419859f, 0.06850235f, 0.34819788f, 
    0.16506046f, -0.21359985f, 0.01275445f, 0.02451518f, -0.05883826f, 0.04944785f, 0.16253921f, -0.30033645f, 
    -0.57248199f, -0.11718748f, 0.13587189f, 0.17534086f, -0.06524670f, -0.17409688f, 0.12762640f, 0.01523936f, 
    -0.21811280f, -0.19540191f, -0.17194217f, 0.05325382f, -0.08182277f, -0.17959088f, -0.07931034f, 0.00950703f, 
    0.09490190f, 0.38279939f, -0.26731709f, -0.17212394f, -0.04903392f, 0.08448689f, 0.07160144f, 0.06028783f, 
    0.08989295f, -0.21509853f, -0.58820295f, -0.33381468f, 0.11137994f, -0.05663559f, 0.04961392f, -0.12120973f, 
    -0.03806434f, 0.06884386f, 0.05663645f, -0.40643698f, -0.74095714f, -0.07822267f, -0.12375287f, 0.07125190f, 
    -0.17902361f, 0.04768069f, -0.10013410f, -0.08967281f, -0.45047894f, -0.46572196f, -0.16951632f, -0.29519328f, 
    0.14780535f, 0.12883456f, -0.08867188f, -0.05175878f, 0.09164845f, -0.01903513f, -0.12127405f, -0.40355557f, 
    -0.00973033f, -0.03499607f, -0.10518642f, 0.00692766f, 0.15542093f, 0.02144511f, -0.06362541f, -0.04311713f, 
    0.41797501f, 0.07268483f, 0.02767986f, -0.05922854f, 0.11815090f, 0.03017002f, 0.02353869f, 0.63466424f, 
    -0.54608738f, -0.44089058f, -0.03754722f, -0.03531284f, 0.26395288f, 0.15583567f, -0.00486361f, 0.01047880f, 
    0.01635748f, -0.04526289f, -0.00647346f, -0.05536704f, 0.17104952f, -0.19974217f, 0.01593384f, 0.02400614f, 
    0.15370762f, -0.14109543f, -0.07868398f, 0.26057923f, -0.14834982f, -0.04566054f, -0.08552939f, 0.03924509f, 
    -0.04733343f, -0.12658440f, 0.11083843f, 0.21241726f, 0.20371702f, 0.08070892f, -0.02100599f, 0.15125695f, 
    -0.00762572f, -0.00688118f, 0.05924917f, -0.17238797f, 0.00565493f, 0.01728944f, -0.13454826f, -0.10727032f, 
    0.21578258f, 0.04283367f, 0.02980074f, 0.17613551f, 0.03252020f, 0.18883741f, -0.03131828f, -0.04111221f, 
    0.13868742f, -0.12403978f, 0.14919877f, 0.06915690f, 0.01506583f, -0.13847344f, -0.18645754f, 0.29019499f, 
    -0.07339488f, -0.00370342f, -0.07559863f, 0.09287484f, 0.00681377f, 0.04615298f, -0.21993747f, -0.11270735f, 
    0.09116650f, -0.13578175f, -0.03759011f, -0.05751552f, 0.03836020f, 0.13710774f, 0.09675751f, 0.08929892f, 
    0.12680441f, 0.23401223f, -0.03379558f, -0.07110030f, 0.08388632f, -0.01576630f, 0.02943815f, 0.13477172f, 
    -0.04921843f, -0.39517516f, -0.16364242f, 0.03015528f, 0.08782789f, -0.04444806f, 0.08331587f, 0.01957185f, 
    0.00309367f, -0.40783697f, -0.04492870f, 0.08051309f, 0.08303709f, 0.05260865f, 0.00838821f, 0.06748296f, 
    -0.00574105f, 0.12283370f, -0.13002011f, 0.12515406f, 0.24607258f, -0.15554254f, -0.06610975f, -0.27105683f, 
    -0.05208082f, -0.13324462f, -0.38374868f, -0.06486509f, -0.02783183f, -0.01525818f, 0.02066548f, 0.20851593f, 
    0.01229938f, 0.11211780f, 0.03677839f, 0.20379740f, -0.20542981f, -0.03682845f, 0.08134329f, -0.11078554f, 
    -0.07804035f, -0.12109794f, -0.04526067f, 0.03884403f, -0.05100022f, -0.14143740f, -0.27241045f, 0.17701052f, 
    0.05658765f, 0.01880958f, -0.11111408f, 0.00219009f, 0.05528172f, 0.20918928f, 0.13480559f, -0.12484880f, 
    0.10923546f, 0.07735307f, 0.06306479f, -0.06476605f, -0.16663480f, 0.08173435f, -0.09042689f, 0.00983416f, 
    0.03727369f, 0.02779767f, 0.03667977f, 0.06007542f, -0.06859599f, 0.01713503f, -0.01972847f, -0.22007695f, 
    0.07026266f, 0.05158804f, -0.09479740f, 0.03492177f, 0.07898799f, -0.03836856f, -0.05671882f, -0.11335471f, 
    -0.21074949f, 0.48248810f, -0.12525178f, 0.22638674f, 0.04608999f, -0.18966566f, 0.10220535f, -0.02944903f, 
    0.15351626f, -0.05607403f, -0.20420463f, 0.00118723f, -0.11384380f, -0.14945248f, -0.00069793f, -0.07904053f, 
    0.08372159f, 0.00269127f, -0.10416310f, -0.22404742f, -0.00064525f, -0.04531552f, -0.00158398f, -0.04983894f, 
    0.02418818f, 0.05549165f, 0.00987610f, 0.25473958f, -0.30786338f, -0.19552213f, 0.15397219f, 0.09282227f, 
    -0.23022395f, -0.28723907f, -0.00313917f, 0.01584950f, 0.03098242f, 0.26558113f, 0.09935231f, -0.06219264f, 
    0.04602574f, 0.10086539f, -0.02259351f, -0.01153933f, -0.18437436f, -0.25697663f, 0.06504837f, 0.03557950f, 
    -0.02929476f, 0.00005765f, 0.03791865f, 0.00965001f, -0.07715708f, 0.11481243f, 0.08515844f, -0.76952004f, 
    -0.34503835f, 0.10665990f, -0.31417447f, -0.12009527f, 0.07040653f, -0.02638220f, 0.02744430f, 0.20281602f, 
    -0.07958318f, 0.02588253f, 0.24334107f, 0.03646853f, 0.06128689f, 0.09094266f, 0.11438336f, 0.12352276f, 
    0.10404064f, 0.13487960f, -0.14771201f, 0.13378568f, -0.05102644f, 0.17329723f, 0.15841450f, 0.08370764f, 
    0.20773771f, -0.08751084f, -0.24311207f, -0.02291523f, 0.13942793f, 0.09015601f, -0.11908647f, -0.00081807f, 
    -0.02370253f, -0.02600446f, -0.05669641f, 0.26409680f, 0.11856156f, 0.10862783f, -0.03227731f, -0.19883257f, 
    0.00070245f, 0.00815630f, 0.10043168f, 0.02169329f, -0.33955565f, -0.26095313f, -0.12536721f, 0.02726356f, 
    -0.00650068f, -0.13628156f, 0.02261770f, 0.07911257f, 0.14858522f, -0.22823413f, -0.16742109f, -0.15942042f, 
    -0.14234872f, -0.06413932f, 0.07264846f, 0.00246125f, -0.07224394f, 0.14779058f, -0.27065873f, -0.01967545f, 
    0.30338198f, -0.09158965f, -0.05993095f, 0.12985836f, 0.01101416f, 0.03577332f, 0.35449710f, 0.17667505f, 
    -0.00397306f, -0.05265926f, -0.03365092f, -0.07152259f, -0.19885935f, -0.15150823f, -0.20078348f, -0.02748322f, 
    -0.41495979f, 0.15282561f, -0.05468459f, 0.00851275f, -0.03827980f, -0.06550568f, -0.04397985f, -0.26538005f, 
    -0.26537341f, 0.09826759f, -0.03424901f, -0.06011449f, 0.07134642f, -0.15008290f, -0.03020800f, -0.02368118f, 
    0.13218959f, 0.10579100f, -0.16336681f, -0.22903982f, -0.10866360f, -0.17793716f, -0.05269690f, -0.24651872f, 
    0.13170011f, -0.12535451f, 0.02052061f, 0.00134967f, 0.03792824f, -0.36554515f, 0.06690721f, -0.21782081f, 
    0.10794165f, 0.09974591f, 0.04408887f, 0.03504017f, 0.06923944f, -0.16422175f, -0.17239460f, -0.06303737f, 
    -0.06884548f, -0.03303753f, 0.15541030f, 0.12375673f, -0.06972383f, -0.10588636f, -0.26652718f, -0.21471536f, 
    0.05040466f, -0.00984834f, -0.00668874f, 0.04458274f, 0.12234538f, 0.14030832f, 0.09438253f, -0.08568834f, 
    0.09417213f, 0.04887155f, -0.04432324f, 0.07918826f, -0.03276963f, 0.01377562f, 0.07149897f, -0.22744583f, 
    -0.35229719f, -0.00689097f, -0.13193437f, -0.05610039f, -0.11192635f, 0.16808701f, 0.01048113f, 0.07956242f, 
    -0.01771229f, 0.18933837f, 0.46641204f, 0.18692762f, -0.00771359f, -0.02934639f, 0.09016261f, -0.12526453f, 
    -0.07836431f, 0.06042330f, 0.07222507f, 0.17556866f, 0.03129308f, 0.00849394f, 0.07444331f, 0.16149941f, 
    -0.31900671f, -0.23201936f, 0.05185548f, -0.06681588f, -0.21632338f, 0.27112988f, 0.00356190f, 0.07495533f, 
    0.12598322f, 0.21575253f, 0.17314385f, 0.11077081f, -0.02564667f, -0.08644459f, -0.15899599f, -0.00560620f, 
    -0.00626197f, 0.11559435f, -0.20003054f, -0.08256277f, 0.12187989f, -0.01014158f, -0.21010837f, -0.07020977f, 
    0.06245955f, 0.16735156f, 0.09714894f, 0.10364534f, -0.03593513f, 0.04022594f, 0.11009321f, 0.18672891f, 
    0.05920240f, 0.00280945f, 0.10971653f, 0.19816796f, -0.31437933f, -0.43789715f, -0.05652874f, 0.05538438f, 
    -0.10324609f, -0.07797416f, -0.03393194f, -0.06965229f, -0.15759392f, -0.01125475f, 0.16973594f, 0.00978643f, 
    -0.00227497f, -0.21131596f, 0.09038169f, 0.10590648f, -0.02091293f, -0.02218980f, -0.11799644f, 0.03582021f, 
    -0.00348255f, -0.08047806f, -0.07780104f, -0.08983857f, 0.10902090f, -0.06236716f, 0.01695766f, -0.01104801f, 
    0.00407184f, -0.04594701f, 0.02156881f, 0.02419178f, 0.11472513f, 0.02576372f, 0.08152898f, 0.12588818f, 
    0.02593422f, -0.24271299f, -0.09775919f, 0.12409406f, -0.18110758f, -0.00160542f, 0.16369535f, 0.03076591f, 
    -0.02584415f, 0.12288728f, 0.00559079f, -0.07294854f, -0.06704645f, -0.28066733f, 0.03333910f, -0.00391548f, 
    0.09343251f, 0.13740802f, 0.02823162f, 0.12024124f, 0.23254824f, 0.26652813f, 0.04076259f, -0.07606969f, 
    0.03400037f, 0.09429450f, -0.04202730f, 0.06841537f, 0.09906276f, 0.05563120f, 0.16186836f, 0.12628223f, 
    0.02834309f, 0.18929908f, 0.04822123f, 0.00438640f, 0.08377584f, 0.13431402f, -0.02513926f, -0.16152960f, 
    -0.13176551f, 0.03054442f, -0.23107077f, -0.19119629f, 0.15002862f, -0.08009621f, -0.12024549f, 0.17970841f, 
    -0.04311724f, -0.29656756f, 0.16094893f, 0.14932103f, 0.11269572f, -0.06784685f, 0.03399419f, -0.12382352f, 
    -0.28856292f, -0.05571977f, -0.09964922f, -0.13553482f, -0.00090536f, 0.01511661f, 0.04372234f, 0.13140278f, 
    -0.01020570f, 0.07425760f, -0.23409395f, 0.12591086f, -0.07385793f, 0.05585013f, 0.13717909f, 0.08914479f, 
    -0.14919287f, 0.02342780f, -0.11947838f, -0.21058466f, -0.26549673f, 0.10093678f, -0.04893800f, 0.11985715f, 
    0.03704141f, 0.11017879f, 0.16796519f, -0.29649034f, -0.44574562f, 0.17630212f, -0.11149049f, -0.05099652f, 
    -0.02395906f, -0.04045130f, 0.06951544f, 0.14990757f, 0.09811911f, 0.24561208f, 0.22754039f, 0.11269765f, 
    0.14959693f, -0.01091070f, 0.03293280f, 0.13438998f, -0.07803638f, -0.11040895f, 0.15367182f, -0.32494137f, 
    0.08268639f, 0.05428101f, 0.24451210f, 0.08973921f, -0.01244178f, 0.07130064f, 0.14898607f, 0.03952160f, 
    -0.14966272f, 0.08940464f, 0.13638930f, 0.14803067f, 0.13577954f, 0.04141103f, -0.16316248f, 0.09136844f, 
    0.33617243f, 0.08886655f, -0.01487255f, -0.18638539f, -0.19730763f, -0.06889708f, 0.22494575f, 0.21939003f, 
    0.00441738f, 0.03020834f, -0.01799728f, -0.06422257f, -0.02682848f, -0.05779072f, -0.00536344f, -0.05824699f, 
    0.02284073f, 0.03769677f, -0.01701366f, 0.03376323f, -0.05159306f, -0.05537504f, 0.03792198f, -0.05069862f, 
    -0.05010488f, 0.03680529f, -0.02817850f, -0.04339694f, -0.00025493f, -0.03462448f, 0.03453726f, -0.00960343f, 
    -0.05631205f, -0.02412922f, 0.03203096f, -0.05396523f, -0.03194807f, -0.06105096f, 0.01609845f, -0.06242540f, 
    -0.01176113f, 0.04078454f, -0.04363520f, 0.02050237f, -0.01161523f, 0.02642589f, -0.00338314f, 0.01706468f, 
    0.01029756f, -0.03321003f, -0.05206341f, -0.01919285f, 0.02562195f, -0.04742897f, 0.04434368f, -0.05116688f, 
    -0.03597484f, -0.00010440f, 0.02476546f, 0.01679578f, -0.02552909f, -0.02825495f, 0.03417072f, 0.01187114f, 
    0.04958182f, 0.02090114f, 0.02917357f, 0.01332528f, -0.04411971f, -0.03965313f, -0.05128199f, -0.01664766f, 
    0.02214651f, -0.04273833f, 0.04946373f, 0.03584280f, -0.00207443f, 0.00115703f, -0.01682937f, -0.02538475f, 
    -0.03784958f, 0.00891410f, -0.03655720f, 0.02356410f, -0.03818871f, -0.03121892f, -0.02082166f, -0.02869517f, 
    -0.04024124f, -0.02645903f, 0.00926512f, -0.01484424f, 0.00347988f, 0.03031293f, -0.03948099f, -0.02988597f, 
    -0.04311529f, 0.00157421f, -0.00803124f, -0.05387346f, -0.03566701f, -0.05586157f, 0.03963942f, 0.02722446f, 
    0.02509280f, -0.06052901f, -0.06394623f, -0.00266547f, -0.04391430f, 0.01715490f, 0.04239861f, -0.01899849f, 
    -0.04614362f, -0.02500275f, 0.00760553f, 0.01715272f, -0.01144450f, 0.03805813f, 0.02233705f, 0.03702435f, 
    -0.04439874f, -0.02312563f, -0.06338444f, 0.01769434f, 0.04439504f, -0.02030656f, -0.06741390f, 0.02167878f, 
    -0.03615402f, -0.06119794f, 0.02937648f, 0.00682668f, 0.03554104f, -0.04739044f, -0.02797403f, 0.04605595f, 
    0.05194012f, -0.00909698f, -0.03936327f, -0.05229938f, -0.01034134f, 0.00063047f, 0.00424650f, -0.01305751f, 
    -0.04397067f, 0.00799537f, 0.05253641f, 0.04929274f, -0.06320610f, 0.02297581f, 0.04290967f, -0.03348098f, 
    0.02056548f, 0.02686262f, 0.00933904f, 0.03948973f, -0.00149379f, 0.02767343f, -0.02029242f, 0.01366568f, 
    -0.00726691f, 0.01695321f, -0.06183502f, -0.04087175f, 0.01149352f, -0.01801168f, 0.00169085f, -0.04701360f, 
    0.04147531f, 0.00754555f, -0.03508287f, -0.01306506f, 0.01717246f, -0.04571977f, -0.01501761f, -0.02437395f, 
    0.04441868f, 0.04738148f, -0.04447311f, 0.01529955f, -0.00812767f, -0.04226723f, -0.00230388f, -0.05887123f, 
    0.04697748f, -0.02908474f, -0.05078316f, -0.06169792f, 0.03656341f, 0.00384273f, 0.04126943f, 0.03807602f, 
    0.00731363f, -0.03061524f, -0.05510142f, 0.00726732f, -0.04256905f, 0.04683983f, 0.04517550f, 0.02067370f, 
    -0.00190123f, 0.00363068f, -0.03145662f, 0.00738496f, 0.02761372f, -0.04364361f, -0.02010900f, -0.03745159f, 
    -0.00835887f, 0.00544543f, -0.03758900f, -0.04657961f, 0.03883008f, 0.02852883f, 0.01975806f, 0.03865379f, 
    -0.01991084f, 0.00495412f, -0.06067972f, -0.02272277f, 0.03637738f, -0.04788025f, 0.01871660f, 0.01804985f, 
    -0.03283408f, 0.04067616f, -0.04640379f, -0.02862849f, -0.06702415f, -0.01453479f, -0.05836719f, -0.03353947f, 
    -0.01196281f, -0.05569283f, -0.05980423f, -0.06677711f, -0.00465123f, 0.03956469f, 0.04204783f, -0.05401242f, 
    -0.05898650f, -0.03134113f, 0.01633593f, 0.01826641f, -0.02229583f, 0.00301978f, -0.04501619f, 0.04206840f, 
    0.03845555f, -0.01735348f, -0.04968517f, 0.03287375f, 0.02589404f, -0.06198214f, -0.04921458f, 0.04393159f, 
    0.04899940f, -0.03350485f, 0.02369291f, 0.01275050f, 0.03128336f, 0.00910330f, -0.03508969f, -0.06383080f, 
    -0.03682344f, -0.01090076f, -0.02798450f, -0.05069404f, -0.05138750f, 0.03624598f, -0.03792033f, 0.04078065f, 
    -0.04403352f, -0.03850391f, -0.04447859f, 0.03010421f, -0.02944447f, 0.01391039f, 0.03849865f, -0.01789575f, 
    -0.05313607f, 0.00717747f, -0.03460350f, 0.04771174f, -0.00097999f, 0.01231515f, -0.05053240f, 0.02989002f, 
    0.03386604f, -0.00831276f, -0.05315407f, -0.06054430f, 0.04553435f, -0.04946171f, -0.05097846f, 0.01978729f, 
    -0.07880555f, -0.01775246f, -0.06425589f, 0.02267196f, 0.00823200f, -0.07638106f, 0.01713300f, -0.07212572f, 
    -0.03595253f, -0.02808004f, 0.00104309f, -0.06327718f, 0.00217841f, -0.00739959f, 0.00584858f, 0.00682934f, 
    -0.05859544f, -0.02894539f, -0.07288016f, -0.04078443f, -0.00810494f, -0.06293525f, -0.06866712f, -0.03363999f, 
    -0.06898976f, 0.01031592f, -0.01209681f, -0.07808464f, -0.05248217f, 0.00858614f, -0.05563493f, 0.02151507f, 
    -0.06208535f, -0.06092404f, -0.02390777f, -0.02848766f, -0.04169763f, -0.06305734f, -0.06759637f, -0.05051896f, 
    -0.04470398f, 0.00439467f, -0.08676893f, -0.06483717f, -0.08393132f, 0.01458036f, 0.00502686f, -0.08607945f, 
    -0.09169110f, -0.03150637f, -0.00159268f, -0.02049598f, -0.02592403f, -0.07659623f, -0.07541036f, -0.07338990f, 
    -0.06696450f, -0.04668124f, -0.08253097f, -0.02486601f, -0.06306284f, -0.07661817f, -0.00321912f, -0.03489747f, 
    0.01413980f, -0.00165247f, -0.06537791f, -0.07002247f, 0.02524532f, -0.10245302f, -0.05159374f, -0.08323596f, 
    -0.04841474f, -0.03273806f, -0.00298855f, -0.02720295f, -0.03750323f, -0.04446989f, -0.08143309f, 0.01232338f, 
    -0.03479177f, -0.08834656f, -0.02607951f, -0.04766122f, 0.03525432f, -0.03918251f, -0.04958756f, -0.06729727f, 
    -0.05755823f, -0.00990487f, -0.01615316f, -0.03895510f, -0.02584451f, -0.09279499f, -0.07072420f, -0.03848046f, 
    0.01505263f, -0.06606724f, 0.01444170f, -0.04088784f, -0.00947209f, -0.07983702f, 0.02557513f, 0.03283387f, 
    -0.08452683f, -0.07780425f, -0.08834494f, 0.02856153f, -0.01221751f, 0.02652632f, 0.00932446f, 0.00874532f, 
    -0.08960062f, -0.05207820f, -0.06577139f, 0.03538335f, 0.03068681f, -0.03781397f, -0.10737690f, -0.02941787f, 
    0.01842983f, -0.04843488f, 0.03781675f, 0.02449131f, -0.04934882f, -0.05686078f, 0.01486292f, 0.01508216f, 
    0.01846131f, -0.02819287f, 0.02658148f, -0.04463977f, -0.01326201f, -0.00833381f, -0.03511639f, -0.02902891f, 
    -0.07422831f, 0.03417600f, -0.07629393f, -0.00226384f, -0.01333061f, -0.01780081f, -0.09074692f, -0.08389398f, 
    -0.00692312f, -0.07205407f, -0.07136216f, 0.00979334f, -0.07194266f, -0.01272206f, -0.08503734f, -0.02742588f, 
    -0.04575701f, 0.02366925f, -0.01624061f, -0.08299316f, 0.03059880f, -0.08157522f, -0.05650972f, -0.07743146f, 
    0.01065475f, -0.08921251f, -0.01073246f, -0.03169276f, -0.06398953f, -0.05782580f, -0.05007611f, 0.00063827f, 
    -0.01314033f, -0.00341634f, 0.00744542f, -0.07292500f, 0.00634314f, -0.06198544f, -0.01104988f, 0.00049206f, 
    -0.05645650f, -0.05637273f, -0.03713179f, -0.07872362f, -0.01303939f, 0.00738376f, -0.02892810f, -0.06349072f, 
    -0.04306171f, -0.03134627f, -0.00060752f, -0.04579790f, -0.07199099f, -0.04544424f, 0.02587560f, -0.07742329f, 
    0.01488643f, -0.03210704f, -0.02476795f, -0.01407691f, 0.01246535f, -0.04325193f, -0.09753653f, -0.08911448f, 
    -0.02442476f, 0.03051938f, 0.00713710f, -0.03704114f, -0.03270479f, -0.04120497f, -0.00473103f, -0.02020082f, 
    -0.06038609f, -0.08905309f, 0.02204910f, -0.01875173f, 0.00608567f, 0.04249402f, 0.03495594f, -0.05798911f, 
    -0.00360281f, -0.01353853f, -0.05463903f, -0.07939555f, -0.06759620f, -0.02149302f, -0.09417480f, -0.01039626f, 
    -0.04573020f, -0.07547179f, -0.06263828f, -0.07231443f, -0.00637395f, -0.05625649f, -0.03355256f, 0.00520384f, 
    0.00156260f, -0.06168843f, -0.05721271f, 0.00675790f, -0.06448781f, -0.09455346f, -0.01834233f, -0.08079407f, 
    -0.03519633f, 0.01173342f, 0.00836552f, -0.04041562f, -0.01055149f, -0.06774738f, 0.01931947f, -0.07803002f, 
    -0.01305010f, -0.05912801f, 0.00006515f, -0.05284344f, -0.07457281f, -0.04749148f, 0.01158543f, -0.02899617f, 
    -0.06063216f, 0.02805992f, 0.03629166f, -0.00158459f, 0.03585726f, -0.04600972f, -0.10014199f, -0.06851964f, 
    0.00517400f, -0.06071693f, -0.07948518f, 0.01375328f, -0.03938954f, 0.03255898f, 0.02105026f, -0.09306815f, 
    -0.06262132f, -0.01937261f, -0.04400072f, -0.01193493f, -0.06981627f, 0.00368605f, -0.07334115f, -0.02943047f, 
    -0.01646752f, -0.02438980f, -0.04433689f, -0.03696769f, 0.01187851f, -0.02972768f, 0.03143098f, 0.01981981f, 
    -0.26034436f, 0.50158292f, -0.01528671f, 0.04277696f, -0.05969809f, -0.19870831f, -0.12580647f, 0.06926160f, 
    -0.05509704f, 0.14217943f, 0.10619600f, 0.00554919f, 0.02259375f, -0.25008830f, -0.01797857f, 0.05769294f, 
    -0.10927296f, 0.13716128f, 0.32725960f, -0.00453184f, -0.02011150f, -0.12075137f, -0.02033177f, -0.11892280f, 
    -0.00443050f, -0.01414712f, 0.12495672f, -0.16330314f, -0.44642949f, -0.44590107f, -0.21801077f, -0.05743146f, 
    0.07634757f, -0.00065474f, 0.00591288f, -0.09268797f, -0.00549203f, 0.27465120f, 0.14104632f, 0.00735086f, 
    -0.03215444f, -0.10911255f, 0.06166355f, -0.02340216f, 0.02928447f, -0.14417547f, 0.08760675f, -0.03194260f, 
    -0.04186124f, -0.12155329f, -0.03438261f, 0.06850387f, 0.23748912f, 0.03055072f, 0.14265771f, 0.02183165f, 
    0.06297621f, -0.08269312f, -0.19454239f, -0.06898536f, 0.06683033f, 0.04302892f, -0.08887278f, -0.07639792f, 
    0.16556074f, 0.02777425f, -0.15143903f, 0.13767263f, -0.11839263f, -0.05715735f, 0.15877213f, -0.09370235f, 
    0.18272980f, 0.10763969f, 0.11784106f, -0.03585747f, -0.18904486f, -0.08760489f, 0.06533431f, 0.07467033f, 
    0.01574336f, 0.03963085f, 0.12436748f, 0.09250600f, 0.03415839f, -0.10138688f, 0.06235198f, -0.04131626f, 
    -0.00825010f, 0.01421666f, -0.04669492f, -0.03700278f, -0.25802818f, 0.06160754f, 0.08443429f, 0.10582048f, 
    0.09725896f, -0.22744928f, 0.01846576f, 0.01565140f, 0.09047772f, 0.12557957f, -0.02188573f, 0.03810881f, 
    0.02209174f, 0.10299220f, 0.08265276f, -0.09497315f, -0.04498919f, 0.23239858f, 0.23131736f, -0.02240611f, 
    -0.22803852f, 0.01542648f, 0.17293198f, -0.10091924f, -0.13404533f, -0.00576376f, 0.16967250f, 0.08588415f, 
    0.15086795f, -0.03452734f, 0.00820579f, -0.05619412f, -0.13311052f, 0.08759425f, -0.28601614f, -0.27488145f, 
    0.11891043f, -0.06006370f, -0.01867445f, -0.10293117f, -0.03147305f, -0.00584114f, 0.02043983f, -0.06491516f, 
    0.19173774f, -0.07172140f, 0.04043778f, 0.00123624f, -0.00937445f, 0.17280291f, -0.07046945f, 0.03308439f, 
    0.00742235f, -0.07222338f, 0.11272491f, 0.01570076f, 0.03430929f, -0.24990772f, 0.06465682f, -0.18662465f, 
    0.06179946f, 0.00753981f, 0.04105002f, -0.54284656f, -0.04420675f, 0.27973628f, 0.24732795f, 0.09726471f, 
    -0.08007745f, -0.04069612f, -0.37956500f, -0.33123666f, -0.10050771f, 0.04423345f, 0.05769028f, -0.10280257f, 
    -0.11515826f, 0.01851675f, 0.00823780f, -0.07540490f, -0.13037805f, -0.28265160f, 0.03533064f, -0.13433932f, 
    -0.07175082f, 0.07355554f, -0.01022775f, 0.08897808f, 0.23001069f, 0.27674463f, 0.12566565f, -0.21557701f, 
    -0.04118527f, -0.22313204f, 0.11681383f, -0.05412148f, -0.00755511f, 0.18847482f, 0.07423342f, 0.03380450f, 
    0.03891849f, 0.07736795f, -0.10401613f, 0.04006425f, 0.00268676f, 0.06468210f, 0.26209688f, 0.27700600f, 
    0.16060214f, -0.01482811f, 0.06007788f, -0.13797754f, 0.02419501f, 0.04979747f, 0.03108786f, 0.06937642f, 
    0.07346966f, -0.06750640f, -0.02465356f, 0.03645034f, -0.01509649f, 0.02238129f, 0.09926107f, 0.15893231f, 
    -0.14776821f, 0.04326199f, 0.21610788f, -0.12225927f, 0.16765122f, 0.03015668f, 0.12880245f, -0.09843793f, 
    -0.02754947f, -0.07869285f, -0.18833674f, 0.36738312f, 0.09280115f, 0.02841956f, -0.14541635f, 0.04505729f, 
    -0.08773770f, -0.18571018f, -0.22798540f, 0.05560523f, 0.44265571f, -0.05481200f, -0.22831489f, -0.05523668f, 
    -0.18200347f, -0.00920259f, 0.31289569f, -0.35832340f, 0.35524815f, 0.33136934f, -0.29372433f, -0.07955207f, 
    -0.31158456f, -0.01291332f, -0.02010496f, -0.00556565f, 0.19887184f, 0.44617617f, -0.19462161f, -0.15138312f, 
    -0.07292146f, -0.05278428f, -0.03288997f, -0.05586590f, -0.01064327f, -0.07009917f, 0.08134750f, 0.04838711f, 
    0.07588395f, 0.07016706f, 0.05706321f, -0.01569769f, 0.03772792f, -0.08123464f, 0.01939972f, 0.16924834f, 
    -0.18116176f, 0.04179524f, 0.12550659f, 0.05850803f, 0.07916743f, 0.00313541f, -0.02609089f, -0.06692744f, 
    -0.27040336f, -0.11649597f, 0.14763968f, -0.19927646f, 0.05864232f, -0.05886266f, -0.02569123f, 0.12735455f, 
    -0.20840529f, -0.30297029f, 0.03729464f, 0.08257455f, -0.15254073f, -0.07095580f, 0.12517929f, 0.06044296f, 
    -0.03318235f, 0.27110595f, 0.11644834f, -0.06765272f, -0.12573139f, -0.10675050f, 0.09872372f, 0.06447971f, 
    0.07328728f, 0.05519342f, -0.22583129f, -0.09051043f, 0.16486904f, -0.00444560f, 0.17284845f, 0.02018022f, 
    0.04144978f, 0.14453462f, 0.04705475f, 0.20433371f, -0.24093790f, -0.13102414f, -0.10391445f, 0.15836503f, 
    -0.02366862f, 0.08970883f, -0.02517909f, 0.10934769f, 0.05345545f, -0.22006789f, 0.08913971f, 0.06664272f, 
    0.21923658f, 0.12216815f, -0.08687469f, 0.00978105f, 0.17990990f, 0.04107994f, -0.17831826f, 0.24267989f, 
    -0.11995348f, -0.04174988f, 0.04693796f, 0.11825031f, -0.04698921f, 0.27847755f, 0.01521218f, 0.15880089f, 
    0.05788403f, -0.02331238f, -0.10721210f, -0.33037338f, 0.14468230f, 0.10475753f, 0.00011698f, -0.09050389f, 
    -0.02118815f, 0.47640216f, 0.13477866f, -0.01942996f, -0.05889391f, 0.27017105f, 0.03754269f, 0.21802436f, 
    0.01500523f, 0.38079491f, 0.28620026f, 0.04131961f, 0.23687848f, -0.07373133f, 0.06220080f, -0.08449034f, 
    -0.14516498f, -0.04599018f, -0.18247953f, 0.24892598f, 0.13646315f, 0.05571340f, -0.07424258f, 0.17305431f, 
    0.04489534f, 0.02443029f, -0.14953208f, 0.12238095f, -0.20478316f, -0.07583902f, -0.06786384f, -0.15198292f, 
    0.15733610f, -0.13824771f, -0.05442131f, -0.07184433f, 0.01452844f, 0.23604605f, 0.00721149f, -0.03446670f, 
    -0.00536735f, 0.23834115f, 0.07780141f, 0.07014157f, -0.01376652f, -0.04211012f, 0.00933014f, -0.11307982f, 
    0.01683922f, -0.12042240f, 0.06348803f, -0.12720402f, 0.04765448f, -0.23197147f, -0.18358903f, -0.24801423f, 
    -0.13706672f, -0.04587837f, -0.07036807f, 0.13553508f, 0.04379847f, 0.01319862f, 0.11896098f, 0.33592153f, 
    0.16427366f, -0.06434467f, -0.02670627f, 0.14260428f, -0.00955898f, -0.01413474f, 0.02730810f, -0.13583979f, 
    -0.18343216f, -0.11824808f, 0.02003310f, -0.20290412f, -0.00764999f, 0.25755361f, 0.16699874f, -0.02715266f, 
    -0.27347448f, 0.01619325f, 0.17864268f, -0.12673335f, -0.02970746f, -0.00964765f, 0.15054046f, 0.09382493f, 
    -0.10208134f, -0.13074945f, -0.52946359f, -0.56176639f, -0.14975043f, -0.06359603f, 0.17080083f, 0.12428281f, 
    0.01014603f, -0.10518278f, 0.13268402f, -0.13636388f, 0.09055435f, -0.00806258f, 0.04509280f, -0.02289397f, 
    -0.04536132f, 0.05928197f, 0.17090063f, 0.42082959f, 0.13875973f, 0.12268687f, 0.00299643f, -0.16800757f, 
    -0.01158197f, 0.04063356f, 0.08026445f, 0.01190775f, -0.17521510f, -0.18701006f, -0.14471437f, -0.07479553f, 
    -0.08126855f, 0.05636393f, 0.04576580f, -0.11966671f, 0.07391258f, -0.32486075f, 0.25771958f, 0.13094009f, 
    0.03332763f, -0.05194056f, 0.03751834f, -0.03518884f, 0.10399824f, 0.05305783f, -0.22935912f, -0.20584923f, 
    0.01405558f, -0.02144192f, 0.01066059f, -0.05765073f, 0.21940356f, 0.08507425f, -0.14397416f, -0.12968443f, 
    -0.10688754f, -0.06872962f, 0.09745106f, 0.03884668f, -0.00696651f, -0.00452441f, -0.01199863f, -0.11845122f, 
    -0.03423899f, -0.26790866f, -0.30993915f, -0.11626271f, -0.01476280f, -0.25421488f, 0.18849684f, 0.12999654f, 
    -0.04116390f, -0.12215187f, -0.20176859f, 0.04873618f, -0.10167851f, -0.10282395f, 0.05230101f, -0.09499065f, 
    -0.00427396f, 0.08801482f, -0.06111649f, -0.22146785f, -0.06263306f, -0.04861956f, -0.16590843f, 0.00972550f, 
    -0.03509418f, 0.02353746f, 0.18356171f, -0.18414344f, -0.43737197f, 0.56150109f, -0.03323079f, -0.17257659f, 
    -0.22245699f, 0.21243690f, -0.18113293f, -0.04051246f, -0.20879842f, -0.09920586f, -0.05181083f, 0.00810128f, 
    -0.04607109f, -0.07130493f, 0.12245969f, -0.01785303f, 0.09780625f, 0.21244588f, -0.14952846f, -0.13615853f, 
    -0.04378419f, -0.12080763f, -0.09495626f, -0.03980365f, 0.11955915f, 0.00678763f, -0.26061189f, -0.32750693f, 
    -0.31801215f, 0.11415492f, -0.21882260f, -0.10674201f, 0.11299299f, 0.15451126f, -0.03666721f, -0.36466905f, 
    0.37925687f, 0.12198214f, -0.05093716f, 0.02269595f, 0.09945443f, 0.05832219f, 0.00012151f, 0.24579893f, 
    -0.05015242f, -0.03918448f, -0.02004416f, -0.05598141f, 0.04692371f, -0.05872200f, 0.00473816f, 0.03450289f, 
    -0.05854817f, -0.06220866f, -0.03858325f, -0.00318332f, -0.03452846f, -0.02434462f, -0.03675801f, -0.02878357f, 
    0.00413602f, 0.01915241f, -0.02992269f, -0.02484113f, -0.01032841f, -0.05516841f, 0.00726335f, 0.04448366f, 
    0.00325937f, -0.00217696f, 0.00847506f, 0.02058978f, 0.00454841f, -0.06314187f, -0.04060856f, -0.00088676f, 
    0.01948723f, 0.03010794f, 0.02400841f, 0.02072220f, -0.06167841f, -0.05437946f, -0.04248355f, -0.05136636f, 
    0.02840990f, -0.01044444f, -0.02716035f, 0.03586089f, 0.01046405f, -0.04076339f, 0.01461477f, -0.05260747f, 
    -0.03333206f, -0.06102173f, -0.06761112f, 0.02593632f, -0.04767295f, 0.01854387f, -0.04781554f, -0.05045509f, 
    -0.01929297f, -0.00335286f, -0.02889324f, -0.05297520f, -0.04786940f, -0.04668029f, -0.06508504f, 0.04808082f, 
    -0.02599326f, 0.02480300f, -0.04277152f, -0.02044214f, -0.01647937f, 0.01264651f, -0.03216339f, 0.03859748f, 
    -0.02193990f, 0.00582250f, -0.03307575f, 0.01749925f, 0.00438475f, 0.01477420f, -0.06149957f, -0.05792202f, 
    0.03388802f, 0.00012118f, -0.04368401f, 0.00682120f, -0.06195589f, 0.00640292f, 0.04081004f, -0.04570692f, 
    0.04925652f, -0.00714622f, 0.01068918f, 0.01118197f, -0.04471587f, 0.03497970f, -0.04073302f, -0.04721542f, 
    -0.03989574f, 0.01462714f, 0.04197734f, 0.00410257f, -0.01493054f, 0.04331763f, -0.03770671f, -0.02917505f, 
    0.03157049f, -0.01951033f, -0.06217357f, 0.04618645f, 0.05652779f, -0.05746670f, -0.01068138f, -0.04929334f, 
    0.04899069f, 0.00969010f, -0.04318093f, -0.04619086f, -0.02760019f, -0.03678501f, -0.03690251f, 0.03408640f, 
    0.03916045f, 0.04034213f, -0.04814055f, -0.06202636f, -0.00401863f, 0.02940860f, 0.02280905f, -0.01350388f, 
    0.04811855f, -0.02570358f, -0.00673007f, -0.03594585f, -0.05677129f, 0.02756473f, -0.06608254f, -0.01215369f, 
    0.01800765f, 0.02846395f, 0.01254852f, -0.05003692f, -0.02741883f, -0.03721611f, -0.05627447f, -0.05118503f, 
    -0.06799985f, 0.04232643f, 0.04261059f, 0.02915904f, -0.03115321f, 0.03855557f, 0.01406918f, -0.01090800f, 
    -0.01594106f, 0.04554616f, 0.03365702f, -0.06088516f, -0.00648362f, -0.01918842f, 0.00591567f, 0.04343342f, 
    -0.05045380f, -0.02832090f, 0.00546957f, -0.00742440f, 0.02145711f, -0.02800811f, -0.04543860f, -0.06763810f, 
    0.01242075f, -0.05153217f, -0.00014081f, 0.01255394f, 0.04373119f, 0.01379062f, -0.05148003f, -0.01098751f, 
    0.04802878f, -0.06320116f, 0.01990020f, -0.03087362f, 0.00756452f, -0.00715290f, -0.03580968f, 0.02330695f, 
    0.03852306f, -0.04247806f, 0.02453695f, 0.03173378f, 0.02908678f, 0.04840438f, -0.00694475f, -0.03429377f, 
    -0.04275753f, 0.04787075f, -0.00962249f, 0.00412091f, -0.06421753f, -0.05423051f, 0.02913006f, 0.02878879f, 
    0.03485281f, 0.00912826f, -0.01432390f, 0.02139323f, 0.05433813f, 0.01261744f, 0.02758653f, 0.04621501f, 
    -0.04237542f, -0.05710819f, -0.01014097f, 0.02757067f, -0.00499660f, -0.05390535f, 0.00064146f, 0.03155046f, 
    0.04411861f, 0.03000834f, 0.04153952f, 0.01520524f, 0.04181849f, -0.04160798f, 0.04223690f, -0.02474951f, 
    -0.04421035f, -0.02954075f, 0.04619288f, -0.01323605f, 0.00160459f, 0.04583381f, -0.05381024f, 0.01430283f, 
    -0.01155959f, 0.00298891f, -0.02325996f, 0.05299897f, 0.01772639f, -0.00992850f, 0.00741754f, 0.02063780f, 
    0.04762695f, -0.04520743f, -0.06553950f, -0.04723922f, -0.04193978f, 0.01921142f, -0.00188381f, 0.01056681f, 
    -0.00963578f, 0.02684246f, 0.03350686f, 0.01349408f, -0.05012285f, 0.05723833f, -0.06284384f, 0.02154741f, 
    0.03858003f, 0.00835588f, 0.03036331f, -0.03883402f, -0.03527017f, 0.06974515f, 0.01178257f, -0.04169438f, 
    -0.04440398f, 0.04987125f, -0.02743093f, 0.03757148f, -0.02357779f, -0.04236356f, 0.04696462f, -0.01760789f, 
    0.01084337f, 0.05007957f, -0.00178570f, -0.05074792f, -0.03652394f, -0.04751067f, -0.06445901f, -0.00893157f, 
    -0.05193570f, -0.05797567f, 0.02468981f, -0.04362319f, 0.05973745f, 0.04993959f, -0.04471858f, 0.02945283f, 
    -0.05366491f, 0.01462470f, -0.05864510f, -0.06479517f, 0.02464788f, 0.02577022f, -0.02301529f, -0.01889272f, 
    -0.00552211f, 0.03732601f, -0.03260814f, 0.00152439f, -0.04058428f, -0.02488577f, -0.02486804f, -0.06086574f, 
    -0.03518819f, -0.04614546f, 0.00013343f, 0.00420136f, -0.00897155f, 0.02543250f, -0.03556418f, -0.04630618f, 
    -0.02823257f, -0.02651143f, 0.01458908f, -0.06817966f, -0.01940944f, 0.03375859f, -0.01948923f, -0.00028726f, 
    0.02883542f, -0.06132471f, 0.02435845f, -0.01979026f, -0.05601539f, 0.02989536f, 0.00779296f, 0.02380222f, 
    -0.02810993f, -0.05908748f, -0.03067346f, 0.02199648f, -0.02569234f, 0.04762564f, 0.02666462f, -0.03856522f, 
    0.03785009f, -0.02319473f, -0.02086242f, 0.04262763f, 0.01501551f, 0.03564984f, -0.02235651f, -0.05265549f, 
    0.04550917f, -0.04606109f, -0.01223390f, -0.04521732f, 0.00138626f, -0.03296375f, 0.01675665f, -0.06543040f, 
    0.02928962f, 0.04809770f, 0.00810741f, -0.01058121f, 0.04444418f, 0.03144855f, -0.04193546f, 0.03444949f, 
    -0.04339796f, 0.01867679f, 0.04024541f, -0.00867837f, -0.03684724f, 0.04783378f, -0.00326253f, -0.03337216f, 
    0.04050396f, 0.02658629f, -0.02668626f, 0.02088389f, -0.02281094f, -0.00391391f, 0.02407298f, 0.03927387f, 
    0.00267355f, -0.05623617f, -0.04955504f, 0.04452689f, 0.02735375f, 0.01388953f, 0.01913434f, 0.02459261f, 
    -0.03958785f, 0.03912362f, -0.01876510f, 0.02272274f, 0.05254956f, 0.02387380f, -0.01176881f, -0.02629529f, 
    -0.00836517f, 0.00660420f, -0.01114385f, -0.05108316f, -0.02076144f, 0.03154756f, -0.01282709f, 0.02759941f, 
    -0.01186809f, -0.05741435f, 0.03297907f, 0.00555886f, -0.02144644f, -0.04539598f, 0.03163906f, -0.03436469f, 
    0.01014721f, -0.03388657f, 0.03521683f, 0.01642093f, 0.02467599f, -0.01990011f, -0.04527884f, -0.02659986f, 
    -0.02213188f, 0.02530094f, -0.00207223f, 0.02626534f, -0.01294677f, -0.06143178f, -0.03337042f, 0.02955941f, 
    0.04614163f, -0.03194556f, -0.02190778f, 0.00230162f, 0.00970961f, -0.00494397f, 0.04462205f, 0.04790468f, 
    -0.01021565f, 0.04409939f, -0.04017774f, -0.03204487f, 0.03948628f, 0.01300006f, -0.02973367f, -0.05562820f, 
    0.00038851f, 0.04870690f, 0.04436367f, 0.04079278f, -0.04140747f, -0.03948976f, 0.01368415f, -0.06424606f, 
    -0.05087356f, -0.02684872f, -0.00411651f, -0.05022174f, -0.02291684f, -0.02197095f, -0.03992848f, 0.03724799f, 
    0.04306788f, -0.06460439f, 0.03628881f, 0.01581118f, 0.01412941f, -0.00232659f, 0.02409787f, 0.02469411f, 
    0.04440942f, -0.04560205f, -0.02420276f, 0.04261417f, 0.04282043f, 0.00070511f, 0.01734110f, -0.06247954f, 
    0.01958602f, 0.02115824f, -0.01967249f, -0.00009187f, -0.01004377f, -0.03871953f, -0.03824762f, 0.00221410f, 
    0.01724098f, 0.02930385f, -0.02341541f, -0.03091238f, 0.00244754f, 0.04066418f, 0.01526205f, -0.04071219f, 
    -0.02691934f, -0.05084819f, -0.01937292f, 0.00838224f, 0.00504426f, -0.00180148f, -0.04335124f, 0.04973431f, 
    -0.02643361f, 0.00620842f, 0.01342941f, -0.00097851f, 0.01471171f, -0.03922246f, -0.06640159f, -0.04382224f, 
    -0.05495017f, -0.03449268f, -0.01050263f, -0.01198999f, -0.04621945f, 0.04310334f, -0.06099942f, 0.04088999f, 
    0.00256697f, -0.05745454f, -0.00911770f, -0.05484839f, -0.04650746f, 0.04548040f, -0.04274951f, 0.04589735f, 
    -0.03797150f, -0.01121563f, -0.04477854f, -0.05570884f, 0.00846820f, -0.02786914f, -0.06184315f, -0.05591147f, 
    0.03379761f, -0.03528583f, -0.01779820f, 0.05532327f, 0.04108863f, 0.04792744f, 0.04181217f, 0.04077426f, 
    -0.04402804f, -0.03017757f, 0.04210930f, -0.02617275f, -0.02171265f, 0.02634002f, 0.00931597f, -0.00942446f, 
    0.00397080f, 0.03043656f, -0.00859535f, -0.04735529f, -0.05279502f, -0.02572351f, -0.04464766f, -0.03300715f, 
    -0.01593499f, -0.03422396f, -0.04565835f, -0.02064115f, -0.05772346f, 0.04925768f, -0.03210688f, -0.02670386f, 
    -0.02323695f, -0.02017585f, -0.00357413f, -0.05839585f, 0.03008280f, -0.05729019f, 0.05319856f, 0.00991969f, 
    -0.04789940f, 0.02891448f, 0.01395030f, 0.01972473f, 0.05139975f, 0.04770084f, -0.04838869f, 0.05910707f, 
    -0.07181804f, -0.27003130f, -0.12781632f, -0.14865260f, 0.22306715f, -0.05250839f, 0.13163742f, 0.07657148f, 
    0.07580976f, -0.16985701f, -0.17046586f, 0.14914802f, -0.03374442f, 0.12890297f, 0.05587307f, 0.03000694f, 
    -0.23302810f, -0.10391098f, -0.00896187f, 0.05343338f, 0.04733457f, 0.04172051f, 0.02849726f, -0.07803948f, 
    0.14944611f, -0.07893793f, 0.23704468f, -0.12692799f, 0.07561894f, 0.15997155f, 0.12616017f, 0.15272355f, 
    -0.08619220f, 0.17987198f, 0.13278867f, 0.16247293f, 0.13071622f, 0.03832215f, 0.04670011f, 0.08245038f, 
    0.06606420f, -0.12822898f, -0.11766850f, 0.25556955f, 0.10137674f, 0.14360954f, -0.18122916f, 0.28309447f, 
    0.06532574f, 0.16124019f, 0.10291031f, 0.02919082f, -0.08409168f, -0.07147837f, -0.07375208f, 0.01135214f, 
    0.10789911f, 0.06538725f, 0.07597715f, 0.06629898f, 0.06385296f, -0.01419461f, 0.07020316f, 0.14475630f, 
    0.08360002f, 0.23109370f, 0.17707942f, -0.08334703f, 0.25363630f, 0.15047890f, -0.09115532f, 0.22539583f, 
    0.03592050f, -0.02316753f, 0.02353356f, -0.14768812f, -0.15121256f, -0.27708766f, -0.09170294f, -0.05763444f, 
    -0.07421789f, 0.07163300f, -0.17552488f, 0.11960839f, -0.01682515f, 0.01958208f, -0.09242681f, 0.21006645f, 
    0.15477259f, 0.17168513f, -0.38956341f, -0.10624563f, -0.12552676f, -0.15833741f, -0.08619598f, -0.01071057f, 
    0.02895162f, -0.07523114f, -0.23793204f, -0.08714313f, -0.06885467f, -0.10911267f, 0.06558763f, 0.14812534f, 
    0.06272302f, 0.25353155f, 0.05316925f, 0.22903313f, -0.03611655f, -0.08735784f, 0.21066147f, 0.14547092f, 
    -0.00398011f, 0.05463084f, -0.21287659f, 0.16895053f, 0.04489335f, 0.05289293f, -0.08469687f, 0.09081586f, 
    0.04921651f, -0.03360161f, -0.04112690f, 0.05881795f, 0.12711793f, 0.03533429f, 0.09821430f, 0.05538687f, 
    -0.03170820f, 0.00458357f, 0.01852247f, 0.24918196f, 0.03319244f, -0.15405025f, 0.10922705f, 0.02392798f, 
    -0.23428574f, -0.29134047f, -0.11325789f, -0.08290801f, -0.05783720f, -0.00388105f, 0.07700223f, -0.06257804f, 
    -0.05738340f, 0.02883454f, -0.21542656f, -0.00374968f, -0.15770543f, 0.03143951f, 0.05814952f, 0.04954877f, 
    -0.25463519f, 0.24026588f, 0.18203807f, 0.22709969f, -0.12113505f, -0.15715969f, 0.02909413f, 0.06506456f, 
    0.01629285f, 0.15424991f, -0.11816059f, -0.07514054f, 0.13375975f, 0.04860704f, -0.11028381f, -0.05340888f, 
    0.00790057f, 0.04591458f, -0.13773178f, -0.01452918f, 0.09866165f, 0.21842813f, 0.00181419f, 0.09003010f, 
    -0.10425752f, 0.01448622f, 0.02799902f, 0.02081100f, 0.05169921f, -0.21410036f, 0.07535956f, 0.02944984f, 
    0.00736638f, 0.14387771f, 0.14063126f, -0.18208335f, -0.09730210f, -0.06975605f, 0.07598704f, -0.00799758f, 
    -0.08262987f, -0.18141842f, 0.00873922f, 0.00843588f, -0.14534760f, -0.07646375f, 0.04665739f, -0.08888354f, 
    -0.17232668f, -0.06692480f, 0.08351361f, -0.09631043f, 0.19928923f, 0.04877916f, 0.12773480f, -0.52408314f, 
    -0.11100550f, 0.01746156f, 0.08147202f, -0.12169620f, 0.16489835f, -0.01402884f, -0.11843667f, -0.07364323f, 
    0.01491404f, 0.03157535f, 0.25786954f, 0.07528736f, -0.00865003f, 0.02561487f, -0.07529764f, 0.03836698f, 
    0.04246675f, 0.12650514f, 0.14540343f, -0.07801052f, 0.00542956f, -0.07721154f, -0.01472795f, -0.06612969f, 
    0.24852240f, 0.20368221f, 0.07558173f, -0.23211022f, -0.06108544f, 0.05132369f, 0.13880083f, 0.12489872f, 
    -0.01634299f, -0.13464318f, -0.04447138f, 0.19123028f, -0.12482063f, 0.22579503f, 0.28810495f, -0.07613643f, 
    0.11303298f, -0.00843749f, -0.10192556f, 0.16911978f, 0.05714854f, -0.06763554f, 0.08241981f, 0.07085177f, 
    -0.04384567f, -0.07816955f, -0.11601479f, 0.01295015f, 0.04782080f, 0.00732275f, 0.01763894f, 0.18761308f, 
    0.04354534f, -0.00155369f, 0.00856780f, 0.09525976f, -0.04658716f, -0.02385368f, -0.06790324f, -0.06649046f, 
    0.14572951f, -0.01989115f, -0.00092585f, 0.25479746f, 0.15532315f, -0.01579330f, 0.18639761f, 0.09299858f, 
    0.04096936f, 0.17548418f, -0.16618405f, 0.04114152f, -0.12012969f, 0.09654901f, -0.21995373f, -0.18207556f, 
    0.08396271f, 0.21438304f, 0.06887936f, -0.04166461f, -0.23341294f, -0.08298666f, 0.01855643f, -0.09501185f, 
    0.15259793f, 0.16060124f, 0.02175567f, -0.09794980f, 0.00947440f, -0.00535927f, -0.05060387f, -0.05844426f, 
    0.02969502f, 0.12724656f, 0.04421671f, 0.08074648f, 0.21820116f, 0.02342512f, 0.03598215f, 0.02476014f, 
    0.08995994f, -0.06106168f, 0.00045837f, -0.17516352f, -0.27498016f, 0.22579619f, -0.15225966f, -0.02102117f, 
    -0.02535871f, -0.08502618f, 0.01689507f, -0.00565626f, -0.16388184f, 0.01700084f, 0.09314556f, -0.09782965f, 
    -0.00411590f, 0.00150104f, 0.10074357f, -0.02073601f, -0.04838540f, -0.04833808f, -0.10473990f, -0.15387177f, 
    0.19632980f, -0.02191387f, 0.07993235f, 0.04814000f, 0.05822345f, 0.02239971f, 0.08886375f, 0.09623052f, 
    -0.58366066f, -0.11668097f, -0.09588133f, 0.08687927f, 0.00263294f, 0.02056696f, 0.12054770f, -0.17085914f, 
    0.10279121f, 0.01494355f, 0.06749323f, 0.08500511f, -0.13596794f, 0.03158133f, -0.01726912f, 0.06197874f, 
    -0.06244509f, 0.01195940f, -0.12857510f, -0.00097492f, 0.10957545f, 0.08232931f, -0.06475513f, 0.09036111f, 
    0.00987641f, 0.13266985f, -0.11815194f, -0.02668737f, 0.11068243f, -0.14845453f, 0.06061731f, -0.05320935f, 
    -0.16333966f, -0.04270442f, -0.05548901f, 0.00228102f, 0.02706668f, 0.08475033f, 0.00345810f, 0.05092193f, 
    0.14934300f, -0.22024046f, 0.12073660f, -0.06662215f, 0.01633140f, -0.01523933f, -0.12007251f, 0.04705479f, 
    -0.11355343f, -0.09686705f, -0.02715242f, 0.01203961f, 0.10516002f, -0.16932984f, 0.07282811f, 0.03316358f, 
    -0.04960679f, -0.11530115f, -0.04340098f, -0.03647913f, -0.01871095f, 0.24441656f, 0.12367862f, -0.03488209f, 
    -0.00421389f, 0.04594785f, -0.05494418f, 0.04847439f, -0.13463385f, 0.06583139f, 0.22922985f, -0.14442593f, 
    -0.06933953f, -0.00923345f, 0.01117227f, 0.06322951f, 0.06296349f, 0.04358049f, 0.03210946f, 0.03821916f, 
    0.32137889f, 0.31679004f, -0.11094851f, 0.01857257f, 0.13688655f, 0.10217728f, 0.06788728f, -0.01530839f, 
    0.24742962f, 0.13485759f, 0.10114361f, -0.09324706f, 0.02231766f, -0.06968520f, 0.10357624f, -0.01195165f, 
    0.05138245f, -0.04941956f, -0.10320126f, -0.28290951f, -0.05057441f, -0.10499824f, 0.01136494f, 0.00171799f, 
    0.07777057f, 0.09834035f, -0.26396033f, -0.11145542f, -0.25588199f, 0.03748381f, 0.02765475f, -0.06831132f, 
    0.16471833f, 0.05427576f, -0.16824199f, -0.16288434f, -0.13596608f, -0.18004912f, 0.11799459f, 0.07696573f, 
    0.12353647f, 0.11042374f, 0.05602201f, -0.18322700f, 0.19816020f, -0.02734171f, -0.30543858f, -0.12474979f, 
    -0.10124786f, -0.05845060f, -0.01945234f, 0.04889778f, 0.19021870f, 0.34027717f, -0.02134520f, 0.24197796f, 
    0.07320060f, -0.04707370f, 0.13713418f, 0.19920422f, 0.08715594f, -0.01069584f, 0.15166555f, 0.32929972f, 
    0.07279009f, -0.09133863f, 0.11344074f, 0.09754157f, 0.01012868f, 0.14288184f, 0.13134465f, -0.18431035f, 
    -0.42539823f, 0.03413862f, -0.10839321f, 0.03305443f, -0.25339195f, -0.04365198f, 0.03004322f, -0.09755954f, 
    0.10011432f, -0.05220179f, 0.03677364f, 0.05231933f, -0.03762442f, -0.05769496f, -0.18284677f, 0.03948341f, 
    0.19172680f, -0.12217107f, -0.01132498f, -0.24921550f, -0.05881002f, 0.10983749f, 0.04955492f, -0.36382857f, 
    0.03004391f, -0.00400686f, -0.37556797f, -0.23399158f, -0.00786575f, -0.08490214f, 0.01999445f, 0.04331491f, 
    0.18699712f, -0.05469307f, 0.30384997f, -0.15669084f, -0.31670302f, 0.08348519f, -0.04178061f, 0.08186736f, 
    -0.06128274f, 0.09698974f, -0.01618654f, -0.07460671f, -0.06616589f, -0.34051841f, -0.17605497f, -0.10452577f, 
    0.07922857f, 0.05535390f, 0.04516847f, -0.02084510f, 0.08019876f, 0.13679460f, -0.37137684f, -0.12356028f, 
    -0.07237733f, -0.14338262f, -0.16831884f, 0.08853160f, 0.02996202f, -0.08994190f, 0.07638562f, -0.29789013f, 
    0.04950706f, -0.06684539f, -0.08265851f, -0.12647928f, 0.08555596f, 0.02788964f, -0.09946545f, 0.79686791f, 
    -0.28637269f, -0.20239048f, 0.00527675f, -0.11324466f, 0.21363096f, 0.04251803f, 0.04870658f, -0.04997529f, 
    -0.00050512f, -0.21105799f, 0.19350243f, 0.03405592f, -0.07631443f, 0.02109945f, 0.11255401f, -0.01072545f, 
    0.07539980f, -0.12208267f, 0.12578882f, -0.01658830f, -0.05947085f, 0.02413837f, -0.09501934f, -0.03158592f, 
    0.00543538f, 0.05858941f, -0.41248614f, -0.19040979f, 0.03709224f, 0.02629178f, 0.03701089f, -0.06733312f, 
    0.15978128f, 0.04582466f, 0.12869382f, 0.71666741f, -0.13232541f, -0.02231146f, -0.12521742f, 0.12910621f, 
    0.25635919f, 0.18421271f, 0.01424067f, 0.00489191f, -0.03642046f, -0.08685187f, 0.20331432f, -0.07546792f, 
    0.06092944f, -0.00106383f, 0.04773015f, -0.01793619f, 0.00262822f, 0.23929219f, -0.08106774f, 0.03606948f, 
    0.03264167f, -0.04667328f, -0.05773536f, 0.12883274f, -0.04126935f, 0.06653548f, 0.22448960f, 0.15491185f, 
    0.11488303f, -0.10249545f, -0.09184004f, 0.03496961f, -0.01782667f, 0.08105243f, 0.04378287f, -0.11745195f, 
    -0.09007077f, -0.24598321f, 0.14389735f, -0.02689476f, -0.09382750f, 0.20876686f, -0.01527902f, 0.09943122f, 
    -0.47451770f, 0.09422323f, 0.02305952f, -0.07824819f, 0.14779264f, -0.03028624f, 0.16204157f, 0.06817240f, 
    -0.08163682f, -0.10840970f, -0.11503994f, 0.00621647f, -0.00940186f, 0.18527439f, -0.08706661f, 0.10683332f, 
    0.07830350f, 0.08934958f, -0.24899375f, 0.18402614f, -0.17232406f, -0.00243168f, -0.06782611f, 0.07502922f, 
    0.10178394f, -0.15332186f, 0.20631985f, -0.19816665f, -0.17509544f, -0.18821153f, -0.05464412f, -0.18616559f, 
    -0.14242618f, 0.08016901f, 0.02014140f, -0.12498996f, 0.03942015f, 0.12524596f, 0.25120860f, 0.00935652f, 
    0.13008320f, -0.14495578f, 0.06287711f, -0.05957540f, 0.10898051f, -0.04634027f, 0.05436686f, 0.06026889f, 
    -0.08097432f, 0.15019740f, 0.05006062f, 0.08636957f, 0.10311145f, -0.04304373f, -0.13057996f, -0.21179445f, 
    0.16339672f, 0.07121535f, 0.08514158f, 0.14378034f, 0.08634111f, -0.18349198f, 0.00951703f, -0.27282202f, 
    -0.33238199f, -0.41970283f, -0.20338884f, -0.07881994f, -0.10170629f, -0.01749996f, 0.20147917f, 0.03063446f, 
    0.04738731f, 0.01516052f, -0.20485510f, -0.24389790f, -0.12376641f, -0.01792440f, 0.13985628f, -0.06691444f, 
    0.06946829f, -0.57001781f, -0.17310745f, -0.26679835f, -0.16104680f, 0.06536599f, -0.03090555f, 0.18753082f, 
    0.03436783f, -0.21338637f, 0.04649883f, 0.23127568f, -0.06304887f, 0.08380871f, 0.09938713f, -0.04067091f, 
    -0.06702356f, 0.04284868f, 0.31690413f, 0.55599886f, 0.02952749f, 0.15857784f, -0.00713098f, 0.09668504f, 
    0.05797091f, 0.12144243f, -0.01708828f, -0.12282878f, -0.26953775f, 0.12065218f, -0.03963359f, 0.04507275f, 
    -0.02826783f, -0.00070991f, -0.11266282f, 0.04556268f, 0.05538979f, 0.14902730f, -0.19740090f, -0.30164158f, 
    -0.05146644f, 0.07415687f, -0.05559462f, 0.05614857f, -0.10047425f, 0.00714822f, -0.51464254f, -0.32240137f, 
    -0.25643387f, -0.00638927f, -0.01352273f, 0.06840342f, 0.04067487f, 0.03923494f, -0.07127222f, 0.44838005f, 
    -0.23023781f, 0.09538294f, -0.06347173f, 0.15656966f, -0.03954649f, 0.14564112f, -0.00036027f, 0.07513226f, 
    -0.12549765f, 0.00821741f, -0.12913987f, 0.15710577f, -0.02196498f, -0.13118684f, 0.19708331f, 0.11659358f, 
    0.11488277f, -0.22274663f, -0.22531021f, -0.10380045f, 0.05971826f, 0.01590513f, 0.19725105f, 0.13416579f, 
    0.24141571f, 0.10699233f, 0.03604246f, 0.00255368f, -0.11261155f, 0.02502878f, -0.18642399f, -0.31641936f, 
    0.03590680f, 0.08126612f, 0.10985784f, -0.28081191f, -0.32778165f, -0.02203081f, -0.00246487f, 0.07997683f, 
    0.09020008f, 0.05588212f, -0.27770165f, 0.05948344f, -0.19867004f, -0.00761241f, 0.01616205f, -0.01422037f, 
    0.05210435f, 0.08325239f, -0.03463583f, 0.04694131f, 0.19194841f, 0.65111411f, 0.13520394f, 0.18601190f, 
    -0.02892520f, 0.10316578f, 0.29692271f, -0.00455194f, 0.01741228f, -0.10943466f, 0.48514715f, -0.05808572f, 
    -0.07714639f, 0.03372431f, 0.03830038f, 0.02110272f, -0.07907008f, 0.03624567f, 0.05293680f, -0.65239894f, 
    -0.02321267f, -0.49612233f, 0.05439566f, 0.05441729f, -0.11426698f, -0.10301652f, -0.15596412f, 0.25450811f, 
    -0.00528329f, -0.03326798f, -0.01125337f, -0.02063652f, -0.01648887f, -0.05451930f, 0.01390708f, 0.04926900f, 
    -0.06204659f, -0.03434303f, 0.04197457f, 0.01915359f, -0.00446930f, -0.05494675f, -0.05625660f, -0.05860035f, 
    0.04475458f, -0.01823602f, -0.01841550f, -0.01951531f, -0.02769249f, -0.04393620f, -0.01270362f, -0.02944038f, 
    -0.03852270f, 0.05023366f, 0.04030399f, 0.00414664f, -0.05856395f, 0.00164095f, 0.01259291f, 0.00876933f, 
    -0.02094108f, -0.05169132f, -0.02842593f, 0.03726021f, -0.00234537f, -0.06312517f, -0.03152725f, -0.05401904f, 
    -0.00665550f, 0.03738809f, 0.04872119f, -0.01885073f, 0.02964340f, 0.04349544f, -0.00844219f, 0.04795563f, 
    -0.00941502f, 0.03134095f, -0.02532468f, -0.03646865f, 0.01643197f, -0.02356185f, -0.02621360f, -0.00213623f, 
    0.04472021f, -0.05569202f, -0.03200495f, 0.04519827f, -0.05312881f, -0.04207228f, -0.03050052f, -0.00454039f, 
    -0.04552457f, -0.00271265f, -0.04552586f, -0.00004163f, -0.01489071f, -0.05164598f, -0.03967347f, -0.00644418f, 
    -0.04966903f, -0.05666900f, -0.05318734f, -0.05167603f, 0.01113179f, -0.02727833f, -0.06106757f, -0.00166070f, 
    0.00888080f, -0.06367458f, -0.02925117f, -0.05082512f, -0.00649629f, 0.03011629f, -0.02101183f, 0.01316859f, 
    -0.00745299f, -0.00010814f, 0.05286185f, -0.00880409f, 0.02246671f, -0.04954859f, -0.02114707f, -0.00002620f, 
    0.04923429f, 0.02458332f, -0.01484754f, 0.05569228f, -0.05995813f, -0.04115054f, 0.01275307f, 0.02447475f, 
    -0.03900764f, -0.00385903f, 0.05247158f, -0.00778202f, -0.05910502f, 0.00869916f, 0.01612093f, -0.04519884f, 
    -0.04872840f, -0.05243443f, -0.01134960f, -0.06244413f, 0.05245631f, -0.05425267f, -0.01739134f, -0.00103192f, 
    0.01247307f, 0.00555581f, -0.05397871f, 0.04482108f, -0.01980789f, 0.02948942f, 0.03656381f, 0.02821514f, 
    -0.06265958f, 0.02337261f, 0.05085713f, 0.00940614f, -0.01755503f, 0.04254160f, 0.01116027f, -0.02705555f, 
    -0.02368202f, -0.00963828f, -0.04417891f, -0.00894685f, -0.01943663f, -0.00723912f, -0.04732047f, 0.05275129f, 
    -0.02743407f, 0.05348869f, -0.00764140f, -0.02178806f, 0.00191564f, -0.03028965f, -0.00686721f, 0.01455586f, 
    -0.02519465f, -0.03188130f, 0.03307993f, 0.02194081f, -0.02466100f, -0.00998522f, 0.03139651f, -0.05210304f, 
    -0.04789529f, -0.02685703f, -0.00222701f, 0.01657260f, -0.03959339f, -0.04514150f, -0.03160425f, -0.01060693f, 
    0.02625410f, -0.03549104f, -0.05962224f, 0.03111602f, -0.02191286f, 0.00603908f, 0.00530274f, -0.02518168f, 
    -0.01551561f, -0.05081860f, 0.02120334f, -0.01521802f, 0.00837793f, 0.00395312f, -0.03839868f, -0.04295885f, 
    -0.05534051f, -0.04564275f, -0.02330150f, 0.04462876f, -0.02034011f, 0.01575969f, -0.04335273f, 0.02344122f, 
    0.01573034f, -0.05973883f, -0.06091573f, -0.03923080f, -0.00297401f, -0.04410500f, 0.02377217f, -0.04749101f, 
    0.04550045f, -0.02045281f, 0.04308090f, -0.06244966f, -0.05025630f, -0.02756871f, -0.06202822f, 0.04612875f, 
    -0.01630838f, -0.01571030f, 0.01921268f, 0.04181803f, -0.02932963f, -0.03025122f, 0.05364772f, 0.05247033f, 
    0.04746096f, 0.01727174f, -0.03888557f, 0.02854688f, -0.02943333f, -0.02151930f, 0.01425530f, -0.02221227f, 
    0.03286328f, 0.03730800f, -0.00138577f, -0.04219930f, 0.04898737f, 0.05162600f, -0.01866322f, -0.02747799f, 
    -0.00653891f, -0.01873903f, -0.03867642f, -0.00892326f, 0.00459950f, 0.05710203f, 0.02948709f, 0.00214006f, 
    0.04283847f, 0.03645882f, -0.00637482f, -0.02008706f, 0.02070397f, 0.01178437f, 0.00559022f, 0.00318167f, 
    -0.06155422f, 0.00886691f, -0.03732064f, 0.02776980f, -0.06375687f, -0.04233734f, -0.05411145f, 0.05689635f, 
    0.05686254f, -0.02179938f, -0.04019828f, -0.00176818f, -0.02284450f, -0.05527419f, -0.01658163f, -0.02052641f, 
    -0.00760357f, -0.00399794f, 0.00534685f, 0.02171175f, 0.01281945f, 0.02434705f, 0.04858217f, 0.04648242f, 
    -0.01814252f, -0.02205147f, -0.01721675f, 0.02107395f, -0.03938035f, -0.02591404f, -0.00873374f, -0.04031505f, 
    -0.06381636f, -0.03241549f, 0.03738155f, -0.04288847f, 0.01497099f, 0.01799817f, -0.04502806f, 0.04607739f, 
    0.04924052f, -0.00074330f, -0.03505326f, -0.04787790f, 0.04781537f, -0.06231867f, -0.05309211f, 0.04329308f, 
    -0.03736758f, -0.06101051f, 0.00986256f, -0.03769711f, 0.04963661f, 0.03665521f, 0.02435923f, 0.04443874f, 
    0.00904604f, -0.02158017f, -0.05057938f, -0.02245751f, -0.05226983f, -0.03869960f, -0.04868671f, 0.02951381f, 
    -0.05768338f, -0.01191581f, 0.04801016f, -0.00693391f, 0.02086029f, -0.03835429f, -0.03216939f, 0.05238094f, 
    -0.01036454f, 0.03082411f, 0.01912826f, 0.01842010f, 0.02526768f, 0.04537257f, 0.04101012f, 0.00737931f, 
    0.02242009f, -0.01038835f, 0.00556532f, 0.01092343f, -0.05020331f, -0.04197736f, -0.05624035f, -0.02098084f, 
    -0.05491697f, -0.05579905f, -0.01586765f, -0.04884361f, 0.01498254f, 0.03669097f, -0.05717108f, 0.01943655f, 
    0.03246338f, 0.00099532f, 0.03916591f, 0.04587219f, -0.05289017f, -0.01225028f, -0.01204729f, -0.01062047f, 
    -0.01812663f, -0.00331565f, -0.02121900f, 0.04916625f, 0.04999436f, 0.01964347f, -0.01209498f, 0.00196915f, 
    -0.04209925f, -0.00611305f, -0.05658808f, -0.02628129f, -0.04612659f, -0.03703355f, -0.05017173f, 0.03029478f, 
    -0.00586030f, -0.04477097f, 0.04863425f, 0.03289797f, 0.01896823f, 0.02190827f, -0.02914485f, -0.05109803f, 
    -0.01349162f, -0.00827097f, -0.03035419f, -0.00922804f, 0.04390055f, -0.00372927f, -0.05267394f, -0.06147894f, 
    0.00269011f, -0.05937668f, -0.04661600f, -0.04572945f, -0.02323884f, 0.03235481f, 0.02088247f, -0.04034071f, 
    -0.06430113f, -0.05957347f, -0.01927116f, -0.00587495f, 0.04539050f, 0.00985644f, -0.00982126f, -0.02055906f, 
    0.02402950f, -0.04191660f, -0.02381015f, 0.00605566f, -0.06260457f, 0.01482954f, -0.03520818f, 0.00668957f, 
    -0.03331283f, -0.02982042f, -0.02851866f, -0.01178585f, -0.02346274f, -0.03340254f, -0.02070545f, 0.00049100f, 
    -0.05732618f, -0.00217575f, 0.00359057f, -0.03407164f, -0.00422696f, 0.03647763f, -0.05113214f, 0.04800388f, 
    -0.03955523f, -0.00526430f, -0.01290682f, -0.03178246f, -0.05730540f, -0.00112010f, -0.02893558f, -0.02901915f, 
    0.01220437f, 0.02501550f, -0.04954688f, -0.04469557f, 0.00704638f, -0.00371631f, -0.02534815f, 0.05293906f, 
    0.00637526f, -0.04438538f, 0.01839735f, -0.06293046f, -0.01260653f, -0.01364869f, -0.05400442f, -0.04532730f, 
    0.03534189f, 0.04412271f, -0.03072674f, 0.04459049f, -0.06026625f, 0.01310715f, -0.03115584f, 0.03803514f, 
    -0.03640233f, -0.00069393f, -0.04870881f, 0.00928213f, -0.01944469f, 0.04309444f, -0.05762121f, 0.04201663f, 
    -0.01491579f, -0.06157037f, -0.03669205f, -0.05346629f, 0.01526097f, -0.00058752f, 0.01269536f, -0.01914832f, 
    -0.04951171f, 0.00789874f, -0.04041664f, -0.03704871f, -0.04474148f, -0.03957949f, -0.02577346f, -0.00354859f, 
    0.00758490f, 0.00077137f, 0.00145238f, -0.00380588f, -0.05905809f, -0.02138712f, -0.02195355f, -0.00893186f, 
    0.02399156f, -0.04376321f, 0.03120909f, -0.05219655f, -0.05613426f, 0.01805511f, 0.05118505f, 0.03267744f, 
    -0.02313738f, 0.05099606f, -0.02733476f, -0.03387772f, -0.02459606f, -0.05061321f, -0.02883361f, 0.02125484f, 
    0.02581733f, -0.02873771f, -0.00052442f, 0.03371863f, -0.05731312f, 0.00726882f, -0.02154666f, 0.02792700f, 
    -0.00433325f, -0.02962839f, 0.01871104f, 0.00113828f, 0.00550183f, -0.03031098f, 0.00533929f, -0.01532040f, 
    0.02700069f, -0.03850050f, -0.02480778f, 0.03511204f, -0.03995900f, -0.02448994f, -0.06135903f, -0.02268098f, 
    0.03813257f, -0.03608168f, 0.04646871f, 0.01760835f, 0.05004705f, -0.00909567f, -0.04482127f, -0.02996246f, 
    0.01466154f, 0.01693391f, -0.03085759f, 0.02722488f, 0.01441456f, -0.01421792f, 0.01155610f, 0.02853825f, 
    0.02706195f, -0.02172967f, -0.05999325f, 0.03282897f, 0.01932597f, -0.01528641f, 0.00100937f, -0.01905508f, 
    -0.03944262f, -0.03404941f, 0.04232495f, -0.05183828f, 0.02460313f, -0.04928089f, 0.00804767f, 0.02225336f, 
    0.03152773f, 0.04637942f, 0.04814263f, -0.04760346f, -0.01024539f, 0.01714909f, -0.05507925f, 0.04957087f, 
    -0.06222183f, -0.01556024f, -0.01577142f, 0.01701724f, -0.00763050f, 0.01919721f, 0.00252333f, -0.05153809f, 
    -0.03293357f, -0.04301457f, 0.46911606f, -0.00922090f, 0.00589108f, 0.13990963f, 0.20645924f, 0.00492970f, 
    0.27798197f, 0.28025225f, 0.12173505f, 0.01458087f, -0.04523750f, -0.01986846f, 0.08454923f, -0.04137647f, 
    0.01107415f, -0.20954101f, 0.01611398f, 0.17313306f, -0.03247200f, 0.19066334f, 0.06130844f, 0.04446156f, 
    0.07349788f, -0.03379409f, -0.14190802f, 0.12411309f, -0.09741002f, 0.07996789f, -0.10387573f, 0.03699578f, 
    -0.14833532f, -0.00580098f, 0.17091818f, 0.04359837f, -0.02471302f, -0.01664134f, 0.02462754f, 0.03304498f, 
    -0.08583055f, -0.08295214f, 0.05278163f, -0.11534347f, 0.12247790f, 0.02746744f, -0.06500579f, 0.26943231f, 
    0.01083512f, 0.24747895f, -0.05925269f, 0.06187195f, 0.01154381f, 0.09960689f, 0.21553630f, -0.02098799f, 
    0.11960939f, -0.09995786f, -0.32728696f, -0.04585005f, -0.04754319f, -0.02719320f, 0.10065981f, -0.22242256f, 
    0.09315755f, 0.15040177f, -0.07831760f, 0.09004632f, -0.18833414f, -0.02047702f, -0.18397820f, 0.10236285f, 
    -0.18127018f, -0.47976092f, -0.22960873f, -0.06233357f, 0.05239593f, 0.13842623f, 0.17845248f, 0.01649052f, 
    -0.04713577f, -0.00913797f, -0.18256235f, 0.08210084f, -0.02485552f, -0.08530241f, 0.07328087f, 0.02783979f, 
    0.22407170f, 0.14060043f, 0.34459952f, 0.20084514f, 0.14143835f, -0.09224440f, 0.09825712f, 0.05276352f, 
    -0.03728998f, 0.09567892f, -0.12162164f, -0.14865156f, 0.16143574f, -0.03554973f, 0.04704242f, 0.10614244f, 
    -0.08192284f, 0.09909035f, 0.12210883f, 0.07862339f, 0.19184874f, 0.11626391f, 0.24499802f, -0.07418525f, 
    -0.13113713f, -0.24484193f, -0.06777215f, -0.06667031f, 0.00605508f, -0.04884731f, -0.06015083f, 0.02852772f, 
    -0.07944822f, -0.06986139f, 0.04404236f, -0.09041541f, 0.10808025f, 0.12923889f, 0.20683946f, 0.10064464f, 
    0.12596996f, -0.18882921f, 0.01637640f, -0.01952146f, 0.02943741f, -0.24707532f, 0.04846527f, -0.36856255f, 
    -0.36351502f, -0.22636606f, 0.05000567f, 0.00241566f, 0.07204961f, 0.08941288f, 0.15845555f, 0.12166563f, 
    -0.30483434f, -0.04888552f, 0.11332847f, -0.03764792f, 0.02309211f, 0.06456427f, 0.17074859f, 0.08430682f, 
    -0.10143232f, 0.10668836f, 0.12572181f, -0.02191680f, -0.33386311f, 0.11506424f, -0.15697180f, -0.00109952f, 
    -0.00312812f, 0.01016694f, 0.08945640f, 0.05054088f, 0.19081023f, -0.03116369f, -0.00514363f, 0.05518649f, 
    0.17397267f, 0.06294321f, -0.15633260f, 0.33258799f, -0.04185481f, 0.06985893f, 0.03445199f, 0.00372323f, 
    -0.10375184f, -0.20489326f, 0.03124065f, 0.00344656f, 0.06726348f, 0.03501228f, 0.09634499f, -0.02270664f, 
    -0.09301773f, -0.27703434f, -0.07153135f, -0.05413825f, -0.01786243f, -0.22606991f, -0.16733825f, -0.25936267f, 
    -0.03863188f, -0.04196079f, -0.16617370f, -0.07976691f, -0.08911774f, -0.12239469f, -0.30588627f, 0.24423081f, 
    -0.00269828f, 0.00393540f, 0.06642591f, -0.04133458f, 0.13778900f, 0.09474060f, 0.03706725f, 0.30180624f, 
    -0.09602710f, 0.19888596f, -0.02332647f, -0.05090131f, -0.09934261f, 0.01561297f, -0.08148400f, 0.10403468f, 
    0.11510054f, 0.00698080f, 0.22695926f, 0.19466917f, -0.03534814f, -0.15163566f, -0.01202874f, -0.11339144f, 
    0.07311673f, 0.37399241f, -0.05142489f, 0.00222830f, -0.13591264f, -0.02410715f, 0.01573156f, 0.00476456f, 
    -0.04658376f, 0.05279872f, -0.08087199f, 0.22995365f, 0.12930459f, -0.11997554f, -0.14403065f, -0.00321758f, 
    0.16092966f, 0.07124306f, -0.29915783f, 0.05403419f, 0.09620122f, 0.25487813f, -0.01166785f, -0.02229473f, 
    -0.44821677f, 0.17128310f, -0.07269669f, -0.00342987f, 0.06822207f, 0.07818047f, -0.03229777f, -0.08660350f, 
    -0.08433230f, -0.15373428f, 0.04274005f, -0.08965180f, 0.05009590f, 0.34120029f, -0.02610532f, 0.15757199f, 
    -0.14735365f, 0.00473699f, -0.16333053f, -0.09390347f, 0.03262919f, 0.16081031f, 0.23981915f, 0.05375838f, 
    0.18833074f, 0.02476002f, -0.32591352f, -0.07405983f, -0.06937903f, 0.03232342f, 0.29624575f, 0.03385703f, 
    -0.03605142f, -0.21000679f, -0.00677607f, 0.24309574f, -0.12131413f, -0.14510345f, -0.10641197f, -0.07380021f, 
    -0.00161366f, 0.08609150f, -0.15040560f, 0.08848444f, 0.00134947f, 0.08713150f, 0.08730334f, -0.13248874f, 
    -0.11429399f, -0.04607360f, 0.13858312f, -0.06606294f, 0.05079444f, -0.08881533f, 0.06513921f, 0.16533351f, 
    0.07338946f, -0.27286506f, -0.22644156f, 0.03317963f, -0.00446560f, 0.20352970f, 0.02947817f, -0.07695509f, 
    0.05361691f, 0.05767420f, 0.06754570f, 0.17569955f, -0.06584945f, 0.15662122f, 0.05025795f, 0.31301871f, 
    0.05172015f, -0.05274095f, -0.05731919f, 0.24622591f, 0.11141663f, 0.15419196f, 0.25164565f, -0.10682593f, 
    0.14057977f, 0.04813815f, 0.02207954f, -0.16746064f, 0.26615000f, 0.09308806f, -0.05388836f, 0.10818903f, 
    -0.12478835f, 0.07220252f, 0.02322988f, 0.06561241f, -0.05884898f, 0.12347469f, 0.01866429f, 0.10053800f, 
    0.02685222f, 0.05361374f, 0.16064447f, 0.06319438f, 0.00580081f, 0.04417237f, -0.13879013f, -0.07947870f, 
    0.00628013f, 0.16606620f, 0.00720145f, 0.17988391f, 0.01269468f, 0.09602226f, 0.00691659f, 0.07417640f, 
    -0.13104151f, 0.20807596f, 0.12148886f, -0.02361102f, -0.11845070f, -0.13127147f, 0.08244117f, -0.00601840f, 
    -0.15552159f, 0.02266995f, 0.11098880f, -0.02740998f, 0.07639183f, 0.03193121f, -0.09112360f, -0.04936237f, 
    0.30252048f, 0.01405264f, -0.19028263f, 0.02684107f, -0.02736245f, -0.20480326f, -0.20176923f, 0.14145702f, 
    0.12939665f, -0.17501637f, -0.17452836f, 0.07430692f, -0.00318750f, -0.00590689f, 0.13571674f, 0.11259674f, 
    0.08272721f, 0.12268265f, 0.11567608f, 0.02718337f, -0.00556689f, 0.11995594f, 0.02358003f, -0.00569425f, 
    0.18422936f, 0.06382900f, 0.05420460f, -0.14794196f, -0.04711263f, -0.08481348f, 0.05839262f, -0.08047579f, 
    -0.07423390f, -0.11191072f, -0.18763372f, 0.00851865f, 0.28872642f, -0.15422374f, -0.02453531f, 0.10653877f, 
    0.40969691f, -0.13144974f, 0.00158662f, -0.01128874f, -0.04730000f, 0.02805022f, 0.11350111f, -0.23746544f, 
    -0.28389379f, 0.04630848f, 0.02611073f, -0.06111544f, 0.13239272f, -0.10418956f, 0.10639969f, 0.17963581f, 
    -0.17949195f, -0.17597570f, 0.09746750f, -0.09906820f, 0.01196613f, 0.01956506f, 0.11029615f, 0.03716488f, 
    0.04418486f, -0.12132042f, 0.09904888f, 0.12131544f, -0.00843917f, -0.05990295f, -0.05098110f, -0.43024758f, 
    0.33469477f, 0.06045939f, 0.01575254f, 0.15471633f, -0.08967041f, -0.11581177f, 0.08484693f, 0.10191056f, 
    0.11395853f, 0.04054500f, -0.02693286f, 0.23874894f, 0.20533107f, 0.12148759f, -0.02246528f, 0.11814298f, 
    0.03472814f, 0.00521597f, 0.02574596f, -0.12247491f, -0.01701694f, 0.03833168f, -0.31664294f, 0.12523413f, 
    -0.00294300f, 0.08739699f, -0.01810618f, 0.09247274f, -0.22778541f, -0.15620473f, -0.07661808f, 0.15892851f, 
    -0.06143252f, -0.12687117f, -0.06422422f, -0.18990993f, -0.07097159f, 0.16323017f, -0.01020195f, -0.09404759f, 
    -0.09567527f, -0.01203416f, 0.03706865f, -0.18129471f, 0.04266341f, -0.22888933f, 0.03047646f, 0.02111397f, 
    0.16694568f, 0.06645874f, 0.01735882f, 0.15509516f, 0.03447406f, -0.00238332f, 0.18787062f, -0.15769671f, 
    0.09409265f, 0.00000075f, 0.15952900f, 0.23725925f, 0.07869628f, -0.20669867f, 0.00526473f, -0.02867252f, 
    0.11516628f, -0.08402583f, 0.02203378f, 0.32816455f, -0.22238904f, -0.01657082f, -0.02121069f, 0.16194452f, 
    -0.07423802f, 0.06193246f, -0.00863136f, -0.13775046f, 0.04922115f, 0.00195602f, -0.07439651f, 0.11875892f, 
    -0.10077847f, 0.20670153f, 0.13555747f, -0.10839706f, 0.02168752f, -0.05630557f, 0.07793251f, 0.18286391f, 
    -0.01382088f, 0.16607650f, -0.01803329f, 0.13850054f, -0.13713768f, 0.17961951f, -0.03011431f, 0.01560779f, 
    0.10417974f, -0.03539136f, -0.11808340f, 0.01862072f, 0.17773177f, 0.26887572f, 0.23067373f, 0.06849281f, 
    0.06647506f, 0.08876678f, -0.08932839f, -0.09471118f, 0.11370710f, -0.01832298f, 0.15260303f, 0.08291519f, 
    -0.03490184f, 0.00139612f, 0.12654959f, -0.21447502f, -0.08322327f, 0.20370488f, -0.06995138f, -0.16703907f, 
    0.00275830f, 0.30604038f, -0.00943954f, -0.03475213f, 0.17593598f, -0.12891778f, -0.05433304f, -0.11581213f, 
    0.01814720f, 0.00132803f, -0.05483562f, -0.04828590f, -0.06008150f, 0.01202525f, -0.03255902f, 0.02463342f, 
    -0.01027538f, 0.05034844f, -0.00592339f, -0.05424547f, -0.02746607f, -0.01356752f, 0.03799872f, -0.03747433f, 
    -0.05777267f, -0.05186165f, -0.06660662f, -0.02201656f, 0.01317893f, -0.01335466f, 0.00252650f, -0.03623538f, 
    0.04729650f, -0.01050997f, -0.05033981f, 0.00268063f, -0.00282951f, 0.02869200f, -0.01292166f, -0.06327924f, 
    0.02965319f, 0.02105375f, 0.04738414f, -0.02212389f, -0.01522453f, -0.05652511f, -0.03060113f, 0.04453181f, 
    -0.02118830f, -0.06017002f, -0.03536069f, 0.01734140f, -0.00362300f, 0.00984995f, 0.04139263f, 0.00212825f, 
    0.04553749f, 0.01608657f, -0.04087754f, -0.00954296f, 0.03552951f, 0.02672561f, 0.02126327f, 0.01634540f, 
    0.03246155f, -0.02340963f, -0.02590308f, 0.04328990f, 0.04300041f, 0.00774444f, -0.00778141f, 0.01101741f, 
    -0.05651616f, 0.01969986f, -0.01251428f, -0.02708369f, -0.01971987f, 0.01758846f, -0.01371397f, -0.01286063f, 
    -0.00790499f, 0.03854039f, 0.03687456f, -0.02484292f, -0.02245501f, 0.04657280f, -0.00938540f, -0.01116877f, 
    -0.03171899f, -0.02210906f, -0.02261440f, 0.04731337f, 0.02068868f, -0.03473543f, -0.02166436f, -0.02064654f, 
    -0.00901503f, 0.01966386f, -0.03378693f, -0.01691602f, 0.03444919f, -0.00217987f, 0.00746638f, -0.03888055f, 
    -0.03155374f, 0.03873939f, -0.01347105f, -0.05200985f, -0.00495334f, -0.03300641f, 0.00996041f, -0.05022899f, 
    0.01151586f, -0.00464644f, -0.06274422f, 0.02561436f, 0.00314716f, -0.04308052f, 0.00298439f, -0.00474031f, 
    -0.05147183f, -0.03965778f, -0.01017113f, -0.04568825f, -0.05173311f, 0.03092738f, -0.05303776f, -0.05870686f, 
    0.04373115f, -0.05765774f, 0.03585023f, 0.04529346f, -0.05935941f, 0.03158603f, 0.03800617f, -0.02981142f, 
    0.05386288f, 0.00197553f, 0.02270219f, 0.05014504f, -0.02266115f, 0.00404320f, -0.00210884f, 0.03494431f, 
    0.02553069f, -0.05853570f, -0.02805510f, -0.04301124f, -0.05952091f, 0.04709715f, 0.01128487f, 0.00749303f, 
    -0.04540764f, 0.03509505f, 0.04254261f, 0.02545631f, 0.03171003f, -0.05271797f, 0.03069125f, 0.03663442f, 
    0.03768025f, -0.04880461f, -0.06057618f, -0.05302604f, -0.02538380f, -0.04336673f, -0.03482858f, 0.01227441f, 
    -0.03856433f, -0.01141343f, -0.04385630f, -0.00116248f, -0.00135617f, -0.01131096f, -0.04526626f, -0.04229556f, 
    -0.03571320f, 0.03059546f, -0.01138232f, 0.01375620f, 0.05154638f, -0.04463474f, 0.00010946f, 0.01118789f, 
    -0.00887637f, 0.03203818f, 0.00129376f, 0.01210122f, -0.05218058f, -0.04024151f, -0.04632498f, 0.04781558f, 
    0.01654905f, -0.04372761f, -0.00079892f, -0.06809855f, -0.05362469f, 0.02372406f, 0.02922698f, -0.03634981f, 
    -0.04235315f, 0.00367780f, -0.04297898f, -0.03852555f, 0.03316345f, 0.03341705f, -0.01390015f, -0.02094004f, 
    -0.04227700f, -0.01228655f, 0.01954930f, 0.04332939f, -0.03689580f, 0.04450175f, 0.03496395f, -0.04984104f, 
    0.01852497f, -0.01966543f, 0.05550172f, -0.02281854f, -0.02487871f, 0.01999778f, 0.02139537f, 0.02034809f, 
    0.04438305f, -0.05276825f, 0.01817055f, 0.02553915f, 0.02177568f, 0.01051204f, -0.06009196f, -0.01814107f, 
    0.01321168f, 0.01051195f, -0.05428737f, -0.00935141f, 0.03308596f, -0.04026839f, -0.06117809f, 0.00265340f, 
    0.03511741f, -0.05107288f, 0.04050242f, -0.04178557f, 0.01704367f, -0.04175914f, -0.02804952f, -0.04822792f, 
    0.01513836f, -0.03239277f, 0.00444545f, -0.06065629f, 0.03706113f, -0.02676584f, 0.00205310f, -0.00847101f, 
    0.01352798f, 0.04126016f, -0.03599768f, 0.03256401f, -0.01905680f, 0.00029077f, -0.06235992f, -0.02983774f, 
    -0.03047833f, -0.03627901f, -0.03410672f, 0.00518741f, -0.01276047f, 0.02693836f, -0.00285414f, -0.00701167f, 
    -0.02065011f, 0.04889172f, -0.05296990f, -0.02931920f, -0.00500281f, 0.01068862f, 0.03276721f, 0.03544397f, 
    0.01988341f, 0.01176195f, 0.03011621f, -0.01213387f, 0.02425820f, 0.02358705f, -0.06637235f, 0.04644738f, 
    -0.06832552f, 0.04329692f, -0.03443102f, -0.06061066f, -0.05622177f, 0.00058352f, -0.00402558f, -0.01030267f, 
    0.04386211f, -0.20433632f, 0.01572283f, -0.21402039f, -0.18275861f, 0.14750803f, 0.15702632f, 0.16890003f, 
    0.05302707f, -0.10129562f, -0.14178482f, 0.12478793f, -0.15399757f, -0.03848207f, 0.03240253f, -0.20778850f, 
    -0.08863519f, -0.16865489f, -0.10656091f, -0.18128467f, -0.08076331f, -0.15338972f, -0.04866362f, -0.03912570f, 
    0.02890967f, 0.07796623f, 0.24313116f, -0.39739460f, 0.13713565f, -0.21391167f, 0.04158585f, 0.23739874f, 
    -0.08886156f, 0.24948040f, 0.15538786f, 0.14818756f, 0.14359622f, -0.19058517f, -0.29317892f, 0.11131803f, 
    0.04882803f, -0.20384800f, -0.01764383f, -0.03345251f, 0.06536844f, -0.15698491f, -0.05056134f, -0.02620108f, 
    -0.05811059f, 0.03307152f, -0.02056169f, -0.03913116f, -0.18341248f, 0.16680475f, 0.03353915f, 0.15986320f, 
    0.02597284f, -0.05875723f, -0.00254191f, -0.06669863f, 0.04109233f, 0.00139575f, -0.04149650f, -0.12358971f, 
    -0.25724131f, 0.02449867f, 0.02280270f, -0.12860577f, 0.02321410f, 0.03165663f, 0.04501790f, 0.08848605f, 
    0.09850404f, 0.19118957f, 0.23379327f, 0.32533768f, 0.01454943f, 0.19007471f, 0.00897787f, 0.11044531f, 
    0.07997188f, 0.04653371f, 0.11583421f, -0.13525864f, -0.07629383f, -0.00383659f, 0.12780750f, 0.10773265f, 
    0.00859395f, 0.03542905f, -0.21344100f, -0.15170197f, -0.15873800f, 0.10295088f, -0.23101380f, 0.12358055f, 
    0.10374912f, 0.09703942f, 0.07026807f, 0.03610418f, -0.03967071f, 0.19092920f, -0.12686910f, 0.16456315f, 
    0.04448015f, 0.16063222f, -0.04936236f, 0.04027632f, 0.01780605f, -0.02446015f, -0.12162519f, -0.05915575f, 
    -0.03731847f, -0.16458640f, -0.14826736f, -0.01694168f, 0.06281457f, 0.19755897f, 0.07770759f, -0.05572600f, 
    -0.01443762f, -0.00316252f, 0.10704302f, 0.17159213f, 0.25325406f, 0.11838058f, 0.29730946f, 0.04660272f, 
    -0.20161341f, -0.00589322f, 0.06356613f, 0.10756907f, 0.12536871f, -0.02642666f, 0.01974951f, 0.04708141f, 
    -0.17490695f, -0.17013147f, -0.19084913f, -0.27985775f, 0.02642629f, 0.14740190f, 0.08567221f, -0.02204193f, 
    0.07612347f, 0.06441317f, -0.00015923f, -0.17621398f, -0.24065386f, -0.15089050f, 0.10332391f, 0.11802268f, 
    0.16046028f, 0.26002491f, 0.01752157f, -0.03938133f, 0.01468107f, -0.05805909f, -0.01728515f, 0.29445249f, 
    -0.04040178f, 0.27992728f, 0.17767864f, 0.14826202f, -0.07437849f, 0.15683711f, -0.06292091f, 0.06402484f, 
    -0.06690847f, 0.05313106f, 0.17728236f, -0.19214317f, 0.13840728f, -0.12669864f, 0.01703213f, 0.06780857f, 
    0.06210109f, -0.11266587f, -0.01330153f, -0.00024669f, 0.01857205f, -0.01946690f, 0.21538036f, -0.04630708f, 
    -0.06026272f, -0.09625538f, -0.10992040f, -0.07764720f, 0.04352015f, 0.13513106f, 0.31231549f, 0.26724884f, 
    -0.24743685f, -0.00217269f, -0.03738260f, 0.21083176f, -0.03323222f, -0.03696431f, 0.24848562f, -0.27977815f, 
    -0.03494078f, -0.05028917f, -0.19950731f, 0.09827608f, 0.05855696f, -0.01372201f, 0.14098029f, -0.50702828f, 
    -0.36135736f, -0.01002173f, 0.17601237f, 0.09715254f, -0.03266442f, 0.08421920f, -0.10556461f, -0.03777552f, 
    -0.01627513f, -0.02594926f, -0.22470696f, -0.04375098f, 0.02418995f, -0.15097980f, 0.04073132f, 0.14293849f, 
    -0.03412169f, 0.13811332f, -0.01601975f, -0.03980449f, 0.22473668f, -0.05814760f, -0.08935197f, 0.05541183f, 
    0.27044842f, 0.08734138f, -0.18773051f, -0.25196722f, -0.31657061f, 0.04867331f, 0.07476999f, -0.02085708f, 
    0.09446821f, 0.19301729f, -0.10215154f, -0.22809149f, -0.41182649f, 0.09664889f, -0.17763330f, -0.18420784f, 
    -0.19621667f, -0.25227481f, -0.18374601f, -0.27753860f, -0.07148956f, 0.13916525f, 0.20324874f, 0.13933760f, 
    -0.00347993f, 0.07515754f, 0.08145307f, -0.05754122f, 0.15022974f, -0.07597521f, 0.04382019f, -0.20023599f, 
    0.04373884f, 0.00592139f, 0.16188098f, 0.14942950f, 0.19659443f, 0.01475731f, 0.07834038f, -0.02973941f, 
    -0.08861154f, 0.07917049f, 0.03695848f, 0.02887466f, 0.21974748f, 0.11422013f, -0.05695107f, 0.17038107f, 
    0.45512003f, 0.42552063f, -0.28480667f, -0.11991070f, -0.29271233f, 0.00587840f, -0.04605957f, -0.24517557f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.01478324f, 0.02941210f, 0.04506154f, 0.11927375f, 0.14183483f, 0.11430691f, -0.07513511f, 0.02704673f, 
    0.07291093f, 0.07274888f, -0.07651891f, -0.06637586f, 0.16563080f, -0.01517801f, 0.02790518f, 0.03580548f, 
    -0.08531832f, -0.02081062f, -0.04315375f, -0.05631548f, 0.25888097f, -0.03383880f, 0.00470990f, 0.09799206f, 
    -0.05111691f, 0.12786362f, -0.03075876f, -0.03556767f, 0.03096038f, 0.16935004f, -0.04399135f, 0.04363695f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16408816f, -0.11843853f, -0.00676001f, -0.02642505f, -0.05683300f, 0.10408935f, 0.11287426f, 0.04017580f, 
    0.02756233f, -0.09914361f, -0.00057999f, 0.15520318f, -0.08351406f, 0.06427933f, -0.01357596f, 0.01696470f, 
    0.02921849f, 0.15647262f, 0.09423793f, -0.03148736f, -0.00567466f, -0.12646154f, -0.01717398f, -0.10005377f, 
    -0.07295582f, -0.17325750f, -0.13981415f, -0.11784418f, -0.11011119f, -0.04670893f, 0.09424905f, -0.02796604f, 
    0.09482667f, -0.16490637f, 0.13397408f, 0.16583501f, -0.18200842f, 0.76765305f, 0.14799266f, -0.10845379f, 
    0.21755280f, 0.01563714f, 0.14911959f, 0.23492132f, 0.22996134f, -0.05496565f, 0.02210090f, -0.19226058f, 
    0.28045613f, 0.08291934f, 0.06951947f, 0.62520063f, -0.28470513f, 0.04448696f, 0.15411797f, 0.03447826f, 
    0.02838018f, -0.59293050f, -0.14077897f, -0.04006874f, -0.23854308f, -0.03391322f, -0.08886177f, -0.08344484f, 
    0.01778812f, 0.00267951f, -0.19197400f, -0.14553292f, 0.05187032f, -0.13447289f, 0.14956895f, -0.09694794f, 
    -0.16275944f, -0.16960549f, -0.15729743f, 0.06101430f, 0.10830668f, 0.09413597f, -0.05067891f, -0.19083284f, 
    -0.16525285f, -0.05721540f, -0.00465067f, -0.20246974f, 0.11176158f, -0.05834112f, 0.06674708f, 0.01908121f, 
    -0.01018641f, -0.00461957f, 0.16566326f, -0.04296873f, -0.18998463f, 0.10515015f, 0.16526417f, 0.01467004f, 
    0.02409322f, -0.06282400f, 0.00902738f, 0.08824298f, -0.13403802f, -0.09800589f, -0.10449544f, -0.17758827f, 
    0.08847968f, 0.03352815f, 0.00643253f, -0.15210283f, 0.03427664f, -0.16726913f, -0.04821951f, 0.08572253f, 
    0.06730069f, -0.15327501f, 0.08810309f, -0.15425219f, -0.01291553f, 0.14346929f, -0.00626127f, -0.06513226f, 
    -0.14329509f, -0.08269548f, 0.06653190f, -0.00923456f, -0.19692391f, -0.13046801f, 0.09499836f, -0.07305188f, 
    -0.09295117f, -0.05559260f, 0.11210303f, 0.27203268f, -0.04966521f, 0.83282191f, 0.02040497f, 0.11692291f, 
    0.23802687f, 0.20574722f, 0.07188103f, -0.18345930f, 0.17890188f, -0.00904535f, 0.35226181f, 0.28435352f, 
    -0.32390571f, 0.02468963f, -0.09188461f, 0.55118555f, 0.07502306f, -0.11621377f, -0.11267035f, 0.01477131f, 
    0.26727420f, 0.13349660f, 0.16069074f, -0.14781804f, -0.28085253f, 0.22098127f, -0.13784122f, -0.27169916f, 
    0.15121154f, -0.02991857f, -0.08157519f, 0.27240998f, 0.02095474f, -0.10724249f, 0.15434796f, -0.44181520f, 
    -0.01189726f, -0.17767523f, -0.07449438f, -0.05544298f, 0.23417942f, -0.11156870f, -0.35901329f, 0.43876496f, 
    -0.11707608f, -0.04192127f, -0.10344611f, 0.06739132f, 0.19225664f, 0.00198283f, -0.07525735f, 0.30120140f, 
    -0.18805265f, -0.53177601f, 0.16055854f, -0.03845564f, 0.07816879f, 0.10285953f, -0.06906515f, 0.29183692f, 
    0.05844518f, 0.02032236f, 0.38464105f, -0.24353398f, 0.22406743f, 0.30964833f, -0.05733300f, -0.03819681f, 
    -0.39195326f, 0.02330932f, -0.34003353f, 0.07445110f, 0.38934442f, -0.27073851f, -0.10367586f, -0.11855987f, 
    0.44845521f, 0.03649615f, 0.01718829f, 0.36831170f, 0.31627625f, -0.09743074f, -0.02214828f, -0.21155557f, 
    -0.07877025f, -0.09070957f, 0.03106966f, -0.06897889f, -0.06538924f, 0.16804732f, 0.10477637f, -0.14408852f, 
    -0.04825621f, -0.01237710f, 0.11829361f, -0.19285402f, 0.31798920f, 0.08358570f, -0.13406512f, 0.29004222f, 
    0.02404505f, 0.27582857f, -0.24156187f, 0.16921586f, 0.10770969f, -0.33111173f, -0.04043161f, -0.42408043f, 
    0.07960755f, 0.03288601f, -0.11669394f, 0.42870674f, 0.05968091f, -0.00394153f, 0.04373033f, -0.24615940f, 
    0.14236531f, 0.01785742f, 0.13851501f, 0.02476554f, -0.37365687f, -0.07751254f, 0.10771107f, 0.11384813f, 
    -0.07808618f, -0.10738703f, 0.09810112f, -0.07439463f, 0.16056986f, 0.27607858f, -0.10566271f, -0.26462650f, 
    0.24062149f, 0.11756157f, -0.08486210f, 0.27279997f, 0.22530374f, -0.30336475f, -0.05255278f, 0.29034472f, 
    -0.22151823f, 0.01706745f, -0.17677703f, 0.22348042f, -0.42420033f, 0.16187605f, 0.04922480f, -0.10638658f, 
    0.03394936f, -0.22092301f, 0.08508871f, 0.01664668f, -0.77698660f, -0.28180879f, -0.13372415f, -0.38452601f, 
    -0.16789815f, 0.15398309f, 0.23791309f, -0.02896190f, 0.23732074f, -0.03879521f, 0.08574852f, -0.35748059f, 
    -0.28155980f, 0.01211503f, -0.44939664f, 0.00094726f, 0.26571643f, -0.23592243f, -0.62216759f, -0.23201814f, 
    0.20246197f, -0.08895910f, 0.06542349f, -0.14156508f, 0.39599845f, -0.15586896f, -0.12112959f, 0.17590907f, 
    -0.07424300f, -0.00790089f, -0.13695303f, -0.08778379f, -0.38670665f, 0.26872817f, 0.05328158f, 0.01060849f, 
    -0.09051582f, 0.13102606f, -0.23314731f, 0.19125447f, 0.10628867f, -0.34446269f, -0.16021217f, -0.31415281f, 
    0.28120056f, -0.01500290f, -0.08641362f, -0.14522974f, 0.18028395f, 0.14528346f, -0.03526492f, 0.52242196f, 
    -0.33119613f, -0.12695614f, 0.09914057f, -0.53688252f, 0.13173370f, 0.11070563f, 0.01321112f, 0.32363540f, 
    0.03413488f, -0.40895289f, 0.09019590f, 0.07289357f, 0.19917901f, -0.01110964f, -0.08951060f, 0.24970101f, 
    -0.14780377f, -0.12182388f, -0.16924690f, 0.06324727f, -0.06723733f, 0.61306727f, 0.16347633f, 0.10308495f, 
    0.41464254f, -0.07252453f, 0.19354825f, 0.26687172f, 0.36203989f, -0.02216844f, 0.57139015f, 0.17414075f, 
    -0.21795388f, -0.00827890f, -0.07868626f, 0.23087551f, -0.19031681f, 0.05807787f, 0.12525113f, 0.17956710f, 
    0.43740216f, -0.36966357f, -0.08064455f, -0.09995522f, 0.19402757f, -0.20212239f, 0.14023022f, -0.20732269f, 
    0.12216870f, 0.13676372f, -0.09201473f, -0.18388650f, -0.14781441f, 0.07703865f, 0.13358459f, 0.10159409f, 
    -0.00618634f, 0.00881179f, -0.16527542f, -0.02682521f, -0.10531418f, 0.00980457f, -0.15722041f, -0.16684413f, 
    -0.12352042f, 0.03210410f, 0.14661001f, 0.06788535f, -0.09874391f, 0.16748196f, 0.01348851f, -0.16459152f, 
    -0.01586269f, 0.04278425f, -0.01481588f, 0.10090139f, 0.05801917f, -0.06920456f, -0.02301623f, -0.13836725f, 
    0.13261873f, 0.08362326f, -0.00708400f, -0.03502193f, -0.05110395f, -0.09824734f, 0.08106324f, 0.25245395f, 
    0.13243417f, 0.17103918f, 0.25676939f, 0.18459252f, -0.26017782f, 0.00032028f, 0.26030371f, 0.10098232f, 
    -0.11338546f, 0.04506637f, -0.11596013f, -0.20730919f, -0.15711962f, 0.01243111f, 0.15854558f, 0.19398154f, 
    0.34165177f, 0.13249703f, 0.12927502f, -0.06559603f, -0.03653114f, -0.28233895f, 0.08151082f, 0.23272344f, 
    0.00408507f, 0.05250234f, -0.11463044f, 0.11046556f, -0.07668588f, 0.19201317f, 0.06395791f, 0.10118316f, 
    0.15322219f, 0.08052064f, 0.04173801f, -0.40739751f, 0.12945470f, 0.22212990f, 0.00158074f, 0.21588202f, 
    -0.44511411f, -0.11031210f, -0.10348441f, -0.07456958f, 0.39143881f, -0.03884810f, 0.02674132f, 0.15523219f, 
    0.11502346f, 0.34041232f, 0.07929406f, -0.16780995f, -0.14039272f, 0.26074767f, 0.01879343f, -0.12309082f, 
    0.15131609f, -0.05534103f, 0.16371664f, 0.01041515f, 0.06626301f, 0.25639638f, 0.06881581f, 0.21573865f, 
    -0.00058266f, 0.24761213f, 0.24801311f, 0.36471641f, -0.08117390f, -0.34404966f, 0.29349789f, 0.30298328f, 
    -0.16735196f, 0.12369353f, 0.03068955f, 0.07174554f, -0.51515085f, 0.14439513f, 0.10007615f, 0.13280617f, 
    0.28128672f, -0.04552433f, -0.09591351f, -0.05836926f, -0.43471220f, -0.17635381f, -0.17295136f, -0.05230030f, 
    0.10725176f, -0.16157542f, -0.44642931f, 0.05696069f, 0.02363371f, -0.04893133f, 0.10251380f, -0.18757220f, 
    0.19641854f, -0.25048846f, -0.02149670f, -0.07873491f, 0.12206207f, 0.22796549f, 0.51634520f, -0.01783910f, 
    -0.00905940f, -0.09392717f, 0.06929615f, -0.86676186f, -0.01807244f, -0.15257482f, -0.06487068f, 0.30090311f, 
    0.32308778f, 0.09652660f, -0.14799571f, -0.03377020f, -0.11377149f, 0.09719766f, 0.08566796f, -0.03282336f, 
    -0.12395137f, -0.01522460f, -0.15010665f, -0.00121210f, 0.07800872f, 0.04066992f, -0.17503318f, -0.00693965f, 
    -0.10212635f, 0.05699421f, -0.01138454f, -0.09884837f, -0.06928805f, 0.01454060f, 0.10820900f, -0.09990379f, 
    -0.16983694f, -0.08587521f, 0.03740760f, 0.00788251f, -0.13982189f, -0.04090619f, 0.08177382f, 0.14956997f, 
    -0.14728159f, -0.06880949f, 0.04982065f, -0.04485301f, -0.17616490f, -0.04530497f, 0.11685146f, -0.06595837f, 
    -0.10936045f, -0.06265768f, -0.09489826f, -0.26545295f, 0.19849533f, -0.56165844f, -0.16274242f, 0.29457197f, 
    -0.01324510f, 0.32564628f, 0.34294453f, 0.00397572f, 0.15766411f, -0.33098805f, 0.07136185f, 0.05324386f, 
    0.03967462f, -0.06253413f, -0.16486344f, 0.29020283f, -0.19175144f, -0.05711940f, -0.11316624f, 0.04462632f, 
    0.36048615f, -0.24316722f, -0.16049838f, -0.05503941f, -0.08105613f, -0.22632471f, 0.12966068f, 0.11006014f, 
    -0.02138896f, 0.07329310f, -0.07700476f, 0.14242405f, 0.01547868f, 0.12401818f, -0.15853180f, 0.23400380f, 
    0.40094110f, 0.16628841f, -0.01961297f, -0.02400751f, 0.04558822f, -0.26513085f, -0.60730737f, -0.09618063f, 
    -0.07999519f, -0.00990318f, -0.03531746f, -0.05297524f, 0.04638839f, -0.09818053f, -0.15452506f, -0.20753236f, 
    -0.31211230f, 0.20050955f, 0.15127747f, -0.11082252f, 0.14648798f, -0.09581175f, 0.06193545f, -0.35786361f, 
    0.17506956f, 0.02367161f, 0.00175337f, 0.01874986f, -0.10077356f, -0.13255566f, 0.10481477f, 0.03496678f, 
    -0.09353035f, -0.11778494f, -0.17494228f, 0.00851700f, -0.13741887f, -0.11229476f, 0.11283031f, 0.03305103f, 
    0.09170274f, -0.15322948f, 0.16087219f, -0.04006042f, 0.15119536f, -0.11104254f, 0.12750831f, 0.00293352f, 
    0.06633767f, -0.00685856f, -0.03442797f, -0.07885812f, 0.11587664f, 0.04622782f, -0.07403697f, -0.11559464f, 
    -0.13722380f, 0.02681548f, -0.05615016f, 0.23028409f, 0.18024963f, -0.00061755f, 0.03376181f, -0.04466671f, 
    -0.06757712f, 0.04357499f, -0.21057706f, 0.26743987f, 0.25547177f, -0.01271917f, -0.12732707f, -0.24586253f, 
    -0.04305241f, 0.01431087f, 0.00753447f, -0.12151515f, 0.21500647f, -0.05329400f, 0.04834702f, 0.16426370f, 
    -0.43172270f, 0.22181624f, -0.16860901f, -0.04297147f, 0.05357227f, 0.10417613f, -0.04277027f, 0.11416011f, 
    -0.09846961f, 0.06045363f, 0.18728459f, 0.20667183f, 0.05022986f, 0.09097842f, -0.09652664f, 0.03388965f, 
    -0.09173418f, 0.12662654f, -0.21406984f, -0.08119752f, 0.20928904f, 0.08082139f, -0.11983269f, 0.10282491f, 
    -0.03030389f, 0.15876053f, -0.04126178f, -0.19946562f, 0.55605626f, 0.16405767f, 0.12777475f, -0.07145151f, 
    -0.10999961f, 0.25467536f, -0.15349807f, -0.17106400f, -0.00666102f, 0.33772632f, 0.13874863f, -0.27127174f, 
    -0.11166202f, -0.15980719f, 0.08718771f, -0.09193623f, 0.48707137f, -0.73010069f, 0.13039619f, -0.13620390f, 
    -0.19830343f, 0.18379134f, -0.14411163f, 0.19842947f, 0.21536468f, -0.01120980f, -0.55374277f, -0.15633179f, 
    0.18403538f, 0.08350828f, 0.12145867f, -0.23406215f, 0.35361314f, 0.15209155f, -0.05678793f, 0.10559838f, 
    -0.38828546f, -0.02704186f, 0.08694786f, 0.03317513f, -0.12522317f, 0.11249884f, 0.02180289f, 0.30505559f, 
    -0.02495907f, 0.06717426f, 0.12974752f, 0.06193176f, 0.02916434f, 0.21477851f, -0.14670973f, 0.40681493f, 
    0.01143793f, 0.21799280f, 0.01941640f, -0.17365201f, 0.07502789f, -0.11161620f, -0.43909901f, -0.11365562f, 
    -0.13479051f, -0.13620816f, -0.03983489f, 0.16858040f, -0.07336468f, 0.08192927f, 0.12836310f, -0.10789713f, 
    -0.24380280f, 0.32034764f, -0.12373880f, -0.13580705f, 0.13373908f, -0.03932656f, 0.13203155f, -0.50841492f, 
    -0.11506797f, -0.06677210f, -0.04051637f, -0.21951936f, -0.05434856f, 0.56707269f, 0.00647638f, 0.21931151f, 
    0.28806427f, -0.00034914f, -0.03970066f, 0.01851209f, 0.12900929f, -0.09226444f, 0.51087731f, -0.30858144f, 
    0.00755468f, -0.12873924f, 0.20259228f, 0.13089710f, -0.16036345f, 0.03535403f, -0.05442009f, -0.29260564f, 
    0.22415794f, 0.18013658f, 0.01780694f, -0.13593379f, 0.20108049f, 0.15259667f, 0.11911909f, -0.06278946f, 
    -0.10136709f, 0.02114920f, 0.22469606f, 0.11051630f, 0.12101406f, -0.54966807f, -0.04053903f, -0.12838443f, 
    0.29145879f, 0.02653157f, 0.27172744f, 0.08888681f, 0.22513901f, -0.33761403f, -0.08644786f, 0.10973810f, 
    -0.03583597f, -0.04485530f, 0.13746454f, -0.71266800f, -0.23542155f, -0.16061635f, -0.00219559f, 0.07196742f, 
    0.18865918f, -0.35021943f, 0.09688254f, 0.07564186f, -0.20503588f, -0.18923534f, 0.03783774f, 0.18871099f, 
    0.11043862f, -0.02003096f, 0.11376332f, -0.08567731f, 0.23585634f, -0.43878049f, 0.15395951f, 0.03725000f, 
    0.02615231f, 0.25072894f, 0.19151780f, 0.05823987f, 0.34053695f, -0.40892649f, 0.43869540f, -0.00690303f, 
    0.37587115f, -0.05871867f, -0.18355270f, -0.06363894f, -0.11566959f, 0.04671863f, 0.03610058f, -0.30332559f, 
    0.35240543f, -0.38212669f, 0.04000214f, -0.15770583f, -0.15412454f, -0.01557268f, -0.00373526f, 0.18635631f, 
    -0.11761621f, -0.03815914f, 0.11466631f, 0.05652222f, 0.30429798f, -0.61331725f, -0.00804572f, 0.11337376f, 
    -0.10394198f, 0.27872476f, -0.20773821f, -0.13293177f, -0.00777460f, -0.00284421f, 0.08263251f, 0.06426797f, 
    -0.22044405f, -0.13318872f, 0.18210851f, -0.24391241f, 0.27849877f, 0.04626350f, -0.04953603f, 0.00305072f, 
    0.08564161f, 0.35308975f, 0.01017511f, -0.14995308f, -0.07860908f, 0.12325544f, 0.13623288f, -0.00135086f, 
    0.01652215f, 0.16367310f, 0.14815822f, -0.06542405f, -0.19302014f, -0.29164907f, 0.05322670f, 0.11121772f, 
    0.26112723f, -0.02806092f, 0.19229132f, -0.04237453f, 0.01807479f, -0.16754946f, -0.05971338f, 0.13914910f, 
    0.22728884f, 0.13749252f, -0.15623809f, 0.18498874f, -0.30588776f, -0.11186016f, -0.06700087f, -0.05574933f, 
    0.21137375f, 0.10064921f, -0.01468579f, 0.12496851f, -0.39179501f, -0.04809870f, 0.11505272f, 0.11575262f, 
    -0.00382604f, -0.06886484f, -0.08994192f, 0.00786921f, -0.16941068f, -0.17085274f, 0.12338161f, 0.00334026f, 
    0.06091610f, 0.08136772f, -0.13996883f, 0.02729683f, 0.02264952f, 0.03490536f, -0.06923793f, 0.02425717f, 
    0.05515675f, -0.14221314f, 0.00896487f, -0.18812221f, -0.09828816f, -0.08367682f, -0.05321550f, -0.11384650f, 
    0.02219143f, -0.03149035f, 0.11790353f, -0.17301597f, -0.16452028f, -0.20133922f, 0.09543122f, 0.10447064f, 
    -0.03113200f, 0.05637442f, -0.15228616f, -0.14042252f, -0.02121875f, -0.13772784f, -0.09192079f, 0.04507842f, 
    -0.16524383f, -0.13256891f, -0.03663326f, -0.12652616f, -0.00606242f, 0.09486112f, -0.00748971f, -0.12985495f, 
    -0.08109684f, -0.16051072f, 0.05094195f, -0.03125143f, 0.12065155f, 0.02773819f, -0.08199292f, -0.16827630f, 
    0.17102015f, 0.07133099f, -0.09728336f, -0.02911587f, 0.06244689f, -0.17468849f, 0.14696117f, 0.06649659f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07617658f, 0.17692579f, -0.11424196f, 0.14092064f, 0.33938250f, 0.26492900f, 0.16319582f, 0.04069565f, 
    -0.25536609f, 0.27025473f, 0.30234879f, 0.12134654f, 0.03097763f, -0.21107483f, 0.16253544f, -0.25200316f, 
    -0.20372406f, 0.03843763f, 0.13351247f, -0.11533814f, -0.06746660f, 0.01294969f, 0.13060974f, 0.18848346f, 
    -0.01257685f, -0.22057888f, -0.04073903f, 0.07916254f, 0.13281712f, 0.17235446f, 0.03126068f, -0.00671398f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.08753791f, -0.11370426f, 0.01894517f, 0.04623487f, -0.17492288f, 0.13789685f, -0.12044221f, -0.22148810f, 
    -0.04907059f, 0.09005369f, -0.12670222f, -0.03662736f, 0.14405373f, 0.00332652f, -0.08172984f, 0.03652852f, 
    -0.03169453f, 0.11873996f, -0.21510130f, -0.01678627f, -0.12876375f, -0.08840990f, -0.11335113f, -0.16861524f, 
    0.06622081f, 0.03560547f, -0.10619734f, 0.11240105f, -0.10126198f, 0.05105964f, 0.15821016f, -0.16351756f, 
    0.08018223f, 0.03095005f, 0.12279640f, 0.12708952f, -0.20735459f, 0.11605050f, -0.09341776f, -0.10238960f, 
    0.05468237f, -0.12556750f, 0.03014017f, 0.04075171f, -0.00391298f, -0.12020640f, -0.07902473f, 0.02342098f, 
    -0.01177196f, 0.01978008f, -0.00728802f, -0.08848212f, -0.00445764f, -0.07923269f, -0.23242348f, -0.11603322f, 
    -0.15543696f, 0.08584764f, -0.10473941f, -0.15474819f, 0.17046969f, -0.05952540f, 0.14350462f, 0.04943743f, 
    0.07785603f, -0.02579902f, 0.03171807f, 0.08135505f, -0.02034196f, -0.08346442f, 0.65276903f, 0.27842069f, 
    -0.32761672f, 0.86300015f, 0.08645283f, -0.55741990f, -0.07775764f, 0.12753738f, -0.11537120f, -0.05341031f, 
    -0.64772779f, 0.14167486f, -0.21676072f, -0.10483441f, 0.15382582f, 0.15775478f, 0.12867086f, 0.36158961f, 
    -0.30497682f, -0.07712648f, 0.12228480f, 0.08092912f, 0.22104679f, 0.00373094f, -0.13713858f, 0.07550105f, 
    0.14131044f, 0.19207563f, -0.13991682f, 0.09829054f, 0.14650761f, -0.04852077f, -0.09147859f, 0.13089480f, 
    -0.15394676f, -0.18506257f, 0.13935766f, 0.30059272f, 0.11462279f, -0.17014943f, -0.02598257f, 0.17569800f, 
    0.15791859f, -0.01395571f, 0.71673477f, 0.15108027f, -0.11852100f, -0.09274954f, -0.20696734f, -0.22549976f, 
    0.24065375f, -0.07397425f, 0.16841663f, 0.37821868f, 0.01321309f, -0.08085849f, -0.06846993f, -0.10782911f, 
    -0.13332765f, 0.14177711f, -0.14354266f, -0.01541474f, 0.17587687f, 0.50033528f, -0.23188613f, -0.15715016f, 
    -0.33734137f, 0.17598103f, 0.38455161f, 0.08841132f, -0.13581254f, -0.12084267f, 0.04857585f, -0.13578656f, 
    -0.68425953f, 0.09380765f, -0.17011258f, -0.10324035f, -0.11227924f, 0.14650434f, -0.01055448f, 0.21569079f, 
    -0.20341104f, -0.29985103f, -0.16185984f, -0.02776936f, -0.06889468f, 0.21192776f, 0.03012164f, 0.05427244f, 
    -0.04051106f, 0.23323095f, 0.15173233f, 0.05955334f, 0.06979627f, 0.08272117f, -0.06750693f, -0.22624560f, 
    -0.00440837f, -0.41064620f, 0.25655586f, 0.39013588f, 0.04922722f, -0.01814948f, 0.00732990f, -0.18074818f, 
    0.48657688f, -0.04793498f, -0.00318933f, -0.02619203f, 0.10780744f, 0.04885921f, 0.00708979f, -0.00246733f, 
    0.02936137f, 0.35658219f, 0.26473567f, 0.29528943f, 0.04125380f, -0.15325186f, -0.06612149f, -0.15185848f, 
    0.01442600f, 0.20090637f, 0.01953812f, -0.11026876f, 0.12361366f, -0.14801554f, 0.55385172f, 0.40410334f, 
    -0.09735556f, 0.54980850f, -0.27214667f, -0.14158447f, 0.12189935f, -0.12755153f, 0.22278787f, -0.56326813f, 
    -0.26325703f, -0.10876051f, -0.10284663f, -0.44358006f, -0.01068863f, 0.17851527f, 0.05831642f, 0.21904576f, 
    0.02863833f, 0.10182527f, -0.11958575f, 0.29895952f, 0.12301881f, 0.09500959f, -0.02426636f, -0.09843201f, 
    -0.14153969f, -0.05801305f, 0.13033666f, 0.10359358f, -0.13514900f, -0.07559393f, -0.14498636f, 0.00074113f, 
    -0.04199057f, 0.03769205f, -0.04417849f, 0.01535782f, 0.06902926f, -0.14265838f, 0.08938442f, -0.14369977f, 
    0.01307937f, -0.12266998f, -0.05885591f, -0.12720467f, 0.13722435f, -0.12619233f, -0.18422674f, 0.11872341f, 
    -0.04934342f, -0.06474368f, 0.02893130f, 0.04125666f, -0.18068323f, 0.05057490f, 0.12144380f, 0.06907506f, 
    -0.00936130f, -0.00996802f, -0.07929936f, -0.04044978f, 0.13432270f, -0.01211736f, 0.34196591f, 0.39832079f, 
    -0.81117034f, 0.38411960f, -0.07154095f, -0.02670714f, 0.11637006f, -0.23305447f, 0.25861967f, -0.62122273f, 
    0.08775883f, 0.07998473f, -0.07154689f, -0.31721592f, -0.01688613f, 0.18705845f, 0.23238529f, 0.30797863f, 
    -0.05236424f, -0.16230947f, -0.33660635f, -0.22401689f, 0.28132737f, -0.52470428f, 0.02450223f, 0.14370209f, 
    -0.10222983f, 0.27675343f, 0.14666967f, 0.12860426f, 0.42839611f, -0.05528316f, -0.20653491f, -0.20767309f, 
    -0.35876843f, -0.36738005f, -0.01688682f, 0.31423715f, 0.09019807f, -0.08584060f, 0.24446979f, -0.19440551f, 
    -0.15963611f, 0.03285827f, -0.18368861f, 0.14385980f, -0.06939920f, -0.16711786f, 0.24669552f, -0.47943887f, 
    0.21995713f, 0.17781094f, -0.22599298f, -0.16797982f, 0.09152228f, 0.12151995f, -0.11047970f, -0.06112301f, 
    -0.13407402f, 0.36504272f, 0.00896827f, -0.14037962f, 0.14593136f, -0.08002472f, 0.13123648f, 0.06784636f, 
    1.00304711f, -0.03949407f, 0.21474564f, 0.35825881f, -0.16063333f, 0.07571226f, -0.29042736f, 0.34772372f, 
    0.13617331f, 0.13203448f, 0.54866093f, -0.14428774f, -0.06487929f, 0.00171828f, -0.23371725f, -0.02803542f, 
    0.03197424f, -0.06381882f, 0.29972568f, 0.44484359f, -0.24918248f, 0.06811414f, -0.09820904f, -0.13765985f, 
    -0.10525496f, 0.40736651f, -0.18529370f, 0.01965116f, 0.25069711f, 0.19317310f, 0.38061354f, 0.15338685f, 
    0.30518588f, 0.23449866f, -0.15458913f, 0.24654065f, -0.13514839f, -0.52370834f, -0.08114079f, 0.07005795f, 
    -0.14788005f, -0.12605754f, -0.15323009f, 0.34677118f, -0.09874985f, 0.09155034f, 0.07647384f, -0.27140057f, 
    0.17580612f, 0.01288229f, -0.35620669f, -0.08700133f, -0.33090851f, -0.50451475f, 0.01929144f, 0.14873153f, 
    0.04188074f, 0.33523315f, -0.05004486f, 0.08852221f, -0.10320248f, 0.30159810f, 0.14196904f, -0.05263454f, 
    0.35430419f, 0.46014071f, 0.19378957f, -0.07824574f, -0.06681805f, -0.27228227f, -0.28972411f, -0.05466696f, 
    -0.39601827f, -0.09190059f, 0.34003386f, -0.57974458f, 0.04912219f, -0.08696666f, 0.00679641f, 0.18984303f, 
    -0.55121940f, -0.12195882f, 0.52321225f, 0.42341092f, -0.13725683f, 0.06347933f, 0.11797414f, -0.15555012f, 
    0.10964545f, -0.04043161f, 0.04373763f, -0.04536068f, 0.20210959f, -0.53324217f, 0.15780285f, 0.55225104f, 
    -0.04461823f, -0.09935351f, -0.36520082f, 0.17267706f, -0.07576942f, 0.07935023f, 0.12109014f, 0.26672223f, 
    0.10729256f, -0.04789641f, 0.20584704f, -0.08409543f, 0.04443382f, 0.12970226f, -0.03764678f, -0.12494238f, 
    -0.05534109f, 0.55347008f, -0.35337612f, 0.24740465f, 0.22897834f, -0.01930650f, 0.06926304f, -0.06364819f, 
    0.00796849f, 0.07227516f, 0.12554538f, -0.11577958f, 0.16137420f, 0.53593934f, -0.15421587f, -0.33613977f, 
    -0.21302798f, 0.06937709f, 0.54355013f, 0.04682538f, -0.07648119f, 0.08004731f, 0.10653538f, -0.37608442f, 
    0.25919133f, 0.09998535f, -0.47886044f, 0.61928791f, -0.14832373f, 0.06550423f, 0.04925862f, 0.08811083f, 
    0.13000628f, -0.12421492f, 0.03252457f, -0.47569984f, 0.09233899f, 0.00525694f, -0.10870218f, 0.06042930f, 
    0.04171943f, 0.03087424f, -0.10808092f, 0.16399802f, 0.14243150f, 0.02099228f, -0.07194488f, 0.30024785f, 
    -0.10574917f, -0.14487591f, -0.01478879f, -0.07950132f, 0.11112627f, 0.11656613f, 0.13542971f, 0.29515988f, 
    -0.27552933f, -0.07584930f, 0.64460593f, 0.01471813f, -0.16325851f, -0.05936099f, -0.08522800f, 0.21492754f, 
    -0.08808403f, -0.33519402f, 0.10744495f, 0.10603191f, 0.16285506f, 0.18710829f, 0.07893278f, -0.14705253f, 
    -0.06470686f, 0.12693053f, -0.14920904f, -0.01545162f, -0.06622767f, 0.21618564f, 0.66238147f, 0.26084703f, 
    -0.17018487f, 0.91042054f, 0.00460777f, 0.01156819f, 0.14534214f, -0.24567877f, -0.00643001f, -0.68219036f, 
    -0.21469523f, 0.16930555f, -0.45072520f, -0.52513373f, -0.14107181f, 0.20423715f, 0.26907259f, 0.34784687f, 
    -0.08274917f, 0.07144859f, 0.02389162f, -0.03871726f, -0.07496203f, 0.09553593f, 0.08780820f, -0.12536730f, 
    0.11977052f, 0.60335374f, -0.10888354f, -0.03660287f, -0.00156939f, 0.27489853f, 0.25102514f, 0.00142282f, 
    0.43069214f, 0.13874374f, -0.10645559f, 0.36271518f, -0.12342751f, -0.14061515f, -0.08565991f, 0.06423768f, 
    -0.13865981f, -0.14310001f, 0.17533235f, -0.50134599f, -0.04104661f, 0.07709886f, 0.12013026f, -0.24675003f, 
    -0.27601814f, 0.04049339f, -0.14020060f, 0.39296007f, -0.36579701f, 0.29293197f, -0.05990693f, 0.11755703f, 
    0.01885613f, 0.21394563f, -0.04660867f, -0.09778952f, 0.39667404f, -0.07961773f, -0.27028692f, -0.11243971f, 
    0.15921481f, -0.43159217f, 0.02696372f, 0.46328741f, -0.06385362f, 0.01375364f, 0.25488582f, 0.71724230f, 
    0.17152509f, -0.06192093f, 0.46356326f, 0.59310538f, 0.09012575f, -0.14912081f, 0.01760446f, -0.41090956f, 
    0.39968053f, 0.20550089f, 0.03597232f, 0.16779004f, 0.04430952f, 0.23770452f, -0.09894697f, -0.10104655f, 
    -0.00415005f, 0.06499577f, -0.14885215f, 0.02461808f, -0.14017984f, -0.04301223f, -0.08871237f, 0.03773906f, 
    0.11835688f, 0.12586170f, -0.15169987f, -0.11154380f, -0.03968170f, -0.02025518f, -0.18668801f, -0.07454863f, 
    -0.00122154f, -0.13215382f, 0.03191872f, -0.13598740f, 0.10780489f, -0.11032942f, -0.15690571f, 0.00915300f, 
    0.03616434f, 0.05988575f, 0.10415749f, 0.06311221f, -0.10525269f, -0.11805980f, -0.13565262f, -0.05370657f, 
    -0.16065508f, 0.06200802f, 0.09027228f, 0.12167513f, -0.02171517f, 0.01668965f, 0.36341867f, 0.47395310f, 
    0.23506659f, 0.14305629f, -0.26787266f, -0.21799363f, -0.12965596f, -0.04106646f, -0.16542837f, -0.14782317f, 
    -0.44341737f, -0.10462542f, 0.62900460f, -0.04054417f, 0.05188026f, -0.05084515f, 0.01152491f, 0.26949576f, 
    -0.04431749f, -0.03772612f, -0.14457151f, 0.43591872f, 0.06925311f, -0.17979151f, -0.04686598f, 0.05312832f, 
    0.17908411f, -0.13406315f, 0.16728728f, 0.07512359f, 0.33265349f, -0.42172393f, 0.21236332f, 0.41443831f, 
    -0.66027170f, 0.29907557f, -0.50957000f, -0.36518067f, -0.13673274f, -0.39126247f, 0.12462822f, -0.13687867f, 
    -0.57088858f, 0.15317990f, 0.06806865f, 0.22686480f, 0.02862595f, -0.08537213f, 0.09262209f, 0.08212321f, 
    0.14530876f, 0.27113435f, -0.27273858f, 0.22671804f, 0.17897782f, 0.33974549f, -0.12026806f, -0.17527515f, 
    0.15057431f, -0.30739525f, -0.01696884f, -0.12658925f, -0.15005477f, 0.03306529f, -0.34129068f, -0.27540195f, 
    -0.17311721f, -0.42786437f, 0.35768601f, 0.12480430f, 0.03537928f, 0.05970057f, -0.02653321f, -0.21706051f, 
    0.91888595f, 0.15107399f, 0.40767714f, 0.52889949f, -0.06238012f, -0.00724964f, 0.17576590f, 0.20727055f, 
    0.09793956f, -0.06639510f, 0.47038439f, 0.42608243f, 0.34963402f, -0.24523661f, 0.12812294f, -0.05569920f, 
    0.03172791f, -0.00903334f, -0.00712328f, 0.15050806f, -0.04054653f, 0.47466624f, -0.02402046f, -0.36805999f, 
    -0.14701271f, 0.07986509f, 0.33225462f, -0.20959085f, -0.02848256f, 0.05326382f, 0.06730951f, -0.36207923f, 
    0.05191325f, -0.11632924f, 0.03382150f, -0.03216200f, -0.05177731f, 0.04110474f, 0.18112348f, 0.28364262f, 
    -0.21723901f, -0.25027868f, 0.25468412f, 0.17228135f, 0.22392488f, -0.03130570f, 0.00419378f, 0.16576195f, 
    0.09420397f, 0.06233380f, 0.16549636f, -0.07230799f, 0.00754013f, 0.06446581f, 0.01294216f, -0.13783678f, 
    0.35337427f, 0.51062769f, 0.28852215f, 0.14478089f, 0.07758547f, 0.27285847f, -0.17615950f, 0.47961751f, 
    -0.01251220f, 0.04650207f, 0.22845022f, -0.32715210f, 0.01268115f, 0.07397415f, -0.22884691f, 0.12684406f, 
    -0.26482740f, -0.52636611f, 0.50390625f, -0.11483107f, -0.18368347f, 0.14476603f, -0.08773297f, 0.17410083f, 
    0.08026761f, -0.32597893f, -0.02250247f, -0.06094273f, -0.08080680f, -0.37142897f, -0.22379920f, 0.18112561f, 
    -0.31753033f, -0.10668082f, -0.22628461f, 0.09966181f, -0.10960552f, 0.33286273f, -0.00594697f, -0.22854136f, 
    0.14938201f, -0.04373581f, 0.21352206f, 0.03607278f, -0.07872954f, 0.16163813f, 0.16242795f, 0.14476414f, 
    0.42506561f, 0.21338110f, -0.39785606f, -0.02508462f, 0.21153396f, 0.03106942f, -0.12281690f, -0.13274865f, 
    -0.06113583f, -0.12210608f, 0.07863886f, 0.05736385f, -0.16740288f, 0.07265025f, 0.31543779f, 0.12501447f, 
    0.29898357f, 0.02390058f, 0.15475655f, 0.21606976f, 0.12654318f, -0.14297977f, -0.10099234f, 0.16231525f, 
    0.44358060f, -0.04397339f, 0.26288879f, 0.73888278f, -0.03130763f, -0.11956400f, 0.01553588f, 0.09033423f, 
    -0.04695915f, -0.16046016f, 0.48900467f, 0.23601511f, -0.15797958f, 0.02510634f, 0.04789596f, -0.06413761f, 
    -0.08904849f, -0.14870214f, -0.03406443f, -0.03564747f, -0.00601345f, -0.13236949f, -0.11742719f, -0.06084614f, 
    -0.10653163f, -0.06945916f, -0.03952413f, -0.04094790f, 0.04894094f, -0.14742450f, -0.08180945f, -0.04374263f, 
    0.01902431f, 0.03113301f, -0.09012247f, 0.10786123f, -0.08559007f, 0.13673045f, 0.09719699f, -0.17343332f, 
    -0.14533441f, 0.00988706f, 0.10257533f, -0.04483733f, -0.03036858f, 0.14971197f, 0.07233139f, -0.01798328f, 
    0.16818553f, -0.13968574f, 0.05488744f, 0.02635194f, 0.01927724f, 0.07331775f, -0.16423056f, -0.19719550f, 
    -0.12745838f, 0.10846373f, -0.09553712f, -0.18668929f, -0.16266583f, -0.16017282f, -0.19041824f, 0.14303267f, 
    -0.05841163f, 0.07683503f, 0.07259724f, -0.10758238f, -0.08927992f, -0.11630069f, 0.04420567f, -0.14157966f, 
    -0.04779815f, -0.01045314f, 0.06678946f, 0.14590572f, 0.07529578f, 0.11842478f, -0.14653888f, 0.09792529f, 
    -0.08259065f, -0.27750593f, -0.10051939f, -0.19529550f, -0.02925091f, -0.07628562f, 0.17906716f, 0.15550883f, 
    0.17262480f, 0.42144576f, -0.18687694f, -0.24974751f, -0.03989826f, -0.12528324f, 0.23004453f, -0.06442822f, 
    0.16213156f, 0.12939067f, 0.35217017f, -0.14239942f, -0.00979078f, 0.10186696f, 0.16905920f, 0.38296407f, 
    0.00549607f, -0.24099663f, -0.07366970f, 0.23925349f, 0.33935568f, -0.05986651f, 0.06908521f, 0.13296030f, 
    0.18631929f, -0.06076418f, 0.09901353f, -0.06181720f, 0.15319832f, 0.32475525f, 0.19196156f, -0.35980982f, 
    -0.19249132f, 0.11750308f, 0.33277115f, -0.01212903f, 0.13213840f, -0.49930182f, 0.10648087f, -0.19480996f, 
    0.02632093f, 0.04121414f, -0.50846541f, -0.15131335f, 0.12856427f, 0.33632535f, 0.24120627f, 0.21178044f, 
    -0.24004461f, -0.12085638f, -0.03907391f, -0.00498164f, 0.15614669f, -0.16963691f, -0.01849477f, -0.07873519f, 
    0.11148842f, -0.18376724f, 0.02029926f, -0.02471173f, 0.29204014f, 0.29051980f, -0.48317435f, -0.21813674f, 
    -0.18455528f, -0.26096496f, 0.51283711f, 0.03004594f, -0.09340821f, -0.23356618f, 0.29998055f, -0.34347802f, 
    0.84466654f, 0.08898917f, -0.24804610f, 0.56029636f, -0.10899553f, 0.11668891f, 0.21129018f, -0.04603506f, 
    0.36212555f, -0.27682137f, 0.14992440f, -0.44923514f, 0.33570743f, 0.11539963f, 0.10619190f, 0.12548070f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04407785f, -0.20201057f, 0.35782981f, 0.07806324f, 0.19143084f, 0.16407897f, -0.19242318f, -0.09069753f, 
    0.13103740f, 0.23251133f, -0.14067559f, 0.00778507f, 0.05648780f, -0.01525038f, 0.16957118f, 0.05803508f, 
    0.16718803f, 0.12346563f, 0.20152350f, 0.09408139f, -0.07711384f, 0.16322410f, 0.27459005f, 0.53112429f, 
    0.13899203f, 0.17726249f, -0.21422935f, -0.16106865f, 0.00034146f, 0.13830087f, 0.55178487f, 0.23904307f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.00009298f, -0.00166479f, 0.19250159f, 0.02546558f, -0.11123388f, 0.10987334f, -0.30839235f, 0.00674757f, 
    0.34995562f, -0.09581653f, 0.20438460f, 0.23260114f, 0.03364091f, 0.16481060f, -0.25126591f, 0.10689271f, 
    -1.01482630f, 0.20020013f, 0.35493243f, -0.00044971f, -0.13340746f, -0.39553896f, -0.10625144f, -0.48503318f, 
    0.31838563f, -0.04139102f, -0.01410317f, -0.07214338f, -0.03828793f, -0.46404865f, -0.84565634f, -0.35612431f, 
    -0.05230978f, -0.14748296f, -0.02291327f, 0.27148312f, -0.07123595f, 0.09315496f, -0.53509706f, -0.11402087f, 
    -0.33654934f, 0.27586535f, -0.09495803f, -0.33107576f, -0.37450740f, -0.10683648f, 0.08899518f, -0.02386618f, 
    -0.53607339f, -0.14451282f, 0.31419113f, -0.06559106f, -0.20974435f, 0.14605530f, 0.34491634f, 0.15816726f, 
    0.07495113f, 0.13692337f, -0.02985818f, 0.09657809f, -0.16400684f, -0.04329149f, 0.00273282f, 0.37157321f, 
    -0.16187494f, -0.06468625f, 0.37537265f, -0.36434558f, 0.09850916f, -0.08611296f, -0.03324855f, -0.08256273f, 
    0.01968963f, -0.57798374f, -0.29671931f, -0.23995487f, 0.38631710f, -0.56397909f, 0.15335998f, -0.09925006f, 
    0.32033867f, -0.10939013f, -0.58114475f, -0.06702464f, -0.15303513f, -0.53919286f, 0.05423752f, 0.37221745f, 
    0.33393422f, -0.13020758f, 0.15479566f, 0.08401225f, 0.15945354f, -0.06761081f, 0.33526692f, -0.23609973f, 
    -0.19836336f, -0.13756543f, -0.02736897f, 0.14024580f, 0.09547593f, -0.12383042f, -0.05645690f, -0.17086948f, 
    -0.30734232f, -0.80277371f, 0.20389327f, -0.17192334f, 0.36603954f, -0.32906058f, -0.02893801f, 0.26275757f, 
    -0.11493476f, 0.00021847f, 0.01070687f, -0.04365534f, 0.28017679f, -0.60151380f, 0.17412724f, 0.21463451f, 
    0.30876443f, -0.49801385f, 0.12582822f, 0.04394772f, -0.00807906f, 0.15869543f, -0.12275814f, -0.17412019f, 
    0.04412723f, 0.01104775f, -0.43606031f, -0.10703631f, 0.08579344f, 0.10556107f, 0.19200128f, 0.04876072f, 
    -0.51599574f, 0.11127184f, 0.11366781f, 0.19941956f, 0.22565202f, 0.26012716f, -0.36677650f, -0.00137955f, 
    -0.03048968f, 0.25310177f, 0.11053023f, 0.12182134f, 0.19799918f, -0.31353879f, -0.13613991f, -0.17565623f, 
    -0.24137528f, 0.28183541f, -0.10030181f, -0.02736490f, -0.08977670f, -0.09114597f, -0.08225910f, -0.64765668f, 
    -0.09265167f, -0.12363210f, -0.40344396f, -0.02042371f, -0.03050753f, 0.26477125f, -0.13866332f, -0.18374513f, 
    0.21113031f, -0.21181458f, 0.12068579f, 0.16089688f, -0.05931868f, 0.02582798f, 0.11857942f, -0.51377022f, 
    0.14852439f, 0.13874049f, -0.06546210f, 0.14321865f, -0.57791597f, -0.51985133f, 0.29021767f, 0.03251052f, 
    -0.13213840f, 0.33282816f, 0.03085105f, 0.13649550f, 0.09974418f, -0.07004441f, 0.15668029f, 0.16696300f, 
    0.10597336f, -0.11380488f, 0.40165061f, -0.68843371f, -0.27610642f, -0.97244543f, 0.17571881f, 0.09646248f, 
    0.29431829f, -0.73791456f, -0.86276364f, -0.29663667f, -0.56274301f, 0.18594339f, -0.45128179f, -0.00719960f, 
    0.14546013f, -0.64864612f, -1.00236714f, -0.11040836f, 0.22670521f, 0.24784340f, -0.23483530f, 0.11571680f, 
    -0.63981390f, 0.09607968f, -0.24553500f, -0.11370063f, -0.02888004f, 0.30369422f, 0.09495725f, -0.22672319f, 
    -0.11481502f, 0.01479932f, -0.14393310f, 0.36779499f, -0.72721016f, -0.10929572f, 0.04924893f, -0.07809640f, 
    0.17050381f, -0.08773191f, -0.14784230f, 0.55188012f, -0.49667913f, 0.37552223f, -0.31119737f, 0.17475638f, 
    -0.20898117f, -0.30783471f, 0.17648755f, 0.16169125f, 0.25646466f, -0.05868825f, 0.03007807f, -0.49703047f, 
    -0.36861417f, 0.15387553f, 0.31718636f, 0.01294414f, -0.13972284f, 0.03678931f, -0.94542187f, -0.24704704f, 
    -0.17677219f, -0.09612554f, -0.02611899f, -0.71390629f, 0.34073687f, -0.20265217f, -0.19166987f, 0.01882112f, 
    0.21694131f, -0.05487255f, -0.64884824f, -0.72309500f, -0.55020261f, -0.37666538f, 0.42876166f, 0.12984312f, 
    -0.10754415f, -0.91428006f, -0.18798305f, -0.14187606f, -0.38566008f, -0.37553316f, 0.27896470f, 0.33801419f, 
    -0.04057854f, -0.17378180f, -0.54112434f, 0.12202944f, 0.06230926f, 0.14629172f, 0.47961918f, 0.53138041f, 
    -0.10310595f, -0.04766393f, 0.18200772f, 0.00216009f, 0.02764444f, -0.15049922f, 0.22295509f, -0.13040881f, 
    0.06551018f, -0.31295180f, -0.06738926f, -0.40415269f, 0.31074065f, -0.01930249f, -0.71497500f, 0.34270966f, 
    -0.05879979f, 0.20433073f, -0.25352770f, -0.06051930f, 0.40362674f, 0.25028461f, 0.18390960f, 0.18982719f, 
    -0.30049306f, -0.17235059f, -0.26858416f, -0.14382343f, 0.10313815f, 0.19455145f, -0.16521904f, -0.51368737f, 
    0.07065143f, 0.07477681f, -0.34650105f, -0.12260220f, 0.23919505f, -0.16548203f, -0.26888829f, 0.13374124f, 
    0.13252845f, 0.48655501f, -0.25787914f, 0.49666724f, -0.43795106f, -0.57132357f, 0.34364775f, 0.03990822f, 
    0.13969919f, 0.21471106f, 0.19377437f, -0.00699955f, -0.09015388f, -0.55797529f, -0.88351578f, 0.04989966f, 
    -0.08495817f, -1.15597034f, -0.69172049f, -0.13419734f, 0.14112177f, -0.36718524f, 0.37707591f, 0.20902503f, 
    0.09985603f, -0.02536022f, 0.12221559f, -0.75858241f, -0.05851894f, -0.28926033f, 0.28782487f, -0.03205368f, 
    0.11390912f, 0.34282446f, -0.51133394f, 0.12322979f, -0.04218773f, 0.09820853f, -0.02433036f, -0.29559085f, 
    0.19750942f, -0.11295192f, 0.00726651f, -0.14450556f, -0.38282150f, 0.36577326f, -0.30051884f, -0.15796934f, 
    -0.17680791f, -0.26626620f, -0.25012836f, -0.18361752f, 0.13162886f, 0.08915483f, 0.02847670f, 0.23291054f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.21252976f, 0.05698054f, 0.04601022f, -0.14836046f, -0.08321154f, -0.02428313f, -0.05607445f, 0.02798260f, 
    -0.00152001f, 0.05159958f, -0.03182275f, 0.08541199f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
