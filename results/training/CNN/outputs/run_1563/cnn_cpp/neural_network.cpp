#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.53888899f, 0.39882296f, 0.25536075f, -0.41687450f, 0.04964982f, 0.05978327f, 0.13854779f, 0.31848565f, 
    0.15935819f, -0.36396736f, 0.13645996f, 0.33668393f, 0.66423655f, -0.76712412f, -0.00822445f, -0.22759438f, 
    -0.05795333f, -0.02428705f, 0.37303260f, 0.57361567f, -0.01946217f, -0.39427316f, 0.03235304f, -0.38803598f, 
    -0.11170670f, 0.27526093f, 0.09792002f, 0.02893912f, -0.00381341f, -0.19264050f, 0.57028133f, 0.11373306f, 
    0.01446487f, -0.43464687f, -0.35306454f, -0.01101210f, -0.44866446f, 0.01088824f, 0.03651570f, -0.18701605f, 
    -0.43328527f, -0.55698973f, -0.05618506f, -0.45090532f, -0.28114623f, 0.40006834f, 0.18618883f, -0.03625407f, 
    0.40108806f, 0.07657321f, 0.40329826f, -0.47788775f, 0.61766595f, -0.64774460f, -0.53102124f, -0.27234665f, 
    -0.32148018f, 0.15692791f, 0.46218446f, -0.38220778f, 0.43988159f, 0.33799881f, 0.02827832f, 0.25805470f, 
    0.04203407f, 0.11159511f, 0.51033276f, -0.39190069f, -0.30274591f, -0.11234903f, -0.07936125f, 0.42212808f, 
    -0.37726146f, -0.28663453f, -0.39448604f, -0.01596088f, 0.25745931f, -0.73227406f, -0.18067425f, 0.32671818f, 
    -0.02976185f, 0.37605292f, 0.16353573f, 0.56984025f, -0.20268905f, -0.32526448f, 0.44568962f, 0.04228763f, 
    -0.22138804f, 0.08874442f, -0.62434250f, 0.37096509f, 0.47789261f, 0.16873953f, 0.09764754f, 0.19963273f, 
    -0.41756934f, -0.14379781f, -0.03648084f, 0.22102423f, -0.05276710f, 0.17013498f, -0.24807005f, 0.24753235f, 
    -0.17172973f, 0.30657366f, -0.02653143f, 0.30123186f, 0.04169771f, -0.05628854f, -0.01020655f, -0.34523532f, 
    -0.20475362f, -0.23831582f, -0.03154671f, 0.42752674f, 0.57279378f, 0.23492417f, 0.43462136f, -0.03734306f, 
    -0.05391021f, -0.02819916f, -0.34312665f, -0.38305488f, -0.45535997f, -0.12645236f, -0.05357299f, -0.65915191f, 
    0.21355939f, 0.80433607f, -0.28674501f, 0.33574033f, -0.30830389f, -0.23523611f, -0.02256423f, 0.17797735f, 
    -0.52564996f, -0.59644455f, 0.12563083f, 0.29714894f, 0.26744568f, -0.22276363f, -0.06949615f, -0.55076581f, 
    0.36005116f, 0.40976027f, 0.17036220f, -0.40649077f, -0.37254003f, 0.53740144f, -0.24995959f, -0.10988008f, 
    0.07455057f, 0.56127846f, -0.76988161f, -0.61204278f, 0.18330041f, 0.09035189f, 0.55371010f, 0.27223384f, 
    0.02214889f, 0.13821177f, -0.08456020f, 0.16216305f, 0.08221547f, -0.43524247f, -0.09426194f, -0.43165123f, 
    0.08285087f, 0.57079595f, -0.55901378f, -0.04078677f, 0.02797322f, 0.46359804f, -0.41217327f, 0.00598141f, 
    -0.10064805f, 0.21740490f, -0.50991982f, 0.52650779f, -0.55793446f, 0.49424869f, 0.09801736f, 0.19612934f, 
    0.63251591f, 0.12267476f, 0.29764634f, 0.09604416f, 0.03297772f, -0.05537117f, 0.56204653f, -0.64862049f, 
    -0.36449838f, 0.78894991f, -0.23912974f, -0.04298104f, -0.26964465f, -0.07210036f, 0.25401247f, 0.85334754f, 
    -0.71064067f, 0.17812228f, -0.13784415f, -0.30815876f, -0.36734870f, 0.29276913f, 0.11928297f, 0.23338385f, 
    0.23490210f, -0.10559367f, -0.35982653f, -0.38510421f, 0.55717415f, 0.30315697f, -0.18538739f, 0.07564647f, 
    -0.23632404f, 0.50170469f, 0.49357662f, 0.11139138f, -0.21053375f, -0.29270566f, 0.05477300f, 0.03987943f, 
    -0.49323556f, -0.21689451f, 0.00580275f, 0.43429053f, 0.30959663f, 0.32602882f, -0.30229369f, 0.28474006f, 
    -0.04106132f, -0.24311738f, 0.13480008f, -0.21448463f, 0.03928970f, 0.19363645f, -0.09143543f, -0.34141320f, 
    0.08082415f, 0.40169448f, 0.31410187f, -0.76413614f, -0.41000900f, -0.09120575f, 0.13579103f, -0.00481113f, 
    -0.07465661f, -0.07355391f, -0.38670570f, -0.08842003f, 0.19053194f, 0.01548577f, -0.09397615f, -0.08591758f, 
    -0.43663755f, -0.36590526f, 0.53602433f, 0.18338394f, 0.09947801f, -0.54479539f, -0.50718081f, 0.81944704f, 
    -0.15325408f, 0.23406960f, -0.32838377f, 0.22375040f, 0.02543939f, 0.17605035f, -0.14925955f, -0.28213507f, 
    0.41782215f, -0.38191554f, -0.40752232f, 0.60793936f, 0.39291647f, 0.09769622f, -0.07955305f, 0.15561955f, 
    -0.18019007f, 0.10503968f, 0.01542231f, -0.87827432f, -0.68812436f, -0.01919494f, 0.41927457f, -0.08130854f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.28153607f, -0.06257778f, -0.02679447f, -0.18576504f, -0.43691438f, 0.17858498f, 0.11412452f, -0.10632838f, 
    0.24776009f, -0.07353248f, 0.18880758f, 0.05881115f, -0.22669485f, -0.02685903f, -0.15159394f, -0.17106855f, 
    -0.17198297f, -0.07082245f, -0.30868310f, -0.05245264f, -0.28701639f, -0.20615798f, -0.19248429f, 0.01674450f, 
    -0.12214137f, -0.04807199f, -0.11442979f, 0.00259195f, 0.02492243f, -0.17034097f, -0.12466401f, -0.10195122f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.00716316f, -0.06318063f, 0.08082967f, 0.19240461f, -0.12139858f, 0.02278297f, -0.01656319f, 0.08143885f, 
    0.12814324f, -0.06437258f, -0.05734592f, 0.15322386f, 0.02381780f, -0.06790128f, 0.09241698f, 0.21585053f, 
    -0.14974357f, -0.07086922f, 0.01735722f, -0.16103709f, -0.06251985f, -0.00700332f, 0.04535301f, 0.09450196f, 
    0.24966188f, -0.08168623f, -0.04865258f, 0.02092728f, 0.02429787f, 0.11782645f, -0.06392845f, 0.03881199f, 
    0.02522919f, 0.07367124f, -0.08710492f, -0.25417542f, -0.21442696f, 0.04985632f, -0.06789547f, 0.10963813f, 
    -0.00145489f, 0.00038631f, 0.01303910f, 0.00554745f, -0.02022962f, 0.04427562f, -0.10189064f, -0.09109551f, 
    -0.02070844f, 0.02874130f, 0.13164528f, 0.01232138f, -0.00643341f, -0.22940597f, -0.04845297f, -0.00814250f, 
    0.01890450f, -0.01581743f, -0.01551674f, 0.05680274f, -0.04807710f, 0.04314427f, 0.16589013f, 0.03154711f, 
    -0.27658841f, 0.01141346f, 0.05065257f, -0.09195215f, -0.12803249f, -0.09471589f, -0.07439958f, -0.09852002f, 
    0.07520574f, 0.04112745f, 0.14755684f, -0.08182690f, 0.00273821f, 0.05791176f, 0.06707821f, -0.05189158f, 
    -0.04889825f, -0.21686190f, -0.02208863f, 0.06683583f, -0.04605687f, 0.05959709f, 0.05669542f, 0.05365626f, 
    -0.21044938f, -0.02141974f, -0.20793606f, -0.14339872f, 0.09723902f, 0.15674062f, -0.14728850f, 0.13235871f, 
    0.00911210f, -0.15465990f, -0.33455375f, 0.03678431f, 0.03342935f, -0.09358925f, -0.07410583f, 0.01269172f, 
    -0.08795071f, 0.00865937f, 0.09270991f, 0.11275266f, 0.16785091f, -0.13066816f, 0.05278846f, 0.14740789f, 
    -0.08526962f, -0.13232529f, 0.17090951f, 0.06563454f, 0.18037987f, -0.02195358f, -0.21447363f, 0.04944244f, 
    0.04462882f, 0.01135560f, -0.00403463f, -0.00661336f, -0.05223572f, -0.13939378f, 0.04999992f, 0.08217054f, 
    -0.03148294f, 0.05695283f, 0.11416186f, 0.09006238f, -0.01946146f, -0.03415874f, -0.42347354f, 0.14561343f, 
    -0.03298675f, -0.01539999f, 0.04601236f, 0.05177457f, 0.03543815f, -0.15647180f, -0.11113077f, -0.09909398f, 
    -0.09200589f, -0.11737778f, 0.14431322f, -0.08114896f, 0.03522701f, -0.09674619f, 0.05628823f, -0.19904394f, 
    -0.00192538f, 0.18104513f, -0.13961338f, -0.17448400f, -0.17927702f, 0.07303912f, 0.12415524f, -0.05038455f, 
    0.03247570f, 0.08593659f, -0.09959240f, -0.02000221f, -0.07287361f, 0.14602454f, -0.17527093f, 0.19194394f, 
    0.13859180f, 0.16563798f, 0.07327633f, 0.07358906f, 0.01407492f, -0.07011084f, 0.04352202f, 0.11925025f, 
    -0.02623631f, -0.04991451f, 0.17127115f, -0.07352436f, -0.02142717f, -0.07833923f, 0.03615267f, 0.07832813f, 
    -0.01136102f, -0.06438149f, -0.07261570f, 0.09754007f, 0.04793264f, -0.04896342f, 0.23653215f, 0.08578081f, 
    0.11018908f, 0.05279254f, 0.06132681f, 0.15116554f, -0.17493379f, 0.10060985f, 0.15348087f, -0.07757457f, 
    -0.08462240f, -0.08310858f, 0.09516600f, 0.23110378f, 0.11280615f, -0.13871370f, 0.02306058f, -0.24298510f, 
    0.16150372f, -0.00949242f, -0.04340855f, -0.00210773f, -0.11097334f, 0.05071123f, -0.10368202f, 0.08498815f, 
    -0.33693898f, -0.24177523f, 0.11829639f, 0.08780129f, -0.04874542f, 0.16015893f, 0.01619543f, -0.00949029f, 
    -0.17967907f, -0.17631797f, -0.12490787f, 0.02210977f, 0.07003825f, 0.05302245f, -0.03062461f, -0.18220519f, 
    -0.16677260f, -0.12508783f, 0.12574098f, -0.03272539f, 0.04367552f, -0.11310394f, -0.04192445f, -0.13049440f, 
    0.18442143f, 0.07785637f, 0.17360303f, -0.13115042f, 0.02709314f, 0.01391866f, -0.02700337f, 0.01420637f, 
    -0.00611067f, 0.00107114f, -0.16691895f, -0.10771872f, -0.02653257f, 0.07823423f, 0.04326753f, -0.06718588f, 
    -0.01128969f, 0.03803220f, 0.16594991f, 0.14055528f, 0.08810017f, 0.06719365f, -0.27583575f, 0.06449827f, 
    0.20792913f, -0.01112116f, 0.08703070f, -0.05917588f, 0.15314458f, 0.03491207f, -0.11814812f, 0.08111878f, 
    -0.03887393f, 0.02551761f, -0.22736624f, -0.03096370f, -0.09966840f, 0.13300489f, 0.24524722f, 0.10868050f, 
    0.02872552f, 0.05249751f, 0.00110434f, -0.02870263f, -0.03999389f, 0.01874972f, 0.06423633f, 0.08400413f, 
    0.03143775f, -0.05510892f, -0.04867759f, 0.03317225f, -0.01986037f, -0.02951218f, -0.02100033f, -0.02404938f, 
    -0.06796819f, -0.00780147f, 0.04086049f, -0.03988386f, 0.04810233f, -0.04649153f, -0.02644984f, -0.01552188f, 
    -0.03692029f, -0.04213593f, -0.04456195f, -0.00434966f, -0.02956685f, 0.04778298f, -0.05162754f, -0.03033606f, 
    -0.04812312f, -0.02031212f, 0.00285514f, 0.04274327f, -0.06382807f, 0.00728277f, 0.01665118f, -0.02843810f, 
    0.00981594f, -0.00134537f, -0.06719254f, 0.03580137f, 0.04398218f, -0.05198096f, 0.02383562f, 0.00664207f, 
    -0.05524080f, 0.02816131f, -0.02359793f, 0.02310443f, -0.00096204f, -0.02921526f, 0.02594312f, -0.05872079f, 
    -0.01437477f, -0.01561552f, 0.02091113f, -0.04055139f, 0.04033063f, -0.06722170f, 0.00395195f, -0.03162296f, 
    -0.02214923f, 0.03678379f, 0.00457581f, 0.02107729f, -0.01791217f, -0.03875465f, -0.05227919f, 0.04638077f, 
    0.04351194f, -0.03704960f, -0.02554930f, 0.03734624f, 0.00381495f, 0.03298621f, 0.01025767f, 0.00908471f, 
    -0.04693259f, -0.05797953f, -0.04835939f, 0.03759769f, -0.01212605f, -0.05910241f, -0.04460029f, -0.01145671f, 
    -0.02750823f, -0.04503028f, -0.04024125f, 0.02463008f, -0.00147545f, 0.03067534f, -0.03445891f, -0.05477819f, 
    0.02424885f, -0.03994642f, -0.00543564f, 0.01694144f, 0.04923495f, -0.00229473f, -0.00398798f, 0.00940671f, 
    0.00682920f, -0.00058079f, 0.02488499f, -0.01423554f, -0.04324151f, -0.02247628f, 0.03698216f, -0.03899789f, 
    -0.00039202f, -0.02979875f, -0.00645069f, -0.04978655f, 0.01206397f, 0.02037049f, -0.03797494f, -0.01654946f, 
    -0.01955260f, -0.02024713f, 0.02075582f, -0.02930836f, -0.01633353f, 0.04689319f, -0.01446939f, 0.02823670f, 
    -0.03842138f, -0.03677582f, 0.01523431f, 0.01877311f, 0.00918004f, -0.02271626f, 0.02978312f, 0.01750221f, 
    -0.05116334f, 0.00209152f, -0.03465390f, -0.02466177f, 0.01960716f, 0.00407020f, 0.01505321f, -0.00263092f, 
    0.03791862f, 0.00356133f, -0.01196748f, 0.02790125f, 0.03612715f, 0.02548846f, -0.04181829f, 0.01521923f, 
    0.01538087f, -0.02426796f, -0.00948508f, 0.03255964f, -0.00672609f, 0.00977795f, 0.02640116f, -0.05604334f, 
    0.04672280f, -0.03428320f, -0.01040288f, -0.05381835f, 0.03904776f, -0.03976801f, -0.06533781f, -0.02567491f, 
    -0.05362759f, -0.03165237f, 0.01147158f, -0.01085499f, -0.04555522f, -0.01088409f, -0.03180669f, -0.06171088f, 
    -0.05324410f, -0.01572840f, 0.02294942f, 0.00403201f, -0.01848441f, -0.05828226f, 0.00236268f, 0.04415727f, 
    -0.03843688f, -0.03573180f, 0.04433712f, -0.00437376f, -0.03347123f, 0.04676051f, -0.05202186f, -0.04163841f, 
    -0.05483729f, 0.02412018f, 0.02226888f, 0.02880330f, 0.03618769f, 0.00044957f, -0.00470975f, -0.02329793f, 
    -0.05945550f, -0.02414017f, 0.01805027f, 0.04468828f, 0.01423586f, 0.00155157f, -0.02954192f, -0.03651924f, 
    0.01581394f, 0.04147162f, 0.00195180f, -0.00031682f, 0.04478997f, -0.06611441f, -0.04789514f, -0.03996363f, 
    -0.04016969f, 0.00798149f, 0.01914710f, -0.04974959f, 0.01446341f, 0.00980001f, 0.03846752f, 0.02091639f, 
    0.02077164f, -0.01012346f, -0.00737223f, 0.00728223f, -0.02917171f, 0.01651036f, 0.04322877f, 0.00479414f, 
    -0.02804409f, 0.01836897f, -0.02252833f, -0.05629712f, 0.02521257f, 0.01620939f, -0.03699907f, -0.01580329f, 
    -0.02350808f, 0.03339604f, -0.01387252f, 0.01354148f, -0.03410174f, 0.02450524f, -0.03737397f, -0.00849051f, 
    0.02270975f, -0.06527203f, -0.01280372f, -0.00532733f, 0.02447473f, 0.02841690f, -0.00306363f, -0.06338704f, 
    0.01174439f, -0.04697226f, 0.01018085f, -0.02322649f, -0.00880790f, 0.01247272f, -0.02931310f, 0.04490347f, 
    -0.05160734f, -0.06753739f, -0.02284857f, 0.01502969f, -0.06736001f, -0.00255285f, 0.01255909f, -0.02512772f, 
    -0.04023566f, -0.03078391f, -0.00698574f, -0.03804233f, 0.03032602f, -0.01886333f, -0.02593115f, -0.01829142f, 
    -0.06722339f, -0.05089570f, -0.03102213f, -0.02832723f, -0.05314319f, 0.03779149f, 0.04512964f, 0.02321285f, 
    0.04436227f, -0.05456121f, -0.00686543f, -0.04462419f, -0.04206630f, 0.03260535f, 0.00471006f, -0.00569443f, 
    -0.31168079f, 0.01554161f, 0.09127437f, 0.03499998f, 0.07433131f, 0.03547896f, 0.05039710f, 0.21506175f, 
    0.06178264f, -0.53296173f, -0.46852669f, -0.16238743f, 0.07209263f, 0.18544157f, 0.02004900f, 0.13831858f, 
    0.04746132f, 0.02020159f, 0.13401118f, -0.36339575f, -0.07967285f, 0.08267701f, 0.08054984f, 0.09438827f, 
    -0.05315458f, -0.08527373f, -0.14674747f, 0.02055670f, -0.13790141f, 0.00128536f, -0.11455068f, -0.05236429f, 
    -0.04315020f, 0.27662566f, 0.13653079f, 0.20886338f, -0.21610980f, -0.07988493f, -0.17950019f, -0.10245870f, 
    -0.11258397f, -0.11598350f, -0.00276807f, 0.22141261f, 0.10643983f, 0.27034357f, 0.13365813f, 0.13402438f, 
    0.04890644f, 0.00332715f, 0.02561939f, -0.03090119f, 0.09622218f, -0.05353587f, -0.28900781f, 0.05879160f, 
    0.35991147f, -0.14002068f, 0.01363597f, -0.17930198f, 0.15440117f, 0.06582607f, 0.06039480f, -0.04835931f, 
    -0.22308977f, 0.06984890f, 0.03743457f, 0.10672701f, 0.05600893f, 0.04577459f, -0.00836435f, -0.07204815f, 
    -0.39325988f, -0.00394927f, 0.07287102f, 0.09093571f, 0.04303316f, 0.00701324f, 0.02929984f, 0.11729930f, 
    0.02478745f, 0.15827221f, -0.03914728f, 0.05436942f, -0.04829171f, 0.07289075f, 0.10025303f, -0.00220876f, 
    0.13719966f, 0.03053293f, -0.09897250f, 0.10842936f, 0.14891198f, -0.01700495f, -0.00655410f, 0.07728264f, 
    0.06928629f, 0.11485705f, 0.18789923f, 0.12846261f, -0.13200694f, 0.01540075f, 0.13873959f, 0.09810527f, 
    0.13315074f, 0.13919461f, 0.00658715f, -0.02532630f, -0.14849141f, -0.18521555f, -0.36486727f, -0.11292520f, 
    0.01749633f, -0.09941910f, -0.05712873f, -0.05449548f, 0.07791015f, -0.01384120f, -0.36264473f, -0.04951767f, 
    0.00662115f, 0.04603723f, 0.10793144f, 0.12814082f, 0.07988564f, 0.20515049f, 0.15395720f, 0.10562385f, 
    -0.05515677f, 0.01575491f, -0.00686949f, -0.02346607f, -0.02843027f, -0.04152402f, 0.13811772f, -0.03206893f, 
    0.07299648f, 0.22197597f, -0.23240721f, -0.05771297f, -0.16119990f, 0.12849753f, -0.07308864f, -0.04873106f, 
    0.06300616f, -0.19768871f, 0.15684745f, -0.06748335f, 0.03026468f, 0.05190574f, -0.02414017f, 0.16087703f, 
    0.07117737f, 0.18640822f, 0.41710210f, -0.00907972f, -0.18392426f, -0.00220648f, 0.03910092f, 0.10332372f, 
    -0.03248341f, -0.04183654f, -0.37741318f, -0.09511689f, -0.25464216f, -0.01972602f, -0.13883854f, -0.13185425f, 
    -0.10308036f, 0.01662029f, 0.02893133f, 0.19621208f, -0.20588936f, -0.17929745f, 0.00180771f, 0.10293514f, 
    0.07420259f, -0.01930572f, 0.04027050f, 0.04595700f, -0.10605930f, 0.09824958f, 0.15670474f, -0.33096021f, 
    -0.08919571f, -0.00202331f, 0.24137811f, 0.04191806f, 0.12264235f, -0.32764715f, -0.86186886f, -0.38162476f, 
    -0.16157511f, 0.03521740f, 0.13211714f, 0.14729747f, -0.12435313f, -0.06231412f, 0.16545619f, -0.53730047f, 
    -0.58069962f, 0.15158457f, -0.06901390f, 0.07317688f, -0.09345658f, -0.04138761f, -0.04385980f, 0.06698611f, 
    0.03692374f, 0.03178681f, -0.10551516f, 0.08396553f, 0.08147907f, 0.22120169f, 0.11386699f, 0.11560306f, 
    -0.07162145f, -0.09903552f, -0.02585930f, -0.04211443f, -0.01842080f, -0.08835134f, 0.00454530f, 0.03327077f, 
    0.14292769f, 0.10277336f, 0.04515294f, 0.18898068f, -0.01575726f, -0.13869663f, -0.03919992f, -0.02775158f, 
    -0.02543418f, 0.28738040f, -0.05091644f, -0.10226718f, 0.00504983f, -0.02115188f, -0.02184680f, 0.04365483f, 
    -0.12755971f, 0.03448870f, 0.08499552f, -0.17634346f, 0.03223465f, 0.67312711f, 0.01062348f, -0.16905266f, 
    0.03930585f, 0.01487243f, 0.03093909f, -0.03021954f, 0.15958270f, 0.01199132f, -0.15471455f, 0.15009581f, 
    -0.00150463f, -0.01037873f, 0.11846949f, -0.07716090f, 0.02050948f, -0.23245610f, -0.47322312f, -0.06316133f, 
    -0.19937219f, -0.07018619f, -0.12031029f, 0.04199207f, -0.04939356f, 0.11349347f, -0.33945057f, -0.02611105f, 
    -0.03399879f, -0.02526482f, 0.01201971f, 0.08316460f, 0.04834396f, -0.02550309f, 0.01788350f, -0.26899856f, 
    -0.32008538f, -0.70507050f, 0.03753000f, -0.13883583f, -0.20140699f, 0.04656376f, -0.04233100f, -0.01221223f, 
    0.02134031f, 0.12599747f, -0.11594878f, -0.07236903f, -0.10476196f, -0.09854341f, 0.00153312f, -0.10464906f, 
    0.08848791f, 0.12113906f, 0.16153298f, -0.16087820f, -0.20273274f, -0.07433330f, 0.10750566f, 0.12919286f, 
    0.08747741f, 0.01118805f, -0.02394520f, 0.15474063f, 0.11331426f, -0.05542959f, -0.13803440f, -0.01104773f, 
    0.09875574f, -0.13640229f, -0.00770014f, -0.04422613f, -0.02884310f, -0.06170334f, 0.05943732f, 0.03698638f, 
    0.00654142f, -0.18668017f, 0.23992354f, 0.06326348f, 0.35214368f, 0.17235674f, 0.24749993f, 0.05951305f, 
    0.05263969f, -0.06416336f, -0.05381591f, -0.10589142f, -0.07034229f, 0.01326331f, 0.07081941f, -0.02939547f, 
    0.05970908f, -0.08156211f, 0.10849086f, 0.00966244f, -0.05700331f, -0.04314526f, 0.10984311f, -0.17708687f, 
    -0.02317378f, 0.06696065f, 0.07109568f, -0.00807775f, -0.07529864f, -0.04758640f, 0.06032008f, 0.03738412f, 
    -0.08629110f, 0.14020450f, -0.02169462f, -0.10137565f, 0.02777978f, 0.04781976f, 0.07052877f, -0.11276249f, 
    0.06618275f, -0.04887228f, 0.03545142f, 0.10560790f, -0.02589653f, 0.00968959f, -0.03744297f, 0.01842474f, 
    -0.00132475f, 0.05404720f, 0.11914612f, -0.16698831f, -0.03448036f, 0.04095751f, -0.18637769f, 0.13760720f, 
    -0.06654750f, 0.05272524f, 0.26684380f, -0.00657212f, -0.21607123f, -0.03361266f, 0.00633521f, 0.07149471f, 
    0.07962720f, 0.09253202f, -0.10536540f, -0.04767721f, 0.01382875f, 0.04301974f, 0.04257014f, 0.05313070f, 
    -0.01718589f, -0.09818412f, -0.00440306f, -0.00618100f, 0.03154524f, 0.11242310f, 0.15519387f, 0.01089232f, 
    -0.10521851f, -0.02728168f, -0.03203780f, -0.21256156f, 0.04089694f, 0.07020938f, 0.10278649f, 0.17177032f, 
    0.01258892f, -0.08226559f, -0.02536455f, 0.06555039f, -0.04502851f, -0.09214467f, -0.00499432f, -0.04239111f, 
    -0.20033857f, 0.03442609f, 0.00995440f, 0.04942113f, -0.03549555f, 0.19015671f, 0.11504337f, -0.02822000f, 
    0.00751572f, 0.35205001f, 0.01379887f, 0.15249377f, -0.06349740f, -0.00354954f, 0.13494031f, 0.10528026f, 
    -0.07082405f, 0.11095716f, 0.02023866f, 0.04880887f, -0.00931839f, -0.21509667f, 0.12218193f, 0.03063364f, 
    0.04684696f, -0.15633199f, -0.02537845f, 0.33072382f, -0.03689270f, -0.03931778f, -0.11639390f, 0.03762915f, 
    0.15823776f, -0.06877174f, 0.20246992f, 0.11670247f, 0.18180120f, 0.10734440f, 0.07187845f, -0.06241945f, 
    0.09218178f, -0.15582766f, 0.05524682f, -0.13045268f, 0.17765847f, 0.09709056f, -0.05457415f, 0.04478742f, 
    -0.07570461f, 0.13059382f, 0.05594325f, 0.11101818f, -0.02877951f, 0.11730652f, -0.01770320f, 0.04741543f, 
    -0.03446054f, 0.04357541f, -0.04821441f, -0.25472638f, -0.03894699f, 0.02564538f, 0.01991917f, -0.12452841f, 
    -0.00132219f, 0.10385566f, 0.12143295f, -0.03936823f, 0.00349285f, -0.02456650f, -0.28286394f, 0.22979304f, 
    0.04073155f, -0.09498584f, -0.19729722f, -0.04360100f, 0.18815176f, -0.04007076f, -0.06127276f, -0.04590126f, 
    -0.04553591f, -0.05767021f, -0.11854884f, 0.18179499f, -0.21328756f, 0.22708492f, -0.03421983f, 0.03602789f, 
    0.13944095f, 0.15496093f, -0.21772997f, 0.05191120f, -0.07881425f, 0.07606320f, 0.05519100f, -0.14410253f, 
    0.03558016f, 0.04078607f, -0.08667988f, -0.13697545f, 0.11524285f, 0.01739469f, 0.02465910f, -0.02500569f, 
    -0.04183681f, 0.00017513f, 0.08586775f, -0.12766548f, 0.05855520f, -0.03644399f, -0.10977696f, 0.08093326f, 
    -0.25553113f, -0.22571704f, -0.13112508f, 0.13628303f, -0.12098313f, 0.06496133f, 0.11456107f, 0.02769570f, 
    -0.06640104f, -0.02059573f, 0.07499474f, -0.00026878f, 0.11308700f, 0.01067360f, -0.06691841f, 0.09081269f, 
    0.03953365f, -0.04793580f, -0.04783131f, -0.01624196f, -0.06446544f, 0.35408321f, -0.08358096f, 0.02479382f, 
    0.04594134f, -0.14499091f, 0.01262212f, 0.10939708f, 0.11019091f, -0.15217628f, -0.01547243f, 0.00708709f, 
    0.02345771f, 0.03163650f, 0.01588145f, -0.08966170f, 0.09978239f, -0.12615104f, 0.07743169f, 0.07519437f, 
    0.12423148f, 0.26516762f, 0.14668384f, -0.11365772f, -0.14573969f, 0.00572534f, -0.02867031f, -0.04385119f, 
    0.10205124f, -0.12347263f, 0.07246381f, 0.00488810f, 0.06403475f, -0.00579341f, 0.12226938f, 0.16594720f, 
    0.13275212f, -0.03496703f, -0.04153913f, -0.20710269f, 0.17301770f, -0.05893034f, -0.25815988f, 0.35868090f, 
    -0.01156309f, 0.10969617f, -0.04779267f, -0.29666436f, 0.21236970f, -0.04667960f, 0.06595372f, -0.09203492f, 
    -0.05149044f, -0.04326457f, 0.02357379f, -0.10866502f, -0.05209385f, -0.10410056f, -0.17007947f, -0.15789442f, 
    -0.07502376f, 0.07053971f, -0.01393575f, -0.20544904f, -0.16888538f, -0.08873082f, 0.02377828f, -0.10431182f, 
    -0.03126851f, -0.03344222f, 0.11135149f, -0.00325308f, -0.00680292f, -0.11751446f, 0.04238053f, 0.02011759f, 
    0.07449537f, -0.07591797f, -0.03646601f, 0.11473360f, -0.03839496f, 0.07073896f, -0.24598286f, -0.03387884f, 
    0.27717185f, 0.06465036f, 0.16906771f, 0.09516808f, -0.08116856f, 0.03626817f, 0.12074129f, -0.14593399f, 
    0.01040514f, -0.07394473f, -0.05358731f, 0.07575968f, -0.05612138f, 0.16452560f, 0.07586110f, 0.18079880f, 
    -0.03398715f, -0.14661549f, 0.23560412f, 0.09066358f, 0.03791720f, 0.07430191f, 0.05802146f, 0.07658385f, 
    0.09939729f, 0.13463666f, 0.00024451f, -0.06953987f, 0.03817594f, 0.07845685f, -0.08564051f, -0.04719280f, 
    -0.06490065f, 0.05877021f, 0.16781105f, 0.13332257f, -0.13620044f, -0.00684624f, -0.02626166f, -0.02368166f, 
    -0.03625411f, 0.08284704f, 0.08981729f, -0.06848396f, -0.19490470f, -0.09901466f, 0.07940175f, -0.04576991f, 
    0.03785887f, -0.02046811f, 0.15085347f, 0.19617358f, -0.44144753f, -0.77697039f, -0.45334554f, -0.04340360f, 
    -0.13980152f, -0.13148241f, 0.00988360f, 0.05041515f, 0.04750591f, -0.12882875f, 0.06511095f, 0.13983801f, 
    -0.02274517f, 0.00606547f, -0.03728763f, 0.17161584f, -0.06017514f, 0.00890401f, 0.05600611f, -0.03613953f, 
    -0.04916853f, -0.00984654f, 0.14717820f, -0.16863559f, -0.02593478f, 0.01313938f, 0.11546145f, -0.08710194f, 
    -0.27361357f, 0.12668405f, -0.00779377f, 0.04265921f, 0.08389998f, 0.06756101f, 0.01702445f, -0.07545600f, 
    -0.03971951f, -0.05375648f, -0.00978193f, -0.11364380f, 0.05066363f, -0.14879856f, -0.05355550f, -0.03549699f, 
    0.03223433f, -0.15233938f, 0.33610940f, 0.19315504f, -0.07798848f, -0.02705109f, 0.11677513f, 0.08189780f, 
    0.02590306f, 0.06390090f, -0.07099594f, -0.36147979f, -0.04601593f, -0.02035746f, 0.12284441f, 0.00568418f, 
    0.01461901f, -0.03685680f, 0.20818144f, 0.06442876f, -0.44356829f, -0.09222969f, 0.07980183f, -0.09120344f, 
    -0.03642767f, -0.10325608f, 0.17549914f, 0.28653544f, 0.04726678f, -0.06181912f, -0.12040667f, -0.11680746f, 
    -0.24298114f, 0.01351010f, 0.05154780f, 0.13114047f, 0.10427137f, 0.14427198f, -0.06803655f, -0.05607545f, 
    -0.07065320f, -0.20184946f, -0.00890112f, -0.00838480f, 0.19785918f, 0.12474567f, 0.25299647f, -0.11741859f, 
    0.03131867f, 0.04135617f, -0.05744332f, -0.32528117f, 0.05061544f, 0.08432982f, -0.17918937f, 0.09548370f, 
    0.07871467f, -0.11666460f, 0.03593656f, 0.09679198f, -0.03934142f, 0.18096364f, 0.03514757f, 0.03531489f, 
    -0.23292738f, -0.01901516f, 0.01662528f, 0.13629580f, 0.00816951f, -0.11743627f, 0.02306741f, -0.04523101f, 
    -0.00628095f, 0.10375220f, 0.08796959f, -0.10719100f, 0.08365534f, 0.03623672f, -0.01620652f, -0.04735286f, 
    0.18349676f, -0.07488777f, -0.15775809f, -0.16368003f, -0.29466239f, -0.09241567f, -0.11925256f, -0.04934644f, 
    -0.02805467f, 0.04310801f, -0.02627678f, -0.09171674f, -0.03397871f, 0.11160000f, 0.05947542f, 0.04153774f, 
    0.09189438f, -0.14512749f, -0.09122828f, 0.04821144f, -0.22353420f, -0.02296576f, -0.10287269f, 0.05382178f, 
    0.21813837f, -0.10536558f, 0.04204781f, 0.03727944f, 0.03372224f, 0.49587184f, -0.29084864f, -0.02492208f, 
    0.16723998f, -0.06625843f, -0.18043816f, -0.01951605f, 0.05393264f, 0.00758245f, 0.08604463f, -0.01116910f, 
    -0.52808350f, -0.02943916f, 0.10629138f, -0.11458173f, 0.05407808f, 0.04810174f, 0.05157602f, -0.48372129f, 
    -0.44131726f, -0.00689472f, 0.01162634f, 0.14175172f, -0.29683748f, 0.06491870f, 0.02121341f, 0.12643400f, 
    0.03358943f, 0.02353948f, -0.03619384f, 0.03668000f, -0.01557833f, -0.00110068f, 0.01728118f, -0.03297336f, 
    -0.04337680f, 0.05180427f, 0.01474996f, -0.05879159f, 0.04460968f, 0.00487016f, -0.02752557f, -0.00453862f, 
    -0.01935135f, -0.04831951f, 0.04731774f, -0.00400466f, 0.01993953f, -0.06153877f, -0.02635762f, 0.03147348f, 
    -0.02265769f, 0.03111335f, 0.02985545f, 0.00279795f, 0.02330450f, -0.01119067f, 0.04099551f, 0.03794314f, 
    -0.02819757f, -0.03522492f, -0.04431196f, 0.03428478f, -0.01351909f, 0.01444365f, 0.02363567f, -0.03015110f, 
    0.03858628f, -0.01883741f, 0.00585018f, -0.04562354f, -0.01547576f, 0.04140170f, 0.01415652f, -0.05255026f, 
    0.01153067f, -0.03499790f, 0.00165654f, -0.03554680f, 0.01435558f, -0.03499135f, 0.01916320f, -0.01847884f, 
    0.00654206f, 0.01466993f, -0.01775288f, -0.05405917f, -0.06669878f, 0.05175120f, -0.01369235f, 0.01194472f, 
    -0.03280626f, 0.05108484f, -0.03932194f, -0.02007647f, -0.05083444f, -0.06143506f, -0.01553383f, 0.03831157f, 
    -0.06221345f, -0.01545180f, -0.03772552f, -0.05413936f, -0.05239308f, -0.00910576f, 0.01831472f, -0.03663478f, 
    -0.02758231f, 0.02674138f, -0.00190777f, -0.02447998f, -0.04334295f, -0.04460688f, 0.03646271f, -0.06197713f, 
    0.04759318f, 0.01329360f, -0.04812299f, 0.00832775f, 0.02014240f, 0.02775583f, 0.02653556f, -0.05946120f, 
    0.05064552f, 0.04071566f, -0.05190964f, -0.03411681f, -0.03433436f, 0.01541215f, 0.03454088f, 0.02194232f, 
    -0.00318992f, -0.00259655f, -0.01472824f, -0.03254417f, 0.01694896f, -0.04693277f, 0.03732271f, -0.02586058f, 
    -0.05460623f, -0.03079543f, 0.00156827f, 0.05577686f, -0.01061406f, 0.02694331f, 0.04736595f, -0.02454080f, 
    -0.00733357f, 0.02823994f, 0.04360852f, -0.02260081f, -0.06673706f, 0.00741833f, 0.04087956f, 0.02103264f, 
    -0.01608852f, -0.00160753f, 0.02124143f, 0.03650670f, 0.00368132f, 0.01658074f, -0.05967522f, -0.00121592f, 
    0.00732742f, 0.02153127f, -0.02977276f, -0.05165116f, -0.04419038f, -0.04122643f, -0.03235280f, 0.00577599f, 
    -0.05610593f, 0.00705707f, -0.01359904f, -0.05909446f, -0.02948232f, 0.01469170f, 0.01087312f, -0.01517228f, 
    0.00283824f, 0.04527286f, -0.03441513f, -0.00790528f, 0.02987665f, 0.00671005f, -0.01642304f, 0.02008802f, 
    -0.03527079f, -0.04566000f, -0.05461108f, -0.05662262f, 0.01304151f, 0.03246884f, 0.05167852f, -0.01196508f, 
    0.03850596f, 0.04569817f, -0.02006751f, -0.01585027f, 0.01348160f, -0.00611404f, 0.04128064f, -0.04103101f, 
    -0.05292467f, -0.00291646f, 0.05367782f, 0.03350855f, -0.04085605f, -0.01310911f, 0.02964206f, -0.02381911f, 
    0.01849141f, 0.01371651f, 0.00729663f, -0.05812317f, -0.04926428f, -0.02616555f, -0.03957196f, -0.02915508f, 
    -0.05119748f, -0.05546192f, 0.03121208f, -0.04781711f, 0.02515044f, -0.01325138f, -0.04185253f, 0.02163361f, 
    0.00789454f, -0.05805844f, 0.04682882f, -0.02311234f, -0.04656715f, 0.01064158f, -0.05746456f, -0.02690545f, 
    -0.03297001f, -0.02955477f, 0.01908383f, 0.04419826f, 0.02892435f, -0.04107917f, -0.05662218f, -0.03950961f, 
    -0.05516628f, 0.02131811f, -0.04833719f, -0.00658931f, 0.00477245f, -0.01690156f, -0.04047365f, -0.01250186f, 
    0.04112721f, 0.03867853f, -0.05941594f, 0.03529084f, 0.03987433f, 0.05178443f, 0.00293585f, -0.00897635f, 
    0.02918962f, 0.04253487f, -0.02562136f, 0.03982809f, 0.00564679f, 0.04362810f, -0.02869390f, -0.02488387f, 
    -0.02496569f, 0.05249129f, 0.00970226f, -0.06221022f, -0.04224965f, -0.01756276f, 0.04713812f, -0.02119592f, 
    0.03348797f, 0.01080272f, -0.03269264f, 0.02448043f, -0.04858401f, 0.03188553f, 0.00622076f, -0.04610912f, 
    0.04380579f, -0.06278496f, -0.05489011f, -0.03428550f, 0.03128475f, -0.03789409f, -0.00805450f, 0.04628507f, 
    0.01189173f, -0.04069656f, 0.00092856f, -0.01136893f, 0.04451249f, -0.01019183f, -0.02707089f, 0.04690451f, 
    -0.00491986f, -0.06111048f, 0.02237155f, -0.04555487f, -0.02186121f, -0.05067616f, -0.00631940f, -0.04473577f, 
    -0.05857094f, 0.01718473f, 0.01991199f, 0.01311955f, -0.01955664f, 0.02244221f, 0.00457362f, -0.03304397f, 
    -0.10043245f, -0.12416868f, -0.04885465f, -0.01034529f, -0.01087802f, 0.05966825f, -0.13103843f, -0.09287973f, 
    -0.04822281f, 0.22318934f, 0.14121905f, 0.02346826f, 0.06712433f, -0.06968070f, 0.19088076f, -0.01759788f, 
    0.13079363f, -0.11071100f, 0.25258714f, -0.01013305f, -0.12154405f, -0.03660639f, -0.15330814f, 0.04973697f, 
    -0.11358579f, 0.02541182f, -0.04223170f, -0.25981507f, -0.09703087f, 0.02600073f, 0.19389303f, 0.05951542f, 
    0.06559130f, -0.08834835f, 0.19076812f, -0.07475773f, 0.09606133f, -0.02195224f, 0.03677237f, 0.19270146f, 
    0.05699005f, -0.05733753f, -0.07819428f, -0.10384402f, -0.01472622f, -0.00721038f, 0.07769959f, -0.09956650f, 
    0.02914441f, 0.06423360f, 0.12936926f, 0.00913515f, -0.02236201f, 0.01505828f, -0.05076589f, -0.12136687f, 
    0.00565863f, -0.05712939f, 0.01456601f, 0.07568574f, 0.09397238f, 0.01944264f, -0.09858304f, 0.20733327f, 
    0.07743641f, 0.00544547f, -0.03650459f, -0.02336024f, 0.26753628f, -0.13621737f, -0.10312863f, -0.02427842f, 
    -0.11584561f, -0.08295283f, -0.08577623f, 0.09397503f, -0.02745202f, -0.05993641f, 0.02511908f, 0.09912548f, 
    -0.01436664f, 0.13117741f, 0.27594703f, -0.08896066f, -0.06095649f, -0.02621455f, -0.14315143f, 0.12161995f, 
    0.09607904f, -0.09411974f, 0.03434306f, -0.08723874f, -0.05104380f, 0.07097625f, 0.15879062f, 0.09754131f, 
    0.05351418f, 0.06428089f, 0.04918341f, 0.01883402f, -0.00220491f, 0.03325941f, 0.04517666f, 0.08367737f, 
    -0.09599138f, -0.00881713f, -0.00383116f, -0.18388271f, -0.21096064f, -0.05216900f, -0.00083392f, -0.01353112f, 
    -0.00664194f, -0.09977459f, -0.26410797f, -0.33679453f, -0.22265796f, -0.00600703f, -0.07377931f, 0.10679415f, 
    0.06512675f, 0.08300052f, -0.04063983f, 0.11814263f, 0.11473348f, 0.03771537f, -0.05701530f, 0.15988627f, 
    -0.22032697f, 0.10010626f, 0.08221303f, 0.02910403f, 0.07946178f, 0.10623021f, 0.06941006f, -0.15451503f, 
    -0.18001339f, 0.00244191f, 0.09516041f, -0.03452659f, 0.07377705f, 0.10722982f, 0.11684575f, 0.29693791f, 
    0.04517907f, 0.15013428f, -0.04610568f, 0.03551967f, 0.00765510f, -0.07766330f, 0.03461277f, -0.00231535f, 
    -0.03672520f, -0.08591193f, 0.10665726f, -0.07421292f, 0.04793525f, -0.02478561f, 0.06246958f, 0.01129381f, 
    -0.10926142f, 0.00369762f, -0.17429592f, -0.12612323f, -0.02087131f, 0.15730506f, 0.16409494f, 0.04050103f, 
    0.04567040f, -0.01847316f, 0.04055248f, 0.01578357f, -0.09321096f, -0.01635833f, 0.03135137f, 0.05458545f, 
    -0.10511865f, 0.10976731f, 0.03780664f, -0.08461201f, -0.02522312f, -0.02727011f, 0.07668994f, 0.04895500f, 
    0.17714122f, 0.09650094f, -0.04761134f, -0.15248090f, -0.13328527f, -0.17800246f, 0.10554160f, -0.06373641f, 
    0.17124510f, 0.15726320f, 0.06543258f, 0.03176378f, 0.07303204f, 0.13219331f, 0.13478260f, 0.04773568f, 
    -0.08610202f, -0.05852794f, 0.08410922f, 0.10312118f, -0.08947592f, 0.17294332f, -0.06947204f, 0.02558914f, 
    0.21246764f, -0.17544694f, -0.02750047f, -0.01873254f, -0.00680267f, 0.03443487f, 0.06181695f, -0.00239171f, 
    -0.02342194f, 0.11842475f, -0.03170463f, 0.04973744f, 0.04077520f, 0.00851175f, -0.08298350f, 0.07547533f, 
    0.01609602f, 0.05812718f, 0.08566041f, -0.07760941f, -0.05354868f, 0.16784580f, -0.01709752f, -0.06499665f, 
    0.04941197f, -0.04379393f, -0.04542456f, 0.05381433f, 0.06785374f, -0.02166200f, 0.07198883f, -0.01520694f, 
    -0.20021005f, -0.43579245f, -0.04949541f, 0.01908621f, -0.03940783f, -0.12260683f, 0.00740812f, -0.08633445f, 
    0.05963962f, -0.01343621f, 0.07862972f, 0.07729033f, 0.02331996f, -0.04386132f, -0.11884572f, 0.03187982f, 
    0.05811018f, -0.02307940f, -0.11981683f, -0.07625181f, -0.11095505f, -0.03264026f, -0.27798712f, -0.06419574f, 
    0.00879216f, 0.08056615f, -0.10270609f, 0.12651585f, 0.00044529f, -0.06677148f, -0.10140751f, -0.00134498f, 
    -0.04896009f, 0.11327546f, 0.16282035f, 0.12395950f, 0.02946585f, -0.06325132f, -0.15347669f, 0.01135672f, 
    0.06210615f, -0.02659186f, 0.14080998f, 0.04002848f, -0.06365663f, 0.06814004f, 0.02978216f, -0.07994890f, 
    0.15419123f, -0.10422588f, -0.23389554f, -0.09967220f, 0.09940138f, 0.08458527f, 0.22759330f, -0.01497115f, 
    -0.09247559f, 0.02565100f, -0.22570129f, 0.35655236f, 0.05930857f, -0.04950368f, -0.00316103f, 0.02056478f, 
    0.01344423f, -0.04273626f, 0.27815950f, 0.06116220f, 0.28350410f, -0.08658760f, -0.05669171f, -0.08461642f, 
    -0.02631242f, -0.05066486f, -0.10582928f, -0.22712123f, -0.20669638f, -0.12627788f, -0.22844958f, 0.00680578f, 
    -0.27704337f, 0.16084988f, 0.05087884f, 0.08844433f, 0.05215940f, 0.05170058f, 0.25353980f, -0.18189438f, 
    0.02533894f, -0.06032417f, 0.11966177f, 0.16578218f, 0.06766909f, -0.11943427f, -0.09678823f, 0.11070419f, 
    -0.00067385f, 0.00632476f, -0.06780063f, 0.10988931f, 0.12864110f, 0.20225215f, -0.17605662f, -0.00756347f, 
    0.20265071f, 0.09041199f, 0.16690722f, -0.03354715f, -0.14991370f, -0.05480604f, -0.12526253f, -0.06732412f, 
    0.09601155f, 0.22510640f, 0.06653731f, -0.06274111f, -0.02160758f, -0.04450591f, -0.01446573f, 0.10376853f, 
    -0.01833011f, 0.10772716f, 0.09810782f, 0.08650469f, 0.09702790f, 0.00553815f, -0.14720368f, 0.11485981f, 
    0.01558391f, 0.06247636f, 0.08230639f, -0.17675409f, -0.09085022f, 0.00964383f, -0.08374178f, -0.02136612f, 
    0.06077417f, -0.08702732f, 0.12107182f, 0.24401565f, -0.08938697f, -0.06509030f, 0.07991068f, -0.06173896f, 
    -0.04391387f, -0.01548756f, 0.11302337f, 0.01761261f, -0.02787511f, 0.00374518f, 0.04390934f, 0.12169720f, 
    -0.00443423f, 0.12778181f, 0.07711773f, -0.07247314f, -0.31831229f, -0.21241198f, -0.35693583f, -0.03631342f, 
    -0.05152201f, 0.01795729f, -0.07062981f, -0.06966504f, -0.24146676f, 0.22719222f, -0.18478800f, 0.07167617f, 
    -0.22378677f, -0.01194574f, -0.05325496f, 0.01779364f, 0.04965406f, 0.16495782f, -0.26764560f, 0.17075600f, 
    -0.07360721f, -0.07669507f, -0.06066392f, -0.02558765f, -0.17562652f, -0.00706633f, -0.08233533f, 0.00130953f, 
    0.05408639f, 0.03830487f, -0.02663154f, 0.09253147f, 0.16178700f, -0.07326596f, -0.01935121f, 0.28171933f, 
    -0.05011605f, -0.01820306f, -0.18623164f, -0.10356849f, 0.00043419f, -0.12063416f, -0.01929996f, 0.05386389f, 
    0.05244659f, -0.21868154f, 0.00023908f, 0.27180660f, 0.07917241f, 0.08445168f, 0.04716424f, -0.02690771f, 
    -0.18811645f, -0.02497900f, -0.03646917f, 0.01201588f, -0.04417531f, -0.15721443f, 0.13359144f, 0.09606287f, 
    -0.04997580f, 0.03622913f, 0.16563538f, 0.09227227f, -0.08102183f, 0.00885578f, -0.03397159f, -0.00087647f, 
    -0.07926556f, -0.09630647f, 0.02124206f, -0.00671456f, 0.20159459f, 0.01200676f, 0.07591061f, 0.02297350f, 
    -0.00291890f, -0.00648909f, -0.01546168f, 0.01975139f, 0.07488408f, 0.44980007f, -0.20767537f, 0.23637943f, 
    -0.26432180f, -0.04323150f, -0.07584532f, 0.07508191f, -0.05784428f, 0.26811585f, 0.41384339f, -0.12693509f, 
    0.24455063f, 0.14324436f, -0.27637875f, -0.06858074f, 0.18033549f, -0.23521201f, 0.00766574f, 0.08269534f, 
    -0.02412321f, -0.21991289f, -0.11167494f, -0.07357490f, -0.11285922f, 0.05985083f, 0.21729544f, 0.02585627f, 
    0.06704173f, -0.14686230f, -0.16445327f, -0.09060842f, 0.05435947f, -0.04089402f, 0.08970895f, -0.00111968f, 
    0.02352657f, 0.12007381f, 0.05609035f, 0.04037175f, 0.21500671f, 0.09941147f, -0.02822059f, 0.09505688f, 
    0.04276348f, 0.07481628f, -0.31564507f, 0.04550458f, -0.12824333f, -0.05193399f, 0.09734596f, -0.00855340f, 
    0.13208231f, -0.11418515f, -0.17277703f, -0.27412006f, 0.16794915f, 0.06999195f, -0.05794489f, 0.02757623f, 
    0.12395839f, -0.27232081f, 0.08488082f, 0.12520403f, -0.07991514f, 0.09526743f, 0.00893334f, 0.21155870f, 
    0.21976481f, 0.05140854f, 0.04592650f, -0.06414579f, -0.24389741f, -0.10070515f, -0.51104552f, -0.14812396f, 
    0.01887239f, 0.00019214f, 0.02524095f, 0.05534643f, -0.04155714f, -0.07744972f, 0.01575228f, -0.25838897f, 
    -0.13649754f, -0.06866226f, -0.08793398f, -0.03003866f, 0.01912340f, -0.02236309f, -0.03782265f, -0.09830333f, 
    -0.07510422f, 0.13939039f, -0.03912333f, 0.23151410f, -0.02182383f, 0.15849599f, -0.05415199f, 0.06920645f, 
    0.04647819f, 0.03729315f, 0.21345946f, -0.11042790f, 0.03825537f, 0.07485255f, 0.00152668f, -0.02763528f, 
    0.10234167f, 0.11494602f, -0.08314294f, 0.12836401f, 0.07423443f, -0.03062099f, -0.01333776f, 0.01695509f, 
    0.05414366f, -0.06660725f, -0.16849525f, -0.11826257f, 0.15021271f, 0.05257780f, 0.07322979f, 0.24019715f, 
    0.14747526f, 0.03572424f, 0.06613381f, 0.10582860f, -0.09776137f, 0.01506242f, -0.09115825f, 0.04998960f, 
    -0.16366737f, 0.05897358f, -0.18002853f, -0.23618798f, 0.05707897f, -0.03645920f, -0.11018633f, 0.10164031f, 
    -0.12377643f, -0.03268005f, 0.03806893f, -0.00523260f, -0.33797941f, -0.12694959f, -0.10709640f, -0.03677697f, 
    0.07293755f, 0.09557132f, 0.18688308f, -0.05140216f, -0.04072167f, 0.00457667f, 0.10259616f, 0.15459251f, 
    0.04710457f, -0.00494125f, 0.02533309f, -0.05595074f, -0.13589591f, -0.00574054f, -0.09041796f, -0.04613739f, 
    0.02600679f, -0.04352849f, 0.18174648f, -0.01531922f, 0.05085529f, -0.06788766f, -0.10227707f, 0.09454535f, 
    0.04214438f, 0.12265661f, 0.15761432f, -0.09710663f, -0.00149624f, -0.05261191f, 0.11081938f, -0.04422206f, 
    -0.02937169f, -0.03382584f, -0.10393240f, -0.02429445f, 0.04254393f, 0.01152604f, 0.00518904f, -0.10402320f, 
    -0.00339308f, 0.03757563f, 0.04772002f, -0.22267079f, 0.04602853f, -0.00551477f, -0.00995767f, 0.13535549f, 
    -0.05415582f, -0.02909830f, -0.02749510f, -0.01554149f, -0.09641911f, 0.08082057f, -0.12243801f, 0.03416141f, 
    0.20162706f, -0.14158039f, 0.13706081f, 0.11881104f, 0.04995258f, -0.06229856f, -0.00359501f, 0.08754687f, 
    0.18645200f, -0.01329421f, 0.08937697f, -0.03945714f, 0.33093917f, -0.00702692f, -0.10622962f, -0.18116920f, 
    -0.03833227f, 0.03950039f, -0.07757261f, -0.15433328f, -0.07383955f, -0.16796072f, 0.05400587f, 0.12984571f, 
    0.21754222f, 0.12500288f, 0.05950644f, -0.05503345f, 0.24866582f, 0.00471372f, -0.24635619f, -0.08973798f, 
    0.18953951f, -0.06242573f, -0.11959486f, 0.09712628f, -0.26605216f, -0.00871336f, -0.07755920f, -0.18381828f, 
    -0.03361719f, -0.11869533f, 0.04316290f, 0.06404064f, 0.05125250f, 0.10562488f, -0.21330926f, -0.22140190f, 
    0.00196308f, 0.25675824f, 0.21558066f, -0.10685404f, -0.03093255f, -0.12834506f, 0.00899069f, -0.25306681f, 
    0.01604481f, -0.00854087f, 0.02737884f, 0.01512878f, 0.13611884f, 0.08935831f, 0.01960268f, 0.19823572f, 
    0.00620358f, 0.10216531f, -0.03881070f, -0.08243081f, -0.08320044f, 0.02579674f, 0.08114705f, 0.15798536f, 
    0.06259326f, 0.02371198f, 0.06520711f, 0.09069594f, 0.12600425f, -0.00067993f, 0.03836063f, 0.06711669f, 
    0.05083605f, 0.00434751f, -0.09567586f, 0.00811872f, -0.04099209f, 0.19916412f, 0.20423746f, 0.34711865f, 
    0.05315046f, 0.15439166f, 0.10999716f, 0.02913065f, -0.21302545f, -0.08831638f, 0.11062958f, 0.04206800f, 
    0.02110642f, 0.04809267f, 0.00965657f, 0.28387386f, -0.01666994f, 0.19645382f, 0.12873232f, 0.06624422f, 
    0.13160044f, 0.06089969f, 0.01760622f, 0.05031194f, 0.01723574f, -0.01361010f, -0.06264368f, -0.02682128f, 
    -0.22499368f, 0.03901697f, 0.09279495f, -0.00120908f, -0.03772798f, 0.07198777f, -0.04747690f, -0.14529252f, 
    -0.06377352f, 0.02677889f, -0.09328260f, -0.01781871f, 0.03926799f, 0.13824044f, -0.02386197f, -0.12247012f, 
    0.15595847f, 0.00724532f, 0.08837146f, -0.04476130f, 0.00738498f, -0.00347493f, -0.01789768f, 0.05558583f, 
    -0.02393502f, 0.11554693f, 0.29500562f, -0.06203876f, 0.12818551f, 0.11982833f, -0.00225343f, 0.01484017f, 
    -0.12020593f, -0.03299392f, 0.02162682f, -0.18390918f, -0.02784250f, -0.07174973f, 0.04182530f, -0.21062258f, 
    -0.03109729f, 0.12497564f, 0.05737682f, 0.14592522f, 0.07335430f, 0.17427947f, 0.34355092f, 0.05800594f, 
    -0.01545631f, 0.21789490f, 0.03580910f, -0.11329821f, 0.08562655f, 0.01463148f, 0.17613667f, 0.05479178f, 
    -0.02094630f, -0.02331896f, -0.11287616f, -0.07783881f, 0.01344398f, 0.15717471f, 0.05092666f, -0.06135063f, 
    -0.05466481f, -0.07426190f, -0.05195972f, 0.00492765f, 0.10728207f, 0.06128960f, 0.09306322f, 0.02731904f, 
    -0.25361493f, 0.15567985f, -0.24165371f, 0.00585373f, 0.09046008f, -0.00367534f, -0.01948624f, -0.23849937f, 
    -0.00859443f, -0.48141930f, -0.60432923f, 0.08297849f, -0.17804401f, 0.16764504f, 0.09947792f, 0.12869306f, 
    -0.12466282f, -0.08682515f, 0.07092988f, 0.11583005f, -0.18630123f, 0.23967218f, 0.13164467f, -0.01712441f, 
    0.09138820f, -0.01636354f, -0.06447178f, 0.19073038f, 0.12802668f, 0.22884205f, 0.02018504f, 0.00332600f, 
    0.07075445f, -0.11743786f, -0.00708476f, 0.13749866f, -0.23435193f, -0.56892121f, -0.38725021f, -0.13194995f, 
    -0.16629116f, -0.10284222f, 0.08230875f, 0.01625395f, 0.22054525f, 0.24250053f, 0.16280547f, 0.16334480f, 
    0.03786105f, -0.06343063f, -0.00875772f, 0.03600186f, -0.00994941f, 0.03540675f, 0.03644091f, -0.09982914f, 
    0.18107851f, 0.05311450f, 0.00383159f, -0.16514745f, -0.00770264f, 0.04986139f, 0.06760064f, 0.17850739f, 
    -0.27939016f, 0.22085786f, 0.17902888f, 0.04154401f, -0.02627581f, 0.05857259f, 0.02932241f, -0.01094892f, 
    -0.20421310f, -0.31520942f, 0.01682585f, -0.20682137f, 0.04148403f, -0.05950085f, 0.04587920f, -0.00573220f, 
    0.11512265f, -0.02992218f, 0.02848610f, -0.01262063f, 0.09661784f, 0.12101351f, 0.13119939f, 0.04164492f, 
    0.08152762f, -0.01068150f, -0.21269812f, 0.25688061f, 0.22306290f, -0.07214171f, -0.02961606f, 0.02568858f, 
    -0.01406456f, -0.09559348f, -0.06091413f, -0.00264196f, 0.06774831f, 0.06522341f, 0.18600294f, 0.14033768f, 
    0.09256037f, 0.02090519f, 0.06889577f, -0.16193868f, 0.00481634f, 0.19672698f, 0.00060163f, 0.08729459f, 
    0.06126557f, 0.06844641f, -0.01570267f, -0.14287959f, -0.11192827f, -0.19703788f, -0.29854774f, -0.14102195f, 
    0.16474622f, 0.00971579f, 0.02043956f, 0.16344239f, 0.03185562f, 0.08062808f, -0.02230453f, 0.34195897f, 
    0.26943833f, -0.17158648f, 0.01354791f, -0.23153013f, -0.13238759f, -0.19729541f, -0.07411055f, 0.19111232f, 
    0.02030382f, 0.06566399f, 0.06341680f, 0.04529732f, 0.04855377f, 0.05582735f, 0.01572104f, 0.17705226f, 
    -0.10942382f, 0.05512301f, -0.05025442f, 0.17673427f, 0.03474724f, 0.09825101f, 0.10292117f, 0.12166616f, 
    -0.00194141f, -0.05910932f, 0.00119514f, 0.09551965f, -0.08019052f, -0.16366431f, -0.04442116f, -0.07252278f, 
    -0.01177993f, -0.09087290f, -0.19284509f, -0.25514677f, -0.11330782f, -0.18976006f, -0.10186514f, -0.26237595f, 
    0.03717374f, 0.00707764f, -0.00015237f, -0.17164473f, 0.10663354f, 0.01468058f, 0.08452512f, -0.00173815f, 
    -0.12498711f, 0.00443903f, -0.01332332f, 0.10915634f, -0.14015014f, 0.06374498f, 0.26453975f, 0.02069459f, 
    -0.03389991f, -0.08472064f, 0.07002750f, 0.01571622f, 0.05609035f, 0.10164418f, -0.46441263f, -0.08900216f, 
    -0.11066865f, 0.07984696f, 0.00526411f, -0.05181917f, -0.06922734f, 0.03443708f, -0.17376432f, 0.30988216f, 
    -0.04233883f, 0.16507396f, -0.20489098f, 0.10768029f, 0.11609241f, 0.06990328f, -0.03234278f, -0.11407402f, 
    -0.02542189f, -0.22152343f, 0.14147139f, -0.01908424f, 0.12933818f, 0.02031221f, -0.02357055f, 0.02816065f, 
    -0.12858370f, 0.02221442f, -0.28739992f, 0.10176803f, 0.04807736f, -0.04190588f, 0.04051855f, 0.05965880f, 
    0.02809468f, 0.03567670f, -0.05198608f, 0.26173353f, -0.07662601f, 0.00855090f, -0.14432904f, 0.04070785f, 
    0.00544421f, -0.03623306f, 0.22492273f, 0.06346596f, 0.10821377f, 0.07363939f, -0.08868296f, 0.07684404f, 
    0.06539936f, 0.05641491f, -0.20151411f, -0.13425516f, 0.11470595f, -0.05692608f, -0.16875024f, 0.25471124f, 
    -0.05624254f, 0.02197185f, 0.05126879f, 0.10105628f, 0.29265717f, -0.00605546f, 0.01874826f, 0.03424207f, 
    0.04941104f, 0.03635630f, 0.00056899f, -0.05147967f, -0.13037989f, -0.57679325f, -0.19872156f, 0.00781756f, 
    -0.09346497f, -0.16144377f, -0.13085045f, -0.20037097f, -0.03846604f, -0.08443666f, 0.14530091f, 0.01299239f, 
    0.24052094f, -0.12582003f, -0.13263863f, 0.11490844f, 0.10051748f, -0.00006083f, -0.03036928f, 0.36674118f, 
    -0.10040615f, -0.13542381f, 0.06170471f, -0.19989520f, -0.00152170f, -0.07267796f, -0.11853265f, 0.03462305f, 
    0.09550048f, 0.08047867f, -0.01577541f, -0.03724231f, -0.07053168f, 0.15933284f, 0.04527547f, 0.08947004f, 
    0.08190151f, 0.11539427f, -0.15732107f, -0.17793708f, -0.17912607f, 0.08506178f, -0.11458305f, -0.04147593f, 
    0.02543266f, 0.15117131f, -0.34781888f, -0.02271038f, 0.10938199f, -0.00568679f, 0.04380423f, 0.14325970f, 
    0.02023126f, 0.04103931f, -0.03027839f, 0.01651434f, -0.10495918f, 0.06835172f, 0.02161533f, 0.11974412f, 
    0.12975447f, -0.23629543f, -0.03611306f, -0.22640593f, 0.35662875f, 0.18717729f, -0.22659054f, 0.09320777f, 
    0.01711305f, -0.02415165f, -0.05089310f, 0.09208111f, 0.06242719f, -0.03173165f, 0.00477125f, 0.24823435f, 
    0.00570366f, 0.17492120f, -0.08333924f, -0.13771129f, -0.01488713f, -0.12447644f, 0.20260541f, -0.05920387f, 
    -0.01275847f, 0.02912928f, -0.07198452f, -0.06979020f, -0.05659608f, 0.05893345f, 0.02406738f, -0.19814059f, 
    -0.23900615f, -0.05025414f, 0.03097987f, -0.00024384f, -0.06368335f, 0.15069102f, -0.12282071f, 0.10606390f, 
    0.19592477f, 0.05627538f, -0.12126636f, -0.03965391f, 0.04643108f, -0.06600133f, 0.06845468f, -0.06406692f, 
    -0.05565763f, -0.10268787f, 0.05421162f, 0.08473478f, 0.04196806f, -0.02163877f, 0.02936400f, -0.02561422f, 
    -0.04261516f, 0.11452450f, 0.01170951f, -0.01043651f, 0.03204213f, -0.09847448f, 0.05923791f, -0.06681874f, 
    -0.16332333f, -0.18142270f, -0.10222699f, 0.00193739f, 0.02188423f, 0.09218397f, -0.05126361f, -0.01324720f, 
    0.05695702f, -0.05696292f, 0.16674049f, 0.23748252f, 0.20934664f, 0.08646666f, 0.05406167f, -0.08403205f, 
    0.14408572f, 0.12678745f, 0.17385063f, 0.10706891f, 0.28164473f, -0.16493176f, -0.19739966f, -0.09810181f, 
    0.03781863f, -0.06224513f, 0.05687718f, -0.03676151f, -0.10786264f, -0.13779238f, 0.17740738f, 0.09737714f, 
    -0.05929606f, 0.01908412f, 0.07356642f, 0.10186154f, 0.07493770f, -0.08144377f, -0.08195960f, 0.20202571f, 
    -0.05760551f, -0.00276502f, 0.06667351f, 0.06383602f, -0.20351091f, 0.02343753f, -0.10723919f, -0.17758775f, 
    -0.27942947f, -0.04833283f, 0.06622964f, 0.02109959f, -0.00845836f, -0.06334496f, -0.04004190f, -0.04246365f, 
    0.18503107f, 0.15947406f, -0.11847309f, 0.10378472f, 0.12294651f, -0.13618755f, -0.15326732f, -0.04012035f, 
    -0.02080621f, 0.00757282f, 0.13432950f, 0.22500436f, -0.03498404f, 0.08779278f, -0.07684840f, 0.07113010f, 
    -0.06818113f, 0.14488116f, 0.08197262f, 0.06369817f, 0.01180130f, -0.00632406f, 0.08473966f, 0.16168429f, 
    -0.09592107f, 0.03645354f, 0.16361965f, 0.09137597f, 0.12160347f, 0.10680158f, 0.10466234f, -0.12025978f, 
    -0.14921829f, -0.04235180f, 0.02127912f, 0.08306790f, 0.07365296f, -0.25824717f, 0.03755412f, 0.17019029f, 
    0.02179414f, -0.19640857f, -0.03137442f, -0.07652339f, -0.12670195f, -0.21360305f, -0.44169855f, -0.13538207f, 
    0.01151914f, -0.14370550f, -0.04817923f, 0.07484848f, 0.14469446f, -0.26366898f, -0.06550574f, -0.12069199f, 
    0.01342493f, 0.02843261f, 0.07919765f, -0.13384953f, -0.12895101f, -0.05192848f, -0.04445912f, 0.05185055f, 
    -0.06713741f, -0.12578090f, 0.04699510f, 0.02905136f, 0.05182728f, 0.05910310f, -0.13935809f, -0.17761028f, 
    0.06782743f, -0.06531586f, -0.06392222f, 0.07661632f, -0.07985844f, 0.10806421f, 0.08074414f, -0.08656552f, 
    -0.08536442f, -0.01086813f, 0.02585469f, 0.06098709f, 0.15025476f, -0.13756377f, 0.05405097f, 0.05188167f, 
    0.17316724f, 0.03108370f, 0.28231058f, 0.43663496f, 0.25450838f, -0.21326292f, 0.00836164f, -0.05485548f, 
    -0.07757486f, 0.04226198f, 0.03971972f, -0.06837054f, -0.05556810f, -0.00496072f, -0.07122771f, -0.05380215f, 
    0.10294946f, 0.14553981f, 0.02945865f, 0.04933755f, 0.08269004f, 0.35034460f, 0.25420600f, -0.20313402f, 
    0.13118066f, 0.07306932f, -0.11892688f, -0.02576725f, 0.03410089f, 0.04027153f, 0.07311735f, 0.13945393f, 
    0.04692335f, 0.05370292f, -0.04334065f, -0.16642903f, 0.04193982f, 0.00564184f, 0.14244275f, 0.10873806f, 
    0.08041289f, -0.05069864f, -0.21771176f, 0.16123277f, 0.09665939f, 0.13539349f, -0.02759993f, 0.05461019f, 
    -0.04390781f, -0.04292719f, -0.01462959f, -0.01963794f, 0.02991220f, -0.06810658f, 0.03214704f, -0.04823032f, 
    -0.04522974f, 0.04661338f, 0.03595311f, -0.03335951f, 0.03140422f, -0.02904070f, 0.00419208f, 0.03888977f, 
    0.00280250f, -0.04082244f, -0.04272167f, -0.06836046f, -0.00549949f, 0.03767331f, -0.05876737f, -0.05247045f, 
    0.00175518f, -0.03457912f, 0.01608878f, 0.01034732f, 0.02317084f, 0.01982842f, 0.01807473f, 0.00545896f, 
    -0.04319334f, 0.02432537f, 0.02385748f, -0.02942431f, -0.03356196f, 0.02522760f, 0.01937284f, 0.00567807f, 
    -0.05717550f, -0.04481892f, -0.05156818f, -0.00495501f, 0.02191083f, -0.05150868f, 0.01719815f, 0.04867186f, 
    -0.05346469f, 0.00750158f, -0.05079993f, -0.00321056f, -0.03222964f, 0.02883910f, 0.00109393f, -0.00962339f, 
    0.00495029f, 0.00929363f, 0.03142892f, 0.02510091f, -0.04281975f, -0.03841822f, 0.01329120f, 0.01854953f, 
    0.03258883f, 0.00811888f, 0.01417975f, 0.00371571f, -0.05699012f, 0.01482734f, 0.00252514f, -0.03140332f, 
    0.01726881f, -0.02303072f, -0.03942254f, -0.00238063f, 0.00580550f, -0.04364133f, 0.01272369f, 0.02768813f, 
    -0.05303831f, -0.01275549f, 0.00623117f, -0.04982430f, -0.05908581f, 0.01180792f, -0.05529581f, -0.00464217f, 
    -0.05841537f, 0.03567455f, 0.00487881f, -0.02913080f, 0.03879027f, -0.06490644f, -0.02416907f, 0.00225430f, 
    -0.00094764f, -0.05603681f, -0.06400947f, 0.02056245f, -0.00576157f, 0.04574699f, 0.03961796f, -0.02105234f, 
    0.00792079f, 0.00154858f, 0.04461949f, 0.00924307f, -0.01846752f, 0.00435437f, -0.02692663f, 0.04724130f, 
    -0.01069901f, 0.02499324f, -0.03471863f, -0.05122821f, -0.06368970f, -0.05726800f, 0.01532702f, -0.00717810f, 
    -0.04899828f, -0.02528560f, 0.03128379f, -0.00238566f, -0.04921386f, 0.00390701f, 0.05143546f, 0.02201476f, 
    -0.00555837f, -0.00522410f, 0.01758393f, 0.00975452f, -0.01066559f, -0.00031644f, -0.05913461f, -0.01580937f, 
    -0.03800428f, -0.01805065f, 0.04935546f, -0.00352601f, 0.05100360f, -0.04895095f, -0.05122489f, 0.02448217f, 
    -0.00504331f, 0.03212899f, -0.01408136f, -0.05199983f, 0.03847514f, 0.01191266f, -0.01729051f, -0.05483476f, 
    0.02259660f, -0.05766631f, 0.04223494f, -0.04777639f, -0.03477939f, 0.04125055f, -0.05148587f, -0.01013408f, 
    0.04633543f, -0.00664576f, -0.00134493f, -0.02445129f, -0.00471093f, -0.06002028f, 0.04811456f, 0.04624056f, 
    -0.05366977f, 0.00271996f, 0.04116286f, 0.02629159f, -0.05697436f, 0.00158336f, -0.02192860f, -0.01356262f, 
    -0.05143092f, -0.02090682f, 0.02919825f, 0.04807940f, 0.03289704f, 0.02627986f, -0.00208575f, -0.04844632f, 
    0.04421710f, -0.01998500f, -0.00847403f, 0.02406305f, -0.06115030f, 0.03469094f, 0.03479091f, 0.01287857f, 
    0.00623610f, 0.02943803f, -0.04575905f, 0.00286584f, 0.03136325f, 0.00642227f, 0.04198706f, -0.03121006f, 
    0.00440497f, -0.02245609f, -0.06749902f, -0.06115153f, -0.03744243f, -0.03718574f, 0.00057334f, -0.01815788f, 
    0.01932450f, -0.01551911f, 0.03450553f, -0.02084443f, 0.02670337f, 0.00488860f, 0.01675698f, 0.04356989f, 
    0.00677058f, 0.01148564f, -0.03381025f, -0.05750030f, 0.04807388f, 0.01300388f, -0.04582098f, -0.04256804f, 
    -0.04023410f, 0.04443168f, -0.06655566f, 0.02764470f, -0.04500775f, -0.03989033f, 0.00411230f, 0.02647815f, 
    0.01585920f, 0.02417802f, 0.01361446f, 0.02245453f, 0.02556372f, -0.02007947f, 0.04209118f, -0.02652321f, 
    0.00328281f, 0.02179017f, 0.03317123f, 0.00113590f, 0.03726224f, -0.05203640f, 0.04676713f, 0.02317638f, 
    0.01238229f, 0.04504390f, -0.06781799f, 0.03525085f, -0.03496752f, 0.01514269f, -0.00464676f, -0.00172208f, 
    -0.02603358f, 0.02567724f, 0.04143851f, -0.02723748f, -0.05340956f, -0.04947286f, 0.01498024f, 0.03129284f, 
    -0.04300427f, -0.04786707f, 0.00571570f, -0.02254453f, -0.02769127f, -0.06701693f, -0.01299453f, 0.01069756f, 
    0.02974006f, 0.03313402f, 0.03333990f, 0.00482812f, 0.03803774f, -0.01592038f, -0.05874744f, -0.00393001f, 
    -0.05970128f, -0.06392132f, -0.03336500f, -0.01403739f, 0.00484834f, -0.05784744f, -0.04911324f, -0.04653996f, 
    0.14160450f, -0.24044110f, -0.01016797f, 0.06802590f, -0.15636981f, 0.07755336f, 0.08216478f, 0.01000193f, 
    0.07627337f, -0.10349857f, 0.29430825f, -0.14938980f, -0.08545475f, -0.04172835f, 0.04521783f, 0.06399447f, 
    0.07082064f, -0.06152721f, -0.05876224f, 0.15456811f, -0.03600332f, -0.01238939f, -0.07790276f, 0.09782005f, 
    0.06881538f, -0.00780455f, 0.11545227f, -0.05440205f, -0.16461673f, 0.09961963f, -0.03162893f, -0.05508403f, 
    0.02036270f, -0.10172588f, 0.09778067f, 0.07961377f, -0.04426263f, 0.21630597f, 0.13502620f, 0.07953588f, 
    -0.08672796f, 0.11570602f, 0.01649525f, 0.14723410f, 0.12490201f, 0.17359781f, 0.29482368f, 0.06732330f, 
    0.10561584f, 0.04784843f, -0.01769374f, 0.06251896f, 0.10339178f, -0.07034658f, -0.14255498f, -0.19819549f, 
    -0.25608021f, 0.12016221f, -0.03885198f, 0.10368735f, 0.07219701f, -0.03434070f, 0.07445930f, 0.15847377f, 
    0.07527091f, -0.05720579f, 0.00954995f, -0.17474581f, -0.09992661f, 0.17678149f, 0.01174852f, -0.04403210f, 
    -0.14715847f, -0.03540003f, -0.26535621f, -0.02641141f, -0.00419435f, 0.20699351f, 0.02263355f, -0.14242171f, 
    0.02008351f, 0.11276881f, 0.17374660f, 0.17223401f, 0.05839986f, 0.01038555f, -0.03827370f, 0.01981760f, 
    -0.06683901f, -0.05058054f, 0.10930684f, 0.02616339f, 0.11071425f, -0.01670199f, -0.10359875f, 0.05236019f, 
    0.03949761f, 0.04678217f, -0.00175344f, 0.20565727f, 0.06739577f, -0.01230726f, 0.07790506f, 0.06789724f, 
    0.02786041f, 0.12230025f, 0.06833885f, -0.09427623f, 0.08694353f, -0.01453647f, 0.09132091f, -0.02789914f, 
    -0.05270480f, 0.10566636f, 0.02229219f, -0.13265947f, -0.01875001f, 0.17704320f, 0.05171146f, 0.04917274f, 
    0.03584374f, 0.10191245f, -0.10360286f, 0.03461472f, -0.03075023f, 0.21888265f, -0.13097042f, -0.48536015f, 
    -0.29129690f, -0.18433435f, -0.03470971f, -0.01962166f, -0.07549788f, -0.06333604f, -0.12521611f, 0.03578728f, 
    -0.42765352f, -0.09200156f, -0.21155627f, -0.04381887f, 0.02215433f, -0.01982535f, 0.06771059f, -0.05663035f, 
    0.10051342f, 0.05393171f, 0.21552384f, 0.04249656f, 0.08859978f, 0.01264252f, 0.06874024f, -0.11120100f, 
    0.00557754f, -0.07814167f, -0.24641152f, -0.29338089f, -0.09867723f, 0.17548297f, -0.25439119f, 0.09381993f, 
    0.09521846f, -0.01902007f, -0.19205029f, 0.00274979f, 0.03726941f, -0.05566607f, -0.21644747f, -0.03253590f, 
    0.00569493f, 0.04370919f, -0.02242324f, 0.09781350f, 0.11348834f, 0.04250313f, 0.00513237f, 0.04995402f, 
    0.02701007f, 0.20561372f, 0.01025250f, 0.06788930f, 0.35983372f, 0.12372739f, 0.02545026f, 0.07292996f, 
    -0.06852191f, 0.01237336f, 0.14396034f, -0.13129809f, -0.07633836f, -0.40449762f, -0.09021405f, -0.49883512f, 
    -0.06176225f, 0.13648394f, -0.20411070f, -0.20970601f, -0.10769711f, 0.12909482f, 0.17134421f, 0.15495008f, 
    -0.08367107f, -0.12519214f, 0.28046244f, -0.06445893f, -0.10368270f, -0.12782647f, -0.03491137f, -0.01953235f, 
    0.11388551f, 0.01702448f, -0.04707476f, 0.12116818f, -0.19382453f, -0.01015021f, -0.03894424f, 0.01186648f, 
    -0.03812447f, 0.08381105f, 0.07299207f, 0.17139415f, -0.01874091f, -0.16774963f, -0.02037703f, 0.05352735f, 
    0.12078239f, 0.08103631f, 0.17884952f, -0.13628280f, 0.19065994f, 0.03508585f, 0.05092849f, -0.01630829f, 
    -0.06669137f, -0.03332037f, -0.01497135f, 0.03794469f, 0.01949583f, 0.06971528f, -0.01144044f, 0.06592032f, 
    0.11138239f, 0.07262872f, -0.00122840f, 0.02397412f, -0.38346940f, -0.30028331f, 0.08882389f, -0.08299319f, 
    0.07091253f, 0.05731940f, 0.04006932f, 0.06272150f, -0.27038413f, -0.00018441f, 0.17216927f, -0.23010194f, 
    -0.00561791f, -0.03160236f, -0.01306933f, 0.06820875f, -0.03964901f, -0.03827720f, -0.60992998f, -0.24512894f, 
    0.00307043f, 0.04188787f, 0.09180802f, 0.23949279f, -0.02613298f, -0.26873052f, -0.08181969f, -0.02139520f, 
    0.15332335f, -0.05940341f, 0.00813100f, -0.07027329f, -0.01102997f, -0.10904186f, -0.19131479f, 0.14947306f, 
    0.33094031f, 0.23601295f, -0.19836655f, -0.05994223f, 0.01760074f, -0.02483093f, 0.03805978f, -0.05091940f, 
    -0.05576478f, -0.00678425f, 0.03013409f, 0.04593519f, -0.06531265f, -0.02183647f, 0.03359262f, 0.02529960f, 
    -0.04910249f, -0.02672581f, -0.05687567f, -0.01850388f, -0.02078367f, -0.04121163f, 0.01036440f, -0.04407820f, 
    -0.00894608f, 0.04190171f, 0.01430297f, 0.02427751f, 0.03516389f, 0.02236201f, 0.02661128f, -0.01028952f, 
    0.02821274f, -0.01571583f, 0.02564290f, -0.01912006f, 0.01548003f, 0.03155097f, 0.05237692f, 0.03024277f, 
    0.03589710f, 0.02927377f, -0.00826525f, -0.02794303f, -0.03070221f, 0.01691468f, -0.06191981f, -0.01681609f, 
    -0.04030642f, -0.01847331f, -0.01026801f, 0.00877024f, -0.04175896f, 0.02986398f, -0.05051264f, 0.05167087f, 
    0.00357612f, -0.02231622f, 0.04101381f, 0.02132338f, -0.07636956f, -0.00793616f, 0.04399822f, -0.01148696f, 
    -0.04764638f, -0.02107250f, 0.03337027f, 0.02150159f, -0.01236965f, -0.00147004f, -0.01298950f, -0.05728575f, 
    0.01155999f, -0.01954109f, 0.02305973f, 0.02192494f, -0.01615677f, -0.04444913f, 0.03606018f, -0.06878201f, 
    -0.01794384f, 0.01309708f, 0.03156476f, -0.04412941f, 0.03207687f, -0.04834184f, -0.02199772f, -0.04956531f, 
    0.04429666f, 0.02221987f, -0.02519748f, 0.02070048f, 0.03966357f, -0.03683306f, -0.01521457f, 0.00566175f, 
    -0.00191224f, 0.03138795f, 0.00242222f, 0.03059278f, -0.02405281f, -0.03453253f, -0.05209402f, -0.05751126f, 
    -0.01910479f, -0.00218989f, 0.01861173f, -0.03953478f, -0.00465032f, -0.02089316f, 0.01719045f, 0.01520321f, 
    -0.07588187f, 0.01937241f, -0.02151788f, -0.01363151f, -0.00393007f, -0.02872520f, -0.06171640f, 0.04079800f, 
    0.03631107f, -0.02435411f, 0.02463543f, 0.04938766f, -0.00252177f, -0.02899119f, 0.02004190f, 0.01563470f, 
    0.02435263f, 0.05652250f, -0.05651709f, 0.01808249f, 0.02405753f, 0.02383384f, -0.05600161f, 0.00620563f, 
    0.04780078f, -0.03749379f, -0.02163827f, 0.00945822f, -0.05521769f, -0.01400641f, -0.03209341f, 0.00288685f, 
    0.04561055f, -0.04549424f, -0.05682398f, -0.06232104f, 0.00496331f, 0.04386391f, 0.00526212f, 0.04967823f, 
    -0.04996727f, -0.03391180f, -0.03261430f, 0.04157503f, 0.02616182f, 0.01710845f, 0.00031246f, 0.01257742f, 
    0.02746406f, -0.05332779f, 0.00323896f, -0.01168527f, -0.00264948f, -0.06208299f, -0.02077245f, -0.03075907f, 
    -0.03897250f, -0.06460062f, -0.03317977f, -0.03782262f, -0.01757855f, -0.00058433f, -0.01561160f, 0.00707941f, 
    0.04640729f, 0.02639798f, -0.00612175f, 0.00540145f, 0.00427467f, -0.05887260f, 0.02081555f, 0.02577183f, 
    0.02009751f, -0.05025105f, 0.01712324f, -0.00171696f, -0.00189382f, 0.03177952f, -0.04190930f, -0.03231486f, 
    -0.04106079f, -0.01625848f, 0.03125420f, -0.01483413f, -0.02426033f, 0.04227906f, -0.03074225f, -0.03697677f, 
    0.00021077f, -0.05343356f, 0.02693481f, 0.04362758f, 0.03178341f, 0.02399816f, -0.01395455f, 0.04314040f, 
    -0.03364857f, 0.01700022f, 0.01537955f, -0.04775516f, -0.01144354f, 0.00754817f, -0.05555722f, -0.01918374f, 
    -0.01871436f, -0.06167451f, -0.01748738f, -0.04170612f, 0.01908369f, 0.01006953f, 0.02598754f, -0.01147424f, 
    -0.05193704f, 0.03841157f, 0.04194478f, -0.05016457f, 0.04391480f, 0.01566309f, -0.03851266f, -0.07366399f, 
    -0.07501202f, -0.05025912f, 0.00754976f, -0.05444786f, 0.03489967f, -0.02697153f, 0.04130990f, -0.01728762f, 
    -0.04981070f, -0.02479671f, 0.04017474f, 0.04678312f, -0.05512182f, -0.05643728f, -0.00754056f, -0.02923147f, 
    -0.04662428f, 0.04857318f, -0.03215823f, -0.00524326f, -0.02456788f, -0.02602657f, -0.02610283f, -0.03565751f, 
    0.04097972f, -0.02546829f, -0.00696995f, 0.03670799f, -0.02061334f, -0.06782812f, 0.03073098f, 0.01815865f, 
    0.01105035f, -0.03773058f, 0.01278833f, 0.00609789f, -0.02186815f, 0.01240987f, 0.01197367f, -0.00894487f, 
    0.04430787f, -0.01199237f, -0.02619734f, -0.00553273f, -0.03559023f, -0.05190627f, 0.04476457f, -0.02695025f, 
    0.04657884f, 0.02237473f, -0.06088538f, -0.03074212f, 0.04402164f, -0.03708729f, -0.03604179f, -0.06465047f, 
    -0.02927151f, 0.02733348f, 0.04569768f, -0.00559690f, -0.04047077f, 0.04786991f, 0.02581371f, -0.06062013f, 
    0.01534973f, -0.04682101f, 0.09213502f, -0.01707187f, 0.01401850f, 0.02805915f, -0.00954802f, 0.12118378f, 
    0.11068152f, -0.10039835f, -0.07939680f, 0.08737259f, 0.12165613f, -0.01717867f, -0.16412809f, 0.29798630f, 
    -0.05924054f, -0.15862213f, 0.03618013f, -0.28853786f, -0.01670576f, 0.08463503f, 0.12238723f, 0.03754986f, 
    -0.09323321f, 0.03963604f, 0.11645850f, -0.28242761f, 0.12541772f, 0.01646912f, 0.01261462f, -0.11435021f, 
    -0.17850617f, 0.02621203f, -0.15167770f, -0.19566433f, -0.24782151f, -0.09166060f, -0.04878422f, -0.12316415f, 
    -0.11130939f, -0.03368047f, 0.13953997f, 0.12740493f, 0.16410984f, -0.07688313f, -0.05914546f, -0.02448742f, 
    0.01508862f, -0.11593709f, 0.00627002f, -0.08721198f, 0.01869771f, 0.09721126f, -0.28413185f, -0.01761639f, 
    0.11630824f, -0.07481151f, 0.02026765f, 0.12046811f, -0.01184438f, 0.02500323f, 0.14097378f, 0.04699198f, 
    0.09844700f, 0.07419816f, 0.04720876f, 0.24068899f, -0.23148787f, 0.17377722f, 0.08695566f, 0.20379655f, 
    -0.16557853f, 0.00704117f, 0.08376106f, 0.02984658f, 0.04459545f, 0.06992197f, 0.06994607f, -0.03170197f, 
    0.01353696f, 0.13143741f, 0.09256500f, 0.03699707f, -0.12202607f, 0.14211527f, -0.03520763f, -0.10060855f, 
    -0.06157002f, -0.01321408f, -0.03316062f, 0.01416184f, -0.02392170f, -0.10770603f, 0.05682461f, 0.05448612f, 
    -0.09586022f, 0.03070243f, -0.19147374f, 0.12679110f, 0.05373150f, 0.04008203f, 0.03265109f, -0.01306368f, 
    0.11874801f, 0.03795422f, 0.11207644f, 0.00278094f, -0.06415584f, -0.12460451f, -0.17799351f, -0.14788009f, 
    0.12339909f, -0.14928342f, -0.00924876f, 0.03844121f, -0.11497786f, -0.36801332f, -0.22592779f, -0.14027828f, 
    0.05123299f, -0.04219798f, -0.02149923f, 0.08318621f, 0.07496309f, 0.03283441f, -0.06058124f, 0.05781374f, 
    -0.12033668f, 0.05510967f, 0.01490500f, 0.04030653f, 0.03151546f, -0.17647001f, -0.19691333f, -0.05919381f, 
    -0.06166891f, 0.13697448f, -0.17198959f, 0.11312355f, 0.06742193f, 0.00034675f, -0.06589471f, 0.06135819f, 
    0.01514405f, -0.08654669f, -0.02208519f, 0.05104672f, 0.09144048f, 0.06518979f, -0.05849119f, 0.00936209f, 
    -0.06974777f, -0.07595245f, 0.00090548f, -0.09129748f, -0.03345156f, 0.19929202f, -0.03051363f, 0.12177286f, 
    0.10063954f, 0.05447339f, -0.08944879f, -0.36351895f, -0.07280739f, -0.11902640f, 0.01618787f, 0.10956666f, 
    0.02428014f, -0.08717494f, 0.18680620f, 0.20216835f, -0.06435909f, 0.15663508f, -0.04763562f, -0.00335135f, 
    -0.05877116f, -0.00864451f, 0.04541659f, 0.06926809f, -0.15925337f, -0.17710671f, -0.02445885f, 0.06303371f, 
    -0.07618127f, -0.01262768f, -0.04527190f, 0.17131035f, 0.22355217f, 0.04680205f, -0.15534177f, -0.03859359f, 
    -0.03249143f, -0.22296445f, 0.09423734f, 0.05945772f, -0.01693590f, -0.01638198f, 0.33316213f, -0.36669427f, 
    -0.05873410f, -0.00146090f, 0.05516199f, 0.01172549f, 0.08389086f, -0.03246585f, 0.04895555f, 0.10173268f, 
    0.01238919f, 0.18420884f, 0.05977393f, 0.10224211f, 0.04968018f, 0.05910721f, 0.04177422f, 0.02262876f, 
    -0.31491888f, -0.23253676f, 0.00379757f, -0.01199545f, -0.08518002f, -0.01664781f, 0.00747453f, -0.01596478f, 
    0.08046129f, 0.01368903f, 0.03285513f, 0.00377990f, 0.11887912f, -0.00711439f, 0.04400428f, 0.06386250f, 
    0.01191564f, 0.02698276f, -0.04914510f, 0.00218909f, -0.13379598f, -0.11439244f, 0.15849583f, 0.03871208f, 
    0.13535812f, -0.06167922f, -0.05237321f, -0.26817447f, 0.00122412f, 0.08339371f, -0.13800514f, 0.00461601f, 
    0.00908596f, 0.04009803f, -0.11978505f, 0.02749393f, 0.01643919f, -0.01690928f, -0.08174983f, -0.03896454f, 
    0.08696703f, 0.05098088f, 0.21577987f, 0.12474999f, -0.05725140f, 0.04214578f, -0.31040654f, -0.19262172f, 
    -0.01095997f, 0.03329137f, 0.16774699f, -0.03506541f, -0.06938881f, 0.11046498f, 0.12015022f, 0.02086775f, 
    -0.00211644f, -0.10148463f, 0.01004558f, 0.07463598f, -0.09801953f, 0.14758882f, 0.04555013f, -0.05548520f, 
    -0.11216670f, -0.20257154f, -0.00490163f, 0.06903630f, -0.12945022f, 0.20143701f, 0.07404079f, 0.18996283f, 
    0.01215556f, 0.14342159f, -0.12903254f, -0.01264661f, -0.08646313f, 0.02239574f, 0.10377836f, 0.05982664f, 
    -0.01634921f, -0.21365412f, 0.00261724f, -0.05972144f, -0.10180658f, -0.06631792f, 0.06855213f, 0.00570770f, 
    -0.01099737f, -0.00444436f, -0.14052305f, -0.13731906f, -0.44814157f, 0.11675028f, -0.02709312f, 0.14083238f, 
    0.03077152f, 0.08748068f, 0.01913585f, 0.11140069f, -0.09743401f, -0.03142904f, -0.07321273f, -0.08261727f, 
    -0.04850017f, 0.05832788f, 0.03515618f, 0.05322951f, 0.11958949f, 0.10150915f, 0.26167494f, -0.04815270f, 
    -0.06981838f, -0.02430361f, 0.07003588f, 0.14693733f, 0.12739573f, 0.12744538f, -0.04037273f, 0.01449301f, 
    0.03427410f, 0.07570159f, 0.06237157f, 0.04341026f, -0.08095712f, 0.09447969f, 0.06173113f, -0.18459243f, 
    0.11813740f, -0.02425225f, 0.05737429f, 0.04146570f, 0.06156318f, 0.00245819f, 0.09470139f, -0.07066173f, 
    -0.35761583f, -0.02711265f, 0.14828849f, 0.10203521f, -0.14705254f, 0.14355633f, -0.05347570f, -0.01757120f, 
    0.09659798f, -0.03187109f, 0.14920796f, -0.06183373f, 0.12712635f, 0.01618794f, 0.00376687f, -0.10238659f, 
    0.03441162f, -0.25919387f, -0.48839435f, -0.37431765f, 0.11068674f, 0.01375995f, -0.03884054f, 0.06288071f, 
    0.02071062f, -0.03809902f, -0.24507044f, 0.10446355f, -0.12168045f, 0.03913498f, -0.10050993f, 0.04772181f, 
    -0.02179833f, 0.06378897f, -0.00071565f, 0.12042320f, 0.02725248f, -0.06423158f, 0.10109744f, 0.06727225f, 
    0.16356465f, 0.15764062f, 0.11179501f, 0.00832759f, -0.00467084f, 0.27076918f, 0.05311911f, -0.08519240f, 
    -0.08050659f, 0.04458411f, 0.00411147f, 0.03412122f, 0.04618800f, -0.13184568f, -0.12448256f, 0.02290627f, 
    0.01617728f, -0.03776040f, 0.01335472f, -0.01784641f, 0.07581146f, -0.02087105f, 0.20552680f, 0.05621937f, 
    -0.24373293f, -0.06640793f, -0.18693128f, -0.03757131f, 0.07700774f, 0.05863759f, 0.03467200f, 0.31731650f, 
    0.01918013f, 0.08758662f, -0.05010826f, 0.00868653f, 0.17180799f, -0.13805979f, -0.01635696f, 0.08935108f, 
    -0.48132783f, -0.33587512f, -0.65159720f, 0.18769199f, -0.05578078f, -0.10345132f, 0.04231670f, -0.04954452f, 
    0.02691912f, 0.16935642f, -0.28242773f, 0.10377557f, 0.03561455f, -0.13959195f, 0.06409100f, -0.03693373f, 
    0.11375160f, -0.17390521f, -0.15344195f, 0.14779255f, 0.17002951f, -0.07843667f, 0.00177222f, -0.00796087f, 
    0.02038225f, 0.06216563f, -0.00229541f, 0.04956727f, 0.00653049f, -0.06592898f, 0.10983508f, 0.17304783f, 
    -0.04780509f, 0.08417910f, 0.04482120f, -0.12464880f, -0.03767890f, -0.14130867f, -0.07735679f, 0.00902613f, 
    -0.08388697f, -0.00904456f, -0.01286269f, 0.02090316f, 0.06310138f, -0.25079185f, -0.50109601f, -0.21660942f, 
    -0.12348622f, -0.20247157f, 0.02935559f, -0.07508670f, 0.08407834f, 0.18728322f, -0.45422795f, -0.08333191f, 
    -0.41470686f, -0.06524622f, 0.03530463f, 0.05213347f, 0.05231772f, 0.03164659f, -0.05397949f, -0.17573707f, 
    0.11391693f, -0.29745591f, 0.07662328f, 0.09758648f, -0.04725861f, -0.07076209f, 0.13589971f, 0.05440142f, 
    -0.26858029f, -0.21199873f, -0.24978620f, -0.10654679f, 0.12661377f, 0.16172026f, 0.08392540f, -0.02210130f, 
    -0.07468355f, -0.03653922f, -0.31414589f, -0.10055192f, -0.22044550f, 0.01295781f, 0.01016864f, -0.00453966f, 
    -0.02115277f, 0.12013201f, 0.04821629f, 0.06215470f, 0.11047797f, 0.02925401f, 0.01669810f, 0.05272880f, 
    0.15920177f, 0.05059404f, 0.02574630f, 0.21499498f, 0.01281534f, 0.16893041f, -0.01653978f, -0.01709941f, 
    -0.08865226f, 0.09059296f, -0.13158888f, 0.04179674f, 0.21039735f, 0.19335766f, 0.09340290f, 0.15834653f, 
    0.04495309f, 0.06763557f, 0.13663182f, 0.10874180f, 0.03366033f, 0.17448679f, -0.09674401f, -0.24397250f, 
    -0.08666784f, -0.11287598f, 0.06219404f, -0.06032767f, -0.01479684f, -0.06270966f, -0.10231019f, -0.21028104f, 
    0.07180427f, 0.16353925f, 0.00444545f, -0.05194166f, 0.10591168f, 0.05296511f, 0.06112927f, 0.15560685f, 
    0.15961564f, 0.02351100f, -0.00062120f, 0.01140502f, 0.03810895f, -0.00923324f, 0.01997312f, -0.04787853f, 
    0.11413459f, 0.03849879f, 0.14973353f, -0.03551319f, 0.03941121f, 0.07702468f, 0.00215461f, 0.06267454f, 
    -0.03396508f, -0.05450229f, -0.47772846f, -0.12918845f, 0.07096770f, 0.00401887f, -0.05986853f, -0.07596351f, 
    -0.05339558f, -0.05133981f, -0.06903520f, -0.41362482f, -0.02220406f, 0.24664687f, 0.02272056f, 0.13329095f, 
    -0.08253612f, 0.02681514f, 0.05533580f, -0.09761727f, -0.31830427f, -0.07849035f, -0.09636734f, -0.01296693f, 
    0.02109302f, 0.04872232f, 0.09624314f, -0.05300002f, -0.04520643f, -0.01746713f, -0.15909475f, 0.03539296f, 
    -0.05184766f, -0.01987525f, 0.02871014f, 0.05041966f, 0.07811349f, -0.04973231f, 0.02687367f, 0.26648754f, 
    -0.07154305f, -0.02235268f, -0.16533987f, 0.12573168f, -0.14306201f, 0.09703030f, 0.32425284f, 0.05545921f, 
    0.18916853f, -0.00972195f, -0.00114564f, -0.04529577f, 0.02764373f, 0.10749710f, 0.01350804f, 0.06249299f, 
    -0.24242032f, -0.20184471f, 0.19208592f, -0.24291365f, 0.11018831f, -0.05738733f, -0.14681290f, 0.06296740f, 
    -0.02195079f, 0.08261167f, 0.39767820f, 0.04595449f, -0.08661178f, -0.18056545f, 0.08733568f, 0.08514059f, 
    -0.04164832f, -0.31161535f, -0.20932564f, 0.02457543f, -0.21474604f, -0.02915082f, 0.01692066f, -0.08883087f, 
    -0.11373352f, 0.05421314f, 0.18753190f, -0.29799449f, -0.19225158f, -0.15818505f, -0.06579302f, -0.04260205f, 
    0.04289371f, 0.01453099f, -0.05587075f, -0.19821867f, -0.06999037f, -0.06295413f, -0.08030602f, 0.11845655f, 
    0.09664953f, -0.01417035f, -0.07209435f, 0.06817871f, -0.14118662f, -0.07970528f, 0.01102907f, 0.15043031f, 
    0.07506762f, 0.04596042f, 0.07060646f, -0.07961485f, 0.00055852f, 0.15326141f, 0.03390495f, 0.02223685f, 
    -0.00058137f, 0.17158218f, 0.01826326f, 0.13486375f, 0.06681842f, -0.07132651f, -0.29595777f, -0.54548556f, 
    0.33665425f, -0.00911716f, -0.09763541f, 0.10553922f, -0.11481065f, 0.06890354f, -0.02852476f, -0.34010038f, 
    0.18093041f, -0.11326904f, 0.01192535f, 0.04156136f, -0.20479952f, 0.13221398f, 0.01985534f, -0.17525931f, 
    -0.16152288f, -0.33991861f, -0.17844710f, -0.18845378f, -0.07789086f, 0.00589348f, -0.15265216f, 0.04214736f, 
    -0.02681422f, -0.23134081f, 0.08409183f, 0.14269423f, -0.07283862f, -0.09137812f, -0.10969179f, 0.04442086f, 
    -0.00330196f, 0.06957389f, 0.00708596f, 0.01134406f, 0.47328097f, 0.06523861f, -0.07851210f, 0.02439381f, 
    -0.06526560f, -0.04952847f, 0.15995131f, -0.26846820f, -0.19641595f, 0.04629859f, -0.16316341f, 0.05917200f, 
    -0.03543805f, -0.04022590f, -0.25966090f, 0.00956354f, 0.63151360f, -0.05845984f, 0.04520083f, -0.15878540f, 
    -0.06253134f, 0.10527208f, -0.03425477f, 0.03687627f, -0.04045833f, -0.09889662f, -0.22778836f, 0.67131293f, 
    0.07033946f, -0.04755843f, 0.15968080f, 0.16204366f, 0.06414574f, -0.22022940f, 0.01259671f, -0.43176100f, 
    -0.33351520f, 0.12763141f, 0.03529288f, 0.16943069f, -0.02051471f, -0.09516023f, -0.02020719f, -0.33336490f, 
    -0.41122085f, -0.01114412f, 0.11637746f, 0.01024261f, -0.09781739f, 0.02669752f, -0.01352856f, -0.05572283f, 
    0.41548017f, -0.38761011f, -0.05007220f, 0.09755685f, -0.10659350f, -0.04011674f, 0.00723919f, 0.04100963f, 
    -0.06009615f, 0.08835100f, -0.20270547f, 0.00240455f, 0.17487459f, -0.21914119f, 0.00026597f, -0.02144801f, 
    0.04827924f, -0.08947305f, 0.06537756f, 0.05524948f, -0.16460821f, 0.13569772f, 0.11307369f, -0.00411581f, 
    -0.01210835f, 0.02110438f, 0.13091695f, -0.07345028f, -0.04032319f, 0.03231226f, -0.08455681f, 0.02217745f, 
    0.06038541f, -0.00726790f, 0.07654334f, 0.04481591f, 0.11297096f, 0.05333070f, -0.20140965f, -0.07651025f, 
    0.00716068f, 0.07718746f, 0.07756977f, 0.03701933f, 0.05201502f, 0.22225361f, -0.00609574f, -0.17422855f, 
    -0.12675282f, 0.13128455f, 0.07230175f, -0.13537553f, 0.02641878f, -0.16584331f, -0.49018207f, -0.12757382f, 
    -0.08122683f, -0.13833092f, -0.09261548f, 0.16475135f, 0.12028654f, 0.01309328f, 0.05032264f, -0.18957189f, 
    0.09830646f, 0.30294418f, -0.09556995f, 0.02846055f, 0.00287824f, -0.07132716f, 0.09235297f, 0.11669343f, 
    0.16531967f, -0.02846513f, -0.12525712f, 0.08483787f, 0.15758821f, 0.13193673f, 0.08648843f, -0.00261099f, 
    0.08024186f, -0.03936050f, 0.00264757f, 0.13679028f, -0.16592774f, -0.02687812f, -0.03403994f, 0.17451446f, 
    0.10580213f, 0.00788338f, -0.06721593f, -0.15488775f, -0.11875387f, 0.12729639f, 0.14194925f, 0.05360137f, 
    0.15169197f, 0.03738162f, 0.03466586f, -0.06054631f, -0.06730407f, 0.18223487f, -0.03647831f, -0.03994704f, 
    0.02209722f, -0.08947828f, -0.08017507f, 0.07551321f, -0.17397161f, -0.05669940f, -0.15829828f, -0.23732941f, 
    -0.16167991f, -0.07041547f, 0.05058656f, -0.11720667f, 0.21390708f, 0.08211487f, 0.31754419f, 0.22591370f, 
    0.07935704f, -0.08132869f, -0.01221281f, 0.10071942f, -0.01104728f, -0.02763470f, 0.01492937f, -0.35656360f, 
    0.09041900f, 0.00721342f, 0.02787407f, 0.02659402f, 0.01454078f, 0.07070153f, 0.01555227f, -0.02856050f, 
    0.03723994f, 0.19741984f, -0.08453377f, -0.05965344f, -0.03505189f, 0.15847515f, 0.07506450f, -0.20968980f, 
    0.24921885f, -0.44490796f, -0.04541344f, 0.05929599f, 0.09398030f, 0.11566295f, -0.15554932f, 0.01737091f, 
    0.05717010f, 0.20053579f, 0.08328485f, -0.01607249f, -0.02800125f, 0.05787515f, 0.10753369f, 0.05553021f, 
    0.02693552f, 0.06603862f, 0.13276082f, 0.08146744f, -0.03976752f, -0.09329125f, 0.09699380f, 0.02142622f, 
    0.00894853f, 0.15663391f, 0.09893385f, 0.12667733f, 0.10394592f, 0.04234286f, 0.05993955f, -0.06809007f, 
    0.02835248f, -0.02736857f, -0.03743231f, -0.10094401f, -0.31069604f, -0.30994102f, -0.14924817f, 0.04927149f, 
    -0.06531683f, 0.03268071f, 0.06025328f, 0.02325632f, 0.15916663f, -0.13550313f, 0.09022964f, -0.10070653f, 
    0.02836683f, -0.08728279f, -0.01359444f, 0.01479435f, 0.11488310f, 0.12136091f, -0.31384897f, -0.45496756f, 
    0.06457950f, -0.08880241f, -0.02738990f, -0.00488879f, 0.04246967f, 0.03244343f, -0.04836933f, -0.29362434f, 
    -0.18895946f, -0.51993394f, -0.00964025f, 0.21102560f, 0.18336770f, -0.01163066f, -0.09454251f, -0.12602486f, 
    0.14602260f, 0.03183715f, -0.08327547f, -0.00748186f, -0.01517870f, 0.16458622f, -0.00565060f, 0.07354644f, 
    -0.07020806f, -0.23853648f, -0.02727723f, -0.39778900f, 0.11984970f, 0.14497373f, 0.10213526f, 0.00741691f, 
    0.02111255f, -0.12319272f, -0.08061258f, -0.08087089f, -0.22989881f, 0.05867659f, 0.11000406f, -0.05209346f, 
    0.07802365f, -0.05730049f, 0.07185756f, 0.07013451f, -0.28294009f, -0.31460240f, 0.03270445f, 0.03128685f, 
    -0.03902831f, 0.02696768f, 0.06787175f, -0.18291797f, 0.24982621f, 0.17394491f, 0.01073856f, -0.21409068f, 
    0.06021443f, 0.00581615f, 0.07796741f, -0.09102774f, -0.17580003f, -0.40180278f, 0.13679864f, 0.12419964f, 
    -0.06482664f, 0.19985221f, 0.01179816f, -0.00964239f, 0.16314803f, -0.12908268f, -0.25441873f, -0.00535115f, 
    -0.07075080f, -0.00017677f, -0.03921023f, 0.33498818f, 0.16458637f, -0.02089492f, 0.02677835f, 0.20779338f, 
    0.07479747f, -0.07407162f, 0.05384235f, 0.01179452f, -0.05866791f, -0.06511755f, -0.06114645f, -0.16027032f, 
    0.08395811f, 0.01875718f, -0.33512869f, -0.04526566f, 0.00803521f, 0.00817914f, 0.10689186f, 0.10402558f, 
    0.12383202f, 0.07737086f, -0.01534237f, 0.10341877f, -0.11926998f, 0.17348926f, -0.00437106f, 0.07826740f, 
    0.07283159f, -0.08641105f, -0.26868618f, -0.09733697f, 0.01422084f, 0.00674375f, -0.11724050f, -0.03656916f, 
    0.04256823f, 0.10236845f, 0.03131733f, 0.52902150f, -0.69137114f, -0.54070359f, -0.11840605f, -0.00676905f, 
    0.09211282f, -0.01571324f, 0.01012255f, -0.02351538f, -0.41671163f, -0.45919850f, -0.01457672f, 0.10927478f, 
    0.08093104f, 0.01595209f, -0.07519192f, 0.02273645f, 0.13759562f, -0.09588393f, -0.59428602f, -0.11573607f, 
    -0.10977789f, -0.12596676f, 0.18885103f, 0.19132833f, 0.03998957f, -0.26366499f, 0.00769239f, -0.19986247f, 
    -0.25180790f, 0.11560588f, 0.00227659f, -0.07286371f, -0.13572957f, -0.11967304f, -0.01816520f, -0.36429560f, 
    -0.40975899f, 0.15125638f, 0.07533550f, -0.11963642f, -0.12754941f, -0.12056756f, 0.00030343f, 0.02219964f, 
    0.00038979f, -0.11143534f, -0.09438451f, 0.03448376f, 0.11612783f, 0.02009969f, -0.09410328f, -0.00296938f, 
    -0.01010976f, 0.20311676f, 0.33519730f, 0.07829166f, -0.02648442f, -0.08241068f, 0.03567855f, 0.04368946f, 
    -0.06203210f, 0.02306361f, 0.15350784f, 0.01911684f, 0.07956161f, 0.04904385f, 0.02677643f, 0.06008470f, 
    -0.20906644f, -0.08827919f, 0.05379508f, -0.23895653f, -0.08173954f, -0.10361850f, -0.10135122f, -0.24791425f, 
    0.11255983f, -0.07186528f, 0.12553713f, 0.11365702f, -0.00383193f, -0.01392836f, 0.12015350f, 0.01159361f, 
    -0.05599035f, -0.00202133f, -0.08065524f, -0.16052125f, 0.15415050f, 0.03813433f, 0.10506882f, 0.05615936f, 
    -0.13349506f, 0.13241728f, 0.03068401f, 0.07378453f, 0.06877118f, 0.05865678f, 0.15669338f, -0.17191182f, 
    -0.21454747f, 0.04432904f, -0.01819345f, 0.16797999f, -0.02835903f, 0.00073331f, 0.02414958f, 0.06039674f, 
    0.15868764f, 0.11044710f, 0.12850088f, -0.06316174f, -0.01829786f, 0.03628271f, -0.11340342f, 0.12684076f, 
    -0.00425578f, -0.11145823f, -0.17025641f, 0.09821844f, -0.01471167f, 0.03517604f, -0.07135306f, -0.15554768f, 
    0.05954400f, 0.18191928f, 0.23194771f, 0.25383782f, -0.10625486f, 0.06553629f, -0.28514907f, 0.01155524f, 
    0.00569144f, -0.06258504f, 0.13113756f, -0.05572571f, -0.05119549f, -0.02678589f, 0.00345247f, 0.11244307f, 
    0.03904922f, 0.22750692f, 0.11287537f, -0.07804535f, 0.03147725f, -0.01735136f, 0.05563280f, -0.04784751f, 
    -0.07191198f, -0.01014577f, -0.00326926f, -0.08036297f, -0.31015304f, -0.28623691f, -0.03533180f, -0.10923798f, 
    0.02514622f, 0.01200611f, -0.04618426f, 0.08933175f, -0.09876215f, 0.07569686f, 0.04425259f, 0.13494664f, 
    -0.08200532f, -0.05387482f, -0.08100894f, 0.08465082f, 0.05877750f, 0.22111042f, -0.13796845f, -0.03288233f, 
    -0.11155257f, -0.00004072f, -0.11033837f, 0.09209003f, 0.06662405f, 0.17544152f, -0.04608583f, -0.08526379f, 
    -0.42893118f, -0.03863588f, -0.02674788f, -0.05397642f, 0.16390848f, -0.06724700f, 0.08290380f, 0.19581424f, 
    0.36979118f, 0.09606134f, 0.16087890f, -0.09336139f, 0.03348310f, -0.30041781f, 0.09163275f, -0.06203154f, 
    -0.04945078f, -0.27810299f, -0.24459824f, -0.17702428f, -0.05322207f, 0.10323372f, 0.06577795f, -0.02626540f, 
    0.04220408f, -0.15518807f, -0.05233052f, -0.15340590f, 0.08265570f, 0.18290152f, 0.10819670f, 0.07499225f, 
    -0.05054678f, -0.05921654f, 0.20602776f, 0.04169794f, 0.00888692f, 0.12186068f, -0.04734249f, 0.05399730f, 
    -0.08581047f, 0.01602239f, -0.21620508f, 0.09631631f, 0.06064210f, 0.12244643f, -0.07751396f, 0.15359317f, 
    -0.00341028f, 0.07452284f, 0.01156323f, -0.05151251f, -0.04602975f, 0.08337453f, 0.23847213f, 0.18416414f, 
    0.12610573f, 0.04876181f, 0.02951116f, -0.00503746f, 0.23797615f, 0.23050897f, -0.04025383f, 0.07001176f, 
    0.18707089f, -0.15717302f, 0.09305111f, -0.06340236f, -0.03638110f, 0.06810671f, 0.13057511f, 0.11207487f, 
    0.00150005f, 0.02988103f, -0.06084882f, 0.06762505f, -0.12830971f, 0.01844918f, 0.12133137f, -0.09454563f, 
    0.07852004f, 0.27866456f, 0.04990477f, -0.00895360f, 0.00644154f, -0.04920568f, -0.04814512f, 0.00594534f, 
    0.02719464f, -0.05073463f, 0.18136156f, -0.15344700f, 0.05394742f, -0.05779616f, 0.07692318f, 0.05209676f, 
    0.08796912f, 0.02843926f, -0.22140907f, -0.08053537f, -0.04495960f, -0.03437566f, 0.03281149f, 0.07198898f, 
    0.07589070f, 0.06760885f, -0.14725989f, 0.30219448f, -0.17355333f, -0.33343276f, 0.03017237f, -0.07774710f, 
    0.08608770f, -0.18627563f, -0.00972922f, 0.02877147f, -0.21372278f, -0.19207500f, -0.01064875f, 0.01582007f, 
    0.12050934f, -0.01504630f, 0.00187060f, 0.02428889f, -0.03314958f, 0.22054049f, -0.22294587f, -0.09490553f, 
    0.06901511f, 0.07345885f, -0.10988808f, 0.14184435f, -0.14606425f, 0.04170701f, 0.02071020f, -0.08092548f, 
    0.15592469f, 0.03262172f, 0.14504358f, 0.18664287f, -0.08519568f, 0.13148750f, -0.00531834f, -0.16085108f, 
    0.06637961f, 0.22353412f, 0.05388251f, -0.06753141f, 0.01624719f, 0.11572347f, 0.02421709f, 0.01978223f, 
    -0.02797611f, 0.00607685f, -0.00515360f, -0.06693805f, -0.06737306f, -0.01838298f, 0.02749652f, -0.08523446f, 
    0.01798054f, -0.04786329f, 0.01847926f, 0.02930185f, -0.04313812f, -0.02694498f, -0.02279996f, -0.01765611f, 
    -0.03177208f, -0.05748411f, -0.00726828f, -0.09906919f, -0.07783313f, -0.03779745f, -0.00839147f, -0.03477027f, 
    0.00729192f, -0.07273866f, -0.05927134f, 0.05528311f, -0.03917409f, -0.03885505f, -0.00446708f, -0.00324415f, 
    -0.02280194f, -0.02961150f, -0.01755616f, 0.02931298f, 0.05331384f, 0.06871741f, 0.02503692f, 0.03756515f, 
    -0.04941851f, 0.02865730f, -0.03979446f, -0.07159363f, 0.01161643f, -0.09263662f, -0.04722748f, -0.01530474f, 
    -0.03204845f, 0.00162690f, -0.09743667f, -0.00882689f, -0.02724607f, -0.02708211f, 0.00002669f, -0.04384518f, 
    0.00040208f, -0.03697508f, 0.02816410f, -0.06593019f, -0.03950441f, -0.02074887f, 0.01410512f, -0.01218805f, 
    -0.08052222f, -0.02493567f, -0.02490059f, -0.10509379f, -0.03939652f, 0.00846265f, 0.02985409f, -0.02661440f, 
    -0.03231803f, 0.06079570f, -0.00999980f, 0.03239457f, 0.02125468f, -0.06218446f, 0.01292542f, 0.01752703f, 
    -0.01124121f, -0.05541315f, -0.05793377f, -0.00360056f, -0.08900803f, -0.09700002f, 0.00445532f, 0.01255403f, 
    0.02710416f, -0.04483168f, -0.03113462f, -0.01454598f, 0.03592781f, -0.02304713f, 0.01797082f, 0.00392506f, 
    0.01618250f, -0.04098041f, 0.01833269f, 0.01384458f, -0.04408200f, 0.01780992f, -0.07866079f, -0.08754932f, 
    0.01140416f, -0.05409838f, -0.03778980f, -0.03456445f, 0.01154969f, 0.02007303f, -0.03929524f, -0.07123362f, 
    0.01448331f, -0.04097481f, -0.02280214f, -0.02086690f, -0.04106624f, 0.02976072f, 0.02375199f, 0.03463245f, 
    -0.08403238f, -0.01878991f, -0.01975385f, -0.02793898f, -0.04521952f, -0.02070674f, 0.05285331f, 0.02422229f, 
    -0.01782158f, 0.00482446f, -0.05208920f, -0.00849091f, -0.03448752f, 0.03270003f, 0.00789246f, 0.02913838f, 
    0.00779395f, 0.02460930f, 0.05392735f, -0.05092967f, 0.02041413f, -0.00765979f, -0.08373382f, -0.08137062f, 
    -0.08300211f, -0.09011937f, -0.06618052f, 0.01377050f, 0.02066778f, -0.02259525f, -0.01981064f, -0.08796854f, 
    -0.03857911f, -0.03287209f, -0.04834561f, -0.05645803f, -0.02278334f, -0.06754856f, -0.04593444f, -0.04640247f, 
    -0.05336222f, -0.06943405f, 0.05484755f, 0.07645208f, -0.01285820f, -0.00842358f, 0.00488167f, 0.02495556f, 
    -0.01893538f, -0.04258777f, -0.03620742f, -0.01350065f, -0.01933173f, -0.06634447f, 0.03309906f, -0.05927689f, 
    0.00722225f, 0.00573169f, -0.07168511f, -0.08378437f, -0.06296091f, -0.00454137f, -0.03723715f, -0.10196655f, 
    -0.07360084f, -0.03234534f, -0.06330466f, 0.01444371f, -0.00114188f, -0.01110514f, -0.06503847f, -0.04086817f, 
    -0.07859567f, 0.02973717f, -0.05773212f, 0.02587735f, 0.05634535f, 0.02140007f, -0.03267564f, 0.00011546f, 
    -0.03373402f, -0.01665120f, 0.00046685f, 0.01625467f, -0.00444295f, -0.07680661f, -0.05010977f, -0.03424133f, 
    -0.03495673f, -0.09053893f, -0.00639063f, -0.04604156f, -0.07847404f, -0.03681750f, 0.00696592f, -0.02273879f, 
    -0.07058097f, -0.00618077f, -0.04513035f, -0.03745088f, -0.07800222f, -0.07583332f, -0.09491393f, -0.06188505f, 
    0.00380695f, -0.00505986f, 0.00692073f, -0.01181321f, -0.07445761f, -0.07512019f, -0.00977723f, -0.04030908f, 
    -0.02494834f, -0.00654971f, -0.07620569f, -0.00242183f, -0.04584129f, -0.01351712f, -0.03940149f, -0.05515907f, 
    -0.04070218f, -0.03120188f, -0.05318515f, 0.00738173f, 0.09294058f, 0.00970572f, 0.05103542f, 0.05759785f, 
    -0.01163637f, -0.06601292f, -0.00796021f, 0.02013783f, 0.02176640f, -0.03631054f, -0.04475009f, -0.04386939f, 
    -0.08213840f, -0.08338523f, -0.02356178f, -0.04040918f, -0.05143550f, -0.00531660f, 0.02773676f, 0.03272428f, 
    0.02353116f, -0.00117423f, 0.01169011f, 0.00398930f, -0.01014470f, 0.01704921f, -0.08813871f, -0.08399766f, 
    -0.05630096f, -0.00470264f, -0.06471585f, -0.05693058f, -0.01326968f, 0.00773887f, -0.03569693f, 0.06588688f, 
    0.06188898f, -0.00439511f, -0.05357846f, 0.00843799f, -0.00660386f, 0.01113156f, -0.01966194f, 0.02808128f, 
    0.06852850f, 0.06226488f, 0.01744722f, 0.12710513f, 0.00184720f, 0.07061898f, 0.09254623f, 0.01532892f, 
    0.06754339f, -0.18132329f, -0.01772425f, 0.21906723f, 0.02823324f, -0.08363346f, -0.15038209f, 0.20179881f, 
    0.11027567f, 0.01403571f, -0.00566980f, 0.01362153f, 0.12512116f, 0.06971341f, 0.05497125f, -0.00276023f, 
    -0.01390156f, -0.07600171f, 0.06183023f, -0.10511673f, -0.16675590f, -0.02174034f, -0.10523446f, -0.08188535f, 
    -0.17049277f, 0.02486995f, -0.09104048f, 0.00570387f, -0.22478248f, 0.16143513f, -0.02479004f, -0.12472995f, 
    0.03251415f, -0.01102561f, 0.16116418f, 0.19103441f, 0.22463065f, -0.02060369f, 0.00630660f, 0.31760558f, 
    0.00810765f, -0.02964140f, -0.01592769f, 0.13971308f, -0.00692964f, 0.19364654f, -0.29155284f, -0.48760062f, 
    -0.16443387f, 0.06809537f, 0.21320812f, 0.04093844f, 0.07063851f, -0.01344715f, 0.01650324f, -0.14410000f, 
    -0.12099030f, 0.19424683f, -0.10750779f, -0.19613780f, -0.12185441f, 0.13171238f, 0.02419848f, -0.00207081f, 
    0.15144609f, 0.08879440f, -0.06939059f, 0.02562341f, 0.06326018f, -0.04939471f, 0.06695918f, 0.08442840f, 
    0.09758963f, 0.07804088f, 0.08194126f, 0.17784815f, -0.04734634f, 0.08347133f, -0.05392880f, -0.05584450f, 
    0.11317519f, 0.01607183f, 0.06730235f, 0.12591679f, 0.15547185f, -0.02535220f, 0.11780349f, -0.06461027f, 
    0.05205647f, -0.02220085f, 0.10038346f, 0.03485598f, 0.08450067f, 0.01687616f, -0.00664253f, 0.04671179f, 
    -0.07889514f, -0.05321922f, 0.05243352f, -0.01747587f, 0.12089913f, 0.03091566f, -0.09596945f, 0.02735566f, 
    -0.18091331f, -0.00498488f, 0.16688183f, -0.06588431f, 0.06720547f, -0.11350518f, 0.15980831f, 0.00435030f, 
    -0.00350360f, 0.05486024f, 0.00297539f, 0.02857769f, -0.09429256f, 0.08853285f, -0.19693904f, -0.46688086f, 
    0.05601261f, -0.07457511f, -0.01810787f, -0.15223579f, 0.05284003f, -0.23237577f, -0.15934847f, -0.04028624f, 
    -0.07762668f, -0.33922538f, -0.08932132f, -0.06957264f, -0.15113232f, 0.01646001f, -0.11639439f, 0.09190314f, 
    -0.01582080f, 0.13302737f, 0.13040659f, 0.05628691f, 0.01145781f, 0.00895815f, -0.06405275f, -0.03204883f, 
    0.09080087f, -0.64722705f, -0.37936819f, -0.51974249f, 0.08486558f, 0.04830304f, 0.03517579f, 0.09186038f, 
    -0.02657204f, 0.06332240f, -0.18895759f, -0.08696954f, 0.00731929f, 0.03889620f, -0.04159795f, -0.13989504f, 
    0.00951771f, 0.02143683f, 0.02996360f, 0.09257256f, 0.19762254f, 0.09635641f, 0.13888825f, -0.00924672f, 
    -0.15337703f, 0.01802391f, 0.08403927f, 0.05184854f, -0.07618071f, -0.16128230f, 0.02507033f, -0.08548337f, 
    0.00980099f, 0.03734098f, 0.16040485f, -0.15068899f, 0.03795191f, -0.33878085f, -0.42739987f, -0.12224009f, 
    -0.03456820f, -0.15859997f, 0.01408271f, 0.13911508f, -0.05195651f, 0.02439537f, -0.23976690f, -0.26740319f, 
    -0.36954755f, -0.02407530f, -0.11045775f, 0.10853963f, 0.06287298f, -0.15854216f, -0.03558825f, 0.02582606f, 
    0.13920014f, 0.04324511f, 0.10980040f, -0.07702456f, -0.15991303f, -0.06548753f, -0.00066474f, -0.04636602f, 
    0.08927716f, 0.17711492f, 0.13605423f, 0.01312062f, -0.07403158f, -0.14538150f, -0.04189507f, 0.01148437f, 
    0.10114534f, 0.12163084f, -0.20143503f, 0.15880333f, -0.05584437f, 0.08160921f, -0.02960996f, 0.04079439f, 
    -0.05337446f, 0.03515537f, 0.17342857f, -0.18866427f, -0.04650542f, -0.09204843f, -0.04959434f, 0.07097427f, 
    0.20623451f, -0.04487582f, -0.14243291f, -0.24295636f, -0.18362528f, -0.38011652f, -0.06870840f, 0.09371569f, 
    0.03782219f, 0.14037581f, 0.10125045f, 0.03756602f, -0.05978518f, -0.11554510f, 0.04480063f, -0.00205267f, 
    0.08602855f, 0.00552705f, 0.02721700f, 0.06323802f, -0.06353435f, -0.28881621f, -0.72955453f, -0.30340391f, 
    -0.15585779f, -0.11689170f, 0.10381065f, -0.00723429f, -0.08140257f, -0.02955143f, -0.08567229f, -0.05094485f, 
    0.05181165f, -0.04731634f, -0.14466894f, -0.11893719f, 0.14962962f, 0.05649993f, 0.04287064f, 0.09349472f, 
    -0.00311874f, 0.08165563f, 0.02551907f, -0.05615075f, -0.13142401f, 0.04472008f, 0.03963328f, 0.01625258f, 
    0.03512559f, 0.02113422f, 0.22742403f, -0.13003647f, 0.14851971f, 0.06011930f, 0.03041999f, 0.11728062f, 
    0.18096268f, 0.11045334f, 0.00517235f, 0.03531420f, 0.08363504f, -0.02459965f, -0.02605194f, 0.09321382f, 
    -0.10575952f, 0.13448210f, 0.12385311f, -0.00007242f, 0.11343111f, 0.07305364f, 0.05410658f, 0.10621551f, 
    0.01352726f, 0.15620469f, 0.06314252f, 0.02202414f, -0.04861627f, 0.01302457f, -0.06590135f, -0.02081722f, 
    -0.10920971f, -0.19742374f, -0.12176720f, -0.13776192f, -0.19213413f, -0.11086825f, 0.08177956f, 0.06604005f, 
    -0.13230385f, 0.03321041f, 0.15052603f, -0.00907768f, -0.25996307f, -0.07816575f, -0.14982495f, -0.06578914f, 
    -0.05063593f, 0.05462328f, 0.03866183f, -0.03454652f, -0.00124101f, -0.20167145f, -0.12160044f, 0.01482076f, 
    0.04804146f, 0.09408476f, -0.15459296f, -0.04030617f, 0.00266076f, 0.03708461f, 0.06622077f, -0.00424926f, 
    -0.06983984f, 0.09728540f, 0.07709165f, -0.05452428f, -0.01076542f, 0.11556455f, 0.12167036f, 0.11875693f, 
    -0.07438169f, 0.00575118f, 0.08968306f, 0.11612362f, -0.01929501f, -0.08396724f, 0.04878204f, -0.01235061f, 
    -0.00676487f, 0.14700207f, 0.10783900f, 0.21635021f, 0.10439184f, -0.06505247f, 0.05405511f, -0.15650338f, 
    -0.13239589f, 0.00262684f, 0.04529051f, -0.14354791f, 0.01231160f, 0.07349142f, 0.05093605f, -0.06341563f, 
    -0.04372811f, -0.02659707f, -0.13607742f, 0.07296471f, 0.01918124f, 0.03109426f, -0.05241672f, 0.02816790f, 
    0.21168402f, -0.10595575f, 0.05666003f, 0.17594905f, -0.04807378f, -0.13994883f, -0.14183490f, -0.03384786f, 
    0.01737535f, 0.01673876f, 0.05762022f, -0.01315619f, 0.13791886f, 0.02303445f, -0.08647312f, -0.19748265f, 
    -0.00225553f, -0.07073328f, 0.06757784f, -0.05445992f, 0.09420755f, -0.12903656f, -0.00086481f, 0.09511990f, 
    0.04577693f, 0.13647935f, -0.03865300f, 0.02919485f, 0.00498594f, -0.11586122f, -0.17329781f, -0.11098708f, 
    -0.01739678f, 0.03404775f, 0.09522983f, -0.18517178f, -0.08550872f, -0.22068284f, -0.17316538f, -0.08540708f, 
    0.21597028f, -0.08464869f, 0.08145572f, 0.07103516f, 0.03906731f, 0.07905171f, -0.10916909f, -0.08094214f, 
    -0.13654302f, 0.02315435f, -0.17423049f, -0.00862443f, 0.12913536f, 0.03750709f, -0.17905167f, -0.01684563f, 
    -0.04481350f, 0.04263252f, -0.06583612f, -0.25993702f, -0.15941805f, 0.01765675f, 0.14980802f, 0.09529792f, 
    -0.01048727f, 0.00956242f, 0.03041255f, 0.20160705f, 0.08416109f, 0.18158850f, -0.04981263f, 0.07613958f, 
    0.19409379f, 0.04840118f, 0.00749879f, 0.16133697f, -0.10004523f, -0.10664682f, -0.08835067f, 0.19056706f, 
    0.06001216f, -0.01812074f, 0.03340935f, 0.00312115f, -0.01616811f, 0.06256858f, 0.23021820f, -0.05689418f, 
    0.05224360f, -0.07193062f, -0.00488111f, -0.04686280f, 0.00936843f, -0.10876504f, 0.27376831f, 0.02816098f, 
    0.03428430f, 0.01622089f, -0.05056571f, 0.09406325f, -0.07349800f, 0.02269461f, 0.02290010f, 0.13290712f, 
    -0.08319738f, 0.35519576f, 0.04351957f, 0.04160356f, 0.15406831f, -0.01103320f, -0.14294334f, -0.01826703f, 
    0.12178220f, -0.26863059f, 0.16650537f, -0.11444206f, 0.20769046f, -0.02492396f, 0.05876353f, -0.01592328f, 
    0.09702774f, 0.08721803f, -0.01311391f, 0.01887402f, 0.10635303f, 0.05094935f, 0.02636141f, -0.00422772f, 
    0.10577955f, -0.02429403f, -0.11719035f, -0.08073406f, -0.13832244f, 0.00384313f, 0.04240287f, 0.03202708f, 
    0.01226528f, 0.03682181f, 0.14186274f, -0.20274445f, -0.02846602f, 0.15570229f, -0.01207182f, -0.07559821f, 
    -0.02831041f, -0.06340200f, -0.14402840f, -0.01522567f, -0.03189114f, 0.05963912f, -0.12255712f, -0.18174553f, 
    -0.02985656f, 0.07783110f, 0.06004085f, 0.08220659f, -0.02754959f, -0.04619481f, 0.21994458f, -0.01541827f, 
    0.09820395f, 0.10006229f, 0.17455441f, -0.01700251f, 0.17514327f, 0.04122936f, 0.13935670f, 0.03313524f, 
    0.11373324f, -0.03572294f, -0.21601632f, -0.13290082f, -0.00774833f, 0.13069017f, 0.13610063f, -0.17021653f, 
    -0.06725346f, -0.34400210f, 0.10824833f, 0.10112549f, 0.02719921f, 0.05504951f, -0.00620464f, 0.11680247f, 
    0.31249493f, 0.07320501f, 0.04200794f, 0.03798928f, -0.02435247f, 0.13355005f, 0.21121471f, 0.05665675f, 
    0.24825050f, 0.08820277f, 0.09190192f, 0.08286881f, 0.10297217f, 0.15716793f, 0.11517677f, 0.01325308f, 
    0.06405955f, 0.15750512f, -0.23202878f, 0.16822994f, -0.01331457f, -0.09836220f, -0.03942738f, -0.07534949f, 
    0.05291878f, 0.12342533f, -0.03167991f, -0.13151017f, -0.14123671f, -0.10500102f, 0.00758243f, -0.15047646f, 
    -0.07869495f, 0.03967627f, -0.18351243f, -0.36232242f, -0.13550995f, -0.03974130f, 0.15690735f, 0.04760651f, 
    -0.04204798f, 0.06443148f, 0.06380281f, 0.15805921f, -0.27803186f, -0.17847477f, -0.01922432f, 0.04552078f, 
    0.12079250f, 0.02153626f, 0.08126851f, 0.05397374f, -0.02383194f, 0.06090190f, -0.12223556f, -0.00577274f, 
    0.10103276f, 0.18127534f, -0.01044425f, 0.12685840f, 0.06056250f, 0.08778711f, 0.12790255f, -0.20220137f, 
    0.01374762f, 0.04841001f, -0.18092760f, 0.04603802f, 0.09400458f, 0.01824777f, 0.01997606f, 0.06650282f, 
    0.02713514f, 0.18275623f, 0.14194529f, 0.04340588f, 0.13185571f, 0.16503002f, 0.14805579f, -0.00705030f, 
    0.11110894f, -0.28408617f, 0.03560680f, -0.27050713f, -0.01539503f, -0.06094132f, 0.04570084f, 0.03538255f, 
    0.03555726f, -0.04009015f, 0.00686993f, 0.06100834f, 0.01391513f, 0.11797664f, 0.08836321f, 0.02785535f, 
    0.09590455f, -0.03967617f, 0.09715173f, -0.10359279f, -0.04444312f, -0.06494701f, 0.04973231f, 0.15720294f, 
    0.11598007f, 0.17836995f, 0.13869268f, 0.27267736f, -0.03429738f, -0.08086786f, 0.08644632f, 0.05762986f, 
    -0.02849877f, -0.02129681f, 0.08558580f, 0.06250434f, -0.05795898f, -0.30230850f, -0.06505597f, -0.12918091f, 
    0.03554993f, -0.01777452f, -0.00185131f, -0.23157428f, -0.29031840f, -0.36129788f, -0.12905706f, 0.03754708f, 
    0.05652603f, 0.02264120f, 0.04687635f, -0.26601633f, 0.13763605f, -0.15177685f, 0.12321088f, 0.13944270f, 
    0.10657885f, 0.21200028f, -0.13303211f, -0.09813689f, -0.08146554f, 0.05918035f, -0.04598096f, -0.12236875f, 
    -0.15488891f, -0.10777881f, -0.22206742f, -0.01858439f, -0.13782842f, -0.03984277f, -0.12166414f, 0.04514103f, 
    -0.02146911f, -0.14031002f, -0.11444255f, 0.21146879f, -0.08011877f, -0.00883953f, 0.18932009f, -0.01714340f, 
    -0.00656382f, 0.07348953f, -0.08867563f, 0.11585594f, 0.16520309f, -0.04389367f, 0.19463737f, 0.07075649f, 
    -0.08994311f, -0.16320710f, 0.03991213f, -0.13099113f, 0.22228740f, -0.09506074f, 0.15643537f, 0.06069576f, 
    0.21442059f, 0.31399956f, 0.16824667f, 0.18764329f, -0.18923010f, -0.23602596f, -0.16771799f, 0.07084189f, 
    -0.06852641f, -0.19448671f, -0.08828828f, 0.06205015f, -0.01673811f, -0.35487673f, 0.24953233f, -0.09325416f, 
    0.13352816f, 0.04819250f, -0.26966932f, 0.13462013f, 0.18607134f, -0.14745897f, 0.15940687f, 0.09362112f, 
    -0.13979033f, 0.03783662f, 0.09943941f, 0.10128617f, 0.05435365f, 0.14862593f, -0.01166831f, 0.04524545f, 
    0.05384399f, -0.02696965f, 0.01949707f, -0.22393991f, 0.11630137f, 0.02654559f, 0.17511629f, -0.04134069f, 
    -0.35304084f, 0.05264585f, 0.00411937f, -0.03283330f, -0.01261712f, -0.01928821f, -0.19847426f, -0.35131535f, 
    -0.08454401f, -0.04931083f, 0.10601992f, 0.02462075f, -0.02076988f, 0.20187449f, 0.05171922f, 0.05184053f, 
    0.06536583f, 0.04374260f, -0.14985260f, -0.16192718f, -0.04179763f, 0.16355215f, -0.01654354f, 0.09744964f, 
    0.03255404f, 0.11494015f, 0.16583650f, 0.02202413f, 0.19157358f, 0.14221247f, -0.02309694f, -0.06733937f, 
    -0.05398910f, 0.19046727f, 0.16223446f, 0.00101309f, 0.07674649f, 0.10788221f, 0.17303747f, -0.00788205f, 
    0.15361734f, 0.10061767f, -0.01910945f, 0.07171525f, 0.05089807f, -0.08495060f, 0.14524813f, -0.06861244f, 
    -0.10056169f, 0.18245591f, -0.07036243f, -0.02746143f, 0.04180788f, 0.09757902f, 0.03568286f, -0.13512197f, 
    -0.25856766f, -0.18209578f, 0.01637773f, -0.11613403f, 0.03180744f, 0.16387758f, 0.10591052f, -0.19327933f, 
    0.12172656f, 0.24683110f, -0.02997170f, 0.16364309f, 0.22142953f, -0.04837953f, -0.02491225f, 0.02262715f, 
    -0.00940629f, 0.01886804f, -0.02942492f, -0.02343445f, -0.00004409f, -0.05909188f, -0.05908916f, -0.02604502f, 
    0.00839346f, -0.01359197f, 0.03577394f, 0.01628041f, 0.05203883f, 0.02796337f, -0.05118567f, -0.02822761f, 
    -0.03247520f, -0.02302634f, -0.05391739f, 0.02564412f, -0.04287419f, 0.05151194f, -0.05893872f, -0.02937135f, 
    -0.01522475f, -0.05881931f, 0.04724170f, -0.00069798f, 0.04946984f, 0.03808642f, -0.05109154f, -0.01852228f, 
    -0.05206833f, -0.02000468f, -0.05493059f, -0.03531227f, -0.02538616f, 0.00960529f, 0.01592975f, 0.04230143f, 
    -0.04027488f, -0.02190529f, 0.03587233f, -0.03062212f, 0.02338417f, 0.03349179f, -0.05756971f, -0.05636853f, 
    -0.04873979f, -0.04926885f, 0.01686145f, -0.00241128f, 0.00020399f, -0.03288701f, 0.02744642f, -0.04773961f, 
    -0.05059773f, -0.05413292f, -0.03991330f, -0.02176500f, -0.03538844f, -0.04206674f, 0.01755799f, -0.00538329f, 
    0.01600911f, -0.04407010f, 0.04092266f, -0.04565943f, -0.04901532f, 0.04692715f, -0.03179584f, 0.04048434f, 
    -0.00152699f, -0.06328300f, -0.01155188f, -0.04075096f, 0.02787336f, -0.03524460f, 0.02970120f, 0.03799744f, 
    0.04656045f, -0.04879328f, 0.05547529f, -0.05251520f, -0.03894807f, -0.00022463f, -0.03709917f, -0.04264156f, 
    -0.01757750f, -0.03555408f, 0.04850437f, 0.01467991f, 0.01757863f, -0.00801968f, -0.04459956f, 0.02272560f, 
    -0.03762500f, -0.05551243f, 0.00070906f, -0.01799292f, 0.01522747f, 0.03064989f, -0.02027535f, 0.04985376f, 
    -0.01276476f, -0.05497712f, 0.03688118f, 0.00107279f, -0.01672560f, 0.04320228f, -0.02085089f, 0.01096966f, 
    -0.04778085f, 0.05726276f, 0.00635524f, 0.02531744f, 0.03017064f, -0.00148558f, 0.05024515f, 0.02921421f, 
    -0.03247008f, -0.03961643f, 0.02446401f, -0.00816058f, -0.03820258f, 0.02184292f, 0.05594253f, -0.03411558f, 
    -0.04389416f, -0.01724799f, -0.06524618f, -0.01258015f, 0.02549163f, -0.00069532f, 0.03238493f, -0.00719903f, 
    0.04045065f, -0.05192097f, -0.00579867f, -0.04276565f, 0.02848667f, -0.02597332f, -0.02836145f, -0.01468775f, 
    -0.00067749f, 0.01485994f, 0.02425714f, -0.02256260f, 0.05149056f, -0.06279849f, 0.01785742f, -0.05444158f, 
    -0.05668340f, -0.04176617f, -0.05944341f, 0.00624822f, -0.04625276f, 0.02568075f, 0.01842180f, -0.00352659f, 
    -0.06618518f, 0.01093158f, -0.05425345f, 0.04003243f, -0.06169460f, -0.01759805f, -0.01985639f, 0.02713953f, 
    0.02570330f, 0.00656659f, 0.04798847f, -0.03986134f, -0.05597718f, 0.04414985f, -0.04006973f, 0.01786877f, 
    0.01798671f, -0.05362160f, 0.04213011f, 0.02595733f, -0.02584852f, 0.01886824f, -0.01312377f, 0.04604575f, 
    0.00699703f, -0.01209447f, -0.02228635f, -0.03487349f, -0.00882123f, 0.03380984f, -0.05850317f, -0.06137638f, 
    0.01126204f, -0.06724240f, 0.01747344f, 0.02135196f, -0.01543227f, -0.01628385f, 0.04819761f, 0.05533839f, 
    0.04427125f, 0.00099534f, -0.05103983f, 0.03812273f, -0.05939281f, -0.04008443f, -0.02542417f, -0.03807374f, 
    -0.02170660f, 0.00696879f, -0.03228646f, 0.05747582f, -0.02261291f, -0.03490872f, 0.01874856f, 0.03892093f, 
    0.05329750f, -0.05015248f, -0.04951267f, 0.04066034f, -0.04249123f, 0.01348581f, 0.01020345f, -0.02404312f, 
    0.04835261f, 0.01316993f, 0.05512064f, -0.02616940f, 0.02240288f, 0.03375917f, 0.03606385f, -0.00952513f, 
    0.03068339f, 0.00047836f, -0.00735157f, 0.04019783f, 0.02702233f, -0.03585405f, 0.01359636f, 0.05506603f, 
    -0.01444409f, -0.04891723f, -0.00089680f, -0.02560057f, 0.03088794f, -0.00237899f, 0.03662764f, -0.03951626f, 
    -0.05705215f, -0.03491196f, 0.01476533f, -0.00100469f, -0.06269559f, -0.03090794f, 0.02865748f, -0.00189853f, 
    -0.02694889f, -0.06805391f, -0.01693953f, 0.00135953f, -0.04744210f, 0.01306505f, -0.01680055f, -0.04757067f, 
    -0.04556894f, -0.00670296f, 0.02126480f, 0.00535063f, 0.04356053f, -0.04184878f, 0.01978857f, -0.05551755f, 
    0.03981885f, -0.01629999f, -0.02894334f, 0.02975489f, 0.02393712f, -0.06696651f, 0.02233019f, 0.02583168f, 
    -0.05311372f, 0.00754541f, -0.02625041f, -0.00286321f, -0.04317565f, -0.03257328f, 0.03159859f, -0.02049829f, 
    -0.00531891f, -0.00353682f, -0.03569958f, -0.06540907f, 0.00204616f, -0.01166278f, -0.06132585f, -0.00434366f, 
    0.04070104f, 0.00844254f, -0.05778032f, -0.02722164f, 0.04664793f, -0.01842790f, -0.02516831f, -0.04923826f, 
    -0.06115688f, 0.00170594f, -0.00536521f, -0.00162659f, 0.04240877f, -0.02459087f, -0.05204425f, -0.00573935f, 
    -0.00203690f, -0.02086766f, -0.05396291f, -0.02621109f, -0.05179913f, 0.01887793f, -0.04844949f, -0.00283163f, 
    -0.00747924f, 0.03453671f, -0.03172917f, -0.04686546f, -0.05492573f, -0.00013256f, -0.02034492f, -0.06020082f, 
    -0.03072078f, 0.04539847f, 0.01622717f, -0.04483406f, -0.00858142f, 0.02648171f, 0.04895434f, -0.06088745f, 
    0.04314660f, -0.01084471f, -0.06456087f, -0.04205490f, -0.01704059f, -0.01031597f, -0.01377560f, -0.01269109f, 
    -0.05492347f, 0.02778543f, 0.03556771f, 0.04788207f, -0.00856692f, -0.01961844f, 0.04195939f, 0.01110021f, 
    -0.04976662f, -0.01270286f, -0.03210820f, -0.03571190f, -0.05869907f, 0.05102373f, -0.04988853f, 0.00394818f, 
    0.04779148f, -0.00446577f, -0.03468245f, -0.00497088f, -0.01630946f, -0.05492783f, 0.00241907f, -0.00481684f, 
    0.00352718f, -0.04519241f, 0.03181488f, 0.01671558f, 0.03989711f, -0.06701059f, -0.00487151f, -0.03569574f, 
    -0.00782916f, 0.03742703f, -0.02223931f, -0.02930945f, 0.02471464f, -0.06527253f, -0.03397965f, -0.02212767f, 
    -0.03590092f, -0.01926675f, -0.03676024f, -0.00588924f, 0.04291746f, -0.03990696f, -0.05701392f, -0.00042545f, 
    -0.00492267f, -0.05924727f, -0.01794090f, 0.04910251f, 0.01247757f, -0.03248366f, 0.03984525f, -0.02570128f, 
    -0.02625363f, 0.01886813f, 0.01957113f, -0.00907689f, -0.03654423f, -0.06661912f, -0.04924228f, -0.01430857f, 
    -0.01541188f, -0.00087763f, 0.01840540f, -0.01805184f, 0.02830548f, -0.04052639f, -0.02438712f, -0.04747152f, 
    0.02111189f, 0.01563066f, -0.06116386f, 0.01184135f, -0.02814416f, -0.01997647f, 0.02490790f, -0.03113570f, 
    -0.03541688f, -0.05762465f, -0.01532855f, 0.05011639f, -0.00641985f, -0.00620042f, 0.03063522f, 0.02699819f, 
    0.02474690f, 0.03027644f, -0.02157649f, -0.01017313f, -0.00946922f, 0.01273235f, -0.04590945f, 0.03717092f, 
    -0.01357243f, 0.00244662f, -0.00340039f, -0.03455499f, -0.04651147f, -0.05688048f, 0.03310815f, 0.01838164f, 
    -0.06777464f, 0.00159057f, 0.05537670f, -0.00511086f, 0.05297167f, -0.00593396f, 0.00240185f, 0.01656074f, 
    0.02692707f, -0.03248534f, -0.05623362f, -0.03000829f, 0.04894605f, -0.00079512f, -0.05750558f, -0.04955001f, 
    0.01716854f, -0.05081157f, 0.03353046f, -0.02644815f, 0.03780558f, -0.04852610f, -0.05010340f, -0.00623249f, 
    0.04053940f, 0.03042135f, 0.00223550f, 0.00691419f, 0.00099859f, 0.01625914f, 0.03829099f, 0.01465835f, 
    0.03495809f, -0.02295838f, 0.00638128f, -0.05009556f, 0.00346230f, -0.00007806f, -0.00000674f, -0.04265193f, 
    0.01976722f, -0.05727095f, -0.03920912f, 0.02427633f, -0.02605914f, 0.00440405f, 0.02955614f, 0.01765430f, 
    -0.04188509f, 0.03391747f, 0.02676981f, 0.02080946f, 0.04468238f, -0.03419505f, 0.03658676f, 0.03980007f, 
    -0.05803053f, 0.04146920f, 0.01859080f, 0.02665291f, -0.02336497f, -0.06540063f, 0.04498241f, 0.03354280f, 
    0.00770374f, 0.00123997f, -0.05556304f, 0.01990500f, 0.01267077f, 0.05011434f, -0.03955716f, -0.00698848f, 
    0.00542423f, 0.00431851f, -0.00070169f, 0.01804033f, -0.02306446f, -0.04344616f, -0.04960024f, 0.02486117f, 
    -0.03143069f, -0.00362183f, -0.03814974f, 0.01207209f, -0.05838576f, -0.06211550f, -0.01260281f, 0.04360310f, 
    0.04048170f, 0.01178874f, -0.00851736f, -0.02501681f, 0.02504820f, 0.02009481f, -0.02077078f, 0.04892090f, 
    0.03407670f, -0.04478859f, 0.02251421f, -0.02597351f, 0.00169987f, -0.04020559f, -0.02869395f, -0.01513698f, 
    0.00756944f, 0.02406268f, -0.04078635f, 0.04155346f, 0.01605632f, 0.03714321f, -0.04241379f, -0.01530570f, 
    -0.04426539f, 0.04731709f, -0.04590237f, -0.06181755f, -0.01362909f, 0.04199241f, 0.03004044f, -0.02420533f, 
    -0.01617173f, -0.05037208f, -0.05837481f, -0.01552641f, -0.02941171f, -0.06644308f, -0.05075320f, 0.00304765f, 
    0.08295596f, -0.00262479f, 0.10635086f, 0.00610422f, -0.00497682f, -0.00996188f, 0.00209128f, 0.08658624f, 
    0.14333583f, -0.52407414f, -0.29019117f, 0.13734369f, -0.07120363f, -0.04038792f, -0.20124963f, -0.00068396f, 
    -0.01297255f, 0.07204740f, -0.21907826f, -0.32920516f, 0.03390548f, 0.01057672f, 0.09218004f, 0.09089225f, 
    -0.07771059f, 0.11905091f, -0.18163250f, -0.32818228f, -0.12287952f, 0.02868170f, 0.04966312f, 0.00497517f, 
    -0.01695721f, -0.00612409f, 0.00430408f, -0.03416956f, 0.01491767f, 0.07021374f, 0.25931352f, 0.07943574f, 
    -0.02735444f, -0.02130875f, 0.22250217f, -0.01174491f, -0.08830357f, -0.18245314f, -0.14336285f, 0.00900220f, 
    -0.07898192f, 0.12395583f, -0.13617174f, 0.02570795f, 0.04869395f, -0.09062122f, 0.19287093f, 0.02869709f, 
    0.24469094f, -0.00463185f, -0.04920411f, 0.06578244f, 0.14484537f, -0.03096494f, 0.09674208f, 0.02128275f, 
    0.06284146f, -0.00316834f, 0.01602686f, -0.05962131f, 0.00643399f, -0.06868482f, -0.12778805f, 0.04255736f, 
    0.07076321f, 0.11424684f, 0.27723795f, 0.02499300f, -0.03624365f, 0.00055104f, 0.03636777f, -0.00554170f, 
    0.02641908f, -0.45639122f, -0.05265113f, -0.14962453f, 0.00287677f, -0.06436093f, 0.04443686f, -0.04841182f, 
    -0.02262276f, 0.07559047f, -0.36052454f, -0.21175313f, -0.19674832f, -0.11521050f, -0.09631276f, -0.10829783f, 
    -0.07169697f, 0.03261603f, 0.10159576f, -0.11326183f, 0.10177295f, 0.18559997f, -0.06653214f, 0.00991630f, 
    0.00268575f, -0.00978105f, -0.06398550f, 0.06907059f, 0.06643461f, 0.25246140f, 0.07439640f, -0.01088597f, 
    -0.01039734f, 0.05008958f, -0.05199838f, -0.06114716f, -0.16415380f, 0.24749441f, -0.08305719f, 0.10443316f, 
    0.15282470f, 0.00729212f, 0.08922207f, 0.23005645f, -0.06277683f, -0.07300424f, -0.63264179f, -0.26262841f, 
    0.14060560f, -0.02891551f, 0.13560954f, -0.04361695f, -0.05067121f, -0.00268618f, 0.08818002f, -0.13950916f, 
    0.11090670f, -0.04445918f, 0.03328228f, -0.11660424f, -0.01193624f, 0.05775597f, -0.03413963f, 0.09686227f, 
    -0.14703684f, -0.61151975f, -0.37845957f, 0.10383714f, -0.13683222f, 0.03224682f, 0.01235850f, 0.00999028f, 
    0.05672615f, -0.33481166f, 0.02158939f, -0.01892013f, -0.01035873f, 0.03676869f, 0.04415558f, -0.03170494f, 
    0.03521206f, 0.00322147f, 0.11749926f, 0.11577464f, 0.49517441f, -0.06432959f, 0.10047527f, 0.10461523f, 
    -0.16040537f, 0.00500796f, -0.00387262f, 0.01050004f, 0.19442159f, 0.34268060f, 0.15604877f, 0.07414794f, 
    -0.06718851f, -0.10123005f, -0.09446824f, -0.03505987f, -0.18054715f, -0.04421807f, -0.09083187f, -0.04710617f, 
    0.06512599f, 0.03868808f, 0.08517666f, -0.00866906f, 0.07769734f, 0.02505837f, -0.13052426f, -0.00859459f, 
    0.06070691f, -0.18332882f, -0.24816178f, -0.24916747f, 0.01694686f, 0.05861706f, -0.13165519f, -0.43519223f, 
    -0.25372985f, -0.12155931f, 0.07031260f, -0.07746465f, 0.03337508f, 0.25081685f, -0.18358913f, -0.19581266f, 
    0.26903179f, -0.32256949f, 0.09121697f, -0.17879717f, 0.00991025f, -0.00539637f, 0.09436989f, -0.00441107f, 
    -0.36962622f, -0.16430326f, 0.35608456f, -0.12749086f, 0.08506451f, 0.07008535f, -0.11470236f, -0.02313612f, 
    -0.04437846f, -0.21688882f, -0.03107759f, -0.10717434f, 0.06156085f, -0.00032480f, -0.08379315f, 0.20196632f, 
    0.02503367f, -0.01998461f, 0.15136109f, 0.09273062f, 0.06514952f, 0.06424708f, 0.00898268f, -0.10418933f, 
    0.03923767f, -0.04810768f, 0.11273841f, -0.17081079f, -0.02007012f, 0.07203624f, -0.01371040f, 0.11229759f, 
    -0.03792400f, 0.10238549f, -0.07219486f, 0.04031320f, 0.12241957f, 0.03540111f, 0.18605137f, 0.08022302f, 
    0.05742177f, 0.06390570f, 0.07237054f, -0.04312954f, -0.03158713f, 0.30176345f, 0.03271919f, 0.04760301f, 
    -0.00547022f, 0.08835378f, -0.13876684f, 0.16897909f, 0.25141385f, 0.02835748f, -0.06759600f, 0.27343529f, 
    -0.04757333f, -0.01595281f, -0.03325946f, 0.00630668f, 0.05778180f, 0.16076566f, -0.03341997f, 0.09820043f, 
    0.26153469f, 0.27441862f, 0.07474236f, 0.15422174f, 0.08704013f, -0.02175550f, -0.18327089f, 0.01332955f, 
    0.02771168f, -0.09678423f, 0.09920079f, -0.22514838f, -0.05530746f, -0.02178144f, -0.13374297f, -0.00842363f, 
    0.04785065f, 0.15924972f, 0.32107788f, -0.14480186f, -0.21311559f, 0.03977522f, 0.15048240f, 0.04665026f, 
    0.10760918f, -0.05560593f, -0.02122552f, -0.05446839f, -0.09553009f, -0.01547127f, -0.11230139f, 0.03777819f, 
    -0.02544760f, -0.07340718f, -0.01989719f, -0.05270303f, -0.02947881f, -0.15590733f, 0.19078411f, -0.02772348f, 
    -0.23729397f, -0.16320294f, 0.08645917f, 0.14602344f, 0.30920711f, 0.30138677f, 0.21219775f, -0.00222658f, 
    0.09780777f, 0.05982241f, 0.10011687f, 0.05123853f, 0.06673316f, -0.10913716f, 0.02553340f, -0.08253120f, 
    -0.01743077f, -0.11034556f, -0.00983687f, 0.16244128f, 0.15686347f, 0.14131011f, 0.00878713f, -0.07933816f, 
    0.17612338f, 0.05842672f, 0.19152325f, 0.10160830f, 0.02185674f, -0.07177194f, -0.01230031f, -0.02010433f, 
    -0.05899341f, -0.12701614f, -0.01446845f, -0.08366564f, 0.01604946f, -0.02753591f, 0.17324145f, -0.20324808f, 
    0.00791730f, 0.12742721f, 0.23850812f, -0.06696195f, 0.12477992f, 0.07877923f, 0.07484823f, 0.00327245f, 
    -0.09572271f, -0.00818207f, -0.20949893f, -0.16491935f, -0.06327758f, -0.09884404f, -0.03910308f, 0.01935268f, 
    0.02509253f, 0.14215857f, -0.10469870f, 0.08099160f, -0.06855874f, -0.07388516f, 0.04819069f, -0.17638247f, 
    -0.08613573f, 0.24360897f, 0.13151506f, -0.06378277f, 0.00733278f, -0.05600899f, -0.09765874f, -0.07928605f, 
    0.11089043f, -0.03107792f, -0.00002426f, -0.02783904f, -0.04783837f, 0.17548814f, 0.02801198f, -0.40063047f, 
    0.05177983f, 0.01426049f, -0.15782328f, 0.06522994f, -0.30425704f, 0.12579854f, 0.20372826f, 0.16560037f, 
    0.04766676f, -0.01108500f, 0.06821837f, -0.10508425f, 0.09395377f, -0.07018322f, -0.03293426f, -0.10107118f, 
    -0.17955606f, 0.08815416f, 0.02066796f, 0.02890784f, 0.13545831f, 0.30424437f, 0.01504104f, 0.06753471f, 
    -0.10602924f, 0.00399590f, 0.02302768f, 0.03374934f, -0.10343425f, 0.11990613f, -0.01084516f, 0.08391935f, 
    -0.00280258f, 0.08615714f, -0.33800286f, 0.03392502f, -0.17050269f, -0.16274068f, 0.22157228f, -0.04263592f, 
    0.11585432f, -0.12653898f, -0.03505323f, 0.00252518f, -0.07416838f, 0.12596591f, 0.10023628f, 0.07834339f, 
    0.28770360f, -0.04686728f, 0.12532249f, 0.05593770f, 0.16549981f, 0.00337341f, 0.01300902f, -0.22722316f, 
    -0.02046837f, -0.21948786f, -0.01769220f, -0.03396343f, 0.02246865f, 0.01033365f, 0.08170372f, 0.06210928f, 
    0.08881333f, -0.10086492f, 0.03668883f, 0.14981399f, -0.00269252f, -0.18651810f, -0.13816272f, -0.09476905f, 
    -0.17734827f, -0.03825721f, -0.15531051f, 0.19389060f, 0.04246238f, 0.11634740f, 0.05365951f, -0.10432491f, 
    -0.00636014f, -0.06575760f, 0.04822414f, -0.03087076f, -0.15469526f, -0.03670154f, 0.17040120f, 0.18281499f, 
    -0.19135351f, 0.05320077f, 0.01250757f, -0.02785335f, -0.14435233f, -0.07295039f, -0.20622684f, 0.19743724f, 
    -0.03023206f, -0.16333035f, -0.02769824f, 0.04520769f, 0.11053203f, 0.12630387f, 0.04741662f, 0.09336748f, 
    -0.17513105f, 0.06093085f, 0.06115118f, -0.17806681f, 0.00301223f, 0.08820525f, -0.13387196f, -0.03934234f, 
    -0.03063243f, 0.15599339f, -0.06562831f, -0.13243312f, 0.01962755f, -0.09112968f, 0.06524729f, 0.08927165f, 
    0.00404465f, -0.01003405f, 0.05328588f, -0.05728144f, -0.01217150f, -0.06468353f, 0.03398256f, 0.13894351f, 
    -0.11253774f, -0.11096726f, -0.11435787f, 0.00788455f, 0.01580700f, 0.19627815f, 0.10868802f, 0.01327725f, 
    -0.01847888f, 0.11514810f, 0.05599423f, -0.04353461f, 0.14853156f, 0.09292995f, -0.05584223f, -0.00012875f, 
    0.01662192f, 0.04173362f, -0.02074605f, -0.05366334f, -0.15691026f, 0.22103508f, -0.17978711f, 0.15135749f, 
    0.09356932f, -0.03616570f, 0.18525411f, -0.02940988f, 0.00820933f, -0.08649353f, 0.32196504f, 0.01313053f, 
    0.19314069f, -0.06640373f, -0.01551700f, -0.02714052f, -0.25087756f, 0.07370051f, 0.02768124f, 0.21227096f, 
    0.16752045f, 0.03777079f, -0.07513990f, 0.00428334f, -0.11447686f, -0.04504744f, -0.17536639f, -0.07793383f, 
    -0.14901686f, -0.27527827f, 0.05610049f, -0.03804281f, 0.08728521f, -0.02087176f, 0.02764375f, 0.11740892f, 
    0.13514352f, -0.63586849f, 0.10852208f, -0.13475356f, -0.16062206f, -0.05425523f, -0.11857663f, 0.07333228f, 
    0.09629063f, -0.05795641f, 0.15785874f, -0.69634789f, -0.33581653f, 0.06748397f, 0.06874547f, -0.22468901f, 
    -0.04671679f, -0.02998488f, 0.05432302f, 0.11165502f, 0.11910310f, 0.13699283f, -0.15860777f, -0.05891104f, 
    -0.15555093f, 0.07573799f, 0.06167899f, 0.13580574f, 0.08098707f, 0.20507927f, 0.11188568f, 0.14450501f, 
    -0.03987630f, 0.02843084f, 0.09422754f, 0.02020854f, 0.15024315f, 0.64259845f, -0.29172099f, -0.07437569f, 
    -0.02987933f, -0.11222322f, 0.05558189f, -0.05424112f, 0.00972380f, -0.14791755f, 0.04113179f, 0.03061095f, 
    -0.08039201f, 0.03295045f, -0.04896080f, 0.17793180f, -0.02010478f, 0.01295436f, -0.03031241f, 0.03036065f, 
    -0.23463301f, 0.13296707f, 0.07524378f, -0.08287062f, 0.00973530f, 0.05991647f, 0.09000815f, -0.10092521f, 
    0.12618035f, 0.14500543f, 0.10537860f, 0.00192551f, 0.05783858f, 0.14640893f, 0.09944884f, -0.09655762f, 
    -0.06582821f, -0.03689147f, -0.34459925f, -0.00680667f, -0.09162839f, -0.15036239f, -0.11881562f, -0.02554481f, 
    0.05123812f, -0.04172913f, -0.62578619f, -0.25618914f, -0.08417634f, -0.08090702f, -0.13917336f, -0.03617672f, 
    0.18517005f, 0.08812880f, -0.07764171f, 0.07918427f, 0.03193604f, -0.00624614f, -0.16632640f, 0.06590480f, 
    -0.04583637f, -0.01864989f, 0.11228160f, 0.13151041f, 0.17446914f, 0.11596430f, 0.05611271f, -0.05770514f, 
    -0.00810581f, -0.07256722f, 0.03614433f, -0.09143370f, 0.12975401f, -0.07024032f, 0.07873575f, 0.10018504f, 
    -0.00424253f, 0.02716686f, -0.01715755f, -0.02316371f, -0.01409208f, -0.13104984f, 0.29104665f, -0.60149157f, 
    0.03107570f, -0.22645360f, 0.01305307f, 0.14153354f, 0.13696799f, 0.10851318f, 0.00180792f, 0.27607244f, 
    -0.09375931f, 0.15879814f, 0.09774266f, 0.04480796f, 0.05217388f, 0.10936686f, -0.05895145f, -0.06646515f, 
    0.18579622f, -0.22202733f, -0.14260043f, -0.05834801f, -0.34994310f, -0.08757342f, 0.00920872f, -0.00367393f, 
    -0.05897880f, 0.45855442f, -0.17341428f, -0.27866518f, -0.10863037f, 0.03062342f, 0.12812449f, -0.02601313f, 
    0.07165012f, 0.10151192f, 0.05721622f, -0.05186351f, 0.21136495f, -0.01962148f, 0.03517823f, -0.16842450f, 
    -0.12510079f, 0.15624106f, -0.03014240f, -0.19576395f, 0.07977357f, 0.11134692f, -0.10131599f, -0.06276559f, 
    -0.13093884f, 0.02820861f, -0.11598647f, 0.10368200f, -0.17570053f, -0.24493848f, -0.22447893f, -0.21558139f, 
    -0.18453309f, 0.01361183f, -0.02568192f, 0.08069413f, 0.11883070f, -0.39860773f, -0.44878155f, 0.01168174f, 
    0.11272570f, 0.00140772f, 0.01831337f, 0.19562434f, 0.09303682f, 0.09643380f, -0.11282201f, -0.40664858f, 
    -0.82296520f, 0.13236229f, -0.00381746f, 0.08075735f, 0.04725520f, 0.07835386f, 0.05201435f, -0.07072732f, 
    0.00889331f, 0.24937059f, -0.13776477f, 0.05339223f, -0.00600923f, -0.04584045f, 0.08626188f, 0.01419533f, 
    -0.19346450f, -0.26491961f, 0.08517820f, 0.00900790f, -0.00925676f, -0.09588753f, -0.10688541f, -0.03550487f, 
    -0.02275894f, -0.08872148f, -0.23873918f, -0.22945668f, 0.05798229f, -0.21489389f, -0.06074114f, -0.02325073f, 
    0.06144471f, -0.04065764f, -0.05360903f, 0.09476357f, 0.10166124f, -0.02791803f, 0.01079079f, -0.10294927f, 
    0.04686429f, -0.01525152f, 0.04178950f, 0.15888898f, 0.02796246f, 0.14401996f, 0.04054394f, 0.03497762f, 
    0.11156369f, -0.00729038f, 0.02346648f, 0.02948596f, 0.06756420f, 0.08401723f, 0.11575091f, -0.11425143f, 
    0.00123466f, -0.10071597f, -0.00417245f, 0.15161584f, 0.07708987f, 0.16122229f, 0.16025051f, 0.02485055f, 
    -0.15520324f, -0.00097096f, 0.16272657f, -0.04145668f, 0.05727551f, -0.03672858f, -0.35060352f, -0.26318705f, 
    0.36854669f, 0.04342909f, 0.11255935f, -0.00661102f, 0.01654169f, 0.09565809f, 0.07178870f, 0.10015822f, 
    0.09937886f, 0.02535624f, -0.15119392f, 0.06902741f, -0.23271234f, 0.09060114f, -0.10850024f, 0.16081113f, 
    -0.03350245f, 0.02275295f, -0.02415535f, 0.04730665f, -0.05128325f, 0.00186623f, -0.02813242f, 0.02503104f, 
    0.04061206f, -0.01566705f, 0.03416529f, -0.02951925f, 0.02974989f, -0.00274740f, 0.03662283f, 0.04587769f, 
    -0.02282131f, 0.02735783f, 0.05223005f, 0.02577914f, -0.01696811f, -0.02223667f, -0.05576583f, -0.04107741f, 
    -0.03902357f, 0.04294236f, 0.02316117f, -0.03893457f, -0.03226523f, 0.01716155f, -0.01888759f, -0.04323675f, 
    0.00732302f, 0.01098181f, 0.00204639f, 0.02490892f, -0.01666624f, 0.05492530f, 0.05168990f, -0.05005955f, 
    -0.05530327f, 0.03183408f, 0.03641665f, 0.04697915f, -0.03326798f, 0.00649077f, -0.03101167f, -0.04712892f, 
    -0.03502961f, -0.00106886f, -0.05159386f, -0.05364819f, -0.03852265f, 0.04729038f, 0.02823420f, -0.00815008f, 
    -0.05030012f, -0.02189712f, -0.00127722f, -0.00255070f, 0.04077251f, -0.01063838f, -0.02319009f, 0.02582938f, 
    -0.02197279f, 0.03874500f, 0.02310902f, 0.00870300f, 0.05156857f, -0.00575281f, 0.04207492f, 0.01883735f, 
    -0.05953728f, 0.00250426f, -0.04532055f, 0.04447314f, -0.00572648f, 0.05114958f, -0.05931738f, -0.00690891f, 
    0.02121043f, -0.01490807f, -0.01868513f, 0.05197184f, -0.03457280f, -0.02388478f, 0.04110025f, -0.01890795f, 
    0.04568770f, 0.01684085f, -0.01051763f, 0.00446479f, 0.04996657f, -0.00088261f, 0.04910246f, 0.04447355f, 
    0.01206032f, -0.05762959f, -0.03021805f, 0.03999826f, -0.01594711f, -0.00665416f, -0.05111362f, -0.05040407f, 
    -0.00163894f, -0.05769709f, 0.01950430f, -0.02919020f, 0.03302071f, -0.03263949f, 0.02095006f, 0.00732727f, 
    -0.03716034f, -0.01263708f, 0.03943741f, 0.03140786f, -0.02758116f, -0.04736269f, -0.00054657f, -0.02435588f, 
    -0.04283485f, -0.05985970f, -0.01522683f, 0.01985053f, -0.02784027f, -0.03271513f, -0.03818742f, -0.03781367f, 
    0.02563628f, -0.00292446f, -0.03057320f, 0.04079525f, -0.03670996f, -0.05007515f, -0.01349561f, -0.05216587f, 
    0.02187836f, -0.03740239f, -0.03639112f, -0.00097325f, -0.04987034f, -0.01730542f, 0.04977075f, -0.04358731f, 
    0.04566886f, 0.01446350f, -0.05246018f, -0.03769080f, -0.05640474f, -0.03178705f, -0.03183483f, -0.02092579f, 
    -0.01249024f, -0.06078533f, -0.01753993f, -0.05824153f, -0.00797960f, -0.03275346f, 0.00583525f, -0.03161379f, 
    0.02299517f, 0.00309994f, -0.04151868f, -0.01251241f, 0.04620117f, 0.00682770f, -0.00933989f, 0.01488665f, 
    -0.05227055f, -0.06423030f, -0.02959227f, 0.01352875f, -0.04455529f, 0.01630179f, 0.00122311f, 0.05007717f, 
    -0.06465227f, -0.03510160f, 0.04944604f, -0.02386642f, 0.04097010f, -0.02319272f, 0.04934661f, 0.04681972f, 
    0.00194232f, -0.04742653f, -0.03914149f, -0.03299613f, 0.00131391f, -0.01283279f, 0.03313279f, 0.04017619f, 
    -0.03182873f, -0.02711109f, 0.01334462f, 0.02177413f, 0.00501061f, 0.00449902f, -0.04577619f, 0.05099552f, 
    0.03791967f, 0.02667576f, 0.02042231f, 0.03278461f, 0.00944318f, -0.02673080f, -0.05752912f, -0.04460723f, 
    0.01746018f, -0.04119968f, -0.01029529f, -0.03887626f, 0.01626642f, 0.01869507f, 0.03950127f, 0.00684031f, 
    -0.01094780f, 0.00372509f, -0.01623735f, -0.02808413f, 0.02782414f, 0.04230953f, -0.05782173f, -0.02934266f, 
    0.03255063f, 0.03604658f, 0.01044314f, 0.01793014f, -0.05227515f, -0.02316958f, 0.05196766f, -0.06253528f, 
    -0.06083633f, -0.04812635f, -0.01776269f, 0.01983204f, -0.00897775f, -0.04553399f, 0.00773604f, 0.00798049f, 
    -0.05520841f, -0.04004570f, 0.01065511f, 0.04313656f, -0.04672140f, 0.02525381f, -0.01795494f, 0.00652027f, 
    0.04399258f, 0.01241476f, -0.01821595f, -0.01189484f, -0.02318716f, 0.04660504f, -0.01172708f, -0.00612401f, 
    -0.04605667f, -0.06458399f, 0.02986934f, 0.01607278f, -0.03287552f, -0.01245019f, 0.01914247f, 0.00216948f, 
    0.04970123f, 0.00035156f, -0.00069221f, -0.04999602f, -0.01197198f, 0.00175339f, 0.03755542f, -0.04804489f, 
    0.00442844f, -0.01031323f, 0.01555490f, -0.05998748f, -0.01418240f, -0.02549250f, -0.03202246f, 0.03820937f, 
    0.02057228f, -0.01894081f, -0.03356451f, 0.03221083f, -0.04397428f, 0.01893491f, -0.05962250f, -0.04375720f, 
    0.01755576f, -0.05918911f, -0.01184042f, 0.04197514f, -0.03015869f, -0.04659133f, -0.04725068f, -0.02445392f, 
    -0.03103677f, -0.03057960f, -0.00869430f, -0.01345946f, 0.01692322f, 0.02262898f, -0.06056480f, -0.03375075f, 
    -0.00555069f, -0.01485233f, -0.05377116f, 0.00212620f, 0.04204123f, -0.02075118f, 0.00226096f, -0.01338705f, 
    -0.02427468f, -0.04321586f, 0.02178528f, -0.02360178f, 0.05175408f, -0.00424641f, -0.06391641f, 0.01160262f, 
    -0.04386222f, -0.01206661f, -0.06092323f, -0.04300588f, -0.03084068f, -0.07058854f, 0.02535832f, 0.04710212f, 
    0.00914925f, 0.01603465f, 0.03184768f, 0.00676172f, 0.00953725f, -0.03860823f, 0.01696892f, -0.03425780f, 
    -0.02797625f, -0.01392339f, 0.02107446f, 0.04352438f, -0.03440363f, -0.07069639f, -0.02477161f, 0.04244743f, 
    0.02241270f, 0.01729420f, -0.06686351f, 0.03585519f, -0.01031256f, -0.02082966f, 0.03938817f, -0.00404911f, 
    0.00271263f, -0.07015921f, -0.02889476f, 0.00061604f, 0.00270447f, -0.04543830f, -0.00919661f, -0.06037951f, 
    0.01362903f, -0.01030734f, -0.01676731f, -0.03144070f, -0.05544465f, 0.02516383f, -0.02313180f, -0.00110446f, 
    -0.02221780f, 0.00222630f, -0.03734940f, 0.05188502f, -0.04385094f, -0.05886099f, -0.02163481f, 0.03131064f, 
    0.03905001f, -0.06170595f, 0.02139037f, -0.03569172f, 0.03331063f, -0.00444429f, 0.00132969f, 0.01014646f, 
    -0.06021860f, 0.03078284f, -0.05777968f, -0.06510103f, 0.03285588f, -0.02811713f, -0.02005161f, 0.02770234f, 
    -0.06504569f, 0.05694380f, -0.05915514f, -0.00318389f, -0.06000140f, -0.04156043f, 0.01419676f, 0.02899439f, 
    -0.06707492f, -0.03424225f, 0.06561359f, 0.04674412f, 0.02904413f, -0.04452339f, -0.00971462f, 0.01805717f, 
    -0.01471762f, 0.03446258f, 0.00112107f, -0.01647843f, -0.00544348f, 0.03453107f, -0.01527580f, 0.00427678f, 
    -0.02929038f, -0.01160773f, 0.03356348f, -0.05379171f, 0.03820061f, 0.05334690f, -0.06934743f, -0.04674502f, 
    -0.01948524f, -0.05592603f, -0.06142601f, 0.04266502f, 0.06294269f, -0.04772235f, 0.00839376f, 0.03598645f, 
    0.05408927f, -0.06907323f, 0.02398759f, 0.03337872f, -0.01112978f, -0.05213067f, 0.03023959f, -0.06141914f, 
    0.02537678f, -0.05242294f, -0.00365713f, 0.02859914f, 0.01071013f, -0.03250789f, -0.00244900f, 0.02343309f, 
    -0.02084118f, -0.02847821f, -0.01103013f, -0.04083040f, -0.02507789f, 0.04179104f, 0.00664824f, -0.01965500f, 
    0.01559986f, 0.02299784f, 0.00925736f, -0.00736278f, -0.05190892f, -0.03063204f, 0.00884390f, 0.02719401f, 
    -0.03005603f, -0.00659757f, 0.01327411f, 0.00179999f, 0.00187089f, 0.04509169f, -0.07207055f, 0.03954751f, 
    -0.05069256f, -0.02584146f, 0.00342544f, -0.04897809f, -0.07167344f, -0.03311666f, -0.02943432f, 0.02692305f, 
    -0.03501842f, -0.01103754f, -0.06362412f, 0.01650835f, -0.05051556f, 0.04360500f, -0.05090680f, -0.03048299f, 
    -0.05830746f, 0.02607803f, -0.02416980f, -0.06456161f, -0.05329742f, 0.02516635f, -0.02392451f, -0.01869656f, 
    -0.06971969f, -0.01966259f, 0.03876128f, -0.04635233f, -0.06335998f, -0.00554498f, -0.02086408f, 0.02850788f, 
    0.03843557f, -0.03522728f, -0.05240783f, 0.01282242f, -0.04665272f, -0.00444250f, -0.05552852f, 0.01297570f, 
    -0.06105118f, 0.00690995f, 0.02691926f, -0.04364086f, -0.06627324f, -0.01746825f, 0.01234813f, -0.02753461f, 
    -0.01691447f, -0.00395100f, -0.00225218f, 0.01677108f, 0.00465318f, -0.02851666f, -0.02462339f, -0.02740845f, 
    -0.03660267f, -0.05694498f, 0.02364230f, 0.01571261f, 0.01585948f, 0.01375951f, -0.03568142f, 0.04002705f, 
    0.00575802f, 0.00103857f, 0.03193672f, 0.03342244f, 0.01003851f, 0.02455841f, -0.04369519f, -0.05769408f, 
    -0.04004353f, 0.03404490f, 0.03532286f, 0.01707874f, -0.03847297f, -0.01596963f, 0.04178298f, 0.00364831f, 
    -0.06191898f, 0.03861877f, -0.00531963f, 0.00094993f, -0.01515827f, 0.02099099f, -0.00134537f, -0.05748870f, 
    0.03965934f, 0.02343427f, 0.03294185f, 0.03797413f, 0.06791476f, 0.03630039f, -0.01458166f, -0.05611803f, 
    0.04431713f, -0.06829096f, 0.03051403f, 0.00165149f, 0.06821769f, -0.06781332f, -0.00098501f, -0.00446091f, 
    -0.03575023f, -0.06271043f, -0.09091271f, 0.15132234f, 0.18678783f, 0.02100448f, 0.08908569f, 0.09728234f, 
    0.01249966f, -0.16585845f, 0.00722532f, 0.22268026f, -0.12299948f, 0.02330763f, -0.02043208f, 0.03341358f, 
    -0.06841245f, -0.15731080f, 0.29053047f, 0.13594541f, 0.18565711f, 0.00867220f, 0.03976167f, -0.07596423f, 
    0.05797203f, 0.17218475f, 0.02072419f, -0.32719544f, -0.36111069f, -0.06248854f, 0.05309683f, 0.03667904f, 
    -0.17601386f, -0.04652783f, -0.18748069f, 0.03150670f, 0.00280830f, 0.08766276f, -0.13473073f, -0.25470531f, 
    -0.26606429f, 0.05028513f, 0.11327290f, 0.03670692f, -0.05143013f, -0.05682500f, -0.00104239f, 0.17702697f, 
    -0.04968502f, -0.05084554f, -0.07385445f, -0.01925068f, -0.04962880f, 0.21437404f, -0.06780721f, -0.06493212f, 
    0.15952086f, -0.12485398f, 0.04920782f, -0.02894543f, 0.06179582f, 0.05047431f, -0.09344997f, 0.10487115f, 
    0.16403672f, 0.20605776f, -0.09069178f, 0.08837680f, -0.13615637f, 0.00868668f, 0.16300222f, 0.06560738f, 
    0.10591664f, 0.19930835f, 0.02571935f, -0.07208579f, -0.01835097f, -0.10248391f, -0.02083385f, -0.01659815f, 
    -0.13943931f, 0.39171278f, 0.19810890f, 0.19124004f, -0.00583431f, -0.01502898f, -0.02868595f, -0.04348266f, 
    0.11241416f, 0.01204298f, -0.04614374f, -0.09826182f, -0.17277774f, 0.08476097f, 0.14674546f, -0.01045928f, 
    0.00586220f, 0.04320735f, 0.16809550f, 0.03645225f, 0.13157031f, 0.11524423f, 0.08533456f, 0.14399184f, 
    0.08548492f, -0.00496746f, 0.03713082f, 0.14455815f, -0.11672153f, -0.07861304f, -0.09678287f, 0.05205185f, 
    0.00724885f, -0.12290317f, 0.19564609f, -0.01739451f, 0.08337458f, 0.04525579f, 0.05076817f, 0.03451983f, 
    -0.09946130f, -0.11057231f, -0.07172220f, 0.08687808f, -0.03165850f, -0.08963978f, -0.42354354f, -0.21105097f, 
    0.17403555f, 0.01670091f, 0.09338558f, -0.06460948f, -0.06089957f, -0.28493083f, -0.03383867f, -0.03415478f, 
    -0.18866017f, -0.23178117f, 0.06189514f, 0.21667030f, -0.26709536f, -0.07020834f, 0.02301473f, 0.11130878f, 
    0.41196921f, 0.15383510f, 0.08094487f, 0.02560386f, -0.04809299f, -0.02417888f, -0.02024964f, 0.15278123f, 
    -0.09870310f, -0.19723992f, -0.11608177f, -0.01563333f, -0.16924585f, 0.04367247f, 0.05429074f, -0.05231833f, 
    0.05271174f, -0.01353669f, -0.19172892f, -0.19956723f, -0.19449136f, -0.19136529f, 0.00875656f, -0.12583898f, 
    -0.08250795f, -0.02680187f, 0.04087400f, 0.10727860f, 0.19490522f, 0.30899775f, 0.15191817f, -0.02509500f, 
    -0.12718397f, 0.01677261f, -0.02334835f, -0.01186638f, -0.01107081f, -0.18920568f, -0.07643061f, -0.13519996f, 
    0.04139992f, 0.10195142f, -0.01812986f, -0.00042838f, 0.02208840f, -0.22403564f, -0.21970664f, 0.14976057f, 
    -0.10598443f, -0.04765427f, -0.20921688f, 0.16986345f, -0.21202250f, 0.12203894f, 0.15311444f, 0.03873321f, 
    0.16588734f, -0.27186283f, 0.03912726f, 0.01565846f, 0.19431724f, -0.01360375f, -0.13398218f, 0.19159788f, 
    0.10977432f, 0.18619637f, -0.03423955f, -0.05170254f, -0.01912270f, -0.07489327f, 0.02075335f, 0.01662021f, 
    0.19237560f, 0.20057423f, -0.00801892f, -0.06898626f, -0.00642647f, -0.09863102f, 0.12122034f, 0.04445517f, 
    -0.03909662f, -0.05950189f, 0.13593325f, -0.09978569f, -0.10869254f, 0.03407968f, 0.02052891f, -0.03786849f, 
    0.03037653f, 0.09261698f, -0.12636259f, -0.10533665f, -0.07320159f, 0.00132413f, -0.02029375f, 0.03084133f, 
    0.00715662f, -0.11603229f, -0.04451187f, 0.20330729f, -0.23452225f, -0.21498314f, 0.00462524f, 0.07000268f, 
    0.02743061f, 0.10780436f, 0.00623392f, 0.09086966f, -0.10122756f, -0.17424607f, -0.02312799f, -0.15290174f, 
    0.10323321f, -0.04156290f, -0.01282044f, 0.08310630f, 0.07876957f, -0.31501547f, -0.14545190f, -0.23781310f, 
    -0.02725799f, 0.02862549f, 0.09209853f, 0.08458870f, -0.08844258f, -0.01955850f, -0.09814977f, 0.11937039f, 
    0.07084828f, -0.18494970f, 0.13338555f, 0.00785423f, 0.15502752f, 0.05864750f, 0.20385173f, -0.07608859f, 
    -0.16350788f, 0.12582959f, -0.22822657f, 0.07053725f, -0.18611401f, 0.02017820f, -0.01782587f, 0.08427741f, 
    -0.01991286f, -0.09120701f, -0.15232846f, 0.03604988f, 0.06025872f, -0.06337993f, 0.03729910f, -0.03858386f, 
    0.02133943f, -0.32984284f, -0.08127422f, 0.41352385f, 0.06626370f, 0.16578586f, -0.05371391f, 0.18696682f, 
    0.04187720f, -0.03987356f, 0.32169646f, 0.22842163f, 0.22665128f, 0.05209127f, 0.01862862f, -0.06873401f, 
    -0.01761798f, 0.01990347f, -0.05562825f, -0.14169291f, -0.33444241f, -0.27015376f, 0.03746225f, 0.02573114f, 
    -0.04284630f, 0.05149104f, -0.08661520f, 0.01660895f, -0.02750787f, 0.03843345f, 0.26526430f, -0.17831518f, 
    0.03675326f, -0.16734229f, 0.04721723f, -0.03374930f, 0.10662293f, -0.10544528f, -0.06448299f, 0.27729377f, 
    0.03299462f, -0.01405521f, -0.05628170f, 0.06394806f, 0.06432859f, 0.13825050f, -0.28862011f, 0.09071888f, 
    0.33423394f, 0.03924222f, -0.04645093f, -0.06410588f, 0.02478920f, -0.05081451f, -0.07554107f, -0.01597014f, 
    0.18355741f, 0.09755173f, -0.11684281f, 0.01975719f, 0.16163644f, 0.07327317f, 0.17103523f, -0.21829709f, 
    -0.19608361f, 0.14586931f, 0.23546185f, 0.05027042f, -0.00505326f, -0.15138507f, 0.08427989f, 0.04911502f, 
    0.10970443f, -0.04180721f, 0.11634398f, -0.01264505f, -0.09475140f, 0.00891435f, -0.08159539f, -0.02480070f, 
    -0.00203272f, -0.12531629f, -0.00118385f, 0.23272283f, -0.23280568f, 0.10080878f, 0.11986090f, 0.08529770f, 
    0.10307026f, 0.00306643f, 0.04948967f, -0.11295642f, -0.08464239f, -0.03180394f, 0.08227587f, -0.08968752f, 
    -0.09695890f, 0.02421841f, 0.13231777f, 0.09198933f, -0.24045704f, -0.03563942f, -0.15579380f, -0.11033010f, 
    -0.13067861f, -0.24630822f, 0.14327712f, -0.18076456f, -0.15895584f, -0.02878601f, -0.19582194f, -0.19982697f, 
    0.11146687f, 0.04177134f, 0.01448025f, -0.00980423f, 0.05661465f, 0.06964967f, -0.19977099f, -0.00906753f, 
    0.03028957f, -0.21756889f, 0.14845099f, -0.11062132f, -0.14201885f, 0.11228701f, 0.12527631f, -0.06836822f, 
    -0.01293032f, 0.22077501f, -0.00073621f, -0.08781052f, 0.09963139f, 0.00258232f, 0.17298664f, 0.25744626f, 
    0.01000590f, -0.01104118f, -0.17060456f, 0.01626243f, -0.10426213f, -0.02885327f, -0.06983443f, -0.09947613f, 
    -0.05228715f, -0.33711514f, 0.20474739f, 0.32484412f, -0.11853760f, -0.08555994f, 0.15681021f, 0.04411189f, 
    -0.00675306f, 0.03434461f, -0.06992162f, 0.15858598f, 0.20814599f, -0.07893473f, -0.05740432f, -0.37161469f, 
    0.01431948f, -0.01166538f, 0.16487774f, -0.31482151f, 0.14543144f, 0.13642569f, -0.10794192f, -0.03841655f, 
    -0.17863260f, -0.04400180f, 0.06558417f, 0.09576148f, -0.00059096f, -0.01041317f, 0.11972094f, -0.07000863f, 
    -0.07762673f, 0.09114550f, 0.12433819f, 0.17787154f, -0.14752112f, 0.29086190f, -0.04741753f, 0.20429201f, 
    -0.10028571f, 0.06159055f, 0.07450446f, 0.03852268f, 0.01641886f, -0.13967913f, 0.26831782f, 0.31795299f, 
    -0.02102257f, 0.15535825f, -0.12154552f, 0.01629293f, 0.13714990f, 0.06433994f, 0.06633572f, -0.05489507f, 
    -0.04091049f, 0.03981351f, 0.02687922f, 0.01396018f, -0.04238253f, -0.02130359f, -0.00672375f, 0.11424097f, 
    -0.28891164f, 0.15071267f, 0.04506122f, -0.06701799f, 0.05461769f, -0.14438324f, -0.04904060f, 0.06970625f, 
    0.12920804f, 0.08177532f, 0.27064922f, -0.05688088f, -0.04120107f, 0.04842720f, -0.07773571f, 0.08495517f, 
    0.15267141f, 0.00855822f, -0.02094906f, -0.00511590f, 0.03685621f, -0.21944788f, -0.02489635f, -0.15450940f, 
    0.15946138f, -0.02076316f, -0.08018803f, -0.22951476f, -0.05087591f, 0.17288013f, 0.02721700f, 0.07529808f, 
    0.01043498f, 0.06923621f, 0.10659619f, 0.19545935f, -0.02394033f, -0.00026840f, 0.06369162f, -0.01319190f, 
    0.21887960f, -0.15190561f, -0.01015482f, -0.02631104f, -0.02262355f, -0.49418864f, -0.26063758f, 0.02866224f, 
    0.07623036f, 0.20912315f, -0.22030373f, 0.08228379f, -0.14205962f, 0.13792330f, -0.15150490f, 0.03099743f, 
    0.10369720f, -0.12768753f, -0.07306083f, -0.26422483f, -0.08245565f, 0.05133307f, 0.09434428f, -0.07479288f, 
    0.16518573f, 0.41804045f, -0.06690880f, -0.00638404f, -0.23687963f, 0.05235326f, -0.06437392f, 0.15519841f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.09671912f, 0.04959699f, 0.15625551f, -0.04281713f, 0.16302949f, 0.04165332f, 0.00263287f, 0.15196873f, 
    -0.02545206f, -0.05972281f, -0.17998277f, 0.04999658f, 0.10497639f, -0.06105811f, 0.16630943f, 0.05750762f, 
    0.04380240f, 0.10756854f, 0.11604957f, -0.04877723f, 0.21865509f, 0.11235990f, 0.24671024f, -0.05070788f, 
    0.02673124f, 0.05496129f, 0.06573739f, 0.00978847f, 0.02182090f, 0.00503294f, 0.14304884f, 0.09862338f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04678283f, 0.02118907f, -0.04993625f, 0.00856647f, -0.23019242f, 0.05571941f, 0.16113073f, 0.06853338f, 
    0.00625641f, 0.19701350f, 0.00332818f, 0.12785807f, 0.02820497f, 0.09858151f, 0.09926179f, -0.35763535f, 
    -0.27194023f, -0.24947657f, -0.28494614f, 0.15331362f, 0.30756712f, -0.03103046f, -0.09952203f, 0.14279002f, 
    -0.16433516f, -0.15883563f, -0.06414520f, -0.09861109f, 0.15222906f, -0.03611758f, 0.26804817f, 0.38869447f, 
    -0.00536894f, -0.00922670f, 0.20305470f, 0.15406696f, 0.19614320f, 0.01216374f, 0.19490483f, 0.06429318f, 
    -0.24187252f, -0.02541434f, -0.28178892f, 0.02391928f, 0.01765730f, 0.14196511f, -0.11159550f, 0.14192384f, 
    -0.26778543f, 0.19047059f, 0.02370722f, 0.04999866f, -0.09252609f, -0.14536090f, -0.06848542f, 0.13645890f, 
    -0.08348125f, 0.19196995f, 0.11790390f, -0.18195592f, 0.07829753f, 0.15083908f, 0.06418891f, 0.23764464f, 
    0.32686803f, 0.09435835f, 0.01886668f, -0.31361902f, 0.33312571f, -0.13144340f, -0.36059687f, -0.00758843f, 
    0.30479544f, -0.00240071f, 0.06608567f, -0.00456670f, -0.18705711f, 0.01442363f, 0.18029362f, -0.06038280f, 
    0.42010492f, -0.16591953f, -0.12382498f, -0.04921231f, 0.30468437f, 0.10028315f, 0.12485593f, 0.04395589f, 
    0.00776556f, -0.11255939f, -0.29334223f, 0.32638031f, -0.00075069f, -0.06138201f, -0.25689214f, 0.13533118f, 
    0.07772458f, 0.14667639f, 0.04694913f, 0.12087603f, 0.14462139f, -0.15988532f, 0.09053966f, -0.01232595f, 
    0.03703137f, -0.11838120f, 0.10959440f, 0.02794455f, -0.01639106f, 0.09262352f, -0.17462136f, 0.13211516f, 
    -0.12996757f, 0.10652726f, -0.18609075f, -0.09301421f, 0.11489668f, -0.00774645f, 0.19224393f, 0.01844108f, 
    0.03692354f, 0.26181057f, 0.30611518f, 0.33610612f, -0.04611726f, 0.00325960f, -0.13532779f, -0.22171341f, 
    -0.11762965f, 0.15113443f, 0.25220791f, -0.16269232f, -0.23572369f, 0.11016926f, -0.12678647f, -0.13529223f, 
    0.09482476f, 0.00003072f, 0.09652461f, 0.05282323f, -0.13467366f, -0.16093552f, -0.24862064f, 0.22700292f, 
    -0.10884288f, -0.20864195f, 0.15611239f, 0.12166127f, -0.02720314f, -0.15757573f, 0.06586389f, -0.14694515f, 
    -0.05375028f, -0.19166948f, 0.16174258f, 0.07240041f, -0.02160068f, 0.07057798f, -0.00352869f, 0.01140781f, 
    0.26422286f, 0.16120648f, -0.14879274f, -0.09507770f, 0.21610291f, -0.07877611f, -0.01386278f, -0.13517459f, 
    0.08160569f, -0.30870792f, -0.26914403f, -0.04702596f, 0.01308515f, 0.09602268f, 0.03406182f, 0.01027296f, 
    0.14783020f, -0.57963717f, -0.03499271f, 0.05530654f, -0.19886276f, 0.25728098f, 0.26527947f, -0.06049376f, 
    0.08558173f, 0.11419981f, 0.10151461f, -0.09816834f, 0.08105253f, -0.01386161f, -0.03049265f, 0.06261770f, 
    0.24340369f, 0.10203703f, -0.14885287f, -0.30774716f, -0.12416311f, 0.17165869f, -0.25919521f, -0.15305200f, 
    0.19882779f, -0.22975464f, -0.05792739f, 0.09846647f, -0.05674891f, -0.09767617f, 0.18176694f, 0.10618189f, 
    -0.33026531f, -0.00939963f, -0.11649159f, -0.09029171f, 0.51673543f, 0.26605725f, 0.25928158f, -0.15623742f, 
    -0.01718259f, 0.02732326f, -0.04233591f, 0.12640151f, -0.15292817f, 0.06613111f, 0.15724410f, -0.04287077f, 
    0.41438863f, 0.13949768f, 0.09049975f, -0.01427099f, -0.11266941f, 0.07870476f, -0.14702307f, -0.00066499f, 
    0.00072265f, 0.23070358f, -0.27494082f, -0.10742263f, 0.20451322f, -0.06939020f, 0.06776633f, 0.31645876f, 
    -0.41088450f, -0.37522435f, -0.02157365f, -0.11839813f, 0.32467577f, 0.12209297f, -0.09677799f, 0.11828545f, 
    0.11475670f, 0.12755488f, 0.00261532f, 0.57496995f, 0.09871052f, 0.06974225f, 0.01615762f, 0.15417825f, 
    -0.22975312f, 0.15193839f, 0.21782330f, -0.00284531f, 0.10033939f, 0.02746804f, -0.01992672f, 0.24256663f, 
    -0.24416420f, 0.13605888f, -0.28942963f, -0.02746945f, -0.43745625f, -0.15435086f, 0.20259626f, -0.14321196f, 
    0.00224966f, -0.12662856f, 0.21245928f, -0.12970172f, -0.23252255f, 0.17673951f, -0.00075464f, -0.03155608f, 
    -0.08417416f, -0.16016315f, 0.24401104f, -0.00486901f, -0.13521092f, -0.00458105f, 0.06080413f, 0.41248003f, 
    -0.08730254f, 0.02575227f, 0.30245522f, 0.07630948f, -0.29523727f, 0.03703931f, 0.07527423f, -0.02525407f, 
    0.01655417f, 0.08285658f, -0.18531179f, 0.07352009f, -0.04791946f, 0.00967748f, 0.00784738f, 0.35024801f, 
    -0.18231627f, -0.20564683f, 0.16426055f, 0.16525605f, -0.26093426f, -0.06491322f, 0.18707757f, -0.15701385f, 
    0.06810908f, -0.19174442f, 0.20613621f, 0.51254267f, 0.11628842f, 0.05960294f, -0.06186384f, 0.04655372f, 
    0.18176293f, -0.03735030f, -0.04895942f, -0.19012986f, -0.03303039f, 0.07194361f, -0.11499870f, 0.07795719f, 
    -0.05649165f, 0.10828549f, -0.30492640f, -0.06056099f, -0.04152820f, 0.13781305f, 0.09456361f, -0.05007233f, 
    0.51750457f, -0.23517409f, -0.16774534f, 0.00285822f, 0.45323902f, 0.24456809f, 0.16813591f, -0.17151366f, 
    -0.01711577f, 0.26063627f, -0.10181040f, -0.08467746f, -0.12349275f, -0.03592629f, 0.29639739f, 0.17396238f, 
    0.09098870f, -0.12681431f, -0.28974971f, 0.04771154f, 0.00987448f, 0.02324875f, -0.12230784f, -0.10911620f, 
    0.05665792f, -0.26673642f, -0.07467072f, -0.15628220f, 0.07021329f, 0.15325172f, -0.11690538f, 0.12637243f, 
    0.15486343f, -0.09303191f, -0.01266209f, -0.14567657f, 0.55794948f, 0.19687499f, 0.25239110f, 0.11766823f, 
    0.03564945f, 0.34934607f, 0.29780951f, 0.36293983f, -0.02002615f, 0.14440340f, 0.13670428f, -0.02733958f, 
    0.03984036f, -0.01254699f, 0.01466042f, 0.08339376f, -0.27540815f, -0.11270499f, -0.16164389f, 0.13674913f, 
    -0.07148226f, -0.13917537f, -0.18934678f, 0.15554275f, 0.09380817f, -0.18031302f, 0.14865680f, -0.24495110f, 
    -0.36497411f, 0.04573622f, 0.03486273f, 0.07520534f, 0.16099112f, 0.01246481f, 0.15160011f, -0.00776714f, 
    -0.16317348f, -0.05169100f, 0.27004200f, -0.39147162f, -0.16070861f, -0.09028629f, 0.17472571f, 0.00224097f, 
    -0.03057628f, -0.11020869f, -0.13172987f, 0.24692884f, -0.31329393f, 0.00314795f, 0.05100427f, 0.02699701f, 
    0.04801834f, 0.14921902f, 0.16403235f, -0.06084570f, -0.12785776f, 0.05711886f, -0.33525014f, 0.18735714f, 
    -0.08751456f, -0.24024448f, 0.05870375f, -0.11384509f, -0.21829417f, -0.17021896f, 0.00172375f, -0.16509287f, 
    0.14233816f, 0.33522093f, -0.04051324f, 0.34808671f, 0.01529313f, -0.11946876f, -0.11910158f, -0.07942186f, 
    0.07226827f, 0.11825518f, 0.05660363f, 0.03625980f, -0.06738600f, -0.05853558f, 0.08747665f, 0.07882155f, 
    -0.16127393f, -0.00386879f, 0.17639184f, -0.09652697f, 0.15237527f, 0.08414712f, 0.03195500f, 0.27515358f, 
    -0.28790736f, -0.46039978f, -0.07058979f, -0.10555770f, -0.46840104f, -0.22743174f, 0.11797695f, 0.04607746f, 
    -0.03468114f, 0.26321736f, 0.14266987f, 0.22159824f, -0.03728189f, 0.03816574f, -0.30219647f, 0.13013545f, 
    -0.01798836f, 0.10191008f, -0.08473158f, 0.08019278f, 0.03141884f, -0.08170818f, 0.17247300f, -0.02552069f, 
    -0.24398747f, 0.03556155f, 0.18818849f, 0.11911341f, -0.02579537f, -0.00413795f, -0.27901897f, 0.00161823f, 
    0.34865454f, 0.19895115f, 0.35257763f, 0.05746686f, 0.00527754f, -0.43652982f, -0.08934311f, -0.15995637f, 
    -0.12617236f, 0.27635679f, 0.05321413f, 0.28932866f, -0.15328346f, -0.12247519f, -0.01542954f, -0.07511589f, 
    -0.06826296f, -0.07181880f, -0.18542835f, 0.00880590f, -0.03845710f, 0.17340337f, -0.23184535f, -0.08362027f, 
    0.19867511f, 0.09971239f, 0.16678359f, 0.02044684f, -0.29183555f, 0.08545519f, -0.17098232f, -0.12637995f, 
    0.77639931f, -0.02317825f, -0.00153575f, -0.14346546f, -0.12178821f, -0.06053230f, 0.27302736f, -0.05298359f, 
    -0.09340691f, 0.31222352f, -0.15825468f, -0.08822598f, -0.07791185f, 0.06492215f, 0.30752039f, 0.25410944f, 
    -0.22354832f, 0.00802450f, -0.20143037f, 0.09588650f, -0.22485034f, -0.10520157f, 0.08045735f, 0.09808207f, 
    -0.09885371f, -0.20271571f, 0.05179801f, -0.00990050f, 0.22645707f, 0.11122071f, 0.13237615f, -0.02338683f, 
    -0.36326915f, 0.39394981f, 0.19249564f, -0.14523950f, 0.22450842f, -0.12867582f, -0.02088568f, -0.15665805f, 
    -0.02298360f, -0.02053976f, 0.19447297f, -0.22836745f, 0.16363171f, -0.08909778f, 0.35922310f, 0.06537271f, 
    0.03994951f, 0.08199567f, -0.17376462f, 0.00803749f, 0.13115124f, -0.08114750f, 0.00633734f, 0.02375462f, 
    0.19406280f, -0.60462129f, -0.08070921f, -0.02770205f, -0.33139944f, 0.04937676f, 0.10981435f, -0.05478122f, 
    0.33171317f, -0.52642328f, -0.10757461f, -0.13886881f, 0.05013453f, -0.11861259f, 0.24909672f, -0.15355889f, 
    0.01676751f, 0.40268552f, 0.23771439f, -0.09728220f, 0.11446948f, -0.11925300f, -0.24513188f, 0.05207849f, 
    0.01321379f, -0.09109151f, 0.10983779f, 0.08739991f, 0.16652952f, -0.16924112f, 0.07526915f, 0.20714058f, 
    -0.23417282f, -0.18665688f, -0.14189541f, 0.11925372f, -0.20941202f, -0.06936142f, 0.07052188f, -0.16885765f, 
    0.63091183f, -0.66081238f, 0.13654201f, -0.02712907f, -0.23725682f, -0.01675186f, 0.18798099f, 0.02900820f, 
    -0.03670417f, 0.37269434f, 0.28093794f, -0.03157843f, -0.00672154f, 0.09130111f, -0.08840199f, 0.05973516f, 
    -0.00726121f, 0.11891764f, 0.42887107f, 0.15104493f, 0.09388276f, -0.00757534f, 0.26633352f, 0.32938272f, 
    -0.27038702f, 0.05410863f, -0.16425352f, 0.08965074f, -0.13685550f, 0.00810395f, -0.00200062f, 0.16684760f, 
    -0.35656381f, -0.32177967f, 0.01458350f, -0.06892149f, -0.15597001f, -0.27100912f, 0.16096923f, -0.16671777f, 
    -0.07165669f, 0.07363919f, 0.18478325f, 0.02346483f, -0.06950382f, -0.00173400f, -0.05517453f, 0.02535618f, 
    0.00526399f, 0.09188782f, -0.07980818f, 0.03812038f, -0.02149164f, -0.02921873f, -0.17615600f, 0.14004335f, 
    -0.06504878f, -0.09642718f, -0.14150015f, -0.00427986f, 0.15822393f, -0.03782117f, -0.21798144f, -0.12506956f, 
    -0.06487743f, 0.21364884f, 0.07070232f, 0.12331707f, -0.04200152f, -0.09862451f, 0.12877002f, -0.05701252f, 
    -0.05213847f, -0.02001459f, -0.13632758f, -0.13745107f, 0.09289169f, -0.05596314f, -0.20937781f, 0.14175466f, 
    -0.31483436f, 0.10286751f, 0.23844649f, -0.28627896f, -0.32288525f, 0.12828414f, -0.15221924f, 0.22003448f, 
    0.04683742f, 0.26516801f, -0.31581864f, -0.11215864f, -0.13076073f, -0.09400147f, -0.00892116f, -0.38381392f, 
    -0.34657982f, 0.09065013f, 0.07353020f, 0.11202140f, 0.20557596f, -0.13171200f, -0.00436438f, 0.04147699f, 
    -0.11177935f, -0.10441186f, -0.18890516f, -0.08386993f, -0.00820188f, -0.05837933f, 0.25466308f, 0.31711826f, 
    0.15622024f, -0.03965176f, -0.30270159f, 0.03510164f, -0.06585822f, -0.14345577f, -0.05651354f, -0.06840705f, 
    -0.00300298f, -0.09781066f, -0.17265595f, 0.14509821f, 0.31456184f, -0.05761276f, 0.01739976f, -0.03674934f, 
    0.19382218f, 0.07502497f, 0.27218473f, -0.02675499f, 0.57316560f, 0.10206366f, -0.04611058f, -0.07532607f, 
    -0.07471163f, 0.21345332f, 0.26633921f, 0.41484693f, -0.08593639f, -0.03913946f, 0.23008364f, -0.09015377f, 
    0.01097108f, -0.11280757f, 0.19213468f, 0.15462343f, 0.32678661f, -0.08573332f, 0.20854858f, 0.31976128f, 
    -0.25907913f, 0.13742720f, -0.25684670f, 0.03602024f, -0.12021923f, 0.06838919f, 0.18841389f, -0.03325080f, 
    -0.51778740f, -0.06115679f, 0.26188686f, 0.07774127f, -0.00738718f, 0.05360432f, -0.10721376f, 0.16986620f, 
    -0.17925927f, -0.04301833f, 0.24124347f, -0.31748363f, 0.01752805f, 0.13876662f, 0.04077408f, 0.16171226f, 
    0.26247352f, -0.07206134f, -0.02519608f, -0.18539926f, 0.25354031f, -0.11185129f, 0.03321450f, 0.17438325f, 
    0.04556647f, 0.09171639f, -0.07185242f, -0.10937803f, -0.38118440f, 0.12566823f, 0.13008004f, -0.23250535f, 
    -0.04496725f, -0.12644145f, -0.22500603f, -0.04126193f, 0.00845765f, 0.17530569f, 0.17485467f, -0.08728307f, 
    -0.09555050f, 0.16103570f, -0.10644925f, -0.15336432f, -0.10972943f, -0.17791297f, 0.14712833f, 0.31144503f, 
    0.25713828f, -0.06197165f, 0.09646305f, 0.12790482f, -0.24192427f, 0.17137413f, -0.05752387f, -0.26715976f, 
    0.01007495f, 0.02202218f, 0.21920870f, -0.06363715f, 0.06465410f, 0.02706390f, -0.20725957f, 0.24900013f, 
    -0.13281532f, 0.17459834f, 0.17613417f, 0.06961377f, -0.04581482f, -0.03309665f, -0.10903499f, 0.16537197f, 
    0.12769666f, 0.13735421f, 0.20557708f, 0.38264751f, 0.05520725f, -0.05278834f, -0.19223365f, -0.07048637f, 
    -0.18133953f, -0.18166627f, 0.17805961f, 0.12011641f, 0.26435205f, 0.14700481f, 0.23420887f, 0.31142858f, 
    0.04042724f, -0.08403196f, -0.40882692f, 0.00879543f, -0.43476641f, -0.08438902f, 0.15122838f, -0.10168990f, 
    0.02755624f, -0.22371683f, -0.12582666f, 0.04252408f, 0.04908296f, 0.09689339f, -0.06011415f, 0.04517213f, 
    0.06212869f, 0.20762542f, 0.04448730f, -0.28434828f, -0.00122559f, 0.05667955f, 0.11525439f, 0.38465726f, 
    -0.10999794f, 0.02516800f, -0.26930001f, 0.22632089f, -0.10003661f, -0.08055353f, -0.06406635f, 0.24653850f, 
    -0.20506519f, -0.02214845f, 0.09779058f, 0.03818128f, 0.34241849f, -0.12924968f, 0.03084973f, 0.34931809f, 
    -0.60683680f, 0.40423167f, 0.16416828f, 0.07869302f, 0.28196788f, 0.05375835f, 0.19966429f, 0.13180912f, 
    0.01661498f, -0.29657751f, 0.08649718f, -0.18955348f, -0.12616500f, -0.15593189f, 0.20405777f, -0.15651183f, 
    -0.00784692f, 0.10258065f, 0.21724746f, 0.24090233f, 0.23777021f, -0.05326324f, 0.10559417f, 0.06775949f, 
    -0.01206143f, 0.20698602f, -0.10983547f, -0.03169757f, 0.12338077f, 0.16070113f, -0.11251945f, 0.21526884f, 
    -0.14858204f, -0.01976890f, 0.31955320f, -0.08068236f, -0.27248761f, -0.27531075f, 0.07489008f, -0.06205127f, 
    0.12241033f, -0.16591547f, 0.18268064f, -0.40494788f, -0.13374645f, -0.00071298f, -0.27678946f, -0.07973731f, 
    0.25386709f, -0.03331243f, 0.00071791f, -0.19275230f, 0.34535941f, -0.15669970f, -0.02964299f, 0.11477174f, 
    0.17347556f, -0.47189534f, 0.15654916f, 0.15491220f, 0.07031627f, -0.07356655f, -0.04084983f, 0.19027478f, 
    0.14676167f, -0.02207113f, -0.13179012f, -0.11301247f, 0.38783988f, -0.03354509f, 0.32772288f, 0.05942471f, 
    -0.03484938f, 0.06939099f, -0.06203770f, 0.31090549f, -0.04640352f, 0.05926260f, -0.24962518f, -0.24963416f, 
    -0.22758327f, 0.00963096f, -0.17600389f, 0.25152397f, 0.10590807f, -0.16722563f, 0.05146557f, 0.09771592f, 
    0.01459334f, -0.42306730f, -0.15816361f, 0.01035006f, -0.27930018f, -0.00253265f, 0.14220364f, -0.13004169f, 
    0.00216394f, -0.13220528f, 0.22725654f, -0.12257662f, -0.21010768f, -0.03133924f, 0.08904517f, 0.14748354f, 
    -0.13738409f, 0.03572594f, 0.03332522f, -0.40963453f, 0.04812036f, -0.00255547f, 0.16039836f, 0.22660841f, 
    0.23804747f, -0.01690168f, -0.52759993f, 0.03464514f, 0.19926313f, 0.13417585f, 0.03984599f, 0.24771655f, 
    -0.17876570f, -0.12376828f, -0.16579217f, -0.03951135f, -0.00897111f, -0.03946618f, 0.28915289f, 0.08768900f, 
    -0.41512042f, -0.21488211f, 0.02581973f, -0.15605193f, 0.37705243f, 0.05684280f, 0.14482835f, 0.02094348f, 
    -0.01872164f, -0.06716877f, 0.07049053f, -0.29349321f, -0.00388257f, 0.10527924f, 0.22636089f, 0.15115927f, 
    -0.14645250f, 0.09421111f, 0.14165667f, 0.19105795f, 0.26171291f, 0.06397345f, 0.22494639f, 0.07901804f, 
    0.05132503f, -0.08271386f, -0.09561571f, 0.06262707f, 0.16416614f, -0.02316193f, 0.09666112f, -0.39392328f, 
    -0.21012612f, 0.16570647f, 0.10633136f, 0.15975794f, 0.03292086f, 0.12016449f, -0.09908231f, -0.00084354f, 
    -0.00924864f, -0.12811930f, 0.12797387f, -0.19337814f, 0.02189704f, -0.13385166f, 0.01676409f, -0.16090262f, 
    0.05093830f, -0.10194770f, 0.27131337f, 0.04978255f, 0.00701790f, 0.04508905f, -0.13895096f, -0.41634077f, 
    0.23977181f, 0.09273352f, 0.27773860f, -0.18022259f, 0.00315947f, 0.13351016f, 0.13391635f, 0.23893009f, 
    0.37485638f, 0.26572150f, -0.16638330f, 0.01051225f, -0.16168126f, 0.08022343f, -0.11543949f, 0.02070211f, 
    0.16474071f, -0.11568544f, -0.35139263f, 0.14096506f, -0.15425074f, -0.18289171f, -0.09488108f, 0.07430426f, 
    -0.14175268f, -0.09253425f, -0.27049085f, 0.12415074f, -0.07814297f, 0.16520768f, -0.06523224f, 0.08976196f, 
    -0.18861075f, 0.28514951f, 0.12269750f, -0.08284107f, -0.00527606f, 0.10210878f, -0.17732677f, 0.38071474f, 
    -0.15278226f, -0.46475342f, 0.09321463f, -0.13233550f, -0.24040782f, 0.10923088f, 0.22176275f, -0.07655458f, 
    0.03523985f, 0.25130886f, 0.26305187f, -0.11447319f, -0.03184384f, 0.10809531f, 0.10854956f, 0.13379942f, 
    -0.16821602f, 0.06441536f, 0.24805912f, -0.06019113f, 0.31244156f, -0.09178136f, -0.15036383f, 0.25122660f, 
    0.24645288f, -0.66929501f, -0.14165887f, -0.09342429f, -0.33028692f, 0.02625450f, 0.10072060f, -0.24310565f, 
    -0.00582674f, -0.06667042f, -0.00045289f, -0.08670434f, -0.07540610f, 0.09933817f, 0.30140179f, -0.01917894f, 
    0.08363185f, 0.01011979f, 0.11587864f, 0.02065343f, -0.10506333f, -0.15636274f, 0.01608437f, -0.00019718f, 
    -0.02392815f, 0.10936654f, -0.22854729f, 0.24988833f, 0.24026795f, 0.04236024f, 0.08990074f, 0.27003554f, 
    -0.13001055f, -0.17271222f, 0.18208025f, 0.09941999f, 0.01404834f, 0.10143543f, 0.24409069f, 0.24838479f, 
    -0.57524520f, 0.17555143f, 0.16348794f, -0.14200611f, -0.27335095f, -0.20709714f, -0.01863890f, -0.09399546f, 
    0.08510262f, -0.14571144f, 0.06425147f, -0.36470327f, -0.04677943f, 0.12861547f, 0.04946529f, 0.08138449f, 
    0.24474020f, 0.09860310f, -0.12594193f, 0.00230665f, -0.07798011f, -0.08600099f, -0.31144825f, 0.20710607f, 
    0.02503437f, 0.05958423f, 0.07633452f, 0.09313470f, 0.00749862f, -0.12605801f, 0.07844132f, 0.12338182f, 
    -0.00225019f, -0.05268480f, -0.16452588f, -0.05110237f, -0.09059761f, -0.12514329f, -0.02022398f, 0.14807828f, 
    0.14492179f, -0.01055505f, 0.02011368f, -0.16075400f, 0.09740617f, 0.10520220f, 0.12490635f, -0.16469541f, 
    -0.11385030f, 0.10362464f, 0.18789151f, 0.06991231f, -0.03461448f, -0.16040134f, -0.22186916f, 0.16118813f, 
    0.06735808f, -0.23778094f, -0.10931434f, 0.12368124f, -0.01570932f, 0.07872136f, -0.00924100f, -0.14442721f, 
    -0.23293164f, 0.28137612f, -0.11379888f, -0.03800246f, 0.27007413f, 0.19082198f, 0.30079973f, -0.00893744f, 
    0.00375762f, -0.31695247f, 0.14661017f, -0.17315668f, 0.06005927f, 0.00931355f, 0.03534781f, 0.09489089f, 
    0.06240669f, -0.03205066f, -0.12172322f, 0.32125086f, 0.35523716f, 0.09802851f, 0.14591014f, 0.33529004f, 
    -0.06339060f, 0.00130033f, 0.16958687f, -0.13977736f, -0.10815576f, -0.16614103f, -0.15155156f, 0.25418028f, 
    -0.10706099f, -0.02063103f, 0.24268070f, 0.17575589f, -0.24361657f, -0.25543475f, 0.18305825f, -0.15211953f, 
    -0.09623792f, -0.04009751f, 0.18572307f, -0.30610874f, 0.11165183f, 0.13321106f, -0.04335731f, 0.05121671f, 
    0.16959263f, 0.17312828f, -0.48613891f, -0.10035475f, 0.02433781f, 0.12897225f, -0.16259199f, 0.16242281f, 
    -0.02198784f, -0.15358560f, -0.14347869f, 0.07741544f, -0.09076150f, -0.09097956f, 0.19180371f, 0.03004521f, 
    0.13900854f, -0.25848594f, 0.06485777f, -0.17890750f, 0.46374613f, 0.24250539f, -0.05086339f, 0.13442892f, 
    0.02517896f, 0.11452693f, 0.06477106f, -0.15997753f, -0.01902342f, 0.11810158f, 0.38821533f, 0.17789656f, 
    0.09745049f, 0.09250068f, 0.01648952f, 0.06333608f, -0.03244538f, -0.05025368f, -0.04833913f, 0.11047370f, 
    -0.07462099f, -0.14436476f, -0.09748537f, -0.00032938f, -0.03016627f, 0.15361078f, -0.10248893f, -0.15237300f, 
    -0.00877630f, 0.02625445f, -0.14250048f, 0.13590029f, -0.07828680f, -0.03356601f, 0.10500419f, -0.04672368f, 
    0.10729510f, -0.08376476f, -0.01372902f, -0.08117341f, 0.06610901f, -0.03626362f, -0.00459358f, -0.17616647f, 
    0.16896272f, 0.05254348f, 0.01479611f, -0.02689221f, -0.36941943f, -0.16859327f, 0.20246434f, -0.00352948f, 
    -0.01916672f, 0.25751078f, -0.29518273f, 0.09867311f, -0.06212054f, 0.16537881f, -0.11080036f, 0.08052068f, 
    0.54341209f, -0.17233290f, 0.08604220f, -0.06957837f, 0.22039616f, -0.04922684f, 0.02529207f, 0.14482011f, 
    -0.10276851f, 0.36570784f, -0.25310695f, 0.08363079f, -0.16041957f, -0.08252045f, 0.46025625f, 0.08023220f, 
    0.11771192f, -0.16659880f, 0.13186115f, -0.34389287f, -0.18091138f, -0.08035817f, -0.17845181f, 0.08538376f, 
    -0.12768191f, 0.24891202f, -0.10102487f, -0.07441987f, 0.07498771f, 0.15400261f, -0.00004150f, -0.23538978f, 
    -0.07492806f, 0.14290492f, -0.12293650f, -0.12610072f, -0.04426752f, -0.06104241f, -0.17930284f, 0.10156712f, 
    0.12018020f, 0.04111311f, -0.12940373f, 0.07111963f, 0.10940622f, 0.08219948f, 0.31196457f, -0.14079933f, 
    0.01104575f, 0.08827034f, -0.17257175f, -0.08650026f, -0.18609698f, -0.00005378f, 0.03054272f, -0.09535281f, 
    0.07361054f, 0.12283299f, 0.08096784f, -0.02393176f, -0.14565301f, 0.03923520f, -0.18778458f, -0.02545652f, 
    -0.18907234f, 0.05180473f, -0.21573351f, 0.09313159f, -0.11142784f, -0.07961434f, -0.21829483f, -0.15431337f, 
    -0.04197950f, -0.03954106f, 0.02363311f, -0.18467745f, 0.13704415f, 0.08590305f, 0.03887192f, -0.02604948f, 
    0.00021937f, 0.16877092f, 0.10113169f, -0.08711050f, -0.07551944f, -0.06057924f, -0.20308410f, -0.25302795f, 
    0.18355386f, 0.00440939f, 0.15206413f, 0.16452323f, -0.12988880f, 0.14900927f, -0.00567540f, 0.16211197f, 
    -0.13479784f, -0.01032501f, -0.35655022f, 0.08479513f, -0.36635980f, 0.05853072f, -0.04648323f, 0.10646083f, 
    -0.00242776f, -0.12744731f, 0.10247406f, 0.41545191f, -0.02895774f, -0.13681836f, -0.05628063f, -0.02459134f, 
    0.01051461f, 0.08275270f, -0.02954304f, 0.08046114f, -0.18087813f, -0.15525334f, 0.16013345f, 0.07452744f, 
    -0.14342849f, 0.20954327f, -0.37294039f, 0.01408100f, -0.02561747f, -0.14030963f, -0.07515645f, 0.22728501f, 
    0.00112724f, -0.05436840f, 0.29234508f, -0.11146918f, -0.28097528f, -0.09678476f, 0.12599014f, 0.10415379f, 
    -0.09312515f, 0.21162435f, -0.17114481f, -0.19220051f, 0.00575205f, -0.09841342f, 0.29074839f, 0.14273259f, 
    0.31676826f, 0.03042936f, -0.43640801f, -0.07275826f, 0.13618596f, -0.02951065f, -0.09787932f, 0.19893679f, 
    0.24454692f, -0.50799799f, -0.03208501f, 0.05166578f, -0.05057372f, -0.15394472f, 0.10545622f, 0.15316841f, 
    -0.14541171f, -0.30518746f, -0.04201514f, 0.14301544f, 0.32300708f, 0.13181084f, 0.09185017f, 0.14596508f, 
    0.00792451f, 0.13434313f, 0.14169170f, 0.13953595f, 0.09612083f, -0.15993784f, 0.19028240f, -0.17744988f, 
    0.04164033f, -0.10228165f, -0.09594902f, -0.20286591f, -0.03280530f, -0.10540764f, -0.24102923f, 0.13788575f, 
    -0.05147886f, -0.24927515f, -0.15649627f, -0.09303217f, 0.02492061f, 0.10068905f, 0.30425069f, -0.01053805f, 
    -0.16332300f, 0.06022218f, 0.20628202f, 0.10299617f, 0.19536516f, 0.14224809f, 0.15699010f, 0.17674710f, 
    0.02185561f, 0.02716636f, -0.03967975f, -0.05773317f, 0.04954744f, -0.04687709f, 0.22803940f, 0.18591881f, 
    0.01378240f, -0.14872646f, -0.07389943f, 0.12326126f, 0.10374615f, -0.01519099f, -0.02669564f, -0.12443399f, 
    0.10554770f, 0.03628594f, -0.11435088f, 0.08625462f, -0.12343064f, 0.01561766f, -0.13736004f, -0.08011519f, 
    0.01155246f, -0.14591964f, -0.10866639f, -0.14613874f, -0.12393814f, -0.10554890f, -0.09830614f, -0.16550420f, 
    0.09017668f, -0.10550877f, 0.03574868f, -0.15971516f, -0.10846844f, 0.13564488f, 0.03619884f, -0.04966987f, 
    -0.11758140f, 0.14428122f, -0.22434646f, -0.10634599f, 0.14016296f, -0.06281026f, 0.09338708f, 0.25812447f, 
    -0.15365811f, 0.39320815f, -0.17605592f, -0.13032483f, -0.21491055f, 0.15361157f, 0.06938073f, 0.13100439f, 
    0.13869996f, -0.41155586f, 0.13518021f, 0.05448055f, 0.05384592f, -0.10107309f, 0.08832906f, 0.14245763f, 
    0.04125991f, 0.26695484f, 0.07361570f, -0.35803986f, -0.02597049f, -0.04126566f, 0.33725020f, 0.25998420f, 
    -0.00940690f, -0.14561358f, -0.60583419f, 0.14439367f, 0.17731744f, 0.04318579f, -0.04887146f, 0.14535987f, 
    0.28375170f, -0.28010675f, -0.04803233f, -0.07528532f, -0.11420356f, -0.07408714f, -0.05128602f, -0.14227670f, 
    0.07728314f, 0.20192826f, -0.04309790f, 0.01501783f, 0.30432791f, 0.09390877f, 0.09388433f, 0.05005466f, 
    -0.09208753f, 0.20280766f, -0.00926228f, -0.37018973f, 0.12362272f, 0.06767489f, 0.29579192f, 0.22851169f, 
    -0.00011302f, 0.09318929f, -0.29583868f, -0.09998716f, 0.18404602f, 0.12074792f, 0.02856367f, 0.18398292f, 
    -0.01154141f, 0.16080035f, 0.24349596f, 0.13111506f, -0.23175934f, -0.07708285f, 0.14313754f, -0.17374811f, 
    0.13348448f, 0.00027080f, -0.03130545f, -0.06621770f, 0.01835649f, -0.02472587f, 0.18945947f, -0.17900026f, 
    -0.06170267f, -0.08755985f, -0.15622760f, -0.41763747f, -0.01496330f, 0.03958729f, 0.30957752f, 0.32270688f, 
    -0.02840730f, 0.08800493f, -0.01452268f, 0.19864504f, 0.10118229f, 0.07218450f, -0.19042405f, 0.00415725f, 
    0.09506996f, 0.13110070f, 0.17953695f, 0.09227231f, -0.17024331f, -0.12377864f, -0.01193100f, 0.28949353f, 
    0.05114145f, -0.43061811f, -0.03204483f, -0.12574264f, 0.05440885f, 0.14383937f, -0.01570702f, -0.00343436f, 
    -0.05538243f, 0.10769700f, 0.24132502f, 0.31123215f, 0.11510435f, -0.07502642f, 0.01432593f, -0.02155763f, 
    -0.26491365f, 0.15861939f, -0.43781316f, 0.31272879f, -0.16449286f, -0.02970323f, 0.30123669f, -0.00340774f, 
    -0.17955047f, -0.08199361f, -0.09026195f, 0.02298198f, 0.12464568f, -0.07930628f, -0.18345098f, 0.38562450f, 
    0.07743875f, 0.10280361f, 0.22988535f, 0.11574049f, -0.28458509f, -0.25203708f, 0.02473519f, -0.14619416f, 
    -0.00006978f, 0.09938005f, 0.02735792f, -0.16032597f, -0.03392898f, 0.09017467f, 0.13907024f, 0.15301095f, 
    0.14164333f, 0.06523260f, -0.00813326f, 0.02078637f, -0.12267032f, 0.11738656f, -0.08350290f, 0.06132723f, 
    -0.19208559f, 0.13164410f, 0.01467333f, -0.13882110f, -0.06527577f, 0.16044377f, -0.04774885f, -0.07868104f, 
    0.04180320f, -0.18896209f, -0.10143911f, 0.09596940f, 0.15105541f, -0.15884775f, 0.09647314f, -0.10782669f, 
    -0.03090421f, -0.10164253f, -0.18143533f, -0.05245591f, 0.14657442f, 0.13887049f, -0.11360807f, -0.17868407f, 
    -0.46551630f, -0.07776275f, -0.13626774f, 0.24990383f, 0.21865338f, 0.00396581f, 0.21405236f, 0.21088675f, 
    0.02082198f, 0.18488020f, -0.16407913f, -0.16678736f, -0.40791112f, 0.07965237f, -0.21792914f, -0.10675570f, 
    0.33243293f, -0.17455640f, 0.17680512f, 0.04624334f, -0.22841810f, -0.21250142f, 0.01091515f, -0.16584612f, 
    -0.00040764f, 0.13081610f, 0.04069218f, -0.31766295f, 0.01175607f, 0.07558966f, 0.25115824f, 0.24450956f, 
    -0.00086131f, 0.09937952f, 0.10213147f, 0.03688443f, -0.21913321f, 0.16264944f, -0.10849982f, -0.15177064f, 
    -0.07531904f, 0.11955246f, -0.17806987f, 0.14455631f, -0.03755925f, 0.14820416f, 0.00894826f, -0.05448303f, 
    0.00964362f, -0.03453549f, -0.14762694f, -0.04834342f, 0.11548953f, -0.03054948f, -0.10431521f, -0.00709091f, 
    0.04871665f, -0.13754965f, -0.00847675f, -0.08027984f, 0.17583194f, 0.15925871f, -0.06945772f, -0.15905821f, 
    0.01994820f, 0.04430685f, -0.18316263f, 0.08249871f, -0.11811573f, 0.03348261f, 0.10184985f, -0.00536783f, 
    -0.14567550f, -0.01685910f, -0.14463457f, 0.08826064f, -0.01827489f, -0.10400584f, -0.01042913f, 0.11385742f, 
    0.10008378f, -0.15240635f, 0.02191969f, 0.06816056f, 0.04126986f, 0.11379549f, -0.12276715f, 0.02986193f, 
    0.05444818f, 0.01021976f, -0.17677024f, -0.08689398f, -0.09538767f, -0.00962621f, -0.09747201f, -0.21257527f, 
    0.17790289f, -0.08742839f, -0.11835801f, 0.08030166f, -0.00751478f, 0.01499507f, -0.17098390f, -0.12970738f, 
    -0.15876733f, 0.03979537f, -0.16950913f, -0.11815241f, -0.02175885f, -0.06914555f, -0.00818212f, 0.02121420f, 
    -0.08440592f, -0.18651369f, -0.06791304f, -0.09189027f, 0.18210770f, 0.11991093f, -0.11077077f, 0.13871895f, 
    -0.00149617f, -0.04569767f, 0.07780571f, -0.05936207f, -0.15840064f, -0.09333578f, 0.07638395f, -0.03635721f, 
    0.04289621f, 0.03882241f, -0.12173199f, 0.09215992f, 0.08803153f, 0.04161912f, -0.20187689f, 0.05724955f, 
    -0.02232099f, -0.16900980f, -0.08763540f, -0.12537442f, 0.05469444f, 0.03839118f, -0.04443273f, -0.09821362f, 
    -0.19142555f, -0.06000452f, 0.01494466f, -0.07230213f, 0.02531337f, -0.00152157f, -0.14808653f, -0.14633103f, 
    -0.13901575f, 0.00765835f, -0.08688963f, 0.07458992f, 0.07128844f, 0.06031208f, -0.16310987f, -0.12287064f, 
    0.19772968f, -0.03687340f, -0.06783440f, 0.23443268f, -0.25964209f, 0.17247480f, 0.00067818f, -0.07166908f, 
    -0.07560077f, 0.06932220f, -0.22730480f, -0.12512772f, 0.28902769f, -0.05973373f, 0.18279561f, -0.04225249f, 
    -0.58785796f, 0.39756089f, 0.17180425f, -0.10593046f, 0.24570608f, -0.04434998f, -0.02707289f, -0.02626643f, 
    0.01960057f, -0.01005291f, 0.23305126f, -0.25730842f, -0.16205615f, 0.01165511f, 0.12526906f, 0.08581165f, 
    0.13026531f, -0.10692918f, -0.38657701f, 0.05333579f, 0.21277338f, -0.04352244f, -0.09581781f, 0.22737797f, 
    0.23864454f, -0.39197850f, 0.24749097f, 0.14370742f, -0.15083396f, 0.00236167f, -0.16545904f, -0.05244075f, 
    -0.21689993f, 0.37651837f, 0.06384575f, -0.04707177f, 0.14856848f, -0.07209676f, 0.21919930f, 0.01002057f, 
    0.18116023f, -0.13908815f, -0.14181028f, -0.29708788f, 0.07447673f, 0.06008651f, -0.00148638f, 0.10889693f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.30251792f, 0.29671258f, 0.04797252f, -0.01723810f, -0.04132850f, 0.11566687f, 0.02594989f, 0.25355759f, 
    0.35035560f, 0.08224656f, 0.21676065f, 0.31036806f, -0.14450055f, 0.09959034f, 0.14149408f, -0.04793065f, 
    -0.17847833f, 0.04355393f, 0.34037158f, -0.03613084f, 0.25112370f, -0.09335091f, 0.04695273f, -0.10108063f, 
    0.26314786f, 0.23221964f, -0.00974507f, 0.21342756f, -0.01675538f, 0.16016786f, 0.32977393f, 0.31783360f, 
    0.21543527f, 0.19592601f, -0.29813424f, -0.15951239f, 0.37793845f, 0.13178745f, -0.14709035f, 0.08313820f, 
    0.07490195f, -0.06843024f, -0.07604571f, -0.04646298f, 0.11170506f, -0.19686775f, -0.01051164f, -0.07008373f, 
    0.33976072f, 0.04075382f, -0.19566138f, -0.12752478f, -0.06138363f, 0.15821114f, -0.00470292f, 0.12974906f, 
    -0.02227139f, 0.05809833f, -0.08364625f, -0.18260908f, -0.15644164f, -0.12802470f, 0.17054170f, 0.04594964f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.24392208f, 0.06897925f, -0.23273870f, 0.02966331f, 0.08393993f, -0.16408627f, 0.18226707f, -0.28126845f, 
    -0.49185655f, -0.26788270f, -0.08504154f, 0.12978947f, -0.00037569f, 0.15095492f, 0.08769531f, -0.06016409f, 
    0.06582008f, 0.09930589f, -0.22142521f, -0.19641301f, -0.06208318f, 0.13050301f, -0.62059271f, 0.05384801f, 
    0.05312421f, -0.11020742f, 0.13599299f, -0.35220879f, 0.28423801f, 0.25208107f, 0.21699798f, -0.05032155f, 
    0.24187966f, 0.02171101f, 0.06682879f, 0.26513654f, -0.26287881f, 0.13844733f, -0.00510679f, -0.05241761f, 
    0.27643842f, -0.06048450f, 0.01420030f, -0.05307717f, -0.03203664f, 0.08877417f, -0.00575041f, 0.17304605f, 
    0.06909811f, 0.10590784f, 0.04456706f, 0.04713377f, 0.15885289f, 0.18669096f, -0.08151761f, 0.54044330f, 
    0.00388174f, 0.11084650f, -0.05934121f, 0.10071952f, 0.02388144f, 0.03932052f, 0.17538784f, 0.33773834f, 
    0.09328701f, 0.07948676f, -0.00462752f, -0.03147810f, 0.05329766f, -0.10022070f, -0.12403649f, -0.08747743f, 
    -0.10804005f, 0.05571909f, -0.00331614f, -0.12831531f, 0.06152933f, -0.10205999f, -0.00380122f, 0.03289495f, 
    -0.02493992f, 0.07696734f, -0.12404152f, 0.08450286f, 0.05218956f, 0.05976559f, 0.01837082f, 0.04445777f, 
    -0.09067657f, -0.04372592f, -0.03984633f, -0.13976230f, -0.04098506f, 0.02451340f, -0.05547144f, 0.01978623f, 
    -0.02958901f, -0.11063928f, 0.00725533f, 0.04211908f, -0.00784567f, 0.01200457f, -0.01609989f, 0.00693947f, 
    0.01549748f, 0.06010384f, 0.11211593f, -0.03724651f, -0.11343714f, -0.04400073f, 0.00853019f, -0.03408648f, 
    -0.10679133f, 0.02880136f, 0.04325001f, -0.02111122f, -0.02392197f, -0.05697063f, -0.07111800f, -0.02014124f, 
    0.08939310f, -0.00751147f, -0.01686369f, -0.01279436f, 0.07987603f, 0.11109962f, -0.10962410f, 0.06572791f, 
    0.10959924f, -0.10588754f, 0.12497620f, 0.01877765f, -0.31174886f, 0.19147596f, 0.06775745f, 0.01661558f, 
    -0.07209340f, -0.38466644f, 0.35776496f, 0.18114561f, -0.10491495f, -0.11104170f, -0.07389021f, 0.11047633f, 
    0.12902886f, -0.14803910f, 0.10587856f, 0.11990389f, -0.12259884f, -0.15304318f, 0.29043674f, 0.13686652f, 
    0.15249383f, 0.20404586f, -0.06461132f, 0.19287620f, -0.26270968f, -0.20266885f, 0.19922936f, -0.01174258f, 
    0.15600565f, -0.08311684f, -0.10866904f, -0.05845810f, 0.03034629f, 0.12788409f, -0.09558347f, 0.03315138f, 
    -0.06545386f, 0.34615338f, 0.09027344f, 0.22097096f, 0.18373115f, 0.00096989f, -0.20849039f, -0.10515577f, 
    0.29476684f, 0.09950623f, 0.10318136f, 0.12387596f, 0.37792787f, 0.08252481f, -0.04144178f, -0.26577356f, 
    -0.10170212f, 0.06278473f, 0.07080500f, 0.09252062f, 0.01117041f, -0.10317574f, -0.00170086f, 0.20817398f, 
    -0.11643530f, -0.31055185f, 0.09168865f, 0.08426432f, 0.16251904f, 0.15474688f, 0.11892389f, -0.06372475f, 
    -0.03716831f, 0.05553461f, -0.10681731f, 0.06749890f, -0.05833549f, 0.10022940f, -0.05546489f, -0.16559443f, 
    0.10146014f, -0.02286772f, 0.07371028f, -0.08488109f, -0.00250325f, -0.12471511f, 0.11526553f, 0.01681330f, 
    -0.44422337f, -0.03925563f, 0.05542656f, -0.30344021f, -0.20451142f, -0.22074394f, 0.17099249f, -0.25286111f, 
    -0.33112362f, -0.15538490f, -0.09093647f, 0.04813056f, 0.25080541f, -0.29399645f, 0.05332488f, -0.00023389f, 
    0.03623204f, -0.20738658f, 0.03593719f, -0.17346291f, -0.01618277f, -0.06400811f, 0.26028174f, -0.33373454f, 
    0.00471493f, -0.07815453f, 0.10408042f, -0.23390190f, -0.11302434f, 0.06092862f, 0.12317557f, -0.14740320f, 
    0.02759409f, -0.25508115f, -0.02292390f, 0.10338838f, -0.05487069f, 0.07447949f, -0.28910911f, 0.11270606f, 
    -0.05480776f, 0.03014788f, 0.01507552f, -0.01955114f, -0.09054466f, -0.03032159f, -0.07893135f, -0.13141853f, 
    -0.06179470f, -0.10861131f, 0.09719399f, 0.01958945f, 0.09692079f, -0.01070874f, -0.00681064f, -0.03885384f, 
    -0.01067701f, -0.02843641f, 0.03033017f, -0.03438103f, 0.05611908f, 0.01742902f, -0.09616587f, -0.07497352f, 
    -0.11755329f, -0.04130468f, -0.17559811f, 0.03751089f, -0.06924012f, 0.03730285f, -0.06550965f, -0.07598949f, 
    -0.06751412f, -0.00778243f, 0.04976812f, 0.03804474f, 0.00157865f, -0.12270643f, -0.06509902f, -0.10521820f, 
    -0.02221539f, -0.12319583f, 0.00299697f, -0.12096582f, -0.07224351f, -0.08737949f, 0.03255886f, 0.01542544f, 
    -0.09067865f, -0.09063850f, 0.00393742f, -0.07860333f, -0.05581012f, -0.02039086f, 0.06315972f, -0.10951777f, 
    -0.11431570f, 0.09212536f, 0.00611129f, -0.09165874f, 0.07297997f, 0.06036064f, -0.04048111f, 0.06751406f, 
    -0.17338379f, 0.12380300f, 0.04615242f, 0.02705403f, 0.14417191f, -0.05819333f, 0.13386670f, -0.27633631f, 
    -0.34732583f, -0.39089814f, 0.17813298f, 0.25353816f, -0.17887190f, -0.17919949f, -0.20842192f, -0.25535667f, 
    0.10909295f, 0.11212955f, 0.03198088f, 0.03516569f, -0.32365489f, 0.14492565f, -0.30477232f, 0.17029758f, 
    -0.14384583f, 0.04948792f, -0.26218623f, -0.09026635f, 0.16197552f, -0.20778218f, 0.22626442f, 0.35958710f, 
    0.37132579f, -0.00869403f, -0.16417392f, -0.06743705f, 0.04525457f, 0.21042885f, -0.18240410f, -0.07703136f, 
    0.02397846f, 0.33595228f, 0.04579888f, -0.02986886f, -0.41012028f, -0.00985444f, -0.09610656f, 0.09406951f, 
    0.33448470f, 0.17187046f, -0.07209547f, 0.14021510f, 0.53552967f, 0.28733721f, -0.09883407f, 0.49082178f, 
    -0.08290738f, 0.16689487f, -0.09843743f, -0.14266500f, -0.02357997f, 0.06563033f, -0.04642114f, 0.46099326f, 
    0.18711561f, 0.01610368f, 0.12506606f, -0.04655746f, -0.08282956f, 0.23637068f, 0.12676485f, 0.04074530f, 
    0.29212508f, -0.17545113f, 0.54499716f, 0.05205571f, 0.18625055f, -0.09305130f, -0.05125973f, -0.15736528f, 
    0.21167669f, -0.08227731f, 0.06857999f, 0.15215394f, -0.14544381f, -0.12566198f, 0.52784544f, -0.00006898f, 
    0.13193870f, 0.16525817f, -0.22085345f, 0.42205641f, -0.25118613f, -0.19122279f, 0.11360746f, 0.18580882f, 
    0.15003499f, 0.05547155f, -0.38900810f, 0.02394897f, 0.28379482f, -0.13864449f, -0.07858322f, 0.09144156f, 
    0.06154385f, 0.38217896f, 0.02303257f, 0.03453994f, 0.24067320f, -0.03041959f, -0.17739886f, -0.10217505f, 
    0.19940950f, 0.04972635f, -0.05526763f, 0.32259792f, 0.19407979f, 0.16838732f, -0.00464898f, -0.32122624f, 
    0.01115428f, -0.02507934f, 0.00636515f, 0.07482845f, 0.14291339f, 0.03966048f, -0.14839430f, 0.14647824f, 
    0.28891882f, 0.14289081f, -0.00510898f, -0.19415006f, 0.02139948f, -0.12807970f, -0.01622524f, 0.23490117f, 
    0.30074012f, 0.18336059f, 0.10015147f, -0.18970089f, 0.25983751f, 0.39281991f, -0.00249158f, -0.18567605f, 
    -0.09333075f, 0.15513030f, -0.35808736f, -0.07547209f, 0.02519467f, -0.06670413f, 0.05400563f, 0.21639769f, 
    0.04465728f, 0.14696679f, 0.08940811f, 0.19092137f, 0.06091874f, -0.10774576f, -0.52614933f, -0.05720858f, 
    0.18228637f, 0.06904423f, -0.16425675f, 0.11117075f, -0.14920180f, 0.04302122f, -0.10443807f, -0.05817305f, 
    -0.11955004f, 0.26787359f, -0.02854036f, 0.41870266f, -0.05761489f, -0.01563473f, -0.00231906f, 0.18583295f, 
    -0.11853091f, 0.26251790f, -0.05997784f, 0.10682058f, 0.03341007f, 0.00408352f, 0.04317814f, -0.01378229f, 
    0.00620694f, -0.05436559f, -0.00469288f, 0.00632060f, 0.08980354f, 0.09705550f, 0.17833464f, -0.12121287f, 
    0.02034581f, 0.31963280f, -0.28496283f, -0.27279159f, 0.23687558f, -0.18955842f, 0.08484342f, 0.04755468f, 
    0.32432872f, 0.23526387f, 0.15487899f, -0.16690987f, 0.26177579f, 0.23130167f, -0.00217197f, -0.30661878f, 
    -0.11593975f, 0.50503165f, -0.31942326f, -0.14509456f, 0.04569577f, -0.02800876f, 0.49900952f, 0.27864438f, 
    0.12370824f, -0.06834493f, -0.02857531f, -0.16671759f, 0.33603674f, 0.12173159f, -0.22965015f, -0.01304600f, 
    0.23051232f, -0.04994768f, -0.25592497f, -0.07981057f, 0.01735462f, 0.03755666f, 0.01393179f, 0.21554831f, 
    -0.09517276f, 0.12214582f, -0.05368393f, 0.32636204f, 0.22250548f, -0.05396834f, -0.47406435f, 0.35935879f, 
    -0.25814110f, 0.34103993f, 0.01240657f, 0.17946614f, -0.22824773f, 0.14094771f, -0.18930399f, 0.37106413f, 
    0.08280405f, -0.16904213f, 0.00662867f, -0.03872776f, -0.04458222f, 0.10485961f, 0.17241238f, -0.12272176f, 
    -0.18633719f, 0.10747334f, 0.07485136f, 0.01136972f, 0.01499715f, 0.36612925f, 0.30019343f, -0.03419505f, 
    -0.00066313f, 0.06062707f, 0.32087234f, 0.41099831f, 0.08457316f, -0.12394433f, -0.07241636f, -0.16563717f, 
    0.21246943f, 0.14266635f, 0.23834707f, -0.02084604f, -0.19324869f, -0.08223734f, 0.14736021f, 0.21152201f, 
    -0.17659196f, 0.15931611f, -0.29675969f, 0.15432125f, -0.12303008f, -0.17101771f, 0.21727200f, 0.01394464f, 
    0.09357108f, 0.03782640f, -0.23962355f, -0.09422112f, 0.25408918f, -0.20232961f, -0.33088258f, 0.07400374f, 
    -0.16865247f, 0.23626056f, 0.05750302f, 0.12398141f, 0.21469757f, -0.14008148f, -0.09219632f, 0.00887295f, 
    0.37329334f, 0.16642360f, 0.03564454f, 0.06043557f, 0.31916317f, 0.00830975f, 0.01038819f, -0.16691855f, 
    0.06919659f, 0.07146415f, -0.01177039f, 0.00095721f, -0.15058368f, -0.03776994f, -0.01717936f, 0.01444870f, 
    0.03027972f, 0.25588754f, -0.44763520f, 0.13755178f, -0.11471102f, -0.13026908f, -0.20790429f, -0.44730881f, 
    0.16330536f, -0.04156558f, -0.26943743f, -0.07281049f, 0.16947411f, 0.18013352f, -0.07209275f, -0.05154726f, 
    -0.13515936f, 0.37989554f, -0.06772905f, 0.16308241f, 0.25644112f, 0.07812776f, 0.00504993f, -0.06309185f, 
    0.17400406f, -0.11204313f, -0.09932990f, 0.10176242f, 0.19080245f, 0.14153986f, -0.22534791f, 0.21833804f, 
    -0.04180131f, 0.05824563f, 0.06997296f, 0.11991651f, 0.18929411f, 0.21083684f, -0.07537934f, 0.25084114f, 
    -0.00363031f, -0.04897204f, -0.03777219f, -0.30118567f, 0.01049178f, 0.11367588f, -0.17222229f, 0.08187260f, 
    -0.04350513f, -0.01105782f, 0.14861457f, 0.18488193f, 0.18010242f, -0.01688982f, -0.12746298f, 0.38650256f, 
    0.00805484f, 0.17185517f, 0.14610556f, 0.01756101f, -0.15128763f, 0.06344998f, 0.20855285f, 0.00049171f, 
    0.00518343f, 0.02958703f, -0.33857474f, 0.06910206f, 0.06849644f, -0.15720144f, -0.32349968f, -0.10205540f, 
    -0.17337258f, -0.06336854f, -0.37282193f, 0.14490739f, 0.02889423f, 0.28245458f, 0.14183100f, 0.50016606f, 
    0.18576273f, 0.06953027f, -0.06589594f, 0.09836604f, 0.14818719f, -0.00306968f, -0.60859919f, 0.32572502f, 
    -0.09301119f, -0.45766574f, 0.23385105f, -0.20600986f, 0.23322181f, 0.01398430f, -0.14903563f, -0.22101955f, 
    -0.06107795f, 0.21947330f, 0.13783029f, 0.08735812f, -0.16996497f, -0.02771910f, -0.07049380f, -0.11576692f, 
    0.14443390f, -0.23747052f, 0.08808672f, -0.07639618f, -0.07520543f, 0.01099173f, 0.01897106f, -0.01899797f, 
    -0.01144300f, -0.13716373f, 0.09605987f, 0.18227525f, -0.06202077f, -0.20058247f, -0.10039810f, 0.25952026f, 
    0.09812102f, 0.32156280f, -0.08752881f, 0.02808602f, 0.01604419f, -0.07999179f, 0.16785829f, -0.03422713f, 
    0.12923919f, 0.00730027f, -0.13549988f, -0.01873242f, 0.13510522f, -0.33116809f, -0.05672153f, -0.06786968f, 
    0.23293665f, 0.10981236f, -0.04642472f, -0.23840640f, 0.10024481f, -0.05200081f, -0.41697857f, 0.04527835f, 
    -0.03874061f, 0.20238282f, -0.58446676f, -0.07777718f, -0.07766280f, -0.02874987f, -0.25383332f, 0.00717106f, 
    0.02164737f, 0.15404862f, 0.01442123f, 0.09044775f, -0.10401545f, 0.11762235f, -0.46131274f, 0.11649488f, 
    -0.10331295f, 0.25041109f, 0.01390822f, -0.17946231f, -0.06338484f, 0.12666227f, -0.12384503f, 0.12594116f, 
    0.10795155f, -0.02618583f, -0.04553773f, 0.03009235f, -0.43763953f, -0.01915012f, -0.17457758f, 0.14112513f, 
    -0.54221934f, 0.07449205f, -0.00276759f, -0.07895681f, 0.11067458f, 0.22001770f, -0.01561710f, 0.05852036f, 
    0.08791804f, 0.21906020f, -0.06780638f, -0.06903675f, 0.02629014f, 0.12218516f, 0.15085059f, 0.11533064f, 
    -0.38771960f, 0.15058008f, -0.02615621f, 0.02855480f, -0.16062997f, 0.21424577f, -0.14788321f, -0.17355509f, 
    0.12769738f, -0.08614353f, 0.05543537f, 0.07051177f, -0.29699299f, -0.04983549f, 0.03783455f, -0.22353593f, 
    -0.08354970f, -0.45641732f, 0.09401264f, 0.20544001f, 0.06451222f, 0.12429906f, 0.14884873f, -0.30800408f, 
    0.06863166f, 0.13085432f, -0.30091813f, 0.29114622f, -0.14388660f, -0.01316709f, 0.11621052f, 0.34026906f, 
    0.20153527f, 0.13457805f, -0.70307040f, -0.16953845f, 0.35416976f, 0.11158590f, 0.24073029f, 0.09103397f, 
    0.23032890f, 0.19935007f, 0.06810267f, -0.39629415f, -0.04736644f, 0.00319169f, -0.26602450f, 0.00786889f, 
    0.15926138f, -0.11013971f, -0.03108063f, 0.08678295f, 0.36054161f, 0.04887326f, 0.07764385f, -0.04153569f, 
    0.05195310f, 0.19125997f, 0.11411927f, -0.07230617f, -0.01009631f, -0.05929714f, -0.20254587f, 0.13386990f, 
    -0.02052946f, -0.20103085f, -0.20866993f, -0.22992879f, -0.13665409f, 0.10584943f, -0.22719406f, 0.02215850f, 
    -0.08710837f, 0.09937833f, -0.07809501f, -0.06474678f, -0.22387688f, -0.01022891f, -0.06486042f, -0.12991776f, 
    -0.29872033f, 0.08664257f, -0.00795993f, -0.11598485f, -0.21367478f, 0.05995827f, 0.12504435f, -0.05373699f, 
    0.13882226f, -0.25693271f, 0.12326604f, -0.08402921f, -0.11253395f, 0.24953887f, -0.29987231f, 0.03595959f, 
    -0.08578258f, 0.04852100f, 0.07926761f, 0.04793536f, -0.03564468f, -0.17735268f, -0.01888613f, -0.15264797f, 
    -0.02694708f, -0.16398817f, 0.07698548f, 0.13429862f, 0.23689686f, -0.07070071f, 0.03322333f, -0.24943478f, 
    0.13048987f, -0.17762794f, -0.02192406f, -0.09629001f, 0.04043566f, -0.15596826f, 0.06854790f, 0.01922025f, 
    -0.06339425f, -0.10467537f, -0.03158181f, 0.06932303f, 0.19399299f, -0.06804740f, 0.09031159f, -0.04291585f, 
    -0.01761217f, 0.25966281f, -0.24917112f, -0.12466951f, 0.02541805f, -0.13529265f, -0.23333175f, -0.35695678f, 
    0.30072579f, 0.06348875f, -0.13035120f, -0.10393275f, 0.18084674f, -0.17137431f, 0.07459030f, -0.08856887f, 
    0.02804016f, 0.18317422f, 0.05383085f, 0.12019088f, 0.28328830f, 0.00886815f, 0.33203340f, -0.14668408f, 
    0.15778778f, 0.10531914f, -0.38342974f, 0.29838586f, 0.12615167f, 0.14181039f, -0.09759546f, 0.41419494f, 
    0.11925686f, 0.04245906f, -0.08058687f, -0.15812525f, 0.20971116f, 0.23350799f, -0.06608639f, 0.07029296f, 
    0.06236677f, 0.00215974f, -0.03122632f, -0.32460696f, -0.16490974f, -0.07838258f, -0.22104073f, 0.02181363f, 
    -0.10254440f, -0.04642094f, -0.11116538f, 0.08186740f, 0.01597257f, -0.02408547f, -0.07756861f, 0.30269167f, 
    -0.00803548f, 0.43802601f, -0.09786321f, -0.06798117f, 0.12500957f, -0.05142649f, 0.05334697f, 0.14023958f, 
    -0.04162990f, 0.00963373f, -0.17553765f, -0.22916934f, -0.11491101f, 0.16762112f, 0.02573986f, 0.08794668f, 
    -0.07736555f, -0.05510491f, -0.10495255f, 0.01155632f, 0.20662545f, -0.20904562f, -0.08044132f, 0.23824428f, 
    0.22345750f, 0.08717709f, -0.10059924f, 0.05240820f, -0.03810738f, 0.07327988f, -0.16696993f, 0.19761051f, 
    0.02520479f, -0.26552483f, 0.18105768f, -0.22628956f, 0.00687143f, 0.16863288f, -0.39109376f, -0.31388727f, 
    -0.07343253f, 0.15655737f, -0.11193134f, 0.16952956f, -0.55485016f, 0.01138027f, -0.15948734f, 0.09477694f, 
    0.08615524f, 0.08326560f, 0.08263551f, 0.02299820f, -0.26435134f, -0.08217090f, -0.05102697f, 0.11646357f, 
    -0.02058632f, -0.01963376f, -0.11074653f, 0.05846607f, 0.07518959f, -0.11508631f, -0.06778388f, 0.04899004f, 
    -0.10414717f, 0.15765800f, 0.10983928f, -0.05652648f, -0.06468263f, -0.10786453f, 0.05397974f, -0.13757837f, 
    -0.14189720f, 0.13541684f, 0.18733695f, -0.02262235f, 0.17927782f, 0.07216445f, 0.13869771f, 0.14424099f, 
    0.02327939f, 0.25708884f, -0.25441614f, 0.00560003f, -0.05977953f, -0.10539126f, 0.20405516f, -0.38851941f, 
    -0.39946070f, -0.17373297f, 0.02526151f, 0.08064826f, 0.15595947f, -0.04313701f, 0.19266550f, 0.13775177f, 
    0.16796930f, -0.03907907f, 0.07200959f, -0.18812986f, 0.17632799f, 0.30987296f, 0.25503296f, -0.15480694f, 
    0.07965294f, 0.07396549f, -0.12995611f, -0.09040258f, -0.03413308f, 0.15390414f, 0.06764724f, 0.18946123f, 
    0.03686761f, -0.04146770f, 0.06165615f, -0.45543984f, 0.20118615f, 0.04141739f, 0.21816665f, 0.01003707f, 
    0.26462975f, 0.18506606f, -0.00007669f, -0.23197345f, -0.20701848f, -0.12391655f, 0.03058187f, 0.13867776f, 
    -0.03145871f, -0.37206280f, 0.17196977f, 0.08052638f, -0.17399849f, -0.03362606f, -0.03775320f, 0.11697764f, 
    0.06662507f, 0.09648702f, -0.20384049f, -0.02843549f, -0.25851360f, 0.24694467f, 0.07001503f, 0.13466524f, 
    0.01361957f, 0.01114939f, 0.36150780f, 0.16067921f, 0.18568449f, -0.00185507f, -0.01805308f, 0.14178288f, 
    0.10999218f, 0.08368713f, -0.03935127f, 0.12690113f, -0.18761903f, -0.21900383f, -0.05223587f, 0.32679093f, 
    0.06973817f, 0.04812656f, -0.10057919f, 0.14623418f, 0.05358901f, -0.09254629f, -0.27009442f, -0.06058114f, 
    0.19208562f, -0.17962478f, -0.26561388f, 0.29139569f, -0.14012600f, -0.10535723f, -0.07410454f, 0.06024960f, 
    -0.15400596f, 0.33270377f, 0.04119674f, 0.19755977f, -0.03222204f, -0.11864097f, -0.31337920f, 0.12865756f, 
    0.10197901f, -0.01792026f, -0.10644480f, 0.27017707f, -0.03930295f, -0.01937323f, 0.08755162f, 0.01395445f, 
    0.01701094f, -0.08720639f, 0.03259613f, -0.07630377f, 0.02494080f, -0.09154345f, 0.13337803f, -0.12655291f, 
    -0.07057060f, -0.06285196f, -0.14162277f, 0.19451566f, 0.09536491f, 0.11440514f, -0.13500206f, 0.15156843f, 
    0.00821465f, 0.39774594f, 0.13804016f, 0.35496736f, 0.21602440f, 0.32244813f, 0.19798455f, 0.17158648f, 
    0.10680643f, -0.00199493f, 0.20275334f, 0.18652019f, 0.20719855f, -0.04803400f, -0.25385338f, 0.08744772f, 
    -0.03936205f, -0.03443067f, 0.09018459f, -0.16993423f, -0.05868897f, -0.01894503f, 0.03504094f, -0.18614915f, 
    0.03830025f, -0.11709540f, -0.03325003f, 0.44926023f, 0.08724089f, -0.00365502f, 0.02352834f, -0.14702865f, 
    0.06000647f, -0.17983735f, 0.00250633f, 0.32336870f, 0.16299541f, -0.05736009f, 0.20035623f, 0.04034757f, 
    0.15432052f, -0.12236334f, -0.13175090f, 0.10714164f, -0.13001983f, -0.23001923f, 0.17814089f, 0.11573385f, 
    0.08507320f, -0.14665465f, -0.07891698f, -0.06154306f, 0.15769634f, 0.02480751f, -0.01891483f, -0.30964285f, 
    -0.04527864f, 0.14592879f, -0.02205890f, -0.02704117f, 0.01249588f, -0.14889447f, 0.04112655f, -0.08213181f, 
    -0.07393761f, -0.10636775f, -0.08085469f, -0.22032271f, -0.19584304f, -0.15324922f, -0.00354253f, -0.09719609f, 
    -0.18827972f, -0.09398141f, 0.04436266f, 0.13671389f, 0.16719708f, 0.09885316f, -0.11461388f, -0.27206758f, 
    0.24508375f, 0.01318460f, -0.10316510f, 0.05135384f, 0.20082027f, 0.25028592f, 0.06137466f, 0.10957003f, 
    0.01674521f, 0.18760590f, -0.03973743f, 0.06197862f, 0.17759591f, 0.25044310f, 0.07592852f, -0.01904393f, 
    0.08495311f, -0.08678650f, 0.01534963f, -0.39833292f, -0.18318892f, -0.08638822f, -0.15714297f, -0.07344742f, 
    0.17614770f, -0.02598706f, 0.01399613f, -0.02207329f, 0.09662529f, -0.06535874f, 0.11521478f, -0.01314338f, 
    -0.08731357f, 0.03481131f, -0.00428577f, 0.00521006f, 0.01249762f, -0.00592160f, 0.13158417f, 0.18302682f, 
    -0.24561772f, 0.06616013f, -0.40766823f, 0.01386302f, 0.09544885f, -0.10129005f, -0.43731782f, -0.27449104f, 
    -0.22269669f, 0.01682944f, -0.38604856f, 0.13624291f, 0.08168612f, 0.24575275f, 0.18363227f, 0.61447299f, 
    0.12771440f, 0.23728310f, 0.08039306f, 0.13959545f, -0.13508703f, 0.03191728f, -0.33851841f, 0.34296253f, 
    -0.07440237f, -0.35298672f, 0.09672537f, -0.39640075f, 0.13160838f, 0.03316363f, -0.19449387f, 0.11924728f, 
    0.07326916f, -0.11896133f, -0.12552242f, 0.17087597f, -0.30049878f, 0.21062016f, 0.16246226f, -0.17408912f, 
    0.21500143f, 0.02203252f, -0.00279610f, -0.12878306f, -0.22248189f, -0.00131324f, -0.02826335f, 0.03625566f, 
    0.01256084f, -0.11351287f, 0.03068849f, 0.02322036f, 0.24797295f, 0.02546459f, 0.13689980f, 0.61441135f, 
    0.05376981f, 0.20022807f, -0.09614834f, 0.07858898f, 0.09871620f, 0.13075607f, 0.05367083f, 0.10472058f, 
    -0.09321941f, 0.07640761f, 0.02491985f, -0.27615345f, 0.13914904f, -0.03592821f, 0.05180237f, -0.24121830f, 
    0.22985603f, 0.02815099f, 0.09511066f, -0.07472838f, -0.06992272f, -0.30157790f, -0.26127699f, -0.26781568f, 
    0.33216378f, -0.00333201f, -0.01949980f, -0.04111830f, -0.05882561f, -0.03572878f, 0.19993007f, -0.27216187f, 
    0.07703564f, -0.00412228f, -0.40663865f, 0.13814734f, 0.16792159f, -0.07552498f, -0.09396863f, 0.30710444f, 
    0.16100797f, -0.16820823f, 0.05782923f, 0.08523071f, -0.08965325f, 0.05566945f, 0.10465182f, 0.23622806f, 
    0.15383686f, -0.03326761f, -0.06465475f, 0.06114900f, 0.02132641f, 0.09313895f, -0.02041973f, 0.21928757f, 
    -0.19996859f, 0.15510075f, -0.03353926f, 0.36847410f, 0.25955051f, 0.26446271f, -0.05266931f, 0.31427184f, 
    -0.08874308f, 0.40861669f, 0.09130438f, -0.01832700f, -0.14255585f, 0.12158656f, -0.04500106f, 0.15005359f, 
    -0.31330031f, 0.32147461f, -0.46880230f, -0.11657954f, 0.06794191f, 0.04479694f, -0.12835480f, -0.16932854f, 
    0.15493923f, -0.03756212f, -0.31863141f, -0.05805241f, -0.01233371f, -0.00984624f, 0.15125379f, -0.24149950f, 
    -0.25674236f, 0.19168566f, -0.10324044f, -0.10143237f, 0.05601941f, 0.23841643f, 0.00615069f, -0.12930527f, 
    0.17841072f, -0.24779618f, -0.07317901f, 0.09083205f, 0.28989246f, 0.26051554f, -0.07543501f, 0.41820037f, 
    0.15434644f, 0.18240502f, 0.00124885f, 0.10273682f, 0.12228492f, 0.12328812f, 0.04922878f, 0.25257906f, 
    0.22797099f, -0.24467032f, -0.03399229f, -0.53794700f, -0.07170213f, 0.03531859f, -0.03646306f, 0.06961180f, 
    -0.02360832f, 0.02361351f, 0.00154349f, -0.00969939f, 0.03844138f, 0.05159019f, -0.12062361f, 0.22886586f, 
    0.10422064f, 0.27390900f, 0.06776127f, 0.09815506f, 0.01856260f, -0.10487059f, 0.05669932f, 0.15276007f, 
    -0.15086702f, -0.03424694f, -0.19626977f, 0.27323455f, 0.02402210f, 0.15716296f, -0.11435568f, 0.32944658f, 
    -0.21343009f, 0.18301468f, 0.04068943f, 0.28198859f, -0.02020502f, 0.22346978f, 0.37068069f, 0.15692659f, 
    -0.14442647f, -0.08968078f, 0.23628749f, 0.11750775f, 0.33266839f, -0.00672607f, -0.54814172f, 0.08406492f, 
    -0.13436563f, -0.11848986f, 0.14365835f, 0.09910000f, -0.04787970f, 0.22608562f, 0.08028221f, -0.37162706f, 
    -0.03888760f, -0.12415342f, -0.10690285f, 0.17831194f, -0.12803853f, 0.07262602f, -0.03025812f, -0.04026143f, 
    0.08728832f, -0.11224207f, 0.04633783f, 0.26644573f, -0.16982992f, 0.11085167f, -0.05148044f, 0.17797807f, 
    0.03582146f, -0.08117315f, -0.13210528f, 0.11486910f, -0.36012417f, -0.10532179f, 0.12685037f, 0.17841581f, 
    -0.07917810f, -0.25264153f, 0.12323022f, 0.03791012f, 0.00697715f, 0.01429094f, 0.03009827f, -0.32167262f, 
    -0.12845705f, 0.00246788f, -0.16948444f, 0.08093913f, -0.27346015f, 0.14428677f, 0.09363978f, 0.37959412f, 
    -0.09126040f, 0.21002688f, 0.18670143f, 0.22413750f, -0.08828142f, 0.28630033f, 0.23214056f, 0.37557811f, 
    0.04343654f, 0.03973058f, 0.00293363f, 0.15565646f, 0.09218206f, -0.13595022f, -0.36767921f, 0.26800078f, 
    -0.08326514f, -0.05107033f, 0.20626234f, 0.08858409f, -0.07442550f, -0.14426683f, -0.09522992f, -0.15304884f, 
    0.04639922f, -0.54835331f, -0.12790407f, 0.32097387f, -0.14320584f, 0.05804291f, 0.09324098f, -0.31991082f, 
    0.05040696f, 0.01607221f, -0.00278772f, 0.35387528f, -0.24707103f, -0.05466226f, -0.17791463f, 0.27436855f, 
    0.06609820f, -0.07362186f, 0.02046127f, 0.11918386f, -0.20489123f, -0.06450228f, 0.13623869f, 0.23881631f, 
    -0.07442683f, -0.04529259f, 0.06731225f, -0.03529560f, 0.00113739f, -0.04639912f, 0.03457873f, -0.20869751f, 
    -0.06536250f, 0.16509719f, -0.16151963f, 0.15290967f, -0.16408625f, 0.08205523f, -0.04365634f, 0.17048052f, 
    0.11647605f, 0.08648651f, -0.10542043f, 0.02433333f, -0.08842226f, 0.08842818f, 0.05545796f, 0.14403096f, 
    -0.23391107f, -0.04436469f, 0.10579383f, 0.31560832f, 0.42848969f, -0.01308526f, -0.42721200f, 0.07308686f, 
    0.17113243f, -0.07513654f, 0.10162699f, 0.30974284f, -0.05749245f, 0.14070463f, 0.03409411f, -0.06208812f, 
    -0.00386475f, 0.18646210f, 0.12082957f, 0.05346169f, 0.00268300f, -0.06784626f, 0.05963066f, -0.05556341f, 
    0.01445744f, -0.13668488f, 0.06011816f, -0.03634353f, -0.08934715f, -0.00409344f, 0.01544777f, 0.21878824f, 
    -0.07220538f, -0.06840497f, 0.03777102f, 0.27893406f, -0.44954279f, -0.16557631f, 0.11533189f, -0.11940613f, 
    -0.07471287f, 0.11239821f, -0.04741038f, -0.06775849f, -0.01344057f, 0.02135790f, 0.17578480f, -0.21819136f, 
    -0.04723902f, 0.18824799f, -0.37216938f, 0.13843979f, 0.18975249f, 0.04605100f, -0.34182402f, 0.00704532f, 
    0.35806951f, 0.27344102f, -0.15974858f, 0.09350178f, 0.21697557f, 0.09835960f, 0.28546223f, 0.16752999f, 
    -0.24832955f, -0.12860359f, 0.25125927f, 0.05753556f, 0.43266928f, -0.02219218f, 0.24162930f, -0.31171694f, 
    0.26489240f, -0.19255269f, -0.00773275f, 0.24526639f, 0.07951291f, 0.33122501f, 0.16262072f, 0.11370300f, 
    -0.02099380f, 0.18735775f, -0.27149507f, 0.23770276f, 0.20953025f, 0.13271923f, 0.17282532f, 0.12822442f, 
    0.22893418f, -0.37546483f, 0.11066230f, -0.02280235f, 0.10253433f, -0.03608406f, -0.31837505f, 0.03317101f, 
    -0.04093391f, 0.04030427f, 0.11440884f, 0.12307166f, -0.47171116f, -0.18193953f, 0.05952942f, -0.13666078f, 
    0.04873269f, 0.20146555f, 0.06795432f, 0.01378100f, 0.18767081f, 0.09273809f, 0.07970931f, -0.12394518f, 
    -0.10958267f, 0.14765690f, -0.05439933f, -0.18371370f, 0.33267993f, 0.03096753f, 0.03710587f, -0.18539953f, 
    0.00410373f, -0.09052961f, -0.07024580f, -0.07426929f, -0.09257650f, -0.02241415f, -0.16854894f, 0.08597764f, 
    0.00930012f, 0.19983371f, -0.02795261f, -0.42049628f, -0.15091996f, 0.27849534f, 0.36375040f, 0.23847011f, 
    -0.10372116f, -0.26394555f, 0.02123500f, -0.21703708f, 0.16404979f, 0.02831804f, -0.08708686f, -0.29602516f, 
    -0.31620064f, -0.08152422f, -0.09854631f, -0.18966468f, -0.06809638f, 0.09155432f, 0.28333580f, 0.08753988f, 
    0.04125419f, -0.12992229f, -0.06849978f, 0.03128896f, 0.13417748f, 0.18203565f, -0.18519850f, 0.06695502f, 
    -0.08657111f, -0.01447223f, 0.10016523f, -0.24464087f, -0.13364480f, -0.03685279f, -0.11766021f, 0.00113932f, 
    0.03279193f, 0.16580243f, 0.09524425f, 0.04489420f, -0.03538730f, 0.00644976f, 0.03285138f, -0.10097403f, 
    -0.08594260f, -0.02655254f, 0.19867842f, -0.01526867f, -0.06735968f, 0.06527608f, -0.07588309f, -0.07804370f, 
    -0.12737696f, 0.05204152f, 0.29676113f, 0.09184313f, -0.09945145f, 0.10829344f, 0.09601728f, 0.18755822f, 
    0.52212191f, -0.15512653f, 0.18867166f, 0.19577202f, -0.09219233f, -0.02729235f, -0.02274939f, 0.07060216f, 
    -0.24025787f, 0.03321153f, 0.17672873f, -0.00001670f, -0.25947657f, -0.05355510f, 0.09795374f, 0.00855671f, 
    -0.39895526f, -0.40428966f, 0.01723959f, 0.19996573f, -0.01789781f, -0.28994957f, -0.11028799f, -0.05952326f, 
    0.01806264f, -0.00971830f, -0.07053541f, 0.54614508f, -0.24759096f, 0.06448834f, -0.04177466f, 0.31157556f, 
    -0.10667961f, 0.01695657f, -0.06526891f, -0.03273685f, -0.06347589f, -0.08553477f, -0.05811996f, 0.06656101f, 
    -0.02041374f, 0.10978273f, 0.01530832f, -0.08695126f, 0.12476261f, 0.09350044f, -0.17209256f, -0.09155284f, 
    0.04040869f, 0.00423788f, -0.04782499f, -0.01356263f, -0.08765153f, -0.10042058f, -0.08281140f, 0.06514720f, 
    -0.13265388f, 0.09308106f, 0.09193659f, 0.05430659f, 0.07913639f, 0.11953928f, 0.13735752f, -0.05915151f, 
    -0.08085421f, 0.06068773f, -0.10174690f, 0.02714000f, 0.09822054f, -0.11185185f, -0.13076346f, -0.15336633f, 
    0.00228281f, -0.03102333f, -0.05684827f, -0.15102312f, -0.06990452f, -0.14300214f, 0.04335310f, 0.06118430f, 
    -0.11847911f, -0.08556259f, -0.12207972f, 0.01636885f, 0.03352699f, -0.16011193f, 0.01056889f, 0.00242329f, 
    -0.13012287f, -0.03188299f, -0.01364569f, -0.03415508f, 0.03402317f, 0.03660259f, -0.08159978f, -0.09044816f, 
    -0.08462287f, -0.05304255f, 0.03404474f, -0.08435323f, -0.16797200f, -0.06516425f, -0.00065653f, 0.04654954f, 
    -0.09948517f, 0.00946505f, -0.09584810f, -0.05136615f, 0.10142437f, 0.07300241f, 0.08781416f, 0.06269368f, 
    0.00153966f, 0.03050775f, 0.02827613f, -0.19696380f, -0.04204927f, -0.04711659f, -0.01698351f, 0.08533013f, 
    0.12270479f, 0.03169084f, 0.07603791f, 0.00710657f, 0.04333476f, -0.02857668f, -0.16467544f, -0.17816220f, 
    -0.08726261f, 0.05284214f, -0.22928466f, 0.07609887f, -0.05864084f, 0.05325093f, 0.09470519f, 0.01177951f, 
    0.11016677f, -0.05200546f, -0.15129423f, 0.12847833f, 0.03584160f, 0.02137415f, -0.07258315f, -0.07847051f, 
    -0.06610526f, -0.06660403f, 0.06087441f, -0.20133069f, 0.09957475f, -0.12221742f, 0.17770115f, 0.01500922f, 
    0.07645450f, -0.00175206f, 0.00445499f, 0.05246216f, -0.04112397f, -0.05271754f, 0.03209987f, -0.03456772f, 
    -0.07975887f, -0.11491411f, -0.06022118f, -0.00429447f, -0.11405905f, 0.01557297f, -0.31288028f, -0.17070861f, 
    -0.06600331f, 0.14487700f, 0.04682025f, 0.07384083f, -0.04006631f, -0.00735475f, 0.06305929f, 0.03818651f, 
    0.10874358f, 0.22252658f, -0.12157845f, -0.19310859f, 0.25797376f, -0.11200009f, 0.12992020f, 0.38664120f, 
    0.19687250f, 0.37119788f, 0.24505310f, -0.10967696f, 0.14526567f, -0.04806543f, -0.02675387f, -0.41181272f, 
    -0.25692478f, 0.15992041f, -0.22817624f, -0.19442245f, -0.05280351f, 0.05782494f, -0.00010619f, 0.30302215f, 
    0.23494895f, 0.04522850f, 0.14944990f, -0.07786667f, 0.21370667f, 0.08618789f, -0.15856116f, -0.04743624f, 
    0.04703093f, 0.14035623f, -0.15633725f, 0.06133039f, -0.20046706f, 0.11831420f, -0.02722363f, 0.18061644f, 
    -0.04151169f, 0.01366915f, 0.05965718f, 0.36785713f, -0.05387664f, 0.12990975f, -0.08023128f, 0.30547446f, 
    -0.14246066f, 0.36873725f, 0.06994785f, 0.12915930f, -0.26185063f, 0.07960983f, 0.03249908f, 0.14720778f, 
    -0.04861429f, -0.12175842f, 0.01489288f, -0.00998793f, 0.00665185f, 0.10142016f, 0.29965672f, -0.11848125f, 
    -0.07936742f, 0.05114136f, -0.07854587f, -0.04339796f, -0.11032014f, 0.20060124f, 0.04836387f, 0.25376186f, 
    -0.06102797f, 0.15817714f, 0.16670620f, 0.06843005f, -0.09508660f, 0.09050141f, 0.06035410f, 0.04914736f, 
    0.16408776f, -0.07568301f, -0.01343083f, 0.12054023f, -0.06105372f, -0.08107977f, 0.01330495f, 0.17341721f, 
    -0.12683140f, 0.03793358f, 0.11135101f, 0.03500227f, -0.24264225f, 0.00004240f, -0.03569398f, 0.00156856f, 
    0.03968672f, -0.50309801f, -0.05715695f, 0.25550452f, -0.17244278f, 0.00043742f, 0.28649163f, -0.13005079f, 
    0.05381492f, 0.23722801f, -0.09402982f, 0.42806995f, 0.01179667f, 0.16390575f, -0.16838120f, 0.08197264f, 
    -0.00046511f, -0.06329171f, -0.02444756f, 0.35084653f, 0.09156695f, -0.09553807f, 0.07124370f, 0.14876562f, 
    0.07962096f, 0.06538362f, -0.10257909f, -0.07872011f, 0.11683626f, -0.00047313f, -0.15155351f, -0.24389315f, 
    -0.06655898f, 0.16286296f, 0.12919578f, 0.09845989f, 0.11681906f, -0.29578257f, 0.20203365f, -0.11990388f, 
    -0.13153532f, -0.29231706f, -0.01349483f, -0.13654485f, -0.08256894f, -0.18057932f, -0.25305730f, 0.36485308f, 
    -0.00587621f, 0.11961497f, -0.06735893f, -0.07575785f, -0.15394558f, 0.22674440f, -0.14818653f, 0.37195918f, 
    -0.25715807f, -0.01065771f, 0.14948216f, -0.17314860f, 0.16847675f, -0.28344497f, -0.02144276f, 0.00152981f, 
    -0.07497155f, 0.02865605f, 0.03223672f, -0.15021451f, -0.13649938f, -0.16139662f, 0.15525475f, 0.20619895f, 
    -0.46956065f, -0.21856025f, -0.11141382f, -0.21221966f, -0.10326480f, 0.01226154f, 0.05501940f, -0.29427633f, 
    -0.50002706f, 0.10785806f, -0.02356745f, -0.26000169f, 0.03019101f, 0.02889464f, -0.01942764f, -0.14401978f, 
    -0.06486429f, -0.02924742f, 0.02930331f, -0.04403529f, -0.01487339f, -0.08523774f, 0.03770370f, -0.05624282f, 
    -0.06428291f, 0.23420456f, 0.15164857f, 0.14871764f, 0.10538293f, -0.06364932f, -0.03139727f, 0.03108964f, 
    0.20967861f, 0.10472880f, -0.06006664f, -0.04065629f, 0.10235986f, -0.29901254f, 0.02218980f, -0.61274940f, 
    -0.50590599f, -0.08698185f, -0.12455520f, 0.16165590f, 0.29192522f, 0.11109769f, 0.10978998f, 0.08748149f, 
    0.25761008f, 0.07894456f, -0.03141366f, 0.29683575f, -0.04252404f, 0.16023540f, 0.13423687f, 0.03252441f, 
    -0.05465746f, 0.08226452f, 0.18179588f, -0.52531451f, 0.57691330f, -0.03909927f, -0.01021096f, 0.21937545f, 
    0.09116299f, -0.40939426f, -0.06267795f, -0.11329025f, 0.21771531f, 0.08611356f, -0.06178356f, 0.02221642f, 
    -0.27726969f, 0.08405043f, 0.02020000f, -0.17458139f, -0.38905153f, -0.13606440f, -0.05498878f, -0.52781475f, 
    0.05189773f, 0.13897085f, -0.03716224f, -0.10252380f, 0.09052916f, 0.06260343f, 0.18608136f, -0.04466631f, 
    -0.13512008f, -0.01196446f, -0.12341620f, 0.20629199f, 0.02883912f, 0.11457090f, -0.04078363f, 0.21550661f, 
    -0.22286364f, 0.29550758f, -0.18602212f, 0.11505384f, 0.01909387f, 0.26134479f, 0.24799310f, 0.36843082f, 
    0.06483601f, 0.22242233f, 0.11662173f, -0.04992612f, 0.09961575f, 0.11710876f, 0.04660968f, 0.07518218f, 
    -0.26637045f, -0.20451355f, 0.22098491f, -0.06258120f, -0.03015081f, -0.07062218f, 0.05162653f, -0.17412861f, 
    -0.18352632f, -0.22914492f, -0.13227400f, 0.21435088f, -0.05441453f, 0.05875710f, -0.13774249f, -0.05109502f, 
    0.06751009f, -0.07493161f, -0.05440554f, 0.05552373f, -0.13278736f, 0.04305122f, 0.14643113f, 0.03629135f, 
    0.08540223f, -0.00168376f, -0.04600200f, -0.17444104f, 0.03361464f, -0.26178968f, 0.16630082f, 0.23381612f, 
    -0.01223096f, 0.00438176f, 0.11208561f, -0.03369088f, -0.09289751f, -0.11669762f, 0.01822780f, 0.00552958f, 
    0.13142811f, -0.21053472f, 0.20606901f, 0.02224943f, 0.13531324f, 0.10049049f, 0.26714876f, 0.01678864f, 
    -0.09999492f, -0.04470675f, 0.20726644f, 0.35013282f, 0.32278413f, -0.08389762f, 0.10412752f, -0.29407483f, 
    -0.07911194f, 0.20524202f, 0.15334702f, -0.08910225f, -0.19934639f, -0.03669171f, -0.05069542f, 0.48183995f, 
    -0.18608516f, -0.11847908f, -0.06441011f, -0.08345600f, 0.08606079f, -0.38958463f, 0.12814373f, 0.02828149f, 
    0.22741739f, 0.16018072f, -0.53701627f, -0.13195993f, 0.31971589f, -0.02437394f, -0.14144558f, 0.12980503f, 
    0.04599735f, 0.28214595f, -0.02299742f, -0.14377044f, 0.33409479f, 0.01154472f, 0.09510836f, -0.22245203f, 
    0.22244196f, 0.23637539f, -0.18346263f, -0.15779606f, 0.27272847f, 0.02853801f, 0.06630562f, -0.13953131f, 
    0.03066778f, -0.33508712f, 0.10860827f, 0.06483953f, 0.20298715f, -0.10686857f, 0.18118012f, 0.04207067f, 
    0.14216234f, 0.15906084f, -0.17325905f, -0.13094066f, -0.03236837f, 0.18117529f, -0.28670135f, -0.34227836f, 
    0.44469887f, -0.07236608f, 0.20808254f, -0.05173767f, 0.03995762f, 0.03925648f, -0.01303030f, 0.14103736f, 
    0.40326080f, -0.09617145f, 0.17211583f, 0.39034066f, 0.05420149f, -0.01615053f, 0.27120268f, -0.01792368f, 
    0.11794845f, 0.03716117f, -0.36609322f, 0.23537830f, -0.29167593f, 0.00218689f, -0.17056237f, 0.51417136f, 
    0.01709172f, -0.09622211f, -0.12212769f, 0.11123551f, 0.19853003f, -0.03802248f, -0.13637075f, -0.09540857f, 
    0.10740509f, 0.16226928f, 0.01549152f, 0.29062626f, -0.34934136f, 0.00873145f, -0.39584559f, 0.10156675f, 
    -0.07785467f, 0.14933293f, 0.00883858f, 0.57682079f, 0.28744283f, 0.18045612f, -0.05517335f, 0.32855386f, 
    -0.03506602f, 0.69723409f, -0.08300942f, -0.08117685f, 0.02589469f, 0.04308884f, -0.11245343f, 0.03935301f, 
    -0.26758927f, -0.31904262f, 0.00116469f, 0.16315295f, 0.00966097f, 0.23012079f, 0.21820825f, 0.18599522f, 
    -0.00983286f, 0.03521626f, -0.19236478f, 0.14718659f, 0.15520142f, 0.00794976f, 0.19202295f, -0.28677785f, 
    -0.14695756f, 0.18642110f, 0.18194607f, 0.05405088f, 0.20340060f, -0.07849927f, -0.12394010f, -0.08458276f, 
    0.07698804f, -0.03754527f, 0.01908130f, -0.17190358f, 0.23639092f, -0.21362284f, 0.19508557f, -0.18439238f, 
    0.13157240f, -0.21172071f, -0.86845607f, 0.06458793f, 0.22537260f, -0.01098998f, 0.01127365f, 0.14297581f, 
    0.14210485f, 0.10286225f, -0.06386976f, -0.75777835f, 0.20899858f, -0.09076066f, 0.26854977f, -0.48008662f, 
    0.29445556f, 0.02169667f, -0.10117451f, -0.19441268f, 0.03760512f, -0.15784405f, 0.08347628f, -0.11768994f, 
    0.01938890f, -0.46947855f, 0.09734376f, 0.08344426f, 0.16133359f, 0.04414590f, 0.02143309f, 0.13683729f, 
    -0.12390997f, -0.30550173f, 0.09405445f, 0.21335651f, 0.20210442f, -0.01439697f, 0.21858183f, 0.05706177f, 
    -0.47600928f, 0.08413972f, -0.00969956f, -0.02452946f, 0.09610736f, 0.04309102f, -0.05628351f, -0.39931616f, 
    0.21310648f, -0.08414531f, -0.25993028f, -0.31494015f, -0.14277837f, -0.00693014f, -0.12717323f, -0.38493201f, 
    0.01007792f, 0.13517992f, 0.20524761f, -0.26570463f, 0.16016111f, 0.14148054f, 0.31253669f, -0.62479037f, 
    -0.29855046f, -0.12914219f, 0.06859621f, 0.00267620f, -0.21643972f, 0.00289411f, 0.15059228f, 0.10299475f, 
    0.24453270f, -0.38632381f, 0.10800047f, -0.09449037f, 0.13514960f, 0.11911025f, 0.25328356f, -0.14899629f, 
    -0.07419912f, -0.16909036f, -0.10747727f, 0.07050967f, -0.09535457f, 0.01182109f, 0.16057238f, -0.49365938f, 
    0.07058135f, 0.04197621f, 0.08019989f, 0.05358566f, 0.03874549f, -0.09823082f, 0.04512341f, 0.20620206f, 
    -0.03943094f, 0.02933045f, -0.10782134f, 0.05692701f, 0.14054441f, -0.27724540f, -0.34738797f, 0.01342860f, 
    -0.16703522f, 0.21627519f, -0.55325019f, 0.05982104f, 0.56227976f, 0.25282729f, 0.07382949f, 0.39778915f, 
    -0.08174451f, 0.24317917f, 0.06418130f, 0.14837877f, 0.04991867f, 0.09106379f, -0.20458254f, 0.11080505f, 
    -0.04845835f, -0.45559648f, 0.22945894f, -0.34332386f, 0.02368768f, 0.15561837f, 0.06657548f, -0.01791674f, 
    -0.15680203f, 0.05655241f, 0.08925947f, 0.10983273f, -0.14617364f, -0.08506464f, -0.06282099f, -0.08430676f, 
    0.18796442f, -0.19801457f, 0.11477078f, -0.26355597f, 0.01349581f, 0.09101500f, 0.05960815f, -0.25334355f, 
    -0.01686892f, -0.18890990f, -0.15342541f, -0.05538646f, -0.26597416f, -0.42275393f, 0.10292076f, 0.27806306f, 
    0.00141880f, -0.01822196f, -0.06833462f, 0.06991526f, 0.02990436f, -0.08540565f, -0.21440104f, -0.11941937f, 
    0.04694553f, 0.04375173f, -0.03449244f, -0.10308020f, -0.24228509f, 0.05453689f, 0.15201028f, 0.27531016f, 
    0.39300615f, 0.18726918f, 0.13020962f, -0.11388566f, -0.01330528f, -0.13249311f, 0.05662289f, -0.28916147f, 
    -0.18641111f, -0.17866129f, 0.21435528f, 0.19794552f, 0.18251337f, -0.24946545f, -0.30557212f, 0.06824876f, 
    0.12374181f, 0.00591513f, 0.09441191f, 0.25428045f, 0.09779245f, -0.01665628f, -0.08516034f, 0.06192989f, 
    0.08502554f, -0.01937448f, -0.08709861f, 0.22371432f, 0.00680029f, 0.03422357f, 0.14518195f, -0.00216131f, 
    0.14367907f, 0.16039138f, 0.08129078f, 0.03253479f, -0.27985758f, 0.06510708f, 0.10336726f, -0.11572502f, 
    0.12300412f, -0.09167675f, -0.02259880f, 0.18877220f, -0.25388616f, 0.04827996f, 0.20390323f, -0.38456944f, 
    -0.05394536f, -0.05601999f, 0.02179098f, 0.04676614f, -0.08142769f, 0.07652558f, 0.07846967f, -0.22691140f, 
    -0.07015055f, 0.18666168f, -0.24551398f, -0.07245222f, -0.22401920f, 0.10508336f, -0.12591316f, 0.13279513f, 
    0.08865179f, 0.04583496f, -0.09532192f, -0.11628987f, -0.12791783f, -0.13220476f, 0.21008711f, -0.10051974f, 
    -0.06295847f, -0.14154789f, 0.12542246f, 0.09135464f, 0.25220856f, -0.00179964f, 0.04731090f, -0.10519105f, 
    0.06657486f, 0.12932770f, -0.15778656f, 0.32439765f, 0.06943592f, 0.13299105f, -0.12361496f, 0.28447911f, 
    0.30944258f, -0.26381609f, -0.26087576f, 0.26225927f, -0.11425020f, 0.17305525f, 0.18625127f, -0.16635673f, 
    0.21377231f, 0.27089065f, -0.02928754f, -0.09134228f, -0.28756425f, 0.04462533f, -0.39698720f, 0.22181287f, 
    0.09726182f, -0.03753926f, 0.00578294f, 0.55993050f, 0.11485644f, 0.16773175f, -0.10355335f, 0.31441724f, 
    -0.03374126f, 0.31975350f, -0.03400907f, -0.03352126f, 0.01889554f, -0.10933453f, -0.02548725f, -0.04068452f, 
    0.20162755f, -0.39146504f, 0.16160202f, 0.10989470f, 0.26112470f, 0.15980117f, 0.05534104f, -0.03478723f, 
    -0.11094197f, 0.29998520f, -0.02521905f, 0.23442779f, -0.01146863f, 0.26476935f, 0.16487347f, 0.11099603f, 
    0.34270468f, 0.17823142f, 0.16062176f, 0.11286965f, 0.00849499f, -0.07193674f, -0.15714221f, -0.20887560f, 
    -0.32806954f, -0.00228421f, 0.07081062f, 0.14199173f, -0.20426914f, -0.17921016f, 0.06739794f, 0.01718772f, 
    -0.37804878f, -0.08145545f, 0.10745439f, 0.30387425f, 0.14257477f, -0.11061648f, 0.11498279f, 0.03439847f, 
    -0.04004759f, -0.25952035f, -0.07229069f, -0.18246572f, -0.23412614f, 0.19973987f, 0.29359803f, -0.24562173f, 
    0.18707258f, -0.22524036f, -0.04665257f, -0.19762082f, 0.16299778f, 0.12232194f, 0.27292261f, -0.07085752f, 
    -0.04819973f, 0.15220143f, 0.03066865f, 0.04671992f, -0.02547071f, -0.02980155f, -0.39562455f, 0.03144842f, 
    -0.11992666f, -0.17797941f, 0.10499352f, 0.11084519f, -0.03591697f, 0.35315174f, 0.02968226f, 0.03359197f, 
    -0.02570657f, 0.29808921f, 0.11184417f, 0.25715169f, -0.07599054f, 0.13831222f, 0.34011823f, -0.18054564f, 
    0.26589358f, -0.10520408f, 0.18215884f, -0.03350973f, 0.01409809f, -0.09745219f, -0.33918604f, -0.13820252f, 
    -0.07664149f, -0.11531515f, 0.10966434f, -0.20639613f, -0.05305238f, 0.20100082f, 0.12315544f, -0.20321473f, 
    0.04089802f, -0.18288921f, -0.20406044f, 0.52118254f, -0.01952477f, 0.08194835f, 0.05170484f, 0.00050181f, 
    0.19200841f, -0.02601625f, 0.05317527f, 0.03979655f, -0.25360754f, -0.08082306f, 0.02861056f, 0.07001925f, 
    0.16886874f, 0.05804395f, -0.09196850f, 0.22730280f, -0.19330318f, -0.00829830f, 0.09196460f, 0.01208250f, 
    0.02606008f, 0.05642303f, -0.00409561f, 0.00229055f, 0.01069648f, 0.07386085f, -0.00547711f, -0.00989442f, 
    -0.20278800f, 0.18182099f, -0.27341616f, 0.12953946f, 0.11781372f, -0.21194865f, -0.41907316f, 0.02330057f, 
    -0.02313280f, 0.12587714f, 0.05292987f, 0.15833525f, -0.35172558f, 0.14164430f, 0.07922506f, 0.53981030f, 
    0.09753249f, -0.12323037f, 0.01500523f, 0.09693149f, 0.15538776f, 0.05473074f, -0.29063660f, 0.43073922f, 
    -0.02960080f, -0.21892539f, 0.20765209f, -0.09282418f, -0.27098486f, -0.15957205f, 0.03748352f, -0.38788396f, 
    -0.49186134f, 0.01562177f, -0.00449469f, 0.00885332f, -0.16930763f, -0.25114414f, 0.12243786f, -0.49418217f, 
    0.08015146f, -0.03116716f, 0.09724393f, 0.41762555f, -0.12037640f, 0.02911183f, -0.17760703f, 0.13211650f, 
    -0.09703509f, -0.40877250f, -0.00955113f, 0.16680260f, -0.26296049f, -0.28555822f, -0.06871602f, 0.07793035f, 
    -0.02965757f, 0.25378215f, 0.04906284f, -0.08111338f, 0.00661938f, -0.12495402f, -0.10473965f, -0.44255713f, 
    0.05905897f, -0.01026881f, 0.11451925f, -0.12427513f, 0.06004079f, -0.00963935f, 0.00590052f, -0.15641591f, 
    0.31855780f, -0.09368001f, 0.10343307f, 0.00415220f, -0.09607530f, -0.26013398f, -0.38043010f, -0.13469689f, 
    0.28063017f, -0.01952253f, -0.00599233f, -0.08969465f, -0.14877445f, 0.06088118f, 0.52085739f, -0.31459418f, 
    -0.00706483f, 0.10141408f, -0.37268376f, 0.31378248f, -0.16996191f, -0.12123513f, -0.01535804f, 0.43578035f, 
    0.02170264f, 0.04327957f, -0.01143056f, -0.23363321f, 0.29451385f, -0.00631671f, 0.04161414f, 0.15538017f, 
    0.07006313f, 0.13404547f, -0.11273627f, 0.15889409f, 0.13136449f, -0.07172847f, -0.14888209f, -0.02492829f, 
    -0.08073186f, 0.12416229f, -0.04488900f, 0.13623744f, 0.31357136f, 0.12451577f, 0.04627001f, -0.13438226f, 
    -0.00601962f, 0.17579596f, 0.01268439f, 0.04142806f, 0.10106108f, 0.02523241f, -0.02515209f, 0.16187783f, 
    -0.11354246f, -0.04633346f, -0.24402435f, -0.04704488f, -0.10897826f, -0.06771362f, -0.28964338f, 0.03962300f, 
    0.25536597f, 0.18403150f, 0.10487953f, -0.07229069f, -0.00093950f, 0.07674227f, 0.24824505f, 0.50538945f, 
    0.22200806f, -0.07532610f, -0.08221810f, 0.25638795f, 0.28434250f, -0.01705106f, -0.03009472f, -0.21792497f, 
    0.06101606f, 0.00166117f, 0.04706078f, -0.03882240f, 0.05050104f, 0.28261095f, -0.01670626f, -0.06893668f, 
    -0.03954965f, 0.01201412f, -0.22214308f, 0.20506485f, -0.18005246f, 0.07191652f, 0.07287371f, -0.13699147f, 
    0.29780319f, -0.11067569f, 0.10589977f, 0.27530956f, -0.28913516f, 0.00427152f, -0.31703830f, 0.27888355f, 
    -0.07996717f, -0.13131425f, 0.02712134f, 0.20066638f, -0.29187104f, 0.09316757f, 0.19325358f, 0.10224020f, 
    0.11264813f, 0.27024934f, 0.10137065f, 0.12405106f, -0.04329964f, -0.02842596f, -0.09650436f, -0.23755483f, 
    -0.15458544f, 0.01242363f, 0.18174490f, -0.08832818f, 0.01446319f, 0.04836809f, -0.09953392f, 0.14640045f, 
    0.08683255f, -0.16874899f, 0.31427872f, -0.21959545f, -0.23882590f, -0.13398860f, -0.07818197f, -0.10817415f, 
    0.23251167f, -0.01617162f, 0.02780091f, 0.06854142f, 0.13694111f, -0.19351929f, 0.38179532f, -0.36946842f, 
    0.03849708f, 0.30807090f, -0.22235562f, 0.18744373f, 0.04533485f, 0.20827930f, -0.11817369f, 0.17683345f, 
    0.35342726f, -0.36112070f, -0.06990115f, 0.12914160f, -0.23528945f, 0.20140669f, 0.09847490f, 0.03015701f, 
    0.22894637f, 0.24464244f, -0.06879295f, 0.19536276f, -0.17829657f, -0.04122285f, -0.22312665f, 0.40808445f, 
    0.05585794f, 0.00715069f, -0.00988643f, 0.72906208f, 0.13199471f, 0.30991435f, 0.15482825f, -0.00045853f, 
    -0.00992497f, 0.27109292f, -0.17155473f, -0.03921836f, 0.09322798f, 0.00558668f, -0.11810075f, 0.17444214f, 
    -0.06646566f, 0.07930355f, -0.20717777f, -0.06591602f, 0.11955701f, -0.08581743f, 0.28269514f, 0.08244354f, 
    -0.26972073f, -0.20853223f, 0.18012331f, 0.40815982f, 0.05042022f, -0.07551108f, -0.14373650f, -0.10318191f, 
    -0.05004505f, 0.32336855f, -0.19644324f, -0.32799771f, -0.23457003f, -0.05405905f, -0.11348262f, 0.34283572f, 
    0.12380958f, -0.03522258f, -0.11325148f, -0.06971303f, 0.26547089f, -0.11108344f, -0.12055933f, -0.09963086f, 
    0.09145187f, -0.02018860f, -0.28093496f, 0.10962623f, -0.16230133f, 0.05205271f, 0.06199051f, 0.14595212f, 
    -0.02000799f, 0.05539687f, 0.07073036f, 0.14153701f, 0.18759966f, -0.01249060f, -0.29731399f, 0.03805074f, 
    0.33066559f, 0.22011748f, 0.03718276f, 0.05740847f, 0.09105099f, -0.07195944f, -0.13200372f, 0.31317028f, 
    0.04380323f, -0.02987728f, 0.15265259f, 0.04240795f, 0.07832769f, -0.12519348f, 0.19827281f, 0.08558899f, 
    -0.00636371f, -0.06272738f, 0.15248264f, 0.26095656f, 0.13771571f, 0.00989815f, 0.20088175f, -0.06300271f, 
    -0.25544491f, -0.08945116f, 0.10701574f, 0.30510169f, 0.26951689f, 0.10809479f, 0.02647487f, 0.12519594f, 
    0.19589514f, 0.11772249f, 0.18534103f, -0.12528637f, -0.13148840f, 0.16139764f, 0.19943291f, 0.28551701f, 
    -0.13067551f, -0.04265079f, 0.16637130f, -0.18933879f, 0.19840942f, -0.05453203f, 0.34539932f, -0.10810310f, 
    0.13346832f, -0.08796238f, -0.03624360f, 0.12945597f, 0.10846450f, 0.14714526f, 0.11582777f, 0.22501755f, 
    0.20423573f, 0.19370490f, 0.01948101f, -0.29381546f, 0.30939689f, -0.03951126f, 0.29990509f, -0.24680746f, 
    0.31760815f, -0.04952838f, 0.05459786f, -0.17225780f, 0.39893585f, 0.12599608f, 0.23813701f, -0.00316231f, 
    -0.08914673f, -0.03079629f, 0.03003046f, 0.09992570f, -0.05282312f, -0.13445781f, -0.00794498f, 0.39697701f, 
    0.13588099f, -0.04238458f, 0.24122897f, 0.16892762f, 0.08970482f, 0.40812281f, 0.05660087f, 0.24938978f, 
    -0.12159913f, -0.01436544f, 0.32700247f, 0.30499971f, -0.05232024f, -0.13628714f, 0.10968494f, -0.45682481f, 
    -0.03700680f, -0.02950692f, 0.22697838f, -0.00256922f, 0.01107240f, -0.22303933f, 0.08544553f, -0.04987631f, 
    0.11239868f, 0.05109716f, -0.22936800f, 0.10089593f, 0.03408282f, 0.00566635f, 0.38788509f, -0.06934556f, 
    0.04930933f, -0.12953338f, -0.21548498f, 0.00275310f, 0.17671685f, -0.04063777f, -0.05794014f, 0.02016033f, 
    -0.00789944f, 0.07251293f, 0.03955040f, 0.05362068f, 0.50126415f, -0.07574283f, -0.01426250f, -0.22329307f, 
    0.36092198f, 0.03035258f, -0.02746694f, -0.13367194f, 0.03697095f, -0.00652528f, 0.14089930f, -0.47452554f, 
    -0.06469133f, -0.24802652f, 0.12318939f, 0.05397545f, -0.06618716f, 0.02335826f, -0.02116025f, 0.19664729f, 
    0.22989368f, -0.03512968f, 0.10771488f, 0.15237294f, -0.18827982f, 0.12696624f, 0.20823255f, 0.27129808f, 
    -0.26645124f, 0.10022533f, 0.06508540f, 0.29754069f, 0.24713063f, 0.07682895f, 0.03565087f, 0.27958992f, 
    -0.05997753f, 0.05431278f, -0.04200413f, -0.07143429f, -0.05355361f, 0.04534803f, 0.02711242f, 0.54349470f, 
    0.07627656f, -0.04642513f, 0.17829938f, -0.19120827f, 0.11060243f, -0.15427382f, 0.18299499f, -0.27318597f, 
    0.11052329f, 0.17504962f, -0.02122006f, 0.01005724f, -0.14524077f, 0.00125592f, -0.06950581f, -0.02822060f, 
    -0.08374708f, 0.32057232f, 0.10263012f, 0.24876614f, 0.16637573f, -0.06027306f, 0.17703523f, -0.19565603f, 
    0.33321315f, 0.21599190f, -0.08506296f, -0.25215027f, 0.06116461f, -0.12041909f, 0.01290223f, -0.06339829f, 
    0.05654924f, -0.41127071f, -0.00968359f, -0.06572614f, -0.10187365f, 0.01370666f, 0.19760831f, -0.15678985f, 
    0.22608998f, 0.13376521f, 0.05234013f, 0.02441265f, -0.12264566f, 0.02075868f, -0.11662295f, 0.16475749f, 
    0.41064137f, -0.00286732f, 0.06891742f, -0.20845948f, -0.20946854f, -0.07653044f, -0.03001058f, -0.05842159f, 
    -0.07048202f, -0.19196521f, 0.12029344f, 0.02563383f, 0.23991567f, -0.29027674f, 0.01789752f, -0.21247157f, 
    0.34874928f, 0.17053379f, -0.02335722f, 0.42120394f, 0.00394841f, 0.15181528f, -0.16955970f, 0.22548091f, 
    0.21920151f, 0.06316911f, -0.03801921f, 0.07851344f, 0.07401264f, 0.07606991f, -0.02504873f, -0.04446917f, 
    0.09993351f, 0.03152914f, -0.08956130f, -0.05945666f, -0.33897036f, 0.03822901f, -0.16481580f, 0.14885810f, 
    -0.05860125f, -0.09581790f, -0.09228980f, 0.55375713f, -0.11151218f, 0.25552547f, 0.07535677f, -0.00310997f, 
    -0.04293124f, 0.40394253f, 0.00799490f, -0.04639606f, 0.12913059f, -0.02756224f, 0.08163165f, -0.09288265f, 
    -0.11068816f, 0.03432458f, 0.05439223f, 0.01567864f, -0.13595611f, 0.07315658f, 0.04255829f, 0.21330373f, 
    0.09511079f, -0.03481745f, 0.18379253f, 0.17970876f, 0.10664770f, 0.09979200f, -0.07614585f, 0.09648699f, 
    -0.18751207f, -0.04479348f, 0.21646518f, 0.06154289f, 0.12145238f, 0.02095642f, 0.41091025f, 0.15064564f, 
    0.11945841f, 0.09005605f, 0.02778792f, 0.07010475f, -0.05385368f, 0.13175729f, 0.24376854f, -0.00425980f, 
    -0.17064726f, 0.05715485f, 0.00583513f, -0.24969076f, 0.28820765f, -0.10837068f, -0.04087726f, 0.06925665f, 
    -0.12129908f, -0.06133489f, 0.11363418f, 0.01217080f, 0.15017384f, 0.16450776f, 0.00419170f, -0.08712292f, 
    0.22732125f, -0.16600783f, 0.06897556f, -0.19500087f, -0.08199840f, -0.07405781f, -0.02127583f, -0.41872063f, 
    0.07906976f, -0.01083111f, 0.04502949f, 0.12648299f, -0.07284860f, 0.08066291f, 0.08643039f, -0.14442654f, 
    0.13457406f, -0.19582848f, 0.06469644f, -0.05641585f, 0.00749451f, 0.15513556f, 0.13893923f, -0.04710921f, 
    0.14228834f, -0.14731485f, -0.02563324f, -0.08127325f, -0.23573956f, -0.01075309f, 0.05130361f, -0.38492045f, 
    0.23714083f, 0.01167658f, 0.07322544f, 0.04469999f, -0.04928081f, 0.09098328f, -0.03414769f, -0.14926417f, 
    0.04834498f, 0.18526973f, -0.18463373f, -0.07764443f, 0.12213226f, -0.05469336f, -0.09433137f, 0.35925251f, 
    0.25925335f, -0.15306623f, 0.07238946f, 0.16920587f, -0.01955291f, 0.11518212f, 0.11555101f, 0.08865225f, 
    0.19203433f, 0.26758289f, -0.01813535f, -0.11555003f, -0.12402157f, 0.05667785f, -0.10209252f, 0.12601456f, 
    -0.02296276f, 0.02754787f, 0.04026829f, 0.32562283f, 0.28794694f, 0.41139248f, 0.02424802f, 0.02002290f, 
    0.01108718f, 0.21522953f, -0.06594351f, -0.06734267f, 0.06084092f, -0.11051733f, -0.01871579f, 0.09777223f, 
    0.12236264f, 0.07706419f, 0.03201438f, 0.00727905f, -0.04017258f, 0.18380976f, 0.14422369f, 0.23471935f, 
    0.35427022f, 0.04423897f, 0.08910125f, 0.20511568f, 0.10768744f, -0.20019054f, -0.09417454f, -0.31332049f, 
    -0.12741038f, 0.14870566f, 0.05332544f, 0.23606776f, 0.01723710f, -0.11663599f, 0.04223620f, 0.12891921f, 
    0.13796028f, 0.16612969f, -0.13489529f, 0.17827441f, -0.02906282f, -0.30529162f, -0.11005715f, 0.11588452f, 
    0.14920750f, 0.09194210f, 0.00909768f, -0.01646411f, 0.22632189f, 0.00182784f, -0.11513096f, 0.08842879f, 
    -0.17205516f, 0.12495106f, -0.09370613f, -0.07354321f, -0.14120610f, 0.01845415f, 0.09244178f, 0.02726634f, 
    0.13788018f, 0.15842719f, -0.02438256f, 0.03387750f, 0.03811521f, 0.01119122f, -0.09543978f, -0.24791187f, 
    -0.09708784f, -0.19353285f, 0.19399486f, 0.11568394f, 0.12752609f, 0.14509688f, 0.04852240f, 0.08261919f, 
    0.05749337f, 0.14690797f, -0.23968409f, -0.02117993f, -0.08318319f, 0.01003745f, 0.10335223f, 0.01468133f, 
    -0.25897205f, -0.41826934f, 0.02392203f, 0.37949327f, 0.19114865f, -0.00672068f, -0.13854627f, 0.13435894f, 
    -0.03845526f, 0.12024662f, -0.25757411f, -0.02737656f, -0.25757936f, 0.12451581f, -0.23989320f, 0.44317001f, 
    0.01831875f, 0.06894705f, -0.02811825f, -0.08405373f, 0.22502145f, -0.07990408f, -0.37117526f, 0.00401577f, 
    0.20073228f, 0.20498449f, 0.14238815f, 0.17369802f, -0.39757279f, -0.03266223f, 0.16203947f, 0.11421958f, 
    -0.12752384f, -0.00228205f, -0.05002298f, 0.20238876f, 0.48343790f, 0.10018328f, -0.16921793f, 0.07478863f, 
    -0.09959245f, -0.00868700f, -0.03997009f, -0.05000265f, 0.08873414f, -0.02620926f, 0.03785709f, 0.27523786f, 
    -0.05905887f, 0.06806832f, 0.12402380f, 0.01460094f, 0.05329045f, -0.05261786f, 0.25978276f, -0.03877223f, 
    -0.03627225f, 0.10214604f, -0.15271638f, -0.16851003f, 0.07245293f, -0.51486832f, 0.11360250f, 0.08174903f, 
    0.43328351f, 0.15764713f, 0.15262261f, -0.10862177f, 0.19702217f, 0.19771820f, -0.43331626f, -0.79441082f, 
    -0.16892536f, 0.02866243f, -0.52505881f, -0.29668331f, 0.15944435f, -0.12643971f, 0.37248552f, -0.05865380f, 
    0.15747167f, 0.04760296f, -0.05345652f, 0.41166735f, 0.11924087f, 0.00373007f, -0.32586798f, 0.08683436f, 
    -0.01975614f, 0.02879370f, -0.22383101f, -0.43170789f, 0.08936922f, 0.00952622f, -0.11913872f, 0.11837817f, 
    -0.17162289f, 0.05772954f, -0.11995533f, 0.32550839f, 0.12217099f, 0.00938508f, -0.45707539f, 0.02684516f, 
    -0.31905642f, 0.03508601f, -0.08830614f, -0.09859893f, -0.04328995f, 0.09676439f, -0.17069128f, -0.40503469f, 
    0.06049758f, 0.08209337f, 0.07145142f, -0.07617413f, 0.01205416f, 0.00092026f, 0.19745065f, -0.12171701f, 
    -0.22547998f, 0.16291338f, 0.08198943f, 0.03467386f, 0.19970861f, -0.28052434f, -0.00204345f, -0.11825249f, 
    0.03825634f, 0.28792399f, -0.34066251f, -0.26406330f, -0.16752276f, 0.16473970f, 0.06752615f, -0.13341714f, 
    -0.17828503f, -0.00752387f, -0.15320823f, -0.07040258f, 0.10537651f, 0.06336956f, -0.10958000f, -0.26261023f, 
    0.17512465f, -0.09164974f, 0.16030772f, -0.14541799f, 0.19547150f, 0.23690993f, 0.16290349f, -0.02355946f, 
    -0.12697421f, -0.02549624f, 0.00887601f, -0.08704732f, -0.01297351f, 0.20419160f, -0.07679665f, 0.09808546f, 
    0.28069162f, -0.39727679f, -0.12750985f, -0.13106129f, -0.08514149f, -0.06698003f, 0.05979878f, 0.19599435f, 
    -0.31724530f, 0.08004153f, 0.01421746f, -0.11290669f, -0.34098595f, 0.17291810f, -0.04523043f, 0.33106044f, 
    0.03935384f, 0.01080047f, -0.07389383f, 0.03608805f, 0.11631334f, 0.00192759f, 0.19826572f, 0.13938537f, 
    -0.16913174f, 0.05654985f, 0.12110148f, 0.13821161f, 0.07826788f, 0.17089443f, 0.23915021f, 0.15404022f, 
    -0.08243036f, 0.23046874f, -0.17482258f, 0.10612006f, 0.01895922f, 0.00325901f, 0.20943464f, -0.31702369f, 
    -0.12639788f, 0.11251055f, 0.11440442f, -0.08415035f, 0.04534036f, -0.00873896f, -0.21706787f, -0.00934043f, 
    0.06939128f, -0.06166270f, 0.04234241f, -0.25364286f, 0.22293490f, 0.12815876f, 0.24569561f, -0.39782605f, 
    0.11127190f, -0.06411878f, -0.43865040f, 0.13232560f, -0.03849500f, 0.13651285f, 0.04114504f, 0.12464920f, 
    -0.00362819f, -0.20246518f, 0.00645672f, -0.30153584f, 0.26506639f, -0.09807282f, 0.00830603f, -0.04575667f, 
    0.18950093f, 0.12101632f, -0.03369947f, -0.16653354f, -0.16065989f, -0.05327847f, 0.06664877f, -0.24260594f, 
    -0.03401396f, -0.25188208f, 0.12863415f, -0.10276010f, 0.04304162f, 0.02130686f, 0.18381290f, 0.04294108f, 
    -0.33931863f, 0.08317000f, 0.17024222f, 0.08197575f, 0.17446469f, 0.24157123f, 0.07914052f, 0.01425129f, 
    0.26302722f, 0.24351387f, 0.21072556f, 0.05273508f, -0.06200026f, -0.34265339f, 0.08280475f, -0.60778952f, 
    0.08911901f, -0.14825189f, 0.11194927f, 0.16299629f, 0.21301171f, 0.00044275f, -0.11392982f, -0.26804835f, 
    0.19477254f, 0.08770040f, -0.25431862f, 0.12431876f, 0.05320365f, 0.22989845f, 0.06424922f, -0.08669349f, 
    0.05026678f, 0.05244089f, -0.19072013f, 0.00712462f, 0.30492374f, 0.06936608f, -0.13728081f, 0.32307822f, 
    0.08893025f, -0.11208680f, 0.02324310f, -0.14638808f, 0.02476811f, 0.06654536f, -0.09858305f, -0.07377105f, 
    -0.04903843f, 0.17424257f, 0.02330726f, -0.08240406f, -0.28193280f, 0.07299093f, -0.06533217f, -0.32089049f, 
    0.09845482f, -0.14154424f, 0.10745855f, -0.08845285f, -0.04645038f, -0.12810351f, -0.14037117f, -0.01042944f, 
    0.18019277f, 0.07465972f, -0.18466279f, -0.03085218f, -0.06639712f, -0.08847114f, 0.06373671f, -0.01432184f, 
    -0.22028650f, -0.27558041f, 0.10306599f, 0.08570710f, 0.18227138f, 0.12937169f, -0.01537779f, 0.13098453f, 
    0.15625340f, 0.19627470f, 0.09216406f, -0.14013112f, -0.04257232f, -0.11317767f, 0.09753040f, 0.08468600f, 
    0.07676671f, -0.01521248f, -0.12423021f, 0.00809521f, 0.11788958f, -0.16209956f, -0.12951753f, 0.06184058f, 
    0.25637215f, 0.00974967f, 0.11469913f, 0.01769094f, -0.22417663f, -0.03024497f, 0.14114049f, 0.09900800f, 
    -0.03819153f, 0.36031237f, 0.03791125f, 0.37936476f, 0.52394301f, 0.04961517f, -0.22035101f, 0.17309888f, 
    0.00455458f, 0.05130721f, 0.06517013f, 0.13352594f, 0.45030090f, 0.21778508f, -0.14007844f, 0.42072022f, 
    -0.05449391f, 0.13395357f, 0.08277573f, -0.00948203f, 0.00970137f, 0.15903448f, 0.18484955f, 0.00950166f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.07811345f, 0.01951045f, 0.01722309f, -0.00733275f, -0.13560031f, -0.03827415f, 0.14364569f, -0.05457167f, 
    0.28724098f, 0.17174160f, 0.07870128f, -0.03966219f, -0.10791664f, 0.02248230f, -0.10092583f, 0.03094796f, 
    -0.03863145f, 0.12634824f, -0.10941930f, -0.10150992f, 0.10267565f, -0.04039347f, 0.11307947f, 0.15833688f, 
    0.14591990f, -0.06106494f, 0.12684014f, 0.29469833f, 0.17334588f, -0.09369778f, -0.09035011f, -0.04941728f, 
    0.21696423f, -0.16975622f, -0.06622159f, 0.32420719f, -0.10586031f, -0.02552377f, 0.02710214f, -0.05151305f, 
    -0.04799560f, -0.20437202f, 0.07665682f, 0.01996483f, -0.00065961f, -0.01382927f, -0.21455415f, 0.20916717f, 
    0.14104092f, 0.11976768f, -0.05358680f, 0.20506078f, 0.11998627f, -0.04636792f, -0.05429901f, 0.26626229f, 
    -0.14416106f, 0.19292346f, 0.02898521f, 0.12528352f, 0.17533953f, 0.18981633f, 0.33244985f, 0.01466386f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.03659644f, -0.08419471f, -0.08099350f, -0.02357268f, -0.06087834f, -0.19670029f, -0.39464822f, -0.14801922f, 
    -0.03545990f, -0.19593276f, -0.22576214f, 0.22728856f, -0.11685268f, -0.60959244f, 0.03266796f, -0.33795893f, 
    -0.09511733f, 0.01315499f, -0.01525696f, 0.11577382f, -0.16206038f, 0.22391850f, -0.13154294f, -0.23947470f, 
    0.11233379f, 0.10290059f, 0.01315867f, 0.12035841f, -0.10143955f, 0.06560248f, 0.01771792f, -0.11172494f, 
    -0.10453756f, -0.04292998f, -0.07207579f, 0.01837081f, 0.21487561f, -0.16839078f, -0.25765869f, -0.00867035f, 
    -0.07705139f, 0.35656795f, -0.06402159f, -0.38332665f, 0.15571718f, 0.02592826f, 0.33663884f, -0.07523266f, 
    0.16098237f, -0.54231149f, -0.15940323f, 0.11324956f, -0.08704124f, 0.18689929f, -0.38506311f, 0.02842825f, 
    -0.48176947f, -0.29082951f, -0.42795289f, 0.06686498f, 0.10941916f, -0.07206134f, -0.35519540f, -0.57493484f, 
    -0.07658701f, -0.05970614f, -0.06021825f, 0.23973326f, -0.05903503f, -0.20846887f, -0.05027380f, -0.00883942f, 
    0.24837935f, 0.18275432f, 0.03230513f, -0.33285502f, -0.07044244f, -0.37175152f, 0.07268620f, 0.07693301f, 
    -0.22837995f, 0.15015069f, 0.01707570f, 0.16987528f, -0.14812508f, -0.60949123f, -0.26335081f, 0.16153766f, 
    0.13680914f, 0.00024317f, -0.03123080f, -0.06540947f, 0.14238483f, 0.13241878f, 0.05471305f, -0.02916347f, 
    0.10462841f, -0.00850706f, 0.09357753f, 0.19678311f, 0.15588103f, 0.20373903f, -0.83477408f, 0.20013562f, 
    -0.18926050f, -0.30980676f, -0.07339194f, -0.63458276f, 0.33334079f, 0.05511493f, -0.69599515f, -0.17028983f, 
    -0.22983901f, -0.37465993f, 0.22239818f, 0.09666025f, 0.15339494f, 0.12868854f, -0.31764084f, 0.19167298f, 
    -0.20380381f, 0.09414972f, 0.00053718f, 0.23204365f, -0.10541435f, 0.13168405f, 0.06245482f, -0.10886873f, 
    -0.18035221f, 0.08824697f, 0.16689812f, -0.14567792f, 0.02184704f, -0.15630533f, 0.05838493f, -0.55433452f, 
    -0.47137263f, 0.05868120f, -0.06026961f, 0.08670615f, -0.37785092f, 0.39630017f, 0.19637220f, 0.18963762f, 
    0.21084289f, 0.07648496f, -0.30944127f, -0.09766153f, 0.20930389f, -0.49635136f, -0.04839210f, 0.08294357f, 
    0.03666625f, -0.62279654f, 0.15767249f, 0.23509683f, -0.30907527f, -0.42096087f, 0.04548833f, -0.09389035f, 
    -0.26694292f, -0.40555352f, 0.27329543f, 0.24028255f, -0.68639904f, -0.25214973f, 0.20954505f, -0.34376821f, 
    0.05350453f, -0.00130447f, 0.15658145f, 0.26037684f, -0.34574211f, -0.05187070f, -0.54072803f, 0.12383357f, 
    0.10554428f, 0.05962598f, -0.46743155f, -0.20022927f, 0.15058397f, -0.16269727f, 0.16233478f, 0.17051509f, 
    0.01342800f, 0.01197444f, 0.07072802f, -0.67281723f, -0.04679833f, -0.14176230f, 0.12995969f, -0.67737234f, 
    0.31617266f, 0.06768366f, -0.11643953f, 0.14264216f, -0.10023800f, -0.06590056f, -0.20015113f, -0.44743198f, 
    -0.35359141f, -0.22336343f, 0.34605530f, 0.14331461f, -0.40912682f, 0.10750061f, -0.82373065f, 0.06595154f, 
    -0.02146094f, -0.03207649f, -0.10468277f, 0.01279577f, 0.15403995f, 0.17840795f, 0.03983521f, 0.32669750f, 
    0.04113718f, -0.02943200f, 0.01876592f, 0.19021732f, -0.13269527f, -0.12382461f, -0.09802963f, -0.13548978f, 
    -0.71753293f, -0.04458215f, -0.41901314f, -1.06755197f, -0.05280233f, -0.36414847f, 0.07942231f, 0.04503083f, 
    0.33228490f, 0.09301378f, -0.04294647f, 0.22372222f, 0.06167814f, 0.06769492f, -0.40534616f, 0.00480778f, 
    0.09013849f, 0.10291396f, -0.14448132f, 0.16391982f, -0.00763672f, -0.17842096f, 0.07949903f, -0.10354802f, 
    0.14667009f, -0.23425694f, -0.14809439f, -0.63235706f, 0.15995733f, -0.01041708f, -0.12084313f, -0.07628667f, 
    0.04078254f, -0.05414812f, 0.08038861f, -0.41906968f, 0.07437164f, -0.25353765f, -0.05881239f, 0.05002289f, 
    -0.36738956f, -0.03077279f, -0.08420400f, 0.12097653f, -0.03422174f, -0.06687475f, 0.06951899f, -0.35716602f, 
    -0.03857667f, -0.34671560f, 0.17880137f, 0.14521262f, -0.23155688f, 0.05164064f, -0.40566364f, -0.64075547f, 
    0.17961977f, 0.20489144f, 0.12774269f, 0.01965210f, -0.36543474f, 0.25376093f, -0.09077878f, 0.00732848f, 
    -0.00559457f, 0.18428291f, -0.11635779f, -0.04199763f, 0.03582484f, -0.37202817f, 0.25605670f, -0.32411918f, 
    0.02522449f, -0.04372838f, -0.07591140f, 0.09200488f, -0.14157917f, 0.06819085f, 0.21565618f, -0.35886928f, 
    0.18644996f, 0.05886257f, -0.13171043f, -0.07708326f, -0.05850605f, 0.01365719f, 0.00227685f, 0.04433477f, 
    -0.09536131f, -0.20061268f, -0.00490264f, -0.26188853f, -0.12241189f, -0.25002417f, -0.27346277f, 0.15782361f, 
    -0.10800701f, -0.03959606f, 0.14032678f, -0.19077663f, 0.03372744f, -0.08579415f, 0.08655355f, 0.14666589f, 
    -0.05723103f, -0.00731498f, -0.35141394f, -0.07748948f, 0.07075623f, 0.23866564f, -0.47291943f, -0.42859319f, 
    0.23954009f, 0.07261179f, 0.32322440f, 0.04210190f, -0.02055413f, -0.03841708f, -0.34323004f, -0.32625988f, 
    0.02456371f, 0.11059909f, 0.06128857f, -0.04800545f, -0.44441065f, -0.18569115f, 0.11773925f, -0.17570706f, 
    0.01904345f, 0.05145998f, 0.07425926f, -0.16349582f, -0.07497802f, 0.17350812f, -0.09321033f, 0.27759758f, 
    -0.42222860f, -0.21606700f, 0.19563602f, 0.01415981f, -0.09429628f, 0.02839975f, -0.12956509f, -0.16188693f, 
    -0.06657735f, -0.00536821f, 0.03016880f, 0.03046074f, 0.12674364f, 0.21837193f, 0.11059833f, 0.04886834f, 
    0.04997876f, 0.18113956f, 0.13808846f, -0.28438938f, -0.38017741f, 0.04070060f, -0.00921783f, -0.17384224f, 
    -0.46248224f, 0.09388206f, -0.19584489f, 0.00167643f, -0.01499762f, -0.28554234f, 0.06226617f, 0.06856193f, 
    0.14940193f, -0.51623487f, 0.13295215f, -0.36220610f, 0.26199067f, 0.18930650f, -0.28872719f, 0.18771005f, 
    -0.24471232f, 0.10577575f, -0.27766532f, -0.79167849f, 0.23500222f, -0.45723081f, -0.01311881f, 0.05903285f, 
    -0.68719476f, -0.76300955f, 0.06638914f, 0.16816308f, -0.36546269f, -0.06294886f, 0.00054696f, 0.14643921f, 
    0.04564577f, -0.65872395f, -0.05341185f, 0.29678878f, -0.19680977f, -0.11308031f, 0.17601328f, -0.27945095f, 
    0.03285036f, -0.18126057f, -0.07529537f, -0.02906098f, -0.31841120f, -0.67274904f, -0.05986686f, 0.19544664f, 
    -0.05498767f, 0.01896407f, -0.61124873f, -0.61674619f, -0.27114180f, -0.32238609f, 0.35261747f, 0.08986688f, 
    -0.06564709f, 0.18989988f, -0.52365118f, 0.32882690f, 0.20234931f, -0.32126495f, 0.06778779f, -0.42186078f, 
    0.43684524f, -0.04669844f, -0.17869166f, -0.00175633f, 0.10635724f, 0.29850549f, -0.36598957f, -0.11802150f, 
    0.06749859f, -0.12429991f, 0.23054491f, 0.09900728f, 0.16981195f, -0.23717389f, 0.06835914f, 0.07575793f, 
    -0.06043342f, -0.00254243f, -0.12220681f, -0.28426102f, 0.06482986f, 0.56267297f, 0.07521107f, 0.14793207f, 
    -0.22771460f, -0.04097480f, -0.22240070f, -0.46972093f, -0.05087778f, -0.14501169f, -0.01271983f, -0.14615649f, 
    0.01579547f, -0.41662568f, 0.16475427f, -0.28851658f, -0.06862503f, 0.07146899f, 0.15285778f, -0.29767114f, 
    0.02788994f, -0.16913694f, -0.67162412f, 0.04411512f, -0.14634390f, -0.62451196f, -0.16038395f, -0.05512823f, 
    -0.38053536f, -0.17526309f, -0.02821044f, 0.03029421f, -0.40648386f, -0.02117920f, -0.29190102f, -0.44018170f, 
    0.07612692f, 0.08710083f, 0.04699798f, -0.42271930f, 0.12909736f, -0.13460444f, -0.26764482f, 0.03103422f, 
    0.33343038f, -0.04488699f, 0.28331807f, -0.30021253f, -0.03799990f, 0.33751044f, 0.11081787f, -0.06671043f, 
    0.02110423f, 0.11350306f, -0.34508717f, -0.36007667f, -0.31926996f, -0.02194724f, -0.62708479f, -0.18126805f, 
    -0.08959358f, 0.22922543f, -0.04750242f, -0.44245553f, 0.05391936f, -0.05352126f, 0.02320567f, -0.11688910f, 
    -0.45933640f, -0.26530296f, -0.43358627f, -0.65920860f, -0.09021830f, -0.58395183f, -0.07212175f, -0.19215739f, 
    0.00153562f, -0.54165936f, -0.54361361f, -0.19401391f, -0.23533230f, 0.13633433f, -0.63967502f, -0.11271428f, 
    -0.03000741f, -0.49412555f, -0.25718868f, -0.17911129f, -0.70103806f, -0.07420838f, 0.02348933f, 0.17382962f, 
    -0.57769448f, 0.18335547f, 0.14936449f, 0.26298770f, 0.23364574f, 0.21737525f, -0.09073883f, 0.07292192f, 
    0.03656846f, 0.02014256f, -0.01118965f, -0.17603977f, -0.07371780f, 0.08918802f, -0.09315828f, 0.07368291f, 
    -0.01241539f, 0.04375346f, -0.34364775f, -0.20742613f, -0.05288643f, -0.54822969f, -0.22992273f, -0.02216359f, 
    0.21780390f, -0.35345358f, -0.02214542f, -0.03886547f, -0.03594113f, -0.26626199f, -0.33226418f, -0.01375582f, 
    0.10813222f, 0.27252704f, 0.03126717f, 0.06836095f, -0.02728415f, -0.21874714f, 0.02537761f, 0.09077370f, 
    0.25941557f, 0.09832374f, 0.16512996f, 0.27359951f, 0.32759693f, 0.07896858f, -0.00532555f, -0.05103037f, 
    0.19590347f, 0.05705762f, -0.05853929f, -0.15794443f, -0.14569663f, -0.56608957f, -0.09535641f, -0.37034345f, 
    -0.25127870f, -0.41723815f, 0.13145326f, 0.20712602f, -0.76268560f, 0.12356693f, -0.40352586f, -0.32299620f, 
    0.30116788f, 0.19423163f, -0.25272882f, -0.44878438f, -0.01333243f, -0.16978469f, 0.13191414f, -0.17946213f, 
    0.00064042f, -0.03956509f, -0.35379291f, -0.11936852f, 0.31178996f, 0.11233048f, 0.19114843f, -0.33492565f, 
    -0.32993901f, 0.07624269f, 0.18163952f, 0.22015391f, 0.09178005f, 0.13254865f, 0.17996305f, -0.36239505f, 
    -0.36616948f, 0.22041917f, -0.34348941f, -0.19427802f, 0.16857564f, -0.02145841f, -0.77260607f, -0.01106390f, 
    -0.11528768f, -0.38819629f, 0.10549282f, -0.01149849f, -0.30520073f, -0.11162336f, 0.20136385f, -0.23367678f, 
    -0.44378576f, -0.32761237f, -0.41892448f, -0.58066237f, -0.19189125f, 0.38936755f, -0.02823860f, -0.16627561f, 
    -0.46526465f, -0.06406898f, -0.56624603f, 0.04431646f, -0.41967830f, 0.07384967f, 0.37306148f, -0.21771206f, 
    0.04255203f, -0.18466163f, -0.12299332f, -0.38634187f, 0.24262707f, 0.03025045f, -0.13539456f, 0.26287195f, 
    -0.09571931f, 0.11808471f, -0.38348994f, 0.04462609f, 0.14883146f, -0.22222881f, -0.05475399f, -0.02183378f, 
    0.16325410f, 0.03698168f, -0.45453823f, -0.01151386f, 0.03921742f, -0.15645026f, 0.15389417f, -0.13093102f, 
    -0.33058107f, -0.03019745f, 0.05064445f, -0.11619431f, -0.01330731f, 0.09332408f, 0.14945677f, 0.14097725f, 
    0.18232615f, 0.16255750f, 0.02586510f, -0.60222542f, 0.01951693f, -0.13645925f, -0.16256642f, 0.11872586f, 
    -0.32083088f, -0.24288613f, 0.26192811f, -0.01341388f, -0.11491673f, -0.35601169f, 0.19122089f, 0.01099984f, 
    -0.31751540f, -0.17320743f, -0.27386874f, -0.20808594f, 0.03176639f, -0.40563089f, 0.03819827f, -0.07550672f, 
    0.12678510f, -0.14055680f, -0.20512511f, -0.35550192f, -0.27214244f, 0.02677402f, 0.20357682f, -0.48573440f, 
    -0.11924222f, -0.10501901f, -0.01550607f, 0.21409386f, -0.81845635f, -0.25388616f, -0.16478732f, 0.15899439f, 
    -0.22814383f, 0.18005520f, 0.06200584f, -0.28534251f, -0.09967127f, -0.14695634f, 0.05031085f, -0.21853206f, 
    0.10391413f, 0.14315748f, -0.14415748f, 0.25167233f, -0.28504279f, -0.21019267f, -0.08679233f, 0.16411328f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.14878833f, 0.23260307f, 0.13616945f, 0.06194249f, -0.01064022f, -0.16177922f, 0.10166694f, -0.28664601f, 
    0.22316550f, 0.14187288f, 0.05880425f, -0.04977791f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
