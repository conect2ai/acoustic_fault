#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.99504089f, 0.08242594f, 0.64835644f, -0.00645273f, -0.21195789f, 0.38227800f, -0.25774384f, -0.01181586f, 
    -0.36830372f, -0.78166187f, 0.22421081f, 0.80986643f, 0.12987688f, -0.09634732f, 0.19816673f, 0.14846635f, 
    -0.28777546f, -0.55098647f, 0.72640771f, 0.20672330f, 0.14040627f, 0.19807924f, 0.13118820f, 0.08754646f, 
    -0.29174393f, 0.07667542f, -0.52905357f, 0.52331531f, -0.04967215f, 0.17387609f, 0.14925046f, -0.17287590f, 
    -0.17669070f, -0.54757714f, 0.01927795f, 0.68355435f, 0.26500168f, 0.45832250f, 0.25798810f, 0.41906986f, 
    0.24980730f, 0.26657081f, 0.23615390f, -0.56081545f, -0.05017899f, -0.42640820f, -0.21815959f, 0.32529923f, 
    0.17087220f, -0.67638183f, -0.45211253f, 0.25188738f, 0.62131691f, 0.37293977f, -0.60510737f, -0.81382841f, 
    -0.84731066f, 0.17412262f, 0.43711191f, 0.75118560f, 0.48226041f, 0.09649073f, 0.67115837f, -0.12514335f, 
    -0.14903794f, -0.15376252f, -0.67885977f, -0.30611089f, 0.61949229f, 0.17127550f, 0.54796672f, 0.67393279f, 
    -0.46739045f, -0.02192664f, -0.28509301f, -0.56470329f, -0.38762978f, -0.66237783f, -0.21481262f, -0.49260548f, 
    -0.10037040f, 0.44598091f, -0.84005290f, 1.08330095f, 0.01572046f, -0.39805555f, 0.18368596f, -0.38990676f, 
    -0.23015974f, -0.10984938f, -0.53569800f, -0.22960967f, 0.14384145f, 0.08281425f, -0.83223534f, -0.39801946f, 
    -0.25504974f, -0.43138480f, 0.33299699f, 0.78084081f, -0.30673310f, -0.09453716f, -0.02918781f, -0.07798281f, 
    0.50445557f, 0.36607745f, -0.31818235f, 0.03112494f, -0.52280915f, 0.23983312f, -0.20557919f, 0.00953208f, 
    -0.35668766f, -0.52788657f, 0.46273240f, 0.25775865f, 0.57240659f, -0.15866625f, -0.28096488f, 0.32209510f, 
    -0.71832663f, -0.18703170f, -0.30666053f, -0.00487050f, 0.13151854f, 0.30363500f, 0.46606594f, -0.86951774f, 
    -0.52216613f, 0.40309539f, 0.82156754f, 0.20470597f, -0.47055978f, -0.35547778f, -0.41870058f, -0.57702476f, 
    0.16582879f, -0.21315089f, 0.52280039f, 0.73450536f, 0.63204169f, -0.26989192f, 0.12675107f, 0.00022873f, 
    0.54672348f, -0.53266335f, -0.25081432f, 0.91369760f, -0.49734142f, -0.42055422f, -0.15829998f, 0.19122764f, 
    -0.31349614f, -0.00028345f, 1.03813553f, -0.84110224f, 0.17489013f, -0.10568807f, -0.10245280f, -0.30844936f, 
    0.43557632f, 0.06881254f, 0.18065007f, 0.49291018f, 0.27418414f, 0.38556528f, -0.63760477f, -0.34539750f, 
    0.09670369f, -0.23854096f, -0.09765772f, -0.74053681f, 0.11439624f, -0.45629755f, -0.54354608f, -0.03302550f, 
    0.02848049f, 0.03285091f, 0.85327733f, -0.48189372f, -0.29866546f, 0.74397588f, -0.78641534f, -0.22393872f, 
    -0.04646671f, 0.06504664f, 0.45589748f, -0.07805813f, 0.43532795f, 0.52473098f, 0.63033986f, 0.64605111f, 
    -0.91278839f, 0.02138954f, -0.24108939f, -0.17661497f, -0.05601799f, 0.50641364f, -0.60792202f, 0.87992746f, 
    -0.91645408f, 0.47501126f, -0.65394038f, -0.13374479f, -0.17121091f, -0.08153072f, -0.30937850f, -0.70370948f, 
    0.45409805f, 0.37650284f, 0.92038476f, -0.61463594f, -0.93321449f, -0.45675504f, 0.22868465f, -0.24496013f, 
    0.18562083f, 0.26791263f, 0.12430376f, 0.64394438f, 0.50192165f, -0.25715357f, -0.13689528f, 0.16553065f, 
    0.65787375f, 1.00645268f, 0.02928317f, -0.20300128f, -0.21922249f, 0.39708224f, -0.63023746f, 0.18721069f, 
    0.28749713f, 0.36846501f, -0.61244130f, -0.58100909f, -0.14387670f, -0.49544591f, -0.16054490f, 0.13265036f, 
    0.15346654f, -0.22054574f, -0.18619522f, 0.29921678f, 0.34835726f, 0.03395483f, -0.05427893f, 0.30274403f, 
    0.50883347f, 0.20265076f, 0.43849444f, -0.43595359f, -0.55916566f, 0.33323127f, 0.22412448f, -0.82582539f, 
    0.01580685f, 1.15003395f, -0.03736190f, -0.08001045f, -0.14292762f, -0.12036554f, 0.43753493f, 0.15275802f, 
    0.11582199f, 0.37434050f, 0.38549161f, 0.23708026f, 0.33804154f, -0.04464464f, 0.35233974f, -0.24548288f, 
    0.58261555f, -0.29364702f, -0.13508864f, -0.36646038f, 0.62601960f, -0.41792831f, 0.48197573f, 0.49364248f, 
    -0.75593525f, -0.51743591f, 0.41299194f, -0.15976602f, 0.93932521f, -0.03683696f, -0.02953524f, -0.26897910f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.33638063f, -0.00305063f, -0.16559395f, -0.07391396f, 0.02890207f, 0.05381257f, 0.24679971f, 0.00571605f, 
    -0.11343441f, -0.27681252f, -0.05972049f, 0.45486191f, -0.14766401f, 0.48771009f, -0.04665802f, -0.38964993f, 
    0.41485158f, 0.06478214f, 0.25053817f, 0.39103621f, 0.07631502f, -0.06714014f, 0.09288545f, -0.24704337f, 
    -0.17166951f, 0.15946320f, 0.08254676f, 0.17814383f, 0.10068588f, 0.46059883f, -0.00422262f, 0.17249604f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.42953584f, 0.16085808f, -0.01099344f, 0.14781278f, -0.11411567f, 0.01758481f, 0.05700627f, 0.11159538f, 
    0.05239839f, 0.22478890f, 0.24890845f, -0.00445359f, 0.07930635f, 0.14980727f, 0.04951235f, 0.01852411f, 
    -0.15164745f, 0.08590012f, -0.48353246f, -0.25321525f, 0.20742378f, -0.00515393f, 0.08638310f, -0.20483391f, 
    -0.13124831f, -0.11691300f, -0.10108536f, -0.23670796f, -0.21514994f, -0.53657174f, -0.07639160f, 0.18529865f, 
    0.00681495f, 0.18024866f, -0.05227471f, -0.09002285f, -0.30092767f, -0.13045016f, 0.12012483f, 0.06982337f, 
    -0.03574480f, 0.01482658f, -0.14454450f, -0.24210235f, 0.02260816f, 0.27257740f, 0.06927945f, -0.24355525f, 
    -0.07360074f, 0.04735097f, 0.00618806f, 0.05077295f, -0.13859534f, 0.15745434f, -0.16011298f, -0.14925158f, 
    -0.08733980f, 0.07957961f, 0.14405537f, -0.04001318f, 0.06323313f, 0.12326753f, 0.03641203f, -0.01118062f, 
    -0.19281957f, -0.16277105f, -0.02297276f, 0.09336910f, 0.05430796f, 0.22548577f, -0.10547148f, -0.13110381f, 
    0.22811525f, 0.01204904f, 0.03528169f, 0.01357281f, 0.01284828f, -0.01299508f, 0.03360715f, 0.14266780f, 
    -0.19046940f, -0.43849635f, -0.23857473f, -0.33710238f, 0.13746226f, -0.18852738f, -0.17802261f, 0.14311998f, 
    -0.08563181f, -0.20101488f, 0.16391017f, 0.03520710f, 0.01332357f, 0.10882870f, 0.03600547f, -0.04727081f, 
    0.04150442f, -0.04318500f, -0.10878865f, 0.10338756f, 0.01948223f, -0.02378491f, 0.22513480f, -0.07634018f, 
    -0.01101160f, -0.02649357f, -0.05097499f, 0.18577056f, 0.28144017f, -0.01708584f, -0.17514956f, -0.08108069f, 
    0.01905606f, 0.06081419f, 0.01304016f, -0.05375634f, 0.15535675f, 0.27802187f, 0.01714448f, -0.01790192f, 
    -0.01548703f, 0.06130367f, 0.11093035f, -0.00269525f, -0.04089461f, -0.01687956f, 0.24022460f, 0.23617658f, 
    0.09594775f, -0.11157939f, -0.01370092f, -0.21908246f, -0.09437215f, -0.10729047f, -0.15536729f, -0.35214332f, 
    -0.40188441f, 0.00704193f, 0.08287821f, 0.00050490f, -0.10420291f, 0.06964294f, -0.17874876f, -0.01327180f, 
    -0.04526918f, 0.00749861f, -0.25686327f, 0.11521463f, 0.08259382f, 0.23429626f, 0.06596353f, 0.17567086f, 
    0.24466306f, -0.45846719f, -0.20853166f, 0.47399986f, -0.17160369f, 0.13271259f, -0.01268168f, 0.20173201f, 
    -0.19852090f, -0.14485089f, -0.58552247f, -0.04660534f, 0.07361407f, -0.18111412f, -0.00007356f, -0.00495142f, 
    0.01809302f, -0.03407591f, 0.01190875f, 0.25160846f, -0.04431504f, -0.13571332f, 0.24554095f, -0.18747313f, 
    0.12953787f, 0.08788173f, -0.05685928f, 0.14788437f, 0.14962521f, -0.19225815f, -0.16793038f, 0.06615833f, 
    -0.05814572f, 0.25315723f, 0.02093188f, 0.26970145f, 0.14752096f, -0.60071796f, -0.36635929f, 0.02949192f, 
    -0.03763689f, 0.02118751f, -0.04178490f, 0.10542464f, 0.02801540f, 0.09912301f, 0.10727923f, 0.05889246f, 
    0.09658592f, 0.01812699f, 0.05761437f, 0.07490827f, 0.02193160f, -0.06980117f, -0.23831579f, 0.07884394f, 
    0.20849977f, -0.00443182f, -0.03361676f, 0.05582895f, 0.06692587f, -0.09721766f, -0.02945585f, 0.11573517f, 
    -0.08901830f, -0.22382255f, -0.06969482f, -0.14384787f, -0.04498366f, -0.03380004f, 0.16168171f, 0.15073663f, 
    -0.11039294f, -0.27809361f, 0.05308484f, -0.13020158f, -0.09251699f, -0.02361199f, 0.16797552f, 0.02764985f, 
    0.06442612f, 0.20498538f, 0.32792076f, 0.00798900f, -0.09732674f, 0.08522686f, 0.01204802f, 0.02871417f, 
    0.03699764f, 0.13957186f, -0.14861226f, -0.03487570f, -0.04441535f, 0.09726316f, -0.01679113f, 0.10763206f, 
    -0.18052670f, -0.07851189f, -0.19172610f, 0.14768027f, 0.16800880f, -0.04792381f, 0.25477087f, 0.05518107f, 
    -0.07473313f, -0.12709357f, -0.05920626f, -0.00449842f, 0.01043296f, -0.01612265f, 0.00302938f, -0.04579373f, 
    0.04592971f, 0.07521001f, -0.05771647f, -0.05300738f, 0.06715295f, 0.05278003f, -0.00735460f, 0.02270363f, 
    -0.06776787f, 0.06849385f, 0.05872374f, -0.03139964f, -0.06951085f, 0.25821456f, 0.21569987f, 0.30784816f, 
    0.08924780f, 0.06553613f, 0.16345444f, 0.18179278f, -0.18065526f, -0.02242870f, -0.02732534f, -0.11949892f, 
    -0.06036726f, 0.01695076f, 0.02380391f, -0.06655091f, -0.02624738f, 0.02086767f, -0.04429499f, 0.02830096f, 
    -0.05563488f, -0.04273209f, -0.06487042f, -0.03515239f, -0.03262266f, -0.01422641f, -0.00521249f, 0.00676649f, 
    -0.05994635f, -0.06509360f, -0.00871075f, -0.01106561f, -0.00122138f, 0.02810504f, -0.00273834f, -0.05033903f, 
    -0.00269887f, 0.03434987f, -0.03021217f, 0.01463728f, -0.02653992f, 0.00274105f, -0.01942892f, -0.03019403f, 
    -0.00484682f, -0.02650927f, 0.03819562f, 0.02521250f, 0.00808403f, -0.05314832f, 0.00347028f, -0.06173725f, 
    0.03915058f, 0.00026538f, -0.01944292f, -0.02688311f, -0.01587958f, -0.01014674f, -0.03495643f, 0.02995591f, 
    -0.03980650f, -0.01705672f, 0.01794819f, 0.02698347f, -0.00497249f, -0.02732776f, 0.01561182f, -0.02849099f, 
    0.00958731f, 0.04271311f, -0.04817541f, 0.01038381f, -0.00376533f, 0.02631975f, 0.05099808f, -0.01972963f, 
    0.04612538f, 0.00239737f, 0.02507395f, -0.06253473f, -0.05994787f, -0.01299407f, 0.01800764f, -0.04411555f, 
    0.03764983f, -0.02227957f, -0.01999874f, 0.02314835f, 0.00624059f, 0.02410919f, 0.03151464f, 0.04762994f, 
    0.03461616f, 0.03859283f, -0.05772617f, -0.03759913f, 0.04097249f, 0.03434325f, -0.02216559f, -0.02337682f, 
    0.00903597f, 0.01110790f, 0.02137759f, 0.05330739f, 0.02761215f, 0.04666744f, -0.03030849f, -0.02735635f, 
    0.03978346f, 0.01649172f, 0.03050776f, -0.02699660f, -0.02684392f, -0.00286391f, 0.00497367f, -0.00510512f, 
    -0.02969117f, -0.02990062f, -0.01335475f, 0.02130393f, -0.00819979f, 0.03755538f, -0.00346937f, -0.04702335f, 
    -0.02184805f, -0.02008233f, 0.01953807f, -0.02935928f, -0.06325606f, 0.01343186f, 0.03141018f, -0.00154366f, 
    0.04073409f, -0.01576955f, 0.04661569f, -0.03759046f, 0.04428304f, 0.04648746f, -0.03353435f, -0.03799492f, 
    -0.01940855f, -0.06397253f, -0.01246898f, 0.03089659f, 0.01169625f, -0.04129386f, -0.07347514f, 0.02554461f, 
    0.03838290f, 0.05096348f, -0.00109567f, -0.03028812f, -0.05638186f, 0.02567991f, -0.04133002f, -0.03631070f, 
    -0.02422121f, 0.00946444f, -0.00180789f, 0.00561395f, -0.00033518f, -0.03755084f, -0.01865028f, -0.06457905f, 
    0.01452716f, 0.00190532f, 0.00999703f, 0.00826035f, -0.05073741f, 0.03265017f, 0.03553790f, 0.00714832f, 
    -0.02659551f, 0.01007202f, -0.03409760f, -0.04684534f, 0.03432406f, -0.06402941f, -0.01047723f, -0.04666459f, 
    0.01444613f, -0.03887644f, 0.04151851f, -0.05648800f, -0.04486803f, 0.01366513f, -0.03949252f, -0.02227467f, 
    0.01635356f, -0.04105832f, -0.05329282f, -0.01780804f, -0.05581848f, 0.03461764f, -0.05632061f, 0.03384073f, 
    -0.02967834f, 0.03485483f, -0.04473328f, 0.01466733f, -0.00863948f, 0.00098280f, 0.01784483f, 0.02614828f, 
    0.00264092f, -0.04292870f, 0.01005516f, -0.02821822f, 0.03490288f, 0.03675202f, 0.01282579f, -0.04229959f, 
    0.03801568f, 0.03818608f, 0.03236635f, 0.00583874f, -0.01001532f, 0.02981619f, -0.04376428f, -0.02214700f, 
    0.02012782f, 0.02330445f, 0.01912069f, -0.01455541f, 0.03676802f, 0.00459385f, -0.05550455f, -0.01185214f, 
    -0.06062946f, 0.01657888f, -0.04297806f, -0.01522323f, 0.02382873f, 0.00459629f, -0.05980520f, -0.00475487f, 
    -0.03428302f, 0.03600622f, -0.00388550f, -0.00061379f, 0.00828999f, -0.05656347f, 0.00938618f, -0.03539737f, 
    -0.04519648f, -0.00799971f, 0.01011280f, -0.05322658f, 0.00328879f, -0.06863257f, 0.01429323f, -0.01926141f, 
    0.02809357f, -0.05073245f, -0.01346322f, -0.06470191f, 0.02993292f, 0.03821012f, -0.02411615f, -0.04308944f, 
    0.03196280f, 0.03036984f, 0.04605965f, 0.02115154f, 0.00192116f, -0.04401308f, 0.00995929f, -0.03041523f, 
    0.03815178f, -0.02630914f, 0.04505752f, -0.03713076f, -0.02172231f, -0.00472780f, -0.02915028f, -0.03897094f, 
    0.03488354f, 0.01359527f, 0.02747014f, -0.02961906f, -0.00588665f, 0.04158177f, 0.01168523f, 0.04492563f, 
    0.02787691f, -0.00410227f, -0.06626552f, 0.01829722f, 0.03591418f, -0.05449362f, -0.04952411f, -0.01701777f, 
    -0.04529322f, -0.02738732f, 0.02532637f, -0.05047143f, 0.00636683f, 0.00588690f, -0.04095586f, -0.06852577f, 
    -0.53020674f, 0.07869894f, 0.16758786f, 0.11474983f, 0.17351197f, 0.05316567f, 0.11895018f, -0.17768146f, 
    0.13568056f, -0.20189966f, 0.11935917f, 0.22172795f, -0.03729733f, -0.13774906f, -0.03139286f, 0.12338119f, 
    0.06875015f, 0.20300344f, 0.24696745f, -0.04044671f, 0.09111378f, 0.03930846f, 0.05346510f, -0.00023166f, 
    0.12992670f, 0.07919137f, 0.02416909f, 0.06982525f, -0.05217088f, -0.18721014f, 0.00274752f, 0.13444547f, 
    -0.06007727f, 0.02788606f, -0.13840169f, -0.18891658f, 0.13779917f, 0.06909422f, 0.22728689f, 0.02026636f, 
    -0.03147839f, 0.10466224f, 0.01823680f, 0.08813997f, -0.01360426f, 0.12699503f, 0.06180034f, -0.00886941f, 
    -0.03169954f, -0.25951141f, -0.06250330f, -0.15788679f, -0.03891092f, -0.06572008f, 0.14240697f, 0.12817343f, 
    0.30833077f, -0.01329100f, -0.08372297f, -0.21156681f, 0.04345796f, 0.05267855f, -0.07051472f, -0.01204772f, 
    0.14610089f, 0.06179015f, 0.06619649f, -0.08359120f, -0.18956698f, 0.02537739f, -0.07704578f, -0.12621938f, 
    -0.10692433f, -0.42350268f, -0.54235071f, -0.27324656f, -0.22743715f, -0.12484298f, 0.03898399f, 0.09513491f, 
    0.05924316f, -0.27830556f, -0.08808858f, 0.20097019f, 0.13888922f, -0.01683330f, 0.00017758f, 0.07257494f, 
    0.09973664f, 0.04299353f, -0.36124232f, -0.08407798f, -0.58948505f, -0.45001581f, -0.10723712f, -0.17233638f, 
    0.00615681f, 0.04158214f, 0.03629447f, 0.04342190f, 0.07641815f, 0.11319952f, -0.03289681f, 0.05567893f, 
    0.06225128f, -0.02564926f, 0.05488093f, -0.07044964f, 0.06276051f, 0.06173437f, -0.09112258f, 0.05820321f, 
    -0.18070056f, -0.04614325f, -0.08732262f, 0.01293359f, 0.01068138f, -0.04253142f, 0.16133168f, -0.02787334f, 
    -0.08440842f, 0.03141120f, 0.04066927f, 0.03947536f, -0.11070976f, 0.12020738f, 0.12949848f, -0.03043659f, 
    -0.17989333f, -0.03839768f, 0.00765708f, -0.08473529f, 0.06155092f, -0.13809736f, -0.00880607f, 0.05194272f, 
    0.11775211f, 0.39560187f, -0.14518845f, -0.10039225f, -0.08343007f, 0.30200344f, 0.07178089f, -0.03447608f, 
    -0.02258589f, -0.22675057f, -0.31852552f, 0.00593707f, 0.10911769f, 0.04832724f, 0.02368511f, -0.02832103f, 
    -0.01731634f, -0.11075589f, 0.06797741f, -0.29599318f, 0.02828707f, 0.03945604f, 0.02825039f, -0.13061692f, 
    0.01510873f, -0.01865145f, 0.23721948f, -0.10126919f, 0.17527595f, 0.10020681f, 0.08171265f, 0.05019482f, 
    0.06624852f, 0.02280466f, 0.02248100f, -0.54175872f, -0.12083990f, 0.07751204f, -0.16034274f, -0.06197938f, 
    -0.10987805f, 0.15188026f, 0.03645722f, 0.14680617f, -0.05386245f, 0.20231183f, -0.03209584f, 0.12024850f, 
    0.08552008f, 0.02024125f, -0.01367651f, -0.21019024f, -0.07385289f, -0.00363105f, -0.06442865f, 0.08998338f, 
    0.22696871f, 0.17101553f, 0.00577453f, 0.07699350f, -0.10998826f, -0.00259120f, -0.04239675f, -0.21436986f, 
    -0.67243046f, 0.09214805f, -0.11123296f, -0.03349584f, 0.21014519f, 0.09337555f, 0.00222283f, -0.62878126f, 
    -0.29998532f, -0.04782164f, -0.13908283f, -0.06745445f, 0.29399195f, -0.06574439f, 0.15646431f, -0.02201058f, 
    0.12903613f, -0.13124073f, 0.09444866f, 0.03147561f, 0.09166768f, 0.11418500f, 0.20430632f, 0.00523027f, 
    -0.06319211f, 0.04752640f, 0.06119176f, -0.05651490f, 0.05229994f, 0.19541861f, 0.13284905f, -0.10223434f, 
    -0.18386637f, -0.05905016f, -0.38151020f, -0.14952643f, 0.05018401f, -0.02236346f, -0.14815329f, -0.08742934f, 
    0.01803472f, 0.00656231f, 0.08335821f, 0.12839720f, 0.07754104f, 0.20851451f, 0.09317755f, 0.03825764f, 
    -0.05032744f, 0.04253116f, 0.10209571f, -0.11164354f, -0.31660530f, -0.04173206f, 0.05978688f, 0.17104836f, 
    0.16991174f, -0.02364283f, 0.01660473f, 0.21934003f, -0.05549073f, 0.09084588f, 0.02782143f, 0.20905586f, 
    0.02843598f, -0.00522482f, 0.07923616f, 0.17646267f, 0.13818233f, -0.13982274f, 0.13265778f, 0.08302130f, 
    -0.04558374f, 0.02410916f, 0.08269287f, 0.06802125f, -0.02590823f, -0.02015897f, -0.10394862f, 0.30797961f, 
    0.04803984f, 0.35573792f, -0.05385573f, -0.09246294f, -0.16358419f, -0.08512083f, -0.17419125f, -0.10389564f, 
    0.06985951f, 0.21037731f, -0.13826951f, 0.01565816f, 0.08516420f, 0.16027845f, -0.04837561f, 0.03140622f, 
    -0.10765066f, -0.14816511f, 0.15640718f, -0.20377067f, 0.00980120f, 0.21879622f, 0.01927804f, 0.01201750f, 
    -0.09868142f, -0.09174755f, -0.00352654f, -0.10146633f, 0.00682122f, 0.02513657f, 0.04653189f, 0.01943423f, 
    0.03002629f, 0.05777686f, -0.19356741f, -0.08021753f, -0.02649837f, 0.10657306f, -0.01078681f, -0.04031816f, 
    0.01913981f, 0.06590396f, -0.19659144f, -0.01692558f, 0.05627469f, -0.00734764f, -0.08013484f, -0.01202197f, 
    0.08147054f, -0.01279540f, 0.05711149f, -0.04463360f, -0.02941870f, -0.28683722f, -0.04754870f, -0.00887063f, 
    0.07729063f, -0.06550425f, -0.28223753f, -0.04051502f, -0.21271004f, -0.11428864f, -0.08045299f, 0.28186816f, 
    0.26123706f, -0.05916707f, -0.07605575f, -0.22619227f, 0.18819901f, -0.06782079f, -0.11809305f, -0.14786807f, 
    0.08856331f, 0.07573087f, 0.09341706f, 0.02938571f, -0.24390513f, -0.15889561f, -0.23517884f, -0.36081803f, 
    -0.23725501f, -0.06780823f, -0.04306818f, 0.08979844f, 0.20687252f, -0.01642465f, -0.06811094f, -0.04481854f, 
    -0.02167833f, -0.36688215f, 0.06870567f, 0.01139189f, -0.04209542f, -0.01495470f, 0.23152779f, -0.07354498f, 
    0.02071232f, -0.18343316f, -0.17713954f, -0.02706045f, -0.04006708f, -0.04445904f, 0.09579961f, 0.11591869f, 
    -0.04396506f, -0.03647248f, 0.01686969f, -0.00105343f, -0.09473804f, 0.18038838f, -0.00347527f, 0.08638950f, 
    0.02521964f, 0.09896348f, 0.05180081f, -0.03592049f, -0.22448920f, -0.05636837f, -0.03688529f, 0.18974297f, 
    -0.01026367f, -0.32929417f, 0.02701765f, -0.19292727f, -0.10294178f, -0.18865912f, -0.05130614f, -0.07321131f, 
    -0.04398326f, -0.13779369f, -0.17616586f, -0.01419657f, -0.00854731f, -0.14395092f, 0.00336930f, -0.12224195f, 
    -0.02846884f, 0.06335742f, 0.06745290f, 0.05489746f, -0.06173111f, 0.09030580f, 0.28166893f, 0.05447829f, 
    -0.06781890f, 0.14154859f, 0.00265438f, -0.06044778f, -0.05176324f, -0.19111192f, -0.11064591f, -0.11157144f, 
    -0.10768505f, 0.16120000f, 0.16338937f, 0.03152199f, -0.00766112f, 0.17747509f, 0.10007758f, 0.24738324f, 
    0.19287266f, 0.15937184f, -0.00550424f, 0.30029467f, 0.07332472f, -0.08672498f, 0.12119301f, 0.19071525f, 
    0.15420966f, 0.13457625f, 0.20217369f, -0.07085094f, 0.10544340f, -0.05834478f, -0.06966081f, 0.00620466f, 
    0.06826957f, 0.12761685f, 0.08975790f, -0.09853301f, -0.07225753f, 0.22330528f, -0.00694040f, 0.10984489f, 
    -0.02791541f, 0.07312366f, -0.00849312f, 0.06383237f, -0.01543253f, 0.11098388f, 0.15541983f, -0.00875762f, 
    0.00559589f, 0.05901431f, -0.12998796f, -0.14240466f, -0.27369428f, 0.04106528f, -0.04817288f, -0.11869648f, 
    -0.00390137f, 0.00456642f, -0.03560425f, 0.05604417f, 0.04297737f, 0.08559985f, -0.07404965f, -0.24909042f, 
    0.36431488f, 0.07334101f, 0.00850722f, 0.05441087f, 0.00431110f, -0.02606955f, 0.15576610f, -0.03420268f, 
    0.09909187f, 0.00095271f, -0.13012818f, 0.15905769f, 0.03406138f, 0.17374445f, 0.10872687f, 0.12721598f, 
    -0.00768044f, 0.06768076f, 0.03140946f, 0.16434662f, -0.13436282f, 0.01473965f, -0.07113654f, 0.08420485f, 
    0.07168214f, 0.15710549f, 0.03213866f, 0.05924927f, 0.04828830f, -0.03225618f, -0.09426160f, -0.06169162f, 
    0.01831551f, -0.03607283f, -0.26054704f, -0.14410478f, 0.07544735f, 0.17649117f, 0.09726959f, -0.04621188f, 
    -0.03042789f, 0.09767112f, 0.04728714f, 0.09250367f, -0.16244371f, 0.02194277f, 0.00245635f, 0.11550430f, 
    0.08931819f, 0.06303564f, -0.04827853f, 0.00297676f, 0.03981268f, -0.03688934f, -0.14026055f, 0.07552867f, 
    -0.02554588f, 0.12453760f, 0.13978143f, -0.07748180f, -0.01429999f, 0.05318749f, -0.15374723f, 0.07717634f, 
    -0.04560795f, 0.07652058f, 0.04900457f, 0.05620670f, 0.04735708f, -0.11163401f, 0.01505865f, -0.08930311f, 
    -0.01116896f, 0.18853161f, -0.01163783f, -0.18396096f, -0.00117127f, 0.07514876f, -0.10704440f, -0.06292263f, 
    0.10142758f, 0.17484097f, -0.06165938f, -0.12781227f, -0.02522545f, 0.00690300f, 0.16959597f, 0.28032431f, 
    0.05021402f, 0.04554479f, -0.05045481f, -0.06195580f, -0.03848640f, 0.04078044f, 0.04291474f, -0.02407911f, 
    0.01045798f, -0.01152927f, 0.00650483f, -0.02689544f, 0.04269833f, -0.03514202f, -0.01163649f, -0.04402370f, 
    -0.02280107f, 0.02683386f, 0.00626217f, 0.03241288f, -0.00852663f, -0.06141622f, -0.05652058f, -0.03335382f, 
    -0.03286527f, -0.00810754f, 0.02205715f, -0.04380253f, 0.01139372f, 0.00610983f, 0.01131047f, 0.05078000f, 
    -0.06112125f, 0.03079458f, 0.04170777f, -0.06324531f, -0.00372234f, 0.03860210f, -0.00570116f, -0.02861741f, 
    0.02418643f, -0.05121835f, 0.00756258f, 0.02287411f, -0.06405584f, -0.05888005f, 0.04915161f, 0.03372149f, 
    0.00248704f, 0.01726567f, -0.04053963f, -0.00065451f, -0.06229091f, 0.00191094f, 0.04724302f, -0.04976242f, 
    -0.02143505f, -0.05972734f, 0.03171917f, 0.03125400f, -0.04965010f, -0.06314670f, -0.02020295f, -0.06363809f, 
    -0.00264717f, 0.01390759f, 0.04002272f, -0.03236639f, 0.01108638f, 0.05010957f, 0.03375581f, -0.00254314f, 
    -0.04502444f, 0.02917866f, -0.05394684f, -0.05658176f, -0.02380030f, 0.05136938f, -0.01830218f, -0.03184211f, 
    -0.04104916f, 0.03951185f, 0.03671015f, 0.04388120f, -0.02379068f, 0.01469015f, -0.03206217f, 0.00154832f, 
    0.03382231f, 0.01874106f, -0.05342003f, 0.03500553f, 0.03681906f, -0.01423798f, 0.04397358f, -0.00064286f, 
    -0.04697355f, -0.02847582f, -0.01386544f, -0.05145553f, -0.05434277f, -0.00230883f, 0.03442707f, -0.00554413f, 
    -0.02508278f, -0.01481522f, -0.00396250f, -0.02607001f, 0.00075495f, 0.04102559f, -0.03434173f, 0.03852706f, 
    -0.03419142f, -0.03636157f, 0.03930784f, -0.04705187f, -0.04342665f, -0.02527736f, 0.02556439f, -0.00490350f, 
    -0.06299445f, -0.02810853f, 0.03561157f, -0.05120701f, -0.00791249f, -0.00945273f, 0.00496551f, -0.06123121f, 
    0.00222652f, -0.02004005f, -0.02209597f, 0.04495101f, -0.05578970f, 0.01574087f, -0.03197576f, 0.02735699f, 
    0.02546715f, 0.02865030f, -0.03708440f, 0.03604288f, -0.03640448f, -0.00625373f, -0.01672116f, 0.05171588f, 
    0.01679655f, -0.03084187f, 0.02916375f, 0.02675024f, 0.04162707f, -0.01579181f, -0.03021770f, -0.04079026f, 
    0.04647166f, -0.02727584f, 0.01221634f, -0.01092216f, -0.02271595f, -0.04652859f, -0.03607515f, 0.01643400f, 
    -0.03804420f, -0.01557176f, -0.03762232f, -0.00226357f, 0.04498691f, -0.06414413f, 0.03603227f, 0.05268008f, 
    -0.03079162f, -0.04173263f, -0.05304531f, 0.03389167f, -0.04718087f, -0.03286214f, -0.03209892f, 0.04560005f, 
    0.01828732f, 0.02461185f, -0.04216110f, -0.04961973f, -0.04722671f, -0.01467280f, 0.03259617f, -0.01640296f, 
    0.02692276f, -0.05587680f, -0.02176202f, -0.05220968f, 0.00522333f, 0.02905125f, 0.01345020f, 0.03907270f, 
    0.03445704f, -0.01341743f, 0.01269971f, 0.05228232f, -0.02684272f, 0.01409832f, 0.00221029f, -0.01269823f, 
    -0.05494020f, -0.02213728f, -0.00750193f, -0.00940252f, -0.04719599f, 0.02829929f, -0.04749460f, -0.04440993f, 
    -0.01105662f, -0.05321369f, -0.01065083f, -0.03038214f, -0.02549155f, -0.02366672f, -0.02464237f, 0.04580389f, 
    0.02610685f, 0.04270535f, -0.06399964f, 0.04282638f, 0.05024862f, 0.03156102f, 0.03591349f, 0.01969397f, 
    -0.00106682f, 0.03477168f, 0.02457174f, 0.03922680f, -0.03182123f, 0.03037983f, -0.02694079f, 0.01540463f, 
    -0.04156440f, -0.00413057f, -0.01820510f, -0.04178677f, 0.04421614f, 0.02846025f, 0.04177215f, -0.01721744f, 
    0.00712612f, -0.00129043f, -0.04168839f, 0.03384174f, -0.05037086f, -0.05605642f, 0.00486765f, 0.02946626f, 
    -0.01551269f, -0.02143248f, 0.01483242f, -0.04920216f, -0.05140046f, -0.06199468f, 0.01219526f, -0.03654321f, 
    -0.00868825f, 0.00772270f, -0.00261487f, -0.02764438f, 0.05196512f, 0.00718718f, -0.06487746f, -0.03570610f, 
    -0.03623331f, -0.04212254f, -0.00108092f, -0.01213730f, 0.01753293f, 0.00145095f, -0.01388005f, -0.01088027f, 
    -0.01168898f, 0.04713819f, -0.00408905f, -0.02777610f, -0.00735978f, 0.04461483f, -0.05326681f, -0.05631422f, 
    -0.04729328f, 0.01886032f, -0.03490071f, 0.00424236f, 0.04028232f, -0.00101946f, -0.06262407f, -0.05682523f, 
    0.28590742f, 0.31746218f, 0.15960447f, 0.01537150f, 0.03511555f, 0.05891415f, 0.09196834f, 0.02562064f, 
    -0.10382204f, 0.08191974f, 0.23790957f, -0.07112466f, -0.04515215f, 0.01115381f, -0.07400276f, 0.08784486f, 
    0.04605595f, -0.14739984f, -0.12821797f, -0.12121782f, -0.10949964f, 0.04465142f, -0.18521041f, -0.12155639f, 
    0.01602238f, 0.11828056f, 0.00270516f, -0.19214867f, -0.07913881f, -0.02084146f, 0.13282998f, -0.04582659f, 
    0.03432796f, -0.01855983f, 0.11876329f, 0.05841915f, -0.09654135f, -0.13207085f, -0.09938066f, 0.12365825f, 
    -0.08795723f, -0.09727006f, 0.18093047f, 0.27816778f, -0.02181128f, 0.18812560f, -0.19798364f, -0.11105023f, 
    0.02227370f, -0.09414498f, -0.05732184f, 0.08164990f, -0.00605642f, -0.06810240f, -0.13306169f, -0.03953900f, 
    0.31699517f, 0.05311111f, 0.12060829f, -0.19943136f, 0.02486249f, 0.15277380f, 0.11585204f, 0.12406085f, 
    -0.05896364f, 0.08183538f, -0.13392442f, -0.06635044f, -0.24009636f, 0.23194180f, 0.13534859f, -0.16707340f, 
    0.04129427f, 0.03774759f, 0.18139002f, 0.07152092f, 0.05459256f, 0.13100788f, 0.09383354f, -0.07816663f, 
    -0.10684605f, -0.25702927f, -0.14973024f, 0.07897792f, -0.09573078f, 0.02439248f, -0.16769671f, -0.19148622f, 
    0.10729992f, 0.12756255f, -0.03699432f, 0.16279435f, 0.21945059f, -0.05141559f, -0.13835226f, 0.00564219f, 
    0.01988170f, -0.10711593f, -0.11270748f, 0.01666430f, -0.08935542f, 0.09766567f, 0.02241862f, -0.02797179f, 
    0.09426032f, 0.22289222f, 0.15705109f, 0.22750448f, -0.02023078f, -0.03655799f, 0.06876065f, 0.05401684f, 
    -0.00178228f, -0.05185606f, -0.05521377f, 0.02099946f, -0.08695689f, 0.26804489f, 0.28159425f, 0.17559807f, 
    -0.08241377f, 0.07580248f, 0.01219517f, 0.16254784f, -0.00251821f, -0.05497275f, 0.12705512f, 0.20430757f, 
    -0.19961588f, 0.00143526f, 0.02265629f, 0.26589668f, 0.01087002f, -0.02680509f, -0.16701066f, -0.04280046f, 
    -0.10406257f, -0.06486974f, -0.03224207f, -0.32438236f, 0.03067173f, -0.05404958f, 0.04860853f, -0.01219871f, 
    0.04533063f, 0.27695611f, 0.13436198f, 0.13647147f, 0.23442793f, 0.14166564f, 0.16333674f, 0.11281110f, 
    0.30140764f, 0.08945936f, 0.20750260f, 0.16223949f, 0.09960572f, 0.16503082f, -0.13956907f, 0.14279847f, 
    0.20934935f, 0.05469058f, -0.16690053f, 0.09464517f, 0.15456939f, 0.09537551f, 0.03933891f, -0.07922330f, 
    -0.04967137f, -0.02296264f, -0.03481456f, 0.39479175f, 0.19715790f, 0.15064697f, 0.08335111f, 0.21139260f, 
    0.11406487f, 0.16946530f, 0.02570813f, 0.00210727f, 0.05781337f, 0.14507389f, 0.15532605f, -0.05275312f, 
    0.26276678f, -0.07553944f, 0.07491177f, 0.15762979f, 0.09147832f, -0.18085608f, -0.06821319f, -0.14053205f, 
    -0.03196141f, -0.00165105f, -0.06374814f, -0.03630813f, 0.00139415f, -0.15371540f, 0.12631510f, 0.02868729f, 
    0.13526534f, 0.08686633f, 0.26306781f, 0.12419763f, 0.09465501f, -0.10451121f, 0.21485819f, -0.00932559f, 
    0.36834183f, 0.04241196f, -0.08282874f, 0.09419125f, 0.05672237f, -0.00054716f, -0.06142641f, 0.01330520f, 
    -0.08065502f, -0.05124031f, -0.17739555f, -0.01516096f, -0.04989032f, -0.10433722f, -0.00524638f, 0.21090735f, 
    0.04426692f, -0.01287767f, 0.13148552f, 0.11932949f, 0.07017953f, 0.08771914f, 0.20406638f, -0.04219966f, 
    0.11731166f, 0.00006284f, 0.04832803f, 0.00733548f, 0.03175875f, 0.05307476f, 0.01918880f, 0.19083914f, 
    0.02699863f, -0.06202016f, 0.00999527f, -0.04252914f, -0.02516202f, -0.09606484f, -0.22374344f, -0.13431549f, 
    0.00138499f, 0.15450373f, 0.10770810f, 0.17141774f, 0.06699659f, -0.15947819f, -0.01433764f, -0.03507359f, 
    -0.05487878f, -0.07712489f, 0.00998293f, 0.12623107f, -0.22459923f, -0.00916729f, -0.08044714f, -0.10090230f, 
    -0.20572059f, -0.04623850f, 0.07405977f, 0.07888407f, 0.09713014f, 0.12438449f, -0.01479262f, 0.16249436f, 
    -0.09669566f, 0.05533389f, 0.11394000f, 0.26238382f, 0.06422517f, 0.07649512f, 0.01935059f, -0.11381511f, 
    0.11735529f, 0.01214100f, 0.04257369f, 0.17297117f, 0.21493427f, 0.00755179f, 0.05969041f, 0.10312043f, 
    -0.00838232f, 0.07731162f, -0.04585405f, 0.18896452f, -0.08228385f, 0.03848287f, -0.09123356f, -0.00619993f, 
    -0.12334161f, 0.05637151f, 0.11902215f, 0.01281172f, 0.13605632f, 0.07343245f, -0.02372434f, -0.19064821f, 
    -0.11193158f, -0.13474508f, -0.08801356f, 0.00417616f, 0.13173296f, -0.02657114f, 0.00774530f, 0.03286625f, 
    -0.10807269f, 0.01801728f, -0.21463382f, -0.20975377f, -0.18868694f, 0.09515072f, -0.11324336f, 0.30676815f, 
    0.01142349f, 0.17555821f, -0.13084620f, 0.37868047f, -0.07848321f, 0.03309050f, 0.05139711f, -0.10171286f, 
    0.12995024f, 0.05973227f, -0.14464195f, -0.19537959f, -0.14086999f, 0.04940903f, 0.01479353f, 0.01720566f, 
    -0.02937203f, 0.09379832f, -0.10290696f, 0.11093308f, 0.03630493f, 0.14995313f, 0.00629336f, 0.05087537f, 
    0.03385813f, -0.08361005f, -0.04410355f, -0.22335690f, -0.01487797f, -0.07892425f, 0.06770089f, 0.04882057f, 
    -0.02624530f, -0.06415638f, -0.00017183f, -0.06219294f, -0.17577596f, 0.19214456f, 0.00232576f, 0.28472632f, 
    0.03632771f, -0.01401841f, 0.00000381f, 0.06846006f, -0.09205599f, -0.08284668f, 0.06439419f, -0.01687920f, 
    -0.09257490f, 0.10790473f, 0.19069466f, 0.07416873f, 0.10627005f, 0.08637694f, 0.13174750f, -0.03321055f, 
    -0.24122342f, -0.08661529f, 0.17768256f, -0.17968945f, 0.00152004f, 0.08731609f, 0.02696336f, -0.02881360f, 
    0.08008890f, -0.17689496f, -0.13809837f, 0.23299062f, 0.00948333f, 0.24233156f, 0.02610865f, 0.00581525f, 
    0.10020211f, -0.27320760f, 0.05425891f, 0.06304450f, 0.02545866f, 0.24768022f, 0.29571003f, -0.05903280f, 
    -0.05894475f, 0.05175196f, 0.10099917f, -0.00107576f, 0.10650596f, 0.00373482f, -0.05421198f, 0.12508892f, 
    0.08128516f, 0.06822783f, 0.06378774f, 0.02505588f, 0.04330506f, 0.06957481f, 0.03073789f, -0.19463678f, 
    -0.16857618f, -0.07657667f, -0.06138338f, -0.11823729f, -0.25591439f, -0.24674651f, -0.29663330f, 0.08465886f, 
    -0.15269014f, -0.22401536f, 0.13776840f, 0.15481189f, 0.04801453f, -0.01309471f, -0.13360651f, 0.00995529f, 
    0.10103329f, -0.03232056f, 0.23997574f, -0.10487569f, 0.24274123f, -0.08066909f, 0.03231349f, -0.01007278f, 
    0.04457559f, -0.07621836f, 0.37806141f, 0.26706290f, -0.07050815f, 0.13237740f, 0.32972747f, 0.10535567f, 
    0.20236561f, 0.08662190f, -0.33216149f, -0.08557181f, 0.02023807f, 0.02581457f, 0.06439802f, -0.05400593f, 
    -0.05709868f, 0.12727690f, -0.14542419f, 0.01428494f, 0.02394484f, -0.09632451f, 0.01825538f, 0.12625736f, 
    -0.09490424f, -0.02629691f, -0.05285016f, 0.02654460f, 0.10889099f, 0.21467212f, 0.06940551f, -0.16588137f, 
    -0.04743293f, 0.11829184f, 0.13422376f, 0.17966223f, 0.07047942f, -0.07924785f, 0.12271326f, 0.13757740f, 
    -0.07522413f, 0.10690710f, -0.05954898f, -0.07082552f, -0.04461121f, 0.11648170f, -0.04907427f, 0.23577544f, 
    -0.16833258f, 0.01539612f, -0.03877389f, 0.05268846f, 0.13071866f, 0.00938903f, 0.01661497f, 0.16957699f, 
    0.00003301f, 0.15285149f, -0.04580969f, 0.26385960f, 0.02052320f, -0.16572239f, -0.04428101f, -0.06206591f, 
    0.02121116f, 0.02873335f, -0.06379771f, 0.01251703f, 0.06323517f, 0.07870588f, -0.00068607f, 0.11088995f, 
    0.08143961f, 0.02445410f, -0.20529594f, 0.13446112f, -0.00408871f, -0.00981000f, 0.04177828f, 0.12793258f, 
    -0.10806622f, 0.45105648f, -0.01432842f, -0.06672612f, -0.23046704f, -0.09074926f, 0.01497630f, -0.08543057f, 
    -0.08060160f, 0.02790862f, -0.00939549f, 0.01530791f, 0.05626389f, 0.10379940f, 0.18310472f, 0.09022583f, 
    -0.03539132f, -0.16986647f, -0.05982581f, 0.08515553f, 0.16213238f, 0.09097779f, -0.03751276f, 0.02869749f, 
    -0.11393835f, -0.06202099f, 0.13785753f, 0.19656259f, 0.16623227f, 0.05835675f, -0.00404339f, 0.15343310f, 
    0.03375686f, 0.12114587f, -0.05931305f, -0.07610666f, -0.11211030f, 0.04594372f, 0.04406548f, 0.28222823f, 
    0.22971344f, 0.09831023f, 0.14547551f, 0.17847453f, -0.12624769f, 0.17035638f, 0.15224709f, 0.09518663f, 
    -0.11204793f, 0.05508853f, -0.08926541f, -0.07589402f, -0.25165263f, -0.03843227f, -0.03250342f, 0.02450185f, 
    0.28429824f, 0.06511593f, -0.22811340f, 0.06249050f, -0.06498452f, 0.11681383f, 0.00980814f, 0.10525257f, 
    0.06617827f, 0.24694103f, 0.21767510f, -0.08598797f, 0.03617542f, -0.08344975f, -0.02519911f, 0.02606209f, 
    0.04657202f, 0.22558960f, 0.07806963f, 0.12861142f, 0.09458657f, -0.05767670f, -0.07011649f, 0.01903317f, 
    -0.05377794f, -0.08106685f, 0.19314721f, 0.09547399f, 0.06447458f, 0.08360101f, -0.03586404f, 0.02769209f, 
    0.00899079f, 0.14640550f, 0.20335032f, 0.08615024f, 0.12442931f, 0.21783943f, 0.11221443f, 0.00265534f, 
    -0.16596788f, -0.19335079f, 0.05889625f, -0.02346322f, 0.08224197f, -0.47977209f, -0.16589829f, 0.08068475f, 
    0.08766756f, 0.01836546f, -0.04779352f, 0.12308944f, -0.08151748f, -0.01426550f, -0.31688061f, 0.28437084f, 
    -0.08246516f, -0.17109099f, 0.22778726f, -0.04925002f, -0.04083265f, -0.08633733f, -0.04486607f, -0.25063387f, 
    0.04652290f, -0.30351266f, -0.21629295f, 0.13811021f, -0.02584285f, -0.01348155f, -0.01007716f, 0.07459258f, 
    -0.62762928f, -0.10050675f, -0.57817489f, -0.11521727f, -0.06545147f, -0.08508545f, -0.10186489f, -0.12897134f, 
    0.11788613f, 0.08063011f, 0.08278034f, -0.22880596f, -0.01923094f, 0.28609622f, 0.07226711f, 0.10031895f, 
    -0.12383696f, 0.00618059f, -0.30828735f, -0.21882211f, -0.00194554f, 0.00182460f, -0.16074803f, -0.06042574f, 
    -0.12914494f, -0.07396721f, 0.10297519f, 0.18820970f, 0.45940888f, 0.20632660f, 0.01436577f, -0.10241401f, 
    -0.02877713f, 0.11280937f, 0.05804031f, 0.00856840f, -0.38172376f, -0.26897106f, 0.11117197f, 0.04193906f, 
    -0.04283575f, -0.06022000f, 0.06241190f, -0.16271137f, -0.03671235f, -0.32140124f, -0.40652755f, -0.26403382f, 
    -0.00994908f, 0.14971045f, 0.03079392f, 0.11373734f, -0.06401820f, -0.02905641f, -0.44620454f, -0.11923578f, 
    0.02147863f, -0.11016814f, 0.05254411f, -0.12649013f, 0.06011875f, -0.03325471f, 0.22090702f, -0.10437885f, 
    0.02431170f, -0.05658951f, -0.02703666f, -0.10957494f, -0.14841168f, -0.02956337f, -0.09946845f, 0.10186476f, 
    -0.16049373f, -0.06734462f, 0.03220157f, 0.03505043f, 0.02596956f, -0.00180089f, 0.11802946f, 0.01547864f, 
    0.24238409f, 0.24766304f, -0.11619760f, 0.08086982f, 0.03526725f, -0.17903554f, 0.21299300f, -0.03478734f, 
    -0.12514609f, 0.01343720f, -0.12304110f, -0.16909945f, 0.10657392f, 0.03072901f, 0.16108663f, 0.01562200f, 
    0.25083825f, 0.11582872f, 0.06852026f, -0.29929909f, -0.13040046f, 0.31921262f, 0.05790661f, 0.11363479f, 
    -0.02748369f, 0.10846373f, -0.01660292f, 0.09757217f, 0.02258766f, -0.16198014f, -0.08783610f, 0.07702470f, 
    0.13227023f, 0.02524867f, -0.00616530f, -0.02999281f, -0.04419031f, 0.30841264f, -0.30921343f, 0.06141987f, 
    -0.08135316f, 0.03319001f, 0.07538520f, -0.14735788f, -0.05341832f, 0.08237159f, -0.01913874f, -0.33408949f, 
    -0.13810274f, -0.08552131f, -0.11766794f, 0.07781310f, -0.17232892f, 0.05477715f, 0.06234162f, -0.13912989f, 
    -0.21181306f, -0.06077074f, -0.01533345f, 0.03667445f, -0.35366550f, 0.18469508f, -0.04476714f, 0.10918051f, 
    0.10093282f, 0.07695644f, 0.11706727f, -0.06023232f, -0.06313264f, -0.07294573f, 0.01136359f, -0.02631053f, 
    -0.05371748f, 0.02533888f, -0.04983102f, 0.08509467f, 0.10521736f, -0.00969486f, 0.06221967f, -0.04611137f, 
    -0.09079494f, -0.06989140f, -0.55977243f, -0.11564931f, -0.43137911f, -0.00801183f, 0.10941378f, -0.07126252f, 
    -0.10579328f, 0.00821507f, -0.00907100f, 0.23073281f, 0.18056923f, 0.16211458f, -0.07255492f, -0.27241483f, 
    0.04781932f, -0.04580079f, -0.13395596f, 0.01785253f, 0.19571863f, 0.25287393f, -0.11081842f, 0.02616515f, 
    -0.06161788f, 0.03420111f, 0.07324157f, 0.14019960f, 0.25065580f, 0.18485411f, 0.13926266f, 0.12369975f, 
    -0.01263592f, -0.29931995f, 0.13356629f, 0.05671640f, -0.15620086f, 0.04110164f, 0.19063745f, -0.01112655f, 
    0.03575594f, 0.03733150f, -0.03554918f, -0.00044321f, -0.05084653f, 0.02640724f, 0.01837543f, -0.22957461f, 
    0.15266868f, -0.13643190f, -0.08000688f, 0.19617319f, 0.15251885f, 0.11237938f, -0.05828786f, 0.08034851f, 
    0.03644976f, -0.04969143f, -0.01769728f, -0.01275460f, -0.04671248f, 0.02915144f, -0.03732441f, -0.03181677f, 
    -0.02881528f, -0.02203085f, 0.04574129f, -0.03582545f, 0.03244995f, 0.02305779f, 0.02503191f, -0.03113610f, 
    -0.02716228f, -0.01306954f, 0.00479727f, -0.00632928f, 0.03357855f, 0.01913483f, 0.04049693f, -0.03808166f, 
    0.00037194f, -0.01570479f, 0.04443549f, -0.04642874f, 0.01825635f, 0.04503073f, -0.01284110f, -0.06691249f, 
    0.01041468f, 0.00026577f, 0.05285929f, -0.03479766f, 0.04418495f, -0.06174328f, 0.02351089f, 0.02108334f, 
    0.04282669f, -0.04785289f, 0.02412765f, 0.02456937f, -0.05511954f, 0.03881703f, -0.02568342f, -0.06497204f, 
    0.03440997f, 0.04584629f, -0.04883067f, -0.00986085f, 0.02454142f, 0.04109514f, -0.06349820f, -0.02658506f, 
    -0.03882820f, -0.00165059f, -0.01456654f, 0.01962007f, -0.02858838f, -0.00275515f, -0.06690021f, 0.04035411f, 
    -0.02383360f, -0.04428852f, 0.04046276f, 0.03996525f, 0.02950507f, 0.00703412f, -0.01544534f, 0.00419423f, 
    -0.01205823f, -0.00434501f, -0.05644586f, 0.02532063f, -0.01882157f, -0.00641231f, -0.03762371f, 0.01646361f, 
    0.03782055f, -0.01619144f, 0.02303724f, 0.04325235f, 0.04273180f, 0.00249833f, 0.04332881f, 0.03869273f, 
    0.04422320f, 0.01604092f, 0.02293225f, 0.00869778f, -0.03131418f, -0.03671392f, 0.01147315f, -0.00546148f, 
    -0.02141989f, -0.07249714f, 0.02761343f, -0.04080395f, 0.03034057f, -0.06491823f, 0.00276400f, 0.01918449f, 
    -0.06043587f, 0.03545041f, 0.03917173f, -0.04642855f, -0.04165866f, 0.00461939f, -0.01524370f, -0.05207598f, 
    0.01418180f, -0.01381688f, 0.05527424f, 0.01185253f, -0.02023802f, 0.01236492f, -0.01747808f, 0.01148690f, 
    0.03933302f, 0.00377829f, 0.00716063f, -0.02261786f, -0.03771847f, 0.00889742f, 0.01120535f, 0.00174476f, 
    -0.05335415f, -0.02905476f, 0.03946838f, 0.03013140f, 0.02680258f, -0.02685884f, 0.00759128f, -0.04433336f, 
    -0.03649832f, -0.01174165f, -0.06669731f, -0.00552134f, -0.03574072f, -0.03857082f, 0.01653280f, -0.03278069f, 
    -0.04204246f, 0.04536461f, -0.04508863f, 0.03514658f, 0.01310708f, -0.05555209f, -0.03451804f, 0.01058846f, 
    -0.02049738f, -0.03542338f, 0.01939947f, 0.03622676f, -0.04998853f, -0.06776927f, 0.04073467f, -0.06131561f, 
    0.04598118f, -0.01506616f, 0.00201566f, 0.02776375f, -0.00527183f, -0.03180045f, -0.01155563f, -0.01242882f, 
    0.01370927f, -0.05562623f, 0.02431301f, -0.03376256f, -0.03174523f, -0.02742393f, -0.01627414f, -0.06071214f, 
    -0.00420592f, -0.06556732f, -0.05696124f, -0.00987494f, 0.03445493f, 0.02209241f, -0.00290444f, -0.01634618f, 
    0.02655131f, 0.00372842f, -0.04977607f, 0.05447420f, -0.02732229f, -0.05849487f, 0.03921735f, 0.04179728f, 
    0.03923292f, -0.02296533f, -0.00810313f, 0.00985733f, -0.04928379f, 0.03132913f, -0.04935012f, 0.04307157f, 
    -0.04449059f, 0.00533720f, -0.00543806f, -0.04711385f, -0.03620466f, 0.02472950f, -0.01063769f, -0.01480476f, 
    -0.05830136f, 0.04586212f, 0.02659504f, 0.00340483f, -0.05423358f, 0.03185114f, 0.04176868f, 0.00607253f, 
    0.00613198f, -0.00673625f, -0.02407387f, 0.01690488f, 0.03441250f, -0.00588812f, 0.01897196f, 0.03212936f, 
    0.03286860f, 0.02812251f, -0.04291793f, -0.05664008f, 0.01593188f, 0.03440274f, -0.02683648f, -0.02141878f, 
    0.04913431f, 0.05387828f, -0.01731482f, 0.03729705f, -0.03253066f, -0.00646823f, 0.00539814f, 0.00704959f, 
    0.01531781f, -0.03542653f, -0.01360450f, -0.02780965f, -0.00136469f, 0.04889445f, -0.07138907f, -0.06015828f, 
    0.01984924f, 0.04182922f, -0.05209179f, -0.06742602f, -0.05304211f, 0.03866684f, -0.05835325f, 0.04404867f, 
    -0.03985585f, -0.02033336f, -0.06038878f, 0.00642097f, 0.03551107f, 0.00805785f, 0.01982980f, -0.01368164f, 
    0.03740608f, -0.04179418f, -0.06781293f, -0.05170471f, 0.01917940f, 0.02794065f, -0.05215326f, -0.04353822f, 
    -0.02657465f, 0.03276663f, -0.01723629f, 0.00333973f, 0.00142185f, 0.03059769f, -0.02048358f, 0.01686801f, 
    -0.01197238f, -0.00745172f, -0.01129502f, -0.01845521f, -0.05292656f, 0.02576498f, -0.00208337f, -0.00164370f, 
    -0.01349373f, 0.03578707f, -0.05888209f, -0.04530845f, 0.03665745f, 0.04599856f, 0.04163168f, -0.00780266f, 
    -0.02973731f, 0.01033770f, -0.01544312f, 0.02507017f, 0.01740530f, -0.02190652f, -0.02531958f, 0.04460447f, 
    -0.04652062f, -0.04248209f, 0.03849319f, 0.03587792f, -0.04524593f, -0.05299957f, 0.00006186f, 0.04278539f, 
    -0.04828928f, 0.02496297f, -0.02181619f, 0.04943860f, 0.03779654f, -0.00237223f, 0.03107710f, 0.04016496f, 
    0.02944691f, 0.03280735f, 0.02703712f, 0.02963526f, -0.01269155f, 0.01896745f, -0.05896364f, -0.04219488f, 
    0.01640994f, -0.03110786f, -0.06122074f, -0.01440567f, -0.05375617f, 0.02667887f, -0.00039541f, -0.02526443f, 
    -0.03429258f, -0.03153278f, -0.00159684f, 0.00457541f, -0.01873383f, 0.00249921f, -0.05374259f, -0.03526887f, 
    -0.01817225f, 0.03646091f, -0.03088881f, -0.01670147f, -0.01181549f, -0.03992286f, -0.00289611f, -0.05622766f, 
    0.01048357f, 0.02469927f, 0.03562037f, -0.04682019f, -0.05505992f, -0.03655521f, -0.04980472f, -0.02843434f, 
    0.01000588f, 0.01110160f, -0.02733787f, -0.02405692f, -0.02594682f, 0.03583546f, 0.03670413f, -0.02768423f, 
    -0.03305594f, -0.05773383f, -0.00781306f, -0.02758961f, 0.00109166f, -0.06211644f, 0.02437509f, -0.02746755f, 
    0.02255723f, -0.00579967f, 0.01006762f, -0.06537058f, -0.00453981f, 0.03941942f, 0.01663654f, 0.00066594f, 
    -0.02071493f, -0.06673334f, -0.06156512f, -0.00961950f, 0.02833901f, -0.05567180f, 0.00984597f, 0.01314027f, 
    -0.01983219f, -0.04573002f, 0.00079710f, 0.02809539f, -0.03127873f, -0.03592372f, 0.05135489f, -0.01609559f, 
    0.00119438f, -0.01963907f, -0.01287685f, -0.00283616f, 0.03943793f, -0.00076210f, 0.04831870f, -0.03617748f, 
    0.04639063f, 0.03249786f, 0.01662117f, -0.02159215f, 0.04310190f, 0.04249045f, 0.04532190f, 0.00039883f, 
    -0.00539958f, 0.03607829f, 0.01281391f, 0.03625458f, 0.00466042f, -0.04234083f, -0.05399305f, 0.02882412f, 
    0.04254412f, 0.03443095f, -0.03212817f, -0.02610896f, -0.03896936f, 0.03186152f, 0.02539124f, -0.03521652f, 
    -0.00091681f, -0.03961429f, 0.01813234f, -0.04643831f, -0.06674509f, -0.05507737f, 0.03045619f, 0.02515569f, 
    0.03940620f, 0.02261530f, -0.01626983f, -0.03114077f, 0.01536969f, -0.02968391f, -0.04907195f, 0.01565367f, 
    -0.05547855f, 0.01878802f, 0.02452038f, 0.00545693f, 0.03189684f, 0.04826095f, -0.01496463f, 0.02027279f, 
    -0.01071388f, -0.04037632f, -0.03582394f, -0.00273656f, -0.06518424f, -0.06103340f, -0.03046707f, 0.03283180f, 
    0.04025420f, -0.03243536f, 0.05039314f, -0.05708244f, 0.01538031f, -0.04267488f, 0.04146221f, -0.05765543f, 
    -0.03264556f, -0.01817166f, -0.04250081f, 0.01633521f, -0.02787941f, -0.01566067f, -0.01693022f, -0.02813977f, 
    0.01446610f, 0.01505539f, -0.02691479f, 0.01723786f, -0.01056217f, -0.05900817f, 0.04559584f, -0.01704513f, 
    0.01713331f, -0.04439002f, 0.01033583f, 0.00489025f, -0.01691189f, -0.03801180f, 0.03570666f, 0.02633888f, 
    0.01011072f, -0.03169581f, 0.03257748f, -0.04848349f, 0.04108826f, 0.01453470f, 0.01538941f, -0.04394190f, 
    0.03129484f, -0.04846876f, -0.03558570f, -0.05340242f, -0.05603182f, -0.04777663f, 0.04141957f, -0.02064306f, 
    0.04670306f, 0.00401127f, -0.05069686f, 0.03408812f, -0.03554725f, 0.03873373f, 0.04707276f, 0.00979905f, 
    -0.01236401f, -0.01608793f, -0.00132331f, -0.05553063f, 0.00916231f, 0.01459580f, -0.00392775f, -0.06321576f, 
    0.05334835f, 0.03436027f, 0.02777755f, -0.05765026f, -0.00207622f, -0.02529623f, -0.05563228f, 0.05543572f, 
    0.01552562f, 0.00507494f, -0.02967831f, 0.01632171f, 0.00254812f, -0.02871874f, 0.01716443f, 0.03935084f, 
    -0.00740102f, -0.01411792f, 0.01263081f, 0.05093879f, -0.04041806f, 0.01365905f, -0.02335703f, 0.02994267f, 
    -0.03301251f, -0.04169112f, 0.05741091f, 0.04676472f, 0.02482196f, -0.00701173f, -0.00069976f, 0.02182079f, 
    -0.04595942f, 0.02830292f, -0.02240260f, -0.02428598f, -0.00076344f, -0.05453689f, -0.04935427f, -0.01253851f, 
    -0.04539426f, 0.04961561f, -0.05881899f, -0.00441196f, 0.05180784f, -0.01263168f, -0.04821709f, -0.02780111f, 
    0.18761787f, 0.13329951f, -0.04942862f, -0.15188713f, -0.00815225f, 0.16301998f, 0.08282970f, -0.05454459f, 
    0.15431088f, 0.16169718f, 0.04140715f, -0.06176354f, -0.17932133f, 0.06107056f, -0.06797428f, 0.16652413f, 
    0.13125230f, 0.10360608f, -0.05114125f, 0.07569609f, -0.10231093f, -0.36477640f, -0.16169225f, -0.10234207f, 
    -0.02355949f, 0.10548201f, 0.11490135f, 0.06233116f, -0.05128663f, -0.04158405f, 0.24379177f, -0.08971924f, 
    0.03757898f, -0.11487750f, 0.07617480f, 0.22082613f, 0.03709595f, 0.13218153f, -0.12396404f, -0.12542957f, 
    -0.04934107f, -0.11691252f, 0.16644736f, 0.38007879f, 0.13366964f, -0.17185676f, -0.40520731f, -0.13970116f, 
    0.03593759f, 0.02756432f, 0.07675608f, 0.13019951f, -0.05319363f, 0.06434670f, -0.19233336f, -0.17419675f, 
    0.23727693f, 0.11297236f, 0.04965432f, 0.00001724f, -0.15152925f, -0.19942696f, 0.20172548f, -0.14749983f, 
    -0.22327599f, -0.21961202f, -0.01804589f, 0.01974135f, 0.01397639f, 0.08931778f, 0.19513245f, 0.07461330f, 
    -0.13395302f, -0.05856181f, 0.28551382f, -0.13110213f, -0.05482990f, 0.01756212f, -0.16454206f, 0.05804090f, 
    0.15385306f, -0.13752708f, -0.25283784f, -0.20560782f, -0.28127787f, -0.23012753f, -0.30742621f, -0.14302847f, 
    0.11556058f, -0.05547318f, -0.18524963f, -0.13828370f, 0.26161042f, -0.00816339f, -0.12059806f, -0.02689674f, 
    -0.16134307f, 0.07561050f, 0.09452722f, 0.07256255f, 0.09229226f, -0.02632144f, 0.12643905f, 0.00173874f, 
    -0.02527001f, 0.38479963f, 0.35787189f, 0.13113044f, -0.20732704f, -0.20239685f, -0.01813610f, -0.01398323f, 
    0.04769382f, 0.03288017f, 0.01891306f, -0.15725015f, 0.09309687f, 0.19928032f, -0.07696307f, 0.09920731f, 
    0.11635261f, 0.07402905f, 0.10708497f, 0.03235875f, 0.14897124f, 0.04699178f, 0.01761847f, 0.09396515f, 
    0.06966029f, -0.22490066f, -0.13279581f, 0.11910816f, -0.14285456f, -0.03442885f, -0.08618080f, -0.10438308f, 
    -0.13780241f, -0.08767443f, -0.01398155f, 0.03153671f, -0.06842289f, -0.20028739f, -0.11770158f, 0.08310571f, 
    0.12188769f, 0.37779459f, 0.16124368f, 0.07205291f, -0.02771950f, -0.05696262f, 0.24259056f, 0.34430185f, 
    0.14988033f, 0.51738149f, -0.25879455f, 0.34863186f, 0.06460451f, -0.07664520f, -0.00485027f, 0.10812441f, 
    0.05455906f, -0.02783643f, 0.08112989f, -0.15780139f, 0.20449647f, 0.00102045f, -0.01036494f, -0.02232257f, 
    0.12935226f, 0.05723312f, 0.10597129f, 0.20454998f, 0.05800402f, 0.20177114f, 0.12959599f, 0.04243830f, 
    0.09600257f, -0.03697768f, 0.04075936f, 0.21389948f, 0.10443421f, -0.21930969f, -0.06028011f, 0.00991787f, 
    0.06383980f, -0.05475588f, 0.05062192f, 0.12617181f, 0.13566689f, 0.26478934f, -0.00295248f, -0.06219722f, 
    -0.12887235f, 0.02485826f, -0.05121081f, -0.18781500f, -0.17025574f, 0.16663623f, 0.12980996f, -0.13644333f, 
    0.29532290f, 0.01048103f, -0.11715094f, 0.07519235f, -0.06591589f, 0.05187655f, 0.08985189f, -0.07774797f, 
    -0.17177263f, 0.25660738f, -0.14721490f, -0.21951067f, -0.07599489f, 0.15544659f, 0.03921166f, -0.11661536f, 
    0.05852521f, 0.05500802f, -0.04619160f, -0.08413551f, 0.02578895f, 0.03162350f, 0.17926192f, 0.07208639f, 
    0.04419772f, 0.05766932f, 0.04722922f, 0.01798318f, -0.05551752f, 0.21603134f, 0.11704945f, 0.37162369f, 
    -0.08820259f, 0.07460180f, -0.06477112f, -0.12572157f, 0.01229202f, -0.08395433f, 0.02991675f, 0.16477865f, 
    -0.30249104f, -0.02118456f, 0.07035374f, 0.12360636f, 0.13908091f, -0.06967916f, -0.01253209f, 0.02026932f, 
    -0.03922264f, 0.21237339f, 0.08947939f, 0.22675480f, 0.36557683f, -0.23780027f, -0.12617502f, -0.21880670f, 
    -0.14123994f, -0.19164772f, 0.16073717f, 0.12509550f, 0.14715281f, 0.07027955f, 0.09854140f, -0.04805921f, 
    0.05486796f, 0.07446763f, -0.02453823f, 0.08953018f, 0.13514245f, 0.17135525f, -0.04046964f, -0.29532966f, 
    0.01869952f, 0.18243609f, 0.05894310f, -0.18320705f, 0.12136800f, 0.11905391f, 0.17734562f, -0.10834824f, 
    0.06774543f, 0.29301625f, 0.17594078f, 0.14787361f, 0.19976395f, -0.18377206f, -0.00460293f, 0.21272303f, 
    -0.19402157f, 0.10625804f, -0.14998966f, 0.00900885f, -0.04433138f, -0.05619813f, -0.04437848f, 0.05079892f, 
    -0.02921514f, -0.44742554f, -0.11285242f, -0.17841901f, -0.16105196f, 0.04182210f, -0.01332108f, -0.09808077f, 
    0.08638687f, 0.17114080f, -0.18547937f, -0.07975755f, 0.03960587f, -0.17862806f, -0.03650204f, 0.01954294f, 
    0.03867032f, 0.04301325f, 0.14393686f, -0.16844773f, -0.08056341f, -0.15345436f, 0.12366894f, -0.13309816f, 
    -0.03696446f, 0.11837306f, -0.05570108f, -0.09602294f, -0.18375230f, -0.06427595f, 0.13590983f, -0.12743030f, 
    -0.10504340f, -0.07201914f, 0.11340501f, -0.03022284f, 0.05964896f, 0.28633511f, 0.11694598f, 0.12063047f, 
    -0.06569573f, 0.08772746f, -0.03259297f, 0.17795193f, 0.10195491f, -0.07988738f, -0.02768858f, 0.03635290f, 
    0.18838632f, 0.09897140f, -0.09625237f, -0.10698988f, -0.09962922f, 0.07355921f, 0.12012280f, -0.09680876f, 
    0.34195396f, 0.06038465f, 0.15255433f, -0.10378592f, -0.04164771f, 0.14171652f, -0.07885020f, 0.02191781f, 
    0.06821100f, 0.16145158f, 0.28152531f, 0.07522963f, -0.00969524f, 0.07070707f, 0.08557507f, 0.01960353f, 
    0.16361602f, -0.84340537f, -0.78677237f, -0.30069542f, 0.08078676f, -0.08936947f, 0.10369864f, 0.07620958f, 
    -0.18227585f, -0.06430221f, -0.05835311f, 0.05405278f, -0.11487735f, -0.19423632f, 0.08234043f, -0.07675040f, 
    0.05463684f, -0.05513531f, -0.08227271f, -0.34917358f, -0.16063531f, -0.20924869f, 0.01785296f, -0.12227231f, 
    0.04315405f, 0.05744952f, -0.02455826f, -0.14559221f, 0.28415796f, 0.11775935f, 0.15887286f, -0.06259710f, 
    0.03382315f, 0.00176749f, 0.08760128f, 0.03054400f, 0.11056842f, 0.14855167f, 0.38613769f, 0.18486597f, 
    -0.01352963f, -0.04647727f, 0.00734572f, -0.00698933f, 0.01777805f, 0.00515932f, 0.23646027f, -0.24964900f, 
    -0.17772163f, -0.16876248f, -0.36010575f, 0.07098322f, -0.01140628f, -0.20545547f, 0.02200882f, 0.40736771f, 
    0.39517283f, 0.15947235f, -0.17931585f, -0.21751183f, -0.04903533f, 0.08323005f, -0.06999472f, 0.04458248f, 
    -0.00702554f, -0.07699098f, 0.24836881f, -0.15953906f, 0.05134500f, -0.01579549f, 0.07115154f, 0.06332065f, 
    0.00447383f, -0.24805264f, -0.09233326f, -0.08817936f, 0.08833778f, -0.08231977f, 0.07576851f, -0.04592938f, 
    0.30802250f, -0.06171966f, 0.13969621f, -0.02006261f, 0.04677472f, -0.08107191f, -0.00596596f, -0.06419006f, 
    0.07125942f, 0.05103846f, 0.08130775f, 0.07910211f, 0.18571723f, 0.13975361f, -0.03762058f, -0.03135404f, 
    0.06778170f, 0.08403196f, 0.06918547f, -0.05440567f, 0.06336328f, 0.21006487f, 0.01787582f, 0.16457286f, 
    0.04290476f, -0.01035341f, 0.04651322f, 0.07070304f, 0.01651475f, -0.08345839f, 0.30550164f, -0.14221905f, 
    0.18908806f, 0.00596226f, 0.14398327f, 0.01215879f, 0.08184858f, -0.04921009f, -0.23714107f, -0.23588112f, 
    -0.04764044f, 0.00134464f, 0.12284072f, 0.27009302f, 0.00453972f, -0.04885717f, 0.06884094f, -0.42909819f, 
    -0.13878022f, 0.11741955f, -0.25337845f, 0.08486302f, -0.30956730f, 0.06384099f, 0.13560329f, 0.04210172f, 
    -0.09575343f, -0.12878539f, -0.07474106f, -0.05653066f, -0.04654682f, -0.04471472f, 0.08936397f, 0.10286111f, 
    0.07115378f, 0.13042155f, 0.18691824f, -0.02415308f, 0.00070197f, -0.08150483f, 0.06609502f, -0.03356722f, 
    0.09394084f, 0.00289529f, -0.11844274f, 0.00167707f, 0.30167246f, 0.09863611f, -0.15962619f, -0.01376001f, 
    -0.01625416f, -0.07364695f, 0.09210110f, -0.20474987f, 0.05158060f, 0.00864500f, -0.12031646f, -0.03047130f, 
    -0.03454512f, -0.01788859f, 0.05211394f, 0.01130826f, -0.44799140f, 0.02858801f, -0.57835460f, -0.06152864f, 
    -0.19529308f, 0.09184998f, 0.03360619f, 0.20684290f, 0.01942414f, -0.21133262f, 0.17807819f, -0.00302014f, 
    -0.07791779f, 0.04215661f, -0.05321208f, 0.00221675f, 0.13135856f, -0.05474517f, 0.09007403f, -0.03686203f, 
    0.12689784f, -0.02025848f, 0.11780404f, -0.07101193f, 0.15966633f, 0.00166611f, -0.20297247f, -0.30329409f, 
    -0.00467718f, 0.20062616f, 0.07264282f, -0.28669655f, -0.06566392f, -0.04332006f, -0.11500508f, 0.05459249f, 
    -0.05565714f, 0.04030391f, 0.03851151f, 0.04947212f, -0.03887997f, -0.00053481f, -0.04203674f, 0.03677906f, 
    -0.03577382f, -0.00852706f, 0.00517140f, -0.00099631f, 0.02541031f, 0.02328248f, 0.01746233f, -0.01247228f, 
    0.02020180f, -0.04383040f, 0.00863270f, 0.00114567f, -0.03572790f, -0.02437129f, -0.03163062f, -0.04536275f, 
    0.03282053f, -0.03388704f, -0.05682194f, -0.05958562f, 0.03153835f, -0.03776991f, -0.03988344f, 0.02011412f, 
    -0.04149941f, -0.01969327f, -0.03140137f, -0.03995756f, -0.00934969f, -0.00781716f, -0.06288716f, -0.03709318f, 
    -0.00681436f, -0.02496733f, 0.04335608f, -0.03410445f, 0.04353091f, 0.01327015f, -0.01939732f, -0.01211608f, 
    -0.01256003f, -0.00332304f, -0.06339538f, 0.02926971f, -0.06125041f, -0.01200230f, 0.00680510f, 0.00430207f, 
    0.03250553f, 0.03143390f, -0.04066144f, 0.03860136f, 0.05049890f, -0.05688864f, -0.03712114f, -0.01173027f, 
    -0.03195724f, 0.04542259f, -0.05269671f, -0.00570494f, 0.03673212f, -0.02471537f, 0.02001452f, 0.00067137f, 
    -0.00076987f, 0.02555140f, 0.00696949f, 0.03477955f, 0.00827449f, 0.03022495f, -0.05635221f, -0.02925624f, 
    0.03723968f, 0.05106029f, 0.02305028f, 0.00269829f, 0.02586011f, -0.04571675f, -0.03114663f, 0.05798298f, 
    -0.00840549f, 0.02656213f, -0.03283175f, 0.05777903f, -0.04805884f, 0.03564718f, -0.04273837f, -0.03323586f, 
    0.02026412f, -0.03053305f, -0.05302631f, -0.03569945f, -0.02847231f, -0.03487816f, -0.02219406f, 0.00263609f, 
    0.00750273f, 0.01394617f, -0.04746840f, 0.04787850f, -0.02469147f, -0.01854159f, -0.00097201f, 0.02973346f, 
    -0.05195881f, 0.04842997f, -0.00869688f, 0.01561304f, 0.04389416f, -0.01647294f, 0.00409254f, -0.02909546f, 
    -0.04001155f, -0.03757853f, 0.00182612f, -0.04124432f, -0.01442971f, 0.01331706f, 0.03471235f, -0.03215701f, 
    0.02548028f, 0.03946674f, 0.03937887f, 0.01013574f, -0.05874823f, -0.00859011f, -0.01733584f, 0.00465008f, 
    -0.04012994f, 0.02685600f, 0.05062818f, -0.03486204f, 0.04577194f, -0.03449507f, -0.01590932f, 0.04851818f, 
    -0.00752930f, -0.04592299f, -0.01156795f, -0.05158724f, 0.00741639f, -0.02402636f, -0.01575048f, 0.02730925f, 
    0.01080344f, 0.00367877f, 0.00771857f, -0.04947191f, -0.04786711f, -0.01394535f, 0.01814996f, -0.06658348f, 
    -0.06518668f, 0.04160279f, 0.01224457f, 0.04368282f, -0.00639338f, -0.02355392f, 0.02932684f, -0.00368099f, 
    -0.01490042f, -0.03454384f, 0.02100327f, 0.04382280f, -0.05054646f, 0.02670401f, 0.03152758f, -0.03757743f, 
    0.03277638f, -0.04050297f, -0.06861332f, -0.00098266f, -0.00697707f, 0.03518874f, 0.04680507f, 0.01341789f, 
    0.02946481f, 0.03608293f, -0.00549263f, -0.05061742f, -0.04152140f, -0.04194467f, 0.00646886f, -0.04687301f, 
    0.00601850f, -0.02457208f, -0.03261367f, -0.01900094f, 0.00454883f, -0.06146458f, 0.03338939f, -0.00958053f, 
    0.05338018f, -0.03827991f, -0.01826951f, 0.03080226f, 0.01889369f, -0.04712480f, -0.00491801f, -0.05208538f, 
    -0.02351494f, 0.04068325f, 0.01767077f, 0.00152212f, -0.05825901f, -0.04938731f, 0.03962138f, -0.03933951f, 
    -0.05670228f, -0.01071378f, -0.04192945f, 0.01702556f, 0.02945136f, 0.01402895f, -0.05470188f, -0.04480818f, 
    -0.05361833f, -0.03966709f, -0.06442346f, -0.03013697f, -0.04672198f, -0.05594066f, -0.03743410f, -0.05550024f, 
    0.01783376f, 0.04687990f, -0.00174945f, -0.02663888f, 0.03097184f, -0.05341991f, -0.00340728f, -0.01800865f, 
    -0.03071977f, -0.03518762f, 0.01104778f, -0.05097289f, 0.01024446f, 0.00496232f, -0.02579677f, -0.02517339f, 
    0.04424061f, -0.03390000f, -0.06036288f, -0.03844545f, 0.01561867f, -0.02080520f, 0.04571074f, -0.04319304f, 
    -0.00201928f, -0.03409358f, 0.01679018f, -0.02798228f, -0.06170446f, 0.00990675f, 0.04088209f, 0.03952628f, 
    -0.04884539f, -0.00731301f, -0.02868862f, 0.00516853f, 0.04839109f, -0.01344867f, 0.04245357f, -0.03846769f, 
    0.03466587f, -0.05381002f, -0.02319086f, -0.02278837f, 0.04959526f, -0.04236193f, 0.05028964f, -0.04038106f, 
    -0.03757974f, -0.02048543f, 0.04027240f, 0.01715040f, 0.05799016f, -0.02146012f, 0.00592540f, 0.02134563f, 
    -0.13803715f, 0.05382509f, 0.03595956f, 0.00859781f, 0.07025339f, 0.06619411f, -0.03123076f, -0.03702460f, 
    0.02439713f, -0.12836614f, 0.14342859f, 0.23262854f, -0.09335054f, -0.00355377f, -0.00590954f, -0.03469046f, 
    -0.19273366f, 0.15053621f, 0.23187010f, 0.04320799f, 0.15004113f, -0.07835542f, -0.07645459f, 0.00255570f, 
    -0.10353411f, 0.13953486f, -0.01551923f, 0.17446569f, 0.07102775f, 0.03955274f, -0.03330738f, -0.13298498f, 
    0.05385411f, 0.09329573f, 0.01509189f, -0.08222929f, 0.14629355f, -0.02558813f, 0.19280604f, -0.07326449f, 
    -0.04461806f, -0.00093816f, -0.05539267f, -0.08251346f, -0.01020693f, -0.12593311f, 0.17719388f, 0.23252283f, 
    0.10267607f, 0.09858881f, -0.14304869f, -0.03102717f, 0.04824890f, 0.08492633f, 0.11795150f, -0.15535051f, 
    -0.35407859f, -0.00596061f, -0.07366790f, -0.03684153f, -0.06509837f, 0.11955092f, -0.11100392f, -0.03392021f, 
    0.02213781f, -0.06323387f, 0.11354705f, 0.03658767f, 0.01399454f, -0.00830531f, -0.01921932f, -0.01602147f, 
    -0.10051431f, -0.01184695f, -0.03285955f, -0.10972697f, 0.01026802f, 0.02393348f, -0.10706695f, -0.03536402f, 
    0.08778563f, -0.03327037f, 0.02348596f, 0.02480896f, 0.04533489f, 0.09955323f, -0.12362597f, 0.17666784f, 
    -0.24663168f, -0.01844981f, -0.09719537f, 0.07926066f, 0.26025340f, 0.03342970f, -0.02784507f, -0.04107146f, 
    -0.07062096f, -0.03306193f, -0.00756382f, 0.21848419f, -0.01503979f, 0.08152173f, 0.12372237f, 0.08120232f, 
    0.09952529f, -0.10878468f, 0.06585907f, -0.00355275f, 0.01850940f, 0.40551499f, -0.06067749f, -0.07374989f, 
    0.19907099f, -0.05613289f, 0.02541989f, -0.04612026f, 0.06075179f, -0.32674578f, -0.01000507f, -0.17409530f, 
    0.12180462f, 0.02255577f, 0.11063115f, 0.04115719f, -0.06643436f, 0.08820921f, -0.01813717f, -0.16333134f, 
    -0.31436655f, 0.00927652f, -0.04542917f, 0.07629808f, -0.20050943f, 0.05017629f, 0.01262511f, 0.15238185f, 
    0.08668029f, -0.09407014f, -0.16260582f, -0.23959020f, -0.19691642f, -0.07704102f, -0.18867022f, -0.09954054f, 
    0.09359594f, -0.18651104f, 0.21493949f, 0.17987537f, 0.07496900f, -0.06034286f, 0.10685609f, 0.11326003f, 
    -0.04696144f, 0.24139230f, 0.18644245f, -0.02275372f, 0.01739697f, 0.12378782f, 0.12175714f, 0.13112435f, 
    -0.02114498f, -0.08028124f, 0.25055644f, -0.01487105f, 0.10373197f, 0.11590138f, 0.02095239f, 0.01050243f, 
    0.03504422f, 0.04552561f, 0.13283230f, -0.14875419f, -0.15988234f, -0.24558115f, -0.10871849f, -0.06485025f, 
    0.00170737f, -0.05967560f, -0.04187418f, 0.01919240f, 0.01101866f, 0.18985593f, -0.11778539f, 0.05442182f, 
    -0.00475841f, 0.14443201f, -0.01508098f, 0.06444024f, 0.05849605f, -0.00442074f, 0.02366589f, -0.30073443f, 
    0.08944760f, 0.12760845f, 0.02545944f, 0.14136198f, 0.10119547f, -0.02253049f, -0.38623351f, -0.37551907f, 
    -0.09503280f, -0.02327667f, 0.13121933f, 0.16750199f, -0.12244380f, -0.08537024f, 0.05670931f, -0.19546804f, 
    -0.31518209f, 0.44345781f, -0.08230326f, 0.08391688f, -0.09793133f, 0.01472691f, -0.09479793f, 0.15108015f, 
    0.12268806f, 0.09082726f, -0.04140373f, -0.08283719f, -0.05925450f, -0.02424097f, -0.01320589f, 0.05017508f, 
    -0.08558952f, 0.16370101f, 0.17056376f, 0.13099769f, 0.01422403f, 0.13737705f, 0.20033637f, 0.10427690f, 
    -0.05383345f, -0.14476499f, 0.25876662f, 0.08752290f, -0.14918493f, -0.10627960f, 0.00632521f, -0.09911504f, 
    0.04229026f, -0.03792285f, -0.10838106f, 0.18554319f, 0.12474568f, 0.05406950f, -0.06765639f, -0.08640555f, 
    -0.06495674f, -0.02432876f, 0.00930148f, -0.04070775f, 0.02707472f, 0.09812921f, 0.10919241f, -0.14568760f, 
    -0.11442520f, 0.06010376f, 0.02352681f, 0.11053728f, -0.09827100f, 0.10226235f, 0.05437253f, 0.10021663f, 
    -0.10331512f, -0.07630666f, -0.04447768f, 0.01174807f, -0.04194449f, -0.09748909f, 0.09591267f, 0.09870861f, 
    0.06200040f, 0.15649047f, 0.04409170f, -0.16131273f, -0.02779865f, -0.05516712f, -0.02201764f, 0.13058732f, 
    -0.02966243f, -0.39202258f, -0.03478045f, -0.07650000f, 0.10955875f, -0.16544463f, 0.00329957f, -0.02792040f, 
    0.11546020f, 0.04715412f, -0.00100352f, 0.08445416f, 0.00686365f, 0.09668896f, 0.08478300f, -0.04347932f, 
    0.20022400f, 0.26626542f, 0.03196600f, -0.27243072f, 0.00447405f, 0.07995417f, -0.09182568f, -0.01176949f, 
    -0.15205918f, 0.04224909f, -0.19990286f, 0.18719913f, -0.31687844f, -0.09332549f, -0.16476622f, 0.06729451f, 
    -0.21020617f, -0.02857191f, -0.13141553f, 0.00333387f, -0.08353978f, -0.00652470f, -0.08650714f, -0.15276930f, 
    -0.19273978f, -0.06567590f, -0.07897536f, -0.21112187f, 0.05083450f, 0.28379375f, -0.10654829f, 0.02518349f, 
    0.07236908f, 0.05583508f, 0.01922660f, 0.06877104f, 0.08372355f, 0.06183976f, -0.16148768f, 0.03527903f, 
    0.02036365f, -0.08355691f, -0.09855559f, -0.02821473f, 0.09168801f, -0.20700370f, -0.37966579f, -0.47666290f, 
    0.22817798f, 0.15626203f, -0.00416888f, 0.09785175f, -0.15037163f, -0.01572084f, -0.03473975f, -0.14659002f, 
    -0.08462062f, -0.00018637f, -0.15592857f, -0.06241323f, 0.00273635f, -0.16372907f, -0.13778207f, -0.08167513f, 
    0.11185277f, 0.11164299f, 0.17130300f, 0.06724449f, 0.01427747f, 0.00969333f, -0.11175728f, 0.01702593f, 
    -0.01200899f, -0.26395065f, -0.16085196f, -0.11918535f, -0.11390469f, -0.10146953f, -0.05689923f, 0.03795821f, 
    0.01739536f, -0.00423996f, 0.08710703f, 0.07524978f, 0.26691568f, 0.03328026f, -0.00111430f, -0.03905040f, 
    0.03873578f, 0.11366672f, -0.02740382f, -0.14834644f, 0.16155225f, -0.01168937f, 0.03290482f, 0.11228097f, 
    -0.09276097f, 0.19051686f, 0.13437301f, 0.08800255f, 0.17576928f, 0.00478528f, 0.05208645f, 0.01309766f, 
    -0.16851829f, 0.04148531f, -0.14077111f, -0.00035820f, -0.45148164f, 0.22330736f, 0.03015797f, 0.13078465f, 
    0.08829465f, 0.03043959f, 0.13225336f, -0.00986184f, 0.14346194f, -0.06186146f, -0.07376602f, 0.23882560f, 
    0.13725577f, 0.12261775f, 0.07940008f, -0.03431215f, 0.16260621f, 0.15078177f, 0.12122542f, -0.28370026f, 
    -0.06992181f, -0.15780069f, 0.04346479f, 0.12384534f, -0.01649282f, -0.18902065f, -0.12244654f, -0.06058909f, 
    0.05101128f, 0.22729541f, -0.07412004f, -0.02079583f, 0.11998354f, -0.00864734f, 0.06891801f, 0.09810546f, 
    0.08622134f, 0.12505326f, 0.25842607f, 0.13609116f, -0.00164960f, 0.05424070f, -0.22536092f, 0.10336339f, 
    0.12419912f, 0.00621730f, 0.17751628f, 0.21201514f, 0.16401716f, 0.07761358f, -0.14540824f, 0.00137512f, 
    0.05143554f, -0.19018015f, -0.01341560f, -0.03393563f, 0.03260216f, 0.07638510f, 0.18081211f, 0.07792894f, 
    -0.00857279f, 0.01762137f, -0.04196645f, -0.00499030f, -0.03646150f, 0.07105261f, -0.10685907f, -0.06868929f, 
    0.03308347f, -0.03080759f, -0.20850947f, -0.05909173f, -0.15793622f, -0.05392556f, 0.18888056f, -0.22159815f, 
    -0.02875531f, -0.18471946f, 0.00937869f, -0.15856676f, -0.06708940f, -0.06895988f, 0.11475687f, 0.10368520f, 
    0.13606445f, 0.14536068f, 0.19289118f, -0.04212593f, 0.08735927f, -0.01234940f, 0.05695186f, 0.42806950f, 
    0.09481508f, 0.11198145f, -0.16381699f, 0.06587709f, -0.12906097f, -0.09301961f, -0.04034433f, -0.01053986f, 
    0.09438694f, 0.05574536f, -0.12835245f, 0.05810893f, 0.07150416f, 0.08690373f, -0.16130966f, -0.15957958f, 
    -0.14547546f, -0.13658853f, 0.12042236f, -0.13180999f, 0.04050383f, 0.00608617f, 0.07139058f, 0.01339243f, 
    -0.22230305f, -0.14312549f, -0.19521725f, 0.05102717f, 0.11738246f, 0.03403954f, -0.01849630f, 0.00819755f, 
    0.02461601f, -0.03615862f, 0.04595048f, 0.09630968f, 0.23811327f, -0.07686519f, -0.06125758f, -0.08014450f, 
    -0.03052565f, 0.02340017f, 0.00432308f, 0.07824470f, 0.18045120f, 0.09168742f, -0.19897518f, 0.12404680f, 
    -0.09930740f, -0.14223814f, 0.06446556f, 0.02600687f, 0.04767647f, 0.16398476f, 0.12779480f, 0.00886105f, 
    0.03395978f, -0.00390142f, 0.04460704f, 0.01898973f, 0.02581741f, 0.03890860f, 0.13919303f, -0.00415987f, 
    -0.05854207f, 0.08933678f, -0.07307027f, -0.00521025f, -0.02430036f, 0.12202162f, 0.04204936f, -0.24219517f, 
    0.13096327f, 0.25074303f, 0.27282199f, 0.15885662f, 0.15480156f, 0.12610309f, 0.21739532f, 0.10750993f, 
    -0.18719713f, -0.04025326f, -0.02946278f, 0.09789854f, 0.11992504f, -0.11377566f, -0.10390326f, 0.02086115f, 
    0.08538328f, -0.40427941f, -0.13803840f, 0.01215780f, -0.11224321f, -0.06824852f, -0.15980032f, -0.01172405f, 
    0.10485010f, -0.02756226f, -0.05796982f, 0.17779040f, 0.36051473f, 0.01390452f, -0.07541746f, -0.20266223f, 
    0.07801894f, 0.16974814f, 0.05646683f, 0.20103425f, 0.31074235f, 0.09697041f, -0.13439699f, -0.16329890f, 
    0.25659469f, 0.07513836f, 0.03629365f, 0.12663992f, -0.11237670f, 0.03596841f, 0.33496973f, -0.02417156f, 
    -0.10943849f, -0.16135573f, 0.09854957f, -0.01387346f, 0.12609103f, 0.11403939f, 0.00262842f, 0.12193592f, 
    -0.00882921f, 0.16312522f, -0.13075887f, 0.12110791f, 0.05652587f, 0.02884065f, -0.27556944f, 0.10895553f, 
    0.05021936f, 0.02483267f, -0.08511857f, -0.13272189f, 0.01998585f, 0.01085091f, -0.00987839f, -0.29095227f, 
    0.19818313f, -0.09811675f, 0.28255600f, -0.20986357f, 0.03075881f, -0.04499190f, -0.06303708f, -0.01621759f, 
    0.07041553f, -0.01095473f, 0.29415178f, 0.01897909f, 0.00659995f, -0.05398991f, 0.10621013f, 0.11061653f, 
    -0.04762565f, -0.51940477f, -0.17581767f, -0.04734133f, -0.05858600f, 0.11844055f, 0.28532928f, -0.10544123f, 
    -0.10448128f, -0.09234524f, -0.05007062f, 0.13860035f, 0.13677378f, -0.07222202f, 0.15576738f, -0.01983291f, 
    0.02416677f, 0.05771911f, -0.02217946f, -0.28261912f, -0.11245866f, 0.16593003f, 0.11491009f, -0.09741263f, 
    0.14656420f, -0.17322516f, -0.03512150f, -0.13572457f, 0.03894527f, 0.02968607f, 0.24386536f, 0.03100029f, 
    0.16827810f, -0.03469172f, 0.03858771f, 0.18161498f, -0.02422920f, -0.15462959f, 0.26316306f, 0.21114594f, 
    0.02024410f, 0.05803470f, -0.05601681f, 0.06509506f, 0.07111410f, 0.07124165f, 0.01261240f, -0.20242880f, 
    -0.12118774f, 0.12840241f, -0.12480580f, -0.03249155f, -0.12736772f, -0.06898068f, 0.22697157f, 0.05314635f, 
    0.05841956f, -0.07099181f, 0.03072324f, -0.14566498f, 0.01262827f, 0.06605267f, -0.11970723f, 0.05158658f, 
    -0.09851746f, 0.14016986f, 0.33169892f, -0.04587930f, -0.07700451f, -0.09686917f, 0.04847054f, -0.10894231f, 
    -0.12876169f, -0.30740529f, -0.09084719f, 0.03954550f, 0.02173066f, 0.22456042f, 0.05016210f, 0.00013818f, 
    -0.04407938f, -0.10457258f, -0.11171152f, -0.08657636f, 0.11978158f, -0.09267883f, -0.11206008f, -0.10344046f, 
    0.03607002f, 0.01015540f, 0.00483484f, 0.17498073f, 0.26349333f, -0.10418232f, -0.13967454f, -0.02812768f, 
    0.11921147f, 0.05992917f, 0.14872260f, -0.05529950f, -0.29264638f, 0.16309768f, 0.09331929f, 0.17903028f, 
    0.11846945f, 0.07716995f, -0.02437789f, 0.05100163f, 0.02748400f, 0.09378526f, 0.42764422f, 0.08566013f, 
    0.02634789f, -0.15643227f, 0.00803194f, 0.12618074f, 0.07915532f, -0.01167415f, -0.12152560f, -0.06384759f, 
    -0.10536246f, 0.13285691f, 0.17018664f, 0.09644726f, -0.03829740f, -0.03647493f, -0.13076667f, -0.37765107f, 
    0.09337962f, 0.24696721f, 0.06386876f, 0.18642047f, -0.22572976f, -0.09633072f, 0.09307398f, -0.00002011f, 
    -0.01956878f, 0.00989464f, -0.14476170f, 0.11508427f, -0.11358117f, -0.18161047f, -0.00853314f, -0.03954221f, 
    0.03172153f, -0.07730411f, -0.11001886f, 0.04376715f, 0.04420631f, -0.10635334f, 0.20101076f, -0.01968069f, 
    0.17368470f, 0.06427248f, 0.04863748f, 0.03947615f, 0.03305412f, -0.06374238f, -0.12406455f, -0.04722307f, 
    0.09188540f, -0.03471891f, 0.10036010f, -0.13863906f, 0.16892096f, -0.01228352f, 0.01869849f, -0.02120875f, 
    0.00556150f, 0.04341080f, 0.14465861f, -0.09507015f, -0.37596679f, 0.34153658f, -0.51728493f, 0.09049177f, 
    -0.22249289f, -0.00285989f, -0.20726244f, 0.13771760f, 0.08033386f, -0.30516526f, 0.04505040f, -0.08019939f, 
    0.05818708f, 0.02625252f, 0.06549559f, 0.00709136f, -0.00415243f, -0.02640653f, -0.17404196f, 0.08740415f, 
    0.32507437f, 0.01689152f, 0.16215450f, -0.10051972f, 0.15426506f, 0.03137315f, -0.05723894f, -0.47272351f, 
    0.27597237f, 0.09871203f, -0.05775618f, -0.20342664f, -0.10656106f, -0.12710111f, -0.14742805f, -0.12857513f, 
    -0.40677530f, 0.13177806f, -0.00534163f, 0.23754816f, 0.14022797f, 0.06333630f, -0.09754053f, -0.04279695f, 
    0.04831867f, -0.44907114f, 0.18082820f, 0.21912873f, 0.14960162f, 0.08281416f, -0.09241410f, 0.03014738f, 
    0.14244604f, 0.01007748f, 0.11061370f, 0.05492092f, 0.13040294f, 0.03153322f, -0.03107424f, -0.01987239f, 
    0.01423993f, 0.08399832f, -0.11649694f, 0.40629402f, 0.35927555f, 0.06381584f, -0.16563705f, -0.04100003f, 
    0.08618513f, 0.19619165f, 0.17951606f, -0.22423500f, 0.15803881f, 0.07114334f, -0.00211131f, 0.06209804f, 
    -0.02841620f, -0.14830127f, 0.02645182f, 0.07525251f, 0.05775704f, -0.24029703f, -0.05778141f, 0.09727852f, 
    -0.13260196f, -0.01912989f, -0.46303681f, -0.04343469f, -0.10131948f, -0.04147375f, -0.21031854f, 0.09503351f, 
    0.00812325f, -0.12439191f, -0.11733966f, -0.04216107f, -0.09422000f, 0.15875676f, -0.15049626f, -0.15005572f, 
    0.12790887f, -0.01587873f, 0.05403065f, 0.06724443f, -0.29528499f, -0.01063729f, 0.06428464f, -0.11893522f, 
    -0.10709970f, 0.01563760f, 0.03853205f, -0.20920041f, 0.04033260f, -0.01819826f, -0.01383207f, 0.03458111f, 
    -0.06512831f, 0.03176383f, 0.09878340f, 0.09421093f, -0.14088809f, 0.01791058f, -0.00916129f, 0.05096409f, 
    -0.10750010f, -0.12693034f, -0.14190429f, -0.04262638f, 0.44245833f, -0.18612789f, 0.08670209f, -0.00716043f, 
    0.10801026f, -0.06807213f, 0.04600336f, 0.14543843f, 0.02165218f, 0.21733952f, -0.02706894f, 0.19067739f, 
    0.05401478f, 0.02291092f, 0.12611425f, 0.00286864f, -0.32452068f, -0.11818437f, -0.07885997f, -0.10342481f, 
    -0.16159810f, -0.34063005f, -0.24326883f, -0.07283732f, -0.08530535f, -0.20324616f, -0.10968989f, -0.00450779f, 
    -0.02886359f, -0.04394947f, -0.23190233f, 0.02573135f, -0.11176305f, 0.00752393f, -0.14333691f, -0.29477519f, 
    -0.14542772f, 0.03251345f, 0.21739693f, 0.02115741f, -0.09148923f, 0.12051746f, 0.34106681f, -0.05090030f, 
    -0.19080861f, -0.13643400f, -0.02422428f, -0.03985802f, -0.03801921f, -0.19198829f, 0.05832065f, 0.13199513f, 
    0.17795992f, -0.08873360f, 0.33387595f, -0.00417633f, 0.12063794f, 0.10827558f, -0.05791846f, 0.09442674f, 
    0.13445677f, 0.06863964f, -0.02706573f, 0.18399620f, 0.19107889f, -0.32512432f, 0.15874165f, 0.22665794f, 
    0.01072101f, -0.02692594f, 0.47047421f, 0.21595928f, 0.15251096f, 0.04743357f, -0.07107513f, 0.05039676f, 
    0.12085892f, 0.19459918f, -0.00047523f, -0.02181409f, 0.02080169f, 0.04389895f, 0.08674904f, -0.22736262f, 
    -0.09405362f, 0.07445814f, -0.11786475f, 0.13551407f, -0.09752571f, 0.05758705f, -0.15847659f, -0.09339834f, 
    -0.16175155f, 0.25434342f, -0.05004240f, -0.01753860f, -0.00138617f, 0.27519047f, 0.37469295f, -0.09341905f, 
    0.03336276f, -0.13698067f, -0.16050740f, -0.02681702f, 0.06810614f, -0.00575565f, -0.06390949f, -0.17050131f, 
    0.07245456f, 0.01237134f, -0.34995368f, 0.16791704f, 0.05214055f, -0.01171549f, 0.03554596f, -0.55587333f, 
    -0.00696692f, 0.29106030f, -0.05738698f, -0.12163358f, -0.23264943f, 0.13324761f, 0.07654314f, -0.03974015f, 
    0.06243396f, 0.12648951f, -0.00548743f, 0.10670184f, -0.09512690f, 0.09281835f, -0.06025464f, 0.21135542f, 
    -0.20107846f, 0.44023350f, 0.01519923f, 0.15743168f, 0.13286184f, 0.11275677f, -0.05620674f, 0.01563635f, 
    0.02574907f, -0.03887463f, -0.26200992f, 0.14155084f, 0.13851836f, 0.00707237f, -0.00570178f, 0.03107190f, 
    -0.00179056f, 0.08778848f, -0.00420015f, 0.09114313f, -0.04766443f, 0.07742340f, 0.05729147f, -0.03518165f, 
    -0.05142584f, 0.06269363f, 0.00966313f, 0.08123831f, -0.13135915f, 0.18082875f, 0.00039185f, 0.02066563f, 
    -0.13632263f, 0.03965332f, 0.00557215f, -0.01616778f, -0.02168080f, 0.02059882f, -0.02327252f, -0.02209119f, 
    0.08233359f, 0.06998315f, 0.02588602f, 0.01011351f, 0.03320103f, 0.11047786f, 0.02471424f, 0.12822728f, 
    0.01881091f, -0.01492680f, 0.01150410f, -0.40700656f, -0.01325022f, -0.07980683f, -0.11380212f, -0.09627665f, 
    0.01838880f, 0.16534622f, -0.03385672f, 0.17565699f, 0.14895801f, 0.00860690f, 0.08748386f, 0.13884676f, 
    0.02534683f, 0.02032956f, 0.13330700f, -0.07064367f, 0.05813064f, -0.10529824f, 0.11341598f, 0.08922625f, 
    0.17639560f, -0.21641594f, -0.09353629f, 0.01356524f, 0.03180021f, -0.13330816f, -0.08420012f, 0.05299337f, 
    -0.11922798f, 0.12574548f, -0.12555024f, -0.02837734f, 0.22693506f, 0.22619787f, 0.05121791f, -0.12020563f, 
    0.18389046f, -0.06509704f, 0.03572097f, -0.06037419f, -0.08497760f, -0.11553770f, 0.00387073f, 0.10663043f, 
    0.03736317f, 0.00307930f, 0.03628954f, -0.29444170f, -0.01187042f, -0.07499461f, -0.04513457f, 0.14364815f, 
    -0.16272783f, -0.05474025f, 0.15046029f, -0.07961398f, 0.12468641f, 0.21671358f, 0.17608993f, 0.30430719f, 
    -0.07420316f, 0.01941447f, 0.08918437f, -0.04626285f, -0.04797425f, 0.09741733f, -0.11440948f, 0.02432814f, 
    0.06534518f, 0.15472788f, 0.13264596f, 0.12038846f, 0.02983955f, 0.16494003f, 0.00041998f, 0.13085389f, 
    0.09823034f, 0.20572002f, 0.02574109f, -0.05668184f, -0.02617183f, -0.08945487f, -0.19197042f, -0.03586706f, 
    0.08268782f, 0.13535024f, 0.23228872f, -0.02201267f, 0.04234841f, -0.13622013f, 0.08082694f, -0.08890840f, 
    -0.09842690f, -0.68217826f, -0.20743409f, -0.34183329f, -0.02433171f, 0.14382106f, 0.01299137f, -0.00341738f, 
    0.04756479f, 0.00328096f, 0.19620441f, 0.19883630f, 0.16683181f, 0.02011542f, 0.05742691f, -0.26688844f, 
    -0.01307071f, -0.06292485f, -0.03870587f, -0.10393570f, 0.01285164f, -0.06574998f, -0.06488434f, -0.05284505f, 
    0.11295647f, -0.07283758f, 0.17513150f, 0.08046886f, 0.23083463f, 0.28928018f, 0.24343275f, -0.10964512f, 
    -0.10178615f, 0.00604458f, -0.14247678f, -0.02117896f, -0.01458369f, 0.07821745f, 0.16961920f, 0.23720649f, 
    -0.13093254f, 0.09199059f, -0.10373005f, 0.00401125f, 0.04762746f, -0.06619593f, 0.31226265f, -0.00241473f, 
    0.21665977f, 0.10045732f, -0.06327456f, -0.05462253f, 0.08753726f, 0.06702881f, -0.00119274f, -0.04670281f, 
    -0.35030773f, -0.11425662f, -0.06054879f, -0.11609513f, -0.05756288f, 0.15740412f, -0.01152245f, 0.13538440f, 
    0.10590721f, -0.00433435f, 0.18342429f, 0.07661325f, 0.08251769f, -0.00028853f, 0.06638404f, 0.02609651f, 
    0.16063516f, -0.17201799f, -0.03863987f, -0.45278355f, -0.06418389f, -0.03520328f, 0.15021849f, -0.09777194f, 
    0.09607531f, 0.05269740f, -0.26151067f, 0.00809832f, -0.29711428f, -0.00724496f, -0.13013223f, 0.09314258f, 
    0.01238323f, 0.06831176f, 0.11459281f, 0.03425118f, 0.09740992f, 0.24239025f, -0.05641089f, 0.08681346f, 
    0.15717807f, 0.10109781f, -0.00652511f, 0.19369458f, 0.01289287f, 0.14089006f, -0.00369844f, -0.00758963f, 
    0.08672257f, 0.23079568f, -0.09415395f, 0.17547937f, -0.14892511f, -0.24512924f, -0.50576013f, -0.03737530f, 
    -0.03938779f, 0.02976545f, -0.02480014f, -0.04932298f, 0.00345985f, -0.09772093f, 0.05924623f, 0.25807765f, 
    0.05667262f, -0.01747926f, 0.12123390f, 0.10718147f, -0.02384764f, -0.05204013f, -0.03186327f, -0.20497110f, 
    0.07894681f, 0.11384562f, -0.01742085f, -0.09920519f, -0.04434144f, 0.02500973f, 0.02143674f, 0.07187293f, 
    -0.10858887f, -0.30114025f, -0.17849396f, 0.06438134f, 0.07864689f, 0.09925028f, -0.11587497f, -0.06195481f, 
    0.02805097f, -0.23714510f, -0.21821886f, -0.08206702f, -0.03761406f, -0.12230713f, -0.01313149f, -0.10101221f, 
    -0.16293919f, 0.07003326f, 0.24306616f, 0.15540807f, 0.24006066f, 0.04133173f, 0.01745894f, 0.02851579f, 
    0.04546130f, -0.01367558f, -0.11214679f, 0.01659972f, -0.20537870f, -0.03826628f, 0.00136130f, -0.10519596f, 
    -0.09985600f, 0.08907378f, -0.07171326f, 0.08804776f, -0.30142656f, -0.04968771f, 0.04309105f, 0.05214809f, 
    -0.01036227f, -0.14893615f, 0.05230337f, 0.11131074f, 0.33734807f, 0.01227847f, -0.18874322f, -0.21461467f, 
    -0.04886754f, 0.01291507f, 0.04393366f, 0.04407971f, -0.01143258f, 0.20036957f, -0.22774033f, 0.09492951f, 
    0.10202919f, -0.27265343f, 0.10192274f, -0.02806831f, -0.18602680f, 0.02076826f, 0.00585781f, 0.20763555f, 
    -0.02977372f, 0.09226499f, 0.03003739f, 0.01698972f, -0.09625175f, 0.02502809f, 0.10537688f, -0.15985993f, 
    0.10315442f, -0.00259013f, -0.11473746f, -0.01660681f, 0.07893623f, -0.00519789f, 0.07886802f, 0.01411472f, 
    0.13841206f, 0.33327365f, 0.14802028f, 0.00712775f, 0.06045733f, 0.01918149f, -0.07385886f, 0.13583653f, 
    0.05890811f, 0.13935074f, -0.06887882f, 0.11177327f, -0.11288955f, -0.01000702f, -0.05957482f, -0.02567976f, 
    0.10766633f, -0.03151799f, -0.08445882f, 0.06092707f, -0.12897940f, 0.10856923f, 0.05274991f, 0.03355942f, 
    0.06314433f, -0.14490195f, -0.13097943f, -0.40267229f, 0.03398769f, 0.01569959f, -0.11358293f, 0.05580795f, 
    0.02934216f, -0.04943337f, 0.02542736f, 0.03723748f, -0.08139271f, 0.10399627f, -0.08787756f, 0.09286546f, 
    0.10373031f, 0.00002906f, 0.03652942f, -0.21603724f, 0.21378045f, -0.31881365f, 0.02657351f, -0.04349477f, 
    0.04697007f, -0.06193062f, 0.05857091f, 0.14308180f, 0.00480368f, -0.01103345f, -0.09363978f, -0.09545811f, 
    0.06317380f, -0.07471580f, -0.02251652f, 0.10351893f, 0.02088835f, -0.18163227f, -0.13252789f, -0.28000313f, 
    0.14265826f, 0.05703415f, 0.11692226f, 0.15011664f, 0.06426959f, 0.05685969f, -0.00377955f, -0.11835763f, 
    0.03390444f, 0.29245496f, 0.08140307f, 0.11278123f, -0.00676882f, -0.27219787f, -0.13982636f, -0.00123813f, 
    0.01958091f, -0.03664600f, 0.11458680f, 0.07804956f, 0.27243769f, 0.24230948f, -0.06573424f, 0.03969568f, 
    0.16050249f, 0.09087929f, 0.03267667f, -0.22650887f, -0.07569571f, -0.12527061f, -0.08408485f, 0.03788729f, 
    -0.00505009f, 0.12162381f, 0.14723770f, 0.12977445f, 0.09225465f, -0.13528100f, -0.01597524f, 0.16618848f, 
    -0.16528104f, -0.12580787f, -0.00136589f, 0.16110151f, -0.35528284f, -0.02667875f, -0.02431477f, 0.03263087f, 
    0.02522251f, 0.03066713f, -0.01764411f, 0.02230843f, -0.01472552f, -0.08182817f, -0.08786615f, 0.04517852f, 
    -0.00569165f, 0.05422413f, 0.08142794f, 0.12307644f, 0.10470990f, 0.12072261f, 0.18633859f, -0.05469040f, 
    0.05623657f, -0.34633678f, -0.06677185f, 0.16436504f, 0.06097698f, -0.20838527f, 0.02957790f, 0.05857304f, 
    -0.02804537f, 0.04415930f, 0.16347031f, 0.15577456f, 0.09350579f, 0.08817528f, -0.07115893f, -0.09145232f, 
    0.17089687f, -0.17584631f, 0.05952401f, -0.11170849f, 0.17698514f, -0.21918245f, -0.02766637f, 0.15769681f, 
    -0.05073023f, 0.06761187f, 0.38198802f, 0.39996782f, 0.14599694f, 0.01978747f, -0.10536854f, 0.09100190f, 
    -0.19145790f, -0.04366489f, -0.01757736f, -0.01334278f, 0.02526485f, 0.01422447f, 0.11554931f, 0.07267205f, 
    0.12100032f, -0.03838149f, 0.02689723f, 0.07316313f, -0.00918023f, 0.05941507f, -0.26579192f, 0.06100763f, 
    -0.08433603f, -0.13414942f, -0.09789275f, -0.01620115f, -0.32891795f, 0.04350751f, 0.28531641f, -0.22578952f, 
    0.05184818f, 0.00556128f, -0.01235451f, -0.04651772f, -0.04447338f, -0.09608063f, 0.11469223f, 0.06396970f, 
    -0.01768066f, 0.23773867f, -0.16653238f, -0.02523166f, 0.14018199f, -0.09884023f, 0.15905316f, 0.53372812f, 
    0.00660574f, -0.10224177f, 0.12156481f, -0.13469817f, 0.13326056f, 0.02970049f, 0.04448315f, 0.04741688f, 
    -0.07639267f, -0.05996367f, -0.30947223f, 0.14751802f, 0.04785037f, 0.02731196f, -0.38082170f, 0.00890005f, 
    -0.18360101f, -0.12108240f, 0.12604570f, -0.13449788f, -0.01013587f, -0.07658353f, -0.07290941f, -0.27267116f, 
    -0.06263046f, -0.05087421f, -0.01850171f, -0.06712975f, 0.13995194f, 0.02752670f, 0.05942247f, 0.08552644f, 
    0.08261164f, -0.07594801f, -0.01830571f, 0.13159063f, -0.01986834f, -0.27613464f, -0.00925916f, 0.02867348f, 
    0.07353277f, -0.05446898f, -0.24805295f, 0.06090248f, 0.16543658f, 0.12566341f, -0.42681652f, 0.01902979f, 
    0.11960638f, 0.00193841f, -0.01816253f, -0.13094516f, 0.04167202f, 0.12962930f, -0.10728041f, -0.35164997f, 
    0.00050230f, 0.06069575f, 0.01524440f, -0.05766436f, -0.09920707f, -0.08506630f, 0.09657389f, -0.21459652f, 
    -0.05116697f, 0.14187855f, -0.09638981f, -0.00920229f, -0.00564135f, -0.13082169f, -0.16836874f, -0.19957204f, 
    -0.01005063f, 0.00423477f, 0.14226870f, 0.18288302f, 0.12860301f, -0.00757731f, 0.16270564f, 0.15232055f, 
    0.39369503f, -0.08742975f, 0.02825741f, 0.00063248f, -0.08505185f, -0.09761388f, 0.05774548f, 0.04362505f, 
    0.16334364f, 0.24052389f, -0.04251640f, 0.16901274f, -0.09346899f, -0.09582530f, -0.25051796f, 0.03116923f, 
    0.04572578f, 0.08825913f, -0.08443229f, -0.05715450f, 0.01406447f, 0.15488978f, 0.06018600f, -0.15505546f, 
    0.03175640f, 0.06762369f, 0.18845180f, -0.22055067f, -0.04459757f, -0.01967967f, 0.12065843f, 0.04724646f, 
    -0.14829275f, -0.16590366f, -0.03917800f, -0.18136649f, 0.02330784f, -0.01294869f, 0.03388492f, 0.18407708f, 
    0.10270574f, -0.09644290f, 0.05286767f, 0.10024249f, 0.14292695f, 0.15662678f, 0.14348388f, 0.08845679f, 
    -0.06783394f, -0.04080515f, -0.10088957f, 0.15798348f, 0.03039801f, 0.08497875f, 0.25210640f, 0.02387319f, 
    -0.03722949f, 0.13460322f, -0.08023591f, 0.08537344f, -0.06119977f, 0.09451551f, -0.02465921f, 0.19424120f, 
    0.06266624f, 0.00347048f, -0.08032883f, 0.20423931f, 0.01940166f, 0.07355637f, -0.02108140f, -0.02807569f, 
    0.12375262f, 0.03360851f, -0.16151126f, -0.09144254f, 0.02137818f, -0.01300451f, -0.13736217f, -0.11309200f, 
    -0.05086309f, -0.27543604f, -0.05708804f, 0.01218587f, -0.07265196f, -0.12061986f, -0.07548871f, 0.18498878f, 
    0.49832150f, 0.01398530f, 0.19185853f, -0.05325347f, 0.00134482f, -0.03299281f, -0.01403384f, -0.07239789f, 
    -0.19815177f, -0.10738452f, -0.17111260f, -0.11520994f, -0.04415590f, -0.06758242f, 0.01902877f, -0.04992156f, 
    0.01940601f, 0.04253890f, 0.29387137f, -0.07287293f, 0.38729560f, 0.03097265f, -0.17317253f, 0.02268604f, 
    -0.06680836f, -0.16301936f, 0.07150411f, 0.05781749f, 0.10342468f, 0.06769987f, -0.18287744f, -0.24163955f, 
    0.01798698f, -0.12468696f, -0.00126495f, -0.02405268f, -0.04699535f, 0.04886642f, 0.11518260f, 0.00496592f, 
    -0.00713243f, -0.00024345f, -0.10124914f, 0.31370857f, -0.05447029f, 0.07193957f, 0.27675331f, 0.13649923f, 
    0.19955525f, -0.10867365f, -0.42211840f, -0.40249652f, 0.08463056f, -0.03937633f, 0.02282116f, 0.08930358f, 
    -0.24601668f, -0.18502557f, 0.05000323f, 0.03866221f, -0.03871312f, -0.04478891f, 0.03730812f, -0.07801912f, 
    0.06265777f, -0.09649097f, -0.02220106f, -0.34047976f, -0.08928444f, 0.01686999f, 0.23365183f, 0.20867985f, 
    -0.04238652f, 0.00630094f, -0.00043382f, 0.09944710f, 0.17289396f, -0.05959787f, 0.10500433f, -0.01075588f, 
    -0.14803527f, -0.09582083f, 0.07425071f, 0.11818933f, 0.04180464f, -0.01725760f, 0.02211333f, -0.01164412f, 
    -0.06723319f, 0.09509870f, -0.21550088f, -0.02850664f, 0.30509409f, -0.02960302f, -0.33087841f, -0.08513506f, 
    0.07850767f, -0.13452075f, 0.09210654f, 0.04822199f, 0.03728352f, -0.05497405f, -0.14206383f, -0.19481112f, 
    0.14304435f, 0.11063086f, 0.00977286f, -0.21899435f, -0.03517344f, -0.07620553f, -0.15054022f, -0.30482846f, 
    -0.14713624f, -0.11831665f, 0.10168016f, 0.06581013f, -0.08654924f, -0.06116921f, 0.03266408f, 0.36738208f, 
    -0.06512640f, 0.19603774f, -0.04682706f, -0.00844712f, -0.11263958f, 0.02097266f, -0.10302350f, 0.11763433f, 
    -0.11276553f, 0.12133358f, -0.04700409f, -0.08215150f, -0.18458258f, -0.28126737f, 0.16710770f, -0.08928243f, 
    -0.03916391f, 0.07298823f, 0.06458994f, 0.05157609f, -0.05223486f, 0.04281101f, 0.09063862f, -0.02484551f, 
    0.01292872f, 0.02299215f, 0.52287257f, 0.13515565f, 0.10250972f, -0.08126140f, -0.04838360f, -0.03136390f, 
    -0.12235209f, -0.11276556f, -0.10857358f, 0.04368308f, 0.04320114f, -0.00070942f, 0.01257800f, -0.05124502f, 
    -0.13213862f, 0.13850671f, 0.01487049f, 0.06529846f, 0.10570957f, -0.17832948f, 0.07793309f, -0.05878541f, 
    0.11150333f, -0.03174853f, -0.13864444f, 0.11295021f, -0.07219470f, 0.12451966f, 0.02471338f, 0.03680446f, 
    -0.19856317f, -0.16337799f, -0.14505801f, 0.06580858f, 0.00400825f, -0.01650892f, -0.08919767f, -0.16654804f, 
    -0.02190419f, 0.04178783f, 0.06718212f, -0.00994245f, 0.00193335f, -0.00094181f, -0.05872527f, 0.17565611f, 
    0.07796907f, -0.09435078f, -0.18314202f, 0.25004700f, 0.13153565f, 0.01209165f, 0.25773364f, 0.00977679f, 
    0.03851285f, 0.03988677f, 0.05183478f, 0.05089018f, -0.14407505f, 0.23321630f, -0.23537727f, -0.12952714f, 
    -0.19455288f, 0.20085011f, -0.11059196f, 0.04594193f, 0.07233010f, -0.09718467f, 0.19942422f, -0.06976381f, 
    -0.19809851f, -0.25991815f, -0.18439043f, -0.01339313f, -0.02271206f, 0.01619114f, -0.05193843f, 0.00835385f, 
    -0.00008975f, 0.01398645f, -0.21683162f, -0.00195314f, -0.05456722f, 0.11419680f, 0.02362943f, 0.04815388f, 
    -0.16374420f, -0.05494363f, -0.06981303f, 0.24765635f, -0.01070642f, -0.02702218f, -0.04421889f, 0.06644177f, 
    -0.02966597f, 0.07511681f, -0.07779305f, 0.04740545f, -0.35217413f, 0.01396601f, -0.11764523f, -0.37536487f, 
    0.12897894f, 0.10729733f, -0.13441598f, 0.26157928f, 0.07491074f, 0.12356433f, 0.06336712f, 0.08085106f, 
    0.13063003f, -0.00712621f, 0.08601206f, -0.09632242f, -0.02047036f, -0.05807994f, 0.03274340f, 0.09650154f, 
    -0.12188399f, -0.16163473f, 0.00869152f, -0.13108422f, -0.28101763f, 0.18207924f, 0.12630069f, 0.15188609f, 
    -0.38840070f, -0.18196912f, -0.15838605f, 0.08483089f, 0.02120503f, 0.03984248f, 0.08819041f, 0.02493473f, 
    -0.04409577f, 0.06779878f, 0.27751979f, -0.03734389f, 0.04046179f, -0.09754790f, 0.01785634f, -0.28014499f, 
    0.06377815f, -0.18912725f, -0.16480516f, -0.15297253f, -0.19221194f, 0.11579701f, 0.01734983f, -0.00377783f, 
    0.09738518f, -0.11204315f, -0.00041403f, 0.05325407f, 0.19406292f, 0.12104606f, 0.13582408f, 0.08030438f, 
    0.09799888f, -0.03297922f, 0.05452244f, 0.01079909f, -0.18586400f, 0.08497313f, -0.04267821f, -0.03191157f, 
    -0.10059005f, -0.12695055f, 0.27033389f, 0.14243522f, 0.01559690f, 0.08085137f, 0.00322996f, 0.12013865f, 
    0.13078773f, 0.18523560f, -0.02458392f, 0.11107154f, 0.02085830f, 0.02217577f, -0.34363452f, -0.08217973f, 
    -0.02415220f, -0.15551686f, 0.04431642f, -0.19422704f, -0.27651575f, -0.32528555f, -0.18723379f, -0.12401600f, 
    -0.01350093f, 0.00317701f, 0.09972379f, 0.28952137f, 0.14033170f, 0.00444819f, 0.13555983f, -0.00065058f, 
    -0.02047676f, 0.19960664f, 0.02384587f, 0.21494660f, 0.11908700f, 0.05742873f, 0.14638138f, -0.09578102f, 
    0.27395186f, -0.17526555f, 0.35008499f, 0.33505464f, 0.04007681f, 0.31287134f, 0.07095985f, 0.00710813f, 
    0.17091124f, -0.00997891f, -0.23457417f, 0.05807283f, 0.04553272f, 0.12390426f, 0.01724977f, 0.07508557f, 
    -0.04093676f, 0.05333070f, -0.12605122f, -0.12084190f, 0.20330435f, 0.01363252f, -0.02397463f, 0.07211895f, 
    -0.00124578f, 0.03907109f, -0.04100391f, -0.06944477f, 0.03979729f, 0.22597115f, 0.00054141f, 0.00245027f, 
    -0.07542348f, -0.09551124f, 0.24174404f, 0.26989499f, -0.07846514f, 0.03918256f, 0.02982458f, 0.33498961f, 
    -0.07140175f, 0.07714073f, -0.26865155f, 0.02118203f, 0.02608070f, -0.02043677f, -0.24356191f, 0.05976395f, 
    0.08622347f, 0.12320036f, 0.02820305f, 0.08735081f, -0.06890970f, 0.08374572f, 0.13144924f, -0.36375773f, 
    0.04250546f, -0.09716740f, 0.29521924f, -0.09905668f, 0.00055438f, -0.02228769f, -0.08575285f, -0.06575819f, 
    -0.13619559f, -0.04400520f, -0.06613330f, 0.18140136f, 0.11890902f, 0.05615851f, -0.04061802f, -0.03396138f, 
    0.06578165f, -0.06901815f, -0.08988693f, -0.08896177f, -0.03599556f, 0.00317524f, -0.20368232f, 0.19549365f, 
    0.18438967f, 0.10408776f, -0.20273402f, -0.27966353f, 0.07712916f, -0.03088763f, -0.13528711f, -0.00375281f, 
    0.00585992f, 0.11426757f, 0.00734373f, 0.03119426f, 0.02198210f, -0.01882248f, 0.19709620f, 0.12290374f, 
    0.00145208f, -0.01061877f, 0.06358172f, 0.14565435f, 0.24926472f, -0.11982043f, 0.05934292f, 0.13080914f, 
    -0.01087949f, 0.07660404f, -0.03620216f, -0.09714206f, 0.03891325f, 0.06313922f, 0.01336939f, -0.01359039f, 
    0.16633971f, 0.07235480f, 0.09834474f, 0.00878244f, 0.10748501f, 0.12959862f, 0.08399623f, -0.04263250f, 
    -0.01175731f, -0.18379594f, -0.05148770f, -0.01704216f, -0.04481715f, 0.20975062f, -0.07065947f, -0.02511866f, 
    0.03222028f, 0.17223659f, 0.01353842f, 0.20626836f, -0.06868885f, -0.12990706f, -0.00501054f, -0.07807404f, 
    -0.26663041f, -0.03794581f, -0.03083015f, -0.06043898f, 0.08384566f, 0.01953056f, 0.00806807f, -0.05253533f, 
    -0.15114230f, -0.18895662f, -0.07162809f, 0.14439109f, -0.04941097f, -0.13498151f, -0.02331780f, 0.05698744f, 
    -0.02465020f, -0.15440251f, -0.01966707f, -0.00934088f, -0.05142779f, 0.12146994f, -0.01563039f, -0.08031078f, 
    0.06950980f, -0.12649196f, -0.10206506f, 0.05921414f, 0.08595037f, 0.21902274f, -0.09719137f, 0.19034888f, 
    0.10641880f, 0.11442892f, -0.08506235f, 0.13142024f, -0.02855817f, 0.05535716f, 0.06231855f, 0.03060361f, 
    -0.17554963f, -0.12392532f, 0.03055118f, -0.18165226f, -0.02773184f, 0.04186400f, 0.44004086f, 0.27854764f, 
    -0.08597832f, 0.24535622f, -0.00083992f, 0.06375339f, 0.13031371f, 0.16664131f, 0.12905499f, -0.13001454f, 
    -0.18037216f, -0.08513811f, -0.15671998f, 0.04660630f, 0.05319634f, -0.04681349f, 0.13731894f, 0.08561654f, 
    0.22478811f, 0.30238971f, -0.07049308f, -0.23442911f, -0.01294546f, -0.00439802f, -0.00984380f, 0.00243362f, 
    0.05392410f, 0.11447550f, 0.20848669f, 0.01423744f, 0.07053888f, 0.18587029f, 0.05763156f, -0.11322665f, 
    -0.09253143f, 0.45750326f, -0.33242512f, -0.14021458f, 0.00243109f, -0.12346088f, 0.21570733f, 0.07643506f, 
    -0.08692381f, -0.21917802f, 0.21531072f, 0.16560857f, 0.06545084f, -0.03963538f, 0.12585114f, 0.04075478f, 
    0.05140354f, -0.08898554f, 0.02392544f, 0.03298562f, -0.30624470f, -0.29558274f, -0.10004382f, 0.01421274f, 
    0.09238666f, -0.03447773f, 0.00556200f, 0.16768499f, 0.11631429f, 0.41832834f, 0.30825570f, -0.23154651f, 
    0.06679939f, 0.00530615f, 0.18951696f, 0.12945729f, 0.18220741f, 0.06627496f, 0.16667293f, 0.17183518f, 
    0.00719089f, 0.04574535f, -0.02532296f, -0.08440018f, 0.05015615f, -0.02181637f, -0.01739766f, -0.39311215f, 
    -0.22225662f, 0.09263855f, 0.01984324f, 0.00190714f, -0.03461246f, 0.05937159f, -0.10788190f, 0.16883506f, 
    -0.02244714f, -0.39327860f, -0.08322341f, -0.01279221f, 0.13714290f, 0.12005755f, -0.06748948f, 0.03553816f, 
    0.11232167f, 0.04868533f, -0.08611950f, 0.14296657f, 0.04117722f, -0.04660930f, 0.12054744f, -0.16257508f, 
    -0.07024703f, 0.29109120f, 0.00566254f, -0.89460808f, 0.00208816f, 0.21345839f, -0.00489693f, -0.04545027f, 
    0.46443295f, 0.16363254f, 0.09384666f, -0.31179699f, -0.32685921f, 0.14396797f, 0.06718554f, -0.20342386f, 
    -0.04525724f, 0.09169675f, -0.05426942f, 0.02830489f, 0.21619660f, 0.25116086f, -0.04398455f, 0.07500973f, 
    0.07112637f, -0.05924859f, 0.16065082f, -0.00025613f, 0.07288059f, 0.10946448f, 0.07542372f, -0.15060462f, 
    0.18259120f, 0.15027408f, 0.05569366f, 0.16840936f, -0.07446077f, -0.15060425f, -0.40625092f, -0.01371204f, 
    0.03769048f, -0.00453292f, -0.12204545f, -0.07460197f, -0.08026132f, 0.00771595f, 0.06608570f, 0.25259316f, 
    0.15273523f, 0.01930195f, 0.04743170f, 0.20082830f, 0.10941967f, 0.00861148f, -0.02150705f, -0.25929266f, 
    -0.09297345f, -0.01281064f, -0.09855139f, 0.09549154f, 0.01935608f, 0.05315460f, 0.03844390f, -0.16975129f, 
    -0.10395679f, -0.21742806f, -0.21907954f, -0.15701516f, 0.08641337f, 0.09100448f, 0.23626544f, -0.00629707f, 
    0.01815796f, -0.44177923f, -0.27630419f, -0.12805414f, 0.02226603f, -0.04810325f, -0.07283472f, 0.03038725f, 
    0.10173500f, 0.16539001f, 0.11830094f, 0.03192153f, 0.13210598f, 0.06549655f, -0.02113837f, 0.00175785f, 
    0.11585297f, 0.05229463f, 0.02868046f, -0.11997796f, -0.25026590f, -0.58092004f, 0.08018930f, -0.15486148f, 
    0.12908182f, 0.00498066f, 0.08304072f, -0.00018374f, -0.44804072f, -0.20763598f, -0.12873672f, -0.07759200f, 
    -0.03824262f, 0.00762261f, 0.03817396f, -0.00288019f, 0.00239221f, 0.05774310f, -0.11406157f, -0.32800728f, 
    -0.04427268f, -0.09807470f, 0.04938809f, 0.08818603f, 0.12832788f, 0.09191941f, -0.41167951f, -0.28502378f, 
    0.13481607f, 0.11237963f, 0.04450781f, 0.02774874f, -0.23492081f, -0.05563286f, -0.03150523f, -0.26252773f, 
    -0.48675606f, -0.14106628f, 0.04188712f, -0.03113396f, -0.00690702f, -0.10117120f, 0.00133939f, -0.05374782f, 
    0.20989639f, 0.10816403f, -0.14657506f, -0.05501476f, 0.05276868f, 0.24731092f, 0.10996063f, 0.09005257f, 
    0.18753673f, -0.14553596f, 0.04487351f, -0.26868778f, -0.13537365f, -0.07232559f, -0.01049493f, -0.02823847f, 
    0.01778440f, 0.21430027f, -0.20103800f, -0.24637975f, -0.11812664f, -0.03526727f, -0.08128503f, -0.05482822f, 
    0.05799785f, 0.00733871f, 0.17660144f, -0.14214388f, -0.31138611f, -0.06108573f, -0.04635835f, -0.17633103f, 
    0.00860897f, -0.13264178f, 0.04465166f, -0.02483851f, -0.05083029f, 0.07074367f, 0.05694444f, -0.04164590f, 
    -0.01086604f, -0.10253166f, -0.02835806f, -0.10773309f, 0.13544400f, -0.25566047f, -0.25659367f, -0.11891255f, 
    -0.07316753f, 0.14265618f, -0.06508317f, 0.01829866f, -0.01440972f, 0.02622670f, -0.24713606f, 0.37665024f, 
    0.38851956f, 0.03932772f, 0.07820980f, 0.02693091f, -0.03752579f, 0.03452812f, 0.04827548f, -0.09942823f, 
    0.16487387f, -0.15420158f, -0.21206966f, -0.01163768f, 0.01812940f, 0.02381908f, 0.19583000f, 0.09667163f, 
    -0.25334668f, -0.25317362f, -0.30349895f, -0.01227699f, -0.10783851f, 0.03309239f, 0.05550247f, 0.00465077f, 
    0.09922558f, -0.36999571f, -0.16627508f, -0.35443696f, 0.01467202f, -0.08031098f, 0.12557140f, -0.11201932f, 
    -0.16570963f, -0.05213322f, -0.12794937f, -0.19123656f, -0.12851092f, -0.06330372f, -0.15811951f, -0.00152005f, 
    0.12471619f, 0.01260154f, -0.00830647f, 0.37821683f, 0.32291716f, 0.05520305f, 0.09695183f, 0.06269965f, 
    0.06860936f, 0.22306766f, 0.06165319f, 0.07839931f, -0.36412817f, -0.32572329f, -0.05125175f, -0.06536410f, 
    0.06814969f, -0.04932605f, 0.10110693f, -0.00430787f, -0.01786626f, 0.16977730f, -0.13867745f, -0.26297754f, 
    0.07721500f, 0.11323741f, 0.10760508f, 0.16327839f, 0.07815965f, 0.17480773f, 0.10515437f, -0.21996285f, 
    0.13719566f, -0.18364970f, -0.12920268f, -0.11574110f, 0.14304952f, 0.03060328f, 0.09886368f, -0.30845430f, 
    -0.12455803f, -0.00510207f, -0.15189649f, -0.19268818f, -0.12101831f, 0.01310930f, -0.01593148f, -0.01157312f, 
    0.11893309f, -0.04036165f, -0.08295317f, 0.05278520f, -0.03239944f, 0.17243667f, 0.20365015f, 0.09100608f, 
    0.15663537f, 0.35737571f, -0.15899089f, -0.36452627f, 0.15138970f, -0.00703541f, 0.10519850f, 0.11317389f, 
    0.02984087f, 0.07645847f, -0.24619752f, -0.48855841f, 0.01141563f, 0.10842802f, 0.13075681f, 0.03758598f, 
    0.21614732f, 0.11454839f, 0.09055045f, -0.41826764f, 0.02965224f, 0.33132032f, 0.05124222f, 0.09418914f, 
    -0.06141728f, 0.15779947f, 0.03490163f, 0.12697783f, -0.02141906f, 0.02184924f, -0.20205043f, 0.00213298f, 
    0.13920645f, 0.08909288f, 0.17087887f, 0.09206940f, 0.05163673f, -0.01505785f, -0.59578413f, -0.24526741f, 
    -0.10146522f, -0.02378192f, 0.02823532f, 0.07284820f, 0.15010446f, -0.03432828f, -0.00596476f, -0.13894705f, 
    -0.18589844f, -0.00846715f, -0.02269016f, -0.07214835f, -0.01317740f, 0.02381089f, 0.07671472f, -0.66498840f, 
    -0.72374701f, -0.36944854f, -0.09245095f, 0.02151052f, -0.26512468f, 0.10512444f, -0.00613785f, -0.10667288f, 
    -0.23330012f, -0.17818423f, 0.01214500f, -0.08001904f, 0.01964972f, 0.03239617f, -0.08250418f, 0.13366038f, 
    -0.00631529f, 0.37490612f, 0.00808844f, -0.12131591f, 0.01383053f, 0.06837454f, -0.04729499f, -0.04881274f, 
    0.18642466f, -0.00915265f, -0.36776727f, -0.06436370f, 0.00702722f, -0.11551738f, 0.00970699f, 0.02594188f, 
    0.03679113f, -0.01892584f, 0.03753985f, 0.07600018f, 0.00184829f, 0.00424619f, -0.01961266f, -0.02859159f, 
    -0.02559090f, 0.07391255f, 0.00098997f, 0.07785324f, -0.25696459f, -0.11672407f, -0.14288011f, -0.20077918f, 
    0.07142086f, 0.13619620f, 0.05009072f, 0.12352867f, 0.10753128f, 0.07233433f, 0.02994653f, 0.08282265f, 
    -0.01533704f, -0.03479952f, 0.03079157f, 0.13655391f, 0.05337017f, 0.06505305f, 0.29167742f, -0.43698546f, 
    -0.38986605f, -0.06971717f, -0.09135484f, 0.04799077f, 0.19816527f, 0.03165217f, 0.06119919f, 0.15478119f, 
    0.14432931f, 0.17958874f, -0.07309681f, -0.10654758f, 0.05518840f, 0.10326143f, 0.07580706f, 0.06180017f, 
    0.00016867f, -0.01938944f, -0.00655288f, -0.00862995f, -0.04486862f, -0.02166037f, 0.02380951f, -0.00863336f, 
    0.01454739f, -0.01255327f, 0.02865332f, -0.03546283f, -0.05987559f, 0.00163749f, 0.05021879f, -0.00602928f, 
    -0.05329325f, 0.01761834f, -0.03234364f, 0.01175432f, -0.00212209f, -0.06387173f, 0.04818309f, 0.01151495f, 
    -0.06816731f, 0.02612347f, -0.03947912f, -0.04322321f, -0.05283090f, -0.00922379f, -0.00147756f, -0.01054147f, 
    -0.04375635f, 0.00565817f, 0.04879455f, 0.04172407f, -0.01180080f, 0.00717193f, -0.03986157f, 0.02234376f, 
    -0.04892459f, -0.06312941f, 0.04191084f, -0.06137076f, 0.02678510f, -0.06897243f, -0.04475627f, -0.05424612f, 
    -0.04269236f, 0.03177175f, -0.00432900f, 0.04257045f, 0.04565395f, -0.04092308f, 0.03713200f, -0.05965310f, 
    0.02795620f, -0.01105425f, -0.06560600f, 0.02492879f, -0.03669196f, -0.05169598f, 0.03181430f, 0.03241020f, 
    -0.03742086f, 0.04325935f, 0.00313384f, -0.00989911f, -0.01682835f, 0.01571612f, 0.00914523f, -0.06249724f, 
    0.02363573f, -0.05852336f, -0.01649803f, 0.04417137f, 0.04966851f, -0.00536349f, 0.02577253f, 0.00845315f, 
    -0.02573327f, 0.01106169f, 0.04078521f, -0.00844505f, 0.03164790f, 0.04939854f, -0.05005452f, 0.03251654f, 
    -0.06050345f, 0.03639007f, 0.04542171f, 0.01966783f, -0.05671585f, -0.03883705f, 0.04573560f, 0.04218664f, 
    0.01900840f, 0.00473121f, 0.00475136f, 0.01388572f, 0.02916696f, -0.02977323f, 0.02949828f, -0.04407052f, 
    -0.01040412f, -0.04260957f, -0.00466320f, 0.00993912f, -0.02424408f, -0.00110287f, 0.04110760f, -0.00649794f, 
    0.02393244f, 0.04180358f, -0.00913117f, -0.03853976f, 0.02156469f, -0.06063813f, 0.03530400f, -0.00295928f, 
    0.01008056f, -0.02635173f, -0.02293452f, 0.00963089f, -0.04237548f, -0.02891402f, -0.01142181f, -0.05548397f, 
    0.02410592f, -0.03381041f, -0.02701543f, -0.03562865f, 0.01279417f, -0.03354508f, -0.04789765f, 0.04274735f, 
    0.03879101f, -0.02111435f, 0.04629398f, -0.05696190f, -0.04995692f, -0.02904220f, -0.05436712f, -0.05612456f, 
    0.03771897f, 0.03616672f, 0.02194325f, 0.01398387f, 0.04686448f, -0.03796217f, -0.06076386f, -0.03776826f, 
    -0.00489856f, -0.00720332f, -0.04526888f, -0.00163108f, 0.01170060f, -0.06484377f, 0.01217062f, -0.00278701f, 
    -0.04912267f, -0.01562728f, -0.02267664f, -0.05919301f, -0.06602895f, -0.02956525f, -0.01775318f, -0.07068647f, 
    0.02146102f, 0.00741710f, 0.01022731f, 0.04130649f, -0.04745743f, 0.00112476f, -0.06533317f, 0.04300137f, 
    0.04039787f, -0.04171737f, 0.02003997f, -0.06448940f, 0.04733557f, -0.03539741f, 0.00576817f, 0.00437355f, 
    0.03752394f, 0.02075620f, -0.04432261f, -0.04727916f, -0.02712838f, -0.01095572f, 0.01560281f, -0.03378936f, 
    -0.02178497f, -0.00347828f, 0.04646672f, -0.03109973f, -0.06363775f, -0.01048469f, -0.03133876f, -0.05151442f, 
    -0.03528108f, -0.03994078f, 0.02489110f, -0.04242294f, 0.02994755f, 0.05714078f, -0.03562618f, -0.05801422f, 
    0.01113182f, 0.00672643f, 0.00266694f, 0.00191996f, -0.00400891f, -0.01728269f, 0.03243686f, 0.00637362f, 
    -0.01087255f, 0.04687131f, -0.02650859f, -0.04505546f, 0.00529754f, 0.04736646f, 0.00490267f, 0.00149270f, 
    -0.05366851f, 0.00494324f, 0.03978535f, -0.00401567f, -0.05768802f, 0.03379514f, -0.02362218f, 0.01706875f, 
    0.02061443f, 0.02071992f, 0.00337906f, -0.05802644f, -0.04961036f, -0.04432013f, 0.03531162f, 0.00627747f, 
    -0.05299783f, -0.02510107f, 0.00683278f, -0.05605460f, 0.00078257f, -0.00480865f, 0.00979105f, 0.05370383f, 
    -0.05286778f, -0.03148575f, 0.03603611f, -0.02188622f, 0.02590558f, 0.01002959f, -0.00735368f, 0.04206695f, 
    0.00060479f, -0.02728118f, -0.03349440f, -0.04211161f, -0.01547049f, -0.01720658f, -0.05841880f, 0.01293127f, 
    -0.02274664f, -0.04595487f, 0.01523555f, 0.01815739f, 0.03766852f, -0.04573817f, -0.03734044f, 0.04657996f, 
    0.02683349f, -0.03303886f, -0.05584333f, 0.00681328f, -0.03543051f, -0.05786792f, -0.04464922f, -0.01517435f, 
    -0.02547337f, -0.04536377f, 0.03955148f, -0.05261811f, -0.05777012f, 0.03692928f, -0.01628734f, -0.00997789f, 
    -0.00454418f, 0.01705493f, -0.06519472f, 0.04934156f, 0.00256216f, -0.05453829f, -0.02169385f, 0.00357310f, 
    -0.06179743f, -0.01519747f, -0.01979937f, -0.00903392f, 0.00007831f, 0.04508545f, -0.01135946f, 0.01287901f, 
    -0.05545090f, 0.01019652f, -0.01998005f, 0.04063662f, -0.04992213f, 0.00864963f, 0.04945017f, -0.02702788f, 
    0.01487134f, -0.05159592f, -0.01999087f, 0.03185375f, -0.06151372f, -0.02264147f, -0.05100628f, -0.02602172f, 
    -0.02038845f, 0.01807624f, -0.03969152f, 0.03628035f, -0.01098695f, 0.00799627f, -0.05990805f, 0.02384249f, 
    -0.00467260f, -0.02136763f, -0.00301560f, -0.04954238f, -0.05006247f, -0.06016705f, -0.04547767f, -0.03225336f, 
    -0.06376847f, 0.01673992f, 0.01012014f, -0.03680603f, -0.02109527f, -0.03326544f, 0.03782310f, 0.03301988f, 
    0.02143440f, 0.03910740f, -0.01375240f, -0.02313060f, -0.04264883f, 0.04175903f, -0.02116583f, -0.02440559f, 
    -0.05072518f, -0.05656006f, 0.03739580f, 0.03522915f, -0.00112888f, -0.06065003f, -0.03854058f, -0.03572861f, 
    0.02789956f, 0.04656594f, 0.01906253f, -0.06106539f, 0.01805545f, -0.00690037f, -0.00542667f, 0.00870251f, 
    -0.03922734f, 0.01720983f, -0.01763848f, -0.04503747f, 0.01334098f, 0.03800173f, 0.03540068f, 0.00134736f, 
    0.02176041f, -0.03732246f, -0.01990717f, 0.04648677f, 0.03588600f, 0.05243463f, 0.03519457f, -0.02913765f, 
    0.00248163f, -0.04892319f, -0.04979184f, 0.04021849f, 0.03453756f, -0.01354997f, -0.02971189f, -0.02479629f, 
    -0.06552157f, -0.01845015f, 0.04321877f, -0.05607263f, 0.02987646f, -0.04323445f, -0.01150084f, 0.05008766f, 
    0.01213544f, 0.03810496f, -0.02334316f, -0.02802481f, -0.05490240f, -0.02543129f, 0.02611948f, -0.03229568f, 
    -0.04314539f, 0.01478480f, -0.04208846f, 0.04964269f, 0.01916579f, 0.03505602f, 0.03570170f, -0.02517180f, 
    -0.03307030f, 0.01087624f, 0.04252406f, -0.03179850f, 0.04219805f, -0.04118835f, -0.04757448f, 0.03790363f, 
    -0.02621627f, 0.02175541f, 0.00432894f, 0.01914166f, 0.01634461f, 0.04559465f, 0.04521998f, 0.04960312f, 
    -0.03811748f, 0.03163377f, 0.04688165f, -0.04809353f, 0.00404156f, -0.05173968f, -0.00476894f, 0.01619331f, 
    -0.01772163f, -0.02618113f, 0.03358288f, -0.01696857f, -0.02147591f, -0.01522362f, -0.02459612f, -0.03420755f, 
    -0.06468184f, 0.02259789f, -0.05847752f, -0.04288466f, -0.03504410f, -0.01316600f, -0.04760740f, -0.00104627f, 
    -0.02001370f, -0.03193697f, 0.02825660f, -0.00527419f, -0.00640016f, 0.01462488f, 0.00939677f, 0.03834137f, 
    -0.03345830f, -0.00797102f, -0.00283150f, -0.01735611f, 0.03537066f, 0.04959499f, 0.00849962f, -0.02122557f, 
    -0.03409213f, 0.00148946f, 0.01359492f, -0.03048368f, -0.03701749f, 0.03719918f, 0.02132872f, -0.05439024f, 
    -0.03491890f, -0.05689508f, -0.00727303f, -0.05807277f, 0.04027216f, -0.03658811f, 0.04013427f, -0.04023864f, 
    -0.03242876f, 0.00418280f, 0.03563824f, -0.02404068f, 0.02811110f, 0.00550992f, -0.05767990f, -0.01480589f, 
    -0.04178587f, 0.00159486f, -0.04874884f, 0.01587950f, 0.03706053f, -0.06406426f, 0.03202901f, -0.01525152f, 
    -0.01671040f, 0.02752266f, -0.04671460f, -0.06219392f, -0.03311042f, -0.00785243f, -0.02629261f, -0.05051283f, 
    -0.00756329f, -0.06222105f, -0.00539828f, -0.05457690f, 0.00916369f, 0.03834184f, -0.03330520f, 0.03472045f, 
    0.02943581f, 0.01826805f, 0.00187755f, -0.02281077f, -0.02173231f, -0.06090993f, 0.05024095f, -0.02008676f, 
    -0.04509037f, -0.00355728f, -0.03437947f, -0.01469494f, 0.03331347f, -0.03730818f, -0.05807246f, -0.03165943f, 
    0.01527778f, -0.05893997f, 0.02556973f, -0.03203646f, -0.00577283f, 0.00306407f, -0.02553702f, -0.05521806f, 
    -0.05935781f, 0.02778647f, -0.06445142f, -0.04913269f, 0.00610098f, 0.03387588f, 0.03698174f, 0.01644447f, 
    0.00667790f, 0.01546404f, 0.02773736f, 0.04561743f, -0.04247987f, 0.04176480f, -0.01018631f, -0.00361343f, 
    0.00365315f, -0.00691896f, -0.00972022f, 0.01587068f, 0.02975320f, 0.01260318f, -0.04766001f, 0.02580370f, 
    0.01104442f, -0.03862805f, 0.01211018f, -0.04332652f, 0.04364390f, 0.00206150f, 0.00971749f, -0.04444519f, 
    0.00669402f, 0.03434419f, 0.39919722f, -0.06438532f, 0.04374273f, 0.07462145f, 0.07250435f, -0.05976666f, 
    -0.07291007f, -0.15170175f, 0.16578826f, 0.28716156f, 0.15748726f, -0.00521071f, -0.07281682f, -0.00303440f, 
    -0.20534191f, -0.10341809f, 0.04442900f, 0.13531604f, 0.07888326f, 0.05915745f, 0.06823240f, 0.05152321f, 
    -0.03873955f, -0.10618395f, -0.25394747f, 0.03724408f, 0.10604963f, 0.06672169f, 0.05293586f, 0.04036658f, 
    -0.07205547f, 0.14300206f, -0.05973094f, -0.17373103f, 0.04651658f, 0.15008287f, 0.07155836f, 0.09722908f, 
    -0.00987586f, -0.00571566f, 0.15677784f, -0.17682599f, -0.05661068f, 0.08325617f, 0.37336668f, 0.22882777f, 
    0.09922756f, 0.05770441f, 0.05767900f, -0.00251379f, 0.04149185f, -0.00965477f, 0.05194500f, -0.18641531f, 
    -0.23265502f, -0.04053025f, -0.10217525f, -0.06539182f, -0.01711133f, 0.03637258f, 0.01760847f, -0.16944502f, 
    -0.04030946f, 0.18782495f, -0.12418188f, -0.06445412f, -0.07945259f, 0.02552882f, 0.06834858f, -0.00758268f, 
    0.22379708f, 0.15362069f, 0.18767785f, -0.00877858f, -0.01918994f, -0.01197260f, -0.06119827f, -0.16530664f, 
    0.02341117f, -0.10436671f, -0.10837854f, 0.11372393f, 0.21404266f, 0.00215312f, 0.14146765f, 0.04809746f, 
    -0.29778001f, -0.19856758f, 0.31667295f, 0.32988191f, -0.04409724f, 0.02613503f, -0.04338236f, -0.05268217f, 
    -0.04667850f, -0.14378227f, 0.05158044f, -0.11749728f, -0.00696718f, -0.17546381f, 0.06997018f, 0.02952550f, 
    0.00288882f, 0.01498258f, 0.02292237f, 0.01355657f, 0.15354182f, 0.21617568f, -0.05345842f, 0.10105382f, 
    -0.06477591f, -0.02921113f, 0.08659981f, 0.00261955f, 0.02614624f, -0.03697198f, 0.05867723f, 0.11950924f, 
    -0.04735628f, -0.05022815f, -0.01759782f, -0.03967974f, -0.04964622f, -0.14386354f, 0.09192336f, -0.24814327f, 
    -0.13754314f, 0.11699321f, 0.01696923f, 0.14621866f, 0.02605232f, -0.14489463f, -0.22266266f, 0.22767814f, 
    -0.10076738f, 0.07758587f, -0.30330536f, -0.37743607f, -0.07296086f, -0.04508507f, -0.10487988f, -0.14838378f, 
    -0.20508385f, 0.10885571f, -0.39961088f, 0.08108576f, -0.04865233f, 0.03871336f, 0.16038200f, 0.00291840f, 
    0.11113402f, 0.01241110f, -0.03239601f, -0.41815948f, -0.03510145f, 0.23911023f, 0.13269071f, 0.02576277f, 
    -0.08442687f, -0.12868096f, -0.13715124f, 0.10159501f, -0.01167395f, -0.07268056f, -0.06321909f, -0.07221071f, 
    0.04374205f, -0.02531289f, 0.01614609f, -0.08070168f, -0.13733758f, 0.01546242f, -0.14602023f, -0.09830026f, 
    0.05543001f, 0.04294764f, 0.02775701f, 0.03887710f, 0.09324835f, -0.11117265f, -0.19946286f, 0.05100682f, 
    -0.05743580f, -0.07071459f, -0.03816958f, 0.16636460f, -0.07416400f, 0.17207554f, -0.11792014f, 0.23604126f, 
    0.06291673f, 0.00000274f, -0.11857530f, 0.20232689f, -0.00601700f, 0.07649861f, -0.17628948f, 0.06252236f, 
    -0.03036352f, -0.02929632f, 0.03549664f, 0.03304425f, 0.00196073f, 0.01877771f, 0.00261968f, -0.25392431f, 
    0.52256215f, -0.32618684f, -0.13566171f, -0.00673125f, -0.02914564f, 0.07618955f, 0.09954957f, 0.08345608f, 
    0.33007947f, 0.10364576f, 0.05637595f, -0.02322539f, -0.26581109f, -0.14995603f, 0.03417493f, 0.16794881f, 
    -0.06068517f, -0.16574231f, 0.36881632f, 0.10476671f, -0.13056910f, 0.10826382f, 0.09660054f, 0.08795193f, 
    0.11364914f, -0.15371457f, 0.42510116f, 0.15471961f, 0.16530024f, -0.11938649f, -0.00118290f, 0.00991371f, 
    -0.02152104f, 0.04124513f, -0.02779463f, 0.05269949f, 0.19882639f, 0.06649351f, 0.05135430f, -0.02071843f, 
    -0.13940257f, 0.05324556f, -0.01133983f, 0.04142191f, -0.25178751f, -0.04929020f, 0.34975225f, 0.04958489f, 
    0.01386784f, -0.10723951f, -0.01849566f, 0.12574185f, -0.02782399f, 0.25333929f, 0.13358170f, 0.00014252f, 
    -0.02780710f, -0.04261578f, -0.13138045f, 0.00903454f, -0.04216204f, 0.03521177f, -0.07312840f, 0.08778210f, 
    0.35233769f, 0.01133687f, 0.10014690f, -0.01705036f, -0.09527973f, -0.07984412f, 0.11276352f, 0.32416302f, 
    -0.47100696f, -0.24616925f, -0.11242403f, 0.13383473f, -0.10550612f, -0.04177845f, -0.09922571f, -0.11273205f, 
    0.20402220f, -0.07018201f, -0.06343328f, 0.07320477f, -0.00496550f, 0.15594506f, 0.22754425f, 0.04885230f, 
    0.17654040f, 0.00122598f, 0.13122070f, -0.29750818f, -0.01313790f, -0.12139844f, -0.01347907f, 0.17477241f, 
    0.00983081f, 0.23892657f, -0.07629731f, 0.14963411f, 0.12031697f, -0.17299098f, -0.03849876f, -0.03197623f, 
    -0.11047373f, 0.03948170f, 0.12501511f, 0.11773770f, 0.16219610f, 0.18518741f, -0.16131690f, 0.02357215f, 
    -0.05763371f, 0.19246764f, 0.07532126f, -0.05250379f, -0.01027241f, 0.19189204f, 0.08501033f, -0.14252479f, 
    0.06441216f, -0.10279207f, -0.05935126f, 0.03812691f, 0.11173691f, -0.28091463f, -0.11517881f, -0.11753224f, 
    -0.09604178f, 0.04967261f, 0.00179360f, 0.09522329f, 0.06653736f, 0.08518455f, -0.16385625f, -0.54444963f, 
    -0.45586979f, 0.06116102f, 0.18872491f, 0.00412579f, 0.06105610f, -0.14003570f, -0.01487884f, -0.22551183f, 
    -0.34556550f, -0.09273790f, 0.06605646f, 0.14117788f, 0.08164611f, 0.03838348f, 0.07823656f, 0.02968320f, 
    0.10663360f, 0.04664924f, -0.19265245f, -0.10873922f, -0.01839041f, -0.06306112f, 0.07909212f, 0.02994218f, 
    0.06065119f, 0.45941249f, -0.11468507f, -0.28255856f, -0.04061939f, -0.03505136f, 0.04445980f, 0.09169313f, 
    -0.01804213f, 0.00987970f, -0.05832547f, 0.33440688f, -0.20761427f, -0.00601882f, 0.05417253f, 0.04768743f, 
    0.08867168f, 0.05802251f, 0.04339221f, 0.05998557f, 0.15902098f, 0.11574629f, 0.08541232f, 0.16721502f, 
    -0.07267852f, 0.03926517f, 0.03596798f, 0.12852035f, -0.22766732f, -0.13760667f, -0.28941837f, -0.16183347f, 
    0.01190728f, -0.10156771f, 0.14003807f, 0.03479930f, -0.03936359f, 0.07751786f, -0.20742396f, 0.04848576f, 
    -0.08768578f, 0.10236833f, 0.01123520f, 0.15249781f, 0.16516575f, 0.11624701f, -0.31257546f, -0.49226412f, 
    -0.34379476f, -0.23111622f, 0.08524097f, -0.07350513f, -0.09205112f, -0.19087280f, -0.04416987f, -0.05570593f, 
    -0.14514266f, -0.24913451f, -0.15501067f, 0.12070066f, -0.13406238f, -0.19370475f, -0.13266565f, 0.05442611f, 
    -0.22507572f, -0.03321563f, -0.11450611f, -0.01534726f, 0.05301911f, 0.11832131f, 0.13022162f, 0.11949556f, 
    -0.02067111f, -0.20166908f, -0.18758219f, -0.25175563f, -0.11201996f, 0.27099192f, -0.03415526f, 0.23360375f, 
    0.08576552f, -0.07850414f, -0.01745693f, 0.22828099f, 0.06694658f, 0.01390825f, -0.04406888f, -0.16248493f, 
    0.05589706f, 0.19759449f, 0.06419992f, -0.12980710f, -0.39419836f, -0.29795498f, 0.02113256f, -0.04442177f, 
    0.00292917f, 0.00251733f, -0.05193680f, 0.06088946f, -0.15661120f, -0.27830657f, -0.19829230f, 0.12619466f, 
    0.16950585f, -0.08311939f, 0.17069072f, 0.10717236f, -0.17351139f, 0.42875952f, 0.23625147f, 0.15899946f, 
    0.01854161f, -0.01007006f, -0.15173426f, -0.02643750f, 0.06748861f, 0.08725400f, -0.48846614f, -0.33863702f, 
    -0.36906579f, -0.06985135f, 0.14085664f, 0.11293276f, 0.06801116f, 0.02236438f, -0.21650904f, -0.50461638f, 
    0.26872197f, 0.10364050f, 0.09044620f, -0.33546022f, 0.03048980f, 0.08742946f, 0.01808500f, 0.00496061f, 
    0.19019631f, 0.14976209f, 0.01546644f, -0.10293417f, 0.12764312f, -0.01098486f, 0.04204918f, -0.00928082f, 
    -0.18563855f, 0.14774670f, 0.20816417f, -0.01229258f, 0.08030844f, 0.14930321f, -0.00371609f, 0.07617626f, 
    0.12234921f, 0.09752841f, 0.29951075f, -0.20826766f, -0.40665969f, -0.12773657f, -0.17861073f, 0.36532876f, 
    0.03587517f, -0.09934669f, -0.04016786f, 0.10123220f, 0.31954211f, -0.01671368f, -0.06202497f, 0.17327783f, 
    -0.12769876f, 0.01167522f, 0.10990171f, 0.12141633f, 0.18876742f, 0.14371222f, 0.11680333f, -0.06828926f, 
    0.15900260f, 0.01881536f, 0.08894495f, -0.08221100f, 0.04440440f, 0.19667010f, 0.24070355f, -0.03314074f, 
    0.02931355f, 0.14731486f, -0.03871504f, -0.07016931f, -0.04787342f, -0.04852933f, 0.25144196f, 0.04323922f, 
    0.02519918f, -0.07501632f, -0.20002382f, -0.03835002f, -0.01408140f, -0.02354581f, 0.12930764f, -0.43889105f, 
    -0.65952247f, -0.16109335f, -0.03618157f, 0.13023654f, -0.05229163f, -0.04125382f, -0.10695071f, -0.04011593f, 
    -0.32336113f, -0.07014731f, 0.13921320f, 0.08868545f, -0.00090582f, 0.06127025f, 0.14376462f, 0.14392480f, 
    0.12970029f, -0.63005042f, -0.43449834f, -0.02759179f, -0.02056940f, -0.09323277f, 0.01143362f, -0.05769204f, 
    -0.10069973f, -0.15937510f, 0.55443609f, 0.21177748f, -0.00254490f, 0.09616847f, -0.06661571f, -0.07315158f, 
    -0.11752587f, -0.01620763f, -0.00530395f, 0.14240138f, -0.09760703f, 0.06270117f, -0.08787784f, 0.09149264f, 
    0.09281255f, 0.02347783f, -0.14992407f, 0.05473675f, 0.04497460f, 0.23553455f, 0.05841301f, -0.19107300f, 
    -0.06835091f, 0.03470736f, 0.05057571f, -0.04744186f, 0.07457702f, -0.12446653f, 0.14798620f, 0.22782743f, 
    -0.06335195f, -0.02244157f, 0.01279144f, -0.01198608f, -0.06112427f, -0.01870160f, -0.12253971f, -0.39784151f, 
    -0.28202492f, 0.02778804f, 0.05037199f, 0.07395481f, -0.08385012f, -0.01202723f, 0.11845113f, -0.02111308f, 
    -0.10689186f, -0.02591392f, -0.00191654f, 0.18054669f, -0.04382445f, 0.13417846f, 0.13123094f, 0.05136203f, 
    0.12450283f, 0.15964234f, 0.07156696f, 0.01959086f, -0.11530124f, -0.06043424f, 0.02268369f, 0.04426899f, 
    0.08905634f, -0.17568581f, -0.31541213f, -0.79568452f, -0.02733019f, -0.02524395f, 0.12758496f, 0.16057608f, 
    -0.11344689f, 0.00024050f, 0.14722404f, 0.10144797f, 0.08974798f, -0.01004726f, 0.16015145f, -0.04676072f, 
    0.02914043f, -0.04984379f, 0.18585923f, 0.44309664f, 0.16904309f, 0.17410405f, -0.08124209f, 0.26785660f, 
    0.10417229f, 0.05199222f, -0.03613379f, 0.04049605f, -0.18635365f, 0.08465425f, 0.04512940f, 0.09622058f, 
    -0.04689230f, -0.16008802f, -0.12273496f, 0.01898461f, -0.03134831f, 0.14267136f, 0.23149237f, -0.05111750f, 
    -0.12945683f, 0.01147733f, -0.03194299f, 0.07877937f, 0.03481925f, 0.07987083f, 0.47243381f, -0.26845160f, 
    0.37778848f, 0.00187436f, -0.08742288f, -0.04680184f, 0.19049805f, 0.05405675f, 0.02846385f, -0.40720993f, 
    -0.15994133f, -0.11240267f, -0.08499577f, -0.02814647f, -0.26455927f, 0.07735565f, 0.01595355f, 0.11637249f, 
    0.32221803f, -0.18679304f, -0.21788895f, -0.08681561f, 0.14577058f, 0.16203900f, 0.16206880f, -0.04993241f, 
    -0.00657715f, -0.39237109f, -0.80446589f, -0.59544635f, 0.08630328f, -0.07812967f, 0.15382329f, -0.02394391f, 
    0.09209903f, -0.16002305f, -0.13753444f, -0.13701785f, -0.31523600f, 0.08374476f, -0.13019720f, -0.13953288f, 
    -0.01865053f, 0.17444068f, 0.11407714f, -0.22281678f, -0.12628716f, 0.00411447f, -0.15049228f, 0.09328485f, 
    -0.08629362f, -0.01603533f, 0.12030970f, -0.10237080f, -0.23212306f, -0.26744297f, 0.02448337f, 0.06558090f, 
    -0.14929506f, -0.11345810f, 0.04837347f, 0.18450998f, -0.03327718f, 0.42520860f, -0.46287271f, -0.38249704f, 
    0.06128689f, -0.17503200f, -0.21576896f, 0.03166611f, 0.07076620f, 0.06713383f, -0.34927034f, 0.42784128f, 
    -0.08303756f, -0.00572084f, 0.06070729f, 0.03312166f, -0.02298012f, 0.07454944f, -0.13846502f, -0.65742815f, 
    -0.03578079f, -0.25343165f, 0.01800243f, -0.07709260f, -0.18193422f, 0.06625593f, 0.06405773f, 0.04892410f, 
    0.09195907f, -0.13233395f, 0.10038694f, 0.01592068f, -0.00577040f, 0.02520269f, 0.05562361f, 0.01531951f, 
    0.19114277f, 0.00372050f, -0.04997915f, -0.11513951f, 0.08561733f, -0.09870368f, -0.10251966f, 0.14339454f, 
    0.10980412f, 0.14648986f, 0.22877532f, 0.18651533f, 0.33895206f, -0.00050089f, 0.08609338f, 0.11212717f, 
    -0.10944189f, 0.00921488f, -0.03437941f, 0.00632336f, -0.02611263f, 0.19751211f, -0.02246584f, 0.10607127f, 
    0.06689493f, 0.17447430f, 0.01909746f, 0.04496699f, -1.14061737f, -0.24524786f, 0.25205991f, 0.06045985f, 
    0.04959476f, 0.04409438f, 0.15029068f, 0.04904636f, 0.05941250f, -0.03525544f, -0.00386146f, 0.10140020f, 
    -0.01781353f, 0.10504016f, 0.07254978f, 0.08250406f, 0.06339493f, 0.16364235f, -0.08575579f, 0.26607981f, 
    -0.27500781f, -0.20320535f, 0.13515590f, -0.18378937f, -0.12308489f, -0.12456273f, 0.05681311f, 0.84698653f, 
    -0.10637943f, -0.18421644f, -0.08446860f, 0.01173319f, 0.11684487f, 0.01878287f, -0.09385339f, -0.18018392f, 
    0.09459406f, 0.04213033f, -0.15553078f, -0.06146791f, -0.24250770f, -0.01740865f, -0.09483542f, 0.00931589f, 
    0.02760005f, -0.10059202f, 0.08632598f, -0.16164166f, -0.00776980f, 0.06453688f, -0.19343728f, 0.12020978f, 
    0.06134938f, 0.14802454f, -0.07108368f, -0.06636798f, -0.03640163f, 0.11369241f, -0.00137743f, 0.13579528f, 
    0.15330744f, 0.03335053f, 0.04321689f, -0.08291911f, -0.09753229f, -0.08525518f, 0.08238285f, 0.10819707f, 
    0.10904528f, 0.12644111f, -0.17381626f, -0.25829622f, -0.01844153f, -0.00793755f, -0.00346905f, 0.09669603f, 
    0.08444899f, 0.00239283f, 0.04883169f, 0.02708518f, -0.02848828f, 0.17131607f, -0.08290588f, 0.10882980f, 
    0.12283289f, -0.02853384f, -0.16123307f, 0.13909541f, -0.16734639f, -0.07568800f, 0.23055810f, -0.11060671f, 
    -0.05542922f, 0.09056470f, 0.02498081f, 0.03237464f, -0.08788820f, -0.28752103f, -0.16697507f, 0.04959827f, 
    -0.07406111f, -0.01920620f, 0.08144873f, 0.01176565f, -0.09727923f, -0.03710922f, -0.48954684f, -0.14968400f, 
    0.06804923f, -0.00287407f, 0.19772312f, 0.19597983f, -0.04657175f, -0.01178625f, -0.03874804f, 0.05626795f, 
    0.03583940f, 0.28166178f, -0.09942958f, -0.39055303f, 0.14461020f, -0.01529546f, 0.19689380f, 0.11429798f, 
    0.02577816f, 0.04717427f, 0.21428773f, -0.25401026f, 0.13823798f, 0.14210518f, 0.04482568f, -0.11424544f, 
    -0.06838190f, 0.01139694f, 0.04551278f, -0.09016123f, -0.10774514f, -0.17928950f, 0.08446804f, -0.00251228f, 
    -0.00942824f, 0.02677545f, 0.14346254f, -0.12604293f, 0.19140510f, 0.05357642f, 0.01711228f, 0.18126702f, 
    -0.11575828f, -0.07386132f, 0.17578474f, -0.23924309f, -0.11770429f, -0.17120728f, -0.14715692f, -0.04373346f, 
    0.08379104f, -0.14309002f, -0.12959807f, -0.04451953f, -0.12192151f, -0.10170177f, -0.23046505f, 0.11886250f, 
    0.05083418f, -0.05429345f, -0.16269141f, 0.02003065f, -0.06421424f, 0.26923752f, 0.22780119f, 0.07183190f, 
    0.17492823f, 0.15852940f, 0.10232894f, 0.06105458f, 0.10552248f, -0.05510109f, -0.04902285f, 0.14274313f, 
    0.00330592f, -0.13744228f, 0.02108710f, 0.09535525f, 0.01796848f, -0.01870972f, 0.06114028f, 0.12975161f, 
    -0.03875631f, -0.20478697f, 0.10741761f, -0.12722015f, -0.13895208f, -0.14849758f, 0.00555291f, 0.14818899f, 
    -0.01718794f, 0.10498210f, -0.17490403f, 0.14988416f, 0.05602859f, -0.00540982f, 0.08121864f, 0.02958986f, 
    0.11381898f, 0.13488787f, -0.11604916f, -0.16438444f, -0.04889872f, -0.00075065f, 0.11135844f, 0.01837588f, 
    0.09554480f, 0.13458495f, 0.01740692f, 0.00577487f, 0.08871509f, 0.13228270f, -0.14727364f, 0.14474782f, 
    -0.14826711f, -0.15500546f, -0.07105422f, -0.25031394f, -0.11609987f, -0.15516627f, 0.09264489f, -0.07189883f, 
    0.14119163f, 0.12904809f, 0.21321218f, 0.04670526f, 0.07276744f, 0.09846381f, 0.10633795f, -0.06419557f, 
    0.06780477f, -0.09981913f, 0.11562647f, -0.06228086f, 0.01948255f, -0.08489165f, 0.09574395f, 0.28965333f, 
    -0.31303552f, 0.03343680f, -0.05011982f, 0.01928783f, -0.00508199f, 0.26812872f, 0.13170052f, -0.06000342f, 
    0.04987403f, -0.02921440f, -0.00439001f, 0.10100573f, 0.04011670f, 0.14310354f, -0.07897756f, -0.27357638f, 
    0.02721176f, -0.11313003f, 0.16857785f, 0.04992859f, 0.13104561f, 0.02353699f, 0.10868769f, 0.17887367f, 
    -0.26029515f, -0.18073837f, 0.06505428f, -0.08447074f, 0.09172810f, 0.32742062f, 0.02054258f, -0.00946232f, 
    0.03410276f, 0.01629967f, -0.08773576f, 0.05808068f, 0.03949942f, -0.12985383f, -0.03854835f, -0.00540795f, 
    0.00730157f, -0.01046897f, -0.20030726f, 0.05032724f, -0.07246852f, 0.11186185f, -0.47072399f, 0.00590713f, 
    -0.02540796f, -0.02517727f, 0.02079874f, 0.07486593f, 0.02410828f, 0.04287696f, 0.14149076f, -0.02509576f, 
    0.02170021f, 0.07782814f, 0.01028356f, -0.01394389f, -0.07964658f, -0.02152144f, 0.18253615f, -0.13893144f, 
    -0.03964296f, 0.15652339f, -0.05383165f, -0.11612937f, 0.06917521f, 0.05872093f, -0.24408144f, -0.11996813f, 
    0.01812035f, -0.13040875f, -0.01391259f, 0.00435508f, 0.09230238f, 0.01336204f, 0.18682098f, -0.00095166f, 
    0.01697014f, -0.00348294f, 0.05022973f, -0.00540455f, -0.02143526f, -0.00218138f, 0.01257674f, -0.02613840f, 
    -0.01902235f, 0.01294593f, -0.03437690f, -0.02030562f, 0.04506128f, -0.01626637f, 0.01681027f, 0.03530583f, 
    -0.01351633f, -0.00205249f, -0.05146538f, -0.05363163f, 0.02000382f, 0.02214249f, 0.01749532f, -0.03658868f, 
    -0.05074425f, -0.05037829f, -0.00120170f, -0.05732024f, 0.01021845f, 0.00575699f, -0.01961685f, 0.01267551f, 
    0.01449049f, -0.05447036f, 0.01940433f, 0.04208352f, 0.03834544f, 0.04168862f, -0.04494480f, 0.00598382f, 
    0.02332846f, 0.03727617f, -0.03998022f, -0.04464757f, 0.02385089f, 0.01749924f, -0.06267418f, 0.04701964f, 
    -0.00678993f, -0.02391213f, 0.03706269f, -0.00182829f, 0.00216298f, -0.05364794f, -0.05475569f, -0.03294367f, 
    0.00455639f, 0.00101499f, -0.03761337f, 0.05049036f, 0.01304423f, 0.01060942f, 0.04733228f, 0.04428418f, 
    0.03364498f, -0.00171016f, -0.01592500f, 0.02090638f, 0.00704815f, -0.02855536f, -0.03083517f, -0.02195346f, 
    -0.00947537f, -0.00410088f, -0.02873256f, -0.01741186f, -0.03815373f, 0.04023105f, 0.00673625f, -0.05995432f, 
    -0.06146200f, 0.02603083f, -0.04446638f, 0.04089527f, -0.04908724f, -0.05283479f, 0.02386156f, 0.04690236f, 
    -0.00642766f, -0.01805493f, 0.00581673f, 0.04226027f, 0.04368547f, -0.01932153f, 0.00372856f, -0.00628194f, 
    -0.04093049f, -0.01184490f, -0.00838214f, -0.05077977f, -0.02741156f, -0.00008499f, -0.06716344f, -0.03483948f, 
    -0.01650333f, -0.06159143f, -0.02426641f, -0.04232849f, 0.01726587f, -0.00393225f, 0.00911689f, 0.03700808f, 
    -0.01559162f, -0.05103584f, -0.05563652f, -0.02264961f, 0.03332366f, -0.03934743f, -0.00174958f, -0.02481552f, 
    0.04352672f, -0.01936539f, -0.00339927f, -0.06335181f, -0.06259471f, 0.02550375f, 0.01274376f, -0.04646574f, 
    0.03454765f, 0.03465324f, 0.01181090f, 0.01460846f, 0.00714573f, -0.04799749f, -0.01553522f, 0.01695198f, 
    -0.03761202f, 0.01772878f, 0.04871162f, 0.00546028f, 0.02816536f, 0.01852117f, 0.04064975f, 0.01277580f, 
    0.01263809f, 0.01827871f, -0.03206831f, 0.00649289f, -0.03979630f, 0.00769912f, 0.03946151f, 0.00036136f, 
    0.00546043f, 0.00532462f, 0.00525953f, 0.01880047f, 0.00370829f, -0.04919068f, -0.05505439f, -0.01233733f, 
    0.05296307f, -0.00052217f, 0.02255720f, -0.05258686f, -0.05800325f, 0.00697797f, 0.02757122f, 0.00232495f, 
    0.05128935f, 0.01626115f, -0.02898946f, -0.00948870f, 0.01253569f, 0.05472912f, -0.00421255f, -0.00965056f, 
    -0.01180115f, -0.00775484f, 0.01481588f, 0.04812060f, -0.03327188f, -0.03294149f, 0.00491854f, 0.06050035f, 
    -0.05273034f, -0.05233219f, -0.06344216f, -0.05530020f, -0.00185208f, -0.00395984f, -0.06067318f, 0.00041197f, 
    -0.02865465f, -0.06413181f, 0.03305116f, -0.03211604f, -0.03399220f, 0.01467403f, 0.04967550f, 0.01444594f, 
    -0.03765360f, -0.05906677f, -0.03717596f, -0.02184962f, -0.04540498f, -0.04733654f, 0.04002075f, 0.01066077f, 
    0.00912804f, 0.04853475f, 0.02588419f, -0.04282868f, 0.04564446f, 0.05830669f, -0.04661458f, -0.01205707f, 
    -0.06319644f, -0.03218729f, 0.04306799f, 0.03468481f, 0.03217974f, 0.05614818f, 0.00812631f, -0.01239603f, 
    0.00370780f, 0.01775185f, -0.05634862f, 0.03178036f, -0.03378168f, -0.02881832f, 0.05205107f, -0.05524892f, 
    0.03414891f, 0.03957528f, 0.02528259f, 0.05096625f, -0.01371237f, -0.06057950f, 0.03022462f, 0.02287375f, 
    -0.01294325f, -0.00952846f, 0.03051009f, 0.04230882f, -0.03772907f, 0.04011245f, -0.03065526f, -0.02284435f, 
    -0.01332116f, 0.03948001f, -0.01070903f, -0.05167988f, 0.01121527f, 0.03287458f, -0.04145020f, -0.00939349f, 
    -0.02114260f, -0.04691151f, 0.03180215f, -0.00433090f, -0.03713306f, -0.01517587f, 0.03309179f, 0.00117381f, 
    0.02960909f, -0.00358132f, 0.04131328f, -0.05651928f, -0.01313158f, -0.04378485f, -0.02564909f, -0.03264758f, 
    -0.01955136f, -0.02968032f, 0.05052729f, -0.04919548f, -0.05037085f, -0.04915005f, -0.05032359f, -0.00405358f, 
    -0.02699863f, 0.02859664f, 0.00485394f, 0.04791321f, -0.01214512f, -0.03049374f, -0.03172986f, 0.01798686f, 
    0.04217017f, 0.02862087f, -0.05439479f, -0.01958298f, 0.00026000f, 0.01920173f, 0.04433760f, -0.03503273f, 
    0.04013500f, -0.05625852f, -0.00762754f, -0.03211538f, -0.05995906f, -0.06566064f, -0.04198458f, -0.02152965f, 
    -0.04753592f, -0.04671979f, 0.02373669f, -0.05503479f, 0.00509594f, 0.03032864f, -0.04539929f, -0.06197384f, 
    -0.00935643f, -0.04161276f, 0.01613000f, -0.03595281f, -0.00143277f, 0.01412055f, -0.04155881f, -0.02376840f, 
    -0.05199240f, -0.05463463f, 0.04564694f, 0.04395290f, 0.02116004f, -0.04218670f, 0.00681113f, -0.04009350f, 
    0.01192292f, 0.00160160f, 0.03048187f, 0.03473445f, 0.04356651f, 0.00462223f, 0.01232615f, -0.06622345f, 
    0.01820005f, 0.03379457f, -0.00276586f, 0.01223070f, -0.00873908f, 0.00123545f, -0.05660036f, -0.01961466f, 
    0.00575881f, -0.05348342f, -0.00094705f, 0.02076326f, -0.02677043f, 0.02492162f, 0.04927817f, 0.01303742f, 
    -0.06203358f, -0.02005887f, 0.02846393f, 0.03299869f, 0.01446569f, 0.03674379f, -0.03182020f, -0.03359208f, 
    0.04799625f, -0.05856807f, -0.04727291f, -0.04501778f, -0.06138478f, -0.03125847f, -0.05385241f, -0.02666256f, 
    -0.01569491f, 0.02594195f, -0.03975369f, 0.05180155f, -0.02600590f, -0.00232880f, 0.03464985f, 0.01664375f, 
    -0.05001865f, 0.03419745f, 0.04593492f, 0.04031603f, -0.01990967f, -0.03280215f, 0.01552627f, -0.03642402f, 
    -0.03146242f, -0.04949862f, 0.04168360f, 0.00301320f, 0.04636579f, -0.02572735f, -0.03975251f, 0.00063992f, 
    -0.00052469f, -0.01370244f, -0.04376062f, -0.01322309f, -0.05470955f, -0.03017852f, 0.03905269f, 0.04594558f, 
    0.04274616f, -0.05191204f, -0.01812482f, 0.02897335f, 0.03156327f, 0.04739692f, 0.00204002f, -0.05501548f, 
    -0.05825398f, 0.00093445f, -0.05073841f, -0.01129256f, -0.06152179f, -0.03655475f, -0.02102671f, 0.00189144f, 
    -0.05107211f, -0.01705781f, 0.00567844f, 0.01862487f, 0.01565488f, -0.01184446f, -0.03965704f, -0.04442783f, 
    0.03635006f, 0.04019387f, -0.04835762f, -0.05938457f, 0.04117876f, -0.02952187f, 0.02462464f, 0.02855737f, 
    -0.01885679f, -0.02435499f, 0.03775465f, -0.01740293f, -0.00408896f, 0.02627405f, 0.03679235f, 0.00860169f, 
    -0.02980580f, 0.01334376f, -0.03723601f, -0.02342941f, -0.06137113f, -0.00733210f, -0.00750994f, 0.00154001f, 
    0.03042421f, -0.04009264f, -0.00983529f, 0.00925507f, -0.04160768f, 0.05027703f, -0.03099513f, -0.06013318f, 
    -0.06153860f, 0.01321824f, -0.03033125f, 0.02226865f, 0.03259620f, -0.04232809f, -0.01419886f, 0.01712928f, 
    -0.03228823f, -0.04037317f, 0.00544559f, -0.04426525f, 0.04413958f, -0.03748178f, -0.03154664f, -0.00327511f, 
    -0.05458562f, 0.01706823f, -0.02636178f, 0.02742024f, -0.04237766f, 0.02923527f, -0.01342063f, 0.00565204f, 
    -0.03610909f, -0.04556937f, 0.01070664f, 0.00070990f, 0.03113044f, -0.03478738f, -0.03661382f, -0.03644331f, 
    -0.01105769f, 0.01317616f, 0.00500454f, -0.01229326f, 0.01636320f, -0.03973133f, -0.01991403f, -0.05653710f, 
    -0.03085191f, -0.02296377f, -0.01794552f, 0.04641405f, 0.01662625f, -0.03002981f, 0.03560681f, -0.00138374f, 
    0.01359031f, -0.03801652f, -0.06221044f, -0.01125582f, 0.04661760f, -0.02510169f, -0.04430899f, 0.03417822f, 
    0.04492756f, 0.03365348f, -0.01161029f, -0.00307705f, -0.02307968f, -0.06196634f, 0.02580435f, 0.03393893f, 
    -0.02937224f, -0.04751776f, 0.02293205f, -0.04740954f, 0.02407980f, -0.01080341f, -0.03834416f, 0.03395177f, 
    -0.00614883f, 0.01461232f, -0.05796163f, -0.02903432f, -0.00342017f, -0.01341688f, 0.03917960f, 0.03289562f, 
    -0.03660641f, 0.01570267f, -0.01564809f, -0.05221693f, 0.00987525f, -0.00748286f, -0.04024955f, 0.04504079f, 
    -0.04639077f, -0.06157693f, 0.05178017f, 0.03822108f, 0.04374428f, -0.00916713f, -0.05669751f, -0.03044428f, 
    0.04419875f, -0.05312924f, -0.00384091f, -0.06273380f, -0.05608342f, 0.00729126f, 0.01307927f, -0.06460638f, 
    -0.05989483f, -0.02115546f, 0.00063242f, -0.04200738f, -0.05747145f, -0.01730547f, 0.02039708f, -0.06017866f, 
    0.01295815f, 0.01106993f, 0.01881569f, -0.02396337f, -0.06514903f, -0.04363662f, -0.04578549f, -0.01689762f, 
    -0.25657547f, -0.27600259f, 0.13410805f, 0.18081711f, 0.05941498f, -0.00188880f, -0.01969580f, -0.04159071f, 
    0.04250585f, -0.32893297f, -0.35573620f, 0.12474182f, 0.05766004f, -0.11506020f, -0.06482839f, 0.06542336f, 
    -0.07431801f, -0.11693629f, 0.06631242f, -0.11202794f, -0.09984072f, -0.14504710f, -0.07114479f, 0.04308712f, 
    0.10614516f, -0.09149510f, -0.05129600f, -0.01438484f, -0.00083448f, -0.16196695f, -0.06734704f, 0.20441218f, 
    -0.01226894f, 0.26293322f, -0.08845206f, -0.09199563f, 0.07141264f, -0.04984503f, -0.02462218f, -0.17245673f, 
    -0.01736296f, -0.20704003f, 0.12886666f, -0.21297960f, -0.20048186f, 0.13492264f, 0.09104259f, 0.23425029f, 
    -0.11001380f, -0.00394302f, 0.05859154f, 0.03237203f, 0.06874441f, 0.07092141f, 0.02460084f, 0.05405490f, 
    -0.19621313f, 0.01489055f, 0.11891901f, 0.08901937f, 0.01296308f, 0.07685202f, -0.02672860f, -0.01222849f, 
    0.05570775f, -0.06599014f, 0.20705195f, -0.00594941f, 0.06852823f, 0.14439255f, 0.10244650f, -0.13836005f, 
    -0.19466452f, -0.08932535f, 0.00961722f, -0.02338860f, 0.07465532f, -0.03849776f, 0.07005427f, 0.00309100f, 
    -0.32492325f, 0.08212644f, -0.10583648f, 0.02198794f, -0.16346395f, 0.20067832f, -0.05351717f, 0.00784386f, 
    -0.23877016f, -0.31112060f, -0.27113092f, -0.04210543f, 0.17894654f, -0.03508164f, 0.15942276f, -0.00942469f, 
    0.06595471f, -0.11692368f, -0.21985547f, 0.37597406f, 0.04064848f, 0.03417217f, -0.23320606f, 0.14059956f, 
    0.12942947f, -0.11690343f, 0.02940370f, 0.00070601f, -0.03136832f, 0.16034910f, 0.33514577f, 0.06504772f, 
    -0.10141508f, -0.00037498f, 0.12320164f, 0.06834917f, -0.07886618f, 0.05870426f, 0.18350951f, 0.14032274f, 
    0.15172954f, 0.06548359f, 0.03587192f, 0.07819419f, 0.13126138f, 0.05799480f, -0.15038872f, 0.01665708f, 
    0.07862309f, -0.10531382f, -0.15707724f, -0.14244294f, -0.15548117f, -0.01560874f, -0.02902506f, -0.22952330f, 
    -0.13489845f, -0.15975338f, 0.03561458f, -0.04628783f, -0.18497528f, 0.06809762f, -0.08218583f, 0.12298615f, 
    0.20268528f, 0.25904217f, 0.19705507f, 0.01604037f, 0.05537021f, 0.04784344f, 0.08019469f, -0.03105208f, 
    0.07386649f, 0.50003046f, -0.19992539f, 0.10701693f, 0.03747787f, -0.04334134f, 0.24542421f, 0.01977426f, 
    -0.03838358f, 0.04895856f, -0.03701314f, -0.13563374f, 0.10790498f, 0.07669501f, 0.04157113f, -0.08699880f, 
    0.11220405f, 0.26508743f, -0.00992582f, 0.02444563f, 0.15016839f, 0.15156384f, 0.00914856f, -0.03628699f, 
    0.04217429f, 0.00669509f, -0.02390389f, -0.02958864f, -0.03231427f, 0.01553746f, 0.14645436f, 0.12461535f, 
    -0.00399272f, 0.14319478f, -0.00838892f, -0.05806825f, 0.01306044f, 0.05346845f, -0.18072176f, -0.07347055f, 
    -0.11228735f, 0.07393792f, -0.08098637f, 0.06246134f, -0.13454194f, 0.06757481f, 0.17674008f, 0.09805381f, 
    0.01638156f, 0.00721567f, -0.00332493f, 0.13265699f, 0.11654969f, -0.16075031f, -0.11918875f, -0.17990857f, 
    -0.30081448f, 0.40187880f, 0.10431519f, -0.04101523f, -0.03661254f, 0.01989606f, -0.02430870f, -0.12442495f, 
    -0.05145482f, -0.25976181f, -0.16289149f, 0.03381095f, -0.06902413f, -0.07340620f, 0.30345061f, 0.04760330f, 
    0.06233787f, -0.06838929f, -0.03140001f, -0.29786614f, 0.10233780f, -0.01164039f, 0.04212542f, -0.05011016f, 
    0.04742597f, 0.21698199f, -0.20990209f, -0.09626746f, -0.02101830f, -0.01430004f, 0.06018030f, -0.03334797f, 
    0.04106662f, 0.01096864f, -0.04709984f, 0.02345030f, -0.19961961f, 0.09644412f, 0.01312085f, -0.18626997f, 
    0.02808071f, 0.01487769f, -0.03519040f, 0.10427310f, -0.05665477f, -0.17322265f, -0.12476522f, -0.06558033f, 
    -0.12067728f, -0.05219569f, 0.14634761f, -0.04567810f, 0.13402271f, -0.13230236f, -0.22156623f, 0.02616945f, 
    0.13305761f, -0.07263019f, -0.06002213f, -0.02542287f, -0.00668646f, 0.12758432f, -0.11806516f, 0.27420875f, 
    0.03800967f, -0.13316971f, 0.02534856f, 0.00218490f, -0.08087286f, -0.07066189f, 0.17737979f, 0.02830051f, 
    0.15323602f, -0.04198686f, 0.09427346f, -0.11567941f, 0.06214170f, -0.07112508f, 0.02621470f, 0.02470406f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.06199357f, 0.03617877f, 0.17544946f, -0.02880611f, -0.00864629f, 0.20939000f, -0.09825185f, 0.12535189f, 
    -0.06777847f, 0.01021137f, 0.22710402f, 0.11623488f, -0.06068029f, 0.04844410f, 0.09063841f, 0.04035470f, 
    0.11336236f, 0.05370056f, 0.05770583f, -0.07237495f, 0.08356983f, -0.03093565f, 0.33092436f, -0.05383981f, 
    0.02871109f, -0.06526812f, 0.15944844f, 0.15495034f, -0.11532371f, -0.04614919f, 0.04323867f, 0.22807756f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.42965871f, -0.03390789f, 0.04341123f, -0.20765312f, -0.13896479f, 0.12613431f, 0.07640900f, -0.53423142f, 
    0.06826174f, -0.09060139f, -0.11608683f, 0.16857962f, -0.10605873f, 0.21077622f, -0.06752719f, 0.13156316f, 
    -0.29451191f, 0.30848968f, 0.04866895f, 0.29092357f, -0.26313162f, 0.46466082f, -0.35266787f, 0.07272837f, 
    -0.16705793f, 0.42082855f, -0.16371535f, 0.74582624f, -0.12113553f, -0.11732661f, -0.10526019f, 0.11437093f, 
    -0.15495950f, -0.04381619f, 0.00915279f, -0.13145168f, 0.11529514f, 0.03765931f, 0.26046249f, 0.09437954f, 
    0.16016459f, -0.03173865f, -0.12848531f, -0.28198338f, 0.02389038f, 0.15452729f, -0.22635867f, 0.03587262f, 
    0.08457470f, 0.31889811f, -0.18282722f, -0.48377806f, 0.23318651f, 0.35768306f, 0.17777355f, 0.03757215f, 
    0.09388700f, -0.04916935f, 0.05423270f, 0.56724238f, -0.26482525f, 0.14396475f, 0.06180794f, 0.57691830f, 
    -0.17022134f, -0.10210769f, -0.12165599f, -0.14588894f, -0.11539665f, -0.38971531f, 0.02731271f, 0.03212587f, 
    -0.15968199f, 0.14314517f, 0.29219294f, -0.22479460f, 0.15748169f, 0.13646436f, 0.24640875f, -0.06084036f, 
    0.05187004f, -0.00981523f, -0.25667939f, -0.28437334f, -0.01183878f, -0.15837443f, 0.05652996f, -0.09064541f, 
    -0.10271354f, 0.03710246f, 0.14216933f, 0.02746015f, -0.05377658f, -0.09556488f, 0.16575044f, 0.26674065f, 
    0.38217369f, -0.03933910f, 0.26567191f, -0.27933723f, -0.00961658f, 0.27484626f, -0.17313246f, -0.39951479f, 
    -0.04013937f, -0.03023016f, 0.09154259f, 0.39272866f, 0.02207329f, -0.26955935f, 0.01145992f, 0.23592798f, 
    -0.02260111f, 0.49334455f, 0.14694749f, 0.01889958f, -0.16179547f, 0.22975576f, -0.37234956f, -0.10273740f, 
    -0.02839605f, 0.30010113f, -0.01672494f, 0.69508076f, -0.13043602f, -0.17178935f, 0.10103308f, 0.16536443f, 
    0.17867360f, -0.11574642f, -0.11711187f, 0.00044345f, -0.05931528f, 0.19235180f, -0.13387024f, -0.15908612f, 
    0.10126513f, -0.12707680f, 0.35901001f, 0.06291905f, -0.09055106f, -0.51881480f, 0.30558303f, 0.01509161f, 
    -0.18403204f, -0.21298526f, 0.19767505f, -0.20496881f, -0.06369768f, -0.20991160f, 0.46860319f, -0.06431182f, 
    -0.02719543f, -0.49082410f, -0.23438303f, -0.40266213f, 0.15274127f, 0.04783812f, 0.07580747f, 0.07270066f, 
    -0.03635876f, 0.03137224f, 0.22153123f, -0.08478857f, 0.00526255f, 0.00071014f, 0.18585579f, -0.20726900f, 
    0.11782994f, 0.05540974f, -0.10289893f, 0.44168860f, 0.08567192f, 0.12466696f, -0.00508697f, -0.14806598f, 
    -0.30543414f, -0.06967790f, -0.16422555f, 0.03576238f, 0.21107650f, 0.05590302f, -0.10563459f, 0.14989801f, 
    0.00205785f, -0.07781415f, -0.06860869f, 0.07402126f, -0.13877343f, 0.08216575f, 0.05032726f, 0.02818930f, 
    0.13494782f, -0.17887008f, 0.31206861f, 0.08778574f, 0.06024900f, -0.01045564f, -0.26973009f, -0.37739921f, 
    -0.03333166f, 0.06642657f, 0.04598610f, 0.45476645f, 0.14023538f, -0.54526591f, -0.03268809f, 0.26153004f, 
    0.05639920f, 0.31572896f, 0.30702412f, 0.28362098f, -0.15590955f, 0.18376128f, 0.07592341f, -0.02823539f, 
    -0.12060744f, -0.41319942f, -0.54323190f, 0.08458868f, 0.12288433f, 0.02336537f, -0.12561592f, 0.14512156f, 
    -0.07359777f, -0.09435126f, -0.05551742f, -0.11730116f, 0.03119575f, -0.12298760f, -0.07375679f, 0.04220586f, 
    -0.01500963f, -0.15739882f, -0.11049571f, 0.01775695f, 0.03523550f, 0.03591851f, 0.00115836f, 0.10198250f, 
    0.10556696f, -0.17420781f, -0.15186115f, -0.11346482f, -0.20747411f, 0.08161398f, 0.08480710f, 0.09182096f, 
    0.14652988f, 0.10090836f, -0.07404072f, -0.16968840f, 0.01810859f, -0.11002045f, 0.09134040f, 0.01694815f, 
    -0.12742215f, 0.07817367f, 0.21121295f, 0.16215698f, -0.11704877f, 0.02805214f, -0.12090532f, 0.14138071f, 
    -0.03319139f, -0.16525160f, -0.16677545f, 0.11313017f, -0.08774249f, 0.17669620f, -0.10274945f, -0.17339164f, 
    0.22657435f, 0.04383090f, -0.31207797f, 0.06764788f, -0.06112767f, -0.28856757f, -0.06160277f, -0.13589153f, 
    -0.06704446f, 0.11758438f, 0.10088661f, 0.27241266f, 0.05075755f, 0.15513092f, 0.15464500f, 0.08287572f, 
    -0.37954476f, -0.04927688f, 0.09606198f, 0.28207225f, -0.08548262f, 0.00889524f, -0.21758959f, 0.02385079f, 
    0.04782448f, -0.11593122f, 0.03110290f, 0.22563328f, -0.09412415f, -0.13362622f, 0.26521033f, -0.07933024f, 
    0.20672469f, -0.19758421f, 0.33859485f, 0.06401503f, -0.00592276f, -0.65338039f, 0.50811458f, -0.07236008f, 
    0.03914545f, -0.28263700f, -0.16767436f, 0.10695752f, -0.05384052f, 0.11042588f, 0.06402024f, -0.02289435f, 
    -0.01892131f, 0.00263360f, 0.02457393f, -0.29925388f, 0.04018175f, 0.19487815f, -0.18327889f, -0.35408717f, 
    -0.14756218f, -0.14638355f, -0.05266057f, 0.06909297f, 0.09238274f, -0.08254270f, 0.03826711f, -0.44438145f, 
    -0.05069938f, 0.46915799f, 0.13997255f, 0.01534301f, -0.05879413f, 0.16241139f, 0.30250555f, 0.08412455f, 
    -0.07893096f, 0.01797794f, -0.53314823f, 1.10143411f, -0.16621020f, 0.06926058f, 0.06558871f, 0.06373278f, 
    -0.18246637f, 0.12681010f, 0.00394285f, 0.06702872f, 0.11193914f, 0.08240944f, -0.18049933f, 0.32909796f, 
    0.02724771f, 0.01398745f, 0.18313655f, -0.12858911f, -0.02203546f, -0.02115793f, 0.44258758f, -0.34806865f, 
    0.39193115f, -0.27221766f, 0.33656862f, 0.06641170f, 0.06972293f, 0.23513280f, 0.39880446f, -0.00899081f, 
    0.10318803f, -0.23640215f, 0.40314457f, 0.50545818f, 0.03778066f, 0.00180837f, 0.05255668f, -0.02895946f, 
    0.07411159f, 0.11593385f, -0.01035907f, 0.05982166f, -0.02672650f, -0.12439368f, 0.01475473f, -0.18045165f, 
    -0.15336880f, -0.14046746f, 0.07382606f, 0.02426504f, 0.03039675f, 0.12093107f, 0.07343414f, 0.09545608f, 
    -0.07905529f, -0.06793997f, -0.02347722f, 0.05694529f, -0.16071692f, -0.07914786f, -0.14777879f, -0.15190114f, 
    -0.01416895f, -0.16366859f, -0.04758833f, -0.07574458f, 0.02243993f, -0.05747823f, -0.01892804f, -0.06771135f, 
    0.34480929f, -0.13699135f, -0.20101401f, -0.30556229f, 0.17935859f, 0.00670876f, 0.10618945f, 0.06191666f, 
    0.06991240f, -0.09103703f, 0.27835926f, -0.38016316f, -0.16456258f, 0.13888422f, 0.13539293f, -0.36458835f, 
    -0.08363599f, -0.08045560f, -0.10345540f, -0.20131522f, 0.24767292f, -0.03041868f, -0.11653162f, 0.13015963f, 
    0.01661706f, 0.16310064f, 0.18364786f, 0.03558336f, 0.14522299f, -0.14226405f, 0.12951054f, 0.25161132f, 
    0.57531345f, -0.05245416f, -0.23624003f, -0.12415356f, 0.16239515f, 0.07886978f, 0.27157491f, 0.16901852f, 
    -0.15096442f, -0.16391641f, 0.18226799f, -0.14994445f, -0.03152441f, -0.08834027f, 0.12467375f, 0.10885318f, 
    -0.29125950f, 0.02482240f, -0.01906220f, 0.01680283f, -0.05519341f, -0.21639431f, -0.30876935f, -0.04756736f, 
    -0.16097289f, 0.01071758f, 0.34965655f, -0.02976826f, -0.05321737f, -0.10814573f, -0.07745171f, -0.01580255f, 
    -0.02597111f, -0.00033125f, -0.03235025f, -0.21195386f, -0.02629451f, 0.19896492f, -0.02165646f, -0.19864736f, 
    -0.12773900f, -0.11505882f, 0.26497579f, -0.02038081f, -0.12037268f, -0.37609065f, 0.21495070f, 0.12690356f, 
    -0.06677163f, -0.09477297f, -0.04310023f, -0.37373513f, 0.29007292f, 0.07393220f, 0.41550043f, 0.16757517f, 
    -0.07607275f, -0.26724523f, -0.22526215f, -0.51027030f, 0.18598649f, 0.00938807f, 0.16819155f, 0.17152008f, 
    -0.15193824f, 0.13702376f, 0.16908415f, 0.22347172f, 0.12832125f, -0.21967237f, -0.05121785f, 0.00794491f, 
    -0.18389302f, 0.04735517f, 0.03845422f, -0.04234154f, 0.00007573f, -0.14399619f, -0.04051109f, -0.04045067f, 
    0.18530914f, -0.20103827f, 0.03208645f, -0.20678554f, -0.14578234f, 0.01738516f, -0.00242859f, -0.08505329f, 
    0.05641786f, -0.01082956f, -0.11283600f, 0.01807224f, 0.01771458f, -0.03538522f, -0.03756768f, -0.06410389f, 
    -0.04601486f, -0.05816383f, -0.15754221f, -0.08233377f, -0.17003964f, 0.09755057f, -0.13466430f, -0.26504275f, 
    -0.15978579f, 0.02529064f, 0.15298647f, 0.29353723f, 0.10527370f, 0.29281172f, -0.01504663f, 0.38764611f, 
    0.17730947f, 0.27036887f, 0.26979139f, 0.35783997f, -0.19914666f, 0.15134698f, -0.46691817f, -0.04598176f, 
    0.09106670f, 0.25709477f, 0.46592069f, -0.32261765f, 0.15602724f, 0.10730634f, 0.02293077f, -0.01078520f, 
    -0.12745629f, -0.02797318f, -0.02941474f, 0.00640359f, 0.10865691f, 0.00776813f, -0.03306573f, -0.16087529f, 
    0.16627920f, -0.00367093f, -0.09879003f, 0.09624062f, 0.12401463f, -0.03872598f, 0.08031096f, 0.01409900f, 
    -0.04149665f, -0.06224976f, -0.06127749f, -0.18066573f, -0.18438995f, -0.12145506f, 0.04570037f, 0.06960975f, 
    0.14683284f, -0.14750646f, 0.04952115f, -0.05314686f, 0.09126824f, -0.02167743f, -0.11225579f, -0.19566232f, 
    -0.27200407f, 0.03698293f, -0.21989417f, 0.29014394f, 0.09275839f, 0.13386972f, -0.00040826f, -0.00492464f, 
    0.09053597f, 0.16756158f, 0.12683867f, 0.09759290f, 0.08643036f, -0.21974237f, -0.13306464f, 0.26807374f, 
    0.31695721f, -0.09376105f, 0.21972649f, -0.53458446f, 0.32290119f, 0.19110315f, 0.12525509f, -0.06895425f, 
    0.16392998f, -0.54862559f, 0.21747541f, -0.06164372f, -0.19245079f, 0.07505689f, 0.14041646f, 0.34055263f, 
    0.17879698f, -0.00514298f, -0.02502208f, 0.11482535f, 0.16340683f, 0.22802010f, -0.08684164f, -0.25267941f, 
    -0.01195065f, -0.11204123f, 0.14689459f, -0.09969057f, -0.08006308f, 0.26778579f, 0.06900401f, 0.04819267f, 
    -0.14688726f, 0.25748822f, 0.22550383f, 0.30364287f, -0.36414814f, -0.03463503f, -0.49691054f, 0.17714186f, 
    -0.06935930f, 0.36348206f, -0.14626765f, 0.30003327f, 0.03570736f, -0.08939524f, 0.05698741f, -0.32839134f, 
    0.02616926f, -0.15172584f, 0.17648375f, -0.04217797f, -0.03486290f, -0.25826836f, -0.19299446f, 0.01212098f, 
    0.10108715f, -0.06775922f, 0.14880067f, -0.19566043f, 0.02815260f, 0.06746875f, 0.00815535f, 0.17153661f, 
    0.22617806f, -0.18076752f, 0.08466558f, -0.04796569f, 0.03455917f, -0.17730038f, -0.00801117f, -0.16563797f, 
    0.11060974f, -0.00322947f, 0.00366823f, 0.32950839f, -0.26257825f, 0.11542442f, 0.02796715f, 0.36046904f, 
    -0.08928815f, 0.15380919f, 0.03579821f, -0.12836753f, 0.12502462f, -0.10176132f, -0.16053465f, -0.18130676f, 
    0.15352868f, 0.13298449f, -0.15297331f, 0.07941412f, -0.16991934f, -0.16805463f, -0.16969524f, -0.01744878f, 
    0.09859255f, 0.06699990f, -0.12340399f, 0.07095312f, -0.10538438f, 0.09079476f, -0.08030722f, 0.12359751f, 
    -0.11083017f, -0.08229579f, 0.03162790f, 0.00011838f, -0.06055214f, 0.06843650f, -0.15041782f, 0.06240041f, 
    -0.09692074f, 0.03721051f, -0.47321779f, 0.51623166f, 0.06020655f, 0.19801806f, -0.06380995f, -0.30736354f, 
    0.13639349f, -0.01915805f, 0.38092840f, -0.06848227f, -0.01936838f, -0.09412361f, 0.09885652f, 0.22150765f, 
    0.26875010f, 0.04019012f, 0.16294689f, 0.31165445f, 0.03419257f, -0.09245906f, 0.02568751f, -0.16162169f, 
    0.05801440f, -0.02607652f, -0.06171314f, -0.92667323f, 0.21894401f, 0.06027748f, 0.07512572f, -0.29231533f, 
    -0.19004123f, 0.14331946f, 0.10755545f, 0.14718474f, -0.12965974f, -0.09677664f, 0.05191259f, 0.20533422f, 
    0.02928644f, 0.08392530f, -0.11209998f, 0.13829996f, -0.13383086f, 0.13725021f, 0.13595545f, 0.00759085f, 
    -0.11814012f, 0.09101292f, 0.10236503f, 0.10141870f, -0.05709162f, 0.04765334f, 0.48769319f, 0.05960765f, 
    0.02581247f, -0.17462419f, -0.24845153f, 0.62886679f, -0.08204561f, -0.06192130f, 0.05226123f, 0.29288423f, 
    -0.16094890f, 0.02431089f, 0.15949242f, 0.18270786f, 0.02387966f, 0.01270049f, -0.04599521f, 0.05182108f, 
    0.00534717f, 0.16763926f, 0.04213525f, 0.06009153f, -0.13798864f, 0.28133896f, 0.10241105f, 0.32745165f, 
    0.22182773f, 0.23548530f, -0.00732669f, -0.07355701f, -0.33413300f, -0.45443934f, 0.21638684f, -0.04803601f, 
    -0.12226366f, -0.02831042f, -0.15350573f, 0.60673451f, -0.38627639f, -0.11328739f, -0.05416680f, 0.17981379f, 
    0.40313873f, -0.13410361f, -0.13555200f, -0.19181159f, -0.17254531f, 0.07829550f, 0.09908452f, 0.19747037f, 
    0.07018832f, 0.02181907f, 0.26031893f, -0.02545128f, 0.16788885f, -0.26237813f, 0.33014992f, -0.41498342f, 
    -0.43172237f, 0.06164929f, -0.18062460f, 0.19840968f, -0.10270697f, -0.37534744f, 0.17802568f, 0.07063098f, 
    -0.06722393f, -0.13440129f, -0.08828550f, 0.00246627f, -0.15257753f, -0.03375242f, -0.10162454f, -0.10049397f, 
    0.29771915f, -0.04517370f, -0.08523958f, -0.24617532f, 0.09894105f, 0.20924665f, -0.02145233f, -0.24488461f, 
    -0.16440205f, -0.07473184f, 0.26476881f, -0.10057658f, 0.03667347f, -0.28356344f, 0.15974620f, -0.10169499f, 
    -0.24209100f, 0.34572136f, -0.17738359f, -0.38898081f, 0.31555521f, 0.41963452f, -0.15456322f, -0.15011270f, 
    -0.12466349f, 0.66326189f, -0.06970534f, 0.35066772f, -0.26291442f, 0.05450719f, -0.10017979f, 0.19669668f, 
    0.01717200f, -0.09631476f, 0.03608095f, 0.04745316f, -0.06444754f, -0.22845310f, -0.02949312f, 0.16264643f, 
    0.16605638f, -0.13036612f, -0.15551400f, 0.11124995f, 0.12064317f, 0.03622209f, 0.18086022f, 0.00661347f, 
    -0.13241084f, 0.24211149f, -0.00041586f, 0.22533922f, 0.19367032f, 0.26152635f, 0.22929628f, 0.08863348f, 
    0.03476479f, 0.14537282f, 0.07170903f, -0.24181896f, 0.12769635f, -0.16636172f, 0.09460288f, 0.25743300f, 
    -0.05566530f, -0.04704542f, -0.16585986f, -0.15342797f, 0.12838507f, -0.11603210f, 0.10279698f, -0.03760395f, 
    -0.05518655f, -0.08683369f, -0.02250069f, 0.13261522f, 0.07601414f, -0.06457816f, -0.09614080f, -0.08168019f, 
    -0.07078093f, -0.00487053f, -0.04959122f, -0.14973147f, -0.09938296f, -0.04109892f, 0.16182135f, -0.01155808f, 
    0.09601628f, -0.00566367f, 0.03052116f, -0.15857618f, 0.00805030f, 0.13014984f, -0.12027469f, 0.05339238f, 
    0.16240232f, -0.03620280f, -0.30376992f, 0.26579630f, 0.11235525f, -0.01690240f, -0.33672419f, -0.48483533f, 
    -0.03608124f, -0.00954109f, 0.21642396f, 0.61566973f, -0.05551109f, 0.06956127f, 0.31330228f, 0.09161946f, 
    0.01440474f, 0.00476531f, 0.31988996f, 0.40559971f, 0.03918763f, 0.42889076f, -0.26851425f, -0.09775057f, 
    0.00953627f, 0.30000666f, 0.15962395f, -0.48704156f, 0.33059001f, -0.09561504f, 0.01026234f, -0.32826972f, 
    -0.29321536f, -0.16968961f, 0.18365638f, -0.04842316f, 0.12624300f, 0.02384766f, -0.04165526f, -0.09711856f, 
    -0.06180326f, -0.16366793f, 0.08313127f, 0.16517729f, 0.03896398f, 0.18477106f, -0.24348792f, -0.00384151f, 
    0.32418475f, -0.00478971f, 0.14531736f, -0.25461823f, 0.02163867f, 0.20649302f, 0.16331537f, -0.15271099f, 
    -0.08056673f, 0.03885679f, 0.16233572f, 0.86004502f, -0.27350178f, -0.03262542f, -0.14675178f, 0.29525971f, 
    -0.26910821f, -0.02218507f, -0.12451191f, 0.30014133f, 0.14237660f, 0.12849095f, -0.27567065f, 0.07803950f, 
    0.05370108f, 0.14339414f, 0.13015650f, 0.06871784f, 0.07462616f, -0.06687627f, 0.25891152f, 0.30903581f, 
    0.08702501f, 0.08712768f, 0.20356461f, -0.17073116f, -0.00268588f, -0.10545070f, 0.65618747f, 0.10124008f, 
    -0.16923967f, -0.67292136f, -0.64988929f, -0.28550124f, -0.16181283f, 0.17533527f, -0.07735111f, 0.33157507f, 
    0.09506696f, 0.01398061f, 0.13437416f, 0.29342794f, 0.10935120f, 0.24644285f, 0.09090455f, -0.26236629f, 
    0.10519840f, 0.00666715f, 0.22796090f, 0.41855362f, -0.08672459f, -0.01779996f, 0.25826100f, 0.25836569f, 
    0.21640731f, -0.23124526f, -0.00780206f, -0.21312766f, -0.15538394f, -0.37644425f, 0.16174112f, -0.05068677f, 
    0.12471856f, -0.47492728f, -0.22213702f, -0.51037323f, -0.07760496f, -0.00865378f, -0.13693191f, -0.14995748f, 
    0.26831171f, -0.09947002f, -0.21479139f, 0.22233239f, -0.00975849f, 0.24713027f, -0.34062079f, -0.35034454f, 
    0.17453979f, -0.01780569f, 0.27125892f, -0.35653535f, 0.13411622f, -0.85386527f, 0.06289217f, -0.12737481f, 
    0.28423020f, 0.26489624f, 0.19968314f, 0.08749454f, -0.12929346f, -0.23828542f, -0.19729058f, 0.14631350f, 
    0.13386722f, 0.18047820f, -0.42278636f, -0.59380341f, 0.30037847f, 0.06894887f, -0.15016444f, -0.14237759f, 
    0.04120477f, 0.13724443f, -0.05946850f, -0.13416292f, 0.11590104f, -0.15793887f, 0.05325359f, -0.11213378f, 
    -0.10065221f, -0.14872441f, -0.12808384f, 0.12923254f, -0.06197254f, -0.12554960f, 0.17402658f, 0.07093135f, 
    0.10560773f, -0.04479849f, -0.12594071f, -0.02935059f, -0.21257311f, -0.04860971f, 0.08483752f, -0.03345507f, 
    -0.14397295f, 0.01133793f, 0.01633268f, 0.09081404f, 0.12111731f, 0.01437321f, 0.05825666f, -0.17955336f, 
    0.32942206f, -0.10827621f, -0.42187396f, -0.04808026f, -0.08973888f, 0.19306043f, 0.31821361f, 0.42377576f, 
    0.15031384f, -0.01620386f, 0.05243222f, -0.34101462f, -0.16521417f, -0.06019397f, -0.12756751f, 0.56658173f, 
    -0.09091833f, 0.00220168f, -0.20554478f, -0.43557036f, 0.02987313f, -0.04465350f, 0.02247287f, -0.09155817f, 
    -0.11047884f, -0.49956954f, 0.41024998f, 0.47975805f, -0.52225167f, -0.00174845f, 0.16214183f, 0.63663340f, 
    0.18041040f, -0.14523251f, -0.44965822f, 0.08566246f, 0.10101226f, 0.25848058f, 0.27057335f, 0.26062742f, 
    -0.08472906f, 0.07643653f, 0.30310079f, -0.41064626f, -0.07100201f, -0.36031005f, 0.09309708f, -0.25201589f, 
    -0.11549029f, 0.00424779f, -0.15495302f, -0.07363462f, 0.10815220f, -0.40454727f, 0.43099800f, -0.06898791f, 
    0.01177836f, -0.34477648f, -0.44682574f, 0.00587004f, -0.24230614f, 0.17245772f, 0.00661265f, 0.02385085f, 
    0.41393691f, -0.00179835f, 0.03389608f, 0.26843044f, -0.02109961f, 0.09397107f, -0.26598650f, 0.08248117f, 
    0.14784931f, -0.14869504f, 0.22311038f, 0.13247184f, 0.11301404f, -0.04158262f, 0.31906676f, -0.32409492f, 
    -0.22344033f, -0.25069493f, 0.05711686f, 0.14710629f, 0.03018136f, -0.29923829f, -0.00103675f, -0.02746565f, 
    -0.16960910f, -0.00761758f, 0.10920902f, -0.65152895f, 0.14075848f, -0.06689932f, -0.05694785f, -0.11919356f, 
    -0.02633845f, -0.14263926f, 0.06982350f, 0.36256561f, 0.00717100f, 0.11923342f, 0.05874940f, 0.07226273f, 
    0.03158042f, 0.02315757f, 0.16586301f, -0.12098967f, -0.05104493f, -0.08978421f, 0.18557011f, -0.23913039f, 
    0.34081161f, -0.20783010f, -0.11331683f, 0.12139183f, -0.03454177f, -0.78262216f, 0.16517055f, -0.15592332f, 
    0.00977797f, -0.19650209f, -0.04842754f, -0.29249254f, -0.16640396f, 0.14887911f, -0.01489779f, 0.09032872f, 
    0.06359874f, -0.13715135f, -0.29319760f, -0.08749075f, 0.04998975f, 0.07039683f, -0.07134519f, 0.13815829f, 
    0.07061424f, -0.16404498f, 0.18285878f, -0.58681154f, -0.00763854f, 0.06761189f, 0.09111926f, -0.45001161f, 
    -0.03412494f, 0.10485595f, 0.09141796f, 0.24163714f, 0.17950952f, -0.05394147f, 0.14868751f, -0.02026243f, 
    0.10731775f, 0.04035957f, 0.21647039f, 0.32205024f, 0.23948924f, 0.06642225f, -0.09987548f, -0.05311042f, 
    0.04063342f, -0.12264033f, -0.10857566f, 0.02284907f, -0.01944616f, -0.07003927f, -0.09094740f, -0.09544936f, 
    -0.17381573f, -0.07823505f, -0.02048019f, -0.09952696f, -0.11609779f, -0.06973860f, -0.14567730f, -0.09854287f, 
    -0.03250379f, -0.04067839f, 0.04655412f, -0.06645620f, 0.03683965f, -0.06916104f, 0.02906847f, -0.11987343f, 
    0.16064663f, 0.01546119f, 0.04344952f, -0.16725056f, 0.05091672f, -0.17507729f, 0.12954177f, -0.08626802f, 
    0.06346799f, -0.05600738f, 0.04772741f, 0.15226965f, -0.08876340f, -0.16605756f, -0.13990845f, 0.07999561f, 
    0.13400239f, 0.11194171f, 0.01591388f, -0.09326011f, 0.09648941f, -0.09056277f, -0.09200087f, -0.02285373f, 
    -0.15676950f, 0.11712765f, -0.16385455f, -0.15164720f, 0.03419656f, -0.17437418f, -0.09908664f, 0.04809974f, 
    0.11590301f, 0.00567781f, -0.01071293f, -0.16641620f, -0.05930057f, -0.06349546f, -0.11573894f, 0.10541843f, 
    -0.10418016f, 0.00637319f, -0.09905877f, -0.12755884f, 0.02022821f, -0.17352793f, -0.13745712f, 0.09632672f, 
    0.06287695f, 0.05676536f, 0.04521475f, -0.00627250f, -0.03816022f, 0.05595780f, 0.12406914f, 0.11914546f, 
    -0.11324624f, -0.00304912f, -0.13439730f, -0.08515564f, -0.14493315f, 0.04784239f, -0.21263954f, -0.01442290f, 
    -0.07256176f, -0.06597957f, -0.07221989f, 0.00796408f, 0.07921971f, 0.17150500f, -0.17404518f, 0.04553504f, 
    -0.35324386f, -0.10670318f, -0.21906693f, -0.04628171f, -0.06917274f, 0.06675537f, 0.19963345f, -0.23647815f, 
    -0.13963112f, -0.10887966f, 0.12488460f, 0.49711210f, 0.06392138f, 0.00534898f, 0.28299025f, 0.35663071f, 
    -0.04606516f, -0.35918671f, -0.04040873f, 0.00829161f, 0.06269038f, 0.01009795f, 0.37463894f, -0.06204343f, 
    0.13126202f, 0.09012893f, 0.13813376f, -0.04695453f, -0.17378370f, -0.07459055f, 0.05647803f, -0.06380883f, 
    -0.07931233f, -0.07147341f, -0.04962288f, 0.10528646f, -0.03459712f, 0.01582270f, -0.06367251f, -0.03041139f, 
    -0.12301374f, 0.11498361f, -0.10980730f, 0.33699498f, -0.15691008f, 0.27355880f, 0.18676367f, -0.04577191f, 
    0.25010729f, 0.13318378f, 0.13129006f, 0.37710324f, -0.31199363f, -0.01519985f, 0.19333543f, -0.05500538f, 
    -0.02134593f, 0.28371763f, 0.18685679f, 0.59507519f, 0.00731978f, 0.07389926f, 0.04382078f, -0.28543222f, 
    -0.16244410f, -0.18047149f, -0.01682938f, 0.14499120f, 0.12038710f, 0.23931932f, -0.05762933f, -0.09794097f, 
    -0.05998549f, 0.11885864f, 0.27846205f, 0.02597287f, -0.08155106f, -0.00913459f, 0.21549520f, -0.42252734f, 
    0.34333140f, -0.16468848f, 0.21182938f, 0.10892779f, -0.01480992f, 0.23856130f, -0.09981103f, 0.07818841f, 
    -0.04634421f, -0.02389072f, -0.29611117f, -0.45428279f, 0.36224225f, -0.12052328f, -0.15608966f, -0.26464489f, 
    -0.04866812f, -0.05516450f, 0.11500653f, 0.01738818f, -0.03896683f, -0.17931326f, -0.02102612f, -0.00982652f, 
    -0.16304827f, -0.05666726f, -0.05257899f, 0.02058699f, 0.02205431f, 0.26954600f, 0.03431102f, -0.00486695f, 
    -0.06700111f, 0.33181334f, 0.20806900f, 0.16826521f, -0.10144840f, 0.28600425f, 0.00778703f, -0.09489219f, 
    0.04880667f, -0.04002155f, 0.21901032f, 0.14416052f, 0.18812826f, 0.15800586f, 0.07453561f, 0.06799202f, 
    0.00812970f, 0.15379986f, -0.10036560f, -0.06707219f, 0.09315287f, 0.18878110f, 0.22440384f, -0.15076941f, 
    0.02951894f, 0.16180755f, 0.22901177f, 0.37638631f, -0.04379670f, -0.18650571f, -0.25890616f, 0.43833199f, 
    -0.21636526f, 0.31231198f, -0.10422732f, -0.13989505f, 0.31976172f, 0.42048553f, -0.35405424f, 0.14345394f, 
    -0.11261380f, -0.04184852f, -0.11285784f, -0.38108838f, -0.00279076f, -0.06203774f, 0.10687672f, 0.36819643f, 
    0.10401230f, -0.07175773f, 0.07297082f, -0.10248350f, 0.06844594f, -0.13333893f, -0.14094998f, -0.22632751f, 
    -0.05518666f, -0.09332988f, -0.09090595f, -0.19997688f, -0.02026290f, 0.02487585f, -0.01089749f, -0.03292489f, 
    0.09182540f, -0.03210051f, -0.12630272f, 0.06594463f, 0.05880774f, 0.13039184f, -0.18585962f, -0.15367009f, 
    0.02453857f, -0.20421785f, 0.01654031f, -0.05945165f, -0.08976071f, 0.13738106f, -0.16547649f, 0.09558907f, 
    -0.12651913f, -0.07899333f, -0.10758317f, 0.11223469f, 0.05908006f, -0.15074730f, -0.08560842f, -0.14169438f, 
    0.11265037f, -0.03867216f, 0.05718871f, -0.06757786f, -0.10567875f, 0.10458305f, -0.12930724f, -0.06790506f, 
    0.11656304f, -0.12700769f, -0.00453707f, -0.16319363f, -0.16713105f, -0.14905980f, 0.11179855f, 0.16154784f, 
    -0.02864487f, -0.01533684f, -0.08386695f, -0.09320946f, 0.14656024f, 0.12161361f, 0.09050776f, 0.07360169f, 
    -0.16679251f, 0.06704496f, 0.11500736f, 0.06471936f, 0.05341106f, 0.01782972f, 0.00283508f, 0.00223891f, 
    -0.10514039f, -0.07086719f, 0.02995699f, -0.38866836f, 0.18022157f, 0.17239220f, 0.29925117f, -0.60705954f, 
    0.14096813f, 0.02359776f, 0.24220507f, -0.03092441f, 0.13752675f, 0.08294994f, 0.26915234f, 0.09353507f, 
    -0.14890385f, 0.06138457f, -0.49799189f, 0.26633283f, 0.12334079f, -0.09268628f, -0.16820054f, -0.08117513f, 
    0.01042366f, 0.04319292f, -0.04872575f, -0.32937649f, -0.06935589f, 0.00701646f, 0.03844884f, 0.04294521f, 
    -0.03134255f, -0.16106315f, -0.01265293f, 0.13104713f, 0.14527410f, 0.17044376f, -0.02586863f, 0.00028254f, 
    -0.16205950f, 0.25579962f, -0.05436770f, 0.09451123f, 0.12269502f, 0.29204953f, 0.12359720f, 0.14638396f, 
    0.08943748f, 0.43419719f, 0.21611181f, 0.27454871f, -0.01203333f, -0.08321308f, -0.12662807f, -0.13836460f, 
    0.46303701f, -0.11905348f, 0.13582158f, -0.26701346f, 0.02414508f, 0.03067436f, 0.14374988f, 0.07688352f, 
    -0.14228694f, -0.11457302f, 0.07790425f, 0.05376189f, -0.09586851f, 0.08177742f, 0.18932757f, -0.31347331f, 
    -0.41627380f, 0.18194094f, -0.23983990f, -0.08858365f, 0.04788050f, -0.18340251f, 0.26724413f, -0.02343944f, 
    0.07091326f, -0.00214497f, 0.13255116f, 0.24612437f, -0.04094023f, -0.04914274f, 0.08909932f, 0.27147120f, 
    -0.12681590f, 0.08473172f, 0.38800421f, 0.33283401f, -0.13227481f, 0.06111872f, -0.34864920f, -0.13471498f, 
    -0.06820774f, -0.07036199f, 0.21249910f, 0.31348485f, -0.10667877f, 0.07568815f, 0.36769935f, -0.05109661f, 
    -0.02005062f, 0.02279939f, 0.42324275f, 0.03849546f, -0.26569134f, 0.01256898f, 0.50962853f, 0.06204062f, 
    0.08989164f, -0.50950694f, -0.57273096f, -0.44612473f, -0.08715875f, 0.00063937f, 0.01038549f, 0.14427377f, 
    0.16967683f, 0.11441372f, -0.16702846f, -0.08082427f, 0.07521111f, -0.01460080f, 0.04238947f, 0.09693006f, 
    -0.00336363f, 0.03647302f, 0.18021673f, -0.53716141f, 0.08435912f, -0.28840837f, 0.10543091f, -0.38904038f, 
    0.37132075f, 0.14558691f, -0.21612446f, -0.22699623f, 0.36537996f, -0.10636679f, 0.36639050f, -0.18602970f, 
    0.04549910f, -0.11657757f, 0.42108053f, 0.34880316f, -0.29650310f, -0.15945965f, 0.00284346f, 0.38457131f, 
    -0.20926493f, -0.05395930f, 0.00779580f, 0.43549851f, -0.17449917f, 0.03562406f, 0.01799771f, 0.09461073f, 
    -0.11193097f, 0.13521695f, 0.01509592f, 0.32859164f, -0.06454661f, -0.03797872f, -0.18242896f, 0.60266399f, 
    0.17774673f, 0.19846907f, 0.06808253f, -0.26957059f, -0.04215995f, 0.16433656f, -0.35473579f, 0.01086374f, 
    -0.16415447f, -0.44724607f, -0.04501973f, -0.27720702f, -0.24140035f, -0.06412587f, 0.05628746f, 0.14100482f, 
    -0.08009042f, 0.03176940f, -0.09177922f, -0.06200248f, 0.05238621f, 0.12013817f, -0.02929641f, 0.14551823f, 
    0.05538072f, -0.06996882f, -0.18649645f, 0.09625677f, -0.04966861f, 0.14703535f, -0.10209819f, -0.09441838f, 
    0.01599221f, 0.05132686f, 0.10756611f, 0.06742095f, 0.14045160f, -0.45064288f, -0.32730693f, 0.15238608f, 
    -0.04316228f, 0.25634032f, -0.01505397f, -0.15664285f, 0.08608436f, -0.06530894f, -0.05474349f, -0.03636519f, 
    0.32383037f, -0.08328231f, -0.40026829f, -0.14020182f, -0.17525464f, -0.09055977f, -0.01200133f, 0.10367996f, 
    0.14380299f, -0.03439645f, 0.20177133f, -0.03613700f, 0.00280007f, -0.08715949f, 0.12752642f, 0.21520443f, 
    0.20709392f, -0.18263973f, -0.00856792f, 0.11627945f, 0.13697889f, -0.08433308f, -0.20885590f, -0.03100630f, 
    0.01116014f, -0.29308581f, 0.63339275f, 0.21880735f, 0.09822617f, 0.06410003f, 0.04020653f, 0.38328534f, 
    -0.28812185f, -0.13313247f, -0.10407823f, 0.31874451f, -0.05989731f, 0.17231275f, 0.17675731f, 0.07668144f, 
    0.02751406f, -0.02241655f, -0.00942534f, -0.64857030f, -0.04229951f, -0.03772391f, -0.18704087f, 0.10550550f, 
    0.37395617f, -0.15454869f, 0.18887000f, 0.05920782f, -0.07146408f, -0.49413729f, -0.16920680f, -0.02896562f, 
    -0.03055536f, 0.02966578f, 0.32449898f, -0.06335675f, -0.19992861f, 0.05686735f, -0.04546501f, 0.06057977f, 
    0.33003876f, 0.06916304f, -0.04794285f, -0.09099956f, -0.15274049f, 0.00469969f, 0.13667934f, 0.17986844f, 
    0.08032446f, 0.04000815f, -0.11581908f, -0.08148568f, -0.07566202f, 0.20080456f, 0.24786744f, 0.16955122f, 
    -0.03464391f, 0.27404308f, -0.04375722f, 0.46134722f, -0.22791047f, 0.00678871f, 0.06091793f, -0.05422160f, 
    0.12485734f, 0.23751582f, -0.19803154f, 0.01285003f, 0.05226212f, -0.06741457f, -0.15215857f, -0.39513025f, 
    -0.06603483f, 0.09541759f, 0.08377249f, -0.08027259f, 0.11903141f, 0.23050596f, 0.25627312f, -0.24057491f, 
    0.16719335f, -0.18514626f, -0.04643200f, 0.49666631f, 0.00161736f, 0.08412714f, -0.18466015f, 0.51881063f, 
    -0.25591511f, 0.00633679f, 0.06609919f, -0.27465022f, 0.25220108f, 0.42056745f, -0.00795508f, -0.03470610f, 
    -0.07531630f, 0.13697152f, 0.14014010f, -0.51886928f, -0.22117722f, 0.02654497f, -0.09707884f, 0.10483819f, 
    -0.00907247f, -0.07513236f, -0.51208687f, 0.20360367f, -0.04722871f, 0.10850401f, -0.19483717f, 0.09588546f, 
    -0.03237347f, 0.09699623f, 0.32019633f, -0.19408633f, 0.02935637f, -0.11803968f, -0.06867025f, 0.17103362f, 
    0.39481750f, -0.11516272f, 0.04816442f, 0.07055322f, -0.00285651f, 0.13923019f, -0.17787673f, -0.00484885f, 
    -0.09856080f, -0.65957606f, 0.30861115f, -0.11103417f, -0.04934615f, 0.06090719f, 0.03204039f, 0.29007867f, 
    -0.04845516f, 0.05366288f, -0.11104063f, -0.15114494f, -0.13729276f, 0.03299922f, 0.01411721f, -0.12541014f, 
    -0.03422464f, -0.07337113f, -0.23219308f, 0.23380117f, 0.00693381f, 0.04174781f, -0.16091430f, 0.04271359f, 
    0.06201627f, 0.19658521f, 0.09606364f, 0.07790122f, -0.23097067f, 0.38295838f, -0.10305525f, 0.10225565f, 
    0.10848124f, 0.33341178f, -0.20075709f, 0.04463722f, 0.05206693f, -0.07763311f, -0.16946569f, -0.32731324f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.05670917f, 0.35316086f, 0.40392542f, 0.38982493f, 0.32378829f, -0.28957307f, 0.07735163f, 0.15973203f, 
    0.30685124f, 0.22012861f, 0.24870276f, 0.04989166f, -0.00536575f, 0.01854630f, -0.11618887f, 0.06328454f, 
    -0.04293612f, -0.14848849f, -0.17173268f, 0.04060661f, 0.07015833f, 0.09583171f, 0.05367305f, 0.16374837f, 
    -0.00529868f, 0.20572712f, -0.04520806f, 0.34799826f, 0.09215609f, 0.00713621f, 0.07915729f, 0.13404974f, 
    0.31677139f, 0.24016483f, 0.02491349f, 0.16761863f, 0.30636540f, 0.10445195f, -0.13438232f, 0.07384188f, 
    0.01733179f, 0.01857549f, 0.14076109f, -0.05625204f, 0.24092996f, 0.12106419f, -0.01125081f, -0.05485830f, 
    -0.01133439f, -0.19408138f, -0.07281045f, 0.17622937f, -0.04076113f, 0.02873202f, -0.00368738f, 0.01838509f, 
    0.15153334f, -0.06597887f, -0.11500098f, -0.11116018f, -0.10051070f, -0.12316707f, 0.25516871f, -0.18582584f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.30233958f, -0.06394586f, -0.04521159f, 0.16991289f, -0.77504164f, -0.02405514f, -0.02765309f, 0.01644567f, 
    -0.01847358f, -0.06223516f, 0.15272780f, -0.31917700f, -0.06607981f, -0.17911620f, 0.01793916f, -0.25747439f, 
    -0.10434843f, 0.01452070f, 0.11514499f, -0.66904211f, 0.31558174f, -0.21537897f, -0.03414599f, -0.02930387f, 
    -0.01783102f, -0.11959881f, -0.25199461f, 0.23045690f, 0.03816406f, 0.05559433f, 0.11918477f, -0.12496869f, 
    -0.89725882f, -0.57548153f, 0.21137764f, -0.03364789f, -0.43327487f, -0.51655698f, -0.10474633f, -0.24078502f, 
    0.05301755f, 0.03397240f, -0.00992241f, 0.00628467f, 0.01425732f, 0.19188821f, -0.04117724f, 0.01949345f, 
    -0.00997873f, -0.07543003f, -0.04511773f, 0.05297956f, 0.16132483f, -0.11032478f, -0.33494040f, -0.05886079f, 
    -0.27879217f, 0.05722996f, -0.30146253f, -0.27755713f, 0.28340927f, 0.06954209f, -0.66358525f, 0.42548886f, 
    0.27851355f, 0.28183258f, 0.46282211f, 0.20587443f, -0.33374712f, -0.11563867f, 0.02293323f, -0.07209745f, 
    0.14077760f, 0.01351592f, 0.32708642f, -0.02439119f, -0.03933444f, 0.08352666f, 0.15068966f, -0.31490874f, 
    0.11013521f, -0.12215021f, 0.08520292f, -0.21816179f, -0.04341036f, 0.08895414f, 0.12030692f, -0.97601807f, 
    0.19124255f, 0.50818825f, 0.25891790f, 0.07776792f, 0.00984215f, -0.03355516f, -1.03751600f, 0.13698280f, 
    -0.27575535f, -0.39227432f, -0.54846561f, -0.04604036f, 0.40925843f, 0.00800420f, -0.30523115f, -0.02884332f, 
    0.07921202f, -0.02546656f, 0.06027819f, 0.05740275f, -0.25039664f, 0.02299253f, -0.40952244f, 0.09875043f, 
    -0.04845547f, -0.06813018f, 0.06997328f, 0.03953671f, -0.01682354f, 0.20925128f, -0.38155478f, 0.15478440f, 
    -0.20446251f, -0.04019487f, 0.03203407f, 0.08182768f, 0.03668642f, -0.00793735f, -0.22241932f, -0.70891863f, 
    -0.82082838f, -0.13880827f, -0.01214956f, -0.05854230f, 0.31754160f, 0.12398809f, 0.13951071f, 0.02793426f, 
    0.14035815f, 0.06496410f, 0.15254602f, -0.10753224f, 0.05352019f, 0.01708313f, -0.03819647f, 0.14751911f, 
    -0.00491893f, -0.39235398f, -0.13378148f, -0.09524512f, -0.48197174f, -0.03352602f, 0.01528772f, 0.17536715f, 
    0.13025972f, -0.12297609f, 0.37593889f, 0.05509013f, 0.13563204f, 0.06777120f, -0.53884757f, -0.29924378f, 
    0.21942852f, 0.02570774f, 0.61310863f, 0.11736254f, -0.10873298f, 0.36706468f, 0.23657617f, 0.08701528f, 
    0.04563038f, 0.01165222f, -0.09264771f, 0.02271463f, -0.45082861f, -0.24638109f, 0.07671529f, -0.08037721f, 
    -0.19145507f, 0.05220810f, -0.03729252f, 0.16876408f, -0.21041262f, 0.04218988f, 0.20960143f, 0.10510975f, 
    -0.28070071f, 0.20298094f, -0.19165948f, -0.23871008f, -0.03494183f, -0.25052592f, 0.10746331f, -0.17069755f, 
    0.17519741f, -0.61218387f, -0.06612585f, 0.04534788f, 0.14080760f, 0.65949589f, 0.02532473f, -0.04677588f, 
    -0.22057912f, -0.71063513f, -0.11445157f, -0.28997266f, -0.05375193f, 0.13867620f, 0.29242077f, 0.04595616f, 
    -0.00921666f, 0.22852321f, -0.11496336f, -0.39233232f, 0.14816773f, -0.03830480f, -0.09304623f, 0.27754521f, 
    -0.52603704f, -0.21761593f, 0.36444843f, -0.05717167f, -0.34289521f, -0.06790779f, 0.14277066f, -0.61137366f, 
    -0.16678184f, 0.14860648f, 0.18811360f, -0.03297955f, -0.28091606f, -0.02894722f, 0.57684004f, -0.28140900f, 
    -0.03412601f, -0.10138288f, -0.02899941f, 0.04193164f, -0.25688294f, -0.16814515f, 0.23940018f, -0.01297555f, 
    0.06546069f, 0.09506757f, -0.06208282f, -0.10794071f, -0.14282924f, 0.08614226f, 0.14090611f, -0.53303319f, 
    -0.14551726f, -0.24906805f, -0.09691646f, -0.53254879f, 0.10067115f, 0.06278906f, -0.14236593f, -0.33703348f, 
    0.10754804f, -0.09079270f, -0.24603473f, 0.17320207f, -0.10624453f, -0.06194958f, 0.32020724f, 0.03994526f, 
    0.17515337f, -0.26527047f, 0.02062923f, -0.02556473f, 0.06132458f, -0.27169681f, -0.23256011f, -0.03488486f, 
    -0.18949473f, 0.26306203f, -0.00561314f, 0.08025156f, -0.01888433f, -0.15622242f, -0.07593448f, -0.00982715f, 
    -0.05119418f, -0.05383676f, -0.71260780f, -0.09408761f, 0.03293680f, 0.03314081f, 0.08960652f, -0.00890720f, 
    0.21802978f, -0.19957824f, -0.07323034f, -0.07692767f, -0.16040824f, -1.02751935f, -0.37005153f, 0.08510695f, 
    -0.22496688f, -0.01844297f, 0.02670960f, -0.04687734f, -0.35505509f, 0.01868766f, 0.00302388f, 0.20918162f, 
    0.16852602f, 0.05408008f, -0.10069527f, -0.22011191f, -0.07412256f, -0.20159355f, 0.38049296f, -0.86463845f, 
    0.47360244f, 0.16914259f, -0.15753618f, 0.13956830f, -0.02581648f, 0.10153655f, 0.09698656f, -0.02676381f, 
    0.07279696f, 0.24424757f, -0.33004150f, 0.06239124f, -0.13424575f, -0.21813691f, -0.16657536f, 0.10036253f, 
    -0.05287684f, -0.48478067f, 0.13134061f, -0.04646065f, 0.04721050f, 0.23549041f, -0.16825935f, 0.14973299f, 
    -0.02738497f, 0.08924048f, 0.04072930f, 0.16386098f, -0.19423896f, -0.17507805f, 0.08177167f, -0.02674152f, 
    -0.12592097f, -0.28156486f, -0.25601822f, 0.26000482f, -0.04239330f, 0.05259473f, -0.09682629f, 0.13837215f, 
    -0.05601677f, -0.31151882f, -0.21382573f, 0.05024980f, 0.00946644f, -0.09109078f, -0.51317918f, -0.33769307f, 
    0.18395643f, 0.00164787f, 0.05368714f, 0.01171127f, 0.00786210f, -0.11392726f, 0.16943704f, 0.07440314f, 
    0.13133454f, 0.02085470f, 0.04033666f, 0.21286084f, 0.05504040f, -0.01116410f, -0.11998757f, 0.07284416f, 
    -0.24255848f, 0.16542529f, -0.04774935f, 0.04896417f, -0.21607636f, 0.12303098f, 0.03800723f, 0.01824713f, 
    -0.19916488f, -0.10507388f, -0.12527716f, -1.19760859f, 0.33480567f, 0.04246755f, -0.63026243f, -0.05434053f, 
    -0.09167042f, 0.33218241f, -0.42396715f, 0.29062125f, -0.08436447f, -0.03776100f, -0.42410859f, 0.03553846f, 
    -0.11022346f, -0.39629674f, 0.07109231f, 0.17136371f, -0.61578482f, -0.05797783f, -0.06669085f, 0.10859944f, 
    0.09133651f, 0.20953983f, 0.21797341f, -1.00970268f, -0.15500902f, -0.13118033f, -0.69275326f, -0.07197938f, 
    0.53127128f, 0.02743881f, -0.47472033f, 0.08174063f, -0.34340283f, 0.50481880f, 0.11770939f, 0.21188341f, 
    0.24027215f, -0.03504820f, 0.06898767f, 0.07971384f, 0.10753866f, -0.08200466f, 0.24584194f, -0.08991169f, 
    -0.72879893f, -0.01332716f, -0.05890962f, 0.27215064f, -0.24714966f, -0.25995433f, 0.32419395f, 0.14141387f, 
    -0.47424507f, -0.01434392f, -0.22736298f, 0.12645049f, -0.13239117f, -0.20907225f, 0.02255062f, -0.12242556f, 
    -0.11209360f, -0.11541221f, -0.17923516f, -0.39204019f, -0.44702429f, -0.15375221f, -0.46630087f, 0.10205539f, 
    -0.16279045f, -0.18838212f, -0.63708901f, 0.04402282f, -0.09979179f, 0.20631495f, 0.32362381f, -0.34095868f, 
    -0.00454530f, 0.24457595f, -0.03144246f, -0.36012518f, 0.17312412f, -0.40459308f, 0.03252080f, 0.30956149f, 
    -0.04925678f, -0.22545224f, -0.08994538f, -0.41949430f, -0.14658217f, -0.12682992f, 0.46295574f, -0.13242692f, 
    -0.31450674f, -0.31252140f, -0.23861834f, -0.04592845f, -0.09620772f, -0.28760844f, 0.07873516f, -0.00798824f, 
    0.27716908f, 0.08831099f, 0.02953820f, 0.06444971f, 0.06467355f, 0.17099640f, -0.17405377f, -0.00017459f, 
    -0.07103664f, 0.08482298f, -0.08976758f, -0.15534563f, 0.03397575f, 0.00118117f, -0.85643756f, 0.08670850f, 
    -0.32167053f, -0.00219301f, 0.34655672f, 0.11488181f, 0.18427761f, -0.13071571f, 0.21360084f, -0.00441064f, 
    -0.19383563f, 0.11262690f, 0.00870087f, -0.09056291f, 0.18842696f, 0.07408886f, -0.91768366f, 0.01067835f, 
    -0.11816584f, -0.03413308f, -0.70607769f, 0.14663196f, -0.13534686f, 0.13128328f, 0.29697022f, 0.24328940f, 
    -0.23694618f, -0.13303417f, -0.09172896f, 0.28347063f, -0.89848852f, 0.11182836f, 0.02484547f, -0.15046437f, 
    -0.12549233f, -0.67801750f, 0.32220075f, -0.02040405f, 0.14829811f, 0.12593141f, 0.04503577f, -0.04147759f, 
    -0.60453367f, -0.05840142f, -0.32586354f, 0.03548237f, 0.32777807f, 0.09934160f, 0.37487432f, -0.02742335f, 
    0.10406370f, 0.12148710f, 0.03928537f, -0.08391993f, 0.13465062f, -0.47603491f, -0.13468145f, -0.08700324f, 
    0.16001534f, 0.07075077f, 0.02372846f, -0.23042360f, -0.02850423f, 0.15924062f, -0.77230078f, 0.30848986f, 
    -0.29605237f, -0.17607053f, 0.38222784f, -0.10779354f, -0.60766906f, 0.23730808f, 0.27028248f, -0.04226593f, 
    -0.17534314f, -0.33427513f, 0.13928488f, 0.02673617f, 0.10424013f, -0.26590180f, 0.20636117f, 0.07212590f, 
    -0.09748525f, 0.31342545f, 0.25084588f, 0.13517547f, -0.07386403f, -0.37535843f, -0.42406565f, 0.02514812f, 
    -0.25342882f, 0.10306627f, 0.03893625f, -0.14515825f, -0.21087629f, -0.21341877f, -0.06246018f, -0.03095807f, 
    0.17330304f, 0.26436576f, -0.13745911f, -0.25690076f, -0.09145098f, 0.00274747f, 0.22256014f, 0.18576041f, 
    0.06808076f, 0.27431226f, -0.16474685f, 0.11597839f, -0.72945970f, -0.31657523f, 0.09264460f, 0.00001042f, 
    -0.16132042f, 0.11010180f, 0.10832840f, 0.04217134f, 0.34716624f, 0.36465761f, 0.10374146f, 0.06486302f, 
    -0.34975761f, -0.04111575f, -0.04718725f, 0.07971548f, -0.00073700f, 0.01885498f, 0.36466116f, -0.31117111f, 
    -0.29218480f, -0.26738238f, -0.12140065f, -0.28117320f, -0.06823833f, -0.00240839f, -0.31143752f, -1.12834704f, 
    -0.13105606f, 0.18598050f, 0.01438903f, -0.03279708f, 0.13479362f, 0.08479213f, -0.18894404f, 0.07706739f, 
    -0.63781989f, -0.15488708f, -0.55469763f, -0.58514941f, 0.09562982f, -0.14860256f, 0.10219620f, 0.27277964f, 
    -0.18259165f, -0.08389866f, 0.01135431f, 0.24699752f, -0.41744047f, -0.06462341f, 0.02731899f, 0.19991562f, 
    -0.02454216f, 0.12482070f, -0.04517853f, 0.11284263f, -0.08361073f, -0.07014653f, -0.50713432f, -0.16946137f, 
    0.32536012f, 0.23088770f, -0.37531841f, -0.00049210f, 0.39997530f, 0.26940465f, -0.31700104f, -0.25113583f, 
    -0.63375860f, 0.03402865f, -0.07584576f, -0.12115256f, 0.40086228f, -0.53531462f, -0.36027381f, -0.35134146f, 
    0.34435001f, -0.06002222f, -0.10342975f, -0.33435243f, -0.05430542f, -0.05720406f, -0.07757957f, -0.20587681f, 
    0.40928534f, -0.11472599f, -0.19524948f, -0.28077522f, 0.05687322f, 0.42540395f, -0.13079000f, -0.48312354f, 
    -0.28050235f, 0.04071596f, -0.31415418f, -0.10034619f, -0.09895345f, 0.04690318f, -0.25491178f, 0.06562256f, 
    -0.00255190f, 0.19359319f, -0.82713467f, -0.04728029f, -0.08454277f, -0.23758908f, -0.07237510f, -0.15505598f, 
    0.22734459f, 0.04300638f, -0.05631807f, 0.40406880f, -0.10347464f, 0.11334535f, 0.05336105f, 0.30909857f, 
    -0.11467399f, 0.27772304f, -0.68010950f, -0.47577667f, -0.63650781f, -0.07975714f, -0.05712315f, 0.21169412f, 
    -0.05506744f, 0.21121073f, 0.24794380f, -0.02679271f, 0.27084652f, -0.03208611f, -0.22994803f, 0.23689245f, 
    -0.11594768f, 0.12208588f, 0.06011811f, -0.05817217f, -0.01171572f, -0.07131518f, 0.03551738f, -0.16939615f, 
    -0.00581202f, -0.12354608f, 0.10635153f, -0.21790560f, -0.37078544f, -0.45928878f, -0.29230973f, 0.09128508f, 
    0.52836424f, -0.23615241f, 0.22602677f, 0.36105132f, -0.49632475f, -0.03064637f, 0.52645808f, -0.22057849f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09069872f, 0.03573357f, -0.06324497f, -0.09865696f, -0.02503703f, 0.09896199f, -0.01499285f, -0.01859512f, 
    0.04313107f, -0.00175948f, -0.10848842f, 0.09505556f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
