#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.66720486f, -0.73610616f, -0.92689425f, -0.50142378f, -0.44863471f, 0.04710305f, 0.12164780f, 0.26467907f, 
    0.23288129f, -0.01648516f, 0.29666060f, 0.45257324f, 0.25844222f, 0.00858502f, 0.02084152f, 0.22311582f, 
    -0.19071482f, -0.24614067f, -0.15589963f, -0.15665860f, 0.00490569f, 0.14334618f, -0.01799328f, 0.14583156f, 
    0.00062698f, -0.24932250f, 0.16568737f, 0.03338924f, 0.19088408f, 0.33810678f, 0.54297042f, -0.57968861f, 
    -0.01258112f, 0.09840684f, 0.27661073f, 0.19819829f, 0.03262547f, -0.25973073f, 0.19153595f, -0.24424520f, 
    0.10818113f, 0.00224512f, -0.27521104f, 0.12792885f, -0.31316242f, -0.39346522f, 0.08423498f, -0.03173267f, 
    0.04124706f, -0.20140433f, -0.13229407f, -0.03048025f, 0.44788760f, 0.78471082f, -0.29018801f, -0.13002345f, 
    -0.43628830f, -0.09070188f, 0.11904053f, 0.05274918f, -0.01504409f, -0.29810145f, -0.07943574f, 0.23385863f, 
    0.28365010f, -0.17598708f, 0.34987119f, -0.03724121f, 0.08048042f, -0.12390546f, 0.15259431f, 0.08262999f, 
    -0.15023820f, -0.04071670f, -0.22840081f, 0.33362237f, 0.56255913f, -0.26068187f, -0.12484919f, -0.29060084f, 
    -0.07618972f, -0.26575902f, 0.27390587f, 0.11582546f, 0.00232638f, 0.38790488f, -0.36927071f, -0.21168058f, 
    0.40738770f, -0.10085110f, 0.05588458f, -0.24863638f, 0.14319231f, 0.19006678f, 0.10438067f, 0.00715910f, 
    0.32070780f, -0.18756662f, 0.14928783f, 0.01915701f, -0.41482201f, -0.12814227f, 0.16774091f, 0.06332932f, 
    0.25417641f, -0.18262145f, -0.08476879f, 0.21159986f, -0.16867425f, 0.29773769f, -0.10303065f, -0.14422692f, 
    -0.15174904f, 0.41192973f, -0.04293127f, -0.16420729f, 0.10962757f, -0.17167675f, 0.14840329f, 0.04644289f, 
    0.02747938f, 0.49291027f, 0.45696771f, 0.20345223f, 0.00030398f, -0.28382447f, -0.25045618f, 0.05218080f, 
    0.25175607f, -0.49883142f, -0.40453640f, -0.24917778f, -0.47232050f, 0.02733521f, 0.12604639f, -0.02003244f, 
    -0.20892540f, -0.29168439f, -0.31314716f, -0.09056943f, 0.26680496f, -0.02939708f, 0.25868067f, 0.33126587f, 
    -0.09364090f, 0.01103497f, -0.29348981f, -0.07728690f, -0.16773900f, 0.28699869f, 0.41532320f, -0.47829303f, 
    -0.08407889f, -0.15081081f, -0.33543968f, -0.25421965f, -0.37302461f, -0.25974911f, 0.03731457f, 0.08044901f, 
    -0.06387766f, 0.21059300f, 0.37155476f, 0.27459183f, -0.02210073f, -0.22623509f, -0.21563193f, -0.01460561f, 
    0.40084282f, 0.00375507f, -0.20052820f, -0.32370004f, -0.28859144f, -0.23972507f, -0.42907012f, 0.64190876f, 
    0.91442877f, 0.45575723f, -0.44619766f, -0.26146984f, -0.07818202f, -0.37718117f, -0.05720884f, 0.23452902f, 
    -0.36181238f, 0.05806752f, -0.13961381f, 0.13642177f, -0.05488500f, -0.28277689f, 0.14284462f, -0.06106672f, 
    -0.00088774f, 0.13024375f, -0.20535800f, -0.03328841f, 0.09317674f, -0.11236842f, 0.08587506f, -0.09791692f, 
    -0.58037132f, -0.36066139f, -0.55797845f, 0.34505928f, 0.72661573f, 0.23113750f, 0.51519787f, -0.54495281f, 
    0.22474806f, 0.07439026f, -0.40362254f, -0.22931565f, -0.63426322f, 0.09743835f, -0.08242581f, 0.15102449f, 
    0.03286873f, -0.00148549f, 0.36261433f, 0.10266571f, 0.09835952f, -0.11778483f, -0.07984926f, -0.12066719f, 
    -0.14425205f, -0.60724223f, -0.01760294f, -0.23027669f, -0.68080574f, -0.55117440f, 0.32649979f, 0.18802962f, 
    0.13438167f, 0.20899771f, 0.37820956f, -0.26083025f, -0.15600996f, -0.05885491f, -0.09125073f, 0.09164754f, 
    0.09321953f, 0.27585971f, -0.05182593f, -0.21554947f, -0.06238974f, -0.13706192f, -0.12784098f, -0.17943844f, 
    -0.21081372f, -0.30599803f, -0.50976938f, -0.37759158f, -0.61854315f, 0.00120618f, 0.33043894f, -0.12906694f, 
    0.00748876f, -0.23485833f, -0.30732250f, -0.32894710f, -0.13180910f, -0.32744911f, 0.10992927f, -0.48543835f, 
    -0.23782896f, -0.28972805f, -0.37918591f, -0.25887352f, -0.15729854f, -0.14708757f, -0.00616304f, 0.17987718f, 
    0.11001837f, -0.37726107f, -0.29924819f, -0.83674669f, -0.21854308f, -0.42614967f, 0.30723804f, 0.61045420f, 
    0.14266826f, 0.38693807f, 0.07889266f, 0.52475935f, 0.34127495f, 0.10921843f, 0.09253938f, -0.11522811f, 
    0.18949033f, 0.43623227f, -0.29416129f, 0.06077199f, -0.06338915f, -0.37917379f, -0.07164022f, -0.14003678f, 
    -0.05090665f, 0.02129016f, 0.19013488f, -0.07920899f, -0.08242698f, -0.31084585f, -0.60645378f, -0.14172760f, 
    0.03792180f, -0.07506008f, 0.04763066f, -0.34220597f, -0.39431438f, -0.16189283f, 0.06133405f, 0.11741435f, 
    0.12206823f, 0.37474975f, -0.28850558f, -0.31057492f, -0.24927203f, 0.10826711f, -0.22639494f, -0.01974707f, 
    -0.06042171f, 0.26831216f, -0.13376391f, 0.16243222f, 0.40760529f, 0.22763681f, -0.90010333f, 0.15103036f, 
    0.58083791f, -0.04119254f, -0.55418617f, -0.20076886f, 0.20534542f, -0.41892096f, -0.31022835f, -0.10430020f, 
    -0.26536626f, 0.21152596f, -0.24396291f, 0.27438638f, -0.06933301f, 0.29303688f, -0.17665668f, -0.08277132f, 
    -0.12832190f, 0.14123890f, -0.15442127f, 0.11530661f, 0.32748744f, -0.15718053f, 0.61196858f, -0.31874603f, 
    0.26422718f, 0.09510324f, 0.02074547f, -0.18258148f, -0.00532802f, 0.36027133f, 0.41616309f, 0.00219210f, 
    -0.14208055f, -0.00553908f, 0.09268947f, 0.09367520f, 0.17655957f, -0.08558894f, -0.16470870f, -0.27253479f, 
    0.05780217f, -0.42539278f, 0.25906533f, -0.05783160f, 0.18766735f, -0.11234857f, 0.16748092f, 0.00099674f, 
    -0.58418834f, 0.62492329f, 0.20672619f, -0.22319332f, -0.16761430f, -0.72749603f, -0.80241317f, -0.46055365f, 
    -0.05141732f, 0.27436960f, 0.33536810f, 0.03891702f, 0.13118725f, 0.38689366f, -0.23520558f, 0.07823029f, 
    0.12611155f, -0.16077740f, -0.01909767f, -0.06919415f, 0.01330102f, 0.04148186f, -0.03417104f, -0.07020274f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.38983530f, 0.20557420f, 0.22812492f, 0.13469231f, 0.15602197f, 0.35481441f, 0.00864594f, 0.17152482f, 
    -0.11176130f, -0.15907912f, 0.01792628f, 0.21593583f, -0.08436543f, 0.31862804f, 0.21093038f, 0.01308517f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.45716730f, -0.28601277f, -0.13282847f, 0.20094977f, 0.00287922f, -0.02261366f, 0.06854299f, 0.13990285f, 
    -0.11443821f, -0.12237598f, -0.01564345f, -0.09062099f, 0.06399462f, 0.16103326f, 0.05404349f, -0.06282726f, 
    0.01743438f, 0.00609500f, -0.02869345f, 0.11709545f, 0.00654746f, -0.09813943f, -0.06523380f, 0.02380160f, 
    0.34466690f, -0.02656821f, 0.36927322f, 0.13657871f, 0.03572588f, -0.13038652f, 0.09789913f, -0.11476506f, 
    0.05937489f, 0.02227680f, 0.01457552f, -0.05709850f, 0.08477890f, -0.06484695f, 0.22134967f, 0.12878284f, 
    -0.06024884f, -0.08497799f, -0.18724118f, 0.10403765f, -0.01341599f, -0.05140972f, -0.03126057f, -0.00275022f, 
    0.00262207f, -0.06151432f, -0.06493634f, -0.13115706f, 0.07529347f, -0.04552110f, -0.19870031f, -0.19969812f, 
    0.03430852f, -0.02131743f, -0.10792568f, -0.00363068f, 0.16147584f, -0.04535349f, 0.17851835f, 0.23004194f, 
    -0.08789668f, -0.08844133f, 0.23192006f, 0.11624385f, -0.12656225f, -0.03791706f, 0.04443116f, -0.01417459f, 
    0.04739781f, -0.20020667f, -0.09495530f, 0.13795370f, 0.02212220f, 0.02241115f, 0.05680009f, 0.14736515f, 
    -0.06412838f, 0.01564276f, 0.01051869f, -0.08185816f, 0.11866488f, 0.12772532f, 0.39400384f, 0.02934339f, 
    0.03173972f, 0.16340104f, 0.00960327f, 0.02471014f, 0.01829357f, 0.10253853f, -0.05078150f, -0.00324432f, 
    -0.02205383f, 0.37092829f, -0.24512930f, 0.05676868f, 0.11451975f, -0.08194433f, 0.36173302f, -0.06943218f, 
    -0.25175813f, 0.05135894f, 0.06909535f, 0.12818000f, -0.05866957f, -0.08559179f, -0.18400893f, 0.02568329f, 
    0.05075464f, -0.12367740f, 0.07729270f, 0.14798811f, -0.07769222f, -0.06752244f, 0.05974087f, -0.01931135f, 
    -0.04713408f, -0.03439392f, -0.11673034f, 0.07234678f, -0.01361824f, 0.04877840f, -0.10230014f, -0.07366706f, 
    -0.00861656f, 0.03777078f, 0.22688034f, 0.02787972f, -0.16501273f, -0.05269299f, -0.49409655f, -0.13162598f, 
    0.15125428f, -0.04774249f, 0.06456949f, -0.03720768f, 0.04931942f, 0.13554183f, 0.08547505f, 0.07880438f, 
    -0.03728842f, -0.06678461f, -0.19420339f, 0.12175502f, 0.00788148f, 0.06264240f, 0.02402290f, 0.12095495f, 
    0.10261723f, 0.14387023f, 0.08102345f, 0.06324316f, 0.14318685f, 0.19076040f, 0.05740245f, 0.03219732f, 
    0.04202900f, -0.06801188f, -0.07640394f, 0.22405556f, 0.15690984f, 0.10864488f, 0.01623731f, 0.15684140f, 
    0.01916320f, -0.02045061f, 0.10463427f, -0.09085192f, 0.18045394f, -0.06165318f, 0.07023182f, -0.01085692f, 
    -0.00398371f, -0.02196875f, 0.05852240f, 0.07796955f, -0.10750265f, -0.05422391f, -0.07663294f, 0.10913076f, 
    0.08850086f, 0.03144028f, 0.23151898f, -0.13553545f, 0.08682221f, -0.00266792f, 0.08870693f, -0.05611950f, 
    0.05131486f, -0.10136481f, -0.27929470f, -0.16544491f, 0.10808455f, -0.00106185f, 0.09367770f, -0.05446938f, 
    0.04518488f, 0.08519477f, -0.06843779f, 0.02837592f, -0.13803537f, 0.00068646f, 0.06203948f, 0.01316531f, 
    0.08451061f, 0.02116135f, 0.11800867f, -0.01718776f, 0.00259795f, -0.12247127f, -0.01011803f, -0.00437579f, 
    -0.18023774f, -0.19023858f, 0.16904968f, -0.04017667f, 0.03442355f, 0.01416465f, 0.07466938f, 0.29399949f, 
    -0.02519505f, 0.01483826f, 0.00692019f, -0.11164905f, -0.05884266f, -0.03525964f, -0.01922991f, -0.04041064f, 
    -0.00154548f, -0.09589831f, -0.10726553f, -0.14183973f, 0.07623530f, -0.03302032f, -0.01378638f, 0.18863927f, 
    -0.18142693f, -0.19679135f, 0.02662757f, 0.11062755f, 0.07449922f, -0.08711764f, 0.04364230f, -0.10650645f, 
    -0.00231110f, 0.28909847f, 0.01840196f, 0.12492837f, 0.08189587f, 0.21089543f, 0.20445599f, -0.06619328f, 
    0.15144968f, 0.00705138f, 0.07891244f, 0.08495349f, -0.05144474f, 0.03410122f, 0.10772998f, 0.15565157f, 
    0.10625265f, 0.03227333f, -0.06682653f, -0.11882836f, 0.06899625f, -0.07062560f, -0.10966890f, -0.02591277f, 
    -0.14552155f, -0.07664508f, 0.03094295f, -0.17415212f, -0.22261477f, -0.02685643f, -0.10808840f, 0.15228735f, 
    0.02072973f, -0.03704035f, -0.07047443f, 0.02680125f, 0.00359630f, -0.16213156f, -0.14565992f, 0.03851807f, 
    0.07593960f, 0.27057227f, -0.02325725f, -0.23489605f, 0.05310254f, -0.21887107f, 0.28129292f, 0.14226535f, 
    0.07663310f, 0.05804656f, -0.08131529f, -0.03396887f, -0.23355807f, -0.08021437f, -0.12887855f, -0.04069630f, 
    0.04933834f, 0.05682268f, 0.04906323f, 0.00903355f, 0.00679724f, 0.01072250f, -0.04953635f, -0.14726329f, 
    0.11732540f, 0.28233233f, -0.03699414f, -0.17376120f, -0.04312506f, -0.10579386f, 0.13516928f, 0.09367736f, 
    -0.10844773f, 0.03635325f, -0.15106948f, -0.05516880f, -0.14695692f, -0.09690566f, 0.04283252f, 0.13225654f, 
    -0.12967943f, -0.11052000f, -0.01820493f, 0.01056901f, 0.11541678f, 0.09562872f, -0.00282424f, 0.06900916f, 
    0.02535747f, 0.11614380f, -0.03292372f, -0.25864193f, 0.14270417f, 0.19175075f, 0.13255610f, 0.02975218f, 
    -0.03369566f, -0.02548059f, 0.00524145f, -0.01229602f, 0.20683987f, -0.09290480f, 0.13323741f, -0.12280603f, 
    0.19457626f, 0.11965366f, 0.09574474f, -0.10527090f, 0.07515997f, 0.07739056f, 0.07481991f, 0.10135412f, 
    -0.01397166f, -0.10225856f, 0.08299868f, 0.13815694f, -0.13480173f, 0.04142508f, 0.04463398f, 0.02874825f, 
    0.02014965f, 0.07453050f, 0.04632122f, 0.11265599f, 0.24870349f, 0.18593615f, -0.02477458f, -0.39969569f, 
    0.10674247f, -0.02778980f, -0.01154817f, 0.01722000f, 0.11762290f, -0.02030595f, 0.02832141f, 0.03073897f, 
    0.09529017f, -0.40535131f, 0.21147990f, 0.02446246f, 0.04297414f, -0.06872290f, 0.08329026f, 0.15031256f, 
    -0.03471818f, 0.08734554f, 0.11237727f, 0.10860490f, -0.08004756f, -0.16085450f, -0.05332405f, -0.10555413f, 
    -0.11769966f, -0.16976216f, -0.04283141f, -0.24260139f, 0.00568883f, -0.02244396f, -0.11828239f, 0.09510037f, 
    -0.09964737f, 0.08088313f, -0.19904710f, -0.10702507f, 0.14036179f, -0.12391069f, 0.08693995f, -0.20058581f, 
    0.06446166f, 0.01139720f, 0.04285623f, 0.13288650f, -0.49426505f, -0.03537951f, 0.06813254f, -0.14040774f, 
    0.06309499f, 0.22081062f, 0.13030116f, -0.08044757f, -0.08797198f, -0.09736495f, 0.01868387f, -0.09230581f, 
    0.09787587f, -0.02098390f, -0.10984811f, -0.02980687f, 0.12904011f, 0.18324076f, -0.00293430f, 0.09219884f, 
    0.07708663f, -0.13138247f, 0.12478890f, 0.07098924f, 0.07907084f, 0.05733589f, 0.09817347f, 0.13234046f, 
    -0.11494881f, -0.08747719f, -0.21072155f, 0.12761356f, 0.09772056f, 0.04418526f, 0.04324085f, -0.05953522f, 
    -0.05171596f, -0.04927455f, 0.16846736f, 0.14214692f, 0.13048816f, -0.03082671f, 0.20059071f, 0.11029187f, 
    -0.05860829f, -0.19815670f, 0.15375467f, 0.10209852f, -0.23362553f, 0.09445067f, -0.14866869f, 0.37625906f, 
    0.07936977f, -0.02198414f, -0.00246609f, -0.02699349f, 0.02095933f, 0.04350805f, 0.02854002f, 0.00823202f, 
    0.09278936f, -0.09891982f, 0.02664712f, 0.02022327f, -0.06072362f, 0.04013206f, -0.20741783f, 0.05066026f, 
    0.01233477f, -0.12629753f, -0.14036450f, -0.03912413f, 0.17172432f, -0.12113950f, 0.09989693f, 0.12809394f, 
    0.09792457f, -0.01197331f, -0.12279883f, -0.08723958f, 0.06707732f, -0.02765137f, 0.07903575f, 0.06428971f, 
    -0.24490802f, -0.08616985f, 0.09456816f, 0.18566878f, 0.10825785f, 0.01267676f, 0.00321753f, 0.14101286f, 
    0.20960964f, 0.07731076f, 0.06886446f, -0.01815240f, 0.36360484f, -0.02373814f, -0.03098433f, -0.03159440f, 
    0.00409987f, -0.02694317f, -0.09112877f, -0.24414611f, 0.03771738f, -0.07578854f, 0.07965437f, 0.04317414f, 
    0.22916453f, -0.02207358f, 0.34333292f, 0.45160136f, -0.05598371f, -0.06671933f, 0.14446190f, 0.26544660f, 
    0.12446488f, -0.01505186f, 0.10094226f, 0.09821118f, -0.01169380f, 0.30445427f, 0.09882314f, 0.34075800f, 
    -0.07797221f, -0.17626619f, 0.20255505f, 0.19519569f, -0.02422145f, 0.06025338f, 0.07524452f, 0.03769840f, 
    -0.18728009f, -0.16217569f, -0.13734582f, -0.07865512f, -0.01312161f, 0.00264960f, -0.08536007f, -0.22942808f, 
    -0.00292507f, -0.01827713f, -0.11903954f, -0.00055475f, 0.18470496f, 0.33372301f, 0.17196687f, 0.34803092f, 
    -0.17521401f, 0.10204839f, 0.10019431f, 0.33228773f, -0.02203148f, 0.11969898f, -0.05362650f, 0.09150719f, 
    0.02315610f, -0.02647249f, 0.01877208f, -0.00475381f, 0.03715485f, 0.05129344f, -0.00372339f, -0.05049941f, 
    -0.06231612f, 0.01130795f, -0.04418410f, -0.06726491f, -0.07991825f, 0.04881851f, 0.00252662f, 0.03642558f, 
    -0.01813429f, 0.00202770f, -0.03852161f, 0.01475300f, 0.00622237f, -0.01555733f, 0.00636538f, -0.00636444f, 
    0.05035005f, 0.06030072f, -0.01075870f, 0.04032439f, -0.05542377f, -0.01609694f, -0.01566876f, -0.01005214f, 
    -0.02403058f, 0.03693976f, -0.02427133f, -0.03132574f, 0.00825755f, -0.04330304f, 0.02951425f, 0.01454984f, 
    -0.06444528f, -0.04533726f, -0.05821335f, 0.01920159f, 0.06090967f, 0.00265566f, -0.04133862f, -0.04917872f, 
    -0.02684794f, -0.01895010f, -0.01872868f, -0.00046741f, -0.03122158f, 0.05204074f, -0.05165546f, -0.06110992f, 
    0.01563621f, 0.00099183f, 0.01820342f, -0.02739338f, 0.03199958f, -0.02869706f, -0.06673201f, -0.05778962f, 
    0.04813905f, -0.00231410f, -0.07460559f, 0.02929583f, 0.00279453f, -0.01116630f, -0.05387530f, -0.05269421f, 
    0.04870219f, -0.04982174f, -0.04578291f, -0.03339341f, -0.00800197f, -0.05810501f, 0.04947543f, 0.04697853f, 
    0.03096382f, 0.01942819f, 0.01729751f, -0.05292315f, -0.03603359f, 0.00471287f, 0.06128264f, 0.04751865f, 
    -0.06413330f, -0.02430213f, -0.02134765f, -0.04407414f, -0.02715089f, -0.07798021f, -0.01075823f, -0.03629128f, 
    0.06128256f, -0.06662832f, 0.03050258f, 0.03721580f, 0.01258361f, -0.00282183f, -0.04464436f, 0.00955956f, 
    -0.05475090f, 0.06239420f, -0.03022259f, 0.02891645f, 0.01244157f, -0.06284629f, 0.01020673f, -0.05468480f, 
    0.04630844f, 0.05460449f, -0.04777677f, -0.05424798f, -0.06085694f, 0.05217333f, -0.04153426f, 0.03290971f, 
    0.02412988f, 0.05855191f, 0.02177522f, 0.04742552f, 0.04393616f, 0.04446666f, 0.04083481f, 0.03836453f, 
    -0.04784707f, 0.02942055f, 0.03399882f, -0.01742153f, 0.04092911f, -0.00463465f, 0.02242338f, -0.07665695f, 
    0.05462655f, -0.07833135f, -0.03928759f, -0.07677487f, -0.03846790f, -0.02758590f, -0.06248371f, 0.01012026f, 
    -0.00111131f, -0.07423083f, 0.04899254f, 0.01144307f, -0.02621496f, -0.01689138f, -0.06193210f, 0.04623888f, 
    -0.00423441f, 0.04376491f, 0.00877689f, -0.00941226f, -0.07030051f, -0.04142202f, -0.07129699f, -0.05840490f, 
    -0.02525085f, -0.01494368f, 0.00401667f, -0.08120146f, -0.06290469f, 0.03128972f, -0.05610269f, -0.00141691f, 
    0.02035325f, -0.03380590f, -0.03595553f, -0.04661420f, -0.04322388f, -0.02439631f, 0.02655797f, -0.03299987f, 
    0.05735494f, -0.00364223f, 0.04179389f, -0.00745732f, 0.05968503f, 0.06016186f, -0.02605210f, -0.03023167f, 
    0.00983590f, -0.00534427f, 0.04348882f, -0.06823944f, 0.00294234f, -0.07116165f, 0.03157555f, 0.04306464f, 
    -0.14041214f, 0.07708445f, 0.15238471f, 0.27810392f, 0.08582725f, 0.04960798f, 0.06614950f, -0.01310621f, 
    -0.01875075f, 0.06969981f, -0.03614612f, 0.02588632f, -0.44822276f, -0.08809912f, 0.04537123f, -0.05888046f, 
    -0.19008228f, -0.04027332f, -0.11842446f, -0.12970665f, -0.03793495f, -0.11018506f, -0.04086676f, 0.07840247f, 
    0.03376317f, -0.16638392f, -0.02103857f, 0.19523589f, -0.32860669f, 0.00140078f, -0.20480162f, 0.03125852f, 
    0.01816312f, 0.07470303f, -0.12210489f, 0.22497568f, -0.25766200f, 0.00753279f, -0.41547555f, -0.09167702f, 
    0.01270454f, 0.23110105f, 0.01487474f, -0.17139359f, 0.22003378f, -0.03077698f, -0.04025986f, -0.11922307f, 
    -0.05758865f, 0.06505012f, 0.05877896f, -0.00307365f, -0.00091230f, 0.12248276f, -0.06040487f, -0.02619450f, 
    0.18513426f, 0.02837080f, 0.00666999f, -0.00107266f, 0.11100262f, 0.09316949f, 0.08689234f, 0.25036469f, 
    -0.24409764f, -0.04769988f, -0.09410074f, -0.10669050f, 0.00273487f, -0.00481847f, 0.11646649f, -0.04119042f, 
    -0.27989548f, 0.04447778f, 0.14309639f, 0.22078136f, 0.07239433f, 0.11984242f, 0.11844002f, 0.04197531f, 
    0.06730879f, 0.09622481f, -0.00749074f, -0.00821329f, 0.05360395f, -0.01619434f, -0.18048066f, 0.17112185f, 
    -0.12075777f, 0.11183193f, -0.17079873f, -0.00609993f, 0.15592593f, 0.00919072f, -0.02402265f, -0.05692590f, 
    0.02342438f, 0.26422521f, 0.04319402f, 0.03417614f, -0.09463490f, 0.17575459f, -0.08472880f, 0.18379131f, 
    -0.30510765f, -0.06018136f, 0.02063258f, 0.08518739f, 0.18007217f, -0.19667749f, -0.01388820f, 0.25892320f, 
    0.20673265f, -0.01298053f, 0.12225322f, 0.19157183f, -0.02531221f, -0.06730133f, -0.09522598f, 0.24502780f, 
    -0.14352052f, 0.02437402f, -0.10184462f, 0.05040630f, 0.05146430f, 0.13124266f, 0.03511828f, 0.09757388f, 
    -0.13795233f, 0.01932655f, 0.12189612f, 0.09635986f, 0.25094169f, 0.20545810f, 0.06466717f, 0.02908154f, 
    0.03852447f, 0.01785407f, 0.05924677f, 0.07854321f, -0.19089764f, -0.07462536f, -0.00464102f, 0.06502348f, 
    0.19750109f, 0.15863910f, 0.01075710f, 0.28889775f, 0.02673752f, -0.02734254f, 0.10131320f, 0.07192907f, 
    0.14282981f, 0.12418933f, 0.09127819f, -0.13288440f, 0.02815582f, 0.15702574f, -0.03223530f, 0.35163507f, 
    -0.11714199f, -0.00101718f, -0.00300573f, 0.14267838f, -0.21635580f, 0.06857311f, -0.13136978f, -0.00562906f, 
    -0.24498451f, -0.26830390f, -0.18869714f, 0.01823859f, 0.00609039f, -0.02388813f, -0.11707973f, 0.03241383f, 
    -0.02819273f, -0.06430417f, -0.01203770f, -0.05877699f, 0.11235381f, 0.07289090f, 0.17960739f, 0.38870227f, 
    0.26275790f, 0.09246931f, -0.01733036f, 0.28898063f, -0.14286499f, 0.05644869f, -0.09527319f, -0.13786116f, 
    -0.00107882f, -0.00697159f, -0.07207906f, 0.02720286f, -0.00020504f, 0.05878471f, -0.05347577f, 0.04458143f, 
    0.00842186f, -0.01523092f, -0.07613232f, 0.00924718f, -0.01571334f, -0.04911401f, -0.00719556f, -0.04502818f, 
    0.02875251f, -0.00251960f, 0.01173265f, -0.03418717f, 0.05750417f, -0.06059534f, 0.00603967f, 0.05044997f, 
    0.01348691f, 0.02316790f, 0.01999345f, -0.00805812f, -0.00700936f, 0.05451515f, -0.03626420f, 0.03234595f, 
    -0.00264038f, 0.01101274f, -0.07525841f, -0.01527122f, -0.00131130f, -0.01047237f, -0.01777335f, -0.00707990f, 
    -0.02208578f, 0.04676782f, -0.04373428f, 0.05307053f, -0.01989516f, -0.03203673f, -0.01678823f, 0.04556158f, 
    -0.03452705f, 0.01077528f, -0.07280146f, -0.04710459f, 0.00110292f, -0.01774743f, -0.02513200f, -0.03857156f, 
    0.02177046f, 0.04247813f, -0.06069500f, 0.01037200f, 0.03292535f, -0.00473580f, 0.05570443f, -0.03988104f, 
    -0.04913932f, 0.05168418f, -0.05354752f, -0.04294883f, -0.05479266f, -0.07029242f, -0.00059896f, 0.05727018f, 
    -0.00721498f, 0.01884104f, -0.02138374f, 0.04179772f, -0.02005203f, -0.01392549f, -0.06431197f, 0.00792472f, 
    -0.06581806f, -0.04111791f, -0.07093868f, -0.08243254f, -0.06640846f, 0.05503923f, 0.04978105f, 0.07470068f, 
    0.02701206f, 0.05451336f, -0.04790397f, 0.03284834f, 0.00507039f, -0.04802352f, 0.04975905f, 0.06701290f, 
    -0.01774031f, -0.00899045f, 0.01565007f, -0.07254136f, -0.02129972f, -0.05131112f, 0.03615375f, -0.05234679f, 
    0.02913901f, -0.05911493f, -0.04692948f, -0.02880445f, 0.02673688f, 0.05116547f, 0.03918203f, -0.01779108f, 
    -0.05694796f, 0.05883141f, 0.03391476f, 0.00420827f, -0.04998524f, 0.04802016f, 0.06012326f, 0.04774422f, 
    -0.08006549f, -0.07677183f, 0.04161064f, 0.04445344f, 0.00637355f, -0.04194013f, 0.03631481f, -0.03746995f, 
    -0.07476302f, 0.01987462f, 0.03036984f, 0.03670628f, -0.03531848f, 0.02425969f, 0.00562313f, -0.01477153f, 
    -0.00322802f, -0.05511473f, -0.02038674f, -0.06759279f, 0.02785690f, -0.03876996f, 0.04900161f, -0.04069567f, 
    -0.04118565f, 0.00337071f, -0.01116757f, -0.03013564f, 0.04595259f, 0.04595273f, 0.02830485f, 0.06101164f, 
    -0.06494405f, -0.01875741f, -0.05325518f, -0.02981657f, -0.04459505f, -0.06085880f, 0.04988312f, -0.05621605f, 
    0.05792635f, 0.02301578f, 0.00743373f, -0.02901638f, -0.01866183f, -0.00392445f, -0.02803495f, 0.06796851f, 
    -0.05996612f, -0.05709668f, -0.05410793f, 0.02994620f, -0.04865010f, 0.01032984f, 0.01669587f, -0.02746688f, 
    -0.00037643f, -0.00777722f, 0.03953805f, -0.00439318f, -0.01621661f, -0.04864662f, -0.01049951f, 0.00614663f, 
    -0.05612193f, -0.07369228f, -0.03386202f, 0.05963783f, 0.06788372f, 0.03027573f, 0.05883847f, -0.03019649f, 
    -0.02566566f, -0.05748087f, -0.02736867f, 0.06337760f, 0.04059312f, -0.07510684f, -0.03923646f, -0.07333694f, 
    -0.05355295f, -0.03705841f, -0.03879293f, 0.04218908f, 0.02638203f, -0.03909533f, 0.00617662f, -0.00040014f, 
    0.00471986f, -0.05709749f, -0.01726316f, 0.03462789f, 0.05569990f, -0.03709854f, -0.03696212f, 0.01886112f, 
    0.01234369f, 0.01206716f, 0.05110237f, 0.05203162f, -0.00659530f, -0.03717462f, -0.02342871f, -0.03404712f, 
    -0.04831539f, -0.04250821f, -0.06067152f, -0.02626259f, -0.03304570f, -0.06292257f, 0.04930826f, -0.05419409f, 
    0.02262799f, 0.00841142f, -0.02513006f, -0.06201058f, -0.07501107f, 0.06250181f, -0.05288613f, -0.04828578f, 
    0.00276109f, 0.00208084f, 0.06450090f, -0.00344495f, -0.07373759f, 0.01561639f, 0.05954899f, -0.02657695f, 
    -0.01058851f, -0.04555537f, -0.04414385f, 0.05720988f, -0.01485800f, 0.02440237f, -0.07051283f, -0.03582285f, 
    0.06281453f, 0.04345159f, -0.07805154f, -0.02233267f, -0.00609171f, -0.05710549f, -0.06138667f, -0.06757629f, 
    0.05878972f, 0.05428487f, 0.04907692f, -0.06455689f, -0.04304121f, 0.02080846f, -0.07485861f, -0.02376033f, 
    -0.07552210f, -0.05670978f, -0.01215477f, 0.01439575f, 0.04611638f, 0.00206415f, 0.04889845f, -0.03387469f, 
    -0.04352247f, 0.00043972f, 0.04746729f, -0.05188672f, -0.06918364f, 0.02748082f, 0.03744461f, -0.01399374f, 
    -0.03824550f, 0.02108385f, -0.02026224f, -0.01332824f, -0.02486810f, -0.00451059f, 0.03883247f, 0.05127466f, 
    0.01225397f, 0.05633315f, -0.06059417f, -0.04157881f, -0.03621724f, -0.07099560f, 0.01834942f, -0.02428018f, 
    0.03179063f, 0.04091981f, 0.00841303f, -0.00171722f, -0.03079395f, -0.00602640f, -0.02889893f, -0.06283958f, 
    0.06111426f, 0.04629799f, 0.03551159f, 0.02213721f, 0.03836401f, 0.05586481f, -0.01279439f, -0.06636082f, 
    -0.01958278f, -0.04674057f, 0.05446248f, -0.02179925f, 0.05668895f, -0.05570230f, 0.06076551f, -0.07022198f, 
    0.02984868f, 0.02280831f, 0.05333564f, -0.07027742f, 0.06905722f, -0.06064828f, -0.02551421f, -0.03911560f, 
    -0.03194715f, -0.03079659f, 0.00392726f, -0.02870953f, -0.00163356f, -0.07772776f, -0.00581959f, -0.00699620f, 
    -0.05910179f, -0.00957278f, -0.00215883f, -0.05156682f, -0.04518878f, 0.03621544f, 0.00481241f, 0.05114985f, 
    -0.01643270f, -0.01352881f, 0.06093395f, 0.04902926f, -0.02746251f, -0.02816537f, 0.06013801f, -0.04794160f, 
    0.00951173f, 0.04833400f, -0.05341356f, -0.06200821f, 0.03761894f, -0.00710088f, 0.01430352f, 0.04862151f, 
    -0.05696578f, -0.05845832f, -0.05015552f, 0.06925169f, 0.03592191f, -0.05408764f, 0.04543139f, -0.07340881f, 
    -0.05034258f, -0.05085618f, -0.04312656f, -0.00160106f, -0.01009486f, 0.04074628f, -0.04727510f, -0.05577752f, 
    -0.02929358f, 0.04892528f, -0.04789715f, 0.03943709f, -0.06433677f, -0.06514425f, 0.00124818f, -0.00406456f, 
    0.05137681f, -0.06820038f, -0.07660813f, 0.01747318f, -0.04843487f, -0.00740272f, 0.03674501f, 0.03791103f, 
    0.02602218f, 0.01231319f, -0.02285588f, 0.04109419f, 0.05162455f, -0.00390016f, -0.01006125f, 0.01607972f, 
    0.02799649f, 0.00974234f, -0.06075344f, -0.00618634f, -0.07193974f, -0.00567872f, -0.07153223f, -0.02381172f, 
    -0.03920641f, 0.02775285f, -0.01258892f, -0.06280494f, -0.02938649f, 0.00365915f, 0.06273528f, 0.01487291f, 
    -0.05380840f, 0.05969995f, -0.06464641f, -0.01617757f, -0.03526179f, 0.00300863f, 0.05571742f, -0.04358494f, 
    -0.00317596f, 0.01979421f, -0.02399898f, -0.07502632f, 0.00727428f, -0.04452416f, -0.06544114f, 0.04781557f, 
    0.07145832f, -0.07033775f, -0.07566452f, 0.02318093f, 0.05405781f, -0.00853065f, 0.03974997f, -0.02376352f, 
    -0.04263856f, -0.03557729f, 0.04983813f, 0.05920565f, -0.05512651f, -0.03893952f, -0.05266794f, 0.05636849f, 
    0.02480013f, 0.05731218f, 0.02634228f, -0.06037936f, -0.07502496f, -0.06441996f, 0.01295979f, 0.04950013f, 
    0.06090511f, -0.04469559f, 0.05560699f, 0.05748222f, 0.01349713f, -0.00706820f, -0.01938210f, 0.05964417f, 
    -0.04704305f, 0.00072223f, 0.00973076f, 0.06083004f, 0.06536777f, -0.04737450f, -0.06664761f, 0.05714673f, 
    0.06398382f, -0.07191777f, 0.05457670f, -0.03242408f, 0.04132082f, -0.01620824f, -0.00997041f, -0.03757068f, 
    -0.02972472f, 0.02409393f, 0.00121055f, 0.01129404f, 0.03703087f, 0.00968626f, -0.07229540f, 0.00088851f, 
    0.07095265f, -0.04731499f, -0.04494898f, -0.04902041f, -0.06639111f, 0.03648948f, 0.03300806f, 0.00440130f, 
    0.05181554f, -0.05919379f, -0.00566352f, -0.00335292f, -0.06987584f, -0.06815455f, -0.03240786f, -0.04519996f, 
    0.05751123f, -0.04443773f, -0.06689478f, 0.00720341f, 0.04500496f, -0.02379938f, -0.06505059f, 0.02255923f, 
    -0.02017485f, -0.03819770f, 0.03957327f, -0.03406981f, -0.07274164f, -0.01451175f, 0.04153552f, -0.02021844f, 
    0.03585089f, -0.05284901f, -0.00213939f, -0.01853564f, -0.06213250f, 0.01781465f, -0.06318361f, 0.01613336f, 
    -0.05331580f, -0.02713230f, -0.04131415f, -0.04326554f, -0.00163722f, 0.01845706f, 0.01257779f, -0.03014435f, 
    -0.00835351f, -0.06938652f, -0.01186654f, -0.01538695f, -0.02511039f, -0.06164206f, -0.05076825f, -0.05462209f, 
    -0.01447768f, -0.02775684f, -0.01246294f, -0.01832177f, -0.04170033f, 0.06356956f, 0.05492275f, -0.03494873f, 
    0.00768963f, 0.05384294f, -0.05840902f, 0.04360164f, 0.05330722f, -0.01970305f, -0.02372855f, -0.07426532f, 
    0.00077369f, -0.07152430f, 0.04894839f, -0.03793767f, -0.05466863f, -0.01133107f, 0.02146918f, -0.05622081f, 
    0.02292733f, 0.04958113f, -0.06341882f, -0.01807251f, 0.05391665f, -0.02538534f, 0.04771870f, -0.05973526f, 
    0.05413514f, -0.00229151f, -0.07463135f, -0.05380076f, -0.04280789f, -0.08119878f, 0.01291428f, 0.02192948f, 
    -0.06642473f, -0.02493933f, 0.04777385f, 0.05890023f, -0.03416834f, -0.06932727f, 0.00673469f, -0.01543745f, 
    -0.03004130f, -0.05941318f, -0.05558918f, -0.01429891f, 0.01803367f, -0.04963297f, -0.03796662f, -0.06398284f, 
    0.05501503f, -0.07574461f, 0.05395692f, -0.02006090f, 0.00672715f, 0.04205169f, -0.02929269f, 0.05041826f, 
    0.00835076f, 0.05633248f, 0.02240215f, 0.02852873f, 0.01768157f, 0.01456102f, -0.08502533f, 0.02203814f, 
    -0.00640888f, -0.05006794f, 0.05620309f, -0.04616616f, 0.05650776f, 0.02391887f, 0.02928590f, -0.04253537f, 
    -0.08349159f, -0.02796740f, 0.00506580f, -0.05487157f, 0.05403873f, -0.06675643f, 0.05562246f, -0.03953999f, 
    -0.05418613f, -0.03152076f, 0.04684874f, -0.07169772f, -0.06025289f, 0.02109632f, -0.01887977f, -0.01340071f, 
    0.00173637f, 0.02548204f, -0.01316809f, -0.05506008f, -0.07441259f, -0.01905493f, -0.05444761f, -0.03538239f, 
    0.04441401f, 0.02983870f, 0.05907838f, 0.02774304f, -0.00909635f, 0.02839459f, 0.00930810f, -0.04146864f, 
    -0.00611359f, -0.06844208f, -0.07962538f, -0.02968057f, 0.04422614f, -0.05398150f, 0.02367736f, -0.05494225f, 
    -0.00942341f, 0.06929911f, -0.02247533f, -0.07926488f, 0.05164712f, -0.02100800f, 0.02198723f, -0.00479048f, 
    0.01595593f, -0.07691456f, 0.05500897f, -0.00037888f, -0.02306193f, 0.03402974f, -0.03886547f, 0.03787503f, 
    0.03450562f, -0.00465580f, -0.04808566f, -0.01345355f, 0.01124285f, -0.02856111f, 0.04387751f, -0.03126568f, 
    -0.03436594f, -0.03192355f, 0.04281342f, 0.05832985f, -0.06650383f, 0.04521779f, -0.02530177f, 0.01649028f, 
    0.04849137f, 0.01724327f, -0.08077209f, -0.05468692f, -0.02377348f, -0.07366142f, -0.04751578f, -0.03665696f, 
    -0.03654866f, -0.02634649f, 0.04377915f, 0.05045298f, 0.05282273f, -0.02546812f, 0.00490243f, -0.05933918f, 
    0.00166880f, 0.06121973f, -0.05397636f, -0.00437528f, -0.06399564f, -0.03816155f, 0.03644881f, -0.01665046f, 
    0.00682412f, 0.01435737f, 0.02192578f, 0.04590466f, -0.06268923f, 0.02919853f, -0.06640474f, 0.02730187f, 
    -0.06183720f, -0.03532750f, 0.00922181f, 0.04942202f, -0.05664184f, -0.05504460f, 0.05742361f, -0.04495099f, 
    -0.07161605f, 0.02099575f, 0.04572887f, 0.04354185f, 0.04123856f, -0.00430686f, -0.06494327f, -0.07355297f, 
    0.02642573f, 0.05934648f, -0.01364986f, -0.04835173f, -0.01132708f, -0.03534519f, -0.04842142f, 0.05107449f, 
    0.03168054f, 0.02465668f, 0.00108373f, 0.06394054f, -0.05256859f, 0.04224759f, 0.02322187f, -0.00819362f, 
    0.05476846f, -0.00882262f, -0.07283241f, -0.00117293f, -0.01206641f, -0.05782248f, -0.04603649f, 0.01977165f, 
    -0.06379656f, -0.00655210f, -0.01521727f, -0.00957570f, 0.03867952f, 0.00922183f, 0.02218955f, 0.03566229f, 
    0.06551792f, 0.00178482f, 0.05989589f, 0.00810632f, 0.03326412f, -0.05428740f, 0.04007027f, -0.03609239f, 
    0.01884507f, -0.04893449f, -0.00572017f, -0.00786681f, -0.04076047f, -0.00910300f, 0.02095468f, 0.03106822f, 
    0.00518479f, 0.02912388f, -0.03003378f, -0.07428801f, 0.05920735f, 0.02341042f, 0.04595343f, 0.05227144f, 
    -0.01692525f, -0.06772739f, 0.02542757f, 0.02215642f, -0.01997090f, -0.00074573f, -0.03676455f, -0.04139721f, 
    0.05434562f, -0.07676908f, 0.06335257f, -0.00394975f, -0.03163534f, 0.02229751f, 0.04160989f, 0.00063851f, 
    0.02789877f, -0.03980826f, 0.02871388f, -0.06246485f, -0.01101501f, -0.07815534f, 0.05821512f, -0.00480085f, 
    0.05341540f, 0.04517876f, -0.07070156f, -0.02723322f, 0.06101043f, -0.03613836f, -0.07390231f, 0.04935360f, 
    0.03532391f, -0.07590586f, -0.02631132f, -0.04301559f, -0.06143592f, -0.06002092f, -0.05048098f, 0.04491322f, 
    0.01113497f, -0.02563427f, 0.04969747f, -0.01461941f, -0.01305291f, -0.07166324f, 0.01753189f, -0.06114671f, 
    -0.02140235f, -0.07582494f, 0.06154209f, -0.04050799f, -0.01355506f, 0.01796075f, 0.00766014f, 0.04471958f, 
    -0.07449825f, 0.05998046f, 0.01860148f, -0.01600541f, -0.03372929f, -0.03742710f, -0.06975773f, -0.04120221f, 
    -0.03914592f, 0.03521656f, -0.02922386f, -0.04865970f, 0.06341936f, -0.01786029f, -0.03702628f, -0.02852052f, 
    -0.02074596f, 0.04491815f, 0.05972331f, 0.05110404f, 0.02480131f, -0.06363022f, 0.01387989f, -0.04372395f, 
    0.02786600f, -0.05006320f, 0.04439976f, 0.05930807f, -0.02108186f, -0.07506978f, -0.00879222f, 0.00007416f, 
    -0.01532547f, 0.00596946f, -0.03265977f, -0.06721331f, -0.01247901f, 0.00682225f, -0.07358681f, 0.02449207f, 
    0.00893701f, 0.01751664f, 0.00579882f, 0.05497340f, -0.05165489f, 0.04955218f, -0.07836405f, 0.01481762f, 
    0.03785669f, 0.01685589f, 0.04923842f, 0.05020728f, 0.05703697f, -0.06943101f, 0.04038955f, -0.02619004f, 
    0.06210252f, -0.01030481f, -0.07410111f, 0.04039386f, -0.04766300f, 0.05470332f, -0.02908101f, -0.00517040f, 
    0.04233167f, -0.00553526f, -0.03741165f, 0.04862591f, 0.00358872f, -0.02163520f, 0.02031323f, 0.00287361f, 
    -0.07222801f, 0.04598351f, 0.01730981f, -0.02954588f, 0.02516559f, -0.00978925f, -0.06182759f, -0.07364244f, 
    -0.06228872f, -0.01593485f, -0.06556506f, 0.05038155f, -0.00124131f, 0.02177214f, -0.03763577f, -0.07085643f, 
    -0.05174075f, 0.04601902f, 0.00597311f, 0.00878131f, -0.06579635f, -0.06919642f, -0.07370228f, -0.03333680f, 
    -0.03174972f, 0.48321688f, 0.31381807f, 0.34900448f, -0.09221223f, 0.11701740f, -0.18749388f, 0.07687442f, 
    0.03130748f, -0.09755251f, 0.04107571f, -0.03739423f, 0.17881204f, 0.15997031f, -0.14573723f, 0.17363466f, 
    0.01267178f, -0.02764187f, 0.04117831f, -0.00510661f, 0.03139463f, 0.08264823f, 0.11343636f, 0.20921195f, 
    0.17265444f, 0.25810158f, -0.09765576f, 0.24262491f, 0.06562404f, -0.03787450f, -0.03804553f, -0.14768814f, 
    0.04047577f, -0.11005707f, -0.01915316f, 0.02193512f, 0.20867877f, -0.00008191f, 0.12956196f, 0.13070846f, 
    -0.01181454f, 0.13240600f, -0.09730835f, 0.18715407f, 0.11764295f, 0.01368567f, 0.01122518f, -0.05735642f, 
    0.09452265f, 0.07656492f, -0.03776760f, -0.06044799f, -0.07961818f, 0.16522604f, 0.01187393f, 0.05426262f, 
    0.07170145f, -0.17168935f, 0.09229336f, 0.03612904f, -0.09753498f, -0.16072562f, -0.06998245f, 0.10314327f, 
    -0.14237230f, -0.07919465f, 0.04745686f, -0.20641087f, 0.04008297f, 0.02827923f, -0.03430824f, -0.13021813f, 
    -0.07223971f, 0.08298036f, -0.02508615f, 0.23175316f, 0.03903772f, -0.03344822f, 0.00005378f, -0.12048338f, 
    0.13796017f, 0.02805115f, -0.03628259f, 0.16811240f, 0.20874909f, -0.20092648f, 0.39486462f, -0.26734594f, 
    0.05968583f, 0.07101351f, -0.09306791f, 0.07211711f, 0.05619001f, 0.02808305f, -0.04723253f, -0.08428917f, 
    -0.13572563f, 0.00506319f, 0.01679628f, 0.21927114f, 0.03694250f, 0.15668464f, -0.07649750f, -0.19378838f, 
    -0.06099265f, 0.04152114f, 0.10953616f, 0.17524777f, 0.22274543f, 0.20444299f, 0.18616223f, 0.21708086f, 
    -0.09233202f, -0.12740420f, 0.06264692f, 0.04384016f, 0.02740381f, 0.04824903f, 0.00558483f, 0.16131479f, 
    -0.22884132f, -0.25029230f, -0.11931685f, -0.03751289f, -0.02996529f, 0.09736302f, -0.05707388f, -0.19321923f, 
    -0.09832750f, 0.01064317f, 0.21813764f, 0.03072602f, -0.24168719f, 0.18110329f, -0.01033977f, 0.10721979f, 
    0.18455027f, 0.09247744f, 0.08288671f, 0.15993488f, -0.07143915f, 0.01244881f, -0.08477882f, 0.09986026f, 
    0.02328003f, -0.19329831f, -0.13940901f, 0.12957978f, -0.06654573f, -0.09175257f, -0.09334106f, -0.17223997f, 
    -0.01148972f, -0.10819250f, -0.05293682f, -0.08070742f, -0.12228490f, 0.07102760f, -0.12245663f, 0.12572734f, 
    -0.23015249f, 0.06979921f, -0.06842518f, -0.01359596f, 0.06306951f, -0.06894767f, 0.02153421f, 0.06868155f, 
    -0.10299926f, 0.01689599f, -0.20739624f, -0.13579389f, 0.07523578f, -0.00811777f, 0.07754537f, 0.15707971f, 
    -0.03905024f, -0.15695342f, -0.02938046f, -0.13083425f, -0.20081262f, -0.09727659f, -0.21179762f, 0.35056910f, 
    0.04714873f, 0.12989241f, 0.07429576f, -0.06324808f, -0.06902456f, -0.03480704f, -0.14129606f, 0.03492668f, 
    -0.04342506f, 0.29296350f, 0.06728444f, 0.06185364f, -0.04733020f, 0.06222162f, 0.03133791f, 0.10969580f, 
    0.14199133f, 0.06636037f, 0.11792061f, 0.01994245f, 0.15808369f, 0.14224046f, -0.02716291f, -0.27435246f, 
    -0.07249579f, 0.04467368f, -0.04009483f, 0.07462281f, 0.22186218f, 0.14123660f, 0.06736669f, 0.06892296f, 
    0.15238583f, 0.06228966f, -0.13668489f, 0.26024875f, -0.13391455f, -0.00103089f, -0.12756625f, -0.04982157f, 
    -0.04806060f, 0.09514748f, 0.01838411f, -0.01994684f, -0.08185425f, 0.09219538f, 0.05103479f, -0.18364234f, 
    0.06005216f, 0.10162648f, 0.06982709f, -0.02470998f, 0.03828358f, 0.05284248f, 0.13401686f, -0.03704812f, 
    0.19815978f, -0.17510332f, -0.31247374f, -0.10152923f, -0.08684913f, -0.02735029f, -0.02218770f, 0.16683190f, 
    -0.00881257f, 0.18343419f, 0.18405731f, 0.11680718f, -0.07272620f, -0.13355689f, -0.04538631f, 0.28742900f, 
    -0.03082581f, -0.01257243f, -0.00672701f, -0.07015108f, 0.01687601f, 0.11922066f, -0.12573598f, -0.06108703f, 
    -0.19877645f, -0.10345587f, -0.11423182f, 0.27508458f, -0.03488645f, 0.23692173f, -0.03442177f, -0.00589460f, 
    0.06592924f, -0.04873304f, -0.05473418f, -0.09262527f, 0.03667423f, 0.02334923f, 0.25006393f, -0.20928314f, 
    -0.16248079f, -0.11784373f, -0.09654852f, -0.09047706f, -0.01531562f, -0.00188810f, -0.05972034f, 0.04610664f, 
    0.01949239f, 0.06309292f, -0.00662004f, -0.05819078f, 0.07746501f, 0.02384240f, -0.05683914f, 0.10819021f, 
    -0.03922243f, -0.13486736f, 0.04427574f, 0.04195540f, 0.16108851f, -0.10332166f, 0.13465291f, 0.28526300f, 
    0.09597285f, -0.01587709f, 0.12516402f, 0.06807897f, -0.03753513f, -0.12289355f, -0.12125403f, -0.02880282f, 
    -0.20984705f, -0.09349462f, -0.10635309f, 0.06869032f, -0.01939288f, 0.04517023f, -0.01472614f, 0.01958864f, 
    -0.00214138f, 0.13147275f, 0.09893643f, -0.04688579f, 0.17121267f, 0.02901856f, 0.03912186f, -0.37760749f, 
    -0.09340078f, -0.07328516f, 0.00404852f, 0.12053183f, 0.05980555f, 0.06595337f, 0.18224095f, 0.10327143f, 
    -0.20328493f, -0.14544387f, 0.02839843f, 0.04263129f, -0.10544570f, 0.03014285f, 0.05159451f, -0.08513637f, 
    -0.00556704f, 0.14297530f, 0.08848812f, 0.19205189f, -0.11782385f, 0.12153720f, -0.17238651f, 0.29954147f, 
    -0.11882109f, 0.09898984f, 0.11465163f, 0.14854605f, 0.04478642f, 0.11850839f, 0.05091067f, 0.08910469f, 
    -0.01212945f, 0.20997562f, -0.06642794f, -0.21349496f, -0.07017570f, -0.08493445f, -0.16292182f, -0.02158586f, 
    0.08332884f, 0.01812972f, 0.05555949f, 0.12767179f, -0.20488663f, -0.22470599f, 0.06069672f, 0.30784515f, 
    -0.02001752f, 0.08227070f, -0.06051253f, 0.11246354f, 0.04335908f, -0.05530315f, 0.00800855f, 0.01151923f, 
    -0.01468478f, 0.15135501f, -0.10174748f, 0.10600126f, 0.01109538f, 0.11693399f, 0.17938592f, -0.16039868f, 
    0.03560787f, 0.08103651f, 0.10138689f, 0.09052210f, -0.12122979f, -0.00305416f, -0.13411772f, -0.34353831f, 
    0.20024267f, -0.21411622f, -0.05407159f, 0.00546018f, -0.03882625f, -0.25678891f, 0.17818765f, 0.11040179f, 
    -0.16287541f, -0.00286346f, 0.28349915f, 0.01103078f, 0.10848513f, -0.26013276f, -0.05907036f, 0.06650762f, 
    0.00908320f, 0.04055100f, -0.00224342f, 0.08699909f, -0.22670929f, -0.24024011f, 0.10095985f, -0.18386835f, 
    -0.05327248f, -0.05593193f, -0.28240269f, 0.06658172f, -0.01962992f, -0.16690201f, -0.00623664f, -0.08318617f, 
    0.06344799f, -0.28960952f, -0.04757694f, 0.07419799f, 0.11780253f, 0.05788931f, -0.02661874f, -0.00800740f, 
    0.05917655f, -0.05260886f, 0.07760628f, -0.07315718f, 0.18426158f, 0.13556969f, 0.29592776f, -0.05298493f, 
    0.04629058f, 0.00968922f, 0.00069771f, 0.14159001f, -0.04903691f, -0.04689053f, 0.10825192f, 0.02942230f, 
    0.08090956f, -0.12711033f, -0.06185207f, 0.06923811f, 0.01539606f, 0.12354268f, 0.01728273f, -0.00436593f, 
    0.02865323f, 0.03907070f, 0.31055117f, -0.02946230f, -0.30829132f, -0.17204204f, 0.40602908f, -0.28478324f, 
    0.12412915f, 0.00801149f, -0.26076335f, -0.04653385f, -0.01245909f, -0.02052093f, 0.14323813f, 0.00304545f, 
    0.22874443f, 0.19130681f, -0.23493913f, -0.13733219f, -0.09963056f, -0.30654183f, 0.26345596f, -0.00974824f, 
    0.12080036f, -0.07978992f, -0.02338048f, -0.02817865f, 0.10779212f, -0.02612519f, 0.34801912f, 0.27419686f, 
    0.07699712f, 0.20854181f, 0.08663967f, -0.00745620f, -0.02045059f, 0.14304078f, -0.01369140f, 0.14337432f, 
    0.14793505f, 0.26194954f, -0.12015481f, 0.10082538f, -0.00857202f, -0.14189294f, -0.02673663f, 0.00100465f, 
    -0.07985597f, 0.03784648f, -0.00326013f, -0.05037533f, 0.02652439f, -0.41409898f, -0.03056766f, 0.10162524f, 
    0.10007711f, -0.00210088f, 0.10871757f, 0.10819065f, 0.02360486f, -0.00811099f, -0.15849979f, -0.14762883f, 
    0.13085754f, -0.05788012f, 0.01955056f, 0.05302257f, 0.07987528f, 0.00034571f, 0.09676377f, -0.00388995f, 
    0.11535553f, -0.18683131f, -0.02076188f, 0.03987975f, 0.19817820f, -0.06637066f, -0.07425603f, 0.19536053f, 
    -0.05708026f, -0.10268410f, 0.18505992f, -0.20525551f, 0.07219527f, 0.15646859f, -0.19473293f, 0.04490839f, 
    -0.18935919f, -0.16855168f, -0.23228717f, 0.23316894f, 0.00356906f, 0.17549719f, 0.04699864f, -0.07922918f, 
    -0.00988128f, 0.02667131f, 0.08966243f, -0.05471763f, 0.25518000f, 0.10168875f, -0.05082873f, -0.03591293f, 
    0.14351505f, 0.14808114f, -0.24160407f, 0.21862604f, 0.13142540f, -0.01801679f, -0.15285550f, -0.09963766f, 
    -0.14311185f, 0.08138327f, -0.14782827f, 0.18109584f, -0.14717521f, 0.00881066f, 0.01032134f, 0.12218524f, 
    0.03194752f, 0.07078425f, 0.08013970f, 0.07268589f, 0.20794454f, 0.26911768f, 0.06910118f, -0.25084955f, 
    0.01092195f, 0.04128294f, -0.08566925f, 0.12648174f, 0.04620149f, -0.02829080f, 0.14951016f, 0.16588441f, 
    0.03155757f, 0.14647226f, 0.27407205f, 0.10968862f, 0.07463230f, 0.02731853f, 0.02649573f, -0.05632912f, 
    -0.02116967f, -0.07074725f, -0.00963518f, -0.02921261f, 0.18208009f, 0.01918742f, 0.15109172f, 0.01862343f, 
    -0.02533350f, -0.07196973f, -0.10014201f, 0.05235085f, -0.12301899f, 0.02261127f, 0.05242467f, -0.00358603f, 
    0.05050169f, -0.17477503f, -0.08796369f, -0.19391318f, 0.03747593f, -0.00538037f, -0.01767883f, -0.07984842f, 
    -0.15206237f, -0.00174714f, 0.04520832f, -0.06495193f, -0.04435417f, -0.15496734f, 0.11096673f, 0.01699341f, 
    0.10556172f, -0.00284261f, 0.04497539f, 0.11383297f, -0.11847576f, 0.05650742f, -0.10718735f, 0.03121585f, 
    -0.12917760f, -0.22935422f, -0.22623494f, 0.04759815f, -0.02243736f, 0.03290819f, -0.05258089f, 0.06009652f, 
    0.05205562f, 0.03174504f, 0.14366387f, -0.00256217f, 0.21825203f, 0.07098233f, 0.49874315f, -0.14707154f, 
    0.05394438f, -0.00864064f, -0.16747490f, -0.06154704f, -0.02665808f, -0.08261390f, 0.03445933f, -0.02485112f, 
    0.03563876f, 0.19550364f, -0.24073565f, -0.07582178f, 0.06384132f, -0.07460878f, 0.13513552f, -0.07105719f, 
    0.07017595f, 0.01595956f, 0.13484602f, 0.07207242f, 0.20702346f, -0.02668433f, -0.02245894f, 0.16560262f, 
    -0.05741977f, 0.00926538f, 0.05100300f, 0.10149674f, -0.04622763f, 0.02316612f, 0.02771311f, 0.04445708f, 
    0.05533210f, 0.06097611f, -0.15287775f, -0.03148432f, -0.00755038f, -0.03041399f, -0.02459192f, -0.00174147f, 
    0.04783813f, 0.16052930f, 0.06198421f, -0.07581576f, 0.01681385f, -0.16009618f, -0.10509638f, -0.25432181f, 
    -0.14869529f, 0.02405203f, -0.07472034f, 0.13121812f, -0.12183088f, 0.11417662f, 0.06186015f, 0.02406264f, 
    -0.29581508f, -0.26437068f, -0.18324618f, -0.04372465f, 0.10913496f, 0.09984870f, -0.04336245f, 0.06695820f, 
    0.00346059f, 0.08487950f, -0.05451814f, 0.04760180f, 0.11075816f, 0.04789304f, -0.05333299f, 0.15191509f, 
    -0.06724388f, 0.03798132f, 0.00954069f, -0.02259590f, 0.03566654f, 0.02728921f, 0.02864485f, 0.14970317f, 
    0.15455247f, 0.17249641f, 0.03956498f, -0.00633130f, -0.06221931f, 0.03817777f, 0.06929804f, 0.01372447f, 
    -0.04122706f, 0.02182757f, 0.05087918f, -0.01657750f, -0.23920877f, -0.19306324f, 0.03635221f, 0.21166244f, 
    0.16851725f, 0.10401478f, -0.03843649f, -0.01506384f, 0.08525123f, -0.08362210f, -0.00714913f, 0.06531820f, 
    -0.35906938f, -0.32660177f, -0.06129975f, 0.15108033f, 0.03415656f, 0.05902626f, 0.10645880f, 0.04915167f, 
    0.06727158f, -0.03286632f, -0.04739834f, -0.10363562f, -0.06440133f, 0.00776406f, 0.15005316f, -0.17347661f, 
    -0.03152670f, 0.04025390f, -0.18208401f, -0.03991689f, -0.00431020f, -0.16079095f, 0.08446468f, 0.14448549f, 
    0.38733745f, 0.03946044f, 0.17179184f, 0.09565373f, -0.02660662f, 0.11284955f, 0.22797121f, 0.18947154f, 
    0.03106931f, 0.10049678f, -0.09836692f, -0.04051913f, -0.01525938f, 0.09862920f, -0.07319487f, 0.06174815f, 
    0.00349521f, 0.02648840f, -0.08136317f, -0.08659528f, -0.04880219f, 0.18827011f, -0.01160477f, 0.05360575f, 
    0.06230591f, -0.05766630f, -0.03927723f, -0.08733907f, 0.06818574f, -0.01960180f, 0.02055288f, -0.10483632f, 
    0.06402365f, 0.16278139f, 0.00947996f, 0.10034815f, 0.09920137f, 0.07165459f, 0.06657099f, 0.26668894f, 
    0.03489368f, -0.01432304f, 0.25101480f, 0.12791620f, -0.10069436f, -0.02893004f, 0.05887316f, -0.05030948f, 
    -0.04589747f, -0.16560316f, -0.05256768f, 0.02607708f, -0.02890634f, -0.13064560f, -0.11980328f, 0.08625519f, 
    -0.06862524f, -0.02636419f, -0.06543320f, -0.18381125f, -0.00063562f, 0.27642205f, 0.13255937f, 0.17097022f, 
    -0.08852033f, -0.05551202f, -0.02556611f, 0.10491106f, -0.01282658f, -0.17569263f, -0.06743933f, -0.15213110f, 
    0.01593315f, 0.48561692f, -0.24122128f, -0.27232796f, 0.07906966f, -0.07715625f, 0.26065296f, 0.10021180f, 
    -0.21893325f, -0.01807805f, 0.12437765f, 0.04758732f, 0.03733956f, -0.19680221f, -0.20205709f, -0.07876947f, 
    -0.03595976f, -0.11382269f, -0.02034947f, 0.16472363f, 0.09315470f, 0.06911216f, -0.00104414f, 0.00673354f, 
    0.06677180f, 0.18222103f, -0.15047461f, -0.01210071f, 0.06680035f, -0.02638138f, 0.08774197f, 0.07476069f, 
    -0.05273463f, 0.02046741f, 0.02830968f, -0.03495937f, 0.21500818f, 0.08147607f, -0.14779387f, -0.17086384f, 
    -0.07734508f, 0.01409306f, 0.01949452f, -0.09925485f, 0.07923858f, 0.08839251f, 0.03677209f, 0.12331298f, 
    -0.05804338f, 0.02669242f, -0.12760325f, 0.02359796f, 0.12770705f, 0.24793501f, 0.04545807f, 0.09388329f, 
    0.04709709f, 0.11046945f, 0.02245796f, 0.01399042f, 0.31584647f, 0.12106165f, -0.00565552f, 0.27582181f, 
    0.21316507f, 0.09814722f, 0.00189443f, 0.17080185f, 0.09710341f, 0.01217955f, -0.09738219f, 0.00392197f, 
    0.02108298f, -0.04754963f, 0.14288923f, -0.17878528f, 0.13880470f, -0.09574091f, -0.12679398f, 0.06088935f, 
    0.13006209f, 0.04010271f, 0.14854889f, 0.21099187f, 0.17642891f, 0.02349861f, 0.00480413f, 0.08834568f, 
    0.22538492f, 0.07003140f, 0.19222493f, 0.11897923f, 0.10899642f, 0.11189076f, -0.11723724f, -0.04753102f, 
    -0.09486268f, 0.17174169f, 0.11915858f, 0.17019114f, -0.08859160f, 0.03156553f, -0.00477567f, 0.18285573f, 
    0.11225827f, -0.03533985f, -0.02885953f, -0.09007597f, -0.26889247f, 0.09965961f, 0.02548285f, 0.26396951f, 
    0.03250628f, 0.02307394f, -0.03896433f, 0.00352516f, 0.07921323f, -0.00894064f, 0.12233191f, 0.07368075f, 
    0.10932907f, 0.32886210f, -0.07092711f, -0.11331373f, 0.09028857f, -0.01133714f, 0.06586923f, 0.12327671f, 
    0.07782001f, 0.14622509f, -0.00746156f, -0.06887785f, 0.32650992f, -0.21087480f, -0.01938509f, 0.20035395f, 
    0.00918227f, 0.15084916f, 0.04100458f, 0.09547482f, 0.03707148f, -0.04542969f, -0.13551556f, -0.05409449f, 
    -0.28762937f, 0.06615473f, 0.07567026f, -0.03255918f, 0.00732783f, 0.13954133f, -0.03219915f, -0.13265076f, 
    0.17872576f, 0.08724405f, -0.11965037f, -0.02795236f, 0.09915863f, 0.02101742f, 0.03620156f, -0.00012021f, 
    -0.03042056f, 0.00954366f, 0.02638240f, -0.03850082f, 0.01789816f, -0.11185148f, 0.05048382f, 0.01392134f, 
    -0.08477753f, 0.07393382f, -0.05508960f, -0.02536630f, 0.10230218f, -0.03301997f, -0.10801821f, 0.04307756f, 
    0.05005496f, 0.22271532f, -0.01585123f, -0.04148835f, 0.54934496f, -0.30931997f, 0.31411153f, -0.13332871f, 
    -0.23723677f, -0.09461554f, -0.11460473f, -0.01283950f, -0.06662806f, 0.11642537f, -0.03138424f, -0.11923395f, 
    -0.42549178f, 0.29441649f, -0.06066264f, 0.40211552f, 0.24861902f, 0.15234680f, 0.01714481f, -0.10458916f, 
    0.07991962f, 0.14181589f, 0.10536290f, 0.09111813f, 0.09171169f, 0.35672963f, 0.01090788f, -0.26442412f, 
    0.00572503f, -0.17790343f, -0.19357574f, 0.00111196f, 0.12517089f, -0.03713714f, -0.05904362f, 0.02965502f, 
    -0.15423959f, -0.08219790f, 0.08120763f, 0.22734204f, 0.09717264f, 0.18011193f, 0.03426744f, -0.03926674f, 
    -0.00169024f, 0.04179619f, 0.15118866f, 0.13461404f, -0.47673687f, 0.06437765f, -0.10150593f, 0.24146271f, 
    0.09437303f, -0.18874387f, -0.13554747f, 0.04672073f, -0.18174639f, 0.03740598f, -0.08326599f, 0.11477507f, 
    -0.04800782f, 0.20234786f, -0.17252697f, 0.15883964f, 0.08301971f, 0.03288459f, -0.06213354f, 0.04571741f, 
    0.03310948f, -0.07983926f, 0.03197356f, -0.14535780f, -0.15810446f, 0.20110071f, 0.35612187f, 0.00155683f, 
    -0.11086086f, -0.03399229f, -0.07979136f, 0.16385303f, -0.06357281f, 0.09260121f, 0.14617237f, 0.16661176f, 
    0.04840748f, -0.02226701f, 0.02573236f, -0.08114976f, -0.16919166f, -0.02158982f, 0.04196649f, 0.12494869f, 
    -0.04261315f, 0.02817281f, 0.11516747f, -0.11202270f, -0.26300627f, 0.24159630f, -0.26561239f, -0.07692746f, 
    0.13722870f, 0.02262611f, 0.21533158f, -0.23015635f, -0.15665404f, 0.16077778f, -0.08655225f, 0.08409143f, 
    -0.00701442f, -0.36157650f, -0.17471871f, -0.14709687f, 0.13094400f, 0.04876957f, 0.15496221f, 0.03404989f, 
    0.04719264f, 0.06866086f, 0.01556318f, 0.05534606f, 0.03028875f, 0.20549354f, 0.07199328f, -0.07156228f, 
    -0.02873924f, 0.00959583f, 0.00369790f, 0.01054522f, -0.02136710f, 0.16578206f, -0.20691675f, -0.04668619f, 
    -0.19807808f, 0.08287093f, -0.00727065f, -0.20568909f, 0.02944539f, -0.12912866f, 0.13034567f, 0.00186384f, 
    -0.09692564f, 0.03287046f, -0.02029276f, -0.02148038f, -0.04208058f, 0.10918362f, 0.15209551f, -0.15595067f, 
    0.07687773f, -0.13541186f, 0.08933173f, 0.00431582f, -0.18465650f, 0.03599084f, 0.13414653f, 0.05972917f, 
    -0.03856072f, -0.01888961f, -0.18876280f, -0.00399902f, -0.03870093f, 0.02910964f, -0.02919989f, 0.06889044f, 
    0.09843861f, 0.17304276f, 0.04610223f, 0.15180494f, -0.08100210f, 0.08454756f, 0.19689779f, 0.02509991f, 
    0.21407618f, 0.02580887f, -0.03668711f, 0.15754464f, 0.04567481f, -0.04527525f, -0.04443922f, 0.03284555f, 
    0.01798826f, -0.09282329f, -0.11186696f, -0.03384487f, 0.04163620f, 0.08515985f, 0.03305056f, 0.07734662f, 
    -0.02066527f, -0.20683838f, 0.01107993f, -0.18197161f, -0.00780246f, 0.19090456f, 0.02893106f, 0.03264040f, 
    -0.08111233f, -0.12597348f, 0.11421214f, -0.01369741f, -0.07509965f, 0.07742307f, -0.04783011f, -0.04731567f, 
    -0.14389157f, -0.07286120f, -0.07004984f, -0.11312788f, 0.01006899f, -0.04016414f, -0.12629052f, 0.02275159f, 
    0.23551886f, -0.04785855f, -0.01605392f, -0.09194483f, -0.02577153f, -0.06641641f, -0.05972484f, -0.12548569f, 
    0.08115990f, -0.08573955f, -0.09462214f, -0.10132732f, -0.17666703f, -0.00166064f, -0.10308619f, -0.32132834f, 
    -0.02488169f, 0.03229495f, 0.03333916f, 0.01925570f, 0.02281003f, -0.06479787f, 0.12086075f, 0.16966371f, 
    0.12594093f, 0.06664100f, -0.20911558f, -0.22133219f, 0.02144976f, -0.03926433f, -0.11864097f, -0.20983420f, 
    -0.05343043f, -0.10220005f, -0.09954963f, -0.16048568f, 0.13040170f, 0.04882272f, 0.08912142f, 0.01188800f, 
    -0.12673661f, -0.08335113f, 0.24679340f, 0.11884836f, -0.04294112f, 0.10174595f, 0.05765461f, 0.12536335f, 
    0.01969028f, -0.03383192f, 0.00850959f, 0.20119937f, -0.15209351f, 0.19802043f, 0.18280628f, 0.19861624f, 
    -0.01411714f, -0.01642412f, 0.08175532f, 0.14336909f, 0.10618329f, 0.01642894f, 0.16478091f, 0.09778038f, 
    0.06387027f, 0.17970844f, 0.12011755f, 0.00491990f, -0.15955262f, -0.02997161f, -0.09171472f, -0.06886493f, 
    0.01909768f, 0.18919931f, 0.05434903f, 0.11479864f, -0.14023872f, 0.13535587f, 0.07683220f, 0.00469734f, 
    -0.18333445f, 0.05884159f, 0.02080671f, 0.16127233f, -0.06404179f, 0.08246431f, 0.07428285f, 0.04609313f, 
    0.28186080f, 0.00293098f, 0.23594987f, -0.03105645f, 0.06050983f, -0.01440838f, -0.01134601f, 0.12473415f, 
    0.14527653f, -0.10802864f, -0.07749426f, -0.04818106f, -0.08288972f, -0.30834439f, -0.15767939f, 0.28681535f, 
    -0.04758719f, 0.02109139f, 0.12192762f, -0.13277115f, 0.07757947f, 0.05852908f, -0.03825221f, 0.14613943f, 
    -0.20926164f, -0.14209731f, -0.27576578f, -0.05264251f, 0.09581840f, 0.01670914f, -0.05268345f, -0.03233122f, 
    0.04932198f, 0.02387170f, 0.10771648f, -0.03476549f, -0.22862589f, 0.00009028f, -0.11841717f, -0.00111249f, 
    -0.00643490f, 0.06738341f, -0.11268395f, 0.09629750f, 0.03745303f, -0.04612465f, -0.05616235f, 0.05966823f, 
    -0.03024088f, 0.04169949f, 0.14552395f, 0.09953433f, -0.07522457f, 0.02980006f, 0.15522565f, 0.01312203f, 
    -0.03948224f, 0.00774186f, -0.10598514f, -0.04711729f, 0.08669629f, 0.19619311f, 0.09970908f, 0.06333768f, 
    0.00794016f, 0.09018568f, -0.02980626f, 0.05508035f, 0.03608368f, 0.04155543f, 0.04344803f, 0.04307136f, 
    0.19684358f, 0.16047075f, 0.17556179f, 0.05435672f, 0.05709801f, 0.01307502f, 0.07896174f, -0.03580724f, 
    -0.05413645f, 0.06092329f, -0.00515392f, 0.04052581f, -0.10902347f, -0.03852224f, -0.20483859f, 0.09414210f, 
    -0.05404380f, 0.01531240f, -0.07129119f, -0.05702922f, -0.02373176f, -0.02443373f, 0.06974707f, -0.07312457f, 
    -0.12571339f, -0.19924958f, 0.46797431f, 0.26848164f, -0.04812368f, -0.00248670f, -0.19473295f, -0.02301546f, 
    -0.02927427f, -0.03617941f, -0.03399856f, -0.05506342f, -0.10826083f, 0.10790492f, 0.06418025f, -0.03335258f, 
    -0.03661842f, -0.03659107f, 0.05835853f, 0.08162870f, 0.16479358f, 0.01328453f, 0.10757372f, 0.03844335f, 
    0.08453570f, 0.06609707f, 0.26837882f, 0.06342871f, -0.00874914f, 0.05108616f, 0.09838478f, 0.07608011f, 
    0.11953945f, -0.08372525f, 0.01261627f, 0.14018631f, -0.15347691f, -0.23279569f, 0.07583325f, 0.18187085f, 
    -0.15673713f, -0.06762892f, -0.02588680f, 0.02444888f, 0.11995875f, 0.02234400f, -0.02678933f, 0.08364020f, 
    0.14149024f, 0.22299483f, 0.28080028f, 0.05927356f, -0.05206670f, 0.13173436f, 0.06033770f, 0.16925630f, 
    -0.03977741f, -0.06670555f, -0.03353836f, -0.09811297f, 0.06520107f, -0.13556284f, 0.24169715f, -0.00940612f, 
    0.09364897f, 0.10410152f, 0.16635981f, -0.00509823f, 0.02518950f, 0.02375346f, 0.03343549f, -0.03236165f, 
    -0.18331350f, -0.23410708f, -0.27765322f, -0.06084659f, 0.00945132f, -0.09915654f, -0.00223762f, 0.13047723f, 
    -0.04317831f, 0.05874901f, -0.06866372f, 0.07623883f, 0.16827118f, 0.19283226f, 0.14389005f, -0.08767446f, 
    -0.00079347f, -0.00272752f, -0.04615726f, -0.08751223f, 0.02177530f, 0.01768407f, -0.00528183f, 0.05786931f, 
    0.19212028f, 0.01636798f, 0.31445947f, -0.30457506f, 0.17419364f, -0.14806297f, -0.06523137f, -0.00942063f, 
    -0.03296359f, 0.05691177f, 0.03134524f, -0.05981927f, 0.02381672f, -0.34146771f, 0.04535248f, 0.13360824f, 
    -0.13211647f, 0.08709288f, 0.02766937f, -0.12866427f, 0.07704171f, 0.09567574f, 0.00003145f, -0.21271880f, 
    0.14288397f, -0.32261017f, -0.45899317f, 0.04318607f, 0.00377796f, 0.14671811f, 0.00327816f, -0.00120228f, 
    -0.06711363f, 0.13718686f, 0.08754361f, -0.02241855f, -0.08615194f, 0.00855899f, -0.47247332f, -0.18382594f, 
    0.03724385f, -0.11653661f, 0.05848401f, -0.18726531f, 0.03563209f, 0.05116140f, 0.06981324f, -0.00022051f, 
    -0.08117244f, -0.13670582f, -0.00156691f, 0.16362976f, 0.03193901f, -0.10832171f, -0.06313518f, 0.10426427f, 
    0.09621213f, 0.11917686f, 0.01109985f, 0.05834475f, -0.11614843f, -0.05032665f, -0.06056288f, -0.00270218f, 
    0.05717417f, 0.00250544f, -0.09996362f, 0.01997928f, 0.11168323f, 0.08296460f, 0.15130681f, 0.12538396f, 
    0.14268848f, 0.11101086f, 0.25135157f, -0.04395794f, -0.01186124f, 0.04951490f, 0.08535203f, 0.12660450f, 
    0.04012172f, -0.03628842f, -0.15838888f, 0.06121760f, 0.02043649f, 0.15251195f, -0.79049128f, 0.17721689f, 
    -0.04847165f, 0.01614528f, 0.23825563f, -0.05396384f, 0.04655371f, 0.12643260f, -0.11823678f, -0.03904279f, 
    -0.31529403f, -0.28109583f, 0.22875173f, 0.13121566f, 0.05328437f, -0.00404590f, -0.02334020f, 0.03853638f, 
    -0.05275790f, 0.04113128f, -0.03473453f, 0.14104950f, -0.14791992f, -0.00371625f, -0.12352490f, -0.21411784f, 
    0.03627090f, -0.05272842f, 0.05960185f, -0.04788477f, 0.07026479f, -0.08536945f, 0.13348828f, -0.12618220f, 
    -0.10599650f, 0.00563302f, 0.07409460f, -0.01401632f, 0.06830284f, 0.02148409f, -0.00616065f, -0.04395703f, 
    0.17655465f, 0.20366609f, 0.00539759f, 0.17282212f, -0.05151112f, 0.18480134f, 0.35716614f, 0.36129090f, 
    0.00327853f, -0.16291837f, -0.12935540f, -0.15264980f, 0.14457251f, -0.07544892f, 0.09525219f, 0.14810237f, 
    -0.10128509f, 0.06890358f, 0.20835783f, -0.14854191f, -0.16885410f, 0.02589965f, 0.02558754f, -0.01663126f, 
    0.03989256f, 0.05648528f, 0.08611858f, 0.18648824f, 0.04291686f, -0.18654749f, -0.11108340f, -0.01309641f, 
    0.17881955f, 0.09697253f, -0.05445144f, 0.03301485f, -0.04624253f, 0.01109850f, 0.06831516f, -0.08435167f, 
    0.13201545f, 0.15621100f, 0.12973307f, 0.11901933f, 0.10633542f, -0.16276129f, -0.06750769f, -0.07623087f, 
    0.07324646f, 0.06789149f, 0.03365147f, 0.05442248f, 0.29114574f, -0.22687700f, -0.03006832f, -0.15712893f, 
    -0.02164769f, 0.13862641f, -0.07729197f, -0.08628147f, 0.04101346f, -0.06681385f, 0.07658897f, -0.02542287f, 
    0.06469056f, 0.18485054f, 0.18532017f, -0.05600502f, -0.01750289f, -0.09791461f, 0.08117765f, 0.04731615f, 
    -0.06431628f, -0.11693821f, -0.04144004f, -0.16962752f, 0.10296743f, -0.35784516f, 0.26896134f, -0.11647699f, 
    -0.08306988f, 0.25857115f, -0.00907283f, -0.05900542f, 0.18985386f, 0.16295387f, 0.09505072f, -0.09263866f, 
    0.02544262f, -0.47134206f, -0.08618531f, 0.23262298f, 0.06125725f, 0.35778257f, -0.12024665f, -0.13075495f, 
    -0.02522494f, 0.14984901f, 0.09990009f, 0.01769829f, 0.12676215f, 0.02136175f, -0.38777706f, -0.03236275f, 
    0.05075802f, -0.04743363f, -0.05632664f, 0.00739878f, 0.13763690f, 0.07607473f, 0.09055241f, 0.01582417f, 
    -0.11737095f, -0.14705460f, 0.00508577f, 0.12327369f, 0.02665795f, -0.00141080f, -0.10552679f, -0.00974761f, 
    0.01747652f, -0.02994562f, -0.22347453f, -0.17454803f, 0.05428604f, -0.10039116f, 0.02419280f, 0.20891269f, 
    0.01198705f, 0.07485525f, 0.16665575f, 0.10184566f, -0.10800295f, 0.05441145f, -0.04025821f, 0.19306095f, 
    -0.00120074f, -0.01179682f, 0.12475966f, 0.05101074f, 0.01473630f, 0.21893308f, -0.00818261f, 0.01303464f, 
    0.09643310f, 0.17020461f, -0.23404247f, 0.05983927f, 0.01204181f, 0.22054292f, -0.42518139f, -0.03581068f, 
    0.05041388f, 0.13443092f, -0.13909499f, -0.12192600f, 0.02380699f, 0.01451415f, 0.09207034f, -0.02062022f, 
    -0.43156925f, -0.26522538f, 0.31074765f, 0.08461969f, -0.08160204f, -0.03987498f, 0.06194463f, 0.10186698f, 
    -0.18797709f, -0.01577008f, 0.07808807f, -0.00873977f, -0.19419591f, -0.09384111f, -0.18222122f, -0.14507827f, 
    -0.09418101f, -0.09363788f, 0.20210104f, 0.11092085f, 0.10750560f, -0.18638746f, 0.06788977f, 0.25715828f, 
    -0.08893927f, 0.07591235f, 0.19982016f, -0.03620028f, 0.01797038f, -0.07029999f, -0.09922343f, 0.00216833f, 
    0.07374094f, 0.10542855f, 0.17545460f, 0.14552303f, 0.03357475f, -0.18803488f, 0.11181990f, 0.11945650f, 
    -0.14283670f, -0.10425842f, -0.08337092f, 0.11630383f, 0.02583946f, 0.08579691f, 0.14909388f, 0.12793937f, 
    0.02424288f, 0.13048947f, 0.21688305f, -0.09564324f, -0.04020527f, 0.02506293f, 0.01937788f, 0.07651933f, 
    -0.04991231f, -0.03627967f, -0.07472876f, 0.05859800f, 0.20752060f, -0.10558317f, -0.04384539f, -0.00408714f, 
    0.13048653f, 0.19788104f, 0.01923176f, -0.02825516f, -0.07827519f, -0.04860426f, -0.04094723f, -0.03958783f, 
    0.09410371f, -0.24935384f, -0.04736665f, -0.22515133f, 0.09506212f, -0.24917910f, -0.07014728f, 0.09331698f, 
    0.19177341f, 0.09610233f, 0.01130763f, 0.03569712f, -0.03015390f, -0.28159639f, 0.23433247f, 0.21483104f, 
    0.27170807f, 0.00855999f, -0.00149508f, -0.18300419f, 0.12211041f, -0.13190366f, 0.01378998f, -0.13652223f, 
    0.06281390f, -0.00221235f, -0.08053260f, -0.17624252f, 0.15950000f, 0.11494973f, 0.07100844f, -0.02034303f, 
    -0.05621042f, 0.06613333f, -0.09340917f, 0.01271654f, -0.04531686f, 0.00552303f, 0.03719058f, 0.02229548f, 
    0.23982288f, 0.02051851f, 0.09480704f, 0.11151106f, -0.01841462f, -0.02738570f, 0.05622233f, -0.01011018f, 
    0.00166709f, -0.01350016f, 0.08587898f, -0.02089037f, 0.22451083f, -0.01976205f, 0.12311786f, 0.13826987f, 
    -0.05854698f, -0.04485566f, 0.03694507f, -0.15232411f, 0.17666796f, 0.09830925f, 0.08403230f, -0.04462495f, 
    -0.04279925f, -0.02375038f, -0.10313462f, 0.00210793f, -0.06109930f, -0.02096736f, 0.05449972f, 0.18418792f, 
    -0.08494470f, -0.15288067f, 0.02884509f, -0.06792855f, 0.08834679f, -0.06637502f, 0.00440219f, -0.13233152f, 
    0.01815404f, 0.26666445f, 0.02847884f, 0.15125452f, 0.07721715f, 0.13182183f, 0.19116805f, -0.25969350f, 
    0.20421407f, 0.04751164f, -0.05352851f, 0.06301027f, -0.01282926f, -0.08338519f, 0.00723135f, 0.01903453f, 
    0.26227847f, -0.09156930f, -0.12284372f, -0.06193548f, 0.02834021f, 0.01952227f, -0.04146460f, -0.05778890f, 
    -0.07171009f, -0.15518828f, -0.13155082f, -0.20215407f, -0.11197426f, -0.02186199f, 0.07102431f, -0.06535492f, 
    -0.00562133f, -0.02740273f, 0.01693027f, 0.01878701f, -0.12852237f, 0.05279939f, -0.03184379f, -0.00326540f, 
    0.12171582f, 0.16801494f, 0.03632665f, 0.02191973f, -0.03387279f, -0.15824667f, 0.28279805f, 0.07871282f, 
    0.09196070f, -0.10620511f, 0.03401883f, -0.05529789f, -0.19611332f, 0.04569506f, 0.08027519f, -0.11892832f, 
    -0.01309237f, 0.05506855f, 0.13584889f, 0.00674764f, -0.09947430f, -0.10652524f, -0.05097852f, -0.18414432f, 
    0.19067270f, 0.15854762f, 0.02179893f, -0.03962292f, -0.04300626f, -0.00435504f, 0.05915971f, -0.02464407f, 
    -0.08570703f, 0.04575738f, -0.04156854f, -0.12067094f, -0.25909922f, -0.14854333f, 0.06345314f, 0.11230941f, 
    -0.12692396f, -0.01043067f, 0.01856402f, 0.08866137f, 0.13366413f, -0.02174278f, -0.02076541f, 0.02677139f, 
    0.02105466f, -0.05337074f, -0.03868053f, -0.16894226f, 0.00846978f, 0.01130016f, -0.04546512f, -0.00402739f, 
    -0.01646934f, -0.00972621f, -0.08993246f, 0.13404848f, 0.12904701f, -0.18962026f, 0.04791147f, -0.11901108f, 
    0.06857122f, -0.03334742f, 0.04840615f, -0.05987864f, 0.20845839f, 0.11390263f, 0.07984212f, 0.04905764f, 
    0.05942001f, 0.05848614f, 0.18965989f, 0.16199139f, -0.05592781f, 0.05429882f, 0.05109744f, -0.01942856f, 
    -0.06238723f, 0.06426482f, 0.07560000f, 0.07743508f, 0.24785115f, 0.07288895f, -0.02844244f, -0.26782593f, 
    -0.08738168f, -0.07460253f, -0.11120979f, 0.04696034f, 0.05418407f, -0.09539617f, 0.13468497f, 0.12318458f, 
    0.16579844f, 0.22170575f, -0.01001610f, -0.11243144f, -0.04443939f, 0.12341117f, 0.00288718f, 0.22016765f, 
    0.08213697f, -0.08626295f, -0.04915425f, -0.05908172f, -0.10084732f, 0.30741063f, -0.00823451f, 0.33080950f, 
    0.08420399f, 0.12697172f, 0.03665495f, -0.04980413f, 0.06875362f, 0.10334141f, 0.09060214f, 0.05875701f, 
    -0.05801745f, 0.23714535f, -0.07303214f, 0.01298607f, 0.09391478f, 0.01945682f, 0.00390248f, -0.06587105f, 
    -0.06283810f, 0.03439716f, 0.02023603f, -0.15704340f, 0.37733459f, 0.00480084f, 0.07650095f, 0.11807169f, 
    -0.07447165f, -0.07564675f, 0.06467425f, 0.16942364f, -0.00955631f, -0.01100294f, -0.05992859f, 0.08487076f, 
    -0.13488711f, -0.04220865f, -0.08128510f, 0.04402091f, -0.11350582f, -0.19527233f, 0.04185951f, -0.06902907f, 
    -0.00886777f, 0.12850647f, -0.02706242f, 0.00965835f, -0.17867516f, -0.05905078f, 0.02423628f, 0.12864344f, 
    0.12365640f, 0.15079463f, 0.02233470f, -0.01232474f, 0.04584502f, 0.02728307f, 0.09056693f, 0.01687003f, 
    -0.11896207f, 0.10488459f, -0.14384505f, 0.02232488f, 0.00726004f, 0.08959199f, -0.17347918f, 0.00489949f, 
    0.03554859f, 0.18929595f, -0.08108523f, -0.18140124f, 0.61359137f, -0.05666191f, 0.31358361f, -0.03395228f, 
    -0.08578024f, -0.05307708f, -0.07354090f, -0.10240496f, -0.03274333f, -0.01005669f, -0.06935526f, -0.10279155f, 
    -0.47091657f, -0.09816299f, 0.29016006f, 0.05004687f, -0.09153799f, 0.12080719f, -0.09535106f, 0.02002086f, 
    0.17889862f, 0.06679656f, -0.03622359f, -0.14985645f, -0.26290926f, 0.22484195f, 0.04405852f, 0.12752502f, 
    -0.02276998f, -0.10411469f, 0.07056519f, -0.00041628f, -0.02568571f, -0.12709658f, -0.01246505f, -0.20609532f, 
    -0.09137001f, -0.07895218f, 0.02558223f, 0.08168118f, -0.07105447f, 0.02029065f, 0.05541711f, 0.08411187f, 
    0.13613757f, 0.12967812f, 0.00988086f, -0.05006180f, -0.41547042f, -0.05389312f, 0.14030203f, 0.02050256f, 
    -0.14694081f, -0.13396423f, -0.10377999f, 0.11373050f, 0.02197669f, 0.00892922f, 0.02593531f, 0.20404387f, 
    -0.05801109f, -0.06454688f, 0.15372150f, -0.03991184f, -0.07420941f, 0.02002664f, 0.02329361f, 0.08020654f, 
    -0.03227064f, -0.15297420f, -0.05732310f, -0.03486860f, 0.05125933f, 0.12652764f, 0.25619969f, 0.05637278f, 
    -0.12716979f, 0.20605911f, -0.00078641f, 0.00893712f, -0.02450767f, 0.03097184f, 0.17723109f, 0.23511936f, 
    0.19200850f, 0.26896030f, 0.20812839f, 0.03054942f, -0.21456760f, -0.06805234f, 0.04874865f, 0.04268434f, 
    0.04298721f, 0.01797595f, 0.01582705f, 0.07461854f, -0.44557568f, -0.00732950f, 0.02416129f, -0.04283250f, 
    -0.00827701f, -0.02616576f, 0.01482261f, -0.28350064f, -0.05955209f, 0.11460670f, 0.00998179f, -0.09383906f, 
    0.08359598f, 0.42659450f, -0.09268777f, 0.15518621f, -0.01414520f, 0.08620834f, 0.08674803f, 0.06617820f, 
    0.00523316f, -0.11387044f, -0.01779214f, 0.10340168f, -0.11008983f, 0.09124990f, -0.08951563f, -0.05740153f, 
    0.13012737f, -0.03196257f, 0.04675821f, -0.11464356f, 0.09830379f, -0.11440602f, 0.23196302f, 0.19862199f, 
    -0.31863827f, -0.11545946f, -0.03036100f, -0.01347755f, -0.10325161f, 0.11652748f, -0.15856531f, 0.02375587f, 
    -0.04233325f, -0.00778791f, 0.01005599f, -0.07465493f, -0.07702100f, 0.03360810f, -0.17453812f, -0.01434328f, 
    -0.11148073f, -0.05626725f, -0.12715529f, 0.00369607f, 0.16503009f, -0.02867469f, 0.06429678f, 0.01811685f, 
    -0.03115495f, -0.09123364f, 0.02759108f, 0.00322643f, -0.09863461f, -0.03712895f, 0.05734677f, -0.09570725f, 
    -0.01950585f, 0.12481455f, -0.13216726f, -0.13395301f, 0.00407774f, 0.06060228f, 0.15625691f, 0.15250476f, 
    0.22506435f, 0.27285066f, 0.03582432f, 0.17301707f, -0.02791631f, -0.05725666f, 0.04460080f, 0.10205320f, 
    -0.09310437f, 0.06784352f, -0.19386968f, 0.13076542f, -0.03302506f, 0.03463520f, -0.10319919f, 0.00744276f, 
    0.02092024f, 0.08542002f, 0.03585570f, -0.16301000f, -0.18778504f, -0.17619881f, 0.15854190f, -0.08775283f, 
    0.01793981f, -0.02215300f, -0.19575235f, -0.03320006f, 0.09804581f, -0.13861598f, -0.06309226f, -0.03216975f, 
    -0.14670950f, 0.03526106f, 0.18389177f, -0.02195478f, -0.03736391f, -0.02452141f, 0.00526242f, 0.04155512f, 
    0.05476765f, 0.14401665f, -0.04641317f, -0.01317456f, 0.10941295f, 0.17128435f, 0.20930892f, 0.40377328f, 
    0.08283976f, -0.00194041f, 0.01417899f, 0.11133724f, 0.01172586f, 0.03514051f, -0.14705886f, 0.16333771f, 
    0.17822179f, 0.32262468f, 0.01015273f, 0.01079229f, -0.01018473f, -0.12931493f, 0.05689710f, -0.03170374f, 
    -0.06093214f, -0.01255069f, -0.09569965f, 0.01027942f, -0.00979793f, -0.10468629f, 0.10498457f, 0.12028272f, 
    -0.24250793f, -0.17070816f, -0.01807769f, 0.12963550f, 0.00548174f, 0.12422281f, -0.15470646f, 0.11065307f, 
    0.20212319f, 0.09918934f, 0.12075125f, -0.10582254f, 0.15254399f, 0.18002941f, 0.04130382f, 0.01859046f, 
    -0.04918379f, -0.10353879f, -0.01930315f, -0.07598861f, 0.32143533f, -0.21340919f, -0.00282654f, 0.14433356f, 
    -0.00477976f, 0.21637267f, 0.20260805f, -0.12935515f, -0.01916360f, 0.01814890f, 0.07673123f, 0.01507888f, 
    -0.10477588f, -0.01306660f, -0.20028684f, 0.05572930f, -0.09443215f, -0.04301995f, -0.03889843f, 0.01711721f, 
    0.09268460f, 0.18671952f, -0.01843602f, 0.10694186f, -0.04041718f, -0.12038794f, 0.09582328f, -0.11908183f, 
    0.31493711f, -0.07980870f, -0.18059725f, 0.00998340f, -0.00823016f, -0.06343802f, 0.10955638f, -0.06961814f, 
    -0.21763195f, 0.03079077f, 0.15654847f, 0.09133577f, -0.06625550f, 0.06740912f, 0.09697047f, 0.15938321f, 
    -0.04243628f, -0.00006158f, 0.00586410f, -0.16083556f, 0.13516694f, -0.31086376f, 0.00731566f, -0.20821750f, 
    0.05580613f, 0.04041097f, -0.11535692f, -0.10145433f, 0.09094939f, -0.01428802f, 0.07760610f, 0.18526068f, 
    0.39171144f, 0.04996416f, 0.07614493f, 0.25248581f, 0.21066566f, 0.03670729f, 0.11669326f, -0.01601911f, 
    0.07476681f, 0.15758440f, 0.03449514f, -0.21989575f, 0.06270755f, -0.03177017f, 0.07576405f, -0.04129649f, 
    -0.02056080f, -0.08223335f, -0.13648035f, 0.00208702f, -0.09460226f, 0.05233367f, 0.07755421f, 0.18021776f, 
    -0.02658789f, -0.25068229f, -0.26648131f, 0.01902805f, 0.11184968f, -0.02747444f, -0.02840459f, 0.05321152f, 
    0.02597642f, 0.12073626f, 0.03864456f, 0.03016958f, 0.02519349f, -0.07582491f, 0.07567327f, 0.29502681f, 
    -0.00669155f, 0.00543701f, 0.21202053f, 0.12644331f, -0.13588271f, 0.03556648f, -0.05881861f, 0.00742263f, 
    0.10731646f, -0.18839018f, -0.05807697f, 0.08623474f, -0.03414690f, -0.03549844f, -0.23437402f, 0.06938415f, 
    -0.08235948f, 0.13336751f, -0.03159921f, -0.21852636f, 0.00302845f, 0.12012758f, 0.28682208f, -0.29384604f, 
    0.04578242f, 0.13635543f, -0.16979916f, 0.04763155f, -0.10485473f, -0.15734492f, 0.11025846f, -0.20067352f, 
    -0.27932826f, 0.08619679f, -0.07673885f, 0.10744448f, 0.05735969f, -0.19608052f, 0.09440432f, 0.08438490f, 
    -0.00703360f, -0.07731012f, 0.01079671f, 0.06036576f, -0.14978226f, -0.05299837f, 0.05678736f, 0.15650609f, 
    0.02085671f, -0.05635462f, -0.00745348f, 0.11717890f, 0.02254822f, -0.12802428f, -0.03701870f, 0.01483405f, 
    -0.12711713f, 0.13522960f, 0.09391222f, -0.00628262f, -0.11249881f, -0.11399587f, -0.07324425f, 0.02853243f, 
    0.07575888f, 0.04276011f, 0.18921353f, -0.14052048f, -0.19227834f, -0.37614048f, -0.10017727f, 0.15391260f, 
    -0.04196359f, -0.06797452f, -0.05304748f, -0.00365937f, 0.14151753f, -0.00010784f, 0.00835827f, 0.19457421f, 
    -0.09313757f, -0.09569174f, 0.11347776f, -0.06625289f, 0.01797715f, 0.11643092f, 0.03111870f, 0.18885781f, 
    0.07057159f, -0.08388352f, 0.04867310f, -0.02027972f, 0.32442841f, -0.03885567f, -0.12658672f, 0.11645158f, 
    0.13800469f, -0.01736144f, 0.10775802f, 0.01874724f, 0.21750747f, 0.02222020f, -0.03778567f, 0.11648124f, 
    0.08391463f, -0.09284648f, 0.01669220f, -0.14619911f, 0.18164986f, -0.03450267f, -0.00708683f, 0.12251683f, 
    0.08184405f, 0.13390933f, 0.19495954f, 0.04981843f, -0.01380686f, -0.20464393f, 0.17648022f, 0.19337559f, 
    0.13386029f, 0.04978538f, 0.03978470f, -0.24534999f, 0.11334721f, -0.05777399f, -0.08580282f, -0.10460487f, 
    0.11046980f, -0.16071403f, -0.13466670f, 0.04087102f, -0.02071136f, 0.15876856f, 0.02590866f, 0.05284619f, 
    0.03727441f, -0.04026576f, -0.11679550f, 0.14063329f, -0.26342666f, 0.22484891f, 0.05430793f, 0.31128293f, 
    -0.17370436f, -0.05515386f, 0.10513557f, -0.22392868f, -0.01374038f, 0.16063333f, -0.12325894f, -0.01917373f, 
    -0.36202449f, -0.00612589f, -0.20641440f, -0.45539123f, -0.08800004f, 0.01951034f, 0.03147624f, 0.02200004f, 
    -0.09272575f, -0.08867830f, -0.08821434f, -0.01086723f, 0.01493593f, 0.03911370f, 0.08390126f, 0.04014705f, 
    -0.02159739f, 0.11257251f, 0.17713138f, 0.03491370f, -0.02493962f, 0.00442642f, -0.07190980f, 0.02412951f, 
    -0.03962246f, 0.21393630f, -0.01507805f, -0.03579406f, -0.11300836f, -0.00993896f, 0.05777325f, 0.11852919f, 
    0.01817671f, 0.28371295f, -0.01241581f, 0.26422659f, 0.00175392f, 0.03009838f, -0.02393983f, -0.02740418f, 
    0.20442384f, 0.30141637f, -0.07555425f, 0.15787472f, -0.01904366f, -0.08844305f, -0.01919242f, 0.03201251f, 
    0.14677826f, 0.21284091f, -0.05401400f, -0.04738105f, -0.01144798f, -0.14522830f, -0.08948015f, 0.07203849f, 
    -0.05196239f, -0.16849382f, -0.12424543f, -0.12485712f, -0.19323729f, -0.00145025f, -0.23226884f, 0.18162671f, 
    -0.15507156f, -0.06832574f, 0.02007411f, -0.02983473f, -0.18877275f, -0.08092078f, -0.21876875f, -0.08431013f, 
    -0.10753500f, -0.07747936f, 0.30099493f, -0.21658443f, 0.00110531f, 0.18332157f, -0.18515506f, -0.11081301f, 
    0.02499413f, 0.02833441f, -0.19770309f, -0.15873091f, -0.00691583f, 0.13954647f, 0.02161407f, -0.12318254f, 
    -0.05094545f, -0.11433896f, -0.22715563f, -0.10837501f, 0.01507350f, 0.11606801f, -0.07682303f, -0.23680662f, 
    0.17085774f, -0.10645362f, 0.07283901f, 0.22161940f, 0.11203253f, 0.13649036f, 0.07199723f, 0.11716136f, 
    0.02993617f, 0.00267188f, -0.09850036f, -0.00942276f, 0.01180681f, 0.20082745f, 0.01900785f, -0.26485080f, 
    -0.04063201f, -0.09629072f, -0.08415367f, -0.18275015f, 0.17358793f, 0.09188221f, 0.11833766f, 0.13643181f, 
    0.17328587f, 0.23610421f, 0.21384214f, 0.20184605f, 0.02988244f, 0.04479982f, 0.07567786f, -0.00093097f, 
    0.11210290f, -0.12528418f, 0.08266914f, -0.01078485f, -0.13185352f, 0.09778064f, 0.25612462f, 0.12383793f, 
    0.04652135f, 0.09043638f, 0.02784950f, 0.21416336f, 0.07240210f, 0.00233848f, 0.18841086f, 0.17913605f, 
    -0.05622354f, 0.12506288f, 0.10937364f, -0.20154360f, -0.21653667f, -0.09016697f, 0.02946496f, -0.06750882f, 
    -0.02915509f, 0.10044661f, 0.15815462f, 0.14716436f, -0.24359387f, 0.16687103f, -0.01368476f, -0.21266460f, 
    -0.04771922f, -0.09652662f, 0.14523813f, 0.09975044f, -0.09211153f, 0.03241891f, 0.08340311f, -0.00253043f, 
    0.02010714f, 0.38334653f, 0.34070447f, 0.03885414f, -0.02919485f, -0.11384958f, -0.08892308f, 0.11382435f, 
    0.12888598f, 0.04790226f, 0.11774161f, -0.11938856f, 0.17783250f, -0.02477909f, -0.01060671f, 0.15567219f, 
    -0.06062037f, 0.11140101f, 0.03602252f, 0.03635456f, 0.04915703f, 0.13470310f, 0.13841350f, 0.12491683f, 
    0.18617378f, 0.13227403f, -0.15222754f, 0.11792918f, 0.08345116f, 0.23511899f, -0.03473335f, -0.15007757f, 
    0.04940441f, 0.11687510f, 0.07331510f, -0.00795678f, 0.18356648f, -0.02163250f, -0.12804630f, -0.04510494f, 
    0.09470984f, 0.10557241f, 0.09832945f, 0.17653248f, 0.07591093f, -0.03684202f, -0.00109545f, -0.03679319f, 
    -0.02579480f, 0.01908633f, -0.18313427f, 0.06289886f, 0.09705450f, 0.16416505f, 0.04354409f, 0.07952842f, 
    -0.09251998f, -0.25192630f, -0.00983722f, -0.05261247f, -0.19988962f, -0.25472906f, -0.20846283f, 0.12386806f, 
    -0.16360506f, -0.03553572f, 0.04688230f, -0.14854102f, 0.07054123f, 0.03250271f, -0.07514348f, 0.04187370f, 
    -0.07171462f, 0.08875360f, 0.11275730f, 0.10491730f, -0.06221822f, 0.05225340f, 0.02532804f, -0.04128628f, 
    0.14173676f, 0.19041911f, 0.09706617f, 0.17996207f, 0.30568960f, -0.10247397f, 0.22790879f, -0.24499731f, 
    -0.05348068f, 0.08762994f, -0.01330067f, -0.02601304f, -0.07526901f, 0.00775262f, 0.11423657f, 0.01458508f, 
    -0.13992368f, -0.19104840f, 0.04371376f, 0.30769628f, 0.11934001f, 0.21850409f, -0.20250089f, -0.04238656f, 
    0.02452617f, -0.03653936f, 0.19090854f, 0.10474577f, 0.14962026f, -0.00145730f, 0.00578035f, 0.12475126f, 
    -0.03776705f, -0.10452280f, -0.02803576f, -0.01671956f, 0.06358166f, 0.04922588f, 0.16789171f, 0.21378843f, 
    -0.29061323f, -0.27735916f, 0.04425891f, 0.11865050f, 0.02144717f, 0.07574424f, -0.07858300f, -0.01726341f, 
    0.04316646f, 0.07131988f, 0.16646414f, 0.07129121f, -0.03664201f, 0.15320733f, 0.13558264f, 0.09212223f, 
    0.02902139f, -0.02975443f, -0.01514620f, 0.11297967f, -0.05826849f, -0.02993153f, 0.08085359f, 0.17000380f, 
    -0.17224374f, -0.20212002f, 0.08761344f, 0.14336774f, -0.08875813f, -0.14618881f, -0.03834702f, 0.06698453f, 
    -0.07180851f, -0.01535258f, 0.00509592f, -0.06372663f, -0.21343054f, 0.08310460f, -0.07278487f, 0.05794050f, 
    -0.02784912f, -0.04827553f, -0.07250602f, 0.06821854f, -0.04324810f, -0.02968258f, 0.01454730f, 0.06183706f, 
    0.06130185f, 0.08662609f, -0.07705585f, -0.06899644f, -0.09679682f, 0.05315992f, -0.04959299f, -0.01253630f, 
    -0.01428619f, -0.03302996f, -0.10203645f, -0.06987057f, -0.07574674f, -0.14924306f, -0.08246321f, 0.22864942f, 
    0.04132938f, 0.07318438f, 0.06283971f, -0.09740798f, -0.02269053f, 0.01396930f, -0.07476719f, -0.05310207f, 
    0.08228702f, -0.10549368f, 0.29980886f, -0.16027646f, 0.10248047f, -0.15811048f, 0.03133329f, 0.12726845f, 
    0.05696135f, -0.00178337f, -0.13706800f, -0.05657213f, -0.11148544f, -0.29551208f, 0.09035358f, 0.41019791f, 
    0.03059356f, 0.12001221f, -0.00096500f, -0.33326885f, 0.12832828f, -0.04564361f, 0.04103069f, 0.00506956f, 
    0.14340620f, 0.02229996f, -0.18537538f, 0.09899514f, 0.12178184f, 0.15039350f, 0.04831440f, 0.12776347f, 
    0.01014574f, 0.05915041f, 0.12610222f, -0.09962046f, 0.05526575f, -0.01420310f, -0.26958692f, 0.03235982f, 
    0.10487514f, 0.04747778f, 0.08033480f, -0.05957467f, 0.01185308f, 0.15888764f, -0.08276844f, -0.05626942f, 
    -0.28295016f, 0.02502919f, 0.14671120f, 0.18402205f, 0.08446632f, 0.01615310f, 0.17304775f, -0.02949695f, 
    0.05874753f, 0.05135168f, -0.19111788f, -0.14974672f, 0.02652621f, 0.07900280f, -0.04499147f, 0.14254889f, 
    0.07327507f, -0.06296460f, 0.12865363f, 0.11341140f, 0.06776092f, 0.07378840f, 0.00867963f, 0.11454454f, 
    0.24331634f, 0.14337738f, 0.23567136f, -0.16838112f, 0.00681107f, -0.07750192f, -0.03129499f, 0.04132105f, 
    -0.05815521f, 0.19361188f, -0.17147326f, 0.02815744f, 0.26167089f, 0.02279599f, -0.25425482f, 0.33039969f, 
    -0.09323920f, 0.02544272f, 0.19279645f, 0.01544019f, 0.02261884f, -0.00673284f, -0.07572655f, -0.10895786f, 
    -0.38336638f, -0.22544286f, 0.34511358f, 0.24775004f, -0.01026710f, 0.02215819f, -0.18944718f, 0.12125704f, 
    0.02300361f, 0.02862484f, -0.10520283f, 0.09238224f, -0.29046988f, 0.12782241f, -0.12339741f, -0.25443336f, 
    -0.02106663f, -0.16448092f, -0.03157272f, -0.01216997f, 0.17057967f, -0.05845971f, 0.12082720f, 0.09585308f, 
    -0.04607428f, 0.06381272f, 0.21804446f, -0.03042974f, -0.04383564f, 0.05234500f, -0.04187742f, 0.09643272f, 
    0.01907121f, 0.03061716f, 0.11025321f, 0.08725758f, -0.05004119f, 0.10458503f, 0.25051555f, 0.39729413f, 
    -0.08682013f, -0.20613798f, -0.14648551f, -0.19281583f, -0.07630207f, -0.04133963f, 0.12839518f, 0.13845344f, 
    0.06746969f, 0.13220514f, 0.18407457f, -0.16101585f, -0.08483064f, 0.01480494f, -0.09284782f, 0.21648034f, 
    -0.03694336f, -0.17911769f, -0.00250579f, -0.07145614f, 0.08666570f, -0.04264930f, 0.06383801f, -0.01542958f, 
    0.16878098f, -0.03051901f, -0.00596991f, 0.06549530f, -0.10163501f, -0.06624997f, -0.01190868f, -0.12969726f, 
    0.05299425f, -0.04027653f, 0.17028338f, 0.15390958f, 0.14841281f, -0.25357813f, -0.09128091f, 0.08070518f, 
    0.09248889f, 0.00216851f, -0.00752314f, -0.02657546f, 0.26586202f, 0.28514156f, 0.16000976f, -0.13294123f, 
    0.07796353f, -0.03808957f, 0.15458404f, -0.18770130f, -0.12450672f, 0.00851511f, -0.11969183f, -0.16007955f, 
    0.02473580f, -0.02824920f, -0.06122386f, -0.01909441f, -0.05769840f, 0.05626836f, -0.07994098f, 0.00540566f, 
    -0.01722589f, 0.05231571f, 0.03462879f, -0.08416079f, -0.02873516f, 0.03577412f, 0.00418853f, -0.01421278f, 
    -0.03106167f, -0.08298329f, 0.01740455f, 0.04091259f, -0.08704416f, 0.03892149f, 0.05271504f, -0.00596198f, 
    -0.06546061f, 0.03267977f, -0.00510085f, -0.00329316f, -0.00986838f, 0.04374147f, 0.02933666f, -0.03203291f, 
    -0.03751019f, 0.02410729f, 0.02517972f, -0.06177558f, 0.01272060f, -0.05955609f, -0.07539594f, -0.00042348f, 
    -0.04678719f, -0.03814258f, 0.02427603f, -0.08284095f, -0.06372443f, 0.01355710f, -0.06004481f, -0.04720805f, 
    0.01023951f, 0.03969577f, -0.06840582f, -0.07724433f, 0.02093532f, 0.03607395f, 0.01443975f, -0.00425742f, 
    -0.08638113f, 0.00361683f, -0.00156024f, 0.03034956f, 0.03951743f, -0.05678823f, -0.07500752f, 0.00480354f, 
    -0.04500240f, 0.06284400f, -0.05817620f, 0.01438435f, 0.00181605f, -0.06867611f, -0.07249920f, 0.04255966f, 
    0.02947044f, -0.05081870f, -0.00876441f, 0.03857960f, 0.01034314f, 0.05140044f, -0.06190574f, -0.03195234f, 
    -0.00301850f, -0.03831070f, -0.05634711f, -0.04872107f, 0.04102248f, -0.00768389f, 0.04112285f, -0.02949541f, 
    -0.03548870f, 0.03431121f, -0.07163491f, 0.01368111f, -0.03606355f, -0.05455656f, 0.01945032f, -0.01543742f, 
    -0.09578989f, -0.00018694f, -0.05350631f, -0.03079775f, 0.03610222f, -0.06491895f, -0.08249597f, -0.02195978f, 
    -0.04522428f, 0.00416675f, -0.06280277f, -0.04995461f, 0.03033224f, 0.02094443f, 0.04815163f, -0.04811800f, 
    -0.02124826f, -0.07011230f, -0.01834816f, -0.05012654f, 0.00562193f, 0.06814858f, 0.02759131f, 0.03858737f, 
    0.00227176f, -0.03828834f, 0.00801598f, -0.05797331f, 0.02757348f, 0.05152533f, -0.01341213f, -0.01992435f, 
    -0.00199455f, -0.03655175f, -0.01821196f, -0.03566248f, -0.03941312f, 0.03954452f, -0.01266352f, -0.03096651f, 
    0.03412508f, -0.00411281f, 0.01820188f, -0.06172388f, 0.03087577f, -0.07460234f, -0.02546321f, -0.00155646f, 
    -0.03752189f, 0.01316351f, 0.02443524f, 0.04332588f, 0.05521851f, -0.03794714f, -0.02116893f, -0.04229960f, 
    -0.02839889f, 0.00032557f, 0.03882724f, -0.04034433f, 0.01772845f, -0.03009081f, -0.04502305f, 0.01571416f, 
    0.02991201f, -0.07526965f, 0.02950681f, 0.03672674f, 0.03831246f, -0.06226438f, -0.03419281f, -0.03322295f, 
    -0.02761140f, 0.00443187f, 0.01068088f, -0.02071164f, 0.01997605f, -0.07186973f, 0.00705768f, -0.01398039f, 
    0.04797943f, 0.02063265f, 0.01667792f, -0.02765154f, 0.00224813f, 0.00283595f, 0.04659113f, -0.01665964f, 
    -0.06159952f, -0.03700618f, -0.03946086f, -0.07598185f, 0.04455538f, -0.02763630f, 0.04993758f, -0.02856496f, 
    0.07412893f, 0.10309637f, 0.07819649f, -0.18040113f, -0.06003194f, 0.07725360f, 0.12192005f, 0.15443246f, 
    0.00928014f, 0.03313351f, 0.19198544f, 0.08450148f, 0.02926845f, 0.01898310f, -0.15936509f, 0.12213301f, 
    0.10118750f, -0.10084537f, -0.02679591f, 0.06781615f, 0.07434288f, 0.18493652f, 0.13655020f, 0.06616467f, 
    0.03110681f, 0.41909570f, -0.13303354f, -0.10795687f, 0.09055360f, -0.24669589f, 0.12414805f, -0.00785001f, 
    0.14587857f, -0.04243386f, 0.07791728f, -0.06432629f, 0.12580657f, -0.07015652f, 0.11795777f, 0.08903217f, 
    0.02960080f, 0.05220649f, -0.08224425f, 0.02991196f, -0.01346763f, -0.04055117f, 0.07120405f, 0.08359330f, 
    0.01706289f, -0.03509641f, -0.11503407f, 0.05563940f, 0.22451633f, 0.11343123f, 0.05557386f, -0.01241548f, 
    -0.07841073f, -0.03249222f, 0.20163506f, 0.04398289f, -0.01182794f, 0.01230223f, 0.05855509f, -0.14061378f, 
    -0.04470501f, -0.00709781f, -0.05875538f, 0.02642733f, 0.02049375f, -0.03374118f, 0.03535106f, -0.09210248f, 
    -0.13223152f, -0.14424494f, -0.09780667f, 0.11842560f, 0.07056116f, 0.06134321f, -0.04878406f, -0.10488315f, 
    0.06866561f, -0.06231739f, 0.14289629f, 0.06702483f, 0.39000040f, -0.05993610f, 0.58499485f, -0.25620362f, 
    -0.16157380f, -0.19872530f, -0.06343393f, -0.03223598f, -0.05137495f, 0.17409006f, 0.09119686f, 0.06193033f, 
    0.02918759f, -0.07673802f, -0.23021387f, 0.34231415f, 0.09072673f, 0.04569172f, 0.03013211f, 0.05831188f, 
    0.20292850f, -0.03141985f, 0.01717865f, 0.08832435f, 0.15012294f, 0.25089779f, 0.29217726f, 0.10533668f, 
    -0.06584582f, -0.07601444f, -0.06136465f, -0.04124349f, -0.07333494f, 0.00657096f, -0.04807673f, -0.13402793f, 
    -0.21713227f, -0.02999772f, -0.10222470f, 0.16499341f, 0.13567860f, -0.00477536f, 0.06411369f, 0.01246476f, 
    0.08103608f, 0.12001767f, -0.02866624f, -0.02792997f, -0.26073834f, -0.08059780f, 0.08710726f, 0.20721553f, 
    -0.01393109f, -0.06263337f, -0.01600488f, -0.03518352f, -0.08348640f, -0.05904237f, -0.09560347f, 0.02814428f, 
    -0.12749954f, -0.29584047f, -0.01536969f, 0.04173483f, 0.03645856f, -0.21202873f, 0.02997302f, 0.04797602f, 
    0.02258877f, -0.16332529f, -0.04891142f, -0.01416572f, -0.05882677f, 0.17763217f, -0.04955860f, 0.08917964f, 
    -0.10073952f, -0.16840728f, 0.01143091f, -0.07340804f, 0.07757896f, 0.01738396f, 0.06727443f, 0.00903133f, 
    0.25020000f, 0.18223594f, 0.06595460f, 0.20473769f, -0.19770047f, 0.09946477f, -0.04614009f, 0.00112825f, 
    0.05972917f, -0.03119199f, -0.05559465f, -0.09861251f, 0.00476440f, -0.02356539f, -0.23981798f, -0.08715300f, 
    -0.12215237f, 0.13572642f, -0.20368606f, 0.16112596f, -0.25098211f, -0.00934102f, -0.18531080f, 0.03627388f, 
    0.33695734f, 0.21077468f, -0.10026805f, -0.32643718f, -0.02159416f, 0.16708338f, -0.07248420f, -0.03966696f, 
    0.15416695f, 0.15053305f, 0.21822579f, 0.18226919f, -0.02106032f, 0.17419401f, -0.04979021f, 0.02638833f, 
    0.08017367f, 0.01736142f, 0.13885659f, -0.05259694f, 0.10781152f, 0.16027728f, -0.05873174f, -0.03701948f, 
    -0.21370043f, 0.15937456f, -0.17731550f, -0.14911719f, -0.11396475f, -0.09228713f, 0.01516345f, 0.08906532f, 
    -0.10886502f, 0.06327484f, 0.05956303f, 0.02437136f, -0.08066174f, 0.14997718f, 0.12827615f, -0.09926230f, 
    0.09541263f, 0.06416667f, 0.12846190f, -0.00260220f, 0.06125282f, 0.06691793f, 0.20480254f, -0.08134846f, 
    -0.00920424f, -0.00295513f, -0.07075658f, 0.07031889f, -0.06500331f, -0.06379508f, 0.14862271f, 0.22447819f, 
    -0.09114039f, 0.13032642f, 0.15978727f, 0.16925196f, -0.12049218f, 0.01642131f, 0.01242689f, -0.31947926f, 
    0.15296316f, 0.10721233f, -0.16697331f, 0.07547469f, 0.05315769f, 0.00009212f, -0.09351353f, -0.04967544f, 
    -0.10833725f, 0.03450601f, -0.12566751f, -0.10093258f, -0.00787902f, 0.04532618f, 0.01528131f, -0.03293663f, 
    0.02386038f, -0.18477222f, 0.08363485f, -0.03216788f, 0.10538538f, -0.01268991f, 0.02139974f, -0.15208863f, 
    -0.10714532f, -0.12493239f, -0.04991738f, -0.05542252f, -0.03171222f, 0.10216819f, -0.00713491f, -0.03461683f, 
    -0.02029110f, -0.28569973f, 0.02441079f, 0.02972646f, 0.05197936f, -0.01076662f, -0.15965214f, -0.00831582f, 
    0.25624150f, -0.11856109f, -0.00844305f, -0.14069358f, 0.05913209f, 0.13789292f, 0.24595685f, 0.10286721f, 
    0.01372809f, -0.00478908f, -0.18045337f, -0.10156895f, -0.07431155f, 0.03889289f, -0.04926656f, -0.22452775f, 
    0.00954922f, 0.00980384f, -0.00922763f, 0.05819135f, 0.09553859f, -0.03666191f, 0.19055565f, 0.12977937f, 
    0.07001804f, 0.07605229f, -0.19363181f, -0.05182233f, -0.04552649f, -0.02008764f, 0.30056760f, -0.00612884f, 
    -0.12321004f, 0.03223779f, -0.09589995f, -0.01152400f, -0.03891734f, 0.01312332f, -0.07213493f, -0.01580378f, 
    -0.10518269f, -0.19220600f, 0.25559789f, 0.14770879f, 0.10595928f, 0.03095409f, 0.03853370f, -0.22739345f, 
    -0.00411785f, -0.08846954f, -0.01192803f, 0.06398498f, -0.29604286f, 0.03267995f, 0.03756993f, 0.04706990f, 
    -0.01775286f, -0.04456511f, 0.15022030f, -0.18412107f, 0.01340279f, 0.03907433f, 0.02560249f, 0.00747513f, 
    0.18848825f, 0.25396654f, 0.12765060f, 0.19091740f, -0.22993053f, -0.02713743f, 0.04569447f, -0.11548782f, 
    0.02562327f, 0.11838773f, -0.05944530f, 0.02370608f, -0.24565516f, -0.05948055f, -0.05233676f, -0.08795019f, 
    -0.22902676f, 0.04732778f, -0.38580024f, 0.13932185f, -0.06307953f, -0.03815443f, -0.03054974f, 0.06059116f, 
    -0.01524925f, 0.03200922f, -0.07993890f, -0.06175409f, 0.01312196f, 0.00774048f, -0.00921050f, 0.04822417f, 
    0.04961960f, 0.01781894f, 0.00789815f, 0.00078855f, -0.00723888f, -0.02582481f, -0.08386536f, -0.02547674f, 
    0.04963612f, 0.03097817f, -0.06623624f, 0.02961481f, -0.04188054f, 0.01615964f, -0.02211577f, -0.02964319f, 
    -0.02330496f, -0.03353973f, -0.06011594f, 0.02010743f, 0.04435240f, -0.01581533f, 0.04261043f, -0.01602770f, 
    -0.07199284f, -0.01720855f, 0.05351695f, 0.04699696f, -0.00082936f, 0.01133944f, 0.02389476f, -0.00749506f, 
    -0.01909508f, -0.05649151f, -0.08066189f, -0.02363388f, 0.01422413f, -0.04868690f, -0.04575299f, 0.05389491f, 
    0.01880848f, 0.04455629f, -0.01713159f, -0.06078800f, -0.04528359f, -0.07302510f, -0.05507857f, 0.03023163f, 
    0.00458872f, 0.05252608f, -0.00074637f, -0.04221826f, -0.04397773f, 0.04199937f, 0.00165974f, 0.00918960f, 
    -0.00941062f, -0.03390727f, 0.02573053f, -0.00737048f, 0.03494550f, -0.02081312f, -0.01972408f, 0.01577762f, 
    -0.06515172f, 0.07326270f, -0.03342222f, -0.03959249f, 0.01588699f, 0.05314555f, -0.03471861f, 0.01917802f, 
    0.00638409f, -0.01433116f, 0.02027454f, -0.04153347f, -0.08419709f, -0.06567553f, 0.02088817f, -0.07088146f, 
    -0.05191229f, 0.04546042f, 0.02009206f, -0.01442409f, 0.00562776f, -0.08001884f, -0.03474464f, 0.04339698f, 
    -0.05155741f, -0.04047348f, -0.00005082f, -0.05220690f, -0.02630252f, 0.04345639f, 0.01788004f, 0.03759618f, 
    -0.05259832f, -0.03494767f, 0.04555034f, -0.02023725f, 0.03654592f, -0.06010880f, -0.05086080f, -0.05515436f, 
    0.01028008f, 0.04512279f, -0.07197727f, -0.00349070f, -0.03628002f, 0.03246126f, -0.02991680f, -0.01737208f, 
    0.00576648f, -0.01114433f, -0.02556635f, 0.05476114f, -0.01022892f, 0.03894758f, 0.04133706f, -0.01219122f, 
    0.02890937f, -0.08216305f, -0.08211701f, -0.03648218f, 0.01079120f, 0.00278277f, -0.00635874f, 0.04122868f, 
    0.01055162f, -0.07374567f, -0.00487599f, 0.03926860f, 0.00720353f, -0.01974483f, -0.02532634f, -0.05681684f, 
    -0.00804633f, 0.07588191f, -0.01729329f, -0.05585642f, -0.07023651f, -0.02130374f, -0.06230731f, 0.02034429f, 
    0.02732101f, -0.07242464f, -0.04919204f, -0.02138565f, 0.04592184f, -0.03566651f, 0.04391498f, -0.07915635f, 
    0.05507533f, -0.08306473f, -0.02413198f, -0.03838840f, 0.01679226f, -0.01952673f, 0.03723089f, 0.00520650f, 
    -0.00105031f, 0.00292824f, -0.07520010f, -0.06156802f, 0.02286673f, 0.00090459f, 0.04816749f, 0.04980262f, 
    0.01102751f, -0.00129208f, 0.01969190f, 0.00337821f, -0.01011028f, 0.04193299f, 0.05172058f, 0.06096435f, 
    -0.05503774f, -0.01352925f, 0.00036882f, -0.05808054f, -0.03784432f, -0.05997446f, -0.07174728f, -0.02259262f, 
    0.02726887f, -0.00688015f, -0.06956026f, 0.03419343f, 0.00002620f, -0.05583855f, 0.00450844f, 0.01131667f, 
    -0.02249446f, 0.05677484f, -0.01913205f, -0.02236851f, -0.07571636f, -0.07124740f, 0.04739906f, 0.00721975f, 
    -0.01095885f, -0.07471015f, 0.01662613f, -0.02391185f, 0.01271419f, 0.05662469f, -0.02158934f, 0.06427035f, 
    0.01141152f, 0.04531599f, -0.07687304f, 0.05736832f, -0.04348634f, -0.04839705f, -0.06618545f, 0.00272376f, 
    0.06442210f, -0.02357057f, -0.07658939f, -0.02866262f, -0.06145487f, -0.05663721f, -0.04373053f, -0.02749335f, 
    -0.00083012f, -0.05110379f, -0.00552191f, 0.01323236f, -0.04780935f, -0.01317320f, 0.04458337f, 0.03396934f, 
    0.06168975f, -0.05158574f, 0.05413385f, -0.02942959f, -0.05640274f, -0.05192598f, -0.00779254f, -0.03996377f, 
    -0.04837297f, -0.06192765f, -0.05148049f, -0.01206001f, 0.00439473f, -0.02637722f, 0.03406840f, 0.02982223f, 
    -0.02611507f, -0.00729483f, 0.02115360f, 0.03909206f, 0.00738095f, -0.06258204f, 0.04060029f, 0.01413822f, 
    -0.03176959f, -0.00683965f, 0.03961495f, 0.01888529f, 0.05499110f, -0.01831375f, -0.06957836f, 0.01085752f, 
    0.00053701f, -0.07132410f, -0.06641547f, 0.00288493f, -0.03236698f, -0.04574924f, 0.01858296f, -0.00766743f, 
    0.01490495f, 0.06160292f, 0.00014669f, 0.04616072f, 0.06664729f, -0.04612592f, -0.03000659f, 0.00419260f, 
    -0.03591641f, 0.01245790f, 0.04554463f, -0.03569334f, 0.03656091f, -0.00907218f, 0.00761794f, 0.00013765f, 
    0.02846785f, 0.04792837f, 0.02715380f, 0.03597620f, 0.05163692f, 0.05548207f, -0.06010384f, -0.01988340f, 
    -0.02765466f, 0.05058224f, 0.06119631f, -0.03146480f, -0.03669566f, -0.00914811f, -0.05320580f, 0.04304598f, 
    -0.04491962f, 0.01103038f, 0.01255269f, -0.04556861f, -0.06795222f, -0.06394678f, -0.07592545f, -0.01506287f, 
    0.02582088f, -0.02478811f, 0.00628165f, 0.00814587f, 0.00946859f, -0.04507772f, -0.06665704f, 0.05590316f, 
    -0.03887566f, 0.01872483f, 0.05188793f, -0.02900506f, 0.00297225f, -0.07118664f, -0.06254978f, -0.02956519f, 
    -0.04846797f, 0.00054839f, -0.05469034f, -0.07441887f, 0.01622853f, -0.01108951f, -0.00094374f, 0.01014280f, 
    -0.06614627f, -0.04994934f, -0.04210822f, 0.06397894f, 0.05552160f, -0.04165391f, -0.07055030f, 0.01409960f, 
    -0.02999271f, -0.05006431f, -0.03488161f, 0.04446631f, -0.07449684f, 0.04680230f, 0.03178405f, 0.05081682f, 
    -0.02457960f, 0.06441327f, -0.02230311f, 0.03638370f, 0.00145293f, -0.01611216f, 0.00186123f, -0.03870885f, 
    -0.01657059f, 0.05545346f, -0.05539290f, -0.04667696f, 0.04873602f, 0.01936678f, 0.06480651f, 0.03611215f, 
    -0.05038214f, -0.01070878f, 0.04666935f, 0.00329038f, -0.05162457f, -0.04551466f, -0.01963045f, 0.00359238f, 
    0.13014960f, 0.05870211f, 0.26956493f, -0.04939090f, -0.05389751f, -0.17812207f, -0.11997834f, -0.08501200f, 
    0.11562808f, -0.08178379f, -0.03782833f, -0.00733747f, 0.17484936f, -0.13914236f, 0.04534540f, -0.05789276f, 
    -0.18816194f, -0.00822239f, 0.01273754f, -0.21809149f, 0.15240867f, 0.13551331f, -0.00203595f, 0.17234387f, 
    -0.05703456f, 0.06353795f, -0.02988969f, 0.06674074f, -0.05482781f, 0.16120191f, 0.02562957f, -0.23381722f, 
    -0.03439987f, -0.01780084f, 0.04844376f, 0.07541782f, -0.41313729f, -0.01862068f, -0.15979572f, -0.27310589f, 
    -0.00233445f, 0.07735328f, 0.05338010f, -0.03894692f, 0.05672713f, 0.00061646f, -0.04122717f, -0.32208249f, 
    0.02140346f, -0.03422952f, -0.08332006f, -0.11015601f, 0.01793076f, 0.18294972f, -0.09200177f, -0.00688022f, 
    -0.29293206f, -0.48359141f, -0.04738058f, -0.36383584f, -0.05125435f, -0.00240209f, -0.11288074f, 0.12533392f, 
    -0.10420008f, 0.08458094f, 0.00177176f, 0.08451781f, 0.06757897f, 0.12328794f, 0.07204778f, 0.07182386f, 
    -0.16716589f, 0.13844620f, 0.25166181f, 0.07906987f, 0.06654508f, 0.16417526f, 0.21641137f, 0.06540097f, 
    0.10170808f, 0.10410163f, 0.11359693f, 0.17744671f, 0.08783978f, 0.21835135f, -0.07031234f, 0.21952336f, 
    0.01336707f, 0.01763917f, -0.01351328f, -0.01310602f, -0.06187448f, 0.03617326f, 0.03546249f, -0.04021744f, 
    0.13459174f, -0.21844080f, -0.03591770f, 0.04106864f, -0.12378012f, 0.16720185f, -0.28586221f, 0.08371645f, 
    0.03228782f, 0.09320442f, 0.06486092f, 0.07805590f, 0.13206367f, -0.18419331f, 0.02354155f, 0.05875572f, 
    0.05131331f, 0.00305842f, -0.14081176f, -0.16853535f, 0.09912382f, 0.05534250f, 0.12883502f, 0.34502870f, 
    -0.12053378f, -0.12210883f, 0.08372456f, 0.11493485f, 0.01077982f, 0.15368018f, -0.03986602f, 0.13358897f, 
    0.20031941f, 0.00621735f, 0.17803867f, 0.22973931f, 0.52158678f, 0.35645244f, 0.20940976f, 0.01910564f, 
    -0.19995828f, -0.04850966f, -0.15611745f, -0.30820557f, 0.04550816f, -0.09304229f, 0.02311546f, 0.08124211f, 
    -0.05735732f, 0.02544191f, 0.15829322f, 0.19020534f, -0.10630406f, -0.01850202f, 0.04045830f, 0.19293638f, 
    0.03266248f, 0.06296148f, 0.04266329f, -0.12347698f, -0.05288985f, 0.08191751f, -0.09189724f, 0.19747576f, 
    0.05839761f, 0.05952327f, 0.08799952f, 0.08621992f, -0.12563336f, -0.02789295f, -0.07264908f, -0.11766071f, 
    0.04198661f, 0.04197312f, -0.18254496f, -0.05070210f, -0.06271843f, -0.09599882f, -0.14604184f, -0.34290007f, 
    -0.07634183f, -0.07399848f, -0.05569166f, 0.04638147f, 0.03093628f, 0.01439625f, 0.14718077f, 0.29781762f, 
    0.07065101f, 0.01609297f, 0.10376622f, 0.17645380f, 0.03192684f, 0.07460324f, -0.13786586f, -0.05686785f, 
    0.07223430f, 0.08037302f, 0.19984597f, -0.07346471f, 0.06504154f, 0.08867223f, -0.08483244f, 0.13436177f, 
    0.05841324f, 0.01486682f, 0.07867289f, 0.06338263f, -0.03193817f, 0.09791721f, -0.09978116f, 0.39884239f, 
    0.10304404f, -0.00262455f, 0.19040988f, 0.02598290f, -0.01491214f, 0.11525575f, -0.09505994f, 0.01274799f, 
    0.04903093f, 0.31413868f, -0.29491588f, -0.09321824f, 0.02349965f, -0.00984892f, 0.07059224f, 0.04548945f, 
    -0.04062677f, -0.01176863f, 0.08779407f, -0.19758509f, 0.12796009f, -0.00342459f, 0.09082734f, 0.12352556f, 
    -0.01594430f, -0.00714302f, 0.20533377f, 0.07423397f, 0.07226633f, 0.03506095f, -0.04802092f, 0.13388877f, 
    -0.16063254f, 0.10612090f, -0.06924128f, 0.05323894f, -0.07366830f, -0.04333740f, 0.13441272f, -0.06611709f, 
    0.04726646f, 0.16514872f, 0.08243898f, 0.17549440f, -0.05872140f, 0.01619537f, -0.10021822f, -0.07248631f, 
    0.04503438f, 0.04764763f, -0.01244963f, -0.04943419f, -0.04514461f, 0.02388345f, 0.04028739f, -0.05386903f, 
    -0.06852136f, 0.15773562f, -0.06540789f, -0.00231536f, 0.02576568f, -0.08442353f, -0.04659656f, -0.06396722f, 
    0.01031913f, -0.03298519f, -0.25550136f, 0.00149333f, 0.23003121f, -0.08771568f, 0.17892797f, 0.02535927f, 
    -0.13751690f, -0.09865277f, 0.14617376f, 0.01432756f, -0.07304271f, 0.10675400f, -0.18019271f, 0.00076629f, 
    -0.21251044f, -0.03908160f, 0.23940118f, 0.13372798f, -0.00967470f, 0.18325235f, 0.07153540f, -0.05070378f, 
    0.00226384f, -0.06810190f, -0.03774777f, 0.06933756f, -0.17107201f, 0.28870803f, -0.07533570f, -0.14691651f, 
    -0.00261987f, -0.09960435f, -0.14829537f, 0.00036680f, -0.10398813f, -0.02685406f, 0.08915135f, -0.24334344f, 
    0.03436927f, -0.24267027f, -0.00945134f, 0.04214707f, -0.00665488f, 0.19836864f, 0.01634203f, 0.07319671f, 
    0.00830189f, -0.00405183f, -0.10274842f, 0.00829550f, -0.39882630f, 0.12457457f, 0.05886332f, 0.15908369f, 
    -0.04936796f, 0.00222520f, -0.04486076f, 0.07891674f, -0.00205420f, -0.06543873f, 0.06420514f, 0.10212711f, 
    -0.06710147f, -0.03717878f, 0.00118470f, 0.16329812f, 0.00537286f, -0.03177947f, -0.07566877f, -0.03937849f, 
    0.07934573f, 0.07165664f, 0.17083162f, 0.05934320f, -0.09158925f, 0.03085174f, 0.18319021f, -0.06333380f, 
    -0.05118810f, 0.02410549f, 0.01177903f, 0.15319885f, -0.01179489f, 0.05840693f, 0.31804445f, 0.12230062f, 
    0.10029134f, 0.18585899f, 0.21053040f, -0.04464699f, -0.01736139f, 0.01930861f, 0.07621497f, 0.15948583f, 
    0.04358269f, 0.07797395f, 0.01646491f, -0.06866946f, -0.20851886f, 0.18514967f, -0.18553723f, -0.21718933f, 
    -0.12885042f, -0.09495877f, 0.11611913f, -0.15373677f, -0.19072366f, 0.09181836f, 0.07439234f, 0.00959519f, 
    0.09231176f, -0.18267760f, 0.01370810f, -0.18243074f, -0.02416351f, 0.12406708f, 0.16473934f, 0.16202365f, 
    0.07374088f, 0.08166257f, -0.07963452f, -0.02267168f, -0.10698039f, 0.22151844f, -0.13581838f, 0.23630683f, 
    0.02936262f, 0.06584530f, 0.09253325f, -0.06030784f, -0.02327462f, 0.17320259f, 0.02385152f, 0.09141897f, 
    -0.09956449f, 0.24982233f, -0.11005744f, -0.16964309f, 0.08958054f, -0.03615867f, 0.06462086f, 0.11568832f, 
    -0.02300687f, -0.04370308f, -0.06557345f, -0.14285344f, -0.00193950f, 0.07765881f, 0.10606822f, 0.06082692f, 
    -0.00637525f, -0.02063547f, 0.18363410f, -0.00276879f, -0.03550164f, 0.04636337f, 0.06830008f, 0.18685791f, 
    -0.09798852f, 0.10346381f, -0.00540612f, 0.03161570f, 0.08761930f, -0.09720445f, 0.05625720f, 0.08260336f, 
    -0.04917990f, 0.15182666f, 0.15962403f, 0.18505430f, -0.05814571f, 0.02684620f, 0.05306334f, 0.01316468f, 
    0.24247161f, 0.06458982f, -0.02672614f, 0.10855272f, -0.05796368f, -0.07727490f, 0.02445034f, -0.04760183f, 
    -0.14673699f, -0.02714403f, -0.03807462f, -0.08094004f, 0.11964250f, -0.00311074f, -0.22430651f, -0.03875584f, 
    -0.15063670f, -0.20896521f, -0.16922633f, -0.23668995f, 0.14017259f, 0.08778715f, 0.21755230f, 0.09513900f, 
    -0.10323967f, -0.10169455f, -0.08478294f, -0.06505158f, -0.09242368f, -0.03919862f, -0.00651710f, 0.00776989f, 
    -0.18785173f, 0.04609190f, 0.17796645f, -0.07825238f, -0.04121354f, -0.00424039f, -0.02100742f, -0.06277299f, 
    0.01689046f, -0.15390034f, -0.03880366f, -0.06289316f, -0.17596349f, 0.12603165f, 0.05208413f, 0.03526262f, 
    -0.05272971f, -0.15277903f, -0.12804136f, -0.06810452f, -0.06282762f, -0.12780023f, -0.03725316f, -0.24593373f, 
    -0.01730539f, -0.10521315f, 0.06135749f, 0.10081598f, 0.06239030f, -0.06260294f, 0.18832038f, 0.22110559f, 
    0.07730916f, 0.13545521f, -0.10399026f, -0.11652260f, -0.18047586f, -0.11669475f, 0.06555986f, 0.00730506f, 
    -0.08489307f, 0.01839385f, 0.01378502f, -0.09932265f, 0.08751344f, -0.00487379f, 0.03357916f, 0.18521531f, 
    0.00946155f, -0.12723418f, 0.17300256f, 0.08886679f, -0.05792793f, 0.11142372f, 0.02088387f, 0.09335425f, 
    0.01866112f, -0.03771827f, -0.00957073f, 0.03580590f, 0.06548563f, 0.06556931f, 0.10228787f, 0.20017266f, 
    -0.05613608f, 0.04911320f, 0.00226057f, 0.09102139f, 0.05076459f, 0.01696396f, 0.25359008f, 0.21916828f, 
    0.08840628f, 0.23494796f, 0.10843059f, 0.07186455f, -0.10440944f, 0.04878372f, 0.05121980f, 0.07679096f, 
    0.12485708f, 0.12255137f, 0.01673059f, 0.13904113f, -0.16554017f, 0.09636782f, 0.05700681f, -0.17993584f, 
    -0.10947333f, -0.01039492f, -0.06450190f, 0.02156349f, -0.06180101f, 0.06353234f, 0.00051409f, -0.01035775f, 
    0.06701005f, 0.14730264f, -0.07653076f, -0.09515826f, 0.05416935f, 0.08969182f, 0.04681762f, 0.03444145f, 
    0.11193886f, 0.10245036f, 0.00833894f, -0.05502462f, 0.17017555f, 0.00226962f, -0.08715080f, -0.20654124f, 
    0.08844974f, 0.04884802f, -0.09339033f, 0.18844600f, 0.15744099f, 0.21848156f, 0.23699278f, -0.04721823f, 
    0.03796168f, 0.06228963f, -0.03428081f, 0.06139342f, 0.06574290f, -0.00249171f, 0.10505319f, -0.03653163f, 
    -0.01197219f, 0.03062207f, -0.01598351f, -0.02820251f, 0.23696028f, -0.01860707f, 0.12101312f, -0.08827810f, 
    0.08111335f, -0.06118644f, -0.02896331f, 0.02505980f, 0.03472706f, -0.02206256f, 0.18996221f, 0.13175865f, 
    -0.06499242f, -0.21175562f, -0.15373221f, 0.05558772f, 0.09661041f, -0.04587628f, -0.08860792f, 0.04243227f, 
    -0.13975947f, 0.08538608f, 0.02034777f, 0.00792196f, 0.02048565f, -0.05506179f, -0.00855722f, 0.07136369f, 
    0.12610877f, -0.01945327f, 0.11937167f, -0.02470544f, -0.04379463f, 0.03214355f, -0.07328222f, -0.00726258f, 
    0.11851241f, -0.08536619f, -0.11311797f, 0.03321218f, -0.03826546f, 0.14773211f, -0.02143229f, 0.01842730f, 
    0.09039623f, -0.01752135f, 0.03132756f, -0.11576241f, 0.36054999f, -0.02671602f, 0.22340296f, -0.43502295f, 
    0.02900094f, -0.03123598f, -0.05033107f, -0.05050831f, -0.11947620f, 0.01836704f, 0.03295933f, 0.02834197f, 
    -0.16868149f, -0.04307240f, -0.01760678f, 0.11357454f, -0.00273748f, -0.00748406f, 0.21804236f, 0.05484236f, 
    0.07036179f, -0.06489259f, 0.08167250f, 0.01985329f, -0.13518861f, 0.01951497f, 0.02992574f, 0.03182531f, 
    -0.05269117f, 0.11395431f, 0.07614078f, 0.01562559f, -0.06454343f, -0.08308564f, 0.08284111f, -0.11317817f, 
    -0.06110411f, -0.01746849f, 0.01987579f, -0.04071496f, -0.07561933f, -0.13022323f, 0.01823383f, -0.07435862f, 
    0.02186018f, 0.13424449f, 0.05669761f, -0.12067665f, -0.43405077f, -0.35337862f, -0.01432108f, 0.03396633f, 
    -0.02403082f, -0.03561753f, 0.01074810f, 0.10164380f, 0.06470723f, 0.00778477f, 0.04291455f, 0.00965886f, 
    -0.22304657f, -0.25325856f, 0.14193992f, 0.09019490f, 0.08030260f, 0.02271580f, -0.01656441f, 0.03155733f, 
    -0.04555739f, 0.07175323f, -0.10292905f, 0.17091143f, -0.02848485f, 0.03903921f, 0.03558321f, 0.00998400f, 
    -0.02247533f, 0.08955782f, 0.06618798f, -0.00244409f, 0.03833849f, -0.05424108f, 0.01981734f, 0.16196738f, 
    0.18618248f, 0.15596703f, 0.10262960f, 0.03889348f, -0.07877142f, -0.00965666f, 0.01992230f, 0.03416030f, 
    -0.05977597f, 0.13406093f, 0.00735071f, 0.03565141f, -0.09843045f, -0.20801616f, 0.12419364f, 0.14437681f, 
    0.03809970f, 0.11952262f, -0.03489251f, -0.13857770f, 0.07833946f, -0.11507628f, -0.02291193f, 0.07314919f, 
    -0.25357845f, -0.08589189f, 0.08088053f, -0.21435642f, 0.12875007f, -0.04376845f, 0.01469577f, 0.08325633f, 
    0.02790084f, 0.07896326f, 0.03822647f, -0.00322918f, 0.06198313f, 0.04581335f, 0.27429515f, -0.12420882f, 
    -0.06632930f, 0.00707735f, -0.04671847f, -0.12305852f, 0.13990591f, 0.00691827f, 0.03336895f, -0.09137426f, 
    0.44598499f, -0.16536376f, 0.01575028f, 0.13790365f, -0.05970548f, 0.26484680f, 0.13324127f, 0.08650462f, 
    -0.06203791f, 0.26199046f, -0.02170436f, -0.03159501f, 0.15550488f, 0.08369409f, -0.18147950f, -0.08931278f, 
    0.01008105f, -0.15821171f, 0.03816469f, -0.09983221f, 0.03297193f, 0.12976483f, 0.08967545f, 0.01423301f, 
    0.03650517f, -0.05767039f, -0.04613920f, 0.01287520f, 0.04741767f, -0.06200110f, -0.02419520f, -0.03066543f, 
    -0.06076973f, 0.27154052f, -0.11864106f, 0.01426056f, -0.01114004f, -0.17227411f, 0.00024001f, 0.25026527f, 
    0.04735977f, 0.06541987f, 0.08378425f, 0.02914784f, -0.05117138f, -0.00263227f, 0.06360064f, 0.12581085f, 
    -0.03824550f, -0.08807938f, 0.00511719f, -0.02486050f, -0.06899449f, 0.02938921f, -0.12576944f, 0.08731511f, 
    -0.08688719f, -0.05890549f, -0.03668144f, -0.20395790f, 0.20218809f, 0.31076348f, -0.24204686f, 0.03579767f, 
    0.04344882f, 0.11244523f, 0.03821798f, 0.06332491f, -0.00252798f, 0.02963785f, -0.09113839f, -0.03354025f, 
    -0.16632980f, 0.18269628f, -0.05074862f, -0.20558333f, 0.11593147f, -0.13547359f, 0.06699539f, 0.11458705f, 
    -0.10002293f, -0.06720744f, -0.01313729f, -0.01985981f, -0.05090539f, -0.15287685f, -0.24601157f, -0.13988517f, 
    0.05481568f, -0.14741734f, 0.01949558f, 0.02452583f, -0.05688579f, -0.12917551f, 0.05434554f, -0.08843748f, 
    -0.06407285f, 0.16998394f, -0.02985548f, -0.05327182f, -0.04958152f, -0.02005318f, -0.01320977f, 0.07833455f, 
    0.04227074f, 0.13817228f, 0.10990002f, -0.05797724f, 0.07957747f, 0.13363345f, 0.09669776f, -0.04949557f, 
    -0.00987768f, -0.05816662f, -0.08549714f, -0.12597252f, 0.01737558f, -0.02472471f, 0.23512314f, 0.08558195f, 
    -0.20822875f, -0.04717063f, 0.08448309f, -0.13024777f, -0.00461552f, 0.15296055f, -0.02461313f, 0.09444430f, 
    -0.07974590f, 0.05123352f, -0.00018209f, 0.21661958f, 0.14336652f, -0.02291328f, -0.19380713f, 0.20486067f, 
    0.23169686f, 0.16195188f, -0.00648897f, 0.10351341f, -0.00955339f, 0.09926903f, 0.02793261f, 0.04471815f, 
    0.16578507f, 0.09601755f, 0.36876234f, -0.09530765f, 0.12837364f, -0.07157648f, -0.11212879f, -0.00388224f, 
    0.17866768f, 0.00596449f, 0.02535809f, 0.02253436f, 0.07835100f, -0.24789251f, 0.02104157f, 0.16147266f, 
    0.16880172f, 0.08761775f, 0.13119423f, -0.03606505f, 0.14675304f, -0.00178674f, -0.00664644f, -0.09374686f, 
    0.18183105f, 0.08856756f, 0.17562300f, 0.00944712f, -0.12861031f, 0.03380401f, 0.08394198f, 0.06564065f, 
    0.20219594f, 0.06738092f, 0.01104804f, -0.08229718f, 0.15194067f, -0.22787157f, -0.09596378f, 0.10713268f, 
    0.04523914f, -0.02624558f, -0.06477636f, 0.05118431f, 0.10588605f, 0.14026682f, 0.30881071f, 0.16318724f, 
    0.14542058f, 0.18312486f, 0.07474026f, 0.18618487f, 0.15138800f, 0.00466923f, 0.02171643f, -0.10649093f, 
    0.19658218f, -0.02048314f, 0.12685062f, 0.07887986f, 0.18115084f, -0.05150317f, 0.19943643f, 0.09329242f, 
    0.05709379f, 0.11654706f, -0.11498305f, 0.19774164f, -0.01771140f, -0.09208103f, 0.12401691f, 0.02554297f, 
    -0.17630792f, -0.16361976f, 0.02089106f, 0.07714888f, 0.16191877f, 0.30181876f, 0.00298816f, -0.03033789f, 
    0.08306044f, -0.26296473f, 0.00284475f, -0.06405557f, 0.05880180f, 0.07425494f, 0.13890678f, -0.02770404f, 
    -0.07570904f, -0.22356927f, 0.04477339f, -0.15479968f, -0.04193995f, -0.05393740f, -0.07979542f, -0.04946723f, 
    0.00740161f, -0.25251293f, -0.06467978f, -0.01219096f, 0.14194007f, 0.16517022f, -0.11175615f, -0.06332198f, 
    0.08309267f, 0.17617728f, 0.11299407f, 0.15713355f, 0.67846620f, -0.03883532f, 0.40812424f, -0.21880931f, 
    -0.02104388f, -0.04343588f, -0.01791806f, -0.09960625f, -0.08223216f, 0.02640291f, 0.04646489f, 0.03153418f, 
    -0.16831106f, -0.30064395f, 0.06642202f, 0.56900758f, 0.07571692f, 0.12136459f, 0.05831545f, 0.04068999f, 
    0.14572336f, -0.07056791f, 0.16767496f, 0.16479567f, -0.05834855f, 0.01781402f, 0.14975989f, -0.13145070f, 
    -0.09657975f, 0.03570263f, -0.13497400f, -0.10311318f, 0.08763643f, -0.17798887f, 0.01094846f, 0.12028733f, 
    -0.32367489f, -0.15997192f, 0.11256358f, 0.12217743f, -0.02046526f, -0.07046518f, -0.07950477f, -0.07010062f, 
    0.08470075f, 0.04260463f, 0.20030038f, 0.10346448f, -0.40541625f, -0.27464497f, -0.04514580f, 0.23607008f, 
    0.02730903f, -0.00372051f, 0.00218699f, 0.15863934f, 0.04396694f, -0.01192943f, 0.01780354f, 0.03892687f, 
    -0.18940514f, -0.18830161f, 0.15089084f, 0.24992879f, 0.09022669f, -0.06754892f, -0.08060694f, 0.06773064f, 
    -0.00860347f, -0.07782654f, -0.20451859f, -0.04422946f, -0.04957030f, 0.05201374f, 0.21062917f, -0.22315297f, 
    -0.03930406f, -0.06721117f, 0.06017082f, -0.10028695f, -0.13539149f, -0.04826449f, -0.01605145f, -0.07155100f, 
    0.29351747f, -0.10687619f, 0.00219021f, 0.07280229f, -0.09330054f, 0.04165861f, 0.12885721f, 0.05645521f, 
    -0.08220721f, 0.14638609f, 0.00607010f, -0.05085084f, -0.04704813f, 0.04915513f, 0.07902235f, 0.12803169f, 
    -0.11450075f, 0.11250404f, -0.05096655f, -0.17197505f, -0.06093851f, -0.06507458f, -0.18987367f, -0.09087771f, 
    0.02258408f, -0.10689994f, -0.08454707f, 0.11586885f, -0.01941315f, -0.04031852f, -0.03147807f, 0.03800793f, 
    -0.13559896f, 0.08459190f, -0.08479764f, 0.03607417f, -0.31475896f, 0.15515631f, -0.09312924f, 0.05463158f, 
    -0.02526599f, -0.03924298f, -0.06082330f, -0.11537058f, -0.06745418f, 0.08801667f, -0.13036440f, -0.06820459f, 
    -0.29185805f, 0.11268121f, -0.11750566f, -0.21454827f, -0.01828220f, 0.03274032f, 0.02149700f, -0.05721459f, 
    -0.04278179f, 0.04357858f, 0.00225065f, -0.01069294f, -0.20023352f, -0.05530672f, 0.10472984f, 0.09741720f, 
    0.05593579f, 0.16406935f, 0.13674919f, 0.02025986f, 0.03610816f, 0.06243575f, -0.02333764f, 0.05531581f, 
    -0.09068754f, 0.25186390f, 0.11431229f, -0.12450172f, 0.05235177f, 0.11573004f, -0.00022026f, -0.05935273f, 
    0.09227329f, 0.10053702f, 0.01652226f, 0.21506622f, 0.07612053f, 0.15069090f, 0.11628620f, 0.01138582f, 
    0.01986164f, 0.06955177f, -0.18011120f, 0.06893559f, 0.03348827f, -0.07168306f, -0.05932188f, -0.00701192f, 
    0.03858577f, 0.01730265f, -0.05709002f, 0.05515358f, 0.10299870f, -0.06908196f, 0.09814461f, 0.05533827f, 
    -0.05141416f, -0.19050623f, 0.02837465f, -0.01472279f, -0.49345052f, -0.05990043f, -0.09068271f, 0.24347898f, 
    -0.11474228f, -0.14415891f, -0.04539898f, -0.02969770f, -0.01346872f, -0.03800238f, -0.02118314f, 0.00266473f, 
    0.22796220f, 0.24715002f, -0.02044599f, -0.20066082f, -0.03824680f, 0.14678563f, -0.03502639f, -0.05759265f, 
    0.00938198f, 0.04876674f, -0.09359345f, -0.06613038f, 0.29933456f, 0.09680530f, 0.02819796f, -0.05285194f, 
    -0.00109804f, -0.03107527f, -0.03794210f, 0.11266951f, -0.04538696f, 0.10823711f, -0.02765289f, -0.08606292f, 
    0.17479406f, 0.02814433f, -0.10330582f, 0.13340047f, 0.00282650f, 0.09125292f, 0.11328293f, 0.14804795f, 
    0.01828646f, -0.08429787f, -0.11464674f, 0.03167985f, 0.18316792f, 0.39796573f, -0.06991994f, -0.25276107f, 
    0.00147104f, 0.06905277f, -0.00314815f, -0.17563732f, -0.00392234f, 0.13900134f, 0.04820032f, 0.08042559f, 
    0.18351364f, 0.29843748f, 0.05079870f, 0.15893699f, 0.00307033f, 0.10885189f, 0.07189368f, -0.03959111f, 
    -0.00257506f, 0.02224070f, 0.04880890f, 0.00513709f, -0.05491571f, 0.26520085f, 0.20382355f, 0.18255281f, 
    -0.12641051f, 0.01094654f, 0.05646187f, 0.05733027f, 0.03013554f, 0.00192141f, 0.10257180f, 0.12142423f, 
    -0.20520566f, 0.08697264f, 0.03190404f, -0.11268912f, -0.02605223f, 0.01118868f, 0.06937764f, -0.07360823f, 
    0.05681932f, 0.00481969f, 0.11303286f, 0.06097411f, 0.07590341f, 0.31714076f, 0.01448371f, -0.16204931f, 
    -0.09698020f, -0.11177275f, 0.22150552f, 0.22833902f, -0.03136505f, 0.07511960f, 0.15216725f, 0.10262255f, 
    -0.34441036f, -0.02804239f, -0.15452434f, 0.40024045f, -0.06239522f, 0.15962462f, 0.07339982f, 0.08189320f, 
    -0.11435235f, 0.01396638f, 0.01119262f, 0.10290789f, -0.10140192f, 0.24106298f, 0.10261329f, -0.29859367f, 
    -0.04671582f, 0.01688875f, -0.08290891f, -0.00525729f, 0.00017962f, -0.04657293f, -0.05616662f, -0.00752428f, 
    0.15421596f, -0.05855614f, 0.25569767f, 0.10882752f, -0.11508674f, 0.17812754f, -0.06566604f, 0.07909649f, 
    -0.02428061f, 0.14248903f, -0.00339218f, 0.05316029f, -0.02630130f, 0.06937059f, 0.05611242f, 0.07148679f, 
    -0.04101191f, 0.07870238f, 0.10377448f, -0.03298349f, -0.05865123f, 0.12349101f, 0.12984537f, 0.07715938f, 
    0.25046948f, 0.16281430f, 0.01384950f, -0.17999715f, -0.06452560f, -0.06842980f, -0.04788483f, -0.08155823f, 
    0.07559627f, 0.34239262f, -0.00024501f, 0.13810861f, -0.02300690f, -0.10664055f, 0.04102478f, 0.31794053f, 
    0.02757595f, 0.07764927f, -0.00259335f, 0.04470092f, -0.08583054f, 0.03116064f, -0.10210761f, 0.02782398f, 
    -0.24928570f, -0.00846171f, -0.14151186f, 0.11868919f, 0.01529449f, -0.02418058f, -0.10687277f, 0.13458022f, 
    0.02417263f, -0.02338193f, -0.01893798f, -0.22613654f, 0.00367639f, 0.10021621f, 0.05865454f, 0.05464099f, 
    -0.01317658f, 0.06496114f, -0.15095440f, 0.06098907f, 0.08827566f, -0.05800215f, 0.06505288f, -0.05244734f, 
    0.06546946f, 0.38904682f, -0.16022187f, -0.32369497f, 0.10644529f, 0.01838009f, 0.05477225f, 0.02986101f, 
    -0.20577137f, -0.03439108f, -0.03355696f, -0.08750791f, 0.23108652f, -0.23146862f, 0.03587598f, 0.15269236f, 
    -0.03767465f, 0.00052903f, 0.00077419f, 0.13576673f, -0.03034664f, 0.02344553f, -0.15643230f, -0.00721690f, 
    0.10762054f, 0.03226517f, -0.09847514f, 0.17997850f, 0.10877047f, 0.04477561f, -0.02231424f, 0.17734207f, 
    -0.10943169f, -0.00085294f, -0.03212875f, -0.14275405f, 0.26188204f, 0.03570839f, -0.12454440f, -0.42775127f, 
    -0.00044514f, 0.07028117f, 0.03675905f, -0.13066097f, -0.05620722f, 0.10353794f, -0.02111009f, -0.05198544f, 
    0.01307720f, 0.07995763f, 0.00010519f, 0.07756408f, 0.02189033f, 0.11702008f, 0.16284063f, 0.06859306f, 
    0.10968938f, 0.11294252f, 0.02019867f, 0.08756823f, -0.05355724f, 0.28707415f, 0.00033078f, 0.27290455f, 
    0.04193542f, 0.07950201f, 0.02882752f, 0.12608691f, -0.00123633f, 0.16329902f, 0.06090285f, 0.03752851f, 
    -0.06511665f, -0.01092063f, 0.01180011f, -0.17441104f, -0.04845232f, -0.04717511f, 0.05254072f, 0.06641709f, 
    -0.06739228f, 0.01723026f, 0.07090784f, 0.07304788f, -0.31338644f, -0.17937222f, 0.06759454f, 0.37355521f, 
    0.25517043f, 0.03792819f, 0.18623674f, 0.05937842f, 0.01939078f, -0.05080125f, 0.12886633f, -0.05079978f, 
    0.18256980f, -0.11865463f, -0.24087255f, 0.02974172f, 0.07974406f, 0.06809306f, 0.09130981f, 0.04559064f, 
    0.01633336f, 0.07434252f, -0.13016611f, 0.00846492f, -0.16820256f, 0.02409547f, -0.17614317f, 0.00360816f, 
    0.08312790f, -0.06447523f, -0.02412123f, 0.04153112f, 0.02582276f, 0.02963774f, -0.04200755f, -0.04145835f, 
    -0.20273080f, -0.00345269f, 0.07124633f, -0.11402131f, 0.00063332f, -0.16217460f, 0.04499521f, 0.03504654f, 
    0.05082209f, 0.02647889f, -0.06810310f, -0.07905963f, -0.08407690f, -0.02575355f, 0.15151586f, 0.02050444f, 
    -0.00013727f, -0.00022337f, -0.11258942f, 0.09475876f, -0.16681139f, -0.08499884f, -0.02847083f, 0.04434043f, 
    -0.20517351f, 0.00608354f, 0.12662488f, 0.01626167f, 0.11737663f, 0.03874070f, -0.00388205f, -0.00453900f, 
    -0.02974441f, -0.00412141f, 0.01700483f, 0.16071099f, 0.08470029f, 0.16318707f, 0.17614456f, -0.25880817f, 
    0.13945046f, 0.09869333f, -0.10588302f, 0.07801762f, -0.01161420f, -0.05598371f, 0.03098505f, -0.06597923f, 
    0.02234522f, 0.00566804f, -0.12454509f, -0.00478846f, 0.17526610f, 0.11690837f, -0.02649861f, 0.05456794f, 
    -0.09716962f, -0.01642613f, 0.06774373f, -0.04632440f, 0.07409517f, -0.18909097f, 0.16235180f, -0.03776223f, 
    -0.05354267f, -0.03900996f, -0.09124137f, -0.11220017f, -0.10356874f, -0.02229980f, -0.00337171f, -0.00413290f, 
    -0.09652015f, 0.07803606f, 0.08017166f, 0.00874321f, -0.07343392f, -0.12421586f, 0.15063035f, -0.05904555f, 
    0.11746302f, 0.00080129f, -0.09622411f, -0.08775391f, -0.03755130f, 0.09537891f, 0.02734075f, -0.05402213f, 
    0.07014789f, 0.06885398f, -0.08263766f, 0.06272326f, 0.00974058f, 0.06308363f, -0.07234302f, -0.23329386f, 
    0.01345921f, 0.04409448f, -0.04936680f, 0.08424873f, -0.00163708f, -0.15174636f, 0.15154454f, 0.01931101f, 
    0.03766809f, 0.10995114f, -0.15597260f, 0.03936612f, -0.33742675f, -0.17213699f, -0.08132511f, 0.01426026f, 
    -0.04830448f, 0.01409029f, 0.08320716f, 0.10978574f, 0.10516963f, 0.01086762f, -0.01631188f, 0.04185968f, 
    0.02179680f, 0.06271320f, 0.13822201f, 0.13197017f, 0.05799195f, 0.11965817f, 0.09847221f, 0.00878973f, 
    0.03672788f, -0.00842226f, 0.06701009f, -0.02590941f, 0.00628146f, -0.03257374f, 0.22822475f, -0.08161250f, 
    -0.01462729f, -0.00038665f, 0.21929432f, 0.01204505f, 0.06509694f, 0.04928862f, 0.06160791f, 0.04773292f, 
    0.05567053f, 0.06782202f, -0.06595788f, 0.05475059f, -0.05633916f, 0.08682145f, 0.09911322f, 0.01580760f, 
    -0.07074345f, 0.05476769f, 0.09892514f, 0.01642698f, -0.00471850f, 0.30536422f, 0.06484301f, -0.12664917f, 
    -0.14440905f, 0.04055636f, -0.07835630f, 0.07403421f, -0.04371011f, 0.12182710f, 0.05384690f, 0.09371004f, 
    -0.04329726f, 0.00632672f, 0.03157777f, 0.00923779f, -0.03312766f, 0.02613935f, 0.06296605f, -0.05481742f, 
    -0.07522053f, -0.03049821f, 0.00694139f, 0.01105343f, -0.00655237f, 0.03819080f, 0.03516328f, 0.01855730f, 
    0.00733575f, -0.02818101f, -0.05353885f, 0.03120320f, 0.00857128f, -0.05384735f, 0.03121653f, -0.03783739f, 
    0.03974849f, -0.00798140f, -0.02476466f, -0.00204994f, 0.00774124f, 0.03612164f, -0.07563586f, 0.05981134f, 
    -0.03098237f, -0.04650097f, -0.01191275f, 0.05271853f, -0.06370093f, -0.00222835f, -0.04308834f, 0.01050389f, 
    -0.05447725f, -0.00477161f, -0.05989352f, -0.00323212f, -0.02664630f, -0.07170992f, 0.05716314f, 0.02605530f, 
    0.01508982f, 0.05925279f, 0.02489258f, -0.03283380f, -0.07786947f, 0.04700654f, -0.02829894f, -0.06572530f, 
    0.02345342f, 0.03810000f, -0.01369323f, 0.05826711f, -0.03563869f, 0.04726562f, 0.00384015f, 0.03853447f, 
    -0.05447114f, -0.01919509f, -0.06632154f, 0.02164329f, 0.05042771f, 0.01366191f, -0.02443866f, -0.01478692f, 
    0.03862457f, 0.00028529f, 0.04600991f, 0.03516264f, -0.03522648f, 0.03715350f, 0.02652999f, -0.06646787f, 
    -0.02859805f, 0.01403795f, 0.05212810f, -0.00454566f, -0.06651705f, -0.02686156f, 0.00154692f, 0.03342780f, 
    -0.01750684f, 0.03773303f, 0.05921374f, -0.07321013f, -0.05112908f, -0.02530042f, -0.07029235f, -0.01183586f, 
    -0.01397313f, 0.00932832f, 0.00999070f, 0.00683992f, 0.02503505f, -0.00895751f, -0.02899793f, -0.04936076f, 
    -0.05154040f, 0.00999597f, 0.04681793f, 0.06422210f, 0.05352686f, 0.00006829f, -0.02273422f, -0.03793881f, 
    -0.00665845f, 0.02267212f, 0.00254855f, -0.06566307f, -0.00555700f, -0.02526111f, 0.04978405f, -0.04619429f, 
    -0.04341328f, -0.03541975f, 0.01341715f, 0.00818751f, -0.02601101f, -0.04001652f, -0.07730510f, -0.06904005f, 
    -0.03374176f, -0.05713652f, -0.05213167f, -0.03960630f, 0.01392510f, 0.02053879f, 0.01590204f, 0.06793286f, 
    0.03031490f, -0.03971579f, -0.07305004f, -0.04919036f, 0.01948986f, 0.04393037f, 0.05288374f, 0.00823807f, 
    -0.05042727f, -0.04661832f, -0.00860239f, -0.04338587f, 0.05243406f, -0.01760000f, -0.02599703f, 0.01127151f, 
    0.02806072f, -0.04224152f, -0.02377747f, 0.04836291f, 0.05892235f, 0.06529342f, -0.02700445f, -0.02463259f, 
    0.04378952f, -0.06557915f, -0.06588405f, 0.04692638f, 0.05357587f, -0.02241533f, -0.05888861f, 0.05008689f, 
    -0.03134780f, -0.05739801f, -0.03357961f, -0.05353336f, -0.03944876f, -0.05567273f, -0.06411757f, 0.06864130f, 
    0.02955764f, -0.05717115f, -0.02944437f, -0.02926798f, -0.00004895f, -0.06204129f, -0.01253191f, -0.02415419f, 
    0.01254827f, -0.01308958f, 0.00363230f, -0.00930536f, -0.02047870f, -0.06945384f, -0.06378126f, 0.03064725f, 
    -0.06512237f, 0.49260896f, -0.14210008f, 0.23119085f, -0.20465685f, 0.15690939f, 0.05188556f, 0.09082775f, 
    0.04069747f, -0.04546412f, 0.05360544f, 0.04163652f, 0.02512412f, 0.41688022f, 0.04114588f, -0.11284408f, 
    0.04747405f, -0.05503364f, 0.08035020f, 0.20017992f, 0.01500501f, 0.16737205f, 0.01260131f, 0.08750071f, 
    -0.25662231f, -0.01166794f, -0.03781124f, -0.07270794f, -0.20230442f, 0.09064642f, -0.09889944f, 0.09083088f, 
    -0.07189947f, 0.00949508f, -0.05997393f, -0.06020978f, -0.07847130f, 0.02273761f, 0.18984301f, -0.02167512f, 
    -0.06751615f, -0.04948735f, 0.15431948f, -0.05509921f, 0.08998188f, -0.06886408f, 0.05475265f, 0.08659662f, 
    0.15647356f, 0.11023126f, -0.04732833f, -0.17043427f, -0.17935698f, -0.10261718f, -0.05475656f, 0.06153241f, 
    -0.03917127f, 0.22295898f, 0.13303342f, 0.20888734f, -0.13075912f, -0.13516028f, 0.04504942f, -0.02469283f, 
    0.03074582f, 0.29348534f, 0.07556239f, 0.02627682f, -0.13471696f, -0.09708484f, -0.08816150f, 0.02626924f, 
    -0.35866860f, 0.07429186f, -0.22014461f, 0.07924878f, 0.02409671f, 0.05430720f, -0.07124822f, -0.01493839f, 
    0.07514104f, -0.10018263f, -0.00291045f, -0.05968233f, -0.25133005f, 0.00335771f, 0.26550013f, -0.35975894f, 
    -0.13918230f, -0.19266254f, -0.24420649f, 0.00537859f, -0.08692301f, -0.02231719f, 0.00502975f, -0.00219168f, 
    0.08268563f, 0.30018464f, 0.05155388f, -0.11979566f, -0.08668897f, -0.01583277f, 0.03480225f, -0.03977957f, 
    -0.06793754f, -0.04002648f, -0.00748612f, -0.07719230f, 0.25680268f, 0.08203813f, 0.10973538f, 0.34672737f, 
    0.03980548f, -0.09175941f, 0.05437838f, 0.08231384f, -0.04945756f, 0.17988500f, -0.12064239f, -0.01445260f, 
    0.10404350f, -0.03059682f, -0.19663280f, 0.10524871f, 0.05972249f, 0.06203339f, 0.11285245f, 0.08330098f, 
    -0.00737119f, 0.01955944f, -0.06302721f, -0.10794634f, 0.19189213f, 0.20965923f, -0.00288920f, -0.38396356f, 
    -0.17797674f, 0.03122633f, 0.03910862f, 0.08900341f, 0.00121092f, 0.22355427f, -0.02010334f, 0.04129562f, 
    -0.11676975f, -0.01370595f, -0.13867748f, 0.02637666f, -0.06433398f, 0.13407217f, 0.17308950f, -0.10419166f, 
    -0.04861415f, 0.01071174f, -0.01124871f, 0.05600523f, -0.12966302f, 0.22677201f, -0.10042224f, 0.33010992f, 
    -0.07511288f, 0.23915927f, 0.02842583f, 0.03204450f, 0.07205298f, 0.05213726f, 0.21170844f, 0.17387471f, 
    -0.13247168f, 0.29927814f, -0.14757188f, -0.16243567f, -0.20727272f, 0.00696861f, 0.06720873f, 0.04664456f, 
    -0.09751199f, 0.02963309f, 0.02158081f, 0.07917663f, -0.39706120f, -0.36375687f, -0.18430679f, 0.08053213f, 
    0.11899498f, 0.03625369f, 0.10151985f, 0.16149332f, 0.07641844f, 0.01734294f, 0.09482957f, 0.01214593f, 
    0.01725126f, 0.22506344f, 0.20116058f, -0.03508182f, 0.01990110f, 0.05213492f, 0.03115936f, 0.04962100f, 
    0.07935015f, 0.01952999f, -0.03663084f, -0.00628336f, 0.31893006f, -0.10828315f, 0.09198322f, 0.01178765f, 
    -0.08946428f, 0.11153223f, 0.07884362f, 0.05667820f, 0.13688128f, 0.22049373f, 0.07521211f, 0.04728204f, 
    0.14137892f, 0.03508782f, -0.05468698f, 0.09516159f, -0.04311131f, 0.22339489f, -0.04437699f, -0.01730981f, 
    0.01727891f, 0.01301396f, 0.04709473f, 0.03939216f, 0.00327809f, 0.11208400f, -0.08048420f, -0.08226551f, 
    -0.00549917f, 0.04128092f, 0.06260537f, -0.06824745f, -0.00448033f, 0.11159192f, 0.13137391f, -0.06655522f, 
    0.12303347f, 0.01729695f, -0.04333702f, 0.07952375f, -0.12476507f, -0.00793195f, 0.07311860f, 0.05939850f, 
    -0.17427401f, 0.00908295f, -0.00672283f, -0.02403424f, -0.12883256f, -0.21372524f, -0.26360148f, 0.15350388f, 
    -0.00343921f, 0.00338860f, 0.06150335f, 0.06751072f, -0.00072070f, 0.00316459f, -0.10736306f, 0.01064651f, 
    -0.05654094f, 0.13324371f, 0.03457925f, 0.00614713f, -0.04392369f, 0.00787255f, 0.02544778f, -0.06686836f, 
    0.16733594f, 0.19372432f, -0.07987077f, 0.09006197f, 0.16164348f, 0.27183565f, -0.03404565f, -0.08430214f, 
    0.04031497f, 0.04463687f, 0.08869807f, -0.00122487f, 0.10438708f, 0.07284567f, 0.13798966f, -0.03470515f, 
    0.01125176f, -0.38113526f, 0.30429906f, 0.07139964f, -0.00584848f, 0.08634726f, -0.18561994f, 0.00806346f, 
    -0.00075604f, -0.05632011f, 0.01939905f, 0.10394024f, 0.05395170f, 0.06160492f, 0.00749714f, 0.05424755f, 
    -0.10237541f, -0.08402438f, -0.00709814f, -0.10551001f, 0.10396441f, -0.10788532f, 0.06920426f, 0.24185014f, 
    -0.01783878f, -0.18673401f, 0.07363866f, 0.04029304f, 0.06960307f, 0.05403369f, 0.01479886f, -0.07239777f, 
    0.02322736f, 0.02518781f, 0.03718333f, 0.12318164f, 0.23855731f, -0.02686695f, 0.28656048f, -0.00848208f, 
    0.00313776f, 0.08086071f, -0.00700242f, 0.02258213f, 0.05070197f, -0.06867626f, 0.08848734f, -0.04677223f, 
    -0.18115203f, -0.26734710f, 0.07624079f, -0.08674907f, -0.00078521f, -0.04254931f, 0.03264026f, -0.06561782f, 
    -0.08845337f, 0.01168853f, -0.05636942f, 0.05013587f, -0.11723015f, 0.02007584f, -0.28461447f, -0.02051181f, 
    0.05701825f, 0.11740142f, -0.06518081f, -0.05320205f, 0.00043260f, -0.12788790f, 0.03014996f, -0.05427230f, 
    0.21386330f, 0.07850453f, 0.09911510f, 0.06445088f, 0.04739908f, 0.01736553f, -0.01193562f, 0.02717814f, 
    0.10426388f, 0.04059663f, -0.12513711f, -0.04002068f, -0.18892072f, -0.32855195f, 0.12497760f, 0.10670312f, 
    0.00809601f, 0.04629653f, -0.06817262f, -0.09361187f, -0.05327605f, -0.07045122f, 0.01298964f, -0.06313272f, 
    0.18656541f, 0.23629043f, 0.15178581f, 0.09955209f, 0.09616689f, 0.04392941f, -0.08367151f, 0.05619369f, 
    -0.01551601f, -0.09029180f, -0.03252928f, 0.00057834f, -0.22605006f, -0.13909090f, -0.11892075f, 0.16175669f, 
    -0.00472706f, 0.06313004f, 0.05319563f, 0.00564663f, -0.01901991f, -0.01110924f, 0.00928773f, 0.12971233f, 
    -0.18644233f, -0.08766516f, -0.12089784f, -0.00972997f, -0.02247469f, -0.01691666f, -0.08455715f, 0.09667751f, 
    -0.02737400f, 0.06394307f, -0.01002530f, 0.04028194f, -0.13972321f, -0.04857301f, -0.11626006f, 0.01485761f, 
    -0.00251751f, 0.05252366f, 0.04549761f, 0.04589241f, 0.15519327f, -0.02747711f, -0.02681030f, -0.07788515f, 
    -0.13150957f, 0.01739435f, 0.08140583f, 0.04750852f, -0.04683176f, 0.02260390f, 0.08217557f, -0.04546414f, 
    0.07355303f, -0.07821976f, 0.02561990f, -0.08362374f, -0.00020487f, 0.10037601f, 0.09541444f, 0.03888752f, 
    0.03710005f, 0.09257180f, 0.02301273f, 0.07935113f, 0.01388277f, -0.06924473f, 0.11348879f, 0.04582993f, 
    0.02155889f, 0.14793020f, 0.16143344f, 0.12332205f, -0.00882906f, -0.05291130f, 0.05314731f, -0.00440806f, 
    0.08119152f, 0.15456598f, -0.03359808f, 0.02814638f, -0.20189720f, -0.25789419f, -0.21201432f, 0.11360500f, 
    -0.06059169f, 0.05895064f, -0.00987236f, 0.05480226f, 0.00436713f, 0.04286011f, 0.02172253f, -0.00647097f, 
    -0.05232105f, -0.05175246f, 0.41333774f, 0.10646599f, 0.02981735f, 0.07563480f, -0.03785381f, 0.01144765f, 
    -0.06911490f, 0.10002479f, -0.05162878f, -0.05037241f, 0.11159459f, 0.13206647f, 0.07201318f, 0.17519249f, 
    0.07077082f, 0.07985767f, -0.05192260f, 0.00223672f, 0.09456919f, 0.08688027f, -0.09529534f, 0.23795131f, 
    0.04905143f, 0.01006312f, 0.15658189f, 0.08318932f, 0.00369306f, 0.06882892f, -0.03244036f, -0.00285052f, 
    -0.00261529f, -0.09801875f, -0.06627267f, 0.19774440f, 0.02088664f, 0.08327121f, 0.05886279f, 0.15204363f, 
    0.03466278f, -0.00066890f, 0.02192412f, 0.01302719f, -0.01528229f, -0.01439168f, -0.12763987f, 0.06519173f, 
    0.26436833f, 0.26880580f, 0.15632185f, 0.17104897f, 0.01707228f, 0.03239113f, 0.00150844f, -0.01525250f, 
    -0.04271538f, -0.06767742f, -0.03494730f, -0.22021277f, 0.07533366f, -0.01445886f, 0.16725574f, 0.20054959f, 
    -0.04227680f, 0.03003266f, 0.11858742f, 0.08424514f, -0.01283900f, 0.00174631f, 0.01779977f, 0.06010676f, 
    -0.22372496f, -0.13769552f, -0.19682200f, -0.00936479f, -0.02177644f, -0.02673584f, 0.05458347f, 0.04237964f, 
    -0.08335319f, 0.10471223f, -0.04640262f, 0.05075810f, 0.22197609f, 0.22732180f, 0.13481511f, -0.01268388f, 
    0.12960170f, -0.06761372f, -0.03696081f, 0.01603321f, -0.00164683f, 0.01433507f, 0.01404306f, 0.00935186f, 
    -0.04298535f, -0.04727147f, -0.30146557f, 0.18317655f, -0.03966057f, 0.05874208f, 0.17470133f, 0.02009295f, 
    0.04925491f, 0.17319091f, -0.01071108f, 0.01431171f, 0.19786686f, 0.19687113f, 0.11780341f, -0.07530417f, 
    -0.15479869f, -0.04853561f, 0.01383105f, 0.05185537f, -0.07843805f, 0.18025102f, 0.21686582f, 0.11068982f, 
    -0.01895511f, 0.32726571f, 0.37570259f, 0.00453038f, -0.01254700f, -0.00829687f, 0.19024628f, -0.05905520f, 
    -0.00390499f, -0.14038101f, -0.06104553f, 0.01911725f, 0.01442636f, 0.11625792f, 0.24154454f, 0.16544454f, 
    -0.10763481f, 0.16258664f, -0.08176158f, -0.01250409f, -0.06881274f, -0.10524463f, -0.00466948f, -0.06601501f, 
    0.07479933f, -0.05991855f, 0.05770665f, -0.11895343f, 0.21023224f, 0.20989658f, -0.05590055f, -0.14116488f, 
    -0.15998706f, -0.29964873f, -0.00620014f, -0.21333489f, -0.00561864f, 0.10924885f, 0.11354146f, -0.12620036f, 
    -0.03618624f, -0.11050341f, 0.04512876f, 0.04875256f, -0.09131165f, -0.02416615f, -0.02978866f, -0.06333790f, 
    -0.26734638f, -0.08439177f, -0.02253746f, 0.00894875f, 0.08820716f, 0.08178420f, 0.15562907f, 0.05587775f, 
    0.04983764f, -0.09382047f, 0.14298822f, 0.29028323f, 0.39834943f, 0.24601823f, 0.48558655f, 0.15340714f, 
    -0.06282516f, -0.08648501f, -0.01943421f, 0.03911008f, -0.01402587f, 0.07947949f, 0.09107235f, 0.14700586f, 
    0.41141140f, 0.09195128f, -0.35471338f, -0.11882886f, 0.05677488f, 0.19929175f, 0.10545003f, -0.04312538f, 
    -0.00874067f, 0.09570817f, 0.20761438f, 0.12362687f, 0.25756848f, -0.10184277f, 0.15701872f, 0.12946853f, 
    0.03781741f, 0.09456506f, -0.13029766f, -0.10210182f, 0.05189176f, 0.06223453f, 0.02186186f, 0.16135071f, 
    0.12517774f, -0.00671730f, -0.10194713f, 0.04241262f, 0.21548563f, 0.04105436f, 0.07526237f, 0.10879961f, 
    0.01978793f, 0.10297747f, 0.02939167f, -0.04592528f, 0.33103320f, -0.01575193f, 0.06585959f, -0.19723329f, 
    -0.03212238f, 0.09706150f, 0.02500690f, -0.09005705f, 0.00307127f, 0.09672661f, -0.09432907f, -0.07367694f, 
    -0.07053289f, -0.15622866f, -0.26387876f, -0.00930948f, 0.10654704f, 0.01013236f, 0.07598690f, 0.01488682f, 
    -0.05100603f, -0.02528535f, -0.21222663f, -0.15114376f, -0.09714371f, 0.19741812f, 0.07250051f, -0.00121070f, 
    -0.04261174f, -0.06413188f, -0.02847055f, -0.09438209f, -0.17907758f, -0.04817245f, -0.11252012f, -0.09967536f, 
    0.23536959f, 0.04068883f, 0.05466699f, 0.19248712f, -0.07988067f, 0.09230683f, 0.01273891f, -0.19607522f, 
    -0.04334346f, -0.04036732f, 0.01518863f, -0.01786583f, -0.16816315f, 0.13033521f, -0.02713687f, 0.07393425f, 
    -0.01513079f, 0.05576781f, 0.11402275f, 0.22126348f, 0.02002541f, 0.02346042f, -0.05398939f, 0.01268894f, 
    -0.19560984f, -0.07162414f, 0.06144559f, -0.09912172f, 0.03245078f, -0.05995409f, 0.15367585f, 0.10015669f, 
    -0.02361282f, 0.02871909f, 0.06610668f, -0.10829923f, 0.38502863f, -0.10499148f, 0.16756016f, -0.17099799f, 
    -0.03087000f, 0.09391984f, -0.06110269f, -0.08199138f, 0.16738835f, -0.01454806f, 0.09979380f, 0.13149013f, 
    0.32128027f, -0.05094488f, 0.15408976f, 0.24087329f, 0.05765815f, 0.17112389f, 0.04940138f, -0.05217138f, 
    -0.00110361f, 0.13318163f, 0.06529253f, -0.06615520f, -0.04661025f, 0.12548053f, -0.09256957f, -0.11037004f, 
    0.02654682f, -0.07255289f, -0.11446773f, -0.13946404f, -0.04032788f, 0.10330854f, 0.15205474f, 0.06034326f, 
    0.14669621f, -0.17280106f, -0.23157986f, -0.01502860f, 0.09915256f, 0.03498181f, -0.00298190f, 0.07938139f, 
    -0.04995934f, 0.06119155f, 0.08775327f, -0.06800643f, -0.06740670f, -0.11408906f, -0.02549231f, 0.20807073f, 
    0.08727249f, 0.00368496f, 0.16688055f, 0.12657279f, 0.04019550f, 0.04343020f, 0.05736773f, 0.11261963f, 
    -0.01201155f, -0.22024828f, 0.04270453f, 0.09594691f, -0.10554747f, 0.12956834f, -0.05586374f, 0.07095116f, 
    0.00983918f, 0.12123798f, 0.16044341f, -0.04918522f, -0.14675559f, 0.42506889f, 0.23249261f, 0.02117737f, 
    0.12549251f, -0.05604287f, -0.08179096f, 0.12847903f, 0.04470554f, -0.06900626f, 0.06013759f, -0.01557636f, 
    -0.00559321f, -0.10998946f, -0.16403088f, -0.12400129f, 0.00506062f, -0.15985958f, 0.01165506f, 0.16711932f, 
    0.00218140f, 0.00519333f, 0.13520958f, 0.03449905f, -0.02690027f, -0.19471569f, 0.00086522f, 0.04499184f, 
    -0.04198327f, -0.01513402f, 0.07826273f, -0.05578938f, 0.11283452f, -0.04355605f, 0.08783913f, 0.22508514f, 
    -0.15468004f, 0.08188362f, -0.06165282f, -0.09419452f, 0.01923906f, -0.03069136f, -0.05109480f, 0.03452055f, 
    0.05318753f, 0.11175419f, 0.17658956f, 0.02723286f, 0.29677433f, -0.01202090f, 0.10151742f, 0.05401670f, 
    -0.03870083f, -0.00931528f, -0.01407655f, -0.07951782f, 0.07621724f, 0.11892579f, 0.09619562f, 0.10929198f, 
    -0.16750479f, -0.26470014f, -0.10613891f, -0.19725506f, -0.06983875f, -0.01309583f, 0.04958856f, 0.20596281f, 
    -0.03665826f, 0.09966964f, -0.00906432f, 0.09158868f, 0.18167748f, -0.04998012f, -0.36284897f, 0.14748782f, 
    0.26127219f, 0.07338493f, -0.02164224f, -0.06249196f, 0.05520304f, 0.10165010f, -0.16441251f, -0.06159373f, 
    0.12253735f, 0.11871942f, 0.16872814f, 0.13443033f, 0.17232077f, -0.10390685f, -0.06607862f, -0.17012930f, 
    0.09278650f, 0.01260817f, 0.08765759f, 0.09983837f, 0.13349544f, -0.33382997f, 0.11615898f, 0.11802968f, 
    0.24406481f, -0.01724377f, -0.11758375f, -0.12561996f, 0.16904485f, 0.03145298f, -0.10490181f, -0.13445069f, 
    -0.21061201f, 0.20319177f, -0.06565469f, 0.03095108f, -0.03190626f, 0.14775728f, -0.01156308f, 0.05078942f, 
    0.14182901f, -0.01410277f, -0.00120075f, -0.06781003f, 0.15265505f, 0.24971934f, 0.03935955f, -0.17723691f, 
    0.06882952f, 0.02174667f, -0.00021659f, 0.18988650f, -0.02939368f, 0.14949839f, 0.15037581f, 0.12038200f, 
    0.17372774f, -0.04764140f, -0.04487867f, 0.17845561f, 0.11350115f, 0.13813335f, -0.02485577f, -0.05381586f, 
    -0.07667229f, 0.05981669f, -0.12870185f, -0.03587059f, 0.10416188f, 0.02764737f, -0.02283604f, -0.08294041f, 
    -0.04662378f, -0.05060090f, -0.09653077f, -0.00401155f, -0.09469548f, -0.09527536f, 0.10480605f, 0.10946430f, 
    -0.12136698f, -0.28119612f, -0.20032042f, -0.09117223f, -0.03376570f, -0.04915383f, -0.28657934f, 0.06848264f, 
    -0.00859259f, 0.19291447f, 0.06219202f, 0.09478781f, -0.05283776f, -0.15089433f, -0.11902292f, 0.19425873f, 
    0.00886889f, 0.07970426f, 0.17203243f, 0.03810159f, 0.02353539f, 0.06178257f, 0.04594562f, 0.00236384f, 
    0.10565554f, 0.02757990f, -0.14057314f, 0.05125964f, -0.13664976f, 0.14320993f, 0.05102792f, -0.02429395f, 
    -0.01478556f, 0.02545772f, -0.16811958f, -0.02933044f, 0.29245362f, -0.05620983f, 0.38824040f, -0.32655779f, 
    -0.01052548f, 0.07727276f, -0.12708695f, -0.04276132f, -0.10995448f, -0.09219611f, 0.01744415f, 0.03953558f, 
    -0.19705679f, 0.03234801f, -0.09508820f, 0.05887379f, 0.03617015f, -0.06556034f, 0.10888947f, 0.01872587f, 
    0.10615422f, 0.11784569f, 0.18572956f, 0.17485565f, 0.06469131f, -0.09417417f, 0.03349821f, 0.14085342f, 
    0.07528742f, -0.01624811f, 0.10608972f, 0.15335965f, -0.06830713f, -0.09870050f, 0.07578181f, -0.04010960f, 
    -0.20104566f, -0.13744012f, -0.11285669f, -0.03810094f, 0.02617921f, -0.06597827f, -0.09410601f, 0.02350407f, 
    0.04543140f, 0.22993325f, 0.25488251f, 0.00471768f, -0.30858532f, -0.21058711f, -0.18555658f, -0.26375440f, 
    0.01520567f, -0.04888230f, -0.01489640f, 0.02864382f, 0.06795166f, 0.06562468f, 0.16444114f, 0.11264097f, 
    -0.26575598f, -0.31030449f, -0.03019628f, 0.06590977f, -0.05179641f, 0.07594780f, 0.11429866f, 0.04202149f, 
    0.18634301f, 0.18895638f, -0.05174329f, 0.15511246f, 0.11422247f, 0.02452516f, -0.07884198f, 0.26637349f, 
    -0.03392296f, 0.19268653f, -0.10927500f, 0.15663669f, 0.14401585f, 0.07880463f, 0.19183767f, 0.15048872f, 
    0.09435055f, 0.14999408f, 0.04990256f, -0.11280316f, -0.04125042f, -0.07183370f, -0.06498743f, -0.01368846f, 
    -0.12164778f, 0.04472774f, 0.05875159f, 0.12327648f, -0.11692697f, -0.28094101f, -0.00342738f, 0.29112515f, 
    0.05390891f, 0.20336708f, 0.08468806f, -0.09783427f, 0.14810678f, -0.03620753f, -0.00154076f, 0.07168792f, 
    0.02864375f, -0.18723060f, -0.09071976f, -0.12834883f, 0.19564793f, 0.09330036f, 0.10538832f, 0.11474200f, 
    0.00798318f, -0.03106037f, 0.05852326f, 0.13570286f, 0.03408692f, 0.26795119f, 0.08825845f, -0.21880740f, 
    0.08870720f, 0.00071874f, 0.09937755f, 0.14877586f, 0.10364959f, -0.02207069f, -0.12134179f, -0.17644455f, 
    0.10116258f, -0.23313954f, 0.01748968f, -0.01447395f, 0.09206048f, 0.05973651f, 0.04714479f, 0.01930417f, 
    -0.02561561f, 0.12927604f, 0.03454717f, -0.04573056f, 0.23491973f, -0.01129578f, 0.09700521f, 0.01304841f, 
    0.09206852f, -0.17733423f, -0.00394387f, 0.07758578f, -0.03754070f, 0.05175651f, 0.05007688f, 0.06933355f, 
    0.01620231f, -0.02292579f, -0.14531897f, 0.01061455f, -0.05934727f, -0.14263092f, 0.02911042f, 0.12100087f, 
    0.03771938f, 0.32959154f, -0.03638946f, 0.16328865f, -0.02478162f, -0.02892883f, 0.08736834f, 0.04748043f, 
    0.14340284f, 0.03003462f, 0.05664827f, 0.06586079f, -0.03879459f, -0.01057429f, -0.06525023f, 0.05350815f, 
    0.15435205f, -0.09953958f, -0.08761470f, -0.09725815f, -0.05216612f, 0.13919228f, -0.10623057f, 0.15575469f, 
    -0.01898290f, -0.14752261f, -0.04041515f, -0.17843162f, 0.20519404f, 0.23379932f, -0.16708437f, -0.06014406f, 
    0.07639682f, 0.05073506f, 0.03358578f, -0.07771008f, 0.03866480f, -0.00743001f, -0.07100451f, -0.05781468f, 
    -0.10040630f, 0.14183056f, -0.02032637f, -0.10475952f, -0.02725889f, -0.19900933f, 0.15411085f, 0.10309992f, 
    -0.06181733f, -0.10515045f, -0.17145655f, -0.09122276f, -0.18368028f, -0.09707055f, -0.06602854f, -0.07620715f, 
    0.09613842f, -0.01702980f, 0.01524309f, 0.08260988f, -0.11580908f, -0.18462543f, -0.01534661f, -0.34402791f, 
    -0.05268981f, -0.01744991f, 0.05147258f, -0.08824965f, -0.07220506f, 0.03607367f, -0.01552459f, 0.14443481f, 
    -0.01722021f, 0.06218891f, -0.02901133f, -0.04333382f, -0.17251803f, -0.08830186f, -0.18622053f, -0.28809151f, 
    0.02121793f, -0.02740675f, -0.01023940f, 0.03059502f, 0.01756346f, -0.04169724f, 0.07204124f, 0.07059738f, 
    -0.15417606f, -0.03057197f, 0.20834963f, 0.05406561f, -0.02240974f, 0.07963401f, 0.01795062f, 0.03224399f, 
    0.06621824f, 0.05021127f, 0.04123438f, 0.18629624f, -0.04370416f, -0.10847151f, 0.11363301f, 0.08705139f, 
    0.10323120f, 0.08584496f, 0.01272029f, 0.10252751f, 0.19122523f, 0.10161911f, 0.17207412f, 0.14106439f, 
    0.18291403f, 0.14045322f, 0.31294563f, -0.07271728f, 0.04716330f, 0.02460964f, 0.05255181f, -0.01109651f, 
    -0.00300926f, -0.01558486f, 0.03618635f, -0.06022346f, -0.12418813f, -0.07730360f, 0.14610989f, 0.16249359f, 
    -0.00356252f, 0.06101379f, 0.06112657f, -0.00416367f, 0.03992159f, -0.07683186f, 0.03990982f, -0.05088767f, 
    0.01132798f, -0.02571140f, 0.00822059f, -0.05401972f, 0.04582598f, -0.04860316f, -0.02723841f, 0.04846818f, 
    0.01571403f, 0.03607271f, -0.00641286f, 0.00996214f, -0.03383379f, -0.04239455f, 0.02805696f, -0.01260361f, 
    0.00876735f, -0.05435558f, -0.07708290f, 0.02520625f, -0.06666063f, -0.04979974f, -0.05398162f, 0.03970940f, 
    0.04711878f, -0.02683989f, 0.01225810f, -0.01923074f, -0.00909680f, 0.02284159f, -0.07904617f, 0.03302077f, 
    0.00042589f, -0.05326184f, 0.00748193f, -0.06788796f, -0.01681135f, -0.05804222f, 0.03844148f, 0.01598316f, 
    -0.00387712f, 0.00380769f, -0.02516621f, 0.00965013f, -0.06993337f, -0.02328833f, -0.00469948f, -0.05713257f, 
    -0.05670503f, -0.02339554f, -0.03925266f, 0.00064994f, -0.00297723f, 0.02873946f, -0.05967285f, -0.04188805f, 
    0.04364172f, -0.02592113f, -0.01649024f, -0.00060883f, 0.04178846f, -0.02303598f, 0.03037128f, -0.07891484f, 
    0.01861775f, 0.02251217f, -0.07885800f, -0.03091544f, -0.03217844f, 0.01685845f, -0.03517591f, -0.01369885f, 
    -0.03684372f, -0.04298350f, -0.05334940f, -0.06998514f, -0.06101023f, -0.06772622f, -0.03329156f, -0.06125577f, 
    0.00128673f, 0.02674413f, 0.05258995f, 0.03048276f, -0.02839180f, 0.00769383f, -0.01222171f, -0.02678276f, 
    0.04508521f, 0.00644941f, 0.03047407f, 0.00633570f, -0.03235692f, -0.05106791f, -0.03401043f, 0.03144912f, 
    0.03488915f, -0.00077134f, 0.05948505f, -0.00178658f, 0.01519092f, -0.07856167f, -0.04797266f, 0.05827600f, 
    -0.07851141f, -0.00173375f, -0.01301978f, -0.04962894f, 0.01296324f, 0.04044953f, 0.00747573f, 0.05628997f, 
    0.06055263f, 0.04210264f, 0.00979937f, -0.04475940f, -0.03118074f, 0.04036245f, 0.03127578f, 0.04856266f, 
    -0.07801514f, 0.03552971f, 0.04230211f, -0.00434898f, -0.04706949f, -0.02051590f, 0.00441635f, 0.03020966f, 
    -0.06765872f, -0.05573474f, -0.04102051f, -0.06642310f, 0.04432961f, -0.05415021f, 0.05453820f, -0.01296303f, 
    -0.05769531f, 0.03979871f, -0.07872608f, 0.04294442f, -0.03027926f, 0.03929013f, -0.01304982f, -0.01980569f, 
    -0.07698177f, -0.03093430f, -0.03064443f, 0.01138598f, 0.06402108f, -0.03062822f, -0.03370124f, -0.00903247f, 
    0.02685499f, -0.01192151f, 0.05304525f, -0.07870460f, -0.05335291f, -0.04107138f, 0.01627563f, 0.00300464f, 
    -0.04897798f, 0.01029107f, -0.04074968f, -0.07064038f, 0.05384152f, 0.03145739f, -0.01598104f, 0.05317024f, 
    -0.06487036f, 0.02125013f, -0.02501759f, 0.02038455f, -0.01039158f, -0.05098301f, -0.06105762f, -0.00276029f, 
    -0.03968384f, -0.02978083f, 0.00313717f, -0.06693860f, -0.01122633f, 0.02678721f, -0.04094619f, -0.04976564f, 
    -0.07443405f, 0.00828683f, -0.06733097f, -0.04306699f, -0.07376025f, -0.07430097f, 0.00339262f, 0.03117263f, 
    0.07937339f, 0.56391889f, 0.30896834f, 0.28041571f, -0.16906670f, -0.15580834f, -0.12796387f, -0.07195391f, 
    -0.03621424f, 0.00852282f, -0.06820942f, -0.16257012f, 0.16813651f, 0.03613375f, -0.08739641f, -0.01733565f, 
    -0.20111619f, -0.08950779f, -0.20440254f, 0.02875855f, 0.16890885f, 0.18807244f, 0.17767856f, 0.06636397f, 
    0.08961803f, -0.00781037f, -0.02429131f, 0.20584084f, 0.09095927f, 0.08385251f, 0.07751007f, -0.11441758f, 
    0.10884543f, 0.00789511f, 0.00472447f, 0.10682420f, 0.05606022f, -0.08502344f, 0.05705595f, -0.04537766f, 
    0.08877241f, 0.13640666f, 0.08344320f, 0.09632371f, 0.08276159f, -0.03386902f, -0.06124562f, -0.14181969f, 
    -0.08061428f, 0.08271548f, -0.01877171f, -0.08028568f, 0.11674681f, 0.22209296f, -0.09529146f, -0.04256144f, 
    -0.05611758f, -0.50210708f, -0.09632342f, -0.07767862f, -0.07653119f, -0.19155239f, -0.11834362f, 0.03565230f, 
    -0.21806479f, -0.02304888f, 0.03394995f, -0.04081387f, -0.02806408f, -0.07068453f, 0.01098009f, 0.00678076f, 
    -0.12026334f, 0.12760474f, -0.02766976f, 0.11865673f, -0.03778842f, 0.05035513f, 0.17951804f, -0.06050480f, 
    0.18462127f, 0.15186048f, 0.18181220f, 0.33612558f, 0.04671944f, -0.18819876f, 0.16895229f, -0.20944273f, 
    -0.05728943f, -0.08586781f, -0.12862065f, -0.00074523f, -0.09685462f, 0.03036377f, 0.08372173f, 0.06195582f, 
    0.20047836f, -0.02373181f, -0.06922740f, 0.20644264f, 0.02901655f, 0.17279106f, 0.04955276f, 0.06886795f, 
    0.05867711f, 0.10612325f, 0.32928658f, 0.20359403f, 0.20284557f, 0.02808636f, 0.03427055f, 0.12577800f, 
    0.00530704f, -0.01690842f, 0.08205298f, -0.02496551f, 0.00912635f, 0.13654956f, 0.01326473f, 0.34016603f, 
    -0.07876809f, -0.18630938f, -0.03880147f, 0.11132079f, 0.02535199f, 0.10000905f, -0.10181330f, -0.12598477f, 
    0.07185288f, 0.13322344f, 0.16670464f, 0.16180055f, 0.12246830f, 0.32641831f, 0.06503106f, 0.08316747f, 
    0.11306714f, -0.06992440f, -0.09089687f, 0.11160225f, 0.06534776f, 0.08418926f, 0.19869244f, -0.01913234f, 
    0.01792745f, -0.13108318f, -0.14827883f, 0.06827995f, 0.00552192f, -0.15010722f, -0.03526057f, -0.01226150f, 
    -0.06827381f, 0.03225865f, -0.13343894f, -0.21030213f, -0.19043714f, 0.17304917f, -0.13848221f, 0.02189647f, 
    -0.03319339f, 0.10027903f, -0.01519128f, 0.00303937f, 0.00052221f, -0.01388957f, -0.07854986f, -0.05327921f, 
    -0.17634648f, -0.05188031f, -0.11861653f, -0.13436255f, -0.07388214f, 0.06662178f, -0.00719508f, -0.13667127f, 
    -0.06638827f, 0.00230880f, 0.01635711f, -0.00700556f, -0.01083307f, -0.24631934f, -0.14330210f, 0.23330827f, 
    0.02668832f, 0.10798869f, 0.17783886f, -0.01577518f, 0.05187243f, -0.05202986f, -0.10736521f, -0.00064206f, 
    -0.03778977f, 0.35581800f, 0.47847393f, 0.03738786f, -0.05132545f, -0.00354952f, 0.01927958f, 0.16008906f, 
    -0.00669374f, -0.07556695f, -0.12864012f, -0.11765905f, -0.18405789f, -0.21348202f, -0.00808274f, 0.19492866f, 
    0.06030256f, -0.01306251f, -0.04646867f, -0.22178277f, 0.07796542f, 0.00123134f, 0.06599323f, 0.10567419f, 
    0.19911136f, 0.03133415f, -0.34610695f, 0.05984806f, 0.05680823f, 0.15735511f, -0.08678974f, 0.07302503f, 
    0.02863028f, 0.20698380f, -0.14010911f, -0.07261986f, -0.04077204f, 0.08002608f, -0.32177833f, -0.18404509f, 
    0.02149710f, 0.15470257f, 0.01694276f, -0.03403812f, 0.15094875f, 0.11095960f, 0.06168802f, 0.07841701f, 
    -0.08509551f, 0.08461986f, 0.00370633f, 0.12870815f, 0.10775394f, 0.08176322f, -0.04751370f, 0.02734649f, 
    0.17862302f, 0.12967640f, 0.06799648f, -0.04276095f, -0.07086379f, -0.09368624f, -0.08289105f, 0.17274132f, 
    -0.01907285f, -0.00480527f, 0.11939205f, 0.06570040f, 0.02042382f, -0.03806880f, 0.07870658f, 0.08927133f, 
    0.06838452f, 0.13920455f, 0.03118964f, 0.11391079f, 0.03428472f, 0.05095569f, 0.04267870f, 0.06694587f, 
    -0.01278263f, 0.04151309f, -0.14125720f, -0.11324468f, -0.06082704f, -0.10078873f, -0.13094665f, 0.02207905f, 
    -0.16298532f, 0.00494941f, -0.05780136f, 0.03414997f, 0.00539433f, -0.09773561f, -0.05241556f, -0.08199293f, 
    -0.25484422f, 0.00136554f, 0.38835388f, 0.16281772f, 0.05753404f, 0.01127398f, -0.08151913f, 0.10933881f, 
    -0.00963930f, -0.12288467f, 0.01659557f, 0.01227205f, -0.07213904f, 0.04475199f, -0.04834416f, 0.11920775f, 
    -0.01787740f, -0.23359454f, 0.14063565f, 0.12254280f, -0.00921083f, -0.03133698f, -0.06536083f, -0.00946566f, 
    -0.26048714f, 0.05648038f, -0.01720403f, 0.02103903f, 0.05454879f, 0.02338800f, -0.13588752f, 0.05502729f, 
    0.08502521f, -0.02904225f, 0.06855688f, 0.06108509f, -0.03192414f, 0.25530180f, 0.19271718f, 0.39646766f, 
    0.07865679f, -0.12971963f, -0.09910755f, -0.03805080f, 0.00276003f, 0.07536550f, 0.03659230f, 0.14820981f, 
    0.05017496f, -0.00806510f, 0.08818214f, -0.03018317f, -0.19082496f, -0.01837385f, 0.03698862f, 0.05838485f, 
    0.06800171f, -0.08779395f, 0.12143788f, -0.01539231f, 0.09504244f, -0.04273749f, -0.06494091f, 0.26115528f, 
    0.02829476f, 0.06493223f, 0.06416723f, 0.03914071f, -0.00775431f, 0.08149872f, 0.04170600f, 0.06307670f, 
    -0.12956601f, -0.03832262f, -0.03182799f, -0.08441368f, 0.10287526f, -0.03241211f, -0.17431493f, -0.01518215f, 
    0.15467015f, 0.03614950f, 0.07199861f, -0.01557963f, 0.21709889f, -0.03537115f, -0.06343747f, 0.09065592f, 
    0.12250053f, -0.04959087f, 0.01857054f, -0.12534411f, 0.02686144f, 0.04603180f, -0.13860336f, -0.12556303f, 
    0.18385802f, 0.05042128f, -0.02919159f, 0.05165614f, 0.02988874f, -0.08375191f, 0.10306396f, -0.07029228f, 
    -0.06838625f, 0.11483745f, -0.06339055f, 0.14374679f, -0.27511558f, -0.05561351f, -0.04024144f, 0.00393761f, 
    0.15605085f, -0.16231136f, 0.00587772f, -0.13131601f, 0.03465061f, -0.14901978f, 0.21290207f, 0.13742980f, 
    -0.36855799f, -0.08471418f, 0.06745886f, 0.01017204f, -0.00319578f, -0.09807299f, -0.22148402f, 0.04028887f, 
    0.02516261f, -0.02851435f, 0.04858838f, 0.03147543f, -0.57649565f, -0.08705283f, -0.11529912f, -0.26208353f, 
    0.10938718f, 0.10918682f, -0.15226869f, -0.08060363f, 0.06822667f, -0.09717371f, 0.07952327f, 0.02169938f, 
    -0.08200738f, -0.12124787f, 0.13374986f, 0.16085656f, 0.05788168f, 0.13679788f, 0.10941352f, -0.03045285f, 
    0.05794851f, -0.11787647f, -0.05084589f, -0.25266701f, 0.10770690f, 0.26042828f, 0.21595109f, -0.08303358f, 
    0.04594149f, 0.05601833f, -0.10027324f, 0.11861666f, 0.05072368f, -0.03358389f, 0.19918422f, 0.08275493f, 
    -0.03675728f, 0.03009439f, -0.02637817f, 0.04861333f, 0.07806887f, 0.18744980f, 0.11280960f, -0.05716555f, 
    -0.01446169f, 0.07761001f, 0.15285610f, 0.02273609f, -0.35732663f, -0.16943714f, 0.03708261f, 0.05454578f, 
    0.02525608f, -0.06842428f, -0.23502429f, -0.06169418f, 0.05058787f, -0.08660446f, 0.07826832f, 0.04301865f, 
    0.14488830f, -0.03471903f, 0.10312278f, -0.03866361f, -0.17301191f, -0.06822412f, -0.01529602f, 0.09247296f, 
    0.11993134f, 0.07216740f, -0.03479910f, 0.00581791f, 0.12843269f, -0.00500741f, 0.23977201f, 0.30620274f, 
    0.10303398f, 0.16413210f, -0.02230990f, -0.00177717f, 0.04945716f, 0.08074301f, -0.07628588f, 0.14048171f, 
    0.05645441f, 0.19838534f, 0.13195020f, -0.02234222f, 0.02580180f, -0.03622006f, 0.16346914f, 0.11248496f, 
    -0.01993183f, -0.04107331f, 0.05779988f, 0.12368989f, 0.21005504f, -0.20738895f, 0.04563547f, 0.28768176f, 
    -0.22779384f, -0.16343080f, 0.04035396f, -0.04187331f, 0.00663692f, 0.06841011f, -0.03527414f, -0.02080825f, 
    0.25643772f, 0.13099997f, 0.02980674f, 0.04325649f, 0.16297108f, 0.05362318f, 0.15461245f, 0.05892537f, 
    -0.05220226f, -0.14140692f, 0.06517565f, -0.05022653f, 0.20314194f, -0.12749422f, 0.11651484f, 0.11950916f, 
    -0.01972943f, -0.08232266f, 0.24783468f, -0.12478670f, -0.00395721f, 0.09704258f, -0.00973403f, -0.01347858f, 
    -0.21301802f, -0.19597471f, -0.32384944f, 0.32351235f, -0.18507402f, -0.01342799f, -0.02622476f, -0.10834037f, 
    0.00834501f, 0.01478960f, -0.05405317f, -0.03936773f, 0.23509836f, 0.17220409f, 0.11626735f, -0.19794013f, 
    0.22750880f, -0.02143136f, -0.30839735f, 0.01394465f, 0.01189586f, 0.01023402f, -0.03403299f, 0.08430281f, 
    -0.03902760f, -0.47381571f, -0.19341791f, -0.16325599f, 0.05568069f, -0.02141798f, 0.08953936f, 0.05003624f, 
    0.02571044f, 0.09277134f, 0.04710831f, 0.12217338f, 0.03823654f, 0.09738555f, 0.09395900f, 0.02430547f, 
    0.04704833f, -0.02096455f, 0.08272190f, -0.02116374f, 0.02549381f, -0.02487848f, 0.07473304f, 0.12233056f, 
    -0.07863026f, 0.17980328f, 0.23301779f, -0.04778451f, 0.22155979f, -0.14399460f, 0.15790284f, 0.11746978f, 
    -0.04113460f, -0.01635250f, -0.03621631f, -0.04683640f, -0.29013968f, -0.04099026f, 0.16360049f, 0.00411011f, 
    -0.04750758f, 0.09512887f, -0.15850857f, -0.00376714f, -0.17153682f, -0.02128518f, -0.10449682f, 0.07508989f, 
    -0.11100622f, -0.07670967f, 0.06349506f, -0.05604663f, 0.15213767f, 0.07517484f, 0.03546076f, -0.21793757f, 
    0.02882941f, 0.05162305f, 0.04766603f, -0.02800677f, 0.15061724f, 0.27699339f, 0.28934491f, -0.06476234f, 
    0.11031973f, 0.01482338f, -0.00638303f, 0.16085270f, -0.01166070f, 0.01770639f, 0.15665285f, 0.07274702f, 
    0.12422342f, -0.06802500f, -0.00675261f, -0.12976933f, 0.15596314f, -0.03663880f, 0.07074696f, 0.04717042f, 
    -0.12382407f, -0.01025718f, 0.21133210f, -0.07583456f, -0.16658713f, 0.12215549f, 0.17568117f, 0.45385787f, 
    0.01108058f, -0.09176337f, 0.06882702f, -0.00462541f, -0.09074593f, -0.05911734f, -0.02208600f, 0.02328101f, 
    0.38021019f, 0.23626417f, -0.16639264f, -0.12757388f, 0.12343422f, -0.00545022f, 0.16026537f, -0.00300332f, 
    0.08490603f, 0.03676960f, -0.01799619f, 0.01889664f, 0.02794433f, 0.02725562f, 0.07673825f, -0.15777192f, 
    -0.03110511f, 0.09861286f, -0.00489921f, 0.05132795f, -0.04935231f, 0.13407527f, -0.00166299f, -0.03256064f, 
    0.16757460f, 0.25175044f, -0.02159527f, 0.01197547f, 0.13197136f, 0.00056122f, 0.14301284f, 0.17117637f, 
    0.06682212f, -0.02109379f, -0.03740254f, 0.05301319f, 0.20243025f, -0.03984343f, -0.13785480f, 0.03083859f, 
    -0.05119657f, -0.00266347f, -0.00257829f, -0.24391982f, 0.02781763f, -0.00955261f, 0.00029210f, 0.02263759f, 
    0.14064775f, 0.07361636f, -0.12373774f, -0.05879791f, 0.15874426f, 0.06922127f, 0.09060092f, 0.09188051f, 
    0.01445376f, 0.00703129f, -0.04652008f, 0.04819242f, 0.26411095f, 0.08105125f, 0.04858552f, -0.01166192f, 
    0.15047009f, -0.13683906f, 0.19111586f, -0.01259404f, 0.08021669f, 0.09028715f, -0.03532467f, -0.01644228f, 
    0.08908416f, 0.00059744f, 0.03620929f, 0.19939585f, -0.10643785f, 0.03985561f, 0.01363544f, -0.20545416f, 
    0.02790361f, 0.02277456f, 0.09776599f, 0.05365398f, 0.23188524f, 0.40622935f, 0.02003177f, -0.22543991f, 
    0.01744804f, -0.06597392f, 0.06933554f, 0.14356084f, 0.00186215f, 0.05831454f, -0.00750041f, 0.01183608f, 
    -0.17865261f, 0.00795271f, -0.09392096f, -0.07143319f, -0.07641009f, 0.00436952f, 0.04200452f, 0.00401978f, 
    -0.01943862f, 0.12200519f, 0.00031259f, -0.06432690f, -0.01750506f, -0.02078261f, -0.03497921f, -0.20368873f, 
    0.08080399f, -0.07396770f, 0.05695648f, 0.03515988f, -0.07932916f, -0.08058438f, 0.09268009f, 0.10352942f, 
    0.04203541f, -0.01189437f, 0.06155310f, -0.03763499f, 0.21290363f, 0.03380161f, 0.07345147f, 0.06254050f, 
    -0.12194315f, 0.00609745f, -0.02604894f, -0.00262328f, -0.19512327f, 0.00864150f, 0.02877426f, -0.09657286f, 
    -0.00406640f, 0.05422271f, -0.04903634f, -0.05538258f, 0.06544058f, -0.06437591f, 0.03753610f, 0.22039928f, 
    -0.07002029f, -0.02134236f, -0.03175762f, 0.04832008f, 0.17929047f, -0.01799759f, -0.08015857f, -0.09136768f, 
    0.06159593f, 0.13020055f, 0.11767479f, 0.18019344f, 0.02605540f, 0.16415152f, 0.17587036f, 0.04224775f, 
    0.15849927f, 0.14868969f, 0.00596492f, 0.13862334f, -0.11819483f, 0.01019007f, 0.12925719f, 0.10237984f, 
    0.05910289f, -0.06827191f, -0.04479495f, -0.02499063f, -0.03104508f, -0.00445626f, 0.06325765f, 0.07009469f, 
    -0.15000270f, -0.14027317f, 0.06549408f, -0.33059815f, -0.64059561f, 0.08212502f, 0.07396913f, 0.04247232f, 
    0.04649536f, -0.05398526f, -0.03783103f, 0.00391919f, -0.15222976f, -0.02770711f, -0.13486929f, -0.07471170f, 
    0.19809350f, 0.27947885f, -0.11725125f, -0.24690242f, 0.00064422f, -0.17155389f, 0.26662180f, 0.09034584f, 
    -0.01460674f, -0.09432077f, -0.03510844f, 0.07108759f, 0.12753549f, -0.06741069f, 0.03166316f, 0.17570233f, 
    0.00707141f, 0.02661687f, 0.14612581f, 0.09778842f, -0.21495301f, 0.07832384f, -0.18473698f, -0.19313855f, 
    0.14450087f, 0.18808264f, -0.12766908f, -0.01478123f, 0.05663872f, -0.02621507f, 0.01077867f, 0.09736829f, 
    0.05012796f, 0.07172256f, 0.03178656f, -0.07706539f, 0.15741406f, -0.01649105f, -0.10425337f, -0.04845092f, 
    -0.07816722f, -0.14136197f, 0.03697720f, -0.03470454f, 0.10996269f, 0.04520266f, 0.04158656f, 0.06644809f, 
    0.11189241f, -0.01825553f, -0.04230197f, -0.18509316f, -0.04710772f, 0.19742431f, 0.10788517f, 0.04903365f, 
    0.04610235f, -0.01318446f, -0.00701063f, 0.04940911f, 0.21154056f, -0.02350253f, -0.09748322f, 0.27188793f, 
    0.12134475f, -0.06780406f, 0.18402350f, 0.09480787f, 0.12719105f, 0.03829173f, -0.04909060f, 0.08319402f, 
    -0.13392949f, 0.10348482f, -0.04388055f, 0.04446720f, 0.00433001f, 0.02626218f, -0.03952965f, -0.05436899f, 
    0.00491519f, 0.15016384f, 0.21416607f, 0.16424091f, 0.28462875f, -0.11065173f, -0.11551438f, -0.20393738f, 
    0.03648748f, -0.06992508f, -0.06176240f, 0.05913107f, 0.14426495f, -0.02823089f, 0.01908897f, 0.03739341f, 
    -0.06169624f, -0.06422803f, 0.00915273f, -0.00580471f, -0.04064804f, 0.02538016f, 0.05479255f, 0.00651047f, 
    0.00208841f, 0.05249631f, -0.03943799f, 0.00239999f, -0.05453847f, 0.02444980f, 0.05652716f, 0.00146945f, 
    -0.06588046f, 0.06130438f, 0.06292973f, 0.00238550f, -0.01993287f, 0.02884904f, -0.00064173f, -0.03997912f, 
    0.01178214f, -0.05851601f, -0.06919160f, 0.04291799f, -0.07405506f, 0.05176868f, 0.05084935f, -0.00051037f, 
    0.05365443f, -0.06418975f, 0.02829705f, 0.05710222f, -0.02442184f, -0.05646157f, -0.04358996f, -0.07269341f, 
    -0.04059346f, -0.02164949f, -0.02776128f, -0.07018711f, 0.06566891f, 0.06398772f, 0.01767267f, -0.03741458f, 
    -0.05328475f, 0.01043397f, -0.02565357f, -0.00645684f, -0.01199288f, -0.07714662f, 0.01671275f, -0.06563216f, 
    -0.07643884f, -0.03109564f, -0.00794997f, -0.06988997f, -0.05056245f, -0.06187934f, 0.04890264f, -0.02047890f, 
    -0.02876625f, -0.06445432f, 0.05858136f, -0.07088611f, -0.00333427f, -0.07764892f, -0.00675162f, -0.00506860f, 
    -0.01891498f, -0.01409005f, -0.05557132f, 0.02229564f, -0.00794175f, 0.03172367f, 0.00597167f, 0.03498874f, 
    -0.01389684f, 0.05929289f, 0.06320984f, -0.06455410f, -0.04467159f, -0.05241102f, 0.04174138f, -0.01360307f, 
    0.00739530f, -0.07670830f, 0.02810881f, -0.00376785f, 0.03781822f, -0.06062251f, -0.03161930f, -0.07199325f, 
    0.02462162f, 0.03427140f, -0.06387208f, -0.01314304f, -0.01955668f, -0.07017052f, 0.04443165f, -0.00520268f, 
    -0.01260381f, 0.00164169f, 0.04961630f, -0.06739847f, -0.02672339f, 0.01602495f, 0.00143278f, 0.02266636f, 
    0.03220512f, 0.04129724f, -0.03860932f, -0.05502579f, -0.07574560f, 0.04697799f, -0.02861751f, -0.04743736f, 
    0.04538233f, -0.02795233f, -0.05792099f, -0.06181853f, -0.02828664f, 0.00641302f, -0.05485424f, 0.06202209f, 
    0.03546875f, 0.03981954f, -0.04204153f, 0.01694007f, 0.02244954f, -0.05879176f, -0.01202720f, -0.06272539f, 
    -0.06952906f, -0.04170483f, 0.04234500f, 0.01988297f, -0.03841693f, -0.01563072f, -0.01409176f, 0.00370622f, 
    0.01701471f, 0.05190019f, -0.07135233f, 0.05384899f, 0.01712898f, -0.01590038f, -0.04415456f, -0.00694921f, 
    0.06438148f, 0.04314939f, 0.04964671f, 0.06147152f, -0.05170611f, 0.05632441f, -0.02021258f, -0.00934793f, 
    0.01734549f, 0.04720072f, 0.04443467f, -0.07003307f, -0.02011088f, -0.04121533f, 0.03673881f, -0.03804704f, 
    0.06127734f, -0.02160763f, 0.03743121f, -0.00965598f, -0.03388822f, 0.04512387f, -0.06043631f, -0.01705981f, 
    -0.03786571f, -0.07729699f, -0.00862980f, -0.04970814f, -0.02910047f, 0.04753082f, -0.03971595f, -0.00520796f, 
    -0.03383277f, -0.00565979f, 0.01860491f, 0.02761786f, -0.03512390f, -0.02432724f, -0.04980409f, 0.07104015f, 
    -0.17899965f, 0.19323829f, 0.20995106f, 0.17144583f, -0.06145957f, -0.14279042f, -0.07327728f, -0.11491990f, 
    -0.10954733f, -0.02390469f, 0.00368225f, -0.03762121f, 0.24595757f, -0.04809285f, 0.15283650f, -0.19750752f, 
    -0.06252503f, 0.01293068f, -0.10119116f, 0.11204688f, 0.14709438f, 0.14040817f, 0.16299583f, -0.02753738f, 
    0.23588160f, 0.00782196f, 0.07847061f, 0.14117695f, -0.03364871f, 0.14965019f, 0.14690633f, 0.00966534f, 
    0.05802909f, -0.07264091f, -0.04476003f, 0.04510074f, 0.05994573f, -0.06577937f, -0.10606897f, -0.10483948f, 
    -0.02565959f, 0.06162082f, 0.04559594f, -0.01506626f, -0.02325615f, -0.03062997f, 0.05927886f, 0.04493701f, 
    0.03652820f, -0.13294500f, -0.17106338f, -0.02077010f, 0.11248875f, 0.15312915f, -0.22781803f, 0.01130800f, 
    -0.19336176f, -0.30282515f, -0.02483997f, -0.15534960f, -0.12546289f, -0.13927712f, -0.13804364f, 0.06834210f, 
    0.02119029f, -0.04735005f, 0.05883205f, 0.06254512f, 0.01143311f, 0.06663247f, -0.08199690f, 0.00784445f, 
    -0.00244451f, -0.12445575f, -0.03523462f, 0.03715743f, -0.02440578f, 0.00528058f, 0.07738137f, 0.04436483f, 
    0.20810473f, 0.13992395f, 0.24775131f, 0.22832945f, 0.02659590f, -0.05862050f, 0.16305371f, -0.26964217f, 
    -0.05851516f, 0.03275248f, 0.01891467f, 0.09186737f, -0.15402001f, 0.04352692f, 0.02995696f, 0.09053213f, 
    0.32799250f, 0.06924560f, -0.29079384f, 0.19065413f, 0.16649261f, -0.05877013f, 0.04373059f, 0.08044359f, 
    0.06484230f, 0.03012606f, 0.27961713f, 0.19687727f, 0.31657416f, -0.09945122f, -0.07002172f, 0.03471141f, 
    -0.11044412f, 0.05886407f, -0.01480928f, -0.02930561f, 0.12161069f, 0.11956992f, 0.20011912f, 0.17178467f, 
    -0.08102033f, 0.00575120f, -0.15029283f, 0.03727129f, 0.14356607f, 0.01982633f, -0.00108033f, 0.10915743f, 
    -0.06555088f, 0.11946040f, 0.11872698f, 0.08351813f, 0.13480346f, 0.27621201f, -0.02176612f, 0.05231445f, 
    0.10957099f, -0.04228051f, -0.18855719f, -0.09957902f, 0.01833742f, 0.08451900f, 0.09038714f, -0.10903414f, 
    -0.23249489f, -0.23332113f, -0.07463402f, 0.00607494f, -0.05955451f, -0.18026085f, 0.08069587f, -0.04307074f, 
    -0.11049839f, 0.04332999f, -0.15209255f, -0.01320364f, -0.10445894f, 0.14105645f, -0.21043850f, 0.05349583f, 
    0.07602397f, 0.01307418f, 0.02868551f, 0.10047933f, -0.08303051f, -0.08324181f, -0.07709437f, -0.09866948f, 
    0.00462244f, 0.00514231f, -0.03468103f, 0.07255851f, -0.02144946f, 0.04799321f, -0.17603149f, -0.30308563f, 
    -0.00090862f, -0.07977404f, 0.00980107f, -0.14785641f, 0.18903230f, -0.24944709f, -0.08733553f, 0.22181427f, 
    0.01544906f, 0.15385164f, 0.06623285f, 0.15411125f, 0.03392129f, -0.11272501f, -0.11487354f, 0.01180847f, 
    0.27474988f, -0.10137413f, 0.17612846f, -0.16600420f, 0.11363764f, -0.06206402f, 0.04570758f, 0.04852735f, 
    0.10264906f, -0.03984906f, -0.08011812f, -0.06055690f, -0.08262641f, -0.35285121f, 0.13637687f, 0.19207205f, 
    0.00632877f, 0.11331510f, -0.06058374f, -0.25023228f, 0.16145444f, -0.00826812f, 0.00572224f, 0.03898659f, 
    -0.14477091f, -0.22898181f, -0.00794932f, 0.06141433f, -0.02039201f, 0.10503843f, -0.12099808f, 0.02195042f, 
    0.02429904f, 0.17956875f, 0.03560546f, 0.03356254f, -0.00438688f, -0.00291802f, -0.40311661f, -0.19874762f, 
    0.15837343f, -0.11376504f, -0.02200490f, 0.04164701f, 0.10628525f, 0.12520099f, 0.00798414f, -0.06297339f, 
    -0.20066902f, -0.05236329f, 0.12756589f, 0.14421149f, 0.00558983f, -0.08851819f, 0.16109891f, 0.07151347f, 
    -0.01225554f, 0.02774191f, -0.22523981f, -0.25033191f, 0.07545747f, 0.11943967f, 0.04136568f, 0.15181881f, 
    0.08944440f, 0.10179381f, 0.12197825f, 0.05530239f, 0.03435259f, 0.09006222f, 0.04484161f, 0.13502985f, 
    0.18544692f, 0.05038012f, 0.20427290f, -0.02059611f, 0.00062970f, 0.07748038f, 0.02228522f, 0.04677892f, 
    -0.04825313f, 0.30087671f, 0.07843731f, -0.00346303f, -0.01541221f, 0.04182108f, -0.39815366f, 0.29516643f, 
    0.03737545f, 0.09910233f, 0.01716019f, 0.03420083f, 0.02682524f, -0.08913213f, 0.01847350f, -0.11728755f, 
    -0.15814313f, -0.18386479f, 0.48172399f, 0.07256114f, -0.05023480f, -0.00829959f, -0.00019569f, 0.15796344f, 
    -0.06554418f, 0.01079188f, 0.01219121f, -0.10157975f, -0.27341020f, -0.10016654f, -0.21996248f, -0.18150054f, 
    0.09295598f, -0.02157044f, 0.07882010f, 0.09141230f, 0.11585234f, -0.07345062f, 0.01412280f, 0.07080197f, 
    0.07280748f, 0.15338191f, 0.27555507f, 0.05516675f, -0.14490278f, 0.01814712f, -0.02295809f, 0.12353494f, 
    0.04820197f, -0.07162825f, 0.03972026f, 0.21786682f, -0.03199270f, -0.15630794f, 0.10288059f, 0.32418242f, 
    -0.08612955f, -0.09130460f, -0.17888461f, -0.05619974f, 0.11400014f, 0.03802649f, 0.06484720f, 0.06213394f, 
    0.20501696f, 0.31021816f, 0.25528920f, -0.04755858f, 0.02225198f, 0.12443809f, 0.00105768f, 0.19170494f, 
    -0.08078726f, -0.03531348f, 0.08180910f, -0.13159923f, 0.15144351f, -0.17211364f, 0.13471001f, -0.01868216f, 
    0.14824387f, 0.06068712f, 0.17256740f, 0.01172590f, -0.01984704f, -0.00414731f, -0.14193822f, -0.06469939f, 
    0.03597223f, -0.28230539f, 0.06201768f, 0.05640545f, 0.10160133f, -0.10755020f, -0.08764466f, -0.00874319f, 
    0.01428667f, 0.12697610f, -0.00615571f, 0.05344952f, 0.21352467f, 0.12871660f, 0.26078892f, -0.03920339f, 
    0.03986367f, -0.07392401f, 0.04841477f, -0.17285141f, 0.13032538f, 0.03501303f, -0.00287413f, 0.02682744f, 
    0.21098404f, 0.02104139f, -0.16800007f, 0.05406186f, -0.02191062f, 0.08091900f, 0.11915447f, -0.00903799f, 
    -0.02599587f, 0.13177830f, -0.07714022f, -0.01966821f, -0.25936773f, -0.08174581f, -0.31642246f, -0.35709801f, 
    -0.00864400f, -0.09030733f, -0.00464057f, 0.01800946f, -0.09926387f, 0.04198435f, -0.00927124f, -0.08820441f, 
    -0.40031353f, -0.02705883f, 0.05902033f, -0.26184484f, 0.07226458f, 0.00145426f, 0.06436332f, 0.08256150f, 
    -0.01264379f, -0.04870858f, 0.00688615f, 0.09372178f, -0.16780402f, -0.13756809f, 0.08023837f, -0.06863123f, 
    0.05329230f, 0.12240033f, -0.14037299f, 0.02320322f, -0.00915510f, -0.02606731f, 0.04749359f, 0.14861292f, 
    -0.00483243f, 0.09733541f, 0.18518187f, -0.01446026f, 0.14148809f, 0.03843800f, 0.05588623f, 0.02902143f, 
    0.06049110f, 0.11100908f, 0.05400871f, 0.09906825f, 0.15987697f, 0.27876025f, 0.16379885f, -0.11939432f, 
    0.17134802f, 0.04437481f, -0.10157987f, 0.08726355f, 0.04683784f, -0.00136105f, 0.00849723f, -0.07379287f, 
    0.09558370f, -0.00218763f, -0.02157941f, -0.09171476f, 0.17211133f, 0.03696126f, 0.10789955f, -0.03680948f, 
    -0.02444593f, -0.03501702f, 0.11403957f, -0.04611721f, -0.56940979f, -0.37736034f, -0.17364769f, -0.14237413f, 
    -0.10743298f, -0.08121446f, -0.11447255f, -0.08299717f, -0.04535085f, -0.10979271f, 0.08045086f, 0.03888573f, 
    0.14884613f, 0.06535530f, 0.11410970f, 0.07720824f, -0.00074850f, -0.10915810f, 0.12579226f, 0.05561161f, 
    0.09122755f, -0.05577441f, -0.04759911f, -0.07784732f, 0.10373890f, 0.01765679f, 0.21496820f, 0.08448337f, 
    0.07436564f, 0.13128561f, -0.11583468f, 0.05920868f, 0.07182234f, 0.13935331f, -0.07362796f, -0.13288204f, 
    0.23140030f, 0.06118218f, 0.00411858f, 0.09137008f, -0.01132723f, -0.01766389f, 0.03937960f, 0.04531195f, 
    0.01570328f, -0.08087840f, -0.23314606f, 0.00928555f, -0.10342167f, -0.23876193f, -0.15949596f, -0.06367189f, 
    -0.06825126f, 0.04764068f, 0.11181803f, 0.11915097f, 0.13027601f, 0.24502087f, 0.00098690f, -0.15961139f, 
    0.23802423f, 0.16452567f, 0.05397996f, 0.05833363f, 0.15962341f, -0.02224324f, 0.10799374f, 0.02370383f, 
    0.02855058f, -0.06706738f, 0.03583130f, 0.04704022f, 0.05007027f, 0.06101650f, 0.20402360f, -0.11773319f, 
    0.07240444f, 0.06528609f, 0.16217177f, -0.08829266f, 0.02726955f, 0.05026819f, 0.07340399f, -0.00447449f, 
    -0.31908500f, -0.25010008f, -0.22802477f, -0.17779841f, -0.02194620f, 0.05397344f, 0.12296242f, 0.05210285f, 
    -0.02277666f, 0.19711624f, 0.09750414f, 0.14023840f, 0.20123871f, 0.25015241f, -0.01416622f, -0.02046333f, 
    -0.04824766f, 0.04000372f, -0.08188577f, 0.13910733f, -0.01095343f, 0.00880215f, 0.11395700f, 0.03863072f, 
    -0.05154157f, 0.01949453f, 0.03953334f, -0.04123168f, -0.05106695f, -0.05783909f, -0.00793743f, -0.05765076f, 
    -0.08017783f, 0.05001711f, -0.03583576f, -0.03775306f, 0.05176639f, -0.07451572f, -0.00795741f, -0.05869716f, 
    -0.04864384f, -0.06926195f, -0.04398586f, 0.02285613f, 0.04274919f, 0.02895822f, 0.01431425f, 0.00880681f, 
    -0.04919252f, -0.06923299f, -0.05137612f, -0.05323677f, -0.05428414f, -0.03362042f, 0.05856299f, 0.02468303f, 
    0.02679984f, -0.07424472f, 0.04585938f, -0.02895339f, -0.00128351f, -0.02296909f, -0.06628836f, -0.00362303f, 
    0.04339629f, 0.05818285f, -0.01433449f, 0.00887703f, 0.02308847f, -0.04183312f, -0.06002401f, -0.03613129f, 
    0.01960772f, 0.00619008f, 0.02880656f, 0.01771025f, -0.00255948f, -0.01952001f, -0.04173076f, -0.05343231f, 
    0.00849053f, 0.03882940f, 0.00457476f, -0.04089015f, 0.02199558f, 0.00590961f, -0.00790330f, -0.00356564f, 
    0.00431115f, -0.05658984f, -0.03936876f, 0.00527823f, -0.00360825f, -0.02717849f, 0.02415547f, 0.04916695f, 
    -0.00749868f, 0.04076447f, -0.00220562f, 0.00435164f, -0.02430429f, 0.04878983f, -0.01696379f, -0.02711034f, 
    -0.01399623f, -0.02456249f, -0.02150020f, -0.05754948f, -0.03933238f, -0.04189385f, -0.02129483f, -0.07553943f, 
    -0.07287057f, -0.07442948f, -0.00910410f, -0.02757415f, -0.02661844f, 0.03681507f, 0.00040926f, -0.03651900f, 
    -0.07992605f, -0.05442176f, 0.00190563f, 0.03926172f, -0.05381695f, 0.04507016f, 0.05551404f, 0.03275793f, 
    -0.01858978f, 0.01686649f, 0.03473476f, 0.04457796f, -0.03884403f, 0.02048722f, 0.03862503f, -0.04668613f, 
    0.00469067f, 0.01812779f, 0.02637874f, -0.03100006f, -0.02748806f, 0.03827159f, 0.05090602f, 0.02324289f, 
    -0.03654715f, 0.01817448f, -0.00611123f, -0.05856464f, 0.04959080f, 0.01409760f, -0.03403063f, 0.00663831f, 
    -0.05531779f, 0.02842097f, -0.06170051f, -0.06305647f, -0.01138587f, -0.02055108f, 0.04310157f, 0.05970601f, 
    -0.07308067f, 0.05039388f, 0.03577180f, 0.05688068f, -0.01585390f, 0.01878302f, 0.05704942f, -0.06237644f, 
    -0.05482692f, -0.01272361f, -0.01974136f, -0.02135509f, 0.04797573f, -0.00368778f, 0.01000006f, 0.00561853f, 
    0.05431126f, 0.01714120f, -0.06858106f, -0.02921579f, 0.01052802f, 0.00484668f, -0.07496725f, -0.00137601f, 
    -0.07333735f, 0.02392976f, 0.03930946f, -0.05260550f, -0.03761315f, 0.04978978f, 0.06059647f, -0.00506129f, 
    -0.07230043f, -0.06314244f, -0.00762086f, -0.04237603f, 0.05508263f, 0.00673814f, 0.00768779f, -0.05163554f, 
    0.05224832f, -0.01787541f, -0.02450247f, -0.03887224f, 0.04181039f, -0.00348216f, -0.03089219f, -0.05494183f, 
    -0.02901894f, 0.00086642f, 0.00692114f, 0.03496978f, -0.03119738f, -0.00539699f, -0.01476052f, -0.01010705f, 
    0.14218853f, -0.51671547f, -0.34938613f, -0.14980169f, 0.01305189f, 0.04923665f, 0.05574496f, 0.11448175f, 
    0.19041662f, 0.14693813f, -0.19668247f, -0.16307385f, -0.01490985f, 0.14306280f, 0.13129304f, 0.04143054f, 
    -0.02535719f, -0.01226723f, 0.07995355f, 0.09214231f, 0.16911466f, 0.18675703f, -0.16270123f, 0.08240105f, 
    0.06518020f, 0.04164931f, 0.24992201f, 0.02358790f, 0.11057405f, 0.06222926f, 0.07064106f, 0.11675753f, 
    -0.07138366f, -0.06209401f, 0.02061467f, -0.00201232f, -0.01070683f, 0.04612069f, 0.16343038f, 0.02971913f, 
    0.18451373f, 0.05359161f, -0.12045362f, 0.11153253f, -0.14642587f, -0.04450233f, 0.04096901f, 0.04413307f, 
    -0.05684565f, -0.03195075f, 0.09686848f, -0.08713634f, 0.22325574f, 0.15492857f, 0.01682752f, -0.11919099f, 
    -0.04851276f, 0.09727312f, -0.11316165f, 0.00392444f, -0.07317451f, -0.00435944f, -0.24038741f, -0.15187618f, 
    0.10998721f, -0.00322413f, 0.15598966f, 0.01120684f, -0.10144167f, -0.02359012f, -0.00272209f, 0.10160647f, 
    0.09793650f, -0.05920877f, 0.00662814f, -0.20644341f, 0.05892590f, 0.12275077f, 0.01355837f, 0.06640166f, 
    0.11391068f, 0.10910595f, -0.12797679f, 0.06354650f, 0.37747923f, 0.31365958f, 0.07101306f, 0.32661596f, 
    0.04098203f, 0.08869474f, 0.07509893f, 0.11541149f, -0.13137986f, -0.12717518f, -0.02218761f, 0.07251477f, 
    -0.13502108f, -0.09734424f, -0.10428673f, -0.26804271f, -0.27051559f, -0.00342001f, 0.08479106f, -0.04652333f, 
    -0.08103831f, -0.11415416f, 0.14017454f, 0.11663616f, -0.31384638f, -0.25882369f, -0.17007300f, -0.15701905f, 
    0.02685283f, -0.03508098f, 0.04682960f, 0.10337521f, -0.04835080f, -0.01612636f, 0.07744599f, -0.11984146f, 
    -0.04686110f, -0.12102152f, -0.10831174f, -0.24526900f, -0.04984040f, 0.00784651f, 0.13320765f, 0.22428696f, 
    0.04122993f, 0.18864548f, 0.08790164f, 0.22826201f, -0.00265476f, -0.00421482f, 0.12638879f, -0.00117164f, 
    -0.13957895f, 0.09803468f, 0.07664384f, -0.06064277f, 0.17152524f, -0.00703104f, -0.14839427f, -0.03498315f, 
    -0.21625683f, -0.10139751f, -0.29121378f, -0.28743741f, 0.00867444f, 0.26544556f, -0.04754930f, -0.06672639f, 
    0.02762462f, 0.07459153f, 0.00135689f, 0.04619560f, 0.02656904f, -0.07650928f, -0.02875859f, -0.22126861f, 
    0.23259696f, 0.18754056f, 0.20435162f, -0.06963692f, -0.01567963f, 0.05011347f, -0.04739160f, 0.02544985f, 
    0.37049389f, 0.00724173f, 0.20700978f, 0.15472381f, -0.01112579f, 0.08005092f, 0.00900947f, 0.10246509f, 
    0.04956061f, 0.02455533f, -0.06338359f, 0.16095988f, -0.05126434f, 0.14580213f, 0.20868623f, -0.23966444f, 
    0.09740470f, 0.09219281f, 0.10562367f, -0.20947741f, -0.06275958f, 0.09478229f, 0.06014435f, 0.05621143f, 
    -0.07402942f, 0.05273021f, -0.05329659f, -0.01882105f, 0.00277526f, 0.03047897f, -0.03494977f, -0.01317112f, 
    0.04620522f, 0.00703983f, -0.01043531f, 0.00158662f, -0.06890772f, -0.02346365f, 0.05360561f, 0.00604916f, 
    -0.05586849f, -0.00645905f, -0.06181535f, -0.07614677f, 0.03041635f, 0.02089208f, 0.05488371f, -0.05685150f, 
    -0.06391908f, -0.01860298f, 0.00153742f, 0.01286331f, -0.00594980f, -0.06792388f, -0.07494179f, -0.00866103f, 
    0.05422435f, -0.00865771f, -0.03971984f, 0.05944855f, -0.00125985f, 0.05523473f, -0.03155568f, -0.03243171f, 
    0.03014858f, 0.05494256f, 0.02222700f, 0.01147416f, 0.03067677f, 0.03628467f, 0.02275674f, -0.07522824f, 
    0.05098090f, 0.04704928f, -0.05505158f, -0.06021942f, 0.04280680f, 0.01996166f, 0.02778257f, -0.02713557f, 
    0.03224124f, -0.05379732f, -0.04738075f, 0.02265392f, -0.08963083f, 0.02068358f, -0.02505703f, 0.01688076f, 
    0.01553641f, -0.02245430f, -0.01633464f, 0.05707204f, 0.01344812f, 0.01028694f, -0.06711282f, 0.03075346f, 
    -0.07229064f, -0.07160284f, 0.00664550f, -0.00570993f, -0.00744907f, 0.02868854f, 0.01058493f, -0.03749007f, 
    0.03146132f, -0.00649253f, -0.04185202f, -0.03849198f, 0.05313585f, 0.01011721f, -0.01942344f, -0.04251526f, 
    0.00732559f, -0.01615015f, -0.01900118f, -0.06253342f, -0.03360906f, 0.05289137f, 0.02221171f, -0.03414558f, 
    -0.08259111f, -0.03657730f, -0.07862950f, -0.06635088f, -0.01324170f, -0.03074611f, -0.05835333f, -0.01555815f, 
    0.01308194f, 0.02675933f, -0.06433643f, -0.05849791f, 0.03817224f, -0.04687574f, 0.03929099f, -0.00412119f, 
    0.02468192f, -0.00611068f, -0.04729823f, -0.05149857f, 0.03317351f, -0.00087289f, 0.05359806f, 0.04127038f, 
    0.04403867f, -0.07337514f, 0.03957467f, 0.00536529f, -0.02267238f, -0.05871423f, 0.02303866f, -0.02275734f, 
    0.01519258f, -0.01257764f, -0.08029002f, -0.01120822f, -0.02167290f, -0.00988414f, -0.05783639f, -0.06418805f, 
    -0.02753065f, 0.06425630f, 0.03265526f, -0.00165967f, -0.04811632f, -0.03980310f, -0.02984559f, 0.03033771f, 
    -0.02593852f, 0.03767744f, -0.05314954f, -0.01415324f, 0.04737466f, -0.03906765f, -0.00720349f, 0.04740416f, 
    -0.02866541f, 0.05103817f, -0.03045444f, 0.04688776f, -0.06914400f, -0.04242323f, 0.01618238f, 0.04889255f, 
    -0.07373008f, 0.05777215f, 0.04788891f, -0.05117930f, 0.06115200f, -0.07062255f, 0.03452652f, -0.07080661f, 
    -0.02100725f, -0.06132860f, -0.06061968f, -0.01596035f, -0.02972449f, 0.05670922f, 0.05295505f, 0.05937856f, 
    -0.02874705f, -0.07237252f, -0.02100015f, -0.00459793f, -0.01980086f, 0.01068653f, -0.03906567f, -0.01181989f, 
    -0.08456224f, 0.04533050f, 0.03822360f, -0.02837471f, -0.07213712f, -0.06153615f, -0.04345748f, -0.06130660f, 
    0.28789085f, 0.20048387f, 0.14681096f, -0.09874377f, 0.02225862f, -0.04437503f, -0.07378036f, -0.04896165f, 
    0.08296400f, -0.05006097f, -0.07999803f, 0.02934065f, 0.08578590f, -0.29588407f, -0.06050888f, 0.30945835f, 
    0.03301385f, 0.07086096f, 0.05948085f, -0.10999122f, 0.02681584f, -0.00003826f, 0.20846874f, 0.11795182f, 
    -0.26058456f, -0.01134233f, -0.03397602f, -0.03897197f, 0.21912242f, 0.00972036f, 0.02094218f, -0.01496391f, 
    0.00969019f, 0.02624918f, 0.11894136f, 0.01908604f, 0.01458687f, -0.01686994f, -0.00987555f, -0.04171879f, 
    0.10295809f, 0.12210163f, -0.00403775f, 0.18523610f, 0.14408334f, 0.01770920f, -0.10501038f, -0.06438491f, 
    -0.22988753f, -0.10921156f, 0.14263435f, 0.14449954f, 0.06221644f, 0.11009921f, 0.14491731f, 0.06912363f, 
    -0.04055005f, -0.29782817f, -0.11187458f, -0.29444280f, 0.07598428f, 0.14166412f, 0.04479749f, -0.18358009f, 
    -0.00445556f, 0.02460006f, 0.00469363f, -0.02020908f, 0.13638993f, 0.03041100f, 0.00660978f, 0.05682921f, 
    0.11075961f, 0.21010505f, 0.16415079f, -0.05397862f, 0.11112528f, 0.16952755f, 0.12015126f, -0.07465974f, 
    0.18852425f, 0.30615050f, 0.20329905f, 0.24796063f, 0.12218859f, -0.15113553f, -0.07882150f, 0.02316654f, 
    -0.01653255f, -0.12777320f, -0.08835743f, -0.07520694f, -0.08092167f, -0.04203106f, 0.04364217f, -0.04689453f, 
    0.02993313f, -0.25831398f, 0.30784157f, 0.25851357f, -0.04342871f, -0.00911518f, -0.04493295f, 0.05960985f, 
    0.21108925f, 0.20914249f, 0.05489454f, -0.02035390f, -0.07354616f, 0.19577412f, 0.00686755f, -0.02642122f, 
    -0.08204703f, 0.12644851f, -0.02972513f, -0.13031963f, 0.21764243f, 0.14553730f, 0.12991078f, 0.30912203f, 
    0.05890889f, 0.02411273f, 0.21156442f, -0.07402071f, 0.09133024f, 0.04263965f, 0.07455591f, -0.03541697f, 
    0.10105593f, -0.02920754f, 0.05128361f, 0.19814941f, -0.10657166f, -0.16078368f, 0.28872919f, 0.36095408f, 
    -0.13425584f, -0.07717882f, -0.01843211f, 0.07935728f, 0.05190397f, 0.05953008f, -0.02089371f, 0.03649836f, 
    0.06786999f, 0.14920709f, 0.08105505f, 0.01721918f, 0.06121831f, 0.05244464f, -0.00929119f, 0.09866660f, 
    -0.07052869f, -0.19394234f, -0.07738248f, -0.30850744f, -0.02373778f, -0.19233651f, 0.05474786f, -0.20574419f, 
    -0.01211113f, 0.00306656f, 0.17711012f, -0.12266707f, -0.11894989f, -0.01750920f, 0.02546978f, -0.16633523f, 
    0.11909879f, -0.12865232f, -0.29996175f, 0.22637880f, -0.16635874f, 0.01415895f, 0.00200017f, -0.07141050f, 
    -0.09106126f, -0.02518031f, -0.05735685f, 0.01315612f, 0.13110749f, 0.23290871f, -0.00362711f, -0.19124578f, 
    0.01409375f, 0.04534279f, -0.14055073f, 0.00719504f, -0.00657980f, -0.00608543f, 0.06841653f, 0.00476632f, 
    -0.10015546f, -0.32314649f, -0.05032554f, 0.41185641f, -0.12198025f, 0.09662920f, 0.02830497f, 0.26222527f, 
    -0.07314356f, -0.06176205f, 0.05818870f, -0.00587954f, -0.11121719f, 0.23076020f, -0.13652895f, 0.04234923f, 
    -0.13385592f, -0.12768839f, -0.12596530f, -0.09467150f, -0.16281904f, 0.12500659f, -0.04293826f, 0.17801924f, 
    0.11281322f, 0.18917480f, 0.18844818f, -0.05288378f, 0.15192941f, -0.06612822f, 0.05879547f, -0.10273784f, 
    0.11366309f, 0.06940918f, -0.09348420f, 0.02091344f, -0.12420835f, -0.14749411f, 0.39708477f, 0.22820325f, 
    -0.04459752f, 0.32358566f, 0.06249230f, 0.14110549f, -0.02712858f, -0.16732442f, -0.09016030f, -0.10321548f, 
    0.03878043f, 0.15907478f, -0.01303721f, -0.12605222f, 0.06468335f, 0.28565025f, -0.00133672f, -0.19868195f, 
    0.03370458f, -0.21456115f, -0.02476581f, 0.08081967f, 0.15799776f, 0.00706194f, 0.14282490f, 0.17608966f, 
    -0.09474570f, -0.11975951f, 0.11665227f, -0.10151693f, 0.02435737f, -0.00839435f, -0.06345798f, -0.02944307f, 
    -0.04153217f, -0.05948406f, -0.02579771f, 0.18490773f, 0.23116845f, -0.14284585f, 0.13856567f, 0.10881733f, 
    0.09181562f, 0.03716320f, 0.08922056f, 0.05782552f, 0.27152634f, 0.05240414f, 0.34159297f, 0.14582656f, 
    -0.07963402f, 0.10643911f, -0.04389961f, -0.02829524f, -0.08628328f, -0.04032582f, 0.06793927f, -0.01853353f, 
    0.14347996f, 0.06962749f, -0.05125244f, 0.18639953f, -0.00863642f, 0.25161049f, -0.10106676f, -0.20190690f, 
    -0.03194515f, 0.06877498f, 0.10760828f, 0.05285675f, 0.15625690f, -0.07972804f, -0.02150193f, -0.00915529f, 
    0.04735578f, -0.09736110f, -0.10200999f, 0.11536837f, 0.10218202f, 0.12300181f, -0.07384916f, 0.10164741f, 
    -0.05302533f, -0.20461486f, 0.00295097f, 0.19517738f, 0.10610835f, 0.16047718f, -0.03219128f, -0.04667361f, 
    0.17514464f, 0.00495112f, 0.11949436f, -0.00659211f, 0.03752944f, 0.00931903f, -0.43072349f, -0.33934808f, 
    0.04888172f, 0.11203727f, 0.09553012f, -0.09323525f, 0.04840082f, 0.09911875f, -0.06934302f, 0.01634356f, 
    0.22519730f, 0.17802188f, 0.02886577f, 0.47320858f, 0.08484545f, 0.02923464f, 0.01627229f, 0.09132654f, 
    0.05052790f, 0.04184391f, -0.03893923f, -0.11670300f, -0.02044117f, 0.45162278f, 0.28238571f, 0.17480874f, 
    -0.09566473f, -0.12018455f, 0.04900911f, 0.23773538f, -0.04907821f, 0.03089570f, 0.05927996f, 0.06176395f, 
    -0.19790594f, -0.14621842f, -0.12344299f, -0.16389079f, -0.00430496f, 0.09156843f, 0.14047121f, -0.01651403f, 
    -0.01719331f, -0.04454131f, 0.03917747f, 0.12658231f, -0.23247930f, 0.44670248f, 0.12404233f, 0.39666030f, 
    -0.11703546f, -0.09608827f, 0.41805595f, 0.11435867f, -0.03105187f, 0.13201933f, -0.11996250f, 0.03417333f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00397820f, 0.16972867f, 0.08367714f, -0.06081254f, -0.02461309f, -0.02268283f, -0.07317115f, -0.02441394f, 
    -0.04404762f, 0.05876197f, 0.07175712f, 0.14074591f, 0.09526747f, 0.04569631f, 0.06650656f, 0.09541860f, 
    0.14391723f, 0.06392652f, -0.01780642f, 0.03366907f, 0.11768746f, 0.31792173f, 0.13958944f, 0.11007173f, 
    0.13534684f, 0.00516268f, 0.05421294f, -0.07228895f, 0.27299339f, 0.20108989f, -0.08313969f, -0.07406170f, 
    -0.04386880f, 0.27258235f, 0.25584427f, 0.20072658f, 0.01010163f, 0.05278595f, 0.01737241f, -0.07726279f, 
    0.17761324f, -0.06593129f, 0.21490633f, 0.00067881f, -0.00641418f, 0.06579109f, 0.11207682f, 0.11700457f, 
    0.14547904f, 0.03430245f, 0.05370944f, 0.16414659f, 0.00322248f, 0.11562538f, 0.22035432f, 0.05127523f, 
    -0.10768951f, 0.06218849f, 0.00089088f, -0.00911688f, 0.13614288f, 0.01989013f, -0.00432327f, -0.05874754f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.15892796f, 0.02940252f, -0.00244601f, -0.02181194f, 0.16931495f, -0.02846582f, -0.06942063f, 0.11083161f, 
    -0.07720482f, 0.01699734f, 0.09700383f, -0.07884566f, 0.21695590f, 0.15479101f, 0.15327160f, 0.28186539f, 
    -0.22405532f, 0.03139072f, -0.12588474f, 0.35725656f, -0.15850990f, 0.06553476f, 0.22326979f, 0.31203893f, 
    -0.15282667f, 0.19261836f, 0.09411407f, -0.10901576f, -0.09185145f, -0.33320144f, -0.09538967f, -0.03581536f, 
    -0.10984694f, -0.17288290f, -0.11139277f, 0.10456566f, 0.16305566f, 0.19479726f, -0.06259777f, 0.23883970f, 
    -0.13037020f, -0.01862183f, 0.09982084f, -0.11800999f, -0.00278318f, -0.13983987f, 0.01940239f, 0.13352120f, 
    -0.14118874f, -0.08207195f, 0.01754100f, 0.09982569f, 0.06222123f, -0.13537522f, -0.05236427f, 0.08765843f, 
    -0.09062106f, 0.03643890f, -0.12874292f, -0.01669834f, 0.02547588f, -0.04402233f, -0.03478819f, -0.03831701f, 
    -0.06670475f, 0.10644297f, 0.10266180f, -0.00758305f, 0.28334796f, 0.08429068f, -0.08171855f, -0.01348658f, 
    -0.08587466f, 0.05113365f, -0.09814358f, -0.03710545f, -0.17398374f, -0.11031055f, 0.11524021f, 0.05142126f, 
    0.14176930f, 0.24442689f, -0.11661085f, 0.23648840f, 0.01815431f, 0.25217009f, 0.14415707f, 0.01501759f, 
    0.57564062f, -0.09247873f, 0.15354861f, -0.05560153f, -0.36106858f, -0.11350483f, -0.06682110f, -0.10093703f, 
    -0.00073392f, -0.01063563f, 0.22683781f, -0.12577088f, 0.00412281f, -0.22433463f, 0.21740092f, 0.33941716f, 
    0.15766385f, -0.04970770f, 0.20183037f, -0.28753132f, 0.14659843f, -0.27244803f, -0.20819159f, 0.13373648f, 
    0.07465962f, 0.03946186f, -0.34395576f, 0.18438123f, -0.05072512f, 0.04365371f, 0.08268078f, -0.00095954f, 
    -0.47491056f, 0.03921549f, 0.13240622f, -0.06943823f, -0.12085582f, 0.02939493f, -0.16337311f, 0.22490020f, 
    0.32351136f, -0.16180305f, -0.18196465f, 0.12338987f, 0.33506858f, -0.09866762f, 0.07677577f, -0.05898473f, 
    -0.02287126f, -0.11169243f, 0.01223097f, 0.13787454f, 0.05920935f, -0.05849826f, 0.02699083f, 0.01804933f, 
    0.06080822f, -0.00896774f, -0.13627298f, 0.03351759f, 0.12008125f, -0.05245396f, -0.23234551f, 0.13919125f, 
    -0.17461589f, -0.15214299f, 0.17696880f, -0.04431016f, 0.08114339f, 0.09424094f, 0.00148265f, 0.02486017f, 
    -0.12054636f, 0.07708345f, 0.01993800f, 0.07494187f, 0.19629209f, -0.08401305f, -0.16775057f, 0.22078390f, 
    -0.09492200f, -0.10472439f, -0.05790566f, 0.10671780f, -0.14353786f, -0.22040512f, 0.09889004f, 0.04728154f, 
    0.12996963f, -0.07141875f, -0.20943829f, 0.15125503f, -0.20633337f, -0.23910265f, -0.09268216f, -0.04619625f, 
    -0.42220682f, -0.08941765f, -0.28601584f, 0.07661514f, -0.04008407f, -0.06802727f, -0.29487062f, -0.15028720f, 
    0.04108362f, -0.16245164f, -0.08876724f, -0.02825994f, 0.06512533f, -0.00065364f, 0.03322790f, 0.06444473f, 
    0.00920709f, -0.10023294f, 0.24051124f, 0.22645451f, -0.20534717f, -0.04008025f, 0.18111359f, 0.31930828f, 
    -0.18149915f, 0.06127262f, 0.31625918f, 0.27983618f, -0.15548913f, 0.19633168f, 0.06413573f, 0.30775911f, 
    -0.02553490f, 0.27154282f, 0.09623140f, 0.11278033f, 0.05646605f, -0.18041261f, -0.04756825f, -0.07195732f, 
    0.10415698f, 0.09940477f, 0.05794092f, -0.06989420f, 0.15067089f, 0.14940959f, 0.06042398f, -0.08585482f, 
    -0.18389469f, 0.01499821f, 0.08048631f, 0.08962235f, 0.16749898f, -0.24674176f, 0.20719570f, 0.04299244f, 
    -0.08355845f, -0.03781418f, 0.19722885f, 0.43008780f, 0.01266583f, -0.11510887f, 0.02647947f, -0.00367411f, 
    0.26185232f, -0.03612951f, -0.21698703f, -0.03730433f, -0.16471821f, 0.04990376f, -0.08684995f, 0.05580913f, 
    -0.06745846f, 0.13405465f, 0.14281897f, 0.10571312f, -0.06381484f, -0.03720499f, -0.09441036f, -0.03385689f, 
    0.04564019f, -0.11329730f, -0.53224003f, -0.07087936f, -0.12712130f, 0.04230506f, 0.08237104f, -0.23480077f, 
    0.10844876f, 0.12227670f, 0.20110220f, 0.33646858f, -0.21182413f, 0.04425699f, -0.05146429f, 0.08993640f, 
    0.17719522f, -0.12166156f, 0.21478331f, -0.02906531f, -0.32632962f, -0.06753176f, 0.09153230f, 0.03374313f, 
    0.23964851f, -0.34602675f, 0.07929152f, -0.11697788f, 0.07743639f, -0.14748496f, 0.07258828f, 0.07166704f, 
    -0.09344617f, -0.05973256f, -0.03060223f, 0.14202143f, -0.08119924f, 0.17623451f, 0.24098036f, -0.18523292f, 
    -0.21317814f, -0.08020169f, -0.10363820f, 0.04360756f, 0.17786443f, 0.12779839f, -0.02020509f, -0.02344412f, 
    -0.07085264f, 0.30327839f, -0.02532775f, -0.07860108f, -0.05096778f, -0.08054405f, 0.12577781f, -0.01495360f, 
    -0.20276591f, 0.09605140f, 0.19613729f, 0.06078103f, -0.03156691f, -0.08310119f, 0.08010263f, -0.10995118f, 
    -0.10744987f, -0.04282162f, -0.31155580f, 0.24284129f, 0.03062721f, 0.17980342f, 0.14690754f, -0.18179828f, 
    0.38695458f, -0.11798962f, 0.10315818f, -0.19813539f, 0.02601335f, 0.07024466f, 0.08204769f, 0.11360874f, 
    0.05698931f, 0.03808955f, -0.08288927f, 0.03594983f, 0.05303429f, 0.15836729f, -0.02481866f, 0.06499930f, 
    0.08258594f, -0.06366366f, 0.14036779f, 0.01345368f, 0.06976532f, 0.05530152f, 0.10508496f, 0.14396481f, 
    -0.03938082f, -0.06803329f, 0.18662001f, -0.07397853f, -0.02934442f, 0.11013990f, 0.13089085f, 0.12763196f, 
    0.03448937f, 0.08253364f, -0.24648623f, -0.17175467f, 0.11449480f, 0.16898733f, 0.11261181f, 0.09958529f, 
    -0.00064264f, -0.14777550f, 0.08541635f, -0.09363788f, 0.17797902f, 0.07444186f, -0.00913804f, 0.01337631f, 
    0.02538021f, -0.11108863f, 0.08054416f, 0.07953745f, -0.03825305f, -0.13006762f, 0.07339886f, 0.08257383f, 
    0.07509158f, -0.08918481f, -0.02591324f, 0.07885835f, -0.00321927f, -0.05748023f, -0.11823286f, -0.06680749f, 
    -0.00264243f, 0.04432517f, -0.02448290f, -0.09656744f, -0.08935498f, 0.05334824f, -0.09523553f, -0.12841277f, 
    0.12467241f, -0.10085674f, -0.02042429f, 0.03361952f, -0.04728458f, -0.07352997f, -0.02068657f, -0.09690963f, 
    -0.00519174f, -0.03486237f, 0.07383596f, 0.09202536f, -0.07472318f, -0.04757888f, 0.09998991f, -0.08241774f, 
    -0.04248030f, -0.03144925f, -0.00838055f, -0.06887718f, -0.07102901f, 0.01518768f, 0.09926665f, -0.03300173f, 
    -0.14062500f, 0.03884773f, -0.07754615f, 0.02449313f, -0.05141575f, -0.05903340f, -0.02874933f, 0.09687100f, 
    0.00640384f, 0.01971078f, 0.03512739f, 0.00844839f, -0.12486204f, -0.10718850f, -0.13851690f, 0.06885964f, 
    -0.08119271f, 0.00949175f, 0.06518292f, 0.06890495f, 0.32731879f, -0.00628156f, 0.10659877f, -0.06809776f, 
    0.05590127f, 0.00205311f, -0.15446369f, -0.14532973f, -0.14655344f, -0.04071578f, 0.08185764f, 0.27127334f, 
    0.13171546f, -0.00172154f, 0.06122538f, 0.03352608f, -0.07019832f, 0.02922473f, -0.00397560f, -0.21524842f, 
    0.36920008f, -0.10909598f, 0.12725323f, 0.00867358f, -0.02626429f, -0.00115607f, 0.00796314f, 0.06752470f, 
    -0.00358865f, 0.15844092f, 0.03398009f, 0.02122045f, 0.03607669f, 0.01250691f, 0.22282721f, 0.13015625f, 
    0.15703590f, 0.11000726f, 0.05458065f, -0.12338796f, 0.13067177f, -0.20751792f, -0.31009969f, -0.16909076f, 
    0.06385627f, -0.07162919f, 0.05847285f, 0.10727365f, 0.10769985f, -0.03329823f, -0.07393449f, -0.05578651f, 
    -0.20694511f, 0.28023627f, 0.18730751f, -0.03524801f, -0.07987332f, -0.06145341f, 0.09499634f, 0.25127280f, 
    0.30205455f, 0.14690551f, -0.15659679f, -0.06764300f, 0.02090933f, -0.05867549f, -0.04733359f, -0.08703936f, 
    0.07388102f, 0.01714421f, -0.06395943f, 0.19684573f, -0.16998680f, 0.27149805f, 0.14950103f, 0.34526286f, 
    0.16473283f, 0.02062841f, -0.03884647f, 0.34733585f, -0.13571957f, 0.38875157f, 0.15270565f, 0.21101418f, 
    0.18391588f, 0.07386301f, 0.02680036f, -0.03703423f, -0.17563270f, -0.10680745f, -0.10830425f, -0.07483857f, 
    -0.05503339f, 0.12712002f, 0.12222428f, 0.15186465f, 0.22698301f, 0.02556885f, -0.07356447f, 0.38251382f, 
    0.09574272f, -0.05985770f, 0.32475293f, -0.06762654f, 0.00538541f, 0.01515911f, -0.15033953f, 0.31083247f, 
    0.05712635f, -0.10399072f, -0.07673568f, 0.09291024f, -0.16550003f, -0.18105732f, -0.10782035f, 0.03008196f, 
    -0.13546078f, 0.08028648f, -0.10802658f, -0.04651240f, 0.07836535f, 0.00453359f, -0.10721850f, 0.15784661f, 
    0.24643964f, 0.07473559f, -0.24620640f, 0.07889648f, -0.33716419f, 0.05192849f, 0.01332666f, -0.00933114f, 
    -0.10454161f, 0.06286942f, -0.05994230f, 0.01187896f, -0.37117803f, 0.25014773f, 0.08405971f, 0.40574837f, 
    0.02774578f, -0.05826860f, -0.08683831f, 0.29601368f, -0.17706354f, 0.18803088f, -0.21529940f, 0.05792751f, 
    -0.28518713f, 0.27434519f, 0.13218646f, -0.08975016f, 0.07550519f, -0.19154751f, -0.04624522f, 0.09025986f, 
    0.02596730f, -0.08448651f, -0.09305521f, 0.09224787f, 0.09140934f, 0.28202862f, -0.34496427f, -0.01513159f, 
    -0.18374437f, 0.03352519f, -0.06905538f, -0.08802018f, -0.20295176f, 0.04651874f, 0.07219313f, 0.13023147f, 
    0.08765412f, 0.09232809f, 0.16845955f, -0.13113260f, -0.53946030f, 0.01950614f, -0.39957437f, 0.11603142f, 
    0.23336653f, 0.08659200f, -0.45689991f, -0.12635128f, 0.15003341f, -0.10789469f, 0.14321721f, 0.23437783f, 
    -0.21297002f, 0.38388720f, -0.13103558f, -0.01989309f, -0.23746377f, -0.00801277f, -0.02871157f, 0.05832257f, 
    0.12204652f, -0.02351146f, -0.23100331f, 0.16299307f, 0.02947886f, 0.01648266f, 0.00883635f, -0.18721397f, 
    0.16535918f, 0.23708208f, 0.35591072f, 0.11972044f, 0.16672984f, 0.14331257f, 0.24210066f, 0.13232407f, 
    0.13233863f, 0.05094234f, 0.00945744f, 0.03126814f, -0.16383010f, 0.12073298f, -0.07879426f, 0.04405028f, 
    -0.09839994f, 0.06946719f, 0.12537834f, 0.15820956f, 0.16398135f, 0.05865927f, -0.05507495f, -0.22065045f, 
    0.15801206f, 0.06328155f, 0.25275391f, 0.12652686f, -0.03779652f, -0.19100843f, 0.17855455f, 0.12934065f, 
    0.02589271f, 0.05582128f, -0.07967001f, 0.10595223f, 0.10128418f, 0.15524466f, 0.24675865f, 0.03502805f, 
    -0.13371617f, 0.20932901f, 0.13148780f, -0.09791660f, 0.19930544f, 0.03129667f, 0.15130547f, -0.24186045f, 
    0.22146469f, 0.29388407f, 0.02730996f, -0.09963990f, -0.20846218f, -0.11757904f, 0.07793626f, 0.11244502f, 
    -0.11065399f, -0.09009534f, -0.00432668f, -0.24036726f, -0.01447087f, 0.10661834f, 0.16531959f, 0.21402286f, 
    0.15463580f, 0.22556138f, -0.16774370f, 0.04376735f, 0.17778996f, 0.42126283f, -0.01397840f, 0.17766298f, 
    0.11675191f, -0.08624505f, 0.22460015f, 0.10920671f, 0.11129989f, -0.15394978f, 0.04700507f, -0.00248713f, 
    -0.26435283f, -0.00428849f, 0.19218071f, 0.18828762f, -0.13979624f, 0.18710656f, 0.01421720f, -0.00343599f, 
    0.19944958f, 0.09038322f, -0.26523805f, -0.15314385f, 0.05980704f, -0.02917439f, 0.04959592f, -0.00884719f, 
    -0.00857790f, -0.01616226f, -0.38265741f, -0.10386023f, 0.08427563f, 0.15474948f, 0.04647166f, -0.04406236f, 
    -0.32802182f, 0.17199762f, 0.23164627f, 0.04889984f, 0.12325680f, 0.03695064f, 0.09070405f, 0.19902052f, 
    -0.16165169f, -0.18383017f, 0.12188608f, 0.10072669f, 0.15755759f, 0.01378503f, -0.07170963f, 0.00454304f, 
    0.05202063f, -0.02319098f, 0.21244253f, 0.08644380f, 0.00094607f, -0.12683535f, -0.00475194f, 0.29676196f, 
    -0.11507101f, 0.10044109f, -0.16018702f, -0.31000027f, -0.22502290f, 0.21273482f, 0.06614584f, -0.14437898f, 
    -0.02290597f, 0.26075566f, 0.04823005f, 0.10004198f, 0.16832225f, 0.09876451f, 0.02602685f, 0.02859782f, 
    0.21378578f, 0.10649119f, -0.02467071f, -0.12680717f, -0.20892045f, 0.21492416f, 0.11933064f, 0.02291537f, 
    0.09388057f, -0.00903781f, -0.06408988f, 0.00678919f, 0.23097326f, 0.16426010f, -0.20586529f, -0.19033529f, 
    -0.25738680f, 0.04516631f, 0.32600513f, 0.09654552f, 0.20808925f, 0.11038125f, -0.16974407f, 0.10533809f, 
    0.03315714f, 0.10329292f, 0.06976501f, 0.00930943f, -0.27892429f, 0.10841335f, 0.27653897f, 0.23750417f, 
    0.01014842f, -0.19197100f, 0.11563598f, 0.05659839f, -0.00473895f, -0.11022802f, -0.02894518f, -0.03998993f, 
    0.01162835f, 0.06790091f, 0.07153965f, 0.22276327f, 0.22808078f, 0.31325981f, -0.05332845f, 0.08714296f, 
    0.15115035f, -0.11805154f, -0.48493305f, -0.07950204f, -0.12646480f, 0.00142004f, -0.06974846f, 0.24706145f, 
    -0.26047704f, -0.02842703f, -0.16978641f, -0.08393892f, 0.12332181f, 0.00575436f, -0.09224320f, 0.10503735f, 
    -0.11664036f, -0.25040326f, -0.08069523f, 0.03598103f, 0.03221263f, -0.05992494f, -0.06599285f, 0.18725668f, 
    -0.03523893f, 0.05811227f, 0.26654246f, -0.10087512f, 0.06858632f, 0.20108321f, 0.15442136f, 0.09165850f, 
    -0.06861617f, -0.11324250f, 0.17004175f, 0.08424759f, -0.08287423f, 0.04323211f, 0.14414474f, -0.11326206f, 
    0.31000409f, 0.03002965f, -0.05709320f, -0.05285812f, -0.05977249f, -0.07009353f, 0.00106305f, 0.01145429f, 
    0.02985640f, -0.05331087f, 0.03434839f, -0.12086518f, 0.11570307f, 0.04822845f, 0.06697521f, 0.01388088f, 
    -0.01234590f, 0.06131917f, 0.09233996f, 0.10687003f, 0.05776132f, -0.09451634f, -0.06400762f, 0.09536435f, 
    -0.02220458f, 0.03101494f, -0.20748445f, -0.00815391f, -0.04454645f, 0.03756582f, -0.11247891f, 0.02545474f, 
    -0.29841775f, 0.01391636f, -0.14963968f, 0.05149359f, -0.00238426f, -0.14585368f, 0.05071568f, -0.11447816f, 
    -0.11491064f, -0.02623408f, -0.14908695f, -0.14846307f, 0.05105684f, -0.19462340f, -0.11183663f, -0.04047463f, 
    -0.16245909f, 0.01027127f, 0.11807102f, -0.10056867f, -0.12919976f, -0.13624549f, -0.09529466f, 0.02248450f, 
    -0.20912054f, 0.07298790f, 0.07894704f, 0.02602460f, -0.09635027f, -0.11980562f, 0.06604770f, -0.11800481f, 
    0.04775467f, 0.03688726f, -0.10497499f, 0.09356546f, -0.16623707f, 0.03948533f, -0.16024894f, -0.11970878f, 
    0.29867807f, 0.01376422f, 0.17529388f, -0.03736219f, 0.24986888f, -0.04703066f, 0.11447296f, -0.03335787f, 
    0.11368800f, -0.05961607f, -0.14051214f, 0.15818661f, 0.18176420f, 0.13099916f, 0.22961661f, -0.22057329f, 
    0.16295321f, -0.14824679f, -0.32350606f, 0.05960230f, -0.13627000f, -0.30220249f, -0.02665083f, 0.24079598f, 
    -0.07472423f, -0.12833562f, -0.20833495f, 0.03298927f, -0.11865306f, -0.40627608f, -0.04101411f, 0.09439816f, 
    0.13639258f, -0.33913833f, -0.08583938f, 0.04811602f, 0.01683124f, 0.07418536f, 0.13164906f, 0.39374873f, 
    0.01286945f, -0.03911790f, -0.07600592f, -0.04967792f, -0.13796867f, 0.11731484f, 0.17946956f, 0.11314247f, 
    -0.00529134f, 0.08623984f, 0.10593382f, -0.14693353f, -0.03956977f, 0.06150556f, 0.21419398f, 0.06806310f, 
    0.20971040f, -0.09062131f, 0.01475828f, 0.02425651f, 0.02197279f, 0.04251432f, -0.26354730f, 0.26936296f, 
    -0.32874569f, 0.28474402f, 0.24472135f, 0.10442793f, 0.24837010f, -0.10968022f, 0.05859617f, -0.04371529f, 
    0.08120722f, 0.01000429f, -0.32902870f, -0.24586339f, 0.04164527f, -0.13907285f, -0.13882208f, 0.11946196f, 
    0.12934424f, 0.14257444f, 0.36300439f, 0.18277939f, -0.02582304f, -0.10506453f, 0.15331402f, 0.08968433f, 
    0.21123657f, 0.03559305f, 0.31047672f, -0.01345186f, -0.01291555f, 0.17038503f, 0.07811333f, 0.01534217f, 
    0.20525706f, -0.01720551f, 0.21316235f, -0.21833998f, 0.11765997f, -0.03490755f, 0.14973380f, -0.13405240f, 
    -0.09154301f, 0.09665372f, -0.31602803f, -0.14992091f, 0.19782399f, -0.25503936f, 0.01111996f, -0.18758585f, 
    -0.15357772f, -0.12301100f, -0.11047294f, 0.19944577f, 0.22168970f, 0.19547521f, 0.08873075f, 0.05880632f, 
    -0.07683171f, 0.12884341f, 0.18630593f, 0.04632110f, -0.19113661f, -0.04013985f, 0.26677066f, -0.13653088f, 
    -0.04938880f, 0.11792444f, 0.15493535f, -0.00775562f, -0.21883833f, 0.03419205f, 0.02308629f, -0.03650942f, 
    0.08805484f, -0.05762103f, -0.25507292f, 0.32321495f, 0.01795016f, 0.08614097f, 0.23162524f, -0.24042194f, 
    0.29166454f, -0.14175077f, -0.00886571f, -0.22094873f, -0.11501108f, 0.04149234f, -0.11954735f, -0.05362883f, 
    0.38702744f, -0.06135334f, -0.19790170f, -0.06764082f, 0.01246320f, 0.21116559f, -0.08495270f, 0.06722646f, 
    0.02100648f, -0.01399128f, 0.20898828f, -0.04324006f, 0.10110260f, -0.14640984f, 0.26689634f, 0.21659604f, 
    -0.04829255f, 0.08398952f, 0.44190431f, -0.06040282f, 0.00671623f, 0.20723838f, 0.00708361f, 0.17201386f, 
    0.12637205f, -0.02756853f, 0.10541935f, -0.08419029f, -0.09740829f, 0.15264371f, 0.28698605f, -0.00827050f, 
    0.14688112f, -0.14052804f, 0.17631866f, -0.01941356f, -0.07100248f, -0.07036081f, -0.28690588f, 0.12322761f, 
    0.18467253f, 0.15653580f, 0.26527080f, -0.03869337f, 0.20352869f, 0.01247392f, -0.12295678f, 0.12077166f, 
    0.03816879f, 0.05672559f, -0.06502498f, 0.20906071f, 0.24979272f, 0.12151833f, 0.17276560f, 0.10365326f, 
    0.09780431f, 0.05353807f, -0.10331155f, -0.11007253f, -0.06042695f, 0.15219425f, 0.07940690f, 0.17699958f, 
    0.40494356f, -0.10759429f, 0.13269563f, 0.04020813f, -0.05902812f, -0.12797680f, 0.03709840f, -0.08074803f, 
    -0.03823834f, 0.03742882f, 0.12397233f, -0.09180348f, -0.01581757f, -0.13128003f, 0.17521887f, 0.04026461f, 
    0.07579392f, -0.06017463f, -0.02936064f, -0.18656842f, 0.17038055f, 0.04151097f, -0.07650615f, 0.13068350f, 
    0.06297240f, 0.01553903f, -0.25251630f, 0.13450263f, 0.21523944f, 0.24203099f, 0.20231427f, 0.03954696f, 
    -0.33505842f, 0.14426418f, 0.21786934f, 0.01201017f, 0.09251684f, -0.05813516f, -0.17314444f, 0.21588288f, 
    -0.08662269f, -0.12660615f, -0.07643663f, 0.04398648f, 0.09316518f, -0.07957148f, -0.05861489f, 0.02323262f, 
    -0.09503195f, 0.07832250f, -0.10496349f, 0.06801541f, -0.12049425f, -0.04555066f, 0.07529154f, -0.06624034f, 
    -0.12891287f, -0.00832167f, 0.05646640f, -0.07699660f, -0.09131382f, 0.00522776f, 0.09300546f, 0.08778453f, 
    -0.11170464f, 0.03715168f, -0.00885041f, -0.11570556f, -0.13880280f, -0.06631327f, -0.09886625f, 0.09444542f, 
    0.02907255f, 0.05647387f, -0.00580347f, 0.06323490f, 0.04853897f, -0.06513558f, -0.06815606f, -0.03993557f, 
    0.02399918f, -0.05201494f, -0.13839597f, -0.13231544f, -0.10577597f, 0.02973836f, -0.13498186f, -0.07601340f, 
    -0.13322970f, -0.11769067f, -0.00167918f, -0.08490936f, -0.07925146f, 0.02791025f, -0.13006677f, -0.01599461f, 
    -0.10325380f, 0.03141025f, -0.09465013f, -0.01393379f, -0.02100292f, -0.12207112f, 0.01787811f, 0.03191342f, 
    0.25843236f, 0.03422132f, -0.02445184f, -0.05660438f, 0.02397381f, -0.05038926f, 0.10837076f, -0.04844406f, 
    0.10225411f, 0.06336218f, -0.24268053f, -0.06907669f, 0.26762363f, 0.14029253f, 0.17075135f, -0.21331923f, 
    0.27130827f, -0.03595860f, -0.01694789f, 0.21990839f, 0.07518287f, -0.06779374f, 0.04948556f, 0.35995090f, 
    -0.06423160f, -0.21425544f, 0.20266061f, 0.01527634f, -0.08736584f, -0.20954575f, -0.00146677f, 0.02743185f, 
    0.01914329f, -0.08172952f, 0.07884996f, 0.06206408f, 0.14421991f, 0.14587842f, -0.09204441f, 0.05096924f, 
    0.07042287f, 0.11057193f, -0.45747262f, 0.03845268f, -0.03411663f, 0.06730112f, 0.14065111f, -0.02973050f, 
    0.24349181f, 0.01443151f, -0.33534345f, -0.02570003f, -0.05679290f, 0.32210883f, -0.04643700f, 0.05939276f, 
    -0.31667882f, 0.18879643f, 0.09293333f, 0.08822268f, 0.17320836f, -0.02630995f, -0.01402816f, 0.16506277f, 
    -0.09706515f, -0.03002923f, -0.12848464f, -0.02439878f, -0.12576486f, -0.10865428f, 0.07487120f, -0.11782481f, 
    0.11196664f, -0.09404578f, 0.02909086f, -0.03736945f, 0.06713804f, 0.05284726f, -0.10646472f, -0.01955100f, 
    0.09383658f, -0.12427725f, 0.04637097f, -0.02092049f, -0.12810057f, 0.03001656f, -0.03839553f, -0.02947083f, 
    -0.11530288f, -0.06738336f, -0.10605838f, -0.02739974f, 0.09620261f, -0.00894993f, 0.06424586f, -0.04221936f, 
    -0.06725206f, 0.00954485f, -0.01142000f, -0.11058208f, 0.08590689f, -0.01591532f, 0.00948099f, 0.01815467f, 
    0.07169275f, 0.05019352f, 0.10266017f, -0.07314192f, -0.08635361f, -0.11739377f, -0.02758032f, -0.13765138f, 
    -0.01437566f, 0.05546876f, 0.03807187f, -0.08402613f, -0.02432749f, 0.00777153f, 0.10723986f, -0.11291529f, 
    0.11233372f, -0.04321269f, 0.00192219f, 0.08853580f, -0.12004133f, 0.04486166f, -0.07561265f, 0.09068538f, 
    0.00121814f, 0.24521653f, -0.09244103f, 0.03829239f, 0.02458693f, -0.00462842f, -0.00610635f, -0.11822686f, 
    -0.09598090f, -0.04910899f, -0.26746368f, -0.29003859f, 0.10262198f, -0.08653760f, 0.20201844f, 0.10299896f, 
    -0.18826716f, 0.04668941f, 0.09469920f, 0.12814507f, 0.02665549f, -0.31968910f, 0.18986072f, -0.26065791f, 
    0.04311409f, -0.30974728f, 0.02473569f, 0.05177615f, -0.34758365f, -0.34838206f, 0.02467036f, -0.06804609f, 
    0.04425120f, -0.23784333f, -0.32035646f, -0.43566594f, -0.09563515f, -0.41120854f, 0.20414869f, 0.04921500f, 
    -0.04812513f, -0.11178855f, 0.09547637f, -0.29929417f, 0.15865234f, 0.28533408f, -0.02682138f, -0.57353318f, 
    -0.32183230f, 0.00440236f, 0.17458068f, -0.00143393f, 0.00714389f, 0.22196700f, 0.16560635f, 0.07376267f, 
    0.04702443f, 0.13139856f, 0.16549037f, -0.09722772f, 0.37364087f, 0.03681816f, 0.22995700f, -0.05663168f, 
    0.19011416f, 0.08846189f, -0.05023682f, 0.05626836f, 0.10125554f, -0.11001758f, -0.01457751f, -0.05844313f, 
    0.03819390f, -0.03329662f, 0.19447592f, 0.03610443f, 0.13932224f, 0.09301253f, 0.27087167f, -0.07654894f, 
    -0.03658571f, -0.17786038f, -0.31215876f, -0.24109189f, -0.00459030f, -0.27725819f, 0.05129125f, 0.00651782f, 
    -0.09421831f, -0.00363293f, -0.21121724f, -0.09564063f, -0.01958786f, -0.11091880f, -0.04969656f, 0.11721672f, 
    0.07706647f, -0.04543655f, -0.02341259f, -0.02041005f, 0.15807013f, -0.25868917f, 0.17101741f, 0.12942687f, 
    -0.00303671f, 0.00828008f, 0.24295223f, -0.06727594f, 0.07256075f, 0.09570618f, -0.03891539f, 0.03720859f, 
    0.00697109f, 0.07229540f, 0.04749798f, -0.17467317f, -0.03857684f, 0.14180833f, 0.00478789f, -0.04566017f, 
    0.25181329f, -0.17115758f, 0.08983847f, 0.03214077f, -0.06870927f, 0.03738567f, -0.19546632f, 0.08368646f, 
    0.20184436f, -0.18973282f, 0.05200532f, -0.01391701f, 0.17041720f, 0.10137997f, -0.04869322f, 0.06826855f, 
    0.00553748f, 0.07184615f, 0.16972412f, 0.30292726f, 0.12878008f, -0.00637357f, 0.05520741f, -0.12015068f, 
    -0.19087778f, -0.05424599f, 0.01271916f, -0.53191227f, 0.22436969f, -0.20586835f, -0.22673988f, -0.05185235f, 
    0.02396447f, -0.17279725f, -0.05847147f, 0.06393935f, 0.19989683f, 0.12257661f, 0.02715710f, -0.00433454f, 
    -0.23691432f, 0.10972370f, 0.05588952f, 0.16347200f, 0.15820032f, 0.00173676f, 0.07424503f, 0.18647613f, 
    0.04856606f, -0.05800067f, 0.09070361f, 0.00503060f, 0.06751278f, -0.11257920f, -0.17495140f, -0.28855383f, 
    0.23361231f, -0.01407249f, -0.69335562f, 0.00578024f, -0.17450784f, -0.20265748f, 0.00976511f, -0.06629853f, 
    -0.21543440f, 0.01409837f, 0.09348061f, 0.02475517f, 0.11842600f, -0.07030399f, -0.36558312f, -0.00573399f, 
    0.01609117f, -0.01780885f, 0.06869300f, -0.04044645f, 0.17998974f, 0.02999615f, -0.07414426f, 0.07066147f, 
    -0.01476820f, -0.02241670f, 0.09580884f, -0.05685944f, 0.17150053f, 0.19007416f, -0.02255591f, 0.00269936f, 
    -0.06704088f, -0.07349769f, -0.49432793f, -0.32126912f, -0.07517092f, -0.31163785f, 0.05323903f, -0.28769594f, 
    0.10958757f, -0.00658261f, -0.26112679f, -0.12048160f, 0.00588423f, 0.13249640f, -0.00636099f, -0.05499703f, 
    0.05980045f, -0.12370117f, -0.10296974f, -0.15913677f, -0.29679012f, 0.07938813f, 0.08726247f, 0.15233608f, 
    0.15599899f, -0.11058450f, 0.31274265f, -0.10976995f, 0.05985240f, 0.30782777f, 0.00021190f, -0.01165658f, 
    -0.22976841f, 0.05754942f, 0.23825914f, -0.03949161f, 0.22707933f, 0.22909866f, 0.08051710f, -0.04006541f, 
    0.43200389f, -0.04335634f, 0.21805282f, 0.08429629f, -0.11028726f, -0.08154418f, -0.04572402f, 0.15060799f, 
    0.01123869f, 0.16466025f, 0.07335705f, 0.12996902f, -0.13220964f, -0.03916625f, 0.08135048f, -0.07183170f, 
    0.02817377f, 0.05098391f, -0.01195194f, 0.23222420f, 0.25974381f, 0.20392972f, 0.10285635f, 0.09736384f, 
    0.17814286f, -0.09833128f, 0.17096664f, 0.01287411f, 0.03719897f, 0.02399752f, -0.06173448f, 0.18005113f, 
    -0.07776598f, 0.08714081f, 0.07150416f, -0.10121598f, 0.08001901f, -0.00836537f, -0.00415106f, 0.07804379f, 
    -0.04509193f, -0.20443161f, 0.03826348f, 0.09661254f, 0.13828784f, 0.02429515f, -0.03046799f, -0.10111693f, 
    0.07807792f, -0.07045167f, -0.03164428f, -0.17597221f, -0.07987252f, 0.13310067f, 0.26419139f, 0.26697665f, 
    0.02581486f, 0.05231380f, 0.00472352f, -0.03791918f, -0.03707249f, 0.10787323f, 0.21080469f, -0.06958532f, 
    0.26359886f, 0.02167528f, -0.00863185f, 0.04915084f, 0.18811090f, -0.12475447f, -0.12572458f, -0.06769161f, 
    -0.17706473f, 0.24942899f, -0.13984583f, 0.04741863f, -0.28605393f, -0.07177263f, 0.01806696f, 0.08061185f, 
    0.07102419f, 0.08570421f, -0.15474284f, -0.19689761f, -0.00721566f, 0.14650473f, 0.06803663f, 0.00896362f, 
    0.06642247f, 0.14214788f, 0.02485654f, 0.07586137f, 0.20989977f, 0.34850001f, 0.24132660f, 0.13218234f, 
    0.39647084f, -0.19530459f, 0.12418517f, -0.07299627f, -0.14215221f, -0.02523617f, 0.11453769f, -0.07797937f, 
    -0.11919118f, 0.09634949f, 0.24287866f, 0.19800851f, -0.15468277f, -0.02403563f, 0.06029749f, 0.00862931f, 
    0.25636920f, 0.01547026f, 0.02467037f, 0.01839300f, 0.08638957f, 0.08162922f, -0.07309295f, 0.15573333f, 
    0.06998707f, 0.06493659f, -0.16617866f, -0.11011997f, -0.07387762f, 0.12901652f, 0.06171502f, -0.08151955f, 
    -0.26176184f, 0.20333508f, 0.15828478f, -0.11048288f, 0.15258843f, 0.00201439f, 0.16827710f, -0.11027587f, 
    0.01615303f, -0.11177760f, -0.24798423f, -0.09959100f, 0.01237295f, 0.06170198f, 0.07842855f, 0.11174795f, 
    -0.06195484f, 0.05069384f, -0.05586806f, 0.07089126f, -0.08506895f, 0.16305758f, 0.07472175f, 0.35392240f, 
    0.08718805f, -0.15545736f, -0.02634824f, -0.14458458f, -0.09158464f, 0.11029731f, -0.24803528f, 0.10571888f, 
    -0.19362403f, 0.07601889f, 0.19383356f, -0.03448328f, 0.32329077f, 0.04002307f, -0.08500656f, -0.05865081f, 
    -0.20065936f, 0.16674866f, 0.08076317f, 0.20091207f, 0.24680854f, 0.27987379f, -0.16410805f, -0.03988993f, 
    0.09960366f, -0.03983161f, -0.11179512f, 0.06197431f, -0.22479083f, 0.26493648f, 0.12856792f, -0.05741680f, 
    0.04904352f, 0.08991632f, -0.28796679f, 0.04448801f, -0.60261226f, -0.04260243f, -0.29955178f, -0.06020707f, 
    0.05596085f, -0.14374746f, -0.07672173f, -0.01550189f, 0.02499376f, -0.02711308f, -0.05960349f, 0.05918027f, 
    0.27980721f, 0.11448422f, -0.20844530f, -0.04121182f, 0.00665830f, 0.08398491f, 0.06587295f, 0.11178780f, 
    0.06144653f, 0.06569713f, 0.07410485f, -0.08726972f, 0.13457991f, 0.11757397f, 0.23129626f, -0.04181898f, 
    -0.17646387f, 0.08189417f, 0.00006817f, 0.18433766f, 0.11907895f, -0.09594803f, 0.10080361f, 0.25717649f, 
    -0.25134388f, 0.02539680f, 0.15167208f, -0.01564385f, -0.16914096f, -0.17941432f, 0.08244191f, 0.10753384f, 
    -0.14643422f, 0.04970634f, -0.11059809f, 0.04835168f, 0.21630548f, -0.03409154f, -0.20715864f, 0.01600209f, 
    -0.12995484f, 0.10127878f, -0.18796515f, -0.10760204f, 0.11654047f, -0.16412376f, 0.04643304f, 0.15570430f, 
    -0.01685547f, -0.07181643f, 0.02145802f, 0.21759291f, 0.04202086f, 0.02379419f, 0.15797453f, -0.04394219f, 
    -0.00314154f, 0.06391672f, -0.01434340f, -0.08668372f, 0.15897359f, 0.06166242f, 0.08614662f, -0.13713807f, 
    0.15818366f, 0.20288241f, 0.08505309f, 0.04863836f, 0.21521726f, 0.12448782f, -0.10717131f, 0.01801409f, 
    0.01420924f, 0.06005339f, -0.33946484f, -0.02021637f, 0.14395374f, -0.03882254f, 0.14089783f, 0.14326991f, 
    -0.05238498f, 0.13355170f, -0.01194898f, 0.13860510f, 0.09900916f, -0.03635070f, 0.07513018f, 0.00432046f, 
    -0.17908397f, -0.25824726f, -0.02922230f, -0.11891978f, 0.01419759f, -0.10409526f, -0.05405509f, 0.00657959f, 
    -0.12048412f, -0.26264238f, -0.16067821f, 0.04030374f, 0.16064166f, 0.07785963f, -0.04986556f, 0.20098211f, 
    0.16253074f, -0.07785037f, -0.32213771f, -0.16436401f, 0.12308862f, -0.01475990f, 0.08823907f, 0.04953630f, 
    0.17932560f, 0.10641517f, -0.15707886f, -0.02439203f, 0.21919493f, 0.17558423f, 0.01161921f, 0.03223757f, 
    -0.11094959f, 0.27717242f, 0.19083054f, -0.11130060f, 0.14922921f, -0.09544826f, -0.01459030f, -0.14953938f, 
    -0.01039962f, 0.00975626f, -0.01120427f, 0.00034404f, -0.03834064f, -0.04638758f, 0.05996838f, -0.05381377f, 
    0.05886173f, 0.00280029f, 0.05501952f, 0.16808428f, -0.05277906f, -0.09576469f, -0.00120722f, -0.05398452f, 
    0.03742908f, -0.22643310f, -0.02551267f, -0.17172593f, 0.04395668f, -0.11944149f, -0.13195372f, -0.10233925f, 
    -0.11369123f, 0.19393757f, -0.01530616f, 0.04725586f, 0.05965433f, -0.00693340f, 0.07729387f, -0.07740930f, 
    -0.35429937f, 0.12093452f, 0.11295373f, 0.01567199f, 0.12420052f, -0.34866625f, 0.34422243f, 0.06179731f, 
    -0.11407317f, -0.07941378f, 0.28233945f, 0.02190931f, -0.06484558f, -0.09388091f, 0.11129820f, -0.12728959f, 
    0.12838213f, 0.07887380f, 0.05234636f, -0.14525618f, -0.37679720f, 0.02554309f, 0.01563685f, 0.08543376f, 
    0.02348854f, -0.33399427f, -0.14793244f, 0.08215549f, -0.11434227f, -0.05383898f, -0.08301797f, 0.03095348f, 
    0.11698013f, 0.06133466f, 0.05196992f, -0.01191986f, 0.27121237f, 0.00074806f, 0.03697583f, 0.10426353f, 
    0.02979242f, -0.06608292f, -0.25392190f, -0.02443608f, -0.29462066f, -0.14442530f, 0.18852490f, 0.21688338f, 
    0.21608512f, 0.08184335f, 0.29534590f, 0.00651666f, -0.13381810f, -0.04641604f, 0.03185549f, -0.23707816f, 
    0.22998619f, 0.00091425f, 0.22045435f, 0.09914836f, -0.29619965f, -0.21242329f, 0.10677443f, -0.07340343f, 
    0.05402122f, 0.09294160f, -0.06963929f, -0.22715104f, 0.22823158f, -0.22064556f, 0.21636339f, 0.16022484f, 
    -0.05485446f, 0.02694397f, -0.06785029f, -0.18503442f, 0.08614763f, 0.05676782f, -0.11535019f, -0.11174377f, 
    0.12306907f, 0.09510697f, -0.03486359f, 0.10565569f, -0.10406350f, 0.02760188f, 0.04924876f, -0.12086731f, 
    0.06439719f, 0.11001513f, -0.08604832f, -0.11294477f, 0.06244278f, -0.05551090f, 0.00186751f, 0.12570602f, 
    -0.05266954f, -0.17898087f, 0.07334089f, 0.08307797f, -0.00903684f, -0.07637107f, -0.08327684f, -0.12821981f, 
    0.04748779f, 0.07505565f, 0.16903144f, 0.01491190f, -0.27539146f, 0.03721588f, -0.10088531f, 0.34107089f, 
    -0.07807860f, 0.14747548f, 0.26729310f, 0.00719749f, -0.02401014f, 0.27513748f, -0.08339828f, 0.06186561f, 
    -0.02859819f, 0.15808657f, 0.27483219f, -0.00699980f, 0.19213878f, -0.01440104f, 0.12068979f, 0.03712787f, 
    0.13087399f, 0.19039355f, 0.21957396f, 0.01568461f, -0.11946569f, 0.36465114f, -0.09646921f, -0.27628085f, 
    0.10657331f, -0.06904513f, -0.31411752f, 0.06242983f, -0.00557289f, 0.14771903f, 0.00572030f, 0.10637408f, 
    -0.11374331f, -0.10957558f, 0.21107651f, 0.17430948f, -0.08035295f, 0.04559969f, -0.05437945f, 0.08168828f, 
    -0.07248223f, 0.12389165f, -0.11836574f, -0.07540866f, -0.07227844f, -0.03480360f, 0.25284001f, 0.10136231f, 
    0.10295475f, -0.42521542f, -0.01294257f, 0.02800233f, 0.14867526f, 0.03035662f, -0.07136349f, -0.05800691f, 
    0.02603856f, 0.11183701f, 0.30315855f, 0.24295834f, -0.05161903f, 0.09981804f, -0.01164009f, -0.07571729f, 
    -0.00037204f, -0.11987318f, -0.25067553f, 0.21799499f, -0.27818409f, 0.04306034f, 0.08336326f, 0.21949047f, 
    0.05826022f, 0.24084713f, -0.13279469f, -0.02840563f, -0.27238148f, -0.23489946f, 0.04189391f, -0.06213316f, 
    0.24089178f, -0.24684137f, -0.12373595f, 0.13350658f, -0.04082154f, 0.10308369f, -0.04427932f, 0.21469699f, 
    -0.08391429f, -0.09691430f, 0.38439605f, 0.05374364f, -0.04946934f, 0.08652103f, 0.12468274f, 0.19502956f, 
    0.02733703f, -0.01301321f, 0.14839593f, 0.04947807f, -0.06344668f, -0.16789255f, 0.03690442f, -0.04604199f, 
    0.15193108f, 0.08655401f, -0.07638326f, 0.06903592f, -0.28320822f, -0.09548294f, 0.06193518f, 0.20049444f, 
    -0.29236042f, -0.16634189f, 0.34107322f, 0.02985887f, 0.26928663f, -0.10819014f, -0.11834972f, 0.04263499f, 
    -0.00852838f, 0.10228387f, 0.15281700f, 0.13632892f, -0.19135121f, -0.24242403f, -0.02362349f, 0.14565220f, 
    0.04698685f, 0.22449659f, 0.09550118f, -0.18052028f, -0.24671075f, 0.11725383f, 0.12149813f, -0.17706820f, 
    0.29603529f, 0.07536941f, 0.17707264f, -0.00344887f, 0.04721837f, 0.06714085f, 0.10050789f, -0.03206352f, 
    0.32746479f, -0.00002824f, -0.01422728f, -0.26344860f, -0.13336185f, -0.15511104f, 0.27605510f, 0.11902253f, 
    0.13964595f, -0.05981471f, -0.04393095f, -0.03888356f, 0.16885103f, -0.15802002f, -0.08742985f, 0.07948835f, 
    -0.02461607f, -0.02660270f, -0.02689913f, 0.14478789f, 0.06386722f, -0.06342874f, -0.01757873f, -0.02606476f, 
    -0.10061102f, 0.09626870f, 0.15132795f, 0.08229173f, -0.26041219f, -0.08580480f, 0.13947670f, -0.02656996f, 
    -0.16462456f, 0.13856585f, 0.10551060f, 0.05961272f, -0.10277870f, -0.01658740f, -0.06278399f, -0.08995795f, 
    0.09988257f, -0.01775976f, -0.25579438f, -0.03839126f, -0.16285349f, 0.07839887f, 0.12011462f, -0.39683935f, 
    0.25600526f, -0.16890919f, 0.28841901f, -0.00325938f, -0.00354952f, -0.06367928f, -0.37117791f, -0.24850839f, 
    0.01641323f, 0.06577600f, 0.06988794f, -0.11310049f, -0.04746021f, 0.35025278f, -0.10445280f, -0.09529892f, 
    0.28037301f, -0.02348794f, 0.18323553f, 0.12185249f, 0.31856912f, -0.06024739f, 0.03249146f, 0.23880288f, 
    -0.03110203f, -0.05613548f, -0.08595644f, 0.28572640f, -0.17834128f, 0.21874909f, 0.22197184f, -0.08013866f, 
    0.13802451f, 0.08590507f, -0.15237887f, -0.20388877f, -0.05820379f, 0.13210589f, -0.19039382f, -0.00673136f, 
    0.05723585f, 0.05004131f, -0.15461837f, -0.09685169f, 0.35792375f, -0.01178233f, 0.05107858f, -0.26687995f, 
    -0.03391149f, 0.02023632f, -0.01581196f, -0.03970753f, -0.12348796f, 0.12362017f, 0.02233262f, -0.12716559f, 
    0.02058910f, -0.01249922f, 0.26345056f, -0.20409623f, 0.13392393f, 0.21804209f, 0.01938537f, 0.21360673f, 
    0.10674499f, -0.00159820f, -0.45512679f, -0.27643767f, -0.08914318f, 0.26518407f, 0.07096703f, -0.22797425f, 
    0.10948610f, 0.12035308f, -0.05400235f, -0.01013190f, 0.15924452f, 0.01516785f, 0.11453923f, 0.02249052f, 
    0.11053756f, 0.03276039f, 0.23685601f, -0.15129992f, -0.31645527f, 0.10184593f, 0.10308856f, 0.15366392f, 
    0.09064573f, 0.02942760f, 0.32366207f, 0.04633935f, -0.02750407f, 0.32954749f, -0.14569433f, -0.14940029f, 
    -0.11087197f, 0.01701014f, -0.03784357f, -0.02428697f, 0.16495888f, 0.21491037f, 0.06205981f, -0.05914170f, 
    -0.10735210f, -0.16586523f, 0.08582906f, -0.12994961f, 0.04251619f, 0.04896110f, 0.14250053f, 0.16665350f, 
    -0.08456901f, -0.02927776f, -0.05841536f, 0.04361455f, -0.06068723f, 0.06393919f, 0.05304627f, 0.08431551f, 
    0.00755244f, -0.02679162f, -0.10204051f, 0.08881371f, -0.05179531f, -0.12108614f, 0.06119807f, 0.01863615f, 
    -0.11563563f, 0.09263771f, -0.08624263f, 0.01002276f, -0.11834394f, -0.12835354f, -0.08252550f, -0.00595726f, 
    -0.03320533f, -0.06203047f, -0.08487092f, 0.10977075f, -0.12183415f, -0.08129111f, 0.00221083f, -0.12215546f, 
    -0.06794775f, 0.01616519f, -0.06020700f, 0.07809792f, 0.05172367f, 0.12375334f, -0.08680284f, -0.07397446f, 
    0.03948161f, -0.11009654f, 0.07812010f, -0.12788764f, -0.07756787f, 0.02666674f, -0.05351837f, -0.04349732f, 
    0.09653311f, 0.09399781f, 0.05229955f, -0.04410556f, -0.00797561f, -0.10324273f, 0.03404843f, 0.11354999f, 
    -0.09639593f, 0.03913332f, -0.01749447f, 0.10711005f, 0.08727558f, 0.05921370f, -0.10363844f, -0.13337681f, 
    0.00316690f, -0.01213767f, 0.04123176f, 0.11970012f, 0.07361305f, 0.04615836f, 0.09521460f, -0.04716596f, 
    0.04953502f, 0.00837519f, -0.17244944f, 0.11003873f, -0.33888865f, -0.02754560f, 0.03644489f, 0.19578199f, 
    0.03271831f, -0.16713895f, 0.18238200f, -0.05364635f, -0.02813053f, 0.08094400f, -0.19658691f, -0.26820430f, 
    0.09308612f, 0.16979659f, 0.20153221f, 0.02766914f, 0.05057823f, -0.03826776f, 0.07394919f, 0.09255320f, 
    0.23124114f, -0.13600688f, -0.06575107f, 0.02908650f, 0.22352655f, 0.18358086f, 0.07335041f, -0.07014189f, 
    -0.12157887f, 0.04522135f, -0.36065051f, 0.11638286f, -0.19921409f, 0.35641482f, 0.09497830f, 0.02868056f, 
    -0.06404670f, 0.07458691f, 0.03952233f, 0.11087766f, -0.25600517f, 0.08461398f, -0.12066033f, -0.09233575f, 
    0.18738188f, -0.06856189f, -0.08860660f, -0.00564711f, 0.25205630f, 0.03186414f, -0.12119347f, 0.00804833f, 
    -0.08028703f, -0.10687237f, 0.11543591f, 0.02805376f, 0.13819601f, 0.09648348f, 0.06274039f, 0.08985640f, 
    0.02147054f, -0.00371821f, -0.03893141f, 0.34759018f, -0.09492616f, -0.04796117f, 0.06491902f, -0.22332157f, 
    0.14023830f, -0.12329991f, -0.01722914f, 0.00884518f, 0.05750195f, 0.11416166f, -0.02978022f, -0.01653166f, 
    0.13639194f, 0.01311445f, -0.20234405f, -0.02910607f, -0.05861202f, 0.14327475f, 0.00076319f, 0.06753168f, 
    0.16223150f, 0.01312830f, 0.22226818f, -0.08810391f, 0.18840273f, -0.31885281f, 0.02875059f, 0.28368035f, 
    -0.19428796f, -0.11720347f, 0.33327329f, 0.01690490f, -0.01279822f, -0.01998981f, -0.01050150f, -0.13694081f, 
    0.13567670f, -0.03961915f, 0.01194143f, 0.10096789f, 0.08452138f, -0.11941567f, 0.09230212f, -0.02547345f, 
    0.01973250f, 0.08140785f, -0.11095297f, 0.02714571f, -0.01589242f, -0.01704286f, -0.12961456f, 0.15768938f, 
    0.19208723f, -0.29054353f, 0.16703703f, -0.07757337f, 0.03437800f, -0.03131116f, 0.03397594f, -0.06538709f, 
    -0.09524740f, 0.00894146f, -0.02969605f, 0.32732776f, -0.18866986f, 0.20904638f, 0.04992613f, 0.19703265f, 
    0.26325986f, 0.09458219f, -0.19564050f, -0.01307500f, -0.02730849f, 0.26717597f, -0.03345378f, 0.01561627f, 
    0.41679761f, -0.01907088f, -0.04037169f, -0.06846880f, 0.01297792f, -0.02735532f, -0.02117851f, -0.02036391f, 
    0.00042118f, 0.16668631f, 0.19256531f, -0.03358306f, 0.10134286f, 0.03277410f, 0.10127928f, 0.35831317f, 
    -0.10091373f, 0.03297032f, 0.39917117f, 0.02329269f, -0.02317067f, 0.04091023f, -0.14544235f, 0.26599631f, 
    -0.06455274f, 0.06272794f, 0.04728935f, -0.00423419f, -0.07887295f, -0.02045897f, -0.03345729f, -0.05545330f, 
    -0.09670232f, 0.01418275f, -0.06454618f, -0.01015878f, 0.02041777f, -0.05066144f, -0.21701227f, 0.26733235f, 
    -0.03982107f, 0.01142311f, 0.05067337f, 0.00232893f, -0.05250367f, 0.06703851f, -0.02881970f, -0.03143732f, 
    0.01988125f, -0.02296010f, 0.02265128f, -0.04867086f, 0.05602708f, -0.05216587f, -0.10544775f, 0.09225674f, 
    -0.11377770f, 0.02180523f, -0.09610573f, 0.01508700f, 0.05081118f, -0.04577562f, -0.19121091f, 0.00027427f, 
    -0.10757627f, 0.01914714f, -0.19496021f, 0.01148625f, -0.07933351f, 0.02366721f, 0.01200437f, 0.05515695f, 
    -0.11099712f, -0.12906368f, 0.04864319f, 0.02905562f, -0.09414151f, -0.11535960f, 0.03514592f, -0.04976482f, 
    -0.09620745f, 0.03934811f, -0.00049737f, 0.06277565f, -0.12836863f, -0.13115682f, -0.13281374f, 0.13084775f, 
    -0.11339336f, 0.07672079f, -0.08739068f, -0.15627269f, 0.02209595f, 0.05588729f, -0.05980884f, 0.03534774f, 
    -0.03469325f, -0.12074270f, 0.03112410f, -0.11552697f, 0.06384689f, -0.11545920f, 0.02511013f, -0.15114306f, 
    0.01144283f, 0.10492395f, -0.02944791f, -0.05722784f, 0.07251943f, -0.09760844f, -0.02545887f, -0.01083869f, 
    -0.11359543f, 0.08456802f, -0.11491628f, -0.26392230f, -0.04690591f, 0.08651172f, 0.20938955f, 0.03583495f, 
    -0.26767436f, 0.04192455f, -0.19052207f, 0.13603936f, -0.20221545f, -0.10498212f, 0.14121696f, -0.16649684f, 
    0.06176338f, -0.13646649f, 0.14685610f, -0.06640881f, -0.49453554f, -0.49407044f, 0.07592640f, 0.09681530f, 
    0.38679478f, -0.18979605f, -0.20218256f, -0.46253601f, -0.02967014f, -0.08731626f, 0.13098317f, 0.08519804f, 
    -0.17064825f, 0.09835484f, -0.05862778f, -0.17835706f, 0.13030992f, 0.24785773f, 0.04450329f, -0.29227397f, 
    -0.46722034f, 0.01044040f, 0.16322885f, -0.15970668f, 0.08702723f, 0.14122623f, 0.06718276f, -0.01268380f, 
    0.13241619f, 0.20207617f, 0.13879064f, -0.02077057f, 0.19954853f, -0.06694703f, 0.08529671f, 0.24421845f, 
    -0.24348345f, 0.08823242f, -0.07517750f, -0.10189465f, 0.09583919f, -0.07554615f, 0.08077215f, -0.05202045f, 
    -0.04393039f, -0.11267906f, -0.03482378f, 0.15679932f, -0.11250214f, 0.12961492f, -0.05036923f, 0.21593805f, 
    0.07901280f, -0.06468388f, 0.00598318f, -0.03022940f, -0.02412320f, 0.30062178f, 0.25754231f, -0.06518386f, 
    0.26149443f, 0.10607656f, -0.16279902f, -0.05267267f, 0.14165726f, 0.10129977f, 0.00664243f, 0.07067695f, 
    0.07564566f, -0.14729032f, -0.01201990f, 0.05489935f, 0.09626058f, -0.22475305f, 0.08663592f, 0.15037343f, 
    0.05631322f, 0.00511429f, 0.63673282f, -0.08469009f, -0.03172223f, -0.08747266f, 0.01883253f, 0.12072596f, 
    -0.19674715f, 0.12327269f, 0.23509479f, 0.30766311f, -0.08704285f, -0.08893608f, 0.14748517f, 0.06842759f, 
    0.02505741f, 0.02692987f, 0.04286538f, -0.04970177f, -0.06146618f, -0.11669765f, -0.16953667f, -0.13039270f, 
    -0.17047767f, 0.22325626f, 0.12065534f, 0.03822138f, -0.10797799f, -0.06108338f, -0.04063030f, -0.11507862f, 
    0.10577570f, 0.08029539f, -0.22238630f, -0.16316327f, 0.25523043f, -0.04459457f, -0.13652712f, 0.04406423f, 
    0.20582065f, 0.07779918f, -0.20608540f, -0.21009648f, 0.13385515f, -0.23519044f, 0.02182413f, -0.06777392f, 
    -0.00190679f, -0.15573540f, -0.19159788f, -0.01676024f, 0.04703126f, 0.25813997f, 0.08566553f, 0.01858030f, 
    -0.16558747f, -0.09993585f, -0.03751346f, -0.03066616f, -0.33673036f, 0.01271577f, 0.19914725f, -0.13976195f, 
    0.19869347f, 0.01392737f, 0.17806707f, -0.37764966f, 0.15425098f, 0.12277178f, -0.33010769f, -0.20688958f, 
    -0.23533578f, -0.00367313f, 0.12517647f, 0.08908570f, 0.17280561f, 0.13817799f, 0.18737577f, -0.12262881f, 
    0.26933649f, 0.04974529f, 0.22421138f, 0.07540178f, -0.55982000f, -0.05500957f, 0.15847123f, 0.06989537f, 
    0.15775579f, 0.05640318f, -0.16367549f, 0.07640986f, 0.03289951f, -0.07258713f, -0.11835752f, -0.09978573f, 
    -0.06840350f, 0.03481602f, 0.15334269f, -0.08915926f, -0.11381106f, 0.02956298f, -0.17533749f, 0.33866274f, 
    0.04463593f, 0.16099623f, -0.28099915f, -0.23114654f, 0.03893328f, 0.27301314f, 0.01815937f, -0.03451190f, 
    0.11746773f, 0.19844560f, 0.11054598f, -0.00160841f, 0.18615232f, 0.05032115f, 0.00765969f, 0.06584714f, 
    -0.05027025f, 0.14122325f, 0.10817531f, 0.08997925f, -0.11767399f, 0.41438144f, -0.08375908f, -0.15004025f, 
    -0.00337670f, -0.00204820f, -0.20840056f, -0.03218382f, 0.15556341f, 0.27986965f, -0.20157903f, 0.15941231f, 
    -0.02591767f, 0.03701343f, 0.21224162f, -0.13715585f, -0.09107240f, -0.04632534f, -0.23932920f, -0.06697540f, 
    0.10230686f, -0.13015331f, 0.09439592f, 0.10831914f, -0.01127691f, -0.02802018f, 0.30173683f, 0.18044326f, 
    -0.04491777f, 0.22103643f, -0.03090717f, -0.09029028f, 0.20492342f, -0.04754616f, 0.04943886f, 0.05364815f, 
    0.00064137f, -0.09993191f, -0.08340403f, -0.00174267f, 0.36109373f, 0.15956010f, 0.15115170f, -0.02726671f, 
    -0.21631758f, -0.02598533f, -0.12473042f, -0.01166800f, 0.08203379f, -0.16403913f, 0.19828297f, 0.02258668f, 
    -0.37103197f, -0.11205532f, 0.05003498f, -0.05370981f, 0.34972107f, -0.07535703f, -0.08763874f, -0.01053143f, 
    0.15134932f, -0.25222456f, -0.00380176f, -0.14475638f, -0.10550680f, 0.03013987f, -0.07758119f, 0.01065737f, 
    -0.05168690f, 0.02810077f, -0.09584825f, 0.02435863f, -0.00993161f, 0.26260287f, 0.20049115f, 0.00444690f, 
    -0.31135675f, 0.02738140f, 0.01840534f, 0.13995764f, 0.32206789f, 0.25362802f, 0.27051789f, 0.00250804f, 
    0.15828624f, -0.01862936f, 0.00625677f, -0.04096800f, -0.05428147f, -0.10196366f, 0.21099083f, -0.06011908f, 
    -0.28050977f, 0.22556056f, -0.04815979f, -0.08497252f, 0.04454594f, 0.07775054f, 0.02356491f, 0.10871936f, 
    0.04647046f, 0.06899224f, -0.15723124f, 0.04900131f, 0.15444539f, -0.17352410f, 0.06395547f, -0.02005412f, 
    -0.06356613f, 0.08547335f, 0.33500159f, 0.43928564f, -0.21065989f, 0.12685767f, 0.18130596f, 0.13981763f, 
    -0.27591026f, 0.15548563f, 0.30216944f, 0.11685548f, -0.06406306f, -0.13263562f, 0.05339473f, 0.11781319f, 
    0.03737696f, -0.24661355f, -0.14824350f, -0.04002064f, 0.01891243f, 0.16937795f, -0.20125523f, -0.14241745f, 
    0.00925639f, 0.04150152f, -0.22369125f, 0.20281635f, 0.15393460f, -0.16235408f, 0.26757690f, -0.00670109f, 
    -0.10481197f, 0.02134372f, 0.12583260f, 0.27103662f, 0.20191595f, 0.04820447f, 0.09749111f, 0.04473908f, 
    -0.14810695f, 0.23869011f, -0.13452280f, -0.01805008f, -0.07191832f, -0.02358892f, 0.25341159f, -0.06216982f, 
    0.10598963f, -0.27111286f, 0.01948421f, 0.12471762f, -0.05379204f, 0.01758131f, 0.05030738f, 0.09118131f, 
    0.02095114f, -0.02640336f, 0.12499829f, 0.34419805f, 0.21090621f, 0.37659726f, 0.11613912f, 0.00355558f, 
    -0.07217238f, 0.04763543f, -0.57309103f, -0.21438402f, -0.06133204f, 0.10865420f, 0.17800681f, 0.21673726f, 
    -0.21850450f, 0.13102178f, -0.26601657f, -0.10326430f, 0.09345955f, 0.07071849f, 0.04503584f, 0.03946913f, 
    0.12446262f, -0.12720054f, 0.05627760f, 0.05230544f, -0.07833949f, 0.16681440f, 0.03842510f, 0.12164978f, 
    0.00106591f, 0.01024063f, 0.33304429f, -0.00961107f, -0.06050592f, 0.26524466f, 0.16873986f, 0.26053837f, 
    -0.17132415f, -0.01120116f, 0.07563560f, -0.13979033f, 0.11722025f, -0.02408618f, -0.02897212f, 0.01619588f, 
    0.22442079f, -0.18275577f, -0.02204183f, -0.01328233f, -0.13616578f, 0.10920849f, 0.06186428f, 0.18284781f, 
    -0.30416667f, 0.27799696f, 0.19530642f, -0.00231742f, 0.21214750f, 0.02385513f, -0.09326759f, -0.04619779f, 
    0.08297001f, -0.03198894f, -0.29071936f, 0.11030748f, 0.23836313f, -0.09069914f, -0.02980191f, 0.06544852f, 
    0.04962829f, 0.15711264f, 0.00537755f, -0.14890723f, -0.08837198f, -0.00325568f, 0.19919111f, 0.08202487f, 
    0.22219494f, -0.07938734f, 0.02527868f, -0.10277151f, 0.17926945f, 0.17566200f, 0.10380261f, 0.07815594f, 
    0.06382178f, 0.00787091f, 0.15539558f, 0.00046802f, -0.17083630f, -0.16253954f, 0.17868367f, -0.00278869f, 
    -0.08335509f, -0.04572703f, 0.26154518f, -0.17482944f, 0.15300162f, -0.02159452f, 0.08601817f, -0.18619154f, 
    -0.21446419f, 0.04358791f, -0.02612839f, 0.09305319f, 0.48228490f, 0.17402230f, 0.30940750f, -0.07151617f, 
    -0.08639363f, 0.07283913f, 0.22675993f, -0.11988942f, -0.14504422f, 0.05916151f, 0.03179055f, -0.00026988f, 
    0.13430597f, 0.09095196f, 0.14634943f, 0.03797427f, -0.23714228f, 0.11101823f, 0.04298557f, 0.01092408f, 
    0.00042605f, 0.09766889f, -0.15157036f, -0.01297846f, -0.10030089f, 0.06218246f, 0.27634031f, 0.09494828f, 
    0.06791081f, -0.01056724f, 0.18323107f, -0.29312181f, -0.00071499f, -0.11015166f, -0.14837909f, 0.26411188f, 
    -0.20311111f, 0.13641174f, 0.16003482f, -0.08015838f, 0.21926801f, -0.11898952f, -0.01024730f, 0.00944816f, 
    -0.07999370f, 0.03052315f, 0.15209675f, 0.07647999f, 0.10821888f, 0.25000608f, 0.02474736f, -0.18077695f, 
    0.04970186f, 0.08815452f, -0.31996232f, -0.14848723f, -0.12571579f, 0.12692718f, 0.16375029f, 0.00218264f, 
    -0.16017978f, 0.04634539f, -0.11151656f, 0.21740469f, -0.01199787f, 0.27564320f, 0.39578894f, 0.00779546f, 
    0.20215663f, -0.01545080f, 0.14800094f, 0.07792327f, 0.16842897f, -0.11872411f, -0.18043445f, 0.12132361f, 
    0.11088500f, -0.07008892f, 0.11895387f, -0.08215502f, 0.16791011f, -0.01292891f, -0.07852307f, -0.05063416f, 
    0.04401658f, -0.05438338f, -0.10474787f, -0.12318990f, 0.02144414f, -0.01304669f, 0.01116587f, 0.16728203f, 
    -0.04050530f, 0.16310310f, 0.00717367f, -0.04964112f, 0.03363317f, -0.30486643f, -0.02683199f, -0.09214720f, 
    -0.00798198f, -0.12752418f, 0.06523396f, 0.06871724f, -0.15683205f, -0.03822326f, -0.10075095f, -0.03141951f, 
    0.04935881f, -0.20007017f, -0.20456621f, -0.05964202f, -0.19482774f, 0.30795908f, 0.20448500f, 0.03004471f, 
    0.14743567f, -0.04345889f, -0.24225111f, -0.25213340f, 0.12245318f, 0.19164030f, -0.21495794f, -0.15934688f, 
    -0.06239589f, -0.10973705f, 0.01602638f, -0.09493981f, 0.21539032f, 0.18722539f, -0.10994772f, -0.00536278f, 
    0.08623225f, 0.19092219f, 0.26974815f, 0.03349968f, -0.08836014f, -0.05634087f, 0.09881956f, 0.27207103f, 
    -0.08709579f, -0.14654651f, 0.28582528f, 0.08605874f, 0.02455194f, -0.01690716f, -0.01823877f, -0.00176135f, 
    0.06283310f, 0.08740859f, 0.03944216f, -0.03947796f, 0.28270170f, -0.21287610f, -0.09307712f, -0.08999605f, 
    0.03876084f, 0.21555121f, -0.05435223f, -0.06711706f, -0.07620329f, -0.10917283f, 0.08316736f, -0.06140416f, 
    -0.06238246f, 0.17575581f, -0.08493497f, 0.02817458f, 0.03667746f, -0.00461872f, 0.05958966f, 0.08991995f, 
    0.18920170f, -0.15386948f, -0.04708001f, 0.09267328f, -0.28809604f, 0.35577193f, 0.05211483f, -0.16642590f, 
    0.09354191f, -0.00147302f, -0.14798087f, -0.10910494f, 0.11119226f, -0.17107460f, -0.23320647f, -0.09205225f, 
    0.02993467f, -0.00226930f, -0.07781979f, 0.03967484f, 0.12382415f, 0.03971880f, -0.03835145f, 0.05512431f, 
    -0.18007474f, 0.10951716f, 0.17050172f, -0.03012254f, -0.31541321f, 0.06637397f, 0.26367718f, 0.21328743f, 
    0.42868522f, -0.08914040f, 0.09342465f, 0.00854497f, -0.13090757f, -0.03649240f, 0.07533255f, 0.07279633f, 
    0.04993246f, 0.05777330f, -0.02152056f, -0.07926031f, -0.04587142f, -0.07281572f, 0.29624397f, 0.00889027f, 
    0.30305898f, -0.10770201f, 0.01708721f, -0.19597369f, -0.06996685f, 0.07879335f, -0.37206218f, 0.14640512f, 
    0.10821662f, -0.10157103f, 0.12671407f, -0.02163426f, 0.08592498f, -0.11861669f, 0.03614396f, 0.06249988f, 
    -0.07604945f, 0.04871765f, 0.20200711f, -0.02763243f, 0.17004643f, 0.02045247f, 0.02554308f, 0.17576155f, 
    -0.03861579f, -0.05688559f, -0.23112923f, 0.01166406f, -0.28428361f, 0.19149224f, 0.15174191f, -0.04263173f, 
    0.00977105f, 0.03429462f, -0.17852622f, 0.03818027f, -0.21821027f, 0.10685930f, -0.00741739f, 0.09046966f, 
    -0.13517649f, 0.07400540f, -0.08371960f, -0.12523252f, 0.16905791f, 0.02799705f, -0.11612634f, 0.23357829f, 
    -0.16997536f, -0.07297692f, -0.23024525f, -0.03085962f, -0.17863791f, 0.11657204f, -0.11837465f, 0.05873609f, 
    -0.10067358f, -0.02398877f, 0.22528380f, -0.15376888f, 0.23753026f, -0.02543917f, -0.25650591f, 0.01869675f, 
    0.02558436f, -0.18953565f, -0.12183436f, 0.07460428f, 0.09259995f, 0.02219703f, -0.03659006f, -0.12376459f, 
    0.03722801f, -0.01122543f, -0.05183232f, 0.05845239f, -0.09146077f, -0.08306070f, 0.06109465f, 0.01348352f, 
    -0.21653125f, 0.18755029f, 0.03348956f, 0.09705472f, -0.04322735f, 0.17883661f, -0.18007611f, -0.18803649f, 
    0.00515231f, -0.13232663f, -0.03708624f, 0.06163383f, 0.06948668f, 0.12571771f, -0.24780317f, -0.03514896f, 
    -0.01036605f, 0.02951556f, -0.17804174f, -0.09218778f, -0.16903922f, -0.22520213f, -0.01647823f, -0.12562452f, 
    0.05642082f, -0.19028947f, 0.32413876f, -0.01357140f, -0.05706313f, -0.01194394f, -0.36202967f, -0.18010466f, 
    0.10632116f, -0.16415399f, 0.13356584f, -0.00021491f, 0.33790478f, 0.09991181f, -0.00550084f, -0.10852890f, 
    -0.11232899f, 0.05923715f, 0.40704110f, 0.36728784f, 0.00445727f, 0.07823394f, 0.03643551f, -0.07337193f, 
    -0.23301999f, -0.00052454f, -0.04855027f, 0.43140027f, -0.37454125f, -0.11185206f, 0.18179721f, 0.14530824f, 
    -0.18558000f, 0.22411238f, -0.03084751f, -0.00437908f, -0.19457123f, -0.23408264f, 0.02691973f, 0.04000911f, 
    0.27882129f, -0.27087572f, -0.25978988f, 0.05992945f, -0.01148500f, 0.12146655f, -0.16435632f, 0.26066986f, 
    -0.08198751f, 0.10455471f, 0.23431265f, 0.21127270f, 0.10028461f, 0.07933545f, 0.09164512f, 0.15650292f, 
    -0.10648400f, -0.01358920f, 0.35377479f, 0.31280002f, 0.03179640f, -0.24197742f, -0.06199840f, 0.08147749f, 
    0.04401382f, 0.03746195f, -0.14169182f, -0.12261770f, -0.21268927f, -0.09459288f, -0.01722438f, 0.06891314f, 
    0.48708487f, -0.04948143f, 0.25394320f, 0.03417742f, -0.04813883f, -0.07731586f, 0.04414514f, -0.10034804f, 
    -0.02105208f, 0.08856663f, -0.02117707f, 0.04790306f, -0.06189336f, 0.06338865f, 0.18788905f, 0.00750815f, 
    0.05842970f, -0.14005508f, -0.31962010f, -0.07228167f, -0.11528406f, -0.02450080f, -0.01453293f, 0.25176150f, 
    -0.04853732f, 0.07713395f, -0.20308140f, 0.01848377f, -0.03873300f, -0.20778970f, -0.00395877f, -0.09654547f, 
    -0.08853950f, -0.04973796f, 0.13927630f, -0.06765941f, 0.02566368f, -0.14180681f, 0.16107982f, 0.28812516f, 
    0.05944399f, -0.06101344f, 0.06531896f, -0.01659673f, -0.01767681f, 0.04620339f, 0.15520583f, 0.23152553f, 
    0.13818412f, -0.05412970f, -0.05467608f, -0.10130936f, -0.12997139f, 0.21910340f, 0.03136298f, 0.08704260f, 
    0.02064976f, -0.11607394f, -0.09080029f, 0.04124202f, 0.13504249f, -0.09272584f, -0.40219584f, 0.21085054f, 
    -0.03895977f, -0.39033511f, 0.26792538f, 0.05123463f, 0.04706560f, -0.09893287f, -0.04574251f, 0.05490330f, 
    -0.09255189f, -0.05973935f, -0.10476119f, -0.04890238f, -0.10356368f, -0.18671626f, 0.03859489f, -0.11412998f, 
    0.05680645f, 0.14171197f, 0.23241833f, 0.25323778f, -0.47927585f, -0.19183166f, -0.14814173f, 0.07938743f, 
    -0.17182000f, 0.25125691f, 0.24051341f, -0.03883038f, -0.06271502f, -0.25290567f, -0.08939552f, -0.11196506f, 
    0.31428856f, -0.19452219f, -0.17573260f, -0.09523128f, 0.03592561f, 0.11834855f, -0.02128990f, -0.07426118f, 
    -0.13715984f, 0.01778388f, -0.47297344f, 0.17644690f, 0.02444091f, 0.12515606f, 0.11107446f, -0.07455336f, 
    -0.26862848f, -0.11167890f, 0.09202402f, -0.00372150f, -0.06700806f, 0.01874399f, -0.19166930f, 0.10997659f, 
    0.28575715f, 0.18134706f, -0.17362216f, -0.02487027f, -0.16864236f, -0.10289397f, 0.04802001f, 0.21062608f, 
    0.09712306f, -0.01894707f, 0.05443414f, -0.00717489f, -0.15048724f, 0.10521479f, -0.09995829f, 0.10507385f, 
    0.00143576f, -0.12654996f, -0.08666310f, 0.04186455f, -0.09059636f, -0.04674757f, 0.00124308f, 0.01763805f, 
    0.09413052f, 0.05823467f, -0.09204554f, -0.12497787f, 0.07501754f, 0.05874772f, -0.05814894f, 0.03224715f, 
    -0.02721604f, -0.01296271f, -0.11272150f, -0.01649570f, 0.00699473f, -0.03900114f, -0.08329493f, 0.04416058f, 
    -0.06102335f, 0.02454105f, -0.13711669f, 0.05222598f, -0.08767988f, 0.04815915f, 0.08126225f, 0.00351645f, 
    -0.01850598f, -0.12359464f, -0.07030699f, -0.12449550f, 0.09573092f, -0.03172182f, 0.01092026f, -0.01334413f, 
    -0.05077062f, 0.10681635f, -0.09563460f, -0.00655670f, 0.05944717f, -0.12040701f, 0.03738112f, 0.00231068f, 
    0.00424770f, -0.02811139f, -0.10868271f, 0.06748596f, -0.03235527f, 0.00202288f, -0.07959986f, -0.09018357f, 
    -0.32280117f, -0.08413773f, -0.12763482f, -0.05607508f, -0.13524263f, 0.03526017f, -0.05033791f, 0.00589237f, 
    -0.08120771f, 0.03156136f, 0.19323118f, 0.17354837f, 0.08537339f, 0.28933841f, -0.13270645f, -0.09780422f, 
    0.11307695f, -0.05121859f, 0.02650292f, 0.33774439f, -0.08662315f, 0.16219886f, 0.05236794f, -0.14926499f, 
    -0.23326986f, 0.20408250f, 0.01713456f, -0.00162755f, 0.09276509f, 0.14442173f, 0.02632030f, 0.12873408f, 
    0.23418872f, 0.02245397f, 0.06013415f, 0.07616106f, 0.09156509f, 0.01196474f, -0.30584416f, 0.14068818f, 
    -0.10715590f, -0.10243171f, 0.23100476f, 0.25843719f, -0.03838053f, 0.24246308f, 0.16591193f, 0.18166426f, 
    -0.02022493f, -0.02749336f, 0.41259241f, -0.15710676f, -0.08568156f, -0.02457906f, -0.21033145f, 0.02616497f, 
    0.43206102f, -0.02388234f, -0.13155662f, -0.00368848f, 0.10220473f, -0.08084894f, 0.26524818f, -0.20061719f, 
    0.10858121f, -0.23370543f, 0.11447376f, -0.05324228f, -0.05479632f, -0.03452874f, -0.10955352f, 0.09190078f, 
    -0.02073292f, 0.08752941f, 0.15146290f, 0.03507879f, -0.23228759f, 0.02647722f, 0.01558402f, 0.04165342f, 
    -0.28809306f, 0.26474398f, 0.47316161f, 0.21462691f, -0.04179773f, 0.03424928f, -0.08372346f, 0.23046179f, 
    -0.26367119f, 0.31929392f, 0.19753432f, 0.02330916f, 0.12226355f, -0.12909339f, -0.11596214f, -0.05826251f, 
    0.08391856f, 0.11807741f, -0.13605043f, 0.20373985f, 0.11473840f, 0.17621519f, -0.13443324f, -0.18503314f, 
    -0.14071783f, 0.07894548f, -0.32375509f, 0.14354502f, 0.13094491f, -0.15021963f, 0.10015110f, 0.29815355f, 
    0.01728985f, -0.01794165f, 0.39789346f, 0.28038010f, 0.04893465f, -0.22989082f, -0.00600496f, 0.06874070f, 
    0.18970323f, 0.20126648f, -0.31997299f, 0.04846271f, -0.11174193f, -0.03835218f, 0.25781325f, -0.12131920f, 
    0.04374553f, -0.15258218f, 0.19716358f, 0.10115390f, 0.26810655f, 0.04493726f, 0.04601220f, -0.08128136f, 
    0.02114801f, -0.02655900f, 0.01036293f, -0.10530497f, 0.00253381f, -0.08611567f, 0.06207517f, -0.12281057f, 
    -0.10864816f, 0.08097189f, 0.11414281f, 0.13032368f, -0.42436448f, -0.21702224f, -0.10138248f, -0.21230261f, 
    0.02712426f, 0.00290775f, 0.19348069f, -0.04508871f, -0.30894637f, -0.32685417f, -0.02069207f, -0.08904518f, 
    0.32000393f, -0.18253605f, -0.32754272f, -0.25664628f, -0.07093895f, -0.07974264f, -0.03547231f, -0.03959605f, 
    -0.17460360f, 0.05347262f, -0.39158267f, -0.08626416f, 0.07819840f, 0.14689845f, 0.02252325f, -0.05246823f, 
    -0.33580780f, 0.10710391f, 0.18128519f, 0.03652135f, 0.19678497f, 0.13280609f, -0.00033532f, -0.00211917f, 
    0.13752069f, 0.06071937f, 0.09309639f, -0.00658223f, 0.20393836f, -0.01244198f, 0.25328922f, 0.21842955f, 
    0.33038768f, -0.09840054f, 0.00101837f, 0.06682690f, 0.06211744f, 0.06974391f, -0.06128082f, 0.01911245f, 
    0.04327570f, -0.01637271f, 0.10508250f, -0.04639916f, -0.25737739f, -0.01148551f, 0.16585682f, 0.19433686f, 
    0.01238045f, -0.03116766f, -0.04951897f, 0.11838959f, -0.10742117f, -0.10443034f, -0.18265536f, 0.04848681f, 
    0.00093817f, 0.01870123f, 0.03585797f, -0.10977325f, -0.09010447f, -0.45107713f, 0.09446796f, -0.08396775f, 
    -0.18968935f, 0.04426092f, 0.08346310f, -0.12761000f, 0.06480031f, -0.16925107f, 0.23148516f, 0.19254555f, 
    -0.12865850f, -0.06732843f, 0.20666383f, -0.02920899f, 0.06720616f, -0.13252683f, 0.03006635f, 0.10200072f, 
    -0.23027170f, -0.05184932f, 0.20265302f, 0.18826701f, -0.15955117f, 0.11644436f, 0.13524219f, 0.12194909f, 
    0.12410008f, -0.07867587f, -0.17049679f, 0.03006441f, -0.05745935f, -0.09954432f, -0.12952638f, 0.23689885f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.03463113f, 0.03326552f, -0.07289721f, 0.12007560f, 0.02385955f, 0.05889069f, -0.06527958f, -0.13415070f, 
    0.11997389f, -0.04044874f, 0.32458535f, 0.17899545f, 0.14877850f, 0.03496974f, -0.08628976f, -0.21001369f, 
    -0.00094772f, 0.17115535f, 0.20540360f, 0.01957791f, 0.04873927f, 0.07710821f, -0.00228441f, -0.00569104f, 
    -0.01409940f, -0.05875229f, 0.04876611f, 0.25020787f, -0.11852807f, -0.00389970f, 0.06144329f, -0.03272682f, 
    -0.02057697f, 0.03685649f, -0.00329730f, 0.12780246f, 0.16386738f, 0.07770284f, 0.07834719f, 0.20881477f, 
    0.15121555f, 0.13697943f, -0.09623368f, -0.10648823f, 0.16870499f, -0.02126615f, 0.07950640f, 0.15297782f, 
    0.00352007f, -0.03182029f, 0.19533868f, 0.25037903f, 0.01417420f, -0.02960535f, -0.09131873f, 0.05835127f, 
    -0.03071820f, -0.00949643f, -0.10290102f, 0.09419341f, 0.24577434f, 0.16455273f, -0.18356687f, -0.02196577f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.17594840f, -0.02615508f, 0.01311542f, -0.34401169f, 0.18687712f, -0.24509694f, -0.07963701f, 0.04909661f, 
    -0.36437476f, -0.11567508f, -0.07251573f, 0.06145618f, 0.10426120f, -0.29690704f, -0.18201946f, -0.07362580f, 
    0.04501293f, -0.14453536f, 0.03042229f, 0.03111118f, 0.03117689f, -0.07081027f, 0.38214508f, 0.06193381f, 
    0.18261458f, 0.17078461f, -0.26150745f, 0.17001426f, 0.11861733f, 0.00854939f, 0.06435916f, 0.00840742f, 
    0.14226143f, -0.07475032f, -0.40692151f, -0.04848864f, -0.38039163f, 0.20728059f, -0.11265263f, -0.02610919f, 
    -0.26129356f, -0.37456650f, -0.12601697f, 0.27356562f, -0.14553267f, 0.27462146f, 0.08556978f, 0.19483584f, 
    -0.02549230f, -0.19871566f, 0.10804986f, -0.17022838f, 0.18305786f, 0.00153283f, -0.34383941f, 0.24122836f, 
    -0.25661105f, -0.15840295f, -0.39047638f, -0.01685083f, -0.03636767f, -0.32044578f, 0.19577348f, -0.04244220f, 
    -0.33792534f, 0.03791121f, -0.11351176f, -0.25697550f, -0.23972264f, 0.18206036f, -0.03354532f, 0.09027780f, 
    -0.01181508f, 0.21888055f, 0.06290785f, 0.15352373f, 0.18873394f, -0.02306382f, -0.10365991f, -0.47692752f, 
    0.09745847f, 0.09625864f, 0.06740962f, 0.06483706f, -0.00997615f, 0.07606441f, -0.69845974f, -0.25720987f, 
    -0.05058265f, 0.12991962f, 0.10307436f, 0.18553975f, 0.18612881f, -0.20701335f, -0.00546183f, -0.15933646f, 
    -0.04192629f, 0.08178174f, -0.34356409f, 0.08333139f, 0.20842552f, 0.16893819f, 0.09584949f, 0.37397313f, 
    -0.11540676f, -0.00798033f, 0.05179160f, -0.72506607f, 0.04797552f, 0.46686906f, 0.11777979f, -0.12445302f, 
    -0.24044181f, 0.11452965f, 0.15739450f, 0.04172148f, 0.15530065f, 0.35869712f, -0.00896232f, 0.10771574f, 
    -0.46176323f, -0.14941257f, -0.36619538f, -0.07975333f, 0.12037817f, -0.19182919f, -0.31534511f, -0.51305282f, 
    0.21213455f, -0.21418975f, -0.07863126f, 0.12284303f, 0.06746276f, 0.02542422f, -0.01118857f, -0.42994198f, 
    -0.06263389f, -0.58021581f, 0.08036938f, -0.01030210f, 0.17024885f, 0.19503887f, -0.07091689f, -0.32592040f, 
    -0.02804926f, -0.02318759f, 0.10039642f, 0.02161413f, -0.21574198f, -0.02256367f, -0.18702693f, -0.11852380f, 
    0.01683361f, -0.01174375f, -0.03808150f, 0.10642652f, -0.09512290f, 0.01561912f, -0.46807456f, 0.04094130f, 
    -0.73421460f, 0.10381651f, 0.16981812f, 0.07336192f, -0.33692965f, 0.23194209f, 0.06203401f, -0.37090245f, 
    0.02593452f, -0.08161231f, -0.00341276f, -0.36410654f, 0.16932668f, -0.24244489f, 0.02285209f, 0.34962264f, 
    0.24796383f, 0.27505216f, 0.24446833f, -0.13273671f, -0.52818620f, -0.39271501f, -0.59110665f, 0.05154637f, 
    0.17182571f, -0.28832912f, -0.21183400f, -0.06257882f, 0.09290531f, 0.09890641f, -0.42859134f, -0.04790243f, 
    0.14602815f, -0.03829402f, -0.49158782f, -0.01836330f, -0.10259302f, -0.07685688f, -0.01321138f, -0.03665469f, 
    0.03610663f, -0.15763585f, -0.38936755f, -0.21469592f, 0.06458345f, 0.16989827f, 0.03349365f, 0.27925038f, 
    -0.13572732f, -0.02986859f, 0.04632067f, -0.08172928f, -0.07299960f, 0.01832842f, -0.09806263f, 0.31052586f, 
    0.11570094f, 0.25434908f, 0.05742615f, -0.35306081f, -0.61985141f, 0.03595128f, 0.07286702f, 0.25735161f, 
    0.07531464f, -0.19414996f, 0.11527535f, -0.01732787f, -0.22005671f, 0.04202622f, 0.09330890f, -0.07051363f, 
    0.07853290f, -0.06290243f, 0.07951581f, 0.02365232f, 0.03669372f, -0.06327795f, -0.13138992f, 0.15033977f, 
    -0.11361385f, 0.19698480f, 0.04356634f, -0.15031332f, 0.06822911f, -0.01424417f, -0.02995108f, -0.63213426f, 
    0.20494892f, 0.12572481f, 0.00619202f, -0.06298412f, -0.13943759f, -0.20201425f, 0.09239420f, 0.02776800f, 
    -0.02990958f, 0.07710190f, 0.10262236f, -0.03565900f, 0.16088015f, -0.22487815f, -0.00666688f, 0.03388558f, 
    -0.02917325f, -0.13512889f, -0.17751452f, 0.02021612f, 0.18044285f, -0.24823494f, -0.08977506f, -0.14766660f, 
    0.03877214f, -0.39924958f, 0.07829019f, -0.03652800f, 0.09683342f, 0.04731038f, -0.13705328f, -0.40223187f, 
    0.15202092f, -0.08050074f, -0.22589189f, -0.12315407f, 0.23386842f, -0.04890268f, -0.08697636f, -0.07094412f, 
    -0.01075699f, 0.14617564f, 0.09421069f, 0.12595157f, 0.22393301f, -0.10834008f, 0.02270154f, -0.59946847f, 
    -0.08284388f, -0.03002932f, 0.11170278f, 0.14527524f, -0.19695088f, -0.20380463f, 0.08172362f, -0.11175657f, 
    0.07738539f, 0.03221752f, 0.01826333f, -0.23515910f, 0.11909737f, 0.23454258f, 0.20300828f, -0.08991063f, 
    0.18452895f, 0.00816582f, 0.27012053f, 0.03901782f, -0.28706428f, 0.08444522f, 0.22661301f, -0.09262083f, 
    0.18019295f, 0.14853393f, 0.03257768f, -0.04336799f, 0.25999114f, 0.02228957f, 0.01922521f, 0.03069550f, 
    0.15142174f, -0.14578144f, 0.15685785f, 0.20012455f, -0.17162859f, -0.18943581f, -0.13039319f, -0.16970658f, 
    0.20881577f, -0.15163167f, 0.14169741f, -0.06387027f, 0.30564165f, -0.02647293f, 0.04769704f, -0.11408007f, 
    -0.17412274f, -0.51204777f, 0.10350324f, 0.22910766f, -0.11552292f, 0.22495468f, 0.26887172f, -0.03767224f, 
    0.14473709f, -0.06739007f, -0.32080469f, -0.01049131f, 0.07091147f, -0.26324165f, -0.07686608f, -0.13055570f, 
    -0.15324667f, -0.12488916f, -0.05320545f, -0.07522849f, -0.01854691f, -0.26623353f, -0.22599660f, -0.05104792f, 
    0.18158466f, -0.26677477f, 0.06963143f, 0.00833518f, -0.01290316f, -0.03705990f, 0.11610539f, 0.04151328f, 
    -0.18553975f, -0.04602700f, -0.51017493f, -0.03209705f, -0.22726886f, -0.03995433f, -0.17386009f, -0.05562145f, 
    0.13608272f, -0.22039147f, -0.07566957f, 0.20739734f, -0.21121994f, -0.12399426f, -0.03653374f, -0.26387236f, 
    0.18053624f, 0.29546434f, 0.17876573f, -0.25686395f, -0.04196607f, 0.05697080f, -0.07665800f, -0.33247873f, 
    -0.57346302f, -0.13275903f, -0.60808438f, 0.07187506f, -0.64689267f, 0.05057175f, -0.05762806f, -0.42861697f, 
    -0.14562003f, -0.26732007f, 0.08588721f, 0.12752959f, -0.03047509f, 0.16766144f, -0.37651029f, -0.12791172f, 
    -0.44801465f, 0.09977239f, 0.23900563f, -0.39826798f, 0.00373940f, -0.44362417f, 0.05556903f, -0.00172775f, 
    -0.08662100f, -0.03371432f, -0.00987258f, -0.30278078f, 0.17229766f, -0.20433179f, 0.06510165f, -0.25794870f, 
    0.17544471f, 0.09832996f, -0.66638047f, -0.13379739f, -0.24012211f, -0.62229973f, -0.48137128f, -0.06940428f, 
    0.30667153f, -0.26551986f, -0.10275164f, -0.02363707f, 0.24858341f, 0.27619800f, -0.60020089f, 0.02187376f, 
    -0.10603717f, -0.29483175f, 0.11128876f, -0.25046349f, 0.44902569f, 0.13538291f, 0.09302128f, -0.31289849f, 
    -0.03332949f, 0.04752136f, -0.09494860f, -0.21191129f, -0.55394381f, 0.08770259f, -0.03300596f, 0.40303493f, 
    -0.03732903f, 0.18943641f, -0.18959631f, -0.11129963f, 0.19762285f, -0.06467733f, 0.23396018f, 0.01333458f, 
    0.14418125f, 0.37330672f, -0.07395564f, -0.03985576f, -0.01883079f, -0.23563381f, -0.16597897f, 0.21139903f, 
    -0.00414382f, -0.38343850f, 0.36992216f, -0.50198370f, 0.24931578f, -0.17890644f, -0.09909565f, 0.05085285f, 
    0.22883654f, 0.02681850f, -0.15875131f, 0.14819527f, -0.12829144f, -0.05849668f, -0.43735093f, -0.11659089f, 
    0.00544553f, -0.04848288f, -0.43001693f, -0.22488427f, -0.13009405f, -0.25098914f, 0.00730979f, -0.07435948f, 
    0.18207525f, 0.07078408f, 0.26124650f, -0.06867006f, 0.10839022f, -0.19295560f, 0.12715340f, 0.02625833f, 
    -0.27914476f, -0.02906110f, -0.32051429f, -0.18227279f, -0.25414157f, 0.18378626f, -0.07292761f, -0.39271557f, 
    -0.06872986f, -0.31229028f, 0.07734238f, 0.00851320f, -0.64967591f, 0.07860508f, -0.03303746f, 0.19108471f, 
    -0.49479496f, 0.30520836f, 0.17863792f, 0.10076784f, 0.13607058f, -0.10598730f, -0.09513295f, 0.35340595f, 
    -0.07233026f, -0.06839171f, 0.14605917f, 0.07301442f, -0.27116466f, 0.03908573f, -0.21224593f, -0.03926356f, 
    -0.17514406f, -0.15579765f, -0.05306767f, -0.25591099f, -0.01676709f, -0.05410387f, -0.00251457f, 0.00966509f, 
    0.02429639f, 0.05951237f, -0.06861844f, -0.47747022f, -0.01975734f, -0.37531814f, -0.31154013f, 0.01435678f, 
    -0.32822981f, 0.17867126f, 0.00212799f, 0.25164855f, -0.46825302f, -0.20979485f, 0.22455569f, -0.31443360f, 
    -0.19849859f, 0.30631930f, -0.42657295f, 0.00200048f, -0.17761847f, -0.12155512f, -0.45718613f, 0.06670485f, 
    -0.09706362f, -0.37628329f, -0.04358669f, 0.24088053f, 0.15272328f, -0.08288514f, -0.09318293f, -0.06106908f, 
    -0.28797761f, -0.14167190f, 0.00161571f, -0.29219994f, 0.15986060f, -0.16922185f, 0.00239899f, -0.24502958f, 
    0.32785973f, -0.16956319f, -0.16256543f, -0.00717201f, -0.27476132f, -0.11044806f, -0.37102756f, -0.29186633f, 
    -0.00197577f, -0.40781644f, 0.05297999f, -0.40142310f, 0.11414589f, -0.01196946f, -0.04886338f, 0.10120338f, 
    0.06131737f, 0.21561749f, -0.23553498f, 0.19922452f, 0.18017085f, -0.54829401f, 0.06672552f, 0.20217478f, 
    -0.17123419f, -0.31873673f, 0.00297184f, -0.15676537f, -0.09410524f, -0.20291096f, -0.15222566f, 0.15135700f, 
    0.23158671f, -0.31413928f, 0.08228271f, 0.21695942f, 0.06880840f, -0.06584124f, 0.02168472f, -0.28194058f, 
    0.00416840f, -0.48615998f, 0.41614920f, 0.06037162f, -0.01928028f, 0.29356956f, 0.13777032f, 0.12239505f, 
    -0.05407880f, 0.24177864f, -0.40055537f, 0.16533004f, -0.16666035f, -0.07664742f, 0.00079518f, 0.18516234f, 
    0.26174015f, -0.28487790f, -0.06839571f, 0.01328456f, 0.05691700f, -0.13442264f, 0.19906898f, -0.50656331f, 
    -0.09892771f, 0.15642411f, 0.18736723f, 0.07009672f, -0.33667386f, 0.00350751f, -0.09402256f, -0.14875619f, 
    -0.29948196f, -0.15715250f, -0.18051958f, 0.15115166f, -0.24070111f, -0.20559527f, -0.42509553f, -0.39178181f, 
    0.31697103f, 0.03890080f, 0.15036584f, 0.21419862f, -0.25780740f, 0.19434148f, 0.10582557f, -0.09706380f, 
    0.06395493f, 0.26266095f, 0.10538222f, -0.04392434f, 0.24404308f, -0.21488643f, -0.00489901f, -0.74698776f, 
    -0.47580382f, -0.13930354f, 0.04831804f, -0.11715554f, -0.22636764f, -0.48028666f, 0.08952874f, -0.43258730f, 
    -0.06046163f, 0.09246370f, -0.19262108f, -0.07705966f, -0.17730397f, -0.19194423f, -0.21125484f, 0.31450769f, 
    0.23139468f, -0.38774234f, -0.58006865f, 0.03695388f, -0.47895780f, -0.12803543f, -0.13278706f, -0.09089945f, 
    0.09424093f, 0.31348753f, -0.30853230f, 0.30206871f, 0.10753682f, 0.15165362f, -0.20990446f, 0.00720316f, 
    -0.14053234f, -0.13986270f, -0.03168684f, -0.04049635f, 0.06711849f, -0.11906673f, -0.35132921f, -0.00650636f, 
    -0.45154142f, -0.17628558f, 0.07373994f, -0.00694260f, 0.16199501f, 0.09664050f, -0.05777034f, 0.00163471f, 
    -0.24696364f, 0.19579950f, -0.07124356f, -0.33141878f, -0.43673050f, 0.16339491f, 0.08771791f, 0.01420667f, 
    -0.68013531f, 0.00289657f, -0.05262327f, -0.42906338f, -0.28713396f, -0.18155894f, 0.30746776f, -0.02488340f, 
    -0.20831567f, 0.13613582f, -0.19658725f, 0.20205458f, 0.18063505f, 0.07273662f, 0.13893127f, -0.38014108f, 
    -0.17110476f, 0.15256183f, -0.06101112f, 0.05605207f, -0.12686279f, 0.04384719f, -0.34305558f, 0.18525597f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.13523477f, 0.03832547f, 0.14290506f, -0.06569252f, -0.10513349f, -0.13348709f, 0.04415871f, -0.09894338f, 
    0.19610995f, 0.09821004f, -0.09630153f, -0.02628674f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
