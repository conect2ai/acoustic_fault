#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.22590157f, 0.51163369f, 0.01616940f, 0.97758418f, 0.28592467f, 0.43764561f, 0.66162926f, 0.14913438f, 
    -0.07655734f, 0.59288019f, -0.47624707f, -0.09835415f, -0.04316514f, -0.43341023f, -0.04520528f, -0.22362667f, 
    0.06730822f, 0.08918235f, 0.02045449f, -0.06852944f, 0.06275713f, 0.27667817f, -0.07562694f, -0.04513725f, 
    0.11307459f, -0.68771166f, -0.73915422f, -0.38253120f, -0.45389658f, 0.30272093f, -0.06790061f, 0.25091693f, 
    -0.36857957f, -0.01037893f, -0.04574931f, 0.10635260f, 0.45073882f, 0.08082111f, 0.17935434f, 0.53711921f, 
    0.14428940f, -0.45291325f, -0.21270935f, -0.55622357f, -0.06550257f, 0.02358068f, 0.20284027f, 0.12697050f, 
    0.53599322f, -0.21153188f, 0.79431921f, -0.02326778f, 0.03215368f, -0.45585400f, 0.05830821f, 0.16380779f, 
    -0.27561560f, -0.63439798f, -0.11227670f, 0.30707672f, -0.31869897f, 0.37707347f, 0.33544344f, -0.01883778f, 
    -0.03352625f, -0.31191629f, -0.03592546f, 0.09430416f, 0.33578515f, -0.15086064f, -0.15121397f, 0.34412029f, 
    -0.19386901f, -0.37241277f, 0.46388400f, 0.66904461f, 0.94314367f, 0.63036799f, -0.07501256f, -0.16097550f, 
    -0.69607306f, -0.17753468f, 0.02613964f, -0.30953944f, 0.06780263f, 0.05509219f, -0.00577616f, -0.21875086f, 
    0.02750197f, 0.43203652f, 0.00580686f, -0.28238675f, 0.05545906f, -0.00847247f, -0.07160547f, 0.17520960f, 
    0.31252518f, -0.19200017f, 0.13763665f, 0.29611409f, 1.03948557f, 0.69242686f, 0.16125594f, 0.10769977f, 
    -0.43064353f, 0.14109823f, -0.20128097f, -0.26710656f, 0.41029036f, -0.11531805f, 0.44755864f, 0.15318242f, 
    0.04173629f, 0.14705478f, 0.12156320f, 0.07023462f, 0.00515763f, 0.18888910f, -0.02097913f, 0.37251845f, 
    -0.20554200f, 0.11870562f, 0.21381396f, 0.14312142f, 0.08578622f, -0.37621248f, 0.24668045f, -0.70706666f, 
    -0.07035509f, 0.41351026f, 0.66441238f, -0.28833815f, 0.24147102f, -0.12050246f, 0.55722886f, -0.15861927f, 
    -0.38564596f, -0.71467906f, -0.15322314f, 0.01774773f, -0.11313899f, -0.16867931f, -0.07563503f, -0.00544610f, 
    0.04381380f, 0.01521285f, 0.02073385f, -0.04458550f, -0.20411308f, -0.24370433f, -0.51434231f, 0.28204408f, 
    -0.26803833f, -0.61069369f, 0.26794228f, 0.43916363f, 0.63628489f, 0.37102574f, 0.61009258f, 0.34757927f, 
    0.50092494f, -0.32853338f, -0.28426540f, -0.07989366f, 0.22044408f, 0.26806858f, 0.03426383f, -0.21536589f, 
    0.29885554f, -0.26585475f, -0.21945196f, 0.32820272f, 0.32157919f, 0.30464166f, 0.24436724f, -0.44449231f, 
    -0.79348052f, -0.69950449f, -0.42137036f, -0.05418474f, 0.03077746f, -0.48570168f, 0.07992987f, 0.39818886f, 
    0.34317771f, -0.13582405f, -0.13870940f, -0.02806892f, -0.03992571f, -0.15376945f, 0.07542286f, 0.29633656f, 
    0.06239228f, 0.02714252f, 0.17707214f, -0.09558043f, -0.05155427f, 0.02777417f, 0.37257466f, 0.25420061f, 
    -0.28475985f, 0.16921663f, 0.47199684f, 0.25213292f, -0.54907954f, -0.68080068f, -0.10059866f, -0.64335269f, 
    -0.58318412f, -0.29397148f, -0.22598223f, -0.11405887f, 0.14700763f, 0.12168080f, -0.27859536f, -0.26957843f, 
    -0.46126816f, -0.43310732f, -0.13938144f, 0.07110281f, -0.14996238f, 0.17799239f, 0.10813265f, -0.16643779f, 
    0.44920018f, 0.98570895f, 0.37644792f, 0.14468765f, 0.64184499f, 0.85335916f, -0.41320249f, 0.53627515f, 
    0.20736213f, -0.23433489f, -0.00561834f, 0.05648513f, -0.08803534f, -0.08082699f, 0.00388738f, 0.04073717f, 
    -0.08996403f, 0.19988768f, 0.34397817f, 0.18041745f, 0.24476001f, 0.04269168f, 0.04823888f, 0.18166851f, 
    0.38546300f, 0.03573202f, 0.34555236f, -0.74243796f, -0.62639356f, -0.25826782f, -0.15737045f, -0.49038914f, 
    0.11403327f, 0.28666374f, -0.32369381f, -0.13643262f, -0.06390096f, -0.07934901f, 0.56933260f, -0.25088280f, 
    0.48622471f, -0.27293563f, -0.19207263f, 0.13426289f, -0.06816871f, -0.00659051f, 0.28326783f, 0.14259574f, 
    -0.10719420f, 0.00447600f, -0.25133124f, 0.49539471f, 0.66593397f, 0.58093637f, -0.13191222f, 0.04148975f, 
    -0.29318148f, 0.38369024f, -0.13630091f, 0.29463151f, -0.20092823f, -0.42654747f, 0.28542906f, -0.14337082f, 
    0.24244928f, -0.38349891f, -0.20481499f, 0.18233688f, 0.48037127f, 0.25551143f, -0.24408825f, 0.16387227f, 
    -0.15966402f, -0.25715083f, 0.28287929f, -0.21447574f, -0.56410062f, -1.10709739f, -0.61493987f, -0.46053916f, 
    -0.17791137f, -0.40216500f, 0.85254270f, 0.48259336f, -0.38710308f, 0.11761223f, -0.16439378f, -0.14206453f, 
    -0.10769561f, 0.06118107f, 0.04033986f, -0.12325232f, -0.15206060f, -0.19141246f, -0.22126371f, -0.08587198f, 
    0.08404301f, 0.15900688f, -0.04934097f, 0.01552792f, 0.11743832f, 0.95165026f, -0.72005892f, 0.64089775f, 
    -0.62262571f, -0.43622929f, 0.36884120f, 0.16744933f, 0.40661815f, -0.20739792f, 0.05409003f, -0.21987022f, 
    0.39086092f, -0.04823072f, 0.04176019f, -0.02854054f, -0.04827205f, -0.21694787f, -0.60660082f, -0.39203477f, 
    -0.33151561f, 0.16983876f, 0.12960562f, 0.22012447f, 0.22527175f, 0.24042305f, -0.19867678f, 0.17652343f, 
    0.79589808f, 0.64481145f, 0.29682979f, 0.07384501f, 0.47569653f, 0.15682414f, 0.10504226f, 0.24458887f, 
    -0.41873020f, 0.06472933f, 0.47331029f, 0.28608996f, -0.22281161f, 0.15074076f, -0.04581530f, -0.28762028f, 
    0.21629702f, 0.00071816f, 0.05010686f, -0.24238291f, -0.20589857f, 0.50450683f, -0.34756720f, 0.50313073f, 
    0.30111542f, -0.77700168f, 0.07384096f, -0.49735329f, 0.16209121f, 0.14651603f, 0.09959484f, 0.55126405f, 
    0.48162934f, -0.14072187f, 0.11750660f, -0.30015144f, -0.39986816f, 0.27425721f, 0.04340910f, -0.35068598f, 
    0.01999256f, 0.43460941f, -0.16534357f, -0.58637923f, 0.05224765f, -0.24153364f, 0.18512122f, -0.42679584f, 
    0.79893869f, -0.28659320f, 0.38837302f, 0.79053271f, 0.25249827f, -0.08892617f, -0.82402062f, -0.04876621f, 
    -0.38870713f, 0.01020363f, -0.08417560f, 0.12714498f, -0.48158267f, -0.52576476f, 0.03724726f, -0.51898730f, 
    -0.04695270f, -0.30052671f, -0.15263496f, -0.20225893f, 0.10418009f, -0.08176164f, 0.18797457f, -0.05621089f, 
    0.02798327f, -0.10880926f, 0.14675896f, -1.19401157f, 0.41577175f, -0.20418172f, -0.33331823f, 0.45922777f, 
    -0.69469094f, 0.50009626f, -0.34958833f, 0.41989717f, 0.00012341f, -0.40577057f, 0.15068670f, 0.47612774f, 
    0.37098539f, 0.19384499f, 0.20769185f, -0.19828571f, 0.30426058f, -0.12970890f, -0.04387482f, 0.01179126f, 
    0.13658033f, -0.02324583f, 1.12230945f, 0.43730691f, 0.11809187f, 0.92996782f, 0.01551034f, 0.53164375f, 
    0.14366755f, -0.65679568f, 0.33611521f, -0.07998790f, -0.02203817f, 0.08752412f, -0.18095039f, 0.12051384f, 
    -0.22637320f, 0.30633792f, -0.15096225f, 0.09440239f, -0.06650784f, 0.08775396f, -0.25027382f, 0.14007264f, 
    -0.21921335f, -0.14456403f, 0.36783189f, 0.48984867f, 0.51439720f, 0.62263215f, 0.52559805f, 0.20697993f, 
    -0.35588938f, 0.04311736f, -0.43832433f, -0.35357222f, 0.04282641f, -0.26319203f, -0.20054354f, 0.01475655f, 
    -0.04801076f, -0.07596239f, -0.27964443f, 0.11839806f, 0.19643562f, -0.26843923f, 0.09569880f, 0.37471488f, 
    0.37359965f, 0.27835166f, 0.36537394f, 0.37340561f, -0.02053931f, 0.76486081f, 0.69330299f, 0.83754867f, 
    0.06417903f, -0.17018983f, -0.15640582f, 0.10440574f, -0.19897975f, 0.38609290f, 0.37095141f, 0.17706449f, 
    -0.03352976f, 0.10122965f, -0.21536952f, -0.00928998f, 0.23200387f, 0.48956740f, -0.21773513f, 0.07126720f, 
    0.16690524f, 0.18477239f, -0.12899569f, -0.35041249f, -0.35738739f, -0.92355841f, 0.15146944f, -0.25900161f, 
    -0.05329486f, 0.70675480f, -0.43000993f, 0.74915868f, 0.41116223f, -0.48180431f, -0.15035766f, 0.07172190f, 
    -0.36494592f, -0.00869250f, -0.46067712f, 0.10147414f, -0.05502551f, -0.13755734f, -0.29533690f, -0.06617181f, 
    -0.21211784f, 0.15357862f, 0.01391379f, 0.10106343f, -0.05195449f, -0.29019547f, 0.45100263f, 0.46072525f, 
    0.60420984f, 0.43218529f, -0.82217902f, -0.09227405f, 0.71655691f, -0.40700027f, -0.25328287f, 0.15225153f, 
    0.40775257f, 0.17536406f, -0.35054460f, 0.04063685f, 0.26108029f, -0.04708043f, -0.45136285f, -0.00373911f, 
    0.17760861f, -0.16754529f, -0.17586102f, -0.19537631f, 0.27212894f, -0.13947481f, -0.11909761f, 0.72455424f, 
    0.87676001f, -0.27624485f, -0.82724899f, -0.83718705f, 0.47960845f, -0.52222139f, -0.45331371f, -0.38681737f, 
    -0.06800006f, 0.48573518f, 0.00928864f, -0.05847999f, -0.09382411f, -0.37770596f, 0.06943344f, -0.25332519f, 
    0.09372913f, -0.04359303f, -0.16379163f, 0.07529040f, 0.12505241f, 0.10416915f, 0.10635619f, 0.16291344f, 
    -0.87533379f, 0.70262676f, -0.18492059f, 0.07792275f, -0.81299335f, 0.91606492f, -0.17693368f, -0.27718645f, 
    0.46433696f, 0.51929629f, 0.08039501f, -0.37437025f, -0.16045660f, 0.06280936f, -0.26254067f, 0.02424275f, 
    0.00859653f, 0.06136263f, -0.20795043f, -0.06433605f, 0.31140560f, 0.24062821f, 0.24395557f, 0.12050153f, 
    0.29733944f, -0.31233948f, -0.09666281f, 0.79643887f, 0.37206817f, 0.43034187f, -1.11434460f, 0.32596186f, 
    -0.42965123f, -0.67120850f, 0.02803655f, 0.43022892f, 0.27342939f, 0.09246172f, 0.11777233f, 0.07019663f, 
    0.07468300f, 0.11455005f, 0.32627314f, 0.04200537f, 0.26906565f, -0.21934766f, -0.18099798f, -0.13701151f, 
    -0.00929964f, 0.20882393f, -1.06201196f, -0.26107758f, 0.30601704f, 0.82144696f, -0.07661959f, 0.55001903f, 
    0.59016144f, 0.23408933f, 0.08889559f, -0.48169363f, -0.17637955f, 0.24674737f, 0.30413911f, 0.34626526f, 
    0.60877836f, -0.19174540f, -0.14033066f, 0.11238975f, -0.04735797f, 0.17501181f, -0.08581204f, 0.07353056f, 
    -0.23576145f, 0.21430007f, -0.22096483f, -0.13041298f, -0.13594724f, 0.30306321f, 0.82433808f, 0.66153812f, 
    0.60356450f, 0.80979437f, 0.56091827f, 0.42571425f, 0.43010506f, 0.03023966f, 0.18804872f, 0.00407862f, 
    0.23445942f, 0.05653724f, -0.22490077f, -0.05302202f, 0.10579469f, -0.00505347f, -0.18149132f, 0.09654559f, 
    -0.06507480f, 0.02731381f, -0.02159823f, -0.21728265f, -0.19179155f, -0.82288325f, -0.20684665f, 0.24523693f, 
    -0.18756896f, -0.01929066f, -0.78190356f, -0.93469167f, 0.00425872f, -0.09301057f, 0.24113999f, 0.51408678f, 
    0.35133582f, 0.19335678f, 0.00814012f, -0.06464262f, -0.26241499f, 0.46196955f, 0.13406123f, -0.18346831f, 
    -0.11180937f, 0.23710172f, -0.41602412f, -0.08027267f, 0.07610555f, 0.28791711f, 0.52329767f, 0.78767067f, 
    0.42362586f, 0.53491759f, 0.00691113f, -0.53794020f, -0.06779555f, -0.31035954f, 0.18134028f, 0.47143498f, 
    -0.05383373f, -0.01993923f, 0.19992347f, 0.15037043f, 0.23875475f, 0.43574578f, 0.21490520f, -0.25693840f, 
    0.49636886f, 0.33313975f, 0.01489876f, -0.19411287f, 0.04944913f, 0.39335504f, 0.65205222f, -0.83587795f, 
    0.03477821f, -0.18419187f, 0.50431955f, 0.81657475f, 0.08529132f, 0.64442366f, 0.27965304f, -0.02227229f, 
    -0.31567964f, 0.17897172f, -0.45401549f, 0.32995826f, 0.24890430f, 0.14588952f, 0.14203000f, 0.08489150f, 
    0.23310119f, 0.27247030f, 0.11484840f, -0.15179695f, -0.12205565f, -0.07901747f, -0.27260959f, -0.21033359f, 
    -0.86830539f, -0.61724776f, -0.00318761f, -0.01843689f, -0.01796851f, 0.20999148f, 0.38625604f, -0.65632445f, 
    0.41810393f, 0.00204960f, -0.04025168f, 0.03576467f, -0.31579775f, -0.11903179f, -0.24170090f, 0.05117923f, 
    0.41943720f, -0.17289741f, -0.52734083f, 0.06921633f, -0.50808054f, 0.29181451f, 0.07830378f, 0.33230957f, 
    0.03394928f, 0.59366268f, -1.03616798f, 0.33357552f, 0.96257943f, 0.26738000f, -0.07322630f, 0.57708353f, 
    0.11854958f, 0.08136939f, -0.42155808f, -0.33398634f, 0.11986675f, -0.32324505f, 0.21893458f, 0.12574449f, 
    -0.02120885f, -0.12326262f, -0.08822884f, 0.10830151f, 0.19096297f, 0.10620931f, -0.09836251f, 0.06998499f, 
    -0.17197569f, 0.72870672f, 0.77389878f, -0.01268485f, 0.67260092f, 0.64289445f, 0.66475290f, 0.13071628f, 
    -0.10604151f, -0.52200508f, -0.39384031f, -0.09355082f, 0.04922371f, -0.34172264f, 0.42912206f, -0.27824163f, 
    -0.08925761f, -0.11818607f, 0.14053832f, -0.06760339f, 0.12397252f, -0.03109021f, -0.00579405f, -0.03093932f, 
    -0.23588376f, -0.20571183f, 0.79597783f, -0.52347153f, -0.43186566f, -1.03971446f, 0.18542622f, 0.31397310f, 
    0.30927619f, -0.25446221f, 0.18016671f, 0.51923084f, -0.26643020f, 0.39055142f, -0.13372472f, -0.02845154f, 
    -0.08602269f, -0.19269609f, 0.42381799f, 0.28357682f, -0.12330173f, 0.03415426f, 0.09382765f, 0.14610216f, 
    0.05978487f, -0.06374626f, 0.05068230f, 0.48188052f, -0.74548805f, 0.76631290f, 0.42946613f, 0.67462564f, 
    -0.95897096f, 0.48820493f, -0.03646601f, -0.51966512f, 0.53041226f, 0.19932653f, 0.55434132f, -0.32178536f, 
    0.07878710f, -0.06285756f, -0.18482521f, -0.02227925f, -0.28238139f, 0.07011425f, -0.17523272f, -0.04084917f, 
    0.06158121f, -0.02730239f, 0.14091344f, -0.18619706f, 0.09576846f, -0.55948657f, -0.12811586f, 0.42829412f, 
    0.86194432f, 0.63269711f, -0.34648132f, 0.03975771f, -0.19340521f, -0.05837584f, 0.13947120f, -0.04474730f, 
    -0.03824550f, 0.09434242f, -0.22214009f, -0.03777113f, -0.00667761f, 0.37469193f, 0.25327745f, 0.50123662f, 
    0.20436069f, -0.04887833f, -0.23265707f, -0.19695491f, -0.11847708f, -0.44391707f, -0.75214618f, -0.26889223f, 
    0.22663839f, -0.39280218f, 0.03789578f, 0.50631183f, 0.26728028f, 0.05244476f, 0.58742720f, 0.16167520f, 
    -0.44295052f, -0.36596978f, 0.15110725f, -0.36750922f, -0.28445265f, -0.13146164f, 0.00348040f, -0.07496973f, 
    -0.19972701f, -0.06379361f, 0.29298323f, -0.31956038f, -0.03619541f, -0.22689927f, 0.68382579f, -0.70816553f, 
    -0.85381907f, 0.67857039f, 0.46695548f, -0.69811803f, 0.20663534f, 0.11107066f, 0.29693615f, 0.26115829f, 
    0.04637072f, 0.19590107f, 0.18407509f, -0.10405764f, -0.04998893f, -0.24934249f, -0.15740544f, -0.17764601f, 
    0.06090629f, -0.01694869f, -0.09580525f, 0.13084997f, -0.00846556f, 0.02997929f, -0.20691676f, 0.44290596f, 
    0.66329896f, 0.05240104f, 0.09446836f, -0.37973654f, 0.36085579f, 0.45090887f, 0.27246010f, 0.46738350f, 
    0.26178277f, 0.00306593f, -0.43669400f, -0.13616474f, -0.34332225f, 0.01875130f, -0.42451888f, -0.41874430f, 
    -0.19854560f, 0.13814314f, -0.06294272f, -0.26598695f, 0.13235694f, -0.06624644f, -0.09858028f, -0.06221855f, 
    0.24864624f, 0.34072864f, 0.41765532f, 0.01663939f, 0.87476707f, 0.48825550f, 0.31875947f, -0.52781248f, 
    0.09169944f, 0.01091197f, -0.29677635f, 0.39781910f, 0.16795948f, 0.39008215f, 0.02729956f, -0.24264902f, 
    -0.02352174f, -0.28328213f, 0.36573899f, -0.15307967f, 0.01896857f, -0.33179298f, -0.10965946f, -0.42509946f, 
    0.10209496f, -0.66875362f, 0.09927419f, -0.36307803f, -0.64980745f, -0.46796322f, 0.19438119f, 0.79154640f, 
    -0.13464037f, 0.01012200f, 0.69136345f, 0.01760364f, -0.20348012f, -0.15204248f, -0.15134455f, 0.02657919f, 
    0.23340653f, 0.28666148f, 0.04076552f, 0.31569234f, 0.07217086f, -0.01358723f, -0.17315350f, -0.10979417f, 
    -0.46767816f, 0.12380017f, 0.19272919f, -1.39286661f, 0.48415217f, 0.64406413f, 0.29154134f, 0.39543462f, 
    0.57006991f, 0.60340905f, -0.11979767f, -0.34142745f, 0.23547564f, 0.10623465f, 0.19461279f, 0.14906994f, 
    -0.02873157f, -0.45199460f, -0.11258237f, -0.24077284f, 0.04204160f, 0.05922959f, -0.28477940f, 0.33463565f, 
    0.07275321f, -0.05603221f, 0.35876217f, 0.11240637f, -0.02311357f, 0.07297464f, -0.42290673f, 0.59074199f, 
    0.34855729f, -0.88411838f, -0.62590092f, -0.71995658f, -0.16569406f, -0.16505934f, 0.27235708f, 0.28452006f, 
    -0.07638078f, 0.21810126f, 0.18448186f, 0.35151342f, -0.25260481f, 0.05061449f, 0.09830630f, 0.18587688f, 
    0.13955675f, 0.39322001f, 0.25924551f, -0.31512392f, 0.52564824f, -0.05805599f, -0.69685620f, -0.81387019f, 
    -0.38907841f, 0.53656316f, 0.65943968f, 0.36571580f, 0.40409118f, -0.09653351f, -0.17128542f, -0.16775770f, 
    -0.20322053f, 0.01978424f, 0.09710000f, 0.04964811f, -0.18301339f, -0.03321310f, 0.14575057f, 0.04326595f, 
    -0.06933857f, -0.03007421f, -0.01009382f, -0.16878141f, -0.08614623f, -0.86403841f, -0.16238318f, -0.52214944f, 
    -0.27162921f, -0.35624638f, 0.82890779f, 0.67441994f, -0.20237099f, 0.46772757f, 0.06254397f, 0.22811112f, 
    -0.32521597f, 0.37393686f, -0.13468978f, -0.00294486f, 0.01190641f, 0.06345184f, 0.08925121f, 0.24423037f, 
    0.04878933f, -0.03877030f, -0.49096376f, -0.34491551f, -0.27719191f, -0.05003194f, 0.91175687f, 0.66341978f, 
    0.17162338f, 0.31901008f, 0.16456597f, -0.03062068f, -0.15605009f, 0.20671333f, 0.61297482f, 0.42650864f, 
    -0.66721523f, 0.19200015f, 0.29373157f, -0.48570231f, -0.34206638f, -0.07888509f, -0.20778783f, -0.20220982f, 
    -0.12972066f, 0.05348658f, -0.00686246f, -0.17129083f, 0.39022633f, -0.05038387f, -0.07005186f, 0.65338606f, 
    0.61454064f, -0.52475536f, -0.53408337f, 0.19496673f, 0.33460826f, -0.39399630f, 0.07925046f, -0.80451030f, 
    -0.20542942f, 0.16769569f, 0.01631974f, 0.40354168f, 0.11700452f, 0.04630863f, 0.40818584f, -0.11827238f, 
    -0.17435136f, 0.15312268f, -0.10871443f, 0.27458152f, -0.25139111f, 0.33835521f, -0.23665944f, 0.11181921f, 
    0.00965330f, -0.03476720f, 0.44088677f, -0.05049251f, -0.83249193f, -0.00442589f, 0.17580840f, -0.06588159f, 
    -0.56884986f, -0.89338171f, -0.27383402f, 0.02735244f, -0.58133918f, -0.21859002f, -0.26683584f, 0.13385350f, 
    -0.17770512f, 0.17931256f, -0.08656503f, -0.04388872f, -0.33099666f, 0.14219801f, 0.23981488f, 0.33529040f, 
    -0.25414395f, -0.46748012f, -0.76996702f, -0.28636450f, -0.26561230f, -0.20446891f, 0.45432645f, 0.34414017f, 
    0.38935512f, 0.17805606f, -0.01272485f, -0.12253662f, -0.30780318f, -0.28657147f, -0.20611347f, 0.27822989f, 
    0.07841918f, 0.36305186f, -0.30270219f, -0.05427156f, 0.13890690f, -0.31779289f, -0.00131692f, 0.34392798f, 
    -0.17013600f, -0.22480205f, 0.71516329f, -0.10459469f, -0.02213285f, 0.12800732f, 0.06877671f, -0.22378893f, 
    -0.23130082f, 0.17759494f, 0.29371643f, 0.44136947f, -0.17185423f, -0.40804654f, 0.01912636f, 0.19879687f, 
    -0.45324367f, 0.05216892f, 0.21877883f, 0.47550416f, -0.05401888f, -0.06126948f, -0.07799885f, -0.24367504f, 
    0.31358251f, 0.26587322f, 0.43240213f, -0.13117811f, 0.01087064f, -0.55682731f, -0.16678986f, 0.69167960f, 
    -0.43429771f, 0.44398317f, 0.29199237f, 0.27039018f, 0.31848279f, -0.19223379f, -0.11605546f, -0.27243370f, 
    -0.38255954f, -0.25741494f, 0.38742241f, -0.16731423f, -0.10766449f, 0.24744518f, -0.01849732f, 0.24806124f, 
    0.12129409f, -0.08085158f, 0.09287231f, -0.27254298f, -0.28460371f, -1.18500793f, -0.56461328f, 0.18353935f, 
    -0.18013746f, 0.12262294f, -0.00465401f, -0.09829310f, 0.45160425f, -0.07780384f, 0.22425258f, 0.29380906f, 
    -0.23520949f, 0.59261316f, -0.07040516f, -0.17074668f, 0.18595077f, 0.40044063f, 0.01813133f, 0.10215122f, 
    0.21735771f, 0.09895253f, -0.11163618f, 0.05072000f, 0.07860770f, -0.72160083f, -0.15133440f, 0.58520865f, 
    -0.00756840f, 0.43399414f, 0.55488449f, 0.19708066f, 0.19659242f, 0.07054264f, 0.23987643f, 0.30170056f, 
    -0.27209672f, 0.47606739f, -0.31455192f, -0.12448970f, 0.06626353f, -0.51867193f, -0.18259273f, -0.44129330f, 
    -0.03752037f, -0.21683443f, 0.09277576f, 0.15963908f, -0.10984360f, -0.11699658f, 0.70698690f, 0.30342054f, 
    0.47301179f, -0.39876497f, 0.56437516f, -0.29546329f, -0.67464745f, -0.07595970f, -0.40291518f, 0.00842951f, 
    0.15303735f, 0.14274903f, 0.23072799f, 0.35080877f, -0.29907516f, -0.02103501f, 0.06195904f, 0.07934272f, 
    0.33278582f, 0.12723045f, 0.37576044f, 0.31648687f, -0.06213659f, 0.06477599f, 0.06708903f, 0.45902407f, 
    -0.11100738f, -0.64302504f, -0.51495838f, -0.12848738f, -0.36048076f, 0.60401720f, -0.32969084f, -0.21711363f, 
    0.04631550f, 0.29593787f, 0.17878804f, 0.58886689f, 0.15137830f, -0.11908543f, 0.01539752f, 0.03560212f, 
    0.37922812f, -0.20073999f, -0.56183338f, -0.02008122f, -0.50571591f, 0.28781793f, 0.10978825f, 0.19519934f, 
    -0.32090259f, 0.13979207f, -0.54939640f, -0.46324250f, -0.59411871f, 0.01470305f, -0.72241896f, -0.15516175f, 
    -0.03982251f, 0.44853461f, 0.25529736f, 0.12803552f, -0.24335352f, 0.07342341f, 0.18618983f, -0.20967899f, 
    -0.04666913f, 0.33276600f, 0.27077132f, 0.34842601f, 0.21457271f, 0.41536722f, 0.23553330f, -0.34776476f, 
    -0.05904604f, -0.62598801f, -0.41988745f, 0.57675511f, 0.53611159f, -0.80835181f, -0.42468470f, -0.00729638f, 
    0.56943411f, -0.55502492f, -0.28117481f, 0.25667271f, 0.16172069f, 0.11139014f, -0.21805775f, -0.20398866f, 
    0.17961617f, 0.22849354f, 0.19691640f, 0.16077641f, -0.55395108f, -0.16981287f, 0.07730736f, -0.03721999f, 
    0.28285748f, 0.20408811f, 0.37940821f, -0.43232527f, -0.74767154f, -0.28687027f, -0.13153656f, -0.24502501f, 
    -0.32676899f, -0.09884080f, 0.38311282f, -0.60544783f, -0.65288508f, -0.20566641f, 0.01642190f, 0.06730316f, 
    -0.24248619f, 0.05884734f, 0.07470639f, -0.12307700f, 0.05125378f, -0.03943715f, 0.21608035f, 0.39529622f, 
    0.28521937f, -0.06289841f, 0.26498514f, 0.88836610f, 0.02719447f, -0.53892183f, 0.87979281f, 0.71087325f, 
    0.64867014f, -0.03029026f, -0.28618884f, 0.25605389f, 0.12657249f, -0.30379716f, 0.18773198f, -0.10994898f, 
    -0.04702109f, 0.21878491f, 0.08160794f, -0.23796277f, 0.25199580f, 0.20496552f, 0.12017863f, 0.27326792f, 
    0.12682295f, -0.04797279f, -0.01818018f, -0.12104704f, -0.34811541f, 0.07998902f, -0.40667391f, 0.92153651f, 
    -0.45586786f, 0.27495342f, -0.24631226f, 0.37273812f, -0.20509405f, -0.70084637f, 0.07313963f, -0.14679350f, 
    -0.34825236f, 0.10553618f, -0.11922672f, 0.11475933f, 0.44915634f, -0.33658102f, -0.24294518f, -0.05739959f, 
    -0.12638044f, -0.32421798f, 0.36538559f, -0.14926593f, -0.15089567f, 0.11219848f, -0.13463715f, -0.13132876f, 
    -0.46452138f, 0.59978509f, -0.03682473f, -0.67048717f, -0.69213915f, -0.50316024f, -0.72965193f, -0.22728446f, 
    0.26069817f, 0.40508753f, 0.13877861f, 0.15032986f, 0.26448327f, -0.01538216f, -0.05528872f, -0.06215724f, 
    -0.21734400f, -0.31555644f, -0.12821519f, 0.25543875f, -0.00759191f, 0.14947540f, 0.50327581f, 0.30032951f, 
    -0.39789227f, -0.70509624f, -0.06407157f, -0.00598885f, -0.38868940f, -0.31252271f, -0.41376227f, 0.20960084f, 
    -0.39777374f, -0.40351093f, -0.34878439f, 0.14373027f, -0.49138483f, -0.03160920f, 0.37516275f, -0.26316586f, 
    0.02284532f, 0.56893861f, -0.39072385f, -0.05997810f, -0.46294183f, -0.30913267f, -0.02711194f, -0.53706133f, 
    0.79498887f, 0.21602114f, -0.49149272f, 0.28284520f, 0.94663066f, -0.78177804f, -0.56721264f, 0.04102604f, 
    -0.54831648f, 0.01680353f, 0.35681185f, 0.25986594f, 0.32779285f, -0.38013569f, -0.30428940f, 0.17649081f, 
    0.01694910f, -0.26180801f, 0.44240817f, -0.20956029f, 0.27259082f, -0.26697710f, 0.00144691f, 0.07580376f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03304770f, 0.08084273f, 0.19019879f, 0.30050749f, 0.23750389f, -0.11930045f, -0.00705925f, 0.24729571f, 
    0.25782543f, 0.18508206f, 0.30014944f, -0.00724066f, 0.13076991f, 0.02976326f, 0.11139546f, -0.09000797f, 
    0.05661594f, 0.33938324f, 0.35830176f, 0.04449207f, -0.02707232f, 0.10533196f, 0.04413205f, 0.18797299f, 
    -0.03176145f, 0.23863082f, 0.36801320f, 0.17397477f, 0.10310657f, 0.07265443f, 0.20733783f, 0.02687481f, 
    0.16286421f, 0.06568574f, 0.08961028f, 0.14320303f, 0.00185624f, 0.19956531f, 0.17714725f, 0.17775644f, 
    0.14552274f, 0.02557470f, 0.16977754f, 0.08144093f, 0.13689922f, 0.04208656f, 0.17605737f, 0.25771299f, 
    0.17976575f, 0.04915583f, 0.10455083f, 0.00571202f, 0.32086512f, 0.21799450f, 0.19256479f, 0.29601920f, 
    0.23306677f, 0.36999083f, 0.08623084f, 0.15562695f, 0.08264245f, 0.24470058f, -0.07031013f, -0.17835623f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01289562f, 0.11894576f, 0.08702438f, 0.15733866f, -0.10719342f, 0.01389228f, 0.03490846f, -0.01345650f, 
    0.02767179f, 0.02192468f, -0.04248201f, 0.10794963f, -0.11995630f, -0.04248366f, -0.03658446f, -0.05037978f, 
    0.03624992f, -0.00008387f, -0.00213094f, 0.03594653f, 0.09060103f, 0.02381613f, 0.11939948f, -0.06409264f, 
    0.00183164f, -0.06388581f, 0.07419796f, -0.22770497f, -0.03370158f, 0.06101737f, 0.03394839f, -0.00614938f, 
    -0.04328261f, -0.03525666f, -0.02597566f, 0.05320264f, 0.09396497f, 0.13930593f, -0.03135852f, -0.08843432f, 
    -0.11681137f, -0.04253130f, -0.06417998f, -0.08128741f, -0.06237618f, -0.02579911f, -0.05811761f, -0.06461279f, 
    0.05442017f, 0.01813374f, -0.06201737f, -0.00595569f, -0.18737470f, 0.04919744f, -0.02290055f, 0.07010674f, 
    0.01342838f, -0.06269698f, -0.10594135f, 0.02900861f, 0.21388371f, -0.08608426f, 0.29818633f, 0.11975455f, 
    0.09586845f, 0.01329932f, 0.14440255f, -0.14432715f, 0.02114274f, -0.03684775f, 0.07617486f, 0.00561827f, 
    0.25153798f, 0.19900514f, 0.14278196f, -0.16072819f, 0.04976939f, 0.10186309f, 0.05832246f, -0.11098254f, 
    0.00946343f, 0.07928014f, -0.05454262f, 0.01199832f, 0.06968677f, -0.01680245f, -0.20357206f, -0.22701472f, 
    0.07877903f, -0.00895972f, -0.02476928f, 0.02702084f, -0.09675651f, 0.02620794f, -0.01934050f, 0.00802669f, 
    -0.11442078f, 0.14611471f, 0.03966228f, 0.11592896f, -0.05534804f, 0.11925873f, -0.09029262f, 0.02237610f, 
    -0.00068225f, -0.01821509f, -0.15224397f, 0.06985825f, 0.19938640f, 0.06446325f, -0.00621200f, 0.12217008f, 
    -0.20718057f, -0.07322435f, -0.11064123f, 0.04742584f, -0.06820044f, -0.09123101f, 0.09913969f, -0.06797057f, 
    -0.31173617f, -0.09840570f, -0.01599403f, -0.06691471f, 0.05619769f, -0.04701456f, -0.03781663f, 0.03261893f, 
    0.02128637f, -0.03421564f, -0.06790892f, 0.09327783f, -0.07210942f, 0.08900095f, 0.01607777f, -0.00282213f, 
    -0.01737430f, 0.02225425f, 0.02618771f, -0.00304219f, -0.02995928f, 0.07194638f, -0.00813415f, 0.02782307f, 
    -0.33202165f, 0.10918461f, 0.02529105f, -0.26942357f, -0.03829308f, -0.02483286f, -0.02915990f, 0.03482904f, 
    0.04622771f, 0.02182022f, -0.00101975f, 0.04829040f, 0.13484806f, -0.13957028f, -0.03369990f, -0.17722571f, 
    0.02833427f, 0.00712527f, -0.14824586f, -0.06325764f, -0.02952650f, 0.12075404f, 0.07422677f, 0.09301637f, 
    -0.08591377f, -0.05749959f, -0.07094220f, 0.24308889f, -0.02471745f, 0.08498336f, 0.02053124f, -0.00490746f, 
    -0.03664201f, -0.17804860f, 0.07462558f, -0.02852095f, 0.15607561f, -0.01139350f, -0.10288625f, -0.20550783f, 
    0.06138169f, -0.09071392f, 0.07996028f, -0.16974398f, -0.00887645f, -0.02359419f, 0.01543816f, 0.00077463f, 
    0.23057768f, -0.32760674f, 0.06558729f, 0.28533471f, -0.19986826f, -0.04827232f, -0.04998448f, 0.00837903f, 
    -0.15613280f, -0.09277313f, 0.02507563f, -0.06268981f, -0.08574213f, 0.12092365f, 0.03844448f, 0.01312394f, 
    -0.22010672f, 0.13736463f, 0.07311679f, -0.10434449f, 0.01946106f, 0.01748481f, -0.05369418f, -0.04228116f, 
    0.09246022f, -0.07878595f, -0.13297686f, 0.26429591f, -0.16789000f, -0.07726633f, -0.08567075f, 0.10487111f, 
    0.04005326f, 0.02121781f, -0.11056901f, -0.05526913f, 0.16964355f, 0.05051195f, 0.01121387f, 0.08663879f, 
    -0.08183417f, -0.09459656f, -0.09140061f, 0.01368161f, -0.13116412f, -0.03404233f, -0.12845010f, 0.03155649f, 
    -0.15341811f, 0.16329765f, -0.14691867f, 0.03066800f, -0.09993556f, 0.00178829f, 0.05495070f, -0.08580369f, 
    0.01397082f, 0.03524006f, -0.05011383f, -0.01682367f, -0.19517109f, 0.18921907f, 0.19067235f, -0.12738383f, 
    -0.03168958f, -0.09177691f, -0.03475643f, -0.08698189f, -0.02354015f, -0.00406059f, 0.05910888f, 0.02530243f, 
    -0.05815851f, 0.16073859f, 0.04436990f, 0.07124719f, -0.13370293f, -0.07854277f, 0.00493321f, -0.00824436f, 
    0.03570955f, 0.02119041f, 0.03673812f, -0.07612560f, -0.21378326f, 0.04723666f, 0.16287090f, -0.28571647f, 
    -0.13227384f, 0.02148022f, -0.02101009f, -0.03496100f, -0.05293452f, -0.10176773f, -0.06087453f, 0.00220116f, 
    0.55784637f, 0.05719943f, -0.09628861f, -0.04932429f, -0.05190269f, -0.00854221f, -0.00442507f, 0.00113624f, 
    -0.03378893f, 0.06766264f, -0.00739603f, 0.04939275f, -0.05498498f, -0.19942583f, -0.14633477f, 0.13926084f, 
    -0.07134450f, -0.03608558f, 0.04504687f, 0.02966628f, 0.03536422f, -0.00387678f, -0.04364923f, 0.00151385f, 
    -0.18347485f, 0.09186723f, -0.05196180f, 0.09372579f, -0.03976126f, -0.05591451f, 0.06159365f, -0.06052519f, 
    0.08281600f, -0.00353020f, -0.00324694f, -0.06337550f, -0.27372855f, 0.09578924f, -0.00049760f, 0.10673154f, 
    -0.00510452f, 0.09999287f, 0.05479924f, 0.01186856f, -0.03032271f, 0.01689308f, -0.04053332f, 0.00731083f, 
    -0.21966633f, -0.34135631f, 0.07854281f, 0.10954607f, -0.01487699f, -0.04953479f, 0.09820012f, -0.07521967f, 
    0.02888331f, -0.01299940f, -0.19197808f, 0.02665669f, -0.02582172f, 0.00311989f, -0.04251113f, -0.08866779f, 
    -0.09165353f, -0.10054184f, 0.12395617f, -0.04785245f, 0.00641691f, 0.06912994f, -0.00807277f, 0.00937655f, 
    0.20019090f, 0.03520634f, 0.00742345f, -0.07112408f, 0.00475398f, 0.01195634f, -0.03538378f, -0.03222176f, 
    -0.01585642f, -0.06394219f, 0.12662463f, -0.03098662f, -0.26261809f, 0.05235196f, -0.08264032f, -0.16525063f, 
    0.09720862f, 0.00780330f, -0.04113812f, 0.15726636f, -0.00192678f, 0.09344374f, -0.19747280f, -0.01229301f, 
    0.05391622f, 0.06837175f, 0.18202487f, 0.08782010f, -0.10533358f, -0.02549400f, 0.06255783f, -0.03391051f, 
    -0.01661218f, 0.08343337f, -0.03123053f, 0.04989346f, 0.17860553f, 0.17087758f, 0.08682963f, -0.07146377f, 
    -0.24976876f, 0.01791150f, 0.04142546f, 0.13589431f, 0.00931048f, 0.04166880f, -0.07368366f, -0.10395240f, 
    0.13461837f, -0.10909207f, 0.22676860f, -0.31156227f, 0.02617483f, 0.01386962f, 0.06990750f, 0.00801266f, 
    -0.25935492f, 0.07870384f, 0.00895914f, 0.06071737f, 0.29032078f, -0.08853640f, -0.11106979f, 0.21150579f, 
    -0.26312417f, -0.05913290f, -0.03816617f, 0.01896104f, -0.02657321f, 0.07629212f, 0.02298937f, -0.03049102f, 
    -0.00629252f, -0.23142461f, 0.09186471f, 0.08662169f, 0.04629820f, 0.07935691f, -0.09282646f, -0.03105238f, 
    -0.02518234f, 0.06811195f, -0.06169721f, 0.02536680f, -0.03719792f, 0.08086734f, -0.07610200f, -0.05649774f, 
    0.04703495f, 0.04226769f, 0.02301420f, -0.03803718f, -0.02317967f, -0.00387599f, -0.05986349f, 0.02587561f, 
    -0.06071192f, 0.07923415f, 0.02550801f, 0.16935493f, 0.02861250f, 0.00397080f, 0.01009097f, 0.00886828f, 
    0.00382475f, 0.03353507f, -0.00148405f, 0.03370467f, 0.04445514f, -0.00077168f, -0.04189022f, 0.04766121f, 
    -0.04091505f, 0.00737022f, 0.07870723f, -0.07132979f, -0.04297517f, 0.02593999f, 0.02802095f, 0.04020896f, 
    -0.11673206f, -0.19460721f, 0.09518811f, -0.18123865f, -0.15130775f, 0.07165617f, -0.04558808f, -0.00254014f, 
    0.04668275f, 0.04627137f, 0.03605172f, 0.04571979f, 0.40625367f, 0.09870758f, 0.15657386f, -0.34588939f, 
    0.07605876f, 0.08472258f, -0.06600904f, 0.03807859f, 0.11649363f, 0.02173327f, -0.01224876f, 0.09423309f, 
    -0.02869895f, 0.12498800f, -0.19571204f, 0.07700725f, -0.06789614f, 0.05052642f, 0.11820515f, -0.06845623f, 
    -0.03262987f, -0.03169907f, -0.09445638f, -0.03773968f, -0.05513432f, 0.04195087f, 0.12926486f, -0.12648678f, 
    0.02162573f, -0.01206137f, -0.03634631f, -0.03176811f, -0.07818612f, -0.06673856f, -0.07190394f, 0.02313711f, 
    0.11575884f, 0.11382138f, -0.02060799f, -0.31854942f, -0.05841983f, 0.02375618f, 0.05617717f, -0.10434159f, 
    0.03250148f, -0.01579477f, -0.00851715f, 0.11993538f, 0.41662982f, 0.04226236f, -0.08365500f, -0.20320472f, 
    0.03303728f, -0.00304712f, -0.08235679f, 0.11330248f, 0.06163632f, -0.06166885f, -0.03310406f, 0.04014352f, 
    0.12268694f, -0.03220479f, -0.12531078f, 0.14622574f, -0.04154234f, 0.00283588f, -0.09841157f, 0.07374368f, 
    -0.05890945f, -0.00159062f, 0.05775353f, 0.00424262f, 0.01403248f, -0.06161729f, 0.16251498f, -0.32642779f, 
    -0.17350276f, -0.16452153f, 0.02511047f, 0.03156335f, 0.03162485f, -0.00224484f, -0.03580268f, 0.02736162f, 
    -0.16488160f, 0.09633153f, 0.16890632f, 0.10648076f, 0.08849032f, 0.05186674f, -0.09447005f, -0.02125988f, 
    -0.01846175f, -0.00363527f, 0.14836039f, -0.11800458f, -0.03516418f, 0.03986040f, 0.07014824f, -0.16353655f, 
    0.00179495f, 0.12218720f, -0.05723703f, 0.09148275f, -0.01435585f, -0.04285286f, 0.05831882f, 0.02950440f, 
    0.07231279f, -0.08940545f, -0.00106786f, 0.24026577f, -0.02421119f, -0.03977801f, -0.02774182f, 0.03015096f, 
    -0.10765462f, 0.16552977f, 0.05368102f, -0.05384349f, -0.04236157f, 0.24754645f, 0.10189360f, -0.09096271f, 
    -0.11296684f, 0.04705998f, 0.06631286f, -0.02379414f, -0.03780320f, -0.00593002f, 0.02194024f, 0.06264524f, 
    -0.12429512f, -0.10600229f, -0.12313490f, -0.03538698f, 0.02730332f, -0.02844370f, 0.01068788f, 0.05706079f, 
    -0.01954893f, -0.06722414f, -0.06126418f, 0.01656027f, -0.03472115f, -0.12597492f, 0.00903135f, -0.03537168f, 
    -0.06299432f, 0.02580730f, -0.13851231f, -0.06709792f, -0.06605405f, 0.04987594f, 0.06674720f, -0.05556307f, 
    0.12393934f, 0.01437963f, 0.07883244f, -0.32475004f, -0.04114642f, -0.01410346f, -0.04844379f, 0.01702715f, 
    0.07969232f, -0.00104535f, 0.03453547f, -0.03907512f, -0.44189039f, -0.21135548f, 0.05168591f, -0.07030737f, 
    -0.11103778f, -0.08249899f, 0.02880839f, -0.06381436f, 0.02938097f, 0.10000197f, -0.01922936f, -0.01510979f, 
    0.08154757f, -0.10631565f, -0.02412063f, 0.00776105f, 0.02395922f, -0.06045087f, 0.05530910f, -0.07451221f, 
    0.01503304f, -0.11816097f, 0.02522371f, -0.00495849f, -0.27249029f, 0.03749176f, -0.06406188f, 0.12708579f, 
    0.02593966f, 0.05775318f, 0.01990035f, -0.04315391f, 0.04422108f, 0.06028330f, -0.05966112f, -0.04929509f, 
    -0.02665123f, -0.10018250f, -0.01067903f, 0.04208175f, 0.13781759f, 0.02751743f, 0.09651408f, -0.02578120f, 
    0.03942354f, -0.06122088f, 0.02455648f, -0.07908183f, 0.28335229f, -0.16682465f, -0.02991032f, 0.26813522f, 
    -0.04072457f, 0.06856127f, -0.03272240f, 0.01614627f, -0.08352966f, -0.00098520f, 0.02252776f, -0.06180833f, 
    0.01102529f, 0.02283269f, -0.05668797f, 0.15009193f, -0.05563142f, 0.08920736f, -0.03088826f, -0.00317557f, 
    -0.02331091f, -0.05043766f, -0.08466797f, -0.22652581f, -0.08817349f, -0.16457835f, 0.16943470f, -0.13146289f, 
    -0.00237087f, -0.04206954f, 0.03139848f, 0.00358117f, -0.02490261f, -0.06819469f, 0.00482006f, -0.19381592f, 
    -0.12674530f, 0.05247394f, 0.18942349f, -0.38305634f, 0.00767525f, 0.00733792f, -0.03824854f, 0.12047823f, 
    -0.04755812f, -0.08622253f, 0.14872640f, 0.00238029f, -0.31868711f, -0.01372884f, 0.14930744f, -0.14092180f, 
    -0.00186447f, -0.03455051f, 0.13612236f, -0.22325666f, -0.00554027f, 0.10464058f, -0.00985658f, 0.12607060f, 
    0.26482439f, 0.10564198f, -0.00793399f, 0.13961044f, 0.02624703f, 0.08073353f, -0.06064900f, -0.01578390f, 
    0.00465136f, 0.05011699f, 0.16537768f, -0.06909772f, 0.06650101f, -0.00451445f, -0.01112261f, -0.11749367f, 
    0.05370897f, 0.07267800f, -0.08341277f, 0.03946823f, -0.14378540f, -0.09922136f, -0.09291925f, 0.05712105f, 
    0.19035822f, -0.05484720f, 0.14474204f, -0.00357340f, 0.07430752f, -0.12987727f, -0.06371390f, -0.02350779f, 
    -0.04962035f, -0.06003045f, 0.09436541f, -0.12555440f, -0.06739082f, 0.04751963f, -0.15220091f, 0.03147667f, 
    -0.06803615f, -0.01725069f, 0.12033106f, 0.08016430f, 0.02501781f, 0.05706160f, -0.08786657f, 0.11039878f, 
    0.14840972f, -0.09949455f, 0.05490648f, 0.02448738f, -0.04980093f, -0.07638706f, 0.01333268f, -0.06089347f, 
    -0.14304262f, 0.13562529f, 0.03658126f, 0.04992781f, -0.13483191f, -0.07439117f, -0.11114828f, -0.08011640f, 
    -0.00997778f, -0.09419960f, -0.16642450f, -0.06153389f, 0.09314954f, 0.10017874f, -0.12053968f, -0.04278332f, 
    -0.12599179f, -0.04246831f, -0.04350320f, -0.10263295f, -0.09233606f, 0.05390690f, -0.17591183f, 0.02574389f, 
    0.13338572f, 0.08297583f, 0.03545226f, 0.04808453f, 0.08799159f, -0.06651162f, 0.04200405f, -0.13275291f, 
    0.04131104f, -0.01458290f, 0.05905871f, 0.12203833f, 0.08692872f, -0.06252639f, 0.00991749f, 0.09578443f, 
    -0.21805337f, -0.08906579f, -0.19410324f, -0.31523868f, -0.02793505f, -0.06342441f, 0.03918828f, 0.05460091f, 
    -0.07036260f, -0.01815698f, 0.00876193f, -0.05361803f, 0.16912800f, 0.03403893f, 0.01536372f, 0.13767949f, 
    -0.16075695f, -0.03007491f, -0.07457493f, 0.03815848f, 0.04538318f, 0.11829349f, 0.03285162f, 0.17168164f, 
    0.08205075f, -0.23123997f, -0.00236195f, 0.07272771f, 0.00420245f, -0.02252080f, 0.06980330f, 0.06175034f, 
    0.01497986f, 0.01455003f, 0.00516195f, -0.00005990f, 0.03453210f, 0.13238570f, -0.06013733f, 0.06542092f, 
    -0.02735607f, -0.20350234f, -0.01907253f, 0.03307322f, 0.12405530f, -0.23330666f, -0.04640688f, 0.02730645f, 
    0.18827774f, -0.10063555f, -0.13487171f, -0.00168940f, -0.06768171f, -0.11032195f, 0.02066773f, 0.01806442f, 
    0.03009703f, -0.01416618f, -0.09409245f, -0.13099428f, 0.12256899f, 0.09315310f, -0.02879362f, -0.16148926f, 
    -0.00763693f, -0.02325533f, 0.09789970f, 0.05948792f, -0.09531799f, -0.22240074f, -0.04571760f, -0.21423465f, 
    0.09990775f, 0.21310081f, -0.01448942f, 0.15401186f, -0.12147561f, 0.02601749f, -0.02010038f, -0.10693959f, 
    0.04577376f, -0.02451276f, -0.01112541f, -0.06557535f, 0.19636652f, -0.19025862f, 0.03771064f, -0.11461569f, 
    0.03712238f, -0.19846299f, -0.05151348f, -0.03888426f, -0.05235783f, 0.01676874f, -0.17983492f, 0.15995362f, 
    -0.17113909f, 0.13374925f, 0.14426349f, 0.23574628f, 0.01806686f, 0.00687073f, 0.08969086f, 0.05977776f, 
    -0.04816873f, -0.01992718f, -0.05398272f, -0.05577417f, 0.13668582f, -0.08718349f, -0.41456857f, 0.07218070f, 
    0.05967451f, -0.04626839f, -0.00399885f, 0.14464355f, -0.02023233f, 0.06980276f, 0.00102634f, 0.00718416f, 
    0.24580242f, -0.14206728f, 0.10338454f, 0.04811652f, -0.01480146f, 0.01197301f, -0.03564781f, -0.00169913f, 
    -0.05880696f, 0.03507758f, 0.00666761f, -0.05122530f, 0.06384265f, 0.03825603f, 0.05189435f, 0.13479283f, 
    -0.07774696f, 0.10715762f, 0.12366012f, 0.05278961f, -0.02297428f, -0.06286813f, 0.12381487f, -0.02700953f, 
    0.07318693f, -0.01326481f, 0.03987834f, 0.19630545f, -0.01663002f, -0.12871034f, 0.01153552f, -0.11523753f, 
    -0.03720713f, -0.12663570f, 0.08343107f, -0.00906150f, 0.18898366f, 0.03425621f, -0.20860541f, -0.22844505f, 
    0.07219943f, 0.10426727f, -0.03044701f, 0.02086319f, -0.00134981f, 0.01713894f, -0.11749776f, -0.06398961f, 
    0.08458035f, -0.07663248f, -0.02408157f, -0.09433154f, -0.24040413f, -0.06893924f, 0.10552803f, 0.00109257f, 
    -0.07510120f, -0.10936679f, -0.06264828f, 0.16203302f, 0.15676372f, -0.03851766f, -0.08657362f, -0.28600514f, 
    -0.00183209f, -0.03227805f, 0.11168022f, 0.06147812f, -0.05599197f, 0.07223820f, 0.08400308f, 0.01927713f, 
    -0.65773284f, 0.00454111f, 0.06061362f, 0.03680588f, 0.04588217f, -0.07882594f, 0.07416898f, 0.00757562f, 
    0.14777021f, 0.00047289f, -0.01869960f, -0.05907587f, -0.25151128f, -0.03729132f, -0.09792510f, -0.08064089f, 
    -0.07024755f, 0.05144984f, -0.02549275f, -0.03317291f, 0.00405696f, -0.03203863f, 0.11865286f, 0.01821185f, 
    -0.05745780f, 0.15720415f, -0.11969916f, 0.10902467f, -0.04584947f, 0.05084300f, -0.15531863f, -0.16501801f, 
    -0.07389724f, -0.00709813f, 0.08505566f, 0.03234370f, 0.27717200f, 0.06608158f, -0.00211298f, 0.11614504f, 
    0.04252616f, 0.09715458f, -0.08205979f, 0.03929923f, -0.01777023f, 0.03456452f, 0.07638938f, 0.00261390f, 
    -0.18488915f, 0.08780987f, 0.00452771f, -0.00487519f, 0.01293682f, -0.01594240f, -0.05423709f, 0.13186237f, 
    0.04370160f, 0.01433366f, 0.12556949f, -0.03806648f, 0.05430903f, 0.11450155f, 0.09742469f, 0.07578200f, 
    -0.11018849f, -0.00690405f, 0.03082097f, -0.04918183f, -0.02401195f, 0.06950001f, 0.09794201f, 0.05355424f, 
    0.32999879f, -0.18913448f, 0.09144068f, -0.06580887f, 0.09835029f, 0.04159955f, -0.02387369f, 0.03010389f, 
    0.04453682f, 0.10012982f, -0.06922336f, 0.05221346f, 0.13464677f, -0.05399309f, -0.06042112f, 0.09013848f, 
    -0.08825760f, -0.03219570f, -0.15319511f, -0.04984076f, -0.01008919f, -0.20850192f, 0.14391634f, -0.04933481f, 
    0.02338165f, -0.02545741f, -0.11001220f, -0.00891453f, 0.03910352f, -0.00856203f, -0.03355880f, -0.02595153f, 
    0.08123875f, -0.03919255f, 0.03949318f, 0.04304951f, 0.05602217f, -0.12004382f, 0.12502173f, -0.00225907f, 
    0.00292909f, -0.10837440f, -0.09266306f, 0.00582956f, -0.07234191f, -0.01649933f, -0.05843970f, 0.01553004f, 
    0.27637365f, -0.26376951f, 0.12944415f, -0.31861889f, 0.13232578f, 0.06883508f, -0.05531574f, 0.09451251f, 
    0.01638052f, -0.01950412f, 0.08964963f, -0.02898937f, -0.25840226f, -0.06604981f, 0.10416551f, 0.11863856f, 
    0.00085290f, 0.02035670f, 0.01722783f, 0.08096525f, 0.02544402f, -0.04156899f, -0.08093061f, -0.04213081f, 
    0.06254746f, -0.11949179f, -0.04068477f, -0.05798538f, -0.14284208f, 0.03428749f, -0.06709194f, 0.10017099f, 
    -0.10740874f, -0.00116696f, -0.00722691f, 0.04682513f, -0.00594972f, -0.00086272f, -0.16525146f, 0.07695477f, 
    -0.00109637f, -0.04928463f, -0.03253179f, 0.00622218f, 0.08016994f, 0.03627536f, -0.09966411f, -0.03022042f, 
    0.20829755f, -0.42226309f, 0.03743042f, 0.04150126f, 0.02949831f, -0.05582644f, -0.01492133f, -0.01574461f, 
    -0.07082009f, -0.01334263f, -0.08739813f, -0.05937565f, 0.07567152f, 0.09141944f, 0.11453996f, 0.03006846f, 
    -0.10714353f, -0.00989318f, 0.02869692f, 0.04442225f, -0.02002527f, -0.03253061f, -0.16572563f, -0.05163814f, 
    0.24285847f, 0.17924306f, 0.01358054f, 0.09937150f, -0.04423891f, -0.11755516f, 0.02599155f, 0.07962445f, 
    0.04397905f, 0.02537472f, -0.07761330f, 0.01250907f, -0.13594005f, -0.03053755f, -0.14329094f, -0.21180800f, 
    -0.00474062f, -0.13886663f, 0.00782720f, 0.02123285f, 0.07940818f, 0.09333547f, -0.07975153f, -0.07918829f, 
    0.00844537f, 0.03431490f, 0.01040164f, 0.11920156f, -0.14410055f, 0.06881226f, -0.00418852f, -0.02526518f, 
    -0.05526226f, 0.02058216f, 0.06572445f, -0.03739028f, 0.07216900f, -0.08005809f, 0.05898657f, -0.22607243f, 
    -0.04459478f, -0.03897038f, 0.13978061f, -0.03696182f, 0.08212472f, 0.00762198f, 0.07791455f, 0.08265021f, 
    0.16341768f, -0.34173262f, 0.07525515f, -0.17824079f, 0.11212599f, -0.05612437f, -0.05969039f, 0.06463249f, 
    -0.11590169f, 0.02000590f, -0.01262051f, -0.02405608f, -0.26126096f, 0.04745167f, 0.06012145f, -0.03656982f, 
    0.16774787f, 0.00297613f, -0.02933324f, -0.01606024f, -0.06797164f, 0.09825263f, -0.07617865f, 0.07375067f, 
    0.21915852f, 0.11084075f, 0.12067964f, 0.21070181f, -0.00218435f, -0.05771974f, 0.08480541f, 0.00455486f, 
    0.02173557f, -0.10918641f, -0.01425846f, -0.09183052f, 0.16881493f, 0.03649559f, 0.10259473f, -0.18374039f, 
    -0.05464208f, -0.09083707f, 0.09947168f, 0.00930239f, 0.00727115f, 0.03413876f, 0.00007675f, 0.01351017f, 
    -0.11002002f, -0.15437673f, -0.31284547f, 0.02609134f, 0.03162904f, 0.01950112f, 0.07440896f, -0.15085541f, 
    -0.12769489f, -0.00341333f, -0.15342702f, 0.04817559f, 0.05949932f, 0.02955731f, -0.08415296f, -0.05326652f, 
    -0.02737824f, -0.03260131f, 0.06246245f, -0.06088096f, 0.07412209f, 0.11691495f, -0.10916877f, 0.00592129f, 
    0.23434420f, 0.00203268f, -0.04737913f, -0.09592357f, -0.02072730f, -0.07903406f, -0.04092374f, 0.03709486f, 
    -0.01987768f, -0.18707620f, 0.06983870f, -0.02526904f, 0.16945004f, -0.01071326f, -0.04856672f, -0.13984932f, 
    0.06875301f, 0.01929128f, -0.06568970f, 0.06748296f, 0.17323387f, -0.02947931f, -0.13919309f, 0.00520634f, 
    0.25591597f, -0.10394607f, -0.26415637f, 0.08986274f, 0.03775914f, 0.06246012f, -0.04319203f, 0.20018587f, 
    0.03661956f, -0.11225880f, 0.06875414f, 0.04249808f, -0.10242224f, 0.13305198f, -0.03855995f, -0.02194881f, 
    0.09535617f, 0.06390067f, 0.10869704f, -0.02932174f, -0.04339502f, 0.00824994f, -0.11851502f, -0.00268090f, 
    -0.00827850f, -0.04066188f, 0.03034184f, 0.06981918f, 0.06382768f, -0.02282607f, 0.10884509f, 0.03595022f, 
    0.04537776f, 0.08244907f, 0.00665865f, 0.09190322f, 0.28145751f, -0.09488083f, 0.02684386f, -0.11482089f, 
    0.02014835f, 0.07340589f, -0.07349785f, 0.09569134f, 0.00113928f, -0.17050162f, 0.04983118f, -0.01796643f, 
    -0.08855522f, -0.09045631f, -0.12750541f, -0.10695617f, -0.05514180f, 0.02587017f, -0.03371016f, 0.01510998f, 
    0.11070208f, 0.07173639f, 0.06199168f, 0.04255764f, -0.37008449f, -0.07285316f, -0.23693597f, 0.11476745f, 
    -0.06974260f, 0.00622897f, -0.09095789f, 0.03054515f, -0.07285716f, -0.05973875f, 0.00484359f, 0.08179922f, 
    0.03880256f, -0.38163298f, -0.02727302f, -0.28843373f, -0.07345808f, -0.15249828f, -0.01762806f, 0.01839068f, 
    -0.04797000f, 0.00887657f, 0.09639982f, 0.01274699f, 0.07582930f, -0.16573070f, 0.03936327f, 0.02849499f, 
    -0.09328187f, -0.05286775f, -0.15605344f, -0.02923299f, -0.05537869f, 0.11527785f, -0.00561520f, 0.10889149f, 
    -0.16629381f, -0.03843354f, -0.24712157f, 0.14521542f, 0.06889927f, -0.10413305f, 0.00607012f, -0.04641837f, 
    0.05439430f, 0.10599364f, -0.10535724f, -0.00320794f, -0.10680655f, -0.05340008f, 0.11621725f, -0.20097299f, 
    0.05294297f, -0.04175636f, 0.07874838f, 0.01813284f, 0.09949234f, 0.04607907f, 0.00914255f, 0.09882099f, 
    0.16859800f, -0.11847058f, -0.03156120f, -0.41106269f, 0.03148185f, -0.01999097f, 0.11706169f, -0.16487581f, 
    -0.10789490f, 0.02104622f, -0.08933228f, -0.17896698f, 0.03156275f, -0.17525335f, -0.01071972f, -0.10940906f, 
    -0.13278547f, 0.05939398f, -0.00050781f, 0.05821335f, -0.01988177f, 0.11398863f, 0.17800529f, -0.15528275f, 
    0.10052983f, -0.24475048f, 0.03679226f, -0.14361426f, 0.09052693f, 0.01947939f, 0.00994257f, 0.03968358f, 
    0.00932870f, 0.07116760f, 0.00068542f, 0.00730839f, 0.28079280f, -0.19337295f, -0.00011672f, -0.15457356f, 
    -0.07079228f, 0.01850769f, -0.16425897f, 0.00837620f, -0.00155430f, -0.02187146f, 0.01686210f, -0.11363975f, 
    -0.28280228f, -0.02384765f, 0.04690333f, -0.11804036f, -0.04182177f, 0.04112182f, 0.05483622f, -0.06762121f, 
    -0.05011548f, 0.14267433f, 0.00831608f, 0.02358073f, -0.13833889f, 0.07772632f, -0.06655877f, -0.20255682f, 
    0.03544667f, 0.06259398f, 0.06319603f, -0.05319615f, 0.01423208f, -0.00582046f, 0.01749528f, -0.03429082f, 
    0.08929263f, 0.04430296f, -0.03533566f, -0.14320992f, 0.05587709f, -0.04605645f, 0.09956370f, 0.03108555f, 
    -0.10912856f, 0.01411028f, -0.04430864f, -0.02818471f, 0.14151414f, 0.04383909f, 0.02920886f, 0.14382294f, 
    -0.11851232f, -0.04217937f, 0.09365085f, -0.08274012f, 0.05396019f, 0.00679776f, -0.03769317f, 0.04012734f, 
    0.16786775f, 0.02526391f, 0.09086685f, 0.14478774f, -0.00848014f, -0.04263988f, -0.05893845f, 0.02075348f, 
    -0.05933484f, 0.05582483f, 0.00477692f, -0.05077885f, -0.05085364f, -0.06749235f, 0.09588738f, 0.13243978f, 
    -0.10532976f, -0.10331701f, -0.10642304f, 0.00565421f, -0.00703545f, -0.04569746f, 0.02908761f, -0.03564195f, 
    -0.08725633f, 0.13949344f, -0.28680614f, -0.08702564f, -0.05360705f, 0.04645913f, -0.03833389f, 0.00715429f, 
    0.01680075f, 0.05985001f, -0.07628495f, -0.00795449f, 0.16894504f, 0.01901534f, 0.02963164f, -0.05760374f, 
    0.14569862f, -0.07584298f, 0.01766063f, 0.02248312f, -0.00159881f, -0.10959729f, -0.02611248f, 0.02133311f, 
    0.40825924f, 0.01936526f, -0.13263036f, -0.02276742f, -0.11273164f, -0.03296223f, 0.00458115f, 0.02084545f, 
    0.02315413f, 0.00160455f, -0.06845118f, -0.00203648f, -0.09062785f, 0.12969686f, -0.10974311f, -0.13535319f, 
    0.04073068f, 0.06514516f, 0.09696797f, -0.07208291f, -0.03363935f, -0.05283834f, -0.00000858f, -0.01521249f, 
    0.38039193f, 0.06065735f, -0.01658739f, 0.11351331f, -0.14929150f, -0.13121161f, -0.09095901f, 0.03802724f, 
    0.09042826f, 0.01976319f, 0.05185013f, -0.00949338f, -0.24073881f, 0.05212373f, 0.10179019f, 0.00132005f, 
    -0.05370817f, -0.07134063f, -0.00668626f, -0.07020374f, -0.05200519f, -0.02606384f, -0.03723280f, 0.07188041f, 
    0.19855921f, -0.01848021f, -0.19908577f, 0.11214701f, 0.00699931f, 0.02271501f, 0.06622245f, -0.13151467f, 
    -0.01024039f, 0.04773597f, 0.07591803f, -0.07543977f, 0.07916911f, -0.02720460f, 0.05712590f, 0.10971042f, 
    -0.05453178f, 0.00118288f, 0.03407218f, 0.16642669f, -0.00495557f, -0.06920210f, 0.03179510f, -0.01487370f, 
    -0.34489393f, 0.18483239f, -0.12902912f, -0.17677957f, -0.04524552f, 0.07866059f, -0.07865274f, -0.03311155f, 
    -0.01296305f, 0.11360112f, 0.02719314f, -0.02503868f, 0.13096415f, -0.22882442f, -0.09588160f, -0.09194278f, 
    0.04579107f, -0.09624771f, -0.04843425f, 0.00466916f, -0.07598215f, -0.06514483f, -0.01666707f, -0.01776370f, 
    0.16950102f, -0.10957326f, -0.03845284f, -0.02299831f, 0.07664103f, -0.02454120f, 0.03550168f, 0.00351624f, 
    -0.03649413f, 0.05387233f, 0.04806205f, -0.09641594f, -0.17621115f, 0.12150007f, -0.10313960f, -0.04846263f, 
    -0.01967403f, -0.00237577f, -0.08070245f, -0.02779750f, 0.08845621f, 0.08408441f, -0.04670830f, 0.03492822f, 
    0.00898709f, 0.09013831f, -0.05598082f, 0.08728974f, -0.07800411f, 0.05355316f, 0.02680681f, -0.11653030f, 
    0.01266227f, 0.03811365f, -0.08855196f, -0.03611808f, 0.20620313f, -0.03008245f, -0.11266355f, -0.06687528f, 
    0.07857298f, 0.03408922f, -0.11787456f, -0.07839399f, 0.03971731f, 0.03223189f, 0.09167904f, 0.03639390f, 
    0.07479182f, -0.04944241f, -0.01419901f, -0.17619549f, 0.02014300f, 0.08554260f, 0.06912746f, 0.03115347f, 
    -0.01451892f, -0.04472204f, 0.00096167f, -0.05103422f, -0.15573528f, -0.18927778f, 0.02990978f, -0.22171052f, 
    -0.01268735f, -0.06781522f, 0.12007008f, -0.05567669f, -0.01114997f, 0.03130799f, 0.06217827f, -0.04519748f, 
    0.23089041f, 0.09239646f, 0.00890807f, -0.01441799f, 0.07405721f, 0.06127875f, 0.00258343f, -0.10765007f, 
    -0.13942325f, 0.09102739f, 0.03958399f, 0.13089220f, 0.44149199f, 0.11349958f, -0.18835822f, 0.16414139f, 
    0.08542810f, 0.05108029f, 0.02530071f, -0.03579435f, -0.10436983f, -0.05233085f, -0.05659162f, -0.06331773f, 
    0.16684318f, 0.03999766f, -0.06416537f, -0.08676459f, -0.11485756f, 0.01021256f, -0.07460442f, 0.05795706f, 
    0.00310650f, -0.02645631f, -0.09189782f, -0.00745108f, 0.08175340f, -0.07774929f, 0.11337412f, -0.01180818f, 
    -0.05101775f, 0.04028054f, -0.02640252f, -0.06391780f, 0.00745719f, -0.00038108f, 0.02644468f, 0.01111703f, 
    0.07185013f, -0.13850194f, -0.01841787f, -0.12679107f, -0.01001472f, 0.01092627f, 0.00039042f, 0.03001157f, 
    0.02802401f, 0.06436963f, -0.11663131f, -0.04623828f, 0.04436761f, 0.13977486f, -0.09052549f, 0.17118682f, 
    -0.02230386f, 0.03728023f, 0.04902307f, -0.08175541f, 0.06634647f, -0.14388740f, -0.09218222f, 0.01567364f, 
    -0.26109636f, 0.18905611f, 0.06932599f, 0.01264610f, 0.07993957f, -0.00801213f, 0.00154316f, 0.10500522f, 
    0.00155605f, -0.15674910f, -0.01268132f, -0.01667848f, 0.38453200f, -0.14546326f, 0.05798762f, 0.21481985f, 
    -0.12537189f, -0.03715197f, 0.01441106f, -0.03738865f, -0.06454498f, 0.03451274f, -0.05681550f, 0.02876676f, 
    -0.05477764f, -0.10435815f, 0.02706848f, -0.05863608f, 0.05536065f, -0.02024248f, 0.01543016f, -0.05369794f, 
    0.07426602f, -0.04120880f, 0.00381142f, 0.07082757f, 0.06555957f, -0.17909658f, 0.04878440f, -0.03508133f, 
    0.08871514f, -0.01871663f, 0.08191224f, -0.06176583f, 0.03647318f, 0.06464018f, -0.02837762f, 0.03998858f, 
    -0.17790504f, -0.08169461f, 0.14266591f, -0.01551761f, -0.03453502f, 0.01607199f, 0.04737981f, -0.00522251f, 
    -0.04773238f, -0.10002290f, -0.12302014f, 0.05882784f, 0.28278643f, 0.16175775f, -0.07773997f, -0.01116741f, 
    0.03048836f, 0.01222377f, 0.01566734f, -0.04093925f, -0.05611391f, 0.01619276f, -0.04242633f, 0.01164417f, 
    -0.38846681f, -0.12638079f, 0.11575470f, 0.17098111f, -0.07109120f, 0.01528769f, -0.10511209f, -0.14852349f, 
    -0.07600504f, -0.09604921f, -0.06098570f, -0.02312798f, 0.25029710f, 0.01572775f, 0.11036547f, 0.09572533f, 
    -0.10334175f, -0.00511741f, 0.01416777f, 0.07438403f, 0.02639858f, 0.04202425f, 0.04564785f, -0.03361895f, 
    0.31079578f, -0.13310537f, 0.00820710f, -0.07211620f, 0.01791618f, 0.06395456f, 0.06365234f, 0.06569663f, 
    -0.00387899f, 0.04508276f, -0.02028043f, -0.07957129f, 0.10102337f, -0.02380840f, -0.10997338f, -0.04698363f, 
    0.01378850f, 0.01758811f, 0.00663832f, 0.00688278f, -0.11520338f, 0.04538855f, 0.09436154f, -0.04790059f, 
    0.01102433f, -0.18686268f, 0.08529611f, -0.06449000f, 0.09288837f, 0.01060389f, 0.05610927f, -0.11487377f, 
    -0.05786651f, 0.04919397f, -0.03781175f, 0.00312993f, 0.25732148f, 0.02425158f, 0.10428036f, 0.15328664f, 
    0.04164301f, -0.01210599f, -0.00075014f, -0.02967422f, -0.05391282f, 0.01381736f, 0.04877677f, -0.12649274f, 
    -0.01072825f, -0.04299089f, 0.05464827f, 0.04343455f, 0.05359354f, 0.05924373f, -0.06055581f, -0.04719813f, 
    0.05005098f, -0.01908340f, -0.01663874f, -0.12779300f, -0.32065681f, -0.06871177f, 0.02697916f, -0.19003248f, 
    0.09150272f, 0.06609596f, -0.04684013f, -0.09410593f, -0.07103954f, -0.10981984f, 0.08004968f, -0.09487322f, 
    -0.10119213f, 0.21040788f, 0.06443775f, 0.24420433f, -0.10797474f, -0.09764293f, 0.10224157f, 0.04755001f, 
    -0.03548517f, -0.10828525f, 0.05386174f, 0.02600306f, 0.28761658f, 0.07394179f, 0.07194777f, 0.05520380f, 
    -0.07216293f, -0.06055909f, -0.01744889f, 0.07029241f, -0.06923793f, 0.01374630f, 0.00508295f, -0.02956153f, 
    0.03029046f, 0.09162033f, -0.02503115f, 0.05589778f, 0.01804781f, 0.04834713f, 0.10004910f, 0.04256164f, 
    0.05814782f, 0.10253059f, 0.01069361f, -0.06362584f, -0.16249202f, -0.04096527f, 0.04395880f, -0.17914428f, 
    0.04435955f, -0.10386033f, 0.04031236f, -0.01913705f, -0.05413361f, 0.06361057f, -0.01188363f, -0.03201202f, 
    -0.24061117f, -0.01655488f, -0.09614995f, -0.34119332f, -0.06114418f, -0.09019620f, -0.05019959f, 0.00474811f, 
    0.05074752f, 0.05676629f, -0.02427722f, 0.00809357f, 0.16044210f, 0.04206490f, 0.00636544f, 0.09572781f, 
    -0.14421935f, 0.02513193f, 0.01908544f, 0.17950259f, -0.01980999f, 0.05029162f, 0.02321024f, -0.07383906f, 
    -0.15264224f, -0.05129081f, -0.02560910f, 0.06567964f, 0.01019436f, -0.01531246f, 0.08738685f, 0.05653210f, 
    -0.14270253f, 0.06792904f, -0.05358544f, -0.02650000f, 0.02919988f, -0.18830615f, -0.07429463f, -0.01223881f, 
    -0.03017979f, 0.15355301f, -0.00443917f, -0.14508067f, 0.01997269f, 0.03228395f, 0.03057755f, 0.04668844f, 
    -0.00110718f, -0.17055292f, 0.06773049f, 0.03097353f, -0.16160992f, -0.01915560f, -0.01366106f, -0.03192463f, 
    0.01459464f, 0.01119862f, -0.03104502f, -0.01938938f, 0.20698047f, -0.02917347f, -0.02447264f, 0.08460493f, 
    -0.17438993f, -0.01607990f, -0.04488419f, -0.06113336f, -0.06893861f, 0.03298794f, 0.02308532f, -0.04569305f, 
    -0.27438655f, 0.11958157f, -0.04932997f, -0.02221342f, 0.07762472f, 0.04430898f, 0.05414533f, -0.09236059f, 
    -0.03492300f, -0.02638253f, -0.01214366f, 0.01318169f, -0.00346457f, 0.08216983f, -0.03280385f, -0.09619296f, 
    -0.03695342f, -0.04702381f, 0.01142286f, -0.04473550f, -0.16544276f, 0.05962273f, -0.10018837f, -0.06410270f, 
    -0.12632364f, -0.05801105f, 0.19077213f, -0.06755557f, -0.04209262f, -0.07659079f, 0.13072218f, -0.07188738f, 
    -0.07055732f, -0.07224550f, -0.01055841f, 0.00365595f, 0.25119853f, -0.12395337f, -0.17443921f, -0.10724995f, 
    -0.09959934f, -0.05696119f, 0.05643302f, -0.05163723f, -0.00340554f, 0.08991580f, -0.01330359f, -0.10184379f, 
    -0.32788810f, -0.11239158f, -0.32347921f, 0.00558797f, 0.03389186f, -0.07969970f, 0.04081108f, -0.04956372f, 
    0.02204178f, -0.01422209f, -0.01863331f, -0.00726512f, -0.01675381f, -0.12116046f, 0.17207575f, -0.08124740f, 
    0.07993277f, 0.01449346f, 0.02961654f, -0.01421282f, 0.04956004f, -0.08548914f, 0.04164488f, -0.05031624f, 
    -0.23310079f, -0.03565879f, -0.28614166f, -0.19503157f, 0.02847645f, 0.12090508f, -0.01739677f, 0.04338071f, 
    0.00144541f, -0.06898339f, 0.01600163f, -0.12241135f, -0.17728978f, -0.05500452f, -0.09630957f, -0.22348106f, 
    0.11606769f, -0.03416737f, 0.05961730f, 0.02371159f, -0.08057757f, 0.05951155f, -0.09983133f, -0.15354389f, 
    -0.37490651f, -0.05524157f, -0.00888001f, -0.17635462f, 0.01052129f, 0.08873913f, 0.06785498f, -0.11241846f, 
    -0.02278787f, -0.06056173f, -0.01369270f, -0.07978057f, 0.04656367f, 0.20927188f, -0.07282949f, 0.02615075f, 
    0.09666492f, -0.04483842f, 0.08598511f, -0.11151446f, -0.08776297f, 0.01184259f, -0.10855067f, -0.04507611f, 
    -0.44642618f, -0.31067342f, -0.33829856f, 0.02976694f, -0.12509550f, -0.15875344f, -0.05505977f, 0.02165742f, 
    -0.00930225f, 0.03248703f, 0.11939635f, 0.07442635f, 0.11700270f, 0.13946134f, -0.04382645f, 0.12176929f, 
    -0.02384566f, -0.13488556f, -0.12561922f, -0.05143017f, -0.00965309f, 0.12887789f, 0.05388421f, -0.06886299f, 
    -0.05116759f, 0.01137775f, 0.05212293f, 0.07501420f, 0.04036907f, -0.06206417f, 0.08882283f, -0.05674806f, 
    0.03029311f, -0.04116680f, -0.13768971f, 0.11566401f, -0.19912101f, -0.17176300f, -0.17439118f, -0.02738462f, 
    -0.00396351f, 0.01273571f, 0.02806266f, 0.01395198f, -0.05674320f, -0.00794018f, 0.05953550f, -0.13882141f, 
    0.05996889f, -0.31910533f, -0.37480888f, -0.07658258f, -0.05634131f, -0.01704843f, -0.02586153f, 0.08368921f, 
    0.01460858f, -0.07189772f, 0.06547631f, -0.11239094f, -0.12825599f, 0.19446647f, -0.08817806f, 0.08423714f, 
    -0.08726757f, -0.06978790f, -0.02139720f, -0.06178719f, -0.02958907f, -0.05652391f, 0.10346133f, -0.05145881f, 
    -0.13348071f, 0.10829926f, -0.01230318f, -0.17849685f, -0.07564952f, -0.04814127f, 0.07329628f, -0.01676890f, 
    0.01733486f, -0.11055113f, -0.09911097f, 0.02114997f, 0.14572750f, -0.02730516f, -0.09490783f, -0.07208702f, 
    -0.14915493f, -0.10882749f, -0.00393225f, -0.04891830f, -0.05343132f, 0.00347586f, -0.02264513f, -0.02889789f, 
    -0.02886022f, 0.18427770f, 0.09849363f, 0.05383088f, -0.00834571f, 0.00492057f, 0.03043306f, 0.03809017f, 
    0.02338706f, -0.00640491f, -0.01819894f, 0.06078979f, -0.62629431f, -0.27635765f, 0.07893752f, -0.08429148f, 
    -0.05761314f, 0.03315703f, -0.01356516f, -0.03874866f, -0.06059920f, -0.08946710f, 0.08293458f, -0.04081820f, 
    0.15713228f, -0.00746143f, 0.05140888f, 0.00293265f, -0.07789622f, 0.00430764f, -0.02472864f, -0.04974531f, 
    -0.08794212f, 0.12203575f, 0.02493535f, 0.06102580f, -0.05998874f, 0.10378034f, -0.11273435f, -0.01487290f, 
    -0.03120521f, 0.05651509f, 0.05767370f, 0.00691778f, 0.02643290f, 0.01824701f, 0.06266202f, 0.11456883f, 
    0.13946050f, -0.03747535f, -0.04395459f, 0.14095469f, -0.09793054f, -0.09124952f, 0.09479159f, 0.02767099f, 
    -0.10263848f, 0.04944732f, -0.00338395f, 0.05117308f, 0.19753334f, -0.18065381f, -0.11073314f, 0.01853555f, 
    0.07885385f, 0.04726344f, 0.09674911f, 0.03836063f, -0.09134223f, 0.13305371f, 0.03268989f, -0.05506188f, 
    -0.38744184f, -0.09862985f, 0.00070409f, 0.06166392f, -0.04272696f, -0.04391254f, 0.09316935f, 0.01643031f, 
    0.02360224f, 0.01012029f, -0.17827344f, 0.03105467f, 0.06329931f, -0.14284915f, 0.06555370f, -0.09907811f, 
    -0.09829152f, 0.06400725f, 0.02935187f, 0.08471601f, -0.00595204f, -0.03155139f, 0.14029971f, 0.05272190f, 
    0.25034690f, -0.22527270f, 0.00451000f, 0.18095838f, 0.06299434f, 0.06552359f, -0.03963188f, -0.02744093f, 
    0.06678783f, 0.09188429f, 0.06607188f, -0.07126466f, 0.31700954f, 0.09629085f, -0.06866916f, -0.18476020f, 
    -0.04367290f, 0.02815343f, 0.07685708f, -0.02245941f, -0.06398113f, -0.12723838f, 0.01197086f, -0.08435646f, 
    0.05220935f, -0.34530377f, -0.38794211f, 0.11773846f, -0.05093374f, -0.09249143f, 0.07644327f, 0.08953172f, 
    -0.00960019f, -0.03682484f, -0.01263178f, -0.00561847f, -0.29760394f, -0.34648344f, -0.10800891f, 0.12330722f, 
    -0.03094250f, -0.06121666f, -0.08415049f, -0.04158012f, -0.00688568f, -0.04013380f, -0.09989289f, 0.05169823f, 
    -0.31899118f, -0.15233456f, -0.12204377f, 0.27693066f, -0.05125409f, 0.06216189f, 0.10244010f, -0.01981647f, 
    0.11815706f, -0.00384560f, -0.05342278f, -0.02419489f, -0.42347682f, 0.16028042f, 0.19544771f, 0.13132302f, 
    0.02513334f, 0.07537153f, -0.02943674f, 0.12617806f, 0.02818669f, 0.07894883f, -0.07461790f, 0.02667993f, 
    -0.52135372f, 0.07411512f, -0.06604091f, -0.01560215f, -0.09892196f, -0.06002347f, -0.06582085f, 0.02349650f, 
    0.07250048f, 0.00462791f, 0.01904289f, 0.02420892f, 0.03969262f, -0.02737940f, -0.01114020f, 0.07393452f, 
    -0.05660500f, 0.08511054f, -0.03459313f, 0.05224161f, -0.09864108f, 0.06548968f, -0.04729268f, -0.02392723f, 
    -0.02473631f, 0.24909130f, -0.17784229f, -0.15069279f, 0.00935644f, 0.05620163f, 0.02792963f, 0.11687776f, 
    -0.01084266f, -0.01253340f, -0.12224320f, 0.06081270f, -0.53223139f, 0.25522521f, 0.21210079f, 0.21199615f, 
    0.13223936f, 0.07954652f, 0.02536141f, -0.04436752f, -0.06723420f, 0.02865607f, -0.11501040f, -0.09926446f, 
    -0.16269447f, 0.11444581f, 0.03626892f, -0.18928038f, 0.03039162f, -0.07694060f, 0.01709848f, 0.05993060f, 
    -0.03703243f, -0.05469717f, -0.09339853f, 0.04646649f, -0.42575368f, -0.01398250f, -0.19171154f, -0.16603310f, 
    -0.06886695f, 0.02326746f, 0.07354414f, -0.06987499f, -0.01179670f, -0.00388558f, -0.01690242f, -0.01699740f, 
    0.15186180f, 0.07631334f, 0.01094510f, 0.06857919f, 0.00803212f, 0.10977893f, 0.05673176f, 0.04462093f, 
    -0.04162240f, 0.03715733f, -0.08041174f, -0.07485112f, -0.34455076f, -0.21729784f, -0.15578414f, 0.22019039f, 
    -0.08838193f, 0.00915508f, 0.01590526f, -0.04391802f, -0.01617367f, -0.05112598f, -0.03656990f, -0.09811957f, 
    -0.21755078f, -0.05345445f, -0.05790912f, -0.08932621f, -0.07088462f, 0.11707313f, -0.00013748f, -0.09211235f, 
    -0.04425411f, -0.06907195f, 0.10254557f, 0.05756987f, 0.20958975f, -0.16446176f, 0.09796027f, 0.01862792f, 
    0.04624454f, 0.04140177f, 0.01499239f, 0.03851672f, 0.09023953f, 0.10640219f, -0.09771526f, 0.03019883f, 
    -0.01904384f, 0.08201022f, -0.20517352f, 0.09774640f, -0.10169149f, -0.04320460f, 0.03204130f, -0.01676406f, 
    0.02289817f, 0.02116159f, 0.06661731f, -0.02226877f, 0.17471944f, -0.24327821f, 0.05027575f, 0.20244768f, 
    -0.11044981f, 0.02911299f, 0.01250745f, 0.02852561f, 0.01640776f, -0.11650507f, 0.09424365f, 0.01605518f, 
    -0.15560767f, 0.02915909f, -0.05450777f, 0.06261753f, -0.00969052f, -0.00378525f, -0.00817344f, -0.03882726f, 
    -0.00493273f, -0.00350706f, -0.10439151f, 0.12785980f, -0.48510379f, 0.27280346f, 0.07455889f, 0.18811263f, 
    0.05703014f, 0.10155636f, -0.02276363f, 0.01013465f, -0.06531993f, 0.09023906f, 0.00777184f, -0.00582009f, 
    -0.03170802f, 0.00708741f, -0.00263285f, 0.25841039f, 0.06168637f, 0.13569345f, 0.01849408f, -0.11706442f, 
    -0.02881100f, 0.06615194f, -0.06168546f, -0.09824347f, 0.03295145f, 0.01595070f, 0.01913759f, -0.12393408f, 
    -0.04355745f, 0.04735175f, 0.01424843f, 0.03426577f, 0.03934714f, -0.07580410f, 0.00178663f, 0.02943011f, 
    0.12918957f, 0.15702778f, 0.06902826f, 0.02748548f, -0.00138450f, 0.00631489f, 0.00299308f, -0.03205024f, 
    0.04527032f, 0.04472209f, 0.04419305f, -0.03312520f, -0.37742412f, -0.24837646f, -0.07997098f, -0.17768605f, 
    0.05388449f, 0.08614570f, -0.03396095f, 0.05265890f, -0.00083811f, -0.00534766f, 0.07877883f, 0.01031925f, 
    0.33131006f, -0.20308506f, 0.06061717f, 0.03612549f, -0.07680391f, 0.11385830f, 0.07132237f, -0.00587106f, 
    0.04139095f, -0.06808338f, -0.16808592f, 0.07662769f, -0.32548463f, 0.09898210f, -0.03090897f, -0.17327143f, 
    -0.12295736f, -0.09544778f, -0.02203613f, -0.00747885f, 0.03421644f, -0.11658046f, -0.09422357f, -0.01014888f, 
    0.01329458f, 0.01923055f, 0.07712304f, 0.05029343f, -0.17818069f, 0.04302657f, -0.02639659f, 0.02339884f, 
    -0.01179390f, -0.02608965f, 0.00955210f, 0.03930873f, 0.25389525f, 0.02191897f, 0.03205353f, 0.18904081f, 
    0.07326443f, 0.05914825f, -0.11390971f, -0.00468575f, 0.03820224f, -0.09465650f, 0.00128816f, -0.04450292f, 
    -0.06156360f, -0.16534603f, -0.04123422f, -0.01235361f, -0.09038435f, 0.04710854f, 0.00135181f, -0.04214358f, 
    -0.08583333f, -0.06016407f, -0.01044167f, 0.04232996f, -0.09256282f, 0.04689858f, -0.11446272f, -0.11750031f, 
    -0.02579656f, -0.01742838f, 0.03342362f, -0.01860922f, -0.01819446f, -0.09272335f, 0.00620946f, 0.03866592f, 
    -0.07059619f, -0.23938726f, -0.29741812f, -0.01247355f, 0.00557577f, -0.08531072f, 0.01062044f, -0.02278916f, 
    0.08404218f, 0.03090108f, -0.11661600f, 0.10182210f, 0.20605581f, -0.07766553f, -0.02266380f, -0.00986655f, 
    -0.04806143f, 0.00907092f, 0.00260788f, 0.05019051f, 0.06691603f, 0.02751427f, 0.01338848f, 0.00724914f, 
    0.02013114f, 0.09786288f, 0.02371307f, -0.01136443f, -0.03175137f, 0.00743455f, -0.02841292f, 0.07165913f, 
    -0.00871867f, 0.05360388f, 0.04223057f, 0.05097601f, 0.08040003f, -0.10158611f, -0.02677796f, -0.06329182f, 
    -0.03346169f, -0.00233545f, -0.04417509f, 0.05715280f, 0.04773558f, -0.06435976f, 0.06186338f, 0.01353659f, 
    -0.05073640f, -0.06777313f, -0.00652629f, -0.07084755f, -0.13188827f, 0.05846065f, -0.09435795f, -0.02053788f, 
    0.05340881f, -0.00647403f, -0.08201925f, 0.10088575f, -0.16354057f, 0.08702561f, -0.03138607f, -0.00297943f, 
    -0.04098251f, 0.01361060f, 0.04840858f, -0.01157505f, -0.09519789f, 0.09612776f, 0.01331131f, -0.09196357f, 
    0.15439689f, -0.04345516f, -0.02641152f, -0.06193126f, -0.13757260f, -0.13599105f, -0.00122586f, 0.00055825f, 
    -0.00745315f, 0.05017493f, 0.01399977f, -0.00511579f, -0.08239974f, 0.01275708f, 0.14296086f, 0.10887381f, 
    0.05868490f, -0.04480091f, -0.14246540f, -0.08062485f, 0.06773719f, 0.10041552f, 0.07814890f, -0.00735987f, 
    -0.07001410f, -0.09588394f, -0.06152857f, 0.15601911f, 0.05643146f, 0.04370540f, 0.04284003f, -0.08834367f, 
    0.03344764f, -0.00241209f, -0.00129498f, -0.05184030f, -0.06014901f, -0.02359984f, 0.08321723f, -0.01203372f, 
    -0.03533536f, -0.07726321f, 0.08738029f, -0.02768059f, 0.00187106f, 0.15647587f, -0.01067495f, 0.07215482f, 
    0.04553202f, 0.12843017f, -0.03874835f, -0.08076479f, -0.10507320f, 0.00485896f, -0.10444170f, 0.03987513f, 
    0.06921913f, -0.00322712f, -0.05659800f, 0.10394807f, 0.06478311f, 0.09509975f, 0.10428195f, -0.10257892f, 
    0.01500404f, -0.06662412f, -0.08042088f, 0.03152154f, -0.02166140f, -0.05540269f, -0.01517030f, -0.02201307f, 
    0.19598202f, -0.00215700f, 0.08232670f, 0.04706268f, -0.08804227f, -0.05168089f, -0.02375208f, -0.06267036f, 
    -0.00646193f, 0.04973940f, -0.10994098f, -0.03300362f, 0.06881357f, 0.03109640f, -0.10647392f, 0.07267829f, 
    0.06684364f, 0.02675949f, 0.02191632f, -0.10039240f, -0.04770962f, -0.11543495f, 0.02835607f, -0.04231993f, 
    0.16526161f, -0.06967743f, 0.04446315f, 0.11407121f, -0.01961707f, 0.00463044f, 0.02519498f, 0.08506235f, 
    -0.05105181f, 0.00628240f, 0.07111006f, -0.12373421f, 0.13584733f, 0.01650511f, 0.17524251f, 0.12622677f, 
    0.09211498f, 0.02929288f, -0.06952683f, 0.00853489f, 0.11264764f, 0.02124741f, -0.07661208f, -0.07540698f, 
    0.00928184f, 0.15121566f, 0.12317834f, 0.01980976f, -0.10801734f, 0.01791495f, 0.10030591f, 0.04982379f, 
    0.01610003f, -0.06787554f, 0.00069061f, 0.09353440f, 0.57484549f, 0.11574820f, -0.04659146f, 0.20097704f, 
    0.14155763f, -0.07302735f, -0.02877583f, 0.18254721f, -0.06211620f, 0.04290029f, -0.15378007f, -0.05192989f, 
    -0.11410605f, 0.05511636f, 0.01461842f, 0.18173702f, -0.01035040f, 0.03056013f, 0.09975510f, 0.03636214f, 
    -0.08950207f, -0.01675002f, -0.07833985f, 0.02366067f, -0.17654833f, 0.10588396f, -0.04396820f, -0.06102958f, 
    -0.02631401f, 0.03749783f, 0.14318535f, 0.10330838f, -0.04597606f, -0.04333087f, 0.03395319f, -0.01150041f, 
    -0.20563610f, -0.16703095f, 0.04131845f, 0.00911442f, -0.08000707f, 0.04501619f, 0.03802027f, 0.04825477f, 
    0.02708035f, -0.08408868f, 0.02543815f, 0.11692495f, -0.20357899f, -0.21886334f, 0.12090398f, 0.09727513f, 
    -0.16043492f, -0.12553206f, 0.03693756f, -0.17879070f, 0.15431990f, 0.04729172f, 0.00794268f, -0.11913738f, 
    -0.09374348f, 0.02425253f, 0.01189530f, 0.00283144f, -0.15568113f, 0.04718241f, -0.02779369f, -0.01747622f, 
    0.06023298f, -0.05111897f, 0.03275807f, -0.06696828f, 0.24435523f, -0.16027078f, -0.21917801f, 0.25606796f, 
    -0.04553343f, 0.09413642f, 0.08862185f, -0.10317879f, -0.02519491f, -0.06060278f, 0.04159650f, 0.02330679f, 
    0.05900626f, -0.02747573f, -0.10232750f, -0.00434870f, -0.04185260f, -0.05313451f, 0.05621380f, 0.00277809f, 
    -0.08777283f, -0.12219766f, 0.10261002f, -0.04247539f, -0.05408691f, -0.02952981f, -0.00824395f, 0.28740475f, 
    0.11543424f, -0.03202806f, -0.04017698f, 0.09681989f, 0.04936269f, 0.07091738f, 0.05720006f, 0.00282437f, 
    -0.18253061f, -0.10602797f, 0.06361616f, -0.04769534f, 0.13273740f, 0.02058775f, -0.06410343f, -0.03924887f, 
    0.04059355f, -0.08677267f, 0.04819054f, 0.05013218f, 0.26741239f, -0.01458233f, 0.00162925f, -0.03999898f, 
    -0.08393934f, 0.00333741f, 0.02186615f, -0.05901336f, 0.09658936f, -0.00380692f, -0.08426879f, -0.18712203f, 
    0.16805142f, 0.07722373f, -0.02631242f, -0.12882228f, -0.02274268f, -0.01896625f, -0.07102569f, 0.00458732f, 
    -0.02613313f, -0.07321925f, 0.00301675f, -0.02349612f, 0.11902728f, 0.03740770f, 0.09638101f, -0.07688019f, 
    -0.02396845f, -0.05772879f, 0.02825641f, 0.03258812f, 0.05855489f, 0.00550673f, -0.10449540f, -0.12136568f, 
    -0.64537418f, 0.08533442f, 0.02361491f, 0.06277829f, 0.09117630f, 0.00436944f, 0.06033471f, 0.06353875f, 
    -0.01812373f, -0.14165421f, 0.04243365f, 0.04976759f, -0.42476481f, 0.15822414f, -0.04238893f, -0.23226750f, 
    0.11224014f, 0.07345961f, -0.07753427f, -0.04574238f, 0.00831619f, 0.03720792f, 0.03109672f, 0.01514219f, 
    -0.23697798f, 0.09074785f, -0.15122899f, -0.05108980f, 0.01434960f, -0.04158243f, 0.02565582f, 0.15665905f, 
    -0.03516832f, -0.01026697f, -0.07100461f, -0.08974674f, -0.24442336f, 0.01817651f, -0.03647184f, 0.08537138f, 
    -0.05100443f, -0.01976927f, -0.05169379f, 0.07244649f, -0.00998233f, -0.02122906f, 0.12400892f, 0.02873810f, 
    0.00682077f, 0.08600454f, 0.18684202f, 0.10319747f, 0.08358610f, 0.08177945f, -0.05855957f, -0.03869213f, 
    0.07880317f, -0.00363029f, -0.08888759f, 0.10889758f, 0.07163646f, 0.24771112f, 0.09550686f, -0.18564905f, 
    -0.06287611f, 0.04770586f, -0.01588129f, 0.00720881f, 0.08036429f, -0.12323884f, 0.03738492f, 0.07135975f, 
    0.10045725f, 0.29802197f, 0.04729839f, 0.03745159f, -0.11657305f, 0.05874900f, 0.04659048f, -0.00124199f, 
    0.00674092f, -0.10306383f, 0.06230234f, 0.01042585f, -0.05413828f, 0.13847762f, 0.23380494f, 0.20463850f, 
    -0.12758216f, 0.01123870f, -0.03340902f, 0.03986395f, 0.20610206f, -0.05118012f, -0.09768415f, 0.02080213f, 
    -0.13854253f, -0.19820634f, 0.02514838f, 0.07409110f, -0.11336517f, 0.15109962f, 0.09828866f, 0.04315117f, 
    0.09264942f, -0.00532599f, -0.12013603f, 0.00970718f, -0.13951509f, 0.15560144f, -0.06560402f, -0.05322750f, 
    -0.12101736f, -0.02727101f, 0.04248422f, -0.08379481f, 0.01520204f, -0.03437697f, 0.12227959f, 0.04219659f, 
    -0.43947038f, 0.00353362f, 0.06329095f, -0.25720033f, 0.02828855f, 0.12234589f, -0.12726097f, 0.06839471f, 
    0.04927244f, 0.06452532f, -0.06479520f, -0.06277253f, -0.10787864f, -0.08788566f, -0.03574875f, 0.04904820f, 
    -0.08878299f, 0.02029095f, 0.02302693f, 0.02269406f, -0.04199109f, 0.00324352f, -0.05591325f, -0.08765124f, 
    0.15692048f, -0.01313108f, 0.06742348f, -0.03049490f, 0.10802677f, -0.01893263f, -0.13004078f, 0.04358780f, 
    -0.02383649f, -0.02645206f, 0.01431225f, -0.06152447f, -0.38094679f, -0.09886817f, 0.13127449f, -0.01273128f, 
    0.01074954f, 0.05035641f, 0.03040152f, 0.04720207f, 0.02328062f, -0.03126241f, -0.09676736f, -0.05457507f, 
    -0.35355112f, 0.03962262f, -0.10352786f, -0.24215616f, -0.00400335f, -0.00337646f, 0.12550204f, 0.04960292f, 
    -0.01677520f, 0.01063365f, 0.00920603f, 0.07214625f, -0.18344364f, 0.01065428f, -0.07075628f, 0.15729192f, 
    -0.05938959f, 0.01618215f, 0.17185624f, 0.03829827f, 0.03287461f, 0.05557775f, 0.02882153f, 0.02564154f, 
    -0.15199833f, -0.03783838f, 0.19935335f, 0.10908873f, 0.03700663f, 0.08534372f, -0.06536880f, 0.02598615f, 
    0.17500819f, -0.22249797f, -0.11816292f, 0.13627380f, -0.09496532f, -0.14856647f, -0.01954334f, 0.09507020f, 
    -0.05695434f, -0.03408428f, -0.06090910f, -0.07368796f, -0.02394338f, 0.08276834f, -0.11455802f, -0.20841964f, 
    -0.22891073f, 0.03355524f, -0.18066764f, -0.04452734f, -0.01870918f, -0.05142925f, 0.08345234f, -0.07129163f, 
    0.07662376f, -0.05082747f, 0.01522313f, -0.05607671f, -0.44821671f, -0.02139210f, -0.01956371f, 0.00701220f, 
    0.06746590f, -0.07366975f, 0.16051470f, 0.00398730f, -0.13391003f, -0.00518332f, -0.04087523f, 0.09342115f, 
    0.40434602f, -0.33743420f, -0.18833147f, 0.12491482f, 0.01662183f, 0.09112272f, 0.02272212f, -0.01344983f, 
    -0.02356552f, 0.04368461f, -0.10458545f, -0.01742898f, 0.20159289f, 0.10679017f, -0.08077888f, -0.02061175f, 
    0.02502031f, 0.06590090f, 0.12167571f, -0.00769957f, -0.14241730f, -0.01600064f, 0.12446360f, -0.01853312f, 
    -0.34350082f, -0.09889118f, 0.14818977f, 0.08449222f, 0.07853577f, -0.20106363f, 0.01205252f, -0.05336668f, 
    0.00940262f, 0.02424051f, -0.08469497f, -0.08848541f, -0.49030074f, 0.09356163f, 0.05172458f, -0.10100029f, 
    0.08119573f, -0.04014122f, -0.06893507f, 0.01416061f, 0.05370496f, 0.09373000f, 0.07471828f, -0.06534891f, 
    -0.10755491f, 0.05662689f, -0.29766753f, -0.14806662f, 0.12951516f, -0.08165180f, 0.13801123f, -0.03588131f, 
    0.10656776f, -0.10753574f, 0.12370843f, -0.05886582f, -0.28226101f, 0.02864978f, 0.06913878f, 0.06668597f, 
    -0.04413599f, 0.12017871f, 0.00058082f, 0.01853083f, 0.00820153f, 0.01672573f, 0.03025667f, 0.01054058f, 
    0.03417195f, 0.16416094f, -0.14823075f, 0.09646855f, 0.05210863f, 0.05546327f, 0.04324985f, -0.03725975f, 
    -0.02708250f, -0.03383054f, -0.02391764f, -0.06086239f, -0.15290628f, 0.04934553f, 0.02159753f, 0.11579780f, 
    -0.01075473f, 0.03017167f, 0.04938706f, 0.10305271f, 0.03396820f, 0.01826531f, 0.10266834f, 0.01686435f, 
    -0.07482086f, 0.11001199f, -0.15103349f, -0.06404962f, 0.01232498f, -0.11329973f, 0.05201551f, 0.16761550f, 
    -0.02514366f, -0.01228364f, -0.03297646f, -0.01355260f, -0.23533772f, -0.13415641f, 0.17421456f, 0.19361782f, 
    -0.03544438f, -0.02461771f, 0.14791219f, 0.03710610f, -0.14757326f, 0.09039158f, 0.07022659f, 0.05120917f, 
    -0.37993467f, 0.22706819f, -0.16437179f, -0.27837083f, -0.00000594f, -0.13599253f, -0.02612838f, 0.10138470f, 
    0.02266237f, -0.04690956f, 0.03131156f, -0.04537250f, -0.11390359f, -0.06258509f, 0.12205198f, 0.15363759f, 
    0.03821972f, 0.07860964f, -0.10579909f, -0.01460739f, 0.02249269f, -0.03271816f, -0.28522664f, 0.05695837f, 
    -0.27042088f, 0.04222477f, 0.15466857f, 0.16103499f, -0.03126871f, -0.00184790f, 0.06068128f, -0.04647782f, 
    0.06872547f, 0.00585242f, 0.06258829f, -0.00289643f, -0.21576831f, 0.09223877f, -0.00054134f, 0.17205916f, 
    0.02447800f, -0.06075373f, 0.17097110f, -0.02878068f, 0.05206886f, 0.08341267f, 0.05172526f, -0.02005192f, 
    0.05402041f, -0.14467955f, 0.08687545f, 0.08807969f, -0.06837165f, -0.00782830f, 0.00568682f, -0.00871454f, 
    -0.09161191f, 0.12476676f, 0.03735962f, 0.05061608f, 0.10201734f, 0.04705848f, -0.11875277f, 0.09500825f, 
    -0.12527236f, -0.00850148f, -0.08230092f, -0.02154730f, -0.10230808f, -0.11838400f, -0.01273691f, -0.07421400f, 
    0.08318039f, 0.07644842f, 0.19484930f, -0.22918402f, -0.01151591f, 0.02942379f, 0.05537315f, -0.02120684f, 
    0.00282574f, 0.02410728f, -0.02639705f, 0.13240679f, -0.18948101f, -0.02468158f, -0.05355217f, 0.11335316f, 
    0.03875320f, 0.05905482f, -0.07893002f, 0.01245743f, 0.05267077f, -0.08141013f, 0.11303212f, 0.10513482f, 
    -0.04698422f, -0.00221737f, -0.05222237f, 0.06968613f, 0.08821347f, -0.10845016f, 0.05408671f, 0.05965785f, 
    0.03211951f, 0.05724900f, -0.00604103f, 0.02443552f, 0.01368984f, -0.06636991f, -0.05470026f, 0.13066225f, 
    -0.04516149f, 0.04392471f, 0.04745825f, -0.05607953f, 0.07735291f, 0.02470315f, 0.10073723f, -0.03314686f, 
    -0.20228240f, 0.30508539f, 0.00386254f, 0.02278787f, 0.02805150f, -0.05504803f, -0.09572688f, 0.08580069f, 
    0.06280337f, -0.07558662f, 0.02973126f, -0.03387076f, 0.03270138f, 0.31128773f, -0.12207645f, -0.17102727f, 
    0.08776487f, -0.07187824f, 0.00189644f, 0.21341464f, -0.01794290f, 0.02319808f, -0.00837547f, 0.07416568f, 
    -0.27124733f, -0.18858419f, -0.07325343f, 0.09420550f, -0.07659516f, -0.07105406f, -0.15981928f, -0.05325279f, 
    0.05136982f, -0.04100053f, -0.10274585f, -0.16531962f, 0.08425801f, 0.01007127f, -0.07195564f, -0.02094138f, 
    0.02344231f, 0.13056827f, 0.13571613f, 0.05916457f, 0.06153078f, -0.03427066f, -0.00306132f, -0.05098876f, 
    0.17780675f, -0.01849192f, 0.03236800f, -0.03297033f, -0.06685462f, 0.05861266f, 0.08529776f, 0.11424281f, 
    -0.02351577f, -0.13053837f, 0.06529402f, 0.02561483f, 0.14237545f, -0.19827408f, 0.05286086f, -0.17938298f, 
    0.06533547f, 0.06029790f, -0.01268837f, 0.07822029f, 0.00696131f, 0.06697939f, 0.01150819f, 0.03978084f, 
    0.12822171f, 0.09046996f, -0.18026610f, 0.07627993f, -0.07232506f, 0.01367168f, 0.03678347f, 0.04047109f, 
    -0.03489674f, 0.05981977f, 0.00949608f, -0.01206211f, 0.15831465f, 0.07166014f, -0.17264307f, -0.03875194f, 
    -0.01144851f, 0.02905501f, 0.14088200f, 0.00202885f, -0.06409331f, -0.20181425f, -0.07650523f, 0.01809973f, 
    0.06604537f, -0.01851219f, -0.07576837f, -0.27363315f, 0.03314712f, 0.00968269f, 0.00680392f, 0.03774009f, 
    -0.00417772f, -0.06666288f, 0.10498954f, 0.08885965f, -0.05482444f, 0.02604762f, 0.11080317f, 0.10744131f, 
    -0.08759715f, -0.02484170f, -0.07652958f, 0.03256707f, -0.00549019f, -0.04409648f, 0.06593323f, 0.02866343f, 
    0.00459416f, -0.11303562f, 0.00233980f, 0.20900817f, -0.08361626f, 0.04990685f, 0.06067591f, 0.16029054f, 
    0.00045573f, 0.04090948f, 0.05873607f, 0.00771607f, 0.00633773f, 0.12684503f, -0.11774619f, -0.19239566f, 
    0.02163906f, -0.00419815f, -0.02977661f, 0.06592154f, 0.04896359f, -0.11240546f, 0.03377809f, -0.03366299f, 
    -0.03515036f, 0.06088751f, 0.23553924f, -0.24757692f, -0.16894473f, -0.06135117f, 0.05397379f, 0.05727962f, 
    0.05978103f, 0.01360620f, 0.02191290f, -0.09550953f, -0.36577410f, -0.04465653f, 0.05641221f, -0.06145685f, 
    -0.06233117f, -0.07668474f, 0.06841707f, 0.05845470f, -0.03022472f, 0.12449814f, -0.09968033f, 0.08061001f, 
    0.06211210f, -0.05900622f, -0.02153214f, 0.02878156f, -0.03828472f, -0.05894408f, -0.00118160f, 0.11400164f, 
    -0.02034804f, -0.11552634f, 0.06057601f, -0.04169516f, 0.08397009f, 0.09933402f, 0.08855382f, 0.10010048f, 
    -0.05816051f, 0.03353427f, -0.08195399f, 0.11622858f, -0.12990242f, -0.01240967f, 0.06118155f, 0.02080683f, 
    0.01160178f, 0.11058731f, -0.09248860f, 0.02460513f, 0.07309448f, -0.00638608f, 0.06026319f, -0.00109487f, 
    -0.01118822f, -0.08277623f, 0.01872913f, 0.08262279f, 0.07421174f, 0.29245222f, 0.17274687f, -0.04684097f, 
    0.09697127f, 0.07375939f, -0.06948713f, 0.08503544f, -0.07140311f, 0.00828329f, -0.02927561f, -0.23810413f, 
    0.07675413f, -0.02120223f, -0.03209086f, -0.09143227f, 0.05732271f, -0.03696327f, 0.22342920f, -0.06438183f, 
    0.06892841f, -0.04153691f, -0.07866296f, 0.14697489f, -0.16789730f, -0.07529460f, -0.16354820f, 0.05409371f, 
    0.10479718f, 0.15034138f, -0.01388842f, -0.14270964f, 0.05418900f, 0.03195461f, -0.02108829f, -0.02378648f, 
    0.08482590f, 0.00574037f, 0.13259487f, 0.26186344f, -0.02181259f, -0.06900274f, 0.03986067f, 0.01038451f, 
    -0.07544862f, -0.07048224f, 0.04181657f, -0.06194094f, -0.11663118f, -0.01675043f, 0.12724970f, -0.12204105f, 
    0.13369399f, 0.00027954f, 0.08713847f, -0.12155574f, 0.04259148f, 0.02563021f, 0.08783956f, 0.08574311f, 
    -0.09098163f, -0.16330789f, -0.02017700f, 0.08666989f, 0.04776512f, -0.03966418f, -0.07587726f, 0.12542135f, 
    -0.16333304f, 0.00509339f, 0.05108241f, -0.07352009f, 0.09920054f, -0.15205173f, 0.05801295f, 0.09280805f, 
    0.06288127f, 0.08656856f, -0.07794501f, 0.04038624f, -0.01846923f, 0.10155243f, 0.10218921f, -0.07099632f, 
    -0.38151264f, -0.12373293f, -0.49037629f, -0.12364420f, 0.17736374f, 0.13440421f, 0.08577704f, 0.06599055f, 
    0.04595196f, 0.08412018f, -0.05567137f, -0.05570598f, -0.18554191f, -0.10077239f, 0.12152171f, 0.22297069f, 
    -0.16690345f, 0.05447484f, 0.12153539f, 0.07612385f, 0.11195918f, -0.00286046f, -0.15745735f, 0.00425041f, 
    -0.02042187f, 0.03469045f, 0.13727809f, -0.15152739f, 0.09459696f, -0.09385310f, -0.05103092f, -0.00051615f, 
    -0.03393677f, 0.08771222f, -0.05985191f, 0.08273759f, 0.19157955f, -0.04870114f, -0.01856534f, -0.15419284f, 
    0.07327724f, -0.11564294f, -0.08565310f, -0.17401108f, -0.26411644f, 0.01555648f, 0.05406431f, -0.08370439f, 
    0.03228910f, -0.11939334f, -0.17210710f, 0.04810277f, -0.01857896f, 0.02669959f, -0.02346586f, 0.09243493f, 
    0.03156334f, -0.05312700f, -0.08929460f, -0.04736522f, -0.19331031f, -0.11859208f, 0.21425861f, -0.07191660f, 
    0.04969953f, -0.09923299f, 0.00881659f, -0.06130205f, 0.11219068f, 0.20049833f, -0.04814311f, 0.13115145f, 
    -0.11031705f, 0.00857816f, -0.04346280f, 0.00941021f, 0.00651500f, -0.00175125f, 0.02640899f, -0.15351792f, 
    -0.01352183f, -0.06131668f, 0.01450073f, 0.14955887f, 0.07586497f, -0.10323361f, -0.02732568f, 0.08221521f, 
    -0.00229932f, -0.04281879f, 0.00906965f, 0.00626757f, -0.09213381f, 0.10764281f, 0.09256771f, -0.00966493f, 
    0.09943146f, 0.04200990f, 0.02519469f, -0.06541043f, 0.05902709f, 0.08918022f, -0.10674540f, 0.13363142f, 
    -0.01506998f, 0.09682512f, 0.07112657f, 0.04969065f, -0.27997881f, 0.09170210f, -0.05677897f, -0.06430165f, 
    0.00250813f, 0.02567350f, 0.09147729f, -0.02062955f, 0.10628051f, -0.03071405f, -0.14617701f, 0.02559055f, 
    0.00379774f, -0.02152262f, -0.10795657f, 0.11385410f, 0.09897387f, -0.01079441f, -0.05252267f, 0.07161457f, 
    -0.02641946f, -0.16355725f, 0.01019436f, -0.17067125f, -0.17137651f, -0.01218151f, -0.04185353f, 0.09515896f, 
    0.09174994f, 0.05472567f, -0.01338825f, 0.12151303f, 0.10383483f, -0.16979977f, 0.00495166f, -0.01904415f, 
    0.07080454f, 0.01025146f, -0.08915851f, 0.10658398f, 0.02854313f, 0.04955345f, -0.06485748f, 0.03142157f, 
    0.12955530f, -0.04944755f, -0.02803132f, -0.02242923f, 0.19811963f, -0.04035633f, 0.05110745f, -0.16244465f, 
    -0.05101451f, -0.06860607f, 0.02867527f, 0.02629568f, -0.03876993f, 0.00252376f, 0.12164963f, 0.10187910f, 
    -0.33902168f, -0.03786605f, 0.13697213f, -0.06684991f, 0.05345507f, -0.04031615f, 0.03682398f, 0.15326227f, 
    0.01211274f, 0.07131084f, -0.00587961f, -0.02128649f, -0.16606361f, 0.14124855f, 0.22292784f, -0.15227136f, 
    0.06861814f, -0.13922915f, 0.00927129f, -0.05508689f, 0.06598977f, -0.04864684f, 0.02023221f, -0.07812584f, 
    -0.10685019f, -0.02798593f, -0.08267962f, 0.00983404f, -0.08104043f, -0.02242766f, -0.09389030f, 0.09649117f, 
    -0.06165369f, 0.10456891f, 0.30649245f, 0.10961434f, 0.04181744f, 0.05538872f, -0.03413830f, 0.05462396f, 
    -0.08207715f, 0.11730624f, -0.01949976f, 0.00921409f, -0.03453824f, 0.09037644f, 0.08388562f, 0.20955250f, 
    -0.27847090f, 0.13592590f, 0.10672152f, 0.02402529f, -0.07774702f, -0.07083143f, -0.10988899f, -0.14667019f, 
    0.06538156f, 0.03438012f, -0.10711734f, 0.03835817f, -0.15616234f, 0.10120436f, -0.10307412f, -0.09053642f, 
    0.07287402f, 0.17127410f, -0.02382686f, 0.06562010f, 0.16029835f, -0.15359883f, 0.10015749f, -0.19629635f, 
    -0.17690536f, 0.21164484f, 0.24404165f, -0.27552360f, 0.01936682f, -0.01446556f, -0.07258365f, 0.01170587f, 
    -0.05291890f, -0.04878144f, -0.00784503f, -0.08186983f, -0.11478510f, 0.04314685f, 0.09034788f, 0.09769353f, 
    -0.07840457f, 0.03211048f, 0.04299295f, -0.05566455f, 0.02079649f, 0.01434635f, 0.00312208f, 0.16959159f, 
    0.06612174f, -0.07634843f, -0.20728531f, -0.03217369f, -0.15040416f, 0.05659539f, 0.00331319f, -0.03323074f, 
    0.19138260f, -0.13940178f, 0.01561896f, 0.00525337f, 0.01733448f, 0.05194749f, 0.12055913f, -0.19754912f, 
    0.02636533f, -0.08644846f, 0.02426216f, -0.07555701f, -0.04666078f, -0.15039539f, -0.01606254f, -0.04693967f, 
    -0.13037515f, 0.04531584f, -0.01665347f, -0.20073053f, 0.09718904f, 0.03492556f, -0.06648430f, 0.01566981f, 
    0.06560404f, 0.14450018f, 0.01352026f, 0.08576629f, 0.00126925f, 0.05271161f, -0.20071805f, -0.03531826f, 
    0.16568723f, -0.11486635f, -0.05434211f, -0.06335765f, -0.06873428f, -0.19633409f, -0.05346415f, -0.09500109f, 
    -0.30679733f, -0.07027153f, -0.03944301f, -0.34632891f, -0.05012381f, -0.14377639f, -0.05061958f, -0.07146092f, 
    0.04038278f, -0.10966165f, 0.06514803f, 0.03563802f, 0.29827306f, 0.04684853f, -0.03078659f, -0.05508208f, 
    -0.01989969f, -0.20578451f, -0.02205886f, -0.00686684f, 0.02351623f, -0.03602251f, 0.02350094f, -0.05334238f, 
    -0.01348366f, 0.03464555f, 0.20508315f, 0.00342922f, 0.19565681f, 0.11866946f, 0.02040142f, -0.00093199f, 
    -0.12072226f, -0.03620302f, -0.00540250f, -0.03818585f, -0.03461885f, -0.09346630f, -0.16126254f, -0.08637144f, 
    0.04684600f, 0.09501600f, -0.19133694f, -0.09696676f, 0.09532373f, -0.06930437f, 0.07313822f, 0.05641444f, 
    -0.39011768f, 0.12897463f, 0.15554836f, -0.00579179f, 0.02536815f, 0.08617294f, -0.01830716f, -0.07240303f, 
    -0.03703982f, -0.00005006f, 0.02797509f, 0.01109578f, -0.09015073f, 0.01479482f, -0.00208485f, 0.17283921f, 
    -0.03489520f, -0.12185331f, 0.01789601f, -0.01949132f, 0.05756485f, 0.16592994f, 0.09213097f, 0.01636311f, 
    0.10091081f, 0.04015191f, -0.27049518f, -0.08451229f, 0.05458399f, -0.00210440f, -0.06779906f, -0.05566163f, 
    0.11855737f, 0.09544896f, -0.10135222f, 0.03407498f, -0.26626182f, 0.05045832f, -0.12976408f, -0.10719401f, 
    0.02874304f, 0.09186343f, -0.07950429f, -0.17149447f, 0.07374212f, -0.09419037f, 0.12034786f, -0.14763208f, 
    0.19882160f, -0.00238209f, 0.09189294f, -0.20979519f, 0.00811752f, -0.06961486f, -0.01427725f, -0.07785913f, 
    0.03383129f, -0.02857812f, -0.15041311f, -0.12544157f, -0.23715472f, -0.05051019f, 0.12886663f, 0.23926999f, 
    -0.00952447f, 0.05262874f, 0.02824157f, -0.01895681f, 0.14327690f, 0.05038385f, -0.01862961f, 0.04523157f, 
    -0.14087208f, 0.09708901f, -0.10749523f, 0.09619585f, -0.06050693f, 0.00869092f, 0.01662079f, 0.15885645f, 
    0.11079417f, 0.03217078f, -0.07529652f, -0.14173944f, -0.18092424f, 0.00004520f, -0.26728868f, -0.01021054f, 
    0.11112324f, 0.02902051f, 0.09888703f, -0.22368100f, 0.02517838f, 0.07480454f, -0.25063282f, -0.08739927f, 
    0.04422377f, 0.01248667f, -0.01819945f, -0.13684031f, 0.01540693f, 0.10114088f, -0.08664240f, -0.04707644f, 
    0.18957536f, -0.14079860f, 0.08261397f, 0.06268027f, 0.04215216f, -0.00609358f, 0.10210127f, -0.30529597f, 
    -0.08787752f, -0.01264244f, -0.08399483f, -0.01251331f, -0.07478133f, -0.01105185f, -0.09158935f, -0.09753800f, 
    -0.54821235f, -0.01222450f, -0.15167509f, 0.06684929f, 0.02112490f, 0.02854214f, -0.00820662f, -0.13940519f, 
    0.08410472f, 0.10837884f, 0.10117090f, 0.01810861f, -0.07076419f, -0.17813185f, 0.09691460f, -0.03619414f, 
    -0.04312269f, -0.04487815f, 0.05982180f, -0.00955081f, 0.06478982f, -0.13600065f, -0.03803668f, -0.12894982f, 
    0.16556154f, 0.08145434f, 0.19537151f, 0.12197717f, -0.08925311f, -0.09793093f, 0.02759243f, 0.05355176f, 
    -0.08307415f, 0.00966761f, 0.01057049f, 0.13254584f, -0.13470444f, 0.09808718f, -0.00037614f, 0.04630919f, 
    -0.02195106f, 0.05891166f, 0.02543652f, -0.01822869f, 0.11727118f, -0.11417055f, 0.11492873f, 0.09142017f, 
    -0.10917968f, -0.00327565f, -0.10448129f, 0.16646580f, 0.19862793f, -0.09586435f, -0.05206802f, 0.12905283f, 
    0.00141730f, 0.08883012f, -0.05800628f, -0.03608778f, 0.09358162f, 0.11306836f, -0.00780133f, -0.07743167f, 
    -0.05209193f, -0.01386455f, 0.03136177f, 0.08923788f, 0.12240513f, -0.20906794f, -0.01238626f, -0.00721433f, 
    0.10471176f, -0.03809822f, -0.03704739f, -0.00175770f, 0.11841473f, 0.15301152f, 0.04219225f, 0.07091589f, 
    0.06204363f, 0.04877865f, -0.06914876f, -0.09836614f, -0.01735518f, 0.01254509f, 0.13551559f, -0.36405963f, 
    0.03946463f, -0.05120711f, -0.09376270f, 0.04699413f, 0.02250888f, 0.13381664f, 0.02623352f, 0.03244928f, 
    -0.13654758f, -0.01274825f, 0.13936824f, -0.18387957f, 0.07236429f, -0.00260894f, 0.07764843f, -0.00638558f, 
    0.08904742f, -0.00270725f, -0.26119587f, 0.13939619f, 0.12908091f, 0.05657624f, 0.05076787f, 0.11646985f, 
    -0.03072558f, 0.01575111f, -0.01508470f, -0.04154452f, -0.10786897f, -0.02552711f, 0.20043503f, 0.15204997f, 
    0.14081801f, -0.00417305f, 0.15586627f, 0.13742886f, -0.07685118f, -0.27443415f, -0.10896250f, -0.00142231f, 
    0.06142570f, 0.13149065f, -0.04212302f, 0.08355118f, -0.39295962f, -0.19509722f, 0.18731374f, 0.20236513f, 
    -0.10036370f, -0.00715359f, 0.00081340f, -0.11611649f, -0.23107952f, -0.07367180f, -0.14261642f, 0.18536104f, 
    -0.00417223f, 0.01519759f, -0.03557327f, -0.15639852f, -0.04139957f, 0.07814173f, -0.00962958f, 0.07712612f, 
    -0.10129506f, -0.07352621f, 0.04168232f, 0.07889570f, 0.00976688f, 0.00011132f, -0.00378682f, -0.20348898f, 
    0.06106786f, 0.07241718f, -0.06828114f, -0.12685642f, -0.05889114f, -0.05009966f, -0.00355129f, -0.01841982f, 
    -0.01315604f, -0.00078781f, -0.09410093f, 0.04616095f, 0.05480113f, 0.06463972f, 0.01102802f, -0.03107158f, 
    -0.00745570f, 0.03914246f, -0.07328658f, -0.02353826f, -0.20699155f, 0.13375570f, 0.06261039f, 0.09627353f, 
    0.07570452f, -0.07409296f, 0.00507375f, 0.11610054f, 0.01980043f, -0.03386379f, -0.05578981f, -0.06956864f, 
    -0.29664651f, 0.04394592f, 0.03856856f, 0.10337042f, 0.03951875f, 0.00237780f, -0.00685055f, 0.00749156f, 
    0.12771237f, 0.02352118f, -0.16176042f, -0.07097106f, -0.14210232f, -0.13783318f, 0.05366209f, -0.21822220f, 
    -0.04237103f, -0.01931490f, 0.10388514f, 0.05512891f, 0.00072463f, -0.09663139f, 0.11820149f, 0.12033486f, 
    -0.16110426f, -0.08656844f, 0.01595561f, 0.01603540f, -0.00361934f, 0.00969566f, -0.03245077f, 0.06779198f, 
    -0.05432374f, 0.02852153f, 0.00404111f, -0.12174113f, -0.33304849f, -0.01905780f, -0.12857760f, -0.42085516f, 
    -0.11717440f, -0.05936726f, -0.02368329f, -0.07824199f, -0.00435353f, 0.02046957f, -0.06378379f, -0.08875118f, 
    0.09572122f, -0.02952933f, -0.02047572f, -0.24775895f, 0.00220331f, -0.00391681f, 0.03792660f, 0.09077623f, 
    0.04328773f, -0.00139222f, 0.03849202f, -0.09399450f, 0.04570999f, 0.14068429f, 0.19691858f, -0.18927290f, 
    -0.03387320f, -0.04541374f, -0.02973717f, 0.11781709f, -0.14533710f, 0.09343158f, -0.06503260f, -0.03527939f, 
    -0.14964277f, -0.00408886f, 0.03852608f, -0.05330640f, 0.01392708f, -0.05327121f, 0.04371771f, 0.00660659f, 
    0.18393913f, -0.06202025f, 0.10529068f, 0.10130558f, -0.11503605f, 0.08192355f, 0.09058160f, -0.02974347f, 
    0.05556044f, -0.01902199f, 0.13697992f, 0.07055001f, 0.01280892f, 0.09479818f, -0.00664571f, 0.08003175f, 
    0.18753918f, -0.17062783f, -0.03604670f, -0.18576095f, -0.01846593f, 0.01441152f, 0.01691153f, -0.21759397f, 
    -0.06103711f, -0.04069656f, 0.17017844f, 0.12195915f, 0.07649327f, -0.05552730f, 0.02670290f, 0.21090883f, 
    -0.03467816f, -0.01862378f, -0.16540021f, -0.16088349f, -0.08396160f, -0.04160791f, 0.12460332f, -0.06525004f, 
    0.17488129f, -0.11889925f, 0.07962537f, -0.02754132f, -0.08651894f, -0.05124454f, 0.14499943f, 0.06836985f, 
    0.04106360f, 0.08753933f, 0.09609062f, -0.01084385f, -0.21091869f, 0.07463735f, 0.05210100f, 0.23647264f, 
    0.11043993f, 0.21405247f, 0.11539332f, -0.06070969f, 0.17698540f, 0.09481639f, -0.06874461f, 0.02696913f, 
    0.21874763f, 0.08356021f, 0.12692134f, -0.59832162f, -0.08927879f, 0.04581052f, 0.00752245f, -0.00923061f, 
    0.02953042f, 0.06753982f, 0.02022318f, 0.12469070f, -0.08091382f, 0.06810774f, 0.01329252f, 0.32814598f, 
    0.15715924f, 0.03998478f, -0.12183522f, -0.00616041f, 0.02588177f, -0.09492368f, 0.01301619f, -0.11533618f, 
    -0.23541610f, 0.15453550f, 0.05919283f, -0.04787473f, -0.05481903f, 0.03694060f, 0.01471627f, -0.00127076f, 
    0.08660711f, -0.04241573f, -0.00478999f, -0.14690533f, -0.07263961f, 0.03772935f, 0.06341449f, -0.10796500f, 
    0.11876744f, -0.05675871f, -0.10703614f, 0.00826876f, -0.09895723f, -0.04516436f, 0.04921252f, -0.09892572f, 
    0.15058249f, 0.14583968f, 0.06724220f, -0.38739985f, -0.04603880f, -0.04103870f, 0.03691798f, 0.00268881f, 
    0.02411993f, 0.02600211f, 0.00175441f, -0.09961825f, -0.01599186f, -0.24416433f, -0.01554243f, 0.14916712f, 
    0.06411020f, -0.06478796f, 0.03453954f, 0.01348912f, -0.08448797f, 0.01187745f, 0.05575690f, 0.07731394f, 
    0.02914427f, 0.03755797f, 0.25499088f, 0.01494913f, 0.05335497f, 0.00327380f, 0.00379172f, -0.04696387f, 
    -0.02484121f, 0.07124485f, -0.04164555f, 0.01458271f, 0.02740577f, -0.11136183f, -0.25151986f, 0.36282855f, 
    -0.08860656f, 0.08878236f, -0.01835522f, -0.00059456f, -0.07635488f, 0.03322087f, -0.05105240f, 0.00063673f, 
    0.20386611f, 0.10775941f, 0.10045392f, 0.11596262f, -0.15006901f, 0.06958707f, -0.07054751f, -0.01270991f, 
    -0.20133536f, 0.00125862f, -0.01536289f, 0.00403436f, 0.20694812f, 0.09845860f, 0.08480869f, 0.05380765f, 
    -0.01429175f, 0.03430700f, 0.03866828f, 0.01724146f, 0.02936048f, -0.02248419f, -0.12674934f, -0.05582581f, 
    0.32867792f, -0.29724905f, 0.13661307f, -0.01346562f, 0.00844738f, 0.05934000f, -0.10352404f, 0.00416727f, 
    0.11751188f, 0.00631749f, -0.07223070f, -0.13404770f, 0.16416471f, -0.34931234f, 0.10614731f, -0.04826552f, 
    -0.13984035f, 0.08812685f, 0.05445160f, 0.13581231f, 0.05315434f, -0.03599972f, -0.05707055f, 0.05865499f, 
    -0.09098719f, -0.00491700f, 0.00998136f, -0.11888751f, 0.15110894f, -0.03603809f, 0.08391207f, -0.09315006f, 
    0.04907759f, 0.02340878f, -0.22559714f, -0.03958988f, 0.15562353f, 0.18033266f, 0.08003949f, -0.24026930f, 
    0.06505130f, 0.06669214f, 0.05909760f, 0.04207510f, 0.09647970f, -0.13872136f, 0.03554122f, -0.22418156f, 
    -0.17374077f, -0.15893647f, 0.06193554f, -0.01199390f, -0.05282959f, -0.01690349f, 0.09886236f, 0.16593167f, 
    -0.04348130f, -0.02416953f, -0.13228576f, -0.02662225f, -0.00533227f, -0.04850643f, -0.08594617f, -0.37768829f, 
    -0.05915996f, -0.00644071f, -0.04177035f, -0.04129621f, -0.02003786f, 0.13400677f, -0.03503475f, 0.26270550f, 
    -0.30006349f, 0.09726547f, -0.00991368f, 0.12749054f, -0.03925941f, 0.01996546f, 0.02562084f, -0.03056686f, 
    0.04728904f, -0.07763121f, -0.00728012f, -0.05451561f, 0.09053648f, -0.05916436f, 0.02410864f, -0.05512635f, 
    0.01153849f, 0.04675353f, -0.03087489f, 0.04499910f, 0.01430404f, -0.04300692f, -0.01223379f, 0.02866537f, 
    -0.23865992f, 0.01561073f, 0.03536352f, 0.19699320f, 0.01606612f, -0.11852390f, -0.04454610f, 0.06740214f, 
    -0.11448176f, -0.01120717f, -0.01346205f, -0.01079729f, 0.47530514f, 0.08206723f, 0.09941582f, 0.13365139f, 
    -0.08272490f, 0.07271641f, -0.02624126f, -0.02095918f, 0.03028887f, 0.00529417f, 0.09431538f, 0.13679348f, 
    0.19052956f, -0.13869467f, -0.08416432f, -0.18993923f, -0.15446280f, 0.10221214f, 0.15487328f, -0.04042152f, 
    0.00152115f, -0.18285064f, -0.07786870f, -0.00396415f, 0.11631823f, -0.28030029f, 0.03015359f, -0.24254824f, 
    -0.06768946f, -0.02069237f, -0.00558480f, -0.08743355f, -0.06680447f, 0.11013300f, 0.12222871f, 0.14214894f, 
    0.20486158f, 0.05808038f, 0.13090731f, -0.16830191f, -0.02036267f, 0.09491687f, 0.06482488f, -0.05493908f, 
    -0.02155444f, 0.03570395f, 0.03974789f, 0.04049120f, -0.11018819f, 0.06937280f, 0.03264447f, 0.13624901f, 
    -0.01359478f, 0.01124946f, -0.01564676f, 0.01087306f, 0.02488095f, 0.02026064f, 0.05440364f, 0.08953323f, 
    -0.06332157f, -0.10394388f, 0.01151566f, -0.02312908f, -0.10715228f, 0.01286148f, -0.04926982f, 0.01783063f, 
    0.02680880f, -0.10744378f, 0.01115745f, 0.02089678f, -0.18075062f, -0.23508283f, -0.27705851f, 0.09814925f, 
    0.03050238f, 0.03765984f, 0.10600933f, -0.00876248f, 0.02380571f, -0.01758248f, 0.04941741f, -0.07743639f, 
    0.50451410f, -0.37482494f, 0.05809079f, 0.00469182f, 0.09628744f, -0.00261897f, 0.04446495f, -0.03678880f, 
    0.09549522f, -0.00863937f, 0.08192974f, -0.06839767f, -0.02417982f, 0.05096009f, -0.01912680f, -0.28880486f, 
    -0.02424018f, 0.05006478f, -0.05489995f, 0.10312206f, -0.06233871f, -0.17343672f, 0.07578110f, -0.07850423f, 
    -0.15310389f, -0.19510275f, -0.21837868f, 0.12541641f, 0.01474617f, -0.01266606f, -0.01112452f, -0.02221640f, 
    0.03573631f, -0.03664046f, 0.03373685f, 0.06346601f, 0.01420023f, -0.27754557f, -0.12221923f, 0.01084412f, 
    -0.09435973f, 0.05751524f, -0.06214867f, 0.01689211f, -0.02868890f, 0.11538398f, -0.08717369f, 0.15957764f, 
    -0.52564836f, 0.22497424f, 0.14658213f, -0.00011153f, -0.10773060f, 0.08621269f, 0.06834290f, 0.08057252f, 
    -0.02435646f, 0.06280356f, 0.13091892f, 0.12227994f, 0.14071241f, -0.00772358f, -0.13470615f, 0.01935359f, 
    0.07100516f, 0.07228608f, -0.04898174f, -0.04624600f, -0.05239316f, -0.11429036f, 0.00865006f, -0.07783917f, 
    -0.04187519f, -0.17719898f, 0.04690079f, 0.03296860f, 0.10669733f, -0.04446368f, 0.06245933f, 0.00699687f, 
    -0.01576438f, -0.01733692f, 0.05608159f, 0.08196418f, -0.00977201f, -0.18517038f, -0.08503801f, -0.21629205f, 
    -0.05848015f, -0.00936364f, -0.08414167f, 0.11882249f, -0.01134204f, 0.03491719f, 0.06286656f, 0.08123597f, 
    -0.06272694f, 0.07057586f, 0.13791610f, -0.07485639f, 0.05669016f, -0.01600737f, -0.00820351f, -0.00250820f, 
    -0.05620411f, 0.01413736f, -0.11567602f, 0.03079937f, -0.27984530f, -0.09961816f, -0.03494946f, -0.17973170f, 
    0.10585874f, -0.00446703f, 0.04124046f, 0.08109524f, -0.13431506f, -0.04818043f, 0.01048160f, 0.05268039f, 
    -0.09000929f, -0.00445352f, 0.05239200f, -0.27387896f, 0.00176490f, -0.02182222f, 0.12695308f, -0.11673482f, 
    -0.12028659f, -0.02588451f, -0.13239124f, -0.10736126f, 0.19481747f, -0.15017496f, -0.03476392f, 0.11703531f, 
    -0.07866486f, 0.04752086f, 0.03004991f, 0.00373609f, -0.01862952f, 0.03475357f, 0.00990870f, 0.10616338f, 
    0.10153785f, 0.04458544f, 0.02965371f, 0.04075139f, -0.02571995f, 0.14540897f, -0.02499017f, -0.03039194f, 
    -0.08931218f, -0.12631811f, -0.00138967f, -0.04834149f, 0.02030419f, -0.10710756f, -0.12318175f, 0.06543754f, 
    0.04534230f, -0.08356366f, -0.07950410f, 0.02265369f, 0.02284876f, 0.08680785f, -0.02774469f, -0.05378713f, 
    -0.09407218f, 0.06804650f, -0.12671451f, 0.15429783f, -0.08128759f, 0.05677898f, 0.06682812f, -0.00749401f, 
    0.02549178f, -0.03362742f, 0.00099289f, 0.02044853f, -0.03465549f, -0.20346791f, 0.07153964f, -0.21685190f, 
    -0.00981619f, -0.07926442f, 0.03619004f, -0.01346765f, 0.05257035f, 0.01155979f, -0.06994008f, -0.01017363f, 
    -0.17041911f, -0.02720162f, -0.01367011f, -0.10291478f, 0.03713967f, -0.14841732f, 0.07202177f, -0.19085017f, 
    -0.06496301f, -0.04828661f, -0.02917895f, 0.00883231f, -0.01742548f, -0.10711844f, -0.01623148f, -0.26741540f, 
    -0.20057811f, 0.12645219f, -0.00820971f, 0.06699533f, 0.09943189f, -0.13915022f, -0.08992038f, -0.09160137f, 
    -0.00311837f, 0.14753251f, 0.16513988f, 0.14867041f, -0.00058105f, 0.06098850f, 0.01565375f, -0.10058159f, 
    0.01336855f, -0.04279988f, 0.01122776f, 0.01726033f, 0.12905286f, 0.11354863f, -0.21473745f, -0.10322724f, 
    -0.00959570f, -0.02482337f, 0.01079310f, -0.08591700f, -0.00048244f, -0.04410053f, -0.02063191f, 0.00258968f, 
    -0.04583878f, 0.03500175f, -0.23828967f, 0.11855174f, 0.03211508f, 0.05789159f, 0.13993517f, 0.08949547f, 
    0.03396714f, -0.11938023f, 0.00959767f, 0.02999086f, 0.19937879f, -0.18264143f, -0.02496218f, 0.08741172f, 
    -0.08028522f, 0.08654179f, -0.03933986f, -0.04817812f, 0.07745289f, 0.01131921f, -0.07623329f, 0.00960214f, 
    -0.15929019f, 0.15594128f, 0.11013569f, -0.10624862f, -0.01442947f, -0.00131478f, -0.04717310f, -0.01865988f, 
    0.03916877f, -0.00892914f, -0.04436417f, 0.01589245f, 0.02226833f, 0.03243373f, 0.21665281f, 0.10624104f, 
    0.04928925f, 0.04103480f, -0.00222172f, -0.01773488f, -0.03716860f, 0.03185290f, 0.05718133f, 0.04708298f, 
    -0.07892027f, -0.09022969f, -0.25643158f, 0.00631497f, 0.01163177f, -0.04943847f, -0.04864537f, -0.02087587f, 
    -0.01721762f, 0.03698197f, -0.00592098f, -0.04589922f, 0.00678694f, -0.28950572f, -0.10534211f, -0.13211286f, 
    0.02729166f, -0.00070395f, -0.01349493f, -0.06455915f, -0.08528735f, -0.02016043f, 0.03384411f, -0.02052899f, 
    -0.34775689f, 0.05018977f, -0.08789168f, -0.10722499f, -0.09592205f, 0.00586378f, -0.07217155f, -0.05220259f, 
    -0.03541071f, 0.01928463f, 0.03712566f, -0.03773025f, 0.01855435f, 0.06000881f, -0.00385985f, -0.04167912f, 
    0.03746142f, 0.00579194f, 0.02364475f, -0.03101486f, 0.01571953f, -0.06265429f, 0.04067135f, 0.00223809f, 
    -0.26872608f, 0.17996132f, 0.04539477f, 0.03648171f, 0.01115094f, -0.07962461f, 0.01075186f, 0.01531441f, 
    0.03951087f, 0.00492516f, 0.09110731f, 0.01573100f, 0.02940920f, 0.22151521f, 0.12904419f, 0.21563438f, 
    0.07471640f, 0.04245099f, 0.05372653f, -0.00383869f, -0.05546033f, 0.02910028f, -0.00465344f, -0.07735820f, 
    0.14097291f, -0.20804091f, 0.03858618f, 0.17959270f, -0.02921194f, -0.06883714f, -0.05492578f, -0.09270238f, 
    -0.08404987f, 0.05768479f, -0.06926958f, -0.03639693f, -0.07746896f, -0.08431687f, -0.08081827f, -0.10002537f, 
    0.00063121f, -0.00168162f, -0.01025884f, -0.00189668f, -0.01092036f, -0.00419312f, -0.02060650f, -0.09962423f, 
    0.15238138f, 0.09640832f, 0.10813136f, 0.03638431f, -0.08534656f, -0.02894243f, -0.03854583f, -0.07229277f, 
    -0.02548450f, 0.01468014f, -0.05072530f, 0.01535414f, -0.03282428f, -0.17247778f, -0.04135597f, -0.11954808f, 
    -0.01955080f, -0.02555244f, 0.04095094f, -0.00401307f, -0.10200036f, 0.03920249f, 0.03525113f, 0.00021695f, 
    0.18034880f, 0.15305236f, 0.24885972f, 0.14790736f, 0.11341693f, 0.09958264f, 0.04081806f, 0.01753716f, 
    -0.04741462f, 0.01237664f, -0.09378301f, -0.01350290f, -0.08282807f, -0.07438979f, -0.05567931f, 0.00524371f, 
    -0.06169304f, 0.03341467f, -0.04621470f, 0.04143378f, 0.01566698f, -0.08434186f, 0.03775466f, 0.05452313f, 
    -0.06175087f, -0.11546274f, -0.03459414f, -0.25454587f, 0.03551993f, -0.00671481f, -0.07385167f, -0.08096702f, 
    -0.00561172f, -0.01379212f, -0.01531159f, -0.05730531f, -0.04015308f, 0.18590617f, -0.06051701f, -0.03376891f, 
    -0.08843989f, 0.01253920f, 0.04249094f, 0.08470586f, 0.02330321f, 0.03279513f, 0.02766997f, -0.05273114f, 
    -0.01671660f, 0.10816780f, -0.11244391f, 0.07746141f, -0.04281000f, -0.03244485f, 0.02197842f, -0.09400748f, 
    -0.12580171f, 0.02235813f, 0.00544912f, -0.02253052f, -0.25743094f, 0.05332752f, 0.08227232f, -0.09655131f, 
    -0.07040031f, -0.02668660f, -0.00948750f, -0.01246272f, 0.03497911f, -0.02710672f, -0.00815417f, -0.02199017f, 
    -0.37969810f, 0.19325821f, -0.05593250f, -0.02190637f, -0.11313879f, -0.01611050f, 0.08868685f, -0.03345658f, 
    -0.06928899f, 0.04587210f, 0.00377955f, -0.06599852f, -0.05100662f, -0.25091255f, -0.05532349f, -0.06766571f, 
    -0.05681030f, -0.08333267f, -0.05024772f, -0.07186525f, 0.00798925f, 0.10415442f, -0.04612869f, 0.11877774f, 
    -0.08362662f, -0.09713586f, -0.09068206f, -0.24224037f, 0.11330727f, 0.04747095f, -0.01857114f, -0.07447788f, 
    -0.09865850f, -0.04265738f, -0.07188180f, -0.03307915f, 0.29595879f, -0.29199913f, 0.21934509f, 0.04310404f, 
    -0.03046160f, 0.03818736f, -0.06062141f, -0.02616196f, -0.03673771f, -0.00517209f, -0.00978310f, -0.02436391f, 
    0.18324816f, -0.03798565f, -0.13253877f, 0.01778525f, -0.02769776f, 0.04208565f, 0.03796903f, 0.05186197f, 
    -0.03381778f, -0.12509666f, -0.00438001f, 0.01589445f, -0.14495477f, 0.07461905f, -0.08657985f, 0.12561323f, 
    0.02538797f, -0.12234459f, -0.07776780f, -0.00985631f, 0.03553675f, 0.01235779f, 0.02798232f, -0.03596266f, 
    -0.17542884f, -0.00977573f, -0.00043648f, 0.07594450f, 0.05009583f, -0.06693113f, -0.02515391f, -0.05421165f, 
    -0.03662755f, 0.10602514f, 0.05708088f, 0.03568868f, 0.14726618f, -0.39286476f, 0.09951074f, -0.06025337f, 
    -0.05419977f, -0.06250641f, -0.05985695f, 0.00355054f, -0.01524918f, -0.00123243f, -0.03290141f, -0.01588104f, 
    0.11970822f, -0.11031041f, 0.05587024f, -0.07688837f, 0.06032277f, 0.02683574f, 0.07010360f, -0.04997540f, 
    0.04213631f, -0.01789729f, -0.03971132f, -0.04567569f, 0.00797198f, 0.07832197f, 0.04719582f, -0.07469886f, 
    0.01730189f, -0.01724977f, -0.04932405f, -0.04643283f, -0.02788455f, -0.01424131f, -0.00141216f, -0.05727303f, 
    0.11662704f, 0.13507934f, 0.01981062f, -0.01369368f, -0.05039427f, -0.04906232f, -0.01293372f, -0.08719374f, 
    -0.09926399f, 0.06435571f, -0.06743181f, -0.05140015f, -0.22516370f, -0.17275023f, -0.05665519f, -0.21511689f, 
    0.05928954f, 0.05234023f, -0.00355169f, -0.05957036f, 0.02680531f, -0.01143023f, 0.04307074f, -0.01734260f, 
    0.02426441f, -0.08592858f, -0.08356263f, -0.10127128f, 0.00013335f, 0.00546872f, -0.02443342f, -0.02540041f, 
    0.00284189f, -0.06737176f, -0.06682629f, -0.00004181f, 0.25103316f, 0.06665599f, 0.24868007f, 0.11293942f, 
    -0.00787349f, 0.06533142f, 0.04486547f, -0.03757617f, -0.09375478f, 0.11833046f, -0.06871852f, -0.09475162f, 
    0.03451469f, 0.12150472f, 0.09219948f, -0.04960435f, -0.06238766f, -0.01159884f, -0.05696519f, -0.01771889f, 
    -0.04601996f, -0.06660359f, -0.03720919f, 0.03405045f, -0.23754609f, 0.13267173f, 0.01486903f, -0.06778187f, 
    -0.06769669f, -0.02951712f, 0.08099887f, -0.05209555f, -0.02301117f, 0.01458264f, -0.03295488f, -0.10644947f, 
    -0.11813328f, 0.02767147f, -0.09739533f, 0.10426992f, 0.00298559f, -0.03294200f, 0.01778893f, -0.06630123f, 
    0.04550745f, 0.12894145f, -0.04191680f, -0.04610550f, 0.19544739f, -0.31860980f, -0.12338475f, -0.14172179f, 
    -0.09575799f, -0.01334617f, -0.00101137f, -0.00282496f, -0.03793087f, -0.04501013f, -0.01688662f, 0.02524298f, 
    -0.10866862f, 0.16767816f, -0.00345380f, -0.03588015f, -0.01764464f, 0.00902025f, 0.00514347f, -0.10810668f, 
    -0.08875056f, 0.00335484f, -0.04152956f, -0.00827214f, -0.00660287f, 0.19023088f, 0.09833717f, 0.10165507f, 
    0.05519155f, -0.00752318f, -0.07713934f, -0.05773719f, -0.04190870f, 0.03865470f, 0.03571755f, 0.01788392f, 
    0.16176322f, 0.12138684f, 0.08254810f, -0.10046262f, -0.04873308f, 0.00272544f, -0.03512481f, 0.01941882f, 
    -0.05685010f, -0.06992103f, -0.04438673f, -0.07382671f, -0.13798214f, -0.05687519f, -0.06395669f, -0.16461623f, 
    -0.01217020f, 0.03740954f, -0.01867473f, -0.07336941f, -0.00277224f, 0.01049773f, -0.00672877f, -0.03492302f, 
    -0.20585670f, 0.05562434f, -0.12990081f, -0.10094212f, 0.03268121f, -0.05484833f, 0.04430181f, -0.03958499f, 
    -0.11670569f, 0.02155905f, 0.04629526f, -0.08401722f, 0.07065977f, 0.23593867f, 0.10387892f, 0.16995038f, 
    0.14372995f, 0.05022068f, 0.02709368f, -0.04272521f, 0.03562525f, -0.03725000f, 0.03967576f, -0.08263271f, 
    0.12375772f, -0.22588052f, -0.15460324f, -0.16453107f, 0.04603893f, -0.05265753f, -0.05358469f, 0.00831483f, 
    -0.00050004f, 0.04243289f, -0.07602446f, 0.08037937f, -0.01371409f, 0.03837820f, -0.04548259f, 0.14346595f, 
    -0.13019013f, -0.06144265f, -0.07593954f, -0.04227003f, -0.00378016f, 0.05661952f, -0.00274380f, -0.06964011f, 
    0.05034146f, 0.14685686f, 0.05062755f, 0.08924725f, -0.03062805f, 0.04919302f, -0.00251297f, -0.10823976f, 
    0.07876090f, 0.03884229f, 0.02332984f, -0.06081102f, -0.09548368f, 0.16515562f, 0.08248400f, 0.08306355f, 
    0.08048299f, -0.01419662f, 0.03516634f, 0.06823222f, -0.01329655f, 0.05244640f, 0.00195316f, -0.00775468f, 
    0.09080350f, 0.03215624f, -0.08548717f, -0.19600177f, 0.02191547f, 0.09994919f, -0.07925307f, -0.04420910f, 
    -0.06888254f, 0.00130356f, 0.01883844f, -0.10842984f, -0.28043234f, 0.04958181f, -0.06377286f, 0.07438637f, 
    0.01069904f, -0.08117501f, -0.10018643f, 0.02273487f, -0.05355954f, -0.04723971f, 0.01947071f, -0.00215572f, 
    0.15304919f, -0.04883182f, 0.13302118f, 0.19468306f, -0.06505898f, -0.00111755f, -0.02758911f, 0.02392263f, 
    -0.03425232f, 0.02204837f, 0.00027525f, -0.01804108f, -0.00308755f, 0.17341979f, 0.06921414f, 0.12919812f, 
    0.11380147f, 0.05403775f, -0.03382109f, 0.02275885f, -0.00800554f, 0.01546971f, 0.03121462f, 0.00601197f, 
    -0.06104338f, 0.03112669f, -0.17626370f, -0.16884957f, -0.05465766f, -0.00507521f, 0.00121286f, -0.01681708f, 
    -0.06412851f, 0.09075842f, -0.03150509f, -0.03229386f, 0.06240086f, 0.00557923f, 0.11106219f, 0.07070486f, 
    0.03985825f, -0.05391996f, -0.05577927f, 0.00538087f, -0.02867917f, 0.01644949f, 0.03337481f, 0.00569848f, 
    0.07937237f, 0.20440726f, 0.12391089f, 0.07028273f, 0.02601389f, 0.05940499f, 0.03356244f, -0.09857406f, 
    -0.03180808f, 0.06403488f, -0.02754399f, -0.07108795f, -0.06164268f, -0.06750300f, -0.06709509f, -0.03955161f, 
    -0.04993434f, -0.00502604f, 0.00691700f, -0.05353627f, -0.09533681f, -0.03414041f, -0.05658660f, 0.04364937f, 
    -0.19317710f, -0.06958723f, -0.20510051f, 0.04482170f, 0.01407579f, -0.12927920f, -0.00903725f, -0.00248182f, 
    -0.13718852f, -0.04571610f, 0.03298327f, 0.00346816f, -0.02038436f, 0.06388531f, 0.05493724f, 0.03533608f, 
    -0.06756902f, 0.02938103f, 0.02339778f, -0.04472053f, 0.01183535f, 0.00696796f, -0.05451379f, -0.07398962f, 
    -0.02304038f, 0.08170971f, -0.00762546f, 0.16924663f, -0.00687219f, -0.03774118f, -0.03711376f, -0.14685681f, 
    -0.02642706f, -0.02573050f, -0.01801904f, -0.06562299f, 0.19639128f, -0.03723457f, 0.14596637f, 0.11264434f, 
    0.10430131f, -0.03348789f, 0.01449511f, -0.02051439f, -0.03050760f, -0.00889419f, 0.01674580f, -0.10359246f, 
    0.22171366f, 0.22944655f, 0.06045658f, 0.17794463f, -0.00539259f, 0.08902133f, -0.01910551f, 0.02724028f, 
    -0.05795239f, -0.04388712f, -0.02012606f, -0.00065942f, -0.23840141f, 0.24983464f, 0.01148764f, -0.06637131f, 
    -0.12290999f, 0.03809953f, 0.03164245f, -0.07924794f, -0.07222269f, -0.01534939f, -0.11524206f, -0.10575145f, 
    0.10312413f, 0.00394141f, 0.05625159f, 0.13162757f, -0.12257699f, 0.01654265f, -0.02396093f, -0.07214613f, 
    0.02567263f, -0.01689792f, 0.02341330f, -0.07827604f, -0.04881540f, 0.02619999f, -0.06700408f, 0.14765662f, 
    -0.12146761f, -0.01993513f, -0.08057581f, -0.01822221f, -0.02518239f, -0.00277531f, -0.00558474f, 0.00296672f, 
    0.05928490f, 0.02088895f, -0.03302910f, 0.21025664f, -0.02846852f, -0.03433341f, -0.05966921f, 0.02915438f, 
    -0.01450662f, -0.06512421f, 0.02874760f, -0.09876837f, 0.00768260f, 0.15222976f, -0.02451427f, 0.12535934f, 
    0.04985294f, -0.07616159f, 0.00458257f, 0.07595345f, -0.10020266f, 0.03509359f, 0.00905583f, -0.03096681f, 
    0.34619743f, 0.07977518f, -0.01139416f, 0.11319608f, 0.04869991f, -0.16355398f, -0.07633579f, -0.06776813f, 
    0.01267640f, -0.06350195f, -0.11146106f, -0.06385628f, -0.12068187f, 0.09975756f, 0.06076556f, 0.00102239f, 
    0.00381340f, 0.02592634f, 0.04557646f, -0.10685341f, 0.05090522f, 0.01783234f, -0.04741612f, 0.03517955f, 
    0.01264665f, 0.11439890f, -0.14314464f, -0.11849985f, -0.01289619f, 0.08482125f, -0.09826536f, 0.03823711f, 
    -0.00668746f, 0.04912636f, 0.12165224f, 0.07553242f, 0.02632290f, -0.12435401f, -0.15651241f, -0.02231965f, 
    0.05669038f, 0.02066052f, -0.06035082f, -0.02188005f, 0.09930967f, 0.00819502f, 0.02113125f, 0.03656109f, 
    0.06043066f, 0.01596351f, -0.07087337f, 0.06044776f, 0.09318739f, 0.07946156f, 0.00268051f, -0.04965978f, 
    0.03694390f, 0.05458489f, 0.03076586f, -0.01686373f, -0.09554548f, 0.00755107f, 0.05255239f, 0.07426731f, 
    0.03789741f, -0.06738355f, -0.17063692f, 0.05394490f, -0.01785848f, 0.10319815f, -0.03823430f, -0.06500787f, 
    0.08089935f, 0.08248307f, -0.02665886f, 0.15996733f, -0.03349562f, -0.04008577f, -0.00453654f, 0.00248359f, 
    -0.06771792f, -0.07035432f, -0.10171819f, 0.03132370f, -0.28576854f, 0.08081977f, 0.17454648f, -0.01110283f, 
    -0.11919572f, 0.06989571f, -0.01470460f, -0.01301403f, 0.01350208f, -0.01927234f, -0.04727668f, 0.04158072f, 
    -0.03312153f, -0.20684133f, -0.20791844f, -0.02110062f, 0.00334517f, 0.00813568f, 0.03156434f, -0.02268566f, 
    0.00159100f, -0.00595765f, 0.02835797f, -0.05490251f, 0.10186204f, -0.03622125f, -0.07138498f, 0.13166198f, 
    0.12059946f, 0.02072527f, 0.00989442f, -0.02861664f, 0.04927512f, 0.01987560f, 0.05108074f, 0.05532882f, 
    -0.17455010f, 0.08477883f, -0.09456882f, -0.23157689f, 0.01961396f, 0.04289837f, -0.08166378f, -0.00007837f, 
    0.03841636f, 0.01024966f, 0.02004827f, -0.17756362f, 0.14387019f, -0.20841043f, -0.14825207f, 0.02261724f, 
    0.10150684f, 0.04268662f, -0.01385029f, -0.02149826f, -0.03354799f, -0.05911837f, 0.12283742f, 0.01670683f, 
    -0.23739731f, -0.06186817f, 0.08858202f, -0.11567969f, 0.00322499f, 0.01573441f, -0.03973288f, -0.00346436f, 
    0.06828084f, -0.00140899f, -0.09566513f, -0.11048517f, 0.13095240f, 0.10384611f, -0.08939419f, -0.08112214f, 
    0.05559618f, 0.02060673f, 0.06692164f, 0.07415512f, 0.07967590f, 0.09091599f, -0.09843247f, 0.09410118f, 
    0.05872928f, -0.14898267f, 0.07138454f, 0.14967749f, 0.07073270f, -0.07251114f, 0.01253328f, -0.08373768f, 
    -0.00358492f, -0.07271045f, 0.00984894f, -0.13002566f, 0.06581049f, 0.18900242f, -0.11765689f, 0.09536423f, 
    -0.10398611f, -0.05693051f, -0.12953766f, 0.05616101f, -0.03468519f, -0.00317587f, -0.03922810f, -0.01808579f, 
    -0.43827516f, -0.08390336f, 0.07845618f, 0.10421199f, 0.03314380f, -0.04877664f, -0.01361544f, -0.05125588f, 
    0.09638838f, 0.05470759f, -0.01814864f, -0.10615036f, -0.05549023f, 0.04381137f, -0.11067729f, -0.08796508f, 
    0.00430753f, -0.02491270f, -0.12874734f, -0.02246287f, -0.02963576f, 0.01629036f, -0.03246929f, 0.09536742f, 
    0.05655070f, -0.08256836f, 0.10385470f, 0.13225213f, 0.07964327f, 0.04199830f, -0.05256183f, -0.03554834f, 
    -0.01582715f, -0.04129388f, 0.04174109f, 0.01068047f, -0.09259190f, -0.08608227f, -0.14577602f, 0.15760909f, 
    0.12411392f, 0.02680158f, 0.06832928f, -0.00753331f, 0.11004584f, -0.01717821f, 0.04481379f, -0.00986334f, 
    0.14296815f, -0.17047596f, -0.04507226f, 0.00813135f, 0.09854959f, -0.07188392f, -0.07738782f, 0.01864354f, 
    0.02495443f, -0.03424009f, 0.09152755f, 0.03398882f, 0.10210240f, 0.06844478f, 0.08090087f, 0.08282138f, 
    -0.11363389f, -0.08120088f, -0.07025814f, -0.15648717f, 0.00833669f, -0.01797193f, -0.13185920f, -0.03027512f, 
    0.21134087f, -0.02672721f, -0.17409931f, 0.04750312f, 0.11058850f, -0.01999301f, -0.00381991f, -0.10476585f, 
    -0.03132467f, 0.03233569f, 0.01709230f, -0.01782380f, 0.05038473f, 0.29262829f, -0.34297395f, -0.16723754f, 
    0.07636765f, -0.00570079f, -0.04273263f, -0.00191238f, 0.00905650f, -0.04823985f, -0.00683326f, 0.10224514f, 
    0.07338619f, -0.01517558f, -0.00405455f, -0.06539883f, -0.10093985f, 0.00278610f, 0.06049080f, 0.09907730f, 
    0.04887913f, -0.00543279f, 0.00779332f, 0.02742811f, 0.07254957f, -0.04561887f, -0.14860344f, 0.03845602f, 
    0.06958602f, -0.02411741f, -0.04754543f, -0.07756192f, -0.00611524f, 0.06815150f, 0.09349815f, 0.08102906f, 
    0.10154589f, -0.14977296f, 0.00251058f, -0.03099343f, -0.03346981f, -0.04552311f, 0.01148950f, 0.01307661f, 
    0.01471264f, 0.07815859f, 0.04480772f, -0.03547863f, 0.23912737f, 0.05274212f, 0.00618458f, 0.13049531f, 
    -0.05204745f, -0.12285455f, -0.06645390f, -0.03991229f, 0.09392686f, -0.06262314f, -0.01142377f, -0.08823068f, 
    0.06147211f, -0.07307553f, 0.12272052f, -0.10814764f, -0.10445067f, -0.05739820f, -0.14967649f, 0.11727839f, 
    -0.06861106f, 0.06872332f, 0.15336087f, 0.02832678f, 0.01939619f, -0.11034998f, 0.00221635f, 0.06343582f, 
    0.07036047f, -0.01468245f, -0.04168094f, 0.04238573f, 0.01439292f, 0.01242909f, -0.00607407f, 0.03257102f, 
    0.00957100f, 0.14969297f, -0.00241658f, -0.03130914f, -0.15511526f, -0.07596664f, -0.02182388f, -0.01711041f, 
    -0.02712618f, 0.03034690f, 0.04178844f, -0.03295798f, -0.20734581f, -0.06579089f, 0.11576901f, -0.06341686f, 
    0.01414303f, -0.00009794f, 0.00417246f, -0.16971196f, -0.01150340f, -0.08119244f, -0.03750324f, -0.06006673f, 
    0.02710959f, 0.04190976f, -0.05603370f, 0.01304018f, -0.02513439f, -0.06290404f, -0.10454365f, -0.05282095f, 
    0.05581223f, 0.04087107f, -0.05154194f, -0.09935948f, 0.07338063f, -0.01166184f, -0.01488629f, 0.14130294f, 
    0.01968519f, -0.01239148f, -0.05443222f, -0.03271565f, 0.06536324f, -0.00054839f, 0.05713538f, -0.07410745f, 
    -0.01090739f, 0.23494639f, -0.11422414f, -0.00969248f, -0.19240755f, 0.05567895f, -0.00126489f, -0.05372358f, 
    0.10235450f, -0.01802787f, 0.03623527f, 0.06779847f, -0.03193163f, -0.11159362f, -0.18427762f, 0.02539478f, 
    0.03283457f, -0.02011796f, -0.01112542f, -0.03712605f, 0.10065146f, -0.00817400f, 0.01817867f, -0.00363653f, 
    -0.16884689f, 0.04917281f, 0.19094495f, 0.10792671f, -0.07884796f, -0.12063349f, -0.07180294f, 0.05573732f, 
    0.07172725f, 0.04739386f, 0.02819618f, 0.02681452f, -0.04775759f, -0.14961056f, 0.17305861f, 0.10418174f, 
    0.02955023f, -0.06254589f, -0.10946681f, 0.02278923f, -0.02790473f, -0.09399711f, -0.03540912f, -0.16871676f, 
    -0.14284791f, 0.18354930f, 0.01942110f, -0.04399569f, -0.04824488f, -0.02862961f, -0.04353638f, 0.02457508f, 
    0.03476163f, -0.04838635f, 0.03173238f, -0.03680885f, 0.18882325f, 0.02069923f, -0.15396999f, 0.05457324f, 
    -0.02601337f, -0.07478006f, -0.00998737f, -0.01910700f, -0.00106772f, 0.03574814f, -0.09789255f, -0.16178013f, 
    0.08694565f, -0.02170607f, -0.09699872f, 0.08029938f, 0.06036942f, 0.02900560f, -0.03883080f, -0.05503760f, 
    0.03360217f, -0.05664121f, 0.06222245f, -0.13167521f, -0.02143293f, 0.06882185f, 0.02393759f, 0.09131599f, 
    -0.03829490f, -0.02179780f, -0.10449377f, -0.00470019f, -0.03840698f, -0.01578398f, 0.05316221f, -0.00825663f, 
    0.06325814f, -0.05614435f, 0.11443198f, 0.02460637f, 0.01584204f, -0.00172871f, -0.03247537f, -0.07177344f, 
    0.02744080f, -0.03246963f, -0.00348423f, 0.04007837f, -0.14391977f, -0.05842824f, -0.11981069f, -0.17242534f, 
    -0.10867390f, -0.11804254f, 0.06749067f, -0.04417851f, 0.13423617f, 0.13512370f, -0.04456745f, -0.02243459f, 
    -0.03187013f, 0.20525439f, -0.02098796f, -0.01563880f, -0.09450260f, 0.00873064f, -0.16149227f, 0.04251055f, 
    0.02669565f, 0.00279664f, -0.05935434f, -0.16460466f, -0.03347552f, -0.04235277f, 0.10022196f, -0.00615396f, 
    -0.10884973f, -0.03403945f, -0.08873212f, -0.05793676f, -0.00502001f, -0.04064757f, 0.04732572f, -0.06196647f, 
    0.09209968f, -0.13342798f, 0.06906930f, 0.01982022f, 0.08402981f, -0.10013399f, -0.02918114f, -0.03784768f, 
    0.00519688f, -0.00140157f, 0.04932141f, 0.05736772f, 0.02844526f, 0.16732438f, -0.21189059f, -0.03874578f, 
    0.04498406f, 0.01945157f, -0.16823031f, 0.00045390f, 0.05740978f, 0.01219881f, -0.00660730f, 0.02261402f, 
    0.02928253f, -0.06809764f, -0.07287332f, -0.18752673f, -0.08169518f, -0.06440785f, 0.09860823f, -0.05564809f, 
    -0.03473928f, -0.04176799f, -0.05394689f, 0.02206030f, -0.15254650f, -0.08600575f, 0.12056243f, -0.01239403f, 
    -0.01378156f, -0.11680391f, 0.02341884f, -0.07093478f, 0.04281151f, -0.00147165f, -0.08811106f, 0.00693717f, 
    -0.04003183f, -0.05040709f, 0.05430477f, 0.06497869f, 0.05711759f, 0.05718806f, 0.02322638f, -0.07662321f, 
    0.07725415f, -0.09798571f, 0.09340442f, 0.02871648f, -0.02218592f, 0.10617270f, -0.03004736f, 0.12434734f, 
    -0.10192617f, -0.11525845f, 0.00942695f, 0.01020189f, 0.02585493f, -0.01380175f, -0.03371715f, 0.01931339f, 
    -0.10960405f, -0.04327881f, 0.24497578f, 0.01165059f, -0.05790835f, -0.02719774f, -0.06359304f, 0.04030621f, 
    -0.00307673f, 0.03308225f, 0.02677682f, 0.05721759f, 0.07952783f, -0.13690135f, 0.05895158f, 0.06894917f, 
    0.08163302f, -0.03368618f, -0.08483010f, -0.14527267f, 0.00459079f, -0.02928613f, -0.00147719f, -0.12260131f, 
    -0.03730932f, -0.02173954f, -0.10879997f, -0.07119408f, 0.01052686f, 0.00203476f, -0.02323724f, 0.01874268f, 
    -0.00395686f, 0.02753010f, 0.10622010f, 0.02045978f, -0.00781047f, 0.11798777f, -0.10790076f, 0.03358280f, 
    0.02170885f, 0.02812576f, 0.04257691f, -0.09539899f, -0.01337182f, -0.04359043f, 0.16998443f, 0.06467286f, 
    -0.11778843f, 0.03058281f, 0.02442171f, -0.09919993f, -0.01015111f, -0.02179302f, -0.05623308f, 0.10008208f, 
    0.03020263f, 0.05632156f, -0.05452850f, 0.06597242f, 0.01798424f, -0.17695349f, 0.07140794f, -0.17996305f, 
    0.01635700f, -0.01746551f, 0.04388113f, -0.07062213f, -0.04444283f, -0.10571237f, -0.00600334f, 0.09040916f, 
    -0.22698544f, -0.02489836f, 0.06802470f, -0.22897224f, -0.02941702f, 0.11275786f, -0.04763064f, 0.07012197f, 
    0.05030572f, -0.02492258f, -0.05751055f, -0.03058047f, 0.10724166f, 0.00161201f, 0.07836519f, 0.13239941f, 
    -0.02287288f, -0.10823503f, 0.04756592f, -0.00099859f, 0.03612680f, 0.02829252f, 0.00248424f, -0.06959790f, 
    -0.16321802f, -0.11304872f, 0.02485069f, -0.19239372f, -0.05903867f, -0.25336757f, -0.06844838f, -0.01049212f, 
    -0.00059684f, 0.02393159f, -0.18295678f, 0.13334520f, -0.25510904f, -0.10481496f, -0.26070288f, -0.24914525f, 
    0.02631832f, 0.09856276f, -0.03158220f, -0.06677698f, 0.07334004f, 0.00267049f, -0.04301301f, -0.04828610f, 
    -0.20173609f, 0.02532336f, -0.27851975f, -0.21880928f, 0.04677641f, 0.01729533f, -0.20514122f, -0.00387414f, 
    0.09470003f, 0.03604779f, 0.05684920f, -0.04061475f, -0.00929611f, 0.03991121f, -0.02542187f, -0.13358150f, 
    0.10708606f, 0.01482469f, -0.20705526f, 0.15735127f, 0.07438290f, 0.08011214f, 0.04078681f, 0.03185965f, 
    -0.08740402f, -0.04310624f, -0.09855471f, -0.06137775f, 0.15802935f, 0.01197790f, 0.11041614f, -0.15027606f, 
    0.10612220f, 0.08087391f, -0.02844610f, 0.01900559f, 0.00901549f, -0.35092893f, -0.25682732f, 0.27177685f, 
    -0.04618866f, -0.11603890f, -0.03162262f, 0.03023900f, 0.10387100f, -0.10140439f, 0.00685457f, -0.05631725f, 
    -0.04711376f, 0.26308379f, 0.13365497f, -0.10437423f, -0.00434131f, 0.06428973f, 0.01114519f, -0.05223375f, 
    -0.02463910f, 0.05247847f, -0.18893424f, 0.02217263f, 0.17101753f, -0.19424620f, 0.16439980f, -0.08918929f, 
    0.06761188f, 0.14496237f, -0.07513495f, -0.07978541f, -0.12573512f, -0.01769136f, 0.00152109f, -0.07099928f, 
    0.09220267f, 0.09631426f, 0.25828719f, -0.15610385f, 0.07180002f, 0.07345343f, 0.01848027f, 0.00469916f, 
    -0.07607502f, -0.10551237f, -0.03252319f, -0.06577355f, -0.15201269f, 0.05050056f, -0.15033706f, -0.27609670f, 
    -0.04256610f, 0.00931025f, -0.07060178f, 0.10025334f, -0.01990364f, 0.01309717f, 0.11247269f, 0.13138270f, 
    -0.13105722f, -0.16228452f, 0.07364494f, 0.07590994f, 0.15308392f, -0.02389216f, -0.19585347f, 0.07617749f, 
    -0.13495775f, 0.03077657f, 0.05563871f, -0.07590631f, -0.03739256f, -0.20232902f, -0.02288376f, -0.02287018f, 
    -0.01052976f, -0.01465922f, -0.05121624f, 0.08353025f, -0.04045150f, -0.05314125f, 0.14039834f, 0.02685286f, 
    -0.05626952f, 0.04590440f, 0.00550859f, -0.14749841f, -0.16198225f, -0.03934476f, 0.00373127f, -0.06019375f, 
    -0.06904846f, 0.10061291f, 0.04221398f, 0.07786784f, -0.27764529f, 0.02427969f, -0.21629053f, -0.04622160f, 
    0.12732325f, -0.06426249f, -0.03177245f, -0.03459120f, -0.09667616f, -0.10821694f, -0.12746659f, -0.15296714f, 
    -0.21381901f, -0.02123919f, -0.06520320f, 0.13442384f, 0.04096747f, 0.11377452f, -0.02045770f, -0.06375114f, 
    -0.00288943f, 0.01757856f, -0.10045595f, 0.08787650f, 0.00326967f, -0.12777846f, 0.16208003f, -0.07695065f, 
    -0.05505535f, 0.07447628f, -0.03237959f, -0.07666869f, -0.08806444f, 0.10221907f, 0.02780792f, -0.03040615f, 
    -0.05654102f, -0.15763333f, -0.06224386f, 0.08923133f, 0.00386577f, 0.00525644f, -0.09224812f, 0.02891451f, 
    -0.01584891f, 0.08249166f, -0.06845337f, -0.03353034f, 0.53898782f, 0.08068550f, 0.03831476f, 0.19996266f, 
    0.12476143f, 0.03851333f, 0.01876230f, -0.02559849f, -0.10393655f, 0.07888555f, -0.00119921f, 0.13171192f, 
    0.20595717f, -0.12243059f, 0.02056378f, -0.11613752f, 0.06689461f, 0.10807130f, 0.01542560f, 0.00474674f, 
    0.01573618f, -0.03513564f, -0.16525051f, 0.13136785f, -0.45125267f, 0.06510323f, 0.08650954f, -0.06532457f, 
    -0.12054551f, 0.11668769f, 0.10512679f, 0.18097976f, 0.22498925f, 0.00701366f, -0.01529767f, -0.04805506f, 
    -0.18995547f, 0.04672471f, -0.21092105f, -0.25678548f, 0.03751505f, -0.16172627f, 0.07366290f, 0.00837929f, 
    -0.11846371f, -0.04636607f, 0.07788282f, -0.05564127f, -0.33467188f, -0.04644118f, 0.10039610f, 0.05073964f, 
    -0.16184342f, 0.01941443f, 0.14934641f, 0.00958728f, -0.08658651f, -0.11364546f, 0.05941075f, -0.11385085f, 
    -0.23689009f, 0.24581489f, -0.01565157f, -0.31125495f, 0.07264993f, 0.01021465f, -0.02876967f, 0.08175665f, 
    -0.03295965f, 0.05931632f, 0.00495546f, -0.09940004f, -0.10825481f, -0.08806754f, -0.12513123f, -0.32197967f, 
    0.05403731f, 0.06301584f, -0.08153185f, -0.06932262f, -0.17539909f, -0.12378233f, -0.09799712f, 0.02355006f, 
    -0.01021237f, 0.06114603f, 0.23802768f, 0.02586296f, 0.03013360f, -0.00731561f, -0.11917561f, -0.00077220f, 
    -0.03677914f, 0.08003423f, -0.08956225f, -0.06057663f, 0.49325699f, -0.39110085f, -0.12991971f, 0.07146195f, 
    -0.04668609f, 0.04745262f, -0.00480697f, 0.06847626f, -0.03176112f, -0.01931522f, 0.09687277f, -0.06181557f, 
    -0.18571708f, 0.09725043f, 0.02900145f, 0.09064982f, 0.00090429f, 0.01058393f, -0.01911807f, -0.02657756f, 
    0.05343092f, 0.06707089f, 0.07473389f, 0.09090856f, 0.15039080f, 0.05507682f, 0.39229289f, -0.11732086f, 
    0.01952549f, -0.01396232f, -0.05464488f, -0.10409565f, -0.06551639f, -0.01809181f, 0.04326061f, 0.00214093f, 
    -0.29107705f, -0.11163865f, 0.15494625f, -0.11538114f, 0.02178060f, -0.10574988f, 0.13915661f, -0.08936677f, 
    0.05123327f, -0.09450747f, -0.00741980f, -0.04626337f, -0.08630894f, -0.03227910f, 0.13225205f, -0.21836142f, 
    0.02447435f, 0.00813275f, -0.02970804f, -0.08376969f, 0.10261080f, -0.00178925f, 0.04211247f, -0.09891358f, 
    0.24387641f, 0.16942029f, -0.15373187f, 0.12838534f, 0.07590996f, 0.03260646f, 0.04471858f, -0.00267766f, 
    0.04437682f, -0.09649783f, -0.04966681f, 0.06153298f, -0.07575115f, 0.12094426f, -0.16182576f, -0.06388633f, 
    0.10393567f, 0.02362432f, -0.12049964f, -0.16958341f, -0.10026997f, 0.05269420f, -0.01901056f, 0.06864764f, 
    -0.03220088f, 0.03053874f, -0.20005539f, -0.04436781f, -0.07071783f, 0.12796454f, 0.09583504f, -0.17564221f, 
    -0.06341635f, 0.15574719f, -0.15694387f, -0.11561475f, 0.01679200f, -0.03603679f, -0.01181112f, -0.30952001f, 
    0.06914809f, -0.04759710f, 0.01396223f, 0.02147068f, -0.04059921f, -0.12800807f, -0.10070461f, -0.10515137f, 
    0.40832201f, 0.21894294f, -0.20595755f, 0.06734338f, 0.05170869f, -0.04074015f, -0.01671476f, 0.05748444f, 
    -0.02788085f, 0.00477460f, 0.04650662f, 0.03652920f, 0.01949749f, -0.05567477f, -0.02461591f, 0.08727515f, 
    -0.01896486f, 0.09989361f, 0.12055758f, -0.07200754f, 0.03211300f, 0.15687092f, 0.02844802f, 0.01041781f, 
    0.07445244f, -0.10509249f, -0.03567868f, -0.09848349f, 0.09598017f, 0.03932507f, 0.04350025f, 0.12704848f, 
    -0.11516995f, -0.01508244f, 0.11830207f, 0.07019858f, -0.41956699f, 0.27765983f, -0.28332028f, -0.13398670f, 
    0.13598916f, 0.00384699f, 0.00611747f, 0.05789526f, 0.01733681f, -0.00299159f, -0.08560120f, -0.08135509f, 
    -0.01604635f, 0.30842918f, -0.20679909f, 0.27728343f, 0.09977327f, 0.14911667f, -0.17565827f, 0.20489387f, 
    0.07222027f, 0.00319391f, -0.08831089f, -0.03073213f, -0.20226441f, -0.07171203f, 0.09893886f, -0.19364005f, 
    0.04753761f, 0.07219373f, 0.02287378f, -0.06193311f, -0.02498302f, -0.05662395f, 0.07160959f, -0.03723301f, 
    0.17549719f, 0.24271767f, -0.18209843f, 0.07228219f, 0.08222000f, -0.04165933f, -0.06724920f, 0.00996724f, 
    -0.11025336f, 0.03459670f, -0.11622680f, 0.03327014f, -0.03121409f, -0.05759047f, -0.05952826f, -0.05361778f, 
    0.00181669f, 0.02594119f, 0.05266499f, -0.03877755f, 0.04032865f, 0.08487367f, 0.05060300f, 0.10287955f, 
    -0.58547646f, 0.02035649f, -0.03285707f, 0.07521131f, -0.03486309f, 0.12138628f, -0.04679481f, -0.06115165f, 
    -0.02874994f, 0.04932408f, -0.01001196f, 0.09152137f, -0.05825076f, -0.00239644f, 0.15378144f, 0.03413341f, 
    0.08399951f, 0.02181014f, -0.08733784f, -0.08626154f, 0.11240903f, 0.07367866f, -0.06247705f, -0.00672170f, 
    -0.19584095f, 0.27337199f, -0.07277720f, -0.14787722f, -0.00290956f, -0.04596396f, -0.05010691f, -0.06897820f, 
    -0.03034478f, 0.10143339f, -0.00145224f, -0.02700747f, -0.02384426f, -0.31113651f, -0.03013566f, -0.16844149f, 
    0.06118607f, -0.02091855f, 0.00764307f, 0.09989540f, -0.06809843f, -0.06425069f, -0.02671530f, 0.05731924f, 
    0.26521218f, 0.12942244f, -0.22238995f, -0.06547105f, 0.11212464f, -0.09706157f, -0.01008675f, 0.09755599f, 
    -0.14047113f, 0.02738673f, 0.02401419f, 0.20545129f, -0.02118375f, 0.13002750f, -0.14324670f, -0.10067263f, 
    -0.02441703f, 0.08130017f, 0.08738653f, 0.01476057f, -0.03546748f, -0.02619197f, 0.04951438f, -0.01230127f, 
    -0.25195384f, 0.27275905f, 0.22511938f, 0.09673961f, 0.11744894f, 0.03548215f, -0.07000243f, 0.16915399f, 
    0.07161384f, -0.05301441f, 0.00982877f, -0.03522267f, -0.15851468f, -0.18674842f, 0.08616026f, 0.04437829f, 
    0.03993604f, 0.00365392f, 0.03077137f, 0.03767287f, -0.01955394f, -0.03907043f, 0.00432791f, 0.01366038f, 
    0.01011982f, 0.12690702f, -0.04223289f, -0.07031540f, -0.00383487f, 0.01149763f, -0.03723461f, -0.05412159f, 
    0.06441797f, -0.04603926f, 0.08159679f, -0.03537996f, -0.19253685f, -0.04777146f, 0.07528360f, -0.01030894f, 
    -0.10105426f, 0.05350707f, 0.06150419f, -0.02108187f, -0.05383122f, 0.04005285f, 0.04747723f, 0.05632846f, 
    0.19185422f, 0.05012635f, -0.11583762f, 0.01979785f, 0.05983468f, 0.01809523f, -0.11058678f, 0.10985842f, 
    -0.02293734f, -0.09064247f, 0.04697992f, 0.08973278f, 0.13489710f, -0.00545601f, -0.09392635f, 0.11991502f, 
    0.07852547f, -0.11058418f, -0.06471433f, 0.00713914f, -0.05338971f, -0.12038376f, 0.16037628f, 0.01475851f, 
    0.08480270f, 0.00652984f, 0.07899189f, 0.02735645f, -0.05414652f, -0.04956620f, -0.05601526f, -0.07464751f, 
    0.02864589f, 0.14596944f, 0.04705748f, -0.03171139f, 0.12694891f, -0.17265904f, -0.00436751f, 0.19610044f, 
    0.05989009f, -0.03154397f, 0.01370540f, -0.03810681f, -0.07815012f, -0.02859305f, 0.09060486f, -0.01699609f, 
    0.16862689f, -0.10427549f, -0.06078066f, 0.16573338f, 0.04345326f, 0.06544124f, -0.00450795f, -0.12897126f, 
    -0.00659439f, 0.11168008f, -0.03361326f, -0.01254867f, -0.02352685f, -0.00253810f, 0.01556024f, -0.05560253f, 
    0.00185830f, -0.05360367f, -0.03263038f, -0.02386867f, 0.09529056f, 0.09455457f, 0.00988218f, 0.03631864f, 
    0.05667884f, 0.07819354f, -0.05371697f, -0.18714839f, -0.03545909f, 0.08919999f, 0.02029017f, -0.11900131f, 
    -0.12212530f, 0.00625162f, -0.07577851f, 0.00640214f, -0.21713035f, 0.03023929f, 0.08526694f, 0.11665893f, 
    0.07196271f, -0.04270853f, -0.16772188f, 0.06077198f, -0.06382737f, 0.09835673f, -0.17530417f, -0.06928971f, 
    -0.17585574f, -0.24567632f, 0.03453401f, -0.18032041f, -0.01302304f, 0.11076154f, -0.02877003f, -0.03666845f, 
    -0.10201693f, -0.03472200f, -0.06062859f, -0.00620914f, 0.18619560f, 0.16480953f, -0.08766809f, 0.10887975f, 
    0.06158952f, 0.01328245f, -0.03472537f, 0.01226579f, -0.10846686f, 0.11915869f, 0.07822508f, -0.05525338f, 
    -0.15719813f, 0.12902924f, 0.11479417f, 0.19216819f, -0.06980939f, -0.03824838f, -0.12238011f, -0.04524663f, 
    0.02271407f, -0.06201284f, -0.04659803f, 0.13004562f, -0.47685480f, 0.46158445f, -0.26081246f, 0.04411384f, 
    0.11839482f, -0.01158226f, 0.07060631f, -0.05635263f, -0.08720507f, 0.05763267f, 0.08331069f, -0.02785275f, 
    0.09097216f, 0.14862971f, -0.13512537f, 0.17715810f, -0.05384674f, 0.02618081f, -0.07754511f, 0.13512257f, 
    -0.02281280f, 0.02510919f, 0.14256118f, -0.08086299f, -0.16682388f, 0.09964120f, -0.22202520f, -0.02963130f, 
    -0.00856975f, 0.14481495f, 0.06321266f, -0.00546549f, -0.00450039f, -0.00897612f, -0.05543117f, -0.03123834f, 
    -0.09421071f, 0.07500822f, 0.06543841f, -0.06682253f, 0.07212991f, 0.13493232f, -0.04798674f, 0.04012295f, 
    -0.02368177f, 0.02484182f, -0.05798773f, 0.03688927f, -0.12669721f, 0.05326125f, -0.02816441f, -0.26815492f, 
    -0.15242594f, -0.07970414f, -0.00632857f, 0.12466268f, 0.10103398f, -0.14895621f, 0.12990274f, -0.01820450f, 
    -0.06979191f, -0.08772162f, -0.20129526f, -0.12104558f, 0.10618792f, 0.06210994f, -0.12602954f, -0.05926586f, 
    0.00542127f, -0.13420257f, -0.01745251f, -0.05118108f, 0.19251108f, 0.06932300f, -0.07486633f, -0.04873147f, 
    0.06241962f, -0.02161326f, 0.13915956f, -0.07533655f, 0.09960283f, -0.08527333f, 0.09814017f, 0.02290875f, 
    -0.11849252f, -0.11641978f, -0.02733616f, 0.07203653f, 0.05960554f, 0.08543976f, -0.01734840f, 0.04163284f, 
    0.02949969f, 0.04379683f, 0.08846463f, -0.00489483f, -0.47003478f, 0.11399376f, 0.03953908f, 0.01340764f, 
    0.17029530f, 0.05222907f, -0.13021104f, 0.02963848f, 0.05625158f, 0.05048347f, -0.18109006f, 0.13246977f, 
    -0.48945373f, -0.28279284f, 0.11449973f, 0.01243763f, 0.10303314f, 0.01956647f, 0.02344896f, -0.02093253f, 
    0.08337841f, 0.16593422f, 0.04922149f, 0.14027663f, -0.02618098f, -0.10275516f, -0.02545143f, 0.00671862f, 
    0.01064455f, -0.08859219f, 0.03215070f, 0.09217878f, -0.03939692f, 0.08880139f, -0.27090710f, 0.03047220f, 
    0.17540927f, -0.05690764f, -0.00725710f, 0.01965624f, -0.04704915f, -0.00140054f, 0.01867115f, 0.03863431f, 
    0.11661136f, 0.07014265f, -0.01596385f, 0.09121931f, 0.01726679f, 0.03821754f, 0.08396312f, -0.08095586f, 
    0.06689092f, -0.00154651f, 0.01332260f, -0.05616770f, 0.08226355f, -0.00779767f, -0.03202558f, -0.00192645f, 
    0.14186284f, 0.10767975f, 0.12632610f, -0.00985561f, 0.02596598f, -0.04507704f, 0.01245305f, -0.08382832f, 
    0.05194602f, 0.04473808f, -0.06719900f, -0.09518843f, -0.38015631f, -0.30295110f, -0.26492071f, -0.02519384f, 
    -0.06662605f, 0.02388766f, 0.00015952f, 0.00822739f, -0.00735819f, 0.18442249f, 0.05666013f, 0.03918947f, 
    0.02730289f, -0.03576303f, 0.02837461f, 0.03832883f, 0.00236613f, 0.18319522f, 0.04101765f, 0.05468025f, 
    -0.07120324f, 0.04963623f, -0.01641262f, -0.04987371f, -0.39723560f, -0.30371758f, -0.00657009f, 0.00331173f, 
    -0.03740219f, 0.05506449f, -0.08716296f, -0.01588736f, -0.05724779f, -0.00726316f, 0.04847905f, -0.10025716f, 
    0.29638195f, -0.03167794f, -0.03178243f, -0.08470492f, -0.15185735f, -0.02269078f, -0.08686856f, -0.06884254f, 
    0.02362038f, 0.04592860f, -0.04575970f, -0.06950885f, -0.17592718f, -0.07220219f, 0.07310009f, 0.07066997f, 
    -0.07018392f, -0.01912153f, 0.08527667f, -0.04259698f, 0.11813188f, -0.12510565f, -0.00044907f, -0.08705265f, 
    -0.38572949f, -0.04154071f, -0.16036963f, -0.14546950f, 0.03122563f, -0.01827762f, -0.20465188f, 0.02587194f, 
    -0.00725723f, 0.01137973f, 0.09939549f, 0.03627837f, -0.19608988f, -0.02189547f, -0.11199455f, 0.08024274f, 
    -0.00351224f, -0.01231139f, 0.01342861f, -0.14887708f, 0.06622994f, -0.10499837f, -0.15717538f, 0.02510744f, 
    0.00715591f, 0.11401423f, 0.09287802f, -0.08403938f, 0.01927741f, -0.02441504f, 0.04902890f, -0.06765222f, 
    -0.06604754f, -0.10389998f, -0.17383637f, 0.02842804f, 0.03096177f, -0.08473891f, 0.02501091f, 0.16287243f, 
    0.03155219f, 0.03920442f, -0.05652838f, 0.08942559f, 0.02027732f, 0.05795530f, 0.09191634f, 0.14338432f, 
    -0.65290737f, -0.46060362f, 0.01154911f, -0.10557921f, 0.12890504f, 0.02707190f, 0.00095208f, -0.06364203f, 
    0.13182977f, 0.02836188f, 0.08919872f, 0.10252967f, -0.13693914f, 0.08776417f, 0.14197692f, -0.29942527f, 
    0.00867444f, 0.01881383f, 0.08498066f, 0.11059526f, 0.08027476f, 0.11365689f, 0.12716983f, 0.08810728f, 
    -0.40105233f, 0.03162285f, -0.14157906f, -0.15975739f, 0.14269060f, -0.21743022f, -0.14727522f, -0.06308760f, 
    -0.15741295f, -0.08221596f, 0.03910270f, 0.06442704f, 0.08207028f, 0.06421685f, -0.13853694f, 0.07458260f, 
    0.03387713f, -0.09234130f, -0.09655850f, 0.00144599f, 0.02522638f, -0.02187443f, -0.13356858f, 0.04491177f, 
    -0.45564920f, -0.10534558f, 0.00451815f, 0.03668769f, 0.08591758f, 0.05611407f, 0.04140700f, -0.09046974f, 
    0.03869234f, -0.06128294f, 0.06667461f, -0.08913653f, -0.27268213f, -0.06248281f, 0.07655253f, 0.02121820f, 
    0.05338526f, -0.01697500f, 0.05579294f, 0.01228779f, 0.01949743f, -0.03311547f, -0.04428110f, 0.07252160f, 
    -0.30221272f, -0.03248116f, -0.08478372f, 0.07813648f, -0.01731043f, -0.00228721f, 0.03137238f, -0.01083264f, 
    0.03907484f, 0.05981969f, 0.14144932f, 0.07294303f, 0.00715815f, 0.23062702f, -0.02261083f, -0.09877597f, 
    -0.04760054f, 0.00650690f, -0.04207833f, 0.10588368f, -0.03977130f, 0.05397827f, 0.06674434f, 0.10548063f, 
    0.11408480f, -0.02536645f, -0.05965155f, 0.15583104f, -0.03052285f, -0.08327134f, 0.06469626f, 0.00825998f, 
    0.01504599f, 0.06177583f, 0.05124947f, 0.06855593f, 0.12997493f, 0.11408579f, -0.10207377f, -0.07886779f, 
    -0.00533580f, -0.13153408f, -0.05333150f, 0.10069656f, -0.08765745f, -0.06081934f, -0.04454264f, -0.07159770f, 
    0.27213335f, 0.17690820f, -0.15277196f, 0.01357348f, 0.06628801f, 0.00565307f, -0.04938433f, -0.04663426f, 
    -0.10298625f, 0.04624380f, 0.13814276f, -0.05119869f, -0.37776464f, 0.02247381f, -0.11523373f, -0.19370523f, 
    0.09932502f, -0.05058953f, 0.00765496f, 0.03006591f, -0.05524663f, 0.10006347f, 0.13203117f, 0.19260171f, 
    -0.01705746f, -0.08897761f, 0.11360039f, 0.13527875f, 0.05625231f, -0.00305953f, 0.03562141f, 0.04341105f, 
    -0.04609247f, 0.11159994f, 0.02563181f, -0.03961095f, 0.08840135f, 0.08501105f, -0.06103957f, 0.00715178f, 
    -0.12539662f, 0.05963412f, -0.05756950f, 0.04583271f, 0.06294125f, -0.10484523f, 0.07793703f, -0.08395423f, 
    -0.01676209f, -0.11538489f, -0.02737054f, -0.01599100f, 0.09631382f, -0.04160368f, -0.00494567f, 0.10074504f, 
    -0.02502980f, 0.07706884f, -0.09959397f, 0.03777280f, -0.45886871f, -0.28871328f, -0.16975981f, -0.24709800f, 
    0.00302211f, -0.04359880f, -0.08872141f, 0.01682620f, 0.02873016f, -0.02468739f, -0.04550022f, 0.00487033f, 
    -0.11225309f, -0.05711243f, -0.09989041f, 0.15145746f, -0.09236873f, 0.04737331f, -0.02232433f, -0.01695287f, 
    0.10742019f, -0.04408851f, 0.12526843f, -0.03255011f, -0.06737933f, -0.19836685f, 0.00602317f, -0.11260578f, 
    0.03226765f, 0.09952709f, 0.00080594f, 0.01006165f, 0.00703357f, -0.06736030f, -0.04272960f, -0.06421615f, 
    0.24218518f, 0.12277918f, 0.10805199f, -0.15928768f, -0.12116672f, -0.17463660f, 0.02038633f, 0.25147465f, 
    0.02740353f, -0.06768731f, 0.11916378f, 0.00264161f, 0.18971503f, -0.00005123f, -0.04906290f, 0.04253279f, 
    -0.03492349f, -0.19297437f, -0.05129926f, 0.05689197f, -0.07196832f, -0.03996080f, -0.08593917f, -0.03382352f, 
    0.01954985f, -0.26739258f, -0.07821547f, 0.08229014f, 0.04702170f, 0.02473923f, 0.04000505f, 0.05596530f, 
    -0.00701152f, -0.15058151f, -0.12427601f, 0.05512631f, -0.14982599f, -0.18151066f, -0.15215674f, -0.09601619f, 
    -0.01348878f, 0.02389317f, -0.01664988f, -0.13226748f, 0.06525183f, -0.06298741f, -0.21466850f, -0.10390111f, 
    -0.28593418f, -0.15221711f, -0.14236470f, -0.08480629f, 0.04190077f, -0.03476460f, -0.08015536f, -0.06703727f, 
    0.04489873f, -0.03078856f, 0.05764413f, 0.04505365f, 0.14502902f, -0.03682692f, -0.08750085f, 0.02004208f, 
    0.01012126f, -0.03890277f, -0.09464789f, -0.07670333f, -0.02300255f, 0.07570995f, -0.04399032f, 0.00598928f, 
    0.03252457f, 0.03941294f, 0.00706425f, 0.03100589f, -0.01827031f, -0.03703013f, 0.06220880f, -0.03279564f, 
    0.03280829f, 0.09987081f, -0.03865373f, -0.02704723f, 0.27479169f, 0.12699127f, 0.04639639f, -0.14574099f, 
    0.16192353f, 0.02103852f, 0.09176715f, -0.05118604f, 0.03955095f, 0.08192217f, 0.05669846f, 0.08907837f, 
    0.11161501f, -0.05743269f, 0.04352520f, -0.05239920f, -0.18593697f, 0.04575337f, 0.05616428f, -0.04966366f, 
    -0.02635074f, -0.06292494f, -0.04260900f, -0.13763314f, 0.22242799f, 0.07089504f, -0.06044918f, 0.01409943f, 
    -0.13178952f, -0.09034502f, -0.01534825f, -0.01632027f, -0.03027853f, -0.08537693f, -0.06281526f, -0.11408652f, 
    -0.49834251f, -0.41435337f, -0.20293617f, -0.07719307f, 0.03284425f, 0.05193415f, 0.01872117f, -0.16689217f, 
    0.01261133f, -0.10404237f, 0.00896979f, 0.05342203f, 0.01227262f, -0.12354466f, 0.00330427f, -0.01423963f, 
    0.13634153f, -0.03853687f, 0.02370548f, 0.01906556f, 0.01470441f, -0.01293959f, 0.01092079f, 0.09679911f, 
    -0.06903467f, 0.09473602f, 0.09079254f, 0.06818452f, -0.02481246f, 0.02430915f, 0.04444695f, -0.03756891f, 
    0.06121613f, -0.00920219f, -0.03163881f, -0.01392131f, 0.21328381f, 0.02676856f, 0.12100295f, -0.05484470f, 
    -0.14760230f, -0.04506550f, 0.08065598f, -0.11779799f, 0.01899765f, 0.03523877f, -0.15256225f, -0.02273529f, 
    -0.33253440f, -0.29514760f, 0.04400029f, 0.10366174f, 0.05101245f, 0.06539577f, 0.10039721f, -0.03912978f, 
    0.07529210f, 0.02785612f, 0.06899612f, 0.00383409f, 0.18241258f, -0.11665927f, 0.04043422f, 0.12487780f, 
    0.13056916f, -0.00830380f, 0.03139973f, -0.02911000f, -0.01313486f, -0.01903227f, -0.06436142f, 0.08339920f, 
    0.11332291f, -0.01557139f, 0.02682432f, -0.03712839f, 0.06252961f, -0.00161833f, -0.05377490f, 0.12283547f, 
    0.05740597f, 0.07902499f, 0.04920403f, 0.02621947f, 0.00753205f, 0.12465369f, -0.09864254f, 0.00490651f, 
    0.03924852f, -0.09523284f, -0.00917404f, 0.06876642f, 0.02135948f, -0.10258704f, -0.07419809f, -0.00988614f, 
    -0.00962788f, 0.04682850f, 0.11985666f, -0.09735588f, 0.07882906f, 0.02461567f, -0.02599904f, 0.05236295f, 
    0.10192616f, 0.13921118f, 0.10478342f, 0.07993875f, 0.02803643f, -0.05492535f, 0.07176526f, -0.09120701f, 
    -0.04100256f, 0.09557965f, 0.03095753f, 0.00234927f, 0.01658265f, -0.06612109f, 0.11396027f, 0.00768706f, 
    0.08392876f, 0.08097758f, -0.06171662f, 0.09139025f, -0.02439782f, -0.02691503f, 0.03337932f, -0.01475023f, 
    0.01707201f, 0.20830585f, 0.13377647f, 0.01409755f, -0.02160722f, 0.12593088f, 0.03775075f, 0.01185313f, 
    0.08690895f, 0.16866820f, -0.00205609f, -0.07109563f, -0.02327124f, 0.01962341f, 0.10361844f, 0.04872364f, 
    -0.12904243f, -0.14758545f, 0.19084698f, 0.00516137f, -0.00575389f, 0.12751073f, -0.05529046f, 0.01556509f, 
    0.02339976f, 0.05252268f, 0.03410909f, 0.03537587f, -0.17804579f, -0.30657253f, -0.06906225f, -0.02776639f, 
    0.02783131f, -0.01357796f, 0.01783220f, 0.08789193f, 0.07057706f, 0.19523005f, 0.08265495f, 0.12429190f, 
    0.03893033f, -0.03505334f, 0.07048302f, 0.08376858f, 0.01036658f, 0.02369909f, 0.01337663f, -0.04637281f, 
    0.06457035f, 0.08349136f, -0.09585109f, 0.05932836f, 0.28480136f, 0.05980803f, -0.01694719f, -0.13698362f, 
    0.09036998f, -0.02245608f, 0.01601033f, 0.04892052f, -0.08720300f, -0.00958516f, 0.01234305f, -0.01337358f, 
    -0.14045528f, -0.07474778f, -0.11009569f, 0.06342694f, 0.12836693f, 0.04070519f, 0.01282009f, -0.07319646f, 
    -0.02217801f, -0.09318959f, -0.14999059f, -0.02049808f, -0.16146693f, -0.04141068f, -0.19822313f, -0.08848747f, 
    0.15198742f, 0.02313522f, -0.00311223f, -0.03326458f, 0.08993351f, -0.03022138f, 0.03190018f, -0.07021914f, 
    -0.26839310f, -0.29966998f, -0.14002492f, -0.19233096f, 0.11989705f, -0.00029883f, 0.13791768f, -0.00441396f, 
    -0.00183141f, -0.04804615f, -0.14553392f, 0.00862908f, 0.02933239f, 0.02995558f, -0.03141034f, 0.07528462f, 
    0.01438650f, -0.00057155f, 0.03484147f, 0.00878459f, -0.03949459f, 0.04568399f, -0.00446578f, 0.05687954f, 
    0.14337875f, 0.04195006f, -0.14481799f, 0.13952717f, 0.06925736f, -0.04598705f, -0.09491378f, -0.00017770f, 
    0.08210842f, 0.11420767f, -0.03999086f, -0.05580893f, 0.50671011f, 0.20599405f, -0.15050749f, -0.02530026f, 
    -0.03794361f, -0.03017739f, -0.00315940f, 0.05184506f, 0.07124548f, -0.04568091f, 0.02390919f, 0.02461369f, 
    0.23515519f, -0.09668117f, -0.02993996f, 0.02741989f, 0.10246687f, 0.00851703f, -0.12150326f, 0.00452599f, 
    0.04678679f, -0.04966994f, -0.06174596f, -0.03021269f, -0.02586619f, -0.12652022f, -0.04361323f, -0.04962005f, 
    -0.04275147f, -0.02080044f, 0.01161708f, -0.03587074f, -0.03989942f, 0.05388601f, -0.02532106f, -0.03383708f, 
    -0.12208213f, -0.13862912f, -0.01324919f, 0.05601462f, -0.03768513f, 0.06451516f, -0.07315789f, 0.06808867f, 
    -0.12305927f, 0.10578214f, 0.07021225f, -0.21290612f, 0.24980935f, 0.07279224f, -0.07021090f, -0.07077406f, 
    -0.15334912f, -0.09876087f, -0.03639226f, -0.00616778f, -0.03318101f, 0.06594092f, 0.01797730f, -0.08514904f, 
    0.20075664f, 0.06144420f, 0.00697018f, 0.15782869f, 0.04192061f, -0.00265556f, -0.05686533f, 0.02497176f, 
    0.08863397f, 0.01605022f, 0.02963604f, -0.00960904f, -0.05748786f, -0.04286012f, -0.13369559f, 0.11538483f, 
    0.13734271f, 0.14972149f, 0.03518053f, 0.00182728f, -0.00352387f, -0.07169798f, -0.14437668f, -0.06166615f, 
    -0.14534070f, 0.16516604f, 0.07748777f, 0.04747974f, 0.08466483f, -0.05500462f, 0.05644445f, -0.08048695f, 
    0.06545042f, -0.01596503f, -0.06332817f, 0.00786329f, 0.16250360f, 0.12005254f, -0.15112178f, -0.03190534f, 
    -0.04510599f, 0.03333561f, -0.06973091f, -0.04257398f, 0.07847065f, 0.00839375f, -0.14840868f, -0.06182389f, 
    -0.09852908f, 0.11105414f, 0.01013746f, 0.01729171f, -0.08264685f, 0.00945634f, 0.04747942f, -0.09976298f, 
    0.02668950f, -0.04578193f, 0.14855209f, -0.00038127f, -0.30442590f, 0.06570575f, -0.00863428f, -0.05502317f, 
    0.06759930f, -0.20022975f, 0.05587814f, 0.05647503f, -0.03592814f, 0.02913742f, 0.08928818f, 0.02593401f, 
    -0.16858974f, -0.03067914f, 0.09229085f, -0.17831069f, -0.06077811f, -0.04173741f, -0.01803273f, 0.00589929f, 
    0.01260715f, 0.01972286f, 0.00496928f, 0.06217583f, -0.07400250f, 0.06967864f, -0.05559430f, 0.05064612f, 
    0.01346742f, 0.07152334f, -0.10346274f, -0.01567399f, -0.01489131f, 0.05030967f, -0.04547082f, 0.00494754f, 
    0.05566274f, 0.00254872f, -0.14631394f, -0.32327461f, 0.13651951f, -0.14321618f, 0.02776791f, 0.02915459f, 
    0.06723043f, 0.01989287f, 0.17341152f, 0.13121238f, 0.15433162f, -0.09702273f, 0.01876255f, -0.08977567f, 
    0.02756281f, -0.01831696f, 0.02313481f, -0.02778216f, -0.01493800f, 0.00011323f, -0.06116895f, -0.12347798f, 
    0.19778800f, -0.24785058f, 0.03163050f, -0.15552826f, 0.01099753f, -0.04035737f, -0.01978880f, 0.01216852f, 
    -0.02606614f, 0.01455041f, -0.02869967f, 0.03370322f, 0.30310583f, 0.18946256f, -0.23751515f, -0.12723038f, 
    0.00372699f, -0.03476095f, 0.01873456f, -0.05580931f, -0.02396205f, -0.01954288f, -0.07441618f, -0.07816825f, 
    0.23885791f, -0.03158894f, -0.04540364f, -0.17296743f, -0.04562036f, 0.02918937f, -0.00532163f, -0.02323598f, 
    -0.00506910f, -0.04306503f, -0.02977369f, 0.03000021f, -0.45032358f, 0.00111020f, 0.09043653f, -0.04684465f, 
    0.02824116f, 0.00850898f, 0.07160828f, 0.01916699f, -0.03230111f, 0.03548645f, 0.15318720f, 0.05292343f, 
    0.55529749f, -0.10526741f, -0.00318471f, 0.16335313f, 0.12469292f, -0.07960314f, -0.07938120f, -0.04319150f, 
    0.01715381f, 0.04801138f, 0.04580926f, 0.01395027f, 0.33703431f, -0.08330184f, -0.13134050f, 0.06121292f, 
    0.08008862f, -0.07559523f, -0.10649753f, -0.05090514f, 0.08189554f, 0.15048964f, -0.01605939f, 0.06091559f, 
    -0.02884692f, -0.25495866f, -0.09273513f, -0.16831756f, -0.15090466f, 0.07074888f, -0.04980125f, -0.05524835f, 
    -0.11080625f, 0.03147861f, -0.08672694f, -0.04364085f, 0.02945416f, 0.13733898f, -0.26142243f, 0.07232180f, 
    -0.01656117f, -0.04710231f, -0.03350808f, 0.08501105f, -0.05839908f, 0.01672497f, -0.05067114f, 0.03571068f, 
    -0.09674487f, -0.00623908f, 0.17651661f, 0.02955328f, -0.03200443f, 0.01133006f, -0.02101234f, -0.00953396f, 
    0.01149302f, 0.00303085f, 0.05604219f, 0.03376340f, -0.20765379f, -0.20083405f, -0.08907576f, -0.24265179f, 
    0.02287756f, -0.05575967f, 0.09657761f, 0.06172223f, -0.05247508f, 0.00088940f, -0.03191208f, 0.11750068f, 
    0.07532015f, -0.05631473f, -0.05474167f, -0.01635554f, 0.12312012f, 0.01133432f, -0.01199141f, 0.04482862f, 
    0.10209013f, -0.13235445f, -0.14570212f, -0.04694083f, 0.18512622f, -0.06392321f, -0.06233105f, -0.05182350f, 
    0.01531664f, 0.05709755f, -0.05925893f, 0.09400634f, -0.07148914f, -0.04492225f, -0.06154283f, 0.01150334f, 
    -0.15841258f, -0.22921686f, 0.08738159f, 0.00736476f, -0.01494131f, 0.03007671f, -0.01036848f, 0.02414816f, 
    -0.04917740f, 0.00171538f, -0.01311800f, -0.01763543f, -0.06195465f, 0.07177161f, 0.02674264f, 0.08635914f, 
    -0.04422421f, -0.20962733f, -0.00354091f, -0.09844821f, -0.02484182f, -0.10948288f, -0.02333718f, -0.05644337f, 
    -0.19850710f, 0.07495067f, 0.03851258f, 0.12002775f, 0.06737686f, 0.01003887f, -0.04287189f, -0.04487225f, 
    -0.01258776f, -0.04559374f, 0.10054109f, 0.03011838f, 0.14766441f, -0.12667049f, -0.06865739f, -0.05760394f, 
    0.09046417f, 0.00630042f, 0.01953283f, -0.12340531f, 0.09635574f, 0.03357065f, 0.01671588f, -0.00453228f, 
    0.10391273f, -0.09171639f, -0.20544145f, 0.08757364f, -0.08318384f, -0.05436156f, 0.05242530f, -0.12029378f, 
    -0.20988536f, 0.09194642f, -0.01785468f, -0.07348513f, 0.02853071f, 0.10469105f, -0.42155609f, 0.06867278f, 
    0.05040979f, -0.05850855f, 0.05291512f, 0.10563230f, -0.04138202f, 0.05839616f, -0.02930299f, -0.00751498f, 
    0.07806638f, -0.13637398f, 0.15032330f, 0.09420153f, -0.03302566f, -0.05422666f, -0.01933021f, -0.04621688f, 
    -0.09742574f, -0.05129184f, -0.07094219f, 0.00529876f, -0.16596916f, 0.04245041f, -0.01570845f, -0.10683220f, 
    0.02763326f, 0.01757338f, 0.02527105f, -0.02279615f, 0.09703360f, 0.06640778f, 0.02095847f, 0.00486953f, 
    -0.18021941f, 0.13612175f, -0.04367158f, 0.04109446f, 0.13569847f, -0.06637746f, 0.05719724f, 0.06052271f, 
    0.11387895f, 0.06359113f, 0.04680602f, 0.03823496f, -0.10904841f, -0.18283609f, -0.00704675f, -0.17576274f, 
    -0.00446430f, 0.09974911f, -0.03560933f, 0.10514860f, 0.03231988f, 0.00889948f, 0.01767515f, 0.00249019f, 
    0.04928775f, -0.16945560f, -0.04726549f, 0.19876471f, -0.05426786f, 0.00487374f, 0.02530218f, 0.03052189f, 
    0.10663249f, 0.06479752f, 0.05488089f, -0.02851825f, 0.09990543f, -0.05281605f, -0.07423662f, 0.17817569f, 
    -0.16754873f, 0.01751757f, 0.04418638f, 0.01043998f, -0.15054320f, 0.04653619f, -0.02780845f, -0.14824428f, 
    -0.31555381f, -0.26288509f, 0.07927892f, -0.01482754f, 0.11045509f, -0.00959867f, -0.01994022f, 0.02330525f, 
    0.03107283f, 0.06990141f, -0.02971640f, 0.05711786f, 0.08408536f, -0.06130547f, -0.19416249f, 0.28964436f, 
    -0.10531363f, -0.04513051f, 0.08960185f, 0.12692273f, -0.09360026f, -0.00535990f, -0.05210059f, -0.01266375f, 
    -0.01809398f, -0.20858602f, -0.12764981f, 0.08013076f, 0.09472327f, 0.02532062f, -0.00753250f, -0.04237582f, 
    -0.05273823f, -0.02165231f, 0.00217994f, -0.03460717f, 0.15556821f, -0.23331195f, 0.09554489f, -0.02763644f, 
    -0.08869701f, -0.00662319f, 0.01042130f, 0.03242688f, -0.03254120f, -0.02558308f, -0.04855907f, -0.08236612f, 
    -0.12463830f, 0.20027710f, -0.10672118f, -0.23481929f, 0.13009493f, 0.03777939f, -0.07676239f, 0.11893784f, 
    -0.00606659f, -0.08294106f, 0.07103658f, -0.01471619f, 0.07650261f, -0.03100312f, -0.15530753f, 0.16158096f, 
    0.19949812f, 0.00769708f, 0.06851509f, 0.02046627f, -0.01692364f, 0.00843113f, -0.04974565f, 0.01682979f, 
    0.04614645f, -0.08855758f, 0.06063226f, 0.08614719f, 0.00499978f, 0.09316032f, -0.03673303f, -0.05079025f, 
    -0.08736859f, -0.03716019f, 0.06151901f, -0.12282281f, -0.12461733f, 0.01681049f, 0.12217937f, -0.03460916f, 
    -0.02735132f, -0.05566848f, -0.04550319f, 0.03249155f, -0.01430132f, -0.03271709f, 0.09699294f, -0.10336675f, 
    0.07197221f, 0.21513052f, -0.02223598f, -0.10628504f, 0.02671921f, 0.01359735f, 0.06822884f, 0.10021728f, 
    -0.16546464f, -0.00629887f, -0.13475621f, -0.06426167f, -0.07595949f, 0.13387233f, -0.16420990f, 0.05401018f, 
    -0.06553825f, -0.10965181f, 0.04953686f, 0.00009385f, 0.00264882f, -0.03562008f, 0.06340451f, -0.09339035f, 
    0.12170804f, -0.00880044f, 0.05254625f, -0.07628227f, -0.02559471f, -0.04671666f, 0.02757829f, -0.07977461f, 
    -0.07200833f, -0.03208341f, -0.01536794f, -0.11542588f, -0.14096613f, -0.10506316f, 0.07615776f, 0.04244937f, 
    -0.07127855f, 0.10726011f, 0.02293616f, 0.01315991f, 0.04117658f, 0.02549697f, 0.00666669f, 0.08906291f, 
    0.21514684f, 0.09247202f, -0.22609659f, 0.09748333f, 0.07188600f, -0.08230097f, 0.05183148f, 0.12463595f, 
    -0.00618841f, -0.00565834f, -0.04108185f, -0.05863704f, 0.06473071f, 0.04008739f, -0.07252780f, 0.11366958f, 
    0.10280378f, -0.04539536f, 0.00783207f, -0.05510596f, -0.06943297f, 0.01519681f, -0.11663595f, 0.12606113f, 
    0.17153797f, 0.01699077f, 0.08153845f, 0.02361034f, 0.02366883f, 0.05396628f, -0.14610228f, -0.09697380f, 
    -0.07461648f, 0.02438275f, -0.09578912f, -0.04404131f, -0.25699437f, 0.20431799f, 0.03146254f, 0.14691161f, 
    -0.13388310f, -0.05828550f, -0.04102356f, -0.11807364f, -0.02980495f, 0.07370739f, 0.04834163f, -0.09304961f, 
    -0.00767076f, 0.19655658f, 0.00809247f, -0.03321117f, 0.04387479f, -0.16999260f, -0.07783114f, -0.10156459f, 
    -0.05409674f, -0.05705043f, 0.06279916f, 0.02177087f, -0.02373018f, -0.09749022f, 0.13312244f, 0.13713950f, 
    0.05508396f, 0.02055724f, 0.02912613f, 0.02100536f, -0.00190539f, -0.04509569f, -0.07086653f, -0.01743588f, 
    0.07123774f, -0.02371623f, 0.14714694f, -0.22442558f, 0.03448438f, -0.07497827f, -0.08553231f, 0.02498381f, 
    -0.08978342f, 0.03673227f, 0.08722571f, -0.00767946f, -0.05758447f, -0.11865012f, -0.18113944f, 0.24567458f, 
    -0.02722111f, -0.03872712f, 0.05943611f, 0.05110283f, -0.03421929f, -0.01595978f, -0.05530175f, 0.00920750f, 
    0.07602956f, -0.03616817f, -0.17224418f, 0.12653713f, -0.07256592f, -0.06414162f, -0.15969428f, -0.20874821f, 
    0.03915731f, 0.00218152f, -0.02864693f, 0.05084622f, -0.03189405f, -0.25607982f, 0.07946178f, 0.27993271f, 
    0.12920026f, 0.12933899f, -0.02513006f, 0.03940860f, 0.03519782f, -0.01389012f, 0.01919005f, 0.02056074f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02665766f, -0.01617266f, -0.05824929f, 0.00662998f, 0.04864432f, 0.03193857f, -0.01529916f, -0.03140534f, 
    -0.03827212f, 0.02219228f, 0.06893915f, -0.00045749f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
