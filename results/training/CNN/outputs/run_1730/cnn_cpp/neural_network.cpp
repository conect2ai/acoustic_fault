#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.84165782f, -0.65853035f, -0.53543836f, -0.74223673f, -1.13330424f, -0.25443450f, -0.23308034f, -0.48792389f, 
    0.53059673f, -0.57635897f, -0.49331376f, 0.06490318f, 0.58993518f, 0.19071272f, 1.01882493f, 0.63445568f, 
    0.64004993f, 1.04820156f, 1.21754229f, 1.27979112f, 0.18030277f, -0.98690200f, -0.71653026f, -1.04340112f, 
    0.22947706f, 0.44316497f, 0.86042684f, 0.02306300f, 0.83935487f, -0.19115348f, 0.98890597f, 0.78323436f, 
    0.56381470f, 0.01681965f, 1.11275792f, -0.80431825f, -0.41343680f, -1.51422369f, -1.83195043f, 0.52474105f, 
    0.63266951f, 0.78305453f, 0.34163913f, 0.37016132f, 0.06481774f, 0.51593006f, 0.50721216f, 1.26238978f, 
    -0.81124997f, -0.31844649f, 0.51096183f, 0.54251629f, 0.20249969f, -0.16739963f, 0.08566731f, 0.72441685f, 
    -0.44913152f, -0.43180484f, 0.41137213f, 0.32241440f, 0.46124166f, 0.35911804f, 0.48536289f, -0.35033351f, 
    -0.35223198f, -1.24742150f, 0.91180444f, -0.10219245f, -0.69528735f, -1.17553699f, -0.91553247f, -0.73427576f, 
    0.57442951f, -1.07625508f, -0.90481395f, -1.31758726f, -0.40411484f, -1.53785133f, -0.05008447f, 0.52444112f, 
    0.45950612f, -1.33491004f, -0.56621385f, -0.49754310f, 0.49902138f, -0.28548583f, 1.51296961f, -0.58912611f, 
    -0.71456891f, -0.57635039f, -1.26753986f, -0.49009842f, 0.96040434f, 0.61400187f, -1.60871577f, -1.57191658f, 
    -0.33542350f, 0.07451432f, -0.11870483f, 0.45039594f, -0.31220239f, 0.38004768f, 0.85383129f, -0.61992502f, 
    -0.62435567f, -0.23977621f, 0.89450431f, -0.71909195f, -0.36471292f, 0.01169838f, 0.75087279f, 0.36572492f, 
    0.56360734f, 0.39576468f, -0.02380133f, -1.03583157f, -0.26375946f, 0.00245280f, 0.53875232f, -0.12590569f, 
    0.51223183f, -0.62135798f, -0.09602644f, 0.50230688f, -0.69687116f, 0.29099622f, -0.50904149f, -1.40477443f, 
    1.61368334f, -0.70034957f, 0.28083462f, 0.30012918f, 0.08226077f, 0.09683066f, 0.80332273f, -0.60470980f, 
    -0.69987667f, 0.91296721f, -0.80771255f, -0.94905090f, -0.64736247f, 0.64108980f, 0.98915792f, 0.69896573f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.45191419f, 0.00587158f, 0.57167423f, -0.17469206f, 0.68000841f, -0.12287153f, 0.54116911f, 0.38663259f, 
    -0.17605871f, -0.58388835f, 0.84955460f, 0.50438535f, 0.40710971f, 0.99175471f, -0.05178020f, -0.11121369f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.44482109f, 0.23860985f, -0.08079578f, -0.15343212f, -0.00231471f, -0.06211896f, -0.07042534f, -0.02851320f, 
    0.05990621f, -0.13507423f, -0.01281678f, -0.26594716f, -0.10252392f, -0.05145335f, 0.07243569f, 0.07827623f, 
    -0.10404344f, 0.03334076f, 0.27567163f, 0.48077253f, -0.35039663f, 0.17675830f, -0.03585783f, 0.09818913f, 
    -0.12743841f, -0.15830766f, 0.06990889f, 0.07749204f, 0.14628573f, 0.26717827f, -0.03989276f, -0.27460623f, 
    -0.06588296f, -0.15199512f, -0.07766733f, 0.22088723f, -0.39944869f, -0.62462860f, -0.51653612f, -0.01267535f, 
    0.21151991f, 0.27780032f, -0.18650551f, 0.12516741f, 0.06021196f, 0.38214871f, 0.15189244f, -0.15799960f, 
    -0.05201935f, -0.15569423f, -0.26836309f, 0.03314341f, -0.13547286f, -0.19815394f, 0.12789805f, 0.11782294f, 
    0.03507064f, -0.02754362f, 0.11145380f, -0.04372127f, 0.08208345f, 0.09905197f, -0.11683767f, -0.28595838f, 
    -0.82076883f, -0.47288013f, -0.02330667f, 0.15937401f, -0.20712544f, -0.04127562f, 0.15605718f, 0.08700407f, 
    -0.12089561f, -0.71099091f, -0.12565538f, -0.02858905f, -0.06882474f, 0.17804317f, 0.06003704f, -0.30290538f, 
    0.10370052f, -0.53116959f, 0.41300970f, -1.16321695f, 0.19262955f, -0.19174433f, -0.09841318f, -0.07537343f, 
    -0.04279727f, 0.21624386f, -0.92370719f, -0.25385663f, 0.35137427f, 0.00826811f, 0.17503928f, -0.15151133f, 
    -0.12517513f, 0.17324209f, -0.04374711f, 0.07059388f, 0.23992215f, 0.30984449f, 0.10113853f, 0.05859742f, 
    -0.07694684f, 0.12724809f, 0.40111715f, 0.21124861f, -0.03900262f, 0.24763638f, 0.14588284f, 0.08082377f, 
    0.09938024f, -0.20069961f, 0.13632654f, 0.14935377f, 0.56202722f, 0.20242153f, 0.57642782f, 0.36554945f, 
    0.08078820f, 0.12326866f, 0.41879418f, 0.20354228f, 0.43025884f, -0.00989157f, -0.36976603f, -0.21738550f, 
    -0.03400732f, -0.02270755f, 0.19618396f, -0.08721583f, 0.18808657f, -0.15192436f, 0.08030479f, -1.00837421f, 
    -0.53293765f, 0.26273304f, 0.05847247f, -0.15615410f, -0.36907339f, 0.08829204f, -0.01248467f, -0.09946205f, 
    -0.04149281f, 0.19366267f, 0.45144528f, -0.35262403f, 0.04165411f, -0.04922494f, -0.05806193f, 0.06604552f, 
    -0.19456074f, -0.04139560f, 0.03790171f, 0.22135447f, -0.20885758f, -0.08523614f, -0.10278919f, 0.14831850f, 
    -0.21839853f, -0.12642071f, 0.14151455f, -0.48800412f, -0.01453196f, -0.02142109f, 0.16490149f, -0.02076555f, 
    -0.08174042f, 0.07245950f, -0.03427392f, -0.03518566f, -0.00224038f, 0.48686203f, -0.28000423f, 0.01152546f, 
    -0.09319974f, 0.12678365f, 0.05700669f, 0.20524849f, -0.08755942f, -0.05123301f, 0.41631305f, 0.13640745f, 
    -0.03436951f, -0.47508642f, 0.11513191f, 0.08008867f, 0.16193038f, -0.23932686f, -0.15792854f, -0.03955748f, 
    -0.07632744f, 0.06934806f, -0.00863273f, 0.23773654f, -0.15828297f, -0.06120833f, -0.31133306f, -0.02868932f, 
    0.19760226f, -0.25024587f, 0.29043707f, 0.24893314f, 0.09161231f, -0.12955046f, -0.09122200f, -0.48037478f, 
    0.04968598f, 0.18992418f, -0.08841559f, 0.17460705f, -0.01759478f, 0.14208663f, -0.04638033f, 0.01308743f, 
    -0.07542701f, 0.28503558f, 0.27905387f, -0.04779046f, 0.10271230f, -0.39522162f, 0.05251038f, -0.08912826f, 
    -0.13141568f, -0.62517864f, -0.50110674f, 0.49305862f, -0.17960711f, 0.05438258f, -0.14278436f, 0.18739545f, 
    0.07963359f, -0.10334924f, -0.20528103f, -0.20325252f, -0.02913785f, 0.04734212f, 0.04249178f, 0.15469055f, 
    0.08704593f, 0.17525294f, -0.02716097f, -0.08784005f, -0.04958548f, 0.78602737f, -0.21215947f, 0.30357724f, 
    0.02202164f, -0.22581744f, -0.06872008f, 0.00663198f, -0.22492354f, -0.36614388f, 0.10747991f, -0.20896068f, 
    -0.12828109f, 0.04067539f, 0.26815075f, -0.22760919f, 0.09065147f, 0.33875114f, -0.30511576f, 0.14416379f, 
    0.03588745f, 0.23121536f, 0.08297638f, 0.00762412f, -0.00164662f, -0.00962839f, -0.08380004f, -0.60077542f, 
    -0.29340813f, -0.12727435f, -0.06551612f, 0.21551134f, -0.26953828f, -0.03784893f, -0.04717632f, -0.28145891f, 
    0.18351643f, 0.27125946f, -0.03036301f, -0.02302585f, -0.08317201f, -0.13022763f, 0.01889459f, -0.03709446f, 
    -0.06518728f, -0.07517242f, 0.05151021f, 0.04436581f, -0.05789142f, 0.04149628f, -0.02864464f, 0.01944141f, 
    -0.03293323f, -0.07199840f, -0.01733697f, -0.07669815f, 0.02261456f, -0.00479766f, -0.00337552f, 0.05735084f, 
    -0.02581811f, -0.00711520f, -0.01037341f, 0.00690027f, 0.02353235f, 0.04355450f, -0.09696422f, 0.05404470f, 
    -0.07160083f, -0.06522869f, -0.00037772f, -0.02616602f, -0.01854899f, 0.00757425f, 0.03449846f, -0.03474908f, 
    0.05061835f, 0.02925212f, 0.05236641f, 0.06076077f, -0.03968810f, -0.00721910f, -0.03753169f, -0.09899428f, 
    -0.07198738f, -0.03861170f, -0.09053031f, 0.04701706f, 0.05833406f, -0.01653999f, 0.02194994f, -0.04032699f, 
    0.01553273f, 0.05884257f, -0.05504676f, -0.02346580f, 0.04588400f, 0.04301766f, -0.08936594f, 0.02396372f, 
    -0.07506370f, 0.03289499f, -0.09780626f, -0.08596594f, -0.08098453f, 0.00464456f, 0.03151066f, -0.03414333f, 
    -0.09432532f, 0.04007952f, 0.03443244f, 0.07195337f, -0.05736258f, -0.09554595f, -0.04313035f, 0.00404649f, 
    -0.05985327f, 0.03690838f, -0.07098526f, -0.02139551f, -0.06706548f, 0.01343776f, 0.05620215f, -0.03839099f, 
    0.00821326f, -0.06375336f, -0.05707812f, -0.00597942f, 0.04213127f, -0.06270713f, 0.06317099f, -0.01862978f, 
    0.04539042f, -0.03548661f, 0.06201323f, 0.00008243f, 0.01986215f, -0.03245429f, -0.07320919f, -0.04534169f, 
    0.00577526f, 0.07811409f, -0.02286097f, -0.05137941f, 0.01088752f, -0.06035061f, 0.00115379f, 0.01348824f, 
    -0.00142194f, 0.03833551f, 0.07048208f, -0.05890365f, 0.03146526f, -0.04524073f, 0.01030098f, -0.00972343f, 
    0.00682816f, 0.02219350f, 0.03810446f, -0.03270049f, -0.02414915f, -0.06670925f, 0.05615324f, -0.04021458f, 
    -0.03425997f, 0.03253244f, -0.08863766f, -0.04746806f, -0.07587157f, 0.00465498f, -0.07481684f, -0.02281849f, 
    0.01970750f, -0.08709392f, -0.09658761f, 0.03100696f, -0.04790721f, 0.04540594f, 0.02141266f, 0.06456130f, 
    -0.05513509f, -0.09482650f, 0.07714936f, 0.03727761f, 0.03939001f, -0.02901788f, -0.06279736f, 0.03989369f, 
    0.00492607f, 0.23980060f, 0.07060572f, 0.16786619f, 0.09877029f, -0.10304029f, 0.02916586f, 0.07120643f, 
    -0.03043810f, 0.16812348f, 0.23117237f, 0.28125921f, -0.08883761f, -0.33992258f, -0.13510890f, 0.06327394f, 
    -0.09537693f, 0.22681817f, -0.45435774f, 0.50647497f, 0.06512234f, -0.02062317f, 0.08810171f, 0.17096047f, 
    -0.11206178f, -0.06153105f, -0.00107920f, 0.32316598f, 0.32686624f, 0.12579821f, -0.62368554f, -0.34782946f, 
    -0.54053044f, 0.18156272f, 0.08634606f, 0.03668141f, 0.24625486f, -0.47292224f, 0.23436064f, 0.02778154f, 
    -0.26263523f, -0.08804453f, 0.10484605f, 0.14927025f, 0.18525627f, -0.51462072f, -0.15404609f, -0.05865266f, 
    0.00327137f, 0.16428073f, 0.09523043f, 0.18413101f, 0.15983981f, -0.07103128f, -0.31346378f, 0.23387314f, 
    0.05228670f, -0.02681030f, 0.15511805f, -0.15952954f, 0.08807082f, 0.14942333f, -0.13534307f, 0.02316810f, 
    -0.55532825f, -0.04315211f, -0.11848058f, -0.01084074f, -0.17509593f, 0.18971059f, -0.22607948f, -0.11325873f, 
    0.21580398f, -0.14958213f, 0.95892894f, -0.05358605f, -0.05264936f, -0.02118616f, 0.11945873f, -0.27000171f, 
    -0.14563547f, 0.12685755f, 0.09434830f, 0.03840128f, 0.09204653f, -0.16569558f, -0.22206928f, -0.07125381f, 
    0.20986927f, 0.01415785f, 0.55284101f, -0.25115469f, -0.32950193f, -0.11753075f, 0.08265790f, -0.24734282f, 
    -0.01711415f, -0.13690248f, -0.01871330f, 0.02484501f, 0.20469093f, 0.53882366f, -0.21993619f, 0.28386137f, 
    -0.12717025f, 0.08643162f, 0.58661139f, -0.01641341f, 0.13863225f, 0.03898562f, 0.03575569f, -0.39377442f, 
    -0.41096890f, -0.29011396f, 0.07853629f, 0.16848543f, 0.21910240f, -0.29033789f, 0.10399786f, -0.17813228f, 
    0.12013953f, 0.08168119f, -0.23243159f, -0.05877779f, 0.35706544f, -0.09638897f, -0.39559504f, 0.50639468f, 
    -0.14553975f, -0.15346520f, 0.02447645f, -0.02837857f, -0.23898320f, 0.05318566f, -0.22446814f, 0.16517249f, 
    0.22761104f, -0.15807548f, -0.22589426f, -0.00005466f, 0.21203299f, 0.02403852f, -0.22230804f, 0.16032201f, 
    -0.52305871f, -0.31527036f, -0.18863817f, -0.08913557f, -0.16254939f, -0.43162364f, -0.17344345f, -0.00576246f, 
    0.04827118f, -0.11556055f, 0.00991232f, 0.05976637f, -0.21429120f, -0.04755142f, -0.29524276f, -0.00215486f, 
    -0.26713854f, 0.31657010f, -0.13287006f, -0.03004174f, -0.09861580f, 0.06966297f, 0.17693698f, -0.02568155f, 
    0.08766908f, 0.07434478f, 0.06368393f, -0.23663861f, -0.15400091f, 0.01762344f, -0.06019753f, 0.03917712f, 
    -0.46583784f, 0.03164102f, 0.07381575f, 0.10330714f, -0.38752919f, 0.21988399f, 0.64398623f, 0.07511288f, 
    0.12976605f, 0.37029988f, -0.00973321f, 0.11125111f, 0.04030604f, -0.23586795f, -0.17037168f, -0.73917073f, 
    -0.34359995f, -0.23065129f, -0.11467104f, -0.22595757f, 0.01677266f, 0.03836768f, 0.26434165f, -0.25513232f, 
    -0.15431857f, 0.01806275f, -0.17796412f, 0.20674755f, 0.08053417f, 0.12660308f, 0.13070069f, -0.28791931f, 
    0.27547297f, 0.16340715f, -0.09634262f, 0.19288316f, 0.00814736f, 0.18746246f, 0.03042622f, -0.20095350f, 
    -0.79141092f, -0.20077524f, -0.06294236f, -0.00330048f, -0.02329922f, -0.31353140f, 0.03449394f, 0.22778906f, 
    -0.13122611f, -0.54929245f, 0.00610803f, 0.37304211f, -0.04025441f, -0.13704664f, -0.23055111f, -0.13900900f, 
    -0.11634467f, 0.01615790f, -0.08566085f, -0.07247458f, 0.20575491f, 0.31770095f, -0.08759041f, -0.35650480f, 
    0.07598861f, 0.04807195f, 0.15190478f, -0.58621049f, 0.28856674f, 0.62188143f, -0.09876571f, 0.04517093f, 
    -0.24528657f, 0.13094711f, 0.20742898f, 0.32802895f, 0.00823460f, -0.35665312f, 0.04161337f, 0.01327232f, 
    0.03892567f, -0.01780964f, 0.24617817f, 0.15066241f, -0.22044346f, 0.26171517f, 0.28550872f, 0.17873187f, 
    0.01004001f, 0.03654397f, 0.58005750f, 0.19079435f, 0.25532416f, 0.31574619f, 0.80360878f, 0.21400005f, 
    -0.11451299f, 0.03152475f, 0.00125139f, 0.24173656f, 0.00983031f, 0.13370058f, -0.05475330f, 0.03522404f, 
    -0.55110490f, -0.88715774f, -0.12443704f, 0.10185830f, -0.00797008f, 0.14764898f, -0.11618296f, 0.03202131f, 
    -0.41065925f, 0.22027007f, -0.19398229f, 0.10116389f, -0.23906958f, -0.20267482f, 0.05636536f, 0.08835465f, 
    0.04331439f, -0.32745451f, 0.31299275f, 0.24916856f, -0.01249254f, -0.08373272f, -0.01830877f, 0.00011623f, 
    0.08666931f, -0.06978576f, 0.82319498f, 0.10425159f, -0.70239264f, 0.09190457f, 0.05546965f, 0.22811499f, 
    0.07583357f, 0.03277274f, -0.27561092f, -0.42475924f, -0.20098077f, 0.19170155f, -0.01215927f, -0.13903798f, 
    -0.09966779f, 0.15637510f, 0.35513961f, 0.13427708f, -0.73067588f, 0.61212498f, 0.53308094f, 0.07178748f, 
    -0.08022884f, -0.09812573f, 0.08149381f, 0.38288996f, 0.30184227f, 0.36504415f, -0.43987516f, -0.47713652f, 
    -0.07967809f, 0.13171676f, -0.21074101f, -0.16609852f, 0.06421139f, -0.01979466f, 0.16131450f, 0.17551002f, 
    0.06514437f, 0.13394970f, 0.27597952f, 0.28642786f, -0.14409108f, 0.16658528f, -0.20730218f, 0.41554511f, 
    -0.30295524f, -0.24360833f, -0.02755835f, -0.01633167f, 0.23895641f, 0.06473517f, 0.32522243f, 0.33219218f, 
    0.15838563f, -0.14513928f, -0.49667004f, -0.11644950f, -0.25903869f, -0.41480666f, 0.11939143f, -0.14840038f, 
    -0.16033500f, 0.01720114f, 0.03633053f, -0.12630999f, -0.63460046f, -0.31559077f, -0.02735370f, -0.06589420f, 
    0.21757080f, 0.19554196f, -0.78736395f, -0.94594622f, -0.48093605f, 0.10606043f, 0.07463805f, 0.05372157f, 
    0.15827565f, 0.04717421f, -0.06291074f, -0.05958688f, -0.76457095f, 0.29985324f, 0.21504609f, 0.25539365f, 
    0.27778333f, 0.49434081f, -0.05311578f, 0.29073822f, -0.32045722f, 0.23265038f, 0.16881451f, 0.03448528f, 
    -0.00952167f, -0.02976456f, 0.25061667f, 0.00911304f, 0.66115749f, 0.21485080f, -0.11399427f, 0.38064456f, 
    0.18049769f, 0.23028666f, 0.05913354f, 0.21528921f, 0.07421754f, -0.02837262f, -0.27377528f, -0.02005183f, 
    -0.08989756f, -0.09777758f, -0.11481942f, 0.20591556f, 0.08076186f, -0.33494934f, -0.20766921f, -0.16455936f, 
    0.09768284f, -0.43042231f, -0.22254664f, -0.30655485f, -0.28591764f, -0.38992655f, -0.25760865f, -0.09903939f, 
    0.32455227f, 0.29159150f, 0.12044483f, -0.00462902f, 0.20241331f, 0.10939046f, 0.08818527f, -0.16514011f, 
    -0.05539386f, 0.17331682f, -0.20427509f, -0.20993689f, 0.21531920f, 0.01213331f, 0.00126362f, -0.34190375f, 
    0.01229867f, 0.06954676f, -0.07860389f, 0.00086164f, 0.24987507f, 0.14140193f, -0.07795584f, -0.22073585f, 
    -0.08046311f, -0.01278138f, -0.28119782f, 0.12392984f, 0.36834881f, 0.06725407f, -0.20030659f, -0.08001425f, 
    0.20291536f, 0.11184683f, -0.26897293f, 0.23528999f, 0.28310448f, -0.19590722f, 0.16071859f, 0.24498114f, 
    0.12696572f, -0.00449437f, -0.14537969f, 0.09831011f, 0.11921890f, 0.20557627f, 0.06195229f, -0.19411245f, 
    -0.20415632f, 0.14506058f, -0.30226880f, 0.31685781f, -0.03157944f, -0.08827186f, -0.25323907f, -0.13750355f, 
    -0.29424191f, -0.07387309f, -0.09648416f, -0.08917033f, -0.14662173f, -0.18821464f, -0.37137818f, -0.00568081f, 
    -0.30863908f, 0.14058667f, 0.03864760f, 0.04885316f, -0.02820987f, -0.25847122f, 0.00231552f, 0.27866605f, 
    0.19016694f, 0.47881135f, 0.30224454f, 0.10787659f, 0.22912073f, -0.11517517f, -0.12532957f, 0.05979974f, 
    -0.05390790f, 0.37666595f, -0.77642852f, 0.09795834f, -0.23882949f, 0.40544575f, 0.26016706f, 0.02941143f, 
    0.08544280f, 0.15508842f, 0.46602809f, 0.02363447f, -0.17274663f, -0.26088133f, 0.03417006f, 0.07736431f, 
    0.00219168f, 0.14107014f, 0.04352318f, -0.04886528f, -0.07101767f, 0.01958366f, -0.16833967f, 0.18486220f, 
    0.12164263f, 0.19518465f, -0.25360119f, -0.11642519f, 0.54773575f, -0.00375905f, -0.39720595f, -0.14183569f, 
    -0.14840092f, 0.07232307f, 0.07919665f, -0.02959563f, -0.00408687f, -0.24124372f, -0.28093430f, -0.37459663f, 
    0.06069637f, -0.09438534f, -0.16532931f, -0.16623659f, 0.08089408f, -0.48038507f, 0.29715511f, 0.12460730f, 
    -0.04986749f, 0.09523351f, -0.17891069f, 0.00972884f, 0.32516608f, -0.12056657f, -0.32630411f, 0.43166554f, 
    0.39262241f, 0.25090632f, 0.15009469f, -0.08942690f, -0.50350672f, 0.23481338f, 0.02198412f, -0.40548968f, 
    -0.41506615f, -0.28233066f, -0.38607183f, 0.24437018f, 0.21475360f, 0.21575311f, -0.12237000f, -0.05974589f, 
    -0.11763725f, -0.08008579f, -0.17798269f, 0.00871440f, 0.12188160f, 0.11795148f, 0.33348975f, -0.04346379f, 
    -0.06678262f, -0.46887058f, 0.12845035f, 0.35119623f, -0.05214485f, 0.12600249f, -0.14684612f, -0.07939733f, 
    0.12298563f, -0.37365115f, -0.09405632f, -0.10104536f, -0.21668477f, -0.16495143f, 0.24800298f, 0.09649102f, 
    0.23558147f, 0.17721048f, -0.21862805f, -0.22205158f, -0.26188216f, -0.31476226f, 0.66097528f, -0.25335535f, 
    0.07819827f, 0.14415582f, 0.10553709f, -0.02246412f, 0.08072943f, 0.32210940f, 0.26535472f, -0.09765572f, 
    0.04179263f, 0.04444150f, 0.13675538f, 0.25089732f, -0.03927855f, -0.16186146f, 0.01169658f, -0.06682951f, 
    -0.07746147f, 0.12842582f, 0.01341196f, 0.07977203f, -0.17457338f, -0.12547188f, -0.24587342f, -0.38167083f, 
    -0.16103676f, 0.39794022f, 0.33034921f, 0.13188948f, -0.05486166f, -0.16610482f, 0.23625922f, 0.27004343f, 
    -0.37673649f, 0.03927328f, -0.11416727f, 0.19528864f, 0.44903889f, 0.05093852f, 0.01111719f, -0.07188957f, 
    -0.18374690f, -0.10841227f, -0.11511118f, -0.53404117f, 0.20998587f, -0.15604502f, 0.44485363f, 0.08466612f, 
    -0.02043082f, 0.17354096f, 0.27338675f, 0.05997274f, 0.28642723f, 0.01605187f, -0.04628359f, -0.21754563f, 
    -0.06756445f, 0.25540268f, -0.02851021f, 0.39377353f, 0.09722812f, -0.43016955f, -0.10713950f, 0.08811523f, 
    0.31141549f, 0.13021386f, 0.03523493f, 0.10721689f, 0.05831439f, 0.08772088f, -0.55318171f, 0.19807495f, 
    0.15201463f, 0.08470084f, 0.12349969f, 0.23733357f, 0.08413272f, 0.18708618f, 0.10881197f, 0.14866546f, 
    0.06884636f, 0.18215263f, 0.17680244f, 0.08589683f, 0.16046594f, 0.18138073f, 0.18529196f, -0.23900123f, 
    -0.17891371f, 0.04011922f, 0.30257931f, 0.05088125f, -0.03827052f, 0.22191024f, 0.06227810f, -0.10687454f, 
    -0.42738551f, -0.13817078f, -0.02416488f, 0.13162813f, -0.02674655f, -0.19832329f, -0.37765127f, -0.50899100f, 
    -0.37131318f, 0.36887044f, 0.00614479f, -0.06327102f, -0.06115570f, -0.23962337f, 0.18152018f, -0.07177348f, 
    -0.28804347f, 0.01735271f, 0.20259522f, -0.19433904f, -0.11254369f, -0.02449210f, 0.02740187f, 0.12133817f, 
    -0.09513988f, 0.14218949f, -0.12096288f, -0.93530840f, 0.19959839f, 0.15374787f, 0.15099485f, 0.18812014f, 
    0.09513154f, -0.17030935f, 0.20424059f, 0.14290968f, 0.14700967f, 0.11778335f, -0.16789591f, -0.18703865f, 
    -0.25151071f, -0.20275310f, -0.19808091f, -0.03928319f, -0.06285210f, 0.40003154f, 0.21472555f, -0.14671034f, 
    -0.08409415f, 0.05791113f, 0.04306337f, 0.05366114f, -0.02011910f, 0.42304629f, -0.21467176f, 0.18759553f, 
    -0.10303702f, -0.04572667f, -0.12982373f, 0.05111606f, 0.07016910f, 0.12532458f, 0.15784185f, -0.13710392f, 
    0.04208133f, 0.41133514f, 0.16155306f, 0.15591198f, 0.03539582f, 0.07634417f, 0.18815531f, -0.29315007f, 
    0.34763274f, 0.01588002f, -0.09993355f, -0.10364998f, -0.06682387f, 0.04536578f, -0.20106097f, 0.07448669f, 
    -0.26077250f, -0.03377370f, -0.74393082f, 0.04133401f, -0.08648012f, -0.01958326f, 0.07684312f, -0.05494425f, 
    -0.15600473f, -0.80672759f, 0.19662695f, 0.00403471f, -0.00893676f, -0.19744402f, -0.28256792f, 0.14055100f, 
    -0.05064320f, -0.22086990f, -0.23197363f, -0.17013983f, 0.30078450f, 0.13426676f, 0.08109040f, -0.00245662f, 
    0.15796615f, 0.00012071f, -0.01364117f, 0.20473485f, -0.37466565f, -0.07726327f, -0.08417249f, 0.14127469f, 
    0.22889076f, 0.03450100f, -0.09079575f, 0.16993314f, 0.24070509f, -0.07128352f, 0.11315405f, -0.11159296f, 
    0.16354017f, -0.21590659f, 0.28039813f, -0.35364956f, 0.15113294f, 0.16289587f, 0.26570085f, 0.22151180f, 
    0.08490863f, 0.24331950f, 0.27294785f, 0.05610085f, 0.09622663f, 0.04403944f, 0.17246747f, 0.35045114f, 
    -0.22378477f, -0.22684774f, 0.24767891f, 0.19207604f, 0.08757309f, 0.26344329f, 0.06492592f, -0.73190033f, 
    -0.02756712f, -0.16583416f, 0.09166481f, 0.11032408f, 0.05128590f, -0.00219345f, -0.07812889f, 0.12875518f, 
    0.15231664f, 0.22414568f, 0.22893742f, 0.08408551f, -0.20987070f, 0.08682283f, 0.31543159f, 0.26029849f, 
    0.24770914f, -0.10060818f, 0.03567275f, -0.02684672f, -0.02924839f, 0.09454372f, -0.12631316f, 0.20096682f, 
    0.29200435f, 0.10676869f, 0.05799747f, 0.36386472f, 0.23406918f, 0.03757839f, -0.04082089f, -0.04204723f, 
    0.08978473f, 0.23083691f, 0.26484957f, 0.03582647f, -0.16228653f, 0.22726294f, 0.33733085f, -0.11476581f, 
    -0.03742352f, 0.08812093f, -0.01917930f, 0.11239778f, -0.36191115f, -0.42015460f, -0.36263415f, -0.11345398f, 
    -0.02921785f, -0.10846873f, 0.09399388f, 0.04066096f, 0.00881909f, -0.01054956f, 0.60996062f, 0.31469798f, 
    -0.05657563f, -0.26677158f, -0.44202146f, -0.03947553f, 0.18227820f, 0.01856838f, -0.13071238f, -0.05167734f, 
    -0.15642208f, 0.10460808f, 0.03881414f, 0.07768808f, 0.24723952f, 0.21476968f, 0.14325298f, -0.04363601f, 
    -0.02136442f, -0.02897991f, -0.00218754f, -0.05018294f, -0.21864556f, -0.07738712f, 0.00711168f, -0.36194569f, 
    0.11031439f, 0.05008042f, 0.36966166f, 0.05353659f, 0.01935195f, 0.17765333f, 0.15602092f, 0.19115503f, 
    0.09792510f, -1.08331895f, 0.47378567f, -0.53815782f, 0.08275702f, -0.10031363f, -0.30224019f, -0.24452211f, 
    -0.28862333f, -0.00071051f, -0.52420086f, -0.06607070f, 0.70425433f, -0.20007792f, 0.13506873f, -0.18562125f, 
    -0.00613427f, -0.07256577f, 0.10880356f, 0.08199690f, 0.21862224f, 0.92122132f, -0.16762379f, 0.08762666f, 
    0.01059159f, 0.04156170f, -0.04298500f, 0.13780421f, -0.42357892f, 0.07500844f, 0.19238462f, -0.02433600f, 
    0.18397735f, -0.25815788f, 0.09593339f, -0.01934009f, -0.27674860f, 0.05677133f, 0.22677292f, 0.56711650f, 
    0.01775853f, -0.12799494f, 0.13872062f, 0.08595605f, 0.05105200f, 0.30552119f, -0.09205121f, -0.48369366f, 
    0.01020092f, -0.16031162f, 0.24762522f, 0.22443989f, -0.00587532f, 0.03346639f, 0.20645128f, -0.01055517f, 
    -0.02965018f, 0.15089411f, -0.05284564f, 0.06488391f, -0.12034544f, 0.17312738f, 0.07454567f, 0.07822269f, 
    0.07040980f, -0.02086210f, 0.06951675f, -0.02826713f, 0.04098904f, 0.02788370f, 0.02749815f, 0.03487245f, 
    -0.03588464f, -0.06241393f, -0.01804080f, -0.05048166f, -0.08724307f, 0.04895123f, 0.03908674f, 0.00167603f, 
    0.06785836f, -0.07447489f, -0.05869360f, -0.06459912f, 0.02214146f, -0.07710303f, -0.00365944f, -0.05886104f, 
    -0.02182563f, 0.02071016f, 0.00330148f, 0.02745768f, -0.05698919f, -0.08318251f, -0.01890072f, 0.03430428f, 
    -0.03105609f, -0.04521544f, 0.01415932f, -0.01006580f, 0.00110570f, -0.07381848f, -0.00965364f, -0.04299087f, 
    0.00066604f, 0.00607295f, 0.00527775f, 0.05213348f, 0.01754156f, -0.06235886f, 0.02041268f, -0.06812061f, 
    -0.04132506f, 0.06182947f, -0.04372120f, -0.06138628f, -0.07114412f, 0.05838863f, 0.01004716f, 0.04598752f, 
    -0.04587516f, -0.07443269f, 0.06722384f, -0.02810609f, -0.03412251f, 0.02891806f, -0.05304350f, 0.04892540f, 
    -0.03609239f, -0.04073429f, 0.01436494f, 0.07754540f, -0.07577290f, -0.08307029f, -0.03203038f, 0.02707490f, 
    -0.08087300f, 0.05899739f, -0.05376818f, -0.05461773f, -0.08111193f, 0.05806754f, -0.02586607f, -0.05962496f, 
    0.02443009f, -0.05074789f, 0.08129776f, -0.00584531f, -0.06488831f, -0.02871811f, -0.01096062f, -0.03734963f, 
    0.03666861f, -0.02186269f, -0.08097382f, 0.07032830f, -0.07651985f, -0.06580956f, -0.05401607f, 0.01301170f, 
    0.01378952f, -0.04704210f, -0.08143272f, -0.05525036f, -0.02201460f, -0.06412214f, 0.05942241f, -0.04165519f, 
    0.06946897f, -0.00510815f, -0.00192709f, 0.07622378f, 0.07086536f, -0.08417203f, -0.05605377f, -0.03781190f, 
    0.03510776f, 0.07163231f, -0.01933732f, -0.03424253f, -0.03210320f, 0.02612849f, -0.01546953f, -0.04914804f, 
    -0.01480362f, 0.07398725f, -0.03511472f, 0.00237599f, 0.00585229f, 0.06583466f, -0.06251174f, -0.07460821f, 
    0.05449768f, -0.00845650f, 0.01788806f, -0.01079344f, -0.03725435f, -0.08776648f, -0.00397017f, 0.03449334f, 
    -0.06855285f, -0.00193727f, 0.04812699f, 0.03619207f, -0.04708730f, -0.08056577f, -0.01854473f, -0.05288738f, 
    -0.09885972f, -0.21015944f, -0.06190379f, 0.09818515f, -0.03634997f, -0.17216469f, -0.14129035f, -0.13550024f, 
    0.20248002f, 0.20383394f, 0.10640324f, -0.14669470f, -0.13475345f, -0.16467549f, -0.08208793f, 0.30885506f, 
    0.01987109f, 0.14895931f, -0.56018752f, -0.16687530f, 0.28028610f, -0.09093582f, 0.11783261f, -0.11211532f, 
    0.14101036f, 0.09497812f, 0.16574082f, 0.03465290f, -0.06869936f, 0.23421590f, -0.34704900f, -0.18823181f, 
    0.06551838f, 0.10848517f, -0.00606690f, 0.34627348f, 0.30212060f, 0.31440151f, 0.07006749f, -0.25584301f, 
    0.29803666f, 0.10182019f, 0.06105846f, -0.01024563f, 0.02024397f, -0.15582044f, -0.17176628f, -0.04731965f, 
    -0.23959920f, 0.02127886f, -0.01298878f, -0.07425432f, -0.23983121f, -0.19161841f, -0.07209255f, -0.23273334f, 
    -0.18825619f, -0.07357828f, -0.28746536f, 0.19403420f, 0.13039303f, -0.02073620f, 0.06372605f, -0.34146556f, 
    -0.03245639f, 0.10476743f, 0.15118602f, -0.22802499f, 0.01080122f, 0.09103895f, 0.01512178f, -0.13132519f, 
    0.06795496f, -0.38518894f, 0.06292681f, 0.14705554f, -0.03269178f, -0.08294962f, 0.03469029f, -0.03831970f, 
    -0.13412480f, -0.06344186f, -0.48439744f, -0.49358109f, 0.10109851f, -0.01656645f, -0.24258913f, -0.46963274f, 
    0.07899510f, -0.04438276f, 0.33725423f, -0.16351858f, 0.11693140f, 0.08047688f, -0.07347121f, -0.22701499f, 
    0.26709425f, 0.10252500f, 0.09588119f, 0.27837345f, -0.11306535f, -0.20491286f, 0.46722543f, 0.22114770f, 
    -0.44363022f, -0.02478622f, 0.07397600f, -0.10190355f, 0.07307006f, 0.16816817f, -0.04867772f, 0.04105493f, 
    -0.35581428f, -0.04501467f, 0.05113367f, 0.07066656f, 0.12820199f, 0.00280759f, 0.22124499f, -0.03799034f, 
    0.11908222f, -0.00912830f, -0.01838283f, 0.10781212f, 0.14737281f, 0.27482802f, 0.73560303f, -0.41455278f, 
    -0.71362764f, -0.13768296f, -0.16021259f, -0.00876375f, 0.11779007f, -0.08532501f, 0.11470855f, 0.13080081f, 
    -0.57047617f, -0.54191673f, 0.01193041f, -0.09015614f, -0.12482958f, 0.07213204f, 0.02306342f, 0.23620598f, 
    -0.11288615f, -0.13430738f, 0.37925506f, 0.10437161f, 0.25759488f, -0.28820139f, 0.12116050f, 0.26736534f, 
    -0.09692866f, -0.27189469f, 0.08193883f, 0.01280206f, -0.09745262f, -0.14344132f, -0.13516991f, 0.21066776f, 
    -0.23655999f, -0.03746990f, 0.30383405f, 0.67467189f, -0.04761875f, 0.10037464f, -0.17606880f, -0.00363033f, 
    -0.06786260f, 0.07327227f, 0.17878287f, 0.07440251f, 0.02724106f, -0.08773249f, 0.07296245f, 0.18654628f, 
    -0.03106018f, -0.06063407f, 0.10808916f, 0.01447779f, -0.26493490f, 0.37457606f, 0.23564920f, -0.08678085f, 
    -0.23122002f, 0.08764289f, -0.04587949f, 0.19834633f, 0.04112128f, -0.26303846f, 0.10404566f, -0.46410200f, 
    -0.18798712f, 0.02952163f, -0.17613198f, 0.05989243f, -0.13569142f, -0.08957630f, -0.13198848f, -0.05866989f, 
    -0.20528334f, 0.12783334f, -0.00830668f, -0.01884979f, 0.36434507f, 0.20524788f, 0.25502637f, 0.32662708f, 
    -0.56453055f, 0.09358556f, 0.04811110f, 0.00940662f, -0.23627895f, -0.02898796f, 0.05449387f, -0.10888356f, 
    0.20985238f, -0.14556564f, 0.80181873f, -0.17608705f, 0.04365944f, 0.04618796f, 0.10204034f, -0.10147026f, 
    -0.05637361f, 0.11566696f, -0.57242519f, -0.31438905f, 0.16524726f, -0.33615440f, 0.03467433f, -0.12387332f, 
    0.31390959f, 0.05337682f, 0.12647563f, 0.34309131f, 0.59226298f, 0.03342596f, 0.00087103f, -0.43121895f, 
    0.03462454f, 0.05903697f, 0.27439889f, 0.01550861f, 0.13100055f, 0.49493778f, 0.03563684f, 0.46212953f, 
    -0.02589246f, 0.15067887f, 0.18302515f, 0.47648966f, 0.15380792f, -0.09438085f, -0.25627661f, 0.10015888f, 
    0.01596843f, -0.00808059f, 0.03984854f, 0.11007929f, 0.05191082f, 0.00896704f, 0.59220481f, -0.06755538f, 
    0.29319075f, 0.22976950f, 0.14826554f, 0.20479278f, 0.43302876f, 0.15837276f, -0.57977694f, 0.25145558f, 
    -0.06353606f, 0.06960191f, -0.08779626f, -0.17148384f, 0.08088885f, -0.08075703f, -0.25092486f, -0.10008755f, 
    -0.21848793f, -0.00435852f, -0.04802926f, -0.00157687f, 0.08542259f, -0.16346532f, -0.39002100f, 0.15270957f, 
    0.34537670f, 0.44798800f, 0.23072059f, -0.16356541f, -0.06971859f, 0.04348454f, 0.12286626f, 0.18559514f, 
    -0.03840913f, -0.11454334f, -0.06292939f, -0.10981050f, -0.05039040f, -0.10734119f, -0.23036610f, 0.18473426f, 
    0.09004229f, -0.01927742f, -0.48983201f, -0.40633848f, -0.09018943f, -0.02082179f, 0.05805818f, 0.18281139f, 
    0.11271152f, 0.17991450f, 0.46401864f, -0.10509948f, 0.16529478f, 0.24042416f, 0.17151107f, 0.04216464f, 
    -0.28278634f, -0.17312290f, 0.01714073f, -0.13805108f, 0.42897630f, -0.25262243f, -0.21630380f, -0.09324428f, 
    -0.17123033f, -0.13531685f, 0.11440796f, -0.06207172f, -0.15105388f, -0.09773377f, 0.05832452f, -0.01578345f, 
    0.02549699f, -0.08507347f, -0.02230948f, 0.12762162f, 0.15107140f, 0.16424137f, -0.08907111f, 0.24387988f, 
    0.10038506f, -0.01701592f, -0.02262793f, 0.01862257f, 0.22665995f, 0.17658950f, 0.05454154f, 0.46838537f, 
    0.06806362f, -0.21474762f, -0.12607610f, 0.04193295f, -0.28851184f, -0.19808978f, -0.16974123f, -0.36671087f, 
    0.46020344f, -0.12389189f, 0.06628835f, -0.33501500f, 0.15150546f, 0.02204177f, -0.05351575f, 0.06472770f, 
    0.11499014f, 0.08665203f, 0.47383693f, 0.21352847f, 0.08562057f, -0.20293866f, -0.27711222f, 0.10080227f, 
    -0.08040040f, -0.38605991f, 0.48770076f, 0.08272205f, -0.13134035f, 0.02260778f, 0.08554339f, -0.01111060f, 
    0.01048590f, 0.04384123f, 0.04998470f, -0.17296821f, 0.07294115f, 0.65394229f, -0.32668197f, -0.03578025f, 
    -0.10334224f, 0.18602131f, 0.24147063f, -0.08056962f, -0.42786992f, -0.07291591f, 0.14862357f, 0.06023065f, 
    0.28226218f, -0.13892208f, -0.20669739f, -0.34052008f, -0.05679007f, -0.23147514f, 0.01005965f, 0.17209597f, 
    0.06388289f, 0.21090122f, -0.08733984f, 0.04153867f, 0.15873940f, -0.07993317f, 0.09543812f, 0.20991643f, 
    -0.27480471f, 0.01040484f, 0.45717975f, -0.15407115f, -0.00311195f, 0.11483058f, 0.13234073f, 0.02020544f, 
    0.27715248f, 0.04685382f, 0.02031499f, 0.19900487f, -0.05147985f, 0.21057282f, 0.11179349f, 0.38558942f, 
    0.08609615f, -0.25939342f, -0.44102359f, -0.17800888f, -0.06634119f, 0.23870647f, -0.14968783f, -0.14594956f, 
    0.07792620f, 0.19264689f, -0.28908670f, -0.25764090f, 0.09911847f, -0.03353108f, 0.01368319f, 0.20521793f, 
    0.10384558f, 0.05572987f, -0.38504040f, 0.25773859f, 0.15480837f, 0.09646209f, -0.03970581f, 0.10610559f, 
    0.02962383f, 0.14618811f, 0.08906031f, -0.13367842f, 0.36941588f, -0.13097870f, -0.16637965f, 0.06665150f, 
    0.00981447f, -0.04989368f, 0.00578032f, -0.01775697f, -0.14243245f, -1.48891866f, -0.62824690f, -0.04406442f, 
    0.30200735f, 0.24793619f, 0.10897403f, -0.31837142f, -0.03993116f, -0.12616694f, 0.15524434f, 0.00683150f, 
    0.05397389f, 0.11088803f, -0.00707075f, -0.06740169f, -0.00958894f, -0.00266813f, 0.03867680f, -0.11569263f, 
    0.07259909f, -0.01796240f, 0.00352077f, 0.03168453f, 0.21278873f, -0.16703546f, -0.01956213f, -0.33402097f, 
    -0.08389804f, -0.46085677f, -0.01502999f, 0.05808335f, 0.18886782f, 0.12357889f, 0.13448927f, -0.05915030f, 
    0.34645528f, -0.91349816f, 0.24310015f, 0.04252331f, -0.00924052f, 0.17105965f, -0.01690009f, -0.03375050f, 
    0.02185526f, 0.19013157f, -1.19017100f, -0.60206062f, -0.06983371f, 0.13192703f, 0.20284986f, 0.09072223f, 
    -0.14189176f, -0.01802219f, 0.09198260f, 0.93757218f, -0.60414195f, 0.09919992f, -0.04608011f, 0.38990980f, 
    0.18738836f, 0.08926427f, 0.21121542f, -0.15128841f, 0.41298869f, 0.06242221f, 0.33206284f, -0.06528731f, 
    -0.04346364f, 0.05812785f, 0.13909419f, -0.02761038f, -0.00513833f, 0.12272982f, -0.18367398f, 0.02950514f, 
    -0.26297957f, -0.08999897f, 0.22926201f, 0.12200680f, 0.29193529f, -0.25808924f, 0.18734682f, 0.00223178f, 
    0.15168649f, 0.05800772f, -0.00783979f, 0.00878804f, 0.19523986f, -0.04426851f, 0.47834554f, -0.88633090f, 
    -0.12943898f, -0.09085064f, -0.07838793f, 0.02827839f, 0.01990828f, -0.36366671f, 0.01140917f, 0.11528758f, 
    -0.39261976f, 0.40626520f, 0.01665173f, -0.14858951f, 0.03759171f, 0.02961510f, 0.00443391f, 0.07237457f, 
    0.43695781f, 0.76043683f, 0.52272987f, 0.03688902f, -0.04340021f, -0.06624403f, 0.12529320f, -0.08160475f, 
    0.00687987f, -0.05489430f, -0.22590442f, -0.04125240f, 0.10503583f, 0.05234344f, 0.03708092f, 0.11977474f, 
    0.12038102f, 0.06253793f, -0.09747596f, -0.53919798f, -0.58387768f, 0.00716773f, -0.03261961f, -0.09845325f, 
    0.08546922f, -0.16980891f, 0.23340265f, -0.06925585f, -0.16722037f, -0.59953696f, -0.24366975f, -0.14993258f, 
    -0.30683938f, 0.08693480f, 0.07844392f, 0.25375339f, 0.43155590f, -0.10549302f, -0.49144977f, 0.23837832f, 
    0.08878826f, 0.23258607f, 0.13724387f, 0.04539743f, -0.04261586f, -0.23702832f, -1.06820774f, -0.37883672f, 
    0.40240887f, 0.05952701f, -0.22536929f, -0.12404875f, -0.01971076f, 0.05349535f, 0.12593360f, -0.23356977f, 
    -0.33588710f, -0.26541740f, 0.19101015f, 0.31352708f, 0.28665808f, 0.04809088f, 0.12955479f, 0.44729263f, 
    0.25276005f, 0.32903776f, 0.04563496f, 0.09536105f, 0.14195247f, 0.30119404f, -0.08292329f, 0.12296983f, 
    0.22544543f, 0.84908611f, 0.46334919f, -0.05775090f, 0.04493727f, 0.04743952f, 0.12216711f, -0.30831960f, 
    -0.07304046f, -0.02497019f, -0.04265258f, 0.01315987f, -0.13130021f, 0.02978136f, -0.13393234f, 0.17646234f, 
    -0.01477678f, 0.15243736f, 0.26904276f, 0.26476187f, -0.06652988f, -0.28042015f, 0.04152010f, 0.03496365f, 
    0.08212641f, 0.09995230f, -0.04171620f, -0.49865052f, -0.61195326f, -0.58985186f, 0.09073291f, 0.03245555f, 
    0.12650639f, 0.25321555f, -0.13327859f, 0.02541221f, -0.14886504f, -0.17944388f, 0.13019316f, -0.04656070f, 
    -0.09584979f, -0.48992997f, 0.14749599f, -0.18458115f, -0.00925750f, 0.00075667f, -0.13529395f, -0.61925358f, 
    0.05188719f, -0.32066536f, 0.11534297f, 0.06753112f, 0.12682188f, -0.16679019f, -0.16150805f, -0.23709255f, 
    -0.43951061f, 0.13940424f, -0.07042642f, -0.09589635f, 0.11020859f, 0.25014299f, -0.01675619f, 0.29953095f, 
    0.41602910f, 0.69193542f, -0.21694522f, 0.09523344f, -0.26313624f, -0.06867665f, 0.02170101f, 0.13665141f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.33389702f, 0.32468942f, 0.00821893f, -0.06388774f, 0.45273685f, 0.50482148f, -0.28343335f, 0.15200040f, 
    0.42266214f, 0.15372755f, -0.07447445f, 0.13062571f, 0.33831826f, 0.03418979f, 0.31004494f, 0.03716462f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.71721202f, -0.51637137f, 0.12345073f, 0.37978116f, -0.79602730f, 0.14935772f, 0.60761362f, -0.06435110f, 
    0.06357075f, -0.45958185f, 0.03354844f, -0.05739966f, -0.64495218f, 0.52252871f, 0.07091616f, 0.38771275f, 
    0.83594394f, -0.44256055f, 0.02795768f, -0.26063156f, -0.40901914f, -0.13013381f, -0.89963472f, -0.25134128f, 
    0.54391688f, 0.12232140f, -0.13994771f, -0.42104897f, 0.00489617f, 0.36577365f, -0.43721995f, 0.38476419f, 
    -1.07063913f, 0.23444222f, -0.01190089f, -0.11195805f, 1.07086670f, -0.12919962f, -0.28293976f, 0.50912565f, 
    0.25132909f, -0.33562386f, -0.21837385f, 0.56176150f, -0.03693304f, -0.54553735f, -0.46295068f, -0.43490371f, 
    -1.09540999f, -0.83848470f, 0.07086281f, 0.66691905f, -0.18778573f, -1.53105724f, 0.34208694f, 0.23185579f, 
    -0.62766784f, -0.04477582f, 0.01178050f, 0.41045493f, 0.61325622f, -0.20659147f, 0.11674686f, -0.21297562f, 
    -0.35969105f, 1.13666487f, 0.08181322f, 0.12446022f, -1.13307786f, 0.06457701f, 0.38564265f, 0.34352380f, 
    -0.19523725f, 0.30946082f, 0.22549140f, -0.08770753f, -0.13240634f, -0.26530409f, -0.45728374f, 0.15631673f, 
    -0.42234066f, -0.21156624f, 0.11021060f, -0.16499846f, -0.15114823f, -0.30916116f, -0.31761056f, -0.19322479f, 
    -0.07340547f, 0.61142921f, -0.21697472f, -0.04230443f, 0.22312424f, -0.18290058f, 0.01169403f, 0.24603428f, 
    0.34222344f, 0.03963736f, 0.03496252f, -0.41591853f, -0.02006155f, 1.21425831f, 0.06115957f, 0.13194059f, 
    0.28809968f, -0.57324755f, 0.08401222f, 0.55583823f, 0.01950863f, -0.58172464f, -0.62101948f, -0.72094500f, 
    0.55612159f, -0.04811875f, -0.15847312f, -0.00470220f, -0.35091740f, -0.98111308f, 0.55129987f, 0.03520969f, 
    0.20813280f, -0.03017592f, 0.03472890f, 0.24694006f, -0.38182893f, -0.03263251f, 0.97750646f, -0.49466518f, 
    -0.13091905f, -0.86889285f, 0.15105163f, -0.76740700f, 0.08480115f, -0.21463713f, -0.76577085f, -0.34631342f, 
    -0.04344280f, 0.23578107f, 0.20485111f, 0.21453181f, -0.04890765f, 0.64561957f, 1.03622532f, -0.43986627f, 
    -0.29835355f, 0.35094360f, -0.18400280f, 0.30866143f, -0.20017713f, 0.57572067f, 0.03022665f, 0.67528766f, 
    -0.10790739f, -0.41928041f, -0.19657095f, -0.61775935f, 0.27565065f, -0.39547426f, -0.18114582f, -0.27848798f, 
    -0.46256503f, 0.79164547f, -0.13346720f, 0.59474051f, 0.67028975f, -0.07660199f, -1.12689173f, -0.94010597f, 
    -0.32563299f, 0.37717137f, 0.01045856f, -0.66501117f, 0.39647910f, 0.42179105f, -0.31175813f, -0.50788301f, 
    0.41914430f, -0.39703622f, 0.12638284f, -0.52252275f, 0.31293708f, -0.03917284f, -0.07124798f, 0.05622702f, 
    -0.20743005f, 0.69468433f, 0.07707419f, -1.02999640f, 0.35388917f, -0.26579630f, -0.60900420f, -0.63789243f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.50230813f, 0.46701422f, 0.43458918f, -0.14696039f, -0.30262524f, -0.01592791f, -0.29030821f, -0.30901766f, 
    0.03620597f, 0.16888799f, -0.20696166f, 0.08927012f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
