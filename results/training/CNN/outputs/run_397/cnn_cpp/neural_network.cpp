#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.11662698f, 0.91522551f, -0.51583737f, 0.70790696f, -0.56316924f, 0.34657490f, 0.06900387f, -0.08996888f, 
    -0.07744990f, -0.97645205f, -0.11096596f, -0.04305107f, -0.68442661f, -0.22224811f, -0.62671840f, -0.24858393f, 
    0.34559384f, 0.59475875f, 0.00706176f, -0.68518364f, -0.53217733f, 0.36214587f, -0.76370263f, 0.73221910f, 
    -0.40425661f, -0.08857895f, -0.68544155f, -0.69801795f, -1.02041185f, -0.92638785f, -0.42008343f, -0.16662562f, 
    0.37818000f, 0.31445673f, -0.14419468f, 0.01991722f, 1.15873873f, -0.66878766f, -0.71884829f, 0.15667309f, 
    -0.33829004f, -0.27251023f, -0.07355988f, -0.45528403f, -0.04145284f, -0.81595850f, -0.77965987f, 0.53888589f, 
    0.35656303f, -0.38970324f, -0.77675748f, -0.02367020f, 0.02797827f, -0.00608283f, -1.06264281f, 1.14490652f, 
    0.11050791f, -0.67564648f, 0.42766365f, 0.36872309f, 0.21704592f, -0.10765681f, 0.17184830f, 0.80619377f, 
    -0.23026365f, 0.29772547f, 0.10346797f, -0.06257002f, 0.78833872f, -0.24323310f, -0.55122817f, -0.49031520f, 
    0.13578095f, -1.26480436f, -0.30704582f, 0.83682030f, 0.61525577f, -0.02990000f, -0.46143395f, -0.21252033f, 
    -0.02580759f, -0.26332951f, 0.40832484f, 0.73957682f, 0.03786591f, 0.27864328f, -0.90875167f, -0.01119376f, 
    0.56466860f, -0.39574280f, 0.71211988f, 0.67496997f, -0.18435119f, 0.03344335f, 0.68126124f, -0.74551171f, 
    0.21435039f, 0.08474507f, 0.21968505f, -0.59360313f, 0.96515584f, 0.21962687f, 0.27771792f, -0.49401248f, 
    -0.70549840f, 0.07763605f, -0.22722813f, 0.34396708f, 0.54095596f, 0.82850820f, -0.09282330f, -0.87358809f, 
    0.38352245f, -0.52708131f, 0.38066709f, 0.39003041f, 0.17838405f, 1.21230209f, -0.48679328f, -0.29272449f, 
    0.58457404f, 0.22448099f, -0.55607879f, -0.29401773f, -0.28649330f, 0.15421693f, -0.56890368f, 0.16745877f, 
    0.72207403f, -0.51198453f, 0.08394660f, 0.49521393f, 0.14635268f, 0.38210168f, -0.32400319f, 0.00855539f, 
    -0.91683024f, 0.69144505f, 0.54635447f, -0.68201274f, -0.04177917f, -0.21371792f, -0.51886690f, 0.43589178f, 
    -0.52565944f, 0.09073572f, 0.68985462f, 0.11173016f, 0.40692919f, -0.67288297f, -0.49290276f, 0.70354086f, 
    -0.14502044f, -0.54010588f, 0.74178874f, -0.77921289f, 0.61011177f, 0.09605629f, -0.96322232f, 0.09981247f, 
    0.36560455f, -0.05803476f, 0.19521935f, -0.90197682f, 0.92087823f, 0.10211959f, -0.82241839f, -0.65207529f, 
    0.06995785f, -0.12594828f, -0.19420113f, 0.62627780f, -0.70566195f, -0.56964213f, 0.86794752f, -0.73325396f, 
    -0.23402911f, -0.16414763f, 0.20871271f, 0.15336625f, 0.66341650f, 0.12819424f, 0.34230542f, 0.32004839f, 
    -0.65495366f, 0.67439771f, 0.06554569f, 0.18825686f, -0.32207197f, 0.25235844f, -0.77564746f, -0.73453891f, 
    -0.76591456f, 0.65603346f, 0.72502393f, -0.30966678f, -0.34714997f, -0.02254552f, 0.73754048f, 0.86411273f, 
    0.76202154f, -0.50394249f, 0.38492563f, 0.00372577f, -0.09094044f, 0.32366967f, -0.46484450f, -0.03908569f, 
    0.92356384f, 0.66938633f, 0.41566992f, -0.29346064f, 0.57882714f, 0.10779157f, 0.12108034f, 0.24484394f, 
    1.28162897f, 0.39945021f, -0.97207975f, -0.51172769f, 0.14220643f, 0.44925576f, 0.10733618f, -0.24976107f, 
    0.53841907f, 0.01856042f, 0.67864788f, -0.42587808f, 0.00251927f, 0.61034632f, 0.83138466f, 0.47970241f, 
    0.11696857f, -0.04052795f, -1.11646211f, 1.06855333f, 0.60570461f, 0.67761540f, 0.35430804f, 0.15632199f, 
    -0.46437123f, -0.10379703f, -0.49405131f, -1.28416157f, 0.61567992f, -0.47011319f, 0.28121230f, 0.97433698f, 
    -0.62640870f, -0.42464760f, 0.07533676f, 0.62207544f, 1.00217795f, -1.34278870f, 1.02049780f, -0.04746100f, 
    -0.20428643f, 0.30108535f, 0.45775473f, 0.08800855f, -0.44194534f, 0.01620954f, 0.67674077f, -0.31426176f, 
    -0.51816303f, -0.63988715f, -0.44146213f, -0.43061101f, 0.05326771f, 0.29659173f, 0.79714286f, 0.80524462f, 
    0.54346627f, 0.31122059f, -0.72533613f, -0.42032477f, 0.09115461f, -0.35717398f, -0.16612564f, -0.92980605f, 
    0.80850929f, 0.80878186f, 0.06418877f, 0.75068998f, 0.39102030f, -0.18479736f, 0.04733023f, 0.37713781f, 
    0.70203346f, -0.92921704f, -0.23550148f, -0.42056060f, 1.00370705f, 0.36211443f, 0.55111051f, -0.16121463f, 
    -0.43201622f, 0.39391211f, 0.41155344f, -0.70531636f, -0.64898741f, -0.70394254f, -0.75992912f, 0.23472252f, 
    -0.05590114f, -0.01299192f, 1.06617713f, 0.98276126f, -0.05945159f, -0.09150360f, 0.57792526f, -0.13765439f, 
    -0.03923825f, 0.11301557f, -0.59839475f, -0.28507450f, 0.85717934f, 0.24786921f, -0.85121489f, -0.53921026f, 
    0.26267567f, -0.25877595f, 0.45236424f, 0.41700155f, -0.00074377f, -0.58391708f, 0.43552443f, -0.77974302f, 
    -0.84743798f, 0.37034687f, 0.75260282f, -0.32051015f, 0.47278333f, 0.88908041f, 0.23544721f, -1.04667711f, 
    0.53992307f, 0.31720608f, 0.33470160f, 0.06775172f, -0.24280125f, 0.16531202f, -0.09195399f, 0.17787538f, 
    -1.08047295f, -0.65503478f, 0.35145158f, 0.39042720f, 0.45932075f, -0.56002814f, 0.46382004f, 0.28727517f, 
    0.13786726f, -0.56750584f, 0.90554881f, 0.27819398f, 0.60172200f, -0.50850993f, -0.67789531f, 0.45300093f, 
    -0.40369254f, -0.39188358f, 0.27845949f, -0.71864933f, -0.49162009f, 0.75176948f, 0.08956156f, -0.41664210f, 
    -0.37502339f, -0.50638205f, 0.70091844f, -0.90289921f, -0.31583306f, -0.48138982f, 0.14122185f, 0.33852822f, 
    -0.17226055f, 0.29229236f, -0.12343861f, -0.49364993f, 0.72220814f, 0.16021483f, -0.63133895f, 0.43519998f, 
    -0.15297632f, -0.47732559f, -0.27851292f, 0.29018196f, 0.64429748f, 0.82224685f, 0.52166146f, 0.42313471f, 
    0.60189480f, -0.57438940f, 0.05469824f, -0.21924470f, 0.78354913f, 0.85756058f, -0.38189989f, 0.82625854f, 
    -0.05989169f, 0.04720580f, 0.41244623f, 0.40796617f, 0.06814984f, -0.50569057f, 0.04959085f, -0.74649096f, 
    0.24857922f, 1.07030559f, -0.06178033f, -0.03649261f, -0.13413006f, -0.56339544f, -0.76679808f, 0.00466984f, 
    -0.00558156f, 0.65030825f, 0.80703115f, 0.74328905f, 0.38133746f, -0.38548958f, -0.22394976f, -0.45727396f, 
    -0.77673417f, -0.77545381f, 0.00890914f, -0.42203289f, -0.36018798f, 0.51393288f, 0.55508149f, -0.51144356f, 
    0.46912405f, -0.75273526f, -0.74626875f, -0.87987047f, -0.16287270f, -0.00731944f, 0.13829702f, 0.47020850f, 
    0.02527826f, 0.37452048f, -0.02770249f, -0.23032174f, -0.51510113f, -1.04423273f, -0.77845281f, -0.31071013f, 
    0.59914732f, -0.36411783f, -0.03744956f, -0.69531590f, -0.54783809f, -0.80829322f, -0.28789395f, -0.40589765f, 
    -0.15777817f, 0.63516647f, 0.47648534f, -0.63600332f, -1.32947743f, -0.61010092f, -0.04305683f, 0.85060614f, 
    0.55058593f, -0.50421309f, 0.14346950f, -0.34339532f, 0.93083131f, 0.61286342f, 0.63984293f, -0.03439898f, 
    -0.87430292f, 0.15222789f, 0.11871736f, 0.36416972f, -0.01787522f, 0.02082896f, -0.89105141f, 0.75256085f, 
    -1.13988769f, 1.04066920f, -0.44243464f, 0.20470427f, 0.15765162f, 0.00137282f, 0.73429775f, 0.93987674f, 
    0.31208843f, -0.09568802f, -0.69334513f, 0.04388214f, 0.59538555f, 0.41986382f, -0.01424530f, -0.87684655f, 
    -1.02690935f, -0.28551629f, 0.33838001f, 0.85105890f, 0.41714424f, -0.07924413f, -0.31703746f, 0.23408011f, 
    0.60497671f, 0.75289088f, 0.31674024f, -0.04974087f, 0.09923045f, 0.38742831f, 0.37738779f, -0.60756063f, 
    -0.57395101f, 0.73145998f, 0.59079319f, 0.75090069f, 0.70565164f, -0.46414778f, -0.59232652f, -0.50096774f, 
    -0.00441367f, 0.24606159f, -0.68496871f, -0.61406606f, -0.60860503f, 0.76315588f, 0.57384241f, -0.20737801f, 
    0.42625540f, 0.47721738f, -0.14664951f, -0.61105591f, -0.57523668f, -0.57355243f, -0.06587277f, -0.54830295f, 
    -0.80746150f, 0.34979260f, 0.30382994f, 0.42104444f, -0.72220755f, -0.61808974f, -0.30469730f, -0.63376099f, 
    -0.44791210f, -0.64254147f, -0.34893882f, -0.35883179f, -0.72641069f, -0.39245954f, -0.90505207f, -0.55750173f, 
    0.07146898f, 0.30130038f, -0.46628395f, -0.09024761f, -0.19852303f, 0.29744008f, 0.87962830f, 0.86048347f, 
    -0.38970858f, -0.03318182f, 0.31487158f, 0.55051166f, -0.54513597f, 0.06903008f, 0.53736067f, 0.96725839f, 
    0.10022490f, 0.82211685f, -0.54975080f, -0.26471120f, -0.71280360f, -0.09000753f, -0.15697524f, -0.12958868f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.07182366f, 0.05044373f, -0.18832800f, 0.40348244f, 0.05453185f, 0.29425803f, 0.19297591f, -0.05516208f, 
    0.10769970f, 0.07883848f, 0.27132437f, 0.18302730f, -0.00206635f, -0.03880818f, 0.19307390f, -0.07710990f, 
    -0.06140359f, 0.05496110f, -0.05862825f, 0.34992516f, 0.24951237f, -0.16161799f, 0.27962103f, 0.26284033f, 
    0.00266213f, 0.24881360f, -0.02786574f, -0.15503526f, -0.02500476f, 0.27784219f, 0.16962095f, 0.33969292f, 
    -0.05176088f, 0.35921296f, 0.14627373f, -0.08654059f, 0.09973936f, 0.24851663f, -0.01847989f, -0.11601940f, 
    0.08286663f, 0.28022638f, 0.14660755f, 0.20537865f, 0.11760055f, -0.13325636f, 0.33096507f, 0.34425905f, 
    0.25670680f, 0.21390195f, 0.12293778f, 0.23627597f, 0.01966633f, -0.08436795f, -0.05004195f, 0.05303378f, 
    0.02958257f, 0.23451024f, 0.47967613f, -0.01165555f, -0.04144352f, 0.33251294f, 0.12323039f, -0.10627471f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.38268414f, -0.08012966f, 0.20451851f, -0.04462432f, -0.09765888f, -0.00765352f, -0.02860227f, 0.00224826f, 
    -0.05523521f, 0.02224064f, 0.05028486f, 0.02718306f, -0.07349113f, 0.02118099f, 0.05914234f, -0.08472750f, 
    -0.01707666f, 0.05146216f, -0.07575463f, -0.03760493f, -0.24418241f, -0.20087132f, -0.07097174f, 0.00823275f, 
    0.03691183f, -0.00995415f, -0.02935507f, -0.04594912f, 0.09637304f, -0.03145672f, 0.03589726f, 0.04614871f, 
    -0.08678784f, -0.02238079f, 0.00759247f, -0.01827861f, 0.03792751f, 0.01462317f, 0.06729212f, -0.05209074f, 
    0.34478259f, -0.11084448f, 0.03953381f, 0.00601272f, -0.28078505f, -0.01317627f, 0.03684467f, -0.01113676f, 
    0.00996338f, 0.00435538f, 0.00027971f, -0.11082798f, 0.07359502f, 0.05583119f, -0.10387079f, 0.07287145f, 
    -0.07552657f, 0.02187833f, 0.04930408f, 0.03864760f, -0.17370811f, -0.02355365f, -0.19566880f, -0.00082303f, 
    -0.19776592f, 0.00770449f, -0.01517617f, -0.03389037f, 0.07488538f, 0.04344042f, -0.00423295f, -0.08006845f, 
    -0.06115046f, 0.03131158f, 0.00965210f, 0.04475880f, -0.07129721f, -0.00966246f, 0.05991094f, -0.06369327f, 
    0.10998786f, -0.33999187f, 0.24958314f, 0.21243289f, 0.20705128f, 0.03970275f, 0.08879426f, 0.04775445f, 
    0.06491072f, -0.04880184f, -0.12568268f, -0.03165013f, 0.03288074f, -0.01120173f, 0.01609498f, 0.02753030f, 
    0.01510663f, 0.03451845f, 0.02404206f, -0.00038718f, -0.37418801f, -0.19273545f, 0.00013424f, 0.01536051f, 
    -0.04944332f, 0.00020676f, -0.10150518f, -0.01573169f, 0.03909760f, -0.00305716f, -0.05043340f, -0.02273961f, 
    0.01000415f, -0.04566696f, -0.07297528f, -0.02309371f, -0.02894164f, 0.06508772f, -0.07138797f, -0.01651851f, 
    0.07414210f, 0.04407844f, 0.07205910f, -0.05565433f, 0.21322116f, 0.05450041f, -0.02573090f, 0.03809528f, 
    0.03527511f, -0.04964430f, -0.00130360f, 0.01921802f, 0.03532056f, 0.01440023f, 0.06578635f, -0.01925680f, 
    -0.02148815f, 0.00401931f, -0.08413184f, -0.07909098f, 0.15695301f, -0.07525615f, 0.03739732f, 0.05565235f, 
    -0.00148516f, -0.08556395f, 0.04090827f, -0.07767796f, -0.02466318f, -0.05053477f, -0.13647775f, -0.01342214f, 
    0.06121368f, -0.09452102f, 0.06086804f, 0.11017499f, 0.05954847f, 0.00020833f, 0.01905795f, 0.02727398f, 
    -0.00311863f, 0.13139102f, 0.04089803f, 0.00833874f, -0.23104553f, 0.04681275f, 0.03001775f, 0.03375906f, 
    -0.08441992f, -0.01751802f, 0.04969038f, -0.01191971f, 0.03399174f, 0.01284675f, 0.02803371f, 0.00231650f, 
    0.11441161f, 0.03149134f, -0.06805081f, 0.05275844f, -0.20245753f, 0.02181957f, 0.08083066f, -0.05427960f, 
    -0.08185549f, 0.02879330f, -0.05687193f, -0.00723105f, -0.02099404f, 0.01040381f, 0.01518993f, 0.08537961f, 
    0.02737863f, -0.02989927f, -0.10186587f, 0.03658982f, -0.02944727f, -0.00864472f, -0.07651739f, -0.10145005f, 
    -0.08867651f, 0.04776398f, -0.03141142f, -0.04239754f, 0.12801200f, -0.07707985f, -0.00605405f, 0.00525420f, 
    0.05425048f, -0.02276653f, 0.00129753f, 0.06823175f, -0.03757529f, -0.04761539f, -0.08845883f, -0.04422012f, 
    -0.07627030f, 0.02697303f, -0.07871944f, -0.04084622f, -0.08665250f, 0.08580486f, 0.03842646f, -0.11730900f, 
    0.11135792f, -0.07021553f, -0.12061592f, -0.04147685f, -0.15596776f, -0.03892450f, 0.02002915f, 0.05821926f, 
    -0.01439846f, 0.06473000f, -0.00789396f, -0.01891083f, -0.03877651f, 0.08371930f, -0.04891773f, -0.07909025f, 
    -0.14324930f, -0.05142532f, 0.01310985f, 0.00336243f, 0.09978077f, -0.01145431f, 0.02764720f, -0.11862082f, 
    0.03192795f, 0.06333480f, 0.02742784f, 0.07176030f, 0.02554432f, -0.03712176f, 0.04877225f, -0.10886648f, 
    -0.05496738f, 0.05006328f, -0.01964360f, -0.09814344f, 0.14277610f, -0.17120984f, 0.17571491f, 0.16851349f, 
    0.26223561f, 0.03302768f, -0.05668953f, -0.03600986f, 0.02809687f, -0.05537619f, -0.14413123f, 0.05987179f, 
    -0.01511985f, 0.02305117f, -0.00922923f, -0.00301266f, 0.02253152f, -0.08410603f, -0.06044478f, 0.02560022f, 
    -0.28150710f, 0.10182720f, -0.02442824f, 0.07193261f, 0.03410055f, -0.02464006f, 0.01086045f, 0.01367753f, 
    -0.01193326f, -0.03896463f, 0.06472420f, -0.03397820f, 0.06602773f, 0.00986308f, -0.03571482f, 0.01514235f, 
    -0.00283485f, -0.04505228f, 0.04852724f, -0.03732432f, -0.05433040f, -0.29044586f, 0.14172758f, 0.11994722f, 
    -0.15474445f, 0.11229397f, 0.04132171f, -0.03959635f, 0.00429019f, 0.10083845f, -0.19328451f, 0.03545429f, 
    -0.05155439f, 0.05206041f, 0.06143296f, 0.03834265f, 0.00336852f, 0.08089091f, -0.03519631f, -0.08048350f, 
    -0.33282837f, 0.01203040f, 0.18105349f, -0.00867315f, -0.07976006f, 0.01141520f, 0.00673856f, 0.03203867f, 
    0.09075353f, 0.03359432f, -0.02542310f, 0.08459078f, 0.04342711f, -0.01522440f, -0.14321630f, 0.02429630f, 
    -0.08483054f, 0.04719399f, -0.03908071f, -0.10054334f, 0.31241673f, -0.08547029f, -0.03638330f, -0.07720211f, 
    0.05943312f, 0.03071748f, -0.04566074f, 0.05474492f, -0.06620818f, 0.04389591f, 0.06958465f, 0.03252326f, 
    -0.01001529f, 0.01039301f, 0.08303621f, -0.04985081f, -0.04210367f, 0.09048796f, 0.02656653f, -0.01483147f, 
    0.03872297f, -0.29576710f, 0.04997307f, 0.04208738f, -0.28593433f, 0.03172813f, 0.00000798f, 0.07568382f, 
    -0.05366633f, 0.03145152f, -0.13598460f, 0.04957377f, -0.10036514f, 0.00707784f, -0.00586166f, -0.06198495f, 
    -0.11302897f, 0.14099538f, -0.02257498f, -0.01954607f, 0.16205239f, -0.35318023f, 0.07198683f, -0.04083400f, 
    -0.03595645f, 0.03535626f, 0.09471401f, 0.04761738f, -0.08367429f, 0.01445389f, -0.12108628f, 0.06943513f, 
    -0.03629670f, 0.05936855f, -0.02404878f, 0.02436920f, 0.04928667f, 0.02862125f, -0.06368792f, 0.01661511f, 
    0.11900812f, -0.13949446f, 0.05418725f, -0.02810434f, -0.06780694f, -0.04321834f, 0.04897545f, -0.10376765f, 
    -0.03235314f, 0.01947045f, -0.05279313f, -0.04810052f, -0.02664795f, -0.00250448f, -0.01367024f, -0.00076267f, 
    -0.02882220f, -0.01356560f, 0.00703181f, 0.03626676f, -0.23079288f, 0.25859427f, -0.01870934f, 0.00312458f, 
    -0.14489463f, -0.00995710f, 0.05069405f, -0.00797328f, -0.04149137f, -0.01693450f, 0.00734154f, -0.06146266f, 
    0.10582966f, -0.00428069f, 0.01027917f, 0.02193639f, 0.01119720f, -0.05003609f, -0.03168644f, -0.04851677f, 
    0.09796484f, 0.06926350f, -0.06208874f, -0.09219617f, 0.20399715f, -0.12405792f, -0.13630293f, -0.09933832f, 
    0.04355640f, -0.01613114f, -0.05536188f, -0.01181326f, 0.00893125f, 0.00132900f, 0.04976511f, 0.01268938f, 
    0.04111011f, -0.05579070f, 0.00711242f, -0.03114142f, -0.21008711f, 0.05615505f, 0.07300644f, -0.04369587f, 
    0.15174581f, 0.00237092f, -0.14796333f, 0.02609055f, -0.04804787f, 0.00397243f, -0.01036585f, -0.04119183f, 
    0.02913306f, -0.00475447f, 0.03217912f, -0.04870231f, 0.01002099f, -0.03120098f, -0.09321027f, 0.06514492f, 
    -0.19848216f, -0.01869983f, 0.09674824f, -0.11151469f, 0.20329033f, -0.06260925f, -0.08200540f, -0.07055799f, 
    0.08686990f, 0.00224932f, -0.00932273f, -0.02357490f, 0.08710071f, 0.04910293f, -0.01332617f, 0.03534005f, 
    -0.04844198f, -0.07826147f, 0.01914836f, -0.02796225f, -0.13075669f, 0.06956064f, -0.02006568f, -0.20562141f, 
    0.06550290f, 0.00027652f, -0.05061333f, 0.02372361f, -0.01191975f, -0.05012459f, -0.05782352f, -0.01714676f, 
    -0.01732597f, 0.07471204f, 0.05441265f, -0.02409254f, 0.02571648f, -0.03372704f, -0.01004545f, -0.09476119f, 
    0.14964233f, 0.10640367f, 0.23909037f, 0.08900008f, 0.16352515f, -0.05232673f, -0.02641770f, 0.08780158f, 
    -0.00146488f, -0.02919344f, 0.02574803f, -0.01069701f, -0.07920959f, -0.05005415f, 0.04604688f, 0.10523077f, 
    -0.03564554f, 0.01133174f, 0.01689742f, 0.00383120f, 0.52339941f, 0.10745593f, 0.08880481f, -0.10325733f, 
    -0.04188722f, 0.04311679f, -0.01775569f, 0.04603857f, -0.06151425f, -0.02701176f, 0.08596431f, -0.02598508f, 
    -0.07588167f, 0.08183562f, 0.08099190f, -0.09142047f, -0.04878738f, 0.03947138f, -0.02374667f, 0.05367011f, 
    0.25097573f, -0.20026562f, -0.05027492f, 0.07269090f, -0.55431956f, -0.06519120f, -0.00476445f, 0.05204581f, 
    -0.00518199f, 0.01826423f, -0.12742712f, 0.08151838f, -0.09972236f, 0.03434915f, 0.00290546f, -0.11370064f, 
    -0.13845347f, 0.04405878f, 0.07223696f, 0.16762975f, 0.05641859f, -0.02085028f, 0.11441243f, -0.03098799f, 
    0.04331049f, -0.05193373f, -0.03893764f, -0.04033582f, -0.01688041f, 0.02330426f, -0.00902645f, 0.00528597f, 
    -0.00840144f, 0.04225323f, -0.00520900f, -0.02998547f, 0.00842392f, 0.02164786f, 0.02527346f, -0.01924379f, 
    0.10433070f, -0.03768200f, 0.06084895f, -0.12936580f, 0.05157074f, -0.15830711f, -0.15469369f, 0.01699529f, 
    0.02265645f, 0.01241910f, 0.01639188f, -0.02791838f, -0.04861341f, 0.02393441f, -0.03163271f, 0.12048690f, 
    0.02315103f, 0.03241630f, -0.00052699f, -0.00000512f, 0.00324047f, 0.03668931f, 0.12973025f, 0.07827618f, 
    0.14143230f, 0.01209578f, -0.04308810f, 0.03657395f, -0.01635291f, -0.05941235f, 0.06872519f, -0.02474641f, 
    0.04556546f, -0.00682765f, 0.02653057f, 0.05277938f, -0.05084767f, -0.01172566f, 0.03197628f, -0.01227506f, 
    -0.21544024f, 0.20643772f, 0.00188377f, 0.04359641f, -0.03294939f, -0.16602381f, -0.04646236f, -0.04703569f, 
    -0.03933005f, 0.07616868f, 0.00070729f, -0.06558047f, -0.07401620f, -0.03513792f, -0.00873564f, -0.03642522f, 
    -0.08715601f, 0.01323367f, -0.01025974f, 0.03917843f, 0.00652085f, -0.10245293f, 0.14051189f, 0.06322167f, 
    0.07248034f, -0.03887836f, -0.02207952f, -0.01450271f, 0.00789397f, 0.00945864f, 0.05527021f, -0.05967396f, 
    0.03795766f, -0.04142767f, -0.02902516f, -0.00946117f, -0.04677259f, -0.00079117f, 0.02970393f, -0.04925855f, 
    0.10555211f, 0.09231107f, 0.06505532f, -0.20608792f, 0.36470032f, -0.21545248f, 0.04590747f, -0.03071790f, 
    0.04722545f, 0.00864327f, -0.06859715f, 0.04264910f, -0.01049436f, -0.09134692f, 0.02355169f, -0.03179191f, 
    0.06693930f, -0.00084286f, 0.00515842f, -0.02638207f, -0.15648530f, 0.06827098f, 0.07202233f, -0.09886310f, 
    0.11056075f, 0.03904141f, -0.07302144f, -0.07375903f, -0.04933983f, -0.04414323f, -0.04204521f, -0.04327601f, 
    -0.00473976f, 0.01865319f, 0.02013297f, -0.07077092f, 0.05054533f, -0.00003922f, 0.01028546f, -0.02502722f, 
    0.02274800f, -0.21611980f, -0.03669680f, 0.06276963f, -0.14197634f, 0.09063058f, 0.04525881f, -0.07341825f, 
    0.00276562f, 0.01256809f, -0.09084086f, -0.00634678f, 0.06042083f, 0.00902215f, 0.00354433f, -0.05358110f, 
    0.04917324f, 0.01382301f, 0.07251114f, -0.12052484f, -0.02638458f, 0.01534393f, -0.00662116f, -0.05395313f, 
    0.18443330f, -0.08621727f, 0.01191452f, -0.01169383f, 0.03639542f, -0.05634147f, -0.00156016f, -0.01716352f, 
    -0.00200566f, 0.03495982f, -0.03197975f, 0.04105241f, -0.05981889f, 0.03185548f, -0.06308419f, 0.02572463f, 
    -0.33875865f, 0.21637553f, 0.02428977f, 0.00543867f, -0.06338587f, -0.00076306f, -0.00595491f, 0.05142881f, 
    -0.07335424f, 0.00188224f, -0.01311609f, -0.01863240f, 0.01146611f, 0.10970270f, 0.08131607f, -0.05230807f, 
    -0.05263577f, -0.04420075f, -0.02836129f, -0.18975012f, 0.12992071f, -0.03724440f, -0.04980037f, -0.03253094f, 
    0.00862179f, 0.03191048f, 0.05594222f, -0.02083688f, 0.02848644f, -0.06488355f, 0.01603961f, 0.08108081f, 
    0.03029887f, -0.02644050f, 0.01314763f, 0.09055871f, 0.08427089f, 0.00066698f, -0.09562489f, 0.04486312f, 
    -0.01189416f, 0.03813060f, -0.04198802f, 0.12804353f, 0.00036031f, -0.10783221f, 0.01119345f, -0.09202588f, 
    -0.01396210f, 0.00862316f, 0.07754996f, 0.01704933f, 0.06976243f, -0.01088255f, 0.03330962f, 0.02398411f, 
    -0.04662801f, -0.10216203f, 0.05892102f, -0.06975013f, 0.14155225f, -0.03565494f, 0.02639042f, 0.05261988f, 
    -0.01617120f, -0.06351908f, -0.04006719f, -0.00270572f, 0.06534949f, -0.02238761f, -0.01250054f, -0.02647189f, 
    -0.02914321f, -0.03960494f, 0.05367906f, 0.02094111f, -0.06399619f, 0.07868827f, -0.06916472f, -0.08806724f, 
    -0.07112677f, 0.03929037f, -0.00811185f, 0.16258962f, -0.09851132f, 0.00797682f, -0.00044677f, 0.01192777f, 
    0.03317541f, 0.06636293f, 0.01050297f, -0.03638009f, -0.00046024f, -0.02573677f, 0.03096183f, 0.02281828f, 
    -0.05821889f, 0.00590684f, 0.04035788f, 0.00744994f, -0.05424022f, 0.05802185f, 0.03240681f, 0.06760700f, 
    0.10944253f, -0.04343496f, -0.08955817f, -0.01618875f, -0.00983016f, -0.06621500f, 0.02528173f, -0.02729590f, 
    0.01747010f, -0.02133775f, -0.03256684f, 0.07102407f, 0.00968357f, -0.06785276f, -0.02609257f, 0.01905265f, 
    0.09644540f, -0.12979378f, 0.01088889f, -0.08957358f, 0.18274690f, -0.15097363f, 0.00235646f, 0.05322915f, 
    0.00563646f, -0.00477048f, -0.01662296f, 0.02124805f, -0.02885129f, 0.05771692f, -0.01336382f, 0.06820732f, 
    -0.01315762f, 0.02092665f, -0.00435898f, 0.04565623f, 0.31211469f, 0.29937083f, 0.16165437f, -0.24595396f, 
    -0.07667133f, 0.06302214f, 0.12138505f, -0.03605835f, 0.05926437f, -0.07584676f, 0.02067002f, 0.02671945f, 
    -0.07473315f, -0.02785992f, 0.06027269f, -0.01185835f, 0.14267659f, 0.05749355f, 0.02367496f, -0.07993006f, 
    0.13528661f, 0.06982163f, 0.12480694f, -0.14758988f, -0.09130564f, 0.05236137f, 0.08032514f, 0.01185372f, 
    0.03797741f, -0.03379627f, -0.05056432f, -0.03979770f, 0.00629821f, 0.00759884f, -0.00897548f, 0.03885480f, 
    0.02987685f, -0.04951757f, 0.07020023f, -0.02514498f, -0.13077553f, -0.33286712f, -0.03928543f, 0.07049984f, 
    -0.09616036f, -0.00518530f, -0.07294336f, 0.04353973f, 0.05102427f, 0.00652138f, -0.01806965f, -0.07517006f, 
    -0.01600520f, -0.05789524f, 0.04839322f, 0.02503841f, -0.02517854f, -0.00484706f, 0.05761233f, 0.00406008f, 
    -0.11893847f, -0.30271301f, 0.08206432f, 0.06222677f, -0.10491356f, -0.05416638f, -0.08224406f, -0.00000476f, 
    -0.00208843f, 0.02926163f, -0.01237611f, -0.01630138f, 0.02392265f, -0.01419569f, 0.01934873f, -0.00318086f, 
    -0.06853617f, -0.07332613f, 0.05549689f, 0.01414873f, 0.09128099f, -0.17592472f, 0.12594226f, 0.07532861f, 
    0.04699674f, -0.02429081f, -0.04702719f, -0.04133416f, -0.07779767f, 0.02210632f, -0.10192373f, 0.00701698f, 
    0.02056041f, 0.05583490f, -0.05627168f, -0.03890552f, 0.04091522f, -0.04413085f, 0.06160342f, -0.09540481f, 
    -0.05964061f, -0.37173480f, 0.02412740f, 0.04736058f, -0.10358378f, 0.00989254f, 0.00788532f, 0.05467411f, 
    0.01485434f, 0.03703675f, 0.03763627f, 0.05621073f, -0.01328823f, 0.02080658f, -0.00134561f, -0.00261924f, 
    -0.01646124f, -0.03109467f, 0.10566375f, -0.01092002f, -0.16300964f, 0.11089407f, -0.09913895f, -0.15594092f, 
    -0.35098395f, 0.06736276f, 0.05084526f, -0.01976589f, 0.03703259f, 0.02606492f, 0.06235616f, -0.03257845f, 
    0.04708416f, -0.01406175f, -0.05521127f, -0.01585389f, -0.00677023f, 0.01262139f, -0.04188379f, 0.03465832f, 
    0.17474401f, 0.00616720f, 0.08434913f, -0.21621597f, 0.02721403f, -0.14592996f, -0.10476807f, -0.08819755f, 
    0.02627458f, -0.00959169f, -0.04133331f, -0.03439362f, -0.00008950f, -0.02010019f, -0.03610611f, -0.00146209f, 
    -0.00311206f, -0.04644344f, 0.04044580f, 0.07799915f, 0.10183078f, -0.39073655f, 0.00487576f, 0.22490828f, 
    -0.29849100f, -0.17833011f, -0.05546500f, 0.04875416f, 0.03567496f, 0.00506708f, 0.05662058f, 0.10156766f, 
    -0.04501880f, -0.02253392f, -0.02009587f, 0.00837780f, -0.09234101f, 0.00619499f, -0.03452737f, -0.03157419f, 
    0.15032215f, -0.00697614f, 0.08055847f, -0.10094820f, 0.17206372f, -0.13639303f, -0.06093564f, 0.01606180f, 
    0.02909464f, -0.03266785f, 0.00737783f, -0.01689442f, -0.00573539f, 0.01605139f, 0.00283840f, 0.02481179f, 
    -0.00101266f, 0.01765767f, 0.00842663f, 0.01693935f, 0.06021091f, 0.17912143f, 0.09219795f, -0.18290028f, 
    -0.36623517f, 0.10251299f, 0.05536225f, -0.01420883f, 0.11858095f, -0.03602457f, -0.01493726f, 0.00195877f, 
    -0.00201360f, 0.01786995f, 0.00168629f, 0.04673344f, 0.02676645f, -0.02982084f, 0.02850047f, 0.02272780f, 
    0.10952662f, 0.04687861f, 0.07560542f, -0.14129852f, 0.18666595f, -0.17108004f, -0.09030738f, 0.00437645f, 
    0.01672328f, 0.04041513f, -0.04870062f, 0.05868429f, -0.01216562f, -0.15068221f, 0.08653401f, 0.02125118f, 
    -0.00734027f, -0.03640674f, -0.06500844f, 0.01037848f, 0.08400913f, -0.02387814f, 0.07001454f, 0.01425393f, 
    0.00120224f, -0.03036002f, -0.11999653f, 0.00277163f, 0.01029307f, -0.01522961f, -0.06670490f, -0.05930328f, 
    -0.07072224f, 0.04450560f, -0.04540038f, 0.02604659f, -0.01115426f, 0.02565074f, -0.02116186f, -0.02886712f, 
    0.04783091f, 0.05281286f, -0.01899670f, -0.11145996f, -0.18012437f, 0.02369671f, 0.02996870f, 0.02563054f, 
    0.08021961f, 0.00034122f, 0.01962402f, 0.01477797f, 0.03740631f, -0.03366587f, 0.04407405f, 0.05709997f, 
    0.05817887f, 0.02241880f, 0.07070245f, -0.06069681f, -0.25602555f, -0.43457517f, -0.08158951f, 0.01626605f, 
    -0.02809441f, 0.03736691f, -0.04409188f, -0.01651187f, -0.01496669f, 0.02695167f, 0.03429861f, -0.01763037f, 
    -0.02483865f, 0.00083130f, 0.07777055f, 0.11793946f, 0.05233564f, 0.04939636f, -0.00219336f, -0.09242115f, 
    -0.12016916f, -0.26676059f, -0.13331354f, 0.12866098f, -0.02111602f, 0.04315905f, -0.03266681f, -0.05541713f, 
    0.02690437f, 0.02070067f, 0.02286124f, -0.03653864f, -0.08152575f, 0.02417986f, -0.01784404f, 0.02718190f, 
    0.00573794f, 0.05247834f, 0.00411255f, 0.03758045f, -0.08504368f, -0.06621137f, 0.00984556f, -0.01995096f, 
    -0.16818389f, 0.03368592f, -0.02978501f, -0.01041331f, -0.02799610f, -0.02342733f, -0.01968618f, 0.00105387f, 
    0.00520267f, -0.01612606f, 0.00535846f, -0.03660553f, -0.02794608f, -0.00034548f, -0.07103497f, -0.01059827f, 
    0.00842271f, -0.06874689f, -0.02161324f, -0.23129062f, 0.21870716f, -0.05397510f, -0.08138319f, -0.07291262f, 
    0.01827645f, -0.00458309f, 0.01976043f, -0.00441268f, 0.02743198f, 0.05087989f, -0.01548941f, 0.03064543f, 
    -0.05597969f, -0.03559420f, -0.02225603f, 0.08015263f, 0.21667054f, 0.05574705f, 0.00248955f, 0.00537267f, 
    -0.06454843f, -0.07863335f, -0.22486939f, 0.00639905f, 0.06713827f, 0.01928088f, -0.03315518f, 0.03352469f, 
    -0.07317922f, 0.00521704f, -0.02804034f, -0.00549751f, -0.04060958f, 0.07693943f, 0.07489762f, 0.02581675f, 
    -0.25825146f, 0.00105440f, -0.17314014f, -0.23486544f, 0.18018736f, 0.10444586f, -0.06815816f, -0.02524015f, 
    -0.05425415f, -0.10707348f, 0.11390361f, 0.13147211f, -0.06222808f, -0.02883494f, 0.08893650f, -0.01765249f, 
    -0.02512344f, -0.03777951f, 0.03100689f, 0.03184424f, -0.06798664f, -0.01895750f, 0.02554590f, -0.08505909f, 
    -0.12001489f, -0.03868475f, -0.03449996f, 0.06322487f, 0.00466849f, 0.12039054f, -0.00670355f, -0.01898254f, 
    0.05740280f, 0.04165557f, 0.01810350f, -0.04336216f, 0.08464251f, -0.01688572f, -0.04288136f, -0.08716353f, 
    -0.11978377f, -0.10297432f, 0.09989496f, -0.19317280f, -0.00517695f, -0.07264123f, -0.01159230f, -0.10044626f, 
    -0.02603307f, 0.06288566f, 0.16494033f, 0.08599998f, 0.03907473f, -0.02246994f, -0.09160592f, -0.06016653f, 
    0.02698328f, -0.08239783f, 0.04805906f, -0.06335548f, 0.22074462f, 0.03328479f, 0.00609094f, 0.04701364f, 
    -0.13327783f, 0.02245874f, 0.00663700f, 0.01279756f, 0.08819260f, 0.06558732f, 0.04621962f, -0.07175799f, 
    0.04147898f, 0.03887118f, -0.02750015f, -0.00242157f, 0.02925494f, -0.02756150f, -0.06261484f, -0.04168379f, 
    0.10344972f, -0.35952955f, 0.04970688f, -0.34448370f, -0.01292146f, -0.02694781f, -0.03455891f, -0.01996784f, 
    -0.07900887f, 0.00833978f, 0.06878219f, 0.01903933f, -0.01935774f, -0.01823882f, -0.08031497f, -0.07867782f, 
    -0.02556890f, -0.19098300f, 0.03649337f, -0.04652694f, -0.05267495f, 0.07645110f, -0.04623370f, 0.09165366f, 
    -0.31676623f, 0.01360952f, 0.02079729f, 0.02334290f, 0.03103772f, -0.03456123f, -0.02464416f, 0.00209335f, 
    0.01678055f, 0.07914247f, 0.00689613f, -0.02338443f, -0.01383928f, -0.07845060f, -0.04794537f, -0.01679151f, 
    -0.16206527f, 0.12495608f, -0.17028716f, -0.22014649f, 0.09192663f, 0.01895640f, 0.14206825f, -0.04270671f, 
    0.04221349f, -0.00939907f, -0.00896889f, -0.16582470f, -0.03845312f, 0.06024146f, 0.01650178f, 0.06050231f, 
    -0.04571122f, 0.03000785f, 0.00707995f, 0.10615091f, 0.06679565f, -0.01771031f, 0.06413522f, 0.08635539f, 
    0.07522025f, -0.00953264f, -0.05180797f, 0.03232208f, 0.03204377f, 0.10423931f, 0.08741049f, 0.13045008f, 
    -0.05140648f, 0.02345364f, -0.17549847f, 0.03653205f, -0.09759744f, -0.00464180f, 0.05803411f, -0.01266254f, 
    0.24250168f, -0.20072392f, -0.13709539f, -0.00721276f, -0.26761988f, 0.01450793f, 0.05987098f, -0.06202415f, 
    0.01305295f, 0.02528331f, 0.11520452f, 0.01824579f, 0.02572858f, -0.02576027f, 0.00686598f, 0.05955796f, 
    0.04992377f, -0.05337849f, 0.05252701f, -0.00759695f, -0.10067150f, 0.03844097f, 0.00427440f, 0.03033069f, 
    0.12524518f, -0.06847402f, 0.04824468f, 0.00284436f, -0.01941382f, 0.08260370f, 0.00839755f, -0.07937624f, 
    0.01825904f, -0.09957749f, -0.01886396f, -0.13263735f, 0.04237811f, 0.02716146f, -0.00826520f, 0.12468445f, 
    0.25092807f, 0.00998897f, 0.07452181f, -0.08301480f, 0.08939176f, -0.07481398f, -0.07351192f, 0.01881498f, 
    -0.02391098f, -0.04458511f, -0.01057499f, 0.00276110f, 0.04181111f, -0.02931136f, 0.06300231f, -0.02851888f, 
    0.04880738f, -0.01712902f, 0.00882879f, 0.00792620f, -0.01931483f, -0.07735103f, -0.03087589f, -0.06405271f, 
    0.08341466f, 0.07703882f, 0.03456595f, 0.05480245f, -0.05428089f, 0.02897455f, -0.00949452f, 0.01905543f, 
    0.07314162f, -0.00572200f, 0.02671198f, 0.02027248f, 0.01381416f, -0.02958832f, 0.00623403f, -0.00680964f, 
    0.27262035f, 0.04056213f, -0.04516669f, -0.06568038f, -0.07710248f, -0.06686357f, -0.11854284f, 0.01273502f, 
    0.00510895f, -0.02970137f, 0.09149864f, 0.05788045f, 0.07221917f, 0.07233366f, 0.00323519f, 0.10335115f, 
    0.02833847f, -0.03165279f, -0.12000683f, 0.00083524f, 0.22201541f, -0.59551567f, 0.10022020f, -0.18927455f, 
    -0.17736606f, -0.06926317f, 0.00504596f, -0.02979537f, 0.01611190f, -0.06481583f, 0.05216158f, -0.01317900f, 
    -0.02720084f, -0.05547898f, 0.02538554f, -0.08201079f, 0.02134563f, -0.12943612f, 0.03747335f, -0.04788136f, 
    -0.26658282f, 0.02749412f, -0.09631294f, -0.03597753f, -0.08999985f, 0.02860799f, -0.00582657f, -0.02322110f, 
    0.00496829f, 0.00015441f, -0.12575881f, 0.03164628f, -0.08410597f, -0.01817060f, -0.06320219f, -0.01863507f, 
    -0.07168316f, 0.07400950f, -0.03707645f, 0.05048426f, -0.32612088f, 0.19696860f, 0.01948524f, 0.07376526f, 
    -0.36711559f, -0.09898704f, 0.10411957f, 0.03217528f, -0.01814926f, 0.04175290f, 0.10543676f, 0.03749339f, 
    -0.01260847f, -0.08635312f, 0.00312685f, -0.06539400f, -0.06185041f, -0.10932619f, 0.16224889f, 0.05046165f, 
    -0.06952409f, 0.18057004f, -0.09118376f, -0.02708250f, 0.09276477f, -0.12928578f, 0.01803131f, 0.01450403f, 
    -0.08554021f, 0.20092881f, 0.07302111f, -0.10925306f, -0.04949563f, -0.09425283f, -0.07474101f, -0.24336420f, 
    0.07081667f, -0.01258343f, -0.05178375f, 0.24468021f, -0.24528334f, -0.06483344f, -0.08227444f, -0.11444222f, 
    0.14988548f, 0.06325459f, -0.08549547f, -0.00134505f, 0.01953406f, 0.08980337f, 0.03668547f, 0.06286002f, 
    -0.00665672f, -0.05537775f, 0.04806439f, 0.02999574f, -0.06802730f, -0.09281617f, -0.07319279f, -0.05601777f, 
    -0.42609838f, 0.16306704f, 0.09417871f, -0.17920144f, -0.43446010f, -0.05811802f, 0.05471857f, 0.01400624f, 
    -0.00513788f, -0.01553024f, 0.06232649f, -0.04544995f, 0.13470317f, -0.05381840f, 0.12912911f, -0.07536837f, 
    -0.03708748f, -0.20718329f, 0.01719894f, 0.09042802f, 0.04370422f, -0.07262772f, 0.13826795f, -0.07421713f, 
    0.08990188f, -0.05198762f, 0.02041020f, 0.03290122f, -0.03598525f, -0.01639523f, 0.03824852f, -0.06328452f, 
    0.04669539f, -0.06428115f, -0.07600988f, 0.02531295f, 0.04184770f, -0.14993192f, 0.01714197f, -0.05216383f, 
    0.03357667f, 0.06925806f, 0.06963049f, 0.05786412f, 0.10422593f, -0.01158986f, -0.07077897f, 0.07478277f, 
    0.01348386f, 0.03296396f, 0.00176994f, -0.01873327f, 0.01220454f, 0.06759172f, -0.03938921f, 0.05361957f, 
    0.03841517f, 0.02129355f, 0.08610077f, -0.00748971f, 0.15272589f, -0.39498994f, 0.01343973f, -0.12543248f, 
    -0.03809736f, -0.16063993f, -0.05833960f, -0.05757603f, 0.00588939f, 0.00070138f, 0.02259540f, -0.01472546f, 
    -0.08547525f, -0.00815908f, -0.05965525f, 0.00094497f, -0.08790951f, -0.00525877f, -0.03498891f, 0.01840839f, 
    0.10016830f, 0.15464418f, -0.02921737f, 0.13118939f, 0.10069977f, 0.03934734f, -0.01500211f, 0.07539632f, 
    0.00529159f, 0.04399490f, 0.01411240f, -0.00843742f, -0.05193014f, 0.07118157f, -0.11489125f, 0.07080014f, 
    0.08815702f, 0.00967252f, -0.06118459f, 0.02327082f, 0.16933627f, 0.09369727f, 0.03752248f, 0.08115561f, 
    0.20082423f, -0.03577624f, -0.02442330f, 0.02537926f, -0.06148070f, 0.03600311f, -0.01737939f, 0.06946538f, 
    0.04675905f, -0.00775901f, 0.07709941f, 0.02986825f, 0.06691931f, 0.02247592f, 0.02117215f, 0.03559227f, 
    0.28731525f, -0.38833708f, 0.10261347f, -0.13347834f, -0.06309593f, -0.07231620f, -0.12998730f, -0.07730661f, 
    0.06939462f, -0.05155088f, -0.06038056f, 0.04008954f, -0.12297914f, -0.00921667f, 0.07473021f, -0.10907184f, 
    -0.08304006f, 0.06858525f, -0.04297484f, -0.04385608f, 0.29207945f, 0.07932058f, 0.02065493f, -0.03372386f, 
    0.05980453f, -0.10448340f, 0.02366559f, -0.02202068f, 0.00211073f, -0.05524807f, 0.11688985f, -0.05486560f, 
    -0.04371625f, -0.01853963f, -0.03432966f, -0.00351463f, 0.02290017f, 0.07692135f, -0.00687289f, 0.15408847f, 
    -0.23075894f, 0.07331637f, -0.12383396f, -0.07034359f, 0.14828338f, 0.03665633f, 0.08844020f, -0.03458667f, 
    -0.11269395f, 0.02071428f, 0.05529962f, 0.12654817f, 0.02862410f, -0.02243728f, 0.03030703f, 0.04729554f, 
    -0.12045910f, 0.06562660f, -0.00686827f, -0.06928466f, -0.53252786f, 0.02904558f, -0.05900938f, -0.04903859f, 
    0.07353075f, 0.00092865f, 0.05720282f, -0.10372622f, 0.05657680f, -0.01224670f, 0.01376577f, -0.02393452f, 
    0.06565909f, -0.08891072f, 0.03111038f, 0.06481078f, -0.05955085f, -0.02212749f, 0.04147477f, -0.20696215f, 
    0.04244981f, 0.04117217f, 0.08205169f, -0.04698417f, -0.10971596f, -0.03770214f, 0.02960840f, 0.03086278f, 
    0.02259131f, 0.03383424f, 0.09234513f, -0.01396070f, 0.06646975f, -0.00886176f, -0.02668982f, 0.01096579f, 
    -0.01721630f, -0.00153340f, -0.04297130f, -0.04427268f, -0.02453316f, -0.06851781f, -0.14262955f, -0.19794336f, 
    0.09931775f, 0.05396125f, -0.05772795f, 0.06367303f, 0.05817881f, -0.03666274f, -0.06964344f, -0.06400340f, 
    0.00641859f, -0.00251423f, 0.06062960f, -0.07678833f, 0.04145845f, -0.06513916f, -0.07194741f, -0.04118535f, 
    0.00118951f, 0.03371833f, 0.03034364f, -0.00520312f, 0.14162149f, -0.03414365f, -0.00717539f, 0.04034000f, 
    0.01291274f, -0.01707720f, -0.11430738f, -0.06646696f, 0.04751638f, 0.05913442f, -0.03531252f, 0.00948530f, 
    0.02873292f, -0.08960500f, -0.01396891f, 0.04542066f, -0.15480062f, 0.17131603f, -0.05511610f, -0.02314807f, 
    0.00859058f, -0.05395830f, 0.09880477f, 0.02042217f, -0.04503470f, -0.05422901f, -0.04621238f, -0.02152176f, 
    0.04466630f, -0.00173264f, -0.02458042f, 0.03642913f, -0.04731987f, 0.10575322f, 0.04208555f, 0.02707927f, 
    0.34611577f, -0.37785655f, -0.00957594f, 0.01236502f, 0.09652627f, -0.08882942f, 0.00441747f, -0.01656234f, 
    0.00207482f, -0.02377386f, 0.07620779f, 0.01408380f, -0.10469179f, 0.02460002f, -0.08754081f, 0.06019663f, 
    -0.03482899f, -0.01701017f, -0.04520736f, 0.00758999f, 0.05722983f, -0.19331637f, -0.16780064f, -0.20554471f, 
    -0.02530621f, 0.00212561f, -0.02355511f, 0.08627114f, 0.07528273f, -0.02556972f, -0.06748792f, 0.00313262f, 
    0.01649014f, 0.02296009f, 0.07642722f, -0.04496204f, -0.06373778f, -0.18149836f, -0.02627978f, -0.02922547f, 
    0.20968868f, 0.08749307f, 0.13462548f, 0.04473533f, 0.09391835f, -0.07344862f, -0.08720879f, 0.01262731f, 
    0.00815526f, 0.01414424f, -0.03067657f, -0.06699426f, -0.06496455f, 0.16133733f, -0.10646760f, -0.06444138f, 
    0.05692946f, 0.00418132f, -0.00436873f, -0.06809522f, -0.11584951f, 0.05863168f, -0.13082689f, -0.18350585f, 
    -0.02528643f, 0.07079329f, 0.02087203f, -0.01930040f, -0.03785535f, 0.01889376f, -0.06202856f, 0.03480643f, 
    -0.00923951f, 0.03847753f, 0.05406556f, -0.01636947f, 0.00012263f, -0.02094782f, -0.02288963f, 0.00646911f, 
    -0.40108249f, -0.00064940f, -0.04590087f, -0.00291020f, -0.09065102f, 0.11125904f, -0.00183577f, -0.04274277f, 
    0.07199751f, -0.01662104f, -0.01091648f, 0.08695464f, 0.03731933f, -0.04542146f, -0.06900450f, -0.01430411f, 
    -0.05908860f, 0.01068604f, 0.05797094f, -0.04945717f, 0.13968448f, -0.32740977f, 0.08825503f, -0.06320592f, 
    -0.04872900f, -0.04336242f, -0.00436588f, -0.06286860f, 0.03618780f, -0.02837618f, 0.02045576f, 0.01868495f, 
    -0.04970582f, 0.01875686f, 0.03271459f, -0.05833654f, 0.08198649f, -0.03294976f, 0.03840588f, 0.03946339f, 
    0.41956449f, -0.19906093f, -0.09503425f, -0.06253561f, 0.07211088f, 0.04998601f, 0.00169648f, -0.00797448f, 
    0.00746967f, 0.00396214f, -0.00595834f, -0.04677197f, 0.02794752f, -0.02425967f, 0.09398670f, 0.03252349f, 
    -0.03737071f, 0.11960164f, 0.03628545f, 0.18558612f, -0.11418902f, -0.04340822f, 0.04575434f, 0.02542322f, 
    -0.00052993f, -0.07302907f, -0.04545021f, -0.06875190f, 0.01706357f, 0.06856350f, 0.06706893f, -0.00797042f, 
    -0.02811176f, -0.01276254f, 0.01224730f, -0.01185710f, 0.05084290f, -0.01135846f, 0.05406104f, 0.10236735f, 
    -0.22109443f, 0.07311613f, -0.04407873f, -0.02051212f, -0.27801722f, 0.02978680f, -0.02169820f, -0.11727571f, 
    0.10413358f, -0.03036493f, -0.00658710f, -0.01450092f, -0.14657985f, 0.00576572f, -0.05019828f, -0.07624631f, 
    -0.00450472f, 0.03543060f, -0.06048128f, -0.04888056f, 0.09165469f, -0.03646780f, -0.09041630f, -0.12857530f, 
    0.16289507f, 0.04160051f, 0.03084185f, 0.03050729f, -0.02136785f, 0.02767543f, 0.08088052f, -0.00267294f, 
    0.00915190f, -0.06169655f, 0.02993860f, -0.00725695f, -0.00546855f, -0.07021071f, 0.04830012f, 0.06201471f, 
    -0.15349108f, 0.16164713f, 0.00407463f, 0.02266671f, -0.17151040f, 0.02812221f, 0.00997885f, -0.00855305f, 
    -0.06163508f, 0.09229229f, 0.04829207f, 0.07940330f, 0.00153095f, -0.03647310f, 0.03218290f, 0.06747729f, 
    -0.06588442f, 0.04429032f, 0.03881178f, 0.02561826f, 0.19408435f, 0.24291790f, 0.05055280f, 0.06064316f, 
    0.10294242f, -0.01977121f, 0.04185232f, 0.04338275f, -0.01102566f, 0.10735568f, -0.02702066f, 0.03894749f, 
    0.05731545f, -0.02126192f, -0.04213193f, 0.02077608f, 0.06416923f, 0.09124245f, 0.02407040f, -0.01885618f, 
    0.07237475f, -0.01965696f, 0.14565845f, -0.02545864f, 0.11400673f, -0.07185224f, -0.10302026f, 0.02790304f, 
    -0.01258708f, -0.04174318f, -0.07001437f, 0.02873376f, -0.02661669f, 0.02672973f, -0.00851552f, -0.03926306f, 
    0.10034281f, -0.05024508f, 0.05148333f, -0.03944060f, -0.06512945f, -0.16052201f, -0.17264998f, -0.07496188f, 
    -0.05414752f, -0.01947461f, -0.07833420f, -0.04865778f, -0.06379083f, 0.08253638f, 0.07387319f, 0.05293420f, 
    -0.10461435f, -0.07190824f, 0.09264200f, 0.03727347f, 0.06707348f, 0.00833632f, -0.00348009f, 0.05918426f, 
    -0.10776284f, 0.12104331f, -0.04654321f, 0.05217603f, 0.00814085f, -0.01597884f, 0.04340886f, -0.07468742f, 
    -0.00941350f, 0.02408646f, 0.07115280f, 0.04486870f, -0.07021467f, 0.01257728f, 0.06054036f, 0.06575812f, 
    0.02332699f, -0.03952492f, 0.01548892f, 0.07580822f, 0.14795697f, 0.03436822f, -0.14834344f, 0.03361031f, 
    -0.07077373f, 0.06098820f, 0.01658923f, -0.02953829f, -0.00815652f, 0.13703489f, -0.10261140f, -0.06322352f, 
    0.04314932f, 0.08054126f, -0.04543678f, 0.02046818f, 0.14526224f, -0.12222498f, -0.07345171f, 0.02146616f, 
    0.12982097f, -0.27251360f, -0.01698211f, 0.03328402f, 0.06126715f, -0.07631425f, 0.06328250f, -0.01622300f, 
    0.11573917f, 0.01586010f, -0.07924319f, 0.03617632f, 0.04065563f, 0.02561366f, -0.05498731f, 0.09647301f, 
    -0.03800340f, 0.07822424f, -0.08090986f, -0.06098497f, -0.08075128f, -0.10711639f, -0.03906444f, -0.11116140f, 
    -0.02413376f, 0.10823382f, -0.00128822f, 0.03857844f, 0.05865514f, 0.00546792f, -0.02519654f, -0.06052114f, 
    0.03645804f, 0.01480721f, -0.01145562f, -0.03209297f, -0.09697253f, -0.15179349f, -0.10967769f, 0.08857229f, 
    -0.09908206f, -0.19981372f, 0.01719908f, 0.01334661f, -0.02334812f, -0.00269984f, -0.01023531f, 0.01141247f, 
    0.08148999f, 0.04353376f, -0.13479008f, -0.06435145f, 0.04804919f, -0.00263702f, 0.03253834f, 0.06802648f, 
    0.05388578f, -0.03635491f, -0.08211181f, 0.00661173f, 0.24176373f, -0.12812275f, -0.10056385f, -0.00397757f, 
    -0.26204154f, 0.00270697f, 0.03585896f, 0.00238721f, -0.01738212f, 0.02856377f, 0.05095216f, 0.02471419f, 
    0.02922037f, -0.00735455f, -0.02818657f, 0.06729695f, 0.08469424f, -0.02595345f, -0.05967238f, 0.03777802f, 
    0.03212776f, 0.09109673f, 0.06882027f, 0.13402006f, 0.14181995f, -0.03373943f, -0.06373097f, 0.08483670f, 
    0.03404608f, 0.03043833f, -0.00003618f, -0.03290756f, 0.07073769f, 0.06203434f, -0.02882007f, 0.04813473f, 
    0.02410175f, -0.04263473f, 0.00888863f, -0.03636395f, -0.25080806f, -0.11107713f, -0.11548281f, 0.13084766f, 
    0.06967714f, 0.01937936f, -0.03998386f, -0.06615912f, -0.04199787f, 0.03477915f, 0.07367952f, -0.06782874f, 
    -0.00882919f, -0.05652031f, -0.07311202f, -0.04979311f, -0.03351633f, -0.04185489f, -0.11776146f, 0.01218610f, 
    -0.05665455f, -0.00102588f, 0.13530441f, 0.04776374f, 0.09106230f, -0.04362900f, -0.07649948f, 0.02880285f, 
    0.00244807f, 0.00131718f, -0.06538321f, 0.04511921f, 0.05146060f, 0.04522290f, -0.02919035f, -0.02254152f, 
    0.02314153f, -0.08139261f, 0.00647256f, -0.05613030f, 0.14899021f, 0.10673909f, -0.12381074f, 0.03919502f, 
    -0.22754797f, -0.00060061f, 0.03029600f, 0.00954834f, -0.03737729f, 0.08578378f, -0.03128193f, 0.05770797f, 
    -0.13015065f, 0.05159742f, 0.02729786f, 0.06443246f, 0.04366863f, -0.01820601f, -0.00546851f, 0.00187045f, 
    0.05110029f, 0.14818248f, 0.13263644f, 0.15243229f, 0.17790875f, -0.02634364f, -0.04631551f, 0.04614909f, 
    0.03180312f, -0.00743021f, -0.03594533f, -0.01240660f, -0.05725338f, 0.08870767f, -0.14272386f, 0.01940901f, 
    -0.02209570f, 0.05309998f, -0.02133362f, -0.00042162f, 0.08074135f, 0.01219694f, 0.06474741f, -0.02929206f, 
    0.15096213f, -0.10737976f, 0.00237988f, 0.01507503f, -0.02417114f, -0.01741629f, 0.01301468f, -0.03666573f, 
    0.06459636f, -0.07605535f, 0.07656453f, 0.00779819f, -0.04796143f, -0.08154783f, -0.00615777f, 0.03711480f, 
    0.06580888f, -0.03560414f, -0.13265523f, 0.04820993f, -0.07860110f, 0.02295538f, -0.00347249f, -0.04188531f, 
    -0.02600206f, 0.12370162f, -0.04160405f, -0.00191073f, -0.04128563f, 0.03614499f, -0.06013672f, 0.06637561f, 
    0.08621215f, 0.00192048f, -0.02991828f, 0.05197778f, -0.02844845f, 0.10453139f, -0.01928593f, -0.01533869f, 
    -0.04050976f, 0.09831651f, -0.01425482f, 0.07787789f, 0.00300920f, 0.00377301f, 0.01489305f, -0.04903088f, 
    0.01787717f, -0.00630840f, -0.04641899f, 0.06630914f, 0.04457478f, -0.23984231f, -0.00715451f, -0.04132335f, 
    0.06803639f, -0.01614653f, -0.10680752f, -0.14432310f, -0.18544553f, 0.00621428f, -0.05935612f, 0.04820324f, 
    0.03203277f, 0.07016551f, -0.02422707f, -0.02386356f, 0.02948962f, 0.03869135f, -0.03587893f, -0.03968472f, 
    -0.01194639f, -0.11810665f, -0.21790148f, -0.19373666f, 0.12371968f, -0.04175868f, -0.10188372f, 0.03791467f, 
    -0.12018910f, 0.05531359f, -0.00945361f, 0.02322021f, 0.08022165f, 0.04899814f, 0.03126784f, -0.01298161f, 
    -0.00357436f, 0.03877963f, 0.02062145f, 0.01306166f, 0.05027783f, -0.05049261f, -0.02208147f, -0.10348941f, 
    0.16796853f, 0.16949777f, 0.14995249f, -0.03358451f, 0.03427383f, -0.00097801f, -0.09289940f, -0.03935748f, 
    0.03199421f, -0.06771947f, -0.07180330f, -0.02479410f, -0.01372144f, -0.03397264f, 0.05171453f, -0.02775380f, 
    0.05541823f, 0.11132308f, 0.01958939f, -0.09089896f, 0.23226330f, -0.10967504f, -0.08294880f, 0.06810769f, 
    0.05167751f, 0.04648764f, -0.06404795f, 0.01504443f, -0.01946558f, -0.04806215f, 0.10111653f, -0.07376451f, 
    0.00657026f, -0.05436210f, 0.06037794f, -0.04919260f, 0.04681995f, -0.16277736f, -0.03753001f, -0.01006214f, 
    0.09390860f, 0.25866386f, 0.01720612f, 0.00313292f, 0.10260727f, -0.01367359f, -0.06268433f, 0.03377670f, 
    0.01430417f, 0.00867355f, -0.09034038f, 0.01065173f, -0.05964897f, 0.07197105f, -0.05380689f, 0.01376127f, 
    0.01870962f, 0.05918153f, 0.04197764f, -0.02927234f, 0.12348685f, -0.06011970f, -0.09885047f, -0.07369432f, 
    -0.14351109f, 0.02994088f, -0.02285330f, -0.15038484f, 0.00540442f, 0.02476567f, 0.02148620f, -0.00984698f, 
    -0.03552680f, -0.05955001f, 0.00658322f, -0.13362122f, 0.04857572f, -0.03180719f, 0.00783432f, -0.04211086f, 
    -0.18086895f, 0.02950235f, 0.01089465f, 0.21313149f, -0.13083661f, 0.06057978f, -0.04981514f, 0.01386045f, 
    0.08577672f, 0.03958986f, 0.02539333f, -0.02692583f, -0.06250875f, 0.07057825f, 0.06158574f, 0.05280576f, 
    -0.00694380f, 0.00616652f, -0.03196650f, -0.02348840f, 0.20544922f, -0.18856412f, 0.05610650f, 0.09470305f, 
    -0.06294822f, -0.11780645f, -0.03790483f, -0.02311468f, -0.05365695f, 0.02620258f, -0.01480282f, -0.00563125f, 
    0.03698350f, -0.05829857f, -0.02789391f, 0.04856561f, -0.07424499f, 0.03893484f, 0.03507146f, 0.05127110f, 
    -0.20251502f, -0.19314359f, -0.09337015f, -0.13457237f, -0.26280060f, -0.00983052f, -0.07049001f, 0.06839921f, 
    0.03030321f, 0.05636459f, -0.02040775f, -0.00035255f, -0.01986054f, -0.02896974f, -0.02763082f, -0.02606364f, 
    0.03417471f, 0.01466431f, 0.05383785f, -0.01053046f, 0.24343784f, -0.31024441f, -0.06351031f, -0.08327075f, 
    -0.10373143f, -0.08487172f, -0.01575861f, -0.04918396f, -0.01359916f, -0.01977534f, 0.02707995f, -0.01163156f, 
    -0.00181840f, -0.03456300f, 0.01916952f, 0.01129886f, 0.01955409f, 0.02716637f, 0.01505123f, -0.03448730f, 
    0.17267087f, 0.10406996f, -0.22435962f, -0.09439775f, -0.06090946f, -0.00383879f, 0.12173901f, 0.00918981f, 
    -0.10625495f, 0.01923191f, -0.05489419f, -0.01045964f, 0.06339357f, 0.01853887f, 0.02060304f, -0.03890829f, 
    -0.00978095f, -0.06636807f, -0.00659975f, 0.04497210f, -0.13769391f, 0.13247015f, -0.03739488f, -0.00223998f, 
    0.00535884f, 0.10082246f, -0.07080384f, 0.00723289f, 0.11969553f, 0.04426811f, -0.10101277f, -0.06750771f, 
    0.03494334f, -0.03139615f, 0.00924514f, -0.16606721f, 0.03133101f, 0.00650671f, -0.03478885f, 0.00759738f, 
    -0.03842020f, -0.12187308f, 0.19065581f, 0.09420086f, 0.22001016f, -0.11915195f, -0.07356072f, -0.06152928f, 
    -0.00847163f, 0.04854930f, 0.01550221f, -0.03291389f, -0.05383262f, 0.01497546f, 0.04128709f, -0.04027392f, 
    -0.01504725f, -0.09080237f, -0.01018001f, 0.05060774f, 0.18045211f, -0.10085796f, -0.06731723f, -0.00866663f, 
    -0.03883507f, -0.00422713f, 0.05543482f, 0.03934044f, -0.03847046f, 0.00370091f, 0.01378857f, -0.02206729f, 
    0.01965472f, -0.05994273f, 0.02633621f, -0.01201848f, -0.02344761f, -0.06058430f, 0.05157488f, -0.01992415f, 
    0.10090009f, 0.04022933f, 0.06637496f, -0.11028763f, 0.01514231f, 0.03597165f, 0.00275328f, 0.06807096f, 
    -0.04227718f, 0.03664750f, -0.05243913f, -0.00651447f, -0.01654554f, -0.01938334f, -0.02045332f, 0.00364516f, 
    -0.08983061f, 0.02917860f, 0.00330214f, -0.04669091f, 0.05158751f, 0.12692842f, -0.07113031f, -0.02608383f, 
    -0.05224773f, 0.06972308f, 0.05271880f, 0.01554093f, -0.03297410f, -0.04325739f, -0.03630614f, -0.00483079f, 
    -0.01998213f, 0.00364198f, -0.04924386f, -0.00282019f, 0.01037622f, 0.02004133f, 0.02064362f, -0.00205701f, 
    0.10810896f, 0.15424284f, -0.00669284f, -0.13081731f, -0.04923286f, 0.08206168f, 0.04532007f, 0.01947332f, 
    -0.14659832f, -0.02325886f, -0.06396535f, -0.06297551f, 0.00027029f, -0.08658370f, -0.03087488f, 0.02578032f, 
    0.05083891f, 0.00821494f, 0.00737845f, -0.00932912f, -0.29696834f, -0.22932099f, 0.09124358f, -0.16802537f, 
    -0.12500545f, 0.02086996f, -0.07718059f, 0.01239490f, 0.07742655f, 0.07365455f, -0.05578168f, 0.01130656f, 
    -0.01452086f, -0.00354314f, -0.06162455f, -0.00525964f, -0.07369963f, -0.01543161f, -0.00766200f, -0.04723334f, 
    0.15500486f, 0.04770564f, -0.13252378f, 0.04674882f, -0.00971290f, -0.03373505f, 0.03393383f, 0.05348381f, 
    0.00143649f, -0.05384101f, -0.00252284f, -0.05663168f, 0.00879808f, -0.00864250f, 0.00302987f, 0.02222994f, 
    -0.02107765f, -0.07722243f, 0.02538977f, -0.00981414f, -0.17962468f, -0.08411957f, 0.09046557f, -0.06226037f, 
    -0.08331590f, -0.01767756f, 0.07656544f, -0.04892568f, -0.11183736f, -0.02823691f, -0.04635480f, -0.05611617f, 
    0.01388140f, -0.01714247f, 0.01898523f, -0.05582083f, 0.04503333f, 0.01443049f, -0.05267214f, 0.01882779f, 
    0.28733939f, -0.09651022f, -0.10419480f, 0.00852941f, -0.03148673f, -0.08453422f, 0.01933270f, 0.06095570f, 
    0.02777110f, 0.01151067f, -0.02513529f, 0.08781915f, 0.05438809f, -0.04082888f, 0.10710514f, -0.04474954f, 
    -0.00573129f, -0.03555007f, 0.07393131f, -0.02467506f, 0.09498589f, -0.17651108f, 0.03333622f, -0.13907334f, 
    -0.11030293f, 0.00339661f, -0.02538945f, 0.00188335f, 0.01350875f, 0.00069615f, -0.01401828f, -0.05006647f, 
    -0.00542312f, -0.04825117f, -0.03228872f, -0.01748621f, -0.02454010f, 0.05213444f, 0.05700247f, 0.00458699f, 
    -0.12130360f, -0.27215666f, -0.15232737f, -0.02483989f, -0.18957748f, -0.02709954f, 0.08332314f, 0.02820284f, 
    -0.03705404f, -0.07418205f, 0.06816976f, -0.08171700f, 0.04003701f, -0.05719915f, -0.01702900f, 0.05474570f, 
    0.04711659f, 0.05649698f, -0.04971024f, -0.03921723f, -0.27457809f, -0.13574088f, 0.06675816f, -0.10415673f, 
    -0.06858262f, 0.01407696f, -0.07915697f, -0.07352500f, -0.04033533f, 0.07765190f, -0.06036693f, 0.05329150f, 
    -0.07512417f, -0.05280413f, -0.01083386f, 0.00691594f, 0.00983551f, 0.01202716f, -0.01248473f, 0.00351647f, 
    -0.16196714f, 0.06034727f, 0.06299031f, -0.04097535f, 0.03947599f, 0.03829505f, -0.01645865f, -0.01059593f, 
    0.05058501f, 0.02489643f, -0.01733609f, -0.05454866f, 0.04046148f, -0.00806729f, -0.00330551f, -0.00578095f, 
    -0.03440450f, -0.06487172f, -0.00901823f, 0.00753024f, 0.40841275f, 0.01503908f, -0.13179892f, 0.19577470f, 
    -0.11713080f, -0.03277772f, -0.09106547f, 0.02572124f, 0.10419570f, 0.07351822f, 0.03370263f, 0.04218538f, 
    0.00005661f, 0.05823206f, -0.03263111f, -0.00846227f, -0.02503606f, -0.08068375f, -0.01002355f, -0.00628804f, 
    -0.02265290f, 0.07737757f, -0.04875704f, -0.08393962f, 0.06084944f, 0.02894893f, 0.05041751f, 0.07571020f, 
    0.01740609f, -0.03198845f, -0.01244938f, -0.01099187f, -0.01121945f, -0.00597314f, -0.02209569f, -0.00124906f, 
    -0.02420865f, -0.08260830f, -0.02463617f, -0.01875248f, 0.06305749f, 0.06564505f, 0.03303654f, -0.00108874f, 
    0.00173394f, -0.01545963f, 0.04067812f, 0.02193726f, 0.00156221f, -0.04215268f, -0.00430914f, -0.00343871f, 
    -0.00300516f, 0.01455039f, -0.01756657f, -0.01209782f, -0.04949207f, -0.02678155f, -0.04404965f, 0.01937416f, 
    -0.02034761f, 0.00900775f, -0.08381315f, -0.03549708f, -0.17282106f, 0.03414938f, -0.13253766f, 0.17164075f, 
    0.07894761f, 0.03254355f, -0.06136633f, 0.00730137f, -0.00338995f, -0.00518315f, -0.00255610f, -0.04354512f, 
    0.01228283f, 0.04944445f, 0.05868152f, -0.00735999f, -0.00544918f, 0.07292141f, 0.04730558f, -0.01581673f, 
    0.02383529f, -0.02568035f, -0.00811169f, 0.04272551f, -0.00776225f, 0.02561601f, 0.01052709f, -0.00929304f, 
    0.07294644f, -0.00748653f, -0.05126086f, -0.02659474f, -0.06291419f, -0.03572986f, -0.00793248f, 0.01180908f, 
    0.24403287f, 0.04448578f, -0.14145640f, -0.00824258f, 0.04843948f, -0.04731009f, 0.01476113f, 0.05041546f, 
    0.03700287f, 0.10823885f, -0.05286093f, 0.06000727f, 0.03144863f, 0.02146879f, -0.01183837f, -0.02556701f, 
    0.00333823f, -0.04062240f, -0.00981715f, 0.00651224f, 0.26437715f, 0.01265697f, 0.02902817f, -0.07591596f, 
    0.08927955f, 0.08077531f, -0.03864540f, -0.09452499f, 0.04045412f, 0.02237576f, 0.01813986f, 0.09173994f, 
    0.02670688f, 0.03749840f, 0.03743338f, -0.04235356f, -0.00496699f, -0.03403075f, -0.02638431f, 0.02120184f, 
    -0.25233296f, 0.20596749f, -0.04497807f, -0.08747559f, 0.02995977f, -0.02075587f, 0.07033464f, -0.00093676f, 
    0.04241441f, 0.00152768f, 0.00077827f, -0.05975237f, 0.04024147f, 0.00001757f, 0.04499765f, 0.04580984f, 
    0.03235755f, -0.03348615f, 0.06804428f, 0.01667891f, -0.18658756f, 0.01044089f, -0.08122165f, -0.10078631f, 
    -0.08698326f, 0.07489348f, 0.03222451f, 0.00200018f, -0.03662810f, 0.00547496f, 0.03857347f, 0.02686689f, 
    -0.04548755f, -0.03201636f, -0.04409150f, -0.00117140f, -0.02988373f, 0.02790683f, -0.03780599f, -0.04526672f, 
    0.02582905f, -0.02557310f, 0.00786191f, -0.06424063f, 0.02998602f, 0.07831730f, 0.04558264f, 0.08620393f, 
    -0.02075319f, 0.00802841f, -0.04343520f, -0.00382332f, -0.03741449f, -0.01905875f, -0.08084712f, 0.00565639f, 
    0.02526182f, -0.03613738f, -0.17107987f, -0.01395148f, 0.19081073f, 0.08121649f, -0.17697811f, 0.02639418f, 
    -0.02987793f, -0.05723352f, 0.03052506f, 0.04041930f, 0.02863812f, 0.03178913f, 0.01249215f, 0.03551638f, 
    0.00806978f, 0.01171207f, -0.00314947f, 0.01014700f, -0.01730355f, -0.07827333f, 0.02537219f, 0.00519666f, 
    0.23363416f, 0.01124293f, 0.11590543f, -0.03298507f, -0.01553797f, -0.00370253f, -0.07667230f, 0.02267107f, 
    0.07338569f, 0.06763534f, 0.00114684f, 0.02981199f, 0.04663864f, 0.01839648f, 0.03345501f, 0.05350877f, 
    -0.03995516f, -0.00253929f, 0.03167953f, -0.04206266f, -0.07989549f, -0.12623665f, -0.06459709f, -0.13829634f, 
    -0.11258387f, 0.06841969f, -0.02633691f, 0.03696711f, -0.06908476f, 0.04063667f, -0.04314840f, 0.04568482f, 
    -0.01724940f, -0.06243474f, -0.00046858f, 0.03244060f, -0.05109957f, 0.10891121f, 0.00418930f, -0.02102244f, 
    0.20526068f, -0.09335651f, 0.02646551f, -0.14771888f, 0.06752513f, 0.05890864f, -0.03033140f, 0.10324708f, 
    -0.01463456f, 0.01655887f, -0.03195145f, 0.00712866f, 0.08182450f, -0.01496738f, -0.04339376f, 0.04378031f, 
    -0.00132494f, 0.03017105f, -0.02136258f, -0.09788307f, 0.09119493f, 0.12147773f, -0.09910498f, -0.04420622f, 
    -0.06353696f, 0.09761598f, 0.11683920f, 0.06166475f, -0.05371093f, -0.02536216f, 0.01244898f, 0.03964219f, 
    0.03099191f, -0.05663603f, -0.05987727f, 0.02008414f, 0.02981622f, -0.01876284f, 0.04849866f, -0.00668912f, 
    0.12299367f, -0.02339166f, -0.08754816f, 0.06387316f, -0.19331568f, -0.08677209f, 0.08843793f, -0.06116618f, 
    -0.03492481f, 0.00262894f, -0.01240207f, 0.00604678f, 0.01143267f, -0.04936996f, -0.03561469f, -0.01342247f, 
    -0.00614173f, -0.08274531f, -0.00397679f, -0.07982373f, 0.00335030f, 0.00949101f, 0.02056588f, 0.04159405f, 
    -0.08751751f, -0.00200119f, -0.10745158f, 0.00694778f, 0.02985118f, 0.04619605f, -0.05202953f, -0.05993981f, 
    -0.00487461f, 0.00446167f, -0.02429394f, 0.00956857f, -0.03818240f, -0.05163860f, -0.00533762f, -0.02708864f, 
    -0.04069326f, -0.03969675f, -0.06784434f, 0.09045520f, -0.18135175f, 0.00134619f, -0.00511279f, 0.00346646f, 
    -0.08522903f, 0.10418001f, -0.00482968f, 0.01693796f, 0.00675262f, 0.03741067f, 0.07641625f, -0.01679495f, 
    -0.07071777f, -0.06165842f, -0.02314456f, 0.01547870f, -0.11731853f, 0.09115635f, 0.14259936f, 0.10963861f, 
    0.04263993f, 0.05840288f, -0.12136227f, -0.05926372f, 0.00941441f, 0.06778403f, -0.03884709f, -0.03111402f, 
    0.02108335f, 0.05375608f, -0.01571828f, -0.17167979f, 0.01634736f, -0.10168058f, -0.03564890f, -0.10046294f, 
    0.04367178f, -0.08265230f, -0.04132721f, 0.09347165f, -0.10562599f, -0.09722788f, -0.02394779f, 0.00882741f, 
    -0.04762829f, -0.01453472f, 0.03830292f, 0.04108492f, 0.03248460f, 0.00771438f, 0.00420861f, 0.01380021f, 
    -0.08987506f, -0.05436228f, -0.03079600f, -0.06471501f, -0.12311812f, 0.00917136f, -0.04783231f, -0.01748185f, 
    -0.04935298f, 0.04508892f, -0.01985775f, -0.00877552f, -0.08894798f, 0.00951208f, -0.03658999f, 0.02685829f, 
    -0.00336610f, -0.04702349f, 0.00382183f, -0.01641046f, -0.07821820f, 0.10234499f, 0.02751768f, -0.00268449f, 
    -0.22896987f, 0.08736097f, -0.08460577f, -0.00035940f, -0.03532670f, -0.04328004f, 0.01234490f, -0.03311535f, 
    0.00075438f, -0.03693632f, 0.05594908f, -0.04041750f, 0.02509256f, -0.02725742f, 0.03566416f, -0.03846477f, 
    0.01651770f, -0.05652960f, -0.04096988f, -0.02480627f, -0.02026308f, -0.02166729f, -0.04030825f, -0.09974349f, 
    -0.03410388f, 0.01207395f, 0.02640009f, 0.04166356f, 0.05352642f, 0.04476613f, -0.04014399f, 0.04601372f, 
    0.01936105f, 0.01007691f, -0.00140453f, -0.06901311f, -0.05818529f, -0.03553262f, -0.03851850f, 0.02563178f, 
    0.16812558f, -0.02437474f, 0.06240397f, -0.07306527f, -0.06948040f, -0.01843133f, -0.09570902f, 0.09721912f, 
    -0.05370285f, -0.02202282f, -0.02279487f, 0.03961148f, 0.07296573f, -0.04656162f, -0.02077928f, 0.03799271f, 
    -0.07128664f, 0.03849052f, -0.00111566f, -0.04945744f, 0.24743767f, -0.01782695f, 0.18017009f, -0.03156700f, 
    0.10514946f, -0.05997169f, -0.03379280f, -0.08438046f, 0.02151219f, 0.08311161f, 0.06309087f, -0.05961114f, 
    0.03889603f, 0.04471170f, -0.00716126f, 0.01556245f, -0.08914003f, -0.00258404f, -0.02387354f, -0.02156667f, 
    0.16586889f, 0.07146328f, 0.07725640f, 0.03081233f, 0.11537727f, -0.00602454f, -0.08104344f, -0.05127019f, 
    0.02655937f, -0.00621870f, -0.00602542f, -0.01869084f, -0.00708134f, -0.04778654f, -0.02346725f, 0.00993484f, 
    -0.06366605f, -0.05684199f, -0.05155419f, 0.01748848f, -0.11223318f, -0.29658905f, 0.10006393f, -0.04143876f, 
    -0.09355665f, -0.02469115f, -0.05970383f, -0.03515262f, 0.00993759f, -0.00728532f, 0.04945351f, 0.00939912f, 
    0.02079141f, -0.03043285f, 0.00121229f, 0.03833650f, -0.02573245f, 0.01654218f, 0.00241603f, -0.01022130f, 
    0.31907439f, -0.13191584f, 0.04954046f, -0.07421229f, -0.20803852f, -0.02072541f, 0.02621274f, 0.08770029f, 
    -0.05237555f, 0.00775868f, -0.02177626f, 0.03035454f, -0.02139683f, -0.06522430f, -0.02785422f, 0.01127116f, 
    -0.03472869f, 0.05593290f, 0.03641181f, -0.01668997f, -0.20830737f, -0.00233023f, 0.04678474f, -0.11523278f, 
    -0.12055973f, 0.03528992f, 0.04608193f, -0.00509458f, 0.04561606f, 0.03309913f, -0.00734134f, 0.03028261f, 
    0.04756228f, -0.04052210f, -0.05057968f, 0.02773295f, 0.00284524f, 0.02295777f, -0.01419114f, -0.10240424f, 
    0.28543302f, 0.01753915f, -0.01454113f, -0.16805233f, -0.16390918f, -0.04931808f, 0.04528987f, -0.06446024f, 
    0.02509500f, -0.01680808f, 0.05282637f, 0.00481486f, 0.02436987f, -0.07808717f, -0.07070210f, 0.00257819f, 
    0.06150832f, 0.08402123f, 0.00435338f, -0.06962486f, 0.23060955f, -0.01902057f, 0.02302861f, 0.09310446f, 
    0.16764133f, -0.18061173f, -0.04905356f, -0.06126920f, -0.02079016f, -0.02300913f, 0.03459948f, -0.02530203f, 
    -0.01042382f, 0.00580642f, -0.02058597f, -0.03962888f, 0.00196021f, 0.01639502f, -0.02334425f, 0.01978978f, 
    -0.21867581f, 0.12581085f, 0.02127683f, -0.15335479f, 0.07145710f, 0.05799839f, 0.04604256f, 0.08190052f, 
    0.03423915f, -0.02849514f, -0.04660789f, 0.01824145f, 0.00166066f, -0.05809228f, -0.03896399f, -0.04220891f, 
    -0.02300885f, -0.07302728f, -0.06462491f, 0.01757680f, 0.31579483f, 0.16199444f, -0.04019351f, -0.12891153f, 
    -0.13439694f, -0.09784274f, 0.10222816f, -0.01970293f, 0.02312944f, 0.00011356f, -0.03064007f, -0.02881556f, 
    -0.00444552f, -0.02113365f, -0.11236738f, 0.10036846f, 0.09991085f, 0.00368715f, 0.11839319f, -0.08480971f, 
    -0.02940638f, 0.05831041f, 0.05376657f, -0.10094844f, 0.00560889f, 0.01114255f, 0.03120454f, 0.13981037f, 
    -0.01624619f, -0.04681415f, -0.08639224f, 0.03689069f, 0.02543353f, -0.02407256f, 0.00512525f, 0.05874474f, 
    -0.07224405f, 0.00981525f, -0.08251371f, -0.06513051f, 0.27092376f, -0.06938105f, 0.12203711f, 0.05864026f, 
    0.22127587f, -0.11784151f, -0.09403389f, -0.11653473f, 0.05372385f, 0.02880118f, 0.09954354f, -0.00586053f, 
    -0.00729866f, -0.06956480f, 0.00384629f, -0.03076035f, -0.07247993f, -0.02508684f, 0.04519387f, 0.01872682f, 
    0.03031853f, -0.01451033f, -0.01787397f, -0.14418595f, 0.05365557f, 0.06247372f, -0.06485513f, 0.06790081f, 
    0.07966270f, -0.02614082f, 0.02698380f, 0.01685505f, 0.03769859f, 0.04144466f, -0.04500849f, -0.03666144f, 
    0.08621981f, -0.04421233f, -0.10903750f, -0.10724256f, -0.07652974f, -0.02992667f, 0.03670587f, -0.02039513f, 
    0.00283617f, 0.02770911f, 0.02744136f, 0.02744140f, -0.02740790f, 0.00433910f, 0.00025831f, 0.06420752f, 
    -0.02624700f, -0.01217493f, -0.04966488f, 0.00849041f, -0.05439400f, -0.00693747f, -0.12844996f, -0.02414353f, 
    0.20022948f, -0.13388968f, 0.13628931f, 0.03376179f, 0.12886627f, -0.05158594f, -0.06309693f, -0.03438126f, 
    0.00776088f, 0.00829057f, 0.01963817f, -0.01729149f, -0.04907503f, -0.00879781f, 0.01812916f, -0.00294052f, 
    -0.01110935f, -0.00644669f, 0.05151303f, -0.01421572f, 0.09790098f, -0.16366504f, -0.01807151f, -0.07858776f, 
    -0.15258035f, -0.00519772f, -0.05511523f, -0.15164813f, 0.04220094f, -0.00428643f, -0.03542380f, 0.07006795f, 
    0.02476960f, -0.10359543f, 0.00217065f, -0.01803440f, -0.01794480f, 0.12925901f, 0.03055238f, -0.01513185f, 
    -0.15642378f, -0.15289192f, -0.15915272f, -0.10899373f, -0.22879487f, -0.12021229f, -0.00330525f, -0.03553517f, 
    0.02332247f, -0.09571012f, -0.03218291f, 0.01404168f, 0.05154637f, 0.04523472f, -0.01460995f, -0.00418073f, 
    -0.03860252f, 0.01931476f, 0.02955099f, -0.00282062f, 0.12632589f, -0.21078485f, 0.06131004f, 0.03442725f, 
    0.05636253f, -0.05628712f, -0.02324337f, -0.08154653f, 0.02981673f, 0.04708916f, 0.01210998f, -0.03970769f, 
    0.00753227f, -0.01043313f, -0.01629818f, -0.00663700f, 0.00820083f, 0.01900942f, 0.01554958f, 0.02106006f, 
    0.03996016f, 0.00681995f, 0.01626974f, -0.04925942f, -0.04966465f, 0.00820918f, -0.02592622f, 0.09475690f, 
    -0.01265734f, -0.01820407f, -0.04871753f, 0.02483057f, 0.03453292f, 0.01226714f, -0.02488675f, -0.02947105f, 
    -0.04932943f, -0.00961616f, -0.02625591f, -0.03176466f, -0.30210209f, 0.19690928f, -0.02572272f, -0.15063919f, 
    0.06119680f, 0.06664475f, 0.07032105f, 0.02028704f, 0.03489446f, -0.06813075f, -0.03670818f, 0.01354889f, 
    -0.09479098f, -0.06570401f, -0.02392052f, -0.05565381f, 0.01960832f, 0.01660000f, -0.05078568f, 0.01859749f, 
    0.25335351f, 0.28848583f, -0.15357082f, -0.00218227f, -0.00755377f, 0.00098113f, -0.02688910f, 0.04379155f, 
    0.11284581f, -0.02236721f, 0.00556463f, -0.07608384f, -0.02341703f, 0.08568543f, 0.00835291f, -0.00850420f, 
    -0.04174439f, 0.01090262f, 0.03799263f, 0.01909723f, -0.17657487f, 0.17892934f, 0.06928338f, 0.10361794f, 
    -0.07992049f, -0.02908328f, 0.01200222f, 0.00621964f, -0.04347634f, 0.01015743f, -0.02655128f, -0.03229445f, 
    -0.01091974f, 0.02557779f, -0.06060923f, 0.03569136f, -0.02102886f, 0.08859912f, -0.02213547f, 0.01727637f, 
    0.05576321f, 0.02919059f, 0.01414232f, 0.16868134f, -0.02973185f, -0.03314510f, 0.02081469f, 0.05226060f, 
    -0.03457320f, 0.04369137f, -0.08963048f, -0.06583332f, -0.02485512f, 0.02758378f, 0.03792205f, 0.01608402f, 
    0.03486358f, 0.03466456f, -0.02412890f, 0.00639106f, 0.10302691f, -0.04705853f, -0.04269947f, -0.03229836f, 
    -0.00771514f, -0.09066078f, -0.05161159f, -0.01033383f, -0.05351670f, -0.05416641f, -0.04669046f, 0.00288222f, 
    -0.02645464f, -0.03802526f, 0.07514815f, -0.05922194f, 0.01488715f, 0.06891252f, 0.01158797f, 0.05373168f, 
    0.07095221f, 0.09161902f, 0.21340337f, 0.01982319f, -0.00496582f, -0.02983944f, 0.14126529f, -0.03729935f, 
    -0.02169772f, 0.07136509f, -0.02052376f, 0.01311630f, -0.08692908f, -0.02143487f, -0.06565704f, 0.01141226f, 
    0.04783050f, -0.01289891f, 0.03828442f, -0.00220911f, -0.04063794f, -0.01990693f, 0.09189775f, -0.02329073f, 
    0.00147629f, 0.01037453f, -0.03761287f, -0.06284953f, 0.02083004f, -0.02343635f, 0.03989929f, 0.00048669f, 
    -0.04001701f, -0.03560946f, -0.08267111f, -0.06839703f, -0.03087586f, 0.00951517f, 0.01899832f, -0.01239203f, 
    -0.29564553f, 0.36291233f, 0.01890081f, -0.17344153f, -0.11972010f, 0.01714054f, 0.00680170f, -0.02295260f, 
    0.03843942f, -0.01620253f, 0.02092351f, 0.01012998f, -0.06804208f, -0.00676053f, -0.06644548f, -0.02154966f, 
    0.08889053f, -0.08193944f, 0.06172827f, 0.02133948f, -0.05472050f, -0.23552793f, -0.07481706f, -0.09975421f, 
    0.08500642f, -0.04758077f, 0.10182945f, 0.02331039f, 0.00809581f, 0.00627847f, -0.01665199f, 0.03824522f, 
    0.01720008f, -0.05076824f, -0.03793354f, -0.02260104f, 0.01563867f, -0.02836973f, -0.01877353f, 0.10539933f, 
    0.03606862f, 0.03607232f, -0.21310778f, -0.05969949f, -0.17300028f, 0.02638162f, 0.01135699f, 0.01841425f, 
    -0.05992810f, -0.01143201f, 0.02315611f, 0.00149573f, 0.02918781f, 0.00913687f, 0.04609039f, 0.02897990f, 
    -0.05886191f, 0.05421722f, -0.04329386f, 0.02786629f, 0.12030067f, 0.12473648f, -0.04785865f, 0.14168537f, 
    -0.01003481f, 0.05437867f, -0.03542285f, -0.05659608f, 0.02128354f, 0.00779223f, -0.02127774f, 0.01143525f, 
    0.00313449f, -0.00983190f, -0.07582843f, -0.10857492f, -0.02022149f, 0.02153657f, 0.01343956f, -0.06480634f, 
    -0.07106028f, -0.12218527f, -0.09085806f, -0.01139470f, 0.02493595f, -0.11048289f, -0.05555218f, -0.03706156f, 
    0.03331750f, -0.01780151f, -0.09175400f, 0.00105699f, -0.02451230f, 0.06470793f, 0.00532571f, -0.03746606f, 
    -0.00699804f, 0.04212889f, -0.02086372f, 0.00377856f, 0.29191217f, 0.11329561f, -0.00053134f, 0.03994261f, 
    0.01969093f, 0.07267159f, 0.04046943f, 0.02933636f, 0.06736314f, -0.05108982f, 0.03102387f, 0.02157660f, 
    -0.07083385f, 0.01930941f, -0.03126141f, -0.00204704f, 0.00061500f, -0.04921136f, 0.05257812f, -0.05555024f, 
    -0.25665554f, -0.08855166f, -0.02082705f, -0.02586781f, 0.13870357f, -0.07717817f, 0.03143890f, 0.02501795f, 
    0.00745978f, 0.00679236f, 0.00195473f, 0.04426527f, -0.03629390f, -0.10090514f, -0.00539929f, -0.04561853f, 
    0.03109947f, -0.02782735f, 0.03076384f, 0.02400125f, -0.03938039f, 0.07778835f, 0.15346116f, 0.13958386f, 
    -0.04670066f, 0.03268548f, 0.09765140f, -0.02532865f, 0.01462248f, -0.01142753f, -0.03221274f, -0.02635900f, 
    -0.00653119f, -0.00394107f, -0.03632329f, 0.01753225f, -0.04511211f, -0.02045064f, -0.00399186f, -0.03682256f, 
    -0.08956075f, 0.10066652f, 0.10503512f, 0.04707217f, 0.02842636f, 0.05911179f, 0.00717699f, 0.00743659f, 
    -0.02254496f, 0.00627539f, -0.03876086f, 0.01554073f, 0.00416814f, -0.00790244f, 0.01444850f, -0.01892016f, 
    -0.02530520f, -0.08497578f, 0.03436730f, 0.01355289f, 0.10219866f, 0.06432391f, 0.02331162f, 0.07782970f, 
    0.09193221f, 0.08194440f, 0.12300688f, -0.04630259f, -0.01502923f, -0.09288055f, -0.02810017f, 0.04664818f, 
    -0.10239438f, 0.03574520f, -0.00940433f, 0.01673661f, 0.04498913f, 0.00642454f, -0.00768460f, 0.02670131f, 
    0.05016663f, 0.20606993f, 0.03774758f, 0.12823616f, 0.01143805f, 0.02006184f, 0.03023722f, 0.01523245f, 
    0.02172634f, -0.03902319f, 0.01063184f, 0.01072052f, -0.09826247f, 0.06382163f, -0.15559018f, -0.11709820f, 
    -0.11965486f, 0.01601689f, 0.00043209f, -0.01137360f, 0.41713879f, 0.18592179f, -0.02411486f, 0.05367956f, 
    0.02786380f, -0.00379382f, 0.01744558f, -0.06128169f, 0.05603288f, -0.03748638f, -0.12987450f, -0.04734765f, 
    -0.04547059f, 0.08654878f, 0.02859258f, -0.01344944f, 0.02473820f, 0.04362872f, 0.00189077f, 0.01444567f, 
    0.03994776f, 0.02170524f, 0.07147602f, 0.16233100f, 0.02501496f, 0.11210736f, 0.08367815f, -0.00282194f, 
    -0.02810360f, 0.05576317f, 0.06785172f, 0.14006166f, -0.13254139f, -0.05181888f, -0.05016884f, -0.00254159f, 
    0.09440585f, 0.07315710f, 0.08808271f, -0.06804119f, 0.02257278f, 0.14627558f, -0.16285054f, 0.11954065f, 
    -0.10380611f, -0.00197467f, 0.10584676f, -0.05256267f, 0.04096071f, -0.03525542f, -0.04847212f, 0.02079024f, 
    -0.02600301f, -0.02250556f, -0.00045945f, 0.02452651f, -0.01605250f, 0.02685259f, -0.02789889f, -0.01787866f, 
    0.04955839f, -0.22301479f, -0.18509643f, 0.07206866f, 0.10277259f, -0.07374416f, 0.01654959f, 0.03430049f, 
    -0.03896108f, -0.05206121f, 0.01631377f, 0.03013163f, -0.03007799f, -0.00335941f, 0.01653642f, -0.02354145f, 
    -0.02579111f, -0.01824537f, -0.04081414f, -0.00313841f, -0.02009395f, -0.12818885f, 0.03492784f, 0.07651958f, 
    -0.00616264f, -0.03239759f, -0.07205724f, 0.09188179f, -0.03114227f, 0.05484565f, -0.07664141f, 0.12160502f, 
    -0.05368046f, 0.03546856f, 0.05628804f, 0.03618014f, 0.04099959f, 0.04556201f, 0.05335719f, 0.01303238f, 
    -0.34487131f, -0.06383494f, -0.19986477f, -0.01051142f, 0.09378096f, -0.05166893f, 0.01853953f, 0.01006346f, 
    0.01401760f, -0.05579991f, -0.01839647f, -0.00389496f, 0.03406587f, -0.02650269f, 0.01153409f, -0.06412068f, 
    -0.03377283f, -0.07420018f, 0.05226856f, -0.00070702f, -0.16873327f, -0.37734932f, -0.05351585f, -0.02202129f, 
    -0.02887170f, -0.02150600f, -0.03142277f, -0.00531988f, 0.01521413f, -0.03923661f, 0.02071705f, 0.03293717f, 
    -0.04555444f, -0.00668814f, -0.00886136f, 0.00478689f, 0.01218000f, -0.02896624f, 0.06324814f, -0.01396776f, 
    0.17499749f, -0.35501975f, -0.04127067f, 0.03500954f, 0.03156210f, -0.08938725f, -0.00124410f, 0.01437083f, 
    -0.00999257f, 0.02548182f, 0.06128938f, 0.01407317f, -0.03499328f, -0.04978088f, -0.07429290f, 0.00021746f, 
    0.01356371f, -0.00098664f, 0.01289019f, 0.02312923f, -0.18867664f, -0.09821139f, -0.00203955f, -0.18106261f, 
    -0.14447285f, -0.04578986f, -0.01713252f, 0.01008742f, 0.01021248f, -0.06231986f, -0.01830850f, 0.01235938f, 
    -0.00938118f, 0.04279715f, -0.00434152f, 0.01652686f, 0.00198457f, -0.10364652f, 0.06812797f, -0.04680787f, 
    0.04319060f, 0.06350868f, -0.01224132f, -0.09170379f, -0.09180178f, -0.06472277f, -0.05202307f, -0.09475502f, 
    0.11024931f, -0.03503967f, 0.01876743f, -0.11256680f, -0.01254450f, 0.06495849f, -0.05320553f, -0.06028098f, 
    0.10131527f, -0.04696588f, 0.10171376f, 0.10373779f, 0.15290734f, 0.26369196f, -0.03295878f, -0.05386369f, 
    -0.04932635f, -0.02604392f, -0.06171234f, -0.04891812f, 0.01267022f, -0.03517326f, -0.02003668f, -0.05144623f, 
    -0.09822162f, 0.04987246f, -0.06958971f, -0.04742633f, -0.04221884f, -0.09756621f, 0.02374892f, 0.04583205f, 
    -0.01518484f, -0.04436775f, -0.13005517f, 0.16973320f, 0.04470457f, -0.09445149f, 0.13173655f, -0.01946620f, 
    0.05102619f, -0.04063164f, -0.03593943f, 0.07846118f, -0.05120019f, -0.10098604f, -0.02182324f, -0.05561502f, 
    -0.03454332f, -0.00685633f, 0.08163037f, -0.06658585f, 0.11248863f, 0.01574540f, 0.03178041f, 0.06588747f, 
    0.10549446f, -0.00490079f, 0.05365950f, -0.01122592f, 0.01058499f, 0.03969228f, -0.01119627f, 0.03643098f, 
    -0.00218919f, 0.05524064f, -0.02461154f, 0.01408187f, -0.02282078f, 0.07236932f, -0.00787177f, 0.06345488f, 
    0.04764620f, -0.21140403f, -0.31606615f, 0.11893884f, 0.08566348f, -0.03826579f, 0.02542562f, -0.01987565f, 
    -0.01668428f, -0.06448717f, 0.02333491f, -0.02246638f, 0.00315640f, 0.00652636f, -0.04564935f, -0.01221058f, 
    0.03466103f, 0.07803623f, -0.00065731f, -0.04853146f, -0.32743829f, 0.07841478f, 0.04023154f, -0.12943274f, 
    -0.12118808f, -0.06258096f, -0.03595890f, -0.03596348f, 0.05539390f, -0.06429724f, 0.03120335f, -0.01627526f, 
    -0.05882401f, -0.01625381f, 0.00285735f, -0.01788127f, -0.01658638f, -0.09795582f, 0.01391396f, 0.02852037f, 
    -0.11213723f, -0.20725594f, -0.03661443f, 0.04254526f, -0.08972292f, -0.04412207f, -0.00410076f, -0.02408439f, 
    0.04434519f, -0.03285677f, -0.08398397f, 0.07932448f, -0.02518134f, 0.03992373f, 0.01068445f, -0.01440515f, 
    0.09098856f, -0.03693820f, -0.03399540f, 0.00990148f, 0.16316476f, 0.08283830f, 0.08627308f, 0.02900503f, 
    0.12576365f, 0.03304058f, 0.07830261f, 0.02284255f, -0.00309895f, 0.01865693f, 0.02263409f, -0.06373313f, 
    -0.01732819f, -0.11494025f, -0.02792834f, 0.04011869f, 0.00644351f, 0.08213691f, -0.00179501f, 0.00801809f, 
    -0.27126944f, -0.24940310f, -0.28881580f, -0.13806285f, 0.10310876f, -0.15027712f, -0.03771850f, -0.03612620f, 
    0.01292403f, 0.04267156f, -0.02908772f, 0.04063564f, 0.07506362f, 0.06510301f, 0.04510276f, -0.03619008f, 
    0.02876408f, -0.15003635f, 0.01455181f, 0.07020937f, -0.23768538f, -0.06764551f, -0.01197998f, 0.13247995f, 
    0.16215609f, -0.04119931f, 0.11988878f, -0.02285271f, 0.03342367f, 0.03793634f, 0.04306310f, 0.10911866f, 
    -0.01317853f, 0.07476109f, -0.05478001f, 0.02364259f, -0.04926502f, -0.00324689f, -0.04446195f, -0.03568047f, 
    0.07428592f, 0.03380641f, 0.04202586f, 0.19317904f, 0.01758050f, -0.01495980f, 0.01264470f, -0.02884180f, 
    -0.05047970f, -0.04150891f, -0.11173464f, -0.01512325f, 0.02309758f, -0.06512640f, -0.01664211f, 0.06291091f, 
    0.11407613f, -0.08140297f, -0.03194348f, -0.04118972f, 0.02374177f, -0.00088523f, -0.02019883f, 0.02414075f, 
    -0.10650361f, -0.05607814f, 0.02998501f, 0.03083799f, -0.00784188f, -0.00140484f, -0.00451238f, -0.03043721f, 
    0.03136197f, 0.02666945f, -0.00310653f, 0.02024549f, -0.01307440f, -0.02844444f, 0.00871875f, 0.02040397f, 
    0.14920165f, 0.03826165f, -0.06997659f, 0.01744113f, -0.10699786f, -0.03025918f, -0.02389619f, 0.04601360f, 
    -0.01112630f, 0.06228790f, 0.02220367f, -0.01835640f, -0.03522158f, -0.02895652f, 0.01191243f, 0.00637115f, 
    0.02098920f, 0.05697587f, 0.00766342f, 0.01730864f, -0.17131391f, 0.01739441f, -0.10822517f, -0.03922059f, 
    -0.17302416f, -0.00134574f, -0.00296497f, -0.02470459f, -0.05198375f, -0.06613894f, -0.03264193f, -0.03438420f, 
    0.02988520f, -0.00434045f, -0.03402468f, 0.00038014f, 0.03336691f, 0.05337977f, -0.10032136f, 0.06042881f, 
    0.13216375f, -0.09835181f, 0.23981127f, 0.14011846f, 0.04925263f, 0.00091271f, 0.04262390f, 0.04223774f, 
    -0.07983303f, -0.03560675f, -0.14668575f, -0.00516287f, -0.01076846f, 0.03741514f, 0.05354924f, -0.02431889f, 
    0.03576479f, 0.01021863f, 0.01605897f, -0.03439405f, 0.12379813f, 0.17548421f, -0.09571115f, 0.00016581f, 
    -0.03895067f, -0.02159173f, 0.02695404f, 0.02390408f, 0.01037036f, 0.00554944f, 0.01586386f, -0.02449937f, 
    -0.05076495f, -0.02190378f, 0.03889913f, -0.08731154f, -0.00679513f, 0.01419988f, -0.01697344f, 0.00375601f, 
    0.04327797f, -0.20962046f, 0.08344569f, 0.06658790f, 0.07513347f, 0.01545049f, 0.03016576f, 0.00443549f, 
    -0.03887273f, 0.01288494f, -0.01575380f, 0.02481548f, 0.04273737f, -0.00372131f, -0.00269204f, -0.03279957f, 
    0.07623658f, -0.00234284f, 0.00300329f, -0.00072451f, -0.40883839f, -0.34387884f, -0.08221103f, -0.04770928f, 
    -0.09610902f, -0.11661835f, -0.04741791f, 0.03140631f, -0.01825812f, -0.06476329f, -0.05545295f, -0.05704251f, 
    0.04621248f, -0.02341361f, 0.04224538f, 0.07292626f, -0.04002342f, 0.03636679f, -0.02845087f, 0.06712115f, 
    -0.03685444f, -0.06171932f, -0.23206471f, 0.05534657f, 0.01663664f, -0.08113249f, -0.11891197f, -0.02481278f, 
    0.08299936f, 0.01247008f, -0.04182490f, -0.01542640f, -0.00767256f, -0.00169290f, 0.02651942f, -0.02206675f, 
    0.01335532f, -0.00700931f, -0.05730540f, 0.00215562f, -0.20820788f, 0.18799302f, -0.04374278f, -0.07260470f, 
    -0.05461660f, -0.10092307f, -0.11429860f, 0.10455270f, 0.01224340f, -0.03558396f, -0.10278592f, 0.00075369f, 
    -0.00220795f, 0.11274184f, -0.01383593f, 0.04716642f, 0.02859899f, -0.05891681f, 0.14890425f, 0.03745061f, 
    -0.17138673f, -0.04865109f, 0.02335920f, -0.10552905f, -0.13329984f, 0.01565359f, -0.12032134f, -0.03715718f, 
    -0.02678221f, -0.06502102f, 0.01898043f, -0.06741881f, -0.01419239f, -0.00740752f, 0.02099171f, 0.04707283f, 
    0.03460574f, 0.01043272f, 0.02177313f, 0.00772321f, 0.07054894f, 0.06187228f, -0.06850889f, 0.00911616f, 
    -0.00911572f, -0.03697715f, -0.00512184f, -0.04389540f, -0.02730014f, 0.06079100f, -0.01407245f, 0.01175350f, 
    0.05102107f, -0.00695344f, 0.03576628f, -0.02676676f, 0.00358239f, 0.02985685f, -0.02348788f, -0.05328816f, 
    0.02901669f, 0.09529956f, 0.10740785f, 0.05290053f, -0.02319144f, -0.04911050f, -0.07170928f, -0.02307778f, 
    -0.03192765f, -0.03383262f, 0.07409815f, -0.01674513f, -0.02575708f, -0.07247518f, 0.01249928f, 0.00298004f, 
    -0.00888792f, -0.00556186f, -0.00221713f, 0.05458124f, 0.03885225f, 0.06128765f, 0.08335213f, 0.14549986f, 
    0.13415971f, 0.01335086f, 0.07686615f, -0.03928128f, -0.01677180f, 0.05034173f, 0.01496534f, -0.02683091f, 
    -0.08713359f, -0.06524665f, -0.03563410f, 0.03018384f, -0.02948231f, 0.09266351f, 0.02887983f, 0.00444140f, 
    0.07959788f, 0.12686218f, 0.05024980f, 0.08290551f, 0.02859747f, 0.00332410f, 0.00426366f, -0.07530980f, 
    -0.09059133f, 0.00119075f, 0.04279502f, -0.00901900f, 0.01453816f, -0.00050615f, -0.01259134f, 0.07574616f, 
    -0.00737497f, 0.10915563f, 0.00951791f, 0.02332005f, 0.00406234f, -0.00764974f, 0.00204489f, 0.02165359f, 
    -0.08713569f, -0.05397341f, -0.11162391f, -0.00555657f, -0.00105153f, 0.03371897f, -0.03441816f, -0.00991863f, 
    0.05116820f, -0.01537023f, 0.06110676f, 0.01632566f, 0.01231448f, 0.01799112f, 0.08650020f, 0.06822705f, 
    0.00377135f, -0.55491459f, -0.30335054f, 0.11836495f, 0.16153868f, -0.02061160f, -0.02071518f, 0.02815216f, 
    -0.00829005f, -0.06111621f, 0.00379581f, 0.00048862f, -0.05312616f, -0.08090707f, 0.01281883f, -0.03494392f, 
    -0.05085488f, 0.04138545f, -0.02825074f, -0.01704592f, -0.43971345f, 0.40081671f, 0.01971597f, 0.14135745f, 
    0.06793261f, 0.06779057f, 0.00872424f, -0.05277655f, 0.01277381f, -0.03453055f, -0.07091806f, -0.02569464f, 
    0.02019372f, 0.03516863f, 0.02032896f, 0.01246856f, 0.00063465f, -0.06104840f, 0.05850624f, 0.08489621f, 
    -0.01635570f, -0.37534869f, -0.25350490f, 0.14691228f, 0.07369341f, -0.06242231f, -0.03077035f, 0.03959861f, 
    0.02943477f, -0.05666114f, 0.01486955f, 0.02639145f, -0.04680111f, -0.17115098f, 0.04555357f, -0.03120923f, 
    -0.07464432f, 0.03159123f, 0.00616834f, -0.05828837f, 0.03278328f, -0.04138474f, 0.02567301f, -0.00001376f, 
    -0.09285979f, -0.03427101f, -0.15308429f, -0.03396977f, -0.03278274f, -0.03058800f, -0.07082681f, 0.02728532f, 
    0.02873383f, -0.00641254f, 0.04720882f, -0.04804969f, -0.01884825f, 0.04847213f, 0.04172755f, 0.02751228f, 
    -0.27416179f, -0.21584137f, -0.15474606f, -0.11342970f, 0.08630691f, -0.11170950f, 0.03511345f, -0.02872636f, 
    0.04095801f, 0.00051456f, -0.04661711f, -0.01985701f, 0.04173792f, 0.04245949f, -0.00355644f, 0.00749013f, 
    0.03653045f, -0.06137849f, 0.04590756f, -0.02267204f, 0.02775898f, -0.28866982f, -0.14743134f, 0.13803150f, 
    0.04408015f, 0.05336768f, -0.00396723f, 0.00108623f, -0.01360061f, -0.11327723f, -0.00756134f, -0.04384080f, 
    -0.10640780f, 0.02598921f, -0.06446639f, 0.00086917f, 0.06885467f, 0.06339109f, -0.03693313f, -0.06415688f, 
    -0.02439839f, 0.07125332f, -0.08456631f, -0.10253856f, 0.03298952f, -0.01726850f, -0.09462269f, -0.04357404f, 
    0.04405179f, -0.02510121f, -0.02056586f, -0.00692431f, 0.05809699f, 0.01746472f, 0.04430475f, -0.04333967f, 
    -0.00049825f, -0.05773366f, 0.03278309f, -0.00335918f, 0.02224353f, 0.11644553f, 0.01029731f, 0.05752904f, 
    -0.04035583f, 0.02736442f, 0.01115762f, -0.00808135f, 0.00989281f, 0.00438010f, -0.11914326f, -0.02093379f, 
    0.03016277f, -0.03281233f, 0.01556259f, 0.02682336f, 0.02115453f, 0.06421143f, 0.00436601f, 0.02535595f, 
    -0.04217077f, 0.10969835f, 0.11396866f, 0.10156220f, -0.02972987f, -0.06668736f, -0.04667456f, 0.02181192f, 
    -0.02622079f, 0.02931946f, -0.03558118f, -0.06964581f, 0.02705091f, -0.02325082f, 0.01217450f, 0.03411832f, 
    0.05384196f, 0.12985200f, 0.09248067f, 0.05313777f, 0.04108630f, 0.04496850f, -0.01544646f, 0.03976738f, 
    -0.02410949f, -0.02606530f, -0.10443461f, 0.04393033f, -0.03952443f, -0.00833697f, -0.02324207f, -0.01587904f, 
    -0.01805259f, 0.01013986f, 0.04019003f, -0.04698156f, -0.04886534f, 0.02247946f, -0.03471799f, 0.02495624f, 
    0.10904964f, -0.39209279f, -0.11945358f, -0.03578388f, -0.03957596f, -0.08984488f, -0.11793475f, 0.02678189f, 
    0.06126792f, 0.00594382f, -0.05702494f, 0.00353199f, -0.01364064f, 0.06711246f, 0.07389440f, 0.00318014f, 
    -0.04362777f, 0.00718664f, -0.10228640f, 0.07689670f, -0.23237854f, -0.08614071f, -0.18230879f, 0.13334121f, 
    0.12478442f, 0.02827017f, 0.06692667f, 0.08622308f, -0.01628529f, 0.05208216f, 0.03254468f, 0.01663785f, 
    -0.03565817f, -0.07921030f, -0.06408662f, 0.03176158f, 0.08224589f, 0.11291340f, 0.02610490f, -0.01403882f, 
    0.45255294f, -0.04208754f, -0.18435453f, 0.01034532f, -0.02207856f, 0.05065015f, 0.11328353f, 0.05534618f, 
    0.01993350f, -0.05755318f, -0.06467715f, -0.09112224f, 0.00534030f, -0.05193952f, -0.09627762f, 0.05995439f, 
    -0.06021302f, -0.12516311f, 0.04300371f, 0.05437900f, -0.12589274f, -0.07459737f, 0.16992913f, 0.02854406f, 
    0.00931279f, 0.02928478f, 0.02726931f, -0.01563122f, 0.03053072f, 0.00946034f, 0.05786764f, -0.03855539f, 
    0.00126537f, 0.02924291f, 0.07013471f, -0.02513999f, -0.06429072f, -0.05526168f, 0.03361090f, 0.01449344f, 
    -0.28312212f, -0.28387734f, -0.18182938f, 0.16586244f, 0.13877927f, 0.07859665f, -0.02779535f, 0.02907720f, 
    0.02746220f, 0.05803853f, 0.03569454f, 0.04558210f, 0.03912729f, -0.03929184f, -0.04124941f, 0.00463006f, 
    -0.01545247f, -0.03693606f, 0.05604779f, 0.03985301f, -0.03014905f, 0.05644484f, -0.16807877f, 0.07597790f, 
    0.16890092f, 0.10291026f, 0.02623389f, 0.01235746f, 0.08472890f, 0.04634834f, 0.01263159f, 0.05427164f, 
    0.03916571f, -0.06924974f, -0.04420118f, 0.03444982f, 0.03743091f, 0.04928922f, 0.03303019f, -0.02095165f, 
    0.02051745f, 0.22751389f, -0.14743011f, 0.06061927f, -0.32383546f, -0.05339208f, -0.11033864f, 0.04331976f, 
    0.00746163f, -0.05687963f, -0.05035164f, -0.04134539f, 0.02614962f, 0.03213997f, 0.02661791f, 0.02791034f, 
    0.02526017f, 0.08921256f, -0.04898169f, 0.10005409f, 0.03016618f, 0.06440122f, 0.02080045f, -0.15724355f, 
    -0.05268595f, -0.05541434f, 0.04309991f, -0.09625690f, -0.00367343f, -0.03939498f, 0.00090314f, -0.02078806f, 
    -0.09208272f, 0.07949112f, -0.09269997f, 0.00137619f, 0.00322252f, 0.02088007f, 0.02308466f, 0.03554722f, 
    0.08971629f, 0.04692161f, 0.00635153f, 0.06894816f, -0.03217899f, 0.07360490f, -0.02807293f, 0.10630678f, 
    -0.03217475f, -0.04180004f, 0.03157745f, 0.09512894f, -0.12850961f, 0.10599587f, -0.00798548f, -0.00855849f, 
    -0.02118349f, -0.07114590f, -0.11659219f, -0.03514344f, 0.01481582f, -0.04130673f, 0.14306414f, -0.02128586f, 
    -0.07197951f, 0.00010400f, 0.00108831f, 0.00880691f, -0.07617500f, 0.02590621f, 0.00127197f, 0.00171005f, 
    0.02661633f, 0.05519670f, -0.04121878f, -0.05753129f, 0.10529549f, -0.05363567f, -0.01691095f, -0.05446916f, 
    -0.55094725f, 0.07614025f, 0.02870341f, 0.14938912f, 0.09682993f, 0.01765594f, -0.09976289f, 0.02307227f, 
    0.01844393f, -0.07081454f, -0.07120959f, 0.03339406f, -0.06176492f, 0.05267102f, 0.04750802f, 0.03598525f, 
    -0.02479119f, 0.12788022f, 0.00875788f, 0.01577399f, -0.18601657f, 0.10979886f, 0.08570471f, -0.07419255f, 
    -0.11759564f, -0.08350142f, -0.03263819f, -0.11547431f, -0.01499949f, -0.00094613f, 0.01534251f, 0.05075694f, 
    -0.09462152f, 0.00897290f, 0.01768789f, 0.03478095f, -0.00382008f, 0.00007018f, 0.04540662f, 0.03781854f, 
    -0.13405143f, -0.02229244f, 0.04384155f, 0.01090602f, -0.02632343f, -0.01832760f, 0.04307623f, -0.02691709f, 
    0.03918531f, -0.07389303f, 0.06429487f, -0.03702046f, -0.05778647f, 0.03292419f, 0.03359121f, -0.03398719f, 
    0.08849214f, -0.13174969f, 0.01197805f, -0.00184155f, -0.04548641f, 0.04782870f, 0.09154473f, -0.04893104f, 
    -0.00219597f, -0.01894727f, 0.06123026f, -0.04348124f, 0.08739342f, -0.02291811f, -0.02311487f, -0.00474568f, 
    -0.09059659f, 0.00531706f, 0.01825707f, -0.10658344f, 0.07851369f, 0.00912896f, -0.02632824f, 0.04181751f, 
    -0.28173953f, -0.25985739f, 0.11356499f, 0.07253776f, 0.04154433f, 0.00937489f, -0.03707723f, 0.08544518f, 
    -0.11124224f, -0.13480954f, 0.07645862f, -0.01980504f, -0.10530841f, -0.04012881f, -0.04279352f, -0.04482312f, 
    0.03622904f, -0.01689313f, -0.05088080f, -0.04204369f, -0.04123187f, 0.23157781f, 0.00880839f, -0.06156836f, 
    -0.23807208f, -0.00575282f, -0.04697565f, -0.01536064f, 0.00163285f, -0.11716374f, 0.06740484f, -0.03441959f, 
    0.05519908f, 0.05910377f, -0.01798979f, -0.05515908f, 0.04945391f, 0.08300798f, -0.09447176f, 0.09419110f, 
    0.17147306f, -0.04078318f, -0.07066210f, -0.02937564f, 0.05891037f, -0.07160480f, -0.02110966f, 0.03671306f, 
    -0.02311521f, 0.04441050f, 0.00988677f, -0.04251319f, -0.04876434f, -0.04458814f, -0.01621818f, 0.01928342f, 
    -0.08289566f, -0.05825810f, -0.01709351f, 0.01986046f, 0.06069152f, 0.09845231f, -0.00136359f, -0.18150392f, 
    0.03642071f, -0.01960189f, -0.02025467f, -0.00420327f, 0.04278228f, -0.08076864f, -0.01423011f, -0.03803974f, 
    -0.03493960f, 0.06882878f, -0.11226425f, -0.03552090f, 0.01062356f, 0.10446835f, -0.05257306f, 0.07754925f, 
    -0.09496497f, 0.22912027f, 0.10003568f, -0.18936309f, -0.12045164f, -0.03238623f, -0.10239731f, -0.19309068f, 
    -0.07361655f, -0.10093476f, 0.05240614f, 0.05933564f, -0.05493265f, 0.03605354f, 0.06733233f, 0.01250322f, 
    0.00369648f, -0.01743637f, 0.05258365f, -0.05529234f, -0.06016252f, -0.01990681f, 0.08760217f, -0.15017216f, 
    -0.16661784f, 0.03606921f, 0.07457024f, 0.00856095f, 0.05851399f, -0.02358940f, -0.06220173f, -0.03865359f, 
    0.02613509f, 0.05886304f, 0.07728430f, -0.03229661f, 0.05986286f, 0.05284682f, -0.09968130f, 0.03433189f, 
    0.01492953f, 0.01273034f, 0.17639184f, 0.06590912f, -0.11108389f, 0.09182629f, 0.02807620f, -0.06077333f, 
    -0.03890894f, -0.05732516f, 0.06266875f, -0.07902828f, -0.11158034f, 0.05098743f, -0.11778596f, 0.00433719f, 
    -0.01223908f, 0.10354497f, 0.06632815f, 0.00792999f, -0.12698247f, 0.04777970f, -0.11487033f, 0.07554322f, 
    -0.12298796f, -0.04424868f, -0.04288980f, 0.08469024f, -0.01664997f, -0.03576729f, 0.00771805f, -0.12023189f, 
    -0.04695382f, 0.02592770f, 0.07000867f, 0.00679118f, -0.02498831f, -0.01244629f, -0.03660829f, 0.07634679f, 
    -0.00164152f, -0.10554811f, 0.00712451f, -0.05425554f, 0.00062538f, -0.01534715f, -0.00607843f, -0.02319662f, 
    -0.09001734f, -0.02449243f, 0.07360497f, 0.05987708f, -0.00246012f, 0.03373095f, -0.03609478f, 0.03381966f, 
    -0.03840105f, -0.04117376f, -0.08466826f, -0.03213445f, -0.05006948f, 0.07050588f, -0.00994967f, -0.00499283f, 
    0.11559713f, 0.02085525f, -0.00332294f, -0.10638752f, 0.00256806f, 0.07838050f, -0.02838265f, -0.13608950f, 
    0.05709969f, 0.03639590f, 0.08041761f, 0.01238248f, 0.01442293f, 0.05316351f, 0.07338347f, -0.15844503f, 
    -0.07589576f, 0.01726506f, 0.17769098f, 0.02771515f, 0.06376638f, -0.01072477f, -0.03580301f, 0.03667067f, 
    -0.01699994f, 0.04335783f, 0.14807208f, -0.02013970f, 0.02593384f, -0.12905948f, 0.01282296f, 0.08301502f, 
    -0.04743319f, -0.04840100f, -0.00918959f, 0.03903743f, 0.18573135f, 0.04339463f, -0.10771778f, -0.02513440f, 
    0.06262463f, -0.05063695f, -0.05213710f, 0.02796076f, 0.05322739f, 0.02388042f, -0.05895956f, 0.00180910f, 
    0.01020352f, -0.01636638f, -0.06802429f, 0.09662452f, -0.05161424f, -0.07389738f, 0.02861172f, 0.05119322f, 
    0.39106169f, -0.15081996f, -0.16610110f, -0.13869224f, -0.34958357f, -0.07218632f, -0.00429194f, -0.00611650f, 
    -0.12176703f, 0.03592039f, -0.03284966f, 0.04823698f, 0.06139538f, -0.03354051f, 0.01799966f, -0.02158431f, 
    -0.00924597f, 0.00691897f, 0.03089088f, -0.09238134f, -0.04285444f, -0.14853044f, -0.10173262f, 0.09983185f, 
    0.03888939f, 0.00506656f, 0.09517321f, 0.03738173f, 0.01018539f, 0.04071563f, 0.00528802f, 0.02105662f, 
    0.03005616f, 0.08767853f, -0.01507442f, 0.03592544f, -0.05062320f, -0.01817626f, -0.02113062f, -0.00281353f, 
    0.34881079f, 0.24804333f, -0.17267530f, -0.09708879f, 0.00902040f, 0.10627979f, 0.03826918f, 0.17957295f, 
    0.06327999f, 0.04688098f, -0.01717135f, -0.07277310f, 0.01428455f, 0.07947198f, 0.01992790f, -0.09603078f, 
    0.09780564f, 0.01748742f, -0.00083925f, 0.04903111f, -0.30099156f, 0.02411604f, 0.00394493f, -0.14649871f, 
    -0.13519125f, 0.10739928f, -0.00355517f, 0.08395596f, -0.01203778f, 0.02419309f, 0.04952095f, -0.03958333f, 
    -0.07198853f, -0.01132475f, 0.07914981f, 0.00062750f, 0.10186618f, 0.02461089f, 0.09836594f, -0.00328001f, 
    -0.32788289f, -0.06047900f, 0.18726331f, -0.20957264f, -0.07850055f, 0.13183141f, -0.01494703f, -0.00723796f, 
    -0.05713367f, 0.05129815f, 0.02766657f, -0.02831968f, -0.02059333f, -0.09047782f, -0.03782060f, 0.02195994f, 
    -0.09286615f, -0.06155682f, -0.00570105f, -0.03046982f, -0.01878605f, -0.13173884f, 0.06572576f, 0.09108423f, 
    -0.02431182f, -0.01366788f, 0.06791946f, 0.01348737f, -0.04993170f, -0.03097541f, 0.03155371f, 0.04195127f, 
    -0.02297771f, -0.01877464f, 0.03484093f, -0.01555108f, 0.04734407f, 0.00975550f, 0.04361111f, 0.02729547f, 
    -0.13881323f, 0.02396287f, 0.15068574f, 0.07956075f, 0.02515914f, -0.04275098f, 0.04516225f, -0.05267522f, 
    -0.03470964f, 0.03726361f, 0.03403506f, 0.00805262f, 0.03623033f, -0.02336458f, -0.02304386f, -0.04541375f, 
    -0.00806296f, -0.01774627f, 0.05596350f, 0.04895334f, 0.03463431f, 0.21086390f, -0.11905170f, -0.06742695f, 
    0.01937437f, 0.04216228f, -0.03500979f, 0.13261725f, 0.04273686f, 0.04940134f, -0.08777430f, 0.02897061f, 
    -0.04088616f, -0.00903028f, 0.04546165f, 0.00457770f, 0.06234261f, -0.09835038f, -0.03795410f, -0.08366513f, 
    -0.39889127f, 0.04996041f, 0.14044523f, -0.18889855f, -0.10020532f, -0.08940807f, 0.11633828f, 0.01304606f, 
    0.07847600f, 0.01991736f, 0.01310472f, -0.08250189f, 0.14550005f, -0.04788006f, 0.04422982f, -0.03914315f, 
    -0.03603027f, 0.06683638f, 0.00742222f, -0.05582009f, -0.04721251f, -0.08766247f, -0.02585099f, 0.08647816f, 
    -0.11056770f, -0.08037776f, -0.02091261f, 0.01396703f, -0.01971635f, -0.00727273f, 0.01405487f, 0.00302004f, 
    0.03488326f, -0.03195826f, 0.07170951f, -0.05227291f, 0.06504964f, 0.08197352f, -0.01454201f, 0.09896206f, 
    0.03655019f, -0.06004382f, 0.21562360f, -0.02393645f, -0.06375784f, 0.00142703f, -0.02214057f, 0.04153039f, 
    0.05244144f, 0.05811604f, 0.05829004f, -0.03797194f, -0.02448199f, -0.09840359f, -0.00403604f, 0.08303544f, 
    0.06630380f, -0.02129810f, -0.07414564f, -0.00013678f, -0.06867269f, -0.29762739f, 0.11976843f, 0.13290706f, 
    0.06900349f, 0.03071670f, 0.02335437f, 0.10838845f, -0.03576355f, -0.06001378f, -0.02183850f, -0.01188799f, 
    -0.03595529f, -0.06074897f, 0.06079717f, -0.07879010f, -0.07854874f, 0.00848894f, 0.01796356f, -0.10677344f, 
    0.04910964f, -0.08972028f, -0.01141037f, 0.08030429f, 0.15530846f, 0.04931603f, -0.06275320f, -0.02830504f, 
    -0.10627839f, -0.02994163f, -0.00851067f, 0.01487946f, -0.18017343f, -0.01342699f, 0.07742289f, -0.14029022f, 
    -0.15121882f, -0.07400262f, -0.08162083f, -0.02195655f, 0.16512531f, -0.05041284f, -0.20655306f, 0.07902805f, 
    -0.12303827f, 0.06965749f, -0.00492332f, 0.03403979f, -0.09637329f, 0.05462981f, -0.06829995f, -0.02324627f, 
    0.03417023f, 0.01210070f, -0.01135243f, -0.02514481f, 0.01474710f, 0.03505687f, -0.01114049f, -0.01299837f, 
    0.28128541f, -0.03956068f, -0.13315874f, -0.02704635f, 0.01026140f, 0.07238502f, -0.02485969f, 0.03110094f, 
    0.00487825f, -0.02882879f, 0.00245794f, 0.02178782f, 0.02724247f, 0.00690146f, -0.04184221f, -0.12296190f, 
    -0.19048443f, -0.08019260f, -0.01004149f, -0.08810728f, 0.03568519f, -0.17146158f, -0.21040271f, 0.18851443f, 
    0.03740411f, 0.19594613f, -0.07034500f, -0.01339958f, -0.01199724f, 0.04128303f, -0.07382673f, 0.04712096f, 
    0.01401275f, 0.03049443f, 0.11994706f, -0.08950531f, -0.05158220f, 0.05105974f, 0.02959692f, -0.09174985f, 
    0.00947016f, -0.16650349f, -0.07062691f, 0.02395513f, 0.17812157f, 0.04027023f, -0.06564048f, 0.05259068f, 
    0.02553045f, -0.05437526f, 0.00213650f, -0.00231861f, -0.06768382f, -0.00507747f, 0.03508405f, -0.01203530f, 
    0.06238729f, -0.08531629f, 0.01647463f, -0.07417273f, 0.03212943f, -0.05870179f, -0.04460496f, -0.01967065f, 
    -0.06172138f, 0.07309357f, -0.00842439f, -0.01407577f, -0.02282617f, -0.11723311f, -0.03447179f, 0.06941814f, 
    0.05425281f, -0.03201506f, -0.00895193f, 0.00455034f, -0.01673662f, -0.01868419f, -0.00814336f, 0.07104196f, 
    0.16452718f, -0.01636787f, 0.00225219f, -0.08345219f, 0.12884413f, 0.00849860f, 0.01133452f, -0.03887691f, 
    0.01890579f, -0.13663603f, 0.02924271f, 0.08356935f, -0.06786315f, 0.01098493f, -0.08232106f, -0.03504455f, 
    0.03300249f, -0.08277468f, -0.06174814f, 0.00078489f, 0.11131477f, 0.10890556f, -0.00702179f, -0.08232275f, 
    0.02482396f, -0.03311964f, -0.07237013f, 0.03174702f, 0.08216508f, 0.02827938f, 0.05995256f, 0.01963445f, 
    -0.01855253f, 0.08580424f, 0.00932682f, 0.04131237f, 0.02561661f, 0.03039734f, -0.01575511f, -0.00813375f, 
    -0.18712427f, -0.02044255f, -0.13337746f, 0.01203105f, -0.07643521f, 0.00215130f, -0.02082785f, -0.08702238f, 
    0.02107898f, 0.03775208f, -0.00050532f, -0.14679670f, -0.00596346f, -0.05197979f, 0.01761190f, 0.07028085f, 
    0.02680873f, -0.05141739f, -0.06039232f, -0.05030533f, -0.31252784f, -0.24430554f, 0.09025060f, 0.08658309f, 
    0.06722094f, -0.01579949f, -0.03831313f, 0.03103145f, -0.05993028f, 0.06686559f, -0.08189438f, 0.03655087f, 
    0.05433798f, 0.07361720f, -0.02975377f, -0.08240565f, -0.00768274f, 0.02492839f, 0.06500240f, -0.01126479f, 
    -0.08260716f, -0.03107787f, -0.11331102f, 0.08748364f, 0.11182752f, 0.00776995f, 0.06329150f, 0.04958170f, 
    0.05856666f, -0.00357761f, -0.02918082f, -0.05178990f, 0.06676615f, 0.02774490f, -0.03463771f, 0.00402821f, 
    0.00280424f, -0.03281343f, 0.06786885f, -0.04365443f, -0.06329633f, 0.08586574f, -0.00287026f, 0.05657372f, 
    0.05909037f, -0.00170595f, 0.05511637f, 0.02731593f, 0.07967281f, 0.06117455f, -0.04462243f, 0.09498915f, 
    0.03804293f, -0.01912325f, -0.00292841f, -0.08118382f, -0.06060651f, 0.01291965f, -0.04839745f, 0.02552027f, 
    -0.07534381f, 0.11014417f, -0.20581263f, 0.04939612f, -0.09233287f, 0.03799576f, -0.03963095f, 0.07465973f, 
    0.05271933f, -0.07905350f, -0.11664565f, 0.01528593f, 0.01569804f, 0.00053347f, -0.04050624f, -0.02274834f, 
    -0.01911182f, 0.03553060f, -0.04656032f, -0.01607410f, -0.00562669f, -0.09405107f, 0.02186788f, 0.22399509f, 
    -0.09220204f, -0.09318489f, 0.05508278f, 0.01492452f, 0.02243318f, -0.07408916f, 0.04856861f, 0.02479225f, 
    0.00522039f, -0.02731141f, 0.12072653f, 0.00331539f, -0.07295997f, 0.00450842f, 0.01812723f, 0.02201719f, 
    -0.02776334f, 0.03866312f, -0.01227916f, 0.17089748f, 0.00247347f, 0.08388953f, 0.00593490f, -0.04068738f, 
    0.05932111f, -0.02780389f, 0.06691010f, 0.11924171f, -0.00732195f, -0.05902804f, -0.02654987f, -0.02764927f, 
    -0.02381376f, -0.06791713f, -0.02636786f, -0.03104077f, -0.63063061f, 0.10129096f, 0.09248960f, 0.10054711f, 
    0.18228079f, 0.06007551f, -0.06100060f, -0.03115271f, 0.07636075f, 0.09917651f, -0.07634591f, 0.03892724f, 
    -0.01068136f, 0.06907964f, -0.00879792f, 0.03206733f, 0.05356806f, 0.08385635f, 0.05116634f, -0.07865569f, 
    -0.15479168f, -0.29799584f, 0.06762695f, 0.06679605f, 0.02525969f, -0.12470315f, 0.07509182f, -0.08515076f, 
    -0.09568483f, 0.06620935f, 0.12195681f, 0.06809018f, 0.01527852f, -0.01438329f, -0.04946532f, -0.04580853f, 
    -0.01905051f, -0.04920134f, -0.00132872f, -0.00229420f, -0.58126205f, -0.08280869f, 0.01265021f, -0.17329003f, 
    0.01785398f, 0.02364135f, -0.03082244f, -0.00786648f, 0.00204914f, 0.00072395f, -0.03368619f, -0.00954000f, 
    -0.00913655f, -0.02790115f, 0.04672869f, -0.03508708f, 0.06095896f, -0.00330754f, 0.08627256f, -0.08984180f, 
    -0.27362534f, -0.30589956f, 0.00541441f, 0.11875394f, 0.04072342f, -0.14391357f, -0.04820351f, -0.04219919f, 
    -0.09474029f, 0.06244094f, 0.04965606f, -0.06273398f, -0.02522147f, -0.05016799f, 0.00996665f, -0.02081863f, 
    -0.03706189f, 0.03480369f, 0.00783908f, 0.04430911f, -0.62463117f, 0.00095904f, -0.13719290f, 0.03418513f, 
    0.24202262f, -0.02313079f, -0.02680702f, 0.02405181f, 0.08823051f, 0.06596556f, 0.03875330f, -0.04410897f, 
    0.01189047f, 0.05836860f, -0.00697407f, 0.04522390f, 0.07198125f, 0.08036928f, 0.04897199f, -0.04149332f, 
    -0.01558083f, -0.14295459f, 0.11575875f, 0.03737318f, -0.06108268f, -0.03319052f, 0.02289042f, 0.01256747f, 
    -0.05467223f, 0.06018238f, 0.04031549f, -0.07705675f, 0.00201566f, -0.01386798f, -0.02222568f, 0.03847976f, 
    0.01622583f, -0.05185077f, 0.03868723f, 0.03960440f, -0.17278260f, 0.10392174f, 0.05839586f, -0.01306391f, 
    0.01080966f, -0.00762072f, 0.03283725f, -0.07580907f, 0.04272379f, 0.01487106f, -0.00469833f, -0.02581860f, 
    -0.00261673f, 0.08576807f, -0.10757616f, -0.06634358f, 0.05995255f, -0.02245288f, 0.00810182f, 0.06046351f, 
    -0.18361557f, 0.06543915f, 0.04060426f, 0.02840705f, 0.05061084f, 0.00284610f, -0.01495666f, 0.03868840f, 
    0.03443535f, -0.01052391f, -0.03560408f, 0.00513800f, 0.02048705f, 0.02329716f, 0.02904832f, -0.03167762f, 
    -0.01964645f, 0.01626827f, 0.01718410f, -0.02584503f, -0.15086044f, -0.01123718f, 0.08598875f, 0.07491004f, 
    0.08935853f, 0.04878444f, 0.09027302f, -0.01206297f, 0.07717536f, -0.01722462f, 0.12280270f, -0.04783113f, 
    0.00411675f, 0.02061031f, 0.06157171f, 0.00117376f, -0.10420804f, 0.02863093f, -0.07140108f, 0.10587557f, 
    0.05593014f, -0.00053146f, -0.05069724f, 0.07760129f, 0.05114774f, -0.01182871f, 0.01519673f, -0.03992903f, 
    0.05004176f, -0.01562103f, 0.12017126f, 0.02842502f, 0.05602072f, 0.02834414f, 0.11667130f, 0.01668461f, 
    0.06596678f, 0.02703144f, 0.13147543f, 0.04097582f, -0.10062627f, 0.07178990f, 0.01488939f, 0.11234730f, 
    0.02516087f, -0.01545823f, 0.04361514f, -0.00651292f, 0.09732845f, -0.05288754f, 0.03724049f, -0.00198255f, 
    -0.04211137f, 0.03366525f, -0.01971084f, 0.04435748f, -0.00792612f, 0.09066991f, 0.08203223f, 0.06299763f, 
    0.24153994f, -0.22905889f, -0.01492928f, 0.03334660f, -0.15085973f, -0.04922435f, -0.01106017f, 0.09029922f, 
    -0.01789649f, 0.03810816f, -0.01488739f, 0.08816583f, 0.00186957f, -0.04286071f, -0.01033812f, -0.05973418f, 
    -0.00187354f, -0.10081375f, 0.05597176f, -0.10377184f, -0.14300920f, -0.12278742f, 0.18919457f, 0.16645074f, 
    -0.01596244f, 0.00079905f, -0.00963300f, 0.01688466f, -0.00820022f, 0.02362721f, 0.16233201f, 0.07098013f, 
    -0.01003707f, -0.06176134f, -0.01714575f, 0.03271098f, 0.02446039f, 0.08095761f, 0.03315628f, 0.08023686f, 
    -0.42033350f, -0.03765059f, 0.25932479f, -0.01458608f, -0.19423589f, 0.04290857f, 0.08042514f, 0.03337337f, 
    -0.03532450f, 0.15033032f, -0.02508565f, -0.00334292f, 0.04749436f, -0.09986345f, -0.17916794f, -0.00281234f, 
    0.08687364f, -0.02289132f, -0.00713655f, 0.06797703f, 0.15366039f, -0.01402586f, -0.15148084f, -0.02021132f, 
    0.01846583f, 0.09847496f, 0.00180683f, -0.06871903f, -0.03065971f, 0.05356708f, -0.00906837f, 0.10963836f, 
    0.09804721f, 0.02963682f, 0.03880247f, -0.02208217f, -0.05961258f, -0.04281761f, -0.20940119f, -0.00795544f, 
    -0.05255799f, 0.10340147f, -0.06639551f, -0.07570802f, -0.06070211f, 0.12653178f, 0.02817653f, -0.04852758f, 
    -0.06256572f, 0.07595525f, -0.00898604f, 0.10433356f, -0.11288506f, -0.10676967f, -0.07394225f, -0.09295833f, 
    -0.02709858f, -0.05968811f, -0.05249489f, -0.03257548f, -0.46606943f, -0.20960805f, -0.14149012f, -0.10067407f, 
    -0.03790876f, 0.12072381f, 0.07843572f, -0.00414828f, 0.01600196f, -0.00870864f, -0.01283029f, 0.08701344f, 
    -0.06290685f, 0.07020427f, -0.08038373f, 0.05086713f, 0.01461052f, 0.02442937f, -0.06061117f, -0.00342574f, 
    0.05764805f, -0.27431160f, -0.16828117f, -0.00042386f, 0.06410534f, -0.00067619f, -0.01327720f, -0.04304935f, 
    0.06676883f, 0.03060923f, 0.09228005f, 0.02786770f, -0.03376513f, 0.04680741f, 0.01871577f, -0.03627290f, 
    -0.06466651f, -0.07225404f, -0.07185770f, -0.11497755f, -0.03270407f, 0.08093901f, -0.12742606f, 0.08708606f, 
    0.02852637f, 0.01382327f, 0.06688292f, 0.00896502f, -0.01917004f, 0.06742226f, 0.02445173f, 0.12455208f, 
    0.07625814f, -0.00830932f, 0.11778725f, -0.00379044f, 0.03477079f, -0.03263282f, 0.06037136f, -0.06183202f, 
    -0.27059793f, -0.10132887f, 0.03084454f, 0.29422265f, -0.21675640f, -0.08685242f, -0.11456231f, -0.01743434f, 
    -0.01274896f, 0.08433815f, 0.13746290f, 0.00826766f, 0.01717355f, 0.04737472f, -0.05244072f, -0.03231904f, 
    -0.10625069f, 0.00549085f, -0.05102512f, -0.08030025f, 0.02425354f, 0.08596930f, 0.02157701f, -0.03429525f, 
    -0.00177906f, 0.02935050f, 0.01186463f, -0.05841137f, -0.09557337f, 0.02985076f, 0.00681136f, -0.05085532f, 
    -0.01052003f, 0.04154477f, 0.09463026f, 0.00944716f, -0.07871271f, 0.05322130f, -0.04451904f, 0.01177305f, 
    -0.18620896f, 0.17160918f, -0.28791162f, -0.11277494f, 0.03234109f, 0.03016775f, 0.04632300f, -0.07289157f, 
    0.06946310f, -0.09792247f, 0.04659762f, 0.00929758f, 0.09650938f, -0.08378252f, 0.00396551f, -0.04325360f, 
    0.07671594f, -0.08711853f, 0.09175652f, -0.00885640f, -0.00181110f, -0.07554081f, 0.01905779f, 0.05779934f, 
    -0.01021525f, -0.00815362f, 0.02989784f, -0.01214434f, 0.00283031f, -0.11636905f, -0.07944600f, 0.07442141f, 
    -0.04638028f, 0.07433169f, 0.12038346f, -0.08196302f, 0.00202649f, -0.02134545f, -0.04902619f, -0.06639590f, 
    -0.00957722f, -0.02066161f, 0.01338390f, 0.13925841f, 0.11080610f, 0.03038570f, -0.02160645f, 0.01320088f, 
    -0.01884107f, 0.13347811f, 0.01180467f, -0.09418021f, -0.01384808f, 0.03023201f, 0.04343619f, -0.06649063f, 
    0.06258970f, -0.11901888f, 0.08475917f, 0.06505421f, -0.10268534f, -0.07661330f, 0.07805923f, 0.18733516f, 
    -0.18954527f, -0.13509804f, -0.06611761f, 0.06337453f, -0.04309975f, 0.05464188f, -0.04134057f, 0.05160036f, 
    0.00801900f, -0.06195027f, 0.04072513f, 0.02153635f, -0.02457230f, -0.03413707f, 0.06986814f, 0.05215545f, 
    0.06987678f, 0.00850033f, 0.08627689f, 0.11997101f, 0.02780606f, -0.13677122f, -0.04182975f, 0.07275650f, 
    0.05992879f, 0.15292439f, -0.04678170f, -0.17300825f, 0.00744179f, -0.00316978f, 0.08784463f, -0.04994667f, 
    -0.01506425f, -0.13234016f, 0.08763038f, 0.07360224f, 0.09782482f, -0.02680560f, -0.06140728f, 0.00487087f, 
    0.19264235f, -0.04554534f, -0.09230389f, 0.04964569f, -0.00847516f, -0.01126904f, 0.16318002f, 0.02999120f, 
    -0.00454533f, 0.05458009f, -0.00240653f, 0.05126144f, -0.02118685f, 0.00891469f, 0.05735574f, -0.02021634f, 
    0.09691533f, -0.01905824f, -0.02135152f, -0.00611679f, -0.18687117f, -0.04944956f, -0.05562351f, -0.03106629f, 
    0.02130445f, 0.05248892f, 0.02524607f, 0.03959644f, -0.01875917f, 0.04970351f, -0.00450692f, -0.03340777f, 
    0.03749429f, 0.07823122f, -0.03340991f, 0.03057775f, -0.01174620f, -0.20499153f, -0.09096447f, 0.13497849f, 
    0.04996285f, -0.01205692f, -0.00863391f, 0.00369204f, -0.00920733f, -0.04704876f, -0.02914630f, -0.01193692f, 
    -0.06463023f, 0.01211747f, 0.09633294f, 0.18735503f, -0.08369404f, 0.03094875f, -0.09359078f, -0.02614721f, 
    -0.00122034f, -0.14799327f, 0.02188681f, 0.05301403f, -0.16179901f, 0.10611019f, -0.00270127f, -0.05542134f, 
    0.06038876f, -0.09350765f, -0.17792316f, -0.05065684f, -0.00487055f, 0.04974250f, 0.11177019f, 0.07212503f, 
    0.01139354f, -0.02674325f, 0.02243085f, -0.18853536f, -0.14008293f, -0.10686474f, 0.02495000f, -0.05463996f, 
    -0.07025291f, -0.08539768f, 0.04358914f, 0.05094282f, -0.01791932f, 0.02124096f, -0.04754811f, 0.00883712f, 
    -0.00712443f, -0.05312884f, -0.10230010f, -0.06246149f, 0.03672412f, -0.16475645f, 0.10122440f, -0.01328615f, 
    0.09309760f, 0.14914650f, -0.08871833f, 0.25055224f, 0.21744277f, 0.00593010f, -0.07057596f, -0.00695652f, 
    0.11682061f, 0.08555096f, 0.01751068f, 0.08402848f, 0.08210031f, 0.07496573f, 0.10139920f, -0.04841797f, 
    0.10003114f, -0.02742588f, -0.01747129f, -0.10680282f, -0.09887700f, -0.16215481f, -0.14200878f, -0.07654460f, 
    -0.03200309f, 0.00890865f, 0.01872906f, -0.04706319f, 0.07913791f, 0.09230936f, 0.04461939f, 0.14669718f, 
    0.11369127f, -0.02215611f, -0.01304435f, -0.00246559f, -0.01903904f, -0.04634404f, 0.10436363f, -0.00093927f, 
    -0.00959272f, 0.02844770f, 0.04574752f, 0.08098327f, -0.01669623f, -0.02264247f, -0.00330610f, -0.06114996f, 
    -0.03746152f, -0.02547689f, 0.01579879f, 0.00484629f, 0.03975441f, 0.02508602f, -0.01797447f, -0.01981867f, 
    0.01442561f, 0.09926449f, -0.05692402f, -0.04050354f, -0.14495851f, 0.01645344f, -0.19130665f, -0.10982092f, 
    -0.00298556f, 0.05704606f, 0.13417242f, 0.03106913f, -0.04713190f, -0.15310137f, -0.00661957f, 0.06451900f, 
    -0.13076307f, -0.03301876f, -0.03232267f, -0.09710432f, 0.00141949f, 0.10147515f, -0.04010601f, 0.01775359f, 
    0.02010433f, 0.00957895f, 0.06971762f, 0.01714155f, -0.06959118f, -0.14974275f, 0.11290559f, -0.01106578f, 
    0.03522918f, 0.01994368f, -0.07299044f, 0.02281842f, 0.08898185f, 0.04230217f, 0.11519187f, -0.05618022f, 
    -0.07738817f, 0.11074568f, -0.00694615f, 0.01009804f, -0.19527972f, -0.02857661f, 0.08021308f, 0.05944740f, 
    -0.27257067f, 0.03683367f, 0.04015454f, 0.02598372f, 0.05933142f, 0.02184114f, 0.02152698f, 0.01943508f, 
    -0.03276759f, -0.05107786f, -0.00462041f, 0.00792783f, -0.01145949f, 0.07343245f, 0.01864636f, 0.02245264f, 
    -0.07936657f, 0.13568425f, 0.09284174f, 0.01394041f, 0.13514037f, -0.06613769f, -0.10464057f, -0.03665109f, 
    -0.09650172f, 0.09928183f, -0.06466634f, -0.03596939f, -0.02297914f, -0.03888278f, -0.08615569f, 0.07762203f, 
    -0.02427916f, -0.06554701f, -0.02289050f, 0.06998318f, -0.06619205f, 0.14298615f, 0.04989810f, 0.01108653f, 
    -0.03338016f, 0.00635399f, -0.02977431f, -0.03210534f, -0.04882272f, 0.04750988f, 0.09467281f, 0.03316033f, 
    -0.03945841f, 0.01244762f, -0.03987775f, 0.07053635f, 0.01257133f, 0.05073282f, 0.07370767f, -0.02163211f, 
    -0.21486016f, -0.01888048f, 0.37304091f, 0.16973260f, -0.40258437f, 0.01451286f, -0.05331736f, -0.03009566f, 
    -0.01749462f, -0.05224036f, -0.04027276f, 0.04640541f, 0.01314640f, -0.05744852f, -0.02953586f, -0.05217278f, 
    -0.00491707f, 0.06061733f, 0.07381727f, 0.00494351f, -0.49232763f, -0.10800438f, -0.04645239f, -0.08937998f, 
    -0.12946171f, -0.10368433f, 0.01150022f, 0.11359110f, -0.05789462f, -0.03228932f, 0.05121793f, 0.01158638f, 
    0.14203756f, -0.06346662f, -0.04919896f, -0.01735420f, 0.01595720f, -0.14781591f, 0.03419265f, 0.04517102f, 
    -0.34644142f, -0.02559792f, 0.01768511f, 0.21265008f, -0.13310903f, -0.03907439f, 0.04224645f, -0.03219189f, 
    0.01625224f, 0.11087474f, 0.10033470f, -0.07910684f, 0.08909169f, 0.01416918f, -0.00859712f, 0.04068383f, 
    0.06986704f, -0.01120973f, -0.12103454f, -0.14535016f, 0.07841271f, 0.04030672f, 0.06057769f, 0.14574030f, 
    -0.06880583f, -0.03140740f, -0.04839105f, 0.01811820f, -0.06048240f, 0.05779937f, 0.01191061f, -0.04391340f, 
    0.02799071f, 0.07345944f, -0.05249386f, -0.02232327f, -0.07923996f, -0.05315295f, 0.00442516f, -0.01956171f, 
    0.02522785f, 0.00055010f, -0.04951767f, 0.10564754f, 0.03264593f, -0.01302593f, -0.01611260f, 0.07399995f, 
    -0.02000475f, -0.00871223f, 0.00132759f, 0.02274825f, 0.01780625f, 0.01664815f, 0.12235343f, -0.00439140f, 
    -0.02752586f, 0.02894317f, 0.06323820f, 0.01197389f, -0.25962979f, -0.10301005f, 0.12026148f, 0.10355324f, 
    -0.20617959f, 0.00335569f, -0.02377020f, -0.05691069f, -0.00876438f, -0.00381929f, 0.09315120f, 0.00696081f, 
    0.00661036f, 0.00883285f, -0.06722107f, -0.00534190f, 0.01255253f, 0.04207619f, 0.06839699f, 0.03851380f, 
    -0.28788063f, 0.06752673f, -0.01075484f, -0.06146279f, 0.03278047f, 0.08439555f, -0.00338412f, -0.03325554f, 
    -0.11796757f, -0.11930349f, -0.01675637f, 0.03929315f, -0.10461310f, -0.04660224f, -0.01836012f, 0.01829440f, 
    0.08812057f, 0.01305312f, 0.04679010f, -0.02092882f, -0.00328800f, 0.00484120f, 0.16750148f, 0.17071538f, 
    0.04895411f, -0.02503492f, -0.04073390f, 0.02131160f, -0.00005786f, -0.02966871f, -0.05155070f, -0.06471450f, 
    0.01193820f, 0.10915501f, 0.06536853f, 0.02091459f, 0.04240130f, -0.15527999f, -0.04201815f, -0.00448999f, 
    0.04783898f, -0.12668358f, -0.09674938f, 0.12421104f, 0.02475596f, 0.03549599f, 0.01168444f, -0.08265558f, 
    -0.06275994f, -0.01101045f, -0.07347345f, 0.03908903f, 0.08430689f, -0.00905218f, 0.07770469f, -0.03198854f, 
    -0.03754063f, 0.05488633f, 0.06218321f, 0.03529430f, 0.22352891f, 0.06070395f, -0.02739302f, 0.18053775f, 
    -0.08848920f, -0.10902882f, -0.02488779f, 0.03041097f, 0.04438928f, 0.02953066f, 0.01832698f, -0.14090890f, 
    -0.07889806f, 0.09418532f, -0.01753090f, 0.02961478f, -0.01776063f, -0.00831436f, -0.00921621f, 0.00877997f, 
    0.11799642f, -0.13740465f, 0.08183844f, -0.01648257f, 0.02203891f, -0.01757106f, 0.00083546f, -0.09234121f, 
    0.05467968f, -0.00496443f, 0.09003019f, -0.14376453f, 0.02260099f, 0.08775000f, 0.00861899f, 0.13795352f, 
    0.06608184f, 0.04577915f, -0.27672246f, 0.12490588f, 0.01934719f, 0.21988298f, 0.04301181f, -0.09755059f, 
    0.01825889f, -0.01843170f, -0.05354136f, -0.07364968f, -0.00594517f, -0.00784819f, 0.02969060f, 0.08852841f, 
    0.00197273f, -0.01010993f, 0.03264620f, 0.02864144f, -0.01580082f, -0.00522573f, 0.06574297f, -0.03983939f, 
    -0.46631441f, 0.08100521f, 0.07578681f, 0.04197920f, 0.10682985f, -0.00806000f, -0.03305143f, -0.05961345f, 
    0.01235682f, 0.04243147f, 0.01955309f, -0.00298521f, -0.08976437f, -0.04355592f, -0.09006288f, 0.04179850f, 
    0.12263235f, -0.02321056f, -0.12267002f, 0.02680079f, 0.21469820f, 0.28129825f, 0.11149940f, -0.14034492f, 
    -0.00172698f, -0.10194137f, 0.02328431f, -0.00389472f, 0.05211337f, -0.04700031f, 0.11344566f, -0.02510074f, 
    0.01673284f, -0.05701142f, -0.05967513f, 0.16049118f, -0.03887183f, 0.01676162f, 0.10464195f, 0.06598917f, 
    0.05751891f, -0.01057003f, -0.11862171f, -0.11872340f, 0.03958069f, 0.06726015f, -0.00217570f, -0.01828749f, 
    0.07763092f, 0.11702571f, 0.02289160f, 0.03496625f, 0.05825277f, -0.01444708f, -0.05453478f, -0.03097527f, 
    -0.02935107f, 0.03374539f, -0.09894100f, 0.05987784f, -0.21479020f, -0.04590729f, 0.04461364f, 0.15391290f, 
    -0.03506082f, -0.01241587f, 0.05083371f, -0.01410819f, -0.06588192f, 0.05943846f, -0.02329374f, -0.04297895f, 
    -0.05188086f, 0.10239464f, -0.10634644f, 0.02086646f, 0.07812150f, -0.12039169f, -0.04258198f, 0.01043151f, 
    -0.03200993f, -0.00504184f, -0.06008361f, 0.06897489f, -0.05197413f, -0.01092674f, -0.05222853f, 0.01937643f, 
    -0.02140828f, 0.00223795f, 0.06033278f, -0.09803853f, 0.08574029f, -0.02074575f, -0.02547015f, -0.07690818f, 
    -0.01287162f, 0.00483080f, -0.05815059f, -0.06359916f, 0.12418816f, 0.02338596f, 0.15185221f, 0.07086447f, 
    -0.09175134f, 0.04685311f, 0.06733061f, -0.00501954f, 0.00396836f, -0.01608051f, 0.02285356f, 0.02048077f, 
    -0.00358361f, -0.00043193f, 0.01497457f, 0.01075906f, -0.02466966f, 0.04693623f, 0.07524082f, -0.03052244f, 
    -0.02684325f, 0.08546940f, -0.03151324f, 0.01059752f, -0.07992586f, 0.06934724f, 0.06312883f, 0.00816254f, 
    -0.01478046f, 0.08361091f, 0.01704084f, -0.07391217f, -0.01879546f, 0.02753097f, -0.03453118f, 0.01921166f, 
    0.01186125f, 0.01993727f, 0.07474050f, 0.02129449f, -0.05332145f, 0.21097195f, -0.05498112f, -0.19954802f, 
    0.06181036f, 0.05697045f, 0.05775149f, 0.16735837f, -0.00422099f, -0.14504246f, 0.12673149f, -0.02544473f, 
    -0.08546086f, -0.02204052f, -0.05951865f, 0.02122651f, -0.07934079f, -0.05899012f, -0.03567242f, 0.04597598f, 
    -0.10089574f, 0.15618992f, 0.01918277f, -0.07010175f, -0.14282413f, 0.03726970f, -0.01864820f, 0.09864942f, 
    -0.07612540f, -0.07231309f, 0.07355728f, -0.01762104f, -0.07039475f, -0.04844584f, -0.06834682f, 0.06985656f, 
    0.02160671f, 0.11228599f, 0.01278753f, -0.01753514f, -0.27321345f, -0.10118826f, -0.04814295f, -0.04690691f, 
    0.09212562f, 0.00172762f, -0.03086919f, 0.00164375f, 0.01647036f, -0.00441668f, 0.07395929f, 0.02832890f, 
    0.00507835f, 0.09806681f, -0.00261042f, 0.14609618f, 0.04696198f, 0.02591735f, -0.09395220f, -0.03607650f, 
    -0.17886969f, -0.19315508f, 0.01491303f, -0.00306027f, 0.06385289f, -0.00611680f, -0.09788637f, -0.00510186f, 
    -0.02231874f, 0.07264552f, 0.03860255f, -0.12952791f, -0.09332132f, 0.03218569f, 0.08125275f, -0.03301552f, 
    0.03865384f, -0.07529653f, -0.08941883f, 0.01857971f, 0.04683232f, 0.02050607f, -0.07459295f, -0.02224975f, 
    0.10773367f, -0.01907215f, -0.17385812f, 0.02259003f, 0.00258124f, 0.01811565f, -0.02475295f, -0.00919354f, 
    0.02291767f, 0.07460592f, 0.06309699f, -0.09407207f, 0.06961069f, -0.02100824f, -0.05179575f, -0.12997314f, 
    -0.16071439f, -0.07569448f, -0.07648848f, -0.00799887f, 0.05184329f, -0.04533519f, -0.04475805f, 0.09073517f, 
    -0.12053593f, 0.08997124f, 0.04770421f, -0.04142866f, 0.02264400f, 0.11636127f, 0.00565727f, -0.09163978f, 
    -0.00741751f, -0.10433174f, -0.12419785f, 0.00059680f, -0.23565710f, 0.17282166f, -0.30195427f, -0.09913994f, 
    0.00193408f, 0.05846361f, 0.08694383f, 0.07627589f, -0.01516041f, -0.11805776f, -0.03571425f, -0.03938140f, 
    -0.07677239f, -0.05733732f, -0.02124166f, -0.00328435f, -0.05312526f, -0.01614345f, 0.05416853f, -0.02952942f, 
    0.07418310f, 0.09443235f, 0.02549695f, 0.16493554f, 0.03436583f, -0.05243590f, -0.01446744f, -0.04245492f, 
    -0.01374412f, 0.00057097f, -0.05034388f, -0.03639091f, -0.02372759f, 0.12403843f, 0.05587513f, 0.04503003f, 
    0.03382054f, 0.15684186f, -0.03423715f, -0.04120155f, -0.18446176f, -0.04356205f, -0.05845906f, -0.13596451f, 
    -0.08056816f, 0.04198525f, -0.02797879f, 0.07101970f, 0.06494603f, -0.05899853f, -0.02303505f, -0.02655688f, 
    -0.04459137f, -0.00937286f, 0.09120008f, -0.02692096f, -0.06378174f, 0.00758949f, -0.06117194f, -0.04775970f, 
    0.12722614f, 0.09721266f, -0.00435325f, 0.08399704f, -0.11014140f, -0.04063470f, 0.01941757f, -0.02691206f, 
    0.03582187f, 0.05767389f, -0.04396730f, -0.09178837f, -0.07393506f, 0.06914946f, 0.05966539f, 0.02232705f, 
    0.05012628f, 0.04157518f, 0.05912807f, 0.02893537f, -0.46780154f, -0.05251210f, -0.21363482f, -0.16472203f, 
    -0.10922863f, 0.10832074f, 0.12676744f, 0.04141136f, -0.10735959f, -0.16971052f, 0.02023428f, -0.04607454f, 
    0.04107282f, -0.09887677f, 0.00033597f, 0.07835357f, -0.06455044f, -0.05626929f, -0.01627343f, -0.01327250f, 
    0.19930707f, 0.01758692f, -0.05069788f, 0.02073407f, -0.12127297f, -0.02686296f, -0.05587386f, -0.11129320f, 
    -0.06422235f, 0.06525364f, -0.06181315f, 0.05044331f, 0.14197466f, 0.05346502f, 0.00303865f, 0.01919807f, 
    0.07361799f, 0.10609974f, 0.06760717f, 0.03422933f, 0.05414943f, -0.06564537f, 0.06434893f, 0.06617395f, 
    -0.01005863f, -0.00624614f, -0.08408837f, 0.13329114f, 0.03769098f, -0.02085167f, -0.01943210f, 0.01652285f, 
    -0.02167435f, -0.00240239f, 0.06919018f, 0.00890958f, -0.00297156f, -0.00107525f, 0.06972915f, -0.00149791f, 
    -0.38341901f, -0.04182710f, -0.15373619f, -0.10935466f, -0.00040954f, 0.07730323f, 0.03081133f, 0.08048145f, 
    -0.05657256f, -0.04107588f, 0.03777302f, -0.01255295f, 0.03120389f, -0.02032533f, 0.07916438f, 0.06442814f, 
    0.07758272f, -0.09853364f, -0.02124191f, 0.03415971f, -0.02935208f, -0.01930017f, -0.04407818f, 0.00042203f, 
    0.09818656f, -0.11597672f, 0.03708440f, -0.01828420f, -0.03443062f, 0.16179895f, -0.09681547f, 0.15095587f, 
    0.13292119f, 0.14370200f, -0.00389148f, -0.06881722f, 0.14742927f, -0.05291498f, -0.07722687f, -0.09393249f, 
    0.05275457f, 0.18158193f, 0.01717155f, 0.00535445f, 0.10887639f, 0.12246422f, 0.04769127f, 0.12031731f, 
    0.04035445f, 0.09886342f, 0.00700446f, 0.06568903f, 0.05280748f, -0.02243031f, 0.03750718f, -0.09788071f, 
    -0.01260066f, -0.00166330f, -0.12559052f, -0.02848491f, -0.32369667f, -0.07420209f, -0.22533636f, -0.00316686f, 
    -0.01033393f, 0.06872340f, 0.16220799f, -0.05086166f, -0.02405404f, -0.01183156f, -0.00841356f, -0.05801914f, 
    0.09278541f, -0.04587051f, 0.03274208f, -0.04085175f, 0.09532540f, -0.06972438f, -0.03474113f, 0.01219615f, 
    0.06262493f, 0.08298524f, 0.08189719f, -0.00282695f, 0.05312762f, 0.00573445f, 0.05995908f, -0.02735198f, 
    -0.11305674f, 0.08729991f, -0.03235421f, -0.08732456f, -0.00015209f, 0.02627519f, -0.12056426f, 0.08028400f, 
    0.01402945f, -0.02634141f, 0.14719795f, 0.11296128f, 0.02177476f, -0.02508474f, 0.03212823f, 0.10231994f, 
    0.20753522f, -0.11070211f, 0.00776312f, 0.00499484f, 0.01926503f, 0.02338339f, -0.15434076f, -0.05391080f, 
    0.07543603f, 0.11537915f, 0.05123709f, -0.09720799f, -0.09826494f, -0.06493457f, -0.05697985f, -0.06103919f, 
    0.06600432f, 0.06829645f, 0.06175969f, -0.00327357f, 0.02630636f, -0.15135272f, -0.07424374f, -0.07003191f, 
    0.03890177f, 0.03978218f, -0.00673955f, -0.04958289f, 0.02417689f, 0.16066650f, 0.07106948f, 0.05669143f, 
    -0.03894995f, -0.00823674f, -0.02133464f, -0.07790308f, 0.01413601f, -0.10650496f, -0.04061849f, -0.00637107f, 
    0.18608412f, 0.04011259f, 0.05151363f, 0.04164109f, -0.11495352f, -0.16243845f, -0.02798142f, -0.02222405f, 
    -0.07604036f, 0.00025964f, -0.02370641f, -0.03671328f, 0.03541723f, 0.00150056f, 0.06849679f, 0.00384073f, 
    -0.31066978f, -0.13410939f, -0.04638635f, -0.33914998f, 0.12219068f, 0.03048635f, 0.02795854f, 0.19324423f, 
    -0.03541946f, -0.16501218f, -0.05608954f, -0.10428902f, -0.00392860f, 0.02043669f, 0.10947020f, 0.06531549f, 
    0.07852709f, 0.04211248f, 0.05896206f, 0.01648499f, -0.20627050f, 0.05465275f, -0.01340627f, -0.21697617f, 
    0.10101606f, 0.00309488f, -0.03205291f, 0.01136286f, -0.05498671f, -0.00062497f, -0.02454040f, -0.04938853f, 
    0.03080709f, 0.02478462f, 0.02914434f, -0.05911252f, 0.00689541f, -0.04215512f, 0.06355878f, 0.03726685f, 
    -0.11601225f, -0.21800770f, -0.23984343f, -0.10064135f, 0.24473596f, 0.02401968f, 0.09349702f, 0.01206199f, 
    0.00515572f, -0.00635532f, -0.00638857f, -0.03743087f, 0.06441329f, 0.01562300f, -0.07993701f, 0.11929258f, 
    0.02100164f, 0.13650505f, 0.03154085f, 0.07823577f, 0.06936509f, -0.03951197f, -0.05812322f, -0.11796283f, 
    0.01428862f, 0.05466812f, 0.02480264f, 0.02293016f, 0.00474675f, -0.06366405f, 0.09445437f, -0.01801831f, 
    0.00969273f, -0.07037488f, -0.02822058f, 0.03429041f, -0.06498896f, 0.05724148f, -0.05542425f, 0.08805036f, 
    -0.05436974f, -0.10799325f, 0.14474848f, 0.03086530f, 0.05671683f, -0.00583277f, -0.14762512f, 0.09543071f, 
    -0.12659648f, -0.01181190f, -0.03377250f, 0.02872532f, 0.00172767f, -0.09895455f, -0.05454085f, -0.04123314f, 
    0.02283072f, 0.06662329f, 0.14082043f, -0.05201053f, -0.17044131f, -0.04728445f, 0.06106453f, 0.00744463f, 
    0.24027413f, 0.10535398f, 0.05452726f, -0.02255859f, 0.02231251f, -0.05103650f, -0.01326444f, -0.00164186f, 
    -0.06647556f, 0.13489456f, 0.01470285f, 0.07612154f, -0.03555323f, -0.07870152f, -0.01059922f, -0.05288685f, 
    0.04509519f, -0.36689833f, 0.01526068f, -0.27570859f, 0.18982176f, -0.06094358f, 0.02868418f, 0.03568412f, 
    0.01540877f, -0.05413730f, -0.02911110f, 0.00269608f, -0.00115624f, 0.06035024f, 0.00242864f, -0.01329974f, 
    0.00186648f, -0.04220488f, -0.09590858f, -0.00032981f, 0.07128998f, -0.01633030f, 0.00982740f, -0.05156349f, 
    0.04089003f, 0.09111840f, 0.03067376f, 0.04174385f, -0.03222196f, 0.02236607f, -0.01853154f, -0.04764609f, 
    0.05799819f, -0.03054404f, -0.06598918f, 0.07052528f, -0.06812569f, 0.03269579f, -0.06067517f, 0.05291641f, 
    -0.10423072f, 0.16643435f, 0.00895230f, 0.05626884f, -0.23376653f, 0.07120079f, 0.02286913f, -0.00758896f, 
    0.04638286f, 0.00374431f, -0.06260184f, -0.00364429f, 0.04217152f, 0.02288359f, -0.06095402f, 0.05019835f, 
    -0.12191358f, 0.03834451f, -0.03056039f, -0.07515678f, 0.16209002f, 0.05135666f, 0.01388339f, 0.02047155f, 
    0.06132851f, 0.05659731f, 0.02607447f, -0.01270619f, 0.08185670f, 0.05357551f, -0.04617393f, 0.06379145f, 
    -0.01295225f, -0.01646217f, -0.11489604f, 0.02838366f, 0.07813037f, 0.00434796f, -0.00269032f, -0.03787857f, 
    -0.14347959f, 0.14842232f, 0.09238589f, 0.03049705f, -0.12793210f, 0.16106200f, 0.10927836f, -0.01260797f, 
    0.05908341f, -0.05046883f, -0.13450573f, 0.02228580f, -0.00983514f, 0.02855357f, -0.13003471f, 0.03087489f, 
    -0.00315682f, 0.02879022f, -0.00900015f, -0.11602378f, -0.09482451f, -0.21301126f, -0.13415316f, -0.09941159f, 
    0.31641132f, -0.10059486f, 0.09811653f, -0.07030941f, -0.05061047f, 0.04876196f, -0.06340925f, -0.04955683f, 
    0.08895759f, -0.01447691f, 0.01002203f, 0.06444286f, -0.03221916f, 0.08060683f, -0.03020600f, 0.07192365f, 
    0.07568529f, -0.07162815f, 0.03530253f, 0.06274214f, -0.01694354f, 0.04252699f, -0.01012811f, 0.03276365f, 
    -0.01901433f, -0.05899011f, 0.02157070f, -0.00726877f, 0.05225774f, 0.03102699f, -0.00730392f, -0.00495552f, 
    0.03118902f, 0.00006916f, 0.05781228f, -0.09597075f, -0.12352774f, -0.18382750f, -0.02251548f, 0.00569162f, 
    0.16336745f, 0.05604488f, 0.01116411f, 0.04435258f, 0.00794406f, 0.09912492f, 0.00586248f, -0.00574357f, 
    0.09253033f, -0.05737831f, -0.00260293f, -0.03374285f, 0.01302985f, 0.10240965f, 0.12562062f, 0.01402780f, 
    0.09729610f, -0.27793106f, -0.03376833f, 0.10876331f, 0.08478901f, 0.02187919f, 0.08955411f, 0.14927083f, 
    -0.08741008f, 0.01396157f, 0.06031213f, -0.05618155f, 0.10573071f, 0.01791420f, -0.06290596f, 0.09110302f, 
    -0.03042666f, 0.07484992f, -0.04098290f, 0.06217175f, 0.06157149f, -0.10428784f, 0.01133438f, 0.22251658f, 
    0.11559222f, -0.01199230f, 0.12949371f, -0.02709865f, 0.03935068f, -0.03048370f, 0.00805238f, 0.01085402f, 
    -0.04720829f, 0.00221244f, 0.06551399f, 0.04877357f, 0.03788310f, 0.10034501f, -0.06954215f, 0.02851951f, 
    -0.11657932f, 0.01800853f, -0.11573003f, -0.15493490f, 0.03262904f, 0.00713159f, -0.02270503f, 0.11321960f, 
    -0.00048446f, 0.08626255f, -0.00488491f, 0.00249120f, -0.01109357f, -0.08154000f, 0.00941887f, 0.06736366f, 
    -0.19572210f, 0.09147482f, 0.06778604f, 0.15608764f, 0.06431351f, -0.15313643f, -0.08296695f, -0.12759383f, 
    0.13012768f, 0.01894826f, 0.06012498f, -0.00347936f, -0.03084758f, -0.05621506f, 0.01310829f, -0.08614931f, 
    -0.05770167f, -0.02072577f, 0.06082384f, -0.06661636f, 0.03942627f, 0.13790585f, 0.00142764f, 0.00953713f, 
    -0.14760028f, 0.11803953f, 0.00983122f, 0.10507118f, 0.09301126f, -0.00077465f, 0.00657853f, 0.04494780f, 
    0.02305703f, -0.02355298f, -0.09489838f, 0.01799952f, -0.01801770f, -0.00525533f, 0.06780758f, -0.01519675f, 
    0.04002146f, -0.03569643f, 0.00143303f, -0.01191310f, -0.04378540f, -0.24898174f, 0.02509899f, -0.17375506f, 
    0.11522397f, 0.12445097f, -0.16634859f, 0.06591383f, -0.02270322f, -0.01884934f, 0.00142512f, -0.05542775f, 
    0.10705334f, 0.07702126f, -0.05671762f, 0.11359632f, -0.02958059f, -0.09316713f, -0.03507758f, 0.12379768f, 
    -0.17276751f, 0.15895985f, 0.07327601f, 0.04210794f, -0.22631037f, 0.04932958f, -0.06919610f, 0.00098980f, 
    0.00708540f, 0.06537003f, 0.00444224f, 0.01916896f, -0.01741462f, 0.07492315f, -0.05371737f, -0.01769467f, 
    0.04350076f, -0.07362796f, 0.00890404f, -0.06017558f, -0.07477403f, 0.14622088f, -0.05323737f, 0.04440895f, 
    -0.10195846f, -0.07160041f, -0.02800251f, 0.02493649f, 0.01515006f, 0.04408446f, 0.02580613f, 0.02792614f, 
    0.02681329f, 0.01327017f, -0.01701942f, -0.00572741f, 0.01490493f, -0.10157112f, -0.03712616f, -0.07990085f, 
    -0.23090439f, 0.07839230f, -0.08598717f, 0.22813736f, 0.03163390f, 0.04811399f, 0.08809540f, -0.04668211f, 
    0.03783702f, 0.05152202f, 0.02873843f, -0.02110706f, 0.06235925f, -0.02358636f, -0.17594516f, 0.05506840f, 
    0.05931249f, -0.10772811f, 0.00681105f, -0.05317596f, -0.25747079f, -0.05592133f, -0.04323395f, 0.11564839f, 
    -0.00923932f, 0.00481843f, -0.01067594f, 0.03390801f, 0.06019461f, -0.01818242f, -0.00393768f, -0.04706775f, 
    0.09960441f, -0.03734517f, 0.01315610f, -0.03163986f, -0.02249108f, -0.13303284f, -0.01804305f, -0.10731199f, 
    0.18279514f, -0.10955636f, -0.03779604f, 0.10929954f, -0.02597381f, -0.11249898f, 0.00835762f, 0.02602901f, 
    0.04716202f, 0.07180677f, 0.01396506f, -0.09165175f, -0.04274216f, -0.01595625f, 0.00362321f, 0.14818889f, 
    -0.09557894f, 0.04507555f, -0.10373702f, 0.00208255f, 0.10059042f, -0.13456449f, 0.00932354f, 0.18299556f, 
    0.14723302f, -0.02157193f, 0.09506199f, -0.02451004f, -0.02663419f, -0.05686727f, -0.05763654f, 0.03085102f, 
    -0.15451148f, 0.01302699f, 0.03711167f, 0.01808013f, 0.06082431f, 0.11764757f, -0.05152385f, 0.06716424f, 
    0.41922548f, 0.04823589f, 0.07526377f, 0.09169579f, 0.32716891f, -0.08011513f, -0.06494291f, 0.03688785f, 
    -0.02159448f, -0.14464137f, -0.11502043f, 0.04994721f, -0.12665012f, 0.01453474f, 0.02016965f, -0.02205085f, 
    -0.09820616f, 0.05259980f, 0.11418198f, 0.02961285f, -0.03167507f, 0.10818325f, 0.01165166f, -0.05184743f, 
    -0.10093585f, 0.02868688f, -0.01432168f, -0.01857288f, -0.00479203f, 0.03757602f, -0.05400183f, 0.01748208f, 
    0.00283823f, 0.01700769f, 0.00999977f, 0.02433537f, -0.06520323f, 0.08908272f, 0.00465405f, 0.00824423f, 
    -0.11983635f, 0.18053277f, -0.04639584f, 0.09723242f, -0.26679218f, 0.00228268f, -0.02487705f, 0.04867410f, 
    0.05832489f, -0.00732567f, 0.04716150f, 0.05725905f, -0.03854529f, 0.00503518f, -0.04701027f, -0.05585380f, 
    -0.01239553f, 0.07751169f, -0.03441574f, 0.05361810f, 0.17756198f, -0.20626035f, -0.01382168f, 0.06732189f, 
    -0.04679216f, -0.02267084f, -0.08473168f, 0.08810396f, 0.00119661f, 0.04643152f, -0.05832471f, 0.08613606f, 
    -0.06601723f, -0.03959266f, 0.03834525f, -0.08280408f, 0.01557018f, 0.03132358f, -0.00296399f, -0.11241732f, 
    0.43675452f, 0.00482407f, 0.00627320f, 0.01250562f, 0.18986201f, 0.12113141f, -0.00689577f, 0.04405871f, 
    0.04582167f, -0.09001539f, -0.10667271f, -0.05286156f, 0.10104470f, -0.01529840f, 0.02638222f, 0.06438456f, 
    0.10780303f, 0.01231741f, -0.09926467f, 0.04447026f, -0.04458343f, 0.06577933f, -0.19212507f, 0.04166560f, 
    -0.08890262f, 0.09194047f, 0.05063821f, -0.08781324f, -0.03039108f, 0.06339522f, -0.00919225f, 0.00289297f, 
    -0.08727241f, 0.00321641f, -0.03156504f, 0.02715275f, 0.00845406f, 0.09329952f, 0.05436004f, 0.02907011f, 
    -0.34529510f, 0.17789523f, 0.00609408f, 0.11834969f, -0.36144978f, 0.00147268f, -0.08115261f, 0.06579077f, 
    0.08702156f, 0.01207584f, -0.00218927f, -0.06522070f, 0.00535877f, 0.06311706f, -0.05595261f, -0.01209697f, 
    0.00124897f, -0.02393858f, -0.02920374f, 0.00972377f, -0.11012061f, 0.10167964f, 0.09801877f, -0.10874047f, 
    -0.04578593f, 0.01819302f, -0.07626466f, 0.02828982f, -0.01318089f, 0.02720256f, 0.01468264f, 0.06961613f, 
    0.01069437f, -0.06074160f, -0.11284396f, -0.03894519f, -0.06984991f, -0.07003449f, 0.00141310f, -0.05944914f, 
    -0.07384235f, -0.02357356f, -0.00359598f, -0.17153130f, -0.08315626f, -0.03031767f, 0.06057803f, 0.10217836f, 
    -0.08533929f, 0.04659840f, 0.04964528f, -0.06846394f, -0.06821560f, -0.02070764f, 0.05354356f, -0.07234608f, 
    -0.00547524f, 0.04654656f, 0.13088048f, -0.06784298f, -0.13929769f, -0.09441528f, -0.09647243f, 0.07882194f, 
    0.08854922f, -0.03206964f, 0.05866030f, -0.03334505f, -0.01406300f, 0.02556787f, -0.00816186f, -0.03821010f, 
    -0.00799505f, -0.01337026f, -0.10673400f, 0.00313948f, -0.03839207f, 0.00782955f, -0.01826952f, -0.02011129f, 
    -0.40850586f, 0.10747148f, 0.04337972f, 0.06441710f, 0.13231422f, 0.00983894f, -0.03126872f, 0.06608592f, 
    -0.07459650f, 0.05176299f, 0.06615239f, -0.09290775f, -0.07330269f, 0.01612272f, -0.04495782f, 0.07721611f, 
    0.01495526f, -0.08415607f, 0.11428131f, 0.10167711f, -0.01313760f, -0.16883300f, -0.12790456f, 0.02146928f, 
    0.08062913f, -0.09515531f, 0.09389506f, -0.05005678f, -0.07616623f, -0.01227951f, -0.13143384f, -0.04991850f, 
    -0.04453274f, 0.08997895f, -0.09006207f, -0.00513274f, 0.02594918f, -0.06185248f, -0.00609617f, -0.12895545f, 
    -0.07343332f, -0.16127576f, 0.00880434f, -0.20281309f, -0.14047582f, 0.04087815f, 0.06047133f, 0.07682490f, 
    -0.11528068f, -0.07591091f, -0.03443219f, -0.14220440f, -0.03532002f, 0.02040754f, 0.03880219f, 0.09834240f, 
    -0.01862324f, -0.00727031f, 0.16135108f, 0.02165594f, 0.03469145f, 0.03312419f, 0.05630593f, 0.05815639f, 
    0.02765463f, -0.04022476f, -0.05551863f, -0.00990073f, -0.08139666f, 0.01947087f, -0.05078940f, 0.00277364f, 
    -0.06207560f, -0.00098421f, -0.00790652f, -0.02690108f, -0.02069111f, 0.00963050f, 0.02212566f, 0.04801796f, 
    -0.09644103f, -0.06329644f, 0.02122674f, -0.01356233f, -0.01464476f, 0.03136978f, 0.03468411f, 0.05330617f, 
    0.03632231f, 0.05585710f, -0.04917127f, -0.04090481f, -0.02745273f, 0.01698764f, 0.07495230f, 0.05174566f, 
    -0.03000828f, -0.00710160f, 0.04107081f, 0.03996410f, -0.04631709f, 0.10496237f, -0.03689807f, 0.16254197f, 
    -0.06629756f, -0.07768980f, -0.04837651f, 0.01238698f, 0.04649070f, 0.05130432f, -0.04216209f, -0.04158018f, 
    -0.04238315f, -0.00106008f, 0.09245235f, -0.02493904f, -0.04410777f, -0.13490383f, -0.11427710f, -0.06929300f, 
    -0.01458653f, 0.06429120f, -0.15355700f, 0.17322795f, -0.11307756f, -0.16651368f, 0.03935226f, -0.04365379f, 
    0.02991398f, 0.05931707f, -0.00719361f, 0.08438238f, -0.00221548f, -0.07890698f, 0.03902741f, -0.09962322f, 
    -0.06452596f, 0.01528970f, -0.11419288f, -0.00474389f, -0.07854389f, -0.38004872f, -0.06920683f, 0.16125265f, 
    -0.09293713f, 0.06615504f, 0.03953561f, -0.04287608f, 0.05854096f, -0.02499963f, -0.04898561f, 0.07576307f, 
    0.07348000f, 0.07183510f, 0.05280115f, 0.03879752f, -0.06401474f, 0.06363591f, -0.11526537f, 0.00960820f, 
    0.09679018f, -0.35914591f, -0.07300670f, 0.02600600f, -0.06772158f, -0.07759836f, 0.02626603f, -0.04857553f, 
    0.00294161f, 0.00722011f, -0.06428594f, 0.03674837f, 0.04026833f, 0.06032484f, 0.10077745f, -0.06373576f, 
    -0.00667401f, -0.02871278f, -0.08746821f, -0.07715464f, -0.00985278f, 0.05357235f, -0.07346667f, -0.12963641f, 
    0.03411644f, -0.02781810f, 0.00513479f, -0.06788341f, -0.02892456f, -0.05258488f, -0.00848926f, -0.03809312f, 
    -0.03336409f, -0.07609046f, 0.05832982f, -0.10213061f, -0.02170234f, 0.05845804f, 0.02151998f, 0.04606964f, 
    0.10153081f, 0.09849479f, -0.06633001f, -0.15088232f, 0.14348789f, 0.05093656f, 0.01462181f, -0.02806194f, 
    -0.04975430f, 0.02590003f, -0.01232892f, -0.04207678f, 0.07583839f, -0.07991820f, -0.02994469f, -0.03537585f, 
    0.08500147f, 0.03722267f, 0.08948874f, 0.03255301f, -0.00222826f, 0.04337810f, -0.06038393f, -0.07140912f, 
    -0.13510765f, 0.00330406f, 0.11557618f, 0.02090733f, 0.02981308f, 0.01045632f, -0.01786521f, -0.08792476f, 
    -0.02636185f, 0.01195510f, -0.09195244f, -0.01472860f, -0.03596246f, 0.19322374f, 0.02850498f, 0.05633971f, 
    -0.02754387f, 0.02166922f, 0.02348735f, -0.12121274f, 0.06383392f, -0.00652825f, 0.03834416f, -0.01099531f, 
    -0.03579294f, -0.03831701f, -0.02239777f, -0.06145915f, -0.04899736f, -0.02104986f, -0.03461299f, -0.05920143f, 
    -0.07237789f, 0.05700702f, 0.04018626f, -0.01776080f, 0.09916023f, -0.34760696f, 0.03015935f, -0.26611155f, 
    0.07924312f, 0.01966091f, 0.02689320f, -0.03991559f, -0.02899957f, -0.07070897f, 0.01929794f, -0.03015406f, 
    0.04810932f, 0.03932777f, -0.00307121f, 0.03638959f, -0.03742237f, -0.01452643f, -0.05618152f, 0.06460943f, 
    -0.15982124f, 0.22214375f, 0.07339571f, 0.06503838f, -0.18172428f, -0.02559345f, 0.01782459f, 0.00175893f, 
    0.03151795f, 0.03593385f, -0.01219136f, 0.05287867f, -0.03414576f, -0.07074441f, -0.06984970f, -0.01115934f, 
    -0.01008737f, 0.02941278f, 0.03274030f, 0.00241115f, 0.52200902f, -0.06486940f, 0.07438941f, 0.00559525f, 
    -0.11719815f, 0.07180315f, 0.12521191f, 0.05014659f, -0.09457597f, -0.06937771f, -0.05786027f, -0.03506264f, 
    0.16106886f, -0.01659223f, 0.03496811f, -0.00843183f, -0.02213590f, 0.06107979f, 0.00052756f, 0.02029727f, 
    -0.09346693f, 0.23577966f, -0.07946021f, 0.06677169f, -0.13654868f, -0.00262712f, 0.00585165f, -0.02622098f, 
    0.01312847f, -0.02679750f, -0.00298003f, 0.08013857f, 0.01963264f, -0.01298765f, -0.05061401f, 0.01805948f, 
    -0.01852667f, 0.03358116f, -0.07997043f, 0.00192238f, 0.11254032f, -0.51749307f, -0.07902770f, -0.18241206f, 
    -0.04316635f, -0.01091981f, 0.04272742f, -0.03380588f, -0.01711135f, 0.02328015f, 0.00857320f, 0.05625786f, 
    0.06220711f, 0.10229560f, 0.03790941f, -0.07548237f, 0.01136498f, -0.04898168f, -0.03519020f, -0.00400409f, 
    -0.23492712f, 0.15509512f, 0.09457319f, 0.08953001f, -0.08674637f, 0.02013637f, -0.07891536f, -0.03504401f, 
    0.05175203f, -0.08387438f, 0.12313986f, -0.02359692f, -0.09086044f, 0.06493600f, -0.00859130f, 0.10070834f, 
    -0.01472144f, -0.08259127f, -0.00141217f, 0.01639642f, -0.10352308f, 0.20442049f, 0.00034543f, 0.08315351f, 
    -0.14314574f, -0.04549485f, 0.01212457f, 0.02590884f, 0.01519699f, 0.03033457f, -0.05039873f, 0.02366436f, 
    0.02467752f, -0.03643251f, 0.05995350f, -0.02160843f, -0.03293926f, 0.08086250f, -0.02168692f, 0.02463439f, 
    0.14537276f, -0.11307410f, 0.00014247f, -0.00512546f, -0.01311937f, -0.01552071f, 0.06558402f, -0.02789161f, 
    -0.02304055f, -0.00599497f, 0.06563953f, 0.09164429f, -0.05183232f, -0.00544358f, 0.12031871f, -0.11011395f, 
    -0.06842394f, 0.04923964f, -0.11789554f, 0.06360810f, -0.01497799f, -0.05913791f, -0.10780248f, -0.08597576f, 
    0.01819201f, 0.00172680f, 0.05265774f, -0.05500555f, -0.12083981f, -0.08826914f, -0.01641441f, -0.10619394f, 
    -0.13081911f, -0.04834081f, 0.02132449f, -0.09635375f, -0.07641086f, 0.00359421f, -0.00938770f, 0.08246849f, 
    -0.20186396f, 0.00957194f, -0.13359362f, -0.30683598f, 0.03444574f, -0.02354284f, -0.00336445f, -0.06858348f, 
    -0.05569442f, -0.00300738f, -0.06087549f, -0.03018566f, -0.15361363f, -0.09943581f, 0.05417148f, 0.05066172f, 
    -0.00615830f, -0.01266886f, 0.07803866f, 0.00214955f, 0.00269728f, 0.04542796f, 0.01390285f, -0.30261132f, 
    0.09164204f, -0.02463266f, -0.00703822f, -0.00517282f, -0.09260876f, -0.04798545f, 0.04076450f, 0.00803507f, 
    0.03347709f, -0.01629783f, -0.05076125f, 0.05228470f, 0.04221180f, -0.03108582f, 0.00486838f, 0.00639829f, 
    -0.32012022f, 0.16078271f, -0.04336974f, 0.11169038f, -0.05887002f, -0.12486995f, 0.04348820f, -0.00956681f, 
    0.06155252f, 0.02968107f, 0.00839984f, 0.01081675f, 0.06324871f, -0.06507737f, 0.03871361f, -0.01365498f, 
    -0.02237817f, -0.07451396f, -0.11453152f, -0.10690711f, -0.21287979f, 0.26913986f, 0.13542195f, -0.06611137f, 
    -0.23404667f, 0.06519707f, 0.03979159f, -0.00696166f, 0.02071012f, 0.04925746f, -0.03665455f, 0.01307468f, 
    0.00258967f, -0.00438046f, 0.00473952f, 0.16627744f, -0.11774699f, -0.07148871f, 0.07386702f, 0.04779553f, 
    -0.04566269f, 0.15661275f, 0.05779792f, 0.08415616f, -0.04964911f, 0.13305354f, -0.11071767f, 0.03470248f, 
    -0.02090090f, 0.01523320f, -0.00570116f, 0.04252724f, 0.07126517f, -0.00297011f, 0.03302063f, -0.02217669f, 
    -0.01594247f, 0.00227505f, -0.03083935f, -0.03388391f, 0.08049148f, -0.09434748f, 0.05846957f, 0.05068093f, 
    0.05817361f, 0.04820495f, -0.01518853f, 0.01064958f, -0.01306616f, -0.01408761f, -0.00787888f, 0.06878432f, 
    0.00618905f, -0.01751950f, -0.01636413f, -0.02621577f, 0.03535933f, 0.01113183f, 0.08546945f, 0.03466480f, 
    0.12619925f, 0.12890340f, 0.16471156f, 0.21997848f, 0.09867405f, -0.01627975f, 0.12711997f, -0.00610419f, 
    0.06134539f, -0.06615735f, -0.07737214f, 0.03512365f, -0.05111682f, 0.01546228f, -0.03808719f, -0.00168174f, 
    -0.04161345f, 0.04848375f, -0.01924471f, -0.04615931f, 0.04685080f, 0.04643324f, 0.15248194f, 0.03793474f, 
    0.07616412f, 0.03372580f, 0.00593189f, -0.06517726f, -0.06355228f, -0.00759227f, -0.02317664f, 0.01313678f, 
    -0.01384029f, -0.05080377f, -0.01779323f, 0.04732325f, -0.02785853f, -0.01333285f, 0.06601617f, -0.08218660f, 
    -0.00768680f, 0.15301834f, -0.00814143f, 0.06219253f, 0.06215882f, -0.05046256f, 0.08419383f, -0.10266862f, 
    -0.03007403f, 0.02263309f, -0.12680416f, 0.00441068f, -0.04014580f, -0.02069565f, -0.05289732f, 0.04944703f, 
    0.01615555f, 0.09062137f, -0.00475857f, 0.00591712f, 0.04956691f, 0.02517493f, 0.05676650f, 0.07815195f, 
    0.15206623f, 0.07412544f, 0.07906299f, -0.00682205f, -0.03848350f, 0.00892861f, -0.00575354f, -0.04938693f, 
    -0.04423627f, -0.04732196f, -0.03507062f, 0.01649220f, -0.03130942f, -0.04410778f, 0.02483349f, 0.01266844f, 
    0.12688628f, -0.40837872f, 0.17969696f, 0.07915029f, -0.21315259f, 0.16173588f, -0.02513889f, -0.05362161f, 
    -0.03321399f, 0.04650915f, -0.03755698f, -0.02786892f, -0.10397654f, 0.01342818f, -0.08370913f, -0.07141407f, 
    0.03311525f, -0.01277171f, -0.03858327f, -0.03903791f, -0.08469257f, 0.00951679f, -0.10605776f, -0.10416760f, 
    -0.11249211f, -0.04782921f, 0.01911910f, 0.01328315f, 0.00129938f, -0.04132193f, -0.00698982f, -0.05238744f, 
    0.04222874f, -0.03937249f, -0.00076154f, -0.01354154f, -0.04269214f, -0.01094640f, 0.01119396f, 0.04033742f, 
    -0.04451923f, 0.04216649f, 0.17334867f, 0.04784145f, 0.13072635f, -0.09630877f, 0.12430565f, -0.04426505f, 
    0.01910527f, -0.00337111f, -0.01666245f, 0.03765283f, -0.05406935f, -0.02137556f, -0.00751276f, -0.00795796f, 
    0.07359643f, 0.00901595f, -0.01338852f, -0.00692058f, 0.02409248f, -0.12077101f, -0.05423695f, 0.10056344f, 
    -0.01260761f, 0.04920339f, -0.01642736f, 0.04040230f, 0.00377051f, -0.06340852f, -0.01588348f, -0.02694468f, 
    -0.02149847f, -0.00461893f, -0.02974170f, 0.04340107f, -0.02179995f, -0.03773691f, -0.00374479f, -0.04295426f, 
    -0.22919780f, -0.02054230f, -0.08462514f, -0.02617744f, -0.09518884f, -0.02095840f, -0.01473923f, -0.02996312f, 
    -0.01056353f, -0.04519303f, 0.00591326f, -0.04057701f, -0.00940796f, -0.01580303f, -0.02766665f, -0.04768405f, 
    -0.03805637f, -0.00934071f, -0.00886034f, -0.05371967f, -0.12803216f, -0.04007467f, -0.05735906f, 0.13201265f, 
    -0.04140389f, 0.04092848f, -0.10423061f, -0.05053386f, 0.02386646f, -0.02904484f, -0.05544899f, 0.00690018f, 
    0.02409632f, -0.01015327f, -0.04453981f, -0.00273914f, -0.02072253f, 0.02410215f, 0.01888552f, 0.03229109f, 
    -0.14476913f, -0.15589012f, 0.03303431f, -0.07372529f, -0.02623754f, -0.01650752f, -0.00811815f, -0.09268165f, 
    0.04187272f, -0.04893667f, -0.05361131f, -0.00400315f, 0.02132607f, -0.02934919f, -0.05257649f, -0.03882713f, 
    0.04434641f, -0.00068315f, -0.00752998f, 0.00174801f, -0.07086769f, 0.13698699f, -0.30526310f, 0.05504821f, 
    -0.02226592f, -0.07454874f, 0.02762346f, 0.00977040f, -0.05584586f, 0.05228197f, -0.06390870f, 0.03703141f, 
    -0.05972240f, -0.02900505f, -0.07052200f, -0.01343180f, 0.04340425f, 0.01720531f, -0.02347310f, -0.05216711f, 
    0.11327866f, -0.12682582f, 0.01511241f, -0.03469717f, 0.00013694f, 0.06098827f, -0.01587450f, -0.05301728f, 
    -0.06036142f, 0.02312090f, 0.01786312f, -0.03656087f, -0.05733969f, -0.03717618f, -0.04344470f, -0.03445435f, 
    0.07991199f, -0.00096439f, -0.01122393f, -0.04085316f, 0.06117297f, 0.05605457f, -0.06420968f, 0.09681714f, 
    0.15798700f, -0.00019077f, -0.09464069f, -0.04874208f, -0.00355438f, -0.04048393f, -0.03802666f, -0.00487740f, 
    -0.03269319f, -0.02562611f, -0.00928396f, 0.04517810f, -0.00777148f, -0.00737464f, 0.03310693f, -0.08053894f, 
    0.06367847f, -0.22923897f, 0.00928456f, 0.05031713f, -0.11726982f, 0.07833057f, 0.02053505f, 0.02627702f, 
    0.00959509f, -0.07317059f, -0.02071371f, -0.01660447f, 0.00440540f, -0.05047990f, 0.02690868f, 0.00508598f, 
    0.11553016f, 0.00195064f, 0.03540595f, -0.03532941f, -0.24090117f, 0.11955757f, 0.07719854f, 0.03645383f, 
    0.04158701f, -0.03285536f, -0.12757447f, 0.00240092f, 0.03174399f, -0.07115930f, 0.00554793f, 0.05542847f, 
    0.02878892f, -0.02622041f, -0.01539682f, 0.03154219f, 0.01706030f, 0.03963869f, 0.00010159f, -0.00395479f, 
    0.09037071f, 0.00533999f, -0.02034976f, 0.08924441f, 0.24952267f, -0.01792521f, -0.02676895f, -0.03669286f, 
    0.00884248f, -0.02215061f, -0.06498950f, 0.06178551f, -0.06223983f, -0.02246157f, -0.10066832f, 0.02674922f, 
    -0.07701114f, -0.05321459f, -0.01136062f, 0.03406566f, 0.07208302f, 0.08884115f, -0.06779945f, -0.00109032f, 
    0.01774640f, -0.05320837f, 0.00722596f, -0.04749636f, 0.02595918f, -0.01663468f, -0.06775948f, 0.02309512f, 
    -0.08806122f, -0.05068503f, -0.03591356f, 0.00152950f, -0.03273083f, 0.03083518f, -0.04862635f, -0.03396667f, 
    -0.03392413f, 0.03012841f, -0.18050289f, -0.07748240f, -0.11633331f, -0.00435916f, -0.02292772f, -0.06135967f, 
    -0.00154283f, -0.02411379f, -0.05987186f, -0.02122751f, -0.02045514f, -0.06828995f, -0.01223737f, -0.00886350f, 
    -0.07588342f, 0.02955761f, 0.00444334f, 0.04016801f, 0.13034201f, 0.09484570f, 0.16354257f, -0.08005614f, 
    0.10485535f, -0.04475529f, 0.08200794f, -0.01372874f, 0.00358269f, 0.02820166f, 0.01974652f, 0.02419500f, 
    -0.04673569f, -0.02390954f, 0.02440280f, 0.03377364f, 0.00480333f, -0.00024031f, 0.05791301f, -0.03504406f, 
    -0.09382959f, -0.25968701f, -0.08734803f, -0.11814547f, -0.14724337f, -0.02817340f, -0.08335795f, -0.01422228f, 
    -0.05768723f, -0.09296256f, -0.01855771f, -0.02905191f, -0.03879149f, -0.00986493f, -0.04512169f, 0.01401512f, 
    0.02761121f, -0.05404455f, -0.03051988f, 0.00010982f, -0.06435280f, -0.01292052f, -0.03303024f, -0.08028413f, 
    -0.17972617f, 0.08338673f, -0.00594582f, -0.00950546f, -0.01882326f, -0.06553668f, -0.01282262f, -0.06734233f, 
    -0.08429393f, 0.00694630f, -0.03392527f, -0.01358080f, 0.03362981f, 0.01033126f, -0.02815810f, 0.00098524f, 
    -0.01736428f, 0.21292214f, -0.02574084f, -0.15485469f, 0.03803558f, 0.02496236f, 0.13387269f, -0.02763781f, 
    -0.02281651f, 0.03999737f, 0.00655164f, 0.00982670f, 0.00862351f, -0.04147367f, 0.01886765f, 0.02465083f, 
    0.01418172f, 0.03696501f, -0.03676502f, 0.07312408f, 0.02760044f, -0.11130259f, 0.03508290f, -0.01629025f, 
    -0.10797612f, 0.04161485f, -0.11416194f, -0.02979096f, -0.07762855f, -0.01604348f, -0.00906033f, 0.00469629f, 
    -0.04117125f, -0.03190590f, -0.10153531f, -0.02054200f, -0.00174197f, -0.00426833f, -0.01826994f, -0.05918982f, 
    -0.08288756f, -0.00482034f, 0.02490953f, 0.01827076f, -0.14364997f, 0.05681614f, -0.01563966f, 0.01527148f, 
    -0.03101270f, -0.02599380f, -0.00390662f, 0.02727721f, -0.00539873f, 0.01554598f, -0.03686169f, 0.10130119f, 
    -0.00833291f, -0.02754406f, -0.06808251f, -0.04040020f, -0.14572589f, -0.00983748f, 0.05525015f, 0.06548693f, 
    -0.02790295f, 0.10925384f, -0.08495352f, 0.07382928f, 0.09955528f, 0.04711974f, -0.07228059f, 0.07437138f, 
    0.06014116f, 0.00838730f, -0.05742175f, 0.07513516f, 0.03020942f, 0.05711577f, -0.04778427f, 0.01106215f, 
    0.05187100f, 0.12006723f, -0.20817471f, 0.00550150f, 0.17423321f, -0.11229236f, -0.09583586f, -0.03867843f, 
    0.05100849f, -0.02653555f, -0.04615716f, -0.00641129f, -0.08847999f, 0.06322511f, -0.02783809f, 0.03488212f, 
    -0.12176438f, -0.00666980f, -0.07710835f, 0.03083375f, 0.03965954f, 0.04863305f, -0.02079795f, 0.02839885f, 
    0.05080066f, 0.02114519f, -0.04910515f, -0.10278337f, 0.02819593f, 0.03079387f, -0.04766224f, 0.00770835f, 
    0.01248162f, -0.02902420f, -0.01563370f, -0.02149342f, -0.01567993f, 0.00610931f, 0.00185630f, -0.03035798f, 
    -0.11456303f, 0.02053722f, -0.10851108f, -0.05278732f, -0.01508225f, 0.00522518f, -0.09845573f, -0.06258771f, 
    0.02884394f, -0.03169150f, -0.09579763f, 0.04048884f, 0.02341762f, 0.00403754f, -0.03327721f, -0.00922916f, 
    -0.05230255f, 0.00196085f, 0.00846945f, 0.02364732f, 0.12133217f, -0.23345621f, 0.07402319f, 0.00991527f, 
    -0.14408746f, -0.00110431f, -0.04250087f, -0.02416329f, -0.06098280f, 0.00094011f, 0.00216868f, 0.01791403f, 
    -0.05618969f, 0.00529145f, -0.03649265f, -0.01083506f, 0.07501316f, -0.00723373f, -0.02815088f, 0.00625159f, 
    0.02399371f, 0.08999970f, 0.03745977f, -0.06866874f, 0.00567346f, -0.13561612f, 0.01285987f, -0.07568292f, 
    -0.02405716f, 0.02889431f, -0.01533271f, 0.05808178f, -0.03474941f, -0.01514288f, -0.06727671f, -0.01827468f, 
    -0.02747300f, 0.01090653f, 0.05411919f, -0.07590932f, -0.08848920f, 0.03333400f, -0.09962777f, -0.03911012f, 
    0.12210382f, -0.02978438f, -0.04795656f, -0.09527203f, -0.01903090f, -0.01406467f, 0.03354390f, -0.00941753f, 
    0.01030221f, -0.05222958f, -0.04793173f, -0.02930441f, -0.06007883f, 0.03023298f, -0.03497945f, -0.04015211f, 
    -0.26972473f, -0.06763242f, -0.07341634f, -0.04073076f, -0.19566689f, -0.00236256f, -0.02912811f, -0.01931650f, 
    -0.05700823f, -0.09816001f, 0.02300436f, -0.00717994f, -0.01687465f, -0.00577188f, -0.00740162f, 0.01188306f, 
    0.01856167f, -0.01983483f, -0.00589806f, -0.00382898f, 0.06389444f, -0.12741397f, 0.03947340f, -0.01078296f, 
    -0.04756799f, -0.00526496f, -0.09632968f, -0.10847370f, -0.03313555f, -0.04075797f, -0.06669301f, 0.00872873f, 
    0.01254859f, 0.03429849f, -0.04103439f, -0.04823762f, 0.04894068f, -0.04918233f, 0.01646507f, 0.01218012f, 
    0.17732154f, 0.05443692f, -0.04007673f, 0.02348467f, 0.13234115f, -0.14144292f, -0.09941752f, -0.02292055f, 
    -0.03008138f, -0.00878846f, -0.03433058f, -0.00717324f, -0.03466580f, -0.03252719f, -0.02443650f, -0.08365852f, 
    -0.03000663f, 0.01707855f, -0.00067205f, -0.02857478f, -0.09011765f, 0.08011205f, -0.00246806f, -0.09277263f, 
    0.01232538f, -0.02789940f, 0.02793393f, -0.03255622f, -0.05807393f, -0.02303349f, -0.02891197f, 0.03911487f, 
    -0.01943085f, -0.05777906f, -0.02664151f, 0.03432445f, 0.00485152f, 0.01533429f, 0.01350895f, 0.02031925f, 
    0.05478682f, 0.02303727f, 0.10688105f, -0.04111860f, 0.05598031f, -0.00163982f, 0.05914885f, -0.04683654f, 
    0.02868909f, 0.03064381f, 0.03157712f, 0.03219837f, 0.06754435f, 0.02752081f, -0.01391814f, -0.04163750f, 
    -0.01814474f, 0.01477004f, 0.00829388f, -0.02895588f, 0.11962632f, 0.12586324f, -0.02643070f, -0.11655836f, 
    -0.00930148f, -0.12380759f, 0.01646272f, 0.02058181f, -0.02619171f, 0.07199144f, -0.04283319f, -0.00267161f, 
    -0.03655102f, 0.05966618f, 0.07404125f, -0.04272941f, 0.00114772f, -0.04008435f, -0.01741590f, 0.02898232f, 
    0.11705088f, -0.00373080f, 0.04917634f, 0.09122238f, 0.09306790f, -0.00078203f, 0.02930049f, -0.02498907f, 
    -0.07479447f, 0.03108512f, 0.01184646f, 0.04228917f, -0.00750055f, -0.04383758f, -0.03653932f, -0.05726768f, 
    -0.00690152f, -0.07120842f, 0.02670503f, -0.01405565f, -0.11971199f, 0.02488148f, 0.03585083f, 0.01958180f, 
    0.00134899f, 0.06764808f, -0.04326399f, 0.01445397f, 0.01218294f, 0.03154687f, -0.02727167f, 0.00900047f, 
    0.01031574f, 0.01865765f, -0.02496779f, -0.01593807f, -0.11297334f, -0.00859106f, 0.01628558f, -0.01647596f, 
    0.08408938f, 0.02543578f, -0.09423595f, 0.03069691f, 0.08800784f, -0.07496582f, -0.02226366f, -0.05510506f, 
    0.02217279f, -0.03405155f, -0.06528141f, 0.02318706f, -0.03028946f, 0.00394033f, -0.05723910f, -0.02162978f, 
    -0.08708270f, -0.01127889f, -0.04332530f, 0.00887689f, 0.06600464f, -0.15433510f, -0.10366577f, -0.13976584f, 
    -0.10239436f, -0.02423532f, -0.03575433f, 0.00663647f, -0.07352902f, -0.08693387f, 0.05998310f, -0.02714201f, 
    -0.05654028f, 0.00868962f, -0.05931293f, 0.04778321f, -0.01873286f, -0.03952424f, -0.06432502f, -0.00364113f, 
    -0.23877636f, 0.14120941f, 0.04723122f, -0.06666172f, -0.11980792f, 0.01626606f, -0.03912671f, -0.04689080f, 
    0.01344965f, -0.01778601f, 0.00900002f, 0.04446683f, -0.01049173f, -0.00088367f, 0.01839498f, -0.05124244f, 
    -0.05104846f, 0.02563574f, 0.01037853f, -0.00771585f, -0.09835778f, 0.11822195f, 0.20028874f, -0.00116341f, 
    0.09652028f, 0.01503775f, 0.02555410f, -0.01095853f, 0.02156386f, -0.02312669f, 0.03616378f, 0.03034126f, 
    0.03371901f, 0.04649073f, -0.08906936f, 0.02400723f, -0.03184417f, 0.02596338f, 0.02825138f, -0.01736808f, 
    -0.00195399f, 0.00885712f, 0.02167820f, 0.00424220f, -0.03868924f, 0.00534286f, -0.01612515f, -0.04171925f, 
    -0.00741426f, -0.03342318f, 0.01856341f, -0.00310083f, 0.02511709f, -0.02606087f, -0.00188815f, -0.03118006f, 
    -0.04980666f, -0.02784066f, 0.03096416f, -0.03194434f, 0.05790580f, 0.10099751f, 0.10019024f, 0.06984638f, 
    0.10766097f, -0.00800226f, 0.04289481f, -0.03512362f, -0.03563090f, -0.01699905f, 0.03323688f, 0.00948011f, 
    -0.04679779f, -0.03237621f, -0.02329808f, -0.04105905f, -0.04050979f, 0.02759719f, -0.00000140f, -0.07155745f, 
    0.13770422f, 0.15564871f, 0.09125454f, -0.03804705f, 0.10044772f, -0.08233375f, 0.07617915f, -0.07061218f, 
    -0.00889366f, 0.01675735f, -0.04944593f, 0.02760199f, -0.03603247f, -0.00753068f, -0.00968843f, 0.02952805f, 
    0.00481547f, 0.09653434f, 0.01786201f, -0.00861793f, 0.00054092f, 0.05401251f, -0.10160274f, 0.10750831f, 
    0.07823218f, -0.01895777f, -0.04576620f, -0.02801973f, -0.02907429f, -0.01127576f, -0.04017345f, 0.02298761f, 
    -0.03423085f, -0.05678291f, -0.01830322f, -0.03572133f, 0.00651231f, 0.01234677f, 0.00829729f, -0.01959975f, 
    0.13679884f, 0.05425113f, 0.12361031f, -0.03932197f, 0.13068932f, -0.06280877f, 0.04521354f, -0.03204991f, 
    0.03159960f, -0.01851395f, 0.01012388f, 0.00456504f, 0.00925931f, 0.03370215f, -0.00723905f, -0.08273924f, 
    0.03892621f, 0.07396661f, 0.00602391f, -0.05493262f, 0.09808014f, -0.02994751f, 0.21504168f, 0.05349933f, 
    0.12414666f, 0.01066261f, 0.11982346f, -0.00089608f, -0.01164110f, -0.01496689f, 0.00113637f, 0.03127898f, 
    -0.01250450f, 0.01289335f, -0.03767025f, -0.06665806f, -0.02380178f, -0.01879277f, 0.01913669f, -0.04099410f, 
    -0.22853725f, -0.02556862f, -0.29312903f, -0.13582538f, -0.13370970f, 0.01324514f, -0.06421433f, -0.04940385f, 
    0.02111514f, -0.02946115f, -0.13958445f, 0.03216295f, -0.01493797f, -0.04019710f, 0.01267335f, -0.00083057f, 
    0.00029856f, 0.00110705f, 0.02570724f, 0.09050586f, 0.31069785f, -0.14194359f, 0.13025726f, -0.08798078f, 
    0.16011496f, -0.07665087f, 0.02600119f, 0.02262060f, 0.03783663f, 0.02113722f, -0.04969257f, 0.01731872f, 
    -0.03744142f, 0.10080678f, 0.02036961f, -0.00857061f, 0.05063873f, -0.00430578f, 0.00452604f, -0.04940813f, 
    -0.46041995f, -0.00109167f, -0.14148317f, -0.13314867f, -0.12647580f, 0.09337705f, -0.05068673f, -0.02911086f, 
    0.02043390f, -0.04312401f, -0.03730312f, 0.02019691f, -0.03143965f, -0.02016336f, 0.04899416f, -0.05147503f, 
    0.02328205f, 0.00853986f, -0.01126576f, 0.10107706f, -0.03550709f, 0.11897355f, 0.21170287f, 0.12723812f, 
    0.12957601f, 0.11913580f, 0.09701763f, 0.02081640f, -0.01640753f, -0.04769028f, -0.07443899f, 0.03716840f, 
    0.04523849f, -0.04066703f, -0.03279947f, -0.01888897f, 0.02527979f, -0.00309956f, 0.05712415f, -0.04127003f, 
    -0.11742527f, -0.11704755f, -0.13028750f, -0.16262396f, -0.20963842f, -0.01208939f, 0.06529497f, -0.01057237f, 
    -0.06911144f, -0.06375697f, 0.00664519f, -0.02875867f, -0.05936712f, 0.01978623f, -0.00986808f, -0.01758390f, 
    -0.00743239f, 0.02849769f, -0.01497889f, 0.01920372f, -0.02909647f, 0.04154493f, -0.13720977f, -0.02818969f, 
    -0.02144781f, -0.00874088f, -0.10048334f, -0.04475724f, -0.01978147f, -0.02508127f, -0.09909917f, 0.04965767f, 
    -0.00863185f, -0.00545804f, -0.06721821f, 0.03901100f, -0.01661511f, -0.00790316f, -0.01513763f, 0.00690371f, 
    0.00340027f, 0.08623129f, 0.13316491f, 0.04962152f, 0.03217251f, -0.01573373f, 0.04216217f, -0.00624133f, 
    -0.01514283f, -0.03140632f, -0.01250913f, 0.02222625f, 0.05041103f, -0.03990938f, -0.01312757f, -0.08071817f, 
    -0.04501715f, -0.00138546f, 0.03214735f, -0.03659178f, -0.05297397f, 0.06833655f, 0.12664755f, 0.03747381f, 
    0.10118815f, 0.00947148f, -0.04482174f, 0.03147941f, 0.00037219f, 0.04907244f, 0.00285516f, -0.00291105f, 
    -0.02060400f, -0.03029275f, -0.00209195f, 0.02127394f, -0.03946053f, 0.05576785f, 0.09368490f, -0.02018039f, 
    0.05629167f, 0.06907882f, 0.12623735f, 0.06291819f, 0.14305921f, 0.08924771f, 0.06319894f, 0.01347508f, 
    0.00308326f, -0.01277663f, 0.00652090f, 0.02520052f, 0.00236675f, -0.01242192f, -0.06248286f, -0.01603115f, 
    -0.02728377f, -0.04540943f, 0.04544029f, 0.07685744f, -0.02266364f, 0.09191119f, 0.15245140f, 0.00794067f, 
    0.07038622f, 0.02387440f, 0.04367179f, -0.01123632f, -0.01343632f, -0.01071966f, -0.04486926f, 0.00638710f, 
    -0.03516775f, -0.01001299f, -0.02032031f, 0.01989662f, 0.04490663f, -0.00469337f, 0.02425025f, -0.00041529f, 
    -0.08222885f, 0.08126517f, 0.05163404f, -0.08208951f, -0.09320498f, -0.02530751f, 0.03357338f, -0.02346704f, 
    0.02268040f, 0.03808918f, 0.02558966f, 0.00086114f, 0.02763364f, -0.04534108f, -0.01552015f, -0.02784874f, 
    0.02896741f, 0.01724598f, -0.04148941f, 0.05741369f, -0.00600952f, -0.11688907f, -0.24637502f, 0.05500266f, 
    0.11552897f, -0.05068083f, -0.08757266f, -0.03072138f, -0.03783685f, -0.03806856f, -0.09989494f, 0.00922480f, 
    -0.01485979f, 0.04019807f, -0.06461496f, 0.00265284f, 0.00115985f, -0.04683115f, 0.01588926f, 0.02308075f, 
    -0.15064077f, 0.06614853f, -0.02631481f, 0.02876239f, -0.00608545f, -0.07668504f, -0.09262308f, -0.15149944f, 
    -0.04926416f, -0.01804318f, 0.01560192f, -0.00860652f, 0.00560287f, -0.07112036f, -0.02684348f, -0.03379505f, 
    0.00401236f, -0.02766042f, 0.00323120f, 0.03883931f, -0.20021461f, -0.03396266f, 0.01977983f, -0.08558577f, 
    -0.13173924f, 0.02177277f, 0.00675373f, 0.01836561f, -0.02702804f, -0.01192169f, 0.04077161f, 0.02272156f, 
    0.01061130f, 0.01249635f, 0.04110676f, -0.01999668f, -0.08732187f, -0.05179752f, -0.12853383f, 0.04340028f, 
    -0.22492608f, 0.06819623f, -0.01053313f, -0.11836424f, -0.09923765f, -0.07019184f, 0.00265739f, -0.05676629f, 
    -0.00978836f, -0.04445085f, 0.02298390f, -0.00935458f, -0.05474383f, 0.04529727f, 0.07798667f, -0.10357049f, 
    0.05480994f, -0.02362156f, -0.06873124f, -0.09495398f, -0.17899096f, -0.02580646f, 0.18861771f, -0.06479453f, 
    -0.01001051f, 0.01429008f, 0.02664042f, 0.01067050f, 0.00274812f, -0.01694776f, -0.00012294f, 0.00849033f, 
    -0.01165498f, 0.03038303f, 0.03186088f, -0.06948085f, 0.01954562f, 0.03158978f, -0.11901551f, 0.04712589f, 
    -0.12976846f, 0.20227510f, 0.11392567f, 0.00984443f, -0.25488636f, -0.06964121f, -0.02844144f, -0.00647438f, 
    -0.05478255f, -0.09183376f, 0.07999758f, -0.02482514f, 0.00287113f, -0.03186680f, 0.01914998f, -0.06373294f, 
    0.03528235f, -0.10840343f, 0.04949123f, -0.00328711f, -0.20243268f, -0.23595659f, 0.09141875f, -0.13559383f, 
    -0.10963378f, -0.06434279f, -0.04515905f, 0.00337669f, -0.02962970f, 0.00656559f, -0.01408894f, -0.00700845f, 
    0.03934390f, -0.00246345f, -0.01307745f, -0.04604603f, -0.05234062f, -0.04481015f, -0.05690974f, -0.04010464f, 
    0.06377588f, 0.15046102f, 0.07987889f, 0.01915680f, 0.09299239f, -0.04834860f, -0.03446598f, -0.04801801f, 
    -0.10350120f, 0.08136278f, -0.06633974f, 0.03490120f, 0.04862629f, -0.03007042f, -0.06917977f, 0.03458016f, 
    -0.02164855f, -0.03115094f, 0.02104497f, 0.02774263f, 0.07390550f, 0.22981191f, -0.07148027f, 0.00885226f, 
    -0.01721806f, -0.00157358f, 0.04375267f, -0.06771276f, -0.02664561f, -0.07573032f, 0.09067027f, 0.03621169f, 
    -0.00283534f, -0.12447558f, -0.00842281f, -0.11968126f, 0.00626687f, 0.07288371f, 0.00185151f, -0.08993308f, 
    -0.00698579f, 0.07164508f, 0.19293122f, -0.02010023f, 0.02510470f, -0.14297058f, -0.09357529f, 0.03337584f, 
    -0.00060181f, 0.02843680f, -0.02843861f, -0.04445890f, -0.06643740f, -0.05757040f, -0.00076445f, -0.01966799f, 
    -0.01294961f, -0.04962792f, 0.06060079f, -0.06909288f, 0.02697102f, -0.07815600f, -0.22604242f, -0.01313262f, 
    0.01261504f, -0.02853381f, -0.00583802f, 0.01312809f, 0.04288011f, 0.04278650f, 0.05620140f, -0.07496799f, 
    0.01999409f, 0.03262820f, 0.03332441f, 0.06090701f, -0.01785460f, 0.03762542f, 0.02066535f, -0.02284683f, 
    0.11163603f, 0.01275291f, -0.21595706f, 0.07289010f, 0.02884329f, 0.07160406f, 0.07388539f, -0.00873115f, 
    -0.07256725f, 0.00686841f, -0.02421766f, 0.00375881f, 0.05013910f, 0.01614498f, -0.01848113f, -0.00556499f, 
    -0.01095431f, -0.03655975f, 0.05813435f, -0.03216918f, -0.08482528f, -0.06955784f, -0.09047545f, -0.09697613f, 
    -0.00435917f, 0.05531874f, -0.03605495f, -0.04357038f, 0.07723590f, -0.02567770f, 0.09668505f, 0.00593155f, 
    0.02341849f, -0.06958966f, 0.02471580f, -0.04836827f, 0.00274837f, 0.00551895f, 0.01216245f, -0.03305355f, 
    0.07744339f, 0.09821609f, -0.21928892f, -0.01869800f, 0.02865447f, 0.01486889f, 0.00014676f, 0.01093238f, 
    -0.04249660f, -0.01537615f, -0.04890493f, 0.02272023f, 0.04346805f, 0.03202602f, -0.00596378f, 0.05820157f, 
    -0.03151653f, -0.03806857f, 0.05106255f, 0.06051607f, -0.00671401f, 0.14555062f, 0.10839200f, 0.04847798f, 
    -0.11204311f, -0.08319762f, -0.00682927f, 0.03746062f, -0.12573710f, -0.05945991f, 0.03723662f, 0.00922495f, 
    0.00090533f, -0.05598383f, -0.04663199f, -0.10955048f, 0.03324590f, -0.12277343f, 0.10505570f, -0.06122210f, 
    0.07486200f, -0.05083263f, 0.07475765f, -0.00848009f, 0.07098395f, 0.01417785f, 0.01920543f, 0.01880627f, 
    -0.08528947f, -0.00364036f, 0.01903504f, 0.02059164f, -0.03273156f, 0.06258500f, -0.00934800f, 0.00641055f, 
    -0.00971737f, 0.04184447f, -0.06621879f, 0.02510869f, -0.11000815f, 0.03562678f, 0.01945096f, -0.11245610f, 
    -0.05336032f, -0.06303453f, -0.07173923f, -0.04611901f, 0.01186918f, -0.12561828f, 0.07023872f, 0.03170166f, 
    0.01984322f, 0.03835210f, 0.06074309f, -0.03231273f, -0.01626275f, -0.00686699f, -0.00906554f, 0.01504043f, 
    0.05479711f, -0.14378870f, -0.18068764f, -0.13809159f, 0.01697103f, -0.05737124f, 0.01047385f, 0.00089214f, 
    -0.05364368f, -0.06299793f, 0.02080063f, -0.07193233f, -0.02546057f, 0.03737599f, 0.13324919f, 0.02732036f, 
    -0.06197030f, 0.03290486f, -0.03086864f, 0.02534334f, -0.00305279f, 0.10826891f, -0.15710844f, 0.06341209f, 
    -0.11237303f, -0.00205120f, 0.00571285f, -0.13878997f, -0.02560694f, -0.05861576f, 0.06618818f, -0.03133029f, 
    0.03849618f, 0.04494599f, -0.02123511f, 0.02288324f, 0.02977812f, -0.12989376f, 0.06787821f, 0.02928790f, 
    -0.24195245f, -0.08061782f, 0.08225413f, -0.15120766f, -0.14121863f, -0.04582172f, -0.08572663f, -0.07438451f, 
    -0.04413871f, -0.04230704f, -0.00288753f, 0.03850587f, -0.01527283f, -0.03708549f, -0.06671301f, -0.03852156f, 
    -0.00706101f, -0.02516704f, -0.12011489f, -0.08621906f, -0.04231082f, 0.10087104f, 0.10751410f, -0.00921642f, 
    -0.15917647f, -0.09738223f, 0.03052523f, 0.01105301f, 0.01433608f, -0.04677812f, 0.04754979f, 0.01916062f, 
    0.05730245f, 0.05947877f, 0.01768913f, -0.06701989f, 0.04597925f, -0.11614110f, 0.07486856f, -0.02549637f, 
    0.00342152f, 0.13227898f, -0.03306440f, 0.00295299f, 0.02635860f, 0.04224737f, 0.03186154f, -0.04663865f, 
    -0.02425802f, -0.00355904f, 0.05260836f, 0.05314574f, -0.02524634f, 0.03264797f, -0.02419646f, -0.03628954f, 
    -0.02355957f, 0.02475659f, 0.03733267f, -0.02889446f, -0.16996944f, 0.15643522f, 0.04901765f, -0.19910195f, 
    -0.02660551f, -0.03082309f, -0.00831075f, 0.04990840f, 0.05772074f, -0.01414931f, 0.04997981f, -0.03062353f, 
    -0.11175282f, -0.05986249f, 0.04307384f, -0.01275063f, 0.03298184f, 0.06096139f, 0.00139161f, -0.03051890f, 
    0.03983961f, -0.11533736f, -0.04109902f, 0.09128711f, 0.15745398f, 0.08760783f, 0.05103432f, -0.01547083f, 
    -0.01604184f, 0.00431459f, -0.05554052f, -0.01816243f, -0.03505266f, 0.04234603f, -0.02090774f, -0.05306249f, 
    -0.01427028f, 0.01536281f, 0.05314544f, -0.04763162f, 0.09916649f, 0.08272883f, 0.01180285f, 0.03178475f, 
    0.12878111f, 0.03242747f, -0.05023808f, -0.07794175f, -0.00806338f, 0.00368169f, -0.00214856f, -0.03048267f, 
    -0.00174060f, 0.02157018f, -0.04543921f, -0.00085947f, -0.01917858f, 0.03155465f, -0.01060016f, 0.01704155f, 
    -0.13112204f, 0.10912576f, -0.17048535f, -0.02293630f, -0.14729303f, 0.00489175f, 0.03632325f, -0.04932195f, 
    0.00610912f, -0.04804059f, 0.11544241f, 0.02295940f, -0.00285220f, -0.00232462f, 0.00727736f, -0.00258708f, 
    -0.00164578f, -0.00193911f, 0.06561612f, 0.00033439f, 0.08510686f, 0.13330138f, -0.05097191f, 0.06467965f, 
    0.14180064f, -0.01698100f, -0.03876790f, -0.01280813f, -0.04999869f, 0.02106219f, -0.06393228f, 0.02135729f, 
    0.00191996f, 0.03640851f, 0.00685956f, 0.08232480f, -0.00815719f, 0.01843205f, -0.00428155f, 0.00771838f, 
    0.06669299f, 0.13124092f, 0.00223889f, 0.08962474f, 0.09909327f, -0.05883748f, -0.09821524f, -0.08702180f, 
    0.01249729f, -0.04278407f, 0.04491406f, 0.01809453f, -0.02639408f, -0.09159165f, 0.04888109f, -0.02751972f, 
    0.01564892f, -0.01497338f, 0.07146312f, 0.04645846f, -0.03069500f, -0.01855262f, -0.02725021f, 0.10789669f, 
    0.00302099f, -0.00371008f, -0.06404957f, -0.15474069f, -0.05637098f, 0.10538702f, -0.00197718f, -0.07301116f, 
    -0.01303376f, -0.03347268f, -0.02925290f, 0.03313255f, -0.01867689f, -0.05267866f, 0.07695444f, 0.00659594f, 
    -0.05971119f, 0.07285234f, 0.00156591f, -0.03877714f, -0.00110769f, 0.08960690f, -0.00498595f, -0.04753918f, 
    -0.04819138f, -0.04727594f, 0.05333824f, -0.02909360f, 0.01932756f, -0.01595090f, -0.11629366f, -0.07459132f, 
    0.09183757f, 0.05339413f, -0.08241002f, -0.02778451f, -0.18137172f, -0.03539990f, -0.17602353f, -0.13271053f, 
    -0.04155914f, 0.05163337f, -0.03865058f, -0.08078444f, 0.02676412f, 0.01225473f, 0.05474923f, -0.01486002f, 
    0.06213380f, -0.05856413f, 0.03569787f, -0.01064080f, 0.01397406f, -0.03997273f, -0.02294236f, -0.00645533f, 
    -0.08392502f, -0.02028154f, -0.04212122f, 0.03736670f, 0.09665561f, 0.06488858f, 0.05812096f, -0.07534876f, 
    0.02111806f, -0.01444533f, 0.06519928f, 0.04144103f, 0.02256061f, -0.02015915f, 0.07728793f, -0.06519354f, 
    0.05422598f, 0.00938821f, 0.05060769f, -0.05590227f, 0.11390053f, 0.05029795f, 0.03803826f, 0.03929084f, 
    0.12841302f, -0.00920398f, -0.02766559f, -0.07436772f, -0.00113572f, 0.05606516f, -0.04900217f, 0.00976426f, 
    -0.04678808f, -0.04814956f, 0.01124487f, 0.00702466f, -0.02259818f, 0.03204829f, 0.04972186f, 0.05885502f, 
    0.03713193f, 0.12055538f, -0.11623674f, 0.04512408f, 0.03690815f, 0.07401735f, -0.04137027f, 0.00704624f, 
    -0.07841470f, 0.03098563f, 0.07709181f, -0.01233367f, -0.01903456f, -0.03792791f, 0.08884575f, 0.01063697f, 
    -0.00709673f, -0.00058702f, 0.04036338f, 0.02024711f, -0.13261345f, 0.06302166f, -0.15214343f, -0.14738949f, 
    -0.15630609f, 0.04421535f, -0.02731844f, -0.07445376f, 0.07719520f, -0.03717547f, 0.02527537f, 0.01910981f, 
    0.03637753f, -0.00888867f, 0.00020433f, 0.02352471f, 0.01132259f, -0.10823548f, 0.01290627f, 0.03330983f, 
    0.13861212f, 0.05176576f, -0.18543775f, 0.11435525f, 0.09245402f, 0.07360583f, 0.01378236f, -0.04693656f, 
    -0.06640653f, -0.04121314f, -0.03015816f, -0.01756543f, -0.05662034f, 0.04988530f, 0.01391603f, -0.04196987f, 
    -0.03907680f, -0.02035699f, 0.06087243f, -0.06389739f, 0.05618514f, 0.06956407f, -0.03721973f, -0.04749140f, 
    -0.01193162f, 0.07455765f, -0.02301643f, -0.04659251f, 0.02058070f, -0.00175410f, 0.09776660f, 0.01789683f, 
    -0.01580559f, 0.03370602f, 0.01992874f, 0.07105932f, 0.03748005f, -0.01833808f, -0.04254007f, 0.04441257f, 
    -0.08220135f, -0.03978822f, 0.04283641f, -0.11043630f, -0.04061545f, 0.05505166f, -0.08543491f, 0.00770822f, 
    0.01591078f, -0.22443938f, -0.02135952f, 0.00770929f, 0.02222445f, 0.03422744f, -0.02748738f, 0.03748212f, 
    0.05284377f, 0.03715478f, -0.20338210f, -0.00434556f, -0.00796127f, 0.07875708f, 0.01140026f, 0.02662421f, 
    -0.02237271f, -0.07963705f, 0.03711210f, -0.02242897f, -0.01677241f, -0.01750587f, 0.07192463f, -0.02066971f, 
    0.00934176f, -0.05519842f, -0.01629412f, -0.04174129f, -0.01425724f, -0.02732043f, 0.07323352f, -0.02857424f, 
    -0.17725828f, 0.11879025f, 0.02067580f, -0.13613181f, -0.07778894f, 0.01715282f, 0.02647635f, 0.01279575f, 
    0.04800414f, -0.01438073f, -0.04277073f, 0.02728730f, 0.07256968f, 0.01725341f, -0.01262556f, 0.00683975f, 
    -0.10079000f, 0.00981785f, -0.07303278f, -0.07009930f, 0.13692857f, 0.08745173f, 0.00852844f, -0.04694417f, 
    0.05304548f, -0.05168811f, 0.06057205f, -0.02863188f, -0.02975635f, -0.05879106f, 0.04684243f, -0.02413237f, 
    0.03159050f, -0.09035535f, -0.05808022f, -0.08084309f, -0.00180054f, 0.01645261f, 0.10267361f, -0.04343444f, 
    -0.09605335f, -0.11145352f, 0.03988884f, -0.17154248f, -0.00462334f, 0.03819908f, 0.07223593f, -0.01702585f, 
    0.01031871f, 0.01481208f, -0.03251360f, -0.03870345f, -0.05187035f, 0.03648194f, -0.00353660f, -0.08761896f, 
    -0.03576843f, 0.09864736f, -0.18082991f, 0.01508178f, -0.08557818f, 0.09729556f, -0.03471602f, -0.09984258f, 
    -0.10273702f, 0.01842652f, 0.01395209f, -0.10417350f, 0.06639576f, 0.02497569f, 0.01859576f, 0.01869383f, 
    0.06602835f, -0.01322153f, -0.01348494f, -0.00773440f, -0.01786316f, -0.05890056f, 0.03087034f, -0.02693259f, 
    -0.04415667f, 0.03795252f, 0.07514269f, -0.04555441f, 0.04959024f, -0.02048812f, -0.01918603f, -0.05992021f, 
    -0.03064847f, -0.06533297f, 0.01133307f, 0.02046022f, 0.03033802f, -0.01880977f, -0.02095211f, -0.05442021f, 
    0.01986503f, 0.08451663f, -0.07979682f, -0.02204728f, 0.18644133f, 0.10549540f, -0.00843177f, 0.03455134f, 
    0.11123090f, 0.00375542f, -0.01775898f, -0.06893761f, -0.01298730f, -0.04614016f, -0.04332278f, 0.03153401f, 
    -0.00061215f, -0.08419791f, 0.04490510f, -0.04448077f, -0.01240777f, 0.07105419f, 0.03243706f, -0.01045722f, 
    0.07462557f, 0.09282652f, -0.06463394f, 0.05146239f, 0.01525627f, 0.00765177f, 0.05624439f, -0.03625821f, 
    -0.00730687f, -0.01560999f, 0.00487038f, -0.00357241f, -0.01181182f, 0.00549971f, 0.04438495f, 0.02830781f, 
    0.03531632f, 0.01958491f, 0.07388145f, -0.01317414f, 0.13169648f, 0.02656885f, -0.07228738f, 0.08883609f, 
    0.11352040f, -0.12973776f, -0.08965757f, -0.11486655f, -0.05278467f, -0.00921070f, -0.02189498f, -0.09064958f, 
    -0.10502380f, 0.01927863f, 0.07351701f, 0.07404679f, -0.02486457f, -0.01172627f, 0.01794676f, 0.00172526f, 
    0.10981251f, -0.01006366f, 0.02089972f, 0.08664239f, 0.14127031f, -0.04381500f, -0.06636643f, 0.00539648f, 
    -0.04985564f, 0.02751665f, -0.06913275f, -0.01172739f, -0.04436702f, 0.00811836f, 0.04888916f, 0.01045735f, 
    0.00803600f, 0.00390371f, 0.05672968f, 0.01141726f, -0.10923231f, 0.07065362f, 0.13815743f, -0.06727124f, 
    -0.10841563f, -0.00236876f, 0.02473091f, -0.01645631f, -0.01768972f, -0.00818325f, 0.00979890f, 0.03617896f, 
    0.02226360f, 0.03861083f, -0.01571417f, -0.02413502f, 0.03895101f, -0.03334972f, -0.10130841f, 0.03617366f, 
    -0.14606285f, 0.19480261f, -0.01049089f, -0.12590544f, -0.13734834f, 0.00580572f, 0.01834064f, -0.05890658f, 
    0.02297787f, -0.05840999f, 0.02843361f, -0.00143520f, 0.00672897f, 0.07008662f, 0.01458920f, -0.03053044f, 
    0.03725124f, -0.14016603f, -0.02471192f, 0.11442560f, -0.07142443f, -0.02860735f, -0.11432640f, -0.27204284f, 
    -0.09782214f, -0.01258022f, -0.02725376f, -0.04247190f, 0.03902585f, -0.03749106f, 0.05489070f, 0.00320743f, 
    -0.03575192f, 0.03780666f, 0.00687581f, 0.04000192f, 0.02143355f, -0.07920862f, -0.08102669f, 0.01262251f, 
    -0.11949527f, 0.10500406f, 0.00647607f, -0.06138679f, -0.14814502f, -0.03225189f, 0.00712595f, -0.00354586f, 
    -0.01357139f, -0.11504693f, 0.01623180f, -0.04055674f, -0.00209712f, 0.08431569f, 0.02716316f, 0.00624213f, 
    -0.00238043f, -0.07013351f, -0.10033540f, 0.04729424f, -0.12794650f, -0.05975919f, 0.12002630f, 0.08652947f, 
    0.10987116f, -0.03664792f, -0.04651469f, 0.03720593f, -0.05315860f, -0.03127641f, 0.03792017f, -0.00113196f, 
    -0.09581365f, -0.02736134f, 0.09533650f, 0.01783583f, 0.01028977f, 0.00507412f, 0.04510331f, 0.01379043f, 
    0.01220296f, 0.06599238f, -0.11273959f, -0.00529094f, 0.11548721f, 0.10939929f, 0.05143265f, -0.03690635f, 
    -0.02266775f, 0.02632572f, 0.05196527f, 0.06791753f, -0.02970229f, 0.10318208f, -0.02326110f, -0.06114758f, 
    0.04638189f, 0.07383709f, 0.04993205f, 0.01687754f, 0.02440976f, -0.11325134f, -0.10181983f, -0.05430586f, 
    -0.07346963f, 0.02664360f, 0.10135956f, -0.00110261f, -0.16227798f, 0.01540549f, -0.01597170f, 0.02992800f, 
    0.07234307f, 0.04899693f, 0.03855262f, 0.02150464f, -0.03035435f, -0.08803983f, -0.00407664f, 0.06617717f, 
    0.07092919f, 0.07455187f, -0.13656855f, -0.00001146f, 0.00185658f, 0.11733370f, 0.06107133f, -0.07902732f, 
    0.01999803f, -0.00781950f, 0.02214595f, -0.00257319f, -0.02095418f, 0.07883971f, -0.00198303f, 0.00915563f, 
    0.03728788f, 0.01940754f, 0.07273734f, -0.04931581f, -0.16871598f, -0.15815262f, 0.20229967f, 0.06360462f, 
    0.11628894f, -0.09417689f, -0.01621456f, 0.05764097f, -0.08972377f, 0.01822692f, 0.03061941f, -0.03422204f, 
    0.02630383f, -0.12913439f, 0.02310123f, -0.04546488f, 0.00654866f, -0.01267488f, 0.00223910f, 0.04517745f, 
    0.03654970f, 0.06999546f, -0.03723827f, 0.13221306f, 0.07935090f, 0.06694183f, 0.03357752f, -0.07004713f, 
    -0.03731011f, -0.07033712f, 0.03659472f, 0.02037784f, -0.01608764f, 0.04076129f, -0.00506062f, -0.13847472f, 
    -0.03768165f, 0.03566162f, 0.04875801f, -0.10178228f, -0.01868784f, -0.05683499f, -0.04721966f, 0.03706194f, 
    0.09054074f, 0.06043684f, 0.01494836f, -0.06192565f, -0.01338135f, 0.01994836f, 0.05270687f, 0.02021664f, 
    0.03992701f, -0.03259849f, 0.05284129f, -0.07907266f, 0.02754232f, -0.00239976f, 0.06011923f, -0.00593867f, 
    -0.01241609f, -0.03865407f, 0.09455469f, 0.07528696f, 0.03458881f, -0.12842143f, -0.00681714f, 0.01824440f, 
    0.01061609f, -0.01808143f, -0.01775617f, -0.00475861f, -0.03374217f, 0.03020498f, 0.05346435f, 0.04415262f, 
    0.00760721f, 0.01508122f, 0.02756909f, 0.00386957f, -0.10659770f, -0.02017632f, 0.03846394f, -0.10762873f, 
    -0.09187929f, -0.08709811f, -0.00819907f, -0.02107257f, 0.03033455f, -0.03842070f, 0.02578628f, 0.04394080f, 
    0.02309391f, 0.02255777f, 0.01641307f, 0.00800090f, -0.01188607f, -0.10203519f, -0.09721804f, 0.06554577f, 
    -0.07235325f, -0.08095212f, -0.04517053f, -0.33743113f, -0.17157741f, 0.05071957f, 0.05274830f, -0.01756262f, 
    -0.06269580f, -0.01198145f, 0.04482855f, 0.04074625f, -0.01399752f, 0.00307414f, -0.04238939f, -0.12178394f, 
    0.01418004f, 0.06825866f, -0.24353167f, -0.12916100f, -0.11424869f, -0.01604770f, 0.13048309f, -0.05255029f, 
    -0.07545969f, -0.00004362f, -0.03717959f, 0.05984106f, -0.04767063f, 0.03278992f, 0.02729287f, 0.00492163f, 
    -0.01266175f, -0.04954233f, -0.02706670f, -0.01566730f, 0.00151247f, -0.04078395f, -0.05953258f, -0.02064080f, 
    0.06635405f, 0.03986297f, -0.13604257f, 0.10253626f, 0.04028536f, 0.02142966f, 0.02477161f, -0.10747072f, 
    -0.05693340f, 0.02303576f, 0.08148562f, 0.04990887f, 0.01040318f, -0.01138238f, -0.00912432f, -0.06171170f, 
    -0.01328823f, 0.00187896f, 0.09758448f, 0.05130007f, -0.18894996f, -0.15074399f, -0.09568179f, -0.00561795f, 
    0.11855067f, 0.04348326f, 0.07544871f, -0.05413839f, -0.10600664f, -0.04307361f, 0.00275167f, -0.01469302f, 
    0.11499161f, -0.02786899f, 0.02967182f, -0.00448035f, 0.09228417f, 0.06464938f, 0.00398950f, -0.09128066f, 
    -0.33810073f, -0.54757655f, -0.11032910f, 0.08091112f, -0.21142851f, -0.08190458f, -0.01376012f, -0.00516737f, 
    0.02446171f, -0.03569776f, -0.12618372f, -0.06215333f, 0.05107456f, 0.03071516f, 0.06904167f, 0.00919918f, 
    0.06897333f, -0.01537816f, 0.02765201f, -0.03950236f, 0.10186720f, -0.18813798f, -0.07147688f, 0.09524260f, 
    0.07526018f, -0.07686746f, -0.02252663f, 0.06083440f, 0.03384823f, -0.03026889f, 0.00080186f, -0.08579289f, 
    -0.06176742f, -0.08844187f, -0.02366860f, 0.06834958f, -0.06753186f, 0.07231169f, -0.00843978f, 0.05455533f, 
    0.33902791f, 0.21175785f, -0.03006954f, 0.05123194f, -0.08300152f, -0.14093554f, -0.05717807f, -0.04242139f, 
    0.00758453f, -0.05592561f, -0.02931589f, -0.08109057f, 0.11222371f, 0.08837966f, 0.12090635f, 0.06618624f, 
    0.00225858f, 0.13926996f, -0.08947145f, 0.13031664f, 0.12320478f, -0.13666797f, 0.03518507f, 0.09946132f, 
    -0.00458754f, -0.11499909f, -0.01359241f, -0.02051225f, 0.01127049f, -0.00389050f, -0.02236381f, -0.01053149f, 
    0.03048553f, -0.01545095f, 0.11762614f, -0.03914102f, -0.02029597f, 0.00732418f, 0.03974466f, -0.00639600f, 
    -0.09378858f, 0.23629870f, -0.04000518f, 0.14263675f, -0.14714095f, 0.04451419f, 0.01365846f, -0.03299893f, 
    -0.02228127f, -0.00422424f, -0.09534668f, -0.05026923f, 0.07626078f, -0.03104077f, 0.17077586f, 0.05483878f, 
    -0.00130387f, -0.02181842f, -0.08274363f, 0.00802745f, 0.04659585f, -0.03193446f, -0.09826736f, 0.03484805f, 
    0.18020546f, 0.06636663f, -0.05206665f, 0.04913672f, -0.00920497f, 0.09511250f, -0.05009438f, 0.03672867f, 
    -0.00261939f, -0.01497430f, -0.00471520f, 0.06312858f, 0.01557156f, 0.05409494f, -0.01719596f, -0.07655404f, 
    0.36563736f, -0.48713750f, -0.04085978f, -0.08723888f, -0.02778872f, -0.10103715f, 0.00584486f, -0.08397085f, 
    0.15568952f, -0.03563334f, -0.05789872f, -0.06900416f, 0.11141316f, -0.10295375f, -0.00434508f, 0.13309625f, 
    0.04340551f, -0.00704538f, 0.02376801f, 0.06326403f, 0.30012867f, 0.03470240f, -0.20303686f, 0.16260794f, 
    -0.10584840f, 0.00264718f, -0.02350414f, 0.13436621f, 0.03757430f, -0.11573774f, 0.12991859f, -0.04966621f, 
    0.03083597f, -0.06480480f, 0.04843101f, 0.08718549f, -0.02028526f, 0.01766741f, -0.03938558f, 0.12142205f, 
    0.17473441f, 0.01503714f, -0.09764173f, 0.05291872f, 0.03351989f, 0.17164171f, -0.01625514f, 0.00525496f, 
    -0.01010508f, 0.25381202f, -0.08303277f, -0.04362065f, -0.01792473f, 0.07750930f, -0.05322551f, -0.02681938f, 
    -0.11461239f, 0.00228679f, -0.08366391f, -0.08459143f, -0.10400797f, -0.02564354f, 0.08624914f, -0.20914057f, 
    0.10239692f, 0.01257125f, -0.01507093f, -0.07522377f, 0.05505751f, 0.01778502f, -0.03617817f, 0.06194499f, 
    0.03208805f, 0.02009546f, 0.01228091f, 0.05818293f, 0.06335131f, -0.02041497f, 0.06056423f, 0.03852057f, 
    -0.17227128f, 0.09696302f, 0.08024968f, -0.14239328f, 0.02991458f, 0.00918452f, 0.03597028f, 0.01043524f, 
    0.01422943f, -0.05737793f, 0.04315705f, 0.04970583f, -0.03057442f, -0.01264493f, -0.01031808f, 0.08356363f, 
    -0.01109725f, 0.15673012f, -0.01665608f, 0.05972608f, -0.07706480f, -0.06687630f, 0.08484548f, -0.17818470f, 
    -0.07112600f, -0.08959425f, 0.03298932f, -0.02157967f, -0.03823468f, 0.00342037f, 0.08402535f, -0.07967529f, 
    0.04514370f, -0.03245127f, 0.05476001f, 0.05048309f, -0.06634934f, 0.02927709f, -0.08714527f, -0.05793304f, 
    -0.13919593f, -0.07728462f, 0.10779041f, -0.17938752f, -0.13441239f, -0.04230310f, 0.05470926f, -0.02165306f, 
    -0.02060876f, -0.02363650f, 0.04005394f, 0.01850839f, 0.03312611f, -0.01494968f, -0.10361856f, -0.01834602f, 
    -0.07581505f, 0.07864959f, 0.04582085f, 0.04226782f, -0.25114006f, 0.35578740f, -0.19478931f, 0.10258441f, 
    -0.14339992f, 0.12128707f, 0.02777401f, 0.03527341f, 0.07351070f, 0.10404312f, -0.14699936f, -0.02909207f, 
    0.00485417f, -0.08965508f, 0.11485441f, 0.13993186f, 0.02215061f, 0.02510144f, -0.12184008f, -0.02499123f, 
    0.06764838f, -0.19601814f, 0.17916767f, -0.00988093f, -0.03777051f, 0.06723996f, 0.02504351f, -0.03680952f, 
    -0.04298868f, 0.01031938f, 0.07775040f, 0.00559325f, 0.05707026f, -0.01452179f, 0.07052486f, -0.04316229f, 
    0.01687500f, -0.04660843f, 0.00881633f, 0.02636712f, 0.30344906f, 0.10728940f, -0.10356180f, -0.37113467f, 
    -0.00208068f, 0.03899772f, -0.06068858f, -0.05691394f, 0.04176097f, 0.04446107f, 0.01897251f, -0.05467342f, 
    0.01975965f, 0.00561029f, -0.05115946f, -0.01088281f, 0.05365198f, -0.11536169f, -0.09694673f, 0.02073039f, 
    -0.06584244f, -0.07200171f, 0.17043531f, -0.21930592f, 0.22948804f, 0.03135907f, -0.10581009f, -0.07890812f, 
    0.16606741f, 0.05281948f, 0.00961922f, -0.03685769f, -0.05968546f, -0.00236070f, 0.00482998f, 0.01249864f, 
    0.09690805f, -0.04436853f, -0.10174944f, 0.01124576f, -0.41007170f, -0.01914958f, 0.10557947f, 0.04402386f, 
    0.16675489f, 0.00580825f, -0.01166091f, 0.01026518f, -0.01174509f, 0.00314541f, -0.03325758f, -0.00496204f, 
    -0.02352752f, -0.04304511f, -0.14133132f, 0.10052139f, -0.09390489f, 0.04279166f, 0.00129557f, 0.10672194f, 
    0.28961653f, -0.00864656f, -0.21753883f, -0.40610316f, -0.03910863f, -0.04014361f, -0.06967948f, 0.03023120f, 
    0.05860659f, 0.01059327f, -0.09006182f, -0.00882339f, 0.03240202f, 0.02766228f, -0.07530567f, 0.01450474f, 
    0.09326760f, -0.01046816f, -0.07209338f, 0.01210989f, -0.02339409f, 0.26156104f, 0.06425126f, 0.08711877f, 
    0.00295508f, 0.01254611f, -0.01446133f, -0.02635919f, 0.03050632f, 0.01056059f, -0.06752808f, -0.00197552f, 
    -0.01518401f, 0.04989498f, 0.03823416f, 0.01569763f, -0.04514988f, 0.01256647f, -0.10185649f, 0.02712932f, 
    0.24924713f, 0.05729919f, -0.00837960f, 0.03863226f, -0.15186250f, -0.04804873f, -0.01876957f, 0.06109646f, 
    0.09155226f, -0.06083699f, 0.00381795f, -0.02082280f, -0.03597011f, -0.11502577f, 0.02463409f, 0.01910838f, 
    0.03860703f, 0.00158960f, -0.00209142f, 0.04408809f, -0.07998951f, 0.07879967f, -0.19283263f, 0.18984787f, 
    -0.06721726f, -0.08090506f, 0.06700360f, -0.04598425f, 0.04561611f, 0.04787759f, -0.07295161f, 0.08145915f, 
    0.03247052f, -0.01452904f, 0.04328098f, 0.06538869f, -0.03442355f, 0.02444034f, 0.01847123f, 0.00193108f, 
    0.08090292f, -0.17715266f, 0.16357282f, -0.06420012f, -0.15188262f, 0.07757743f, 0.10676091f, -0.03288048f, 
    -0.05095569f, -0.03903494f, -0.04021113f, 0.03517117f, -0.03771435f, -0.02063777f, 0.03647283f, -0.06865726f, 
    0.02726750f, 0.01158812f, 0.04013570f, -0.01161740f, 0.08595252f, -0.13271593f, 0.03539646f, -0.06944480f, 
    -0.19166577f, 0.01728640f, 0.11196883f, -0.02578150f, -0.02635004f, -0.11705990f, 0.03730509f, -0.00318573f, 
    0.01246679f, 0.06443368f, -0.07116329f, -0.03860310f, 0.01994458f, -0.06129946f, -0.04508383f, -0.10213132f, 
    -0.38266861f, 0.04619721f, 0.11167584f, 0.11832780f, -0.08461979f, 0.05536156f, 0.06072357f, -0.01401696f, 
    0.00182375f, -0.03699139f, 0.00455089f, -0.03441297f, 0.02808912f, 0.06306890f, 0.00932199f, 0.05924277f, 
    0.04364767f, -0.01157090f, -0.03900163f, -0.08501510f, 0.25061768f, -0.18843746f, 0.03286950f, -0.08453754f, 
    -0.09752285f, 0.08022535f, -0.02046682f, -0.05893194f, 0.04931026f, -0.06119285f, -0.03809636f, 0.07578260f, 
    0.02515231f, -0.12635195f, -0.01012916f, 0.00150483f, 0.00967260f, -0.01419419f, -0.09427987f, 0.00064617f, 
    -0.07222890f, -0.32229790f, -0.05737605f, -0.06098693f, 0.09534458f, 0.04275252f, 0.02459090f, -0.12709005f, 
    -0.07088897f, -0.05177763f, -0.04173885f, 0.01779449f, 0.03233755f, 0.06999660f, 0.02352304f, -0.05799280f, 
    0.08757821f, -0.18847299f, -0.05059171f, -0.00646041f, 0.45001587f, -0.39512920f, 0.05292331f, 0.10155475f, 
    0.14679204f, -0.02717615f, -0.01223017f, 0.03379275f, 0.05721451f, -0.02545692f, 0.02990114f, 0.00902103f, 
    0.00377727f, 0.07039447f, -0.05733053f, -0.01675097f, -0.06751980f, 0.05630254f, -0.11964067f, 0.01357514f, 
    0.39014867f, -0.20244142f, -0.18136369f, -0.14054610f, -0.24308830f, -0.01313906f, 0.01569059f, 0.13980103f, 
    0.02427522f, -0.09795199f, -0.03518167f, -0.06828330f, -0.01294931f, 0.12130278f, -0.02713064f, 0.00801978f, 
    0.14063355f, -0.05076558f, 0.06249055f, 0.12714121f, -0.03799470f, -0.10091469f, 0.05199894f, -0.05172250f, 
    -0.01686735f, -0.06327483f, 0.05702431f, -0.01026326f, 0.03343063f, -0.05416678f, 0.00091125f, -0.04717217f, 
    -0.04723509f, 0.00305241f, -0.02546394f, 0.04832572f, 0.04729575f, 0.00162112f, -0.00611181f, 0.06435454f, 
    -0.05357093f, -0.02025394f, 0.08373388f, -0.13657156f, -0.14429104f, -0.02064552f, 0.05539348f, -0.10132664f, 
    -0.05495928f, 0.03566610f, -0.00277877f, -0.07733194f, -0.01469056f, -0.06187202f, 0.00421048f, 0.02638880f, 
    0.01988383f, -0.00124244f, -0.03984101f, -0.01557322f, 0.32933939f, -0.27736992f, 0.11580288f, -0.07701299f, 
    0.03719171f, 0.04487295f, 0.02313326f, -0.03684444f, -0.04574951f, -0.09782108f, 0.07476176f, -0.01508638f, 
    0.03324755f, 0.07063714f, 0.02714486f, -0.01039414f, 0.01883404f, -0.13071804f, -0.02379864f, 0.03387700f, 
    -0.08818883f, 0.02652778f, -0.21382874f, 0.20363246f, -0.17802481f, 0.06804461f, 0.03820344f, -0.03337888f, 
    -0.03033336f, 0.09413369f, -0.04655605f, 0.05093843f, 0.07881822f, 0.08810145f, 0.06722143f, -0.01970837f, 
    -0.13610475f, -0.06533668f, -0.01007047f, -0.03322190f, -0.19932212f, 0.05470154f, 0.15287162f, -0.12720248f, 
    -0.07849287f, -0.02442050f, 0.01642074f, 0.02772673f, -0.02457500f, 0.01087837f, 0.03448752f, -0.01954599f, 
    0.01863671f, -0.02215903f, -0.05191040f, 0.01290924f, 0.03355394f, 0.05659347f, 0.05299749f, -0.05656346f, 
    -0.18118076f, 0.09073242f, 0.07575146f, 0.04323177f, -0.07758220f, 0.07403633f, 0.06018890f, -0.04438232f, 
    -0.06051585f, -0.05443738f, 0.00566285f, 0.01444351f, -0.00298057f, 0.01041028f, 0.00524678f, 0.07346336f, 
    -0.09920076f, 0.11800338f, -0.04910597f, 0.05175764f, 0.19324622f, -0.45733035f, 0.03844994f, -0.02432028f, 
    -0.20254366f, -0.03432402f, 0.02848872f, -0.01452773f, 0.00798983f, -0.04007168f, -0.01616510f, -0.02076851f, 
    0.14775862f, -0.05120307f, -0.01263302f, 0.01069954f, 0.00194933f, 0.05636209f, 0.01698978f, 0.00702519f, 
    0.11239503f, 0.06915436f, -0.07267249f, -0.01476787f, -0.06484545f, -0.17954272f, -0.02571745f, 0.06568199f, 
    0.04150023f, 0.10083149f, -0.03081233f, 0.06659005f, 0.03514040f, 0.02480938f, -0.02039854f, 0.07916728f, 
    -0.00549615f, -0.15754247f, 0.11967386f, 0.05755690f, -0.29332963f, 0.15779150f, 0.19114032f, -0.00448259f, 
    0.07683586f, 0.03713658f, 0.00866607f, 0.04394013f, 0.03478213f, -0.01184180f, 0.04674785f, 0.01491230f, 
    0.08766843f, 0.05203485f, 0.05810662f, 0.05487496f, -0.04403082f, 0.03809981f, -0.12641105f, 0.06202405f, 
    0.09855106f, -0.30919462f, 0.18497667f, 0.05860912f, -0.11369746f, -0.19201960f, -0.03812347f, -0.06182871f, 
    0.19383942f, -0.09117942f, -0.08447471f, 0.07079390f, -0.03007371f, -0.00992809f, -0.09653236f, 0.00538429f, 
    0.13553558f, 0.05683091f, 0.09760689f, -0.05876486f, -0.28478077f, 0.12194302f, 0.16817012f, -0.09667361f, 
    0.05211818f, 0.04678480f, 0.03148183f, 0.12721780f, 0.03450634f, 0.03607110f, 0.00050149f, 0.06392461f, 
    -0.04597456f, 0.05639446f, -0.02021510f, 0.00516874f, -0.06359158f, 0.07224180f, -0.24444345f, 0.06135961f, 
    0.17393726f, 0.05933030f, -0.05250775f, 0.06877315f, -0.06738472f, -0.05326804f, -0.02816156f, 0.05064656f, 
    0.06718933f, 0.04034478f, 0.04261990f, 0.04355408f, 0.09966238f, -0.00175071f, -0.01722792f, 0.09470196f, 
    0.02314222f, 0.11144890f, 0.04997804f, 0.09059425f, 0.05629651f, -0.34516615f, 0.10964862f, -0.02339502f, 
    -0.05392949f, -0.06360095f, 0.01238765f, 0.03350813f, 0.11171827f, -0.03580884f, -0.07273504f, -0.04917472f, 
    0.08677560f, -0.02725674f, -0.00011087f, 0.00430532f, 0.07812228f, 0.12746903f, 0.11324029f, -0.06726727f, 
    0.28363335f, 0.02094508f, -0.05908104f, -0.13082820f, 0.00782731f, 0.00714786f, 0.02378676f, -0.03605657f, 
    0.00636792f, -0.07183670f, -0.00983241f, -0.00797615f, -0.01744455f, 0.05338772f, -0.02638931f, 0.08867515f, 
    0.04444876f, 0.01420572f, 0.03499203f, 0.00334286f, -0.08075944f, -0.15185659f, 0.05522845f, 0.00075882f, 
    -0.01328642f, 0.12420456f, 0.14069471f, -0.04825603f, -0.07901524f, -0.18215771f, 0.02006326f, 0.00971713f, 
    0.00003536f, 0.07289258f, -0.03746642f, -0.01427495f, -0.01850558f, -0.09144933f, -0.01775284f, -0.03350664f, 
    -0.04334706f, 0.18016940f, 0.19413573f, -0.17720635f, 0.02034627f, 0.06690179f, 0.03861036f, 0.03165231f, 
    -0.03931079f, -0.08962795f, 0.02585815f, 0.05178986f, 0.08287451f, -0.01781499f, 0.04565880f, -0.04033770f, 
    0.01782003f, 0.01089839f, -0.05534394f, -0.01441108f, -0.24756670f, -0.00383646f, 0.06132790f, 0.16110751f, 
    0.07131443f, 0.11883381f, 0.07347374f, -0.10902396f, -0.01571369f, 0.01564777f, -0.05491891f, -0.06912816f, 
    0.03760675f, -0.00641666f, 0.01858460f, -0.00024072f, 0.00367195f, -0.02319629f, -0.05637739f, 0.11463339f, 
    0.00064854f, -0.01875917f, -0.10132034f, 0.01714773f, 0.00224221f, 0.05388245f, 0.03058649f, -0.00559294f, 
    -0.00727957f, 0.04794576f, 0.01125050f, -0.03378015f, 0.04263473f, -0.01612311f, -0.00668324f, -0.05423983f, 
    0.00097486f, -0.06110804f, -0.00459584f, 0.01577169f, -0.08685554f, -0.09470207f, -0.00128992f, 0.12058223f, 
    -0.00226997f, -0.02005964f, 0.05016616f, 0.07877903f, -0.07383953f, -0.06497987f, 0.05568307f, 0.01533318f, 
    -0.04815227f, -0.03527312f, -0.06095482f, 0.00855216f, -0.02740341f, -0.03930897f, 0.08402649f, -0.01881094f, 
    -0.19969289f, -0.08904558f, -0.05729942f, 0.11386609f, -0.07273109f, -0.04986979f, 0.07540274f, 0.00247968f, 
    -0.10676310f, 0.07308159f, 0.05324403f, 0.00248271f, -0.06438327f, 0.06913799f, 0.06633453f, 0.00081593f, 
    0.00675431f, 0.01293385f, 0.03946451f, -0.04532333f, -0.08684867f, 0.03444153f, 0.10336520f, -0.16462648f, 
    -0.13960013f, -0.11215523f, 0.05782972f, -0.02112926f, -0.06326693f, 0.09194764f, 0.02969066f, -0.00025371f, 
    -0.03385375f, -0.01275649f, 0.00658248f, -0.00687457f, 0.02111785f, -0.07064911f, 0.07772224f, 0.02221649f, 
    -0.23280601f, -0.07549569f, -0.15740168f, 0.07850681f, 0.00795822f, -0.04292198f, -0.00165189f, 0.02143836f, 
    -0.01738798f, -0.00088278f, 0.00277615f, -0.01993710f, -0.15364680f, -0.01809572f, 0.01593707f, 0.01189751f, 
    -0.00194661f, 0.01297445f, 0.09152839f, 0.07614622f, 0.10985500f, -0.14015113f, -0.05806398f, 0.09394661f, 
    -0.03072720f, -0.02964174f, 0.03756874f, -0.01753654f, -0.04653876f, 0.10941649f, 0.00849117f, -0.05599342f, 
    0.03196443f, 0.04885193f, 0.07334092f, 0.00548129f, -0.05091804f, -0.00461659f, 0.05089905f, -0.02164828f, 
    0.12713780f, 0.01490768f, 0.07232042f, -0.15763870f, -0.32992363f, 0.07579797f, 0.07700284f, 0.11194222f, 
    -0.05575574f, -0.01585599f, -0.04300713f, -0.02424922f, -0.05516851f, -0.19523998f, -0.00258809f, -0.07389291f, 
    0.02054510f, -0.16376433f, 0.01544846f, -0.03030892f, -0.24258767f, -0.23843491f, 0.14726694f, -0.08008819f, 
    -0.01595436f, -0.01618797f, -0.05139263f, -0.03524370f, -0.01823813f, 0.03860753f, 0.01657761f, 0.03426003f, 
    -0.11414643f, 0.08848785f, 0.02182488f, -0.09410074f, 0.04894337f, 0.03028622f, 0.06207860f, 0.04806514f, 
    0.11033089f, 0.01366602f, 0.21704827f, -0.23534770f, -0.30715537f, 0.04574775f, 0.02224903f, 0.04358266f, 
    -0.04038537f, 0.04981604f, -0.03590790f, -0.09939902f, 0.01338565f, -0.14897105f, -0.03797190f, -0.03279641f, 
    0.01920939f, -0.03982354f, -0.04867836f, -0.09688786f, 0.24043319f, -0.06780817f, -0.07417843f, 0.13839193f, 
    0.01655944f, 0.04475543f, -0.15454862f, -0.05352210f, 0.02801497f, 0.15771760f, -0.05976652f, 0.06108604f, 
    -0.03583319f, 0.00935791f, 0.02610049f, -0.05640454f, -0.07139990f, 0.03832698f, 0.01261480f, -0.02445071f, 
    0.03067281f, -0.00892237f, 0.04147168f, 0.02198012f, -0.05451119f, 0.00364048f, 0.07397878f, 0.03491393f, 
    -0.00596845f, 0.02018150f, 0.01314737f, -0.03466780f, -0.02521963f, -0.12039081f, 0.04781369f, 0.04347893f, 
    -0.06560356f, -0.02119742f, -0.15730283f, 0.02902602f, -0.01066782f, 0.04792986f, 0.00788284f, -0.20014477f, 
    -0.11215953f, -0.00892480f, 0.07630400f, -0.04397567f, -0.00220201f, 0.01921556f, -0.01144478f, -0.02702484f, 
    0.00813167f, -0.05180112f, -0.01710873f, 0.02808633f, 0.02704393f, -0.01516659f, -0.02930384f, 0.00392407f, 
    -0.15100096f, -0.09043056f, -0.09158083f, 0.16500776f, 0.07554103f, 0.03250092f, 0.00555450f, -0.06223260f, 
    -0.04518943f, 0.10296968f, 0.05360030f, 0.03891840f, 0.03995434f, 0.00066094f, -0.08545440f, -0.09240150f, 
    -0.07483734f, -0.00844388f, 0.03436788f, 0.01914594f, -0.13782220f, -0.10005060f, -0.06666513f, 0.09097220f, 
    0.01472898f, -0.01261695f, -0.03558465f, -0.00077473f, -0.01714981f, -0.08837239f, -0.05429402f, 0.07383084f, 
    -0.12743373f, -0.10225966f, -0.06611027f, -0.05600872f, -0.05479442f, 0.07142863f, 0.09678224f, 0.02059002f, 
    0.01939505f, -0.14403872f, 0.04242124f, 0.07846564f, 0.01154717f, -0.17181727f, 0.05495908f, 0.02108725f, 
    -0.05616116f, -0.01191729f, -0.01932932f, 0.00972289f, 0.01858805f, 0.03965956f, 0.02238550f, 0.06818728f, 
    0.07007755f, 0.01376962f, -0.00104967f, 0.03045069f, 0.04938922f, -0.16380738f, 0.01360785f, 0.08300810f, 
    0.04274651f, 0.03374517f, -0.03600143f, -0.02801586f, -0.02426521f, 0.11171506f, -0.02984494f, 0.06336547f, 
    -0.09084781f, 0.02917420f, 0.01880186f, -0.00087362f, -0.08968786f, 0.04219975f, -0.00649031f, 0.03525361f, 
    -0.10002203f, 0.00650655f, -0.01241081f, 0.05997450f, 0.01984615f, 0.05082551f, 0.02150106f, 0.06984427f, 
    -0.04366259f, -0.13810402f, 0.07255439f, 0.03507584f, -0.03421572f, 0.05309743f, -0.02422607f, 0.00130300f, 
    0.01309174f, -0.00942884f, -0.06950004f, 0.02930955f, 0.00791695f, -0.13163894f, -0.03673010f, -0.25843892f, 
    -0.35610759f, -0.03594688f, 0.12626792f, -0.15907873f, 0.04905851f, -0.02102947f, -0.10141510f, 0.00158233f, 
    -0.05562460f, -0.01257758f, -0.06141049f, -0.06633653f, 0.04371120f, 0.10497063f, 0.08328295f, -0.00849033f, 
    -0.23710129f, -0.09124099f, 0.00425922f, -0.02172548f, 0.04364287f, -0.00703570f, 0.00672455f, -0.01504955f, 
    -0.06003246f, -0.02478990f, -0.00108437f, 0.06895865f, -0.06757709f, -0.03922931f, 0.11317191f, -0.03208036f, 
    -0.00710761f, 0.03129283f, -0.00107113f, 0.06185929f, 0.23346695f, 0.14112967f, -0.07792910f, -0.02136168f, 
    0.07270115f, 0.04402273f, 0.00556707f, 0.03476725f, 0.01435087f, 0.01357678f, -0.07076924f, 0.00762281f, 
    0.08043688f, -0.06166862f, -0.02172510f, 0.07419869f, 0.02129230f, -0.03892186f, -0.08520269f, 0.06353959f, 
    -0.04173179f, -0.08643332f, 0.02959977f, -0.14921696f, 0.10290180f, 0.00155709f, -0.02763431f, 0.03872266f, 
    0.01501215f, 0.05776596f, -0.01232234f, 0.12287690f, -0.09041095f, -0.06304287f, -0.02882729f, -0.09618124f, 
    -0.01945639f, -0.21074563f, -0.05068501f, 0.02816177f, 0.09444229f, 0.03758325f, 0.08565727f, -0.02200290f, 
    -0.00981351f, 0.03886714f, 0.01835603f, 0.02893295f, 0.03343371f, 0.03412742f, 0.05836918f, 0.01511841f, 
    -0.00810346f, 0.05215365f, -0.06462938f, -0.01584154f, 0.02536273f, 0.00345641f, -0.09161896f, 0.02913759f, 
    -0.24627092f, -0.21439323f, 0.04340829f, 0.01800144f, 0.04781124f, 0.00098136f, 0.05954027f, 0.03609759f, 
    0.01789463f, -0.01920000f, 0.03130610f, -0.00701284f, 0.00574943f, -0.01169541f, 0.06561542f, -0.05176273f, 
    -0.08857989f, -0.18241264f, -0.00371584f, -0.00894719f, 0.11901849f, 0.14088252f, -0.05504180f, 0.07136302f, 
    -0.03028318f, 0.00644743f, -0.01211373f, 0.02726990f, -0.03440816f, -0.01644622f, 0.02887921f, -0.00636798f, 
    0.04448565f, -0.00960296f, -0.01838258f, 0.00070629f, 0.04424906f, -0.08313833f, -0.00610325f, 0.00972224f, 
    -0.28844073f, 0.06678849f, -0.11998273f, 0.00836808f, 0.13886721f, 0.04271387f, 0.01959000f, -0.05673573f, 
    0.00645050f, 0.04617605f, 0.07910869f, 0.04200668f, 0.02687628f, 0.02536296f, 0.13764614f, 0.05584661f, 
    0.00598700f, 0.12871763f, -0.01377752f, 0.03008802f, -0.22865671f, -0.23339695f, 0.00202943f, -0.00124870f, 
    -0.02085593f, -0.01269632f, -0.05781302f, -0.04881203f, -0.06958390f, -0.06717287f, -0.01970234f, 0.00008202f, 
    -0.00288844f, -0.05687644f, 0.00464628f, -0.13475887f, -0.02954401f, -0.03366629f, 0.04436904f, 0.02417809f, 
    0.18961726f, 0.17067108f, 0.01932872f, 0.10494124f, -0.05964316f, -0.10551551f, -0.11797784f, 0.06378100f, 
    0.05054880f, 0.00781594f, -0.03116992f, -0.05244276f, 0.07407839f, -0.06384800f, -0.09447756f, -0.04296622f, 
    -0.04719505f, 0.02362238f, 0.05719400f, -0.03214502f, -0.19165334f, 0.04650382f, -0.03099738f, -0.04632686f, 
    -0.02292461f, 0.04206366f, 0.00585073f, 0.01104183f, 0.01016262f, 0.11156213f, 0.04482936f, 0.04787507f, 
    0.03220860f, 0.01681068f, -0.02867848f, 0.02173907f, 0.01095273f, 0.03900906f, -0.02954078f, 0.03573665f, 
    -0.25148925f, -0.16492191f, -0.04947844f, 0.00085009f, -0.10546644f, 0.04503714f, 0.03047610f, -0.05790282f, 
    -0.00308730f, -0.00753656f, 0.09547615f, 0.03853050f, -0.00961888f, -0.03934109f, 0.05111286f, 0.01767384f, 
    -0.00313315f, 0.04077327f, 0.04627651f, -0.00840019f, -0.08486264f, 0.02965565f, -0.14615574f, 0.00495333f, 
    0.12252810f, 0.04910617f, -0.01524361f, -0.01263878f, -0.01936082f, 0.07823535f, 0.01586359f, -0.00656296f, 
    0.06001171f, -0.00992307f, 0.01968419f, 0.01523475f, 0.04243516f, 0.01783776f, -0.02518171f, 0.02217224f, 
    -0.12752616f, -0.14304729f, -0.01231411f, 0.05145244f, -0.05788413f, 0.05362336f, 0.04388276f, -0.11658957f, 
    0.02042786f, 0.02610560f, 0.00550221f, 0.02497667f, -0.00416539f, 0.08034803f, 0.04201827f, 0.10237906f, 
    0.03270045f, 0.09990319f, 0.02109064f, -0.04195378f, -0.31934977f, -0.16100901f, -0.00518216f, 0.00237566f, 
    -0.12323566f, 0.00286082f, 0.02893309f, 0.03727306f, -0.01697974f, 0.02135030f, 0.10536641f, -0.01548412f, 
    0.05740423f, -0.05305519f, 0.01801897f, 0.00282076f, -0.04222153f, -0.10049909f, 0.07708757f, 0.00046708f, 
    -0.20004076f, 0.11356004f, -0.07244051f, -0.09356507f, 0.02849707f, 0.05475294f, 0.00554687f, 0.03013222f, 
    0.05130694f, -0.04701599f, -0.02514818f, 0.03672625f, -0.01592062f, 0.00403023f, 0.03594792f, -0.01049859f, 
    0.04011057f, 0.12538365f, -0.06416468f, 0.08919142f, -0.02128388f, 0.14668837f, 0.00537841f, 0.14764662f, 
    -0.02393374f, -0.02367182f, -0.09142698f, 0.02373758f, -0.08788616f, 0.09692532f, 0.01845662f, -0.04805383f, 
    -0.00215438f, -0.03328294f, 0.00028290f, 0.00633126f, -0.09341682f, -0.09932491f, 0.00654932f, -0.02574836f, 
    -0.18588816f, 0.09461923f, -0.16211621f, -0.01254328f, 0.01406117f, 0.04918587f, -0.00465951f, 0.00146679f, 
    -0.03236282f, 0.08798850f, 0.03626760f, 0.02528528f, 0.02024797f, -0.13874868f, -0.01890702f, 0.01667642f, 
    0.02983073f, 0.04623948f, -0.01593414f, 0.12260341f, -0.01917543f, 0.01289376f, -0.16684610f, 0.09564289f, 
    -0.02495820f, 0.00282671f, -0.03894330f, -0.00044103f, 0.02435988f, 0.06015262f, 0.05184733f, -0.00006764f, 
    0.07738785f, -0.01846974f, 0.07273063f, 0.02904758f, 0.00110468f, -0.12838380f, 0.09892347f, 0.01371647f, 
    0.00826815f, 0.17245929f, 0.09761371f, 0.04110668f, -0.24744484f, 0.04239905f, -0.00812931f, 0.00277967f, 
    -0.03173082f, 0.02894243f, -0.00284389f, -0.06510454f, 0.06982160f, -0.02240485f, 0.00837392f, -0.01578855f, 
    -0.00776127f, -0.21155369f, -0.07555510f, -0.02699781f, -0.01622571f, -0.05184714f, 0.06014552f, 0.01030938f, 
    0.09627152f, 0.04190882f, -0.04915752f, 0.09190132f, 0.00553634f, 0.03098561f, 0.03497998f, -0.00866255f, 
    0.01171200f, 0.03060211f, 0.01299569f, 0.01274782f, 0.01825586f, -0.02675503f, 0.12517303f, 0.02798530f, 
    -0.26427060f, -0.13297544f, 0.03403015f, 0.01797123f, 0.03941353f, 0.06222118f, 0.01562129f, 0.00511677f, 
    -0.01241340f, -0.00441034f, 0.00717581f, -0.00056141f, -0.03142681f, 0.02948377f, 0.03292897f, 0.03437582f, 
    0.00794709f, 0.02922472f, 0.07789958f, 0.07164928f, 0.12623313f, -0.14762317f, -0.02658739f, -0.03339403f, 
    0.06709614f, -0.05073332f, 0.06995167f, 0.01677496f, -0.01009407f, -0.12632234f, -0.01071274f, 0.03929838f, 
    -0.02369965f, -0.09823191f, -0.02224126f, -0.12990516f, -0.01217452f, -0.03699193f, -0.08927436f, 0.06214352f, 
    -0.36326739f, -0.15516333f, -0.11091451f, -0.10101693f, -0.22082062f, 0.02281606f, 0.00740971f, -0.04648003f, 
    -0.05149253f, 0.06459379f, -0.02614482f, 0.04008434f, -0.02811221f, 0.05443158f, -0.00165671f, 0.02699404f, 
    0.04728650f, 0.07204051f, -0.01829493f, 0.00962810f, -0.34836027f, -0.06601386f, -0.12243304f, -0.12256087f, 
    -0.03456055f, 0.07168132f, -0.01929918f, -0.07163368f, 0.00307155f, 0.00874449f, 0.00821939f, 0.04964004f, 
    -0.03787266f, 0.03624772f, 0.03715404f, -0.00728413f, 0.04359097f, 0.09774088f, 0.03795952f, 0.04914911f, 
    -0.39721513f, -0.41781574f, 0.02669924f, -0.05772578f, 0.23403922f, 0.07224472f, 0.12012404f, 0.05266009f, 
    -0.05737634f, -0.13808917f, 0.00868412f, -0.03217212f, -0.00332760f, 0.07788761f, 0.06306052f, 0.01958371f, 
    0.00305758f, 0.07872998f, 0.03467089f, 0.05370544f, 0.05617528f, 0.04844071f, -0.08870066f, -0.00011292f, 
    0.04953044f, 0.00510359f, 0.02684510f, -0.08449984f, 0.03187312f, 0.01599981f, -0.02655875f, -0.03661378f, 
    -0.01282461f, 0.02541549f, 0.08866005f, 0.02108841f, 0.12632428f, 0.18820582f, 0.07362927f, 0.05455473f, 
    -0.41521278f, -0.04387538f, -0.17792070f, -0.12149294f, -0.01473685f, 0.07040843f, 0.02709679f, -0.19941922f, 
    -0.03213440f, 0.00431236f, 0.01599505f, 0.06388164f, -0.07408421f, -0.15571593f, 0.09622823f, -0.06729306f, 
    -0.05416447f, 0.08006849f, -0.01314790f, 0.01721260f, 0.01423894f, 0.06905039f, -0.16804084f, 0.06860708f, 
    -0.01024222f, -0.12588270f, -0.09029742f, -0.06861962f, -0.00031969f, 0.02898340f, -0.02976686f, -0.04612413f, 
    0.08268391f, -0.15072863f, 0.08495581f, -0.01938595f, 0.03318223f, 0.02570748f, -0.03645942f, -0.07774011f, 
    -0.30347189f, -0.03760175f, 0.17357060f, -0.02287724f, -0.08758067f, 0.05514780f, -0.04824590f, -0.02078002f, 
    -0.08771879f, 0.04627663f, -0.05214874f, 0.02553099f, 0.05918983f, -0.06875838f, 0.05095674f, -0.02373008f, 
    0.03331416f, 0.04967670f, -0.02475557f, 0.08436270f, 0.08768654f, 0.01792033f, 0.04490962f, 0.02123604f, 
    0.02320570f, 0.07900933f, 0.02797480f, -0.00241491f, 0.03492739f, 0.00060017f, -0.00932594f, 0.05595448f, 
    0.00815116f, -0.00327267f, 0.03938660f, 0.03576976f, 0.01036546f, -0.09582549f, -0.05287214f, -0.07713725f, 
    -0.40029803f, -0.13668165f, 0.05311402f, -0.10600032f, -0.14288113f, 0.08921632f, -0.03358604f, 0.00978365f, 
    -0.01349674f, 0.04252299f, 0.00711232f, 0.00192813f, -0.01533381f, 0.05666711f, -0.00605459f, -0.02817659f, 
    -0.07359918f, -0.05155084f, -0.00060215f, -0.03977413f, -0.25247759f, -0.03957437f, -0.16158091f, -0.06551652f, 
    0.07529388f, 0.04571996f, 0.03042191f, -0.08125649f, -0.01299665f, 0.02701659f, 0.03570602f, 0.00812254f, 
    0.02478330f, -0.01869862f, 0.08313469f, -0.00931939f, 0.03094127f, 0.13989183f, 0.02087973f, 0.09022088f, 
    0.07197817f, -0.12782934f, -0.06585429f, -0.01441693f, 0.03406768f, -0.00886164f, -0.03470447f, 0.04176615f, 
    -0.04750049f, -0.04703034f, -0.04424566f, -0.08795708f, -0.03783300f, -0.09420963f, 0.00442254f, -0.10283919f, 
    0.06047221f, 0.05386371f, 0.08150966f, 0.06746326f, 0.05344901f, 0.00788647f, 0.10123362f, 0.09195226f, 
    -0.01834898f, 0.10710189f, 0.07592046f, 0.05092286f, 0.04028097f, -0.07329864f, -0.00059593f, 0.06886905f, 
    0.04154537f, 0.05997341f, 0.00957873f, -0.03283897f, -0.01005403f, -0.13478701f, -0.06257477f, -0.03996273f, 
    -0.42589918f, -0.29969162f, -0.19547403f, 0.00281083f, -0.22251980f, 0.04351038f, 0.03991224f, -0.06935164f, 
    -0.06717482f, 0.01113614f, 0.06367019f, -0.00818908f, -0.05439743f, 0.00107570f, -0.00973331f, -0.01372339f, 
    0.04271474f, 0.03602755f, 0.06287940f, -0.05524071f, 0.16273104f, 0.10393444f, -0.11522034f, -0.00732671f, 
    0.04681709f, 0.08409090f, -0.00258961f, -0.05721633f, -0.04103216f, -0.05213198f, -0.00915928f, 0.04567768f, 
    -0.02563844f, -0.00940164f, 0.04423026f, 0.06935828f, 0.11956956f, 0.01441381f, -0.03539958f, 0.06196025f, 
    0.04337111f, 0.16364758f, 0.11368845f, -0.08138378f, -0.02070101f, 0.04534454f, 0.05319257f, 0.07556212f, 
    0.01130630f, 0.04126441f, -0.06491157f, 0.01739624f, 0.04508015f, 0.03978812f, -0.02577760f, 0.09382159f, 
    0.10908083f, 0.04624272f, 0.01903096f, 0.05206136f, -0.00189090f, -0.04678050f, -0.02963283f, -0.02368407f, 
    0.10310161f, -0.02778229f, 0.03144744f, 0.02193136f, 0.00505872f, -0.01905868f, 0.03530464f, 0.01233431f, 
    -0.00399907f, -0.04494930f, 0.05575174f, 0.04829386f, 0.00472054f, 0.00820107f, 0.09749635f, 0.01222624f, 
    0.05828668f, -0.03117035f, 0.07943902f, 0.02194136f, 0.11289473f, 0.00360811f, 0.11926156f, -0.00963302f, 
    0.01644517f, -0.10338778f, 0.00062567f, 0.03680380f, 0.03921375f, 0.01098386f, 0.05693867f, -0.02615794f, 
    0.06383915f, 0.10064431f, -0.04600212f, 0.03047398f, 0.05129420f, 0.01309283f, -0.11156219f, 0.01760022f, 
    -0.06287790f, -0.04595215f, -0.02022503f, 0.04152198f, -0.01267879f, -0.06946810f, 0.02150256f, -0.06402220f, 
    -0.06041853f, -0.09775861f, 0.08152915f, 0.02707440f, -0.04578520f, 0.05113827f, 0.08395167f, -0.02704901f, 
    -0.06976501f, 0.07928137f, 0.01165152f, -0.06133785f, 0.04284183f, 0.01422708f, 0.01337223f, -0.01554616f, 
    0.02576334f, -0.08425371f, -0.07038730f, 0.06092393f, 0.05159159f, 0.03270318f, -0.06687605f, -0.03383608f, 
    0.03322270f, -0.03508120f, -0.13912307f, 0.07467941f, 0.08078645f, 0.01753880f, 0.03920161f, 0.01530334f, 
    0.07951441f, 0.02455402f, -0.01603255f, 0.07081459f, 0.06421532f, -0.02268362f, 0.01027445f, 0.07250654f, 
    0.05713460f, -0.00531122f, 0.08357237f, 0.01936564f, 0.08426108f, 0.01757410f, -0.01476755f, -0.02535885f, 
    -0.18210040f, 0.03634893f, 0.04334257f, 0.03603502f, -0.00844089f, 0.01071593f, -0.03361505f, -0.02475402f, 
    0.00269998f, 0.01961788f, -0.02430582f, 0.01974734f, -0.00673465f, -0.04781193f, 0.02828100f, -0.02194728f, 
    -0.01634582f, -0.00792125f, -0.01186036f, -0.01541528f, -0.26623756f, -0.12230340f, -0.13042825f, -0.12895466f, 
    -0.14425921f, 0.02779891f, 0.03790977f, -0.10209539f, -0.01669439f, 0.01150343f, 0.01203602f, -0.06159561f, 
    -0.03229388f, 0.00043238f, 0.01308461f, -0.05736393f, -0.01710663f, 0.09936316f, 0.06265454f, 0.02011831f, 
    -0.31691408f, -0.29999146f, -0.19657625f, -0.10168437f, 0.03906749f, 0.01283116f, 0.05809382f, -0.03229758f, 
    0.01865448f, -0.02974868f, 0.05882036f, -0.02329577f, -0.02444222f, 0.01658780f, 0.01742682f, 0.06799853f, 
    0.05468966f, 0.03497214f, 0.11727902f, 0.02386289f, 0.27169704f, -0.02821297f, -0.11556025f, 0.09712552f, 
    -0.06027776f, -0.13406964f, -0.07344694f, -0.11953139f, 0.02743072f, 0.04669816f, 0.03330212f, 0.04359240f, 
    -0.11089308f, -0.08089072f, 0.03326206f, -0.09889162f, 0.00896164f, -0.10738076f, -0.03920679f, -0.10336836f, 
    0.12826782f, 0.01566798f, -0.06941634f, 0.00871452f, 0.00932229f, -0.04487064f, -0.03006539f, -0.03101780f, 
    0.06528164f, 0.01140782f, 0.00737035f, 0.02511095f, -0.05995869f, -0.02536565f, -0.01121837f, -0.03650196f, 
    0.03594984f, 0.05935108f, 0.02089961f, 0.02140841f, 0.16947435f, 0.03114471f, 0.07478836f, -0.03022290f, 
    -0.05155055f, 0.05252593f, -0.05559269f, 0.02745718f, 0.00481933f, -0.01348149f, 0.06667673f, -0.03158692f, 
    -0.03635529f, 0.06443906f, -0.04689893f, 0.02003692f, 0.03718119f, -0.04478555f, 0.03851041f, 0.03596587f, 
    0.06585135f, -0.01409971f, -0.00082651f, 0.00441356f, 0.04119383f, 0.12936421f, 0.05865780f, -0.02573659f, 
    0.03839305f, -0.00348765f, 0.00054977f, -0.00553197f, -0.02389720f, 0.02638576f, -0.05435069f, 0.06675642f, 
    0.00884610f, -0.07659583f, 0.02379557f, -0.00050121f, 0.17101945f, 0.05936253f, 0.11051212f, 0.01487606f, 
    0.00729630f, 0.06917627f, 0.05114812f, 0.07154275f, 0.07417181f, 0.03114678f, -0.02528879f, 0.03273323f, 
    0.04631477f, -0.02393914f, -0.04333734f, 0.04528799f, 0.08851612f, -0.18986744f, -0.05951221f, 0.04313613f, 
    0.14980614f, 0.04697151f, -0.06791457f, -0.05295411f, -0.03161673f, 0.09646065f, 0.06746025f, 0.00385446f, 
    0.03318371f, -0.00307350f, -0.04846388f, -0.03429690f, 0.02873046f, -0.01413915f, -0.07730301f, 0.09236490f, 
    0.07423837f, -0.17524329f, -0.01399220f, 0.02295139f, 0.22459804f, 0.04495591f, -0.00889031f, -0.01560078f, 
    0.00938958f, -0.10277598f, -0.03249175f, -0.03709172f, 0.05814862f, -0.05059845f, 0.00066839f, 0.04003591f, 
    -0.04386145f, -0.06002869f, -0.06754790f, -0.02309498f, -0.01370641f, -0.04051799f, -0.08018588f, -0.01325146f, 
    -0.44395876f, -0.16161104f, -0.03990547f, -0.12053502f, -0.07967351f, 0.10285242f, -0.05330010f, -0.04477866f, 
    -0.05216937f, -0.01713137f, -0.01098166f, 0.01855358f, -0.04191098f, 0.13548021f, 0.03012124f, 0.09357438f, 
    0.01839519f, -0.02856716f, 0.01885047f, -0.03330006f, 0.04331576f, 0.00441906f, 0.00334589f, 0.01357313f, 
    -0.10137681f, -0.01465772f, 0.05443049f, 0.06328665f, 0.07194376f, 0.00591321f, 0.00775049f, 0.02440890f, 
    -0.02787490f, -0.05079994f, -0.03856737f, 0.16350570f, -0.00459792f, 0.03459499f, -0.06563581f, 0.05810694f, 
    -0.31825820f, -0.12394045f, -0.16030075f, -0.12509102f, 0.00623012f, 0.11230438f, -0.00076059f, -0.06975003f, 
    0.00380662f, -0.01958340f, 0.00197888f, 0.05710820f, 0.03430950f, 0.08461637f, -0.03564791f, 0.06740956f, 
    0.05569432f, 0.04998758f, -0.02560050f, 0.01858021f, 0.24785393f, 0.14187035f, -0.13100892f, 0.03350151f, 
    -0.07578386f, -0.12638821f, -0.10314774f, -0.00101868f, 0.01795137f, -0.10525490f, 0.05127018f, -0.00478310f, 
    -0.04563026f, -0.08529897f, -0.09945212f, -0.05490552f, 0.02152313f, 0.01952636f, -0.03200868f, -0.02462246f, 
    -0.18882476f, -0.07792462f, -0.14883700f, -0.09031753f, -0.06988841f, 0.02418867f, -0.02080744f, -0.03083788f, 
    -0.10789383f, 0.01520922f, -0.07824326f, 0.00028310f, -0.06696656f, 0.01108122f, -0.02088601f, -0.09485466f, 
    0.00973134f, 0.07744012f, 0.01526518f, 0.02839134f, -0.27602080f, -0.16327347f, 0.02724078f, -0.12095382f, 
    -0.10684177f, 0.03485350f, 0.01547728f, -0.00669827f, -0.04988329f, 0.05667178f, 0.04791520f, -0.04904805f, 
    0.03742997f, 0.02147465f, 0.02097563f, -0.01010718f, -0.10066460f, 0.00017710f, 0.05854677f, 0.00532335f, 
    0.15760154f, 0.08442477f, -0.02195722f, 0.06999324f, -0.06917052f, -0.05948814f, -0.05916255f, 0.02075463f, 
    0.07737618f, 0.05234303f, 0.05558657f, -0.01690592f, -0.05214632f, 0.01444441f, -0.02263938f, 0.03886858f, 
    0.05487550f, 0.06560095f, 0.03753620f, 0.01234035f, 0.21259077f, 0.15614127f, -0.07863022f, -0.01653345f, 
    -0.12041347f, 0.03756706f, -0.03558880f, 0.05954259f, 0.00219643f, -0.00814382f, -0.02888105f, -0.05209387f, 
    0.03094283f, -0.03020257f, -0.02541790f, -0.00327089f, 0.13668233f, -0.08017471f, -0.01152413f, 0.03911114f, 
    0.09342617f, -0.05067235f, -0.02689813f, 0.06051074f, 0.05242607f, 0.02431457f, -0.02019892f, 0.00934092f, 
    -0.04061707f, -0.04988509f, -0.02096097f, -0.02763274f, -0.07071212f, -0.03811531f, -0.11760714f, -0.01340098f, 
    -0.09062643f, -0.17525837f, -0.14389279f, -0.09990977f, 0.14315853f, 0.04896547f, -0.04745807f, 0.08477277f, 
    -0.08549581f, 0.00509338f, -0.01106078f, 0.06086838f, 0.02554453f, -0.00394892f, -0.00282823f, 0.03876016f, 
    0.02047768f, -0.00001018f, -0.03483158f, 0.01574153f, 0.04620253f, -0.04742495f, 0.00316903f, -0.01231218f, 
    -0.40515631f, -0.20942017f, -0.06948674f, -0.07069219f, 0.12625210f, 0.04890890f, 0.06783442f, -0.04746341f, 
    -0.06372840f, -0.08283996f, 0.01703714f, -0.05131033f, -0.04137809f, 0.04558013f, 0.01611416f, 0.02536321f, 
    0.03861343f, 0.08671997f, 0.05421723f, -0.00166144f, -0.42348543f, -0.13794813f, 0.20858990f, -0.27028424f, 
    -0.37482727f, 0.06993129f, -0.02932892f, -0.01961797f, -0.06725880f, 0.04432557f, -0.00586898f, 0.05057441f, 
    -0.00159800f, 0.06342725f, 0.01557843f, -0.02472430f, -0.03024122f, -0.10847883f, -0.17142674f, -0.13029118f, 
    -0.21778654f, -0.11106292f, -0.01865682f, 0.06676494f, 0.18707912f, -0.06069896f, 0.12533262f, -0.03601920f, 
    0.02262251f, -0.04902562f, 0.03117182f, -0.05885227f, -0.02115735f, 0.02397062f, -0.04085876f, -0.03333341f, 
    -0.06010351f, 0.05967044f, -0.13615948f, 0.00135856f, -0.21649529f, 0.10699777f, -0.02814789f, -0.04934227f, 
    -0.00216193f, -0.10650831f, -0.08637204f, 0.00943910f, -0.01889998f, -0.05232619f, 0.06229675f, -0.01846528f, 
    -0.08621678f, 0.04319905f, -0.00809647f, 0.01552385f, -0.02809367f, 0.01463595f, 0.06039146f, -0.02957952f, 
    0.12854066f, 0.09478232f, -0.09405864f, -0.02652009f, -0.01206819f, 0.01520660f, -0.11117673f, -0.05936889f, 
    -0.05842303f, -0.10102911f, -0.11332630f, 0.03337736f, 0.08595494f, 0.05434127f, -0.01853552f, -0.00580693f, 
    -0.04014125f, 0.10473943f, 0.08788650f, 0.01563986f, 0.04733729f, 0.10893621f, -0.00896937f, -0.07683985f, 
    -0.01494609f, -0.03285953f, -0.04255266f, 0.01389583f, -0.13514586f, -0.05579539f, -0.00013978f, 0.02614755f, 
    0.05797118f, -0.08663838f, -0.01013018f, 0.02273247f, -0.02000554f, -0.01111548f, 0.08284625f, -0.02448569f, 
    0.05910049f, 0.10415603f, -0.00669766f, 0.02487615f, 0.12654163f, 0.06582109f, -0.15608774f, 0.01057411f, 
    -0.00549153f, 0.03105134f, -0.01443307f, 0.08261196f, -0.05160209f, -0.01157883f, 0.03514067f, -0.03797344f, 
    0.07706230f, -0.04777338f, -0.01933483f, 0.07184853f, -0.09368594f, 0.00698663f, 0.04069778f, 0.13085644f, 
    0.19050516f, -0.07248293f, 0.05589890f, 0.08455975f, 0.01649778f, 0.00065422f, -0.02021539f, -0.05249246f, 
    -0.04269824f, 0.02758857f, 0.07351851f, 0.00646284f, 0.03388275f, 0.00349962f, 0.02709751f, 0.02768181f, 
    -0.19977170f, 0.00411371f, 0.02599109f, 0.05593067f, 0.00585517f, -0.14475645f, 0.09590882f, -0.00108379f, 
    -0.00044052f, -0.02519131f, -0.10025848f, 0.02808792f, -0.03602731f, -0.02736798f, 0.03573512f, -0.01188820f, 
    0.03330625f, -0.04433463f, 0.00142945f, -0.06101168f, -0.29230028f, -0.04733264f, -0.09515226f, -0.12387122f, 
    -0.24405614f, 0.04100890f, -0.02913538f, 0.07169139f, 0.03656744f, 0.07796215f, -0.09665446f, -0.08443455f, 
    0.01110538f, 0.03244807f, 0.09214785f, 0.01613122f, 0.02562928f, 0.01871286f, 0.00147317f, 0.01996155f, 
    0.03384895f, -0.19832571f, 0.07824560f, 0.03113558f, 0.00968063f, 0.02341711f, -0.01341859f, 0.06163337f, 
    -0.07445511f, -0.04528234f, -0.02844809f, -0.02243764f, -0.07000615f, 0.04546830f, -0.07361406f, -0.07822991f, 
    -0.03689084f, -0.03596884f, -0.08957525f, 0.02698510f, 0.24627732f, -0.02616555f, -0.11154021f, 0.15524089f, 
    -0.06373583f, -0.06860743f, 0.00781209f, 0.03893030f, 0.03796420f, -0.04880043f, 0.06886465f, -0.02560903f, 
    0.00976659f, 0.00019149f, -0.00324444f, 0.09211005f, 0.00681995f, -0.07560894f, 0.02385891f, -0.02535753f, 
    0.20663039f, -0.05353445f, -0.17788726f, 0.07680351f, -0.12383994f, 0.00428509f, -0.01698269f, -0.02523529f, 
    -0.02328013f, 0.02341271f, -0.00024293f, 0.01643398f, 0.04426750f, 0.05557023f, -0.01934793f, -0.01915331f, 
    0.01654303f, 0.01455657f, -0.07447139f, -0.06492050f, 0.03274072f, -0.11347825f, -0.04821289f, 0.13376467f, 
    0.02733084f, -0.03441097f, 0.07024855f, -0.04920324f, -0.01993361f, -0.07287798f, 0.04100603f, -0.07427244f, 
    -0.03905859f, 0.06998890f, 0.06734610f, 0.04738732f, -0.00572501f, -0.01334797f, 0.01081755f, 0.03517697f, 
    0.27483225f, 0.03755740f, -0.19439021f, 0.02838102f, -0.02018987f, 0.03719167f, 0.00081081f, 0.03000136f, 
    0.00349986f, 0.03410936f, -0.00563470f, 0.05085073f, 0.00501270f, -0.01145059f, 0.08062714f, -0.03070185f, 
    -0.03540823f, 0.00022242f, -0.01664894f, 0.02846146f, 0.04142539f, -0.14278054f, -0.13171704f, 0.00794564f, 
    -0.02083332f, 0.01972002f, -0.03879995f, -0.01011460f, -0.00095772f, 0.06176685f, -0.03752597f, 0.05551111f, 
    -0.08943326f, -0.01325026f, -0.00992441f, -0.02027767f, 0.10336350f, 0.03644722f, -0.03808834f, -0.08424583f, 
    -0.00970899f, 0.12382784f, -0.04454237f, -0.04806142f, 0.04202167f, -0.05674744f, 0.06304959f, -0.02652367f, 
    0.05038130f, 0.07284535f, 0.05671982f, -0.03393237f, 0.03279004f, 0.03440330f, 0.04830276f, 0.02110716f, 
    -0.01075707f, 0.02931225f, -0.04293239f, -0.01327182f, 0.03752485f, -0.03085237f, 0.02753010f, 0.05965980f, 
    0.04843187f, -0.09634656f, -0.01580858f, 0.09810999f, 0.06372806f, 0.00587742f, 0.04744712f, -0.05509802f, 
    0.00523003f, 0.09014085f, -0.07932670f, -0.06141993f, 0.04210525f, -0.07928888f, 0.03721571f, -0.02992447f, 
    0.06706274f, 0.02181569f, 0.00695223f, 0.10064581f, 0.02699495f, -0.12159316f, -0.00814257f, 0.05316200f, 
    0.00536841f, -0.04435507f, 0.09507243f, -0.05809227f, 0.02284425f, 0.00035189f, -0.01569713f, 0.13555482f, 
    -0.06277832f, -0.06297549f, 0.09958110f, -0.00509177f, 0.07491183f, -0.04371672f, -0.05605857f, 0.10323272f, 
    -0.18297350f, -0.06396465f, -0.02680736f, -0.00012019f, -0.05046360f, -0.06250502f, 0.06000005f, -0.02989569f, 
    0.05374831f, 0.00011353f, -0.06062134f, 0.01615204f, -0.03201045f, 0.03048332f, -0.01921966f, -0.12993456f, 
    0.04807601f, -0.19082551f, -0.05173317f, 0.06313252f, 0.35496771f, 0.04771722f, -0.06076316f, 0.06562532f, 
    -0.00428491f, -0.03790428f, -0.02221363f, -0.13463597f, 0.03387918f, 0.07777607f, 0.02887038f, 0.07760476f, 
    0.07767975f, -0.06605868f, 0.00224229f, 0.01600553f, 0.11075097f, -0.12309153f, 0.01327525f, 0.02767247f, 
    0.04368430f, 0.06740682f, -0.07652295f, -0.04346269f, 0.06013501f, -0.01020596f, 0.00017873f, -0.00721673f, 
    -0.00979948f, 0.06758208f, -0.01298096f, 0.01975827f, -0.00126513f, 0.02860615f, -0.03561756f, -0.01457767f, 
    0.02076483f, -0.01459956f, -0.07946458f, -0.13650323f, -0.10115591f, 0.08912987f, -0.04188908f, -0.00381526f, 
    0.01975626f, 0.04281637f, -0.01294747f, -0.03817371f, 0.06905393f, -0.01911554f, 0.00535505f, -0.01004815f, 
    0.05298814f, 0.00585805f, 0.03606351f, 0.01872522f, -0.27141497f, 0.20141646f, 0.06980291f, 0.05154090f, 
    -0.07586325f, 0.16082983f, -0.08230236f, 0.01591875f, -0.01907966f, -0.03133195f, 0.03381654f, -0.03676184f, 
    0.04135744f, -0.03036852f, -0.03794297f, 0.01699048f, 0.05924150f, -0.06163588f, 0.02766278f, 0.05511555f, 
    0.40589473f, 0.00463178f, -0.14827341f, -0.08569866f, -0.10710071f, -0.04003581f, -0.06040379f, 0.02797237f, 
    0.05546432f, 0.05871007f, 0.09113020f, -0.02827225f, -0.02211482f, -0.00388492f, 0.01584695f, 0.01545939f, 
    -0.07671517f, -0.03668880f, -0.00700494f, 0.05694122f, 0.05114029f, -0.17354552f, 0.02636507f, -0.01248356f, 
    -0.01096526f, 0.00590714f, 0.05229652f, -0.02556407f, -0.00671996f, 0.03569431f, 0.05155478f, -0.07232583f, 
    0.02624500f, -0.02830929f, 0.02965048f, -0.04783654f, -0.02249123f, -0.00875304f, 0.00904494f, -0.04418705f, 
    -0.31917402f, 0.39753187f, -0.07667599f, 0.10958324f, 0.05211542f, 0.13547713f, 0.05620838f, 0.06687653f, 
    0.03083891f, 0.01698379f, -0.01099128f, 0.05580931f, -0.00947625f, 0.01360336f, 0.10964403f, -0.03068499f, 
    0.05959892f, 0.03967823f, -0.00190240f, 0.06394064f, -0.24383886f, -0.07258591f, 0.00403789f, -0.01285041f, 
    -0.06048675f, 0.07898498f, 0.06959454f, 0.01734692f, 0.02451457f, 0.04285130f, -0.07430340f, 0.04877676f, 
    -0.00324750f, -0.07925668f, 0.01306923f, -0.02865890f, 0.00153503f, -0.05225889f, -0.06543043f, -0.02666689f, 
    -0.34679776f, -0.23142284f, -0.08481953f, -0.05551109f, -0.11505324f, -0.05416822f, 0.06353403f, 0.03379969f, 
    0.01898589f, -0.06144620f, 0.00223887f, -0.00044502f, 0.08139493f, 0.08012084f, 0.01961382f, 0.00163392f, 
    0.01905119f, -0.08152322f, -0.06471162f, 0.01846238f, -0.02212298f, -0.04941047f, -0.00466221f, -0.01129228f, 
    -0.13149261f, -0.01184091f, 0.06985075f, -0.04800704f, 0.02879089f, -0.04099857f, -0.17360292f, -0.06677570f, 
    0.04888940f, 0.07735121f, -0.06580990f, -0.03886363f, -0.09016481f, -0.00552415f, -0.12217187f, -0.06262944f, 
    -0.26651323f, 0.05897072f, -0.06450573f, -0.20856549f, 0.27649391f, 0.07165421f, -0.10375165f, -0.00715712f, 
    0.08078124f, 0.05917250f, -0.06118816f, 0.01377280f, 0.06101437f, 0.10394241f, 0.04458688f, 0.03866373f, 
    0.05758877f, 0.00663293f, -0.05380378f, -0.05758994f, 0.01742649f, 0.14805689f, -0.09900021f, -0.00828022f, 
    0.03362687f, -0.01146561f, -0.01996476f, 0.00088669f, -0.01186477f, -0.07616478f, 0.06002584f, 0.00240946f, 
    -0.04920186f, -0.03627249f, 0.02471631f, 0.06997656f, 0.05083327f, 0.04979159f, -0.02756239f, 0.05705703f, 
    0.31763992f, 0.00566150f, -0.15411261f, -0.06229923f, -0.06348789f, -0.00349464f, -0.01232206f, -0.03314747f, 
    -0.00686789f, -0.01379417f, 0.05051187f, -0.00115580f, -0.00429788f, 0.04135609f, 0.00004742f, 0.02615833f, 
    -0.00935461f, -0.04018662f, 0.01685756f, 0.01902402f, -0.36199972f, 0.05407582f, -0.03563123f, 0.02350568f, 
    -0.01469456f, 0.00310585f, 0.02201797f, -0.05286440f, 0.04614685f, 0.00750510f, -0.03008030f, -0.02304004f, 
    0.04507859f, 0.02912277f, 0.02088220f, -0.02707907f, 0.01784262f, -0.06126393f, -0.02753512f, -0.00628539f, 
    -0.28902403f, 0.17633653f, 0.04308550f, -0.02025350f, -0.00670559f, 0.17985143f, 0.09840281f, 0.07352273f, 
    -0.01610466f, 0.08981235f, -0.04204011f, -0.04214628f, -0.03384866f, 0.01946429f, -0.03772339f, -0.02728547f, 
    0.00409203f, -0.07799543f, 0.00197176f, -0.03366400f, 0.13042663f, 0.09821904f, -0.11508207f, -0.04120077f, 
    0.16181169f, -0.01655942f, 0.02320993f, 0.01047703f, -0.01730466f, -0.01468671f, 0.00608167f, 0.04201814f, 
    -0.02722558f, 0.02923688f, -0.07413485f, 0.05134539f, 0.03587728f, 0.05110471f, -0.01761210f, 0.04587883f, 
    0.23538202f, 0.06846490f, -0.12519266f, 0.00131118f, -0.23348166f, 0.02378875f, 0.05494690f, 0.05229105f, 
    -0.01251705f, 0.05734892f, 0.07357616f, 0.04114972f, -0.03067737f, -0.01742864f, 0.00229380f, -0.07471114f, 
    -0.02864676f, 0.01524581f, -0.05136230f, 0.03647808f, -0.10363586f, 0.14986078f, -0.04160176f, 0.02524360f, 
    0.02880788f, -0.03494426f, 0.08437066f, -0.00212628f, 0.04936571f, -0.02791025f, 0.02132836f, 0.00035278f, 
    -0.05731557f, -0.06553089f, 0.06684887f, 0.04239412f, -0.07242445f, 0.01092095f, 0.00968030f, 0.05375572f, 
    -0.21174166f, 0.07403342f, -0.04317404f, -0.13326083f, 0.14710264f, 0.02443685f, -0.05592464f, 0.05639727f, 
    0.09170420f, 0.07780042f, 0.01149901f, 0.00409500f, 0.06570987f, -0.06610782f, 0.01458004f, -0.05025531f, 
    -0.03689914f, 0.03788457f, 0.03578696f, -0.03244922f, -0.04961142f, -0.12350024f, -0.00865524f, 0.04873561f, 
    -0.01746236f, 0.10045216f, 0.05024049f, 0.03962086f, 0.05355223f, 0.03585349f, 0.01712252f, -0.01809246f, 
    0.01229858f, 0.02974663f, -0.01019968f, -0.11093356f, -0.01383544f, -0.09742551f, -0.01662030f, -0.01943018f, 
    -0.07023780f, 0.05438126f, -0.03379331f, -0.01173280f, -0.07512562f, -0.10158916f, 0.10051217f, 0.00727553f, 
    -0.11772601f, 0.00703803f, -0.00902384f, 0.01153655f, 0.00495374f, -0.09392731f, -0.04327362f, 0.00381041f, 
    0.06320386f, 0.01525288f, 0.08398449f, 0.03858286f, -0.01269556f, -0.44763505f, 0.02504018f, 0.01483483f, 
    -0.13304496f, 0.08788608f, 0.02836651f, 0.02710116f, -0.00513622f, 0.06195965f, -0.04072922f, -0.09298687f, 
    0.04947568f, 0.00143471f, 0.01301038f, -0.11321904f, -0.04030463f, -0.04146838f, -0.12401864f, -0.07360431f, 
    -0.24723215f, 0.19349161f, -0.02045715f, -0.14474389f, 0.09285130f, -0.02002476f, -0.00795268f, 0.00672200f, 
    -0.01117431f, -0.00758105f, 0.01208201f, -0.06015733f, -0.02332166f, 0.02027031f, 0.06064603f, -0.00234099f, 
    -0.03452115f, 0.02767967f, -0.05127460f, 0.03899755f, 0.01101959f, 0.02636180f, -0.02484325f, -0.03967461f, 
    0.05852983f, -0.04271459f, 0.09163354f, 0.00057968f, -0.04735234f, -0.00245707f, 0.01962446f, 0.06270903f, 
    -0.06195802f, -0.02762479f, -0.00708005f, 0.05081417f, 0.04368112f, 0.00400967f, -0.00347147f, -0.00346697f, 
    -0.07479732f, -0.09377252f, 0.04775129f, -0.15426157f, 0.04763566f, -0.06425224f, 0.00328774f, -0.00911150f, 
    0.06998964f, 0.02792288f, -0.02498798f, -0.03271189f, -0.00757259f, 0.02354844f, 0.01846726f, 0.00819028f, 
    -0.00840593f, 0.00627260f, 0.02583904f, 0.00727253f, -0.13217729f, -0.22656740f, -0.10249007f, -0.14195478f, 
    -0.24260731f, -0.04267916f, 0.03473760f, 0.03051752f, 0.02493625f, 0.05587538f, 0.01606780f, 0.00799594f, 
    0.02247008f, -0.12782232f, 0.00635752f, -0.09045959f, 0.04817328f, -0.04254502f, -0.02447611f, -0.01181851f, 
    0.09294675f, -0.20785348f, -0.00680363f, -0.00336414f, -0.04666622f, 0.11957602f, -0.02208001f, 0.03762892f, 
    -0.05127301f, 0.01750443f, 0.04033414f, 0.04256384f, 0.02860492f, 0.05823479f, -0.00877376f, 0.00102964f, 
    -0.11015531f, -0.01121573f, -0.06935585f, 0.00415223f, 0.06881365f, -0.13069060f, -0.08639141f, -0.00321088f, 
    -0.20856601f, -0.02508997f, -0.00447512f, 0.07056003f, -0.04116017f, -0.05568555f, -0.20478970f, -0.05353447f, 
    0.12832217f, -0.05972209f, -0.14818576f, -0.09514391f, -0.01931549f, -0.03277955f, -0.12773696f, -0.10497286f, 
    -0.22820832f, -0.15766783f, 0.05388165f, -0.05209017f, 0.00967149f, 0.02069486f, 0.01912792f, 0.01348833f, 
    0.00890430f, 0.00097030f, -0.07969651f, 0.10196900f, 0.04023739f, -0.00634865f, -0.08352111f, -0.01261325f, 
    -0.07232329f, -0.01523235f, -0.11058519f, -0.03024077f, 0.08205202f, 0.09154418f, -0.03996756f, -0.09492484f, 
    -0.00660556f, -0.04326741f, -0.03129844f, 0.04621364f, -0.06334099f, -0.07224339f, -0.00742712f, 0.05831770f, 
    -0.00947550f, -0.06011889f, -0.04036920f, 0.01810167f, -0.05782286f, -0.01003464f, 0.09697568f, -0.06127451f, 
    -0.17815185f, 0.12692112f, -0.09844615f, -0.15494709f, 0.07779790f, 0.11970172f, -0.10649128f, 0.00060019f, 
    -0.08148409f, -0.09408291f, 0.00656580f, 0.12748235f, 0.00466911f, -0.00586999f, 0.00617264f, 0.03643950f, 
    -0.01760113f, -0.05600901f, 0.00705547f, -0.06934682f, -0.02330885f, 0.08185080f, -0.09248982f, -0.03492509f, 
    0.08910047f, 0.04994982f, -0.01203340f, 0.00044880f, -0.02149237f, -0.03674280f, 0.01460141f, 0.08549711f, 
    -0.03388531f, -0.04821878f, -0.00668096f, 0.09537546f, -0.04255400f, 0.06094762f, 0.06048995f, 0.02197711f, 
    -0.09076209f, 0.09102063f, -0.15445228f, -0.09534831f, 0.04158712f, 0.03536189f, -0.09818756f, -0.00992248f, 
    -0.02578719f, -0.00869326f, 0.05142443f, 0.06924930f, -0.00150270f, -0.00032779f, 0.00326703f, 0.03146018f, 
    -0.00684592f, 0.06734014f, 0.01097554f, -0.08474818f, -0.12831785f, 0.12464536f, 0.00895925f, 0.06271629f, 
    -0.01752697f, -0.01186328f, -0.06831314f, 0.00490046f, -0.07771423f, -0.05548293f, 0.01543139f, -0.01942142f, 
    0.06715760f, -0.03435434f, 0.00211429f, -0.02624203f, -0.02562630f, 0.00846687f, -0.07450720f, 0.00216121f, 
    0.31663445f, 0.07989361f, -0.19123265f, -0.15492895f, -0.03741217f, 0.05301554f, -0.00012281f, -0.06184487f, 
    0.07964950f, -0.00455716f, 0.07217585f, 0.00383021f, 0.04981189f, 0.02103973f, 0.00692283f, 0.05759878f, 
    -0.04864807f, -0.00602095f, -0.00423695f, 0.10348500f, -0.00090083f, 0.27761394f, -0.19241175f, 0.10299180f, 
    0.29893437f, 0.13350590f, -0.07112042f, -0.05481833f, 0.01573933f, 0.05797153f, -0.07872750f, 0.00775350f, 
    0.06611593f, -0.02677087f, -0.02312143f, 0.04582941f, 0.07047441f, 0.05225373f, 0.00427868f, -0.10567851f, 
    0.38119566f, 0.00896939f, -0.07228348f, -0.06360207f, 0.03417737f, 0.12221686f, 0.08907783f, -0.06799620f, 
    0.02869914f, -0.02775607f, 0.06111763f, 0.05736320f, -0.02363892f, 0.01511567f, 0.04619122f, 0.01413236f, 
    -0.05620725f, -0.00637465f, -0.00155542f, 0.10717134f, -0.13623048f, 0.02761619f, 0.12404115f, -0.03120981f, 
    0.08933999f, -0.02574690f, 0.06406067f, 0.04512874f, -0.03433214f, -0.18476668f, -0.03097371f, -0.01531154f, 
    0.05309951f, -0.03633926f, -0.01921097f, -0.09222879f, -0.03629201f, -0.03723598f, -0.10168251f, 0.00602229f, 
    0.14618698f, -0.13337851f, -0.14937569f, -0.07752214f, -0.26850384f, 0.05270506f, 0.09387481f, 0.02888682f, 
    0.02702636f, 0.05492928f, 0.05065479f, 0.02348967f, -0.01060430f, -0.00243794f, 0.04264212f, -0.03037745f, 
    -0.05974509f, -0.09591226f, 0.02489029f, -0.00739796f, 0.17261072f, -0.01970042f, -0.16621178f, -0.00340432f, 
    -0.09982322f, 0.02522001f, 0.01678142f, 0.01943111f, 0.00093648f, -0.02206124f, 0.05346860f, 0.04471128f, 
    -0.04483300f, 0.00009001f, 0.03182412f, 0.08271271f, 0.01046718f, -0.02940219f, 0.05791595f, -0.01660653f, 
    0.09415884f, 0.00602072f, 0.09065542f, -0.04694591f, -0.01898830f, -0.01413883f, 0.01855548f, 0.02922410f, 
    -0.03580103f, -0.08694979f, -0.04071583f, -0.05604457f, 0.02001934f, 0.00406122f, -0.07724273f, -0.00631832f, 
    -0.04486210f, 0.03304032f, -0.06690817f, -0.04916754f, 0.09910309f, 0.01800752f, -0.02952331f, -0.07246913f, 
    0.00372409f, -0.06845356f, -0.02442055f, 0.03989891f, 0.05464533f, 0.03125933f, 0.09181691f, -0.12787834f, 
    -0.07734472f, 0.03321349f, -0.02442781f, 0.03444645f, -0.07181115f, 0.04958462f, 0.10220748f, -0.04266338f, 
    0.00186709f, -0.01958017f, -0.10538907f, -0.15919586f, 0.03536443f, -0.07014900f, -0.13261995f, 0.04333204f, 
    -0.04683628f, -0.19474755f, 0.03854914f, -0.01598977f, -0.01705186f, 0.01624252f, 0.01841740f, 0.04458865f, 
    -0.09452742f, -0.02408457f, 0.09422868f, 0.10916195f, 0.16536987f, 0.01768480f, 0.06228575f, -0.01017639f, 
    0.06190453f, -0.02401456f, -0.05367843f, 0.02223266f, -0.02308904f, -0.07015977f, 0.01762078f, -0.04561930f, 
    0.02160718f, -0.01816332f, 0.00107161f, -0.01210351f, 0.00878083f, 0.04970008f, -0.01603998f, 0.04827630f, 
    -0.25417653f, 0.14816177f, -0.11354154f, 0.06077664f, -0.14715353f, 0.11812586f, 0.04208127f, 0.01580561f, 
    0.01743561f, 0.00880649f, 0.02918772f, -0.01585181f, -0.06726473f, -0.03679165f, 0.07195847f, -0.00241774f, 
    0.00899107f, -0.03513628f, -0.09657769f, -0.00098449f, 0.39436761f, 0.18937309f, -0.25639665f, -0.18204165f, 
    0.24878073f, -0.04921851f, -0.08389574f, -0.01261755f, -0.00462786f, -0.03726289f, 0.06880953f, -0.05563269f, 
    0.00179603f, -0.00113641f, -0.05198102f, 0.05241939f, -0.00311223f, 0.04931323f, 0.00146699f, 0.03871939f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01547377f, 0.04464132f, -0.03396658f, 0.00801919f, -0.00165172f, 0.02939148f, -0.00633929f, -0.03818657f, 
    -0.01519573f, -0.00251205f, 0.03831640f, -0.00093560f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
