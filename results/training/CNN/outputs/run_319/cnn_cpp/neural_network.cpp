#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.13021034f, 0.31972441f, -0.19313413f, 0.40778223f, 0.79502302f, 0.39511824f, -0.54640925f, -0.61245984f, 
    -0.20932512f, -0.08113018f, 0.23341763f, -0.01021742f, 0.25852057f, 0.22866267f, -0.09311290f, -0.11188796f, 
    -0.40650406f, -0.04520895f, -0.06440104f, -0.22759990f, -0.07847778f, 0.10628302f, 0.14611876f, 0.17501973f, 
    0.08971750f, 0.10721347f, -0.94119865f, -0.40416166f, 0.26522478f, 0.01818758f, -0.59908694f, 0.13129561f, 
    -0.05752733f, -0.12971404f, 0.26683289f, -0.20779246f, 0.32661650f, -0.17316622f, -0.03856294f, 0.20657124f, 
    -0.21464857f, -0.19400007f, -0.06054173f, -0.09226519f, -0.18549331f, -0.01884157f, 0.04464670f, -0.22128282f, 
    0.17386973f, 0.16116458f, 0.72805876f, 0.31754434f, 0.10063240f, 0.85891944f, 0.13715608f, 0.66552860f, 
    0.30363473f, -0.38621584f, 0.06609551f, -0.40954968f, -0.11645921f, -0.05053589f, -0.13136987f, 0.00088790f, 
    -0.32281893f, 0.25206161f, -0.13310955f, 0.23247883f, -0.06301045f, 0.12375145f, -0.27103192f, 0.00965403f, 
    -0.12608537f, -0.18147278f, 0.05174139f, -0.01530710f, -0.13584760f, -0.72752982f, -0.66218561f, -0.04638708f, 
    -0.01047571f, -0.37525856f, -0.55236876f, -0.34647498f, -0.05443368f, 0.18076620f, 0.03392620f, 0.47464383f, 
    0.20999207f, -0.04364191f, -0.15295796f, 0.35840318f, 0.01470020f, 0.15285981f, 0.18687190f, -0.03788264f, 
    -0.31072462f, 0.42358220f, 0.18116406f, -0.30095047f, 0.15257011f, -0.59894496f, -0.28363013f, -0.39582500f, 
    0.16396166f, 0.43759137f, 0.87246841f, -0.19495054f, 0.00305180f, 0.15689784f, -0.02815242f, -0.06894667f, 
    -0.23253801f, -0.02179941f, 0.09042785f, -0.15506019f, 0.21349502f, 0.06620983f, 0.00450206f, 0.05351356f, 
    0.07583115f, -0.06349041f, 0.07947940f, 0.08023287f, 0.00264277f, 0.69665426f, 0.13543238f, -0.12325156f, 
    0.63908494f, 0.47834334f, -0.66380292f, 0.30397272f, -0.14054154f, 0.21457735f, 0.02438514f, 0.24704468f, 
    0.24433139f, 0.22445041f, 0.06668290f, -0.18617864f, 0.03379752f, 0.14427155f, -0.11107066f, -0.13602512f, 
    -0.32467455f, -0.17916575f, -0.15972319f, -0.01632672f, 0.16115382f, 0.07428253f, 0.03066494f, 0.32625911f, 
    -0.49309418f, 0.16183427f, -0.25964665f, -0.10809701f, -0.44635653f, -0.31780100f, -0.14065051f, -0.24986602f, 
    -0.16849813f, 0.17240241f, 0.12438121f, 0.32972914f, -0.25890687f, 0.07670619f, -0.11679246f, -0.20047805f, 
    0.16398169f, -0.31103325f, 0.00948049f, -0.08500333f, -0.08430678f, 0.12806153f, 0.20620950f, 0.11164805f, 
    0.23570542f, -0.27944008f, 0.23105766f, 0.26389185f, -0.53238690f, -0.49716523f, -0.43527782f, -0.02456972f, 
    0.16379258f, -0.23840323f, -0.07187013f, 0.13312076f, -0.15386470f, -0.08176165f, 0.07286026f, 0.15577225f, 
    0.17944650f, -0.20719600f, -0.17809719f, -0.26094618f, 0.17212234f, 0.04824667f, 0.03357018f, 0.35831547f, 
    -0.32263863f, 0.10986014f, 0.27391624f, -0.54786223f, -0.39935178f, 0.18434539f, -0.42168927f, -0.51733106f, 
    -0.54721469f, 0.15665290f, -0.03955774f, 0.12272889f, 0.05709772f, 0.43222231f, -0.09808546f, -0.44763547f, 
    -0.09543220f, -0.12078107f, 0.02732226f, 0.32378179f, -0.07771040f, 0.32299840f, -0.19496404f, 0.10453014f, 
    0.16810274f, -0.47923547f, -0.37958458f, -0.23236874f, -0.34443605f, -0.48149073f, -0.04013422f, 0.08372244f, 
    -0.09218610f, -0.34884876f, 0.04785821f, -0.37492734f, 0.08834120f, 0.00656105f, 0.27155703f, 0.14360249f, 
    -0.17967628f, 0.16705352f, 0.05649679f, 0.32326657f, 0.15972388f, -0.19608501f, 0.13761802f, -0.28286746f, 
    -0.18452650f, -0.09560625f, 0.43823904f, 0.34916776f, -0.68582624f, -0.53205252f, -0.09547777f, 0.40645945f, 
    0.05334708f, -0.09131777f, -0.54067886f, -0.15955314f, 0.31352803f, -0.02015480f, 0.19054735f, 0.05931014f, 
    -0.05279700f, 0.13206300f, -0.22049755f, -0.09705158f, -0.21442381f, 0.04440209f, -0.16297877f, -0.02101482f, 
    0.12868956f, -0.09249078f, 0.04232070f, 0.43261394f, 0.51993656f, 0.61698383f, 0.24638380f, 0.40473989f, 
    0.05191815f, -0.13396007f, -0.21161085f, -0.07196861f, -0.19459605f, 0.20790417f, 0.09593320f, -0.29141843f, 
    0.25038281f, 0.17804654f, -0.14504941f, -0.34177881f, -0.10731141f, 0.10428567f, 0.11385077f, -0.05972099f, 
    0.32159191f, -0.10496217f, -0.16290931f, 0.31642732f, -0.68492442f, 0.30806872f, 0.10539480f, 0.09729444f, 
    0.45062312f, 0.50285190f, 0.05098575f, -0.69978148f, 0.43502611f, -0.39455295f, -0.33751249f, 0.11010162f, 
    -0.47638413f, 0.21686807f, -0.12472933f, -0.12535170f, -0.03403954f, 0.09714334f, -0.05946454f, 0.16782291f, 
    -0.11656268f, -0.01467594f, -0.24363087f, 0.05594096f, 0.14718567f, -0.17252934f, -0.10383428f, 0.12286606f, 
    -0.39576954f, -0.24056815f, -0.34592465f, -0.19225085f, -0.18663928f, -0.32521686f, 0.25836781f, -0.01568047f, 
    -0.01166121f, -0.40430331f, 0.13634308f, -0.31609303f, 0.05531899f, -0.41198510f, 0.11947152f, -0.19647789f, 
    0.01805749f, 0.09119774f, -0.01779830f, 0.27575257f, 0.25763386f, 0.27097192f, 0.37343293f, 0.42105478f, 
    0.33730486f, 0.62578589f, 0.27760193f, 0.18163925f, 0.22430940f, 0.24350895f, 0.19334777f, -0.16699882f, 
    -0.01448748f, -0.24306673f, -0.11189809f, 0.21647315f, 0.29511556f, -0.08808433f, 0.10093003f, 0.00641763f, 
    0.26890269f, 0.35371408f, 0.25466666f, -0.28671080f, -0.26776713f, -0.18263844f, 0.02880089f, -0.11815674f, 
    -0.06097066f, -0.12272936f, 0.53430194f, 0.18251915f, 0.15710181f, 0.44951725f, 0.46001080f, -0.11199404f, 
    0.44436428f, -0.28467786f, -0.19715618f, 0.35199842f, -0.47506618f, -0.36266378f, -0.47565922f, -0.22014375f, 
    0.21591569f, -0.10541436f, -0.02879886f, 0.38014969f, -0.13331152f, 0.16672586f, 0.05993097f, -0.10973783f, 
    0.56372130f, 0.45210564f, 0.46035182f, 0.12167156f, -0.07234164f, -0.04265056f, -0.64083874f, -0.01937940f, 
    0.02457292f, -0.00017727f, 0.33928868f, -0.06148759f, -0.11011811f, -0.08229122f, -0.22502533f, -0.07319453f, 
    -0.06170871f, -0.24938573f, -0.06143920f, -0.19098152f, 0.31456593f, 0.31522897f, 0.39511362f, -0.14083964f, 
    0.14323114f, -0.03064578f, 0.46440017f, 0.55052799f, 0.57866418f, 0.38973552f, 0.23907472f, 0.11355484f, 
    -0.10494235f, 0.15775527f, 0.26514193f, -0.27356035f, -0.10977597f, 0.10318715f, -0.16696288f, -0.13140173f, 
    0.02640400f, 0.23343612f, 0.36777124f, 0.00799336f, -0.20849572f, -0.02809706f, -0.18336046f, -0.10077945f, 
    -0.03307864f, -0.10856446f, 0.03716075f, -0.34814641f, -0.17030782f, -0.48947585f, -0.46072564f, 0.38526312f, 
    -0.17637481f, 0.57177168f, 0.55326772f, -0.15770181f, 0.40674371f, -0.23408425f, -0.39863998f, -0.23589322f, 
    -0.29076889f, 0.08613294f, 0.01820605f, 0.06684945f, 0.02807488f, -0.00169418f, -0.18418813f, -0.21789029f, 
    0.00130192f, -0.48121539f, -0.10425372f, -0.62178868f, -0.32794610f, -0.70219153f, 0.10428357f, 0.27854183f, 
    0.31307626f, 0.43924582f, 0.39256522f, -0.35562849f, -0.11989062f, 0.29769179f, -0.17074440f, 0.25863978f, 
    0.09044734f, 0.27363765f, -0.14870299f, 0.14833201f, 0.00153466f, -0.13085033f, -0.38738605f, 0.13305700f, 
    -0.13623591f, -0.03446812f, 0.12994307f, -0.32039100f, -0.60411835f, -0.41793025f, 0.42142984f, 0.37377679f, 
    0.45956889f, -0.11061404f, 0.59847605f, 0.39228916f, -0.48212421f, -0.48726788f, 0.05916518f, 0.11426201f, 
    -0.06987218f, 0.33365306f, 0.19004315f, -0.28260922f, 0.09192033f, 0.10992930f, -0.04106109f, 0.22900638f, 
    -0.26619014f, 0.04708677f, 0.06529468f, 0.02870057f, -0.07088953f, 0.00281563f, -0.36731440f, -0.02095835f, 
    0.70190316f, -0.17279749f, -0.29051098f, -0.41113254f, 0.07061658f, 0.12649742f, 0.01611384f, 0.38481411f, 
    -0.41381213f, 0.07117130f, 0.25098017f, -0.29808500f, 0.08170900f, 0.11356859f, -0.00662995f, -0.31997302f, 
    -0.00686755f, -0.09663182f, -0.15626071f, 0.22367378f, -0.03286504f, -0.02189400f, 0.28247210f, 0.00794535f, 
    0.25498506f, 0.87939358f, 0.17021672f, 0.58242464f, 0.00948101f, -0.36844328f, 0.34637716f, -0.01238476f, 
    -0.00243119f, 0.09918632f, -0.06539800f, 0.27884284f, -0.26252687f, -0.10951262f, 0.10046939f, -0.06149995f, 
    0.09855670f, -0.20865124f, -0.19459626f, 0.35291624f, 0.01122173f, 0.02777943f, 0.03910040f, 0.03502500f, 
    0.80417639f, 0.28975672f, -0.49076608f, 0.33056781f, -0.71616936f, 0.42202377f, 0.03569296f, -0.60714614f, 
    -0.27798313f, 0.00397522f, 0.03517023f, -0.03780995f, -0.17701207f, 0.14301071f, 0.20899327f, -0.00906513f, 
    0.02424257f, -0.06584632f, -0.47637403f, 0.00057096f, -0.02559354f, 0.06168815f, 0.25440645f, 0.19139178f, 
    0.37874466f, 0.48085010f, 0.50846177f, 0.28262931f, 0.10260893f, 0.37528682f, -0.04004438f, -0.27622738f, 
    -0.11823767f, -0.38060716f, 0.07720081f, 0.19164377f, 0.15749890f, -0.05786162f, 0.38351229f, -0.00940013f, 
    0.03353013f, 0.10545779f, 0.17400022f, 0.22245520f, 0.23675956f, 0.12600791f, -0.05007054f, 0.05219871f, 
    0.30858153f, 0.59662342f, 0.28173038f, 0.33699226f, 0.60195160f, 0.51867843f, 0.49994305f, 0.03567841f, 
    -0.13976671f, 0.02327756f, -0.17238140f, -0.01767807f, 0.41434032f, 0.12495970f, -0.09548640f, -0.09235416f, 
    -0.06882414f, 0.12445705f, 0.21652821f, -0.04712092f, -0.15086624f, 0.28669477f, 0.24684817f, 0.20638558f, 
    0.01065263f, 0.18213686f, -0.02130129f, 0.83616370f, 0.00790006f, 0.06207806f, 0.46384877f, -0.18160039f, 
    0.49686310f, -0.01599427f, -0.23112199f, 0.27046397f, -0.24892899f, -0.23620136f, 0.18452989f, -0.41234580f, 
    -0.09152266f, -0.11488064f, -0.21826656f, -0.02377908f, -0.19546460f, -0.18774289f, 0.04833157f, -0.05263409f, 
    0.00492358f, -0.02745722f, 0.09180911f, -0.77488369f, 0.57520920f, 0.19806078f, -0.36764672f, -0.22004470f, 
    0.54840529f, 0.02996637f, -0.36854145f, -0.02726715f, -0.14093697f, 0.17778172f, -0.16771245f, -0.05319272f, 
    0.36620814f, 0.10698998f, 0.19529746f, -0.21780014f, -0.08466522f, -0.10241000f, -0.13915423f, -0.15655452f, 
    0.21872064f, 0.52828288f, -0.01191541f, 0.10578905f, -0.70327938f, 0.43484187f, 0.37616602f, -0.23730271f, 
    0.02951012f, 0.39069051f, -0.36073565f, 0.19640480f, -0.54879397f, 0.17151894f, 0.00259505f, -0.12283988f, 
    -0.12528241f, -0.03368629f, -0.20201828f, 0.14235890f, 0.12396347f, -0.00575243f, -0.18454126f, -0.11813473f, 
    0.00312956f, -0.16710077f, -0.00945653f, -0.13936529f, -0.21818757f, 0.52317470f, 0.34228989f, 0.26614171f, 
    -0.06002526f, -0.22917899f, -0.03631587f, -0.23437457f, 0.36097708f, 0.22287317f, -0.11154590f, -0.28514865f, 
    0.47588515f, 0.28037700f, -0.03611460f, -0.30286810f, -0.15192460f, 0.02576850f, -0.25079432f, 0.05598554f, 
    -0.14172493f, -0.38180873f, 0.03648790f, 0.05358796f, 0.07717153f, -0.41720071f, -0.45867470f, -0.45147160f, 
    -0.46420547f, -0.61973071f, -0.25967190f, 0.09529547f, 0.24395853f, 0.05780715f, -0.11027391f, 0.00179351f, 
    -0.31601927f, 0.33377486f, 0.06224306f, -0.12973189f, -0.05375195f, 0.32298762f, 0.11179248f, 0.03453574f, 
    0.22665679f, 0.23732960f, 0.16896056f, -0.18438822f, -0.14758319f, -0.04718845f, 0.36861914f, -0.16068593f, 
    -0.41207153f, -0.38568577f, -0.06606053f, 0.51482487f, -0.09380196f, -0.41501629f, -0.43056533f, -0.46155372f, 
    -0.31603113f, -0.41530597f, 0.19376385f, 0.27197438f, 0.04200364f, 0.14598387f, 0.20362037f, -0.21564333f, 
    0.08024885f, -0.03125506f, -0.41294628f, -0.18590063f, -0.06804603f, 0.13943949f, -0.15439238f, -0.02206769f, 
    0.49314031f, 0.64157307f, 0.38135061f, 0.39092904f, 0.53183061f, -0.40463218f, -0.03811987f, -0.27798864f, 
    -0.45765984f, -0.08459889f, 0.28477287f, -0.15969522f, 0.04219448f, 0.18657316f, -0.02277368f, 0.21183589f, 
    0.15429816f, -0.06018514f, 0.22137228f, 0.12880145f, 0.18400338f, -0.19514169f, 0.19375196f, -0.02825533f, 
    0.30596605f, -0.44104013f, -0.31868348f, -0.39862895f, 0.04507620f, -0.61345655f, 0.35998765f, 0.47859621f, 
    0.10646348f, 0.26031145f, -0.19438922f, -0.04715546f, -0.02650474f, 0.06431749f, 0.26180887f, 0.36059311f, 
    -0.11965544f, -0.25745401f, 0.31170541f, -0.21708901f, -0.05343206f, 0.20781985f, 0.04193003f, -0.40013078f, 
    -0.13990502f, -0.22453998f, 0.33411291f, -0.03088782f, 0.32672408f, 0.73437965f, 0.40784800f, -0.22126387f, 
    -0.07253401f, 0.28612956f, 0.21253428f, -0.32014737f, -0.48615429f, -0.42985496f, -0.34339336f, -0.23908980f, 
    0.03065260f, 0.17745598f, 0.13430597f, 0.25915501f, 0.31663105f, 0.43231803f, 0.01804130f, 0.03664672f, 
    0.14610796f, -0.21780653f, -0.22225969f, 0.18504071f, -0.46696690f, -0.16850217f, 0.38048592f, 0.31953609f, 
    -0.18190998f, 0.21165383f, -0.37452850f, -0.02296071f, 0.32482046f, 0.44793072f, 0.19248573f, 0.22490230f, 
    0.29818410f, -0.04455496f, 0.12579091f, -0.24861816f, 0.30968124f, 0.10219867f, -0.03635063f, 0.09847502f, 
    -0.36894974f, 0.08603656f, -0.08815034f, 0.07851906f, 0.77995932f, 0.22883844f, -0.11731213f, -0.13422033f, 
    0.02276709f, 0.47730824f, 0.29108095f, 0.23214638f, 0.52039635f, -0.00148708f, -0.37396479f, 0.34631512f, 
    -0.32375848f, -0.00993158f, -0.13613459f, -0.11191368f, 0.05677307f, -0.17070962f, -0.16263834f, -0.00843943f, 
    0.04734761f, -0.07832035f, -0.09826548f, -0.02868194f, 0.03049312f, -0.30048460f, -0.45779419f, -0.27359852f, 
    -0.15890256f, 0.10789166f, -0.02830039f, -0.56615132f, -0.25505921f, 0.05293663f, -0.14405328f, 0.23988524f, 
    0.30912244f, 0.46508458f, -0.27166092f, -0.43579617f, -0.18226747f, 0.00850120f, -0.06089432f, 0.23636617f, 
    -0.03129856f, -0.16381055f, 0.10885043f, -0.00690134f, -0.04046914f, 0.00596928f, -0.16873533f, -0.54418391f, 
    -0.63885444f, -0.06889149f, -0.14847127f, 0.31081957f, 0.15880522f, 0.42953694f, 0.17606522f, -0.00142746f, 
    -0.07537223f, 0.02909644f, 0.04148975f, 0.12240059f, -0.08829037f, -0.15784748f, -0.11840672f, 0.17945188f, 
    -0.27244839f, -0.14645129f, -0.25360560f, -0.10128167f, 0.02287226f, -0.22382416f, 0.00018783f, 0.66756749f, 
    0.59517384f, 0.67153996f, -0.29722175f, -0.60065258f, 0.17439125f, -0.31931290f, 0.15837786f, 0.01215248f, 
    0.52894306f, 0.39285246f, 0.10830368f, 0.12020371f, -0.00084457f, -0.27392098f, 0.01243060f, 0.21187560f, 
    -0.04564250f, -0.06880879f, -0.09972364f, 0.11129837f, -0.05653733f, 0.13351803f, 0.03878701f, -0.03152930f, 
    0.18003128f, 0.12750337f, 0.30687758f, 0.77619815f, -0.02910401f, 0.22990441f, 0.37616184f, 0.24361826f, 
    -0.10017206f, 0.42126331f, -0.18966229f, -0.20886073f, -0.19718874f, 0.06981853f, -0.28517956f, -0.27245405f, 
    -0.08727954f, -0.29476994f, -0.26098537f, -0.27732047f, -0.10178009f, 0.14812377f, -0.41749513f, -0.03025307f, 
    -0.10399144f, 0.13105667f, 0.37102845f, -0.21026051f, 0.01574500f, -0.02281995f, -0.44932401f, -0.77205712f, 
    -0.23755963f, -0.33357024f, -0.13666312f, -0.13713235f, -0.15151830f, -0.02174391f, -0.16362725f, 0.11917700f, 
    -0.05226265f, -0.26023009f, -0.07857810f, -0.02984754f, 0.19300687f, 0.33735451f, -0.00693464f, -0.22292382f, 
    -0.24042308f, -0.03917680f, -0.23940243f, -0.02245708f, -0.15854251f, -0.13854817f, 0.59093142f, 0.31096342f, 
    -0.43066967f, -0.69696605f, -0.20753366f, -0.07468713f, -0.07142359f, 0.26942199f, 0.08366387f, -0.23615164f, 
    0.18160410f, -0.23456176f, -0.21661660f, 0.06792428f, -0.24817342f, 0.25972655f, 0.22638774f, -0.05920525f, 
    -0.29367632f, 0.08285154f, -0.15124284f, -0.08954507f, 0.07599763f, 0.34371269f, 0.04291005f, 0.25593501f, 
    0.38220277f, -0.22614138f, -0.51347947f, 0.15589629f, -0.01433457f, 0.19121157f, 0.41019121f, 0.25902900f, 
    -0.04666143f, 0.39590311f, -0.04357235f, 0.00810756f, -0.11777028f, -0.09437153f, 0.02905768f, -0.14852488f, 
    -0.01557160f, 0.32859603f, 0.26276058f, 0.18919057f, -0.52294189f, 0.41068709f, 0.58915544f, 0.45766965f, 
    -0.63695937f, -0.36950058f, -0.19950461f, 0.15936075f, 0.15385407f, -0.42578039f, 0.19041362f, 0.24857691f, 
    0.09423708f, -0.16596940f, -0.13376057f, 0.01955373f, 0.24373965f, 0.10304759f, 0.19665007f, -0.32570717f, 
    0.04477964f, -0.16952661f, -0.19368014f, 0.00148996f, -0.19883995f, -0.52902496f, -0.66404843f, 0.01110631f, 
    0.17898674f, -0.09481786f, -0.26699707f, -0.09088460f, -0.19915624f, 0.29520935f, -0.30352467f, 0.41461357f, 
    0.38217345f, -0.26198354f, 0.39450362f, 0.29938999f, 0.23031542f, -0.11201937f, -0.15816106f, 0.30653214f, 
    0.17721303f, 0.03157253f, 0.27756828f, 0.16473831f, -0.21528791f, 0.14588903f, 0.63954550f, 0.84153515f, 
    -0.47733885f, -0.08581695f, -0.53647667f, -0.19699846f, 0.07965375f, -0.46751121f, -0.09609716f, 0.38643220f, 
    0.34580851f, 0.16438597f, 0.12786163f, -0.13523006f, -0.15410721f, -0.07932629f, -0.24075845f, 0.11776040f, 
    -0.15202948f, -0.06200449f, 0.09040927f, 0.00884415f, 0.27255732f, 0.15120715f, -0.13752544f, 0.55704111f, 
    0.28006274f, -0.27238688f, -0.26662010f, 0.45759949f, 0.12610295f, -0.29351994f, 0.51957071f, 0.57701284f, 
    0.27056289f, -0.18419266f, 0.12676853f, 0.05082436f, -0.33073214f, 0.02657640f, -0.05754734f, -0.05497519f, 
    -0.03554094f, -0.05101192f, -0.10110521f, 0.15744932f, 0.20994145f, -0.12037160f, 0.20486508f, -0.21026203f, 
    -0.28170615f, -0.43129182f, -0.69635224f, -0.34715042f, 0.05164008f, 0.40174520f, -0.29732484f, 0.10782223f, 
    0.50868237f, 0.02027661f, -0.03090653f, -0.07069481f, -0.01926302f, -0.11005604f, -0.00034947f, 0.15740183f, 
    -0.16423452f, -0.09073583f, -0.21265562f, -0.11296920f, 0.19210917f, 0.05924684f, 0.35637367f, 0.10385478f, 
    0.18321648f, -0.91380811f, 0.76946753f, 0.03741559f, -0.30972755f, -0.13907559f, 0.12553607f, 0.57464504f, 
    -0.36781085f, -0.01844656f, 0.09578614f, -0.18716253f, 0.20946154f, -0.15118118f, -0.19560567f, -0.00949018f, 
    -0.09763891f, 0.01930272f, -0.04600068f, -0.12095129f, -0.33288646f, 0.19947141f, 0.01042619f, 0.03640241f, 
    -0.04826950f, 0.05761231f, -0.80641633f, -0.11985439f, 0.09693364f, -0.30751133f, -0.56552494f, 0.36874866f, 
    0.36039218f, -0.09151061f, 0.18788868f, 0.38689995f, 0.11407528f, -0.27054143f, 0.22811347f, 0.03623581f, 
    0.26152289f, 0.06960053f, -0.12105212f, -0.15553170f, -0.08550865f, -0.06012481f, -0.14494520f, -0.07871349f, 
    0.09233112f, 0.01774060f, -0.04377637f, -0.63024056f, -0.54855001f, -0.52482963f, 0.27016199f, 0.03939129f, 
    -0.66073376f, 0.69403553f, 0.71791172f, 0.00484438f, 0.16128159f, 0.12589699f, -0.14195526f, 0.10933856f, 
    -0.22571892f, 0.14843965f, 0.14486000f, 0.15686527f, 0.18825214f, 0.27495724f, -0.20978913f, -0.06926870f, 
    -0.10277948f, 0.02403793f, -0.13106760f, 0.22748843f, -0.11072449f, 0.43081498f, 0.37288308f, 0.04394985f, 
    0.34022343f, 0.38093784f, 0.47884983f, 0.22126779f, -0.13662934f, 0.21188024f, -0.43826878f, -0.29449961f, 
    0.10027516f, -0.32500342f, -0.18324798f, -0.42421180f, 0.14955801f, -0.19029807f, 0.06472461f, 0.04339229f, 
    -0.17094956f, 0.00485971f, -0.18967916f, 0.17605974f, 0.05521777f, -0.60803789f, -0.63586241f, -0.54109693f, 
    0.00861322f, -0.00776998f, 0.17847495f, 0.28079075f, 0.17665491f, 0.34207803f, -0.03035542f, -0.06894575f, 
    0.19401027f, -0.00751686f, -0.18214028f, -0.02939371f, -0.12430919f, 0.41293323f, 0.38730091f, -0.12619999f, 
    0.05509094f, -0.24867374f, -0.19057371f, -0.29451615f, -0.21224909f, -0.03619600f, 0.19524762f, -0.40465510f, 
    -0.38789320f, -0.25316727f, -0.19673079f, 0.34810925f, 0.91602641f, -0.20194995f, 0.30186766f, 0.28124067f, 
    -0.09236835f, -0.08458856f, -0.27635700f, 0.13690345f, -0.29125071f, -0.08014404f, -0.01751752f, -0.13286486f, 
    0.19766924f, -0.31391540f, 0.02650511f, 0.17806549f, 0.03240944f, -0.05796502f, 0.27955180f, 0.16624744f, 
    0.35684052f, -0.12862921f, 0.53058791f, 0.14729674f, -0.15822293f, -0.51571310f, -0.34063897f, -0.52853644f, 
    0.16917703f, 0.18995045f, 0.36104119f, -0.01551742f, 0.09551793f, -0.27876925f, 0.09387558f, 0.04339973f, 
    0.15108097f, -0.27263209f, 0.28917077f, -0.11676429f, 0.08941177f, 0.36699548f, 0.19955601f, -0.16221029f, 
    0.73609656f, -0.27194223f, 0.24773604f, 0.35254559f, -0.33618575f, -0.14293332f, -0.17826827f, -0.08303943f, 
    0.09472413f, 0.31466678f, 0.42431140f, -0.12421726f, -0.20785953f, 0.03159643f, -0.07013646f, 0.42498052f, 
    0.20880052f, 0.34864765f, 0.06507257f, 0.41928309f, -0.18964747f, -0.26003200f, 0.11791257f, 0.07601947f, 
    -0.29315305f, 0.00120222f, -0.26858559f, 0.30157563f, 0.24298228f, -0.32162780f, -0.34924161f, -0.84550029f, 
    -0.16535419f, -0.06061057f, 0.11163538f, -0.29754555f, 0.28628668f, -0.02149808f, -0.33831206f, -0.28963500f, 
    0.09054792f, -0.23586218f, 0.08413698f, -0.21789545f, -0.06535812f, 0.13801433f, -0.03723565f, 0.11900193f, 
    -0.03874207f, -0.34694362f, -0.20798641f, -0.96577001f, -0.30759570f, 0.45472431f, -0.17906015f, -0.40336165f, 
    0.71649432f, 0.30060074f, -0.54423571f, 0.14264832f, 0.18683335f, 0.00396740f, 0.02416977f, 0.15821174f, 
    -0.00010051f, -0.34029704f, 0.09005486f, -0.21641603f, -0.09426145f, -0.17793053f, 0.07805832f, -0.18717523f, 
    -0.01473671f, 0.07693915f, -0.09162855f, 0.80815500f, 0.28846568f, 0.31022078f, -0.18651828f, 0.71749055f, 
    -0.18681845f, -0.11768957f, -0.29028448f, 0.23467936f, 0.02717513f, -0.16328970f, -0.00665594f, 0.15833239f, 
    -0.07841139f, 0.30133986f, 0.17666934f, 0.06107849f, -0.18845761f, 0.11461118f, 0.22097673f, -0.22337362f, 
    0.06753957f, 0.21827145f, 0.11255892f, -0.18105355f, -0.43814564f, -0.47024527f, 0.04789873f, 0.59067243f, 
    -0.40760514f, 0.27319157f, 0.14239946f, 0.17836428f, 0.28914931f, 0.27330640f, -0.07494807f, -0.24526940f, 
    0.05033971f, -0.05110385f, -0.07009468f, 0.04088326f, 0.09393113f, -0.12546800f, -0.28211245f, 0.13700822f, 
    0.20643124f, 0.38922235f, -0.10595781f, 0.22080179f, 0.06451686f, -0.19678792f, -0.62375420f, -0.13305677f, 
    -0.28233716f, 0.33323207f, -0.62888575f, 0.32976881f, 0.22292450f, -0.53278053f, 0.34195769f, 0.22109231f, 
    0.27430749f, 0.11244791f, -0.10933410f, 0.08434270f, -0.32647967f, -0.22678691f, -0.22800526f, 0.05333268f, 
    -0.06361871f, 0.14030121f, -0.02005105f, 0.13190761f, -0.13766858f, 0.19519131f, -0.65074974f, 0.69484812f, 
    0.23638776f, -0.50501609f, -0.11661474f, 0.60523337f, -0.31757635f, -0.33316544f, 0.40323099f, -0.51617169f, 
    -0.34927797f, -0.23747569f, 0.01594723f, -0.01773882f, -0.09268329f, -0.15969101f, 0.02933665f, 0.07998533f, 
    -0.21358195f, 0.02659247f, -0.00085430f, 0.05734697f, -0.10572334f, 0.15441458f, 0.04959934f, -0.51468128f, 
    -0.09923176f, -0.22995712f, -0.32277057f, -0.34639794f, 0.29833040f, 0.34038186f, -0.30433184f, 0.37518448f, 
    0.41336265f, 0.07710231f, -0.31252873f, -0.01312010f, -0.33376524f, -0.07024115f, -0.18816324f, 0.16372636f, 
    -0.09303322f, -0.10909091f, -0.21659307f, -0.11014561f, -0.09566526f, 0.02260100f, -0.06412015f, -0.24216615f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.25071204f, 0.03693702f, -0.11468332f, 0.14226834f, 0.18539068f, -0.03415526f, -0.04446820f, 0.04472640f, 
    0.12524121f, -0.06517687f, 0.22143283f, 0.10493184f, 0.02556367f, 0.17114612f, -0.03481375f, -0.07498231f, 
    -0.05005914f, 0.13264056f, 0.06267776f, 0.08222477f, 0.04670377f, 0.17274220f, 0.07993054f, 0.15567830f, 
    -0.07407445f, -0.05116659f, 0.03008115f, 0.22245170f, -0.09554039f, 0.03472739f, 0.05319403f, 0.34249404f, 
    -0.08960759f, -0.03838085f, -0.15558138f, 0.09882537f, 0.07424632f, 0.14649083f, -0.10510072f, 0.09102967f, 
    0.10570715f, 0.18678471f, 0.21654916f, 0.10234707f, 0.24760750f, 0.22715737f, -0.00964384f, -0.05510695f, 
    0.02136632f, 0.06201912f, -0.15885879f, 0.18516009f, 0.05570848f, 0.17045078f, 0.16828521f, 0.23776637f, 
    -0.02072985f, 0.20887540f, 0.06625719f, -0.07815450f, 0.04480713f, 0.17732199f, -0.06691881f, -0.05081343f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.09818969f, -0.01730793f, -0.19604094f, -0.16450028f, 0.13168263f, -0.02436261f, 0.10941980f, 0.00837919f, 
    -0.00595028f, 0.02400071f, -0.01373517f, -0.02436432f, 0.33882397f, -0.13408856f, -0.07104691f, -0.00930005f, 
    0.04813506f, 0.00373909f, 0.09049907f, 0.12093626f, 0.00558770f, -0.04736420f, 0.01913622f, 0.05770888f, 
    -0.13953054f, -0.24339823f, 0.11365339f, -0.25850943f, 0.11402485f, -0.02846736f, -0.03342091f, -0.00110906f, 
    -0.10026355f, 0.00679783f, -0.04145756f, 0.02808662f, 0.24670282f, -0.01640266f, 0.00607089f, 0.04008143f, 
    0.13253821f, 0.12765963f, -0.02975963f, 0.01309638f, -0.08301386f, 0.02073033f, 0.04815138f, -0.03451678f, 
    0.30525926f, -0.19012676f, -0.01574784f, 0.05810818f, 0.12377988f, 0.04237140f, -0.01725642f, 0.04682618f, 
    0.02630547f, -0.02046124f, -0.05317836f, -0.05321397f, 0.08076039f, 0.02025805f, 0.02569930f, -0.04654967f, 
    0.06186134f, -0.01142053f, -0.01833059f, 0.05856128f, -0.08979125f, 0.07413419f, -0.09131458f, -0.00683442f, 
    -0.13415204f, -0.04432729f, 0.01792309f, -0.10738036f, 0.06833682f, 0.00644702f, 0.05662554f, 0.13237655f, 
    -0.03401018f, 0.15527467f, -0.10433719f, 0.00131233f, -0.10692214f, 0.02909434f, -0.09908570f, -0.15196693f, 
    0.00069988f, 0.05225716f, 0.10217839f, -0.04269988f, -0.08895648f, -0.05265871f, 0.09129018f, -0.05976874f, 
    -0.06663217f, 0.04775001f, -0.07224543f, 0.02577963f, -0.04881541f, -0.04537593f, -0.08254055f, 0.09183075f, 
    0.13762103f, 0.13002688f, 0.09103083f, -0.08889499f, 0.22716489f, 0.08571012f, -0.00911723f, 0.16994517f, 
    0.00000705f, 0.00646895f, 0.10582740f, 0.02295775f, -0.03882397f, 0.09919509f, -0.06174947f, -0.04155527f, 
    0.10044193f, -0.16060171f, 0.10692140f, -0.07432623f, 0.10463945f, -0.02424150f, 0.04593906f, -0.02788018f, 
    0.03197472f, 0.09631401f, 0.00691259f, -0.06320269f, -0.00510421f, 0.01345683f, -0.04927180f, -0.16880693f, 
    0.06328541f, 0.04638157f, 0.03217445f, 0.01187491f, 0.04968446f, 0.00497133f, 0.04240648f, 0.06692131f, 
    -0.19682048f, -0.00024939f, -0.22610588f, 0.05778154f, -0.01610793f, 0.05318156f, 0.09531412f, 0.05906528f, 
    -0.07365956f, 0.03680113f, 0.05719463f, -0.03346391f, 0.06264584f, 0.04841115f, -0.04150555f, -0.07418399f, 
    0.04454150f, 0.03725524f, -0.04872475f, 0.00172492f, -0.04132562f, 0.07205871f, 0.05357772f, 0.07698357f, 
    -0.09203733f, -0.03858697f, -0.07555124f, -0.11510342f, 0.10986640f, -0.00204741f, -0.06009145f, 0.00531237f, 
    0.06196247f, -0.00851539f, -0.17386927f, 0.10010377f, 0.06190848f, -0.11443820f, -0.12019655f, 0.08804083f, 
    0.14021042f, -0.03880822f, -0.03420694f, -0.00475068f, 0.11866996f, -0.03121283f, 0.02821202f, 0.21396680f, 
    -0.01325648f, 0.17039244f, 0.07494636f, -0.17033355f, 0.05050768f, 0.05349968f, 0.08588524f, 0.03670406f, 
    -0.06588443f, 0.03160754f, 0.13336718f, 0.11401987f, 0.06801508f, -0.04220787f, -0.08957080f, -0.12816699f, 
    0.03775500f, 0.06659786f, 0.02767313f, -0.03801441f, -0.08517163f, -0.02186635f, 0.02818589f, -0.11293812f, 
    -0.05001651f, -0.17392866f, 0.08277176f, 0.07667127f, -0.01672700f, -0.06012996f, 0.08152936f, 0.09214866f, 
    -0.01051890f, -0.03807607f, 0.07150276f, -0.08565539f, 0.37935859f, 0.00421663f, 0.01665977f, 0.27277616f, 
    -0.00342009f, 0.00024220f, -0.07519227f, 0.06593303f, -0.01120386f, -0.06896538f, -0.04222739f, -0.03035338f, 
    0.35397896f, 0.01215889f, -0.22130278f, 0.00508112f, 0.00276901f, 0.00024213f, -0.07844879f, 0.07409424f, 
    -0.03730804f, 0.04054135f, 0.02187585f, -0.04495959f, -0.14081198f, 0.16127543f, 0.04474635f, -0.06350015f, 
    0.05169668f, 0.01703775f, 0.01318989f, 0.00866095f, 0.03670192f, -0.02530344f, 0.04011879f, 0.01210523f, 
    -0.03214415f, -0.07082846f, 0.06186136f, -0.25999722f, 0.02891717f, 0.04675522f, -0.05215900f, 0.04016175f, 
    0.02440755f, 0.09555501f, 0.04704564f, -0.00463927f, 0.18617401f, -0.06764372f, -0.10983526f, -0.03786802f, 
    0.03267965f, 0.17276269f, 0.02266719f, 0.12661558f, 0.06547005f, 0.13117851f, 0.03374396f, 0.12025087f, 
    -0.18401736f, -0.16735564f, 0.03040454f, -0.15035078f, 0.04086696f, 0.05307371f, -0.01930756f, -0.00002374f, 
    0.04754029f, -0.05892885f, -0.01753051f, 0.00197816f, -0.12746356f, 0.03044420f, -0.06296566f, -0.15548074f, 
    0.02477787f, 0.04141831f, -0.01392536f, -0.02338751f, 0.00532752f, -0.00487938f, -0.00337314f, -0.07048322f, 
    0.10359559f, -0.05775762f, -0.13835964f, -0.12203083f, 0.09877737f, 0.11333567f, 0.02193766f, -0.01831602f, 
    0.07290144f, -0.02296927f, 0.13694055f, 0.10809019f, -0.23616235f, -0.20876038f, -0.03991227f, 0.01824640f, 
    0.10110583f, -0.03860790f, -0.04131017f, 0.02687376f, 0.01780281f, -0.06200612f, 0.01058470f, 0.02239892f, 
    0.18014881f, -0.15472908f, -0.14202613f, -0.08358779f, 0.02774120f, 0.07642943f, -0.02468114f, -0.00427458f, 
    -0.12360004f, 0.03865384f, -0.04935208f, 0.07596061f, -0.25530466f, 0.07559235f, 0.01147188f, -0.00075729f, 
    0.09023083f, 0.03232437f, 0.07212677f, 0.04800168f, -0.03042867f, -0.01356037f, 0.02093169f, -0.10027161f, 
    0.13442941f, 0.03037189f, 0.05559652f, 0.13761650f, -0.06439138f, -0.07262772f, 0.03078131f, 0.05233296f, 
    -0.02724842f, 0.08666128f, 0.01928908f, -0.06706276f, 0.16592371f, 0.09547278f, -0.01073279f, -0.06051095f, 
    0.04920089f, -0.02059648f, 0.09543891f, 0.13360469f, 0.02655086f, 0.03753142f, -0.02831396f, 0.00072680f, 
    0.09446737f, 0.11742394f, -0.15161277f, -0.15575263f, 0.15291406f, 0.01466016f, -0.00451436f, -0.08335665f, 
    0.00452473f, 0.04480140f, -0.05326161f, 0.05751185f, 0.14669646f, 0.05888295f, 0.05667539f, 0.24176431f, 
    -0.04379557f, 0.02933690f, 0.11335989f, 0.06594341f, -0.06202721f, -0.02929691f, -0.04297614f, 0.15569942f, 
    -0.22473650f, 0.04343043f, -0.12380189f, -0.21472368f, -0.02534316f, -0.00689260f, -0.01317178f, 0.03757418f, 
    -0.08538250f, -0.10369062f, -0.18793784f, 0.01850041f, 0.13540341f, -0.02916305f, 0.01830722f, 0.02389459f, 
    0.09442321f, -0.02750760f, -0.11941783f, 0.12049045f, -0.08255620f, 0.01054757f, -0.02189001f, -0.04871055f, 
    -0.20723549f, 0.07086358f, 0.05332099f, 0.04115551f, 0.04913238f, -0.05976887f, 0.05169730f, 0.01639709f, 
    0.06703023f, -0.01345781f, 0.04308647f, -0.06193144f, 0.20886472f, 0.15811133f, 0.04228362f, 0.09638369f, 
    0.09181984f, -0.02032357f, -0.07682896f, 0.07235704f, -0.09958649f, -0.01820392f, 0.07348289f, -0.08715984f, 
    0.04666684f, -0.01146607f, 0.08724505f, 0.17674191f, -0.00510378f, -0.05177706f, -0.01433715f, 0.09768509f, 
    0.00848695f, -0.07314319f, -0.00884770f, -0.01661945f, 0.16830955f, 0.00960485f, 0.22325546f, 0.02787796f, 
    -0.03399456f, 0.06330828f, 0.02818563f, 0.00673807f, -0.01499235f, 0.00328076f, 0.06881484f, 0.07939471f, 
    -0.02798142f, -0.02986256f, 0.01041683f, -0.07869963f, 0.05182410f, 0.04256160f, 0.04178053f, 0.02139377f, 
    0.11095961f, 0.09847664f, 0.00776769f, 0.03315657f, -0.17903100f, 0.01570559f, -0.05142368f, -0.06262694f, 
    0.03633795f, 0.13294095f, 0.08901986f, 0.03255191f, -0.06262396f, 0.07826553f, -0.01468876f, 0.02607866f, 
    0.12523392f, 0.04323862f, -0.00009517f, -0.06493130f, 0.06341158f, -0.04640892f, 0.03738954f, 0.06448518f, 
    0.03908945f, -0.02911790f, 0.11622682f, 0.00425884f, 0.07802759f, -0.05450233f, -0.04734877f, -0.01479947f, 
    0.03629676f, -0.01942652f, -0.01110535f, 0.15709984f, -0.02505424f, -0.08050524f, 0.02659322f, -0.09545721f, 
    0.01711273f, -0.00344887f, 0.00729808f, 0.02019108f, -0.04203892f, 0.03913087f, -0.09324440f, 0.02349659f, 
    0.01014654f, 0.00475206f, -0.01675829f, 0.04340611f, 0.22825646f, 0.15886754f, -0.05371267f, -0.00031459f, 
    0.13097139f, 0.10054871f, 0.10740879f, 0.02504714f, 0.01304443f, -0.03033518f, -0.08656184f, 0.05693784f, 
    0.27310732f, 0.03316458f, 0.18123512f, -0.05249809f, -0.04380945f, -0.07456721f, 0.11194533f, 0.12105397f, 
    0.00022604f, 0.01942998f, 0.08033276f, 0.06486918f, -0.23389716f, 0.11095306f, 0.03432308f, 0.11017576f, 
    0.04715483f, 0.02532430f, 0.05685796f, 0.06949528f, 0.22761451f, -0.02384498f, 0.09201067f, 0.13316044f, 
    -0.04320580f, -0.09325219f, 0.04630096f, 0.04105500f, -0.00810857f, -0.06787361f, -0.14602026f, 0.02257615f, 
    0.17300406f, 0.06344784f, 0.01750505f, 0.11297108f, -0.34703511f, -0.24283835f, -0.25321069f, -0.05140738f, 
    -0.02554160f, -0.14811192f, 0.03593572f, 0.01175993f, -0.04021838f, -0.00301438f, 0.15272446f, 0.00651758f, 
    -0.08052547f, 0.05558453f, -0.00721145f, 0.04673038f, -0.09184712f, -0.04420798f, 0.01653561f, 0.04413498f, 
    -0.07669849f, 0.06067761f, -0.00644434f, 0.08027191f, 0.36072889f, -0.06681510f, -0.00752022f, 0.21413365f, 
    0.04254784f, 0.00104772f, -0.00728670f, 0.15192436f, -0.09017631f, 0.03695156f, 0.05121908f, 0.00707524f, 
    0.08598409f, -0.05393645f, 0.02895354f, -0.02080737f, -0.02062661f, 0.12225333f, 0.06199028f, 0.01161502f, 
    0.01578991f, 0.14177452f, 0.05561882f, 0.05283843f, 0.23976815f, -0.01886287f, 0.00172359f, 0.15105504f, 
    0.01721565f, 0.01196383f, -0.01188800f, 0.03463917f, -0.07696669f, -0.04640699f, 0.02855625f, 0.06477831f, 
    0.19708785f, -0.16495094f, -0.03414851f, 0.02174197f, 0.17854704f, -0.00904804f, -0.06808173f, 0.07456779f, 
    0.00397797f, 0.01174992f, 0.02689116f, -0.02972138f, -0.05589801f, 0.08687881f, -0.03498024f, -0.13939029f, 
    0.15174562f, -0.00496726f, 0.00087844f, 0.00064541f, 0.02029846f, -0.00487996f, 0.11570425f, -0.00973574f, 
    0.01444110f, 0.02620894f, 0.20476517f, -0.03038176f, 0.07426267f, -0.06899019f, 0.05024212f, 0.00377907f, 
    -0.09657007f, -0.02095931f, -0.06732481f, -0.02575324f, -0.11922418f, 0.18875034f, 0.08287915f, -0.16133615f, 
    -0.02931783f, 0.10498630f, 0.05831959f, 0.04326310f, 0.00438368f, -0.06099727f, 0.06048596f, -0.02374287f, 
    0.56183690f, -0.00861241f, -0.02636225f, 0.14444932f, -0.05847034f, 0.08670510f, -0.00218756f, -0.03137438f, 
    0.00420009f, -0.05042640f, 0.07268143f, -0.00684701f, -0.12357982f, -0.01159299f, 0.03238248f, 0.09220383f, 
    0.03850614f, 0.04035571f, 0.08080587f, -0.07479176f, 0.06406397f, -0.00835579f, -0.01614887f, -0.01122744f, 
    0.03374799f, 0.05633401f, -0.06909027f, 0.04129431f, 0.00340693f, -0.06891927f, -0.04355710f, -0.12801728f, 
    0.00719942f, 0.03640347f, 0.03902713f, 0.07832273f, 0.38394612f, 0.03077541f, 0.00000109f, 0.10687362f, 
    -0.01830683f, 0.05195199f, 0.05257643f, 0.01721528f, 0.03114640f, 0.00663361f, 0.07770219f, -0.16858463f, 
    -0.43509457f, -0.11550272f, 0.01220600f, -0.09924628f, -0.13235170f, 0.05051716f, -0.04221867f, 0.03558881f, 
    -0.02363454f, 0.01366717f, 0.07665076f, -0.05267015f, -0.03271123f, -0.11327112f, -0.02083443f, 0.01208259f, 
    -0.05899396f, -0.16620669f, -0.01769689f, -0.02448442f, -0.01111855f, 0.14124680f, 0.06310689f, -0.08820682f, 
    -0.01950250f, -0.01924661f, -0.02916551f, -0.03897166f, -0.00602279f, 0.00187663f, -0.00966926f, -0.03551273f, 
    0.01452010f, -0.03535773f, -0.03794631f, -0.00726186f, 0.01601234f, 0.00649992f, -0.02340674f, -0.03374260f, 
    -0.03885712f, 0.00298502f, -0.00692652f, -0.01142247f, -0.04017719f, 0.03289196f, -0.00406238f, -0.00255749f, 
    0.00278629f, 0.02675436f, -0.00527455f, 0.03542455f, 0.00206371f, 0.02204551f, -0.00768656f, 0.02741932f, 
    -0.00065530f, 0.02787207f, 0.01319109f, 0.00305874f, -0.04084893f, -0.03907619f, -0.00886868f, 0.02919745f, 
    0.01503745f, -0.02735985f, -0.03393645f, 0.03462904f, 0.02514120f, -0.01702125f, 0.01844760f, 0.01071392f, 
    0.02146790f, -0.03626595f, -0.00785302f, 0.00448244f, -0.00495343f, -0.01228051f, -0.01419109f, -0.01493625f, 
    -0.00515356f, -0.01620074f, -0.02685968f, 0.00814645f, -0.03192732f, -0.00689114f, -0.01550699f, 0.02300198f, 
    0.01991535f, -0.02878217f, 0.00631658f, -0.03139538f, -0.00376105f, -0.01492555f, 0.01274619f, -0.03188610f, 
    -0.01738299f, -0.03048519f, 0.01178558f, 0.00736475f, -0.01737057f, -0.02066749f, 0.01917196f, -0.00791648f, 
    0.02565323f, -0.02289754f, -0.01349917f, 0.00321132f, -0.01225151f, 0.02996794f, -0.01004530f, 0.00683298f, 
    -0.02696580f, 0.02243296f, -0.02166913f, 0.00363377f, 0.02800687f, -0.01544098f, -0.01199815f, -0.02174327f, 
    -0.03539670f, 0.01483264f, -0.02336490f, -0.02717734f, -0.00783714f, -0.01113695f, -0.03159524f, -0.03676151f, 
    -0.02439839f, 0.01463827f, -0.00344796f, -0.00827544f, 0.01828416f, 0.00753880f, 0.03410751f, 0.00350302f, 
    -0.04141124f, -0.02466310f, 0.00189266f, -0.00447080f, -0.03389023f, 0.01955461f, -0.02516558f, 0.00959475f, 
    -0.02128722f, -0.01662735f, -0.00376352f, 0.01749122f, 0.02534228f, 0.01056572f, 0.01025556f, 0.00125581f, 
    0.01980170f, -0.00459037f, -0.03151080f, -0.03801155f, 0.00057829f, -0.02017258f, 0.00842875f, 0.03010644f, 
    -0.02958978f, 0.00909527f, -0.00151798f, -0.01612189f, -0.01384958f, 0.00459236f, -0.01406449f, 0.00452354f, 
    -0.00762694f, -0.01274780f, -0.03302690f, -0.03493910f, 0.01799868f, -0.02350179f, -0.01099536f, -0.00487265f, 
    -0.01375664f, -0.00826328f, -0.00724755f, 0.01103476f, 0.01186249f, -0.01782922f, 0.01264172f, -0.01802731f, 
    0.00540672f, -0.02480540f, -0.01079152f, -0.03129622f, -0.02553911f, -0.00989102f, -0.02307099f, 0.00684308f, 
    -0.00241302f, 0.00562570f, -0.01958183f, 0.01188271f, -0.01701715f, 0.02945041f, 0.02247465f, 0.00939353f, 
    -0.01615130f, 0.02467055f, 0.00970907f, -0.02482483f, -0.03084844f, 0.01764032f, -0.02990756f, 0.03466545f, 
    0.01675379f, -0.02071206f, -0.02971209f, -0.02444724f, 0.01638847f, -0.02129221f, -0.02450782f, 0.02168371f, 
    -0.00303692f, 0.01927447f, -0.01144819f, -0.00834421f, -0.01633463f, -0.02775461f, -0.02372547f, 0.01902509f, 
    -0.03551908f, -0.01024784f, -0.00623618f, -0.00405359f, -0.03737475f, -0.00555685f, 0.00438899f, -0.00048957f, 
    0.01139502f, -0.00096169f, -0.02776579f, 0.00460154f, 0.01185539f, 0.01259253f, -0.00107054f, -0.01728331f, 
    -0.00833935f, 0.01664518f, -0.02536782f, -0.00173517f, -0.02550238f, -0.03369479f, -0.00897337f, -0.01537405f, 
    -0.00610883f, -0.00149722f, -0.01138878f, -0.00101088f, 0.01570554f, 0.01603688f, 0.02128719f, -0.01703657f, 
    -0.03786492f, 0.02743696f, -0.02668122f, 0.02304758f, 0.02224302f, -0.02832919f, 0.02622391f, -0.00951053f, 
    -0.00889814f, -0.03654174f, 0.02913419f, -0.01928898f, 0.01030148f, 0.01879229f, 0.01816878f, -0.03900140f, 
    -0.01499276f, -0.01326383f, 0.02029397f, -0.03478966f, 0.01757811f, -0.01305009f, -0.00323047f, 0.00549482f, 
    -0.04029384f, 0.02586369f, -0.03036346f, -0.03115294f, -0.00452709f, 0.00488789f, 0.00532119f, -0.03764801f, 
    -0.00315178f, 0.03456781f, -0.01618231f, -0.00756086f, 0.01506036f, 0.02564811f, 0.02602670f, -0.03698820f, 
    -0.03641293f, -0.02707771f, 0.01112470f, -0.01499452f, -0.00565331f, -0.04057253f, -0.00673914f, 0.00677377f, 
    -0.01904971f, -0.03610579f, 0.02294621f, 0.02480985f, -0.03253454f, -0.01808269f, 0.02618920f, -0.03155787f, 
    -0.03282710f, -0.00357920f, -0.02429469f, -0.01271394f, -0.02600804f, -0.02716301f, 0.01005929f, -0.01228549f, 
    -0.00842267f, 0.00083655f, -0.00059152f, 0.00864235f, -0.04055911f, -0.03733299f, 0.02613850f, -0.01427611f, 
    0.02085375f, 0.02109897f, -0.02973858f, -0.03106996f, 0.00125505f, 0.02742761f, 0.02978832f, 0.01391802f, 
    -0.00144371f, -0.03059670f, 0.02313454f, -0.04039040f, -0.02847631f, -0.00798535f, -0.00381537f, 0.01896681f, 
    0.03048964f, -0.01323108f, 0.01301776f, 0.02818627f, -0.00023435f, -0.01904906f, 0.02469823f, -0.03859277f, 
    0.00493212f, -0.01873252f, -0.00255525f, -0.00519745f, 0.00693844f, -0.02452419f, -0.02715813f, 0.02664903f, 
    -0.03121832f, 0.00153862f, -0.01731878f, 0.02882906f, -0.00691191f, -0.01668852f, 0.00284121f, -0.01726804f, 
    -0.03450277f, 0.00767464f, -0.00964645f, -0.03082224f, -0.00928450f, -0.00118850f, 0.00281314f, -0.03196030f, 
    0.02256725f, 0.02182355f, 0.00165938f, -0.01147120f, -0.01309351f, -0.00074109f, 0.02051863f, -0.03062943f, 
    -0.00843289f, -0.01099553f, -0.00701979f, 0.00791592f, 0.02874375f, -0.00741588f, 0.01892530f, -0.02185676f, 
    -0.01354450f, 0.02083843f, 0.02495666f, 0.02583040f, -0.00847492f, -0.02562122f, -0.02375639f, 0.02332620f, 
    0.00128939f, -0.03946415f, 0.02981198f, -0.00888967f, -0.01949278f, -0.00980728f, -0.00126897f, -0.01602141f, 
    -0.02499508f, -0.01991966f, -0.02505220f, -0.03596858f, 0.00523716f, -0.00564441f, 0.02739289f, -0.03253131f, 
    -0.01571316f, 0.00887982f, 0.01964084f, 0.00390835f, -0.02423603f, 0.01437596f, -0.03536250f, -0.01640449f, 
    -0.02348426f, -0.00554964f, 0.00364316f, 0.01417968f, -0.02283818f, -0.02266237f, -0.03453507f, 0.01557491f, 
    -0.01832118f, 0.02759686f, 0.01805217f, -0.03530558f, -0.00461246f, -0.02611585f, -0.01234135f, 0.02230294f, 
    0.01423834f, 0.01943360f, -0.02977186f, -0.00303635f, -0.01419794f, -0.01967396f, 0.00572549f, -0.03463617f, 
    0.00674809f, -0.01896540f, 0.01394486f, 0.02759841f, 0.01714079f, -0.02854065f, 0.03378991f, 0.01076462f, 
    -0.01211847f, -0.01006903f, 0.01805526f, 0.02299280f, 0.01196729f, -0.00486267f, 0.00139462f, -0.03055206f, 
    0.01565724f, -0.01600919f, 0.00772596f, -0.02075681f, 0.00178300f, -0.02080635f, 0.00496464f, -0.02976981f, 
    -0.01692131f, 0.00041450f, 0.00786879f, 0.01195877f, -0.00324535f, 0.02850870f, 0.02303703f, -0.01679104f, 
    -0.01456362f, -0.00980225f, 0.02057453f, -0.01430453f, -0.02317584f, -0.02390455f, -0.02691623f, -0.01334215f, 
    0.03376515f, -0.01606632f, -0.01610508f, -0.01662204f, 0.02127827f, 0.00040692f, -0.03277344f, -0.01138065f, 
    0.01837679f, -0.04010186f, 0.00760700f, -0.04033033f, 0.02125042f, 0.02557442f, -0.03432408f, -0.04110495f, 
    -0.00092509f, -0.00734198f, -0.02070189f, -0.00118080f, -0.01557960f, 0.00686106f, 0.02252091f, -0.03366103f, 
    -0.04037528f, 0.00915472f, 0.02944081f, -0.00043699f, -0.02112142f, -0.01591604f, -0.02548520f, 0.02072175f, 
    0.02522392f, -0.00844409f, -0.00551365f, 0.00987668f, -0.02572656f, -0.02062856f, 0.02160270f, -0.00511235f, 
    -0.02890651f, -0.00458142f, 0.00524642f, -0.01856166f, 0.01333969f, -0.00151616f, -0.00063976f, 0.03033202f, 
    -0.04014828f, -0.00979964f, 0.00102692f, -0.03204377f, -0.03648135f, -0.01411280f, -0.03694098f, 0.01589456f, 
    0.01035603f, -0.00403412f, 0.01921131f, 0.03027162f, -0.02058296f, 0.03004501f, -0.01439642f, 0.01290532f, 
    -0.02492088f, -0.01926820f, 0.02419274f, -0.03333250f, -0.00717403f, -0.02248769f, -0.02787331f, 0.01285884f, 
    -0.00678829f, 0.02964765f, -0.00647556f, 0.02629647f, 0.01795419f, 0.01821745f, -0.01133769f, 0.02016521f, 
    -0.02850865f, -0.03962816f, 0.00020850f, -0.03049793f, -0.02854689f, 0.01173490f, -0.04086155f, -0.02112615f, 
    0.01784301f, 0.01599743f, -0.03085686f, -0.00523440f, -0.01712188f, -0.00132196f, 0.01465473f, 0.02762474f, 
    0.00919335f, -0.03012704f, 0.02610963f, -0.01467435f, -0.00446270f, 0.02928541f, 0.02286724f, 0.02482640f, 
    0.02415817f, 0.00133916f, -0.01332574f, 0.02411956f, 0.00466761f, -0.03248611f, 0.02677458f, -0.01975046f, 
    0.02496860f, 0.00451938f, -0.02878483f, 0.01533986f, 0.03065180f, -0.00865611f, -0.03000841f, -0.02927857f, 
    -0.00560380f, 0.00805517f, -0.00306740f, -0.03509704f, 0.01851699f, 0.00650522f, 0.02947046f, -0.02804130f, 
    -0.00935447f, -0.01468782f, -0.03922427f, -0.03665025f, 0.02102753f, -0.00349231f, -0.01897110f, -0.03995995f, 
    -0.03830900f, 0.03361063f, 0.01051572f, -0.03743063f, 0.01928389f, -0.02176832f, -0.02478700f, -0.03445090f, 
    -0.02105041f, -0.02315420f, -0.03859380f, 0.02403992f, -0.00495370f, -0.00736544f, -0.00222372f, -0.02258346f, 
    -0.00348993f, -0.01418031f, -0.03755802f, 0.02233720f, -0.01695047f, 0.02585794f, -0.00826244f, -0.01771494f, 
    -0.03030776f, -0.01323107f, 0.01213979f, 0.01149417f, -0.00352059f, 0.02450048f, -0.01825932f, -0.03830113f, 
    0.02674702f, -0.01121741f, -0.03999399f, -0.01813497f, -0.02593717f, 0.02271256f, -0.03942560f, 0.01942496f, 
    -0.01807125f, -0.03914796f, 0.02512687f, 0.01615483f, 0.00947372f, 0.02027453f, -0.00744006f, -0.01259349f, 
    -0.01661825f, -0.03167670f, -0.01411766f, -0.03892357f, -0.01846035f, -0.03724554f, 0.01751137f, 0.00692967f, 
    0.01342542f, -0.03056576f, 0.02793692f, 0.02232657f, 0.02042544f, -0.01285760f, -0.03939505f, 0.00568902f, 
    -0.03773450f, -0.03386751f, 0.01433310f, -0.03270642f, 0.01817721f, -0.00119517f, 0.01715848f, -0.00033978f, 
    0.01408630f, -0.00494079f, 0.02121755f, -0.02816011f, -0.03991910f, -0.03876037f, -0.02443491f, -0.00513803f, 
    -0.01465738f, 0.02190263f, -0.03112158f, -0.04041703f, -0.02491577f, -0.01828332f, -0.00876770f, -0.03424462f, 
    -0.01264694f, 0.00820965f, -0.02654935f, -0.03068143f, -0.01039196f, 0.01153727f, -0.00104647f, 0.02584542f, 
    0.01663084f, 0.02359141f, -0.00439123f, 0.03168290f, 0.00772564f, -0.01892728f, 0.02205684f, 0.02425064f, 
    0.02532127f, -0.01463099f, -0.00786118f, -0.00429259f, -0.00767775f, -0.00430519f, 0.00945663f, -0.04110175f, 
    -0.01343802f, -0.01844360f, -0.03132990f, -0.03558354f, -0.03666513f, 0.02473191f, -0.01004306f, 0.00462218f, 
    -0.02709043f, -0.01470033f, -0.03517201f, 0.00815582f, -0.03187035f, 0.01002666f, -0.02111497f, -0.03411602f, 
    -0.03699318f, -0.03849836f, -0.03248024f, 0.02050852f, 0.02181554f, -0.02102323f, -0.02373178f, -0.03575238f, 
    -0.03629003f, -0.01391226f, 0.01495629f, 0.00443260f, -0.01973211f, -0.01409837f, 0.02879406f, -0.01087710f, 
    0.01428564f, -0.00968174f, -0.03358751f, 0.00489659f, -0.03080993f, 0.02148955f, -0.02169401f, -0.01259676f, 
    -0.03339047f, -0.01832733f, 0.02319280f, -0.03539255f, 0.02028135f, -0.01305352f, -0.02683836f, 0.00489658f, 
    -0.03548521f, -0.02089706f, -0.00851220f, 0.02656597f, -0.03228084f, 0.02130573f, 0.02046985f, -0.01090358f, 
    0.07079928f, -0.11910519f, 0.01467034f, 0.21671747f, -0.07384650f, 0.02571047f, 0.09331228f, 0.06840365f, 
    -0.00131242f, -0.01909074f, -0.04219396f, 0.11325693f, -0.24484265f, 0.31986460f, 0.09243657f, 0.02254137f, 
    0.09602897f, 0.06862903f, 0.00085168f, 0.08629856f, -0.02831939f, 0.00021975f, -0.01856611f, -0.05700019f, 
    0.09497591f, -0.08379292f, 0.02232517f, -0.05934316f, -0.03373192f, 0.04403311f, 0.01844038f, -0.06470673f, 
    0.02855557f, 0.03968133f, -0.00116444f, 0.06168785f, 0.13904488f, 0.06536773f, 0.02421728f, 0.13003255f, 
    -0.05470884f, -0.13129805f, -0.05667214f, 0.04043114f, 0.12409766f, -0.06518392f, -0.01561292f, 0.17861825f, 
    0.05472488f, -0.00880706f, -0.03267622f, -0.07847317f, 0.03928400f, -0.00955873f, -0.05642314f, 0.09990455f, 
    -0.04355796f, 0.01447571f, -0.02996659f, -0.06078031f, -0.04417296f, 0.08570754f, 0.04992270f, -0.12403990f, 
    0.05805331f, 0.06528046f, 0.10868153f, -0.03246808f, 0.12479986f, -0.07736403f, -0.00071569f, 0.06385180f, 
    0.15578578f, 0.11171667f, 0.00205041f, 0.21773201f, -0.00766774f, 0.01588460f, 0.00303504f, -0.05097356f, 
    -0.02632214f, -0.03095536f, 0.11711833f, 0.04868251f, 0.00253253f, 0.09845536f, -0.04770241f, 0.03920871f, 
    0.04216243f, 0.12764856f, 0.05373649f, 0.03495904f, 0.03066538f, -0.14330289f, -0.11538126f, 0.08669531f, 
    0.13826053f, -0.03301361f, 0.08600144f, 0.26319769f, -0.02024329f, -0.05892997f, 0.04782592f, -0.01176191f, 
    0.02186999f, -0.10708543f, 0.14369017f, -0.07524395f, -0.14810425f, 0.00732078f, -0.04527946f, -0.03612513f, 
    -0.09025903f, 0.00218511f, -0.02985843f, 0.09701900f, 0.10909986f, -0.05506184f, 0.09976857f, 0.05164539f, 
    0.28977853f, 0.05577469f, -0.10559336f, 0.12415324f, 0.14189333f, 0.04254867f, -0.04472836f, 0.00819141f, 
    0.04059964f, 0.00203321f, -0.00104129f, 0.07455302f, 0.22181797f, 0.07057317f, 0.04611851f, 0.22925653f, 
    -0.01069448f, 0.08800074f, -0.02774823f, 0.03896133f, 0.03523847f, -0.05131909f, 0.09303004f, -0.06202284f, 
    0.31833971f, -0.18472469f, 0.20073374f, -0.03209269f, -0.00800039f, 0.05353737f, 0.00429332f, -0.07603526f, 
    0.00635412f, 0.06938756f, -0.02060605f, -0.02348158f, 0.03591691f, 0.14127979f, -0.02954444f, 0.15229028f, 
    0.00982614f, -0.05326274f, 0.10822809f, -0.09853247f, 0.01265955f, -0.07441477f, -0.03323139f, -0.02300367f, 
    0.11706647f, 0.02272374f, 0.10197796f, -0.03381882f, -0.04338346f, -0.06429605f, -0.05383375f, -0.03637898f, 
    -0.01582230f, -0.09729692f, 0.05468491f, 0.05311167f, -0.00799336f, -0.17727992f, 0.18666162f, -0.15914258f, 
    0.00124162f, -0.01878076f, 0.02767924f, 0.01599910f, -0.13433291f, -0.03625546f, 0.02583452f, -0.14310382f, 
    0.10705822f, -0.01761076f, -0.05846176f, 0.28497174f, 0.03747625f, 0.05880118f, -0.00035826f, 0.10221307f, 
    0.05629350f, 0.05662024f, -0.05030585f, -0.03438437f, 0.16753921f, -0.04881553f, 0.10206806f, -0.06070540f, 
    0.07884433f, 0.01687096f, -0.01921452f, 0.00674699f, 0.02495519f, 0.11487459f, 0.07950820f, 0.03685036f, 
    -0.22845499f, -0.05231281f, -0.23747516f, 0.13709064f, 0.05138266f, -0.11615819f, -0.07932908f, -0.14753360f, 
    -0.02602072f, -0.06236437f, -0.06665785f, 0.22117135f, -0.29180780f, 0.07914867f, 0.04000617f, -0.18379071f, 
    0.00872284f, 0.00309771f, 0.13276507f, -0.07806216f, -0.01549895f, 0.00525020f, 0.04562011f, 0.01253651f, 
    -0.10989505f, -0.10678121f, 0.24820086f, 0.07238975f, 0.10473645f, -0.00709775f, 0.04799180f, -0.04963918f, 
    -0.00472234f, 0.09607240f, 0.04586703f, -0.06068930f, -0.03136232f, -0.10475975f, 0.09257357f, -0.05789061f, 
    0.12269067f, -0.04215306f, 0.05746948f, -0.03121037f, 0.08547555f, -0.08134605f, 0.07548440f, 0.00904054f, 
    0.05445740f, -0.01772726f, 0.18603887f, -0.09550302f, -0.10630830f, -0.03804350f, 0.13382170f, -0.00587066f, 
    0.01557157f, -0.02254344f, 0.04210756f, -0.10837832f, -0.12897693f, 0.12856504f, 0.05405257f, 0.20041086f, 
    0.03892785f, 0.01927263f, 0.14057237f, 0.07539190f, 0.06375392f, -0.06369241f, -0.09496908f, 0.11810786f, 
    0.33499873f, -0.07673266f, 0.08136246f, 0.19697960f, -0.03875513f, 0.01239693f, 0.00692971f, 0.10219393f, 
    -0.03552208f, 0.02350000f, 0.06685691f, -0.04969608f, 0.13477384f, -0.21033919f, 0.21343324f, 0.09995499f, 
    -0.06818110f, 0.04798314f, 0.02495174f, 0.07012225f, 0.08585459f, -0.04683222f, 0.02741578f, -0.03342968f, 
    -0.23724145f, 0.10734960f, -0.04213010f, 0.15718114f, 0.01403873f, 0.06046833f, 0.03593948f, 0.01683898f, 
    0.04360097f, -0.02114375f, 0.04272524f, -0.05088287f, 0.02267254f, 0.05737767f, 0.09394756f, 0.22439963f, 
    -0.13540280f, 0.10061508f, 0.06404807f, 0.02865182f, -0.07752783f, -0.01920484f, 0.03185846f, -0.08350158f, 
    -0.00167134f, -0.06391829f, 0.06581751f, 0.16676134f, -0.04807498f, -0.02140886f, 0.01421332f, -0.03107242f, 
    0.06887575f, 0.08481684f, 0.03343002f, 0.08165015f, 0.15924756f, 0.11027414f, 0.01127905f, 0.12599432f, 
    0.10120622f, 0.00176167f, -0.02690493f, 0.07643633f, 0.05019585f, 0.08361674f, -0.09913813f, 0.08537425f, 
    -0.20858128f, -0.07288069f, -0.19715014f, -0.04702532f, -0.03145644f, 0.01962478f, 0.01312839f, -0.07913362f, 
    0.08552504f, 0.02626609f, 0.04601210f, 0.04938171f, 0.06778511f, 0.08875579f, -0.02047078f, 0.00928181f, 
    0.02463140f, 0.13015686f, -0.08933894f, -0.05881204f, -0.01766768f, 0.01879386f, 0.26817667f, 0.09465797f, 
    0.08932716f, -0.00256952f, 0.14086387f, 0.10035358f, 0.11803617f, 0.02734778f, 0.05335369f, -0.06969401f, 
    0.01357573f, -0.07912460f, 0.02050498f, 0.07427566f, -0.29649889f, -0.15182582f, -0.04874819f, -0.10966352f, 
    0.01384279f, 0.02073514f, -0.15283364f, 0.02790744f, 0.02808150f, 0.14384645f, 0.06862751f, -0.06570068f, 
    -0.01671861f, 0.08656465f, 0.11882445f, -0.22751503f, 0.03924658f, 0.01022304f, 0.10314132f, 0.04109171f, 
    -0.08280879f, 0.00510651f, -0.07585698f, 0.03447206f, -0.02575582f, 0.05941309f, 0.13096295f, -0.09306534f, 
    -0.01311078f, 0.07618248f, -0.03201926f, -0.00967197f, 0.02817107f, -0.02494778f, 0.16783854f, 0.05459270f, 
    -0.02437866f, -0.23038855f, 0.02476894f, 0.05176110f, -0.05792351f, 0.08484805f, 0.07017233f, -0.10442801f, 
    -0.04185009f, -0.06125382f, -0.07575621f, -0.00345401f, -0.09470872f, 0.05105488f, 0.06086782f, 0.02811731f, 
    0.02708775f, 0.11488138f, 0.00276520f, -0.03781489f, -0.04995881f, -0.07874103f, -0.10382298f, 0.17831287f, 
    -0.28513321f, -0.16119385f, -0.11696557f, -0.18343231f, 0.03119639f, -0.02557269f, -0.00255145f, -0.17097318f, 
    -0.01299270f, 0.10950287f, 0.07308842f, 0.06316799f, 0.43549174f, 0.09887802f, -0.26831979f, 0.19651096f, 
    0.02118615f, 0.02859868f, -0.03835953f, 0.08705944f, 0.06202264f, -0.06278677f, -0.01975757f, 0.00538836f, 
    0.23926355f, -0.03819965f, 0.15017551f, -0.01209069f, 0.01396265f, -0.07108115f, 0.00308769f, 0.05106759f, 
    0.01603607f, -0.02831152f, 0.03294313f, -0.01903142f, 0.03835937f, 0.11577348f, -0.00047372f, 0.15204448f, 
    0.04837221f, -0.03167975f, 0.05612640f, 0.03990815f, -0.02492589f, 0.03836325f, 0.09677829f, 0.05780192f, 
    0.10998875f, 0.04540983f, -0.02248324f, 0.15260662f, 0.02056460f, 0.15183763f, -0.05105348f, 0.02313584f, 
    -0.08838709f, 0.14242665f, 0.00714128f, 0.02320744f, 0.14589930f, -0.06133164f, -0.05526980f, 0.20763606f, 
    -0.04895649f, 0.04543343f, 0.06188669f, -0.06619868f, -0.00265714f, 0.09666409f, -0.16062425f, -0.00289655f, 
    0.17558756f, -0.09138791f, 0.20346308f, -0.08910017f, 0.10448084f, -0.03968651f, -0.01932509f, 0.09261831f, 
    0.11425526f, -0.03896913f, 0.03201148f, 0.08809214f, -0.12078047f, 0.08009791f, 0.07604215f, -0.09925989f, 
    0.10388089f, 0.04265588f, -0.09530124f, -0.05169143f, 0.00908800f, 0.00909483f, 0.03442154f, 0.03238252f, 
    0.25577229f, 0.04417228f, -0.19286993f, 0.15269436f, 0.05316143f, -0.01337161f, -0.10323529f, 0.04766424f, 
    -0.06562299f, -0.05086792f, -0.01018191f, 0.03570980f, -0.07327200f, -0.06707868f, -0.08799206f, -0.06396872f, 
    0.03156902f, -0.13434161f, -0.04516397f, -0.07761452f, -0.03136951f, -0.13992962f, -0.02583217f, -0.05074053f, 
    -0.16423294f, -0.08437645f, 0.00989308f, -0.21816695f, 0.05259749f, 0.10064971f, 0.06898320f, -0.11942998f, 
    0.00571289f, 0.01824283f, -0.05503928f, 0.02117650f, -0.30199781f, 0.08118302f, -0.03112073f, 0.11852920f, 
    -0.02602518f, 0.08623845f, -0.03858955f, 0.05187735f, -0.05228564f, -0.04838840f, 0.00923784f, 0.00661865f, 
    -0.57697684f, -0.09797004f, -0.08421596f, 0.01344888f, -0.05528564f, 0.05844150f, 0.02076223f, -0.12597410f, 
    -0.02296894f, -0.02853482f, -0.06201638f, -0.08236188f, -0.33950394f, 0.00034953f, 0.02844305f, -0.09123392f, 
    -0.01585797f, 0.03543162f, 0.01556359f, -0.06698262f, -0.00018339f, -0.08227464f, -0.02528911f, 0.02840826f, 
    -0.04120961f, -0.07181079f, -0.03571734f, 0.01659865f, -0.02626069f, -0.00191280f, -0.01558432f, -0.01459276f, 
    0.03019783f, -0.00433591f, 0.11866113f, -0.04737100f, -0.26372132f, -0.02167083f, 0.11666183f, -0.07436825f, 
    -0.03314545f, 0.08884357f, -0.11608769f, -0.05996723f, 0.06652229f, 0.13296711f, 0.00116994f, -0.10003544f, 
    0.09614863f, -0.06626195f, -0.16540542f, -0.08278307f, -0.05856091f, 0.05473853f, 0.03158180f, -0.04533677f, 
    0.04303880f, -0.12766425f, 0.04685408f, 0.03046336f, 0.13918139f, -0.05453725f, -0.00592784f, 0.18659236f, 
    0.07679240f, 0.11046679f, -0.03669007f, 0.07088079f, 0.00950877f, 0.03985569f, -0.02568199f, 0.05192580f, 
    -0.09559540f, 0.00293598f, -0.10119498f, -0.06137222f, 0.07129043f, -0.03700758f, -0.07884896f, 0.00553991f, 
    -0.02088993f, -0.04567285f, 0.06421455f, -0.08098985f, 0.07802552f, 0.05813379f, -0.10281131f, 0.06956008f, 
    0.13105503f, 0.02148459f, -0.02467413f, 0.03909530f, 0.08694743f, -0.04848128f, 0.02369637f, 0.04996957f, 
    -0.21201566f, 0.20582722f, 0.08418369f, -0.09524482f, 0.11057087f, -0.02872225f, 0.09708463f, 0.04749370f, 
    0.00552909f, -0.04168607f, 0.11132342f, -0.04842960f, 0.10995930f, 0.13776214f, 0.00574247f, 0.17669950f, 
    -0.03621839f, -0.04139251f, 0.06044932f, -0.10335316f, -0.05285839f, 0.01097485f, 0.02610154f, 0.04934026f, 
    -0.15816389f, -0.16547236f, 0.05054617f, -0.12319858f, -0.09045240f, 0.01374648f, 0.05254820f, 0.04122230f, 
    -0.04853507f, -0.03584513f, 0.03809256f, -0.09779783f, -0.10529634f, 0.17420384f, 0.08335467f, -0.03400778f, 
    0.03956369f, 0.05844443f, 0.05090576f, 0.03023613f, 0.00803230f, 0.01277355f, 0.11147410f, 0.01592016f, 
    0.33578297f, -0.17417270f, 0.07143351f, 0.32588437f, -0.07681108f, -0.05634116f, 0.01884284f, 0.09816919f, 
    0.05826784f, 0.06364908f, 0.04883991f, -0.10424255f, -0.26316297f, -0.10294116f, -0.12123571f, -0.09578829f, 
    -0.03702872f, 0.11586723f, -0.07224341f, -0.07781553f, -0.00111746f, -0.04971113f, -0.01835382f, -0.05246574f, 
    -0.00500053f, 0.00387097f, -0.01117656f, 0.00635924f, 0.02751824f, -0.02046665f, 0.02259120f, -0.03122139f, 
    0.00440977f, -0.01478079f, -0.00622063f, -0.03143798f, -0.01446342f, 0.00461080f, -0.03732612f, 0.01653535f, 
    0.01016279f, 0.02269429f, -0.02503161f, -0.01633037f, 0.00364919f, 0.01140434f, 0.03653312f, -0.00630842f, 
    -0.03054175f, -0.03650083f, 0.02635607f, -0.00572095f, -0.00837091f, 0.00852998f, -0.01408281f, 0.01060501f, 
    -0.03066182f, 0.01664185f, 0.01727360f, 0.00325928f, -0.00314577f, -0.00486760f, 0.01924219f, -0.03322309f, 
    0.01578321f, -0.03304994f, 0.01071294f, -0.01079266f, 0.01086378f, 0.00853544f, -0.02004077f, 0.02487305f, 
    -0.02859301f, -0.02231343f, 0.00925107f, -0.02134196f, -0.01407972f, 0.02745898f, -0.02324533f, -0.01643176f, 
    -0.02600199f, -0.00635551f, 0.02564556f, -0.02442222f, -0.02367671f, -0.03708870f, -0.02601171f, 0.00812838f, 
    -0.03620872f, -0.00993661f, -0.03300974f, -0.02755871f, 0.01088347f, -0.02588277f, 0.00366679f, -0.00139299f, 
    -0.00584099f, -0.02867705f, 0.01450549f, 0.01780008f, 0.00086982f, -0.02258252f, -0.01295564f, -0.00119069f, 
    -0.00960169f, -0.02669252f, -0.03721944f, 0.01724010f, -0.03381961f, -0.02183641f, -0.01875592f, 0.01170846f, 
    0.01197115f, 0.02558748f, -0.03509498f, 0.01488113f, 0.00004397f, -0.03723238f, -0.02378774f, 0.02188648f, 
    -0.01379811f, 0.01989034f, 0.02583255f, 0.01045635f, -0.01320776f, -0.00729750f, -0.04089291f, 0.01629268f, 
    -0.02151790f, -0.03648068f, 0.00154590f, 0.00296550f, -0.00329424f, -0.04057463f, -0.02970385f, -0.00525824f, 
    -0.03347083f, 0.00843852f, 0.02512353f, 0.01597843f, -0.00563289f, -0.01798201f, -0.00174107f, 0.00711076f, 
    -0.02833069f, 0.01644151f, 0.01227958f, 0.00803915f, 0.00757071f, -0.03438573f, -0.01680303f, 0.02864917f, 
    0.02654982f, -0.01669536f, 0.00456669f, -0.02440002f, -0.01950724f, 0.01748493f, 0.01352922f, 0.02156044f, 
    -0.01550329f, -0.02426363f, -0.00482692f, 0.01852445f, -0.04078341f, 0.00496297f, 0.00800089f, -0.02080212f, 
    -0.00785890f, 0.02985702f, 0.02818745f, -0.01873688f, -0.01911948f, 0.02290799f, -0.01512885f, -0.04028259f, 
    -0.03848082f, -0.03550099f, -0.04144363f, -0.03609664f, -0.02871583f, -0.01150016f, 0.00844774f, -0.02983390f, 
    0.01456062f, 0.00428621f, -0.04094491f, -0.00810171f, -0.00725971f, -0.00404150f, 0.02914611f, -0.00536802f, 
    -0.03407340f, 0.01515740f, 0.01472359f, -0.01993405f, -0.00024501f, -0.00473125f, -0.01812674f, 0.00193532f, 
    0.01633216f, -0.03874275f, -0.01905845f, -0.01268010f, 0.00258643f, -0.03444161f, -0.01951925f, -0.00947512f, 
    -0.01495629f, 0.03028801f, -0.04016338f, -0.00658846f, -0.01951217f, 0.03503408f, 0.01713353f, -0.01224968f, 
    0.01773270f, 0.01400656f, 0.00309569f, -0.00870535f, -0.01220693f, 0.02049948f, 0.02273032f, -0.04116746f, 
    0.00129788f, -0.00761478f, 0.03410062f, -0.04104435f, -0.03196620f, -0.01616229f, 0.02863120f, 0.02132240f, 
    0.00648972f, 0.03594061f, 0.01629421f, -0.03366086f, -0.02647079f, -0.00982946f, -0.04021863f, -0.01391006f, 
    -0.00763068f, 0.02805840f, 0.00402451f, -0.02648676f, 0.01092503f, 0.00139751f, -0.03569769f, 0.00360872f, 
    -0.00877634f, -0.03202863f, -0.00840782f, 0.02156200f, 0.02116997f, -0.03889310f, 0.03466604f, -0.01078830f, 
    -0.03324313f, -0.02506389f, 0.02600607f, 0.01868517f, -0.02350225f, 0.00344783f, 0.00777205f, 0.02456877f, 
    0.04161217f, 0.01737092f, -0.03482352f, 0.02689334f, -0.01899195f, -0.02022764f, -0.01142598f, 0.00376364f, 
    -0.00897459f, -0.03025351f, -0.00548292f, 0.00592608f, -0.01353787f, 0.01740027f, 0.01939303f, -0.02686079f, 
    -0.03922480f, -0.01881808f, 0.00542812f, -0.00249789f, -0.03950488f, 0.03409829f, -0.03807091f, -0.02648643f, 
    0.00192371f, 0.01645668f, -0.02498217f, -0.03950768f, 0.01018341f, -0.01104039f, 0.00092393f, -0.00615610f, 
    0.01011119f, -0.01907923f, 0.02621042f, 0.02167337f, -0.02141912f, -0.04010719f, -0.02133573f, -0.03808687f, 
    0.02030387f, -0.02140429f, 0.02415890f, 0.01697669f, -0.03539071f, -0.02560445f, -0.00222741f, -0.02687276f, 
    0.03404903f, -0.03229810f, -0.00684657f, -0.04049186f, 0.02494878f, -0.01997482f, -0.00046350f, -0.00268673f, 
    -0.03115059f, 0.02158814f, 0.00804061f, -0.03183342f, -0.03131726f, 0.02680849f, 0.01960548f, 0.00900459f, 
    0.02551816f, 0.01418251f, 0.00861307f, -0.02233047f, -0.04131029f, -0.00204035f, 0.01332973f, 0.00501785f, 
    -0.02273545f, 0.02861706f, 0.00195864f, -0.01134537f, -0.03999347f, -0.02942870f, 0.02915594f, 0.01164939f, 
    0.02358867f, -0.02469696f, 0.01577406f, 0.01415320f, -0.02271340f, -0.03119847f, -0.02939829f, -0.02710566f, 
    -0.00760044f, -0.03617212f, -0.04131530f, -0.04184413f, 0.01396512f, 0.00960383f, -0.02857596f, 0.01755966f, 
    -0.01137890f, -0.00049442f, 0.02658262f, 0.00559271f, -0.02272123f, 0.00104453f, 0.01958595f, -0.02434810f, 
    -0.02616392f, -0.03944438f, -0.03620704f, 0.02292132f, -0.03785229f, 0.02078014f, 0.00917574f, 0.01672252f, 
    -0.02974309f, -0.02036841f, -0.02893580f, -0.00797691f, -0.01342404f, 0.03014956f, -0.03070362f, 0.02645315f, 
    -0.00692371f, 0.00557273f, 0.00320041f, -0.03084031f, -0.02028402f, -0.01279466f, 0.00857592f, 0.02107693f, 
    -0.03584716f, 0.00532485f, 0.01328559f, -0.02255033f, 0.02710654f, -0.03194736f, 0.00458326f, -0.03198144f, 
    -0.01241710f, -0.00324499f, 0.02535449f, 0.02468314f, 0.02954689f, 0.01636853f, -0.03295328f, -0.00397733f, 
    0.03807784f, 0.01769054f, -0.03342962f, -0.02627549f, -0.04188288f, -0.03883107f, -0.02186112f, 0.01387557f, 
    0.01678116f, 0.02377351f, 0.01167181f, 0.02741651f, 0.02334269f, -0.03554485f, 0.02011605f, -0.03800567f, 
    -0.02256870f, -0.01579589f, -0.02191413f, 0.02283028f, 0.00575183f, -0.03672376f, -0.01745922f, -0.02085224f, 
    -0.03456846f, -0.03879641f, -0.03027085f, -0.02832497f, -0.03317241f, 0.00255356f, -0.00232550f, 0.01633379f, 
    -0.03599098f, 0.00178403f, 0.00953385f, -0.03366331f, 0.01391147f, -0.03348396f, -0.00071358f, -0.00787732f, 
    0.03033132f, -0.03676046f, 0.02452476f, 0.01829703f, 0.02713369f, 0.00491558f, 0.01193771f, -0.03529933f, 
    0.00187942f, -0.01168971f, -0.02256928f, -0.03607598f, 0.01973680f, -0.02624316f, -0.02589061f, -0.01969702f, 
    0.01516499f, 0.02033711f, -0.00066253f, 0.02915333f, 0.02300914f, -0.02743170f, -0.02205541f, -0.03815365f, 
    0.00240155f, -0.01972662f, -0.02728764f, 0.02842931f, 0.01096561f, 0.00412251f, -0.03080880f, -0.02159891f, 
    -0.01659438f, -0.02879777f, -0.01480265f, 0.02321298f, -0.02536037f, -0.02254704f, 0.02303441f, 0.00448558f, 
    0.01335460f, -0.02042734f, -0.03410362f, -0.01072586f, -0.01151136f, -0.00398047f, -0.02327151f, -0.00224609f, 
    0.02709360f, 0.01459516f, 0.00307948f, -0.02784695f, -0.00293436f, -0.00639836f, -0.01916895f, -0.01378142f, 
    0.02371663f, 0.01917375f, -0.00081609f, -0.03457029f, 0.00987866f, -0.01910681f, -0.00511175f, 0.01500923f, 
    -0.01577997f, -0.01789585f, -0.01332516f, -0.03168735f, -0.03994329f, -0.00544557f, -0.02775867f, -0.01042765f, 
    0.00930958f, -0.04002346f, -0.00798971f, -0.00169695f, -0.03959305f, -0.01709954f, -0.00032665f, -0.01634346f, 
    -0.01961932f, -0.03541096f, 0.00242132f, 0.01714402f, 0.00175865f, -0.02997815f, -0.00372475f, 0.01803778f, 
    -0.01100064f, -0.02314729f, 0.02840996f, 0.00380989f, 0.00617881f, -0.00742689f, 0.00839892f, 0.02819018f, 
    -0.03866777f, 0.02712915f, 0.01511847f, -0.02522608f, -0.00835914f, -0.03048024f, 0.00001738f, -0.03216601f, 
    0.02235746f, -0.01620091f, 0.01544702f, 0.01206486f, 0.02556160f, -0.03013694f, -0.01830216f, -0.00015387f, 
    0.00637070f, -0.02788210f, 0.02457517f, 0.01919489f, 0.02146825f, 0.01237969f, 0.02946896f, 0.00229034f, 
    0.00551908f, -0.02174935f, -0.00463822f, -0.00906936f, 0.02451280f, 0.00759537f, 0.00057058f, 0.00981933f, 
    -0.03011625f, 0.02982100f, 0.00116025f, 0.00249814f, -0.02283259f, -0.01907549f, 0.01391119f, 0.02770509f, 
    0.00628416f, 0.00921586f, 0.02119539f, -0.03141558f, -0.02821987f, 0.00051538f, 0.03045609f, -0.01090044f, 
    -0.03568411f, 0.01340091f, -0.01375381f, -0.03858035f, -0.02133016f, -0.03882575f, 0.00464688f, -0.03143134f, 
    0.01395928f, -0.01434003f, -0.02349028f, -0.00716806f, -0.03262461f, 0.02857942f, 0.01700083f, 0.01937301f, 
    0.00876221f, 0.01405330f, -0.00055099f, -0.00870756f, -0.02839303f, -0.00223350f, -0.01237033f, -0.00871140f, 
    -0.04198179f, -0.02267881f, 0.01088654f, -0.01287223f, 0.00430474f, -0.03019049f, -0.01026386f, -0.00527463f, 
    -0.01068917f, -0.01564608f, -0.01578015f, 0.00490305f, 0.01539190f, 0.01770545f, -0.01228501f, -0.03001878f, 
    -0.03820558f, -0.02941155f, 0.02466157f, 0.01397699f, -0.01556451f, 0.01020108f, -0.02655234f, -0.00793949f, 
    -0.00598549f, -0.01451682f, 0.00596217f, 0.02934948f, -0.03827253f, -0.00200486f, 0.01326619f, 0.01875504f, 
    0.02333866f, -0.02213824f, 0.01437881f, 0.02919818f, 0.00875027f, -0.00925362f, 0.00910943f, 0.00720408f, 
    -0.01811188f, 0.01647470f, 0.00187637f, -0.00390025f, 0.01599979f, 0.02439625f, 0.02844839f, 0.01221436f, 
    -0.03558873f, -0.00992864f, -0.03946734f, 0.00953716f, -0.02849912f, -0.02893647f, -0.00100281f, -0.03172925f, 
    -0.04118203f, 0.00781273f, -0.00103523f, -0.03993349f, -0.02997713f, -0.01415822f, -0.00268118f, -0.01916899f, 
    -0.01074628f, 0.00907955f, 0.01887722f, -0.00743860f, 0.02794545f, -0.01107515f, 0.02848503f, -0.03796681f, 
    -0.00869112f, -0.01331108f, -0.01321765f, -0.01394911f, 0.02199298f, -0.03827243f, 0.01186099f, -0.02075031f, 
    -0.01583498f, 0.02674768f, 0.03052860f, 0.00336295f, 0.00495051f, 0.01875283f, 0.02992174f, -0.03387302f, 
    -0.00781056f, 0.04134830f, 0.00362386f, 0.00623626f, 0.00887866f, -0.02588691f, 0.02360933f, 0.00492220f, 
    0.00235009f, -0.03517692f, -0.02426719f, 0.02409883f, -0.04105721f, 0.00151855f, -0.00410234f, -0.01777085f, 
    -0.01991040f, -0.03180377f, 0.01694175f, 0.01938723f, 0.00062017f, -0.00172821f, -0.01132588f, 0.00195729f, 
    -0.01508008f, -0.00202860f, 0.01822653f, -0.01186265f, -0.00701150f, -0.03325676f, 0.01023606f, -0.03912964f, 
    -0.01816977f, 0.00978258f, 0.03867237f, -0.03868775f, -0.02639675f, 0.01101150f, 0.02197386f, -0.00489333f, 
    -0.00226966f, 0.01512546f, -0.02152591f, -0.00134463f, 0.00369318f, -0.01221356f, 0.01214868f, 0.00767737f, 
    -0.02890985f, 0.00421680f, -0.03499973f, 0.01380274f, -0.03873833f, 0.02816645f, -0.00222723f, -0.03111125f, 
    0.00674083f, -0.03264690f, -0.04046569f, -0.01186079f, 0.01096372f, 0.02370468f, 0.01672027f, -0.03655116f, 
    0.02526070f, -0.02460029f, 0.02581317f, -0.03644359f, 0.00889842f, -0.00854339f, -0.00193980f, 0.01201422f, 
    -0.03015208f, 0.01328505f, 0.01563290f, -0.00124596f, 0.00597792f, 0.02015432f, -0.00913617f, -0.00880490f, 
    -0.00859364f, -0.03110539f, 0.00178314f, 0.01870969f, 0.02346776f, -0.01122408f, -0.04182225f, 0.03246979f, 
    0.00570689f, 0.00208895f, -0.03483039f, -0.02516525f, -0.01744350f, 0.00678241f, -0.03900981f, -0.03798391f, 
    -0.00165215f, 0.01530465f, -0.02847892f, -0.02999730f, 0.00691104f, -0.03751001f, 0.01051650f, -0.01425814f, 
    -0.00168545f, 0.00379093f, 0.00948649f, -0.01946439f, 0.01310866f, -0.03736393f, 0.00335418f, 0.00674993f, 
    0.00517778f, -0.03298447f, 0.03202954f, 0.02292681f, -0.02606886f, -0.00732333f, 0.01348318f, 0.00050486f, 
    -0.00145539f, 0.01588901f, 0.01161591f, -0.00453586f, 0.01642819f, 0.00766402f, -0.02257838f, 0.00959727f, 
    -0.00919090f, 0.00037766f, -0.02783433f, -0.03125647f, 0.01988802f, -0.01153883f, -0.02222065f, -0.00173817f, 
    -0.03315476f, 0.01575335f, 0.00136301f, 0.01532109f, 0.01083204f, -0.01308863f, -0.03867957f, 0.01533080f, 
    0.02436190f, -0.02908724f, 0.02938317f, 0.02825722f, 0.01177232f, -0.03548966f, -0.01862812f, -0.01077134f, 
    0.00547062f, 0.02814055f, -0.03313625f, -0.00776060f, -0.00609520f, -0.01475929f, -0.02933506f, -0.03226980f, 
    -0.01504268f, -0.00969848f, 0.02443506f, 0.00764861f, -0.03366139f, -0.02743507f, -0.00480781f, -0.03401526f, 
    -0.00886879f, -0.02292440f, -0.02238084f, 0.00079851f, -0.01979776f, 0.02190567f, -0.00858754f, 0.02158936f, 
    -0.00287969f, -0.01317831f, 0.00950123f, -0.03074519f, 0.00144708f, -0.01295503f, -0.03096054f, -0.00023832f, 
    -0.02161222f, 0.01787139f, -0.00246312f, -0.01221592f, -0.01306933f, -0.03845265f, 0.02928328f, -0.00181904f, 
    -0.01128706f, 0.02010791f, 0.02884531f, -0.03898270f, -0.01157982f, -0.01962694f, -0.01752848f, -0.03840787f, 
    -0.03727253f, 0.02043723f, 0.03343772f, 0.01412121f, 0.01653736f, 0.01083264f, -0.03452830f, 0.00220550f, 
    0.00195616f, -0.00916403f, -0.02609825f, 0.03098621f, -0.00372840f, -0.00806228f, 0.01596208f, -0.01295784f, 
    -0.01668931f, -0.03232381f, 0.02729278f, 0.00482224f, 0.02605011f, 0.01758584f, -0.01696261f, 0.02518009f, 
    -0.00354274f, -0.01840088f, -0.01760248f, 0.01278281f, -0.00960919f, -0.00839053f, 0.00122375f, 0.00778246f, 
    -0.00466310f, 0.00628741f, -0.00349371f, 0.00453930f, 0.00893075f, -0.00147302f, 0.02249885f, 0.00817804f, 
    -0.01682149f, -0.01316308f, -0.00098337f, 0.03140898f, 0.01472242f, 0.02296855f, 0.01268447f, -0.00267411f, 
    -0.00372323f, 0.02143444f, -0.03170836f, -0.02050641f, 0.02191436f, -0.00659119f, -0.03003405f, -0.01962065f, 
    -0.01911021f, -0.01547330f, 0.01839558f, -0.01110624f, -0.03757283f, 0.01605302f, 0.00557777f, -0.02689539f, 
    -0.01897950f, -0.00183247f, 0.01690956f, -0.00421297f, -0.02467668f, -0.01116716f, 0.03602295f, -0.01305036f, 
    -0.01693581f, 0.00922668f, 0.01529991f, -0.02524634f, 0.00793849f, 0.02645311f, -0.01299218f, 0.02751146f, 
    0.00968213f, -0.01293932f, -0.03291350f, 0.01202648f, 0.00202815f, -0.02277389f, -0.03857008f, 0.02014558f, 
    -0.00386948f, 0.02327180f, -0.02014486f, -0.03233306f, 0.01796711f, -0.04128228f, 0.00429928f, 0.02375364f, 
    -0.02844588f, -0.01446282f, 0.00350662f, -0.03511092f, -0.00662114f, 0.00226724f, 0.03251226f, 0.00062116f, 
    -0.03882075f, -0.02259937f, 0.02920435f, 0.00936801f, -0.02315290f, -0.02507336f, -0.02484196f, -0.00629708f, 
    0.02283687f, -0.00189242f, -0.01770516f, 0.00450769f, 0.00337972f, 0.00597750f, 0.02066503f, -0.02717745f, 
    -0.02927539f, 0.01239239f, -0.01991566f, 0.00155055f, 0.00001597f, 0.01021031f, 0.02993213f, -0.00502858f, 
    -0.00493490f, -0.03828177f, -0.00122228f, 0.00096994f, -0.03762818f, -0.00274143f, 0.00242370f, -0.03388353f, 
    -0.01614699f, -0.01284462f, 0.01344619f, 0.02822118f, -0.02484983f, -0.03096891f, 0.02584204f, 0.01638542f, 
    -0.04205975f, -0.01212972f, 0.02329261f, -0.04174581f, -0.03071908f, -0.02644337f, 0.02291095f, -0.00944027f, 
    0.02248093f, 0.02212541f, 0.01503056f, 0.04040375f, 0.00487956f, 0.01498611f, -0.03908705f, -0.00613871f, 
    -0.02489132f, 0.00614215f, -0.00093988f, 0.01970912f, 0.01466824f, 0.01283745f, 0.02827654f, -0.00240495f, 
    0.03275041f, 0.00549635f, -0.03047034f, -0.00336627f, -0.02760902f, 0.01387513f, -0.01701574f, 0.01963989f, 
    -0.00453387f, -0.03439309f, -0.01327539f, -0.02630897f, -0.02945387f, 0.01282666f, -0.02127211f, 0.01574590f, 
    0.02267646f, -0.04027725f, 0.01819339f, 0.01340501f, -0.02830257f, -0.00484415f, 0.00810734f, -0.04372861f, 
    -0.00884933f, 0.00915475f, 0.02709873f, -0.00627526f, -0.01088634f, 0.01883577f, 0.01169203f, -0.01843720f, 
    -0.03728167f, -0.02386072f, -0.02354440f, -0.01916274f, 0.01725552f, -0.00949041f, -0.00398149f, -0.03769703f, 
    0.00371652f, -0.01593691f, -0.01854642f, 0.02072705f, -0.03361903f, 0.01189564f, -0.01804554f, -0.03558835f, 
    0.01275370f, -0.00349960f, 0.03106605f, 0.01054217f, -0.02652482f, 0.01638542f, -0.00652563f, 0.01950846f, 
    0.01044965f, -0.00439910f, 0.01046858f, -0.00018114f, 0.02234467f, 0.01717464f, -0.02763064f, 0.03148866f, 
    -0.03411955f, -0.00615922f, -0.00688039f, -0.04173970f, 0.00316351f, -0.03270818f, 0.00381480f, -0.02589790f, 
    0.00611032f, -0.00444466f, -0.02029128f, 0.01065481f, -0.00358931f, -0.03534419f, -0.01892254f, -0.01739935f, 
    0.02505023f, 0.00443414f, -0.00622523f, 0.01434305f, 0.00592387f, -0.01808953f, 0.00875604f, -0.03492457f, 
    -0.00313104f, 0.03820115f, 0.00887140f, -0.02563135f, 0.01125793f, 0.02594946f, 0.02663429f, -0.01630234f, 
    0.02210063f, -0.02626986f, 0.01338864f, -0.00294753f, 0.00766255f, 0.01516180f, -0.02193439f, -0.00822376f, 
    0.01923037f, 0.01919559f, -0.03740795f, 0.02090085f, -0.03161696f, -0.03682749f, 0.02472694f, -0.00521412f, 
    0.00161220f, -0.02278407f, -0.01015858f, 0.02087653f, 0.01859216f, -0.01189387f, 0.00559726f, 0.00549647f, 
    0.02154011f, -0.02731100f, -0.03583394f, 0.02637580f, 0.00233228f, -0.02767212f, -0.02317232f, -0.03244216f, 
    0.00314192f, 0.02235913f, 0.00158786f, -0.02162133f, -0.03492967f, 0.03266655f, -0.01923162f, 0.02988949f, 
    -0.03454818f, 0.00150644f, -0.00925821f, -0.03104600f, 0.02332195f, -0.02298828f, 0.00007186f, 0.02275651f, 
    -0.00641094f, -0.01857833f, -0.04263882f, 0.00918929f, -0.01083084f, -0.00406489f, 0.01391701f, 0.02239720f, 
    -0.03220361f, 0.01567454f, 0.01248754f, -0.03663447f, -0.01622202f, -0.01781658f, 0.02559802f, -0.03183025f, 
    0.00775399f, -0.03544572f, -0.01448105f, -0.00032358f, 0.01184010f, 0.02982595f, 0.01237576f, -0.00811923f, 
    -0.03477204f, 0.00513959f, 0.01379153f, 0.00181581f, -0.03730698f, 0.02171258f, -0.00112832f, -0.01653065f, 
    0.03077332f, 0.01978661f, 0.00222189f, -0.00722496f, -0.00191267f, 0.00973525f, 0.01449496f, 0.02992459f, 
    0.00072975f, 0.00493442f, -0.01309218f, -0.00229007f, -0.03246634f, -0.03505251f, -0.01243305f, 0.01575386f, 
    0.00127634f, -0.02587818f, -0.02436058f, -0.00613999f, -0.00109018f, -0.00751802f, -0.00548367f, -0.04201993f, 
    -0.01523827f, 0.00788672f, -0.03514652f, -0.01427516f, -0.02052875f, -0.00065339f, -0.01496732f, -0.01064308f, 
    -0.03098700f, -0.02077791f, 0.02281042f, -0.03120011f, -0.02163688f, -0.01816670f, 0.00645981f, -0.00044875f, 
    0.00917561f, 0.02238526f, -0.01181303f, 0.02320515f, 0.01462194f, -0.03212090f, 0.01046781f, -0.02336721f, 
    0.02762229f, -0.03133503f, -0.01359941f, 0.01964602f, -0.04065028f, 0.00862064f, 0.02480318f, -0.03672773f, 
    -0.02171926f, 0.00232315f, -0.02045717f, 0.02419973f, -0.00870455f, 0.01554086f, 0.00359997f, 0.01087622f, 
    -0.02260943f, -0.01517693f, 0.02751107f, -0.02292426f, 0.02356958f, 0.02821581f, 0.02732397f, 0.01485320f, 
    -0.00064872f, 0.02650254f, 0.01826070f, 0.00209485f, 0.00883315f, 0.02560151f, -0.00573469f, 0.00713001f, 
    -0.00259630f, 0.02218413f, 0.00948717f, 0.02191810f, -0.03227370f, -0.03409452f, -0.04094768f, -0.02593006f, 
    -0.00915610f, 0.02230402f, 0.00802302f, -0.00740001f, 0.02100172f, -0.00145771f, 0.01169585f, -0.03092843f, 
    -0.01775143f, -0.02450907f, -0.03286959f, -0.02677706f, 0.02629744f, -0.00733145f, 0.00100462f, -0.01854247f, 
    0.01018489f, -0.02977885f, 0.01963200f, 0.01741563f, 0.00898534f, -0.01968548f, -0.00821061f, -0.03270407f, 
    0.01335258f, -0.02834164f, -0.02229578f, 0.02790820f, -0.01644559f, -0.02301079f, 0.02247849f, -0.03510195f, 
    -0.01110867f, 0.01558054f, -0.01480170f, -0.01568646f, -0.00736706f, 0.00753664f, -0.01232996f, -0.00418516f, 
    0.00459748f, 0.00858763f, -0.00983179f, -0.03652342f, 0.01719625f, 0.02495287f, -0.02590896f, 0.01117944f, 
    0.03025831f, -0.02761772f, -0.01530495f, 0.01210718f, -0.01266359f, -0.01878566f, -0.01633322f, -0.00091403f, 
    0.02793221f, 0.02502732f, 0.00802299f, -0.02084159f, 0.00689522f, 0.02393173f, -0.01234942f, -0.01137428f, 
    -0.02601163f, 0.02671850f, -0.00490849f, 0.02251822f, -0.03826622f, 0.01700995f, 0.01476742f, 0.01509304f, 
    0.01517236f, 0.00825925f, 0.01490453f, 0.00131459f, 0.01698915f, 0.00719267f, -0.00577365f, 0.03101427f, 
    -0.03165938f, -0.01294386f, 0.03550928f, 0.01210640f, 0.01749467f, 0.00308549f, 0.02804354f, 0.02974317f, 
    -0.01054563f, 0.01308089f, -0.02297958f, -0.03489012f, -0.01738258f, -0.03723481f, 0.01826666f, 0.00116994f, 
    0.01398363f, 0.00770515f, -0.00490271f, 0.02521898f, 0.00310228f, -0.03190352f, 0.02696504f, -0.01240308f, 
    -0.00113327f, 0.02880532f, 0.00478908f, -0.03901927f, -0.03190983f, -0.02685090f, 0.01344612f, 0.01439880f, 
    -0.00567689f, -0.01180768f, 0.02212071f, -0.02000713f, 0.02889796f, -0.00057991f, -0.01824936f, 0.01613891f, 
    -0.02578870f, 0.02539891f, 0.00641086f, 0.01188137f, -0.04122447f, -0.00551884f, 0.00547759f, 0.00355295f, 
    0.01847278f, -0.00793627f, -0.02667645f, 0.02436367f, 0.00136636f, -0.01205191f, -0.03395589f, 0.02161596f, 
    -0.02132165f, -0.01591882f, -0.02464432f, -0.02839020f, 0.02120906f, 0.00752954f, 0.02059338f, -0.00893032f, 
    -0.00048803f, 0.01518632f, 0.00590783f, 0.01055470f, 0.01349476f, -0.03391481f, -0.03677350f, 0.00518299f, 
    -0.01663283f, -0.02737688f, 0.00612300f, -0.04089606f, -0.02893262f, 0.00852284f, 0.02864889f, -0.03260745f, 
    -0.00416939f, -0.01879078f, 0.03087910f, 0.02561610f, -0.03535934f, -0.00479580f, 0.00328747f, 0.01899159f, 
    -0.01902115f, 0.02732617f, 0.01146863f, -0.03663834f, -0.00038418f, -0.02357452f, -0.00675283f, -0.00597148f, 
    -0.01535612f, -0.00502095f, 0.01947105f, -0.01000896f, -0.04038769f, 0.00022539f, 0.02140601f, 0.01245108f, 
    -0.00275127f, -0.02285478f, -0.02184473f, 0.00689175f, -0.00841769f, 0.02134009f, -0.03760788f, 0.00767510f, 
    -0.04036802f, 0.00728549f, 0.01142758f, 0.00297306f, -0.01631363f, 0.01806929f, -0.02454113f, -0.03297260f, 
    0.02537072f, -0.00073529f, 0.00819435f, 0.00895093f, 0.00215315f, 0.02603862f, 0.02933671f, -0.02265945f, 
    -0.02169637f, -0.00563308f, 0.00125355f, -0.02811023f, -0.01987833f, -0.01220001f, 0.01042147f, 0.01279935f, 
    0.03042567f, -0.00500080f, -0.00931593f, -0.03807698f, 0.01839061f, -0.03191925f, 0.02528070f, 0.01705010f, 
    -0.16749352f, -0.11279912f, -0.02249954f, -0.01803627f, -0.08359250f, 0.07718145f, 0.05174991f, -0.00088010f, 
    0.06070060f, -0.01069916f, -0.01633991f, -0.05658179f, -0.15036631f, -0.10648564f, -0.01141564f, 0.07473650f, 
    0.12043717f, 0.05856935f, 0.01862948f, 0.22561625f, -0.00846126f, -0.06346776f, -0.05619925f, -0.06864131f, 
    -0.01098943f, -0.03495499f, 0.19146968f, 0.19128612f, 0.00151613f, -0.02682453f, -0.05602007f, -0.04652360f, 
    -0.07478048f, 0.07036454f, 0.02923486f, 0.07436714f, -0.08774032f, 0.08574309f, 0.20600294f, -0.08679549f, 
    0.11724788f, -0.03478981f, 0.09884571f, 0.02255639f, -0.01954508f, -0.02101836f, 0.15540227f, 0.12933244f, 
    0.22336000f, 0.01835743f, -0.11451334f, -0.14859872f, 0.07575930f, -0.00980822f, 0.05563045f, 0.01099513f, 
    0.15252751f, 0.04541365f, -0.03392941f, -0.00281213f, 0.21173662f, -0.12642004f, -0.00138106f, 0.24912140f, 
    -0.05438082f, 0.01633913f, 0.04047035f, -0.02239800f, -0.07902162f, -0.23030294f, -0.04981156f, 0.01733961f, 
    -0.31374547f, -0.01704619f, 0.04997760f, -0.07987412f, 0.03777436f, 0.03814345f, -0.03584789f, 0.08515208f, 
    0.00309467f, -0.04660498f, 0.01544535f, -0.05208240f, 0.01064910f, -0.11643054f, 0.01441949f, -0.09176534f, 
    0.02954439f, 0.03627701f, 0.06445151f, 0.03369204f, 0.00955177f, -0.10684214f, 0.18664755f, -0.01168759f, 
    -0.30313152f, 0.08525655f, -0.01438348f, 0.03737598f, 0.03247600f, -0.04415916f, 0.04377646f, 0.05409466f, 
    0.01030948f, 0.16449678f, 0.23277847f, -0.14820130f, 0.02855872f, 0.07930925f, -0.04980130f, 0.10613651f, 
    0.20925879f, 0.11037793f, 0.01063075f, 0.00826065f, 0.01011549f, 0.13260277f, 0.07851735f, -0.07615113f, 
    -0.02194487f, 0.00997407f, 0.16336879f, -0.16338815f, 0.00761078f, -0.03319005f, 0.04827971f, -0.01084411f, 
    -0.03708446f, 0.02904425f, -0.03802174f, 0.04045511f, 0.03674074f, -0.05895174f, 0.08385924f, 0.08703976f, 
    0.06860570f, 0.05970934f, 0.09251984f, -0.01022667f, -0.07954452f, 0.09974700f, 0.01118897f, 0.06292110f, 
    -0.37915975f, -0.07834279f, -0.00589568f, -0.15032201f, 0.04359523f, 0.03100224f, 0.02401200f, -0.01933565f, 
    -0.02654493f, 0.09844468f, -0.00452843f, -0.13081197f, -0.06425906f, -0.07459895f, 0.00252508f, -0.11440312f, 
    0.15018670f, 0.08202965f, -0.00663405f, 0.12773892f, 0.05771413f, 0.00277972f, 0.03051390f, -0.11417858f, 
    0.17676076f, 0.01320442f, -0.04485383f, 0.20112349f, 0.09930360f, -0.02104627f, -0.14692937f, -0.08107352f, 
    0.01011504f, 0.15078658f, 0.04814499f, 0.12377105f, 0.33468872f, 0.13610484f, -0.01282281f, 0.17959629f, 
    0.04256987f, -0.01378133f, 0.07030264f, 0.04268431f, 0.05586987f, -0.00439738f, 0.13913760f, -0.24222606f, 
    -0.15964919f, 0.18949485f, 0.23597308f, 0.09198872f, 0.08739118f, 0.00333532f, 0.10776312f, 0.02848340f, 
    -0.01996399f, -0.03308012f, -0.02404570f, -0.00401945f, 0.06690907f, -0.02711004f, 0.01304674f, 0.18600081f, 
    0.10504281f, -0.00754001f, -0.06972306f, -0.09236296f, 0.02904058f, -0.07722325f, 0.08263332f, -0.09483842f, 
    0.18268107f, 0.11438066f, 0.04423144f, -0.01921687f, 0.12955381f, 0.01380325f, -0.03723368f, -0.03196403f, 
    0.06020873f, -0.00861929f, -0.03972718f, -0.01865149f, 0.06522498f, 0.22240737f, -0.00676938f, 0.08165070f, 
    0.08389673f, -0.01433348f, -0.14316601f, 0.13461897f, -0.01589760f, 0.06855713f, 0.05433603f, -0.04626787f, 
    -0.13590674f, 0.02267908f, -0.15769105f, -0.05713288f, 0.01417268f, 0.07116783f, 0.02902166f, -0.10786841f, 
    -0.09598805f, 0.09546407f, 0.09081354f, 0.05095813f, -0.24713261f, -0.04804480f, 0.07752312f, 0.11252462f, 
    0.11452323f, -0.03934231f, -0.05011389f, 0.02907699f, 0.01683335f, -0.13578704f, 0.12167548f, 0.17042257f, 
    -0.07428929f, -0.07646225f, 0.04480930f, 0.03407602f, -0.02818047f, -0.02533995f, 0.05673074f, -0.02468487f, 
    0.02785463f, 0.04727988f, 0.05887734f, -0.07570949f, 0.20729095f, 0.19095427f, -0.03634606f, -0.04389734f, 
    -0.07177417f, 0.24608558f, 0.01134975f, 0.07245865f, 0.13968764f, -0.00952260f, 0.04772096f, 0.18277636f, 
    -0.00725437f, -0.00123402f, 0.02084630f, 0.02825028f, -0.06705128f, 0.06745774f, 0.06668205f, -0.01664355f, 
    0.06279475f, 0.05954594f, 0.10392074f, 0.17258793f, 0.03805582f, -0.05542070f, 0.15599863f, 0.19886343f, 
    -0.00955617f, 0.02960041f, 0.07937612f, 0.06269000f, 0.03048890f, 0.06771918f, 0.04547957f, 0.03846241f, 
    0.34695730f, 0.02052183f, -0.02352848f, 0.08671000f, 0.06077024f, 0.10979607f, 0.00508275f, -0.07431662f, 
    0.07052443f, 0.00946206f, 0.09174535f, -0.16499485f, -0.45951894f, -0.11937293f, 0.04524098f, -0.14412649f, 
    0.04469732f, 0.07240325f, 0.21668410f, -0.03128306f, 0.10681116f, 0.05294187f, 0.04457400f, 0.08747733f, 
    0.01150726f, -0.23961060f, 0.09398736f, -0.03295840f, 0.16889800f, -0.20129444f, -0.04216141f, -0.27204111f, 
    -0.00070723f, 0.03299115f, -0.12107214f, 0.00759804f, 0.16120081f, -0.08562848f, -0.12851770f, 0.01400263f, 
    0.12108998f, -0.02213053f, -0.03383927f, -0.03088821f, -0.07864077f, -0.16405205f, 0.01979333f, -0.12992416f, 
    0.10751403f, 0.15474775f, 0.20666008f, 0.00151631f, 0.18799090f, 0.13667983f, 0.11966771f, 0.10330883f, 
    0.08953578f, 0.09944567f, 0.07832768f, 0.11128614f, -0.01679549f, 0.07721567f, 0.02725820f, -0.13194653f, 
    -0.06724064f, -0.00606876f, 0.02574618f, 0.02521977f, -0.01076977f, 0.05270376f, 0.16303350f, 0.03930739f, 
    0.13969779f, -0.04612941f, 0.03014556f, 0.22599033f, 0.04965051f, -0.00477731f, 0.01094406f, -0.03472854f, 
    -0.02034911f, 0.09969820f, -0.00828158f, 0.24504648f, 0.09831849f, 0.06355261f, 0.03670650f, 0.12488662f, 
    0.02850638f, 0.00549452f, 0.01096556f, 0.22965135f, -0.04751484f, 0.15879688f, -0.00882204f, -0.07432358f, 
    0.10622358f, 0.03026946f, -0.10781772f, 0.21867488f, -0.01670584f, -0.07292700f, -0.02824199f, -0.02185760f, 
    0.01051877f, 0.19752632f, 0.01396068f, 0.00892698f, 0.15518394f, -0.14405093f, -0.07427131f, 0.11350065f, 
    -0.00141842f, -0.03730583f, -0.06226186f, 0.09496663f, 0.01666385f, 0.04280697f, 0.22483191f, -0.06693909f, 
    0.56786937f, -0.01685331f, 0.08173083f, 0.04534525f, 0.06650680f, -0.05606526f, -0.05643616f, -0.07022700f, 
    -0.06576257f, -0.07414366f, -0.01858556f, -0.01735867f, -0.01157761f, -0.02473149f, 0.13629380f, 0.02367689f, 
    0.09176708f, 0.03872923f, 0.01923634f, 0.12209539f, -0.02591292f, 0.02793717f, 0.14342797f, 0.03142953f, 
    0.01276057f, 0.15508571f, 0.08098692f, -0.03037643f, -0.03411167f, 0.14437813f, -0.11948548f, -0.09965031f, 
    -0.04963502f, 0.00138045f, -0.02896718f, -0.04848683f, 0.22614215f, 0.12078194f, 0.07214145f, -0.17525458f, 
    0.02685256f, -0.00045170f, -0.00262382f, -0.01297091f, 0.06773847f, -0.08059526f, 0.19585374f, 0.02663649f, 
    0.17315368f, 0.10131370f, 0.00367698f, 0.19819687f, -0.00308967f, -0.01006757f, -0.06007108f, -0.03685972f, 
    -0.07507432f, -0.06863286f, -0.15785162f, -0.27441671f, -0.17255674f, -0.13500459f, 0.05871911f, -0.13971946f, 
    0.03205069f, -0.04883273f, -0.05318959f, 0.02515397f, -0.10742373f, 0.19422527f, 0.02723000f, -0.00693425f, 
    -0.18149941f, -0.01742301f, -0.04868345f, -0.18788692f, -0.09504471f, -0.11154875f, -0.01297374f, 0.05870491f, 
    -0.01040191f, 0.06919206f, 0.04830942f, -0.06162464f, -0.04735777f, 0.03395177f, 0.02868397f, -0.10117011f, 
    -0.05321364f, -0.01283832f, 0.00050647f, -0.06530593f, 0.06558415f, 0.01176877f, 0.05796390f, 0.07887736f, 
    -0.16723159f, -0.12644976f, -0.15173784f, -0.07861978f, 0.08853512f, -0.05417070f, -0.06875782f, -0.00114585f, 
    -0.01879243f, -0.05740580f, 0.07591189f, 0.14950940f, 0.03754546f, -0.08284557f, -0.03707296f, 0.01971197f, 
    0.04060866f, 0.05223861f, 0.03775401f, 0.14360623f, -0.04601944f, 0.15428630f, -0.06603762f, 0.28320661f, 
    0.27876210f, 0.04238072f, 0.03758444f, -0.24817514f, -0.07260634f, -0.22120766f, 0.24730052f, 0.10646570f, 
    0.01830364f, -0.09805652f, 0.16572027f, -0.04777877f, 0.33960566f, -0.04908351f, 0.03732239f, 0.01853841f, 
    0.06925017f, -0.11203611f, -0.13382204f, 0.02803037f, 0.15062563f, -0.10813512f, 0.04790687f, 0.09395340f, 
    -0.05547587f, -0.00215197f, 0.10648644f, -0.06288532f, 0.08306047f, 0.10734689f, 0.06310578f, 0.06939802f, 
    0.19573081f, 0.06199739f, -0.03429723f, 0.04988704f, -0.51192033f, -0.12472689f, -0.24993293f, -0.09868968f, 
    0.11948469f, -0.05123707f, -0.03565643f, 0.01315280f, 0.08498805f, -0.09474539f, 0.10673591f, -0.17569867f, 
    -0.33686805f, -0.05571641f, 0.10774913f, -0.05552448f, 0.05539780f, -0.06811099f, 0.19978878f, -0.13503979f, 
    0.02865193f, 0.00213254f, 0.02697064f, 0.00317589f, 0.20357667f, 0.11757078f, -0.03802935f, 0.04695762f, 
    0.07528988f, 0.06028919f, -0.08490190f, 0.04944636f, 0.02042144f, 0.07336686f, 0.05874667f, 0.11901791f, 
    0.26998237f, 0.23974308f, 0.14055069f, 0.08210863f, -0.00930503f, 0.10578822f, -0.00608908f, -0.10330426f, 
    -0.10988222f, 0.02899303f, -0.04648526f, -0.08487941f, -0.02241955f, 0.22873758f, -0.07641996f, 0.16861692f, 
    0.26810449f, 0.14757156f, -0.05674484f, -0.13926546f, -0.02214825f, -0.08508526f, 0.00237941f, 0.01536284f, 
    0.29960898f, -0.08185238f, -0.12974185f, -0.04304495f, 0.03739245f, 0.01447229f, -0.09499204f, 0.07394656f, 
    0.04638148f, -0.12759688f, 0.01317751f, -0.06227350f, -0.08209810f, -0.03019766f, 0.04677392f, -0.06635418f, 
    0.11340046f, -0.08593386f, 0.07588420f, -0.04126929f, 0.06908660f, 0.01191159f, 0.11216363f, 0.18386927f, 
    0.23396996f, -0.06829367f, -0.16470815f, 0.12658195f, 0.05791626f, -0.17385773f, 0.06500939f, -0.18433648f, 
    0.12792538f, 0.03981058f, 0.08099827f, 0.07345093f, -0.06718051f, -0.01458528f, 0.04585263f, -0.04089125f, 
    -0.08581319f, -0.12212883f, 0.01622866f, -0.04536653f, 0.04860595f, -0.20080498f, 0.01241517f, -0.07451049f, 
    0.06257636f, 0.01537934f, -0.06571891f, 0.14943494f, 0.01823653f, 0.00545835f, -0.09859144f, 0.16726899f, 
    -0.02302937f, -0.10328701f, 0.01677002f, 0.07641225f, 0.21796513f, -0.12941307f, 0.04295387f, -0.04281927f, 
    0.07930991f, -0.11293819f, 0.06140409f, -0.10261916f, -0.01581055f, 0.04571065f, -0.02160380f, 0.05567827f, 
    -0.27767164f, 0.06307252f, -0.12277451f, 0.18320739f, -0.02428256f, 0.00718283f, 0.06226284f, -0.03157362f, 
    0.08435398f, 0.07148924f, -0.05907230f, 0.06171668f, 0.19065830f, -0.12566265f, 0.06936179f, -0.09012464f, 
    -0.02551117f, 0.06886057f, -0.04614292f, 0.10279857f, -0.05531488f, 0.14211467f, 0.04343427f, -0.08277729f, 
    -0.48293296f, -0.17877886f, 0.29858574f, -0.08067208f, -0.09056085f, -0.04123729f, -0.05338449f, -0.01380693f, 
    0.02088490f, 0.03399853f, 0.04015639f, -0.12535192f, -0.05544312f, -0.02963664f, -0.02122783f, 0.03522664f, 
    0.20083515f, -0.05189238f, 0.01583865f, -0.14861214f, 0.08866841f, -0.09836546f, -0.12075442f, -0.10927698f, 
    0.27834386f, 0.00047205f, 0.14445581f, 0.22061300f, 0.17905539f, 0.09914304f, 0.05471161f, -0.06029457f, 
    0.16705999f, 0.01643269f, 0.07963444f, -0.05884259f, -0.01404380f, -0.05070530f, -0.05795834f, 0.06595816f, 
    0.05298771f, 0.01659450f, 0.02278339f, -0.01243063f, 0.16346465f, 0.05774517f, -0.00771131f, 0.01801842f, 
    0.12236012f, -0.48641244f, -0.12191804f, 0.23413076f, 0.01702893f, -0.04297971f, -0.03216372f, -0.03853120f, 
    -0.00284761f, -0.02402977f, -0.04517969f, -0.01299963f, -0.05467213f, -0.02991730f, 0.00435900f, -0.23738357f, 
    -0.10936847f, 0.04174830f, 0.02087259f, 0.04760396f, -0.08554474f, -0.01392022f, 0.03045700f, 0.10004878f, 
    0.14005320f, -0.02146730f, 0.08726627f, -0.07730512f, -0.12099096f, -0.00232827f, 0.12150695f, -0.03623797f, 
    0.03344915f, -0.04182366f, 0.08774561f, 0.05749289f, -0.09276073f, -0.18398453f, -0.12059985f, 0.12250880f, 
    0.10033681f, -0.03097957f, 0.12926075f, -0.06383613f, 0.03728082f, -0.05613664f, 0.02509609f, 0.04313154f, 
    0.04507556f, -0.01131321f, -0.07144584f, -0.14646041f, 0.11934294f, 0.06224654f, 0.08182625f, 0.07099250f, 
    0.04204714f, -0.04236465f, 0.00112024f, 0.00744446f, 0.06812830f, -0.09197091f, 0.04439662f, 0.14353731f, 
    0.09637827f, 0.04029391f, 0.02603452f, 0.03639073f, 0.03326467f, -0.11492773f, 0.07093247f, 0.00261646f, 
    -0.03439662f, 0.04366073f, -0.12456870f, -0.21422553f, -0.02463203f, 0.00022780f, -0.02115273f, 0.03893223f, 
    0.09237371f, 0.02750706f, 0.07162560f, 0.05876664f, -0.13058051f, -0.18479137f, -0.17241268f, -0.23236327f, 
    -0.03787829f, -0.06560554f, -0.15555097f, -0.01643200f, 0.02382696f, -0.00717007f, 0.05590416f, -0.08279288f, 
    -0.03586750f, 0.10474028f, 0.18460529f, -0.18311067f, 0.11398051f, 0.00135478f, 0.00744339f, 0.09996349f, 
    0.08247956f, 0.00957220f, -0.02415771f, 0.05836766f, 0.16063130f, -0.10873856f, -0.17862202f, 0.00899404f, 
    0.12499434f, 0.16907458f, 0.02871594f, -0.05504053f, 0.04985129f, 0.00986252f, 0.02969182f, 0.04543453f, 
    0.15956070f, -0.29967272f, 0.21463998f, 0.37241966f, 0.00202355f, -0.08082465f, 0.07579173f, 0.01586442f, 
    0.00775680f, 0.08798771f, -0.01504480f, -0.09852643f, -0.00209041f, 0.01098324f, 0.05690968f, -0.21235828f, 
    0.00130917f, 0.01514587f, -0.05806394f, 0.04300875f, 0.03537270f, 0.09689397f, 0.07725231f, 0.11653168f, 
    -0.01144600f, -0.28069043f, -0.11359903f, 0.04134859f, 0.04313358f, 0.00118881f, -0.05638520f, -0.00528822f, 
    -0.08464093f, 0.10115869f, 0.00596156f, -0.00154258f, -0.09758136f, 0.10212512f, -0.10430779f, 0.08403443f, 
    -0.03916807f, 0.08812195f, 0.07345450f, 0.14760217f, 0.15256222f, 0.00129748f, -0.10055142f, -0.10946611f, 
    0.40236130f, 0.01802156f, -0.25747958f, -0.04065672f, 0.17375748f, -0.02305791f, 0.02857503f, 0.03865563f, 
    0.12621465f, 0.03733830f, -0.01293105f, -0.18048403f, -0.08359119f, -0.37570277f, -0.01242806f, 0.24445271f, 
    0.07108849f, -0.05418733f, -0.03885452f, 0.01122456f, -0.02376677f, -0.09176697f, 0.03825385f, 0.04190544f, 
    0.03458279f, 0.02486470f, 0.02917736f, -0.16380726f, 0.04985306f, 0.00321466f, -0.01600023f, 0.10844370f, 
    -0.01133931f, 0.08307418f, -0.10826378f, -0.11742967f, 0.12352934f, 0.09766693f, 0.18619618f, 0.09649741f, 
    -0.05186514f, -0.03973979f, -0.11750430f, -0.04106441f, 0.03753733f, 0.03928521f, -0.07269944f, -0.02009233f, 
    -0.09732598f, 0.31955594f, 0.10037290f, 0.10281449f, -0.07043407f, -0.06246364f, 0.07155170f, 0.03812987f, 
    0.09168350f, -0.01550218f, -0.02802291f, 0.13201159f, 0.12178236f, 0.02334629f, 0.10102148f, 0.18671905f, 
    0.04818095f, 0.11360549f, 0.00476016f, 0.15895408f, 0.02154050f, 0.10216916f, 0.03729066f, -0.04074273f, 
    -0.00581233f, -0.34156367f, -0.05432237f, 0.27229634f, 0.09375354f, -0.04804353f, 0.03814383f, 0.02234665f, 
    0.04170508f, 0.00973329f, -0.02705357f, 0.06252212f, 0.18211237f, 0.32381618f, -0.23483966f, -0.02589658f, 
    0.04649911f, 0.16560547f, -0.02917651f, 0.06271613f, -0.05911913f, -0.00944596f, -0.01303354f, 0.03788723f, 
    0.25151119f, -0.09792078f, -0.11290268f, -0.01477936f, 0.06096343f, 0.04977342f, -0.00076502f, -0.04493040f, 
    0.04439860f, 0.10779534f, -0.00513588f, 0.02337398f, 0.13468540f, -0.18639110f, -0.22829500f, 0.18739226f, 
    0.14127468f, 0.12487283f, -0.01160908f, -0.07392261f, 0.13334641f, 0.04705853f, -0.05270829f, 0.05721450f, 
    0.14851551f, -0.19502163f, -0.21532191f, -0.10525344f, 0.10121566f, 0.02333554f, -0.02714185f, -0.03866036f, 
    0.02381163f, 0.09830917f, 0.11936650f, -0.02569610f, 0.07373479f, -0.00987036f, -0.06400114f, -0.01690718f, 
    0.10313506f, -0.00788719f, 0.06194009f, 0.07019489f, 0.14095140f, -0.02805455f, 0.03107281f, 0.12101756f, 
    -0.37652308f, 0.01173925f, 0.25269836f, -0.06044425f, 0.00740209f, -0.04847823f, -0.03815326f, 0.08758773f, 
    0.05634886f, 0.01219619f, -0.01913084f, 0.00465612f, 0.07796028f, 0.20448601f, -0.19187169f, 0.02786111f, 
    0.02204429f, 0.05652292f, 0.02466005f, -0.04807262f, 0.02625580f, -0.15445839f, -0.06431666f, 0.01425579f, 
    -0.15409259f, 0.00961572f, -0.04664014f, -0.32133618f, -0.12999742f, -0.07368658f, -0.08176454f, 0.11929765f, 
    -0.01103871f, -0.03729566f, 0.06908213f, 0.05785869f, 0.05616511f, 0.02159593f, -0.04261063f, 0.08866356f, 
    0.07484336f, 0.07352380f, 0.01430823f, 0.03086460f, 0.00718956f, -0.04855308f, -0.04926155f, -0.01171335f, 
    0.18189478f, -0.13414806f, -0.34043908f, 0.17635073f, 0.09715881f, 0.14071265f, -0.00656152f, 0.00141286f, 
    -0.06690117f, 0.06381005f, -0.03851193f, 0.11078909f, 0.26343068f, -0.06188082f, -0.07730600f, -0.08089647f, 
    -0.12135762f, -0.10283688f, 0.00412238f, 0.04261192f, -0.03659810f, -0.01792265f, 0.12760504f, -0.03575398f, 
    -0.32355878f, -0.29545629f, -0.17460489f, 0.28111672f, 0.01947464f, -0.10364456f, -0.04963589f, 0.00717105f, 
    -0.02783652f, 0.01146180f, 0.10509655f, 0.01208269f, 0.06308636f, -0.03572085f, 0.02858738f, 0.17690162f, 
    0.02122577f, 0.05765544f, 0.06259821f, -0.06123203f, -0.06212642f, 0.00825564f, 0.15867740f, 0.03605552f, 
    0.01538409f, 0.06415284f, -0.13193129f, -0.09463935f, 0.03703424f, 0.09287332f, -0.00553882f, 0.02653620f, 
    -0.07944793f, 0.01433251f, 0.00903028f, -0.05574274f, -0.07802728f, 0.03521676f, 0.03197312f, -0.06218969f, 
    -0.13666981f, -0.05675896f, -0.12746157f, 0.11575872f, 0.06087706f, -0.02213726f, 0.12163099f, -0.07904986f, 
    0.19378327f, 0.09346856f, 0.11628561f, -0.07128553f, -0.05433287f, -0.14174362f, -0.03532140f, 0.06511509f, 
    -0.06771811f, -0.05217306f, -0.06029205f, -0.12982476f, 0.38209799f, 0.09708639f, -0.11166352f, -0.05217813f, 
    0.07321712f, -0.03802136f, 0.02983468f, 0.02770245f, -0.00446582f, 0.01247596f, 0.05169050f, 0.12634471f, 
    -0.11700648f, -0.18247563f, -0.32223964f, 0.03893192f, 0.15935415f, 0.04352275f, -0.01282965f, -0.06542371f, 
    0.04866333f, 0.04626615f, -0.03451332f, -0.07822037f, 0.25864202f, 0.16183402f, 0.00862455f, -0.11647931f, 
    0.08649081f, 0.11532325f, 0.02917137f, 0.08923519f, 0.02893350f, 0.14294611f, -0.02234833f, -0.11040992f, 
    0.27720636f, 0.04160698f, 0.08423579f, 0.11992136f, -0.03816124f, 0.07376814f, 0.07344759f, 0.07514969f, 
    0.07751506f, 0.12472216f, 0.04906247f, -0.02988106f, 0.28972933f, -0.12443005f, 0.08675104f, 0.18690936f, 
    0.14466524f, 0.05206985f, 0.03199129f, 0.07419040f, 0.13595848f, 0.04012055f, 0.11673759f, -0.03862941f, 
    -0.16728963f, 0.38135451f, -0.09558152f, 0.03318997f, -0.17051490f, 0.09820947f, -0.00005098f, 0.00200323f, 
    -0.02677176f, 0.02160029f, 0.08872490f, 0.10657401f, 0.04384026f, -0.08779150f, 0.06122420f, -0.05056247f, 
    -0.11193976f, -0.05295888f, 0.06330747f, 0.03383695f, 0.09012904f, 0.00764377f, 0.07610937f, 0.05726288f, 
    0.21883339f, 0.09714940f, 0.02495963f, -0.16160238f, 0.08384418f, 0.01126261f, 0.03605435f, 0.04767400f, 
    0.05501812f, 0.06846800f, 0.18692367f, 0.01630058f, 0.02366102f, 0.07382981f, -0.01226245f, 0.03159419f, 
    -0.00059552f, 0.09086023f, 0.07496271f, 0.09247864f, 0.03339773f, -0.14478616f, -0.01460400f, 0.03001240f, 
    0.09928336f, 0.07428114f, 0.02623332f, -0.01320247f, -0.11840110f, -0.10614241f, 0.01478976f, 0.07734336f, 
    0.05356046f, 0.05211334f, -0.00294174f, 0.00066919f, 0.10636117f, 0.15884778f, -0.02666087f, -0.07511231f, 
    -0.18623109f, 0.00514688f, -0.13457248f, 0.03867099f, 0.03925113f, 0.04850621f, 0.11844832f, 0.00280598f, 
    0.13289230f, -0.04064723f, 0.07909285f, -0.28305370f, -0.17793243f, -0.09667486f, -0.06470551f, 0.02778719f, 
    0.05866330f, -0.04828333f, 0.03528484f, -0.01793811f, 0.11932793f, 0.15886940f, 0.01338624f, 0.06628465f, 
    -0.07861885f, -0.14350893f, 0.04476615f, -0.03481679f, 0.03297543f, 0.10759132f, -0.04710395f, -0.03887875f, 
    -0.13108923f, -0.22507910f, -0.10527623f, -0.09643858f, 0.14239079f, 0.02205382f, -0.01100214f, 0.02620012f, 
    0.01301032f, -0.04011764f, 0.01894546f, -0.03447544f, 0.05920680f, -0.15042435f, 0.00828604f, -0.04314183f, 
    -0.14645611f, -0.05873736f, -0.01726602f, -0.03433921f, 0.00302589f, -0.09540737f, -0.04698312f, -0.00273394f, 
    0.22632381f, -0.07696163f, -0.01181581f, 0.02093841f, -0.10599247f, -0.10000003f, 0.04315742f, 0.03281673f, 
    0.01641899f, -0.10086630f, 0.02875242f, -0.04339774f, 0.26204252f, 0.06901572f, 0.02913499f, 0.10685986f, 
    0.22250114f, 0.02980429f, 0.09650151f, 0.09702184f, 0.02156367f, 0.05134017f, 0.10782151f, 0.00393818f, 
    0.05983253f, -0.15930803f, -0.00635851f, 0.16247097f, 0.06692718f, -0.03529870f, -0.02539402f, -0.04571966f, 
    0.09192590f, 0.02250492f, 0.09655073f, 0.14975868f, -0.04913299f, -0.01564453f, 0.14325467f, 0.10559397f, 
    0.10620106f, -0.00167880f, 0.04258617f, 0.08206923f, 0.00157994f, 0.05010807f, 0.00586773f, -0.02081005f, 
    0.00722737f, -0.05574799f, 0.04740505f, 0.06692691f, -0.01169824f, -0.08024696f, -0.02313480f, -0.01496512f, 
    0.03677224f, 0.01455431f, -0.00359407f, 0.01263442f, 0.15398535f, -0.09898429f, -0.16409338f, -0.01140105f, 
    0.07282282f, -0.00289764f, 0.08991757f, -0.10435282f, 0.01155203f, -0.05748791f, 0.01134140f, 0.00103394f, 
    0.20501234f, 0.08792792f, -0.05270022f, 0.02109536f, -0.04021608f, -0.06093444f, 0.12533405f, 0.02940491f, 
    -0.02271399f, 0.05122185f, -0.04774304f, 0.01331115f, 0.10855735f, 0.12727584f, -0.00136497f, -0.06968621f, 
    0.00958725f, -0.02888331f, 0.02772571f, -0.00968535f, -0.03355324f, 0.14162882f, -0.03592357f, 0.01429035f, 
    -0.13182071f, -0.21136151f, 0.13104118f, 0.02744039f, 0.10780658f, 0.10935097f, -0.00151412f, 0.08375175f, 
    0.04876402f, 0.01355573f, -0.05140764f, 0.02551793f, 0.20873590f, -0.13790947f, 0.05828423f, -0.19828808f, 
    -0.17421153f, 0.01247281f, -0.04849105f, 0.02652126f, 0.08700292f, -0.17196982f, -0.10790698f, -0.05963115f, 
    -0.02379576f, 0.13396125f, 0.10551375f, -0.08287250f, 0.03974069f, 0.02124257f, -0.03277918f, -0.06856399f, 
    0.00020847f, 0.05857921f, -0.10296842f, -0.07469231f, 0.18177438f, -0.11127197f, 0.14108410f, -0.08725819f, 
    -0.10793485f, 0.08342749f, -0.01254508f, -0.07282075f, 0.06200612f, 0.06263777f, 0.04957968f, 0.04689974f, 
    0.16704273f, 0.09748711f, 0.13096502f, 0.36528093f, 0.05034729f, 0.02118889f, -0.01411922f, 0.11423779f, 
    0.06126020f, 0.04013985f, -0.00177524f, 0.02151765f, -0.25241637f, 0.06592397f, 0.15463135f, -0.22366264f, 
    0.02464921f, -0.03418864f, -0.00732341f, -0.02617522f, 0.02763789f, -0.12413534f, 0.03530893f, -0.02162070f, 
    -0.00970862f, 0.00835411f, 0.00725139f, -0.15224716f, 0.05824161f, 0.05611338f, -0.10122615f, 0.14529844f, 
    0.10619811f, -0.00047026f, -0.02043387f, 0.14207630f, 0.26268148f, 0.11053375f, 0.10709823f, 0.13306135f, 
    -0.12463758f, 0.11032052f, -0.00964222f, 0.01370253f, 0.04612722f, 0.08908733f, 0.11438558f, -0.00929717f, 
    -0.08643489f, 0.03555046f, -0.04014993f, -0.00141269f, 0.04992972f, -0.04487951f, -0.05315612f, 0.13191856f, 
    0.08357877f, 0.15853471f, -0.03143498f, 0.02906092f, -0.02402576f, 0.04907823f, -0.05140540f, -0.17259924f, 
    -0.08066759f, 0.02824155f, -0.06307302f, -0.02716287f, -0.01170721f, 0.05321681f, -0.00647761f, 0.02183846f, 
    -0.05471331f, 0.14451563f, 0.05747108f, -0.22424546f, 0.06581702f, 0.04038060f, 0.13507654f, -0.04745537f, 
    -0.11713242f, 0.07166688f, 0.01985913f, 0.03618238f, -0.11794608f, 0.04131925f, 0.07750407f, -0.14222252f, 
    -0.03983627f, -0.04793390f, 0.07102457f, 0.01877934f, 0.00470072f, 0.00962596f, 0.01345984f, 0.15119691f, 
    0.01887964f, 0.17513801f, -0.01965549f, -0.07059278f, -0.08645771f, -0.05941195f, 0.00799849f, 0.05944305f, 
    -0.02611910f, -0.03938166f, 0.05834816f, -0.03392299f, 0.03219196f, 0.09860682f, 0.18076509f, 0.11411399f, 
    -0.03539684f, -0.06802268f, 0.02921674f, 0.06382126f, -0.00394993f, 0.01450488f, -0.00310417f, -0.02361210f, 
    0.17555742f, -0.28430527f, -0.09456231f, 0.06571165f, 0.11596332f, 0.03816869f, 0.07297339f, -0.00653417f, 
    0.00827072f, 0.07056829f, 0.08133682f, -0.00372965f, -0.27082404f, -0.04018958f, -0.12089127f, -0.09657451f, 
    0.08285969f, 0.01739128f, -0.03958671f, -0.00685504f, -0.06967457f, 0.07284509f, 0.08380548f, 0.13195261f, 
    0.16604517f, 0.16200823f, 0.06247346f, 0.25108850f, 0.04314140f, 0.00607357f, 0.05601744f, 0.06757832f, 
    0.08159369f, 0.01855862f, 0.03229826f, -0.03136716f, 0.23602450f, 0.15709896f, 0.05694541f, 0.10731940f, 
    0.08549305f, -0.00786636f, 0.04561762f, -0.05658446f, -0.04716605f, 0.13021211f, 0.05484965f, 0.20115061f, 
    -0.22105178f, 0.09440970f, 0.06430261f, 0.19465783f, 0.00345796f, 0.09387580f, 0.04221099f, -0.00175757f, 
    -0.07311529f, -0.07482886f, 0.09009222f, -0.02191010f, 0.25044727f, 0.10738435f, 0.10281033f, 0.30997589f, 
    -0.00994430f, 0.07606313f, 0.07460639f, -0.06443333f, 0.09914992f, 0.04456171f, -0.04803573f, 0.06969468f, 
    -0.12407567f, 0.11061323f, -0.04066443f, 0.01709008f, 0.01441037f, 0.11162111f, 0.15150343f, 0.07481616f, 
    0.09847475f, 0.02646842f, 0.12140387f, 0.08055602f, 0.00528762f, 0.11932325f, -0.07728464f, -0.00132531f, 
    0.06112573f, 0.12403657f, -0.01152979f, 0.07805844f, 0.06485301f, 0.08304615f, -0.01525582f, -0.03139713f, 
    0.24605943f, -0.01856976f, 0.00640886f, 0.11040763f, -0.03431111f, 0.10587214f, -0.00901045f, -0.01957244f, 
    0.11970356f, -0.07052310f, 0.06323544f, 0.02982968f, -0.05911374f, -0.02073489f, -0.08892579f, 0.14918564f, 
    -0.05216205f, 0.02277882f, 0.10266932f, -0.06505074f, -0.01423273f, -0.01230637f, -0.01263572f, 0.05923674f, 
    0.13639423f, -0.02751771f, -0.09993418f, 0.15837677f, -0.04328311f, 0.09177418f, -0.05460332f, 0.01371183f, 
    0.03823347f, 0.05644261f, 0.03087110f, 0.00737616f, -0.17394546f, 0.11113033f, -0.06033013f, -0.21400027f, 
    0.22249554f, -0.07766739f, 0.03927345f, 0.01484785f, -0.01699640f, 0.11415349f, -0.01712612f, -0.04466281f, 
    -0.04026645f, 0.05921492f, 0.08359423f, 0.10073008f, -0.01396068f, -0.00833754f, 0.00286342f, -0.00239237f, 
    -0.00017363f, -0.03255750f, 0.00925439f, 0.00336983f, 0.02707264f, 0.21061023f, 0.14543213f, 0.16536228f, 
    -0.05694496f, 0.01494645f, 0.02078488f, -0.04413317f, -0.07791501f, 0.01997003f, -0.01788601f, -0.01917421f, 
    0.07657800f, 0.06631515f, 0.24214652f, -0.01918276f, 0.03743470f, -0.02394507f, 0.06509813f, 0.02558630f, 
    0.02596161f, 0.00664897f, 0.00591185f, 0.12442750f, 0.20615147f, 0.14515197f, -0.04578656f, -0.06790815f, 
    0.00807925f, 0.03577362f, -0.03296084f, 0.02731300f, -0.00401882f, 0.01470009f, -0.12168439f, 0.02099460f, 
    0.44622919f, 0.11053096f, -0.04054126f, -0.02218505f, 0.10055350f, 0.01406135f, 0.06306101f, 0.06317163f, 
    0.05730629f, -0.05886180f, 0.01951826f, 0.02497406f, 0.11701332f, 0.08555838f, 0.04209596f, 0.09209480f, 
    0.03654578f, -0.09475426f, 0.21615267f, 0.04305093f, -0.00836340f, 0.16450673f, 0.00462447f, 0.09618893f, 
    0.02149955f, -0.04843852f, -0.00777223f, -0.13365515f, 0.03348453f, -0.05627738f, 0.10174993f, 0.06546996f, 
    0.06958073f, 0.04125437f, 0.01301202f, 0.13535550f, -0.22941855f, -0.04678968f, 0.12151322f, -0.16400068f, 
    0.02053769f, 0.01598003f, -0.02205615f, -0.07145912f, 0.02749806f, -0.01207413f, -0.15112896f, -0.01470777f, 
    0.07560365f, 0.16325083f, 0.30983037f, 0.09156067f, -0.07900754f, -0.03681198f, 0.05656788f, -0.00501509f, 
    0.06523447f, 0.01566558f, -0.02645144f, -0.12657683f, 0.11464559f, 0.12513490f, 0.09074228f, -0.05804623f, 
    0.00575242f, -0.01644225f, 0.01663260f, 0.00971311f, 0.04630197f, -0.12554182f, -0.00126747f, 0.06056852f, 
    0.19017220f, 0.11032293f, 0.07795949f, 0.26218736f, 0.00178958f, 0.08934816f, 0.02907459f, 0.04935339f, 
    0.00029591f, 0.04965090f, 0.08097176f, 0.04030536f, 0.11590151f, 0.07919074f, 0.02354216f, -0.00489315f, 
    -0.07263348f, 0.03111365f, -0.04049416f, -0.00937770f, 0.05341119f, 0.09864909f, -0.05195470f, -0.04540461f, 
    0.23792084f, 0.15797167f, 0.00674558f, 0.14100465f, -0.04055307f, -0.04105037f, 0.06802881f, 0.09528023f, 
    -0.09699919f, 0.07763740f, 0.03588796f, 0.03752423f, -0.18728276f, -0.18198024f, 0.09125831f, -0.04885757f, 
    0.00681454f, -0.00271463f, 0.04435461f, -0.12705556f, -0.01545603f, 0.15837544f, 0.02245114f, 0.05600135f, 
    -0.01262353f, 0.05355934f, 0.03511563f, -0.00638977f, 0.00908766f, 0.13769951f, 0.03675654f, 0.16301306f, 
    0.03659354f, -0.02079527f, 0.00277334f, 0.12097190f, -0.19558708f, 0.17379537f, 0.07230713f, 0.20501097f, 
    -0.04740510f, 0.04651337f, 0.14077352f, -0.00898594f, 0.00730540f, 0.06638158f, -0.00774836f, -0.13738173f, 
    0.01099347f, 0.11101345f, 0.14698382f, 0.26325166f, -0.03020819f, 0.16870208f, 0.07402788f, 0.01205304f, 
    -0.04819574f, 0.11259146f, 0.13701917f, 0.04229700f, -0.08912834f, -0.04042968f, -0.08752259f, -0.19905779f, 
    -0.02013394f, 0.01727855f, 0.04476706f, 0.00582980f, 0.00683904f, -0.00016457f, 0.08372311f, 0.06191557f, 
    -0.13148530f, -0.01207530f, 0.02414738f, -0.24431139f, -0.04901703f, -0.05240143f, 0.02096516f, -0.06133071f, 
    -0.02797203f, -0.00420702f, 0.01141311f, 0.00514567f, 0.05644127f, 0.01558133f, 0.12292293f, -0.15908089f, 
    -0.05555967f, 0.02603757f, -0.05572266f, -0.02535206f, 0.00334481f, 0.01134644f, 0.10973167f, -0.06682172f, 
    0.01110913f, -0.10387516f, -0.06452633f, 0.14868025f, 0.14414443f, -0.03690108f, 0.11619765f, 0.04656077f, 
    0.04186359f, 0.07559855f, -0.03067129f, -0.02330438f, -0.00998363f, -0.08331612f, -0.01232857f, 0.02318772f, 
    -0.03830508f, 0.10204770f, -0.02025139f, -0.05711034f, -0.00801979f, -0.09431183f, 0.17070605f, -0.02790548f, 
    0.04702399f, 0.16850047f, 0.00063747f, -0.03233450f, 0.02386138f, 0.11302087f, 0.11555478f, 0.09261911f, 
    -0.06175741f, 0.08961637f, 0.04015002f, 0.00251745f, 0.04184549f, 0.10177048f, 0.15294671f, -0.00070631f, 
    0.02684932f, -0.01268070f, 0.08952842f, 0.03787290f, 0.07508942f, 0.06663910f, -0.06630076f, 0.03720845f, 
    -0.12467074f, 0.12730354f, -0.00553617f, -0.03177077f, -0.08792519f, 0.09589139f, -0.04595423f, -0.00314479f, 
    -0.03426534f, 0.06356802f, -0.00433411f, 0.06396844f, 0.41299304f, -0.01467983f, 0.02000092f, -0.10824374f, 
    0.01546562f, 0.12489598f, 0.09010635f, 0.10791333f, -0.01079553f, 0.03990555f, -0.10285874f, 0.06825700f, 
    0.36391848f, 0.02845133f, 0.07901096f, -0.20671824f, 0.02100766f, 0.08387402f, 0.00744779f, 0.05268919f, 
    -0.03123998f, 0.07345638f, 0.07695185f, 0.13915138f, 0.15484822f, -0.11847858f, -0.10484170f, 0.05134779f, 
    -0.01159322f, 0.01900772f, 0.05001658f, -0.00676391f, 0.06754736f, -0.09681893f, 0.05138801f, 0.13686483f, 
    0.23183118f, 0.10073894f, 0.13416050f, 0.22099623f, -0.03733440f, -0.02764481f, 0.00130079f, 0.09436490f, 
    -0.01946980f, 0.04605749f, 0.05350058f, 0.12138839f, -0.07783828f, -0.08022588f, -0.07707683f, -0.05025987f, 
    0.03787270f, 0.03021760f, 0.03442331f, 0.13322695f, 0.09511194f, 0.01881590f, -0.07488524f, 0.16822526f, 
    0.12714216f, -0.10513036f, 0.05998912f, -0.07847460f, 0.04583599f, 0.07381693f, -0.03894524f, 0.08910310f, 
    -0.07690229f, 0.15967117f, 0.06280839f, 0.15615475f, -0.07572527f, 0.11389234f, 0.07530218f, 0.02224826f, 
    -0.13561997f, 0.05710906f, -0.04270872f, 0.01918921f, 0.11349332f, 0.02006001f, -0.04014829f, -0.08454549f, 
    0.17626972f, 0.14497510f, -0.02224588f, 0.15882728f, -0.17231508f, 0.13627347f, 0.10369207f, 0.18234229f, 
    -0.00058350f, 0.03917369f, -0.03440612f, 0.02197577f, -0.21301790f, 0.01330265f, -0.01182002f, 0.00770115f, 
    -0.03180895f, 0.03635019f, 0.09609833f, 0.05164666f, 0.05795875f, 0.04167461f, -0.03073714f, 0.03154859f, 
    0.28194967f, -0.20922114f, 0.08946128f, -0.03112437f, -0.07698727f, 0.04054100f, 0.03277323f, 0.00550499f, 
    0.06589465f, 0.12219167f, 0.08457241f, 0.02551842f, -0.07724741f, 0.20350021f, 0.24090016f, -0.15702014f, 
    0.06978224f, 0.16824014f, -0.02211827f, 0.14427453f, 0.01942386f, 0.01443856f, 0.01137569f, -0.03630086f, 
    0.16783413f, 0.02608582f, 0.05186824f, -0.00868210f, 0.00799585f, 0.07910378f, 0.02690861f, -0.06046393f, 
    0.03926517f, 0.01546584f, 0.05305260f, 0.04743499f, 0.18174101f, -0.00043306f, 0.10805937f, 0.08599723f, 
    0.00065953f, 0.00020220f, -0.14438550f, 0.02707380f, 0.03682555f, -0.09811222f, -0.02082834f, 0.06381858f, 
    0.23508638f, 0.01448198f, 0.01463118f, 0.04092063f, -0.02931500f, 0.00821072f, 0.14205071f, 0.01521199f, 
    0.06769960f, 0.10433724f, 0.00976232f, 0.08681476f, 0.19770665f, 0.07942430f, -0.00953202f, -0.16368094f, 
    0.10612956f, 0.08124606f, -0.02298084f, 0.13300367f, 0.08323860f, 0.16419286f, 0.10189224f, 0.12342177f, 
    -0.02359773f, -0.07886054f, 0.04745322f, 0.28453019f, 0.02413041f, -0.01765754f, -0.10652333f, 0.10248699f, 
    0.03764552f, -0.00178067f, 0.03238199f, -0.02077651f, 0.00477723f, 0.19631937f, 0.11178738f, 0.16783074f, 
    0.01138678f, -0.10029490f, -0.12822136f, 0.11448180f, -0.10476120f, -0.04274129f, 0.01584767f, 0.12053895f, 
    0.44234297f, -0.02817176f, 0.05307843f, 0.11411729f, 0.00236232f, 0.11000402f, 0.02190907f, 0.13046737f, 
    -0.01632633f, -0.02883545f, 0.21117570f, 0.07188874f, 0.33574072f, 0.15414989f, -0.04500560f, 0.11012729f, 
    0.03781932f, -0.05636825f, 0.21554314f, -0.06406172f, 0.04698194f, 0.13003762f, 0.06251825f, -0.02860744f, 
    -0.04016423f, 0.09009071f, 0.06511003f, 0.15971065f, -0.14909071f, -0.06392117f, 0.08117564f, -0.01275989f, 
    -0.03130778f, -0.04499973f, 0.01644811f, 0.02787868f, 0.25680706f, -0.21157093f, -0.10954412f, 0.17155725f, 
    0.02787906f, 0.01789726f, -0.05643345f, -0.00007265f, -0.02092237f, 0.06530589f, -0.05800189f, -0.01649207f, 
    0.10299898f, -0.12012226f, -0.18858969f, -0.02397281f, -0.11043148f, -0.03204104f, 0.04172880f, 0.07736171f, 
    0.10955159f, 0.01689013f, -0.04244453f, -0.00677618f, 0.06085457f, -0.10838204f, -0.04331471f, 0.18120560f, 
    0.02264767f, -0.04621596f, 0.09433202f, 0.07631419f, 0.06330269f, 0.02600528f, 0.05630964f, 0.00511773f, 
    0.20972277f, -0.01373478f, 0.20654574f, -0.01624506f, -0.06039725f, 0.04664764f, -0.02415585f, 0.06002515f, 
    0.05554909f, -0.00060137f, -0.04841470f, -0.04834272f, 0.22422969f, 0.11888005f, 0.27485695f, 0.19355932f, 
    -0.08685840f, -0.07107227f, 0.07081617f, 0.05679553f, 0.04153727f, 0.02961090f, 0.05087699f, 0.06824394f, 
    0.15974042f, 0.21807936f, -0.27685264f, 0.00509679f, -0.00481339f, -0.02328378f, -0.00104006f, -0.09347245f, 
    -0.10224666f, -0.05181209f, 0.10470864f, -0.01733275f, -0.09314998f, -0.11477105f, 0.04666787f, 0.22153266f, 
    -0.05134980f, -0.09358452f, -0.02111697f, 0.03139825f, 0.07850618f, -0.00384419f, 0.02646167f, -0.13709964f, 
    0.34779531f, 0.23040311f, -0.24488354f, -0.22615497f, 0.04541988f, -0.06356179f, -0.04009968f, 0.11990573f, 
    -0.01502938f, -0.07447211f, 0.05159657f, 0.10088682f, -0.07193379f, 0.07974465f, 0.13258454f, 0.09897248f, 
    0.04124698f, 0.01329004f, 0.04083231f, 0.10375366f, 0.07470669f, -0.02468368f, 0.00507301f, 0.00683338f, 
    0.06376864f, -0.05349604f, -0.02283018f, 0.12161985f, -0.05251129f, -0.00610413f, 0.06831305f, 0.10404652f, 
    -0.03891716f, 0.04825798f, 0.13461412f, -0.06503430f, -0.01847813f, -0.07213693f, 0.02152858f, 0.21078259f, 
    -0.05403077f, -0.02500748f, -0.06494287f, -0.02894724f, 0.04610705f, 0.02979326f, 0.05473613f, -0.12294783f, 
    -0.10953551f, -0.21271385f, -0.01100381f, 0.16300401f, 0.03652363f, 0.04428336f, -0.06741177f, 0.01596682f, 
    0.09959084f, 0.13221233f, 0.05568056f, 0.01229460f, -0.03264832f, 0.01609731f, -0.23288693f, -0.00670579f, 
    -0.08452360f, 0.01347855f, 0.05441131f, 0.12395658f, -0.01075319f, 0.00951342f, 0.02031983f, -0.01424244f, 
    -0.10322914f, 0.14145581f, 0.33356929f, 0.02991662f, -0.13682744f, 0.05812298f, -0.04906705f, -0.06452243f, 
    0.00042526f, 0.09198932f, 0.09104399f, 0.07805192f, 0.05712554f, 0.14847635f, -0.19366719f, 0.01106699f, 
    -0.07193898f, -0.03483841f, 0.12564364f, -0.05949681f, -0.07516910f, -0.01141592f, 0.03213505f, 0.00100877f, 
    -0.41967717f, 0.02217670f, 0.18045300f, -0.03237440f, -0.01480259f, 0.01078951f, -0.03187481f, -0.04005076f, 
    -0.20197749f, 0.00606104f, -0.02136189f, -0.01732017f, 0.05101115f, -0.12829594f, -0.06230318f, 0.00146796f, 
    0.07388218f, -0.01122337f, 0.04611205f, 0.03270423f, -0.11765687f, 0.04613666f, -0.06767656f, 0.07132398f, 
    0.18449616f, -0.03390150f, 0.03561277f, 0.18146630f, -0.01800930f, 0.02279482f, 0.00406951f, 0.16446477f, 
    0.10008220f, -0.10016949f, -0.02440161f, 0.14110757f, -0.35445449f, 0.07939843f, 0.19760497f, -0.03954061f, 
    -0.04769717f, -0.10789601f, 0.15243976f, -0.03425193f, 0.10009874f, 0.06243220f, -0.03657012f, -0.01535735f, 
    -0.23244549f, -0.01500031f, -0.01947692f, 0.05279800f, 0.02960546f, -0.01996526f, -0.12113012f, -0.04916645f, 
    0.12866537f, -0.00112888f, -0.00853209f, -0.12303721f, 0.16264325f, -0.18383418f, 0.05866318f, 0.13063177f, 
    0.02424744f, -0.04834106f, -0.06350560f, 0.03306359f, 0.00325433f, -0.11470287f, -0.13961920f, -0.00067345f, 
    -0.07897758f, 0.27818674f, 0.00818696f, 0.17279035f, -0.03775162f, 0.04835556f, -0.03906896f, 0.14089194f, 
    0.07557348f, -0.04866082f, -0.06325778f, -0.00084025f, 0.28369448f, 0.26874018f, -0.02160655f, -0.18428588f, 
    0.00143371f, -0.04733081f, -0.11596832f, 0.03298238f, 0.05783229f, 0.07434160f, 0.12881848f, -0.04107950f, 
    0.25552428f, 0.17670314f, -0.15138729f, -0.05539978f, 0.04343556f, 0.07545415f, 0.04269636f, -0.04836326f, 
    -0.10573287f, 0.10632946f, 0.05403545f, -0.03435804f, -0.00638628f, -0.28360391f, 0.05764413f, -0.16278656f, 
    -0.02913982f, 0.01405925f, -0.00557771f, 0.00421071f, 0.11126686f, 0.16285765f, 0.01087549f, 0.02282465f, 
    0.13701785f, 0.18491940f, 0.26641923f, 0.15165909f, -0.05743745f, -0.03078604f, 0.02430973f, -0.02853606f, 
    -0.00854035f, 0.03145591f, -0.00406501f, -0.02933975f, 0.04125411f, 0.00144324f, 0.14935416f, 0.05838444f, 
    -0.06084027f, -0.08802611f, -0.01324923f, 0.03720472f, 0.06688891f, -0.05011147f, -0.05328641f, -0.06049693f, 
    -0.18585019f, -0.22365162f, 0.04666335f, 0.19685590f, -0.03634508f, -0.04557467f, -0.06131976f, 0.00898804f, 
    0.00886250f, 0.04045694f, 0.05945069f, -0.15297319f, 0.14876506f, -0.00618905f, 0.11263849f, 0.01305666f, 
    -0.03942215f, 0.00414685f, 0.04504722f, 0.05961088f, -0.11769857f, -0.01616494f, 0.00888627f, -0.01645321f, 
    0.08963118f, -0.12470526f, -0.02833244f, 0.00816754f, 0.11018839f, -0.02628264f, 0.02277088f, 0.00813804f, 
    0.23577045f, -0.04689089f, -0.02469916f, -0.02843512f, 0.00123217f, -0.04219506f, 0.04671630f, 0.07579571f, 
    0.04447353f, 0.09070706f, 0.00669535f, 0.01246567f, -0.03617502f, -0.09116241f, -0.05049727f, -0.09629136f, 
    0.19119829f, -0.24725361f, -0.06951701f, -0.01487636f, -0.02838755f, -0.00901682f, 0.11094300f, 0.03946868f, 
    0.03991520f, 0.03688511f, 0.01546259f, 0.10060160f, 0.18964759f, 0.11216674f, 0.04791721f, -0.01169651f, 
    0.05320885f, -0.03920470f, -0.02028901f, 0.06783344f, 0.12523144f, 0.06672410f, 0.05362545f, 0.09347276f, 
    0.07050487f, -0.00405996f, -0.03307036f, 0.13642210f, -0.08021916f, -0.08772386f, 0.04689348f, 0.01606299f, 
    0.00303010f, 0.06965069f, 0.03632575f, 0.03281963f, -0.35588682f, -0.22185442f, -0.04442470f, -0.17229432f, 
    -0.01210473f, 0.04210017f, -0.05132244f, -0.01983316f, 0.07632142f, 0.07533083f, -0.03077091f, 0.03021948f, 
    -0.00392156f, -0.12364811f, 0.11643174f, 0.22574739f, 0.08526686f, 0.05774384f, 0.13917123f, 0.07256357f, 
    -0.00324426f, -0.09808416f, 0.06559846f, 0.03486712f, -0.00687864f, -0.13093394f, -0.20311217f, 0.08714587f, 
    0.05344168f, -0.03828640f, -0.11663163f, 0.03080486f, 0.14144769f, -0.07847537f, 0.04400446f, 0.02972120f, 
    -0.02340526f, 0.02296787f, 0.01292923f, 0.02045230f, 0.06051070f, -0.02095909f, -0.02958365f, -0.11390325f, 
    -0.04865900f, -0.15345320f, -0.06632569f, 0.03052934f, -0.13992228f, -0.09058654f, -0.01094203f, -0.05999334f, 
    0.09197963f, 0.02902797f, -0.13749328f, -0.01425061f, 0.02025735f, -0.06883306f, -0.04377424f, 0.03581017f, 
    -0.08800678f, -0.23832797f, -0.01743297f, -0.17954512f, 0.00813092f, 0.00658440f, 0.06745258f, -0.05243162f, 
    -0.06387386f, -0.03351977f, -0.13109170f, 0.03070537f, -0.07563568f, 0.15257463f, 0.03080645f, -0.00739348f, 
    0.01079596f, -0.02611379f, -0.14610821f, 0.11242936f, -0.08454054f, -0.00785583f, -0.02134530f, -0.07651050f, 
    -0.08895406f, -0.41367301f, -0.34330490f, -0.10047396f, 0.01896518f, 0.07493822f, 0.01352244f, -0.01881073f, 
    0.06507777f, 0.11323867f, -0.03820470f, 0.02247754f, 0.10785246f, -0.38463092f, -0.05325926f, 0.09397284f, 
    0.00067132f, -0.01221544f, 0.00161597f, -0.06945978f, -0.05189655f, 0.14944850f, -0.05530649f, -0.01692639f, 
    0.18152229f, -0.03585031f, 0.03970593f, 0.14186619f, 0.04053519f, -0.04106088f, -0.00491219f, -0.08961743f, 
    -0.11093131f, 0.00173329f, 0.02403568f, -0.07727595f, -0.02185728f, 0.51564693f, -0.06196479f, -0.15504834f, 
    0.01881483f, 0.07874127f, 0.04217030f, 0.04441163f, 0.10932209f, 0.12222016f, -0.05839443f, -0.06870354f, 
    0.15582272f, 0.23245884f, 0.11083002f, 0.14799553f, 0.11006140f, -0.02634125f, 0.00183435f, 0.08475920f, 
    -0.09850212f, -0.10068083f, -0.03077966f, 0.07227515f, -0.06914517f, 0.10127792f, 0.20336451f, 0.05376283f, 
    -0.03483785f, 0.01206504f, -0.00938922f, 0.05634379f, -0.08590648f, 0.01555460f, -0.02592864f, -0.03458588f, 
    -0.00687737f, 0.14123395f, -0.12290035f, 0.06438661f, 0.02517412f, -0.02426073f, 0.06161622f, 0.15564696f, 
    0.07709084f, -0.05321712f, -0.07724808f, -0.09726141f, 0.00336158f, 0.20942932f, 0.20084468f, 0.03826808f, 
    -0.02474838f, -0.10697833f, -0.00819345f, 0.10828721f, -0.00076297f, 0.08544513f, 0.12694545f, 0.04225564f, 
    -0.08292907f, 0.13421661f, 0.12725027f, 0.19050492f, -0.08022320f, -0.03820833f, 0.09970512f, 0.05817606f, 
    0.00936025f, -0.05331685f, -0.00924416f, 0.00734764f, -0.08865938f, -0.25996953f, -0.08239726f, 0.20410629f, 
    -0.07674410f, 0.00710330f, 0.03065579f, -0.05585887f, -0.02959910f, -0.01071630f, -0.01035745f, 0.04897545f, 
    0.00510299f, -0.19593656f, -0.05324894f, -0.04125186f, -0.08057784f, 0.06870633f, 0.06021451f, -0.10569465f, 
    0.11837929f, 0.08841226f, -0.09120480f, -0.03081173f, 0.03548257f, -0.12964009f, -0.01550438f, 0.12518427f, 
    -0.09549568f, 0.03832988f, -0.06027786f, 0.02340464f, 0.03470673f, -0.00916937f, 0.06792553f, 0.11483208f, 
    -0.21353541f, 0.20456266f, 0.11868537f, 0.05611666f, 0.02630566f, -0.06982465f, 0.05566844f, 0.01439872f, 
    -0.05218513f, -0.05562145f, -0.06495253f, 0.21095355f, -0.01840255f, -0.23341344f, -0.10286231f, 0.23472521f, 
    -0.01882780f, -0.08523119f, -0.01954561f, 0.08700498f, 0.05528948f, 0.00047812f, -0.03543101f, 0.01396287f, 
    -0.18561018f, -0.13955489f, 0.09848142f, 0.05051781f, 0.02260463f, 0.04222477f, -0.10866498f, 0.15130979f, 
    0.03259074f, -0.13059962f, -0.01212578f, -0.04953726f, -0.06905579f, 0.12841204f, 0.13765569f, 0.02518966f, 
    0.03529915f, -0.04305972f, 0.01498672f, 0.08923940f, 0.01610959f, 0.04074137f, 0.02223841f, 0.10984101f, 
    0.34288207f, 0.33493647f, -0.35319901f, -0.29800835f, 0.11524522f, -0.00171201f, 0.02315014f, 0.04743408f, 
    -0.00964459f, 0.07391573f, 0.00814937f, 0.06562034f, -0.07531720f, 0.23131725f, 0.14841333f, 0.24932332f, 
    -0.02255274f, 0.01932657f, 0.00364282f, 0.11597133f, -0.06129511f, -0.08197852f, 0.09610900f, 0.01623605f, 
    0.02425986f, -0.02960943f, -0.00668749f, -0.01895259f, -0.01629181f, -0.01267248f, 0.03062026f, 0.01799504f, 
    -0.00491463f, -0.02458557f, -0.02832899f, -0.01106540f, 0.00262040f, -0.00237406f, -0.02532793f, -0.03703848f, 
    -0.01886547f, 0.01831660f, 0.03496945f, -0.01183102f, -0.00651845f, -0.00075276f, -0.01374654f, -0.03865297f, 
    -0.01567539f, 0.01900282f, 0.00099226f, 0.01444543f, 0.01031980f, 0.02795560f, 0.00077531f, -0.02755378f, 
    -0.02246346f, -0.00491172f, 0.01096517f, 0.00329476f, -0.03179562f, -0.02943487f, 0.02368872f, 0.02161998f, 
    -0.03760995f, -0.03013035f, 0.01170583f, -0.03148562f, -0.02957339f, -0.00450704f, -0.03274646f, 0.02864421f, 
    0.00742392f, 0.01880724f, -0.01219467f, -0.01519340f, 0.01659016f, 0.01885004f, -0.00185355f, -0.02943987f, 
    0.03013188f, -0.00942046f, -0.03521124f, -0.02065495f, 0.00370120f, 0.01439722f, -0.02713066f, 0.02736885f, 
    -0.03589883f, -0.03869214f, -0.03702310f, -0.03178424f, 0.02347441f, -0.01022798f, 0.00087607f, -0.00756739f, 
    -0.02234183f, -0.00825480f, 0.01615613f, 0.02101676f, -0.03007022f, -0.04041542f, 0.00162736f, -0.03238651f, 
    0.02750637f, -0.03774005f, -0.03158978f, -0.01232399f, 0.00725864f, -0.03539164f, 0.02401998f, -0.03042595f, 
    -0.04095862f, -0.00348156f, -0.03895569f, -0.00263835f, -0.02929950f, 0.00966604f, -0.01443724f, 0.01701664f, 
    -0.03595207f, -0.00868063f, -0.00044010f, -0.01866550f, -0.00819893f, -0.00367667f, -0.03880097f, 0.01735888f, 
    -0.02361016f, 0.00149288f, 0.00753076f, -0.01824366f, -0.03763754f, 0.01529646f, 0.01627453f, -0.02321167f, 
    -0.01955710f, -0.00224794f, -0.01451426f, -0.02920414f, 0.00189875f, -0.03934397f, 0.02575128f, 0.02002415f, 
    -0.00681207f, 0.01915624f, -0.04029481f, -0.01305853f, 0.02877036f, -0.02984075f, -0.00243990f, -0.01401638f, 
    0.01716152f, 0.02018819f, -0.00100281f, -0.01872264f, 0.00639297f, 0.01973737f, -0.03879334f, 0.02235076f, 
    -0.03736763f, -0.00023549f, 0.01281946f, -0.01123836f, 0.00391492f, 0.00693762f, 0.01754587f, 0.00445411f, 
    0.00630956f, 0.00595432f, 0.02495448f, -0.03818719f, 0.00918642f, -0.01855557f, 0.01614234f, -0.02051991f, 
    -0.01574389f, 0.01578094f, -0.04081408f, 0.02696023f, 0.00294164f, -0.01468872f, -0.02435831f, -0.00840063f, 
    -0.02419559f, -0.02163602f, -0.02953290f, 0.02549769f, -0.03192682f, -0.03215294f, -0.02352787f, -0.02970656f, 
    0.00213264f, 0.00279565f, 0.00681547f, 0.00152443f, -0.01994028f, -0.03487146f, -0.04091411f, -0.01049476f, 
    -0.03628012f, 0.01761152f, 0.01730597f, -0.01840122f, -0.04295174f, 0.00109841f, -0.03172798f, -0.00160095f, 
    0.02572174f, 0.00283855f, -0.01792724f, 0.00795476f, 0.02375753f, 0.00645379f, 0.01818516f, 0.01296606f, 
    -0.03164915f, -0.03706832f, -0.03184257f, 0.02113120f, -0.00871810f, -0.03864042f, -0.02026507f, 0.01208746f, 
    0.00742085f, -0.03102211f, -0.01234460f, -0.03607722f, 0.02444186f, 0.00407795f, 0.01761885f, 0.03061905f, 
    -0.02880575f, -0.02454619f, -0.00169371f, 0.00485283f, -0.01569509f, 0.00741036f, -0.01905494f, 0.01599186f, 
    0.02040828f, -0.03363855f, -0.01332221f, 0.00417176f, -0.02965216f, 0.02352007f, -0.02927510f, 0.00087215f, 
    0.01955834f, 0.02438065f, 0.01443821f, 0.02933189f, -0.00546721f, 0.00678042f, 0.01410287f, -0.00532583f, 
    -0.01564189f, 0.00917201f, -0.02895194f, -0.00389363f, 0.02185306f, -0.00548556f, 0.00334057f, 0.00175262f, 
    -0.02876072f, 0.02423277f, 0.00368240f, -0.04367790f, -0.02997671f, -0.02863852f, -0.00866604f, -0.01774114f, 
    -0.02732905f, 0.02338694f, 0.00904333f, -0.01233387f, 0.00409557f, -0.00851470f, 0.02227750f, -0.02618086f, 
    -0.03227434f, -0.01564095f, -0.00678379f, 0.02222386f, -0.02367177f, -0.03729803f, -0.00555393f, -0.01038659f, 
    0.03278693f, 0.00620364f, -0.00021006f, -0.03706097f, -0.02911844f, 0.01956223f, 0.01058579f, 0.01385279f, 
    0.02001307f, -0.00260974f, -0.00910133f, -0.04499583f, 0.02341932f, -0.00385605f, 0.02415841f, 0.00585941f, 
    -0.01655281f, -0.02824574f, -0.02117112f, -0.02110294f, -0.00844446f, 0.03065076f, -0.03210329f, -0.03965816f, 
    0.03162132f, 0.03963454f, 0.01288983f, -0.00888723f, 0.01787726f, 0.00642968f, -0.02940601f, -0.03968507f, 
    -0.02492741f, -0.00775698f, -0.01235720f, 0.01127438f, -0.01373603f, -0.02017033f, -0.03649163f, -0.00183479f, 
    0.01422931f, 0.02608653f, -0.02412681f, -0.03317074f, -0.02065669f, -0.00963551f, -0.00192310f, 0.00662103f, 
    -0.00123974f, -0.00595704f, -0.02952273f, 0.02259850f, -0.00572938f, -0.03603477f, -0.02847831f, -0.02493863f, 
    0.00313791f, 0.00369087f, -0.03709312f, -0.02139734f, -0.00701114f, -0.03969717f, 0.00134068f, 0.01198012f, 
    0.01665031f, 0.01076915f, 0.00315992f, 0.00622014f, 0.01665423f, -0.03331564f, -0.01848146f, 0.00920018f, 
    -0.01827698f, -0.01549382f, 0.02308701f, -0.02726337f, -0.00491466f, -0.00873955f, -0.01094314f, -0.01164766f, 
    -0.03278803f, 0.00312321f, -0.02371792f, 0.03357450f, -0.01820033f, -0.03730599f, 0.00774931f, 0.02367560f, 
    -0.01747104f, -0.03018856f, -0.03459847f, -0.00344234f, -0.00641642f, 0.01172668f, 0.00898696f, 0.01841192f, 
    0.02200933f, 0.02314248f, 0.02189072f, 0.02862176f, -0.03476248f, 0.02066821f, -0.00882561f, -0.03434504f, 
    -0.01131786f, 0.01687143f, 0.02071236f, -0.04273567f, -0.01842728f, -0.00500904f, 0.01954086f, 0.00248686f, 
    0.01312219f, 0.00536257f, -0.01914535f, -0.00632703f, -0.00473203f, 0.00202035f, -0.02470153f, -0.02828373f, 
    -0.00305100f, -0.00483504f, 0.01901972f, -0.03054943f, -0.00497742f, 0.02980200f, 0.03484590f, -0.02538549f, 
    -0.03383017f, -0.02317018f, -0.01172131f, -0.04289730f, -0.02614443f, -0.03863056f, -0.00481055f, -0.02893927f, 
    0.00654333f, -0.00901471f, -0.02281294f, 0.02942755f, -0.00791860f, 0.02341165f, 0.02342532f, -0.01538805f, 
    -0.03792815f, 0.01348110f, 0.01287743f, -0.00253371f, -0.01425850f, -0.01659231f, 0.00420283f, -0.01791380f, 
    0.00610330f, 0.00899697f, -0.00797609f, 0.02842891f, -0.02179614f, 0.00057095f, -0.02562558f, 0.02528374f, 
    0.02008200f, -0.03537565f, -0.01132549f, 0.02162257f, -0.04378019f, -0.03774981f, 0.01987822f, -0.00427737f, 
    -0.02491458f, -0.00509742f, -0.03468287f, 0.02501337f, 0.02747750f, -0.00220402f, -0.02068085f, -0.01769081f, 
    0.02046660f, 0.00253493f, -0.00249329f, -0.02109754f, -0.02156645f, 0.00558264f, 0.01009545f, -0.01791366f, 
    0.00404694f, 0.02296682f, 0.00352722f, -0.02548718f, -0.03358740f, -0.01295550f, -0.03231998f, -0.01006006f, 
    0.01445971f, 0.01203279f, 0.01688830f, -0.03960953f, -0.02621820f, -0.01500190f, 0.00266283f, -0.04383086f, 
    -0.01719891f, 0.02595747f, 0.02325405f, 0.00861531f, -0.02960884f, -0.03331735f, -0.02912287f, -0.02315696f, 
    0.00874130f, -0.00147542f, 0.03847556f, -0.01468474f, -0.03502731f, 0.02868019f, 0.01795365f, -0.02735786f, 
    0.00196426f, 0.00730919f, 0.00990913f, 0.01243318f, 0.02357615f, 0.02597514f, 0.02524084f, -0.01216084f, 
    0.00793739f, -0.00618390f, 0.02411538f, 0.02095000f, -0.04150833f, 0.01307326f, 0.02450440f, 0.00176790f, 
    -0.02730550f, -0.01174380f, 0.00485175f, 0.01785283f, 0.02829360f, -0.03378227f, 0.00428977f, -0.04192869f, 
    -0.02012518f, -0.02806140f, 0.02112281f, 0.01977385f, 0.01218931f, -0.01938244f, 0.00630077f, -0.00800190f, 
    -0.01864315f, -0.03925914f, 0.03094525f, -0.04094157f, 0.01498905f, -0.03435399f, -0.00558352f, -0.01544184f, 
    0.01197833f, 0.01289871f, -0.03072410f, -0.00405877f, -0.00134469f, 0.02880035f, 0.01036836f, 0.02459451f, 
    0.00609043f, -0.01080293f, -0.00373804f, 0.00316716f, -0.03657766f, -0.03027969f, -0.02009169f, 0.00307081f, 
    -0.00626828f, -0.04371454f, -0.02551110f, -0.03966211f, 0.00986582f, -0.02512136f, 0.02135640f, 0.00894356f, 
    -0.01635063f, -0.00009672f, -0.01313991f, -0.01217384f, -0.02098043f, 0.00990983f, 0.02595743f, 0.02726365f, 
    -0.03212579f, 0.00952298f, -0.02507357f, 0.02892599f, 0.00150187f, -0.00309964f, 0.01548446f, -0.01966917f, 
    0.00694278f, -0.04583253f, -0.00944242f, 0.01558817f, -0.01017830f, -0.03265179f, -0.03063593f, -0.01664184f, 
    0.02992344f, -0.01022608f, -0.01385436f, -0.00098939f, -0.00962901f, 0.01794576f, 0.00768730f, -0.00821850f, 
    -0.02991286f, -0.00543622f, -0.02880775f, -0.03406689f, -0.01309599f, 0.02946506f, 0.02058241f, 0.01026783f, 
    0.00951835f, -0.01938765f, -0.01034016f, 0.02689656f, -0.01565557f, -0.03844178f, 0.02402124f, -0.00287742f, 
    -0.01362050f, 0.01348646f, 0.01997972f, -0.03290017f, -0.01461254f, -0.02711479f, -0.00365532f, 0.02817880f, 
    -0.01729580f, 0.02986876f, 0.01788651f, -0.03676184f, 0.00070520f, -0.03205756f, -0.03619907f, -0.03090652f, 
    0.00009729f, -0.00456585f, -0.02417064f, -0.03275985f, -0.01254465f, -0.03127516f, -0.02606313f, -0.01747866f, 
    0.02206104f, 0.00439649f, -0.02290594f, 0.00879959f, -0.02559939f, -0.02717657f, -0.03022738f, -0.00662920f, 
    0.01334986f, 0.00516240f, -0.00874790f, -0.00479196f, -0.03085261f, 0.02987762f, -0.00281938f, 0.01088292f, 
    -0.00660725f, 0.00918644f, 0.03842079f, 0.01110864f, -0.02802014f, -0.03667703f, -0.03938673f, 0.02313613f, 
    -0.03166574f, -0.00891225f, 0.02599771f, 0.00534219f, -0.02632540f, 0.01211356f, -0.00142470f, 0.00900444f, 
    -0.02451199f, -0.00407904f, 0.02964146f, 0.01414712f, -0.03229742f, 0.01724720f, 0.01359035f, 0.02041873f, 
    -0.00107773f, 0.00880363f, -0.03412342f, -0.02367169f, -0.00737556f, -0.03593669f, -0.00675186f, 0.00507648f, 
    -0.00264136f, 0.00762291f, 0.02999374f, -0.03634817f, -0.02561601f, 0.02254870f, 0.02429474f, 0.02720768f, 
    -0.01299914f, -0.00747957f, -0.01788306f, 0.00946515f, -0.02067225f, -0.01843699f, -0.02056408f, 0.00792113f, 
    0.00730555f, -0.03842750f, -0.02704528f, 0.01864745f, -0.03417002f, 0.01279287f, -0.01033024f, 0.00620974f, 
    0.02467273f, -0.02890770f, 0.02146320f, -0.01973569f, -0.00907535f, 0.01768585f, 0.01631652f, -0.02752527f, 
    0.02032517f, -0.00019093f, -0.03989919f, 0.02527713f, -0.02912864f, -0.01851795f, 0.01215929f, -0.01794774f, 
    -0.04089866f, 0.00494104f, -0.01647712f, -0.03230386f, -0.02612775f, -0.00688663f, 0.02525478f, 0.00625706f, 
    0.01500906f, -0.01514806f, 0.00262919f, -0.03780396f, 0.02103004f, -0.03209972f, 0.02322735f, -0.03440611f, 
    0.01405676f, -0.00709191f, 0.01514909f, -0.03420740f, -0.02360515f, -0.01585941f, -0.02710839f, 0.02892350f, 
    -0.02789312f, -0.00877449f, -0.01754687f, -0.02833511f, 0.02271055f, -0.04296520f, -0.03059802f, 0.00617969f, 
    -0.01296965f, -0.01669019f, 0.03200658f, -0.00889690f, -0.00610552f, -0.02670326f, -0.00314196f, 0.02061585f, 
    0.02089242f, -0.04238936f, 0.00216216f, 0.00589298f, 0.01958002f, 0.02667655f, -0.03707892f, -0.01750450f, 
    -0.01054342f, 0.01428390f, -0.01747024f, 0.01377590f, -0.04090701f, 0.01176002f, -0.03925432f, -0.03669052f, 
    0.03107800f, -0.01176050f, -0.00375023f, -0.03065290f, 0.01228246f, -0.03534621f, -0.03837818f, 0.02348155f, 
    0.01454095f, -0.03958173f, 0.01585609f, -0.00968820f, -0.00674545f, -0.02071904f, -0.03651318f, 0.02279438f, 
    0.00754764f, 0.01202166f, -0.03729087f, 0.01187720f, 0.00794212f, -0.03096117f, -0.00403538f, 0.01041529f, 
    -0.03887160f, -0.00460908f, -0.01202430f, 0.00166729f, -0.03632899f, -0.01797141f, -0.00351790f, 0.00819363f, 
    -0.01408608f, 0.01179815f, -0.02675116f, 0.02198923f, -0.02165210f, 0.02603609f, -0.03629465f, -0.01558087f, 
    -0.01639222f, -0.02763833f, -0.03626851f, 0.02075644f, -0.02591356f, 0.01949531f, -0.02620929f, 0.00612258f, 
    -0.00955482f, -0.00813914f, -0.03319945f, 0.02187700f, -0.02276336f, 0.02918628f, -0.00080569f, -0.00900215f, 
    -0.00426070f, -0.00263326f, 0.02121037f, -0.00145426f, 0.00939682f, -0.03548419f, -0.04110337f, 0.00347245f, 
    -0.04082694f, -0.01888991f, -0.03940057f, -0.00295819f, -0.00201613f, 0.00881526f, 0.01031866f, -0.02234031f, 
    0.01037059f, 0.01811149f, 0.01969054f, -0.02730367f, 0.00028077f, 0.03000182f, -0.01831235f, 0.01909317f, 
    0.00981179f, -0.00804460f, 0.02449785f, -0.02914982f, 0.00171892f, 0.02985824f, -0.03539182f, -0.01369208f, 
    -0.02224482f, 0.00185570f, -0.04114371f, -0.02801932f, -0.00110555f, 0.00356831f, 0.02897576f, -0.03622709f, 
    0.01412343f, 0.02752455f, 0.02871182f, -0.01189040f, -0.03907320f, 0.02199460f, -0.04100788f, 0.01652624f, 
    0.01889966f, 0.01459673f, 0.01236648f, -0.02244117f, -0.01770985f, -0.00460583f, -0.03665517f, -0.01048654f, 
    -0.01885772f, 0.01231013f, -0.01558906f, -0.04185527f, -0.00086277f, -0.00398285f, -0.02858673f, -0.01335871f, 
    -0.00384887f, -0.00798747f, -0.03592340f, 0.01646386f, 0.01189876f, -0.03416027f, 0.00044034f, -0.02971011f, 
    -0.01300887f, -0.01201142f, -0.02626301f, -0.02830941f, 0.00535314f, 0.00606989f, 0.00559756f, -0.03371424f, 
    -0.04290469f, -0.02247729f, -0.02161400f, 0.01728165f, 0.00392625f, 0.01616771f, 0.03408466f, 0.01350446f, 
    -0.00373963f, -0.03497915f, 0.02798669f, -0.02958031f, -0.01610990f, 0.00037458f, -0.00762160f, -0.02196803f, 
    0.02238913f, -0.02316206f, 0.02134487f, -0.01083907f, -0.03141680f, -0.04127419f, 0.00585204f, 0.01366415f, 
    0.00765883f, -0.03049369f, -0.02159776f, -0.00961748f, 0.00878363f, 0.02018678f, 0.02923225f, 0.00049053f, 
    0.02922128f, 0.03669654f, -0.01266653f, -0.02673364f, 0.01108850f, 0.01173351f, 0.00671510f, -0.01729289f, 
    -0.02189089f, -0.04013442f, -0.00430616f, -0.00944071f, -0.02146084f, 0.04169554f, -0.03203199f, 0.04019310f, 
    -0.03780048f, -0.02597883f, -0.03561603f, 0.02468680f, -0.03580832f, 0.03549262f, -0.01613065f, 0.00493266f, 
    -0.00342822f, -0.02344341f, -0.00895345f, -0.00408979f, -0.01595386f, 0.01968367f, -0.01506066f, 0.01859612f, 
    0.00077772f, -0.00314075f, 0.00308219f, 0.02767315f, 0.01194239f, 0.01648003f, 0.01163930f, -0.02535005f, 
    0.01885898f, -0.02189951f, -0.02261208f, 0.03050555f, -0.01180380f, -0.00922443f, 0.01328351f, 0.02493831f, 
    0.01253273f, -0.02790046f, -0.03066330f, -0.01938792f, 0.01642360f, -0.01877917f, -0.02776479f, -0.01202821f, 
    -0.03850109f, 0.01340214f, 0.00143114f, 0.01310717f, 0.01644821f, 0.00449394f, -0.04196672f, 0.02220531f, 
    0.00812143f, -0.02762631f, -0.01432555f, -0.00991607f, -0.00521097f, -0.01213577f, -0.00123788f, 0.01653137f, 
    0.00927045f, 0.01683791f, -0.03783592f, -0.00307971f, 0.00938350f, 0.03508151f, 0.00234279f, 0.01753550f, 
    -0.01896426f, 0.03491740f, -0.01748328f, -0.03410974f, -0.00455202f, -0.01996665f, 0.01650782f, 0.03250322f, 
    -0.02663380f, 0.02208111f, 0.02704917f, -0.02446101f, 0.01222663f, 0.01064104f, -0.02315672f, -0.04289469f, 
    -0.03736785f, -0.03226902f, -0.00841253f, 0.02284289f, 0.00862596f, -0.03741727f, 0.02200928f, -0.00096615f, 
    -0.01434708f, -0.02087806f, -0.00333569f, 0.02004313f, -0.00490999f, -0.00526704f, -0.04157484f, -0.03785188f, 
    -0.03014684f, -0.00953468f, -0.01201028f, -0.02283472f, 0.02015784f, -0.01688102f, -0.04228786f, 0.01561078f, 
    -0.03461209f, 0.00678163f, 0.00081172f, 0.01556805f, -0.01901064f, 0.01069593f, -0.00025471f, 0.00095586f, 
    0.02113784f, -0.01287463f, -0.01611403f, 0.01814076f, -0.00486665f, 0.01020365f, 0.00964254f, 0.03902543f, 
    -0.01827801f, 0.00939019f, 0.02310946f, -0.02068566f, 0.00646401f, -0.02189754f, 0.03193395f, 0.00253753f, 
    0.01591163f, 0.02458184f, 0.02422172f, -0.02495418f, -0.02726766f, 0.02504929f, -0.00007648f, 0.01324515f, 
    0.00063405f, -0.01186724f, 0.02185618f, 0.00369572f, -0.02346968f, 0.00110856f, -0.00521910f, 0.02548387f, 
    -0.00148712f, -0.02021092f, -0.02622438f, -0.03638688f, 0.00263125f, -0.00941562f, -0.01612327f, -0.03446953f, 
    -0.00046159f, 0.02598038f, 0.00545633f, 0.01463218f, -0.04100799f, -0.03165039f, -0.01248054f, -0.00337658f, 
    -0.00237655f, -0.01820472f, 0.03055783f, 0.00099627f, -0.00142648f, 0.01263844f, -0.03687185f, -0.00841301f, 
    0.02307785f, -0.04008933f, -0.02514560f, -0.01753052f, -0.02953783f, -0.01131807f, -0.00734088f, 0.00408816f, 
    -0.02478529f, 0.01267157f, -0.00046156f, -0.03524090f, -0.00030181f, -0.01045217f, -0.02712735f, -0.03495756f, 
    -0.00802405f, 0.02279304f, -0.00306974f, 0.01928872f, 0.00803158f, 0.02621683f, 0.02615987f, 0.00058947f, 
    0.00304246f, -0.02633356f, 0.00869251f, 0.02162326f, 0.00687267f, 0.01265778f, 0.02574331f, 0.00742232f, 
    -0.02606053f, -0.03634333f, -0.00624091f, 0.02594738f, 0.01775955f, 0.02183755f, 0.02063068f, 0.01871748f, 
    0.02265769f, 0.02217897f, -0.03930377f, -0.03376101f, -0.02702707f, 0.03824112f, 0.00328718f, 0.00279310f, 
    0.02529111f, 0.00808772f, -0.01349924f, -0.02364570f, -0.03449233f, 0.01309582f, -0.01963181f, -0.02747608f, 
    -0.01106448f, 0.03482446f, 0.01207668f, 0.00968266f, -0.03106463f, -0.01930114f, 0.02723407f, 0.00617272f, 
    0.01371142f, -0.04057607f, -0.03445922f, -0.00823050f, -0.00285873f, 0.01099265f, -0.03921657f, 0.02386559f, 
    -0.02095959f, -0.00087210f, 0.02389058f, -0.01879301f, -0.00041274f, -0.04069820f, -0.00966875f, 0.01240423f, 
    -0.00269471f, 0.01668424f, -0.03630760f, -0.00497071f, 0.01137733f, 0.01448399f, -0.03486296f, 0.02598444f, 
    0.00187335f, -0.04230955f, 0.02140917f, -0.02117906f, 0.03297612f, 0.01710280f, -0.00782573f, -0.02674256f, 
    0.02284507f, 0.02580859f, -0.03173482f, 0.01300373f, -0.01987700f, -0.02444437f, -0.03510515f, 0.01905102f, 
    0.02528821f, 0.01034964f, -0.00027200f, 0.00636902f, 0.01446035f, 0.01567626f, -0.02904572f, -0.03531878f, 
    0.00396739f, -0.01664987f, 0.02152229f, 0.00060686f, -0.00469834f, 0.02019319f, 0.02682133f, -0.03447689f, 
    -0.03187697f, -0.00990157f, -0.02044695f, 0.00935854f, -0.02208189f, -0.01137713f, 0.00660716f, -0.03095880f, 
    -0.02582102f, 0.00320796f, 0.00968844f, 0.00988329f, 0.00187029f, -0.00008663f, 0.02122177f, 0.00828359f, 
    0.00120816f, 0.01907120f, -0.00835805f, -0.03913208f, -0.03386424f, -0.01562075f, -0.00501881f, 0.01022336f, 
    -0.01811523f, 0.02315607f, -0.03898108f, -0.03258447f, -0.00025189f, 0.00437246f, 0.00889363f, -0.03991588f, 
    -0.03918159f, -0.03128200f, 0.02142103f, 0.00701877f, -0.04097329f, 0.01511788f, -0.02479201f, -0.01316653f, 
    -0.04084061f, -0.01159156f, -0.02607559f, -0.03649163f, -0.01014878f, 0.00400033f, -0.01542239f, -0.01163726f, 
    0.00705592f, -0.02208142f, -0.03584299f, 0.01370117f, -0.02806113f, 0.01125053f, -0.00489094f, -0.00296511f, 
    0.01300850f, -0.01996199f, 0.00339626f, -0.00901646f, -0.01982426f, -0.03954617f, 0.01501875f, -0.00709081f, 
    -0.01895612f, 0.02680820f, -0.00004152f, 0.01074291f, 0.01948478f, 0.01048858f, -0.01869023f, 0.00672951f, 
    -0.00383350f, 0.00157992f, -0.02783174f, -0.00702219f, -0.02441064f, 0.01757991f, -0.01728286f, 0.02507496f, 
    0.02086820f, 0.02721518f, -0.03569378f, 0.03897301f, -0.00768189f, 0.02978075f, 0.00517157f, 0.00564814f, 
    -0.02993445f, -0.02804472f, 0.02893369f, -0.02990743f, -0.02673715f, 0.01810567f, -0.03924176f, 0.01685543f, 
    0.03229185f, 0.00795637f, 0.03117837f, 0.02941316f, -0.03941772f, 0.00673634f, -0.00968843f, -0.02352370f, 
    0.01739760f, -0.00126262f, 0.03740860f, -0.01450428f, 0.00195264f, -0.02639610f, 0.00563691f, 0.02952288f, 
    0.00009003f, 0.02298581f, -0.02487708f, 0.01277035f, 0.02648288f, -0.03986119f, -0.03793706f, -0.01243358f, 
    0.01663159f, 0.00099069f, 0.00448300f, -0.03297941f, 0.01299135f, 0.01747968f, 0.00840897f, 0.01919244f, 
    0.01841267f, -0.02577630f, -0.02629843f, -0.02211134f, 0.01558515f, -0.01315161f, 0.01252975f, 0.00890670f, 
    -0.02665506f, -0.03446193f, 0.03201640f, 0.01520766f, -0.01318149f, 0.01472411f, -0.03110160f, -0.03526449f, 
    0.01590124f, -0.02401604f, -0.02016147f, 0.03734096f, -0.03715773f, -0.01124590f, -0.01226854f, -0.02281614f, 
    -0.00751117f, -0.01890798f, 0.03404789f, 0.01981008f, -0.03886469f, 0.02449560f, -0.00589623f, -0.01956778f, 
    -0.03252485f, 0.03067223f, 0.03986252f, -0.01859537f, -0.01565309f, -0.03185937f, 0.00050398f, 0.04137218f, 
    0.02086700f, 0.00637017f, -0.02215896f, -0.01713512f, -0.03748164f, -0.01591550f, -0.03631816f, 0.01483303f, 
    0.02168697f, -0.01865684f, 0.01292587f, -0.04079530f, -0.01573625f, -0.00914176f, -0.03416970f, -0.01676428f, 
    0.00157954f, -0.02533003f, 0.03514597f, 0.02049520f, 0.01957703f, 0.01787495f, -0.00517353f, 0.00088351f, 
    -0.00138345f, 0.00771562f, 0.01680105f, -0.00689667f, -0.04100641f, -0.00230523f, 0.03699391f, 0.02521494f, 
    -0.02976855f, -0.01957179f, 0.01954639f, -0.00307981f, 0.01588287f, -0.00761619f, 0.01750318f, 0.02590483f, 
    0.00902956f, 0.01985468f, 0.01478811f, -0.01154714f, -0.04203581f, 0.03775445f, -0.03206581f, 0.01805002f, 
    -0.01620138f, 0.00056084f, -0.02492103f, 0.03239845f, -0.00347935f, -0.00997549f, -0.00697977f, -0.02923116f, 
    -0.02970118f, -0.01630052f, -0.01004878f, 0.02845379f, -0.01331866f, 0.02644661f, -0.03324683f, -0.03487713f, 
    0.01026007f, -0.04009891f, 0.00197387f, 0.03923513f, -0.01631122f, -0.03684137f, -0.01524626f, 0.01028098f, 
    -0.03330874f, 0.02137778f, 0.02140941f, 0.03239328f, -0.03437229f, -0.02147448f, 0.03166289f, 0.01088394f, 
    -0.02079201f, 0.01714560f, 0.02203507f, -0.02756757f, -0.01914269f, 0.00646835f, 0.00691012f, 0.00827217f, 
    -0.03182741f, -0.03441606f, -0.03607239f, 0.02891185f, -0.03397157f, -0.02052709f, -0.02853571f, -0.01795343f, 
    0.02450483f, -0.03330760f, -0.01173566f, -0.01743893f, -0.03293754f, 0.01181610f, 0.01740625f, -0.02935520f, 
    0.01979853f, -0.01013672f, -0.02691975f, 0.00460625f, 0.00396276f, -0.03704326f, 0.01834218f, 0.00340490f, 
    0.01657074f, 0.01221673f, 0.02316199f, -0.01448087f, -0.00051583f, -0.00482784f, 0.02690506f, -0.03375998f, 
    -0.04076786f, -0.02414451f, -0.03013183f, -0.03984211f, -0.02114760f, 0.01477192f, 0.00917502f, -0.02226847f, 
    -0.02045645f, -0.02877928f, 0.00819567f, 0.01711709f, -0.01504593f, -0.03869503f, -0.03785003f, 0.00151425f, 
    -0.07569499f, 0.22919722f, -0.02390324f, 0.07586627f, 0.10523590f, 0.02720530f, -0.07734444f, 0.09400084f, 
    0.04997650f, 0.05483668f, 0.20994321f, 0.03155260f, 0.13072464f, 0.17749727f, 0.13591741f, 0.02411593f, 
    0.02657945f, 0.02698522f, 0.05266765f, -0.07273573f, 0.05202173f, 0.09521336f, 0.08273979f, 0.07809556f, 
    -0.17960212f, 0.23174527f, -0.13951081f, -0.14035633f, 0.04239249f, 0.05463595f, 0.07627054f, 0.02938404f, 
    0.10466617f, 0.01062123f, 0.06524473f, -0.00502306f, 0.13385811f, 0.13362373f, -0.08226930f, 0.16996251f, 
    0.06483275f, 0.14404298f, -0.06197623f, 0.01340385f, 0.05820414f, 0.08690837f, -0.10647451f, -0.07875446f, 
    -0.07052160f, 0.17959765f, -0.00425130f, 0.25953650f, -0.06481764f, 0.02879757f, 0.07860006f, -0.04495974f, 
    -0.05335972f, 0.03056513f, 0.12810114f, -0.00609744f, -0.30529356f, -0.05327994f, -0.07081851f, -0.15956038f, 
    0.12640712f, -0.03650329f, -0.02981928f, 0.00176955f, -0.03546378f, 0.14625511f, 0.06618272f, 0.07458919f, 
    0.17632714f, 0.10852896f, 0.09911437f, 0.04182832f, 0.01536703f, -0.01588398f, 0.05845254f, -0.03612294f, 
    -0.02110286f, 0.00556786f, 0.05519993f, 0.08622389f, 0.00756358f, 0.05177731f, 0.15377665f, 0.12686889f, 
    0.05311451f, -0.11745165f, -0.06743063f, -0.00842557f, 0.08660100f, 0.26336455f, 0.04062473f, 0.08664116f, 
    0.32179898f, 0.02420645f, 0.02785814f, 0.06553885f, 0.13809982f, 0.01713816f, 0.00262661f, 0.11225354f, 
    0.03682614f, -0.01213891f, -0.17462097f, 0.14893855f, 0.18647188f, -0.01280461f, 0.15047841f, 0.09690587f, 
    0.12157478f, 0.01825669f, 0.00540597f, 0.03758750f, 0.04887389f, -0.05763580f, -0.06970608f, 0.03135881f, 
    -0.10227743f, 0.18094505f, 0.03224466f, 0.19840188f, 0.00114773f, 0.13095330f, 0.00208428f, 0.08604508f, 
    0.02547179f, 0.07605843f, 0.06691216f, -0.00135084f, -0.13596717f, -0.01834584f, -0.20393413f, -0.14687634f, 
    0.10140488f, 0.01790755f, -0.03038804f, -0.03525778f, 0.05022194f, 0.04746137f, 0.03934677f, 0.03743020f, 
    -0.03936520f, 0.32416573f, 0.12791373f, 0.10718212f, 0.04034125f, -0.05517894f, 0.05143676f, 0.14333977f, 
    0.03738043f, -0.00493850f, 0.07060929f, 0.17308649f, 0.28506806f, 0.07837108f, 0.24901055f, 0.14740357f, 
    0.03145336f, 0.01780378f, 0.06674989f, 0.00524406f, 0.03420594f, 0.09994425f, 0.02852259f, 0.09724340f, 
    -0.18350181f, -0.13847122f, -0.00716633f, -0.21651244f, 0.02507710f, 0.09534132f, 0.08172470f, -0.05925507f, 
    0.02759798f, -0.02133025f, -0.01817226f, -0.04099536f, -0.16450581f, -0.01450524f, -0.05288008f, -0.12813248f, 
    0.00915851f, 0.02538836f, -0.00343580f, 0.03076783f, 0.10087005f, 0.05564142f, -0.04315805f, 0.17089619f, 
    0.09861141f, -0.06885017f, -0.17105161f, -0.24116570f, 0.03969535f, 0.03429066f, 0.00726737f, -0.08935421f, 
    0.00260095f, 0.06153972f, 0.03404202f, 0.08975326f, -0.20973735f, 0.04452935f, -0.05495679f, -0.14587335f, 
    0.04321387f, -0.01774650f, 0.01808637f, 0.10338031f, -0.01257718f, -0.00491114f, 0.04613918f, 0.06164806f, 
    0.18486661f, 0.04604308f, 0.18778919f, 0.07668146f, -0.02875102f, 0.08874705f, 0.09989519f, 0.16439059f, 
    0.02163396f, 0.06511216f, 0.05922465f, -0.06152227f, 0.18026653f, -0.13643962f, 0.02962610f, 0.06729955f, 
    -0.00870886f, 0.01069499f, 0.09238792f, 0.08494711f, 0.03403507f, 0.04139975f, 0.02236796f, 0.07804950f, 
    0.20596045f, -0.01851005f, 0.05418762f, 0.00434356f, 0.01650414f, -0.02479641f, 0.05667974f, 0.17721656f, 
    0.11172123f, -0.00783275f, -0.07170448f, 0.07362482f, 0.35383093f, 0.13070247f, 0.12710162f, -0.06071028f, 
    -0.04289209f, 0.04438607f, 0.07548729f, 0.06467754f, 0.04609481f, 0.14313993f, 0.01408891f, -0.02812974f, 
    -0.09583028f, 0.10044467f, -0.06739395f, -0.07060903f, 0.15791583f, -0.03645752f, -0.06299003f, -0.00190488f, 
    0.01277022f, 0.02751275f, 0.05666099f, 0.13288327f, 0.16781007f, -0.30337691f, 0.13438472f, 0.17531078f, 
    0.02417225f, -0.03242919f, -0.03767421f, -0.03848923f, -0.05233736f, 0.04708977f, 0.08812290f, -0.11379451f, 
    -0.08256815f, -0.00738290f, -0.11621062f, -0.15658452f, 0.11632545f, -0.02932473f, -0.02233193f, -0.06359082f, 
    0.01085402f, 0.01615514f, -0.01564840f, -0.02644499f, -0.18534589f, 0.14963479f, -0.26646754f, -0.22323583f, 
    0.27051175f, -0.00810284f, -0.04852151f, -0.06550301f, -0.00076034f, -0.01513639f, 0.07589374f, 0.04071758f, 
    0.06366346f, -0.13136339f, -0.06279729f, -0.06073955f, 0.10600289f, -0.03958153f, -0.11035744f, 0.05082895f, 
    -0.02329522f, 0.05411066f, 0.00572510f, 0.10064784f, 0.28737840f, 0.08402189f, 0.03392010f, 0.16457148f, 
    0.11955136f, 0.02009539f, -0.05066862f, 0.02949431f, 0.04123032f, 0.03448011f, 0.15411171f, 0.02253513f, 
    -0.11574736f, 0.16678232f, -0.00620568f, 0.13042127f, 0.02457474f, 0.22513464f, 0.02724164f, 0.14067806f, 
    0.02261757f, -0.01481711f, 0.15203834f, 0.07486527f, 0.00271695f, -0.11280368f, 0.07293060f, -0.01511912f, 
    -0.10153516f, 0.14039125f, -0.00968860f, 0.00842179f, 0.12166820f, 0.01934888f, 0.02131077f, 0.05338650f, 
    0.14256573f, 0.09942196f, 0.09134195f, 0.21285625f, 0.06524771f, 0.04546845f, -0.02263054f, -0.01537154f, 
    -0.06405579f, -0.00178473f, -0.04391368f, -0.09132221f, 0.10430790f, 0.07498216f, 0.00311930f, 0.26102316f, 
    0.04657751f, 0.03413395f, 0.11358001f, 0.09717543f, 0.06577872f, 0.05845085f, -0.02357671f, -0.02348046f, 
    -0.26158538f, -0.20393932f, -0.15641232f, -0.17597406f, 0.05466712f, -0.04587551f, -0.03116578f, 0.04565659f, 
    -0.01767247f, 0.01811410f, 0.02777797f, -0.07964953f, 0.09089945f, 0.05468909f, 0.06548888f, 0.03571883f, 
    0.01166058f, 0.06203330f, 0.16631012f, -0.11340453f, 0.10916425f, -0.01755217f, -0.00428118f, 0.08232439f, 
    -0.03578520f, -0.12958793f, 0.06771102f, -0.06980924f, 0.00995285f, 0.02601947f, 0.00118800f, -0.02184620f, 
    0.06125912f, -0.03359660f, 0.08827669f, 0.04461891f, -0.15506977f, 0.16691166f, 0.01222981f, -0.02677086f, 
    0.11556540f, 0.00559544f, 0.08639488f, -0.02255491f, 0.01606378f, 0.01385155f, -0.04603549f, 0.04963678f, 
    -0.25498575f, 0.13514958f, -0.11772834f, -0.12997144f, 0.08351460f, 0.07031775f, 0.04469221f, 0.04583398f, 
    0.13451977f, 0.10616487f, 0.04341378f, 0.06694659f, 0.21375565f, 0.26008180f, -0.01844086f, 0.10261711f, 
    0.03287759f, -0.01948580f, 0.08948416f, 0.07454243f, 0.02220540f, 0.02653268f, -0.00147500f, -0.03698445f, 
    0.17155319f, 0.05292594f, 0.16375962f, 0.21925667f, 0.07556209f, -0.02364328f, 0.10926680f, 0.16311087f, 
    0.08055256f, 0.02688488f, -0.00404503f, -0.03218622f, -0.14430450f, -0.20490907f, 0.00975907f, -0.05609507f, 
    0.09331347f, 0.08045320f, -0.00120529f, 0.01173437f, 0.01006526f, 0.14495870f, -0.02377262f, 0.10354818f, 
    -0.19202662f, -0.15124880f, -0.12902412f, -0.24346696f, 0.08397913f, -0.06714416f, 0.01186557f, -0.04438221f, 
    0.11755817f, 0.06146558f, 0.02435755f, 0.17969361f, 0.15262266f, 0.15817425f, 0.08406839f, 0.17075574f, 
    0.06333644f, 0.04677670f, 0.00824748f, 0.05768951f, 0.13111559f, -0.00908754f, -0.03478913f, 0.04628390f, 
    0.15625064f, 0.19965167f, 0.04020758f, 0.16021155f, 0.14822643f, 0.03272864f, 0.08451243f, 0.07478399f, 
    0.11350266f, -0.04387687f, 0.03454703f, 0.04641280f, 0.04216956f, 0.14011849f, -0.09501490f, 0.07903583f, 
    0.15282683f, 0.01232350f, 0.00622638f, 0.11936161f, 0.00861007f, 0.02685722f, 0.05544229f, 0.03005956f, 
    0.19861975f, 0.19188765f, 0.13805929f, 0.14523941f, -0.02363697f, 0.07315332f, 0.02769960f, 0.03213198f, 
    -0.00622043f, 0.01213664f, 0.05679241f, -0.06199082f, 0.15122385f, 0.11111753f, 0.11656419f, 0.02512860f, 
    0.04379641f, -0.05542184f, 0.07725835f, -0.07102752f, 0.09910484f, 0.00583002f, -0.00529584f, -0.02595330f, 
    -0.23931569f, 0.06116340f, 0.18649963f, 0.16352732f, 0.13494766f, 0.20789751f, -0.06066982f, -0.09328597f, 
    0.13331063f, 0.09783521f, 0.04647481f, 0.04474995f, -0.01491488f, 0.08167323f, -0.09598183f, -0.01369767f, 
    0.02003094f, 0.15676948f, -0.04360637f, -0.02553387f, -0.09101295f, 0.19102067f, 0.03393091f, -0.01032857f, 
    0.14827253f, 0.16566655f, 0.08287042f, 0.27609172f, 0.10027928f, -0.04052886f, 0.07940599f, 0.06289852f, 
    -0.04767846f, -0.04085682f, 0.09072500f, 0.01102162f, 0.42039564f, 0.06244913f, 0.25246310f, 0.17741103f, 
    0.07685798f, 0.04445932f, 0.00212043f, 0.01812400f, -0.06405395f, 0.08058557f, 0.07910739f, 0.16420682f, 
    0.31578717f, 0.19084792f, 0.05050150f, 0.21359015f, 0.13281390f, 0.02996405f, 0.00091676f, 0.13177837f, 
    0.05443301f, 0.05415960f, 0.05940970f, -0.01109592f, 0.17862013f, -0.06514898f, 0.14240751f, 0.01127744f, 
    0.04115807f, -0.02285389f, 0.07153407f, 0.03500115f, -0.05646863f, 0.07231731f, 0.04881112f, -0.08445944f, 
    -0.08233939f, -0.12912206f, -0.11521348f, -0.09477806f, 0.01284313f, 0.02563177f, 0.02504570f, 0.08686982f, 
    0.12978666f, 0.01998197f, -0.02177569f, 0.09261016f, 0.14208581f, 0.04916697f, 0.19982411f, 0.16777973f, 
    -0.06306874f, -0.04335012f, 0.20274270f, 0.14066866f, -0.03579172f, 0.10245746f, 0.03529829f, -0.00478034f, 
    -0.18196689f, 0.24501830f, 0.17432337f, 0.19087109f, 0.01913814f, 0.06167223f, 0.10567472f, 0.03979426f, 
    -0.03144324f, 0.05955973f, 0.05994904f, 0.02191647f, -0.00310747f, 0.05076102f, -0.02747296f, -0.05782940f, 
    0.06839555f, 0.09074799f, -0.02652854f, 0.07088935f, -0.05011724f, 0.00137644f, 0.06180617f, -0.05442147f, 
    -0.06979893f, 0.07695043f, 0.16440299f, -0.10865077f, 0.03786992f, 0.10784329f, -0.03470975f, 0.04684687f, 
    -0.01456069f, 0.02902374f, -0.01569044f, -0.03207246f, 0.24085839f, 0.10220180f, 0.10112282f, 0.07810953f, 
    0.07919137f, 0.10979516f, 0.03595618f, 0.01614447f, -0.03192002f, 0.17797698f, 0.02309171f, 0.01178119f, 
    0.06138827f, 0.10720980f, 0.16964126f, 0.00038301f, 0.03619905f, 0.03512787f, 0.00840228f, -0.01433569f, 
    -0.00367860f, 0.11933518f, -0.00838234f, 0.01182591f, -0.20137453f, -0.04948860f, -0.20377152f, 0.05876114f, 
    0.02697537f, 0.08271309f, -0.01857460f, 0.00758568f, 0.02737932f, -0.02929967f, 0.05978917f, 0.02316892f, 
    0.18665978f, 0.08889921f, 0.14318317f, -0.04428534f, 0.12962988f, -0.02736637f, 0.05691188f, 0.03756608f, 
    -0.01940268f, 0.02327934f, 0.03524869f, 0.05236570f, -0.04501690f, 0.03640522f, 0.08808117f, 0.11530575f, 
    0.02448380f, 0.07087529f, 0.09594709f, -0.07300249f, -0.03066816f, 0.02301336f, 0.00653703f, 0.08836420f, 
    0.14028193f, 0.27720898f, -0.10530939f, -0.00838576f, 0.12205376f, 0.06577468f, 0.01006930f, 0.06276490f, 
    -0.01367526f, 0.01054343f, 0.04851893f, 0.16806394f, -0.03321514f, 0.12405742f, 0.16631779f, 0.15876542f, 
    0.04102924f, 0.03413159f, 0.10548530f, 0.14488083f, 0.00407022f, 0.02054203f, 0.10829593f, 0.13743262f, 
    0.00069714f, 0.01954461f, -0.02173792f, -0.01663813f, 0.02810130f, -0.01567448f, 0.02415547f, -0.00553217f, 
    -0.03626343f, -0.02438484f, -0.04146317f, 0.01429505f, -0.01817247f, -0.02473205f, -0.02608752f, 0.02406245f, 
    0.02405880f, -0.04075080f, -0.00068999f, 0.02488339f, 0.02299540f, -0.03925405f, -0.00046545f, 0.02262175f, 
    0.02730677f, -0.01289765f, -0.03952321f, -0.00010363f, 0.00734838f, -0.00143198f, 0.00335446f, 0.01930988f, 
    0.02609531f, -0.03828487f, 0.01167734f, 0.01121358f, 0.02020337f, -0.00794840f, -0.02862746f, -0.02935550f, 
    -0.02968714f, -0.03656032f, 0.02400630f, -0.02596011f, -0.02863585f, -0.03600210f, 0.02715142f, 0.00862832f, 
    0.02557804f, -0.03910895f, 0.02703960f, -0.03307882f, 0.02860594f, -0.02317093f, -0.00527597f, 0.01480926f, 
    -0.02393959f, -0.02464171f, -0.01961326f, 0.01959752f, -0.00959646f, -0.01905407f, -0.02588875f, 0.01852364f, 
    0.01763529f, -0.03049478f, 0.00537794f, -0.03061532f, -0.04180512f, -0.00460495f, 0.00382978f, 0.01172466f, 
    0.01610693f, -0.03798239f, -0.01189345f, 0.02756642f, 0.01441273f, -0.02303427f, 0.00527803f, -0.03577675f, 
    -0.02697000f, 0.01496302f, 0.00820532f, -0.02586025f, -0.03441171f, -0.01606739f, -0.02729489f, 0.00893136f, 
    -0.00034475f, -0.01698947f, -0.02991311f, 0.01641048f, 0.00684757f, -0.00393082f, -0.02278585f, -0.01251675f, 
    0.00609285f, -0.04184178f, 0.00612184f, -0.00504114f, 0.01645011f, -0.00179113f, 0.02891303f, 0.00612086f, 
    -0.04032087f, 0.00791455f, -0.00115540f, -0.01861059f, 0.00750497f, 0.01854146f, -0.02816977f, -0.03158455f, 
    -0.01262209f, -0.01325351f, -0.03441042f, 0.00404373f, 0.01961779f, -0.02599626f, 0.02220443f, 0.00220176f, 
    -0.02297979f, 0.01201393f, -0.02192119f, -0.00472909f, -0.01659848f, 0.00372714f, 0.02300237f, -0.03990829f, 
    0.00404600f, 0.00792013f, 0.00022778f, 0.01182417f, -0.01371064f, 0.02822686f, 0.02357351f, -0.00099148f, 
    -0.00712673f, -0.00777660f, 0.02069722f, 0.01424335f, 0.00763192f, 0.01020998f, 0.02876645f, -0.02642915f, 
    -0.00748934f, 0.02631977f, 0.00125980f, -0.03702534f, -0.00361938f, 0.00439897f, -0.00533848f, -0.03197816f, 
    -0.04094414f, -0.04034636f, -0.00734151f, -0.03237857f, 0.00345685f, -0.02362987f, -0.00190676f, 0.01104509f, 
    0.01253312f, -0.03695404f, -0.02688783f, 0.00361994f, -0.02953425f, 0.00455187f, 0.00403135f, -0.02511056f, 
    -0.01195873f, -0.01368137f, -0.01662868f, -0.02058516f, -0.03653923f, 0.01912327f, 0.03001231f, -0.01761825f, 
    -0.01259176f, 0.00695655f, 0.00959600f, -0.00288860f, 0.02887133f, -0.02839843f, -0.03890124f, -0.00347921f, 
    -0.03728124f, 0.02824535f, -0.03298313f, 0.02110425f, -0.00046037f, 0.00118126f, -0.00619551f, -0.00064274f, 
    -0.02444288f, -0.02299966f, -0.01081598f, 0.00231626f, 0.02785813f, -0.01836388f, -0.01898770f, 0.02544965f, 
    -0.03451294f, -0.01404520f, 0.00296194f, -0.03159345f, -0.03875019f, -0.04082118f, 0.01664039f, -0.01062468f, 
    0.00833415f, 0.00127509f, 0.00354428f, -0.00116427f, -0.01924310f, -0.00145445f, -0.01840341f, 0.01066306f, 
    -0.01191166f, -0.02652407f, 0.01340419f, -0.01971840f, 0.01410065f, 0.01254898f, 0.00925090f, -0.03744510f, 
    -0.03655192f, 0.00708777f, 0.00157511f, 0.00289074f, -0.00699411f, -0.03477569f, 0.02661605f, 0.02085313f, 
    -0.02912305f, 0.02080301f, 0.01132566f, -0.00771629f, 0.01729623f, 0.01507803f, -0.02793659f, -0.04016696f, 
    0.02185667f, 0.01578594f, 0.00830310f, -0.00260411f, 0.00521869f, 0.00187251f, -0.00969608f, -0.03989328f, 
    -0.00539783f, 0.02203932f, -0.04155882f, -0.00459114f, -0.02898774f, -0.02871478f, 0.02921906f, -0.02519426f, 
    0.00227895f, -0.00004582f, -0.02344038f, -0.03237390f, -0.00307115f, 0.01524065f, -0.02735323f, -0.03043698f, 
    0.02318326f, 0.02660994f, 0.00509240f, -0.02737266f, 0.02273863f, 0.00175375f, -0.00159831f, -0.02401563f, 
    -0.03323139f, -0.01878292f, 0.01887458f, -0.04076925f, 0.00213478f, 0.00542335f, 0.02105710f, 0.02812242f, 
    -0.02415591f, 0.01082937f, 0.02525313f, -0.00848872f, 0.01118491f, 0.01519653f, -0.02790563f, 0.00376468f, 
    0.00486241f, -0.02359309f, -0.01707097f, -0.04089053f, -0.00274418f, -0.02858474f, -0.01993195f, -0.00714470f, 
    -0.03537708f, -0.00798802f, 0.01684314f, 0.02977780f, -0.02097920f, -0.00480575f, 0.01305837f, -0.01906501f, 
    -0.00245528f, 0.01783676f, -0.03574773f, -0.03360015f, 0.01756511f, 0.01248703f, -0.00104745f, 0.01946331f, 
    -0.02485385f, -0.03385804f, 0.01124279f, 0.00144414f, 0.02288431f, -0.02171919f, 0.00002791f, 0.02389099f, 
    -0.03308708f, 0.00689818f, 0.01062414f, 0.01235124f, 0.02749727f, -0.02328020f, 0.01886780f, -0.02180075f, 
    -0.03518520f, -0.02422943f, 0.02167899f, 0.02876756f, -0.01659388f, -0.01178851f, 0.01624653f, -0.00992972f, 
    0.02843796f, 0.00723386f, 0.00910200f, -0.02490173f, -0.01065839f, 0.01576888f, -0.01026977f, 0.00964380f, 
    0.00587103f, 0.01923946f, -0.00461914f, -0.03182158f, -0.01819634f, 0.01712335f, -0.03092611f, -0.03676315f, 
    0.00706241f, 0.01179544f, -0.02310431f, 0.00863402f, -0.02468879f, -0.01016566f, -0.01349529f, -0.03526235f, 
    0.01247956f, -0.00558176f, -0.02362982f, -0.01755258f, -0.01062860f, 0.01068918f, 0.00133937f, 0.00517073f, 
    0.02082499f, -0.01724997f, -0.00517234f, -0.01487702f, 0.01052911f, -0.03617275f, 0.02299430f, 0.01183071f, 
    -0.02151673f, 0.01598099f, 0.02847914f, -0.00335001f, 0.00385577f, -0.00316530f, -0.00789835f, -0.02209443f, 
    -0.02985526f, 0.00709507f, 0.02675033f, -0.00745272f, 0.00047483f, -0.03133549f, -0.02334405f, -0.03441184f, 
    -0.00082721f, -0.01557277f, -0.00973647f, 0.00130291f, -0.01715623f, -0.01479786f, 0.01542087f, 0.02858558f, 
    0.00564261f, -0.02449647f, -0.02806681f, -0.01435711f, 0.03720669f, -0.03375591f, -0.03978067f, 0.02569653f, 
    0.01255019f, -0.04000472f, 0.01888241f, 0.03738908f, 0.02241620f, 0.01893705f, -0.00943260f, 0.01332436f, 
    -0.00227496f, 0.00118237f, -0.02740437f, 0.00179152f, 0.02155561f, 0.00135579f, -0.00966549f, -0.02452977f, 
    -0.03380786f, -0.03914218f, 0.01619940f, -0.00571529f, -0.03044133f, -0.02913980f, -0.02694678f, -0.00076532f, 
    0.02459248f, 0.01695636f, 0.01165795f, -0.01111627f, -0.00027239f, 0.01696612f, -0.00807199f, 0.01406500f, 
    -0.01941632f, -0.01018038f, -0.02043482f, -0.01697226f, -0.00867714f, -0.03841104f, -0.01947466f, 0.01325355f, 
    -0.02478607f, -0.00805990f, 0.01583203f, 0.01689968f, -0.02307257f, 0.02561161f, -0.03728180f, -0.00841657f, 
    -0.03574338f, -0.03372326f, 0.03963924f, 0.00932867f, 0.00691269f, -0.03503011f, -0.04174500f, -0.02177199f, 
    0.01905266f, 0.01079398f, -0.03000453f, -0.03993395f, -0.03595669f, 0.01174750f, 0.01158522f, -0.03461777f, 
    -0.02593133f, -0.03213606f, -0.02683349f, 0.01424192f, -0.03038490f, -0.04002292f, -0.01209826f, 0.01604779f, 
    -0.01934918f, -0.01113588f, -0.02148641f, -0.00518269f, 0.02820161f, -0.03334574f, 0.00024114f, 0.00875025f, 
    0.00332673f, -0.00433147f, -0.03604656f, 0.00544396f, 0.00950982f, 0.01706462f, -0.03183376f, -0.03521163f, 
    -0.01902400f, 0.01207279f, 0.01253729f, 0.00920374f, -0.00790900f, -0.01063295f, 0.00730962f, 0.00889324f, 
    0.00758723f, -0.02590160f, -0.03240401f, -0.01000081f, 0.02121005f, 0.02384795f, -0.02872370f, 0.01248593f, 
    -0.03685569f, -0.03893724f, -0.03151827f, -0.03170311f, 0.02392164f, 0.01686799f, -0.02214223f, -0.01090732f, 
    0.01169372f, 0.00252975f, -0.03855188f, -0.00091643f, 0.00995709f, -0.03270778f, 0.00032414f, 0.00470048f, 
    -0.02795903f, -0.00692173f, 0.00639052f, -0.03113864f, -0.02682923f, -0.03422552f, -0.02689996f, -0.00044915f, 
    -0.02168052f, -0.02570504f, -0.03769492f, -0.03187529f, 0.00107192f, 0.00202240f, -0.02031281f, -0.02928008f, 
    0.00644915f, 0.02810124f, -0.03426770f, -0.02009467f, -0.01174986f, 0.01342978f, 0.02605175f, -0.03371334f, 
    -0.03094751f, 0.00601557f, -0.03618021f, -0.02669458f, -0.03983586f, 0.01405199f, 0.01982136f, 0.00044834f, 
    0.01859863f, -0.03469771f, -0.02105402f, 0.00261390f, -0.04097939f, -0.03894541f, 0.02426559f, -0.04053311f, 
    0.02767411f, 0.01513000f, -0.02232774f, -0.03200889f, 0.02262718f, -0.03950805f, 0.02525230f, -0.00211598f, 
    -0.01072827f, -0.02314060f, 0.00156810f, -0.00691804f, -0.01903727f, 0.00786657f, -0.01308526f, -0.01963991f, 
    -0.04170969f, 0.02070645f, -0.00477769f, -0.02571948f, 0.02274572f, 0.00896049f, -0.02274961f, -0.00127275f, 
    -0.03667732f, -0.02914889f, -0.02428933f, -0.00764707f, -0.00658672f, -0.03402327f, -0.02060786f, -0.01660719f, 
    0.00462647f, -0.03784628f, -0.04208840f, -0.00848531f, 0.02501075f, -0.04172036f, -0.03316811f, -0.04022583f, 
    0.02640080f, 0.00262315f, 0.01190573f, -0.01779196f, 0.01567946f, -0.01399415f, 0.02500183f, -0.02525651f, 
    0.01087209f, 0.02282327f, -0.01985834f, -0.00499602f, -0.01584675f, -0.03601019f, -0.02016086f, -0.02214558f, 
    0.02325415f, 0.02192871f, -0.00045361f, -0.04080594f, -0.00065444f, 0.01847455f, -0.04108467f, -0.04073029f, 
    -0.01730010f, -0.03295998f, -0.03403297f, 0.00799137f, 0.02088248f, -0.01405597f, 0.01227306f, 0.00611992f, 
    -0.00561562f, -0.02147424f, -0.03570303f, -0.00849725f, 0.01983707f, 0.01825925f, -0.01729808f, 0.01671082f, 
    0.02799469f, -0.01073662f, -0.02808332f, -0.04193800f, -0.00238339f, -0.00251820f, -0.03312054f, 0.01785086f, 
    -0.03622223f, 0.00626433f, -0.01708043f, 0.02015798f, 0.02526082f, 0.01219920f, 0.02546583f, -0.03358684f, 
    -0.02167541f, -0.02843563f, -0.00418818f, -0.00130590f, 0.02791636f, 0.00662111f, 0.02550537f, -0.02630948f, 
    0.02911494f, 0.02175367f, -0.01715134f, 0.01580123f, -0.01244233f, 0.02911901f, -0.01283402f, 0.02682948f, 
    -0.02822484f, 0.01464380f, -0.02937285f, 0.00875307f, 0.02297154f, -0.01905899f, -0.00239088f, 0.01622947f, 
    0.00466981f, 0.01822313f, -0.03719121f, 0.01772703f, 0.01058075f, -0.02362592f, -0.02920414f, 0.00348424f, 
    -0.00808856f, -0.02506546f, 0.02380139f, 0.00977207f, -0.03560762f, -0.01837778f, 0.01133227f, -0.03516475f, 
    0.02856401f, -0.02035395f, 0.00366403f, -0.01875649f, -0.02148769f, -0.01583293f, 0.01087517f, -0.03949952f, 
    -0.02060116f, -0.00999837f, 0.00251167f, 0.00511301f, 0.01942803f, 0.02954219f, -0.00616291f, -0.01885672f, 
    -0.03025465f, -0.03988598f, 0.02974951f, -0.03922480f, -0.01198955f, 0.02790548f, -0.01355592f, 0.00108457f, 
    -0.02753218f, -0.03090635f, 0.02347284f, 0.02927222f, 0.02013957f, 0.00843625f, 0.02650812f, 0.01363224f, 
    0.01983727f, 0.02482780f, -0.00962215f, 0.01099266f, -0.00400399f, 0.00872096f, -0.02488288f, -0.03324067f, 
    -0.00280253f, -0.01140154f, 0.01092369f, 0.02396329f, -0.00277454f, 0.00429532f, -0.04201517f, 0.01443299f, 
    -0.03889646f, -0.01604993f, 0.01837052f, 0.00784488f, -0.02258831f, -0.00277921f, -0.01236336f, 0.01695162f, 
    0.01417686f, 0.02623449f, 0.00692742f, -0.03265284f, -0.00010550f, 0.01536880f, -0.00638138f, -0.02274523f, 
    0.01647486f, 0.01492210f, -0.01907347f, 0.01079867f, -0.02096223f, -0.01486486f, -0.00925725f, 0.00100745f, 
    0.01347582f, 0.01591869f, -0.03041193f, -0.03289421f, -0.00083091f, 0.02200588f, 0.00804704f, -0.02699200f, 
    0.00646526f, 0.00272940f, -0.03174341f, 0.01386113f, 0.02871820f, -0.03017449f, 0.01307404f, -0.00980766f, 
    -0.03321005f, 0.00185808f, -0.02259493f, 0.00424144f, -0.02378027f, 0.01162999f, -0.03898275f, -0.00150869f, 
    0.00869924f, -0.01865558f, -0.01146557f, 0.02213604f, -0.02140825f, -0.00360722f, -0.04163001f, -0.01532939f, 
    -0.00108282f, -0.01327090f, -0.00048254f, -0.00435348f, -0.02797646f, -0.00806390f, -0.02492308f, -0.01801954f, 
    -0.00751532f, -0.03590235f, -0.02736975f, -0.02527213f, 0.02663500f, 0.01898646f, -0.03914890f, 0.02580382f, 
    0.02171694f, 0.00421599f, 0.02157025f, -0.03896400f, -0.02993785f, 0.01088975f, -0.02240490f, -0.04131210f, 
    -0.00383933f, 0.01356424f, 0.01307035f, -0.02649256f, 0.02155332f, 0.00420811f, 0.00982668f, 0.00206915f, 
    -0.00228031f, 0.02352899f, -0.03826446f, -0.02933714f, -0.00923711f, -0.04177849f, 0.01787845f, -0.00302854f, 
    -0.01694886f, -0.00425854f, 0.02362509f, -0.03175471f, -0.00659908f, 0.00589059f, 0.02380081f, -0.01412174f, 
    0.02240817f, -0.03041257f, 0.01044784f, -0.02759241f, -0.01774293f, -0.02557972f, 0.03212646f, -0.03572342f, 
    0.02224725f, -0.02704525f, -0.02546721f, -0.02145931f, -0.03312333f, -0.03199569f, 0.00895540f, -0.02245227f, 
    -0.02161707f, 0.00065859f, -0.02138430f, 0.01697089f, -0.02718065f, -0.04214201f, 0.00019789f, -0.04034131f, 
    -0.01078224f, 0.00053039f, -0.02047073f, -0.03688479f, 0.00467685f, -0.03301902f, -0.01888115f, -0.01980468f, 
    -0.01046858f, 0.00171905f, 0.00957260f, -0.03344244f, -0.00672243f, -0.00988367f, -0.01414389f, -0.03558109f, 
    -0.02417110f, -0.01325737f, 0.01966211f, -0.04035948f, -0.00969904f, 0.01980382f, 0.02627365f, -0.03138242f, 
    -0.01511607f, -0.02229122f, -0.01130845f, 0.00454997f, -0.01279314f, 0.00195688f, -0.01897149f, -0.03683543f, 
    -0.00248940f, -0.03088125f, -0.03941166f, -0.04074756f, 0.01379363f, -0.01317134f, 0.02844171f, -0.00855166f, 
    -0.03626370f, -0.00870027f, 0.01878508f, 0.01070421f, -0.00196719f, -0.00091627f, 0.02075930f, -0.00459360f, 
    -0.02467756f, -0.03013155f, -0.00389733f, -0.01929040f, 0.00913376f, 0.02318201f, 0.01682504f, -0.03095596f, 
    -0.03004044f, 0.00098892f, -0.00684486f, -0.01459591f, -0.02513166f, -0.04127629f, -0.02786033f, 0.02093460f, 
    -0.01049633f, 0.02126810f, -0.03196843f, -0.00476357f, -0.00802116f, 0.00958737f, -0.02918280f, -0.01684629f, 
    -0.02284602f, 0.00636022f, -0.03106874f, -0.02169552f, 0.00079767f, -0.02182404f, 0.01327052f, 0.00746002f, 
    -0.01563661f, -0.00203379f, 0.01270674f, -0.02040743f, -0.04005182f, 0.00137031f, -0.00142214f, -0.02661102f, 
    0.00458667f, 0.01215041f, -0.01025924f, 0.00502283f, -0.03404372f, -0.02384982f, 0.01151111f, -0.00864616f, 
    -0.02547555f, -0.04130241f, 0.02620768f, -0.02777856f, 0.02173616f, 0.02823309f, -0.04016659f, -0.00355344f, 
    -0.00417322f, 0.02798468f, -0.02290532f, -0.00613990f, -0.01329488f, 0.01293616f, -0.01737106f, -0.02714708f, 
    0.02593187f, -0.03963691f, -0.02175900f, -0.04214017f, 0.02153285f, 0.00051692f, -0.03929606f, 0.00393193f, 
    0.01539012f, 0.01370567f, -0.00116927f, 0.02028127f, 0.01926303f, 0.00133759f, -0.00477471f, 0.00016355f, 
    0.00552338f, -0.02981235f, -0.01872344f, -0.02718734f, 0.00216079f, 0.00568909f, -0.01911602f, -0.04090708f, 
    -0.03657378f, 0.01157332f, 0.02081140f, -0.03593251f, -0.04166334f, 0.01346563f, 0.02266781f, -0.00834727f, 
    0.01898402f, 0.01574529f, 0.00152200f, -0.04134150f, -0.00564536f, -0.02158489f, 0.00396202f, -0.03449077f, 
    -0.04284501f, -0.04155010f, -0.00745702f, -0.04162265f, 0.01707897f, 0.01666095f, 0.02387575f, -0.02465113f, 
    0.01600939f, -0.01103861f, -0.00966682f, 0.02300803f, -0.03767594f, -0.01820215f, 0.02736489f, -0.03820177f, 
    -0.00070849f, 0.02729531f, -0.03982385f, -0.02703529f, 0.01486488f, -0.01469260f, -0.02822620f, -0.03930441f, 
    0.01828825f, -0.02447005f, -0.01275160f, 0.01876073f, -0.03511048f, -0.02467616f, -0.00530910f, 0.00499497f, 
    -0.00555748f, 0.01287170f, 0.01854469f, -0.03349115f, 0.01538088f, 0.01355412f, -0.00026046f, 0.01088727f, 
    0.02209530f, -0.00400822f, 0.00068204f, -0.02999490f, 0.00437783f, -0.04132603f, -0.00223270f, 0.00125361f, 
    -0.01207391f, 0.00149107f, -0.00779364f, 0.01031250f, 0.00464651f, -0.02228660f, 0.01688478f, -0.00378196f, 
    0.02638753f, 0.02682593f, 0.00418787f, -0.02533081f, -0.03124970f, -0.01312806f, -0.02669379f, -0.03904555f, 
    0.02310229f, 0.02267198f, -0.00254133f, -0.01482625f, 0.00437185f, 0.01294926f, 0.01297397f, -0.01601558f, 
    0.00117886f, 0.00545840f, -0.02932216f, 0.02138975f, -0.03563257f, -0.03975808f, -0.03842772f, -0.02051557f, 
    0.00691787f, 0.02790439f, 0.00900150f, 0.00585202f, -0.01052165f, 0.01045224f, -0.03773614f, -0.02634976f, 
    0.00373984f, 0.02007929f, 0.01763229f, -0.02929349f, 0.01458570f, -0.01515841f, -0.03837167f, 0.01301059f, 
    -0.03442785f, -0.03628899f, -0.01225661f, -0.00218183f, 0.00171188f, 0.02044505f, -0.02070245f, -0.01573497f, 
    -0.01927077f, -0.00689601f, -0.03618804f, -0.03804155f, 0.02032921f, -0.00155482f, 0.02075534f, -0.03331269f, 
    -0.03646257f, 0.00161979f, -0.03353155f, -0.03317038f, 0.02490350f, -0.02638357f, -0.00376533f, 0.01493960f, 
    0.00252465f, -0.00469201f, 0.01174841f, -0.00690867f, 0.00659136f, -0.01156508f, -0.02192498f, -0.02257864f, 
    -0.02908731f, 0.01848090f, 0.02212575f, 0.00267317f, 0.00833624f, -0.01500360f, -0.02293795f, -0.01110072f, 
    0.02754164f, -0.00142076f, -0.03588660f, 0.00316217f, 0.00678951f, 0.02418626f, -0.02594917f, 0.01066263f, 
    -0.02959790f, 0.02735850f, -0.04235320f, -0.03089074f, -0.03295573f, -0.03034624f, -0.00266248f, -0.01002336f, 
    -0.03777608f, -0.00531953f, 0.02187090f, -0.01053218f, -0.00709308f, -0.03981612f, 0.00299394f, 0.00721687f, 
    -0.01096927f, -0.01751141f, -0.01933420f, -0.02534944f, 0.01456586f, 0.01835598f, -0.01772966f, -0.02012518f, 
    0.02532803f, -0.02784136f, 0.00635523f, -0.00292290f, -0.01270030f, -0.01587989f, -0.01691745f, 0.00717892f, 
    -0.01630230f, 0.00205214f, -0.00365046f, -0.03325626f, -0.03031131f, -0.00839507f, -0.02228341f, 0.00968219f, 
    -0.03302507f, 0.00520374f, -0.02325086f, -0.00234987f, -0.04125220f, -0.02724220f, 0.02540722f, 0.00394387f, 
    -0.03192735f, 0.02092209f, -0.00018541f, -0.00484826f, 0.01811714f, -0.00438851f, -0.01387955f, -0.03179349f, 
    -0.03032617f, 0.02790179f, -0.04078298f, -0.04003343f, -0.02917311f, 0.02424513f, -0.00628050f, 0.00665985f, 
    -0.03631786f, 0.02521902f, -0.04263123f, -0.04092238f, 0.00364630f, 0.00110901f, -0.01423285f, 0.01403820f, 
    -0.00280168f, 0.00697227f, 0.01236328f, 0.00043117f, 0.02851796f, -0.02564930f, 0.02617133f, 0.02122693f, 
    -0.03599416f, -0.01546911f, -0.01817700f, -0.00056213f, -0.03332008f, -0.03131464f, -0.00984918f, -0.00211738f, 
    0.00324742f, -0.02692040f, -0.02897982f, -0.01597203f, -0.01962651f, -0.01548567f, 0.02580182f, -0.01805799f, 
    -0.01892908f, -0.00013709f, 0.01224049f, 0.02748816f, -0.03510376f, 0.00702501f, -0.01310316f, -0.00133285f, 
    0.02518429f, -0.03111859f, 0.00595968f, -0.01884446f, -0.02528169f, -0.04101814f, 0.02995037f, 0.02439619f, 
    -0.01817098f, -0.02735704f, 0.01326915f, 0.01212868f, 0.00168658f, -0.00300423f, -0.01433664f, 0.01907292f, 
    -0.03214375f, 0.02369771f, 0.01451970f, -0.02908839f, 0.00296411f, -0.01430731f, 0.01976811f, 0.00450640f, 
    -0.02906204f, -0.01755380f, -0.03536372f, -0.02074867f, 0.02299410f, -0.02664564f, -0.03623593f, 0.02812276f, 
    -0.03291016f, 0.02190765f, 0.01262308f, -0.01657915f, -0.03032406f, -0.02040901f, -0.01074449f, 0.00558553f, 
    0.01246229f, -0.02192738f, 0.00002333f, -0.02605470f, -0.03911981f, -0.02664666f, -0.02370485f, -0.03948929f, 
    -0.03505563f, -0.02650312f, 0.00575175f, -0.01183827f, -0.02713156f, 0.01205233f, -0.03365326f, -0.01891706f, 
    -0.01010093f, -0.00551963f, -0.00807174f, -0.00004714f, 0.02041118f, -0.03924011f, -0.00502267f, -0.01142800f, 
    0.00872131f, 0.00691619f, -0.03739289f, -0.00109066f, -0.02331663f, 0.00296112f, 0.01708251f, -0.03247178f, 
    -0.02946767f, -0.03507851f, -0.03678861f, 0.00940271f, 0.01004464f, -0.02246762f, -0.03514176f, 0.01975136f, 
    -0.02950157f, 0.01925920f, -0.03461051f, -0.03096116f, 0.01191776f, -0.01401370f, -0.03062711f, 0.00564550f, 
    -0.02935234f, -0.03532716f, -0.01871492f, 0.02290979f, -0.00956882f, -0.04048646f, 0.01737870f, 0.00345269f, 
    -0.01580199f, -0.02938735f, 0.00983241f, 0.01400378f, 0.01238398f, 0.03087001f, 0.02463209f, -0.04245253f, 
    -0.00652260f, 0.01815940f, 0.01517482f, 0.00273128f, -0.02022120f, 0.02469191f, 0.00518166f, 0.01463804f, 
    0.01169924f, -0.03318524f, -0.01749444f, -0.03791184f, 0.01183491f, 0.00768759f, 0.00105981f, -0.02262954f, 
    -0.02295857f, -0.03910962f, 0.00199414f, 0.02056713f, -0.02119300f, -0.04192193f, 0.00755311f, -0.00855183f, 
    0.01657122f, -0.04033941f, -0.02719489f, -0.01840210f, -0.01937954f, 0.01727104f, 0.01663905f, -0.01907735f, 
    -0.00564419f, -0.01812950f, 0.00288082f, 0.02159770f, -0.00222958f, 0.01157213f, 0.02019081f, -0.00499872f, 
    -0.01018558f, 0.02820312f, -0.00761590f, -0.00434368f, 0.02508234f, 0.01765300f, -0.02133327f, 0.00785642f, 
    0.01239821f, 0.02480401f, -0.03018409f, -0.01669209f, 0.01223076f, -0.02600968f, 0.00815555f, -0.00491717f, 
    0.01032094f, 0.00024693f, -0.03232963f, 0.03007299f, 0.00037777f, 0.02353939f, 0.02914296f, 0.01749745f, 
    -0.00707719f, 0.02500802f, -0.03522916f, 0.01559711f, -0.01902352f, 0.00484940f, -0.01849609f, 0.01145551f, 
    -0.03466268f, -0.02767610f, -0.03571305f, -0.02653664f, -0.02392415f, -0.00418666f, 0.00013040f, -0.02374754f, 
    -0.03955819f, 0.00040020f, -0.01227944f, 0.02815682f, 0.01282102f, -0.03881327f, -0.00966589f, -0.02067992f, 
    -0.01217118f, -0.03311648f, -0.00746047f, 0.00951911f, -0.00555583f, 0.01018540f, -0.03934774f, -0.02265730f, 
    -0.01241304f, -0.03526604f, 0.01260197f, 0.02137738f, -0.02112891f, -0.01400925f, -0.00235503f, 0.00356190f, 
    -0.03043049f, -0.00003643f, -0.02365398f, 0.01489866f, -0.00162392f, -0.03425497f, 0.00827278f, 0.01006605f, 
    0.01437168f, -0.02580692f, 0.01755008f, -0.00474783f, -0.02858307f, 0.02703718f, 0.00609871f, -0.00903564f, 
    0.00995483f, 0.00023688f, -0.02886997f, -0.03852174f, 0.00737837f, 0.00456003f, -0.01078134f, 0.00430013f, 
    0.01339108f, -0.00344108f, 0.01282232f, -0.02764907f, -0.02760158f, -0.02917315f, 0.01400293f, -0.01774151f, 
    -0.01754255f, 0.01780018f, -0.03707685f, -0.03596600f, 0.02058525f, -0.01298535f, -0.02006834f, -0.01044956f, 
    -0.04035523f, -0.02140222f, 0.00632678f, -0.01504611f, 0.01881979f, -0.02361847f, 0.00202176f, 0.00911898f, 
    0.00076183f, -0.02780651f, 0.01181887f, -0.03298857f, 0.01507701f, 0.01462827f, -0.01383485f, -0.02968477f, 
    -0.04303761f, -0.04513404f, -0.01908893f, 0.01452316f, 0.01241446f, -0.01775057f, 0.02518764f, 0.00668028f, 
    0.01731160f, -0.00355003f, -0.03359448f, 0.02517926f, -0.01055754f, -0.04379984f, -0.00779606f, -0.00481933f, 
    0.01716074f, -0.00726073f, 0.01869459f, 0.02472638f, -0.00062227f, -0.01128832f, -0.00290177f, -0.00309823f, 
    0.02038233f, -0.02943529f, 0.01579153f, 0.01004466f, -0.03234579f, -0.00174768f, -0.02705105f, 0.01174718f, 
    0.01469534f, -0.00377557f, 0.02153601f, 0.01256331f, -0.03327415f, 0.00774081f, -0.04313037f, -0.00028461f, 
    -0.03306678f, 0.01255865f, 0.02108631f, -0.03462565f, 0.00517374f, -0.03400505f, -0.01429804f, -0.02901673f, 
    -0.01916510f, 0.02514901f, -0.00692606f, 0.02526705f, 0.00593038f, 0.00573543f, 0.00278301f, -0.03157267f, 
    -0.02974596f, 0.01966189f, 0.01393443f, 0.01386588f, 0.02605589f, -0.02738835f, 0.01680515f, -0.01335263f, 
    -0.00553407f, -0.00052442f, -0.00829555f, 0.01297616f, -0.01600597f, 0.01198458f, 0.00780305f, 0.02617485f, 
    0.01438693f, -0.00099754f, -0.03196808f, -0.03758162f, -0.00105261f, -0.04550872f, -0.03468400f, -0.02099716f, 
    0.00171384f, 0.01144838f, 0.01479413f, -0.03888081f, -0.02326306f, 0.02401501f, -0.04179573f, -0.04530386f, 
    -0.03340165f, -0.02149116f, 0.01347265f, -0.01556118f, 0.00849291f, 0.01225424f, -0.00146472f, -0.03637409f, 
    -0.02448823f, -0.02826954f, -0.00737080f, -0.03164753f, 0.01714615f, 0.01061270f, 0.01836080f, -0.01103895f, 
    0.01738139f, -0.01147537f, -0.00307970f, 0.02151866f, 0.01157492f, -0.00226848f, 0.00672132f, -0.00250241f, 
    0.00336266f, -0.02984164f, -0.02365241f, -0.03177548f, -0.03921431f, -0.04363301f, -0.04115484f, 0.01209657f, 
    0.01876111f, 0.00378969f, 0.01725369f, -0.00519257f, 0.01668675f, 0.02473444f, -0.00260597f, -0.01754479f, 
    -0.01356052f, -0.01551399f, -0.01398197f, 0.01229320f, -0.03693055f, 0.01987725f, 0.02325796f, 0.01236476f, 
    0.01797807f, -0.03486321f, 0.01795771f, 0.00309763f, 0.02381125f, -0.04221339f, 0.01467033f, -0.01871839f, 
    0.01802772f, -0.03563072f, 0.01232286f, -0.01178146f, -0.01979810f, -0.01894173f, -0.03528011f, -0.02447226f, 
    0.01576082f, -0.01279646f, -0.04095477f, -0.00428343f, -0.02288326f, 0.02357743f, -0.02940789f, -0.00102333f, 
    -0.04344337f, -0.00347893f, -0.01326779f, -0.04024857f, -0.00962448f, -0.03686657f, -0.01559697f, -0.03982688f, 
    -0.01159036f, 0.02393648f, 0.01494201f, -0.03450466f, 0.01163605f, 0.02201835f, 0.00018060f, -0.00641810f, 
    -0.04258686f, 0.00814398f, -0.03856469f, -0.01742225f, 0.01173974f, -0.03868859f, -0.03166807f, 0.01858751f, 
    -0.02251878f, -0.01142831f, 0.00331150f, -0.01813398f, -0.01210318f, 0.02065912f, -0.01283420f, -0.03063684f, 
    0.00364374f, -0.04543424f, 0.01504517f, 0.01813554f, 0.00212361f, 0.02276006f, -0.00805702f, -0.01847643f, 
    -0.00493439f, -0.02207927f, -0.00051225f, 0.00366573f, -0.03098376f, -0.00182770f, 0.01611746f, -0.00160195f, 
    0.00153190f, -0.01588234f, 0.01925024f, -0.03756898f, 0.01400460f, 0.01958994f, -0.04053129f, 0.01427489f, 
    -0.03733946f, -0.02037307f, 0.00986500f, 0.01087468f, 0.00799794f, -0.01604153f, 0.02509103f, 0.02270460f, 
    -0.00407463f, 0.02370934f, -0.01692242f, -0.02245055f, -0.01857558f, 0.00418712f, -0.00849693f, 0.01887319f, 
    -0.00151214f, 0.01134344f, -0.00855373f, 0.02060301f, 0.00977378f, -0.00293361f, -0.04117017f, -0.01796620f, 
    0.00882512f, 0.00201468f, -0.01182242f, -0.01761846f, -0.04313860f, -0.02462159f, 0.02091905f, -0.02319536f, 
    -0.04260559f, -0.01419680f, -0.00881197f, 0.00039523f, -0.02641054f, -0.01494084f, -0.02623086f, -0.03528012f, 
    -0.03325531f, -0.02311762f, -0.00038775f, 0.01109534f, -0.04087328f, -0.01974852f, -0.02367725f, -0.02897403f, 
    0.02046985f, -0.01868209f, -0.00334862f, 0.00052496f, -0.02120050f, 0.00196006f, -0.01303204f, 0.01901303f, 
    -0.02290951f, -0.04575562f, -0.02261710f, 0.02476749f, 0.01049248f, 0.01107907f, -0.03382592f, -0.01076245f, 
    -0.02594494f, 0.00160794f, -0.01638599f, -0.00190478f, -0.00759685f, 0.00231202f, 0.01912805f, -0.03435104f, 
    0.01173213f, -0.01821402f, -0.01070487f, 0.00409165f, -0.00609224f, -0.03731983f, 0.02605101f, -0.00411996f, 
    0.00147783f, -0.01556042f, 0.00373430f, -0.04210544f, -0.02126363f, -0.01625750f, -0.04031432f, -0.03688026f, 
    -0.01651107f, 0.00022353f, -0.03631785f, -0.00638483f, 0.01682342f, -0.04542969f, -0.01286640f, -0.03742519f, 
    -0.00370958f, -0.00377195f, -0.02992387f, -0.01716197f, -0.00582477f, -0.00257983f, 0.02233507f, 0.02489761f, 
    -0.03600356f, 0.02423355f, 0.01142225f, -0.00615416f, -0.03374584f, -0.02627249f, -0.02048960f, -0.01777183f, 
    -0.03229826f, 0.01600342f, 0.02615817f, -0.02768072f, -0.02530286f, -0.03192744f, -0.01527074f, -0.03614461f, 
    0.01709930f, -0.02017291f, -0.00695481f, -0.04569637f, -0.00169290f, -0.00123784f, -0.04655358f, -0.00852839f, 
    0.00149706f, -0.02500044f, 0.02398952f, 0.01706780f, -0.01091043f, -0.04240130f, 0.01867145f, 0.01952413f, 
    0.00150575f, -0.02488351f, -0.02883550f, -0.01632291f, -0.03883693f, 0.01325195f, -0.03432091f, -0.00747131f, 
    -0.03421037f, -0.03108641f, 0.02306747f, -0.04277060f, 0.00989599f, -0.01962200f, -0.00912850f, -0.02494388f, 
    -0.03731304f, -0.01655379f, -0.03267580f, 0.00075244f, -0.00670505f, -0.02126673f, -0.01867176f, -0.00639900f, 
    0.01749585f, -0.01107867f, 0.01708758f, -0.01340600f, -0.00578297f, -0.00361784f, -0.03847253f, 0.00448367f, 
    -0.03662373f, -0.04521460f, 0.02282676f, -0.03412797f, 0.01490485f, 0.01654657f, 0.00320140f, 0.00064829f, 
    -0.03955030f, -0.00868334f, 0.01148560f, 0.01295851f, 0.02056069f, 0.01893870f, 0.00310823f, -0.01837506f, 
    0.00583996f, -0.03839254f, -0.04150275f, 0.01853531f, -0.02004762f, -0.00672195f, 0.02585278f, -0.04174181f, 
    0.00010670f, -0.00972479f, 0.00607353f, -0.01289671f, -0.03375268f, 0.00362575f, 0.02058313f, 0.01757854f, 
    -0.01166392f, 0.02227019f, -0.00474593f, 0.01554239f, -0.01430699f, 0.00112324f, 0.01766929f, 0.00404398f, 
    -0.00370072f, -0.00572398f, 0.00321909f, -0.03181980f, -0.01688234f, -0.04300114f, 0.02161579f, -0.00326814f, 
    -0.04333000f, 0.00070879f, -0.02926954f, -0.03729983f, 0.01783726f, -0.00332089f, 0.00518783f, 0.00969545f, 
    -0.00808666f, -0.04280705f, 0.02387412f, -0.00850585f, -0.04320389f, 0.02100643f, 0.00039085f, 0.00325480f, 
    -0.01316268f, -0.01749308f, -0.01155183f, -0.04201726f, -0.02653396f, 0.00757243f, 0.01212849f, -0.02059552f, 
    -0.00956846f, -0.03092717f, -0.02766295f, 0.02519294f, -0.03557054f, -0.03176507f, 0.02650806f, -0.02099050f, 
    0.01561374f, -0.02656013f, -0.04190043f, -0.02938233f, 0.01852819f, -0.00900521f, 0.00267991f, 0.00380314f, 
    -0.01386777f, 0.01298948f, -0.00648801f, -0.03050779f, -0.02270689f, 0.02547882f, -0.00306428f, -0.00544107f, 
    -0.02740038f, -0.02763987f, -0.03806090f, -0.04132602f, 0.01397608f, -0.01468376f, 0.01005013f, 0.00625778f, 
    -0.01773429f, 0.02353819f, 0.00605579f, 0.01472351f, 0.01732368f, -0.00636190f, 0.02370502f, -0.03247067f, 
    -0.01562705f, -0.00834059f, 0.02504152f, -0.04318585f, -0.00858777f, 0.00462604f, -0.02311762f, -0.04422356f, 
    0.00246128f, -0.03853345f, 0.01357614f, -0.00996735f, -0.03579392f, 0.01541666f, -0.00576598f, 0.02324293f, 
    0.01772873f, -0.02247963f, 0.02154180f, -0.02228333f, 0.01509764f, -0.01379464f, 0.00442075f, -0.03615391f, 
    -0.01677800f, -0.00213009f, 0.01997360f, 0.00024150f, -0.04182999f, -0.01038223f, 0.00436908f, 0.02183617f, 
    0.01836159f, 0.01982944f, -0.02934482f, -0.02505519f, -0.01776503f, 0.00812086f, 0.00026022f, 0.00006269f, 
    0.01805855f, 0.00750306f, -0.04080528f, -0.03715321f, 0.00276406f, -0.01052717f, -0.02243803f, -0.00408235f, 
    -0.01822052f, 0.01440509f, -0.01720160f, -0.02244749f, -0.02362373f, 0.00355046f, 0.00308838f, -0.03732141f, 
    -0.01343987f, -0.01937335f, 0.02450180f, -0.02631018f, 0.01270138f, -0.04378328f, -0.02154405f, 0.00515892f, 
    0.00791006f, -0.02431057f, 0.00282922f, 0.02402630f, 0.01193509f, -0.00311749f, -0.00630643f, 0.01122784f, 
    -0.00062775f, -0.00041641f, -0.03300013f, 0.01613698f, 0.00349528f, 0.01330913f, 0.01431299f, -0.04599516f, 
    -0.00333172f, 0.00853759f, -0.03493793f, -0.03369183f, -0.00182450f, -0.03726036f, -0.03391432f, -0.01583126f, 
    0.02206516f, -0.02125501f, 0.01786843f, -0.02719900f, -0.02622323f, -0.02013128f, -0.01870702f, 0.03057181f, 
    -0.00605180f, 0.00039122f, -0.01430714f, 0.00594269f, 0.01770831f, -0.01088187f, -0.03929507f, 0.00182824f, 
    0.01399785f, 0.00699426f, -0.02384206f, -0.01453288f, 0.00544794f, 0.01817189f, -0.02141952f, -0.01231615f, 
    0.02537187f, 0.02008078f, -0.04090568f, 0.02483600f, 0.01480492f, 0.00278757f, 0.02219101f, 0.02078504f, 
    0.02292312f, -0.03195007f, -0.02967081f, -0.02095444f, -0.03295716f, 0.01066773f, -0.00408328f, -0.00149360f, 
    -0.01401752f, -0.01759757f, -0.00209033f, -0.01112666f, -0.01317861f, -0.03331599f, 0.02397257f, 0.00121300f, 
    -0.00606685f, -0.02479497f, -0.04202175f, -0.01713897f, 0.01064813f, 0.00640443f, -0.03152396f, -0.00141474f, 
    0.00447942f, -0.01677221f, -0.01120665f, -0.01970045f, -0.01254849f, 0.01010895f, -0.02523810f, -0.00578963f, 
    -0.02719471f, -0.00350925f, 0.02181272f, 0.02226059f, -0.04123861f, -0.03731607f, 0.02161415f, 0.01772383f, 
    -0.04104151f, -0.02415829f, 0.01610578f, -0.00994035f, -0.03074927f, -0.01254257f, -0.01046436f, 0.01470675f, 
    0.01108746f, -0.03352589f, -0.02757262f, -0.00036819f, -0.00709154f, 0.00203135f, -0.00135428f, -0.03043474f, 
    -0.03735963f, -0.00833137f, 0.01431663f, 0.01901338f, -0.02070688f, 0.02355318f, 0.01948566f, -0.03748875f, 
    0.00602564f, -0.01449416f, -0.03764381f, 0.02568863f, -0.03179614f, -0.01080246f, 0.00996421f, -0.01076865f, 
    -0.02375965f, 0.00796074f, 0.02207970f, -0.00073409f, -0.00183626f, -0.03860198f, -0.03209925f, 0.02268589f, 
    -0.02428758f, 0.00754142f, -0.04146259f, 0.01394384f, -0.03253331f, -0.03700581f, -0.03759214f, -0.02883197f, 
    0.01074626f, 0.01714749f, -0.00775291f, 0.01970348f, 0.01060736f, -0.00887857f, -0.00524340f, -0.02667039f, 
    -0.01783010f, 0.01055579f, 0.01650369f, 0.01972208f, 0.01238476f, 0.01310515f, -0.04017927f, -0.03888710f, 
    0.01078003f, -0.01662554f, 0.00574374f, 0.00202081f, -0.02000242f, 0.01166209f, -0.02632148f, -0.03696381f, 
    -0.04275267f, 0.00917132f, 0.02039391f, 0.02456260f, -0.02328133f, -0.02771615f, -0.02958293f, -0.00007357f, 
    -0.03305636f, -0.00675053f, -0.04483799f, 0.00827152f, 0.01784920f, -0.04253076f, -0.00577541f, 0.01871406f, 
    0.01115527f, -0.02266018f, -0.00004900f, -0.00576095f, 0.01022942f, -0.00993522f, -0.03292479f, 0.01467902f, 
    0.02572018f, -0.00873759f, 0.01628832f, -0.04288397f, -0.00554298f, 0.01383206f, -0.00888882f, 0.02891407f, 
    0.01280168f, 0.01753157f, 0.02478804f, -0.00597237f, -0.00443211f, 0.00724194f, 0.02721671f, -0.00044314f, 
    0.01491406f, -0.01386643f, -0.03134479f, -0.00520595f, -0.03826337f, -0.02784090f, 0.02303570f, 0.00774017f, 
    -0.01752669f, 0.02928039f, 0.02890358f, 0.01242886f, 0.00737805f, -0.02013512f, -0.00991830f, -0.00619096f, 
    -0.02861875f, -0.01638932f, 0.00962061f, -0.00742719f, -0.00473832f, 0.00058188f, 0.01579533f, -0.00082037f, 
    -0.03462893f, -0.01488601f, 0.02950566f, 0.01577619f, 0.01478945f, -0.02560993f, 0.01867613f, 0.01066584f, 
    0.01440550f, -0.03879582f, 0.00223084f, -0.01859287f, -0.01465049f, 0.02341192f, 0.01723810f, 0.01312137f, 
    -0.00614929f, 0.02990208f, -0.02268976f, 0.00896333f, -0.01792547f, 0.03380930f, -0.02057481f, -0.03467559f, 
    -0.04115577f, -0.03983947f, -0.02696488f, -0.00901364f, 0.01531182f, 0.00385806f, 0.01566322f, -0.02052690f, 
    0.00942330f, 0.01063801f, -0.01310399f, 0.01903148f, -0.02461336f, -0.02712209f, -0.00193200f, -0.01164357f, 
    0.01521274f, 0.02003038f, -0.02028638f, -0.03264385f, -0.03676971f, -0.03786723f, -0.03749386f, -0.01813403f, 
    -0.03034122f, 0.03041094f, -0.02347400f, -0.02484192f, 0.02548607f, -0.02559048f, -0.01301526f, -0.02143645f, 
    0.02272841f, -0.01384530f, 0.00916412f, -0.01907955f, -0.01447310f, -0.01648918f, 0.00415827f, 0.01920392f, 
    0.00940657f, -0.02523929f, -0.02772821f, -0.00846121f, 0.01701711f, 0.01963018f, 0.00055511f, -0.03323765f, 
    -0.02548821f, -0.02326636f, -0.01565551f, 0.01351429f, -0.00869122f, -0.03090336f, 0.01675374f, 0.03015485f, 
    -0.03100576f, 0.01756303f, -0.01691324f, -0.01555599f, 0.00788501f, 0.00941428f, 0.00126285f, 0.00708578f, 
    -0.02409861f, 0.02713112f, -0.03752774f, 0.00173604f, 0.01583593f, 0.00383461f, -0.03853587f, 0.00611091f, 
    -0.02974345f, 0.02414046f, 0.00907442f, -0.00551986f, 0.01465532f, 0.02479924f, 0.00476853f, -0.02046971f, 
    -0.01413130f, -0.00028608f, 0.00726883f, 0.01901331f, 0.01338919f, 0.00567236f, 0.02519464f, 0.01920454f, 
    0.02780134f, -0.00725128f, -0.01072010f, -0.00988145f, 0.02542766f, -0.03454725f, -0.03101782f, -0.03073913f, 
    -0.00444322f, -0.03163528f, 0.01190178f, -0.00451982f, 0.00888546f, 0.00666645f, -0.01792584f, -0.01518181f, 
    0.00208744f, -0.00064558f, -0.02733536f, -0.03384710f, 0.02411059f, -0.01404571f, -0.03992268f, -0.01842091f, 
    -0.01530138f, 0.00381305f, -0.00118185f, -0.01617092f, 0.03336876f, -0.00893200f, 0.00627051f, -0.03315778f, 
    0.01888011f, 0.00813231f, 0.01406263f, 0.02603372f, 0.01347484f, 0.00905654f, -0.00783347f, -0.03130763f, 
    0.01229613f, 0.01412812f, -0.01111084f, 0.00484756f, -0.03478374f, -0.03690604f, 0.01212833f, -0.03879249f, 
    0.02683197f, -0.02632271f, -0.01891643f, 0.02183527f, 0.00379201f, -0.03310534f, 0.00062927f, 0.01859824f, 
    0.02860681f, -0.00194291f, 0.00010496f, 0.00096175f, -0.03288032f, -0.02632429f, -0.03120329f, -0.02428940f, 
    0.02523675f, -0.03249341f, -0.00056655f, -0.02583795f, -0.02897108f, -0.01593025f, 0.02634562f, 0.02502984f, 
    0.02396373f, 0.00648334f, -0.01239245f, 0.02314971f, -0.03450648f, -0.03564372f, -0.02017217f, 0.01374326f, 
    -0.01457558f, -0.01392729f, -0.01112968f, 0.00011847f, -0.00343206f, 0.00865285f, -0.01231827f, 0.03043047f, 
    -0.01948102f, 0.00887370f, -0.01825512f, 0.01818468f, -0.01059962f, 0.02042524f, -0.03093655f, -0.01144923f, 
    -0.02196801f, 0.00172809f, 0.01368998f, -0.01614003f, 0.00196289f, 0.01961957f, -0.03116222f, 0.01293559f, 
    -0.01796363f, -0.02347134f, -0.02822547f, 0.00032397f, 0.01452958f, 0.00413437f, -0.00137804f, 0.01117952f, 
    0.02259094f, -0.00647063f, 0.03003282f, -0.01564525f, 0.01681388f, 0.01836654f, -0.03620674f, -0.01867863f, 
    0.03019123f, -0.02153770f, 0.00958354f, -0.00471754f, -0.02109551f, -0.03168875f, 0.00933729f, 0.00745876f, 
    0.03077789f, -0.03595144f, -0.01233310f, -0.00696877f, 0.02733323f, -0.01065230f, 0.02312884f, 0.00757295f, 
    -0.03707447f, -0.00034829f, 0.02137734f, -0.02203867f, 0.00218623f, -0.01362150f, 0.00143862f, -0.01325359f, 
    -0.00274996f, 0.00295737f, -0.03882948f, -0.03362288f, 0.02449697f, 0.01021862f, -0.00118417f, -0.02924150f, 
    -0.00170419f, -0.02190349f, -0.03409611f, -0.03029794f, -0.03153471f, -0.04139128f, -0.03245481f, 0.01233170f, 
    0.00527274f, 0.01142119f, -0.03172049f, 0.01295755f, -0.00798852f, -0.04060766f, -0.02334669f, 0.00530476f, 
    -0.03658764f, 0.01155837f, -0.02655941f, 0.02900114f, 0.00979196f, 0.00072277f, 0.01629922f, -0.02662585f, 
    -0.01587288f, 0.01273424f, 0.01084146f, 0.01729572f, -0.03948283f, -0.00536236f, -0.03537136f, 0.00841238f, 
    0.00561512f, -0.02332770f, -0.03420516f, -0.02404374f, -0.03672883f, -0.01032026f, -0.02798125f, -0.02908994f, 
    0.02965808f, 0.02708149f, -0.02218444f, -0.02468582f, -0.03005626f, -0.03404374f, -0.02382177f, 0.00783963f, 
    0.01551617f, -0.00702155f, -0.03850755f, -0.02654921f, -0.01478383f, -0.01450480f, 0.01866749f, 0.02514599f, 
    0.00035482f, -0.00273274f, -0.01516461f, 0.02093145f, -0.00121265f, 0.02690774f, -0.03763151f, -0.01071389f, 
    -0.03815639f, -0.03877591f, -0.02908392f, 0.01954309f, 0.00262653f, -0.02847581f, 0.02360587f, -0.03356021f, 
    0.02115774f, -0.02210956f, 0.02483844f, 0.01453637f, 0.02662512f, 0.01894208f, -0.02644019f, -0.02245161f, 
    0.02198954f, -0.01311410f, -0.00249888f, 0.01534005f, 0.02847840f, -0.03855438f, -0.01347690f, 0.01089320f, 
    0.02295218f, 0.02963952f, 0.02510530f, 0.02507568f, -0.03305283f, -0.02343159f, 0.02970955f, 0.00938333f, 
    0.02285902f, 0.02256409f, 0.00255885f, -0.00471122f, 0.00577870f, -0.02226196f, 0.01305008f, -0.03605282f, 
    -0.02817702f, -0.01898519f, -0.01465515f, -0.00837336f, 0.00278265f, 0.02147430f, -0.02794967f, 0.00546397f, 
    -0.01950686f, -0.00949342f, 0.01253694f, -0.02109263f, -0.01822679f, 0.02544077f, -0.01525437f, -0.00039489f, 
    0.02395547f, -0.00733045f, -0.00483949f, 0.01987512f, 0.01281488f, -0.01949279f, -0.01959234f, -0.00723781f, 
    0.00751062f, 0.02648269f, -0.01428117f, -0.02586034f, 0.02132529f, -0.01648999f, 0.02693782f, -0.01365681f, 
    0.01600409f, 0.00591512f, -0.00808631f, -0.00904295f, -0.01864319f, 0.01488133f, -0.02960238f, 0.00406433f, 
    -0.02931799f, 0.01004995f, 0.00781169f, -0.00324035f, 0.02360851f, -0.01697596f, -0.02137411f, -0.01130101f, 
    -0.02114481f, -0.00949165f, 0.02763687f, -0.01541383f, -0.03459687f, 0.00384838f, 0.00609699f, 0.00318817f, 
    -0.02653953f, -0.02572635f, -0.01931926f, -0.00978470f, 0.02000066f, -0.03646100f, 0.01643376f, 0.01612784f, 
    0.01417132f, -0.00414472f, -0.03249109f, 0.01006109f, -0.00086045f, 0.00340906f, 0.00714500f, 0.02933331f, 
    -0.01482061f, 0.01885548f, -0.01055305f, -0.00987050f, -0.04074551f, -0.00827592f, -0.03648222f, -0.01034500f, 
    0.01388809f, 0.01624594f, -0.01828390f, -0.03320298f, 0.01623889f, -0.01044337f, -0.01664068f, -0.04026965f, 
    -0.01007051f, -0.03757655f, -0.00787509f, 0.00741441f, -0.00546493f, -0.02686013f, -0.00042909f, 0.02895719f, 
    -0.00531178f, -0.04121513f, -0.02044387f, 0.01062217f, -0.02975149f, -0.01909903f, -0.01799806f, -0.00457197f, 
    0.00261848f, 0.03048686f, -0.01757598f, 0.00286889f, -0.01278597f, 0.01685317f, 0.00639681f, -0.02422242f, 
    0.00918197f, 0.00345170f, -0.03047913f, 0.02409794f, 0.01919303f, -0.01189501f, -0.03204319f, -0.02483591f, 
    0.02560151f, -0.04111766f, -0.00536071f, 0.01799582f, 0.02346957f, 0.00712379f, -0.00624256f, 0.01786619f, 
    -0.01575252f, 0.01142500f, -0.02231313f, -0.03133543f, -0.02795779f, 0.02261565f, -0.01950116f, -0.02501882f, 
    -0.01612721f, 0.00830032f, 0.02523752f, -0.01631280f, 0.00611975f, -0.01147288f, 0.01368494f, 0.00371195f, 
    0.00981388f, 0.02537216f, 0.03084842f, 0.00807248f, -0.00512028f, -0.01379443f, 0.01073132f, -0.00390537f, 
    -0.00311061f, -0.02704374f, 0.02195542f, 0.00507533f, -0.02743981f, -0.03292986f, 0.03041654f, -0.01419954f, 
    -0.00245004f, -0.00596536f, -0.02993762f, 0.01695438f, 0.00352430f, 0.02980657f, -0.01232999f, -0.02273672f, 
    -0.02219417f, -0.03487452f, -0.03485544f, 0.01317954f, 0.01969377f, -0.00387974f, -0.01488211f, 0.00941009f, 
    -0.01375441f, -0.02991534f, 0.02164884f, 0.01596033f, -0.03206072f, -0.00317498f, -0.03052987f, -0.03993005f, 
    -0.03209005f, -0.02473491f, -0.02997204f, 0.00923281f, -0.00617016f, -0.00779000f, 0.02978052f, -0.01553668f, 
    -0.00630794f, -0.02240643f, -0.03336867f, 0.02369140f, -0.01945203f, -0.00150188f, 0.01722794f, -0.02273920f, 
    0.03228250f, 0.01363021f, -0.03905318f, -0.00998702f, -0.02311926f, -0.01335494f, 0.02043946f, 0.00685111f, 
    -0.03440551f, -0.03637107f, -0.01715760f, -0.00565571f, 0.01589731f, 0.01203341f, -0.02421426f, -0.02190395f, 
    0.00711357f, -0.01499766f, -0.02318895f, -0.02548731f, -0.02483566f, 0.00088719f, 0.02095497f, -0.00487222f, 
    -0.02154095f, 0.02382719f, -0.02655941f, -0.00505037f, -0.00384830f, -0.00836700f, 0.01656823f, -0.04101186f, 
    0.02314001f, 0.03245551f, -0.02156603f, 0.01923674f, -0.00393207f, 0.01080174f, 0.02655984f, -0.00540545f, 
    0.00672520f, -0.00382058f, -0.01927030f, -0.00466483f, 0.01312744f, -0.03490958f, 0.00411383f, -0.01556056f, 
    0.00804497f, -0.00109591f, -0.02549418f, 0.01790133f, -0.02535869f, -0.03385121f, 0.00333050f, -0.01239883f, 
    -0.02745589f, -0.01750300f, 0.01597992f, -0.00897268f, -0.01853380f, -0.00982070f, -0.03694442f, -0.03654503f, 
    -0.00803099f, -0.03547527f, -0.02022062f, 0.00171701f, 0.00262532f, -0.02094487f, 0.01768540f, -0.00416768f, 
    -0.00407815f, -0.00440482f, -0.02927184f, 0.01746064f, 0.02953806f, -0.03694868f, -0.03105329f, 0.01715590f, 
    -0.01363158f, -0.03078154f, 0.02666973f, 0.03832942f, -0.01603983f, 0.01072761f, -0.02814412f, -0.02986147f, 
    0.00162432f, 0.01707259f, -0.03028010f, 0.02932835f, -0.03285931f, -0.02613746f, 0.00144367f, 0.01846131f, 
    -0.01804508f, -0.01115438f, -0.01000395f, 0.01525591f, -0.03763542f, 0.01653080f, 0.00305034f, -0.01830237f, 
    -0.01208328f, 0.02629938f, 0.00626173f, -0.03834211f, -0.02396386f, 0.01426682f, 0.02972880f, -0.02738811f, 
    0.01664189f, 0.00281252f, -0.02665623f, -0.00758805f, 0.01830325f, 0.03921064f, 0.00977915f, -0.03354289f, 
    0.01908205f, 0.02212687f, 0.00816031f, -0.00380397f, -0.01764310f, -0.00438184f, -0.03557524f, -0.03630254f, 
    0.01398651f, -0.01077870f, -0.02315677f, 0.01889618f, 0.00110224f, 0.03120493f, -0.01962131f, 0.02849039f, 
    -0.01064565f, -0.03247327f, -0.01623764f, -0.02596506f, 0.02483386f, -0.03792835f, -0.03308548f, -0.03444729f, 
    0.01769673f, -0.00706319f, -0.02595013f, -0.02951700f, 0.02376090f, 0.02760780f, 0.01562015f, -0.02454319f, 
    0.02373153f, 0.00375892f, 0.00681629f, -0.03501324f, -0.00219731f, -0.00725797f, 0.02276858f, 0.00314537f, 
    0.00138221f, 0.00860691f, -0.00990483f, -0.03719606f, -0.00934260f, -0.03430213f, 0.00041915f, -0.03977305f, 
    -0.41091162f, 0.23001203f, -0.17867242f, -0.03505891f, -0.09522397f, 0.05612832f, 0.04425203f, 0.09649954f, 
    -0.03121956f, -0.04652938f, 0.04259882f, 0.07287624f, -0.26473737f, 0.30698287f, 0.00182063f, -0.09929248f, 
    0.03678102f, 0.04471749f, 0.05876020f, 0.03878396f, 0.03829072f, 0.06648719f, -0.05289464f, -0.00545928f, 
    -0.18337312f, 0.51733118f, 0.01505720f, -0.18354724f, 0.14673346f, 0.01262353f, 0.02056086f, -0.08131596f, 
    0.03597638f, 0.05965277f, 0.02798487f, 0.08630263f, -0.18022211f, 0.20297591f, -0.00516098f, 0.21650736f, 
    0.06826133f, 0.06744037f, -0.13684134f, 0.14018641f, 0.12412351f, -0.00269131f, -0.09189361f, 0.13900472f, 
    -0.16580273f, 0.17734700f, -0.12347165f, 0.22036886f, 0.09887850f, -0.04733777f, -0.09343708f, -0.01812338f, 
    -0.04203184f, 0.03306917f, -0.01699266f, -0.06985544f, -0.27524492f, 0.15228368f, 0.09184995f, -0.19181189f, 
    0.11408832f, -0.00048783f, 0.00954096f, -0.00572413f, -0.03346180f, 0.04090012f, 0.01138593f, 0.18872383f, 
    -0.11396929f, 0.00913550f, 0.06127787f, 0.05526168f, -0.06017003f, -0.08295713f, 0.06643668f, -0.08766758f, 
    -0.13587533f, -0.05781459f, 0.14222570f, 0.09617677f, -0.30643883f, 0.03567471f, -0.00706507f, -0.14947011f, 
    -0.00978714f, 0.03813577f, -0.09783437f, 0.00939285f, 0.09619544f, 0.01020136f, -0.04943920f, 0.08907053f, 
    0.27154481f, -0.06961929f, 0.03863064f, -0.07025421f, 0.12869057f, -0.12272596f, 0.03257716f, 0.04972954f, 
    0.01526160f, -0.08334897f, 0.08927786f, 0.07877567f, -0.07994912f, -0.04800864f, 0.13555512f, -0.03077738f, 
    0.16481189f, -0.01255299f, 0.03301528f, 0.09295087f, 0.01508411f, 0.01908940f, 0.02176416f, 0.07370751f, 
    -0.13092040f, 0.24060340f, -0.03502670f, 0.30036998f, 0.12072933f, 0.11829843f, -0.09698515f, -0.04847538f, 
    0.07749747f, 0.05231847f, 0.05846707f, 0.05771464f, -0.21728419f, 0.14722502f, -0.01593931f, 0.09788774f, 
    0.13325663f, 0.12764359f, -0.05424681f, 0.03954916f, -0.01443044f, 0.02934621f, 0.08774491f, -0.01125403f, 
    -0.22715707f, 0.13988593f, 0.00062351f, -0.23593773f, -0.11220492f, 0.04128217f, -0.09086325f, -0.00673829f, 
    0.00057446f, -0.00057274f, 0.01245111f, 0.06804240f, 0.13747402f, -0.14958148f, 0.01655692f, 0.07365228f, 
    -0.09698837f, -0.02296179f, 0.15665422f, -0.08654094f, -0.00195268f, -0.01212725f, 0.00934302f, 0.00488401f, 
    0.05243488f, 0.15286528f, 0.12151270f, -0.00975992f, 0.04532101f, 0.05637274f, 0.03420600f, -0.02242322f, 
    0.04105775f, -0.08980408f, 0.00969648f, -0.04966531f, 0.21050626f, -0.14548321f, 0.14265987f, -0.05227701f, 
    0.09147760f, -0.06063806f, 0.07734939f, -0.03235432f, -0.07667889f, -0.07084561f, 0.00883792f, -0.03486210f, 
    -0.19120379f, 0.05894975f, 0.04487028f, 0.02417476f, -0.02583679f, 0.11518010f, 0.03358740f, 0.01500991f, 
    0.06618439f, -0.02720037f, -0.08641245f, 0.01706349f, 0.06149447f, 0.16987504f, 0.17532954f, -0.07142840f, 
    0.16395864f, 0.04273234f, -0.07377369f, 0.07230989f, 0.04853071f, 0.08695816f, 0.02784589f, -0.00226211f, 
    0.03884266f, 0.02755653f, -0.09195541f, 0.32477528f, -0.01720450f, -0.12313117f, 0.06130559f, 0.07326950f, 
    -0.01119883f, -0.11268991f, 0.05958226f, 0.18569553f, -0.08148214f, -0.23721004f, -0.01261154f, -0.12833954f, 
    -0.10480012f, -0.08603822f, 0.16590104f, -0.00246850f, -0.04440506f, 0.00550891f, 0.03995557f, 0.02028017f, 
    0.26069275f, -0.30806202f, -0.10191044f, -0.05956989f, 0.09471487f, -0.11042909f, -0.00994970f, 0.01363221f, 
    0.06277787f, 0.09695617f, -0.07108593f, 0.02612426f, -0.04170196f, -0.05165862f, 0.16449885f, -0.19699821f, 
    -0.02463885f, -0.10266290f, 0.11353594f, -0.05530702f, 0.06019568f, 0.02730246f, 0.01431645f, 0.02538653f, 
    -0.04788568f, 0.21020751f, 0.19922981f, -0.34146714f, 0.08182157f, -0.04723372f, 0.03899242f, -0.04720947f, 
    -0.01870579f, -0.13977423f, 0.02775565f, -0.02469848f, 0.19663614f, -0.26522002f, 0.06573014f, 0.23852108f, 
    0.00111890f, 0.06401034f, -0.03203222f, -0.06660622f, -0.01346516f, -0.03966038f, 0.07821371f, 0.09883768f, 
    0.06720976f, 0.05238427f, -0.03313059f, -0.06285708f, 0.20251152f, 0.11100692f, 0.03774066f, 0.03505597f, 
    -0.05908445f, 0.01494730f, 0.08899068f, -0.05893043f, 0.01462253f, 0.29312029f, 0.02705200f, -0.14133817f, 
    0.24685283f, 0.04430904f, 0.00805944f, 0.09375872f, 0.07235301f, -0.04124624f, 0.10234403f, -0.03550864f, 
    0.03777258f, -0.04798654f, -0.03118270f, 0.16458580f, 0.10229935f, 0.05845312f, -0.00856287f, -0.02127853f, 
    -0.02777779f, 0.03231834f, -0.00233216f, 0.00038908f, -0.00448265f, -0.11669618f, 0.10997451f, 0.07868421f, 
    -0.04316984f, 0.06502578f, 0.04946175f, -0.01038207f, -0.00568525f, -0.02967966f, 0.03400916f, 0.01211905f, 
    0.13120338f, -0.09659795f, -0.13513875f, -0.07418540f, -0.12684599f, 0.00791789f, -0.11386544f, -0.03658934f, 
    0.08338533f, 0.04190167f, 0.03247087f, 0.16476855f, 0.18318079f, -0.10698379f, 0.01330449f, -0.01432081f, 
    0.04452828f, 0.20397945f, -0.00617043f, 0.04384122f, 0.04340195f, 0.11661615f, 0.01932168f, 0.12061761f, 
    -0.13318849f, -0.14519908f, -0.03483590f, 0.25981313f, 0.18000491f, 0.03914513f, -0.04931090f, 0.00832953f, 
    0.08288970f, 0.02486811f, 0.03961890f, 0.00431053f, -0.18908158f, 0.09548818f, -0.21366565f, 0.10944128f, 
    -0.03187725f, 0.10064976f, -0.00373500f, -0.01114896f, 0.03757449f, 0.15507756f, 0.17185174f, 0.04726034f, 
    -0.24201474f, -0.07812864f, 0.12102787f, -0.01742032f, 0.21651094f, 0.03420852f, 0.01578704f, 0.01604545f, 
    -0.00610786f, -0.04490453f, 0.07632792f, -0.01060922f, -0.24671848f, -0.10277121f, 0.16380623f, 0.00385378f, 
    0.07009779f, -0.07548962f, -0.14077392f, -0.01807351f, 0.07868931f, 0.14645611f, -0.03839000f, -0.00366014f, 
    0.02171924f, 0.15729609f, 0.17002183f, -0.22588606f, 0.12478416f, -0.04340118f, 0.05493146f, -0.02806904f, 
    -0.01854568f, 0.12559925f, -0.02555349f, 0.08047403f, -0.12604114f, 0.23849948f, 0.04976680f, -0.11928248f, 
    0.09251333f, -0.05249397f, 0.04645220f, -0.06804835f, -0.01594782f, -0.03476534f, 0.09808698f, 0.19199234f, 
    -0.02686493f, 0.23584105f, 0.09215897f, 0.07157732f, 0.00824118f, 0.09494042f, 0.05980516f, -0.01067684f, 
    0.08923249f, -0.01185344f, -0.05230065f, 0.08546194f, -0.19160374f, 0.12098419f, 0.10732697f, 0.03659924f, 
    -0.01210967f, 0.09978791f, -0.03445310f, 0.00806309f, -0.06665123f, -0.05488832f, -0.05160740f, 0.15655158f, 
    -0.33206385f, -0.04946591f, 0.09720568f, 0.10834470f, 0.05543336f, 0.09099997f, 0.05884822f, 0.01653107f, 
    0.03015188f, 0.09733926f, 0.02812350f, 0.06470130f, 0.36999702f, 0.11756534f, -0.07693348f, 0.12254946f, 
    0.04516226f, 0.18430182f, -0.04816827f, 0.00132444f, 0.04951849f, -0.03571303f, 0.01894428f, 0.06157219f, 
    0.16452932f, 0.07162641f, 0.14179546f, -0.11537953f, 0.10775105f, -0.09384552f, -0.01588406f, 0.01088568f, 
    0.00976188f, -0.10088869f, -0.00696601f, 0.12846033f, -0.20966120f, -0.16877718f, -0.03855194f, 0.03199594f, 
    0.05900697f, -0.07947460f, 0.14709032f, -0.02236489f, 0.14623895f, 0.05313824f, 0.03142399f, 0.00571687f, 
    -0.29054412f, 0.09501605f, -0.13561383f, 0.05999517f, 0.03790545f, 0.04301335f, 0.01800005f, 0.07753795f, 
    0.04175258f, 0.08175397f, 0.02509657f, 0.09957405f, -0.00362304f, 0.17400731f, -0.24509718f, -0.09068360f, 
    0.03880208f, -0.00935450f, 0.05511777f, -0.02391414f, 0.04847264f, 0.04592108f, -0.05701265f, 0.05744693f, 
    0.44518214f, -0.13749897f, 0.31033289f, -0.10090682f, 0.09857848f, -0.01937298f, -0.02804995f, 0.10864390f, 
    0.17995410f, 0.00637002f, 0.08627738f, 0.01828972f, 0.01362911f, -0.10041051f, 0.15026775f, -0.10596473f, 
    0.11992953f, -0.08358542f, 0.00360060f, -0.12357007f, 0.10736762f, 0.09784150f, -0.04675868f, 0.11072280f, 
    -0.22378998f, 0.19649722f, 0.08216112f, 0.15692556f, 0.03333756f, 0.01855919f, 0.00087547f, -0.06026619f, 
    -0.00873549f, -0.13104852f, -0.02108244f, 0.02256131f, 0.04043295f, 0.10504406f, -0.12025429f, 0.15895893f, 
    -0.04766138f, -0.07617725f, -0.16745189f, 0.05172745f, -0.04758440f, 0.03845746f, 0.03431141f, -0.05459683f, 
    -0.34131461f, -0.09525409f, 0.06076106f, 0.20180491f, 0.07124709f, -0.03142450f, 0.03324503f, 0.02222595f, 
    -0.05165501f, -0.05665958f, -0.01234611f, 0.07831535f, 0.06035446f, -0.36387217f, 0.13272241f, 0.16329707f, 
    0.08518828f, -0.01270248f, 0.02217847f, 0.02173686f, -0.06241640f, -0.01388835f, -0.03555701f, 0.19759443f, 
    -0.26368380f, -0.15727292f, 0.00560822f, 0.12250817f, 0.08982180f, 0.04089135f, 0.10414535f, -0.08219860f, 
    0.02732639f, 0.07124944f, -0.04974187f, -0.00533285f, -0.05083477f, -0.25062990f, 0.03219696f, 0.07149133f, 
    -0.08705915f, 0.01614865f, -0.02566510f, -0.05035543f, 0.01021744f, -0.05928504f, 0.03135849f, -0.02477711f, 
    0.23826919f, 0.04740886f, -0.05424064f, 0.02682564f, 0.00762558f, -0.02001676f, -0.12398688f, -0.06209562f, 
    0.03364991f, 0.03291241f, 0.06558725f, 0.07416919f, -0.28661340f, -0.20780514f, 0.20878622f, 0.19070530f, 
    -0.06660230f, 0.09017037f, 0.03585238f, -0.09810682f, 0.02962537f, 0.11342265f, 0.05108176f, -0.02606317f, 
    -0.24433558f, 0.13897872f, -0.00290463f, 0.12691924f, 0.04256843f, 0.05865355f, -0.03376811f, -0.02116764f, 
    0.08799305f, -0.07928696f, 0.05733918f, 0.03670286f, -0.33963451f, 0.08025022f, -0.10015066f, -0.18950634f, 
    -0.04057157f, 0.13419431f, -0.03222881f, 0.04413633f, 0.01577737f, 0.00330709f, -0.07692611f, 0.02611976f, 
    -0.02599041f, 0.19408879f, 0.10685045f, -0.18689677f, 0.13601744f, 0.07091557f, -0.08643913f, -0.04203384f, 
    -0.05629299f, -0.05253024f, 0.04669097f, -0.10465834f, 0.02798642f, -0.06534759f, -0.03921267f, -0.16807257f, 
    0.06359718f, 0.03378271f, 0.05472036f, 0.07934722f, 0.08942567f, 0.03646423f, 0.00994694f, 0.03736437f, 
    -0.22301310f, 0.02089356f, 0.14687768f, -0.19644244f, 0.16477621f, -0.05956248f, 0.03575794f, 0.03721100f, 
    -0.09994742f, 0.05657224f, 0.05265503f, -0.03125574f, -0.20107736f, 0.11271749f, -0.00821032f, 0.07897774f, 
    0.06274410f, 0.11936520f, -0.07394347f, -0.09509127f, -0.02729703f, -0.00541956f, 0.04698326f, 0.06258130f, 
    -0.04678576f, -0.25124753f, 0.11359125f, -0.10329314f, 0.01504685f, -0.12565853f, 0.07799378f, 0.01696129f, 
    -0.05655832f, 0.01281883f, -0.02344138f, -0.06888624f, -0.19859488f, -0.05096464f, 0.02629034f, 0.02363366f, 
    0.02964493f, 0.03945595f, 0.02574493f, -0.10515506f, 0.04264486f, -0.03977482f, 0.10943053f, -0.01988877f, 
    -0.00302162f, -0.03798774f, 0.06760006f, -0.08955570f, -0.07233636f, -0.01938259f, -0.18791446f, 0.02261790f, 
    0.07037055f, -0.04968033f, 0.06599879f, -0.07921689f, -0.41927776f, -0.22684117f, -0.00225130f, 0.15183780f, 
    -0.00307775f, -0.00754090f, 0.05339367f, -0.02133416f, 0.01155664f, 0.06156397f, 0.02381473f, 0.08931524f, 
    0.01720835f, 0.01677127f, -0.00777240f, -0.02188919f, -0.01126250f, -0.02129502f, -0.04046723f, -0.00436966f, 
    -0.02966842f, -0.03703717f, -0.01956032f, 0.01575113f, 0.01180919f, -0.00038049f, 0.01137529f, -0.00181581f, 
    -0.00799739f, 0.02144875f, 0.02824419f, -0.00277971f, -0.03874313f, -0.04252099f, 0.01763649f, 0.02701237f, 
    0.00019532f, 0.01856904f, 0.01351348f, 0.02419773f, 0.01678102f, -0.01819482f, 0.02437894f, -0.01790512f, 
    0.01245981f, 0.02573079f, -0.02740167f, -0.01133589f, -0.00314266f, 0.02831045f, -0.00510660f, 0.02831860f, 
    -0.02963215f, 0.02739084f, -0.03257464f, -0.01302680f, -0.03715183f, -0.00063111f, -0.01776280f, -0.00455202f, 
    -0.03417012f, -0.00443892f, 0.00297453f, 0.02255303f, -0.03741826f, 0.01506409f, -0.01532303f, -0.02442037f, 
    0.01486430f, -0.03635141f, -0.03614519f, 0.02381258f, 0.02574692f, -0.03793434f, -0.02755823f, -0.00667884f, 
    -0.02629048f, -0.00094603f, -0.03686606f, 0.00519494f, 0.02319279f, -0.04050852f, 0.00587616f, -0.03767047f, 
    -0.04209548f, -0.03546596f, -0.02264530f, 0.00656665f, 0.01633497f, 0.01379098f, 0.01930521f, 0.02687219f, 
    0.00564998f, -0.03487085f, -0.01951926f, -0.04260100f, -0.02205398f, 0.02809698f, -0.02234165f, -0.02965527f, 
    0.00555506f, 0.00457837f, -0.00798134f, -0.03355760f, 0.01510449f, 0.01381544f, -0.00642632f, 0.00374760f, 
    -0.01499638f, -0.02579452f, -0.00932621f, -0.01435160f, -0.03616419f, 0.00761343f, 0.02018400f, 0.01285686f, 
    -0.00355950f, -0.03078758f, -0.01346211f, 0.02038597f, 0.00771653f, -0.02137536f, -0.03901723f, 0.01141788f, 
    0.02790511f, -0.03156446f, 0.00159343f, 0.02703468f, 0.01005740f, -0.00834970f, -0.03689146f, -0.04378432f, 
    -0.03552077f, 0.00223190f, -0.02793386f, -0.03889965f, -0.01296965f, -0.03971711f, 0.02048396f, -0.00695429f, 
    -0.03837954f, -0.00160994f, 0.02257569f, -0.01380774f, 0.01439159f, -0.02995284f, -0.00744609f, -0.03040966f, 
    0.01682631f, -0.01198340f, -0.01860108f, -0.03838403f, -0.02554005f, -0.04046336f, -0.01412111f, 0.02221850f, 
    -0.01350136f, 0.02422370f, -0.03642710f, -0.01592072f, 0.01025911f, 0.00093131f, 0.01767412f, 0.02072242f, 
    -0.02447700f, -0.02671234f, 0.00608087f, -0.01849595f, -0.02940229f, 0.01850563f, 0.00708780f, 0.00455158f, 
    -0.00268598f, 0.00893034f, -0.02178601f, 0.01499729f, 0.02109796f, -0.02729705f, -0.00712522f, -0.00398966f, 
    -0.03947984f, 0.01172615f, 0.01124529f, -0.03475352f, -0.01203431f, 0.02756648f, -0.04192106f, -0.03961224f, 
    0.00458879f, -0.00074818f, -0.01056262f, -0.01458696f, -0.03595087f, 0.00528201f, -0.01498357f, 0.02385695f, 
    0.02053705f, 0.02473789f, -0.03837557f, 0.00488308f, -0.00742134f, 0.02597289f, -0.02652064f, 0.01188037f, 
    -0.02866084f, 0.00373231f, 0.00388108f, -0.00581784f, -0.03902921f, -0.03603299f, 0.00377629f, 0.01708649f, 
    0.02251271f, 0.02879041f, 0.01490946f, 0.02493162f, 0.02855767f, -0.04034371f, -0.01517117f, -0.01137633f, 
    -0.00472336f, 0.02537880f, -0.03405554f, 0.00027418f, -0.01190436f, -0.02201064f, -0.03705674f, 0.01015752f, 
    0.00497412f, 0.00005044f, -0.01187125f, -0.02809741f, -0.04021203f, -0.03573833f, -0.04300543f, -0.02708492f, 
    -0.01340208f, -0.03705921f, -0.00309181f, 0.02370037f, 0.02931522f, -0.00764411f, 0.01483127f, -0.03669145f, 
    -0.01915644f, -0.00811931f, 0.02726693f, 0.00791381f, -0.04166827f, 0.01418906f, 0.01320270f, -0.02618922f, 
    -0.02562982f, 0.02207130f, 0.00764030f, -0.02686688f, -0.02689360f, 0.01106711f, 0.00724428f, -0.02039671f, 
    0.01158936f, -0.00237199f, 0.02076764f, 0.00664617f, 0.02472624f, -0.02388127f, -0.01621658f, 0.00301614f, 
    0.00775631f, 0.02439719f, -0.04023807f, -0.03630010f, -0.00487038f, 0.01055988f, 0.02052243f, -0.01221867f, 
    -0.03893516f, -0.02911482f, 0.02186161f, -0.02978694f, -0.03008353f, 0.02530758f, -0.04048572f, -0.03948730f, 
    0.02344951f, -0.02580204f, -0.02450519f, -0.00869059f, 0.00540707f, -0.03887421f, 0.02665603f, -0.01675853f, 
    -0.02441336f, 0.01737814f, -0.01210906f, -0.04438779f, 0.02848195f, 0.00070036f, 0.02573452f, -0.00865365f, 
    0.02907033f, -0.03055221f, 0.00938723f, -0.01903563f, 0.02669573f, -0.02855274f, 0.02585552f, 0.01630021f, 
    -0.00667561f, 0.01788967f, -0.02543408f, 0.02830803f, 0.00154433f, 0.01371250f, -0.02940901f, -0.01919541f, 
    0.00574987f, 0.02173857f, -0.01506044f, -0.00602820f, 0.02278385f, -0.00094770f, -0.00346164f, 0.00371644f, 
    -0.01504462f, -0.02821216f, -0.02197981f, -0.01858225f, 0.01370177f, 0.02859474f, 0.00232725f, -0.01997181f, 
    0.01508806f, -0.01693093f, -0.00183454f, 0.02616052f, 0.01021001f, -0.00141282f, -0.00899496f, 0.02016878f, 
    -0.01874343f, 0.01222032f, 0.02486578f, -0.03537383f, -0.02989266f, 0.01552507f, -0.03629516f, 0.00248591f, 
    -0.01411411f, 0.01172565f, 0.01405609f, -0.02437517f, 0.00880997f, -0.02983264f, -0.00942052f, -0.03525090f, 
    0.02609583f, 0.02403761f, -0.02601815f, 0.00219697f, -0.01761847f, -0.03133563f, 0.01271827f, 0.02047340f, 
    -0.00472680f, -0.01606184f, -0.02527674f, 0.01790371f, -0.00533297f, -0.00688363f, -0.01817179f, -0.01073366f, 
    -0.01211337f, -0.01107405f, 0.02514187f, -0.01313536f, 0.02061805f, -0.00922181f, 0.02136141f, 0.01992888f, 
    0.01236472f, 0.02784483f, -0.01992112f, -0.01985037f, -0.00259958f, -0.04190623f, 0.01036924f, -0.00063044f, 
    -0.03156343f, 0.00328872f, 0.02887199f, -0.01511773f, -0.01845795f, 0.00540357f, 0.00676763f, -0.00578266f, 
    -0.04412654f, -0.01233941f, 0.00980532f, -0.00557425f, 0.01532977f, -0.00260286f, -0.01652246f, -0.04032274f, 
    0.00248438f, 0.01712534f, -0.03158426f, -0.02033074f, -0.00481826f, -0.01248082f, -0.02179950f, 0.01772094f, 
    -0.00315100f, -0.01272213f, -0.01618149f, -0.00690621f, -0.02486607f, 0.00872939f, -0.02445624f, -0.03777451f, 
    -0.01304575f, 0.01427382f, -0.01472847f, -0.03562951f, -0.01203547f, 0.02982963f, -0.03182093f, -0.01887311f, 
    -0.03413794f, 0.02726708f, -0.01354508f, 0.02359986f, -0.04158989f, -0.01406890f, -0.01730908f, -0.01979616f, 
    0.00043877f, -0.04216430f, -0.03561419f, -0.01315588f, -0.01535471f, 0.00920667f, -0.02942738f, 0.00226388f, 
    -0.04145162f, 0.02335620f, 0.02548069f, -0.01971335f, -0.02397683f, -0.01640344f, -0.01530132f, 0.02085884f, 
    -0.01193419f, 0.01531736f, -0.00478046f, 0.00657344f, -0.01151212f, -0.01845496f, 0.00469574f, 0.01749526f, 
    0.02858924f, 0.01569856f, 0.02898842f, 0.02546036f, -0.00699603f, -0.02017120f, -0.04044590f, -0.02925895f, 
    0.01186964f, 0.00274820f, -0.01934868f, -0.03731856f, -0.00092272f, -0.00366014f, -0.01939104f, 0.01117327f, 
    0.00944155f, -0.01822119f, -0.02430635f, 0.01133400f, 0.00165327f, 0.02594402f, 0.01895252f, -0.03840262f, 
    -0.02940375f, 0.02620438f, 0.00870785f, 0.02336208f, -0.03663437f, -0.02805902f, -0.02837327f, -0.04072023f, 
    0.01380593f, -0.03104513f, -0.00972667f, -0.00782689f, -0.02260001f, -0.02434663f, -0.01315919f, -0.00221779f, 
    -0.02083024f, -0.04317462f, 0.01138614f, -0.00266188f, 0.00550895f, -0.01136146f, -0.00273450f, -0.00382935f, 
    0.00048384f, -0.00321955f, -0.04309110f, -0.03590199f, -0.00482769f, 0.00429596f, -0.03685018f, -0.04285252f, 
    0.01117843f, -0.03160180f, -0.01112126f, -0.01173666f, 0.01572985f, 0.02625860f, -0.04077617f, 0.00329626f, 
    -0.04162632f, -0.00503684f, 0.02302198f, 0.00252999f, 0.01902215f, 0.01110721f, 0.00202022f, -0.04036060f, 
    0.01912297f, -0.03159221f, -0.02961764f, -0.00440379f, -0.03971765f, -0.00308908f, -0.02510075f, -0.02077185f, 
    -0.02446831f, -0.02892060f, -0.00293605f, -0.02904315f, -0.03264897f, 0.00743290f, 0.00225264f, 0.00004044f, 
    -0.04118064f, 0.02605467f, 0.00625442f, -0.02836072f, -0.03303185f, 0.01642428f, -0.01713441f, -0.01648041f, 
    -0.02139194f, -0.01756013f, -0.01776897f, -0.04160716f, 0.02589105f, -0.02743351f, -0.01645062f, 0.01947368f, 
    0.00161824f, -0.01355823f, 0.01028931f, 0.00095732f, -0.00705131f, 0.00393097f, -0.03664222f, -0.01156286f, 
    -0.00768401f, 0.01402651f, 0.01807101f, -0.02002444f, -0.00899944f, -0.00494695f, -0.00550292f, 0.00927061f, 
    0.01880016f, -0.00676132f, 0.01750636f, -0.04308653f, -0.02407549f, 0.01232930f, -0.02595044f, -0.03727654f, 
    -0.02895382f, -0.01709203f, -0.04306678f, 0.02134231f, -0.00447986f, -0.02035114f, 0.02637359f, 0.01392666f, 
    0.00991914f, 0.01886156f, 0.02007892f, -0.00303354f, -0.04206009f, -0.02730634f, -0.03530328f, -0.02744369f, 
    -0.01833627f, 0.01180616f, 0.01872197f, -0.01121292f, 0.02000737f, -0.02963451f, -0.02317809f, -0.01459518f, 
    -0.02971637f, -0.00804538f, -0.01922083f, 0.00563263f, 0.00091072f, -0.04213511f, 0.02729607f, 0.00197451f, 
    -0.00341318f, -0.00287793f, 0.02759954f, -0.04046862f, 0.01049028f, 0.02533139f, 0.00777422f, -0.00245997f, 
    -0.01079472f, -0.01163268f, -0.03540226f, -0.02110290f, 0.01789519f, -0.02352554f, -0.03129416f, -0.00590662f, 
    -0.01262930f, -0.01842101f, -0.01944682f, 0.02175500f, 0.02648003f, 0.00474667f, -0.01757604f, 0.00079672f, 
    -0.01193741f, -0.00053232f, 0.02016168f, -0.01254099f, 0.01052634f, 0.00765987f, -0.02196746f, 0.00239027f, 
    -0.01070354f, 0.00294062f, -0.01347340f, -0.01192778f, -0.01725297f, 0.00884990f, -0.00672704f, 0.02639558f, 
    0.01344128f, -0.04045077f, 0.02115645f, -0.00398606f, -0.02089895f, 0.00433963f, -0.01497781f, 0.01100279f, 
    0.02887915f, -0.02981098f, 0.00481238f, -0.02729372f, -0.02091811f, -0.03976060f, 0.01063124f, -0.00376645f, 
    0.02062823f, 0.00092881f, 0.00330889f, -0.03708122f, 0.01497298f, -0.00960479f, -0.03084412f, -0.02898773f, 
    -0.04066059f, -0.03710191f, 0.04085900f, -0.03064927f, -0.01822113f, 0.00720101f, -0.03214069f, -0.03323324f, 
    0.00789303f, -0.03798426f, -0.00608314f, -0.03481218f, -0.02544797f, 0.00657374f, 0.01298183f, 0.00758013f, 
    0.00013561f, -0.03860491f, -0.02353358f, 0.00675893f, 0.01469573f, 0.00160782f, -0.00004131f, 0.02239870f, 
    -0.03953975f, 0.00974507f, -0.01373473f, 0.00663286f, -0.03691933f, -0.03250512f, -0.00608677f, -0.02043575f, 
    -0.00489282f, -0.04242481f, -0.00045624f, 0.01782044f, -0.02177635f, -0.01224921f, -0.00367842f, 0.02406621f, 
    -0.03542724f, 0.02730800f, -0.00771718f, -0.00905258f, -0.01158200f, -0.01274945f, -0.03685702f, -0.00564992f, 
    0.02049201f, -0.02786066f, -0.03292353f, -0.01671126f, 0.02042723f, -0.00328454f, 0.01330822f, 0.00921825f, 
    0.01023663f, -0.03914752f, -0.01542805f, -0.02869049f, -0.03184425f, -0.03310828f, 0.02749325f, -0.03152392f, 
    -0.02635220f, 0.00001276f, -0.02471182f, -0.02114875f, -0.04356617f, 0.02821673f, 0.01391743f, -0.00151156f, 
    -0.02226105f, 0.02173027f, -0.00763688f, -0.02208037f, 0.02697458f, -0.02567122f, -0.02598754f, -0.02754649f, 
    -0.01730965f, -0.01335507f, 0.00212256f, 0.02345906f, 0.02423971f, -0.04144166f, 0.00336856f, -0.02700109f, 
    0.01990950f, 0.00072370f, 0.00096084f, -0.03089181f, -0.00940683f, -0.04097877f, 0.00548079f, -0.02820016f, 
    0.00586433f, -0.00562969f, -0.01844012f, -0.00726243f, -0.00087147f, -0.03039053f, -0.03546510f, 0.02734255f, 
    -0.00421926f, 0.01909566f, 0.00684853f, 0.02786514f, -0.00140210f, -0.00204798f, 0.01208968f, 0.01080851f, 
    -0.02216290f, -0.02731537f, 0.01058762f, -0.03947549f, 0.02289117f, -0.03619581f, -0.01061572f, -0.03026446f, 
    -0.00111153f, -0.00824023f, -0.02977297f, 0.00919259f, 0.01135569f, -0.01677698f, -0.02911704f, -0.04460981f, 
    -0.03334685f, 0.01290943f, -0.03543862f, 0.00746352f, -0.02612962f, 0.02588899f, 0.03076929f, -0.00844990f, 
    -0.03830290f, -0.02012639f, 0.01535522f, 0.01260137f, -0.01352165f, 0.00531255f, -0.02432767f, -0.01876091f, 
    -0.01367969f, 0.02095171f, -0.03410882f, -0.03797336f, -0.01297991f, -0.02401504f, 0.00724927f, -0.03934953f, 
    0.00268321f, -0.04059599f, -0.02955404f, -0.02908815f, 0.02785497f, -0.03244836f, -0.00559760f, 0.02279211f, 
    -0.04063327f, 0.00508460f, -0.04300174f, 0.03155628f, -0.00832706f, -0.00818217f, 0.03081167f, 0.00489531f, 
    -0.00362110f, 0.01195715f, -0.02921896f, 0.01883875f, 0.01677776f, -0.00272541f, -0.03911713f, 0.01367200f, 
    -0.02916638f, 0.00184759f, 0.02684831f, -0.02530683f, 0.02786702f, -0.04382576f, -0.03679724f, 0.01117801f, 
    0.01878216f, -0.01788406f, 0.02807295f, -0.02165494f, -0.02497043f, -0.02481553f, -0.00460326f, 0.03086850f, 
    0.02554927f, -0.02114219f, -0.00407218f, 0.02096395f, -0.02648642f, -0.01306869f, -0.03891934f, 0.01153401f, 
    0.01376818f, -0.00557045f, 0.00538338f, -0.02867332f, -0.00762629f, 0.01713049f, -0.03214844f, 0.00579693f, 
    -0.00656268f, -0.02984618f, -0.00618112f, 0.01695807f, -0.03165676f, 0.02284677f, -0.00810034f, 0.02169635f, 
    -0.00587766f, 0.00830448f, -0.02290490f, 0.00211835f, -0.02847526f, 0.00787772f, 0.00064872f, -0.01445624f, 
    -0.01219502f, -0.02583265f, -0.04221103f, 0.01116537f, -0.00588754f, -0.01077569f, -0.00540545f, 0.01823958f, 
    -0.02620777f, -0.02721801f, 0.01286737f, 0.00056001f, 0.01511328f, 0.01101518f, -0.00896246f, 0.01363437f, 
    0.01379465f, -0.00412173f, 0.01790431f, 0.01523767f, 0.02655719f, -0.02261717f, -0.00690426f, 0.01172002f, 
    -0.01773188f, 0.02744322f, 0.02500880f, 0.02431310f, -0.00497135f, 0.02378848f, 0.00271457f, -0.00150222f, 
    -0.03049615f, -0.00874855f, 0.01146388f, -0.02353111f, -0.01771316f, 0.02760285f, -0.03069069f, -0.01135259f, 
    0.00170037f, 0.00128433f, -0.02582491f, 0.02177119f, 0.02051928f, 0.00965990f, 0.01333764f, -0.00468488f, 
    -0.00661289f, -0.03684940f, 0.03042315f, 0.00457419f, -0.01650460f, 0.02626752f, -0.02470809f, -0.03210084f, 
    -0.00033022f, 0.02035404f, -0.04446194f, 0.00048588f, -0.02445919f, -0.01321677f, -0.00595237f, -0.04331974f, 
    -0.02067022f, -0.02698446f, 0.01920479f, -0.01203771f, -0.02895184f, -0.02722284f, 0.01397113f, -0.01609243f, 
    -0.00454587f, -0.02267589f, 0.00208329f, 0.02318748f, -0.01860820f, 0.00166549f, -0.03717760f, 0.00426491f, 
    0.02708566f, -0.00924504f, -0.03154173f, -0.03536082f, 0.00946830f, -0.00498329f, 0.02340706f, 0.00480228f, 
    0.02417093f, -0.00862821f, -0.02869081f, -0.04036663f, 0.02014365f, -0.04242404f, 0.00352355f, -0.02633131f, 
    -0.04233614f, -0.02638536f, -0.01545417f, 0.01895206f, -0.01269517f, 0.01077485f, -0.01092993f, -0.02922022f, 
    0.02580909f, 0.00190661f, 0.00434403f, 0.00936831f, -0.01005262f, -0.00337639f, 0.00683254f, 0.01988251f, 
    -0.02273657f, 0.01430153f, -0.04445322f, 0.02490980f, 0.02159581f, -0.02461816f, 0.00285489f, 0.00181916f, 
    -0.00704296f, -0.00961291f, 0.02453956f, 0.02704760f, -0.02055518f, -0.02659368f, 0.02074045f, -0.02983265f, 
    -0.01650359f, -0.03893625f, -0.02744421f, -0.03276800f, -0.04057301f, -0.02319034f, 0.02637175f, 0.01973977f, 
    -0.04089382f, -0.03469237f, 0.00469562f, 0.00073490f, 0.00495295f, 0.00202901f, -0.03128980f, 0.01248795f, 
    -0.00385705f, 0.01480159f, -0.03120911f, -0.02175856f, -0.03172111f, -0.02067875f, 0.02471334f, 0.01175725f, 
    -0.01805173f, 0.02035992f, 0.00846674f, -0.01169425f, 0.00355859f, -0.02036953f, 0.00513484f, -0.00192143f, 
    -0.01443716f, -0.01632210f, -0.01935147f, -0.00345219f, -0.03105126f, -0.03570452f, -0.02802977f, -0.00008744f, 
    -0.02523849f, 0.02689718f, 0.02091438f, 0.01969945f, -0.00699576f, 0.00968251f, 0.00931410f, -0.00580083f, 
    0.02603013f, -0.03985127f, -0.03757035f, -0.03827628f, -0.01191794f, -0.00254390f, -0.00941326f, -0.02518691f, 
    0.01398343f, -0.04265914f, -0.01593240f, -0.02821945f, 0.03229338f, 0.00181952f, -0.00185135f, -0.00822193f, 
    -0.02758801f, 0.02528239f, 0.02149419f, -0.02095767f, -0.01431141f, 0.00348430f, -0.03454635f, 0.02576266f, 
    0.01079340f, -0.04157927f, -0.03411417f, -0.02444910f, -0.03030315f, -0.00864792f, -0.00906197f, 0.00077700f, 
    0.02490349f, -0.00132284f, 0.01591378f, 0.02384691f, -0.03867709f, 0.01567616f, 0.01466431f, -0.01850765f, 
    -0.00141813f, 0.00487238f, -0.03329707f, -0.00627797f, -0.03944255f, 0.02522695f, -0.02077169f, -0.00716835f, 
    -0.00176770f, -0.04096923f, -0.00752785f, 0.01140731f, -0.00754493f, 0.00333252f, 0.01075968f, 0.02144011f, 
    -0.01705729f, -0.04496773f, 0.00378766f, 0.02441755f, -0.00026024f, -0.00425846f, -0.03626976f, 0.02424253f, 
    0.02842320f, -0.03315161f, -0.03759220f, -0.01087397f, 0.01738089f, -0.03530907f, -0.02887032f, 0.02253743f, 
    0.00321601f, -0.03837230f, -0.03666873f, 0.02014361f, -0.02748258f, -0.03290261f, -0.03598037f, 0.02066640f, 
    0.02398989f, 0.01249067f, -0.02039645f, -0.01344508f, -0.03926386f, -0.02023063f, -0.02976995f, -0.02139765f, 
    0.00866955f, -0.01243751f, 0.01459036f, -0.00806809f, -0.01880850f, -0.00276350f, -0.01934925f, -0.03728354f, 
    0.02451276f, -0.00873399f, -0.01690176f, -0.01471358f, -0.02122814f, -0.02081006f, 0.02310013f, -0.01079916f, 
    0.00417504f, 0.01763489f, 0.00925697f, 0.01410447f, -0.04332408f, -0.01042246f, -0.03522645f, -0.01326508f, 
    0.00807805f, -0.00427122f, 0.00229417f, -0.02802234f, -0.03189680f, -0.01394358f, 0.01658837f, 0.01862896f, 
    -0.00084021f, -0.01083587f, -0.00555375f, 0.02698565f, 0.00205345f, -0.02615435f, 0.02753731f, -0.03579971f, 
    0.00213034f, -0.03814302f, -0.02450910f, -0.01996648f, 0.02272018f, -0.00864586f, -0.03577518f, 0.00645929f, 
    0.01287367f, -0.03646655f, 0.01859775f, 0.01503283f, -0.00748063f, -0.04056467f, 0.01661521f, -0.03951794f, 
    -0.03687846f, -0.01436532f, 0.01869361f, 0.01311720f, -0.02717714f, 0.00877399f, 0.01666398f, -0.02671184f, 
    0.01811107f, 0.00906359f, -0.02297685f, -0.04366574f, -0.03698921f, 0.01611432f, -0.00228487f, -0.02841011f, 
    -0.03917707f, -0.03569186f, 0.01177215f, -0.01301789f, 0.01673685f, -0.02444592f, 0.03066967f, -0.01323569f, 
    -0.00558911f, 0.02777594f, -0.00511414f, -0.02239326f, -0.02788255f, -0.03229795f, -0.03286580f, -0.00037617f, 
    -0.03729089f, 0.02541261f, 0.00091343f, 0.01007740f, -0.02908088f, -0.01625805f, -0.02152351f, 0.01793924f, 
    0.01961109f, -0.00015133f, 0.00773398f, 0.02063433f, 0.00927373f, -0.03658653f, -0.03402824f, -0.04459535f, 
    0.02251480f, 0.02304546f, 0.01332955f, -0.01628948f, -0.00498538f, -0.02757066f, -0.04351581f, 0.02586366f, 
    0.02299875f, 0.02336852f, -0.02471556f, -0.01273757f, -0.03916652f, 0.01764243f, -0.00622846f, -0.02994471f, 
    -0.03456461f, 0.00599514f, 0.00658223f, -0.00978430f, 0.01850522f, 0.01641346f, -0.00229795f, -0.01640551f, 
    -0.02417557f, -0.00605550f, 0.00662688f, 0.02052006f, -0.02805681f, -0.02471871f, -0.02718489f, 0.02809377f, 
    -0.00517921f, -0.04174808f, -0.03696960f, 0.01566843f, -0.00840901f, -0.03717770f, -0.02586429f, -0.02930299f, 
    -0.04215087f, 0.02095170f, -0.00741645f, -0.01206352f, 0.01588493f, -0.02303631f, -0.00915765f, -0.00143302f, 
    0.02958432f, -0.00187867f, -0.01048717f, -0.02394156f, 0.01964534f, -0.02127943f, -0.01489630f, -0.01080468f, 
    -0.00455535f, 0.01105795f, -0.01816696f, -0.02391913f, 0.02007305f, -0.01829344f, 0.01410680f, 0.01263206f, 
    0.00055435f, -0.01999185f, -0.01004037f, 0.02960145f, 0.01921525f, 0.00551264f, 0.01166009f, -0.00703284f, 
    -0.00057692f, 0.00908658f, -0.02339538f, -0.03496139f, 0.02742247f, -0.01113146f, 0.02382389f, 0.02687551f, 
    -0.01760234f, -0.00414951f, 0.00729431f, 0.02637451f, -0.00664716f, -0.00619550f, -0.03537903f, -0.00942424f, 
    -0.03834550f, 0.01493897f, -0.00487030f, -0.02955679f, -0.00276006f, -0.04101756f, -0.00463475f, -0.04396470f, 
    -0.02659061f, -0.02926138f, 0.00066990f, -0.00762557f, -0.03322293f, 0.02206893f, 0.02150048f, 0.02027506f, 
    -0.03758168f, -0.03723594f, -0.00190608f, -0.00072036f, 0.01515146f, 0.01741861f, -0.00078581f, -0.03690676f, 
    -0.03506653f, 0.00582535f, 0.02253274f, -0.03061947f, -0.02907500f, -0.02444457f, 0.01378519f, -0.00429755f, 
    0.02903227f, 0.01312939f, 0.00487396f, 0.00004960f, -0.02639699f, -0.02622279f, 0.01716634f, -0.00562447f, 
    -0.00295208f, 0.01388333f, -0.01291018f, -0.03509515f, 0.01715025f, -0.03293456f, -0.00077336f, 0.01024811f, 
    -0.02670339f, 0.00606763f, 0.00777412f, -0.02548065f, -0.03684955f, -0.04249824f, 0.00896136f, -0.01775254f, 
    -0.00638217f, -0.02789126f, -0.01235157f, 0.00622961f, -0.00901909f, -0.00310342f, -0.00252855f, -0.01674602f, 
    0.00948983f, -0.03620816f, -0.03404086f, -0.01635289f, 0.01766984f, 0.00325626f, 0.02368902f, -0.02938628f, 
    -0.01794524f, -0.01688957f, 0.02473010f, -0.02722532f, -0.03073310f, 0.01988949f, -0.02160431f, 0.01347262f, 
    -0.00455800f, -0.03796992f, -0.01027514f, 0.00115738f, -0.00096099f, 0.02373781f, -0.02461467f, 0.01210388f, 
    -0.02358621f, 0.00654458f, -0.02253948f, 0.00045982f, -0.02438488f, 0.02434844f, 0.00082151f, 0.00635477f, 
    -0.01754079f, 0.01227444f, -0.01179067f, -0.04285302f, -0.02207877f, 0.01937298f, 0.00368516f, -0.03708040f, 
    -0.02406322f, 0.01690325f, -0.02330081f, 0.00006142f, -0.01889209f, 0.02658823f, -0.01127323f, -0.00211603f, 
    0.02482366f, -0.00042531f, 0.02497286f, 0.01305224f, 0.00387270f, 0.01109541f, 0.01928903f, -0.03068963f, 
    -0.02535086f, 0.02229708f, 0.01842092f, -0.02353583f, -0.01248969f, 0.02356948f, 0.02885154f, -0.04426821f, 
    -0.00226163f, -0.01399272f, -0.00105222f, -0.02745513f, 0.02798469f, -0.03030420f, -0.03525991f, -0.03461457f, 
    -0.01108313f, -0.01549076f, -0.01612433f, -0.00780641f, -0.00457000f, -0.03075565f, -0.00392496f, -0.03631116f, 
    -0.02624181f, -0.03550189f, -0.00628478f, 0.00384051f, -0.02776356f, -0.04205001f, 0.02140771f, -0.02241474f, 
    0.01108647f, -0.03677987f, -0.02664126f, -0.01974074f, 0.02194501f, -0.01400578f, 0.01041025f, 0.00604986f, 
    -0.02206480f, -0.00115981f, -0.03413783f, 0.01403884f, -0.01909423f, -0.02171907f, -0.00403823f, -0.02131147f, 
    0.02449423f, 0.00993328f, -0.03534368f, -0.02122828f, 0.00796613f, -0.02116037f, 0.01234202f, 0.01082881f, 
    -0.01237009f, 0.02354557f, 0.01447320f, 0.00882263f, 0.01306452f, 0.00340601f, -0.00264242f, 0.01567646f, 
    0.04435199f, 0.06993458f, 0.14368354f, -0.08924195f, 0.00533303f, -0.06034017f, -0.04244938f, 0.03323527f, 
    0.01524301f, 0.03577852f, -0.06763715f, 0.06756822f, -0.25157088f, -0.09927647f, -0.12502502f, 0.00506772f, 
    0.05392442f, -0.03184338f, 0.05708768f, -0.00029346f, 0.01053342f, -0.04354569f, 0.03694028f, 0.05254215f, 
    0.20710327f, 0.06477536f, -0.00877740f, 0.03948462f, 0.13727131f, 0.04792264f, 0.02941622f, 0.15294291f, 
    -0.02220545f, 0.09819146f, -0.04505228f, -0.06472719f, 0.03185722f, -0.15705045f, 0.03372092f, 0.06862435f, 
    0.06556614f, 0.00194108f, 0.09199680f, 0.03158465f, -0.02908457f, 0.03319290f, -0.04771275f, -0.05655124f, 
    -0.17595689f, -0.17538613f, 0.08799039f, -0.02170688f, 0.15318756f, 0.09081928f, -0.08825178f, 0.07374208f, 
    0.03647007f, -0.02834002f, -0.00510693f, 0.02555692f, 0.17836043f, 0.09366176f, 0.10534721f, 0.14495574f, 
    -0.04942254f, -0.02687046f, -0.09732095f, 0.03317792f, 0.06870963f, 0.24626686f, 0.01599101f, 0.01088530f, 
    -0.13361312f, 0.06847906f, -0.02777357f, -0.20544021f, -0.04062025f, -0.02226221f, -0.01419311f, 0.11301205f, 
    0.14628808f, 0.15961306f, -0.18038379f, -0.04402912f, 0.03026814f, 0.00604936f, 0.06423591f, 0.05378458f, 
    -0.22935411f, -0.05073382f, 0.03751895f, -0.00278840f, 0.02443639f, 0.10109591f, 0.01556971f, 0.04010371f, 
    -0.13109697f, -0.01087878f, -0.00084592f, -0.26056236f, -0.06937503f, 0.07855918f, 0.02727564f, 0.03157111f, 
    0.00833674f, -0.01159903f, -0.04434100f, 0.04773091f, -0.11494950f, 0.09515519f, 0.09501646f, 0.00089788f, 
    -0.01323821f, -0.02846166f, 0.03109501f, -0.00000080f, 0.05229517f, 0.06918429f, -0.04380855f, 0.12260525f, 
    0.07423002f, -0.12357002f, -0.00114267f, -0.06472931f, -0.00947162f, -0.00688424f, 0.07447743f, 0.01258887f, 
    -0.06198058f, 0.00206378f, 0.06699692f, 0.09407613f, 0.25954843f, -0.01571416f, 0.19468373f, 0.04268801f, 
    -0.07651590f, -0.07479528f, 0.02777340f, 0.00654414f, 0.06638885f, -0.06332476f, -0.03587421f, -0.03164557f, 
    -0.00266355f, 0.07746709f, -0.11839289f, -0.07275619f, -0.02581211f, -0.04959999f, -0.03177220f, 0.11873141f, 
    -0.03142427f, -0.01118249f, 0.16728158f, 0.02256596f, -0.16841504f, -0.14456044f, -0.13095111f, -0.10695144f, 
    -0.04288718f, -0.02641296f, 0.01217360f, 0.08083089f, -0.06658630f, 0.01882679f, 0.01115268f, 0.10750335f, 
    0.22205323f, 0.04799233f, -0.04646640f, 0.21368138f, 0.03568124f, -0.01186932f, 0.05018953f, 0.04644034f, 
    0.01622006f, -0.04642860f, -0.02629884f, -0.05583346f, -0.16326906f, 0.02485200f, -0.04050266f, 0.21671465f, 
    0.11780702f, 0.10583645f, 0.04684150f, -0.12479567f, -0.04126495f, 0.01602325f, -0.07706575f, 0.24473022f, 
    0.31270415f, 0.07558392f, 0.23996150f, -0.00719339f, -0.12285791f, -0.01638461f, -0.01617168f, -0.07428303f, 
    -0.04527663f, -0.08727761f, 0.06655479f, -0.07745869f, 0.16293652f, 0.15480033f, -0.00305392f, 0.14614993f, 
    -0.09367482f, 0.13573898f, 0.12027299f, 0.07666916f, -0.02267282f, 0.04440794f, -0.12497041f, 0.08158986f, 
    -0.13600135f, -0.11269184f, 0.10186484f, 0.05616764f, -0.01473397f, 0.09831488f, 0.10326726f, 0.18767384f, 
    0.11407496f, 0.03579330f, 0.19530213f, -0.00543314f, 0.12943909f, 0.07066908f, -0.15060614f, 0.01834108f, 
    0.15065290f, 0.05031586f, -0.08170910f, -0.06152005f, 0.02847949f, 0.03124226f, 0.02389746f, 0.08933214f, 
    -0.16217633f, 0.21243984f, -0.16598155f, 0.03558450f, 0.05769175f, 0.05558716f, -0.09636651f, -0.01120174f, 
    -0.03519503f, -0.13722962f, 0.13071622f, 0.03990383f, -0.08628083f, 0.12397823f, -0.04225091f, 0.11566500f, 
    0.04209455f, 0.02559635f, -0.05656859f, 0.14315704f, 0.03508626f, 0.09867002f, -0.07259975f, -0.03292328f, 
    0.24165578f, 0.17798625f, -0.07562141f, -0.03005605f, 0.03312695f, 0.06253672f, -0.14613123f, 0.01866312f, 
    -0.03650513f, -0.04030909f, -0.10050087f, 0.07357806f, 0.04698388f, 0.14126666f, -0.04334129f, -0.18843339f, 
    0.06586108f, -0.09625089f, 0.03849369f, -0.03731934f, 0.00307334f, -0.02006538f, 0.06636158f, -0.09660131f, 
    0.18075925f, 0.18501399f, 0.07893464f, 0.11919975f, -0.07927088f, -0.05135915f, -0.06873324f, -0.06490122f, 
    -0.00380609f, -0.13531330f, -0.09644476f, -0.07800422f, 0.25686225f, 0.27477154f, 0.01697348f, 0.11990643f, 
    -0.05728267f, -0.05221858f, -0.01977924f, -0.01655809f, -0.09069587f, 0.02226344f, -0.13523288f, -0.04088712f, 
    0.34841481f, 0.09700275f, 0.07294510f, -0.07124300f, -0.05232131f, 0.01910627f, 0.10423695f, 0.01165313f, 
    -0.01841154f, 0.02524477f, 0.02087335f, 0.21833020f, 0.10629383f, -0.01195235f, -0.05090848f, -0.17364128f, 
    -0.01376940f, 0.04754172f, -0.09780034f, 0.00843818f, 0.07358915f, -0.05292094f, -0.14628825f, 0.04498982f, 
    0.29249924f, -0.02934474f, -0.16565515f, -0.32102010f, -0.15896191f, 0.16420248f, -0.03175571f, 0.08767607f, 
    -0.04633223f, 0.05617984f, 0.03977484f, -0.03712759f, 0.07528318f, 0.15734835f, 0.08262475f, -0.09520338f, 
    -0.03713797f, -0.07124907f, 0.00872532f, -0.01659418f, 0.08006562f, 0.10351146f, 0.13702926f, -0.01351491f, 
    -0.11652488f, -0.07830160f, -0.04212938f, 0.00418465f, 0.00001675f, -0.11875648f, 0.05062763f, 0.10698501f, 
    0.11226849f, -0.02118725f, -0.07799111f, 0.00472832f, -0.21203251f, -0.02069538f, 0.06952795f, 0.09029807f, 
    0.00362451f, -0.02145137f, 0.01242752f, 0.05487082f, 0.09010455f, -0.09807338f, -0.17680709f, 0.07382967f, 
    0.26471204f, 0.15696715f, 0.11977648f, 0.17684174f, -0.14544596f, -0.05267918f, -0.02036657f, 0.05472087f, 
    -0.02890297f, -0.05227438f, -0.02787549f, -0.16993026f, -0.05576798f, 0.07350355f, 0.04996027f, -0.01885714f, 
    0.14052057f, 0.13683972f, 0.01254105f, 0.01103151f, 0.13885207f, -0.13060391f, -0.05102832f, 0.05224711f, 
    0.26555556f, 0.16367690f, -0.00799150f, 0.18617460f, 0.07754043f, 0.08609479f, -0.03729732f, 0.00844946f, 
    0.16067237f, -0.14554270f, -0.03820201f, -0.06050489f, -0.12729546f, 0.01812598f, -0.08275541f, 0.05957770f, 
    0.06235652f, -0.05912436f, 0.02142444f, -0.01902075f, 0.06961760f, 0.08893332f, -0.17726280f, -0.07372874f, 
    -0.00321415f, 0.15879172f, 0.10622580f, 0.07046495f, 0.05542081f, -0.10367383f, -0.01696822f, 0.09637556f, 
    -0.01836198f, 0.06654084f, 0.13334902f, 0.03127497f, -0.19891877f, -0.27711305f, -0.02610236f, 0.05018140f, 
    0.08231626f, 0.04657387f, 0.09991995f, 0.05438503f, 0.16433460f, 0.22077842f, -0.02580833f, -0.04964506f, 
    -0.07179039f, -0.10755802f, -0.14670211f, 0.04966239f, 0.12824371f, 0.07200666f, 0.01620729f, 0.23979875f, 
    0.11999491f, -0.00012565f, 0.06977630f, 0.12278844f, 0.27303943f, 0.05314288f, 0.28130168f, -0.13057853f, 
    -0.19291830f, 0.05139515f, 0.07015605f, -0.04366656f, -0.00367780f, 0.07588054f, 0.01818655f, -0.11596565f, 
    -0.09505726f, 0.19984053f, 0.10324512f, 0.18752882f, -0.03551238f, 0.09479473f, 0.09460964f, 0.08782519f, 
    0.00673726f, 0.19876818f, 0.17287427f, 0.23246883f, -0.10007807f, 0.00987809f, 0.00517586f, -0.05072613f, 
    -0.11440802f, -0.00542404f, 0.06237973f, -0.01579561f, 0.11677152f, -0.09892129f, -0.02381671f, -0.00558598f, 
    -0.29183179f, -0.06579142f, 0.00878643f, 0.02498914f, 0.00220558f, -0.00022029f, 0.05580241f, -0.00869520f, 
    0.02016901f, -0.10093501f, 0.02406623f, 0.07691357f, -0.05600403f, 0.00591205f, 0.13371968f, -0.00410046f, 
    -0.02085659f, 0.02227246f, -0.15658979f, 0.03480107f, -0.03937912f, -0.12957846f, 0.04993865f, -0.01168100f, 
    -0.08427739f, -0.02778567f, -0.11443297f, -0.02768633f, 0.02652352f, 0.06263571f, 0.05829366f, 0.00800946f, 
    0.03376994f, 0.12685813f, -0.09403937f, -0.04246876f, -0.14044669f, 0.10198548f, -0.09334805f, 0.05139101f, 
    0.10658993f, 0.01258821f, -0.00881322f, 0.08305226f, -0.00017138f, -0.11110308f, -0.04957144f, -0.17215261f, 
    0.27208281f, 0.01430478f, 0.09491552f, -0.07114605f, -0.10949761f, 0.04433974f, 0.08159602f, -0.05971894f, 
    -0.11021197f, 0.08873624f, -0.12979795f, 0.04837554f, 0.10019389f, -0.02312390f, 0.03240951f, -0.00332628f, 
    0.00023023f, 0.08937325f, 0.19599375f, 0.07984584f, 0.07639252f, 0.11856806f, -0.02285050f, 0.14827438f, 
    -0.01589425f, -0.12976578f, -0.14816852f, 0.05129544f, 0.08881459f, -0.10656879f, -0.12773703f, 0.16362299f, 
    0.01961572f, -0.02200012f, 0.06966736f, 0.04531058f, 0.28998101f, -0.06308979f, 0.11941933f, -0.14807627f, 
    -0.00265648f, 0.03918698f, 0.10912862f, -0.01759721f, 0.05591379f, 0.15880696f, 0.03608606f, 0.17228487f, 
    0.14383923f, -0.06291532f, 0.02526197f, -0.14954884f, -0.01761721f, -0.00242386f, -0.06393553f, 0.16061683f, 
    0.03815909f, 0.07593422f, -0.00508203f, 0.11568961f, -0.12505555f, 0.15669270f, -0.20909515f, 0.16275015f, 
    0.12456198f, -0.06029527f, 0.00649553f, 0.12240724f, -0.01077580f, -0.07738594f, 0.09873884f, -0.00232671f, 
    0.10502844f, 0.08059795f, 0.00794302f, 0.02075448f, 0.01773798f, 0.00883189f, 0.09011237f, 0.14290449f, 
    -0.05709425f, 0.11195363f, 0.07384191f, 0.12154663f, 0.02430713f, -0.05535405f, -0.13140130f, 0.13399808f, 
    0.06820278f, -0.04424412f, 0.14224705f, 0.14730591f, 0.02221822f, 0.07823914f, -0.02873679f, 0.05814862f, 
    -0.24953142f, -0.16436081f, 0.16889451f, -0.03312626f, 0.09262502f, -0.07415037f, -0.12874027f, 0.06251463f, 
    0.04025593f, 0.14286540f, -0.05765466f, 0.07503133f, -0.03320491f, 0.11254279f, 0.16666032f, 0.02748916f, 
    -0.12850092f, 0.01570917f, -0.05681544f, -0.04288339f, 0.03691655f, -0.00240076f, -0.00947394f, -0.07074229f, 
    0.27940261f, -0.05396310f, 0.14301533f, 0.01196512f, -0.05520020f, 0.19458558f, 0.04540058f, 0.11973047f, 
    -0.00847834f, -0.04816934f, -0.10452968f, -0.06014321f, -0.19445309f, -0.11319444f, 0.05065501f, -0.19223548f, 
    -0.06641057f, 0.09390847f, 0.05422077f, 0.07205449f, 0.03913607f, 0.01376237f, 0.05654363f, 0.07935691f, 
    -0.26497307f, -0.00042699f, -0.23150429f, 0.04712781f, 0.15324022f, 0.08516867f, 0.04712638f, -0.02469416f, 
    -0.02915804f, 0.03210849f, 0.01062030f, 0.05430479f, 0.25047851f, 0.09231859f, 0.04136799f, 0.13187313f, 
    -0.05454201f, 0.11763679f, -0.03921666f, 0.15442762f, -0.01537746f, -0.11003596f, -0.06880631f, -0.06812280f, 
    -0.04465115f, 0.12509881f, -0.07121433f, 0.02284185f, 0.13957489f, 0.14109613f, -0.11681188f, -0.02068974f, 
    0.03823563f, -0.06007156f, -0.03167420f, 0.09183026f, -0.26447427f, -0.03736445f, -0.11349402f, 0.03845285f, 
    0.04771954f, -0.00659781f, 0.01010184f, 0.06275589f, -0.04545905f, -0.06324291f, 0.02126944f, -0.00245536f, 
    0.00708086f, 0.05326883f, -0.08237800f, -0.13039008f, -0.18185817f, 0.07662056f, 0.07151837f, -0.00946579f, 
    0.07239278f, -0.09024333f, 0.07602921f, 0.14356183f, 0.20084259f, -0.17882285f, 0.03022688f, -0.05490334f, 
    0.06077027f, 0.04179820f, 0.00341710f, 0.14301251f, 0.00591380f, 0.20044371f, 0.14102067f, 0.18178198f, 
    -0.01128795f, -0.04131008f, -0.02378781f, -0.00715775f, 0.00146792f, -0.02733503f, -0.02209077f, 0.00629552f, 
    -0.02024329f, -0.03971873f, 0.01355271f, 0.02332440f, -0.00431229f, -0.04086323f, 0.00055812f, -0.01794297f, 
    0.02193530f, 0.00763861f, -0.01708264f, 0.00725791f, -0.03958363f, -0.02560093f, -0.01505626f, 0.01007768f, 
    -0.02375840f, -0.02006065f, 0.01457698f, -0.00042474f, 0.01324539f, -0.02413156f, -0.01052608f, 0.01386267f, 
    -0.00839120f, -0.03032823f, -0.00210762f, 0.02427391f, -0.03168278f, -0.02406741f, 0.02172709f, -0.04160399f, 
    0.00509711f, -0.03909322f, -0.02612778f, 0.02519832f, -0.03963280f, -0.04029389f, -0.01284291f, 0.00860206f, 
    -0.00895138f, 0.03426054f, 0.02138670f, -0.02448899f, -0.02950352f, -0.02111897f, 0.00535078f, -0.03605444f, 
    -0.04063131f, 0.03184798f, -0.03065892f, -0.01887514f, 0.00540821f, -0.02604704f, -0.04093907f, 0.02474192f, 
    -0.03940621f, 0.01656413f, -0.00734525f, 0.00723573f, -0.00414580f, -0.04136109f, 0.00523531f, 0.01624074f, 
    0.00322613f, 0.00431960f, -0.01203965f, -0.00949576f, -0.03967389f, 0.01135782f, 0.00846715f, 0.00308576f, 
    0.01669603f, -0.01604071f, 0.02275303f, 0.02335688f, 0.02338918f, -0.03481065f, 0.01713314f, 0.00022918f, 
    0.02954215f, -0.00333590f, 0.01817604f, 0.00796232f, -0.03470078f, -0.03214648f, -0.00701334f, -0.01487149f, 
    -0.04137946f, 0.01491008f, 0.00884452f, 0.02741607f, -0.02473602f, -0.02701063f, -0.03555378f, 0.01126377f, 
    -0.03558894f, -0.01205599f, 0.00625627f, 0.02982340f, 0.01872635f, 0.02849905f, -0.00725471f, -0.03595635f, 
    0.02302886f, 0.00442857f, -0.01064330f, -0.04083723f, -0.01968558f, -0.02710843f, -0.03596947f, 0.02133164f, 
    -0.01972503f, -0.02474329f, -0.02908604f, -0.00853241f, -0.03686043f, -0.03061994f, -0.01067407f, -0.00577581f, 
    -0.03621976f, -0.00607963f, -0.01683030f, -0.01370905f, -0.02606078f, 0.00424102f, 0.00155868f, -0.03620836f, 
    0.00497042f, -0.02464967f, -0.03768411f, 0.02647613f, 0.01955926f, -0.01386799f, 0.00898595f, -0.00370762f, 
    -0.02466723f, 0.01487799f, 0.00662740f, -0.03360707f, -0.02346440f, 0.01987622f, -0.03852394f, -0.01227025f, 
    0.03043477f, -0.02951278f, 0.02108999f, -0.02910341f, -0.03900880f, -0.03853569f, -0.02850828f, -0.01306472f, 
    -0.00696599f, 0.00633427f, 0.00666398f, 0.01791950f, 0.00509226f, -0.02429024f, -0.03011550f, -0.02889543f, 
    -0.00024610f, -0.02257102f, -0.03091111f, -0.02213958f, 0.02496831f, 0.02275183f, -0.01329490f, -0.01804960f, 
    -0.01360329f, -0.00111603f, -0.03140317f, -0.02629637f, 0.01588917f, 0.02754916f, -0.02387054f, -0.00429408f, 
    -0.01933197f, -0.03815735f, -0.00142637f, 0.03223658f, -0.02786417f, 0.00734221f, 0.02750416f, 0.00918176f, 
    -0.03228780f, -0.04152448f, 0.01882337f, -0.02003532f, -0.00549503f, -0.03788804f, 0.00981679f, -0.01887525f, 
    -0.01925282f, 0.01381085f, -0.01590830f, -0.01936703f, 0.02999993f, -0.02785618f, -0.03359263f, -0.00021368f, 
    -0.01282911f, -0.00916466f, -0.00153084f, 0.00405963f, 0.02591412f, 0.00563433f, 0.02378733f, -0.01372172f, 
    0.02069458f, -0.03432228f, 0.01024896f, 0.00642948f, 0.02302850f, -0.03184431f, -0.03460586f, -0.03701650f, 
    0.01801370f, 0.02697928f, -0.00793510f, -0.01628440f, 0.01202993f, -0.03130503f, -0.00309142f, 0.01643777f, 
    -0.04111821f, -0.02780323f, -0.03488810f, 0.02983776f, 0.00749651f, 0.00972629f, -0.03992248f, -0.00515733f, 
    0.02813047f, 0.01604867f, 0.02199589f, -0.00675123f, -0.01078862f, -0.03044680f, -0.02516474f, -0.03523254f, 
    0.03211146f, -0.03088104f, -0.01775976f, 0.00471320f, 0.02092173f, -0.03130985f, -0.01342332f, -0.03391738f, 
    0.00175953f, 0.01813106f, 0.01794201f, -0.00783201f, 0.00695887f, -0.00280240f, 0.01599009f, -0.01647197f, 
    -0.01119176f, 0.00313004f, -0.02076996f, 0.02195895f, -0.03851357f, -0.00249791f, -0.02265316f, -0.03812804f, 
    0.01156716f, 0.00668812f, -0.01997590f, -0.02914752f, -0.03046225f, -0.01920344f, -0.03606637f, -0.01366070f, 
    0.01768381f, 0.00951991f, 0.02223847f, -0.03926592f, 0.02029167f, -0.01812663f, -0.01832642f, -0.03899472f, 
    0.01901644f, 0.02896030f, 0.02958574f, -0.03965017f, 0.01493505f, 0.01592362f, -0.03248233f, 0.00449442f, 
    0.03005320f, -0.00848466f, 0.00073532f, 0.01865281f, 0.02790812f, -0.03604918f, 0.00577262f, 0.02138027f, 
    0.00080292f, -0.03789610f, -0.01345323f, -0.00495209f, -0.04000545f, -0.01055728f, 0.00725548f, -0.00232242f, 
    -0.03475605f, 0.01776607f, 0.01896473f, 0.01775955f, -0.01388913f, -0.01945362f, -0.01000863f, -0.03564008f, 
    0.01063480f, 0.01364606f, -0.00984735f, -0.01072811f, 0.00320277f, 0.02229925f, 0.01616095f, -0.01930176f, 
    -0.00083711f, -0.01513829f, 0.00130273f, -0.00020047f, -0.02963796f, -0.03927786f, -0.01568551f, 0.01697407f, 
    0.00281676f, -0.02237331f, -0.03912640f, -0.04124096f, -0.04119264f, 0.00765289f, -0.02034775f, -0.02319821f, 
    0.00445551f, -0.03205179f, -0.03446729f, -0.00744393f, -0.00965519f, 0.00391006f, -0.03546594f, -0.00875776f, 
    0.02680468f, -0.02781363f, 0.02901796f, -0.03276159f, -0.03493012f, -0.04051731f, 0.02190273f, -0.03500922f, 
    0.01556452f, -0.02186073f, 0.00721747f, -0.01520687f, -0.03023056f, 0.01065770f, -0.01489698f, -0.03730915f, 
    -0.00667785f, 0.01895406f, -0.01593463f, -0.01482597f, -0.00865397f, -0.00992751f, -0.03352665f, 0.00668964f, 
    0.02435107f, -0.03067063f, -0.03592599f, 0.01178757f, -0.00341097f, 0.00868273f, 0.02097842f, -0.00916899f, 
    0.02469522f, 0.02580648f, -0.01908147f, -0.03548117f, -0.00706749f, -0.01920209f, -0.01832014f, 0.02566029f, 
    -0.02953409f, 0.03544908f, -0.02670700f, -0.03134877f, -0.00364264f, -0.01355720f, -0.02998296f, -0.02602623f, 
    0.02521489f, -0.02656535f, -0.02278739f, 0.01741839f, 0.00146869f, -0.03921358f, 0.01491209f, 0.02739359f, 
    -0.01859416f, 0.01902877f, -0.01802276f, 0.02410468f, 0.00639746f, 0.02869388f, -0.03003227f, 0.00580406f, 
    -0.02398373f, -0.02942030f, -0.00731793f, 0.02612017f, -0.01180302f, 0.02934060f, -0.01628425f, -0.00713156f, 
    0.02859019f, 0.02679857f, -0.02483955f, -0.01281331f, -0.00303249f, 0.02516707f, -0.04122626f, -0.01499222f, 
    -0.03373187f, -0.02636050f, -0.02347587f, 0.01478924f, 0.02528528f, -0.01049949f, 0.01236328f, -0.02797710f, 
    -0.02770462f, -0.00214499f, 0.02854675f, 0.00913315f, 0.01913990f, 0.00640843f, 0.01443565f, 0.02773612f, 
    0.00638391f, -0.00251396f, 0.03421378f, -0.00219825f, -0.00008140f, -0.01349291f, -0.00973947f, -0.04035535f, 
    -0.02770126f, -0.03706234f, -0.03333446f, -0.03778433f, -0.03953580f, -0.00697924f, 0.02997399f, 0.01978566f, 
    -0.02089913f, 0.02214264f, 0.02552002f, 0.00678841f, -0.04097388f, -0.03895900f, 0.00724443f, -0.00999838f, 
    0.02614900f, 0.00010581f, 0.01212418f, 0.01963757f, -0.03466499f, -0.00937841f, 0.02725076f, -0.00753515f, 
    0.01469621f, 0.00625483f, 0.02180830f, 0.00545751f, 0.00955455f, 0.00117171f, -0.01830469f, -0.00674947f, 
    -0.00418792f, 0.00169121f, 0.02054414f, -0.02493867f, 0.01673884f, -0.00659609f, -0.00565127f, -0.03632445f, 
    0.01832933f, -0.00364942f, 0.00903816f, -0.03994584f, 0.01097368f, -0.02320079f, -0.00303561f, 0.00157144f, 
    -0.00595132f, -0.03447229f, -0.03427595f, -0.01521724f, 0.00412648f, -0.03391701f, 0.02807024f, 0.00845448f, 
    0.01627411f, -0.01244126f, -0.01493777f, -0.00272420f, -0.02407932f, 0.02816583f, -0.03656210f, 0.00542892f, 
    0.02671118f, -0.01305026f, 0.01962937f, 0.01566642f, -0.02757086f, -0.02881115f, 0.00809978f, 0.02792009f, 
    0.02206956f, 0.01688357f, -0.01617988f, -0.02244310f, 0.00353959f, 0.02488988f, 0.02237367f, 0.00048899f, 
    0.02983317f, 0.02936075f, -0.01975401f, -0.00678509f, -0.01713347f, 0.02950713f, 0.00037569f, 0.02213774f, 
    0.00856674f, -0.03890938f, -0.00783821f, -0.03443434f, -0.00673180f, 0.00178430f, 0.00972666f, -0.03965304f, 
    0.00349297f, -0.03412502f, -0.03909471f, -0.03434610f, -0.03307150f, -0.02454023f, 0.01898265f, -0.00206571f, 
    -0.03752964f, 0.01274353f, -0.02578978f, -0.03481219f, -0.03528226f, 0.02224535f, -0.01720568f, 0.00589824f, 
    -0.03394574f, 0.02666073f, -0.01344841f, -0.01942677f, -0.02281931f, 0.00809294f, 0.01786020f, -0.02046896f, 
    -0.00526918f, 0.00469590f, -0.02862628f, -0.02308152f, 0.02569232f, 0.00422372f, -0.03447870f, -0.00804364f, 
    0.02731944f, 0.02162498f, 0.00512825f, -0.00183323f, -0.03756118f, -0.03155838f, 0.00324743f, -0.01317580f, 
    0.02388193f, 0.01842437f, -0.03482523f, -0.00246978f, -0.00314681f, -0.02050188f, 0.02859805f, -0.01372951f, 
    -0.03462112f, 0.02180579f, 0.01391233f, 0.00474426f, 0.00446224f, -0.03186436f, -0.03697038f, -0.00384825f, 
    -0.01501129f, -0.04068151f, -0.00611814f, 0.03039110f, 0.00508708f, -0.02526484f, -0.02730921f, -0.01786698f, 
    0.01880977f, -0.00798327f, 0.00584360f, -0.02306150f, 0.00621841f, 0.01640076f, -0.02640272f, -0.03609530f, 
    0.02864368f, -0.00715033f, -0.00584124f, -0.03797984f, -0.04153671f, -0.01224416f, 0.01993265f, 0.01741942f, 
    -0.02021787f, -0.00650737f, 0.01779585f, -0.04010338f, 0.00050365f, -0.00996856f, 0.01445157f, 0.02481218f, 
    -0.03898859f, 0.00630936f, -0.02407376f, -0.03553510f, -0.01812832f, -0.02340298f, -0.01958585f, 0.02604336f, 
    -0.02708020f, -0.03781541f, -0.00329263f, 0.01586257f, -0.01023870f, -0.00640459f, -0.03336441f, 0.00214426f, 
    -0.02811456f, 0.02547814f, 0.00827161f, -0.02814585f, 0.01379294f, 0.02973813f, -0.00691725f, -0.01699467f, 
    0.00283099f, -0.02638337f, 0.01416661f, -0.00709362f, -0.00211723f, -0.02228278f, 0.02437997f, -0.00549087f, 
    -0.01310015f, -0.00287122f, 0.02088281f, -0.02801248f, -0.02785676f, -0.02075620f, 0.00580765f, -0.03552182f, 
    -0.04146639f, -0.00404750f, -0.00642675f, 0.00294487f, -0.01712064f, -0.02760928f, 0.00021548f, 0.02340120f, 
    -0.01380981f, -0.02437416f, 0.00670436f, -0.01225394f, -0.01518482f, -0.00882497f, -0.01191328f, -0.03776780f, 
    0.02684732f, -0.03920430f, -0.03088270f, 0.02044483f, -0.01877709f, 0.02539072f, -0.03926181f, -0.02699863f, 
    0.00715842f, -0.02087110f, -0.01923979f, -0.02981799f, 0.03031592f, -0.01615714f, 0.01293982f, -0.01222093f, 
    0.01671008f, 0.02820413f, -0.00233915f, 0.02306090f, -0.00163786f, -0.04089490f, 0.03186647f, -0.02722721f, 
    -0.01079382f, 0.00952521f, 0.02705854f, -0.00779569f, 0.01630184f, -0.02265342f, 0.00344337f, -0.03443567f, 
    -0.03176589f, 0.00573989f, 0.01305463f, -0.01123931f, 0.01477900f, 0.02560512f, -0.03993593f, 0.02805030f, 
    0.03052313f, 0.01545160f, -0.02657539f, -0.02752154f, -0.03790938f, 0.02559658f, -0.01496284f, 0.00830546f, 
    0.02891599f, 0.02302376f, -0.01099575f, -0.01788592f, -0.02119275f, 0.00692510f, -0.01561404f, 0.02436503f, 
    -0.00210919f, 0.02843477f, -0.03753937f, 0.00750496f, 0.01702140f, -0.03334976f, -0.03291564f, 0.02775578f, 
    0.02318532f, -0.01245961f, 0.01907801f, 0.02670490f, -0.01597054f, 0.00369938f, -0.00106978f, 0.01934285f, 
    0.01728990f, -0.03032495f, 0.00809532f, -0.02465538f, -0.00157416f, 0.02992165f, -0.01752251f, -0.02778354f, 
    0.01428539f, 0.01458098f, 0.00203490f, 0.01287018f, 0.01676636f, -0.00089371f, -0.03194604f, 0.01055901f, 
    0.01983106f, 0.01605487f, -0.02899030f, -0.00714499f, -0.00771803f, -0.02529213f, 0.02515979f, 0.00626887f, 
    0.00613017f, 0.00782772f, -0.04083219f, -0.02470681f, 0.00824195f, -0.01730863f, -0.01243502f, 0.02841545f, 
    0.01642579f, 0.00202337f, -0.02064209f, 0.01583268f, -0.02855553f, -0.04172019f, -0.02633727f, -0.00418725f, 
    -0.03044869f, -0.03579742f, -0.03654585f, 0.02484392f, -0.00293897f, -0.04062181f, 0.00047261f, -0.02514428f, 
    0.01766470f, -0.03931407f, 0.02277852f, -0.03401779f, -0.03596554f, 0.02975716f, -0.03898879f, -0.04000393f, 
    -0.02208116f, -0.00957835f, 0.02523629f, -0.03429540f, 0.00805171f, -0.02905610f, -0.03982958f, -0.02479668f, 
    0.01525459f, -0.00104550f, -0.02019227f, 0.01541805f, -0.00952324f, -0.04082962f, 0.01258624f, 0.00249178f, 
    -0.02144709f, -0.01936167f, 0.01966340f, -0.02090120f, -0.00403660f, -0.01068589f, -0.00757368f, -0.02632332f, 
    -0.03645067f, -0.01437617f, -0.02656816f, 0.02255207f, -0.00596982f, -0.02784470f, -0.00972982f, -0.03991026f, 
    -0.04204567f, -0.03543136f, -0.00392217f, -0.02938528f, 0.01354598f, 0.01006513f, 0.01005904f, 0.01849491f, 
    -0.01227829f, 0.00417799f, -0.03183263f, -0.00218801f, -0.04089048f, -0.00060306f, 0.02866581f, 0.00248892f, 
    0.00092453f, -0.04073745f, -0.03180317f, -0.01481124f, -0.02594456f, 0.01877885f, 0.00995061f, -0.03096421f, 
    -0.02571589f, -0.03952829f, -0.00642349f, -0.03807753f, 0.00547057f, 0.02690677f, 0.01485628f, 0.00609122f, 
    -0.02080634f, -0.03038308f, 0.01432854f, 0.00474319f, 0.02025512f, 0.01279955f, 0.00073196f, -0.00850588f, 
    -0.01529359f, -0.02835790f, 0.02790795f, 0.01557547f, -0.03039558f, -0.02536797f, -0.02818017f, 0.00890774f, 
    0.02824596f, 0.00302089f, -0.03076917f, 0.02357431f, -0.03683481f, 0.01993520f, -0.03799384f, -0.03993238f, 
    0.02420612f, 0.01624904f, -0.02977723f, 0.01877873f, -0.00172825f, -0.03458878f, -0.01431270f, -0.01168972f, 
    -0.03054541f, 0.00274462f, -0.03076276f, -0.01244131f, -0.03568632f, -0.01344119f, 0.01204173f, -0.00958717f, 
    0.01943470f, -0.01580519f, -0.00579329f, -0.00308468f, 0.00636137f, 0.02402803f, -0.02078705f, -0.01076277f, 
    -0.01048716f, 0.02784619f, 0.01364280f, -0.03923485f, -0.03528354f, 0.01757048f, -0.01390678f, -0.02060168f, 
    -0.03628307f, -0.00386582f, -0.00893924f, 0.02875499f, -0.01594272f, -0.03951067f, -0.00994340f, -0.02904047f, 
    -0.00359961f, -0.01162178f, -0.04183196f, 0.00128176f, 0.01095970f, 0.01733597f, -0.00792116f, -0.00622710f, 
    -0.03063321f, 0.01502655f, 0.02522860f, 0.00302123f, -0.03270140f, -0.01980560f, -0.01851417f, -0.03377166f, 
    -0.00048098f, 0.02030301f, -0.03133995f, -0.03121245f, -0.01030064f, -0.03830457f, -0.01906884f, -0.01871247f, 
    -0.02829713f, -0.00718681f, 0.02223104f, -0.01976818f, -0.02583927f, -0.02282639f, -0.02634658f, -0.02820013f, 
    0.00905208f, 0.00815259f, -0.03311145f, 0.01688300f, -0.03662361f, 0.01869652f, 0.00511854f, -0.04072933f, 
    0.01107852f, 0.00169652f, -0.00125520f, 0.00865635f, -0.02721167f, -0.02501005f, -0.01070966f, 0.01024386f, 
    0.00577056f, -0.02837654f, 0.02039109f, -0.01355940f, -0.02850701f, -0.03004475f, 0.01878167f, -0.00999614f, 
    0.00002198f, 0.02161567f, -0.01933024f, -0.04187090f, -0.04170609f, -0.03740091f, -0.03466057f, 0.00155401f, 
    0.02507205f, 0.01630051f, -0.00469980f, -0.00936671f, -0.02692828f, 0.01491962f, -0.02095253f, -0.00719956f, 
    0.00691992f, -0.01065294f, 0.02131839f, -0.01344489f, 0.02198236f, 0.00473276f, -0.02842860f, 0.01568910f, 
    -0.00143323f, -0.02252701f, 0.02222530f, -0.01822364f, 0.01105128f, 0.00035846f, 0.00870700f, -0.00756329f, 
    -0.01637414f, 0.01314910f, -0.00758048f, 0.02591997f, 0.02860906f, 0.02068368f, 0.01995750f, -0.01844893f, 
    -0.03478477f, -0.01717148f, -0.00295813f, 0.01868742f, 0.00673838f, 0.02645299f, 0.00943525f, 0.01959681f, 
    -0.01575803f, -0.00449392f, -0.01658950f, 0.00408923f, -0.01266544f, -0.01668811f, 0.02406805f, -0.03945260f, 
    0.00000320f, -0.00156831f, 0.01716090f, 0.00502200f, -0.01747639f, 0.00074559f, -0.02179584f, 0.02549052f, 
    -0.02541886f, 0.01252743f, 0.02979216f, -0.02702100f, 0.01368173f, -0.02362116f, -0.03029358f, 0.01585857f, 
    -0.00825319f, -0.02471388f, -0.01711574f, -0.04071343f, 0.01021748f, 0.00958203f, -0.03808486f, -0.03637928f, 
    -0.02400013f, -0.00537268f, -0.00879079f, -0.01467364f, -0.02133851f, -0.04067276f, -0.01911547f, 0.01984016f, 
    0.02663557f, -0.02136071f, -0.01801138f, -0.01901706f, 0.02803169f, 0.01787456f, 0.02828632f, -0.03644842f, 
    0.01236699f, -0.02390177f, -0.03703459f, -0.02658925f, -0.01096664f, 0.00574650f, 0.00594387f, -0.00707617f, 
    0.02487554f, 0.00901768f, -0.00458348f, 0.02344716f, -0.02965158f, -0.01318700f, 0.02177846f, 0.01017804f, 
    -0.02974732f, -0.03191216f, -0.03016558f, 0.01768132f, 0.00700981f, -0.03465535f, -0.01646870f, -0.03721654f, 
    0.00454621f, 0.02501560f, -0.01916453f, 0.02126249f, 0.00285141f, -0.02626948f, -0.00427846f, -0.00708377f, 
    -0.03917322f, -0.03951375f, 0.02806791f, 0.02610124f, -0.01175980f, -0.02340670f, -0.03116920f, -0.01991289f, 
    -0.02560109f, 0.02559010f, -0.04156942f, -0.02077160f, 0.01916422f, -0.00342869f, -0.03495723f, 0.00734834f, 
    0.02734724f, 0.02847890f, 0.02230476f, 0.01743818f, -0.01310326f, -0.03003784f, 0.02329777f, 0.01322863f, 
    -0.03275042f, -0.00606444f, 0.02624202f, -0.01861984f, -0.02684466f, -0.03407325f, 0.00367961f, 0.00455199f, 
    -0.00407808f, -0.00417312f, -0.01922545f, -0.04170017f, -0.03741132f, -0.02786431f, -0.00843619f, -0.01454199f, 
    0.02611258f, -0.02708887f, -0.02646147f, 0.02026243f, -0.00667450f, -0.00092265f, -0.01784890f, 0.00688858f, 
    -0.02672156f, 0.00210294f, -0.00159603f, -0.01776638f, 0.00790537f, 0.02016411f, -0.04121682f, -0.03042672f, 
    -0.02609375f, 0.02640482f, -0.01482089f, 0.02203069f, -0.00918013f, 0.00086963f, 0.02960057f, -0.00033968f, 
    -0.00704066f, -0.01170607f, -0.01436009f, -0.03078540f, 0.00374922f, -0.01283494f, -0.00708806f, 0.01010771f, 
    0.01631774f, -0.03108286f, -0.00356855f, 0.02190543f, -0.02343620f, -0.01343963f, -0.01953131f, 0.00654120f, 
    -0.03301075f, -0.01800002f, 0.01064623f, -0.00802171f, 0.01822298f, 0.02382593f, -0.04201365f, 0.01843026f, 
    0.01696710f, -0.01169829f, -0.00479147f, -0.04138628f, 0.00726091f, -0.01591105f, -0.03965500f, -0.03356406f, 
    -0.00895688f, 0.01177448f, 0.01452884f, -0.01057913f, 0.00919469f, -0.02367940f, 0.01431737f, -0.00325766f, 
    -0.02671569f, 0.02969095f, -0.01167299f, -0.01254423f, -0.00580414f, -0.01298423f, -0.00096050f, 0.02410970f, 
    0.02874778f, 0.04191664f, 0.02029621f, -0.01284018f, -0.01726641f, -0.01875629f, -0.02103072f, 0.00197717f, 
    -0.03193589f, 0.00529441f, 0.02613700f, -0.01558079f, 0.01371470f, 0.00360243f, -0.01078621f, -0.03436815f, 
    0.00516746f, -0.03799151f, 0.01506777f, 0.01252886f, -0.03923439f, -0.01796203f, -0.04190469f, -0.01648051f, 
    -0.00924841f, -0.03414563f, 0.00796008f, 0.02381675f, -0.03493751f, -0.00794781f, -0.03490901f, 0.02363594f, 
    -0.00785619f, -0.03143366f, 0.01171690f, 0.02151405f, 0.00712847f, -0.02484778f, -0.01389608f, 0.00621700f, 
    -0.03304455f, 0.01859842f, -0.01394484f, 0.00404645f, -0.01129362f, -0.01850242f, -0.00974545f, -0.00362497f, 
    -0.04108535f, -0.03862792f, 0.02525829f, -0.00095024f, -0.00069011f, -0.02714808f, -0.04006363f, -0.03380450f, 
    -0.00346302f, -0.01640193f, 0.02186321f, 0.02372591f, 0.02709457f, 0.02141781f, 0.02183632f, -0.02400840f, 
    -0.01272384f, -0.03703385f, 0.00871368f, 0.01583800f, 0.01076985f, -0.00013484f, 0.01554628f, -0.00362452f, 
    -0.01317856f, -0.01718086f, -0.01740266f, -0.02528375f, -0.01488994f, -0.01754719f, -0.02624393f, 0.01665423f, 
    -0.00694570f, -0.03268405f, 0.01065664f, -0.00489079f, 0.00971399f, -0.00922077f, 0.00193878f, 0.02824889f, 
    0.01352302f, -0.00027899f, -0.01408601f, -0.02377753f, 0.00623242f, 0.00041287f, -0.01638225f, 0.02964399f, 
    -0.01029698f, -0.02492035f, -0.02246915f, 0.00683641f, 0.02101451f, 0.00741486f, 0.01037732f, 0.00392083f, 
    0.02242871f, -0.01766486f, -0.02587916f, 0.00200308f, 0.02550120f, -0.03087508f, -0.01616137f, 0.00320128f, 
    -0.00418940f, -0.02442324f, 0.02875168f, -0.03500787f, -0.02093755f, -0.03586040f, -0.03489416f, 0.02903668f, 
    -0.03198751f, -0.01145128f, -0.00829453f, -0.00042793f, 0.02939596f, -0.01568747f, -0.00915541f, -0.04024341f, 
    -0.02283382f, 0.00171184f, 0.00950590f, 0.00660343f, 0.01484933f, -0.03831587f, -0.03279965f, 0.01479265f, 
    -0.01558234f, -0.01193706f, 0.01262258f, -0.03007328f, 0.01627702f, -0.02224270f, 0.02434575f, -0.04191250f, 
    -0.01734969f, -0.02538607f, 0.02912062f, 0.02939342f, 0.01837393f, -0.00014056f, -0.01854442f, 0.01279478f, 
    0.02954473f, 0.00368372f, 0.00859223f, 0.02016695f, -0.00550019f, -0.01438002f, -0.02781442f, -0.04085049f, 
    -0.01186168f, -0.02351502f, 0.01519184f, -0.00236361f, -0.01599024f, -0.03568204f, -0.00772066f, 0.00685573f, 
    -0.00622114f, -0.00784425f, 0.00113098f, 0.00991485f, -0.01330737f, -0.03232679f, -0.00356126f, 0.01571965f, 
    -0.00726541f, -0.03467628f, -0.00980821f, 0.00425866f, -0.04195404f, -0.00033790f, 0.01281746f, -0.00234777f, 
    0.02449335f, 0.02620423f, 0.02317556f, -0.01247687f, -0.01101852f, -0.03015969f, 0.02286987f, -0.00696232f, 
    -0.01535956f, -0.01680107f, 0.00093695f, 0.00643326f, 0.01626625f, -0.02015782f, -0.01342634f, -0.03343057f, 
    -0.01374218f, -0.00918027f, 0.01157294f, -0.00851859f, 0.01308736f, -0.01135357f, 0.01585534f, 0.02251072f, 
    0.00683753f, -0.02213750f, 0.01331393f, -0.00792847f, -0.01960748f, 0.00254092f, -0.01839091f, -0.01354437f, 
    0.01690443f, 0.02528615f, 0.02465487f, 0.00760255f, -0.02362591f, -0.00428842f, 0.00354103f, -0.02537095f, 
    0.00127525f, 0.02460435f, 0.02077162f, -0.04054088f, -0.01076597f, -0.02234529f, 0.01978192f, 0.00861611f, 
    -0.00234206f, -0.00307245f, 0.02732980f, -0.03049775f, -0.00733900f, 0.01621471f, -0.02627786f, -0.01001188f, 
    -0.00797848f, 0.00814535f, 0.02832443f, -0.01136123f, -0.00944111f, 0.00612950f, -0.00057239f, 0.01478516f, 
    0.02554125f, 0.00605970f, 0.02911527f, -0.03859668f, 0.03002201f, -0.00195825f, -0.01333804f, -0.03701310f, 
    0.00516333f, 0.00410825f, -0.03097680f, -0.01680634f, -0.00520684f, 0.01236049f, 0.02165787f, -0.02753311f, 
    -0.01603904f, -0.01737986f, -0.01438932f, -0.03308308f, 0.00586196f, -0.03109130f, -0.00250489f, -0.00531661f, 
    -0.03370248f, -0.03359408f, -0.00365448f, 0.00367903f, -0.02276133f, -0.03654085f, -0.04045665f, 0.02382915f, 
    -0.03361721f, -0.00056548f, -0.03757934f, 0.01045807f, -0.02395043f, 0.00660776f, -0.00254367f, -0.02100412f, 
    0.04861152f, -0.15144078f, -0.02123113f, 0.21298108f, 0.01471813f, 0.00583692f, 0.08888590f, 0.01802682f, 
    0.10643949f, 0.06979907f, -0.01295070f, -0.00730074f, 0.19887482f, 0.16119568f, -0.10124535f, -0.07928292f, 
    0.12920372f, 0.00929458f, 0.01002043f, 0.20893247f, 0.06103647f, -0.03925506f, -0.00735113f, 0.07916294f, 
    0.11150851f, -0.24166329f, 0.22969243f, -0.19989505f, -0.00676707f, -0.03426598f, -0.07197233f, -0.03646213f, 
    -0.02311543f, 0.00871281f, 0.06211327f, 0.08068828f, 0.18682733f, 0.01849956f, -0.14259109f, -0.12303760f, 
    0.03370637f, 0.01371905f, 0.09178907f, -0.06881729f, -0.02197644f, 0.06522574f, 0.05904955f, 0.06414700f, 
    0.23731905f, -0.03359039f, 0.07675246f, 0.01128733f, -0.00597471f, -0.07621969f, 0.13838948f, 0.05483795f, 
    -0.00425001f, -0.04794342f, -0.04591684f, 0.03319691f, 0.17119168f, -0.00817992f, -0.05596510f, 0.08459504f, 
    0.13603935f, 0.02455497f, 0.03165041f, 0.03101153f, -0.01593275f, 0.04476236f, -0.08068482f, 0.01018079f, 
    -0.04494778f, -0.07576142f, -0.13469027f, -0.12701105f, 0.05736437f, 0.04259679f, -0.05579526f, 0.00744965f, 
    0.03025364f, 0.01163039f, 0.05657314f, -0.00351056f, -0.03360772f, 0.14053877f, -0.07434683f, 0.06540467f, 
    0.15847772f, 0.15301874f, 0.12766202f, 0.08774120f, 0.08623976f, -0.09662309f, 0.04866632f, -0.04669884f, 
    0.07705078f, -0.11248165f, -0.04539927f, 0.01988187f, -0.09463111f, 0.03030404f, -0.01172600f, 0.03937339f, 
    0.13959430f, 0.06898459f, 0.10474193f, -0.09874208f, -0.02411790f, -0.03427576f, -0.06288867f, 0.01117129f, 
    -0.11608551f, -0.04638530f, 0.06314614f, -0.02359634f, 0.00802410f, 0.09783085f, -0.01169424f, -0.11344100f, 
    0.12921757f, 0.01700770f, -0.19821453f, -0.11327507f, 0.20058793f, -0.00609661f, 0.03163061f, -0.16107388f, 
    0.01487076f, -0.01994729f, 0.05545874f, 0.02512790f, 0.04232559f, 0.11079867f, 0.08503189f, 0.15015830f, 
    0.02424519f, 0.06982347f, -0.05040219f, 0.00338803f, 0.16266018f, 0.02149619f, 0.08275783f, 0.10868371f, 
    0.03810538f, -0.03911298f, -0.05453588f, 0.05653869f, -0.03976550f, 0.14032125f, -0.10115140f, 0.00351894f, 
    0.12479520f, 0.01588164f, -0.04891098f, -0.01372916f, -0.06703112f, 0.09083571f, 0.00289119f, -0.14560848f, 
    -0.02197089f, 0.02057560f, 0.09355346f, 0.02924569f, 0.05323549f, -0.03681397f, 0.04966972f, -0.00587077f, 
    0.03736231f, -0.07302023f, -0.01817643f, 0.06216675f, 0.04142284f, -0.07044777f, -0.15154615f, 0.06731784f, 
    -0.00344366f, 0.04371954f, 0.05921941f, 0.10605533f, 0.26120207f, -0.17382185f, -0.03632404f, 0.12066764f, 
    -0.02621093f, -0.10025943f, -0.09231721f, -0.00560260f, 0.05441836f, -0.04335557f, 0.13060850f, 0.00426913f, 
    -0.03040748f, 0.11811098f, 0.03041149f, 0.10137717f, 0.09063648f, 0.05087138f, 0.04614973f, 0.04064559f, 
    0.15005824f, 0.11761579f, 0.08294835f, 0.07089973f, 0.11761519f, -0.11703008f, -0.05317303f, -0.10862482f, 
    -0.00136128f, -0.07687569f, -0.07416253f, -0.00246739f, -0.09102538f, 0.00308846f, 0.11444183f, -0.09131353f, 
    -0.27317479f, -0.02252623f, 0.06206741f, 0.01749106f, 0.00893525f, -0.13263483f, -0.09966695f, -0.06422163f, 
    -0.12158233f, -0.05059519f, -0.04517433f, 0.08792498f, 0.05612494f, -0.01853527f, -0.01016136f, 0.01513063f, 
    -0.07868835f, -0.05872867f, 0.11786965f, -0.02646553f, -0.09119710f, -0.07371835f, 0.03401224f, -0.05976092f, 
    0.02149983f, -0.04697517f, -0.05739512f, 0.04037483f, 0.01658406f, -0.01714228f, -0.00681438f, 0.00645264f, 
    -0.03741643f, 0.12215454f, 0.00991283f, 0.00537860f, -0.14572619f, -0.10670308f, 0.09342558f, -0.14655586f, 
    0.07930197f, -0.00596988f, 0.04934704f, 0.06974314f, -0.02753691f, -0.02475602f, 0.07671200f, 0.05454918f, 
    0.17908579f, -0.21549001f, 0.26853412f, -0.13104486f, -0.05583571f, -0.01807087f, 0.05286404f, 0.03039698f, 
    0.05711908f, 0.03863783f, 0.03457681f, -0.02273132f, -0.05489241f, 0.22783728f, -0.07177131f, 0.07236357f, 
    -0.04270706f, 0.07113606f, 0.11408748f, 0.03543306f, 0.16408202f, 0.01235537f, -0.10421690f, 0.21176818f, 
    -0.02781595f, -0.07737696f, 0.03918377f, 0.04508354f, 0.00735580f, 0.08354109f, -0.02677077f, -0.04708517f, 
    0.17480643f, 0.01326225f, 0.07159403f, 0.04104616f, 0.10773099f, -0.22739628f, 0.09326109f, 0.00410974f, 
    -0.03960107f, -0.01593989f, 0.00996273f, 0.03685077f, 0.14762658f, 0.01440830f, 0.01875271f, -0.03606345f, 
    -0.11488422f, 0.28893474f, -0.17458248f, 0.07266415f, 0.09768168f, 0.05826791f, 0.00222040f, -0.03552750f, 
    0.03952599f, -0.00122468f, 0.11624327f, -0.06321694f, -0.08971373f, -0.01455186f, -0.13355783f, -0.01663077f, 
    0.10731570f, 0.03342355f, 0.05196143f, -0.01233262f, 0.04191316f, 0.03160159f, 0.08502223f, 0.00309838f, 
    0.02426980f, 0.00792253f, -0.02797247f, -0.13613187f, -0.07435948f, -0.10833152f, -0.00191576f, -0.02670274f, 
    -0.13652931f, 0.10503778f, -0.05361192f, -0.01239321f, -0.19749601f, -0.01218936f, 0.00747692f, -0.06828281f, 
    0.13137700f, 0.02286290f, 0.02363521f, -0.07606070f, 0.02902198f, 0.06462619f, 0.09206868f, -0.02750699f, 
    -0.04148730f, 0.10090814f, -0.00756365f, -0.00378448f, -0.14830941f, 0.01011229f, -0.03235599f, -0.02182040f, 
    -0.01730490f, -0.01574383f, 0.02891820f, -0.07451518f, 0.16746916f, 0.00509488f, -0.05202861f, -0.17956290f, 
    0.13707845f, -0.02177706f, 0.01061654f, 0.03114939f, -0.00016448f, -0.06587169f, -0.01013235f, 0.00422054f, 
    0.11147050f, 0.16022174f, -0.05647797f, 0.14307120f, 0.14142954f, 0.08433577f, -0.06023159f, -0.06318935f, 
    0.03730684f, 0.10508174f, 0.00145378f, 0.10929979f, 0.13095269f, -0.19691780f, 0.08025303f, 0.01481979f, 
    -0.04666562f, -0.05567393f, 0.01166842f, 0.17908205f, -0.21856989f, 0.08064947f, 0.09650530f, -0.09411228f, 
    -0.17361341f, 0.01814053f, -0.00130008f, -0.17170008f, 0.00564094f, -0.07706606f, -0.02144193f, 0.12687333f, 
    -0.07017968f, 0.04502586f, -0.17712876f, 0.07848544f, 0.21599153f, -0.03157078f, 0.06043972f, 0.11986064f, 
    0.00376120f, 0.09475631f, -0.03942041f, 0.17061076f, -0.10260390f, -0.06192997f, 0.10321298f, 0.05860773f, 
    -0.09461632f, -0.13845602f, -0.01641433f, -0.01123854f, -0.03255732f, -0.04826970f, 0.06551503f, 0.04029716f, 
    0.05127155f, -0.12131522f, -0.01075909f, 0.00400392f, 0.08317822f, 0.16898338f, 0.08324258f, -0.16968580f, 
    0.11580230f, -0.00411996f, -0.10106818f, 0.03034846f, 0.00059298f, -0.09946429f, 0.06783328f, 0.07178849f, 
    -0.13850249f, -0.06682011f, 0.12671585f, -0.10779399f, -0.01891188f, -0.11797649f, -0.00197990f, -0.04945885f, 
    -0.04311732f, 0.02866964f, 0.03890162f, -0.06930612f, 0.10591418f, 0.05879075f, -0.04824860f, 0.14955561f, 
    0.07765760f, 0.04737795f, -0.05016654f, -0.00485118f, 0.04473276f, 0.01116417f, 0.09983154f, 0.14973348f, 
    0.24764448f, -0.08391048f, 0.04469280f, -0.02806069f, 0.12057970f, -0.01377377f, -0.02182074f, 0.03484223f, 
    0.01488969f, -0.05885756f, 0.08099151f, -0.10725115f, -0.07389004f, 0.06821994f, -0.07137929f, -0.04955140f, 
    0.06985544f, 0.01644573f, -0.06078230f, 0.01848587f, 0.07751626f, 0.01940726f, 0.00058972f, -0.02137608f, 
    0.17370023f, 0.02837106f, -0.04251589f, 0.06460158f, 0.01414811f, 0.06093010f, -0.00326648f, -0.01281572f, 
    0.07154997f, 0.01485649f, -0.07782403f, 0.06845917f, 0.11705803f, -0.14265712f, -0.10394979f, 0.09168739f, 
    0.04488950f, 0.11771719f, 0.05556280f, 0.05216625f, 0.08946702f, 0.04099479f, -0.09240138f, 0.07290757f, 
    0.06436621f, -0.13148102f, 0.15565334f, -0.26562309f, -0.05500975f, -0.04329529f, -0.02586679f, -0.06346763f, 
    -0.03740286f, -0.00634326f, -0.03163584f, 0.10757006f, 0.09863839f, 0.04001231f, 0.09386118f, -0.15254414f, 
    0.13347368f, 0.06757884f, -0.02641771f, 0.05305408f, 0.05257323f, 0.03587124f, 0.00182541f, 0.13560975f, 
    0.19326045f, -0.04481086f, -0.17907171f, -0.04267139f, 0.09115281f, -0.09687752f, -0.00577261f, 0.05578042f, 
    0.03659496f, 0.09636344f, 0.06151542f, 0.06597145f, -0.21731582f, -0.14039414f, -0.08398286f, 0.20698155f, 
    -0.02888094f, -0.05059541f, 0.00901337f, 0.05051363f, 0.11889421f, -0.01750998f, 0.03497143f, 0.03940733f, 
    -0.11141968f, -0.12196960f, 0.15565035f, -0.08154155f, -0.02241592f, -0.03309903f, -0.06397501f, 0.02530996f, 
    0.02357402f, 0.01715770f, -0.03191753f, 0.00487498f, -0.40562531f, 0.11560010f, -0.33910343f, -0.10728233f, 
    -0.12801720f, -0.09784309f, -0.04617544f, -0.04402414f, 0.08336835f, -0.04053422f, 0.01799844f, -0.12793368f, 
    -0.14943099f, -0.12476757f, -0.08648982f, 0.04320176f, -0.11954214f, 0.05941848f, 0.07472096f, -0.00819026f, 
    -0.15018634f, -0.00688141f, 0.01351064f, 0.02022322f, 0.06725821f, -0.07254656f, 0.13367859f, 0.05462860f, 
    -0.10622955f, 0.09757348f, 0.06356476f, 0.03466979f, 0.01152472f, 0.09799325f, 0.01043623f, 0.04333845f, 
    0.12369024f, 0.14019234f, -0.06329032f, -0.05607042f, 0.05013107f, 0.06881580f, -0.07588822f, -0.11385619f, 
    0.07016931f, -0.02997331f, 0.01967640f, -0.03675224f, 0.00421904f, -0.09045912f, 0.14704821f, -0.09011409f, 
    -0.07494412f, -0.03350391f, -0.04783239f, 0.01812027f, 0.04719505f, -0.05170584f, -0.01822071f, -0.04064802f, 
    0.26549056f, -0.06889061f, -0.03383215f, 0.08337519f, -0.02134894f, -0.02666195f, 0.09625930f, 0.05422418f, 
    0.06619168f, -0.10365902f, 0.11547316f, -0.06864116f, 0.01309392f, -0.00707223f, -0.06074101f, 0.01751102f, 
    0.03923497f, 0.01019292f, 0.06775166f, -0.05477897f, 0.02501638f, 0.08679583f, 0.05782906f, 0.11015198f, 
    -0.22264932f, -0.08204626f, 0.16152011f, 0.00572807f, 0.02477916f, -0.07709011f, -0.03525220f, -0.12065124f, 
    -0.09813174f, 0.02997191f, 0.02820826f, 0.06515485f, -0.13103011f, -0.02738270f, 0.05523950f, -0.11725273f, 
    0.03530705f, -0.06459679f, -0.00713393f, -0.01421497f, 0.11178803f, -0.03844028f, 0.06263207f, 0.03361592f, 
    0.22121502f, 0.09423310f, 0.11171850f, 0.02280306f, 0.04935502f, 0.03713716f, 0.13807845f, 0.05863837f, 
    0.08799531f, -0.12612545f, 0.00622834f, 0.05238589f, -0.05872452f, -0.01467911f, 0.08642621f, 0.25661421f, 
    -0.06636094f, -0.11624123f, 0.12302086f, -0.10543003f, 0.10767472f, 0.16130273f, 0.01028314f, 0.10473102f, 
    0.02843142f, -0.22110514f, 0.10322957f, -0.01345713f, -0.13377513f, -0.04520353f, 0.07131260f, 0.10875105f, 
    0.00341347f, -0.03456119f, 0.03114011f, -0.03611292f, 0.16675647f, 0.22127037f, -0.00661782f, -0.03113059f, 
    0.07910366f, 0.09484134f, 0.07902339f, 0.12452514f, 0.12752371f, 0.05838808f, 0.02506323f, -0.00360440f, 
    -0.18230923f, -0.04870174f, -0.15175785f, -0.13256277f, 0.02720369f, 0.01130567f, -0.05273204f, -0.02550372f, 
    0.09021329f, 0.07002333f, -0.03669171f, -0.08220716f, -0.02773962f, -0.03953904f, -0.02091098f, 0.04958445f, 
    -0.15822004f, -0.08051652f, 0.03565148f, -0.08418538f, -0.05043413f, -0.01091697f, -0.04647627f, -0.05871312f, 
    -0.00958308f, 0.02519510f, 0.01035904f, -0.03015462f, 0.02971129f, 0.02035842f, 0.01209647f, 0.01993384f, 
    -0.00846616f, -0.00839964f, 0.00523856f, -0.01913099f, -0.02639748f, -0.00894961f, 0.00418050f, -0.02015211f, 
    -0.01252277f, -0.01195292f, -0.01800059f, 0.01325706f, -0.01648274f, -0.01929296f, 0.02010140f, -0.02000571f, 
    0.01142396f, 0.00548724f, 0.00044514f, -0.02860526f, 0.01742818f, 0.00607227f, -0.00281506f, -0.02950534f, 
    -0.01835019f, -0.01755957f, 0.01120542f, 0.00236303f, -0.00886312f, -0.02747797f, 0.02182611f, 0.01616223f, 
    0.00837863f, -0.02867999f, 0.00385820f, 0.02546832f, 0.01999999f, -0.03106274f, 0.01341248f, -0.03608191f, 
    0.02561119f, -0.03364402f, -0.03425647f, -0.00648177f, 0.02383902f, -0.03555084f, -0.03407198f, -0.01634801f, 
    -0.01470864f, 0.00078674f, 0.01878045f, -0.03957461f, 0.01443543f, -0.02848832f, -0.03274063f, 0.02209261f, 
    0.02330800f, -0.00684170f, -0.01788693f, -0.01381895f, 0.01691782f, 0.02169349f, 0.00922958f, 0.00331561f, 
    -0.03575034f, 0.02003850f, -0.03024169f, 0.00003368f, 0.02009224f, -0.03556529f, -0.03178966f, 0.02616772f, 
    0.02408287f, 0.02073807f, -0.03390723f, -0.04556017f, -0.01443803f, -0.02844798f, -0.03567769f, 0.02300044f, 
    -0.00503625f, 0.02853291f, 0.01946906f, 0.01103435f, -0.04345715f, 0.01608054f, -0.00919554f, -0.01458470f, 
    -0.01275589f, 0.02975827f, -0.02301547f, -0.02607085f, -0.02522149f, 0.01133470f, 0.00667270f, 0.01320460f, 
    -0.01727249f, -0.01399858f, -0.00227748f, -0.00583045f, 0.00733045f, -0.00670231f, -0.03710214f, -0.01960145f, 
    0.01948022f, -0.01260197f, -0.02865104f, 0.00104529f, 0.01117307f, 0.02604703f, 0.00763307f, 0.00941376f, 
    -0.00143822f, -0.00245333f, 0.00353575f, 0.01668620f, 0.03023701f, 0.01166705f, 0.02217637f, -0.04049329f, 
    -0.03679370f, -0.02040362f, -0.00732923f, 0.00357362f, -0.03690042f, -0.01559131f, -0.03096569f, 0.02083443f, 
    0.02771332f, -0.03209831f, -0.02905399f, -0.02645602f, -0.01029397f, 0.00552971f, -0.00396379f, -0.03968167f, 
    0.00441523f, 0.00738331f, -0.00619191f, -0.00970708f, -0.03860065f, 0.02130941f, -0.04103621f, -0.00770882f, 
    -0.02138202f, -0.02818050f, -0.02932447f, -0.01048394f, -0.03978632f, 0.00089220f, 0.00022185f, -0.03024555f, 
    0.02034539f, 0.02407550f, -0.00899363f, -0.03879619f, -0.03805923f, -0.01345951f, -0.04103973f, -0.02016230f, 
    -0.01693266f, 0.02467880f, -0.03070505f, 0.01453140f, -0.00827106f, -0.04535114f, 0.02314984f, -0.00161972f, 
    0.02169555f, 0.01356542f, 0.03633621f, 0.01952347f, -0.00111237f, 0.00684682f, 0.01347700f, 0.00535347f, 
    -0.00495732f, -0.02724515f, -0.02961762f, -0.02642592f, 0.01556711f, -0.01162772f, -0.03241080f, -0.03160474f, 
    -0.02431551f, -0.01270547f, -0.00706857f, 0.02931689f, -0.03648320f, -0.01858367f, -0.04216354f, -0.04271405f, 
    0.00867925f, -0.03580190f, -0.00784564f, -0.02449496f, 0.02228025f, 0.02359400f, -0.03026656f, -0.01364094f, 
    0.00859148f, -0.03430636f, -0.03790811f, -0.00616342f, 0.00920205f, -0.00863997f, 0.02354196f, -0.02597513f, 
    0.00213977f, -0.00532024f, -0.03498991f, -0.04104837f, 0.00142458f, 0.01061580f, -0.03443870f, -0.01058898f, 
    -0.02568575f, -0.04140332f, 0.01101303f, -0.01079475f, -0.00501995f, 0.00555849f, -0.01068595f, 0.00219924f, 
    -0.04156128f, -0.03269083f, -0.03107902f, 0.01590477f, 0.02478563f, -0.00883498f, -0.02207810f, -0.00464509f, 
    -0.01100226f, 0.00890044f, -0.03986664f, 0.02258163f, -0.03911554f, -0.04109480f, -0.03603757f, 0.00134233f, 
    -0.02030263f, -0.00075368f, 0.03072249f, -0.03850962f, 0.01579326f, -0.01687170f, 0.00816152f, -0.03859765f, 
    -0.00010708f, 0.00983848f, -0.02233015f, 0.01967074f, -0.01824064f, 0.01390867f, 0.01710822f, 0.00370941f, 
    -0.04084744f, 0.01927274f, -0.04010032f, -0.03701783f, -0.01211832f, -0.01351864f, 0.01335340f, 0.01547874f, 
    -0.03239622f, -0.03518502f, 0.01088359f, -0.00120862f, -0.04220496f, -0.02450524f, 0.01244338f, 0.01837800f, 
    0.00651090f, -0.00839309f, -0.03859347f, 0.01507915f, 0.01291228f, -0.01594243f, -0.01823900f, 0.02578592f, 
    -0.00354744f, 0.00797786f, -0.00996598f, -0.03450262f, -0.00798489f, -0.03458159f, 0.02428563f, -0.02752450f, 
    -0.00147320f, 0.02435167f, 0.00747452f, 0.03502300f, 0.01395318f, 0.00976637f, 0.02513703f, -0.04247518f, 
    -0.02844285f, -0.02004349f, -0.03916372f, -0.00283078f, -0.03463644f, 0.01348451f, 0.02427467f, -0.00859799f, 
    0.02591511f, -0.03072706f, -0.01433475f, -0.02893439f, 0.01509880f, 0.00459843f, -0.03085123f, 0.01394129f, 
    0.01998474f, 0.01774888f, -0.03182838f, 0.03316969f, -0.02832177f, -0.01455547f, 0.01691167f, -0.00230943f, 
    -0.02933366f, -0.01083482f, -0.00222479f, -0.00201628f, -0.01210030f, -0.03488939f, -0.03462277f, 0.02198983f, 
    -0.02127571f, 0.02092408f, -0.00799698f, -0.00811470f, -0.03308294f, -0.00472247f, -0.01890919f, -0.01855709f, 
    -0.03259022f, 0.00030261f, -0.00358322f, -0.00317095f, -0.01636995f, -0.03705793f, -0.01733316f, -0.00191600f, 
    0.02229811f, -0.02786347f, 0.00767186f, 0.01317584f, -0.02121498f, -0.02643825f, 0.01182510f, -0.02797863f, 
    0.03053951f, -0.02556528f, -0.03420250f, 0.01622851f, -0.02657913f, -0.04474559f, -0.02848409f, -0.02610215f, 
    0.02702815f, -0.00444092f, -0.00455149f, 0.00515763f, -0.01517880f, 0.00840364f, -0.03538689f, -0.00298735f, 
    0.01187529f, -0.02901441f, -0.00933009f, -0.03350063f, 0.02731923f, 0.00716798f, -0.00626093f, -0.01188452f, 
    0.02962423f, -0.00502136f, -0.02784329f, 0.02226826f, -0.01867173f, 0.02473411f, 0.02720478f, 0.00481976f, 
    0.02590229f, -0.02568706f, 0.01032434f, -0.01595825f, -0.02500189f, -0.01671947f, 0.00163914f, -0.00940043f, 
    -0.01231901f, 0.00314474f, 0.02537190f, 0.00320914f, -0.02679273f, -0.02731111f, -0.02375072f, -0.00099473f, 
    -0.03698707f, 0.00474541f, 0.01541066f, -0.04160473f, -0.02622143f, 0.02739788f, 0.01389215f, 0.02027647f, 
    -0.02149774f, -0.01804267f, -0.03895487f, 0.01091938f, 0.01058027f, 0.02368183f, 0.00221823f, -0.01319658f, 
    -0.00531699f, -0.01881661f, -0.00438739f, -0.04313988f, -0.01364703f, -0.02568215f, -0.02444585f, -0.03571835f, 
    -0.03540992f, 0.00818215f, 0.02450661f, 0.00528893f, -0.04316022f, -0.04613666f, 0.02490597f, -0.01267341f, 
    0.00091570f, -0.01752514f, 0.01944679f, -0.01232143f, -0.02599396f, -0.00382191f, -0.00261810f, -0.02486312f, 
    0.02764443f, 0.01865473f, 0.01877062f, -0.03325865f, 0.00319027f, 0.02629130f, -0.00085793f, 0.01784642f, 
    -0.04088745f, -0.00122703f, -0.00642744f, 0.01698083f, 0.01829010f, -0.02503381f, 0.02151994f, 0.00111329f, 
    0.00102407f, 0.01149897f, -0.02573556f, -0.03958336f, -0.03821164f, -0.02017954f, -0.01099464f, 0.01418401f, 
    0.00695948f, -0.03554741f, -0.00401330f, -0.02780043f, -0.03809918f, -0.00384040f, 0.00774681f, -0.00029312f, 
    -0.03449040f, 0.00777566f, 0.00495343f, 0.02155031f, -0.03255262f, 0.02508611f, -0.00046287f, 0.00632702f, 
    -0.02577250f, 0.02225437f, 0.00976909f, -0.02278679f, -0.02554716f, 0.01599345f, -0.00687420f, -0.00241079f, 
    0.01793645f, 0.02749347f, -0.04448046f, 0.01944258f, -0.03630176f, -0.04411358f, 0.01811934f, 0.01153252f, 
    -0.02728799f, 0.02856338f, 0.03017728f, -0.02523933f, -0.01576828f, 0.01695539f, -0.00275903f, 0.00440242f, 
    -0.03691260f, -0.02586233f, -0.03677314f, -0.02160392f, -0.02314616f, 0.02402336f, 0.03132160f, -0.01471256f, 
    -0.00520621f, 0.01452225f, 0.01661573f, -0.02597501f, -0.03295433f, -0.01459387f, -0.01663634f, 0.01687500f, 
    0.01527879f, 0.01560830f, 0.00306268f, 0.01540976f, -0.04407630f, 0.00882976f, -0.02976209f, -0.01316443f, 
    -0.01566288f, 0.00917584f, -0.01196478f, -0.01865539f, -0.02105399f, -0.03742043f, 0.02145546f, -0.00604976f, 
    -0.00691284f, -0.00938715f, -0.00896168f, 0.01037249f, -0.00392910f, 0.00886807f, -0.03399993f, 0.01943159f, 
    0.02390136f, -0.02691551f, -0.00568067f, -0.02190636f, 0.03172855f, 0.00211090f, -0.02557183f, 0.00865071f, 
    0.01553521f, -0.04075220f, 0.02392063f, 0.01243866f, -0.00972573f, 0.02422025f, 0.00525245f, 0.02390767f, 
    -0.01882455f, -0.01204639f, -0.02727192f, -0.00484938f, 0.00825936f, 0.01731995f, -0.03168868f, 0.00144398f, 
    -0.01702546f, -0.02344372f, 0.01986581f, -0.02069897f, 0.02139359f, -0.04272528f, -0.02750689f, -0.02545322f, 
    -0.01348451f, 0.01587613f, 0.02848459f, 0.00689491f, -0.02006629f, 0.01849416f, -0.02912951f, -0.03998483f, 
    -0.02082489f, 0.02605516f, -0.03709954f, 0.00829161f, -0.03367673f, -0.02334628f, 0.02312408f, -0.03672202f, 
    -0.00148726f, 0.01423605f, -0.00496183f, -0.02394764f, 0.01883063f, -0.04333348f, 0.02072291f, 0.00975778f, 
    -0.04415471f, 0.00571812f, -0.01216271f, 0.00350104f, -0.02697336f, 0.02238422f, -0.00998220f, -0.03775868f, 
    -0.01889117f, 0.01454524f, 0.00156126f, -0.03953905f, 0.00366828f, 0.03102513f, 0.02000656f, 0.01507718f, 
    -0.02760825f, 0.01463416f, -0.00172837f, -0.01343354f, -0.02852722f, -0.03886062f, -0.00861205f, -0.03000584f, 
    0.02438498f, 0.02326533f, 0.02160909f, 0.02770588f, -0.00086626f, 0.02748888f, -0.02335697f, -0.00840789f, 
    0.02495132f, -0.01202533f, -0.00980741f, -0.00466557f, 0.01812166f, -0.02389302f, -0.02700265f, 0.00221072f, 
    0.01628104f, -0.01588113f, 0.00251509f, 0.00627110f, -0.01339076f, -0.00771285f, 0.00972311f, 0.00771121f, 
    0.01322237f, -0.03711689f, 0.01727158f, -0.04078456f, 0.00515025f, 0.02346442f, 0.02623124f, -0.00510522f, 
    0.00915881f, 0.00417430f, -0.01554930f, -0.04043044f, -0.01471279f, 0.00590538f, 0.02202956f, -0.00107313f, 
    -0.04052017f, -0.01951579f, -0.02018212f, 0.01199980f, -0.01822813f, -0.01329705f, 0.00662332f, -0.00523827f, 
    -0.01901149f, 0.01232347f, -0.00098562f, -0.01745674f, -0.02702336f, -0.01933880f, -0.02135686f, -0.03933171f, 
    0.02107312f, 0.01567300f, 0.00749803f, 0.00523622f, 0.01963268f, -0.00542333f, 0.01224213f, -0.00146027f, 
    0.01135189f, -0.02877562f, -0.03811960f, -0.00030999f, -0.00518643f, 0.02511379f, 0.00694030f, 0.00754859f, 
    -0.01901309f, 0.00059000f, -0.04064436f, 0.02054544f, 0.01117012f, -0.04010260f, 0.00661242f, -0.03241816f, 
    -0.01981945f, 0.00076736f, -0.03138148f, -0.00538937f, -0.01349581f, -0.00776652f, 0.01313543f, -0.01340909f, 
    0.02371864f, 0.02035357f, 0.00650006f, 0.00321334f, -0.03049370f, 0.02742592f, -0.03672926f, -0.01498748f, 
    -0.02292540f, -0.00535895f, -0.00349369f, -0.02721680f, 0.01978659f, 0.01816568f, -0.04423261f, 0.00763927f, 
    -0.02527880f, -0.02465359f, -0.03483242f, -0.00988259f, -0.01611874f, 0.01836877f, 0.00064049f, -0.03088185f, 
    0.02489574f, 0.03548786f, -0.04000758f, -0.04035407f, -0.01332568f, -0.01308193f, -0.02031838f, -0.03118808f, 
    0.02688786f, -0.03360161f, 0.00708270f, -0.00168100f, -0.04214485f, -0.00992004f, 0.02234678f, 0.00823624f, 
    0.02730951f, 0.00012775f, 0.00449820f, -0.01419301f, 0.01695528f, -0.02012526f, -0.00224020f, 0.01156632f, 
    0.00972799f, -0.02677204f, -0.02882938f, -0.03538946f, 0.02046267f, -0.04184724f, 0.02848874f, -0.01920689f, 
    -0.02378167f, -0.03580687f, -0.02226799f, -0.01889446f, 0.02427852f, -0.00006009f, 0.00550572f, -0.02784834f, 
    0.02464896f, 0.00972103f, -0.03309792f, -0.01135446f, -0.00370262f, 0.01594588f, 0.01879211f, -0.00735543f, 
    0.00450092f, -0.03672823f, 0.02432824f, -0.00564934f, -0.02760429f, -0.00032169f, 0.01211047f, -0.04011578f, 
    -0.03080500f, -0.02056757f, -0.01313802f, -0.00979111f, 0.01866737f, 0.02197808f, -0.02058827f, -0.00075479f, 
    -0.02254853f, 0.00318283f, 0.00739978f, -0.02237111f, 0.01850635f, -0.03042319f, 0.02451597f, -0.01017696f, 
    -0.03105840f, 0.02948304f, -0.00593185f, 0.01079775f, -0.03527367f, -0.04160477f, -0.03003699f, 0.01688504f, 
    0.02206942f, -0.04151446f, -0.03595480f, -0.02569027f, -0.03246458f, -0.02757769f, -0.01501105f, -0.00704956f, 
    -0.02509239f, -0.01219451f, 0.02021330f, 0.01850047f, -0.01527541f, -0.01131782f, 0.00958214f, 0.00116584f, 
    -0.03620733f, -0.00778450f, 0.02421996f, 0.00696102f, 0.02284367f, 0.00893387f, -0.01639468f, 0.00247431f, 
    0.02811988f, 0.00802778f, -0.03648837f, 0.00009034f, -0.00794146f, -0.01479130f, 0.02979412f, 0.02531334f, 
    -0.02272836f, 0.00304671f, -0.04065140f, 0.01539049f, 0.00911186f, 0.01100786f, 0.02612162f, 0.00906671f, 
    0.00299836f, -0.02652542f, -0.00960020f, -0.01364532f, -0.00832319f, -0.03310908f, 0.00698822f, 0.01644357f, 
    0.00790192f, -0.02293562f, -0.01838137f, -0.03291380f, -0.01223251f, 0.01607522f, -0.01047642f, 0.00977579f, 
    0.01649981f, -0.02604683f, -0.02873104f, 0.02561385f, 0.02045815f, -0.01094662f, 0.00520421f, 0.00742600f, 
    -0.00476501f, -0.03787853f, -0.01387881f, 0.01104666f, -0.02745288f, 0.02171528f, -0.00383110f, -0.02177315f, 
    -0.00638279f, -0.00101870f, -0.00129863f, -0.00093656f, -0.00471160f, -0.00462569f, 0.01744139f, 0.02795417f, 
    0.00034879f, -0.03101133f, -0.01261736f, -0.00805014f, 0.02153671f, -0.00553408f, 0.02437997f, -0.03755243f, 
    -0.01784275f, 0.00587207f, -0.00182796f, -0.02514870f, -0.02611071f, -0.03346565f, -0.00133787f, 0.02112040f, 
    0.01189406f, -0.01477359f, -0.03091963f, -0.04093613f, -0.03640851f, 0.02626781f, -0.03377966f, -0.02691117f, 
    -0.00181414f, -0.03451838f, -0.03753080f, -0.00199293f, 0.02490762f, -0.02731605f, -0.00457136f, -0.01128171f, 
    0.02147556f, 0.02224822f, 0.01780616f, 0.01710855f, -0.02301112f, 0.00305547f, -0.00999500f, -0.01778976f, 
    0.01019413f, 0.02870261f, 0.01839359f, -0.01131304f, 0.01013900f, 0.01048172f, 0.02696522f, 0.02903350f, 
    -0.03498343f, -0.00569665f, -0.03668496f, -0.03831539f, -0.00244603f, -0.01326803f, -0.03933694f, 0.02126925f, 
    0.00063937f, 0.00560942f, 0.00982692f, -0.01622575f, -0.02535801f, -0.02513992f, -0.02004331f, -0.03056237f, 
    -0.01276566f, -0.02656749f, 0.02633246f, -0.03704529f, -0.03011877f, -0.03250461f, 0.01975671f, 0.01048567f, 
    -0.02763234f, -0.00733286f, -0.02865062f, 0.02563738f, 0.00402247f, 0.02462823f, -0.02359420f, -0.01183015f, 
    0.00577186f, -0.03767527f, -0.02837484f, 0.00048911f, 0.01405553f, -0.04129796f, -0.01766694f, -0.01632655f, 
    0.02213523f, -0.00808845f, -0.03998443f, -0.01344737f, 0.00761129f, -0.02891289f, 0.01961114f, 0.02291827f, 
    0.00894126f, -0.03879071f, 0.01067834f, -0.02367360f, 0.02660002f, 0.00849140f, -0.01650850f, 0.00567442f, 
    0.02940378f, 0.02262885f, -0.03045249f, -0.03006723f, -0.00413008f, 0.01355609f, -0.02006682f, -0.04019443f, 
    0.00203166f, -0.03225708f, -0.00514638f, -0.01036645f, 0.02944241f, 0.00155870f, 0.02336755f, -0.03180919f, 
    -0.02956898f, 0.00212669f, -0.00203924f, 0.00142760f, 0.00198306f, 0.01729117f, -0.00347234f, -0.01333740f, 
    -0.02215489f, 0.00799716f, 0.01199000f, -0.01681437f, -0.00390238f, -0.00611466f, 0.01473335f, 0.00236689f, 
    -0.01792003f, 0.02053147f, -0.01670293f, 0.00293469f, 0.02453174f, -0.03401864f, -0.00496956f, -0.04040233f, 
    0.00078294f, 0.00518738f, -0.03530201f, -0.00578873f, -0.03521869f, 0.01404158f, 0.00494777f, 0.00800174f, 
    0.02625731f, -0.02321799f, -0.03521735f, -0.04058780f, -0.00144777f, -0.01815506f, -0.01473441f, 0.00117996f, 
    0.01713169f, -0.02102166f, -0.03965684f, -0.02541486f, -0.03121657f, -0.02548170f, 0.00247269f, -0.01616619f, 
    -0.03780798f, -0.00525573f, 0.02644898f, -0.02854295f, 0.01406132f, -0.02704675f, -0.01924295f, -0.00248336f, 
    -0.03663400f, 0.01081053f, -0.01665148f, 0.02815566f, -0.02070572f, -0.02193221f, -0.02881179f, -0.00637646f, 
    -0.00648014f, 0.02194194f, 0.00541117f, -0.03401403f, -0.02064906f, -0.00538840f, -0.01606142f, -0.00185430f, 
    0.02512598f, -0.01780200f, -0.00986389f, -0.00992387f, -0.01013014f, -0.01027275f, -0.01573662f, 0.02528216f, 
    0.00158007f, 0.01742403f, 0.00675177f, -0.00659302f, -0.00511948f, -0.03293877f, 0.01322874f, -0.02128779f, 
    -0.01087601f, 0.00891408f, -0.03367182f, 0.02445375f, -0.00413538f, 0.00635934f, 0.01244961f, 0.00206524f, 
    -0.03824781f, 0.01135426f, 0.00203563f, -0.01776441f, -0.00370786f, -0.02739843f, 0.00598413f, 0.00981683f, 
    -0.00912941f, 0.02948309f, 0.00140374f, 0.00508017f, -0.02251737f, 0.02119543f, -0.01546239f, -0.00198585f, 
    0.00539789f, 0.00087130f, -0.00989732f, -0.00033440f, 0.01962046f, -0.00818839f, -0.03771468f, -0.02075836f, 
    -0.01022703f, 0.00595902f, 0.02011227f, -0.03222648f, -0.02992796f, -0.03643720f, -0.02853277f, 0.02078882f, 
    -0.03137181f, -0.00568495f, -0.00136362f, -0.01199074f, -0.00719048f, -0.03802966f, 0.00323456f, 0.00599796f, 
    -0.04115285f, -0.01205062f, -0.02396550f, -0.00854146f, 0.00770502f, -0.03770943f, 0.01906673f, -0.02709137f, 
    0.01021402f, -0.02204329f, 0.00462831f, 0.01575052f, -0.00531387f, -0.02978809f, -0.01073379f, -0.03047988f, 
    0.00659158f, -0.00242136f, -0.01825131f, 0.02378001f, 0.02245387f, 0.02902478f, -0.03777616f, -0.03499792f, 
    0.01557125f, -0.00879345f, 0.01403084f, -0.01772673f, -0.02422969f, -0.00215873f, 0.00343940f, -0.02299639f, 
    -0.00587108f, -0.02858512f, -0.00750763f, -0.02553729f, -0.03593211f, -0.03487391f, -0.02358515f, 0.01374916f, 
    -0.02778098f, 0.01331912f, -0.00499467f, -0.01872535f, -0.04139064f, -0.00289003f, -0.01354898f, -0.01241167f, 
    -0.02465975f, -0.00863723f, 0.00731699f, 0.00785498f, 0.02495809f, 0.01526160f, 0.00555028f, -0.03760285f, 
    0.02380694f, 0.02747483f, 0.00183794f, 0.02424205f, -0.01127350f, -0.02750453f, -0.02661924f, 0.02131864f, 
    0.00352712f, -0.03863689f, -0.01164567f, -0.02624818f, -0.01105784f, 0.01116106f, -0.02450975f, -0.01731618f, 
    -0.04047317f, 0.00901786f, 0.00148112f, 0.01569505f, 0.00980411f, 0.01722218f, 0.00659870f, -0.02349908f, 
    -0.01146855f, -0.01608735f, -0.01790015f, -0.01514410f, -0.02464425f, -0.02792473f, -0.00559280f, -0.02198423f, 
    0.00491966f, 0.00810341f, 0.01184925f, -0.01242110f, -0.01664194f, 0.02889385f, -0.02486913f, 0.00509120f, 
    -0.01824930f, -0.03991746f, 0.01114155f, -0.02873632f, -0.03830211f, 0.01266561f, -0.03043559f, -0.02310288f, 
    0.02092779f, -0.02765863f, 0.00895008f, 0.00919370f, 0.02540099f, 0.02456958f, -0.02414455f, 0.00750884f, 
    0.00302346f, -0.00123884f, 0.01549184f, 0.02752482f, -0.00651009f, 0.02222736f, -0.01186335f, -0.02061729f, 
    0.01296057f, -0.02368032f, 0.01974577f, 0.01516600f, -0.03955267f, -0.01005018f, -0.03323118f, 0.02189085f, 
    -0.01940336f, 0.00610903f, 0.01336223f, 0.02878434f, -0.00740283f, -0.02851431f, 0.02977275f, -0.01669045f, 
    -0.03225720f, 0.01567764f, -0.01353502f, -0.02557135f, 0.00661443f, 0.01992519f, -0.03834716f, 0.00034819f, 
    0.00421403f, -0.02981311f, -0.00751874f, 0.01984515f, -0.03319008f, -0.00701845f, -0.03790298f, -0.01493731f, 
    0.00715953f, -0.02479860f, 0.02639963f, -0.02251825f, -0.03200313f, 0.00009145f, -0.04181749f, 0.01397371f, 
    -0.00125916f, -0.01731847f, -0.03310936f, 0.00579576f, -0.02841450f, -0.02369245f, 0.02594404f, -0.03431331f, 
    -0.01649668f, -0.01408687f, -0.00645273f, -0.03443855f, 0.01557944f, -0.02588625f, -0.02435501f, -0.00008380f, 
    -0.01575989f, -0.02886404f, 0.02377636f, 0.02796302f, 0.00809402f, -0.01502288f, 0.00778947f, 0.02769912f, 
    0.00611319f, 0.00687479f, 0.01927491f, -0.02114262f, -0.01972997f, -0.02999217f, 0.02671745f, -0.02755792f, 
    0.02291968f, -0.03915154f, 0.02494826f, 0.02720262f, -0.04119883f, -0.03132472f, -0.03667109f, -0.02911318f, 
    -0.01083444f, 0.02602001f, 0.01795451f, -0.01431212f, -0.02545534f, -0.02257532f, 0.00625789f, -0.01382793f, 
    0.02635660f, -0.02338817f, 0.00427038f, -0.01669030f, -0.03466263f, 0.01699244f, -0.01095692f, -0.01868548f, 
    0.00988510f, 0.00423570f, 0.02837967f, 0.01163639f, 0.02740936f, -0.02764754f, 0.02441120f, 0.02524969f, 
    0.00976416f, -0.03811039f, -0.03478611f, 0.00674924f, -0.00928195f, -0.00538121f, -0.02491315f, -0.03994815f, 
    -0.01415274f, -0.02595607f, -0.03297963f, -0.00449358f, -0.03353493f, 0.01461147f, 0.01470111f, 0.02930727f, 
    0.02147128f, -0.00261972f, 0.01925630f, -0.02883926f, 0.02702491f, -0.00658756f, -0.03988680f, -0.00647944f, 
    0.01341113f, 0.02828224f, 0.01873631f, -0.01233582f, -0.03591360f, -0.02773572f, 0.00988802f, -0.04065720f, 
    -0.00414412f, 0.01236663f, -0.02828048f, -0.02916843f, -0.04077202f, -0.03604447f, -0.02045113f, 0.02421018f, 
    -0.01973543f, 0.01827998f, -0.00142924f, 0.00515278f, -0.02745098f, -0.03244699f, -0.00428079f, -0.03571624f, 
    0.00302252f, -0.03452199f, -0.01401694f, 0.01982431f, 0.01067637f, -0.00169231f, -0.03792785f, -0.00771737f, 
    -0.01080674f, 0.00933290f, 0.02571959f, 0.01374394f, -0.01663465f, -0.02632283f, -0.00467151f, 0.00965696f, 
    -0.01440311f, -0.01555474f, -0.01985666f, 0.00528788f, -0.03810692f, 0.01137522f, -0.01445573f, -0.01356722f, 
    -0.02403687f, -0.02093314f, 0.01623789f, -0.00620399f, 0.02502400f, -0.02406261f, -0.00831341f, -0.00816306f, 
    0.00542257f, 0.01788651f, -0.04049104f, -0.02165040f, -0.01517258f, -0.02074956f, -0.02810650f, 0.00983407f, 
    0.00781116f, 0.02008480f, -0.01138204f, -0.00432409f, 0.00584817f, -0.02938147f, -0.02675308f, -0.03762427f, 
    0.02225320f, 0.02743745f, 0.02441300f, -0.01585238f, 0.01093007f, -0.02104502f, -0.02554607f, -0.03778279f, 
    0.00535181f, -0.02785091f, 0.01099873f, 0.01716962f, 0.00152584f, 0.00222923f, -0.03610810f, -0.03397064f, 
    -0.02547403f, 0.02173782f, 0.01921487f, 0.01509435f, -0.01849634f, 0.00215148f, -0.00463298f, 0.00405268f, 
    0.00212511f, -0.03282817f, -0.01352708f, -0.00001873f, 0.02697733f, -0.02419744f, -0.02078430f, 0.00073209f, 
    -0.01704736f, -0.02908347f, -0.00512186f, -0.01168428f, 0.00690179f, -0.03383926f, 0.00116063f, 0.01482871f, 
    0.02218896f, -0.03677109f, 0.01828230f, -0.02087070f, 0.02132288f, -0.01314177f, -0.02967426f, -0.00258145f, 
    -0.02942445f, -0.02718288f, 0.00575290f, -0.00038896f, -0.04117959f, -0.01140567f, 0.01687490f, 0.00871626f, 
    0.01142361f, -0.00628112f, 0.01106155f, -0.03187934f, 0.00312558f, -0.01601688f, -0.00839281f, 0.00152412f, 
    -0.02278900f, 0.01107308f, 0.02612706f, 0.01987118f, 0.01121619f, 0.02540365f, -0.02445163f, -0.00632970f, 
    0.02395741f, -0.04256880f, 0.00167334f, 0.01507710f, -0.03336050f, 0.00094455f, -0.01964048f, 0.02730276f, 
    -0.01796032f, 0.01431320f, 0.01167584f, -0.00308741f, 0.00612544f, -0.03667108f, 0.01572187f, -0.03299090f, 
    -0.01796760f, -0.02127715f, 0.02728922f, 0.02588833f, 0.01152623f, 0.02596273f, -0.02253301f, -0.00567728f, 
    0.02589947f, 0.01819570f, -0.00063266f, 0.00152404f, 0.00965094f, 0.02668936f, 0.01126801f, -0.01578926f, 
    -0.02887315f, -0.02558879f, -0.00782224f, 0.01393947f, -0.00656018f, 0.01072189f, -0.00198403f, -0.02989479f, 
    -0.01359263f, 0.02426228f, 0.02982479f, 0.01585867f, -0.01158183f, -0.00779949f, -0.02111699f, 0.02528696f, 
    -0.03111454f, 0.01463754f, -0.03922875f, -0.01202244f, -0.01803628f, 0.00946304f, -0.02151452f, -0.03551091f, 
    -0.02885968f, 0.01443392f, -0.00452876f, -0.01100446f, 0.03117593f, -0.00034194f, 0.02880140f, -0.03437179f, 
    0.00661983f, 0.00258865f, -0.02292124f, -0.00957512f, 0.04092221f, -0.01097619f, -0.02443011f, 0.00298494f, 
    -0.03370191f, -0.03189158f, -0.01721083f, 0.00016752f, -0.04276253f, -0.00733666f, 0.01201603f, -0.02544425f, 
    0.02935244f, 0.00181821f, -0.00615982f, -0.03405035f, 0.01639299f, -0.04216821f, -0.00548413f, -0.02709871f, 
    -0.01667677f, 0.01361645f, -0.04281816f, 0.03012685f, -0.01583391f, 0.00875777f, 0.02563826f, 0.01598202f, 
    -0.03505489f, -0.02825693f, -0.00829573f, 0.00843829f, 0.00584153f, 0.02551867f, -0.02518547f, -0.03235128f, 
    -0.02930268f, -0.03863007f, 0.00110523f, -0.02212654f, -0.03682645f, -0.00237280f, -0.02303035f, -0.01070850f, 
    0.00328089f, 0.02268908f, -0.01628376f, -0.03220126f, 0.03165168f, 0.02504719f, -0.01746434f, -0.00120385f, 
    -0.04187837f, -0.02272895f, 0.02734813f, -0.00111945f, -0.00758193f, 0.01579837f, 0.00976483f, -0.03909047f, 
    -0.01824930f, -0.03245062f, 0.00343451f, 0.02159223f, 0.02023368f, 0.01525838f, -0.00208357f, -0.03943058f, 
    -0.01469941f, -0.03635275f, -0.00529286f, 0.01860321f, 0.02424370f, 0.00657149f, -0.00721893f, 0.01581977f, 
    -0.03531646f, 0.00444372f, -0.00650628f, -0.02912615f, -0.01250417f, -0.01076232f, 0.01626446f, 0.02374247f, 
    -0.03074634f, 0.00988071f, 0.02775364f, 0.02256295f, -0.02858069f, -0.00279961f, -0.02158711f, -0.02013412f, 
    -0.02136694f, -0.02393551f, 0.00295610f, -0.03210180f, -0.01879671f, -0.01238003f, -0.02851488f, 0.02745357f, 
    -0.00741724f, -0.03329332f, 0.02521731f, -0.00267055f, 0.01827499f, 0.02328889f, -0.01511977f, -0.03186212f, 
    0.02384079f, 0.01037894f, 0.03068334f, -0.01741562f, 0.01242560f, 0.01282729f, 0.01695845f, -0.03834178f, 
    0.01177184f, -0.00512169f, 0.02827964f, 0.00920395f, 0.00432040f, -0.04327537f, -0.01819449f, -0.03262601f, 
    0.00085003f, -0.00088802f, -0.00356399f, 0.02511879f, -0.04298076f, -0.03461295f, 0.02572096f, 0.02512796f, 
    0.01688919f, -0.03146129f, -0.00530770f, 0.02327927f, 0.00555186f, -0.00616628f, -0.03277478f, 0.01474857f, 
    -0.01071923f, 0.01918956f, -0.02541290f, -0.03248867f, -0.00359852f, 0.01968745f, -0.02320660f, -0.00409143f, 
    -0.03772609f, 0.01061260f, -0.01136344f, -0.03809690f, -0.01747312f, -0.01292039f, 0.00179198f, -0.02554408f, 
    0.03364655f, -0.01249854f, 0.01314855f, -0.03470350f, -0.02197454f, -0.01500935f, -0.03207055f, -0.02442350f, 
    0.00538122f, 0.01472167f, 0.00262730f, -0.02027678f, -0.01450192f, 0.01236218f, -0.01951796f, 0.01944082f, 
    -0.03025727f, -0.03545871f, 0.01286357f, 0.02297737f, 0.02629844f, 0.01947999f, 0.02141876f, 0.01395354f, 
    -0.00595923f, 0.00945198f, 0.00941387f, 0.02298978f, -0.01102830f, 0.00855667f, -0.00129138f, 0.00745326f, 
    -0.02238993f, -0.03197534f, -0.02229715f, -0.00305755f, 0.03324553f, -0.01869417f, 0.01724954f, -0.01218664f, 
    0.01966950f, -0.03690495f, 0.01554893f, -0.01158794f, 0.01412081f, -0.02243707f, -0.03214490f, 0.01696659f, 
    0.02646921f, -0.01432229f, -0.02993093f, 0.00960600f, -0.03622001f, 0.00243561f, -0.01368837f, 0.01543718f, 
    0.00898313f, 0.00305733f, -0.02481128f, -0.00847167f, 0.00784904f, -0.00874075f, 0.00107838f, 0.01897331f, 
    0.02212678f, -0.03689501f, 0.00231908f, 0.01336661f, 0.00589836f, 0.00566659f, -0.04355462f, -0.00081445f, 
    -0.00339138f, -0.00838670f, 0.03162446f, 0.00900442f, 0.00873456f, -0.03782029f, -0.02522067f, 0.02148630f, 
    -0.00052316f, 0.03585369f, -0.02682323f, -0.00303553f, -0.03980754f, 0.03140178f, -0.03556234f, 0.01960271f, 
    0.02074701f, 0.01566145f, 0.02101081f, -0.03023607f, 0.00842763f, 0.01412543f, -0.03848050f, 0.00958115f, 
    0.00288215f, -0.01032333f, -0.01433535f, -0.00494618f, -0.01502686f, 0.01759292f, 0.01907027f, -0.00715202f, 
    0.01497040f, -0.00710669f, 0.00099964f, 0.00699222f, 0.00093771f, 0.00947763f, 0.00339886f, 0.02415819f, 
    -0.02213524f, -0.00000435f, -0.00057934f, -0.00570064f, -0.00812049f, -0.02950289f, 0.01636948f, 0.00788830f, 
    -0.00734774f, 0.00740193f, -0.00591502f, 0.02295763f, 0.00400081f, 0.03363850f, -0.02983277f, -0.00195753f, 
    -0.03068486f, 0.00541515f, -0.03117413f, -0.00323834f, -0.03445607f, -0.01838199f, 0.00290375f, -0.02423126f, 
    -0.02363098f, -0.03146344f, -0.03435171f, -0.02937415f, -0.04309957f, 0.02046145f, 0.02670070f, 0.01545965f, 
    0.00057384f, 0.01878777f, 0.01284602f, -0.03621244f, -0.01436287f, -0.03238305f, -0.00422813f, 0.01581101f, 
    0.02849636f, 0.00751194f, 0.01569370f, -0.04295974f, 0.01129529f, 0.02535930f, -0.02116815f, 0.02793875f, 
    -0.02738633f, -0.01232935f, 0.02102196f, 0.00621696f, -0.04194072f, -0.03005154f, 0.03035359f, -0.02758176f, 
    -0.00199044f, -0.02246292f, 0.02499631f, -0.00674524f, 0.02683840f, -0.01202824f, 0.01708202f, -0.00551861f, 
    -0.00443130f, 0.01154193f, 0.00360119f, -0.03918961f, 0.02701390f, 0.01869839f, 0.00707421f, 0.00808980f, 
    -0.02049559f, 0.01193623f, -0.00011531f, -0.03487462f, -0.03416082f, 0.00518899f, -0.03536704f, -0.02607141f, 
    -0.04288567f, 0.00661220f, -0.02144201f, -0.00419462f, -0.01570405f, -0.01966522f, -0.00954377f, -0.02930841f, 
    0.01031287f, -0.03326356f, 0.02250982f, -0.01974881f, 0.00837225f, 0.02494803f, -0.00807090f, -0.03839019f, 
    -0.00674066f, -0.00832264f, -0.01592330f, -0.02920803f, 0.01543534f, 0.02073997f, -0.01103822f, 0.03307728f, 
    0.00658816f, 0.01017133f, 0.01088556f, -0.02748691f, 0.00443470f, 0.02399283f, -0.02331498f, -0.00120634f, 
    -0.01784874f, 0.00507027f, -0.02597991f, -0.02899509f, -0.03088343f, 0.02530177f, -0.00948439f, -0.01540818f, 
    -0.01486488f, 0.02546043f, -0.02210959f, 0.00850500f, -0.01867503f, -0.00470932f, -0.01153328f, 0.01223169f, 
    -0.03787113f, -0.00340803f, -0.04202056f, 0.01309188f, -0.00978638f, 0.01392910f, -0.03397993f, 0.01374034f, 
    -0.02494717f, 0.02568665f, 0.02615003f, 0.01340289f, -0.02095837f, -0.00537213f, -0.00623844f, -0.02961808f, 
    0.00988861f, 0.02642343f, -0.02689393f, -0.02969263f, -0.00192476f, -0.04023779f, 0.01047895f, -0.03073402f, 
    -0.00530190f, -0.00408652f, -0.00178402f, 0.01996342f, -0.03373489f, -0.02236717f, -0.02284701f, 0.00008302f, 
    0.02266058f, 0.00153799f, -0.01616804f, -0.01987717f, 0.00105839f, -0.03561661f, 0.01317294f, -0.03902688f, 
    -0.03525382f, 0.03784328f, -0.00830460f, -0.00238794f, -0.03446184f, -0.03868212f, -0.01284833f, 0.03241200f, 
    0.00118483f, -0.01873561f, -0.01915586f, -0.01584512f, -0.01764394f, 0.03224275f, 0.01299687f, 0.02915514f, 
    0.03567897f, 0.02627774f, -0.00016798f, -0.00931356f, -0.02929931f, -0.02850130f, -0.01302152f, -0.02383868f, 
    -0.00765595f, 0.01246930f, -0.02051011f, -0.00537536f, -0.00151806f, -0.00991421f, 0.00984324f, -0.00534129f, 
    0.01454693f, 0.01800085f, -0.00486318f, -0.01246827f, -0.00823728f, 0.01722001f, 0.03262565f, -0.02507938f, 
    0.01617822f, 0.00096642f, 0.02318965f, -0.02827154f, -0.02190635f, 0.00392862f, -0.02981480f, -0.04056752f, 
    0.01579802f, 0.01850041f, -0.00711759f, -0.02735031f, 0.02035691f, -0.00067212f, 0.00079886f, -0.00565747f, 
    -0.04070168f, 0.02603610f, 0.00057096f, 0.00364260f, 0.01104952f, -0.00924665f, 0.01411911f, -0.01925042f, 
    0.01318400f, -0.01054261f, -0.01993205f, 0.00427228f, -0.00432595f, 0.00409571f, 0.02555429f, -0.00245285f, 
    0.02213504f, -0.02273506f, 0.00634826f, 0.01234404f, -0.01944574f, 0.01209271f, -0.04127439f, 0.00479739f, 
    0.01595309f, 0.02759797f, -0.01603417f, 0.03415680f, 0.02033842f, -0.03782822f, -0.00666258f, 0.01110066f, 
    -0.01367983f, 0.03196422f, 0.01432180f, -0.02779377f, -0.02293276f, 0.00979230f, -0.02778148f, -0.02785883f, 
    -0.02183855f, -0.01242614f, 0.00371603f, -0.02517755f, -0.01689432f, -0.02139780f, -0.01863439f, -0.03857572f, 
    -0.01930717f, -0.03466664f, -0.01088161f, 0.02334468f, 0.02398128f, -0.01748435f, -0.00811153f, 0.00772461f, 
    -0.03025425f, -0.01299611f, -0.03706591f, 0.02128948f, 0.02535402f, 0.00744010f, -0.01196511f, -0.01392145f, 
    0.01951756f, 0.00735584f, -0.01984411f, 0.01524571f, -0.00551003f, -0.03264073f, 0.00069949f, 0.00040606f, 
    -0.00618306f, 0.02496968f, -0.00383736f, -0.03071863f, 0.03319935f, 0.00442417f, -0.00462730f, 0.02343808f, 
    -0.03131857f, 0.01677648f, 0.02459334f, 0.03033994f, -0.01253910f, -0.00146290f, -0.02832480f, -0.00268856f, 
    0.02136730f, -0.03320055f, 0.00256685f, -0.00187169f, 0.00750994f, -0.02549093f, -0.00424264f, 0.00340164f, 
    -0.03987032f, 0.01322408f, 0.02615825f, -0.01432264f, -0.00493541f, 0.01324051f, 0.03028409f, -0.00467037f, 
    0.01157117f, -0.00791608f, 0.02079501f, -0.02160049f, -0.02985148f, -0.03915272f, -0.02760939f, 0.02022491f, 
    0.00570654f, 0.00319892f, -0.03245518f, -0.00809709f, 0.00274132f, 0.01829331f, -0.00552047f, -0.04267746f, 
    -0.03072352f, 0.00266166f, -0.00778963f, 0.02306525f, 0.00844654f, 0.00407158f, -0.02740601f, -0.02838983f, 
    0.01963846f, -0.01016399f, -0.03967443f, -0.01418665f, -0.03486540f, 0.00985063f, 0.03454954f, -0.00263744f, 
    0.00343553f, 0.01767428f, 0.01154853f, -0.04175126f, -0.00363237f, -0.00251652f, -0.00435392f, 0.00103704f, 
    -0.00850682f, -0.00413345f, -0.04039490f, -0.00839514f, 0.01970617f, -0.01729436f, 0.01114388f, -0.04128067f, 
    -0.03099796f, 0.00334552f, -0.03871222f, -0.03382030f, 0.02609979f, -0.03812169f, 0.01028190f, 0.02259005f, 
    -0.02719803f, -0.00476919f, -0.02769949f, -0.00030960f, -0.02389073f, -0.03057316f, 0.02447895f, -0.03534333f, 
    0.02025352f, 0.02703805f, -0.02789846f, 0.00613484f, 0.00547151f, 0.00859219f, -0.03112550f, 0.00601376f, 
    -0.00842647f, -0.03090214f, -0.00265271f, 0.02510094f, -0.00386637f, -0.00413248f, 0.00347458f, -0.01126803f, 
    0.00063832f, 0.01175074f, 0.00241419f, 0.00496032f, 0.01235937f, -0.04171170f, 0.01828277f, -0.03491977f, 
    0.20462202f, -0.03936161f, 0.09768059f, 0.12453597f, -0.09946778f, -0.02886390f, -0.05109306f, 0.09915986f, 
    0.00152042f, -0.06877984f, 0.03961368f, 0.03050455f, -0.07612215f, -0.04145838f, 0.08069941f, 0.16733316f, 
    -0.01173553f, -0.02264517f, -0.06707085f, -0.02017589f, -0.09003557f, 0.00398721f, -0.01249223f, -0.03503380f, 
    0.06347951f, 0.23454015f, -0.04690024f, 0.11208101f, -0.12930344f, 0.02281711f, 0.04482486f, -0.00735231f, 
    0.08592077f, 0.00994102f, 0.11359762f, 0.06460997f, 0.08657158f, -0.01003210f, 0.02806702f, 0.05943561f, 
    -0.01085754f, -0.12084156f, 0.13104808f, 0.07217373f, 0.13376309f, 0.06551930f, 0.02275344f, 0.04483006f, 
    -0.17414834f, 0.04156726f, -0.03211268f, -0.04962635f, -0.06941857f, -0.01828410f, 0.01057897f, 0.06335646f, 
    -0.01147594f, 0.11586718f, 0.06878250f, 0.09640551f, -0.01046291f, -0.10343385f, -0.00819569f, 0.03782279f, 
    -0.12320893f, 0.08842706f, 0.07681625f, -0.00248577f, 0.06050248f, -0.10575619f, 0.02759871f, 0.00778989f, 
    0.31112751f, -0.04976667f, 0.11622930f, 0.32021728f, -0.06639809f, 0.07758057f, 0.10043977f, -0.01032692f, 
    0.05230561f, -0.07853916f, 0.12559593f, 0.11361431f, 0.25562656f, -0.05186643f, 0.05630003f, 0.21047872f, 
    0.04121274f, 0.02059068f, -0.00333052f, 0.08719924f, -0.02610508f, 0.03818543f, 0.01031971f, 0.10596686f, 
    0.04792846f, 0.06345796f, 0.21501714f, 0.28210384f, 0.03737595f, 0.07094759f, 0.05294491f, 0.02152740f, 
    -0.07697378f, -0.05129913f, 0.04785858f, 0.01288218f, 0.02038480f, 0.06339644f, -0.04219393f, 0.12919830f, 
    -0.03088539f, 0.07455083f, 0.01617515f, 0.06114270f, 0.02819783f, -0.09163840f, 0.13325219f, 0.12330569f, 
    -0.04108832f, -0.01104317f, 0.01036807f, 0.03598979f, -0.15316577f, -0.03324918f, 0.05764301f, 0.09539963f, 
    0.00734734f, -0.00377755f, 0.04449201f, -0.01303408f, -0.12060224f, -0.03745191f, 0.12409856f, 0.06827667f, 
    -0.05887692f, -0.02547741f, 0.01962084f, 0.00035950f, -0.05651446f, -0.02158446f, 0.02857717f, -0.09841371f, 
    0.34798551f, 0.13928261f, 0.07424857f, -0.17343999f, 0.14943556f, -0.00817592f, 0.01314835f, 0.04139964f, 
    -0.00778421f, -0.02076226f, -0.00700391f, -0.02203855f, 0.07481593f, 0.05391100f, 0.06405581f, 0.26739570f, 
    0.11399172f, 0.06079059f, 0.01908069f, 0.06103422f, 0.07987492f, 0.00256406f, -0.06854089f, -0.01118371f, 
    -0.06752417f, 0.10691902f, 0.05880766f, -0.06676614f, -0.02934990f, 0.00411250f, 0.03297207f, -0.04652108f, 
    -0.00476547f, 0.00614439f, 0.17404528f, -0.00868836f, -0.10367672f, 0.21276133f, 0.08548409f, -0.17768897f, 
    -0.09085689f, 0.04090678f, 0.01844219f, 0.11742493f, -0.04909060f, 0.06291454f, 0.09846088f, -0.17123973f, 
    -0.14885321f, -0.27045429f, 0.02960847f, 0.26512060f, -0.01784299f, -0.04616599f, -0.06648380f, 0.03428596f, 
    0.01161982f, 0.09385923f, -0.01124664f, 0.00810028f, -0.11352307f, 0.09874199f, -0.02366439f, -0.00083193f, 
    -0.03786327f, -0.01831865f, 0.01631762f, -0.01087634f, 0.09532464f, 0.04341875f, 0.05652419f, 0.09646711f, 
    0.12198973f, 0.05626513f, -0.06160678f, -0.06779273f, 0.00730585f, 0.00237826f, -0.01213959f, -0.13547155f, 
    0.06921038f, 0.09906563f, -0.07115674f, 0.13715853f, -0.27735817f, 0.12862508f, -0.12845521f, -0.17399912f, 
    0.07689005f, 0.02790674f, 0.07291538f, 0.07400417f, 0.07703581f, 0.10965404f, 0.07919571f, 0.05546882f, 
    -0.30340272f, 0.13895825f, 0.19984268f, -0.02427104f, 0.06953749f, 0.05034120f, 0.04180730f, -0.02130056f, 
    -0.02718155f, -0.00627472f, -0.00375472f, 0.00573703f, 0.23717828f, -0.06898208f, -0.09820137f, 0.10681680f, 
    0.06405863f, -0.01806459f, -0.02043285f, -0.03609086f, 0.04701737f, -0.00635083f, 0.04440765f, 0.14706217f, 
    -0.14921413f, 0.14309013f, -0.07491531f, 0.25081697f, 0.04055259f, -0.05557521f, 0.08009960f, -0.01233206f, 
    0.07149974f, 0.00159297f, 0.04247390f, 0.03935318f, -0.40282607f, 0.04520470f, 0.30440751f, 0.04449435f, 
    -0.04632690f, -0.03774157f, 0.06074003f, 0.00861328f, 0.02657122f, 0.01461132f, -0.00185592f, -0.02211927f, 
    -0.15040490f, 0.06687240f, 0.11673001f, 0.11374110f, -0.05831456f, 0.02612522f, 0.03429870f, 0.09767898f, 
    -0.06522511f, 0.12661444f, 0.10686408f, 0.06393478f, -0.09636953f, -0.12606221f, 0.13498293f, 0.01564756f, 
    -0.09475958f, 0.03130608f, 0.00657856f, 0.08541981f, 0.00320616f, 0.01559435f, 0.07884476f, 0.11891993f, 
    -0.31043115f, 0.04554505f, 0.16115838f, 0.01416877f, -0.14944884f, -0.00449892f, -0.03078398f, 0.03016052f, 
    0.05166490f, -0.02437404f, -0.11573679f, -0.07935131f, 0.08823864f, 0.19293445f, 0.18976393f, 0.04718124f, 
    -0.01562452f, 0.10007304f, 0.09259346f, 0.06404878f, -0.02540987f, 0.04960862f, 0.06914021f, -0.01320242f, 
    -0.24095064f, 0.10635793f, 0.17275378f, 0.28254315f, 0.13391243f, -0.04458341f, 0.07659931f, -0.02236076f, 
    0.10880492f, -0.02302960f, 0.05504055f, 0.00011094f, 0.08213103f, -0.15374631f, 0.07635020f, 0.16015345f, 
    -0.07092351f, 0.00146335f, -0.00666924f, 0.00195097f, -0.00549699f, 0.02936567f, -0.04474573f, 0.04827856f, 
    0.06413770f, 0.02600355f, -0.02685821f, -0.09479136f, 0.15150647f, 0.14822125f, 0.10831541f, 0.01152522f, 
    -0.00759754f, -0.00515570f, 0.06847766f, 0.06166176f, 0.15838078f, 0.03291902f, 0.10314687f, 0.09953874f, 
    -0.02030643f, 0.02173607f, 0.02538102f, 0.03210666f, -0.01831258f, 0.04054699f, 0.18350707f, 0.04420386f, 
    -0.16898131f, -0.12954281f, 0.28690881f, -0.04160064f, -0.12893294f, -0.03074985f, 0.01243422f, 0.06176886f, 
    0.03374009f, 0.02266825f, 0.08185156f, 0.03591379f, -0.12392129f, 0.05644909f, -0.18142630f, -0.06930590f, 
    0.04052917f, -0.00774193f, 0.00335117f, 0.00982459f, 0.09787588f, 0.06067150f, 0.06490243f, -0.04335440f, 
    0.16516626f, -0.01092224f, 0.06412844f, 0.04509809f, -0.04250577f, 0.03519343f, 0.06379944f, -0.03832757f, 
    0.08453028f, 0.06385486f, 0.10726005f, 0.02979484f, -0.02748584f, -0.08303302f, 0.00417417f, -0.05439688f, 
    -0.02240588f, -0.01970171f, 0.03653292f, -0.02746476f, 0.18529014f, 0.03766953f, 0.06849357f, -0.03157270f, 
    0.10600525f, -0.22688474f, 0.03162309f, -0.01118315f, -0.02595821f, 0.09778916f, 0.05439096f, -0.12400659f, 
    0.03369534f, -0.03332335f, -0.03584273f, 0.09045684f, 0.15163952f, -0.01556489f, -0.08399850f, 0.01942152f, 
    -0.01260742f, 0.04732747f, 0.14084448f, 0.01846002f, 0.05349644f, -0.01083815f, -0.04381839f, 0.09553959f, 
    0.11071882f, 0.03774094f, -0.28264409f, -0.13137496f, -0.02177007f, 0.08253718f, 0.02710724f, -0.12671502f, 
    -0.02110783f, 0.05625952f, 0.00684763f, 0.09946639f, -0.47665289f, -0.14558728f, -0.10720729f, 0.03160531f, 
    0.05716898f, -0.01632294f, 0.06089868f, 0.01049185f, 0.08501452f, -0.03612807f, -0.04956805f, -0.01290832f, 
    -0.08017340f, 0.04220474f, 0.04467669f, 0.12170743f, -0.08098149f, 0.00732006f, -0.00631939f, 0.05013511f, 
    -0.04594309f, -0.11221243f, -0.05711827f, 0.00868329f, 0.24509855f, -0.06500503f, 0.15702626f, 0.30302581f, 
    0.06295658f, 0.03968618f, -0.04625628f, -0.02017462f, -0.06120738f, -0.01588726f, 0.07004058f, 0.15551822f, 
    0.15294924f, -0.06973451f, 0.03062030f, 0.04118326f, -0.04957344f, 0.03970123f, -0.01836156f, 0.00112262f, 
    -0.05846700f, 0.00679773f, -0.00541902f, -0.01666214f, -0.09547002f, 0.09886680f, 0.07528762f, 0.00810640f, 
    -0.05634851f, -0.07430577f, 0.01409411f, -0.03210806f, -0.02706977f, 0.11823461f, 0.01054801f, 0.13455984f, 
    -0.16966365f, 0.09222279f, -0.05459680f, 0.06741344f, 0.11420777f, 0.04030266f, 0.04032065f, 0.07549296f, 
    -0.04674139f, 0.09190983f, 0.07592539f, 0.07555170f, -0.11128476f, 0.03609012f, -0.14705080f, 0.14267731f, 
    -0.02180788f, -0.06570486f, -0.00300253f, 0.04568847f, -0.07201890f, 0.14825563f, 0.09656929f, 0.01972681f, 
    -0.26232183f, -0.29666427f, -0.08805316f, 0.10722462f, -0.08168925f, 0.10202999f, 0.01754639f, 0.04438963f, 
    0.12068135f, -0.06625386f, -0.03685113f, -0.02258571f, 0.22741087f, -0.23319148f, 0.01398044f, -0.21063292f, 
    -0.01214452f, -0.03233937f, -0.07870674f, -0.19798116f, -0.10920662f, -0.04939230f, 0.00644131f, -0.06838486f, 
    0.22239727f, -0.01955902f, -0.16946918f, -0.16263412f, -0.02322471f, 0.12956379f, 0.18211831f, -0.09762497f, 
    -0.02395361f, 0.07036150f, -0.02658145f, -0.07522207f, -0.06812649f, 0.29220068f, 0.23133478f, 0.12424419f, 
    0.08674568f, 0.12030514f, 0.03446444f, 0.08982475f, 0.01855456f, 0.07235288f, -0.02097876f, -0.07311941f, 
    -0.11407252f, 0.04219609f, -0.00240227f, 0.01525321f, 0.09126373f, -0.04069057f, 0.02457642f, -0.05240452f, 
    0.00916189f, -0.09541606f, -0.03785880f, 0.02416240f, -0.22541372f, 0.10805923f, -0.09617435f, -0.20427680f, 
    0.14625302f, 0.03222739f, -0.01911323f, -0.07676365f, 0.06952974f, 0.06455591f, -0.08297098f, 0.12556840f, 
    -0.29332924f, 0.08195099f, 0.04092373f, 0.04078215f, -0.04526703f, -0.02580705f, 0.00532452f, 0.04079142f, 
    0.03159392f, -0.07388118f, -0.03592962f, -0.09812963f, -0.01661160f, 0.20209996f, -0.16375850f, -0.05772797f, 
    0.17240608f, 0.02618541f, -0.00031312f, 0.05893694f, 0.06177955f, 0.05808018f, 0.08222901f, -0.01550014f, 
    -0.04915838f, 0.11467764f, -0.08607478f, -0.05176237f, -0.07939202f, 0.08606216f, 0.13425067f, 0.00822400f, 
    0.02818223f, 0.01492742f, -0.04513968f, 0.08351789f, 0.14871281f, -0.10872417f, 0.10310004f, 0.25279838f, 
    -0.04075179f, 0.05316274f, 0.00975587f, 0.05591116f, 0.01195699f, 0.03655396f, -0.03565797f, 0.11501016f, 
    -0.03442701f, -0.05169645f, -0.23434204f, 0.05502770f, -0.01937018f, -0.09146480f, 0.03424538f, -0.02831757f, 
    0.10022306f, 0.12148810f, 0.05572201f, -0.00063692f, 0.29941705f, 0.00386268f, -0.04726377f, 0.40748748f, 
    0.05949220f, 0.01900484f, -0.04026008f, -0.03260447f, -0.00771864f, -0.00739375f, -0.01030030f, 0.10629726f, 
    -0.33244175f, 0.06804934f, -0.05567777f, 0.00920703f, 0.07986184f, -0.08450421f, 0.00096113f, 0.13426279f, 
    0.00122627f, 0.03980166f, -0.01340038f, 0.06145194f, 0.06797163f, -0.08487494f, 0.05680592f, -0.16400187f, 
    -0.05132547f, -0.00339137f, -0.03959093f, 0.07255347f, 0.02982508f, 0.00698564f, 0.05365097f, 0.01912734f, 
    -0.10186189f, 0.04577380f, -0.09914120f, 0.00544822f, 0.12087280f, 0.15140857f, 0.02599220f, 0.09917425f, 
    0.01703184f, 0.02355846f, 0.07019936f, -0.06063838f, -0.14251199f, -0.05498419f, 0.01906455f, -0.06092896f, 
    -0.00948360f, -0.06880121f, -0.02059386f, 0.08650839f, 0.03506257f, 0.03115268f, -0.04896333f, 0.16707051f, 
    0.36824134f, 0.15540448f, 0.09498053f, 0.14929511f, 0.11277809f, -0.06663593f, 0.03143588f, 0.05527101f, 
    -0.11616112f, 0.07076968f, -0.02915341f, -0.05145857f, -0.06487258f, 0.25624552f, -0.06594326f, 0.03538683f, 
    0.11704580f, 0.12704098f, 0.02268223f, 0.07583124f, 0.01095232f, -0.10561340f, 0.03834850f, 0.05256207f, 
    0.12542079f, 0.00793411f, 0.05450047f, 0.12474710f, -0.08242697f, 0.00619281f, -0.03417466f, 0.09276808f, 
    0.04003675f, -0.04107553f, 0.06225562f, 0.09237637f, -0.55468810f, 0.04040303f, -0.14053249f, 0.12854901f, 
    0.05010165f, -0.05573149f, 0.03917650f, 0.00833118f, -0.02546990f, -0.00709445f, -0.01793853f, -0.08154799f, 
    0.02162323f, 0.15188505f, -0.11962417f, -0.05797330f, 0.01810286f, 0.03378813f, 0.02541746f, -0.11056141f, 
    -0.00763935f, 0.10568950f, 0.03357743f, 0.01018646f, 0.05311020f, -0.14023048f, 0.05557299f, 0.27239484f, 
    -0.03194776f, -0.08599412f, 0.00849419f, 0.10586822f, 0.03856131f, 0.03417008f, -0.01024675f, 0.15446499f, 
    -0.25614727f, -0.03972808f, 0.05567654f, 0.01309747f, 0.09213510f, -0.00689565f, 0.07039315f, -0.07218879f, 
    -0.00184629f, 0.00793398f, 0.04389487f, -0.04439380f, -0.13332793f, 0.02109942f, -0.00544854f, 0.05719655f, 
    0.00979111f, -0.04889578f, 0.07165540f, -0.02240478f, 0.08518627f, -0.00270730f, -0.00193786f, 0.07148835f, 
    -0.02015463f, 0.12355485f, 0.12717693f, 0.04357347f, -0.10074640f, 0.00851278f, 0.10580019f, -0.11819325f, 
    -0.01594267f, -0.10703311f, 0.00638429f, 0.03861453f, 0.04184501f, -0.09570191f, 0.15638526f, 0.16880165f, 
    -0.11723252f, 0.00815070f, 0.06178425f, 0.01318667f, 0.05991653f, -0.00600884f, 0.01992929f, 0.11074760f, 
    -0.05927820f, -0.04914469f, 0.02971455f, 0.10786109f, 0.03669936f, 0.04512434f, -0.02920937f, -0.00710733f, 
    -0.01394513f, -0.07484242f, 0.04937560f, 0.07360635f, -0.11656141f, 0.06561479f, -0.02576557f, 0.13806526f, 
    0.11411982f, 0.15120685f, -0.12319934f, 0.00011229f, 0.12307089f, 0.00363086f, 0.01414007f, -0.02630609f, 
    -0.03106472f, -0.13052703f, 0.13201086f, 0.10170866f, 0.03467382f, 0.06490536f, 0.02627021f, 0.04149551f, 
    0.00957578f, 0.07321279f, -0.02592273f, 0.05485572f, 0.28416997f, -0.00664425f, -0.01520630f, 0.09116369f, 
    -0.01096363f, 0.09726553f, 0.06656144f, 0.02249831f, -0.00682375f, -0.01308275f, 0.07938935f, -0.00032853f, 
    -0.08012807f, 0.15921138f, 0.20491834f, -0.09326645f, -0.00822544f, -0.11007881f, 0.01161547f, 0.01152102f, 
    0.01053022f, 0.04720814f, 0.00608344f, -0.02087842f, 0.12440989f, -0.09840352f, 0.01523454f, 0.12668733f, 
    -0.07401830f, -0.00378442f, 0.06054573f, 0.08013233f, 0.08516002f, -0.03453064f, -0.04502894f, -0.09414119f, 
    0.12149578f, -0.02438894f, 0.04394927f, 0.04005928f, 0.02572863f, 0.03543987f, 0.08409387f, -0.03212905f, 
    -0.04356726f, 0.04850679f, 0.09091904f, -0.00978401f, -0.27276734f, 0.02874813f, 0.06077655f, -0.06780992f, 
    0.01457317f, 0.08720876f, 0.07815640f, 0.09299557f, -0.03570465f, -0.10454839f, -0.04301295f, -0.17589830f, 
    0.37614083f, -0.02468995f, 0.11194239f, 0.04587129f, -0.07809149f, -0.14835623f, -0.04045041f, 0.02703777f, 
    0.02504546f, -0.04490970f, -0.08943425f, -0.08073652f, -0.07629655f, 0.02721926f, 0.06836915f, -0.00390399f, 
    0.07577317f, 0.04337623f, -0.02156540f, 0.07052965f, -0.00044974f, 0.07487316f, 0.00678788f, 0.05226370f, 
    0.16648269f, -0.03744592f, -0.03506992f, -0.01574287f, 0.04960057f, 0.00485352f, -0.05948772f, -0.03853666f, 
    0.01060379f, -0.00801785f, -0.03776846f, -0.00825450f, -0.23133899f, 0.08109856f, 0.05621307f, -0.20569278f, 
    0.14812130f, -0.02053043f, -0.07775036f, -0.05000269f, 0.09325057f, -0.01266575f, 0.16406554f, 0.05525965f, 
    -0.41601476f, 0.19984533f, 0.04875554f, -0.06959110f, 0.15230042f, 0.00519227f, 0.07952212f, 0.01862261f, 
    -0.04449784f, 0.03894218f, 0.09875593f, 0.08289543f, 0.01853386f, 0.07410397f, 0.03412543f, 0.04694448f, 
    0.12447844f, 0.02481371f, -0.08279254f, 0.06773113f, 0.03512223f, 0.00388887f, 0.00745680f, 0.02537094f, 
    -0.04046477f, 0.13120490f, -0.01420543f, -0.01660342f, 0.04099051f, -0.00646882f, 0.05149264f, 0.02007801f, 
    -0.00107885f, -0.06060100f, -0.02452334f, 0.05533209f, 0.18266611f, 0.07495556f, 0.02956173f, 0.16407776f, 
    -0.05403753f, 0.03757311f, 0.01806018f, -0.03842567f, -0.05793699f, -0.14347920f, 0.11098094f, -0.01689086f, 
    0.38621220f, 0.15841462f, 0.02993882f, 0.14804247f, 0.02137082f, 0.03801025f, 0.06820349f, 0.04038751f, 
    -0.08985452f, 0.06312437f, 0.06627804f, -0.03068516f, 0.20046255f, -0.02370094f, 0.02053636f, 0.15019239f, 
    0.07311387f, 0.00267020f, 0.06308253f, 0.10603710f, 0.05208169f, 0.00535200f, 0.03366004f, 0.00008250f, 
    0.08507298f, -0.07981919f, -0.02236879f, 0.09003459f, -0.11016943f, 0.03786052f, 0.07214363f, 0.02449963f, 
    0.03292465f, 0.04600949f, 0.04157285f, -0.07295839f, -0.08986760f, -0.08224184f, 0.12067383f, 0.07479960f, 
    -0.04647716f, 0.10553023f, 0.04759357f, 0.01808988f, 0.10740247f, -0.01505781f, 0.01483450f, -0.01659579f, 
    -0.31991342f, -0.14403099f, 0.12901038f, -0.08234465f, -0.10966181f, 0.05168252f, -0.06734774f, -0.03272353f, 
    0.05779996f, 0.07977493f, -0.00787300f, 0.03496985f, 0.25222787f, 0.08164461f, -0.06029170f, -0.02270719f, 
    -0.06877010f, 0.02891124f, -0.09628832f, 0.02603479f, 0.01680017f, -0.11078116f, -0.03953840f, 0.03333592f, 
    -0.18994868f, 0.00017017f, -0.04274354f, 0.02286064f, 0.10854150f, 0.05375881f, -0.01678571f, 0.02165241f, 
    0.10012762f, -0.01063395f, -0.03385194f, 0.01715552f, -0.06736969f, 0.02734678f, -0.01679766f, 0.22681606f, 
    -0.07011134f, 0.09496361f, 0.00869554f, 0.01152392f, 0.06815845f, -0.02203308f, 0.23718524f, 0.14433135f, 
    0.17262997f, -0.07614410f, -0.01401509f, 0.15092236f, -0.04347434f, 0.02742680f, 0.01556494f, 0.07905927f, 
    -0.03110398f, -0.00789078f, 0.06603771f, 0.06030270f, -0.35626352f, 0.01182332f, -0.08972605f, -0.02934283f, 
    0.13154264f, 0.11901979f, -0.10945354f, 0.06502693f, 0.14754964f, 0.05638181f, 0.01283426f, -0.05777573f, 
    0.12922341f, -0.00485341f, -0.03145036f, 0.02627865f, 0.04057031f, -0.01527545f, 0.04701642f, -0.08328366f, 
    0.17958108f, 0.01419578f, 0.07776999f, 0.00199673f, -0.15759419f, -0.06918491f, -0.08680265f, 0.03952542f, 
    0.11452971f, -0.01121475f, 0.02713452f, -0.02223819f, 0.11776599f, -0.04213303f, 0.11001849f, 0.06683557f, 
    0.03995164f, -0.00700031f, 0.09314518f, -0.04103150f, 0.10064669f, 0.08331837f, -0.01300050f, -0.05586328f, 
    0.04857422f, 0.00773607f, 0.02011343f, 0.03237830f, -0.11367235f, -0.13923150f, -0.08578430f, 0.10137851f, 
    -0.00661700f, 0.12231366f, 0.07860520f, 0.06737045f, 0.09899411f, 0.00680741f, -0.03765322f, 0.04818772f, 
    -0.17295142f, -0.02636413f, -0.14905576f, 0.00165272f, 0.12163273f, -0.03298628f, -0.06877457f, -0.08436793f, 
    -0.02414138f, 0.05632415f, 0.03536003f, -0.01223618f, 0.52300304f, -0.05509297f, -0.04928249f, -0.20221305f, 
    -0.05268193f, -0.05544811f, -0.01571175f, 0.00442851f, 0.09937432f, -0.05256034f, 0.03847264f, -0.05042834f, 
    0.00708673f, 0.09817775f, -0.01957666f, 0.02275954f, 0.03710547f, -0.02991359f, 0.01286628f, 0.01956780f, 
    0.03617087f, -0.00485372f, -0.03539369f, 0.07427814f, 0.07424278f, 0.08611722f, 0.20290586f, 0.25115731f, 
    -0.03691722f, -0.06089509f, 0.04215257f, -0.01040946f, 0.04077309f, 0.07114270f, -0.01807421f, 0.04026061f, 
    -0.12155414f, -0.06576597f, 0.02665908f, 0.17670377f, 0.02863958f, 0.04395338f, 0.01678196f, 0.06429238f, 
    0.01153508f, 0.11846378f, 0.02974190f, 0.04459849f, -0.00765700f, -0.00269912f, 0.02261536f, 0.19283006f, 
    0.00341235f, -0.00369422f, -0.00115629f, 0.03315885f, 0.08430722f, 0.01818543f, -0.00830665f, 0.08474810f, 
    -0.06187719f, 0.18502888f, -0.03409481f, -0.09343380f, -0.03186502f, 0.07505150f, 0.00507688f, 0.02648065f, 
    0.05439609f, 0.06939594f, 0.03978625f, 0.11066996f, -0.16965879f, 0.04625966f, 0.00363696f, 0.07082453f, 
    0.04165382f, -0.06088189f, -0.00096144f, 0.08914477f, 0.04705798f, 0.02238049f, -0.08400737f, -0.01532874f, 
    0.12364504f, 0.04625553f, 0.09022747f, -0.05580566f, -0.05288331f, -0.07433832f, -0.03379985f, -0.06316174f, 
    -0.00606905f, -0.11809975f, -0.02579477f, -0.04579994f, 0.25413597f, -0.06214373f, -0.02592889f, -0.06991939f, 
    0.06305842f, 0.06884935f, -0.04570369f, -0.02239103f, -0.00926442f, -0.01089702f, 0.02889143f, -0.02339995f, 
    0.11608338f, -0.07642334f, -0.18210538f, 0.00804245f, 0.16911089f, -0.01422028f, 0.10034519f, 0.11424895f, 
    0.05557948f, -0.03333029f, 0.03366942f, -0.05972368f, -0.14415689f, -0.09155253f, 0.27374130f, 0.02003910f, 
    0.03798354f, 0.05465006f, -0.03055197f, -0.03914022f, 0.02893268f, 0.07851526f, 0.04174040f, 0.04107099f, 
    -0.38208562f, -0.12348614f, 0.02131769f, 0.00873197f, 0.05921775f, -0.05153738f, 0.03120945f, -0.03904053f, 
    0.18176612f, -0.02198942f, -0.12666786f, -0.09122689f, -0.41703218f, 0.38408664f, -0.11805680f, -0.03529037f, 
    0.13388205f, -0.01098210f, -0.09263716f, 0.01914139f, 0.02626625f, -0.03926767f, -0.01601300f, -0.02735858f, 
    -0.09996056f, -0.04741630f, 0.02905713f, -0.05107493f, 0.04791775f, -0.00204135f, 0.03012940f, -0.01362103f, 
    -0.04092849f, 0.01034749f, 0.05526766f, -0.02031484f, -0.14036213f, 0.14339563f, -0.02147908f, 0.12620007f, 
    0.11541466f, 0.02206027f, 0.00039556f, -0.11671165f, 0.01894997f, 0.02438989f, -0.01478006f, -0.11413870f, 
    -0.29285356f, -0.00624762f, -0.03708326f, -0.04674479f, -0.01724621f, -0.01935358f, 0.03745480f, 0.01944654f, 
    0.07570838f, -0.08364174f, -0.03071292f, -0.10972684f, 0.15781166f, -0.00428945f, 0.22666648f, 0.14413129f, 
    0.02116492f, -0.09276015f, 0.02602982f, 0.01053873f, -0.00249439f, 0.03734053f, 0.05040901f, 0.03641346f, 
    0.16732319f, -0.11830816f, -0.04981447f, -0.09336134f, 0.13214739f, 0.00376984f, -0.03217073f, -0.05390891f, 
    0.12525511f, -0.03754482f, 0.08045582f, 0.00246312f, 0.12427267f, -0.16118009f, 0.03884609f, 0.01550821f, 
    0.01626052f, -0.01510112f, -0.03234573f, 0.04394222f, 0.02620460f, -0.05342966f, 0.03148946f, 0.01145061f, 
    -0.65150094f, 0.25837368f, -0.18930115f, 0.01347130f, 0.21497469f, -0.01545410f, -0.08736587f, 0.05477130f, 
    -0.08933799f, 0.01853360f, -0.01794311f, -0.04654076f, 0.40465957f, 0.02274938f, -0.18260410f, 0.04384669f, 
    -0.03011138f, -0.00792110f, -0.00801332f, 0.01486135f, -0.01899443f, -0.10422880f, -0.01368279f, 0.07588437f, 
    -0.19739297f, 0.09052717f, -0.13601020f, 0.04279444f, 0.10921570f, 0.09129876f, -0.03930225f, -0.01168418f, 
    -0.00209266f, -0.00944171f, -0.13027053f, 0.00100207f, -0.40221173f, -0.05821248f, -0.14828387f, -0.15953469f, 
    0.05094420f, 0.01309730f, 0.09388561f, 0.03290462f, -0.08530772f, 0.10084160f, 0.08208466f, -0.01741797f, 
    -0.06314564f, -0.11210553f, 0.13233554f, 0.12136901f, -0.08766796f, 0.01049044f, -0.06022536f, -0.02397463f, 
    0.01036188f, -0.07240734f, 0.04819413f, -0.00742602f, -0.11555631f, -0.15990558f, -0.03983223f, 0.08236203f, 
    0.06515492f, 0.05321939f, 0.04762582f, -0.05307946f, 0.01658699f, -0.12314525f, -0.11685848f, -0.03072814f, 
    0.26377672f, -0.11349995f, -0.04372841f, 0.01693207f, 0.02547430f, 0.02324500f, 0.23521884f, 0.09381020f, 
    0.03110856f, 0.03275153f, 0.00124340f, 0.06844196f, 0.05843702f, 0.06962065f, -0.08439025f, -0.01863515f, 
    0.12187412f, 0.07154891f, 0.06928296f, 0.08615693f, 0.05153906f, -0.01683244f, 0.00414795f, 0.06334465f, 
    -0.03880848f, -0.27990958f, 0.00598340f, -0.25844550f, -0.02965451f, 0.04517221f, -0.00175882f, -0.01771269f, 
    -0.00630977f, -0.02930548f, -0.03746723f, 0.03951373f, 0.25436535f, -0.15149976f, -0.18303929f, -0.01829031f, 
    -0.00369989f, 0.07646538f, -0.06919216f, 0.01367549f, 0.03258101f, 0.04958243f, 0.02786243f, 0.08759750f, 
    0.25772354f, -0.20118138f, -0.03967492f, -0.01140657f, 0.07026420f, 0.03330119f, -0.00946168f, 0.04104164f, 
    -0.01749693f, 0.06421807f, -0.00125731f, 0.00799514f, -0.03012522f, 0.16850388f, 0.09805200f, -0.02578221f, 
    0.02285145f, 0.03469656f, 0.05650052f, 0.06529953f, 0.14257979f, 0.09731685f, 0.01571066f, -0.01640943f, 
    0.11225855f, -0.03750356f, -0.00422277f, 0.10747202f, 0.09082841f, 0.08974688f, 0.08301020f, 0.02863560f, 
    0.02097000f, 0.06642906f, 0.03959995f, -0.01344912f, 0.05521695f, 0.23077215f, -0.09288396f, 0.08088055f, 
    0.07939407f, 0.15335201f, 0.12677695f, 0.05456457f, -0.00437968f, -0.08735970f, -0.05100695f, -0.05770507f, 
    0.00961175f, -0.11286709f, -0.00495765f, 0.11856793f, -0.08018886f, 0.07886223f, 0.01785144f, 0.03587330f, 
    0.15772235f, 0.04202414f, 0.07825316f, -0.01748084f, -0.04641294f, -0.05623753f, -0.11536326f, 0.00729926f, 
    -0.22381908f, 0.05968186f, 0.05469542f, 0.01481036f, 0.06327156f, 0.04311580f, 0.03781735f, 0.02672827f, 
    0.24446811f, -0.18071669f, -0.07794154f, 0.07041500f, 0.10041428f, 0.06288109f, 0.06463383f, 0.00813820f, 
    0.14314486f, 0.07111678f, 0.00887217f, 0.01263498f, 0.18138199f, 0.17970553f, 0.09417398f, -0.01137026f, 
    -0.01921118f, 0.07791348f, 0.02924692f, 0.04541551f, 0.13755850f, 0.01173382f, 0.05379522f, 0.04037297f, 
    0.11262592f, -0.10596024f, 0.03981908f, 0.11149964f, -0.04322315f, 0.08328990f, 0.05912100f, 0.00104106f, 
    0.08265597f, 0.03555817f, -0.01775322f, 0.01275965f, 0.00938591f, 0.11256355f, -0.09176771f, -0.03835871f, 
    -0.02816353f, -0.02032096f, 0.05344500f, -0.04040019f, 0.00207561f, 0.01084589f, 0.03455262f, 0.01016023f, 
    -0.02873249f, -0.02864551f, 0.07869908f, -0.16562885f, 0.00830394f, -0.05120366f, -0.05165465f, 0.08524502f, 
    0.08103441f, -0.07530624f, -0.02118450f, 0.12368244f, -0.12773828f, -0.17888780f, -0.01910106f, -0.10085140f, 
    0.07490286f, 0.01594105f, -0.04082651f, 0.03405091f, -0.02693476f, -0.03414177f, 0.06782338f, 0.15909874f, 
    0.10631473f, 0.06316962f, -0.00815339f, 0.07945213f, -0.00299347f, 0.04217672f, -0.01918404f, 0.11488830f, 
    0.03961981f, 0.04117512f, 0.04099604f, 0.05550848f, 0.10512261f, -0.01589833f, 0.02989169f, -0.17264956f, 
    0.01731945f, 0.03348382f, 0.08381509f, 0.06069140f, -0.05087143f, 0.02676043f, 0.02016656f, 0.01596630f, 
    -0.21720353f, -0.28135231f, -0.23368138f, -0.04296241f, 0.06943546f, -0.13089292f, -0.02411959f, -0.09040675f, 
    -0.04684902f, -0.01856527f, -0.04365468f, 0.16438831f, -0.03521621f, -0.05978037f, 0.01806068f, 0.09371980f, 
    -0.03932778f, 0.04263924f, 0.12233417f, 0.03744442f, -0.04323146f, -0.00938291f, 0.03311761f, 0.04042782f, 
    0.07827146f, 0.05327573f, 0.04247683f, 0.10551982f, 0.08963419f, -0.02435257f, -0.01015258f, 0.07398032f, 
    0.00577479f, 0.09242507f, 0.02710477f, -0.12199632f, -0.07286312f, -0.02235071f, 0.05810750f, -0.10005502f, 
    0.06141555f, 0.04813826f, 0.07064467f, 0.03397266f, 0.08427417f, -0.02275570f, 0.09659307f, -0.05875045f, 
    0.10051312f, -0.10353269f, 0.18763547f, -0.15380608f, -0.06098510f, -0.01401213f, 0.12837861f, 0.03333495f, 
    0.05504509f, 0.05890485f, 0.07962562f, -0.01417811f, -0.07270917f, 0.16648737f, -0.00545444f, 0.04692385f, 
    0.01644513f, 0.10568715f, 0.08837229f, 0.16189960f, 0.01865084f, 0.04848696f, -0.04694937f, 0.12841305f, 
    0.12530051f, -0.07361242f, 0.01912296f, 0.06825145f, -0.04434146f, -0.00770675f, 0.01214886f, 0.06053504f, 
    0.03574287f, -0.03385231f, 0.06691981f, -0.01780908f, 0.06151354f, -0.16659148f, 0.04251024f, -0.13391785f, 
    -0.13640471f, -0.02023226f, 0.02469744f, 0.06349844f, 0.09880763f, 0.04082344f, 0.05411700f, -0.04155254f, 
    -0.32386544f, 0.16032879f, -0.08452016f, 0.02631674f, 0.00693908f, 0.10888040f, 0.10193832f, 0.08596817f, 
    0.08028381f, 0.01943295f, 0.09912591f, 0.07500511f, -0.08701903f, -0.08912352f, 0.01520252f, 0.19747688f, 
    0.00610491f, 0.07494202f, 0.02701573f, 0.06313633f, -0.06505723f, -0.00991039f, 0.01351199f, -0.07045905f, 
    -0.10574940f, -0.05592499f, 0.02906745f, -0.04503604f, -0.08619909f, 0.01693142f, 0.03345040f, 0.06080853f, 
    -0.00695691f, 0.12215392f, 0.00445473f, 0.05125896f, -0.24370128f, 0.11530547f, 0.06832752f, 0.15986829f, 
    0.07551670f, -0.00794453f, 0.02246672f, 0.03912744f, 0.03833733f, 0.06256898f, 0.02114248f, 0.03326251f, 
    -0.04485641f, -0.08359092f, -0.24061868f, -0.18880390f, -0.23037130f, -0.03276838f, 0.01745498f, -0.06589698f, 
    -0.03902327f, 0.00016645f, 0.04860106f, 0.00274944f, 0.26128572f, 0.10001369f, -0.06105351f, -0.11514856f, 
    0.14008284f, 0.05579598f, 0.05294706f, 0.06456709f, -0.01267529f, 0.01276885f, 0.09174591f, 0.07419726f, 
    0.21958353f, 0.25106320f, 0.01706246f, -0.12473781f, 0.06664064f, 0.04613822f, 0.00290617f, 0.00967235f, 
    0.06252111f, -0.02248463f, -0.00221119f, 0.05723085f, -0.07435387f, -0.17597987f, -0.07903302f, -0.01404591f, 
    -0.02960378f, -0.00825380f, -0.06297946f, -0.00759414f, -0.02319201f, 0.05030633f, 0.07909486f, 0.07156103f, 
    -0.14183958f, 0.12452711f, 0.10585491f, -0.33869740f, -0.07386082f, 0.02849783f, 0.01092141f, 0.14340204f, 
    -0.11800475f, -0.15318260f, -0.18547025f, -0.02107959f, 0.15836470f, 0.04711250f, 0.12934254f, -0.01399363f, 
    0.03268513f, 0.00843630f, -0.00926694f, 0.13444853f, 0.07122939f, -0.03072324f, 0.07927868f, 0.04785719f, 
    -0.43980807f, -0.14939490f, 0.03153461f, 0.05755363f, -0.01324700f, 0.03240603f, 0.00047446f, 0.02237538f, 
    0.02009727f, -0.07719538f, 0.01012260f, -0.00483975f, 0.16957726f, 0.13064604f, -0.10739319f, 0.00273166f, 
    0.05043411f, 0.04005296f, 0.03113777f, -0.01057886f, -0.00049815f, -0.06974753f, -0.01810542f, 0.02500651f, 
    -0.08102431f, -0.20791253f, -0.07234057f, -0.21697481f, 0.05619279f, -0.07403328f, 0.07216786f, -0.05134076f, 
    0.02896205f, 0.07092195f, 0.02695800f, 0.08388218f, 0.15336391f, 0.04303812f, 0.02777205f, 0.29936826f, 
    0.05237795f, 0.01022140f, -0.02182830f, 0.09861385f, -0.03365870f, 0.00095861f, 0.03774183f, 0.06742726f, 
    0.13128483f, 0.00873776f, 0.12288712f, -0.09546169f, 0.02822006f, -0.00192605f, 0.00645786f, 0.12556706f, 
    0.07467117f, 0.06062187f, 0.06976071f, 0.06820010f, 0.09716979f, 0.19450527f, 0.08641911f, 0.11420164f, 
    0.04898053f, 0.14057280f, 0.06185863f, 0.02625226f, -0.02967026f, -0.04536464f, 0.04059966f, 0.07819822f, 
    0.29836532f, 0.07682732f, -0.00302409f, 0.08704219f, 0.06005439f, 0.17191310f, 0.03921384f, 0.02343299f, 
    0.05239258f, 0.07777923f, 0.06472671f, 0.08356470f, 0.11531597f, -0.10899739f, -0.00885955f, 0.16479498f, 
    0.00353561f, 0.01788439f, 0.09449839f, 0.05754746f, -0.00949094f, 0.06025599f, -0.09095407f, 0.01633889f, 
    0.07875710f, 0.06836613f, 0.25758263f, -0.02678804f, 0.02562689f, 0.03525447f, 0.04174399f, 0.05037916f, 
    0.05219632f, 0.01499376f, -0.02618809f, 0.07788678f, 0.01899679f, 0.17479247f, -0.00776357f, -0.05576054f, 
    0.12868206f, 0.06224220f, 0.06303569f, 0.05690499f, -0.01901170f, 0.00983078f, 0.03871831f, -0.08293638f, 
    0.25490299f, -0.03112329f, -0.01976974f, 0.16167666f, 0.09755126f, 0.02770127f, -0.09279565f, 0.10317669f, 
    -0.03744721f, 0.03086433f, -0.02890370f, 0.06254289f, -0.49911249f, 0.04584187f, 0.02570756f, 0.04962524f, 
    0.02188646f, -0.00399185f, 0.02067989f, 0.03445734f, 0.04276575f, -0.04607103f, 0.03183671f, 0.07490452f, 
    -0.08758441f, -0.17984836f, -0.08670109f, -0.27681360f, -0.07442360f, -0.05029724f, -0.02555235f, -0.05059617f, 
    0.02327656f, 0.08417837f, 0.05387864f, 0.08614345f, -0.30889493f, -0.03350865f, -0.10261574f, 0.07131826f, 
    -0.13599035f, -0.01077660f, -0.00574323f, 0.01449123f, 0.02223628f, 0.02086509f, 0.09107562f, -0.00098368f, 
    -0.23117796f, -0.13997070f, -0.08072902f, 0.00835882f, -0.26190251f, 0.08192245f, -0.06022574f, 0.03033918f, 
    -0.08100254f, 0.02438477f, -0.01554863f, 0.01478744f, -0.18821442f, -0.02517249f, -0.05724411f, -0.05285448f, 
    -0.00305480f, 0.00491448f, 0.05846417f, 0.03729495f, -0.03101029f, 0.02673835f, 0.00035022f, 0.02650733f, 
    -0.15114513f, -0.08060491f, -0.03842779f, -0.01939071f, 0.01390138f, 0.05602474f, 0.05752730f, 0.01725585f, 
    0.04092457f, 0.02236960f, 0.13950779f, 0.00634821f, 0.06642656f, -0.08590149f, -0.06117013f, -0.16728994f, 
    -0.07540537f, -0.00373772f, -0.05805517f, 0.01038419f, -0.00483482f, 0.06872682f, 0.04813447f, -0.00814549f, 
    0.16916743f, -0.15180726f, -0.12304205f, -0.08076236f, 0.07181707f, -0.01554821f, 0.01541854f, -0.05049578f, 
    0.05033334f, 0.03591885f, 0.05776113f, 0.00472286f, 0.23653048f, 0.07128225f, -0.02451224f, 0.07113762f, 
    0.11501177f, 0.06339628f, 0.04219050f, 0.06420442f, 0.02066231f, 0.06027407f, -0.02085021f, 0.04331664f, 
    -0.16704760f, 0.04800998f, 0.20208792f, 0.02202988f, 0.08371157f, -0.06822184f, -0.00133121f, 0.05404795f, 
    -0.11191037f, -0.03313145f, -0.01414083f, 0.01775390f, -0.08061041f, 0.14951722f, 0.07286383f, -0.03627878f, 
    0.12464553f, 0.05322029f, 0.04120240f, 0.10505632f, 0.04859222f, 0.03385783f, 0.04843639f, 0.10564931f, 
    0.13927710f, 0.13250230f, -0.03093383f, 0.02124307f, 0.06002326f, 0.02996496f, 0.17461152f, 0.01672848f, 
    0.11979764f, -0.06496447f, 0.13721803f, 0.00687856f, -0.01947681f, 0.17506225f, 0.07037417f, 0.12454899f, 
    -0.06660203f, 0.01272232f, 0.09624626f, 0.01864984f, 0.06764624f, 0.05558193f, 0.05684651f, 0.07120454f, 
    0.15029833f, -0.06684183f, 0.02518138f, -0.09236714f, -0.11865704f, 0.03390118f, 0.07145912f, -0.05477973f, 
    -0.04176752f, -0.03047713f, 0.07849243f, -0.01070814f, 0.12169693f, 0.18776935f, -0.09784547f, 0.08941764f, 
    0.02289350f, 0.05789865f, 0.11986169f, 0.11914764f, 0.10258958f, -0.00544603f, 0.07539711f, -0.08971112f, 
    -0.00185780f, -0.27521092f, 0.06017885f, 0.23866634f, -0.09926162f, -0.01223299f, 0.03308612f, 0.03110190f, 
    0.03704018f, 0.04120612f, -0.04352477f, -0.00223410f, 0.02569651f, -0.15084399f, -0.14292681f, -0.18958619f, 
    -0.19556487f, -0.01552901f, -0.07617377f, -0.07831233f, -0.03089838f, 0.07124166f, 0.03475301f, -0.04689037f, 
    0.02713320f, 0.01925675f, -0.03553287f, -0.01267182f, -0.00950647f, 0.01811312f, 0.00052460f, 0.02778776f, 
    -0.00103560f, 0.02062819f, 0.03082646f, -0.00767411f, -0.00231304f, 0.02874191f, 0.02981457f, -0.01294367f, 
    -0.01688169f, -0.02141720f, -0.01062346f, -0.01587607f, -0.00225607f, -0.03043417f, -0.03619520f, -0.03346771f, 
    0.01615862f, -0.01470298f, -0.03348800f, -0.01373825f, 0.00629680f, -0.01929238f, -0.03517996f, -0.02190620f, 
    -0.03031267f, 0.01801551f, -0.00248866f, -0.00132421f, -0.03186320f, -0.03406557f, -0.01840298f, 0.00112965f, 
    -0.03030914f, 0.02674633f, 0.02946485f, 0.03149038f, -0.02776252f, -0.01559819f, 0.00413740f, 0.00035073f, 
    -0.02193548f, 0.01753781f, -0.02028745f, 0.02224192f, -0.00815979f, 0.01871431f, -0.00721627f, 0.00821555f, 
    0.02718806f, 0.02003286f, -0.03254016f, -0.03080969f, 0.01104752f, -0.03444878f, -0.03813608f, -0.02798950f, 
    0.01206803f, 0.02112528f, -0.01765429f, 0.00054780f, -0.01596344f, 0.01214936f, 0.00698815f, -0.01109003f, 
    -0.01343917f, 0.02268692f, 0.01389512f, -0.01232367f, 0.01977114f, 0.00929396f, -0.01857167f, -0.01427275f, 
    -0.02681890f, 0.01842909f, -0.04104561f, -0.01437994f, -0.00685223f, 0.02016787f, -0.03154243f, -0.00723369f, 
    0.02116510f, -0.01909117f, -0.00992950f, 0.01606744f, 0.00278793f, 0.02136627f, 0.00060890f, 0.02340500f, 
    -0.00543454f, -0.01767362f, 0.00798934f, -0.00931278f, 0.01990315f, -0.01916834f, 0.02929128f, 0.03303933f, 
    0.02436137f, -0.01168165f, 0.02321059f, -0.00961771f, -0.00548554f, -0.02194375f, -0.00862415f, 0.02535763f, 
    -0.01216715f, -0.02064249f, -0.03983494f, 0.01177158f, -0.03214554f, -0.00885544f, -0.02458603f, 0.02699410f, 
    -0.00237353f, -0.02089271f, 0.02574863f, -0.03679698f, -0.03810531f, -0.00898984f, 0.01237968f, -0.01464661f, 
    0.01741390f, 0.00544619f, -0.00282500f, 0.00523893f, 0.01025764f, -0.02993375f, -0.03943158f, -0.00213551f, 
    0.02963217f, -0.03341283f, -0.02840006f, -0.03538180f, 0.02794020f, -0.00418884f, -0.01127681f, -0.00717844f, 
    0.00411647f, -0.03416333f, 0.02629879f, -0.02301152f, -0.00637971f, -0.00020244f, 0.01874607f, -0.02891994f, 
    0.01493018f, 0.00150841f, 0.01735686f, -0.01740380f, 0.00676499f, 0.01999811f, 0.00969281f, -0.01912028f, 
    0.00339093f, 0.00160925f, 0.01267884f, -0.00732418f, -0.00486260f, -0.03193261f, 0.02120193f, 0.01162727f, 
    -0.02536843f, 0.00092125f, -0.02027777f, -0.03812024f, -0.00225823f, -0.03163865f, 0.02652122f, -0.02192937f, 
    0.00591136f, 0.01782195f, -0.00902431f, 0.01335115f, 0.02217711f, 0.01829388f, -0.00423717f, 0.02475569f, 
    0.03140756f, 0.01498013f, -0.00924774f, 0.01091701f, -0.02374090f, -0.02616206f, 0.00742166f, -0.00588896f, 
    0.01405314f, -0.02823147f, -0.00402710f, 0.01122474f, -0.02938115f, 0.02355058f, 0.01308086f, 0.02043265f, 
    0.01169791f, -0.03602723f, -0.02096335f, -0.01216785f, -0.02725175f, -0.00290963f, -0.01008829f, 0.00991460f, 
    -0.00491782f, 0.02434446f, 0.01670795f, -0.00584802f, -0.03306728f, 0.02079178f, -0.00460384f, 0.02901746f, 
    0.02081127f, 0.00917273f, 0.02219536f, -0.01469714f, 0.02624349f, 0.01178300f, -0.00261250f, -0.02338530f, 
    -0.03953706f, -0.02088480f, 0.02667297f, 0.02041255f, 0.00052406f, 0.01272011f, 0.01913697f, 0.00203557f, 
    0.00836646f, 0.02662230f, 0.00848085f, 0.00524371f, 0.00741458f, -0.00627652f, 0.01183459f, 0.01179462f, 
    0.02605803f, -0.02148504f, -0.00987404f, -0.03432827f, -0.00068189f, 0.01660339f, 0.01816024f, -0.03321719f, 
    -0.03180325f, 0.01273829f, -0.01468548f, 0.00888905f, 0.01756585f, -0.01185440f, 0.01243161f, -0.00883682f, 
    -0.00641996f, 0.00913413f, 0.02841911f, 0.00137520f, 0.00647563f, -0.02377037f, 0.00050750f, -0.02739960f, 
    -0.04130967f, 0.03458110f, -0.00862820f, 0.02668452f, 0.00298612f, 0.02975565f, -0.01489408f, 0.00105538f, 
    0.02307684f, -0.00723033f, 0.02483480f, -0.00051909f, 0.01693386f, -0.02961370f, -0.01261203f, -0.03642025f, 
    0.01959993f, 0.01364097f, -0.01020573f, -0.01418807f, -0.00081341f, -0.00688854f, -0.01745791f, 0.02113722f, 
    -0.01651824f, -0.01941598f, -0.03127055f, -0.02053517f, -0.02353138f, 0.01722341f, 0.00965978f, -0.03774628f, 
    -0.00626659f, 0.01011394f, -0.03899257f, -0.03695719f, -0.00936047f, -0.02383206f, 0.01695093f, 0.02810412f, 
    0.02122762f, -0.01579865f, 0.00694510f, 0.01392413f, 0.00930227f, -0.01715181f, -0.00163231f, -0.00485538f, 
    0.01244709f, -0.02652236f, -0.01113281f, 0.02838301f, -0.00747659f, 0.01031159f, 0.01517898f, -0.01271778f, 
    0.02446451f, 0.01369537f, -0.00687561f, -0.03774795f, -0.01213192f, 0.02499412f, -0.03425010f, -0.00682809f, 
    -0.01243747f, -0.00284701f, 0.00041760f, -0.02829106f, -0.00157870f, 0.02941051f, 0.02178081f, 0.03091582f, 
    -0.00645322f, -0.02822787f, -0.02015749f, 0.02468329f, 0.00353046f, 0.01639926f, -0.00583940f, -0.00830759f, 
    0.00066853f, -0.02674137f, -0.02624750f, -0.03767315f, -0.03467578f, -0.03660208f, 0.01711783f, 0.00372251f, 
    -0.00208601f, -0.00843102f, -0.00261874f, 0.02198282f, -0.04164955f, 0.01639565f, -0.01460509f, 0.02243761f, 
    0.02318301f, 0.01466175f, 0.00717892f, -0.00809859f, 0.00152735f, -0.01803545f, -0.03661297f, -0.02941619f, 
    -0.02680653f, -0.01116597f, 0.00086300f, -0.01284439f, -0.02318287f, -0.00540844f, -0.02393248f, -0.03194916f, 
    0.00277286f, 0.02568572f, -0.03546116f, -0.00034698f, -0.01420742f, 0.01231504f, -0.01952387f, -0.02591225f, 
    -0.03462824f, 0.01878347f, -0.03592702f, 0.01943556f, -0.03397475f, -0.02401922f, -0.02004573f, -0.03394167f, 
    -0.00367794f, -0.02599747f, 0.02552053f, -0.01173845f, -0.02937778f, -0.02063984f, -0.01763580f, 0.01284677f, 
    0.01214613f, -0.02892368f, -0.02753620f, 0.03055048f, -0.03622776f, 0.02485207f, -0.02903482f, -0.01619743f, 
    0.01419640f, 0.04268114f, 0.02088531f, 0.00984619f, 0.00969563f, 0.01399199f, 0.00580379f, -0.00998580f, 
    -0.03377882f, -0.02106154f, 0.03069585f, -0.03345890f, 0.02229751f, 0.02453646f, 0.02940920f, 0.00700602f, 
    -0.01152469f, 0.00426736f, -0.00145909f, 0.03121012f, 0.00893853f, 0.02854268f, -0.00098671f, -0.00565362f, 
    0.00174470f, 0.00577623f, 0.01171450f, 0.02097345f, -0.00232877f, -0.00970919f, -0.02813921f, -0.01759660f, 
    -0.02179548f, -0.01187505f, -0.00309169f, 0.01931973f, 0.02737176f, 0.01320448f, 0.00165167f, 0.00348744f, 
    -0.04178089f, 0.01537451f, -0.01900578f, 0.00233793f, 0.02030603f, 0.00904890f, -0.03014472f, 0.03090070f, 
    -0.00063023f, 0.00835973f, 0.00410470f, -0.00034491f, -0.01681633f, 0.01386745f, 0.01554145f, 0.00200770f, 
    -0.00932688f, -0.01700685f, -0.03720204f, 0.00930463f, -0.02440838f, -0.00434037f, -0.02425185f, 0.02897778f, 
    -0.00469187f, 0.02475780f, 0.00969048f, 0.00934040f, 0.02123215f, 0.00031492f, -0.00386015f, -0.03356532f, 
    -0.03837224f, -0.03150361f, 0.01082214f, -0.04028772f, -0.00066988f, 0.02462308f, 0.02610071f, -0.02273649f, 
    -0.01926794f, -0.01406694f, -0.01887717f, 0.02690732f, -0.00750262f, 0.02641955f, 0.02307408f, -0.01760205f, 
    -0.01430967f, -0.00387723f, -0.02785462f, -0.01179876f, -0.01941987f, -0.03186696f, -0.00922423f, -0.00432513f, 
    0.03199996f, -0.03314020f, -0.01279925f, 0.00593033f, 0.02790174f, -0.00772262f, -0.04144576f, 0.00177600f, 
    -0.01056663f, -0.00480449f, 0.01274366f, -0.00002349f, 0.02661600f, -0.00673036f, -0.02963819f, -0.02943415f, 
    -0.01041169f, -0.00097252f, 0.01604646f, -0.00322224f, 0.00952125f, -0.03997266f, -0.03484247f, 0.02445439f, 
    -0.00671164f, 0.02722816f, -0.00222779f, 0.00726845f, -0.04112129f, 0.01492101f, -0.03386571f, -0.02555819f, 
    -0.03230085f, 0.00229877f, -0.00974397f, 0.00689028f, -0.03046822f, -0.03628367f, 0.01628147f, 0.02602131f, 
    -0.03866718f, 0.01494050f, -0.02694715f, 0.02310288f, 0.03242720f, 0.00618774f, -0.00451293f, 0.01603795f, 
    -0.01507134f, -0.00959262f, -0.00089580f, -0.00293050f, 0.02216560f, 0.02297640f, -0.00976939f, -0.02867474f, 
    0.01629201f, -0.01820379f, 0.00636575f, -0.02555186f, -0.01718712f, 0.01022772f, 0.03085400f, 0.01801468f, 
    -0.03603620f, -0.03497145f, 0.02826735f, 0.02251400f, -0.00293047f, -0.00941638f, 0.01750098f, 0.02136456f, 
    0.02195187f, -0.00368430f, -0.01062925f, -0.00499864f, -0.00561521f, -0.04052626f, 0.01942207f, -0.00562488f, 
    0.02053943f, -0.01246622f, -0.01884270f, 0.00669713f, -0.03401751f, -0.01241290f, -0.02021145f, -0.00444308f, 
    0.02310333f, -0.04014215f, 0.00577147f, -0.03154681f, 0.01217926f, -0.01994603f, 0.01124842f, 0.02707244f, 
    -0.04154013f, 0.00796207f, 0.00793582f, 0.00089892f, -0.02346964f, 0.02391943f, -0.02371838f, 0.02744447f, 
    0.01081656f, 0.00196048f, 0.01231069f, -0.03219727f, 0.00317979f, 0.02998650f, 0.00204754f, -0.01465488f, 
    -0.00816406f, -0.01491015f, -0.01832984f, 0.00238929f, -0.02275634f, -0.00394505f, 0.00909672f, -0.03359199f, 
    0.01574316f, 0.03013060f, 0.00877100f, -0.01861027f, 0.02290545f, 0.02975748f, -0.01116692f, 0.01824759f, 
    -0.01540645f, 0.00486589f, 0.02595561f, -0.03500670f, -0.00365069f, 0.01662727f, -0.01599889f, -0.03552960f, 
    0.02603726f, -0.02431972f, 0.02215717f, -0.03982884f, -0.03318320f, -0.01054526f, -0.02747368f, -0.02482821f, 
    0.00281024f, -0.03525026f, -0.00592323f, -0.01359032f, -0.02011822f, 0.01284537f, 0.02320597f, -0.01259483f, 
    -0.04078502f, -0.01615190f, -0.02486691f, 0.01967617f, -0.02258309f, 0.02263055f, 0.01995958f, -0.02124424f, 
    0.01599124f, 0.00711067f, -0.00679690f, -0.02483209f, -0.02856328f, 0.02633008f, -0.01287865f, 0.00475374f, 
    0.02416493f, 0.02184609f, -0.03872489f, -0.00490015f, -0.03567011f, 0.03152182f, -0.02324681f, 0.00943211f, 
    0.02919730f, -0.02042961f, 0.01507586f, -0.03266798f, 0.03060643f, -0.00710441f, -0.01433988f, -0.02691354f, 
    -0.02101631f, -0.01811659f, -0.02352910f, -0.03239352f, 0.03115754f, -0.02550262f, 0.01490389f, 0.00599583f, 
    -0.02042186f, 0.00079410f, -0.01978477f, 0.00815036f, 0.00269962f, 0.02863360f, 0.03165024f, 0.00756098f, 
    0.00199245f, -0.00761602f, 0.02076369f, -0.02605367f, -0.01938682f, -0.00371837f, -0.01763373f, 0.02205322f, 
    -0.00625219f, 0.00892730f, -0.00950161f, -0.03148818f, -0.03518268f, -0.03946462f, -0.01041884f, -0.02995411f, 
    0.02338143f, -0.00663747f, 0.01218624f, 0.00968253f, 0.01408367f, 0.00933671f, -0.01920216f, -0.03061687f, 
    -0.00057107f, 0.00067617f, -0.03614376f, 0.00444655f, 0.00681264f, 0.01884432f, -0.02696130f, -0.03400520f, 
    -0.01256164f, -0.03638553f, 0.03125785f, 0.01351006f, 0.01938921f, -0.03029328f, 0.02840135f, 0.02749116f, 
    -0.02189804f, -0.00621253f, -0.00442274f, -0.02896545f, 0.02247877f, 0.02469173f, -0.02601307f, 0.02455672f, 
    -0.02435830f, 0.00770295f, -0.03722618f, 0.00074377f, -0.01303157f, -0.00155829f, -0.02855655f, -0.02366391f, 
    0.02955659f, 0.02599069f, 0.00387783f, 0.01757491f, -0.02972239f, 0.01134444f, -0.01803235f, -0.02877835f, 
    -0.01873510f, -0.03198428f, 0.01559101f, 0.02013348f, 0.01077072f, -0.00663560f, -0.01688318f, 0.01036523f, 
    -0.03768011f, -0.01045095f, -0.02749653f, -0.03595458f, 0.02927906f, -0.00747130f, -0.01725581f, -0.02092971f, 
    0.02603523f, -0.03497447f, -0.01413600f, -0.02328506f, 0.01230879f, -0.02435194f, -0.02132820f, -0.00094796f, 
    0.00911943f, -0.01851710f, 0.01378462f, -0.00547281f, 0.00992240f, 0.01799629f, -0.03907215f, -0.00264643f, 
    -0.01459670f, 0.02099047f, 0.00615557f, -0.02354528f, -0.01009020f, 0.02015740f, -0.03388285f, -0.02138315f, 
    -0.02382543f, 0.01778992f, -0.03297375f, -0.02461045f, -0.03142564f, -0.02500956f, -0.01182800f, 0.01856012f, 
    0.02675521f, -0.00559717f, -0.02282734f, -0.00460336f, -0.03759496f, -0.00399582f, 0.00999966f, 0.01814366f, 
    0.01023065f, -0.01651725f, 0.03178284f, 0.02683820f, -0.02267422f, -0.00626369f, 0.00464048f, -0.00495973f, 
    0.00380871f, 0.02742288f, -0.01601518f, 0.01934537f, -0.03809057f, -0.00669195f, -0.02527667f, 0.00072344f, 
    -0.02268012f, 0.03000183f, -0.01320861f, 0.02929026f, 0.02946119f, -0.00598807f, -0.00613904f, -0.00048400f, 
    0.02266407f, 0.00120137f, -0.02726988f, 0.00067474f, -0.01864687f, -0.02232781f, 0.03140828f, 0.00037153f, 
    -0.01200780f, 0.03019695f, -0.00791205f, -0.01503122f, 0.01503098f, 0.01344722f, 0.02698090f, 0.02334382f, 
    0.02499804f, 0.00751399f, -0.01979575f, 0.00142582f, 0.00770469f, -0.01215865f, 0.02650975f, -0.02524693f, 
    0.01487820f, -0.01861921f, 0.02414514f, -0.01000762f, -0.02903652f, 0.00450287f, 0.01264021f, -0.01508477f, 
    0.02681884f, 0.02370678f, 0.03139563f, -0.04109881f, -0.01681258f, -0.02701091f, 0.02708651f, 0.03163976f, 
    -0.03307220f, 0.00706180f, -0.00052414f, 0.01952727f, -0.03006217f, -0.01573274f, -0.01879418f, 0.01126744f, 
    -0.03687971f, -0.00343811f, 0.00341008f, -0.01202476f, -0.01900714f, -0.02312979f, -0.00960617f, 0.01833206f, 
    -0.02137455f, 0.02593985f, -0.01420691f, -0.03452893f, -0.01412674f, -0.03723780f, -0.01723071f, -0.00892578f, 
    -0.02910194f, -0.02958833f, 0.00233298f, 0.00729588f, 0.01177847f, -0.01187745f, -0.00923883f, 0.02054447f, 
    -0.03613633f, -0.03378595f, 0.02621209f, -0.01468439f, 0.03228578f, -0.01816706f, 0.02836313f, -0.03645965f, 
    0.01629011f, 0.02403718f, -0.00151305f, -0.03565075f, -0.03077723f, 0.02728100f, -0.01231419f, 0.02648045f, 
    0.00460132f, -0.00462392f, -0.04083135f, 0.01812941f, 0.00444177f, -0.03028819f, -0.01836869f, -0.02015612f, 
    0.00042419f, 0.00483470f, 0.02100787f, -0.03783118f, -0.00229528f, -0.00998957f, 0.02881613f, -0.02863641f, 
    0.00952094f, 0.00632916f, -0.01170795f, -0.03812219f, -0.00027727f, -0.02137495f, -0.03110198f, -0.00102959f, 
    0.01810991f, -0.02997520f, -0.00796797f, 0.00957047f, 0.01836693f, -0.00656815f, -0.04291873f, -0.00002076f, 
    0.01768248f, -0.01194176f, 0.01422571f, -0.00058532f, -0.04004801f, -0.01057661f, 0.02138535f, -0.01785713f, 
    -0.02080409f, -0.01267573f, -0.01879838f, 0.00342111f, -0.03378665f, 0.01572626f, -0.00855805f, 0.01907210f, 
    -0.00973504f, 0.01458687f, -0.02688055f, -0.02217926f, -0.01940569f, -0.03804945f, 0.01108978f, -0.03712398f, 
    -0.02142948f, 0.00793476f, 0.02804066f, 0.01176341f, -0.03772928f, -0.01180701f, -0.00779458f, -0.00451964f, 
    -0.02345338f, 0.01737416f, -0.01040142f, 0.02337530f, -0.03860914f, 0.01644487f, 0.02669276f, -0.03801324f, 
    -0.02934819f, -0.02315810f, 0.01578393f, 0.00047807f, -0.01302639f, -0.01208434f, -0.00866413f, -0.03044931f, 
    -0.00500287f, -0.03647131f, -0.03827586f, 0.01140904f, 0.02818568f, -0.00178394f, -0.02746788f, 0.00781624f, 
    -0.00944624f, -0.00314578f, -0.01558737f, -0.02053983f, 0.03102953f, -0.02024426f, 0.02483753f, -0.03504647f, 
    0.00932682f, 0.00867177f, -0.00947714f, 0.00788066f, 0.00346032f, -0.00201443f, 0.00432759f, -0.01711141f, 
    0.01326762f, -0.01514387f, -0.03126982f, -0.03483785f, -0.00431553f, -0.00958535f, -0.00045836f, 0.03211604f, 
    0.00790800f, -0.03827219f, 0.00338969f, 0.02185371f, 0.02103189f, 0.00764496f, -0.02730164f, 0.02879460f, 
    0.00206619f, 0.01256317f, -0.03737245f, -0.00944301f, -0.01640355f, 0.01582371f, -0.03090369f, -0.00576265f, 
    -0.02257621f, 0.00612386f, 0.02132338f, -0.02594339f, 0.00596302f, -0.00785255f, 0.01586705f, 0.02439443f, 
    -0.01732794f, -0.00059582f, -0.02037635f, -0.02973946f, 0.01711614f, 0.02746929f, -0.03912653f, -0.02439430f, 
    -0.01469971f, -0.03284317f, -0.02805657f, -0.02347611f, -0.01178922f, -0.01641762f, -0.00425876f, -0.03153121f, 
    -0.00552344f, -0.03277646f, -0.02863568f, -0.02891448f, 0.02370570f, -0.03896601f, -0.01782623f, -0.03939050f, 
    0.02021136f, -0.00636211f, 0.02767451f, -0.04237755f, 0.00566293f, -0.03559978f, -0.03007139f, 0.01806429f, 
    -0.00008192f, -0.00869869f, 0.02680242f, 0.02187313f, -0.03764603f, 0.02509368f, -0.03257937f, 0.01140277f, 
    -0.02943240f, 0.03125917f, 0.02762159f, -0.01726581f, 0.00285449f, -0.01998936f, 0.00843225f, 0.01617871f, 
    0.02081226f, -0.00313734f, -0.02491387f, -0.02081792f, 0.00357498f, -0.01263297f, 0.02311300f, -0.04069524f, 
    -0.00045314f, -0.03813095f, -0.03597908f, -0.00012760f, -0.00851285f, 0.01391175f, -0.03124662f, 0.02361095f, 
    -0.02270760f, 0.02617491f, -0.01418599f, 0.03080760f, -0.02052769f, 0.01822061f, 0.03195667f, 0.02869928f, 
    -0.02045764f, -0.00227587f, -0.01356110f, -0.03061871f, -0.03929058f, -0.01722823f, -0.00342745f, 0.00227676f, 
    0.01287395f, -0.03557938f, -0.02213416f, -0.03940675f, -0.03593843f, 0.01158428f, -0.00717943f, 0.01387087f, 
    -0.03651103f, -0.01032240f, -0.01933658f, -0.01882119f, -0.03545545f, 0.00005164f, 0.00145839f, 0.01996752f, 
    -0.03544787f, -0.01385631f, -0.00081658f, -0.02933895f, 0.01282570f, 0.00198652f, -0.02273436f, -0.03377965f, 
    0.01757665f, -0.02650661f, -0.01308013f, 0.01667201f, -0.02847595f, 0.02017494f, -0.03839091f, -0.02312022f, 
    -0.00720873f, 0.00414926f, -0.01695941f, -0.00538830f, 0.02669873f, -0.03568565f, -0.00101693f, -0.00452071f, 
    0.01199566f, -0.02626492f, -0.02260824f, -0.01300257f, -0.03601502f, 0.02520647f, 0.02017007f, -0.02040777f, 
    -0.00470321f, -0.03404525f, 0.00518131f, -0.00008697f, 0.02107925f, -0.02600627f, 0.00525459f, -0.03992178f, 
    0.01864956f, 0.03058370f, -0.01273802f, -0.01884089f, 0.01585674f, -0.00703157f, -0.00815799f, -0.02811660f, 
    -0.01665318f, -0.02832712f, -0.03127386f, -0.01457057f, 0.01266633f, -0.01584223f, -0.02182502f, -0.03472890f, 
    -0.02606830f, -0.01893196f, -0.03549370f, 0.00704069f, 0.01085704f, 0.01179317f, -0.03662764f, 0.01193535f, 
    -0.02768562f, 0.02368795f, 0.01446893f, -0.04515819f, 0.01158499f, 0.02148560f, 0.01850032f, 0.00697209f, 
    -0.02604556f, 0.02408556f, -0.03645925f, -0.00226018f, -0.03581764f, 0.00288357f, -0.00600581f, -0.01166646f, 
    0.02409685f, -0.00695441f, 0.00665083f, 0.00556638f, 0.00935026f, 0.00931559f, 0.02645708f, -0.00739226f, 
    -0.00295780f, 0.01172622f, -0.01242949f, 0.01012936f, -0.01118037f, -0.01521065f, 0.03898690f, 0.03489954f, 
    -0.03030294f, -0.01803329f, 0.01399415f, -0.02732310f, 0.01185462f, -0.02106918f, 0.02640063f, -0.00490450f, 
    -0.00225551f, -0.03632207f, -0.03787576f, -0.02498837f, -0.01662548f, -0.01541425f, 0.01839248f, -0.03950955f, 
    0.01285996f, -0.02249885f, -0.01569328f, -0.00095408f, -0.00273794f, -0.03597201f, -0.03723110f, -0.02068241f, 
    0.02854792f, -0.02876256f, -0.00004673f, 0.02156853f, -0.01402104f, -0.03676598f, 0.00194541f, -0.02907139f, 
    0.03058092f, -0.02954789f, -0.00495158f, 0.00703030f, -0.00378683f, -0.01453684f, 0.01293496f, -0.01546942f, 
    -0.02580547f, -0.04042695f, 0.01389037f, -0.03266137f, 0.02288794f, -0.00294302f, 0.02851263f, -0.02862984f, 
    0.01767378f, -0.01920166f, 0.01139313f, 0.00614231f, 0.01566269f, 0.01616153f, -0.01395335f, -0.01218493f, 
    -0.02787777f, 0.00565342f, 0.03095888f, -0.01159060f, 0.00851777f, 0.02921188f, 0.01668397f, -0.03616907f, 
    -0.02762968f, -0.03986321f, 0.00129207f, -0.00999307f, 0.00076684f, 0.00391810f, 0.02209329f, -0.02556841f, 
    0.01945430f, 0.00741824f, 0.01934861f, 0.01675228f, 0.02168298f, 0.02294580f, -0.02612768f, -0.01672518f, 
    -0.00498499f, 0.00752590f, 0.01057823f, 0.02121721f, 0.01646142f, -0.00903471f, -0.03382483f, 0.00637837f, 
    -0.01749256f, 0.02893705f, 0.00557326f, -0.03504764f, -0.00435947f, 0.02090869f, 0.01129589f, -0.02241004f, 
    -0.02113064f, -0.03332116f, -0.03224481f, 0.00878309f, 0.01833732f, 0.00218150f, -0.03496748f, -0.01631940f, 
    -0.00474257f, 0.02096010f, -0.00169894f, 0.00314890f, -0.04144892f, 0.01351236f, 0.01256134f, -0.00264678f, 
    -0.03464323f, -0.02920992f, -0.02781866f, -0.00149110f, 0.01860159f, 0.00866713f, -0.04211390f, -0.03668604f, 
    -0.03258923f, 0.01007773f, 0.00653616f, 0.02508456f, -0.00103393f, -0.03093048f, -0.01458783f, -0.00661728f, 
    -0.02157876f, -0.03665361f, 0.02702334f, -0.01083696f, -0.00873022f, -0.03883606f, -0.01018587f, 0.02652122f, 
    -0.02594008f, -0.02347710f, -0.01119347f, -0.01711649f, -0.00199649f, -0.01138516f, -0.00678205f, 0.00373136f, 
    -0.02459757f, 0.02385264f, 0.01518604f, 0.01583779f, 0.02516353f, -0.00194952f, -0.03109361f, 0.01311776f, 
    -0.03855554f, 0.00105374f, -0.02818829f, 0.00862724f, 0.01608244f, 0.00887309f, -0.02056691f, 0.02332508f, 
    0.02340713f, 0.01574939f, -0.00380398f, 0.00178456f, -0.00835796f, -0.00275455f, -0.03468361f, 0.02285783f, 
    -0.02250643f, -0.02577885f, 0.00708507f, 0.01541765f, -0.03677520f, 0.01325569f, 0.01009772f, 0.01367985f, 
    -0.02525159f, 0.01465730f, 0.02125511f, -0.02764608f, -0.02662447f, 0.02340379f, 0.02926120f, 0.00793492f, 
    -0.00133491f, -0.01418292f, 0.02976238f, 0.00542268f, 0.02046274f, 0.00211943f, -0.03623255f, -0.02859082f, 
    -0.03451239f, 0.00450897f, 0.03040332f, -0.04051656f, 0.02516823f, 0.02296683f, -0.01961150f, -0.01549694f, 
    0.01433991f, 0.01696898f, -0.04038899f, -0.01979523f, -0.02795718f, 0.02065047f, 0.00191438f, 0.01507982f, 
    0.00579896f, -0.03362276f, -0.03870667f, -0.00428859f, -0.03120814f, -0.03835583f, -0.01975702f, -0.02578748f, 
    -0.00890488f, -0.00829684f, 0.01149899f, -0.03134510f, -0.00969380f, -0.04281336f, 0.02054579f, -0.01394174f, 
    -0.01679480f, 0.00055260f, -0.04209159f, 0.00939860f, 0.01064039f, -0.03103535f, -0.02461931f, 0.01293010f, 
    -0.01741108f, -0.01138951f, 0.02236890f, -0.03042809f, 0.00564134f, -0.00766355f, -0.01326450f, 0.01745511f, 
    -0.01779455f, 0.00826053f, -0.00879237f, -0.02158160f, 0.02931722f, -0.01267311f, 0.00326743f, -0.02135498f, 
    0.03855241f, 0.01528457f, -0.02044533f, 0.02158267f, -0.00590202f, -0.02247542f, -0.02760748f, -0.03375601f, 
    -0.00402128f, -0.02062447f, -0.03471620f, -0.00176669f, -0.00190768f, -0.00307139f, -0.00812384f, 0.01751380f, 
    -0.00638525f, -0.03211809f, 0.01938726f, 0.00808541f, -0.02228943f, -0.01663081f, 0.01953200f, -0.00362962f, 
    -0.01190737f, -0.01223002f, 0.01212941f, -0.02541439f, -0.03800549f, -0.02089575f, -0.01079904f, 0.01955881f, 
    -0.00875007f, -0.01588579f, -0.02370844f, 0.00556031f, 0.00536507f, -0.00217677f, -0.01282820f, -0.00169480f, 
    0.01877084f, 0.00668826f, -0.01435987f, -0.00462783f, -0.00511899f, 0.01804976f, 0.03847963f, -0.00178478f, 
    -0.02370866f, -0.00510626f, -0.00842450f, 0.00141829f, -0.00558161f, -0.02058445f, 0.01885411f, -0.00277724f, 
    -0.04122841f, -0.00750569f, 0.00973923f, -0.01309023f, -0.02581634f, -0.00606394f, 0.03052995f, -0.03578037f, 
    0.00529474f, -0.01233709f, -0.02713401f, -0.02985414f, 0.00836482f, 0.00094955f, 0.00103788f, 0.02140950f, 
    0.02435139f, 0.00086542f, -0.00455423f, -0.01618523f, 0.01595493f, 0.00222514f, 0.01434441f, 0.04079382f, 
    -0.01132303f, -0.03034345f, -0.03860973f, -0.02206998f, 0.00269275f, -0.01747650f, -0.00772285f, 0.02207460f, 
    0.01234808f, 0.01761799f, 0.02832406f, 0.02900867f, -0.00990271f, 0.02769206f, -0.01791179f, -0.03410426f, 
    -0.02069061f, -0.02676425f, 0.02055334f, -0.02092621f, 0.02005591f, 0.00650701f, -0.01676704f, 0.00107059f, 
    -0.00030572f, 0.02257576f, -0.01267119f, 0.01939192f, 0.02209274f, 0.01147815f, 0.01096927f, 0.03844708f, 
    -0.02336414f, 0.02705299f, 0.02859831f, 0.01631426f, 0.02602265f, -0.00662636f, -0.02505382f, -0.01870491f, 
    -0.01974530f, -0.02830203f, -0.03012190f, -0.00309411f, -0.03399422f, -0.01105880f, -0.03343672f, -0.00437333f, 
    0.02858176f, 0.02348312f, -0.03632174f, 0.00486152f, -0.00267778f, -0.03849614f, -0.02785662f, 0.02644815f, 
    -0.03156356f, 0.03948884f, 0.00187282f, -0.03541013f, -0.02081146f, -0.00144361f, 0.02153575f, -0.00623295f, 
    -0.03405354f, -0.01057641f, 0.02136271f, 0.00605156f, 0.00300884f, 0.01684221f, -0.03447898f, -0.03413986f, 
    0.02876679f, -0.03938027f, 0.02539651f, 0.03510534f, -0.03508474f, 0.03523078f, -0.00195491f, -0.02175739f, 
    -0.02023899f, -0.01969323f, -0.02232825f, 0.01460756f, -0.01874807f, 0.04100634f, -0.04188408f, 0.00927222f, 
    -0.00701790f, -0.00107119f, -0.02046200f, -0.01559995f, 0.01818909f, 0.03451496f, -0.01392676f, -0.00879791f, 
    0.02218408f, 0.04136458f, -0.01299818f, 0.00325625f, 0.00068321f, -0.01555780f, -0.02857088f, -0.01452561f, 
    -0.02631946f, 0.02240684f, 0.02358601f, -0.00795101f, 0.00129516f, 0.00819116f, 0.00094619f, -0.00214035f, 
    -0.03393213f, 0.00876412f, 0.00907243f, 0.03048754f, 0.01124842f, -0.02419031f, 0.02827011f, -0.01270622f, 
    -0.01314520f, 0.02018113f, 0.02393998f, -0.00986571f, -0.03142966f, 0.01092715f, 0.00682401f, 0.03868460f, 
    0.01835082f, -0.01869728f, 0.01852137f, -0.02090014f, 0.02533821f, 0.02191099f, -0.00468250f, -0.01763391f, 
    -0.00330405f, 0.00652264f, 0.01563844f, -0.02280872f, -0.02591883f, -0.00623212f, -0.00453491f, 0.02158176f, 
    0.03231377f, -0.00519163f, -0.03728974f, 0.00525053f, 0.02053777f, -0.01388145f, -0.00739787f, -0.01746688f, 
    0.00013779f, 0.02791701f, 0.00702845f, 0.02817151f, 0.01781747f, -0.01008449f, 0.02290060f, 0.02008247f, 
    -0.04150712f, -0.03290495f, 0.03062692f, 0.02546744f, 0.02137975f, -0.03368066f, -0.00369334f, -0.00910620f, 
    0.01306707f, -0.02073313f, 0.02394914f, -0.02530695f, -0.00752006f, 0.00121545f, -0.01633639f, 0.01767389f, 
    -0.01956390f, 0.02089660f, -0.01462085f, 0.01639021f, 0.00508026f, 0.01112714f, 0.00081811f, 0.00776902f, 
    -0.02831092f, 0.01865768f, 0.00432958f, 0.02777868f, 0.02418101f, 0.02216959f, 0.00124214f, 0.02374393f, 
    -0.04022400f, -0.02409923f, -0.02034107f, 0.01943703f, -0.03757528f, 0.01424895f, -0.02363587f, 0.03249694f, 
    -0.03947048f, 0.02848285f, 0.00069478f, -0.01941786f, 0.04004980f, 0.00517016f, -0.01901529f, 0.02077362f, 
    -0.00228101f, -0.00460209f, -0.01765846f, 0.02189418f, -0.02290893f, -0.02219700f, -0.00192504f, -0.01506451f, 
    -0.00365268f, -0.01637647f, -0.03767821f, -0.03116958f, -0.02592832f, -0.01694508f, -0.03745615f, 0.00078891f, 
    -0.03243496f, 0.01664905f, 0.02836513f, -0.02039738f, -0.02953397f, -0.02822346f, 0.00086824f, -0.01935034f, 
    0.01038308f, -0.03178201f, -0.00344729f, 0.00774713f, -0.01468324f, -0.04121464f, -0.03180023f, 0.03798206f, 
    -0.02669597f, -0.00134297f, 0.02440576f, 0.01731499f, 0.03876321f, 0.03797698f, 0.01016027f, 0.00101211f, 
    -0.01332431f, 0.00621603f, -0.00749122f, 0.01943777f, 0.02170790f, -0.03298460f, 0.00211291f, -0.00602938f, 
    0.00504763f, -0.02515819f, -0.02210772f, 0.00983997f, -0.00561248f, -0.01644752f, -0.00714968f, 0.02643580f, 
    -0.00954952f, -0.00294312f, 0.03335768f, 0.02762577f, -0.01704984f, 0.02500020f, 0.00725021f, 0.01145924f, 
    0.03309627f, -0.00361774f, -0.01997991f, -0.00150000f, 0.01694055f, 0.03339185f, -0.03535559f, 0.02579182f, 
    -0.02310975f, -0.02288846f, 0.00576045f, -0.02341555f, -0.02066271f, -0.02514133f, -0.04043617f, -0.01969013f, 
    0.01200223f, -0.01658309f, -0.00979391f, 0.02222708f, -0.01690617f, -0.03682524f, -0.00613465f, 0.00679673f, 
    0.00009059f, -0.01645905f, 0.02481743f, 0.03897361f, -0.00884363f, -0.00692030f, -0.01227522f, -0.03219207f, 
    0.00568457f, 0.02305952f, 0.01794957f, 0.00832033f, 0.00742308f, 0.01753185f, 0.00534505f, 0.02900566f, 
    -0.00359096f, -0.03145851f, -0.00536941f, 0.02777592f, 0.01556777f, -0.00823629f, -0.03026043f, -0.03812275f, 
    -0.01998183f, -0.02610999f, -0.00599424f, -0.03519898f, -0.01115129f, 0.04161255f, -0.01571912f, 0.00753253f, 
    0.00182774f, -0.02351058f, 0.01006477f, -0.01037704f, 0.02483483f, 0.00029848f, 0.00638890f, -0.03664844f, 
    0.01046572f, 0.03209039f, -0.02415611f, -0.03697057f, -0.03302436f, -0.01103890f, -0.00824341f, -0.02350236f, 
    -0.01008061f, -0.00874195f, -0.02597216f, -0.02414839f, -0.00531601f, -0.02729704f, -0.03439524f, 0.00386285f, 
    -0.00427704f, 0.01689634f, 0.02751470f, 0.02606536f, 0.02484749f, 0.03692430f, 0.02511759f, 0.02774599f, 
    -0.01397339f, -0.00788528f, -0.01022763f, -0.02612553f, -0.00528709f, -0.01288018f, 0.00337478f, -0.00657544f, 
    -0.03894877f, -0.01906408f, -0.01459603f, 0.03340007f, -0.02677082f, -0.01372746f, 0.00967734f, 0.00176702f, 
    0.03906319f, -0.00275781f, -0.00805011f, -0.00226025f, -0.00579284f, -0.00534171f, -0.00012180f, -0.00956711f, 
    -0.02721394f, -0.00075405f, -0.00743379f, -0.02947713f, -0.00042022f, -0.03495546f, 0.00438374f, -0.02046665f, 
    -0.04059859f, 0.03797300f, -0.02060295f, -0.02057034f, -0.03100987f, 0.02878054f, -0.00874702f, 0.00023487f, 
    0.00908031f, -0.00885831f, -0.02968155f, -0.00219602f, 0.00838489f, -0.03907553f, -0.00371642f, -0.02807884f, 
    0.01367815f, -0.01048874f, -0.02988003f, 0.00165036f, 0.00966934f, 0.03178558f, 0.00869966f, 0.00428257f, 
    -0.03522788f, -0.01379867f, -0.00419285f, -0.02878902f, -0.04096314f, -0.02648113f, -0.01870006f, 0.00995272f, 
    -0.02109170f, 0.02035060f, -0.00609009f, -0.01404221f, -0.01447558f, 0.03348380f, -0.02164216f, 0.00151864f, 
    -0.04199518f, -0.00136898f, -0.01818096f, 0.02880838f, 0.01887299f, -0.01291900f, 0.00208967f, 0.01072881f, 
    0.00057949f, 0.00051048f, -0.00800056f, -0.03938335f, -0.02312024f, -0.02827752f, -0.00951241f, 0.01144111f, 
    -0.03395016f, 0.01726718f, -0.00040675f, -0.03301483f, -0.01588394f, -0.02588140f, 0.00769744f, 0.02347008f, 
    -0.03131892f, -0.03371404f, 0.01481231f, 0.00639573f, 0.03288509f, 0.00299679f, 0.01699430f, -0.00469704f, 
    -0.02331829f, 0.00015640f, -0.01410570f, 0.00747456f, 0.01866418f, 0.00572743f, 0.00397296f, -0.01081241f, 
    0.02387174f, 0.00298265f, 0.01459579f, 0.00750187f, -0.01439453f, 0.00753580f, -0.03487048f, -0.03577011f, 
    -0.02830752f, 0.02811720f, -0.00048835f, -0.02282963f, 0.02062882f, 0.00060410f, 0.00340962f, -0.01030736f, 
    -0.04146234f, -0.01590038f, 0.00849456f, -0.02233906f, -0.01995737f, -0.00430987f, -0.01542335f, -0.00168544f, 
    -0.02901288f, -0.00807771f, -0.00377642f, -0.03945696f, -0.01363757f, -0.00961850f, 0.02864679f, 0.00897577f, 
    -0.02798250f, -0.03645040f, -0.01872174f, -0.01615590f, -0.02124487f, -0.00685485f, 0.03269040f, 0.02127865f, 
    -0.02372772f, 0.01952461f, -0.00466818f, -0.02186863f, -0.04168867f, 0.01855496f, 0.02594485f, -0.00563463f, 
    -0.02704562f, -0.02468446f, 0.01119515f, 0.02467503f, 0.02444892f, -0.01831848f, 0.00964628f, -0.01129659f, 
    0.04093902f, -0.03984791f, -0.02492949f, -0.01286010f, 0.01491962f, -0.01972459f, -0.02813463f, 0.02597129f, 
    0.02865218f, 0.01497230f, 0.02740866f, -0.00252280f, 0.01613082f, 0.00819322f, 0.02314802f, -0.03482940f, 
    -0.03813142f, -0.01902388f, 0.03848775f, -0.02976420f, -0.02278416f, -0.02921831f, 0.01239711f, -0.02186066f, 
    0.02295535f, -0.02242922f, -0.01356566f, 0.00092545f, -0.02076215f, -0.01869299f, 0.01738194f, -0.00224684f, 
    -0.02531320f, 0.00409441f, -0.01599858f, -0.03776683f, 0.01451021f, 0.00528747f, 0.01522081f, -0.04030643f, 
    0.02036352f, -0.02869900f, 0.04173439f, -0.01220480f, 0.03924525f, 0.00497082f, -0.03942433f, 0.01220435f, 
    0.01554214f, -0.01081264f, 0.01257823f, -0.00137526f, -0.04034575f, -0.03470678f, 0.00064751f, -0.00222423f, 
    0.01542624f, 0.02884390f, -0.01729979f, -0.00086777f, -0.02454755f, -0.02811552f, 0.02996080f, 0.01312481f, 
    -0.02518707f, -0.00643342f, -0.00284383f, -0.02362589f, 0.01614695f, 0.01707795f, -0.02372199f, -0.04121127f, 
    0.04130001f, 0.01740366f, 0.02813536f, -0.02086162f, -0.01658092f, -0.02067910f, -0.02974928f, -0.00540866f, 
    0.00092695f, 0.01106097f, 0.00137036f, 0.00415869f, 0.01917370f, 0.00507429f, -0.03710493f, -0.00312819f, 
    -0.01052805f, -0.00541204f, -0.02130976f, -0.02479574f, -0.01276024f, 0.02453977f, -0.03766700f, 0.00997769f, 
    0.02744700f, 0.00161048f, 0.00082343f, 0.01566533f, 0.00653210f, -0.01266960f, 0.00197177f, 0.00722113f, 
    -0.01483528f, -0.02759653f, 0.00945180f, 0.02665332f, -0.02060059f, 0.00037908f, -0.00528354f, 0.02580711f, 
    -0.00527061f, 0.02347953f, 0.00163053f, -0.02980953f, -0.02820174f, -0.01058969f, 0.03956050f, -0.00324852f, 
    0.01813850f, -0.01978423f, -0.02798166f, -0.03664730f, -0.00195021f, -0.02964107f, 0.03331017f, -0.02757417f, 
    0.01231904f, -0.01679652f, -0.00389432f, -0.00670626f, -0.02961507f, -0.00251271f, 0.02704774f, -0.00939291f, 
    0.00179756f, -0.00896149f, 0.01383121f, -0.00212561f, -0.01345494f, -0.03818900f, -0.01024311f, -0.01514646f, 
    0.03818616f, 0.00835528f, 0.00443191f, -0.03470544f, 0.02411273f, -0.00846614f, 0.01844844f, -0.02976130f, 
    0.01824046f, 0.01354078f, 0.00664072f, 0.02623987f, -0.00083950f, -0.00418117f, -0.03475527f, -0.02112584f, 
    -0.01003049f, -0.02197199f, 0.00882285f, 0.01263528f, 0.02555964f, -0.04071497f, -0.01015682f, -0.00435473f, 
    0.01194435f, -0.00254818f, -0.01999501f, -0.02076206f, 0.02864040f, 0.02988608f, -0.01807308f, 0.01149642f, 
    0.02390832f, 0.02007269f, -0.02185662f, 0.00895356f, -0.02210200f, -0.01702270f, 0.02844963f, -0.02221381f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03799658f, 0.02119951f, 0.05092084f, 0.02460190f, -0.00615436f, -0.00513660f, 0.01414491f, -0.03863608f, 
    0.00369941f, 0.02293171f, -0.02331545f, 0.04990911f, -0.01170577f, 0.01575283f, -0.01105635f, -0.01062139f, 
    0.02418228f, -0.02111943f, -0.00575450f, 0.01784608f, -0.01991925f, -0.00029727f, 0.04406091f, 0.00337971f, 
    -0.00523805f, -0.03439831f, 0.01699941f, 0.03209671f, 0.12262196f, 0.00617138f, 0.02813833f, -0.01582626f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.16415863f, 0.13357638f, -0.14898199f, -0.04322684f, -0.17474711f, -0.15847780f, -0.06854866f, 0.01581350f, 
    -0.09922451f, 0.03075721f, -0.15854348f, -0.08559732f, 0.01909027f, 0.15654260f, 0.04742085f, -0.01338127f, 
    -0.16709733f, -0.07948957f, -0.14199671f, -0.16459957f, 0.00319992f, -0.03352238f, 0.03574649f, 0.03735475f, 
    0.16859730f, 0.10437416f, 0.11252873f, 0.14694966f, 0.04302266f, 0.00840891f, 0.04079484f, -0.14330031f, 
    0.04008679f, -0.12706508f, 0.33841965f, -0.00007862f, -0.16102085f, 0.42505038f, -0.00087332f, 0.07012587f, 
    -0.11866946f, 0.05224651f, -0.07459535f, -0.33023387f, 0.14102377f, -0.03474578f, 0.12865473f, -0.08317843f, 
    -0.11565329f, 0.07459842f, 0.13840093f, -0.00788303f, -0.09471206f, -0.09063097f, 0.25699872f, 0.03914894f, 
    0.15105380f, -0.03911170f, 0.05804872f, 0.05598793f, 0.01774871f, 0.01482549f, -0.17953305f, 0.13629431f, 
    -0.26693761f, -0.09944399f, -0.11324696f, -0.12272459f, -0.15848336f, 0.19855732f, 0.27436841f, 0.31454042f, 
    0.20997460f, -0.15377171f, 0.07972567f, -0.20577231f, -0.00440405f, -0.00483030f, 0.03201889f, 0.12494338f, 
    -0.34758589f, -0.05375244f, 0.08546109f, 0.30788168f, -0.14852324f, -0.01133483f, -0.20148857f, -0.01972300f, 
    0.15114959f, 0.01086382f, 0.24299209f, 0.18449765f, -0.10151369f, 0.14862956f, 0.02006562f, 0.12892026f, 
    -0.05740234f, -0.18021736f, 0.12545668f, 0.07827947f, -0.12928268f, 0.29397368f, -0.12055691f, 0.03819525f, 
    -0.48082817f, -0.09097807f, -0.07861739f, 0.02861167f, 0.11464874f, 0.16213509f, 0.01961349f, 0.07898102f, 
    0.60836375f, -0.11478352f, -0.09691890f, 0.14510420f, 0.15006478f, -0.16715586f, -0.00573699f, -0.15024981f, 
    0.07160825f, 0.14321657f, -0.06429329f, 0.38387400f, 0.07981316f, 0.13354869f, 0.13179705f, 0.13606510f, 
    0.19059281f, -0.11389958f, 0.39266121f, -0.04304493f, 0.16326104f, -0.21144290f, 0.12414800f, 0.17926405f, 
    0.06374457f, -0.11854918f, -0.13840668f, -0.21238217f, -0.11859920f, -0.05775251f, -0.10053005f, 0.02318163f, 
    -0.27988890f, -0.06905094f, -0.09926349f, 0.15100504f, -0.00436179f, 0.01355009f, 0.24460319f, 0.12324154f, 
    0.01686992f, 0.13826767f, 0.14366624f, -0.03378735f, 0.34736925f, 0.11733489f, 0.00529927f, 0.16918470f, 
    0.16086654f, -0.10319927f, -0.12226415f, 0.10890368f, -0.07417941f, -0.05354724f, -0.17268212f, -0.08986941f, 
    0.00995152f, 0.09807020f, -0.00395588f, -0.12745303f, 0.03088352f, 0.04833266f, -0.12945041f, 0.03876848f, 
    0.15898061f, 0.16984555f, -0.09028974f, 0.01044700f, 0.13392067f, 0.11976016f, -0.13947283f, 0.05338868f, 
    0.13310577f, -0.10522328f, 0.01395940f, 0.09307210f, -0.04092410f, 0.04396517f, 0.08895864f, 0.07616932f, 
    0.20612262f, 0.17277995f, -0.09806666f, -0.02911391f, -0.17008989f, -0.33078134f, -0.37373745f, 0.24815913f, 
    0.29170603f, -0.06233850f, 0.09985753f, 0.16955692f, -0.03134882f, 0.09690215f, 0.17192818f, -0.14631341f, 
    -0.02516151f, 0.04116484f, 0.12112652f, 0.38686523f, -0.14778118f, 0.12833853f, 0.12606271f, 0.09959859f, 
    0.14929745f, 0.15598942f, -0.18346590f, -0.23048024f, 0.05777402f, 0.05683015f, 0.13349354f, -0.15435156f, 
    -0.03619093f, -0.01054261f, 0.32084462f, 0.08413702f, 0.03502335f, 0.30260456f, -0.09007641f, 0.22132534f, 
    -0.36099279f, -0.02669128f, 0.13781966f, -0.31633076f, -0.10768669f, 0.11399391f, -0.13291050f, 0.14256133f, 
    -0.21735764f, 0.01836555f, 0.05607077f, 0.03306120f, 0.10384307f, 0.05490632f, -0.05347762f, -0.06154333f, 
    0.14438131f, 0.07212747f, 0.22359464f, -0.00161594f, 0.21452618f, -0.02680251f, -0.02196822f, 0.00794685f, 
    -0.06347610f, -0.03460720f, -0.17148371f, -0.06004910f, 0.02596945f, 0.08869533f, 0.02178278f, 0.23791188f, 
    0.17168891f, -0.16188124f, 0.02078800f, -0.14816053f, -0.11575785f, -0.07760670f, 0.03768314f, 0.14520855f, 
    0.09358100f, 0.13541651f, -0.10136995f, 0.17707899f, 0.07461613f, 0.12358577f, 0.39225608f, -0.17168236f, 
    0.01556761f, -0.11948396f, -0.12843788f, -0.42234427f, 0.05532786f, -0.17377108f, 0.05764058f, 0.05094014f, 
    0.45558584f, -0.12327171f, -0.17157350f, -0.03561180f, 0.12389461f, -0.07122187f, 0.17672336f, 0.06928404f, 
    -0.27304766f, 0.03514878f, 0.15815195f, 0.06492550f, -0.04836813f, 0.06128708f, -0.08679372f, 0.03972535f, 
    0.00584955f, 0.04923073f, 0.16322875f, 0.31508869f, 0.17251344f, -0.09031226f, 0.11719752f, -0.00745123f, 
    0.12153252f, -0.16873243f, -0.24586339f, 0.08779462f, 0.31981310f, 0.13049050f, -0.05786797f, -0.16517067f, 
    0.27107802f, -0.04426081f, -0.23692811f, -0.17117116f, -0.02200792f, 0.01337249f, -0.10756521f, -0.09465528f, 
    0.28954858f, -0.00555021f, -0.08757495f, 0.23019773f, -0.00994442f, -0.03749428f, -0.03093075f, -0.01918322f, 
    -0.10331100f, -0.08082608f, -0.01119452f, -0.22194825f, -0.07838429f, -0.05400958f, -0.13011344f, -0.07256764f, 
    0.14028877f, -0.03450934f, 0.10956835f, -0.22538103f, 0.02029986f, -0.07341655f, 0.10626969f, 0.00443994f, 
    0.06766830f, -0.01676283f, 0.27627498f, 0.10039541f, -0.00222288f, 0.15733774f, 0.28413072f, -0.21950440f, 
    -0.15408845f, -0.06742783f, -0.16272324f, -0.00760823f, 0.14985497f, -0.02366396f, -0.00607985f, -0.11912967f, 
    0.01891069f, -0.00184538f, -0.07075753f, -0.16225035f, -0.10125551f, -0.15238543f, 0.33572084f, -0.14102788f, 
    -0.07909144f, -0.05030863f, -0.07002112f, 0.32550770f, 0.22631770f, 0.00829184f, -0.05690788f, 0.03933639f, 
    0.03933381f, 0.02806778f, 0.13316518f, -0.05171980f, 0.04754624f, 0.24908164f, -0.29183158f, -0.11789613f, 
    0.12389121f, 0.01206919f, -0.14668083f, 0.01538856f, -0.15363117f, 0.05316711f, 0.12859784f, 0.05959211f, 
    -0.14248993f, -0.04589859f, 0.00083083f, -0.02483007f, 0.07358798f, 0.14363308f, -0.19681852f, 0.09468254f, 
    0.07839017f, -0.02741813f, 0.44049466f, 0.37334186f, 0.15005517f, 0.16421078f, 0.12212575f, 0.01150004f, 
    0.26976401f, -0.03549840f, 0.18355700f, 0.03022025f, 0.05657776f, 0.31852412f, -0.03760726f, -0.11411352f, 
    0.00794196f, 0.15742008f, 0.09388093f, -0.15596242f, -0.15414651f, 0.03778402f, 0.12248760f, -0.04992928f, 
    0.29033202f, 0.03595835f, 0.07538565f, 0.48103079f, 0.17237040f, 0.13758881f, 0.05901974f, 0.08362572f, 
    -0.16807744f, -0.00743848f, -0.27712232f, 0.46060559f, 0.07535739f, -0.03033661f, -0.17778517f, -0.14807448f, 
    -0.14156671f, 0.03954308f, 0.11402213f, -0.05403702f, -0.00220568f, -0.01981110f, -0.06203087f, -0.14312823f, 
    0.07733236f, 0.11309396f, -0.14256014f, -0.03536684f, 0.16884665f, -0.11348055f, -0.17589067f, -0.02772618f, 
    -0.03193107f, -0.13408716f, 0.05396276f, 0.07874654f, -0.02590168f, -0.04112045f, -0.14704721f, -0.03348035f, 
    0.12624149f, -0.05709746f, -0.07662364f, 0.04068607f, -0.08479784f, 0.12646163f, 0.07019082f, 0.17321834f, 
    0.40136474f, 0.02262909f, -0.07846574f, 0.11267045f, 0.00298649f, 0.29032585f, 0.39615974f, 0.05914818f, 
    0.01030107f, -0.09952889f, 0.00173248f, 0.09907547f, -0.09094198f, -0.07523020f, -0.14888866f, 0.11729114f, 
    0.12380069f, 0.12334280f, -0.07920136f, -0.01901816f, 0.15189651f, -0.00497080f, 0.22619624f, -0.15709420f, 
    -0.01369821f, 0.08219328f, -0.42313316f, -0.17530119f, -0.02578827f, 0.13266566f, -0.16906612f, 0.11516557f, 
    0.07867799f, -0.14783086f, -0.13628832f, 0.00594224f, -0.09747801f, 0.10709676f, -0.29814517f, -0.12012947f, 
    0.29899785f, 0.15255420f, 0.04260200f, 0.31389502f, -0.08112771f, 0.09601180f, -0.08547173f, -0.11750451f, 
    0.25578254f, 0.05954108f, 0.04102394f, -0.15044285f, -0.04562272f, -0.14670277f, -0.30561557f, -0.10937314f, 
    -0.16492370f, -0.11337406f, 0.30216062f, -0.08016709f, -0.27187636f, -0.11471875f, 0.05915415f, -0.14985126f, 
    -0.03722367f, -0.10806460f, 0.10903301f, 0.04451887f, -0.11209464f, 0.16374217f, -0.13771746f, -0.12193856f, 
    -0.07618342f, -0.14803056f, 0.13381961f, -0.04590632f, 0.04747511f, 0.01892151f, 0.01425132f, 0.11713001f, 
    -0.06439371f, 0.10424397f, -0.16348229f, 0.07883233f, -0.08723555f, -0.02873734f, -0.08486938f, -0.08146971f, 
    0.06587525f, 0.10252185f, 0.00750498f, 0.00112427f, -0.16597454f, -0.14221193f, 0.14599736f, 0.06720300f, 
    -0.11291339f, 0.02884562f, 0.40103599f, 0.02178557f, 0.04308705f, -0.24295515f, 0.11413628f, -0.07712145f, 
    0.00765952f, 0.11272442f, 0.05065528f, 0.27015710f, 0.14056680f, -0.02302635f, -0.05696527f, -0.16850767f, 
    0.01720561f, -0.08865494f, -0.10942168f, -0.26490498f, 0.01822704f, 0.02093141f, 0.35292688f, 0.00792236f, 
    0.09710395f, -0.14267361f, -0.06503948f, -0.22186397f, 0.39641586f, 0.01381494f, 0.06034819f, -0.14911164f, 
    -0.15774094f, -0.05833697f, -0.02900572f, -0.09174171f, 0.08155528f, 0.19368802f, 0.31594124f, -0.10781250f, 
    0.54622722f, 0.12952802f, 0.09420986f, 0.14559330f, -0.10554510f, -0.02796599f, 0.13905066f, 0.15251562f, 
    -0.32284215f, 0.02029861f, -0.03575313f, -0.06642317f, -0.17186628f, 0.04925955f, 0.34357387f, 0.08431350f, 
    -0.01959470f, -0.13066214f, 0.23986627f, 0.14653422f, -0.18650207f, -0.11090269f, 0.00564411f, 0.15573132f, 
    -0.11552574f, -0.00179223f, -0.01254457f, 0.07908360f, 0.05530796f, 0.03342541f, -0.17373239f, -0.07985383f, 
    -0.03200107f, -0.00745885f, 0.04118910f, -0.17586927f, -0.09667855f, -0.15060499f, 0.03146611f, -0.14716904f, 
    0.02618741f, 0.12888619f, 0.07765845f, 0.03809695f, 0.14540021f, -0.09775067f, 0.10927413f, 0.13126099f, 
    0.00825366f, 0.12262472f, -0.01810999f, 0.01311524f, 0.09864980f, -0.05122030f, 0.00571893f, -0.13354431f, 
    -0.33278599f, -0.14215554f, 0.18704762f, -0.06805074f, -0.06186970f, -0.21577339f, -0.21059269f, 0.03911354f, 
    0.33148685f, -0.15618840f, -0.04389421f, 0.11620910f, 0.01723067f, -0.12292339f, -0.10792112f, -0.05005977f, 
    0.29060024f, 0.03425737f, -0.16190836f, 0.35080788f, -0.11650464f, 0.14208433f, -0.28994414f, -0.00284685f, 
    -0.01114970f, 0.09974904f, 0.26847652f, 0.39411923f, -0.12641130f, -0.04548429f, 0.10835085f, -0.02616904f, 
    -0.14013457f, -0.04789995f, -0.14789896f, -0.01624734f, 0.11754783f, -0.05082534f, -0.04191650f, 0.04035126f, 
    -0.10288336f, 0.06355561f, -0.05807987f, -0.13711615f, 0.05068754f, -0.02460204f, 0.04664447f, 0.09440186f, 
    0.13525732f, -0.07991068f, -0.01690691f, -0.17094104f, 0.04471093f, 0.12450563f, -0.07173546f, 0.14556481f, 
    0.10124545f, 0.14435734f, 0.10337848f, 0.02685748f, 0.05373479f, 0.14691713f, 0.16511329f, 0.10142040f, 
    -0.23110986f, -0.15029693f, 0.02679994f, 0.13277808f, 0.10298462f, -0.37473437f, 0.12842205f, -0.01906876f, 
    0.15942115f, -0.04629882f, -0.14337862f, 0.19065398f, 0.02093417f, 0.11223295f, 0.00933553f, 0.05666151f, 
    -0.06338820f, 0.15682407f, -0.11615015f, 0.01786768f, -0.03082343f, -0.10057959f, -0.26304770f, 0.04679531f, 
    -0.02206102f, -0.14525330f, 0.29619709f, 0.15463868f, 0.30171862f, 0.13460256f, -0.13300772f, -0.10814225f, 
    0.08355379f, -0.15235111f, 0.36265093f, -0.06813515f, -0.16129632f, -0.10156785f, 0.10014504f, -0.30773664f, 
    0.29039222f, -0.16122560f, -0.12930243f, -0.02601255f, 0.15055676f, -0.16733307f, 0.04424769f, -0.00581854f, 
    0.17739126f, 0.07971161f, 0.07598326f, -0.01407403f, -0.11320541f, -0.15846559f, 0.39008236f, -0.03680906f, 
    -0.08623121f, 0.05876931f, 0.11020657f, 0.29772747f, 0.19304353f, 0.06290568f, 0.05279046f, -0.10912535f, 
    -0.05653447f, 0.04060830f, -0.10999157f, -0.12282483f, 0.10379837f, 0.00902044f, -0.08186538f, -0.17446186f, 
    -0.01376761f, 0.12143390f, -0.10673211f, -0.01508746f, -0.13849145f, -0.00838233f, 0.08303805f, 0.01637144f, 
    -0.10285022f, 0.12164405f, 0.14598164f, -0.01242771f, -0.12454911f, 0.16982810f, 0.14131188f, 0.14472869f, 
    0.14693367f, -0.12668455f, 0.04436003f, 0.03523502f, 0.05987697f, 0.08140682f, -0.02340027f, -0.03871420f, 
    0.07159151f, 0.10005865f, -0.16258268f, -0.11198959f, 0.10221035f, -0.16009876f, 0.34811392f, 0.20900352f, 
    -0.28697765f, -0.12714705f, -0.07275897f, 0.24975674f, 0.15186982f, 0.06257767f, 0.05615671f, 0.06743410f, 
    -0.13547489f, 0.03797937f, 0.17266031f, 0.20274812f, -0.04863160f, 0.07924455f, -0.45553035f, 0.00863011f, 
    -0.11502120f, 0.15693340f, 0.12995809f, 0.04920329f, -0.11179382f, 0.16934715f, 0.04404786f, -0.11077985f, 
    0.35871607f, 0.01092748f, -0.22382200f, 0.13464656f, 0.03079947f, 0.35728070f, -0.14056760f, 0.23225309f, 
    0.06940276f, 0.10164852f, -0.07072029f, -0.11447276f, -0.06106551f, -0.15810269f, 0.03810875f, 0.00942024f, 
    -0.13262835f, -0.07991956f, 0.15218434f, -0.15072778f, -0.16410150f, -0.05584591f, 0.28123462f, -0.12075986f, 
    -0.06423309f, 0.13062561f, 0.07858654f, -0.35264045f, 0.13304581f, -0.05813831f, 0.06678420f, 0.04638345f, 
    0.10067745f, 0.00043967f, -0.08079372f, 0.12925130f, -0.12130056f, -0.19109043f, 0.02214456f, -0.01664756f, 
    -0.07130110f, 0.03720515f, -0.13149650f, 0.29285154f, 0.00372544f, 0.02805765f, 0.11848576f, -0.13610119f, 
    0.16914710f, 0.00475435f, 0.09773095f, -0.22270912f, 0.10651471f, 0.12015959f, 0.32014015f, 0.01035743f, 
    -0.10048653f, 0.05674192f, 0.16915432f, -0.09964178f, 0.05043141f, -0.05324901f, -0.03635489f, -0.05301871f, 
    -0.15966558f, -0.17566355f, 0.36485469f, 0.13501069f, 0.04778141f, 0.00401624f, -0.10003868f, 0.08795352f, 
    0.30685306f, 0.03219169f, -0.10642716f, -0.18420951f, -0.09844218f, 0.17526938f, 0.06382065f, 0.08253516f, 
    0.32499757f, -0.09656311f, 0.09759101f, -0.18235435f, 0.11376665f, -0.00437937f, 0.32558113f, 0.01235937f, 
    -0.13709436f, 0.07982747f, 0.22195311f, -0.00382528f, 0.04724076f, -0.01447191f, 0.03297673f, -0.14268263f, 
    -0.22367443f, 0.17228822f, -0.13389452f, -0.10406497f, 0.11043804f, 0.30816168f, 0.05654685f, 0.35004801f, 
    0.27545828f, -0.03685025f, -0.15735215f, -0.08826444f, 0.14569037f, -0.06689963f, -0.08510695f, 0.04072742f, 
    -0.29266042f, -0.12959315f, -0.09155139f, 0.24221049f, -0.04813499f, 0.17004716f, -0.03484708f, 0.08555469f, 
    0.07926276f, -0.15829645f, 0.03480163f, 0.14727516f, -0.35276103f, -0.00839450f, -0.02131414f, -0.12214146f, 
    -0.05440295f, 0.13900402f, 0.30949435f, -0.04485658f, 0.15835537f, -0.12067597f, -0.11043913f, 0.36096168f, 
    -0.02697480f, -0.13234915f, -0.03479955f, 0.06854167f, -0.04143882f, -0.17983663f, 0.14047441f, -0.00534628f, 
    0.51502353f, 0.02335417f, -0.07089901f, -0.18311991f, 0.11527397f, 0.15489791f, -0.16426766f, -0.01434504f, 
    0.01495872f, -0.05836175f, 0.03640200f, -0.21764268f, -0.12061747f, -0.01917980f, -0.01736353f, -0.00431006f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.15297225f, -0.11148192f, 0.07277455f, 0.22527801f, -0.02849552f, -0.11189030f, -0.05249023f, 0.04954671f, 
    -0.15836415f, 0.22921485f, -0.05799196f, 0.15127718f, -0.14013498f, 0.26003921f, -0.02373881f, -0.06780156f, 
    0.18548170f, -0.13210876f, 0.16204764f, -0.01707012f, -0.14972645f, -0.17651387f, -0.11273360f, 0.22294872f, 
    0.13727836f, 0.11744271f, 0.18319136f, 0.19320567f, 0.00907243f, -0.11114433f, -0.09726676f, -0.08523304f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.04459492f, -0.36233333f, 0.44118294f, -0.18874872f, -0.09403341f, 0.11657765f, -0.13856688f, 0.12812389f, 
    -0.04870551f, -0.07418247f, -0.54505885f, -0.23422463f, 0.06233742f, -0.03423221f, -0.06625076f, -0.30685237f, 
    -0.17033209f, -0.11006582f, -0.44564146f, 0.16909547f, 0.03803475f, 0.18606758f, -0.14831536f, 0.12614928f, 
    -0.28601789f, -0.16492392f, 0.31237626f, -0.06886804f, -0.20459075f, -0.35246000f, 0.49339339f, -0.21341035f, 
    0.13422474f, 0.37745050f, 0.18298605f, -0.12726516f, 0.19633256f, 0.04344902f, 0.07550186f, 0.43930343f, 
    0.12729469f, -0.04610698f, 0.31852964f, -0.09729181f, 0.02425874f, 0.15595149f, -0.17973609f, 0.14506507f, 
    0.18216328f, 0.09840848f, -0.40244746f, 0.07493361f, -0.17415173f, -0.06776923f, -0.04474132f, -0.44828123f, 
    -0.02508681f, 0.07385673f, -0.32157764f, 0.35788298f, -0.36609069f, -0.10340373f, 0.04544155f, -0.25947273f, 
    0.15659887f, -0.53775543f, 0.06439066f, -0.21236567f, 0.02933713f, 0.13903864f, 0.29780635f, -0.28288588f, 
    0.31696513f, 0.30602905f, -0.15723625f, -0.33372530f, -0.54655594f, -0.02127524f, 0.02349795f, 0.23140924f, 
    -0.39358398f, -0.16853411f, -0.12999965f, -0.16337283f, 0.11472484f, -0.39615414f, -0.06485420f, -0.33506370f, 
    -0.32650873f, -0.05685227f, 0.23991607f, 0.28860497f, 0.01551951f, -0.31058580f, 0.21202669f, 0.13471602f, 
    -0.03541414f, -0.33850554f, 0.19466357f, -0.63707417f, 0.21492431f, 0.08132515f, -0.09598903f, -0.64681041f, 
    -0.32602933f, -0.34994707f, -0.02515268f, -0.25643438f, -0.11450701f, -0.52346182f, -0.17465957f, -0.16109249f, 
    0.08637227f, 0.12010673f, 0.20173275f, 0.23647591f, -0.16985710f, 0.09123410f, -0.13132353f, 0.34459385f, 
    0.01099217f, -0.09883754f, 0.26832774f, -0.31952044f, -0.10010885f, 0.17795637f, -0.10946686f, 0.15839866f, 
    0.00893711f, -0.92081702f, 0.11696873f, 0.00423557f, -0.08564129f, 0.07399090f, 0.26958165f, -0.57088965f, 
    0.11121538f, -0.11857799f, -0.20459093f, -0.28628150f, 0.08825392f, 0.13407937f, -0.16806716f, -0.38175038f, 
    0.19255239f, 0.09747352f, -0.24671787f, 0.02998958f, 0.01771931f, 0.35478967f, -0.00071778f, -0.00425916f, 
    0.20888253f, -0.06386960f, -0.16230179f, -0.27310050f, -0.07653141f, 0.17839901f, 0.10528191f, -0.10757262f, 
    -0.14205313f, -0.00428873f, 0.05961087f, 0.28123751f, 0.01966282f, -0.01094927f, -0.61422509f, 0.31170818f, 
    -0.41713500f, -0.12314481f, -0.13609220f, 0.21573247f, 0.28481582f, 0.07440794f, 0.00822765f, -0.26067355f, 
    -0.00596242f, 0.04985717f, -0.13057083f, -0.19265534f, -0.06643347f, -0.00399273f, -0.10650849f, -0.15961143f, 
    0.15889309f, -0.06818720f, -0.04575204f, -0.10062709f, -0.11362731f, 0.17875797f, -0.12058143f, 0.22843294f, 
    -0.05723944f, -0.66675055f, -0.08354913f, -0.02963784f, 0.20933023f, 0.14320500f, 0.36190295f, 0.13283089f, 
    0.26064047f, 0.09273881f, -0.22202989f, -0.24096860f, -0.15258652f, -0.00643517f, 0.03270599f, -0.26909015f, 
    -0.32116681f, -0.02233787f, 0.33170551f, -0.54158753f, 0.16846125f, 0.01817192f, 0.16112489f, 0.02642930f, 
    -0.06308760f, -0.02142413f, -0.26655567f, 0.19322392f, 0.13099596f, 0.12629211f, -0.40227464f, 0.35492721f, 
    -0.13856408f, -0.13796477f, -0.35940275f, -0.18726383f, -0.64353245f, -0.12593479f, 0.14555828f, 0.05465646f, 
    -0.08917592f, -0.55120695f, 0.17590052f, -0.51232767f, 0.16116491f, -0.25493735f, 0.08550357f, -0.17232320f, 
    0.43909660f, 0.16417655f, 0.03897010f, 0.06323388f, -0.00971329f, 0.20076038f, 0.14723209f, -0.02651440f, 
    -0.16040400f, -0.01348428f, 0.06829831f, 0.11486765f, 0.18796989f, -0.11912932f, 0.08867191f, 0.29377684f, 
    -0.04420425f, 0.13225587f, 0.02197446f, 0.12059397f, -0.19579910f, 0.00345869f, -0.34085247f, -0.42625916f, 
    0.28473586f, -0.24605419f, -0.39713594f, 0.05615184f, -0.51194268f, 0.09504391f, -0.06253323f, 0.24704647f, 
    -0.09592813f, 0.02433070f, 0.12790833f, 0.19076020f, -0.11401121f, -0.03938327f, -0.16172147f, -0.47312286f, 
    0.06842647f, 0.11121965f, -0.61295497f, 0.10404370f, -0.06681582f, 0.33300173f, 0.17876016f, 0.32525757f, 
    0.01963489f, -0.83034760f, -0.01807459f, 0.35659921f, -0.28211057f, 0.06577615f, 0.01322641f, -0.47813672f, 
    -0.24882643f, 0.26022127f, -0.25620583f, -0.14170308f, -0.22726540f, 0.21403264f, -0.05809337f, 0.16268139f, 
    0.13612393f, -0.08113155f, -0.29632622f, -0.38856506f, 0.08544740f, 0.11370087f, 0.11723973f, 0.01890241f, 
    -0.15836923f, 0.09196359f, 0.34764466f, -0.29150534f, 0.04573107f, -0.49030331f, -0.20311353f, 0.15141700f, 
    -0.12053394f, -0.41739392f, -0.23856704f, -0.29409188f, -0.10837974f, -0.03091685f, -0.28915304f, -0.36547875f, 
    0.07977550f, 0.02425040f, 0.14962512f, 0.04974839f, -0.04296819f, -0.17676419f, -0.03611520f, -0.00205612f, 
    0.05951511f, -0.17551717f, 0.24089248f, 0.24798846f, 0.02575014f, -0.33545533f, 0.18189409f, 0.02700331f, 
    0.16650628f, 0.00249179f, -0.06756594f, 0.38341933f, 0.30927181f, -0.03840916f, -0.59285903f, -0.49880809f, 
    0.14917065f, -0.59102356f, -0.14814876f, -0.12985396f, 0.10677362f, 0.12874284f, 0.03876619f, -0.55677837f, 
    -0.37123728f, 0.20487738f, -0.31731626f, 0.39383927f, -0.06908650f, 0.26551425f, 0.06716138f, 0.01014062f, 
    -0.53568637f, -0.04370655f, 0.24913262f, 0.11429234f, 0.14262654f, 0.05320632f, -0.14346141f, 0.08663040f, 
    0.31356663f, -0.01729159f, -0.16791263f, -0.55564219f, 0.02529597f, -0.22335345f, -0.40700722f, -0.48826823f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.00370334f, -0.01004500f, 0.12751636f, 0.02261613f, -0.01731604f, 0.10723248f, 0.13644493f, 0.05388407f, 
    -0.17292383f, 0.17172445f, -0.07917891f, -0.08105417f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
