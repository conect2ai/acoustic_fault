#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.68226177f, -0.62162471f, -0.34426537f, -0.96658921f, -1.13743937f, -0.89567095f, 0.22605132f, 0.45183936f, 
    0.18924659f, -0.30986235f, -0.96228665f, 1.36206758f, -0.83541542f, -1.15697873f, 0.23937295f, 0.63830149f, 
    -0.62607777f, -0.32884705f, -0.94456214f, -0.95147461f, -0.78350002f, 0.53188294f, -0.19575496f, 0.71311796f, 
    0.40817180f, -0.09604666f, 0.03951294f, -0.85179383f, -0.21237440f, 0.43193197f, 0.94723898f, -0.53527004f, 
    -0.54172826f, -0.25777423f, 0.41110665f, 0.22085837f, 0.09943801f, 0.85451007f, 0.34234276f, -0.09842727f, 
    -0.54912829f, -0.20789468f, 0.21206783f, -0.66767687f, -0.25051835f, -1.08490443f, -0.60467786f, -0.53474629f, 
    0.31003663f, 0.79594421f, 0.57539153f, 0.23721451f, 0.35144240f, -0.14759549f, -0.24479926f, 0.47752592f, 
    0.28729919f, -0.79614788f, 0.08497797f, 0.18364850f, 0.24166945f, 0.12345856f, -0.00993116f, 0.10638253f, 
    -0.39256546f, -0.51313001f, -0.33312699f, 0.04668792f, 0.13164002f, 0.33011305f, 0.35292351f, 0.45704845f, 
    -0.81272757f, 0.01573039f, -0.82705677f, -0.52147609f, 0.74663031f, 0.24915847f, -0.35473257f, -0.01173723f, 
    -0.16568883f, -0.00644374f, -0.90599734f, -0.34566602f, -0.27816579f, -1.00520277f, -0.85022140f, -0.22126809f, 
    0.03954953f, 0.08318898f, -0.10219926f, 0.37092090f, -0.04767272f, 0.38623312f, 0.72119147f, -0.03946076f, 
    -0.13673113f, 0.16983368f, 0.01776732f, 0.31106311f, 0.40006259f, -0.05579702f, -0.92484361f, 0.88875169f, 
    0.27326846f, -0.33402267f, -0.54032069f, 0.01695680f, 0.30576015f, 0.48066652f, -0.67441493f, -0.05530240f, 
    -0.67181849f, -0.44270232f, -0.77840096f, -0.45497301f, -1.01135266f, 0.07406152f, -0.86347139f, 0.85921431f, 
    0.86468273f, 0.44239268f, -0.46572199f, -0.42690516f, -0.18976521f, -0.70764470f, 0.78087533f, 0.36961657f, 
    0.65373421f, 0.26103252f, -0.76443869f, -0.71138912f, -0.33183318f, -0.38529533f, -0.10870953f, 0.08021730f, 
    1.19228482f, 0.17825042f, -0.85415244f, -0.92487556f, -0.08853098f, -0.13707116f, 0.36958840f, 0.48980653f, 
    0.64881009f, 0.39012146f, -0.92513871f, -0.02154472f, -0.33185071f, 0.22144049f, 0.50429738f, -0.38072315f, 
    0.08887994f, 1.25685608f, -0.67475027f, -1.03408706f, 0.73556364f, 0.19868504f, 0.24481143f, -0.49024847f, 
    0.58924484f, -0.35058302f, -1.02416682f, -0.64648253f, -0.70706391f, 0.22022034f, 0.34095475f, 0.11256658f, 
    -0.53977591f, -0.69830042f, -0.52934206f, 0.38100266f, 0.62159252f, 0.30016091f, -0.48087031f, 0.03920936f, 
    0.39602378f, -0.24959168f, 0.04347498f, 0.28017265f, -0.31219292f, -1.04772401f, -0.63907534f, 0.22472994f, 
    0.78101707f, -0.02921474f, 0.21686913f, 0.16355012f, 0.10333789f, 0.30445176f, -0.09622442f, -0.17984398f, 
    0.46346056f, -0.05278634f, 0.57965785f, -0.40962279f, -0.21511565f, 0.04395286f, 0.35023212f, -1.15129709f, 
    -0.08657925f, -0.24998857f, -0.27035522f, -0.46503514f, -0.45226327f, 0.33610246f, -0.55557048f, -1.37496936f, 
    -1.20082831f, 0.08573432f, 0.78744256f, -0.55923092f, -0.87695992f, -0.06368762f, -0.56548786f, -0.10303237f, 
    0.45017931f, 0.33648744f, 0.11819859f, -0.17225260f, 0.30041641f, -0.02612518f, -0.33610171f, 0.50056851f, 
    0.36079639f, 0.05344629f, -0.68890804f, -0.23808032f, 0.11651015f, -0.30398977f, 0.09190512f, 0.30417359f, 
    -0.14695756f, 0.62667507f, -0.76111132f, -0.12327267f, 0.68549728f, -0.48043659f, -0.44899681f, 1.00592256f, 
    -0.50148475f, 0.18402511f, 0.26925036f, 0.22488798f, 0.56270522f, -0.35085919f, 0.53033304f, -0.53654361f, 
    -0.11097062f, 0.14838447f, -0.17493133f, 0.02566529f, -0.91994417f, -0.45599192f, 0.88506150f, -0.64322615f, 
    -0.30881974f, 0.39493603f, 0.24176158f, 0.54651386f, -0.11708817f, 0.98687840f, -0.64262766f, -1.21071851f, 
    0.86298627f, 0.87971270f, -0.14715156f, -0.43582681f, -0.27982241f, -0.06759093f, -0.32346818f, 0.63480800f, 
    -0.45058912f, -0.72281998f, -0.51790917f, -0.34603289f, 0.34148818f, -0.53200495f, 0.54621667f, -0.14384960f, 
    0.26180300f, 0.05734835f, -0.07667734f, -0.43711913f, 0.60814250f, 0.41640311f, -0.43782800f, 0.02451603f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.19574234f, 0.13018456f, 0.12436001f, 0.10575297f, 0.08335177f, 0.12900975f, 0.17593418f, -0.08035970f, 
    0.15919887f, 0.14761746f, 0.22606684f, 0.18085614f, -0.04369289f, -0.04122237f, 0.01550337f, 0.09638809f, 
    0.21562785f, 0.05815496f, -0.35319495f, -0.19129616f, 0.36726418f, 0.10578685f, 0.27211794f, -0.08130492f, 
    -0.15628448f, 0.12331381f, 0.42246601f, 0.34280410f, 0.04608541f, 0.20268533f, 0.16757393f, 0.15816480f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.37684220f, 0.39521605f, 0.05211974f, -0.43124419f, -0.27961835f, 0.15971841f, 0.11594126f, 0.12931281f, 
    0.03712110f, 0.12133134f, 0.09658603f, -0.02198463f, 0.05722304f, 0.00904779f, 0.00335127f, 0.02308858f, 
    -0.07404839f, -0.01133326f, -0.00202015f, -0.00526950f, 0.12875135f, 0.41029546f, 0.57794267f, -0.85620445f, 
    0.14356768f, -0.03082876f, 0.13049665f, -0.15182857f, -0.11274046f, 0.03804996f, 0.06639722f, -0.05734155f, 
    -0.11196855f, -0.05043067f, -0.05927360f, -0.04146152f, -0.02059945f, -0.04989398f, 0.03266490f, -0.09773298f, 
    0.34964612f, 0.07937596f, 0.08466140f, -0.18789744f, 0.07198571f, 0.21227266f, 0.26355287f, 0.28660774f, 
    -0.02912478f, -0.00003539f, 0.01280884f, -0.05683319f, -0.02738532f, 0.06924800f, 0.16230093f, 0.06595334f, 
    -0.00640721f, 0.06455775f, 0.00135297f, -0.02534695f, 0.58964097f, 0.37840143f, -0.11646714f, -0.23685671f, 
    0.04290320f, -0.25979403f, 0.11209613f, -0.05043516f, -0.12888372f, -0.09355105f, -0.07178471f, -0.21620528f, 
    0.03103629f, -0.08702537f, -0.00863596f, -0.09966139f, -0.02389606f, 0.02154547f, -0.11272512f, 0.04591295f, 
    -0.69321644f, 0.18240130f, -0.03278024f, 0.19063795f, -0.08440425f, -0.01582181f, 0.02357992f, -0.02420468f, 
    0.00941033f, 0.02676011f, 0.02652841f, -0.02978088f, 0.02280471f, -0.00488020f, 0.10264087f, 0.02028979f, 
    0.13148515f, -0.10312046f, 0.02525298f, -0.00739650f, 0.11042777f, 0.06328130f, -0.17155863f, 0.02648843f, 
    0.09733143f, 0.15790100f, 0.13499942f, 0.15168218f, 0.03418702f, -0.09829672f, -0.00980686f, -0.01401882f, 
    -0.06382929f, 0.13696058f, 0.07742743f, 0.05603175f, 0.06131648f, 0.03311219f, -0.02549973f, 0.01894767f, 
    -0.15789209f, -0.06735536f, 0.15287110f, 0.05157961f, -0.02544413f, -0.17004637f, -0.04069069f, 0.05641659f, 
    -0.01868222f, 0.01038151f, -0.01314507f, 0.04776506f, -0.08769030f, 0.00484385f, 0.03735282f, -0.08167522f, 
    0.05186385f, -0.11510720f, -0.11271134f, -0.04740266f, 0.09806321f, 0.09549686f, -0.00232208f, 0.02217490f, 
    0.00134445f, 0.07036533f, 0.04753521f, 0.10879986f, 0.00105531f, -0.05945532f, -0.10836608f, -0.05439028f, 
    -0.06896603f, 0.03176078f, 0.07157008f, -0.02722027f, -0.08814704f, -0.01421313f, 0.03433504f, -0.02277179f, 
    0.21301387f, 0.09919421f, -0.03649265f, -0.06123462f, -0.13153474f, 0.05750520f, 0.04411687f, 0.21424752f, 
    -0.06867716f, 0.06625517f, 0.03437620f, 0.01319506f, 0.01907382f, 0.00975796f, 0.03766320f, -0.04831429f, 
    0.06112780f, -0.02163771f, -0.10492478f, -0.03159958f, 0.24019656f, 0.20782270f, -0.06617157f, -0.27618420f, 
    -0.07548060f, 0.13664941f, 0.09136524f, 0.06488930f, -0.12999731f, 0.08240920f, 0.02600152f, -0.00189541f, 
    0.03030113f, -0.05093706f, -0.01611237f, -0.02136321f, -0.09299422f, -0.00401255f, 0.08660779f, -0.02319670f, 
    -0.05811082f, -0.08009239f, -0.03710253f, -0.01615506f, 0.01260800f, 0.03277625f, -0.02092625f, 0.02810974f, 
    0.04834507f, 0.06665133f, -0.25951576f, -0.18384740f, -0.13411632f, -0.06989728f, -0.22351205f, -0.06894320f, 
    -0.00935613f, -0.00922047f, -0.03568012f, 0.02496934f, -0.65686482f, -0.46947879f, 0.62143624f, 0.09103799f, 
    -0.29555395f, 0.05677176f, -0.08480924f, -0.04787591f, 0.04132311f, 0.02626434f, 0.01978881f, 0.01358924f, 
    -0.05411561f, 0.07115840f, 0.05428706f, -0.12923390f, 0.05381064f, -0.16812792f, -0.22579610f, -0.24949273f, 
    0.00267345f, 0.34355068f, 0.19489112f, -0.19974823f, -0.28097108f, -0.21759082f, -0.08663700f, -0.08015849f, 
    -0.05127356f, 0.02369916f, -0.04766323f, -0.11929913f, -0.08335914f, -0.00772521f, 0.04380559f, 0.14932494f, 
    0.01243396f, 0.20127714f, -0.01151959f, 0.05018247f, 0.63487065f, -0.08622462f, -0.18327902f, -0.32718611f, 
    0.12428325f, -0.01999873f, -0.11126666f, 0.09274668f, 0.01484768f, 0.11504915f, 0.03252180f, 0.06525239f, 
    -0.03595139f, 0.10087433f, 0.02976181f, -0.09336329f, -0.05160652f, 0.14715470f, -0.08926881f, 0.25537258f, 
    -0.33671254f, 0.51730281f, -0.45269206f, -0.08811603f, 0.03568862f, -0.00438937f, -0.03742370f, -0.11625259f, 
    -0.01060234f, 0.08035034f, 0.02669316f, -0.02856018f, 0.05220824f, 0.03632654f, 0.04139789f, 0.04680907f, 
    0.15216725f, -0.06516803f, -0.03219286f, 0.03872371f, -0.04774886f, 0.01282551f, 0.04982112f, -0.05857133f, 
    -0.19490299f, -0.12857151f, -0.17387819f, -0.32824737f, -0.03701176f, -0.13579170f, 0.04375774f, 0.05315299f, 
    0.01857134f, 0.06153648f, -0.00496933f, -0.06266394f, -0.00130438f, 0.01320741f, -0.09369129f, -0.04800418f, 
    -0.20942093f, -0.11743509f, -0.42567000f, 0.01890165f, -0.17716174f, -0.04877812f, -0.21440625f, -0.08253709f, 
    0.16603878f, -0.05431759f, -0.25313929f, -0.04370888f, -0.19515175f, -0.40457663f, -0.02349594f, -0.12841307f, 
    -0.03309574f, -0.04770643f, 0.00439824f, -0.18392129f, -0.32431370f, -0.47025841f, -0.67370528f, 0.19889095f, 
    -0.00699716f, 0.04141004f, -0.01054196f, -0.01101926f, -0.01935172f, 0.03542853f, -0.06205200f, -0.02245675f, 
    -0.15541339f, -0.22869298f, -0.05169450f, -0.01953598f, 0.08748156f, -0.09831963f, -0.01068359f, 0.01282970f, 
    0.34459233f, 0.15602267f, 0.13244262f, -0.12907691f, -0.11615520f, 0.13496906f, 0.12363364f, 0.15193516f, 
    -0.01056931f, 0.11236379f, -0.02092500f, 0.03267880f, 0.03515224f, 0.00465048f, 0.03155443f, -0.04740933f, 
    0.05159144f, 0.02693652f, -0.05781728f, -0.06798670f, -0.07536789f, -0.15186284f, 0.01075545f, 0.09211987f, 
    0.01756527f, 0.06012812f, -0.00206785f, -0.02502516f, 0.00624784f, 0.01454147f, -0.00994956f, 0.07165708f, 
    0.00319309f, 0.03958958f, 0.03837121f, -0.10910756f, -0.14624871f, -0.07575235f, 0.02067865f, -0.01792363f, 
    0.23822170f, 0.21172164f, -0.31961969f, 0.00059639f, 0.05448499f, 0.13851240f, 0.03050521f, 0.15236425f, 
    -0.22610740f, -0.15084471f, -0.00712479f, -0.04014879f, -0.06933048f, 0.03864213f, -0.01387117f, 0.03713768f, 
    0.07703923f, -0.00825635f, 0.00614880f, 0.06875736f, -0.17654374f, -0.10936134f, -0.16539519f, -0.07703712f, 
    -0.04804007f, 0.01052045f, 0.04291043f, 0.01998967f, 0.04055241f, 0.05066466f, 0.17134538f, 0.09656901f, 
    0.03139680f, -0.01965367f, -0.12047461f, -0.01921627f, 0.00930373f, -0.00941869f, 0.04719919f, -0.06620562f, 
    0.24860111f, 0.08698189f, -0.03691132f, -0.23221201f, -0.03515908f, 0.17812680f, -0.01230185f, 0.25830534f, 
    -0.25893205f, 0.06498908f, -0.04148833f, 0.00705953f, -0.04114540f, -0.08437864f, -0.10866097f, -0.02476124f, 
    -0.10585832f, -0.06211095f, 0.13566549f, 0.11659333f, 0.50612950f, 0.29253969f, -0.04553048f, -0.43526441f, 
    -0.06782053f, 0.07987484f, 0.15309243f, 0.11666729f, 0.05984916f, 0.08722361f, 0.04021794f, -0.00125022f, 
    0.00866748f, -0.02101628f, -0.02009323f, -0.05426530f, -0.14079477f, 0.05590149f, -0.02714775f, 0.02383596f, 
    -0.08577358f, -0.02027735f, -0.01998879f, 0.01979390f, 0.02079600f, 0.06347430f, 0.02226320f, 0.00727261f, 
    0.05067373f, 0.06981792f, -0.02812998f, 0.02972095f, -0.02853102f, -0.02069157f, 0.00671364f, -0.25266212f, 
    -0.06848834f, -0.14515038f, -0.00750114f, -0.03134587f, 0.14621674f, 0.11152676f, -0.03406605f, -0.02283157f, 
    0.05665956f, 0.05466364f, 0.08809020f, 0.03333906f, -0.04449817f, -0.15296726f, -0.11235300f, -0.01979781f, 
    -0.09571596f, -0.04872650f, 0.02676830f, -0.04886344f, -0.03230443f, -0.06395005f, 0.02459480f, -0.04807593f, 
    -0.60881513f, -0.17609881f, 0.43452409f, -0.06711247f, 0.13771112f, -0.29833916f, -0.03672516f, 0.04217693f, 
    -0.01899534f, -0.09018297f, -0.06215741f, -0.23087662f, -0.02948700f, -0.18284105f, -0.10341068f, -0.18013541f, 
    -0.20382454f, -0.06209077f, -0.08302758f, -0.24873064f, -0.32844430f, -0.29076484f, -0.33715528f, 0.05094476f, 
    -0.15220892f, -0.03276116f, -0.06827451f, -0.03349251f, -0.01376822f, -0.06260074f, -0.16333981f, 0.03082111f, 
    -0.07341542f, -0.01246679f, 0.01861374f, -0.16594018f, -0.04450768f, -0.30048123f, -0.07828456f, -0.17348814f, 
    0.08004344f, 0.18310423f, 0.32133549f, -0.12230673f, 0.05339342f, -0.11228640f, 0.14063726f, 0.15702787f, 
    -0.05461590f, -0.19053003f, 0.11698006f, -0.08621454f, -0.10248791f, -0.03084074f, -0.05400071f, 0.03887007f, 
    -0.02546795f, -0.07099755f, -0.01909327f, -0.03487015f, 0.10253473f, -0.47566211f, -0.80480522f, 0.20919622f, 
    -0.11206178f, -0.02717478f, 0.00456402f, 0.04532726f, -0.05134689f, 0.05773868f, 0.01670357f, -0.00525556f, 
    -0.16510001f, -0.02958079f, -0.10555959f, -0.01798040f, 0.09014774f, -0.10397348f, -0.05533271f, -0.01042313f, 
    0.11979751f, 0.17516749f, 0.11484467f, -0.34916836f, -0.26298180f, 0.00332362f, -0.04474899f, -0.05749835f, 
    0.11353938f, 0.03359454f, -0.04580685f, 0.02986155f, -0.03086562f, -0.05825929f, -0.08853220f, -0.08028553f, 
    -0.04945202f, 0.04570162f, -0.07437393f, -0.15159397f, -0.32100415f, -0.14408700f, 0.03860488f, -0.02411270f, 
    0.00625606f, 0.04262961f, -0.02857925f, -0.00686282f, -0.02013986f, 0.00950050f, -0.11655279f, -0.00110458f, 
    -0.25073069f, -0.04470094f, -0.02070722f, -0.07709046f, -0.17062350f, -0.05630653f, -0.03141997f, 0.01374726f, 
    -0.30172718f, 0.12834989f, -0.06540780f, 0.37423766f, 0.09422910f, -0.15514754f, 0.05508415f, -0.14783165f, 
    0.03819905f, -0.09269157f, -0.05470650f, -0.02862790f, -0.00441521f, 0.03713372f, 0.03470304f, -0.00110101f, 
    0.05665752f, 0.05159246f, -0.23828942f, 0.12976529f, -0.98020667f, 0.20607205f, -0.58425891f, -0.51336247f, 
    0.25570139f, -0.14224640f, -0.08582567f, -0.29169139f, 0.17605609f, 0.05857090f, -0.05205472f, -0.00996870f, 
    0.04154528f, -0.11335789f, 0.03433551f, 0.03964275f, -0.10496509f, 0.10885039f, -0.21064135f, -0.31441242f, 
    -0.24989486f, 0.05945865f, -0.20847480f, -0.01387224f, -0.12665226f, -0.07653721f, 0.06339602f, 0.24642213f, 
    -0.23889543f, -0.10809302f, 0.01247118f, -0.00709578f, -0.01148305f, -0.03248664f, -0.03907399f, -0.03093822f, 
    -0.00870319f, -0.01050329f, -0.03247451f, 0.04643284f, -0.65473682f, 0.10531373f, 0.03114848f, 0.05356942f, 
    0.28490943f, 0.30969924f, 0.02239570f, 0.25858936f, 0.22589713f, -0.07973859f, 0.04162828f, -0.03396153f, 
    0.10953224f, 0.03186481f, -0.09494989f, -0.13521540f, 0.12557705f, 0.04062220f, -0.00528600f, -0.07430910f, 
    0.34462392f, 0.08211104f, -0.00605554f, -0.08335753f, 0.02949161f, -0.05697081f, -0.05421322f, -0.06181815f, 
    -0.06018316f, 0.01375779f, -0.02193625f, 0.00092450f, 0.03933247f, 0.01881774f, 0.05594587f, -0.00291998f, 
    -0.17038979f, 0.05941129f, 0.08560742f, -0.05395404f, -0.03698869f, -0.48711127f, -0.08260404f, 0.00216702f, 
    -0.07034538f, -0.05089806f, 0.02763801f, 0.01199260f, -0.01086493f, -0.02817842f, 0.01791195f, 0.01921305f, 
    -0.03964257f, -0.09464772f, -0.09375461f, -0.00213137f, -0.02300884f, -0.02957425f, 0.04853832f, 0.00170906f, 
    0.13668980f, -0.05473226f, 0.10719761f, -0.07927025f, 0.06076486f, -0.07350685f, 0.04898567f, -0.00960657f, 
    0.02814560f, 0.03090622f, 0.10338949f, -0.06362195f, 0.00144464f, 0.03009830f, 0.00108621f, 0.01640607f, 
    -0.00752938f, -0.02406280f, 0.05866830f, -0.08928356f, -0.08809956f, -0.07855291f, -0.15322998f, -0.03719532f, 
    -0.05723768f, -0.01598399f, 0.05003740f, 0.08706403f, -0.03322731f, -0.00492804f, 0.17095535f, 0.17881894f, 
    0.09594593f, 0.08764476f, -0.04966461f, -0.06202254f, -0.03733766f, 0.00881802f, -0.05854912f, 0.03236732f, 
    -0.10842100f, -0.01042778f, 0.33219519f, -0.09805483f, -0.19453160f, 0.01053111f, -0.00344766f, -0.15410070f, 
    -0.19047250f, 0.08535244f, 0.07279281f, 0.02110106f, -0.04537088f, -0.02746092f, -0.05547956f, 0.05583052f, 
    0.03137493f, -0.04234284f, 0.02702349f, 0.05136398f, -0.05595796f, 0.15725172f, -0.13586302f, 0.25187430f, 
    -0.15098615f, -0.09589952f, 0.13395329f, 0.00797694f, -0.13434470f, -0.08410837f, -0.01933836f, -0.05518457f, 
    0.06439947f, -0.00214289f, 0.13599698f, 0.01385352f, 0.07818682f, 0.08393374f, -0.14921330f, 0.08774656f, 
    0.09630185f, -0.00801906f, 0.05443751f, 0.15071383f, 0.08684740f, -0.01851649f, 0.01086769f, 0.00619724f, 
    -0.00484091f, -0.03712378f, 0.13951585f, 0.05777882f, -0.06900377f, -0.01218777f, 0.06773776f, -0.01443915f, 
    -0.03916693f, -0.07463695f, 0.00166736f, -0.03180805f, 0.39704129f, 0.01737078f, 0.17532857f, 0.06021669f, 
    0.16806291f, -0.02049540f, -0.04901588f, 0.00262984f, -0.04208845f, 0.06132344f, -0.08034670f, 0.00530236f, 
    -0.04913196f, -0.03791461f, 0.00473588f, 0.12402926f, -0.09895673f, -0.06686141f, 0.27517012f, 0.15950760f, 
    0.03597672f, 0.16909486f, -0.36627555f, -0.16049783f, -0.58895159f, 0.12215140f, 0.00821814f, -0.09603462f, 
    -0.08501684f, -0.03632426f, -0.03849743f, 0.06026375f, -0.00172567f, 0.02302344f, 0.04101906f, -0.47416690f, 
    -0.47984546f, -0.29359636f, -0.21704176f, -0.21380673f, 0.17409970f, -0.57178992f, 0.00932720f, 0.05716693f, 
    0.37581611f, -0.02055836f, -0.06066040f, 0.01575827f, 0.00740267f, -0.03172633f, 0.05247271f, 0.08892704f, 
    0.04051676f, 0.08294948f, 0.01628306f, 0.18852457f, -0.18819170f, -0.15780979f, -0.08485774f, -0.19502757f, 
    0.62529206f, 0.14069729f, -0.23085126f, 0.02124263f, -0.26778418f, -0.07204662f, -0.14034447f, -0.11838987f, 
    -0.04128619f, -0.10139916f, -0.04063465f, -0.02275178f, 0.03625141f, 0.00083723f, 0.00329764f, 0.25112802f, 
    -0.13179272f, -0.12538582f, -0.07726550f, 0.04062074f, -0.19831000f, -0.23879112f, -0.00542226f, -0.19376852f, 
    -0.09693363f, 0.14856714f, -0.07839230f, -0.18022010f, -0.06140317f, 0.03827759f, -0.09320057f, -0.10264384f, 
    0.09522004f, 0.14714773f, -0.00840278f, -0.09860205f, 0.08389430f, -0.15029685f, 0.11057537f, 0.04468968f, 
    -0.11683847f, 0.02517746f, 0.11861665f, -0.01549042f, -0.19069254f, 0.04467009f, -0.05998248f, -0.04347630f, 
    0.03267253f, -0.00814170f, 0.04099172f, 0.07141793f, -0.05769123f, 0.20477021f, -0.13070053f, -0.01352608f, 
    -0.15368776f, 0.01711914f, 0.01536063f, -0.03231132f, 1.27280664f, 0.15763165f, -0.34164733f, 0.02727822f, 
    -0.21411531f, -0.01761289f, 0.02194254f, -0.05143910f, -0.00753281f, -0.05371857f, 0.09730612f, 0.19928524f, 
    -0.17211865f, -0.07292835f, 0.04549579f, -0.04138889f, 0.04880778f, -0.04963887f, 0.10171741f, 0.10173233f, 
    0.20992197f, 0.24329439f, 0.63609725f, 0.17034322f, -0.12244234f, 0.10900726f, -0.06353424f, 0.07309673f, 
    0.13063078f, -0.07294752f, 0.08479707f, -0.01999884f, -0.07037422f, -0.11754189f, -0.00930688f, 0.18215980f, 
    -0.00199939f, -0.21623471f, 0.03912907f, -0.00324187f, 0.21845686f, 0.08978276f, 0.14306763f, 0.04388092f, 
    0.15072775f, 0.00167135f, -0.04515430f, 0.00136293f, -0.07602710f, -0.02477414f, 0.03921914f, 0.02493927f, 
    0.00075475f, 0.08627456f, -0.04226519f, -0.06590900f, 0.21503301f, -0.09240961f, 0.05247292f, -0.03550899f, 
    0.07539794f, -0.30453920f, -0.25502717f, -0.05342595f, -0.14550574f, -0.09182028f, 0.12205604f, 0.12632023f, 
    -0.02692310f, -0.05466579f, 0.01950868f, -0.11952753f, 0.06477885f, -0.02514034f, -0.04514221f, 0.01836482f, 
    0.01794049f, -0.03014928f, 0.00519850f, 0.03079048f, 0.56617445f, -0.00266452f, 0.12943830f, 0.11360129f, 
    0.09964356f, -0.04317535f, 0.01097833f, 0.03780139f, -0.01334743f, -0.06623501f, -0.02669140f, -0.07732585f, 
    -0.01549598f, -0.14722350f, -0.05265365f, 0.09358206f, -0.01123762f, -0.10238100f, 0.00184834f, -0.08060923f, 
    -0.21705924f, 0.21181963f, -0.10420056f, 0.08448129f, 0.04365515f, -0.04823165f, 0.13223131f, -0.13920428f, 
    0.05212373f, 0.24527691f, 0.03704440f, -0.02060938f, -0.01122618f, 0.06615850f, 0.10627522f, -0.06504820f, 
    0.04144999f, -0.00078822f, -0.07689278f, 0.05171102f, 0.18413684f, 0.28193334f, 0.15849456f, 0.07915257f, 
    0.15118423f, 0.09778698f, -0.15432125f, 0.10326543f, 0.11571229f, -0.27007851f, 0.08729102f, -0.02731351f, 
    0.08161761f, -0.12674728f, 0.01813753f, 0.01550731f, 0.03678994f, 0.04606862f, -0.19287065f, -0.05333662f, 
    0.06530037f, 0.05740033f, 0.04590082f, 0.06823301f, 0.07330478f, -0.03884470f, -0.03811096f, -0.01311655f, 
    -0.01992449f, -0.02715296f, 0.01666702f, 0.01825304f, 0.11979343f, 0.04876905f, -0.02443449f, -0.13795568f, 
    0.11938779f, -0.14123875f, -0.01087204f, -0.04383934f, -0.13942237f, -0.06979287f, -0.14586316f, -0.04677691f, 
    -0.13376534f, -0.01008454f, 0.06930403f, 0.11023776f, 0.03194164f, -0.02372203f, 0.01190211f, -0.03868847f, 
    0.15740524f, 0.01128088f, -0.07690234f, 0.00134950f, 0.07316485f, 0.05469611f, -0.05497419f, 0.00918909f, 
    -0.48334032f, -0.07069824f, 0.11211934f, -0.06843486f, 0.00408500f, -0.01287947f, -0.06365744f, 0.23000561f, 
    -0.01872254f, 0.01290877f, 0.25395116f, 0.15905412f, 0.04122422f, 0.06046988f, -0.05658821f, -0.03307955f, 
    0.14677402f, 0.07639805f, 0.09329736f, 0.08110663f, -0.02933968f, 0.18408532f, 0.00153813f, -0.04651598f, 
    0.04325840f, 0.07629504f, -0.07839260f, 0.01434472f, 0.04176253f, -0.02729549f, -0.03365615f, -0.03190478f, 
    0.03690854f, -0.00794485f, 0.05483148f, 0.05361410f, 0.05971663f, 0.10158274f, 0.02644883f, 0.06756080f, 
    -0.50787073f, -0.06442779f, -0.16406670f, -0.11335297f, 0.20428827f, -0.13761781f, -0.03980871f, 0.16673899f, 
    0.20367169f, 0.13098679f, -0.07721212f, 0.11794702f, -0.02246468f, 0.02793731f, -0.08774357f, -0.04354300f, 
    0.06616494f, -0.01351869f, 0.03472699f, 0.10934618f, 1.00387609f, -0.18340287f, -0.01014412f, 0.24826880f, 
    -0.23612541f, 0.01489270f, -0.01885381f, 0.03123625f, 0.01751680f, -0.11888517f, 0.23322392f, -0.26075929f, 
    0.05492208f, -0.09557261f, -0.00851144f, 0.08931867f, -0.02621483f, -0.30239609f, 0.04880315f, 0.05716559f, 
    -0.18385743f, -0.04654365f, -0.14736079f, -0.15939105f, -0.28248724f, 0.14385210f, -0.08208182f, -0.24117538f, 
    -0.21887471f, 0.08820768f, -0.08692309f, 0.14251100f, -0.02638363f, 0.13007116f, 0.05765984f, 0.03094390f, 
    -0.00579488f, 0.03258434f, -0.17598583f, 0.13942805f, -0.03199115f, 0.03481606f, 0.13441290f, 0.01876118f, 
    0.08659124f, 0.02348515f, -0.00194055f, 0.11858800f, -0.02277124f, -0.04978115f, 0.04736360f, 0.07954933f, 
    -0.03021851f, -0.00597842f, 0.07985589f, 0.06423405f, -0.07785294f, 0.04275296f, 0.07763162f, -0.06396297f, 
    -0.59034532f, -0.98154390f, -1.03569078f, -0.10672532f, -0.79273427f, 0.01091878f, 0.03676509f, -0.01968492f, 
    -0.11886698f, -0.23735872f, -0.01789741f, 0.05205987f, 0.01878543f, -0.01412841f, -0.02963516f, 0.00859878f, 
    -0.00132338f, -0.02734322f, -0.36397856f, -0.02999034f, -0.07510585f, 0.21915397f, -1.15649927f, 0.05009399f, 
    -0.24423642f, -0.01205187f, 0.04482896f, -0.12253166f, 0.00098213f, 0.15789954f, -0.04997433f, -0.03405591f, 
    0.02735518f, 0.01117685f, -0.10305972f, -0.12510696f, 0.01125426f, 0.04119122f, -0.32868627f, 0.10871966f, 
    -0.20697252f, 0.24471693f, 0.27764603f, 0.26033217f, 0.32350862f, -0.11423492f, -0.16801149f, 0.00347083f, 
    0.18236892f, -0.03950958f, -0.00487512f, 0.02418304f, -0.00107349f, -0.06860955f, -0.00802609f, -0.04170306f, 
    -0.02778832f, 0.04196173f, -0.04551943f, -0.00067830f, 0.55468017f, -0.01605841f, -0.15124878f, 0.24471124f, 
    0.15143526f, 0.28247094f, -0.35941246f, -0.18219891f, 0.17483607f, -0.07775144f, -0.03281155f, 0.18970852f, 
    -0.01828187f, 0.02578802f, -0.09641808f, 0.01352664f, -0.04892883f, -0.04751891f, 0.18199489f, -0.06714951f, 
    -0.16192012f, -0.17619100f, 0.43882686f, -0.50248116f, -0.13156651f, 0.04625070f, 0.06832726f, -0.05934056f, 
    -0.00282804f, 0.05717796f, -0.01775291f, 0.02623830f, 0.03752170f, 0.06999896f, -0.05237276f, -0.00343390f, 
    -0.02419726f, -0.01409192f, -0.03431020f, -0.08163422f, -0.02585248f, 0.03549843f, 0.42318878f, 0.07288729f, 
    0.23097542f, -0.06941633f, -0.01274286f, 0.02238787f, 0.11211979f, -0.10796511f, -0.04225831f, -0.07461203f, 
    -0.07462041f, -0.03840820f, 0.08167820f, 0.04618816f, -0.05480606f, 0.00137700f, -0.00473443f, 0.00134567f, 
    0.01116391f, -0.03438691f, 0.02925607f, -0.02646312f, 0.03638104f, 0.04068784f, 0.00190376f, -0.11996087f, 
    -0.02413309f, 0.06702403f, 0.05897019f, -0.00230126f, 0.04529664f, 0.02405491f, -0.10789678f, 0.12728581f, 
    -0.05041258f, 0.03439423f, 0.01047857f, -0.00844820f, -0.01022268f, 0.06129053f, 0.01825916f, 0.04123358f, 
    0.08796733f, -0.05967090f, -0.06482944f, -0.00499709f, 0.01731216f, -0.20022714f, -0.12732089f, -0.07782803f, 
    0.02282953f, 0.02917123f, 0.06560384f, 0.01197139f, -0.08028038f, 0.02695672f, -0.00906339f, -0.04878799f, 
    0.13396206f, 0.18999279f, 0.49203506f, 0.04160547f, 0.27707106f, 0.15557453f, 0.05904934f, 0.01339714f, 
    0.03140899f, 0.11923032f, -0.03545185f, 0.02668319f, 0.04129422f, -0.06035050f, 0.12287564f, 0.02544856f, 
    0.04077696f, -0.03464662f, 0.05843692f, -0.02552314f, -0.15273902f, -0.30752763f, -0.18635081f, 0.04887730f, 
    -0.42196608f, 0.06642871f, 0.01762018f, 0.02948132f, 0.06534447f, -0.03679148f, 0.01604024f, 0.04309081f, 
    -0.01793440f, 0.01388227f, -0.06149064f, -0.02590288f, 0.02863456f, -0.01713146f, 0.04226609f, 0.06602533f, 
    0.03821307f, -0.07178360f, -0.07988854f, -0.08911140f, 0.07747731f, 0.03561238f, -0.05709448f, 0.04409523f, 
    0.04945186f, 0.04184941f, -0.12078223f, -0.06021987f, 0.14270446f, -0.01973311f, 0.00126927f, 0.02592863f, 
    0.00299965f, 0.01045779f, 0.06467625f, -0.00308733f, 0.05333439f, -0.26156452f, -0.35239348f, -0.18224137f, 
    -0.19157515f, 0.05545796f, 0.00573476f, 0.00708858f, -0.05234512f, 0.05963993f, -0.02585375f, -0.04745923f, 
    -0.06501282f, -0.00755610f, 0.03126063f, 0.08250169f, -0.03621339f, -0.15297040f, 0.28968436f, -0.10683037f, 
    -0.00896897f, -0.31164610f, 0.11040770f, 0.05586270f, -0.30802065f, 0.01613474f, -0.04124492f, -0.00977334f, 
    0.01688751f, 0.00780904f, 0.00797036f, 0.03632632f, -0.01975130f, -0.00462030f, -0.01422015f, 0.12744430f, 
    0.20068084f, 0.12641749f, 0.14835094f, 0.24175970f, -0.23734775f, 0.22134985f, -0.12881951f, -0.06009366f, 
    0.01577315f, 0.07105193f, -0.01145510f, -0.08246352f, 0.00859940f, -0.03196915f, -0.07434373f, -0.05418203f, 
    0.03530209f, -0.17199168f, 0.06022028f, 0.06938110f, 0.23210168f, 0.07155944f, 0.09187474f, 0.11674661f, 
    -0.98435134f, 0.19144149f, 0.23136401f, -0.59044814f, 0.04888466f, 0.02157587f, -0.00818296f, -0.08101885f, 
    0.05701931f, -0.00113331f, 0.02435848f, 0.03162701f, 0.02324260f, -0.01634023f, 0.00347732f, -0.04023229f, 
    -0.03021662f, 0.10861252f, 0.04092497f, 0.02089508f, -0.29651409f, -0.15270840f, 0.09776717f, -0.00664167f, 
    0.08649999f, -0.01806369f, 0.01133485f, -0.41205892f, -0.24352199f, 0.06911728f, 0.03654588f, -0.00959415f, 
    0.00893257f, 0.03543160f, 0.02461588f, 0.05123156f, -0.10687701f, -0.03665305f, -0.15875657f, -0.03398008f, 
    -0.21988387f, 0.17831819f, 0.07063715f, 0.03603733f, -0.11134768f, -0.04963885f, 0.10302815f, -0.10991623f, 
    -0.16996039f, -0.03511312f, 0.06131662f, 0.08999275f, -0.09671251f, 0.09068800f, 0.04582001f, 0.10924551f, 
    0.00272401f, -0.09241911f, 0.06075254f, -0.07449671f, -0.60587156f, 0.53701437f, 0.38193664f, -0.04528141f, 
    -0.05636220f, -0.05957889f, -0.07438903f, -0.00315164f, -0.01400954f, 0.17452076f, 0.14098912f, -0.01183790f, 
    -0.19810989f, 0.17899795f, 0.02632836f, 0.08008884f, -0.03533649f, 0.15123765f, 0.22456925f, -0.12485294f, 
    -0.47666329f, -0.30555609f, 0.64416671f, 0.35210487f, 0.28089282f, -0.15811351f, -0.07033252f, -0.04714385f, 
    -0.01211079f, -0.00145016f, 0.02430825f, -0.05304114f, -0.00431693f, -0.09967183f, -0.08871879f, -0.01693259f, 
    0.01524968f, -0.03575310f, -0.06148079f, -0.00512504f, -0.19175425f, -0.14838697f, -0.04460727f, -0.04936832f, 
    0.06531128f, -0.06033554f, 0.00499110f, -0.00954390f, 0.00220038f, 0.01431281f, -0.00003510f, -0.10672129f, 
    -0.05619939f, -0.04376126f, 0.02072242f, -0.21366429f, -0.14786054f, -0.05620208f, -0.02314704f, -0.02435378f, 
    0.11695450f, -0.02592928f, 0.40947843f, 0.02317132f, 0.23041710f, -0.03990053f, -0.00070956f, 0.04263839f, 
    0.24084467f, -0.08386824f, 0.04164152f, -0.02833715f, 0.06066410f, -0.07152683f, 0.07866541f, 0.07109298f, 
    -0.06914745f, -0.01374884f, 0.07907628f, -0.07250059f, -0.19962692f, -0.00935249f, -0.21889891f, 0.00093003f, 
    0.04710776f, -0.03660703f, -0.03416510f, 0.00436248f, -0.01329913f, 0.03616837f, 0.04333580f, 0.05918711f, 
    -0.06355686f, -0.09070567f, 0.11947738f, -0.05446812f, 0.13147619f, 0.23314102f, 0.08471568f, -0.06793014f, 
    0.16318199f, -0.00595785f, 0.09711026f, 0.02519603f, -0.26184419f, -0.00285849f, 0.05081468f, 0.03837188f, 
    0.10457476f, 0.06250978f, -0.00742828f, 0.04603111f, -0.00125952f, 0.02564574f, 0.00465728f, 0.00859992f, 
    0.01059526f, -0.06190833f, 0.07982013f, 0.01511539f, -0.03315415f, -0.35980690f, 0.49322963f, 0.63953418f, 
    -0.03867942f, 0.10555560f, 0.07984849f, -0.18382585f, 0.27560335f, -0.00931250f, -0.03022322f, 0.03263858f, 
    -0.03446440f, -0.02395247f, -0.10819433f, -0.06689639f, -0.00357325f, 0.10783798f, -0.07617595f, 0.01599353f, 
    -0.17059457f, -0.05773020f, 0.01826128f, -0.11548580f, 0.05844134f, -0.08621006f, -0.06453714f, 0.01460431f, 
    0.04285311f, 0.07259972f, 0.02207757f, -0.14688088f, -0.08841212f, -0.03179393f, -0.04040394f, -0.07108144f, 
    -0.19002143f, -0.09571786f, -0.00648558f, -0.01797469f, 0.00958567f, -0.02101633f, -0.01272458f, 0.11394863f, 
    0.07934566f, -0.02267344f, -0.06555462f, 0.01724874f, -0.10777318f, -0.16600828f, -0.04902517f, 0.02192206f, 
    0.13542241f, -0.02352616f, 0.01765880f, 0.01269883f, -0.04021718f, -0.00346518f, -0.02635880f, -0.09574128f, 
    0.53841883f, 0.23658012f, -0.34998560f, 0.06391291f, 0.15047863f, -0.16300447f, 0.13717893f, -0.02148587f, 
    -0.11032946f, 0.05507056f, -0.06016737f, -0.01996218f, 0.02030841f, -0.03282854f, 0.04657324f, -0.00505026f, 
    -0.00929280f, 0.11300443f, -0.16101649f, 0.09822597f, -0.04156597f, -0.00929227f, 0.15022881f, -0.26287809f, 
    0.05358396f, -0.01283543f, 0.02529231f, -0.08981093f, -0.00308758f, 0.06722075f, 0.08648771f, 0.02949972f, 
    0.04696475f, 0.09294627f, 0.02769056f, -0.06095131f, -0.12928501f, -0.16654512f, 0.03824929f, 0.00172374f, 
    0.43502679f, 0.16163914f, -0.31117964f, 0.08403119f, 0.11555962f, -0.06961712f, 0.10202037f, -0.15052842f, 
    -0.00959959f, 0.14619941f, -0.07030999f, 0.01417557f, -0.07426185f, 0.03237637f, -0.05615657f, 0.00185967f, 
    0.01672313f, 0.00515166f, -0.17261130f, 0.04546321f, -0.22321460f, 0.16350931f, 0.59519994f, -0.15069021f, 
    -0.03510650f, 0.06506360f, -0.11358389f, -0.00319834f, 0.00063400f, 0.06528946f, 0.09410451f, 0.01966826f, 
    0.02514777f, -0.10634238f, -0.03476147f, 0.04882051f, 0.02961104f, 0.07060108f, 0.17289147f, -0.09321059f, 
    -0.09440723f, -0.55290687f, -0.23118493f, -0.08740055f, -0.23884596f, 0.18190889f, 0.01317063f, 0.04635146f, 
    -0.12695332f, 0.01469777f, -0.06946592f, 0.00393014f, 0.01243384f, 0.01832344f, -0.06727453f, 0.06551670f, 
    -0.04707850f, -0.08526817f, -0.08631071f, 0.17627428f, 0.02511331f, -0.10011533f, -0.09157957f, -0.08387207f, 
    0.05315644f, -0.01201726f, -0.02215518f, 0.01210592f, -0.00165619f, 0.04952879f, 0.10537493f, -0.01588898f, 
    -0.05265708f, 0.03223212f, -0.08692420f, 0.00399208f, 0.03921251f, 0.06389459f, 0.08064225f, -0.08825012f, 
    0.08354966f, -0.21411058f, -0.35049313f, 0.04192501f, 0.35741946f, 0.17497842f, 0.14361757f, 0.12524182f, 
    0.15633446f, 0.16063857f, -0.03216322f, -0.12826551f, 0.01569452f, -0.08656438f, -0.07050340f, -0.08989912f, 
    -0.02827802f, 0.14677410f, -0.32775468f, 0.07896814f, 0.15127040f, -0.09949923f, -0.02569351f, -0.24064550f, 
    0.23894966f, 0.05711310f, 0.17386010f, -0.20989121f, 0.06461857f, -0.14027056f, 0.01428155f, 0.02943855f, 
    0.02068672f, 0.04740335f, -0.03225043f, 0.00007862f, 0.00920040f, 0.01665766f, -0.40302134f, -0.13945960f, 
    -0.02439298f, -0.08376950f, -0.13124259f, -0.10962351f, 0.36690357f, 0.33272186f, 0.07207534f, -0.17695439f, 
    -0.02429909f, -0.31496707f, -0.10711848f, -0.00153552f, 0.10189668f, 0.08615069f, 0.11627550f, -0.06426370f, 
    0.01721967f, 0.15693270f, -0.00851596f, -0.09662005f, -0.60396957f, 0.75191015f, -0.29629865f, -0.23336044f, 
    0.30463213f, 0.05038134f, 0.06061994f, 0.00538476f, 0.25450140f, -0.22456279f, -0.23449941f, 0.10080900f, 
    -0.30177620f, 0.11505142f, -0.09711143f, -0.31545708f, -0.30356714f, 0.25690505f, 0.14577541f, -0.18387066f, 
    -0.16877285f, -0.48640803f, 0.67367262f, -0.10733898f, 0.36484843f, -0.38193735f, 0.05424262f, 0.01951817f, 
    0.04453133f, 0.00798013f, 0.11957606f, 0.04508050f, 0.00398947f, -0.05777707f, 0.04567198f, -0.11599842f, 
    -0.06926840f, 0.02237866f, -0.04492792f, 0.01131689f, 0.08668153f, 0.14341271f, -0.14551504f, -0.08786923f, 
    0.26945323f, 0.27444619f, 0.10846680f, 0.03078829f, -0.09903187f, -0.15083484f, -0.22404435f, 0.01250863f, 
    -0.09240658f, 0.00038023f, 0.03441998f, -0.02351234f, -0.00510885f, -0.16390270f, 0.11093928f, 0.08841442f, 
    0.21445882f, -0.02295979f, 0.09385930f, -0.43494141f, -0.36108178f, -0.11539258f, -0.11573141f, -0.08503079f, 
    -0.07987557f, -0.07114345f, 0.03321930f, -0.09006889f, 0.05298246f, -0.11565226f, -0.00265184f, -0.13331603f, 
    -0.04614741f, -0.18111067f, 0.05962006f, 0.03231433f, -0.15149103f, -0.03548642f, -0.26681244f, 0.09063065f, 
    0.20974015f, 0.08069184f, 0.02433285f, 0.02520199f, 0.04779041f, 0.13538283f, 0.08563573f, 0.16115989f, 
    -0.01312448f, -0.19778578f, -0.00752182f, 0.27782211f, -0.12012818f, 0.04093509f, 0.17418544f, -0.03839565f, 
    0.28728759f, -0.04248949f, -0.05350705f, -0.10414723f, 0.23044012f, 0.02112774f, -0.03588230f, -0.00867574f, 
    -0.06500924f, -0.06379624f, -0.19179033f, 0.10317352f, -0.01310397f, 0.05787522f, -0.00085721f, 0.08757117f, 
    0.11062504f, 0.07918278f, -0.05329892f, 0.05237473f, -0.07854342f, -0.06013653f, -0.28215680f, 0.10004160f, 
    0.25100526f, 0.04499096f, 0.02591899f, -0.00555971f, -0.01426008f, 0.10003630f, -0.08726211f, -0.01840973f, 
    -0.11268962f, -0.07730561f, -0.06723139f, -0.04734247f, -0.15161319f, 0.06154017f, -0.15399536f, -0.02341375f, 
    -0.44841591f, -0.13187869f, -0.25968489f, 0.02505372f, -0.46205130f, 0.23518120f, 0.01256404f, -0.03664042f, 
    -0.01996484f, 0.07301093f, -0.12705620f, -0.19062281f, -0.02051216f, -0.15101105f, -0.06779421f, -0.11151917f, 
    -0.00793829f, -0.20904404f, 0.04327020f, -0.08128668f, 0.32200608f, 0.27955595f, 0.00766927f, -0.08183834f, 
    -0.55003977f, -0.18055771f, -0.13175361f, 0.11494749f, 0.13120687f, -0.07684823f, -0.01220173f, -0.00496125f, 
    0.08549688f, -0.04303563f, -0.02169281f, -0.09088314f, -0.02745739f, -0.20227775f, 0.22682413f, 0.09299684f, 
    0.09734663f, -0.23340906f, 0.03199465f, 0.01828409f, 0.25250000f, -0.11230052f, 0.09957468f, -0.05784808f, 
    0.15065566f, 0.09183279f, -0.01189709f, 0.04310249f, -0.01076476f, -0.12466162f, 0.04174068f, 0.08640759f, 
    0.02916890f, -0.06370571f, 0.07544050f, 0.06838339f, -1.21009743f, 0.94634098f, -0.20774186f, 0.25414783f, 
    -0.47920915f, 0.08918864f, 0.15519448f, 0.13711233f, 0.02882385f, 0.15401794f, -0.28786948f, -0.03694703f, 
    0.09713688f, -0.18939131f, -0.03127009f, 0.03649117f, 0.05287242f, 0.07297152f, 0.01904607f, -0.07669669f, 
    -0.59271270f, -0.40972504f, 0.72120947f, 0.20625880f, 0.23864765f, -0.17353268f, 0.03528498f, 0.05099301f, 
    0.00610521f, 0.03025320f, 0.13377380f, 0.11292186f, -0.10778537f, 0.01700095f, 0.25918233f, 0.02955146f, 
    0.02832436f, 0.20761046f, -0.12214379f, 0.01297006f, 0.04315254f, 0.26408678f, 0.57853776f, -0.36455625f, 
    0.43847784f, -0.14993875f, 0.01229458f, 0.04956635f, -0.07539888f, -0.04280512f, 0.18027885f, 0.03213869f, 
    -0.07738000f, -0.19291249f, 0.10980707f, -0.01187613f, -0.08928490f, 0.11234347f, -0.10387290f, -0.09476854f, 
    -0.35820499f, 0.09350196f, 0.05143318f, 0.21215715f, 0.28110373f, -0.24054614f, 0.04858138f, -0.14953279f, 
    -0.13626593f, -0.03506231f, -0.08126631f, 0.09764224f, 0.00727833f, -0.01297973f, -0.10373174f, 0.06088308f, 
    0.09802321f, 0.11399291f, -0.17283463f, -0.16553251f, -0.08378398f, 0.30927092f, 0.34011266f, 0.20278947f, 
    0.37290564f, 0.07012271f, 0.16651835f, -0.02370244f, 0.08546291f, -0.09260019f, -0.00325152f, -0.08253732f, 
    0.27689549f, 0.09623164f, -0.09186373f, -0.00150727f, -0.07901522f, 0.20395666f, -0.08815958f, -0.06168396f, 
    0.21643320f, 0.08782158f, -0.29815450f, -0.00499137f, 0.27889037f, 0.17288478f, 0.08917312f, -0.07995789f, 
    0.11609977f, 0.10789821f, -0.08836260f, 0.13072293f, 0.04730697f, 0.15564679f, 0.16808067f, -0.01783006f, 
    0.16837518f, 0.17193301f, 0.09739985f, 0.11973847f, -0.37880591f, -0.19799693f, -0.02299863f, -0.12931880f, 
    -0.34133571f, -0.16184184f, -0.36234817f, -0.10496793f, -0.08940051f, -0.09112392f, 0.12342798f, 0.04258471f, 
    0.08251525f, -0.00134571f, 0.09509630f, 0.07833579f, 0.14388834f, -0.12182435f, -0.19188584f, -0.17728518f, 
    -0.30020708f, 0.33737853f, -0.07326047f, -0.08756040f, 0.24211541f, 0.16950141f, -0.06129641f, -0.03065578f, 
    -0.11546056f, 0.05577359f, -0.15740690f, 0.04295554f, -0.03402291f, -0.06104238f, 0.03601187f, 0.01435666f, 
    -0.06268646f, -0.10993741f, 0.10267519f, 0.07010621f, 0.11402219f, 0.09122123f, -0.16576612f, -0.14869900f, 
    -0.20676765f, 0.32353503f, 0.30643222f, 0.13823763f, 0.15990394f, -0.03910821f, 0.00263339f, -0.09248480f, 
    0.09178996f, -0.04816407f, 0.02025021f, -0.08076163f, 0.05819556f, -0.05851093f, -0.12118887f, -0.11754198f, 
    -0.25916645f, 0.06112598f, -0.26008376f, 0.08032631f, 0.15039802f, -0.14935021f, -0.09826295f, -0.03299898f, 
    -0.08771124f, 0.01202459f, -0.06902740f, 0.13757218f, 0.07406801f, -0.01768681f, -0.12207723f, 0.00938519f, 
    -0.03622617f, 0.17728674f, -0.10927575f, -0.04359761f, -0.34794542f, 0.27052644f, -0.26329866f, -0.13021985f, 
    0.43779883f, 0.14071457f, 0.09884854f, -0.10867339f, 0.11215682f, 0.02880427f, -0.17353109f, 0.13813654f, 
    -0.17763366f, 0.11310322f, 0.09721612f, -0.17688449f, 0.03904506f, 0.17432183f, 0.06646983f, -0.02261738f, 
    -0.15014824f, -0.28135139f, 0.09827633f, -0.09361088f, -0.18574683f, 0.05101589f, -0.33729693f, 0.04021847f, 
    -0.12719491f, -0.13455090f, -0.06351398f, 0.07612528f, -0.24597278f, 0.06334635f, 0.12106580f, 0.12160595f, 
    0.02591881f, 0.10167471f, -0.48250726f, -0.13485935f, -0.31120443f, -0.07555504f, -0.19580673f, -0.13180521f, 
    0.30239657f, 0.07777292f, -0.02136304f, -0.03173949f, 0.04058710f, 0.01292347f, -0.10087486f, 0.06224585f, 
    0.09237443f, 0.00362807f, 0.01385634f, 0.17256722f, 0.07744705f, 0.21206413f, 0.02961927f, -0.24551779f, 
    0.41389418f, 0.50103909f, -0.32240537f, -0.50478977f, -0.10193640f, -0.18370573f, -0.08692568f, -0.06728925f, 
    -0.05868769f, -0.27240193f, 0.03400391f, 0.02803783f, -0.16392183f, -0.01190801f, 0.03815904f, 0.13919133f, 
    -0.00483513f, -0.03438002f, -0.10165507f, -0.16389771f, -0.91705298f, -0.20516731f, 0.48505300f, -0.24916850f, 
    0.21935675f, -0.31863448f, 0.08191136f, -0.23212564f, -0.10233808f, -0.01767308f, 0.09769148f, 0.01728936f, 
    -0.08381497f, 0.00291939f, 0.06525342f, -0.05427497f, 0.06280261f, 0.12870729f, -0.17021301f, -0.04941170f, 
    0.44847947f, 0.36407495f, -0.39479700f, -0.61759949f, 0.24838001f, -0.06244671f, 0.04090538f, -0.14699370f, 
    0.05116311f, -0.08983085f, 0.11263739f, 0.01405326f, -0.08292360f, -0.02860212f, -0.01054561f, 0.15902056f, 
    0.04458165f, 0.08016609f, 0.04717011f, 0.22169474f, 0.07544613f, 0.78860152f, -0.26193875f, 0.18483131f, 
    0.18284319f, 0.27015916f, 0.05752036f, -0.04032772f, 0.17985852f, 0.05517869f, -0.12356629f, -0.05421496f, 
    -0.05371695f, 0.03672643f, 0.04273581f, 0.06744061f, -0.23516159f, -0.05149413f, 0.06169355f, -0.07086854f, 
    0.14451815f, -0.13723445f, -0.15263289f, -0.17833821f, 0.29072109f, -0.09057879f, 0.10795816f, -0.03974696f, 
    -0.12630665f, 0.08240364f, 0.04462703f, 0.02394927f, 0.06002591f, -0.22056328f, -0.01471514f, -0.07622582f, 
    -0.19157928f, -0.05179232f, 0.17542477f, -0.16537392f, 0.01977620f, -0.09615075f, 0.06550005f, -0.35521588f, 
    -0.64199585f, -0.00913532f, -0.15538511f, -0.16449174f, 0.04678051f, -0.40481043f, 0.04548835f, 0.00183197f, 
    -0.01705082f, -0.07280703f, -0.05985742f, -0.15098952f, -0.06315753f, 0.11943278f, -0.23108177f, -0.36497259f, 
    0.15287364f, 0.34230906f, 0.49978790f, 0.28731152f, 0.35827878f, -0.16108070f, -0.00792672f, -0.08257443f, 
    0.05626415f, 0.29290494f, 0.03824385f, 0.01761251f, 0.02807994f, 0.00634539f, 0.03114478f, -0.01910353f, 
    -0.01946452f, -0.11983686f, 0.05254059f, -0.21373591f, -0.26719078f, -0.15047260f, 0.10766641f, 0.35148048f, 
    -0.16989359f, -0.28795230f, -0.11454408f, -0.03533218f, -0.04746176f, -0.06537413f, 0.00138361f, -0.01390638f, 
    0.03245614f, 0.07113473f, -0.01968042f, 0.07155443f, 0.07599428f, -0.13480069f, 0.15619631f, 0.20839927f, 
    0.23184720f, 0.04841133f, 0.23583806f, 0.19154024f, 0.10616966f, -0.25253648f, -0.11441774f, -0.24079478f, 
    -0.02683443f, 0.07093409f, 0.06862963f, 0.09500251f, -0.13086899f, 0.03398956f, -0.04802040f, 0.01468550f, 
    0.06173100f, 0.01043773f, 0.08568042f, -0.04882399f, 0.18794341f, -0.23486057f, 0.07575810f, -0.09955103f, 
    -0.39932519f, 0.06252743f, -0.36682603f, 0.01149086f, -0.21569480f, -0.03212418f, -0.04899664f, -0.06601833f, 
    0.02371253f, 0.02933968f, 0.03754607f, 0.02323377f, -0.17282861f, -0.00349682f, -0.22070625f, -0.30260244f, 
    0.46692935f, 0.23913370f, -0.48193920f, 0.29864740f, 0.05210331f, 0.07121825f, 0.00135719f, 0.04401872f, 
    0.08791152f, 0.06379075f, 0.09369444f, 0.00222071f, -0.04108703f, 0.00082131f, 0.00304437f, 0.06557874f, 
    0.10545687f, 0.06195942f, -0.03538149f, 0.10198835f, 0.17572145f, -0.18067373f, 0.09454259f, -0.04046272f, 
    0.12158272f, -0.13218668f, -0.05301809f, -0.02471077f, 0.02648302f, 0.11214013f, 0.09973323f, -0.06060408f, 
    -0.06751717f, -0.13186294f, -0.00732484f, 0.08910771f, 0.03764312f, 0.06490333f, -0.02010817f, -0.00569795f, 
    -0.01097390f, 0.00217943f, -0.05663742f, 0.00714144f, -0.03082567f, 0.03968182f, 0.07450745f, -0.10008840f, 
    -0.01387444f, 0.05057903f, 0.18333258f, -0.04823140f, 0.02556206f, 0.03679923f, -0.02985010f, -0.07226739f, 
    -0.06535738f, -0.15006961f, -0.22136529f, 0.02553923f, 0.18392015f, 0.01615388f, 0.11576930f, 0.04249205f, 
    0.03141508f, 0.04192256f, -0.00218694f, -0.05616027f, 0.02541080f, -0.02289859f, 0.00531638f, -0.22270533f, 
    -0.03573022f, 0.03667299f, -0.01322593f, 0.07137629f, -0.02685624f, -0.01177122f, -0.03305303f, -0.03218272f, 
    -0.12949015f, -0.12504819f, 0.05552231f, 0.16003148f, 0.18948549f, -0.10576211f, 0.03308615f, -0.13889943f, 
    -0.06315315f, 0.00168614f, -0.03388449f, -0.01973502f, -0.00588012f, -0.05491286f, 0.04932575f, -0.06166757f, 
    -0.01622664f, 0.02458010f, -0.06450941f, 0.04140283f, 0.03812839f, 0.09571887f, 0.34180310f, 0.06313093f, 
    0.21514249f, -0.05536673f, 0.07724742f, 0.00085037f, 0.14397575f, -0.01706623f, -0.04647598f, -0.00211929f, 
    0.00287428f, 0.07328737f, 0.00826808f, 0.02415987f, 0.05417408f, -0.16735588f, -0.05133140f, -0.09980397f, 
    0.11070593f, 0.09341190f, -0.04165355f, -0.09432197f, -0.12980658f, 0.07681549f, 0.01559178f, 0.01525222f, 
    0.00033497f, 0.10505868f, -0.03716373f, -0.04834424f, 0.10604841f, -0.07112964f, 0.04971685f, 0.08417083f, 
    0.03107871f, -0.00560597f, -0.11878063f, 0.04632664f, -0.57338166f, 0.40865225f, -0.29574993f, -0.37610847f, 
    -0.46775725f, 0.10286757f, 0.01342341f, 0.00783122f, 0.07550047f, -0.00852984f, 0.18469709f, -0.08117782f, 
    -0.03557957f, -0.04734055f, 0.05702199f, -0.04582272f, -0.01951243f, 0.36371374f, -0.42089581f, 0.07423916f, 
    -0.16149917f, 0.04830918f, -0.04479543f, 0.01421719f, 0.11965755f, -0.01936243f, 0.01935111f, 0.12313155f, 
    0.14627117f, 0.02841305f, 0.05086605f, -0.03735123f, -0.00625560f, 0.04151442f, -0.02280649f, 0.09694709f, 
    0.30438775f, 0.18740812f, 0.10628274f, 0.44508958f, -0.01372910f, -0.51100302f, 0.12946795f, -0.24637111f, 
    -0.20913438f, 0.14792401f, 0.03794354f, 0.08516911f, 0.01914014f, 0.08234377f, 0.00447767f, 0.03794554f, 
    0.07964566f, 0.01127100f, -0.16493906f, -0.09342811f, -0.05797668f, 0.03574165f, 0.08942398f, 0.40835816f, 
    0.41484782f, 0.08360545f, -0.31073570f, 0.19506600f, 0.46712211f, 0.02867237f, 0.11438960f, 0.07608476f, 
    0.07442919f, 0.09770886f, 0.03901772f, 0.05336514f, -0.01157007f, 0.02119938f, 0.01905094f, 0.08058682f, 
    -0.06389677f, -0.04224684f, 0.10389211f, -0.03028613f, -0.02431830f, -0.01971806f, -0.00505935f, 0.17031136f, 
    0.26390561f, -0.14789096f, 0.06807905f, 0.08317752f, -0.00334943f, 0.07991805f, 0.06291308f, -0.06206528f, 
    -0.05375217f, -0.15463205f, 0.05135839f, -0.14446285f, -0.15522358f, -0.07474758f, -0.07511826f, -0.30912232f, 
    -0.18166545f, -0.24593386f, 0.13282852f, -0.22936371f, -0.12062283f, -0.01949580f, 0.03833288f, -0.07266448f, 
    -0.09714688f, -0.01420151f, 0.06529128f, -0.30619341f, 0.08259059f, -0.32412785f, -0.23463827f, -0.05112584f, 
    -0.02984177f, -0.14132898f, -0.11182537f, -0.07184343f, -0.22465968f, -0.07836183f, -0.03221284f, -0.24878988f, 
    -0.19075470f, 0.05751593f, 0.05769400f, -0.07989657f, -0.02665726f, 0.04346814f, 0.04871982f, -0.30328879f, 
    -0.08039359f, 0.16447224f, 0.05901645f, 0.03225566f, 0.14695084f, -0.21472520f, -0.20224747f, -0.11376760f, 
    -0.26879317f, -0.26972333f, 0.02579229f, 0.11909524f, 0.20227544f, -0.10926799f, 0.06192789f, 0.03464023f, 
    -0.10105021f, -0.00368348f, 0.00333980f, 0.07414000f, 0.00737899f, 0.05113735f, -0.06124428f, 0.00101856f, 
    0.11539664f, 0.04678417f, 0.05343916f, 0.15044743f, 0.06058559f, 0.04765327f, -0.04180836f, -0.01874625f, 
    0.10942183f, 0.09570047f, 0.09378901f, 0.00244067f, 0.03207315f, 0.02327989f, 0.18736683f, 0.07141353f, 
    0.01405805f, 0.00355008f, 0.11308146f, 0.04456494f, -0.11438582f, 0.07556909f, -0.05617509f, 0.05857236f, 
    0.08968896f, -0.22196515f, 0.11329419f, 0.07449017f, 0.06087394f, -0.11912830f, -0.03144768f, -0.14049186f, 
    -0.11543864f, -0.07109386f, 0.03842648f, -0.06148196f, -0.00258628f, 0.03058220f, 0.03679131f, 0.00375646f, 
    0.01165514f, 0.06488880f, -0.06029642f, -0.11749233f, -0.10735278f, 0.18702750f, -0.01558274f, -0.14836884f, 
    -0.29588202f, 0.06424971f, 0.03617604f, 0.00800161f, 0.07327111f, 0.13016124f, 0.02534307f, 0.04221329f, 
    -0.12870559f, -0.11216063f, 0.05564608f, -0.20552146f, 0.09115850f, -0.07324774f, -0.13669921f, 0.15429626f, 
    -0.04464152f, -0.11524490f, 0.28276497f, 0.03476592f, 0.03338370f, -0.09721253f, 0.13169508f, -0.09445910f, 
    -0.06351931f, -0.09462799f, -0.02615797f, -0.01142940f, 0.01490955f, -0.05022860f, 0.00680220f, 0.05997298f, 
    0.10328240f, -0.06485623f, -0.11199412f, 0.06000305f, -0.03703390f, -0.21274920f, 0.05406717f, 0.18874513f, 
    0.01032478f, -0.15017679f, 0.03761835f, 0.01202751f, -0.28417203f, -0.10668337f, -0.04938665f, -0.00205788f, 
    0.06875366f, 0.06174201f, -0.00418933f, 0.02837952f, 0.02339137f, -0.01810426f, 0.03673143f, 0.08547809f, 
    0.08039772f, 0.07790337f, -0.07126463f, 0.01387348f, 0.05872986f, 0.19320586f, 0.18226686f, 0.08779205f, 
    -0.02446590f, 0.05843144f, 0.15172382f, 0.15318014f, 0.05150835f, -0.06786894f, 0.17949252f, 0.26640660f, 
    -0.13764949f, 0.04556051f, -0.03935616f, -0.01670111f, 0.17560887f, -0.01479472f, 0.12660451f, 0.00901665f, 
    0.00596760f, 0.07829382f, -0.00753311f, 0.02366923f, -0.04227936f, -0.07900224f, 0.08652896f, -0.10548352f, 
    -0.13105546f, 0.02723773f, 0.02488943f, 0.01410720f, -0.01631244f, -0.11210414f, -0.06357932f, -0.08501819f, 
    -0.05353324f, -0.22278491f, 0.00559713f, -0.21159048f, -0.07432795f, -0.11643874f, -0.23354115f, -0.07579438f, 
    0.06485669f, -0.01071561f, -0.10877193f, -0.21831515f, 0.06296266f, -0.06738190f, 0.04073641f, -0.24286969f, 
    -0.35290432f, -0.06041784f, -0.13536140f, -0.05971176f, 0.12665378f, -0.09466957f, -0.05749475f, 0.09084581f, 
    -0.12141215f, 0.08615877f, 0.01386924f, -0.01740410f, -0.01941163f, -0.01409367f, -0.01617697f, -0.06011017f, 
    0.03670149f, -0.06006759f, -0.05578979f, 0.01602290f, -0.10827800f, 0.03790679f, 0.04170418f, -0.06109422f, 
    -0.18300092f, -0.03757108f, 0.14210655f, 0.15349278f, -0.13849553f, 0.07058652f, -0.12292465f, -0.07992817f, 
    -0.18968514f, 0.00202534f, -0.23117012f, 0.03047739f, 0.15298282f, 0.07484019f, -0.02438254f, -0.06424329f, 
    -0.21748918f, -0.07320539f, -0.22834790f, -0.12899591f, -0.48248363f, -0.32268599f, 0.13046643f, -0.30007100f, 
    -0.13367277f, 0.00652328f, 0.15703082f, -0.22924627f, 0.01349957f, 0.05283408f, 0.00625700f, 0.01820277f, 
    0.10791692f, 0.17434925f, -0.04586712f, -0.10407993f, 0.01133486f, -0.01815494f, -0.05301661f, -0.10803154f, 
    -0.00155915f, 0.15594965f, 0.26007280f, 0.40362909f, 0.12290123f, -0.05971391f, 0.12368279f, -0.18880968f, 
    0.20725735f, 0.05152549f, 0.09704553f, -0.07292619f, -0.01433612f, -0.04835699f, -0.07812905f, -0.08279710f, 
    0.00311130f, -0.25956148f, 0.02438816f, -0.32326636f, 0.12799568f, -0.11911573f, -0.01539652f, -0.14478569f, 
    -0.13873297f, -0.04476069f, 0.03022883f, -0.04595066f, 0.04413147f, 0.01245916f, 0.02999642f, 0.01127056f, 
    0.07161657f, -0.06559797f, -0.08471826f, 0.06325155f, -0.00169735f, -0.06569775f, -0.10576857f, 0.13583754f, 
    0.17349967f, -0.09181307f, 0.37887055f, -0.01261563f, -0.31981739f, 0.15651560f, 0.17033628f, 0.15519527f, 
    -0.11523198f, -0.33561903f, 0.08144895f, -0.04534352f, 0.00906543f, -0.01608419f, 0.01930070f, 0.03766689f, 
    0.03861915f, -0.00564913f, 0.15589136f, 0.15109661f, 0.48202056f, -0.19990177f, 0.22994524f, 0.26724920f, 
    -0.59679627f, 0.13615097f, -0.08285473f, 0.25400662f, -0.18938963f, 0.16134742f, 0.04961177f, -0.01584580f, 
    -0.07889113f, -0.02983211f, 0.06949466f, -0.12637590f, -0.12882467f, 0.11667942f, 0.06788941f, 0.04061290f, 
    -0.40552947f, -0.03852221f, -0.27714786f, -0.06926477f, -0.32357749f, 0.00587549f, 0.06122421f, 0.00312693f, 
    -0.16766390f, -0.02565341f, 0.09658898f, -0.06425611f, 0.03576358f, -0.11035971f, -0.05600308f, -0.02298871f, 
    -0.01953595f, 0.00601450f, 0.03288651f, 0.07865640f, -0.16566229f, -0.44943756f, 0.22709878f, -0.20439436f, 
    -0.28890318f, -0.27969432f, -0.00877512f, -0.25376150f, -0.12553442f, 0.11924147f, 0.19349159f, 0.06797459f, 
    -0.01221856f, -0.03219968f, 0.10056470f, 0.17904434f, -0.00001137f, -0.03417558f, 0.06019396f, 0.28469041f, 
    -0.11400083f, 0.02725904f, -0.17813586f, 0.00905111f, 0.15090063f, 0.14694171f, 0.03374702f, -0.06258290f, 
    -0.00314782f, 0.02252391f, -0.01579146f, 0.07951819f, -0.02584844f, 0.04945811f, -0.04745922f, 0.04881390f, 
    -0.10722699f, 0.20591134f, 0.00973077f, -0.09127702f, -0.36324403f, 0.17378139f, -0.46184543f, -0.06531329f, 
    -0.11747626f, 0.10622922f, 0.02602718f, -0.02968774f, 0.04405838f, -0.12093609f, 0.09287839f, -0.04439296f, 
    0.06047407f, 0.05287762f, -0.07087356f, -0.07118004f, -0.01207730f, 0.08796807f, -0.09703556f, 0.00276771f, 
    -0.30851886f, 0.02883407f, -0.20646223f, 0.20868048f, 0.04749340f, 0.23480615f, -0.33127069f, -0.06009889f, 
    0.06775727f, 0.07783148f, -0.21906140f, 0.08484476f, 0.01765774f, 0.05386338f, 0.04028583f, 0.10848228f, 
    -0.04735870f, 0.24512988f, -0.06960315f, 0.04383181f, 0.10390338f, -0.02162916f, -0.00280390f, -0.03809396f, 
    -0.11517128f, 0.00244235f, -0.05661912f, -0.05118040f, 0.04564198f, 0.14381422f, -0.16993244f, -0.09311283f, 
    -0.02164726f, -0.06807629f, -0.09738325f, -0.00846716f, 0.11353256f, 0.02247225f, -0.04931619f, 0.13178104f, 
    -0.15093361f, 0.30450723f, -0.13269635f, 0.14110066f, -0.17120388f, 0.05993087f, -0.06766066f, 0.13685638f, 
    0.12911925f, 0.01059194f, -0.02852776f, -0.03958177f, 0.03368602f, 0.12592813f, -0.05751234f, -0.03340245f, 
    -0.08720718f, 0.05989620f, 0.02074486f, -0.02747225f, 0.15834786f, 0.08176040f, 0.31258127f, -0.07487965f, 
    -0.04169249f, 0.21985467f, 0.03204986f, 0.04743109f, 0.05788945f, 0.00444069f, 0.08413409f, 0.01055814f, 
    0.06655993f, 0.04260801f, -0.01249964f, -0.01827706f, 0.00728353f, -0.07834976f, 0.04064478f, 0.10766257f, 
    -0.01511894f, -0.08721957f, -0.36352211f, 0.00052325f, 0.07463808f, 0.02406329f, -0.02830083f, -0.09304779f, 
    -0.04652861f, -0.03181102f, 0.17422129f, 0.16807958f, 0.01133223f, 0.17705886f, -0.10195580f, -0.07752654f, 
    -0.01754902f, 0.15563890f, 0.13804972f, 0.06928347f, 0.23985241f, -0.35060772f, -0.17038411f, 0.18343493f, 
    0.26662460f, 0.05905472f, 0.02575882f, -0.07277180f, -0.05931186f, 0.04773625f, 0.08747033f, -0.01623822f, 
    0.16593337f, 0.04699492f, -0.06083649f, -0.13371018f, -0.09984936f, 0.23238434f, 0.03218437f, -0.15028259f, 
    0.31017104f, 0.08949583f, 0.26604182f, -0.00877677f, 0.37849331f, 0.06201751f, 0.14130501f, 0.01294632f, 
    0.01394167f, -0.04078566f, 0.04253599f, 0.07476571f, 0.07155327f, 0.02093786f, -0.06957403f, -0.06851041f, 
    -0.15899633f, -0.36052501f, -0.18957078f, -0.73282558f, 0.29012749f, 0.17893919f, 0.03800794f, -0.31066781f, 
    -0.05120983f, -0.00727831f, -0.03051062f, -0.02126787f, -0.06292786f, -0.07235447f, -0.01547637f, -0.01182721f, 
    -0.16295092f, -0.00635387f, 0.14301986f, -0.14019753f, -0.10260495f, 0.03513249f, 0.14802311f, -0.17206565f, 
    -0.43082598f, -0.14239174f, -0.31068414f, -0.19361818f, 0.09881460f, 0.07984380f, 0.15965903f, -0.08762180f, 
    0.04220238f, 0.05960337f, 0.02187017f, 0.02318933f, -0.01487655f, -0.06787775f, -0.01873048f, -0.27781665f, 
    0.12945785f, 0.08226197f, 0.05016036f, -0.03244785f, -0.03225025f, 0.06697793f, -0.08190870f, 0.34402031f, 
    -0.11158186f, -0.12281003f, -0.06452530f, 0.03407354f, -0.09019374f, 0.19417734f, -0.07951563f, 0.05560727f, 
    -0.09254077f, -0.08206198f, -0.03430266f, 0.15148979f, -0.00755292f, 0.19363561f, -0.22442150f, 0.10202106f, 
    0.71620697f, -0.04843194f, -0.25281051f, -0.20016071f, 0.27831241f, 0.01816788f, 0.14106172f, 0.02722538f, 
    -0.19474043f, 0.19841792f, 0.02429128f, 0.06559417f, 0.00650535f, 0.12832947f, 0.09718614f, 0.15884946f, 
    0.21168256f, -0.04789931f, 0.00379848f, 0.23979953f, -0.55925739f, -0.32467842f, -0.17240173f, -0.42930248f, 
    0.08442055f, 0.01614122f, 0.02404424f, 0.04476375f, -0.18027702f, -0.15523081f, 0.12175835f, 0.00743175f, 
    0.12017258f, -0.35591269f, -0.03736703f, 0.03804720f, -0.12306883f, -0.05235555f, 0.02538420f, -0.09644766f, 
    -0.37447593f, 0.18446396f, -0.24859436f, -0.16286783f, -0.26572084f, -0.13044244f, -0.20606151f, -0.04530414f, 
    -0.14222705f, -0.10460016f, -0.00983994f, -0.03507047f, -0.06575133f, -0.06762529f, 0.01524224f, -0.28853124f, 
    -0.17329070f, -0.07087613f, -0.17834757f, -0.20205396f, -0.07193145f, -0.19184186f, -0.08876114f, 0.17902304f, 
    0.00149330f, 0.03868954f, 0.04229051f, -0.03379145f, -0.00658598f, 0.03332645f, -0.05140622f, -0.04989652f, 
    0.00599944f, -0.02134626f, 0.05508982f, 0.15888502f, -0.21274437f, 0.13305713f, -0.00870304f, 0.00567743f, 
    -0.10565156f, -0.04363153f, -0.12455975f, -0.19604000f, -0.13619705f, 0.04649960f, -0.02429436f, 0.00628003f, 
    0.04786167f, 0.16477190f, 0.04318128f, 0.09815686f, -0.09832831f, 0.04963236f, -0.07357173f, -0.05482164f, 
    -0.00969594f, 0.06312298f, -0.02791103f, 0.09147432f, -0.24318415f, -0.22810805f, -0.09827773f, -0.18846036f, 
    0.15950130f, 0.01468099f, 0.01457934f, -0.12581143f, -0.04811976f, -0.03324937f, -0.08885369f, 0.00199087f, 
    0.12491853f, 0.16250607f, 0.12319072f, -0.07650921f, -0.10057765f, -0.00387037f, 0.10707994f, 0.15201801f, 
    0.37774682f, 0.06927708f, 0.28251216f, -0.02879654f, -0.10982628f, 0.10111531f, -0.03677354f, 0.00491082f, 
    0.00322017f, -0.07733684f, 0.07736435f, -0.03980340f, 0.08355767f, 0.08695037f, -0.04223061f, 0.04853307f, 
    -0.02848603f, -0.12844814f, 0.00670610f, -0.10002347f, -0.26861873f, -0.05622243f, 0.28546420f, -0.08653913f, 
    -0.26747298f, 0.05754811f, 0.09054208f, 0.03459843f, -0.13497914f, 0.05817109f, 0.05028738f, 0.01218712f, 
    -0.14362268f, 0.09275161f, 0.07113992f, 0.07206790f, -0.01388021f, -0.06379379f, 0.05791798f, 0.07831746f, 
    0.10720958f, -0.12125444f, -0.11535645f, 0.16591626f, 0.03273135f, 0.03151646f, 0.07068031f, -0.04398448f, 
    -0.00296411f, -0.00055106f, 0.04263831f, -0.15644550f, 0.04590270f, 0.03903442f, 0.04284098f, 0.15177612f, 
    -0.11427215f, 0.16610472f, -0.06617130f, -0.02040059f, 0.18487348f, -0.05142904f, 0.05195950f, -0.05742488f, 
    -0.14370033f, -0.05930519f, -0.00596231f, -0.10537706f, -0.04147924f, 0.15210195f, 0.01557834f, 0.05355875f, 
    -0.02629187f, -0.02624590f, -0.05209473f, 0.06285278f, 0.10083366f, -0.07848416f, 0.04289242f, 0.15828286f, 
    -0.09203566f, -0.39942247f, -0.01506435f, 0.37177455f, -0.17774238f, 0.26943770f, 0.00875133f, -0.24465060f, 
    0.06168022f, 0.20341332f, -0.09029752f, 0.10661150f, -0.04390508f, 0.04453873f, 0.10231264f, 0.15773004f, 
    0.08088409f, -0.00388916f, 0.02886741f, 0.19891468f, 0.33610308f, -0.04204750f, -0.24877638f, -0.10113595f, 
    0.16976152f, 0.00292093f, 0.09859227f, -0.11132661f, -0.14331946f, 0.10808109f, 0.10196353f, -0.00236838f, 
    0.00698486f, 0.00212092f, -0.04331413f, 0.07978482f, 0.02231083f, 0.00139753f, 0.01679516f, -0.00494773f, 
    0.11992168f, -0.19348104f, 0.12869148f, 0.26263961f, -0.38265258f, 0.14102331f, -0.07676300f, -0.06707675f, 
    0.05829239f, 0.08645318f, 0.11673594f, -0.12475491f, -0.07239350f, -0.01090147f, 0.22472569f, -0.06101618f, 
    0.15026210f, 0.04846980f, -0.03688603f, -0.00274406f, -0.14982887f, 0.26315075f, -0.39485073f, -0.70556062f, 
    0.01590717f, -0.12616023f, -0.04863172f, 0.07574731f, -0.14753969f, 0.01970578f, -0.03254651f, 0.06902137f, 
    -0.19350712f, -0.13125780f, 0.06192562f, 0.03417651f, -0.11953151f, 0.16657707f, -0.10938426f, 0.00700603f, 
    0.07316747f, 0.27025846f, 0.09458096f, 0.07049356f, -0.00609743f, -0.05654534f, -0.08277653f, 0.10011495f, 
    0.07898127f, 0.09326464f, 0.02561495f, -0.10875493f, 0.10397007f, 0.11523266f, 0.08502380f, 0.07431728f, 
    0.06397086f, 0.04146583f, -0.16760185f, 0.17846654f, -0.16503891f, 0.03479844f, -0.24910003f, 0.10632960f, 
    0.11588536f, 0.08986752f, -0.05937754f, -0.15267740f, -0.12260047f, 0.21801403f, 0.02158837f, -0.10863637f, 
    0.17730007f, 0.13902773f, 0.01191421f, 0.09986181f, -0.08798435f, 0.03536000f, 0.03136348f, 0.09618993f, 
    -1.07905591f, -0.96373868f, -0.69471282f, -0.62806910f, 0.24516499f, -0.21874037f, -0.07665961f, -0.31855217f, 
    -0.29790351f, -0.48403856f, -0.04689884f, -0.01777205f, -0.04506275f, -0.02259656f, 0.00336084f, -0.05504494f, 
    -0.00486178f, 0.10373547f, 0.18623534f, -0.14814991f, -0.37803739f, -0.39734244f, -1.09944022f, -0.09435737f, 
    0.31973168f, -0.07810707f, 0.17490070f, 0.07904750f, -0.23381682f, -0.01819308f, -0.11963344f, 0.05579968f, 
    0.07073905f, -0.02265987f, 0.04636046f, 0.00274485f, 0.00873125f, -0.18364619f, 0.32827353f, 0.07984278f, 
    -0.59359097f, 0.80476397f, 0.38687775f, -0.28545657f, -0.00712360f, -0.30244926f, -0.08576902f, -0.04639810f, 
    0.02315553f, 0.23434795f, -0.08375596f, 0.00276236f, 0.04988438f, -0.01511123f, 0.06900182f, 0.00843388f, 
    0.03107552f, -0.06477788f, 0.07660597f, -0.00964992f, -0.53631955f, -0.53726095f, -0.02150911f, 0.15235890f, 
    -0.20827027f, 0.12171708f, -0.09532741f, -0.06123689f, -0.00207911f, 0.04493564f, 0.05525089f, 0.07122161f, 
    0.00424058f, 0.09758051f, -0.03590931f, -0.04449358f, -0.02081567f, 0.08350269f, -0.06227504f, 0.13693564f, 
    -0.14370932f, -0.22758883f, -0.26505899f, -0.16179736f, 0.02396334f, -0.00935831f, 0.06826207f, 0.07739466f, 
    0.03254214f, -0.02269216f, -0.02961363f, -0.04105063f, 0.06000891f, -0.05982137f, 0.01336600f, 0.00230609f, 
    -0.05255557f, 0.03938493f, 0.08532363f, 0.13157654f, -0.50037211f, 0.38463345f, 0.45101935f, 0.12069516f, 
    0.15165029f, -0.17254700f, -0.11676717f, -0.04416867f, -0.20475768f, 0.23906370f, -0.19495739f, 0.10967168f, 
    0.08242038f, 0.02827355f, 0.05785730f, 0.01782364f, -0.00588017f, -0.02686919f, -0.00559588f, 0.00760635f, 
    0.11977773f, -0.07701273f, -0.11131062f, -0.04321127f, 0.11641306f, -0.03505481f, 0.02385485f, -0.03756355f, 
    0.06946196f, 0.09091967f, -0.02901937f, 0.06797367f, 0.02332161f, -0.12546612f, 0.05205644f, -0.08542444f, 
    -0.01895943f, -0.16172399f, 0.02016971f, 0.03369076f, -0.10173649f, 0.28789148f, 0.09867159f, -0.10631268f, 
    -0.03541161f, -0.12022594f, -0.01817286f, -0.13818240f, -0.12090899f, -0.10290709f, 0.00458791f, -0.13725686f, 
    -0.09061142f, -0.00616262f, 0.06941674f, 0.02793318f, -0.06356542f, -0.02202299f, -0.05767922f, -0.11657875f, 
    -0.35542500f, -0.31754142f, -0.03787148f, -0.12686934f, 0.57882643f, -0.11612055f, 0.09161603f, -0.02422594f, 
    -0.00448100f, 0.05307488f, 0.07430984f, 0.02957716f, 0.02763015f, 0.05780910f, -0.02075984f, -0.05776877f, 
    -0.00523398f, -0.05595300f, 0.11337735f, -0.00151242f, -0.64371008f, -0.64443386f, -0.58046198f, -0.08283469f, 
    -0.12720366f, -0.04789292f, -0.06497633f, -0.15317111f, -0.00759943f, -0.42524678f, 0.00618174f, -0.03871999f, 
    -0.09196392f, -0.01499264f, 0.04736285f, 0.00110968f, 0.00321750f, 0.12656489f, 0.11089046f, 0.04993054f, 
    -0.02549949f, -0.04870418f, 0.10006857f, -0.02862191f, 0.01545858f, 0.00036001f, -0.00370765f, 0.00155501f, 
    0.00342118f, 0.08021033f, -0.11451318f, 0.03837336f, 0.01579336f, 0.02182847f, -0.07596540f, 0.02699600f, 
    -0.00680116f, -0.01512590f, -0.10261291f, -0.00551585f, -0.22419973f, 0.03549363f, -0.13136894f, -0.16055676f, 
    -0.03594974f, -0.06546125f, -0.00365940f, 0.12622812f, 0.00028196f, 0.04798873f, 0.10297710f, 0.02623750f, 
    0.03424801f, -0.07019392f, -0.06090111f, 0.07736992f, 0.08685159f, -0.14712591f, -0.12696728f, 0.21527566f, 
    -0.27466816f, -0.04347727f, -0.05072402f, -0.10697026f, -0.14885896f, -0.02313675f, 0.11025374f, 0.07198266f, 
    0.06972297f, -0.01413390f, 0.01554637f, -0.06535722f, 0.04241019f, 0.09265055f, 0.06856521f, 0.01234776f, 
    0.04277198f, 0.20381980f, 0.17764978f, 0.04188346f, 0.04119942f, -0.07756397f, 0.04487767f, -0.01759780f, 
    -0.40289748f, 0.03856172f, 0.14151977f, -0.08641051f, -0.06404009f, 0.03519132f, -0.02022054f, -0.04995801f, 
    0.03372853f, 0.06186629f, -0.15000527f, 0.19851312f, 0.08140594f, 0.10432093f, 0.03548009f, -0.09235810f, 
    -0.19186287f, -0.86182195f, -0.32601228f, -0.08101298f, -0.00947202f, -0.01067260f, 0.21960457f, 0.16330709f, 
    -0.03549626f, -0.10261927f, 0.03500566f, -0.01267993f, 0.00093848f, 0.03725581f, 0.05719131f, 0.07450054f, 
    0.06349307f, 0.05081762f, -0.04133739f, 0.14682889f, 0.20972507f, -0.33853087f, -0.53674263f, -0.24151403f, 
    0.29929450f, -0.03580752f, 0.09832384f, 0.29387194f, 0.27162108f, -0.16725636f, 0.01534214f, -0.03970810f, 
    -0.12748033f, -0.01935755f, 0.04963585f, -0.03441038f, 0.04762205f, 0.03393440f, 0.27362436f, 0.09941506f, 
    0.38733041f, 0.26976618f, -0.04382462f, 0.07408327f, 0.05572226f, 0.05751079f, 0.01536990f, 0.09240806f, 
    0.15599278f, -0.02245098f, 0.24340497f, 0.17762659f, 0.08726003f, -0.23663962f, 0.13262767f, -0.04755361f, 
    0.13165513f, -0.11115167f, -0.02797431f, 0.01275805f, -0.11537623f, 0.42048153f, 0.03510503f, 0.00075624f, 
    0.19606139f, 0.09457517f, -0.03079215f, 0.01113003f, 0.01462791f, -0.08910888f, 0.00437865f, 0.03994883f, 
    0.19521420f, 0.12276682f, -0.01253039f, 0.08133858f, -0.09530478f, 0.12380944f, -0.12261018f, 0.04128579f, 
    0.09288222f, -0.57496607f, -0.72455013f, -0.38261130f, 0.60907304f, -0.05175203f, -0.07820802f, -0.04177877f, 
    -0.13913862f, 0.05517034f, 0.02574956f, 0.04400409f, 0.04953692f, 0.00990977f, -0.28135332f, -0.03897640f, 
    -0.01135471f, -0.01614386f, 0.10129807f, 0.02075737f, 0.12284362f, -0.06180720f, -0.16757528f, -0.17285235f, 
    0.01907032f, -0.07149193f, -0.02875903f, 0.10446352f, 0.02194739f, 0.03132609f, -0.07090456f, -0.07353274f, 
    -0.23062280f, -0.08618733f, -0.13930072f, -0.16887851f, -0.28071183f, -0.23186822f, -0.02113500f, 0.02018280f, 
    -0.49228302f, 0.52938753f, 0.46062651f, 0.02444267f, 0.13603096f, -0.10162137f, -0.09186105f, -0.12000433f, 
    -0.15475586f, 0.16575502f, 0.01154456f, 0.07840399f, 0.05939560f, 0.02806103f, 0.05477650f, 0.07125983f, 
    -0.04392722f, 0.02099764f, -0.03614693f, -0.02562258f, -0.09202915f, 0.15371485f, 0.17965955f, -0.10879569f, 
    0.17345096f, 0.00228875f, -0.00447286f, -0.06941706f, 0.03337708f, -0.00118508f, -0.07544133f, 0.01734011f, 
    0.10706510f, -0.02149663f, 0.02752419f, 0.07658084f, 0.06909163f, 0.03207056f, -0.12202872f, 0.11747643f, 
    -0.44274825f, -0.70588481f, -0.57086885f, 0.45975652f, -0.04043107f, 0.02160294f, -0.00114043f, 0.05674125f, 
    -0.09530851f, -0.20635150f, -0.00919583f, 0.02975016f, 0.01643796f, -0.03571868f, 0.01557813f, -0.04184984f, 
    0.00624652f, 0.16432500f, 0.10401071f, -0.06870812f, -0.54240000f, -0.77998769f, 0.02256548f, -0.05850396f, 
    -0.41464835f, 0.00106394f, -0.29355344f, -0.09956229f, -0.23954216f, -0.09811144f, -0.10045825f, 0.04548367f, 
    -0.01961413f, 0.06114034f, -0.07857429f, 0.02631407f, -0.03200999f, -0.00803981f, 0.03082023f, 0.02332492f, 
    0.09617930f, -0.06478728f, -0.05760420f, -0.09495214f, 0.03749537f, 0.02717373f, -0.02689485f, 0.00005114f, 
    -0.00807897f, -0.00482666f, -0.11701512f, -0.07806368f, -0.18172801f, -0.10083776f, -0.13555221f, -0.32569468f, 
    -0.25448412f, -0.10364150f, -0.05612042f, -0.03061476f, -0.23376146f, 0.37044582f, 0.17332788f, 0.02037023f, 
    0.02469327f, -0.08541780f, -0.08497856f, -0.18981677f, 0.04685949f, -0.02036577f, -0.02715129f, 0.00425083f, 
    -0.02046206f, 0.01434509f, 0.08872087f, 0.04512029f, -0.02902327f, -0.05920931f, -0.03708865f, -0.02743472f, 
    -0.09887788f, 0.17549908f, -0.19777398f, -0.03640644f, 0.27379829f, -0.01525666f, 0.10014530f, -0.06341178f, 
    0.06972936f, 0.25206640f, -0.02296569f, 0.09706303f, 0.04087255f, 0.05003722f, 0.09083617f, 0.07957192f, 
    0.13661999f, -0.17442894f, 0.17002179f, -0.06626084f, 0.15862143f, 0.00034674f, 0.13643287f, 0.02034030f, 
    0.08812920f, -0.00312036f, 0.01770867f, 0.08901040f, 0.05836565f, -0.02132357f, 0.11625645f, -0.02893623f, 
    -0.02645681f, -0.04341360f, 0.03176659f, -0.03532543f, 0.06415302f, -0.00267237f, -0.07365166f, 0.03899528f, 
    -0.43640137f, -0.13695541f, 0.11319117f, -0.03827211f, 0.06649864f, -0.26077256f, -0.00968392f, -0.12535188f, 
    -0.12266803f, 0.12262338f, -0.02229857f, -0.02799628f, 0.16314487f, 0.04265689f, 0.10067596f, -0.01351726f, 
    -0.00678496f, -0.15211134f, 0.16937424f, -0.21992014f, -0.24237286f, 0.21511193f, 0.03793148f, 0.06288448f, 
    0.26579350f, 0.00731873f, 0.03643832f, 0.00820362f, 0.02416947f, -0.08426832f, 0.14729831f, 0.20167102f, 
    0.14530510f, 0.16884853f, 0.07547053f, 0.03241687f, 0.00727477f, 0.11218603f, -0.04610576f, 0.07024287f, 
    -0.39445376f, -0.67141294f, -0.63172650f, -0.03444665f, 0.17945744f, -0.13343471f, 0.05784607f, 0.03279302f, 
    0.02866951f, -0.37941426f, 0.05539954f, -0.03061852f, -0.08916309f, -0.02846038f, 0.06056579f, 0.05337553f, 
    0.03493315f, 0.07168441f, 0.16950351f, 0.01348417f, 0.13299444f, 0.16453169f, 0.03461383f, 0.12767464f, 
    0.05888081f, 0.02388018f, 0.03712023f, -0.01800076f, 0.09105133f, 0.14688037f, -0.19617717f, 0.06118974f, 
    0.16713902f, -0.17648968f, -0.00601962f, -0.07916486f, 0.11111678f, -0.31311053f, 0.07175284f, -0.03964286f, 
    0.16269214f, -0.86968899f, -0.20408028f, 0.58818084f, 0.14932290f, 0.01243577f, 0.06237506f, 0.02937415f, 
    0.06900035f, 0.36677495f, 0.06074383f, 0.02213335f, -0.02212899f, -0.04795413f, -0.05882249f, 0.01166772f, 
    -0.00546970f, -0.04146412f, 0.03917855f, -0.08313334f, -0.49321955f, -1.08203626f, 0.24430019f, 0.72325927f, 
    0.21809596f, 0.04056033f, 0.32375947f, -0.20142166f, 0.06129788f, 0.01773891f, 0.06495549f, 0.02582715f, 
    -0.09514531f, 0.01652420f, 0.06368756f, -0.11637957f, 0.11606905f, -0.07031886f, -0.00705872f, 0.10849594f, 
    0.77112252f, -0.98196507f, -0.64405537f, -0.31432191f, -0.15481569f, -0.05344578f, -0.12599897f, -0.11762793f, 
    0.33084923f, -0.08440314f, 0.00407341f, 0.08869975f, -0.03340933f, -0.00059804f, 0.03066489f, -0.01399674f, 
    -0.03747679f, -0.00135241f, 0.05106457f, -0.02863644f, 0.65053570f, -0.42671207f, 0.44430447f, -0.70145714f, 
    -0.01333127f, -0.30907890f, 0.41474330f, -0.14477722f, 0.10846226f, -0.33946431f, 0.08673195f, -0.01043808f, 
    0.09781694f, -0.08482709f, 0.03997707f, -0.04770480f, 0.04170026f, 0.02365647f, -0.05754213f, 0.08681051f, 
    -0.14627102f, 0.17168292f, 0.14378029f, -0.09221166f, -0.23989296f, -0.04744748f, 0.05254009f, -0.01863764f, 
    -0.00847180f, -0.02547450f, 0.02673526f, -0.02245271f, 0.02582273f, -0.00142647f, 0.01195088f, 0.05131507f, 
    0.02974035f, -0.15715732f, -0.01347292f, -0.09690557f, 0.44319981f, 0.21834591f, -0.23399262f, -0.26185578f, 
    -0.31360713f, -0.00649693f, -0.07554182f, -0.00406857f, 0.00769357f, 0.09642565f, -0.01449701f, -0.06006370f, 
    0.10798651f, 0.04238082f, 0.12738214f, 0.03996044f, 0.04857283f, 0.01086423f, 0.05823753f, -0.02392563f, 
    0.03090629f, 0.02287273f, -0.04005173f, 0.04992896f, -0.19591638f, 0.01940482f, -0.00692829f, 0.04412830f, 
    -0.03280890f, -0.02320901f, -0.06414983f, 0.03868578f, -0.02160149f, -0.00267347f, -0.03591536f, -0.08190615f, 
    -0.06979447f, -0.02058183f, -0.03110734f, 0.02305155f, -0.03278498f, -0.08744898f, -0.07855559f, 0.02037765f, 
    -0.01035169f, 0.07945534f, 0.04884722f, 0.04752894f, -0.00603233f, 0.05899687f, -0.12141686f, 0.01068354f, 
    0.08802017f, 0.09355674f, 0.06766765f, 0.00523389f, 0.04754858f, -0.02207534f, -0.00294356f, -0.05066297f, 
    0.42677745f, -0.40255943f, -0.37363213f, -0.40755525f, -0.25187704f, 0.06847673f, -0.11726049f, 0.03255988f, 
    -0.02591846f, -0.07797838f, -0.00307697f, 0.02288499f, 0.01639077f, 0.04217731f, -0.04354788f, -0.07534920f, 
    -0.10181274f, 0.07725599f, -0.09371040f, -0.06304768f, -0.44251245f, -0.38720673f, 0.53676480f, 0.02293569f, 
    0.37427601f, -0.10853472f, 0.05797522f, -0.01861711f, 0.08805097f, 0.09570637f, -0.00610552f, -0.00404447f, 
    -0.07874815f, -0.05946454f, -0.02319730f, -0.01917794f, -0.02237381f, -0.08087254f, 0.08206702f, -0.08196809f, 
    0.03344388f, 0.12932216f, 0.06446326f, 0.00620613f, -0.05098727f, -0.00271137f, 0.00339780f, 0.01505194f, 
    -0.03706877f, -0.10648004f, -0.06941366f, -0.20606379f, -0.18642588f, -0.28512046f, -0.12528081f, -0.05158616f, 
    -0.01602299f, -0.01583219f, 0.00126422f, 0.03015840f, -0.10643510f, 0.14312768f, -0.20306544f, 0.23531531f, 
    -0.33443266f, 0.00861761f, 0.11115108f, 0.03080077f, -0.09557115f, -0.03516575f, 0.03204085f, 0.03098090f, 
    0.07015853f, 0.05313078f, 0.07587499f, -0.08166386f, -0.00120968f, 0.13159810f, -0.25299704f, 0.08268920f, 
    -0.21430589f, 0.23858711f, 0.27506426f, 0.12917461f, 0.06585068f, 0.07018591f, -0.21139830f, 0.01103114f, 
    -0.06217014f, -0.10604426f, -0.03884644f, -0.08442225f, -0.01170905f, 0.02536282f, 0.02744951f, 0.18944573f, 
    0.06310553f, 0.09608992f, -0.04205533f, 0.04382485f, 0.18673818f, -0.12185349f, -0.01453607f, -0.10236403f, 
    -0.04032728f, 0.04677155f, 0.06106415f, 0.02072034f, -0.01296617f, -0.00638295f, -0.02409188f, 0.05199136f, 
    0.03256517f, -0.05938909f, -0.01340664f, 0.02785213f, -0.00997490f, -0.18442376f, -0.03066928f, 0.07602818f, 
    0.02642940f, 0.30136582f, 0.13854027f, -0.24678645f, -0.16952382f, -0.00946664f, -0.00736563f, -0.09437911f, 
    -0.07861002f, 0.04359572f, 0.04045286f, 0.04514888f, 0.09370506f, 0.02337811f, -0.03522252f, 0.15158759f, 
    0.05935827f, -0.03461222f, 0.00633631f, -0.01979393f, -0.24325979f, -0.04736590f, -0.23229912f, 0.21843269f, 
    -0.36965093f, 0.12653664f, -0.06776687f, -0.07328562f, -0.04209798f, 0.01747137f, 0.08651583f, 0.05071148f, 
    0.00113235f, 0.05149217f, 0.01460333f, -0.00125607f, -0.05274035f, 0.00705711f, -0.02665792f, 0.03255519f, 
    -0.09062588f, 0.05211341f, 0.08844691f, -0.14174163f, 0.08167820f, 0.07394113f, -0.05373599f, 0.01547134f, 
    0.03303995f, -0.05066251f, 0.01071087f, -0.08097810f, 0.06703164f, -0.06483714f, -0.04632950f, 0.05438785f, 
    -0.09416623f, 0.01283579f, -0.00748231f, -0.01534643f, -0.27261651f, -0.08055707f, 0.13016166f, 0.01455086f, 
    0.00554257f, 0.03843415f, -0.00229389f, 0.13292396f, 0.04421198f, 0.04660551f, -0.20496918f, -0.01640990f, 
    0.12205814f, 0.17442563f, -0.09419481f, 0.00233286f, 0.01227604f, -0.04219122f, -0.00178811f, 0.10023917f, 
    0.44784889f, -0.78051388f, -0.68240887f, -0.66960460f, -0.36545131f, 0.12125192f, 0.06002123f, -0.10623454f, 
    0.25281811f, 0.06960806f, 0.04363523f, 0.05369463f, -0.07803991f, 0.09551003f, 0.02916314f, -0.19483145f, 
    -0.10073013f, 0.02318633f, 0.03533985f, 0.15161581f, 0.02763359f, 0.12438132f, -0.14548166f, 0.04726118f, 
    -0.22005071f, 0.00717554f, -0.05504703f, -0.00877217f, 0.00550830f, -0.09238207f, 0.03748618f, 0.04988001f, 
    0.05198336f, -0.03683398f, 0.01614572f, -0.22814073f, -0.19358011f, 0.18337545f, 0.06857378f, 0.07278100f, 
    0.28287247f, -0.32729992f, -0.29727653f, -0.24706016f, -0.27814502f, -0.03835364f, -0.17569874f, 0.04061987f, 
    0.11234194f, -0.03518922f, -0.04255237f, -0.00161795f, 0.07650670f, 0.06312175f, 0.05142474f, -0.02037662f, 
    0.01560517f, 0.07017606f, 0.00577616f, 0.01038679f, 0.03546416f, -0.02687888f, -0.09378466f, 0.00317258f, 
    -0.07298575f, 0.01717409f, 0.09094746f, 0.08522939f, 0.01172800f, -0.03148063f, -0.05761848f, -0.10820886f, 
    -0.11388582f, 0.05322380f, -0.04908986f, -0.07638534f, -0.06839894f, -0.22264864f, 0.04927396f, 0.12262381f, 
    -0.61647964f, -0.63918549f, 0.06026420f, -0.34365419f, 0.53330517f, -0.06940234f, -0.08894464f, 0.08685812f, 
    0.05162863f, -0.01495852f, 0.02324715f, -0.04952300f, -0.02127054f, -0.13638295f, -0.05928142f, 0.05438343f, 
    0.02944282f, -0.11230303f, 0.07359361f, -0.16522597f, 0.58743060f, -0.79912531f, 0.45582056f, -0.42440969f, 
    -0.09741199f, -0.09538954f, 0.12047122f, -0.28733283f, 0.40614226f, 0.07346804f, 0.03796651f, 0.00054100f, 
    0.04093255f, -0.09620960f, 0.03789862f, -0.02193213f, 0.00400028f, -0.16165261f, 0.15586446f, 0.00652258f, 
    -0.03228691f, 0.14317755f, -0.02393747f, 0.08199118f, -0.13830058f, -0.01013234f, -0.03538995f, -0.00197967f, 
    0.03240859f, -0.03240415f, 0.03334519f, 0.05043427f, 0.09388532f, 0.02752450f, -0.08785487f, -0.11653297f, 
    -0.13625912f, 0.11374177f, 0.05965075f, 0.08757671f, 0.04490229f, -0.17396978f, -0.11240721f, -0.11293294f, 
    0.00963029f, 0.09567095f, 0.05157799f, 0.02007674f, 0.00364321f, 0.00277251f, -0.13316751f, 0.05474509f, 
    0.03326416f, 0.08088207f, 0.07281908f, -0.00319587f, 0.00605226f, -0.02768566f, -0.00104608f, -0.00459930f, 
    0.33627558f, 0.19641602f, -0.29552174f, 0.10292304f, -0.14061888f, 0.06198898f, 0.03395599f, -0.11333479f, 
    -0.16089778f, -0.02509148f, -0.00179960f, -0.04334839f, 0.08102161f, 0.00350705f, -0.14053828f, -0.10925236f, 
    -0.30048165f, 0.03710460f, -0.10192807f, -0.15722975f, -0.00579466f, 0.08709298f, 0.06696177f, -0.09479938f, 
    0.00716970f, -0.03638463f, -0.06568845f, -0.01994765f, -0.01449814f, 0.00027733f, 0.01074256f, -0.02162191f, 
    0.11466722f, -0.06719901f, -0.03948186f, -0.14846689f, -0.25904080f, -0.02450030f, -0.03061600f, 0.01761062f, 
    0.38143376f, -0.08120278f, -0.23498516f, 0.31572151f, -0.04945210f, 0.34875196f, -0.03769908f, 0.07287006f, 
    -0.08080713f, 0.08213110f, 0.10090493f, 0.09684187f, 0.18002567f, -0.03903435f, 0.00025162f, -0.07327319f, 
    -0.05951856f, 0.01311484f, -0.02805568f, -0.15256967f, -0.23749720f, -0.12011441f, 0.24556972f, 0.08457140f, 
    0.08420597f, -0.00832073f, -0.00022542f, 0.13706715f, 0.02917326f, 0.00106436f, -0.10136979f, -0.00341562f, 
    0.04812303f, 0.02058558f, 0.03527772f, -0.07154799f, 0.01451856f, -0.10556350f, 0.05116985f, 0.12404586f, 
    -0.60639137f, -0.83824354f, -0.59423864f, 0.51070768f, -0.11858755f, -0.02995900f, 0.09813961f, 0.00379780f, 
    0.00948206f, -0.01147710f, -0.02066778f, -0.02862923f, 0.05091674f, -0.05650229f, -0.06455281f, 0.02455683f, 
    0.04442409f, -0.10917853f, -0.18674907f, -0.06509747f, 0.03397213f, 0.10438995f, 0.05511503f, -0.06241282f, 
    -0.02180573f, -0.02322475f, 0.06649375f, -0.06125492f, -0.01572077f, -0.05449168f, 0.04064938f, 0.04450135f, 
    -0.02886348f, -0.05756464f, 0.07147285f, -0.00371295f, -0.09589811f, 0.05032894f, -0.03363958f, -0.02350981f, 
    -0.08617484f, -0.89711845f, -0.75381476f, -0.23540449f, -0.35066679f, 0.01779283f, -0.01629021f, -0.23971270f, 
    -0.03521641f, -0.06088988f, -0.04490396f, 0.00050764f, 0.03526742f, -0.00084335f, 0.06229024f, -0.01898627f, 
    0.04989239f, 0.06968356f, 0.13381711f, 0.20958111f, 0.93729866f, 0.53365737f, -0.27863786f, -0.07945185f, 
    0.03354654f, 0.14127991f, -0.22996286f, 0.01638268f, 0.09324940f, -0.23769373f, 0.09189001f, 0.12063156f, 
    0.20362055f, 0.03702836f, -0.02460001f, 0.06129348f, 0.08092893f, 0.05274442f, 0.04609217f, -0.04094290f, 
    -0.30604354f, -0.99291182f, -1.12106037f, -0.53526205f, 0.17320107f, 0.10316338f, 0.14656359f, 0.26075548f, 
    0.22327977f, 0.12478554f, -0.04393832f, -0.08069517f, -0.09117019f, 0.00833329f, -0.01124781f, 0.04027716f, 
    -0.03426653f, -0.06848133f, -0.07743777f, -0.02168649f, 0.40185073f, -0.00137792f, -0.25530636f, -0.25532937f, 
    0.02535876f, 0.19449455f, 0.01825865f, 0.07058272f, 0.12626015f, 0.41753721f, 0.06951378f, 0.11008891f, 
    0.01906426f, 0.02504702f, 0.09171824f, 0.05444847f, 0.28023112f, 0.09026191f, 0.01502613f, 0.12230882f, 
    -0.40909478f, 0.25453964f, 0.23058288f, 0.15082611f, -0.06378360f, 0.05711250f, -0.17733623f, -0.08692510f, 
    -0.05937634f, -0.21050471f, -0.04061709f, -0.00595788f, -0.03085533f, -0.12644224f, -0.00522694f, -0.14620599f, 
    -0.00032532f, -0.10102143f, -0.08294512f, -0.05090228f, -0.09526066f, -0.44416395f, -0.32038638f, -0.19096398f, 
    -0.07961988f, -0.07372198f, 0.11898784f, 0.13497922f, 0.08635497f, 0.08701774f, 0.13066873f, 0.01534748f, 
    0.02259868f, -0.08788396f, -0.04902698f, -0.03086038f, 0.07335701f, 0.04616121f, 0.05537344f, -0.02683719f, 
    0.17267834f, 0.16148809f, -0.01726188f, -0.03310026f, -0.04645931f, -0.05579137f, -0.00411386f, -0.04052339f, 
    -0.02090052f, -0.14280808f, -0.01516189f, -0.03711898f, 0.03294052f, 0.05144864f, 0.08995181f, 0.03981192f, 
    0.12391733f, 0.10040174f, 0.18663372f, 0.08090364f, -0.06434103f, -0.23006317f, -0.20507820f, -0.03513524f, 
    -0.01310470f, -0.10115514f, -0.05315259f, -0.04627937f, 0.00797852f, 0.09276674f, 0.06599716f, 0.03635786f, 
    -0.07714773f, -0.01413031f, -0.05052711f, -0.00356284f, 0.14746082f, 0.13201305f, 0.20582280f, 0.09982504f, 
    0.07990301f, -0.32602841f, -0.46621889f, -0.23792475f, 0.18295205f, -0.00531951f, 0.20730630f, 0.05693235f, 
    0.18980817f, -0.16586177f, 0.01474251f, -0.02968937f, -0.01731507f, 0.06824832f, 0.06468476f, 0.09174463f, 
    -0.02441730f, -0.07587473f, 0.02379631f, -0.09738051f, 0.36849815f, -0.44581541f, -0.36688945f, -0.09340878f, 
    -0.06209582f, 0.05521683f, -0.07063868f, -0.08741449f, -0.03379600f, -0.12328773f, 0.01583196f, 0.01091438f, 
    0.06508759f, 0.04123652f, 0.04809548f, 0.03013257f, 0.07703114f, 0.08683649f, -0.09418120f, -0.07908440f, 
    -0.22361714f, -0.00869511f, 0.10798409f, 0.02503369f, -0.24109563f, -0.13057846f, 0.01528138f, 0.07629538f, 
    0.06735019f, -0.06579178f, 0.03300847f, 0.07472046f, 0.07463377f, 0.10906143f, 0.11506967f, 0.04946207f, 
    0.04446861f, 0.04877033f, 0.04500318f, 0.05148974f, -0.55670446f, 0.22509828f, 0.34705999f, 0.04121643f, 
    -0.04015135f, -0.07148873f, 0.01313813f, -0.12585162f, 0.07802828f, -0.00020246f, -0.10233823f, -0.09234346f, 
    -0.02313522f, -0.09814469f, 0.01086967f, -0.03752941f, -0.09326597f, -0.28230485f, -0.04926402f, -0.37345681f, 
    -0.10225427f, -0.00937833f, 0.05136010f, 0.01406575f, -0.02021039f, 0.06593460f, -0.06945687f, 0.06896839f, 
    -0.03482306f, -0.02181141f, 0.06346292f, 0.03018202f, 0.03914674f, -0.03941727f, 0.03098814f, -0.17069887f, 
    -0.11295831f, -0.07031066f, -0.22498196f, -0.47778395f, 0.23513357f, 0.16070560f, 0.16206791f, 0.07234065f, 
    -0.11373664f, -0.12483262f, -0.13671827f, -0.13463759f, 0.03569160f, -0.03587095f, 0.00465694f, -0.13116822f, 
    0.01737769f, 0.03214774f, 0.01361047f, -0.21642314f, -0.10056346f, -0.11730210f, -0.54099828f, -0.32122225f, 
    -0.45836562f, 0.10731678f, 0.30450794f, 0.14699824f, -0.06995205f, 0.02615727f, -0.27879918f, -0.20466907f, 
    -0.07149351f, -0.21006313f, -0.06344942f, -0.08103881f, -0.08160092f, -0.14005204f, -0.08929745f, -0.04961584f, 
    -0.15614119f, -0.19023636f, -0.28730923f, -0.17238936f, 0.35781410f, 0.15998396f, 0.02448996f, 0.05478563f, 
    -0.30749840f, 0.07249422f, -0.14043936f, -0.04619379f, 0.04711033f, -0.32061094f, -0.02450603f, 0.06838128f, 
    0.09543245f, -0.00359581f, -0.00675472f, 0.01178792f, 0.09233263f, 0.17092730f, 0.22309698f, 0.17243379f, 
    -0.36659220f, -0.06453719f, -0.03300923f, 0.00098589f, 0.34342736f, 0.10455737f, 0.08453105f, -0.00697258f, 
    0.07574058f, -0.04260458f, 0.04073600f, -0.04490857f, 0.06458516f, 0.06343880f, 0.06489609f, -0.08623324f, 
    -0.01233170f, 0.12037738f, 0.07338173f, 0.10727144f, -0.52084780f, -0.51980460f, 0.22201680f, 0.14111966f, 
    0.10598291f, -0.08364951f, 0.02636009f, 0.05022139f, -0.09301698f, 0.12266165f, 0.08726597f, 0.06860218f, 
    0.03476264f, 0.12250511f, 0.06430589f, -0.07267047f, 0.05801880f, -0.08831698f, 0.08447807f, 0.07528228f, 
    0.05318068f, -0.19385692f, -0.75443894f, -0.47376743f, 0.10678955f, -0.13889873f, 0.01929892f, 0.10184290f, 
    0.10060180f, 0.00251147f, -0.00482961f, -0.10833480f, -0.09147468f, -0.05335793f, 0.09532790f, 0.14049342f, 
    -0.10327254f, 0.08875787f, -0.12703507f, -0.27229726f, -0.29573560f, 0.13053890f, 0.10114766f, 0.06647395f, 
    -0.19314444f, -0.06743187f, 0.01277204f, -0.05874319f, 0.03711576f, -0.05301556f, -0.08540399f, -0.12734424f, 
    -0.04043463f, 0.09346870f, -0.02917920f, 0.04428669f, 0.08151249f, -0.02559705f, 0.04559111f, -0.03411515f, 
    0.04135282f, -0.45947039f, -0.40599847f, -0.11996531f, 0.05006544f, -0.02021714f, 0.15436071f, 0.10618587f, 
    0.10736511f, 0.11210918f, 0.05925477f, -0.08422908f, 0.04894178f, -0.06054061f, -0.01268599f, 0.00032353f, 
    0.02799774f, 0.00036413f, 0.03506169f, -0.07362441f, -0.34156269f, -0.07274076f, 0.15156712f, 0.05343828f, 
    -0.01887485f, -0.07559881f, -0.09509364f, -0.03548364f, -0.03531050f, -0.04977911f, 0.01488761f, 0.06823295f, 
    -0.04225544f, 0.04182944f, 0.09218661f, -0.00840011f, 0.02984484f, 0.05386272f, -0.15905218f, -0.07046258f, 
    0.67515522f, -0.31957343f, -0.37270954f, -0.04931950f, 0.12134214f, 0.03071656f, -0.03872177f, -0.02251698f, 
    -0.00924491f, -0.11185089f, 0.02998775f, -0.02638258f, 0.05530129f, -0.00855737f, 0.12751535f, 0.02612093f, 
    -0.01993773f, 0.03134215f, -0.17325543f, -0.19768481f, -0.13735627f, -0.16591445f, -0.86188996f, -0.42558295f, 
    -0.11035123f, 0.23166728f, -0.31789431f, 0.16518034f, -0.07442182f, -0.14578401f, 0.03887362f, 0.03232612f, 
    -0.03560951f, 0.09103601f, 0.09557734f, 0.08642879f, -0.02758658f, 0.01139438f, -0.02176835f, -0.03148444f, 
    -0.21861818f, -0.03603411f, 0.04449309f, -0.04311156f, -0.23678723f, -0.11749010f, -0.02882765f, -0.07498901f, 
    0.02743936f, -0.04867519f, -0.07602579f, -0.04744010f, -0.11423263f, 0.04629210f, 0.01799710f, 0.07712845f, 
    0.22159348f, 0.03303516f, 0.16390373f, 0.01917323f, 0.03792722f, -0.19167770f, -0.19563936f, -0.05426353f, 
    -0.00377389f, 0.03076729f, 0.01342884f, 0.00582353f, -0.03436202f, 0.10288922f, -0.04450374f, 0.04350329f, 
    -0.16710335f, -0.00808434f, -0.03534418f, -0.00414000f, 0.06996371f, 0.12105950f, 0.12226511f, 0.12878996f, 
    0.45052499f, 0.05202809f, -0.15067446f, -0.04948243f, -0.09824522f, 0.13645461f, 0.11854721f, 0.10302497f, 
    0.08736384f, 0.03063445f, 0.09060083f, -0.04365709f, 0.02431625f, 0.07204641f, 0.03551800f, 0.06380340f, 
    0.03785984f, -0.08334298f, 0.22318515f, -0.06445499f, -0.28182879f, 0.01021267f, 0.12476165f, 0.07370415f, 
    0.04189216f, 0.02481190f, -0.08531653f, 0.09360678f, 0.08262340f, -0.06078114f, 0.02763164f, 0.05534618f, 
    -0.02129774f, 0.03386237f, 0.12765044f, -0.04850220f, 0.08432058f, 0.01542336f, -0.06288691f, 0.15913452f, 
    0.39992142f, -0.00682557f, -0.24186818f, -0.13159944f, -0.16315015f, 0.11382961f, 0.00641085f, -0.10200766f, 
    0.02340719f, -0.07986338f, 0.03830732f, -0.09798045f, 0.10439906f, 0.07063683f, -0.02055476f, -0.03573017f, 
    0.03620970f, -0.06324101f, 0.23423219f, -0.00590946f, -0.29738748f, -0.36659098f, 0.17483154f, 0.23372856f, 
    0.28622156f, -0.15475351f, 0.00166189f, -0.05921710f, -0.03670341f, 0.02179951f, 0.01691918f, 0.04489191f, 
    0.06513564f, 0.08044367f, 0.07669366f, -0.03585544f, -0.05559751f, -0.05321877f, -0.03075780f, 0.02518178f, 
    0.39201283f, -0.01124365f, -0.15163292f, -0.12918714f, 0.16750009f, 0.16430505f, 0.09418982f, 0.15884358f, 
    0.10028330f, -0.12391385f, -0.04750843f, 0.14986698f, 0.07839617f, -0.03552784f, 0.01978885f, 0.04791667f, 
    0.05682329f, 0.17886873f, 0.07841925f, 0.27496490f, 0.15394638f, 0.16316187f, 0.00062117f, 0.03127156f, 
    0.09124761f, 0.01768009f, 0.10563439f, 0.05590498f, 0.04207653f, -0.06070310f, -0.09223851f, 0.01099530f, 
    -0.03030721f, -0.01416346f, 0.03324367f, -0.00375889f, 0.02475404f, -0.07343479f, 0.00881640f, 0.06851112f, 
    -0.32568321f, -0.11410791f, 0.22439110f, 0.17449291f, -0.30802560f, -0.04661755f, -0.42993239f, 0.38099298f, 
    0.22483945f, 0.19540441f, -0.02799060f, -0.03874244f, 0.03176038f, -0.06058697f, -0.12674813f, 0.03928249f, 
    0.00216105f, 0.05927498f, 0.13032551f, -0.18157977f, 0.13735031f, -0.49664631f, -0.70104760f, 0.13896310f, 
    -0.44790292f, 0.00074546f, -0.12370905f, -0.04763405f, 0.05260416f, 0.03696091f, 0.08159414f, -0.03104872f, 
    -0.02070227f, 0.03168986f, -0.01669955f, -0.01885945f, 0.07798864f, -0.10279100f, 0.12595285f, 0.17840183f, 
    0.09224246f, -0.16975291f, 0.41244876f, 0.47290519f, -0.92669380f, 0.02328097f, -0.26727742f, -0.47311160f, 
    0.05418409f, -0.18885271f, 0.09827254f, -0.06992294f, 0.12141670f, 0.06293739f, 0.13190722f, 0.06305221f, 
    -0.06141315f, 0.02216525f, -0.01853317f, 0.03887614f, -0.45922688f, -0.68889058f, -0.02425322f, -0.34346858f, 
    -0.02087365f, -0.47361553f, 0.26279736f, -0.25086287f, -0.24734080f, -0.09031079f, 0.08614713f, -0.12327948f, 
    -0.00335794f, -0.04033161f, 0.02067551f, 0.16709267f, -0.01953822f, -0.00842938f, -0.15547097f, -0.12696010f, 
    -0.13496916f, -0.24357812f, -0.72400564f, 0.15911168f, 0.04648563f, 0.00946581f, 0.18127523f, 0.30774093f, 
    -0.01742064f, 0.12744777f, -0.00624266f, 0.05687746f, -0.03545232f, -0.01004308f, -0.01395227f, -0.03833397f, 
    0.12312262f, -0.01770972f, 0.00610837f, 0.06304614f, 0.10641386f, 0.20571698f, 0.27770641f, 0.48662600f, 
    -0.30906782f, 0.17461944f, -0.11061640f, -0.26363224f, -0.11996888f, -0.23544882f, 0.07298329f, 0.02616165f, 
    0.08815737f, 0.11974546f, 0.09520586f, 0.09423774f, -0.04190763f, -0.05226073f, 0.01791784f, 0.03141907f, 
    -0.23772393f, 0.19294274f, -0.32518575f, 0.11833249f, 0.14924701f, 0.00713659f, 0.19288331f, 0.23210250f, 
    -0.02417973f, -0.09705952f, 0.08043540f, -0.00536175f, -0.01519995f, -0.05174802f, -0.00044959f, 0.07668651f, 
    0.00579449f, -0.16816071f, 0.03205694f, -0.00486112f, -0.07179119f, 0.21599513f, 0.45964727f, 0.12994891f, 
    -0.05511809f, 0.05551549f, -0.12792520f, -0.09395830f, -0.07887439f, -0.05397097f, 0.05365027f, 0.09011282f, 
    0.03374097f, -0.01484498f, 0.06491135f, -0.10570554f, -0.08303166f, -0.11991624f, -0.06536543f, -0.03602457f, 
    -0.05073145f, 0.06679899f, -0.12121420f, 0.22064155f, -0.47060359f, 0.11062402f, -0.19943933f, -0.08623248f, 
    -0.00074606f, 0.03731894f, -0.03436270f, -0.08784471f, 0.00973206f, 0.02687855f, 0.00428830f, 0.02170080f, 
    0.03374766f, 0.08944969f, 0.02296153f, 0.05667797f, -0.12013472f, -0.28421837f, 0.23154587f, 0.08550540f, 
    -0.09693584f, -0.21064547f, -0.08953730f, 0.22254150f, 0.06671239f, 0.20771271f, -0.08606814f, 0.03774410f, 
    0.06612714f, 0.01090818f, -0.01045365f, 0.00660778f, 0.04924647f, 0.05655247f, 0.11724965f, -0.10313377f, 
    -0.12813953f, 0.08035245f, 0.10773499f, 0.06194863f, 0.18786606f, -0.01764754f, 0.01449581f, -0.00550938f, 
    -0.03782250f, -0.05056848f, 0.14220916f, 0.09091079f, 0.02972887f, -0.00002774f, -0.04668050f, 0.16163427f, 
    0.04457167f, -0.01069870f, -0.09601220f, 0.05952665f, -0.51764864f, -0.16630012f, -0.46314847f, -0.35827768f, 
    0.30945158f, 0.12295608f, -0.04872556f, 0.15313019f, -0.01678413f, -0.00532970f, 0.08791928f, 0.02712522f, 
    -0.04884407f, 0.11847880f, 0.10469129f, -0.02514192f, 0.08924703f, -0.09543581f, 0.03825532f, 0.05223292f, 
    0.17404988f, -0.46818152f, -0.38929659f, 0.05791341f, 0.00811111f, 0.04287802f, -0.08560087f, 0.13381471f, 
    -0.04210388f, 0.12855791f, -0.01197781f, 0.10004386f, -0.00072409f, -0.04198670f, -0.03427415f, 0.13820763f, 
    0.13814808f, 0.23417842f, 0.04846613f, 0.36491209f, -0.19324633f, -0.19702321f, 0.12475983f, 0.00556362f, 
    0.30867398f, -0.08200852f, 0.14482519f, -0.20866390f, 0.07502948f, -0.08873694f, 0.01976208f, -0.14026818f, 
    0.11462826f, 0.08266193f, -0.08095874f, -0.00991940f, 0.19806075f, -0.12069420f, -0.09773098f, 0.12120366f, 
    0.25588727f, -0.35815826f, -0.28837654f, 0.15950471f, 0.03931884f, 0.12677515f, 0.13307218f, 0.28367537f, 
    -0.01342870f, 0.29413584f, -0.02674587f, -0.06612375f, -0.17522568f, 0.03076643f, -0.09496130f, -0.02437330f, 
    0.01508481f, 0.01893723f, -0.12385911f, -0.05746443f, -0.23162888f, 0.59827393f, -0.83064175f, 0.15036534f, 
    -0.36630324f, 0.05595497f, 0.08865040f, 0.21968749f, -0.06812751f, 0.01762694f, 0.12280983f, -0.00436079f, 
    -0.00577559f, -0.13921751f, -0.06877892f, 0.09293629f, -0.13276871f, -0.21013771f, 0.06842368f, -0.15648913f, 
    -0.03125979f, 0.11776464f, 0.04673475f, -0.61611956f, -0.24928649f, -0.01722196f, -0.19403701f, 0.01583416f, 
    -0.07374921f, 0.01484901f, -0.16474269f, 0.07608883f, -0.05173137f, -0.06496958f, 0.00473104f, 0.08024688f, 
    0.01140190f, 0.04709272f, 0.00223539f, -0.06067461f, 0.16034834f, -0.23811696f, 0.35810411f, -0.65893722f, 
    -0.13326776f, -0.04761916f, -0.32326525f, 0.02186629f, 0.06233910f, -0.15980247f, -0.13868771f, 0.11271030f, 
    -0.07468664f, -0.01393464f, 0.06175170f, 0.09539069f, 0.09417452f, 0.07994319f, -0.11551149f, 0.10777116f, 
    0.12298694f, 0.16161251f, 0.04702510f, 0.64917654f, -0.65571463f, 0.01812765f, 0.03573023f, -0.18732949f, 
    0.09236419f, -0.11408403f, 0.05112393f, -0.08172186f, 0.10224844f, 0.00199963f, 0.07055928f, 0.12094132f, 
    0.12091404f, 0.22478406f, 0.19517796f, 0.14744224f, -0.47083208f, 0.05612761f, -0.31182075f, -0.07796858f, 
    0.01462540f, 0.09891237f, -0.00901958f, 0.16414849f, -0.03060427f, -0.07119893f, 0.10462082f, -0.00362254f, 
    0.12527156f, 0.09934141f, 0.07907844f, 0.14045595f, 0.06667710f, -0.01337298f, -0.02831639f, 0.07673498f, 
    0.13078801f, 0.04044968f, 0.28468007f, 0.39660364f, -0.43380913f, 0.14247878f, -0.03037155f, -0.29425007f, 
    0.02125305f, -0.18243378f, 0.09436718f, 0.02160426f, 0.06911694f, 0.15505441f, 0.04135128f, 0.08933368f, 
    0.03599332f, -0.05283817f, 0.04946371f, 0.10029622f, 0.09067555f, 0.07914155f, -0.25361007f, 0.08360019f, 
    0.14978911f, 0.02684185f, -0.10774782f, 0.16675125f, -0.03140588f, -0.08029082f, -0.01800053f, 0.03908973f, 
    0.03032788f, -0.00403493f, -0.25208980f, 0.10841914f, -0.02013099f, 0.07860070f, -0.07988134f, 0.10290233f, 
    0.05489039f, -0.16414638f, 0.20099108f, -0.08044970f, -0.22261460f, -0.07829371f, -0.18099470f, -0.02977469f, 
    0.11261705f, 0.17465644f, -0.04262863f, 0.03397331f, 0.01486959f, 0.02995001f, -0.07956820f, -0.03630203f, 
    0.13016704f, 0.13322683f, 0.08898088f, 0.15921763f, -0.24856864f, -0.27241981f, -0.31169933f, 0.05808372f, 
    -0.53772610f, -0.38930693f, 0.14552465f, 0.06946079f, 0.20716426f, 0.16551892f, 0.11203530f, -0.03420781f, 
    0.06647795f, 0.01342072f, 0.08491436f, -0.06489812f, 0.05849944f, -0.04742454f, 0.02761430f, -0.07946482f, 
    -0.19055708f, -0.04430527f, -0.16394068f, -0.29912904f, -0.04099007f, 0.09714103f, 0.11146122f, 0.14994393f, 
    0.07261319f, 0.01260369f, 0.23033990f, -0.02797106f, -0.02003110f, 0.07463506f, 0.04801835f, 0.12470742f, 
    -0.10198455f, -0.02095070f, -0.04221896f, 0.03225405f, 0.12403661f, 0.15014969f, 0.27838495f, -0.03456448f, 
    -0.17115690f, 0.00432323f, -0.01779591f, -0.13722080f, -0.06566497f, -0.10912517f, 0.05353067f, -0.06004591f, 
    0.04734938f, 0.00419031f, 0.01912463f, -0.04860118f, -0.06688212f, -0.05959133f, -0.08341645f, -0.03770817f, 
    -0.32183382f, 0.17507488f, -0.36480343f, 0.32670039f, -0.03482408f, -0.04763186f, -0.07939520f, -0.10571882f, 
    -0.06428392f, -0.20320319f, -0.09276333f, -0.11014476f, -0.00842733f, -0.09577225f, -0.08574554f, -0.07181590f, 
    -0.04578953f, -0.05610282f, 0.02278039f, 0.12514356f, 0.03019927f, -0.01066422f, -0.24023874f, -0.03775442f, 
    -0.06629884f, 0.08512479f, 0.14324741f, 0.17786890f, -0.05767626f, 0.10459624f, 0.00165751f, 0.02567020f, 
    -0.17413709f, -0.05008612f, 0.03400546f, 0.07618656f, -0.00169910f, -0.08806033f, -0.04489576f, -0.13790131f, 
    -0.46884924f, 0.11421448f, 0.03015365f, 0.36367050f, -0.28516877f, 0.03669598f, -0.13516305f, -0.16560201f, 
    -0.10086786f, -0.16835792f, -0.04886874f, -0.11973976f, -0.00630086f, -0.03989721f, -0.03587425f, 0.11092652f, 
    -0.09479080f, -0.15906003f, -0.01994888f, -0.10033649f, 0.09717394f, -0.32395020f, 0.03755694f, -0.14236593f, 
    -0.08588994f, -0.16598761f, -0.07065789f, 0.00742327f, 0.11841933f, -0.04145461f, -0.11801327f, 0.04654789f, 
    -0.01626745f, 0.05058142f, -0.05684549f, 0.05460816f, 0.10232709f, 0.17754517f, -0.01048224f, 0.14472950f, 
    -0.12201621f, 0.45149371f, -0.31351385f, -0.19674511f, -0.18339188f, 0.02589826f, -0.20834331f, 0.02173804f, 
    -0.10155075f, 0.13344254f, -0.06883200f, 0.09380348f, -0.09892011f, -0.11292047f, 0.04031986f, 0.04985319f, 
    -0.03554428f, 0.10855705f, 0.08695291f, -0.24054380f, -0.15459079f, -0.11267620f, -0.31680930f, -0.12408603f, 
    0.06518978f, -0.05780011f, 0.12216920f, 0.22418968f, -0.02914444f, -0.18366796f, 0.07404485f, 0.07087700f, 
    -0.07992391f, 0.01769027f, 0.00540079f, -0.03999471f, 0.19134322f, -0.08160314f, -0.12342492f, 0.14592601f, 
    -0.65140635f, -0.08327127f, -0.41481164f, -0.17011796f, 0.03649152f, -0.03874083f, -0.07353332f, -0.03305032f, 
    -0.02844451f, -0.01890312f, -0.06867116f, 0.13547687f, 0.02161682f, 0.04382284f, -0.01838525f, 0.10950506f, 
    0.04452345f, -0.15015027f, 0.09286274f, 0.09923512f, -0.70991731f, -0.24158683f, 0.26451439f, -0.10572905f, 
    0.09115607f, 0.05403283f, -0.06545603f, 0.23641689f, 0.25184417f, 0.10305954f, -0.21098867f, 0.03561579f, 
    -0.28180978f, 0.19537668f, 0.05081212f, 0.19428249f, -0.25310564f, 0.02529017f, -0.05031114f, -0.06658719f, 
    -0.16135773f, 0.02750211f, 0.14224949f, 0.20443355f, 0.12777995f, -0.04098372f, -0.01937398f, -0.17798820f, 
    0.06754069f, 0.14484175f, -0.13139264f, 0.12741666f, -0.10493870f, -0.11708916f, -0.12661748f, 0.06148925f, 
    0.01431919f, 0.03207034f, 0.03651324f, 0.09464230f, 0.29319105f, 0.25944972f, -0.41417283f, 0.29637921f, 
    0.24922960f, 0.11831279f, 0.22449407f, 0.24567959f, -0.16259699f, 0.18248649f, -0.22838482f, 0.02093893f, 
    0.05524694f, 0.03338612f, -0.00461187f, 0.00416903f, 0.11589632f, -0.23070715f, 0.10082436f, 0.17958888f, 
    0.19519408f, -0.23061967f, -0.41418374f, 0.23413615f, 0.10901047f, -0.10385084f, -0.26299265f, 0.11172910f, 
    -0.29495469f, -0.11722697f, -0.03515508f, 0.02933795f, -0.19488570f, 0.07147650f, 0.14106899f, 0.07268498f, 
    -0.31966341f, -0.24655503f, -0.20649491f, -0.01357778f, 0.29010725f, 0.03718031f, 0.08758098f, -0.21213140f, 
    -0.15422103f, 0.06551006f, 0.00056115f, -0.18825521f, 0.09887994f, 0.02901509f, 0.00064078f, 0.19617505f, 
    -0.07200375f, -0.05539307f, -0.06339201f, -0.09669045f, -0.02948478f, 0.02022153f, 0.04958590f, -0.06006442f, 
    -0.09387647f, -0.43457583f, 0.07871611f, 0.03593863f, -0.17810667f, -0.11155821f, 0.02104651f, 0.21114148f, 
    -0.03071295f, -0.07994583f, -0.00760843f, 0.03970897f, -0.05660278f, 0.11570608f, 0.13616623f, 0.11777624f, 
    0.06214507f, 0.15136196f, 0.05389604f, 0.05717054f, -0.35007170f, -0.12920448f, 0.10056864f, 0.21538997f, 
    -0.02214050f, -0.04978303f, 0.15872118f, -0.11040218f, -0.00911587f, 0.04794407f, 0.17305070f, -0.16326760f, 
    -0.11424459f, 0.06999278f, -0.02624000f, 0.08863320f, 0.15728062f, -0.02606357f, 0.11214732f, 0.27822497f, 
    -0.00080318f, -0.02021963f, 0.10302830f, 0.15161283f, 0.06631099f, -0.02287846f, 0.02516701f, -0.06695244f, 
    0.08310595f, -0.04850854f, -0.04608980f, 0.05010157f, -0.12070074f, -0.12339627f, -0.15447015f, -0.04393277f, 
    0.00266283f, 0.09981228f, -0.05088546f, -0.18547031f, -0.45016602f, 0.08585437f, -0.41450283f, -0.00670222f, 
    0.06065991f, -0.03241738f, -0.14166565f, -0.12946157f, -0.05226799f, 0.00727526f, 0.03562151f, 0.05274793f, 
    0.02898043f, 0.06965527f, -0.04884773f, 0.02605269f, 0.00701305f, -0.26203701f, 0.02320958f, -0.07589732f, 
    0.13914108f, -0.27631775f, 0.28779668f, -0.05089093f, -0.44294384f, 0.06045813f, -0.13517191f, 0.05362073f, 
    -0.02442741f, -0.00643838f, -0.06382988f, 0.11121491f, -0.12357134f, 0.04313119f, -0.00613596f, -0.03764582f, 
    0.08535068f, 0.07897730f, 0.02238630f, 0.02847976f, -0.02964192f, -0.20224126f, 0.26753721f, 0.18053129f, 
    0.10211602f, -0.24912617f, 0.06261776f, 0.12526017f, -0.09153634f, -0.31259856f, -0.09881872f, 0.07074714f, 
    -0.14803132f, 0.00646841f, -0.01672134f, 0.04241030f, 0.04264794f, -0.01325451f, -0.08224841f, -0.28844598f, 
    -0.04732984f, -0.05158488f, -0.16624978f, 0.19120033f, 0.07382908f, -0.10003373f, 0.15128191f, 0.22564468f, 
    -0.28396711f, -0.04460573f, 0.04102397f, 0.07922704f, -0.04284951f, 0.00642013f, -0.08953124f, -0.02575463f, 
    -0.20213631f, -0.30546984f, -0.57308507f, -0.28294140f, -0.04955357f, 0.17596199f, 0.15892027f, 0.28556582f, 
    -0.10592494f, 0.04531336f, -0.04562814f, 0.15468271f, 0.01465325f, -0.23502395f, -0.08991485f, -0.04329465f, 
    -0.10835062f, 0.08679399f, 0.10280517f, -0.17871299f, -0.02509956f, -0.30242184f, -0.06667109f, -0.21892710f, 
    0.02415059f, -0.45275417f, -0.25726652f, 0.21566947f, -0.11169601f, -0.15684953f, -0.27255902f, 0.10375936f, 
    -0.03730242f, 0.01309240f, -0.06646238f, 0.03794817f, -0.09664086f, -0.03023957f, 0.04299630f, 0.03361553f, 
    -0.32757026f, -0.27337632f, -0.04893447f, -0.08504695f, -0.62445873f, -0.61647868f, 0.28336245f, -0.20321055f, 
    -0.10847747f, 0.02160086f, -0.02319690f, 0.23667707f, -0.15388031f, -0.03987377f, -0.23150933f, -0.00532355f, 
    0.07579403f, 0.03134383f, 0.01826968f, 0.05609803f, 0.01140843f, 0.16913328f, 0.09802917f, -0.03217032f, 
    0.14697668f, -0.07347528f, -0.32122946f, 0.56279707f, 0.12009909f, -0.20060346f, -0.06660715f, 0.30252180f, 
    0.02999920f, 0.02527923f, -0.00048830f, -0.00433135f, -0.06530857f, 0.11072854f, 0.26953414f, -0.07259219f, 
    -0.11213599f, 0.16814712f, -0.04147233f, 0.12096933f, -0.48103812f, 0.36814523f, 0.08977433f, 0.29483905f, 
    0.09572186f, 0.16923657f, -0.07563409f, -0.14552143f, 0.02263464f, 0.23098943f, -0.05605195f, 0.06908944f, 
    -0.00239108f, 0.07220063f, -0.13670935f, -0.15536734f, 0.00526664f, -0.18885523f, -0.00901440f, -0.04993086f, 
    -0.19672471f, -0.07901082f, -0.50131398f, -0.04981988f, -0.12657161f, 0.00244720f, -0.05049373f, -0.00010706f, 
    0.00695320f, 0.06167400f, -0.04912180f, 0.17440550f, -0.01840823f, -0.23772572f, -0.28454676f, 0.05635403f, 
    -0.01076607f, 0.08503210f, -0.16021821f, -0.19163963f, -0.24504468f, -0.59280217f, -0.15612268f, -0.36281639f, 
    -0.38695475f, -0.05924420f, -0.17196910f, 0.07070360f, 0.04582016f, -0.13009682f, -0.18905868f, 0.13872857f, 
    0.08752602f, -0.03275551f, -0.04345858f, 0.13634692f, -0.00382295f, 0.03150679f, 0.07939835f, -0.18130267f, 
    -0.06289743f, 0.25094378f, 0.10661864f, 0.00221973f, 0.07240598f, 0.10947327f, -0.02963449f, -0.09456626f, 
    -0.05436164f, 0.03089019f, -0.05705081f, 0.12646788f, -0.10287067f, -0.03307283f, -0.03462976f, -0.02406124f, 
    -0.03193289f, 0.02139411f, -0.06164640f, 0.01975335f, -0.22173126f, -0.00322443f, 0.24461085f, 0.39011800f, 
    -0.09394963f, -0.05601468f, -0.10938080f, -0.20145096f, 0.00364756f, 0.01607448f, 0.00421517f, 0.22710173f, 
    -0.02673353f, 0.08824599f, -0.08405741f, 0.04266250f, -0.21388970f, 0.05946608f, 0.14103128f, -0.13937758f, 
    -0.50428677f, 0.25879192f, -0.01654310f, 0.27895179f, -0.03146656f, 0.04915716f, -0.06388375f, -0.08091814f, 
    0.09307463f, -0.06977487f, -0.07476428f, 0.01485487f, 0.01814120f, -0.08605056f, 0.01615620f, -0.12796317f, 
    0.13439685f, -0.33910829f, -0.18839240f, -0.03642091f, -0.20682453f, 0.20947686f, -0.50468057f, 0.06915335f, 
    0.29165885f, 0.09898511f, -0.13983746f, -0.00206378f, -0.20463882f, 0.13335989f, -0.10944136f, 0.10124049f, 
    0.01164513f, -0.02135959f, 0.08915544f, 0.06166904f, -0.03027401f, -0.22067700f, 0.04663406f, -0.01670635f, 
    -0.31186998f, -0.47903377f, 0.04319791f, -0.21338782f, -0.25030947f, 0.13051274f, -0.12355793f, -0.07394633f, 
    0.04572989f, 0.05264730f, -0.21006119f, -0.02994666f, 0.06709249f, -0.17107618f, -0.14428392f, -0.00578101f, 
    0.22880952f, 0.09821106f, 0.16330019f, 0.05327274f, -0.36392131f, 0.04477177f, 0.12144105f, 0.34530470f, 
    0.20483112f, 0.02589629f, 0.06635843f, -0.03401586f, 0.15912277f, -0.00352651f, -0.02418724f, -0.10830250f, 
    0.10183952f, 0.07327273f, 0.12572519f, 0.11037078f, 0.14673035f, -0.11195658f, 0.13882656f, 0.26523715f, 
    0.20826562f, -0.16828366f, 0.34359276f, 0.09861195f, 0.01698967f, -0.04098408f, -0.00516263f, 0.03055974f, 
    0.13246770f, -0.16549402f, 0.00227099f, 0.05249327f, -0.01367739f, 0.06163633f, 0.02746212f, 0.09799696f, 
    0.09675378f, 0.07048513f, 0.23643486f, -0.06953541f, 0.00744176f, -0.09322053f, -0.39391935f, 0.46562412f, 
    -0.12155581f, 0.01744600f, -0.07239893f, 0.22730146f, -0.23111835f, 0.10040416f, -0.04926999f, 0.02086934f, 
    -0.06290206f, 0.01372994f, 0.14118068f, -0.06288048f, -0.03229399f, 0.16702221f, 0.13956928f, 0.15112904f, 
    0.00229450f, 0.06587815f, 0.22021273f, -0.36455202f, 0.02588608f, -0.24130735f, 0.08554894f, 0.21312194f, 
    0.24857670f, -0.06604859f, -0.10733181f, 0.04476821f, -0.04465951f, 0.07612745f, 0.00066036f, 0.09859177f, 
    -0.01896261f, 0.19734865f, 0.08926157f, 0.04443517f, -0.09375285f, 0.29246938f, 0.09222985f, -0.00285232f, 
    0.01824344f, 0.04964194f, -0.08640074f, 0.07782649f, -0.03890602f, 0.11419299f, -0.00742459f, 0.00307233f, 
    -0.09630939f, 0.00845035f, -0.04345748f, -0.03203152f, -0.01009656f, -0.02117584f, -0.02099339f, -0.15696275f, 
    -0.20868228f, -0.13163270f, 0.34986970f, 0.40250880f, 0.27782905f, -0.04016183f, 0.08676988f, 0.37502012f, 
    -0.20644136f, -0.13469993f, 0.09598043f, 0.13563427f, 0.00929377f, 0.13821237f, 0.06360829f, 0.11290713f, 
    0.05905236f, 0.12835304f, -0.02226196f, 0.20921171f, 0.03497045f, -0.27538681f, 0.20260419f, 0.23491614f, 
    0.05898899f, -0.20009680f, -0.12983133f, 0.05478172f, -0.03551799f, -0.00672668f, 0.00045372f, -0.09610803f, 
    -0.08270346f, 0.26628903f, 0.20947503f, -0.03492881f, -0.02200221f, 0.17478240f, 0.02983149f, 0.19650471f, 
    -0.04122328f, -0.38380399f, -0.33185226f, -0.20693363f, -0.06944779f, -0.02040709f, -0.44037941f, -0.16306037f, 
    -0.29707086f, -0.18273754f, 0.00162959f, 0.10707740f, -0.04685555f, -0.06398775f, -0.01263407f, 0.05272520f, 
    -0.06115430f, 0.05690977f, -0.01401641f, -0.18394056f, 0.28777346f, -0.65232724f, 0.43945435f, 0.28727987f, 
    0.33919927f, -0.02436405f, -0.39937392f, 0.24137767f, -0.09383658f, -0.16475564f, 0.14864355f, -0.12647301f, 
    0.18100019f, -0.00964420f, -0.05186611f, 0.17992367f, -0.01567866f, 0.09412502f, 0.13633515f, -0.13681367f, 
    -0.19729416f, -0.30309385f, 0.04617910f, -0.00996460f, -0.72650909f, 0.00962284f, -0.17478663f, -0.22330463f, 
    -0.09294017f, 0.18461816f, -0.05124282f, -0.00074747f, 0.12424212f, -0.02741721f, -0.05282731f, -0.08716969f, 
    0.03398245f, -0.06873477f, 0.05666665f, -0.10352711f, -0.60305035f, -0.09615243f, -0.07811098f, 0.49021086f, 
    -0.11317183f, 0.01885961f, -0.06603307f, 0.21051110f, -0.18833025f, 0.05572239f, -0.19355793f, -0.14313336f, 
    -0.07182816f, 0.00118025f, 0.04101996f, -0.00207683f, -0.16505459f, 0.02345367f, 0.14788754f, -0.14578286f, 
    0.39409548f, -0.10409497f, 0.24519929f, 0.03610757f, -0.21344432f, -0.12520768f, -0.01925791f, -0.09932144f, 
    0.03128157f, 0.10027382f, -0.06774177f, 0.02881029f, -0.02240682f, -0.09094906f, -0.03112455f, 0.04680292f, 
    0.14738849f, -0.07480096f, 0.09279481f, 0.08871955f, -0.50463283f, -0.06273704f, -0.27441683f, 0.06889636f, 
    -0.22567260f, 0.00682683f, 0.08616854f, 0.02959557f, -0.02011406f, 0.11227617f, -0.05970015f, -0.10305065f, 
    0.02058118f, 0.05068169f, -0.01062772f, -0.03125659f, -0.07150029f, -0.04359490f, -0.04036764f, 0.09016551f, 
    0.16735098f, 0.11722239f, 0.22836328f, -0.12753585f, 0.09558081f, 0.01490743f, 0.10371916f, -0.00010786f, 
    -0.04641752f, 0.00100545f, -0.17858778f, -0.02201441f, -0.01733626f, -0.00534405f, -0.00980301f, 0.06623563f, 
    0.03479001f, -0.14489692f, -0.09704477f, 0.04021976f, -0.17916109f, -0.17237404f, 0.00465913f, 0.14813028f, 
    0.11379283f, -0.09513951f, -0.01833213f, 0.00916928f, 0.06258533f, -0.09142628f, -0.00395485f, -0.00888944f, 
    0.01267956f, -0.14847076f, 0.14654447f, -0.06683899f, -0.14507970f, -0.01563891f, -0.19340786f, -0.21903722f, 
    -0.01683433f, -0.07230922f, -0.06445377f, 0.06369970f, -0.32500440f, -0.09659935f, -0.02134666f, 0.00820611f, 
    -0.02648107f, -0.05057706f, 0.00722744f, 0.05551528f, 0.08633178f, 0.03032022f, 0.01140089f, 0.00834873f, 
    0.11253081f, 0.08935583f, 0.11157030f, 0.12769237f, -0.01047110f, -0.12237500f, -0.16894509f, 0.03634726f, 
    0.00636192f, -0.00524933f, -0.24776645f, -0.14216532f, -0.15621546f, -0.12274816f, 0.03373275f, 0.00869367f, 
    -0.00870841f, -0.04203089f, 0.00980966f, 0.05477037f, -0.02004655f, 0.05740024f, 0.05604625f, -0.07281043f, 
    -0.13046989f, -0.07211006f, -0.07849523f, -0.08465886f, 0.13004832f, 0.02607180f, 0.13570218f, -0.01748017f, 
    0.09560716f, 0.04978909f, -0.08688403f, -0.01580612f, 0.01862355f, 0.03370246f, 0.01595524f, -0.07183383f, 
    -0.10003971f, -0.06469309f, -0.11020540f, -0.14207682f, 0.46557981f, -0.14338401f, 0.03290768f, 0.13607904f, 
    0.25677472f, 0.06835469f, 0.12269809f, -0.16226335f, 0.03182940f, -0.29860383f, -0.12906438f, 0.02075790f, 
    -0.06099996f, -0.07222411f, -0.12216448f, 0.18191954f, -0.03711369f, 0.01735875f, 0.06363317f, 0.06664208f, 
    -0.03911471f, -0.49287266f, 0.00610099f, 0.00211029f, 0.10257779f, 0.08034860f, -0.09595460f, -0.06794253f, 
    0.00754170f, -0.06007344f, -0.05709842f, 0.05310452f, -0.04800406f, 0.01056855f, 0.01068234f, 0.14595757f, 
    0.06394212f, 0.02182910f, 0.20866998f, 0.03313051f, -0.79006439f, 0.05207211f, -0.27920377f, 0.15919696f, 
    -0.01217197f, 0.11163765f, 0.00850871f, 0.21066254f, -0.27820590f, -0.01195627f, 0.01518188f, -0.04157684f, 
    -0.05030928f, 0.22134428f, 0.10029656f, 0.05843450f, 0.06981581f, 0.21294130f, 0.20827840f, -0.03761008f, 
    0.44657806f, 0.05018233f, 0.40438563f, 0.12283846f, -0.44805390f, -0.08137538f, -0.03633140f, 0.16828732f, 
    -0.07035847f, 0.00563129f, -0.11001740f, 0.07566102f, 0.02845563f, -0.06635236f, 0.04580724f, -0.20163840f, 
    0.07016265f, 0.13172916f, 0.27035567f, 0.00925688f, 0.65734315f, 0.10122008f, 0.51900572f, -0.21843792f, 
    0.05612458f, 0.17286871f, 0.12580650f, -0.13121583f, 0.19901253f, -0.03519634f, -0.14125012f, 0.06735066f, 
    0.02410032f, 0.16432956f, 0.08202701f, -0.11496380f, -0.01540378f, -0.03465411f, -0.23210151f, 0.14399269f, 
    -0.00505036f, -0.28981692f, 0.18282254f, 0.23383169f, -0.15520953f, -0.13700610f, 0.02540069f, -0.00502975f, 
    0.26286298f, -0.06981684f, -0.11750904f, -0.02931632f, 0.03508381f, 0.12729864f, -0.04075683f, -0.09534220f, 
    -0.00090227f, 0.20444238f, 0.12203881f, -0.17167406f, -0.63213837f, -0.21566528f, -0.63632309f, 0.52765971f, 
    0.12314978f, -0.06012461f, 0.24649580f, -0.10448037f, 0.26585239f, -0.04299389f, -0.23948698f, -0.10166740f, 
    0.00945459f, 0.06870419f, 0.11678988f, 0.05947060f, 0.00907988f, 0.24991474f, -0.02571018f, -0.00814573f, 
    -0.18019344f, -0.32067209f, -0.12033669f, -0.24184655f, -0.39515570f, -0.03124974f, 0.13069612f, 0.13625994f, 
    -0.22526383f, -0.08296426f, -0.07959763f, -0.00562652f, 0.17333756f, 0.25813982f, 0.04124062f, -0.00627305f, 
    0.22607528f, 0.05999853f, 0.07439431f, 0.17398746f, 0.30588871f, -0.01978776f, 0.32610014f, -0.20716034f, 
    -0.06925863f, -0.03368793f, 0.15668882f, -0.10248029f, 0.10784738f, 0.03041649f, -0.13669491f, 0.06045698f, 
    0.01998587f, -0.07428761f, -0.04028663f, -0.02782008f, 0.11253436f, -0.01232605f, -0.16601390f, 0.04236394f, 
    -0.50040567f, -0.04718607f, -0.37588340f, 0.34141645f, -0.29126275f, -0.06150167f, -0.01430501f, -0.05395675f, 
    0.08561882f, 0.03054041f, -0.04275762f, -0.01522049f, -0.04367115f, -0.05522056f, 0.00139978f, -0.01022368f, 
    -0.00857251f, -0.02557964f, -0.02609269f, -0.01275471f, -0.14844859f, -0.16562213f, -0.06294123f, -0.04606925f, 
    -0.16742051f, -0.08171201f, 0.03685187f, -0.03410005f, -0.00060708f, -0.04505915f, -0.18440132f, -0.10779534f, 
    0.05725429f, -0.03626829f, 0.07240964f, 0.04435409f, -0.14620282f, 0.01596276f, -0.04759276f, -0.18304093f, 
    -0.08686737f, -0.00690631f, -0.20681123f, 0.06408443f, -0.11724286f, -0.02244281f, -0.08094619f, -0.11928122f, 
    -0.00783615f, -0.07047118f, 0.02322468f, 0.09005197f, -0.06245086f, 0.01654234f, 0.03340990f, 0.14217983f, 
    -0.03392777f, 0.21920107f, 0.07272825f, 0.00803137f, -0.05925258f, -0.42771643f, -0.15233782f, 0.27463904f, 
    -0.05549845f, -0.05144650f, -0.13685936f, 0.12218648f, -0.21759053f, 0.06377383f, 0.02117085f, -0.04577705f, 
    0.10963398f, 0.03426607f, -0.13385314f, 0.07343113f, -0.03190678f, 0.11103202f, -0.00228351f, -0.00818228f, 
    0.25018591f, 0.11574589f, 0.17397514f, 0.00560684f, -0.02317540f, -0.07578833f, 0.22114459f, 0.04016194f, 
    0.08141840f, 0.07049849f, -0.27158445f, 0.04727704f, 0.04941798f, -0.03858656f, 0.03144338f, -0.02330318f, 
    0.05385497f, 0.12241782f, -0.14838520f, -0.08307285f, -0.05358509f, -0.27810666f, 0.07213748f, 0.22069363f, 
    -0.06435448f, -0.08227265f, -0.11619964f, -0.06117940f, -0.03185793f, 0.03992593f, 0.04319065f, 0.00173658f, 
    -0.05630631f, -0.17670190f, -0.02217066f, -0.02661477f, -0.14251119f, -0.06449308f, -0.13749701f, -0.32296324f, 
    0.06318783f, -0.25314927f, 0.42394066f, -0.30190128f, 0.19153340f, 0.16028765f, 0.16039248f, 0.05646276f, 
    0.04477250f, -0.04441733f, -0.05982317f, 0.06295222f, 0.12115734f, -0.02313854f, 0.09917826f, 0.00462135f, 
    0.19311187f, -0.03194395f, -0.17960191f, 0.04373509f, 0.16604300f, -0.07752815f, 0.11386178f, 0.05553386f, 
    -0.14302436f, -0.05998885f, 0.16679254f, -0.12189494f, 0.25663584f, 0.08229551f, -0.20677461f, 0.04928908f, 
    -0.09384670f, -0.00572499f, -0.08368744f, 0.09705061f, 0.15742254f, 0.06494327f, 0.02022645f, -0.10130934f, 
    -0.06254000f, -0.12883502f, 0.00876288f, -0.24382311f, 0.25490966f, 0.25343046f, 0.12014486f, 0.01989741f, 
    -0.13207540f, -0.09941395f, 0.01684915f, 0.09197978f, -0.03311218f, -0.02861534f, -0.13789448f, 0.06151345f, 
    0.03140688f, 0.03853865f, -0.03798073f, 0.04935478f, -0.69466555f, 0.12749305f, -0.42242423f, 0.21610457f, 
    -0.02967756f, -0.04536286f, 0.15262717f, -0.01671990f, 0.11589522f, -0.00504826f, -0.20479424f, -0.03371750f, 
    0.10343319f, 0.08605514f, 0.01328937f, 0.05518550f, -0.00783838f, 0.06119207f, -0.04257816f, 0.19128479f, 
    0.31369042f, -0.53064352f, 0.34114259f, -0.11398199f, 0.23079343f, 0.02768125f, -0.28114417f, -0.17661013f, 
    0.19986862f, -0.11217501f, 0.09564900f, -0.06115511f, 0.05473492f, 0.04202968f, -0.04027935f, -0.01325523f, 
    0.11281882f, -0.09880928f, 0.28778040f, -0.04600606f, 0.18640767f, -0.05458319f, 0.13118859f, 0.00169711f, 
    -0.05482691f, -0.00666228f, 0.02606546f, 0.03233321f, 0.16611110f, -0.04079263f, 0.11331747f, -0.09261930f, 
    0.01205833f, 0.01238667f, -0.09664381f, -0.01751383f, 0.09286144f, 0.10084911f, 0.10758738f, -0.06098558f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18374714f, 0.08166361f, 0.07842013f, -0.06367894f, -0.07113792f, 0.08233155f, 0.03034875f, -0.06745223f, 
    0.06621303f, 0.00482092f, 0.03812252f, -0.04660419f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
