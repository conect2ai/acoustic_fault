#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.34824607f, 0.34968793f, 0.61902773f, 0.50387716f, 0.52281523f, 0.03788715f, -0.09937678f, -0.57704753f, 
    -0.59623712f, -0.08924952f, 0.30671886f, 0.27557516f, 0.11336907f, 0.16498119f, -0.42279130f, 0.20149775f, 
    -0.28534505f, 0.00220663f, 0.11525557f, -0.14265905f, 0.10957178f, 0.19322616f, 0.32411683f, 0.22743839f, 
    -0.11550013f, -0.10565560f, -0.04654894f, -0.57084751f, -0.12462757f, -0.07020656f, -0.47062704f, -0.40356332f, 
    -0.47523779f, -0.38728237f, -0.07187193f, -0.48099107f, 0.29604539f, 0.23479564f, -0.09484517f, -0.07879313f, 
    0.02073924f, -0.06576423f, 0.38770294f, -0.02345465f, -0.08325795f, 0.21915421f, -0.00721975f, 0.16499193f, 
    0.15616854f, 0.08271059f, -0.56441396f, -0.75534254f, -0.37521923f, 0.08127289f, 0.29833928f, 0.45420146f, 
    0.22779623f, -0.35362890f, 0.28741056f, 0.07882404f, 0.18938911f, 0.16429263f, 0.32424277f, 0.19622216f, 
    0.14451356f, -0.31714767f, 0.01831262f, 0.07136241f, -0.06110012f, 0.28128901f, -0.40758827f, -0.34122017f, 
    -0.35970286f, -0.30283910f, -0.09003867f, -0.25005379f, -0.12084153f, -0.60647804f, -0.38000327f, -0.02903385f, 
    -0.10804383f, -0.08532534f, -0.05796259f, 0.18491161f, 0.10313461f, 0.00680259f, 0.00947998f, 0.30663070f, 
    0.03604132f, -0.17507641f, -0.14852136f, -0.27787641f, -0.21892434f, -0.32483244f, 0.18877812f, 0.11120880f, 
    0.33637547f, 0.01127476f, 0.12813203f, 0.00029317f, -0.49788979f, -0.09266239f, 0.29301396f, 0.21646424f, 
    0.42524928f, -0.35912687f, 0.47983530f, -0.02298470f, -0.08761905f, -0.03295946f, 0.38980752f, -0.05402885f, 
    -0.03480403f, -0.31883886f, -0.18248925f, 0.07161273f, 0.34467718f, 0.36470363f, 0.56580830f, 0.14773162f, 
    -0.13390952f, -0.17566957f, -0.29689139f, -0.27155191f, -0.29103085f, -0.41136739f, 0.29385820f, -0.68369192f, 
    -0.07830923f, 0.33119151f, -0.42308030f, 0.48001534f, -0.15084118f, 0.18782763f, 0.11484521f, 0.30883527f, 
    -0.06913766f, 0.02038790f, -0.06747499f, -0.24800001f, -0.21771407f, 0.02010165f, -0.48612598f, -0.36471224f, 
    -0.31966054f, 0.22536138f, 0.03462516f, 0.22694130f, 0.24964932f, 0.02470575f, 0.42080513f, 0.15619197f, 
    0.22418685f, 0.49472013f, 0.56408185f, 0.66304922f, 0.29984564f, -0.19271699f, 0.34363127f, -0.08730346f, 
    -0.10188685f, 0.30240744f, -0.15908720f, 0.05145795f, -0.19387530f, -0.05362609f, -0.30933499f, 0.22265761f, 
    0.14463821f, -0.06001723f, 0.32726705f, 0.00226489f, 0.22555332f, -0.14890376f, 0.19789910f, 0.69326961f, 
    0.37417239f, -0.12145159f, 0.98926806f, 0.33994576f, 0.19201511f, -0.11619065f, -0.26214731f, 0.23787595f, 
    -0.05002581f, -0.19364643f, -0.13279745f, -0.06113955f, -0.03437005f, 0.02376056f, 0.15884636f, 0.09526604f, 
    0.00141190f, -0.15995236f, 0.03108739f, 0.19880064f, -0.06561656f, -0.07967846f, -0.38130888f, 0.07072466f, 
    -0.53190345f, 0.45388865f, 0.45980194f, 0.47388023f, -0.60927099f, 0.52855170f, -0.33770517f, -0.21416317f, 
    -0.08804829f, -0.20555204f, -0.18112889f, -0.15614986f, -0.19704205f, -0.20018479f, 0.06933430f, -0.29236913f, 
    0.28772882f, -0.05250849f, 0.05236247f, -0.00215882f, 0.03089648f, -0.08996426f, 0.07519501f, -0.15059747f, 
    -0.39521614f, 0.74487996f, 0.32327053f, -0.28605425f, -0.43653443f, -0.82596403f, 0.43001118f, 0.01912227f, 
    -0.08362428f, -0.07330510f, 0.19262160f, 0.60846788f, 0.24670662f, 0.23733331f, 0.08067512f, -0.06933719f, 
    0.15594269f, 0.00133418f, 0.13624696f, 0.17518023f, 0.17558844f, -0.03977735f, -0.01112547f, 0.06315707f, 
    0.17708485f, 0.08462884f, 0.22571971f, -0.63442242f, -0.55573231f, -0.26315761f, -0.17976381f, -0.40169591f, 
    -0.06143194f, -0.02721039f, 0.39635503f, 0.37198222f, -0.33668846f, 0.41557419f, -0.06861756f, 0.25022513f, 
    0.04276936f, -0.08369079f, -0.18083206f, -0.38190633f, 0.05167185f, 0.06108603f, -0.02739141f, -0.14171232f, 
    0.33335567f, -0.07542078f, -0.27919161f, 0.41150668f, -0.38164908f, 0.30831429f, 1.02380443f, 0.08288071f, 
    -0.04728915f, 0.28891593f, 0.26652369f, 0.32538453f, 0.08884313f, -0.23038681f, 0.28973392f, 0.16544709f, 
    0.02831151f, -0.20266721f, -0.08398576f, 0.01562894f, 0.26444751f, 0.07416540f, 0.09082855f, 0.01899678f, 
    -0.01883327f, 0.09334263f, 0.28509307f, 0.04420764f, -0.35441333f, 0.59523737f, 0.11669872f, -0.39366198f, 
    0.37075755f, 0.23744230f, 0.09746445f, -0.74782926f, -0.43362227f, -0.38198778f, 0.01525434f, 0.31141102f, 
    0.11446004f, 0.06732426f, -0.06918117f, -0.01511542f, 0.01017906f, -0.12337841f, 0.04149636f, 0.22816069f, 
    0.46382779f, -0.20822379f, -0.17261209f, 0.01283398f, 0.12631221f, 0.22494383f, 0.33427763f, 0.58358300f, 
    0.09701213f, 0.41539046f, -0.01309785f, -0.16193856f, -0.09515285f, -0.28206077f, -0.13583037f, -0.15621144f, 
    0.13912831f, 0.06304908f, 0.44803545f, -0.07262775f, 0.25613695f, 0.33173686f, -0.04883374f, 0.19850789f, 
    0.15076800f, -0.22663939f, -0.19222468f, -0.07986836f, 0.14239973f, 0.19784077f, -0.28748438f, -0.58519030f, 
    -0.58249563f, -0.41698036f, -0.27607045f, 0.48481208f, -0.32371807f, -0.25635773f, 0.19725320f, -0.23277542f, 
    -0.51951766f, -0.18301894f, -0.00661281f, 0.42970151f, -0.10358419f, -0.15564512f, 0.24320239f, 0.02667112f, 
    0.18423320f, 0.17927305f, 0.10873082f, 0.14155415f, -0.40198699f, 0.13924599f, -0.16739537f, -0.24127211f, 
    -0.37559488f, -0.15759380f, -0.18267047f, 0.01354778f, -0.30847961f, -0.20737451f, 0.52061427f, 0.34391549f, 
    -0.25939786f, -0.18424778f, -0.23267311f, -0.02195435f, -0.34592643f, -0.15995041f, 0.20972636f, -0.10280968f, 
    0.22968464f, -0.23220210f, -0.35011774f, -0.23697878f, 0.21669108f, 0.18671711f, 0.18595545f, 0.07225673f, 
    -0.34036145f, -0.40337864f, -0.37309787f, -0.20623200f, -0.41727361f, 0.60816443f, 0.80187970f, -0.04182944f, 
    -0.21269022f, 0.21430333f, -0.03064650f, -0.24690664f, -0.20235020f, 0.09473873f, 0.22084236f, -0.23653917f, 
    -0.22362833f, -0.26788989f, 0.13753749f, -0.38703978f, -0.15776715f, 0.01348150f, 0.16358854f, -0.10490564f, 
    0.11862644f, -0.03362172f, -0.42462879f, 0.09961330f, 0.54385066f, 0.03114670f, 0.02539621f, 0.89258993f, 
    -0.17223930f, 0.06288899f, 0.46600348f, 0.03585601f, 0.27087179f, -0.11431000f, 0.31325254f, -0.08255556f, 
    -0.12809759f, -0.25660217f, 0.07856223f, -0.27198017f, -0.12836546f, 0.26427677f, 0.16897884f, 0.10406647f, 
    0.03283222f, 0.20531532f, -0.10344774f, -0.03992814f, -0.49457654f, -0.07007383f, -0.10196539f, 0.43970421f, 
    -0.47993049f, 0.15263303f, 0.49836633f, -0.45091623f, -0.20914572f, 0.17253636f, 0.30160382f, 0.30070907f, 
    -0.22005349f, -0.28536013f, -0.13777083f, -0.24273592f, -0.10920378f, 0.39832410f, -0.20444578f, -0.02994636f, 
    0.09815973f, -0.21347736f, -0.11678196f, 0.24193838f, 0.96004015f, 0.71386093f, -0.12251771f, -0.07247383f, 
    -0.76935399f, 0.55771226f, -0.00680755f, -0.45713502f, -0.14878531f, 0.13663787f, 0.18000422f, -0.17673610f, 
    0.08135125f, 0.22959489f, 0.14604649f, 0.16365799f, 0.33270299f, 0.04821323f, -0.29623726f, 0.06336641f, 
    -0.11601448f, -0.06811668f, -0.01353257f, 0.07627852f, -0.28350765f, 0.27718276f, 0.15860745f, -0.18297157f, 
    0.23833035f, -0.69536567f, 0.69247818f, -0.08653410f, 0.08447457f, 0.37650663f, -0.29408151f, 0.37580124f, 
    -0.39918509f, -0.14606293f, -0.00922294f, -0.02913983f, -0.45366302f, -0.22646813f, 0.01324023f, 0.07116834f, 
    0.21391343f, 0.13994397f, -0.00824167f, -0.02234435f, -0.18979290f, 0.49318045f, 0.14464086f, 0.22187072f, 
    -0.47898188f, -0.38412046f, -0.12853967f, 0.18275218f, 0.32333353f, 0.28906155f, -0.14779502f, 0.16671953f, 
    0.31880033f, 0.11006576f, 0.19030043f, -0.01462977f, -0.18734984f, -0.16099055f, -0.28174540f, -0.16272460f, 
    0.14586924f, 0.14530270f, 0.07794430f, -0.03569005f, 0.25020123f, 0.20561989f, 0.28551832f, 0.35988981f, 
    0.00523680f, -0.68659866f, 0.09844115f, 0.29414022f, 0.05287405f, -0.52944350f, -0.24585181f, -0.76749510f, 
    0.07218447f, -0.42550400f, -0.16177228f, 0.16034764f, -0.26145512f, 0.17527302f, 0.18643017f, -0.47244883f, 
    -0.39024913f, -0.10908326f, -0.02170904f, 0.14846274f, 0.36705056f, -0.08206922f, -0.29565763f, -0.00869735f, 
    -0.01216094f, 0.22903234f, 0.46465391f, -0.32978016f, -0.24826910f, -0.51678717f, -0.11874482f, 0.27760562f, 
    -0.43109849f, -0.13928285f, 0.38277221f, -0.40337601f, 0.17532483f, -0.20433207f, -0.52772003f, 0.08161540f, 
    0.20413142f, -0.10608786f, -0.04320487f, 0.21526803f, 0.09554116f, -0.16772126f, -0.15112571f, 0.27047196f, 
    -0.02462683f, -0.54755914f, -0.44234931f, 0.54260916f, -0.34209904f, 0.01357695f, 0.09100561f, -0.11165305f, 
    -0.00905140f, -0.20373169f, 0.12812749f, -0.14840855f, -0.12217607f, 0.22422020f, -0.05972528f, -0.00279939f, 
    0.02096047f, 0.32446843f, -0.09840573f, 0.48840746f, 0.03969166f, 0.31813231f, -0.17710763f, 0.13241623f, 
    -0.01890050f, 0.45800084f, -0.60185641f, 0.52855432f, 0.57809341f, 0.42589554f, -0.20123017f, -0.38301235f, 
    0.63952029f, 0.35394672f, -0.31668383f, 0.29400700f, -0.26248151f, -0.38893500f, -0.12426140f, -0.12646273f, 
    0.13967468f, -0.03126007f, 0.02030940f, 0.00000340f, -0.05537175f, -0.09398047f, 0.20916703f, 0.07703219f, 
    0.26732019f, -0.00149792f, -0.21391866f, -0.57573789f, -0.45710841f, -0.56778926f, -0.46953103f, 0.51276922f, 
    0.47457349f, 0.07518624f, 0.26912695f, 0.41740212f, -0.03595487f, -0.27037486f, 0.20329748f, 0.05429449f, 
    -0.24985814f, -0.10489316f, 0.01542358f, 0.29586583f, -0.10869560f, -0.09536833f, 0.17380767f, -0.28858286f, 
    0.39046878f, 0.32866144f, 0.07166450f, -0.43430454f, -0.29031828f, -0.31794444f, -0.46811023f, -0.41474679f, 
    0.07923238f, 0.49325293f, 0.57492566f, 0.40936747f, -0.04218652f, -0.14357641f, -0.06657849f, 0.08338063f, 
    -0.29885182f, -0.06962149f, 0.11030033f, -0.25757077f, -0.15874392f, 0.25885463f, -0.34181172f, -0.10671952f, 
    -0.08425134f, 0.00499145f, -0.20536499f, 0.13140465f, -0.39762759f, -0.48408374f, -0.47093502f, -0.34772176f, 
    -0.42222911f, -0.01862806f, -0.57184160f, -0.12454098f, 0.29113585f, 0.24570642f, -0.06111290f, 0.21495657f, 
    -0.11526059f, -0.10786421f, -0.22027411f, -0.00932905f, 0.28177616f, 0.28749311f, 0.19102973f, -0.22695297f, 
    0.12892784f, 0.03971550f, 0.14752506f, -0.04463369f, 0.05389579f, -0.06931948f, 0.68422216f, 0.59996992f, 
    -0.92702311f, -0.34740701f, 0.12740029f, -0.01826314f, -0.31772825f, -0.56395513f, -0.23987900f, 0.02252661f, 
    0.40838233f, 0.03850228f, 0.30608156f, 0.21316424f, -0.14993744f, 0.11944509f, -0.03394160f, -0.30636626f, 
    0.00644225f, -0.13751595f, 0.09391911f, 0.07759226f, -0.01048749f, 0.00838471f, 0.45729846f, 0.15437770f, 
    -0.33244950f, -0.69203883f, 0.34433556f, -0.10887134f, -0.54697978f, 0.40530676f, 0.45698467f, -0.34717515f, 
    -0.40730858f, -0.26437956f, -0.09141621f, -0.26451880f, -0.07129557f, -0.28952733f, 0.31625116f, -0.10169560f, 
    0.20353502f, -0.04750560f, -0.19893667f, -0.16904674f, -0.25789848f, -0.39624846f, -0.13688023f, 0.38959762f, 
    -0.31059942f, 0.54958069f, 0.21877730f, 0.16831784f, 0.40541986f, 0.04903639f, -0.40671250f, 0.21022217f, 
    -0.04338223f, 0.16957442f, -0.12080800f, -0.23692748f, 0.11206315f, -0.20430967f, -0.13755368f, -0.31520092f, 
    -0.47263640f, 0.10565706f, -0.30243623f, -0.37393755f, 0.13213354f, 0.01207646f, 0.24871795f, -0.07525276f, 
    0.62381572f, 0.09272128f, -0.63670564f, -0.75171125f, 0.09979171f, -0.09541165f, -0.09235533f, 0.23677960f, 
    0.15993777f, 0.26412684f, -0.36857226f, 0.37017903f, 0.15351945f, -0.24061763f, -0.09146671f, -0.03824700f, 
    -0.18568973f, 0.01412831f, 0.56097478f, -0.04998991f, 0.00144027f, 0.22741425f, -0.27569252f, -0.03032255f, 
    0.18755238f, -0.61529452f, -0.47412321f, -0.45883831f, 0.33005083f, 0.13423043f, -0.18204235f, -0.24925652f, 
    -0.27472180f, 0.40982300f, -0.16344088f, -0.06145305f, 0.31656906f, -0.22565921f, 0.02276707f, -0.21287726f, 
    -0.19718356f, 0.15108958f, -0.11220246f, -0.18552044f, -0.03621195f, -0.16238610f, -0.03862126f, -0.05449221f, 
    0.13428591f, -0.02232194f, 0.25375205f, 0.46075293f, 0.29901591f, 0.16468088f, 0.28840527f, -0.37494442f, 
    -0.20189105f, 0.32954973f, 0.00827750f, 0.01170839f, -0.22200896f, -0.22181721f, 0.14401177f, 0.09994259f, 
    0.04768960f, 0.23553953f, -0.06824002f, 0.13075210f, -0.31040505f, -0.18787591f, 0.24933484f, 0.23226249f, 
    0.22399603f, 0.38243279f, 0.07412901f, -0.29428619f, -0.62354696f, -0.38513210f, 0.30651236f, -0.46595782f, 
    0.20037603f, -0.19031188f, -0.40856010f, 0.13182096f, -0.40165755f, -0.01487578f, 0.22270976f, 0.01248755f, 
    0.31889758f, 0.15690643f, -0.11430257f, 0.19364755f, -0.02063647f, 0.06071343f, 0.06188986f, 0.00311806f, 
    -0.23131795f, 0.40099564f, -0.04875216f, 0.01326087f, -0.28485537f, 0.24405707f, 0.36576718f, 0.30767888f, 
    0.53038245f, 0.66847295f, -0.33104345f, 0.41969129f, 0.05153349f, -0.03701295f, 0.08562073f, 0.08864854f, 
    0.51879799f, 0.37050310f, 0.16862614f, 0.01950806f, -0.03129064f, -0.37065592f, -0.12030652f, 0.13769624f, 
    -0.06672044f, -0.06834732f, 0.07223929f, -0.05221500f, 0.01644659f, -0.67411196f, -0.24647214f, -0.26569700f, 
    -0.29343680f, 0.21899655f, 0.10350576f, 0.61111802f, 0.16581255f, 0.55251873f, 0.51522797f, 0.22175997f, 
    -0.26618463f, 0.07891461f, -0.47666749f, -0.13162521f, 0.02258699f, -0.08745754f, -0.07725464f, 0.36646169f, 
    -0.14186095f, -0.23882404f, -0.10281800f, -0.33231208f, -0.13741820f, -0.09945837f, -0.76018798f, -0.77725995f, 
    -0.40943336f, -0.24211979f, -0.38283321f, -0.40028441f, -0.10266265f, 0.34606761f, -0.31629303f, 0.43914896f, 
    0.14226320f, 0.08731841f, -0.00995027f, -0.16142881f, 0.26420173f, -0.01024081f, 0.05700545f, -0.06682149f, 
    0.08805653f, 0.05679337f, -0.15186636f, 0.01983720f, -0.04058995f, 0.17806777f, 0.15482751f, -0.11974099f, 
    0.40070641f, 0.58909333f, -0.08765769f, 0.36458209f, 0.16336475f, 0.01619020f, -0.14437452f, 0.27040946f, 
    -0.40481594f, -0.19976576f, -0.33076650f, -0.17109488f, -0.13238850f, 0.14256971f, -0.54333854f, -0.26573431f, 
    -0.03238288f, -0.09124463f, -0.50149316f, 0.16100973f, -0.00716254f, 0.13613993f, 0.24577175f, 0.31292763f, 
    0.74886525f, 0.09125847f, 0.35459822f, 0.11365279f, -0.40774092f, -0.13724582f, -0.11093809f, 0.09776022f, 
    -0.03870220f, 0.29342917f, -0.10083654f, 0.07876193f, 0.19444683f, 0.13326432f, -0.22551674f, 0.24629524f, 
    0.11448744f, 0.17479390f, 0.24719007f, -0.15309809f, -0.34667435f, -0.25485903f, -0.27379486f, -0.22771597f, 
    -0.07794815f, -1.04755712f, 0.54244375f, -0.17382662f, -0.25274423f, 0.03666435f, 0.10216097f, 0.75128448f, 
    -0.37213254f, 0.14976069f, 0.52788258f, -0.41509676f, -0.13057300f, 0.13566117f, -0.20619808f, 0.01760808f, 
    0.05750632f, 0.01970450f, -0.15777001f, -0.05097645f, -0.35221836f, -0.00670442f, -0.01662194f, 0.01607820f, 
    0.00832962f, -0.19472478f, 0.36848387f, 0.72095126f, 0.61328089f, 0.60787231f, 0.03543771f, -0.24852465f, 
    -0.02461155f, -0.60473979f, -0.34218192f, 0.21977027f, 0.42501673f, 0.11611775f, 0.03069004f, 0.06301259f, 
    -0.15904029f, -0.23697881f, 0.05364378f, 0.25637463f, -0.16254404f, 0.13657957f, 0.25117415f, 0.04651982f, 
    -0.28422618f, 0.03037602f, 0.05435202f, -0.47506312f, -0.18711549f, -0.09527850f, -0.49791163f, -0.27960649f, 
    0.22711678f, -0.00652484f, -0.03603451f, 0.27971858f, -0.44123062f, 0.37661570f, -0.14310527f, -0.15331444f, 
    0.29877546f, 0.09855108f, 0.16409551f, -0.10341315f, -0.29625627f, -0.49363989f, -0.22617008f, 0.07672570f, 
    -0.02909155f, 0.18065099f, 0.07262941f, -0.23103793f, 0.67293984f, 0.26652223f, 0.19842520f, -0.08236193f, 
    -0.29941088f, -0.13621612f, 0.44030729f, 0.41283223f, 0.47772846f, 0.64655364f, -0.02005028f, 0.16461048f, 
    -0.28132668f, -0.53180140f, 0.12872227f, -0.00391676f, 0.12436025f, 0.02525168f, -0.06101404f, 0.06147768f, 
    0.10530267f, -0.31226239f, -0.04254688f, -0.24631713f, 0.12495012f, -0.23922579f, -0.33126336f, 0.24002808f, 
    -0.11956272f, -0.57749593f, -0.15320045f, 0.26449668f, 0.44816041f, -0.25953096f, -0.14553948f, -0.26137075f, 
    0.07472136f, -0.36705896f, -0.23761888f, -0.10640740f, 0.21076505f, 0.30811715f, 0.27899885f, 0.20245177f, 
    -0.08604784f, -0.09429660f, -0.03300159f, -0.13566361f, -0.23230368f, -0.01814391f, -0.04568212f, -0.58366919f, 
    0.51353133f, 0.39537841f, -0.18833433f, 0.34255669f, -0.50083035f, 0.39384007f, -0.13030966f, -0.55090165f, 
    -0.18948629f, -0.37052304f, -0.10173985f, 0.09045380f, -0.16518013f, 0.17428194f, 0.29107937f, -0.10688011f, 
    -0.00671683f, 0.11672539f, -0.02076334f, -0.19128913f, 0.21347883f, -0.17738438f, -0.13500676f, -0.35045072f, 
    0.03725774f, 0.58869755f, -0.09752319f, 0.27105159f, 0.60372877f, 0.53702360f, 0.52532929f, 0.34715217f, 
    0.17960878f, 0.01546782f, 0.04413325f, -0.50752860f, 0.29128161f, -0.33139592f, -0.00511653f, -0.08792195f, 
    0.00189546f, 0.02556911f, 0.25113803f, -0.20419282f, 0.04091424f, -0.40192643f, 0.01412403f, 0.31663767f, 
    -0.07703262f, 0.80229503f, -0.21888904f, -0.30243081f, -0.04148419f, 0.63375366f, -0.22404571f, -0.46815172f, 
    -0.17843883f, -0.37948987f, 0.29768029f, 0.29277489f, 0.11949524f, 0.21690151f, -0.29293758f, -0.07673534f, 
    0.01114599f, 0.24629223f, -0.08068397f, -0.09853363f, 0.05571213f, -0.22315301f, -0.00875512f, 0.05184593f, 
    -0.09648687f, 0.71593171f, 0.42616883f, 0.35151106f, 0.02244967f, 0.56870496f, -0.44743970f, 0.23120710f, 
    -0.13209990f, 0.24294695f, -0.18107460f, -0.04268275f, -0.22002259f, 0.19418962f, -0.02912903f, 0.27453130f, 
    0.08611400f, -0.19269845f, 0.02046394f, -0.06944913f, 0.18013492f, -0.08821138f, -0.15283643f, -0.15913647f, 
    -0.02660209f, 0.04062585f, 0.78994173f, -0.00783389f, 0.13263322f, 0.68626076f, 0.57993019f, 0.01997669f, 
    -0.09074982f, 0.30038333f, -0.28478041f, 0.35024714f, -0.01148627f, -0.13535298f, -0.01885526f, -0.14162500f, 
    0.11827285f, -0.12496775f, -0.06195400f, 0.14239863f, 0.08358514f, 0.05445983f, 0.28411826f, -0.09758561f, 
    -0.13628878f, -0.40500531f, -0.06927111f, 0.61652261f, 0.36947751f, 0.35536963f, 0.29694119f, 0.52211607f, 
    0.06438904f, -0.16770548f, -0.03102002f, -0.68534213f, -0.32519722f, -0.14600112f, -0.06566189f, -0.02072910f, 
    0.34332457f, 0.14029659f, 0.02087794f, 0.30524263f, 0.31822473f, -0.06538360f, -0.13411222f, -0.19588120f, 
    -0.11819491f, -0.18591526f, -0.05362497f, 0.09136525f, 0.49331018f, 0.51328760f, -0.40941980f, 0.12469114f, 
    -0.38549018f, 0.04069321f, 0.32334906f, -0.31885433f, 0.35536373f, 0.04105619f, 0.29792356f, -0.03756878f, 
    -0.19884570f, 0.31118995f, 0.26363465f, -0.12443747f, -0.21764296f, -0.14708360f, -0.30279273f, -0.24179667f, 
    -0.23484473f, 0.38181776f, 0.17436367f, 0.08776204f, -0.06766856f, 0.97446007f, -0.14359027f, -0.45623222f, 
    0.16943581f, 0.09279313f, 0.19133465f, 0.37174803f, 0.00431567f, 0.26885051f, -0.00432277f, -0.30249736f, 
    0.34790000f, -0.14608146f, 0.20464087f, -0.15542832f, 0.03632756f, 0.12224352f, -0.43961999f, 0.04814428f, 
    -0.10490533f, -0.31529185f, 0.20431420f, 0.01835422f, 0.01046158f, 0.07262818f, 0.61166352f, -0.47264624f, 
    -0.50723553f, -0.55029154f, 0.87203562f, 0.19832033f, -0.27633438f, 0.22199932f, -0.12295212f, 0.18493466f, 
    -0.19476689f, 0.29483816f, -0.25108904f, -0.04408468f, 0.17758588f, -0.32315391f, -0.21186426f, -0.12677038f, 
    -0.04739496f, 0.05280893f, 0.05675750f, -0.03566498f, -0.02407975f, 0.14786327f, -0.18406497f, 0.54546249f, 
    -0.67462778f, -0.04331474f, 0.54266888f, -0.45092118f, -0.39457110f, 0.27732262f, 0.27709258f, -0.58032143f, 
    0.35822138f, 0.08497503f, 0.05874683f, 0.31926298f, -0.17096630f, 0.13224728f, -0.23909995f, -0.02719920f, 
    0.29763898f, 0.10946564f, -0.20488794f, 0.22440393f, -0.00991777f, 0.27393216f, 0.04302064f, -0.00526151f, 
    -0.08886778f, 0.19419007f, -0.15355441f, 0.32420334f, 0.73756272f, -0.71648115f, -0.80148882f, -0.28967783f, 
    -0.03935530f, -0.04279828f, 0.04954188f, 0.48233804f, -0.15743816f, -0.15215154f, 0.12247021f, 0.19372842f, 
    0.11292639f, -0.05555255f, 0.18896434f, 0.10910822f, -0.07130425f, -0.31974158f, 0.10297482f, -0.03799170f, 
    -0.25962448f, -0.00390751f, 0.60295451f, 0.61984295f, 0.03146473f, -0.09869267f, -0.75167465f, -0.34375498f, 
    0.17802083f, -0.50790918f, -0.26279265f, 0.15973450f, -0.15887430f, -0.06245117f, -0.02632274f, 0.31263280f, 
    0.04342262f, 0.01571586f, 0.06024115f, -0.02165311f, 0.11145905f, 0.27939150f, 0.40215138f, 0.04995836f, 
    0.24154590f, -0.12574008f, 0.25226530f, 0.05897723f, 0.16688529f, 0.71779001f, 0.33436334f, 0.12141407f, 
    0.03492464f, 0.45116922f, 0.17625080f, 0.05050994f, 0.18746784f, -0.32905027f, -0.22165246f, 0.10934994f, 
    -0.13777895f, 0.13918644f, -0.26174194f, -0.11883590f, -0.21549164f, -0.32561061f, 0.11675341f, -0.10869429f, 
    -0.34511894f, 0.21250881f, -0.18280590f, 0.31946149f, -0.65144998f, 0.21369621f, -0.02451174f, -0.09276244f, 
    -0.27822697f, 0.10966120f, -0.23346013f, -0.29192424f, -0.46464366f, 0.07168635f, -0.34305257f, -0.23947439f, 
    0.04458356f, -0.25833091f, 0.33700821f, -0.25869837f, -0.37097415f, -0.14433661f, -0.51652163f, 0.09640047f, 
    -0.05697179f, 0.39290428f, 0.10488161f, 0.36579365f, -0.46368548f, -0.01604702f, 0.61464655f, 0.34606764f, 
    -0.33054373f, 0.07316496f, 0.47577506f, -0.46518460f, -0.39857343f, 0.24963377f, 0.42671657f, 0.17735848f, 
    0.01828477f, 0.14305893f, -0.09814771f, 0.04920689f, -0.20840965f, -0.42803383f, -0.12532850f, 0.37468025f, 
    -0.25627264f, 0.27817625f, 0.27505913f, 0.01165594f, 0.22043377f, -0.10567685f, 0.27775255f, 0.67808706f, 
    0.44871897f, 0.24876215f, 0.37247798f, -0.41370037f, -0.01087928f, -0.26249599f, 0.31956622f, 0.46139234f, 
    0.17379895f, 0.17674397f, 0.26361871f, -0.00348411f, -0.22711204f, 0.21423241f, 0.29528898f, -0.03550635f, 
    0.05783084f, 0.00243829f, 0.20150721f, -0.02012902f, -0.02831153f, 0.04116372f, 0.59783036f, 0.45782292f, 
    -0.60613889f, -0.16662174f, 0.44810402f, 0.10155712f, 0.28483555f, 0.30197889f, 0.27413100f, 0.11698668f, 
    0.07587659f, 0.05143760f, 0.02261329f, 0.04827411f, 0.12966478f, 0.13299723f, -0.03312510f, -0.09115080f, 
    0.11165723f, 0.27745768f, 0.24872281f, -0.01101369f, -0.03326859f, 0.10169543f, -0.05930443f, -0.83118308f, 
    0.50883830f, 0.70292491f, -0.40545115f, -0.16711496f, 0.32322088f, 0.38272998f, 0.28565592f, -0.07015020f, 
    0.24246587f, 0.24761422f, 0.18436635f, 0.29983750f, -0.43667772f, -0.32085112f, -0.32423353f, -0.19409244f, 
    -0.09582564f, 0.04424251f, -0.34914714f, 0.17266458f, 0.05629453f, 0.16461831f, 0.17548607f, -0.16647570f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11202339f, 0.25559780f, -0.09832233f, 0.19373025f, 0.15760721f, 0.29180479f, -0.12811112f, 0.25321966f, 
    0.08535773f, -0.21148188f, 0.01862316f, -0.00004286f, 0.27742034f, 0.03750262f, -0.04560811f, -0.03692769f, 
    0.04887353f, 0.18684730f, 0.15675841f, 0.25425547f, 0.06133368f, -0.09591553f, 0.17504680f, 0.05755852f, 
    0.19371091f, -0.10862005f, 0.02862290f, 0.12108620f, 0.27449161f, 0.04695317f, 0.01307885f, 0.25842184f, 
    -0.05544164f, 0.21311344f, 0.21117978f, 0.28364113f, -0.06730550f, 0.18009222f, 0.15473031f, -0.01447374f, 
    0.27581993f, -0.08686393f, 0.20249195f, 0.21218798f, 0.09555831f, -0.14872648f, 0.05813691f, 0.22332674f, 
    0.11186929f, -0.02109740f, 0.05515852f, 0.08478615f, 0.19339505f, -0.13456927f, 0.12844346f, -0.05852335f, 
    0.24296696f, 0.30642954f, 0.16651821f, -0.04460156f, 0.08070002f, 0.00911362f, 0.14263861f, 0.10177619f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.18155223f, -0.01547958f, 0.10464914f, 0.20971391f, -0.01732003f, -0.06156548f, 0.01715134f, -0.02355730f, 
    -0.00671275f, 0.03651733f, 0.05241525f, 0.02811927f, 0.11795942f, -0.01782280f, -0.00186395f, -0.16902637f, 
    0.06144074f, 0.02823584f, 0.01845616f, 0.05341729f, 0.00858318f, -0.03798550f, 0.13647419f, -0.04938120f, 
    0.10641202f, 0.12637405f, 0.14145333f, -0.04220764f, 0.06572020f, 0.04675884f, -0.12782405f, -0.05505107f, 
    -0.20047194f, -0.11592735f, 0.01100366f, -0.05382917f, 0.07968653f, -0.02870440f, -0.04509518f, 0.02177606f, 
    0.20218438f, 0.05100592f, 0.00257396f, 0.05099006f, -0.01837001f, -0.00337575f, 0.03752409f, 0.00626858f, 
    0.12523706f, -0.06769516f, -0.00468009f, -0.06226465f, 0.02702517f, 0.01397715f, -0.14098074f, 0.10407682f, 
    -0.01473519f, -0.03414757f, 0.00308504f, 0.04064898f, 0.17365664f, 0.08474247f, 0.01081628f, -0.07485696f, 
    0.01513930f, 0.13354988f, 0.00414450f, -0.01473759f, 0.02374079f, -0.07401875f, -0.03215379f, 0.00558017f, 
    0.23148505f, -0.23712896f, 0.24646205f, 0.16588117f, -0.01563152f, -0.00233858f, -0.02561933f, 0.00415498f, 
    0.05748468f, 0.11246081f, 0.05970780f, 0.09626910f, 0.24963096f, -0.24540246f, 0.04729650f, 0.14853597f, 
    -0.01909705f, -0.09987693f, -0.11168412f, 0.01274082f, -0.04734432f, 0.10860736f, 0.04488204f, 0.09121400f, 
    -0.24190061f, -0.09927210f, -0.02767919f, -0.01098198f, 0.02573731f, 0.02542749f, 0.01636112f, -0.08694579f, 
    -0.00888051f, -0.04506662f, -0.06573350f, -0.05459674f, 0.10149796f, -0.09642862f, 0.11410686f, -0.14292605f, 
    -0.03972137f, -0.10971536f, 0.14414053f, -0.05169883f, 0.03057684f, -0.01178755f, 0.08011543f, 0.12996063f, 
    0.19114925f, -0.19467497f, 0.14259861f, 0.03098072f, 0.02425282f, 0.09901080f, 0.18823250f, -0.08246829f, 
    -0.15321389f, 0.05305896f, -0.13989690f, -0.07891832f, -0.06774350f, 0.07626577f, -0.19709437f, 0.24812073f, 
    -0.13707991f, 0.05335424f, 0.02145104f, -0.03261111f, 0.05198186f, 0.01290159f, 0.05145306f, -0.03056541f, 
    -0.18463053f, 0.07501550f, 0.06943125f, -0.13616566f, -0.06438769f, 0.07458267f, 0.01985063f, 0.00631567f, 
    -0.02837374f, 0.09230288f, 0.03748562f, 0.02049898f, 0.10875859f, 0.03790001f, -0.00468282f, 0.18822618f, 
    -0.02640508f, 0.05287289f, 0.03676848f, 0.01912067f, -0.01684307f, 0.01289848f, -0.00040043f, 0.06108133f, 
    0.06472331f, 0.05659965f, 0.00111501f, -0.04219382f, 0.02104696f, 0.02124871f, 0.09196111f, 0.09511725f, 
    0.03016413f, 0.04938281f, 0.04835770f, -0.10071775f, -0.14476070f, 0.03688067f, 0.03195269f, -0.17028598f, 
    0.01011921f, 0.18427749f, -0.00372844f, -0.03648366f, 0.11464223f, 0.01985267f, -0.11684351f, 0.01781951f, 
    0.27999005f, 0.20184687f, -0.07625450f, -0.07870164f, -0.10495264f, -0.03756367f, 0.07846698f, 0.07894965f, 
    -0.01291087f, -0.10532847f, -0.08118940f, -0.10902663f, 0.28482920f, -0.00698504f, 0.01142287f, 0.15488555f, 
    -0.09482866f, 0.08957035f, -0.06192213f, 0.11726476f, 0.03034239f, -0.02141773f, 0.10286065f, -0.01310695f, 
    -0.15608644f, -0.00575754f, 0.08637773f, -0.11695172f, -0.10431569f, 0.07830609f, 0.07987706f, -0.04705619f, 
    -0.08326472f, 0.09754838f, -0.05981052f, -0.04071893f, 0.06258681f, 0.22909300f, -0.25109181f, -0.10278362f, 
    -0.01966102f, 0.09320056f, -0.03050896f, 0.01868427f, 0.05552178f, 0.01293842f, 0.00862227f, 0.15508191f, 
    0.05284363f, 0.09746971f, -0.06781874f, -0.07108591f, 0.07471627f, -0.02307034f, 0.02147015f, -0.03644858f, 
    0.12359111f, 0.18837512f, -0.11890997f, 0.03713112f, -0.04040614f, 0.02651807f, -0.14091349f, -0.10404293f, 
    -0.06808235f, -0.00892049f, 0.08189428f, -0.01791482f, 0.02061793f, -0.02887364f, -0.09292270f, -0.02962513f, 
    -0.13191678f, 0.12753604f, 0.07677390f, -0.13925219f, 0.01005162f, -0.12224146f, 0.19806938f, -0.10115051f, 
    0.02264349f, 0.08807350f, -0.09753344f, 0.01325350f, -0.13017076f, -0.00741381f, -0.17860772f, 0.02981251f, 
    0.00137333f, 0.11078794f, -0.11707667f, 0.06344283f, -0.10413799f, -0.10558559f, 0.01004424f, 0.01058473f, 
    0.02780749f, -0.04514952f, -0.12343065f, 0.10113160f, -0.00033037f, 0.06552099f, -0.08339093f, 0.08021406f, 
    0.13161787f, 0.11076582f, 0.05604423f, 0.13499503f, -0.42863026f, 0.06026196f, -0.13961659f, 0.30143705f, 
    -0.06358015f, 0.04216037f, -0.07535580f, -0.00797618f, 0.07574321f, 0.03447813f, 0.02735594f, 0.05110271f, 
    0.17166191f, 0.06873094f, 0.07443826f, -0.02176241f, 0.12889548f, 0.08428045f, 0.10250615f, -0.01699052f, 
    0.03883654f, -0.02419920f, 0.05397042f, 0.04720248f, 0.21103206f, 0.13310872f, -0.08217426f, -0.11204626f, 
    0.03049275f, 0.02572025f, -0.02662080f, 0.01205203f, -0.00455777f, -0.12935272f, -0.03136165f, 0.00873310f, 
    -0.11776122f, -0.00803790f, 0.12334467f, 0.05238521f, 0.14335951f, 0.00428078f, 0.10395020f, -0.04017075f, 
    0.08309645f, -0.09498294f, 0.08026061f, -0.01628619f, -0.33173445f, 0.27275398f, -0.12731321f, -0.15598932f, 
    0.00035894f, 0.01533059f, 0.14603721f, -0.00758036f, 0.04357921f, 0.00720431f, 0.01110947f, -0.07970455f, 
    -0.12179503f, -0.02715703f, 0.03657101f, -0.07277499f, 0.14969146f, -0.00661598f, -0.07327461f, -0.02678405f, 
    -0.05422711f, -0.10900085f, 0.04499434f, -0.10918143f, -0.15736802f, -0.05898016f, 0.15744784f, 0.12571812f, 
    -0.03363568f, 0.02128681f, -0.01641609f, 0.01725132f, -0.03471325f, 0.09504533f, -0.13146426f, -0.05096744f, 
    0.15175267f, 0.10093030f, 0.09226718f, -0.27081025f, 0.12581074f, -0.01526997f, -0.04117668f, -0.01624240f, 
    -0.01717770f, -0.14424899f, 0.15878390f, 0.05952284f, 0.04336492f, -0.04238589f, -0.12817478f, -0.13750370f, 
    0.10529940f, 0.04106803f, -0.01117702f, 0.02237825f, -0.06015255f, -0.17734472f, -0.02422631f, 0.00015114f, 
    0.03071171f, 0.11757483f, -0.03166153f, 0.03449876f, -0.02166123f, 0.01462095f, 0.08457064f, 0.00457449f, 
    0.00826103f, -0.04313431f, 0.06235000f, 0.03895727f, -0.00286333f, -0.01341996f, -0.05620393f, -0.10946871f, 
    0.10056023f, 0.04751487f, 0.04835922f, -0.01377001f, -0.06848310f, 0.08736839f, 0.03820715f, 0.13850328f, 
    -0.07253481f, 0.20021844f, 0.21065995f, 0.04497787f, -0.03045724f, 0.07482539f, 0.07795414f, -0.12783928f, 
    0.00627467f, 0.04220150f, -0.08619998f, -0.01086083f, 0.33833104f, 0.21260445f, 0.00855884f, -0.03868141f, 
    0.05761417f, -0.02858105f, -0.10338160f, -0.09052778f, 0.00417634f, -0.01626069f, -0.14622964f, -0.00744616f, 
    0.23069848f, 0.11592593f, 0.15751764f, 0.08460967f, 0.09566393f, 0.01495050f, -0.02246454f, 0.10226745f, 
    -0.02363182f, 0.06842059f, -0.07418127f, 0.09528495f, -0.03049762f, 0.11238545f, -0.05479918f, 0.13400954f, 
    -0.18381079f, 0.12694788f, 0.07159283f, 0.09238505f, 0.10699922f, -0.00507382f, -0.05180689f, -0.03637291f, 
    0.06457169f, 0.03753512f, -0.04171540f, 0.02936092f, -0.00834766f, -0.02071812f, -0.08995967f, -0.00333660f, 
    -0.03496425f, -0.06943922f, 0.09333923f, -0.00961086f, 0.00891295f, 0.17715462f, -0.07099669f, -0.03783155f, 
    0.13454473f, -0.01709762f, -0.01168502f, -0.17146353f, 0.04417567f, -0.00977212f, 0.06545627f, -0.10883896f, 
    0.14284091f, 0.05688129f, 0.03526268f, 0.12167277f, -0.06518514f, -0.03279719f, 0.07757295f, -0.03261489f, 
    -0.02000245f, -0.03081541f, 0.10574483f, 0.08776305f, -0.15952200f, -0.08851479f, 0.12878920f, -0.11534709f, 
    0.02103154f, 0.15806830f, 0.06760421f, 0.02159744f, 0.07623147f, -0.06596138f, -0.07602258f, 0.01591459f, 
    0.34636006f, 0.02912470f, -0.04347083f, -0.04928000f, -0.05300842f, -0.09886894f, -0.02959503f, -0.02780983f, 
    -0.10018218f, -0.02998709f, -0.08650672f, 0.06534027f, -0.07733771f, 0.15550886f, -0.14120628f, -0.02243780f, 
    0.06912591f, -0.01787232f, -0.02154434f, 0.10364801f, 0.14714998f, 0.05307805f, -0.03422683f, -0.11325695f, 
    -0.39314538f, 0.04387202f, -0.01670454f, 0.07751451f, -0.15551463f, 0.00835588f, -0.01400306f, 0.01239547f, 
    0.12898688f, 0.11864896f, 0.01079037f, -0.05469052f, 0.27259177f, 0.17229491f, 0.09227762f, -0.05149677f, 
    0.00136432f, 0.01525460f, -0.08561964f, 0.05024150f, 0.02288294f, 0.09069745f, -0.05293164f, 0.03888827f, 
    -0.21173725f, -0.08277252f, 0.01860022f, -0.07689147f, 0.04663099f, -0.09654215f, 0.09470034f, -0.11315200f, 
    -0.00873185f, 0.07401177f, -0.02456710f, 0.02708729f, 0.16945863f, 0.02666341f, -0.11411104f, 0.12061167f, 
    0.02996605f, 0.03437366f, 0.03507854f, 0.06526528f, 0.00113662f, 0.09016844f, -0.11621638f, 0.00204605f, 
    0.15019245f, 0.01394460f, 0.11604980f, 0.26824528f, 0.01793422f, -0.00850150f, -0.14686906f, 0.06645889f, 
    -0.02040317f, 0.07328405f, -0.01055646f, 0.07409310f, 0.05251526f, 0.05265190f, 0.02470214f, 0.21196085f, 
    0.02128682f, 0.08098694f, -0.01653723f, -0.03342060f, -0.02198858f, 0.02208717f, 0.04981583f, 0.02118841f, 
    0.22287501f, -0.16592009f, -0.21025999f, -0.04060530f, -0.09562392f, -0.17723998f, 0.09452879f, -0.04095868f, 
    -0.05195050f, -0.07266270f, -0.08012813f, 0.06468190f, 0.24216706f, -0.15636452f, -0.03498730f, -0.07948176f, 
    0.02229680f, 0.01070645f, -0.02422929f, -0.02630842f, -0.09372085f, -0.04508588f, -0.03110708f, -0.07564257f, 
    0.14623272f, -0.10612310f, 0.26634824f, -0.29028204f, 0.06940465f, 0.00080795f, 0.00918200f, 0.11610358f, 
    0.00101258f, -0.01914639f, -0.16308838f, 0.02183682f, 0.24806967f, 0.05206907f, 0.08513907f, 0.24187876f, 
    -0.12602721f, 0.07555271f, 0.00262026f, 0.09052446f, 0.13890095f, -0.01772418f, 0.10219157f, -0.03122348f, 
    0.22462319f, -0.04651994f, 0.00468138f, -0.00443041f, 0.07120965f, -0.10925755f, 0.02626180f, -0.00939243f, 
    -0.11594776f, -0.02017703f, -0.07033534f, 0.05320920f, -0.09564373f, 0.25463355f, -0.09835151f, 0.01468227f, 
    -0.03307608f, -0.01518901f, -0.02182510f, 0.01477818f, 0.06029843f, 0.01307477f, 0.01283531f, 0.13488129f, 
    -0.10779144f, 0.04297648f, -0.03697560f, 0.16071227f, 0.03659287f, -0.04053128f, -0.11018161f, 0.02033739f, 
    0.00787295f, 0.02948144f, -0.02815080f, 0.04905120f, -0.16774610f, 0.10325565f, 0.06843493f, -0.10424434f, 
    0.01810184f, 0.06106342f, -0.04022843f, 0.03852943f, 0.13554615f, -0.14027154f, -0.15560247f, 0.08723912f, 
    0.02026937f, -0.08510409f, -0.06413502f, -0.02208977f, -0.12459147f, -0.03537148f, 0.03029912f, -0.02590669f, 
    -0.02980839f, -0.02014987f, 0.06603058f, 0.11113567f, -0.07680384f, 0.09838248f, 0.15602511f, 0.14410587f, 
    -0.05862322f, 0.05208796f, -0.01340860f, -0.03417019f, -0.02572617f, 0.02607563f, 0.06338494f, -0.06679925f, 
    0.26880845f, -0.05568693f, 0.04650760f, -0.14262994f, -0.03679391f, -0.05193998f, 0.03326381f, -0.04288926f, 
    -0.05347477f, 0.15126300f, -0.06858803f, 0.06043027f, 0.02679265f, 0.06991060f, -0.06482582f, 0.04829890f, 
    -0.11239333f, 0.05372614f, 0.00389380f, 0.06075525f, 0.05781299f, -0.01881828f, 0.09794436f, -0.23919408f, 
    0.03105141f, -0.03106437f, -0.03030537f, 0.02676551f, 0.02003663f, 0.01599371f, 0.01996228f, -0.01143486f, 
    0.01311852f, -0.02611741f, -0.02372204f, -0.02489231f, -0.03107365f, 0.00144885f, 0.01487680f, 0.00479305f, 
    0.01612957f, -0.01454556f, -0.02357790f, -0.03618789f, -0.00380889f, 0.01896725f, 0.01050218f, -0.01668022f, 
    0.01245203f, 0.02598498f, 0.01224680f, -0.01903903f, -0.01492017f, 0.02162242f, 0.00973409f, -0.03498799f, 
    -0.00139532f, -0.00019611f, 0.01665315f, 0.02701346f, 0.01156906f, -0.02822292f, 0.02300030f, 0.01652506f, 
    0.02587118f, -0.03074628f, 0.01777924f, -0.00404262f, -0.00648584f, -0.00501978f, -0.01183649f, -0.01300550f, 
    0.02841261f, -0.00594660f, -0.03954215f, 0.01734122f, -0.01616393f, 0.01217880f, -0.02533427f, -0.02907112f, 
    0.01866463f, -0.03078187f, -0.00852938f, -0.02160861f, 0.03052610f, 0.01833893f, 0.02559132f, -0.00460266f, 
    -0.00148616f, 0.00768613f, -0.02951657f, -0.00533221f, -0.01403606f, -0.00510953f, -0.01222122f, -0.01269485f, 
    -0.02183289f, -0.01955548f, -0.02836354f, 0.00379074f, -0.01690174f, 0.00201065f, 0.02949014f, -0.02002993f, 
    0.01902727f, 0.00337128f, 0.01253414f, -0.03794611f, 0.01697668f, -0.02094684f, 0.00441147f, -0.01041096f, 
    0.00356819f, -0.02136092f, -0.03192451f, -0.03259386f, 0.00319683f, -0.02199848f, -0.03261516f, -0.00271741f, 
    -0.03534694f, -0.03369729f, 0.00915983f, -0.01054675f, -0.02517961f, -0.02170496f, -0.00861594f, -0.03025680f, 
    0.02356262f, -0.01134276f, 0.01768461f, 0.00692344f, 0.02645652f, 0.00875887f, 0.00754670f, -0.02355038f, 
    -0.01521744f, -0.02081154f, 0.02669298f, 0.00036195f, -0.04284306f, 0.00475454f, -0.02074230f, 0.00239109f, 
    0.01183706f, -0.03372677f, 0.01171927f, 0.01013401f, 0.00016511f, -0.00229331f, -0.03076891f, 0.00109323f, 
    0.01493347f, 0.02872548f, 0.01083834f, -0.01919145f, -0.02675463f, 0.02235761f, 0.02816025f, 0.01487909f, 
    -0.02735409f, -0.01218512f, -0.01256932f, -0.02110166f, -0.01556311f, -0.02481700f, 0.02694230f, -0.02373469f, 
    0.01910681f, -0.02872627f, -0.00972472f, 0.02755169f, -0.03248896f, 0.00199874f, 0.02539584f, -0.03428755f, 
    -0.01443578f, -0.01377595f, 0.01843082f, -0.00717556f, 0.02912205f, -0.00891236f, 0.00843138f, -0.00260566f, 
    -0.00957828f, 0.01325458f, 0.02571328f, -0.02567912f, -0.02725431f, 0.01598063f, -0.01006733f, 0.00322576f, 
    -0.02868007f, 0.01428509f, 0.02125946f, -0.02933984f, -0.02999412f, -0.00229664f, 0.02104054f, -0.02669183f, 
    -0.02190806f, -0.03257350f, -0.04136085f, 0.01325131f, 0.01083358f, -0.00323852f, -0.02311194f, 0.01934404f, 
    -0.01589903f, 0.02633972f, -0.00620762f, -0.00977172f, 0.02385106f, 0.03342594f, 0.00356309f, -0.00101715f, 
    -0.02746141f, 0.01436938f, 0.03284104f, -0.01634037f, -0.00852598f, 0.00919459f, 0.00649373f, -0.01800552f, 
    0.02396688f, -0.00170130f, -0.01227197f, 0.01214208f, -0.01882637f, 0.01179275f, -0.00974550f, 0.00515070f, 
    -0.01443345f, -0.00335075f, 0.02013506f, 0.02942602f, -0.02769467f, -0.03605477f, -0.03410673f, -0.04235426f, 
    0.02409741f, 0.00720932f, 0.01274695f, -0.00709396f, 0.00140142f, 0.02428704f, 0.00206262f, -0.02155081f, 
    -0.01713703f, -0.03664529f, 0.00894307f, 0.02607044f, 0.01827396f, -0.00622492f, 0.02985224f, -0.01188052f, 
    -0.01303865f, -0.04488734f, 0.01326573f, 0.02385670f, 0.02206695f, 0.02221042f, 0.02653057f, -0.02372158f, 
    -0.04452745f, 0.01226874f, -0.01806446f, -0.00763008f, -0.01173539f, 0.01660406f, 0.02512489f, -0.00794220f, 
    0.01684409f, -0.02992725f, -0.02409717f, -0.00503092f, -0.00546630f, 0.01006221f, 0.02551692f, -0.00540084f, 
    -0.02338684f, -0.03234579f, -0.03275797f, -0.02287024f, -0.04194427f, 0.03197246f, -0.00700530f, -0.02962969f, 
    -0.02194764f, 0.00610308f, -0.01407858f, -0.02078479f, -0.00345093f, -0.01704148f, 0.00346243f, 0.00647159f, 
    0.02826422f, 0.00935374f, -0.02613657f, -0.02960393f, 0.03233736f, 0.03747940f, 0.00226306f, 0.02553663f, 
    0.00439557f, 0.03110174f, -0.00812556f, -0.02190270f, 0.00779290f, 0.02600576f, 0.02432263f, 0.01643776f, 
    -0.00757181f, 0.02408520f, 0.02614781f, 0.01612331f, 0.00886501f, 0.01266253f, -0.00471885f, -0.03797228f, 
    -0.02737765f, -0.00117390f, 0.01846405f, -0.04142152f, -0.01957635f, -0.02302082f, 0.02966097f, 0.03120986f, 
    0.00094283f, -0.01410008f, -0.00215478f, 0.01567901f, -0.01691002f, 0.00860851f, -0.02550702f, -0.02682072f, 
    -0.04179416f, -0.01213464f, 0.02748746f, -0.02196716f, 0.02137372f, -0.01439023f, -0.01764011f, 0.00143347f, 
    -0.01412708f, -0.00681266f, -0.00666889f, -0.00822719f, 0.00287886f, 0.00885646f, -0.04166365f, 0.01613606f, 
    -0.02896485f, -0.03194140f, 0.00680767f, -0.02543848f, -0.00010107f, 0.01575663f, -0.02266825f, -0.00105931f, 
    -0.00393934f, 0.00421397f, 0.02657192f, 0.02834800f, 0.01323303f, -0.03744834f, -0.01586783f, -0.01890335f, 
    -0.03753560f, 0.02006366f, -0.00027569f, -0.02922007f, 0.02473029f, 0.01862958f, 0.02034085f, -0.03383084f, 
    0.01971864f, -0.01536351f, -0.03265179f, 0.00748887f, -0.02873978f, -0.02254694f, -0.03513766f, 0.01715136f, 
    -0.01942047f, 0.01806298f, 0.02462544f, -0.01663306f, -0.01885329f, 0.01280256f, -0.02608968f, 0.02268431f, 
    0.00604119f, -0.02236746f, 0.02426698f, -0.00597680f, 0.03022085f, 0.00752822f, 0.03100133f, 0.01010821f, 
    0.03001893f, 0.02812561f, 0.01805916f, 0.01265057f, -0.00213823f, 0.00787136f, -0.02112309f, -0.03848668f, 
    -0.01179173f, -0.04265533f, -0.02197444f, -0.02564548f, -0.01719240f, -0.03466305f, 0.02717039f, -0.00065966f, 
    -0.01851429f, -0.01552402f, -0.03292948f, 0.02052827f, -0.03164978f, 0.01384990f, -0.03292858f, -0.01700351f, 
    0.00180373f, 0.01144663f, -0.02569702f, -0.01064121f, -0.02633407f, -0.02308834f, 0.01283998f, 0.02262785f, 
    -0.03408486f, 0.01411720f, -0.01197402f, -0.02859105f, -0.04135914f, 0.00177273f, -0.02026092f, 0.00491009f, 
    -0.02076491f, -0.01920570f, 0.00404238f, -0.04666889f, -0.00627085f, -0.00814884f, -0.03303110f, -0.02936777f, 
    -0.00587633f, 0.02362346f, -0.03616254f, -0.03067936f, -0.03586166f, -0.01442008f, -0.00961803f, 0.00091767f, 
    0.00851850f, -0.02312268f, -0.02835985f, -0.04500433f, -0.00265852f, -0.00764380f, -0.01998282f, 0.00232253f, 
    0.00424175f, 0.02221462f, -0.01051127f, -0.02864793f, 0.01302104f, -0.01791263f, -0.03987316f, -0.02237737f, 
    -0.01061702f, 0.00929829f, -0.03751969f, -0.03609141f, 0.02667245f, -0.00727221f, 0.00194132f, -0.01789016f, 
    -0.03798823f, 0.01168935f, 0.01399831f, -0.01328884f, 0.00107174f, 0.01435660f, -0.03038815f, 0.00336689f, 
    0.02964477f, 0.00651642f, -0.02302415f, -0.00700336f, -0.03764442f, -0.01994996f, -0.00804529f, -0.00424853f, 
    0.01819648f, -0.02590342f, 0.01443099f, 0.01014365f, 0.01603845f, -0.01676052f, -0.01734272f, 0.02062737f, 
    0.02533468f, 0.01404587f, -0.00259402f, -0.03284645f, -0.01303330f, -0.04131792f, -0.02249710f, -0.03451468f, 
    0.02404713f, 0.03431010f, 0.01162113f, 0.01668034f, -0.02959759f, 0.00012488f, 0.00054317f, -0.02235362f, 
    -0.00000585f, 0.01954853f, 0.02607713f, -0.03488131f, 0.03368859f, -0.00707747f, 0.00175481f, 0.00121100f, 
    0.01697931f, -0.03255209f, 0.03393919f, -0.00132191f, -0.01635429f, -0.02784991f, -0.02329057f, -0.00693416f, 
    -0.02254684f, 0.01539091f, -0.00068857f, 0.01617498f, 0.00781891f, 0.01286892f, 0.00133175f, -0.02631391f, 
    0.01213354f, 0.02125537f, 0.02540843f, 0.02880587f, -0.03588685f, 0.02050573f, -0.02196229f, 0.01718470f, 
    -0.01975984f, 0.02249674f, -0.02986450f, 0.00295082f, 0.02502309f, -0.03783054f, -0.00182708f, -0.00305241f, 
    0.01304907f, -0.02971911f, -0.02992188f, -0.03313806f, -0.00527968f, 0.01911982f, 0.00070406f, 0.00448101f, 
    -0.00722619f, 0.00591548f, -0.03048036f, 0.02869625f, -0.01866614f, 0.02426985f, 0.00128690f, -0.02888956f, 
    -0.03283704f, -0.00615411f, 0.00344163f, -0.01373090f, -0.02197741f, -0.00740440f, -0.02032738f, -0.03759603f, 
    -0.01052281f, -0.03108868f, 0.02139827f, 0.01654211f, -0.01392872f, -0.02345309f, 0.02427986f, -0.02038680f, 
    0.02416142f, 0.02125283f, 0.00593114f, 0.01046930f, 0.00324062f, 0.00421678f, -0.02162860f, -0.02424306f, 
    0.01994360f, 0.00771196f, 0.01294236f, -0.03263654f, -0.00159579f, -0.02826858f, 0.02775941f, -0.01143785f, 
    0.02588016f, 0.00353885f, 0.02465047f, -0.02253095f, 0.00822645f, 0.01763023f, -0.02810796f, -0.04084302f, 
    -0.00859650f, -0.03840175f, -0.04427726f, 0.01763592f, 0.01044662f, -0.00369252f, 0.03002397f, -0.00435047f, 
    -0.00180058f, -0.02231224f, 0.01963947f, 0.00462663f, 0.02061413f, -0.03584721f, 0.00733182f, 0.00688228f, 
    0.01978561f, -0.01455503f, 0.01095369f, 0.02128402f, -0.03750137f, 0.01699974f, 0.01816081f, 0.01347250f, 
    0.01521334f, -0.00443951f, -0.03714549f, 0.00961207f, -0.02971919f, -0.01925549f, 0.01495090f, 0.02722649f, 
    -0.04652068f, 0.02078003f, 0.01341936f, -0.02482490f, 0.01015308f, 0.03099038f, 0.00246678f, -0.00719489f, 
    0.00494361f, 0.02990363f, 0.00553759f, -0.02423036f, 0.00698188f, -0.03090153f, 0.00821619f, 0.02728007f, 
    0.02572055f, -0.01764801f, 0.02395597f, -0.04121017f, 0.02901165f, -0.00625723f, -0.01611798f, -0.01927216f, 
    -0.01555903f, 0.00616837f, -0.00345294f, -0.02678083f, -0.03391681f, -0.00953057f, -0.03921153f, -0.01701579f, 
    0.03455689f, -0.00401771f, -0.03225782f, 0.00481969f, 0.00803905f, -0.02585116f, 0.02136602f, 0.01337979f, 
    -0.04024216f, -0.00973336f, 0.02366688f, -0.02043496f, -0.00353110f, -0.01651703f, 0.01518965f, 0.01904990f, 
    0.01546719f, 0.01398099f, 0.00142629f, -0.02809194f, 0.01730214f, -0.03581188f, -0.02698803f, -0.03711141f, 
    0.01921311f, -0.01096088f, 0.00390837f, 0.01356948f, -0.04253979f, 0.02183789f, -0.00214903f, -0.00357080f, 
    0.02679127f, 0.02511107f, 0.00273069f, 0.02381494f, 0.00928140f, 0.01161484f, -0.02838854f, -0.00547432f, 
    0.02928559f, -0.03122766f, -0.00334393f, -0.02550375f, 0.00044801f, 0.00064087f, 0.01608328f, -0.00234407f, 
    -0.02843830f, -0.00877484f, 0.01230057f, 0.02261827f, -0.01450651f, -0.01380890f, -0.00515257f, -0.03733801f, 
    -0.00414480f, -0.01061911f, -0.01310183f, 0.01666496f, -0.00575404f, -0.00424584f, 0.03536065f, 0.02259688f, 
    -0.00096534f, -0.02551525f, -0.01126900f, -0.03762592f, 0.01506523f, 0.00324651f, -0.02786691f, -0.02963724f, 
    0.02694064f, -0.03670788f, 0.01924028f, -0.02531788f, 0.01559151f, -0.03720700f, -0.00148729f, -0.03592560f, 
    -0.03561644f, 0.01980183f, -0.02676122f, -0.00899907f, -0.02549277f, -0.01092030f, -0.00932035f, -0.04308157f, 
    -0.00642333f, 0.02765791f, -0.00740020f, 0.00121860f, -0.03875416f, -0.02587278f, -0.00675723f, -0.04130957f, 
    -0.00888412f, -0.00979669f, 0.01211327f, -0.01010886f, -0.00606739f, -0.00563728f, 0.01144492f, -0.01646114f, 
    -0.00390940f, -0.03122676f, -0.03672182f, 0.02839783f, -0.00997659f, 0.00753306f, 0.03365889f, 0.00446643f, 
    -0.01870394f, 0.03045904f, -0.03113737f, 0.02413043f, 0.01213792f, 0.02589536f, -0.02078129f, 0.00784457f, 
    -0.03184886f, 0.03392078f, 0.01663160f, -0.01216892f, 0.01099324f, 0.02257411f, 0.02764658f, -0.03275868f, 
    -0.00964675f, -0.01818934f, 0.01201414f, -0.01968718f, 0.02777521f, -0.02324589f, 0.03020531f, -0.01352855f, 
    0.00397163f, -0.02138788f, -0.02269757f, 0.01243246f, 0.01017720f, 0.00967826f, 0.01038708f, 0.01936273f, 
    0.00554057f, -0.01816507f, -0.00625100f, 0.03340357f, -0.01735106f, -0.00524097f, -0.02224469f, 0.01621310f, 
    -0.00800186f, 0.02675864f, -0.02426873f, -0.01307805f, 0.01392930f, 0.00992923f, -0.01039808f, -0.01204829f, 
    -0.02163455f, -0.01218148f, 0.00767060f, -0.02515083f, -0.00966874f, -0.01061200f, 0.01362471f, -0.02388430f, 
    -0.00279479f, -0.02168141f, -0.01540973f, 0.02834342f, 0.03067006f, 0.02256497f, 0.00411768f, -0.01376293f, 
    -0.02053307f, 0.03047658f, -0.00759631f, -0.01662093f, -0.03158838f, -0.03284552f, -0.03544832f, 0.01985479f, 
    0.00423576f, -0.00811164f, -0.02997553f, 0.01104113f, -0.01128153f, 0.01183094f, 0.02491209f, 0.00008636f, 
    0.01130493f, -0.02421801f, -0.03974577f, -0.00854020f, 0.02832527f, -0.01929548f, -0.01436972f, 0.00274442f, 
    0.02918256f, -0.00136058f, 0.01524034f, -0.02510446f, -0.03036951f, 0.02858471f, 0.01456830f, 0.01447586f, 
    0.01801050f, -0.00072886f, 0.01778757f, -0.01699171f, 0.01868075f, 0.02873666f, -0.02369813f, 0.02827376f, 
    -0.02321762f, -0.00568225f, 0.02262037f, 0.01134670f, 0.00862144f, -0.01126659f, 0.01254763f, -0.01407530f, 
    -0.01821157f, -0.00158825f, -0.01483094f, 0.02144380f, -0.04152770f, 0.00634843f, -0.00537999f, -0.00936648f, 
    0.01107882f, -0.00958619f, -0.03858626f, 0.00892991f, -0.00765555f, 0.03250925f, -0.03408527f, -0.03400543f, 
    0.02889755f, 0.00027963f, 0.02577682f, 0.02273986f, -0.00970112f, -0.02319597f, 0.02802837f, -0.02285595f, 
    0.00213768f, -0.02422873f, 0.00673917f, -0.01557538f, 0.00080257f, 0.02221043f, 0.02196246f, -0.03998315f, 
    -0.02890454f, 0.00080957f, -0.03285415f, -0.02218901f, -0.02201778f, 0.01245018f, -0.03564685f, 0.01663305f, 
    -0.02419258f, -0.01243956f, 0.02916327f, 0.02742184f, -0.01324312f, -0.01220114f, 0.00425851f, -0.01861615f, 
    0.01520022f, 0.00700352f, 0.01163758f, 0.02448573f, 0.00128755f, -0.01392075f, -0.03826855f, -0.02567373f, 
    -0.01728491f, -0.01192461f, 0.00073392f, 0.01428355f, -0.03509106f, 0.03445295f, -0.00347241f, -0.00881992f, 
    -0.01029313f, 0.00471967f, -0.01393481f, 0.02337050f, -0.01858456f, 0.00807558f, 0.02633771f, 0.00407869f, 
    0.02130455f, -0.02288494f, -0.02430380f, -0.03167071f, -0.04315285f, 0.02021447f, 0.01548932f, 0.02549976f, 
    -0.03010307f, 0.03290792f, -0.01776454f, -0.03658481f, -0.01212898f, 0.00552922f, 0.01685153f, -0.01100956f, 
    0.00178482f, -0.00035094f, 0.03128001f, -0.02946877f, 0.00328387f, -0.02189925f, -0.00790661f, -0.03657255f, 
    0.02095820f, -0.02541029f, 0.01455125f, -0.02537419f, 0.00401736f, -0.03024645f, 0.03379728f, 0.01904707f, 
    -0.01994107f, 0.03144338f, -0.03603247f, -0.01403939f, 0.00834759f, 0.02528287f, 0.00847199f, -0.01637996f, 
    -0.00889714f, 0.02405519f, -0.01503628f, -0.01947127f, -0.03856782f, 0.01203741f, -0.01226270f, 0.00792439f, 
    -0.03720283f, -0.00425925f, 0.01782665f, -0.03063546f, 0.02217392f, -0.01404060f, -0.01688400f, -0.00818584f, 
    0.00120712f, 0.00011902f, 0.01673784f, -0.02842296f, 0.02583536f, -0.02096977f, 0.00469665f, 0.01455443f, 
    0.01430192f, -0.02692045f, 0.00266588f, 0.00641583f, 0.01454836f, -0.02957716f, -0.03938599f, 0.02630237f, 
    0.02912488f, -0.02914147f, -0.03645380f, -0.04088670f, -0.02715290f, 0.00862584f, -0.01815569f, -0.04093960f, 
    -0.03789622f, -0.03081848f, 0.00717005f, -0.00277746f, -0.00947422f, -0.01169599f, 0.01103889f, 0.00708190f, 
    0.00275137f, -0.02224782f, 0.00453697f, 0.02714867f, 0.01246857f, 0.01182123f, 0.00820801f, -0.00179055f, 
    -0.02629550f, 0.01173648f, 0.03078096f, -0.03753964f, 0.02716056f, -0.00098289f, 0.02283588f, 0.00118134f, 
    -0.00178440f, 0.01201403f, 0.00480129f, 0.01283051f, -0.02356034f, 0.02558502f, -0.00201110f, 0.01230599f, 
    -0.02619245f, -0.00592554f, -0.01055662f, -0.00752523f, -0.01610642f, -0.00770595f, -0.03897741f, 0.02942720f, 
    -0.01671125f, 0.00846806f, 0.00233000f, 0.00877549f, 0.01430302f, 0.00839717f, -0.01832120f, 0.00605013f, 
    -0.01530208f, -0.03058268f, -0.02497968f, 0.00213468f, 0.01255062f, 0.02653765f, -0.01771517f, -0.03932440f, 
    -0.00528182f, 0.00648479f, -0.03430157f, 0.01589681f, -0.00294215f, 0.02529447f, -0.03046730f, -0.03527540f, 
    -0.00285261f, -0.00558758f, -0.00971161f, 0.02606400f, -0.01534026f, 0.03106387f, 0.00090580f, -0.02943796f, 
    -0.04281129f, -0.01696885f, -0.00907583f, -0.02653905f, 0.00998571f, 0.02117440f, -0.02305151f, 0.00672240f, 
    0.00932790f, -0.00248108f, 0.00200022f, -0.03177848f, 0.02076076f, -0.00379856f, -0.00459821f, -0.02467749f, 
    -0.01921245f, 0.03652346f, 0.03794183f, -0.02656522f, -0.00531395f, -0.02614276f, 0.00280722f, 0.02272253f, 
    -0.03494736f, -0.02113160f, 0.00377367f, -0.02442536f, 0.02041795f, -0.03291820f, 0.02343303f, -0.00508364f, 
    0.01131164f, -0.01528651f, -0.01692447f, -0.01620068f, 0.00637318f, -0.01096404f, -0.03291313f, 0.00949998f, 
    -0.00188429f, 0.00957888f, -0.01363308f, -0.03790623f, -0.00866604f, -0.02717233f, -0.02486898f, -0.01702289f, 
    -0.00275969f, -0.02265105f, -0.03774502f, -0.02210911f, -0.02336306f, -0.00170497f, 0.00925353f, -0.01778442f, 
    0.01190345f, -0.01659007f, -0.01012319f, -0.00007128f, -0.02131128f, 0.03166296f, -0.03679387f, 0.03156243f, 
    -0.02878909f, -0.02516609f, 0.01004773f, -0.03421874f, -0.01536320f, 0.00526858f, 0.02168811f, -0.01742292f, 
    -0.01800937f, 0.02043446f, -0.00961832f, 0.00868245f, 0.00557691f, -0.02332580f, -0.00304424f, -0.04268935f, 
    -0.03024097f, -0.02823466f, -0.00365801f, -0.00212866f, 0.02756995f, 0.02064999f, -0.03514419f, 0.03015961f, 
    -0.02987302f, -0.01459972f, 0.02424408f, -0.00018602f, 0.01303708f, 0.02318534f, -0.03623985f, 0.00221056f, 
    0.03035362f, 0.02027182f, -0.03685670f, -0.01758941f, 0.02106352f, -0.02541931f, -0.03979778f, 0.02024104f, 
    0.00925694f, -0.02327743f, -0.03400487f, -0.03910473f, -0.02902522f, 0.00894420f, -0.04183251f, 0.02509134f, 
    -0.03505899f, -0.03940317f, 0.00260901f, 0.03057730f, -0.01900794f, -0.01673849f, 0.02515921f, 0.01514405f, 
    0.02259409f, 0.00913311f, 0.02574120f, 0.00979578f, -0.02705027f, -0.02445923f, 0.01557439f, -0.02325892f, 
    -0.02419138f, 0.03513686f, -0.02182971f, 0.03040443f, 0.02421585f, 0.00113934f, -0.00034780f, -0.04294143f, 
    -0.02286156f, -0.01378799f, -0.02244152f, 0.02197835f, -0.02413869f, 0.00582299f, -0.00449413f, 0.02142543f, 
    -0.01671235f, -0.00824690f, 0.03607253f, -0.01819810f, -0.01144245f, 0.02704300f, 0.02287165f, 0.02934208f, 
    -0.03092902f, -0.03161431f, 0.02703574f, 0.02418469f, -0.00408900f, 0.02981604f, -0.03759656f, 0.00942445f, 
    0.02914486f, 0.01805001f, 0.01349317f, -0.03893455f, 0.00162900f, -0.01142939f, 0.03437198f, 0.02358536f, 
    0.02218357f, 0.02842401f, -0.00878162f, -0.00198129f, -0.00077614f, 0.02133131f, -0.02730992f, -0.02836543f, 
    0.02574955f, 0.00364002f, 0.02073516f, 0.01776762f, -0.02158249f, -0.01063752f, 0.01430927f, -0.01224760f, 
    -0.01369079f, 0.02578022f, 0.01157269f, 0.01807008f, 0.03292069f, -0.01267253f, 0.03333284f, 0.01176913f, 
    0.00195178f, -0.01778730f, -0.02317716f, 0.02538107f, -0.03148704f, 0.01828770f, -0.01952758f, 0.00240531f, 
    -0.02862611f, -0.01596490f, -0.02083894f, -0.00086364f, -0.00843149f, -0.00643427f, 0.00484636f, -0.03126903f, 
    -0.00677844f, 0.04291704f, -0.00456052f, 0.03154211f, 0.01364930f, -0.00230063f, -0.02401416f, -0.02232397f, 
    -0.00090659f, -0.00142033f, 0.01067024f, -0.03455862f, -0.03333271f, -0.01869131f, -0.00465557f, -0.02395594f, 
    -0.02448690f, 0.01761080f, -0.03124276f, -0.02904140f, 0.02152611f, 0.00470182f, 0.01530905f, 0.00807353f, 
    0.01232513f, -0.02748531f, 0.00184734f, 0.02379997f, -0.00158934f, -0.04081360f, 0.00714984f, -0.02449508f, 
    0.00175925f, 0.02490660f, -0.01297218f, 0.00573085f, -0.03359000f, -0.02326342f, -0.01785967f, -0.02278025f, 
    -0.01484017f, -0.03280900f, -0.01366943f, 0.00641324f, 0.02475708f, 0.01455635f, 0.01860345f, -0.02102296f, 
    0.01542557f, -0.02206028f, -0.04365279f, -0.02126717f, 0.03524085f, 0.02325241f, 0.01800127f, 0.00919497f, 
    0.00513602f, -0.02188291f, 0.01421764f, 0.02748812f, -0.03208547f, 0.01841142f, 0.01390356f, 0.03094208f, 
    0.01969781f, -0.01084262f, -0.03395256f, 0.01828102f, -0.02929886f, 0.01093675f, -0.01346357f, 0.00094026f, 
    0.01173912f, -0.00219013f, -0.02792856f, -0.01710340f, 0.01339186f, -0.02147830f, -0.03514182f, -0.02599114f, 
    0.02570677f, 0.01454146f, -0.02632367f, 0.02656809f, -0.00672146f, -0.00386325f, 0.00033259f, -0.03899460f, 
    0.02319734f, -0.03844797f, -0.00222225f, -0.01806873f, -0.01801563f, -0.01003538f, 0.02143705f, 0.03102796f, 
    0.01420609f, 0.00296813f, -0.01698542f, -0.03583091f, 0.01755642f, -0.01206442f, -0.00756431f, 0.01979463f, 
    0.00660576f, -0.02781978f, 0.00078088f, -0.02488286f, 0.02317807f, 0.02317022f, 0.01106004f, -0.03314001f, 
    0.00687037f, 0.02270434f, -0.01771928f, 0.01022644f, 0.02339171f, 0.01312188f, -0.01061204f, 0.02092416f, 
    0.02310336f, -0.01791450f, 0.01489246f, 0.01724624f, -0.00276174f, -0.03550112f, -0.01467805f, -0.03472774f, 
    0.00306574f, -0.01004461f, -0.01298697f, -0.00746029f, -0.02296042f, -0.00199957f, 0.00407218f, -0.03767556f, 
    -0.00651350f, -0.03308035f, 0.00778006f, -0.01050522f, 0.02571658f, -0.02148886f, 0.00944686f, 0.01916379f, 
    0.00536442f, 0.03540335f, -0.01009130f, -0.00311585f, -0.02274938f, 0.02476130f, 0.02991857f, -0.03781788f, 
    -0.00698488f, 0.00411484f, 0.03402102f, 0.01827151f, 0.00672167f, 0.00713951f, -0.01876006f, -0.02540667f, 
    -0.03283768f, -0.00809455f, 0.02273656f, 0.00485267f, -0.00032598f, -0.02984380f, 0.01238052f, 0.00533932f, 
    -0.01531343f, -0.03756323f, 0.03354223f, -0.00363045f, -0.01283367f, 0.00221940f, 0.00655521f, 0.01227226f, 
    0.02119688f, -0.03717744f, -0.00006448f, -0.00529556f, -0.00133016f, 0.03216277f, -0.02590000f, -0.03066366f, 
    0.02459875f, -0.02166336f, 0.01326618f, -0.00912980f, 0.02536686f, 0.00560179f, -0.02837649f, 0.01635795f, 
    -0.03209474f, -0.00613703f, -0.03245763f, 0.02293340f, -0.00373237f, 0.00207244f, 0.02314641f, -0.01623823f, 
    -0.03706949f, 0.02276879f, 0.02060170f, -0.03457642f, 0.00082717f, 0.02507107f, -0.02649129f, 0.02219061f, 
    0.02516436f, -0.01137363f, -0.01880048f, 0.02348463f, 0.02788669f, 0.03798221f, -0.01524803f, -0.02919553f, 
    -0.02178454f, -0.03544600f, -0.00349976f, 0.01388182f, -0.03445562f, -0.01349081f, -0.03115904f, -0.02605019f, 
    -0.03842296f, 0.02907005f, -0.01874047f, 0.01816942f, -0.03132488f, -0.00721696f, 0.01683445f, -0.03901903f, 
    0.01650962f, -0.03430936f, 0.01091308f, -0.00399431f, -0.03831214f, -0.01515690f, -0.01886812f, -0.01313223f, 
    -0.01954344f, -0.03800716f, 0.00580342f, -0.03565736f, -0.02991922f, 0.01719592f, -0.02553600f, -0.03862050f, 
    -0.02553520f, 0.03203315f, 0.01946927f, 0.00009923f, 0.01678601f, 0.00695020f, 0.02606718f, -0.01844505f, 
    0.02263584f, 0.01698196f, 0.00051833f, 0.00348577f, 0.01641942f, 0.01740059f, -0.03946235f, -0.01366802f, 
    0.00452725f, 0.00235019f, 0.02429754f, 0.00670340f, 0.02423127f, -0.00808167f, 0.02474100f, 0.02085567f, 
    -0.01695425f, 0.00173369f, -0.00610124f, -0.00462235f, 0.02920944f, -0.01252741f, 0.00762895f, -0.03958883f, 
    0.00179303f, -0.01973501f, -0.00502429f, 0.01876630f, -0.03382233f, 0.02918163f, 0.01571184f, -0.02466599f, 
    0.00456054f, -0.01068247f, -0.01891245f, 0.02453169f, -0.00702821f, 0.02172231f, -0.01737834f, 0.01596007f, 
    -0.01128911f, -0.00595013f, 0.01206035f, 0.00069392f, 0.00801382f, -0.01751512f, -0.00841376f, -0.00256840f, 
    -0.01113953f, 0.00717018f, -0.02305414f, 0.02014437f, -0.01722527f, 0.02847977f, -0.00264965f, 0.01192475f, 
    -0.02647134f, 0.02129509f, -0.00114184f, -0.01903239f, 0.00191057f, 0.00422639f, 0.02507798f, 0.02014055f, 
    0.00320582f, 0.01427374f, 0.02733935f, -0.00320586f, 0.00235468f, -0.00666535f, -0.01044003f, 0.02378990f, 
    0.01206382f, 0.00097550f, -0.03678311f, -0.00491533f, 0.03278269f, -0.02908516f, 0.01347866f, 0.03160836f, 
    0.01321605f, -0.02248017f, 0.02670040f, -0.02433080f, 0.01710910f, 0.00546423f, 0.01145666f, -0.02387156f, 
    -0.01180768f, -0.01943438f, -0.02684561f, 0.01028822f, 0.01049324f, -0.03652909f, 0.01322116f, 0.01391701f, 
    0.01140187f, -0.00965772f, 0.01512152f, -0.01811997f, -0.02423190f, 0.02989852f, 0.01766348f, 0.02316228f, 
    0.00994045f, -0.00355050f, -0.02499021f, -0.00812631f, 0.02732332f, -0.02844895f, 0.01174200f, 0.01485434f, 
    -0.00156962f, -0.01351020f, -0.01198267f, -0.02520812f, 0.01311319f, -0.02766570f, -0.01998376f, -0.00170751f, 
    -0.01191901f, 0.00273507f, -0.02921767f, 0.03005051f, -0.01706781f, -0.02414541f, -0.01934163f, -0.03288666f, 
    0.02942327f, -0.02873088f, -0.00658350f, -0.00636217f, -0.02658336f, 0.02206680f, -0.02665701f, 0.02227573f, 
    0.02129356f, -0.00124140f, -0.02536754f, 0.03118934f, 0.02695647f, -0.01982506f, 0.00485565f, -0.00445978f, 
    0.02527508f, -0.01112834f, 0.02025266f, -0.01924140f, 0.01043993f, -0.00127399f, -0.01897008f, 0.02265080f, 
    0.02746154f, 0.00387245f, -0.02260679f, -0.01591756f, 0.00290046f, -0.02597620f, -0.02542551f, 0.02193149f, 
    -0.02374568f, 0.01605153f, 0.01609153f, 0.01963514f, -0.03618881f, -0.00403763f, 0.01559103f, -0.02656863f, 
    0.02136485f, 0.01070207f, -0.01375803f, -0.02891678f, 0.01736192f, 0.01087040f, -0.02919840f, 0.02077420f, 
    0.02024008f, -0.01433153f, -0.00623789f, -0.02295720f, -0.02385638f, -0.03133348f, -0.00902333f, -0.02158938f, 
    -0.00551535f, 0.01601049f, -0.02267974f, 0.02901727f, -0.01333630f, -0.01168913f, 0.02795877f, -0.03057866f, 
    0.02530237f, 0.01451295f, 0.01241646f, 0.00055900f, -0.00824350f, 0.02662526f, -0.01151846f, 0.00391296f, 
    -0.03528006f, 0.00618590f, -0.01834225f, 0.02535580f, -0.01704160f, 0.01787390f, 0.01894398f, 0.01273404f, 
    0.01597362f, -0.01601258f, -0.03253870f, 0.02349722f, -0.00190876f, -0.00078584f, 0.00131301f, -0.03339609f, 
    -0.03811825f, 0.01574184f, 0.00991305f, 0.02378830f, -0.01677453f, -0.03813310f, 0.01640419f, -0.00702251f, 
    0.02844965f, 0.02595802f, 0.01944717f, 0.02512024f, -0.02188062f, -0.01535938f, 0.02925254f, -0.03915093f, 
    0.00354011f, -0.03823149f, -0.00831296f, -0.00069383f, -0.01391883f, 0.00769615f, -0.01089181f, -0.02099041f, 
    -0.03825412f, 0.00648020f, 0.02203906f, 0.00950375f, -0.03103643f, -0.01467724f, 0.02169824f, -0.03174937f, 
    0.01212236f, -0.01136678f, -0.00988237f, -0.01644766f, 0.02415200f, 0.00127976f, -0.04071143f, 0.00376423f, 
    -0.00292601f, -0.02013534f, 0.02012023f, -0.03614023f, 0.01542366f, -0.03955066f, 0.01532619f, -0.03722345f, 
    -0.03594791f, -0.01062998f, 0.01932797f, -0.02690609f, -0.01006305f, -0.02641278f, 0.01266056f, 0.01030014f, 
    -0.01060921f, 0.00299606f, 0.00755310f, -0.01290401f, -0.02224960f, 0.00533312f, -0.02592929f, 0.02781413f, 
    -0.00356060f, -0.01647428f, -0.02540947f, 0.00619129f, -0.01160700f, -0.01136562f, -0.03818876f, -0.01747784f, 
    -0.00800914f, 0.02646767f, -0.03451937f, 0.01170432f, -0.02342128f, -0.01114185f, -0.01752715f, -0.01430116f, 
    -0.03929396f, -0.01860190f, 0.00083094f, 0.02771739f, 0.01994450f, -0.02538895f, -0.02066582f, -0.01936374f, 
    -0.01516721f, 0.01119706f, 0.01311535f, 0.02658816f, -0.01612540f, -0.00441438f, 0.00911482f, -0.02842644f, 
    -0.01806004f, 0.02397752f, -0.03783317f, -0.03445663f, 0.03269166f, -0.03033253f, 0.02831963f, -0.02147207f, 
    -0.00779671f, 0.01603151f, 0.00875912f, -0.01261725f, -0.02428971f, 0.01710320f, -0.02389673f, 0.02378751f, 
    0.01115065f, 0.00990768f, 0.01087024f, 0.01949201f, 0.02398959f, 0.00873242f, -0.01033774f, -0.00330461f, 
    -0.00357455f, 0.01386002f, 0.02136354f, 0.00340909f, -0.01499260f, -0.01478375f, 0.00109979f, -0.01136438f, 
    0.02036770f, -0.03619725f, 0.02529839f, -0.00959028f, -0.01597706f, 0.01942053f, -0.00308402f, -0.03621460f, 
    0.03891159f, 0.02358120f, -0.03130019f, -0.01103009f, -0.00341666f, 0.01588222f, -0.00982113f, 0.03935698f, 
    -0.01355943f, 0.00695347f, 0.02396833f, 0.02910985f, 0.01089682f, -0.00508883f, -0.00667933f, -0.02960944f, 
    0.00135506f, -0.01532017f, 0.01267408f, -0.00003090f, -0.00074010f, -0.01424376f, 0.01678071f, 0.00516525f, 
    -0.01599215f, -0.04250541f, -0.01263030f, 0.00446708f, 0.02998422f, -0.00908990f, -0.01544419f, -0.00922144f, 
    0.00925228f, 0.00579327f, -0.00292231f, -0.01377618f, 0.03160602f, 0.01926687f, 0.00447562f, -0.00121662f, 
    -0.03466051f, -0.02040051f, 0.02835319f, 0.00154304f, -0.01790505f, 0.00284006f, -0.02638666f, 0.00107915f, 
    -0.01470216f, 0.01933562f, -0.03399377f, 0.03169472f, -0.00259441f, -0.02578543f, 0.02668016f, -0.03050355f, 
    -0.01136641f, -0.03352252f, 0.02139990f, 0.00592143f, -0.04129166f, -0.01286518f, -0.01727076f, 0.01232561f, 
    0.02217446f, -0.00633688f, -0.00648320f, -0.02352089f, -0.01669782f, 0.00228546f, -0.00562513f, 0.00298298f, 
    -0.03224446f, 0.02286812f, -0.01947865f, -0.02487052f, -0.03921748f, 0.00382772f, 0.02446921f, -0.02863475f, 
    -0.02580269f, 0.00529100f, 0.00269976f, -0.03972747f, -0.01259570f, -0.01830094f, 0.00833370f, -0.01500010f, 
    0.01612841f, -0.00692261f, 0.04322120f, -0.02872156f, -0.03446947f, -0.03317286f, -0.03715487f, 0.01980423f, 
    -0.02180874f, -0.04111115f, 0.01554934f, -0.02670037f, 0.00310827f, -0.02971002f, 0.01878042f, -0.02402563f, 
    0.00212449f, -0.00916816f, 0.00486999f, -0.02049025f, 0.01718021f, 0.01958232f, 0.03015584f, 0.02848435f, 
    0.02673793f, 0.01025440f, 0.00550632f, 0.00545305f, -0.02656102f, -0.03798823f, -0.03361462f, 0.01962653f, 
    0.01283708f, -0.01344063f, 0.01789757f, -0.01717964f, 0.02371008f, -0.00884526f, -0.01092431f, 0.02221025f, 
    -0.02063258f, 0.02640432f, 0.01030371f, -0.03939874f, 0.01819391f, 0.00412323f, -0.00941269f, 0.02375401f, 
    -0.04047035f, -0.02169857f, -0.03443718f, 0.00932586f, -0.01384898f, -0.03260871f, 0.02302119f, 0.00729857f, 
    0.00574579f, 0.00020025f, 0.00352224f, 0.00038752f, -0.02176053f, -0.00136243f, 0.01067698f, 0.00322393f, 
    -0.00800588f, -0.02481418f, -0.01765987f, -0.03307669f, -0.01968523f, -0.01070318f, -0.00107519f, -0.01838515f, 
    0.00288916f, 0.01405401f, -0.00532785f, -0.03200497f, -0.00555336f, 0.01554320f, 0.01523410f, 0.00856909f, 
    0.00129513f, -0.01308020f, -0.00027367f, -0.00690610f, -0.01685131f, -0.00646599f, -0.01161386f, -0.03998110f, 
    -0.02748101f, -0.01858553f, 0.00501525f, 0.01569820f, -0.03509488f, -0.00817869f, -0.03357370f, -0.00221877f, 
    0.00367580f, 0.00066714f, 0.00370407f, 0.01746723f, -0.03161706f, 0.02023975f, -0.01425244f, -0.00202781f, 
    0.02378917f, -0.02599531f, -0.01292006f, 0.00404464f, 0.03087709f, 0.00078029f, -0.02241080f, 0.02245682f, 
    0.00221853f, -0.00692206f, 0.02087245f, -0.00983191f, -0.02461030f, -0.02708695f, -0.03827483f, -0.02739646f, 
    0.00198862f, -0.00615009f, 0.00971078f, -0.01761439f, 0.02655764f, -0.01638628f, -0.00975392f, -0.00990950f, 
    -0.03727889f, -0.00381955f, 0.00045152f, 0.01698337f, 0.03065702f, -0.01820041f, 0.01309865f, -0.00027934f, 
    0.01239108f, -0.00212973f, 0.00575957f, 0.02115000f, -0.00962441f, -0.04226996f, 0.01037283f, -0.01750310f, 
    -0.02004923f, 0.03143299f, 0.00684069f, 0.01732325f, -0.00747898f, 0.03117257f, -0.03260956f, -0.03487745f, 
    0.00980637f, 0.03131898f, -0.03436709f, 0.02348339f, 0.01212311f, 0.00459859f, -0.02196505f, -0.03556363f, 
    0.01297152f, -0.02935237f, -0.00171775f, -0.00056368f, -0.01909311f, -0.03930787f, -0.02925855f, -0.00643070f, 
    0.01118142f, -0.01442943f, 0.01415671f, 0.03489755f, 0.02563325f, -0.01117884f, -0.01487341f, -0.02341574f, 
    0.02314539f, 0.00134399f, -0.02077023f, -0.03964356f, 0.00276862f, -0.03481866f, 0.02786265f, -0.01671212f, 
    -0.01224604f, -0.03097358f, -0.01452216f, -0.02611230f, 0.03189718f, -0.01948335f, -0.03236247f, 0.02017393f, 
    -0.01510022f, -0.02836831f, 0.02304341f, 0.01510497f, -0.00775449f, 0.02696590f, -0.00565250f, 0.01107524f, 
    -0.01876938f, 0.00301445f, 0.03049444f, 0.02260537f, -0.00197432f, -0.00080102f, -0.00766029f, 0.02225151f, 
    0.00080073f, 0.00761210f, -0.03708307f, -0.02677634f, 0.01392737f, -0.03188631f, -0.03359457f, -0.00136291f, 
    0.00297919f, -0.00491574f, -0.01864968f, -0.00211286f, 0.02932320f, -0.01031394f, -0.03986963f, 0.00958457f, 
    -0.01602517f, -0.03187106f, -0.01222681f, 0.02687393f, -0.02576711f, 0.01423864f, 0.01339860f, -0.00621882f, 
    -0.01858825f, -0.03544067f, 0.01711860f, 0.00691666f, 0.02220366f, -0.02880650f, -0.02199709f, -0.01126796f, 
    -0.00887080f, 0.00809202f, -0.00416317f, 0.00807285f, -0.00554651f, -0.00976369f, 0.02642220f, 0.02819510f, 
    0.01987680f, 0.01246945f, -0.00880356f, 0.00568291f, -0.00880702f, -0.02536958f, 0.03250945f, 0.01963853f, 
    -0.02628297f, 0.02327260f, 0.02213428f, 0.02208429f, 0.00936723f, 0.02002308f, -0.01221989f, 0.03516454f, 
    0.01241085f, -0.03581327f, -0.00238610f, -0.03086909f, 0.02489244f, 0.02511103f, 0.00827998f, 0.01316309f, 
    0.00653507f, 0.03409323f, -0.01855003f, 0.02822552f, -0.02455606f, -0.02767935f, 0.01310238f, -0.02371583f, 
    0.01101744f, -0.02901060f, -0.02625029f, -0.01844881f, -0.01915295f, -0.04251826f, 0.02315596f, -0.02144181f, 
    0.01129529f, -0.03341592f, 0.00488176f, -0.00589277f, 0.02880811f, -0.01991682f, -0.01114354f, -0.01548189f, 
    0.01588838f, 0.23693272f, 0.13013057f, -0.06538642f, -0.05356088f, 0.01443951f, -0.05457607f, 0.06548902f, 
    0.04629081f, 0.18244463f, 0.00038120f, -0.11934155f, -0.14966047f, -0.07754650f, 0.00937894f, 0.04805257f, 
    -0.05212596f, 0.04407314f, 0.12545525f, -0.00371200f, 0.02338649f, 0.05651766f, -0.11898816f, 0.20537052f, 
    0.02251836f, 0.02064930f, -0.16893099f, -0.03985937f, 0.11187223f, -0.04763513f, -0.00401197f, 0.25419316f, 
    0.01170041f, 0.08193319f, -0.16147785f, 0.01959795f, -0.04193956f, -0.17399800f, -0.02951914f, -0.15132697f, 
    -0.10791721f, -0.07929712f, 0.01714364f, -0.04921673f, -0.05352513f, 0.05454641f, 0.01465135f, 0.04699336f, 
    0.10902150f, -0.03588023f, -0.01528235f, 0.08049852f, 0.06739422f, 0.10810808f, 0.08169402f, 0.05944444f, 
    0.09091552f, -0.03492303f, -0.06134813f, -0.06062477f, 0.26779574f, 0.04228339f, 0.10819240f, -0.11975463f, 
    -0.02510520f, 0.03101149f, -0.02190603f, 0.00303686f, -0.07561108f, 0.09151819f, 0.08543076f, 0.03106881f, 
    -0.03991322f, 0.05218200f, 0.04558860f, 0.06491624f, 0.09827876f, -0.11298583f, -0.10875185f, 0.04900817f, 
    -0.07613906f, 0.04853781f, 0.04694890f, 0.08285567f, 0.00313677f, -0.02468337f, -0.09683777f, 0.20752570f, 
    -0.02410821f, 0.02599567f, 0.00520093f, -0.01311877f, 0.08241194f, -0.00071601f, 0.06991681f, 0.08623085f, 
    -0.06873787f, 0.28521562f, -0.16576391f, 0.19566363f, -0.06285845f, 0.10369752f, 0.02172108f, -0.03851067f, 
    -0.06222885f, 0.08093483f, 0.08915605f, 0.27947059f, -0.24856927f, -0.24474874f, 0.23932578f, -0.04408779f, 
    -0.02616175f, 0.09545163f, 0.07877325f, 0.08698598f, -0.00028235f, 0.00846064f, 0.00151515f, -0.09951396f, 
    0.08567247f, -0.20405008f, -0.08307949f, -0.09859781f, -0.04079362f, 0.06407592f, 0.01983012f, 0.14235784f, 
    -0.08276475f, 0.00483146f, 0.07856409f, 0.03105815f, 0.05457441f, -0.01172710f, -0.13144659f, 0.21096307f, 
    -0.08935212f, 0.02865020f, 0.01510486f, -0.05925816f, 0.02469895f, -0.03783574f, -0.13474047f, 0.15787412f, 
    -0.16679151f, 0.11313057f, 0.09621486f, -0.27799988f, 0.04292209f, 0.06383786f, 0.01975207f, 0.05273747f, 
    0.07263194f, -0.03198856f, 0.02451619f, 0.02701705f, 0.17199409f, 0.23558052f, 0.02574080f, -0.06868044f, 
    0.03725103f, 0.06843982f, 0.02069137f, -0.02758463f, 0.13925555f, 0.01063188f, -0.05309046f, -0.03860607f, 
    -0.17336293f, -0.10689416f, -0.11333988f, -0.18614475f, 0.00090829f, -0.14613210f, 0.05330962f, 0.03751938f, 
    0.08436798f, -0.00017092f, -0.03229755f, 0.16858986f, -0.00223768f, -0.15059046f, -0.09922694f, 0.08933979f, 
    -0.05832645f, -0.07522870f, -0.11219940f, -0.04987801f, 0.01711513f, 0.18399432f, 0.15422587f, 0.18726252f, 
    0.29893896f, 0.03226300f, 0.14240140f, -0.08152748f, 0.00805580f, 0.06254368f, -0.07484714f, 0.06496885f, 
    0.13466384f, 0.07457176f, -0.06625788f, 0.16708806f, -0.02641498f, 0.03318324f, 0.05254563f, 0.16471988f, 
    -0.15119253f, 0.03960152f, 0.06765027f, -0.10169657f, 0.11056125f, 0.21974689f, 0.03884445f, 0.03496377f, 
    -0.10658777f, 0.01101084f, -0.02590111f, -0.11421339f, 0.03887286f, -0.00108101f, -0.03782954f, 0.05472139f, 
    0.13172300f, -0.00155185f, 0.03571388f, 0.08058184f, -0.31862906f, 0.31017938f, 0.04264269f, 0.07239438f, 
    0.09168196f, 0.02940809f, -0.00573413f, -0.05134723f, 0.05085291f, 0.10591452f, 0.02247681f, -0.15399203f, 
    -0.12785205f, -0.01593105f, 0.09282362f, -0.02101446f, 0.18610749f, 0.15702322f, -0.00574859f, -0.08472598f, 
    0.06692322f, -0.04069277f, 0.15185460f, 0.11492202f, -0.20816101f, 0.06535406f, 0.05475688f, -0.03083128f, 
    -0.03318288f, -0.00843125f, -0.02340351f, -0.05000931f, 0.01984642f, -0.01017223f, 0.08516347f, -0.05857439f, 
    -0.18714283f, -0.05800434f, 0.07600434f, -0.44461703f, -0.03430878f, 0.10960613f, -0.06049236f, 0.02490500f, 
    -0.01164022f, -0.00495420f, 0.12555212f, -0.02465854f, 0.09085635f, 0.07609107f, -0.00987836f, 0.32185611f, 
    0.07607274f, 0.00663987f, 0.14499038f, -0.11756231f, 0.01449003f, 0.07311857f, 0.06987090f, 0.08900533f, 
    0.09860692f, 0.01501454f, -0.28442714f, 0.17596428f, 0.06353734f, 0.07215027f, 0.07210432f, 0.14530781f, 
    0.01171968f, -0.14831737f, -0.03233875f, 0.09941522f, 0.26277068f, 0.12817648f, 0.01391217f, 0.27288643f, 
    -0.07294726f, 0.01346881f, 0.07155599f, -0.08340019f, 0.06248293f, 0.06217653f, -0.03297938f, 0.02977231f, 
    0.05564684f, -0.04160949f, -0.10313246f, -0.28699592f, 0.05419092f, -0.00674769f, -0.03614771f, 0.16816489f, 
    0.00346850f, 0.12784296f, -0.03812493f, 0.17896608f, 0.21111132f, -0.03864477f, -0.07578722f, -0.11053634f, 
    0.02918066f, -0.06387593f, 0.10027442f, 0.10205851f, 0.04455112f, 0.11599461f, 0.05256088f, 0.03085794f, 
    -0.18924661f, -0.24752757f, -0.00979778f, -0.11633621f, 0.00081934f, -0.06589565f, 0.11340134f, 0.10794795f, 
    -0.08678548f, 0.00970273f, -0.00901632f, 0.00409527f, -0.37246951f, 0.23211128f, -0.00995804f, -0.15210235f, 
    0.08592470f, 0.10659589f, 0.08823083f, 0.06476960f, 0.04789611f, -0.09014985f, -0.02020108f, 0.09355801f, 
    -0.10492565f, -0.01842950f, 0.05311952f, -0.13409615f, 0.09153923f, 0.04636067f, 0.17117767f, 0.18966803f, 
    0.10651045f, 0.01970006f, -0.01136420f, 0.10469044f, 0.09099072f, -0.02509292f, 0.05749156f, -0.08515084f, 
    0.05414916f, -0.00305542f, -0.05444343f, 0.10445965f, 0.06694242f, 0.09108554f, 0.09753675f, 0.08083854f, 
    -0.04966627f, -0.33358908f, 0.21139018f, -0.21978994f, 0.05234698f, 0.03714936f, 0.26060310f, 0.11575381f, 
    -0.04145238f, -0.07903433f, -0.02327564f, 0.07716742f, -0.06856701f, -0.10583418f, -0.13552772f, 0.16203453f, 
    -0.02222653f, -0.01690374f, -0.08267924f, 0.16157500f, -0.03382390f, -0.05379660f, 0.10965344f, -0.01189279f, 
    -0.03349449f, 0.10610632f, 0.01074166f, 0.05371545f, -0.03416639f, -0.00065322f, 0.00575991f, -0.10182329f, 
    -0.07400824f, 0.17054211f, 0.11019218f, 0.01729202f, 0.01522897f, 0.05317302f, -0.21550204f, -0.01067742f, 
    0.03352045f, 0.04334586f, -0.03169111f, 0.17741936f, -0.05029770f, -0.08172448f, -0.00330404f, 0.10623022f, 
    0.12616898f, 0.14791295f, -0.04304426f, 0.06633734f, 0.00934973f, 0.00789720f, -0.02927064f, -0.05732697f, 
    0.06963006f, 0.03628172f, 0.01720735f, -0.03396045f, 0.32109332f, 0.02821068f, -0.17504543f, 0.02273187f, 
    0.07679629f, 0.09876758f, 0.04882038f, 0.20759654f, -0.01653761f, 0.05599612f, -0.01746707f, 0.07238795f, 
    0.16458516f, -0.24493657f, -0.20998600f, -0.11493007f, -0.10647798f, -0.04471258f, -0.09574932f, 0.13527709f, 
    -0.01126217f, -0.11000285f, 0.00101459f, 0.00536648f, -0.16545218f, 0.11121076f, -0.00874081f, -0.21392682f, 
    -0.04069418f, -0.14553678f, -0.05040253f, -0.03362471f, -0.02656618f, -0.06092136f, 0.03089069f, 0.27268842f, 
    -0.02963649f, -0.01009793f, 0.10109305f, 0.15862374f, 0.16150568f, -0.03218062f, 0.15060009f, 0.08657274f, 
    0.11257404f, 0.00848170f, -0.00168088f, 0.07248032f, 0.60340154f, 0.02949486f, 0.04438117f, -0.12585923f, 
    -0.01417812f, 0.15637101f, 0.03852055f, 0.15471096f, 0.12428299f, 0.18075898f, 0.03735502f, 0.10667173f, 
    -0.23230503f, 0.24300376f, 0.23670366f, 0.11513116f, -0.17083067f, -0.06542807f, 0.02070285f, -0.02025172f, 
    -0.02298175f, 0.07578319f, -0.05983109f, -0.12437899f, 0.15417574f, -0.00236714f, -0.08122834f, -0.06202641f, 
    -0.04780352f, 0.15937687f, -0.07791892f, 0.04168931f, 0.04466569f, -0.05545781f, -0.03081930f, -0.06736351f, 
    -0.20307338f, -0.21253780f, 0.11463843f, 0.19574673f, 0.09540527f, -0.10538256f, 0.08116644f, -0.02587087f, 
    0.20334168f, 0.12277246f, 0.20045282f, 0.03094726f, -0.07624899f, 0.10427115f, -0.01931318f, 0.13550560f, 
    0.05754449f, -0.04767628f, 0.15005544f, 0.01026541f, -0.03868499f, 0.13208677f, 0.01481743f, 0.05522203f, 
    0.03092704f, 0.13951007f, -0.00532487f, 0.15913709f, 0.12496584f, 0.20780635f, 0.10997212f, -0.04429662f, 
    0.11532737f, 0.04854198f, -0.01145225f, 0.04394368f, -0.01836380f, -0.15526856f, -0.06248483f, -0.03322879f, 
    0.06132123f, 0.00417809f, 0.11599136f, 0.12547497f, -0.03589324f, 0.10213313f, 0.06438431f, 0.03887969f, 
    0.09611174f, 0.04410443f, 0.12858762f, -0.13452581f, -0.11589095f, 0.09510174f, 0.11648856f, 0.04825329f, 
    0.05781172f, 0.08054174f, -0.07620894f, -0.08864347f, 0.04031960f, 0.15293726f, 0.11172090f, -0.14769562f, 
    -0.13773610f, -0.12298045f, -0.07279562f, 0.11209369f, 0.12648310f, -0.06799629f, 0.00344212f, 0.01460553f, 
    0.27858874f, -0.07677473f, 0.11400429f, 0.17846523f, -0.08062869f, 0.02527339f, 0.05759772f, 0.02461995f, 
    0.00270929f, 0.03241368f, 0.03886776f, 0.13207068f, 0.11582787f, 0.21060361f, 0.04437272f, -0.11075661f, 
    -0.04598790f, -0.05032098f, 0.01952140f, 0.09061759f, 0.10774156f, 0.06909519f, -0.09828578f, 0.00488622f, 
    -0.07134224f, -0.04880005f, 0.09755094f, -0.00216206f, 0.04369995f, 0.13762237f, 0.10430165f, 0.08974845f, 
    0.06091821f, -0.03147264f, -0.05994418f, 0.07935567f, 0.20555946f, -0.12069517f, 0.02559383f, 0.00373265f, 
    0.06814839f, -0.01172396f, -0.07639860f, 0.20201856f, 0.03367634f, 0.16848505f, 0.13213630f, 0.00630000f, 
    0.23211801f, -0.02093690f, 0.12598799f, -0.18952303f, 0.11160269f, 0.09793848f, 0.06073800f, 0.07386696f, 
    0.02445002f, -0.02504121f, 0.19855228f, 0.08112878f, -0.04905747f, -0.16578989f, -0.00116369f, 0.15149051f, 
    -0.03995655f, 0.21691991f, -0.03628310f, -0.11001162f, -0.03623101f, 0.24437015f, 0.01773839f, 0.16336924f, 
    0.28296730f, 0.01969285f, 0.35488841f, 0.14510879f, -0.00731513f, 0.09538166f, 0.00173490f, -0.01434582f, 
    0.08797476f, 0.04981717f, 0.19995721f, 0.00752730f, -0.26237911f, 0.20818512f, -0.00487620f, 0.14134397f, 
    0.08613157f, 0.04892439f, 0.01648581f, -0.14528814f, -0.09699178f, 0.12113138f, 0.09159707f, 0.03654424f, 
    -0.04436928f, 0.14599748f, 0.02991475f, 0.27299607f, -0.00471302f, -0.04092899f, 0.08398918f, -0.00821046f, 
    0.10934082f, 0.11254980f, 0.11414467f, 0.09941327f, 0.11056857f, -0.05232935f, 0.10280623f, -0.21556358f, 
    -0.21930827f, -0.14277104f, -0.12656149f, 0.05405438f, 0.03696787f, 0.27239972f, 0.23567700f, -0.14512615f, 
    -0.30521658f, 0.09928803f, 0.19303751f, 0.06402607f, 0.04748362f, 0.09405192f, -0.08878679f, 0.08117480f, 
    0.14128231f, 0.02444550f, 0.03275431f, -0.09843524f, -0.18038999f, 0.32583833f, 0.03822362f, 0.07676660f, 
    -0.10515159f, -0.05392978f, -0.03010635f, -0.04911526f, 0.00451093f, 0.13936378f, 0.02273716f, -0.01801664f, 
    0.05258789f, -0.17424829f, 0.08094898f, -0.10436537f, -0.11592645f, 0.01962382f, 0.13164942f, 0.16403280f, 
    0.05281408f, -0.11196592f, 0.17664656f, 0.06391663f, 0.25472471f, 0.03401335f, -0.01023844f, -0.02487752f, 
    -0.05071131f, 0.02187980f, 0.03922866f, 0.01283801f, -0.03818751f, 0.13032468f, 0.15150730f, 0.18750255f, 
    0.13373744f, 0.09073093f, 0.02886016f, -0.14599504f, -0.12563501f, -0.11879318f, 0.00598782f, 0.00367210f, 
    -0.06768578f, -0.08253109f, 0.01463389f, 0.19250330f, 0.02184759f, -0.00665304f, 0.14675632f, 0.32084864f, 
    0.07759768f, 0.06055199f, 0.07719845f, 0.03290641f, -0.08320642f, 0.05463103f, 0.04951954f, -0.01370522f, 
    -0.20226543f, -0.01157660f, -0.13693717f, -0.05006763f, 0.02896982f, 0.16796270f, 0.20056592f, -0.05523139f, 
    0.15884763f, 0.06075243f, -0.03297500f, 0.04616740f, 0.11866528f, -0.08235192f, -0.14354505f, 0.03795686f, 
    -0.05456860f, 0.09148122f, 0.06725314f, 0.04816305f, 0.05321086f, 0.03526786f, 0.00487646f, 0.06568871f, 
    -0.06377053f, 0.10651290f, 0.03694090f, -0.22297087f, -0.09268359f, 0.03124512f, 0.09462636f, 0.05913645f, 
    0.15664528f, 0.07229411f, 0.03684612f, 0.03329100f, -0.16211176f, -0.05686731f, 0.13575472f, 0.02912517f, 
    -0.04208921f, -0.07411581f, -0.00824418f, 0.16261353f, -0.00323923f, 0.08797047f, 0.07410903f, -0.02307314f, 
    -0.23488571f, 0.04454413f, -0.04914429f, -0.18637033f, -0.02202820f, -0.03012400f, 0.01781813f, 0.04699813f, 
    0.06717809f, -0.02004445f, 0.02301873f, -0.06320614f, -0.07871190f, 0.28744578f, 0.17274399f, -0.16056249f, 
    -0.03941129f, 0.12281332f, 0.08381913f, 0.09878748f, 0.02302838f, -0.05739462f, -0.01826897f, 0.02954799f, 
    0.11019114f, 0.13596821f, 0.35477257f, 0.02204506f, 0.06037192f, 0.20544003f, 0.04855733f, 0.00228458f, 
    -0.10806231f, 0.06866060f, 0.06300983f, -0.01084895f, -0.03273585f, -0.07147013f, -0.01615791f, 0.14747357f, 
    0.18761271f, 0.06108891f, 0.02612333f, -0.05490008f, 0.06442004f, 0.02170502f, 0.00057666f, -0.17328025f, 
    -0.07945631f, -0.07767124f, -0.17335327f, 0.03927952f, 0.19286723f, -0.12404830f, -0.00113519f, -0.07891953f, 
    0.07977024f, -0.05480777f, 0.08887489f, -0.00587344f, -0.18381175f, 0.05960785f, 0.03429685f, -0.07800733f, 
    0.16865805f, 0.00840124f, -0.00312641f, 0.09534449f, -0.00297243f, 0.05260237f, 0.11573788f, 0.01511186f, 
    -0.27519447f, -0.04908813f, 0.09468786f, 0.20830426f, 0.08572147f, 0.10012806f, 0.10999664f, -0.05270264f, 
    0.03974482f, -0.05070597f, 0.07744347f, 0.09710587f, -0.05303242f, 0.13079099f, 0.14526753f, -0.18229404f, 
    -0.09875198f, -0.10445815f, -0.00906140f, 0.06472781f, 0.11681300f, 0.01533468f, 0.02041559f, -0.00809656f, 
    0.28569099f, -0.02205604f, -0.15720749f, 0.20517616f, 0.17060646f, 0.14052501f, 0.02348830f, -0.13215379f, 
    0.06054063f, 0.01676605f, 0.05377352f, 0.09173772f, 0.11994120f, 0.24223939f, -0.10612175f, 0.12317099f, 
    0.21839367f, 0.08882920f, 0.08657145f, 0.03960568f, -0.06017247f, -0.03707613f, 0.18513501f, -0.05650811f, 
    -0.26792365f, -0.03662562f, -0.01218305f, 0.06393321f, 0.11285342f, 0.11656287f, 0.15394180f, 0.01364369f, 
    0.22144908f, 0.08834048f, 0.09910668f, 0.18294451f, -0.42510340f, 0.15907538f, 0.04691499f, -0.15472583f, 
    0.03573390f, -0.09614384f, 0.06000163f, 0.06568862f, 0.00581833f, -0.01143895f, -0.04295386f, -0.03812321f, 
    0.23881413f, -0.09724069f, -0.15429123f, -0.05433213f, 0.06899288f, 0.14105937f, -0.06173452f, 0.06701370f, 
    -0.01115053f, -0.08983681f, -0.08942389f, 0.23811427f, 0.10065446f, -0.05718813f, 0.21244583f, 0.14797644f, 
    -0.09716882f, -0.02523508f, -0.01722641f, 0.01660669f, 0.00189225f, 0.07576180f, -0.00557518f, -0.08922793f, 
    -0.09207126f, -0.23814696f, 0.14095233f, 0.01632195f, 0.00692430f, 0.01891370f, -0.06593838f, 0.04945258f, 
    0.06991143f, 0.01660109f, 0.09175196f, -0.11349947f, -0.18131588f, 0.06293502f, 0.07391133f, 0.12549844f, 
    -0.08610103f, 0.12320086f, -0.02927760f, 0.03979036f, -0.08400702f, 0.01316755f, 0.03254325f, 0.00061580f, 
    -0.06363495f, -0.03518352f, 0.11491241f, 0.26114437f, -0.01064813f, 0.19994265f, -0.00194872f, 0.06837600f, 
    0.07964652f, 0.04570214f, 0.13344738f, 0.07821113f, 0.31079549f, 0.15089858f, 0.06195582f, -0.07788277f, 
    0.02299372f, -0.00837584f, -0.06262954f, -0.02286797f, -0.06230655f, -0.02867245f, 0.02521440f, 0.08193884f, 
    -0.00680058f, 0.37479037f, 0.09992180f, -0.04670973f, 0.00158467f, 0.05059829f, -0.03213204f, -0.07481181f, 
    0.02490715f, -0.04734550f, 0.10613021f, -0.03686930f, 0.36292750f, 0.04864560f, -0.12158300f, -0.18508975f, 
    0.04115960f, 0.10176142f, 0.01894784f, 0.05938888f, 0.13904731f, -0.02321655f, 0.02673447f, 0.06997633f, 
    0.06693607f, 0.05318858f, -0.32701039f, 0.07016908f, 0.06108247f, 0.12071858f, 0.02662401f, 0.02029641f, 
    0.08233434f, -0.00691137f, -0.01313163f, -0.01998203f, 0.01251958f, 0.10183027f, -0.13615336f, -0.00997945f, 
    0.12109384f, 0.13185586f, 0.00745514f, -0.08365342f, -0.00040142f, 0.12686034f, -0.03549860f, 0.11162093f, 
    0.33976781f, 0.12902936f, -0.25063530f, -0.00182485f, 0.12062629f, 0.10514367f, -0.05923769f, -0.05385217f, 
    -0.08963504f, 0.12626791f, -0.00344948f, -0.04050205f, -0.23290899f, -0.16195352f, 0.24773198f, 0.35452482f, 
    -0.02441593f, -0.00835551f, -0.07695076f, -0.04505824f, -0.14907353f, -0.08220286f, 0.07593180f, 0.02632483f, 
    0.42845801f, 0.10916257f, 0.15028216f, 0.19087084f, -0.06855322f, 0.06859606f, 0.08736280f, -0.08036704f, 
    -0.05603135f, -0.02893632f, 0.06604994f, 0.12670334f, 0.12674613f, 0.10526894f, -0.11225536f, 0.00533824f, 
    -0.02319507f, -0.05192379f, 0.13473891f, 0.06370644f, -0.00308407f, 0.07950284f, -0.06391455f, 0.05522055f, 
    0.12255044f, -0.17705785f, 0.01203401f, 0.05297327f, 0.08514419f, 0.02326388f, 0.10265334f, -0.07176404f, 
    0.06013777f, 0.01973758f, -0.01185998f, -0.11228237f, 0.01333602f, 0.25034210f, 0.05313886f, 0.05487868f, 
    -0.00224587f, -0.00216636f, 0.15625300f, 0.02949169f, 0.10656908f, 0.02591278f, 0.00346458f, 0.02998089f, 
    0.13767698f, 0.14395376f, 0.05781701f, 0.03175185f, -0.13460515f, -0.03157625f, 0.00120823f, 0.06450429f, 
    0.10078900f, 0.06668583f, 0.11290917f, -0.10180847f, -0.12171721f, 0.12639581f, -0.01411586f, 0.16973402f, 
    0.02789698f, 0.11087782f, 0.03521563f, -0.03304527f, 0.01278673f, -0.05018888f, 0.00018647f, -0.03856774f, 
    -0.23478945f, -0.26803303f, 0.06992493f, -0.03498350f, -0.00401971f, 0.05536358f, -0.04310752f, 0.21070646f, 
    -0.23203269f, -0.06459019f, -0.01234373f, 0.15631306f, -0.12760234f, 0.01826293f, -0.09370748f, -0.12270792f, 
    0.05446204f, 0.10317048f, 0.17300417f, -0.13894258f, -0.03625908f, 0.06687922f, 0.04503801f, 0.05812503f, 
    -0.37520102f, 0.10813028f, -0.24552859f, 0.00525489f, 0.19863281f, 0.24757642f, 0.10545017f, -0.00773527f, 
    0.02498300f, -0.05143642f, -0.00431779f, -0.04519337f, 0.11775986f, 0.12221231f, 0.08655260f, 0.14430656f, 
    -0.11549810f, -0.05491336f, -0.09453695f, -0.01981312f, -0.12393363f, 0.14408296f, -0.02526910f, -0.06882478f, 
    0.04683422f, 0.00954144f, 0.17614093f, 0.03484138f, -0.06884183f, 0.00823097f, 0.03679981f, 0.05921406f, 
    0.01404345f, 0.03099787f, -0.07508916f, -0.02023704f, -0.03158422f, -0.33101618f, 0.13919538f, 0.04936503f, 
    -0.02079221f, 0.05893621f, 0.14666347f, 0.06726765f, -0.01582234f, -0.01542787f, -0.04225191f, 0.09714475f, 
    0.03829170f, 0.15519087f, 0.18472476f, -0.17140466f, -0.00703385f, -0.03278282f, -0.04396202f, 0.01149767f, 
    -0.01679722f, 0.07981070f, -0.07749312f, 0.15225387f, 0.02970615f, -0.11392025f, -0.11985745f, 0.02077505f, 
    0.00761114f, -0.03896721f, 0.13858543f, 0.07242698f, 0.12260870f, 0.03599855f, 0.11193055f, -0.05832786f, 
    -0.24086393f, -0.16497092f, 0.05363680f, 0.06432604f, 0.01479473f, -0.00026703f, 0.02440084f, 0.04480354f, 
    0.10551849f, 0.02444408f, 0.16079305f, -0.01052872f, 0.16538432f, 0.16100137f, 0.07519459f, 0.10521293f, 
    -0.15282349f, 0.13031140f, 0.00184399f, 0.01729691f, 0.09858570f, 0.03433282f, 0.08624236f, -0.09254912f, 
    0.15660398f, -0.02251907f, 0.16005535f, 0.08919853f, 0.10564129f, -0.06850079f, -0.03240272f, 0.01587718f, 
    -0.03571001f, 0.02480045f, 0.00303641f, -0.02356327f, -0.22825637f, -0.01701099f, 0.05364426f, 0.06866678f, 
    0.13742670f, 0.04480546f, 0.13360208f, 0.03403813f, 0.03165101f, -0.03181525f, -0.11658944f, 0.07021657f, 
    -0.22850832f, -0.15873365f, 0.12200452f, 0.22136486f, -0.04761892f, 0.10778886f, 0.04654782f, -0.01533564f, 
    0.07316870f, 0.00433862f, 0.07619438f, 0.03650643f, 0.16481456f, 0.21873447f, 0.23719431f, -0.14659303f, 
    -0.17567396f, -0.06210292f, 0.01263693f, 0.04386032f, 0.08888216f, -0.09985152f, 0.02955227f, 0.06505374f, 
    0.07470095f, 0.00008646f, 0.00457119f, -0.23726562f, -0.08213568f, -0.00047768f, 0.06235933f, 0.09704232f, 
    -0.02697242f, 0.00119306f, -0.08352034f, 0.02898838f, 0.18468021f, 0.23003979f, 0.21292666f, -0.14082390f, 
    -0.11328720f, -0.11321127f, -0.02012501f, 0.02451120f, 0.02038252f, 0.06266747f, 0.03223829f, 0.07778154f, 
    -0.24735619f, 0.05699585f, 0.08720797f, 0.13195021f, -0.10546719f, 0.13462462f, 0.02625127f, 0.10944075f, 
    0.01837984f, 0.12135836f, 0.02240879f, -0.02898566f, -0.27198753f, 0.07568647f, -0.10055853f, -0.09153780f, 
    0.02631709f, 0.00147848f, 0.15723455f, -0.03754514f, -0.02600666f, 0.11163539f, -0.00287535f, 0.03459221f, 
    0.18813789f, -0.19267899f, 0.03463248f, -0.13610326f, -0.01470811f, -0.06352310f, 0.07103186f, -0.01132337f, 
    -0.08521057f, 0.02274916f, 0.11987615f, 0.06614079f, -0.37103176f, 0.23968002f, 0.20893797f, -0.12240785f, 
    0.04201803f, -0.17823814f, -0.05092718f, 0.01721859f, -0.01631589f, 0.05321379f, -0.10096359f, -0.11194103f, 
    0.01765884f, 0.02276099f, 0.16622104f, 0.05926472f, -0.08476250f, -0.00630894f, -0.01450083f, 0.04682368f, 
    -0.00530646f, -0.01600264f, 0.13477828f, 0.13403878f, 0.17976777f, 0.09774051f, 0.14525269f, 0.29739717f, 
    -0.09399227f, -0.04021798f, -0.02188045f, 0.02997940f, -0.03349180f, -0.02256452f, 0.02971895f, -0.12386636f, 
    -0.00713487f, 0.00078323f, 0.08026216f, -0.20628895f, -0.01638937f, 0.08923963f, 0.04276812f, 0.00008946f, 
    -0.01203744f, -0.04883759f, -0.08234983f, 0.00196480f, 0.14168085f, 0.24043192f, 0.21930851f, 0.23583280f, 
    -0.01991272f, -0.09131309f, 0.17967121f, 0.09240577f, -0.01018595f, -0.05370817f, 0.18625219f, -0.11421107f, 
    0.04250008f, -0.02459197f, 0.08209039f, 0.21041530f, 0.04022283f, 0.08695830f, -0.04696186f, 0.04552606f, 
    0.09073792f, 0.09245867f, -0.01572916f, 0.03823003f, -0.04487437f, -0.13612115f, -0.00381387f, -0.11809598f, 
    0.00315322f, 0.06934604f, 0.03280981f, -0.05250471f, 0.06849171f, 0.06517700f, -0.01241689f, 0.11441232f, 
    -0.05742067f, 0.03155110f, 0.11756638f, -0.09151303f, 0.21711206f, 0.07873641f, 0.01640441f, -0.04391026f, 
    0.12230085f, -0.03264081f, 0.02490061f, 0.03092500f, -0.17218980f, -0.22257353f, -0.07995855f, 0.03696597f, 
    0.09417234f, -0.10692307f, -0.09672672f, -0.00086354f, 0.13827716f, 0.01699063f, -0.08970699f, 0.10183413f, 
    0.01149529f, 0.00101977f, -0.02270526f, 0.02154061f, 0.00424579f, 0.01631676f, -0.03444466f, 0.02614544f, 
    0.02859963f, 0.00699291f, 0.00196029f, 0.01930216f, 0.02411631f, 0.02935087f, -0.00327893f, -0.02669650f, 
    0.00567980f, -0.00668252f, -0.03302024f, -0.00827860f, -0.02343361f, 0.02473453f, -0.03317765f, 0.00821674f, 
    -0.01200442f, 0.01619246f, -0.03526087f, 0.02812552f, -0.02847876f, -0.02858577f, -0.02202107f, 0.00833141f, 
    0.02580890f, -0.00482040f, 0.02648238f, -0.00308384f, -0.03007685f, -0.02391855f, -0.02326540f, -0.02764888f, 
    0.01697899f, -0.00911568f, -0.01962471f, -0.01252957f, -0.03770996f, 0.02030754f, -0.03920124f, 0.00165442f, 
    0.02729031f, 0.01255590f, 0.03079063f, -0.01855408f, -0.02733487f, -0.02869420f, -0.02991610f, 0.01222947f, 
    -0.02400953f, -0.03584489f, 0.02323526f, -0.00274173f, 0.02989393f, 0.03082453f, -0.00587662f, 0.02420331f, 
    -0.01692031f, 0.03280345f, -0.01720332f, -0.01276101f, -0.03771597f, -0.03538447f, -0.00764865f, -0.01466542f, 
    0.02056088f, -0.01794944f, -0.03398734f, -0.02197237f, 0.02298748f, 0.00075484f, -0.01916709f, 0.02863555f, 
    -0.02207263f, -0.03261907f, 0.00962663f, 0.01046106f, 0.00958488f, 0.02468470f, 0.01203072f, -0.01882114f, 
    0.00834599f, 0.02208248f, 0.01975990f, 0.02739899f, -0.00241064f, 0.01254723f, -0.03293695f, -0.00736552f, 
    -0.01557593f, -0.03723921f, 0.00440264f, 0.00976294f, -0.00831441f, 0.00647834f, 0.01921597f, -0.00181921f, 
    0.03106070f, 0.01028131f, -0.03972760f, -0.02222361f, 0.02515841f, -0.03923805f, -0.00720427f, -0.00912823f, 
    0.00575306f, -0.03759655f, -0.01990730f, -0.01135356f, 0.02366504f, -0.02391597f, -0.00757651f, 0.01134214f, 
    -0.00210147f, 0.01408639f, -0.02998333f, 0.01378263f, -0.02516990f, -0.00163148f, 0.00333454f, 0.01240180f, 
    0.02461304f, -0.02406898f, 0.00872376f, -0.02979686f, -0.01261557f, 0.03310204f, 0.03209981f, -0.01433687f, 
    -0.02291327f, -0.03374732f, 0.02580469f, 0.00571198f, -0.00564695f, -0.00253090f, 0.02121879f, -0.02277713f, 
    -0.01071241f, 0.02041273f, 0.01345836f, 0.01286885f, -0.00857250f, 0.02937134f, -0.02049824f, -0.00099936f, 
    0.01542713f, -0.03241151f, 0.00935829f, -0.02518744f, 0.00077352f, -0.00395355f, 0.02213506f, -0.03144975f, 
    -0.01670620f, 0.02023789f, 0.01284638f, -0.03437672f, 0.00108658f, 0.00293993f, 0.01857538f, 0.01399136f, 
    -0.00860199f, -0.02032308f, -0.01376050f, -0.01278039f, 0.00677854f, -0.01503340f, 0.01770034f, -0.02714974f, 
    -0.01791638f, 0.01173906f, -0.03243446f, 0.00429317f, -0.02295817f, 0.01914302f, 0.02387062f, 0.02627526f, 
    -0.00475232f, -0.02859115f, -0.00370708f, 0.01638024f, 0.01710666f, -0.00814210f, -0.01286278f, 0.00573539f, 
    0.02434355f, 0.02114387f, -0.02206401f, -0.03718835f, 0.01261560f, -0.02756540f, 0.00760112f, -0.00434812f, 
    0.00214289f, -0.03431077f, 0.03496386f, 0.00699442f, -0.00788854f, -0.01507359f, 0.02118495f, -0.02808478f, 
    0.02690993f, -0.02347269f, 0.01942366f, 0.02304130f, -0.03052772f, -0.00024086f, 0.02648345f, 0.02983402f, 
    -0.00242229f, -0.04065727f, -0.00418622f, -0.02072197f, 0.00428925f, -0.02317222f, 0.00870486f, 0.02348450f, 
    -0.01146484f, 0.00893887f, 0.01506877f, 0.02468037f, 0.00116257f, -0.01147609f, -0.00698278f, -0.01722790f, 
    0.01973538f, -0.03861054f, -0.01457723f, 0.01209438f, 0.00195682f, 0.01393621f, -0.01486530f, 0.03028415f, 
    -0.02577052f, -0.01271182f, 0.00029452f, 0.00175954f, -0.03941391f, 0.01206903f, -0.01979751f, 0.02412325f, 
    -0.02980102f, -0.03239296f, -0.02819937f, -0.02959322f, 0.01029504f, 0.02144702f, -0.02297756f, 0.03101325f, 
    0.03892270f, 0.02144425f, -0.02033610f, -0.00432644f, -0.00431163f, 0.02283680f, -0.01069055f, 0.00428363f, 
    -0.02117463f, 0.02058164f, 0.02236446f, -0.02327958f, 0.02216556f, -0.03725635f, 0.02526622f, -0.04164848f, 
    -0.01317202f, -0.02184475f, -0.00514580f, -0.00256202f, -0.01666893f, 0.01272598f, -0.02854258f, 0.02393159f, 
    -0.02737545f, -0.02490452f, 0.02370118f, -0.00886114f, 0.00099090f, 0.02687387f, -0.03911598f, -0.02236130f, 
    -0.00013990f, -0.03368378f, 0.01509800f, 0.02772439f, -0.02704441f, -0.03592665f, -0.03139892f, -0.03875007f, 
    -0.01294347f, 0.01221396f, 0.01805792f, 0.01751473f, -0.02478606f, -0.00264877f, -0.03778132f, -0.03500078f, 
    -0.01130212f, -0.01569513f, 0.02383045f, 0.03209182f, 0.01101247f, -0.01387654f, -0.00571147f, -0.01664506f, 
    -0.00314090f, -0.02341521f, 0.01202742f, -0.01689874f, -0.00773758f, -0.00550781f, -0.01470670f, -0.03179005f, 
    -0.01768648f, -0.04184316f, -0.00614862f, -0.03834138f, -0.01970920f, 0.00859319f, 0.02767412f, -0.03026874f, 
    0.02595398f, -0.02501999f, -0.01605999f, 0.02606566f, 0.00339263f, -0.00186637f, -0.01208505f, -0.00564639f, 
    0.01655863f, -0.03375065f, 0.02415865f, -0.02111976f, -0.03943061f, 0.02004572f, -0.01764715f, -0.03564730f, 
    0.00707879f, -0.03931064f, 0.02284199f, 0.02329187f, 0.01214845f, 0.01398669f, 0.01791256f, 0.02665357f, 
    0.01187596f, -0.02413480f, -0.02834393f, -0.01814006f, 0.02854916f, 0.00490123f, -0.00820899f, 0.00710827f, 
    0.01872575f, -0.02031840f, -0.02927041f, 0.02447985f, -0.03600603f, -0.02898446f, 0.00031099f, 0.02495428f, 
    0.01277506f, -0.02375498f, 0.01509381f, 0.03045473f, 0.01585730f, 0.02892926f, 0.00400549f, 0.03421624f, 
    0.01890156f, -0.04075655f, -0.03741295f, 0.02319752f, 0.03077299f, -0.02676209f, 0.01051473f, -0.01209541f, 
    0.00954798f, -0.02405491f, 0.00870872f, 0.02083015f, -0.02181425f, -0.03284831f, 0.02806690f, -0.01821728f, 
    -0.00832930f, -0.03541763f, -0.02375054f, -0.03734408f, 0.03062629f, -0.03675068f, -0.02868380f, -0.01264303f, 
    -0.00644049f, -0.03156026f, 0.00803674f, -0.01970222f, 0.02233022f, -0.03446866f, -0.01874826f, -0.01254430f, 
    -0.00872772f, -0.01267612f, -0.00930219f, -0.00475551f, -0.01169678f, -0.03315121f, 0.02892137f, -0.03360419f, 
    -0.02331672f, -0.04086051f, 0.01394477f, 0.01722699f, -0.00773082f, 0.02763253f, -0.00461430f, 0.01524943f, 
    -0.01618103f, -0.01352177f, -0.02997724f, 0.02193685f, 0.00273256f, -0.01912067f, -0.02867766f, -0.00552254f, 
    -0.01972510f, 0.02155358f, -0.01596134f, 0.01177905f, 0.01235718f, -0.01002508f, -0.01054066f, 0.00137934f, 
    -0.03038627f, -0.02909679f, 0.00408910f, 0.00155928f, -0.01979183f, -0.03103882f, -0.03252719f, 0.00442115f, 
    0.02372498f, 0.02277119f, -0.02683065f, 0.00798976f, 0.01863733f, -0.01727291f, -0.03533784f, -0.01805225f, 
    0.01592369f, -0.02924280f, -0.02978086f, -0.02261893f, -0.03869106f, 0.02890550f, 0.00559003f, -0.03279100f, 
    -0.03786654f, -0.03861244f, -0.01251725f, 0.00938921f, -0.02357417f, -0.02790776f, 0.04312069f, 0.00771772f, 
    -0.01666584f, 0.01482621f, 0.02282556f, 0.01981085f, -0.00584955f, -0.03465421f, -0.03667283f, -0.01760540f, 
    -0.03958217f, 0.03084218f, -0.02307845f, 0.02778587f, 0.03002473f, 0.02303328f, -0.02217317f, -0.01183084f, 
    -0.00634658f, 0.01394730f, -0.03551629f, -0.02686893f, -0.03160464f, 0.00289698f, 0.03048683f, 0.01595592f, 
    0.01883668f, 0.01691194f, -0.01840588f, 0.01689020f, 0.01025877f, 0.00113779f, -0.03776395f, -0.00095678f, 
    -0.01405419f, -0.03373652f, -0.01866323f, 0.01523936f, -0.01507335f, -0.01681483f, -0.01572051f, 0.01688070f, 
    -0.00407656f, -0.02933230f, 0.02317770f, 0.02400240f, -0.01293877f, -0.02018908f, 0.02677324f, 0.02752768f, 
    0.03020076f, 0.01531238f, 0.01192417f, 0.00058840f, -0.02007927f, -0.00882423f, 0.02897951f, 0.01884145f, 
    0.00972101f, -0.02723975f, 0.01272086f, -0.03353833f, 0.01432256f, -0.01398623f, 0.01394527f, -0.03266731f, 
    0.02135199f, 0.01546308f, -0.02087362f, 0.02428762f, 0.01849972f, 0.00044255f, 0.02359584f, -0.02415960f, 
    -0.00447770f, 0.00884387f, -0.04239190f, -0.00061084f, -0.01900829f, 0.01952481f, -0.02914287f, 0.01462818f, 
    0.02094842f, 0.00773192f, -0.00621032f, -0.03293289f, 0.02753365f, -0.00458650f, -0.03374257f, 0.01211180f, 
    0.01508578f, -0.00614696f, -0.00627228f, 0.00546399f, -0.03316219f, 0.01843252f, 0.03176814f, -0.02176505f, 
    -0.02543392f, 0.00982583f, 0.02440423f, -0.01083445f, 0.02266098f, -0.00496428f, -0.01078105f, 0.02125867f, 
    0.02121736f, 0.00484955f, -0.02471996f, 0.02181667f, 0.00078909f, 0.01812887f, -0.01613384f, 0.00510430f, 
    -0.02857532f, -0.03660652f, -0.01620576f, 0.00928858f, -0.02132201f, 0.01649220f, 0.00812378f, 0.01919075f, 
    -0.03774318f, -0.04038952f, 0.01987895f, 0.02665491f, -0.03461355f, -0.03296524f, 0.00718709f, 0.03193389f, 
    0.00412902f, -0.01873352f, 0.03230101f, 0.02936905f, 0.01337143f, 0.00301886f, -0.01507908f, 0.01867164f, 
    0.03061236f, -0.01490792f, 0.01235706f, 0.02081203f, -0.00945489f, 0.00195887f, -0.01722793f, 0.03031444f, 
    -0.03860135f, 0.00827643f, -0.01030889f, 0.02814842f, 0.01471031f, 0.01473145f, -0.00789067f, -0.03026823f, 
    -0.02611915f, -0.03762439f, -0.01923502f, 0.00756353f, 0.01437060f, 0.00277320f, 0.01243722f, 0.01161647f, 
    0.01587188f, -0.00236257f, -0.03253444f, 0.02183560f, 0.00905980f, -0.03994451f, -0.02624776f, -0.01129542f, 
    -0.01388816f, -0.01691421f, 0.01114955f, -0.02569832f, 0.01503078f, -0.01348228f, 0.01416401f, -0.01112767f, 
    -0.00597431f, 0.01047920f, -0.00738424f, -0.03607893f, 0.01897370f, -0.02290467f, 0.00699897f, 0.01722329f, 
    -0.03193293f, 0.00229718f, 0.02646274f, 0.01800748f, -0.03849702f, 0.02543777f, 0.02208035f, 0.02149168f, 
    0.00994167f, 0.02632897f, 0.01516585f, 0.02870618f, -0.01347961f, -0.01618582f, -0.00636550f, -0.03698266f, 
    -0.00107554f, -0.03227494f, 0.03078091f, -0.03147826f, -0.03388835f, 0.02076523f, 0.02494653f, -0.00508709f, 
    -0.01686361f, 0.01599602f, -0.01752096f, -0.02779473f, -0.02674703f, 0.02429881f, -0.01025781f, -0.00694356f, 
    0.02720613f, -0.03783110f, -0.00501493f, 0.00577553f, -0.03385243f, 0.01652220f, 0.00463054f, -0.03693271f, 
    -0.02749433f, -0.00876464f, -0.02429750f, -0.03466409f, 0.00194033f, 0.00642593f, 0.01894815f, -0.02741296f, 
    0.01553921f, -0.02723053f, -0.03658082f, -0.03646486f, 0.03790443f, -0.00436604f, -0.03819212f, 0.03229638f, 
    -0.00861425f, 0.02710902f, -0.02657089f, -0.02715977f, 0.01707542f, -0.01408075f, 0.00080566f, -0.01363951f, 
    0.03837243f, -0.03537852f, -0.01738521f, 0.03968035f, -0.01513786f, 0.02242899f, 0.02806437f, 0.02948154f, 
    0.01639699f, 0.00282740f, -0.03992077f, -0.01759013f, 0.02794484f, -0.00810900f, 0.00518069f, -0.01545151f, 
    -0.04004800f, -0.01760261f, -0.00168084f, -0.03770236f, 0.03465511f, 0.00471852f, -0.01745026f, 0.01408381f, 
    0.03127079f, 0.00630774f, 0.02238161f, -0.02196975f, -0.01237684f, -0.03185403f, 0.00504650f, -0.02347174f, 
    -0.00528441f, -0.00115594f, -0.02424410f, -0.02212964f, 0.01177558f, 0.02114066f, 0.00474578f, 0.03295435f, 
    -0.01224729f, 0.00572363f, -0.03643713f, 0.01599488f, 0.00205239f, -0.00741071f, -0.01687178f, -0.03717242f, 
    -0.12405300f, -0.26014784f, 0.38955411f, 0.38502678f, 0.07922450f, 0.05570268f, 0.08932088f, 0.05504905f, 
    0.10864081f, -0.04117574f, 0.09257254f, 0.09902470f, 0.28353459f, -0.06647583f, 0.02339181f, 0.14219531f, 
    -0.04466803f, -0.00041474f, -0.00411653f, 0.02664448f, 0.10146726f, -0.03810087f, 0.23841618f, -0.02775462f, 
    -0.08986845f, 0.12344530f, 0.04464370f, 0.03694607f, 0.12121195f, 0.00265526f, -0.04360585f, -0.16527794f, 
    -0.08488715f, -0.06284110f, 0.12810296f, -0.05329260f, 0.15304984f, 0.01979345f, -0.09265583f, -0.00357635f, 
    0.19375972f, 0.05926517f, 0.02226396f, 0.05987734f, -0.01398352f, -0.08518270f, 0.04455819f, -0.05087822f, 
    -0.28996155f, 0.21132657f, -0.07393678f, -0.24672237f, 0.07368969f, -0.05477072f, -0.05725291f, 0.09752592f, 
    -0.00057081f, 0.13865198f, 0.07131658f, 0.02245702f, -0.00006147f, 0.20547879f, -0.22376095f, 0.01730870f, 
    0.19160403f, 0.11009445f, 0.17261867f, 0.04524976f, 0.00607714f, 0.03981884f, -0.08183341f, 0.10423958f, 
    0.46317065f, -0.25139335f, 0.18048403f, 0.05977735f, -0.07946909f, -0.03015149f, 0.00038793f, 0.00941891f, 
    0.14418566f, -0.05507399f, 0.08887191f, 0.15021926f, 0.44395944f, -0.20349951f, 0.06397084f, 0.25079036f, 
    -0.09176576f, -0.07241093f, 0.07692636f, 0.03174604f, -0.00350378f, -0.00831479f, 0.04638219f, 0.05494977f, 
    -0.02778370f, -0.21314880f, 0.05589056f, -0.09600685f, 0.12715940f, 0.04680966f, 0.09279472f, 0.06388559f, 
    0.16048606f, 0.06404379f, -0.09887596f, -0.03835535f, 0.33701003f, -0.08587856f, -0.25839666f, 0.10762332f, 
    -0.04455806f, 0.00199200f, -0.01556364f, 0.00956752f, 0.08570529f, -0.05686817f, 0.02762690f, 0.10879830f, 
    0.04893757f, 0.13705534f, 0.03664120f, 0.19756819f, 0.16375372f, -0.00535558f, 0.02341772f, -0.08730087f, 
    -0.13116974f, 0.22338176f, -0.00139641f, 0.00653251f, 0.08512663f, 0.07970381f, -0.01071755f, 0.11909832f, 
    -0.10579325f, -0.16595332f, 0.03782934f, 0.02594588f, 0.03190882f, 0.03754893f, -0.00969751f, 0.01602186f, 
    0.02829980f, 0.07782815f, 0.14775807f, 0.07086191f, -0.02314621f, 0.10228791f, -0.02151064f, -0.03967456f, 
    0.00933359f, 0.10406547f, 0.06249487f, 0.04226670f, -0.01280423f, -0.05274205f, 0.12549196f, 0.21080415f, 
    -0.02437909f, 0.01211905f, 0.06724954f, -0.06084406f, 0.00787098f, 0.00995605f, 0.06787864f, 0.01589411f, 
    0.02020742f, -0.15212312f, 0.01748927f, -0.04927774f, -0.05363251f, 0.01246160f, 0.06012974f, 0.18996403f, 
    -0.00693179f, 0.06223960f, 0.10447543f, -0.13148713f, -0.02729386f, 0.01219247f, -0.00181763f, -0.23583910f, 
    -0.03241716f, -0.02432368f, 0.12747031f, -0.09840009f, -0.07432948f, -0.03730050f, -0.20550784f, 0.00548654f, 
    -0.26699674f, -0.13407232f, -0.25989509f, -0.07551291f, -0.10218093f, -0.07856777f, 0.09483244f, 0.04255958f, 
    -0.15709169f, -0.05228279f, 0.00570095f, -0.08911123f, -0.04562018f, 0.01696928f, -0.05344506f, 0.00899276f, 
    0.07789289f, 0.13296300f, -0.03628839f, 0.06625578f, -0.04761335f, -0.10323030f, 0.09701989f, 0.08054428f, 
    -0.16842844f, -0.07822560f, -0.12508123f, -0.04777297f, -0.06269575f, 0.07055654f, 0.08078319f, -0.06736583f, 
    0.03353912f, 0.02839142f, 0.02074667f, -0.06177068f, -0.41837260f, 0.30015871f, 0.00294845f, 0.07512757f, 
    -0.05873666f, 0.04167659f, 0.07839908f, 0.07887062f, 0.20105478f, -0.00611881f, 0.02871765f, 0.18982908f, 
    -0.32943398f, 0.60737395f, -0.05252193f, 0.07074369f, 0.03149516f, -0.01794729f, 0.12912187f, 0.02617849f, 
    0.02647033f, 0.10088106f, -0.13021410f, 0.04407038f, 0.17425624f, -0.15818474f, -0.15764081f, -0.13456041f, 
    0.00591403f, -0.06079558f, 0.08420105f, -0.06751283f, 0.08178835f, 0.03535973f, -0.11833122f, -0.04134940f, 
    0.34394839f, 0.09514455f, 0.13726619f, 0.04112625f, -0.04078646f, -0.06561569f, 0.13363205f, 0.07091674f, 
    0.00888401f, 0.08470886f, -0.04957572f, 0.04928897f, -0.08231547f, -0.05701222f, 0.02738938f, -0.00091021f, 
    -0.00604919f, 0.14692995f, -0.16535127f, 0.15547328f, -0.00507480f, -0.16890500f, 0.01219580f, 0.03482608f, 
    -0.01692877f, -0.10038475f, -0.02631817f, -0.05560521f, 0.00017171f, -0.00118671f, -0.02132844f, 0.12327858f, 
    0.17481551f, 0.07523958f, 0.11368030f, 0.12669145f, -0.34201306f, -0.14028336f, 0.27503958f, 0.22907065f, 
    -0.01046400f, -0.03053264f, -0.03126765f, 0.05801324f, 0.06070612f, 0.02606796f, -0.10693912f, 0.05631468f, 
    -0.07816502f, -0.26718915f, -0.11785323f, -0.10700767f, 0.04218925f, 0.01115544f, 0.12298296f, 0.01576567f, 
    -0.01490569f, -0.07334981f, 0.04629726f, -0.01706261f, -0.22085139f, -0.17873326f, -0.02117521f, -0.13268428f, 
    -0.09681155f, -0.03505035f, 0.04994014f, -0.08377676f, -0.05282125f, -0.16455616f, 0.05999540f, 0.06116669f, 
    0.16069427f, 0.14589271f, 0.00150244f, 0.08944847f, -0.03230308f, 0.10408835f, 0.03852629f, 0.07298372f, 
    0.13555990f, -0.01172055f, 0.02453723f, 0.03675434f, 0.12446243f, 0.15696855f, 0.05628219f, 0.01554535f, 
    -0.13183217f, 0.00253484f, 0.04512303f, 0.11959378f, 0.08931327f, 0.18187214f, 0.04512598f, -0.07485366f, 
    -0.07343540f, -0.27267030f, 0.14479502f, 0.02288374f, 0.10136777f, 0.03194576f, -0.12102479f, -0.16976945f, 
    -0.01034320f, -0.01014245f, 0.01117685f, 0.10011725f, -0.14318204f, 0.03234503f, 0.18409577f, 0.10780596f, 
    -0.04351353f, -0.04980529f, 0.04403014f, 0.04774285f, 0.09162022f, 0.03289135f, -0.00274653f, -0.02684244f, 
    0.03395002f, -0.16056606f, -0.08616596f, -0.11546748f, 0.08326157f, -0.00061749f, -0.06568434f, -0.04903477f, 
    -0.04123454f, -0.11666962f, 0.11141364f, 0.05323298f, 0.23282152f, 0.12435855f, -0.09745717f, -0.12760758f, 
    0.12633781f, 0.07679249f, 0.01610009f, 0.03133217f, 0.00213352f, -0.11498894f, -0.02794237f, 0.01567165f, 
    0.04088359f, 0.01541683f, 0.13500571f, 0.19465902f, -0.04749675f, -0.09226228f, 0.15744866f, 0.03778815f, 
    0.08731798f, -0.02715323f, -0.12189604f, 0.01676959f, 0.03837909f, 0.08421923f, 0.11281165f, -0.15108359f, 
    0.07658014f, -0.03777730f, -0.02069241f, 0.02260736f, 0.09051443f, 0.02434204f, 0.03450735f, 0.17386211f, 
    -0.10897900f, -0.10470054f, 0.07206365f, 0.01277047f, 0.07238533f, 0.00860681f, 0.13224292f, 0.01538155f, 
    0.05923875f, 0.00439991f, -0.05611643f, -0.01523735f, -0.13151473f, 0.15305594f, -0.09986543f, -0.05820045f, 
    0.04276713f, -0.10001715f, -0.11272297f, -0.05312289f, 0.18480061f, -0.00326618f, 0.04587987f, 0.05663322f, 
    -0.01155443f, 0.00873476f, 0.14034264f, 0.06557374f, 0.08275704f, -0.01254042f, -0.04876733f, 0.15553027f, 
    -0.00009072f, 0.07904368f, -0.03191671f, 0.18293408f, 0.23968844f, 0.14263332f, -0.10666843f, 0.16153020f, 
    -0.14101867f, 0.04795143f, 0.11345810f, 0.21305805f, -0.03521084f, 0.05173875f, -0.07695162f, -0.21784219f, 
    0.22429985f, -0.08110943f, -0.03745925f, 0.10450741f, 0.02539695f, 0.01134262f, -0.11076158f, -0.08312050f, 
    0.13744254f, -0.02967233f, 0.13786554f, 0.04950472f, -0.63850522f, 0.31601772f, -0.13513158f, -0.08633874f, 
    -0.05687154f, -0.11690193f, -0.04700650f, -0.11708269f, -0.00539835f, 0.08380930f, 0.05099064f, -0.09397152f, 
    0.08339454f, -0.22161809f, 0.02057767f, 0.27415714f, -0.09272826f, 0.03669604f, 0.00887868f, 0.07430125f, 
    0.06448393f, -0.07222773f, 0.24829553f, 0.04832356f, -0.08681346f, 0.00672830f, 0.12309889f, -0.17715918f, 
    0.12433492f, -0.01424443f, 0.13328715f, 0.00465394f, -0.08662055f, 0.08307953f, 0.02233051f, 0.12947133f, 
    0.11590474f, 0.01737058f, -0.00300705f, -0.06494865f, -0.05791233f, 0.00470522f, -0.05241138f, -0.11228871f, 
    -0.08709151f, 0.00652679f, -0.13472247f, 0.10457674f, -0.29500926f, -0.13338439f, 0.13188237f, -0.30245599f, 
    0.06662410f, 0.07795662f, -0.11926735f, 0.16764045f, 0.15529655f, 0.02489311f, -0.09874173f, -0.08269339f, 
    -0.34012637f, -0.04957528f, -0.03055124f, -0.01489409f, -0.06830422f, -0.01100459f, 0.07197966f, -0.02433799f, 
    0.03759360f, 0.12323596f, -0.00605036f, 0.09720696f, 0.07680261f, 0.06977889f, -0.04505477f, -0.08721756f, 
    -0.02898511f, 0.02507725f, -0.09226472f, -0.05998382f, 0.04492031f, -0.03708258f, 0.07700541f, 0.00811367f, 
    0.38407657f, 0.05529817f, -0.09942080f, 0.14599498f, -0.00719337f, 0.03824633f, -0.05443539f, -0.00265579f, 
    0.03442804f, 0.05668474f, -0.02479558f, 0.02150440f, 0.20839703f, -0.00213629f, 0.01421436f, 0.27315354f, 
    -0.08584651f, 0.11731781f, 0.10576985f, 0.02853506f, 0.02189917f, 0.08467735f, -0.01621336f, 0.01147798f, 
    0.36296007f, -0.08168288f, 0.17666934f, 0.21134695f, -0.05496614f, 0.06114993f, -0.03357655f, 0.07214062f, 
    0.15904750f, 0.02052334f, 0.05022128f, -0.04313357f, 0.16380565f, -0.09699958f, 0.25032887f, 0.35938871f, 
    -0.11960442f, 0.08278647f, -0.01203059f, -0.02575696f, 0.12763815f, -0.15311137f, 0.12679076f, 0.11860226f, 
    0.27924159f, -0.06060173f, -0.26612523f, -0.04143935f, 0.01180629f, -0.08539895f, -0.06701802f, -0.00684764f, 
    -0.06550010f, 0.00825631f, 0.04600205f, 0.01295140f, 0.32898211f, -0.18204464f, -0.07538175f, -0.02073203f, 
    -0.03296844f, 0.06323449f, -0.03447576f, -0.15335794f, -0.01164032f, -0.03573463f, -0.00186153f, 0.07699748f, 
    -0.01044052f, -0.16860978f, -0.07967531f, -0.11602445f, 0.12586495f, -0.02508458f, -0.00508720f, 0.04304687f, 
    0.01345084f, 0.06187481f, -0.16750887f, -0.03094388f, -0.21588334f, -0.14444761f, 0.09270643f, 0.02772712f, 
    -0.03667660f, 0.07717942f, -0.07011363f, 0.17339906f, 0.15215699f, -0.21187299f, -0.09388084f, -0.18328741f, 
    0.01403922f, -0.01196967f, -0.10959774f, 0.28045589f, 0.07957863f, -0.11772671f, 0.08771581f, -0.02594606f, 
    -0.08648986f, 0.05238411f, -0.22813492f, 0.22085193f, -0.27914956f, -0.15439305f, 0.26350373f, 0.16454978f, 
    0.03682863f, -0.10328323f, 0.03580863f, -0.00195211f, 0.13616484f, 0.08392368f, -0.00961097f, 0.08842698f, 
    0.14043587f, -0.03306703f, 0.00456291f, 0.18171881f, -0.05549285f, 0.00053205f, 0.01727031f, 0.18827693f, 
    0.03857461f, 0.08606502f, -0.01874439f, 0.12065707f, -0.23557253f, 0.24821088f, 0.24487366f, -0.05906692f, 
    0.17749469f, 0.08309927f, 0.09760514f, 0.03494276f, 0.10699342f, -0.15362982f, -0.20707458f, 0.22290680f, 
    -0.43891466f, -0.08021831f, 0.02711500f, -0.17611745f, 0.03070847f, -0.03833004f, 0.11436785f, 0.02558823f, 
    -0.12299404f, -0.07426924f, 0.09557064f, 0.02354673f, -0.06322526f, -0.27821285f, 0.16538657f, 0.23773278f, 
    0.07961650f, -0.02328239f, 0.05619425f, 0.02890304f, 0.16153011f, -0.10256295f, 0.07300144f, -0.09135174f, 
    0.22489955f, -0.24754453f, -0.17399308f, -0.04024510f, -0.16076654f, -0.06025365f, -0.10506910f, -0.05517395f, 
    0.01263832f, 0.12008341f, -0.12819013f, 0.03793526f, -0.34131378f, 0.19801630f, -0.00142321f, -0.06778031f, 
    0.02763393f, -0.04153116f, -0.00200146f, 0.10139418f, 0.09400029f, -0.05186998f, 0.06519251f, -0.18059738f, 
    0.02581733f, 0.01772362f, 0.02861668f, 0.00927305f, -0.02644210f, 0.01459428f, -0.01317998f, -0.00288753f, 
    -0.03364891f, -0.02839578f, 0.01031956f, 0.02099578f, 0.00777252f, -0.02534986f, 0.00903996f, 0.01652715f, 
    -0.02062217f, -0.00761499f, 0.03844034f, -0.03459271f, -0.02720943f, -0.02923338f, -0.00008828f, -0.03114553f, 
    -0.02195036f, 0.02373669f, -0.00817712f, 0.00104170f, 0.01212077f, -0.03869610f, -0.02069680f, -0.00645265f, 
    -0.04228633f, -0.01297372f, -0.00625769f, -0.01475588f, 0.01763110f, -0.03739652f, -0.03193159f, -0.02050832f, 
    -0.03413631f, 0.00186236f, -0.02522799f, -0.03932455f, -0.04167307f, -0.03239565f, -0.02509163f, -0.02243790f, 
    0.01895957f, 0.02444348f, 0.00416875f, -0.03463143f, 0.02513001f, -0.00554834f, 0.02575527f, 0.00404647f, 
    -0.01629801f, 0.01210852f, -0.01226830f, -0.00676585f, -0.02491817f, -0.02066668f, 0.00672544f, 0.00001484f, 
    -0.03953181f, -0.01733964f, 0.01545818f, -0.02391355f, -0.00019010f, -0.00081984f, 0.00299062f, -0.01485499f, 
    0.00389436f, 0.00684028f, -0.02614350f, 0.01539129f, -0.01201308f, -0.03730292f, -0.02926318f, 0.01926075f, 
    0.00367986f, -0.03865581f, -0.04007732f, 0.01133149f, 0.02913340f, 0.02562277f, -0.03027461f, 0.01634339f, 
    -0.00525167f, -0.01920135f, -0.00002464f, 0.00750155f, 0.01216972f, 0.02092719f, -0.00987204f, 0.02853943f, 
    -0.02332148f, 0.00858671f, -0.02632966f, -0.01723138f, -0.00027493f, -0.04013183f, -0.02870686f, -0.01673275f, 
    -0.04176145f, 0.02606473f, -0.04140955f, 0.00803081f, -0.00845059f, 0.01012981f, -0.00970934f, -0.00486493f, 
    0.00096497f, -0.01419314f, 0.00501895f, -0.03888768f, 0.00565079f, 0.02779532f, 0.01070478f, -0.02869816f, 
    0.01327268f, -0.03018603f, -0.00944084f, -0.00269184f, 0.00013262f, -0.01088249f, 0.01156517f, -0.01576805f, 
    0.01125481f, 0.01594654f, -0.01160593f, -0.00556349f, -0.03943340f, -0.00502476f, -0.03020607f, -0.02378807f, 
    0.01799505f, -0.03828058f, -0.00656023f, 0.02389270f, 0.01514538f, 0.01857853f, -0.03487168f, -0.01231091f, 
    0.01334003f, 0.00511089f, -0.01174567f, -0.00559623f, -0.01602341f, -0.00965463f, -0.03331365f, 0.01532905f, 
    -0.03045801f, 0.01748688f, -0.02389426f, -0.00855789f, -0.02729676f, -0.02490713f, -0.01871306f, -0.00809848f, 
    0.02312458f, -0.00490085f, -0.01012088f, -0.02677560f, -0.00890776f, 0.02325823f, 0.02226773f, -0.00154140f, 
    -0.02652813f, -0.03742220f, -0.00413674f, 0.00503556f, 0.00735426f, -0.03452514f, -0.01373047f, -0.01115398f, 
    0.01879671f, 0.02769362f, 0.02171694f, 0.00496458f, -0.00823064f, 0.02158938f, -0.00338444f, 0.01823880f, 
    -0.01551294f, -0.02217042f, -0.03380429f, -0.01277019f, -0.04073506f, 0.00867496f, -0.02316036f, -0.00534827f, 
    -0.00552385f, 0.02230555f, 0.01807952f, -0.01821231f, -0.03051754f, 0.02442870f, -0.02643451f, 0.00739723f, 
    0.01865868f, -0.01522831f, 0.02177387f, -0.02168133f, -0.02105919f, -0.04246730f, 0.02502782f, -0.01096570f, 
    -0.00689225f, -0.02799502f, 0.00472424f, -0.04034257f, -0.02799860f, 0.01166675f, -0.02660318f, -0.04214539f, 
    0.01150947f, 0.01361053f, -0.00139478f, -0.00330035f, -0.01765618f, 0.02719825f, 0.02046638f, -0.03619279f, 
    -0.01309626f, -0.00512688f, 0.01883081f, -0.01497692f, 0.01762832f, -0.03331796f, -0.02489486f, -0.00368528f, 
    -0.03144459f, 0.00673688f, 0.02492504f, -0.00935293f, 0.01676919f, 0.02424142f, -0.00169563f, 0.01452487f, 
    -0.00318607f, -0.02292303f, -0.01112118f, -0.03735562f, 0.01380256f, 0.00067310f, 0.02776694f, 0.00719855f, 
    -0.01810875f, -0.02227776f, 0.00909670f, -0.02139688f, 0.02804136f, -0.03030619f, -0.04005085f, -0.02858694f, 
    -0.01909252f, 0.00956923f, -0.03672389f, 0.03099237f, -0.02558776f, -0.03724577f, 0.01008309f, 0.00212851f, 
    0.00808100f, 0.02344991f, -0.02157741f, -0.01267251f, 0.01185235f, 0.00549422f, 0.02193516f, -0.02473739f, 
    -0.02393571f, 0.02443176f, -0.01410661f, 0.00028254f, -0.03852779f, -0.02222656f, 0.01533789f, 0.02106029f, 
    -0.00804944f, 0.01209547f, -0.01947187f, -0.00764001f, 0.01355173f, -0.02430006f, -0.03466355f, 0.00690383f, 
    -0.03183177f, -0.01456005f, -0.01027849f, -0.02966274f, 0.02562408f, -0.00248230f, -0.02005728f, 0.00393742f, 
    -0.00390650f, -0.03296127f, -0.01512499f, 0.02246466f, 0.00685639f, 0.02349258f, 0.01976396f, -0.01373933f, 
    0.02136696f, -0.01101699f, 0.01853480f, 0.00456152f, 0.01865701f, -0.02291161f, -0.00494696f, -0.01152323f, 
    -0.02549222f, -0.00115875f, -0.01179477f, 0.00388815f, 0.00873057f, 0.01999144f, 0.00848573f, 0.00748422f, 
    0.00041991f, -0.01896910f, 0.02425337f, 0.00105009f, 0.01680666f, 0.02233294f, -0.02368730f, 0.01105086f, 
    -0.01326083f, -0.01191784f, -0.04258000f, 0.01295835f, -0.03454439f, -0.01693494f, 0.02970187f, 0.00394143f, 
    -0.03846557f, 0.01994955f, -0.01831462f, 0.00399476f, -0.00737788f, -0.03687527f, 0.02660003f, 0.01880036f, 
    -0.01543032f, -0.04052040f, 0.00009548f, -0.03884479f, 0.01591694f, -0.03392085f, 0.02939885f, -0.00303535f, 
    0.02173414f, -0.03928179f, -0.00178800f, 0.00061669f, 0.02550503f, 0.01474221f, -0.04148277f, 0.02809084f, 
    -0.03846971f, 0.03582807f, 0.01874861f, -0.00544321f, 0.02965343f, 0.02549189f, 0.02635513f, -0.00285815f, 
    -0.03316288f, -0.03048259f, -0.03024807f, -0.00392201f, -0.00369952f, -0.00521936f, 0.00394416f, -0.00733813f, 
    0.01664510f, 0.01471511f, -0.00483648f, 0.01982601f, -0.00482147f, 0.02873217f, 0.00586783f, 0.02727565f, 
    -0.03790223f, -0.01851207f, -0.03044041f, -0.01177382f, -0.03116076f, -0.00408844f, 0.00238668f, 0.02121301f, 
    0.01546606f, -0.02922534f, 0.00628219f, -0.03654766f, 0.02542344f, -0.00954907f, -0.00988375f, -0.01899558f, 
    0.00027086f, -0.04046075f, -0.03477449f, -0.01513803f, 0.00072458f, 0.01083451f, -0.00147763f, -0.02923450f, 
    0.01202583f, -0.03560845f, -0.02695378f, -0.03469043f, -0.00598101f, -0.02478199f, -0.01044300f, -0.02087515f, 
    0.01035749f, -0.02663255f, -0.01821124f, -0.03615340f, 0.01945746f, -0.00331917f, -0.02212259f, -0.03863436f, 
    -0.02595675f, 0.02598747f, -0.02390595f, -0.02453700f, 0.01918012f, -0.00930506f, 0.00518643f, 0.02367934f, 
    0.01798853f, -0.03690955f, 0.01746170f, 0.00616728f, 0.00752646f, -0.00391895f, -0.01854687f, -0.00436917f, 
    -0.01886928f, -0.00967265f, -0.03811434f, -0.01035453f, 0.00227366f, 0.02821209f, 0.00408281f, 0.02577815f, 
    0.00130962f, -0.01432912f, 0.02212303f, -0.02236589f, -0.00087945f, 0.02475640f, -0.02820889f, 0.00270069f, 
    -0.01552969f, -0.00512823f, -0.03996983f, 0.01714936f, -0.03355630f, -0.00354167f, 0.00063486f, 0.00062529f, 
    -0.01483478f, 0.01041704f, -0.00003780f, 0.02161345f, -0.00481570f, -0.04160917f, -0.03007647f, 0.01736514f, 
    0.02696505f, -0.00459836f, -0.00029672f, 0.02534444f, -0.01304864f, -0.03688420f, -0.00566621f, 0.01043619f, 
    -0.02672427f, 0.00142106f, -0.00730423f, -0.01419563f, -0.00983952f, 0.01591347f, -0.00634042f, -0.01785368f, 
    -0.02850087f, -0.01629728f, 0.01947665f, 0.01458804f, 0.01157520f, 0.01617262f, 0.02183515f, 0.01152160f, 
    0.01685771f, -0.02264488f, -0.02621291f, -0.03785177f, 0.01980154f, -0.02233929f, -0.04166657f, 0.02588539f, 
    -0.03676793f, -0.01870445f, 0.02811932f, 0.03300666f, 0.01144644f, 0.01619101f, 0.00450093f, 0.00609982f, 
    0.03100141f, -0.01373458f, -0.03762902f, -0.00816109f, -0.01677202f, -0.01050251f, -0.01598729f, 0.02885444f, 
    0.00587818f, -0.02796132f, 0.01959413f, -0.02892048f, -0.00238450f, -0.00869180f, 0.00125998f, -0.04116279f, 
    -0.03151780f, 0.02102926f, -0.01070434f, 0.03676039f, -0.00112175f, -0.01304742f, -0.02461035f, -0.02753007f, 
    -0.02034620f, -0.01980364f, -0.03505175f, -0.01539350f, -0.01718201f, -0.04138501f, 0.02750515f, 0.01920810f, 
    -0.03792313f, 0.02158199f, 0.01054504f, -0.03043796f, -0.02381956f, 0.02111433f, 0.02097166f, -0.01723127f, 
    0.01865097f, 0.02402159f, 0.00496348f, 0.01999716f, 0.00154918f, 0.01350057f, -0.01469955f, -0.00639188f, 
    -0.00151560f, 0.02197023f, -0.02857379f, 0.02957255f, 0.02479859f, 0.02720630f, 0.02763362f, -0.02668163f, 
    -0.01395688f, -0.02690114f, -0.00998073f, -0.00974156f, 0.00581762f, -0.01562757f, -0.01126994f, -0.01530003f, 
    0.03106622f, -0.00938102f, 0.01334345f, -0.00766807f, 0.02178978f, 0.02955160f, -0.03548994f, -0.00023781f, 
    -0.00413816f, 0.01384201f, -0.03359938f, 0.00829527f, -0.02781400f, -0.02846603f, 0.00575938f, -0.01410732f, 
    0.00734303f, 0.01896563f, 0.00967919f, 0.01921983f, -0.03045320f, 0.00982259f, -0.03866740f, -0.00005097f, 
    0.00299957f, -0.01054169f, -0.00950479f, -0.02349210f, 0.00240898f, 0.02125210f, -0.01271826f, -0.00607664f, 
    0.01884298f, 0.00049358f, -0.02386935f, 0.01361035f, -0.03048635f, -0.02192318f, 0.01161302f, -0.01428045f, 
    -0.00967768f, -0.00532593f, 0.00112932f, -0.03527822f, 0.01307176f, -0.02433778f, -0.02065474f, -0.00450760f, 
    -0.01606747f, -0.00923838f, 0.02894504f, 0.01858116f, -0.00198641f, -0.02765858f, 0.00934472f, -0.01402998f, 
    0.01298717f, 0.02891119f, -0.02784536f, 0.02434955f, -0.03379991f, -0.02414926f, -0.02900445f, -0.03437782f, 
    0.01519616f, -0.01232275f, 0.02920431f, -0.00786488f, 0.01523649f, -0.02316006f, -0.01828694f, 0.00941467f, 
    -0.00315144f, -0.03036240f, -0.03401558f, 0.01916944f, 0.00674489f, 0.00282136f, -0.01263498f, -0.02746875f, 
    -0.01172674f, 0.00021258f, -0.03373094f, -0.04199846f, -0.01583492f, 0.00549172f, -0.03149819f, -0.00906440f, 
    0.00983481f, -0.02722998f, -0.02308373f, 0.01080236f, 0.00008633f, -0.00878934f, -0.02151329f, -0.01931533f, 
    -0.03021491f, -0.01163309f, -0.03179952f, -0.00257694f, -0.01932200f, -0.01376479f, -0.01277800f, 0.01778645f, 
    -0.03440116f, -0.02261849f, 0.02122996f, -0.02303794f, 0.01254616f, -0.02272443f, -0.02122049f, -0.01820687f, 
    -0.00793836f, 0.00097577f, -0.04053544f, -0.03394613f, 0.02914145f, -0.03246028f, -0.02217572f, -0.00704259f, 
    -0.01360402f, -0.01401928f, -0.04237648f, -0.01739743f, -0.02757711f, 0.00300304f, -0.00694409f, 0.02639175f, 
    0.02308785f, -0.02320619f, -0.01693021f, -0.02583320f, 0.01224721f, 0.02918574f, 0.01487099f, -0.00118024f, 
    0.00290628f, -0.02703796f, -0.01905590f, -0.02718252f, -0.03071852f, -0.02476253f, 0.01596321f, -0.01147547f, 
    0.01199928f, -0.01336683f, -0.01682660f, 0.02750625f, -0.02639074f, -0.00695461f, 0.00609293f, -0.03936649f, 
    -0.03275447f, -0.01852226f, -0.00866299f, 0.00913860f, 0.01481608f, -0.03139371f, -0.01507306f, -0.02940772f, 
    0.02345941f, -0.02678132f, 0.01472137f, -0.00667399f, 0.01585765f, -0.03011058f, -0.00848798f, -0.00043026f, 
    -0.03866175f, -0.02934803f, -0.03265357f, -0.01550154f, -0.02471893f, -0.00341809f, -0.00674565f, -0.02796104f, 
    -0.01228391f, 0.01976496f, 0.02140534f, 0.02811686f, 0.00044415f, -0.03603626f, 0.02853164f, -0.01446370f, 
    -0.00128845f, -0.01109772f, -0.01136432f, -0.04018222f, -0.00568888f, 0.02411131f, 0.01101988f, 0.01764205f, 
    0.03246444f, -0.01407070f, -0.00451173f, -0.03768538f, -0.00221674f, -0.00165047f, -0.02704882f, -0.02968736f, 
    0.00724589f, -0.02048256f, -0.02306544f, -0.02987809f, -0.03975888f, 0.01643826f, -0.04024684f, -0.00524315f, 
    -0.02544188f, 0.01916227f, 0.02620042f, -0.03505956f, 0.01263870f, -0.02155595f, -0.00443901f, -0.01069041f, 
    -0.03362400f, -0.02707267f, -0.02349446f, 0.01572755f, -0.03340651f, -0.01222894f, 0.03048037f, -0.02616240f, 
    -0.00851115f, 0.01599839f, 0.02229458f, -0.00208535f, -0.01167791f, -0.00451286f, 0.00684631f, -0.03857324f, 
    -0.02906211f, -0.03377794f, 0.00113450f, -0.03379664f, 0.00880628f, 0.02636653f, -0.03752209f, 0.03329474f, 
    0.00589982f, -0.01203689f, -0.02089586f, -0.01209165f, 0.02374413f, 0.01456445f, -0.02243347f, -0.00263748f, 
    0.01933962f, 0.02729399f, 0.01627981f, -0.03889546f, -0.01673034f, 0.01795725f, -0.03070565f, 0.02258649f, 
    -0.02163071f, 0.01463115f, -0.01435709f, -0.00391370f, -0.02454112f, -0.00277301f, -0.03545294f, 0.00995158f, 
    -0.03338446f, -0.01193521f, 0.01423731f, -0.03004332f, -0.00916186f, -0.00389335f, 0.00827263f, -0.02553718f, 
    0.02657903f, 0.02576608f, -0.01452913f, 0.03198616f, 0.01265093f, -0.00815254f, 0.01121503f, -0.01876723f, 
    0.01535480f, 0.00003947f, 0.02101215f, 0.02065622f, -0.00188698f, -0.02588100f, 0.01165712f, -0.02438532f, 
    -0.03785753f, -0.02911605f, 0.01770359f, -0.02183502f, -0.02004019f, -0.03447014f, -0.01921870f, 0.01627015f, 
    -0.00170692f, -0.02527327f, 0.02297661f, 0.00156242f, -0.03118212f, -0.02757333f, 0.01822532f, -0.01789956f, 
    -0.02682376f, -0.02393682f, 0.02023622f, -0.02686371f, -0.00953328f, 0.02355682f, -0.04064135f, -0.02387119f, 
    -0.02797485f, -0.04323772f, -0.01323201f, 0.02201116f, 0.00190151f, -0.04193227f, -0.03065253f, 0.03619367f, 
    0.02413748f, -0.03753792f, 0.01925633f, 0.01599656f, 0.00003876f, -0.00933826f, 0.01850449f, -0.01256243f, 
    -0.01693926f, 0.01115960f, 0.00765198f, -0.01118500f, -0.01034663f, 0.03064360f, 0.02432593f, -0.02038700f, 
    0.00500214f, 0.00195805f, -0.02835645f, -0.02459256f, -0.02787362f, -0.02626655f, 0.03269117f, 0.01171595f, 
    0.02686898f, 0.00791285f, 0.01074953f, -0.02980967f, -0.01112977f, 0.01923944f, -0.03484299f, 0.02904060f, 
    -0.02428972f, -0.02710456f, 0.03076600f, -0.03746473f, 0.02321175f, -0.02577168f, 0.01267115f, -0.01494605f, 
    -0.01159260f, 0.01218451f, -0.04024811f, 0.01825611f, -0.00779573f, -0.01464827f, 0.00561777f, -0.03775181f, 
    -0.02280185f, 0.02935658f, 0.01667806f, 0.02435382f, 0.01000075f, 0.01883142f, -0.00916309f, 0.01791619f, 
    -0.00610480f, -0.00338346f, 0.00474576f, -0.00604596f, -0.01085791f, -0.00026937f, -0.00546637f, -0.00996975f, 
    -0.03189781f, -0.00661531f, 0.00326443f, -0.00306928f, -0.00970889f, -0.03246232f, 0.02238882f, 0.01902703f, 
    -0.01071285f, -0.02189033f, -0.02608635f, -0.00663737f, -0.00358129f, 0.00283752f, -0.00359808f, 0.01290029f, 
    -0.03269090f, 0.01888104f, -0.03391860f, -0.02440921f, -0.00023825f, -0.02028032f, 0.01335194f, -0.03750447f, 
    -0.02093383f, 0.00269779f, 0.01228998f, 0.00762849f, -0.00569067f, -0.01884531f, 0.02752237f, -0.00707476f, 
    -0.03407608f, -0.00275007f, -0.01641363f, 0.00870190f, -0.03319688f, 0.00065479f, 0.02450476f, -0.02517948f, 
    -0.01339951f, 0.01242677f, -0.02463523f, -0.00639776f, -0.03587348f, -0.00884509f, -0.02049445f, -0.00280739f, 
    -0.00546651f, -0.02267875f, -0.01118487f, 0.02037013f, 0.00591024f, 0.01467137f, -0.01011312f, 0.02320339f, 
    -0.01274512f, -0.02125273f, -0.03842591f, 0.02202129f, 0.01842918f, -0.04474839f, -0.02611590f, 0.01945180f, 
    0.00569577f, -0.00939588f, 0.02001858f, -0.00613134f, -0.02483367f, -0.03757204f, -0.02561597f, 0.02685034f, 
    0.01927641f, 0.00547399f, 0.00501318f, 0.01339967f, -0.00047565f, 0.01366916f, 0.02743622f, 0.01971595f, 
    -0.03816017f, -0.04037698f, 0.02138984f, -0.03160620f, -0.03395993f, -0.00967774f, -0.03562807f, 0.01369031f, 
    0.02798033f, -0.01483728f, -0.02141155f, -0.01162892f, -0.01909607f, 0.01962274f, 0.00208997f, 0.02728694f, 
    -0.01018857f, -0.01057531f, 0.02165615f, -0.04033031f, 0.02411064f, -0.03753078f, -0.00002866f, 0.00965286f, 
    0.01355013f, 0.01195916f, -0.02705703f, 0.01807237f, 0.01998275f, -0.00958296f, -0.02603439f, -0.01482884f, 
    -0.00498739f, 0.01839180f, -0.01491551f, -0.00975977f, -0.02764525f, 0.00426074f, 0.00011846f, 0.02646686f, 
    -0.00191796f, -0.03250282f, -0.04198976f, 0.00984388f, 0.02205201f, 0.01009474f, 0.00678156f, 0.01034308f, 
    -0.01051583f, 0.01820652f, 0.03624709f, -0.01056373f, -0.00324985f, -0.01968991f, -0.02311469f, -0.00165612f, 
    -0.04118908f, 0.01724345f, -0.04233607f, 0.00263344f, 0.00241272f, 0.00044107f, -0.03278632f, 0.03290415f, 
    -0.04420201f, -0.01794833f, -0.00618720f, -0.01017308f, -0.02462392f, 0.00520085f, -0.03773509f, 0.01832169f, 
    0.01754391f, -0.00809414f, 0.01148203f, -0.03669676f, 0.02616992f, -0.01748918f, -0.02868176f, 0.03088716f, 
    0.02130173f, -0.01900508f, -0.00712263f, 0.00096686f, -0.03515444f, 0.00525537f, 0.03144032f, -0.02987294f, 
    0.01878417f, 0.01544899f, -0.01839551f, 0.01009141f, 0.03054892f, -0.03592146f, 0.03150009f, 0.02221351f, 
    -0.01640946f, 0.02421261f, 0.02015963f, 0.00665931f, 0.00621305f, -0.01422044f, -0.02510866f, 0.01041067f, 
    -0.01150960f, 0.01302377f, -0.02978914f, -0.03685296f, 0.01201514f, 0.02312242f, 0.00520981f, -0.01876145f, 
    -0.00032457f, -0.02677879f, -0.02811101f, -0.01732570f, 0.03647832f, 0.00287165f, 0.01853679f, -0.01248885f, 
    -0.03127899f, -0.00672338f, 0.02032700f, 0.02063786f, -0.03781215f, -0.03568043f, -0.04131328f, 0.00859319f, 
    0.01435623f, -0.01919824f, 0.01389460f, 0.00780256f, -0.03640648f, 0.00239664f, 0.00042906f, -0.03468483f, 
    0.02587472f, 0.00351090f, 0.01520610f, -0.00167645f, -0.03368657f, -0.03707429f, 0.01668597f, 0.01402881f, 
    -0.00415422f, 0.02944920f, -0.03052754f, 0.00860941f, 0.01908751f, -0.00833221f, -0.01413464f, -0.03131224f, 
    -0.00016480f, 0.03384012f, -0.00821969f, -0.02878775f, -0.00438501f, 0.00432349f, -0.02585230f, 0.02051594f, 
    -0.00742814f, -0.02329606f, -0.02232576f, -0.03187656f, -0.03059119f, 0.01737494f, 0.02646388f, -0.00880898f, 
    -0.01167859f, -0.02562153f, 0.01981366f, 0.02060516f, -0.02972837f, -0.00286901f, -0.02254864f, 0.00252137f, 
    -0.04030549f, -0.01148379f, -0.03324948f, 0.02856186f, -0.03746896f, 0.02695186f, 0.00921722f, 0.02342452f, 
    -0.01638258f, 0.00403846f, -0.00716534f, -0.01918112f, -0.03080977f, 0.00879568f, -0.01812457f, -0.00240457f, 
    0.00832850f, -0.00039499f, 0.00392017f, -0.02066275f, -0.03566401f, 0.00223937f, -0.01884892f, 0.03092151f, 
    -0.02953911f, -0.02915531f, -0.04192172f, -0.03009973f, -0.03437283f, 0.03212568f, -0.00261872f, -0.00511492f, 
    0.00244330f, -0.01670092f, 0.01564075f, 0.01093153f, -0.01679719f, -0.01396137f, 0.02909338f, -0.00908379f, 
    0.01505204f, -0.01501635f, -0.03807507f, -0.00774045f, -0.00593443f, -0.00797717f, 0.01677141f, 0.02917614f, 
    0.02175882f, -0.00646759f, -0.00725481f, -0.02257110f, 0.02866967f, 0.01909338f, 0.01894133f, 0.02426825f, 
    0.02177831f, -0.02320617f, 0.02733332f, 0.02513059f, 0.03376911f, 0.00225201f, -0.00765702f, 0.00461358f, 
    -0.02286622f, -0.02984011f, -0.02694018f, -0.01289131f, 0.01431348f, -0.02659629f, -0.02420731f, -0.03834055f, 
    -0.02583911f, -0.03475676f, -0.03953071f, -0.00374365f, -0.02689383f, -0.00099456f, -0.01830870f, -0.03250015f, 
    -0.00201966f, 0.00709730f, 0.00606844f, 0.02271794f, 0.00093151f, 0.01167928f, 0.00452626f, 0.01097243f, 
    0.02016793f, 0.01498246f, -0.02383821f, 0.02920032f, -0.00489683f, -0.00604942f, -0.00097387f, -0.02358519f, 
    0.00488908f, 0.00945181f, -0.02039437f, -0.00535729f, 0.00957869f, -0.01944600f, 0.00116587f, 0.03199172f, 
    0.00676176f, 0.00846351f, 0.01834555f, 0.02027942f, 0.02582454f, 0.01759450f, 0.00184897f, -0.02653474f, 
    -0.00281249f, -0.03485904f, 0.01722966f, -0.01664454f, -0.01584825f, 0.03004660f, 0.00175773f, 0.00672209f, 
    -0.03321801f, 0.02637314f, 0.01079924f, 0.00141322f, 0.02259387f, -0.02266416f, -0.00566106f, 0.03218137f, 
    -0.02504828f, 0.01339946f, -0.02437576f, 0.00102297f, -0.02703398f, -0.02001259f, 0.02423419f, -0.00874578f, 
    -0.01585379f, 0.00696478f, 0.02786391f, -0.04241141f, 0.00605905f, -0.01068522f, 0.03357029f, 0.04033309f, 
    0.02594598f, -0.01878920f, 0.01912678f, -0.00734334f, 0.00449463f, 0.00000219f, -0.00423924f, 0.00472638f, 
    -0.02704116f, -0.00748720f, 0.04643584f, -0.02301883f, 0.00343612f, -0.03570567f, -0.00821221f, -0.00123769f, 
    -0.02064519f, -0.03830476f, 0.00741260f, 0.01155760f, 0.01618501f, 0.01421616f, 0.00326096f, 0.01768589f, 
    -0.01034355f, 0.00754621f, -0.03343445f, 0.03255837f, 0.03601868f, 0.01777688f, -0.02092305f, 0.03151185f, 
    -0.00006604f, -0.01369301f, 0.01628258f, -0.00863880f, -0.01659215f, 0.00232115f, -0.02634622f, 0.00957007f, 
    0.03182565f, 0.01523526f, 0.00825382f, -0.00585423f, -0.02427202f, -0.02438006f, -0.03138754f, 0.01430521f, 
    -0.00160010f, 0.00301665f, -0.02192208f, 0.02402651f, -0.03093958f, 0.01343327f, -0.01276528f, 0.03073714f, 
    0.00748445f, 0.00713040f, -0.03262971f, -0.03640106f, -0.02493534f, 0.01517854f, -0.00914603f, -0.03280037f, 
    0.02983491f, -0.03209961f, -0.01644360f, 0.02431194f, 0.01737085f, -0.01222760f, 0.01568493f, 0.02668416f, 
    -0.02241837f, 0.01937468f, -0.01120699f, 0.02797057f, 0.01729172f, -0.03595560f, -0.00183548f, 0.01437127f, 
    -0.01725908f, 0.01821173f, -0.03424791f, -0.01161600f, 0.01042540f, -0.01885944f, -0.01106845f, -0.00330272f, 
    0.01915440f, -0.00791789f, -0.01114463f, 0.00390625f, -0.01343050f, 0.00067016f, -0.02993799f, 0.01439118f, 
    -0.00399811f, -0.03677346f, 0.01632358f, -0.02273695f, -0.02743579f, 0.03165000f, -0.00555412f, 0.00524208f, 
    -0.02187536f, 0.02250873f, -0.00486197f, -0.01360280f, 0.00207651f, -0.02862642f, 0.01853282f, 0.01950107f, 
    0.01883693f, -0.02636753f, -0.00986024f, -0.01774861f, 0.02368004f, 0.02496667f, -0.01519925f, 0.00252794f, 
    -0.01036020f, 0.00107124f, 0.01709475f, -0.00816819f, 0.02203739f, -0.02968118f, 0.03385371f, 0.02746956f, 
    -0.01017667f, -0.00377105f, 0.00743027f, -0.01601465f, -0.02431306f, -0.01893028f, -0.02847323f, 0.00834220f, 
    -0.00974067f, -0.00949101f, -0.04087289f, -0.04659185f, 0.02580339f, 0.03408732f, -0.01775549f, 0.00540069f, 
    0.02398714f, -0.02618258f, -0.00261018f, 0.00708502f, -0.02853619f, 0.00421813f, 0.02105211f, 0.02393582f, 
    -0.02213999f, 0.02221931f, -0.00482469f, 0.03853346f, 0.00492770f, 0.03055753f, 0.01875026f, 0.03208733f, 
    0.01859071f, -0.00419525f, 0.02135105f, 0.01473432f, -0.02222572f, -0.03429721f, -0.00733986f, -0.01118097f, 
    0.00377128f, -0.01832786f, -0.01600884f, -0.03303259f, 0.02548889f, 0.00701964f, -0.00189599f, 0.02921815f, 
    0.28399518f, -0.04103521f, 0.16368537f, -0.01512483f, 0.01496555f, -0.04536664f, 0.09831201f, 0.02277339f, 
    -0.04320900f, 0.04421901f, 0.01158834f, 0.03609352f, -0.26199639f, 0.00723959f, 0.03483171f, -0.03434316f, 
    -0.03932563f, -0.03873135f, 0.00207770f, 0.00180544f, -0.02640801f, -0.07528010f, 0.03753586f, 0.05951931f, 
    -0.00957969f, -0.01997702f, -0.03948441f, -0.05232592f, 0.03182762f, 0.02049872f, -0.16450076f, 0.08789811f, 
    0.02251706f, 0.09840795f, 0.01428676f, 0.00219815f, -0.08210699f, -0.01064984f, 0.02755101f, -0.17739868f, 
    -0.04329182f, 0.01964335f, 0.02641393f, -0.09043001f, -0.01315980f, -0.05073945f, -0.02411680f, 0.01295611f, 
    0.18080312f, -0.13960057f, 0.11588450f, -0.04623121f, -0.05732476f, 0.00887838f, -0.00757678f, 0.03075572f, 
    0.00500845f, -0.11285570f, -0.04389089f, 0.01541355f, -0.03352481f, 0.05868689f, 0.13162449f, -0.04391146f, 
    0.04067862f, 0.02687993f, -0.00308587f, -0.04437197f, 0.00165657f, -0.10635025f, 0.01873377f, -0.01262485f, 
    0.08891826f, -0.32297701f, 0.20974660f, 0.19369748f, -0.03761049f, 0.01588883f, -0.08193457f, 0.11749993f, 
    0.04356286f, -0.03356147f, -0.08800354f, 0.07862666f, 0.08630272f, 0.04167953f, 0.01161394f, 0.06370888f, 
    -0.11378755f, 0.13349967f, 0.02379358f, -0.00162269f, 0.01336850f, -0.01514379f, 0.03287148f, -0.11227883f, 
    0.20200956f, -0.03343574f, 0.10416347f, 0.03021673f, -0.09620608f, 0.01921017f, 0.03936682f, 0.01102077f, 
    0.06127465f, 0.03867214f, -0.00049322f, 0.06365471f, 0.33210179f, -0.06261611f, -0.25324777f, 0.09310547f, 
    -0.05134942f, 0.05684856f, -0.06576399f, -0.05409686f, -0.06046755f, -0.00395539f, 0.00798078f, -0.06118172f, 
    0.10818075f, -0.09327245f, 0.09189668f, -0.09265643f, 0.04422745f, -0.02518204f, 0.01761724f, -0.02468756f, 
    -0.10426253f, 0.13091381f, 0.04214714f, -0.01218058f, 0.12117239f, -0.21396375f, 0.13984074f, 0.12885743f, 
    -0.12678066f, 0.05564185f, -0.00824660f, -0.03578447f, -0.06234442f, -0.03656330f, -0.09283016f, -0.03704476f, 
    -0.01918318f, -0.16339557f, 0.08856671f, 0.10380679f, 0.06323573f, 0.06859860f, -0.02173813f, 0.07314377f, 
    0.00852027f, -0.07045370f, 0.03638267f, 0.08118002f, 0.22536226f, 0.21933785f, 0.04895407f, 0.02209590f, 
    -0.07571080f, 0.04760715f, 0.04771634f, -0.03918377f, 0.06608501f, 0.01174541f, -0.03076660f, -0.09805995f, 
    -0.02864940f, -0.15217152f, 0.01501288f, -0.22951740f, -0.12098494f, -0.03724495f, 0.06461172f, 0.06043979f, 
    0.13614729f, 0.11575305f, 0.14783610f, 0.01652791f, -0.20814686f, -0.08146895f, 0.02456386f, -0.12029775f, 
    0.10284841f, -0.07469348f, -0.00916468f, -0.09548873f, 0.11006428f, 0.01166080f, -0.09743612f, 0.12035274f, 
    0.07052593f, -0.17282371f, 0.00462576f, -0.03528638f, -0.03930171f, 0.13178341f, 0.01804469f, -0.08639372f, 
    -0.02336897f, 0.06414253f, -0.01814497f, -0.01987012f, 0.19651431f, -0.05662833f, 0.11680149f, 0.13053386f, 
    -0.14100675f, 0.04803708f, 0.11515518f, -0.05958499f, -0.01306934f, 0.07055360f, 0.12017903f, -0.04966744f, 
    -0.15109611f, -0.12077086f, 0.10054456f, -0.07423960f, -0.10803589f, 0.02088772f, 0.02132307f, -0.08290374f, 
    0.01028357f, -0.11516201f, -0.05435008f, 0.10146352f, 0.11604529f, 0.37599888f, -0.13023105f, 0.01730760f, 
    0.10146161f, -0.01027963f, 0.07442511f, 0.03122357f, 0.02700560f, 0.00220781f, -0.04322798f, 0.01331262f, 
    -0.12677358f, 0.19003664f, 0.05555942f, -0.07321762f, 0.01581554f, 0.17033465f, 0.00296265f, 0.03107117f, 
    -0.03297126f, -0.13511957f, -0.04722784f, 0.02589511f, -0.05011973f, 0.13720851f, -0.02902112f, 0.22288229f, 
    -0.01829258f, -0.02505714f, 0.02663301f, -0.06301159f, -0.08441119f, -0.02208868f, -0.07678432f, -0.14867260f, 
    0.32195458f, -0.14554235f, -0.09703682f, 0.03043563f, -0.04990039f, -0.01917732f, -0.04068438f, -0.03834000f, 
    -0.01248091f, 0.01950690f, -0.02354353f, 0.01297450f, 0.02838416f, 0.02202374f, 0.06933753f, -0.13697471f, 
    0.09348061f, 0.06752533f, 0.07385527f, -0.01901507f, 0.05090774f, -0.02326838f, 0.07242614f, 0.05442521f, 
    -0.11046101f, -0.00345632f, -0.19232011f, -0.02155520f, 0.06802616f, 0.05740027f, 0.13719039f, -0.00450766f, 
    0.00521149f, -0.07446773f, 0.03861555f, 0.02587984f, -0.01720888f, 0.07964601f, 0.15665014f, 0.14542057f, 
    -0.08235819f, 0.07178518f, 0.11480755f, 0.02055426f, 0.00596561f, -0.10268237f, -0.07243127f, 0.06684627f, 
    0.11902140f, -0.19120336f, -0.20977695f, -0.30826283f, -0.00689972f, 0.08408020f, -0.04123997f, 0.00067967f, 
    -0.12635610f, 0.01736739f, -0.05461980f, 0.10554857f, -0.10600673f, -0.07123594f, -0.24362175f, -0.19004016f, 
    0.08669559f, 0.01554972f, 0.02941031f, -0.04797052f, 0.01805593f, 0.04362291f, 0.10631335f, 0.12888323f, 
    -0.07832073f, -0.06541527f, -0.09836783f, -0.09720666f, 0.04273579f, -0.08944613f, -0.05379246f, -0.04072910f, 
    -0.01419528f, -0.04361225f, 0.00486482f, 0.09474666f, -0.03647395f, 0.28178534f, -0.03005817f, 0.16121212f, 
    0.03693339f, 0.10777695f, 0.16408886f, 0.09082886f, -0.06485324f, 0.02191097f, -0.04464122f, 0.02853908f, 
    -0.03318284f, 0.06324283f, 0.02375149f, -0.04304823f, 0.05433927f, -0.02431033f, 0.09771871f, -0.07959106f, 
    0.05544857f, -0.03669468f, 0.02999976f, 0.05797110f, 0.24366371f, -0.07609040f, 0.04164514f, 0.14229831f, 
    -0.02237970f, -0.11148966f, 0.01867617f, 0.05840025f, -0.06240837f, 0.16188066f, 0.11500907f, -0.02257051f, 
    0.14149572f, -0.03804698f, 0.02281122f, -0.31455567f, 0.16282497f, 0.09676255f, 0.17209750f, 0.05099970f, 
    -0.05263495f, -0.14567778f, -0.06159087f, 0.13422899f, -0.01765258f, -0.01144375f, -0.13943721f, -0.02405779f, 
    0.07477584f, 0.06715208f, 0.04210377f, -0.06681851f, 0.03518718f, 0.02695360f, 0.00363209f, 0.07617964f, 
    -0.05157437f, 0.21242231f, 0.06050419f, -0.01879518f, 0.03362569f, -0.06012658f, 0.01042345f, -0.01506180f, 
    -0.04595143f, -0.01015286f, 0.01456714f, -0.13082725f, -0.11286420f, 0.01345830f, 0.07201947f, -0.06428540f, 
    -0.01394413f, 0.03654119f, 0.06054283f, 0.08241831f, 0.01238482f, -0.05223647f, 0.06550665f, 0.18733853f, 
    0.04831444f, -0.16916846f, 0.17045379f, 0.14574333f, -0.21616532f, 0.00719706f, 0.06469563f, -0.08431531f, 
    0.01525288f, 0.02255547f, -0.09011898f, 0.03701937f, 0.07557196f, -0.07461929f, -0.10860588f, -0.15417473f, 
    -0.04361324f, 0.09564473f, -0.00568407f, -0.04662202f, -0.02696312f, 0.03026943f, -0.06054474f, 0.12219457f, 
    -0.18220094f, -0.02568746f, -0.04963908f, -0.03332549f, -0.03113297f, 0.01752116f, 0.03958370f, 0.00290258f, 
    0.02405444f, 0.03186816f, -0.01470815f, 0.05396440f, 0.07611961f, 0.11073224f, 0.06591409f, 0.23575906f, 
    -0.13908507f, -0.04652711f, -0.01762835f, 0.10348888f, -0.14489007f, 0.06373543f, -0.09441918f, 0.02336252f, 
    0.35623705f, 0.16192073f, 0.05216498f, 0.16515270f, -0.01768504f, -0.14547195f, -0.03568281f, 0.08510028f, 
    0.00820672f, -0.07044580f, 0.03391300f, -0.04217846f, 0.02254059f, -0.05030768f, 0.02957302f, -0.10693983f, 
    -0.07925221f, 0.23739791f, -0.02473453f, -0.03700399f, 0.00383223f, 0.07066631f, 0.09556010f, 0.09323560f, 
    0.39955646f, 0.25516781f, -0.08344354f, -0.01213557f, -0.06763072f, -0.06370537f, 0.01466183f, 0.02180208f, 
    -0.00840862f, -0.04248574f, 0.15341382f, -0.00434566f, -0.11518149f, -0.13621370f, 0.01350754f, 0.00470953f, 
    0.09690659f, 0.17176834f, -0.06358133f, 0.01168022f, -0.05181873f, 0.02108573f, 0.00486553f, -0.01135657f, 
    0.18674164f, 0.05281285f, 0.02481858f, 0.18319538f, -0.09044889f, -0.16415606f, -0.18107127f, 0.02580862f, 
    -0.02424224f, 0.05763878f, 0.05368669f, -0.08510062f, -0.19802941f, 0.07910732f, -0.20401318f, -0.04029503f, 
    0.00006687f, -0.15790305f, -0.03249290f, 0.05710095f, 0.06808913f, -0.03143564f, -0.05628940f, -0.03447323f, 
    -0.28566584f, 0.00473886f, -0.04134579f, 0.02245238f, 0.05359033f, 0.12937473f, 0.02903256f, -0.04087149f, 
    0.05775958f, -0.00021887f, 0.01773818f, 0.01349980f, -0.16311941f, -0.34188479f, -0.03762580f, 0.09609967f, 
    -0.07955551f, 0.01097485f, 0.05751544f, -0.01259809f, 0.04411564f, -0.00056241f, 0.03519503f, 0.00232188f, 
    0.32817519f, -0.07145588f, 0.09931508f, 0.21103340f, -0.01870694f, 0.05360708f, 0.05116879f, 0.01740134f, 
    0.01934687f, 0.03785365f, 0.00106166f, 0.03247716f, 0.21916983f, 0.43616000f, 0.20545658f, -0.00479957f, 
    -0.06831250f, -0.01573905f, 0.03969092f, 0.03790264f, -0.00066101f, -0.00894796f, 0.14070225f, 0.00925005f, 
    0.49230364f, 0.06453300f, 0.29991233f, -0.01587922f, -0.13572939f, 0.03211613f, -0.05589822f, 0.09407661f, 
    0.07728428f, 0.07961817f, 0.03753657f, 0.08510686f, 0.33697426f, 0.11822466f, 0.07155062f, 0.01160153f, 
    -0.06388710f, 0.01224732f, 0.06834807f, 0.03854294f, 0.24201031f, -0.01743212f, -0.00068825f, 0.01293607f, 
    0.22191539f, 0.08630478f, -0.05439965f, 0.07144265f, 0.06307254f, -0.03717309f, 0.07679033f, 0.00566924f, 
    -0.10812845f, 0.01600004f, -0.01730302f, -0.01244094f, 0.18397976f, -0.33990255f, 0.08574069f, -0.13037366f, 
    0.08365279f, -0.06135259f, -0.05173949f, -0.04958868f, -0.00704289f, 0.09274763f, 0.06747928f, 0.09357966f, 
    0.19565289f, 0.05060804f, 0.36162263f, -0.26960188f, 0.04366518f, -0.03097173f, -0.02826796f, 0.06403042f, 
    -0.02794167f, 0.03404316f, -0.00030989f, 0.10963649f, 0.20956604f, -0.00488623f, 0.10890191f, 0.12985787f, 
    0.04369497f, 0.00241991f, -0.04420094f, 0.02322863f, -0.03968805f, 0.04302711f, -0.03320299f, -0.01779745f, 
    -0.03642261f, 0.10998942f, 0.16005866f, -0.08830138f, 0.01541621f, 0.11982684f, 0.04718404f, -0.01515684f, 
    -0.00570428f, -0.01825363f, 0.05669566f, -0.04510612f, -0.03636161f, 0.01987091f, -0.08206452f, -0.03222188f, 
    0.15491061f, -0.02593419f, 0.03082653f, 0.08841488f, -0.01335653f, -0.00831354f, 0.06191673f, -0.00356489f, 
    -0.01450684f, 0.03407923f, 0.17205375f, 0.15527946f, -0.11241896f, 0.06285337f, 0.07641343f, 0.04675993f, 
    -0.02152634f, 0.10367883f, 0.03488523f, 0.06343839f, -0.01048485f, 0.01919462f, -0.03300996f, -0.01205271f, 
    0.14858899f, -0.07100642f, 0.06354129f, 0.06979601f, 0.04689128f, 0.05512990f, -0.00128579f, -0.02249288f, 
    -0.01495278f, -0.12289104f, 0.11362818f, 0.05323039f, 0.04023401f, 0.06614419f, 0.16572912f, -0.05975242f, 
    0.09343842f, 0.02557969f, 0.11048120f, -0.20203155f, 0.21816544f, 0.03118492f, 0.07241049f, 0.10113836f, 
    -0.07969594f, -0.05565040f, 0.13390903f, 0.00665202f, 0.04261017f, 0.05616822f, 0.03393126f, -0.02492069f, 
    -0.07430708f, -0.02357971f, 0.15415619f, -0.13119788f, -0.05808776f, -0.05030061f, 0.02527947f, 0.05268168f, 
    -0.02379294f, -0.05355348f, 0.03425548f, -0.08528697f, -0.07009830f, -0.24383245f, -0.08776000f, 0.18866402f, 
    -0.02884952f, -0.16235465f, -0.02177949f, 0.02107131f, 0.00829120f, 0.06851031f, 0.05879349f, 0.07337359f, 
    -0.00081979f, 0.02849505f, 0.00441932f, -0.03539084f, -0.02584548f, 0.01162542f, 0.00642753f, -0.00841036f, 
    -0.03415592f, -0.01685099f, -0.00179910f, -0.03470438f, 0.01209681f, 0.00370193f, -0.02642954f, -0.02735159f, 
    -0.02824817f, -0.03443012f, -0.00820746f, -0.03526085f, 0.00374151f, 0.00828601f, -0.00445668f, 0.02120328f, 
    0.00270111f, 0.02047733f, -0.01761870f, 0.00371014f, -0.03409786f, -0.00918175f, -0.01429052f, -0.03815783f, 
    0.01562102f, -0.01356465f, -0.01748659f, 0.00072275f, -0.03889680f, 0.00466536f, 0.01917321f, 0.01788598f, 
    -0.00490792f, 0.01171536f, -0.02834797f, 0.00552961f, -0.03002916f, 0.00362800f, -0.02195992f, 0.01952023f, 
    -0.00056153f, 0.02488586f, -0.04434411f, -0.03420805f, -0.00809859f, -0.01846442f, -0.02109146f, -0.00165257f, 
    -0.02962026f, -0.02578729f, -0.03180470f, -0.00685212f, 0.01858726f, -0.01899807f, 0.01374366f, -0.01979306f, 
    -0.03440837f, 0.02394401f, -0.04071471f, -0.04021113f, -0.04083296f, -0.02954270f, 0.00230768f, -0.02610091f, 
    0.00677069f, -0.02614646f, -0.00062322f, -0.03862793f, -0.00857709f, -0.02151807f, -0.02344547f, -0.00176307f, 
    -0.02010511f, -0.04836763f, -0.04597744f, 0.02762052f, 0.00159780f, 0.02758040f, -0.01124817f, -0.03097328f, 
    0.02478068f, -0.03361382f, 0.01817302f, -0.00784767f, 0.01058081f, -0.00424375f, 0.01331733f, 0.01530315f, 
    0.02053119f, 0.00414961f, -0.00094078f, 0.01978120f, -0.00349127f, -0.02292443f, 0.02252476f, -0.02552551f, 
    0.01182117f, -0.03381245f, -0.03679043f, -0.01552742f, 0.02118487f, -0.02243490f, -0.02398728f, -0.00643609f, 
    -0.02751994f, 0.01518387f, -0.02116506f, 0.02786436f, 0.02153404f, 0.02219804f, -0.03333486f, -0.02241377f, 
    0.02368897f, -0.01820801f, -0.02047521f, -0.02004663f, 0.02042789f, 0.00021673f, -0.01199534f, 0.01502786f, 
    0.02764247f, -0.02143074f, -0.03566469f, 0.00578955f, 0.01198921f, 0.03655118f, 0.01714088f, 0.01959211f, 
    -0.01427121f, -0.03052096f, -0.02318413f, -0.00936907f, -0.00482066f, -0.00407745f, -0.00374178f, -0.00051986f, 
    -0.01523708f, -0.00517193f, 0.00279393f, -0.03581963f, 0.00510311f, 0.01090289f, -0.03726346f, -0.01129189f, 
    0.01682976f, 0.02521744f, -0.01182365f, 0.01917039f, -0.02454909f, -0.00143747f, -0.03787538f, 0.02341022f, 
    0.00312702f, 0.01497252f, 0.01686370f, 0.03411387f, -0.02731390f, 0.01701439f, 0.01434397f, 0.01751718f, 
    0.02408116f, 0.01045115f, -0.03123412f, -0.01573957f, 0.00017395f, -0.02649968f, 0.00887910f, -0.00915969f, 
    -0.00231036f, -0.03646548f, 0.02411995f, 0.01496365f, 0.02100242f, 0.01555590f, -0.01576031f, 0.01573558f, 
    -0.00264245f, -0.03139865f, 0.00485750f, 0.02186462f, -0.02046735f, -0.01389148f, 0.00909304f, -0.01829591f, 
    0.01160183f, 0.01185469f, 0.02534681f, -0.02015280f, -0.01799929f, -0.03554718f, 0.00245835f, -0.03057260f, 
    0.01171270f, -0.01616782f, -0.04106321f, -0.01804328f, -0.02031385f, 0.02126235f, 0.00122978f, -0.02872425f, 
    -0.00167390f, -0.02285128f, -0.01299895f, 0.02480152f, 0.03065633f, 0.00214639f, 0.00984806f, 0.00446821f, 
    -0.00801071f, -0.03434088f, -0.03352826f, -0.03584059f, 0.02729338f, -0.00717060f, -0.00822525f, 0.01355250f, 
    0.02126655f, -0.01460009f, 0.00400741f, 0.01172394f, -0.04347299f, -0.00098506f, -0.01133892f, -0.00946111f, 
    -0.00476806f, -0.03130613f, 0.02215286f, -0.00323248f, -0.03091629f, -0.03720622f, 0.01197352f, -0.03255016f, 
    0.02773598f, 0.00208380f, -0.03467719f, -0.01582217f, -0.01526690f, -0.00317243f, -0.00090459f, -0.00463405f, 
    -0.00843544f, 0.02649247f, 0.00556930f, 0.01319739f, -0.02230631f, -0.03146620f, 0.00196219f, -0.03673345f, 
    0.00905998f, 0.01124738f, -0.00359310f, 0.00901820f, -0.03314768f, 0.02288096f, -0.01120738f, -0.03690818f, 
    -0.03376457f, 0.00720073f, -0.01879113f, -0.03873989f, -0.01681902f, 0.02716476f, 0.00839560f, -0.03988184f, 
    0.00960908f, 0.02597532f, -0.03460630f, 0.01070389f, -0.02906492f, -0.02986397f, -0.01184031f, -0.00801948f, 
    0.01578285f, -0.02161197f, -0.01832236f, -0.00207811f, 0.00111552f, -0.00729945f, 0.00679869f, -0.04346827f, 
    -0.01543815f, -0.00920833f, 0.01008558f, -0.01779179f, 0.00422850f, -0.03502623f, -0.01640835f, -0.03629931f, 
    -0.00972641f, -0.02030889f, -0.03100565f, -0.00842484f, -0.03706570f, -0.01696360f, -0.04046394f, 0.01508420f, 
    0.02570658f, -0.01127211f, -0.00709935f, -0.01046264f, 0.00471022f, 0.01118565f, -0.03050149f, 0.02031604f, 
    -0.03246300f, -0.01964403f, -0.00722821f, 0.02182593f, -0.02594508f, 0.00854357f, -0.01472061f, -0.03182074f, 
    -0.02628091f, -0.02399519f, -0.02993664f, 0.00027837f, 0.01472567f, -0.03562010f, -0.01161120f, 0.00377173f, 
    -0.01223745f, 0.00869009f, -0.02945895f, 0.01647157f, 0.00987956f, 0.00601138f, 0.01576620f, 0.02815721f, 
    0.00725981f, -0.00209244f, -0.01856491f, -0.02371167f, 0.01440931f, 0.00126567f, -0.03433756f, -0.00088930f, 
    -0.02557977f, -0.02754913f, -0.02020272f, 0.00375825f, -0.02371760f, 0.00611165f, 0.00032137f, 0.00840368f, 
    -0.03364190f, 0.00313359f, 0.01975347f, -0.01070820f, -0.01885908f, -0.00961296f, -0.03558694f, -0.00461410f, 
    0.01746954f, 0.00870560f, 0.00280620f, -0.01410711f, 0.00353691f, -0.02196023f, -0.00483959f, -0.03439303f, 
    0.00931394f, -0.02802890f, -0.01613478f, -0.01797152f, 0.02363491f, 0.01221674f, -0.01993253f, 0.00978077f, 
    0.00335872f, -0.01219442f, -0.01080729f, -0.01140777f, -0.04138373f, 0.02263667f, 0.02663891f, 0.01487324f, 
    0.02275763f, -0.01614219f, 0.01864575f, 0.00818490f, 0.02058907f, 0.03082959f, -0.01091731f, -0.04220343f, 
    -0.03939696f, -0.04060576f, 0.01667624f, -0.00951944f, -0.00739383f, -0.03053333f, -0.00574904f, -0.02847837f, 
    -0.02734239f, 0.01922380f, -0.03672901f, -0.00311113f, -0.01492653f, -0.00704288f, -0.01063200f, 0.00881366f, 
    0.00467460f, 0.00713157f, 0.00483553f, 0.03087299f, 0.02938884f, 0.01882203f, 0.01223382f, -0.03197859f, 
    0.01556593f, -0.02813890f, 0.02332933f, -0.00257111f, -0.00643646f, -0.01521158f, -0.00546065f, 0.01678931f, 
    -0.04172345f, -0.00480934f, -0.00287565f, 0.00281873f, -0.03577198f, -0.00321303f, -0.00155234f, 0.00707089f, 
    0.01596622f, -0.02512078f, 0.01087071f, 0.01805403f, 0.00118438f, 0.01906039f, 0.00474389f, 0.00823918f, 
    -0.02266281f, 0.01310290f, 0.01244999f, -0.02343128f, -0.00995689f, 0.00118461f, -0.01067203f, -0.01618329f, 
    -0.00997884f, -0.00160407f, -0.04150439f, -0.01209953f, -0.03879420f, -0.00323810f, -0.00494736f, -0.02257705f, 
    -0.03869906f, -0.00885194f, -0.01010416f, 0.01488571f, 0.01569444f, -0.01596826f, 0.02777120f, 0.01657328f, 
    0.00549593f, -0.02849452f, 0.02361632f, 0.00310822f, 0.01259740f, 0.02113503f, 0.02935104f, -0.01640582f, 
    0.02939743f, -0.03032234f, -0.01256043f, -0.03464646f, -0.01134552f, 0.01164808f, -0.02456474f, -0.00293448f, 
    -0.00308604f, 0.01033003f, -0.01210735f, 0.01444714f, -0.01717436f, -0.00068782f, -0.02015970f, 0.01418288f, 
    0.02459537f, -0.02578136f, -0.00266612f, -0.00410772f, -0.00669967f, -0.02346137f, -0.00494091f, -0.04288530f, 
    -0.04434012f, -0.04414659f, -0.01934461f, 0.00353299f, -0.02353473f, -0.01705805f, -0.01859008f, 0.00032250f, 
    0.00744060f, -0.02584962f, 0.02754009f, -0.02882057f, -0.01554106f, 0.00120885f, 0.01879927f, 0.01022919f, 
    -0.01157842f, -0.02949270f, -0.03297199f, 0.01741045f, -0.02511588f, 0.02534378f, -0.02151587f, 0.02533762f, 
    0.00452119f, -0.01874388f, 0.03158901f, -0.02756424f, 0.00524929f, -0.02626450f, 0.02796528f, 0.00703776f, 
    -0.01273950f, -0.02150558f, -0.01621000f, -0.02421449f, 0.00605584f, -0.03001560f, 0.02323892f, -0.02698120f, 
    -0.01820798f, 0.01304714f, 0.01330255f, -0.03593469f, -0.04217992f, -0.00346013f, 0.00715396f, 0.00535417f, 
    0.02074429f, -0.02229212f, -0.00796191f, -0.00174681f, 0.00804959f, 0.00772028f, -0.00515147f, -0.02947603f, 
    0.02340199f, -0.00527605f, 0.02529883f, -0.01998485f, -0.00263021f, -0.02400914f, 0.00080551f, -0.03572290f, 
    -0.03167403f, -0.04401619f, -0.03486334f, 0.00868136f, -0.02849928f, -0.01029100f, 0.00699617f, -0.02493814f, 
    -0.02667330f, 0.02129496f, -0.03933806f, 0.01470346f, -0.03724140f, -0.03331088f, 0.00815111f, 0.01850982f, 
    -0.00412861f, -0.02063851f, 0.03843443f, -0.04465245f, 0.00858816f, 0.02774784f, 0.02798731f, -0.02792427f, 
    0.00246271f, 0.01922619f, -0.01002354f, -0.03235021f, 0.04043236f, 0.02112586f, 0.00366870f, -0.01052507f, 
    -0.00175212f, 0.01669449f, 0.00347140f, 0.02677602f, 0.02854099f, 0.02400112f, -0.03675629f, 0.01844989f, 
    -0.01010624f, 0.01031751f, -0.00264812f, 0.00016555f, -0.03163471f, -0.00737083f, -0.00807290f, 0.01698026f, 
    -0.03305337f, -0.03649893f, -0.02902961f, -0.01723279f, 0.01475326f, -0.00472928f, 0.03029273f, 0.02559559f, 
    0.00294459f, -0.02155283f, -0.04255778f, -0.01037018f, -0.00067055f, 0.01608985f, -0.03828218f, 0.00416352f, 
    0.01124536f, -0.01309047f, -0.02287906f, -0.03792214f, -0.02463861f, 0.02143615f, -0.01979865f, 0.00750590f, 
    -0.00572164f, -0.02239098f, -0.03962265f, -0.00760674f, -0.03585080f, 0.02150272f, -0.01332933f, -0.01463492f, 
    -0.00289106f, 0.00676231f, -0.03138617f, 0.00021527f, -0.02523926f, 0.03282548f, 0.00870825f, -0.04256650f, 
    0.01380257f, 0.00467832f, -0.02256305f, 0.01788173f, -0.02414619f, 0.00650568f, -0.01342561f, 0.01326208f, 
    -0.00681556f, -0.00444221f, 0.00866041f, 0.01448173f, 0.01880389f, -0.00659242f, -0.00668540f, 0.02622405f, 
    -0.01367609f, -0.01517143f, -0.01139521f, -0.04435844f, -0.02119317f, -0.01420974f, 0.01973200f, -0.00394865f, 
    -0.04188580f, -0.01973587f, -0.02385355f, 0.00755347f, -0.00723220f, -0.03844266f, 0.01847151f, 0.00276302f, 
    -0.00094484f, -0.00364845f, -0.01863372f, 0.02518384f, -0.01718470f, -0.02485614f, 0.01781035f, -0.02752974f, 
    -0.03626010f, -0.02000448f, -0.03041220f, 0.02618045f, -0.03114901f, 0.02967402f, 0.00976679f, -0.02006772f, 
    0.03192177f, -0.01358918f, 0.02868265f, -0.00265808f, 0.00798916f, 0.01118083f, 0.01191456f, -0.04086160f, 
    -0.01340811f, -0.00040092f, 0.00680068f, 0.02137732f, -0.03612228f, -0.03675523f, -0.00080709f, 0.00633903f, 
    -0.01993000f, -0.01167214f, -0.02290561f, -0.00894534f, -0.02252132f, 0.01975630f, -0.03936182f, 0.01213657f, 
    -0.00867989f, 0.02281680f, 0.01146840f, 0.00863348f, -0.01322137f, -0.00404881f, 0.00787795f, -0.00130063f, 
    -0.00859729f, -0.04228982f, 0.02079806f, 0.01538994f, 0.01271833f, -0.00352756f, -0.04631086f, 0.02415271f, 
    0.00232737f, 0.01162707f, 0.00826265f, -0.03043899f, 0.00913365f, 0.01911614f, 0.01769844f, 0.02229051f, 
    -0.02347835f, -0.04290794f, 0.00288680f, 0.02754672f, -0.02322118f, 0.01139682f, 0.02688504f, -0.00629087f, 
    -0.01569522f, -0.02070485f, -0.01290792f, 0.00208124f, 0.01884753f, -0.03137090f, -0.02485418f, -0.00855023f, 
    0.00188423f, -0.01857578f, 0.01105112f, -0.00702756f, 0.00675378f, 0.03400730f, -0.03296388f, -0.04028243f, 
    -0.01173910f, -0.00432172f, -0.01442259f, -0.02880451f, 0.00902318f, 0.01525483f, -0.03983647f, -0.00083427f, 
    -0.00860040f, 0.02477093f, -0.00454474f, -0.02052305f, 0.02729025f, -0.00824271f, 0.02379879f, -0.00876537f, 
    0.01223120f, -0.01827514f, -0.00938235f, -0.01999997f, -0.02371927f, 0.01140410f, -0.01007250f, -0.01430302f, 
    -0.03308563f, 0.02015050f, 0.01188141f, 0.01952305f, -0.02846838f, -0.02796562f, 0.01194796f, -0.03835935f, 
    0.01966469f, 0.00046950f, 0.02644580f, -0.01849589f, -0.02423831f, 0.01636363f, 0.00120844f, 0.01150099f, 
    0.02303199f, -0.02946584f, 0.02814100f, 0.02517534f, -0.01180614f, -0.02506235f, 0.01291703f, 0.03105017f, 
    0.02502341f, -0.00624262f, 0.02683172f, 0.02744577f, -0.01244132f, 0.01490728f, 0.00851644f, -0.02251772f, 
    -0.02250123f, -0.00985485f, 0.00649049f, -0.01749129f, 0.02250483f, 0.00734760f, 0.00640098f, -0.00982177f, 
    -0.00702206f, -0.00197551f, 0.02460000f, 0.03024535f, 0.01392114f, -0.00310206f, 0.01537624f, -0.00034733f, 
    0.02424879f, 0.03071869f, -0.02116624f, 0.01867978f, -0.00098418f, -0.03126043f, -0.04113712f, -0.01652774f, 
    -0.01124018f, -0.02648310f, 0.00913454f, 0.00556738f, -0.02712919f, 0.01323016f, 0.00665717f, 0.00500182f, 
    0.01973226f, -0.02703463f, 0.00237146f, 0.00877293f, -0.01450090f, -0.01654271f, -0.01851312f, -0.02836682f, 
    0.01949496f, 0.00504871f, 0.01510279f, -0.02906944f, -0.02672975f, -0.00258060f, 0.01274785f, -0.02973342f, 
    0.01797130f, -0.01079546f, -0.01483283f, -0.03817939f, -0.01656493f, 0.00530761f, -0.01136743f, -0.00947450f, 
    -0.00219255f, -0.02817371f, -0.00832451f, 0.02485982f, -0.01009201f, -0.01934814f, -0.02119019f, -0.03445465f, 
    0.00018489f, -0.04166419f, 0.01000549f, -0.01470393f, -0.02255498f, 0.00937672f, -0.00119970f, 0.02638677f, 
    0.00214577f, 0.01199008f, 0.00916606f, 0.02243272f, -0.01195017f, -0.01582674f, -0.03440537f, 0.03116255f, 
    0.00660181f, 0.00854511f, -0.02946441f, 0.02111272f, -0.03542453f, 0.01020399f, -0.00515129f, 0.00582313f, 
    0.02802666f, 0.02234597f, 0.02995481f, -0.03317839f, 0.03275258f, -0.01756381f, -0.03433037f, -0.03514657f, 
    0.02475825f, -0.03639507f, 0.03224457f, -0.02133300f, 0.00753166f, -0.00270910f, -0.02336068f, 0.00875549f, 
    -0.01756665f, -0.01706261f, -0.03983785f, 0.00463364f, 0.01462189f, -0.00717247f, -0.03387186f, 0.02867876f, 
    -0.03942077f, -0.01358149f, -0.01522728f, -0.02248535f, 0.02799111f, -0.03674157f, -0.01151336f, 0.00559045f, 
    -0.03399587f, 0.02490579f, -0.02614594f, 0.03268941f, 0.00283786f, 0.00748299f, -0.03687143f, 0.02914743f, 
    -0.00035417f, 0.01273791f, -0.03771090f, -0.01061268f, -0.03565314f, -0.03164729f, -0.02018446f, 0.03332915f, 
    -0.01398159f, 0.00016636f, -0.01102981f, -0.01420878f, 0.01052606f, -0.01972621f, 0.03113053f, -0.01272895f, 
    0.00414307f, -0.01351739f, 0.01566371f, 0.00954755f, 0.01531666f, 0.02619764f, 0.00572762f, 0.01909844f, 
    0.01278997f, -0.03031943f, 0.03168469f, 0.01469820f, 0.00497639f, 0.00291703f, 0.02287357f, -0.02895824f, 
    0.02835246f, 0.01735823f, 0.01301035f, 0.01307847f, -0.02037178f, -0.01485235f, 0.01302359f, 0.02182270f, 
    -0.04137139f, -0.02336953f, -0.03333270f, 0.00656614f, 0.00935053f, -0.02884569f, 0.00301080f, 0.00591095f, 
    -0.01588950f, -0.02200226f, 0.02472875f, -0.00383136f, -0.00649832f, -0.03462425f, -0.00237753f, 0.01736491f, 
    -0.00599614f, 0.01393012f, -0.02093988f, 0.02407024f, -0.01120039f, -0.00085305f, 0.00287599f, 0.02523935f, 
    0.02039402f, 0.00215246f, 0.00340190f, 0.00699969f, 0.02790816f, 0.01908998f, -0.02092548f, 0.03099669f, 
    -0.00337803f, -0.01225462f, 0.00335220f, 0.01230743f, -0.01205046f, 0.01098304f, -0.04021455f, -0.00674075f, 
    0.00682335f, -0.01218426f, -0.00136457f, 0.00498281f, -0.00387613f, -0.02403285f, -0.02415258f, 0.01044572f, 
    0.00208429f, 0.00715912f, 0.03258625f, 0.01189049f, 0.00719171f, -0.00314980f, 0.02228267f, 0.02047817f, 
    0.01246712f, -0.00298667f, 0.03336351f, 0.01083176f, -0.02702718f, -0.02155351f, -0.01293591f, -0.02854030f, 
    -0.03619398f, -0.03455827f, 0.00152525f, -0.00607973f, 0.01211772f, -0.01365455f, -0.00498928f, -0.02300435f, 
    -0.02163050f, -0.01660121f, 0.00253968f, -0.01676725f, 0.01179720f, -0.01469010f, -0.02532998f, -0.02441707f, 
    0.03905267f, 0.00675913f, 0.00213890f, -0.01631036f, -0.02935732f, 0.01948747f, -0.01918861f, -0.01743281f, 
    -0.00345768f, -0.00875672f, -0.03509187f, -0.03708601f, -0.00109871f, -0.00615230f, -0.00650793f, 0.01319494f, 
    0.02673336f, -0.02833384f, 0.02712259f, 0.02642412f, 0.02053416f, 0.03324795f, 0.03121186f, 0.00304800f, 
    -0.02390607f, -0.02114074f, 0.01343282f, -0.01715467f, -0.02852627f, -0.03417648f, 0.00826122f, 0.00546314f, 
    0.00212426f, -0.02108683f, -0.01609903f, -0.03514819f, 0.01955708f, 0.03086447f, 0.02853281f, -0.01302525f, 
    -0.03546975f, -0.03405385f, -0.02555654f, -0.02032256f, 0.02169128f, 0.02517286f, -0.03593653f, -0.03159486f, 
    -0.02879843f, -0.03580110f, -0.03908796f, -0.03397565f, -0.02226548f, -0.02249395f, -0.01737410f, -0.00317006f, 
    -0.01466490f, 0.01840340f, -0.03857109f, 0.02798636f, -0.00676619f, 0.00073834f, -0.00867284f, -0.01273546f, 
    0.01864733f, -0.01727726f, -0.00283729f, -0.00903166f, 0.03101877f, -0.00909532f, -0.04035786f, 0.02710235f, 
    0.02536852f, 0.00660714f, -0.01288137f, 0.01501765f, -0.02016815f, 0.01383710f, -0.00625094f, 0.01109068f, 
    0.01234470f, -0.01419005f, -0.02547365f, 0.02006947f, -0.03273945f, 0.02278699f, 0.00797444f, 0.01367548f, 
    0.02278379f, -0.04243056f, 0.00487534f, 0.02146778f, -0.00226808f, -0.01733915f, 0.00794185f, 0.02688369f, 
    0.00360447f, -0.01543745f, -0.02785245f, 0.00843990f, 0.01680960f, -0.00545385f, -0.01967238f, 0.00576757f, 
    -0.01154326f, -0.01778322f, 0.00163369f, 0.00876651f, 0.00456429f, -0.01129998f, -0.01580810f, 0.00815852f, 
    0.01621226f, 0.02521436f, 0.02423867f, 0.03460895f, 0.02332456f, -0.02904901f, -0.00180721f, -0.03709862f, 
    -0.01114324f, 0.02612973f, 0.01480925f, 0.02227814f, -0.04078544f, -0.00283875f, -0.03009322f, -0.02043567f, 
    -0.02570328f, 0.01808701f, 0.01680506f, -0.03124714f, 0.00400412f, -0.02508724f, -0.01127534f, 0.00447901f, 
    -0.02296243f, 0.01527538f, 0.01077228f, 0.00009958f, 0.00126386f, -0.02154496f, -0.00185677f, 0.02311308f, 
    0.00565980f, -0.02218970f, -0.03299428f, 0.00995922f, -0.00159404f, 0.02906678f, -0.02915500f, -0.02521904f, 
    0.02243806f, 0.02808809f, -0.01025460f, 0.00579959f, 0.03155772f, -0.00612884f, -0.01656471f, 0.00001527f, 
    -0.01560571f, -0.02838343f, -0.02195234f, 0.01709393f, -0.02966509f, 0.02028901f, 0.01436555f, -0.02757873f, 
    0.00613586f, 0.01855812f, -0.02945588f, -0.02963637f, 0.01225211f, -0.00713126f, -0.01265485f, -0.02562016f, 
    0.02452441f, -0.01216022f, -0.04136997f, -0.01244366f, 0.00152731f, -0.03375831f, 0.01007783f, -0.02647990f, 
    0.00237931f, 0.00958393f, -0.02278890f, 0.01134458f, -0.03391076f, -0.00028741f, -0.02478215f, -0.01720695f, 
    -0.00042774f, -0.03182382f, -0.00867163f, -0.00341874f, -0.01803590f, -0.00836763f, 0.01525790f, -0.00102477f, 
    0.01064313f, -0.02527957f, -0.00518437f, -0.01156074f, 0.01454012f, 0.00744067f, 0.01015437f, 0.01932662f, 
    -0.03260458f, -0.02172556f, -0.00695163f, 0.00647697f, 0.03152901f, 0.02222230f, 0.01278520f, -0.00261095f, 
    -0.00186494f, -0.01184827f, 0.01774983f, 0.02487625f, 0.00250883f, -0.03451927f, 0.00399487f, -0.02956304f, 
    0.01569143f, 0.03503434f, -0.01288009f, -0.04042501f, -0.01985709f, -0.01520951f, 0.00784618f, -0.02802622f, 
    -0.00723021f, 0.02727085f, -0.02680784f, 0.03037543f, 0.00657594f, -0.00338082f, 0.03031478f, -0.03076641f, 
    0.03090055f, 0.02068128f, -0.02381490f, 0.00951679f, -0.01370410f, -0.03537406f, 0.00184677f, 0.01257134f, 
    -0.02172914f, -0.03257511f, -0.03428091f, -0.00965793f, -0.02125856f, -0.01856881f, -0.01526600f, -0.00158981f, 
    -0.00265759f, -0.02153279f, -0.02831471f, 0.00043671f, -0.00529381f, 0.03466656f, -0.02888746f, -0.02682773f, 
    -0.01902988f, -0.00178923f, -0.03267518f, -0.00727514f, 0.01159233f, 0.00713977f, -0.02347200f, 0.03238708f, 
    -0.02709099f, -0.01997064f, 0.02888985f, -0.01502331f, 0.00620248f, 0.02279832f, -0.00989843f, -0.01807936f, 
    -0.02496923f, -0.03014787f, -0.00664421f, 0.02304957f, -0.00323787f, 0.00165007f, -0.03598597f, 0.01224586f, 
    0.02405806f, 0.01087655f, -0.00484682f, 0.01800505f, -0.01301402f, -0.03005576f, -0.02035135f, -0.03322744f, 
    -0.00349398f, 0.00873409f, 0.01050845f, 0.00538710f, 0.02718282f, -0.00906109f, 0.01901902f, 0.01236701f, 
    0.00104017f, -0.01931912f, -0.02774608f, -0.02014366f, 0.02794419f, -0.02062130f, -0.03967584f, 0.00565012f, 
    0.02750977f, -0.00477278f, -0.03113578f, -0.01097879f, 0.00292771f, 0.02890117f, 0.01035863f, -0.02127344f, 
    0.00622286f, -0.00638441f, -0.03267071f, -0.01278515f, 0.01904316f, 0.00671137f, -0.00580482f, -0.00195245f, 
    0.00314787f, 0.00003820f, -0.00153224f, 0.00948672f, -0.01330870f, 0.02530760f, -0.01385776f, -0.03974169f, 
    -0.02078238f, -0.01645098f, -0.01743537f, -0.01873313f, 0.01276569f, -0.01256934f, 0.02419261f, 0.01363766f, 
    0.00060004f, -0.03176383f, 0.01276843f, -0.00869671f, -0.02551676f, -0.01772901f, 0.02411314f, 0.00818866f, 
    -0.01258231f, 0.03355500f, -0.01366744f, -0.03849322f, -0.02295589f, -0.00906547f, -0.03213117f, -0.03375806f, 
    -0.00562854f, 0.00869601f, -0.00855207f, 0.00123712f, 0.00440009f, -0.01344108f, 0.01461589f, -0.00437186f, 
    0.00821001f, -0.04020949f, 0.01891825f, -0.03087060f, -0.02081270f, 0.01000542f, -0.01773618f, -0.01301056f, 
    0.01262386f, 0.00921260f, -0.01547990f, -0.01783668f, -0.01849255f, -0.01570975f, -0.01241099f, -0.02196713f, 
    0.02806688f, -0.02575724f, -0.02306346f, -0.00902721f, -0.00479547f, 0.01981720f, 0.02416774f, -0.02018723f, 
    -0.03707777f, -0.02502928f, 0.02371076f, -0.00220234f, -0.01385401f, -0.01630445f, -0.00499630f, 0.00647067f, 
    -0.00726000f, -0.01643279f, -0.02026004f, -0.02723696f, -0.01249833f, 0.01597931f, 0.01396736f, -0.01423674f, 
    -0.01199206f, -0.02129708f, 0.00472284f, 0.01490578f, -0.00157076f, 0.00749664f, -0.00175028f, 0.00150565f, 
    -0.03893610f, -0.03021462f, -0.02486981f, -0.01797888f, 0.01112587f, -0.01902084f, 0.01117641f, -0.02682389f, 
    -0.02631190f, -0.03755166f, -0.02957412f, -0.03381252f, 0.02830830f, -0.00289121f, -0.02716048f, 0.02520070f, 
    -0.01647548f, -0.00013014f, 0.02821409f, -0.03834919f, 0.02919430f, 0.00011425f, 0.00656252f, -0.02922842f, 
    -0.00388333f, -0.01790946f, 0.00346789f, -0.00148044f, -0.02826897f, 0.02206718f, 0.00787880f, 0.02796534f, 
    0.03946937f, -0.02759521f, -0.01357526f, -0.01429135f, 0.02900484f, 0.03348739f, 0.02155278f, 0.02946576f, 
    0.02922555f, 0.01820643f, -0.01288082f, 0.00719810f, 0.01771012f, 0.02338699f, 0.01935655f, 0.01980371f, 
    0.00027809f, -0.01394281f, 0.00174676f, -0.01593945f, 0.02020581f, -0.01564732f, -0.01152891f, 0.02565628f, 
    -0.00956939f, 0.02207053f, 0.00635871f, 0.00475610f, 0.00547189f, -0.01378925f, -0.03080713f, 0.00322083f, 
    0.02225552f, 0.01972050f, -0.01939486f, -0.02382263f, 0.02253543f, 0.03297938f, -0.03273057f, 0.00971391f, 
    -0.02395026f, -0.00325589f, -0.02824831f, -0.02721418f, -0.00144101f, 0.01177839f, -0.02969832f, 0.01472196f, 
    0.01714226f, -0.00795741f, -0.02607089f, 0.00171109f, 0.00330455f, -0.00040687f, -0.02579024f, -0.01948762f, 
    -0.03381398f, 0.01958576f, -0.02906959f, 0.00333557f, -0.00636651f, 0.00948136f, -0.01183137f, -0.01484042f, 
    0.00017647f, -0.03387698f, 0.01807339f, 0.01532776f, -0.01435730f, -0.01902021f, -0.04133722f, 0.00103949f, 
    -0.01230270f, 0.02171886f, -0.03467191f, -0.03654705f, -0.00794506f, 0.02279290f, -0.02637952f, -0.02163441f, 
    -0.00801081f, -0.02642313f, -0.03716751f, -0.02713657f, -0.01606265f, 0.00631248f, -0.01939437f, 0.02066989f, 
    -0.01918798f, -0.00126944f, -0.01858960f, 0.02614047f, 0.01111446f, 0.01467005f, 0.02370510f, 0.00076071f, 
    0.01724520f, -0.01068149f, 0.01288757f, -0.00303444f, -0.01023040f, 0.02213074f, -0.03348641f, -0.01897275f, 
    -0.01164463f, 0.02886263f, 0.00248318f, -0.00136239f, -0.00721995f, 0.02492259f, 0.02428071f, -0.03683731f, 
    0.03102730f, -0.02203581f, 0.03242052f, 0.01564305f, 0.02171697f, 0.01614859f, -0.01484466f, 0.01730549f, 
    -0.02081257f, -0.00761756f, 0.00235580f, -0.00108092f, -0.03438069f, 0.03052705f, -0.00312947f, -0.01111064f, 
    0.00982531f, -0.02737473f, 0.02999690f, -0.00029051f, 0.01872347f, -0.00034277f, -0.01789138f, -0.02813670f, 
    0.00529187f, 0.01062587f, -0.03544942f, 0.01842533f, 0.02715116f, -0.02176603f, -0.00572000f, -0.01986885f, 
    -0.02791068f, 0.01610163f, -0.02026781f, -0.00151744f, 0.00749548f, 0.01319739f, -0.00646987f, 0.01398018f, 
    -0.00606260f, 0.01835552f, -0.03139411f, -0.00461924f, -0.02997326f, -0.03554858f, -0.00209764f, 0.02079283f, 
    0.02648068f, 0.02693329f, -0.03698887f, 0.02016421f, -0.02525205f, 0.00455934f, 0.02298055f, 0.02016223f, 
    0.00336490f, -0.03936350f, -0.00971333f, -0.03035495f, -0.02596860f, -0.02481312f, -0.02054309f, -0.02039093f, 
    0.03254124f, -0.01472727f, -0.02986977f, 0.01914567f, -0.00325896f, 0.01591151f, 0.02719661f, 0.00715872f, 
    0.00356516f, -0.03060029f, 0.02318379f, -0.00737221f, 0.02735519f, -0.01624859f, -0.02466629f, -0.02002672f, 
    0.02473312f, -0.01806224f, 0.01892560f, -0.02410928f, 0.01068767f, -0.04127049f, 0.02302799f, -0.01652439f, 
    -0.01706732f, -0.01910985f, -0.03501286f, 0.01503787f, 0.02141539f, -0.03608922f, -0.02390132f, -0.01501598f, 
    -0.01148135f, 0.01734390f, 0.00931601f, -0.01317209f, 0.01322419f, 0.02146969f, -0.02962978f, -0.03991595f, 
    -0.00056127f, -0.00640640f, -0.02232181f, -0.04247677f, 0.00015373f, -0.01724475f, -0.03769026f, 0.00606401f, 
    -0.02765045f, -0.04263068f, 0.00710571f, -0.01546989f, -0.03511303f, -0.01305109f, -0.02870673f, -0.02524810f, 
    0.01855934f, -0.03401083f, -0.00780062f, 0.01496874f, -0.03114275f, -0.02378337f, -0.00704843f, 0.00489251f, 
    0.01628971f, -0.03263644f, 0.01717033f, -0.03924942f, 0.00534817f, -0.03611828f, -0.01288177f, 0.03015942f, 
    -0.01252716f, -0.04328502f, 0.00907701f, -0.00917175f, 0.02302331f, 0.02413870f, -0.00952332f, -0.02587089f, 
    0.00928781f, -0.01405298f, -0.01256128f, -0.02360041f, 0.02839793f, 0.02461722f, 0.02599549f, -0.03086728f, 
    -0.03225736f, -0.03462217f, 0.00152396f, 0.03067050f, 0.01661236f, -0.01927606f, -0.00055639f, -0.02067068f, 
    0.01058818f, -0.02834340f, -0.02215081f, 0.02356956f, -0.03512320f, -0.00709766f, -0.02084499f, 0.01006881f, 
    0.00023252f, -0.01742820f, 0.02875945f, -0.00306530f, -0.04281000f, -0.00107644f, -0.02407276f, -0.03560245f, 
    -0.00177873f, 0.02236667f, 0.02115060f, -0.00200507f, 0.00089283f, 0.01134572f, -0.01275691f, 0.02363237f, 
    -0.03822399f, 0.00947539f, 0.01173261f, 0.00028461f, -0.01558303f, 0.01663238f, -0.02477589f, -0.01605275f, 
    0.02733034f, 0.01888408f, 0.01993773f, 0.01954742f, -0.00997024f, 0.01338934f, -0.03534165f, 0.02055965f, 
    0.02501522f, 0.01843181f, -0.00121902f, 0.03290020f, -0.00173195f, -0.03093942f, 0.02827736f, -0.00251122f, 
    0.00416563f, -0.02387504f, -0.01815416f, -0.02015468f, -0.00740350f, 0.02546383f, 0.00341661f, -0.01270118f, 
    0.01590193f, 0.00166426f, -0.00032826f, 0.02661902f, -0.03490544f, 0.02560573f, 0.02627627f, 0.01091103f, 
    -0.02310027f, 0.00227546f, 0.01991672f, 0.02481893f, -0.00253326f, 0.01625640f, -0.04372286f, 0.02428144f, 
    -0.03395325f, 0.01012982f, -0.01001196f, -0.01907561f, -0.01162539f, -0.01529132f, -0.03453789f, -0.00059043f, 
    -0.00233866f, -0.01586485f, -0.01203885f, 0.01445583f, 0.00249717f, -0.00795031f, -0.03403766f, 0.00582791f, 
    0.01499124f, -0.00933261f, 0.00450597f, -0.04024348f, 0.01862781f, -0.00682094f, 0.00411460f, 0.01072257f, 
    -0.01258834f, 0.04197076f, 0.00018745f, 0.03274404f, -0.00981553f, -0.01927678f, 0.02466331f, -0.01939936f, 
    -0.02201191f, 0.02384553f, -0.03643965f, -0.01010922f, 0.01760611f, -0.03755679f, 0.00452771f, -0.00099081f, 
    0.02880949f, -0.03989065f, -0.04379922f, 0.00066689f, -0.00655125f, -0.02360229f, 0.02914824f, -0.01079705f, 
    -0.02887966f, 0.01735607f, 0.00460915f, -0.00847951f, 0.00867221f, 0.02142359f, 0.01767061f, 0.00307758f, 
    -0.02513889f, -0.03023390f, 0.00102334f, 0.01057145f, -0.02022494f, -0.03904451f, 0.01858453f, -0.00097564f, 
    -0.00723691f, 0.02195528f, 0.00458528f, -0.01915092f, -0.02879384f, -0.04099434f, -0.01741201f, -0.04153996f, 
    -0.01722692f, -0.02320036f, -0.03069958f, 0.01007668f, 0.02678671f, -0.01633211f, 0.02532386f, -0.02440172f, 
    -0.00234691f, -0.03131169f, 0.00306414f, 0.03852661f, 0.00484613f, 0.00363072f, -0.00054258f, 0.00357192f, 
    0.00784434f, 0.02005943f, -0.02729726f, 0.01946818f, -0.04226653f, -0.03008248f, 0.02017613f, -0.02839625f, 
    -0.03649966f, 0.00337743f, 0.00832671f, -0.02395047f, -0.04004687f, 0.01991793f, 0.02353566f, -0.01177608f, 
    -0.00997193f, -0.02218170f, 0.01498727f, -0.00961259f, 0.01693871f, 0.01284400f, 0.01537843f, -0.02994339f, 
    0.01732713f, -0.00016607f, -0.00814435f, -0.01303118f, -0.01199112f, -0.02933374f, -0.03532444f, 0.00183810f, 
    -0.00476738f, 0.01154136f, -0.00206401f, -0.03177479f, 0.00863899f, -0.01014695f, 0.02730889f, 0.00262473f, 
    0.00703173f, -0.01374689f, 0.02507270f, -0.01022343f, 0.02202757f, 0.02056791f, -0.00442128f, -0.01406856f, 
    0.01521463f, -0.02465835f, 0.00309718f, -0.00666644f, -0.01476534f, 0.00056641f, -0.01732971f, 0.01338000f, 
    0.01688705f, -0.02145270f, 0.00629704f, -0.00217497f, -0.00796340f, -0.00532868f, -0.00422343f, 0.02358796f, 
    -0.01165268f, 0.01272466f, -0.03652313f, -0.02075138f, -0.02763681f, -0.00994864f, -0.00666482f, 0.01461004f, 
    -0.02008638f, 0.01618012f, -0.02203348f, -0.01696436f, 0.00308614f, -0.02010931f, 0.00752063f, 0.00390080f, 
    0.00832341f, -0.03133198f, -0.01438666f, 0.01694476f, -0.01490066f, -0.04326713f, -0.01406430f, 0.01935624f, 
    -0.02338291f, 0.01244172f, -0.01206257f, -0.00457828f, 0.00405794f, 0.01711660f, -0.01452056f, -0.04012274f, 
    -0.03483785f, 0.00204153f, -0.01464994f, -0.02242506f, -0.01499813f, -0.03268752f, 0.01106899f, -0.02187834f, 
    -0.03802437f, -0.01519712f, 0.00995566f, 0.00595029f, -0.03269862f, -0.03839785f, 0.00648882f, 0.01087001f, 
    0.03291934f, -0.00268559f, -0.02763189f, 0.02795914f, -0.01841659f, -0.01017391f, -0.01503723f, -0.03907020f, 
    -0.00436600f, -0.02923770f, -0.01553572f, 0.02585649f, -0.03022623f, -0.03052624f, 0.00251585f, -0.01353442f, 
    0.01199452f, -0.00359759f, -0.02689541f, -0.02483764f, -0.01555033f, 0.01025539f, -0.01332215f, 0.01684032f, 
    -0.04254518f, -0.02534360f, 0.00388456f, -0.00659796f, -0.04022753f, -0.03380214f, 0.01355764f, -0.01988510f, 
    -0.01947217f, 0.01032234f, -0.01231695f, -0.01999508f, -0.01560132f, 0.00956956f, -0.02451209f, -0.01096962f, 
    -0.00029006f, -0.04142900f, -0.03864785f, 0.00709006f, 0.02015672f, 0.02575121f, -0.03764570f, -0.03285063f, 
    -0.02829546f, -0.02427481f, 0.02145819f, -0.01622439f, -0.00535384f, 0.00859710f, -0.02846966f, 0.02373101f, 
    -0.04143296f, -0.01384251f, -0.00849396f, -0.02046256f, -0.02664903f, -0.01658820f, -0.00231322f, 0.00089978f, 
    -0.02455689f, 0.02912112f, -0.00419350f, 0.00174407f, -0.01133863f, 0.00004453f, 0.00324850f, -0.01425622f, 
    0.01088833f, -0.02942173f, -0.04239330f, 0.00311331f, 0.00432157f, 0.02207461f, -0.03519399f, -0.03405725f, 
    0.01007304f, 0.00129415f, 0.00138129f, -0.02879960f, -0.04212496f, 0.01377925f, 0.02217187f, 0.01448104f, 
    0.02696698f, 0.02214286f, 0.00823489f, -0.02472068f, -0.01386153f, 0.02804697f, -0.02301717f, -0.03024653f, 
    -0.02596110f, 0.01447822f, 0.00211938f, -0.02212445f, -0.00448634f, -0.02427477f, 0.01492263f, 0.01862619f, 
    0.00004506f, -0.02043496f, -0.03075668f, -0.03200817f, 0.03047653f, -0.01509480f, 0.00492087f, -0.03187616f, 
    -0.03347845f, 0.00307548f, -0.01017625f, -0.01176724f, -0.02889443f, -0.03485589f, -0.00871636f, 0.00159520f, 
    -0.03062679f, -0.04399862f, 0.00658651f, 0.00118601f, -0.02021776f, -0.02382889f, -0.00882268f, 0.00933006f, 
    0.02729304f, -0.02757039f, 0.02684855f, -0.00796965f, -0.02999343f, -0.03886007f, -0.01137001f, -0.03087791f, 
    -0.01388216f, -0.01973250f, -0.01067664f, -0.01349599f, -0.01089493f, 0.02343246f, -0.01228276f, -0.00842622f, 
    0.01526924f, 0.02092412f, -0.02948249f, 0.03431387f, 0.00980248f, -0.03134762f, 0.00300873f, -0.04263855f, 
    0.02647779f, 0.02824581f, -0.01174965f, -0.02534751f, -0.03844038f, 0.02906509f, -0.01107717f, 0.00234668f, 
    -0.02075040f, 0.00910458f, -0.02083597f, 0.02779450f, -0.00750096f, 0.00884291f, -0.01553054f, 0.00434072f, 
    -0.03380276f, 0.00676711f, -0.00642950f, 0.00335553f, -0.02008217f, -0.00938983f, 0.00136834f, 0.00605963f, 
    -0.01584500f, -0.00049216f, -0.01812761f, 0.02739033f, -0.00224162f, 0.00809651f, -0.03455171f, -0.00121299f, 
    0.01729301f, -0.03952381f, -0.03252286f, 0.00574367f, 0.01679759f, 0.01302143f, 0.00910392f, 0.01170117f, 
    -0.00964326f, 0.03262998f, 0.02303512f, -0.02982877f, 0.02105398f, -0.02919452f, -0.00258962f, -0.00058187f, 
    -0.02066795f, -0.01978863f, -0.00805761f, -0.01046170f, -0.02467958f, -0.01373092f, 0.04218882f, -0.02047051f, 
    0.02988614f, -0.01980209f, -0.02421249f, -0.02980149f, -0.01177628f, 0.01210897f, -0.00429143f, 0.01406822f, 
    -0.03110927f, 0.00147433f, -0.02746118f, -0.03245084f, -0.01258966f, -0.02278719f, 0.02973867f, 0.00593919f, 
    0.00376355f, 0.02473304f, -0.01395554f, 0.00317260f, -0.02719715f, 0.00395242f, 0.01666954f, -0.00984711f, 
    0.01414318f, -0.03740081f, -0.04455110f, -0.03795391f, 0.01243805f, -0.00574042f, -0.02799502f, -0.00413091f, 
    0.02109529f, -0.01867832f, -0.02906380f, -0.01256215f, -0.02664555f, 0.00977331f, -0.00644720f, -0.01912737f, 
    -0.03517678f, -0.00246662f, 0.01878288f, -0.00847429f, 0.00068015f, 0.01478966f, 0.01632681f, -0.03242987f, 
    -0.01268785f, -0.03389665f, -0.02092444f, -0.00950224f, -0.00890454f, 0.00510150f, 0.01087775f, 0.02358497f, 
    -0.02516740f, 0.01711269f, -0.01746372f, -0.04138037f, -0.01477706f, -0.03567726f, -0.01031842f, 0.00063764f, 
    -0.03499451f, -0.02896253f, 0.01366209f, 0.01556082f, -0.03491534f, 0.02540716f, 0.00800029f, 0.01499820f, 
    0.01370068f, -0.03503521f, -0.02496496f, -0.02850289f, 0.02866421f, -0.00807675f, -0.02023504f, 0.00829431f, 
    -0.01360821f, 0.02279931f, -0.01475438f, -0.01250047f, -0.03556461f, -0.01895746f, 0.01573076f, -0.01215911f, 
    0.03254639f, 0.01484266f, 0.00314117f, 0.01764455f, -0.00831085f, 0.01366462f, 0.02134618f, -0.02868059f, 
    -0.01282841f, -0.03948693f, -0.03838070f, 0.02202393f, 0.00035411f, 0.00648261f, -0.02467168f, -0.02628558f, 
    0.02292780f, 0.00438084f, -0.00335830f, 0.02861482f, -0.01826295f, -0.03010643f, -0.01797138f, -0.00821168f, 
    -0.00349061f, -0.04333280f, -0.00364046f, 0.00329034f, -0.01427674f, 0.01485145f, 0.01518001f, -0.02490409f, 
    -0.02731437f, -0.02929784f, -0.00241940f, 0.01761730f, 0.02847592f, 0.02341654f, 0.00845871f, 0.01696505f, 
    0.01656701f, -0.01504401f, -0.02596548f, 0.00467916f, -0.02341812f, -0.03760179f, -0.01986145f, 0.00907830f, 
    -0.03828692f, -0.00283582f, -0.01608399f, -0.02284738f, 0.01981293f, -0.01157016f, -0.01144184f, -0.00339354f, 
    -0.03417104f, -0.01055399f, 0.00127189f, -0.04332136f, 0.00710986f, -0.01418482f, -0.01412847f, 0.00342103f, 
    -0.01854361f, 0.01959767f, -0.00778156f, -0.03151813f, 0.01620379f, 0.01974172f, -0.01920419f, -0.02370163f, 
    -0.00008518f, -0.00764275f, 0.01090254f, 0.00950152f, -0.03854030f, -0.04031365f, -0.01870532f, 0.00481998f, 
    0.01339306f, 0.00529429f, -0.02503687f, 0.00259898f, -0.01320694f, 0.00161235f, -0.04277541f, -0.02962168f, 
    0.00298463f, 0.00426205f, 0.01284599f, -0.02282380f, -0.00174222f, -0.00064188f, 0.00801380f, 0.00830022f, 
    -0.00811460f, -0.03607881f, -0.01896071f, -0.00329494f, 0.01409210f, 0.01812109f, 0.01097998f, -0.01541374f, 
    -0.02611883f, -0.03410417f, 0.00492185f, -0.01731708f, 0.00880926f, 0.02835423f, 0.00639336f, 0.00359881f, 
    -0.00623753f, -0.01219562f, -0.01747883f, -0.01372732f, -0.01289060f, 0.03056202f, 0.01902070f, 0.02301546f, 
    -0.01810381f, 0.03238993f, -0.01980848f, -0.00933233f, 0.00439626f, -0.00155947f, 0.00401900f, 0.00989031f, 
    -0.04022426f, 0.01102613f, 0.02494713f, -0.02753764f, 0.00067046f, -0.02444730f, 0.01635402f, 0.00654155f, 
    0.01944399f, -0.01732442f, -0.01283620f, 0.00802263f, 0.00773461f, -0.00612726f, -0.02802723f, -0.00167723f, 
    -0.02704948f, 0.03035320f, 0.00465587f, 0.00158507f, -0.00764964f, -0.01958690f, -0.04270019f, -0.00787248f, 
    0.02072974f, -0.03537595f, -0.03626754f, -0.01296662f, -0.00485147f, -0.02547841f, -0.01300879f, -0.01650355f, 
    -0.02452786f, -0.00175766f, 0.01012804f, -0.00185244f, -0.01018829f, 0.00631134f, -0.02839825f, -0.02749359f, 
    -0.03826785f, 0.03031955f, -0.01605069f, -0.03861599f, -0.01676831f, 0.01275576f, -0.00709945f, -0.01852560f, 
    0.00518596f, 0.00122098f, 0.01142453f, -0.03009933f, 0.02716311f, 0.00911532f, -0.00672113f, 0.00459660f, 
    0.02024545f, 0.00829452f, -0.03219517f, -0.01241343f, -0.00428797f, 0.00078881f, -0.02134747f, -0.00769287f, 
    0.02393395f, 0.00549178f, 0.02933898f, 0.00442784f, -0.00248051f, -0.00493704f, 0.02444704f, -0.01003174f, 
    -0.00620579f, -0.00862744f, 0.02523210f, -0.03998305f, -0.03647863f, 0.02424716f, 0.02314935f, 0.01099913f, 
    0.00767102f, -0.03787601f, 0.02714772f, -0.01629515f, -0.03907802f, -0.01004487f, -0.00324109f, 0.02860585f, 
    -0.01071618f, -0.03971432f, -0.03669566f, -0.00553018f, 0.00538185f, -0.00469428f, -0.02169501f, -0.03435737f, 
    0.00894268f, 0.00602243f, 0.01404708f, -0.01501741f, -0.01976635f, 0.02912347f, 0.01192946f, -0.01018332f, 
    0.01120031f, -0.03532958f, -0.04285815f, 0.02304855f, 0.01917340f, 0.02886663f, 0.01431818f, -0.00773071f, 
    -0.03232486f, -0.04055112f, 0.02246275f, 0.00471595f, 0.00211830f, 0.02758774f, 0.02057639f, -0.02299666f, 
    -0.01782329f, 0.01277582f, -0.02708426f, -0.02867914f, -0.04472138f, 0.00891189f, 0.02110800f, -0.02453380f, 
    0.00864104f, 0.01068616f, -0.03057648f, -0.00114433f, -0.01533031f, -0.01138741f, -0.02019660f, -0.00692625f, 
    -0.00650567f, 0.00042984f, -0.04153917f, 0.02553845f, 0.02151152f, -0.02359812f, 0.01413678f, -0.03058632f, 
    0.03429930f, -0.03283690f, 0.02721219f, 0.01513252f, -0.01872796f, -0.03476550f, -0.02208626f, 0.00421447f, 
    -0.04010843f, 0.01192553f, -0.02110229f, -0.02459025f, -0.02557686f, -0.00804248f, 0.02251315f, 0.00981830f, 
    0.03003790f, 0.00509954f, -0.01973234f, -0.00931569f, 0.00069972f, -0.00202181f, 0.00649797f, 0.01420472f, 
    -0.02083525f, -0.03746483f, -0.00485998f, -0.00730362f, 0.02350453f, 0.00533081f, -0.01704286f, 0.00996576f, 
    -0.01121173f, 0.03890871f, -0.01763358f, 0.02210316f, -0.02973529f, -0.00187622f, 0.00585375f, -0.03405609f, 
    0.02234745f, 0.00167486f, 0.02950405f, 0.02022390f, 0.02377902f, -0.00809098f, -0.00289836f, 0.02087107f, 
    -0.03924045f, -0.04114182f, -0.04358293f, -0.00499654f, 0.01191059f, -0.03787314f, -0.03406812f, -0.00437485f, 
    0.01075079f, -0.01747499f, -0.01549374f, 0.02186059f, -0.00190638f, -0.00822720f, 0.02543539f, 0.01126943f, 
    -0.01972759f, -0.03748641f, -0.02591853f, 0.01153323f, -0.03095627f, 0.02675540f, -0.04066043f, -0.02979556f, 
    0.00219314f, 0.00428324f, -0.01620340f, -0.02956455f, 0.02871959f, -0.00766140f, -0.01525404f, 0.00126535f, 
    0.02698183f, -0.01333429f, -0.01497452f, -0.01319960f, 0.02716981f, -0.02389832f, -0.02717393f, -0.02411222f, 
    0.01883725f, -0.03219979f, -0.00968298f, 0.01856186f, -0.00327575f, -0.03715995f, -0.02248630f, 0.00679361f, 
    0.02948193f, -0.01576435f, -0.03499898f, -0.02179593f, -0.03147852f, -0.00046831f, 0.01406750f, 0.03027430f, 
    -0.04031440f, 0.02306790f, -0.02048163f, -0.01961682f, 0.01865454f, 0.02310916f, -0.00085762f, 0.01915091f, 
    0.02741151f, 0.00413166f, -0.02424841f, -0.03191424f, 0.02746035f, 0.02944151f, -0.03149513f, 0.02323015f, 
    -0.00541805f, 0.01578309f, 0.01248231f, -0.03901327f, -0.00621704f, -0.00572085f, -0.00211258f, -0.03533344f, 
    0.00910332f, 0.00465165f, -0.01180154f, -0.03153598f, 0.01590295f, 0.01442154f, 0.02289748f, 0.01613323f, 
    -0.01875207f, -0.02965444f, -0.02475663f, -0.03830054f, -0.01340371f, 0.00272684f, 0.02700822f, -0.00934802f, 
    0.02073888f, -0.02348078f, 0.00414710f, -0.02465118f, -0.02991802f, -0.00841855f, 0.01088186f, 0.01186713f, 
    0.01497870f, -0.01727353f, 0.00342744f, 0.01819214f, -0.00424024f, 0.02023982f, -0.04058720f, 0.02976727f, 
    -0.00658676f, 0.02152719f, -0.03850370f, -0.03933895f, -0.03988041f, -0.02512870f, 0.03515775f, -0.01940485f, 
    0.01124973f, 0.00580981f, 0.01781117f, -0.04168104f, -0.00477473f, -0.02106777f, -0.01669913f, 0.00657910f, 
    -0.01648625f, 0.02409617f, 0.03302411f, -0.03185816f, -0.02828139f, 0.02052744f, -0.02848559f, -0.00367943f, 
    0.00108524f, -0.02865567f, 0.01523484f, -0.03177622f, -0.03964117f, 0.00819481f, -0.01325237f, 0.01660743f, 
    0.01795551f, -0.02995200f, -0.01809333f, -0.00826020f, -0.01587495f, -0.01732959f, 0.00703217f, -0.02556781f, 
    -0.02271273f, -0.02862001f, 0.02127492f, -0.02103661f, -0.01217316f, -0.04718831f, 0.01294431f, -0.03814707f, 
    -0.04041506f, -0.00810340f, 0.00123196f, 0.00496249f, 0.01464908f, -0.00722076f, -0.01372328f, 0.01915490f, 
    0.00154661f, 0.02829533f, -0.00976437f, 0.02558129f, 0.00136037f, -0.01301925f, 0.00538776f, -0.02052364f, 
    0.00130916f, 0.02963783f, -0.01928943f, 0.01959085f, -0.00511070f, -0.03668690f, -0.02039504f, -0.02778553f, 
    0.02036081f, -0.00451504f, -0.01323738f, 0.02118087f, -0.01363396f, 0.02582773f, -0.03442922f, 0.00841082f, 
    -0.01289581f, -0.01136097f, 0.02561644f, -0.00395110f, -0.01824788f, -0.01381840f, -0.02601620f, -0.01629948f, 
    -0.01955577f, -0.01969041f, -0.00714599f, -0.00145295f, -0.01912558f, -0.02565004f, -0.04098209f, -0.01379048f, 
    0.00985857f, -0.02052079f, -0.01792569f, 0.01595848f, -0.03604815f, -0.03375456f, 0.01992100f, -0.02396003f, 
    0.01774190f, 0.00207370f, -0.00414497f, -0.00717175f, -0.01249234f, 0.00587093f, -0.04138437f, 0.01151988f, 
    -0.01961353f, -0.01698908f, -0.03118193f, 0.00727080f, -0.03532356f, 0.00293299f, -0.00398844f, 0.00104727f, 
    0.00123035f, -0.00701728f, -0.03389857f, -0.03219431f, -0.01053819f, -0.00047606f, -0.03264949f, -0.01908170f, 
    0.01288531f, 0.01819522f, 0.00347714f, -0.04166679f, 0.01027399f, -0.02847273f, -0.02971365f, -0.03690626f, 
    -0.03047524f, -0.01579575f, -0.02485788f, -0.03110233f, -0.00803364f, -0.00317142f, -0.01871909f, -0.03706852f, 
    0.00681999f, 0.02157066f, -0.02569022f, -0.00948326f, -0.03779961f, 0.02099147f, -0.01351949f, 0.02152592f, 
    0.01404759f, -0.04463239f, 0.00172928f, -0.02265625f, 0.02968017f, -0.00347092f, -0.02089804f, -0.01476486f, 
    0.01474485f, 0.00666710f, 0.02006514f, 0.02564162f, 0.00131457f, 0.02745496f, 0.01736422f, -0.03026780f, 
    -0.00994572f, 0.01066120f, 0.02237757f, -0.00632321f, -0.03445610f, 0.01075773f, 0.02364594f, -0.02625937f, 
    -0.01668217f, 0.00944087f, 0.02378129f, -0.02739440f, 0.02470782f, -0.03728928f, 0.00466781f, -0.01025208f, 
    0.02355863f, 0.00812907f, -0.03651765f, -0.04180823f, -0.01018812f, 0.02578017f, -0.02320693f, 0.00190363f, 
    -0.01195473f, 0.03354928f, -0.01651970f, 0.01625109f, 0.01336764f, 0.01118045f, 0.01292900f, -0.01663873f, 
    0.01419802f, -0.01415806f, 0.02299111f, 0.01709107f, -0.03472720f, -0.01636474f, -0.01287347f, 0.01366180f, 
    -0.00146282f, -0.01087845f, -0.01140271f, -0.01000270f, 0.01612158f, 0.00709098f, 0.03054892f, -0.00830004f, 
    0.02140810f, -0.01866697f, 0.02128120f, 0.00680838f, -0.02476784f, 0.02225511f, 0.00045004f, 0.01187254f, 
    0.01981492f, -0.02368790f, -0.01157582f, 0.00063531f, 0.02271940f, -0.01079679f, 0.01031026f, 0.01998886f, 
    -0.01691125f, -0.02029341f, 0.02346791f, -0.00197978f, -0.02179164f, 0.00889374f, -0.01882075f, -0.01102010f, 
    -0.02956364f, 0.00414124f, 0.01668183f, -0.01027915f, 0.00441054f, -0.00258909f, -0.00975953f, -0.02234457f, 
    0.00582241f, -0.00583344f, 0.02286478f, -0.00337909f, 0.02325964f, -0.03058281f, -0.00803483f, 0.00353262f, 
    -0.04155828f, -0.01117514f, -0.01351963f, 0.00886837f, -0.01830304f, -0.04536127f, 0.02644356f, -0.00968274f, 
    -0.03586654f, 0.02673867f, -0.00324808f, -0.03148265f, -0.02009957f, -0.03590599f, -0.00102725f, 0.01509889f, 
    -0.03697252f, -0.00762844f, -0.01507955f, -0.03062838f, -0.01919319f, 0.01429005f, -0.00323941f, -0.00813572f, 
    0.11178210f, 0.20040539f, 0.11198904f, 0.04851245f, 0.05920453f, -0.06875829f, 0.07534970f, -0.10327639f, 
    -0.03071701f, -0.10469662f, 0.01727800f, 0.19485895f, -0.27362591f, 0.01169384f, 0.03275446f, -0.00157645f, 
    0.03100314f, -0.05144828f, -0.02507514f, 0.00071903f, -0.02624211f, -0.07713506f, 0.08918274f, -0.09200162f, 
    -0.23916607f, -0.17566986f, -0.09872928f, -0.14002872f, 0.02605210f, 0.13756157f, -0.00535104f, -0.11715645f, 
    -0.02570515f, 0.11467610f, 0.09888782f, -0.07095059f, -0.19242431f, -0.12896876f, -0.02259002f, 0.06320287f, 
    0.05734808f, 0.04742976f, 0.06122305f, 0.04158266f, -0.00274214f, -0.04997731f, -0.03001765f, 0.05537769f, 
    0.16285366f, -0.04789939f, 0.02587031f, -0.00959215f, 0.02625428f, -0.09392405f, -0.08264964f, -0.00992639f, 
    0.05917289f, -0.07665076f, 0.08160680f, 0.03607645f, -0.14371167f, -0.18986122f, 0.10763148f, 0.01579470f, 
    -0.03773198f, -0.00390256f, -0.00580478f, 0.13586934f, 0.07460678f, -0.09951699f, -0.00897366f, -0.02534450f, 
    -0.06355566f, 0.10709797f, 0.15916307f, 0.02945913f, 0.08252960f, 0.04606737f, -0.01701288f, 0.03886809f, 
    0.12682070f, 0.02373542f, 0.02551649f, -0.02837510f, -0.03831412f, 0.24499075f, 0.13561657f, -0.05688288f, 
    0.07543165f, 0.10062170f, 0.01356788f, -0.03542696f, -0.01624996f, 0.07899008f, -0.03480589f, -0.03486919f, 
    0.13900609f, -0.06465665f, 0.35104766f, -0.28281844f, -0.01450824f, 0.06628740f, -0.05634451f, 0.05573319f, 
    0.01309848f, -0.01543125f, -0.00820056f, -0.04400174f, 0.32598287f, 0.25525400f, -0.00373977f, 0.06478007f, 
    0.03779272f, 0.07915421f, 0.01653202f, -0.15558238f, -0.01729972f, -0.08603927f, 0.03545456f, -0.03208122f, 
    -0.28658691f, -0.07017464f, -0.06318118f, -0.01212404f, 0.13960566f, -0.07403547f, 0.02062314f, -0.03407497f, 
    0.08685907f, 0.03158138f, -0.02230349f, 0.05042825f, -0.03051496f, 0.06996673f, 0.27007231f, -0.06957075f, 
    0.11120126f, -0.04903001f, 0.00866074f, 0.00982707f, -0.01937819f, 0.12366412f, 0.07936106f, -0.00889738f, 
    -0.07574902f, -0.10497323f, 0.02920423f, 0.17756188f, 0.09840143f, 0.00628299f, -0.01571958f, 0.02351306f, 
    -0.02680432f, 0.09068897f, 0.04759690f, 0.06911365f, 0.15559106f, 0.24162334f, 0.16858347f, 0.04909641f, 
    0.10038869f, 0.07251371f, -0.06046577f, -0.09491736f, -0.07553519f, -0.00784132f, -0.02458207f, -0.01342286f, 
    -0.33276176f, -0.23586068f, 0.01524647f, -0.04319345f, 0.09194624f, 0.10531193f, -0.08126995f, -0.03928246f, 
    0.04806518f, 0.06121721f, 0.05903078f, -0.08336282f, -0.14124505f, -0.11060458f, -0.19370112f, 0.02738051f, 
    0.15920553f, 0.09734620f, 0.07382155f, 0.10295965f, 0.00457105f, -0.07355662f, -0.09575800f, 0.08698338f, 
    -0.39623138f, -0.19772254f, -0.08490995f, -0.00498918f, 0.01776440f, 0.04013735f, 0.07394487f, -0.00748877f, 
    0.02278916f, 0.04682872f, 0.13923556f, -0.06824096f, -0.03733988f, 0.03639169f, 0.08197205f, -0.11843738f, 
    0.07190165f, -0.08107097f, 0.11249071f, 0.05888738f, 0.02193363f, 0.02738283f, 0.02639559f, -0.03789716f, 
    -0.24094014f, -0.11322768f, 0.12549667f, 0.01108406f, 0.02976379f, 0.08707912f, -0.04147008f, 0.00661189f, 
    -0.14394878f, -0.04598485f, 0.02514944f, 0.13296032f, 0.48680583f, -0.00376917f, 0.08230323f, 0.12227390f, 
    0.03300149f, 0.01193508f, -0.00915304f, -0.03154196f, 0.07964040f, 0.02367609f, 0.06042386f, 0.10689922f, 
    0.04413877f, -0.09748727f, 0.01120557f, -0.04013970f, -0.09023693f, -0.03702440f, 0.02605180f, 0.09565104f, 
    -0.01517752f, 0.06311060f, -0.08818624f, -0.04736507f, 0.07201936f, 0.29374161f, 0.00618591f, 0.13755116f, 
    0.03178342f, 0.11900297f, 0.11011101f, -0.00401169f, -0.13119729f, -0.05180209f, -0.12520964f, 0.06527078f, 
    0.15215719f, -0.00451660f, -0.03868050f, 0.33160254f, 0.01184521f, 0.13966720f, 0.06453731f, -0.00441803f, 
    0.16557603f, 0.05547477f, -0.00684330f, 0.11233781f, -0.01727668f, -0.07232062f, 0.08564513f, -0.19847773f, 
    0.05131520f, 0.09583599f, -0.05586129f, -0.03306754f, 0.07507616f, -0.03985913f, 0.07218650f, 0.09187873f, 
    -0.24567056f, 0.06945758f, -0.03953568f, -0.14851154f, 0.08712402f, 0.01249318f, 0.01035619f, -0.14550959f, 
    -0.07265075f, 0.06835937f, -0.01482750f, -0.05171098f, -0.04341052f, 0.16739267f, -0.05522808f, -0.17693223f, 
    0.16412231f, -0.02036195f, -0.03714295f, 0.01278119f, 0.05887798f, -0.00212746f, 0.04803296f, 0.10759623f, 
    -0.17809561f, -0.27352485f, -0.14147863f, 0.08481135f, -0.05287639f, 0.04707670f, 0.09068289f, -0.00950969f, 
    -0.02212785f, -0.12836120f, -0.07464994f, -0.01625991f, -0.36425415f, -0.14705166f, -0.27846220f, 0.02837428f, 
    0.05626975f, 0.00458082f, -0.01460049f, 0.05292730f, -0.06008899f, 0.00343349f, -0.04251234f, 0.08405375f, 
    -0.14020824f, -0.14618801f, -0.10443707f, 0.04957034f, 0.09845441f, 0.05000591f, -0.10560513f, -0.03127024f, 
    -0.04341447f, -0.02712316f, -0.01273735f, 0.06987795f, 0.07817509f, -0.06482010f, -0.02506964f, 0.08555738f, 
    -0.00264072f, 0.03895797f, -0.02307654f, -0.04504582f, -0.10097874f, 0.06562233f, 0.08522416f, 0.03822396f, 
    -0.03370845f, -0.02758099f, -0.08414292f, 0.27127174f, 0.03390980f, -0.04146226f, 0.07097146f, -0.05795406f, 
    -0.04063477f, 0.10972974f, 0.03380371f, 0.03139560f, 0.11352769f, 0.13385217f, -0.01383954f, 0.10930803f, 
    0.07256734f, 0.05927660f, 0.13717473f, -0.09254353f, -0.00009022f, -0.00565484f, 0.03821930f, 0.01548655f, 
    -0.07527404f, 0.09410701f, -0.13807048f, 0.12292674f, -0.06561039f, 0.03612046f, -0.00934352f, 0.10223509f, 
    0.03623930f, -0.05714384f, 0.00543210f, -0.00933623f, -0.28340951f, -0.08810680f, -0.02284991f, 0.01158594f, 
    0.07182067f, 0.05401369f, 0.08594514f, -0.04075938f, 0.15346819f, 0.16754645f, -0.01139303f, 0.21165065f, 
    0.19235654f, 0.14604157f, 0.14929174f, 0.12136766f, 0.12730171f, -0.00441468f, -0.00760659f, 0.01904755f, 
    0.00777312f, -0.09052002f, 0.10314156f, -0.04414608f, -0.31168681f, -0.20796829f, 0.10953438f, -0.07748446f, 
    0.04012482f, 0.04206353f, 0.06419123f, -0.14069659f, -0.00211617f, 0.01126999f, 0.01196580f, 0.06477685f, 
    0.13950196f, -0.08397177f, 0.06492268f, -0.04470037f, -0.03775265f, -0.03342373f, 0.01786384f, 0.12491298f, 
    -0.10787800f, -0.02884531f, -0.01869784f, 0.12401371f, -0.11380101f, -0.32113114f, 0.01331923f, -0.00298008f, 
    -0.00945749f, -0.00859662f, 0.07428123f, -0.02929010f, 0.02755681f, 0.01619177f, 0.09599477f, -0.02070783f, 
    -0.57550156f, -0.09983050f, -0.16953208f, 0.10918669f, 0.09654690f, 0.05822824f, 0.10845596f, 0.07972172f, 
    -0.02392009f, 0.05404784f, -0.01427083f, -0.02462824f, 0.23638165f, -0.01468267f, 0.10696024f, 0.37777570f, 
    0.13740231f, 0.16598673f, -0.13771358f, -0.00318755f, -0.06969935f, 0.23705287f, 0.09600338f, -0.14993259f, 
    0.15390801f, 0.12789558f, 0.09658211f, -0.04931931f, -0.06410294f, 0.07381701f, -0.03609955f, -0.01221190f, 
    -0.04198287f, 0.02032331f, 0.08647906f, -0.02361702f, -0.22892624f, -0.47711936f, 0.00280114f, -0.04069036f, 
    -0.08652197f, 0.10514128f, 0.11052877f, -0.01654091f, 0.00362792f, -0.04184934f, 0.02078248f, 0.09055860f, 
    0.26656878f, 0.12261806f, 0.10375239f, 0.04321807f, 0.18613537f, 0.08291795f, -0.03996201f, -0.04478439f, 
    0.03627222f, 0.00082393f, 0.06295910f, 0.08802892f, -0.21196805f, -0.24639900f, -0.09690621f, 0.05730217f, 
    0.05070858f, -0.04960269f, 0.07165735f, 0.09910459f, 0.04271412f, 0.12213830f, 0.02828580f, 0.07778738f, 
    0.37366617f, 0.09618088f, 0.09753588f, 0.12036516f, -0.09175936f, 0.08334030f, 0.03809506f, 0.08185874f, 
    -0.06144980f, 0.01720662f, 0.02072278f, -0.04502878f, -0.05780283f, -0.13704790f, -0.33548802f, -0.12744626f, 
    -0.08846810f, -0.03824144f, -0.06008155f, 0.09720518f, 0.13205968f, -0.06791630f, 0.00411475f, 0.01493220f, 
    -0.04820303f, 0.01997537f, -0.03394766f, -0.26557097f, 0.10923294f, -0.06610501f, -0.10476270f, -0.02124904f, 
    -0.09430441f, -0.00096473f, 0.07461862f, 0.02465513f, 0.10074414f, 0.02824879f, 0.06073361f, 0.11300877f, 
    -0.04467196f, 0.12243225f, 0.01959917f, -0.07914036f, 0.15363455f, -0.03211713f, -0.02436904f, 0.09056982f, 
    -0.12877442f, -0.04354562f, 0.21645893f, 0.11876066f, 0.07191034f, 0.03210168f, -0.01459111f, -0.08813851f, 
    0.05208531f, -0.10308019f, 0.10054521f, 0.09282061f, 0.17217852f, 0.22289130f, 0.13874403f, 0.21139847f, 
    0.12407480f, 0.12465038f, -0.05159995f, -0.16404791f, -0.06355669f, 0.03329526f, 0.14300597f, 0.13399021f, 
    0.09108917f, 0.18983929f, 0.13441806f, -0.06240349f, 0.09858560f, -0.08240668f, -0.14610165f, 0.01555248f, 
    0.02771752f, 0.04410852f, -0.07025428f, 0.02299942f, 0.12333527f, 0.21765201f, 0.13418034f, 0.09025966f, 
    0.07254466f, 0.01570087f, -0.01677642f, -0.11485486f, 0.04188257f, 0.04380111f, 0.09388207f, 0.10630946f, 
    0.15500925f, 0.09612971f, 0.04299589f, 0.00313887f, 0.00376501f, 0.00375758f, 0.06741199f, 0.02603165f, 
    0.05058915f, 0.02948333f, -0.01801786f, 0.04809860f, -0.32522190f, 0.23795046f, -0.02792276f, -0.14494586f, 
    0.01789371f, 0.01434564f, 0.13487481f, -0.09570873f, 0.12703887f, 0.05819037f, -0.05725461f, 0.09900233f, 
    -0.18180043f, 0.02654692f, -0.02684289f, -0.07690298f, -0.07962913f, -0.09279792f, -0.03738527f, 0.12897693f, 
    0.03174850f, 0.10077191f, -0.01563012f, 0.03458154f, -0.11998978f, 0.20795333f, 0.07678737f, -0.06572467f, 
    -0.00803161f, -0.13653030f, 0.00730183f, 0.13371707f, -0.00516642f, -0.05611902f, 0.07371327f, -0.07552139f, 
    -0.17006880f, 0.01412836f, 0.06963331f, -0.15614840f, -0.01213361f, 0.02922612f, 0.08333530f, -0.06183087f, 
    0.04946313f, 0.02999328f, 0.01803182f, 0.08256517f, 0.25818729f, -0.15408981f, 0.04224743f, -0.00814032f, 
    -0.02970894f, -0.05926063f, 0.03642229f, 0.06175010f, 0.06289499f, 0.01631194f, 0.03135332f, -0.01846722f, 
    0.08018178f, 0.15301669f, 0.08728045f, -0.04353265f, 0.06650040f, 0.03023558f, -0.01301970f, 0.00728214f, 
    -0.05913534f, -0.01419638f, -0.02278579f, 0.01365743f, -0.14808476f, 0.08335309f, -0.12215099f, 0.12566164f, 
    0.21230485f, 0.02611756f, 0.12319613f, -0.07851276f, -0.03821468f, -0.18096019f, 0.01062920f, 0.10362083f, 
    0.14037493f, -0.16103204f, -0.07595658f, -0.05804649f, -0.03773830f, 0.04275674f, 0.15901907f, -0.02167856f, 
    0.05567190f, 0.05700075f, 0.02161232f, -0.06256927f, 0.35207611f, 0.00802060f, 0.10752174f, 0.05367440f, 
    -0.02640673f, 0.16836715f, -0.04250693f, 0.02800237f, 0.02735834f, 0.00122435f, 0.08972982f, 0.04918227f, 
    -0.06019867f, 0.20257317f, 0.07449531f, 0.04930026f, 0.12477680f, 0.03358945f, -0.02611410f, -0.05670308f, 
    0.05748989f, -0.00377011f, 0.00111626f, -0.02019184f, -0.06444068f, -0.21583846f, -0.06963197f, 0.01683791f, 
    0.03768657f, -0.08263110f, 0.02772855f, -0.02320250f, 0.04938927f, -0.01980846f, -0.08602569f, 0.01499523f, 
    -0.02095288f, -0.00353226f, 0.01283637f, 0.01241962f, -0.03181272f, -0.00317358f, -0.00102745f, 0.00556635f, 
    -0.00317136f, -0.03574326f, 0.00688240f, -0.01912134f, -0.00343476f, 0.00211187f, -0.02057478f, 0.02631254f, 
    0.02335896f, 0.01473403f, -0.03765858f, 0.00239178f, -0.00232867f, -0.01738000f, -0.01866640f, -0.01550259f, 
    0.01573844f, 0.00559225f, -0.01400787f, -0.00817585f, 0.00530181f, 0.01288530f, -0.02323411f, -0.00689123f, 
    -0.01003371f, 0.01214779f, -0.00011047f, -0.04360562f, -0.00053485f, 0.01436050f, -0.03921761f, -0.03974061f, 
    -0.03098436f, 0.01782853f, 0.01302883f, -0.00734009f, -0.02072371f, -0.01259489f, 0.00761120f, -0.01146939f, 
    0.00432900f, 0.03091340f, -0.02685106f, 0.02069486f, -0.02811070f, -0.00565650f, 0.03578312f, 0.01507190f, 
    0.02334562f, -0.03404943f, -0.02299468f, 0.02661095f, -0.02227944f, 0.00010559f, 0.01259101f, 0.01877757f, 
    0.00701713f, -0.04031888f, -0.01155548f, -0.02900738f, -0.01575875f, -0.02179226f, -0.00121731f, 0.02432531f, 
    0.00951099f, -0.02388188f, 0.02970921f, -0.02805619f, -0.00459200f, -0.03656667f, 0.00538967f, -0.00145068f, 
    -0.01020958f, 0.01521040f, 0.01582900f, 0.01112522f, 0.02179701f, 0.01828876f, -0.03206784f, 0.02882967f, 
    0.00375752f, 0.01668256f, 0.02517208f, 0.01290587f, -0.03322370f, -0.01844792f, 0.00041277f, -0.02284287f, 
    -0.00294091f, -0.00440471f, -0.00836071f, -0.01993741f, 0.01721436f, 0.00140195f, 0.01744146f, -0.02990365f, 
    0.02340232f, -0.00027256f, -0.03865817f, -0.00300647f, -0.02193770f, -0.04640779f, 0.02443992f, -0.01354349f, 
    0.01903568f, -0.04207695f, 0.03295059f, -0.00003871f, 0.00004508f, -0.03915297f, -0.01996222f, -0.02965090f, 
    -0.02416103f, -0.01465856f, -0.03430455f, 0.00325178f, 0.01515563f, -0.01654540f, -0.03021112f, 0.01032243f, 
    0.00684986f, 0.00515286f, -0.01037680f, 0.01000183f, -0.02023823f, -0.02029128f, -0.03714861f, 0.01075122f, 
    0.01235601f, 0.02591856f, 0.00946857f, 0.02348922f, -0.03913942f, -0.01716169f, -0.01589017f, 0.02525218f, 
    0.00347139f, -0.04727938f, -0.02172499f, -0.02051197f, -0.00624875f, -0.02030663f, 0.01382887f, 0.00282447f, 
    0.01038881f, -0.01058641f, -0.01299581f, -0.03416419f, 0.01336756f, 0.00945944f, -0.02539507f, -0.01487130f, 
    -0.00207833f, 0.00381696f, -0.02838205f, 0.02699200f, 0.00117990f, 0.00162808f, 0.00234966f, -0.03316553f, 
    -0.03479857f, -0.04969203f, -0.02247030f, 0.01335176f, 0.00752106f, -0.02682003f, 0.02543344f, -0.00931877f, 
    0.01888416f, 0.02987806f, -0.00353691f, 0.04094804f, -0.02456462f, 0.01141657f, -0.01808701f, -0.01267609f, 
    0.01740143f, 0.02331468f, 0.02596230f, 0.02762773f, -0.00895188f, -0.02263882f, -0.03629479f, -0.01084047f, 
    0.02603611f, 0.01635606f, -0.01800809f, 0.01788674f, -0.00769029f, 0.01035583f, -0.03211025f, 0.00877148f, 
    0.02148927f, 0.01141949f, 0.02419784f, 0.03152435f, -0.01289470f, -0.00492290f, 0.02140489f, -0.01035836f, 
    0.01519677f, -0.03402321f, 0.01308533f, -0.01684006f, 0.00147988f, -0.00858469f, -0.00604440f, 0.01779081f, 
    0.00337626f, 0.01259353f, -0.01781525f, 0.00567232f, -0.01235252f, 0.00385312f, 0.02256063f, -0.02410893f, 
    0.00634996f, -0.00071550f, -0.04091432f, 0.01265745f, -0.04208210f, -0.01293667f, 0.01964870f, 0.00994290f, 
    -0.04451635f, -0.03024831f, -0.01776922f, -0.00200437f, -0.01347309f, 0.00442719f, 0.01550045f, -0.01323022f, 
    0.00371394f, 0.02223329f, -0.00926372f, 0.01168931f, 0.02574469f, 0.02090134f, 0.01149184f, -0.00871731f, 
    0.01647660f, -0.00147727f, 0.00749455f, -0.04190101f, -0.00189416f, -0.00231814f, -0.02756122f, -0.02179486f, 
    -0.01437233f, 0.01249276f, -0.00473069f, -0.04008107f, 0.00240302f, -0.01615025f, 0.01177644f, 0.01059994f, 
    0.01362231f, 0.00975591f, 0.02168869f, -0.00863469f, 0.02924424f, -0.00999145f, 0.01298311f, -0.02425578f, 
    0.02123198f, -0.01553333f, -0.02325432f, -0.03140514f, 0.01556862f, -0.00147787f, 0.00023433f, -0.03616750f, 
    -0.01716175f, 0.02857494f, 0.02420863f, -0.01760630f, 0.01706221f, -0.02114548f, 0.01096779f, -0.01155438f, 
    0.00829714f, -0.04487806f, 0.00042029f, -0.00096849f, 0.00450749f, 0.01739154f, 0.02425873f, 0.02399745f, 
    -0.03829205f, 0.02004162f, -0.03765842f, -0.03687692f, -0.00010273f, 0.03545959f, -0.02388619f, -0.01306906f, 
    0.02202554f, 0.01795114f, -0.02129547f, -0.00626966f, -0.02165540f, 0.02467102f, -0.03727928f, 0.00297534f, 
    -0.00924964f, 0.00266214f, -0.03284630f, -0.00152408f, 0.03201526f, -0.03652953f, 0.02752347f, -0.00773607f, 
    -0.01914586f, 0.02483268f, 0.02789627f, -0.01488651f, -0.04306892f, -0.00549218f, 0.00856509f, 0.01875636f, 
    -0.03114993f, -0.02296282f, -0.00738093f, 0.00133005f, -0.02238372f, -0.04029829f, 0.02975675f, -0.00997827f, 
    -0.01800991f, -0.02765872f, -0.00282855f, 0.02103106f, 0.01808263f, -0.00197975f, -0.02034319f, 0.01763452f, 
    -0.01413685f, -0.00865258f, -0.01633327f, -0.01825207f, -0.01316326f, 0.01131060f, -0.01166171f, -0.01085548f, 
    0.02698877f, 0.00126515f, -0.03639172f, 0.01026684f, -0.01785100f, 0.01621055f, 0.02861559f, -0.00229575f, 
    0.01541968f, 0.03322459f, 0.02296741f, -0.00709031f, -0.03132724f, -0.02256889f, 0.01509783f, -0.00638364f, 
    -0.03977739f, 0.03481730f, 0.01411902f, -0.00206409f, 0.01706931f, 0.02467716f, -0.00198238f, -0.00025398f, 
    0.00551734f, 0.02785765f, -0.01106241f, -0.03953539f, -0.02607896f, -0.02537152f, -0.02840969f, -0.01791998f, 
    -0.02125463f, -0.01276380f, -0.03740914f, 0.02139847f, -0.04084190f, -0.00523648f, -0.00832544f, -0.00072770f, 
    -0.04166783f, -0.03942939f, -0.00516559f, -0.02451752f, -0.01562686f, -0.03288031f, -0.04666495f, -0.04550656f, 
    -0.02887308f, -0.02021997f, 0.01345817f, -0.00693374f, -0.03330535f, 0.03523532f, -0.01592211f, -0.01522328f, 
    0.00512164f, 0.00547861f, -0.00721409f, -0.02780123f, 0.02616274f, -0.02158866f, -0.00365260f, 0.01587393f, 
    -0.03866368f, 0.02373402f, -0.02539511f, 0.00363697f, 0.02280477f, 0.02149477f, -0.03767103f, 0.02573182f, 
    -0.01054487f, -0.00903872f, -0.03291174f, -0.02869819f, 0.01969912f, -0.01669789f, 0.00402522f, -0.01312446f, 
    -0.04016194f, -0.01041745f, -0.00879425f, 0.00844510f, -0.02579388f, -0.00993668f, -0.03114417f, 0.01114808f, 
    -0.02214538f, -0.01175433f, 0.00541399f, 0.01805190f, 0.04499533f, 0.02442298f, -0.02300942f, -0.00772575f, 
    -0.01408291f, -0.01536516f, -0.02228427f, 0.00930127f, -0.00664950f, -0.00474001f, -0.01794516f, -0.03610077f, 
    -0.02154590f, -0.01657850f, 0.01418822f, -0.04168260f, 0.00599691f, -0.00535629f, 0.00083383f, 0.00179222f, 
    -0.02608689f, 0.01611244f, -0.01824268f, -0.01945979f, -0.01684215f, 0.03007226f, 0.02606493f, -0.01985833f, 
    -0.02468547f, 0.02114868f, 0.00077621f, 0.00000302f, 0.00472900f, 0.02222963f, -0.04019479f, 0.02943786f, 
    0.01749404f, 0.01674725f, 0.02843456f, 0.00429153f, 0.01814930f, -0.02524996f, -0.00728155f, 0.01641490f, 
    -0.00729820f, 0.02017110f, -0.02635524f, -0.03446750f, 0.02691463f, -0.01771226f, -0.01467675f, -0.00804234f, 
    -0.03360863f, 0.02433388f, -0.01002483f, 0.01697855f, 0.03030416f, -0.03492789f, -0.01421184f, -0.02008703f, 
    0.02922795f, 0.02909792f, 0.00395467f, 0.01034428f, -0.03091094f, 0.00706020f, -0.03311488f, -0.00181073f, 
    -0.02499051f, -0.02909335f, -0.00658928f, 0.01886479f, -0.03054568f, 0.00027324f, 0.00195920f, 0.02308006f, 
    -0.03282431f, 0.00396075f, -0.00716502f, 0.02763706f, 0.02466438f, -0.01384058f, 0.02133655f, -0.00976222f, 
    -0.02388393f, -0.03584936f, 0.02813811f, -0.02929215f, 0.02063970f, 0.01210427f, -0.02849872f, -0.01391890f, 
    0.02171863f, -0.00284234f, -0.02882528f, -0.04347994f, 0.02319716f, 0.02013322f, -0.01487816f, -0.01947830f, 
    -0.04508919f, -0.01630225f, -0.02862926f, -0.00338062f, -0.02410312f, -0.01382769f, 0.00837444f, 0.00644888f, 
    -0.00267724f, 0.00913302f, -0.03491086f, 0.00780299f, -0.00713839f, 0.03253546f, -0.00513352f, 0.02177975f, 
    -0.01618354f, -0.00493141f, 0.02294829f, -0.03660212f, 0.00732586f, 0.02734273f, 0.00673144f, 0.00572123f, 
    -0.00397454f, 0.01628782f, -0.01606025f, -0.03293117f, -0.01802357f, 0.00521462f, 0.02399515f, 0.00244986f, 
    0.01270729f, 0.00810836f, 0.02069169f, 0.01017559f, -0.04332471f, -0.01367168f, -0.00293166f, 0.01623404f, 
    -0.02584073f, -0.02133111f, -0.01555312f, 0.00391537f, 0.02514167f, -0.00784489f, 0.03867935f, 0.03005249f, 
    0.00255975f, 0.01951524f, -0.00875325f, 0.01719692f, -0.00323537f, -0.00511735f, 0.00091714f, -0.00534418f, 
    0.04693897f, 0.01637758f, 0.02896814f, -0.02038094f, -0.00321892f, 0.01676204f, -0.01007424f, 0.01333499f, 
    0.00249230f, 0.01266807f, -0.00626576f, 0.00181054f, -0.02058761f, 0.01275476f, 0.03509876f, -0.02046993f, 
    -0.03732319f, 0.02320619f, -0.00994209f, -0.00337254f, 0.01279978f, -0.02212815f, 0.00190119f, 0.00831848f, 
    -0.01382392f, 0.01943611f, -0.03749088f, 0.01868496f, -0.00224611f, 0.01041299f, -0.02555141f, -0.00353571f, 
    -0.03349162f, -0.03828972f, 0.01163712f, -0.01414435f, -0.00934661f, 0.03217984f, -0.04830102f, 0.01923891f, 
    -0.01975912f, -0.01197389f, -0.00420511f, -0.02621772f, -0.02462140f, 0.01519331f, -0.03091679f, 0.01434668f, 
    0.02521433f, -0.03530894f, -0.01380734f, 0.01346469f, 0.02098501f, 0.01985632f, -0.00827538f, 0.00733572f, 
    0.00424832f, -0.02599968f, 0.02113862f, -0.02591025f, -0.03668509f, 0.01375171f, -0.00426708f, -0.00292652f, 
    0.01319324f, 0.01026861f, 0.02202401f, -0.03331641f, -0.01993351f, -0.00219567f, -0.02911930f, 0.01961256f, 
    0.01077691f, 0.01957858f, -0.01295007f, -0.03605172f, 0.01516818f, 0.00249675f, 0.00308969f, 0.01112820f, 
    0.00897918f, -0.03217287f, -0.00302177f, -0.00126732f, 0.00685185f, 0.02855460f, 0.01862624f, -0.03876279f, 
    -0.00924008f, -0.03668969f, 0.02925464f, -0.01800274f, -0.03070266f, -0.01901180f, -0.02151131f, -0.00478537f, 
    0.00989215f, 0.02969310f, 0.02687068f, -0.03082361f, 0.00532103f, 0.01227048f, -0.04072106f, -0.04223088f, 
    -0.02046669f, -0.00627878f, -0.00757580f, -0.02145327f, 0.01782237f, -0.02533790f, -0.03297551f, 0.01620785f, 
    -0.01448845f, 0.00735175f, 0.01268114f, 0.00974428f, 0.02926475f, -0.01817468f, -0.00450714f, 0.01385779f, 
    0.00191350f, 0.02124525f, 0.01686584f, 0.01144757f, 0.00723651f, -0.02357009f, 0.00903238f, -0.00104783f, 
    0.03104887f, -0.00052687f, 0.01226697f, -0.02333210f, 0.02074175f, -0.00393834f, -0.03804466f, -0.00329601f, 
    -0.03718092f, 0.01253665f, -0.01631660f, 0.01342882f, 0.00196264f, -0.00325027f, -0.02635557f, -0.03291387f, 
    0.01439150f, -0.01652975f, -0.00874818f, 0.01443571f, -0.03563611f, -0.02852112f, 0.01965826f, 0.02155384f, 
    -0.03519128f, 0.00257368f, -0.01072057f, 0.01666325f, -0.00322270f, 0.00395323f, 0.00658123f, -0.00688498f, 
    -0.02555828f, -0.03692847f, -0.01755733f, -0.00286943f, -0.03344116f, -0.00079928f, 0.02626046f, -0.01422601f, 
    -0.02094438f, -0.03321886f, -0.00740843f, 0.01701579f, 0.00715652f, 0.02641618f, -0.00491408f, -0.03058694f, 
    0.01838063f, -0.03623310f, 0.00506451f, -0.02548531f, -0.03573436f, 0.00761908f, 0.02201534f, -0.01350806f, 
    -0.02915602f, -0.02972730f, -0.00381623f, 0.01845895f, -0.02548235f, 0.02113389f, -0.02024341f, 0.00691234f, 
    -0.03505181f, -0.00517683f, -0.03854689f, -0.03005277f, 0.01034008f, 0.01649273f, -0.03229645f, 0.02688773f, 
    -0.00197096f, -0.01431105f, -0.00023158f, 0.01633136f, -0.03442960f, -0.02998666f, 0.00180083f, 0.01452398f, 
    0.02037627f, 0.02660538f, -0.00533790f, -0.02464289f, 0.01554853f, 0.02886517f, 0.02571183f, -0.00758971f, 
    0.02916918f, -0.02831068f, -0.02974833f, -0.03414252f, 0.01194518f, -0.02912227f, 0.00637168f, 0.02800424f, 
    0.00539755f, -0.03006572f, -0.00676231f, 0.02730515f, -0.00810471f, -0.01891842f, -0.03492189f, 0.01901302f, 
    -0.00282519f, -0.01482021f, 0.00671065f, 0.02888784f, 0.02496010f, -0.02395483f, -0.02679160f, -0.03542827f, 
    0.00645341f, 0.02322741f, 0.02156086f, -0.03305942f, -0.00121269f, -0.02986430f, -0.02707453f, 0.01035434f, 
    0.00754238f, -0.00237771f, 0.01698731f, -0.01410885f, 0.01270839f, -0.01601293f, -0.01711426f, 0.01207443f, 
    0.00199790f, -0.01452714f, -0.00876052f, -0.03779772f, 0.00004091f, -0.02547585f, 0.00018080f, -0.03401142f, 
    -0.00877688f, -0.03985188f, -0.00866968f, -0.00452988f, -0.01504675f, 0.01927512f, -0.03430505f, 0.00693223f, 
    -0.03395896f, -0.02440741f, -0.04084679f, 0.00177801f, 0.02040560f, -0.01064675f, 0.01061232f, 0.02107412f, 
    0.02884914f, -0.01824919f, 0.01761770f, 0.01976574f, -0.00706919f, -0.02015591f, -0.00693613f, -0.00791393f, 
    -0.02701428f, 0.02941382f, 0.01007717f, -0.03030393f, -0.01479752f, -0.01857743f, 0.01074788f, 0.02858406f, 
    -0.02651545f, 0.02913959f, 0.00262692f, -0.00513605f, 0.01873944f, 0.02253862f, -0.00502842f, 0.01490012f, 
    -0.03911497f, 0.00205435f, -0.02536627f, -0.00873654f, 0.03180291f, 0.03101343f, 0.03219798f, -0.00459939f, 
    -0.01896524f, 0.03285368f, -0.00187855f, -0.02223004f, -0.01937492f, 0.01468894f, -0.02236300f, 0.02501775f, 
    -0.01162888f, 0.02296355f, 0.00497659f, 0.02334705f, 0.00027206f, 0.02894980f, 0.01279892f, -0.02876170f, 
    0.01761044f, 0.03412918f, -0.00659151f, 0.01835944f, 0.00532595f, 0.03053099f, 0.00289337f, 0.01638709f, 
    0.00661474f, -0.00904488f, 0.02261890f, 0.01450336f, -0.01911305f, 0.01409180f, -0.03674594f, -0.03512337f, 
    -0.01824798f, -0.03712234f, 0.02406567f, 0.02049793f, -0.02618744f, -0.00615911f, -0.02945430f, 0.02976994f, 
    -0.02998362f, -0.02583139f, -0.00721741f, -0.00477664f, 0.02427659f, 0.00611850f, -0.00205100f, 0.01465703f, 
    -0.00703768f, -0.01724524f, -0.02899865f, 0.01707344f, -0.02626701f, 0.02615972f, -0.01366768f, -0.01588860f, 
    -0.00886009f, 0.02263469f, -0.00856065f, 0.01114898f, -0.02577189f, 0.00978126f, -0.03297110f, 0.02145528f, 
    0.02919181f, -0.02551464f, -0.00514499f, 0.00663283f, -0.03196926f, -0.02657691f, 0.01261220f, -0.00428671f, 
    -0.04113680f, 0.02983036f, -0.02843731f, -0.00198756f, -0.03127531f, 0.02523204f, -0.00364621f, 0.00498615f, 
    0.01214320f, 0.01503661f, 0.02814679f, 0.02507051f, 0.02943383f, 0.02802401f, 0.01636299f, -0.01990677f, 
    0.01617180f, -0.01873938f, -0.00808779f, 0.02686737f, 0.02933160f, 0.01195578f, 0.02982558f, 0.00125171f, 
    -0.01980760f, -0.00731567f, -0.02535742f, 0.03320638f, 0.00016641f, 0.02712829f, -0.03616183f, -0.00696236f, 
    -0.01486210f, -0.01152032f, -0.01062080f, -0.00361974f, 0.02017571f, 0.01856272f, 0.03120460f, 0.00216981f, 
    -0.02134328f, -0.01730745f, 0.01324605f, 0.00577970f, 0.03171512f, 0.01280661f, 0.03150667f, -0.01466522f, 
    -0.01452453f, -0.00433811f, 0.01342396f, 0.00342011f, -0.00643476f, 0.01149838f, 0.02741198f, 0.01531779f, 
    -0.02185019f, 0.00462816f, 0.00180467f, -0.03112675f, -0.03045087f, -0.03359377f, -0.00358418f, -0.02474166f, 
    0.02863598f, -0.03281284f, -0.00516982f, 0.01270693f, -0.01312198f, -0.01861691f, 0.02280785f, -0.00307732f, 
    0.03056171f, -0.01527480f, -0.03484216f, 0.02006642f, -0.00963443f, 0.02831990f, 0.02540971f, -0.02737791f, 
    0.02538568f, 0.03373824f, -0.01570782f, 0.02593524f, 0.00976903f, -0.02229346f, 0.00399759f, 0.02343128f, 
    -0.02365270f, 0.00332609f, -0.02803628f, -0.01281374f, -0.00090106f, -0.00404095f, 0.00159470f, 0.00287234f, 
    -0.00241057f, 0.00893383f, -0.00674390f, -0.03382049f, -0.02658733f, -0.03839879f, -0.03504841f, -0.03395651f, 
    0.01287161f, 0.02658238f, -0.01922489f, 0.00570113f, -0.03638341f, 0.02497879f, -0.03931114f, 0.00171711f, 
    0.02970159f, -0.03643832f, -0.01415146f, -0.01222285f, 0.02528763f, 0.02850318f, 0.01865144f, -0.02486968f, 
    -0.01749269f, -0.04094266f, 0.02944478f, 0.02203810f, 0.02071080f, -0.01843283f, 0.01947939f, 0.02130324f, 
    -0.01484452f, 0.00261034f, -0.02597917f, 0.01718714f, 0.02118958f, 0.02561512f, 0.01314147f, 0.00818864f, 
    0.02276554f, 0.02070202f, -0.00170508f, 0.01179925f, 0.00233562f, 0.00226286f, 0.00085720f, -0.03395725f, 
    0.00361420f, 0.03532330f, -0.02572324f, 0.00055396f, 0.02739925f, 0.01155372f, -0.03885156f, 0.00664283f, 
    0.03241719f, 0.02351080f, 0.03102037f, -0.02265522f, 0.01682804f, 0.02107263f, -0.03681899f, -0.03441928f, 
    -0.03015075f, -0.01985149f, -0.01302860f, 0.00354489f, 0.02086965f, 0.02502804f, -0.00391386f, 0.02240726f, 
    -0.00773762f, -0.01856364f, 0.01608765f, 0.02864766f, -0.00589981f, 0.01935924f, 0.03210939f, -0.01199348f, 
    -0.03417908f, -0.01428856f, 0.00299532f, 0.03310346f, 0.00131366f, -0.01149268f, -0.00145837f, -0.02532781f, 
    -0.01494758f, -0.04049693f, -0.02993461f, -0.03358631f, 0.02634688f, 0.03828586f, -0.03343933f, 0.01368346f, 
    -0.02216411f, 0.02825920f, -0.00890372f, -0.03126179f, -0.03675541f, 0.00849903f, 0.03177633f, -0.02113338f, 
    -0.03142522f, 0.01963997f, 0.00547969f, -0.02946980f, -0.02032724f, -0.02743456f, 0.00094628f, 0.00376703f, 
    -0.00410424f, 0.01262641f, 0.00740964f, -0.02450573f, -0.02980479f, -0.02277959f, -0.02888238f, 0.02084769f, 
    -0.01869564f, -0.02227888f, 0.02704650f, -0.02330022f, 0.00347318f, 0.02198570f, -0.03426436f, -0.02319519f, 
    -0.00471485f, 0.03361464f, -0.03591071f, 0.00918403f, -0.03623163f, -0.00498938f, -0.00974043f, 0.03352084f, 
    0.02632441f, -0.01736090f, -0.03287674f, 0.02540348f, -0.00171385f, -0.03017057f, -0.00851290f, -0.03364647f, 
    0.02165744f, 0.02107119f, 0.02187187f, 0.00036736f, -0.00365488f, -0.03476004f, -0.03645642f, -0.00594978f, 
    -0.02385189f, -0.02284765f, -0.00810069f, -0.00438058f, -0.03795175f, -0.02117531f, -0.02775132f, -0.02777381f, 
    0.02866805f, -0.02485646f, 0.02540068f, 0.02152553f, -0.00818724f, 0.02005003f, -0.01616077f, -0.00705631f, 
    -0.02419149f, -0.02902399f, -0.02363936f, 0.02527707f, -0.03530836f, -0.03263705f, 0.00067350f, -0.02871310f, 
    0.01064185f, -0.02286778f, -0.01402000f, -0.00338895f, -0.01922567f, 0.01655932f, 0.02874762f, 0.02110689f, 
    -0.03739434f, 0.02225309f, 0.00044722f, -0.03299591f, -0.01715180f, -0.01696073f, -0.02442062f, 0.02816108f, 
    0.03526329f, -0.03229050f, -0.00908341f, -0.01598789f, -0.03135868f, -0.00119574f, -0.01687037f, -0.02654732f, 
    -0.03056442f, -0.01229188f, -0.01235869f, 0.01896388f, 0.03054333f, -0.03229280f, -0.03492074f, -0.02132409f, 
    -0.03522801f, -0.00968402f, -0.02176321f, -0.02251065f, -0.02356882f, -0.03242473f, -0.03619708f, -0.01389896f, 
    0.00193181f, 0.02024438f, -0.03561212f, 0.01437854f, -0.03400313f, 0.01798878f, -0.01908580f, -0.01202509f, 
    -0.02949551f, -0.00030005f, 0.02129159f, 0.01045197f, 0.00171895f, -0.00716417f, 0.02458367f, 0.02613373f, 
    -0.03682724f, -0.00662190f, 0.02749582f, 0.02083424f, -0.01157032f, -0.02536546f, 0.00210635f, 0.02667420f, 
    -0.00301761f, -0.01562287f, -0.02063198f, -0.00577999f, 0.00282796f, 0.02459464f, -0.01645586f, 0.02233981f, 
    -0.02505136f, -0.03541571f, -0.03430725f, -0.02250778f, -0.01902607f, -0.01320116f, -0.02024735f, -0.03207387f, 
    0.01574494f, -0.01532357f, 0.02750851f, 0.01160005f, -0.03939407f, -0.03340635f, 0.02654155f, -0.03084325f, 
    0.00324024f, 0.01576665f, 0.03154624f, -0.03529205f, 0.02373392f, 0.00725829f, 0.03607257f, -0.00788108f, 
    -0.01039683f, 0.01370949f, 0.03011261f, -0.03379868f, 0.02056882f, -0.02057449f, -0.00870068f, 0.02758574f, 
    -0.00095455f, 0.00601579f, 0.03002420f, -0.01763366f, -0.02897712f, 0.02042313f, 0.03359211f, -0.00870247f, 
    0.02844856f, -0.01139878f, 0.02796839f, -0.01679874f, -0.02781574f, -0.03086957f, 0.00605728f, 0.02274183f, 
    0.01632247f, 0.01977828f, -0.01318077f, -0.03264459f, -0.02945389f, 0.03406734f, -0.01300370f, -0.02093306f, 
    -0.01591005f, -0.00164029f, 0.03107482f, -0.02958348f, -0.02383240f, -0.03612202f, 0.01701676f, -0.01617875f, 
    -0.03599662f, 0.02371761f, -0.03250458f, 0.01276459f, 0.02656802f, 0.02315158f, -0.02057256f, -0.02376843f, 
    -0.00255142f, -0.01689057f, 0.00494951f, -0.01706048f, -0.02783625f, 0.00945400f, 0.00252669f, -0.03121652f, 
    0.00871297f, -0.00293703f, 0.03168852f, 0.01218582f, 0.02764554f, -0.01465018f, -0.00885990f, -0.02248853f, 
    -0.02394126f, 0.02159977f, 0.00538552f, -0.00530307f, 0.01897300f, -0.02659831f, -0.00741088f, 0.02356660f, 
    0.02606620f, 0.02840702f, 0.02128629f, -0.03009379f, -0.00166261f, -0.03843997f, -0.01617834f, -0.02165277f, 
    0.02984877f, 0.03205892f, 0.02015331f, 0.01734147f, 0.01407111f, -0.02205519f, 0.01719925f, 0.02025997f, 
    0.01386841f, -0.01989598f, 0.01698259f, 0.00082502f, -0.02710269f, 0.00255182f, -0.03964560f, -0.01281395f, 
    0.01121750f, -0.03481066f, -0.02992304f, -0.03031515f, 0.01814608f, 0.00626481f, -0.00794929f, -0.00750809f, 
    0.01410727f, -0.03416303f, 0.01332234f, 0.00345781f, -0.00282149f, -0.01536784f, 0.00011184f, -0.01814546f, 
    0.00911794f, 0.00392369f, -0.04171612f, -0.01117349f, -0.01008765f, -0.02047611f, -0.02852218f, 0.01283031f, 
    -0.02594526f, 0.00810897f, 0.01493309f, 0.00796817f, 0.00736017f, 0.02171330f, -0.03682633f, 0.00997790f, 
    -0.02506383f, 0.01159206f, -0.02670038f, -0.01884750f, 0.01021605f, -0.01116814f, -0.00289079f, -0.02732168f, 
    0.00972593f, -0.03110296f, 0.00612741f, 0.01074682f, 0.02997971f, -0.00735386f, -0.03813520f, -0.01754764f, 
    -0.02093670f, 0.01218866f, 0.02755087f, -0.01429209f, 0.00153184f, -0.00584696f, -0.01110572f, -0.03636915f, 
    0.00855711f, -0.00984768f, 0.03623060f, 0.00613195f, -0.03767109f, 0.03190890f, 0.02078268f, -0.01576965f, 
    0.00369593f, 0.00352295f, -0.03209744f, -0.01156030f, 0.00117087f, -0.00432624f, -0.02520362f, -0.02013273f, 
    0.02120761f, 0.03223425f, -0.02549859f, -0.03093682f, 0.00427388f, -0.03686592f, -0.02957901f, -0.01266262f, 
    -0.03148500f, 0.02426924f, -0.03170371f, -0.00309361f, 0.03071685f, 0.01344376f, 0.01868154f, -0.02160709f, 
    0.00361307f, -0.01295230f, 0.00746975f, 0.01511544f, -0.01457728f, 0.00913294f, 0.03373765f, 0.01560489f, 
    -0.00788683f, -0.00474209f, -0.02538636f, 0.01157406f, 0.00138822f, -0.00700167f, -0.01477284f, -0.00052811f, 
    0.02055287f, -0.02936768f, -0.02421244f, -0.00010794f, 0.00331192f, 0.02120173f, 0.00673823f, 0.00991771f, 
    -0.02427928f, -0.00279955f, -0.04301798f, -0.00444932f, -0.01368855f, -0.01863490f, -0.01212619f, -0.05005868f, 
    -0.00225427f, -0.02907139f, -0.03137120f, 0.00215535f, -0.02394596f, 0.02308650f, 0.02646842f, 0.03158609f, 
    0.00325616f, 0.01913759f, -0.00497558f, -0.02609307f, -0.00165343f, -0.00986639f, 0.00885092f, 0.00325942f, 
    0.02333770f, 0.01108171f, 0.00835001f, 0.01472061f, 0.02868643f, -0.00349592f, -0.02928724f, 0.03266690f, 
    0.01811618f, 0.00523391f, 0.02665543f, -0.01502488f, -0.03002469f, -0.00784087f, 0.02744080f, -0.01132923f, 
    -0.01438917f, -0.04091180f, -0.03841696f, 0.00959543f, -0.02352578f, -0.02751274f, -0.02856032f, -0.01703721f, 
    0.00813690f, -0.00120120f, -0.00727431f, 0.00327003f, 0.02201122f, 0.03010329f, 0.02116067f, 0.01802909f, 
    0.00056486f, 0.00009329f, 0.02940112f, 0.02110911f, -0.01547218f, 0.01050147f, 0.02204064f, 0.01789436f, 
    -0.00767389f, -0.01928985f, -0.02049141f, -0.02127509f, 0.00772991f, -0.03826655f, -0.03749859f, -0.02359660f, 
    -0.00632229f, 0.02783320f, -0.03442631f, 0.00209123f, 0.01779448f, -0.02852777f, -0.01473008f, 0.02275344f, 
    -0.00774483f, -0.01143482f, 0.02603074f, -0.00839841f, -0.00281589f, -0.01511633f, -0.01007830f, -0.00690082f, 
    0.00195518f, -0.02494266f, 0.00768858f, -0.03069763f, -0.04302549f, -0.03753699f, 0.02192038f, -0.01497898f, 
    -0.04828703f, 0.01445111f, 0.00720436f, -0.03824370f, -0.01021963f, -0.02546690f, -0.03189725f, -0.03544940f, 
    -0.03775850f, -0.03667989f, -0.04562006f, -0.03909814f, -0.00785276f, -0.00878718f, 0.02618814f, -0.04018651f, 
    -0.01783841f, 0.02538815f, -0.02747847f, 0.02909204f, -0.04235929f, -0.00431912f, 0.00083516f, -0.00947255f, 
    0.02921984f, -0.03994836f, -0.01615833f, -0.00111895f, -0.02214954f, 0.02777703f, 0.03010521f, 0.01261255f, 
    -0.00297944f, -0.00047745f, -0.01082526f, 0.02319366f, 0.02019698f, -0.00333642f, -0.01969992f, 0.02358426f, 
    0.00622097f, 0.02820724f, 0.00587230f, 0.02335251f, 0.00855991f, -0.03574618f, 0.02049894f, -0.03287733f, 
    -0.03326090f, -0.02312922f, 0.00268946f, 0.00610664f, 0.02782159f, 0.02036850f, 0.01065017f, -0.02718745f, 
    -0.02281638f, -0.02335127f, -0.03964754f, 0.02555249f, -0.01971659f, 0.02427381f, 0.01314723f, 0.02362892f, 
    -0.02575758f, -0.02615907f, -0.03170802f, 0.02071766f, 0.00052668f, -0.01639665f, -0.02832476f, -0.00619156f, 
    0.00015720f, -0.02737754f, -0.01628378f, 0.01938283f, 0.02089020f, -0.01015025f, 0.00579384f, 0.03155368f, 
    -0.02023165f, 0.00634525f, 0.02525494f, -0.02857755f, 0.01458368f, -0.04368897f, -0.00174081f, -0.01794551f, 
    -0.02619934f, 0.02777962f, 0.02184226f, -0.00721081f, 0.00372794f, 0.00536064f, -0.00515273f, -0.00861556f, 
    0.02398308f, 0.03183745f, -0.03931418f, -0.04264062f, 0.02323859f, 0.01189847f, -0.02114921f, 0.02446171f, 
    0.00637767f, -0.01787532f, -0.01347503f, 0.02562893f, -0.00222418f, -0.00628983f, -0.00046695f, -0.01699492f, 
    -0.00327061f, 0.00756158f, 0.00483574f, -0.00723471f, 0.01272911f, -0.03800601f, 0.01276936f, -0.01276651f, 
    0.02022175f, -0.02880705f, 0.00883209f, -0.02270069f, -0.02120075f, 0.02033316f, -0.04563327f, 0.02173914f, 
    -0.02867524f, -0.04125391f, -0.00746334f, 0.00087154f, 0.02937460f, 0.01008402f, 0.01831038f, -0.00371513f, 
    0.00131972f, -0.02237055f, 0.00260506f, 0.01852406f, -0.03156481f, -0.00828843f, 0.02159603f, 0.01118477f, 
    0.02018743f, -0.02025629f, -0.00003446f, -0.00924821f, 0.01083475f, 0.00920734f, -0.00245293f, 0.00991217f, 
    -0.02031270f, -0.02366905f, -0.02469278f, 0.03389147f, 0.02368075f, -0.00489485f, -0.03946256f, 0.02912346f, 
    -0.01601346f, 0.01038299f, -0.03799238f, -0.03850155f, -0.04272982f, 0.01260525f, 0.03044519f, 0.00177537f, 
    0.01831595f, 0.00563364f, 0.02817994f, 0.01334676f, -0.02737051f, -0.01415390f, -0.04018139f, -0.02844574f, 
    0.02626038f, 0.01182723f, -0.00126354f, 0.00078853f, -0.01092868f, 0.00662820f, -0.02797354f, 0.02970596f, 
    -0.01733721f, -0.00979154f, 0.00843672f, 0.01777109f, -0.04207262f, -0.01162433f, 0.04441795f, 0.02836078f, 
    -0.03290464f, 0.04635032f, 0.04101798f, 0.02536792f, 0.02335205f, 0.01020516f, 0.02649830f, -0.03969275f, 
    -0.00369263f, -0.04619659f, -0.01324413f, 0.02691410f, -0.02229143f, -0.01163762f, 0.01901621f, -0.02520372f, 
    0.01495341f, -0.00943683f, 0.00494096f, -0.00938826f, 0.01953402f, -0.00173331f, 0.00993120f, 0.01013701f, 
    0.00415597f, 0.00891434f, 0.01127764f, 0.00093262f, -0.02369848f, 0.02228046f, -0.03232651f, 0.00072403f, 
    0.01433765f, -0.02550969f, -0.04857879f, -0.02251267f, -0.01565997f, 0.01405090f, -0.04310120f, -0.02201475f, 
    -0.01150413f, 0.00286712f, -0.01690023f, -0.03809495f, -0.02449544f, -0.03893428f, -0.01736400f, -0.02616772f, 
    0.02683157f, 0.01133268f, -0.01039227f, 0.02112432f, 0.00839836f, -0.00299918f, 0.00480004f, -0.00890309f, 
    0.02687661f, -0.04173627f, -0.01857506f, -0.00503343f, -0.03669681f, -0.04476573f, 0.01595191f, -0.03555535f, 
    -0.00476333f, -0.03076860f, -0.01887823f, -0.02488905f, 0.01253327f, -0.01852039f, -0.01194993f, 0.02267356f, 
    0.02013158f, 0.02422000f, 0.03476365f, -0.01546200f, -0.04315582f, -0.04087634f, -0.01522413f, 0.00116771f, 
    -0.02402600f, 0.01918436f, -0.01368905f, 0.01263782f, 0.03059333f, -0.00790988f, -0.01020833f, 0.01463248f, 
    -0.00074088f, -0.00315676f, 0.03112259f, -0.00592702f, -0.03404539f, 0.00576830f, -0.00091592f, 0.01340865f, 
    -0.00074520f, 0.02764976f, 0.00046519f, 0.03215654f, 0.03085500f, 0.03612749f, -0.01799070f, -0.02932226f, 
    -0.00005053f, 0.01026398f, 0.01563872f, 0.02273020f, 0.01590671f, 0.00962259f, 0.00016886f, 0.02259207f, 
    0.03480337f, 0.01672817f, 0.00350274f, 0.01900228f, -0.02608582f, -0.01438460f, -0.01295195f, -0.00673332f, 
    0.03556065f, -0.02278969f, -0.00271431f, 0.01179116f, 0.03694693f, 0.00437033f, 0.01676108f, -0.02155331f, 
    -0.00932015f, -0.03511792f, 0.01783910f, 0.02151585f, -0.00217962f, 0.01999382f, 0.00767096f, -0.00620411f, 
    -0.02665729f, -0.02662292f, 0.01375885f, 0.00795156f, -0.03117328f, -0.03095531f, 0.02379151f, -0.00289416f, 
    -0.00370244f, -0.02281350f, -0.00233217f, -0.01904910f, -0.03915315f, -0.03415003f, -0.00065863f, -0.03126950f, 
    -0.03827877f, -0.04257901f, -0.03218780f, 0.01413135f, 0.02500103f, 0.02779585f, -0.00629811f, -0.00097039f, 
    -0.00671026f, -0.01073773f, 0.02055455f, -0.03733032f, 0.02444673f, 0.03444913f, -0.03194005f, 0.02952465f, 
    0.01777260f, -0.03402142f, -0.00438798f, -0.03541833f, -0.02503746f, 0.01312733f, 0.01089246f, -0.01015957f, 
    -0.02565924f, 0.03237273f, -0.03215100f, -0.01044807f, 0.01623064f, -0.01568186f, -0.03095655f, 0.02376375f, 
    0.02319635f, 0.02636544f, 0.00773110f, -0.02242923f, 0.00693121f, -0.01557589f, -0.04737489f, 0.02361426f, 
    0.01438326f, -0.03928558f, 0.03200974f, 0.03560388f, 0.03193008f, 0.02562679f, -0.02259956f, -0.02150525f, 
    0.00910900f, -0.00554572f, 0.00101336f, -0.01522407f, -0.01376047f, -0.00198886f, -0.03768224f, -0.02142987f, 
    -0.00550423f, 0.00812241f, -0.02370471f, 0.02848413f, -0.03387932f, 0.01013340f, -0.04185844f, -0.03680463f, 
    -0.00494771f, 0.01744349f, -0.03059625f, 0.02489240f, -0.00040057f, 0.01599548f, -0.02206836f, -0.00558560f, 
    0.02034776f, -0.01053806f, -0.03190923f, 0.01244124f, -0.03098941f, 0.03850966f, -0.01876510f, -0.02543904f, 
    0.00676125f, 0.00911126f, 0.02412108f, 0.00518807f, 0.00876080f, -0.01976342f, -0.03252966f, -0.01103569f, 
    -0.02694328f, -0.03626097f, -0.03464074f, -0.00005083f, -0.03946194f, -0.02333814f, -0.03003218f, 0.00350723f, 
    -0.02856826f, -0.04534153f, -0.00705511f, -0.01892412f, -0.01980835f, -0.02049717f, -0.01508225f, 0.00962324f, 
    0.02441337f, 0.02444340f, -0.04040498f, 0.01141751f, -0.02073733f, -0.02166582f, -0.02349498f, -0.02732244f, 
    -0.01397057f, 0.01032999f, 0.02374442f, -0.02768048f, 0.00068955f, -0.00246360f, 0.00476682f, 0.01053378f, 
    -0.00368039f, -0.02358695f, -0.03939650f, 0.01534845f, -0.02633064f, 0.01417408f, 0.01016736f, -0.04535881f, 
    -0.00751324f, 0.04138225f, -0.01020092f, -0.02840967f, -0.00237526f, 0.00306328f, -0.01364796f, -0.02190813f, 
    0.00264301f, -0.02844775f, 0.00853721f, 0.02970180f, -0.01588806f, 0.02010142f, 0.02821428f, -0.03840737f, 
    -0.00740127f, -0.02638155f, 0.02048425f, -0.03126086f, 0.02585461f, 0.02958350f, -0.00948551f, -0.04152858f, 
    -0.02741041f, 0.03062570f, -0.02578047f, 0.02006371f, -0.00871901f, -0.01794359f, 0.01122862f, -0.02396577f, 
    -0.00950704f, -0.02089736f, -0.00370458f, -0.02884981f, 0.02098728f, -0.00827628f, 0.01848360f, -0.02222724f, 
    0.00942088f, -0.02443437f, -0.00676601f, -0.03543343f, -0.01125429f, -0.00599016f, -0.01511374f, 0.01464495f, 
    -0.03094956f, 0.00031724f, -0.00865237f, -0.02392270f, -0.02994034f, -0.03865721f, -0.03919734f, -0.03827783f, 
    0.01546923f, -0.03823904f, -0.01970533f, 0.01699166f, 0.00105076f, -0.03363056f, -0.02592295f, -0.04815993f, 
    -0.01928813f, 0.02873373f, 0.02753968f, -0.04009607f, -0.02537785f, -0.01207542f, -0.01690385f, 0.03617495f, 
    -0.03213284f, -0.00420088f, 0.01253207f, -0.00097129f, -0.03811173f, 0.02032446f, 0.03293575f, 0.02878689f, 
    -0.00712723f, 0.01818964f, 0.02466119f, -0.02423765f, -0.03344201f, 0.02112452f, -0.02989731f, -0.01718043f, 
    0.01953019f, 0.00903524f, -0.03958710f, -0.04426160f, -0.02797539f, 0.00881181f, -0.01692861f, 0.02530345f, 
    -0.03147892f, 0.00105969f, 0.02027475f, -0.00224863f, -0.03961367f, -0.02945720f, -0.02523464f, 0.04382044f, 
    -0.01397772f, -0.00470215f, -0.02963898f, -0.04056846f, -0.00774061f, 0.00481477f, -0.03917459f, -0.02727287f, 
    -0.03160005f, -0.03095633f, -0.00897717f, 0.00265299f, -0.02201332f, -0.01514160f, -0.02303308f, -0.01396800f, 
    -0.00009088f, 0.02208258f, -0.02012798f, -0.00484743f, -0.02814914f, 0.00762794f, 0.00879841f, 0.00855575f, 
    0.00289148f, -0.01563225f, 0.01974734f, -0.03208579f, 0.01867234f, 0.01775334f, -0.03530876f, -0.02119814f, 
    -0.02497197f, 0.00348915f, 0.00602659f, -0.03068382f, 0.01072811f, 0.01096494f, 0.00852598f, 0.01454371f, 
    0.01984550f, 0.02438414f, -0.00051965f, -0.03776799f, 0.00915218f, 0.01366968f, -0.01666402f, -0.01591407f, 
    -0.02917556f, 0.01910840f, 0.02922505f, 0.02956307f, 0.02929966f, 0.03348946f, -0.00176526f, -0.01541412f, 
    0.01659510f, -0.01700496f, -0.02086788f, 0.03509048f, -0.02551861f, -0.01828738f, -0.00052683f, -0.02067626f, 
    -0.02464280f, -0.02683420f, 0.00989720f, -0.01529654f, 0.00384325f, -0.02618786f, 0.00125560f, -0.00652714f, 
    0.02071572f, 0.01092761f, -0.02989707f, -0.03828597f, -0.01362447f, 0.00871460f, -0.00115475f, -0.01453187f, 
    0.00923760f, -0.03401763f, -0.01694507f, -0.04395290f, -0.00064362f, 0.00831593f, -0.00098202f, 0.02772420f, 
    0.02038739f, -0.03152742f, 0.00565865f, -0.03380487f, 0.01488195f, -0.02259825f, 0.02461291f, -0.00220750f, 
    -0.01321976f, 0.02117821f, 0.00773905f, -0.02275793f, -0.00797484f, 0.02024047f, 0.02321171f, -0.01421862f, 
    0.00962469f, -0.03037724f, 0.01148940f, 0.01580868f, -0.00744712f, -0.01932951f, -0.02439903f, 0.02672430f, 
    -0.03334508f, -0.01571748f, 0.02169312f, 0.01543078f, 0.00116779f, -0.00091403f, 0.02667943f, -0.01093026f, 
    0.01498395f, -0.02574522f, -0.03438276f, 0.01814812f, 0.00309278f, -0.03325924f, 0.00022664f, 0.01331925f, 
    0.01671952f, 0.00062091f, -0.01860324f, 0.00847469f, 0.00890618f, -0.03302531f, 0.01537116f, 0.00722411f, 
    -0.00116951f, -0.00810024f, 0.01765620f, -0.00775253f, 0.00499290f, -0.03054921f, -0.04384796f, -0.04288878f, 
    0.01475781f, 0.00993111f, -0.02471629f, -0.03452721f, -0.01134708f, -0.00116890f, -0.00458174f, 0.01410939f, 
    0.02332347f, -0.01021970f, -0.04226604f, -0.04089710f, 0.01353878f, 0.00413325f, -0.04357976f, 0.01598273f, 
    0.00276901f, -0.00899733f, 0.01175067f, -0.00906135f, 0.01456558f, 0.00302891f, -0.01703357f, 0.02747716f, 
    -0.02857901f, 0.02488863f, 0.01638625f, 0.00895752f, 0.01788797f, -0.02028696f, 0.01041979f, -0.01522911f, 
    -0.02482013f, 0.00923597f, 0.02038341f, -0.02947887f, 0.02401285f, 0.03376897f, -0.03223413f, 0.02446889f, 
    -0.00471390f, -0.00126751f, 0.00424859f, -0.00446027f, -0.01767957f, -0.03368237f, 0.02389403f, -0.02502200f, 
    0.00489604f, -0.01610068f, 0.02009297f, 0.00882932f, -0.01776987f, 0.02462768f, 0.01945312f, 0.02322239f, 
    0.02579843f, 0.02317900f, -0.01374969f, 0.02096253f, 0.01818720f, -0.03062495f, 0.02090094f, -0.00621200f, 
    0.01076054f, 0.01456828f, -0.03143054f, 0.00400511f, -0.00085509f, -0.04254083f, -0.03717613f, 0.00094313f, 
    0.00628916f, 0.01181590f, -0.01468670f, 0.02471377f, -0.03707768f, -0.01310678f, -0.03629412f, -0.00824801f, 
    -0.03650050f, 0.01938763f, -0.02857817f, 0.02369917f, 0.01848717f, -0.01693305f, -0.02326701f, -0.01259021f, 
    -0.03752695f, 0.00287886f, 0.01792394f, -0.02159297f, -0.01625879f, 0.01291447f, -0.03565979f, 0.00760085f, 
    -0.02239799f, -0.00408898f, -0.00623801f, -0.03671562f, -0.01151369f, 0.00326540f, 0.01230175f, -0.01587744f, 
    0.00303848f, 0.02417815f, 0.02498742f, -0.00063035f, -0.01263948f, 0.02578042f, -0.02055092f, -0.01974677f, 
    -0.04420079f, -0.00637191f, 0.01299010f, -0.03207904f, -0.00729250f, 0.00102427f, -0.03791957f, -0.03643408f, 
    -0.00857776f, 0.00002698f, -0.03639928f, -0.02194315f, 0.01730565f, 0.01037842f, -0.02737127f, 0.01355348f, 
    -0.02575917f, -0.03248602f, -0.02691644f, -0.00806399f, 0.02074338f, -0.03748616f, -0.01077843f, 0.00320937f, 
    0.02268987f, 0.01096313f, 0.00229502f, -0.01576724f, 0.01365538f, 0.00583432f, -0.02036681f, -0.02777441f, 
    -0.01040461f, 0.02219135f, -0.02530602f, 0.00323237f, -0.04276032f, 0.00800158f, 0.00965195f, -0.01843553f, 
    -0.02132940f, 0.02433197f, 0.00561120f, -0.01406139f, -0.02415952f, -0.01979475f, 0.01009882f, 0.00999289f, 
    0.00010333f, 0.02917329f, -0.00506685f, -0.02738459f, -0.01856313f, -0.02713408f, 0.01102947f, -0.02284762f, 
    0.00955890f, 0.01141665f, 0.01572320f, 0.00706733f, 0.00695899f, -0.00261792f, 0.00814709f, 0.00928301f, 
    -0.01188750f, -0.00511979f, 0.00660887f, -0.03122819f, -0.02092894f, 0.00858000f, 0.00646075f, -0.01831074f, 
    -0.00565672f, -0.00131745f, 0.00468104f, -0.02429359f, -0.02947572f, 0.00682733f, -0.02729227f, 0.02074262f, 
    0.02607237f, -0.01069178f, -0.02709850f, 0.02646856f, -0.00084608f, 0.00481344f, -0.01491029f, -0.03699902f, 
    0.00480309f, 0.00990329f, -0.03203083f, 0.02940288f, 0.00930677f, -0.01460517f, -0.00245473f, 0.01955950f, 
    -0.00668377f, -0.03884100f, 0.00058091f, 0.00268690f, -0.03698703f, 0.00474441f, 0.02388242f, -0.00115015f, 
    -0.04374202f, -0.00135568f, 0.00189293f, -0.02710125f, 0.01043061f, -0.03575166f, -0.02945174f, -0.02383091f, 
    -0.01304702f, -0.02509499f, 0.00880498f, -0.00014431f, -0.04032771f, -0.01727163f, 0.01199858f, 0.01206194f, 
    -0.03460563f, -0.03190637f, -0.02407926f, 0.00411041f, -0.02666051f, -0.00134789f, -0.01255589f, -0.02903837f, 
    0.00304374f, 0.02486705f, -0.01877717f, -0.00471595f, -0.01426633f, 0.01767910f, 0.00650211f, 0.00685044f, 
    -0.00308919f, 0.01510868f, -0.02792488f, -0.01393269f, -0.00877727f, -0.00711176f, -0.04416243f, 0.02219479f, 
    0.01400395f, 0.01380496f, 0.00817567f, -0.00661078f, -0.03275767f, -0.02771929f, -0.00147554f, -0.03607723f, 
    0.03249115f, 0.02765603f, -0.00443135f, -0.00289403f, -0.03372703f, 0.00961160f, -0.03618577f, -0.01454530f, 
    0.00783677f, 0.02611222f, -0.02720970f, -0.01235388f, -0.01842748f, 0.01170236f, -0.04199940f, -0.01566795f, 
    0.00732591f, -0.01340908f, 0.01453828f, 0.00075782f, 0.00539492f, 0.00666101f, 0.00821826f, -0.01385392f, 
    0.01336664f, 0.01554027f, -0.01954991f, -0.00667068f, 0.02441301f, 0.02117536f, -0.00248082f, -0.02572852f, 
    0.02684849f, 0.00323166f, -0.00709950f, -0.01642296f, 0.01142537f, 0.01501869f, 0.01643653f, -0.03042635f, 
    -0.01052308f, 0.00770841f, 0.01597478f, 0.00225030f, 0.02400819f, -0.03801781f, -0.01027654f, 0.02466146f, 
    0.02471397f, -0.02382414f, 0.02089929f, -0.04421602f, 0.00558389f, -0.01455214f, 0.02794936f, -0.02062632f, 
    0.02437107f, -0.02711491f, 0.02376782f, 0.01765280f, 0.01137459f, 0.02136087f, 0.01285077f, 0.01598428f, 
    -0.03932161f, -0.00860861f, -0.01643302f, -0.00060648f, 0.00833364f, 0.00972758f, -0.02705823f, -0.01969668f, 
    0.00824204f, 0.00865647f, 0.02042865f, 0.02585795f, 0.00950738f, -0.02087276f, 0.00564601f, 0.01197465f, 
    0.00795145f, -0.00770093f, 0.00581142f, -0.02048910f, -0.02685049f, -0.00983594f, 0.00276503f, -0.02544642f, 
    -0.02769447f, -0.01956729f, -0.04352644f, -0.00493808f, -0.03794725f, -0.00780028f, -0.03562324f, 0.00051207f, 
    0.01298728f, 0.01597617f, -0.02046715f, 0.00347656f, 0.00695274f, 0.02223242f, -0.02903278f, 0.01705079f, 
    0.02723357f, -0.03994487f, 0.00722548f, -0.00351933f, -0.02763341f, -0.02084865f, -0.02896630f, -0.03514773f, 
    0.00673275f, -0.01000421f, 0.00286115f, 0.01951543f, -0.02969199f, -0.01783089f, 0.00784434f, -0.01387221f, 
    0.03345796f, 0.00509309f, 0.00296320f, -0.02854925f, 0.02393823f, -0.03730914f, -0.01573737f, -0.00250554f, 
    -0.02158400f, 0.02794992f, 0.02568550f, 0.01139338f, -0.02736621f, -0.01478001f, -0.00930437f, 0.00626207f, 
    0.03250931f, -0.01364076f, 0.01530915f, -0.00602410f, -0.00006333f, -0.00950260f, 0.00522006f, -0.03471337f, 
    -0.03095715f, -0.03932422f, 0.00728433f, 0.02248713f, 0.01408360f, 0.01969828f, -0.01396709f, -0.03572515f, 
    -0.00898951f, 0.03809049f, -0.01613817f, -0.04038161f, -0.00251347f, 0.01235532f, -0.03621751f, -0.00369496f, 
    -0.03429715f, -0.03365848f, -0.00341426f, 0.00643976f, -0.02334462f, 0.01606758f, -0.00299043f, -0.02590896f, 
    0.00437031f, -0.01137010f, -0.03602640f, 0.01067734f, -0.03800068f, -0.03339323f, -0.01450116f, 0.00528338f, 
    -0.03125038f, -0.03111772f, 0.01896531f, -0.00953902f, -0.00149447f, -0.04143019f, -0.02385523f, -0.03948782f, 
    0.02084958f, -0.00854704f, -0.02314015f, 0.02572230f, -0.00573409f, 0.00873809f, -0.02144896f, -0.02885204f, 
    -0.02400071f, -0.01904014f, -0.00335238f, 0.00289364f, -0.01089326f, -0.01393397f, -0.02651357f, 0.02007906f, 
    -0.00754048f, 0.01753080f, 0.01591162f, 0.03457325f, -0.01075640f, 0.00257861f, 0.00542238f, 0.02916190f, 
    0.00352143f, 0.00735469f, -0.02949666f, -0.01032276f, -0.04616112f, 0.00765965f, -0.03023020f, -0.01336789f, 
    0.03555688f, -0.00571890f, 0.01491398f, -0.00577081f, 0.01812615f, 0.00613620f, -0.00012687f, 0.01900082f, 
    -0.02341362f, -0.03270262f, -0.03007191f, -0.04115056f, -0.00455530f, -0.00790231f, -0.01146153f, 0.01641966f, 
    -0.01874341f, 0.02172752f, -0.01083677f, -0.04112164f, -0.01717835f, -0.00653072f, -0.02393983f, -0.02756864f, 
    -0.00534808f, -0.01922624f, -0.04300903f, -0.01690892f, -0.01422734f, 0.00969285f, 0.02425907f, -0.02185801f, 
    0.02654556f, 0.01315832f, -0.02458820f, 0.00073952f, 0.00037076f, -0.04286066f, -0.00306398f, 0.02203098f, 
    0.00083041f, 0.00761161f, -0.03308081f, -0.02175615f, 0.00333523f, 0.01407183f, -0.03417382f, 0.01072510f, 
    -0.00753380f, 0.02047718f, -0.03281707f, -0.03838570f, 0.01027283f, 0.01262523f, 0.01342408f, 0.00820360f, 
    0.00906418f, 0.00144479f, -0.02388455f, 0.02733143f, 0.01162363f, 0.01895701f, 0.02652986f, -0.01780006f, 
    -0.02481493f, 0.01811615f, 0.01535709f, 0.00526049f, -0.02013774f, -0.01856961f, -0.01951527f, -0.02229069f, 
    -0.02187169f, -0.03424894f, -0.03849431f, -0.02226515f, 0.02296080f, 0.02302399f, 0.02753933f, 0.00513911f, 
    -0.03271922f, -0.03463496f, -0.00097185f, -0.02638705f, -0.01158424f, 0.02541037f, -0.00369427f, -0.00451884f, 
    -0.00548835f, 0.00532540f, -0.02528223f, -0.04287444f, -0.03495933f, 0.01233468f, -0.01686712f, -0.00023246f, 
    -0.03984186f, -0.01303861f, 0.01704225f, -0.00475738f, 0.00726385f, 0.01536800f, 0.01250685f, 0.01178537f, 
    -0.00225798f, -0.00292498f, -0.01774936f, -0.02893264f, -0.02072832f, 0.01223119f, -0.00436877f, -0.03492860f, 
    -0.00816347f, 0.00590689f, 0.01324717f, -0.01387714f, -0.00649162f, 0.00214391f, 0.00115609f, 0.01280036f, 
    -0.03461723f, -0.01150497f, 0.01875420f, 0.02831293f, -0.02234835f, 0.00491682f, 0.01723443f, -0.03395507f, 
    -0.03502819f, 0.00276394f, 0.01772102f, -0.04265317f, 0.00988736f, -0.03802028f, -0.03732201f, -0.00649343f, 
    -0.01933828f, -0.03494092f, -0.02301535f, -0.00021041f, -0.00749821f, 0.00602065f, -0.01043733f, -0.03414980f, 
    -0.03259752f, -0.01896080f, -0.00098342f, 0.00691159f, 0.00895958f, -0.01289547f, -0.02225164f, 0.02020984f, 
    -0.03125235f, 0.02001832f, -0.00783084f, -0.03301486f, 0.00473798f, -0.00631393f, 0.00052013f, 0.00063161f, 
    0.01657965f, -0.00903707f, 0.03857271f, -0.01928263f, -0.02165813f, 0.02516146f, -0.02210959f, -0.04553933f, 
    -0.01879697f, 0.03369462f, 0.01516654f, -0.03450464f, 0.01871978f, -0.01550463f, 0.02901118f, -0.03441072f, 
    0.01696315f, 0.01784005f, -0.00761566f, -0.01766177f, 0.01559925f, 0.02067894f, 0.01592738f, 0.02805845f, 
    0.00698857f, -0.00063236f, -0.03009684f, -0.03332224f, 0.00587877f, 0.02558409f, -0.03128990f, 0.01869628f, 
    -0.00656327f, 0.02006172f, 0.03001448f, -0.04329287f, -0.00342177f, -0.00479696f, 0.01316942f, -0.03218276f, 
    -0.01907214f, -0.03235978f, 0.00269365f, 0.02157378f, -0.02624129f, -0.01961243f, 0.01590609f, -0.04005861f, 
    -0.00266440f, 0.00518239f, -0.01453585f, 0.00279278f, 0.00268771f, 0.01641762f, -0.00312224f, 0.02411234f, 
    0.19591628f, -0.16360585f, -0.14400788f, 0.06669972f, 0.00579365f, 0.03334063f, 0.03610750f, -0.01574032f, 
    0.00530513f, 0.09062183f, 0.04196961f, -0.05721837f, 0.05805571f, 0.18673976f, -0.13561450f, -0.10401849f, 
    0.12413567f, 0.00202642f, -0.10657801f, -0.11243720f, -0.03372435f, -0.06338085f, -0.01047322f, -0.06339198f, 
    0.38523135f, -0.09786383f, 0.12936877f, 0.02850458f, 0.00846408f, -0.04502577f, 0.09912657f, 0.25334620f, 
    0.03354684f, -0.05877432f, -0.04639116f, 0.03086212f, 0.14357013f, 0.21952720f, 0.16589075f, 0.00647320f, 
    0.12099653f, 0.04527626f, -0.06919500f, -0.11351211f, 0.08567289f, 0.01486329f, 0.04222613f, 0.01674138f, 
    -0.03104417f, 0.02722521f, -0.00253198f, 0.23360041f, 0.00504558f, 0.05091661f, 0.04089982f, -0.05005934f, 
    -0.20468964f, 0.02960581f, -0.07534510f, -0.03888517f, -0.01424628f, -0.00799064f, -0.06880010f, 0.05424995f, 
    0.13771962f, 0.03893971f, 0.09871870f, 0.01582388f, 0.08415539f, 0.07517906f, 0.15614751f, 0.06826808f, 
    0.11570089f, 0.00857965f, 0.01199838f, 0.02780928f, -0.03693710f, 0.10827279f, -0.05433470f, -0.02117857f, 
    0.01758980f, -0.07379232f, -0.06105696f, -0.00789983f, 0.02638283f, 0.06719681f, 0.04351360f, -0.14242387f, 
    0.07846166f, -0.00947553f, 0.03826811f, 0.04302269f, 0.09207200f, 0.06774152f, -0.00150294f, 0.04938864f, 
    0.19436187f, -0.13821359f, -0.00114298f, -0.14955755f, -0.03878209f, -0.01588859f, -0.04418282f, 0.00641541f, 
    0.09586672f, -0.03166206f, 0.05908696f, -0.01905468f, -0.00823489f, -0.02973486f, 0.06849678f, -0.02335476f, 
    -0.01038603f, -0.05479712f, -0.08925523f, -0.03915276f, -0.01016613f, 0.10345324f, -0.06875627f, -0.05139412f, 
    0.10340840f, 0.28204358f, 0.07826095f, -0.04579055f, 0.03408593f, -0.00929243f, -0.06960214f, 0.14780067f, 
    0.09025849f, 0.04921484f, 0.01784756f, 0.09206403f, 0.07310494f, -0.05828303f, 0.02582676f, -0.26926026f, 
    0.00692924f, 0.11398646f, -0.09367491f, 0.06129724f, -0.01670690f, 0.00939167f, -0.06440338f, -0.08886454f, 
    0.40549839f, -0.06521601f, -0.04426928f, 0.23515442f, 0.01763275f, -0.07314776f, -0.04639135f, -0.00608797f, 
    0.07152789f, -0.07344849f, -0.02358714f, -0.08758110f, -0.06186868f, -0.09906250f, -0.18374446f, 0.23983121f, 
    -0.03995122f, -0.00647832f, -0.03712823f, 0.01720235f, 0.00213935f, 0.09023748f, -0.12576512f, -0.03908474f, 
    0.22476411f, 0.14220954f, 0.01697657f, 0.03451108f, -0.09524435f, 0.01470562f, -0.05435264f, -0.01278000f, 
    -0.14864650f, -0.08275404f, -0.08742767f, -0.07664824f, -0.00218088f, 0.18545754f, 0.10829523f, 0.01421136f, 
    -0.13977070f, -0.07963858f, -0.04342064f, 0.05014540f, -0.06712200f, 0.06424044f, 0.10902514f, -0.07557981f, 
    0.09817629f, -0.25011450f, 0.07531504f, 0.11219831f, 0.05325708f, -0.02070313f, 0.00840222f, 0.05356957f, 
    -0.12844409f, 0.03033750f, 0.05600133f, 0.08880055f, 0.38786256f, -0.07896171f, 0.03189493f, -0.02727462f, 
    0.16041221f, 0.09630681f, -0.00881771f, 0.01737846f, -0.02166427f, -0.12044517f, 0.00816034f, 0.04359112f, 
    0.12914045f, 0.13262856f, 0.01861141f, 0.15595473f, 0.07603575f, 0.06457527f, 0.07271149f, 0.09311222f, 
    0.07027484f, 0.00911106f, 0.02572159f, -0.00926809f, 0.21554434f, -0.02879805f, -0.04754286f, 0.00950169f, 
    -0.02389580f, -0.05495512f, 0.09856569f, -0.00976056f, -0.03914650f, 0.01582691f, -0.07153463f, -0.00362515f, 
    0.22007328f, 0.21590526f, -0.11363325f, 0.00825335f, -0.11683388f, 0.08412635f, -0.00235961f, 0.07457821f, 
    -0.08703668f, -0.13768125f, 0.17289937f, 0.04555761f, -0.08881672f, -0.05149671f, -0.03254602f, 0.00528155f, 
    0.13643663f, -0.01832403f, -0.00155114f, 0.10306422f, -0.00237853f, 0.02381458f, 0.06658805f, -0.07195283f, 
    0.22662120f, -0.02299240f, -0.04379894f, 0.13535352f, 0.05214768f, -0.17852756f, -0.03003884f, 0.02484608f, 
    -0.10383063f, -0.00133931f, 0.05168974f, 0.00918084f, -0.08705792f, 0.12590115f, 0.10968807f, -0.12332243f, 
    0.00952277f, 0.00109441f, 0.04387612f, 0.01513491f, 0.20477319f, 0.03582593f, 0.04101900f, -0.02711969f, 
    0.09379736f, -0.07167207f, 0.26318231f, -0.08296722f, 0.00403935f, -0.05264911f, 0.00588146f, -0.01248001f, 
    -0.01672527f, -0.06934936f, -0.09048285f, -0.09089134f, -0.16062173f, -0.01035491f, 0.04037138f, -0.24227093f, 
    0.06174605f, 0.07688767f, -0.07953656f, 0.15282927f, -0.08782019f, 0.02364107f, 0.06793623f, -0.03007905f, 
    0.01578680f, 0.02208647f, 0.22329940f, 0.17134190f, -0.10196329f, -0.09214410f, -0.03182591f, -0.05340151f, 
    -0.09181160f, 0.02320916f, 0.00627745f, -0.10548069f, -0.12039962f, 0.06890376f, 0.20058133f, 0.22817467f, 
    -0.06990722f, 0.07236867f, 0.00955870f, 0.03096640f, -0.02396968f, 0.05113347f, 0.08574649f, -0.10982354f, 
    0.17079768f, 0.20781706f, 0.17682497f, -0.01963373f, -0.14363943f, -0.05706494f, -0.09768471f, -0.12724504f, 
    -0.04498895f, 0.01477840f, 0.07148314f, -0.04553525f, 0.43748912f, -0.17085740f, -0.21288565f, 0.02868623f, 
    -0.06042457f, -0.11436691f, -0.04760804f, -0.05791692f, 0.14237061f, 0.10583040f, -0.04108646f, 0.02619944f, 
    -0.25469109f, 0.17964374f, -0.20077251f, 0.13756421f, -0.01923366f, -0.02608550f, 0.12640275f, -0.07132005f, 
    0.05987012f, 0.06649465f, 0.11010681f, -0.02895269f, 0.12765883f, -0.06046341f, -0.06999437f, -0.02297937f, 
    0.07065923f, -0.00377812f, -0.05751113f, -0.05366459f, 0.07833175f, 0.01268857f, 0.12939358f, 0.09526319f, 
    -0.09447456f, 0.37532187f, -0.18189992f, 0.40515259f, 0.04641705f, -0.03256288f, -0.05916165f, -0.12277142f, 
    0.06199287f, 0.06109124f, -0.03922961f, 0.00963568f, 0.30410838f, 0.08773882f, 0.05983105f, -0.16271207f, 
    0.05829234f, 0.04772080f, 0.00789614f, 0.04247373f, 0.04651022f, 0.13707905f, -0.05011631f, 0.04085006f, 
    -0.09571969f, 0.10354453f, -0.02832544f, -0.01449327f, 0.01744694f, 0.01966849f, 0.01261863f, 0.05340934f, 
    0.04682295f, 0.03955160f, -0.07327235f, -0.00068498f, 0.30621454f, -0.05799117f, 0.06473781f, -0.08322617f, 
    0.05162490f, -0.00690399f, 0.00184309f, -0.00116723f, 0.00974269f, -0.06416164f, -0.05369271f, -0.09217710f, 
    0.06313190f, 0.00706983f, -0.13997111f, 0.04460628f, 0.01134340f, 0.01300976f, -0.06263480f, 0.02805308f, 
    0.10187647f, -0.06264929f, 0.02325945f, -0.11700165f, -0.23769978f, -0.04728455f, 0.10643032f, 0.15831485f, 
    -0.05946809f, 0.04812609f, 0.07617433f, 0.22035527f, 0.05487916f, 0.01929971f, 0.07270844f, 0.00996492f, 
    0.19559367f, 0.16836599f, 0.11593677f, 0.06731179f, -0.08851432f, 0.04770207f, -0.00161930f, -0.08452050f, 
    -0.00020477f, -0.02776021f, -0.02085179f, -0.10037363f, 0.23742846f, 0.09879567f, -0.00769246f, -0.03670980f, 
    0.13331689f, -0.07504056f, -0.06230466f, 0.01076084f, 0.21218988f, 0.10363561f, 0.07877337f, 0.19993876f, 
    -0.15962389f, 0.08303905f, -0.06347692f, -0.03451363f, -0.02105115f, 0.07370219f, 0.05617637f, -0.06778342f, 
    -0.02994877f, 0.10272200f, -0.04568019f, -0.02448294f, -0.08994815f, 0.10271852f, -0.08892529f, 0.14671405f, 
    -0.07971864f, -0.03518474f, 0.06191163f, 0.08375800f, -0.13437001f, 0.07038451f, 0.03491801f, 0.03428899f, 
    0.34407032f, -0.05177632f, -0.16455220f, -0.01351872f, 0.01717054f, 0.06398571f, -0.05566029f, -0.01600322f, 
    0.15005113f, 0.04777550f, 0.04497562f, -0.02589429f, 0.06840353f, 0.11829396f, 0.04677521f, -0.00132183f, 
    0.08714927f, -0.00939948f, -0.06606910f, -0.02467181f, -0.17561777f, 0.05474187f, 0.15908591f, 0.04211164f, 
    -0.31520876f, 0.24023061f, 0.02199456f, -0.09138393f, -0.03635065f, 0.12473515f, 0.12277929f, 0.05679119f, 
    -0.02982113f, 0.02350195f, 0.07471131f, -0.03263070f, -0.12278562f, -0.03715488f, 0.13233751f, -0.06492465f, 
    -0.09685228f, 0.09794409f, 0.00270739f, -0.10594994f, -0.22227275f, -0.08377168f, 0.00613414f, -0.12960371f, 
    -0.01138398f, -0.03341500f, -0.01592391f, -0.20428436f, -0.05069108f, 0.09808233f, -0.09143288f, 0.04133429f, 
    0.00457497f, -0.08581226f, 0.01679676f, -0.03823795f, -0.11136439f, 0.00101725f, -0.11549320f, 0.06528278f, 
    -0.12285376f, 0.00197170f, -0.03935047f, 0.15084018f, 0.02060693f, 0.04450301f, 0.09572847f, -0.01712197f, 
    0.20083474f, 0.00230605f, -0.15225066f, 0.08422309f, 0.13918999f, -0.08077541f, 0.03602699f, 0.05951348f, 
    0.00007220f, 0.05967814f, 0.01716338f, 0.00004334f, -0.13193424f, 0.08169782f, -0.08400815f, 0.16560528f, 
    0.12729511f, -0.03155912f, 0.01185506f, -0.02634088f, 0.03327762f, 0.03258697f, 0.04564827f, -0.01790925f, 
    -0.20917679f, 0.09747693f, -0.03421956f, -0.09172136f, 0.13045239f, -0.02087298f, 0.07255749f, -0.00562546f, 
    0.07571486f, -0.03548871f, 0.04458692f, 0.01207512f, -0.07921845f, -0.14059454f, -0.03502656f, 0.07828295f, 
    0.08379645f, 0.00383081f, 0.01116901f, -0.06299913f, 0.06816443f, 0.08432846f, 0.00071318f, -0.05742174f, 
    0.08180686f, -0.03473422f, 0.07525554f, -0.05439809f, 0.13785960f, 0.04698804f, -0.07313424f, -0.05282732f, 
    -0.00228886f, 0.09872431f, 0.09417611f, -0.01568436f, -0.21598820f, 0.01924810f, 0.14035246f, 0.00186183f, 
    0.02914700f, -0.03711611f, 0.09364032f, 0.01756997f, 0.06164770f, 0.00440460f, -0.03093417f, 0.01786885f, 
    -0.14202017f, 0.00593689f, -0.15358271f, 0.33072597f, 0.08641040f, 0.01902722f, 0.11365303f, -0.03211625f, 
    0.04524308f, 0.05789048f, -0.03516594f, 0.07057261f, 0.12474378f, 0.02370207f, 0.00535121f, -0.17125697f, 
    0.11799803f, -0.08804952f, 0.15638611f, -0.10935104f, -0.02008132f, -0.00266881f, -0.02259585f, 0.02687579f, 
    -0.09597559f, 0.12110396f, -0.25226444f, 0.04423483f, 0.09821993f, 0.12013670f, -0.01915282f, 0.09786589f, 
    0.03872450f, -0.02636025f, -0.08625113f, -0.08688565f, 0.14839993f, 0.00539117f, -0.06546366f, -0.05574858f, 
    -0.06008381f, 0.01296728f, 0.01228673f, -0.00088834f, 0.03650167f, -0.07024786f, -0.06440600f, -0.03576196f, 
    0.09309638f, -0.10257521f, -0.02376115f, -0.17266901f, -0.02608489f, 0.01274714f, -0.02418719f, 0.07001811f, 
    -0.00842890f, 0.12040845f, 0.08657801f, -0.00470024f, 0.05907747f, -0.08880836f, -0.15608791f, 0.00777742f, 
    0.06440565f, -0.02108163f, -0.02902556f, -0.08240826f, -0.05099250f, 0.06871492f, 0.12235565f, -0.00111521f, 
    0.46269372f, 0.00609469f, -0.07812005f, 0.01832148f, 0.04006869f, 0.08105607f, 0.00064815f, 0.01354962f, 
    -0.04394909f, 0.01056672f, -0.02910532f, -0.02301500f, 0.25094655f, -0.16967505f, -0.04367113f, 0.06467469f, 
    0.01200574f, 0.02416021f, 0.01663082f, 0.00119443f, 0.02898014f, -0.03391926f, -0.12617615f, 0.02003686f, 
    -0.12130141f, -0.03708507f, -0.05732460f, 0.31424463f, 0.13492143f, -0.03295847f, 0.12647977f, -0.00930650f, 
    -0.00710343f, 0.02985629f, -0.10498568f, -0.12285321f, 0.05508558f, 0.18964443f, -0.01225204f, -0.03103326f, 
    -0.08759945f, 0.23701128f, -0.00156855f, 0.01356692f, -0.04712329f, 0.09991092f, -0.03309010f, -0.01614202f, 
    -0.02318159f, -0.01836523f, -0.04337519f, -0.04169734f, 0.00924612f, -0.01496821f, 0.01453093f, 0.01108205f, 
    -0.02582500f, -0.02834624f, -0.04358683f, -0.04104461f, 0.01622206f, 0.01996085f, -0.01930456f, -0.02390731f, 
    -0.00708283f, 0.01602971f, 0.01032114f, -0.00439773f, -0.01396522f, 0.00855889f, -0.00739203f, 0.00251239f, 
    -0.02978656f, 0.00595529f, 0.02026828f, -0.01087888f, 0.02161431f, -0.03319590f, -0.00180011f, -0.02748653f, 
    0.00026642f, 0.01641880f, -0.01011100f, 0.01219371f, 0.00526230f, -0.00273829f, -0.00100882f, -0.02413714f, 
    0.02336460f, -0.03341896f, 0.01666637f, 0.00777799f, -0.02615824f, -0.03178535f, -0.00762544f, -0.02963275f, 
    -0.02349208f, 0.00794272f, -0.02980997f, -0.02270253f, -0.01395048f, -0.00505093f, -0.01080875f, -0.03449459f, 
    -0.04036370f, -0.02404755f, 0.00308327f, 0.02068629f, -0.00234251f, -0.00703214f, -0.01076418f, 0.00367978f, 
    -0.01904140f, -0.03430225f, 0.02121910f, -0.02615377f, -0.03781576f, -0.02080723f, 0.00421312f, -0.03295703f, 
    0.01044805f, -0.00135578f, -0.02749859f, -0.04093493f, -0.04519528f, -0.03334705f, 0.01182224f, 0.01558253f, 
    -0.01477557f, 0.01809660f, 0.01367642f, -0.00334176f, -0.00250851f, 0.01347833f, -0.02112351f, 0.01888736f, 
    -0.01563597f, -0.01470012f, 0.01930308f, -0.04088960f, -0.03251010f, -0.00416559f, 0.00838783f, -0.01327411f, 
    -0.01660482f, -0.01606089f, -0.01870153f, 0.02086275f, 0.01449992f, -0.02527028f, 0.02274136f, 0.00167110f, 
    -0.03466645f, 0.00448985f, -0.01286877f, -0.03695905f, 0.01807068f, -0.01980388f, -0.01958020f, -0.01253193f, 
    -0.02905075f, -0.03404722f, 0.00547446f, -0.00583549f, -0.03389065f, -0.02838159f, 0.00107349f, 0.00324164f, 
    -0.03182610f, -0.03642837f, -0.02858369f, -0.03564168f, -0.02357671f, -0.00562645f, -0.02438257f, -0.03006428f, 
    0.00559923f, -0.02703521f, 0.01575888f, 0.00317225f, -0.02991879f, -0.01546641f, -0.01040411f, 0.02198729f, 
    0.01484480f, -0.00186993f, 0.01862812f, -0.02905368f, -0.03834920f, 0.03310766f, -0.04277650f, 0.01016282f, 
    0.00919366f, -0.04041161f, -0.04539187f, -0.01071468f, -0.01158495f, -0.00708228f, 0.01902496f, -0.01233171f, 
    -0.04158416f, -0.04097008f, -0.00458664f, 0.01526481f, 0.01523423f, -0.01559090f, -0.02239213f, -0.01197910f, 
    0.01481418f, 0.00451629f, -0.02909248f, -0.04428316f, 0.02153150f, -0.01625062f, -0.03289491f, -0.03993058f, 
    0.00094276f, -0.01224690f, -0.01070662f, 0.00228359f, -0.04030510f, -0.02697893f, -0.00377178f, 0.02381501f, 
    -0.00752080f, -0.03162493f, 0.01006313f, -0.00571528f, -0.02938893f, -0.03777278f, -0.03028934f, 0.00655827f, 
    -0.03126711f, -0.03517270f, 0.00816642f, -0.01487728f, -0.04246473f, -0.01033685f, -0.03542926f, -0.02973067f, 
    -0.02305891f, 0.01723260f, 0.00436512f, 0.00417966f, 0.00365486f, 0.00725555f, -0.02232996f, -0.01870140f, 
    -0.02823463f, -0.04525261f, -0.03121181f, 0.01314604f, -0.00518186f, -0.02075974f, -0.00937382f, -0.00311461f, 
    -0.00571922f, 0.00230121f, -0.01784136f, 0.00208406f, -0.02537713f, -0.04455081f, -0.01386772f, -0.00594243f, 
    -0.00549783f, -0.00720099f, -0.04235446f, -0.01132717f, -0.02772412f, -0.01110937f, 0.02513450f, 0.01541060f, 
    0.02415201f, -0.01680696f, 0.00632883f, -0.00997423f, 0.02184281f, 0.01784495f, 0.00219801f, 0.01644870f, 
    -0.00167133f, -0.01149482f, 0.01781508f, -0.02412507f, -0.04259964f, 0.00372862f, 0.01427041f, -0.00226357f, 
    -0.01654444f, -0.02693967f, 0.01542021f, -0.01305457f, -0.03381890f, 0.00431450f, -0.02397305f, -0.00656666f, 
    -0.01138339f, -0.01472107f, 0.01671384f, -0.04024919f, 0.01109087f, -0.02118954f, -0.01270121f, 0.00033785f, 
    0.02134305f, -0.00834806f, 0.01954936f, 0.00996000f, 0.02552172f, -0.04168857f, -0.00078535f, -0.00035454f, 
    0.02448458f, -0.00174988f, -0.02657505f, 0.01740328f, 0.01691408f, 0.01272840f, 0.01601388f, -0.01322284f, 
    -0.02652356f, -0.00559095f, -0.02957002f, 0.02150100f, -0.01686151f, -0.00547207f, 0.01929474f, 0.01362813f, 
    0.00140431f, -0.03430428f, -0.03916451f, -0.02515228f, -0.01032993f, -0.01197659f, -0.00294086f, -0.02284342f, 
    -0.03581266f, -0.03188859f, -0.04197864f, 0.01032524f, 0.01374653f, -0.01709422f, 0.02578762f, -0.00765989f, 
    0.00161030f, -0.03433686f, 0.02627935f, 0.00681906f, -0.01934248f, -0.03424486f, 0.01699416f, -0.00229605f, 
    -0.03491707f, 0.00270481f, -0.00959924f, -0.01984513f, -0.03664143f, -0.01428611f, 0.01183923f, -0.02207725f, 
    -0.04500527f, 0.02094400f, -0.01589515f, 0.02816429f, 0.00255289f, -0.03945381f, -0.02244481f, -0.01539676f, 
    0.01225740f, -0.00814262f, -0.03519560f, 0.02177804f, 0.00146608f, -0.03834734f, -0.00025784f, -0.01377884f, 
    -0.01666002f, 0.00416651f, 0.00113654f, -0.02869865f, -0.02542324f, -0.04423740f, -0.01607521f, 0.00963275f, 
    0.00788522f, 0.00090169f, -0.03456639f, 0.02197244f, 0.01138910f, -0.01298493f, -0.01131069f, 0.01439234f, 
    -0.03513009f, 0.01458303f, 0.02339670f, -0.00942733f, -0.00441648f, -0.04228733f, -0.02801562f, 0.02604957f, 
    0.01841218f, 0.00316181f, -0.02053694f, -0.02608079f, -0.02047230f, -0.03290422f, -0.02457567f, 0.00219890f, 
    -0.02109586f, -0.01005420f, 0.01051982f, -0.00255359f, -0.00279248f, 0.00337578f, -0.00059026f, -0.03303894f, 
    -0.03168380f, 0.01066237f, -0.02479386f, -0.04221585f, -0.00674235f, 0.00903053f, -0.03494141f, -0.03842247f, 
    0.01187237f, 0.01696313f, -0.01694909f, 0.00665525f, 0.01288326f, -0.03713195f, 0.00283023f, 0.01735449f, 
    0.00774398f, -0.02569576f, -0.00150862f, -0.04220406f, 0.00864279f, -0.01077411f, -0.03715597f, -0.02226957f, 
    0.01178525f, -0.01107983f, -0.01973924f, 0.00884594f, -0.01502728f, -0.01513676f, -0.01876304f, 0.00587092f, 
    0.00795024f, -0.02912313f, 0.00363112f, -0.01163692f, -0.04079314f, 0.00047016f, -0.01331600f, -0.00065608f, 
    0.01614207f, 0.01473536f, -0.04150565f, 0.01188485f, -0.03271087f, -0.00239164f, 0.02109704f, 0.02315487f, 
    -0.03025303f, 0.02163471f, -0.03735935f, 0.00121182f, 0.00226544f, -0.02209003f, -0.02735791f, -0.03182007f, 
    -0.02531943f, 0.02582931f, 0.00483473f, -0.02001913f, -0.01080289f, -0.00069047f, -0.03334514f, -0.04013496f, 
    0.00851559f, -0.03625748f, 0.01195258f, 0.00945904f, -0.03568767f, -0.03280703f, -0.03021574f, -0.03448562f, 
    0.01823183f, 0.02440932f, -0.02139337f, -0.02195993f, -0.02427218f, 0.02378925f, -0.03514967f, -0.00663255f, 
    -0.00112551f, -0.02324142f, -0.02561065f, -0.03191023f, -0.01704845f, -0.02511550f, -0.01779548f, -0.03253889f, 
    -0.02159676f, -0.03771128f, 0.00996395f, -0.04525824f, -0.03353437f, -0.03309800f, -0.03276359f, -0.00636011f, 
    0.02342117f, -0.01643439f, 0.01735006f, -0.01589748f, -0.04185201f, 0.00891631f, -0.03929302f, -0.01526507f, 
    -0.02954805f, -0.01416776f, -0.02553323f, -0.00824635f, -0.01885728f, -0.02012013f, -0.02969837f, -0.00760876f, 
    -0.02231886f, -0.03337403f, -0.00629774f, 0.00379063f, 0.03012003f, -0.04090932f, 0.01039107f, -0.04275429f, 
    -0.01842652f, 0.00791407f, -0.02971762f, -0.01088438f, -0.02448922f, -0.04257271f, -0.01415836f, -0.03031649f, 
    -0.02562100f, -0.04411044f, -0.01567224f, -0.01186461f, -0.00497341f, -0.01294530f, 0.01134781f, 0.01076211f, 
    -0.00581975f, -0.04253816f, -0.02948623f, -0.04295803f, 0.02953723f, 0.01678960f, 0.01315518f, 0.02277808f, 
    0.01157620f, -0.03808985f, -0.03955156f, -0.02121506f, -0.03211608f, 0.01225177f, -0.00854579f, -0.04122959f, 
    0.02625033f, -0.00221570f, -0.04011409f, -0.00578269f, 0.00295181f, -0.02358268f, -0.01453954f, 0.01142441f, 
    -0.03135416f, 0.01250429f, -0.03356126f, -0.00022570f, -0.01393653f, -0.04027043f, -0.00128291f, 0.01941998f, 
    0.02491366f, 0.00728182f, -0.03448973f, 0.01576556f, 0.01656520f, 0.02280765f, 0.01083360f, 0.02495424f, 
    -0.00443494f, -0.03979714f, -0.02150811f, -0.00836768f, -0.02811982f, -0.03406379f, 0.02095990f, 0.00234576f, 
    0.00874801f, -0.00627619f, 0.00478119f, 0.00730627f, 0.00716944f, -0.03537173f, 0.02038031f, -0.04557499f, 
    -0.00384969f, -0.04058105f, 0.00618913f, 0.01815289f, -0.01335036f, -0.04268295f, -0.02227793f, 0.02601499f, 
    -0.03170060f, -0.03538071f, 0.01887995f, -0.03547668f, -0.03703756f, -0.00377890f, -0.00317147f, 0.01177758f, 
    -0.02279808f, 0.02155399f, -0.00100782f, 0.02316547f, -0.00030810f, -0.02682282f, -0.00080509f, -0.00268556f, 
    -0.01320883f, -0.03521781f, -0.03805380f, 0.01982137f, -0.00793348f, -0.02630848f, 0.01377074f, -0.01149171f, 
    -0.01295863f, 0.00613422f, 0.00218716f, 0.01659943f, 0.00491920f, -0.02096684f, 0.02538321f, -0.04243974f, 
    -0.01942275f, -0.02931827f, -0.04027071f, -0.01145867f, 0.01428156f, -0.01842536f, -0.01044604f, -0.02502208f, 
    0.02622140f, -0.02111172f, -0.01246881f, -0.02826885f, -0.03641903f, -0.03088748f, -0.00095270f, -0.01292405f, 
    -0.03002508f, 0.02961743f, 0.01179385f, 0.01565820f, -0.01891520f, -0.01566567f, 0.01150494f, 0.02518827f, 
    -0.02686968f, -0.00805327f, 0.02366347f, -0.00058911f, -0.02331536f, -0.01408962f, -0.02504330f, -0.03829298f, 
    -0.01953833f, -0.02019967f, 0.00316626f, 0.01743938f, -0.03061582f, 0.02288183f, -0.04356656f, -0.00728826f, 
    -0.01055881f, 0.02255598f, -0.04257329f, 0.02334525f, 0.00449865f, -0.03340220f, 0.01494350f, -0.04357180f, 
    0.00602220f, -0.04537882f, 0.01383213f, -0.04392755f, 0.00603124f, -0.01026699f, -0.00590361f, -0.02956098f, 
    -0.02634883f, -0.02037957f, 0.02370097f, -0.02646355f, 0.01069197f, 0.02377871f, -0.02257841f, -0.03522426f, 
    -0.01662242f, -0.04026461f, -0.00215041f, -0.04535761f, -0.03138940f, -0.03188148f, -0.03104488f, -0.03041471f, 
    -0.03652941f, -0.02403546f, -0.01129635f, -0.04546884f, -0.02349773f, -0.01115954f, -0.00556184f, -0.00223230f, 
    -0.00547152f, -0.02096038f, -0.00828168f, -0.00942139f, -0.00607458f, -0.02227255f, 0.01128201f, 0.01750711f, 
    -0.00560308f, -0.03763872f, 0.01385105f, 0.00202260f, -0.00865352f, -0.01523806f, -0.02173522f, -0.02041432f, 
    -0.02794512f, 0.01741456f, -0.01915797f, -0.01720097f, 0.00884248f, 0.01825313f, -0.02770522f, -0.01230653f, 
    0.00771558f, -0.02318208f, -0.04101038f, -0.01856469f, 0.00174623f, -0.04508654f, -0.00617377f, -0.00039969f, 
    -0.03149442f, -0.02818201f, 0.00488434f, -0.04285347f, -0.00857203f, 0.00780843f, -0.03851155f, 0.00843124f, 
    -0.03563427f, -0.04199201f, -0.04329947f, 0.00559959f, -0.02283203f, -0.00817058f, 0.01508574f, 0.01357995f, 
    -0.00020659f, 0.01184897f, 0.01420470f, -0.04263130f, -0.03116345f, -0.01106761f, -0.01467694f, -0.02356319f, 
    0.00345711f, -0.01519422f, -0.00996917f, -0.03654050f, -0.01225328f, -0.01586050f, 0.00330936f, -0.01134819f, 
    -0.00367608f, -0.01242308f, -0.01185225f, -0.01577479f, -0.01456858f, 0.02444634f, 0.01051858f, 0.01730421f, 
    -0.01753125f, -0.01898037f, -0.02136732f, 0.02363124f, 0.01149963f, -0.00915123f, -0.03078535f, -0.02805401f, 
    0.00964114f, -0.02792158f, -0.01778452f, 0.02486526f, -0.01012741f, -0.03104845f, -0.03095477f, 0.02607056f, 
    -0.03038510f, 0.00298227f, 0.02722787f, -0.02590661f, -0.03699192f, 0.01025718f, -0.03718412f, 0.01674496f, 
    0.01598823f, 0.01758189f, -0.03560409f, 0.01730820f, -0.03123159f, 0.02608200f, -0.00249008f, 0.01997983f, 
    -0.02697288f, 0.00185567f, 0.02014351f, -0.01077245f, 0.00588823f, 0.01556375f, 0.01684688f, 0.00376136f, 
    -0.01126184f, -0.00475933f, -0.03654680f, 0.02046039f, -0.00478804f, -0.00974150f, -0.01332484f, 0.02648237f, 
    0.01006572f, 0.01212143f, -0.01396049f, 0.01517618f, -0.00441388f, 0.00743051f, -0.01846478f, -0.00716179f, 
    0.00145500f, -0.00191838f, -0.03228492f, 0.01458138f, -0.00845420f, 0.01629259f, -0.02486794f, 0.02027818f, 
    -0.00891498f, 0.00033333f, 0.03173905f, -0.00387076f, 0.00341326f, -0.00379285f, 0.02175880f, -0.00869925f, 
    -0.02989219f, -0.03086968f, -0.00337337f, -0.00415055f, 0.00865179f, -0.02505199f, 0.02463562f, -0.00145932f, 
    -0.00270713f, 0.00811540f, 0.00229191f, -0.03505226f, 0.02648952f, -0.00587739f, -0.02571106f, -0.00352377f, 
    0.01200376f, 0.00991698f, -0.02479265f, -0.01335285f, 0.01727972f, -0.04068867f, 0.00146871f, 0.02907080f, 
    0.00221052f, -0.03576529f, -0.03200095f, 0.03030313f, 0.00970381f, 0.01115156f, 0.02269586f, 0.01595390f, 
    -0.03141232f, 0.01093386f, -0.03163768f, -0.02349079f, 0.01217188f, 0.00862117f, 0.00082060f, 0.01906733f, 
    -0.03400839f, -0.02352627f, -0.00598051f, 0.01386691f, 0.01453784f, -0.01555084f, -0.03270252f, 0.02135362f, 
    -0.01355135f, 0.00811336f, 0.02878260f, 0.00463154f, 0.01129785f, 0.01294944f, -0.03170491f, -0.01610254f, 
    0.02690057f, 0.00112490f, 0.00383046f, -0.03493077f, 0.03011713f, -0.02245277f, -0.00272961f, 0.01714060f, 
    0.01188751f, 0.00409902f, -0.02089554f, 0.01883642f, -0.03085064f, -0.03579279f, -0.02759810f, 0.01299188f, 
    -0.01783848f, 0.02398665f, -0.02154777f, -0.03009984f, -0.00873609f, -0.01806519f, -0.03174977f, 0.03696582f, 
    -0.01859312f, 0.02603081f, -0.01786496f, 0.01870631f, 0.00900740f, -0.02623989f, 0.01723279f, -0.00520526f, 
    -0.03469691f, -0.00802530f, 0.01014154f, -0.01703738f, 0.02845308f, 0.00068940f, -0.02522155f, -0.00359432f, 
    -0.01438434f, -0.00557710f, 0.01485700f, -0.01017342f, -0.00220188f, -0.00814296f, -0.01902506f, -0.03743311f, 
    -0.01637893f, -0.02330764f, -0.00953546f, 0.00005130f, -0.01756453f, -0.03364412f, -0.00089818f, -0.00654518f, 
    0.00415548f, 0.03412130f, 0.02745931f, -0.01748363f, 0.03762406f, -0.02959315f, 0.00135799f, -0.01012933f, 
    -0.03120827f, -0.02472804f, 0.01143657f, 0.01019247f, 0.00833443f, -0.02316538f, 0.01715970f, -0.03009685f, 
    0.03521097f, -0.03100030f, -0.01978049f, -0.02707848f, 0.00353044f, -0.03401599f, 0.02931451f, 0.02337751f, 
    -0.00400923f, 0.02312549f, 0.03282369f, -0.02297379f, 0.01825016f, 0.01997823f, 0.00418582f, -0.01747823f, 
    0.00636367f, -0.00993241f, -0.03451726f, 0.01511863f, -0.00999698f, -0.03446711f, -0.03239506f, -0.00065294f, 
    0.00815720f, 0.02899683f, 0.01420897f, -0.00802115f, -0.02301635f, 0.00218718f, -0.01726975f, 0.01277718f, 
    -0.01816248f, -0.00627043f, 0.02486102f, 0.00030274f, 0.00425271f, -0.01847440f, -0.02412367f, -0.01895088f, 
    -0.02025739f, -0.00619271f, -0.01508010f, -0.01149151f, 0.02897911f, -0.01044215f, 0.01302263f, -0.01008161f, 
    0.00404302f, -0.00138494f, -0.01419683f, -0.02512569f, 0.00700272f, -0.02697989f, 0.02211653f, -0.03498713f, 
    -0.02285854f, -0.00743766f, -0.01266735f, 0.02286539f, 0.01345709f, -0.00301125f, 0.03036737f, -0.03186461f, 
    -0.02071865f, -0.00160281f, 0.02540061f, 0.02061475f, -0.00616103f, -0.01647104f, 0.02393458f, -0.03353478f, 
    -0.03041854f, -0.01640811f, -0.03776238f, -0.02961250f, 0.02860067f, 0.02617454f, 0.00116415f, -0.02120651f, 
    0.02033859f, -0.00735631f, -0.01087155f, 0.02836104f, 0.01936619f, -0.00952885f, 0.00907790f, -0.01074393f, 
    0.00279502f, -0.00753264f, 0.01291797f, 0.02786849f, -0.02988426f, -0.01773610f, -0.01424037f, 0.01791256f, 
    0.00295645f, -0.00002467f, -0.03292909f, -0.00564974f, 0.00431848f, 0.01076959f, 0.00553573f, 0.03386787f, 
    -0.01638420f, -0.03095491f, -0.01452664f, 0.01543781f, 0.01983153f, -0.00874007f, 0.00946752f, -0.01098160f, 
    0.00981914f, -0.00511149f, -0.03258990f, 0.01579147f, 0.00813449f, -0.01412663f, -0.01920943f, 0.02339759f, 
    -0.01443962f, 0.02433398f, -0.01808829f, 0.02589811f, 0.00377705f, 0.01956430f, -0.02273499f, 0.03329373f, 
    -0.02497562f, -0.00011541f, -0.03537288f, 0.02186491f, 0.02512865f, 0.01592428f, 0.02808623f, -0.02700504f, 
    0.00663934f, 0.00912546f, 0.00594793f, -0.01522079f, 0.03322660f, 0.00716780f, -0.00975073f, -0.02357611f, 
    0.02632350f, -0.02106250f, -0.03689998f, 0.01140445f, -0.02443133f, 0.00613928f, 0.00520302f, -0.01365854f, 
    0.02442253f, 0.02993728f, -0.02439744f, -0.02424467f, -0.00275669f, 0.00899957f, -0.02774931f, -0.03833128f, 
    -0.02183719f, -0.00869789f, -0.03388079f, 0.00146183f, -0.01171206f, -0.00442858f, 0.02694622f, -0.03012487f, 
    -0.02728193f, 0.00162679f, -0.02903965f, -0.01994438f, 0.03005658f, 0.01976727f, -0.01262649f, 0.00128440f, 
    0.01048446f, 0.01776818f, 0.00637107f, -0.01416601f, 0.02624246f, -0.01452278f, 0.01993071f, -0.02489391f, 
    0.02067973f, -0.02466247f, -0.00345766f, 0.01696218f, -0.02216644f, -0.02828039f, 0.01103829f, -0.02347686f, 
    -0.03555425f, 0.02342883f, -0.00456735f, -0.03120883f, -0.03768595f, 0.01519738f, -0.02532115f, -0.01215507f, 
    0.01697782f, 0.02026308f, -0.03617928f, -0.01488610f, 0.00839528f, -0.00982228f, -0.03127384f, -0.02827566f, 
    -0.01093028f, -0.02999768f, -0.00640340f, 0.02962272f, 0.00827518f, -0.00704375f, 0.01978016f, 0.02941988f, 
    -0.00179535f, -0.02068015f, 0.03325617f, 0.02491355f, 0.03091042f, -0.00417719f, -0.01714723f, 0.00173386f, 
    0.01757506f, -0.00555186f, 0.01379659f, 0.00601705f, 0.00853071f, 0.02963375f, -0.01327362f, -0.02210755f, 
    -0.01750020f, -0.01640338f, 0.00113208f, -0.02795313f, 0.01271263f, 0.00791359f, -0.00261049f, -0.01079941f, 
    -0.02959124f, -0.03802744f, 0.00827288f, -0.01831174f, -0.00340416f, -0.03109637f, 0.01179259f, 0.03361541f, 
    -0.03903596f, 0.01005660f, -0.03020977f, 0.02156688f, 0.02287768f, 0.01532030f, -0.00373256f, -0.01654865f, 
    -0.03478388f, 0.00712242f, 0.00291605f, 0.01582239f, 0.01968966f, -0.02733121f, 0.01903911f, 0.01533674f, 
    -0.01604376f, -0.00698445f, 0.00365054f, 0.00670829f, 0.00922780f, -0.00767562f, 0.00959731f, 0.02018939f, 
    -0.00628179f, -0.00075664f, -0.02391362f, 0.02084371f, 0.02726247f, 0.00315769f, 0.01698886f, 0.01291187f, 
    -0.01995565f, 0.00683392f, -0.00994105f, 0.00412166f, -0.01282701f, -0.01705332f, -0.01745436f, -0.03014126f, 
    -0.02292112f, -0.00797636f, 0.01269565f, -0.01614622f, 0.02644166f, 0.01680977f, -0.02329218f, 0.00636896f, 
    0.01887264f, 0.02419840f, 0.00650990f, 0.02073514f, 0.02947346f, 0.01297696f, -0.02602584f, -0.02485884f, 
    0.00080013f, -0.00493770f, -0.00536317f, -0.02709323f, 0.03311301f, 0.01018009f, 0.03173418f, -0.01001860f, 
    0.00402085f, 0.00022405f, -0.02252418f, -0.03392785f, -0.01896293f, 0.03341037f, 0.01086561f, 0.00937666f, 
    -0.03243426f, 0.00610760f, -0.01711215f, -0.03286171f, -0.03015528f, 0.00846535f, -0.00058380f, 0.00809818f, 
    -0.03732411f, 0.01736556f, -0.00819282f, -0.03455383f, 0.01129289f, -0.02944759f, 0.02784564f, -0.01315590f, 
    0.01717375f, 0.01150500f, 0.03340955f, -0.02613268f, 0.01085635f, 0.02472677f, -0.00290084f, 0.00734602f, 
    0.01376904f, -0.01461934f, -0.00552389f, -0.00078209f, 0.02929438f, -0.01037710f, 0.03506077f, 0.01233946f, 
    -0.00412918f, -0.01769884f, -0.01268755f, 0.01607343f, 0.01380324f, -0.03249242f, 0.02719519f, 0.01841656f, 
    0.00228603f, 0.03879120f, -0.03698888f, -0.02673882f, 0.00038373f, 0.00460223f, -0.01884477f, 0.01722482f, 
    -0.00510323f, 0.01510635f, 0.01362517f, -0.02024849f, -0.00925129f, -0.02824110f, 0.02024281f, -0.02485164f, 
    -0.02243581f, 0.02015882f, 0.02916389f, 0.00119221f, 0.00793633f, 0.03022363f, -0.02228595f, -0.02546391f, 
    0.01740676f, -0.02404087f, 0.02755507f, -0.00987608f, 0.02468133f, 0.01318370f, 0.02810601f, 0.00110283f, 
    0.01640599f, 0.03036169f, 0.02085479f, -0.00262906f, 0.03105221f, -0.00288987f, 0.01489002f, 0.00543454f, 
    0.00546879f, 0.02174076f, -0.01180209f, -0.03402893f, -0.03157188f, 0.02170088f, -0.01414284f, 0.03058327f, 
    0.00773132f, 0.01666092f, -0.00328824f, -0.02776003f, 0.00983781f, -0.02223336f, -0.03606328f, 0.01024352f, 
    0.02176933f, -0.01412275f, 0.00061400f, -0.02385930f, -0.00093379f, -0.01504114f, 0.02408529f, 0.00226292f, 
    -0.00365111f, 0.01316628f, -0.01738356f, -0.03117444f, -0.01095316f, -0.01337535f, -0.02212617f, 0.00996609f, 
    -0.02800990f, 0.01058925f, 0.01697179f, 0.00698115f, -0.00585153f, 0.03416802f, 0.01261350f, -0.00103041f, 
    -0.01511438f, -0.02922749f, 0.02403524f, -0.03394458f, 0.01496916f, 0.00555732f, -0.01377053f, -0.01754301f, 
    0.01931129f, -0.02570941f, 0.00537667f, 0.02992922f, -0.01287365f, -0.02705791f, 0.01098954f, -0.02723366f, 
    -0.01151511f, 0.01259180f, 0.00375503f, -0.02854934f, -0.01731186f, 0.03076465f, -0.03097657f, 0.00231955f, 
    -0.00457297f, -0.00136535f, -0.00576865f, -0.03248957f, -0.03279109f, -0.00593521f, 0.00889086f, 0.01847698f, 
    -0.03024754f, -0.03721856f, -0.00363049f, 0.02117731f, 0.02567550f, 0.01861766f, -0.00753206f, 0.03512922f, 
    0.01661488f, -0.03532854f, 0.02124391f, -0.00732625f, -0.03100441f, 0.01366773f, -0.01059554f, 0.00595562f, 
    0.00792383f, 0.00182414f, -0.02549610f, 0.02865963f, -0.02354975f, 0.00290045f, -0.02627275f, -0.01327662f, 
    -0.04111709f, 0.00569310f, -0.01935942f, 0.02400487f, -0.01234454f, -0.00682380f, 0.01328379f, 0.00715866f, 
    0.01324166f, 0.00687561f, -0.03206068f, -0.00795688f, -0.02548255f, -0.03479850f, 0.01410925f, 0.00658451f, 
    -0.01173442f, 0.03130212f, 0.02559348f, 0.00046963f, 0.01544126f, -0.01192410f, -0.03064187f, -0.01813855f, 
    -0.00806935f, 0.00033428f, -0.02841145f, -0.00044455f, 0.01668700f, 0.00472647f, -0.03896404f, 0.00382964f, 
    -0.02946999f, -0.00833121f, -0.01183775f, 0.00134570f, -0.02254204f, -0.02496537f, -0.01247027f, -0.02305288f, 
    -0.00128433f, -0.02005986f, -0.03558837f, 0.00214012f, 0.02654990f, -0.02102800f, 0.01094184f, -0.03700038f, 
    -0.01142477f, -0.01612725f, -0.00687746f, 0.02191957f, -0.00281397f, 0.00427313f, 0.01278415f, -0.00966902f, 
    -0.01499552f, 0.01190970f, -0.03218940f, 0.00991141f, 0.01799510f, -0.01995806f, -0.02208417f, -0.00156098f, 
    0.02712294f, -0.00052455f, -0.01349012f, -0.02302703f, -0.03532981f, 0.00169555f, -0.02786981f, 0.02451563f, 
    -0.01662380f, 0.01371592f, -0.03022737f, 0.01472636f, -0.00611324f, -0.02299432f, 0.03112263f, -0.00552317f, 
    -0.03188953f, -0.01734643f, 0.02962930f, 0.02536644f, 0.03312132f, 0.00402364f, -0.03043621f, -0.03560597f, 
    -0.00572788f, 0.01983384f, -0.02092248f, -0.01934433f, -0.03561584f, -0.01007780f, 0.01906225f, -0.01396072f, 
    -0.03463724f, 0.00719859f, -0.00129404f, -0.01608795f, -0.01688429f, 0.01877172f, -0.01710270f, -0.00218164f, 
    0.00556090f, -0.04147464f, -0.00516901f, -0.03104385f, -0.04178758f, -0.02657593f, 0.02754419f, -0.00381404f, 
    -0.01389624f, -0.00256074f, -0.03493918f, -0.00735958f, 0.01772944f, -0.04021019f, -0.00269609f, -0.00828173f, 
    0.01746885f, -0.02534453f, -0.00921826f, -0.02909313f, -0.02839484f, 0.00095647f, -0.01271053f, -0.00823353f, 
    -0.00825520f, 0.02642646f, 0.02895772f, -0.03770986f, 0.02300736f, -0.03333473f, 0.01669244f, 0.02190733f, 
    -0.03624712f, -0.02346487f, 0.02002149f, -0.04254090f, -0.01330340f, 0.01144411f, -0.02306264f, 0.02401603f, 
    -0.00183939f, -0.03244837f, 0.01323872f, 0.01650787f, -0.02174009f, 0.00114103f, -0.00006348f, -0.03928755f, 
    0.00001868f, 0.02967101f, 0.01946675f, 0.01804712f, 0.01851282f, 0.00092700f, 0.02601294f, -0.01916805f, 
    -0.00869359f, 0.03123028f, -0.03639278f, -0.01940213f, 0.01096213f, 0.00760498f, 0.00490889f, 0.02358483f, 
    -0.03559583f, -0.00289493f, -0.01107846f, 0.03050543f, -0.02846691f, -0.00224865f, -0.01704932f, 0.01820860f, 
    -0.03687785f, 0.00320266f, -0.00973783f, -0.02904883f, 0.02821935f, -0.04079400f, -0.02045131f, 0.01595329f, 
    -0.00440522f, -0.01284776f, -0.02563417f, -0.03234345f, 0.01218919f, -0.01531205f, 0.00789412f, 0.02817263f, 
    0.01502171f, -0.03848750f, -0.00623257f, -0.02861864f, -0.00923980f, 0.01839575f, -0.00559745f, -0.02340865f, 
    0.01253696f, 0.02334008f, 0.02344904f, 0.02336152f, 0.00284020f, -0.03244966f, 0.00414633f, -0.03497556f, 
    0.02809268f, -0.02898636f, -0.01103460f, 0.00910870f, 0.00932247f, -0.02354384f, -0.01838066f, -0.02784611f, 
    0.03426059f, 0.02643324f, -0.01403714f, -0.00174847f, -0.01065111f, 0.01085656f, -0.01350193f, 0.01272113f, 
    -0.02731080f, -0.01612818f, -0.03412158f, 0.00095467f, 0.00155855f, -0.00372964f, -0.03718165f, 0.02244548f, 
    0.01112253f, -0.01377899f, -0.02932691f, -0.01095384f, -0.02475574f, 0.00499892f, -0.01824852f, -0.01405027f, 
    -0.01567499f, 0.01162500f, 0.02699189f, 0.02695697f, -0.02883005f, 0.00477405f, 0.01555541f, -0.00590007f, 
    -0.03647085f, 0.02096221f, -0.01976449f, -0.01666746f, -0.00777520f, -0.03426730f, -0.00572635f, 0.00691877f, 
    -0.00945338f, -0.02215703f, 0.02360221f, 0.03173300f, -0.02367766f, -0.01164921f, 0.02776672f, 0.02264377f, 
    0.01182961f, -0.02588841f, 0.00494322f, -0.02011524f, 0.01281209f, -0.01084073f, -0.02184292f, 0.02524334f, 
    -0.00127706f, -0.03773104f, -0.03622549f, 0.00295586f, 0.01271344f, 0.00506323f, -0.02210520f, 0.02225254f, 
    -0.02349315f, 0.01532896f, 0.01279597f, 0.02894760f, 0.00212585f, -0.01905395f, -0.00804256f, 0.01808177f, 
    -0.01435500f, -0.03797072f, 0.01750894f, -0.01330421f, 0.00082726f, -0.00237024f, -0.00049842f, 0.00694718f, 
    0.02806474f, 0.02326016f, 0.01998329f, -0.03908459f, 0.00748571f, 0.00063644f, 0.02086714f, -0.00279503f, 
    0.02122736f, -0.00313514f, -0.00908793f, -0.03095293f, 0.02412366f, -0.02428346f, 0.01191971f, -0.01863607f, 
    0.00054969f, -0.00472219f, 0.02509740f, -0.00632218f, -0.03289019f, 0.01755540f, -0.03140174f, -0.00528965f, 
    0.02936460f, 0.00991383f, -0.03980834f, -0.02554070f, 0.02216688f, 0.02832379f, -0.01277322f, 0.01103446f, 
    -0.03912774f, 0.02663374f, 0.03018609f, 0.03160365f, 0.02090679f, -0.02982094f, -0.02338668f, 0.01948128f, 
    0.00559998f, -0.00487073f, 0.00362074f, 0.01306963f, -0.00448423f, 0.00716487f, 0.01262647f, 0.02383453f, 
    -0.03668905f, 0.00918773f, -0.00537014f, -0.03029791f, -0.02389576f, -0.01918175f, 0.02343201f, -0.03501011f, 
    0.02596228f, 0.00416153f, -0.00623656f, 0.00217127f, -0.02814893f, 0.00574802f, -0.01139765f, 0.00556260f, 
    -0.04153438f, 0.01202200f, 0.02133886f, 0.01599039f, 0.02054158f, 0.02581724f, 0.02529032f, 0.01646791f, 
    -0.01251478f, -0.02754317f, -0.00701398f, -0.03694063f, 0.00921708f, 0.00091637f, 0.02620510f, 0.02067106f, 
    0.01582145f, 0.02623033f, -0.00661997f, -0.02927558f, -0.03234539f, 0.03052191f, 0.01214927f, -0.00918870f, 
    0.00753816f, 0.00938995f, -0.01913576f, 0.02685939f, -0.00822305f, 0.00462597f, 0.01345949f, -0.02188991f, 
    0.02765584f, -0.02290209f, 0.01037421f, -0.03496082f, -0.00812989f, -0.00642509f, -0.00327122f, -0.01085765f, 
    -0.01679931f, -0.03501324f, -0.00628235f, -0.03247060f, 0.00082647f, 0.02446659f, 0.00989510f, -0.00829768f, 
    0.00271630f, -0.01907314f, 0.01440605f, 0.01235614f, -0.01342082f, -0.02294073f, -0.01141041f, 0.00687470f, 
    -0.00026869f, -0.01134018f, 0.01439179f, -0.02773524f, 0.02912701f, -0.01421690f, -0.01913215f, 0.00635027f, 
    0.00496933f, -0.00745735f, -0.00780282f, -0.02155126f, 0.03613832f, -0.03964294f, 0.01055390f, 0.02583550f, 
    0.01148940f, -0.00142575f, 0.01791967f, -0.03751979f, -0.01574971f, 0.02116732f, 0.00975654f, 0.00991152f, 
    -0.04122026f, -0.00458533f, 0.00657871f, 0.00404350f, -0.03112141f, -0.00456593f, -0.02811950f, 0.02181023f, 
    0.00460722f, 0.03501085f, 0.01822085f, 0.00065448f, 0.00438614f, -0.03786898f, 0.01914879f, 0.02827192f, 
    0.01383820f, -0.01530216f, 0.00894115f, 0.01282786f, 0.02531437f, 0.03175472f, -0.03585027f, -0.04206800f, 
    0.00079286f, 0.00950120f, -0.02714054f, 0.00634072f, 0.02371209f, 0.02197075f, -0.01723847f, 0.01558925f, 
    0.02192428f, -0.01830415f, 0.02081717f, 0.00872328f, -0.02410168f, 0.00642243f, -0.02423355f, -0.02892945f, 
    -0.04033465f, -0.03253074f, -0.04178260f, -0.01140474f, -0.00940158f, 0.03113905f, 0.01655577f, 0.02735162f, 
    0.00295419f, 0.01656503f, -0.03319079f, -0.02132585f, -0.00099644f, 0.01103622f, 0.00792930f, 0.02754790f, 
    0.02430353f, 0.01114636f, -0.03264729f, 0.01931588f, -0.01028287f, -0.03629080f, 0.01889325f, -0.02999808f, 
    0.02670925f, 0.00583545f, -0.00039485f, 0.02775276f, -0.01961398f, 0.00967878f, 0.01018994f, -0.02755853f, 
    0.02955907f, 0.00416290f, 0.01262732f, 0.03163457f, 0.02156498f, 0.02771601f, 0.00998415f, -0.01691429f, 
    -0.03040824f, -0.01202167f, 0.00814432f, -0.04116869f, -0.02168956f, -0.01120108f, 0.00435952f, -0.00796739f, 
    -0.01266544f, -0.02799077f, 0.00813421f, -0.03729757f, 0.03320938f, 0.02183322f, -0.00314708f, 0.01781389f, 
    0.01296469f, 0.00045582f, -0.02898817f, -0.01446553f, -0.00766171f, -0.03021766f, -0.00727498f, -0.03364087f, 
    0.02659283f, 0.01004462f, -0.01982852f, -0.01159163f, -0.02770050f, -0.01155007f, -0.01279708f, 0.02912010f, 
    -0.04163840f, 0.02695831f, 0.01114619f, 0.02029279f, -0.00064959f, -0.03902742f, -0.01753623f, -0.00494505f, 
    -0.02179938f, -0.03823279f, 0.01978214f, -0.04102204f, 0.01098946f, 0.01566071f, -0.01030712f, 0.01822898f, 
    -0.00761432f, -0.03476832f, 0.00103646f, -0.00967232f, -0.01503517f, 0.01404647f, 0.02202175f, -0.02656275f, 
    0.00421217f, 0.02683405f, 0.01541402f, 0.01849340f, -0.04040375f, -0.03595163f, 0.02350419f, -0.03213317f, 
    0.00219396f, -0.01801414f, 0.00412655f, -0.01840876f, 0.01385849f, 0.01955111f, 0.01447215f, -0.03351412f, 
    -0.01877877f, 0.01693997f, -0.03814209f, 0.00617982f, -0.02058559f, 0.01490725f, 0.02687759f, 0.00496254f, 
    -0.01697581f, -0.00654912f, -0.00407107f, -0.00850573f, -0.01409666f, 0.02829966f, -0.02283107f, -0.02680457f, 
    -0.02190583f, -0.01855643f, -0.02115545f, -0.02926068f, 0.00697430f, -0.00426473f, -0.03127247f, -0.00592629f, 
    0.02569254f, -0.03976407f, 0.01045543f, 0.02358028f, 0.02295726f, 0.01393082f, -0.02803842f, -0.02129842f, 
    -0.03218052f, 0.00429828f, -0.02160608f, -0.02912312f, 0.00241440f, -0.02089604f, -0.00947236f, -0.01727835f, 
    0.00059032f, 0.01213889f, -0.00810301f, 0.02043206f, -0.02140146f, 0.00728249f, -0.02300072f, -0.00794951f, 
    0.00413846f, 0.01503998f, 0.03108671f, 0.02677651f, 0.01849473f, -0.02022698f, 0.01311874f, 0.00475945f, 
    -0.00057233f, -0.02609874f, 0.01595659f, 0.00948506f, 0.00454565f, 0.02966192f, 0.00904837f, 0.00520331f, 
    -0.00623162f, 0.00390765f, -0.01863392f, -0.02560925f, -0.01973864f, -0.00420184f, 0.00983162f, 0.01808250f, 
    -0.00632301f, 0.00706441f, 0.00712281f, -0.02786590f, 0.02309916f, -0.00589332f, 0.01493942f, -0.03870369f, 
    0.00307388f, 0.02616703f, -0.02839352f, 0.00297565f, -0.02779627f, -0.01318629f, 0.01137955f, -0.00795500f, 
    -0.01162040f, -0.01289132f, -0.03830618f, -0.02486936f, -0.01342229f, -0.00884057f, -0.03983175f, -0.02659756f, 
    0.00971912f, -0.00508075f, -0.00538767f, -0.01072431f, 0.00570957f, -0.01963803f, 0.02252126f, 0.02921726f, 
    0.01367096f, 0.00793360f, -0.03585185f, 0.03025699f, 0.02754988f, -0.03568386f, -0.01697338f, 0.00476377f, 
    0.00457149f, 0.00056718f, 0.01384250f, -0.02123265f, -0.00640002f, 0.02829712f, -0.00927962f, -0.00570985f, 
    -0.01367472f, -0.03437083f, -0.03610526f, -0.01627174f, -0.03176606f, -0.03427546f, -0.00878944f, -0.03238229f, 
    -0.01430742f, -0.03007144f, 0.00364324f, -0.04144725f, 0.01863929f, -0.02980745f, 0.02146167f, 0.01276169f, 
    -0.01401386f, 0.02385279f, 0.01467729f, 0.01250321f, -0.02375762f, 0.00965506f, 0.00784445f, -0.01565631f, 
    -0.00445187f, 0.02559576f, 0.02652587f, -0.00219753f, -0.02556998f, -0.01239234f, -0.00075770f, -0.00137557f, 
    0.00593994f, -0.00773966f, 0.00471931f, 0.02031337f, 0.01359416f, 0.01002199f, 0.01901703f, 0.03023396f, 
    0.01842857f, 0.01425557f, 0.02835912f, -0.01474916f, -0.03615461f, 0.00362375f, -0.03071044f, -0.01581243f, 
    -0.03415889f, 0.00733541f, -0.00118565f, -0.00490111f, 0.00875220f, -0.03049609f, 0.00392627f, 0.00724700f, 
    -0.01653599f, -0.04225924f, -0.01719619f, 0.01034690f, 0.00235546f, -0.02567204f, -0.03259106f, 0.01730510f, 
    0.02762530f, -0.00383116f, 0.00719888f, 0.02624316f, 0.01078707f, 0.00554363f, -0.02174896f, -0.00951170f, 
    -0.03852532f, 0.01784245f, -0.02310523f, -0.02085762f, 0.02826491f, -0.03021829f, 0.00287465f, -0.03366568f, 
    -0.00566734f, -0.03674010f, -0.03805251f, -0.00960194f, 0.02106057f, -0.00115417f, 0.01642435f, -0.01331745f, 
    0.01728490f, 0.03192862f, -0.02039991f, -0.03185700f, 0.00935711f, 0.01201960f, -0.02500856f, 0.01861260f, 
    -0.00275440f, 0.01285045f, 0.00989892f, 0.01553204f, -0.02430123f, -0.01903020f, -0.02546028f, -0.04086064f, 
    -0.01439896f, 0.01778933f, 0.01130944f, 0.00867214f, -0.00132360f, -0.03760424f, 0.00658153f, 0.02086253f, 
    -0.01701646f, 0.02061363f, 0.02301394f, 0.00637467f, -0.03418275f, -0.02152489f, 0.00930214f, -0.00305987f, 
    -0.01246360f, 0.02036448f, -0.04140858f, -0.04001391f, -0.01599355f, -0.02572569f, 0.01737290f, -0.01753741f, 
    -0.03860417f, 0.02578711f, 0.02341379f, 0.02784775f, -0.03646812f, -0.02353265f, -0.02046241f, -0.02594355f, 
    0.01231544f, 0.02219475f, 0.03059289f, -0.03075039f, -0.01100997f, 0.02712230f, -0.01763323f, -0.02709181f, 
    -0.00765438f, -0.00528116f, -0.01766610f, 0.02720587f, -0.03102843f, -0.01735173f, -0.00067082f, -0.03725114f, 
    -0.00212100f, -0.02140653f, 0.01313837f, 0.01355661f, -0.02430565f, 0.00048035f, -0.03914212f, 0.02370411f, 
    0.01225048f, 0.00013503f, 0.01702329f, 0.02525464f, 0.00869504f, 0.00538824f, 0.00946014f, -0.02043026f, 
    -0.03056595f, -0.01557469f, 0.01263166f, 0.01789364f, 0.02598927f, 0.02066969f, 0.01671125f, -0.03280306f, 
    -0.01752740f, -0.00423581f, -0.01257180f, 0.00558362f, -0.00232973f, 0.00973679f, 0.00621023f, -0.02057957f, 
    -0.02132737f, -0.02059103f, -0.01149119f, 0.02571565f, 0.02455482f, 0.00717518f, 0.00711813f, 0.01913068f, 
    -0.01825822f, -0.00045870f, -0.02679432f, -0.03612559f, -0.02390144f, 0.00253913f, 0.02649849f, -0.02544633f, 
    -0.00165200f, 0.02888294f, 0.02994724f, 0.00388993f, -0.01658129f, -0.03424232f, 0.02556890f, -0.03470201f, 
    -0.02089761f, 0.00530257f, -0.00439459f, -0.01967165f, 0.02717769f, -0.02369872f, -0.00888552f, -0.01488207f, 
    0.01443616f, 0.02909289f, -0.03673143f, -0.03551867f, -0.01354457f, -0.03901866f, -0.02945421f, 0.00765630f, 
    -0.00216482f, -0.01989033f, -0.03066353f, -0.03483758f, 0.02984963f, -0.00030143f, 0.00788245f, 0.01645460f, 
    -0.02937181f, 0.01557576f, 0.01603341f, -0.00185616f, 0.01867376f, -0.00006972f, -0.02988094f, 0.01588557f, 
    -0.00669195f, 0.03035038f, 0.01366626f, -0.02448544f, -0.01378189f, 0.00916241f, -0.04020560f, 0.02774240f, 
    -0.01855003f, -0.00785744f, 0.00878674f, 0.01086045f, -0.03962729f, 0.02664955f, -0.00894712f, 0.01583932f, 
    0.02985960f, -0.02540651f, -0.03473990f, -0.01730108f, 0.01645490f, 0.00418138f, -0.02051975f, -0.03970099f, 
    0.01568633f, 0.01206851f, 0.02025037f, 0.00597384f, 0.02161909f, 0.01808299f, -0.01341214f, 0.00598954f, 
    0.02452869f, -0.03849412f, -0.03906183f, -0.01519633f, -0.03028921f, -0.01799430f, 0.01660711f, -0.01746987f, 
    -0.00820455f, -0.02537063f, 0.02447013f, 0.00525446f, -0.02534243f, 0.00795914f, -0.03442007f, -0.02515780f, 
    0.01794693f, -0.04049521f, -0.03836964f, 0.02262007f, 0.00607097f, -0.01868383f, -0.00277952f, 0.01191342f, 
    -0.00453536f, -0.01994967f, 0.00096469f, -0.00928378f, -0.01227633f, 0.02776047f, -0.01265405f, -0.03759245f, 
    -0.00459492f, 0.00208790f, 0.03042693f, -0.02022413f, 0.01600193f, 0.01226734f, 0.02595142f, -0.01962186f, 
    0.02074071f, -0.02615239f, -0.03462057f, -0.00139393f, -0.01444717f, 0.01028439f, -0.02722760f, -0.00258527f, 
    0.01963452f, -0.01374264f, -0.02164802f, -0.00470006f, 0.01965914f, 0.01715896f, -0.03711162f, -0.01484378f, 
    0.03443659f, -0.00328969f, 0.01515292f, -0.00720975f, 0.02214420f, 0.02852377f, -0.01947816f, 0.03116108f, 
    -0.03465941f, -0.01628677f, 0.02771239f, 0.01695600f, -0.02268084f, -0.03793091f, 0.02039094f, -0.01753664f, 
    -0.01709893f, 0.03222756f, 0.00716981f, -0.02804495f, -0.02161042f, 0.01774663f, 0.01384406f, 0.01363154f, 
    -0.01402013f, 0.02227692f, -0.03917478f, -0.03250425f, -0.00375209f, -0.02782524f, -0.03379902f, 0.01121563f, 
    -0.02598749f, 0.02109557f, 0.01122031f, -0.02672893f, -0.01240775f, -0.01655661f, 0.00274032f, -0.02613696f, 
    0.01733908f, -0.01249462f, -0.02842170f, 0.03053896f, -0.03788535f, 0.01637530f, -0.01729767f, 0.02325063f, 
    0.01021206f, 0.01692812f, 0.00157311f, 0.00022180f, -0.04042482f, -0.02561545f, -0.01731408f, -0.01729446f, 
    0.02061784f, 0.00400283f, -0.03215103f, 0.02562434f, 0.00985232f, -0.01525190f, -0.02135831f, -0.02745748f, 
    -0.02559023f, 0.01455216f, -0.02456258f, -0.01790782f, 0.03137821f, 0.01242385f, 0.01687369f, -0.02484745f, 
    -0.02740738f, 0.00502459f, 0.00307017f, -0.00501726f, 0.01494915f, -0.01924310f, -0.00354756f, -0.03315721f, 
    0.01777041f, -0.03836949f, -0.00719523f, 0.01036800f, -0.02514049f, 0.02405787f, -0.00106321f, -0.02683203f, 
    -0.00340001f, -0.03301402f, 0.02179726f, -0.02317404f, 0.01088808f, -0.00830619f, -0.02026465f, 0.01656198f, 
    -0.01259998f, -0.00225474f, -0.01825966f, -0.03170005f, 0.00165906f, -0.02802800f, -0.03438614f, 0.01260588f, 
    -0.02202538f, -0.00991487f, -0.01674445f, -0.02810200f, 0.01277934f, -0.01090232f, 0.01997712f, -0.03396643f, 
    -0.00022118f, 0.01650700f, 0.02219946f, -0.02643997f, -0.01398117f, 0.01806596f, 0.00269902f, -0.03158437f, 
    0.02192461f, 0.02998198f, 0.01894730f, 0.02255600f, -0.02333689f, 0.00706531f, -0.03568042f, 0.00084970f, 
    0.02474942f, 0.03107401f, 0.01968780f, 0.01799676f, 0.02862528f, -0.02452531f, -0.01857409f, -0.00286824f, 
    -0.00133932f, 0.00577082f, -0.01654608f, -0.01174400f, 0.01447439f, 0.00842307f, 0.01162763f, 0.01558586f, 
    0.02969601f, 0.01135835f, -0.01416587f, 0.00386101f, 0.00239373f, 0.02421316f, 0.02088212f, 0.00732891f, 
    -0.00632034f, -0.03644314f, 0.01707828f, 0.01896528f, 0.01865613f, -0.00996684f, 0.01708340f, -0.00573384f, 
    -0.04074696f, 0.01857088f, 0.01911115f, -0.02013577f, -0.03634428f, 0.00372206f, 0.02678505f, -0.04040328f, 
    -0.03300093f, 0.02929836f, 0.01992744f, 0.00029487f, -0.03032623f, 0.02482772f, -0.03175741f, 0.02448702f, 
    -0.03360774f, -0.01548924f, 0.00459912f, -0.03072102f, -0.01771431f, 0.00303877f, 0.00420285f, -0.01330088f, 
    0.02507638f, -0.00809926f, 0.02148148f, -0.01620713f, 0.01302921f, 0.02211373f, -0.01991485f, -0.03628309f, 
    -0.02430799f, -0.00953142f, -0.00007361f, -0.02421043f, -0.03409482f, -0.03015233f, 0.02426503f, -0.03671476f, 
    0.01099049f, -0.00883980f, 0.00939127f, -0.03290563f, -0.00662804f, 0.00760046f, 0.02732142f, -0.01464348f, 
    0.02594139f, -0.00376932f, 0.00807549f, 0.00927973f, -0.01221986f, 0.01976510f, -0.02020287f, 0.00225458f, 
    -0.01746886f, 0.00819981f, -0.04108507f, 0.00546256f, 0.01462379f, 0.00944748f, 0.00684156f, -0.02931093f, 
    -0.03328266f, -0.01128744f, -0.02354452f, -0.02876082f, -0.00641575f, 0.00853226f, 0.01373637f, -0.00073096f, 
    0.00197633f, 0.01315635f, 0.00484368f, -0.02052074f, -0.01319148f, -0.02579323f, -0.00760981f, -0.03481915f, 
    0.02446743f, -0.03097798f, 0.03013277f, -0.01765846f, -0.01548892f, -0.00249133f, 0.02521169f, 0.02911229f, 
    0.01316597f, -0.01044780f, -0.00044743f, -0.03049934f, 0.00155496f, -0.01290772f, -0.01352777f, 0.01692287f, 
    0.00504955f, 0.01364113f, -0.02442110f, -0.00294978f, 0.01308784f, -0.03569725f, -0.02272293f, -0.03974302f, 
    -0.00616194f, 0.00470733f, 0.02208778f, -0.02919547f, -0.01744344f, -0.01044818f, 0.02766655f, -0.02482277f, 
    0.02772072f, -0.00678843f, 0.00093568f, -0.03144128f, 0.02007148f, 0.02479596f, 0.00572764f, -0.03992878f, 
    0.01376271f, 0.00690184f, -0.02457447f, -0.00222999f, -0.02303942f, -0.02580545f, -0.00085909f, 0.00245020f, 
    -0.00201990f, 0.01120543f, 0.01613055f, 0.01867744f, -0.02161124f, -0.03830110f, -0.01251439f, -0.00504689f, 
    0.01461535f, 0.02304787f, 0.00200629f, -0.01209375f, 0.02960961f, 0.01744084f, 0.02228904f, 0.00222375f, 
    -0.01701336f, 0.00787662f, 0.02839964f, -0.02596941f, -0.03141996f, -0.03807121f, 0.02220956f, 0.01300766f, 
    0.01457984f, -0.00489898f, -0.01557827f, -0.01263143f, -0.00562519f, 0.02650738f, -0.00560931f, -0.03296753f, 
    -0.03318738f, -0.04124037f, -0.02226456f, 0.01457839f, -0.03766828f, 0.01314941f, 0.02483599f, 0.00753347f, 
    -0.02944885f, 0.02860061f, 0.02132064f, -0.00784517f, -0.00357413f, -0.03812776f, 0.02882732f, -0.01290815f, 
    -0.02896811f, -0.00516115f, 0.00051817f, -0.02529721f, -0.00221671f, -0.02079517f, 0.02191610f, 0.00864894f, 
    0.00114199f, -0.02935550f, -0.03501911f, 0.00939607f, -0.01111383f, 0.01338367f, -0.04167213f, 0.01826823f, 
    -0.01454986f, 0.01112194f, -0.02506783f, 0.00446636f, 0.00042741f, -0.00666315f, -0.02354031f, 0.01733408f, 
    -0.00157320f, -0.01344372f, -0.03585358f, 0.03048261f, -0.00585992f, -0.03374908f, -0.00827229f, 0.02154581f, 
    0.01743980f, 0.01719921f, -0.03965431f, -0.03099677f, 0.01878506f, 0.02575025f, -0.00778201f, 0.02894411f, 
    0.01817637f, -0.00385295f, -0.02920366f, -0.04105781f, 0.02717892f, -0.00893778f, 0.02033978f, -0.03939985f, 
    0.01714551f, 0.00556815f, 0.02410974f, -0.00034963f, -0.03809305f, 0.00673119f, -0.03377446f, 0.01073261f, 
    -0.00764113f, -0.01579814f, -0.01209234f, 0.01179776f, -0.03777618f, 0.01096770f, -0.03229110f, 0.01311417f, 
    0.02316260f, -0.03131919f, 0.01327362f, -0.01901609f, -0.01234577f, -0.02440391f, 0.02062426f, 0.01546869f, 
    0.00213407f, -0.03418225f, 0.00527606f, 0.03723890f, -0.03730940f, 0.01676445f, 0.01018609f, 0.01223179f, 
    -0.03673648f, -0.01782042f, 0.00940504f, 0.02792514f, -0.02388188f, 0.02639847f, -0.03294053f, 0.03067917f, 
    0.01533401f, -0.03294731f, 0.00447084f, -0.02747194f, -0.01515920f, -0.01534137f, -0.01136279f, -0.04070175f, 
    -0.00954189f, -0.03417350f, 0.02844528f, 0.01361112f, 0.01229035f, -0.03553902f, -0.00527373f, -0.03974488f, 
    0.04051762f, -0.03879946f, 0.03024574f, -0.03928924f, 0.02104030f, -0.01064427f, -0.04030394f, -0.02734651f, 
    -0.01370193f, 0.00248202f, 0.02648396f, 0.01373662f, -0.01839983f, 0.01945881f, -0.00932415f, 0.02933945f, 
    -0.01278431f, 0.02543404f, 0.02442812f, -0.02600561f, 0.00176371f, 0.01267879f, -0.01852801f, 0.01440134f, 
    0.01103488f, -0.03546796f, -0.01547112f, -0.03141359f, 0.02316334f, 0.01681516f, -0.02557714f, 0.01879560f, 
    0.02046318f, 0.01317052f, -0.00716239f, 0.01818888f, 0.02791146f, 0.01554784f, 0.01624750f, 0.01860758f, 
    -0.01236550f, -0.02768919f, 0.00634506f, 0.00714907f, -0.02460941f, 0.01399252f, 0.02412039f, -0.02493849f, 
    -0.02234342f, -0.00389577f, -0.00473996f, -0.01944469f, 0.00654752f, -0.01184230f, 0.02008273f, 0.00077378f, 
    0.01500854f, -0.03755293f, -0.01171512f, -0.01563093f, -0.00462426f, -0.03521724f, 0.02608857f, 0.00557964f, 
    -0.02514292f, -0.03489834f, 0.02834606f, 0.00143009f, -0.02609578f, 0.02395329f, -0.01599079f, -0.00038736f, 
    0.03037545f, -0.02071828f, -0.02422248f, 0.00102978f, -0.01606344f, 0.03062151f, 0.02222609f, -0.00695351f, 
    -0.00983996f, -0.01354221f, 0.00662662f, 0.00455464f, -0.03090102f, -0.01432229f, 0.04191383f, 0.00471329f, 
    -0.02251488f, -0.03408546f, -0.03374114f, 0.00126982f, 0.02256929f, -0.01051869f, -0.03878850f, -0.00873457f, 
    0.00042865f, -0.03229490f, 0.00926690f, 0.01413743f, 0.00418535f, -0.00774661f, -0.02728009f, -0.00723827f, 
    0.00466876f, 0.02066848f, 0.01503655f, -0.03780678f, -0.02943764f, 0.01308582f, -0.01963884f, -0.03015563f, 
    -0.03766633f, 0.01062953f, -0.03495618f, -0.03883835f, -0.01581719f, -0.03155889f, -0.02945107f, -0.03041529f, 
    0.00246540f, -0.01948007f, -0.00731200f, -0.02338533f, 0.00312684f, 0.00380477f, -0.00575312f, 0.00582464f, 
    0.01784147f, -0.00160339f, 0.00161833f, 0.00477711f, -0.02542882f, -0.02558234f, -0.02767778f, 0.02444967f, 
    -0.02866590f, 0.01499029f, -0.03888981f, -0.02251921f, 0.02285959f, -0.01588404f, -0.03025174f, -0.02756199f, 
    0.20730884f, 0.17572039f, -0.07153092f, -0.08889209f, 0.17006382f, 0.09077536f, 0.00593012f, -0.06254139f, 
    0.07883096f, 0.07950784f, 0.03038348f, -0.09411883f, 0.11412670f, 0.07651868f, -0.17449991f, -0.23663534f, 
    0.12041007f, 0.16684400f, 0.05617037f, -0.00172890f, -0.00748288f, 0.04323723f, 0.10510884f, -0.02645751f, 
    0.48592082f, -0.06273761f, 0.08706810f, 0.08218906f, -0.09388109f, -0.04732323f, 0.01278410f, 0.14438953f, 
    -0.07288536f, -0.06170729f, 0.01720315f, 0.01269971f, 0.08079980f, -0.05536469f, 0.17564206f, 0.05383856f, 
    0.04853949f, 0.02314738f, 0.03435747f, 0.06719220f, 0.07895632f, 0.03332944f, 0.02268861f, 0.08383283f, 
    0.26253104f, -0.00360245f, -0.07261478f, 0.20785549f, 0.12531671f, -0.04297090f, -0.16721965f, 0.03999886f, 
    -0.11392806f, -0.06728496f, -0.05729574f, 0.02281078f, 0.17239942f, -0.10667433f, 0.06343507f, 0.17032681f, 
    -0.00183018f, 0.15712345f, -0.01721262f, 0.00993392f, 0.14610399f, -0.05593925f, 0.09539809f, 0.04752275f, 
    -0.00350510f, 0.06995267f, 0.19328657f, 0.01230200f, 0.08591373f, 0.09243679f, -0.04593141f, -0.00445293f, 
    0.07527044f, 0.07148658f, 0.07453818f, -0.02607278f, -0.20090783f, -0.14736065f, 0.04227554f, -0.10610013f, 
    0.21513604f, -0.05892014f, -0.04287118f, -0.01989001f, 0.10054345f, 0.11670366f, 0.08349039f, 0.10303000f, 
    -0.16906950f, -0.12347028f, 0.09714341f, -0.10346776f, 0.04864034f, -0.04553596f, -0.09748286f, -0.04725843f, 
    0.01508577f, -0.04305928f, -0.03510222f, -0.00567455f, 0.15652473f, 0.00942928f, 0.24977183f, -0.10058362f, 
    0.04296646f, -0.09484322f, 0.06464503f, 0.01492377f, -0.00430232f, 0.05636728f, 0.05730097f, 0.10589361f, 
    0.07766706f, -0.10368748f, 0.16183849f, 0.01402869f, -0.06403179f, 0.09955938f, 0.15233149f, 0.01674646f, 
    0.02667866f, -0.00807435f, -0.15181394f, 0.05083611f, -0.10072859f, -0.13835318f, 0.00585070f, -0.10679935f, 
    0.08397356f, 0.06618437f, -0.05684207f, -0.01444221f, 0.08260949f, 0.09268004f, 0.05143773f, 0.05815906f, 
    0.17034584f, 0.05168650f, -0.12396472f, -0.03582420f, 0.00695072f, 0.00155880f, -0.07919079f, 0.07121035f, 
    0.02320055f, 0.11034314f, 0.04657765f, -0.02808080f, 0.02216363f, -0.03318301f, -0.04508116f, 0.06207854f, 
    0.10082866f, 0.10161942f, -0.07126921f, -0.03964339f, -0.00466300f, 0.05386729f, -0.00593909f, 0.07900476f, 
    0.00223917f, -0.07361797f, -0.06135874f, -0.12898125f, -0.13211249f, -0.01658810f, -0.01814222f, -0.00537062f, 
    -0.04528615f, 0.04353582f, 0.05345726f, -0.06420091f, -0.05715079f, -0.18174772f, -0.01057584f, 0.01640622f, 
    -0.01055623f, 0.09595254f, 0.01950752f, 0.17055129f, 0.13525555f, 0.03275463f, -0.01359506f, 0.09367269f, 
    0.23866545f, -0.02803686f, -0.08843181f, 0.09732529f, -0.02246331f, -0.04426759f, 0.04961858f, 0.08416304f, 
    0.01398659f, 0.04975304f, 0.09718744f, -0.08908483f, 0.51813114f, -0.06235960f, 0.02498129f, 0.08719397f, 
    0.15206441f, 0.01546020f, -0.00341175f, 0.02613206f, 0.14348041f, 0.05041409f, 0.07843923f, -0.01191070f, 
    -0.16016038f, -0.01363439f, 0.34727469f, 0.04159449f, -0.01103467f, 0.00963722f, 0.07789464f, 0.15013230f, 
    -0.01686489f, 0.14194170f, -0.00207114f, -0.00624745f, 0.31787783f, 0.02126610f, -0.21439777f, -0.02944434f, 
    0.08734621f, 0.13500285f, 0.02342958f, 0.04385938f, -0.00658329f, 0.05331013f, 0.04499751f, 0.16615535f, 
    0.25890860f, -0.02042463f, -0.15182668f, 0.12047255f, -0.03651153f, -0.02458931f, 0.09111552f, 0.07944112f, 
    -0.01276742f, 0.07324267f, -0.06747762f, 0.13289274f, 0.10753644f, 0.21537445f, 0.07616004f, 0.05421986f, 
    0.17425600f, -0.04583979f, 0.04598019f, 0.16971937f, -0.03741426f, -0.03148293f, -0.08105721f, -0.02915337f, 
    -0.00407805f, -0.03808028f, -0.07078888f, 0.01729946f, 0.15866859f, 0.02980794f, 0.12984441f, 0.01527890f, 
    -0.02920237f, 0.12348611f, -0.01729695f, 0.05174822f, -0.15008852f, 0.05178019f, -0.01985385f, -0.05592409f, 
    0.03249182f, 0.05548351f, 0.07219276f, 0.11947429f, 0.07260209f, 0.15059447f, 0.03015717f, 0.01625512f, 
    0.06496228f, -0.12798329f, 0.10357974f, -0.01653547f, 0.12209734f, -0.01460956f, -0.02674344f, 0.01413629f, 
    0.02606701f, 0.07636838f, 0.02596785f, 0.09046569f, -0.41473207f, 0.04063520f, -0.06863099f, -0.14363582f, 
    0.13258588f, -0.07149207f, -0.08907197f, 0.09338693f, -0.08510321f, 0.05474919f, 0.06660631f, 0.08425412f, 
    0.05153390f, -0.09748886f, 0.19789341f, 0.10063059f, -0.15837441f, -0.11352088f, 0.00371471f, -0.03215217f, 
    0.12807848f, 0.01613725f, 0.09891497f, 0.00277772f, 0.06298326f, 0.00080884f, 0.00393519f, 0.01181580f, 
    -0.09717928f, -0.05033618f, -0.02664548f, 0.14232714f, 0.06252667f, -0.01192853f, 0.03412640f, 0.04447074f, 
    -0.16708969f, -0.03581229f, 0.12029120f, -0.04016700f, 0.04499498f, 0.03489353f, 0.03594258f, -0.07388990f, 
    0.07065031f, 0.01957693f, 0.08625168f, 0.09038011f, -0.02680950f, -0.00910889f, -0.22565004f, -0.14523268f, 
    0.03078629f, 0.04720031f, 0.04625284f, 0.03247349f, 0.14364377f, 0.07459079f, -0.00210470f, 0.06215182f, 
    -0.37376094f, 0.02059679f, -0.04283915f, 0.04337794f, 0.03355600f, -0.04076365f, 0.09229977f, 0.13042378f, 
    0.08537924f, 0.06341269f, 0.05916563f, -0.09046639f, 0.00665976f, 0.08976486f, 0.07630892f, 0.02684759f, 
    0.23069566f, 0.13623758f, 0.06172105f, -0.02812245f, 0.07199660f, 0.07117611f, 0.04498404f, 0.06788535f, 
    -0.08729412f, 0.27955645f, 0.08142154f, 0.25898141f, -0.08640690f, 0.12256020f, -0.04467380f, 0.13228044f, 
    0.10611475f, -0.00275964f, 0.06635677f, 0.08983134f, 0.19469324f, -0.05006380f, -0.05552737f, 0.03244299f, 
    0.01102637f, 0.04487523f, 0.12055036f, 0.04527074f, 0.02278672f, 0.05139281f, -0.00674068f, 0.14616539f, 
    -0.05833787f, 0.08980092f, -0.01108612f, -0.01080638f, 0.20267817f, 0.16433193f, 0.08896053f, 0.04781449f, 
    0.04925774f, -0.00797337f, 0.07078121f, 0.13496228f, 0.12811218f, -0.19333147f, -0.09536615f, -0.04043943f, 
    0.09507265f, 0.10646874f, 0.13094111f, 0.06574100f, 0.03147049f, 0.15937558f, 0.08442718f, 0.12665227f, 
    0.28070846f, 0.33074757f, -0.01764279f, -0.09824787f, 0.05242654f, -0.06767762f, 0.06590062f, -0.00904828f, 
    0.05735154f, -0.05859886f, -0.07779213f, -0.00973220f, 0.17523788f, -0.16412987f, 0.05021943f, 0.14401861f, 
    -0.02834687f, -0.10173820f, 0.03701064f, 0.12931901f, 0.02818205f, 0.04013563f, -0.00101351f, 0.06489851f, 
    0.10236734f, 0.02253670f, 0.14143200f, -0.06194561f, -0.05782532f, -0.07933073f, 0.13304321f, -0.00231672f, 
    -0.02789139f, 0.11901966f, 0.04582705f, -0.00413385f, -0.03273547f, -0.02767827f, 0.01907178f, 0.08964198f, 
    0.16564316f, 0.18653566f, 0.01205967f, -0.00414416f, 0.22598876f, 0.04088018f, 0.08547300f, 0.09762420f, 
    -0.18706244f, 0.00877666f, 0.06126906f, 0.04346772f, 0.18003888f, 0.13035235f, -0.03278842f, -0.03812144f, 
    0.03019663f, 0.02569103f, 0.17858268f, 0.07282018f, 0.00312401f, -0.08443233f, -0.20870882f, 0.00844324f, 
    -0.03122887f, -0.02336666f, 0.01499230f, 0.02580920f, -0.01019700f, 0.01706605f, 0.12578845f, 0.00829446f, 
    0.13928202f, 0.14005655f, 0.05042225f, -0.09232039f, 0.22570957f, 0.09842131f, -0.00917728f, -0.03880364f, 
    0.13954596f, -0.00223291f, 0.13103819f, 0.01745847f, 0.06229215f, -0.11135379f, 0.05804211f, 0.01486140f, 
    0.05255961f, 0.06185735f, 0.08423308f, 0.11494897f, 0.06746470f, 0.03755360f, 0.03463800f, -0.01164189f, 
    0.31489983f, 0.25025752f, 0.07301535f, 0.09514131f, -0.00913750f, 0.15951216f, 0.12546933f, 0.04355443f, 
    -0.01386084f, -0.00075377f, -0.04768736f, 0.07749186f, -0.16186462f, -0.12209700f, -0.34158310f, -0.03554581f, 
    -0.12525386f, -0.04866197f, -0.01538030f, -0.05455483f, 0.00071473f, -0.04583148f, 0.06199192f, 0.02978557f, 
    -0.11457767f, -0.05062629f, -0.00054562f, -0.20592362f, 0.00302476f, 0.00007562f, 0.01112903f, 0.09595454f, 
    0.03808359f, 0.04553399f, 0.08730759f, 0.12818553f, 0.24822734f, 0.15815595f, 0.00909302f, -0.03016205f, 
    0.10010007f, 0.04679750f, -0.09481462f, 0.16778235f, 0.11604793f, 0.09445373f, 0.05078221f, 0.12251767f, 
    -0.09112546f, -0.07955045f, -0.02833184f, -0.13667145f, 0.20848352f, 0.00372255f, -0.02381338f, 0.03501295f, 
    0.03056146f, 0.04728713f, 0.05197129f, -0.01556848f, -0.21653572f, -0.07748316f, -0.15206233f, 0.15299486f, 
    0.21795820f, 0.11779559f, 0.04178230f, -0.08906329f, 0.00683740f, 0.06336476f, -0.04816447f, 0.18188661f, 
    -0.40697044f, 0.07098410f, 0.00808154f, 0.07154396f, 0.22392966f, -0.05098367f, -0.07316520f, 0.02127990f, 
    0.08541600f, 0.03927832f, 0.11233392f, 0.12492210f, -0.27953562f, -0.07465009f, -0.16116151f, -0.00834912f, 
    0.26007879f, 0.12061005f, 0.01485991f, -0.05855276f, -0.07222120f, 0.05826653f, 0.02844752f, 0.01099406f, 
    0.19631784f, -0.04407534f, 0.13624288f, 0.07181060f, 0.14367026f, 0.01902059f, 0.06703097f, -0.05845897f, 
    0.10463423f, -0.04179078f, -0.00984022f, 0.06717567f, -0.23020142f, 0.07503083f, 0.05375251f, 0.04568893f, 
    0.04178952f, -0.06178133f, 0.00243683f, 0.01079580f, 0.17189711f, -0.00107006f, -0.01835352f, 0.11812140f, 
    -0.02626337f, 0.18345700f, 0.16636036f, 0.27272624f, 0.05038115f, -0.06599136f, 0.02199871f, 0.17553292f, 
    0.17864141f, 0.05906432f, -0.06516643f, 0.14916587f, 0.13691899f, -0.04323149f, -0.02251306f, 0.23578298f, 
    -0.00130407f, 0.15404215f, 0.12777290f, 0.05135750f, 0.08095144f, 0.05806941f, 0.23705029f, 0.09405191f, 
    0.12236784f, 0.06884921f, -0.13705917f, -0.09273940f, 0.12288842f, -0.03867547f, 0.02661812f, 0.12219118f, 
    0.03322662f, 0.03131197f, -0.04281054f, 0.00789550f, 0.10214703f, 0.21676086f, -0.01541331f, -0.20782325f, 
    0.05918541f, 0.12932160f, 0.13371266f, 0.19286089f, 0.13880873f, 0.00602352f, -0.00257856f, 0.13372661f, 
    0.04363191f, 0.11622725f, -0.05227579f, -0.05092554f, 0.18240237f, -0.00248579f, -0.12342793f, 0.03046658f, 
    0.06112618f, 0.03866335f, 0.04759516f, 0.14280355f, 0.09777063f, -0.05924647f, -0.15087418f, 0.00055082f, 
    0.18071763f, 0.10385194f, 0.02389025f, 0.03461675f, -0.03644602f, -0.04400476f, -0.06856731f, 0.08198694f, 
    0.27937651f, 0.02512990f, -0.11745580f, 0.03564453f, -0.03107244f, -0.03808454f, 0.09470896f, -0.04132276f, 
    0.07553609f, 0.03882032f, 0.03791726f, 0.01615050f, 0.20620134f, 0.17211078f, 0.09639267f, 0.00129863f, 
    0.10696347f, 0.08942584f, -0.07188661f, 0.06700943f, -0.06900551f, -0.04768312f, 0.01860397f, -0.06626996f, 
    0.00735466f, 0.01342538f, 0.08189985f, 0.24629854f, 0.06096637f, -0.04232601f, 0.00322687f, -0.01354392f, 
    0.10960937f, 0.02932809f, -0.03957709f, 0.03374879f, 0.12592725f, 0.02098493f, 0.02810786f, 0.03683180f, 
    -0.14504585f, 0.11926519f, -0.02075168f, 0.07265259f, -0.04178553f, 0.12798515f, 0.04745113f, -0.01375062f, 
    0.01402091f, 0.01156903f, 0.00377375f, 0.00568772f, -0.01355307f, 0.02767089f, 0.01339057f, 0.00388102f, 
    -0.03900234f, 0.00853417f, 0.00017680f, 0.01215409f, -0.01536062f, 0.01792183f, -0.00768488f, -0.00715753f, 
    -0.04033050f, -0.02567954f, 0.00080888f, 0.00783870f, -0.03491236f, 0.00945374f, -0.00658887f, -0.03223541f, 
    0.02889767f, 0.01507581f, 0.02284723f, 0.00289101f, 0.00402256f, 0.01638179f, 0.02026990f, 0.01895952f, 
    -0.01818147f, 0.01953539f, -0.01887114f, -0.00651269f, -0.00338329f, -0.00955728f, 0.00259296f, -0.01815984f, 
    -0.03178955f, 0.01366782f, 0.02387843f, 0.01816316f, -0.02845407f, -0.02013054f, -0.02405553f, 0.02474527f, 
    -0.01986891f, -0.02931281f, 0.03062375f, 0.02226280f, 0.03221620f, 0.02796034f, 0.00018023f, 0.02365945f, 
    -0.01678693f, 0.02860983f, -0.00689272f, 0.00613547f, -0.02016840f, -0.03870810f, -0.01672175f, -0.00642852f, 
    -0.00082925f, 0.01592151f, 0.01268838f, 0.02229075f, -0.02823059f, -0.02769648f, 0.03239334f, -0.01079487f, 
    0.02471796f, -0.02299154f, -0.02105388f, -0.00549413f, -0.02868362f, 0.01656857f, -0.04368489f, -0.01939066f, 
    -0.02254851f, 0.02781787f, -0.02907280f, 0.03587516f, -0.04083540f, 0.01627507f, -0.00444316f, 0.02923317f, 
    0.03155617f, -0.02288220f, 0.01087724f, 0.01310741f, 0.02056654f, 0.00975551f, 0.00441751f, 0.00893139f, 
    0.00310885f, 0.02347078f, 0.01492427f, -0.01047527f, 0.02371998f, 0.01966556f, -0.00837774f, -0.00995463f, 
    0.01026869f, -0.03733937f, -0.03676227f, -0.00559626f, 0.00614467f, -0.02637750f, -0.02402930f, -0.03557449f, 
    -0.01277515f, 0.01830781f, -0.01772660f, -0.02799788f, -0.00105941f, 0.00181438f, 0.00713001f, 0.02108792f, 
    -0.02227810f, 0.00106148f, -0.00893335f, -0.03627533f, -0.00028273f, 0.00232220f, -0.01082112f, -0.00172099f, 
    0.01399137f, 0.03082774f, -0.00567766f, -0.01657223f, -0.03854532f, 0.00866841f, -0.02417213f, 0.01047119f, 
    -0.01245052f, 0.02234026f, 0.01670404f, 0.02417326f, 0.02087251f, -0.03347500f, -0.02392373f, -0.02206439f, 
    0.03206718f, -0.04338750f, 0.01160517f, 0.00993962f, -0.01333006f, 0.02955200f, 0.00802527f, 0.02138602f, 
    0.01975484f, 0.01844805f, -0.02301940f, -0.00734437f, -0.04209062f, 0.01212374f, -0.01041654f, -0.03312486f, 
    0.00888264f, -0.03647495f, -0.01902516f, -0.02253530f, -0.01349693f, -0.01064071f, 0.01519783f, -0.01130506f, 
    0.03120303f, 0.00476715f, -0.01383241f, -0.00921921f, 0.00433572f, 0.02416146f, 0.03032951f, -0.01243666f, 
    0.00408919f, 0.00712564f, -0.03437939f, 0.00472109f, 0.00254072f, -0.00053187f, -0.03745975f, 0.01493430f, 
    -0.01005544f, 0.02060040f, 0.01746239f, -0.02784486f, -0.02666948f, 0.00348058f, -0.01672054f, -0.00747608f, 
    0.01042987f, 0.02107462f, -0.02335870f, -0.02177566f, -0.03274159f, -0.02605027f, 0.02618151f, -0.02402756f, 
    -0.02844064f, -0.00053574f, -0.01027082f, 0.02026545f, 0.01033676f, -0.02415707f, -0.00154587f, -0.02104603f, 
    -0.01051861f, -0.01528955f, -0.01576889f, -0.00318316f, -0.04162975f, 0.01493412f, 0.00708098f, -0.02708106f, 
    -0.00577257f, -0.02044044f, -0.01079821f, -0.00262418f, 0.00009423f, 0.02333692f, -0.03488306f, -0.01172157f, 
    0.00382700f, -0.04296782f, 0.00689491f, -0.02974766f, 0.01778353f, -0.02745414f, -0.01906576f, 0.00680717f, 
    -0.00534909f, 0.00229415f, -0.03614936f, -0.00195191f, -0.04339876f, -0.03736129f, 0.03339103f, -0.01089574f, 
    -0.01125303f, -0.00535502f, -0.03114389f, 0.00281729f, 0.02609932f, -0.03582289f, 0.01900816f, -0.01137630f, 
    -0.03703328f, 0.02420334f, -0.00324782f, 0.02883622f, -0.04099067f, -0.03109800f, -0.03978543f, -0.02020268f, 
    0.02360944f, 0.02900487f, -0.01143949f, -0.02088135f, -0.00174982f, -0.03257034f, -0.00426145f, -0.01678115f, 
    0.02289111f, 0.01121231f, 0.00662763f, -0.01575797f, -0.00757837f, -0.00796444f, -0.00470856f, 0.00394634f, 
    -0.00285129f, 0.01939683f, -0.02220712f, -0.02121148f, 0.00830903f, 0.00921464f, 0.01195251f, -0.01961817f, 
    0.01346423f, -0.02249029f, -0.00616713f, 0.02128095f, 0.00794108f, -0.00035391f, 0.00706240f, -0.01874098f, 
    -0.02863437f, -0.00268939f, 0.01064626f, 0.02216143f, -0.01736391f, -0.03712640f, -0.03489505f, -0.04025515f, 
    0.02818901f, -0.03556072f, 0.01147782f, -0.00441546f, 0.02248044f, 0.01704010f, 0.03139205f, -0.01541836f, 
    0.01650827f, -0.00226728f, -0.01650951f, -0.00692113f, -0.01356038f, -0.02316763f, 0.03123248f, 0.03224566f, 
    -0.01750149f, 0.01200947f, 0.02212533f, 0.02446705f, 0.02451630f, 0.00594922f, 0.01010016f, 0.00809556f, 
    0.00327336f, -0.02930609f, -0.02210640f, -0.02391865f, -0.01382456f, -0.03355262f, -0.01832461f, -0.00487593f, 
    0.00657308f, -0.03880952f, -0.04044950f, -0.01991369f, -0.02996727f, -0.02894748f, 0.02024615f, -0.00911263f, 
    -0.01748361f, 0.00426706f, -0.00932517f, -0.03106655f, -0.02418920f, 0.01087795f, 0.03081680f, -0.03802304f, 
    -0.02678748f, 0.03246380f, -0.03016867f, -0.03772934f, 0.00565178f, -0.03733231f, -0.04288778f, 0.00029039f, 
    -0.01211148f, -0.02515969f, -0.01975017f, 0.00088333f, 0.02121328f, 0.01302154f, 0.01558457f, 0.00395177f, 
    -0.03151930f, -0.00770172f, -0.01530373f, -0.01738761f, 0.02990259f, -0.00044265f, -0.03056147f, -0.01915153f, 
    -0.00074514f, -0.00274753f, 0.01739429f, 0.00647669f, 0.00598442f, -0.03257595f, -0.00057174f, -0.00633409f, 
    -0.01641656f, 0.03159109f, -0.03315943f, -0.02220445f, -0.01703164f, 0.00871019f, 0.01241809f, -0.03140392f, 
    -0.03668305f, 0.02113369f, -0.03750221f, -0.03249900f, 0.01497104f, 0.02583836f, -0.01943933f, -0.02941570f, 
    -0.00384537f, 0.02156944f, 0.01533711f, -0.02654111f, -0.01550610f, 0.02344623f, -0.02953411f, -0.01405821f, 
    -0.03484886f, 0.01158707f, -0.00198715f, -0.02501234f, -0.01845120f, -0.01302121f, -0.01838815f, -0.04201629f, 
    -0.01784546f, 0.02243790f, 0.01488967f, 0.03338087f, -0.03433472f, -0.00667600f, -0.03367830f, -0.03400733f, 
    0.03338939f, -0.01421453f, 0.00200653f, 0.02057344f, 0.00775806f, 0.00879400f, -0.02955315f, 0.01769725f, 
    -0.01459561f, 0.01729218f, 0.01756447f, -0.02725879f, -0.01332641f, -0.00084231f, -0.00521394f, -0.03771774f, 
    0.02072520f, -0.01712907f, -0.01058306f, -0.00813540f, 0.02589468f, 0.00458952f, 0.02292624f, -0.03394315f, 
    -0.02975940f, 0.02306535f, -0.03213448f, -0.02708079f, -0.00337838f, 0.02167001f, -0.02429743f, -0.02338171f, 
    -0.01863367f, -0.01390813f, 0.01662072f, 0.00666634f, 0.00549154f, -0.01560837f, 0.00930202f, 0.00217779f, 
    0.00877431f, -0.00310913f, 0.03221575f, -0.00124994f, 0.00080112f, 0.00093027f, 0.02506565f, 0.01482612f, 
    -0.02955090f, -0.02005688f, -0.00996641f, -0.00753949f, 0.00181970f, -0.02540940f, -0.02967284f, 0.01412138f, 
    -0.03402187f, -0.01052066f, -0.02482880f, -0.00817222f, -0.03090205f, 0.02688843f, -0.00297766f, -0.01319628f, 
    -0.03345128f, 0.00180194f, 0.01379019f, -0.04366172f, -0.02168847f, 0.00907915f, -0.03246627f, 0.00324666f, 
    0.01528266f, 0.00443587f, 0.00398395f, -0.02987122f, 0.01343540f, -0.02717263f, 0.01167494f, -0.02723760f, 
    -0.03050536f, 0.01977645f, 0.02989464f, -0.01701305f, 0.01956310f, -0.01958579f, -0.00194810f, -0.02131000f, 
    -0.02102344f, 0.01237807f, 0.01566477f, -0.01882230f, 0.01262490f, -0.01322301f, 0.00907070f, -0.03753683f, 
    0.00377895f, -0.02355191f, -0.00638310f, -0.03847172f, -0.01662623f, 0.02332839f, 0.02078240f, -0.03590710f, 
    -0.03103207f, -0.03689350f, 0.00147412f, 0.01137898f, -0.02041043f, 0.02047300f, -0.00748335f, 0.01233378f, 
    -0.00232094f, -0.02292533f, 0.01798099f, -0.03160977f, 0.03066419f, 0.00477746f, 0.02277635f, -0.04134337f, 
    0.00360393f, 0.01537620f, -0.00820377f, -0.01316626f, 0.02816448f, 0.02165287f, -0.01085078f, 0.00668951f, 
    -0.01768750f, 0.00794331f, -0.00212379f, 0.02079355f, 0.01237803f, -0.01663046f, 0.02251400f, -0.03457370f, 
    -0.00681446f, -0.00036092f, -0.00960680f, 0.00942649f, 0.00907713f, 0.03238129f, -0.02581098f, -0.02361204f, 
    0.00947079f, -0.00380372f, 0.00912149f, 0.02773007f, -0.02796269f, 0.02580423f, 0.00788804f, -0.02467079f, 
    -0.03357684f, -0.00164500f, 0.00320779f, -0.03845719f, -0.03472633f, 0.01410989f, -0.02630018f, -0.02036279f, 
    0.00428674f, -0.00576711f, -0.00861704f, 0.00806636f, -0.03283043f, -0.01298202f, 0.01413593f, 0.01180042f, 
    0.02839427f, -0.00100582f, -0.00562631f, -0.01623757f, 0.02865017f, -0.02637470f, 0.01681233f, -0.02946252f, 
    -0.02228573f, -0.01624458f, -0.02770104f, 0.01750298f, -0.01055283f, 0.01482363f, -0.02996043f, 0.02708925f, 
    -0.00043156f, -0.02763436f, 0.01209812f, -0.03976778f, -0.02271883f, -0.01071937f, 0.00397869f, -0.03687774f, 
    -0.02737945f, 0.00346635f, 0.01118524f, 0.00423331f, -0.03624526f, -0.00764389f, -0.02203767f, -0.02526642f, 
    -0.02178189f, -0.03311942f, -0.00680035f, -0.03555733f, 0.02398711f, 0.01570830f, 0.03213709f, 0.01107308f, 
    0.01662124f, 0.01514979f, -0.03523567f, -0.01289555f, -0.03597690f, 0.02101491f, 0.00676962f, 0.00549289f, 
    -0.03814652f, -0.01592828f, 0.02131455f, 0.02967355f, 0.02373412f, -0.03480843f, -0.00038446f, -0.02683192f, 
    -0.01540685f, -0.00382734f, -0.02853613f, -0.02449503f, 0.00885262f, 0.00505468f, -0.01998704f, -0.01607610f, 
    -0.04257381f, -0.02509662f, -0.00119034f, -0.00061609f, 0.00962871f, -0.01176104f, -0.01586357f, 0.00365671f, 
    0.01130646f, -0.03674776f, -0.04278837f, 0.00372665f, 0.01661703f, 0.00939981f, -0.02670841f, -0.03315494f, 
    -0.01995304f, -0.01412649f, -0.01902845f, -0.01670158f, -0.01671988f, -0.01164935f, 0.01576912f, 0.03286383f, 
    -0.02044670f, -0.00157821f, 0.00942161f, -0.00603025f, -0.00571617f, -0.02357796f, 0.01804228f, -0.03719813f, 
    -0.02782413f, -0.02841858f, 0.00684062f, -0.02622590f, -0.02872533f, 0.02636450f, 0.00509448f, -0.03870789f, 
    -0.04261341f, 0.00482122f, 0.01679856f, -0.02369541f, -0.01544436f, -0.01643654f, -0.03267311f, 0.01753236f, 
    0.03069376f, -0.03718155f, -0.03593759f, -0.04113636f, -0.03470991f, 0.00523752f, -0.01873236f, -0.02358284f, 
    -0.02390049f, 0.01003175f, -0.02930939f, 0.01123778f, 0.01962602f, 0.01445887f, -0.00736576f, 0.01453556f, 
    -0.00517358f, -0.00799948f, -0.00276871f, -0.02757647f, -0.00389565f, -0.02939061f, -0.00800920f, -0.02150191f, 
    -0.03044471f, 0.02986130f, -0.03074729f, -0.02366261f, 0.02051841f, -0.02324584f, 0.02063652f, 0.00813977f, 
    -0.01617567f, 0.00951906f, -0.01485562f, -0.03497922f, -0.00659047f, 0.02268837f, 0.03699326f, -0.01462514f, 
    -0.01473958f, 0.00611425f, -0.01200238f, -0.01161303f, -0.02412559f, 0.00369314f, -0.00327710f, -0.03467626f, 
    -0.03338705f, 0.00946569f, -0.02374809f, 0.02800832f, 0.00222596f, -0.03815003f, -0.02814901f, -0.02423642f, 
    0.02037852f, 0.02889348f, -0.01843735f, -0.02165019f, -0.02998426f, -0.01695602f, 0.01411465f, -0.02998281f, 
    -0.00774148f, -0.02665154f, -0.04171745f, -0.03559216f, 0.02146075f, 0.02841510f, -0.01081401f, 0.01279315f, 
    -0.38734159f, 0.01588746f, 0.04186497f, 0.21656525f, -0.04729589f, 0.02612849f, -0.09824573f, -0.01060549f, 
    0.05289954f, -0.03108085f, 0.01046105f, 0.06297185f, 0.00734537f, -0.01336880f, 0.18177021f, 0.18421528f, 
    -0.00633849f, -0.05195118f, 0.01221639f, 0.06896140f, 0.11063797f, 0.07015539f, -0.09633833f, 0.10341074f, 
    -0.29087174f, 0.08722562f, 0.07697993f, 0.04325959f, 0.11751799f, 0.06119041f, 0.16850404f, -0.02647972f, 
    0.08619091f, 0.08938542f, 0.06763040f, 0.07537878f, -0.03253466f, 0.03300112f, 0.03385208f, 0.12897648f, 
    0.06395076f, -0.04094226f, 0.02003367f, 0.17138596f, -0.02253892f, 0.06721549f, 0.05833173f, 0.06691011f, 
    -0.17412187f, 0.02789632f, 0.03243903f, 0.10489435f, 0.00258636f, 0.04934612f, 0.10144393f, 0.02067443f, 
    0.16432197f, 0.18174030f, 0.07633670f, 0.00047006f, 0.04904339f, 0.11169152f, 0.01631887f, 0.00753685f, 
    0.09310488f, -0.02883717f, 0.08452117f, 0.08292621f, -0.04073361f, 0.18573637f, -0.01774582f, 0.10191470f, 
    0.05649192f, 0.35791671f, -0.16756077f, 0.00805934f, 0.12022719f, -0.06061865f, 0.13857286f, -0.10784987f, 
    -0.08898577f, -0.01865414f, -0.01637790f, -0.03973136f, 0.18488708f, 0.19091016f, 0.08443926f, 0.24793576f, 
    0.04694436f, 0.04066447f, 0.04985948f, 0.00066869f, 0.00036710f, 0.02998053f, -0.01092991f, 0.05704625f, 
    0.11830593f, 0.16530199f, -0.06228037f, 0.15963668f, 0.06520810f, 0.15291296f, 0.03631479f, 0.08745257f, 
    -0.03708502f, 0.05892927f, 0.10754515f, 0.13019402f, -0.18049146f, 0.21848230f, 0.15891324f, -0.09223991f, 
    0.04110748f, 0.05446048f, 0.09852269f, 0.12045214f, 0.03991885f, 0.00016754f, 0.03961945f, -0.02536566f, 
    -0.04654993f, 0.24954231f, -0.01317654f, 0.18861444f, 0.06866577f, 0.05536712f, -0.00104993f, 0.13336748f, 
    0.07572919f, 0.04769785f, 0.10601982f, 0.10043201f, 0.21632473f, 0.31267074f, -0.10678795f, 0.17289427f, 
    0.07325909f, -0.08202225f, 0.02074146f, 0.03391834f, 0.03291798f, -0.06959921f, 0.04249948f, 0.07470381f, 
    -0.04048936f, 0.14669885f, 0.03484615f, -0.05683777f, 0.03122510f, -0.01415655f, 0.05239680f, 0.00557075f, 
    0.03390931f, 0.05016354f, -0.02156062f, -0.00496835f, -0.02520484f, -0.01457011f, 0.02015965f, 0.06514727f, 
    0.04872839f, -0.02661072f, 0.00339063f, 0.02872104f, 0.00316535f, -0.05240213f, 0.07290230f, 0.06988046f, 
    -0.07382990f, 0.15024267f, 0.15463893f, 0.29402846f, 0.23545404f, 0.08691047f, 0.03865234f, 0.04880081f, 
    -0.00407296f, -0.04278122f, -0.03378169f, 0.18299092f, 0.17806335f, 0.18252641f, 0.02077123f, 0.22860961f, 
    0.05846364f, 0.05924328f, 0.04908099f, 0.04865104f, -0.11163897f, 0.00081603f, 0.12797204f, 0.05856811f, 
    -0.14477538f, 0.24190767f, 0.16437273f, 0.01757092f, 0.13747112f, -0.00414288f, 0.02311206f, 0.13306299f, 
    0.01809743f, -0.05605590f, 0.03798304f, 0.16799635f, -0.39113811f, 0.12361509f, -0.02351107f, -0.08828049f, 
    0.07347558f, -0.01533948f, -0.08195956f, 0.00601054f, -0.03339152f, 0.03309947f, -0.17169458f, 0.10677566f, 
    0.22596490f, 0.23030819f, -0.18195228f, 0.10745711f, 0.07724509f, 0.00862061f, -0.01785596f, 0.01200806f, 
    0.09070098f, -0.00376019f, 0.14645031f, -0.03243832f, -0.15542202f, -0.25082195f, 0.23372912f, 0.03707867f, 
    -0.01461571f, -0.02347033f, 0.01517643f, -0.00865469f, 0.07021838f, 0.02933786f, 0.07647205f, -0.11939187f, 
    -0.00300867f, -0.08208554f, 0.16095515f, 0.08146582f, 0.05922909f, -0.01002520f, 0.06029540f, 0.00037062f, 
    0.04415677f, 0.02485978f, 0.12729031f, 0.02951069f, 0.17131774f, -0.11907903f, -0.00055297f, -0.16627659f, 
    -0.06906296f, -0.00575234f, 0.00221614f, -0.05093783f, 0.05821540f, 0.04363797f, 0.20082507f, 0.18075284f, 
    -0.12877394f, 0.20500302f, 0.18566391f, -0.05184214f, -0.05853777f, 0.09800935f, -0.00943364f, 0.11456155f, 
    0.05229903f, -0.00613165f, 0.12935157f, 0.03345548f, 0.10302376f, -0.10734602f, 0.06199060f, 0.20560569f, 
    -0.06673671f, -0.03707016f, 0.00044989f, 0.00998743f, 0.02083935f, -0.00175173f, 0.00071620f, 0.02564366f, 
    0.04305749f, 0.08976295f, 0.08958949f, 0.10859409f, 0.01287248f, 0.08919232f, -0.02657866f, 0.10930214f, 
    -0.00359217f, -0.00840740f, -0.03047057f, -0.03022330f, 0.38920712f, 0.00137826f, 0.09057906f, 0.27998805f, 
    -0.01749771f, 0.01351836f, 0.03485649f, -0.08433823f, 0.13805258f, 0.05371305f, 0.09797873f, -0.02171918f, 
    -0.12018261f, 0.18351863f, 0.13033585f, 0.26414144f, 0.22351234f, 0.06569171f, 0.06611188f, 0.13128790f, 
    0.04978634f, -0.04172430f, 0.02968804f, 0.06336111f, 0.06260166f, 0.12581688f, 0.24647093f, 0.20329356f, 
    0.05342756f, 0.06890991f, 0.05970068f, 0.08319522f, 0.05216281f, 0.05699518f, 0.05650941f, -0.02758780f, 
    0.09690443f, 0.03423563f, 0.16037761f, 0.13767286f, 0.05322735f, 0.16861695f, 0.09476616f, 0.18159677f, 
    0.05372337f, 0.01405213f, 0.01317013f, 0.04777603f, 0.18275116f, -0.10751317f, 0.16899422f, -0.13839866f, 
    0.01070969f, 0.03513106f, 0.00016044f, 0.01790238f, 0.04593467f, 0.00053132f, 0.07857814f, -0.01192019f, 
    0.36528671f, -0.01950257f, 0.01253498f, 0.08195072f, -0.03646283f, 0.11893717f, -0.01853297f, 0.11267211f, 
    0.02343017f, 0.08700325f, 0.08885402f, 0.11391971f, -0.05139834f, 0.11454407f, 0.06056564f, -0.06806026f, 
    0.00443044f, 0.04864530f, -0.06178560f, 0.05607215f, 0.07684309f, -0.10398272f, 0.05062610f, 0.02703112f, 
    -0.01048538f, -0.06843916f, -0.01637771f, 0.09381408f, 0.06427980f, -0.07398417f, 0.08535411f, 0.00024886f, 
    -0.01043476f, 0.13749792f, 0.05775324f, -0.00319697f, -0.18982963f, 0.01418062f, 0.23325256f, 0.14267039f, 
    0.01962451f, 0.02414271f, -0.06291232f, 0.09735183f, -0.00301555f, 0.00340296f, 0.07654907f, -0.03244246f, 
    0.17521541f, -0.22111090f, -0.00630728f, 0.17924163f, -0.09874871f, 0.00387423f, -0.08974520f, -0.09235483f, 
    0.04673638f, 0.08904788f, -0.00832988f, 0.07196067f, -0.03350492f, 0.08068043f, 0.15108405f, 0.12880847f, 
    -0.00831142f, -0.03520425f, -0.05756010f, 0.03661544f, 0.02753197f, -0.02982402f, 0.05340288f, -0.05864584f, 
    0.06106240f, 0.06988842f, -0.16339743f, 0.02243695f, 0.14803781f, 0.00250735f, -0.05875811f, 0.07887493f, 
    0.05388518f, 0.09531190f, 0.10448509f, -0.03375487f, -0.02194092f, 0.21710205f, 0.12924407f, 0.17548488f, 
    0.07984019f, 0.11003868f, 0.09373178f, 0.08514324f, 0.05969096f, -0.00485593f, 0.20147496f, -0.11472471f, 
    0.23476063f, 0.00710596f, 0.05367084f, 0.14636827f, 0.09806887f, 0.07743579f, -0.00034264f, 0.10173164f, 
    0.00881323f, 0.04248895f, 0.10067469f, 0.02689741f, 0.05586186f, -0.00483010f, -0.02856878f, -0.17736000f, 
    0.07706928f, 0.00507802f, 0.00158337f, -0.02073503f, -0.03898251f, -0.07310995f, 0.10393174f, 0.04956222f, 
    0.15067922f, -0.03701505f, -0.02985067f, -0.07709542f, 0.01104796f, 0.11857360f, 0.12865318f, 0.03902549f, 
    0.07303203f, 0.01905788f, -0.04386223f, 0.05480878f, 0.29812524f, 0.12681240f, 0.21879986f, 0.15766042f, 
    0.18999904f, 0.00905153f, 0.07747520f, 0.13854720f, 0.09905930f, 0.04219169f, -0.07045530f, 0.08348522f, 
    -0.36742970f, -0.22408441f, 0.08994433f, 0.18902671f, -0.05734520f, -0.05433956f, -0.04450632f, 0.00057046f, 
    -0.00302725f, 0.06568880f, -0.14900203f, -0.03476035f, 0.08087501f, 0.29074386f, 0.07498044f, 0.16867754f, 
    -0.01141100f, -0.02402461f, 0.03065602f, 0.05401299f, 0.01709086f, 0.00549237f, 0.03772720f, 0.11287972f, 
    -0.13115962f, -0.07206575f, -0.02725064f, -0.06639958f, 0.04197681f, 0.02256455f, 0.15594690f, -0.05414930f, 
    0.09194629f, 0.05153653f, 0.01088799f, 0.10199648f, 0.27328509f, 0.11676630f, 0.36460674f, 0.09961911f, 
    0.09694262f, 0.15499909f, 0.10420560f, 0.05269481f, -0.01440916f, 0.08538550f, 0.06726804f, 0.12289085f, 
    0.36887565f, 0.22090670f, 0.00302883f, 0.11071855f, 0.01757789f, -0.01102351f, -0.00288055f, 0.06959700f, 
    0.03497449f, 0.10142701f, 0.00545992f, 0.03067848f, 0.04378182f, 0.16917184f, 0.05037668f, 0.01076400f, 
    0.04024898f, -0.02505649f, 0.04405008f, -0.06357240f, -0.06731606f, -0.04787892f, 0.10414663f, -0.02176114f, 
    -0.06581351f, 0.30122900f, 0.10354652f, -0.11654159f, -0.04117631f, 0.00852268f, 0.02114380f, 0.00013880f, 
    0.00771505f, 0.03188879f, 0.05631987f, -0.04861047f, 0.13354906f, -0.28274831f, -0.00710715f, 0.05127747f, 
    -0.00362914f, -0.05743444f, 0.02082289f, 0.00252000f, 0.00780831f, -0.06289025f, -0.03719389f, -0.05245041f, 
    0.16243292f, 0.01184340f, -0.18613477f, 0.19660598f, 0.05372542f, 0.02396265f, 0.16111341f, -0.12835078f, 
    0.01020182f, -0.01947240f, -0.00132708f, -0.08285545f, 0.01053574f, 0.08930990f, 0.11801786f, 0.20121065f, 
    -0.01106376f, -0.02888693f, 0.02625510f, 0.01012948f, -0.10842960f, 0.02642981f, 0.02482053f, -0.00493773f, 
    -0.16468227f, 0.06084321f, 0.00994314f, -0.10482103f, -0.04834704f, 0.09621686f, -0.03325560f, 0.07730684f, 
    0.11096337f, 0.01919795f, 0.08625036f, 0.08180179f, 0.18562748f, 0.35440889f, 0.00571991f, 0.13981476f, 
    -0.00632568f, 0.09991886f, 0.09099985f, 0.12488908f, -0.02505547f, -0.00791817f, 0.03281955f, -0.01604483f, 
    -0.04685268f, 0.02944558f, -0.30860850f, 0.16538537f, 0.00846044f, 0.05370711f, 0.07528377f, -0.07195541f, 
    -0.03142311f, 0.04636448f, 0.08320990f, -0.02521294f, -0.00064275f, 0.04079415f, -0.17038284f, -0.23037349f, 
    0.02611019f, 0.02416651f, -0.05501359f, -0.04896181f, -0.01005097f, 0.04316951f, -0.04000497f, 0.07065444f, 
    -0.14565034f, -0.14671755f, -0.01806332f, 0.13644747f, -0.02412780f, -0.04349073f, -0.01642670f, -0.00790399f, 
    0.12485933f, 0.07880522f, 0.05201141f, 0.02572135f, 0.05106572f, -0.24116071f, 0.11315455f, 0.19924518f, 
    -0.05452406f, 0.04630528f, -0.01582271f, -0.20065239f, -0.03718413f, 0.01714572f, 0.00943313f, -0.04137493f, 
    0.11140545f, 0.03477496f, 0.02357983f, 0.13063477f, -0.00083293f, 0.03173008f, 0.11114433f, -0.03984361f, 
    0.09712375f, 0.02854500f, 0.06104857f, -0.01644222f, 0.00004140f, 0.01670607f, 0.16422951f, 0.10470864f, 
    -0.16514859f, 0.02011365f, 0.00762147f, -0.07774034f, -0.04529392f, 0.21689276f, 0.12349287f, 0.11713554f, 
    -0.24842492f, 0.04961488f, 0.05912242f, -0.07766574f, 0.12541245f, 0.02471593f, -0.13630405f, 0.10040516f, 
    -0.06138140f, 0.00809355f, -0.07014079f, 0.13820066f, -0.16579472f, -0.04357652f, -0.04133303f, -0.03565608f, 
    0.03729485f, -0.01441278f, -0.06435446f, -0.03885521f, 0.00176758f, 0.00861518f, 0.01522908f, 0.00467679f, 
    0.23282585f, 0.11189133f, -0.10541429f, -0.02300670f, -0.01215782f, 0.08029808f, -0.00975503f, -0.00014864f, 
    -0.04557151f, -0.02813369f, 0.02108477f, 0.05640144f, 0.20432436f, 0.31114972f, 0.23308060f, -0.09916126f, 
    0.17829160f, 0.08420292f, 0.14374098f, -0.04657134f, -0.00551764f, -0.06619179f, 0.00428881f, 0.01208843f, 
    -0.04302794f, -0.06345081f, 0.00392317f, 0.15611905f, 0.10732003f, -0.00813390f, 0.00560201f, -0.00358880f, 
    -0.02974537f, 0.02740126f, 0.03124719f, -0.03224419f, -0.24276319f, 0.08017500f, -0.11984259f, 0.06011405f, 
    -0.04834113f, -0.19092883f, -0.09989794f, -0.09595104f, 0.04980352f, -0.00002183f, -0.14748627f, 0.06369987f, 
    -0.06401503f, -0.18748492f, 0.01616461f, -0.07151642f, -0.13020727f, 0.00627767f, 0.01185312f, 0.09282478f, 
    0.13910887f, 0.03670860f, 0.02857479f, 0.04215777f, -0.05456483f, 0.14408761f, 0.09957692f, -0.05667048f, 
    -0.09231103f, -0.03758904f, -0.01299497f, -0.11534814f, 0.02482975f, 0.04038125f, -0.02459257f, 0.07103918f, 
    -0.03087038f, -0.08349150f, 0.10359199f, 0.21093243f, -0.07817762f, -0.02244985f, 0.14561981f, -0.06286209f, 
    -0.02826837f, 0.01284586f, 0.00144589f, -0.10085455f, -0.08972284f, 0.14525984f, 0.01199238f, 0.03418937f, 
    0.13172825f, -0.13353087f, 0.00068061f, -0.05176368f, -0.04734407f, 0.09099904f, 0.03965089f, 0.09583316f, 
    0.04736115f, 0.09347166f, -0.04744543f, 0.04604855f, 0.01690390f, -0.04114519f, -0.03675942f, -0.02454281f, 
    -0.00383285f, -0.08887018f, -0.11992419f, 0.03777904f, 0.05688801f, 0.19957499f, -0.03438461f, 0.10469039f, 
    0.02612480f, 0.10216065f, 0.13725030f, -0.03556593f, 0.05396372f, -0.01976145f, -0.02439661f, -0.01927343f, 
    0.36618781f, 0.04581966f, 0.01128101f, 0.03928413f, -0.10178204f, -0.02058104f, -0.08118203f, 0.10494344f, 
    0.11343282f, 0.05119042f, 0.11176805f, 0.10185740f, -0.02302808f, 0.20858292f, -0.13340729f, 0.08899178f, 
    -0.08711565f, 0.10257342f, -0.09258983f, 0.01772568f, -0.10260260f, 0.04745715f, -0.09486781f, -0.11654759f, 
    -0.07732678f, 0.26926959f, -0.00339875f, -0.07197943f, -0.04188537f, -0.03911397f, -0.14133175f, 0.12568039f, 
    0.08709858f, 0.05331002f, 0.19099900f, 0.07584626f, 0.31095266f, -0.08779475f, 0.12575443f, -0.06122588f, 
    -0.02382287f, -0.02705223f, -0.05340433f, 0.01476014f, -0.02028265f, 0.03017253f, -0.09683103f, -0.01760147f, 
    0.31145322f, -0.11012344f, 0.05935735f, 0.02704119f, 0.02790370f, -0.07213277f, -0.02514486f, 0.07704554f, 
    0.05834836f, -0.13895595f, -0.09510127f, 0.02914671f, -0.01286871f, 0.04560385f, -0.01524074f, 0.13871498f, 
    0.01678147f, 0.00229464f, -0.00860841f, -0.04060488f, 0.00229713f, 0.00241851f, 0.00353381f, -0.05717425f, 
    -0.11897688f, -0.04020913f, 0.13939725f, -0.10799624f, -0.11645681f, -0.06923921f, -0.09490648f, -0.01481282f, 
    -0.06219678f, -0.09283014f, -0.02989629f, 0.07564511f, -0.03457290f, -0.01838973f, 0.02787133f, 0.09647233f, 
    -0.08464681f, -0.20887882f, -0.10961518f, -0.03973950f, -0.04334850f, 0.06489404f, 0.00327443f, 0.03713972f, 
    0.00085005f, -0.23893872f, 0.26046246f, -0.05223627f, 0.02157054f, 0.06587790f, -0.03213920f, -0.07876242f, 
    -0.06414224f, 0.00893878f, 0.12390602f, 0.11882874f, 0.09654453f, -0.04266569f, 0.07994590f, -0.04794673f, 
    0.00212655f, 0.04317543f, 0.02130697f, -0.03910314f, -0.01365926f, -0.01549277f, 0.01278970f, -0.01953479f, 
    0.07631478f, 0.12137225f, -0.10048144f, 0.12390754f, 0.02719005f, 0.01824382f, 0.05239918f, -0.05350510f, 
    0.04878983f, -0.07711157f, 0.05293620f, 0.09334059f, -0.01972012f, 0.00736502f, 0.12293679f, 0.11747345f, 
    0.08955862f, -0.10851969f, 0.03501228f, -0.05873162f, -0.05441645f, 0.00311342f, -0.01345117f, -0.09434307f, 
    0.04421106f, 0.18163323f, -0.04206641f, 0.02093423f, 0.04074553f, 0.13318042f, 0.01741688f, 0.11657035f, 
    -0.05766978f, -0.16614702f, 0.16677600f, 0.07427195f, 0.12918638f, 0.10270135f, -0.06770703f, 0.05415479f, 
    0.03442979f, 0.02408403f, 0.05838703f, -0.05648877f, -0.00602897f, 0.04779343f, 0.12528855f, -0.04002781f, 
    0.19882613f, -0.02350927f, -0.04136489f, 0.04022389f, -0.04954228f, -0.07368203f, -0.14005792f, 0.03018421f, 
    -0.01181364f, -0.02392933f, 0.10408935f, 0.01370152f, 0.03789474f, -0.06377393f, 0.17536467f, -0.01136714f, 
    0.05192722f, -0.05058713f, 0.07287736f, -0.02702300f, 0.16277151f, 0.00735185f, -0.00184231f, 0.00502656f, 
    -0.01173252f, -0.12772849f, 0.09513774f, -0.09351814f, -0.01357797f, -0.06128903f, 0.14330214f, -0.01729217f, 
    -0.04630596f, -0.10091276f, -0.10060819f, -0.12522352f, 0.31534952f, -0.02861377f, 0.17460455f, 0.07654183f, 
    -0.02436832f, -0.01418887f, 0.03219674f, 0.05033376f, -0.10817167f, -0.02008737f, 0.02034156f, -0.04844214f, 
    -0.09308746f, 0.06771303f, 0.02524383f, -0.08524147f, -0.15122250f, -0.03387644f, -0.05777873f, 0.00166293f, 
    -0.17692478f, 0.05091271f, -0.11344962f, 0.00818871f, -0.16414142f, -0.05851377f, 0.02611009f, 0.05621961f, 
    -0.09318455f, 0.08746846f, 0.05485934f, 0.06329468f, 0.01763166f, 0.06694600f, 0.12246424f, 0.01107103f, 
    0.00774236f, 0.01182035f, 0.05054168f, -0.03552127f, -0.14548360f, -0.09527478f, -0.11986355f, -0.00585128f, 
    -0.10825133f, -0.00603075f, -0.07417355f, 0.07000545f, 0.42308694f, -0.03567355f, -0.06998251f, -0.05242583f, 
    -0.01211925f, 0.10019721f, 0.05443330f, 0.01003549f, 0.00639723f, 0.04212706f, -0.10488886f, 0.10482363f, 
    -0.11390495f, 0.06893589f, -0.17340626f, -0.01142399f, 0.00568407f, 0.08908347f, 0.10196619f, -0.07801849f, 
    0.06196134f, 0.10157838f, -0.00202430f, 0.13135883f, 0.25427011f, -0.01993282f, -0.10061646f, 0.00089689f, 
    -0.02543559f, -0.08557800f, -0.05235391f, -0.04183554f, 0.03292609f, -0.01807775f, 0.24105521f, 0.04108610f, 
    -0.12250692f, 0.12082268f, -0.25541076f, 0.14073896f, 0.04951950f, 0.01277172f, 0.12015186f, 0.00180505f, 
    0.01962029f, 0.09199306f, -0.11074314f, 0.07464310f, 0.02749741f, -0.01937509f, 0.10289728f, -0.02273135f, 
    -0.01716099f, -0.02946110f, -0.04635644f, -0.05781494f, 0.06221153f, 0.11054378f, 0.05142622f, 0.05186832f, 
    -0.07152756f, -0.00079768f, 0.02129845f, 0.02612852f, 0.11895438f, -0.02564302f, -0.12950473f, -0.00859546f, 
    0.03239859f, 0.08645339f, -0.07818484f, -0.12661014f, 0.02320970f, -0.14744294f, 0.11492042f, -0.06195864f, 
    -0.13250373f, -0.11277871f, -0.08532072f, 0.03153078f, 0.06369717f, -0.10394239f, -0.05423289f, -0.07090708f, 
    0.20623513f, -0.19603303f, -0.10234823f, 0.16943671f, -0.09654044f, -0.08392075f, -0.11086458f, 0.02503791f, 
    0.11643439f, 0.00785204f, 0.08671519f, -0.10299756f, -0.18813239f, -0.07215651f, -0.00020365f, 0.11980367f, 
    -0.10930430f, 0.08122648f, 0.02198813f, 0.07823630f, 0.05372372f, -0.03364274f, 0.13707039f, 0.06826535f, 
    -0.04121399f, -0.08072272f, -0.00912287f, -0.07176011f, -0.07918885f, -0.04169792f, -0.05052767f, -0.08533938f, 
    0.04689827f, -0.09370695f, 0.02510699f, -0.05950320f, 0.15696356f, -0.04212442f, 0.01540363f, -0.01662138f, 
    0.15402928f, -0.19530056f, -0.17436691f, -0.14046443f, -0.00918324f, 0.11705159f, 0.07811919f, 0.14695702f, 
    0.01293817f, 0.17106082f, -0.02712190f, 0.07735649f, -0.07251084f, 0.08956692f, 0.02734746f, -0.00544795f, 
    -0.06632362f, 0.05085326f, -0.07339872f, -0.01761339f, 0.21572073f, 0.12733856f, 0.03343662f, 0.09416272f, 
    -0.09848846f, 0.11883607f, 0.05215601f, 0.11922543f, -0.05430899f, -0.01027618f, -0.09142328f, 0.18852538f, 
    0.08086261f, 0.02973082f, -0.10388727f, 0.14754927f, 0.09550047f, 0.01326153f, -0.13413116f, -0.02754803f, 
    0.01620582f, 0.02917414f, -0.06410954f, -0.07145553f, 0.07567608f, 0.13443598f, -0.02537321f, 0.05644216f, 
    0.01013175f, 0.00014704f, -0.08687616f, -0.08667512f, -0.17725533f, 0.03788456f, 0.08338068f, 0.06336872f, 
    -0.26074901f, -0.01701588f, -0.06648736f, 0.15416527f, 0.04867717f, 0.07058041f, -0.06738199f, 0.02692018f, 
    0.05578689f, 0.09901994f, 0.09612617f, -0.04059771f, -0.09406561f, -0.02659749f, 0.11700398f, -0.07020339f, 
    -0.02348807f, 0.03025320f, 0.02321512f, -0.01163388f, -0.13465884f, -0.11806917f, -0.05902959f, 0.06414334f, 
    -0.00719479f, -0.05406985f, -0.03835581f, -0.03849342f, 0.04932899f, 0.16568956f, -0.04733799f, 0.03167635f, 
    -0.05554641f, -0.09480348f, -0.01533098f, -0.01078843f, -0.04870767f, -0.19768523f, -0.16122571f, 0.09147805f, 
    -0.13370569f, -0.08362684f, 0.00087168f, -0.04537107f, -0.00813540f, -0.05463056f, 0.12717655f, -0.01941403f, 
    0.39769280f, 0.20470923f, -0.05705374f, 0.10172118f, -0.05902321f, -0.01513207f, 0.02988032f, 0.04592498f, 
    -0.05801767f, -0.02625297f, 0.00848894f, -0.00474320f, -0.03202093f, 0.16604982f, 0.07312193f, 0.01993572f, 
    0.07537018f, -0.04019393f, -0.07775868f, -0.08217698f, -0.02084289f, -0.03188439f, 0.14872675f, -0.06098588f, 
    0.19867381f, 0.08467822f, 0.10446953f, -0.02137508f, -0.01952673f, 0.01493892f, 0.08596566f, -0.11356726f, 
    0.08079749f, 0.07044351f, 0.07208342f, -0.06197778f, 0.11039901f, -0.05829339f, 0.06359997f, 0.11845097f, 
    0.07197943f, -0.01450368f, -0.01423163f, -0.09638076f, 0.17240101f, 0.01476993f, 0.00992402f, -0.03091897f, 
    0.11656225f, 0.18396714f, 0.02515732f, -0.01922989f, 0.09380378f, 0.17268555f, -0.02363432f, 0.03517318f, 
    0.03373630f, 0.09606475f, 0.14511479f, -0.03929730f, 0.07238331f, 0.07710450f, 0.14781107f, -0.03192512f, 
    0.01116483f, 0.01512576f, 0.00843092f, 0.03813759f, 0.00324953f, 0.02005919f, 0.07938960f, 0.05986110f, 
    -0.16213207f, 0.18897448f, -0.12611470f, 0.14383194f, -0.08510377f, -0.02466280f, 0.02013419f, -0.05843326f, 
    0.03546134f, 0.06082949f, 0.10652650f, -0.01654680f, 0.24730362f, -0.03381496f, -0.06753161f, -0.22296615f, 
    0.12118383f, -0.07764443f, -0.04163451f, -0.07262845f, -0.08196714f, 0.12044768f, -0.05685329f, 0.06150246f, 
    -0.18554856f, 0.04177975f, 0.00099852f, -0.02293561f, 0.12692535f, 0.22275941f, -0.02275737f, -0.00208340f, 
    0.05720375f, -0.02816459f, 0.05198248f, -0.14241399f, 0.00894762f, -0.20928833f, -0.04398708f, -0.04818064f, 
    0.12252796f, 0.05681003f, -0.03221742f, -0.04202566f, -0.00900565f, 0.01259238f, -0.01616114f, -0.11804517f, 
    0.01448280f, -0.09894734f, 0.06742680f, 0.08766866f, -0.10556637f, -0.02817687f, 0.11755849f, 0.01822298f, 
    -0.02210549f, 0.05932680f, 0.18122573f, -0.05804361f, -0.07778765f, -0.07162979f, -0.15442991f, -0.02775060f, 
    -0.05077573f, -0.09053075f, -0.07332211f, -0.20646015f, 0.00218372f, 0.22841267f, 0.12997562f, -0.02148579f, 
    0.26868132f, 0.01114238f, 0.08895923f, -0.05646169f, 0.08732674f, 0.11071583f, 0.03081087f, 0.09846891f, 
    0.01941423f, -0.04088617f, 0.01911410f, -0.11650276f, 0.27585405f, -0.07355154f, -0.04160546f, 0.11984216f, 
    0.01422027f, -0.07003038f, -0.00205657f, 0.00770996f, 0.02576644f, 0.07700192f, -0.09241916f, 0.02777054f, 
    -0.16874421f, 0.05591855f, -0.07432649f, 0.12874784f, -0.10092509f, 0.06808124f, 0.13181011f, 0.07635874f, 
    -0.03969403f, -0.08812002f, 0.08407561f, -0.08077966f, 0.23133492f, 0.14896242f, -0.01313629f, 0.02972386f, 
    0.05639999f, 0.09596687f, 0.12272710f, -0.06618537f, 0.04416533f, 0.03586911f, -0.00221905f, 0.13359167f, 
    -0.03500958f, -0.00214535f, -0.03316335f, 0.01005308f, 0.01943831f, 0.01248920f, 0.01238714f, 0.00152793f, 
    0.00731459f, -0.00031593f, -0.00526044f, -0.03569326f, 0.02152496f, 0.00268333f, 0.02191460f, -0.03027762f, 
    0.01268759f, -0.02397685f, -0.00280932f, 0.02222199f, 0.01202221f, 0.02557527f, 0.02559129f, 0.01251295f, 
    -0.02057889f, -0.01184225f, -0.01578509f, -0.00907349f, -0.03506282f, 0.02278709f, -0.01933725f, -0.02813260f, 
    -0.03000520f, -0.02202259f, 0.00055466f, -0.02101114f, -0.00055219f, 0.02008312f, 0.02396349f, 0.02598995f, 
    0.00188414f, -0.03703363f, -0.00086559f, -0.02289986f, -0.02814724f, -0.02422604f, -0.03200668f, 0.02379565f, 
    -0.04169529f, -0.03723970f, -0.04288881f, 0.02621204f, -0.02426255f, -0.03342309f, 0.01769733f, -0.02643939f, 
    -0.02032303f, -0.00530818f, 0.00556075f, -0.01252022f, 0.01824629f, -0.00359440f, -0.02391682f, 0.01935584f, 
    0.02304796f, 0.00221550f, 0.01955736f, 0.01169616f, -0.00659795f, -0.04187224f, 0.00576451f, -0.02456607f, 
    -0.03145864f, -0.02898753f, 0.02442776f, 0.01942120f, 0.01691430f, 0.00003305f, -0.03018231f, -0.00337323f, 
    0.00649321f, 0.01867587f, -0.03212751f, -0.03660891f, 0.02097691f, -0.00872656f, -0.00954862f, -0.01399437f, 
    -0.02942809f, 0.00976246f, 0.00077839f, 0.01047738f, 0.02314200f, -0.04168162f, 0.02380579f, 0.02711233f, 
    -0.03012007f, -0.01374817f, 0.00526056f, -0.02883921f, 0.00037661f, 0.02453886f, -0.01137314f, -0.00398024f, 
    -0.04293536f, -0.00342604f, -0.01006803f, -0.03260723f, -0.02699528f, -0.02480861f, 0.01462075f, -0.03954977f, 
    -0.01880534f, 0.02060772f, -0.02922168f, 0.01631681f, 0.02544302f, 0.02518729f, -0.00547066f, 0.00713397f, 
    0.00713230f, 0.01720924f, -0.02094315f, -0.03286967f, -0.01185652f, -0.04421118f, -0.00870298f, 0.02839179f, 
    0.02384598f, -0.02665923f, 0.00926582f, 0.01521558f, -0.00449404f, -0.03517481f, -0.01201910f, -0.02382141f, 
    0.00396587f, 0.03346422f, -0.04000589f, -0.03635399f, -0.01956866f, 0.00056619f, -0.00267198f, -0.00195160f, 
    0.00734230f, 0.00594471f, -0.03301740f, -0.01967484f, -0.02312563f, -0.01719107f, -0.01240297f, -0.02164994f, 
    0.00681528f, 0.01450488f, 0.00408091f, -0.02271807f, 0.00890138f, 0.01184938f, -0.03747679f, 0.01781990f, 
    0.02392660f, 0.01622546f, 0.00992312f, -0.01065267f, -0.02342533f, 0.00809041f, 0.01251966f, 0.00129834f, 
    0.00708443f, -0.01119893f, 0.02471625f, -0.02110087f, -0.01678393f, 0.01845700f, 0.01673267f, -0.02730664f, 
    -0.01220074f, 0.01431972f, -0.03620195f, 0.00079461f, -0.00670959f, -0.00604921f, -0.02432464f, 0.01509144f, 
    -0.02586568f, 0.00407325f, -0.04131807f, -0.01711746f, 0.02211378f, 0.02453922f, -0.02974584f, -0.00739824f, 
    -0.02782819f, 0.00663117f, -0.00353775f, 0.02624414f, -0.00114878f, -0.03282166f, 0.01824076f, -0.01683073f, 
    -0.02053179f, 0.00392961f, 0.00509473f, -0.02322293f, 0.03201200f, 0.01598810f, -0.03635849f, -0.01122338f, 
    0.02473155f, 0.00430470f, -0.01261932f, 0.01849268f, 0.01964331f, -0.00999380f, -0.03596590f, 0.02373207f, 
    -0.00459771f, -0.01351246f, -0.01959680f, -0.04303702f, -0.03676782f, -0.00575348f, -0.03481600f, -0.00330370f, 
    -0.03113194f, 0.02591962f, 0.00403766f, 0.01229928f, 0.02080797f, 0.01399701f, -0.02983265f, 0.00763245f, 
    -0.01049687f, 0.03374394f, -0.01931730f, -0.02916828f, 0.02726547f, -0.03052256f, 0.01974591f, -0.03704898f, 
    -0.03761755f, -0.01404968f, 0.00001874f, 0.02894957f, -0.04066459f, -0.04324709f, 0.00205413f, -0.00008059f, 
    0.00738800f, 0.02224496f, -0.02312988f, 0.02683124f, -0.02323434f, -0.02967090f, -0.00000710f, -0.00362635f, 
    0.02333027f, -0.00777133f, -0.02183531f, -0.02519746f, 0.01084002f, 0.02272715f, -0.01198128f, 0.01114331f, 
    -0.00157058f, 0.02746000f, 0.02793246f, 0.00076190f, -0.03929514f, -0.01465391f, -0.01988734f, 0.02762961f, 
    0.00848584f, 0.01125064f, -0.02503604f, -0.02440372f, -0.03388171f, 0.02338746f, 0.02576336f, 0.00114151f, 
    0.00294295f, -0.03831762f, -0.04063429f, 0.01618121f, -0.04178369f, -0.03777315f, -0.03651911f, -0.00281925f, 
    0.01454342f, -0.00586637f, -0.03517226f, -0.01226620f, 0.01967964f, -0.02570930f, -0.03072567f, 0.00957850f, 
    -0.02691488f, -0.01929649f, 0.02120604f, -0.01140120f, -0.03533467f, 0.00233043f, 0.00060270f, -0.01947635f, 
    0.01277998f, 0.00969880f, -0.03475556f, -0.02769301f, 0.01209509f, 0.00398049f, -0.03347488f, 0.01164362f, 
    -0.02181618f, 0.02204907f, -0.00543548f, 0.02946896f, 0.00723133f, -0.01368578f, -0.00930023f, 0.01678117f, 
    0.01810546f, -0.01444621f, 0.01256993f, 0.00118950f, 0.02833265f, -0.03590886f, -0.00625886f, -0.04387078f, 
    -0.04502200f, -0.00816223f, -0.04189556f, -0.00677061f, -0.00961936f, 0.01201096f, 0.00186482f, -0.04337285f, 
    0.00044687f, -0.02469947f, 0.01204835f, -0.03088063f, 0.01007679f, -0.03703937f, 0.01159036f, 0.02210168f, 
    -0.02963611f, 0.02241657f, -0.00475327f, 0.00628135f, -0.01177042f, -0.02614242f, -0.02702651f, -0.02084795f, 
    0.00457259f, 0.02938550f, -0.01923485f, 0.01186636f, 0.00286639f, 0.01178991f, -0.00876289f, 0.00460965f, 
    -0.01240639f, 0.01791985f, -0.04295088f, -0.02993156f, -0.00378493f, -0.03696010f, 0.02814594f, -0.00752732f, 
    -0.03237528f, 0.02656504f, -0.03249988f, 0.02956854f, -0.03652861f, 0.01577621f, -0.03721917f, 0.01292594f, 
    -0.04107198f, 0.02042512f, -0.03651079f, -0.01113370f, -0.03873282f, 0.02422994f, 0.00073590f, -0.01800383f, 
    -0.03662968f, -0.00053199f, -0.01996326f, 0.02741021f, -0.03105234f, -0.01740206f, -0.03496753f, -0.02441737f, 
    -0.04093501f, 0.02729500f, -0.00753147f, -0.00145995f, 0.00332082f, -0.01171198f, -0.03940310f, 0.01976697f, 
    0.02296011f, 0.01915202f, 0.01179083f, -0.03637097f, 0.02880611f, 0.00990250f, -0.03293694f, -0.04160703f, 
    -0.00121946f, 0.00827616f, 0.01014778f, 0.00407302f, 0.00041726f, -0.02073598f, -0.04033146f, -0.00454991f, 
    0.02567515f, -0.03753769f, 0.02173682f, -0.02383383f, 0.01263192f, -0.01885320f, -0.04012383f, -0.01729549f, 
    0.01855564f, 0.01961235f, -0.00706583f, -0.02403963f, -0.02285404f, -0.04106044f, 0.02791630f, 0.02806093f, 
    -0.01400795f, 0.00503985f, -0.03731729f, -0.01713711f, 0.00372715f, -0.03819366f, -0.02678518f, -0.00842651f, 
    -0.00623858f, 0.00399759f, 0.02357111f, 0.00726447f, -0.03148012f, 0.02663792f, -0.01579960f, -0.02688654f, 
    0.00448851f, -0.01356703f, 0.02672526f, 0.00021519f, -0.03604938f, 0.01831283f, -0.02676431f, 0.01135532f, 
    -0.03378846f, -0.00579920f, -0.03458760f, -0.01435303f, 0.01202158f, -0.01163159f, -0.01695361f, -0.03521835f, 
    0.00134407f, 0.00067626f, -0.02138756f, -0.00016808f, -0.00223583f, 0.00906063f, -0.02790591f, 0.02144486f, 
    0.00879149f, 0.02564438f, 0.00406640f, -0.00590816f, -0.00727467f, 0.01906420f, 0.01160915f, -0.03332651f, 
    -0.02614690f, 0.02471644f, -0.02855736f, 0.00727305f, -0.01375605f, -0.03823032f, -0.03700532f, 0.02233850f, 
    0.02006285f, -0.02753355f, -0.01273940f, -0.01917880f, 0.01175941f, 0.00183857f, -0.00802515f, 0.02488535f, 
    0.01445044f, -0.01309211f, -0.04176409f, 0.00182020f, 0.01244311f, 0.02980361f, -0.02875262f, -0.01884184f, 
    -0.00791475f, 0.01593202f, 0.01507757f, -0.03866595f, -0.01560009f, -0.01282398f, -0.00825292f, 0.01775619f, 
    -0.00880172f, -0.00864240f, -0.01919512f, 0.01987788f, -0.01103990f, 0.00803231f, 0.01507865f, 0.00336600f, 
    0.01682246f, 0.02682876f, -0.03179717f, 0.02790659f, -0.03301960f, 0.02295190f, -0.01357798f, -0.01666622f, 
    -0.01865157f, -0.00337343f, -0.02549220f, -0.00449238f, -0.00139720f, 0.01202352f, 0.02261089f, -0.00293029f, 
    0.00731023f, 0.01055653f, 0.00405676f, -0.03095323f, 0.02499287f, 0.02468047f, 0.01746890f, 0.01200814f, 
    0.00273446f, 0.00879044f, -0.04312159f, 0.01859533f, -0.02563152f, -0.01620141f, -0.00849444f, 0.00686322f, 
    -0.04144045f, -0.01887376f, -0.00240884f, -0.03690742f, -0.01014553f, 0.02317837f, 0.02942388f, 0.01195181f, 
    0.00539280f, -0.00993936f, 0.02232824f, 0.02597462f, -0.02585824f, 0.02342031f, 0.00096264f, -0.03471860f, 
    -0.01757478f, 0.02743686f, 0.00200436f, 0.00379190f, -0.04077074f, 0.00809425f, 0.00568537f, -0.01727719f, 
    -0.01760203f, 0.02410178f, -0.03621665f, -0.01020000f, -0.02721699f, -0.02725920f, -0.03590896f, -0.00556453f, 
    -0.02540277f, -0.00860658f, -0.02827322f, -0.02050686f, 0.00478926f, -0.02813586f, -0.03925719f, -0.03677824f, 
    0.02390537f, 0.01434455f, 0.02054418f, -0.02936872f, -0.03220060f, -0.03011971f, 0.01633242f, -0.02903522f, 
    -0.02419279f, 0.01443588f, -0.03393961f, -0.03736630f, 0.01941520f, 0.00102827f, 0.01361804f, 0.01927978f, 
    -0.00265610f, -0.00187179f, 0.01840556f, -0.01895757f, -0.00704358f, 0.00212130f, 0.01868814f, 0.00015386f, 
    -0.01272742f, 0.00807510f, -0.02527351f, -0.03839820f, -0.00043692f, -0.00477918f, 0.00060670f, 0.03110749f, 
    -0.01711620f, -0.01668326f, 0.00869458f, -0.03992733f, 0.02119059f, -0.00441523f, 0.00633347f, 0.02502624f, 
    -0.00246405f, -0.00957494f, 0.01402256f, 0.02510554f, 0.01666882f, -0.01375134f, -0.03720102f, 0.00588524f, 
    0.02709050f, 0.00745475f, 0.03046698f, 0.02333402f, 0.02412840f, -0.01120425f, -0.00271213f, -0.02781017f, 
    0.02845876f, -0.03649811f, -0.02912358f, -0.03865556f, -0.00583038f, 0.01976844f, -0.00574707f, -0.02144419f, 
    -0.02169790f, 0.02179061f, -0.02167754f, -0.01692840f, 0.02669647f, 0.03626766f, 0.01665890f, -0.02210722f, 
    -0.02835236f, -0.01136769f, -0.02818906f, 0.02001966f, 0.01638259f, -0.02713975f, 0.00942644f, 0.01029176f, 
    -0.03057976f, -0.03863985f, -0.01586059f, 0.02114812f, -0.00250325f, -0.02930796f, 0.02003614f, 0.01293781f, 
    -0.01939231f, -0.03432215f, 0.00367818f, 0.00744074f, 0.00233237f, -0.02891262f, 0.02080446f, 0.01086303f, 
    0.02180469f, -0.01299333f, -0.01067624f, -0.03034473f, -0.01093724f, -0.01649088f, -0.01224910f, 0.00200502f, 
    -0.01625986f, -0.01447689f, 0.02419813f, 0.00529032f, 0.01120304f, -0.00663273f, -0.03877548f, -0.00317557f, 
    0.02657601f, -0.01317226f, -0.04237988f, 0.02041494f, 0.02014371f, 0.01681174f, -0.02947610f, -0.04269969f, 
    -0.02729778f, 0.01076102f, -0.03778991f, -0.00440271f, 0.00746147f, 0.02681366f, -0.02104237f, 0.02556357f, 
    0.02648026f, 0.00653063f, 0.00121172f, -0.00516339f, -0.00071364f, 0.01996857f, -0.02032747f, -0.03799815f, 
    0.02723793f, 0.00789638f, -0.00264340f, 0.02111243f, 0.01545157f, -0.01449699f, -0.00395466f, -0.02102317f, 
    0.01350025f, -0.03829404f, -0.01387441f, 0.02548146f, -0.02794905f, -0.02359400f, 0.00643410f, 0.01717540f, 
    -0.03513256f, 0.03327672f, 0.01411647f, -0.03370756f, -0.01576493f, 0.03039444f, -0.00713400f, -0.01843083f, 
    0.02756548f, 0.02756602f, 0.00291921f, -0.00415268f, -0.00091532f, -0.01142703f, -0.00563775f, 0.00814967f, 
    0.01157241f, 0.02020135f, -0.02133961f, -0.03182270f, -0.03571973f, 0.00717548f, 0.02219424f, 0.01461926f, 
    0.01744119f, -0.00662137f, 0.01485256f, 0.00677424f, 0.02642864f, -0.02120312f, -0.02577472f, 0.02172720f, 
    -0.02730129f, 0.01935261f, -0.01058430f, 0.02624999f, 0.02508465f, -0.03671607f, -0.02237951f, 0.00132471f, 
    -0.02112523f, 0.00973550f, 0.02997793f, 0.01213144f, 0.00426325f, 0.01736587f, 0.01965045f, 0.00733066f, 
    0.00369329f, -0.01916136f, -0.03911575f, -0.02532283f, 0.01292641f, -0.03739867f, -0.03529733f, -0.00078355f, 
    -0.03176624f, 0.00489730f, -0.02411205f, -0.00827320f, -0.00568978f, -0.02774516f, 0.00726805f, -0.04043639f, 
    0.01286388f, -0.03834523f, 0.02411055f, 0.00093078f, 0.01464970f, 0.02209236f, 0.00632479f, 0.01509711f, 
    0.03054103f, -0.03319307f, 0.00544539f, 0.02079095f, -0.00023400f, -0.02680563f, -0.00948604f, -0.03098868f, 
    -0.00170012f, -0.03330905f, -0.00638910f, -0.03819453f, 0.01862082f, -0.01555133f, -0.02536736f, 0.01416135f, 
    0.02968796f, -0.03398180f, 0.01749508f, -0.03946933f, 0.00209431f, -0.01341473f, 0.02173101f, 0.01989924f, 
    0.03050573f, -0.03859388f, 0.01526408f, -0.02165631f, 0.02698664f, 0.00435991f, -0.01132731f, -0.03435850f, 
    0.02468085f, -0.00708086f, -0.03781187f, 0.00609584f, 0.02355896f, -0.03538058f, -0.03302670f, 0.00455959f, 
    -0.00225072f, -0.01293763f, 0.00149747f, -0.02671991f, 0.01831441f, 0.00550237f, -0.02681709f, -0.00343441f, 
    0.02530177f, 0.01140542f, -0.02491957f, -0.01524912f, 0.01120666f, -0.03938913f, -0.01060569f, 0.02862272f, 
    -0.00172094f, 0.00992447f, 0.00284910f, -0.02339860f, -0.03517148f, 0.01348675f, 0.00520635f, -0.03099748f, 
    -0.03508048f, 0.02977777f, -0.01259593f, -0.01791715f, -0.02576562f, 0.02113590f, 0.02566865f, -0.02473041f, 
    0.01985142f, -0.03608922f, 0.03020648f, 0.02633067f, -0.01897044f, -0.04174727f, -0.01698776f, -0.01973700f, 
    0.00591258f, 0.02192188f, 0.01228940f, 0.01149039f, -0.01077503f, 0.02946056f, -0.03365002f, 0.02376982f, 
    -0.00890596f, 0.02229290f, 0.00702739f, -0.01030462f, 0.02783035f, -0.03472586f, -0.00594170f, 0.00930981f, 
    -0.00438424f, -0.02869191f, 0.01246021f, -0.01004482f, 0.02724981f, -0.02801369f, -0.03152934f, -0.03175505f, 
    -0.00102926f, -0.03621390f, 0.02319068f, -0.00468668f, 0.02466317f, -0.01704061f, 0.01935680f, 0.00124617f, 
    -0.00570589f, -0.00591340f, -0.01308547f, -0.01285434f, 0.01903540f, 0.00266042f, -0.01671711f, -0.02804095f, 
    -0.01650061f, -0.03778223f, 0.01506182f, -0.01157944f, -0.03619346f, 0.01702958f, -0.02037412f, -0.01824226f, 
    -0.00789498f, -0.00726452f, 0.00945194f, -0.02589817f, 0.01527542f, -0.01751592f, 0.00727393f, -0.02558904f, 
    0.02990694f, 0.00472261f, 0.02351214f, -0.00138243f, -0.03846423f, -0.04203253f, -0.04363711f, 0.03006220f, 
    -0.03610627f, -0.00202684f, -0.01687542f, -0.02009214f, 0.01843718f, 0.01904625f, -0.01717660f, 0.02089557f, 
    -0.00457757f, -0.03567453f, -0.03884239f, 0.01702291f, 0.00611755f, 0.02468859f, 0.01449592f, -0.02554926f, 
    0.01287921f, -0.02867209f, -0.03775700f, -0.00951682f, -0.01183956f, 0.02357048f, -0.03816414f, -0.03235147f, 
    -0.04034838f, 0.02228036f, -0.00815087f, -0.03236729f, 0.01250932f, 0.00637797f, -0.00162327f, -0.03250913f, 
    0.01923512f, 0.00799129f, -0.03826141f, -0.03941711f, -0.02392291f, 0.00550544f, 0.01450940f, -0.00746108f, 
    -0.03416656f, -0.00585957f, -0.03834120f, -0.03027391f, 0.02247344f, -0.00306763f, 0.01034699f, -0.00148220f, 
    -0.03843664f, 0.02789307f, -0.02823440f, -0.01743802f, 0.00119286f, -0.01184295f, -0.01717401f, 0.02472942f, 
    -0.01289574f, -0.03590302f, -0.00406199f, -0.00466873f, -0.03069351f, -0.03971819f, -0.02371057f, -0.03904347f, 
    -0.02151502f, -0.03503069f, 0.01942623f, -0.02491523f, -0.01319786f, 0.00674636f, 0.02856072f, -0.00201414f, 
    -0.03386873f, 0.01042416f, -0.03641267f, 0.00471336f, -0.02065058f, 0.00472846f, -0.03743226f, -0.00439155f, 
    0.01398376f, -0.01858473f, -0.03094799f, -0.03921475f, -0.03564401f, -0.02353736f, -0.01669774f, 0.02425425f, 
    0.01137545f, -0.03635658f, -0.00507312f, -0.01175002f, -0.03651850f, -0.02089467f, 0.02938417f, -0.00583306f, 
    0.00868078f, -0.02236242f, -0.01786910f, 0.00030218f, -0.00354860f, -0.01533270f, -0.00269606f, 0.02234796f, 
    -0.01154872f, 0.02783827f, 0.01533786f, -0.02611500f, 0.00706572f, -0.01464367f, 0.00920506f, -0.02001928f, 
    0.01942754f, 0.01552932f, -0.02777231f, -0.01906596f, -0.02098020f, -0.00946960f, 0.02747311f, 0.00818680f, 
    0.02532298f, -0.01250135f, -0.02536264f, -0.02560328f, 0.02726642f, -0.01169497f, 0.01869742f, 0.00174035f, 
    0.00711368f, -0.02929239f, 0.01385431f, -0.03339746f, -0.03280272f, -0.00757037f, -0.03444479f, -0.02329268f, 
    -0.02047978f, -0.00373276f, 0.00615095f, 0.02274716f, -0.03539226f, -0.01998983f, 0.02150142f, 0.00488127f, 
    -0.02881571f, -0.03342931f, -0.00234961f, -0.01086429f, -0.02392789f, -0.01369692f, -0.03263834f, -0.01703019f, 
    0.02123402f, -0.03497355f, 0.01167203f, -0.03838496f, 0.01134320f, -0.01740116f, 0.00321597f, 0.00997917f, 
    0.02624655f, -0.01421617f, -0.03491781f, 0.02726762f, 0.01268595f, 0.02914428f, -0.04153439f, -0.00255261f, 
    0.01394867f, -0.02867894f, -0.01582472f, 0.00521109f, -0.03027408f, -0.03472677f, 0.00318291f, -0.02787069f, 
    0.01333337f, 0.01509531f, -0.02665417f, 0.01657354f, -0.01615553f, -0.01740541f, 0.02760371f, -0.01467149f, 
    0.01643186f, 0.01770263f, -0.03492297f, 0.02634261f, -0.00906191f, 0.01115345f, 0.01292276f, 0.00566173f, 
    -0.00933208f, 0.03177293f, -0.02507510f, -0.03990290f, 0.01292525f, 0.00490465f, -0.01641653f, -0.00351119f, 
    -0.03708449f, 0.02904305f, 0.02769349f, -0.01731236f, 0.01478751f, -0.03264916f, -0.02458526f, 0.00307688f, 
    -0.00454276f, 0.02824029f, -0.00425912f, -0.02857256f, 0.00906408f, -0.02281959f, -0.03452598f, 0.01653372f, 
    0.01006969f, -0.00425688f, 0.01474666f, 0.00731630f, 0.02862885f, -0.00575908f, -0.00939445f, -0.00199971f, 
    -0.00990483f, -0.01211001f, -0.03881770f, -0.00807810f, -0.02577947f, -0.02449888f, -0.02163350f, 0.01970038f, 
    0.01543883f, -0.02253090f, -0.04302436f, -0.00959181f, 0.00336798f, 0.01015123f, 0.00444026f, -0.02983481f, 
    -0.00338359f, 0.00835162f, -0.02407020f, -0.03366223f, 0.00975454f, -0.02166777f, 0.00657343f, -0.02449965f, 
    0.01032462f, -0.00275859f, -0.02271112f, -0.02470879f, -0.03342704f, 0.00903450f, -0.00519229f, 0.02235757f, 
    -0.00618998f, -0.02484963f, 0.02508676f, -0.00171983f, 0.02846227f, -0.02377162f, -0.00708657f, -0.01930897f, 
    0.02403007f, -0.03732210f, 0.02016381f, -0.02988727f, -0.02675246f, 0.01016036f, -0.02852137f, 0.01502916f, 
    0.03078578f, -0.01136172f, 0.01640655f, 0.00989779f, 0.02557803f, -0.02435018f, 0.01533900f, -0.02355404f, 
    -0.01181193f, -0.03114588f, 0.00611314f, 0.01482835f, 0.02971871f, -0.01918417f, 0.00933563f, 0.02700055f, 
    -0.00325449f, -0.01708438f, 0.02785144f, 0.00399762f, 0.01768926f, 0.00476847f, 0.00630637f, 0.02853216f, 
    -0.02683003f, -0.01425217f, 0.01259814f, 0.00145721f, 0.00097997f, 0.01431533f, 0.02178809f, -0.04222222f, 
    -0.02437605f, 0.02565461f, -0.02725787f, -0.03567690f, -0.00116854f, -0.01428904f, -0.03950727f, 0.00462561f, 
    -0.01900853f, 0.00122261f, 0.02632650f, -0.00319943f, -0.00574655f, 0.02255196f, -0.03881220f, 0.02614956f, 
    -0.02464933f, -0.03016845f, -0.03008600f, -0.01329255f, -0.02940229f, -0.02071768f, -0.04097247f, -0.02211389f, 
    0.00344807f, -0.02183893f, -0.04006863f, 0.00444377f, 0.00658722f, 0.02086524f, 0.02321995f, -0.02117630f, 
    0.02199464f, 0.02411512f, 0.01547039f, -0.00955663f, -0.00535254f, 0.00615980f, -0.01651774f, 0.00455088f, 
    -0.02780232f, -0.03021357f, 0.02841330f, -0.00528747f, -0.00393923f, -0.01300701f, -0.03522716f, 0.02926492f, 
    -0.01153677f, 0.00473821f, 0.02743992f, -0.03411113f, -0.03307740f, -0.00183472f, -0.02601821f, -0.03065090f, 
    0.02041179f, 0.02928022f, -0.02948917f, 0.01601403f, -0.01524931f, -0.01168793f, -0.03545095f, 0.01287863f, 
    0.01067051f, -0.00038448f, -0.03056188f, 0.02207837f, -0.02190642f, -0.03043384f, -0.02683385f, -0.04320468f, 
    -0.00464757f, -0.03696587f, 0.02652407f, -0.01080900f, 0.00642128f, -0.01168828f, 0.02235692f, -0.03392275f, 
    0.00740086f, -0.03576674f, -0.02633148f, 0.01295404f, -0.01518954f, 0.01121707f, -0.02256165f, 0.02662650f, 
    0.02836880f, 0.01163157f, 0.00060079f, 0.02633257f, -0.00230668f, 0.02585244f, 0.01794825f, -0.00881521f, 
    -0.00833035f, 0.00498352f, -0.03185145f, -0.04153151f, 0.02868233f, -0.01589680f, -0.03400052f, -0.02721904f, 
    -0.03061913f, 0.01258218f, -0.02892358f, 0.01578390f, 0.00422201f, 0.00490089f, -0.01674709f, -0.00177393f, 
    0.01206961f, 0.01694561f, -0.02881879f, 0.00133716f, 0.03092144f, -0.01062581f, 0.02035881f, -0.02478426f, 
    0.02809023f, -0.01395474f, -0.00624355f, 0.00611849f, 0.00422843f, 0.00341825f, 0.02417432f, 0.00565957f, 
    0.00933001f, 0.02005457f, -0.03978312f, -0.04085775f, -0.02161862f, -0.03021159f, -0.00932145f, -0.01232168f, 
    0.01950535f, -0.04066551f, -0.02325598f, -0.00381653f, -0.01067192f, -0.01441990f, 0.01764171f, -0.04101743f, 
    -0.00650442f, -0.03650318f, -0.03971328f, 0.00009944f, 0.00894907f, 0.02803991f, 0.02116899f, 0.02636074f, 
    -0.03005001f, 0.02784421f, -0.01300590f, 0.01102402f, -0.00446675f, 0.00956564f, -0.02645319f, -0.02723533f, 
    -0.01520594f, 0.00478075f, 0.00187370f, -0.02078355f, -0.03526209f, -0.00728553f, -0.00882268f, -0.03689346f, 
    0.02924790f, -0.00878377f, -0.01058644f, -0.00875772f, 0.01776830f, 0.00820088f, 0.01175318f, -0.00643079f, 
    -0.01553980f, -0.00592270f, 0.01091160f, -0.01675558f, -0.00597479f, -0.01359538f, -0.00808210f, -0.03857662f, 
    -0.02466569f, 0.02622325f, 0.02855947f, 0.01195290f, 0.01851350f, -0.03538276f, 0.02947773f, 0.02920462f, 
    -0.01092715f, -0.03422227f, 0.01152810f, -0.00453978f, -0.03243738f, 0.02771958f, -0.03461195f, 0.02578488f, 
    -0.00628191f, -0.00492218f, -0.03845284f, 0.01308357f, -0.01013296f, 0.00573371f, -0.03842423f, 0.02071259f, 
    -0.01628664f, -0.01514925f, -0.02955169f, 0.00845406f, 0.01280971f, 0.02650549f, -0.03520155f, 0.02485130f, 
    0.01702654f, -0.01934232f, 0.00941483f, 0.01091779f, -0.00723336f, 0.02216056f, -0.03410868f, 0.00518190f, 
    0.01326231f, -0.03639082f, -0.01560195f, 0.00406344f, -0.02063445f, 0.00085609f, -0.01470859f, -0.00662873f, 
    0.02034601f, -0.01765386f, -0.01051050f, -0.02602766f, -0.00326288f, 0.01016966f, -0.03445708f, -0.02640306f, 
    0.03054285f, 0.00673870f, -0.01094427f, 0.00728263f, 0.00329646f, 0.03192293f, -0.03361587f, 0.02547279f, 
    -0.00550178f, -0.03482010f, -0.00639392f, 0.01551412f, -0.01666851f, 0.01413434f, 0.01192129f, -0.03884123f, 
    0.00380842f, 0.03226874f, 0.02723837f, 0.00089947f, 0.00101395f, 0.01479340f, 0.00116547f, -0.01547375f, 
    -0.04289419f, -0.01899390f, -0.04003277f, -0.02974799f, 0.02779565f, -0.02856477f, -0.01097413f, -0.03521324f, 
    0.25714919f, -0.23610310f, -0.14420143f, 0.02872666f, 0.03398612f, 0.00058752f, -0.02383918f, -0.00526706f, 
    0.03611209f, 0.00837845f, 0.03953034f, 0.05563400f, 0.32994229f, 0.12227854f, -0.03482682f, 0.13155878f, 
    0.12998533f, 0.14420590f, -0.00731958f, -0.07832579f, 0.01030524f, 0.10248545f, 0.04978066f, -0.06863273f, 
    0.19023216f, -0.11210144f, -0.10981870f, -0.00972383f, -0.12739500f, 0.01238064f, 0.11562927f, -0.01210940f, 
    0.13061868f, -0.09823740f, -0.00601285f, -0.01655554f, 0.16355340f, 0.09695357f, 0.00448502f, 0.03050201f, 
    -0.08853441f, 0.06654099f, -0.03799771f, -0.06193896f, 0.15551992f, 0.01776464f, 0.05693977f, 0.07167172f, 
    -0.20725696f, 0.17303275f, 0.15370867f, 0.08611530f, 0.00114537f, -0.03907162f, 0.00967334f, -0.04072303f, 
    -0.07168549f, 0.03600979f, -0.00405700f, 0.12323157f, -0.08948136f, 0.13559501f, -0.02355545f, 0.15364750f, 
    -0.00639386f, 0.00960628f, 0.09232781f, -0.00076160f, 0.12713711f, 0.13969031f, 0.13079587f, 0.02921584f, 
    -0.20603542f, -0.21770371f, -0.00072450f, -0.21847488f, -0.03689466f, 0.06308027f, 0.00388735f, -0.01528461f, 
    0.13592674f, -0.01011886f, 0.04295631f, -0.02385714f, -0.09364995f, -0.16943198f, -0.05714788f, -0.13332346f, 
    0.02911857f, -0.05740714f, -0.00801108f, -0.05816019f, 0.04465182f, 0.02591240f, 0.02518763f, 0.05140142f, 
    0.01644922f, -0.01933547f, 0.14998955f, 0.21968085f, 0.05115976f, 0.01696944f, 0.00363794f, 0.06481779f, 
    0.03453707f, 0.03359815f, 0.06056516f, -0.06094651f, -0.18962263f, -0.20356043f, -0.05039064f, 0.15090264f, 
    0.02608049f, -0.06860137f, -0.03789454f, 0.12760709f, -0.01407152f, 0.03789613f, -0.05955309f, 0.06158887f, 
    0.03462163f, 0.03202998f, -0.13092886f, -0.08453033f, -0.03203284f, 0.03246035f, -0.01246086f, -0.04095183f, 
    0.20240214f, -0.07420406f, 0.03136197f, -0.00820750f, -0.31386459f, -0.18760933f, -0.03719566f, -0.24486656f, 
    0.06645034f, -0.00466849f, -0.04452054f, 0.09095635f, 0.06015714f, 0.04078477f, 0.08374727f, 0.00414619f, 
    0.38714558f, 0.08486201f, 0.10896355f, 0.26080096f, 0.07443450f, 0.05403650f, 0.10568741f, 0.03658735f, 
    -0.01545321f, -0.02847758f, 0.01674829f, -0.02802871f, -0.18239692f, -0.26164711f, -0.01396957f, 0.04740212f, 
    -0.02403780f, -0.03186822f, 0.00985617f, -0.02809634f, -0.02034282f, 0.01866660f, 0.05313021f, 0.09392428f, 
    0.29345858f, -0.02886496f, -0.18598166f, -0.06279827f, -0.10498135f, 0.07642660f, 0.02010910f, -0.00920749f, 
    -0.06335715f, -0.03294785f, -0.00937186f, -0.08045933f, 0.13419974f, 0.19754416f, 0.09415680f, 0.06668164f, 
    -0.05830285f, -0.06034008f, 0.05975067f, -0.04566998f, 0.00963401f, 0.00405931f, 0.05453921f, -0.16700837f, 
    0.11769347f, -0.03318100f, -0.06393182f, 0.03428216f, 0.05300765f, -0.01118218f, 0.13959217f, 0.06567529f, 
    0.03841135f, 0.04259218f, 0.12346593f, -0.02543338f, -0.03511639f, 0.04935077f, -0.02644518f, -0.04269840f, 
    0.09620800f, -0.01640161f, -0.01738041f, -0.00106384f, -0.02307932f, -0.10874261f, 0.09821088f, 0.00588679f, 
    0.27188790f, -0.04439132f, -0.03025237f, 0.04911044f, 0.05089178f, 0.09540743f, 0.09143773f, 0.10007674f, 
    0.01332864f, 0.05261064f, 0.01734827f, 0.06528002f, -0.08641414f, -0.02078232f, -0.07529163f, 0.06754806f, 
    -0.09943426f, 0.00846161f, 0.00664726f, 0.03306955f, -0.09837350f, -0.03822260f, 0.08592371f, 0.00030849f, 
    0.10552324f, 0.15221265f, -0.10588455f, -0.01086957f, -0.05128525f, 0.00987824f, -0.08762550f, 0.05319093f, 
    -0.05309828f, 0.00324408f, 0.05865778f, -0.03172694f, -0.08667944f, 0.04916598f, -0.01621593f, 0.02801158f, 
    0.02822562f, 0.05327455f, -0.01878037f, 0.10628191f, -0.03135337f, 0.06634957f, -0.01371591f, -0.00249206f, 
    0.19424877f, 0.01147283f, 0.03586577f, 0.34072959f, 0.01440602f, -0.01309890f, -0.02510574f, 0.13547800f, 
    -0.01164098f, 0.06035798f, -0.00070409f, 0.02093531f, 0.20128351f, 0.17017692f, 0.12786099f, 0.03740774f, 
    0.08322283f, -0.05426067f, 0.00504233f, 0.04955067f, -0.08427752f, 0.18036014f, -0.01796842f, 0.01489695f, 
    0.14976284f, 0.08696721f, 0.22783139f, 0.00812942f, 0.00603551f, -0.06994654f, -0.05632547f, -0.11714475f, 
    0.01578862f, 0.03719716f, 0.05394862f, 0.04271291f, -0.19996025f, -0.17427720f, 0.03644849f, -0.29384845f, 
    0.06072709f, 0.09949769f, -0.10065140f, 0.10454127f, -0.04872857f, -0.03475029f, 0.06837699f, -0.05796187f, 
    0.25801283f, 0.16145043f, -0.11680578f, -0.09777565f, -0.15970154f, -0.02411953f, 0.03490227f, -0.02591729f, 
    0.02498891f, -0.07334365f, 0.06230372f, -0.08448342f, 0.05355588f, 0.14413109f, -0.00107960f, -0.16166317f, 
    -0.03026042f, 0.06499652f, 0.00121036f, -0.03138667f, 0.01562183f, 0.08358743f, -0.00702848f, 0.01294329f, 
    0.21350177f, 0.18186767f, -0.04634987f, -0.07611604f, -0.00663388f, -0.07524609f, -0.01317404f, -0.12390739f, 
    -0.05446242f, 0.10096259f, -0.03474819f, -0.07563477f, 0.00893648f, -0.08136772f, -0.05203713f, 0.22447194f, 
    -0.01181429f, -0.06423977f, 0.01865244f, 0.03305418f, 0.00311316f, -0.03129524f, 0.05005009f, -0.07931410f, 
    -0.08552252f, 0.24269934f, 0.28582460f, 0.15300477f, -0.00554044f, 0.08128958f, 0.04771119f, -0.10894372f, 
    0.00504051f, 0.05595203f, 0.04034721f, 0.02984229f, 0.03815342f, -0.15456469f, -0.06847509f, 0.06047028f, 
    -0.01584705f, 0.02178852f, 0.03296780f, -0.00690994f, 0.08320659f, 0.04410595f, 0.08719848f, 0.09272522f, 
    -0.02915502f, 0.11761088f, -0.04194501f, 0.09673776f, -0.05899936f, 0.06721524f, -0.06210557f, -0.10455222f, 
    0.11577095f, 0.11721176f, 0.00101169f, 0.07753964f, 0.29238841f, 0.16401275f, 0.03988703f, -0.05373428f, 
    0.00993800f, -0.01551085f, 0.16589153f, 0.00785175f, 0.02711644f, 0.07787141f, 0.00195714f, -0.01126210f, 
    -0.15472573f, -0.01901045f, -0.09148487f, -0.01491164f, 0.03107646f, 0.04106489f, 0.05176853f, 0.00648868f, 
    0.06251358f, 0.02140804f, 0.01628830f, 0.09218396f, 0.27541906f, 0.04331414f, -0.02058105f, 0.03049181f, 
    0.02729357f, 0.09587673f, 0.03045771f, 0.00395455f, 0.10603689f, 0.10344682f, 0.05167064f, -0.05622700f, 
    -0.27559900f, -0.26771873f, 0.06049180f, -0.10472607f, 0.06470961f, 0.09351117f, -0.00391525f, 0.05459419f, 
    -0.06017703f, -0.10230891f, 0.02609901f, 0.00569208f, -0.15942799f, 0.06384756f, -0.00276721f, -0.18564223f, 
    -0.05623353f, -0.05393449f, 0.03415895f, -0.02403443f, 0.03557568f, -0.01196433f, 0.00855409f, 0.11107903f, 
    -0.02949358f, 0.17416191f, 0.02628644f, -0.21126758f, 0.05767271f, 0.02668435f, 0.07378694f, -0.13368584f, 
    -0.00201326f, -0.05918260f, -0.00638692f, -0.04986027f, 0.01107729f, -0.06795843f, 0.09595746f, 0.00046275f, 
    0.02025481f, -0.01381555f, -0.00901969f, -0.09003681f, 0.13054074f, 0.09102054f, 0.00630806f, -0.01954898f, 
    -0.25660595f, -0.05499765f, -0.04689864f, 0.15232812f, 0.05539637f, 0.10069843f, -0.01047633f, -0.01714391f, 
    0.04487605f, 0.13575931f, -0.02048169f, 0.12767763f, -0.10175856f, 0.10543325f, -0.05673446f, -0.06714456f, 
    -0.06460443f, -0.04384973f, 0.06625298f, 0.03717702f, -0.08898040f, -0.04700659f, -0.03733429f, 0.02135304f, 
    0.17677549f, 0.02048833f, -0.21004328f, -0.00915874f, 0.14049253f, 0.04980617f, -0.04166313f, 0.02025452f, 
    -0.04584934f, 0.05291475f, 0.00312623f, 0.12796085f, 0.12657937f, -0.04032395f, 0.01940380f, -0.05423621f, 
    0.07395501f, -0.06996335f, 0.01727082f, 0.01685884f, 0.03938323f, 0.07623283f, 0.11915721f, -0.01080004f, 
    -0.22858827f, 0.05344853f, -0.24295370f, -0.21718454f, 0.02245566f, 0.23657648f, -0.02609320f, 0.04093079f, 
    -0.00032956f, -0.04213414f, 0.04182668f, 0.06782652f, -0.09020846f, 0.14401044f, 0.10633899f, -0.01709433f, 
    -0.17434470f, 0.10927077f, -0.04275898f, 0.02258947f, 0.01504603f, -0.00782516f, 0.04250079f, -0.08815523f, 
    -0.02036548f, -0.23739982f, 0.23932840f, 0.25946283f, -0.03173656f, -0.01955591f, 0.03645135f, 0.06352172f, 
    -0.04785407f, -0.01421646f, 0.03237002f, 0.01030284f, -0.20698798f, 0.06174556f, 0.02354948f, -0.12211566f, 
    0.07276002f, 0.03860072f, 0.06171473f, 0.12703130f, 0.01188234f, 0.11066228f, 0.01682265f, 0.01672735f, 
    0.20293689f, -0.04286423f, -0.10169423f, 0.22477993f, 0.06034703f, 0.03856661f, 0.01008490f, 0.15927409f, 
    0.01358513f, 0.00929483f, -0.02921578f, 0.05834186f, -0.22081752f, 0.01671393f, -0.05431162f, -0.07551677f, 
    0.02205156f, 0.04330434f, 0.03498830f, 0.00911631f, 0.00995039f, 0.00762071f, 0.13097501f, -0.00143138f, 
    -0.27919391f, -0.19082096f, -0.02771177f, -0.18279496f, 0.04495630f, 0.03187270f, -0.02311131f, -0.06939289f, 
    0.01918344f, -0.10220705f, 0.00648163f, 0.03499533f, -0.06845638f, -0.34707323f, -0.02048701f, -0.01698962f, 
    -0.03159893f, -0.06484003f, -0.03191793f, -0.06076717f, -0.04343119f, -0.04713154f, 0.16539043f, 0.07584326f, 
    0.03821826f, 0.01024356f, 0.03753259f, -0.02231453f, -0.02877988f, 0.04435729f, -0.07115130f, 0.04721618f, 
    0.02860311f, 0.04093020f, 0.12956458f, -0.03678131f, -0.29421580f, -0.07160669f, -0.07450186f, -0.04978980f, 
    -0.04508878f, 0.00549768f, 0.14055468f, -0.01846545f, -0.01098844f, -0.04710165f, -0.01498267f, 0.05192871f, 
    0.04625968f, 0.11549638f, 0.00818755f, 0.18144198f, 0.05165799f, -0.00998382f, 0.10095607f, -0.05854519f, 
    0.06999069f, 0.01030477f, 0.03822131f, 0.05131399f, -0.23449519f, -0.15166466f, 0.13540106f, 0.09601647f, 
    0.10100226f, -0.02937096f, 0.06281076f, 0.02778272f, 0.07956052f, 0.01035800f, -0.01405808f, -0.05626694f, 
    0.24508476f, 0.16946089f, -0.03818240f, 0.11828960f, 0.10330294f, 0.03466676f, 0.03436721f, 0.04948581f, 
    -0.05759013f, 0.01298438f, -0.01030782f, 0.02198825f, 0.10011055f, 0.24378482f, 0.08026417f, 0.11759602f, 
    0.04998758f, 0.10641906f, 0.03832483f, 0.15673172f, 0.06110003f, -0.11921547f, -0.02179240f, 0.00415480f, 
    -0.07966849f, -0.27071682f, -0.12709193f, -0.33478969f, 0.02496058f, 0.05752903f, -0.08744347f, -0.06768721f, 
    -0.09498193f, -0.01446446f, 0.01594974f, -0.06718792f, 0.08502305f, 0.11951675f, 0.14633505f, 0.28704232f, 
    0.07327407f, -0.03573370f, -0.03277213f, 0.04218934f, 0.08555183f, -0.01515804f, -0.00443003f, -0.02521220f, 
    0.24981920f, 0.12242970f, 0.19043630f, 0.17042494f, 0.11567274f, 0.02519633f, 0.04473497f, 0.10360430f, 
    0.04840955f, 0.01391977f, 0.09805673f, 0.07801908f, 0.04323666f, -0.29881370f, -0.08258790f, 0.02910790f, 
    0.16555651f, 0.04278660f, 0.06905688f, -0.03743607f, 0.03631840f, -0.04821440f, -0.07172725f, 0.12199316f, 
    -0.25618830f, 0.01150990f, 0.02204934f, 0.01504887f, 0.11101963f, 0.04537043f, 0.08647662f, -0.05577251f, 
    0.04440875f, 0.00600062f, -0.00120704f, 0.02091793f, -0.28774154f, -0.07077927f, -0.02416117f, -0.11527006f, 
    0.03226333f, -0.00593063f, -0.06482062f, 0.08731427f, 0.08501654f, 0.09088651f, -0.01118862f, 0.12449636f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03783081f, -0.01066050f, 0.01999685f, 0.00955242f, 0.00924208f, 0.04061805f, 0.00942449f, 0.03500682f, 
    0.00363236f, 0.00310668f, 0.01702547f, 0.02062614f, 0.00192055f, 0.02514778f, 0.00101031f, 0.01271489f, 
    -0.03213475f, -0.03329866f, -0.02323464f, -0.03062124f, 0.01685781f, -0.03621558f, -0.00172684f, -0.00352318f, 
    0.02605885f, 0.07832894f, -0.00713976f, -0.03883804f, -0.00749533f, 0.00802133f, 0.01703330f, 0.09926717f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.30246216f, -0.15721241f, -0.04049299f, 0.00257936f, 0.03776365f, 0.04427917f, -0.14495197f, 0.04521164f, 
    -0.01550097f, 0.01518429f, 0.11083572f, -0.14697513f, -0.06671501f, 0.03718358f, 0.04236433f, 0.21529873f, 
    -0.14932375f, -0.17426413f, 0.09239019f, 0.16407423f, 0.21169874f, -0.15691340f, 0.11300395f, -0.09051082f, 
    0.05429059f, 0.27927902f, 0.05825081f, -0.32957441f, 0.30536145f, 0.05259041f, -0.02128679f, 0.30388317f, 
    -0.15801585f, 0.12757571f, -0.16190584f, -0.00223922f, -0.14902093f, 0.05357638f, 0.14019024f, -0.10223963f, 
    -0.03027443f, -0.04025455f, -0.02184574f, -0.07630910f, -0.13355246f, 0.15437090f, -0.10917554f, -0.06592429f, 
    -0.10077383f, 0.15529466f, -0.07778264f, -0.18310741f, 0.11971962f, 0.04063523f, -0.06155401f, 0.08262133f, 
    -0.16377130f, -0.03148874f, -0.09128416f, -0.04191131f, 0.07434766f, -0.01675168f, -0.17082928f, -0.07265020f, 
    0.34196991f, -0.10913520f, 0.05782838f, 0.00237459f, -0.17431796f, -0.49749982f, -0.02933257f, 0.13762154f, 
    -0.12515181f, -0.05924944f, -0.17099126f, 0.11575186f, 0.06964310f, -0.04972803f, 0.02558343f, 0.29168603f, 
    0.01294021f, -0.17510672f, 0.13983715f, 0.08146986f, 0.09347876f, 0.01863917f, 0.02863763f, 0.13332595f, 
    0.13366018f, 0.34155080f, 0.15497242f, 0.10468230f, 0.16425219f, 0.07117391f, -0.16123022f, -0.39838633f, 
    -0.38708290f, 0.00475193f, -0.09727109f, 0.15446477f, -0.00937105f, 0.15313162f, -0.17941201f, -0.12718526f, 
    0.07840148f, -0.06390438f, -0.09373548f, -0.15233222f, 0.09591475f, -0.04521105f, -0.08553417f, 0.01059111f, 
    0.04605986f, 0.04794059f, -0.13472934f, 0.13100304f, -0.05786510f, 0.00171922f, 0.01131114f, 0.15863271f, 
    0.09653150f, 0.01292999f, -0.07391427f, 0.21650408f, 0.14055046f, 0.08046017f, 0.12789136f, 0.35966721f, 
    -0.09983665f, 0.15378171f, -0.06354780f, 0.00694243f, 0.10264356f, -0.07067294f, 0.03179562f, -0.15860748f, 
    -0.13379319f, -0.06723756f, -0.15569168f, 0.07862065f, -0.02375834f, 0.02549604f, 0.14269404f, -0.06936674f, 
    -0.16616271f, 0.17481579f, -0.04408915f, -0.01133115f, -0.11862440f, -0.07422732f, 0.14192349f, -0.13242652f, 
    -0.16711734f, -0.14937872f, 0.03372884f, -0.01828966f, -0.14385268f, -0.04446493f, -0.05538732f, 0.11210698f, 
    0.00730950f, 0.00590012f, -0.10444109f, 0.17751312f, -0.21882842f, -0.14374453f, 0.16318399f, -0.05660161f, 
    0.07642367f, 0.07593460f, 0.24612346f, -0.06847902f, -0.09928914f, -0.03296388f, -0.14351493f, 0.40673950f, 
    0.12982284f, 0.11892606f, 0.00223680f, -0.10939993f, 0.25840682f, 0.12494732f, 0.05171189f, -0.05333490f, 
    -0.05355849f, 0.18286747f, 0.16440049f, -0.11548716f, 0.31215525f, 0.08076122f, 0.02262636f, 0.16090877f, 
    -0.43803000f, -0.01714109f, 0.16470794f, 0.16913317f, 0.02105937f, 0.04329008f, -0.06482952f, -0.41718456f, 
    0.02139853f, 0.12919343f, 0.15864195f, 0.02972637f, -0.11573299f, -0.05424644f, 0.03275233f, 0.03751229f, 
    -0.13621879f, 0.17631179f, 0.10222691f, -0.11110713f, 0.25889251f, -0.07825980f, 0.16174632f, 0.16874950f, 
    0.05487102f, 0.03117571f, 0.03820559f, 0.17965157f, 0.60597271f, 0.14586857f, 0.09434677f, -0.10128334f, 
    0.14360210f, -0.16084395f, -0.16650590f, 0.16974865f, 0.01404924f, -0.14360574f, 0.01552744f, 0.03670550f, 
    0.07140849f, -0.17715743f, -0.07586859f, -0.00881394f, 0.15490018f, 0.15792172f, -0.07994417f, -0.16663274f, 
    0.00858466f, -0.03381532f, 0.13918948f, 0.09370544f, 0.05962411f, -0.09684372f, -0.07895286f, 0.15230486f, 
    0.02173381f, -0.13096945f, 0.09817556f, -0.14622492f, -0.00986880f, 0.05823089f, 0.10273400f, -0.15825510f, 
    -0.57243574f, -0.04531543f, 0.14251883f, -0.14328405f, 0.07129253f, 0.13478132f, -0.10757878f, -0.30520645f, 
    0.07134981f, -0.12823595f, -0.36743271f, 0.06663520f, -0.07759888f, 0.01525661f, 0.07862616f, 0.13747565f, 
    -0.15379789f, 0.08798439f, 0.08914190f, 0.10283283f, 0.31558278f, -0.00830960f, -0.15197593f, -0.05150121f, 
    -0.02522771f, 0.09804001f, -0.04836526f, 0.18266988f, -0.07513181f, 0.12671797f, 0.00446510f, 0.21081428f, 
    0.35087389f, 0.07477506f, -0.07655020f, 0.08210256f, -0.00158341f, -0.02513302f, 0.17416626f, 0.16355570f, 
    0.14403202f, -0.04370240f, 0.47020239f, 0.03178209f, 0.04677277f, 0.15191595f, -0.00406361f, 0.19903822f, 
    0.07460951f, 0.15285070f, 0.13175610f, 0.10702942f, 0.03794973f, 0.16449371f, 0.11715849f, 0.05950062f, 
    -0.04969611f, 0.14641298f, 0.10525432f, -0.16609004f, 0.02598817f, 0.04647474f, -0.07431339f, 0.28939945f, 
    0.14719312f, 0.09210581f, -0.05603751f, 0.12282451f, -0.08765400f, -0.08531382f, 0.12227008f, -0.14323494f, 
    -0.14819041f, 0.03335335f, -0.02492541f, -0.13501669f, 0.15984589f, 0.06333017f, -0.17521097f, 0.08434023f, 
    0.12080792f, 0.00216148f, -0.07186120f, 0.10082610f, -0.11421174f, -0.14342277f, 0.15487255f, -0.04861132f, 
    0.14733523f, 0.01292903f, -0.06609658f, -0.07857890f, -0.01011200f, -0.09227964f, -0.11397304f, -0.08844371f, 
    0.23405229f, -0.03549041f, 0.06485496f, 0.00960740f, -0.27676672f, 0.06758987f, 0.05792156f, 0.17939505f, 
    0.11273943f, 0.00538278f, -0.17321117f, -0.15093847f, 0.09805954f, 0.05724226f, 0.06837080f, 0.20059481f, 
    0.11313522f, -0.04643277f, 0.03229770f, -0.06938239f, 0.17671505f, -0.16244045f, 0.02778747f, 0.13764003f, 
    -0.06377212f, 0.24646710f, -0.10103569f, -0.13348854f, -0.20940439f, 0.01707369f, -0.03892238f, 0.27338076f, 
    -0.00380766f, -0.02582936f, 0.12890200f, -0.09599377f, 0.07619345f, -0.06334164f, 0.09332395f, 0.03718881f, 
    0.03314212f, 0.09816324f, -0.08043480f, 0.02460053f, -0.02945274f, -0.06143699f, 0.09352493f, 0.10031426f, 
    0.05293202f, 0.05885001f, -0.02785981f, -0.06968422f, -0.06010777f, -0.04754287f, -0.10850149f, 0.14935136f, 
    0.00905663f, -0.16244100f, 0.02140789f, -0.00492479f, 0.04367859f, -0.15346947f, -0.07846928f, 0.00487152f, 
    -0.34706500f, 0.03781065f, 0.01611796f, 0.10237639f, 0.19256607f, 0.18407100f, 0.00948372f, -0.14264426f, 
    0.13889052f, -0.15819824f, 0.15395278f, 0.11035722f, -0.05722490f, -0.15671524f, -0.06479617f, 0.57175797f, 
    -0.12334667f, 0.05455248f, 0.05938290f, -0.15669404f, -0.41253787f, -0.10987847f, -0.05239034f, 0.06979762f, 
    -0.05219733f, -0.01013226f, -0.13362624f, 0.16633074f, 0.01513011f, 0.07868190f, 0.02431246f, -0.23308451f, 
    -0.14741367f, 0.08336982f, -0.05664314f, -0.11109495f, -0.17841603f, -0.12542327f, -0.04935404f, -0.06004299f, 
    -0.08626542f, 0.03626800f, -0.03518005f, -0.02244286f, 0.03793666f, -0.02215889f, 0.09076898f, 0.02555212f, 
    0.16744690f, -0.11685751f, -0.09674973f, 0.02287352f, -0.04442836f, 0.17464657f, 0.10076504f, 0.07970868f, 
    -0.00008100f, -0.11741874f, 0.10817130f, 0.07309711f, 0.13698357f, 0.00601379f, 0.08789811f, -0.01755711f, 
    0.10862385f, -0.08646195f, 0.14327127f, -0.01671820f, 0.12026317f, 0.04262133f, -0.15027888f, 0.41341600f, 
    0.05856547f, -0.13706109f, -0.14529374f, -0.08154026f, -0.00034178f, -0.04885962f, 0.15994829f, -0.36523053f, 
    -0.17135672f, 0.00437223f, 0.01448700f, 0.10256155f, -0.10379546f, 0.15974416f, 0.11740031f, -0.00076883f, 
    0.03059111f, -0.10896272f, -0.11570314f, 0.21579976f, -0.20097794f, -0.18063995f, 0.08486318f, 0.51408869f, 
    -0.22275250f, -0.05189219f, 0.12711021f, -0.04073919f, 0.36812976f, 0.25302857f, 0.03950761f, 0.38210598f, 
    -0.03085821f, 0.15419310f, 0.35837510f, -0.15251258f, -0.08055629f, 0.11420127f, -0.11593501f, 0.13117287f, 
    0.05660982f, -0.07208905f, -0.11385481f, -0.15841572f, -0.32470101f, 0.09960475f, 0.10648347f, -0.15732701f, 
    -0.17235644f, 0.10389063f, -0.12751985f, -0.03955429f, -0.21599080f, 0.03271993f, 0.12446510f, -0.06317206f, 
    -0.03717750f, -0.09297764f, 0.04187197f, -0.14396444f, -0.09279399f, 0.12366115f, -0.10644080f, 0.72194701f, 
    0.09934134f, 0.03338750f, 0.18042058f, 0.04846053f, 0.15273966f, -0.06032891f, 0.15835677f, 0.21790557f, 
    0.11136818f, -0.16088983f, -0.08933415f, -0.14482613f, 0.12172128f, -0.12350184f, -0.06566597f, -0.03695678f, 
    -0.14288765f, -0.34377649f, 0.03547933f, 0.16826165f, 0.33085832f, 0.00240672f, -0.12197940f, 0.00844824f, 
    -0.09242164f, 0.10549940f, 0.08863783f, 0.11704109f, 0.13673401f, -0.36449730f, 0.11124843f, 0.04278189f, 
    -0.09718749f, 0.01514233f, -0.31820393f, -0.00818096f, -0.08980057f, -0.15283674f, -0.15153633f, -0.24297355f, 
    -0.09529240f, 0.16377532f, -0.00214421f, 0.04152920f, 0.19005229f, 0.12547462f, -0.16460818f, -0.12284253f, 
    -0.05784649f, 0.26049680f, -0.01093573f, 0.28346035f, 0.07154209f, 0.09537119f, -0.00402819f, 0.10590383f, 
    0.14781716f, 0.14548454f, 0.15330082f, -0.05392892f, 0.41218871f, -0.06972111f, -0.14658384f, 0.12754631f, 
    0.10757574f, -0.05940017f, 0.25640765f, 0.10560603f, 0.14122312f, 0.09672483f, 0.11018673f, 0.17033575f, 
    0.16131201f, 0.08236899f, -0.13816272f, 0.04486533f, -0.27143824f, -0.08704840f, -0.09776463f, 0.03497038f, 
    -0.00461406f, 0.22607021f, -0.14594790f, 0.09984761f, -0.11505599f, -0.00174354f, -0.09529109f, -0.40785357f, 
    0.50671667f, -0.15519825f, 0.06370351f, -0.09623895f, 0.33031234f, 0.27331978f, 0.08591535f, -0.05630799f, 
    0.01740582f, -0.05807544f, 0.08197445f, 0.13255621f, 0.06942121f, 0.04548815f, -0.01158282f, 0.18781963f, 
    -0.03409680f, 0.07602235f, 0.14147617f, -0.14308284f, -0.21136005f, 0.03544472f, 0.13226697f, 0.12393957f, 
    0.09354617f, 0.04433744f, -0.17345358f, -0.01117659f, -0.58961022f, 0.11463355f, -0.05270044f, -0.20062385f, 
    0.07748458f, -0.03224093f, 0.16114095f, -0.13772097f, 0.05324067f, 0.02504922f, -0.02817890f, 0.47442529f, 
    -0.01922925f, -0.16625968f, -0.10082231f, -0.05570422f, -0.14322768f, 0.09663741f, 0.03627245f, -0.40575844f, 
    -0.13537994f, 0.17018166f, 0.04699961f, -0.05929330f, 0.11938836f, 0.00272711f, 0.06470675f, 0.08201692f, 
    -0.11906198f, -0.20813200f, 0.08439887f, 0.32458460f, 0.29716986f, -0.03958482f, -0.12036826f, 0.05071923f, 
    -0.08136956f, -0.03867892f, -0.08676475f, -0.00667602f, -0.10016461f, -0.04009388f, -0.11889095f, -0.16015846f, 
    -0.10919119f, -0.02074520f, -0.15607464f, 0.01588492f, -0.11639910f, 0.09890013f, 0.14943150f, -0.53197992f, 
    -0.13279569f, -0.04790347f, -0.04106126f, 0.11676742f, 0.13585426f, 0.13144085f, -0.16584946f, 0.16867599f, 
    0.12456729f, 0.29133135f, 0.07634558f, 0.09912900f, -0.23298348f, -0.13047589f, -0.14672002f, 0.48399395f, 
    0.20387331f, 0.08128195f, -0.06097959f, 0.15709469f, -0.00501129f, 0.26877466f, -0.13137269f, -0.39630306f, 
    -0.09844402f, -0.10152570f, -0.26682758f, -0.07847610f, 0.05996864f, 0.08688216f, 0.11082897f, 0.05988813f, 
    0.15604810f, 0.07438841f, -0.09258313f, -0.04415792f, -0.21590070f, -0.09460801f, 0.15422839f, -0.00887590f, 
    0.11584558f, -0.06324572f, -0.07178266f, 0.32404667f, -0.19887945f, 0.02850493f, 0.07055024f, -0.04944941f, 
    -0.40467194f, 0.12131488f, 0.05916830f, -0.04571082f, 0.32841596f, -0.00782816f, 0.01736851f, -0.18455741f, 
    0.15339552f, 0.15327176f, 0.01665672f, -0.07527758f, -0.03007729f, 0.07902276f, 0.01533966f, -0.17183350f, 
    -0.02822323f, -0.04486864f, -0.01450971f, 0.11702874f, 0.24223401f, 0.14049134f, -0.05739450f, 0.17594206f, 
    0.01280232f, -0.15182199f, 0.10401046f, 0.23401837f, 0.47419000f, -0.04785768f, 0.07016310f, -0.19868290f, 
    0.10741637f, -0.08602706f, -0.00470982f, 0.13815628f, -0.26837519f, -0.04259858f, -0.13792489f, 0.38673455f, 
    -0.02386982f, 0.01329354f, 0.05228003f, -0.04893420f, 0.07646469f, -0.09534792f, -0.05870017f, 0.23444954f, 
    -0.09058118f, -0.14905408f, -0.10672828f, -0.12614810f, 0.10643559f, 0.12793176f, 0.12091289f, 0.17084529f, 
    0.06049803f, 0.07133271f, -0.01651024f, 0.25315014f, -0.33768299f, 0.04434716f, 0.01409526f, -0.39037263f, 
    -0.10677786f, 0.07095115f, 0.02573947f, 0.07807636f, -0.14759800f, -0.12796280f, -0.07820603f, -0.13925393f, 
    -0.10510378f, 0.15304665f, -0.16745274f, 0.08791218f, 0.03408121f, -0.06115429f, 0.05651743f, -0.10826779f, 
    -0.14127766f, 0.08977120f, -0.06783944f, -0.08937028f, -0.00783837f, 0.12998554f, -0.15061712f, -0.05088735f, 
    -0.09508912f, -0.04714659f, 0.12401404f, -0.00812677f, -0.06914339f, 0.15623268f, 0.01803136f, 0.05614831f, 
    0.46244806f, 0.17189121f, 0.01226015f, -0.02214260f, 0.25433674f, -0.19204278f, 0.09455445f, 0.02091645f, 
    -0.00748552f, 0.14529625f, 0.22012836f, 0.12938230f, 0.01792564f, 0.15166447f, -0.13952479f, -0.25660855f, 
    -0.07684799f, 0.05382525f, -0.05277378f, -0.02120448f, 0.36030233f, 0.05833739f, -0.03754282f, -0.17201233f, 
    0.00205764f, 0.32889935f, -0.15781380f, -0.17010227f, -0.04438024f, 0.12329423f, 0.14562283f, -0.07423049f, 
    -0.15396814f, 0.00891842f, 0.02448843f, -0.03430960f, -0.14651790f, -0.16884154f, -0.11560283f, -0.08291254f, 
    -0.09228928f, 0.01583449f, 0.03963042f, -0.16965708f, -0.14469655f, -0.07276805f, -0.10228890f, -0.14325605f, 
    0.10317637f, -0.09942882f, -0.03177206f, 0.01007071f, 0.10172591f, 0.09284043f, 0.16447198f, 0.14860314f, 
    -0.13061932f, 0.01796720f, 0.01130669f, -0.08405603f, -0.04760535f, 0.00586191f, 0.15159240f, 0.09791426f, 
    -0.28689134f, 0.15355133f, 0.10194550f, -0.07924774f, -0.26417348f, 0.35622495f, 0.06201615f, 0.15152097f, 
    -0.09993313f, 0.01072281f, -0.07936526f, 0.00344094f, -0.17427644f, -0.14724155f, -0.07940838f, 0.39720172f, 
    -0.12014684f, -0.03815747f, 0.06312964f, 0.08844256f, 0.15042815f, 0.02604239f, -0.09584087f, 0.06748585f, 
    -0.12580089f, 0.14036521f, 0.04246341f, -0.07858542f, 0.02664548f, -0.02679189f, 0.05559856f, 0.11856470f, 
    -0.17996924f, 0.09956644f, 0.09148458f, 0.04167129f, -0.20789118f, 0.30559811f, 0.03103765f, -0.13969186f, 
    -0.05099923f, 0.10208318f, -0.10472736f, -0.04014849f, -0.12981412f, 0.15315092f, 0.06035139f, 0.01816436f, 
    0.15885521f, 0.09372020f, -0.00667176f, -0.10475098f, 0.28538710f, -0.03524046f, 0.10575916f, 0.12522218f, 
    -0.08508991f, 0.21131864f, -0.09870122f, -0.05822724f, -0.09183368f, 0.16204375f, 0.15727803f, 0.34092942f, 
    -0.03577423f, 0.00901368f, -0.00333078f, -0.08617397f, 0.19372277f, 0.32480624f, 0.09309088f, -0.56789815f, 
    -0.09462245f, 0.11871757f, 0.12332059f, 0.14432010f, -0.14286280f, -0.14808480f, 0.14796226f, 0.17467979f, 
    0.16158591f, -0.11324717f, -0.02018160f, 0.14095636f, -0.00087024f, 0.09371983f, -0.10989789f, -0.08495730f, 
    -0.08482493f, 0.00907876f, 0.09653737f, 0.07802971f, 0.03019170f, 0.03683054f, 0.09173410f, 0.09361166f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.09445497f, 0.08425424f, -0.01794283f, 0.20546299f, 0.05660255f, 0.02489411f, -0.00860611f, 0.13615814f, 
    0.03455744f, -0.13858584f, 0.03976155f, -0.08213548f, 0.09444685f, -0.01705392f, -0.10952180f, -0.01913708f, 
    0.03286967f, 0.12574841f, 0.05176870f, 0.16983093f, 0.21712407f, -0.01247989f, 0.15104151f, 0.17617194f, 
    0.11879005f, 0.08032912f, 0.05984084f, 0.19867283f, -0.11881037f, -0.05785195f, -0.02304895f, -0.18790819f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.49753562f, 0.07103670f, -0.42923507f, 0.06716814f, -0.17598267f, -0.33359140f, -0.08254863f, -0.10500239f, 
    -0.69158429f, 0.11335724f, -0.06478478f, -0.55681676f, 0.01064208f, 0.03097406f, 0.08822111f, 0.21662894f, 
    0.20111269f, 0.09324917f, -0.18736169f, 0.21710807f, 0.18476577f, 0.10444504f, -0.63269329f, 0.29521307f, 
    0.10918269f, -0.22880860f, 0.07059827f, 0.14387819f, -0.08479114f, -0.67723346f, -0.47255382f, 0.18637024f, 
    -0.18112011f, 0.00851144f, 0.16983324f, -0.38507318f, 0.00322272f, -0.07119427f, -0.76851064f, 0.02106838f, 
    -0.52449334f, 0.14542951f, 0.00387165f, -0.12698410f, -0.00152762f, 0.02773974f, 0.14401725f, -0.08382078f, 
    0.24648201f, 0.13493055f, -0.14000914f, 0.23782806f, 0.14399993f, -0.06703416f, 0.16959524f, -0.28710440f, 
    -0.33068401f, 0.34887606f, 0.04306011f, 0.25811231f, 0.00349307f, -0.33949515f, -0.34198642f, -0.23523773f, 
    -0.03708468f, 0.08955172f, 0.30245760f, -0.24072263f, -0.09811831f, 0.17464800f, 0.07390751f, 0.09370662f, 
    -0.11326565f, 0.07192763f, 0.16739011f, 0.05587458f, 0.05485121f, -0.14990419f, 0.00303541f, -0.35305932f, 
    -0.20837764f, -0.40053120f, 0.29888999f, 0.13731614f, 0.15500583f, -0.31512183f, -0.03675284f, -0.02803314f, 
    0.04582661f, -0.13286170f, 0.09366357f, 0.28257677f, 0.14818661f, -0.41479936f, -0.12071998f, 0.13589156f, 
    -0.08341635f, 0.06742906f, -0.43985453f, 0.23253773f, -0.09901817f, -0.08731438f, -0.06193177f, 0.09461763f, 
    -0.09373739f, 0.04555745f, 0.05899863f, -0.31359571f, 0.06057680f, -0.36608610f, -0.11731472f, 0.29324293f, 
    0.08393624f, 0.26299331f, 0.32701498f, -0.17866592f, -0.54548991f, 0.35945022f, 0.11208078f, -0.35725659f, 
    0.20434451f, -0.24821386f, -0.05208730f, -0.18270800f, 0.11740395f, -0.24395858f, -0.13670859f, -0.23187117f, 
    -0.28388864f, -0.10718253f, 0.08857659f, 0.08957867f, 0.05369627f, -0.32324606f, -0.01670645f, -0.12267553f, 
    0.23473065f, -0.30668646f, -0.09093490f, -0.11298949f, -0.01165479f, 0.10511036f, 0.12941860f, 0.06306062f, 
    0.13961153f, 0.32318896f, -0.04124258f, 0.08185861f, -0.06420235f, 0.29895443f, -0.60430121f, 0.13344337f, 
    0.11786045f, 0.19781774f, -0.06402524f, -0.24872054f, 0.01918386f, 0.09636400f, -0.11121877f, -0.14646024f, 
    -0.09343215f, -0.07060284f, -0.03808022f, 0.04624022f, -0.05659999f, 0.13488971f, -0.45361766f, -0.03272387f, 
    -0.44528109f, 0.23258181f, 0.12878989f, 0.24476896f, 0.16994232f, 0.19796637f, -0.04352007f, -0.01160159f, 
    0.24055561f, 0.17787033f, -0.41945139f, -0.09272823f, 0.16186953f, -0.28240871f, -0.48278183f, 0.18042660f, 
    -0.60733980f, 0.26885802f, 0.00251652f, -0.38976681f, 0.02958168f, 0.28816283f, 0.02417004f, 0.04261741f, 
    0.29530787f, -0.03893805f, -0.79339552f, -0.04402680f, 0.05999306f, 0.12912704f, 0.42885917f, -0.16865243f, 
    -0.14115159f, 0.22987980f, 0.06970653f, -0.32354188f, 0.12325475f, 0.11544420f, -0.00906498f, -0.39159846f, 
    0.19506857f, 0.16574660f, -0.42665794f, 0.07175965f, -0.17106244f, -0.28202537f, -0.41275486f, -0.51312423f, 
    0.24343863f, -0.27194005f, -0.06446456f, -0.02433223f, -0.08162389f, -0.02972648f, -0.01393870f, 0.08542182f, 
    -0.59634095f, -0.04687468f, 0.18880947f, 0.18329358f, -0.06607629f, -0.25780630f, 0.37186140f, -0.02502966f, 
    0.19983765f, -0.39364535f, 0.04979442f, -0.09150758f, -0.10371267f, -0.13709766f, -0.04236479f, 0.06554072f, 
    -0.39193940f, 0.06617820f, 0.11733118f, -0.42415133f, -0.14329383f, 0.24932775f, 0.10221593f, 0.47916088f, 
    0.18021245f, 0.26320469f, 0.09117029f, -0.33569664f, -0.03131320f, 0.00939896f, 0.08750843f, 0.08280236f, 
    0.04949168f, -0.06801359f, 0.54176480f, 0.00349052f, -0.15880139f, 0.27013931f, 0.13716285f, -0.01038516f, 
    -0.48808178f, 0.00239140f, 0.05977071f, 0.22099718f, -0.06962389f, -0.12975156f, -0.09259686f, -0.10796095f, 
    -0.13676621f, 0.27931178f, 0.25953084f, 0.03357983f, -0.43623093f, -0.04836674f, -0.29766619f, -0.43024337f, 
    -0.32568121f, 0.34435517f, -0.13890478f, 0.01072408f, -0.14830069f, -0.03180295f, -0.20297088f, -0.60362792f, 
    -0.07404314f, -0.14153233f, 0.05895970f, 0.23953164f, 0.06771487f, -0.07456814f, 0.37101018f, 0.11212169f, 
    0.42795634f, -0.32126012f, 0.02029826f, -0.37201777f, -0.03634475f, 0.25099578f, 0.13922864f, -0.32230869f, 
    0.12399436f, -0.31590405f, 0.13984525f, 0.09739088f, -0.07149351f, -0.58141315f, -0.10572039f, 0.33160591f, 
    0.12062082f, -0.06528632f, 0.05265836f, -0.28066736f, -0.01750980f, 0.00584005f, -0.02014218f, 0.12044782f, 
    0.11169633f, -0.02350646f, -0.03245680f, 0.09283867f, -0.00381646f, -0.23483083f, -0.67964709f, 0.00902404f, 
    0.17065826f, -0.11363968f, -0.02245487f, 0.33396059f, 0.11666759f, -0.43048584f, 0.00159600f, 0.24812146f, 
    0.05766902f, -0.36748204f, 0.22777079f, -0.16089837f, 0.13172303f, -0.13587750f, 0.30118856f, -0.05276131f, 
    -0.46669185f, -0.27690089f, 0.00720865f, 0.24558254f, -0.00509433f, -0.15525410f, 0.28273809f, -0.26530018f, 
    0.13931108f, 0.02398444f, -0.22509784f, 0.10293745f, 0.08660869f, 0.29704276f, 0.06457669f, 0.07273960f, 
    0.20283477f, 0.22972642f, -0.12431988f, 0.20371166f, -0.03905612f, -0.40557688f, -0.11420565f, -0.08715189f, 
    -0.06689715f, 0.07219310f, -0.23394556f, -0.37805274f, -0.20883211f, -0.21627900f, -0.10860664f, -0.30918482f, 
    -0.16328803f, -0.04522973f, -0.09896126f, 0.13482085f, -0.17508969f, 0.28445631f, 0.23797576f, 0.05495540f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.11390539f, -0.07840236f, 0.06576486f, 0.13299957f, 0.10263897f, 0.16655923f, -0.13758776f, -0.18339349f, 
    -0.21792613f, 0.09261397f, 0.22234502f, 0.03311366f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
