#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.34555352f, 0.54828936f, 0.11754625f, 0.55559397f, 1.15108538f, 0.88725364f, 0.87906855f, -0.03017659f, 
    0.61850584f, 1.16488230f, 0.61629820f, 0.22081231f, -0.75476301f, 0.00061966f, -0.49591354f, 0.50521582f, 
    -0.27844521f, -0.20010717f, -0.56974375f, 0.07833483f, -0.90174758f, -1.13036013f, 0.20391005f, -0.07666521f, 
    0.58081257f, -0.05680680f, 0.43631262f, 1.30221713f, 0.93384302f, 1.06277955f, -0.15623003f, -0.53832394f, 
    0.18901232f, 0.44259197f, 0.27537346f, 0.44403625f, -0.01897616f, 0.46696791f, 0.49092701f, -1.18042254f, 
    -0.78357953f, -1.29179513f, -0.16011861f, 0.17730731f, 0.09080186f, 1.01764500f, 0.64799666f, 0.70086706f, 
    -0.51321155f, 0.83168733f, -0.68347800f, -0.51157022f, 0.03730658f, -0.09117411f, -1.47628534f, 0.88025838f, 
    -0.66168892f, 0.73512155f, -0.26718637f, -0.76600212f, 0.17803584f, 0.40291786f, 0.49619374f, 0.78397501f, 
    1.05560172f, 1.43243241f, 0.59925830f, 0.20946240f, 0.44193727f, -0.26422930f, -0.14488766f, -0.24239264f, 
    -0.80398768f, 0.86174577f, 1.55680728f, -1.08787525f, 0.10050354f, 0.24495314f, 0.08580841f, 0.06656986f, 
    -0.19927938f, -1.67794728f, -1.41279519f, -0.85167581f, 0.35067752f, -0.09551566f, -0.44353506f, 0.23343723f, 
    0.27769661f, 0.19029909f, -1.01744199f, -0.73416072f, -0.89125079f, -0.29370537f, -1.10305774f, -0.15465996f, 
    -0.39819336f, -0.19622575f, -0.10394052f, -1.33384693f, -1.01705348f, -0.97888207f, 0.45914140f, 1.08448482f, 
    0.82351255f, -0.33447361f, -0.23192632f, -0.92655033f, 1.15945053f, -1.33262932f, -0.63352627f, -0.70113194f, 
    -1.04687250f, -0.49242082f, -0.03054594f, 0.07959633f, 0.49952036f, 0.48958093f, 0.39699689f, 0.68754566f, 
    -0.02688051f, -1.37139118f, -0.42820641f, 0.25731325f, 0.87751383f, 0.41656697f, -0.19618954f, -0.67164987f, 
    -0.82352990f, -0.84972864f, 0.40495741f, 1.20505440f, -0.27834371f, -0.42961976f, 0.24332429f, 0.97036874f, 
    -1.20043957f, 0.29736111f, 1.39600837f, 0.33546817f, 0.48190954f, -0.40517271f, -0.28709677f, -0.10158069f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.46162045f, 0.42916948f, 0.52426106f, 0.10339180f, 0.71339095f, 0.47043815f, -0.01538990f, 0.61227429f, 
    -0.10383460f, 0.32839715f, -0.15895563f, -0.06445363f, 0.22274789f, -0.12842129f, -0.06926633f, -0.24060301f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03872406f, -0.05650111f, 0.05576740f, -0.00075583f, -0.08007589f, -0.07707317f, -0.00544105f, -0.07871690f, 
    0.02386834f, -0.06586847f, 0.00905621f, -0.01804919f, -0.09073121f, 0.04779423f, -0.05996176f, 0.02068899f, 
    -0.03798738f, 0.05851693f, -0.06608422f, 0.05104208f, -0.00523824f, -0.01907204f, -0.06487150f, -0.03830149f, 
    -0.01124110f, -0.07353554f, 0.00691558f, -0.03113107f, 0.03121716f, 0.04810302f, -0.04828320f, -0.09430355f, 
    -0.02638260f, -0.05576591f, 0.01615093f, -0.06125890f, -0.00446049f, -0.05892912f, -0.07201853f, -0.02992632f, 
    0.02459552f, 0.04140883f, -0.05665793f, -0.05975232f, -0.09031283f, -0.02081302f, -0.00463694f, -0.06214352f, 
    -0.00753937f, -0.05118771f, -0.05316179f, 0.04604564f, -0.06861471f, -0.02326470f, -0.07268044f, -0.07456243f, 
    0.04022217f, -0.09527296f, 0.00473506f, -0.03413787f, -0.06029118f, -0.08913320f, -0.05488206f, 0.00893971f, 
    0.03454061f, -0.04561406f, -0.06038585f, 0.03668271f, 0.02575390f, -0.03522750f, 0.07005473f, -0.02957898f, 
    -0.04552173f, 0.05801433f, -0.01668467f, -0.03257138f, 0.01242276f, -0.00116434f, 0.04289801f, -0.04916861f, 
    0.02097506f, -0.05160169f, -0.08930359f, 0.01339119f, 0.06705095f, -0.07790615f, -0.00448710f, -0.08325835f, 
    0.03670447f, -0.06357822f, -0.09373048f, -0.03765192f, 0.02977347f, -0.00125270f, 0.02545912f, 0.03077411f, 
    0.05491381f, -0.03491165f, -0.05136110f, 0.05788227f, -0.05345723f, -0.04902435f, -0.06502685f, 0.03921336f, 
    0.01210049f, -0.03681559f, -0.09463008f, 0.06046054f, -0.04246228f, -0.06136438f, -0.06595472f, 0.04093243f, 
    -0.02420633f, 0.04661777f, 0.00290876f, -0.04640603f, 0.00921533f, -0.01948795f, -0.02599612f, 0.06868893f, 
    -0.08195142f, 0.00751710f, 0.01831136f, -0.03585014f, -0.02741276f, 0.01510362f, -0.03009151f, -0.03347599f, 
    -0.06579398f, -0.06616401f, 0.06393950f, 0.00395822f, 0.02797853f, 0.05656996f, -0.04350128f, -0.05677819f, 
    -0.02471097f, -0.07455865f, 0.06322126f, 0.05178927f, -0.06796682f, -0.08790198f, 0.03816562f, -0.07253639f, 
    -0.07505319f, 0.02002208f, 0.05294174f, -0.07927836f, -0.08869033f, -0.01464718f, -0.09034631f, 0.00758300f, 
    -0.00375473f, -0.08944057f, 0.05393745f, 0.05843171f, 0.01716658f, -0.08698867f, 0.01642122f, -0.06358457f, 
    0.04468166f, -0.03607453f, 0.02649925f, 0.02849746f, -0.04378862f, -0.06316738f, 0.05921928f, 0.02969100f, 
    -0.00411966f, -0.00931188f, -0.08975166f, -0.03530835f, -0.00445757f, -0.08367132f, 0.05208153f, 0.03528493f, 
    -0.00668024f, 0.00303437f, 0.04898423f, -0.08948259f, 0.00218985f, -0.00657995f, 0.01602776f, -0.01946128f, 
    0.04097270f, -0.02128554f, -0.03606212f, -0.08154470f, -0.00536909f, 0.00100767f, 0.00334068f, 0.06119207f, 
    0.02529799f, 0.01468744f, -0.09222373f, 0.01242244f, -0.07619271f, -0.06126942f, -0.00454884f, 0.06967135f, 
    0.01486418f, -0.04183997f, 0.03829563f, -0.08228323f, 0.05366578f, -0.03107321f, -0.04883369f, -0.07971266f, 
    -0.06432667f, 0.05976262f, -0.05962604f, -0.00514448f, -0.03011875f, 0.05648631f, 0.03695400f, -0.05818447f, 
    0.02829376f, 0.00845526f, 0.05442896f, 0.06902714f, 0.05589321f, 0.01646007f, -0.04283293f, 0.02783739f, 
    -0.04311985f, -0.03329533f, -0.08239286f, 0.02735895f, 0.05285912f, -0.05182229f, -0.08112711f, -0.00108292f, 
    -0.06846201f, -0.04205583f, -0.00687215f, 0.03569106f, 0.04896033f, -0.06415759f, -0.02184329f, -0.00946269f, 
    0.02707827f, -0.08167651f, 0.02476361f, -0.06668885f, 0.07255626f, -0.03372061f, -0.09322334f, 0.01634167f, 
    -0.06294702f, 0.04579397f, -0.03987469f, -0.01615513f, -0.04113184f, 0.06425641f, -0.07792553f, 0.04485989f, 
    0.02225877f, 0.00838526f, -0.03707754f, -0.07293291f, -0.05387935f, 0.04252296f, -0.04334385f, 0.06250799f, 
    0.02340172f, 0.00013351f, -0.02186855f, 0.01431567f, 0.02917575f, 0.03892568f, -0.03125570f, -0.03471057f, 
    -0.02987971f, 0.03843455f, -0.07188587f, -0.08749547f, 0.06922846f, 0.03001137f, -0.06191095f, -0.06599258f, 
    -0.00280247f, -0.03841665f, -0.06592392f, -0.04933508f, -0.08235718f, 0.04552002f, -0.05587967f, 0.05994844f, 
    0.68766481f, -0.10173761f, 0.34462032f, -0.01912422f, 0.15223134f, 0.05881394f, -0.02535435f, -0.11398100f, 
    0.03917656f, 0.46236232f, 0.12656803f, -0.00332392f, -0.07402918f, -0.35020092f, 0.02643437f, -0.03374678f, 
    0.06448688f, 0.33223540f, -0.30527800f, 0.33431324f, -0.15338239f, 0.00063339f, 0.03806135f, -0.05791019f, 
    -0.03764575f, -0.30284163f, -0.18545759f, 0.65689534f, 0.11084893f, -0.05936348f, -0.34741595f, -0.10301005f, 
    -0.06598405f, -0.04160395f, 0.10534165f, -0.16696532f, -0.19189511f, 0.07639356f, -0.26392487f, 0.24001907f, 
    0.06146550f, -0.19895041f, -0.19785570f, -0.06053179f, 0.02259174f, -0.09519319f, 0.14666642f, -0.08522106f, 
    -0.12906994f, -0.02429521f, -0.19454090f, -0.01581425f, 0.20006259f, 0.02272646f, 0.57644457f, -0.28236362f, 
    0.01120443f, 0.14788581f, -0.47718203f, -0.06077240f, 0.00298109f, 0.03908189f, -0.07731265f, -0.30174279f, 
    0.22790164f, 0.19454016f, -0.28100327f, -0.05025432f, -0.46775672f, 0.18464792f, 0.17812935f, -0.09437384f, 
    -0.41422585f, -0.03119302f, 0.03895406f, -0.27113533f, -0.07995278f, 0.04657532f, -0.03398620f, 0.09344174f, 
    0.10274237f, -0.07688128f, 0.01700049f, -0.17579538f, 0.08115867f, 0.21313454f, -0.09873500f, -0.09099017f, 
    -0.18439014f, -0.20426503f, -0.38910642f, 0.00303790f, -0.26222438f, -0.07330492f, -0.04459680f, 0.11393595f, 
    0.25227091f, 0.16849421f, 0.33080301f, -0.02184349f, 0.47313890f, -0.26543024f, 0.32123399f, -0.00244208f, 
    0.23140551f, 0.01210758f, -0.05445944f, 0.06967475f, 0.43021372f, -0.18092461f, 0.26800233f, 0.01511878f, 
    0.02430942f, -0.02344006f, 0.00616048f, 0.24573007f, -0.01777891f, -0.16721137f, 0.18961437f, 0.05498288f, 
    0.10231324f, 0.12187269f, -0.06261234f, 0.03531490f, -0.04043172f, 0.06308240f, -0.17293252f, 0.31409854f, 
    -0.75615549f, -0.11397701f, -0.08015026f, 0.00727401f, 0.03270062f, 0.36670041f, 0.23107181f, 0.31434298f, 
    -0.09813629f, -0.47737935f, -0.12941004f, 0.08133664f, 0.08062364f, -0.15620215f, 0.02301755f, 0.11479164f, 
    -0.05363571f, -0.02236081f, 0.01236537f, -0.02055627f, -0.05657864f, 0.04818049f, -0.08362416f, -0.08004185f, 
    0.07105167f, 0.01272732f, 0.03762666f, -0.04128247f, 0.00113932f, -0.03551691f, 0.07003198f, -0.03116090f, 
    -0.06631053f, -0.06646910f, 0.04273422f, -0.05085619f, -0.03627307f, -0.03639647f, 0.01422312f, -0.04763494f, 
    -0.08143073f, -0.03212967f, 0.00808442f, -0.02925918f, -0.05821042f, -0.01596642f, 0.04495008f, -0.08542625f, 
    -0.00287489f, -0.00885383f, -0.08704709f, -0.04772639f, 0.04782188f, -0.05290520f, -0.06173733f, -0.06026773f, 
    -0.08226725f, 0.05064394f, 0.00898549f, 0.07507652f, -0.02191957f, -0.03698025f, -0.06391748f, -0.02782237f, 
    -0.00661267f, -0.08363172f, -0.07144443f, 0.03572507f, -0.03194064f, -0.03613547f, 0.05165991f, -0.07105386f, 
    -0.04270644f, -0.00156840f, 0.03087479f, -0.00902678f, 0.05079456f, 0.02002758f, 0.05812945f, -0.02963446f, 
    0.03108292f, -0.04307091f, 0.07428434f, 0.07256684f, -0.05620523f, 0.04517625f, -0.05573660f, 0.03500781f, 
    -0.04834805f, -0.07243266f, 0.03260591f, -0.07165274f, 0.03273232f, -0.06413175f, -0.05210462f, -0.04340438f, 
    -0.01750124f, 0.03146402f, -0.04802389f, -0.06395784f, -0.06395456f, 0.05306279f, -0.03393834f, -0.02668106f, 
    -0.08083311f, -0.02284375f, 0.00600659f, 0.04515950f, -0.05108628f, -0.05749726f, -0.03224052f, 0.03409609f, 
    -0.05321474f, -0.05249569f, -0.01021239f, 0.04060474f, -0.06688908f, -0.07028051f, -0.08524831f, -0.03967957f, 
    -0.01640874f, 0.01929864f, 0.02202409f, 0.01848438f, -0.06374662f, -0.04432274f, 0.05460986f, 0.04723925f, 
    -0.01296398f, 0.02062731f, 0.04553344f, 0.04474531f, -0.03082624f, -0.08937904f, -0.03478143f, 0.04303370f, 
    -0.04235654f, 0.02460507f, 0.00826529f, 0.07488472f, 0.06667914f, 0.05423968f, -0.03815010f, -0.03564416f, 
    -0.08325707f, 0.02544765f, -0.04284245f, 0.04877431f, 0.04958034f, 0.02214351f, 0.00728592f, 0.05803021f, 
    -0.08813445f, -0.03494181f, 0.00297543f, -0.06535536f, 0.06538609f, -0.02706986f, 0.05846101f, -0.05853091f, 
    0.45454183f, 0.04918817f, 0.08255126f, -0.18667758f, -0.07462464f, -0.03587765f, -0.09485864f, 0.04533591f, 
    0.16174987f, -0.38480052f, -0.34325764f, -0.38624990f, -0.01545325f, 0.10996933f, 0.04635512f, 0.10770152f, 
    -0.09418970f, 0.04789233f, -0.21664351f, -0.26060149f, -0.37617564f, 0.26483327f, 0.07229201f, 0.12052043f, 
    0.01832898f, -0.03093588f, 0.13994706f, 0.07409075f, 0.30467376f, 0.31687194f, 0.06168076f, 0.04727768f, 
    -0.01370466f, -0.14095436f, -0.05499861f, 0.09605102f, 0.07505051f, -0.24571955f, -0.19838537f, 0.09948734f, 
    0.24888748f, -0.00947484f, 0.23278160f, 0.22452608f, 0.08797100f, -0.25387970f, -0.34472436f, -0.31765494f, 
    0.18455227f, 0.08826003f, 0.20173354f, -0.09852708f, 0.14462040f, -0.12859970f, -0.78548694f, -0.25098860f, 
    -0.55054945f, 0.15313970f, 0.15019983f, 0.07755085f, 0.16447729f, -0.02984347f, 0.22486174f, -0.06156439f, 
    0.20103669f, 0.17571981f, 0.15266445f, -0.05671860f, 0.01578221f, 0.07687379f, 0.00026958f, -0.01274443f, 
    0.29887941f, -0.53665084f, 0.11539702f, 0.16717409f, 0.05237756f, -0.10275847f, 0.25740534f, 0.14145209f, 
    -0.02690310f, -0.18837459f, -0.11059938f, 0.70331067f, -0.04414708f, -0.15592480f, -0.04737294f, -0.03970124f, 
    -0.01352261f, 0.13354078f, 0.14820345f, -0.00812996f, 0.02319080f, 0.06102448f, -0.21171084f, 0.15651703f, 
    0.06007549f, 0.14222597f, -0.03270813f, -0.45947579f, -0.24475248f, 0.04599161f, -0.08246300f, -0.09857766f, 
    -0.10176465f, 0.23446609f, -0.07172573f, -0.37667918f, -0.63390565f, 0.45296186f, -0.04545923f, 0.04509457f, 
    0.05498128f, 0.05729775f, -0.07978618f, -0.00658179f, -0.11137781f, 0.46745807f, -0.08776112f, -0.00425524f, 
    -0.01240127f, 0.04211479f, 0.05248174f, 0.12109558f, 0.25990671f, 0.28091806f, -0.50793725f, -0.22995938f, 
    -0.10400149f, -0.37601388f, -0.09503235f, -0.02202559f, -0.19531175f, 0.06730016f, -0.06820358f, -0.01544962f, 
    0.20338966f, 0.11348553f, 0.14426428f, -0.11951159f, -0.18437879f, 0.16095589f, -0.10216751f, 0.17260036f, 
    0.57687426f, 0.39366403f, 0.27049312f, 0.03770088f, 0.03410683f, 0.08081879f, 0.10655677f, 0.02666080f, 
    0.10341332f, 0.23327255f, 0.27337700f, 0.14812416f, 0.00260185f, -0.04915458f, 0.15171841f, 0.02062481f, 
    0.10911174f, 0.02363537f, 0.56614178f, -0.40035853f, -0.40440872f, 0.11098763f, 0.02229089f, 0.36145237f, 
    -0.17583466f, -0.15133676f, -0.00108131f, -0.24614838f, 0.14494993f, 0.04237583f, -0.00173197f, -0.13519613f, 
    0.14996344f, -0.12526114f, -0.11558167f, 0.19538587f, -0.36526340f, 0.17159721f, -0.46734360f, 0.00146025f, 
    0.00309123f, -0.02967409f, -0.02720734f, -0.16815646f, -0.02327002f, 0.11241601f, 0.25246140f, -0.16559313f, 
    0.17097597f, 0.14554468f, 0.07151568f, -0.39022386f, -0.02688472f, -0.15711550f, -0.17110756f, -0.09843875f, 
    -0.20803922f, 0.01750411f, -0.11749030f, 0.12392995f, -0.00688606f, 0.06169237f, -0.05875283f, -0.25804585f, 
    -0.36850694f, 0.16795781f, -0.06992825f, 0.00221607f, 0.00510130f, 0.00265043f, 0.07318720f, 0.21067570f, 
    -0.23284277f, -0.07131346f, -1.08510470f, -0.06680454f, 0.24770823f, 0.12657151f, -0.14881109f, -0.03501954f, 
    -0.02329897f, 0.53110290f, 0.03423417f, 0.47292241f, -0.05158227f, -0.17684206f, 0.03147018f, 0.03173015f, 
    0.00000050f, 0.03779286f, -0.67280370f, 0.00347179f, -0.09133836f, 0.18187398f, 0.09899839f, 0.01145995f, 
    -0.10527312f, 0.09436299f, 0.21642235f, 0.84099197f, 0.08516512f, 0.03827391f, 0.15976064f, 0.05530909f, 
    -0.08940918f, 0.23046055f, 0.01568906f, -0.02756857f, -0.44774321f, -0.10805317f, -0.32087594f, 0.01209439f, 
    0.23126364f, 0.14753549f, -0.11735048f, -0.02275904f, -0.22081728f, -0.43828952f, -0.03290098f, -0.15591842f, 
    -0.03208005f, 0.22944604f, -0.29802018f, 0.01225637f, 0.29231665f, -0.09966580f, 0.73432422f, 0.07128013f, 
    -0.28759971f, 0.27981418f, -0.31719497f, 0.22286467f, 0.02593855f, -0.06796157f, 0.43013149f, -0.68019235f, 
    -0.01982640f, 0.35058987f, -0.13568537f, 0.10668628f, -0.04896731f, 0.10648360f, -0.13313459f, 0.15502904f, 
    0.13094053f, 0.39946306f, 0.12342186f, 0.01158064f, -0.10549553f, -0.05974754f, -0.02013008f, 0.05145545f, 
    0.18737549f, -0.58512533f, -0.42375103f, -0.03134495f, 0.11621732f, -0.16423073f, -0.04343337f, -0.27198732f, 
    -0.16008890f, -0.22194721f, -0.21474546f, 0.20690981f, -0.17533958f, -0.01577454f, -0.20411344f, -0.00011410f, 
    -0.05723747f, -0.12771466f, 0.04416218f, -0.10804406f, -0.37975717f, 0.13179937f, 0.06999476f, -0.14666417f, 
    0.16777730f, -0.17511463f, 0.04625657f, -0.02411972f, -0.11220073f, -0.38280696f, -0.22899000f, -0.03582657f, 
    -0.05812657f, 0.12113849f, -0.04912353f, -0.16707714f, -0.09022896f, -0.21839960f, -0.63599396f, 0.17411025f, 
    0.09229244f, -0.11076817f, 0.16549416f, -0.26381505f, 0.10044907f, -0.11026219f, -0.08470039f, 0.21267122f, 
    0.02617055f, 0.04796100f, -0.06372403f, -0.09634820f, -0.02505567f, -0.04019377f, 0.18624777f, 0.53764415f, 
    -0.35533968f, -0.06550496f, 0.01486603f, 0.05363197f, -0.06258579f, 0.09098914f, 0.16939619f, 0.12553266f, 
    0.04211055f, 0.01166644f, -0.05292716f, -0.07717334f, 0.05574626f, -0.29051402f, -0.33506614f, -0.21958092f, 
    0.07471279f, -0.28222582f, 0.49932045f, 0.27986133f, -0.00807902f, 0.21985266f, 0.09095784f, -0.27458006f, 
    0.20504907f, -0.03151122f, -0.14377016f, 0.69705135f, 0.11723609f, 0.40441257f, 0.04228592f, 0.05687441f, 
    -0.07133519f, -0.09575737f, 0.05754537f, 0.51126134f, 0.67300832f, 0.39143479f, 0.25709027f, 0.17855109f, 
    -0.21172485f, 0.17079084f, 0.02207210f, -0.03530046f, 0.53220534f, 0.31599957f, -0.38116804f, -0.19849479f, 
    0.00874158f, -0.17818858f, 0.02770501f, -0.35984015f, -0.03073513f, 0.14387186f, -0.59033561f, -0.03104297f, 
    -0.03817889f, -0.21222650f, 0.08960342f, 0.00626249f, 0.30715847f, 0.13865465f, 0.33337384f, 0.10165099f, 
    -0.04828091f, -0.04360536f, 0.20113078f, 0.03039171f, -0.17300923f, 0.09827666f, 0.00348708f, -0.12396708f, 
    -0.16011161f, -0.10839170f, -0.07289749f, 0.10537692f, -0.14747427f, -0.01948017f, 0.28998324f, -0.08331139f, 
    -0.19477972f, -0.18791726f, 0.09617253f, 0.08520763f, -0.01726123f, 0.20953415f, -0.06723695f, -0.06639092f, 
    -0.07174061f, 0.00228386f, 0.29073533f, -0.05081252f, -0.05098166f, -0.07156457f, -0.25454596f, -0.05660113f, 
    -0.13091843f, -0.09150528f, -0.62062877f, 0.21176454f, 0.07809319f, 0.14757386f, 0.18398196f, 0.30822191f, 
    -0.01572174f, 0.02160397f, -0.24781010f, 0.00477708f, 0.31410712f, 0.05019228f, 0.08476732f, 0.08665784f, 
    0.20271611f, -0.06697698f, -0.07326258f, -0.20881163f, -0.38083407f, 0.19819871f, -0.44603732f, 0.14955696f, 
    -0.04325126f, -0.18248720f, 0.23350258f, 0.04586818f, -0.03302925f, 0.08379032f, 0.16233602f, -0.28434935f, 
    0.44939110f, -0.07990570f, 0.16569325f, -0.04293064f, 0.05414318f, 0.05039078f, -0.43896991f, 0.12723033f, 
    -0.09414408f, 0.05764483f, -0.03229751f, 0.28223583f, 0.02217663f, -0.06655896f, -0.08171502f, 0.21514714f, 
    0.32508227f, -0.24588133f, 0.53926122f, 0.23428054f, 0.18911155f, 0.13387741f, 0.01572376f, 0.05750135f, 
    -0.43981338f, 0.71997666f, -0.10033864f, -0.14311038f, -0.42308292f, -0.06731778f, 0.04198007f, 0.26898363f, 
    -0.10311746f, -0.02810128f, -0.33961403f, 0.77784622f, 0.14572534f, 0.11961246f, -0.20367984f, 0.04153130f, 
    -0.02003852f, 0.06366606f, 0.41136351f, -0.42202184f, 0.08651181f, 0.22097532f, 0.16076156f, 0.00444023f, 
    -0.14874625f, 0.13376427f, 0.33489412f, -0.44240093f, -0.46920151f, 0.59042680f, 0.10313337f, -0.02590452f, 
    0.15606548f, -0.08026803f, 0.10950021f, 0.21152426f, 0.02440850f, 0.12658556f, -0.20773388f, -0.04236414f, 
    -0.28630668f, -0.11615991f, 0.02388349f, 0.06545728f, -0.01234984f, 0.11158223f, 0.07451549f, -0.81348044f, 
    -0.07092254f, 0.05233545f, -0.15705505f, -0.03772961f, 0.13070621f, -0.15914074f, 0.01112183f, -0.69053102f, 
    0.23181969f, -0.28952894f, 0.07920361f, 0.12481726f, 0.17884663f, 0.03405119f, 0.20278654f, 0.46678227f, 
    -0.24388522f, 0.08273483f, -0.23806560f, 0.20673348f, 0.01379284f, -0.23623206f, 0.12511909f, 0.22260217f, 
    0.01130398f, -0.00298390f, 0.01680052f, 0.01536130f, -0.06812856f, -0.03421525f, -0.05046393f, 0.05658101f, 
    -0.00221343f, 0.00726526f, 0.00444959f, -0.02310165f, -0.00118159f, 0.06302099f, -0.03481611f, 0.05083513f, 
    -0.05571799f, 0.00374012f, -0.06127251f, -0.05346163f, 0.02844871f, -0.07104036f, -0.04756956f, 0.02159252f, 
    -0.08710318f, 0.00752296f, 0.05194240f, 0.01676233f, 0.02539127f, -0.00653606f, 0.00248434f, 0.04563728f, 
    0.03659540f, -0.03398157f, -0.08041339f, -0.03928198f, 0.02363071f, -0.06346999f, 0.03799400f, -0.08872725f, 
    -0.08585749f, 0.01720781f, -0.08330086f, 0.03328043f, -0.07540716f, -0.00252345f, -0.02749153f, -0.07971440f, 
    0.00453212f, -0.00712089f, -0.08581012f, 0.01909199f, 0.02204229f, -0.03104686f, 0.00590949f, 0.00127202f, 
    -0.03886551f, 0.02611037f, -0.02768419f, 0.02314489f, 0.03981626f, -0.04385149f, -0.04690961f, -0.01909390f, 
    0.02160920f, -0.01978563f, 0.02494994f, -0.02947099f, 0.07232001f, -0.02531483f, -0.06934380f, 0.04963202f, 
    -0.03270186f, 0.04167804f, -0.07724322f, 0.03440452f, -0.01407247f, -0.02346900f, 0.03554277f, -0.07241300f, 
    -0.00645056f, -0.01164867f, -0.06105748f, -0.01595867f, -0.03057794f, 0.00806481f, 0.01168506f, -0.06150881f, 
    0.05222305f, 0.05467307f, 0.04640391f, -0.05042377f, 0.01502719f, 0.06650711f, -0.00571953f, -0.05750239f, 
    0.05918896f, -0.07144449f, -0.09301374f, 0.05436966f, 0.06822288f, -0.06779102f, 0.04041411f, -0.03071669f, 
    0.01624250f, 0.04546470f, 0.00183109f, 0.01286424f, 0.04727298f, -0.04711565f, 0.01734040f, -0.08052088f, 
    0.05905245f, -0.04582414f, -0.08001251f, 0.01879473f, 0.01180854f, -0.00737264f, 0.00187610f, -0.09291509f, 
    -0.02944681f, 0.00537819f, -0.03403599f, 0.02096026f, 0.01880657f, -0.03657621f, -0.01588713f, -0.02600082f, 
    0.00993515f, -0.01639848f, -0.03037953f, -0.06600950f, 0.06631786f, -0.05293813f, 0.05059180f, -0.07149784f, 
    -0.07312632f, 0.04254722f, 0.00875395f, 0.03596343f, 0.01079907f, 0.01945683f, 0.04183831f, 0.02323178f, 
    -0.48731577f, -0.30106071f, 0.27634642f, 0.14987443f, -0.23757848f, 0.05491126f, 0.17223415f, -0.12087399f, 
    -0.13232009f, 0.05605493f, 0.40035963f, 0.03438872f, -0.09624331f, 0.10878641f, 0.08529753f, 0.05417059f, 
    0.18259916f, 0.14227773f, -0.06582622f, -0.22353302f, 0.10457861f, 0.12682360f, -0.05272961f, -0.03522548f, 
    0.24077587f, 0.19474649f, -0.01579039f, 0.24204823f, 0.31509590f, 0.17039198f, 0.12126379f, 0.12667847f, 
    0.20727882f, 0.26746488f, -0.14266667f, 0.03655414f, 0.52591598f, -0.04496362f, 0.02821145f, 0.15718582f, 
    -0.06961150f, 0.01620154f, 0.01122219f, 0.13172904f, 0.20878439f, 0.01840904f, 0.19096372f, 0.01338293f, 
    0.04623969f, 0.42715192f, 0.13697593f, -0.19390562f, 0.19467673f, 0.32020757f, 0.03683352f, -0.16113804f, 
    0.15061416f, 0.09895187f, -0.14279051f, -0.17236362f, 0.06351198f, -0.04154645f, 0.19313437f, 0.34552985f, 
    0.31961063f, 0.51200277f, 0.10680053f, 0.07723483f, 0.05323033f, 0.28669044f, 0.22024778f, 0.04748107f, 
    -0.10959037f, -0.01503924f, -0.18311892f, -0.11482795f, -0.33878955f, 0.00362632f, 0.09731202f, -0.06554506f, 
    0.25538832f, -0.22452272f, -0.23252140f, -0.66480333f, -0.01123078f, -0.05260107f, 0.10554204f, -0.12308950f, 
    0.25553319f, -0.20823444f, -0.13988352f, 0.03248706f, -0.27668372f, 0.04419086f, 0.49355739f, -0.09995271f, 
    -0.00388742f, 0.38456061f, -0.11579309f, 0.11404813f, -0.14370146f, -0.61239612f, 0.11812746f, 0.16307218f, 
    0.00082460f, 0.03681004f, -0.10014101f, -0.28006870f, -0.47850224f, -0.22114675f, -0.07754758f, 0.24215420f, 
    -0.20145516f, 0.06435801f, 0.22991352f, -0.03703737f, 0.20341508f, 0.24945883f, 0.23208861f, -0.19597882f, 
    -0.21663505f, -0.19545078f, 0.10460153f, 0.02598756f, -0.07449107f, 0.18900381f, -0.71793008f, -0.28583807f, 
    -0.51579660f, 0.38612351f, 0.23735973f, 0.10203965f, 0.14456531f, -0.13264140f, 0.07844893f, -0.26293167f, 
    -0.32929993f, -0.26580870f, -0.38912696f, 0.12116989f, 0.28314918f, 0.12005290f, 0.09057619f, 0.23474219f, 
    0.48944154f, 0.15723306f, -0.05566795f, -0.09759902f, 0.00275208f, -0.04261231f, 0.33603308f, 0.04402290f, 
    0.33550391f, 0.00518807f, 0.04686793f, 0.37625855f, 0.31866321f, 0.15728623f, 0.06432334f, 0.24139774f, 
    -0.09542310f, -0.09762020f, -0.07741281f, -0.30202428f, -0.35659167f, 0.11038264f, 0.07527782f, -0.15043782f, 
    0.08315682f, 0.09026789f, -0.00240077f, -0.70644969f, -0.54760236f, -0.24424848f, 0.44130963f, 0.02762054f, 
    0.15197848f, -0.15535939f, -0.10677138f, -0.08286657f, 0.55789071f, 0.45079222f, 0.20571160f, 0.41278410f, 
    0.03343067f, 0.05998939f, -0.01200443f, -0.05103865f, 0.16758955f, -0.68398070f, -0.08849052f, 0.14927623f, 
    0.11210700f, 0.22445932f, -0.02367484f, -0.13899346f, -0.09539343f, -0.17127080f, 0.27554911f, -0.07621249f, 
    -0.38184032f, -0.20335001f, -0.18246737f, -0.10053097f, 0.07888651f, 0.12507342f, 0.09719452f, -0.41540161f, 
    -0.65307319f, -0.24720642f, -0.00379223f, 0.12732477f, 0.22557302f, -0.23945437f, 0.07955329f, 0.08082803f, 
    -0.01670597f, 0.04890972f, -0.38981983f, -0.28623953f, -0.06596334f, 0.03017172f, -0.18432310f, -0.08668490f, 
    -0.17073739f, -0.12429845f, 0.24302669f, -0.05873366f, -0.05377298f, -0.18431570f, -0.13432014f, -0.16854826f, 
    -0.10358672f, 0.05559135f, -0.66454792f, -0.32295948f, -0.17251779f, -0.00085542f, 0.11710647f, 0.10944194f, 
    -0.12878624f, -0.12403122f, 0.01574573f, 0.37685037f, 0.16757958f, 0.04900271f, -0.43829760f, -0.06065345f, 
    -0.25121215f, 0.02034652f, -0.00507077f, -0.14468615f, 0.56764054f, 0.15799156f, 0.15065280f, -0.00626607f, 
    -0.13204806f, 0.15386887f, 0.26334879f, 0.00311498f, 0.03703462f, -0.00964575f, 0.00112842f, 0.11369098f, 
    -0.03194449f, 0.08769249f, -0.10921653f, -0.08341582f, 0.35442376f, 0.25979942f, 0.12660706f, -0.20037048f, 
    0.21823178f, -0.20314012f, 0.09081431f, -0.16389024f, 0.06487302f, 0.13257505f, 0.00792901f, 0.01125406f, 
    0.14517196f, 0.25687310f, 0.05993589f, -0.21002781f, -0.09382249f, -0.17219569f, 0.03983458f, -0.08407180f, 
    -0.20107889f, -0.13013299f, 0.18223068f, 0.02876726f, 0.03088573f, 0.12915485f, -0.20504358f, 0.20004472f, 
    -0.04010484f, 0.58345026f, 0.13844714f, 0.07267468f, 0.23221888f, 0.01570589f, -0.24257058f, 0.09258343f, 
    0.05663471f, 0.10102404f, -0.37174797f, -0.14696078f, 0.05169639f, -0.14060822f, 0.21778804f, -0.06749600f, 
    -0.09599972f, 0.08156759f, -0.10431527f, 0.47771922f, 0.12166586f, 0.20268844f, 0.09799540f, -0.09113914f, 
    -0.08185871f, 0.42733276f, 0.18315876f, -0.06061737f, -0.01849046f, -0.09040920f, -0.28243873f, 0.10465701f, 
    -0.12388133f, -0.02661551f, -0.02870213f, -0.15339454f, -0.14004806f, 0.31648615f, 0.12845160f, -0.12198039f, 
    0.14428388f, 0.00584282f, 0.12498088f, -0.10597920f, -0.21192473f, 0.01097520f, -0.50511104f, 0.03530838f, 
    -0.22539908f, -0.04866873f, 0.16862293f, -0.02141041f, -0.05596309f, -0.11009568f, 0.05888723f, 0.52531093f, 
    -0.12078053f, 0.11812118f, 0.01597680f, 0.02148668f, 0.06434239f, -0.08013526f, 0.13564487f, 0.04299726f, 
    0.41333145f, -0.10296404f, -0.35428882f, -0.06508332f, -0.04709082f, -0.04790686f, -0.01392391f, -0.09088819f, 
    -0.04053601f, 0.36906871f, 0.25718880f, -0.11166134f, -0.24268185f, -0.27414882f, -0.01039316f, 0.01342693f, 
    0.02456931f, -0.04616828f, 0.34061205f, 0.51672089f, -0.06724560f, -0.21036036f, 0.12652946f, 0.07295297f, 
    -0.17921640f, 0.13075447f, 0.10449481f, -0.51922214f, 0.04194895f, -0.00654024f, -0.24638091f, -0.11142875f, 
    0.04594432f, -0.08795779f, 0.10132750f, 0.00363413f, 0.32851318f, -0.06593993f, -0.32256067f, 0.18745905f, 
    -0.23953101f, -0.08895027f, 0.18165405f, 0.19789858f, -0.03596131f, 0.27232951f, 0.01730213f, -0.33194944f, 
    0.08991087f, 0.03846762f, -0.07599553f, 0.16191453f, 0.08157242f, -0.10615952f, -0.84214556f, -0.08238114f, 
    0.08287402f, 0.16139485f, 0.19042537f, 0.06461167f, -0.08324882f, -0.05103437f, 0.13284220f, -0.20501027f, 
    -0.55950171f, 0.11223938f, 0.03621638f, 0.17629251f, 0.29873878f, -0.23253219f, -0.04414916f, -0.05359614f, 
    -0.30859721f, 0.47917584f, -0.25717509f, 0.28792372f, 0.05271957f, 0.08463396f, 0.15464245f, 0.06377769f, 
    0.19004576f, 0.16082259f, -0.04164738f, -0.06432939f, 0.07991572f, 0.25434098f, -0.10314025f, -0.05746491f, 
    0.06706472f, -0.14062344f, 0.01076786f, 0.13702641f, 0.07248650f, 0.27722028f, -0.05819493f, -0.07039533f, 
    0.04080518f, -0.11748914f, 0.12354089f, -0.69771522f, -0.59951299f, -0.10464132f, 0.05197867f, 0.13203369f, 
    0.19593212f, -0.07684825f, 0.44154423f, -0.17766351f, 0.43646854f, -0.03394939f, 0.30275854f, 0.23925889f, 
    -0.21307509f, -0.11269560f, -0.20142229f, 0.07915850f, -0.20759018f, 0.25252381f, -0.43470323f, 0.33627719f, 
    -0.20883508f, 0.23937248f, 0.29837021f, -0.04046821f, 0.02442918f, -0.17990336f, 0.39534584f, 0.14443819f, 
    0.04052519f, -0.10128467f, -0.11410291f, 0.00714956f, 0.24953389f, 0.06026973f, 0.00193447f, -0.68861437f, 
    -0.08906412f, 0.09074274f, 0.08361824f, 0.31343925f, 0.32049459f, 0.01173964f, 0.01258238f, 0.04497838f, 
    -0.06793580f, 0.20932037f, 0.07730621f, -0.18663403f, -0.12220917f, -0.09660381f, 0.23366907f, -0.19584507f, 
    -0.06893723f, 0.16625690f, -0.12305647f, 0.09326398f, -0.08224811f, 0.29979768f, -0.12358988f, -0.09140244f, 
    -0.02627409f, -0.10493715f, 0.07946166f, -0.36446118f, 0.26084885f, 0.08087149f, -0.04328938f, 0.25609699f, 
    0.05459215f, 0.12920813f, 0.24929331f, 0.13212256f, 0.36143917f, 0.17938271f, 0.00729649f, 0.05882312f, 
    0.44626379f, -0.16361353f, 0.41053119f, 0.36740851f, 0.51385856f, -0.07959131f, 0.00631854f, 0.04114493f, 
    -0.20548414f, 0.02779473f, 0.24159621f, 0.31986526f, 0.04679892f, -0.10661363f, -0.58935511f, 0.22460254f, 
    -0.16200614f, -0.00049727f, -0.24097560f, 0.11236302f, -0.01386070f, -0.21839121f, -0.26292521f, -0.19600068f, 
    -0.03520191f, -0.09795184f, 0.05939407f, -0.23070922f, 0.23783690f, 0.15306090f, -0.12972298f, -0.73172295f, 
    -0.04629955f, -0.41537586f, 0.18471640f, 0.42315236f, -0.11891421f, -0.00157742f, 0.33264419f, -0.32334948f, 
    -0.03996091f, -0.04105683f, 0.04684001f, -0.03418802f, -0.02435635f, -0.04795292f, -0.00222224f, -0.02686807f, 
    0.04903359f, -0.04845788f, 0.01090140f, -0.04344754f, -0.08276472f, 0.00113338f, 0.06508588f, -0.05481065f, 
    0.00031238f, -0.07859416f, -0.07505935f, 0.00745880f, -0.05115795f, 0.02195489f, -0.01526129f, 0.04323947f, 
    0.05354250f, -0.05711532f, -0.01057674f, -0.05224551f, -0.03839577f, -0.02047792f, -0.01574670f, 0.07911949f, 
    0.03130852f, 0.00437161f, -0.02506531f, -0.02439407f, -0.07284215f, -0.02361861f, -0.02089344f, -0.08848418f, 
    -0.05528450f, -0.00403780f, -0.03500886f, 0.04026079f, -0.07468287f, -0.08765176f, -0.03152738f, -0.09136770f, 
    0.05203091f, 0.06453676f, 0.04497414f, 0.04757576f, 0.06128512f, 0.07296240f, 0.06546955f, 0.01841889f, 
    0.01550473f, 0.02814241f, -0.05143470f, -0.03540975f, 0.05483418f, -0.00349030f, -0.00798946f, -0.03126422f, 
    -0.07299907f, 0.00109068f, 0.01731044f, -0.01208758f, -0.02963789f, -0.02703448f, -0.01024034f, -0.02058192f, 
    0.04582267f, 0.05847853f, -0.00922600f, -0.02620734f, -0.07183907f, -0.04593472f, -0.06331187f, 0.03565206f, 
    -0.04873497f, 0.06943378f, -0.06823570f, -0.00009742f, 0.03323852f, 0.05623218f, -0.02392863f, 0.01829861f, 
    -0.06928868f, 0.02191420f, -0.06251588f, -0.06269555f, -0.09086637f, -0.05510287f, 0.07195944f, 0.01859204f, 
    0.02223032f, -0.04187688f, -0.01125343f, -0.06463691f, -0.03368381f, -0.02194625f, -0.01957992f, -0.05954665f, 
    -0.08399258f, 0.03380562f, -0.03461224f, 0.03017383f, -0.02376362f, 0.05311716f, 0.04178226f, 0.00852673f, 
    -0.07014991f, -0.00145145f, 0.07248855f, -0.02069780f, -0.03371433f, -0.01623696f, 0.01220358f, 0.05904860f, 
    -0.05922549f, -0.06485818f, -0.03318364f, -0.02708518f, 0.02118663f, -0.01443079f, -0.07757653f, -0.05717620f, 
    -0.07091109f, -0.07425952f, 0.04413754f, 0.01002750f, -0.00425068f, 0.06520174f, -0.03483258f, -0.06120583f, 
    -0.00299214f, 0.00306742f, 0.05811745f, -0.00194894f, -0.07589656f, 0.04784117f, -0.09434048f, 0.02846141f, 
    -0.03685245f, -0.01684830f, 0.06693034f, -0.07367847f, -0.06684632f, -0.03720298f, 0.00993320f, -0.06004735f, 
    0.01239925f, -0.06352244f, -0.03431134f, -0.06530054f, 0.06024672f, -0.08625136f, -0.06976002f, -0.05988036f, 
    -0.06186658f, 0.06983430f, -0.02632700f, -0.08422679f, -0.00304597f, -0.09403052f, -0.02699211f, 0.01546068f, 
    0.00640855f, -0.08757965f, -0.03361243f, -0.01239434f, -0.00072348f, -0.00798421f, -0.06514999f, 0.01405761f, 
    -0.07293496f, 0.04676782f, -0.04251146f, 0.07080507f, 0.04337967f, -0.02094187f, -0.08446413f, 0.00940275f, 
    -0.02435081f, -0.01712837f, 0.03437010f, -0.01855863f, 0.01891420f, -0.03563405f, 0.05823471f, -0.01263482f, 
    -0.03750057f, 0.05002208f, -0.01545536f, -0.03930146f, 0.00967582f, 0.02368353f, 0.05082157f, 0.06043113f, 
    -0.08118244f, -0.07192031f, -0.04951751f, 0.01743223f, -0.07967539f, -0.03894091f, 0.00123825f, -0.01048358f, 
    -0.07282609f, -0.01530058f, -0.02445596f, -0.07238200f, 0.07324167f, -0.00043142f, 0.00830037f, 0.06908070f, 
    0.03146512f, 0.01183130f, -0.08283771f, 0.02445242f, -0.06679590f, 0.00631207f, 0.06257511f, -0.00359734f, 
    0.00936880f, 0.00034366f, 0.06987796f, -0.04625775f, -0.05933045f, -0.06950115f, -0.06004604f, -0.02079581f, 
    0.05472922f, -0.04191962f, 0.04316580f, 0.05503504f, -0.04047911f, -0.07899086f, -0.02084472f, 0.05832600f, 
    -0.02330549f, -0.07303791f, -0.00790920f, 0.05408082f, -0.00044122f, 0.03124493f, -0.03142065f, -0.00338714f, 
    -0.01678174f, -0.02630573f, 0.01709119f, -0.00736046f, -0.05275380f, -0.05979018f, 0.04537180f, -0.02383091f, 
    -0.01285970f, 0.04189707f, -0.09004826f, -0.06629513f, 0.07246565f, -0.02052191f, 0.07035656f, 0.00542286f, 
    0.07550204f, -0.05876854f, 0.00446809f, 0.04323775f, 0.04201918f, -0.03869103f, 0.00819692f, -0.02295859f, 
    0.02116436f, -0.06391554f, 0.04004392f, -0.01890437f, 0.03396700f, -0.07669554f, -0.04644362f, -0.02363452f, 
    -0.07979335f, -0.02274198f, -0.00696091f, 0.05511473f, 0.05973665f, -0.05826870f, 0.07046048f, 0.04511109f, 
    0.17677481f, 0.34134722f, -0.08969337f, -0.09293736f, 0.38497654f, -0.14479189f, 0.03242491f, 0.04568571f, 
    -0.08382323f, 0.03842467f, 0.18689224f, 0.24160884f, -0.41333887f, -0.26181653f, 0.05379968f, -0.00932923f, 
    -0.04118108f, -0.01605311f, 0.07623987f, -0.09787253f, -0.31640643f, 0.27233270f, 0.12148944f, 0.23618449f, 
    0.06348001f, -0.14493820f, -0.17506965f, -0.29969594f, -0.12866537f, 0.26289409f, 0.06353696f, -0.12602475f, 
    -0.09812640f, -0.01795726f, -0.02159402f, -0.21481116f, -0.29253036f, 0.31675154f, 0.13405225f, 0.04528542f, 
    0.03505439f, 0.25233063f, 0.06595134f, 0.02339008f, 0.25744018f, 0.00358729f, 0.30119410f, 0.32803038f, 
    -0.12686607f, -0.26837710f, 0.04842051f, 0.22627710f, 0.17601076f, 0.06830254f, -0.65009946f, -0.34952384f, 
    -0.16040745f, 0.07385064f, 0.25493035f, -0.17010771f, -0.06802274f, -0.17596844f, 0.07842069f, 0.45971769f, 
    0.13450845f, 0.37746477f, 0.09080178f, -0.19456238f, -0.25848570f, 0.35518134f, 0.19793993f, 0.19537790f, 
    0.09515204f, 0.00792080f, -0.10053033f, -0.21737008f, -0.22162509f, -0.20836647f, -0.16180004f, 0.16114938f, 
    -0.10100483f, -0.23446743f, 0.30806801f, 0.36682844f, 0.06791238f, -0.00143301f, -0.01932980f, -0.14488120f, 
    0.11960302f, 0.06277065f, -0.02945288f, 0.31654766f, 0.28009018f, 0.42199323f, -0.10031901f, 0.12513781f, 
    0.03720606f, 0.04033219f, -0.06253429f, 0.07860147f, -0.07429702f, -0.58014709f, 0.41855538f, 0.23648380f, 
    0.13696934f, -0.02081583f, -0.03973890f, -0.03627738f, -0.23750533f, -0.47871676f, -0.32950950f, -0.05947815f, 
    0.27659664f, -0.11399836f, 0.17781104f, 0.04405776f, 0.01022932f, -0.04824391f, -0.07764575f, -0.00317154f, 
    -0.73874319f, 0.03918913f, -0.12114441f, 0.20494887f, 0.03208294f, 0.02529893f, 0.06685792f, -0.06730080f, 
    -0.32110974f, 0.08570199f, -0.14997405f, 0.15164922f, -0.13501748f, -0.07239102f, 0.02034977f, 0.05039908f, 
    -0.19819522f, -0.64168578f, 0.08637027f, 0.07744717f, -0.04566123f, 0.42479581f, 0.02774996f, -0.03486950f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.05389597f, 0.00555116f, -0.14444350f, -0.02849443f, 0.12394017f, 0.14661174f, -0.33381286f, 0.10202260f, 
    -0.02465740f, 0.35875869f, 0.20193477f, -0.19139050f, -0.02860805f, 0.02425194f, 0.03681121f, 0.39214012f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.19721618f, -0.16109003f, 1.05378020f, 0.03053888f, -0.24998762f, 0.00750289f, -0.32939732f, 0.00245279f, 
    -0.11962608f, -0.14735715f, -0.45934889f, -0.86844480f, -0.08303940f, -0.03075879f, 0.16420740f, 0.16753182f, 
    0.05664400f, -0.00528829f, -0.14599706f, 0.21044964f, 0.64118850f, 0.41242358f, 0.00681761f, -0.63697666f, 
    -0.19009304f, -0.08647268f, -0.55292690f, 0.10268721f, -0.20290168f, -0.24752042f, 0.02211237f, 0.45247677f, 
    0.11205418f, 0.00585651f, -0.05055413f, -0.08327913f, -0.16056998f, 1.25155652f, -1.47945690f, 0.02428442f, 
    0.20284349f, -0.46020091f, 0.51047546f, 0.24922441f, -0.59426451f, 0.24901880f, -0.05774718f, -0.21603149f, 
    -0.06348401f, 0.08164373f, 0.03853619f, 0.06697352f, -0.34408119f, -0.66406006f, 0.36218932f, 0.16787894f, 
    -0.20866019f, -0.27644125f, 0.59093589f, -0.39114672f, 0.56735551f, -0.19519509f, -0.19193502f, -0.82748669f, 
    0.12562095f, -0.18442973f, -0.47205159f, 0.23667213f, -0.12137285f, -0.11677151f, -0.20683560f, 0.37599674f, 
    0.22169307f, -0.15116023f, -0.15038438f, -0.26840475f, 0.04390074f, -0.22318494f, 0.09531228f, 0.45600039f, 
    -0.03677690f, 0.20532531f, -0.28988191f, 0.16030723f, 0.08124398f, -0.10830514f, 0.17120934f, -0.33471781f, 
    0.11698928f, 0.53998494f, -0.63091153f, -0.49062645f, -0.28480986f, 0.14608046f, 0.19658771f, 0.36099973f, 
    -0.20744865f, 0.13136594f, -0.11890776f, 0.02395699f, -0.98024279f, -0.61769867f, -0.25903720f, 0.08284478f, 
    -0.18579602f, 0.58045739f, -0.23719288f, 0.42862833f, -0.17449683f, -0.16850653f, 0.02338604f, 0.09299920f, 
    0.08823223f, 0.06429042f, -0.10458505f, -0.06324188f, 0.46164709f, -0.07523655f, 0.93369573f, 0.00778618f, 
    0.13974991f, -0.65912592f, -0.52324581f, -1.00209868f, 0.35514858f, 0.18913141f, -0.18508758f, -0.36462280f, 
    0.02563405f, -0.12151998f, 0.11369637f, -0.03258933f, 1.16269386f, -0.29356721f, 0.82650799f, -0.04908681f, 
    0.17382164f, -0.11793171f, 0.01669860f, 0.20003642f, -0.71568245f, -0.02946960f, -0.15052997f, 0.04950436f, 
    0.05622849f, -0.03780705f, 0.01802396f, 0.23932986f, -0.36450410f, -0.53663278f, -0.20609812f, 1.07070208f, 
    -0.05283578f, -0.07532916f, -0.12041002f, -0.16194229f, -0.30265057f, -0.14931273f, -0.06492250f, 0.26347131f, 
    0.15652284f, 0.22809024f, -0.80575854f, -0.07601931f, 0.04068197f, 0.10519286f, -0.06934853f, -0.24995479f, 
    0.07941275f, -0.21159063f, 1.01116383f, 0.01014865f, 0.32175651f, -0.12427713f, -0.01493868f, -0.62839919f, 
    -0.07527281f, -0.03675697f, 0.17462517f, 0.01885488f, -0.29577824f, -0.13081828f, -0.07502653f, -0.16335562f, 
    -0.19136144f, -0.22734255f, 0.05160897f, 1.09340727f, 0.19613828f, 0.08563907f, 0.11146914f, -0.39059493f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17521694f, 0.01711476f, -0.00692696f, -0.14685424f, 0.81711560f, 0.54681635f, -0.41597170f, -0.52775252f, 
    -0.52469277f, -0.21618631f, 0.17172630f, -0.32783356f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
