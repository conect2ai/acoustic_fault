#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.24311602f, -1.15257239f, -0.56314194f, 0.32834980f, 0.21721771f, -0.90184921f, -0.40825537f, -0.25604248f, 
    0.41293803f, -1.19845927f, -0.01993661f, 0.52223331f, -0.45252055f, 1.23856556f, -0.23537154f, -0.12194118f, 
    0.12426505f, -0.17877921f, -0.41008401f, 0.11010128f, 0.74946576f, 1.16190398f, -0.27326709f, -0.83826828f, 
    -0.09178339f, -0.03054815f, -0.12155288f, 0.44583485f, 1.09639072f, -0.98922890f, -0.65864277f, 0.38376758f, 
    -0.54218221f, -0.11246941f, -0.36677384f, 0.65045029f, 0.38962168f, 0.11432480f, -0.42306426f, -0.32895857f, 
    -0.07089321f, 0.88876009f, 0.84853095f, -0.38389310f, -0.16919447f, -0.33463934f, -0.36127001f, -1.26460540f, 
    -0.13700722f, 0.22490740f, 0.13754505f, 0.16827136f, 0.43597481f, 0.49811277f, -0.80120683f, -0.75970268f, 
    -0.57297611f, -0.72455275f, -0.70358109f, 0.46020824f, 0.58742380f, 0.28888446f, 0.30542582f, -0.46251950f, 
    -0.35888746f, 0.33616230f, -1.31116498f, -0.48147327f, -0.99862605f, 0.29684949f, -0.25937387f, 0.78787500f, 
    -0.28561831f, -0.84613967f, -1.09521031f, 0.58259344f, 0.77609670f, 0.74200511f, 0.05362811f, -0.35191166f, 
    -0.60995603f, 0.65435064f, 0.67716491f, 0.79500717f, -0.38347557f, -0.34453768f, -0.70796806f, 0.23854707f, 
    0.65629435f, -0.08576348f, -0.43887573f, 0.79466093f, -0.08099270f, 0.87423021f, 0.92117083f, 0.23872595f, 
    0.02742619f, 0.64798963f, -0.14361610f, 0.05869823f, 0.13855042f, 0.89968777f, 0.83931136f, -0.15293734f, 
    -0.16872574f, 0.33469290f, -0.34104127f, -0.70828497f, -0.15897073f, 0.01146810f, 0.47516483f, -0.22548182f, 
    -0.91794968f, -0.99281007f, 0.23499244f, 0.46703991f, 0.65893549f, 0.74145961f, 0.32455039f, 0.01847835f, 
    0.84661335f, -0.58280265f, -0.29719391f, -0.39308834f, 0.80072701f, 0.26964235f, 0.95662230f, 0.44757691f, 
    0.67069042f, 0.21773821f, -0.14602560f, -0.10901185f, 0.59149569f, 0.06024820f, 0.29083073f, -1.04742539f, 
    -0.77112412f, 0.37494481f, -0.28992498f, 0.65172100f, -0.22651070f, -0.01436539f, 0.45910946f, 0.66608649f, 
    -0.22441694f, 0.15188858f, 0.37751758f, 0.53896946f, 0.56412458f, 0.46779206f, -0.42333233f, -0.31624857f, 
    -0.24484600f, 0.67312992f, 1.16253459f, -0.94808888f, -0.12061261f, 0.02896377f, -0.15038709f, -0.11594951f, 
    0.25710145f, 0.16546273f, -0.25671241f, -0.64257622f, -1.11781955f, 0.14601848f, -0.30224341f, -0.55648458f, 
    -0.63748485f, -0.73048979f, -0.10965641f, 0.88010526f, -0.90444165f, 0.26475951f, 0.30589885f, -0.11696466f, 
    0.09853892f, 0.16677873f, 0.34586647f, 0.54674244f, 0.49331233f, -0.26213390f, -0.59437823f, 0.60649210f, 
    -0.01438284f, -0.11635812f, 0.27129090f, 0.62133235f, -0.73241740f, 0.69713455f, -0.51909077f, -0.83925617f, 
    -0.06085403f, 1.17091179f, 0.75994009f, -0.37714410f, -0.46395802f, -0.37372813f, -0.92147648f, 1.61724150f, 
    -0.85132390f, 0.02797977f, -0.12445924f, -0.50679499f, 0.27553138f, -0.62518930f, 0.59028095f, -0.40082523f, 
    0.60334241f, 0.83977002f, 0.30953658f, -0.63225991f, 0.00966743f, -0.19542028f, -0.68016881f, 0.03062377f, 
    -1.06234825f, -0.60907489f, 0.20633596f, -0.49050829f, -0.46524829f, -0.62585557f, -0.58442408f, -0.32458037f, 
    -0.77501750f, 0.89871854f, 0.60184431f, -0.31242004f, -0.37218449f, -0.22312108f, 0.24782972f, 0.45357126f, 
    0.29233348f, -0.37550390f, 0.11891741f, 0.49222368f, -0.78981918f, -0.75461864f, -0.28433552f, 0.95100975f, 
    -0.79018545f, -0.67394161f, -0.59508419f, 0.52164167f, -0.85158807f, -0.60229141f, -0.66024858f, -0.92721540f, 
    -0.95238900f, 0.61246014f, 0.29958355f, 0.00901101f, -1.11545002f, 0.45125645f, -1.02326596f, 0.31685957f, 
    0.44397214f, 0.39061022f, 0.59539646f, 0.29471096f, 0.48743972f, -1.69668555f, -0.40908447f, 1.15376389f, 
    0.18199292f, 0.39410877f, 0.60791200f, 0.05277053f, -0.36543852f, 0.00013244f, 0.27460670f, 0.72159994f, 
    1.06231987f, -0.57711399f, -0.35930255f, 0.63133156f, -0.70874161f, 0.06122852f, 0.52034938f, -0.08060426f, 
    -0.55964792f, 1.06191683f, -0.09879239f, 0.29847720f, 0.65640110f, 0.05951343f, 0.13502549f, 0.21362430f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11386864f, -0.04563837f, 0.38277540f, 0.18933679f, 0.16136713f, 0.73727059f, -0.17334856f, 0.17041895f, 
    -0.04432398f, 0.36954439f, -0.38240567f, -0.32591027f, 0.29576665f, -0.15806866f, -0.35175100f, -0.33976659f, 
    0.54185092f, 0.47152928f, -0.25356960f, -0.28086275f, 0.93855029f, -0.17704929f, -0.02858301f, 0.05027331f, 
    -0.52755904f, 0.56250358f, 0.10845744f, -0.00907001f, 0.65308589f, 0.17005907f, -0.07335955f, -0.28647333f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.23723987f, 0.09057394f, -0.22497596f, -0.02210218f, -0.04428688f, -0.10710970f, -0.01701998f, -0.08221100f, 
    -0.09062114f, 0.44393310f, 0.08199909f, 0.41910261f, 0.02997873f, 0.05432303f, -0.02163332f, 0.15674685f, 
    0.06364653f, 0.06942486f, -0.17606014f, -0.00588397f, 0.08931163f, 0.01374658f, -0.01265428f, 0.09440136f, 
    -0.06180093f, -0.05929395f, -0.01518428f, -0.06831883f, -0.13409521f, 0.25648090f, -0.01059956f, 0.02821711f, 
    0.18107885f, 0.18691757f, 0.16058561f, 0.06072292f, 0.23983850f, -0.13389154f, -0.04905919f, 0.16754532f, 
    0.04947963f, 0.19557372f, -0.06439308f, 0.02474206f, 0.30251169f, 0.06291731f, 0.02086295f, -0.06454452f, 
    -0.05756487f, -0.05497271f, -0.11213136f, 0.09890895f, 0.03835925f, 0.00696137f, 0.29721126f, 0.13282238f, 
    -0.37486079f, 0.10798230f, 0.09014051f, -0.18003736f, 0.09833341f, 0.13528025f, 0.19619547f, 0.04979356f, 
    0.06649303f, -0.19288458f, 0.07327817f, 0.10670869f, 0.03428895f, 0.10585617f, 0.04808096f, 0.16761781f, 
    0.12180037f, 0.02518288f, -0.07873038f, -0.22470516f, 0.10805655f, -0.05288328f, -0.20173292f, -0.31503934f, 
    -0.24275629f, -0.16260518f, -0.05424955f, 0.06520339f, -0.17819367f, -0.01032515f, 0.10715733f, -0.07074178f, 
    -0.00237275f, 0.10879602f, -0.09955560f, -0.04167202f, 0.01655915f, 0.10260603f, 0.11257216f, 0.13769810f, 
    -0.04830541f, 0.10331551f, -0.02840984f, -0.08488769f, -0.05745134f, 0.01475072f, 0.15673985f, 0.01333460f, 
    0.12648965f, -0.09195527f, -0.13989663f, -0.55047822f, -0.10164844f, -0.06254917f, 0.09978742f, -0.14644811f, 
    0.03232048f, 0.06458012f, 0.30766755f, 0.31418210f, 0.18432491f, -0.41395840f, -0.07809942f, 0.32347760f, 
    -0.06808326f, 0.00118655f, -0.07362732f, -0.05149799f, 0.26303256f, 0.33879510f, -0.27474257f, 0.09686690f, 
    0.10197183f, -0.28410053f, -0.16491354f, -0.13706931f, -0.10524002f, 0.09054100f, -0.19130003f, 0.17262501f, 
    0.14004581f, 0.14181127f, -0.08916478f, -0.07916611f, -0.18987617f, 0.21917991f, 0.25477874f, 0.10185207f, 
    -0.08109963f, -0.11364251f, -0.03025558f, 0.17661451f, 0.10310909f, 0.08228848f, -0.11919169f, -0.33605522f, 
    -0.45502797f, -0.17353642f, 0.00662886f, 0.17355751f, -0.04726149f, -0.05620319f, 0.00571994f, 0.01432600f, 
    -0.00237168f, 0.13037729f, 0.15944393f, -0.04809922f, -0.34036964f, -0.07376479f, 0.08780790f, -0.14468966f, 
    -0.06136535f, -0.31304604f, -0.17503960f, -0.17736036f, -0.01536020f, -0.12367205f, 0.01070327f, -0.14861396f, 
    -0.14659004f, 0.07013264f, 0.11390761f, 0.18299018f, -0.02458500f, 0.09783647f, -0.07962643f, 0.02544262f, 
    0.16356820f, 0.05933101f, -0.03224662f, -0.11770993f, 0.14055619f, -0.24812114f, -0.06237811f, 0.25689405f, 
    0.24869610f, 0.13489540f, -0.00833462f, -0.17430775f, -0.18075237f, -0.19816789f, 0.08366913f, 0.28186542f, 
    0.16313148f, 0.30629355f, -0.23486887f, 0.35714242f, 0.03116625f, 0.14877766f, -0.00776339f, -0.12424670f, 
    -0.01254665f, -0.09370154f, 0.02766391f, -0.17063020f, 0.13936163f, -0.32335809f, -0.22951345f, -0.42170990f, 
    0.00925900f, 0.05801656f, -0.17985627f, 0.02100382f, -0.01040527f, -0.02441682f, -0.13471766f, -0.07242788f, 
    -0.24853081f, -0.24643238f, -0.09805497f, 0.01887616f, -0.10107998f, -0.13673387f, -0.02780387f, -0.15073232f, 
    0.13656026f, 0.15629014f, -0.07590625f, 0.17885458f, 0.00919489f, -0.07140574f, -0.07310804f, -0.02261590f, 
    -0.46262050f, -0.20078535f, -0.24096732f, 0.04946205f, 0.11152522f, -0.44332349f, 0.05515078f, -0.02669877f, 
    0.01451945f, 0.03479653f, 0.14073469f, 0.14437611f, 0.01962377f, -0.01337618f, -0.05637569f, 0.00890532f, 
    -0.03045495f, 0.14159915f, 0.15592083f, 0.25105971f, 0.18870263f, 0.30127707f, 0.13238464f, 0.20041832f, 
    0.31976593f, 0.21817708f, 0.07017700f, 0.13189678f, -0.15699166f, -0.05589468f, 0.05219398f, 0.04795460f, 
    0.12250877f, -0.01397115f, 0.05507084f, 0.07294849f, -0.20430169f, -0.12517996f, -0.04324965f, 0.03005612f, 
    0.02263088f, -0.16426776f, -0.03389535f, -0.16369906f, 0.03793171f, 0.01848748f, -0.19925177f, -0.01296583f, 
    -0.03069923f, -0.03672060f, 0.04460538f, -0.00144953f, -0.05004150f, 0.03208893f, -0.00402698f, -0.03114899f, 
    0.02882561f, -0.00486427f, -0.00425208f, -0.01696671f, 0.00073978f, -0.05531053f, 0.01965350f, 0.00877618f, 
    0.05765092f, 0.05675460f, 0.05000512f, 0.05635913f, 0.02870014f, -0.01265312f, -0.02313762f, 0.04053245f, 
    -0.04389795f, -0.02415559f, 0.00928735f, 0.00459991f, 0.01699475f, 0.00017053f, 0.05556703f, -0.04837115f, 
    -0.05714971f, -0.01323065f, -0.02624973f, -0.05059106f, 0.01827364f, 0.00079199f, -0.05151507f, 0.02709829f, 
    -0.00299637f, -0.01344917f, 0.03265690f, -0.03237158f, -0.02060047f, -0.05735243f, 0.04591502f, 0.04311223f, 
    -0.01927198f, 0.01906539f, -0.02864454f, 0.02054486f, 0.03267791f, 0.02163247f, -0.01649860f, 0.04055656f, 
    -0.05428413f, -0.04480786f, 0.04230051f, 0.02954708f, -0.00362067f, 0.04512367f, -0.00100343f, 0.00450705f, 
    -0.04325598f, -0.02834938f, -0.04205015f, -0.05308466f, -0.02701311f, 0.02427824f, -0.03783785f, -0.01797229f, 
    -0.04347926f, 0.03595074f, -0.02840599f, -0.04898896f, -0.05506264f, 0.00534121f, -0.04206943f, -0.02053156f, 
    -0.03370588f, -0.05039030f, -0.05593626f, -0.02496865f, 0.04115744f, 0.01971336f, -0.03552836f, 0.02048687f, 
    0.05877747f, -0.00786420f, -0.04829355f, -0.00432177f, -0.00102835f, 0.02277770f, -0.01216005f, -0.04249877f, 
    0.00427879f, 0.02878215f, -0.05630882f, -0.00215667f, 0.01447786f, -0.04822876f, -0.03666195f, -0.03563930f, 
    -0.02492210f, -0.03924003f, 0.04138473f, 0.00031552f, 0.03304029f, 0.01041131f, 0.04365755f, -0.03782390f, 
    0.02155054f, 0.00729952f, -0.05396253f, 0.00247946f, 0.00080045f, 0.05739978f, 0.04168194f, -0.00355916f, 
    -0.04114649f, 0.00093140f, 0.04864957f, -0.02847705f, -0.00518242f, 0.05017098f, 0.00266065f, -0.04405033f, 
    0.03083744f, -0.01107295f, 0.00389591f, 0.00591074f, 0.00032637f, 0.04138074f, -0.02013464f, -0.04803788f, 
    0.03744811f, -0.01229119f, -0.01292522f, 0.05530266f, -0.02951824f, 0.04504421f, 0.00600081f, -0.04535014f, 
    -0.02204277f, -0.05720525f, 0.05157227f, -0.02720125f, 0.03834350f, -0.03106259f, 0.00004085f, 0.02525847f, 
    0.02936339f, -0.02315831f, 0.03606108f, 0.00228408f, -0.04508196f, -0.01785054f, 0.00536743f, 0.00176569f, 
    -0.01661252f, 0.03136086f, -0.05166429f, 0.05667172f, -0.05293192f, -0.03779666f, 0.03689067f, -0.00542166f, 
    -0.02915732f, -0.03833404f, 0.03916010f, -0.00175277f, -0.03259785f, 0.01657343f, -0.01875822f, -0.03059639f, 
    -0.00219725f, -0.04260821f, -0.02361296f, 0.02334168f, 0.00660943f, 0.01217962f, 0.01596591f, 0.02521117f, 
    -0.01830240f, -0.01642380f, -0.03422231f, -0.04568852f, -0.05175035f, -0.00943190f, 0.05815235f, -0.02259932f, 
    -0.00438184f, 0.03782115f, 0.05807175f, 0.04062770f, 0.05406431f, -0.01457256f, -0.00021560f, 0.00148500f, 
    -0.04501078f, -0.04278078f, -0.04400518f, -0.05325375f, 0.01482596f, 0.05337752f, -0.02591801f, -0.00655724f, 
    -0.05331179f, 0.01561626f, -0.04407701f, -0.01420624f, 0.05645334f, -0.05374948f, -0.05436445f, -0.02383075f, 
    0.04601748f, 0.00373876f, -0.03353887f, -0.04155630f, -0.03830119f, -0.01325030f, -0.02000300f, -0.04548086f, 
    -0.04389058f, -0.03315201f, -0.00075978f, 0.01597375f, -0.00036673f, 0.04169156f, 0.01948481f, -0.03176207f, 
    -0.04171124f, -0.02477013f, 0.01670731f, 0.04078368f, -0.04222753f, 0.01287458f, 0.00334321f, -0.05557091f, 
    -0.05505010f, -0.05385015f, -0.05113543f, -0.03093300f, 0.04695990f, -0.02359739f, 0.01972142f, 0.03337998f, 
    0.02612283f, 0.01258373f, -0.05393533f, -0.05789892f, 0.00413496f, 0.00633917f, -0.03276258f, 0.00320039f, 
    -0.05842427f, 0.02384695f, -0.05621809f, -0.05343701f, -0.00040717f, 0.05877876f, -0.01544205f, 0.01995936f, 
    0.02405297f, 0.04439462f, 0.00130645f, 0.03503112f, 0.05686394f, 0.02205650f, -0.05707239f, 0.02601774f, 
    -0.05067267f, -0.02172461f, -0.04243227f, 0.05133498f, 0.05550937f, -0.04736621f, -0.02492723f, -0.03880177f, 
    -0.03483861f, 0.03275422f, 0.00039579f, -0.02855509f, -0.04598649f, 0.01159291f, -0.02612038f, -0.01449890f, 
    -0.05255244f, 0.03415486f, -0.01797312f, -0.05155064f, -0.02001798f, 0.01235190f, -0.01816608f, -0.02579373f, 
    -0.00521121f, -0.00629747f, -0.00417400f, -0.03933664f, 0.01865908f, 0.04386564f, -0.06343401f, 0.04088445f, 
    0.04427410f, -0.06390737f, -0.04459394f, -0.02090724f, -0.05552302f, 0.02645187f, 0.01931935f, -0.01796261f, 
    0.04749738f, -0.05930832f, -0.05889066f, -0.00296748f, 0.04161338f, -0.00030893f, -0.03767911f, -0.00151549f, 
    -0.06401554f, -0.03434881f, -0.04475904f, 0.02040464f, 0.00785073f, -0.00023154f, 0.00050121f, 0.02969716f, 
    -0.04811146f, -0.01294640f, 0.04578575f, 0.01752462f, 0.03208481f, -0.00975398f, -0.05278378f, -0.00297654f, 
    -0.05691776f, 0.01652694f, 0.04620294f, 0.01286409f, 0.00222590f, -0.06451192f, -0.04764628f, -0.00745457f, 
    0.04579676f, 0.04329432f, -0.00182455f, -0.04364587f, -0.03637801f, -0.00400299f, -0.03526908f, -0.03109572f, 
    0.03087158f, 0.00016490f, -0.03537818f, 0.03843672f, -0.03367023f, 0.00606017f, -0.02553273f, 0.03722442f, 
    0.05480693f, -0.04732960f, -0.03330686f, 0.03507350f, -0.01379611f, -0.06897489f, 0.00318557f, 0.03795089f, 
    0.01715074f, -0.02625270f, 0.04102488f, -0.00739231f, 0.03667676f, -0.04141508f, 0.02269872f, 0.00261922f, 
    0.03965057f, -0.02574489f, -0.01429532f, -0.01793414f, -0.00559258f, 0.01722918f, -0.03260471f, -0.06471382f, 
    -0.04216164f, -0.06417289f, 0.00623891f, 0.01344260f, 0.05389752f, -0.03263403f, -0.04583250f, -0.01944059f, 
    -0.04906082f, -0.05957096f, 0.00524710f, 0.00085695f, -0.00512945f, 0.01180687f, -0.02258816f, -0.00685954f, 
    -0.05539349f, 0.01415884f, -0.05945001f, -0.00937641f, -0.00893157f, -0.02628715f, -0.00757550f, -0.03978246f, 
    0.02678696f, 0.02755681f, -0.05909595f, -0.05996139f, 0.02460344f, -0.05770682f, -0.04327367f, 0.03836622f, 
    0.05457497f, 0.06163257f, -0.04160038f, 0.02361394f, -0.01167665f, 0.02293217f, 0.04163123f, -0.03490666f, 
    -0.03128711f, -0.04546456f, 0.01264444f, 0.00634239f, -0.04279839f, 0.01104286f, -0.04850210f, -0.00216440f, 
    -0.02029238f, 0.02373291f, -0.05962460f, -0.05289156f, -0.04158732f, -0.01225755f, -0.02250541f, -0.03917731f, 
    0.00491204f, -0.03908845f, -0.05028641f, 0.03833246f, -0.02620277f, -0.00545659f, -0.03778848f, 0.01379481f, 
    0.01834811f, -0.02606430f, -0.03290307f, 0.01679059f, 0.03847792f, 0.03726073f, -0.01778804f, -0.06209533f, 
    0.01299742f, -0.05052151f, -0.03147309f, 0.00415204f, 0.01382538f, 0.04113707f, -0.04469582f, -0.03658915f, 
    -0.00365116f, -0.03626980f, -0.00238381f, -0.04669061f, -0.04198306f, -0.01875141f, 0.00863547f, -0.00002263f, 
    -0.01252483f, -0.02487131f, 0.04811085f, -0.02184524f, -0.01240699f, 0.03288842f, -0.04130078f, 0.01018291f, 
    -0.01697917f, 0.03158525f, -0.02119781f, -0.03236726f, -0.05570338f, 0.02402177f, -0.04958591f, -0.01827472f, 
    0.04343227f, -0.02880601f, -0.03514113f, 0.01658315f, 0.02434291f, -0.03066747f, 0.02849581f, -0.02135020f, 
    -0.02100735f, 0.00679831f, 0.00580943f, -0.03456311f, 0.01491660f, 0.03093093f, 0.00607762f, 0.01565812f, 
    0.04625346f, -0.00829731f, 0.05092201f, 0.02315593f, 0.02211678f, -0.01937122f, -0.01041741f, 0.02968084f, 
    -0.00123819f, 0.03420031f, -0.02672696f, 0.02011929f, -0.00477623f, -0.05902541f, 0.04737566f, 0.04096046f, 
    0.04497025f, -0.02614285f, 0.01966336f, 0.00602481f, -0.04244269f, 0.04591858f, -0.00964649f, -0.01287275f, 
    -0.02608404f, -0.04136024f, 0.00522629f, -0.06353036f, 0.04175550f, -0.03851474f, -0.02670730f, 0.04797971f, 
    -0.06432398f, 0.04180156f, 0.03535300f, -0.03145993f, -0.04328806f, 0.01890599f, 0.04443325f, 0.04014003f, 
    -0.03668818f, -0.06223566f, -0.05449265f, -0.01995416f, -0.04190885f, 0.02094108f, -0.03441256f, 0.02855219f, 
    -0.06196365f, -0.04578885f, -0.02825165f, 0.01705588f, -0.05819142f, -0.00657774f, -0.02093743f, 0.05759407f, 
    -0.00012776f, -0.00459774f, -0.03598728f, 0.02742730f, -0.00052898f, -0.04590514f, -0.04623930f, -0.00027462f, 
    -0.02770843f, 0.01359432f, -0.05197044f, 0.05543872f, -0.00206321f, -0.01100115f, -0.05335451f, -0.02845746f, 
    -0.00262781f, 0.02100714f, -0.03741375f, 0.04549612f, -0.03510182f, -0.06674513f, -0.02090589f, -0.00508801f, 
    -0.05724580f, 0.05250298f, 0.00841881f, -0.01231882f, -0.04421313f, 0.04685212f, -0.05218923f, -0.04406749f, 
    0.00533864f, -0.05749354f, -0.03005805f, 0.01080232f, 0.05196705f, -0.00588760f, 0.06103436f, -0.02278955f, 
    0.03806593f, -0.05482632f, -0.03997968f, 0.01907696f, 0.04006896f, -0.01088016f, -0.00231647f, -0.04597457f, 
    -0.05697090f, 0.01795996f, 0.02666621f, 0.01106037f, 0.01141901f, -0.01206207f, 0.06103627f, 0.02374650f, 
    -0.00735744f, 0.01265000f, 0.01947126f, -0.00466782f, -0.03470646f, -0.06454758f, -0.00552620f, 0.04219159f, 
    -0.06793604f, 0.02221698f, 0.02634348f, -0.02896419f, -0.02561431f, -0.05732486f, 0.01160220f, -0.02913046f, 
    0.02684987f, 0.03360258f, 0.03158402f, -0.00817369f, -0.04859306f, -0.04092613f, 0.04615782f, -0.06191564f, 
    0.03539083f, 0.03814607f, 0.03000543f, 0.00618646f, -0.01224889f, -0.03923343f, -0.00433909f, -0.05843334f, 
    -0.03847487f, 0.00812621f, -0.00075366f, 0.04012892f, 0.03899182f, -0.04415141f, -0.05963048f, 0.02400322f, 
    -0.03955451f, 0.00545948f, 0.04654001f, -0.03297051f, -0.00131197f, 0.03922910f, -0.03245359f, 0.01905217f, 
    -0.02016958f, -0.05783705f, -0.04954202f, 0.05306467f, -0.01359826f, -0.00052288f, -0.04186633f, 0.02777650f, 
    -0.05547829f, 0.01510287f, 0.05452488f, -0.03362668f, 0.01361821f, 0.02322274f, -0.00238659f, -0.04956169f, 
    0.02082596f, 0.02879304f, -0.03651481f, -0.00030428f, 0.00148189f, 0.00960171f, -0.00556470f, -0.00537602f, 
    0.03799333f, -0.01964354f, 0.01812110f, 0.04450412f, -0.02846579f, -0.00844841f, -0.00542454f, 0.04233669f, 
    -0.03901970f, -0.05522738f, 0.01802029f, -0.02827144f, 0.05413213f, -0.02488274f, -0.04986045f, 0.02876939f, 
    -0.01167990f, 0.01996645f, 0.02870617f, -0.01820070f, -0.06613532f, 0.03868613f, 0.02259806f, -0.03602790f, 
    -0.04125621f, 0.03646094f, -0.03749723f, -0.04351815f, 0.00875271f, 0.01655266f, -0.04256867f, -0.03942152f, 
    -0.05032600f, 0.00319134f, 0.05442976f, -0.02818255f, 0.03829857f, -0.02372316f, -0.02299356f, -0.02775089f, 
    -0.04269321f, -0.03689596f, 0.05652560f, 0.03360325f, 0.00823046f, -0.04046262f, -0.01380137f, -0.03967279f, 
    0.03615117f, 0.04843030f, -0.01431787f, 0.03575687f, -0.04292958f, -0.01656202f, -0.01114984f, 0.03091554f, 
    0.01061556f, -0.02010622f, 0.03690914f, 0.00531473f, -0.04403466f, -0.01338406f, 0.04115478f, 0.02123970f, 
    0.03353927f, -0.04134348f, 0.04064948f, 0.04243582f, 0.03238199f, 0.00841361f, 0.00356868f, -0.03426973f, 
    -0.00922660f, -0.05106309f, 0.03040697f, 0.03364208f, -0.02907352f, 0.03215302f, 0.02153745f, -0.06120413f, 
    -0.02380088f, -0.05653676f, -0.05469824f, 0.04497417f, -0.01720353f, -0.05130674f, -0.04423412f, 0.02946105f, 
    -0.03024985f, -0.02396804f, -0.05019307f, -0.04904409f, 0.03522214f, -0.03341140f, -0.05164336f, -0.04861040f, 
    0.04381774f, 0.04361418f, -0.02044826f, 0.02090663f, -0.04567024f, -0.04576983f, 0.01672270f, 0.01455207f, 
    -0.02865233f, -0.03522008f, 0.02757844f, 0.01643676f, 0.04465251f, -0.02245318f, -0.00475473f, 0.02515667f, 
    -0.03590541f, -0.03625997f, 0.00810897f, 0.04155300f, -0.00709518f, -0.02695637f, 0.03998394f, -0.00674122f, 
    -0.02342837f, -0.01316082f, -0.05821443f, -0.05646561f, -0.04081843f, 0.04165715f, 0.03852734f, -0.05686516f, 
    -0.05173334f, 0.00371502f, 0.02164337f, 0.01210042f, -0.01356965f, 0.03907150f, -0.04233428f, -0.00106090f, 
    0.04664992f, -0.01766641f, 0.00789320f, -0.03072732f, -0.05780550f, -0.01607341f, 0.03252710f, -0.06032480f, 
    0.03252182f, 0.01021265f, -0.03305634f, -0.05440239f, 0.03375970f, -0.00799133f, 0.05366158f, -0.02459435f, 
    -0.04489100f, -0.05276898f, -0.06540458f, 0.02088053f, 0.01079775f, -0.03894636f, -0.03700463f, -0.03607582f, 
    0.00286424f, 0.01218534f, -0.00720558f, 0.04907868f, -0.04991699f, 0.00601212f, -0.02185021f, -0.02460115f, 
    0.02087698f, 0.02259159f, 0.04405177f, 0.02567263f, -0.01317623f, -0.03309672f, -0.05488212f, -0.02473780f, 
    -0.23642612f, -0.08810737f, 0.32837740f, 0.21993792f, 0.18582103f, 0.05965604f, 0.10924330f, 0.07724233f, 
    0.05506922f, 0.44099838f, -0.15992306f, -0.30258080f, 0.11371843f, 0.06240113f, 0.05283764f, 0.11365128f, 
    -0.02514412f, -0.06168233f, -0.03215922f, 0.38988373f, 0.22438228f, 0.25599906f, 0.18764669f, 0.06956651f, 
    0.19813639f, -0.14325044f, 0.11187605f, -0.03455373f, 0.11114326f, 0.01827164f, -0.22647935f, 0.18482418f, 
    -0.26146871f, 0.11863881f, 0.01299674f, 0.12981012f, -0.05373763f, 0.06891591f, -0.14625026f, -0.06903270f, 
    -0.09210797f, 0.15471585f, 0.23953371f, -0.10852253f, 0.12845306f, -0.15898047f, -0.00106958f, 0.46377859f, 
    -0.04774692f, 0.07164638f, 0.05836213f, 0.01129378f, 0.13756473f, 0.24393292f, 0.02719989f, -0.23595607f, 
    0.19983183f, -0.01855520f, 0.07305003f, 0.10478061f, 0.00624843f, 0.05907907f, -0.05404501f, 0.25206554f, 
    -0.26257285f, 0.07998388f, -0.00125013f, 0.16854480f, -0.09777272f, -0.03367743f, 0.29098749f, -0.18563747f, 
    -0.12360562f, 0.29797655f, 0.29602459f, 0.24455807f, 0.07163537f, 0.15464100f, 0.12528959f, 0.10497194f, 
    0.11063659f, -0.33753181f, -0.02525525f, -0.08818278f, -0.06835898f, -0.16073723f, 0.02515934f, 0.12042541f, 
    -0.02449010f, 0.23235597f, 0.00399298f, -0.21716413f, -0.36589637f, 0.36016312f, -0.22624747f, -0.09919062f, 
    -0.01571147f, -0.19767316f, -0.00435190f, -0.18054444f, -0.07782292f, -0.15042323f, 0.01980563f, 0.10757846f, 
    -0.02506462f, 0.00761652f, 0.05261967f, 0.05710046f, 0.01708310f, -0.12992045f, -0.03102634f, 0.03889450f, 
    0.02354455f, -0.00605619f, 0.00821507f, 0.16210061f, -0.09179214f, -0.18256979f, -0.30751461f, -0.16269048f, 
    0.09504575f, -0.33971620f, 0.06126488f, 0.26948127f, -0.46602640f, -0.02296639f, -0.34456873f, -0.29642314f, 
    -0.45378911f, 0.07884900f, -0.24710633f, -0.09118579f, 0.16195333f, 0.05944309f, -0.07262874f, -0.33848819f, 
    -0.47960436f, -0.00416884f, -0.26208541f, -0.01975612f, -0.01853042f, -0.09058336f, 0.02530485f, 0.01943163f, 
    0.07005408f, -0.00980394f, -0.08176448f, 0.27395704f, 0.30096734f, 0.12174446f, -0.14031425f, 0.02582579f, 
    -0.01411184f, -0.38038290f, 0.34277371f, 0.12370677f, 0.01730798f, -0.06743316f, -0.14170334f, 0.18667513f, 
    -0.11065137f, 0.01164562f, -0.10510331f, -0.28150511f, 0.24034514f, 0.03030124f, 0.09523401f, 0.05497629f, 
    0.29972932f, 0.11404265f, -0.17027178f, -0.10703868f, 0.08524407f, -0.24254388f, 0.13406596f, -0.14295147f, 
    -0.25835982f, -0.01378801f, 0.01169265f, 0.01669505f, -0.20130068f, 0.14355567f, 0.35203102f, 0.12533230f, 
    0.07457958f, 0.15319186f, 0.18978748f, 0.34647176f, 0.45304054f, 0.24542023f, 0.15448804f, 0.03239001f, 
    0.16327706f, -0.16260582f, -0.07597566f, -0.05773313f, 0.04424590f, -0.05473195f, 0.02673279f, 0.00809625f, 
    0.00497378f, -0.10026167f, -0.07146835f, -0.33158985f, 0.07557096f, -0.14030062f, 0.07674786f, 0.21882851f, 
    0.30417481f, 0.14418195f, -0.06311629f, -0.03551742f, -0.06886128f, -0.07885380f, 0.20678918f, -0.02836868f, 
    0.09538551f, -0.07633549f, 0.14410903f, 0.17255975f, 0.04713013f, 0.02122518f, -0.00640533f, 0.12224203f, 
    -0.27718493f, -0.33603886f, 0.16574967f, 0.13056612f, 0.04829617f, -0.10859435f, 0.10570130f, 0.08806200f, 
    -0.19183218f, 0.17023245f, 0.19787359f, -0.14304863f, 0.00040513f, -0.16765873f, 0.19127685f, 0.07476282f, 
    0.15276231f, 0.02726274f, -0.34892634f, 0.03584436f, -0.10558858f, 0.46545297f, -0.01140071f, 0.06443685f, 
    0.13837370f, 0.05881397f, 0.04342901f, 0.01590682f, 0.04340821f, -0.06732869f, 0.02905182f, 0.11402864f, 
    0.19463502f, -0.05230684f, -0.04459459f, 0.11354090f, 0.15956555f, 0.34645945f, -0.15301260f, -0.37989077f, 
    0.30509824f, -0.05942119f, -0.14317039f, -0.03022629f, 0.02247018f, 0.07975930f, -0.20975772f, 0.00964899f, 
    -0.24593788f, -0.14040269f, -0.16749673f, -0.20757866f, 0.12270615f, 0.12708949f, 0.00376598f, -0.15786096f, 
    -0.24345204f, -0.30878186f, -0.10728338f, -0.51190823f, -0.63019598f, 0.01696502f, 0.09397428f, -0.34703410f, 
    0.01365331f, 0.01165957f, 0.01050697f, -0.03291626f, -0.04507974f, -0.05938076f, -0.02987472f, -0.00108453f, 
    0.03229632f, 0.01442375f, 0.02157633f, -0.00881217f, 0.02318668f, -0.03559517f, -0.06120059f, 0.03045917f, 
    0.03043799f, 0.02738971f, -0.01241152f, -0.00514575f, 0.00457378f, 0.00063391f, -0.02846177f, -0.03456106f, 
    0.00735807f, 0.03328876f, 0.05197855f, -0.01252798f, 0.04149973f, 0.01526565f, 0.01775985f, -0.06293461f, 
    -0.02990532f, -0.00190951f, 0.02428756f, -0.05967799f, 0.01374692f, 0.02853849f, -0.04400833f, 0.01643982f, 
    -0.05612674f, 0.01394735f, -0.04752158f, 0.01757592f, -0.03949860f, 0.03282751f, -0.02526243f, 0.03576624f, 
    -0.04709185f, 0.00881074f, -0.00007958f, 0.01658783f, 0.02967605f, -0.01475516f, -0.02151532f, 0.03905820f, 
    -0.03471982f, -0.01202573f, -0.05485129f, 0.04001278f, -0.05688322f, -0.01202628f, 0.04297005f, 0.03192497f, 
    -0.05187225f, 0.00840508f, -0.05200805f, 0.01992273f, -0.01966505f, -0.00345047f, -0.01199298f, -0.04614573f, 
    0.03717877f, -0.04924406f, -0.01244011f, 0.04669394f, -0.00587653f, 0.04573444f, 0.04800178f, -0.04086071f, 
    -0.04932274f, -0.05382600f, 0.03641506f, -0.04343298f, 0.04506420f, -0.02749959f, -0.03317225f, -0.04847342f, 
    0.00355021f, -0.05479109f, -0.01717876f, -0.03218942f, -0.02665445f, -0.02747621f, 0.05195915f, 0.01126320f, 
    0.01349146f, 0.04307695f, -0.05079459f, -0.04271352f, 0.03411819f, 0.05800755f, 0.03671778f, -0.03578254f, 
    0.05105629f, -0.00025942f, -0.01418399f, -0.02706060f, -0.00403077f, -0.01477226f, -0.04371998f, 0.00382537f, 
    -0.03074329f, -0.05422683f, -0.04493648f, -0.00765279f, 0.02056038f, -0.02354756f, 0.01780049f, -0.01177340f, 
    -0.03846886f, 0.01440808f, -0.05287779f, 0.05254082f, 0.00970194f, 0.00896059f, 0.01808650f, -0.01167512f, 
    0.04960900f, -0.01378172f, 0.02371831f, -0.00436072f, -0.01452377f, -0.00709228f, -0.03587340f, 0.02336156f, 
    -0.05150182f, -0.00749587f, -0.05788035f, -0.00311275f, 0.01152863f, 0.00767235f, -0.02663431f, -0.01906866f, 
    -0.00187048f, -0.00261625f, -0.05305628f, 0.02710095f, -0.01542300f, -0.02825634f, 0.03687761f, -0.04559221f, 
    -0.00837628f, 0.05278435f, 0.03207457f, 0.02755026f, -0.02875832f, 0.00414505f, 0.01917702f, -0.04640708f, 
    0.01786285f, 0.02332862f, 0.00266535f, -0.04951378f, 0.00351091f, 0.03750779f, 0.04770521f, 0.02718917f, 
    0.04217411f, -0.05653628f, -0.04320610f, 0.01854672f, 0.00390760f, -0.03360634f, -0.02705731f, 0.04702641f, 
    -0.03210892f, -0.04891247f, 0.03906461f, -0.02892052f, -0.03873721f, -0.00363868f, -0.03621813f, 0.00235468f, 
    -0.01227943f, -0.05241494f, -0.00934433f, -0.04426615f, -0.02995024f, -0.05499437f, 0.04372311f, 0.03220148f, 
    -0.03483808f, 0.04988518f, -0.01373647f, 0.01211031f, 0.02025779f, 0.01047937f, -0.00445445f, -0.05975776f, 
    -0.01842636f, 0.03693377f, 0.00418134f, 0.00840616f, -0.03293316f, 0.01165490f, -0.01525392f, -0.03875044f, 
    -0.01338108f, -0.04208388f, 0.04353194f, -0.02958976f, 0.02048249f, 0.00177360f, -0.05323160f, -0.02728107f, 
    -0.03024157f, 0.05060887f, -0.04015998f, 0.05087394f, -0.00863452f, -0.05822429f, 0.01053063f, 0.04505066f, 
    0.04159759f, 0.01840634f, -0.02435530f, -0.05349519f, -0.03608383f, 0.01122024f, -0.05622435f, 0.00126589f, 
    -0.03958238f, -0.01106712f, 0.02805485f, -0.04292492f, -0.03258549f, 0.02323138f, -0.01429646f, -0.06379227f, 
    0.02567329f, 0.02828285f, -0.02346699f, 0.04516017f, -0.05806179f, 0.03984835f, 0.04808259f, -0.05658306f, 
    -0.00318047f, -0.04459846f, -0.05570172f, -0.03981833f, -0.04677080f, -0.03791915f, 0.01458361f, -0.06237917f, 
    -0.01399932f, -0.05483807f, -0.05248394f, -0.00489488f, 0.02837783f, 0.03868972f, 0.02588263f, 0.01083028f, 
    0.04797022f, -0.05109727f, 0.03550589f, -0.04183301f, -0.03473865f, 0.04577725f, 0.05098073f, -0.02016250f, 
    0.02465662f, -0.05899781f, -0.03863786f, -0.06279578f, 0.01282802f, -0.00935942f, -0.03958778f, -0.02032323f, 
    0.05447052f, -0.05005625f, 0.04102324f, -0.05612973f, -0.03668220f, -0.04752314f, -0.03823111f, 0.04653864f, 
    0.52823460f, 0.15824567f, 0.28762919f, -0.25977921f, 0.04801792f, 0.03190058f, -0.09970443f, -0.01251211f, 
    0.04525085f, -0.65614051f, -0.77100182f, 0.32064155f, -0.21812998f, 0.04719070f, 0.04561318f, 0.04702392f, 
    -0.03552680f, -0.20955317f, -0.25499275f, -0.71461695f, 0.03401539f, -0.02537173f, -0.19196652f, -0.02155839f, 
    0.11217099f, -0.00303548f, -0.05096797f, -0.25160354f, -0.22256398f, -0.11131000f, 0.06435779f, -0.22969134f, 
    -0.16911128f, -0.11305653f, 0.10522944f, 0.25129130f, -0.50295186f, 0.11403918f, 0.22615035f, -0.20428529f, 
    -0.07729788f, 0.12035919f, 0.14201921f, -0.06824996f, -0.26859289f, 0.09065443f, -0.11695164f, 0.00679631f, 
    0.03638595f, 0.03948386f, 0.00730687f, 0.16702826f, 0.03583855f, 0.30089942f, -0.14123021f, 0.05328537f, 
    0.08790237f, 0.02387200f, -0.04395272f, -0.17905445f, 0.22347088f, 0.00336821f, 0.14556861f, -0.04021313f, 
    0.37595496f, 0.05594514f, -0.23503579f, 0.39276674f, -0.16676915f, 0.02681256f, -0.06285306f, 0.24328102f, 
    0.23497108f, -0.32372233f, 0.25599295f, -0.10902280f, 0.15510233f, -0.03256721f, 0.35393003f, -0.26014444f, 
    -0.34012935f, 0.17096862f, -0.24512999f, -0.17457616f, -0.20903820f, -0.21577454f, -0.12124458f, 0.05608165f, 
    -0.04862924f, 0.10429627f, -0.31902489f, -0.46323037f, -0.11773673f, -0.34156215f, -0.23286985f, -0.14449403f, 
    -0.08554595f, 0.07406561f, -0.08357891f, -0.18621260f, -0.33683687f, 0.06464355f, -0.15763888f, -0.14769351f, 
    0.06687980f, -0.35580373f, -0.41382059f, -0.30744696f, -0.17678471f, 0.22324014f, -0.05992350f, -0.26549241f, 
    0.05272674f, -0.08681851f, 0.10566705f, 0.04143039f, 0.47704569f, 0.09972899f, -0.57208943f, 0.00508136f, 
    -0.06951663f, -0.13019906f, -0.04508885f, -0.06971275f, 0.04418956f, 0.10128042f, 0.24132626f, -0.23349442f, 
    -0.08370074f, -0.11751561f, -0.09011738f, -0.00335522f, 0.04259383f, 0.04693156f, 0.14388028f, 0.00034239f, 
    -0.29468939f, -0.12974748f, -0.17690901f, 0.14410612f, 0.25143933f, -0.10268921f, 0.15984403f, 0.17339839f, 
    -0.39395165f, -0.20426103f, 0.13149709f, 0.10461450f, -0.15959582f, -0.15549152f, 0.02272347f, -0.01292840f, 
    0.24210201f, -0.13152438f, -0.81125647f, -0.38767290f, 0.00297959f, -0.22524361f, 0.30708143f, 0.02043921f, 
    0.13934793f, -0.13817832f, 0.28625289f, 0.21911329f, 0.36361536f, -0.33378607f, 0.18352714f, -0.19200367f, 
    0.15341215f, -0.09622635f, -0.00245189f, -0.28281552f, -0.20296510f, -0.32400331f, -0.21605392f, -0.05741147f, 
    -0.15615945f, 0.02190845f, 0.18155324f, 0.30350053f, 0.52225685f, -0.25483945f, 0.11618942f, -0.09981986f, 
    0.02603919f, -0.10845448f, 0.02931469f, -0.03956434f, -0.06415349f, 0.26088065f, -0.30333245f, 0.66147059f, 
    0.04537537f, 0.08111127f, -0.18842727f, -0.00404698f, -0.13294460f, 0.21238741f, -0.23930286f, 0.21437024f, 
    0.01619755f, -0.02691399f, -0.18849555f, -0.07782241f, 0.08641250f, 0.18262215f, 0.42878395f, -0.31486329f, 
    -0.34666708f, -0.51418924f, 0.03873884f, -0.05233707f, -0.18671626f, 0.20791689f, 0.06374519f, -0.09254611f, 
    0.19925764f, 0.05810540f, 0.15912554f, -0.22365947f, -0.06483897f, -0.11534926f, 0.09936547f, 0.06543670f, 
    0.12719376f, 0.01429827f, -0.23179297f, 0.20044205f, -0.01588687f, -0.04880035f, 0.31913626f, -0.04121231f, 
    0.02702119f, 0.04270769f, -0.34181488f, 0.55831212f, 0.09782764f, 0.07933543f, 0.02640623f, -0.06623935f, 
    0.18053927f, 0.11771201f, -0.16690783f, -0.01273495f, 0.08201172f, 0.25319329f, -0.22090313f, -0.10498283f, 
    -0.21896423f, 0.11484848f, -0.03567230f, 0.28507465f, -0.24000175f, -0.57180673f, -0.23857765f, -0.07827547f, 
    0.07951894f, 0.09058177f, 0.02739607f, 0.00174720f, 0.19146514f, -0.76087874f, -0.58011037f, 0.06282575f, 
    -0.03251327f, -0.06041137f, 0.13224067f, 0.15164919f, 0.05280152f, 0.03309871f, -0.08946502f, -0.21092829f, 
    -0.13811098f, 0.09533468f, -0.19640701f, -0.22500001f, 0.25840127f, 0.19395907f, -0.02100854f, -0.23357211f, 
    -0.06254345f, -0.61093324f, -0.39453173f, 0.20061451f, 0.19182348f, 0.18488283f, 0.06657114f, 0.24287234f, 
    -0.01427075f, 0.14655590f, -0.51356471f, 0.09713201f, -0.19393484f, 0.04622794f, -0.05568509f, -0.07377532f, 
    0.02217272f, 0.25718039f, -0.30039760f, -0.32416525f, 0.05180556f, 0.06710158f, 0.14590637f, 0.19762389f, 
    0.25466731f, -0.14758411f, -0.42307633f, 0.24426167f, -0.04959276f, -0.01922364f, 0.04309272f, 0.12890041f, 
    0.09113511f, -0.06981423f, -0.18926556f, -0.22370888f, 0.16964936f, -0.12126681f, 0.17112224f, 0.24536458f, 
    0.18952401f, 0.08536822f, 0.11865173f, 0.09093665f, -0.02831611f, 0.16692300f, -0.23829775f, 0.08005504f, 
    0.23764522f, -0.01546691f, 0.09321035f, -0.03999322f, -0.00801542f, -0.14623724f, -0.43358442f, -0.25113356f, 
    0.07115460f, 0.13184239f, 0.09162258f, -0.11970130f, 0.01448772f, 0.20974340f, 0.06400983f, -0.12123740f, 
    -0.05454880f, -0.17532562f, -0.03424234f, 0.02291625f, -0.06308599f, -0.01646297f, 0.02722233f, 0.16741776f, 
    0.03984543f, 0.47131255f, -0.03140545f, 0.11608174f, -0.09203876f, 0.05444222f, 0.14002645f, 0.29548806f, 
    -0.08695262f, -0.63745624f, -0.38585258f, -0.22503871f, 0.26108697f, 0.00862820f, -0.11345506f, -0.27922535f, 
    0.15390497f, -0.03068847f, 0.03686984f, 0.22702181f, 0.13900967f, -0.20016871f, -0.04438049f, -0.05273208f, 
    0.02606815f, 0.07206896f, -0.01741164f, 0.23741031f, -0.13277954f, -0.18298727f, 0.05591087f, -0.22687586f, 
    0.02950967f, 0.20118037f, 0.33268288f, -0.37979969f, 0.29684949f, -0.16104446f, -0.02159534f, -0.08025503f, 
    -0.17379238f, 0.02365223f, -0.10237553f, -0.03053431f, 0.23392601f, 0.28616780f, 0.28138077f, 0.04418278f, 
    -0.01272225f, -0.06352711f, 0.18373074f, 0.15912612f, 0.20611274f, -0.43218112f, 0.12652883f, -0.07029419f, 
    -0.05892836f, -0.02601998f, -0.28581965f, -0.03902601f, 0.17078049f, -0.25315493f, -0.29043579f, 0.23672116f, 
    -0.06495658f, 0.01404174f, -0.23569831f, -0.26682198f, -0.07594131f, -0.11562043f, 0.12695979f, -0.22665481f, 
    -0.22484168f, -0.20719427f, 0.07034864f, 0.10369918f, -0.08383097f, 0.00065013f, -0.00005297f, -0.01516683f, 
    -0.06429546f, -0.04937882f, 0.24156313f, 0.04721304f, -0.12057847f, 0.05163563f, -0.08701848f, -0.00854149f, 
    0.10416795f, -0.36566052f, -0.01350813f, -0.02001605f, -0.01043993f, 0.20797870f, 0.08438078f, -0.14255776f, 
    0.04923692f, -0.00383549f, 0.05497120f, -0.14638907f, -0.56692314f, -0.26153404f, -0.05434344f, -0.05557685f, 
    0.02593711f, -0.04319780f, 0.00530078f, -0.21998157f, -0.21364766f, -0.28936172f, 0.01604184f, -0.00314586f, 
    -0.15828195f, 0.01900083f, 0.02986565f, 0.11689259f, -0.31870493f, 0.37004831f, -0.36756936f, 0.18290547f, 
    0.28360343f, 0.00295375f, 0.11256436f, 0.02046631f, -0.07310876f, -0.25602210f, -0.93560225f, -0.00573709f, 
    -0.12335489f, 0.39113942f, -0.24020845f, 0.03432506f, 0.11742958f, -0.20132305f, -0.00597568f, -0.01506466f, 
    -0.34777111f, 0.11277843f, 0.30369043f, 0.22950831f, 0.02425412f, 0.27648214f, 0.10540641f, 0.06396536f, 
    0.31346124f, 0.16499086f, -0.05175475f, -0.09701912f, 0.15368614f, 0.16369113f, -0.13938439f, 0.05376190f, 
    -0.14520945f, -0.13944516f, -0.14318518f, -0.14316243f, -0.22835603f, 0.26428738f, 0.23135184f, 0.06316004f, 
    0.16214277f, -0.30210942f, 0.11968940f, -0.06527238f, 0.07994866f, -0.02476685f, 0.05781522f, -0.27458295f, 
    0.07248310f, -0.06021832f, 0.25173402f, -0.37410519f, 0.11895172f, 0.04731192f, 0.01003220f, -0.09457082f, 
    -0.17477156f, -0.12223107f, 0.03156648f, 0.16378403f, 0.04938117f, -0.09930616f, -0.02569546f, 0.05693919f, 
    0.02595265f, 0.03017381f, 0.09230994f, 0.00379611f, 0.17004740f, -0.53437507f, -0.37564310f, -0.00312580f, 
    0.14422634f, 0.07372819f, -0.07163887f, 0.04352465f, 0.05113306f, 0.28269708f, -0.25619763f, -0.32086575f, 
    0.03616389f, -0.00617630f, 0.15247479f, 0.20331438f, 0.12331443f, -0.09499171f, -0.16204013f, -0.12987432f, 
    0.58170158f, 0.18366955f, -0.22994713f, 0.00199967f, 0.13839039f, 0.04378726f, 0.16415136f, 0.13883424f, 
    -0.35315669f, -0.25305593f, -0.05891273f, -0.41262805f, -0.29322821f, 0.00186668f, 0.04904499f, -0.01819447f, 
    -0.16847554f, -0.12707752f, 0.11214927f, -0.22327624f, 0.01045359f, -0.19597343f, 0.13714372f, -0.09239004f, 
    -0.01276274f, -0.30893421f, 0.13786808f, 0.24630600f, 0.18147428f, 0.18432112f, 0.06955338f, 0.08327030f, 
    -0.03446176f, 0.09536351f, -0.18683137f, -0.04017404f, 0.28805417f, 0.11948071f, 0.29150724f, 0.08109847f, 
    0.28223053f, 0.16395833f, -0.03328361f, 0.16176698f, -0.02253843f, 0.02070725f, 0.15530455f, 0.21695633f, 
    0.25208086f, 0.25830022f, 0.07134017f, -0.16206302f, -0.03855952f, 0.36576563f, 0.19394040f, -0.11828913f, 
    -0.07210460f, 0.26937386f, -0.09203684f, 0.19970813f, 0.11802261f, -0.01440320f, 0.35428247f, 0.11723037f, 
    0.05440482f, -0.03843091f, 0.04711559f, 0.11038470f, 0.04008259f, 0.10838867f, -0.22967830f, 0.04730335f, 
    0.10379016f, -0.14442830f, -0.11247115f, -0.10257145f, 0.06106462f, -0.12395699f, -0.00145424f, -0.15272519f, 
    0.07324009f, -0.23433605f, -0.09428358f, -0.04506582f, -0.04318641f, 0.12757583f, 0.16073154f, 0.10459234f, 
    -0.09162452f, -0.08834378f, -0.28422469f, -0.00873659f, -0.05836866f, -0.24038260f, -0.11166068f, -0.19941641f, 
    -0.11627012f, 0.13584065f, -0.30600423f, -0.14037095f, 0.06368364f, 0.22485819f, 0.08931798f, -0.09162271f, 
    -0.00759949f, 0.18335818f, -0.22652519f, -0.03755302f, 0.02903559f, 0.09894617f, -0.07205397f, -0.06104593f, 
    -0.00515740f, -0.07255166f, 0.04974491f, -0.38685149f, -0.04424150f, 0.07661697f, -0.01489022f, 0.02871457f, 
    -0.28697166f, -0.01958739f, -0.04224226f, -0.06843797f, 0.15966062f, -0.07322405f, -0.16426568f, -0.09340501f, 
    0.08298516f, 0.21291378f, 0.12454983f, 0.29166874f, 0.22535194f, 0.23319232f, -0.20404713f, 0.06409093f, 
    -0.13318864f, 0.21385144f, -0.04113975f, -0.10813147f, 0.07443081f, 0.30345148f, 0.03269660f, -0.09899657f, 
    -0.04417720f, -0.12113341f, 0.05180618f, 0.03050843f, -0.19779012f, -0.15393001f, 0.20306069f, -0.32787374f, 
    0.14724267f, 0.12444338f, -0.03795304f, 0.08127138f, 0.22334130f, 0.08093066f, -0.03074968f, -0.07165505f, 
    -0.10209516f, 0.14781220f, 0.03057402f, 0.00067206f, -0.00443565f, -0.02660144f, 0.14928578f, -0.06960443f, 
    -0.01400672f, 0.32823029f, 0.00329031f, 0.18313415f, 0.21688627f, 0.20391020f, 0.16642109f, -0.00655360f, 
    0.04205674f, 0.15449439f, -0.07228869f, -0.20290035f, -0.50143033f, -0.10191191f, -0.10634751f, -0.48752323f, 
    -0.01941566f, -0.07204273f, 0.05141378f, 0.01703922f, 0.00630573f, 0.00747921f, -0.12819783f, 0.05660743f, 
    0.17351733f, 0.07267637f, 0.02823229f, 0.20316021f, 0.14793122f, 0.07982693f, 0.21961652f, 0.13446042f, 
    0.28589490f, 0.10404992f, 0.13243759f, 0.25382271f, 0.24221613f, -0.12026522f, -0.20375617f, -0.05743277f, 
    -0.27290621f, 0.02446096f, -0.00920064f, 0.00800666f, -0.15295294f, -0.19531961f, -0.95162690f, 0.36461064f, 
    -0.02522913f, 0.15207164f, -0.00955709f, 0.24155577f, 0.19420795f, 0.09896851f, -0.24241132f, -0.31781903f, 
    -0.08230194f, 0.28208545f, 0.11432886f, 0.06432970f, 0.03118690f, 0.27303359f, 0.14713383f, -0.05529312f, 
    -0.43665135f, -0.46639949f, -0.12385389f, 0.01064116f, 0.04394510f, -0.07742681f, -0.06909612f, -0.02627188f, 
    -0.12209206f, 0.33949792f, 0.05827327f, 0.12997018f, -0.07440196f, 0.22893633f, 0.13381879f, -0.15922728f, 
    0.14661536f, 0.23986013f, -0.00414585f, -0.17543489f, -0.68027771f, 0.01126548f, 0.13772981f, 0.05429716f, 
    -0.12532398f, -0.13569820f, -0.14077745f, -0.27754754f, -0.05645746f, -0.39518669f, -0.13511844f, -0.07649089f, 
    -0.01515035f, 0.09864382f, 0.02152994f, -0.05730325f, -0.25219214f, 0.22334355f, 0.15674548f, 0.01352507f, 
    -0.04089945f, 0.07413795f, 0.03952593f, 0.19905710f, 0.19212891f, -0.20045313f, 0.26416332f, 0.09935429f, 
    0.09846760f, 0.06489179f, -0.06826254f, -0.02319208f, -0.03939095f, 0.32367086f, -0.10000329f, -0.00728913f, 
    -0.12376843f, 0.08105442f, 0.06523856f, 0.00613380f, 0.11053666f, 0.06892501f, 0.06748590f, -0.12386786f, 
    0.09794945f, -0.11037532f, 0.12508972f, 0.10989588f, 0.07694387f, -0.04906757f, 0.07896391f, 0.16053244f, 
    0.17848124f, -0.06465907f, 0.12124742f, -0.03649531f, -0.19885996f, -0.19320704f, -0.03201570f, 0.02297161f, 
    -0.01559844f, 0.11322384f, -0.27392372f, -0.51401019f, 0.06754882f, 0.11004274f, 0.11871701f, -0.02415790f, 
    -0.07042851f, -0.10895384f, -0.15832917f, 0.14065610f, 0.06822807f, -0.01912921f, -0.21550477f, 0.18558796f, 
    0.07965031f, -0.05606757f, -0.01955758f, 0.24460685f, -0.31670088f, -0.00323639f, 0.23316234f, 0.07833771f, 
    -0.20495141f, 0.08141389f, 0.05733833f, 0.02241921f, 0.17846850f, -0.08657787f, 0.04981769f, -0.11309321f, 
    0.05034454f, -0.21228655f, -0.18271564f, -0.12690264f, 0.37483016f, -0.03072598f, -0.46780375f, 0.20806468f, 
    0.02176666f, 0.03597279f, -0.00203828f, 0.18260060f, 0.22259212f, 0.00589016f, 0.52760625f, 0.01806627f, 
    0.19822313f, 0.06917196f, -0.22449684f, -0.18342467f, 0.10942661f, 0.07207272f, 0.02486533f, 0.33031389f, 
    0.03328302f, 0.28079924f, 0.02071640f, -0.19782370f, 0.16629216f, 0.08559120f, 0.02619033f, 0.13172793f, 
    0.04449829f, 0.16549534f, 0.02306651f, -0.39740181f, -0.18281356f, -0.10338468f, -0.19955353f, -0.27293587f, 
    -0.07347748f, 0.25452644f, 0.14144289f, 0.29035607f, 0.06143575f, -0.40683144f, -0.07956013f, 0.09534679f, 
    0.12767760f, 0.16431883f, 0.06317330f, 0.03626445f, -0.21291435f, -0.09542380f, -0.25766042f, -0.05367242f, 
    0.09515956f, 0.22006148f, 0.05496346f, 0.04755769f, -0.16062579f, 0.15737204f, -0.08916929f, -0.03701159f, 
    0.10436264f, 0.06124683f, -0.13370162f, -0.17514645f, -0.09754688f, 0.00817423f, 0.28448898f, 0.07719868f, 
    -0.05970348f, 0.16275716f, 0.06385164f, 0.34177074f, 0.02844247f, 0.11595854f, 0.13924892f, -0.06408658f, 
    0.06024555f, -0.15151824f, -0.11852401f, -0.04208409f, 0.21491942f, -0.09810571f, 0.26396668f, 0.13609938f, 
    0.14589207f, 0.03889332f, -0.21052219f, -0.16024244f, 0.13160400f, 0.11433491f, 0.13359421f, -0.02900511f, 
    -0.49168500f, -0.22704367f, 0.00434339f, -0.09824928f, 0.02933882f, -0.00640959f, 0.09493090f, -0.10337070f, 
    0.15227956f, -0.00883726f, -0.01026505f, 0.01374124f, -0.02632144f, 0.12627037f, -0.07931360f, 0.06331903f, 
    -0.10014509f, 0.20522127f, -0.05245890f, -0.29223230f, 0.20412214f, -0.09218150f, -0.07394996f, -0.02204602f, 
    0.14980423f, -0.05367554f, -0.15089671f, 0.07089724f, 0.17344487f, -0.22324082f, -0.13729320f, -0.26648572f, 
    -0.08895030f, 0.02919014f, -0.00817399f, 0.10794902f, -0.18369445f, -0.02533127f, 0.04717647f, 0.06107864f, 
    0.01417846f, 0.17788862f, 0.46510306f, -0.15851079f, 0.10548893f, 0.02722287f, -0.00918881f, 0.02839296f, 
    0.01959073f, 0.09349537f, 0.08958296f, -0.05553193f, 0.12766367f, 0.04283415f, -0.12412608f, -0.20423673f, 
    -0.11139400f, -0.07894929f, -0.02901294f, -0.38019967f, -0.18262593f, -0.07557214f, 0.03491920f, -0.38769212f, 
    -0.09552081f, 0.09366243f, -0.08770783f, -0.06721956f, 0.09593230f, -0.33409873f, 0.05652175f, 0.19268291f, 
    -0.04596188f, 0.24757743f, -0.04689532f, -0.22145838f, 0.05399309f, 0.11691725f, -0.01367687f, -0.08182772f, 
    -0.14139563f, -0.35753646f, 0.10072794f, -0.17066641f, -0.28409427f, -0.13695852f, 0.10678934f, 0.09930168f, 
    -0.03451648f, 0.12681206f, 0.16539793f, -0.01601305f, 0.03398166f, -0.02135765f, -0.08355559f, -0.04898130f, 
    0.04000704f, 0.15505332f, 0.29013595f, -0.31676832f, 0.14619334f, 0.16095966f, -0.13460286f, -0.29717380f, 
    -0.27147913f, -0.28023568f, -0.06389640f, -0.03549141f, 0.11560046f, 0.29053339f, -0.01245231f, -0.20822959f, 
    -0.05768766f, 0.10377548f, 0.21764448f, 0.03382434f, 0.07077395f, -0.22372748f, -0.15028571f, 0.05507866f, 
    -0.03778071f, 0.07098944f, 0.27004123f, 0.18269147f, 0.05215189f, 0.08291911f, -0.15616482f, -0.30732200f, 
    -0.10371589f, -0.03340045f, 0.19794780f, 0.03343508f, -0.09514781f, -0.14068513f, 0.24374107f, -0.00516754f, 
    0.27197790f, 0.07414863f, -0.16855752f, 0.02806200f, 0.10373598f, 0.26496857f, -0.08521792f, 0.00323134f, 
    -0.04060978f, -0.08364806f, -0.09839130f, -0.09404327f, 0.07048237f, -0.34792912f, -0.18002410f, 0.04470485f, 
    -0.29825589f, 0.03781639f, 0.31170830f, -0.00636966f, -0.24102362f, 0.00661582f, 0.07949587f, 0.19120605f, 
    -0.06780006f, 0.05238337f, 0.43336543f, 0.06620537f, -0.30561465f, 0.07876439f, -0.02127752f, -0.21232563f, 
    -0.00004612f, -0.01777979f, -0.42650184f, -0.11278007f, 0.00014416f, -0.18314140f, 0.21080476f, -0.29607737f, 
    0.03170066f, -0.02999614f, 0.04291680f, 0.24113944f, 0.27246371f, 0.33312246f, 0.03576225f, 0.39592624f, 
    -0.10402259f, 0.06777896f, 0.07976077f, 0.19113362f, -0.75629354f, 0.18912806f, 0.12279010f, -0.03240955f, 
    -0.07104708f, -0.04771554f, -0.24855441f, 0.04985805f, 0.19079611f, -0.12735713f, 0.06606452f, 0.23804507f, 
    0.12336800f, 0.18667442f, 0.04801393f, 0.07532174f, 0.05664180f, 0.02384746f, 0.05584590f, -0.02530666f, 
    0.13967432f, -0.05144114f, -0.02863420f, -0.05241519f, 0.07121249f, -0.02074736f, 0.16474694f, 0.02410094f, 
    0.38362107f, 0.62953454f, 0.16711046f, 0.01884728f, -0.04268229f, 0.03221410f, 0.03150709f, 0.07613797f, 
    -0.40256178f, 0.22076328f, -0.10604181f, 0.07752839f, -0.08658490f, 0.00116263f, -0.04367556f, -0.10146718f, 
    -0.29463121f, -0.25753167f, 0.35693088f, 0.33916932f, 0.00546798f, 0.11017626f, -0.26678699f, -0.09297135f, 
    0.31351182f, -0.10428405f, 0.13931166f, 0.00341056f, -0.13197012f, 0.18332334f, -0.08771107f, 0.02704720f, 
    0.00012000f, -0.03958292f, -0.14350373f, -0.64179742f, -0.56835580f, 0.35366842f, -0.05252326f, 0.22926643f, 
    -0.21438788f, -0.07557587f, 0.09539228f, 0.05929067f, -0.15198822f, 0.22135399f, 0.19504078f, -0.06845798f, 
    0.06489829f, 0.00424168f, 0.05546345f, 0.05883011f, 0.17430639f, -0.31392732f, 0.01387936f, 0.20504160f, 
    -0.17234445f, 0.01717418f, -0.25480860f, 0.10070473f, 0.25726953f, 0.16131598f, -0.39084226f, -0.35884023f, 
    0.12444932f, 0.06114253f, -0.07660573f, -0.06130637f, 0.15567659f, -0.00003420f, 0.00142480f, -0.23448242f, 
    0.15088177f, 0.17018548f, 0.11225827f, 0.00539753f, 0.18535791f, 0.09973923f, 0.02343647f, 0.04453088f, 
    -0.25300536f, 0.10834736f, -0.29852325f, 0.09808417f, -0.00462189f, -0.19477606f, 0.08784754f, -0.07178018f, 
    -0.05654469f, -0.23591904f, -0.18442784f, -0.28354016f, 0.02056094f, 0.20695123f, -0.10025522f, -0.02755201f, 
    0.09327280f, 0.14717619f, -0.22481714f, -0.12303790f, 0.25882688f, -0.02345863f, -0.23606785f, -0.07557385f, 
    0.01098688f, -0.10772054f, -0.06180518f, -0.21583042f, -0.34132057f, -0.22066776f, -0.06383753f, -0.15777394f, 
    0.20452669f, -0.04475709f, 0.03295789f, 0.22328438f, -0.04367615f, 0.34751409f, 0.26246971f, 0.02015279f, 
    -0.11759628f, 0.18193913f, 0.07211058f, 0.20410915f, -0.01035637f, -0.26293764f, 0.04271126f, -0.54916835f, 
    0.06212988f, -0.28255227f, 0.00105100f, -0.14681004f, 0.01207346f, 0.03095107f, 0.28023279f, 0.17898507f, 
    0.45612672f, -0.07054225f, 0.42364684f, 0.00017947f, 0.05834082f, 0.18903571f, 0.03954915f, -0.09891699f, 
    0.16065072f, 0.16606115f, -0.21882856f, -0.00431684f, -0.23104122f, -0.02881316f, -0.06512452f, -0.04471311f, 
    -0.28075603f, -0.22734857f, 0.44305283f, -0.01945667f, 0.02070912f, -0.08771229f, 0.15340458f, 0.00130130f, 
    -0.03560656f, -0.26856053f, 0.05128416f, -0.07414614f, 0.10481205f, -0.10273834f, -0.14878553f, -0.08188339f, 
    0.14431405f, 0.02547089f, -0.04991587f, -0.12317174f, -0.42540520f, -0.00910678f, -0.05294833f, -0.00963001f, 
    0.16069835f, -0.29408482f, -0.06358718f, 0.04546004f, 0.21509604f, 0.54300839f, -0.02854045f, 0.11292865f, 
    0.21418653f, 0.00970855f, -0.05403231f, 0.14966443f, 0.00182694f, -0.00994497f, 0.02944864f, 0.13572094f, 
    0.23088203f, 0.14428273f, 0.13438040f, 0.23177199f, 0.12381785f, -0.18119821f, -0.07372472f, -0.86693394f, 
    -0.18780756f, 0.17590441f, -0.19541675f, -0.21876419f, -0.17587577f, 0.04291441f, -0.62330210f, 0.13859080f, 
    -0.70407951f, -0.23831746f, -0.00815720f, -0.22607268f, -0.03253805f, -0.10740293f, 0.07451160f, -0.11288646f, 
    -0.20064248f, -0.17273870f, -0.20051400f, 0.02974504f, -0.01426324f, -0.10299994f, 0.00859892f, 0.29361677f, 
    0.04516445f, -0.00591729f, 0.17945945f, -0.21913017f, 0.13545482f, 0.17105044f, 0.00480529f, -0.01594054f, 
    0.08716813f, -0.51568323f, 0.10241395f, -0.00580275f, -0.12327655f, 0.13831230f, -0.14048412f, 0.09127775f, 
    -0.02737899f, 0.22631136f, 0.09588560f, 0.22376055f, 0.05122537f, 0.09521499f, 0.18637900f, -0.05054362f, 
    0.01459421f, 0.12236157f, -0.11106082f, 0.17692523f, 0.09408152f, 0.18315889f, 0.16734360f, -0.07356734f, 
    -0.09982057f, 0.21742509f, 0.14485525f, -0.14537741f, -0.12688820f, 0.07711889f, -0.00155857f, -0.01660189f, 
    -0.02199828f, 0.23016834f, 0.00702871f, -0.08922010f, -0.04474008f, -0.07029621f, 0.06132757f, 0.05976636f, 
    0.04261923f, 0.14631924f, -0.16735327f, -0.17861895f, 0.00320224f, -0.02550798f, 0.02723628f, 0.04624758f, 
    -0.09792808f, 0.15537937f, 0.04945758f, 0.12525979f, 0.04366291f, 0.04109318f, -0.07524763f, 0.04503640f, 
    0.08032888f, -0.05978068f, -0.15174834f, 0.07965051f, -0.16521253f, 0.05183145f, -0.08760912f, -0.08242978f, 
    -0.24052277f, -0.11656369f, -0.02514501f, -0.01907143f, 0.02567780f, 0.01786455f, 0.06430931f, 0.24133295f, 
    0.22707070f, 0.30251479f, 0.40781695f, 0.11455667f, -0.27317318f, -0.02863675f, -0.23277895f, -0.00866608f, 
    0.01468510f, -0.15192698f, -0.20580943f, -0.28062201f, -0.07581469f, 0.08332086f, 0.07508753f, -0.00373568f, 
    -0.13656384f, -0.11330620f, -0.04192386f, 0.29850137f, 0.14049956f, 0.06631558f, -0.05303172f, 0.11664440f, 
    -0.08340846f, -0.05080228f, 0.08342183f, -0.15090218f, 0.06244009f, 0.12620766f, 0.08874033f, -0.12073152f, 
    0.09479983f, -0.23297131f, -0.12439267f, -0.08928111f, -0.10427160f, 0.15720680f, 0.05755600f, 0.19851488f, 
    0.16025032f, -0.07051645f, -0.11033696f, -0.13899985f, 0.11177640f, -0.31659421f, 0.27955741f, 0.25580013f, 
    0.07297618f, -0.11667107f, 0.01275511f, -0.08490070f, 0.02746855f, 0.04831359f, -0.31240132f, -0.36636284f, 
    0.02124931f, -0.00170153f, 0.05289024f, 0.07660131f, -0.22088870f, -0.10890687f, -0.09248935f, 0.05292655f, 
    -0.21928343f, -0.01510172f, -0.06978472f, 0.10785313f, 0.06145439f, -0.08496869f, -0.01800677f, 0.14411104f, 
    -0.12556641f, 0.09548845f, 0.16000257f, 0.21778905f, 0.02842025f, -0.03648928f, 0.06877707f, 0.06538989f, 
    0.14038746f, -0.11681520f, -0.01249972f, 0.06904102f, 0.17730552f, -0.03124698f, 0.09557093f, 0.38081345f, 
    -0.01099030f, 0.11639526f, 0.20425381f, -0.10414099f, -0.08345791f, 0.03779670f, 0.14620303f, -0.04794391f, 
    0.07775717f, -0.20040101f, -0.16576058f, -0.48479581f, 0.19548884f, -0.23915118f, 0.32023072f, 0.14325088f, 
    0.17588642f, 0.10575353f, 0.17092460f, 0.00118506f, 0.02369107f, -0.56069732f, -0.26427484f, -0.17616379f, 
    0.08143145f, -0.14903304f, 0.14211924f, -0.08142041f, -0.03889560f, 0.29482269f, 0.35474369f, -0.13444752f, 
    0.31305110f, 0.05918083f, -0.13269046f, 0.02777664f, 0.09276585f, -0.22800931f, -0.07621773f, 0.40429869f, 
    0.28689978f, 0.18956220f, -0.05916718f, -0.11782468f, 0.07543632f, 0.16326074f, 0.08283445f, -0.16441032f, 
    -0.29597175f, 0.07741667f, -0.01222745f, -0.10949693f, 0.04994799f, 0.28830144f, 0.04149140f, 0.00971108f, 
    0.31102487f, 0.10285413f, 0.14489342f, 0.23959562f, -0.19290495f, -0.08648139f, 0.01688732f, 0.00626050f, 
    0.04951468f, -0.01536283f, -0.18264921f, 0.09750178f, 0.01390290f, 0.12410989f, -0.30314547f, 0.04228419f, 
    -0.02936317f, 0.27596477f, 0.13809605f, -0.03567844f, -0.06645881f, 0.41519460f, 0.00604652f, -0.17066234f, 
    0.09714668f, -0.04252358f, 0.00683672f, -0.06898145f, -0.18305363f, -0.00937778f, 0.01570304f, -0.04480154f, 
    0.12669350f, -0.08122263f, -0.00065627f, -0.16936219f, -0.18655729f, -0.55465037f, -0.34550434f, -0.01371013f, 
    -0.00868648f, 0.23910099f, -0.02325078f, 0.06031616f, 0.21439692f, 0.18674640f, 0.20772994f, 0.35398763f, 
    0.02989796f, -0.03632727f, -0.21444611f, 0.08439995f, 0.11725421f, -0.15988652f, -0.35542971f, -0.25139228f, 
    -0.10169282f, -0.03328101f, 0.11366105f, 0.23541480f, -0.00623859f, -0.05816527f, -0.02348965f, -0.19174956f, 
    0.44044545f, 0.19552712f, 0.11940927f, -0.15668559f, -0.03231189f, -0.04454120f, -0.00075100f, -0.01005532f, 
    -0.19619717f, 0.20057116f, 0.26893103f, -0.43467382f, -0.35246447f, 0.03823701f, -0.12099907f, 0.13120206f, 
    -0.06511655f, -0.31864882f, -0.06734239f, -0.14923763f, 0.11721081f, -0.16741249f, 0.15955128f, -0.10603565f, 
    0.26251754f, 0.04665407f, 0.16303916f, -0.94538987f, 0.00214556f, 0.45947757f, 0.00300798f, 0.31278428f, 
    -0.20450881f, -0.12875335f, 0.13307463f, -0.03258975f, -0.24929972f, 0.09194344f, 0.17957135f, -0.12088380f, 
    -0.10340058f, -0.02126886f, 0.11218291f, -0.03208800f, -0.06562185f, 0.19551916f, -0.25071400f, -0.21182810f, 
    0.13296835f, 0.09163532f, 0.02285310f, 0.05657185f, 0.09500991f, 0.12242012f, 0.57265848f, -0.10038843f, 
    -0.24710885f, -0.15479825f, -0.06387190f, 0.07992083f, -0.03004044f, -0.00000580f, -0.03038626f, 0.02918628f, 
    0.02219102f, 0.11023769f, 0.01079110f, -0.02463304f, -0.05625905f, -0.05348315f, 0.16338114f, 0.05601154f, 
    0.02780684f, -0.11731523f, -0.37788105f, -0.24285358f, -0.14862908f, 0.06920005f, 0.14214756f, 0.02735993f, 
    -0.31702772f, -0.31078634f, -0.34663245f, -0.09198996f, 0.00792906f, -0.01821241f, 0.15168957f, 0.20284919f, 
    0.05021140f, 0.06718684f, 0.30967230f, 0.04294198f, 0.11125910f, -0.24905978f, -0.21753700f, -0.39456433f, 
    -0.06595436f, -0.10524062f, -0.13468574f, 0.01370095f, 0.00175345f, 0.18551433f, -0.21984448f, 0.14296253f, 
    -0.22320829f, -0.11967054f, -0.09546488f, 0.09637528f, -0.57174748f, -0.34060466f, 0.38031182f, -0.00254999f, 
    0.15708187f, 0.02309705f, 0.03066835f, 0.07716054f, 0.33565369f, -0.10453404f, 0.01944703f, 0.23135307f, 
    -0.10124464f, 0.01170762f, -0.07465331f, 0.06630699f, -0.07489421f, 0.12775432f, 0.01913976f, -0.19584683f, 
    0.13097455f, -0.06876884f, -0.01176226f, 0.07711395f, 0.20449637f, -0.18018931f, 0.09215999f, 0.29548424f, 
    0.14409898f, -0.18097688f, -0.03724316f, 0.14191122f, 0.24813384f, 0.15714298f, -0.02309789f, -0.05752563f, 
    0.02107108f, 0.04150245f, 0.17509545f, -0.03234971f, -0.00114698f, -0.31488982f, 0.02746189f, -0.16478656f, 
    -0.08950601f, -0.21716920f, -0.04681672f, -0.09825819f, 0.18763950f, 0.00041961f, 0.11646976f, -0.06160767f, 
    0.07957897f, 0.05163441f, 0.15822114f, 0.18421128f, -0.00489050f, -0.17957285f, -0.10925350f, -0.13375187f, 
    0.05075466f, 0.05521268f, -0.20610072f, 0.16681890f, -0.10380408f, 0.02449726f, 0.09135949f, 0.07010403f, 
    0.05316941f, -0.01703482f, 0.09636961f, 0.07828695f, 0.13044922f, -0.04309942f, 0.11834367f, -0.20768656f, 
    -0.01911338f, -0.14761019f, 0.01861387f, 0.17286994f, -0.03852456f, 0.20769469f, 0.17313191f, 0.18085651f, 
    -0.18452898f, -0.12525724f, 0.04407224f, -0.02252934f, -0.33693385f, -0.00626008f, 0.16877051f, -0.20276627f, 
    0.14197995f, -0.04519986f, 0.33134416f, -0.10251966f, -0.07355852f, 0.39186928f, 0.02882558f, -0.27866849f, 
    0.06192933f, -0.06728083f, -0.18251288f, 0.00374091f, -0.21022440f, 0.01051464f, 0.06426381f, 0.02238668f, 
    0.37256911f, 0.00922193f, 0.17642613f, -0.08481066f, -0.11905566f, -0.39122128f, 0.19465098f, 0.11329883f, 
    -0.08433890f, -0.08283160f, 0.05121887f, 0.02292374f, 0.04305819f, 0.00300763f, 0.12613612f, 0.03908054f, 
    0.17341688f, 0.26538813f, -0.23578435f, 0.15528198f, -0.10672342f, 0.16323255f, -0.01187832f, -0.10128206f, 
    0.02516429f, -0.13265586f, 0.17438091f, -0.01263264f, -0.45095715f, -0.06174652f, -0.14200586f, 0.05783178f, 
    0.00535531f, -0.01894740f, 0.09722918f, 0.21248943f, 0.15323630f, 0.09770773f, -0.21220651f, 0.02109971f, 
    -0.03155540f, 0.11967700f, 0.09306441f, 0.14384401f, 0.01936411f, 0.27803251f, 0.07971981f, -0.19644193f, 
    -0.54034519f, -0.00405492f, -0.07313587f, -0.03813962f, -0.04525666f, -0.13678129f, -0.26424709f, 0.00700765f, 
    -0.14284791f, 0.01573313f, -0.07135480f, -0.00013216f, 0.10491102f, 0.21029115f, -0.05251608f, -0.00660133f, 
    0.09764589f, -0.01128751f, -0.28887105f, -0.01091514f, -0.07545628f, -0.00078324f, 0.00963397f, -0.03623763f, 
    0.10534795f, 0.15378331f, 0.06103720f, -0.00257865f, 0.01040788f, -0.02695401f, -0.05534182f, 0.08264642f, 
    0.12027245f, 0.00727988f, 0.06645993f, 0.52332538f, -0.48711941f, 0.14920914f, 0.21456373f, -0.01633241f, 
    0.14402741f, 0.00622062f, -0.37265059f, -0.48614052f, -0.25610843f, -0.00906592f, -0.27181447f, 0.14260018f, 
    -0.15470858f, 0.04881207f, 0.04358177f, 0.17988864f, 0.08678409f, 0.13332203f, 0.03966016f, 0.25730065f, 
    0.22533484f, -0.02700049f, 0.09708993f, -0.06106598f, -0.08387861f, -0.26217356f, -0.15581019f, 0.01404282f, 
    -0.18740653f, -0.11166407f, -0.12113623f, 0.12068754f, 0.07768070f, 0.37286404f, 0.27626047f, 0.10925858f, 
    -0.04044778f, 0.03984588f, 0.02128038f, 0.04029714f, 0.02847640f, 0.12729944f, 0.51425451f, 0.32470760f, 
    0.25016618f, -0.12566543f, -0.08294205f, -0.08566359f, 0.19766501f, 0.16708983f, 0.02025692f, 0.24259861f, 
    0.51322752f, 0.44711980f, 0.01250107f, 0.19326441f, -0.13245554f, -0.01918373f, 0.00153428f, 0.05836467f, 
    -0.11599185f, -0.56654286f, -0.26370156f, 0.09105890f, -0.05200623f, -0.02692300f, -0.00163453f, -0.20087513f, 
    -0.11740801f, -0.25741789f, -0.26695719f, 0.17197613f, 0.12718067f, 0.10582328f, 0.15940410f, -0.20477700f, 
    -0.01211423f, 0.03992471f, 0.19584639f, -0.05196249f, -0.04710448f, -0.05331961f, 0.00423023f, 0.08837312f, 
    0.02271900f, 0.10679398f, 0.09335413f, -0.10217430f, -0.05081322f, 0.10442615f, 0.10124784f, -0.16128759f, 
    -0.03511772f, -0.14506035f, -0.32135490f, -0.20696300f, 0.08012827f, 0.30693468f, 0.25104633f, 0.01285795f, 
    -0.01851076f, -0.02103971f, 0.05317740f, 0.06515944f, 0.03865043f, -0.14214887f, -0.15138140f, -0.13765803f, 
    0.10272863f, -0.11126268f, 0.12619269f, 0.09461737f, 0.37214831f, 0.13661754f, -0.34091944f, -0.09408515f, 
    -0.03983016f, 0.21051502f, 0.08548418f, 0.06924614f, 0.09706834f, -0.07305252f, -0.00689295f, 0.37849399f, 
    0.13192704f, 0.17995179f, -0.30960298f, -0.17304130f, -0.23373467f, 0.07716867f, 0.19687071f, -0.00073449f, 
    -0.11688207f, -0.08382038f, -0.13556997f, -0.05091798f, -0.03993672f, -0.12649429f, 0.05923966f, -0.09203227f, 
    -0.08628663f, -0.18461873f, -0.57876819f, -0.36238083f, -0.00587295f, 0.15913941f, 0.15670709f, -0.16769439f, 
    0.21163186f, 0.07535609f, -0.05222870f, 0.17889324f, 0.19691728f, 0.03462794f, 0.13789752f, -0.05769483f, 
    -0.01749959f, -0.42361850f, -0.07705939f, -0.02552729f, -0.05567107f, -0.12702465f, -0.03745137f, -0.07985693f, 
    0.04246681f, 0.06986991f, 0.08615315f, 0.09566334f, 0.00566099f, -0.00108416f, -0.15600727f, 0.10568386f, 
    0.11651003f, -0.07459907f, -0.02834751f, -0.04186287f, 0.02773959f, -0.24255924f, -0.26059496f, -0.20499502f, 
    0.17557804f, -0.01875577f, -0.05299595f, 0.20388640f, -0.02775002f, -0.23535946f, 0.23384550f, 0.39341849f, 
    0.26708591f, 0.05674832f, 0.32770097f, 0.29351237f, 0.07332300f, 0.27413157f, -0.21313132f, -0.22876939f, 
    -0.15368456f, -0.06221568f, 0.09989581f, -0.06822001f, -0.00255979f, -0.25448021f, -0.23050050f, -0.38542366f, 
    -0.12955196f, 0.15376180f, 0.04986054f, -0.01144283f, 0.07683338f, 0.15628272f, 0.20371607f, -0.16716123f, 
    -0.45004052f, -0.08639967f, -0.39402193f, -0.30138943f, 0.05916846f, 0.05342582f, 0.02135791f, -0.16468441f, 
    0.02256852f, 0.09056890f, -0.02666565f, 0.13614579f, 0.05079867f, 0.13110071f, -0.02106490f, -0.00886586f, 
    -0.08289319f, -0.06891530f, -0.32201260f, 0.36926180f, 0.34140128f, 0.21033242f, 0.16929029f, 0.20653172f, 
    0.09861199f, 0.11819727f, -0.16711394f, 0.03072052f, 0.11034551f, 0.11024018f, -0.06363048f, -0.23407264f, 
    -0.11368929f, 0.01449830f, 0.07290483f, 0.15102950f, 0.07912903f, -0.12755351f, -0.11558784f, -0.00195587f, 
    -0.38263768f, 0.00124708f, 0.00178219f, -0.04269514f, -0.06352911f, -0.09010260f, -0.16636196f, -0.19576350f, 
    -0.04180614f, -0.09840850f, 0.07161801f, -0.11223846f, -0.06955934f, 0.03320915f, -0.25668094f, 0.01557759f, 
    0.06618483f, -0.11301691f, -0.23532674f, 0.11592644f, -0.15354964f, -0.22702223f, 0.03408763f, -0.06810244f, 
    -0.29889506f, -0.00822400f, 0.29262495f, 0.23718105f, -0.19845995f, -0.15866581f, -0.07297557f, -0.17723060f, 
    0.09999726f, -0.14329939f, -0.11594313f, 0.29418349f, 0.16084871f, 0.04180546f, 0.16026945f, -0.26908419f, 
    -0.00074507f, 0.27665287f, -0.29276153f, 0.20198026f, 0.37240818f, 0.11061208f, 0.18434319f, -0.37625840f, 
    0.13676268f, 0.10631962f, -0.17149669f, 0.56961143f, 0.06064282f, -0.06580541f, 0.01761841f, 0.00204764f, 
    0.15198015f, -0.04925016f, 0.15509066f, -0.10513380f, 0.11557063f, 0.06131904f, 0.16652860f, -0.28282034f, 
    -0.05743269f, 0.00420481f, -0.02001967f, 0.31473890f, 0.20481023f, -0.20287870f, 0.26578492f, 0.27186504f, 
    -0.01050707f, 0.11743587f, 0.04713494f, 0.04430051f, 0.06902010f, -0.03824760f, -0.13210726f, 0.22696114f, 
    0.32205260f, -0.12018356f, 0.02899921f, -0.15235083f, -0.08992229f, -0.09451272f, -0.07306319f, 0.11546599f, 
    -0.30077672f, -0.09419494f, -0.10813628f, -0.06099046f, -0.08062775f, 0.05150130f, -0.09710187f, 0.10325422f, 
    -0.10262964f, 0.19712162f, 0.18746077f, -0.08986484f, -0.12044054f, 0.03391715f, -0.23976123f, 0.09879446f, 
    0.26555008f, 0.05569845f, 0.03645765f, 0.15586127f, 0.04299610f, 0.18588562f, -0.08813494f, -0.01583461f, 
    0.13824792f, 0.03372671f, -0.13456638f, 0.13617809f, -0.12004618f, -0.39245668f, -0.26746669f, -0.18275395f, 
    -0.00551037f, 0.24168268f, 0.10970967f, -0.19877124f, -0.00486035f, 0.13243233f, 0.07227900f, -0.05177518f, 
    -0.20458640f, -0.15494867f, 0.38677728f, 0.25960797f, 0.00742066f, -0.13885306f, 0.18260981f, -0.09350183f, 
    0.14477059f, -0.12597679f, 0.10921746f, -0.19095226f, -0.19837248f, -0.03009100f, 0.10729463f, -0.02289287f, 
    -0.33073968f, 0.29591006f, -0.07751291f, 0.14036298f, 0.09840567f, 0.03519430f, 0.03891646f, 0.01664656f, 
    0.01417792f, -0.26331371f, 0.03663737f, -0.00218621f, 0.02721987f, 0.26283371f, -0.01190131f, -0.22744623f, 
    -0.32354715f, -0.13485113f, 0.00859666f, 0.18807761f, -0.11709791f, -0.20371144f, -0.01190440f, 0.13289952f, 
    -0.01533589f, 0.03087680f, -0.00320101f, -0.21017694f, 0.00862902f, -0.10081772f, -0.08199807f, 0.05390491f, 
    0.07190951f, 0.42819092f, 0.14240897f, -0.08217245f, -0.04294287f, 0.13680442f, 0.13326453f, 0.05136556f, 
    0.04020169f, -0.06736598f, -0.06269643f, -0.13253228f, 0.08189058f, -0.02521931f, -0.20895910f, 0.05239864f, 
    0.11281107f, 0.11390553f, 0.06975660f, -0.03732496f, -0.01981047f, -0.21609104f, -0.33624572f, 0.11945530f, 
    0.16640788f, 0.11599285f, 0.10601070f, -0.01292893f, -0.14145000f, 0.20234558f, 0.19335812f, 0.02082176f, 
    0.03443777f, 0.13899927f, 0.07426019f, 0.01873481f, 0.43608820f, -0.12315221f, -0.15281659f, -0.20658796f, 
    -0.24372426f, -0.00426454f, -0.15421313f, -0.24403672f, 0.15607622f, 0.11978499f, -0.02966065f, -0.24338636f, 
    -0.01708666f, -0.25631523f, -0.03879796f, 0.09680063f, -0.09638569f, 0.23329702f, 0.14710064f, -0.01836092f, 
    -0.04302923f, 0.06304899f, -0.03407364f, 0.17036048f, -0.14103772f, 0.05941239f, -0.07196958f, -0.05814221f, 
    0.04547024f, -0.15894927f, 0.24631678f, -0.11061855f, -0.24211393f, 0.11526991f, 0.07746137f, -0.08154013f, 
    0.08456173f, 0.33370182f, -0.02883123f, -0.05791705f, -0.06048707f, -0.01608658f, -0.08341789f, 0.00424746f, 
    0.04665351f, 0.05722644f, 0.19804296f, -0.45393154f, -0.31892708f, -0.29947820f, -0.24517688f, 0.18618946f, 
    0.01146380f, -0.05234412f, 0.13604355f, -0.02293420f, -0.00316911f, 0.24160242f, 0.14707996f, -0.07388553f, 
    -0.04738873f, 0.01949256f, -0.06942204f, -0.09335372f, -0.11708798f, 0.06732228f, -0.01027391f, -0.16723256f, 
    0.16796952f, 0.21875136f, -0.01181184f, 0.19032873f, 0.18389858f, 0.04817574f, 0.02652209f, 0.15452623f, 
    0.17596498f, -0.07121247f, -0.02070108f, -0.04873691f, -0.01268519f, -0.03077168f, -0.12704034f, -0.14148660f, 
    -0.10783335f, -0.06884805f, -0.01367235f, -0.38628381f, -0.12391832f, 0.07221660f, 0.02065904f, 0.04562724f, 
    -0.08446697f, 0.01211441f, -0.00984030f, -0.04935865f, -0.26457179f, 0.22697271f, 0.09112391f, -0.05587463f, 
    -0.00025435f, -0.04554541f, 0.16732870f, 0.19370867f, 0.08561400f, -0.03325189f, -0.09024181f, 0.06668251f, 
    0.10417505f, -0.82199842f, -0.56829345f, 0.15294045f, -0.26871890f, -0.23481852f, -0.05904991f, 0.06921686f, 
    -0.04225507f, 0.05599418f, -0.46332821f, -0.61118287f, -0.28800276f, -0.07016709f, 0.01795035f, -0.10343646f, 
    0.34566510f, 0.01622329f, -0.01272773f, 0.52596104f, -0.37401327f, -0.52075803f, 0.11323152f, -0.08941732f, 
    0.25671235f, 0.05492066f, -0.09042737f, -0.01200816f, 0.13973142f, 0.17968677f, -0.28436559f, 0.16099277f, 
    -0.11737060f, -0.26859087f, 0.14737272f, 0.10292985f, 0.13428706f, -0.21651213f, 0.26033995f, 0.06848934f, 
    0.09790413f, 0.04667800f, 0.02297400f, 0.04304485f, 0.09194501f, -0.02255447f, -0.16042423f, 0.04437139f, 
    0.05896868f, 0.25599214f, -0.12643886f, 0.05724093f, -0.04314801f, -0.02401114f, -0.05728584f, 0.04397228f, 
    -0.04069942f, 0.05146714f, 0.12233078f, -0.12288778f, -0.11711226f, -0.04610059f, -0.12055587f, -0.11432989f, 
    -0.34970176f, -0.21536118f, -0.11512593f, -0.09929589f, 0.04454521f, -0.11376829f, 0.08683490f, 0.18042926f, 
    0.25635019f, 0.36824226f, -0.59960014f, -0.49386901f, 0.03209559f, 0.20215394f, 0.05624527f, -0.00840873f, 
    0.10815223f, 0.12060452f, -0.05142928f, 0.06304368f, 0.00520352f, -0.10498785f, -0.00749099f, 0.21395259f, 
    0.08485169f, -0.06449892f, 0.18233985f, -0.03300085f, 0.08040481f, 0.09482407f, 0.06593142f, 0.02033503f, 
    -0.12310550f, -0.03409507f, -0.15355963f, 0.09655983f, 0.11351550f, -0.30773449f, -0.06168381f, -0.09298727f, 
    0.10591494f, -0.09794424f, 0.11004402f, -0.06680124f, -0.05987345f, 0.07847158f, 0.02761295f, 0.02406482f, 
    -0.29184589f, 0.18722421f, 0.04719558f, 0.12628783f, 0.07675809f, -0.02424262f, 0.37550002f, 0.04134601f, 
    -0.04727718f, 0.10141038f, 0.11343645f, -0.02561776f, 0.06921412f, -0.04571716f, -0.20020500f, -0.30674529f, 
    -0.30517727f, 0.04368989f, -0.07663373f, -0.08510544f, -0.10363090f, -0.13336010f, 0.00404954f, -0.04978545f, 
    -0.12629284f, 0.19861345f, 0.06518955f, 0.00996017f, -0.00231335f, -0.00795933f, -0.10801119f, -0.00124375f, 
    0.13757589f, 0.79240841f, -0.11466818f, -0.51593661f, 0.02228985f, -0.03195463f, 0.33832097f, 0.10266320f, 
    0.02330968f, 0.10079178f, 0.02896534f, 0.06298142f, 0.02330678f, 0.13392921f, 0.01599097f, 0.01780199f, 
    -0.08326343f, 0.15434800f, 0.08089230f, 0.08463614f, 0.28051433f, -0.11799561f, -0.11817058f, -0.05127846f, 
    0.09267086f, 0.22145922f, -0.13014971f, -0.10018989f, -0.06290779f, -0.09930886f, 0.17462085f, 0.30862761f, 
    0.02824677f, 0.15711416f, 0.18945709f, -0.02906916f, 0.17654556f, -0.36092183f, -0.05896936f, -0.38350528f, 
    -0.03716831f, 0.03980128f, 0.00431577f, 0.20171702f, 0.05879202f, 0.17476548f, -0.35636324f, -0.29037225f, 
    -0.10498450f, 0.13949028f, -0.43137893f, 0.09103564f, 0.20079917f, -0.21554141f, -0.04014758f, -0.45767388f, 
    -0.25562721f, -0.19842206f, 0.08376400f, 0.12660766f, 0.04969321f, 0.05135177f, -0.04392845f, 0.10676986f, 
    -0.01748095f, -0.08798601f, 0.19112897f, 0.04408837f, 0.01188192f, 0.09046702f, 0.01954475f, 0.06435553f, 
    0.07795051f, 0.64139795f, -0.09324823f, -0.62188077f, 0.07523790f, -0.04133967f, -0.01907728f, 0.10413416f, 
    0.15690646f, 0.08005849f, 0.27340546f, 0.14555888f, -0.21246842f, 0.01828407f, -0.05310392f, -0.05665243f, 
    0.27878505f, 0.08351709f, 0.23243526f, 0.06952360f, 0.01037571f, -0.14886983f, 0.10084987f, 0.14062375f, 
    -0.12760879f, 0.07672972f, -0.16043036f, -0.08563811f, -0.12822397f, 0.24489541f, 0.02739875f, -0.00939442f, 
    -0.08951886f, 0.05928676f, 0.06354909f, 0.07421755f, -0.05859395f, -0.52567065f, -0.14384229f, 0.06889448f, 
    -0.07179849f, -0.26495495f, 0.00856481f, -0.10730220f, -0.04988977f, -0.10373390f, 0.13744207f, -0.03947918f, 
    -0.17491387f, 0.00397764f, 0.08479302f, -0.01524729f, -0.33975428f, -0.00178503f, -0.22541326f, 0.15082593f, 
    0.09903036f, -0.29205737f, -0.02431469f, -0.20405431f, -0.05222736f, 0.02194742f, -0.35395938f, -0.11562952f, 
    -0.05392005f, -0.01206541f, -0.00116347f, 0.04243223f, -0.06100730f, -0.02107186f, 0.00193529f, -0.06476483f, 
    -0.00538347f, -0.04242353f, -0.01949996f, 0.04921327f, -0.02583895f, -0.04940232f, -0.04376076f, 0.03308253f, 
    0.01176402f, -0.06194633f, -0.06769355f, 0.03122145f, -0.01384059f, -0.03550190f, -0.05521627f, 0.00771677f, 
    0.00419306f, -0.02338540f, -0.05337735f, -0.01501352f, -0.00147675f, 0.00027982f, 0.02519257f, -0.02714129f, 
    0.00315335f, -0.03231619f, 0.00085551f, -0.01233933f, -0.02017858f, -0.03345283f, -0.01786687f, -0.01707760f, 
    -0.01242326f, 0.00528948f, 0.00304647f, 0.00345761f, 0.04008627f, -0.02150555f, 0.04994899f, 0.00775166f, 
    0.01191701f, -0.05195839f, -0.03643070f, -0.01965839f, -0.05619299f, -0.00695362f, -0.00353031f, -0.05178041f, 
    0.01790788f, 0.00949363f, -0.04885248f, -0.05396252f, -0.01991964f, 0.02092923f, 0.04235963f, -0.01227793f, 
    -0.01162955f, -0.02316411f, -0.01551553f, -0.01125509f, 0.03775948f, 0.02794828f, -0.05949719f, 0.03517482f, 
    -0.05263280f, 0.03641516f, -0.03440555f, -0.00636323f, 0.02958210f, 0.01115854f, -0.03662394f, 0.03083257f, 
    0.00703146f, -0.05155513f, -0.03321603f, 0.03627375f, 0.01417343f, -0.03019543f, -0.02584441f, 0.01360661f, 
    0.03805118f, -0.01787804f, 0.01710501f, -0.01153425f, -0.03369377f, -0.00532642f, -0.01616897f, 0.02596970f, 
    0.04309865f, -0.06834280f, -0.00706439f, 0.02203816f, 0.00070674f, -0.04930867f, -0.05316037f, -0.00054354f, 
    0.04099059f, 0.02185500f, 0.02252683f, -0.03999544f, -0.06670479f, 0.00238378f, -0.06649941f, 0.03502216f, 
    -0.05962512f, 0.01068768f, 0.02366766f, 0.00008927f, 0.04512063f, -0.04806281f, -0.04433255f, -0.04285383f, 
    -0.01727390f, -0.05513632f, 0.02437465f, 0.03895346f, 0.00860892f, -0.04656522f, -0.02435559f, -0.00727668f, 
    -0.06473741f, 0.01347175f, 0.03986683f, 0.01207541f, -0.03805424f, -0.05695331f, -0.05295511f, 0.01980195f, 
    -0.05464257f, -0.05520001f, -0.04417586f, -0.01076863f, -0.00611256f, -0.05105886f, 0.02096113f, -0.00875575f, 
    -0.05740071f, -0.01512430f, 0.02952079f, -0.07138845f, -0.05586466f, -0.02657268f, 0.03047835f, -0.06933384f, 
    -0.00975881f, -0.06409431f, 0.00154105f, -0.01401487f, 0.04376938f, -0.06447462f, -0.03653278f, -0.05885094f, 
    0.02820294f, -0.01226786f, -0.00698159f, 0.04526262f, 0.01800422f, -0.03198987f, -0.05424137f, -0.04750291f, 
    -0.04692612f, -0.02711713f, -0.03827506f, -0.01688860f, -0.01905638f, -0.02598237f, -0.04839950f, -0.05421302f, 
    0.02295445f, -0.05990747f, -0.03418785f, 0.00361421f, -0.03216334f, 0.03042571f, -0.05453316f, 0.01566307f, 
    0.00847690f, -0.00937609f, -0.01762836f, 0.02302881f, -0.06460858f, -0.04018627f, -0.03148752f, 0.01134268f, 
    -0.03083924f, -0.00980303f, -0.06306698f, 0.00250855f, 0.01547749f, -0.05850938f, -0.06444427f, 0.02201724f, 
    0.00629767f, 0.02668376f, 0.04414823f, 0.00241709f, -0.01892279f, -0.04173262f, 0.02530427f, -0.06474758f, 
    -0.01945825f, 0.00890269f, 0.04661369f, -0.02171205f, -0.03688183f, -0.02980691f, 0.04839348f, -0.01304041f, 
    -0.03552349f, -0.01103030f, -0.02138728f, 0.04664434f, 0.03269973f, 0.02174606f, -0.03080523f, -0.02963145f, 
    -0.01961844f, 0.01619826f, 0.02297988f, 0.04481496f, -0.01577246f, 0.03815277f, 0.04881888f, 0.01641152f, 
    0.04570283f, 0.00261929f, 0.03662346f, -0.03041101f, 0.00721197f, -0.01415924f, 0.00454980f, -0.00490203f, 
    0.03586168f, 0.00892950f, -0.04504604f, 0.01383459f, 0.00915337f, 0.02568115f, -0.05615429f, 0.00460541f, 
    0.03620828f, 0.03893844f, -0.00919131f, 0.01952047f, 0.00306810f, 0.04321381f, -0.01554648f, 0.01039531f, 
    -0.06486368f, -0.01016316f, 0.04530905f, 0.01701316f, -0.03065207f, 0.03607558f, -0.01521001f, -0.02061410f, 
    0.02193506f, -0.05821473f, 0.01889541f, -0.01869214f, 0.01978152f, 0.03690531f, -0.02721193f, 0.01291778f, 
    0.02367810f, -0.01739632f, 0.04444166f, 0.01113201f, -0.04833074f, -0.04197524f, -0.02895908f, -0.06861708f, 
    -0.05545256f, -0.03459853f, -0.05539155f, 0.03895998f, 0.05010382f, -0.06435513f, -0.00049660f, 0.03441583f, 
    0.26482978f, -0.10712547f, 0.29741958f, -0.05140178f, -0.02445209f, -0.10055911f, -0.17267255f, -0.14532652f, 
    -0.04011999f, 0.05931719f, 0.22188210f, 0.13236193f, -0.15005888f, -0.07290313f, -0.18428724f, -0.14301889f, 
    0.02911130f, 0.15263720f, 0.26445988f, 0.13119519f, 0.02236530f, 0.07401410f, 0.00409906f, -0.38559175f, 
    -0.35407442f, -0.15029167f, 0.02213497f, -0.12502885f, -0.15534155f, 0.13718592f, 0.24634250f, -0.00645171f, 
    -0.00773071f, -0.06553151f, 0.00910812f, 0.28793818f, 0.11983855f, 0.13946353f, 0.12469785f, -0.08951671f, 
    -0.38766631f, 0.02232219f, 0.26652861f, 0.18750939f, -0.03362865f, 0.41577315f, 0.07237647f, 0.12108115f, 
    0.12204284f, -0.13005540f, 0.03659074f, 0.01839034f, -0.07162225f, 0.07644972f, 0.56646609f, 0.50388354f, 
    -0.00422597f, 0.07103515f, -0.14408800f, 0.01977553f, -0.09691882f, -0.04696229f, 0.12443455f, -0.28209972f, 
    -0.51231050f, -0.15583858f, -0.04974522f, -0.11577524f, -0.19881159f, -0.05091717f, -0.03793345f, 0.06501797f, 
    0.18423735f, 0.37926605f, 0.48405948f, -0.22063813f, -0.17459351f, 0.12588783f, 0.13193034f, 0.29084787f, 
    0.06710143f, -0.14264229f, 0.02863962f, 0.29729754f, 0.07737233f, 0.09040113f, -0.00426844f, 0.00867393f, 
    0.09641176f, -0.33321840f, 0.08664069f, 0.05018039f, 0.01277563f, -0.99881184f, -0.43796000f, -0.25805873f, 
    0.06897428f, 0.11061105f, 0.11555497f, 0.11351446f, 0.05268263f, 0.03387333f, -0.11003252f, -0.07644828f, 
    -0.18037830f, -0.08433188f, 0.21391924f, 0.27601287f, -0.22768945f, -0.14953694f, 0.26247633f, 0.10662283f, 
    0.01452345f, -0.27490178f, 0.04236658f, -0.01883756f, -0.09700752f, 0.01744946f, 0.15948422f, 0.03439460f, 
    0.03101904f, -0.12817803f, 0.00032238f, -0.09692583f, -0.12756509f, -0.11167616f, -0.01050208f, 0.00159477f, 
    0.06397560f, 0.09866744f, 0.10983069f, -0.11583246f, 0.01231785f, -0.28543884f, -0.19197263f, 0.34739071f, 
    0.10101734f, -0.09964834f, 0.16881157f, 0.10198522f, -0.11691616f, -0.01403599f, -0.09439945f, 0.07032277f, 
    0.09142825f, 0.01587983f, -0.03001239f, -0.23998873f, -0.34831390f, -0.21591118f, -0.06165486f, 0.21507804f, 
    0.19349688f, 0.10477159f, 0.09681511f, 0.04214122f, 0.17699297f, -0.10323812f, 0.07375065f, 0.09322413f, 
    -0.00628647f, -0.09440047f, -0.06051923f, -0.37628007f, 0.19348238f, -0.12953326f, -0.03350664f, 0.04377987f, 
    -0.01304485f, -0.10028788f, -0.02990909f, -0.00486033f, 0.08457088f, -0.11223887f, -0.53436869f, -0.20696932f, 
    -0.09032782f, 0.14125082f, -0.09523160f, 0.04115796f, -0.07125008f, -0.07454731f, 0.22997072f, -0.11104811f, 
    -0.05082377f, -0.05338250f, 0.14367037f, 0.07971618f, 0.00781059f, -0.04282901f, 0.11542220f, 0.14925434f, 
    -0.23696679f, -0.26983532f, 0.22194415f, -0.13508584f, 0.25242114f, -0.11534674f, 0.38364011f, -0.39135951f, 
    -0.44303688f, -0.07424005f, -0.05170722f, 0.19550484f, 0.07685665f, -0.00598081f, 0.18654007f, -0.05379148f, 
    0.22331093f, -0.13021226f, 0.06668084f, 0.04356241f, -0.09623545f, 0.12003013f, 0.38236928f, 0.28737488f, 
    0.16450222f, -0.06295300f, -0.37835684f, -0.17233285f, 0.01764395f, -0.12284026f, -0.00080846f, -0.10295235f, 
    -0.00370352f, 0.05713475f, -0.01380029f, -0.08243546f, 0.10378717f, 0.09626016f, -0.04735227f, -0.11414824f, 
    0.06036376f, -0.12297813f, -0.34893987f, -0.07921820f, -0.12795360f, -0.07182755f, -0.08630618f, 0.17808083f, 
    0.35286796f, 0.26010039f, 0.33638498f, -0.36144298f, -0.02784245f, 0.23957260f, 0.05102519f, 0.01218310f, 
    -0.14781271f, -0.04972686f, 0.12072889f, 0.03249733f, 0.30476800f, 0.15243477f, -0.09263118f, 0.08293689f, 
    -0.32361537f, 0.02364736f, 0.11897836f, -0.02107434f, 0.00070133f, 0.32934338f, 0.32052612f, -0.10868800f, 
    0.01564956f, -0.31762341f, -0.27828735f, 0.01736764f, 0.05720305f, 0.16664188f, -0.09594881f, -0.00717629f, 
    -0.17075287f, 0.05497361f, -0.00253730f, -0.09128713f, -0.24947228f, -0.20176807f, 0.10602144f, 0.06224606f, 
    0.08303210f, -0.20851256f, -0.38080156f, -0.01731900f, -0.09390222f, 0.25670123f, 0.09894618f, 0.10342025f, 
    -0.05006862f, -0.04819204f, 0.00294476f, -0.02328931f, -0.01683186f, -0.03215962f, 0.00540721f, -0.05081641f, 
    0.01697940f, -0.02920145f, 0.00671771f, -0.00500419f, -0.02864488f, 0.01246166f, -0.01320153f, -0.00837860f, 
    0.00331027f, 0.02325486f, 0.04700244f, -0.02304828f, -0.05945561f, -0.02039640f, -0.02511320f, 0.03348923f, 
    0.01000784f, -0.02249306f, -0.03797592f, -0.02386105f, -0.01105341f, -0.00927242f, 0.03715601f, -0.05758517f, 
    -0.04788671f, -0.06020349f, -0.01629519f, 0.01537993f, -0.04403894f, 0.02030307f, -0.03230536f, -0.01921785f, 
    -0.02147465f, 0.03256961f, 0.03280370f, 0.03978926f, -0.02406299f, 0.03869437f, -0.00738984f, 0.01505382f, 
    0.03850723f, -0.01055292f, -0.00813447f, -0.05047384f, 0.04216361f, -0.04693470f, -0.02135351f, -0.00575298f, 
    -0.01874845f, -0.00565417f, 0.03379686f, 0.00333697f, -0.04349358f, 0.04077794f, -0.05021747f, 0.04150987f, 
    0.02462159f, 0.03764628f, 0.01150593f, -0.00628862f, -0.00366631f, -0.00807716f, -0.00800390f, -0.05979923f, 
    0.02469652f, -0.02728843f, -0.05556839f, -0.01082466f, -0.00063439f, 0.02233815f, 0.04737644f, -0.02800440f, 
    -0.04144210f, -0.04902702f, -0.05151431f, 0.03064948f, 0.00402483f, -0.03804192f, 0.01454350f, 0.03898937f, 
    -0.03117189f, -0.03802860f, 0.02174863f, -0.02298372f, -0.05099029f, 0.03893460f, -0.01478679f, 0.01858227f, 
    0.02327154f, -0.05511736f, -0.01615597f, -0.00321896f, -0.01627304f, -0.04016822f, -0.04228856f, -0.03733824f, 
    0.03409672f, -0.02066277f, 0.02205531f, -0.04163613f, -0.03022864f, -0.00870368f, -0.04287310f, -0.06050155f, 
    -0.01977913f, -0.03008553f, 0.03983781f, 0.01271919f, -0.06314050f, 0.01287568f, 0.04833177f, -0.04932198f, 
    0.04959033f, -0.04399884f, -0.02308821f, -0.02548035f, -0.06518664f, -0.05783562f, 0.04351337f, 0.02788781f, 
    0.01469912f, -0.04120598f, 0.04258521f, 0.00269002f, 0.02739970f, 0.02355726f, 0.01250199f, 0.00691645f, 
    -0.06187661f, -0.01670030f, -0.05710043f, 0.03968277f, -0.01095904f, 0.01033224f, 0.03669048f, 0.02456362f, 
    0.00969887f, -0.05154024f, 0.04472060f, -0.05857664f, -0.04816809f, 0.03795246f, -0.04891537f, 0.01273062f, 
    0.02285855f, 0.05203199f, 0.03155165f, 0.03230276f, -0.03843571f, 0.02689091f, -0.04088050f, 0.03551337f, 
    0.04126889f, 0.04694298f, 0.04865392f, -0.04612796f, -0.06237370f, -0.01341300f, -0.03595547f, -0.00567949f, 
    -0.02774303f, -0.02892465f, -0.01170873f, 0.02606548f, -0.01496863f, -0.03783256f, -0.02724319f, -0.01847639f, 
    0.01259938f, -0.00596942f, 0.03774621f, 0.00907529f, 0.00668271f, -0.03183796f, -0.00365900f, -0.05032868f, 
    0.00866550f, -0.01911965f, 0.04297924f, 0.01424553f, 0.00755770f, -0.01125984f, 0.00539765f, 0.00314873f, 
    0.04133187f, -0.00469515f, -0.01953395f, -0.05741533f, -0.00141968f, 0.00270589f, -0.00507037f, -0.02314910f, 
    0.01059186f, -0.05171085f, 0.00696274f, -0.03340071f, 0.02922463f, -0.03079923f, -0.01636484f, -0.03028929f, 
    -0.03599510f, -0.05519634f, -0.02112346f, -0.01137972f, 0.01822084f, -0.02676689f, 0.04177055f, -0.04126486f, 
    -0.01724517f, 0.03018618f, 0.01971160f, 0.05257568f, -0.06245115f, -0.05373193f, 0.03402570f, -0.02146513f, 
    -0.04716746f, 0.04884937f, 0.03048307f, -0.06385574f, -0.05442490f, -0.02201623f, 0.01734829f, 0.03552717f, 
    -0.00015014f, -0.00623972f, -0.06173026f, -0.03383878f, -0.05324157f, 0.03560328f, -0.03449963f, -0.04745375f, 
    -0.04919031f, 0.05465981f, -0.01256494f, 0.03271127f, -0.04808671f, 0.02232604f, 0.04851484f, -0.00056998f, 
    0.05685114f, 0.01289830f, -0.01407731f, -0.04159551f, -0.04590807f, -0.01791566f, 0.04612646f, 0.00487745f, 
    -0.01342198f, 0.00902187f, -0.06538071f, 0.02333812f, 0.01644322f, 0.00176885f, 0.04248602f, -0.01504329f, 
    0.01796061f, 0.00013492f, -0.06251940f, -0.04908885f, -0.00316820f, -0.05802825f, -0.05848094f, -0.02349854f, 
    0.04243664f, 0.01108021f, 0.02930818f, -0.06127773f, 0.01205219f, -0.03425156f, 0.04887139f, 0.01462558f, 
    -0.05501628f, -0.04238098f, -0.06845902f, -0.04380806f, -0.03321785f, -0.00227094f, 0.01432939f, 0.03874996f, 
    -0.06110476f, -0.00198792f, -0.00577937f, -0.02288959f, 0.02179041f, 0.02550925f, -0.03506584f, -0.02048702f, 
    0.02426273f, 0.03011149f, -0.03695391f, -0.06754097f, -0.02377078f, -0.05304013f, -0.02390839f, -0.03913968f, 
    0.03513942f, 0.03897272f, 0.04572463f, -0.03112023f, 0.05007164f, 0.04496972f, 0.02397183f, -0.01424686f, 
    -0.05668146f, 0.01021081f, 0.02480468f, 0.04430480f, -0.02036574f, -0.01191468f, -0.04196109f, -0.06418256f, 
    -0.03356600f, -0.03303035f, -0.06642579f, -0.03625342f, -0.00634408f, 0.04657092f, 0.00417524f, 0.04582218f, 
    0.02280472f, -0.02712426f, -0.01046245f, 0.04677345f, 0.03374738f, 0.03663319f, -0.03295503f, -0.01016211f, 
    0.04683379f, 0.01522646f, 0.00505854f, 0.03452426f, -0.03619133f, 0.04053652f, 0.05979264f, -0.03164052f, 
    0.02363662f, -0.00884616f, -0.03936011f, 0.01262784f, -0.05490905f, 0.03550772f, 0.03904063f, 0.02046241f, 
    -0.01999929f, -0.03909075f, 0.02153983f, 0.04742385f, -0.00707179f, 0.00057784f, -0.05007377f, -0.03049533f, 
    -0.04442354f, -0.05011372f, -0.01979196f, -0.01533493f, -0.04428246f, 0.05674895f, -0.06070658f, -0.00514036f, 
    -0.03257867f, 0.03993848f, 0.02235948f, -0.02893251f, -0.00960939f, -0.02777569f, -0.02280450f, -0.04392263f, 
    -0.05713340f, -0.04471518f, 0.03928015f, 0.02762199f, 0.01109615f, 0.02244967f, 0.04016488f, 0.00551538f, 
    -0.03276867f, 0.02341073f, 0.04260204f, -0.04427671f, -0.05537448f, -0.00665024f, -0.00645094f, -0.03837919f, 
    0.03949022f, 0.00487293f, 0.01820523f, 0.00629593f, -0.01025532f, -0.00609298f, -0.03751431f, 0.04759695f, 
    -0.00947612f, 0.00181879f, 0.00345845f, -0.03002305f, 0.03576097f, -0.03585085f, 0.01140423f, -0.02732494f, 
    0.05008847f, -0.02038235f, 0.05853645f, -0.01074894f, -0.02017128f, -0.05485259f, -0.02141841f, -0.00140257f, 
    -0.00048779f, 0.06030172f, -0.02099113f, 0.00847676f, -0.03890716f, -0.06815885f, 0.01371798f, 0.03596473f, 
    -0.00485095f, 0.03055054f, 0.03326908f, 0.00171903f, -0.06667349f, -0.06784217f, -0.05209404f, 0.03213372f, 
    -0.05975839f, 0.00946544f, -0.05932605f, 0.01098564f, -0.02691665f, -0.04525391f, 0.04226978f, 0.01923543f, 
    -0.01465324f, 0.05775928f, -0.00521096f, -0.01415258f, 0.02100727f, -0.04882590f, 0.04192330f, -0.04242475f, 
    0.00708904f, 0.00697437f, -0.06093232f, -0.02333007f, 0.00246954f, 0.04512467f, -0.06683557f, -0.06133198f, 
    0.04200601f, -0.05152430f, -0.05924313f, -0.00371529f, 0.02042601f, -0.04779401f, -0.04068761f, -0.02377180f, 
    -0.05666635f, 0.00290841f, 0.04715830f, 0.04791510f, -0.05538260f, 0.04360811f, -0.05764925f, -0.02481976f, 
    0.03443635f, -0.05656495f, 0.03627534f, -0.00065889f, -0.00623911f, 0.01076041f, -0.02232068f, 0.03209307f, 
    0.02264235f, 0.02066460f, 0.02490571f, 0.04235264f, -0.01401567f, 0.03569607f, -0.06745249f, -0.06778474f, 
    -0.04990702f, -0.04682896f, 0.05049420f, -0.06120620f, -0.01017179f, -0.02590595f, 0.02668753f, -0.03264061f, 
    -0.06895100f, -0.03268341f, 0.03946346f, -0.02526654f, 0.03234863f, 0.02034139f, -0.02550167f, -0.00756774f, 
    0.03104060f, -0.05262082f, 0.01445928f, -0.05530556f, -0.03669246f, 0.03561679f, -0.03023959f, -0.02982025f, 
    -0.00519258f, -0.01170287f, -0.04821264f, -0.01743234f, -0.03510376f, 0.00289563f, -0.03389653f, -0.04850634f, 
    -0.00366554f, -0.00617344f, 0.02872601f, 0.02421527f, -0.00110965f, -0.03297570f, -0.03031212f, -0.00090712f, 
    0.02145920f, -0.01998198f, -0.04283165f, -0.04490098f, 0.01906050f, 0.02901530f, -0.06903101f, 0.02811913f, 
    0.05030591f, -0.03921823f, -0.04852573f, -0.02288090f, 0.00860783f, 0.00572959f, -0.03533415f, -0.04003661f, 
    -0.01815048f, -0.06451339f, -0.03442127f, 0.03121727f, -0.01552865f, -0.02348232f, -0.03663158f, 0.04419252f, 
    0.02803832f, -0.00750444f, 0.02027868f, 0.04289142f, -0.02166430f, -0.05320330f, -0.02626387f, 0.00725579f, 
    0.00386976f, 0.01927801f, -0.01506743f, 0.01337884f, 0.02701273f, -0.06339315f, 0.04440844f, 0.03116996f, 
    -0.03298312f, -0.06186455f, 0.00684781f, 0.05240778f, -0.02250665f, -0.06194349f, 0.02998239f, 0.03585920f, 
    -0.12976292f, -0.07891770f, -0.48488715f, -0.22605415f, -0.07741726f, 0.09866563f, -0.00912008f, 0.05229713f, 
    -0.20284835f, -0.36305347f, -0.05181964f, -0.13506620f, -0.13249883f, 0.15902829f, 0.04101311f, -0.11710026f, 
    0.02509745f, -0.02494387f, 0.18366255f, 0.19940929f, 0.24168164f, -0.06105187f, 0.15054807f, 0.03965296f, 
    0.22928011f, 0.11568702f, -0.11916958f, 0.22437786f, 0.39241236f, 0.15711367f, -0.03290114f, 0.13066684f, 
    0.11891680f, -0.08041406f, 0.03392633f, 0.23736109f, 0.07944664f, 0.00778918f, 0.08160260f, -0.09577665f, 
    0.00368821f, 0.12145414f, 0.02399206f, 0.20018208f, 0.02565310f, -0.26984519f, -0.23133704f, -0.15869559f, 
    0.01759281f, 0.02139758f, 0.21597123f, 0.02875997f, -0.01093816f, 0.00490789f, 0.37889117f, 0.29637316f, 
    0.19294575f, -0.13854723f, 0.15510632f, 0.02684066f, -0.17239201f, -0.16684197f, -0.03269497f, -0.44355530f, 
    0.16396824f, -0.28503880f, 0.02005728f, -0.01368877f, -0.10927191f, -0.26352105f, -0.15156275f, 0.03437632f, 
    -0.07906564f, -0.68109566f, -0.59379655f, -0.18040107f, -0.03114591f, -0.12553991f, -0.11683217f, -0.04102254f, 
    0.17856562f, 0.20384571f, 0.11440120f, 0.00333762f, -0.10750326f, -0.01518928f, -0.07575316f, -0.16223340f, 
    -0.00970326f, -0.13759199f, 0.15541627f, 0.08909594f, -0.08145171f, -0.10267027f, -0.20772526f, -0.14484993f, 
    -0.28831056f, -0.05293157f, -0.04606739f, 0.14708860f, 0.14834833f, 0.14199075f, -0.17517610f, 0.03601853f, 
    -0.02077944f, -0.01598828f, -0.00281738f, -0.08461447f, -0.43377501f, 0.05091393f, 0.17296952f, -0.01535254f, 
    -0.02289780f, -0.20619622f, -0.31833491f, -0.10018613f, -0.15679538f, 0.26237613f, 0.25757527f, 0.07397144f, 
    -0.06787872f, -0.12537608f, -0.01421083f, 0.19354369f, -0.01364356f, -0.17510998f, 0.33110899f, 0.10573811f, 
    -0.03424666f, -0.00795526f, -0.07699936f, -0.15336743f, -0.03824969f, -0.03971162f, -0.13021760f, -0.38420302f, 
    -0.35393843f, -0.30375203f, -0.45915017f, -0.12051845f, 0.03647488f, -0.11237557f, 0.04883103f, -0.21733668f, 
    0.02468125f, 0.15302934f, 0.22620846f, -0.03804706f, -0.02559538f, -0.08591329f, 0.09803510f, 0.04441877f, 
    0.05740587f, 0.32474360f, 0.16404822f, 0.24074639f, 0.07803711f, 0.09571650f, 0.07303451f, -0.04067784f, 
    0.07360739f, -0.17387959f, 0.01343523f, -0.19603325f, -0.48114896f, -0.10198227f, -0.05848012f, 0.15240718f, 
    0.10512391f, 0.11424723f, 0.05983886f, 0.09453014f, 0.00829897f, -0.05023681f, -0.09769370f, 0.11298735f, 
    -0.05969668f, -0.02260154f, -0.14064781f, -0.20590042f, 0.24664906f, 0.07092258f, 0.04541802f, 0.06941416f, 
    0.07662944f, 0.06706396f, 0.27793700f, 0.17240699f, 0.09931305f, 0.22131501f, -0.37055707f, -0.05249272f, 
    -0.17966984f, -0.05431978f, -0.03562441f, -0.23759383f, 0.19442396f, -0.09367836f, -0.39614820f, 0.14630105f, 
    -0.04196816f, 0.11799832f, 0.21639055f, 0.06753223f, -0.16315120f, 0.09341151f, 0.27988213f, 0.23727034f, 
    0.27504769f, 0.08236110f, -0.04110283f, 0.09943260f, -0.11763185f, 0.03255899f, 0.03377105f, 0.09783141f, 
    -0.09395283f, -0.35975468f, -0.19792283f, 0.01418588f, -0.07499914f, 0.04581312f, 0.02466510f, 0.07918701f, 
    0.19274485f, 0.32992384f, 0.10631033f, 0.24534033f, 0.03149756f, 0.06735381f, 0.17314890f, -0.00854774f, 
    0.00469464f, -0.02035773f, -0.31522417f, -0.05910309f, -0.11806565f, -0.02791088f, -0.00368815f, 0.10062211f, 
    0.06551851f, 0.17313299f, 0.14299789f, -0.15087497f, 0.05054428f, 0.15320596f, -0.11926422f, 0.11249582f, 
    0.04034419f, 0.04841829f, -0.02149408f, -0.03959852f, 0.02844217f, -0.18138435f, -0.34191120f, 0.01804310f, 
    -0.07810017f, 0.00969551f, -0.18750438f, 0.01520924f, 0.02305708f, -0.00469786f, 0.13594472f, 0.00425672f, 
    0.02522285f, -0.01946243f, -0.11924698f, 0.04031949f, -0.07498827f, -0.10527071f, 0.22199911f, 0.21498513f, 
    -0.09068850f, -0.11033712f, 0.02954870f, -0.11008394f, 0.04769158f, -0.05594007f, -0.01838176f, 0.10738266f, 
    0.03900696f, 0.03668084f, -0.11692232f, -0.14066434f, -0.11041398f, -0.06590192f, -0.12387761f, -0.21315895f, 
    0.04789369f, -0.03409589f, -0.04329359f, -0.01250363f, 0.02732355f, -0.02017994f, -0.00206625f, 0.01794512f, 
    -0.04999144f, -0.01907923f, 0.00081699f, -0.06120312f, 0.02591675f, -0.04952809f, 0.05101378f, -0.05208837f, 
    -0.03969030f, -0.04774918f, -0.05167915f, -0.03926246f, -0.02301095f, -0.04075952f, 0.03633660f, -0.03524897f, 
    0.04701687f, 0.02352274f, -0.02277737f, -0.03019309f, -0.03965957f, -0.04344244f, -0.06461378f, 0.03347271f, 
    -0.02447481f, 0.03371203f, 0.03074336f, -0.04858193f, 0.03956704f, -0.06010521f, -0.04596105f, -0.05413978f, 
    -0.00244086f, 0.01436064f, -0.05370810f, 0.03488777f, 0.01952487f, -0.01456568f, 0.02558000f, -0.04172178f, 
    -0.05938210f, -0.05467129f, 0.03135584f, -0.02716427f, 0.02689671f, -0.00628804f, -0.04148697f, 0.03526552f, 
    -0.01807916f, 0.01193727f, -0.04921164f, -0.01690302f, 0.03044464f, -0.04604085f, 0.01171839f, 0.04065477f, 
    -0.01563325f, -0.03570129f, -0.03005853f, 0.02510908f, -0.00164958f, 0.01445681f, -0.02091382f, -0.01788619f, 
    0.02090064f, -0.06080789f, -0.06474584f, -0.04567677f, -0.02261140f, -0.04467242f, -0.01655062f, 0.00363415f, 
    0.01145381f, -0.03399801f, 0.00538588f, -0.05234437f, 0.00431140f, -0.04358917f, -0.04214188f, 0.04461072f, 
    0.04455108f, -0.04422109f, -0.05769629f, -0.00153585f, -0.04337473f, -0.03810578f, -0.02395893f, 0.01721158f, 
    -0.02355004f, -0.03719268f, -0.04169994f, -0.03057852f, -0.04278136f, 0.02127494f, 0.02734207f, 0.01198705f, 
    -0.04445355f, -0.01630954f, -0.04517539f, -0.03509471f, 0.03289213f, -0.04989712f, 0.03486026f, -0.04536734f, 
    -0.01851816f, -0.04741862f, 0.01695499f, -0.06218305f, -0.02694107f, -0.05784727f, 0.01123887f, 0.02760594f, 
    -0.01183420f, -0.00186429f, -0.02813434f, -0.01327635f, -0.04670942f, 0.04958476f, 0.03127654f, -0.00231801f, 
    0.00730324f, -0.05899182f, -0.02827480f, 0.01494975f, 0.02527801f, 0.02189204f, -0.00414397f, 0.01679474f, 
    0.01883494f, -0.03619979f, -0.01942834f, -0.04588714f, 0.06219288f, -0.04791363f, 0.01267332f, 0.02040941f, 
    -0.03864455f, 0.05167820f, 0.01517765f, 0.00176922f, 0.01357522f, -0.00300926f, -0.00330771f, 0.04788807f, 
    -0.04836240f, -0.00148842f, 0.03660696f, 0.03521753f, 0.04217421f, 0.01141877f, -0.05703992f, -0.03791686f, 
    -0.05441500f, 0.01309675f, 0.03791763f, 0.01808625f, 0.04453222f, -0.05242691f, 0.01581893f, -0.04741616f, 
    -0.00640591f, -0.05027108f, 0.03801581f, 0.05218334f, 0.02304707f, -0.02095155f, -0.05673828f, -0.04560671f, 
    0.02165994f, 0.02703043f, -0.05210268f, -0.02441703f, -0.05186361f, 0.01734509f, 0.00330940f, -0.05761811f, 
    0.00830252f, -0.02356712f, -0.03987699f, -0.04897645f, 0.05266331f, -0.00877767f, -0.03056386f, 0.00066218f, 
    0.05155677f, 0.03484174f, -0.03553756f, -0.01306781f, 0.03838172f, -0.05403447f, -0.00842514f, 0.00125815f, 
    0.02250594f, 0.03667490f, 0.00563606f, -0.05649964f, 0.04695156f, -0.00027856f, -0.04822303f, 0.02167018f, 
    0.00844685f, -0.00948098f, -0.05940126f, -0.01832412f, 0.01823043f, 0.02413934f, 0.05857983f, -0.01148752f, 
    -0.03120129f, -0.05439460f, 0.02625009f, 0.00072576f, -0.02831755f, -0.03241238f, 0.02676056f, -0.01374528f, 
    -0.02226984f, 0.01046570f, 0.04539848f, 0.00952904f, 0.01979378f, -0.00037294f, -0.00530537f, -0.03593392f, 
    0.02158312f, 0.00574931f, -0.01471817f, 0.04709515f, -0.03424184f, 0.03942034f, 0.04618449f, 0.01929478f, 
    0.02278445f, -0.03611798f, 0.02378725f, -0.05005915f, 0.02765318f, -0.06431792f, -0.01633652f, -0.01503912f, 
    -0.00811038f, 0.00254394f, 0.00242504f, -0.00336987f, -0.06289209f, 0.02195241f, 0.01300118f, -0.06223113f, 
    0.03542276f, -0.01645199f, 0.02628179f, -0.01899466f, -0.01055668f, 0.02632633f, -0.00390637f, 0.04863918f, 
    -0.03425070f, -0.01193139f, 0.00890328f, 0.02733412f, 0.02750536f, 0.00608407f, -0.00260011f, -0.03172046f, 
    -0.03319077f, 0.00153217f, 0.01372145f, 0.01931848f, -0.02267162f, -0.02102679f, 0.04013955f, -0.01725147f, 
    -0.01585200f, 0.01756268f, 0.03470328f, -0.03326199f, 0.03946240f, 0.02796148f, 0.05528700f, 0.00928561f, 
    0.16991581f, 0.15498188f, 0.02556066f, -0.08721434f, -0.07062004f, -0.09768044f, 0.04840873f, -0.05779670f, 
    0.09543736f, -0.13719332f, -0.61348027f, 0.22938712f, 0.26595703f, -0.10423263f, 0.10225917f, 0.05075637f, 
    0.02784757f, -0.06256513f, -0.19671208f, -0.18379118f, 0.11271286f, -0.18939236f, -0.09705735f, 0.05587577f, 
    0.02588000f, -0.06706649f, -0.26598847f, 0.20169291f, 0.00215503f, 0.03391690f, -0.14675687f, 0.05865084f, 
    0.03570359f, 0.28748062f, -0.31317431f, 0.16675808f, -0.17950253f, -0.21428269f, 0.23361148f, -0.05324043f, 
    0.13920408f, -0.22278854f, -0.21217775f, -0.15851441f, -0.00643607f, 0.13419634f, 0.02051448f, -0.09808771f, 
    -0.09657292f, -0.16196339f, -0.00916172f, 0.14585623f, 0.02858907f, 0.01065528f, 0.01652140f, -0.18633088f, 
    0.08436336f, 0.15992533f, -0.32914644f, 0.03961664f, 0.09005080f, 0.12458096f, 0.00447947f, -0.11427243f, 
    0.10390060f, 0.39875033f, -0.02439997f, 0.14644548f, 0.07711916f, -0.00391957f, 0.05452135f, 0.07582133f, 
    -0.11342847f, -0.71216297f, 0.01979253f, 0.13340889f, -0.06286786f, -0.02581853f, -0.12260636f, -0.15835327f, 
    -0.33441213f, -0.18360783f, -0.17111616f, 0.03905061f, 0.10043395f, 0.01824583f, 0.07446858f, -0.04970813f, 
    0.05965113f, -0.00931248f, 0.17976516f, 0.13958982f, 0.03146241f, -0.11886537f, 0.02843032f, -0.18372504f, 
    0.01057712f, 0.05115181f, -0.00653763f, 0.00812296f, -0.02933672f, 0.34935197f, -0.09050477f, -0.10260077f, 
    -0.00733982f, -0.32249892f, -0.22932881f, -0.40289751f, -0.07167295f, -0.22774595f, 0.06321584f, -0.11385222f, 
    0.15626208f, 0.11595766f, 0.20796929f, 0.21604310f, 0.08065722f, 0.18048882f, 0.19772872f, 0.15733604f, 
    -0.11994801f, 0.06131373f, -0.03040409f, 0.22879349f, -0.09080249f, 0.15431617f, 0.05853525f, 0.22116582f, 
    0.19829407f, 0.11081330f, 0.04505472f, 0.06445213f, 0.10742176f, -0.04377893f, -0.05881223f, 0.23820762f, 
    -0.20101313f, 0.02493602f, -0.07912737f, -0.28944921f, 0.05501679f, 0.01632320f, 0.07140546f, 0.15677083f, 
    0.06714308f, -0.01762578f, 0.05230039f, -0.10959554f, -0.14670059f, 0.18946058f, 0.12528349f, -0.10688826f, 
    -0.15132248f, 0.06955300f, -0.06131899f, -0.22922640f, -0.13813962f, 0.15620691f, 0.17757076f, 0.04129828f, 
    -0.16076364f, 0.11054014f, 0.19464733f, 0.37237647f, 0.29622096f, -0.03290997f, -0.02606967f, -0.05781965f, 
    -0.05011248f, -0.11349383f, -0.18220080f, 0.05669405f, 0.09485025f, 0.07798255f, 0.08596434f, 0.12386579f, 
    -0.05613471f, 0.06034302f, 0.04746443f, 0.07788593f, 0.11607092f, 0.08176324f, -0.04474698f, 0.02625242f, 
    -0.10868391f, -0.06567576f, -0.00642687f, 0.05296257f, -0.16236140f, 0.03642732f, -0.52295983f, 0.12855199f, 
    0.12736951f, -0.00797825f, 0.34462875f, -0.15104164f, -0.05541317f, -0.06520449f, -0.16954237f, 0.10875306f, 
    0.24719407f, 0.06700369f, 0.08427776f, 0.02852840f, 0.00045897f, -0.30267569f, -0.08133987f, 0.17049976f, 
    -0.30967188f, 0.02179794f, 0.03495093f, 0.00977302f, 0.02839196f, 0.12911591f, -0.23742419f, -0.34496233f, 
    -0.05983396f, -0.04238856f, 0.10421138f, 0.08468390f, 0.02309219f, 0.06226181f, 0.01641754f, 0.05181195f, 
    -0.11797100f, -0.22548153f, -0.14078769f, 0.02900807f, -0.04876863f, 0.09242441f, 0.10015589f, -0.04345099f, 
    -0.12936524f, 0.20086281f, 0.02340435f, -0.14545806f, 0.05708022f, 0.07250526f, 0.07926314f, -0.18888341f, 
    -0.24382058f, -0.08910721f, -0.08750532f, 0.06187073f, 0.04842062f, 0.09746019f, -0.11215641f, 0.04986614f, 
    0.15902680f, 0.09552563f, 0.12185372f, -0.05905878f, 0.19133620f, 0.13271822f, -0.09053106f, -0.01905131f, 
    0.00552561f, -0.14813249f, 0.12051746f, 0.11429764f, 0.05700271f, -0.16351825f, -0.23736466f, 0.30565390f, 
    0.16875376f, -0.24555519f, 0.23122492f, 0.01357974f, 0.01415656f, -0.07029612f, 0.38826039f, -0.03373820f, 
    0.16525061f, 0.11785508f, 0.11207353f, -0.14643174f, -0.04667112f, -0.05838263f, 0.16271499f, 0.05650990f, 
    0.06137232f, 0.19028375f, -0.02560533f, -0.04926404f, -0.05234175f, -0.26602221f, -0.13035628f, -0.09898221f, 
    -0.42948875f, 0.11234409f, 0.40140733f, -0.00687324f, 0.11585903f, -0.20557211f, 0.05165002f, -0.14740366f, 
    -0.02752439f, -0.18349688f, -0.44610065f, 0.73246098f, 0.07507942f, 0.18886241f, -0.23307185f, -0.04716548f, 
    -0.10132423f, 0.11111915f, -0.03212701f, 0.01160881f, 0.36280814f, 0.05057610f, 0.12289002f, -0.36443716f, 
    0.09000498f, 0.17080115f, 0.16977334f, 0.13458154f, 0.13968483f, 0.18998663f, 0.12550448f, 0.13506022f, 
    0.16363768f, 0.13154887f, -0.18299349f, -0.03511848f, -0.44387245f, 0.17886730f, 0.28029674f, -0.05456409f, 
    0.10118192f, 0.01577649f, 0.03232849f, 0.18229799f, 0.13890359f, -0.19212840f, 0.07959335f, 0.27027002f, 
    0.06700611f, 0.04058382f, 0.11581530f, 0.07199689f, 0.02677579f, -0.07109869f, -0.66746604f, 0.27200204f, 
    -0.58397919f, -0.22495900f, 0.03007258f, -0.09658033f, -0.16396733f, 0.19424382f, -0.09132146f, -0.82659900f, 
    -0.61783981f, 0.21090992f, -0.23153861f, 0.05897312f, -0.33146480f, 0.02857888f, 0.00685577f, 0.13479665f, 
    -0.46458915f, -0.16259664f, 0.17200905f, 0.18583339f, -0.03561534f, 0.21916960f, -0.10368518f, 0.12024738f, 
    0.17239219f, -0.01611463f, 0.10870608f, 0.07208143f, 0.15895180f, 0.02818639f, -0.20824793f, 0.14038958f, 
    0.11434046f, 0.11365522f, 0.05776908f, -0.45529956f, -0.11020142f, -0.04162087f, -0.08716457f, -0.00601013f, 
    0.23437801f, -0.05807998f, -0.09615626f, -0.29122940f, -0.06246315f, 0.11611316f, 0.02981390f, 0.08260150f, 
    -0.42722633f, 0.10154934f, 0.10311789f, -0.18494241f, -0.45189536f, -0.34861901f, -0.01703397f, 0.01911114f, 
    0.09441136f, -0.28847381f, 0.25823438f, 0.01252653f, 0.06642407f, -0.06358238f, -0.21627250f, 0.14659832f, 
    -0.02934408f, -0.13692960f, -0.33949855f, -0.06452423f, -0.04148028f, 0.04332538f, -0.00439373f, -0.08895661f, 
    -0.19690028f, -0.20434532f, -0.24013565f, -0.32997322f, -0.23715794f, -0.03062871f, -0.35343453f, -0.13442038f, 
    -0.10814863f, 0.41009465f, -0.16947009f, -0.15343484f, -0.39858848f, 0.05021306f, -0.07826884f, -0.07328312f, 
    -0.06541108f, -0.26163647f, -0.03347446f, 0.01508628f, 0.04408958f, -0.09094640f, 0.15160228f, 0.06975744f, 
    0.18933077f, 0.28885025f, 0.11270566f, 0.29397476f, 0.21754083f, 0.10726828f, 0.10006991f, 0.00421881f, 
    -0.11538735f, -0.10057457f, -0.25707677f, -0.18999253f, -0.35194692f, -0.05092041f, 0.03262245f, 0.06820717f, 
    0.19034281f, 0.03642086f, 0.11352244f, -0.15447383f, -0.28704646f, -0.34905615f, -0.23002863f, -0.06940749f, 
    0.24234423f, -0.10265438f, -0.07574684f, -0.06931241f, 0.14579123f, 0.10799211f, 0.51669246f, -0.02035529f, 
    0.37781927f, 0.18841015f, 0.13087276f, 0.06357215f, 0.34773061f, -0.65655255f, -0.36236000f, 0.30801523f, 
    -0.01118775f, -0.06431963f, 0.02926596f, -0.03081864f, 0.10044674f, 0.01661940f, 0.20370978f, -0.22799668f, 
    -0.01546659f, -0.10622541f, -0.15204002f, 0.64213324f, 0.27612710f, -0.11921870f, 0.00655084f, -0.17594780f, 
    0.14978109f, 0.21857908f, -0.22384436f, -0.11710843f, -0.09592143f, 0.06505581f, 0.05395621f, -0.02487714f, 
    -0.10065843f, 0.19247971f, -0.26749590f, -0.17146708f, 0.02395325f, -0.25199583f, 0.11827309f, 0.02534017f, 
    -0.11161350f, 0.09557358f, 0.12510419f, 0.19587074f, -0.00532139f, 0.13538949f, -0.14304586f, -0.06250232f, 
    0.15388817f, -0.08717622f, -0.19376285f, 0.12747112f, -0.01664168f, 0.02030618f, -0.26627490f, 0.15780130f, 
    0.14717446f, 0.17725393f, 0.08574647f, -0.55954385f, -0.43203819f, -0.33944985f, -0.02497546f, -0.01156305f, 
    0.08441615f, 0.13125056f, 0.04006373f, -0.08903333f, -0.24746658f, -0.06552467f, 0.19046469f, -0.01147282f, 
    0.01815742f, 0.21676712f, 0.08557443f, 0.05281754f, -0.14834309f, -0.12127347f, -0.01764444f, -0.02127835f, 
    0.28858554f, 0.28170854f, -0.10746618f, -0.25327268f, 0.16577476f, 0.16305898f, -0.08430444f, 0.14771898f, 
    -0.46048778f, -0.27645487f, -0.20049912f, 0.01542577f, 0.22007331f, -0.19436644f, 0.08848598f, 0.08711119f, 
    -0.23597689f, -0.28277972f, 0.13197334f, 0.05068213f, 0.03541436f, 0.14480495f, -0.22772619f, -0.10618549f, 
    0.41287088f, 0.21623088f, -0.19340223f, 0.03277944f, -0.13244426f, 0.21061860f, 0.03524035f, 0.09509575f, 
    -0.01851563f, 0.40140107f, -0.09168161f, 0.29358679f, -0.03774346f, -0.14935531f, 0.05433059f, -0.13519193f, 
    -0.03045039f, 0.02420852f, 0.03181148f, 0.44276774f, -0.54336423f, -0.38354614f, -0.24550265f, 0.12306642f, 
    0.07952113f, 0.01889401f, 0.02143672f, -0.11410576f, 0.34964797f, -0.17219336f, 0.08069049f, -0.06706451f, 
    0.07447318f, -0.14068608f, 0.03872587f, -0.12724271f, 0.09158589f, -0.01206347f, -0.33045217f, -0.00872942f, 
    0.07253956f, -0.20460440f, 0.30745178f, 0.21487224f, 0.28444678f, 0.00528290f, 0.28348354f, -0.38665524f, 
    0.08462439f, -0.19983333f, 0.06023734f, -0.09772627f, 0.07388142f, -0.15677184f, 0.39145741f, 0.25649378f, 
    0.42328846f, 0.20530178f, 0.11605842f, -0.21237831f, -0.10719783f, 0.08041012f, -0.09628417f, 0.10276412f, 
    0.39231658f, 0.29984555f, 0.06141718f, -0.25389126f, -0.07199894f, -0.29365769f, 0.08937622f, -0.10391230f, 
    0.65324664f, -0.81664640f, -0.63323456f, 0.15946952f, 0.31506002f, -0.06577205f, -0.00001713f, 0.07221616f, 
    -0.01437996f, -0.09983986f, -0.54252303f, -0.11971221f, -0.28540158f, 0.03436504f, -0.25791761f, -0.11624351f, 
    -0.10273629f, 0.10673744f, -0.01399099f, -0.20429264f, -0.53321952f, 0.00919073f, -0.20041962f, 0.07522079f, 
    -0.12743598f, 0.05172740f, 0.29572320f, 0.30480987f, 0.03986634f, -0.14187673f, -0.05558915f, -0.07967316f, 
    0.11179807f, 0.18160868f, -0.16178268f, 0.15044373f, 0.16546346f, 0.24698560f, -0.01768907f, -0.05246203f, 
    0.05232823f, -0.19151431f, 0.04090102f, -0.00815465f, -0.07862069f, -0.16136310f, 0.24121174f, 0.55516994f, 
    -0.01882967f, 0.22712182f, -0.08471084f, 0.07710990f, -0.01162344f, -0.02599414f, 0.34521908f, -0.07726532f, 
    -0.33217296f, 0.13555917f, 0.08304427f, 0.00438072f, -0.02667153f, 0.08596514f, 0.10155735f, -0.08172816f, 
    0.49269754f, -0.06238278f, 0.28872684f, -0.61127919f, 0.24410120f, 0.14454898f, 0.30577612f, -0.23738994f, 
    0.13552824f, -0.16083106f, -0.18815812f, -0.01562613f, -0.16107610f, -0.09969111f, -0.00472700f, -0.13929109f, 
    -0.06664670f, -0.21897526f, 0.15572891f, -0.71688092f, 0.08830292f, -0.13624321f, 0.24278544f, -0.04172671f, 
    -0.08807132f, -0.30506915f, 0.46768945f, 0.21846946f, 0.02785718f, -0.00339175f, 0.06076360f, 0.28115362f, 
    0.09068144f, -0.03702791f, -0.01241946f, -0.27447340f, 0.45350498f, 0.00673074f, -0.19352174f, 0.01987929f, 
    0.20912993f, 0.03352942f, 0.37651435f, -0.05202546f, -0.24936330f, -0.49827421f, -0.47643062f, 0.18108922f, 
    -0.25843900f, -0.15709051f, 0.00695468f, -0.08316106f, -0.08044425f, 0.45243424f, -0.40900734f, -0.02982994f, 
    0.30269569f, -0.12827289f, -0.12578881f, 0.18573666f, 0.18866737f, 0.02463687f, -0.13154699f, 0.34069595f, 
    -0.25539419f, -0.09239504f, -0.03657176f, 0.27328205f, -0.07364178f, 0.28463537f, 0.13046442f, -0.66708046f, 
    0.54143107f, 0.42969021f, -0.17351232f, -0.14430372f, 0.03090567f, 0.01792342f, -0.13101485f, -0.10318342f, 
    0.68760180f, 0.46098024f, 0.07161324f, -0.04531568f, 0.12087002f, 0.47392154f, 0.10393421f, -0.00664061f, 
    0.05224876f, -0.15551373f, -0.26014349f, -0.42856237f, 0.13115741f, -0.13225663f, -0.20258470f, 0.03865442f, 
    0.03344310f, 0.20448771f, -0.00562819f, 0.12988748f, 0.30474848f, -0.11689679f, 0.09737591f, 0.18455653f, 
    0.07287505f, -0.12597123f, 0.09275605f, 0.32480082f, 0.59904683f, -0.09640419f, 0.18926866f, -0.09256091f, 
    -0.05495815f, 0.01169422f, -0.01491667f, 0.21519811f, -0.18600017f, -0.45891243f, -0.52267313f, 0.09673325f, 
    -0.05660263f, 0.11967165f, -0.12319673f, 0.00135083f, -0.11687369f, 0.35807800f, -0.16051187f, 0.56598788f, 
    0.10977882f, -0.06665016f, 0.01564826f, 0.01085401f, 0.02670413f, -0.29289490f, 0.02357181f, -0.37434301f, 
    0.15283717f, 0.06261598f, 0.20522629f, -0.34501198f, 0.08322378f, 0.15796821f, 0.12971379f, 0.03109012f, 
    0.04026061f, -0.37208202f, -0.13204692f, -0.35501054f, 0.05484415f, 0.16091828f, -0.09995124f, 0.13501203f, 
    0.08560040f, -0.08183406f, 0.16107725f, -0.20081110f, 0.13780600f, -0.02583748f, 0.11758515f, -0.01776891f, 
    0.16827273f, 0.62635255f, -0.25026721f, -0.07674198f, 0.12755311f, -0.17130616f, 0.10236311f, 0.13325211f, 
    -0.02406696f, 0.16602571f, 0.07561446f, 0.36722201f, -0.15272368f, -0.17835855f, -0.09266938f, 0.16773131f, 
    0.13385580f, 0.35800740f, 0.12212756f, -0.20792799f, -0.09317335f, -0.35105386f, 0.09743202f, 0.00416137f, 
    0.05322337f, 0.05119210f, -0.13356352f, 0.11867663f, -0.01866286f, -0.14617670f, -0.32153159f, -0.00903290f, 
    -0.10355281f, -0.14177591f, 0.07286739f, 0.27966762f, 0.07934333f, -0.14507876f, 0.13359486f, 0.04870240f, 
    -0.21153279f, 0.18837281f, 0.22298020f, 0.10400369f, -0.01280615f, 0.12625423f, 0.23829728f, 0.23958772f, 
    0.19452627f, -0.07087792f, -0.16496933f, 0.13936020f, 0.08766013f, 0.09327693f, -0.19019817f, 0.26264310f, 
    0.05481014f, -0.10115999f, -0.00607947f, 0.05494535f, 0.01562024f, -0.26503378f, 0.01292241f, -0.30007020f, 
    0.30404314f, 0.32236639f, 0.14136893f, 0.17847012f, -0.06951150f, -0.04189351f, 0.15091555f, 0.04588695f, 
    0.03523627f, -0.30095649f, -0.11263363f, 0.07259252f, -0.01888939f, -0.11346435f, -0.07401154f, -0.15010101f, 
    0.00883971f, 0.23933059f, -0.49611598f, -0.98771238f, -0.46616346f, 0.16418405f, -0.00871113f, 0.15020484f, 
    0.15203735f, -0.20886184f, -0.10048009f, -0.40791354f, -0.30710986f, -0.25951570f, -0.06608588f, 0.04405373f, 
    -0.18834503f, 0.20479439f, 0.08686001f, 0.28041941f, 0.15215497f, -0.09993994f, -0.22770032f, -0.18467461f, 
    0.06329918f, -0.02369238f, -0.12109505f, 0.25649875f, -0.01530986f, -0.17522450f, -0.59351522f, -0.27265275f, 
    0.03311501f, -0.09627405f, 0.40057600f, 0.06677559f, -0.09647631f, -0.06440609f, -0.69694716f, -0.83229685f, 
    -0.29470930f, 0.23513511f, -0.15823512f, 0.08684272f, -0.10524639f, 0.24059643f, 0.18091382f, -0.26429909f, 
    -0.46276215f, -0.07287402f, -0.16494532f, -0.15326183f, 0.19918521f, 0.17279212f, 0.00123750f, 0.11079353f, 
    -0.09073980f, -0.18348818f, -0.06759582f, 0.30032954f, 0.07740612f, 0.05415694f, 0.09757024f, 0.02776434f, 
    0.21356812f, -0.41690716f, -0.27197748f, -0.18586944f, -0.04443611f, -0.05205900f, 0.25836480f, 0.16441292f, 
    -0.04719581f, -0.01304693f, -0.15558557f, -0.03883584f, 0.17266773f, -0.03827075f, 0.05629530f, -0.16341862f, 
    0.18190585f, -0.00219693f, -0.30789188f, 0.35925889f, -0.18527442f, -0.52633274f, 0.05261836f, 0.01057061f, 
    -0.07298600f, 0.11376160f, -0.00496212f, -0.13232625f, 0.06557643f, -0.17773753f, 0.15476519f, 0.06671038f, 
    0.07230450f, 0.20088612f, 0.21777713f, 0.26199257f, 0.19471084f, 0.63114160f, -0.03986173f, -0.03358648f, 
    -0.07687292f, -0.21591584f, -0.02282724f, 0.02874173f, -0.05133530f, -0.22361973f, 0.22794579f, -0.14242718f, 
    -0.32165006f, 0.00735130f, -0.22942562f, -0.05603851f, 0.03455856f, 0.34599933f, -0.02094870f, -0.13555807f, 
    0.17790850f, -0.02254387f, -0.08160006f, -0.13948596f, 0.13563502f, 0.11589929f, 0.13027054f, -0.07620196f, 
    0.26935378f, -0.08587515f, -0.02234589f, 0.08603571f, -0.02387687f, -0.10167465f, 0.13882913f, -0.00603692f, 
    -0.45536661f, -0.38371360f, -0.09204908f, 0.23498842f, -0.05409470f, -0.17692722f, 0.15144482f, 0.01457701f, 
    0.03260922f, 0.39601609f, 0.14912003f, 0.00380192f, 0.17057453f, 0.12473509f, -0.07161441f, 0.04123962f, 
    0.22163181f, 0.14454508f, -0.11888395f, 0.09610469f, 0.13671745f, 0.06222762f, -0.10885715f, 0.10356401f, 
    0.15969929f, 0.20856608f, 0.10329698f, -0.03612427f, -0.04944094f, -0.22450870f, -0.28274399f, -0.10681394f, 
    -0.02671784f, 0.28350851f, 0.01148877f, 0.14327037f, 0.21305257f, 0.23893416f, 0.19154824f, 0.09198906f, 
    0.09417673f, -0.07543226f, -0.08339640f, 0.10751309f, 0.14035551f, 0.03784454f, -0.26992229f, -0.53749597f, 
    -0.10808096f, -0.04431286f, 0.02523272f, -0.18823755f, 0.40337145f, 0.16184336f, -0.11359271f, -0.45723349f, 
    -0.59682035f, -0.68177253f, -0.20726517f, 0.15148041f, -0.48109141f, 0.33949482f, 0.17262208f, -0.41156796f, 
    -0.15048034f, -0.05567910f, -0.04023865f, 0.11220402f, 0.12346042f, 0.17087722f, 0.17604394f, -0.00110574f, 
    -0.08811579f, -0.43131772f, 0.43584752f, -0.04221663f, -0.23734285f, -0.00579070f, -0.09303223f, 0.24758786f, 
    0.06826083f, 0.08059677f, -0.66307330f, -0.36601117f, 0.01014120f, -0.11326551f, 0.04100330f, -0.08853047f, 
    0.16712928f, -0.16060899f, -0.05223207f, -0.20478207f, 0.18273401f, -0.07590971f, 0.12487867f, 0.31878188f, 
    0.13758993f, 0.10058196f, 0.09472123f, -0.27103826f, -0.04075146f, -0.03369089f, 0.27209777f, 0.26258615f, 
    0.18304361f, 0.11736888f, 0.22301996f, 0.14134979f, 0.02459948f, 0.13241458f, 0.30179271f, 0.08132631f, 
    0.19203790f, 0.05718507f, 0.10044479f, 0.00364475f, 0.03868029f, 0.13519315f, -0.42253911f, -0.44316736f, 
    0.12746239f, -0.11625171f, -0.12082876f, -0.14920777f, 0.02493831f, 0.00933671f, -0.00498460f, -0.19711395f, 
    0.11461826f, -0.13020438f, 0.04263006f, -0.01954398f, -0.11269796f, 0.19337912f, -0.05454064f, 0.09881670f, 
    0.08377129f, 0.11525434f, 0.10928890f, -0.11630205f, -0.29119846f, -0.26310930f, -0.02553557f, 0.02578460f, 
    -0.22147682f, -0.05519681f, -0.10846634f, -0.60169905f, -0.06968906f, 0.20609815f, -0.13711545f, -0.03882022f, 
    0.02498235f, -0.04040772f, -0.35163692f, 0.22060728f, 0.07875672f, -0.01287065f, -0.01280588f, 0.06033631f, 
    0.04464038f, 0.15382604f, 0.08725565f, -0.43043247f, -0.17480262f, -0.25879660f, -0.19551359f, -0.07441197f, 
    -0.26568869f, -0.30470338f, -0.17048655f, 0.07451817f, 0.07422296f, 0.01682761f, -0.35122743f, -0.13649878f, 
    0.03224042f, -0.03677620f, 0.28351223f, 0.05148886f, 0.01351816f, -0.20116070f, -0.02222781f, -0.12441027f, 
    -0.24428757f, 0.09406611f, -0.14302897f, 0.11467665f, 0.01597845f, 0.04365827f, 0.08099551f, -0.23443833f, 
    -0.39114693f, -0.10601521f, -0.07958672f, 0.10895203f, -0.00998656f, -0.29392809f, -0.14904754f, -0.36634836f, 
    -0.04248508f, -0.19159426f, 0.05256791f, -0.16490117f, -0.15425217f, -0.09324351f, 0.08078530f, 0.13982767f, 
    -0.00119806f, 0.36364233f, 0.00468357f, -0.11672617f, -0.11235797f, -0.14110889f, 0.15521698f, 0.18830915f, 
    -0.04212134f, 0.18038276f, 0.07341262f, -0.22784536f, 0.03811776f, 0.14303862f, 0.27462578f, 0.04383034f, 
    0.25024113f, -0.03386528f, -0.01213769f, -0.23349592f, -0.20847212f, -0.08294403f, 0.03255015f, -0.06141944f, 
    0.24396914f, 0.04732988f, -0.10995697f, 0.22200577f, 0.03011638f, -0.17110194f, -0.02873788f, -0.25885653f, 
    0.50581133f, 0.06849204f, -0.15173343f, 0.32390976f, 0.06513894f, 0.28737646f, 0.17560628f, 0.15241785f, 
    0.17031674f, -0.12571163f, -0.22428709f, 0.17867531f, 0.03286042f, -0.38851669f, 0.04545960f, -0.45991832f, 
    0.13661709f, -0.11235907f, 0.05529891f, 0.25807503f, 0.14384364f, -0.05742600f, -0.72649008f, 0.27882338f, 
    -0.16380788f, 0.01831506f, 0.51910800f, 0.07069164f, -0.23507527f, 0.28891131f, -0.11872082f, -0.28103617f, 
    -0.32791555f, 0.08375876f, -0.00196644f, 0.07309619f, 0.03079607f, -0.01104535f, -0.13413119f, 0.09971159f, 
    0.01932497f, -0.01304733f, 0.23023415f, 0.02260999f, -0.00896363f, 0.08621649f, 0.21611065f, 0.04541595f, 
    0.07276794f, 0.15139453f, -0.03777858f, -0.47222877f, 0.13457619f, 0.01164498f, -0.13264926f, 0.08169200f, 
    0.11065204f, 0.03972195f, 0.02979864f, -0.10510313f, -0.31418374f, 0.19156684f, 0.03532283f, 0.18657325f, 
    0.22857334f, -0.07255185f, -0.02872626f, 0.21379401f, -0.31862110f, 0.05078263f, -0.16225018f, -0.17384961f, 
    -0.09566323f, 0.05774854f, -0.14178123f, 0.00216014f, -0.02254916f, 0.32437178f, 0.15583287f, 0.04407609f, 
    0.16385739f, 0.15687032f, -0.07787649f, 0.31796703f, 0.24547723f, -0.21611881f, 0.13852464f, 0.13260977f, 
    -0.06096302f, -0.20756584f, -0.14455082f, -0.02231116f, 0.03012449f, -0.09460366f, -0.31729457f, -0.12065383f, 
    -0.10966440f, -0.21709840f, -0.16935930f, 0.05757427f, -0.20760845f, -0.19515598f, 0.08079272f, 0.10553547f, 
    -0.15653813f, -0.12461477f, -0.13692707f, -0.27381605f, 0.06126965f, 0.00957977f, 0.09478083f, -0.13858661f, 
    -0.36678940f, 0.18394563f, 0.68062919f, -0.03343527f, -0.13300724f, 0.01851312f, -0.02152236f, 0.00647180f, 
    0.00911583f, -0.21682331f, -0.08439665f, 0.19678949f, 0.09972832f, -0.10752983f, -0.01147617f, 0.00851468f, 
    -0.05792564f, 0.09728404f, -0.09872895f, 0.02959378f, 0.18654834f, 0.06725881f, -0.04401033f, -0.00351107f, 
    0.33374420f, 0.36261016f, 0.10191364f, 0.07238355f, -0.73101145f, -0.48659122f, -0.07895844f, 0.10862023f, 
    0.14098069f, 0.03330814f, -0.01374957f, 0.08469436f, 0.18452056f, 0.29529321f, -0.18213245f, -0.03825652f, 
    0.22264767f, -0.07932214f, 0.09372272f, -0.02484865f, 0.03418070f, 0.07725889f, 0.50602233f, 0.14454718f, 
    0.11313664f, 0.06232644f, 0.06193855f, 0.11483253f, 0.23009421f, 0.15091704f, -0.70306516f, 0.31019422f, 
    0.16839556f, -0.30979118f, -0.11185139f, -0.09546313f, 0.00736423f, 0.08447015f, -0.04416410f, 0.00959782f, 
    -0.51463878f, -0.35608852f, 0.06543849f, -0.04808413f, -0.09475908f, 0.13570514f, 0.09761058f, -0.02279177f, 
    -0.08358986f, 0.20354800f, 0.72765881f, -0.24487083f, -0.15724675f, -0.33041841f, -0.07537733f, -0.14445804f, 
    -0.24643464f, -0.26587829f, -0.20819327f, 0.06047789f, 0.02027396f, -0.02009374f, -0.07827733f, 0.12289298f, 
    0.21710016f, -0.19532952f, -0.09034921f, -0.13571179f, 0.02824733f, -0.17500925f, -0.08079163f, -0.08183863f, 
    -0.02996037f, -0.07320933f, -0.05309279f, -0.25047660f, -0.15871313f, -0.28013811f, -0.16454607f, -0.30562291f, 
    -0.25046414f, 0.01858189f, -0.14520438f, -0.10489271f, 0.16496423f, -0.53568715f, -0.08784842f, 0.27708757f, 
    0.04807737f, -0.05164374f, 0.14637893f, 0.19231603f, 0.12406893f, -0.17622223f, -0.27959129f, -0.19362010f, 
    -0.03920276f, -0.19583027f, -0.20825034f, -0.04078961f, -0.06971268f, -0.04623934f, -0.31450573f, -0.25368595f, 
    -0.18073021f, -0.15317208f, -0.21569796f, -0.17149200f, -0.00046206f, -0.07070127f, 0.04794753f, -0.29839751f, 
    -0.10521356f, 0.12857613f, -0.37325445f, 0.26313654f, 0.02355150f, -0.06323233f, 0.00621288f, 0.19016965f, 
    -0.01163085f, 0.07501647f, 0.09158559f, -0.03075418f, -0.09534844f, 0.09513117f, 0.12599914f, 0.03858542f, 
    0.03198235f, 0.16769700f, -0.15754756f, -0.02997955f, -0.03873045f, -0.05063077f, 0.17709224f, 0.05306670f, 
    -0.01169676f, 0.04522051f, -0.44112110f, -0.07689914f, 0.04710611f, -0.10558050f, -0.21789038f, -0.16296610f, 
    0.07521802f, -0.11475879f, 0.04785205f, 0.05153875f, -0.04055709f, -0.18636847f, 0.00151004f, 0.00254457f, 
    -0.20189874f, 0.00160645f, 0.01234908f, 0.04939906f, 0.25466660f, 0.27836362f, 0.08116630f, 0.27556279f, 
    0.22542818f, 0.18180285f, -0.03462292f, 0.34988064f, 0.13174379f, -0.07584799f, -0.39642674f, -0.02349596f, 
    -0.19999249f, -0.12567444f, -0.15854824f, -0.02107178f, -0.17404777f, -0.17915016f, 0.07266079f, -0.29373661f, 
    -0.58919799f, 0.12678163f, -0.03056424f, -0.34897137f, 0.01889059f, -0.20905706f, 0.09794635f, -0.17038712f, 
    0.06593822f, 0.06893268f, 0.10545962f, 0.01356295f, -0.06694975f, 0.17282246f, 0.00078274f, 0.17784654f, 
    -0.32501835f, -0.39298183f, 0.03222778f, -0.09302313f, -0.11440521f, -0.16890483f, -0.23175824f, -0.12924583f, 
    -0.07694525f, 0.12521814f, 0.06553702f, -0.08596461f, 0.04418026f, 0.02932796f, 0.04080874f, 0.12367342f, 
    0.19809398f, 0.24275342f, -0.21226434f, -0.24825746f, 0.14101750f, -0.10265807f, 0.05191316f, -0.07619470f, 
    0.13370016f, 0.08415560f, 0.09101369f, -0.14446282f, 0.00741532f, -0.55934137f, -0.03003100f, -0.00170715f, 
    -0.02590193f, 0.05905387f, 0.13620548f, 0.03870087f, 0.04589790f, 0.35409564f, 0.14703782f, 0.12636313f, 
    0.14069791f, 0.15724376f, 0.12785400f, 0.12061509f, 0.11654729f, 0.00196218f, -0.00095494f, 0.36112168f, 
    -0.01154287f, -0.34005889f, -0.05874041f, 0.03056784f, -0.04973600f, 0.23717652f, 0.01181345f, 0.00151156f, 
    0.22112727f, -0.20900656f, -0.09515911f, 0.00199700f, 0.10494280f, -0.08225562f, -0.11281805f, -0.00955321f, 
    -0.09566648f, -0.19686593f, -0.14910422f, -0.32179955f, -0.01698360f, 0.06009242f, -0.05299204f, -0.04310761f, 
    -0.10806835f, 0.01282112f, -0.00631797f, 0.01278224f, -0.04115365f, -0.05432216f, -0.07594745f, -0.06024772f, 
    0.00141557f, -0.00498299f, -0.03567964f, -0.07361688f, -0.06820241f, -0.01922653f, -0.02914389f, -0.04003440f, 
    -0.00126089f, -0.04192231f, -0.01219360f, -0.01142069f, -0.07100835f, -0.01465738f, -0.06332450f, -0.00382103f, 
    0.01620556f, -0.03722746f, -0.00033541f, -0.06662614f, -0.04759907f, -0.07537362f, 0.05098294f, -0.00319926f, 
    -0.01144982f, -0.05440880f, -0.03471330f, -0.01803282f, 0.01435671f, -0.04193328f, -0.03347599f, -0.04599006f, 
    -0.07447658f, -0.04432750f, 0.02455768f, 0.02135353f, -0.07075670f, -0.08051956f, -0.02114684f, -0.08237711f, 
    0.02600024f, -0.04768138f, -0.00569497f, 0.01631117f, -0.02982295f, -0.08478022f, -0.00953091f, -0.05216815f, 
    -0.01465644f, -0.05095658f, -0.02418070f, 0.02948485f, -0.00665917f, -0.07249751f, -0.04639641f, -0.06399751f, 
    -0.02191320f, -0.01749496f, -0.07128609f, -0.02094990f, -0.05588477f, 0.01289170f, -0.11933031f, -0.10175140f, 
    0.00524153f, -0.05055257f, -0.08648786f, -0.02953051f, -0.08763272f, -0.02576227f, -0.07950467f, -0.03615759f, 
    -0.00803812f, -0.05991303f, -0.07190391f, -0.06351157f, -0.03097459f, -0.03934569f, -0.07950187f, -0.00729790f, 
    0.01891632f, -0.08258969f, 0.05123484f, 0.01794194f, 0.01260925f, 0.01178787f, -0.01503466f, -0.04199918f, 
    0.00426909f, -0.05686945f, -0.03003892f, -0.03503345f, 0.03356560f, -0.02644063f, 0.03026558f, -0.06284103f, 
    -0.00825035f, -0.00346398f, -0.01076386f, 0.01621970f, -0.06385843f, -0.10594925f, -0.02973489f, -0.06194065f, 
    0.02788694f, -0.05393026f, 0.01236190f, -0.03989648f, -0.09587095f, 0.00983190f, -0.00237007f, -0.02563633f, 
    -0.02317185f, -0.08410359f, 0.00250745f, -0.05347485f, -0.03074419f, 0.00407417f, -0.04626656f, -0.02316480f, 
    0.02740759f, -0.05696577f, -0.09244908f, 0.02529149f, 0.00195740f, 0.00401145f, 0.01359978f, -0.00459293f, 
    0.01133985f, -0.00553242f, 0.00551847f, 0.00454581f, 0.02631242f, -0.06985459f, 0.00846963f, -0.05318926f, 
    -0.05469541f, -0.04191181f, 0.00993566f, -0.01324286f, -0.06460933f, -0.07200458f, 0.00067298f, -0.03128186f, 
    -0.06130856f, 0.03732269f, -0.02399782f, -0.07206418f, -0.02266503f, -0.04969263f, -0.08066700f, -0.05518432f, 
    0.02944442f, -0.04344798f, -0.10669035f, -0.06694597f, 0.00989962f, -0.04320120f, -0.03209537f, -0.01101387f, 
    -0.09453514f, -0.03145483f, -0.03096107f, -0.06214647f, -0.01265107f, 0.02747608f, 0.00653681f, -0.05374429f, 
    -0.01058576f, 0.01155959f, -0.02940533f, -0.04634692f, -0.05625743f, -0.00365849f, -0.07333758f, -0.00690167f, 
    -0.08240696f, -0.07675567f, -0.01201014f, -0.06527006f, 0.00494478f, -0.06858880f, -0.04343870f, -0.09104142f, 
    0.02079505f, -0.09922055f, -0.09961434f, -0.01186404f, -0.01805534f, -0.00146470f, -0.05464519f, -0.09490401f, 
    -0.07739557f, 0.00740178f, 0.01202047f, 0.00870404f, -0.07985908f, -0.07457701f, -0.02014352f, 0.02253867f, 
    -0.00797642f, -0.01229113f, -0.00328876f, -0.06045734f, -0.05170077f, -0.01631651f, -0.05424697f, -0.06341873f, 
    -0.07527869f, -0.06836300f, -0.03694057f, -0.08967027f, -0.06790327f, -0.04434298f, -0.13287799f, -0.08834469f, 
    -0.02996422f, 0.03233190f, -0.04546864f, -0.02308167f, 0.02572314f, -0.01034701f, -0.04770868f, -0.07739281f, 
    0.00044682f, -0.00702539f, 0.02600067f, -0.05347649f, -0.02986545f, -0.08238065f, -0.08424521f, 0.01365958f, 
    0.00554541f, 0.00745650f, -0.10195188f, -0.00709486f, -0.04290078f, -0.01756522f, 0.02365159f, 0.02995239f, 
    -0.03804270f, -0.09907933f, -0.08090621f, -0.01575227f, -0.01985114f, 0.02615658f, -0.02068327f, -0.06371106f, 
    0.01275249f, -0.03049884f, -0.06672188f, 0.03642129f, -0.06971882f, -0.05599367f, 0.01270400f, -0.07006488f, 
    -0.09642271f, 0.01701347f, -0.02157624f, -0.04543488f, -0.07549107f, -0.00956986f, -0.04065262f, 0.05889776f, 
    -0.01697327f, 0.02593225f, -0.02573821f, -0.06725490f, -0.08359944f, -0.00777270f, -0.05578161f, -0.07854181f, 
    0.03284257f, -0.05094385f, -0.08027668f, -0.03883065f, 0.03209674f, 0.00287630f, 0.01033273f, -0.05530857f, 
    0.37749419f, -1.07379675f, -0.66621566f, 0.01622572f, 0.41112015f, 0.14379133f, -0.15081304f, -0.06554734f, 
    0.00900706f, 0.04348895f, -0.77239752f, -0.39515206f, 0.12646031f, 0.05813562f, 0.17804648f, 0.16080876f, 
    -0.02601484f, -0.17999569f, -0.30458415f, 0.16634552f, -0.23163629f, -0.15186921f, 0.13849875f, 0.08440684f, 
    0.06881127f, 0.07570180f, -0.02570092f, -0.22148888f, -0.11114558f, 0.02316642f, 0.13001001f, 0.31253058f, 
    0.06067282f, 0.22963236f, 0.04058119f, 0.07607375f, -0.00559308f, 0.35176048f, -0.14625369f, 0.23129548f, 
    0.04087345f, -0.03248782f, 0.10870033f, 0.02005271f, 0.03253203f, -0.75027287f, -0.40312880f, -0.16240989f, 
    0.12404064f, 0.10967164f, 0.14451584f, 0.04420968f, 0.06268132f, 0.03753700f, -0.54869592f, -0.52429366f, 
    -0.06076196f, -0.09370133f, -0.01068893f, -0.08184105f, -0.09673986f, -0.14071959f, 0.02933604f, -0.06079885f, 
    -0.38803458f, -0.11330616f, 0.04418116f, 0.05552630f, -0.17269060f, 0.08198346f, 0.01639119f, 0.03238984f, 
    -0.92869169f, -0.08027136f, -0.22441277f, 0.09509560f, -0.06249642f, 0.09740818f, -0.24081787f, -0.16367987f, 
    0.07918755f, 0.22212997f, 0.09017006f, -0.07423841f, 0.15261476f, 0.07638853f, -0.11324592f, 0.07279216f, 
    0.10233127f, 0.01537272f, 0.01683860f, 0.19311376f, -0.14284012f, -0.13826580f, 0.04715558f, -0.03539451f, 
    0.22777079f, 0.04151113f, 0.09502335f, -0.09703639f, -0.03143269f, -0.13139462f, -0.19891866f, -0.06259471f, 
    -0.06278683f, -0.09637910f, 0.04427763f, 0.08497316f, -0.26028678f, 0.04906714f, 0.21292599f, 0.06063706f, 
    0.03005753f, -0.16314708f, 0.03408327f, 0.00658614f, 0.05371056f, -0.18635955f, 0.19407235f, 0.05595235f, 
    -0.05152399f, -0.09327311f, 0.04525166f, -0.09061176f, -0.07361840f, -0.01933102f, 0.26638988f, 0.08724920f, 
    -0.14652513f, 0.00666417f, -0.07293382f, -0.12371060f, -0.00413540f, 0.02979961f, -0.08095447f, -0.35006166f, 
    -0.24576242f, 0.00908915f, -0.00708735f, 0.08817006f, -0.03355184f, 0.06781727f, 0.07011186f, -0.12406892f, 
    0.08489434f, 0.23760137f, -0.00643047f, 0.02726877f, -0.06999263f, -0.02091214f, 0.03017917f, -0.04175339f, 
    0.23810752f, 0.13023119f, 0.34305140f, 0.03782711f, 0.04490754f, 0.10473476f, 0.06997941f, 0.10878508f, 
    0.04148365f, 0.12263050f, -0.25438333f, -0.63208222f, -1.11913407f, -0.07337812f, 0.12518340f, -0.10835338f, 
    -0.02078637f, -0.05204787f, -0.08243231f, 0.09143352f, -0.00370419f, -0.15214786f, -0.08928984f, -0.10496050f, 
    0.00941461f, 0.06442996f, -0.19441469f, 0.00578614f, -0.19927660f, 0.39596063f, 0.26028013f, 0.09417325f, 
    0.22049254f, 0.10202952f, 0.12268832f, 0.23697875f, 0.20947127f, -0.86868763f, 0.42058921f, -0.18114501f, 
    0.06545179f, -0.05738041f, -0.01473915f, -0.17416140f, 0.00300146f, -0.09063306f, -0.18150932f, -0.58003253f, 
    -0.77539325f, 0.01986440f, 0.65837848f, 0.07659610f, 0.22791530f, 0.19257782f, -0.15722448f, 0.15222606f, 
    0.14472967f, -0.19224359f, -0.14588428f, -0.10842243f, 0.03382794f, 0.07042911f, 0.03419280f, 0.08091600f, 
    0.33410749f, -0.19387685f, -1.16087329f, -0.20982055f, -0.30229422f, 0.13428885f, 0.18999246f, -0.13161528f, 
    0.09712096f, 0.24212301f, 0.33197305f, -0.09083766f, -0.02873420f, 0.11955351f, -0.09219307f, 0.09205096f, 
    0.07402600f, 0.10388727f, -0.17060320f, 0.10010812f, 0.21055739f, -0.01981330f, -0.05321296f, 0.06246969f, 
    0.06816404f, 0.05098040f, 0.10953170f, -0.66332573f, -0.27584493f, 0.22369139f, -0.27557576f, 0.17302670f, 
    0.14310381f, -0.04689393f, 0.03203166f, 0.08653314f, -0.08811158f, -0.05054948f, -0.29121056f, 0.01019804f, 
    0.09385182f, 0.04932994f, 0.19565529f, 0.03094216f, 0.08103804f, 0.06405949f, -0.58442891f, -0.59749663f, 
    -0.02455577f, 0.07220356f, 0.04284686f, 0.25703287f, 0.05472890f, 0.00097466f, 0.39812890f, 0.14303650f, 
    -0.11420481f, -0.00282966f, 0.02299571f, 0.04383535f, -0.07394007f, -0.05312465f, 0.06279343f, 0.09976939f, 
    -0.14640982f, -0.30791470f, -0.08764937f, -0.15247905f, -0.09573568f, 0.00335435f, 0.00528925f, -0.13550659f, 
    -0.03165253f, -0.17477348f, -0.12693098f, -0.12739387f, 0.07984269f, -0.07482652f, 0.12335830f, 0.01577264f, 
    -0.07353730f, -0.64798808f, 0.17220606f, 0.10980770f, -0.22858934f, -0.00221063f, -0.66239333f, 0.12344143f, 
    -0.06488506f, -0.11653159f, -0.31355277f, -0.67229241f, 0.15794253f, -0.24854374f, 0.27039570f, -0.35575888f, 
    0.00316944f, -0.04914979f, 0.12788914f, -0.39104423f, 0.64421690f, -0.05735840f, 0.09599862f, -0.07069943f, 
    0.08654264f, -0.06768963f, 0.04604522f, -0.00379058f, -0.52129537f, 0.16805194f, -0.04742816f, 0.03027355f, 
    -0.19458637f, -0.01231010f, -0.05324388f, 0.14466694f, -0.23502384f, 0.00986314f, 0.05864928f, 0.23076020f, 
    0.17314577f, -0.05014752f, -0.12420775f, -0.07079420f, 0.09278537f, 0.11483399f, 0.05463400f, -0.03459477f, 
    0.57783645f, 0.21690495f, -0.40904200f, -0.03318843f, 0.03402171f, -0.00829354f, 0.06156631f, 0.22550045f, 
    0.31300652f, 0.35220468f, 0.06372700f, -0.04755313f, -0.04769706f, 0.05510985f, -0.02498655f, 0.10205124f, 
    0.11734794f, 0.04019178f, 0.35734749f, 0.00561175f, -0.37899607f, -0.12115631f, 0.04300749f, -0.05273817f, 
    0.07288750f, 0.08491361f, -0.07541025f, 0.03837467f, 0.02018300f, 0.22492155f, 0.13476479f, 0.05791656f, 
    -0.01613487f, 0.01824924f, -0.00087825f, 0.21670343f, 0.22049253f, -0.23143072f, -0.21302009f, -0.21659847f, 
    0.08534389f, -0.01389446f, 0.03642366f, -0.33795792f, -0.16695331f, -0.04814827f, -0.31151894f, 0.14818321f, 
    -0.15617628f, -0.07498414f, -0.04956727f, -0.03588156f, 0.26996848f, 0.26474088f, 0.07697631f, 0.00236888f, 
    0.20263456f, 0.09256485f, 0.15364659f, 0.00192583f, 0.00072837f, 0.03491471f, -0.26941264f, 0.04843270f, 
    0.08717187f, 0.05245621f, 0.00222618f, 0.14752537f, -0.12040935f, -0.02049200f, 0.17973544f, -0.12453551f, 
    -0.23828755f, -0.00783259f, 0.08269759f, 0.14303681f, 0.18313654f, -0.06519057f, 0.01296470f, -0.18227139f, 
    0.09411749f, -0.09380248f, -0.16019379f, 0.03619630f, -0.13668859f, 0.20926969f, -0.14581974f, 0.08398047f, 
    -0.00978061f, 0.22653194f, 0.18981354f, -0.22416651f, -0.09104842f, -0.06305034f, 0.14266205f, 0.05524735f, 
    0.16418551f, -0.36622408f, 0.05686276f, -0.05338327f, -0.00692236f, -0.09814505f, 0.13113546f, 0.10315473f, 
    0.14766563f, -0.02650234f, 0.13073640f, -0.19943120f, -0.03065141f, -0.11527783f, 0.09162310f, -0.06073437f, 
    0.04585332f, -0.03873166f, -0.01122268f, -0.11955786f, -0.05648869f, 0.21439222f, -0.05795047f, -0.09371033f, 
    0.06297365f, 0.23952681f, 0.04087994f, 0.08064421f, 0.10155928f, -0.14931314f, 0.32625452f, -0.11118342f, 
    0.06892890f, -0.10814577f, 0.06603365f, 0.25993797f, 0.07223976f, 0.13285032f, -0.20608976f, -0.08565886f, 
    0.08013967f, -0.45311573f, 0.03999671f, 0.02050175f, 0.11527240f, 0.12543353f, -0.09555189f, -0.08915298f, 
    -0.32899180f, 0.05048005f, 0.15647514f, -0.00799918f, -0.14674810f, -0.09076859f, -0.06492396f, -0.34256104f, 
    -0.02096740f, -0.10662244f, 0.05506730f, 0.01968025f, 0.03380637f, 0.04107389f, 0.01030400f, -0.02105009f, 
    -0.04265509f, 0.04081748f, -0.22918199f, 0.03442883f, -0.03139596f, -0.14533305f, 0.11501057f, 0.10727782f, 
    0.18349689f, -0.21227863f, -0.20642529f, -0.24301931f, -0.03865887f, 0.06568500f, 0.06949498f, 0.00889915f, 
    0.13358144f, 0.03756483f, -0.19865103f, -0.32286742f, -0.47549307f, 0.00828197f, -0.13786764f, 0.10406077f, 
    0.06293119f, 0.04525209f, 0.01058773f, 0.33782628f, 0.24299456f, 0.52089113f, -0.11127026f, -0.30959675f, 
    0.19191024f, -0.01610698f, -0.02209679f, -0.00956651f, 0.01346215f, -0.06715776f, 0.02285822f, 0.09930252f, 
    -0.04154905f, -0.14798571f, 0.10666212f, 0.17304891f, 0.05158050f, -0.34514791f, 0.24887592f, -0.42923838f, 
    -0.18663380f, 0.02988841f, -0.34687254f, -0.05496809f, 0.13903520f, -0.01210911f, -0.67477810f, -0.23010735f, 
    -0.34720245f, 0.07213645f, -0.17488408f, 0.12870832f, -0.02755265f, -0.09946391f, 0.30224454f, -0.23161569f, 
    -0.03438063f, -0.00310347f, -0.17396031f, -0.12618691f, -0.08936511f, -0.12287638f, 0.18313013f, -0.22202045f, 
    -0.03937864f, -0.01067012f, 0.04440461f, 0.02400201f, -0.05626552f, 0.01875278f, -0.01219861f, -0.04335963f, 
    0.01366013f, 0.04500621f, 0.05031163f, -0.00106780f, -0.04576128f, 0.05213543f, 0.04114174f, 0.04818581f, 
    0.01571287f, -0.05990195f, -0.02164847f, -0.01810989f, -0.03065192f, 0.02016556f, -0.00695380f, -0.05435492f, 
    0.03338727f, -0.01323553f, -0.02914180f, -0.01976428f, -0.01428818f, -0.01238324f, 0.01984097f, -0.00261095f, 
    0.04548169f, 0.01880838f, 0.00830939f, -0.01795207f, 0.01515627f, -0.03429559f, 0.00660818f, -0.02722329f, 
    -0.03235105f, -0.01486970f, 0.04318457f, -0.03363251f, 0.01420579f, -0.01389324f, -0.00312109f, -0.01849012f, 
    -0.03475086f, -0.00488767f, 0.01823524f, -0.05174700f, -0.02660133f, 0.01774465f, -0.02018601f, -0.05253362f, 
    0.01823255f, -0.02208898f, 0.02161171f, -0.03990155f, 0.03495579f, 0.01222490f, -0.06768046f, 0.02926708f, 
    -0.02608922f, 0.01718317f, -0.03731683f, 0.04820486f, -0.06167068f, 0.00504954f, -0.05676417f, -0.02846387f, 
    -0.01770354f, 0.02214608f, -0.03079768f, -0.03142743f, -0.03785344f, -0.05698174f, -0.03292675f, -0.01248155f, 
    0.03053547f, -0.02765103f, -0.02103277f, -0.04494167f, 0.03368229f, -0.06549150f, 0.02264235f, -0.02275966f, 
    -0.02567744f, -0.05749758f, -0.05628826f, -0.04315752f, -0.02907266f, -0.01004332f, -0.03917904f, 0.04294791f, 
    -0.00175778f, -0.05590889f, -0.01957437f, -0.02594957f, 0.04014615f, 0.03004071f, -0.01490559f, -0.05895014f, 
    -0.01396583f, -0.02687614f, 0.04769182f, -0.05786206f, 0.01152312f, -0.02710603f, -0.00690265f, -0.02293634f, 
    0.02098284f, 0.02515264f, 0.03443434f, 0.04014641f, -0.05039380f, -0.04357547f, 0.04009261f, 0.02016715f, 
    0.04626419f, 0.03253721f, 0.04522165f, -0.01001987f, 0.00592527f, 0.00380245f, -0.00670469f, 0.04159135f, 
    0.02031515f, -0.01762469f, -0.01151338f, 0.02929982f, -0.01801318f, 0.01993230f, 0.04908307f, -0.04893467f, 
    -0.05989959f, 0.00386744f, -0.00666083f, -0.04716431f, -0.00324452f, -0.05856383f, 0.03514785f, 0.04204404f, 
    -0.05514490f, 0.03870527f, -0.01126068f, -0.03698448f, 0.02545345f, -0.05526319f, -0.03961443f, 0.03858974f, 
    -0.00176446f, 0.00500842f, -0.03020675f, 0.01171041f, -0.02598268f, 0.03766766f, -0.03034816f, 0.02932342f, 
    -0.00539780f, -0.02655406f, -0.02699905f, -0.05178880f, 0.00927379f, -0.01226686f, 0.03194742f, 0.02702434f, 
    0.01071658f, 0.02470500f, -0.01493687f, 0.04542179f, 0.02644805f, 0.04268224f, 0.05104986f, 0.03836199f, 
    -0.01968213f, 0.01138068f, -0.02945038f, -0.01341568f, 0.03968350f, 0.03283432f, -0.00742258f, -0.02553247f, 
    0.00682201f, -0.04847850f, -0.04963529f, -0.06121030f, -0.06337608f, -0.02754097f, 0.03723781f, 0.02734472f, 
    -0.00921182f, -0.06106567f, -0.06040695f, 0.04427141f, -0.04713764f, 0.01159259f, -0.04353568f, 0.01329559f, 
    -0.06314492f, 0.04342281f, -0.01646329f, -0.04013154f, 0.00276596f, 0.01990451f, -0.05147124f, 0.04677712f, 
    -0.00514655f, 0.03341467f, -0.02059849f, -0.03032555f, -0.02389503f, -0.04737400f, 0.04913858f, 0.03485555f, 
    -0.02413424f, 0.03916516f, -0.04016736f, 0.02839337f, 0.00467586f, 0.03675193f, 0.03340845f, -0.06113816f, 
    0.05328947f, 0.01809588f, -0.03469219f, 0.02247017f, -0.06717005f, 0.00095354f, -0.06320705f, 0.01884830f, 
    -0.04471293f, 0.00496503f, -0.04708687f, -0.02855834f, 0.00454543f, 0.02188062f, 0.02646649f, -0.04760733f, 
    -0.06167893f, 0.04466846f, -0.03381164f, -0.04319174f, 0.01948796f, 0.00171441f, -0.01542033f, 0.03410663f, 
    -0.01947726f, -0.02119160f, -0.03568126f, -0.01208622f, 0.01778859f, 0.02429253f, 0.04678283f, -0.05986244f, 
    -0.01990606f, -0.01630389f, -0.01737979f, 0.02978949f, 0.04504472f, -0.03903154f, 0.04431492f, -0.04997865f, 
    0.01499220f, -0.03844177f, -0.01658942f, 0.02027640f, 0.01364712f, -0.04450174f, 0.00605845f, -0.02765082f, 
    -0.03904893f, 0.04174351f, -0.00611790f, -0.03836767f, -0.00047893f, 0.01418314f, -0.04219468f, 0.02634204f, 
    -0.03778220f, -0.02602484f, 0.03336689f, 0.01439880f, -0.02236629f, -0.03329987f, -0.01518823f, 0.02712375f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.07056331f, 0.04018122f, 0.01973143f, -0.02036780f, 0.15330653f, -0.03385377f, 0.07447226f, 0.13798124f, 
    0.32621196f, 0.13128430f, 0.05857217f, 0.14781605f, -0.11310611f, 0.03567268f, 0.21793011f, 0.14842999f, 
    0.01516663f, -0.01247511f, -0.03631048f, -0.03428038f, 0.24129677f, 0.01730138f, 0.09719303f, 0.25605708f, 
    -0.25431290f, 0.17787294f, 0.26783910f, 0.42210591f, -0.04974243f, 0.18875405f, 0.08616737f, -0.02233622f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.18418452f, 0.11158688f, 0.05022982f, -0.01591553f, -0.68728685f, -0.16799378f, 0.25459117f, -0.24652125f, 
    -0.13796152f, -0.24250650f, -0.57716596f, -0.19834079f, 0.37408593f, 0.29874235f, -0.72061938f, -0.04981406f, 
    -0.04654419f, 0.12323386f, -0.11708581f, 0.13988714f, 0.04549759f, 0.16396032f, 0.24234699f, 0.27871719f, 
    0.78533655f, 0.25886202f, -0.51816469f, -0.21130598f, -0.07604837f, -0.65100372f, -0.09427000f, 0.04407609f, 
    0.03774443f, -0.12403345f, 0.08040403f, 0.09893958f, 0.09131517f, -0.15203138f, 0.87225664f, -0.38247108f, 
    0.31569612f, 0.15974517f, -0.22070903f, -0.14744578f, 0.21637194f, -0.20011722f, -0.32884973f, -0.23890482f, 
    -0.08318053f, -0.44004092f, 0.05668107f, -0.03517255f, 0.67651021f, 0.02861471f, 0.14562258f, -0.61564660f, 
    -0.17155166f, 0.32337657f, -0.55559671f, 0.24096556f, 0.02394297f, 0.17933436f, -0.21210998f, -0.00899792f, 
    -0.19679324f, 0.10024472f, 0.01695804f, 0.10429893f, 0.30229500f, -0.16035959f, -0.89245111f, -0.81163293f, 
    -0.09483837f, -0.14691132f, -0.48952615f, -0.18806762f, -0.06914982f, -0.15956844f, 0.22735691f, -0.14526068f, 
    0.04520071f, 0.43315983f, 0.07691830f, 0.13883950f, -0.62835443f, 0.00314611f, 0.01554353f, 0.31464669f, 
    -0.56594151f, 0.45480612f, -0.12611699f, 0.57860672f, 0.14600649f, -0.60059559f, -0.88538766f, -0.12254430f, 
    0.08456239f, 0.00452754f, 0.04375071f, -0.11395199f, 0.61319256f, -0.16219607f, -0.56094688f, 0.05282521f, 
    -0.58016342f, 0.09685549f, 0.21935000f, -0.08143916f, 0.23987569f, -0.19170956f, -0.06757949f, -0.94853199f, 
    -0.08435249f, 0.41863319f, 0.12503603f, 0.03678347f, -0.44467083f, -0.11373257f, -0.56523615f, -0.51286685f, 
    0.04648663f, 0.30401093f, -0.61913615f, -0.52659887f, 0.08168652f, -0.39885408f, 0.25615883f, 0.13721754f, 
    -0.44300318f, -0.05633809f, -0.17270675f, 0.10460000f, -0.22355673f, -0.07353511f, 0.38877422f, -0.67454559f, 
    -0.29953298f, 0.20791306f, 0.43127728f, 0.54770571f, -0.16546179f, 0.34237042f, -0.30252588f, 0.13404112f, 
    0.07318174f, 0.02168929f, 0.00217524f, -0.09176471f, -0.39125749f, 0.03544368f, 0.22242373f, -0.53577048f, 
    -0.29693192f, 0.00906418f, -0.31487799f, -0.37786600f, 0.07899615f, -0.07354473f, 0.51498508f, 0.03279697f, 
    0.27246922f, 0.11388542f, 0.01282962f, -0.16504529f, -0.09067368f, -0.05263842f, -0.05736644f, 0.49883613f, 
    -0.16739289f, 0.43625221f, 0.03502339f, -0.11710218f, -0.30091873f, 0.21015325f, 0.19468454f, 0.60820442f, 
    -0.09997154f, -0.22707146f, -0.06182882f, 0.16530713f, -0.00175234f, 0.04032322f, 0.28836995f, -0.38956687f, 
    0.03056197f, -0.04591076f, 0.17896618f, 0.03104809f, 0.08345141f, -0.31961975f, -0.57940453f, -0.08729834f, 
    -0.17857954f, -0.17002356f, 0.01790596f, 0.07730988f, -0.17185311f, 0.16123626f, -0.32178941f, -0.30791152f, 
    0.20119290f, -0.64549220f, -0.63902748f, 0.26024717f, -0.41103458f, -0.76274776f, 0.32307464f, 0.98831117f, 
    0.09059235f, 0.27769077f, -0.10136526f, 0.08037199f, -0.23483519f, -0.06221179f, -0.43781316f, 0.17620780f, 
    -0.37949547f, -1.01210308f, 0.55890614f, 0.37484893f, 0.00755225f, -0.00147648f, -0.84014922f, 0.03114370f, 
    0.17956255f, -0.16259870f, -0.16823718f, 0.04781819f, -0.01404248f, -0.02243414f, 0.36492208f, 0.77742779f, 
    -0.30324823f, 0.10625289f, -0.27124617f, -0.41713449f, 0.44793192f, -0.41887400f, 0.07954177f, -0.20913370f, 
    -0.15835235f, 0.37827429f, -0.01671678f, 0.02953427f, 0.29208145f, 0.15417802f, -0.03079315f, -0.20658022f, 
    0.24574488f, -0.58171391f, -0.47866842f, -0.47005063f, -0.19285075f, 0.36339292f, -0.14389974f, 0.02567001f, 
    0.51908875f, -0.02416154f, -0.02647355f, -0.15792756f, -0.02663916f, -0.14683717f, -0.66104287f, 0.70281374f, 
    -0.06509385f, 0.14280264f, -0.01643344f, -0.30842954f, -0.23321404f, 0.02200933f, -0.35027334f, -0.34143865f, 
    -0.07067668f, -0.56079119f, 0.03332572f, -0.04100307f, -0.36544877f, 0.11002601f, 0.20485242f, -0.01166336f, 
    -0.59439909f, -0.06504988f, 0.30259722f, 0.08323801f, 0.00322958f, 0.82534641f, -0.16731328f, -0.09161729f, 
    -0.85085511f, -0.04881481f, 0.17469653f, -0.01229936f, 0.18248767f, -0.10560056f, -0.21408589f, -0.30239829f, 
    0.08584360f, -0.27210376f, -0.57769346f, 0.34951425f, -0.75979018f, -0.50947481f, 0.34516749f, -0.20844993f, 
    -0.06803357f, -0.03118219f, 0.16440713f, -0.11096404f, 0.29458734f, 0.03791463f, 0.31187418f, -0.51793343f, 
    0.08830480f, -0.32539502f, 0.54608625f, 0.34540924f, 0.06305248f, -0.18573362f, 0.99923950f, -0.01033654f, 
    0.24097618f, -0.15562963f, 0.07079514f, 0.06372356f, -0.21097599f, -0.12734143f, -0.28171581f, -0.32715887f, 
    0.28149420f, -0.47562411f, 0.78110635f, -0.45799381f, 0.52100080f, 0.06541491f, -0.08571997f, -0.71097171f, 
    -0.01115964f, -0.30427489f, -0.05590370f, -0.13496009f, -0.44486365f, -0.08118633f, -0.01509218f, 0.50836492f, 
    -0.54748672f, -0.53342247f, 0.68461603f, -0.25111166f, 0.14665346f, -0.58509988f, 0.12879843f, 0.06821832f, 
    -0.07754750f, 0.07465983f, 0.02637663f, 0.10377029f, -0.10583545f, -0.02522573f, -0.25526306f, -0.37810379f, 
    0.37848106f, 0.34032780f, 0.11926299f, 0.37940013f, -0.85328197f, -0.38405704f, 0.24031839f, -0.52229416f, 
    0.06081206f, -0.28963271f, 0.03742987f, 0.13697046f, 0.09647089f, -0.03945440f, -0.20348531f, 1.05991805f, 
    -0.40467995f, -0.19986412f, -0.58395946f, -0.89466494f, 0.08520108f, -0.30208012f, -0.08002873f, -0.05379228f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11271912f, -0.02702833f, 0.30369979f, 0.06619238f, -0.13064095f, -0.19233908f, 0.16861008f, -0.45317024f, 
    -0.16500774f, 0.12572537f, 0.03410816f, -0.09444281f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
