#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.44359553f, 0.91220665f, 0.77301842f, -0.21053150f, -0.51355714f, -0.59064043f, 0.53297180f, -0.15539792f, 
    -0.37116387f, -0.57217473f, 0.14005637f, 0.14887491f, -0.61659575f, -0.16773142f, -0.43372846f, -0.25008231f, 
    -0.42117026f, -0.25673950f, -0.08254253f, -0.36156130f, 0.18905048f, 0.44654962f, 0.09967983f, 0.02544896f, 
    0.14688499f, -1.64849067f, -0.12199586f, -0.41327891f, 1.10219300f, -0.36700943f, 0.78577459f, 1.11181247f, 
    -0.17367844f, 0.31069610f, -0.45824423f, -0.12509611f, -0.26049739f, 0.37043720f, -0.14732097f, -0.04047837f, 
    -0.00917868f, 0.04033127f, -0.17452438f, -0.26722959f, -0.09710743f, 0.21294147f, 0.20240717f, 0.11727436f, 
    -0.20350182f, -0.09987888f, -0.04444659f, -0.59905040f, 0.11370684f, 0.59933615f, -0.52272493f, -0.99420834f, 
    -0.58064628f, 0.10890768f, -0.67699987f, -0.26821992f, 0.28635255f, -0.28459325f, 0.36704859f, 0.09562964f, 
    -0.20998022f, 0.37060735f, -0.19986534f, -0.31630358f, -0.08439337f, -0.42010275f, -0.36079428f, 0.04186317f, 
    0.12489262f, 0.35112843f, 0.48987457f, 0.85097939f, 0.81891531f, -0.77567655f, -0.92935872f, -0.86956143f, 
    -0.06724343f, 0.19651124f, -0.66519743f, -0.72300011f, -0.89677221f, 0.17002992f, -0.18962291f, 0.01280291f, 
    -0.08196269f, -0.23860444f, 0.10475626f, -0.12508111f, 0.00397962f, -0.06296352f, -0.09070575f, 0.01663096f, 
    -0.11803748f, 0.19082825f, -0.13880534f, 0.14279026f, 0.98889261f, 0.38205603f, 0.00413281f, -0.88518608f, 
    0.63255316f, 0.78513247f, -0.40587363f, -0.74742103f, -0.84746438f, -0.40268728f, 0.02439270f, 0.48399574f, 
    0.14163341f, 0.38771904f, -0.40059227f, 0.00961793f, 0.01968700f, 0.09529244f, 0.01491272f, 0.14630547f, 
    -0.03585968f, -0.20331056f, 0.08973545f, -0.16457202f, 0.09725139f, -0.60326838f, -0.71209610f, -0.42292067f, 
    -0.90097892f, -0.38907635f, 0.09000306f, -0.89231330f, 0.22256795f, 0.08604222f, -0.40856820f, 0.68416101f, 
    -0.42617843f, -0.29698056f, 0.36480102f, 0.00170213f, 0.25643703f, 0.42157662f, -0.37329814f, 0.17900611f, 
    0.26737699f, 0.05716320f, 0.38799596f, 0.04232639f, 0.44802675f, -0.45928377f, 0.67513317f, -0.99411541f, 
    0.93841320f, 1.08088112f, 0.03011236f, -0.39286333f, -0.04807484f, -0.27544585f, 0.16285089f, -0.08457737f, 
    0.37787393f, 0.16983654f, 0.11638873f, 0.25279754f, 0.02044323f, -0.36896583f, -0.31285903f, -0.39071196f, 
    0.09250894f, -0.04982064f, -0.59050155f, 0.15043284f, 0.05474595f, 0.12769718f, 0.39112973f, 1.34545839f, 
    0.01980879f, -0.15131919f, 1.23476136f, 0.79224259f, 0.21442120f, 0.37562275f, -0.40214768f, 0.12061755f, 
    0.03918762f, -0.44825959f, -0.34819269f, -0.34314188f, -0.22556677f, -0.44327438f, -0.23622681f, 0.21755953f, 
    -0.19015828f, -0.23042135f, -0.22134417f, -0.21992928f, -0.01121995f, -0.27363726f, -0.35873112f, -0.02807012f, 
    -1.06078231f, 0.03528466f, 0.48284918f, 0.00258238f, -0.62438804f, 0.44163054f, 0.03865916f, -0.60803229f, 
    -0.55577153f, 0.55250025f, 0.36067078f, 0.19028237f, -0.40469062f, -0.34690738f, 0.04983222f, -0.19402191f, 
    0.05586315f, 0.27340928f, 0.41466779f, 0.28574708f, -0.05411084f, 0.01170656f, 0.47081858f, -0.00765890f, 
    -0.37439436f, 0.86998361f, -0.16512620f, -0.77877212f, -0.76546127f, -0.81346923f, 0.64877856f, 0.61964607f, 
    0.89920640f, 1.04175198f, 0.35919115f, -0.08863240f, -0.01170197f, -0.32349250f, 0.03413575f, 0.20175667f, 
    0.07916840f, -0.03224861f, -0.03441797f, 0.18618573f, 0.01935264f, -0.01634135f, -0.10301062f, -0.12855875f, 
    -0.32706296f, -0.09932333f, -0.08222240f, 0.69029170f, 0.97395366f, 0.59013134f, 0.20499206f, -1.59539235f, 
    -0.15031342f, -0.33081448f, -0.22263975f, -0.21257195f, 0.06867229f, -0.02469106f, -0.25097293f, 0.27347261f, 
    0.11076043f, -0.17630364f, -0.02844433f, -0.08687212f, 0.08063589f, 0.18185058f, 0.44287440f, 0.18704404f, 
    0.21978079f, 0.26464403f, 0.26854590f, 0.23641464f, 0.84200424f, -0.23622198f, 0.06744847f, -0.56803328f, 
    -0.41475490f, -0.73757464f, -1.12158597f, -0.71459299f, -0.40804008f, 0.28331432f, 0.36462960f, 0.13459112f, 
    0.13417271f, -0.13709472f, 0.25909334f, -0.15981755f, -0.12590849f, -0.21469039f, -0.14175324f, 0.04610906f, 
    0.00981472f, -0.04709711f, 0.30322415f, 0.15154813f, 0.33964580f, -1.05226088f, -0.42943528f, -1.00347245f, 
    0.38267559f, -0.66174489f, 0.33954591f, -0.05898781f, -0.50951052f, 0.05725802f, -0.00680893f, 0.13629854f, 
    0.40432987f, 0.25182438f, 0.03365676f, -0.12742630f, -0.04771449f, -0.40748659f, -0.43747959f, -0.15280651f, 
    -0.03899444f, -0.34148782f, 0.38303977f, 0.44003960f, -0.25711229f, -1.52774501f, 1.54717803f, -0.53131443f, 
    -0.53474903f, 0.58052695f, -0.56437743f, 0.77434975f, -0.22530374f, 0.12125355f, 0.39766595f, -0.10813568f, 
    -0.11253612f, 0.18044469f, -0.41676882f, 0.07133891f, 0.29678094f, 0.19259518f, -0.02453568f, -0.03114962f, 
    -0.09270480f, 0.09185800f, 0.08907788f, -0.03352964f, -0.06783795f, 0.01692189f, 1.31620371f, 1.07320356f, 
    -0.06842659f, 0.13200653f, 1.23665679f, 0.45120338f, 0.41183951f, 0.52714342f, 0.71488106f, 0.65946454f, 
    -0.27913845f, -0.06141569f, -0.05766006f, -0.19524610f, -0.10325573f, -0.01124057f, -0.25574517f, -0.29418826f, 
    -0.12553838f, 0.13595366f, 0.01878060f, -0.12695198f, -0.10681323f, 0.13209055f, 0.17396846f, 0.99476463f, 
    0.88549596f, 1.13899863f, 0.29100752f, 0.12456661f, 0.77211511f, 0.28334606f, -0.15264946f, -0.00696381f, 
    0.42125207f, 0.21816145f, 0.50822324f, -0.17813385f, -0.01546564f, 0.15467490f, 0.28828338f, -0.15060793f, 
    0.22392616f, -0.06556110f, -0.26805487f, -0.00727182f, -0.06763046f, 0.15299757f, -0.04820378f, 0.34862900f, 
    1.03881884f, 0.31474558f, 0.95778280f, 0.96660233f, 0.62035418f, 0.79100347f, -0.20332451f, -0.18666717f, 
    -0.30776826f, -0.33912894f, 0.37558612f, 0.20071954f, -0.55319601f, -0.10398450f, -0.12689495f, 0.48490334f, 
    0.23179135f, 0.19237180f, 0.30497503f, 0.16593403f, 0.26780930f, -0.02323354f, -0.01134113f, -0.04491882f, 
    0.21673180f, -1.37138593f, 0.36521724f, 0.80359852f, -0.86130989f, -0.47281033f, 0.19413824f, 0.05565619f, 
    -0.41622475f, 0.26001894f, -0.60449028f, -0.37970468f, 0.09360805f, -0.34038028f, 0.25193623f, 0.14265384f, 
    -0.59335959f, -0.12037546f, -0.42493758f, -0.44807133f, -0.40869689f, -0.00095162f, 0.22650971f, -0.08701524f, 
    -0.04548008f, -0.35969633f, 0.21482357f, 0.41708869f, -0.78628409f, 1.01735961f, 0.45105606f, -0.08328572f, 
    0.53087300f, 0.11779751f, 0.80695552f, -0.66157907f, 0.18485223f, -0.22042057f, -0.58237559f, 0.00898497f, 
    -0.29657385f, 0.22446309f, -0.59011143f, 0.09977470f, 0.24666503f, 0.50619733f, 0.59177053f, 0.17059320f, 
    -0.00056426f, -0.21746230f, 0.39764076f, 0.67265242f, 0.65593994f, 0.74239522f, 0.98502898f, 0.08596861f, 
    0.16531506f, 0.17007990f, -0.10016599f, -0.06034199f, 0.56844038f, -0.40043899f, -0.03753821f, -0.01078446f, 
    0.22477022f, 0.00352548f, -0.41201359f, -0.06184665f, 0.27616727f, -0.34183872f, -0.21374062f, -0.28383926f, 
    -0.34487337f, -0.32808602f, 0.12277482f, -0.39110053f, -0.24459417f, 0.76313215f, -0.29461741f, 0.59089333f, 
    -0.27344078f, 1.06047595f, 0.03514026f, -0.98207080f, 0.15411027f, -0.48325559f, -0.10209309f, 0.21434553f, 
    0.03610731f, 0.60287601f, -0.30011398f, -0.47208014f, -0.36492395f, 0.00678961f, -0.01167953f, 0.14544612f, 
    -0.10219777f, -0.22799271f, -0.39774412f, -0.13955884f, -0.19912301f, -0.93030638f, -0.75012666f, -0.16803429f, 
    0.42716071f, -0.15497151f, -0.31528682f, -0.20680968f, 0.43125933f, -0.21733493f, -0.41271538f, 0.45986333f, 
    0.31384879f, -0.21795061f, -0.10141660f, -0.32015997f, 0.19851792f, 0.55693305f, -0.28675726f, 0.37254366f, 
    -0.23650581f, 0.04226598f, -0.39779037f, 0.24888743f, -0.05459165f, 0.39559039f, 0.24067976f, 0.75688392f, 
    0.02736371f, 0.45265889f, -0.11945681f, 0.02814231f, 0.55351478f, -0.55411458f, -0.61903542f, 0.03215051f, 
    -0.23995090f, 0.47298396f, 0.34504730f, 0.53781611f, 0.28272069f, 0.37229115f, -0.34880400f, -0.24451724f, 
    0.29417244f, 0.08734544f, 0.24419598f, 0.38445267f, 0.16860674f, -0.28419363f, -0.12352934f, -0.73888445f, 
    -0.99032438f, -0.82774490f, -0.53670961f, 0.21491754f, 0.50133473f, 0.51933825f, 0.05474675f, -0.08744704f, 
    0.54588592f, -0.36046889f, 0.18954980f, 0.34861919f, -0.13934039f, 0.31281984f, 0.04763771f, -0.18069363f, 
    0.30849484f, 0.05072902f, -0.19800335f, 0.02949071f, -0.20863713f, -0.26779273f, 0.05964755f, -0.15338123f, 
    0.73593885f, 0.81336021f, 0.43468684f, 0.74228549f, 0.66450006f, 0.07474340f, -0.75385869f, -0.23630585f, 
    -0.40290540f, -0.24931978f, 0.23450664f, 0.26348498f, 0.02304743f, 0.16889693f, 0.08701330f, -0.18555623f, 
    0.37815979f, 0.50337154f, 0.28421861f, -0.08124761f, 0.10685274f, 0.19103944f, 0.14964056f, -0.18456729f, 
    0.07600540f, -0.72300637f, -1.40097415f, -0.90451372f, -0.06808012f, 0.13627717f, -0.55091614f, 0.81105465f, 
    0.62660289f, 0.53345209f, 0.36486176f, -0.09249188f, -0.35788447f, -0.21669404f, -0.49461329f, -0.75762546f, 
    0.07013837f, 0.29795226f, 0.05485505f, -0.19138473f, -0.23402807f, -0.01935096f, 0.19226144f, -0.06207073f, 
    0.16357824f, -0.16263077f, 0.66918343f, 0.02725467f, -0.27438152f, 0.76979572f, 0.02426528f, -0.22527626f, 
    -1.06128585f, -0.11454024f, -0.51133060f, -0.35852122f, 0.22604184f, 0.50563478f, -0.10261286f, 0.02391081f, 
    -0.08466250f, 0.16919844f, -0.02511161f, -0.32018310f, 0.25050598f, -0.13338275f, 0.21377200f, -0.23298705f, 
    0.08597504f, 0.39091459f, -0.31520703f, 1.30669343f, 0.67785460f, 0.60746527f, -0.14805898f, -1.16163158f, 
    -0.64986300f, -0.88099587f, 0.37594724f, -0.11467872f, 0.00299255f, -0.21383551f, -0.12044161f, -0.03960619f, 
    0.09341772f, -0.52371919f, -0.29731327f, 0.00065275f, 0.15772292f, -0.40644142f, -0.13294610f, -0.01942779f, 
    0.21367507f, -0.03135883f, -0.07073931f, -0.20005779f, -0.08789820f, 0.49254763f, 1.20805943f, -1.35816872f, 
    -0.28032535f, -0.21336289f, 0.22343531f, 0.19242103f, 0.49344102f, -0.09459382f, -0.04547634f, 0.78955591f, 
    -0.18383479f, 0.11465869f, -0.42984596f, -0.05177420f, 0.24392892f, -0.17224668f, -0.12914993f, -0.28778860f, 
    0.03087638f, 0.02909070f, -0.07432055f, -0.02288287f, 0.00232015f, -0.79795295f, -1.02234709f, -0.51765156f, 
    -0.47519618f, 0.00192133f, -0.89220017f, 0.76868618f, 1.08422136f, -0.27569711f, 0.44001836f, 0.04519153f, 
    -0.08113378f, 0.22395895f, -0.14388618f, 0.22758514f, -0.21767804f, -0.24390242f, -0.23963496f, -0.07152433f, 
    -0.18138738f, 0.20822524f, 0.21128064f, 0.16757642f, 0.14391045f, 0.18026231f, -0.96339589f, -0.08726969f, 
    0.14473748f, -0.45181635f, -0.69968903f, 0.41986519f, 0.60838497f, -0.10253962f, 0.01546485f, 0.17516561f, 
    0.20421755f, 0.02113683f, -0.52951306f, -0.01311934f, 0.47660446f, 0.20737761f, -0.53041625f, -0.13387126f, 
    0.01709826f, 0.16307183f, -0.06241991f, -0.01209895f, 0.39664683f, 0.52640933f, 0.54191017f, -0.91736472f, 
    -0.55746537f, -0.52460802f, -0.58105147f, -0.24865197f, -0.33893919f, -0.29554284f, 0.13898526f, 0.74854219f, 
    -0.41450867f, -0.24433604f, 0.40049669f, -0.05121474f, 0.07607014f, -0.15088953f, 0.21865532f, -0.11860988f, 
    0.08883005f, 0.24927236f, 0.31397319f, 0.29455858f, -0.32751200f, -0.19944045f, -0.11807349f, 0.08250253f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02051360f, 0.02703961f, 0.05858772f, 0.00721334f, 0.22057337f, 0.45593965f, 0.17906351f, -0.07223216f, 
    0.07182097f, 0.23316690f, 0.34375060f, 0.08443149f, 0.30539736f, 0.12216369f, 0.23479441f, 0.22828522f, 
    0.07127282f, 0.19935726f, 0.05569177f, 0.22759473f, -0.00399134f, 0.35508916f, 0.11080094f, 0.09548901f, 
    0.04654356f, -0.05787646f, -0.08086361f, 0.30608976f, -0.05644236f, 0.12758034f, 0.10667852f, 0.22702226f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.08604058f, 0.27726725f, 0.12622501f, 0.03436011f, -0.05907438f, 0.03222242f, -0.20015879f, 0.00298678f, 
    -0.05796598f, -0.01303026f, -0.12073307f, 0.00395829f, 0.84549713f, 0.18827815f, 0.07820491f, 0.18488629f, 
    -0.01750997f, 0.16938683f, -0.12524496f, 0.00327022f, 0.09154449f, -0.11949564f, -0.01954190f, -0.15306664f, 
    -0.20525260f, -0.24624713f, 0.03043455f, 0.31265354f, -0.00066666f, 0.09242094f, -0.08481900f, -0.04038816f, 
    -0.09758399f, 0.07486128f, 0.04095852f, 0.02032702f, -0.43159753f, 0.18082228f, 0.16150662f, -0.43164861f, 
    -0.34445050f, 0.14181551f, 0.06488656f, 0.07829919f, -0.12118445f, -0.16903709f, 0.01606763f, -0.00774110f, 
    0.00272857f, -0.06384075f, 0.27098167f, -0.59740424f, -0.04838968f, 0.04494413f, 0.05397939f, 0.12424731f, 
    -0.01964489f, 0.06564780f, 0.02923626f, -0.04489216f, -0.09275373f, -0.26464909f, -0.17485699f, -0.02248517f, 
    -0.13305785f, 0.18470056f, 0.10996729f, -0.08424752f, -0.01578312f, 0.00086787f, 0.12023927f, -0.05765880f, 
    0.28952688f, -0.13666162f, -0.34396124f, 0.46405917f, -0.12301482f, -0.07954409f, 0.03228311f, 0.03669381f, 
    -0.04380100f, -0.02752349f, -0.04554489f, 0.08655238f, 0.17499270f, -0.21246277f, 0.01319903f, 0.58192873f, 
    -0.29922834f, -0.01316661f, 0.01898691f, 0.06116481f, -0.12904078f, 0.08776613f, -0.05346265f, 0.02670657f, 
    0.03368565f, 0.06967182f, 0.07836171f, -0.03465938f, 0.14677584f, -0.04837536f, -0.00045615f, -0.08143517f, 
    0.16893406f, 0.06555966f, 0.17885216f, -0.00761568f, 0.34989569f, 0.14744841f, -0.14769796f, -0.39391997f, 
    -0.00079994f, 0.11347384f, 0.09713847f, -0.19137029f, -0.03234152f, -0.00891030f, 0.02652338f, -0.01820046f, 
    0.11473535f, -0.00797765f, -0.10974392f, 0.18321240f, -0.07698016f, -0.09544127f, -0.03792296f, -0.18770243f, 
    0.02113992f, -0.18103747f, -0.09001426f, -0.00497919f, -0.17881292f, -0.04109570f, 0.16758119f, -0.04490573f, 
    -0.07183707f, 0.20676239f, 0.05904495f, 0.09033503f, 0.06918965f, -0.08617404f, -0.13310838f, -0.00027971f, 
    -0.47559342f, -0.08215185f, -0.09153520f, -0.27823043f, -0.10147408f, -0.13819179f, -0.04969109f, -0.02468490f, 
    -0.00839518f, -0.02384990f, -0.02289296f, -0.14081745f, 0.45077163f, -0.04809480f, 0.31356406f, -0.15867305f, 
    -0.04868277f, -0.07453295f, 0.06160133f, -0.17636590f, 0.00805821f, 0.00154035f, -0.12669261f, -0.13883522f, 
    0.18484546f, -0.04442954f, 0.19435598f, 0.00963849f, -0.21142115f, -0.05497553f, 0.03723308f, 0.16556519f, 
    -0.08150978f, 0.01880863f, 0.09104239f, -0.06759269f, -0.11432695f, -0.06861999f, 0.01513597f, 0.00071743f, 
    -0.29805344f, -0.15964505f, 0.07923339f, 0.07133994f, 0.05419848f, -0.00462062f, -0.04399772f, 0.00484587f, 
    0.15205102f, -0.13165610f, -0.08051620f, 0.15085113f, -0.20172139f, -0.04368715f, 0.08508522f, 0.11842240f, 
    0.07589106f, -0.04505593f, -0.04670277f, -0.03240237f, -0.20978032f, -0.22750790f, 0.14549166f, 0.08163836f, 
    -0.02174572f, 0.07185683f, 0.07807594f, 0.00718032f, -0.04466558f, 0.02770691f, 0.02154110f, -0.10737754f, 
    -0.03465115f, 0.23136869f, -0.06565174f, 0.01658287f, -0.17056434f, 0.00351808f, -0.03003249f, -0.00406765f, 
    0.03872590f, 0.06851913f, 0.07794253f, 0.07386221f, 0.12404907f, -0.10046992f, -0.26382661f, 0.29823086f, 
    -0.20685841f, -0.15182865f, 0.07420980f, 0.05491810f, 0.00133315f, -0.05728346f, -0.21671404f, 0.01824427f, 
    -0.16926153f, 0.02846701f, -0.07189641f, 0.13897038f, -0.06386918f, -0.11570161f, 0.12226609f, -0.07148951f, 
    0.13450682f, 0.07093521f, -0.02064136f, 0.09273797f, -0.55703157f, -0.08349765f, -0.25811544f, 0.11190712f, 
    -0.07508931f, 0.05552441f, 0.12600882f, 0.15448947f, 0.03183089f, -0.07282434f, -0.12941556f, -0.12147963f, 
    0.00383137f, 0.14234436f, 0.01169436f, -0.24357134f, -0.16154109f, 0.23017149f, -0.10115805f, -0.00929861f, 
    -0.00858229f, -0.06561536f, -0.15865916f, -0.12640195f, -0.02364729f, -0.02346251f, 0.11871492f, -0.40243921f, 
    0.10047595f, -0.08421672f, 0.14425142f, 0.01170165f, 0.06790300f, 0.02513110f, -0.01420518f, 0.00254937f, 
    0.26306811f, 0.03707393f, 0.03738403f, -0.16634819f, -0.28822264f, -0.02781284f, 0.01130670f, 0.00650721f, 
    0.05597800f, 0.01838008f, -0.03020987f, 0.04301969f, -0.31725729f, 0.59485340f, -0.11509907f, -0.12512670f, 
    0.04415002f, 0.14756477f, 0.12820481f, -0.09133843f, -0.06528794f, 0.10008016f, 0.04221346f, 0.10646324f, 
    0.27504352f, -0.10088603f, 0.13823286f, 0.28566667f, -0.01032198f, 0.06124484f, -0.05631888f, 0.01175107f, 
    -0.03778484f, -0.01947505f, -0.00399670f, -0.12111324f, -0.08678484f, -0.02650168f, -0.07154223f, 0.04115495f, 
    -0.09384476f, -0.19753031f, -0.20954239f, -0.09924130f, -0.14317143f, 0.07523061f, -0.04965300f, 0.01928947f, 
    -0.61089706f, 0.24769704f, 0.17187418f, -0.17696822f, -0.04112172f, -0.11601309f, -0.10572591f, -0.07340305f, 
    0.00524533f, -0.06408001f, 0.03217927f, -0.04036075f, -0.55492282f, 0.35141939f, -0.11814904f, -0.23798403f, 
    0.10092039f, -0.07562049f, -0.06871364f, 0.10819601f, 0.03167085f, 0.03842672f, -0.00117121f, 0.15658210f, 
    0.26120225f, 0.22069719f, 0.18760169f, -0.32604086f, 0.02684997f, 0.10607991f, 0.09867926f, 0.09265009f, 
    0.05109910f, 0.00790661f, 0.00324702f, 0.05099944f, -0.12831357f, 0.20492792f, -0.03652854f, -0.29700539f, 
    0.03891888f, -0.02405522f, 0.09552932f, 0.11852332f, 0.02748164f, -0.14964435f, 0.04594047f, -0.12442608f, 
    0.08329525f, 0.19173154f, -0.08802619f, -0.00630118f, -0.15373191f, 0.14626874f, 0.11240859f, 0.11268137f, 
    0.11734771f, 0.10191315f, 0.00361020f, 0.09708698f, -0.60816842f, 0.02388551f, -0.36119631f, 0.22461112f, 
    0.08974674f, 0.01474436f, -0.00456294f, 0.11124299f, -0.03384754f, 0.07943096f, 0.00070116f, 0.00879199f, 
    -0.49284518f, 0.06690996f, -0.15334061f, 0.02784917f, -0.00601154f, 0.08214864f, 0.03360355f, 0.20279630f, 
    -0.27224034f, 0.06565662f, -0.28412065f, -0.04582561f, 0.28183568f, -0.17673205f, 0.02968240f, -0.58269960f, 
    0.08223694f, 0.06279840f, 0.09497683f, 0.16701292f, -0.29222742f, -0.05510703f, 0.07144448f, 0.12237672f, 
    0.34377119f, -0.12476760f, 0.04394186f, -0.21992333f, -0.00063382f, -0.08054676f, -0.03583152f, -0.01999987f, 
    -0.12652335f, -0.07011831f, 0.01274786f, 0.02327996f, -0.03676212f, 0.12221737f, 0.04008139f, -0.04973263f, 
    -0.05694291f, -0.13150525f, 0.10119746f, 0.07556440f, 0.09452139f, 0.25606808f, -0.07002610f, 0.11991860f, 
    -0.23986338f, 0.03063047f, 0.23065396f, -0.01192560f, -0.04103431f, 0.01194049f, -0.03421602f, 0.00097310f, 
    0.05769534f, 0.01614440f, -0.00405226f, -0.14782029f, 0.43096769f, -0.32183164f, 0.05734568f, 0.16559327f, 
    -0.09627464f, 0.18581605f, -0.10501752f, 0.01052764f, -0.07207118f, -0.12217925f, 0.00838151f, -0.20633660f, 
    -0.28325671f, -0.15266758f, -0.32452917f, 0.14969510f, -0.02573507f, -0.27891818f, -0.13398182f, -0.24421242f, 
    -0.03912537f, -0.04527800f, -0.06761999f, -0.04311264f, 0.30558097f, -0.37420002f, 0.13903013f, -0.23748218f, 
    0.05202331f, -0.13084495f, -0.11076708f, -0.01160899f, -0.10540688f, 0.09583168f, 0.08193105f, -0.03122587f, 
    -0.08298784f, -0.00153706f, -0.16995762f, 0.01830335f, -0.00221412f, 0.09133233f, 0.05687143f, 0.06620956f, 
    0.07586336f, 0.12306802f, 0.02666461f, 0.08182480f, -0.07884140f, -0.11064269f, -0.28752929f, -0.36539567f, 
    0.04750718f, 0.14340082f, 0.08376652f, 0.10906074f, 0.04512402f, 0.26045957f, 0.07405493f, -0.05447522f, 
    0.45098498f, -0.24674544f, 0.23530187f, -0.15366274f, 0.14671542f, -0.00199340f, -0.02289643f, -0.09607527f, 
    -0.07903301f, -0.10806673f, -0.09606952f, -0.10613083f, -0.11355869f, 0.11194205f, -0.44537207f, -0.60556710f, 
    -0.04612746f, 0.10182663f, -0.14540330f, -0.01960833f, 0.11432350f, -0.06931999f, 0.15095410f, 0.07284325f, 
    0.30068567f, 0.08215575f, 0.16410965f, 0.21418801f, -0.01939683f, -0.07561740f, -0.00357983f, 0.00321668f, 
    0.00962952f, 0.01393512f, -0.07708811f, 0.12920436f, 0.31393167f, 0.17165966f, 0.25639760f, 0.03673657f, 
    -0.15602890f, -0.12976278f, 0.02832267f, -0.05332942f, -0.03345990f, -0.04835477f, -0.00904338f, 0.11111899f, 
    0.18845285f, -0.00841948f, 0.26962656f, 0.20348075f, -0.11674569f, -0.04154843f, -0.03833390f, 0.00280738f, 
    -0.01892398f, 0.01216431f, -0.07664308f, 0.09953582f, -0.34194455f, 0.12673272f, -0.08740374f, 0.02830474f, 
    -0.15262018f, -0.06794185f, -0.03397560f, -0.09750942f, -0.09162384f, -0.06347287f, -0.24553177f, -0.03007010f, 
    0.10302944f, -0.17858341f, -0.05609545f, 0.48261899f, -0.06131577f, 0.03481521f, -0.03784005f, 0.16357681f, 
    0.18450698f, 0.13272904f, -0.21074080f, 0.06794316f, 0.21808575f, 0.16250791f, 0.09696615f, 0.28722408f, 
    -0.07419740f, 0.12347811f, 0.05063324f, -0.03681260f, -0.00999941f, -0.08280258f, 0.20403701f, 0.04504660f, 
    -0.12310969f, -0.23308688f, -0.07851742f, 0.08597983f, -0.00095379f, -0.02122768f, -0.12795597f, 0.06827534f, 
    -0.07921862f, 0.03392342f, 0.02590498f, -0.15951288f, 0.04806465f, 0.13401927f, -0.22017100f, 0.21622126f, 
    -0.01940313f, -0.05327377f, 0.01050386f, 0.07942495f, -0.16784762f, -0.04056320f, 0.04326594f, 0.16339287f, 
    0.04913217f, 0.13550039f, -0.10124658f, -0.02879111f, 0.00055082f, -0.00859139f, -0.03602034f, 0.01172900f, 
    0.20822313f, 0.16769467f, -0.14007188f, 0.22066855f, 0.41902500f, 0.03862644f, 0.04242053f, -0.16248542f, 
    0.02866483f, -0.03525903f, -0.01970546f, 0.16118287f, -0.14226180f, -0.03987733f, 0.10584158f, 0.07243466f, 
    0.00246453f, 0.02482029f, 0.21172294f, 0.40400243f, 0.00747956f, -0.08416010f, -0.02826774f, 0.02286765f, 
    -0.01031032f, -0.01007986f, 0.13656664f, 0.03091142f, 0.42836285f, -0.22820340f, -0.14211531f, -0.05001461f, 
    -0.03890696f, -0.03819241f, -0.15462805f, -0.10829250f, 0.08918853f, -0.13991648f, -0.21310768f, 0.04926335f, 
    -0.13630722f, -0.08143467f, 0.00132344f, 0.17327639f, -0.00467203f, -0.03578475f, 0.16284415f, -0.03019837f, 
    0.06871280f, 0.13951911f, -0.16702925f, 0.24324465f, 0.19885370f, 0.08346614f, -0.27639231f, -0.12832545f, 
    -0.13858211f, -0.09724558f, 0.05463293f, 0.04071522f, 0.01084502f, -0.11949268f, 0.03589317f, -0.05037677f, 
    -0.54793137f, 0.24508190f, -0.28452018f, -0.11300037f, -0.01582001f, -0.09499629f, -0.05000062f, -0.09975475f, 
    0.15872425f, -0.11910120f, -0.11878351f, -0.40869489f, 0.35238492f, -0.04030056f, -0.03750732f, 0.04407362f, 
    -0.12017199f, 0.03729611f, -0.04244047f, -0.03217980f, 0.06579507f, -0.07078715f, -0.06698881f, -0.02115798f, 
    -0.54712492f, -0.12263575f, -0.29199448f, -0.11246765f, -0.11661269f, -0.00694098f, -0.07508166f, -0.06150843f, 
    0.01947840f, 0.06463855f, -0.18015708f, 0.05656870f, 0.02320288f, -0.11807518f, 0.04361463f, -0.14317703f, 
    0.06014486f, -0.00627353f, 0.04199056f, 0.16155173f, 0.01041305f, 0.02467342f, 0.13932879f, 0.10924184f, 
    0.10596057f, 0.21866336f, -0.08799093f, -0.13892937f, -0.02811193f, -0.02429944f, 0.01874367f, -0.11698057f, 
    -0.08591573f, 0.03694106f, 0.05182822f, 0.09597767f, 0.39161012f, -0.06730756f, 0.05520390f, -0.04533141f, 
    -0.01555209f, -0.05761567f, -0.30199748f, 0.05371398f, 0.19286011f, -0.02211478f, -0.01337282f, -0.03054348f, 
    0.39733985f, -0.09404494f, -0.37876964f, -0.21391287f, -0.08670265f, 0.05750884f, -0.08472756f, -0.15414278f, 
    0.08337790f, 0.00599487f, 0.11474850f, -0.09768254f, -0.36220688f, -0.19401121f, -0.35146913f, -0.51685607f, 
    -0.08878589f, -0.02464180f, 0.14815280f, -0.01810834f, 0.06180351f, 0.09351556f, -0.03572166f, 0.05544751f, 
    -0.46121538f, -0.10765091f, 0.03014486f, -0.22821105f, 0.13055101f, -0.04865959f, 0.07173733f, -0.04183204f, 
    -0.15256640f, 0.12299266f, -0.07572189f, -0.07785651f, -0.49105299f, 0.05679986f, -0.04532417f, 0.21072342f, 
    -0.10930370f, 0.12852263f, -0.04429988f, -0.09571170f, -0.03109355f, -0.11649539f, -0.00777159f, 0.09472462f, 
    -0.01843195f, 0.14034346f, -0.20452991f, -0.09926640f, -0.11500191f, 0.14105797f, -0.13314323f, 0.03531451f, 
    -0.04671803f, 0.09985002f, -0.04135017f, -0.20722835f, -0.06305960f, -0.08927036f, 0.01459958f, -0.17632873f, 
    0.22675727f, -0.06506634f, 0.02898555f, 0.01701366f, 0.02936689f, 0.06271141f, -0.03163433f, -0.01561415f, 
    0.47654372f, -0.37403274f, 0.13138787f, -0.38774297f, -0.00831645f, 0.15810739f, 0.12628488f, 0.12870431f, 
    -0.18615027f, -0.07337806f, 0.10497978f, -0.11067656f, 0.06443707f, 0.35165438f, 0.05734986f, 0.37288180f, 
    -0.13909674f, -0.15113276f, 0.18278390f, 0.23868133f, -0.12126485f, -0.09020722f, -0.05515561f, -0.00225303f, 
    0.12079116f, 0.25361723f, -0.38435796f, -0.01774990f, 0.09962413f, 0.00275633f, -0.05538056f, -0.12535192f, 
    -0.18302804f, 0.00451718f, -0.12015921f, 0.00189868f, -0.39630273f, 0.16811794f, -0.14893520f, -0.39505503f, 
    0.13359392f, -0.01694074f, 0.07625805f, 0.02237679f, 0.02034169f, 0.09306974f, -0.14218108f, -0.15025169f, 
    0.37963513f, 0.01668921f, -0.17409450f, -0.26195514f, -0.23902138f, 0.08820639f, -0.12458915f, -0.12377775f, 
    0.02714221f, 0.00198048f, -0.12518623f, -0.01620958f, 0.19371335f, -0.18228953f, -0.26471880f, -0.27830276f, 
    0.09095594f, 0.00233020f, -0.01618156f, -0.16535757f, 0.01199695f, 0.08407382f, -0.01286657f, -0.04757987f, 
    0.28121752f, -0.11231079f, -0.03754431f, -0.07019899f, 0.11578486f, -0.08818198f, 0.15021963f, -0.07610480f, 
    0.01178173f, 0.08172874f, 0.14322573f, 0.05309436f, 0.17640428f, -0.10431457f, -0.00449578f, -0.14637555f, 
    0.10911757f, 0.06727599f, 0.00329882f, -0.01266622f, 0.04145550f, 0.02445916f, 0.05192606f, 0.02828922f, 
    0.06372316f, -0.06388522f, -0.02564168f, 0.15043701f, 0.19256012f, 0.04965620f, -0.02767812f, -0.07436207f, 
    -0.10251081f, -0.11517711f, -0.05475445f, -0.03231157f, 0.43157089f, -0.06209868f, -0.49443722f, -0.39779699f, 
    0.01506859f, 0.07392863f, 0.03571966f, 0.05099553f, 0.03889830f, 0.15212817f, -0.05132151f, 0.03522876f, 
    0.20002237f, -0.21541035f, -0.17160012f, -0.25435820f, 0.03036880f, -0.05967880f, 0.04939838f, -0.03055108f, 
    -0.03188449f, 0.02102548f, 0.09918690f, 0.03175544f, -0.00746055f, -0.03068088f, 0.03445586f, -0.08408990f, 
    0.05170391f, 0.14468496f, 0.02447332f, 0.09701324f, 0.03027802f, 0.16315551f, -0.03525724f, -0.05200292f, 
    0.18806507f, -0.09864769f, -0.06510746f, -0.09705420f, 0.05976117f, 0.00921958f, 0.00488893f, -0.09624956f, 
    -0.01755804f, 0.21750028f, -0.05265832f, 0.01044482f, 0.26520163f, -0.38254735f, -0.03592879f, 0.03486083f, 
    -0.12319460f, -0.03044412f, -0.08591659f, -0.08253872f, 0.01901473f, -0.02406638f, -0.01200341f, -0.17058858f, 
    -0.14247453f, 0.07405177f, 0.02427348f, -0.36983562f, -0.01384908f, 0.24678814f, 0.03973098f, -0.19394623f, 
    0.00651609f, -0.07814685f, -0.04201465f, -0.11852286f, 0.34163499f, -0.07376444f, 0.16182695f, 0.19372243f, 
    -0.24076878f, -0.17127173f, -0.07993247f, 0.09317510f, 0.07887156f, 0.03144168f, -0.10300491f, 0.08859029f, 
    0.13121787f, 0.15107623f, 0.07156982f, 0.08138204f, 0.14568450f, 0.02251657f, 0.03251207f, -0.09928191f, 
    -0.19995713f, -0.03117343f, -0.07571566f, -0.00690185f, 0.44176936f, -0.19988032f, 0.09438709f, 0.27317303f, 
    -0.27229190f, -0.03733365f, 0.01422515f, 0.17070490f, 0.10516848f, 0.06561207f, 0.09869371f, 0.06204623f, 
    -0.35570338f, 0.09003405f, -0.13458407f, -0.27107310f, 0.09004155f, 0.03310164f, -0.01706438f, -0.01501866f, 
    -0.09919242f, -0.03173485f, 0.03827937f, -0.15365604f, -0.69476658f, 0.12424974f, 0.09429261f, -0.18861069f, 
    -0.03787492f, -0.06565510f, 0.05400487f, 0.09585998f, -0.27524477f, 0.11391789f, 0.05917876f, -0.00261711f, 
    -0.04627576f, 0.19627151f, -0.36350337f, -0.07769503f, -0.04234505f, -0.01127700f, 0.21778423f, 0.06070647f, 
    -0.03849464f, -0.08353161f, -0.04749853f, 0.05117891f, 0.47639781f, 0.01552832f, -0.12378500f, 0.35013786f, 
    -0.11775023f, -0.12490533f, -0.08216546f, -0.07426284f, 0.10364886f, -0.04311575f, 0.03847625f, 0.05492156f, 
    0.43537742f, -0.03886715f, 0.14428383f, -0.05484133f, -0.05676884f, -0.06326979f, -0.28260234f, 0.12817545f, 
    0.03627057f, -0.00063987f, 0.11197422f, -0.14992674f, -0.11924402f, 0.12311723f, -0.00201314f, 0.00411631f, 
    -0.14264886f, -0.22504270f, 0.10028157f, 0.08976881f, 0.01496269f, 0.04502342f, -0.10063868f, -0.02306632f, 
    -0.48516965f, 0.24855702f, -0.07933226f, 0.03030988f, -0.00228300f, 0.02447601f, -0.02408280f, -0.04981520f, 
    -0.08223747f, 0.15361606f, 0.06336705f, -0.23742652f, -0.26163909f, 0.22940230f, -0.13011783f, 0.01850844f, 
    -0.00060962f, -0.05563587f, 0.13101603f, 0.13441919f, 0.03329026f, 0.02201459f, -0.16293541f, -0.06017862f, 
    0.37163317f, -0.14571601f, 0.21514131f, -0.00751970f, 0.09298612f, 0.00371824f, -0.07647224f, -0.01933651f, 
    0.12335461f, -0.07231890f, -0.19490312f, -0.09973206f, 0.16183497f, 0.08462676f, 0.04760873f, -0.06102110f, 
    -0.08142138f, -0.03363257f, 0.02029374f, -0.04313338f, -0.04178791f, 0.12626140f, -0.14159729f, 0.01523245f, 
    0.12794544f, 0.00211329f, 0.05991087f, 0.15702449f, 0.05810277f, 0.02179608f, 0.00527674f, 0.12719272f, 
    -0.01656719f, -0.03168825f, -0.07954390f, -0.01337940f, 0.06395169f, -0.06466559f, -0.15995638f, -0.17137700f, 
    -0.04146308f, 0.14701974f, 0.03487355f, 0.03239603f, 0.02671859f, -0.06330025f, 0.00988240f, -0.00131219f, 
    -0.40747157f, -0.05423471f, 0.11436845f, 0.08492012f, -0.14924644f, 0.02230040f, 0.09717411f, 0.05542143f, 
    0.07872314f, -0.00824711f, -0.02450332f, -0.00515775f, -0.09653307f, -0.41835722f, 0.10066552f, 0.08821620f, 
    -0.03537486f, 0.06387296f, 0.09533199f, -0.08761808f, 0.07161472f, 0.10315263f, 0.07490995f, 0.05990670f, 
    0.07834847f, 0.21103491f, -0.01149043f, 0.04697990f, -0.03267146f, -0.10512491f, -0.18185228f, 0.18099616f, 
    0.04900892f, -0.16789970f, 0.06879694f, -0.05969313f, -0.18733825f, -0.27971521f, -0.19266057f, -0.09697194f, 
    -0.08280434f, 0.17074607f, -0.08001733f, 0.01074706f, -0.11863500f, 0.02317886f, -0.04417193f, 0.04776893f, 
    -0.58954120f, 0.23407480f, -0.06166915f, 0.10745829f, 0.11800046f, 0.11521605f, 0.01755179f, -0.04768798f, 
    -0.15498900f, -0.13521001f, 0.08034234f, -0.10741558f, 0.20723331f, -0.04915784f, 0.01478717f, 0.15909356f, 
    0.06691190f, 0.12903607f, -0.01860108f, 0.06552941f, 0.04667918f, 0.04725977f, 0.08409034f, -0.13881460f, 
    -0.04513758f, 0.16223514f, 0.03215899f, 0.27046895f, 0.12154708f, -0.07658736f, -0.06724957f, 0.15472488f, 
    -0.05704970f, 0.20127320f, 0.11623641f, 0.03810413f, 0.19230577f, 0.72032261f, -0.10124901f, -0.09713623f, 
    0.02212217f, 0.02176183f, -0.01489264f, 0.22637525f, 0.04339053f, 0.01265995f, -0.15868162f, -0.01593217f, 
    -0.48366800f, -0.39557493f, -0.59131569f, -0.36118492f, -0.19249611f, -0.05371781f, -0.08531739f, -0.01149077f, 
    -0.14766149f, -0.05732431f, 0.07743238f, 0.04414663f, -0.60572404f, -0.56686747f, -0.42162377f, 0.08697465f, 
    -0.10820530f, -0.17334016f, 0.03600396f, 0.01860413f, 0.09453247f, -0.11831175f, -0.01169759f, -0.00459087f, 
    -0.21470930f, -0.73077047f, -0.12738883f, 0.37249902f, -0.09153569f, -0.01030992f, 0.01121807f, 0.05631289f, 
    -0.06830911f, -0.05506985f, -0.00279773f, -0.16719922f, 0.20212792f, 0.30088356f, 0.17940634f, -0.08146977f, 
    -0.14246602f, 0.11585949f, -0.10392302f, 0.05671770f, 0.09730583f, -0.00326327f, 0.01453967f, 0.09106135f, 
    0.32588810f, 0.10833298f, -0.07998805f, -0.26729375f, -0.01008621f, -0.10737379f, 0.05731219f, -0.14255439f, 
    -0.09688812f, 0.08674695f, 0.21637657f, -0.23583411f, -0.32060724f, -0.51503754f, -0.30998790f, 0.07279625f, 
    0.02376949f, 0.01978112f, 0.21246286f, 0.05892308f, 0.09792605f, -0.01687438f, 0.01203256f, -0.00919120f, 
    0.83624285f, 0.15651429f, -0.15590210f, 0.29162961f, 0.12251266f, -0.03517742f, -0.01195464f, 0.05394564f, 
    -0.01147634f, -0.00741912f, -0.04624371f, 0.13039996f, 0.08864497f, -0.04014389f, 0.10310132f, -0.05633202f, 
    -0.13981847f, -0.16561928f, 0.05752236f, 0.01244938f, -0.03367727f, -0.03389842f, 0.02397192f, -0.06059706f, 
    0.02173187f, -0.28495160f, 0.21586421f, 0.16311292f, 0.02844839f, 0.03953297f, -0.21994160f, -0.00682898f, 
    -0.08788843f, -0.16780126f, -0.01618219f, 0.13457467f, 0.00711212f, 0.10530063f, -0.04322216f, -0.02452114f, 
    -0.08336294f, -0.22021791f, -0.10335209f, 0.05227466f, -0.10553302f, -0.08371011f, -0.08419339f, 0.00017623f, 
    0.19132088f, -0.48192230f, -0.04456829f, 0.23795579f, 0.07624610f, 0.14943114f, 0.05270415f, -0.13361241f, 
    0.11598250f, -0.17254713f, -0.05137114f, -0.14635910f, -0.08780780f, -0.00318352f, 0.03665320f, 0.04389241f, 
    -0.11807803f, -0.13716377f, 0.03280914f, 0.06977426f, -0.24291566f, 0.14131552f, 0.08412550f, -0.09622063f, 
    0.32556501f, -0.20644216f, 0.02915422f, 0.17683332f, 0.13658372f, 0.05042363f, -0.08365820f, 0.05122103f, 
    0.15664837f, 0.05996033f, -0.07161066f, -0.08687188f, 0.18516511f, -0.43793586f, -0.26881844f, 0.10207374f, 
    -0.13681830f, 0.10185538f, -0.00892857f, 0.09547942f, 0.00019582f, 0.10702741f, -0.12351291f, 0.13002552f, 
    -0.07624470f, 0.22258829f, 0.31812376f, -0.13712530f, 0.10493524f, -0.07881949f, 0.11372331f, 0.06108094f, 
    -0.07835911f, 0.14310171f, -0.02053964f, 0.11248752f, 0.18520869f, -0.02900698f, 0.12829925f, 0.04269822f, 
    0.07040799f, -0.18690850f, -0.01763979f, -0.12614854f, -0.04497663f, -0.03199346f, -0.04351471f, 0.00663965f, 
    -0.01341591f, 0.12012848f, 0.13940521f, -0.29944938f, 0.06037105f, -0.07837780f, 0.07256631f, 0.02302043f, 
    -0.02313055f, -0.16198020f, 0.06674720f, -0.09330418f, -0.14128450f, -0.04643264f, 0.04330637f, -0.08691998f, 
    -0.24319497f, -0.04557326f, -0.02696715f, 0.00673399f, -0.17200096f, -0.09884133f, 0.01687800f, 0.02646408f, 
    -0.11289961f, -0.17260593f, 0.29091102f, -0.10628984f, 0.02263290f, -0.07371070f, 0.07903717f, 0.00211300f, 
    -0.02306625f, -0.01563505f, 0.10453087f, -0.10666344f, -0.54872751f, 0.00349249f, -0.22867242f, -0.59310532f, 
    0.19102041f, 0.07763819f, 0.04770616f, 0.02761953f, 0.15090947f, -0.09967607f, -0.14280210f, 0.00712414f, 
    -0.00714269f, -0.27485368f, -0.03067986f, -0.06866586f, -0.08449892f, 0.09264474f, 0.04902456f, 0.04429194f, 
    -0.00682362f, 0.20491259f, -0.10483819f, -0.01277693f, -0.05216346f, -0.07597253f, 0.06256455f, -0.06217980f, 
    -0.03034898f, -0.00344019f, 0.12521149f, -0.06160729f, 0.05532727f, 0.08671799f, -0.01532147f, -0.09172757f, 
    -0.10108911f, -0.15894586f, 0.07983528f, -0.04449186f, -0.14684159f, 0.06283616f, 0.02886736f, 0.01416384f, 
    -0.02034812f, -0.06329707f, 0.04718825f, -0.07563845f, 0.34511739f, 0.23745190f, -0.07671496f, 0.20532367f, 
    0.08877237f, 0.09317844f, -0.06398372f, 0.13790183f, -0.02572994f, -0.18534631f, 0.02478868f, -0.00165116f, 
    -0.44899511f, 0.14484480f, 0.21352552f, -0.04242121f, -0.01613277f, -0.06301803f, 0.00202107f, -0.05587120f, 
    0.04533613f, -0.08385801f, -0.11076245f, -0.14692982f, 0.50563675f, 0.23837332f, -0.05350595f, -0.04618034f, 
    -0.00547393f, 0.07096355f, 0.10189238f, 0.09024756f, -0.08441134f, 0.10371673f, 0.02850636f, 0.15241098f, 
    0.03660282f, -0.04429540f, 0.16120934f, -0.27746791f, -0.08292240f, 0.12659304f, -0.09658094f, 0.11774133f, 
    -0.06827321f, 0.08570926f, -0.10812506f, 0.18533339f, -0.45973518f, 0.01710627f, 0.25547799f, 0.26573262f, 
    -0.10913452f, 0.21010596f, -0.02719108f, -0.07304646f, 0.15200435f, 0.09857932f, 0.12348069f, 0.11878614f, 
    -0.36780125f, -0.13883108f, 0.30612794f, 0.31148931f, -0.08940469f, -0.04005620f, -0.00441935f, -0.12881730f, 
    0.10077310f, -0.00249101f, -0.13013320f, -0.06851378f, -0.16958131f, -0.21505201f, 0.15599830f, -0.03857244f, 
    -0.11847879f, 0.01537897f, 0.12721851f, -0.24057534f, 0.10016079f, -0.09306784f, -0.00310247f, -0.02098553f, 
    -0.09354455f, -0.02500276f, -0.00043831f, -0.08558286f, 0.17215915f, -0.11178334f, 0.10298110f, 0.23852678f, 
    0.02959622f, 0.03468288f, 0.03880537f, -0.04674046f, -0.06086539f, 0.23681696f, 0.15108705f, 0.05348463f, 
    -0.22506833f, -0.04644931f, 0.17378761f, -0.04966754f, 0.06418128f, 0.07999256f, -0.04478037f, -0.01924627f, 
    0.14205137f, -0.35026401f, -0.17761245f, 0.10233048f, -0.04514723f, -0.01144730f, 0.10418945f, 0.06439634f, 
    0.02877012f, 0.04767351f, 0.00880306f, -0.04223825f, -0.38590017f, -0.03301698f, -0.11133794f, -0.18838961f, 
    -0.09690595f, -0.00011197f, -0.08150028f, 0.11318542f, 0.04625675f, -0.01515261f, 0.07681105f, -0.00442838f, 
    -0.00509747f, 0.25584912f, 0.11823960f, -0.26823714f, 0.01773904f, 0.12000668f, 0.06719277f, 0.09487572f, 
    0.16054152f, -0.05378256f, -0.10572865f, -0.24087361f, 0.43459511f, 0.17103466f, -0.07820934f, -0.30798194f, 
    -0.02337527f, -0.19086435f, 0.06413157f, -0.02266762f, 0.10068020f, -0.12073579f, -0.12963025f, 0.01910536f, 
    0.36180744f, 0.03456597f, 0.04725912f, -0.14687598f, 0.00690137f, 0.01729692f, 0.00027865f, -0.29453066f, 
    0.08700141f, -0.23647544f, 0.22888708f, -0.06974086f, -0.11485124f, 0.03109333f, 0.07271786f, -0.08823071f, 
    -0.05272747f, 0.07217646f, 0.01836577f, 0.16601370f, 0.03808207f, 0.01133219f, 0.07667286f, 0.12002720f, 
    -0.26992247f, 0.33132726f, -0.03256371f, -0.26629442f, -0.08828064f, 0.11150604f, 0.04634510f, -0.00854587f, 
    -0.17361228f, -0.03059903f, 0.00479934f, 0.07928057f, -0.12116900f, -0.07700178f, -0.14490293f, -0.09157525f, 
    0.20573014f, 0.02758891f, -0.00887361f, 0.15584078f, 0.04743733f, 0.22891524f, 0.11724860f, -0.08248083f, 
    -0.44996673f, -0.09881943f, 0.10605624f, 0.14972135f, 0.06803142f, -0.28556240f, 0.03582079f, -0.10158090f, 
    -0.00437638f, -0.12553848f, 0.07655941f, -0.00309613f, -0.43690854f, 0.12108312f, -0.04295899f, 0.19162644f, 
    0.09342002f, -0.18563528f, 0.09579609f, 0.05228199f, 0.00935279f, -0.13630651f, -0.10694613f, -0.02167174f, 
    -0.31805095f, -0.12050922f, 0.16025428f, 0.19841836f, -0.09849679f, 0.03793694f, -0.11617370f, 0.11186340f, 
    0.08510690f, 0.00724694f, -0.03990607f, -0.09218948f, -0.56883162f, -0.02263399f, -0.10762869f, 0.27141607f, 
    -0.01985472f, 0.00416218f, -0.05099612f, 0.12724760f, 0.08686963f, 0.10042112f, 0.26431787f, 0.07020227f, 
    -0.27144694f, -0.00706707f, 0.13932578f, 0.22309218f, -0.18253827f, 0.14201733f, -0.05794505f, -0.20510107f, 
    0.11472730f, -0.11358492f, -0.04310861f, -0.10170610f, -0.05171786f, -0.34256104f, 0.20630452f, -0.09625745f, 
    -0.23543526f, 0.17035598f, 0.10831507f, -0.00013324f, 0.03128225f, 0.04082841f, 0.07644741f, 0.11710352f, 
    0.60321623f, 0.04250506f, 0.05534324f, -0.35366166f, -0.03285894f, -0.02150276f, -0.05934900f, -0.05549366f, 
    -0.02347118f, 0.15622716f, 0.14585148f, -0.11762756f, -0.46950251f, 0.04121990f, -0.22692586f, -0.03859812f, 
    0.00382311f, 0.02353359f, 0.05979965f, 0.03522962f, -0.06280100f, -0.13978043f, -0.07529668f, -0.06253031f, 
    -0.12336881f, -0.07354553f, -0.07265991f, -0.01315367f, 0.04487966f, -0.07642227f, -0.05447036f, 0.12998787f, 
    -0.11280247f, -0.23586358f, -0.00250487f, -0.01120992f, 0.21727048f, 0.09281703f, -0.07996812f, 0.22548237f, 
    0.19962050f, -0.02406001f, -0.05242715f, 0.19539209f, 0.23087040f, -0.10816981f, 0.06464142f, -0.02101085f, 
    -0.22040316f, -0.03349261f, -0.01986819f, 0.27033702f, -0.01927003f, 0.06160317f, -0.20416878f, 0.17673273f, 
    0.18039656f, 0.02091351f, -0.15958638f, -0.22038789f, -1.01002336f, 0.13616861f, 0.26890507f, -0.19423489f, 
    -0.14359988f, 0.11881129f, 0.13642032f, -0.02072340f, -0.06461263f, 0.02608916f, 0.07404432f, -0.11951993f, 
    0.16971017f, 0.01732395f, 0.07715247f, 0.02958708f, -0.03418721f, -0.01128464f, 0.00926867f, -0.02168037f, 
    0.10096440f, -0.42764157f, 0.03342263f, 0.07426566f, 0.10889205f, 0.08162125f, -0.09701036f, 0.21726663f, 
    0.01648287f, -0.11324966f, 0.02598087f, 0.07562824f, 0.22465318f, 0.12446319f, 0.06689572f, -0.20164874f, 
    -0.14533331f, -0.17903855f, 0.28451613f, 0.21656376f, -0.08060885f, -0.05274012f, 0.17860042f, -0.02103321f, 
    0.19413191f, -0.03674505f, 0.02520115f, 0.21485236f, -0.16315746f, -0.55200696f, 0.00803144f, 0.11767717f, 
    0.15937449f, -0.10180283f, -0.00891454f, 0.01442804f, 0.05736448f, 0.25197604f, -0.18138935f, 0.04072794f, 
    -0.12499596f, -0.08346193f, -0.04829591f, 0.13002761f, -0.26257837f, 0.20502569f, 0.02207198f, 0.04430564f, 
    -0.03329535f, -0.24818255f, 0.10911418f, -0.00110091f, -0.17002824f, 0.08968195f, 0.16405769f, -0.09135952f, 
    -0.03564472f, -0.24151331f, -0.08029702f, -0.06296917f, 0.13403752f, -0.16996796f, -0.16047959f, -0.08440583f, 
    -0.31006771f, 0.05396068f, -0.10508117f, 0.02104352f, 0.14654715f, -0.10150980f, 0.14129192f, -0.08434687f, 
    0.08392591f, 0.00801337f, 0.15125977f, -0.05130893f, 0.26598698f, 0.02178605f, -0.32579479f, 0.01952582f, 
    0.04618483f, -0.13272190f, -0.13484672f, -0.24955976f, 0.02095442f, 0.06663996f, -0.22138453f, 0.09236546f, 
    0.19429907f, 0.03567879f, -0.06053323f, 0.14729035f, -0.09988628f, -0.00066568f, 0.01214462f, 0.20763399f, 
    -0.10487948f, 0.09656433f, 0.19218329f, 0.05222906f, 0.04536030f, 0.11384422f, 0.18879889f, 0.25905642f, 
    -0.12259242f, -0.02779460f, -0.03965140f, -0.05081448f, -0.19006199f, -0.27465388f, 0.07032348f, 0.19850153f, 
    -0.25224730f, -0.18495663f, 0.01792223f, -0.05643114f, -0.04489586f, -0.05240369f, 0.11030310f, 0.02726243f, 
    -0.04515429f, 0.09698585f, 0.11920445f, 0.06692529f, -0.41026795f, -0.35525212f, 0.13992803f, 0.06923933f, 
    -0.14974876f, -0.07918639f, -0.03087911f, -0.25829136f, 0.05602695f, 0.04751022f, 0.08073489f, 0.09872537f, 
    0.18880132f, 0.11248533f, 0.22722559f, -0.18188104f, -0.03832449f, 0.00056503f, -0.16414748f, -0.05519493f, 
    0.03324631f, -0.07507748f, -0.10440981f, -0.05389471f, 0.15024036f, -0.04171195f, 0.11318648f, 0.22879675f, 
    0.10504240f, 0.20309880f, 0.03716412f, 0.03192923f, 0.00088888f, 0.05295214f, -0.02279766f, 0.01443653f, 
    0.02725864f, -0.06055379f, 0.08223987f, 0.21136543f, 0.01526898f, 0.12637721f, -0.11110678f, -0.02350643f, 
    0.05269468f, 0.21779902f, 0.10303803f, 0.31700879f, -0.32090873f, -0.24031791f, 0.29009908f, 0.19614409f, 
    0.12375655f, -0.06084961f, -0.05087316f, 0.23827845f, 0.03975968f, 0.01520190f, 0.13223781f, -0.19554166f, 
    -0.15595852f, 0.27199551f, 0.07487320f, -0.26221979f, 0.02145929f, -0.08735199f, -0.22950773f, -0.05452867f, 
    -0.05089090f, 0.12218371f, -0.15812317f, -0.06020841f, 0.01827796f, -0.09866903f, 0.28062031f, -0.08403514f, 
    0.05949769f, 0.12123895f, -0.01322659f, -0.05017028f, -0.19954406f, 0.03300996f, 0.02869738f, -0.20387909f, 
    -0.11642364f, -0.09197833f, 0.11248037f, -0.14385633f, -0.06806245f, 0.10050374f, 0.02214315f, -0.04132104f, 
    -0.23992898f, -0.20836629f, 0.03423296f, -0.13211305f, -0.19691268f, -0.10040501f, -0.13176560f, -0.29955009f, 
    0.07012880f, 0.12781668f, 0.10051949f, -0.11339869f, 0.10966784f, -0.19115719f, -0.19992134f, 0.22305082f, 
    0.07486792f, 0.01082077f, 0.14829426f, 0.16537771f, -0.08899070f, 0.01519601f, 0.11099101f, 0.06641515f, 
    0.01965164f, 0.11596901f, 0.16578849f, 0.05466857f, -0.70766854f, -0.03509623f, -0.22085585f, -0.23725620f, 
    0.18016253f, 0.22289664f, -0.09033038f, -0.18880019f, 0.12444816f, 0.07360224f, 0.05415897f, -0.10979027f, 
    0.04509748f, -0.01187385f, -0.03527373f, 0.02590614f, -0.07939758f, 0.06335302f, 0.03121933f, -0.01216792f, 
    0.02135846f, -0.03172977f, 0.14329049f, 0.31223631f, -0.15684505f, 0.22212531f, -0.19592656f, -0.29070503f, 
    0.14624870f, 0.13984774f, -0.10479357f, -0.19720078f, 0.02195755f, -0.22775474f, -0.23246421f, -0.13823400f, 
    0.03903636f, -0.09135298f, -0.16289309f, -0.10718872f, 0.06404939f, -0.16423805f, -0.19961736f, 0.15123926f, 
    -0.13652706f, -0.05213628f, -0.01499901f, 0.06158980f, 0.19521113f, 0.14475237f, -0.08222626f, 0.08475083f, 
    0.11412323f, -0.05886346f, -0.02129176f, 0.14673579f, 0.03575849f, -0.14922275f, 0.06181323f, -0.17775814f, 
    0.21667342f, -0.04378226f, 0.03960662f, 0.16805385f, 0.08655334f, -0.06037418f, -0.02237717f, 0.09241055f, 
    -0.09873484f, -0.02872165f, -0.06725837f, 0.32561207f, -0.51434964f, -0.17746530f, -0.17164953f, -0.32163081f, 
    0.18071172f, 0.10450774f, 0.16896544f, 0.11844873f, 0.03457830f, 0.17554075f, -0.04633614f, 0.04818158f, 
    -0.20885885f, -0.14874999f, -0.04483291f, 0.10280716f, 0.15334119f, -0.01154228f, 0.23783751f, 0.03387064f, 
    0.01574300f, 0.08301986f, -0.07630555f, 0.08965801f, 0.06670829f, -0.27025756f, -0.26881766f, 0.11908560f, 
    0.19551302f, 0.00706919f, -0.06721969f, -0.29347566f, -0.07730675f, 0.23853670f, 0.01172309f, 0.15834105f, 
    -0.20716938f, -0.05922892f, -0.03068444f, -0.03161871f, 0.17112088f, -0.25296000f, 0.04611425f, 0.05681345f, 
    -0.11110723f, 0.02493438f, 0.20497461f, 0.20143119f, 0.70237887f, -0.32774636f, 0.28443241f, 0.18502642f, 
    -0.08336628f, -0.05009286f, -0.02897068f, 0.00969019f, -0.04968801f, 0.01236599f, 0.08005863f, 0.02595470f, 
    -0.14747128f, -0.15725563f, -0.01698841f, -0.27456728f, -0.14143322f, -0.16233245f, 0.01609115f, -0.07620367f, 
    0.27890944f, -0.01178727f, 0.07493416f, -0.05445177f, 0.00383487f, -0.63298672f, -0.37983853f, 0.54704899f, 
    0.18319450f, 0.00190157f, -0.08927789f, -0.01814383f, 0.09393047f, -0.11516040f, -0.02408808f, 0.09420062f, 
    0.12449742f, 0.07007618f, -0.16713281f, -0.03767268f, -0.12317041f, 0.10456320f, -0.03816291f, 0.01919967f, 
    -0.00111129f, -0.02260746f, -0.05706619f, -0.04501244f, -0.37788689f, 0.14044724f, -0.02843297f, -0.30206400f, 
    -0.12099339f, 0.04623407f, -0.04681700f, -0.25120243f, -0.13168600f, -0.12860224f, 0.11013500f, -0.14533803f, 
    0.41097498f, 0.03643685f, 0.08275143f, -0.32149044f, 0.07926697f, -0.17691740f, 0.05889951f, 0.06259750f, 
    0.01382464f, 0.04022921f, 0.09110396f, -0.01585996f, 0.04233887f, 0.17936027f, -0.06405389f, -0.47810027f, 
    -0.18450229f, 0.03819453f, 0.02441334f, 0.13803168f, 0.10308427f, -0.02642174f, 0.05136541f, 0.11678267f, 
    0.34749794f, 0.14032400f, 0.09666835f, 0.04816896f, -0.03821205f, 0.04425520f, 0.00219392f, 0.10149030f, 
    0.00494896f, 0.13686310f, -0.05334309f, -0.13917637f, -0.66672254f, -0.17084603f, -0.26265588f, 0.19147949f, 
    0.05164522f, 0.09770238f, 0.11454041f, 0.00932329f, 0.02968627f, -0.11191433f, 0.17772725f, -0.00717342f, 
    0.05134642f, 0.13461548f, 0.15037829f, -0.29633075f, 0.12653480f, 0.00002680f, 0.03875260f, 0.12736277f, 
    -0.06289896f, -0.03651902f, -0.14894904f, 0.05620133f, -0.04318665f, 0.08353271f, -0.14471096f, 0.23901799f, 
    0.08239615f, -0.00336638f, -0.11273009f, 0.03933714f, -0.02876587f, -0.08724937f, 0.04850343f, 0.04581189f, 
    0.16892162f, 0.14828447f, -0.00194233f, -0.04908689f, -0.10537630f, 0.09658144f, -0.25767168f, 0.01965702f, 
    0.12732379f, 0.00384229f, -0.02836311f, 0.13542031f, -0.35543969f, -0.15236437f, 0.11919218f, 0.35669729f, 
    0.17198505f, -0.01104994f, 0.19923414f, 0.00507424f, -0.25624827f, -0.03661420f, -0.17252864f, -0.02248570f, 
    -0.86838055f, 0.21336998f, 0.21124464f, 0.01539918f, -0.15954490f, -0.20813754f, 0.07950663f, -0.00270760f, 
    -0.01732276f, 0.07274754f, 0.11923617f, 0.11715546f, -0.20573767f, 0.30134115f, -0.09100974f, 0.18331905f, 
    -0.10638423f, -0.16304322f, 0.06544717f, 0.01062901f, 0.07054862f, 0.04038606f, 0.00184662f, -0.04402465f, 
    0.14033565f, 0.18246508f, 0.01129312f, -0.53000289f, -0.07973789f, 0.01494050f, 0.02657278f, 0.09520149f, 
    0.02993219f, -0.09195337f, 0.01508888f, -0.09578948f, 0.39811048f, -0.13095331f, -0.16216929f, -0.23324074f, 
    -0.01736297f, 0.01978544f, -0.07372303f, -0.06948103f, -0.13873102f, 0.17140985f, 0.14534119f, 0.17670801f, 
    -0.15318120f, 0.03012353f, 0.12746455f, 0.14247929f, 0.17451315f, 0.19144529f, 0.12939593f, 0.00183369f, 
    0.03717405f, -0.23975758f, 0.11993031f, -0.13983005f, 0.24837923f, 0.23471540f, 0.08784757f, -0.33696276f, 
    -0.04050975f, -0.12477680f, -0.05886919f, 0.09189501f, -0.06976593f, 0.10702701f, -0.09181409f, 0.05932831f, 
    0.16740687f, -0.08600205f, 0.22501858f, 0.20518929f, 0.00819569f, 0.02394611f, -0.01534918f, 0.09620816f, 
    0.13622569f, 0.04526055f, -0.12470211f, 0.17615029f, 0.05295087f, 0.07536654f, 0.26513499f, -0.04492546f, 
    -0.16137135f, 0.07089940f, -0.00680145f, 0.01699500f, -0.05248859f, -0.08176738f, 0.06898707f, -0.26487100f, 
    -0.08562414f, -0.05924776f, 0.03949251f, -0.16516224f, 0.07191929f, 0.10179301f, -0.09273408f, 0.14800824f, 
    -0.14943992f, 0.04972570f, -0.04353877f, -0.40042681f, -0.19593306f, -0.18339238f, -0.18666972f, -0.39883676f, 
    -0.05691376f, 0.05625397f, -0.12386904f, -0.02668259f, -0.04296881f, 0.18115012f, -0.02816224f, 0.26744241f, 
    0.15277761f, 0.22300495f, 0.01908108f, -0.37281242f, -0.07156923f, 0.08723097f, 0.03766077f, -0.00572719f, 
    0.17300022f, 0.05039813f, -0.17910267f, -0.04714597f, -0.16949455f, -0.55068690f, -0.02822886f, -0.51403642f, 
    0.05572084f, -0.09694980f, 0.08220904f, 0.00078903f, -0.07812815f, 0.03889431f, 0.12268391f, 0.19608332f, 
    0.42866942f, 0.18889119f, 0.04830498f, -0.20111038f, -0.09064920f, 0.21536733f, 0.00056885f, -0.01375482f, 
    0.06830531f, -0.03122864f, 0.01480640f, -0.00853277f, -0.50301391f, 0.10664781f, -0.01627506f, 0.17243846f, 
    0.11795976f, 0.04641853f, 0.00103081f, 0.01439954f, -0.00385324f, 0.04594689f, -0.14293282f, 0.07011887f, 
    -0.18159036f, -0.15088174f, -0.04857583f, 0.53148997f, 0.01557200f, 0.02524034f, -0.05831510f, -0.22187483f, 
    -0.07507030f, 0.02305547f, -0.01027164f, -0.12982050f, -0.14529400f, -0.19535366f, 0.02905165f, -0.01001062f, 
    -0.09439073f, -0.03950482f, 0.03947138f, -0.19289272f, 0.12255020f, -0.17946610f, 0.08289555f, 0.06153123f, 
    0.29742348f, 0.02514218f, -0.22988063f, 0.16525200f, -0.08596566f, 0.05281422f, -0.06366066f, -0.18558840f, 
    -0.24451084f, 0.03744844f, 0.05775111f, -0.18665770f, -0.36919659f, -0.08711796f, -0.10704280f, -0.16005446f, 
    -0.00748064f, 0.02335262f, 0.21122962f, 0.07097819f, 0.03149822f, 0.00224296f, 0.11093087f, -0.00201192f, 
    0.08159821f, -0.61492425f, -0.09772845f, -0.05895634f, 0.10075933f, -0.07077163f, -0.00803741f, -0.15318277f, 
    -0.04234771f, -0.20823257f, -0.02146243f, 0.01685094f, -0.15061413f, -0.09475816f, 0.18543957f, -0.04492511f, 
    0.12607636f, -0.13004652f, 0.05950779f, 0.00950322f, -0.14272955f, 0.01866942f, -0.01416959f, -0.02499206f, 
    0.45371279f, 0.08755198f, 0.10066517f, 0.14117439f, -0.15814264f, 0.00832904f, -0.03064755f, -0.13848798f, 
    0.06356163f, 0.07787729f, 0.02095184f, 0.01483515f, -0.13140590f, 0.18009982f, 0.00998615f, 0.33188283f, 
    0.00145447f, -0.09446796f, -0.14291398f, 0.05548975f, -0.07158238f, -0.02453890f, -0.09262358f, -0.17388581f, 
    -0.19643408f, 0.11799727f, -0.21130304f, 0.12808816f, -0.06247340f, 0.00081814f, -0.06253195f, -0.07563932f, 
    -0.09208450f, 0.05987218f, -0.04907428f, -0.13476044f, -0.05104974f, 0.21334668f, 0.15959473f, 0.25368091f, 
    0.11115922f, -0.03254452f, 0.00908452f, -0.05277291f, -0.13369779f, -0.05905768f, -0.03735378f, -0.19137132f, 
    0.44403112f, 0.02121884f, -0.36930674f, -0.12729010f, -0.07329886f, -0.11747075f, -0.05301299f, -0.12353580f, 
    -0.11417536f, -0.07491188f, -0.05013982f, -0.04460213f, -0.20606427f, 0.25028554f, 0.05782306f, -0.09878350f, 
    -0.22563486f, 0.04690288f, -0.06505310f, -0.13961725f, -0.10995521f, -0.04641669f, -0.17825261f, -0.11713917f, 
    0.31045792f, 0.12400689f, 0.03082939f, 0.29228532f, 0.19090697f, 0.08147935f, 0.06004734f, -0.07828436f, 
    -0.14880037f, -0.00388928f, 0.13160768f, -0.17991324f, 0.02253401f, 0.20965022f, -0.06741977f, 0.05324763f, 
    -0.02906206f, 0.06599831f, -0.11343559f, -0.00724982f, 0.04558815f, -0.01563922f, -0.02463807f, -0.08608191f, 
    0.15861298f, -0.41232595f, -0.09558804f, -0.15412982f, 0.05424706f, -0.18176535f, -0.09154638f, -0.09867347f, 
    -0.19279273f, 0.03656598f, -0.02076714f, 0.01855861f, -0.14536700f, -0.03034108f, -0.11502369f, 0.31177998f, 
    -0.07086975f, -0.07893741f, -0.13853943f, 0.08920402f, 0.04224037f, 0.09134685f, 0.00512840f, -0.02363112f, 
    0.06667970f, 0.03624866f, 0.15907894f, 0.12428007f, -0.20373777f, 0.06353157f, 0.03591907f, -0.00995809f, 
    -0.02076537f, -0.00093988f, -0.03702530f, 0.12163427f, -0.17593263f, -0.15404926f, 0.22555783f, 0.28221259f, 
    0.38554364f, -0.22509761f, -0.08721884f, 0.07456248f, -0.06316379f, -0.01880527f, -0.06283398f, 0.01369683f, 
    -0.11167473f, 0.23581825f, -0.07532878f, -0.00844503f, -0.03409357f, -0.05646242f, -0.12463387f, -0.11100800f, 
    -0.16759686f, -0.04998279f, -0.01167406f, -0.15965709f, -0.12064551f, -0.07866181f, -0.15210938f, -0.19068690f, 
    0.06377906f, -0.01883258f, -0.00634356f, -0.06774668f, -0.11213023f, -0.08668430f, -0.08912505f, -0.02301931f, 
    -0.38523331f, 0.10649516f, -0.20369203f, -0.09420811f, -0.18195570f, 0.01897483f, -0.03208922f, -0.14077266f, 
    -0.10073753f, -0.02902810f, -0.04424786f, -0.01149362f, 0.21470909f, 0.22550268f, 0.09015625f, 0.19938311f, 
    0.21355809f, 0.18387367f, 0.12516570f, 0.03079647f, -0.14338502f, -0.08387303f, -0.02532006f, -0.02082727f, 
    -0.40168795f, -0.06545042f, -0.06230223f, -0.21095285f, -0.03988780f, -0.08826192f, 0.04865102f, -0.10954004f, 
    -0.00122381f, -0.04227087f, 0.06310804f, -0.15527059f, -0.34626698f, -0.06494991f, -0.27776188f, -0.30437833f, 
    -0.03339654f, -0.02935034f, -0.03946637f, -0.11279007f, -0.05391563f, -0.01515527f, -0.05117917f, -0.20308323f, 
    -0.28696471f, 0.29357219f, -0.00576216f, -0.03159807f, -0.13700789f, -0.12518494f, 0.14386174f, -0.03701939f, 
    -0.09498663f, 0.03782253f, -0.04865111f, -0.15168446f, 0.22460195f, 0.06473411f, 0.22994618f, 0.15683670f, 
    0.19592698f, 0.05887578f, -0.02363810f, -0.05043406f, -0.12400127f, 0.03196912f, 0.00167033f, -0.12454262f, 
    -0.22307579f, -0.07406072f, -0.02421085f, -0.05179395f, -0.12373608f, -0.09239674f, 0.01477023f, -0.03200153f, 
    -0.27860427f, 0.02229554f, 0.06567748f, -0.03656799f, -0.08969887f, 0.13159658f, 0.20314573f, 0.13129303f, 
    0.06037603f, 0.14141826f, 0.08917309f, 0.07125164f, -0.04982742f, -0.05157504f, 0.02024127f, -0.01949394f, 
    -0.54339504f, 0.00428142f, -0.36842096f, -0.14711058f, 0.00691308f, -0.01800621f, -0.00822541f, -0.06737571f, 
    -0.08120264f, 0.05536708f, -0.01852192f, -0.05291178f, 0.16190337f, 0.07078234f, 0.30873936f, 0.05154285f, 
    0.18488368f, 0.10876361f, 0.02677738f, 0.07849985f, -0.12825401f, 0.19772109f, 0.20046076f, -0.05621502f, 
    -0.01231189f, 0.27179155f, -0.14277160f, 0.27015725f, -0.22695035f, 0.00327886f, -0.09646928f, 0.08418728f, 
    -0.13287811f, -0.09862011f, 0.02122528f, -0.12281131f, -0.08691392f, -0.08534180f, -0.27054691f, -0.04213782f, 
    -0.14451958f, -0.05370328f, -0.05793792f, -0.08616714f, -0.14908032f, 0.01823602f, 0.03372290f, 0.00461000f, 
    0.24298684f, -0.60515720f, 0.10648146f, 0.07983682f, 0.07630202f, 0.04054560f, 0.11682573f, -0.00222209f, 
    0.11462815f, -0.31820875f, -0.01784017f, -0.00106727f, 0.23097596f, -0.12069838f, 0.25671136f, 0.08956064f, 
    0.06486396f, 0.05604452f, 0.04628562f, 0.00196713f, -0.08824175f, -0.00796155f, -0.08473834f, 0.01949312f, 
    0.23948017f, 0.27538025f, 0.13264416f, 0.20155585f, 0.14138250f, 0.11668292f, 0.14300390f, 0.04118026f, 
    -0.01912103f, -0.10781709f, 0.20218822f, -0.09288488f, 0.19425893f, 0.23190737f, 0.12840684f, 0.19743334f, 
    0.20345050f, 0.05443508f, 0.14929982f, -0.10088150f, -0.08026047f, 0.03328511f, -0.10007314f, -0.11247551f, 
    0.16388343f, 0.05533298f, -0.20106357f, 0.01543193f, 0.17519644f, -0.03566350f, 0.06671510f, -0.05084849f, 
    -0.03934506f, -0.06161490f, -0.28301251f, 0.17350104f, 0.16550632f, -0.28765768f, 0.04145932f, -0.07401600f, 
    -0.09380154f, -0.16405953f, -0.09859696f, -0.09845454f, -0.07955700f, -0.13955469f, -0.15213919f, -0.05342049f, 
    -0.27036598f, -0.19067180f, -0.09015223f, -0.19489916f, 0.20729208f, -0.10041341f, 0.11657512f, 0.00438927f, 
    0.05972280f, -0.14738260f, -0.05491548f, 0.27145949f, 0.07465659f, 0.42487192f, -0.58001757f, -0.12639667f, 
    0.15846586f, -0.12666927f, -0.19228865f, -0.10516942f, 0.13737245f, 0.01945026f, 0.01724360f, -0.05423151f, 
    -0.18335104f, 0.14254598f, -0.27918762f, -0.07697945f, -0.08876943f, 0.10420451f, -0.07793282f, -0.07759844f, 
    0.13367318f, 0.00651171f, 0.00610386f, 0.04917937f, -0.31716946f, 0.11217529f, 0.26871270f, -0.22890899f, 
    -0.07930148f, -0.25867873f, 0.07318227f, 0.06277210f, -0.00533890f, 0.09148980f, -0.02655701f, 0.16639583f, 
    0.08092422f, -0.38589987f, 0.04152913f, 0.07277346f, 0.14135699f, -0.00234382f, -0.00338659f, -0.15843457f, 
    -0.14931048f, 0.03156685f, 0.01090972f, -0.04350414f, -0.08726718f, -0.12604310f, 0.30930454f, 0.33517343f, 
    0.13475570f, -0.09238774f, 0.01941738f, -0.02573053f, 0.06440000f, -0.13560545f, -0.09364149f, -0.00986455f, 
    -0.04532224f, -0.31328326f, 0.02520101f, -0.25421742f, 0.05418285f, -0.08810236f, 0.17061678f, 0.08960038f, 
    0.04691221f, -0.06308833f, -0.00133748f, 0.10795143f, 0.06309912f, 0.36849621f, -0.00426125f, 0.09938677f, 
    -0.27433044f, -0.00050369f, -0.11342509f, -0.00177531f, 0.05097836f, -0.03606474f, -0.15343845f, -0.19606458f, 
    -0.24814650f, -0.23554796f, -0.04368080f, 0.05131016f, -0.00691804f, 0.00724695f, 0.05050124f, -0.05803594f, 
    0.22863615f, 0.06974313f, 0.15258808f, -0.11653560f, 0.12901045f, 0.00109590f, -0.49967241f, -0.34164852f, 
    -0.01343677f, -0.30549312f, 0.04296050f, -0.00604356f, 0.11554388f, -0.04703926f, 0.17845666f, 0.10833190f, 
    -0.23572840f, 0.29966068f, -0.02931228f, -0.09773863f, 0.01790848f, -0.01923133f, 0.10515766f, -0.15135236f, 
    0.06167554f, -0.00152117f, 0.00989724f, -0.01041555f, 0.07012325f, 0.29404694f, -0.05871754f, 0.21804781f, 
    -0.06876545f, -0.15045226f, -0.25113580f, -0.09292923f, -0.02177341f, 0.04458594f, 0.06826970f, -0.18512429f, 
    0.25654963f, 0.06820649f, 0.00729680f, 0.14032172f, 0.03397066f, -0.06812231f, -0.11335927f, -0.06775059f, 
    -0.19738811f, 0.02658185f, -0.03051297f, -0.12269340f, 0.21993889f, 0.12655842f, -0.24669372f, 0.14048222f, 
    0.08380598f, 0.04837731f, -0.01251306f, -0.08240601f, -0.04180282f, -0.07505683f, 0.07276870f, -0.05636037f, 
    -0.07089300f, 0.20291838f, 0.12185024f, 0.30745432f, 0.02806668f, -0.00968165f, -0.02759080f, -0.03845200f, 
    0.02397889f, -0.01252512f, 0.10223431f, 0.16221786f, 0.01470827f, -0.25845635f, -0.03719118f, -0.33886716f, 
    0.15700847f, -0.21604729f, 0.13018163f, -0.05870184f, 0.01591673f, 0.13908806f, 0.00112893f, -0.12571114f, 
    0.14189185f, -0.32312846f, -0.03351525f, 0.12044208f, -0.02469015f, -0.03263820f, -0.07719946f, 0.07466082f, 
    -0.05878190f, 0.03202068f, 0.09470174f, 0.13543372f, 0.11553481f, -0.04385811f, -0.01543872f, 0.22239965f, 
    0.08535539f, -0.07313029f, -0.06902342f, -0.11503965f, -0.05192682f, -0.05020665f, 0.16962591f, -0.17330813f, 
    0.30197930f, -0.46981272f, 0.01563854f, 0.00823190f, 0.12914370f, -0.05361542f, -0.16607259f, -0.02857166f, 
    0.19964603f, -0.12670425f, 0.23631637f, -0.27147722f, -0.37056434f, -0.32345858f, 0.18924306f, -0.21540760f, 
    -0.21093577f, 0.09415883f, -0.09538280f, -0.41042355f, 0.06683482f, -0.07192282f, -0.09399563f, 0.22214584f, 
    0.20893010f, -0.09042230f, -0.30284095f, 0.10484108f, 0.16792187f, -0.10410580f, -0.01257261f, -0.07859980f, 
    0.01779659f, 0.04207095f, 0.20237352f, -0.06367621f, -0.33964634f, 0.08054744f, 0.12729147f, 0.08791449f, 
    -0.09728567f, -0.09514499f, -0.09152332f, -0.20048901f, 0.07598446f, 0.12884852f, 0.04964026f, -0.13305245f, 
    -0.10616168f, 0.01196201f, -0.00700250f, 0.06763136f, 0.01720046f, 0.06648935f, -0.09164523f, 0.02881045f, 
    0.14611299f, 0.05555277f, 0.14805435f, -0.05128609f, -0.20185253f, -0.11443366f, 0.33819667f, 0.04886615f, 
    -0.08912447f, -0.13813724f, -0.06624392f, -0.12499958f, 0.09418698f, -0.30228040f, -0.37509120f, -0.01016874f, 
    -0.11010377f, -0.17929976f, -0.23367395f, -0.35100996f, -0.06997512f, -0.19796407f, 0.11683866f, 0.09195145f, 
    0.07824160f, 0.07431309f, -0.02643058f, 0.14611124f, 0.01874264f, -0.18434745f, -0.19302817f, -0.07767908f, 
    0.10451002f, -0.08600102f, -0.07749628f, 0.02613917f, 0.16120864f, 0.07075741f, 0.01801573f, -0.15277778f, 
    0.46422467f, 0.08833817f, -0.21629000f, -0.05112989f, -0.11902924f, 0.04025046f, 0.04285065f, 0.01387839f, 
    -0.00810091f, 0.04708698f, 0.06427048f, 0.24063805f, 0.08429194f, -0.09780776f, 0.30449545f, 0.03461359f, 
    0.01737115f, 0.14846894f, -0.00484168f, -0.11905645f, 0.03899442f, -0.01728169f, 0.10139254f, 0.05197007f, 
    0.09613942f, -0.07127824f, 0.01857412f, 0.06056802f, 0.10069571f, 0.11217388f, 0.16379550f, -0.11753547f, 
    -0.06940061f, 0.00980000f, 0.03234593f, 0.16147584f, -0.39048791f, -0.07759815f, 0.18715277f, -0.04353355f, 
    -0.01601150f, -0.00617229f, -0.16502549f, 0.03742621f, 0.06055965f, -0.05267704f, -0.10740080f, 0.06729649f, 
    0.20523687f, -0.25319666f, 0.22091416f, -0.13475709f, -0.04396833f, 0.04892506f, -0.10733636f, -0.13335583f, 
    -0.18878166f, 0.13877717f, 0.03957999f, 0.10559866f, 0.29194996f, -0.00257809f, -0.16910887f, 0.42588487f, 
    0.01419825f, 0.03911212f, -0.05272662f, 0.01112021f, -0.00834545f, 0.06210672f, -0.10658696f, 0.15837705f, 
    -0.01343769f, 0.17966054f, -0.15036118f, 0.10330076f, 0.03864895f, -0.05314896f, 0.06786127f, 0.00386646f, 
    -0.15693972f, 0.15646851f, 0.15337324f, 0.00709845f, -0.27661905f, 0.07562727f, 0.40790334f, -0.01375448f, 
    -0.04074521f, -0.05411776f, -0.10409750f, 0.00476546f, -0.17316397f, -0.09451556f, 0.15266739f, -0.00962006f, 
    -0.15663460f, 0.53653771f, -0.17530708f, -0.12270744f, 0.10157954f, 0.01240818f, -0.06615913f, 0.11090203f, 
    -0.11703184f, 0.01378199f, 0.05483644f, -0.07488529f, 0.13495646f, -0.25318351f, -0.11634162f, -0.00362518f, 
    -0.00491419f, 0.03152763f, -0.09785065f, 0.13144419f, 0.04846554f, -0.24087813f, 0.02448948f, -0.08066907f, 
    -0.05156690f, 0.22759916f, -0.12808833f, -0.46008676f, -0.02826118f, 0.01155889f, -0.00287774f, -0.00964168f, 
    0.05507303f, -0.06539866f, -0.06432083f, 0.23445535f, -0.69788140f, 0.28419051f, -0.22074991f, -0.18482989f, 
    0.17474106f, -0.13958833f, 0.05049044f, -0.02580000f, -0.08342665f, 0.05733849f, 0.09697293f, 0.11993145f, 
    -0.31644097f, -0.04709805f, -0.11564689f, -0.00880426f, -0.00675105f, 0.22109413f, 0.03859238f, 0.02715951f, 
    0.03715007f, -0.03916344f, -0.00181031f, -0.02982909f, -0.04488832f, 0.13983677f, 0.23649293f, 0.04568163f, 
    0.12953651f, -0.01333874f, -0.04305863f, 0.37443954f, 0.07458965f, -0.19783680f, -0.01893527f, 0.00983066f, 
    -0.00864402f, -0.42522240f, 0.02680957f, -0.41257420f, -0.07229553f, 0.00217403f, -0.01304175f, -0.13053371f, 
    -0.10329795f, -0.12857448f, 0.09349935f, -0.06741972f, -0.11867771f, 0.14224057f, 0.16993180f, -0.26044548f, 
    0.01441550f, -0.02566056f, -0.13587552f, 0.08411680f, 0.02153789f, 0.02243945f, -0.00570741f, -0.22667973f, 
    -0.30531973f, -0.07450441f, -0.34447753f, 0.53211612f, -0.01504113f, 0.09091046f, -0.15575105f, -0.01567361f, 
    -0.02735928f, 0.02066371f, 0.06402550f, -0.05619095f, 0.75377589f, -0.92804343f, 0.07282162f, -0.10737115f, 
    -0.06497484f, 0.16958638f, 0.10802670f, 0.21248142f, -0.08110316f, -0.07275595f, 0.00798025f, 0.01663256f, 
    -0.24795336f, 0.33309591f, -0.06173095f, -0.06011755f, -0.00259319f, 0.13013639f, -0.16463836f, -0.15264788f, 
    0.01833143f, 0.02458650f, 0.05808363f, -0.07195578f, -0.17907074f, 0.22909756f, 0.11094261f, -0.17251678f, 
    0.14715132f, 0.14502089f, -0.12724434f, -0.11838974f, -0.14478897f, 0.24973735f, -0.00773590f, -0.13229468f, 
    -0.00960030f, 0.24029234f, -0.18851168f, -0.25618839f, 0.22116296f, -0.07657348f, 0.10603753f, 0.06216806f, 
    -0.16701663f, 0.08864238f, 0.05928567f, -0.30397290f, -0.33789968f, -0.37781805f, 0.00308681f, 0.22244872f, 
    -0.00710194f, 0.15813644f, 0.00756218f, -0.05408548f, 0.14022362f, -0.18211912f, 0.16821544f, 0.11484954f, 
    -0.40220088f, 0.18619995f, 0.09877802f, 0.22303292f, 0.10093965f, -0.08161645f, 0.11582405f, -0.06707357f, 
    -0.26675123f, -0.03021534f, -0.17390841f, -0.07162940f, -0.37784898f, -0.02700846f, -0.03758227f, -0.13668038f, 
    0.01889319f, -0.03626939f, 0.06874948f, 0.02879835f, 0.09000570f, 0.01652300f, -0.23326412f, 0.11863172f, 
    -0.47467285f, 0.18808998f, -0.08240526f, -0.06369138f, 0.19448783f, -0.07336799f, 0.04640474f, -0.09746655f, 
    0.11306082f, 0.11166963f, -0.07751445f, 0.02374826f, 0.26715279f, 0.04342437f, -0.11820795f, 0.34419030f, 
    0.01696196f, -0.14785732f, 0.00794514f, -0.04186368f, 0.02337277f, 0.03091068f, 0.10588271f, -0.07541528f, 
    0.02854086f, 0.06467380f, -0.08127720f, -0.06343111f, -0.09443647f, 0.08970395f, 0.15164633f, 0.04223679f, 
    -0.00901655f, 0.03761524f, -0.09155104f, 0.06479379f, -0.08478650f, -0.49166679f, -0.04366422f, 0.06246802f, 
    0.21455635f, 0.01856845f, -0.03260581f, 0.04349799f, 0.19091167f, 0.01445876f, 0.02260098f, -0.04251607f, 
    -0.08683607f, 0.05437148f, -0.11792037f, -0.45504138f, 0.08686372f, -0.00295065f, 0.01904003f, 0.01924267f, 
    -0.05722428f, -0.03899511f, -0.18593639f, -0.16558687f, 0.18746714f, -0.20778395f, 0.00695574f, 0.18356395f, 
    0.07585899f, 0.10517118f, -0.04218162f, 0.13481890f, -0.11256712f, 0.12634329f, 0.08584863f, 0.02942232f, 
    -0.31149125f, 0.13484171f, -0.01747561f, -0.30694363f, -0.07796132f, -0.10037842f, 0.00700899f, -0.02128809f, 
    -0.01414363f, 0.05019633f, 0.22961040f, -0.13230944f, 0.37181121f, 0.11392450f, 0.21465154f, 0.11384071f, 
    0.13415845f, 0.05263400f, 0.18416347f, -0.18125209f, -0.04467090f, 0.05118038f, -0.04026354f, -0.11297604f, 
    0.12638794f, -0.37598664f, 0.23682763f, -0.23351409f, 0.02700264f, 0.14731526f, -0.10684499f, 0.07598227f, 
    -0.08353956f, 0.04099592f, 0.19148827f, 0.11627253f, 0.18819837f, -0.28206033f, -0.00799728f, 0.01438888f, 
    0.03979294f, -0.02674326f, -0.21744548f, -0.01653042f, -0.00921256f, 0.19309470f, 0.02098920f, -0.12001887f, 
    -0.17620981f, -0.08226202f, 0.07074910f, 0.04308482f, 0.10774830f, -0.25991973f, 0.06190825f, -0.04643590f, 
    0.12691553f, -0.02058396f, 0.07686125f, 0.04433347f, -0.14955449f, -0.33549619f, -0.05926717f, 0.14320616f, 
    -0.05776253f, -0.05309290f, 0.02605894f, -0.12431271f, 0.01230964f, -0.12643513f, -0.07172187f, -0.07179485f, 
    -0.52406293f, -0.13740654f, -0.10645418f, -0.14965396f, 0.04066175f, 0.00732477f, 0.01809743f, -0.05188658f, 
    0.04947747f, -0.06801511f, -0.29394054f, 0.07545107f, 0.49503401f, 0.15269238f, -0.17746224f, 0.13415232f, 
    -0.19398989f, -0.24382462f, 0.02154725f, 0.03180261f, 0.04849579f, -0.18826149f, 0.05685970f, -0.10264685f, 
    -0.03327823f, 0.22851008f, 0.05815393f, -0.03457116f, 0.25575349f, 0.17356871f, 0.10486414f, -0.05458372f, 
    0.01595175f, 0.01753614f, 0.07788611f, 0.05099685f, -0.42455247f, -0.14734674f, 0.33624521f, -0.00149379f, 
    0.12291575f, -0.08322224f, -0.16144747f, -0.06494960f, 0.05954938f, -0.14406291f, 0.01671956f, -0.16359083f, 
    -0.02574400f, -0.19303507f, 0.09538648f, -0.20952056f, 0.09851573f, 0.09534872f, 0.03613582f, -0.08325012f, 
    0.06368511f, -0.00830624f, 0.03570045f, 0.11697261f, 0.17287752f, -0.06782304f, 0.03338839f, -0.17967549f, 
    0.02284729f, -0.07420725f, 0.03827168f, -0.13929431f, 0.20747568f, 0.18859832f, 0.09987462f, 0.12540126f, 
    0.01144600f, 0.02147583f, 0.07428324f, 0.02637406f, 0.15045199f, 0.13142607f, -0.10542022f, 0.00818616f, 
    0.10893120f, 0.18399133f, -0.02330446f, -0.04354949f, -0.44608903f, -0.42650622f, -0.13786337f, -0.27364472f, 
    -0.05910568f, -0.19265349f, -0.14998668f, -0.08541727f, -0.09422305f, -0.31162426f, -0.16224490f, -0.24717039f, 
    -0.18748829f, 0.19184698f, -0.08063330f, 0.39262894f, -0.04187659f, -0.05596810f, 0.13756749f, -0.11384632f, 
    0.10520550f, 0.17007673f, 0.08566304f, 0.18330450f, 0.12151031f, -0.13869090f, 0.13502045f, -0.09821424f, 
    -0.16643359f, 0.03103606f, 0.09709749f, -0.07456096f, 0.04720124f, -0.00520326f, -0.11917014f, -0.03283245f, 
    -0.01529376f, 0.37627968f, 0.29107204f, -0.07341246f, 0.14139315f, 0.08400691f, 0.03213007f, 0.26200366f, 
    0.05458375f, 0.24709865f, 0.01520555f, 0.11070913f, 0.34132996f, 0.00501317f, 0.23848037f, -0.00985433f, 
    0.17463796f, -0.05130695f, -0.02590077f, 0.02003984f, 0.01683235f, -0.05442864f, -0.03033659f, 0.01885365f, 
    0.18467262f, 0.01305882f, 0.09517898f, -0.15238923f, -0.03029102f, 0.08109295f, 0.07975028f, -0.10760468f, 
    0.16497840f, -0.00628856f, -0.11880518f, -0.06249224f, -0.46129122f, 0.06006347f, -0.25152048f, 0.22300611f, 
    0.16913411f, 0.05555891f, -0.22913300f, 0.05204765f, -0.04198208f, 0.16039334f, 0.09181286f, 0.16022754f, 
    -0.27541065f, -0.37830928f, -0.33332092f, -0.09326615f, 0.03960216f, 0.19328262f, -0.01003466f, -0.05451201f, 
    0.13886695f, -0.01026153f, -0.07253388f, 0.08798847f, -0.77713585f, -0.51887459f, -0.04119484f, -0.19353497f, 
    0.17871936f, 0.13636068f, -0.07266288f, -0.06185045f, 0.12730515f, -0.10616320f, 0.20595434f, 0.06333835f, 
    -0.77026808f, -0.25039259f, -0.21050045f, -0.52971506f, 0.08399463f, 0.07719322f, -0.09702826f, 0.00066729f, 
    0.07734851f, 0.11174420f, 0.10789905f, 0.12769216f, -0.31104371f, 0.00164452f, -0.19616708f, -0.03309261f, 
    0.15089625f, -0.00166635f, 0.04410143f, -0.07099614f, 0.00509492f, -0.07808846f, -0.23515756f, -0.20425847f, 
    0.00628160f, -0.40410477f, -0.00901075f, 0.04256905f, -0.03734690f, -0.01353509f, -0.03649185f, 0.20584044f, 
    0.04922199f, 0.18750085f, -0.03538362f, 0.31382915f, -0.70184433f, -0.29591423f, 0.15367530f, 0.07968524f, 
    0.08831652f, -0.04398147f, -0.22913127f, -0.14736097f, 0.02851337f, -0.10479456f, 0.10907376f, -0.03125360f, 
    -0.34658352f, -0.17034931f, 0.00071471f, 0.08555854f, -0.00257660f, -0.03215821f, -0.04672812f, 0.03229360f, 
    0.17718877f, -0.10561154f, -0.03814789f, -0.05936212f, 0.04613568f, 0.10758901f, 0.06352532f, -0.06776585f, 
    0.13840199f, 0.06548403f, 0.10749237f, 0.07478993f, 0.10156057f, 0.04962434f, -0.13907140f, 0.16683885f, 
    -0.23221628f, -0.31456038f, -0.16174327f, -0.12249547f, 0.02151039f, -0.16760306f, 0.03778163f, 0.14186522f, 
    0.14847489f, 0.18195207f, 0.11340564f, -0.03699898f, 0.30082342f, 0.16936998f, -0.05667910f, 0.00181208f, 
    -0.18187024f, -0.11690866f, 0.09536786f, 0.01520053f, -0.09213455f, 0.10253819f, 0.15615132f, -0.12999658f, 
    -0.36208525f, -0.00952884f, -0.10321721f, -0.17849042f, -0.04825988f, -0.00529736f, -0.05583655f, 0.06462920f, 
    0.00451528f, 0.09386676f, 0.07138059f, 0.09421136f, 0.09242690f, -0.18982871f, -0.09554722f, -0.13567144f, 
    -0.10886370f, -0.08585566f, 0.02395166f, 0.01685842f, -0.01251625f, -0.22887829f, -0.09426469f, -0.04622127f, 
    -0.02281527f, 0.04044932f, -0.00058147f, -0.02409947f, 0.09846925f, -0.08958935f, 0.18650924f, -0.06021504f, 
    -0.06519547f, 0.06301426f, -0.03454242f, 0.20973293f, -0.90273207f, 0.13124125f, 0.45964110f, 0.21045198f, 
    0.31115657f, 0.04995638f, 0.00334154f, -0.22426614f, 0.11309073f, -0.08428003f, -0.04463821f, 0.03469321f, 
    -0.45332211f, -0.24911761f, -0.04259121f, -0.01586605f, 0.06108363f, 0.05737389f, -0.01647995f, 0.00062959f, 
    0.03173771f, -0.07360549f, -0.05901059f, -0.14165117f, 0.22088377f, 0.10569976f, -0.08370887f, -0.12288471f, 
    -0.09199768f, 0.12644179f, 0.04100133f, 0.15023464f, 0.08473314f, 0.21499133f, 0.01989581f, 0.01655631f, 
    0.10676757f, -0.00175923f, -0.01993300f, 0.08303017f, -0.07196294f, 0.02124142f, -0.12322814f, 0.00146640f, 
    0.17177092f, 0.15298128f, -0.04704292f, 0.11502968f, 0.21975800f, -0.04842043f, 0.05853324f, -0.26540819f, 
    -0.02146071f, 0.02636003f, 0.02615004f, 0.12887254f, -0.01769095f, 0.09945402f, 0.02821979f, 0.06387094f, 
    0.76076031f, 0.04911890f, -0.00054406f, -0.04127885f, -0.05692887f, 0.06623901f, -0.06473320f, -0.07092559f, 
    0.06181985f, -0.03252916f, 0.15816173f, -0.00392671f, -0.05610292f, -0.28619346f, 0.24079737f, -0.26484674f, 
    -0.09821004f, -0.00460643f, 0.10014047f, -0.24460126f, -0.08480357f, 0.07454113f, 0.08918019f, 0.10912640f, 
    -0.41755822f, 0.30831632f, -0.04711843f, 0.10756423f, 0.19008556f, -0.02492943f, -0.04309849f, 0.00808332f, 
    0.01875158f, 0.07799472f, 0.02209368f, -0.05229171f, 0.13555261f, -0.10026798f, -0.25399661f, 0.11379682f, 
    0.09257562f, 0.06433019f, -0.08168446f, -0.21538202f, 0.02165807f, 0.06955878f, -0.01205346f, 0.02610280f, 
    0.20717058f, -0.33972615f, -0.37900838f, 0.56322539f, -0.00664996f, -0.08057768f, -0.03143523f, -0.12582529f, 
    0.06711854f, 0.18017980f, -0.00180784f, -0.01720055f, 0.21725023f, 0.16515496f, -0.06836962f, 0.00855159f, 
    -0.00948823f, -0.01018234f, -0.15413404f, -0.18642990f, -0.12422109f, -0.16963401f, 0.06002967f, -0.15561607f, 
    0.06107885f, 0.12210216f, -0.10864313f, -0.06782504f, 0.33378598f, -0.19495524f, -0.14103241f, 0.14961596f, 
    0.01623300f, 0.10811354f, 0.04944375f, 0.30148157f, -0.31522450f, -0.20517498f, 0.05524091f, -0.37773573f, 
    0.10948172f, 0.03336675f, 0.08170588f, -0.06413200f, 0.00861518f, 0.05808751f, 0.04037957f, -0.01987313f, 
    0.23312967f, -0.28083774f, 0.13706292f, 0.09127893f, -0.17014469f, 0.14837943f, -0.10788433f, 0.07479616f, 
    -0.11279216f, 0.03672250f, -0.10809229f, -0.10774954f, -0.49947742f, -0.06204294f, 0.04440703f, 0.01408178f, 
    0.13625880f, -0.16006283f, 0.04898955f, 0.06184575f, -0.09627134f, -0.02154703f, 0.06902853f, -0.08769210f, 
    0.47645494f, 0.04476841f, -0.18356661f, -0.11828109f, -0.10022563f, 0.00699218f, -0.13484685f, 0.08604075f, 
    0.08200556f, -0.05926787f, -0.11652870f, 0.12754911f, 0.32911763f, -0.11755902f, -0.28478152f, 0.18428645f, 
    0.04311657f, -0.19216311f, -0.01110290f, -0.06574769f, 0.03402569f, 0.09626862f, -0.04392663f, 0.11656931f, 
    -0.11331391f, 0.11639328f, -0.14618057f, 0.00159770f, 0.12250746f, -0.01519870f, 0.16652860f, -0.08540386f, 
    -0.13476256f, 0.01948811f, 0.01894121f, 0.20001136f, -0.35400301f, 0.07129212f, -0.16294844f, 0.09881165f, 
    -0.01777450f, 0.02652746f, -0.03464789f, 0.16781406f, -0.15950529f, -0.06590656f, 0.12876324f, -0.00408935f, 
    -0.40136635f, -0.17241348f, -0.27369824f, -0.01646508f, 0.22143111f, 0.03427954f, 0.10562316f, 0.12481942f, 
    0.02574958f, 0.10076406f, -0.02122644f, -0.16160654f, 0.46720198f, -0.26891410f, -0.07272851f, -0.19464907f, 
    -0.05258469f, -0.11363135f, 0.09442872f, -0.04758281f, 0.00397207f, 0.04191178f, 0.00895532f, 0.05145236f, 
    0.25822464f, -0.34477007f, -0.11708850f, 0.07437556f, 0.08206346f, 0.03586420f, 0.01730533f, -0.01426929f, 
    -0.13497612f, -0.00588496f, -0.06768323f, -0.01123318f, -0.39359266f, -0.08578681f, 0.00665543f, 0.16746075f, 
    -0.06742887f, 0.13236178f, -0.13626376f, -0.07509446f, 0.16908816f, 0.07194732f, 0.06108293f, 0.23874764f, 
    -0.03335582f, -0.11027125f, 0.15605326f, -0.24495739f, -0.03948237f, 0.10040171f, -0.02036623f, 0.01942762f, 
    -0.02267692f, -0.12707116f, -0.16737780f, 0.01073929f, 0.14323701f, -0.01087520f, -0.08050328f, -0.28040180f, 
    0.12945822f, -0.15200625f, 0.03095676f, -0.09918035f, 0.14987402f, -0.05839493f, -0.09259803f, 0.03883991f, 
    0.11211156f, -0.15147890f, 0.08526823f, -0.02087941f, 0.02160561f, -0.05481257f, 0.01413962f, 0.03049154f, 
    0.11384714f, -0.02199293f, -0.06894324f, 0.18717779f, -0.15008688f, 0.22447698f, -0.00645345f, -0.21619931f, 
    -0.21476662f, -0.03506482f, -0.10436852f, -0.08739784f, 0.00690236f, 0.00308448f, 0.05829187f, -0.11539148f, 
    0.31576604f, 0.00641205f, 0.04186328f, 0.18201904f, 0.17445545f, -0.10047967f, -0.03640676f, -0.14235070f, 
    -0.09664210f, -0.16769132f, -0.00741692f, 0.04398994f, 0.20737158f, -0.09239912f, -0.14063448f, 0.21565545f, 
    -0.01447652f, 0.05474649f, 0.13393977f, -0.08172536f, 0.00325583f, -0.04239719f, -0.07956538f, -0.02602476f, 
    0.19514130f, 0.05997286f, -0.22303388f, 0.06695379f, 0.13505577f, -0.02255759f, 0.06794339f, -0.12347878f, 
    -0.04452642f, -0.01300174f, 0.03222493f, -0.00114651f, -0.13123456f, 0.33531883f, -0.15312354f, -0.01561297f, 
    -0.02395321f, -0.16347580f, 0.12042900f, -0.05299846f, 0.03000499f, -0.02810913f, 0.09172887f, -0.25685978f, 
    0.09311639f, -0.10240064f, -0.11736147f, -0.04985653f, 0.21783304f, -0.16058281f, -0.03957729f, 0.00103608f, 
    -0.05242113f, -0.09969555f, 0.09301363f, -0.04424640f, 0.38093987f, 0.21035106f, 0.03482771f, -0.36768550f, 
    -0.01444154f, 0.02054323f, -0.24540038f, -0.07173680f, 0.04196126f, 0.08166306f, 0.07833765f, -0.04780378f, 
    -0.24473260f, -0.12764338f, 0.02133833f, 0.14714701f, -0.09770809f, 0.06896050f, 0.15867606f, 0.23439418f, 
    0.02042255f, 0.09664443f, -0.14661126f, -0.06757834f, -0.52344543f, 0.36481884f, -0.01652413f, 0.03505196f, 
    -0.02473463f, 0.08845346f, -0.04475968f, -0.02780042f, -0.08863834f, 0.01882763f, 0.06919240f, -0.06831340f, 
    -0.20208077f, -0.01309146f, 0.00112161f, 0.26899964f, -0.13903674f, 0.04917383f, -0.14078403f, 0.09429055f, 
    0.03625253f, 0.09130774f, 0.04819978f, -0.03809388f, 0.13693550f, 0.24133730f, -0.09047826f, -0.04001256f, 
    -0.29323009f, 0.18137176f, -0.11979689f, -0.24727218f, -0.05391240f, 0.03056267f, -0.11704209f, -0.09820798f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08314046f, 0.07447287f, -0.01121950f, 0.01085062f, 0.03986712f, 0.05474673f, 0.00581188f, -0.07184841f, 
    -0.01974323f, -0.02331935f, 0.18960348f, 0.06210613f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
