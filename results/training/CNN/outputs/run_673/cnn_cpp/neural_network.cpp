#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.01795300f, -0.85677350f, -0.65771961f, -0.20363791f, 0.36194271f, 0.09208294f, -0.83531803f, -0.57098556f, 
    -0.19646958f, -0.38088867f, 0.13852474f, 0.48749936f, 0.34719661f, 0.24867657f, 0.29544240f, 0.37104103f, 
    0.20738633f, -0.10815948f, 0.14104956f, 0.20954193f, -0.11086985f, -0.04096057f, 0.17689705f, 0.08886528f, 
    0.08836106f, 0.12221984f, 0.84547710f, 0.73846108f, 0.67775404f, 0.88776433f, 1.06230402f, 0.04132936f, 
    -0.99918056f, 0.08042245f, -0.53511190f, 0.16919485f, 0.28566650f, -0.14372459f, 0.23509155f, -0.54392338f, 
    0.09612799f, -0.05055736f, 0.15063399f, -0.00771328f, -0.19474232f, 0.30106953f, 0.05175861f, -0.08981185f, 
    -0.02525588f, 0.06832607f, -1.19912803f, -0.02485578f, -0.17123042f, 0.03782339f, -0.05646190f, 0.78512603f, 
    1.48438656f, 0.38304535f, 0.51389819f, 0.41711685f, -0.15034445f, -0.27572939f, 0.15432596f, -0.45289981f, 
    -0.11690433f, -0.15021445f, -0.14478353f, 0.10678486f, -0.01025708f, -0.24077015f, 0.01670091f, -0.19072549f, 
    0.07396398f, 0.06922215f, 0.05224875f, -1.64801931f, -1.26567411f, -0.49939844f, 0.03825511f, 0.26502702f, 
    0.39897114f, -0.01804785f, 0.36036777f, 0.18387441f, 0.12762550f, 0.40165776f, -0.04887344f, 0.28078127f, 
    0.30122703f, 0.52719659f, 0.02689154f, 0.36472452f, -0.03089010f, 0.08898729f, -0.00583911f, -0.26547742f, 
    -0.36171678f, 0.09794816f, -0.16391738f, -0.12060641f, -1.06663239f, 0.59097987f, -0.38753298f, -0.92142242f, 
    -0.67995363f, 0.07762113f, -0.10333485f, 0.00469948f, 0.46088773f, -0.47809318f, -0.32165307f, -0.05685442f, 
    -0.04751355f, -0.15571706f, -0.45045912f, 0.31367818f, 0.35399464f, 0.22699249f, 0.25860757f, 0.29568177f, 
    0.02144365f, 0.14537853f, -0.15540068f, 0.03739635f, 0.04999329f, 1.44134867f, 0.95737386f, 0.27555791f, 
    -0.62203556f, -0.79834074f, 0.34891915f, -0.01503167f, 0.10516528f, -0.08934775f, 0.60726798f, 0.58320707f, 
    0.44443300f, -0.35871670f, 0.00060592f, 0.03669956f, 0.05500769f, 0.07758492f, -0.12053791f, -0.04203631f, 
    0.06808309f, 0.13358377f, 0.17781417f, 0.08679531f, -0.05894390f, 0.26456681f, -0.96243489f, 1.12693536f, 
    0.20379944f, -0.39118990f, 0.13102199f, -0.28227478f, -0.53341484f, -0.58801407f, -0.20952292f, -0.09056178f, 
    -0.35269728f, -0.10089872f, -0.65815455f, -0.22862925f, 0.06391725f, -0.38288650f, -0.18269534f, -0.45706978f, 
    -0.51788247f, -0.06601256f, 0.17704740f, 0.22158293f, 0.05540058f, -0.09022995f, -0.14571138f, -0.10413247f, 
    -0.25856254f, -0.67692232f, -0.88648158f, -0.68102640f, 0.39774144f, 0.72205448f, -0.31747621f, 0.24335386f, 
    0.46517384f, 0.40756550f, -0.24347247f, 0.01256396f, -0.03064257f, -0.15358439f, -0.03958297f, -0.26258707f, 
    -0.00717024f, -0.09325813f, -0.10007505f, -0.35695875f, 0.30312684f, -0.03015937f, 0.17910422f, 0.13762201f, 
    0.13711371f, 0.87784892f, -0.70650351f, -0.68050259f, -0.42486146f, 0.54340857f, -0.86715060f, -0.90198684f, 
    -0.56529444f, -0.33492070f, 0.00625511f, 0.36623341f, 0.30671105f, 0.15094657f, -0.15675242f, 0.02960674f, 
    -0.18616526f, 0.24458686f, -0.02668792f, 0.27592829f, 0.01217526f, 0.14109759f, 0.04909022f, 0.02939462f, 
    0.15430930f, 0.34340253f, 0.55588293f, 0.91472638f, 0.72143662f, -0.52254939f, -0.68813735f, -0.85407031f, 
    -0.49298027f, -0.07249646f, 0.05874331f, 0.73238200f, 0.29441887f, -0.07399761f, 0.33294231f, -0.25162256f, 
    0.37012511f, -0.02455543f, 0.13676396f, -0.02020013f, 0.26985085f, -0.29612100f, -0.00443495f, 0.41981757f, 
    0.11376242f, -0.02866149f, -0.11092176f, 0.31441289f, -0.65712559f, -0.74710572f, -0.42424637f, 0.63264513f, 
    0.13306552f, 0.34113592f, 0.74619603f, 0.71104312f, -0.25335827f, -0.11481126f, -0.22623038f, -0.21998896f, 
    0.43140110f, 0.25069493f, 0.03569979f, -0.27394247f, 0.45014361f, 0.53257143f, -0.00354552f, -0.29671091f, 
    -0.29961056f, -0.17768613f, -0.17215689f, 0.31976023f, 0.10288630f, 1.35420549f, 0.19475226f, -0.36921987f, 
    0.44305417f, -0.30746692f, 0.77847463f, 0.28069142f, 0.41345561f, -0.32227439f, 0.00197182f, -0.26108310f, 
    -0.14630397f, -0.43834403f, 0.10918331f, -0.08359227f, -0.52906942f, -0.28516066f, -0.11929446f, 0.06105994f, 
    -0.13041764f, 0.03003130f, 0.02371320f, -0.40646350f, 0.54787970f, 0.80769646f, 0.36509416f, 0.23455545f, 
    1.02440417f, -0.03994346f, -0.40778491f, 0.08103447f, -0.39396524f, 0.00360829f, 0.27230680f, -0.31546181f, 
    -0.47863981f, -0.20618775f, 0.22877182f, -0.12865774f, -0.54201251f, -0.29468051f, -0.10213082f, 0.16403264f, 
    -0.05597967f, 0.12286375f, 0.03824097f, -0.27539268f, 0.27728552f, 0.94401860f, 0.15063308f, 0.28861222f, 
    1.37174094f, 0.85370320f, -0.18870568f, 0.07785696f, 0.17126808f, 0.39428151f, 0.01523753f, -0.57285339f, 
    -0.35263115f, -0.09994424f, 0.02033996f, 0.08932899f, -0.11841249f, 0.11634735f, 0.04248758f, 0.24504355f, 
    0.32354355f, 0.30602345f, 0.09558416f, -0.22954351f, -0.10868450f, -0.06346150f, 0.73798037f, 0.77857912f, 
    0.61764455f, 0.77214020f, 0.36092845f, -1.08630788f, 0.39669564f, -0.63681471f, -0.32934913f, -0.22718479f, 
    0.02824580f, 0.22927807f, 0.08693312f, 0.41253662f, 0.12593910f, -0.36966431f, 0.10841594f, 0.57962501f, 
    -0.22702423f, -0.12862313f, 0.21962705f, 0.15768327f, 0.23946147f, 0.19175310f, 0.18924941f, 0.75761902f, 
    0.05186364f, -0.27146050f, 0.13737316f, -0.19596915f, -0.34050027f, 0.15751588f, -0.84452760f, 0.63057959f, 
    0.66656220f, 0.12580726f, -0.04405069f, -0.11575697f, 0.05071518f, -0.06984895f, -0.06931866f, 0.18831754f, 
    0.14809677f, 0.10974895f, 0.29480708f, -0.13662344f, 0.36631531f, 0.18942001f, -0.26626557f, -0.30705646f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.42938098f, 0.14880034f, -0.17952466f, 0.32395276f, 0.23238458f, 0.36983296f, 0.19105218f, 0.19061747f, 
    0.30492705f, 0.34110683f, -0.05886629f, 0.15995777f, -0.01145553f, -0.04174911f, 0.12498495f, 0.25265440f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.34506613f, -0.33328617f, 0.42465138f, -0.13567805f, -0.14728363f, 0.02877226f, -0.05698333f, 0.13636228f, 
    0.15385121f, -0.24380462f, 0.03026675f, -0.07238148f, 0.12869479f, 0.05851885f, 0.26592579f, 0.16076960f, 
    -0.12888490f, 0.01960588f, 0.09734327f, 0.08178312f, -0.07960737f, 0.18128797f, -0.03609344f, 0.01343244f, 
    0.27999634f, -0.05961809f, 0.19581942f, 0.03928649f, 0.07655691f, 0.13773753f, 0.05390221f, -0.05159763f, 
    -0.08199931f, 0.07917742f, 0.03178548f, 0.13770472f, -0.26179934f, 0.25555494f, 0.22555532f, 0.07073013f, 
    0.00946260f, 0.12016269f, -0.15578887f, 0.29812059f, 0.05299549f, 0.14051238f, -0.17220783f, 0.03706242f, 
    0.27266097f, 0.09195524f, -0.10398825f, -0.02696056f, -0.01524628f, -0.15184453f, 0.19014809f, -0.01315371f, 
    0.35906643f, 0.03731693f, -0.06754957f, -0.15265857f, 0.30171198f, 0.16596460f, 0.07432778f, -0.25817004f, 
    -0.05925544f, 0.08162311f, -0.20584697f, 0.01006992f, -0.14169236f, -0.12472063f, 0.05329589f, -0.05998304f, 
    -0.43932334f, -0.07647479f, -0.23945102f, -0.26612547f, -0.01825849f, 0.01820453f, -0.04455559f, -0.31697574f, 
    -0.02132170f, -0.06379545f, 0.07124791f, 0.22344922f, 0.12609227f, 0.07673819f, 0.07897103f, -0.08924948f, 
    0.08031967f, 0.10587848f, -0.06143895f, 0.08394226f, -0.11921177f, 0.01855976f, -0.03679509f, -0.04359394f, 
    -0.35831237f, -0.25799906f, -0.05486076f, -0.15984063f, 0.06337775f, -0.04663017f, 0.14430760f, -0.07859401f, 
    0.01845127f, 0.06346630f, 0.06265316f, 0.04133508f, -0.26628378f, -0.15165949f, -0.24596393f, -0.11180189f, 
    -0.23103154f, 0.10815895f, -0.01465428f, -0.03217431f, -0.06356174f, -0.06794507f, -0.18068165f, -0.06241084f, 
    0.18148220f, -0.11911079f, -0.16980869f, 0.32338923f, 0.02833208f, 0.03488382f, 0.00071999f, -0.07886061f, 
    -0.03489492f, 0.08167438f, 0.12784962f, 0.04169410f, -0.16737793f, 0.04047965f, 0.00582737f, 0.21626957f, 
    -0.12852368f, 0.00452843f, 0.10670604f, 0.21491863f, 0.15178628f, 0.16324866f, 0.30363196f, -0.09361839f, 
    0.53807366f, 0.11423905f, 0.31922188f, 0.19131365f, -0.13768393f, -0.24387074f, 0.20274398f, 0.18230404f, 
    -0.08998673f, -0.12094205f, 0.12715960f, -0.24201022f, 0.91376626f, 0.32209241f, -0.15954316f, 0.44682845f, 
    -0.05775392f, 0.25651601f, 0.07880164f, 0.06319419f, 0.04696422f, -0.00849830f, -0.14820425f, 0.00968689f, 
    0.61354333f, 0.26541263f, 0.21599615f, 0.19627726f, -0.17996305f, -0.11470476f, -0.10115895f, -0.22442801f, 
    0.15041746f, -0.11863197f, -0.10469519f, -0.14935604f, 0.35647368f, 0.09672955f, -0.30590725f, 0.03182709f, 
    -0.11583015f, -0.02905200f, 0.17052335f, -0.08839117f, -0.13498352f, 0.09909967f, 0.06410565f, -0.05826081f, 
    -0.04576688f, 0.20686014f, -0.23752803f, 0.21654128f, 0.05323112f, -0.11456224f, -0.10856058f, -0.23044494f, 
    0.10254800f, 0.06202940f, 0.00504958f, -0.13448003f, -0.10549235f, 0.39552170f, -0.12862222f, -0.18602507f, 
    0.05448223f, 0.01167876f, 0.04312130f, 0.00952351f, -0.09632418f, -0.01691235f, -0.08672510f, 0.13678010f, 
    -0.43679509f, 0.00504528f, 0.14309850f, -0.01216562f, -0.00810154f, 0.02773674f, 0.20117158f, -0.01030083f, 
    -0.09486923f, 0.00386810f, 0.15897609f, 0.13756640f, -0.53508657f, -0.46918765f, 0.01676851f, -0.21569240f, 
    0.00468256f, 0.08507883f, 0.10873064f, -0.13470420f, 0.08667172f, 0.14700516f, 0.09671630f, -0.02325158f, 
    0.42823845f, 0.02373946f, -0.10640363f, 0.40012589f, 0.14732683f, -0.12911256f, -0.09549120f, -0.05006799f, 
    -0.09183677f, -0.04810875f, 0.01608562f, 0.05839925f, -0.28240809f, 0.03656760f, -0.15330254f, 0.30829802f, 
    -0.06675024f, 0.09619045f, -0.00760919f, 0.01719751f, 0.12982768f, 0.09495202f, -0.00056742f, -0.26737934f, 
    0.21460687f, -0.09749602f, 0.57445854f, 0.65392083f, 0.03847045f, -0.06816966f, -0.06942876f, 0.31722286f, 
    -0.04217863f, 0.02816679f, 0.13879295f, 0.06028031f, -0.09867297f, 0.24890205f, 0.02507207f, 0.37711149f, 
    0.03101593f, 0.23436198f, 0.04705364f, -0.14001466f, 0.14390229f, 0.15426719f, 0.09323055f, 0.14101323f, 
    0.17112060f, 0.27985120f, 0.09321406f, 0.58491486f, -0.12136409f, -0.15463570f, -0.09883116f, 0.05112942f, 
    -0.03490226f, -0.19097382f, -0.05267749f, 0.15415750f, 0.30972889f, -0.07941075f, 0.17341249f, -0.12350101f, 
    -0.09500704f, 0.05140559f, -0.10769236f, -0.04631540f, 0.01481235f, -0.01190248f, -0.07076212f, -0.12646011f, 
    0.01990914f, 0.17215843f, -0.07385697f, 0.09896511f, -0.12339051f, 0.07957435f, -0.01542324f, -0.04550981f, 
    0.07387096f, -0.06792238f, 0.15059380f, 0.10255934f, 0.29117557f, -0.07639530f, 0.15956262f, -0.06321897f, 
    0.15026644f, 0.20863360f, -0.03500337f, 0.10586631f, -0.05143927f, 0.25633094f, -0.16352086f, 0.30371678f, 
    -0.13064043f, -0.06316079f, -0.14603524f, 0.02673371f, 0.00649987f, 0.23650476f, -0.06633495f, 0.02502566f, 
    0.01372818f, 0.02870576f, 0.16797227f, -0.05568149f, -0.08084958f, 0.14608648f, 0.41789696f, -0.45948040f, 
    0.05298923f, 0.02722172f, 0.19185267f, -0.01911242f, 0.05101027f, -0.01574941f, 0.14963838f, 0.00785543f, 
    -0.27795920f, -0.19764842f, 0.12190355f, -0.18571685f, 0.15596722f, -0.12768266f, -0.01584335f, 0.09380762f, 
    -0.10611629f, 0.17642969f, -0.07289229f, -0.10319333f, -0.37569064f, 0.30294660f, 0.03704529f, -0.11709686f, 
    -0.03349766f, 0.23211835f, -0.03668438f, 0.12773712f, -0.04652130f, -0.11386913f, -0.05461265f, 0.05167562f, 
    0.44638318f, -0.03912117f, -0.03470289f, 0.24653314f, 0.24760433f, -0.15825453f, -0.03111245f, 0.15281296f, 
    -0.03134659f, 0.02545502f, 0.12629540f, 0.08872465f, 0.47216091f, -0.46395263f, 0.14578952f, 0.14162096f, 
    -0.08166748f, 0.23034230f, 0.04609875f, -0.03389468f, 0.09436799f, 0.00064372f, 0.03874479f, 0.06652296f, 
    -0.70781636f, 0.36787361f, -0.13916805f, -0.31565869f, -0.08737458f, -0.15793785f, 0.01082402f, 0.03323317f, 
    -0.04432375f, 0.08938541f, -0.01603665f, -0.18166816f, 0.03256823f, 0.13031311f, -0.04165258f, -0.14721072f, 
    0.12639171f, 0.03899422f, 0.03600596f, 0.10343507f, -0.02748686f, -0.02634198f, -0.12794535f, 0.13131247f, 
    -0.09690064f, 0.28321081f, -0.09742218f, -0.03418497f, -0.17314272f, 0.11325940f, -0.06562445f, -0.12269846f, 
    0.09229468f, -0.01231372f, 0.07469102f, -0.03054633f, -0.26894501f, -0.58166993f, -0.05282224f, -0.25296840f, 
    -0.01749612f, 0.10884143f, -0.02920048f, 0.04141987f, 0.16010183f, 0.07977391f, -0.07486263f, 0.05178587f, 
    0.24690264f, 0.72470969f, 0.26821402f, 0.40309283f, -0.08702210f, 0.16962616f, -0.03082529f, 0.15734710f, 
    0.16044530f, 0.06626517f, -0.05592819f, -0.00389701f, 0.19259828f, -0.33395606f, -0.20438130f, -0.04468348f, 
    -0.16705309f, 0.01353729f, 0.13788660f, -0.04564540f, 0.03106919f, -0.06738976f, -0.06841777f, 0.03579730f, 
    0.24916719f, -0.25396222f, 0.05890172f, 0.48213539f, 0.08162928f, 0.10500250f, 0.16579789f, -0.10134713f, 
    0.04668637f, 0.03719554f, 0.02401189f, -0.02741491f, 0.28165531f, -0.30750063f, -0.11661276f, 0.22406402f, 
    0.07161389f, -0.02912775f, -0.12642798f, 0.12903464f, 0.07368985f, -0.18523899f, 0.18781193f, 0.38303888f, 
    0.20371723f, -0.17987955f, 0.06817756f, -0.04014236f, 0.04713551f, 0.00730467f, -0.19115770f, -0.17904133f, 
    0.00957222f, 0.21376729f, -0.12762454f, 0.08897477f, -0.54085159f, -0.09140503f, -0.06231497f, -0.13168216f, 
    0.01368051f, -0.03027829f, -0.16687329f, -0.04909774f, -0.04268698f, -0.04289100f, -0.05350274f, -0.02526538f, 
    0.36805877f, -0.29045606f, -0.03303731f, 0.32061225f, -0.03142142f, 0.01114576f, 0.14001353f, 0.00050850f, 
    -0.03453604f, -0.03197598f, -0.07911978f, 0.08702362f, 0.00292988f, -0.06897134f, -0.10818512f, -0.30804273f, 
    -0.02580898f, -0.10982331f, -0.11711510f, 0.05158625f, 0.09165090f, 0.04041772f, 0.07216364f, 0.22636634f, 
    0.11879773f, -0.00318318f, 0.08588402f, 0.07490525f, -0.15087998f, -0.03811873f, -0.11626209f, 0.07469073f, 
    0.00084581f, 0.08026678f, 0.13164958f, 0.02439022f, 0.26371166f, -0.12924278f, 0.00684092f, 0.04602523f, 
    0.15994890f, 0.07375657f, 0.11362605f, -0.02348644f, -0.02057727f, -0.10463614f, 0.13458854f, 0.13396333f, 
    -0.35892192f, 0.00563239f, 0.04428305f, 0.09145358f, 0.17215773f, 0.01291642f, -0.07476337f, -0.00770670f, 
    0.10215176f, 0.23373367f, 0.16132936f, 0.32439873f, -0.08811091f, -0.02231553f, 0.31690398f, 0.13079172f, 
    0.25883409f, 0.08800992f, -0.07161283f, -0.11539444f, 0.11263237f, -0.03068101f, 0.04750157f, 0.13985164f, 
    -0.09546877f, 0.13086900f, 0.03888150f, 0.05156540f, 0.10003718f, 0.15675320f, 0.08801945f, -0.04076580f, 
    0.27332574f, -0.18528029f, 0.04876648f, 0.01515103f, -0.43473989f, -0.38943788f, 0.05561257f, 0.01989283f, 
    0.16665669f, 0.06369945f, 0.07733726f, -0.14073281f, 0.04411025f, 0.05570372f, 0.11961289f, -0.06634527f, 
    -0.01304728f, -0.55652326f, -0.05139651f, -0.02235018f, 0.27006990f, -0.10916277f, -0.32753775f, 0.07173397f, 
    0.04846271f, -0.09609984f, 0.07983247f, -0.04556026f, 0.62795949f, 0.18190831f, 0.02042982f, -0.05950585f, 
    -0.03885238f, 0.07763735f, 0.25718474f, -0.15919316f, 0.08769982f, -0.05888377f, 0.00124647f, 0.02680229f, 
    -0.38943484f, -0.20404157f, 0.31027865f, 0.11094313f, 0.15227900f, 0.04159443f, 0.04132964f, 0.24642156f, 
    -0.00322900f, 0.08892888f, -0.18423419f, -0.21061128f, 0.00529453f, -0.45558226f, -0.04620367f, 0.09504159f, 
    0.06860449f, -0.08506329f, 0.11270592f, 0.04703822f, -0.01779358f, -0.00301252f, 0.02523137f, 0.10551646f, 
    -0.59599584f, 0.27690604f, 0.06645443f, -0.19850995f, -0.01668240f, -0.05492408f, 0.05636623f, -0.19392885f, 
    -0.00925909f, -0.13731934f, 0.22260584f, 0.08897699f, 0.08939232f, 0.23837188f, 0.02360569f, -0.00842644f, 
    0.08183511f, -0.00453663f, 0.01266349f, -0.10230156f, -0.04616429f, -0.16212390f, 0.07316502f, 0.19224320f, 
    0.25164229f, 0.11825224f, 0.14578272f, 0.03761111f, 0.11361678f, -0.11806032f, -0.01194365f, -0.23039466f, 
    -0.08886092f, -0.04894808f, -0.08760500f, 0.01395020f, 0.54164743f, 0.15524574f, 0.15271844f, -0.06649170f, 
    0.25363752f, -0.10453116f, -0.24617735f, -0.06396705f, -0.10955659f, -0.08351950f, -0.28407329f, 0.02147649f, 
    -0.00220412f, 0.10915481f, 0.13062069f, 0.18257225f, 0.11614231f, 0.02676531f, -0.07010028f, -0.03361033f, 
    -0.13672183f, -0.00712813f, 0.01614061f, 0.26386142f, 0.04793520f, 0.15872625f, 0.21210456f, 0.02571039f, 
    0.12607110f, -0.14435396f, -0.13975272f, 0.05252617f, 0.07413576f, 0.19044939f, 0.24692459f, 0.14426020f, 
    0.16622107f, -0.04075404f, -0.01075116f, 0.17843992f, -0.03639939f, 0.16243571f, 0.14708595f, 0.11485764f, 
    0.14749965f, -0.09502406f, 0.22492707f, 0.04379287f, 0.04658787f, -0.23177898f, 0.02537773f, -0.02312336f, 
    0.12614459f, -0.16225800f, 0.04123798f, 0.11335014f, -0.11695562f, -0.07843807f, 0.06596798f, -0.14068809f, 
    0.24927965f, 0.06862043f, -0.07417316f, 0.15604503f, 0.04931074f, -0.00656001f, 0.17245932f, 0.15162247f, 
    0.04621782f, 0.03554697f, -0.12725450f, 0.03320170f, -0.11432387f, 0.30882674f, -0.10485869f, -0.46039224f, 
    0.00028432f, 0.04469728f, 0.01996467f, 0.18475662f, 0.02081969f, -0.06975998f, 0.19728681f, -0.07010586f, 
    -0.24655303f, -0.52626920f, -0.43237069f, 0.09134238f, -0.07916831f, -0.00260271f, -0.09668352f, 0.01997744f, 
    0.05430078f, 0.10897946f, 0.00301231f, 0.01880065f, 0.05048652f, 0.24540128f, -0.28687629f, 0.09705356f, 
    -0.02839715f, -0.11792157f, 0.23359531f, 0.17661782f, -0.05492608f, 0.04708837f, -0.08649271f, 0.06728730f, 
    -0.32543668f, -0.29459566f, 0.06982018f, -0.10896657f, -0.22034813f, -0.06752182f, 0.26874146f, 0.13979773f, 
    0.16125078f, 0.16658629f, 0.06035493f, 0.06645860f, -0.10171796f, 0.02007176f, 0.07837076f, 0.30051517f, 
    0.12324593f, 0.06177405f, -0.02143139f, -0.16134584f, 0.16212440f, 0.03814026f, -0.00570741f, -0.13521326f, 
    -0.04846084f, -0.09506885f, -0.23222326f, -0.07909741f, -0.07630993f, 0.06548307f, 0.05282895f, -0.02705640f, 
    -0.08436250f, 0.06108198f, 0.13427818f, 0.04392306f, -0.30561319f, -0.31432423f, -0.00785179f, -0.12897852f, 
    0.07281752f, -0.04684057f, 0.04770238f, 0.10298854f, 0.09345194f, 0.16553666f, 0.10878474f, -0.07020791f, 
    -0.14161463f, -0.29634646f, 0.05680264f, -0.08884703f, 0.16384520f, 0.21144786f, 0.06192700f, 0.01220144f, 
    0.02403082f, 0.09040313f, 0.26048356f, 0.00575465f, -0.22197160f, 0.30735815f, 0.47557360f, -0.20824936f, 
    0.04274658f, 0.00602691f, 0.05075791f, -0.25237495f, 0.00027394f, 0.11931674f, -0.07486375f, -0.00229622f, 
    -0.41417068f, -0.41927475f, 0.03339056f, 0.02637064f, 0.05060204f, 0.04131842f, 0.09386015f, 0.14687996f, 
    0.12492482f, 0.02137181f, -0.06600020f, -0.08660623f, 0.04667526f, 0.16347611f, 0.09795573f, 0.02111728f, 
    0.12315794f, 0.22189584f, -0.07013179f, 0.10290293f, -0.00635545f, -0.13430227f, 0.29450300f, 0.21993001f, 
    0.08708680f, 0.04541827f, -0.06216254f, -0.18526608f, 0.08850011f, -0.13884674f, -0.01961594f, -0.01508377f, 
    0.25034875f, 0.00092964f, -0.11110301f, 0.37216094f, 0.19739780f, 0.13576406f, 0.05509758f, -0.21153100f, 
    -0.06158738f, 0.04293256f, 0.13658926f, 0.06236219f, -0.10937335f, 0.17985143f, -0.02438279f, 0.03267419f, 
    -0.42103451f, 0.24306852f, 0.55570334f, -0.08024871f, -0.13463901f, 0.17934294f, -0.04296565f, 0.10464261f, 
    0.23081601f, 0.02435638f, 0.07540247f, 0.15178068f, -0.01995789f, -0.01189773f, 0.16587433f, 0.06300253f, 
    0.04115133f, 0.06843878f, 0.33685151f, 0.00907146f, -0.05138152f, 0.03380139f, -0.00926232f, 0.03107035f, 
    -0.00358280f, 0.00857041f, -0.04815422f, -0.07449408f, 0.05567598f, 0.00154297f, -0.01695151f, 0.01186225f, 
    -0.07028904f, -0.05235907f, -0.05497319f, 0.02778480f, 0.02461807f, -0.03444067f, -0.06290887f, -0.02161890f, 
    0.03944406f, 0.02673972f, -0.04402397f, -0.07497047f, -0.03802151f, -0.03371533f, 0.05928955f, 0.01429793f, 
    0.02795325f, 0.03602823f, -0.05274191f, -0.07975000f, -0.04364214f, 0.01760230f, 0.03106048f, 0.03184121f, 
    0.02411634f, 0.03153978f, -0.00922971f, -0.03934244f, -0.02793487f, 0.04073486f, -0.01497175f, 0.03848856f, 
    0.03245128f, -0.04487336f, -0.00955396f, -0.03127274f, -0.02972036f, -0.01533454f, 0.00970670f, 0.03584667f, 
    -0.03899005f, 0.01942619f, 0.03922920f, 0.00375885f, -0.02028351f, 0.02671509f, 0.00373637f, 0.02953324f, 
    -0.07485100f, 0.02934531f, 0.00422174f, -0.01043920f, 0.06709929f, -0.02827578f, 0.01222603f, -0.02903925f, 
    -0.02679078f, -0.01330900f, -0.05516009f, -0.03716620f, 0.00580354f, -0.05320455f, 0.02010589f, 0.03791924f, 
    -0.07897095f, -0.07633105f, -0.03038403f, -0.04471553f, -0.06150784f, 0.01059381f, -0.03540875f, -0.06608061f, 
    -0.02781446f, 0.02507911f, 0.05019312f, 0.01375472f, 0.03278585f, 0.03623239f, -0.04854746f, -0.03823376f, 
    0.03781749f, -0.05855854f, 0.03812400f, 0.00368534f, -0.06902741f, 0.02348709f, -0.01370265f, 0.01833905f, 
    0.05481099f, 0.02681113f, 0.07063466f, -0.06025179f, -0.06931962f, 0.02387102f, -0.07163960f, -0.01440989f, 
    -0.00092593f, -0.04824456f, -0.02222784f, 0.04248485f, -0.06487335f, -0.01079946f, 0.03463777f, -0.05454052f, 
    0.01963231f, -0.07860316f, -0.02161401f, -0.00502475f, -0.02994222f, -0.02674591f, -0.04570581f, 0.01771406f, 
    0.04803653f, -0.05096733f, 0.00713935f, -0.00543243f, -0.05065405f, 0.03151746f, -0.05726608f, -0.06723253f, 
    0.06060560f, 0.05798566f, 0.04462579f, 0.03452039f, 0.06402255f, 0.03109407f, 0.03010135f, 0.03019974f, 
    -0.01338527f, -0.06022755f, -0.04649454f, -0.00241869f, -0.05174449f, -0.05830671f, -0.07387441f, 0.00600262f, 
    0.01240113f, -0.03894041f, -0.03411245f, -0.06348997f, -0.01584592f, -0.01343185f, -0.00111209f, 0.05876503f, 
    0.05431091f, 0.06296573f, -0.03410265f, -0.06374919f, 0.01923397f, 0.02839105f, -0.01557079f, -0.03182631f, 
    -0.02129613f, -0.03505222f, 0.03862569f, -0.02472548f, -0.04271783f, -0.04047091f, 0.02802720f, -0.06342676f, 
    0.00237808f, -0.03291433f, -0.05638744f, 0.00363470f, -0.00247110f, 0.05257894f, -0.02943283f, 0.00367134f, 
    0.04078427f, -0.07270503f, 0.04628308f, 0.04524273f, 0.02124484f, -0.04826024f, 0.03512015f, 0.02378606f, 
    -0.03099758f, -0.06027382f, 0.04517430f, 0.03677547f, 0.01216591f, -0.05147564f, 0.04956383f, 0.04351845f, 
    0.08668570f, -0.05308877f, -0.03713557f, -0.30226263f, -0.05827979f, -0.04239160f, -0.09531859f, 0.12151552f, 
    -0.08340022f, 0.03206698f, -0.05441604f, -0.09091963f, 0.32004455f, -0.60113490f, 0.42260441f, 0.28027064f, 
    -0.02567024f, 0.10810913f, 0.09198067f, -0.11981222f, 0.00888049f, 0.03951261f, 0.09977293f, 0.14466341f, 
    -0.11139143f, -0.37329853f, -0.01039487f, -0.15308011f, 0.04928289f, 0.14147824f, -0.20227002f, 0.06297392f, 
    -0.08234277f, 0.05256438f, 0.07389741f, 0.09161203f, 0.21104968f, 0.15526369f, 0.00775812f, -0.14430608f, 
    0.02635935f, 0.24259983f, -0.00682362f, 0.11061552f, -0.02081278f, 0.09189964f, -0.10221489f, -0.03270781f, 
    -0.19187678f, -0.09611040f, -0.02920595f, 0.17810485f, -0.05959918f, 0.24429038f, -0.16073588f, -0.14965351f, 
    0.17720002f, -0.08030639f, -0.18124399f, -0.09770224f, 0.54900950f, 0.31651807f, -0.00535160f, 0.19083288f, 
    -0.12595189f, -0.09984840f, -0.05750880f, 0.06959561f, -0.04928270f, 0.01836018f, 0.10365045f, -0.04666610f, 
    -0.16882981f, -0.13767970f, -0.32290104f, 0.02397733f, 0.06844610f, 0.11374258f, -0.02589740f, -0.14637679f, 
    -0.12649979f, 0.07080977f, 0.04388404f, -0.01060874f, 0.19802214f, -0.25422454f, -0.28131613f, -0.08485083f, 
    -0.05470001f, -0.10045920f, -0.07339571f, -0.19198985f, 0.09366572f, 0.14129966f, -0.15764531f, -0.13829772f, 
    0.19852801f, -0.26731533f, -0.25870162f, 0.24788827f, 0.17130958f, -0.16804583f, 0.08149885f, -0.09046784f, 
    0.07318392f, 0.07242773f, -0.13163416f, -0.06554462f, 0.43730485f, 0.46358383f, -0.02043352f, -0.15177806f, 
    0.06444807f, -0.02821102f, 0.15291089f, 0.08267764f, -0.00135545f, -0.10006545f, 0.01646619f, 0.20018421f, 
    -0.05853019f, 0.03220259f, -0.11728001f, -0.24066599f, 0.11029878f, -0.10529090f, -0.09348977f, -0.07156595f, 
    -0.21454865f, -0.02067968f, 0.00181228f, -0.11381099f, -0.17510228f, 0.39054024f, 0.01544374f, 0.21071154f, 
    -0.09715621f, 0.01437215f, 0.13295417f, 0.14908272f, 0.07099087f, -0.12572919f, 0.19712463f, -0.18653636f, 
    0.31786862f, 0.15597664f, 0.15983111f, 0.07567478f, -0.08800146f, -0.01214977f, 0.22580180f, 0.11539266f, 
    0.00471315f, -0.04897761f, -0.02413528f, 0.09501787f, -0.07165030f, 0.08062220f, 0.09040441f, -0.23795663f, 
    -0.08462798f, 0.04744398f, -0.01573603f, 0.01899264f, -0.07120610f, -0.11806144f, -0.05490896f, 0.02606962f, 
    0.93753034f, 0.46946958f, -0.29161519f, -0.23983163f, 0.14261138f, -0.11055493f, 0.10548398f, 0.11353393f, 
    -0.20360447f, -0.13392158f, 0.00931563f, 0.10615373f, 0.43961617f, -0.05773631f, -0.00769314f, -0.16640469f, 
    0.11628035f, 0.08858802f, 0.09751165f, 0.03095395f, -0.23707478f, 0.12301360f, 0.14268322f, -0.04424037f, 
    -0.19364692f, -0.02052170f, 0.22419189f, 0.12535189f, 0.06669409f, 0.18207325f, 0.20818391f, 0.14760928f, 
    -0.00196621f, 0.30371395f, 0.17205939f, 0.31543154f, -0.47734791f, 0.19896933f, 0.13334268f, -0.09337462f, 
    0.07792377f, -0.07461687f, -0.17813510f, -0.03399008f, 0.10745317f, -0.01004398f, 0.08544739f, 0.04842551f, 
    0.50250769f, 0.10526753f, 0.02890992f, 0.12305693f, 0.19049501f, 0.22030243f, -0.22172755f, -0.09989729f, 
    0.12003766f, 0.05670820f, -0.08687256f, -0.08762063f, 0.37164474f, 0.21107389f, -0.04735252f, 0.16604465f, 
    0.19548208f, 0.07434276f, 0.11113929f, -0.11059373f, -0.00429636f, -0.00429127f, 0.07318565f, -0.06302038f, 
    -0.26932323f, -0.48021775f, 0.21074532f, -0.25465387f, 0.14338078f, 0.13539517f, -0.02203030f, 0.25085071f, 
    0.09421203f, -0.06352820f, 0.07372373f, -0.03776943f, 0.65586042f, 0.25076684f, 0.16856320f, -0.10948791f, 
    0.00873262f, -0.06893831f, 0.17720215f, -0.07423142f, 0.02054881f, 0.08329849f, 0.05565949f, 0.31773201f, 
    -0.41430342f, -0.30625385f, -0.00961468f, -0.33475941f, 0.12876365f, -0.05565366f, 0.09075969f, -0.16054463f, 
    -0.08538075f, -0.11799682f, -0.09165455f, -0.03370432f, 0.07805027f, -0.27547798f, 0.02928360f, -0.25072125f, 
    0.06656656f, -0.01429256f, -0.03356062f, 0.04754112f, -0.01081770f, -0.04635917f, -0.03809094f, 0.00724700f, 
    -0.51406187f, 0.11443197f, 0.18017623f, -0.70332789f, -0.03907639f, -0.03514200f, 0.02519305f, -0.00750099f, 
    0.09565892f, 0.09044078f, 0.22775604f, -0.06853933f, -0.03766469f, 0.44626161f, 0.22316650f, -0.06166430f, 
    0.21713847f, -0.15690435f, 0.01838334f, -0.01311925f, -0.01614209f, -0.05336667f, 0.10825393f, 0.10526922f, 
    0.25063252f, -0.03463736f, 0.15923645f, -0.16331138f, 0.24595012f, -0.06545240f, 0.19422874f, 0.03747923f, 
    -0.13978620f, 0.03384308f, -0.21386738f, 0.01440542f, 0.57899785f, 0.17490166f, 0.01995090f, 0.00460596f, 
    0.09195206f, -0.26778972f, -0.13386357f, -0.27250475f, 0.04203631f, -0.18199590f, -0.05397037f, -0.11225980f, 
    -0.03637147f, 0.06953743f, 0.08289288f, -0.24593697f, -0.02647743f, -0.11683495f, -0.08815216f, 0.05770718f, 
    -0.24631689f, -0.01142626f, -0.15686578f, 0.17333016f, 0.01932079f, -0.11767341f, -0.18575092f, 0.50092161f, 
    -0.03588654f, -0.16831441f, -0.18852524f, 0.00541511f, -0.04377109f, 0.20421030f, 0.01759504f, 0.01771590f, 
    0.22456737f, 0.00317250f, -0.16246629f, 0.10750622f, -0.07625268f, 0.10123502f, 0.06283657f, 0.00348952f, 
    0.00318136f, -0.19019265f, 0.32325968f, 0.13195068f, 0.17016819f, -0.27340093f, -0.06954180f, 0.15676661f, 
    0.05192107f, -0.17847826f, -0.01000040f, 0.08175956f, 0.06794336f, 0.21924600f, 0.10912035f, 0.00102465f, 
    -0.09639797f, 0.18787588f, -0.09964540f, -0.43227646f, -0.14604512f, -0.13266179f, -0.03848137f, 0.02800705f, 
    0.02752788f, -0.00377472f, -0.21712169f, -0.03418236f, 0.34642151f, -0.07471706f, 0.05343959f, 0.06204908f, 
    0.03914898f, 0.13588920f, -0.00060451f, 0.01334038f, 0.05720866f, 0.00307134f, 0.01113999f, 0.00618194f, 
    -0.11387966f, -0.71499604f, -0.25613213f, 0.14104919f, -0.20924886f, 0.05257363f, -0.06523531f, 0.07612660f, 
    -0.05037770f, 0.13866809f, 0.12816684f, 0.12211245f, -0.04193885f, 0.07354901f, 0.12482702f, 0.08062788f, 
    -0.13707274f, 0.02580513f, 0.10150464f, 0.14963524f, -0.08145059f, 0.07423701f, 0.08852349f, -0.01865816f, 
    -0.31903100f, 0.01153997f, -0.06228749f, -0.17470402f, -0.14498073f, -0.10851627f, 0.11553803f, 0.01944570f, 
    0.10337628f, 0.06865729f, 0.01426790f, 0.03316944f, 0.30470884f, 0.41387376f, -0.19560930f, 0.28524038f, 
    -0.06542702f, 0.13112931f, -0.24796939f, -0.17264770f, -0.06224119f, -0.05193239f, 0.07265472f, -0.03710458f, 
    0.01455547f, -0.21710773f, -0.48314741f, -0.33829391f, 0.04466223f, 0.08820441f, -0.13777076f, 0.02638943f, 
    0.06334122f, 0.19648872f, 0.15990791f, 0.10167687f, -0.24413371f, 0.20415214f, -0.06025196f, 0.15723601f, 
    0.08492891f, -0.07899816f, -0.03158066f, -0.04960822f, -0.08115921f, 0.06973562f, 0.03513250f, -0.04612604f, 
    0.08838099f, -0.20759596f, -0.51649708f, 0.19489227f, 0.18980111f, -0.09752452f, -0.02860532f, 0.03675252f, 
    0.03637104f, 0.09413781f, 0.15105453f, -0.06436213f, -0.14062417f, 0.03248440f, 0.18855277f, -0.40623233f, 
    0.11538792f, 0.15011998f, 0.23816355f, -0.08024337f, 0.00200909f, 0.09944742f, -0.07213372f, -0.06312853f, 
    -0.47471550f, -0.03640696f, -0.12553605f, 0.22408773f, -0.06408828f, 0.03041634f, -0.04432817f, 0.28771177f, 
    -0.07837866f, 0.03208965f, -0.03329189f, -0.09112946f, 0.18022856f, 0.28889263f, 0.03867279f, -0.04799375f, 
    0.04128730f, 0.14513697f, 0.00434223f, 0.18464385f, 0.04754172f, 0.04194188f, 0.33357978f, 0.08242957f, 
    0.15493438f, 0.19141196f, -0.01976351f, 0.26088580f, 0.27677986f, 0.00787375f, 0.02891311f, -0.04162805f, 
    0.20984176f, 0.08234353f, 0.06791002f, 0.02404705f, 0.10522773f, 0.11100359f, 0.13100509f, -0.14635804f, 
    0.03405979f, 0.05357605f, 0.08532187f, 0.10131165f, 0.03410854f, -0.05895104f, -0.03630362f, -0.07042198f, 
    0.36852318f, 0.18536776f, 0.07395001f, -0.04921988f, 0.21892026f, 0.12542541f, 0.05392463f, 0.00530271f, 
    0.09577391f, 0.05321255f, -0.04164862f, 0.03889786f, 0.13494726f, 0.15914978f, -0.01303456f, 0.01920802f, 
    -0.04272744f, 0.17050053f, 0.09546126f, -0.02839820f, -0.03085013f, -0.06479587f, 0.03849291f, -0.10518598f, 
    0.17496090f, 0.00015527f, -0.03025458f, -0.30921680f, 0.09885123f, 0.00415225f, 0.14052476f, 0.20383804f, 
    -0.09162519f, -0.17221837f, -0.03833392f, -0.04217540f, 0.09796453f, -0.13538732f, -0.18464808f, 0.06066341f, 
    -0.07441299f, -0.18406726f, -0.01308427f, 0.22783931f, 0.08492804f, -0.09727623f, -0.09983595f, -0.04527289f, 
    0.23833884f, -0.33314642f, -0.07463842f, 0.03123643f, 0.01800229f, -0.00747817f, -0.00729250f, 0.05821429f, 
    -0.13887218f, 0.03705717f, -0.05402242f, 0.12409534f, 0.10393114f, -0.09788008f, -0.02971332f, 0.04594800f, 
    -0.17494598f, 0.06296264f, -0.11649282f, 0.24606590f, 0.09682891f, 0.13071807f, 0.07195031f, 0.06973712f, 
    -0.04805204f, -0.13414964f, 0.15569231f, -0.27293923f, -0.43904689f, 0.08136261f, 0.19301291f, -0.08585445f, 
    0.02922207f, -0.08142161f, 0.10175627f, 0.03342960f, -0.09915347f, 0.15440680f, -0.27341321f, 0.32810405f, 
    0.08380129f, -0.09818973f, -0.09517652f, 0.08793806f, 0.10053422f, 0.15124103f, 0.05489242f, 0.06256904f, 
    -0.03215707f, 0.15423645f, -0.09198178f, -0.16360447f, -0.02780964f, 0.14973378f, 0.09085955f, -0.02406279f, 
    0.15301771f, 0.02002096f, 0.19885512f, 0.21640815f, 0.20166816f, -0.19728956f, -0.16394971f, -0.46290651f, 
    -0.10116803f, 0.12731075f, 0.01393268f, -0.01284189f, -0.00404936f, 0.13804686f, 0.05435736f, 0.02840611f, 
    0.37509954f, -0.33988932f, 0.06797125f, -0.02333630f, 0.04874885f, 0.28497660f, 0.09003340f, -0.09882410f, 
    0.17411570f, -0.11896821f, -0.20808759f, 0.09218400f, -0.01362734f, 0.16275406f, 0.20274112f, -0.05114759f, 
    0.15315336f, -0.15934330f, 0.12887472f, 0.03318604f, 0.11509607f, 0.10511292f, -0.06037483f, 0.07920386f, 
    0.11469320f, -0.28194758f, -0.10923692f, -0.24000159f, -0.08437543f, 0.03142559f, -0.01230799f, 0.10141113f, 
    0.04324399f, 0.15361696f, 0.01845638f, 0.06219245f, -0.50773960f, -0.12210739f, -0.07809151f, 0.42044297f, 
    -0.10616420f, 0.07003830f, 0.13295093f, 0.02502254f, 0.05819533f, -0.11147543f, 0.18242900f, -0.04427949f, 
    0.23124944f, 0.20318447f, 0.21791667f, -0.22310126f, -0.26129809f, -0.00998852f, 0.07740877f, 0.21584579f, 
    0.35133043f, -0.05139790f, -0.09201954f, 0.02733354f, 0.05168163f, -0.16546527f, -0.10478854f, 0.24945648f, 
    -0.18591310f, -0.05324851f, -0.04236770f, 0.20368548f, 0.02142857f, -0.07573578f, -0.22497840f, -0.03171794f, 
    -0.00288180f, 0.37622198f, -0.00694977f, 0.11124939f, 0.01039681f, -0.09848095f, -0.04002722f, 0.15443212f, 
    0.01124751f, 0.02840013f, -0.12519702f, -0.05797964f, 0.00053049f, -0.10881278f, 0.25933096f, 0.25823897f, 
    0.11733700f, 0.16105767f, 0.16509776f, 0.09814376f, 0.10493872f, 0.25553373f, 0.09297358f, 0.17713842f, 
    0.11366002f, 0.23884289f, 0.27394691f, 0.32268798f, -0.03071678f, 0.11806197f, -0.01213170f, 0.15416504f, 
    0.16139776f, 0.04522108f, 0.03124602f, -0.06696032f, -0.18475206f, 0.29942319f, 0.06667294f, 0.02711348f, 
    -0.22422142f, 0.06251901f, 0.11820916f, 0.13963997f, -0.12376265f, 0.04397543f, 0.06261972f, 0.09953015f, 
    -0.45604426f, 0.58820647f, 0.03152941f, -0.13198757f, 0.16544573f, 0.12546940f, 0.16819827f, -0.15996140f, 
    0.04469690f, 0.02717752f, -0.00743787f, 0.00955339f, -0.20081080f, 0.36269602f, 0.09359685f, 0.09687234f, 
    0.43461525f, 0.15243922f, 0.04876173f, -0.03788351f, 0.02286748f, 0.05927465f, -0.02093576f, 0.02905503f, 
    0.38141876f, 0.37211832f, 0.17720479f, -0.12170188f, 0.17410396f, -0.07040444f, 0.25924963f, 0.29681319f, 
    0.21583191f, 0.07609593f, -0.05647916f, 0.00540997f, -0.21687885f, -0.20200069f, -0.25657982f, -0.35523403f, 
    0.00214565f, -0.00832588f, -0.16607937f, -0.04147508f, -0.00230550f, 0.13897245f, -0.07906329f, 0.03811468f, 
    -0.17394918f, 0.32580462f, 0.27159923f, 0.19247840f, 0.19278379f, -0.15340082f, -0.03956711f, -0.14127807f, 
    0.00254861f, -0.03954013f, 0.05023358f, 0.06734638f, 0.10450447f, 0.26960665f, -0.18224980f, -0.13615975f, 
    0.03329447f, 0.26174489f, 0.02529945f, 0.05990450f, 0.06608749f, -0.05565937f, -0.01083043f, 0.08101128f, 
    0.35428497f, 0.13015267f, 0.25407395f, 0.21722974f, -0.23259956f, 0.01530050f, 0.01095102f, 0.04990455f, 
    -0.02934290f, 0.16335844f, 0.13417970f, 0.02314182f, -0.08431406f, -0.51751429f, -0.11761902f, 0.20530042f, 
    -0.09945787f, -0.20196262f, -0.13262956f, -0.01100798f, 0.09401585f, 0.00163911f, 0.02355259f, -0.08186213f, 
    0.35627499f, -0.20353608f, -0.12457230f, -0.24033433f, 0.10012133f, -0.04624595f, -0.03537491f, -0.22457893f, 
    0.21298291f, 0.16184661f, -0.06174198f, 0.11528621f, 0.00334421f, -0.36646929f, 0.00515864f, 0.11155455f, 
    -0.10151755f, -0.13311352f, 0.05121335f, -0.07140632f, 0.17034866f, -0.01803690f, 0.06745154f, 0.01325662f, 
    0.27989519f, -0.26893520f, -0.03385029f, 0.11445969f, -0.29172209f, -0.02264483f, 0.01553456f, 0.20051670f, 
    -0.28127903f, -0.06775306f, 0.04297791f, -0.10304494f, 0.79262680f, -0.02701756f, 0.09035363f, 0.42527372f, 
    -0.29021502f, 0.04568598f, 0.14352888f, -0.04734102f, 0.02139793f, 0.16416356f, 0.14251122f, -0.08258036f, 
    -0.07558742f, -0.44423831f, 0.05956369f, 0.18534452f, -0.27048245f, -0.12707710f, -0.13544236f, -0.04838721f, 
    0.00274536f, -0.16671987f, 0.05378224f, -0.01687911f, 0.16909188f, 0.14630325f, -0.46940330f, 0.18345456f, 
    -0.03649515f, -0.20917077f, -0.03677528f, -0.02224283f, 0.06007229f, -0.01948722f, 0.04172387f, -0.06228019f, 
    0.00836778f, 0.03218670f, -0.00131770f, -0.04226246f, 0.00967943f, 0.05968121f, 0.01302000f, 0.04184166f, 
    -0.04589065f, -0.02915128f, 0.04706449f, -0.04883036f, -0.02076346f, 0.05528898f, -0.00922125f, -0.07826313f, 
    -0.01425058f, -0.04894785f, -0.04484607f, -0.02576997f, 0.03827057f, 0.04010450f, -0.06948034f, -0.06396297f, 
    -0.03750652f, -0.07925791f, 0.04820951f, 0.04641387f, -0.06578013f, -0.03163150f, -0.03261828f, -0.00332974f, 
    -0.02807210f, 0.04481631f, -0.04964488f, -0.05910340f, 0.07274669f, -0.02920439f, -0.03266013f, 0.04142253f, 
    -0.04873041f, -0.01733193f, -0.03358885f, 0.04662456f, -0.06681586f, 0.00106326f, -0.03300074f, -0.07576646f, 
    -0.05847059f, 0.02423768f, -0.04092829f, 0.01623581f, 0.05812395f, 0.05685544f, 0.00768171f, -0.03993173f, 
    -0.03123577f, -0.02109192f, 0.06163796f, 0.04573107f, -0.00520466f, 0.02728097f, 0.02256591f, -0.07393545f, 
    0.05567518f, 0.01377926f, 0.04002325f, 0.00792683f, -0.07888854f, -0.00351636f, -0.04447290f, 0.01100773f, 
    -0.06907518f, 0.02067245f, -0.02073255f, 0.00348784f, 0.01827548f, -0.04489582f, 0.04715316f, -0.00525840f, 
    0.00360379f, -0.00597308f, 0.05778177f, -0.00908880f, 0.01405044f, 0.02163445f, -0.05784049f, 0.01209837f, 
    -0.06869069f, 0.00910220f, 0.02848843f, 0.00128156f, 0.00158168f, -0.05402964f, -0.04069681f, -0.05382787f, 
    -0.03339573f, -0.04621709f, -0.03672982f, -0.01449390f, -0.02081266f, -0.04643926f, -0.03822945f, -0.01945080f, 
    -0.01165273f, -0.01567398f, 0.00726428f, 0.00096992f, -0.05920592f, -0.02151046f, -0.07654130f, -0.04504325f, 
    -0.05825030f, -0.04060289f, -0.07918674f, 0.01766427f, -0.07460137f, -0.05451858f, 0.02545271f, 0.00817216f, 
    -0.04245197f, -0.02106980f, -0.03060175f, 0.03371646f, 0.04350222f, 0.01304842f, -0.03288656f, 0.05560042f, 
    0.00175470f, 0.01697158f, -0.03177630f, -0.04139449f, 0.01454752f, -0.03590341f, -0.01156253f, 0.04412463f, 
    0.01691182f, 0.01089852f, -0.07015517f, 0.05271912f, 0.05979437f, 0.05202383f, -0.06043506f, 0.03162678f, 
    0.01227098f, 0.02183740f, -0.06913496f, -0.07826896f, -0.05523808f, -0.02834757f, -0.06867950f, -0.06352281f, 
    0.02261960f, 0.02381634f, -0.04986282f, -0.01410394f, -0.07987435f, 0.04914757f, -0.03769653f, 0.05276643f, 
    -0.06954179f, 0.01871221f, -0.01013084f, 0.06148206f, -0.04429335f, -0.07359464f, -0.03616599f, -0.04786858f, 
    0.02175182f, -0.06586552f, -0.05562313f, -0.03086812f, 0.01370314f, 0.01262606f, 0.03476956f, 0.00497698f, 
    0.01620570f, -0.01193308f, 0.03669310f, -0.05274672f, -0.01775251f, -0.01206974f, 0.00495495f, -0.07970639f, 
    -0.04267679f, -0.03694021f, -0.07053779f, -0.04385493f, -0.02755817f, 0.04497239f, -0.05367127f, 0.03322053f, 
    -0.04759345f, -0.02928461f, 0.03064192f, -0.07164189f, -0.00234047f, 0.00080777f, -0.07232408f, 0.05703170f, 
    0.05189741f, -0.03946393f, -0.05754137f, -0.00037848f, 0.01980811f, -0.04342845f, 0.04806025f, -0.06983274f, 
    0.03823721f, 0.07228194f, -0.02971391f, -0.04775966f, 0.04261737f, 0.03153571f, -0.00289085f, -0.04104680f, 
    0.05698629f, 0.05547949f, -0.00985015f, -0.01694345f, 0.01181585f, -0.05101700f, -0.01358247f, -0.02741027f, 
    -0.04054900f, -0.03959472f, -0.06690780f, -0.04573475f, 0.07349784f, -0.03889502f, -0.08533752f, -0.01957677f, 
    -0.00409116f, -0.04205165f, 0.02444259f, 0.04421369f, -0.06395693f, 0.01411525f, 0.00167976f, 0.00179077f, 
    -0.01278052f, -0.04765284f, -0.02705584f, 0.03596697f, -0.07032795f, -0.06540436f, -0.04101296f, 0.04907167f, 
    0.00354625f, 0.03632224f, -0.05819024f, -0.01081219f, -0.04146245f, -0.02053405f, 0.07058492f, 0.01037199f, 
    0.05839938f, 0.05605196f, 0.01671324f, 0.04484360f, 0.01077660f, -0.02120377f, -0.07866405f, 0.05291929f, 
    -0.04718354f, 0.02648428f, -0.00789887f, 0.01167606f, 0.02063584f, 0.00969440f, -0.08538563f, 0.05777441f, 
    -0.05466727f, 0.07209476f, 0.00055642f, 0.06857994f, 0.00138702f, -0.07583789f, -0.04747244f, -0.09070305f, 
    -0.02186058f, -0.05890400f, -0.02326135f, 0.02271816f, -0.02686271f, -0.03785108f, -0.05517912f, 0.08450591f, 
    -0.12264325f, -0.10062639f, 0.02702059f, -0.04980540f, -0.03733192f, -0.02877158f, 0.05746906f, -0.08224267f, 
    0.01409277f, 0.03619328f, -0.04669571f, -0.01536283f, 0.06689622f, -0.03777998f, 0.01664254f, -0.00273083f, 
    -0.03408821f, -0.00133767f, 0.06200582f, -0.07150994f, 0.03718988f, -0.06367592f, -0.02147897f, 0.00049028f, 
    -0.04442931f, 0.01081073f, -0.02168609f, -0.04235621f, -0.05440407f, -0.04658076f, 0.02504292f, -0.01033899f, 
    0.05497770f, 0.00373322f, -0.04110369f, -0.02968346f, -0.00015652f, -0.00905477f, -0.07144617f, -0.03638042f, 
    0.01428013f, 0.03300263f, -0.00236923f, 0.06231281f, -0.01324688f, 0.01289039f, 0.06284114f, -0.05790620f, 
    -0.00372569f, 0.05651370f, -0.06213912f, -0.02646775f, 0.07419076f, -0.03929790f, -0.06206518f, -0.01924152f, 
    -0.04141325f, 0.02985977f, -0.03051039f, -0.05173017f, -0.06094989f, 0.02952097f, -0.10492142f, 0.01277486f, 
    0.02500065f, -0.01195084f, -0.07243890f, 0.05046882f, -0.08055535f, 0.02512932f, 0.04872973f, 0.00915632f, 
    0.03298840f, -0.04699815f, -0.04971540f, -0.03611667f, -0.03941455f, -0.03946596f, -0.06519528f, 0.04011541f, 
    -0.03718370f, -0.01977249f, -0.03819608f, -0.01785685f, -0.07716031f, -0.09481398f, 0.03707194f, 0.00437612f, 
    -0.01387789f, -0.07663894f, 0.04309183f, -0.06462868f, 0.01335908f, -0.04885728f, -0.00845260f, 0.07693847f, 
    -0.07472157f, -0.05128362f, -0.06260011f, 0.03691856f, 0.00323342f, 0.01280915f, -0.06544073f, -0.07639585f, 
    -0.02116001f, -0.07510137f, -0.01886770f, -0.06123523f, 0.05060220f, -0.07843205f, -0.03805192f, -0.01303304f, 
    -0.08200756f, 0.02234294f, -0.01836589f, 0.03260401f, 0.00155352f, -0.02223297f, -0.02927975f, -0.08819485f, 
    -0.00852559f, 0.04186029f, 0.02765882f, -0.04794175f, 0.00756634f, 0.03034920f, -0.01388477f, -0.08168051f, 
    -0.04026628f, 0.04848403f, 0.03202400f, -0.07141287f, -0.07594357f, -0.02292322f, -0.04734647f, -0.06439663f, 
    0.05666870f, -0.03253945f, -0.03065659f, -0.08532248f, 0.02698951f, 0.01320166f, 0.04010864f, -0.01503521f, 
    -0.06927650f, 0.01005617f, 0.03529185f, 0.03926135f, -0.02470355f, 0.03983004f, -0.06038616f, 0.04135454f, 
    -0.07964322f, -0.06579489f, -0.01147988f, 0.01464412f, 0.03564905f, -0.06266756f, -0.07136253f, 0.00227701f, 
    -0.06537362f, -0.06542294f, -0.04862357f, 0.04896946f, 0.04756062f, 0.03701133f, 0.04764874f, -0.01151579f, 
    0.01747805f, -0.06291045f, -0.07967172f, -0.07474971f, 0.03182833f, -0.05883405f, -0.05896541f, -0.03071987f, 
    -0.03957791f, 0.02679482f, -0.03459167f, -0.04514757f, -0.01742456f, -0.04514816f, -0.06743146f, -0.08433169f, 
    0.01415359f, 0.05406173f, 0.04772202f, 0.03574887f, -0.07962377f, 0.02537527f, 0.02814270f, -0.06386825f, 
    -0.00238545f, -0.04918683f, 0.01649452f, -0.02158103f, 0.00777332f, 0.00696532f, 0.05087608f, -0.08799206f, 
    0.01366329f, -0.07138192f, -0.02576310f, 0.01961622f, -0.05287772f, -0.01270903f, -0.00953616f, 0.04212770f, 
    -0.04455539f, 0.04090352f, -0.05781705f, 0.03009865f, -0.06469250f, -0.01180421f, -0.06736953f, 0.05253641f, 
    0.03116837f, -0.01675140f, -0.06741111f, -0.04957061f, 0.03409069f, -0.06959126f, -0.01867785f, 0.03641715f, 
    -0.01066435f, -0.07298762f, -0.07899545f, -0.03264624f, 0.04037721f, 0.01272152f, -0.03459314f, -0.03001300f, 
    -0.06688432f, -0.03815764f, -0.00604747f, -0.01145771f, 0.02591402f, -0.06964645f, 0.05313995f, -0.03684338f, 
    -0.00705621f, 0.04483341f, 0.00565132f, 0.04692139f, 0.04154268f, 0.04301903f, -0.04223189f, 0.05118701f, 
    -0.01129359f, -0.05802476f, -0.01627443f, 0.02318524f, -0.01936680f, -0.04704511f, -0.08117406f, -0.01522692f, 
    0.02165734f, 0.04087031f, 0.05364418f, -0.04224080f, 0.03647050f, -0.01646596f, -0.02549071f, -0.07977126f, 
    -0.05618165f, -0.03563832f, -0.08607105f, -0.04904356f, 0.05518658f, -0.05704427f, -0.03671698f, -0.02149244f, 
    0.03415156f, 0.01813824f, -0.05558554f, 0.04960394f, -0.00102288f, -0.00306296f, -0.04725100f, -0.08048615f, 
    -0.00222937f, -0.04677625f, 0.02481731f, 0.00895003f, -0.06733172f, -0.03853444f, -0.05582877f, -0.05192275f, 
    -0.02586272f, -0.05110108f, 0.01296197f, -0.00490352f, -0.01225563f, -0.06115407f, -0.07069786f, -0.03045144f, 
    -0.07317285f, 0.04557898f, 0.04435370f, 0.00494331f, -0.04139723f, -0.07364763f, 0.03578236f, 0.02262353f, 
    -0.03870643f, -0.01351569f, -0.05560254f, -0.01201257f, -0.03245462f, -0.01375936f, 0.04832168f, -0.05675724f, 
    -0.03493475f, -0.01846712f, 0.05621313f, 0.05908544f, 0.03580878f, -0.04220575f, -0.02335514f, -0.06890669f, 
    0.06014513f, -0.00802539f, -0.04830783f, -0.07823978f, -0.06854520f, -0.00244109f, -0.00585479f, -0.03622811f, 
    0.04475577f, -0.00254222f, 0.02699857f, -0.03379081f, 0.01919243f, -0.07051937f, 0.02873107f, 0.00015361f, 
    0.00612564f, 0.04478231f, 0.05035257f, -0.08764537f, 0.01822832f, -0.04200873f, -0.06408393f, 0.04533443f, 
    0.00026762f, -0.05381434f, -0.05859198f, 0.02245368f, -0.01437220f, -0.05100457f, 0.02146444f, 0.03071847f, 
    0.00286984f, 0.02499046f, -0.00628581f, 0.01594171f, 0.02408649f, 0.04643394f, -0.06188933f, -0.04110954f, 
    -0.07667678f, -0.07566132f, -0.02114648f, -0.03325852f, -0.01209502f, 0.01519620f, -0.04496761f, -0.05325636f, 
    0.04478998f, -0.04273756f, -0.00715808f, 0.02988868f, -0.02203592f, -0.05229877f, -0.04424397f, 0.00102864f, 
    -0.03186201f, 0.00148413f, -0.02695213f, 0.03331040f, 0.02481687f, 0.00023544f, -0.01436572f, 0.03921845f, 
    -0.04147865f, 0.00830086f, 0.04272700f, 0.05081039f, 0.02541482f, -0.06941965f, -0.04174863f, 0.02379648f, 
    0.02769004f, -0.01551246f, 0.02054966f, -0.00884847f, 0.00230434f, -0.03046424f, -0.05385904f, -0.05522067f, 
    -0.06880051f, -0.04233237f, -0.01110452f, -0.02322800f, -0.04614676f, 0.04707606f, 0.03611889f, 0.03088517f, 
    -0.02059901f, 0.04073296f, 0.06202185f, 0.00565594f, -0.01404679f, -0.05706727f, 0.03905018f, 0.03187964f, 
    -0.06480280f, 0.02916671f, -0.02608724f, -0.01049390f, -0.02966315f, -0.00830165f, 0.03724544f, 0.00545784f, 
    -0.04869194f, 0.02513841f, 0.03138210f, -0.04049952f, -0.00411253f, -0.01268178f, -0.03148200f, -0.02617702f, 
    0.00692107f, -0.00298103f, 0.01683263f, -0.01401373f, -0.07234219f, 0.06271732f, 0.04395537f, 0.03189345f, 
    0.04878525f, -0.05467416f, -0.02902753f, -0.03273898f, 0.04869145f, 0.05354746f, 0.04847642f, 0.05396269f, 
    -0.06915697f, -0.07347883f, -0.04523597f, -0.01237518f, 0.04640428f, 0.05270994f, 0.00496991f, 0.04722271f, 
    0.05283722f, -0.08096706f, -0.03751022f, -0.07051306f, -0.00651860f, 0.02730183f, -0.00730933f, 0.05762639f, 
    -0.05785291f, 0.02106654f, -0.00775841f, -0.01120956f, 0.01534669f, -0.02944498f, 0.01224110f, -0.04642655f, 
    -0.07165246f, -0.00207425f, 0.04944543f, -0.02819773f, -0.02506493f, -0.05020384f, -0.03134862f, -0.02308167f, 
    -0.01543380f, -0.06013368f, 0.04644164f, 0.01014495f, 0.00438464f, -0.05920952f, -0.03259994f, 0.02308811f, 
    0.01299559f, -0.06669350f, -0.00397284f, 0.05922122f, -0.00200878f, -0.07143702f, 0.05264207f, -0.04964433f, 
    -0.04730742f, -0.03595557f, -0.00691006f, -0.05443842f, 0.04056789f, 0.03149056f, -0.07882763f, 0.06967109f, 
    0.03851344f, -0.07181729f, 0.05769332f, 0.04723341f, -0.07882868f, -0.03157935f, -0.01768459f, -0.05383479f, 
    -0.02810687f, 0.05336146f, 0.05866726f, 0.04710220f, 0.01436708f, 0.02774334f, -0.05080200f, 0.04730803f, 
    -0.04765077f, -0.06092873f, -0.07263791f, 0.02593259f, -0.05432570f, -0.02887823f, -0.03155304f, 0.05989955f, 
    0.01005550f, -0.05150640f, -0.01258299f, 0.02930861f, -0.05043643f, -0.05271254f, 0.04123089f, -0.06244909f, 
    -0.06526180f, 0.00784508f, 0.03760635f, -0.06866523f, 0.00150426f, 0.05461222f, -0.02939894f, 0.00722920f, 
    -0.01803540f, -0.02699850f, -0.00175877f, -0.06829047f, -0.03419764f, -0.07348329f, 0.00766896f, 0.01752193f, 
    -0.04901205f, 0.03470777f, 0.05981941f, 0.00216971f, -0.05822416f, -0.00145229f, 0.01925311f, -0.04626210f, 
    0.03612260f, 0.01065316f, 0.02692153f, -0.07348915f, -0.05046304f, -0.01769561f, -0.06747089f, 0.05425714f, 
    -0.00511978f, -0.04388307f, -0.04647473f, 0.06339263f, -0.03913150f, -0.07933609f, 0.01332300f, -0.04650907f, 
    -0.00967462f, -0.06173915f, -0.04617851f, -0.06017905f, 0.01160920f, -0.06221786f, -0.00257908f, -0.03166904f, 
    -0.06324892f, -0.06521438f, -0.00350220f, -0.00155734f, -0.01171891f, 0.03210917f, -0.03115040f, 0.04795177f, 
    -0.02140122f, -0.06764060f, -0.00891758f, 0.04332576f, 0.06233228f, -0.07577973f, 0.05417245f, -0.06800383f, 
    -0.05974829f, -0.06901384f, 0.04029927f, 0.00633661f, 0.01684352f, 0.02714228f, 0.06173222f, -0.04757865f, 
    -0.03858370f, -0.07636645f, -0.01061576f, 0.04497409f, -0.03589591f, -0.03749358f, 0.00312057f, -0.06388134f, 
    0.05295933f, -0.04836587f, -0.05918149f, -0.01851042f, 0.04986552f, -0.02157312f, -0.06823037f, 0.01278959f, 
    -0.02276823f, 0.05298763f, 0.01575774f, -0.02001417f, -0.06109514f, 0.03394250f, -0.02367370f, -0.02798906f, 
    0.03102748f, -0.01544376f, -0.06856298f, -0.07159416f, 0.02103298f, -0.06119351f, 0.00088638f, -0.03926108f, 
    0.01393081f, -0.01947455f, 0.02832808f, -0.01146900f, -0.07908981f, -0.01575756f, -0.07168807f, -0.05249150f, 
    0.00621676f, 0.01195485f, 0.00027511f, -0.03028043f, 0.05854423f, -0.02764091f, -0.05643282f, -0.07031878f, 
    -0.00037770f, 0.04168140f, -0.01325718f, 0.04967352f, -0.02604619f, 0.02151393f, -0.02411585f, -0.01593630f, 
    -0.00328633f, -0.04179418f, -0.01565314f, -0.02519787f, -0.04663928f, -0.03335878f, 0.05853228f, 0.01425452f, 
    0.05927547f, 0.01939001f, -0.03252611f, 0.01546504f, -0.04943226f, 0.00774164f, 0.04054561f, -0.01537193f, 
    -0.03820017f, -0.06654549f, -0.01289543f, -0.05238742f, -0.00752391f, 0.02144575f, -0.07191211f, -0.04090409f, 
    -0.00157309f, 0.02222352f, -0.00484981f, -0.07493404f, -0.02832008f, 0.01453129f, 0.04232307f, 0.05139720f, 
    0.05437923f, 0.00829199f, -0.01846988f, 0.04127779f, 0.04019094f, -0.01664856f, 0.02721611f, -0.07665473f, 
    -0.00309589f, -0.04778279f, -0.00852337f, -0.05781545f, 0.01247679f, 0.06431936f, 0.05345377f, -0.04175380f, 
    -0.02781777f, -0.07339825f, -0.04810463f, -0.02837099f, -0.02192985f, 0.06113652f, -0.02184100f, -0.02397755f, 
    0.04517540f, -0.07480392f, 0.03676543f, 0.03834730f, -0.07044086f, -0.05252435f, -0.06066668f, -0.06730983f, 
    -0.03848417f, -0.03049242f, -0.05334621f, 0.04518161f, 0.01256608f, 0.06052022f, 0.03931938f, -0.03743401f, 
    0.00475683f, 0.01151249f, -0.04605630f, 0.02825496f, -0.05457843f, -0.06535733f, -0.02909085f, -0.06770491f, 
    0.00557095f, 0.04386815f, -0.06493197f, -0.02384413f, -0.01821647f, -0.07153540f, -0.03983131f, -0.01838499f, 
    -0.00732899f, -0.03000935f, -0.07313293f, 0.05954601f, -0.05073665f, -0.05386207f, -0.03457830f, 0.04215045f, 
    -0.00820577f, -0.06450477f, 0.05676654f, 0.01202877f, 0.05882069f, -0.03797395f, -0.06519952f, 0.05060010f, 
    0.00427825f, -0.00881791f, -0.00523469f, 0.00156035f, -0.07986843f, -0.02220852f, 0.01289951f, -0.02398428f, 
    -0.06348420f, 0.02799958f, -0.02403837f, 0.02874660f, -0.04581564f, -0.06019939f, 0.03900163f, -0.01615925f, 
    -0.08016469f, 0.00872122f, 0.01824624f, 0.03064215f, 0.03995016f, -0.01311510f, -0.02306839f, 0.05140398f, 
    -0.04874057f, -0.07848267f, 0.04448231f, -0.02189683f, 0.05347062f, -0.07403725f, -0.02947328f, 0.03621790f, 
    0.05458562f, 0.02855106f, 0.01876959f, -0.03371036f, 0.06165330f, -0.05951053f, 0.01457634f, 0.05941060f, 
    -0.01610541f, 0.02441964f, -0.03909194f, -0.05445381f, 0.01734953f, -0.07195126f, -0.00218515f, 0.04900087f, 
    -0.06875488f, -0.00105154f, -0.02605469f, -0.01908365f, 0.00858225f, -0.03591367f, 0.01100656f, -0.03331957f, 
    0.00120806f, 0.02441470f, 0.05720007f, 0.01242690f, 0.04959463f, -0.04694102f, -0.06410623f, -0.01864238f, 
    -0.04730902f, 0.03112112f, 0.01907619f, 0.04591972f, 0.06125230f, 0.04298859f, -0.02560117f, 0.04039387f, 
    -0.03302736f, -0.01664425f, 0.00500441f, 0.00946685f, 0.00263756f, -0.04443590f, -0.05782375f, -0.04408287f, 
    -0.06941287f, -0.04281542f, -0.06636601f, -0.06529339f, -0.04314533f, 0.06264103f, -0.05447573f, 0.02045943f, 
    0.04686436f, -0.00431367f, -0.03326145f, -0.01990538f, 0.01931280f, 0.06022561f, 0.03005582f, -0.06448273f, 
    0.04343141f, -0.02763466f, -0.00983226f, -0.04437427f, -0.01237957f, -0.00297408f, 0.00983187f, 0.04830005f, 
    -0.00038220f, -0.07517970f, 0.03345337f, -0.03573976f, -0.07524226f, -0.06170809f, 0.03659545f, 0.03901660f, 
    0.02536465f, -0.07001177f, -0.04123263f, -0.00992026f, -0.02845314f, -0.00802858f, -0.05874428f, 0.06621674f, 
    0.03960818f, 0.00658192f, 0.02979320f, -0.02232671f, -0.04213087f, 0.04456270f, -0.06139508f, -0.01450626f, 
    -0.02729702f, 0.05940456f, 0.00385540f, 0.07024051f, -0.05314073f, -0.04057551f, -0.04994996f, -0.00017404f, 
    0.04252664f, -0.05880014f, 0.05417976f, -0.01661695f, -0.03538337f, -0.01531599f, 0.02500535f, -0.00556944f, 
    -0.03814253f, 0.06013855f, -0.00662591f, -0.04345576f, 0.00850887f, -0.05615916f, 0.05506848f, -0.02360781f, 
    -0.00484727f, 0.03813707f, -0.02250217f, 0.00759279f, -0.05384256f, -0.04659169f, 0.00449297f, -0.06122128f, 
    -0.02441188f, 0.03950490f, -0.02198985f, -0.01003453f, -0.03214321f, 0.03914342f, 0.04444094f, 0.03390357f, 
    0.01168268f, -0.01684371f, -0.03186235f, -0.01522557f, -0.02451093f, -0.06383581f, 0.05828604f, -0.00866159f, 
    -0.07928502f, -0.06545853f, -0.06834008f, -0.02689904f, -0.05996476f, -0.02971083f, -0.04604590f, -0.05064342f, 
    -0.01222854f, 0.05543888f, 0.02193155f, -0.05075097f, 0.04781667f, -0.06468556f, 0.00009942f, -0.01663376f, 
    -0.07351787f, -0.06089431f, 0.05523426f, 0.06173345f, 0.04340399f, -0.07235622f, 0.05593717f, -0.03707106f, 
    -0.04033199f, -0.06980060f, 0.01923731f, -0.00534762f, -0.03150198f, -0.05287041f, -0.04291643f, 0.03756196f, 
    -0.06489815f, 0.05455364f, 0.05007076f, 0.03347169f, -0.01426032f, -0.06321947f, -0.03957838f, -0.02349093f, 
    0.01304079f, 0.05492086f, -0.03093404f, 0.00686276f, 0.04066270f, 0.04365401f, -0.00256535f, 0.01570511f, 
    -0.00260566f, -0.00531163f, 0.03619474f, -0.04188409f, 0.07211091f, 0.04304501f, -0.00914367f, -0.03724272f, 
    0.00179436f, 0.03354244f, 0.04316597f, 0.05021009f, 0.03136717f, -0.02168240f, 0.00726246f, -0.07103682f, 
    -0.06425271f, -0.06208173f, -0.04184579f, 0.00841849f, 0.03282441f, -0.00869788f, -0.06651369f, 0.01360916f, 
    0.01054387f, -0.03600744f, -0.06978498f, 0.00330526f, 0.04009638f, -0.05820188f, -0.02040595f, 0.05320432f, 
    0.03996465f, 0.06420080f, -0.01545900f, -0.06930217f, 0.01055281f, -0.07199494f, 0.03752394f, -0.06106273f, 
    0.03130125f, -0.04626342f, 0.04656219f, 0.00741295f, 0.05477307f, 0.06909589f, -0.05628389f, 0.05868663f, 
    -0.00824335f, 0.01122828f, 0.04107225f, 0.01678338f, 0.02660696f, 0.05401265f, 0.00121675f, 0.00075640f, 
    -0.05090198f, -0.06438583f, -0.02641487f, -0.07142933f, 0.01072358f, 0.02141000f, -0.07432469f, -0.05997419f, 
    0.15306011f, 0.37383959f, -0.05157912f, 0.27479485f, -0.12715241f, -0.04659658f, 0.10631743f, -0.01190695f, 
    -0.02684313f, -0.02270438f, -0.19972618f, -0.23095295f, -0.02506692f, 0.25459871f, -0.34384146f, -0.12002454f, 
    -0.01826465f, -0.04449351f, 0.03640716f, -0.19279297f, -0.11922414f, 0.00100991f, -0.13049908f, -0.26681465f, 
    -0.09843606f, -0.18697724f, 0.00562752f, 0.26760483f, -0.02725587f, -0.06000117f, -0.07898051f, 0.14635755f, 
    -0.14310122f, 0.12101216f, 0.09258696f, 0.05779564f, 0.63015163f, 0.39654431f, -0.01365106f, 0.19569819f, 
    -0.03259688f, -0.22871439f, 0.21118701f, 0.03117281f, 0.01523895f, -0.26946563f, 0.05386169f, -0.09094356f, 
    0.01154655f, 0.06707052f, 0.06665478f, 0.11264896f, -0.01163907f, 0.23838995f, 0.07246774f, 0.30573532f, 
    -0.28680152f, 0.09114870f, -0.08066551f, 0.11010033f, 0.31485811f, -0.16559090f, 0.16280909f, -0.07933547f, 
    0.02881713f, -0.02643231f, -0.11603277f, -0.07610517f, -0.07097743f, 0.05809011f, 0.00051412f, 0.06283307f, 
    0.50486827f, -0.19896851f, -0.08448622f, -0.00345194f, -0.05509348f, 0.12434381f, 0.07630044f, -0.08813608f, 
    -0.02383460f, 0.00281797f, 0.12139113f, 0.20656085f, -0.07390705f, 0.35094690f, 0.40804508f, 0.32452258f, 
    0.27691120f, -0.06486662f, -0.21915895f, 0.10325946f, 0.10731920f, 0.08130366f, 0.07859513f, 0.12553102f, 
    -0.09913995f, 0.35527834f, -0.12874861f, 0.05175042f, 0.31712255f, -0.00869311f, -0.09043986f, 0.25223851f, 
    -0.01017462f, 0.21329825f, -0.11247605f, -0.04108420f, 0.20560195f, -0.03673962f, 0.19627792f, -0.15009567f, 
    -0.01798439f, 0.03626484f, -0.14909504f, -0.06448679f, -0.05473659f, -0.03103537f, 0.08505289f, -0.15984967f, 
    -0.42263398f, 0.17081584f, 0.24065904f, 0.19549194f, -0.01888158f, 0.12314928f, 0.23697425f, 0.42534038f, 
    0.10339855f, -0.17552325f, -0.09363356f, -0.09519345f, 0.39531592f, -0.11344326f, 0.03593956f, -0.46688452f, 
    -0.01845287f, 0.18828446f, -0.09099147f, 0.22264554f, 0.15217677f, 0.16576378f, 0.28483301f, 0.02497451f, 
    -0.05314033f, -0.20315769f, -0.37478629f, -0.07853913f, 0.16856182f, 0.11883196f, -0.07193889f, -0.21327774f, 
    0.14156991f, 0.14010718f, 0.10476369f, -0.09798907f, -0.54903191f, -0.08885438f, 0.06679398f, -0.15248019f, 
    0.10043769f, 0.07560506f, 0.08822834f, -0.05724564f, 0.03510108f, -0.02047698f, -0.01237791f, -0.04697110f, 
    -0.10480338f, -0.09195092f, -0.10614348f, -0.27447560f, -0.04055751f, 0.00997136f, -0.09138139f, -0.16859800f, 
    0.02633898f, -0.00036807f, -0.14762758f, -0.22886930f, -0.06132788f, 0.30512196f, 0.12880355f, -0.17393433f, 
    -0.07616112f, 0.10908169f, 0.05581498f, 0.04364385f, -0.04869153f, -0.03774390f, -0.05803402f, 0.03746698f, 
    -0.05175922f, 0.27973530f, -0.21222277f, -0.14636871f, -0.00235226f, -0.14515133f, -0.07983098f, -0.01201896f, 
    0.08767903f, -0.03228237f, 0.05737600f, 0.00800914f, 0.42137760f, -0.17063089f, 0.09477976f, 0.06726594f, 
    -0.00475095f, 0.12894472f, -0.10128353f, 0.12591968f, 0.06173140f, 0.03076130f, 0.10273550f, 0.17859569f, 
    -0.41385350f, -0.21208881f, -0.06575162f, -0.01107191f, -0.27057001f, -0.09018672f, 0.04086888f, -0.02674844f, 
    -0.06306163f, -0.20448992f, -0.01483016f, 0.01357205f, -0.70473593f, -0.27852088f, 0.29935309f, -0.07349318f, 
    -0.10581836f, -0.09435695f, 0.22984459f, -0.00572554f, 0.10169264f, 0.23134841f, 0.09743182f, -0.00484462f, 
    0.02267149f, 0.10929458f, -0.06354341f, -0.10683106f, -0.19946602f, -0.20732981f, -0.14483759f, -0.07202671f, 
    0.15241471f, -0.01181087f, 0.03524582f, 0.10345126f, 0.08008043f, 0.01237795f, -0.47801340f, 0.40064529f, 
    -0.00875007f, 0.21088840f, -0.24101415f, -0.03422687f, 0.05771601f, -0.00872886f, -0.06332008f, -0.04332891f, 
    0.00672190f, 0.29607630f, 0.20416561f, 0.08550622f, 0.01735332f, 0.06184072f, -0.24939822f, 0.22946095f, 
    0.19579157f, 0.16278489f, -0.14951588f, -0.14237583f, -0.07854606f, 0.01220568f, -0.17622869f, 0.17668569f, 
    -0.10974085f, 0.04090767f, 0.06564177f, -0.19185780f, -0.12440941f, -0.07198261f, 0.05722722f, 0.02261006f, 
    0.38518786f, -0.01654525f, -0.15115635f, 0.47155994f, -0.05035592f, -0.05281144f, -0.05661939f, -0.07080013f, 
    0.11688931f, -0.18181413f, 0.02572482f, 0.15437384f, -0.17093730f, -0.37776709f, 0.09436382f, -0.15935752f, 
    0.20072383f, 0.03972304f, 0.12243073f, -0.03624533f, 0.06051799f, -0.05149782f, -0.15634291f, 0.21376345f, 
    -0.13344304f, 0.11522344f, -0.09544843f, 0.12503004f, -0.17140365f, 0.06605785f, -0.17557733f, 0.02468855f, 
    0.05055010f, -0.09767189f, 0.10558310f, -0.02699184f, -0.12289523f, 0.01892832f, 0.08475596f, -0.01106115f, 
    0.12801763f, -0.01813903f, -0.13090643f, 0.06996071f, -0.07213927f, 0.08791631f, -0.06793270f, 0.26767626f, 
    0.08718261f, -0.00287121f, 0.01276642f, 0.39122030f, 0.18728051f, 0.18724030f, -0.14210112f, 0.01223820f, 
    0.06236971f, 0.04508747f, 0.01468788f, -0.00163893f, 0.28614360f, 0.02720898f, 0.39352763f, -0.22402281f, 
    0.03157041f, -0.04271489f, 0.05077429f, 0.04852330f, 0.03355028f, 0.01982090f, 0.22759154f, 0.01030217f, 
    -0.19263515f, -0.06637473f, 0.20143451f, 0.11004452f, 0.21056388f, 0.18073434f, -0.06171669f, 0.09560115f, 
    -0.03120778f, 0.03309765f, 0.10439843f, 0.04328101f, -0.05992537f, 0.19596979f, -0.00626688f, 0.13191342f, 
    0.12895581f, 0.25127828f, 0.00066454f, 0.07039220f, 0.05090870f, -0.07879996f, 0.02310971f, -0.12971482f, 
    -0.07988399f, -0.14221072f, -0.34508073f, 0.14004225f, 0.03192966f, -0.06322692f, -0.10008606f, -0.03124754f, 
    0.08744505f, -0.29763460f, -0.19441296f, -0.52066404f, 0.05670735f, 0.28736830f, -0.27581295f, -0.26135436f, 
    0.02300996f, -0.10181987f, -0.01181680f, 0.07716887f, -0.09043336f, 0.00288976f, -0.13029332f, -0.08980307f, 
    0.33140481f, -0.32908675f, -0.16512306f, -0.07338660f, 0.05356425f, 0.08955850f, 0.14413834f, 0.11623241f, 
    -0.27805904f, -0.04879139f, 0.09100860f, 0.37184149f, 0.49925774f, -0.14003764f, -0.01374524f, 0.00083375f, 
    -0.10879368f, 0.07641307f, -0.08147482f, 0.27073848f, 0.01936574f, -0.24524148f, -0.01712652f, -0.10697059f, 
    0.57751095f, 0.03856987f, -0.17209473f, -0.10633269f, -0.17415741f, 0.00816526f, 0.10010761f, -0.06500062f, 
    -0.15881778f, -0.08058657f, -0.05174042f, 0.00438476f, -0.04789189f, -0.07131048f, 0.13462809f, 0.09971910f, 
    0.22063674f, 0.08463912f, -0.06631374f, -0.02830816f, -0.01799454f, 0.02466636f, -0.02707619f, -0.12413577f, 
    0.23821720f, -0.25431982f, 0.22108309f, 0.02459178f, -0.19837368f, 0.28709438f, -0.09834006f, -0.09185586f, 
    0.05766693f, -0.10236577f, 0.35063887f, 0.57187736f, -0.02129814f, 0.35848832f, 0.32846311f, 0.05219119f, 
    0.04762604f, 0.09997926f, -0.15531829f, 0.12134201f, 0.23152535f, 0.23016752f, 0.21571755f, 0.13284208f, 
    0.06143872f, -0.09733043f, 0.14595941f, 0.06136088f, 0.04653203f, 0.15703668f, 0.02287324f, 0.10364972f, 
    0.13117339f, -0.04270724f, -0.25956792f, 0.23553568f, 0.05562051f, -0.12109214f, 0.09211269f, -0.03024504f, 
    -0.10284044f, 0.23276679f, -0.04917647f, 0.15008137f, 0.06929166f, 0.12093978f, -0.08961973f, -0.28867459f, 
    -0.05418968f, -0.13284217f, -0.07068273f, 0.17642617f, -0.06004528f, 0.10382692f, 0.19092511f, 0.33802718f, 
    0.11981754f, -0.28365561f, 0.22447337f, 0.05841193f, 0.05220379f, -0.28163585f, -0.29337305f, -0.21259582f, 
    -0.04075462f, 0.25814605f, -0.09335733f, 0.12495445f, 0.09863281f, 0.22588053f, 0.21783130f, 0.16561261f, 
    0.23681329f, -0.02779162f, 0.00284970f, -0.09120282f, -0.01616687f, 0.04476764f, -0.23785204f, 0.08633454f, 
    0.25142467f, -0.04490305f, 0.22945027f, -0.33076084f, 0.03566284f, 0.10416139f, -0.18932049f, 0.14139690f, 
    0.17841236f, -0.00257139f, 0.17305955f, -0.19473572f, -0.07110953f, -0.25207555f, 0.00960893f, -0.06693381f, 
    -0.11394496f, 0.09533660f, 0.01108635f, -0.08789690f, 0.24986169f, -0.15361124f, -0.26963833f, -0.35576379f, 
    -0.07367287f, -0.01300858f, -0.31949455f, -0.16961041f, 0.06543770f, 0.31383035f, 0.17052463f, 0.09124797f, 
    -0.01867853f, 0.25103748f, 0.02423538f, 0.02514433f, 0.03877981f, 0.10566153f, 0.14538831f, 0.04104809f, 
    -0.12465267f, 0.18924262f, -0.09850451f, 0.31369576f, -0.05988758f, -0.15889716f, 0.01349859f, 0.10835702f, 
    -0.01999865f, 0.17415306f, -0.00209446f, 0.08901769f, 0.37958428f, -0.24141514f, 0.24278142f, 0.27016953f, 
    0.03439240f, -0.02169798f, -0.12487505f, -0.07856952f, 0.15248781f, -0.09938677f, 0.02395712f, -0.08804168f, 
    -0.59969997f, -0.11529206f, -0.05993708f, -0.15101148f, 0.16718659f, 0.11712376f, -0.09262243f, 0.00869049f, 
    0.01447449f, 0.08094103f, -0.00052610f, -0.21769376f, 0.31936014f, -0.01267051f, -0.10370348f, 0.05482934f, 
    0.03083099f, -0.03073350f, 0.16089725f, -0.12633070f, 0.04168508f, -0.02348853f, 0.15546490f, 0.05350970f, 
    -0.38997453f, -0.20202313f, 0.23031551f, -0.26026234f, -0.14733267f, 0.27517134f, -0.34755164f, 0.17030948f, 
    0.01173995f, -0.17148693f, -0.06802756f, 0.13553606f, 0.98070610f, -0.05526503f, -0.06893017f, 0.07437366f, 
    -0.13003169f, -0.04431143f, -0.01321967f, -0.04402632f, 0.01944310f, 0.18295962f, 0.06798365f, 0.13582705f, 
    -0.13083181f, -0.14454021f, 0.07707709f, 0.07107414f, -0.08223172f, -0.05866902f, 0.03162975f, 0.09764487f, 
    -0.03836362f, -0.01383180f, 0.03435023f, -0.04108555f, 0.04250520f, -0.34417075f, -0.26031363f, -0.36015788f, 
    -0.09579837f, -0.07237455f, -0.14616098f, -0.10889145f, 0.06370217f, -0.01865111f, -0.16065957f, 0.12604107f, 
    0.27927655f, 0.03819668f, 0.09367392f, -0.07102416f, -0.03838190f, 0.02743983f, 0.05318273f, 0.13392451f, 
    0.13724874f, -0.01148334f, 0.02084603f, 0.06455062f, 0.34970471f, 0.12358235f, 0.11318770f, -0.00598270f, 
    0.41440514f, -0.12898298f, -0.00850597f, 0.06131970f, 0.17728022f, -0.10967819f, 0.15562601f, 0.28073534f, 
    -0.20350114f, -0.01674560f, 0.12935960f, -0.42928499f, -0.05050299f, -0.00490123f, -0.07467362f, 0.06687289f, 
    0.03635904f, 0.06503346f, -0.12420847f, -0.08967117f, 0.31683993f, -0.00573152f, 0.23440370f, -0.02639153f, 
    0.05413170f, -0.14028686f, -0.01563353f, -0.04390315f, -0.00492605f, 0.06531970f, 0.07102686f, -0.01479050f, 
    0.27655938f, -0.38415390f, -0.08697231f, 0.04041546f, 0.10104480f, 0.11385363f, -0.04109057f, -0.06973284f, 
    -0.02862079f, 0.06291754f, 0.07128125f, -0.00885770f, -0.25922996f, -0.25248563f, -0.00523573f, -0.02151654f, 
    -0.01357459f, -0.05605897f, -0.07712337f, 0.01089801f, 0.11669409f, 0.00079675f, 0.10531952f, 0.11284629f, 
    0.42903182f, -0.06798937f, -0.31113988f, 0.05576795f, 0.02546205f, 0.00675424f, 0.03113546f, 0.07452077f, 
    0.07552662f, -0.14345379f, 0.15358509f, 0.00016348f, 0.28107536f, 0.02205380f, 0.15137772f, -0.02507774f, 
    -0.05173336f, 0.09976662f, -0.01834127f, 0.05452956f, 0.03146275f, -0.05808209f, 0.06364616f, 0.07878368f, 
    -0.05147191f, -0.02036082f, 0.05120923f, 0.10040767f, -0.06565882f, -0.02037629f, 0.09264607f, 0.00202858f, 
    -0.01276894f, -0.07192760f, -0.10514095f, 0.01101072f, 0.27930638f, -0.01558673f, 0.11466835f, 0.40743914f, 
    -0.03805856f, 0.03073890f, -0.12677158f, -0.01453420f, 0.05235940f, 0.08389200f, 0.10003476f, -0.07392867f, 
    0.11888135f, 0.48892194f, 0.01383560f, 0.18031114f, -0.12944825f, -0.22001562f, -0.01333448f, 0.05607429f, 
    0.04988864f, 0.05534488f, -0.10170557f, -0.08219055f, 0.51475871f, 0.46660361f, 0.13626297f, 0.30847692f, 
    -0.14271167f, -0.20814987f, 0.01417929f, 0.05752713f, -0.02310400f, -0.18885599f, 0.02572677f, 0.00863698f, 
    -0.12715176f, 0.47807878f, -0.13827027f, -0.35066521f, -0.05154881f, 0.02387708f, 0.03496559f, 0.10529800f, 
    -0.03494512f, 0.04728151f, 0.05235161f, 0.15303852f, -0.18643351f, -0.38895842f, 0.03266193f, -0.46488294f, 
    0.03378863f, 0.04210537f, -0.11836646f, 0.07366014f, 0.03903690f, 0.01339544f, -0.04349667f, 0.19919087f, 
    0.28696805f, 0.24833380f, -0.14478543f, -0.25039890f, 0.03019123f, 0.03805158f, -0.01564052f, 0.00599509f, 
    0.09551187f, -0.17867695f, -0.04615894f, 0.09309483f, -0.12152376f, 0.25844479f, 0.37916857f, 0.23621151f, 
    -0.05370512f, -0.19123475f, -0.05330700f, 0.24456260f, -0.13810645f, -0.26677707f, 0.06700440f, -0.05292679f, 
    0.01066804f, 0.06102722f, -0.19561951f, -0.28581578f, 0.15888925f, 0.06730485f, 0.07217336f, 0.17305882f, 
    0.00883755f, 0.28965122f, 0.16876492f, -0.02463074f, -0.17836927f, -0.55371535f, -0.17593089f, 0.18011291f, 
    0.10349774f, 0.18561001f, -0.05191804f, -0.05344233f, 0.00874768f, -0.04001159f, 0.06307152f, 0.06003393f, 
    -0.08829919f, 0.03707866f, 0.25662857f, 0.32101470f, -0.17417021f, -0.00696254f, 0.05201802f, 0.13224325f, 
    0.17550179f, 0.06256455f, -0.18850029f, 0.07411902f, 0.07713395f, -0.17252719f, -0.04251570f, -0.27662298f, 
    -0.11259355f, 0.04672275f, -0.10501203f, 0.08027400f, 0.03814526f, 0.13365096f, -0.02442914f, -0.21684507f, 
    0.00148932f, -0.24842705f, -0.17993882f, 0.46581972f, 0.20319556f, 0.03799342f, -0.06493678f, -0.17744586f, 
    0.01935341f, -0.04659454f, 0.03047042f, -0.05836198f, 0.13210957f, 0.01909791f, -0.27732062f, 0.60522425f, 
    0.12454869f, -0.01867029f, -0.03637219f, 0.09532926f, 0.17596257f, 0.18501602f, 0.06381569f, -0.01241776f, 
    -0.06283972f, -0.33151105f, 0.05209278f, 0.36254671f, -0.08753509f, 0.21029283f, -0.12961903f, -0.19238320f, 
    0.23784542f, 0.00855012f, -0.05600959f, -0.12172058f, 0.23057827f, -0.00832371f, -0.07100206f, 0.09507118f, 
    -0.14303662f, -0.08525258f, -0.00383868f, -0.00785400f, 0.17192088f, 0.01185634f, -0.13020331f, 0.06974307f, 
    -0.18132100f, -0.03871785f, -0.06400615f, 0.63723415f, 0.00793373f, -0.01708626f, -0.10905591f, 0.07278489f, 
    0.13335343f, -0.07374736f, -0.04956369f, -0.00210159f, 0.18916023f, 0.35369745f, 0.05714329f, 0.01745046f, 
    0.03899904f, 0.13708164f, 0.03831809f, -0.00850077f, -0.20133214f, 0.09005216f, -0.16846231f, 0.02670790f, 
    -0.60289413f, 0.29620141f, 0.05930784f, -0.12024330f, 0.21144402f, 0.00053924f, 0.13715857f, -0.08123258f, 
    0.06683664f, -0.02607929f, 0.13004698f, 0.12138094f, -0.16392124f, -0.18284118f, -0.35963419f, -0.18811238f, 
    0.16078977f, 0.10302902f, -0.02736496f, 0.00306341f, 0.14583831f, -0.01605890f, 0.08693111f, -0.00065927f, 
    0.43786711f, -0.19536480f, -0.00076988f, 0.05549063f, 0.16845629f, -0.17028226f, -0.04181313f, 0.10385784f, 
    0.01897302f, 0.16347361f, -0.00936093f, 0.11583881f, 0.40972579f, -0.25152403f, 0.20386091f, -0.07464269f, 
    -0.07135905f, 0.07694375f, -0.01518365f, 0.11673442f, -0.10175145f, 0.05357185f, 0.02352458f, -0.28066260f, 
    0.06533021f, -0.20673123f, 0.41411421f, 0.32317764f, -0.24427602f, 0.00566800f, 0.13064456f, 0.11048584f, 
    -0.05334589f, 0.00931945f, 0.03004523f, 0.05183651f, -0.15645269f, -0.49029729f, -0.02769726f, -0.06404892f, 
    0.03526496f, 0.06704113f, -0.10373522f, 0.13258782f, 0.04866624f, 0.08147320f, -0.02381018f, 0.21281084f, 
    -0.23803058f, -0.05395301f, 0.49188668f, -0.03934872f, -0.12816609f, 0.08947057f, 0.03257541f, 0.00306026f, 
    -0.10064792f, -0.25271103f, 0.05014907f, 0.15470743f, 0.05729076f, -0.01205224f, -0.00429993f, 0.21358469f, 
    -0.19937576f, 0.12668212f, -0.05845435f, -0.04967510f, -0.01392929f, -0.10285106f, 0.05638291f, -0.15338157f, 
    0.05095783f, -0.16812122f, 0.12274873f, -0.15996200f, -0.00679915f, -0.04035223f, -0.01215841f, -0.08802331f, 
    0.13719825f, -0.02131259f, 0.26350302f, 0.16591023f, 0.43840459f, -0.05263853f, 0.27403620f, 0.09184091f, 
    0.08066111f, 0.04953349f, 0.06269907f, -0.00874744f, -0.01343975f, 0.15020391f, -0.05318731f, 0.16959693f, 
    0.14357919f, -0.31077814f, 0.04943807f, -0.09705315f, -0.04209714f, 0.18867207f, 0.01740324f, 0.04645216f, 
    -0.06765718f, 0.00328133f, 0.17310065f, -0.18986747f, 0.20830952f, 0.31103048f, 0.11626233f, 0.01759609f, 
    0.02303553f, 0.22772706f, 0.21799174f, -0.05453420f, 0.12194388f, 0.06061451f, 0.06971051f, 0.07715897f, 
    -0.22759111f, -0.16980082f, 0.31748819f, 0.12615742f, -0.06631708f, 0.02529934f, -0.09459198f, -0.11180994f, 
    0.00785773f, -0.21293975f, -0.15336102f, -0.05801719f, 0.05130823f, 0.10932472f, 0.05693675f, -0.07866459f, 
    -0.26141426f, -0.01495663f, 0.13108595f, 0.05890756f, -0.07706720f, -0.19151461f, -0.16977111f, 0.06958949f, 
    -0.06921609f, 0.01554886f, 0.05924129f, 0.02247044f, -0.03334543f, -0.01419834f, 0.05169837f, 0.03840755f, 
    0.05893273f, -0.01327777f, 0.04556341f, 0.02758671f, -0.01684479f, 0.00256835f, 0.02235706f, -0.02908202f, 
    0.05444028f, 0.01148195f, 0.02192087f, -0.07925721f, -0.05914388f, -0.05547635f, -0.00384462f, -0.03275567f, 
    -0.06966054f, -0.05687540f, 0.02609624f, 0.04937778f, -0.05379186f, -0.05032169f, 0.00415524f, -0.07098311f, 
    -0.03565598f, -0.04324381f, -0.06874198f, 0.05047085f, -0.03715647f, 0.04212428f, -0.07045899f, 0.04169746f, 
    -0.02350081f, -0.04242420f, 0.00879895f, -0.07865728f, 0.03116485f, -0.02723738f, -0.06561182f, 0.04324376f, 
    -0.04881984f, 0.01137654f, 0.04282367f, 0.01845767f, 0.01863005f, 0.04905794f, -0.03175587f, 0.03888008f, 
    0.04596924f, -0.02255947f, 0.04278279f, -0.04353201f, -0.03016257f, -0.01478262f, -0.07089575f, -0.03481469f, 
    -0.06357046f, 0.05156653f, -0.04287384f, 0.00998836f, 0.02779884f, 0.03123876f, -0.05669443f, -0.07617977f, 
    0.02345175f, -0.00749759f, -0.07737680f, -0.04965819f, -0.03067744f, 0.02804386f, -0.04043112f, -0.03112733f, 
    -0.07291673f, -0.07459788f, -0.06919207f, -0.04573721f, 0.05943364f, 0.02858319f, 0.02174206f, -0.00248304f, 
    -0.07282335f, 0.05318065f, 0.04746982f, -0.02182009f, -0.06537025f, -0.00727900f, -0.03293784f, -0.07181302f, 
    0.06088845f, 0.00424549f, 0.04430534f, 0.03307473f, -0.06215809f, 0.04367969f, 0.01924298f, 0.00474531f, 
    -0.01577391f, -0.07129625f, -0.08011422f, 0.01100605f, 0.03482340f, -0.00805384f, -0.07221320f, -0.03707502f, 
    -0.04484193f, -0.03799034f, -0.00085905f, -0.04696916f, 0.04045537f, 0.00497536f, 0.03831875f, -0.01795797f, 
    0.06095059f, -0.04842965f, -0.06444780f, 0.04030107f, 0.01543858f, -0.07601549f, 0.04768193f, -0.02123819f, 
    -0.00256513f, -0.04351750f, 0.03474998f, 0.01389564f, 0.02865372f, -0.02950276f, -0.02431084f, 0.02051280f, 
    -0.01544186f, -0.05218598f, -0.01413375f, -0.01325768f, -0.06197004f, -0.03454976f, 0.02419024f, 0.00186654f, 
    -0.01555662f, -0.05796533f, -0.04544056f, 0.01046863f, 0.06369423f, 0.01317142f, -0.04229872f, 0.01514705f, 
    -0.02187233f, -0.00526109f, 0.04404390f, -0.03570408f, 0.04780015f, -0.02728502f, 0.04749934f, -0.04609266f, 
    -0.06057902f, 0.03123468f, -0.07791568f, -0.05698190f, -0.00706453f, 0.03071374f, -0.00518643f, 0.04378951f, 
    -0.05498079f, 0.00772313f, -0.03872398f, -0.02032632f, -0.07348210f, -0.07915953f, 0.05636268f, -0.00107050f, 
    -0.01650371f, -0.06422776f, -0.03256658f, 0.03322895f, -0.07108534f, -0.03807870f, -0.01180641f, 0.00686009f, 
    0.03525157f, -0.06682960f, -0.01703062f, 0.01607099f, 0.02854216f, -0.04282559f, -0.05865931f, 0.05825382f, 
    0.47644362f, 0.12534083f, -0.15228058f, 0.01426097f, 0.20161447f, 0.07855578f, 0.12596263f, 0.01695831f, 
    -0.09099416f, 0.02693289f, 0.15225947f, -0.08044206f, -0.82807094f, 0.43813014f, -0.33461958f, -0.56077582f, 
    0.03558682f, -0.03350860f, -0.00969267f, 0.11407461f, -0.11314465f, -0.03012203f, 0.10990456f, 0.01169688f, 
    0.43282765f, 0.10365772f, -0.05505101f, -0.11615740f, 0.02135569f, 0.08770074f, -0.00719690f, -0.03820004f, 
    0.03241060f, 0.04843613f, -0.06391827f, 0.11297180f, 0.04671917f, -0.03741635f, -0.13630380f, 0.01491337f, 
    0.01013814f, -0.01192937f, 0.01344742f, 0.01394015f, 0.01849502f, 0.01997068f, -0.08612257f, 0.02150078f, 
    0.25223416f, -0.02237494f, 0.15107934f, 0.49638647f, 0.24120946f, 0.08874757f, 0.29045478f, -0.01119865f, 
    0.02418005f, 0.06851974f, 0.09168898f, -0.01836523f, -0.75346297f, 0.07671347f, 0.02678685f, 0.31527796f, 
    0.22799020f, -0.00966482f, 0.21795751f, -0.00965012f, 0.12835671f, 0.10716143f, -0.03887754f, -0.02964678f, 
    0.00064702f, -0.05589983f, 0.18275042f, 0.47224018f, 0.09420015f, 0.04162440f, -0.01201976f, 0.07778565f, 
    -0.05438287f, -0.07283435f, 0.19071303f, 0.00916623f, 0.18065827f, 0.19078781f, 0.03626398f, 0.00532906f, 
    0.03352218f, 0.16840464f, 0.11288728f, 0.00196784f, 0.21242352f, 0.17164341f, 0.07138924f, 0.11970633f, 
    0.09792215f, 0.02589899f, 0.37041202f, 0.21380611f, -0.14813973f, 0.10367774f, -0.08048403f, -0.03246980f, 
    -0.03470523f, -0.06776474f, -0.05922739f, 0.01418086f, -0.07470549f, 0.47890213f, 0.30011156f, 0.05164835f, 
    -0.00533150f, -0.07421926f, -0.00949375f, -0.12682797f, -0.03189507f, 0.23942369f, 0.06202340f, -0.11443277f, 
    0.36565688f, -0.03863448f, -0.16646314f, -0.08571943f, 0.11255541f, 0.05851932f, 0.14095591f, -0.09522412f, 
    0.15498893f, 0.00382593f, 0.02248466f, 0.06010117f, -0.32476088f, -0.16062994f, -0.05677589f, 0.16823275f, 
    0.16251121f, 0.14106566f, 0.02758711f, -0.06438703f, 0.04109387f, -0.19928722f, -0.00420925f, 0.15760890f, 
    -0.41859627f, 0.28232795f, 0.11933694f, -0.48017243f, -0.12356619f, -0.04418395f, 0.04799972f, 0.15077920f, 
    0.03272451f, 0.00315792f, -0.15214536f, 0.24768096f, -0.27388281f, 0.01517826f, 0.05844334f, -0.33132592f, 
    -0.11031754f, 0.04191710f, 0.05146717f, -0.03500534f, -0.08400653f, -0.09898885f, -0.05521633f, -0.05534658f, 
    -0.51798403f, 0.14056440f, 0.10061116f, -0.34120798f, 0.02863472f, -0.09804232f, 0.05606738f, 0.11684217f, 
    -0.10474212f, 0.09183890f, -0.06720137f, 0.05340894f, -0.55665761f, 0.06958123f, 0.03994178f, 0.13967843f, 
    0.13097593f, 0.03391078f, 0.01911148f, 0.09499177f, 0.07491686f, 0.17832498f, 0.15168315f, -0.03035773f, 
    0.16041957f, 0.06568517f, -0.04914033f, 0.29001456f, 0.16525370f, -0.15323345f, 0.08893710f, 0.03193690f, 
    0.01330023f, 0.16414256f, -0.01279943f, 0.14472651f, -0.16454855f, -0.01771353f, -0.07784858f, -0.20084937f, 
    0.10678519f, 0.04876380f, 0.03738040f, -0.15575683f, 0.04696741f, -0.03113869f, 0.04686999f, 0.16833472f, 
    -0.40163690f, 0.13784660f, -0.00121312f, -0.00737451f, -0.10539491f, -0.06183463f, 0.08163206f, 0.03617869f, 
    -0.02257797f, -0.00842130f, 0.05794558f, -0.02749435f, -0.18851751f, 0.01959701f, 0.26137042f, 0.02873458f, 
    0.05705457f, -0.11212488f, 0.25819787f, -0.12625203f, 0.03482129f, -0.02475617f, -0.16400631f, -0.04464290f, 
    0.28437787f, 0.21939409f, -0.23614934f, 0.24534811f, 0.02916804f, -0.05126629f, -0.27316612f, -0.12184996f, 
    -0.05338702f, -0.08923300f, 0.03742368f, -0.04538901f, -0.19344121f, -0.53048044f, 0.27340740f, -0.38728160f, 
    0.21477717f, 0.12052748f, 0.14379498f, -0.06960650f, 0.23939753f, -0.04638452f, 0.13044780f, 0.12034606f, 
    -0.03481219f, 0.17058805f, 0.32652062f, 0.47854555f, 0.05925390f, 0.09165179f, -0.18707545f, 0.02843738f, 
    0.10774552f, -0.02084714f, -0.06578752f, -0.02401546f, 0.10215662f, 0.11505329f, 0.14863919f, 0.44711435f, 
    0.13408551f, -0.12055903f, 0.11261489f, 0.06674853f, 0.04068939f, -0.06124127f, -0.04489545f, 0.04061171f, 
    -0.25346261f, 0.06400423f, -0.08890153f, 0.21744837f, 0.16098313f, -0.21190053f, -0.06727911f, -0.16453151f, 
    0.13904580f, -0.04876336f, 0.08393168f, -0.06389944f, 0.43000239f, -0.16440579f, -0.01757204f, 0.06269053f, 
    -0.12688076f, 0.10974132f, -0.30654329f, -0.00817511f, -0.07426380f, -0.03289111f, 0.10990128f, 0.17501394f, 
    0.29310220f, 0.10175849f, 0.11920056f, 0.34864295f, -0.02372492f, 0.12443504f, -0.09656851f, -0.03419388f, 
    0.01906506f, -0.09145933f, 0.05931026f, 0.04655075f, -0.11034896f, -0.15113214f, -0.09106439f, -0.47139475f, 
    0.15266423f, 0.09550667f, -0.22221211f, 0.03793330f, -0.08121087f, -0.02528913f, -0.13110799f, 0.02685146f, 
    0.21420392f, -0.24615033f, -0.19192939f, 0.17087428f, 0.18644297f, 0.05088197f, -0.04012721f, -0.14808492f, 
    -0.05800637f, 0.02822270f, -0.09452861f, 0.09074390f, -0.24302499f, 0.01919503f, -0.02305176f, -0.40542910f, 
    0.19601603f, -0.06152720f, -0.11343800f, 0.06746396f, 0.08361206f, 0.09396660f, 0.17882755f, 0.16899064f, 
    0.04479671f, -0.10251170f, 0.10550283f, 0.05942847f, -0.00674840f, 0.09679413f, -0.07915205f, 0.07552555f, 
    0.09917908f, 0.14897776f, 0.10863981f, -0.02360644f, 0.09985567f, -0.01455495f, 0.16578650f, 0.04667256f, 
    0.24495833f, -0.04794178f, 0.14259779f, 0.02896003f, -0.03164355f, -0.16478834f, 0.03858881f, -0.01390176f, 
    -0.15084967f, -0.30081099f, 0.17248991f, 0.13975663f, 0.06666189f, 0.08496530f, -0.03298717f, -0.02479416f, 
    0.01310084f, -0.11036398f, 0.10876255f, -0.06741945f, 0.27874029f, -0.14703873f, 0.12132536f, 0.20208141f, 
    0.13702257f, -0.05839939f, 0.04536095f, 0.04575878f, -0.01862081f, 0.03947403f, -0.14831440f, 0.04414880f, 
    0.40862453f, 0.32980621f, 0.05499412f, -0.14398964f, 0.10170306f, 0.14622571f, 0.04823928f, 0.16332436f, 
    0.22786123f, -0.18494745f, -0.05925578f, 0.05392809f, 0.18963896f, -0.03305151f, -0.30224398f, 0.02877874f, 
    0.04943761f, -0.02113711f, -0.25636834f, 0.10337348f, 0.05944500f, -0.00566934f, -0.08089339f, -0.00948353f, 
    0.12548728f, -0.11837830f, 0.18262212f, 0.00679209f, 0.06552950f, 0.01685700f, 0.10053881f, -0.07720719f, 
    -0.00876455f, 0.18308549f, -0.02955624f, 0.10561963f, -0.08583724f, 0.12454399f, 0.24415210f, -0.04205951f, 
    0.05761578f, -0.07398357f, 0.21168293f, 0.15942848f, -0.05167598f, -0.05950561f, -0.01136977f, -0.13158923f, 
    0.24906582f, 0.02461903f, 0.14904192f, -0.01626715f, -0.06807017f, 0.05139057f, 0.24440542f, 0.03336390f, 
    -0.00904641f, 0.11736319f, -0.01407587f, -0.10826677f, 0.11480196f, -0.42999148f, 0.15178283f, -0.30109370f, 
    -0.08607303f, -0.12389208f, -0.00549781f, 0.17103373f, 0.07480869f, -0.06616127f, 0.03239265f, 0.23386340f, 
    -0.27814528f, 0.15176047f, 0.47350028f, -0.25850058f, -0.13262494f, 0.13433684f, 0.17795743f, -0.00293947f, 
    -0.15310428f, -0.08051574f, -0.10791176f, 0.05499990f, -0.35033709f, 0.25481600f, -0.09371796f, 0.32389951f, 
    -0.15417309f, 0.13329028f, -0.00068358f, 0.11657730f, -0.03116496f, -0.02099208f, 0.09363077f, -0.11583251f, 
    0.06479947f, 0.01668478f, 0.07673460f, -0.15287432f, 0.23555303f, -0.02156151f, 0.17975277f, -0.10792892f, 
    0.04549332f, -0.02475063f, 0.15455259f, 0.10050530f, 0.01450994f, -0.09374601f, -0.03971464f, 0.46577963f, 
    -0.11679882f, -0.12460497f, 0.13396505f, -0.10394891f, -0.05550536f, 0.03715015f, -0.11681156f, -0.05968526f, 
    -0.26248261f, 0.09864880f, 0.38272169f, -0.28989804f, -0.13785012f, -0.01613492f, 0.01821076f, 0.03096419f, 
    -0.04668473f, -0.01044453f, 0.19432874f, 0.05069943f, -0.00497624f, -0.01611732f, -0.16850269f, 0.21293400f, 
    -0.01630216f, -0.00934782f, -0.02219127f, -0.13201201f, 0.03389461f, 0.13851999f, 0.13810444f, -0.00312828f, 
    -0.41817838f, 0.13273475f, 0.23348959f, 0.16139860f, -0.12126718f, 0.02807032f, 0.01396405f, -0.10061782f, 
    -0.11703274f, -0.17938022f, 0.02232445f, 0.03990668f, -0.01992840f, -0.23636274f, 0.17336443f, 0.00989490f, 
    -0.08131420f, -0.12824786f, 0.16392764f, 0.04790913f, 0.10688740f, 0.09640383f, -0.02288308f, 0.15844272f, 
    -0.06192548f, 0.00595061f, -0.00139119f, -0.01314515f, -0.06794661f, -0.05094923f, -0.03376623f, -0.02804205f, 
    -0.05801210f, -0.00424994f, -0.01100158f, -0.07206231f, -0.00311819f, -0.04480938f, -0.04142091f, -0.03054653f, 
    -0.03399707f, -0.06483319f, 0.00479525f, -0.07658265f, -0.01450640f, -0.05879338f, 0.00813975f, 0.00435122f, 
    -0.00778528f, -0.00124281f, -0.07688838f, -0.02529713f, -0.06409883f, 0.00400731f, -0.01450603f, 0.01143851f, 
    -0.02210680f, 0.00237086f, -0.05240447f, 0.01485326f, 0.03545170f, 0.01587674f, 0.04139623f, -0.02306524f, 
    0.03894478f, -0.05541370f, -0.02824150f, -0.03855647f, -0.02763200f, -0.07285342f, -0.01929760f, -0.06963161f, 
    -0.06994894f, -0.04005960f, -0.02981039f, -0.07351986f, -0.00486926f, -0.01631498f, 0.00196651f, -0.03791606f, 
    -0.01098424f, -0.05390791f, -0.01761434f, -0.02814907f, 0.04459352f, -0.05494379f, -0.05282871f, 0.00053370f, 
    0.02275044f, 0.05005947f, 0.01831272f, 0.02833272f, -0.00352765f, 0.04957629f, 0.00874071f, -0.07968812f, 
    0.02178201f, -0.05651050f, -0.05357283f, -0.01550986f, -0.06939550f, 0.02219792f, -0.04382296f, -0.01522392f, 
    0.03019991f, 0.04858843f, 0.02821299f, 0.05908981f, 0.01655271f, 0.05469195f, -0.00523840f, 0.04429921f, 
    -0.06690750f, -0.05880415f, -0.06677128f, 0.03206356f, 0.03933925f, 0.06116702f, 0.02643857f, 0.03843538f, 
    0.04401721f, -0.02763900f, -0.01568612f, -0.05477653f, 0.04299328f, 0.05890192f, 0.04625089f, -0.02292950f, 
    0.01731323f, -0.00661455f, -0.03830351f, -0.03511339f, 0.05126869f, -0.01950365f, -0.03923510f, -0.07480404f, 
    0.05879724f, -0.02933787f, -0.02081731f, 0.01484735f, -0.07058492f, -0.05457859f, -0.04637939f, -0.03092237f, 
    0.01165372f, -0.01379733f, -0.00821217f, -0.04215038f, 0.03426357f, -0.03542969f, 0.02673557f, -0.07003286f, 
    0.05657034f, -0.03904367f, 0.03375471f, -0.03513863f, 0.02123089f, 0.03606117f, 0.03979872f, -0.03014046f, 
    0.04405855f, -0.01802119f, 0.02601003f, -0.01869126f, 0.02921992f, -0.04897355f, -0.05852495f, -0.07258344f, 
    -0.04467766f, -0.00812653f, -0.06478418f, -0.01257306f, 0.02000890f, 0.05427067f, 0.00126879f, -0.00458738f, 
    -0.04486029f, -0.00168562f, 0.05313010f, -0.05947260f, -0.05615999f, 0.01008580f, -0.05560884f, -0.04178764f, 
    -0.06978595f, -0.02795098f, 0.02603538f, -0.03456822f, -0.00999337f, -0.00329889f, -0.00438977f, -0.04655371f, 
    -0.00881667f, -0.00221403f, 0.03663925f, -0.07633986f, -0.00685474f, -0.03858627f, 0.01455144f, 0.01994188f, 
    -0.06626729f, 0.03645878f, -0.03155964f, -0.01931129f, -0.02876963f, 0.05301977f, -0.02712501f, -0.01831248f, 
    -0.07752509f, -0.07388590f, -0.04095540f, -0.06071066f, -0.07819603f, -0.05717899f, -0.08025674f, 0.03649354f, 
    0.19510023f, -0.13415478f, -0.07709976f, -0.44778147f, 0.09156732f, 0.07819919f, -0.00696493f, -0.04979608f, 
    -0.08492674f, -0.00825597f, 0.07415373f, -0.03869126f, 0.14485757f, -0.55058259f, -0.06313089f, 0.22490250f, 
    0.24682572f, -0.08220600f, 0.02898568f, -0.02412830f, 0.17206433f, 0.02943760f, 0.14203735f, 0.10808343f, 
    0.74015355f, -0.14923154f, 0.11701419f, -0.01682726f, -0.17723919f, 0.01961154f, -0.06032023f, 0.19583331f, 
    0.02747574f, -0.04229135f, -0.11160968f, -0.07632351f, 0.26754233f, -0.17081079f, 0.23345950f, 0.04187978f, 
    -0.35138583f, 0.04054194f, -0.20862059f, 0.10434182f, -0.00762315f, 0.08267783f, 0.03772574f, -0.00105613f, 
    -0.23075536f, 0.09768336f, -0.04568002f, 0.02101912f, -0.08866758f, 0.11415681f, -0.13849822f, -0.18626119f, 
    -0.16892073f, -0.10976323f, 0.02200423f, -0.11737920f, -0.11036068f, 0.26140153f, -0.07600660f, 0.10930921f, 
    0.23791048f, 0.01740700f, 0.27026740f, 0.05367323f, 0.00278141f, 0.02188256f, 0.09728314f, 0.22324413f, 
    -0.01239528f, 0.02028309f, -0.18588750f, -0.12005454f, 0.16130967f, 0.05582265f, -0.07868885f, 0.09364188f, 
    0.21266258f, 0.04982582f, -0.11056463f, 0.03560546f, 0.34677064f, 0.22233395f, 0.02621379f, -0.06965565f, 
    -0.26002008f, -0.17512643f, 0.05649617f, -0.02337867f, 0.04967634f, 0.01599700f, 0.02670650f, -0.07715145f, 
    0.11773771f, 0.30050319f, -0.20109735f, 0.00318130f, 0.06328118f, -0.00195324f, 0.06286867f, -0.00319162f, 
    0.10357817f, 0.04716836f, -0.22733785f, -0.03745436f, 0.17357014f, 0.26050168f, -0.13402902f, 0.09425415f, 
    0.23288912f, 0.04760564f, 0.03749023f, 0.15096332f, -0.05635883f, 0.12686852f, -0.00612188f, 0.18862061f, 
    0.14739062f, 0.31302023f, -0.06663948f, -0.04201447f, 0.05505285f, 0.03042268f, 0.06733023f, 0.02031193f, 
    -0.18581659f, -0.00108855f, 0.04925746f, 0.06777539f, -0.41579375f, 0.04360829f, -0.29175290f, 0.17748272f, 
    0.00366702f, -0.02390653f, 0.06389485f, 0.00665726f, -0.00805684f, -0.06678287f, -0.07296651f, -0.02962959f, 
    -0.26575521f, 0.23086531f, 0.02183295f, -0.10245428f, 0.12861501f, -0.07059453f, 0.04673756f, 0.07651990f, 
    0.22716802f, 0.02612086f, 0.02718134f, 0.04624317f, -0.52756423f, -0.15980113f, -0.28772473f, -0.03738621f, 
    0.18273844f, -0.24724570f, -0.19357383f, 0.03366856f, 0.02948482f, -0.10106027f, -0.03682769f, 0.00091071f, 
    0.24353470f, 0.34124035f, -0.45217794f, -0.18668181f, 0.36157709f, -0.00104522f, 0.14295517f, -0.00941245f, 
    -0.12974484f, 0.13533270f, 0.09103664f, 0.02084413f, -0.06168716f, -0.33018798f, 0.24884446f, 0.17930153f, 
    0.18351938f, 0.20949833f, 0.03647136f, 0.09261686f, 0.16895112f, 0.16745459f, 0.10208682f, 0.03623815f, 
    0.05821086f, 0.14847285f, 0.12453377f, -0.12226105f, -0.14605623f, -0.02509390f, -0.10015947f, -0.12525684f, 
    -0.05024019f, -0.07738776f, 0.07122746f, 0.02817967f, 0.60786617f, -0.32965359f, 0.12056398f, 0.14660305f, 
    0.18578574f, 0.03752176f, 0.05321000f, 0.02660784f, -0.08073465f, -0.00086914f, 0.13194637f, 0.00218328f, 
    -0.04634827f, 0.27744609f, -0.12202203f, 0.00130076f, -0.11776891f, -0.03219313f, 0.03712150f, 0.03570720f, 
    0.22953431f, -0.16562597f, -0.09029144f, -0.09968875f, 0.43130937f, 0.25398493f, -0.04197779f, 0.09955190f, 
    -0.22778015f, -0.13509446f, -0.05351079f, 0.07099985f, -0.06147850f, -0.06015093f, 0.06340592f, 0.16160701f, 
    -0.17358877f, 0.41378194f, 0.10904635f, -0.18051942f, 0.08579112f, 0.07494665f, 0.21100689f, 0.14556842f, 
    0.09158963f, 0.26478097f, -0.01828327f, 0.05654766f, -0.37335595f, 0.09696689f, -0.31052607f, 0.07966936f, 
    -0.03537971f, 0.04860975f, -0.02449155f, -0.08735173f, -0.05194108f, -0.05948171f, -0.00903962f, -0.14081705f, 
    0.49362272f, 0.21053647f, -0.11664833f, -0.28093690f, 0.15385981f, 0.00278926f, 0.06493267f, 0.04461484f, 
    -0.11869409f, 0.17333573f, -0.16026928f, -0.17490436f, 0.04740375f, 0.19617994f, -0.10689960f, -0.13394490f, 
    -0.27186862f, -0.01984213f, -0.04729470f, -0.00581074f, -0.15607743f, -0.03689420f, -0.07704194f, 0.05280568f, 
    0.27007607f, 0.36081454f, -0.00093864f, -0.04345863f, 0.02176770f, 0.00797040f, 0.22170883f, 0.17140140f, 
    -0.02030181f, 0.26573911f, 0.16299476f, -0.12394698f, -0.59045142f, -0.07636184f, 0.00548526f, 0.17002811f, 
    0.27771804f, 0.18570766f, 0.09167945f, 0.02334345f, -0.10055583f, 0.08890740f, 0.01266968f, -0.02264603f, 
    -0.36753723f, 0.16735150f, -0.12735087f, -0.19441007f, 0.06354775f, -0.07287311f, 0.07257348f, -0.08807590f, 
    0.05671220f, 0.05531125f, -0.01641475f, 0.02043028f, -0.18329495f, 0.12137070f, -0.18042406f, 0.37667117f, 
    0.02164769f, -0.07189827f, 0.00191880f, -0.03841160f, -0.07596134f, -0.04727625f, -0.01718454f, -0.02332514f, 
    -0.60946232f, 0.06677920f, 0.07861330f, 0.29640839f, 0.07205112f, -0.06849003f, 0.09505149f, -0.15991002f, 
    -0.11929959f, -0.17540824f, 0.09379101f, 0.11664689f, 0.23713779f, -0.25881526f, 0.09129015f, 0.05022657f, 
    -0.10431515f, 0.09861188f, -0.04828023f, -0.20559941f, -0.14667515f, 0.21229900f, 0.21447670f, -0.07214598f, 
    -0.41642129f, -0.05154765f, 0.01430982f, 0.02566964f, 0.12475499f, 0.22296883f, 0.00398393f, 0.12771413f, 
    -0.19504210f, -0.04709400f, 0.13613009f, 0.22365353f, -0.15552428f, -0.07981644f, -0.09162252f, 0.09496997f, 
    0.03141681f, 0.08464298f, -0.10802718f, -0.03621455f, 0.08410549f, 0.03661408f, 0.02381810f, 0.11248232f, 
    -0.01637902f, -0.01529985f, -0.04905137f, -0.07389559f, 0.06169637f, 0.02800716f, -0.06194317f, -0.07115109f, 
    -0.03754865f, -0.06668930f, 0.03539731f, 0.05109561f, 0.02402529f, -0.04161029f, -0.02047314f, -0.02725298f, 
    -0.03099308f, -0.00279300f, 0.01885584f, -0.04446930f, -0.04942366f, -0.01481688f, 0.02361191f, -0.02277363f, 
    -0.07387152f, 0.04730706f, -0.00155178f, 0.01456616f, -0.04498213f, -0.02268142f, -0.03946781f, 0.00919909f, 
    0.02278803f, 0.04214603f, -0.06079484f, 0.05270691f, -0.05415267f, -0.04369958f, -0.06987385f, -0.03885167f, 
    0.04451336f, -0.03056974f, 0.03126137f, -0.02340129f, -0.03440374f, -0.03254875f, 0.03703297f, 0.02861547f, 
    -0.04935726f, -0.04577542f, 0.01713342f, -0.06543102f, 0.04932013f, -0.05176408f, -0.02478743f, 0.02809454f, 
    -0.04857748f, -0.01385373f, 0.02181642f, -0.04071547f, 0.01374935f, -0.01704394f, 0.04837840f, -0.01407513f, 
    0.03059810f, -0.04053945f, 0.03658809f, 0.04610376f, 0.03399028f, 0.04491189f, 0.01450005f, 0.01517481f, 
    -0.01431968f, -0.04133266f, 0.04124054f, -0.00959187f, -0.04334909f, 0.04514954f, -0.05549747f, -0.03745330f, 
    0.02857224f, -0.02571573f, 0.05905491f, -0.06242056f, -0.05429365f, -0.03820356f, 0.00313121f, -0.04748530f, 
    -0.01486164f, -0.04072477f, 0.01148982f, 0.01281653f, 0.04615335f, 0.06126805f, 0.03273062f, 0.02203134f, 
    0.01693265f, 0.01484271f, -0.02185972f, 0.01755165f, -0.05972198f, -0.00233027f, 0.00429584f, 0.05129094f, 
    0.00384177f, 0.01150776f, -0.06580717f, -0.01744927f, -0.07763822f, -0.06218567f, -0.06104349f, -0.04366383f, 
    0.02449062f, 0.00865613f, -0.01439131f, -0.01858814f, 0.01880191f, -0.01345977f, -0.04666903f, 0.04245501f, 
    -0.04477912f, -0.00322884f, -0.01188821f, -0.00628387f, 0.00280563f, 0.00560263f, -0.01039886f, -0.07576913f, 
    -0.01418770f, -0.04671463f, -0.03976203f, -0.06178510f, -0.04704774f, -0.07318833f, -0.04970559f, 0.02701427f, 
    -0.02468799f, 0.00911097f, -0.01757552f, -0.05226422f, -0.04299881f, -0.04242595f, -0.01455939f, -0.00714541f, 
    -0.01559072f, -0.03762943f, 0.04039044f, -0.04129371f, 0.02292207f, 0.06215963f, 0.00779315f, -0.00667799f, 
    -0.02790661f, 0.01640271f, -0.04268786f, 0.01731944f, -0.04734168f, -0.06154338f, -0.06470793f, -0.02201087f, 
    0.03232367f, -0.00080831f, -0.07203354f, 0.03997645f, 0.02311855f, 0.00066244f, -0.04303689f, -0.00971970f, 
    -0.05406781f, 0.03195682f, 0.06613615f, -0.05130362f, -0.05855808f, 0.06449115f, -0.01974289f, 0.05812690f, 
    0.03842019f, 0.05278122f, 0.01472755f, -0.04718006f, -0.01710690f, 0.02761970f, 0.04903728f, 0.02820468f, 
    -0.00044482f, 0.04712728f, 0.03834551f, -0.04606661f, 0.06041147f, -0.01266022f, 0.04130179f, -0.04566559f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12365153f, 0.00813486f, 0.14638530f, 0.07800402f, 0.20715994f, -0.03060975f, 0.09716543f, -0.01607694f, 
    0.00168318f, 0.11671491f, -0.11628427f, -0.07561255f, -0.05518139f, -0.08139163f, 0.01141765f, -0.00642587f, 
    0.00236695f, -0.04978168f, 0.10034384f, 0.09896164f, 0.10277810f, 0.11294944f, -0.03008943f, 0.02683457f, 
    -0.04414796f, 0.08642524f, 0.06277892f, -0.05846491f, -0.07081298f, 0.02041710f, 0.04874787f, -0.03076169f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.37521473f, -0.36231518f, -0.12546410f, -0.10490915f, -0.52631700f, -0.17614262f, -0.01127999f, 0.18266335f, 
    -0.61170113f, 0.34221059f, 0.32759285f, 0.03151510f, 0.02537546f, 0.08292619f, -0.04025750f, 0.04765469f, 
    0.08661082f, -0.11339798f, -1.02714586f, -0.42597702f, 0.45875168f, -0.16645850f, -0.11825374f, 0.12556125f, 
    -0.18027760f, 0.04201203f, -0.43894649f, 0.33243310f, 0.03249827f, 0.08653095f, -0.39499980f, -0.09034500f, 
    0.23976043f, -0.77142572f, -0.00451283f, -0.02100861f, 0.25963506f, 0.08888748f, 0.33008030f, 0.29432768f, 
    0.12589572f, -0.00817826f, 0.09580092f, 0.01974544f, 0.00859656f, -0.14450695f, -0.11588994f, -0.00887297f, 
    0.00995437f, -0.03084723f, 0.02662709f, -0.20926566f, -0.89072961f, 0.35506138f, 0.01536662f, 0.04009810f, 
    0.12563939f, -0.33974642f, -0.47456670f, 0.02789823f, -0.08324997f, -0.23857293f, 0.16400042f, -0.12378560f, 
    0.15996039f, -0.52269298f, -0.45840466f, 0.03377467f, -0.20631708f, -0.16834499f, 0.19555297f, 0.07531931f, 
    0.08623112f, -0.21691307f, -1.07801640f, 0.04894456f, 0.02384604f, 0.10307740f, -0.08148193f, 0.00350230f, 
    -0.15649350f, 0.01501671f, 0.30252311f, -0.58481050f, 0.23689872f, -0.47034898f, 0.23122695f, -0.13342121f, 
    0.14605191f, -0.23393363f, -0.03283699f, 0.40183449f, -0.02610927f, 0.50249350f, 0.14975454f, -0.03104156f, 
    -0.84491062f, 0.15622345f, 0.38337851f, -0.55094033f, -0.45921543f, -0.10054947f, -0.25840706f, -0.66757470f, 
    -0.33491847f, 0.00478214f, 0.11350780f, -0.14947465f, -0.04762877f, -0.04579664f, -0.01359441f, 0.15280111f, 
    -0.13955688f, 0.02709077f, 0.08667831f, 0.33744344f, 0.24113002f, 0.29411915f, 0.29327455f, 0.12769790f, 
    -0.15248133f, -0.18749313f, -0.32439837f, 0.27347785f, -0.05860713f, 0.03847119f, 0.60256195f, 0.15111075f, 
    0.18033704f, 0.08112147f, 0.04535359f, -0.15402940f, 0.34532210f, 0.04061055f, -0.52287751f, -0.26777974f, 
    0.02445077f, -0.14332868f, 0.12207942f, -0.01077089f, -0.14599286f, -0.08642422f, 0.06297731f, 0.04459718f, 
    -0.15730180f, 0.09648210f, 0.04464364f, 0.27998242f, 0.35548183f, -0.36184558f, 0.28617170f, 0.32256240f, 
    0.01262814f, -0.17655054f, 0.22091474f, -0.13400204f, -0.12609686f, -0.63541633f, -0.20620821f, 0.15150814f, 
    -0.14345121f, 0.35178751f, 0.23938999f, 0.36326671f, -0.03947366f, -0.12634072f, 0.23206869f, -0.03080145f, 
    -0.20739965f, -0.15735359f, -0.02328592f, -0.02480249f, 0.02678675f, 0.01411245f, -0.13921522f, -0.12712772f, 
    0.06984337f, -0.06914970f, -0.84970069f, 0.34441260f, -0.95446849f, 0.24768573f, -0.65221184f, 0.36417761f, 
    -0.00206062f, -0.04782696f, 0.19316874f, 0.06257632f, -0.00977895f, -0.14109531f, -0.17312281f, -0.13433565f, 
    0.09600117f, 0.22027336f, -0.39878798f, -0.30685174f, 0.31387070f, 0.09986685f, 0.32353902f, -0.41422328f, 
    0.47753149f, 0.37041155f, -0.30379629f, -0.16990031f, -0.14590311f, 0.02222370f, -0.15603377f, -0.06848535f, 
    -0.05525412f, 0.00669148f, -0.36398447f, 0.40580890f, 0.38134944f, -0.37814373f, -0.76679379f, -0.11303148f, 
    -0.16250542f, 0.19925450f, -0.60848236f, -0.16077174f, -0.03409140f, 0.09343476f, 0.05317296f, -0.07908105f, 
    0.09072743f, 0.41650459f, -0.21650167f, -0.27411631f, -0.58812380f, -0.14224420f, -0.23547783f, -0.20109768f, 
    -0.22216924f, -0.88123053f, 0.45226118f, 0.07265925f, 0.00535314f, 0.11353596f, -0.04459699f, 0.15670533f, 
    -0.09470676f, -0.06456112f, 0.26736170f, -0.26332012f, 0.16753417f, -0.81819803f, 0.13908929f, -0.01433159f, 
    -0.15893927f, 0.27676484f, 0.30512187f, -0.40501007f, 0.03693279f, -0.26696047f, 0.00751586f, 0.03961019f, 
    -0.04085241f, -0.14767350f, -0.56154960f, 0.34343407f, -0.49304533f, -0.06461100f, -0.12191643f, 0.26832485f, 
    0.42026386f, -0.24562380f, -0.23997384f, -0.04961404f, -0.16506957f, 0.08707154f, 0.04264243f, 0.09096370f, 
    0.01697970f, 0.16676344f, -0.21162437f, 0.64026242f, -0.34773001f, 0.14125380f, 0.33419043f, -0.70582700f, 
    0.12564601f, -0.68229562f, -0.14422786f, -0.55841404f, 0.02794601f, 0.33530295f, -0.01311036f, -0.14797246f, 
    -0.45365852f, 0.19457605f, -0.95372367f, 0.04939485f, 0.32433328f, 0.00148865f, -0.19998141f, 0.31930590f, 
    -0.04266585f, -0.02734632f, -0.40039846f, -0.15549041f, 0.10719558f, -0.04986496f, -0.14600937f, -0.03549374f, 
    -0.04502048f, 0.07088904f, 0.54303020f, -0.38917416f, 0.37604856f, 0.36927402f, -0.41611347f, 0.30520782f, 
    -0.09806369f, 0.14891939f, -0.31193298f, 0.00970350f, 0.01490777f, -0.23312622f, -0.58659327f, -0.12400421f, 
    -1.02813148f, -0.27487820f, 0.42338553f, -0.26868784f, 0.45298392f, 0.09556716f, -0.28906330f, 0.03831189f, 
    -0.49045554f, 0.30670217f, -0.14829889f, 0.02969590f, 0.07873102f, 0.02237745f, 0.02622059f, -0.06306707f, 
    -0.11907946f, -0.12544209f, -0.14801975f, -0.13296922f, -0.50056994f, -0.32746583f, 0.04615941f, -0.68390268f, 
    0.15600930f, 0.53630364f, 0.32304615f, -0.04176385f, -0.16212068f, 0.33907232f, 0.11833275f, 0.16311164f, 
    -0.11520994f, -0.00324801f, 0.49221122f, -0.25957721f, -0.22746186f, 0.14953454f, 0.47782353f, -0.36626470f, 
    0.16747817f, 0.13681243f, -0.22533543f, 0.10293738f, -0.03182088f, 0.05216512f, 0.15748405f, -0.08820624f, 
    0.10220734f, -0.04507771f, 0.28447098f, 0.14610466f, 0.19607873f, 0.51109505f, 0.05281215f, -0.09414628f, 
    -0.13652253f, -0.43965346f, 0.38122293f, -0.68784517f, 0.06029442f, 0.04198134f, -0.74221349f, -0.06168815f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.06138510f, 0.12384444f, -0.07809529f, 0.13952075f, 0.10472696f, 0.05274866f, 0.02217075f, -0.02998455f, 
    -0.01844241f, 0.00891717f, 0.22710714f, 0.05425888f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
