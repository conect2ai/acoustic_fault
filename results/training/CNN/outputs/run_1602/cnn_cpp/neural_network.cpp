#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.45280030f, -0.46832621f, 0.23259938f, 0.14041251f, 0.66168135f, 0.59666538f, 0.47437620f, -0.02066590f, 
    -0.37396169f, -0.58897519f, -0.26558533f, -0.26265740f, -0.13402978f, -0.26281205f, 0.29637501f, -0.19971509f, 
    -0.28434801f, -0.03873762f, -0.05336406f, 0.03581502f, 0.26035610f, -0.19218352f, 0.24229623f, 0.26767135f, 
    -0.28410733f, 1.20421898f, 0.14119601f, -0.71264338f, -0.87446910f, -0.87737930f, 0.40761954f, 0.22972378f, 
    0.37248337f, -0.13727657f, 0.28205967f, 0.06728236f, 0.28830546f, 0.02729304f, -0.19040620f, -0.14295605f, 
    0.25145674f, -0.00133204f, -0.19832973f, -0.21922278f, -0.26508290f, -0.12883283f, -0.18986744f, -0.31622177f, 
    -0.08727238f, 0.02649852f, -0.41140413f, -0.64559585f, 0.20367190f, 0.55084145f, 0.13039516f, -0.32354993f, 
    -0.14941788f, -0.00864982f, -0.06672978f, -0.34431273f, 0.43493089f, -0.33792317f, 0.11290513f, 0.16743493f, 
    -0.15794317f, -0.06800855f, -0.28734383f, 0.12341771f, 0.17985827f, 0.22407083f, -0.18478912f, -0.20825122f, 
    0.09523753f, 0.19212177f, 0.29312351f, 0.67907423f, -0.47064677f, 0.11544221f, 0.07299726f, -0.37072134f, 
    -0.26608989f, -0.18725638f, -0.53012091f, 0.20235465f, -0.65267378f, -0.15495947f, -0.18146777f, -0.22616585f, 
    0.58099478f, -0.38045728f, 0.00453959f, -0.07087813f, -0.07039162f, 0.18891317f, 0.05120977f, 0.07851373f, 
    -0.03027244f, 0.00260477f, -0.02964432f, 0.05858799f, 0.20050785f, 0.34847614f, 0.47792199f, 0.13559735f, 
    -0.49818933f, -0.19499274f, 0.07356195f, -0.08403692f, -0.12578729f, -0.09737322f, 0.16763964f, 0.30221471f, 
    0.25746357f, -0.45032120f, -0.08447712f, -0.17734098f, 0.04271254f, -0.13856877f, -0.02301296f, -0.01746819f, 
    -0.13825162f, 0.28806722f, -0.25330862f, -0.45389134f, 0.37027788f, -1.17937994f, -0.91469842f, -0.13452277f, 
    0.02084341f, -0.26288101f, 0.91563225f, 0.64394498f, -0.07535901f, -0.20677105f, 0.29623666f, -0.07414357f, 
    -0.08881328f, 0.02048856f, 0.11863580f, 0.02095870f, 0.06268311f, 0.09731096f, -0.00420250f, -0.20311813f, 
    0.10510071f, 0.05335252f, 0.01278658f, 0.04029377f, 0.07140267f, -0.15628327f, 0.58000803f, 0.27941710f, 
    0.08417030f, -0.31805933f, -0.62701368f, 0.41274107f, -0.09273116f, 0.19179638f, -0.51522660f, -0.45538649f, 
    0.03100437f, -0.26609644f, -0.03788489f, 0.15868224f, 0.34417477f, -0.32239294f, -0.06229109f, 0.23209605f, 
    -0.21075355f, 0.24384871f, 0.07900745f, 0.02320246f, 0.12424111f, -0.17193355f, -0.23072664f, -0.09751206f, 
    -0.47189602f, 0.15630357f, 0.14105479f, 0.48564318f, 0.16942912f, -0.26145428f, -0.03082183f, 0.06799883f, 
    0.36156467f, 0.13930038f, 0.22358517f, -0.10531060f, -0.21154045f, -0.07036047f, -0.23765704f, -0.17035949f, 
    0.14139047f, 0.16906692f, -0.25065851f, 0.03393459f, -0.44031852f, 0.00453900f, 0.30059978f, -0.01962800f, 
    1.01408303f, -0.49753889f, -0.49944681f, 0.02852337f, -0.21087252f, 0.56728691f, 1.09491074f, -0.07982664f, 
    -0.60344636f, -0.56652611f, -0.18572643f, 0.06891420f, -0.25548825f, 0.02815028f, -0.05812658f, 0.18650383f, 
    -0.26609004f, 0.05801239f, 0.43902376f, -0.11317445f, -0.03767932f, -0.16350260f, 0.13758005f, -0.03718786f, 
    -0.15743025f, 0.44459739f, 0.13320051f, 0.17781617f, -0.12521592f, -0.46855101f, -0.59978008f, 0.06991263f, 
    0.45249593f, 0.15639991f, -0.25953168f, 0.08140203f, 0.15727273f, 0.02974856f, -0.10409977f, 0.01719333f, 
    0.38490602f, 0.02376115f, -0.30256131f, -0.21090575f, 0.10122501f, -0.14839108f, -0.11423264f, -0.23151550f, 
    0.03201712f, 0.44919240f, -0.86260879f, -0.51857942f, -0.08316898f, -0.26486158f, 0.07975036f, 0.37389481f, 
    -0.22507820f, 0.39688098f, 0.37112844f, 0.48830295f, -0.38513437f, -0.29634574f, 0.13061701f, 0.39098126f, 
    -0.23015076f, 0.09004988f, -0.39354911f, 0.04607476f, -0.02321680f, -0.11171842f, -0.11634559f, 0.22366913f, 
    0.34406751f, -0.24245510f, 0.08064353f, 0.24732056f, 0.33811960f, 0.22250663f, -0.24985503f, 0.10939381f, 
    0.02992962f, 0.28605109f, -0.26390895f, -0.01865070f, 0.10206245f, 0.16537857f, 0.17379895f, -0.21951331f, 
    0.00365060f, 0.02880044f, 0.25700274f, -0.19588433f, 0.20663464f, -0.00182480f, -0.23108979f, 0.06585623f, 
    0.19502656f, 0.04929810f, -0.05804836f, -0.20523629f, -1.23706293f, -0.34385344f, -0.45778695f, -0.84756994f, 
    -0.58091068f, 0.06165876f, -0.05332688f, -0.37467036f, -0.32231730f, 0.20021528f, -0.33374679f, -0.39073890f, 
    -0.36871985f, -0.37425202f, -0.23216049f, 0.07726219f, 0.00372910f, -0.28226644f, -0.19671622f, -0.08437169f, 
    -0.07886150f, -0.05865401f, -0.12510273f, 0.00547727f, -0.10150926f, 0.27486694f, -0.46719313f, -0.50016034f, 
    -0.36430740f, -0.60684490f, 0.41661200f, 0.30038291f, 0.29256740f, 0.12844485f, 0.11011776f, -0.04838061f, 
    0.06110999f, 0.22280712f, -0.31545773f, 0.08269953f, -0.59666854f, -0.37124288f, 0.25832516f, -0.39475951f, 
    -0.16334406f, 0.12046156f, -0.08661404f, 0.18200226f, 0.23514065f, 0.38529286f, -0.46574610f, 1.03391850f, 
    -0.45159864f, -0.21459240f, -0.13068810f, -0.33050263f, 0.11159251f, 0.11860286f, -0.26226911f, -0.17523086f, 
    -0.22801501f, -0.02127352f, 0.30799752f, -0.22708060f, -0.07309797f, -0.00975807f, -0.25320733f, -0.17527965f, 
    -0.38593370f, -0.18051201f, 0.13229965f, -0.24364001f, -0.42572948f, -0.16497596f, -0.28928670f, -1.39101434f, 
    0.49053165f, 0.58512473f, -0.62180018f, -0.03240846f, 0.16063592f, 0.05628366f, 0.11438915f, 0.62599528f, 
    -0.00821477f, -0.21746482f, -0.04139654f, -0.07347377f, -0.29951957f, 0.32640192f, 0.31410700f, 0.02707088f, 
    -0.21267650f, -0.14861462f, -0.02706448f, -0.06591556f, -0.02915591f, 0.17582987f, -0.12219664f, 0.14006098f, 
    -0.60096675f, -0.80526710f, -0.06335619f, 0.17660893f, 0.55342829f, 0.37874353f, -0.04630609f, -0.25587294f, 
    -0.32164696f, -0.51765001f, -0.18431142f, 0.06172952f, -0.23583595f, -0.37555355f, -0.35513011f, 0.11733826f, 
    0.05143253f, 0.04321042f, 0.46343681f, -0.03884602f, 0.07417283f, -0.03232665f, -0.10547394f, -0.05813622f, 
    0.30770183f, -0.40326345f, 0.15975395f, 0.30875099f, -0.00901697f, 0.29627946f, -0.41112107f, 0.16947076f, 
    0.31646532f, -0.32436895f, 0.13457762f, -0.15788518f, -0.25875142f, 0.03568378f, -0.22341195f, 0.39766893f, 
    0.20158598f, -0.16892560f, -0.09094324f, 0.15012370f, -0.08821001f, 0.11265383f, 0.08343152f, 0.03400001f, 
    -0.17351601f, -0.44145694f, 0.40230337f, 0.23824853f, -0.54456455f, -0.60942692f, 0.11873830f, 0.20070922f, 
    0.23408389f, 0.09624133f, -0.04253615f, -0.15496813f, 0.02476912f, -0.04977017f, 0.19978774f, -0.28803152f, 
    -0.19951022f, -0.17646536f, 0.29197064f, -0.27608106f, 0.09689502f, -0.25399205f, -0.02575880f, -0.06433926f, 
    0.13632239f, 0.27436611f, 0.46621716f, 0.77499288f, 0.61081922f, 0.22876091f, -0.13899054f, -1.03818572f, 
    0.09250645f, -0.35123953f, 0.10676565f, -0.13942410f, -0.18356532f, 0.16686948f, 0.13503094f, -0.17296994f, 
    0.45227206f, -0.04395323f, -0.20087430f, -0.09358880f, -0.21693853f, -0.14211221f, 0.28915063f, 0.32039049f, 
    -0.18192913f, -0.08096720f, -0.29291442f, 0.10435808f, 0.12793289f, 0.36333403f, -0.00335886f, -0.05315047f, 
    -0.38437694f, -0.50646353f, 0.14402597f, -0.01632122f, 0.02026387f, 0.16318300f, 0.17894496f, -0.36384702f, 
    0.49822706f, -0.21337730f, 0.11162058f, -0.21931367f, -0.13427325f, 0.15562841f, 0.17144936f, 0.12482798f, 
    -0.08758087f, 0.17736311f, 0.02360860f, -0.36166570f, 0.48859173f, 0.24398501f, -0.32024240f, -0.64312136f, 
    -0.41270155f, -0.57253140f, 0.38861191f, -0.34833518f, 0.00816183f, 0.52297026f, -0.02219362f, 0.24175946f, 
    -0.23361091f, 0.11853532f, -0.06113825f, 0.41203877f, -0.18921794f, 0.21982345f, 0.08998602f, -0.03476551f, 
    0.20256580f, -0.47158244f, -0.09075156f, 0.13707915f, -0.01122792f, -0.25117943f, -0.03704869f, -0.42355579f, 
    -0.32647938f, -0.28548598f, 0.52498347f, 0.26890454f, 0.49162221f, -0.20243299f, -0.32787281f, -0.58932936f, 
    0.46240881f, 0.58502889f, -0.23432216f, 0.27790385f, -0.24702144f, -0.17586757f, -0.12455343f, -0.26061365f, 
    -0.23209718f, -0.11230870f, 0.30189377f, 0.28153157f, -0.28704903f, -0.15300293f, 0.06500115f, -0.55595154f, 
    -0.42532775f, -0.16184074f, 0.51307863f, 0.38226196f, 0.58419102f, 0.23905967f, -0.15998995f, 0.03955101f, 
    -0.42369375f, 0.28746438f, -0.18932623f, -0.05490819f, 0.12057213f, 0.24963517f, -0.15504566f, -0.08981735f, 
    0.08328428f, -0.17704508f, -0.17119850f, 0.28469142f, -0.18973416f, -0.01568634f, 0.14358683f, 0.15646760f, 
    -0.09375775f, -0.37932783f, -0.50430161f, -0.53716195f, -0.36064771f, -0.38264260f, -0.26443520f, 0.12307046f, 
    -0.35411310f, -0.50363523f, 0.18493766f, 0.24369821f, -0.05105406f, -0.30931699f, -0.07790428f, 0.26822442f, 
    -0.00631400f, -0.06938580f, 0.00182635f, 0.08594728f, 0.31931961f, 0.18574363f, -0.10529128f, 0.25498962f, 
    0.09364392f, -0.34717071f, -0.00153806f, 0.09898600f, 0.26897401f, 0.08398741f, 0.26664385f, 0.01337834f, 
    -0.18089870f, 0.06652402f, 0.16017404f, 0.25673571f, 0.20396039f, 0.01527607f, -0.35439438f, -0.02984110f, 
    -0.07544277f, 0.24741328f, 0.08462238f, 0.02480623f, -0.30192855f, -0.08066134f, 0.12696485f, 0.25213429f, 
    0.12409345f, 0.14149007f, -0.23083791f, 0.43694881f, -0.16745885f, -0.00458841f, -0.18096955f, -0.21394119f, 
    -0.28534576f, -0.35083482f, -0.20184594f, 0.00721633f, -0.17442909f, -0.25427070f, -0.07161371f, -0.26106855f, 
    -0.25473815f, -0.13786896f, -0.06568561f, -0.03229419f, 0.13052407f, -0.40998396f, -0.30965242f, -0.28255272f, 
    -0.20841770f, 0.11823326f, 0.15976247f, 0.59068382f, 0.73001432f, 0.14719392f, -0.10485727f, -0.07629414f, 
    -0.35406193f, -0.22935551f, 0.10798753f, -0.23810595f, -0.40354934f, -0.18087000f, -0.18196376f, -0.02864935f, 
    0.13604648f, -0.19745800f, 0.22975494f, 0.05309713f, 0.21791282f, -0.28618163f, 0.11732236f, -0.21033815f, 
    0.10638769f, -0.05502772f, 0.27889147f, -0.06461429f, -0.51838559f, -0.26526627f, -0.07478955f, 0.15087683f, 
    -0.12225222f, 0.01965811f, 0.10219053f, -0.09715100f, -0.00039875f, 0.32058719f, 0.06964952f, 0.08632471f, 
    0.29386437f, -0.56209183f, -0.41985852f, -0.03217651f, -0.00168649f, 0.02596819f, -0.04852609f, -0.00090517f, 
    -0.09790283f, 0.09792212f, 0.20217384f, 0.22591145f, 0.10475708f, -0.88946718f, -0.38568369f, -0.58943230f, 
    -0.93735164f, -0.65556228f, 0.51558083f, -0.04518691f, -0.25096542f, 0.08617693f, 0.47413236f, -0.04333325f, 
    -0.13654566f, -0.22642104f, -0.12784405f, -0.06005093f, 0.17498103f, -0.20303151f, 0.08977283f, 0.15663052f, 
    -0.18020010f, 0.02791120f, -0.11869407f, -0.22190498f, -0.17274381f, -0.04216209f, 0.37688690f, 0.22578420f, 
    0.20835458f, 0.17060900f, -0.29668820f, -0.33818310f, -0.40134504f, -0.13183290f, 0.34245813f, -0.16612954f, 
    0.03795251f, 0.04853432f, 0.18478781f, -0.14039595f, -0.41219917f, -0.03489206f, 0.19231170f, 0.28641874f, 
    -0.04492432f, -0.06884512f, 0.08685953f, -0.05907193f, 0.11339329f, 0.28177014f, -0.07268110f, 0.12375229f, 
    -0.59913725f, 0.04128340f, 0.18514314f, 0.49826756f, 0.27408546f, 0.51212859f, 0.44494829f, -0.24566883f, 
    -0.34141713f, -0.29599571f, -0.33882236f, -0.01665077f, 0.02336328f, 0.17623357f, -0.20944025f, 0.12626459f, 
    0.06891944f, 0.03301026f, -0.20923717f, 0.36522585f, -0.32105580f, -0.45047137f, 0.15316536f, 0.15099947f, 
    -0.35192835f, -0.28588113f, -0.19857575f, -0.41936487f, -0.55060577f, -0.28876841f, -0.37871525f, -0.46150780f, 
    -0.35501492f, -0.49962333f, -0.15493494f, -0.01107667f, 0.49938101f, 0.41463917f, 0.02868327f, 0.14516658f, 
    -0.19634624f, -0.02590393f, 0.08903898f, 0.15494892f, 0.00326042f, 0.35019007f, -0.06917396f, -0.10716648f, 
    0.09371819f, -0.93298608f, -0.45206466f, -0.36988083f, 0.03101951f, -0.18124944f, 0.70472533f, -0.24500911f, 
    -0.38830689f, -0.29371163f, -0.44271591f, -0.35347897f, -0.29107097f, -0.10813180f, -0.49622485f, -0.42956117f, 
    -0.00296442f, -0.09073765f, -0.10491338f, -0.19839819f, -0.13346392f, 0.03315986f, -0.01999715f, 0.12510216f, 
    -0.04802346f, 0.03078118f, -0.04748875f, 0.58088338f, 0.25844729f, -0.29155222f, -0.27620557f, 0.42136765f, 
    -0.47843030f, -0.24834897f, -0.07164064f, -0.46418387f, -0.10181606f, 0.33451518f, -0.58378005f, -0.22835030f, 
    -0.03656625f, -0.30154595f, -0.07999379f, -0.15552433f, -0.09762095f, -0.28179479f, 0.07104139f, 0.05458163f, 
    0.00425381f, -0.04898960f, -0.07074396f, 0.72344327f, 0.34000215f, 0.28141493f, 0.34978640f, -0.00463448f, 
    -0.34613577f, -0.40693969f, -0.40449673f, -0.67649746f, -0.38703665f, -0.04647405f, -0.23616065f, 0.42292348f, 
    -0.19204493f, -0.13411650f, 0.08210874f, 0.18352067f, 0.23433115f, 0.16155912f, 0.12135869f, -0.15028009f, 
    -0.13937534f, 0.12710477f, -0.12253974f, -0.11595083f, -0.35132885f, -0.79158843f, -0.75211287f, -0.64839888f, 
    -0.18690261f, -0.02729290f, 0.11048015f, 0.49492279f, 0.24456729f, 0.13686411f, 0.23341747f, -0.09780402f, 
    -0.31364182f, -0.22818242f, 0.23194672f, -0.16519392f, -0.12952128f, -0.01843947f, 0.06646327f, -0.53876865f, 
    -0.41697183f, -0.21340333f, -0.24378701f, -0.23453844f, 0.05261128f, 0.19982935f, -0.04884499f, 0.28089598f, 
    0.10738940f, 0.09708148f, 0.43694419f, -0.30462241f, -0.10227854f, -0.05626509f, 0.21886766f, 0.18989699f, 
    0.05202341f, -0.17794646f, 0.01556081f, 0.08322473f, -0.26047680f, -0.25374469f, -0.18303226f, 0.23919272f, 
    0.03843901f, -0.32237899f, 0.20110653f, 0.17652607f, -0.16600655f, 0.11497767f, -0.52606487f, 0.07904015f, 
    0.22038068f, -0.41104269f, -0.30371338f, -0.02936235f, 0.30391860f, -0.22284727f, -0.13103256f, 0.33291754f, 
    0.29317585f, 0.39522985f, -0.15354511f, 0.12913807f, -0.12455055f, -0.34522173f, -0.09373606f, -0.30335546f, 
    -0.04499558f, -0.48889261f, -0.09935520f, 0.05906182f, 0.34985298f, 0.33057791f, 0.24666962f, 0.32547426f, 
    0.29912171f, 0.30318707f, 0.30860880f, 0.13999306f, -0.21798444f, -0.01143472f, 0.01185556f, 0.12742186f, 
    -0.01250079f, -0.24884740f, 0.09738596f, 0.01055112f, 0.08992262f, 0.14561762f, 0.04134439f, 0.13247140f, 
    0.05988557f, -0.15906315f, 0.05567548f, -0.16039267f, -0.13077532f, -0.01102784f, 0.04050308f, -0.24883074f, 
    0.24725516f, -0.08103999f, 0.18414238f, 0.40244344f, 0.57833892f, -0.45392266f, 0.06091343f, -0.39123109f, 
    -0.21589708f, 0.06639069f, 0.09777546f, -0.20021416f, 0.16240579f, 0.04865674f, 0.02700956f, -0.22388130f, 
    -0.10591169f, 0.05652234f, 0.19062820f, -0.09574600f, 0.06189309f, -0.00040072f, -0.24471115f, 0.13545871f, 
    0.07440557f, -0.96338463f, -0.60049313f, -0.27205777f, 0.43984398f, 0.46160305f, 0.09081247f, -0.24623881f, 
    0.15542401f, 0.62816381f, 0.52708399f, 0.14071544f, 0.14599323f, -0.25088868f, 0.04586273f, -0.25935811f, 
    -0.15491746f, 0.28516349f, -0.20505695f, -0.18732582f, -0.02621774f, -0.00746469f, -0.22364216f, -0.25387028f, 
    -0.15897462f, -0.18171066f, -0.42991281f, -0.51214516f, 0.06419662f, -0.51274472f, -0.34943971f, -0.21525878f, 
    -0.52483797f, -0.49140069f, -0.05831544f, -0.30713740f, 0.26991713f, -0.02481285f, 0.14807786f, 0.62750262f, 
    -0.16692904f, -0.03914382f, -0.09476291f, -0.26389673f, -0.41815013f, -0.35867742f, -0.02792914f, -0.14628716f, 
    -0.24454421f, -0.21448408f, -0.40789431f, 0.12578917f, 0.23120703f, 0.06451262f, -0.12518553f, -0.42414236f, 
    -0.05642328f, 0.24121675f, 0.19700561f, 0.19985458f, 0.07741986f, -0.19090272f, -0.08272950f, 0.24001755f, 
    -0.08166195f, -0.25530723f, 0.05574799f, -0.16775893f, -0.24531046f, 0.05189798f, -0.03319381f, 0.15749933f, 
    0.24495035f, 0.17281412f, -0.08885210f, 0.14594170f, -0.71457261f, 0.50899118f, 0.19415629f, -0.41716528f, 
    -0.40944424f, -0.14882192f, -0.00121713f, 0.07351262f, 0.97625887f, -0.27116868f, -0.08339849f, -0.40945536f, 
    0.29598269f, -0.53402430f, -0.13871691f, 0.34752196f, 0.17118460f, 0.13203633f, 0.04988088f, -0.04421348f, 
    -0.07157486f, 0.08454793f, -0.16343920f, -0.05648883f, 0.27408385f, -0.31431618f, 0.23348828f, 0.40670553f, 
    0.09662504f, 0.11510471f, -0.51440328f, -0.39307195f, 0.00045730f, 0.56909096f, -0.01638358f, -0.45835200f, 
    -0.38393581f, -0.11481056f, 0.39167413f, 0.11017014f, -0.02837639f, 0.04481753f, -0.04528698f, -0.14177045f, 
    0.26455820f, -0.32787007f, -0.21674179f, 0.03145116f, -0.09607249f, -0.27557078f, -0.17456377f, -0.00456242f, 
    0.45969602f, 0.22907686f, -0.37741858f, 0.06657144f, 0.32463962f, -0.02862800f, -0.02715031f, -0.41351259f, 
    -0.34000742f, 0.11085585f, -0.00755155f, 0.13901378f, -0.03149754f, 0.29038858f, -0.01704865f, -0.12299511f, 
    0.01672494f, 0.27908465f, 0.12547216f, -0.27429450f, -0.21253255f, 0.06830072f, 0.02085855f, 0.04770243f, 
    -0.08126765f, 0.01316531f, 0.01340027f, 0.11699732f, 0.32574651f, -0.08099293f, -0.00387194f, 0.38440925f, 
    0.21644810f, 0.30865675f, -0.18565123f, -0.19911012f, 0.36635372f, -0.37133437f, -0.16758606f, -0.08767258f, 
    0.09317266f, 0.05808169f, 0.21400885f, 0.12191696f, 0.17919154f, -0.13772450f, -0.11489937f, 0.10273761f, 
    -0.38722044f, 0.44055557f, 0.67412490f, 0.05241758f, -0.32845980f, -0.27077702f, -0.17437187f, -0.31860748f, 
    0.13316347f, -0.24436998f, -0.27082604f, -0.06801859f, -0.06882992f, -0.04928320f, 0.03253270f, 0.21195363f, 
    0.14707519f, 0.14483728f, -0.00106309f, -0.10777415f, -0.26057923f, -0.44261146f, 0.14123362f, -0.03074127f, 
    -0.22459875f, -0.08367709f, 0.05664364f, -0.29707029f, -0.54515767f, -0.13745037f, 0.15030256f, -0.16114692f, 
    0.31302035f, 0.41884539f, -0.15413037f, -0.11609568f, -0.20095801f, -0.29864234f, -0.42043120f, 0.21401118f, 
    0.05388716f, 0.37580919f, 0.32509977f, 0.09196130f, -0.16263270f, -0.11897887f, 0.31835631f, -0.23139511f, 
    -0.08683972f, 0.02858341f, -0.70103514f, -0.12386274f, 0.51978648f, -0.60264003f, -0.51764095f, -0.14924775f, 
    -0.04473493f, -0.03675014f, 0.11423537f, 0.18186255f, -0.28451574f, -0.21377343f, -0.33095315f, 0.21444210f, 
    0.03409687f, 0.15057459f, 0.12702368f, -0.12871294f, 0.03123929f, -0.14120060f, 0.06622305f, 0.15729780f, 
    0.26319715f, 0.27905592f, -0.11536453f, -0.62534606f, -0.12776072f, 0.17041658f, -0.04375402f, -0.46422520f, 
    -0.23150134f, 0.33152634f, 0.20816571f, 0.42161307f, 0.12045279f, 0.10603708f, 0.06048063f, -0.19304332f, 
    0.47069383f, -0.06015366f, -0.25857523f, -0.24338762f, -0.20252861f, 0.05412891f, 0.25530851f, -0.09185801f, 
    0.00835730f, 0.02916934f, 0.05971237f, -0.00450251f, 0.88506204f, 0.61811209f, 0.19313310f, -0.20285848f, 
    -0.39983952f, 0.25985211f, 0.19628681f, 0.14659134f, -0.21510775f, -0.10509122f, -0.21194658f, -0.08250539f, 
    0.19569512f, -0.08409029f, -0.40695697f, 0.11326895f, -0.12377458f, -0.23367871f, -0.03306552f, -0.18450843f, 
    -0.02177276f, -0.07814743f, -0.21326211f, -0.09627330f, 0.14124630f, -0.17128879f, 0.04443552f, -0.72903460f, 
    -0.47665948f, 0.01805247f, -0.27199101f, -0.59101874f, -0.52416033f, -0.57812965f, -0.33669165f, -0.06897293f, 
    0.26760054f, 0.30066788f, -0.33966845f, -0.21094267f, -0.04372178f, -0.32511926f, -0.19555014f, 0.00950957f, 
    -0.03141718f, 0.13024376f, -0.18927945f, -0.16078973f, 0.19155207f, 0.07316679f, -0.51111430f, -0.20605092f, 
    -0.28033388f, 0.60935938f, 0.45785469f, 0.19597249f, -0.28140089f, -0.44725928f, -0.49783126f, 0.22049057f, 
    0.05361603f, -0.32266921f, -0.05305912f, -0.00752771f, -0.10244329f, 0.01232186f, 0.00079814f, 0.15658395f, 
    -0.07786982f, 0.16573068f, 0.30911073f, -0.32984194f, 0.07975982f, -0.11081565f, 0.23706605f, -0.06471931f, 
    -0.02805745f, -0.22796956f, -0.09771120f, -0.55116653f, -0.68223417f, -0.46426994f, 0.23113412f, -0.47051397f, 
    -0.33340505f, 0.25511080f, -0.07098465f, 0.14537729f, -0.24930063f, -0.11844350f, -0.00272632f, 0.12340073f, 
    0.34854585f, 0.24318144f, -0.06143796f, -0.27979761f, -0.25272900f, -0.21420883f, -0.22472259f, 0.17555566f, 
    -0.08145209f, -0.00827375f, -0.06128492f, 0.12621337f, 0.29274896f, 0.41852772f, 0.02215277f, 0.01820876f, 
    0.25551498f, 0.18080321f, 0.44374934f, -0.23326634f, -0.33978456f, -0.20105386f, -0.16858469f, 0.02970410f, 
    0.07843392f, -0.10622098f, -0.24617353f, -0.30186152f, 0.25395066f, -0.31499001f, -0.06059100f, 0.20898852f, 
    -0.03994559f, 0.08584172f, 0.24399856f, -0.01875302f, -0.36245781f, 0.16612922f, -0.17249702f, -0.00623592f, 
    0.14230981f, -0.21702537f, -0.14498386f, 0.19868125f, 0.26379865f, 0.05072606f, -0.32665089f, -0.14698461f, 
    -0.03263634f, 0.00083310f, -0.07485975f, -0.04399494f, 0.11734661f, -0.19952862f, -0.26002237f, -0.38114348f, 
    -0.47214586f, -0.34644318f, 0.47630072f, 0.28950313f, 0.21634817f, 0.08850413f, 0.11500147f, 0.18335252f, 
    0.09341075f, 0.25333360f, -0.03708054f, -0.04988006f, 0.13567971f, 0.08587996f, -0.17803062f, -0.22537383f, 
    -0.22034563f, 0.14161885f, 0.09759790f, -0.06549777f, -0.04431223f, -0.20299861f, 0.06191130f, -0.04976494f, 
    -0.12709039f, -0.28338677f, -0.27645540f, -0.45107746f, -0.65669441f, -0.07001229f, 0.43264994f, 0.26965550f, 
    -0.36977935f, -0.94560933f, -0.57306564f, 0.50875866f, -0.62600845f, 0.34772724f, 0.51041132f, 0.11128493f, 
    0.33189419f, 0.01083055f, -0.11377028f, -0.11820970f, -0.10416647f, -0.58258951f, 0.06437238f, 0.23919159f, 
    0.12632115f, 0.15170093f, -0.41235703f, -0.11174410f, -1.01076543f, -0.68097639f, -0.08345945f, 0.45716858f, 
    -0.03936943f, -0.20384516f, -0.35272560f, -0.19252329f, 0.17134133f, 0.47702178f, 0.29862025f, 0.07580117f, 
    0.32023287f, 0.33357424f, -0.16401917f, -0.28407618f, 0.14454712f, -0.16139734f, 0.04989775f, 0.11526369f, 
    0.30904973f, 0.29209393f, -0.10077564f, -0.13527191f, 0.30685520f, 0.25793117f, 0.01515584f, -0.40640205f, 
    -0.01221833f, 0.29585794f, 0.07697625f, -0.07865953f, 0.03170035f, 0.16666600f, -0.21624520f, 0.18429658f, 
    -0.25973779f, -0.04517777f, 0.09805050f, 0.28496429f, -0.26374936f, 0.14403991f, -0.22945629f, -0.32476458f, 
    0.19571932f, 0.06548578f, -0.05293151f, 0.14549638f, -0.01084170f, 0.28488505f, -0.17403974f, 0.00889009f, 
    0.07478479f, -0.49662763f, -0.59400916f, -0.22497453f, -0.38723594f, -0.50823349f, -0.53542626f, -0.64638162f, 
    0.12687097f, -0.31613255f, -0.21471030f, -0.30592838f, 0.22440827f, 0.03196536f, 0.13280594f, -0.24898717f, 
    -0.46648386f, -0.35633624f, -0.19986360f, -0.12192448f, 0.18031025f, 0.24777171f, 0.19929126f, -0.02824708f, 
    -0.62953061f, -0.41988179f, -0.11197305f, -0.58069080f, 0.54556125f, 0.17569692f, 0.29371420f, 0.09373856f, 
    0.28564915f, 0.02320614f, 0.67103422f, -0.38806236f, -0.19427612f, -0.35793969f, -0.38722804f, 0.18934473f, 
    -0.08551878f, -0.09756060f, 0.20324375f, 0.12758265f, 0.06415685f, -0.03058269f, -0.00585770f, 0.12699185f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.00721163f, 0.40088600f, 0.17910494f, -0.04129981f, 0.26686233f, 0.18695658f, 0.26183489f, 0.48674175f, 
    0.30893525f, 0.31776428f, -0.01903574f, 0.08345593f, -0.28282323f, 0.03842401f, 0.06448865f, 0.19887388f, 
    -0.04530502f, 0.17231385f, 0.17833270f, 0.30388772f, 0.32280108f, 0.00969083f, 0.09806326f, 0.25269181f, 
    -0.18685167f, 0.09375928f, 0.01935303f, 0.21905008f, 0.07235430f, -0.12431312f, 0.11103802f, 0.25732711f, 
    -0.35119149f, -0.38842523f, -0.17751518f, -0.03287088f, 0.14266326f, 0.07626831f, 0.18297738f, -0.09931935f, 
    0.28457159f, 0.09196839f, -0.06662286f, 0.00319948f, 0.01168021f, 0.05088000f, 0.09099250f, -0.08180907f, 
    -0.04253306f, -0.14220995f, 0.00500699f, 0.19808638f, 0.36863977f, 0.09611164f, 0.31629497f, 0.12131779f, 
    0.02602969f, -0.00761468f, 0.10972743f, 0.32870054f, 0.15029077f, 0.32075194f, -0.25130603f, 0.17055875f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.48696846f, -0.03693184f, -0.28957587f, -0.14269038f, -0.03718169f, -0.09282802f, 0.04630129f, 0.00042762f, 
    -0.05304724f, -0.01433239f, 0.04808243f, 0.08342461f, -0.18278773f, -0.20253144f, -0.23946635f, 0.12253279f, 
    0.00703885f, 0.00596379f, -0.11733375f, 0.01575802f, -0.15391588f, -0.05464958f, -0.11195810f, -0.04196929f, 
    0.22678807f, 0.04509559f, 0.16131335f, -0.15220326f, 0.02577344f, -0.14488804f, 0.08281410f, -0.07381441f, 
    -0.01903217f, -0.03300462f, -0.03074080f, 0.00131300f, 0.07614376f, 0.01051088f, -0.02738719f, -0.34249645f, 
    0.10504029f, -0.08337604f, 0.15426618f, 0.07264701f, -0.01598808f, 0.03724008f, -0.03309209f, -0.02037456f, 
    -0.07324651f, -0.40595627f, 0.05061731f, -0.16948077f, 0.06284794f, 0.00238592f, 0.01488600f, -0.03143038f, 
    -0.00141860f, -0.04106699f, 0.03500773f, -0.02780720f, 0.36341578f, -0.00359049f, -0.21674633f, -0.11004314f, 
    0.07396728f, 0.11331028f, 0.03691202f, -0.04459483f, -0.02697985f, 0.01435188f, -0.01471077f, 0.00195870f, 
    0.03327943f, -0.34728840f, -0.23869288f, -0.08391545f, -0.07308217f, -0.12401980f, -0.04191674f, 0.03254842f, 
    -0.12068733f, 0.04402177f, -0.01806219f, 0.01329090f, -0.34324419f, 0.02778659f, 0.04575872f, -0.12445674f, 
    -0.00400711f, 0.02655311f, 0.03691740f, -0.02168666f, 0.02185669f, -0.06316248f, -0.02669793f, -0.11482100f, 
    0.11693781f, -0.43605819f, -0.36808735f, 0.07771377f, -0.06823814f, -0.01477875f, 0.10877302f, -0.15910971f, 
    -0.06230458f, -0.07050399f, -0.14173493f, 0.10282170f, -0.16778274f, -0.30283174f, 0.10987129f, -0.03020838f, 
    -0.09122626f, 0.03331457f, -0.05764703f, 0.01474995f, -0.28846753f, -0.09408948f, -0.06959597f, -0.15957381f, 
    0.12610257f, 0.12047721f, 0.16345844f, -0.17322540f, 0.06690876f, 0.05606360f, 0.04470365f, -0.05081519f, 
    -0.00198118f, 0.11928319f, 0.01487793f, 0.05909083f, -0.00710278f, -0.03224785f, -0.02618262f, 0.01779206f, 
    0.01629117f, -0.00759346f, 0.03613985f, 0.00224289f, -0.06063150f, -0.03333015f, -0.05773042f, -0.03137264f, 
    0.23866881f, 0.21919139f, 0.05199955f, -0.10539227f, 0.13912861f, 0.23310548f, 0.07318227f, 0.12002824f, 
    -0.01924270f, -0.00546437f, -0.08102890f, -0.10380042f, 0.04076154f, -0.29625612f, -0.30889180f, 0.10834089f, 
    0.11247199f, 0.05214277f, -0.07339242f, -0.07599579f, -0.02561828f, -0.21072763f, -0.20256925f, -0.10707626f, 
    -0.03756739f, 0.14942190f, -0.12754543f, 0.13326889f, -0.09334616f, -0.16359304f, -0.06968404f, -0.11582384f, 
    -0.03244919f, -0.11165230f, 0.04330572f, 0.05154632f, -0.22549078f, -0.02187586f, 0.20251660f, -0.18791692f, 
    -0.16936928f, 0.03816525f, 0.01328913f, 0.09832449f, -0.08918487f, -0.04030805f, 0.04464411f, -0.22148345f, 
    0.39742383f, 0.08583716f, -0.16886628f, -0.11717011f, -0.04419816f, -0.02417345f, 0.08872674f, 0.09846348f, 
    -0.00460691f, -0.03524448f, -0.01529801f, -0.01454981f, -0.22910003f, 0.03842683f, 0.07234990f, -0.01802773f, 
    -0.04507203f, -0.07121575f, 0.06901051f, -0.05729337f, -0.07713155f, -0.00723844f, -0.06970496f, 0.00357155f, 
    -0.05521844f, 0.02750472f, -0.30465990f, 0.00460866f, 0.00325818f, 0.05966248f, 0.02673759f, 0.00984846f, 
    -0.08422360f, -0.12103608f, -0.05154371f, -0.19510049f, -0.07608431f, -0.62586206f, -0.31460920f, 0.08387053f, 
    -0.10973426f, 0.01391964f, -0.10314532f, 0.07515135f, -0.11332177f, 0.06239895f, -0.03859655f, -0.18639901f, 
    -0.11108290f, -0.08450617f, 0.08929999f, 0.02230188f, -0.04674596f, -0.18101917f, -0.08186809f, -0.15994376f, 
    -0.03072635f, -0.00863027f, -0.03736053f, -0.06836007f, 0.21718311f, 0.06693874f, -0.02741687f, -0.01138715f, 
    0.06923981f, 0.09061953f, -0.07501216f, 0.04038509f, -0.10968727f, 0.08066955f, -0.00045370f, 0.06944955f, 
    0.04615514f, 0.18988577f, -0.83445007f, -0.00811786f, 0.00075993f, 0.07297871f, 0.01855189f, -0.13706650f, 
    -0.16336429f, -0.03414909f, -0.23234674f, -0.18413514f, -0.02646316f, -0.04009203f, 0.00908295f, -0.10968775f, 
    0.02790807f, 0.02654276f, 0.05443048f, -0.04307115f, -0.05595628f, -0.30381855f, -0.09211289f, -0.09286677f, 
    0.24953997f, 0.12572317f, -0.20424995f, -0.10474138f, 0.09468540f, 0.03415794f, -0.14991070f, -0.02637460f, 
    -0.00123891f, -0.00713001f, 0.04638916f, 0.04200372f, -0.00459875f, 0.03061222f, -0.00153631f, 0.03073189f, 
    -0.05212170f, -0.04724117f, 0.01097222f, 0.03303054f, -0.01746999f, -0.09744741f, 0.02776090f, -0.02444057f, 
    0.02171136f, 0.26720980f, -0.03117459f, -0.09090178f, -0.15853122f, -0.15951610f, -0.11973860f, 0.13803528f, 
    -0.12803906f, -0.18177034f, -0.11311936f, 0.02634246f, -0.13695781f, 0.02564817f, -0.02867076f, 0.07882337f, 
    -0.00865393f, -0.01003256f, -0.01941650f, 0.03047834f, 0.00551015f, 0.01606619f, -0.00966803f, 0.04699018f, 
    0.13284771f, 0.12367828f, -0.00367775f, -0.08320747f, 0.03255519f, -0.16058603f, 0.05134945f, -0.02360024f, 
    -0.00116543f, -0.02168627f, 0.07029158f, -0.06236250f, 0.24749117f, 0.15888566f, -0.00257591f, -0.11720437f, 
    0.07991269f, 0.24622086f, 0.12738910f, 0.06460093f, -0.01387228f, 0.00946868f, 0.09425620f, 0.02965918f, 
    -0.02889266f, 0.00720261f, 0.00478521f, -0.04176018f, -0.16791503f, -0.06432019f, -0.15369637f, -0.01929117f, 
    -0.03617275f, -0.02997124f, 0.01595347f, 0.00263626f, 0.23582250f, -0.61623442f, -0.20432226f, -0.10516735f, 
    -0.02499055f, -0.00316332f, 0.04287161f, 0.07460736f, 0.04756277f, -0.01329421f, -0.03850881f, 0.01703673f, 
    0.35803059f, 0.14846064f, -0.09319995f, -0.20106260f, 0.05223811f, 0.12688252f, 0.00949006f, -0.00826340f, 
    -0.01134115f, 0.01145130f, 0.00129442f, 0.04513001f, 0.40124816f, 0.27147132f, -0.17815191f, -0.23314281f, 
    0.02602256f, 0.18188734f, 0.08083623f, 0.09869580f, -0.00618648f, -0.00975834f, -0.02183149f, -0.00243946f, 
    0.07587809f, 0.23687488f, -0.28658864f, 0.07562852f, -0.05002479f, -0.02575947f, -0.04831330f, -0.06025010f, 
    -0.06441174f, 0.02140478f, 0.00770152f, -0.04433233f, 0.06424360f, -0.00217059f, 0.00613523f, -0.04140195f, 
    0.16527370f, 0.00008712f, -0.00343557f, 0.07162187f, -0.01498854f, 0.05955823f, -0.00558936f, 0.02880181f, 
    0.22156835f, 0.03320396f, -0.05533643f, -0.07119121f, 0.09031126f, 0.07142631f, -0.00790277f, -0.04538316f, 
    -0.03407407f, -0.09731150f, -0.00423804f, 0.09957506f, -0.22562201f, -0.26734853f, -0.01769426f, -0.04513388f, 
    0.02235789f, 0.01842802f, 0.02762251f, 0.01737005f, -0.01980608f, -0.00655617f, -0.00222256f, -0.08587088f, 
    -0.01813428f, -0.19663510f, 0.04396898f, -0.03194079f, 0.04692077f, 0.01915648f, -0.03316269f, -0.06192477f, 
    -0.09230292f, -0.03510468f, -0.23351683f, -0.16698377f, -0.08409091f, -0.03849065f, 0.01028283f, 0.08462626f, 
    0.07752326f, 0.00104527f, 0.00530794f, 0.00970500f, 0.01864367f, 0.01008429f, 0.01759242f, 0.02727024f, 
    -0.41126996f, 0.00325632f, 0.12120877f, -0.12862964f, -0.01904861f, 0.01799709f, -0.10495596f, -0.01407929f, 
    -0.02909184f, 0.02611654f, -0.02359251f, 0.03061341f, 0.17929901f, 0.27239338f, 0.12993053f, -0.05048444f, 
    -0.00726088f, 0.03838867f, 0.09905842f, 0.03585047f, -0.03548197f, 0.16670845f, 0.05411152f, -0.11543767f, 
    0.23289391f, 0.16002402f, -0.02472316f, -0.15757026f, -0.07607874f, -0.03127985f, -0.03622836f, 0.16525379f, 
    -0.06186704f, -0.16290739f, -0.08586046f, -0.04806293f, -0.10276467f, -0.11769825f, 0.04683919f, -0.06594380f, 
    0.03735639f, 0.01986391f, 0.01940941f, 0.03318596f, 0.01201521f, 0.00943768f, -0.04173838f, -0.00717670f, 
    -0.04681152f, 0.19194730f, 0.10863671f, -0.22582786f, -0.24064945f, 0.02275065f, -0.08578728f, 0.09166184f, 
    0.08241610f, 0.02264532f, 0.08264228f, -0.16365702f, -0.52044213f, 0.16214748f, 0.26213881f, -0.16536592f, 
    0.01649798f, -0.08564604f, -0.01173695f, 0.02132989f, 0.00972453f, -0.03928936f, -0.04532427f, -0.04913136f, 
    -0.05173271f, -0.16322629f, 0.01508687f, 0.00626098f, -0.00776936f, 0.01038346f, -0.10820384f, -0.04201374f, 
    -0.04100664f, -0.01744686f, 0.05762246f, -0.07163376f, -0.00444893f, -0.01133143f, -0.02529522f, 0.00185985f, 
    0.02515729f, 0.04615580f, 0.00618308f, 0.00830361f, -0.00642071f, 0.07763725f, -0.14056231f, -0.21856445f, 
    -0.03170078f, 0.05704708f, -0.01913121f, -0.08395814f, -0.10146790f, 0.07420877f, -0.08489630f, 0.10065416f, 
    -0.02160103f, -0.06877532f, 0.00978178f, 0.05739777f, 0.09852195f, -0.00253065f, 0.00955974f, 0.00621666f, 
    -0.13332173f, 0.04410993f, -0.02495376f, -0.00504141f, 0.06725326f, 0.11175413f, -0.01526333f, 0.06640653f, 
    0.09204044f, 0.08187421f, 0.08386288f, -0.05525317f, -0.00358623f, 0.10869526f, -0.05283529f, 0.01617197f, 
    -0.02093105f, -0.00506868f, 0.00825897f, -0.04003126f, -0.17330468f, -0.26611170f, 0.10118523f, 0.02437641f, 
    0.02515642f, -0.00746634f, 0.01656366f, 0.03090966f, -0.06169608f, -0.09664890f, -0.17556664f, -0.02925769f, 
    -0.56591946f, -0.37301943f, -0.40195990f, 0.43507749f, 0.01764225f, 0.03080142f, 0.02638880f, 0.00003615f, 
    -0.02588535f, -0.02008992f, -0.00394423f, 0.04026832f, 0.29874280f, 0.19373272f, -0.28928512f, -0.07624216f, 
    0.13915835f, 0.03453260f, -0.01498339f, -0.01355401f, 0.01643307f, -0.04813933f, 0.02648525f, 0.01407760f, 
    0.29083276f, 0.18775874f, -0.03777463f, -0.22993340f, 0.03372334f, -0.08189199f, -0.04042342f, -0.09522431f, 
    -0.05102691f, -0.02471905f, 0.01470938f, 0.01331114f, 0.16916473f, 0.13838845f, -0.01688505f, -0.21683119f, 
    0.16201919f, 0.03607273f, 0.07527874f, 0.13848926f, 0.03909536f, 0.03567761f, 0.00759006f, 0.02781240f, 
    -0.25110063f, -0.43570513f, 0.00591232f, -0.13262005f, -0.02401590f, 0.04423394f, 0.04035572f, 0.04722331f, 
    0.00098112f, 0.04842311f, 0.00230809f, 0.02774996f, 0.01797255f, 0.01527943f, -0.02497423f, 0.07858549f, 
    0.06996566f, -0.05565657f, -0.10662790f, -0.06045947f, 0.01526493f, 0.06623419f, 0.21821295f, 0.03607355f, 
    -0.16099934f, -0.10551880f, -0.05341776f, 0.06919503f, -0.00442333f, 0.05764557f, 0.00680548f, -0.01923280f, 
    0.01383178f, -0.01038012f, -0.01506447f, 0.01106200f, 0.22868547f, 0.28090295f, -0.02353897f, -0.32721668f, 
    -0.04535424f, 0.06657842f, 0.01387800f, 0.05519012f, 0.02986392f, 0.04102044f, -0.02093470f, -0.06883913f, 
    0.07306127f, 0.24718851f, 0.18046294f, -0.12572840f, -0.09607594f, -0.00043460f, 0.12719962f, 0.02758489f, 
    -0.03563898f, -0.13594271f, -0.03030495f, -0.06858669f, -0.08807085f, -0.02869599f, -0.06826275f, 0.00493480f, 
    -0.05028940f, 0.04946479f, -0.05336772f, -0.04306017f, -0.05393947f, 0.01769826f, -0.13708584f, -0.13486329f, 
    0.20269302f, 0.07824366f, -0.18470442f, -0.21520290f, 0.06168797f, 0.10107500f, -0.03950727f, 0.05839575f, 
    -0.06827097f, -0.01075327f, 0.03145067f, -0.06280190f, 0.05273820f, -0.16092908f, -0.21578325f, -0.04697992f, 
    0.05189734f, 0.04184208f, 0.03919289f, -0.03318203f, -0.01733409f, 0.19586897f, -0.05510883f, -0.19554305f, 
    -0.09567598f, -0.53309023f, 0.43024039f, 0.11885912f, 0.02582465f, -0.01814322f, 0.02925771f, -0.04994025f, 
    0.00979447f, 0.02523316f, 0.10087448f, -0.16467004f, 0.48353261f, -0.40190607f, -0.07207211f, -0.19772343f, 
    -0.01003692f, 0.01074435f, 0.00725024f, -0.01629317f, 0.12945642f, -0.16263460f, -0.10497618f, -0.03144811f, 
    -0.30248779f, 0.14261819f, -0.11872478f, -0.05699908f, -0.04756775f, 0.15985332f, 0.12151046f, -0.07742299f, 
    0.06562251f, -0.00732470f, 0.06803204f, 0.04081700f, -0.04127653f, -0.07977837f, -0.25743484f, -0.36768514f, 
    0.00090332f, -0.05793897f, -0.10618270f, 0.00749953f, -0.02176524f, -0.09058979f, 0.06649093f, -0.03755378f, 
    0.21190394f, 0.04009359f, 0.23438765f, -0.19937161f, -0.01455747f, 0.04745363f, -0.11390557f, -0.04512740f, 
    0.05645092f, 0.01776303f, 0.00268580f, -0.02977800f, 0.36283416f, -0.10087947f, 0.11243977f, -0.11078572f, 
    0.05600249f, -0.06493966f, -0.00332574f, 0.05742353f, -0.00090845f, -0.10891185f, -0.00891071f, -0.04221437f, 
    0.26206037f, -0.03279964f, 0.13174982f, -0.16324575f, -0.10710813f, -0.04747961f, 0.00610747f, 0.03340770f, 
    -0.05724833f, 0.05115726f, 0.09765012f, 0.00956132f, 0.14148580f, 0.10064501f, 0.05679064f, 0.12410553f, 
    -0.03387312f, -0.00436378f, -0.02329659f, -0.02688933f, 0.07535692f, -0.07516810f, 0.09068682f, 0.05942379f, 
    0.63020748f, -0.29584226f, -0.02629913f, 0.16885050f, -0.04585956f, -0.12114800f, -0.04902463f, -0.08133072f, 
    0.04909151f, -0.09314547f, 0.17584187f, 0.03684612f, 0.16806646f, -0.11054125f, 0.11962870f, -0.05115410f, 
    -0.03453453f, 0.16256556f, 0.11614839f, -0.25695214f, 0.13548358f, -0.04047837f, -0.09651993f, 0.18828189f, 
    -0.55803263f, 0.15463562f, -0.07433485f, -0.08678968f, -0.10145396f, 0.03536820f, 0.01022604f, 0.03390205f, 
    -0.10962336f, -0.01356852f, 0.02969139f, 0.04606958f, 0.12850055f, 0.05350710f, 0.04940823f, 0.07895785f, 
    -0.00790604f, -0.05009002f, -0.03891834f, -0.01711490f, 0.01528504f, 0.03093164f, 0.01721542f, 0.00430847f, 
    0.37200174f, 0.25961661f, 0.20040761f, 0.19585077f, 0.16007873f, 0.12473780f, -0.14762276f, -0.01956027f, 
    0.01874099f, 0.02402021f, -0.01126841f, -0.01962858f, 0.25299534f, -0.12836345f, -0.06190964f, -0.31614858f, 
    -0.02579893f, 0.01683089f, 0.05514794f, 0.01946557f, 0.07836507f, 0.07620038f, -0.02762297f, 0.02511413f, 
    -0.19138061f, -0.61887944f, 0.03355396f, -0.06800661f, 0.06009477f, 0.11597677f, -0.08199718f, -0.05176625f, 
    -0.06373674f, -0.11660757f, -0.12414623f, 0.01152354f, -0.34992960f, 0.21409538f, 0.05997675f, -0.08434519f, 
    0.12199465f, -0.04846892f, -0.03298812f, -0.02482526f, -0.01431550f, 0.03284191f, 0.00579505f, -0.09576631f, 
    -0.00554827f, -0.02736806f, -0.11127129f, 0.02130573f, -0.14850253f, -0.07647369f, 0.02725824f, 0.04205157f, 
    0.07119446f, -0.06367237f, -0.07965337f, 0.01940886f, 0.01674428f, 0.02766393f, -0.10129326f, 0.09170059f, 
    0.01821214f, -0.02506514f, -0.12232177f, 0.07388664f, 0.08613577f, 0.00173319f, 0.06171215f, -0.13490331f, 
    0.23249643f, -0.09029779f, -0.02460092f, 0.07749865f, 0.18633425f, -0.00628461f, 0.06558340f, -0.01112940f, 
    0.01613854f, 0.03648642f, 0.01938946f, -0.12488665f, 0.24724637f, -0.08371167f, 0.05064477f, -0.51218927f, 
    -0.01642703f, -0.12032159f, -0.00192269f, 0.00037472f, 0.03903465f, -0.07986510f, 0.04143224f, 0.00536925f, 
    0.04466608f, -0.04684145f, 0.04330002f, -0.07868090f, -0.03095485f, 0.19098964f, -0.09856978f, -0.00212516f, 
    -0.07023320f, 0.08255159f, 0.02841227f, -0.02834616f, -0.07596578f, 0.01137654f, -0.02442669f, -0.07451095f, 
    0.05008958f, 0.14185564f, 0.10124794f, -0.31238076f, 0.11110832f, 0.16708656f, 0.01923208f, -0.12356681f, 
    -0.00140215f, -0.34156525f, -0.18397196f, 0.07265259f, -0.10802279f, -0.09399929f, 0.03207386f, 0.06681149f, 
    -0.00798602f, 0.19294035f, -0.00803256f, 0.11681191f, -0.09367941f, -0.09771475f, 0.00845564f, 0.10242078f, 
    -0.09399834f, -0.07309282f, 0.05339632f, 0.05168492f, 0.16740957f, 0.09441305f, 0.24980853f, 0.00143329f, 
    0.09597676f, 0.15505113f, 0.11296008f, 0.15484233f, -0.12981021f, 0.15347813f, -0.16285740f, -0.24733050f, 
    -0.04219275f, -0.01500488f, -0.09037646f, 0.02244007f, -0.03860642f, 0.04904366f, 0.07286808f, 0.02796543f, 
    0.05974168f, 0.00936890f, 0.01956415f, 0.04523667f, -0.00267535f, 0.01623144f, -0.07462451f, 0.05058725f, 
    -0.08929963f, -0.08575098f, -0.04472117f, 0.02701342f, 0.12007084f, 0.03426645f, -0.05779912f, -0.22207616f, 
    0.04055883f, -0.09511953f, -0.00398847f, 0.08514460f, 0.18317181f, -0.05468808f, 0.05087392f, -0.12943685f, 
    -0.06745277f, -0.12374825f, -0.04510496f, -0.04552766f, -0.05278234f, 0.08235595f, -0.06415831f, 0.04927043f, 
    0.01487767f, 0.02542790f, -0.15777938f, -0.00854915f, 0.08080693f, 0.17568049f, 0.07306628f, 0.02125633f, 
    -0.04755413f, 0.04397872f, -0.17560902f, 0.12836361f, 0.15913934f, 0.22753581f, 0.02053618f, 0.00838677f, 
    -0.02645853f, 0.06014344f, -0.18645985f, -0.19852270f, -0.04563208f, 0.05511482f, -0.03999433f, -0.11597987f, 
    -0.04346813f, 0.02468046f, 0.04789057f, -0.02496669f, 0.20644015f, -0.09222654f, 0.01778985f, -0.06926080f, 
    -0.08981790f, -0.06496655f, 0.02050200f, 0.04862474f, 0.28623196f, -0.05963157f, 0.42185858f, 0.26544794f, 
    -0.06640760f, -0.01522659f, 0.00892274f, -0.04778594f, 0.24992344f, -0.05398293f, -0.06225757f, -0.15645874f, 
    -0.06675985f, -0.01272535f, 0.29250723f, 0.32990500f, -0.12239517f, -0.09409311f, -0.16358401f, 0.01639386f, 
    -0.07455745f, -0.05014405f, 0.00702268f, 0.01914264f, 0.19785622f, 0.22401202f, 0.24476328f, 0.05821208f, 
    0.08229980f, -0.03860606f, 0.05624326f, 0.22850840f, 0.04822012f, 0.03634363f, -0.10774988f, -0.05596745f, 
    -0.09729551f, -0.25943884f, -0.50386268f, -0.24835202f, 0.06475276f, -0.05144775f, 0.07115876f, 0.11713324f, 
    0.00429729f, -0.05809846f, 0.01749672f, -0.13503769f, 0.00087774f, 0.19903950f, -0.29420814f, -0.28299060f, 
    -0.21559842f, -0.02478695f, -0.10164405f, -0.06166117f, -0.02851644f, 0.02393383f, -0.03615070f, 0.05754938f, 
    -0.10585392f, 0.06278775f, -0.15937711f, -0.16808090f, -0.01273504f, 0.07997160f, -0.04585094f, -0.28716555f, 
    -0.06169150f, 0.07159212f, -0.25190419f, -0.05142714f, 0.21609677f, 0.21425228f, -0.05137150f, 0.13900384f, 
    -0.04616955f, 0.03896951f, -0.03272262f, -0.02282393f, -0.01587091f, 0.05006216f, 0.06833792f, 0.02114727f, 
    -0.03198867f, -0.42185438f, -0.08379280f, -0.12800397f, -0.02771527f, 0.07859413f, 0.08211467f, 0.12791887f, 
    0.05690682f, -0.08130718f, -0.00950003f, 0.07634823f, 0.05461552f, 0.10622387f, 0.11202580f, 0.10756341f, 
    0.01431567f, -0.04298544f, -0.06015074f, -0.01241215f, 0.04336114f, 0.09087943f, -0.01978420f, -0.02612915f, 
    0.03159648f, 0.37680599f, -0.13817893f, 0.01641760f, -0.07229400f, -0.09065839f, -0.01436594f, -0.04000174f, 
    0.01387954f, -0.05781651f, 0.04931881f, -0.05453214f, 0.04980084f, 0.04959432f, -0.05304083f, -0.06998219f, 
    -0.08509945f, -0.03805003f, 0.00154148f, -0.04307768f, -0.15704642f, -0.41025215f, -0.28698209f, 0.11411935f, 
    -0.11886048f, -0.16709764f, -0.09442908f, 0.14517418f, 0.08700730f, 0.00191462f, 0.05217194f, 0.20627706f, 
    -0.07330217f, -0.02166410f, 0.03643163f, -0.12767684f, 0.10042404f, -0.01728908f, 0.11570479f, 0.06523344f, 
    -0.05829713f, 0.00458147f, -0.00340651f, 0.00455761f, -0.08849567f, -0.03106293f, -0.03641786f, -0.03029143f, 
    -0.26659244f, 0.04638784f, 0.08088408f, -0.22403921f, -0.08000189f, 0.14286101f, -0.12536432f, -0.18170717f, 
    -0.00905465f, -0.01037413f, -0.18986163f, -0.09679686f, -0.11232217f, 0.09023620f, -0.01024867f, -0.09659534f, 
    0.00402422f, -0.00278750f, -0.06098322f, 0.01786145f, 0.04665700f, 0.06186618f, -0.03924130f, -0.04674193f, 
    -0.02864555f, -0.07259987f, 0.07132187f, -0.05357385f, -0.10466599f, 0.05247936f, -0.02196228f, -0.05443652f, 
    0.18972231f, -0.10800917f, 0.04379066f, -0.08813077f, 0.00492967f, 0.07835200f, 0.01111116f, 0.05580300f, 
    0.00058141f, 0.01061267f, -0.00924189f, -0.03259483f, 0.06604503f, 0.09032350f, -0.00937078f, 0.00490431f, 
    -0.06616272f, -0.05920327f, 0.10301165f, -0.29870722f, 0.18793221f, 0.00996132f, -0.20733969f, 0.07141151f, 
    0.03774215f, 0.13915007f, 0.02598424f, -0.04875524f, -0.00525414f, 0.16377524f, 0.01656180f, -0.06814762f, 
    0.12748428f, 0.03914597f, -0.04801906f, -0.28536990f, -0.11806276f, -0.01912838f, -0.13799584f, -0.16055171f, 
    0.05067666f, 0.00709101f, 0.21330580f, -0.00599367f, 0.15183920f, -0.12213014f, -0.08391891f, 0.21979892f, 
    -0.03130720f, -0.06060211f, 0.03227960f, -0.03547035f, -0.20385237f, -0.20684737f, -0.13899925f, -0.12627937f, 
    -0.01162635f, -0.01133921f, 0.05049185f, -0.01867657f, 0.09822411f, -0.08687776f, 0.09075958f, 0.03994961f, 
    0.59598833f, 0.24763988f, 0.23497732f, 0.19716109f, -0.01571376f, -0.01754373f, -0.01265349f, 0.00942289f, 
    -0.03582081f, 0.00374886f, -0.01218322f, 0.05937115f, -0.00171787f, -0.16228205f, -0.02317921f, 0.31889406f, 
    -0.03669683f, 0.17334852f, -0.17567873f, 0.01589542f, 0.00980032f, 0.02499245f, -0.00777224f, 0.09323902f, 
    -0.29831445f, 0.09915299f, -0.20531991f, -0.04528661f, 0.01878968f, -0.11795801f, 0.12293626f, -0.09535783f, 
    0.08925658f, -0.02702943f, -0.01399784f, -0.00222208f, -0.05346710f, 0.07633638f, 0.02574539f, -0.22735755f, 
    -0.15436108f, -0.03240231f, -0.13717809f, -0.24967018f, 0.04065407f, -0.01140777f, -0.04673754f, 0.07215950f, 
    0.08271939f, 0.07710209f, 0.14955667f, 0.29451278f, 0.00514652f, 0.01934722f, 0.03050142f, -0.02040365f, 
    0.08960380f, 0.01021255f, 0.03647766f, 0.07728212f, -0.00957290f, -0.09897045f, 0.01314624f, -0.03071536f, 
    0.02209670f, -0.05589671f, -0.11180537f, 0.03761354f, -0.34473529f, -0.16911896f, -0.28893390f, -0.06764273f, 
    0.19500762f, 0.09664693f, 0.10102813f, 0.12344614f, 0.00046250f, 0.01641978f, -0.03112407f, 0.01135943f, 
    0.00168819f, 0.04902499f, -0.10125839f, 0.16376950f, -0.62871152f, 0.06013310f, -0.37684453f, 0.02077274f, 
    0.13228676f, -0.05218993f, 0.11409469f, 0.18077618f, 0.00080810f, 0.00198761f, -0.00297238f, 0.03882202f, 
    -0.26395532f, 0.15605167f, -0.12734535f, 0.01593846f, -0.01645052f, 0.05789917f, 0.07234909f, 0.01018033f, 
    -0.12930056f, -0.05071483f, 0.06002121f, 0.03502398f, -0.01222015f, 0.02443430f, 0.03090793f, 0.13116115f, 
    -0.01205811f, -0.00583598f, 0.10919718f, 0.01604760f, -0.00057798f, -0.00592893f, 0.02107797f, -0.02626064f, 
    0.04714857f, -0.00794961f, 0.18043697f, -0.29652449f, 0.05173916f, 0.02305310f, 0.01576881f, 0.08534756f, 
    -0.00422856f, 0.06056754f, 0.02367183f, 0.06061510f, 0.27717850f, 0.04165061f, -0.32621467f, -0.23975579f, 
    -0.01476500f, -0.04921234f, 0.06421517f, 0.02182294f, -0.06279940f, 0.05281218f, -0.19428194f, 0.05218567f, 
    0.26563710f, 0.20065506f, -0.37363833f, 0.02423397f, 0.06143774f, -0.10129255f, 0.06242929f, 0.00492733f, 
    -0.02861978f, 0.04559854f, 0.01224720f, -0.06532536f, -0.05478194f, 0.33019683f, 0.09512164f, 0.02772662f, 
    -0.02055939f, 0.05722551f, 0.02815035f, -0.23189519f, 0.05027691f, 0.10604440f, 0.01186241f, 0.22954710f, 
    0.01274750f, 0.14149073f, -0.11344931f, -0.09787460f, 0.11271875f, -0.00056096f, 0.11700578f, 0.12738404f, 
    -0.05476253f, -0.00610583f, 0.05536521f, -0.12715335f, -0.81432027f, -0.04264070f, -0.16948965f, -0.29565445f, 
    -0.08277332f, -0.17474425f, -0.05374294f, -0.14799854f, -0.02964576f, -0.00682605f, 0.04682866f, -0.00298111f, 
    -0.09029857f, 0.03694637f, 0.07651537f, -0.22840734f, 0.08038487f, 0.00630937f, -0.14998974f, 0.05029995f, 
    0.05116246f, -0.05610809f, 0.06349789f, -0.10175765f, 0.14166969f, -0.22819726f, 0.74997461f, 0.32883978f, 
    0.02545321f, -0.02546713f, 0.03202242f, 0.07213925f, 0.10464438f, -0.00090383f, 0.03316307f, -0.05610625f, 
    -0.15301527f, 0.03172392f, 0.04734000f, -0.28248405f, -0.05529601f, -0.05644289f, -0.03689370f, -0.13976991f, 
    0.18286705f, 0.04870568f, 0.01222330f, -0.13651437f, -0.08518612f, 0.02964471f, -0.12313335f, 0.10846700f, 
    -0.01545610f, -0.00951123f, 0.06735092f, 0.06826542f, -0.06845095f, -0.08601938f, 0.08714268f, -0.09659541f, 
    -0.22183220f, -0.00358033f, 0.19533147f, -0.29952615f, 0.06459325f, 0.04849536f, -0.13445191f, -0.07006148f, 
    0.04810255f, 0.02050856f, 0.09044654f, -0.04555311f, -0.06299099f, 0.20194927f, -0.06238082f, -0.05036211f, 
    -0.04311251f, 0.02355243f, 0.06140150f, -0.10106894f, 0.01874556f, -0.01840115f, -0.18373437f, 0.13806072f, 
    -0.24977913f, 0.01049711f, 0.12959370f, 0.33443230f, 0.02773302f, 0.01099165f, 0.00720714f, -0.09362446f, 
    0.05317948f, -0.16305012f, 0.09954919f, -0.14223726f, 0.00518304f, -0.07313002f, 0.02814512f, -0.08416028f, 
    -0.02268333f, -0.07513718f, -0.01753521f, 0.04611069f, -0.04166926f, -0.06447705f, 0.02111029f, 0.01455702f, 
    -0.17076020f, 0.09777071f, 0.31006503f, 0.39265594f, -0.07912081f, -0.01231894f, 0.05089862f, -0.01789877f, 
    -0.03981931f, -0.05230764f, -0.03045353f, -0.01111697f, -0.13415925f, 0.18074845f, 0.28772131f, -0.00461819f, 
    0.00567610f, 0.03283680f, -0.08754005f, -0.07850716f, -0.29745388f, -0.11523403f, -0.06846184f, -0.26069441f, 
    0.36447966f, -0.24419259f, 0.04538216f, 0.04665249f, 0.02052768f, -0.06470294f, -0.06604829f, 0.01240079f, 
    -0.07999396f, 0.00128785f, 0.11444651f, -0.00088864f, 0.34349081f, -0.07254679f, -0.13304797f, 0.25903022f, 
    0.07164203f, 0.10004028f, 0.00982171f, -0.09822645f, -0.15926985f, 0.07703946f, -0.07244125f, 0.17922765f, 
    -0.22803454f, -0.04583845f, -0.14104538f, 0.07071799f, -0.07092487f, -0.02563394f, 0.03549229f, 0.14436820f, 
    0.02363300f, -0.01228208f, 0.04413807f, -0.03664861f, 0.11797424f, -0.11786994f, -0.09128095f, -0.03043418f, 
    0.07341879f, 0.02343546f, 0.03516509f, -0.02611301f, -0.07763859f, 0.05662760f, 0.01231702f, 0.05562252f, 
    -0.06275712f, -0.00689427f, 0.07242201f, -0.21509363f, -0.05337466f, -0.00743974f, 0.03996509f, -0.05451217f, 
    0.00077266f, -0.07848706f, -0.09894584f, -0.06501905f, -0.30461445f, 0.24631761f, 0.00178625f, -0.39845771f, 
    0.04247801f, -0.17788297f, -0.30511773f, -0.02413153f, 0.06845057f, 0.06299922f, -0.10586383f, 0.10510658f, 
    -0.03956936f, 0.04276394f, -0.03863680f, 0.00975833f, 0.11359912f, 0.20557959f, -0.07717495f, 0.08860038f, 
    0.04109826f, 0.00739960f, 0.05642588f, -0.05033511f, -0.21092115f, 0.14921047f, 0.06320245f, 0.12385055f, 
    -0.03225662f, -0.06059282f, 0.16273923f, -0.04991516f, 0.02899073f, 0.10538784f, -0.04729626f, 0.09313735f, 
    0.11317720f, -0.09787866f, -0.09811208f, -0.13012792f, 0.01306944f, -0.25851339f, -0.02597979f, 0.21275546f, 
    0.02851355f, 0.04043145f, -0.25444946f, -0.09099797f, -0.12049577f, 0.01628758f, 0.00517736f, 0.02387679f, 
    0.02774802f, -0.02245700f, 0.06472895f, 0.20516060f, -0.15588871f, 0.10391167f, -0.22422904f, -0.00896908f, 
    -0.44532946f, 0.02817256f, -0.03063104f, -0.31310189f, 0.03810686f, -0.18541425f, 0.14814140f, -0.03604448f, 
    0.01229693f, 0.01282668f, -0.08825394f, 0.00137886f, -0.07012930f, -0.03460567f, -0.03921580f, -0.01978627f, 
    0.02033165f, -0.02236059f, 0.00532634f, 0.02329631f, 0.01168504f, -0.02540684f, 0.01762372f, -0.00453468f, 
    0.10710128f, -0.07061239f, 0.24097534f, -0.08267145f, 0.01214913f, 0.01919249f, -0.00396609f, -0.11214747f, 
    0.00817224f, -0.06148466f, 0.07555855f, -0.05601488f, -0.20033902f, -0.14475657f, 0.20468137f, -0.20006914f, 
    0.04122020f, 0.06276533f, 0.01038481f, 0.06789160f, -0.05973824f, -0.04185146f, -0.03366569f, 0.02643895f, 
    0.00073635f, 0.00711147f, 0.02064775f, 0.03571485f, 0.03145352f, -0.03454241f, -0.05696763f, 0.00584449f, 
    -0.02263577f, -0.02173429f, 0.04346253f, -0.01912383f, 0.14228278f, 0.43358263f, 0.44627726f, 0.49761972f, 
    -0.01907666f, -0.07821602f, 0.00139658f, 0.16214472f, 0.01811169f, -0.00521470f, 0.00838148f, 0.05721483f, 
    -0.16436501f, 0.02672609f, 0.12629600f, -0.07445585f, -0.08893903f, 0.05615538f, 0.09409897f, 0.12252992f, 
    0.02703886f, -0.09375060f, 0.03210452f, -0.00144664f, 0.18157935f, 0.10057574f, -0.12476792f, 0.17851079f, 
    -0.00572920f, 0.01017223f, 0.03640675f, 0.05934462f, -0.04055015f, 0.08059378f, 0.04203884f, -0.11435059f, 
    -0.74102730f, -0.86990738f, -0.33849826f, -0.01885975f, -0.06234551f, -0.14144269f, -0.06726891f, -0.11660279f, 
    0.05628269f, 0.02483583f, 0.05520364f, -0.06533053f, -0.76541841f, -0.39003643f, -0.05518530f, 0.07004721f, 
    -0.03585107f, -0.15894213f, 0.03556831f, -0.07641071f, -0.01862460f, -0.01518766f, -0.02068605f, -0.04374914f, 
    0.06269029f, 0.14871243f, 0.11043706f, -0.50998420f, 0.01613873f, -0.01204971f, -0.02787110f, 0.06403302f, 
    0.01848866f, 0.02156426f, -0.08624155f, 0.10178313f, -0.49811488f, -0.08010128f, -0.03438972f, -0.36592358f, 
    -0.19220790f, -0.19329982f, -0.08451463f, -0.26893312f, 0.05212775f, -0.03526224f, 0.02906774f, -0.03055308f, 
    -0.09125078f, 0.49081275f, 0.27139401f, 0.01542392f, -0.03041491f, 0.04493918f, 0.09285480f, 0.12165464f, 
    -0.07470366f, 0.03899327f, 0.01936683f, 0.04336167f, -0.28744942f, 0.14929523f, -0.10073251f, -0.15888801f, 
    -0.02602139f, 0.00166108f, 0.01874408f, 0.05718255f, 0.03258934f, -0.01330040f, 0.03964750f, -0.05253359f, 
    0.22079767f, -0.11789759f, -0.03474776f, -0.13910949f, 0.10552725f, 0.01062902f, -0.08109993f, -0.00533398f, 
    -0.01229790f, -0.11418969f, -0.06862289f, 0.08584748f, -0.18101357f, 0.01357561f, -0.01786174f, -0.05706961f, 
    0.00779953f, 0.00915987f, 0.04533033f, 0.00060581f, -0.07591032f, -0.00216640f, -0.07144103f, 0.05917577f, 
    -0.15782849f, 0.17665896f, -0.02315444f, 0.03026422f, 0.03231716f, 0.05867333f, 0.03367697f, 0.12871669f, 
    -0.02857568f, -0.03665326f, 0.05790122f, -0.00313910f, -0.00259626f, -0.01637425f, -0.05799694f, 0.25161630f, 
    0.00717456f, 0.02703182f, -0.00022716f, 0.05561217f, 0.15273666f, 0.02343965f, -0.06014426f, 0.29299131f, 
    -0.05201623f, -0.13500530f, 0.02636578f, -0.03284190f, -0.08469620f, -0.03308439f, 0.08440877f, -0.08012553f, 
    -0.02450168f, -0.04086166f, 0.06183777f, 0.11116408f, -0.03337622f, -0.07367238f, -0.05854478f, -0.11234794f, 
    -0.03200967f, 0.05117203f, -0.01543764f, 0.08476631f, -0.00055812f, -0.01741089f, 0.00412903f, -0.05013627f, 
    0.07036009f, 0.12241367f, -0.16828462f, 0.00895508f, 0.11894320f, 0.04013562f, -0.17737381f, -0.02028898f, 
    -0.00774382f, 0.04290960f, -0.02251704f, -0.01102357f, -0.09327295f, -0.03367253f, -0.13043247f, 0.03159234f, 
    0.01614509f, -0.00365063f, 0.02873272f, -0.05839532f, -0.10684610f, 0.00930487f, 0.04580216f, 0.02957699f, 
    0.09492449f, 0.05480262f, -0.07664606f, -0.05635216f, -0.11846825f, -0.03551611f, -0.08393885f, 0.06541149f, 
    -0.00303480f, 0.05870796f, 0.02532575f, -0.00593976f, -0.11117135f, -0.02305168f, -0.03033462f, 0.03229506f, 
    -0.02000254f, 0.02900829f, 0.04015620f, 0.12894133f, 0.00258260f, -0.07260727f, 0.08225875f, -0.03265689f, 
    0.00726568f, -0.03727699f, -0.02127589f, -0.15516867f, -0.03295023f, -0.04559647f, 0.10401291f, -0.04170821f, 
    -0.12199371f, 0.09140143f, -0.00973251f, -0.04175160f, -0.16327652f, 0.21063933f, 0.10115752f, 0.04247241f, 
    0.09406352f, -0.00283416f, -0.16566432f, 0.00100871f, 0.03779014f, 0.00061056f, -0.01339894f, 0.09983730f, 
    0.17530830f, -0.03168005f, 0.03671139f, 0.13208275f, 0.01141862f, 0.09017620f, 0.07382713f, 0.11456545f, 
    -0.03492034f, -0.04313067f, 0.01313435f, -0.03776512f, 0.28550819f, 0.21528256f, 0.06653059f, 0.08294009f, 
    -0.01828982f, 0.03202745f, 0.03260247f, 0.02773730f, -0.00361048f, -0.00270823f, 0.01735649f, -0.03315124f, 
    -0.18416899f, 0.10448347f, 0.15211678f, -0.50608200f, 0.00765564f, -0.01774474f, -0.04675465f, 0.06741510f, 
    0.02979115f, -0.07865984f, 0.04490847f, -0.11267209f, -0.10568050f, -0.50148678f, -0.17200936f, -0.05323566f, 
    0.21519224f, 0.09464161f, 0.08792633f, 0.03385361f, 0.00885013f, 0.01879409f, -0.05863388f, -0.06055497f, 
    0.03915262f, 0.13815373f, -0.05955365f, 0.03656811f, 0.05745745f, -0.00989045f, 0.07071923f, 0.25374898f, 
    0.01363548f, 0.08199593f, 0.00209947f, -0.02592437f, -0.26521739f, -0.06603314f, -0.10928112f, -0.07955383f, 
    0.16917990f, 0.16526262f, 0.02852304f, -0.09356214f, 0.01781563f, 0.02058230f, 0.09127482f, -0.01265096f, 
    -0.07608493f, -0.19281854f, -0.11918049f, -0.06694641f, 0.02442368f, -0.03827144f, 0.06680896f, -0.04079200f, 
    0.04819989f, 0.00876567f, -0.04408839f, 0.06858409f, 0.03776012f, -0.04466699f, -0.02357688f, -0.00078743f, 
    -0.06567742f, 0.04316468f, -0.04887587f, -0.03318762f, 0.08668338f, 0.08260887f, 0.07468225f, 0.14710586f, 
    -0.00359102f, -0.16651465f, -0.02984162f, -0.01168650f, -0.00426217f, 0.01448347f, -0.00349104f, 0.05905693f, 
    0.02242044f, -0.12530051f, -0.05286884f, 0.09100015f, -0.27711147f, -0.06677629f, -0.38448441f, -0.01878310f, 
    0.07059465f, -0.08564568f, -0.01772822f, -0.00138060f, 0.01438755f, 0.05129694f, -0.09464562f, -0.01199579f, 
    0.08430014f, -0.06650033f, -0.08112083f, 0.17657445f, 0.10935476f, 0.04572984f, -0.15469916f, 0.02488304f, 
    0.08776184f, -0.08606312f, 0.02551855f, -0.00693753f, -0.09152749f, 0.02212990f, -0.01778193f, 0.05183176f, 
    -0.03797949f, 0.03139643f, 0.03043949f, -0.02798179f, 0.02363173f, 0.08587904f, -0.14218840f, 0.02601631f, 
    -0.55622292f, -0.44409525f, -0.17997065f, -0.44818375f, -0.02853873f, 0.02162024f, -0.09154966f, -0.26179433f, 
    -0.07706657f, -0.05632490f, -0.08952946f, -0.01685471f, -0.02083186f, 0.19854917f, 0.14732486f, 0.06375310f, 
    0.04973802f, -0.00471781f, 0.00041971f, -0.05014321f, 0.06558735f, -0.07479418f, -0.24467890f, 0.02157110f, 
    -0.38531494f, 0.56133777f, -0.28140566f, -0.09453434f, 0.01482566f, 0.13479178f, -0.14601405f, -0.01753333f, 
    -0.16577704f, -0.10707871f, 0.08089596f, 0.00798142f, -0.29488140f, -0.01693903f, -0.00335231f, 0.37333000f, 
    0.01164818f, 0.03956787f, -0.05695175f, -0.05317466f, -0.02515330f, 0.04833703f, 0.09637205f, 0.16329487f, 
    -0.35804194f, 0.13953747f, -0.20637839f, -0.01726623f, 0.08404574f, 0.01944784f, -0.10828169f, -0.00428102f, 
    -0.09521719f, -0.14095494f, 0.10311786f, -0.12632035f, -0.20634806f, -0.22082984f, -0.02794550f, 0.24702609f, 
    -0.03239280f, -0.05115901f, 0.13617203f, -0.03929664f, -0.09414724f, -0.05746556f, 0.03285653f, -0.14680761f, 
    -0.12190216f, -0.01109842f, -0.03823058f, 0.09314696f, -0.03968293f, -0.11597207f, -0.23105834f, -0.01576588f, 
    -0.14218131f, -0.05934066f, -0.05174029f, -0.02874082f, -0.25169763f, 0.28667313f, 0.04198250f, -0.00826474f, 
    0.14619853f, 0.10628518f, 0.00445941f, -0.03762322f, -0.21913588f, 0.02415408f, -0.05878744f, -0.01729340f, 
    -0.37253985f, -0.27404484f, 0.17715739f, 0.20054191f, -0.07089632f, -0.05773338f, 0.01098950f, -0.08913291f, 
    -0.03605813f, -0.07617121f, -0.07003808f, -0.07355930f, -0.48113945f, 0.19834711f, -0.11699057f, -0.42897767f, 
    0.09722682f, -0.12916620f, 0.03536147f, -0.20693976f, -0.06146120f, 0.03185232f, -0.11206851f, -0.01312193f, 
    -0.31295592f, 0.42268756f, -0.30622712f, 0.33315220f, 0.05954964f, -0.02532083f, 0.08618804f, -0.03548076f, 
    0.08832824f, -0.12689599f, 0.06944877f, -0.07142489f, -0.12467615f, -0.33022892f, 0.12610942f, -0.10151708f, 
    -0.04844158f, -0.15372756f, -0.12454230f, 0.03062243f, -0.05533320f, -0.13234894f, 0.02138896f, -0.11277182f, 
    0.28918105f, -0.16004841f, -0.12077364f, -0.14424913f, 0.22913618f, 0.08539299f, -0.07121014f, 0.08570044f, 
    -0.03406375f, -0.01942924f, 0.08225768f, -0.04480910f, -0.19133501f, -0.07147198f, -0.44481531f, 0.00748560f, 
    -0.18188551f, 0.06560543f, -0.28246725f, -0.04667044f, -0.06332352f, -0.08620089f, 0.14714099f, -0.06565344f, 
    0.16408028f, -0.18378757f, 0.00490207f, 0.17779231f, 0.00666722f, -0.05121657f, -0.01532679f, -0.05016258f, 
    0.02168465f, 0.02763288f, 0.02960374f, 0.14308870f, -0.22281243f, 0.23513527f, 0.13376629f, 0.22652812f, 
    0.11549518f, -0.07650889f, 0.06365632f, 0.03330813f, 0.11411773f, 0.06989969f, 0.15355763f, 0.03428489f, 
    0.04864229f, -0.04439395f, 0.20661923f, -0.05675155f, 0.02061709f, 0.06303863f, -0.02930817f, -0.02387015f, 
    -0.12302438f, 0.11132330f, 0.04574521f, 0.08492471f, 0.98106349f, 0.02682118f, -0.02327816f, -0.11229520f, 
    0.01553031f, 0.01773259f, -0.16721055f, -0.16668306f, -0.32335752f, -0.00383024f, -0.11123010f, 0.06879722f, 
    -0.15216829f, 0.30361220f, -0.17629077f, 0.03960897f, 0.15682946f, -0.07643040f, -0.06755034f, 0.10785607f, 
    0.03491022f, -0.01934487f, 0.09965175f, 0.14195265f, 0.42582861f, 0.13845684f, -0.13747315f, -0.19959882f, 
    0.01888898f, -0.01064205f, -0.04966146f, -0.07217951f, 0.06494775f, 0.01420786f, 0.07618877f, 0.12780404f, 
    -0.03914310f, 0.27684879f, -0.12691711f, 0.33501026f, 0.14702587f, -0.12225240f, -0.05887591f, -0.22853783f, 
    0.06310384f, 0.05759626f, -0.01210348f, 0.07757831f, -0.40593967f, 0.03201509f, 0.20893912f, 0.00265497f, 
    0.11964640f, 0.08134967f, -0.06823280f, -0.00612200f, 0.01722378f, -0.02039169f, -0.06645218f, -0.02442000f, 
    0.03335865f, 0.05641025f, -0.18512687f, -0.11334599f, -0.08850567f, 0.04671007f, -0.34212932f, 0.04108015f, 
    -0.14742476f, -0.17737398f, 0.13627537f, -0.24360898f, -0.18883403f, -0.27095494f, -0.08002383f, 0.10219995f, 
    0.04419012f, 0.02451108f, -0.15280023f, -0.06215353f, -0.02567186f, -0.03635038f, -0.19977057f, 0.07352847f, 
    -0.05125674f, 0.26340845f, -0.30799952f, 0.03198513f, 0.04434365f, 0.00448149f, 0.06928019f, 0.02519732f, 
    -0.05321697f, 0.04691229f, 0.06991231f, -0.01760866f, -0.17783745f, 0.54934788f, -0.32703221f, -0.29157889f, 
    0.20569432f, 0.11287620f, -0.00633483f, -0.01470463f, -0.15969226f, -0.10203463f, -0.05745729f, -0.06518292f, 
    -0.01417684f, -0.10964051f, -0.08551356f, 0.08115473f, -0.00484783f, 0.07996047f, 0.11944198f, 0.12005801f, 
    0.03372695f, 0.06145867f, 0.04291761f, -0.05484835f, 0.06024299f, -0.08401480f, -0.00143020f, -0.11649514f, 
    0.03256942f, 0.01190429f, -0.00023865f, -0.09831697f, -0.10275634f, 0.03413317f, -0.03043708f, -0.16914816f, 
    -0.02741999f, -0.17292525f, 0.03374702f, 0.04046622f, -0.00484189f, 0.05191338f, -0.00560613f, 0.04406045f, 
    -0.13393691f, -0.06599777f, -0.04635470f, -0.11780564f, -0.04214081f, -0.43582657f, 0.46102172f, 0.10036754f, 
    -0.24822570f, -0.15464231f, -0.01086790f, -0.05417247f, 0.05656720f, 0.02193414f, 0.15346321f, -0.01382515f, 
    -0.07929073f, -0.07725933f, -0.03525256f, -0.09770899f, 0.01762125f, 0.14134166f, -0.01666762f, 0.07950038f, 
    0.04385011f, 0.01772682f, -0.08956891f, 0.05772399f, 0.09542629f, -0.21469422f, -0.01951457f, 0.21235222f, 
    0.03031973f, -0.03350465f, 0.05021092f, -0.11870925f, -0.00723711f, 0.02542375f, 0.09375687f, 0.09242924f, 
    0.13717218f, -0.23733576f, 0.15088025f, 0.02713467f, 0.00744543f, -0.02053579f, 0.10777930f, -0.17242022f, 
    -0.04287728f, 0.20556661f, -0.21324608f, 0.07550772f, -0.21088202f, 0.82301998f, -0.42272738f, -0.08199825f, 
    0.17199674f, -0.03844715f, 0.15688328f, -0.04100925f, -0.15453137f, -0.13042137f, -0.00371384f, 0.02616277f, 
    0.01550295f, -0.16900374f, -0.01196876f, 0.15127949f, 0.12199931f, 0.01080013f, -0.11160693f, -0.01116583f, 
    0.01981794f, -0.00754828f, 0.00181486f, -0.01378319f, -0.13734490f, -0.02311205f, -0.09664997f, 0.00667160f, 
    0.06949390f, 0.07394642f, 0.07632229f, 0.13771497f, -0.10052836f, 0.04235543f, -0.07409807f, -0.02056372f, 
    -0.04706202f, -0.19167086f, 0.29719591f, -0.05657324f, -0.09085309f, 0.03561619f, 0.02523031f, 0.02568771f, 
    0.02659439f, 0.00462629f, -0.12547767f, 0.02741304f, -0.05691477f, -0.00931058f, 0.00513534f, 0.31479943f, 
    0.01999705f, 0.12445692f, 0.27653253f, -0.02653079f, 0.13255379f, 0.02621231f, -0.06415845f, -0.01262506f, 
    -0.02013065f, -0.04875884f, -0.11464735f, 0.17444231f, 0.05979298f, 0.04274795f, -0.00835466f, -0.09987959f, 
    -0.02432694f, 0.15650579f, 0.05493518f, 0.05465397f, -0.41926327f, -0.09869651f, 0.15244970f, -0.25303933f, 
    0.04046433f, -0.00439162f, -0.22292131f, 0.03381433f, -0.10773171f, -0.18676154f, 0.01944946f, -0.04115076f, 
    0.12875761f, -0.00781388f, -0.01224749f, 0.19226511f, -0.05631256f, -0.04575734f, -0.06425862f, -0.12483409f, 
    -0.01777383f, -0.01723133f, -0.05907873f, -0.01597218f, -0.27250203f, -0.20126922f, -0.08982785f, -0.10377564f, 
    -0.32387885f, -0.13871919f, -0.00078867f, 0.03105514f, 0.12149882f, 0.11784981f, 0.06713071f, 0.11190442f, 
    -0.12609923f, 0.27086475f, -0.05481661f, 0.18229586f, -0.15803304f, -0.15767327f, 0.14800976f, -0.02167613f, 
    0.10486621f, -0.01676963f, 0.18100463f, -0.01896512f, -0.07776633f, -0.00726711f, -0.24768820f, -0.35250956f, 
    0.20983312f, 0.09350343f, 0.03717323f, -0.04164343f, -0.08774347f, 0.02373584f, -0.12661026f, -0.04827092f, 
    -0.04795358f, -0.11045397f, -0.00038953f, 0.15585665f, 0.03664977f, 0.02611377f, -0.00779832f, 0.12884468f, 
    -0.03490070f, 0.13511325f, 0.00154649f, 0.10084025f, 0.10262684f, -0.01199121f, 0.13061474f, 0.14429247f, 
    0.12204465f, 0.15590550f, -0.04319103f, 0.07877334f, -0.11897077f, 0.11920638f, 0.16530639f, 0.03689195f, 
    0.86790562f, -0.48108232f, -0.01469127f, 0.00898755f, 0.03674082f, -0.00175524f, -0.08231264f, 0.09122277f, 
    -0.13571139f, -0.09214769f, -0.02858711f, 0.00107505f, 0.50189430f, 0.11771010f, 0.08517701f, -0.32104969f, 
    -0.31115466f, 0.01682271f, -0.00615978f, -0.05126464f, 0.12377656f, 0.05726908f, 0.09548984f, -0.08336040f, 
    -0.00564435f, 0.33092493f, 0.13517746f, 0.14962119f, -0.13094623f, -0.37048280f, 0.01067327f, -0.12168162f, 
    -0.11646451f, -0.00719069f, -0.00658827f, -0.05006662f, -0.21031967f, -0.20664714f, -0.27551591f, -0.49173081f, 
    0.15453506f, 0.21242866f, -0.00444251f, -0.03269401f, -0.12086830f, -0.03260889f, -0.10586575f, -0.16617447f, 
    0.26787516f, 0.17553277f, 0.24166113f, 0.12710419f, -0.15019776f, 0.02022025f, 0.10911361f, -0.05343617f, 
    -0.00935553f, 0.17018551f, 0.04605750f, 0.02133019f, 0.43241960f, -0.18489748f, -0.01001562f, 0.07271362f, 
    0.01072705f, -0.03313013f, -0.06784576f, 0.07034223f, -0.04858991f, -0.01368350f, -0.09377461f, 0.07101700f, 
    0.31366029f, 0.11362584f, 0.11598785f, 0.16319822f, 0.00667224f, -0.04581111f, -0.16807243f, -0.09834309f, 
    0.02379667f, 0.02233800f, -0.03984877f, 0.26038718f, 0.30028737f, -0.08762760f, 0.01874958f, -0.01279595f, 
    0.11521332f, 0.01619339f, -0.10201085f, -0.10228021f, -0.05319673f, 0.00793619f, -0.04023107f, -0.19417164f, 
    -0.33886477f, -0.10851821f, 0.27681425f, -0.10462753f, 0.00692473f, 0.03810202f, -0.14605635f, -0.00960861f, 
    0.04744696f, 0.05343384f, 0.13799341f, -0.05774911f, -0.01598705f, -0.01337132f, -0.00080613f, 0.05023283f, 
    0.01541137f, 0.04718027f, 0.12608059f, -0.00448551f, -0.06195885f, -0.03009125f, 0.00590937f, -0.07232762f, 
    -0.03663442f, 0.18114761f, -0.26642886f, 0.06090689f, -0.11213189f, 0.05513413f, -0.09174079f, -0.07429385f, 
    -0.11871707f, 0.02721179f, 0.00129378f, 0.02880990f, 0.00209486f, -0.21507609f, -0.02450773f, 0.08605789f, 
    -0.05754378f, 0.08897241f, 0.01116235f, -0.03599552f, -0.02201412f, -0.05010920f, -0.02107047f, -0.05046166f, 
    0.08462340f, 0.07182141f, -0.07909995f, -0.31364399f, 0.17599683f, 0.13080864f, 0.09880961f, 0.11015452f, 
    -0.16689037f, 0.13833655f, 0.08526164f, -0.08325309f, 0.01667144f, -0.10031231f, 0.06375232f, 0.06226752f, 
    -0.00714274f, 0.10014977f, 0.07564546f, 0.01716185f, 0.04594907f, 0.05897541f, -0.08763625f, 0.08375800f, 
    -0.36186114f, -0.22004384f, -0.11093545f, -0.00551632f, 0.02637382f, 0.17992419f, 0.02099377f, 0.15911944f, 
    0.05195453f, 0.09774303f, 0.03316111f, -0.00328559f, 0.03197235f, -0.08176623f, -0.18516445f, -0.03359990f, 
    0.11240348f, -0.02638807f, 0.06712628f, 0.22841647f, -0.05460888f, -0.01554824f, -0.04861224f, -0.08810218f, 
    -0.04600817f, -0.13223401f, -0.05444502f, -0.18526611f, 0.12531564f, -0.03043387f, -0.08419543f, -0.06013014f, 
    -0.01156288f, 0.04028708f, -0.08006476f, 0.05454690f, -0.06583080f, -0.12232001f, 0.03255416f, -0.01533608f, 
    -0.02665862f, -0.20257632f, -0.13633555f, -0.02491933f, -0.00948900f, -0.10139881f, -0.13112549f, -0.20576990f, 
    0.07775469f, -0.25097343f, 0.09179389f, 0.27272195f, -0.06701376f, 0.03555508f, -0.06490773f, 0.05752648f, 
    -0.11116601f, 0.01048388f, -0.14379255f, -0.07501894f, -0.32116386f, -0.04843010f, -0.09217878f, 0.06645793f, 
    -0.02070408f, -0.03896893f, 0.12816116f, -0.00463912f, -0.09190793f, 0.07554209f, -0.02829457f, -0.01070582f, 
    -0.16590607f, -0.51366770f, 0.01709551f, 0.05534504f, 0.09261769f, 0.06988274f, 0.07077312f, -0.00485341f, 
    0.00896348f, -0.02897212f, -0.07130114f, 0.00886979f, -0.12737280f, -0.08167975f, -0.04275775f, -0.02397721f, 
    0.06090907f, -0.02279126f, -0.05041264f, -0.01312118f, 0.01081243f, 0.04637828f, 0.11473814f, 0.09608569f, 
    0.04394272f, -0.15326095f, 0.12876543f, 0.13049342f, -0.27261928f, -0.11414258f, -0.13284469f, 0.07344744f, 
    -0.17403492f, 0.05363105f, -0.13231324f, -0.00583572f, 0.18487415f, 0.14170358f, 0.24015039f, -0.02436791f, 
    0.06611146f, 0.24153131f, -0.14801256f, 0.10761991f, 0.03268295f, -0.03068095f, -0.11990710f, 0.04727218f, 
    -0.00777730f, 0.12572747f, 0.06804999f, -0.05114224f, -0.00508737f, -0.05898514f, 0.03823197f, -0.03083122f, 
    0.06410553f, 0.00459950f, -0.06710426f, -0.09199752f, 0.15654488f, -0.16748449f, 0.08337664f, 0.08932336f, 
    -0.18545082f, -0.10129578f, 0.11892358f, -0.18385196f, 0.00232974f, 0.02146179f, 0.02128946f, -0.00070225f, 
    -0.01697581f, 0.18537876f, -0.26138553f, -0.05907679f, 0.01416965f, -0.00086220f, -0.09693873f, -0.04916120f, 
    0.05508440f, -0.05278564f, -0.01267316f, 0.00712764f, -0.15585148f, -0.16566060f, -0.30893531f, -0.05291828f, 
    -0.03069163f, 0.03432270f, 0.01904280f, -0.00847777f, -0.21578652f, -0.03741505f, -0.09495596f, -0.08793013f, 
    -0.19958967f, 0.09056170f, -0.03355037f, -0.10778169f, 0.08606336f, 0.08731315f, -0.02503265f, -0.13446972f, 
    -0.06291506f, 0.00851855f, -0.15334660f, 0.13800119f, -0.06300031f, 0.11635613f, -0.09807888f, -0.09144516f, 
    -0.00594487f, -0.08832964f, -0.21844538f, -0.04290401f, 0.08679578f, 0.05663415f, -0.03863289f, -0.21404807f, 
    0.09176891f, -0.02559315f, 0.04063049f, 0.10982639f, -0.23744665f, -0.08428627f, -0.00379394f, 0.01659675f, 
    -0.03297254f, -0.14231430f, -0.09499907f, -0.08079370f, 0.01779803f, 0.01630638f, -0.02552718f, 0.02656989f, 
    0.07446031f, 0.02598546f, 0.03668780f, -0.00363024f, 0.06466863f, 0.01692049f, 0.04419854f, 0.01664639f, 
    -0.16236632f, -0.10741203f, -0.01653029f, 0.03835265f, -0.00907502f, 0.00863377f, -0.02566802f, 0.03275613f, 
    -0.00455788f, -0.01061561f, 0.04579959f, 0.13369489f, 0.03552988f, 0.15855847f, 0.09920928f, 0.19576417f, 
    -0.02486303f, -0.15213963f, 0.00074068f, 0.00136207f, -0.19901927f, -0.21024182f, -0.20679972f, 0.04051104f, 
    0.16088781f, 0.07809975f, -0.05019858f, 0.00801617f, -0.03200594f, -0.12061023f, -0.06243537f, -0.04918911f, 
    0.10163076f, 0.07686067f, 0.03269790f, 0.08889266f, -0.07655384f, -0.41278583f, -0.37056109f, 0.11773573f, 
    0.00545431f, -0.14743443f, 0.10791270f, -0.08875206f, 0.05426813f, -0.14392368f, 0.04557436f, -0.12377716f, 
    -0.07977144f, -0.26885071f, 0.19107436f, 0.13386036f, -0.06477198f, 0.05556308f, -0.12599906f, -0.09747157f, 
    -0.06007243f, 0.02321543f, -0.08427328f, -0.14119893f, -0.06338389f, -0.04567653f, -0.04883909f, 0.02330767f, 
    0.09518336f, 0.00531963f, -0.04809704f, -0.12769488f, 0.14935757f, -0.17898910f, -0.10580152f, 0.20486650f, 
    0.01710038f, -0.14565043f, -0.04256912f, 0.05295018f, 0.09299800f, 0.04418165f, -0.06962697f, 0.03551929f, 
    -0.11762615f, 0.04622700f, -0.02760816f, -0.23612250f, -0.03899943f, -0.04444643f, -0.14192377f, 0.10377653f, 
    0.03552713f, 0.11484420f, -0.10736944f, -0.00895361f, 0.05521963f, 0.06274940f, -0.09715336f, -0.08782971f, 
    -0.08574553f, 0.06001761f, 0.01580998f, 0.01617913f, -0.02452222f, -0.10456410f, -0.06376158f, 0.03936923f, 
    0.10363915f, -0.06268808f, -0.10454880f, -0.15134890f, 0.01143421f, -0.00339844f, 0.16373402f, 0.10490430f, 
    -0.01122523f, -0.08447789f, -0.03983945f, -0.10905743f, -0.09297188f, -0.18375143f, 0.08715309f, 0.15491261f, 
    0.38801867f, -0.30672687f, 0.10213024f, 0.00245250f, 0.00177598f, -0.08323087f, -0.00111815f, -0.01769158f, 
    0.14566457f, -0.13265154f, -0.03693976f, -0.03100760f, 0.35691831f, -0.40584713f, 0.04721300f, 0.03747265f, 
    0.02880277f, -0.05004488f, -0.05023973f, -0.01136340f, -0.06391252f, 0.12356732f, -0.25293127f, -0.17507862f, 
    0.11229858f, 0.09216543f, 0.17414366f, 0.07905443f, 0.00775231f, -0.17746165f, -0.04647330f, -0.06606311f, 
    0.06947087f, 0.05203002f, -0.00837894f, 0.00873088f, 0.06643783f, 0.09507025f, -0.02957012f, -0.03454973f, 
    0.05661577f, 0.04292879f, 0.05845305f, -0.02386559f, -0.06012053f, -0.04400324f, -0.14573306f, -0.05631368f, 
    0.06131807f, -0.02358165f, -0.00772237f, 0.09643511f, -0.00811002f, 0.02192386f, 0.09463935f, 0.04580144f, 
    -0.00781151f, 0.10786102f, 0.10323951f, -0.06541284f, 0.08961987f, 0.35579154f, -0.07256392f, 0.27215511f, 
    0.00577048f, 0.13570316f, 0.00693133f, 0.11044104f, 0.05931173f, -0.01110562f, -0.05364213f, -0.09029658f, 
    0.09213488f, -0.02907900f, -0.14070632f, 0.00720576f, -0.15116362f, -0.07783512f, 0.03423488f, -0.09516095f, 
    0.05247651f, 0.01271580f, -0.07553642f, -0.15440521f, -0.14585814f, 0.01082152f, 0.08429915f, 0.21066311f, 
    -0.02812940f, -0.03018210f, -0.09725185f, 0.01281222f, -0.02478101f, 0.03074954f, 0.02374361f, 0.04080051f, 
    0.04980455f, -0.03794077f, 0.00551166f, 0.06942180f, -0.15830262f, -0.08484845f, -0.04442210f, 0.15994798f, 
    0.09148552f, -0.04376283f, 0.00137810f, -0.11033849f, -0.26459408f, -0.57064635f, -0.11018778f, -0.43573472f, 
    0.11946994f, 0.13143583f, -0.01313107f, -0.00836142f, -0.02877912f, -0.01118449f, 0.04888638f, -0.13791580f, 
    0.04210968f, 0.24070016f, 0.15844397f, 0.14158823f, -0.20821297f, -0.06481043f, 0.21605708f, 0.27573156f, 
    0.07481784f, -0.01872348f, -0.04199221f, 0.03656128f, -0.07341209f, -0.27057660f, -0.03882549f, 0.12731498f, 
    -0.04866983f, -0.07183742f, 0.05264543f, -0.10875667f, 0.00459439f, -0.02431130f, 0.09475943f, 0.00790447f, 
    0.26389474f, 0.02802726f, -0.23852296f, 0.39534816f, 0.12864821f, -0.10951757f, 0.16053408f, -0.04435864f, 
    -0.08004542f, -0.04575906f, 0.06518766f, -0.05126728f, 0.19692196f, 0.23044355f, 0.22678091f, 0.23772827f, 
    0.18754548f, 0.07232054f, 0.07939267f, 0.20284536f, 0.04609843f, -0.06408041f, 0.02374791f, -0.04637066f, 
    -0.14216143f, 0.01878010f, 0.07795481f, 0.11287815f, -0.13132620f, -0.04356835f, -0.04337709f, 0.06034577f, 
    0.06384800f, 0.10263140f, -0.04501633f, 0.03920324f, -0.09662331f, -0.33208975f, -0.11559156f, 0.07284392f, 
    0.04289967f, 0.01335380f, 0.03920819f, -0.03452943f, -0.01693941f, 0.06533738f, -0.07906073f, 0.03892860f, 
    0.04425878f, 0.30355099f, -0.09162822f, 0.32406148f, 0.11487874f, 0.02127793f, 0.04407854f, -0.19003548f, 
    -0.13459592f, -0.44453934f, 0.01952655f, -0.14034769f, -0.01651734f, 0.00473944f, -0.01342931f, -0.00300981f, 
    0.06845064f, 0.04362113f, 0.06050782f, 0.04970607f, 0.06995501f, 0.04345581f, 0.06666582f, 0.13471520f, 
    -0.11776163f, -0.21716256f, 0.25464684f, 0.17094968f, 0.06610797f, 0.05646893f, -0.03722405f, 0.03532712f, 
    0.00361442f, -0.05702590f, -0.04751946f, 0.01934702f, -0.00743190f, -0.22227831f, -0.07268088f, 0.11435138f, 
    -0.10515245f, 0.01127708f, 0.03375866f, 0.07620181f, 0.07149506f, 0.20441085f, 0.10873564f, 0.09316588f, 
    0.02923923f, 0.14295009f, 0.14871143f, 0.16483569f, -0.06467901f, -0.02954459f, -0.01241256f, -0.07474682f, 
    0.16431543f, 0.13561951f, 0.07709946f, 0.12602995f, 0.08648671f, 0.11518940f, -0.08970564f, -0.05643361f, 
    0.06122119f, -0.01823669f, 0.03849901f, 0.02697563f, 0.01689292f, -0.10117254f, -0.04497955f, -0.19050953f, 
    -0.06444383f, -0.17920139f, -0.12875010f, 0.04272656f, -0.05175413f, -0.13021669f, 0.06345227f, 0.04990522f, 
    0.05341234f, 0.04145185f, 0.13351062f, -0.13608143f, -0.12436455f, -0.15445322f, -0.07912089f, 0.05267726f, 
    -0.00955313f, 0.00774395f, -0.05423854f, -0.04577215f, -0.06310482f, -0.06860697f, -0.01226304f, 0.17169109f, 
    0.03196757f, -0.06020349f, -0.06308704f, 0.03691679f, 0.14997035f, 0.07552681f, -0.11012185f, -0.02114698f, 
    -0.09118142f, 0.09216420f, -0.15450592f, 0.04421908f, 0.16078064f, 0.06565459f, 0.01425149f, -0.00455660f, 
    0.10452317f, 0.07879581f, 0.05092960f, 0.12260547f, 0.02041961f, -0.12763113f, -0.25721529f, -0.03108247f, 
    0.10449608f, 0.02626880f, -0.12638181f, 0.26186743f, -0.01483132f, -0.06167110f, -0.05531779f, -0.20741472f, 
    -0.04965035f, -0.12651408f, 0.03358041f, 0.07077312f, -0.25231773f, -0.02383227f, -0.09456103f, 0.03361484f, 
    0.02661888f, 0.05093705f, -0.10757795f, -0.06876392f, 0.06585216f, -0.00919087f, 0.09222393f, -0.02000378f, 
    -0.18511423f, 0.00175968f, -0.14525771f, -0.00419662f, -0.07818629f, -0.16113295f, 0.05468466f, -0.31795689f, 
    0.00106242f, -0.05174961f, 0.02219136f, 0.02169892f, 0.11450620f, 0.11306880f, -0.02444115f, -0.11486128f, 
    -0.00058338f, -0.05512247f, 0.03231730f, -0.04533301f, -0.10304233f, -0.03223749f, -0.13548678f, 0.05946552f, 
    0.05233404f, -0.27660140f, -0.85496467f, -0.23588866f, 0.08695337f, 0.03629340f, 0.04835508f, -0.00060130f, 
    0.05727617f, 0.04466473f, -0.00182958f, 0.03238855f, 0.05558606f, 0.09499998f, 0.12611954f, 0.05815420f, 
    -0.06568983f, -0.09805994f, -0.04098068f, 0.10584067f, 0.03434673f, -0.00595745f, -0.02305737f, -0.03299001f, 
    -0.13515596f, -0.26799068f, 0.22701086f, 0.12057737f, 0.00859076f, 0.00134536f, -0.07143810f, -0.14088784f, 
    -0.13726838f, 0.03021718f, -0.09150814f, -0.02158539f, 0.00867388f, 0.15136702f, 0.08197224f, 0.14377399f, 
    -0.09089239f, 0.04455899f, -0.02538028f, 0.12636466f, 0.02183409f, -0.04592492f, 0.04441551f, -0.08344343f, 
    0.06851578f, -0.09668273f, -0.17327981f, 0.13043675f, 0.00243211f, 0.05578307f, 0.05432766f, 0.02471782f, 
    0.01134145f, -0.21563673f, -0.38913488f, -0.16254126f, 0.07673660f, 0.06460152f, -0.04933931f, 0.01447130f, 
    0.00490508f, -0.01675117f, 0.08585485f, -0.07241631f, 0.15044312f, -0.00116727f, 0.10442945f, 0.10786949f, 
    0.07903500f, -0.02940970f, -0.08497834f, -0.07887790f, 0.05241866f, -0.01628930f, 0.08388925f, 0.06489553f, 
    0.19063178f, 0.05511088f, 0.01050511f, 0.05126961f, 0.01215012f, -0.00294263f, 0.31106421f, 0.12113591f, 
    -0.07147130f, -0.00960629f, -0.20441328f, -0.12570406f, -0.04118736f, -0.13677576f, -0.06427425f, 0.03326900f, 
    0.11677529f, 0.14220242f, -0.10010677f, 0.00975078f, -0.12047485f, -0.04632970f, -0.00965005f, -0.07694512f, 
    0.00163067f, 0.12054992f, -0.05371321f, -0.05616296f, 0.09657166f, -0.10950240f, 0.04670069f, -0.01942072f, 
    -0.02094481f, -0.03364832f, -0.04220302f, 0.03508691f, -0.08714751f, -0.14338757f, 0.03912486f, -0.08836470f, 
    -0.01415618f, 0.29060873f, 0.05569823f, 0.26487380f, 0.09053083f, 0.03007925f, 0.06020272f, 0.11782270f, 
    -0.08256610f, -0.07566778f, -0.00602655f, -0.04405910f, 0.15539572f, 0.24679835f, 0.17037922f, 0.00199775f, 
    -0.02433646f, -0.00846815f, -0.04680736f, 0.03066705f, 0.05595684f, -0.12999617f, -0.17206448f, -0.03202973f, 
    0.24097224f, 0.27315184f, -0.11121448f, 0.06017411f, -0.06805866f, -0.08725799f, 0.02315801f, 0.14332856f, 
    0.04565798f, -0.07210543f, -0.15265653f, -0.04633091f, 0.10580939f, 0.00211258f, -0.18436821f, -0.19677024f, 
    -0.01459833f, 0.04765748f, 0.02985598f, 0.02393254f, 0.11261250f, -0.27550629f, -0.10473171f, -0.13055174f, 
    0.25972605f, -0.14300460f, 0.00688994f, 0.13519137f, 0.24265981f, 0.18324064f, 0.16446258f, -0.20801568f, 
    0.14230274f, -0.00737361f, -0.11526053f, 0.10384735f, 0.24926148f, 0.12316981f, -0.03182541f, 0.24080949f, 
    -0.10665366f, 0.07580171f, 0.06938291f, -0.06713749f, 0.01895391f, 0.10193307f, 0.00686510f, 0.02804059f, 
    -0.01108669f, -0.19205791f, -0.49972734f, 0.46389672f, 0.08763331f, -0.09266765f, 0.16810402f, 0.10277133f, 
    -0.04203278f, -0.13485089f, 0.10100089f, 0.23938063f, -0.52087373f, 0.04048708f, -0.16293465f, -0.18927102f, 
    0.02704670f, -0.02452601f, -0.07307516f, -0.03464072f, 0.09526034f, 0.03428360f, -0.07657850f, -0.16591400f, 
    -0.10485046f, -0.06042596f, -0.36187240f, 0.11762511f, 0.16170962f, 0.17976642f, 0.04832622f, 0.17487639f, 
    0.00917908f, 0.05651243f, -0.05864465f, -0.09881934f, 0.12406611f, -0.18982624f, 0.21130802f, 0.11297864f, 
    0.03151178f, 0.00398488f, -0.02878466f, 0.13345990f, 0.10488862f, 0.04791877f, 0.03250997f, 0.23706068f, 
    0.03006706f, 0.28832534f, -0.28707325f, -0.53602123f, -0.05301077f, -0.02390816f, 0.10070792f, 0.12948816f, 
    0.01535243f, 0.18739593f, -0.21410389f, -0.36470219f, 0.00568420f, -0.07543104f, -0.30554640f, 0.25352183f, 
    0.14093675f, -0.11782087f, -0.09034490f, 0.16644044f, 0.08533131f, 0.03689714f, -0.01788717f, 0.19066463f, 
    -0.32509056f, -0.51840502f, -0.02425373f, -0.16620766f, 0.14593661f, -0.12003576f, -0.10458537f, -0.09163538f, 
    0.19228609f, 0.03891644f, -0.07197352f, -0.06497990f, -0.23246171f, -0.04272412f, -0.14407913f, 0.00506343f, 
    0.00185855f, -0.05513401f, -0.00813032f, -0.00429984f, 0.07400735f, 0.07397822f, -0.10543294f, 0.06221912f, 
    -0.23924655f, 0.13222682f, 0.06832346f, -0.17933531f, -0.04424386f, -0.10581593f, -0.00868191f, 0.01174007f, 
    0.05931250f, 0.01030051f, -0.00517279f, -0.01637339f, -0.01385933f, -0.28900298f, -0.29883465f, -0.26418275f, 
    -0.03341735f, 0.05097874f, -0.13857605f, -0.10404224f, 0.20354754f, 0.17082192f, 0.16250741f, -0.09474961f, 
    0.03946392f, 0.49930215f, -0.00272020f, 0.18057175f, 0.07407837f, 0.10200849f, -0.01484938f, -0.08603669f, 
    0.00395097f, -0.18037470f, -0.02389828f, -0.33091927f, -0.44368654f, 0.09631218f, -0.08723035f, 0.15277515f, 
    -0.00354762f, -0.01587257f, -0.04316339f, 0.12763235f, 0.15772378f, -0.02508678f, -0.21407580f, 0.10290134f, 
    -0.07739272f, 0.16244872f, 0.23327686f, -0.04636176f, 0.14531377f, 0.17669594f, 0.18913816f, -0.13777670f, 
    -0.05761995f, 0.07420043f, 0.05548706f, 0.13754617f, -0.20281255f, 0.05699784f, 0.18839593f, 0.01405079f, 
    -0.04584580f, -0.15752445f, 0.00460925f, 0.20017654f, -0.06613629f, 0.03015565f, 0.03807560f, -0.14926478f, 
    0.00324190f, 0.04095945f, -0.07797649f, -0.26000863f, -0.21839726f, 0.02344042f, -0.05212791f, -0.14771795f, 
    0.20449929f, -0.10658376f, 0.03989768f, 0.28448516f, 0.11848534f, -0.06787740f, -0.52921426f, 0.44787920f, 
    -0.00919641f, 0.13034195f, 0.00265527f, -0.10916729f, -0.10899512f, 0.05515147f, 0.07333213f, -0.12440549f, 
    0.00232335f, -0.06705038f, -0.11762682f, 0.08897928f, 0.02306462f, -0.10978732f, 0.17293970f, -0.00243138f, 
    -0.01511650f, 0.02250354f, 0.04983921f, 0.25214106f, 0.11084887f, -0.07623325f, -0.12651059f, -0.19829111f, 
    -0.02860935f, -0.02840440f, -0.06312934f, 0.27715710f, 0.03015279f, -0.14582692f, 0.05687977f, -0.15597770f, 
    0.20159212f, 0.31351531f, 0.15451887f, -0.34945112f, 0.11887752f, 0.01602222f, -0.02026206f, -0.05159876f, 
    -0.04559378f, -0.18959095f, 0.07764027f, 0.10692832f, 0.14303094f, 0.08289023f, 0.07274164f, 0.05870121f, 
    -0.12427761f, -0.02778262f, -0.00858544f, -0.04110473f, 0.09201592f, 0.01859822f, -0.13453779f, 0.03663122f, 
    -0.01429235f, 0.04002972f, -0.01984974f, -0.05647144f, 0.15079276f, 0.15395471f, 0.10628994f, 0.18405356f, 
    -0.00857094f, 0.00171860f, 0.04777016f, 0.05440055f, -0.06005364f, -0.12912729f, -0.02389998f, -0.01430151f, 
    -0.10815645f, -0.06759525f, -0.03502066f, -0.07712779f, 0.04794285f, 0.00148868f, 0.18091047f, 0.05570335f, 
    0.07846420f, 0.13263170f, 0.00955284f, -0.01015374f, -0.04133730f, 0.04449755f, -0.06373791f, -0.03388995f, 
    -0.00083818f, 0.05342168f, -0.09982601f, 0.00175440f, -0.02932291f, -0.10451102f, -0.32456589f, 0.10970886f, 
    0.20870075f, 0.15776718f, -0.05427682f, 0.00095501f, 0.05187176f, -0.03876431f, 0.02824259f, 0.04280132f, 
    -0.17802738f, -0.12109265f, 0.15964060f, 0.11697847f, -0.00613732f, 0.02448240f, -0.07345810f, -0.06453720f, 
    0.05960812f, 0.01403898f, 0.12966463f, 0.02519025f, -0.30603755f, -0.00718674f, -0.01917988f, -0.44532153f, 
    0.10781987f, -0.00085700f, 0.03877056f, 0.15256603f, 0.01494832f, -0.10960066f, -0.07271616f, -0.01845590f, 
    0.11279790f, 0.07202552f, -0.20145729f, -0.02160852f, -0.11391910f, 0.13116542f, -0.15456855f, -0.07190970f, 
    0.07367528f, 0.08058563f, 0.00077059f, -0.06246860f, -0.13801663f, -0.12463376f, -0.01274972f, -0.13578792f, 
    0.00777317f, -0.02850744f, -0.10763448f, 0.06748851f, -0.23597693f, 0.05908877f, -0.05853973f, 0.06338613f, 
    0.05349769f, 0.08347819f, -0.14166276f, -0.16096795f, 0.34907347f, 0.07009387f, 0.08930381f, -0.10005198f, 
    0.01419376f, 0.02996279f, 0.00060029f, 0.06302244f, -0.22086118f, 0.15500629f, 0.14328140f, -0.08645239f, 
    -0.04627256f, -0.01183910f, -0.05690975f, -0.16688916f, 0.02837746f, 0.00317117f, 0.15226984f, 0.08016222f, 
    -0.05151400f, 0.16282679f, 0.18199614f, -0.29921359f, -0.05909750f, 0.02518936f, -0.15683623f, 0.02802560f, 
    0.05833520f, 0.06003958f, 0.09330722f, 0.10795838f, 0.10704586f, -0.10579749f, -0.14458077f, -0.15710261f, 
    -0.04710718f, -0.05191917f, -0.13320245f, -0.05279468f, 0.01296618f, -0.04677076f, 0.02140771f, -0.05509854f, 
    0.09374953f, -0.11157283f, -0.04464129f, -0.11436088f, -0.08852173f, -0.10874105f, 0.06753087f, 0.09068201f, 
    -0.03400802f, -0.29229113f, -0.07429150f, -0.11476925f, -0.14129345f, -0.04243746f, 0.04646639f, 0.02720143f, 
    0.06958111f, -0.03768017f, 0.02796529f, 0.05679257f, 0.15077709f, -0.05487341f, -0.06692947f, 0.14336815f, 
    -0.31310913f, 0.14401491f, 0.10137581f, -0.16902050f, -0.14900912f, -0.09952749f, -0.06206206f, 0.01036760f, 
    0.09938133f, 0.18037231f, 0.15322238f, -0.15122743f, -0.09179453f, -0.08214562f, -0.04200670f, 0.08999639f, 
    0.06084488f, 0.03962135f, -0.04888201f, -0.03885238f, -0.08788443f, -0.13495636f, 0.00497267f, -0.10797560f, 
    -0.01786566f, -0.36014447f, 0.05086267f, -0.08287801f, 0.03134314f, -0.06741160f, 0.00584158f, 0.05366791f, 
    -0.04998450f, 0.05819501f, -0.08018700f, 0.10093567f, -0.36367765f, -0.35421166f, 0.09889643f, 0.06714426f, 
    0.07411136f, 0.00856046f, -0.03877895f, 0.06238073f, -0.00007586f, -0.18347916f, 0.09574845f, -0.11547236f, 
    0.07000548f, 0.09487442f, 0.13814591f, -0.17196332f, 0.03521363f, 0.02360937f, -0.03994111f, -0.11864432f, 
    -0.01163828f, -0.15130651f, -0.04496806f, -0.12946379f, -0.04921715f, -0.08692648f, -0.12645377f, 0.20099343f, 
    0.05338179f, -0.03688390f, -0.03154463f, -0.07029298f, 0.16192554f, 0.02466457f, 0.05071923f, 0.17449357f, 
    -0.18814342f, -0.01598499f, -0.16853635f, 0.21631649f, 0.18390384f, -0.05313554f, 0.08130747f, 0.13362110f, 
    -0.09815138f, -0.05868058f, 0.10744808f, 0.28873926f, -0.16994755f, -0.35848767f, 0.04066439f, 0.31800941f, 
    0.00750366f, 0.01827260f, -0.01394516f, -0.11468213f, 0.00737811f, -0.03405458f, -0.06534524f, -0.14897291f, 
    0.03985091f, 0.04651445f, -0.29615402f, 0.10374272f, 0.06855692f, 0.02304663f, -0.01884308f, 0.02233127f, 
    -0.08639703f, 0.05886644f, 0.05065415f, 0.07054309f, -0.07758576f, -0.16321619f, -0.00735260f, -0.00541045f, 
    -0.03799035f, -0.08231251f, -0.11831307f, -0.10608211f, -0.15084665f, -0.09841146f, 0.28154159f, 0.24352172f, 
    -0.15709925f, 0.01227928f, -0.04978482f, 0.06328611f, -0.04325891f, -0.13178256f, -0.07700594f, -0.08279289f, 
    0.01786236f, -0.08581815f, -0.01433874f, -0.15777057f, -0.02117908f, -0.08302396f, -0.13151024f, -0.14479096f, 
    -0.09545566f, -0.16661963f, 0.00825281f, 0.26218060f, -0.09128767f, -0.07134271f, 0.15519179f, 0.11334443f, 
    -0.14109693f, -0.01639919f, -0.05371061f, -0.07194859f, 0.05834861f, 0.03042491f, 0.07896421f, 0.06000265f, 
    0.05783132f, 0.07599875f, -0.03349335f, -0.03163961f, -0.16422793f, -0.28400522f, -0.12573469f, 0.22070466f, 
    0.01370220f, 0.06515803f, -0.02450082f, 0.03033547f, -0.05208447f, 0.21621732f, 0.05049255f, 0.01248196f, 
    0.01846821f, -0.39521784f, -0.45278472f, 0.17449042f, 0.05328962f, 0.07563084f, 0.03521238f, 0.01933714f, 
    0.12899941f, 0.00901544f, -0.09916617f, -0.04630997f, 0.06221052f, 0.17123894f, 0.19256386f, -0.14494042f, 
    0.12975916f, 0.11686749f, -0.02023083f, -0.10526092f, 0.07791205f, 0.02215613f, 0.04353643f, 0.05472517f, 
    0.21033192f, 0.06934696f, 0.14686231f, -0.14013152f, -0.08683413f, 0.09151651f, -0.04371259f, 0.23907954f, 
    0.08717787f, -0.06753838f, 0.02040611f, 0.01566798f, 0.14474949f, 0.06680456f, -0.06416576f, 0.15755917f, 
    0.18667534f, -0.04279149f, -0.04600986f, -0.06759198f, -0.08136822f, 0.00995073f, 0.08325842f, 0.07803526f, 
    -0.15748534f, 0.16812371f, -0.27733278f, -0.17011377f, 0.00393224f, -0.05214910f, -0.00453701f, 0.01750079f, 
    -0.01781914f, 0.02413704f, 0.12801680f, 0.15433376f, 0.01440228f, 0.03075181f, -0.03132760f, -0.03338026f, 
    -0.02028499f, 0.01515155f, -0.05199599f, -0.03613743f, -0.13790046f, -0.16262417f, -0.01726477f, -0.07240535f, 
    -0.07100470f, -0.05858202f, -0.11903954f, 0.05134533f, 0.02861214f, 0.00714975f, -0.00858916f, -0.01130705f, 
    0.03811022f, -0.05477146f, 0.11527596f, -0.19595423f, 0.44677022f, 0.09036189f, 0.19779193f, 0.13844261f, 
    -0.12232432f, 0.03255952f, 0.07785867f, -0.14271489f, 0.00046084f, -0.01184509f, 0.05134978f, -0.02402116f, 
    0.18974108f, -0.41010436f, 0.12226816f, -0.02335968f, -0.01626652f, 0.10656878f, -0.09319074f, 0.17765021f, 
    0.10463829f, 0.05107637f, 0.00590428f, -0.03142360f, -0.02469336f, 0.00041536f, -0.00618012f, -0.07195124f, 
    0.00556270f, 0.04808398f, -0.10320181f, -0.08928014f, -0.00553703f, 0.07766637f, 0.05916658f, 0.21669742f, 
    0.07456269f, 0.09282857f, -0.00356135f, -0.06675544f, 0.02885312f, 0.03234687f, 0.07646415f, -0.11527411f, 
    0.11484061f, 0.00332469f, 0.02871179f, 0.10077957f, -0.29761377f, -0.39086577f, -0.05617208f, -0.06536537f, 
    0.00656187f, 0.12300600f, -0.11378490f, -0.12423529f, 0.05619801f, -0.06771606f, 0.37982804f, 0.05956118f, 
    -0.07874146f, -0.27289420f, 0.03923121f, 0.24049023f, 0.11251602f, 0.06085494f, -0.08732233f, -0.02462500f, 
    0.02797410f, -0.00414017f, 0.07839260f, 0.06180279f, 0.49396220f, 0.28899983f, -0.13853990f, 0.08534283f, 
    0.02551759f, -0.01632654f, 0.07700456f, 0.07153464f, 0.04927106f, 0.14620174f, 0.14322461f, 0.02112123f, 
    -0.22648904f, -0.21807282f, 0.15069021f, 0.07140922f, -0.09921667f, -0.13967730f, -0.14380158f, -0.30671924f, 
    -0.10914977f, -0.10676617f, -0.03720950f, 0.01899619f, -0.25826871f, -0.05853687f, 0.01370092f, 0.07115698f, 
    0.10633795f, 0.08967624f, 0.08142424f, -0.35412961f, 0.02745447f, -0.02955755f, -0.00042801f, 0.03991766f, 
    0.15033115f, -0.11116636f, 0.03158104f, -0.14783359f, 0.02091798f, 0.00812529f, 0.11087868f, -0.03482409f, 
    -0.02076507f, 0.06714880f, -0.04242557f, 0.08209543f, -0.31698474f, 0.01372661f, 0.31842080f, -0.06354382f, 
    -0.02553273f, -0.00367124f, 0.08096126f, -0.13844514f, -0.05750410f, 0.06114826f, 0.04131449f, 0.10390911f, 
    0.34834990f, -0.15474442f, 0.23788479f, 0.04551443f, 0.13968925f, -0.02332472f, 0.07808673f, -0.06856693f, 
    -0.01362690f, -0.14607072f, 0.02611961f, 0.11276719f, 0.06093867f, 0.09051746f, 0.06839779f, 0.06064979f, 
    0.07326053f, 0.01786241f, 0.02148679f, 0.13456294f, 0.02134851f, 0.04759467f, -0.08432744f, 0.00558028f, 
    -0.40140286f, -0.04988696f, 0.27980649f, 0.18825756f, 0.10486300f, 0.11650720f, 0.01292263f, -0.07849015f, 
    0.10874765f, -0.00566914f, 0.12946351f, -0.03953705f, 0.39639473f, 0.22015217f, -0.04617611f, -0.13144115f, 
    0.01254441f, -0.07928468f, 0.20509733f, -0.10099047f, 0.12136777f, 0.08463804f, 0.17962074f, -0.17256390f, 
    -0.03017051f, 0.00406347f, 0.15438236f, -0.10947116f, -0.05013371f, -0.02098195f, -0.06040733f, 0.16847709f, 
    -0.02471680f, 0.12875389f, 0.00608734f, 0.21540594f, 0.04273566f, -0.09276251f, -0.08035051f, -0.07729324f, 
    0.01245451f, 0.01164534f, 0.00759726f, 0.04013457f, -0.01565981f, 0.01771517f, -0.08049657f, -0.13571709f, 
    -0.42430934f, -0.57579893f, -0.27492532f, -0.04182324f, -0.10667408f, 0.03693952f, -0.06773461f, -0.09095573f, 
    -0.00017550f, -0.02775023f, 0.01586631f, 0.07532551f, -0.11732797f, 0.40306687f, 0.18487433f, 0.21672204f, 
    -0.03853515f, -0.21356925f, 0.06705442f, 0.07018741f, -0.00234165f, 0.03156296f, -0.09936391f, 0.10528305f, 
    -0.06538142f, -0.22769827f, -0.04624550f, -0.36748210f, -0.02969448f, -0.03048491f, 0.16838911f, 0.06126871f, 
    0.07699594f, 0.10128716f, 0.11165290f, 0.11216297f, -0.06752074f, -0.24497694f, 0.27670810f, 0.18850084f, 
    0.00305867f, -0.05212025f, -0.02811859f, 0.07854297f, 0.03512740f, -0.00501706f, 0.17955108f, -0.06298716f, 
    -0.20203008f, -0.34039164f, -0.11958509f, 0.26677763f, -0.07860938f, -0.21051827f, -0.01819867f, -0.18247567f, 
    -0.05279715f, 0.02802048f, 0.01302654f, -0.00029583f, 0.11897980f, -0.02535913f, -0.17836955f, 0.05640641f, 
    0.04329555f, 0.05914840f, 0.18502402f, -0.06063941f, 0.00037499f, 0.02007434f, 0.09018499f, 0.00856098f, 
    -0.13600625f, -0.05990510f, -0.01259008f, -0.16565149f, 0.08434557f, -0.17800738f, -0.06563152f, 0.04300692f, 
    0.04513492f, 0.07586737f, -0.16703103f, -0.22601378f, 0.50441742f, 0.04644680f, -0.00668603f, -0.29688811f, 
    0.07013234f, 0.03627802f, 0.03306387f, -0.06741512f, 0.10104205f, -0.01344432f, 0.14070341f, -0.05395553f, 
    0.21686077f, -0.18283679f, -0.09744237f, 0.10082811f, -0.12206028f, -0.02221579f, 0.29389250f, 0.12532285f, 
    -0.05096564f, -0.00306863f, -0.09014343f, -0.01601734f, -0.05746428f, 0.14091516f, -0.10882547f, 0.10224393f, 
    -0.00292144f, 0.10332761f, 0.01464395f, 0.07669876f, 0.11664491f, -0.11549147f, 0.13916157f, 0.02589955f, 
    -0.47624803f, -0.09981527f, 0.50779307f, 0.00613770f, 0.11397056f, 0.04361269f, -0.11138926f, -0.08124938f, 
    0.01731540f, 0.03666824f, 0.13736247f, 0.01517719f, -0.22207095f, -0.07368381f, 0.23392589f, 0.05250555f, 
    0.05375251f, -0.07861270f, -0.06201606f, -0.09163323f, 0.00483274f, 0.07244513f, 0.02357160f, 0.03760603f, 
    -0.37440047f, -0.32644323f, -0.34671167f, -0.34875503f, -0.26693526f, -0.13913734f, -0.14935970f, -0.18953454f, 
    0.04384043f, -0.02637842f, 0.04148895f, -0.05594027f, -0.01468850f, -0.04387933f, 0.06206121f, 0.01487459f, 
    0.03503488f, -0.00830764f, -0.09598446f, 0.04733896f, -0.04789734f, 0.01401291f, -0.13365850f, -0.14334768f, 
    -0.30853066f, -0.22361425f, -0.27399492f, -0.29590943f, -0.01860866f, 0.04820456f, 0.07266404f, 0.02899643f, 
    0.00346596f, 0.09804925f, -0.03949760f, 0.12786475f, 0.03340590f, -0.20378385f, -0.03164248f, -0.32737800f, 
    -0.09596198f, 0.10780839f, 0.17127034f, -0.04431326f, -0.03744641f, -0.06521852f, -0.09073569f, -0.05864546f, 
    0.02615685f, -0.08425617f, 0.24279243f, 0.20101060f, -0.20754403f, -0.05535231f, -0.07071024f, 0.04863650f, 
    -0.07790802f, 0.02214149f, -0.06195557f, -0.15788570f, -0.62908149f, -0.23425636f, 0.26930052f, 0.09806007f, 
    -0.09835634f, -0.12891436f, 0.17301475f, 0.05115348f, -0.04763056f, 0.02912130f, 0.03361255f, 0.00066526f, 
    0.12203441f, -0.14589518f, -0.31188825f, -0.26788229f, -0.09423911f, 0.06953728f, 0.15219504f, -0.04201149f, 
    -0.02186800f, 0.08499518f, -0.15201575f, -0.08855586f, -0.10739932f, 0.04863238f, 0.04661796f, -0.21192557f, 
    0.11514387f, -0.03684260f, -0.01137938f, -0.05029088f, -0.06998499f, 0.03884483f, -0.01265125f, 0.13323085f, 
    -0.75123352f, -0.47410297f, -0.30658129f, -0.28320497f, 0.18330631f, -0.12917088f, -0.09069139f, -0.46729130f, 
    0.03220951f, -0.04556806f, -0.04652945f, 0.05532739f, -0.06587669f, -0.57299763f, -0.32705072f, -0.10035031f, 
    -0.07563164f, -0.28733379f, -0.15752256f, -0.24978448f, -0.04886298f, 0.02563661f, -0.01488007f, 0.04041309f, 
    -0.26625448f, -0.35580349f, 0.03442171f, -0.32707310f, 0.12130918f, 0.01508535f, 0.06771198f, -0.11523230f, 
    0.08006347f, -0.02132568f, 0.21278338f, -0.03344766f, -0.27761731f, -0.61597025f, -0.30566522f, 0.10175031f, 
    -0.02896426f, 0.07634858f, 0.12333868f, -0.07508133f, 0.04196609f, 0.01621813f, -0.06064741f, 0.09573929f, 
    -0.29227105f, 0.39687511f, 0.07065593f, 0.08408474f, -0.11952913f, -0.05576571f, 0.01386354f, 0.14848895f, 
    0.05272477f, 0.03825714f, 0.16498373f, 0.01237058f, 0.00923700f, 0.00461196f, 0.01408021f, 0.24123618f, 
    0.00988942f, 0.07877455f, -0.01103939f, 0.00483974f, -0.05020433f, -0.10457426f, 0.01033423f, 0.01389328f, 
    0.06411461f, -0.03006672f, 0.25643298f, 0.10479900f, -0.05390328f, -0.19806787f, -0.03741508f, 0.00945789f, 
    0.05412532f, 0.14207454f, 0.06725176f, -0.17392616f, -0.02156965f, -0.04149057f, -0.12312409f, -0.12833941f, 
    -0.05752404f, 0.03965162f, 0.01916859f, 0.04210663f, -0.11556362f, -0.13046558f, -0.12924248f, -0.03034980f, 
    -0.14561465f, -0.31026620f, -0.19407183f, 0.14054495f, 0.10956088f, 0.09251063f, 0.00637491f, 0.06119835f, 
    -0.00884139f, -0.04548305f, -0.01941510f, 0.08760925f, -0.13754886f, 0.13452253f, 0.11649632f, 0.09380991f, 
    0.02030161f, -0.02220692f, 0.01119903f, 0.11800709f, -0.03251270f, 0.20159431f, 0.20262709f, -0.00300479f, 
    -0.45816427f, -0.38718167f, 0.01584941f, -0.22422263f, 0.00073224f, -0.07164101f, -0.10400700f, -0.11783450f, 
    0.05660295f, 0.03414914f, 0.08986308f, 0.07951428f, -0.03836267f, -0.00006979f, -0.13057989f, -0.03669107f, 
    -0.01597776f, -0.07240018f, 0.06251514f, -0.03465071f, -0.03376210f, -0.07501092f, -0.01008534f, -0.08377581f, 
    -0.23686939f, -0.10141787f, -0.04428669f, 0.35467041f, -0.04075076f, 0.01170195f, 0.16270083f, 0.05813352f, 
    -0.00377610f, 0.07516113f, 0.03298288f, -0.09603625f, -0.07834516f, 0.12845750f, -0.06735529f, 0.04313524f, 
    -0.02970722f, 0.11760401f, 0.01286714f, 0.10764218f, -0.03107192f, -0.07739661f, 0.06886104f, 0.09432636f, 
    -0.00962745f, -0.09812694f, 0.15137202f, 0.11054922f, 0.07801723f, 0.17280276f, -0.00810078f, -0.36222345f, 
    -0.02963442f, 0.01062812f, -0.00226021f, -0.02734623f, 0.03786398f, 0.05500300f, 0.00206947f, 0.01748814f, 
    0.05160520f, -0.00792271f, 0.00910845f, -0.03818380f, 0.01597015f, -0.04361781f, -0.00225890f, 0.08057054f, 
    -0.03605108f, -0.20423442f, -0.06057226f, -0.15924111f, -0.09570134f, 0.21785878f, 0.00315166f, 0.07019674f, 
    0.01830095f, 0.01313130f, -0.04920673f, 0.12778634f, -0.11043900f, 0.12044114f, -0.04977947f, 0.14527005f, 
    0.04839297f, -0.03743841f, 0.07739151f, 0.00875842f, 0.03772501f, -0.02200378f, 0.09681663f, -0.06677365f, 
    -0.24691951f, -0.29604745f, -0.31895208f, -0.13851678f, -0.01631572f, 0.02273673f, -0.17215459f, -0.10605997f, 
    -0.03166704f, 0.03170860f, 0.00263182f, -0.03951096f, -0.18237107f, 0.10003681f, 0.20463820f, 0.13879153f, 
    -0.02411458f, -0.02396181f, -0.09349191f, -0.03736874f, -0.01236684f, -0.05091568f, 0.16524202f, 0.08836511f, 
    0.04211633f, 0.01517812f, 0.04211001f, -0.45409870f, 0.03239793f, -0.03294696f, 0.04164363f, -0.09046140f, 
    -0.03291146f, 0.05564852f, -0.03575412f, -0.01483822f, -0.56238854f, -0.52609253f, -0.23493995f, -0.00439654f, 
    -0.05441144f, -0.00454279f, -0.20341827f, -0.19557573f, 0.02336956f, -0.05947765f, -0.01327220f, -0.04704139f, 
    0.08790305f, -0.33276954f, -0.00842479f, 0.42772785f, 0.10691287f, 0.00848284f, 0.06700771f, 0.01586879f, 
    -0.10083895f, 0.02824163f, -0.00869197f, 0.08266732f, -0.37393942f, -0.32476008f, -0.32571277f, -0.25781199f, 
    -0.21715072f, -0.10456634f, 0.17303678f, -0.09648472f, 0.07151306f, 0.04124428f, 0.01412459f, 0.01264134f, 
    0.14205515f, 0.09171367f, -0.05694824f, -0.11239979f, 0.07982875f, -0.05094278f, -0.05622314f, -0.01747324f, 
    -0.00067023f, 0.12133573f, 0.11841756f, 0.06786495f, -0.05381668f, -0.00285260f, -0.02244273f, 0.00789961f, 
    -0.02739992f, 0.01478198f, 0.10320256f, 0.03581927f, 0.11074834f, 0.16285445f, 0.09085199f, 0.04776348f, 
    0.04735088f, 0.03663466f, -0.10432265f, -0.18448253f, 0.03964983f, 0.05789278f, -0.00491845f, 0.00451369f, 
    -0.05469439f, -0.02859124f, 0.00070011f, -0.16129318f, -0.71364719f, -0.29407898f, -0.24659970f, -0.09618822f, 
    -0.03244794f, 0.07499741f, -0.26427597f, -0.18825127f, 0.00834013f, -0.07968124f, 0.13517995f, 0.00968139f, 
    -0.37684953f, -0.14250933f, 0.26208398f, 0.01562634f, -0.15295485f, -0.29148024f, -0.07782019f, -0.10574891f, 
    -0.08920678f, -0.00576454f, -0.08559616f, -0.04466781f, -0.04044619f, 0.10112119f, 0.00307926f, 0.02788290f, 
    0.16159005f, -0.02151304f, -0.07715412f, 0.08513804f, 0.01280212f, -0.07832662f, 0.09125662f, 0.00776015f, 
    -0.42047089f, -0.60423541f, -0.12367427f, -0.49095494f, -0.10952881f, -0.11984538f, -0.04949480f, -0.24581017f, 
    -0.00836606f, -0.05902708f, 0.06146377f, -0.04863742f, -0.30311039f, 0.16135944f, 0.31412458f, 0.51978618f, 
    0.01807846f, -0.09888456f, -0.07406653f, -0.09639019f, -0.01901880f, 0.01265290f, 0.04992073f, 0.00060456f, 
    0.28045025f, 0.01229153f, -0.03635839f, -0.16418523f, -0.02219519f, -0.03500230f, -0.02806288f, 0.05913951f, 
    0.07668438f, 0.03904646f, 0.01592089f, -0.17910363f, -0.39833856f, -0.04122932f, -0.09153928f, 0.21431100f, 
    -0.02651110f, -0.05532583f, 0.02700809f, -0.01576069f, 0.01310249f, 0.07125471f, 0.02987583f, -0.07146350f, 
    0.10955546f, -0.11558182f, -0.07602321f, 0.01640647f, -0.06679014f, -0.12185687f, -0.09721469f, 0.09773500f, 
    -0.05977831f, 0.03117310f, -0.02074206f, -0.00189704f, -0.61487442f, 0.03416273f, 0.10031163f, -0.03912526f, 
    0.00869477f, 0.05010589f, 0.08453035f, -0.09529989f, -0.04091257f, 0.02688050f, 0.01624094f, 0.07003084f, 
    -0.02416449f, 0.15177853f, -0.04073422f, -0.03578640f, -0.00256782f, -0.04513035f, 0.06266071f, 0.02716450f, 
    0.03893516f, 0.02248657f, -0.02646091f, -0.05020386f, 0.53174800f, -0.49602020f, -0.50181949f, -0.30433145f, 
    -0.14079395f, -0.06203744f, -0.28046700f, 0.13684106f, 0.02228839f, 0.11576308f, 0.03409756f, -0.01922695f, 
    -0.09825434f, 0.26461318f, -0.04324769f, 0.02899092f, -0.00884121f, 0.01268427f, -0.00167499f, -0.03674126f, 
    -0.09915841f, -0.11961664f, -0.04250614f, -0.12209650f, 0.07636032f, -0.00316960f, 0.04370249f, -0.29994059f, 
    -0.01918167f, 0.01225043f, -0.00796671f, -0.01461830f, -0.03097715f, -0.00767808f, -0.06061967f, -0.24486147f, 
    -0.22438599f, 0.24825259f, 0.26125470f, 0.23658088f, 0.01612717f, -0.22772142f, 0.17281576f, 0.03078078f, 
    -0.09604608f, 0.03774105f, -0.01477248f, 0.08746616f, -0.04115220f, 0.13619564f, -0.15450169f, 0.14074765f, 
    -0.03443940f, -0.02475995f, -0.00296314f, -0.04383072f, -0.11014871f, 0.05044973f, -0.12771751f, -0.11649358f, 
    0.48258722f, -0.07350514f, -0.28955483f, -0.39269736f, -0.04370411f, -0.00222372f, -0.05809274f, 0.01344216f, 
    -0.02191076f, 0.02186266f, 0.09413473f, 0.00467263f, 0.04534254f, -0.00851906f, 0.12004725f, -0.00183082f, 
    -0.03946004f, -0.01543682f, -0.04537836f, -0.01223395f, 0.08343782f, -0.14655028f, -0.01309375f, 0.00795966f, 
    -0.09957115f, -0.23027296f, -0.25152135f, -0.17894806f, 0.01163245f, -0.06998360f, -0.08540706f, 0.17282405f, 
    0.02696772f, 0.01339443f, -0.02925976f, 0.05713414f, -0.11416917f, -0.35222915f, -0.42038625f, -0.39543787f, 
    -0.07528893f, 0.09367397f, 0.11559700f, 0.08588813f, -0.05956411f, 0.06482057f, 0.02791645f, -0.04919621f, 
    -0.17919581f, 0.28490347f, -0.35432100f, 0.21809493f, -0.07428842f, -0.23058450f, 0.02581779f, 0.00410023f, 
    0.05280175f, 0.00504499f, 0.01705914f, 0.05640854f, 0.31530294f, 0.22647883f, -0.17825365f, -0.07824412f, 
    -0.08555776f, 0.14942320f, -0.01007779f, -0.02182779f, -0.04754003f, -0.01118843f, 0.09187160f, -0.05148244f, 
    -0.05257809f, -0.42823920f, 0.17356658f, -0.34551048f, -0.04911102f, -0.09524234f, -0.09519781f, 0.25223875f, 
    0.01633615f, -0.04702391f, -0.03286576f, -0.06511693f, 0.04830156f, -0.06711908f, -0.13976251f, 0.01242437f, 
    -0.02081768f, -0.10451552f, -0.09691130f, -0.09417877f, -0.11805449f, 0.06554275f, -0.02434744f, 0.03785564f, 
    -0.06802196f, 0.13683581f, 0.10082452f, 0.00753885f, 0.00481630f, 0.03724031f, 0.08054364f, 0.01480883f, 
    0.01891840f, -0.03443278f, -0.07916422f, 0.00926135f, -0.16530970f, 0.26653615f, -0.19810414f, 0.03519368f, 
    -0.04288036f, -0.01425774f, 0.03917555f, 0.12642318f, -0.04156611f, 0.05928178f, 0.04756631f, -0.02805678f, 
    -0.05308506f, -0.01945281f, -0.05202313f, 0.02448154f, -0.12294350f, -0.04642802f, -0.13824356f, -0.10966185f, 
    -0.05627079f, 0.03859178f, -0.01982326f, -0.01106095f, -0.10317177f, -0.06777744f, -0.02295398f, -0.17433913f, 
    -0.14601053f, -0.06831416f, -0.01061669f, -0.05568608f, -0.04431224f, -0.03828824f, -0.03265327f, 0.03288367f, 
    -0.23836853f, 0.22448263f, 0.28104761f, 0.20847848f, 0.09112181f, 0.01952002f, 0.03753350f, 0.04183093f, 
    -0.03034025f, -0.04894502f, 0.08999032f, 0.05337381f, 0.16785488f, 0.05025468f, 0.02911989f, -0.24266544f, 
    0.05131818f, 0.12284322f, 0.00342529f, 0.01311068f, 0.01533148f, 0.04121991f, -0.05888034f, 0.04900214f, 
    -0.33586398f, -0.27924865f, -0.37130538f, -0.08914390f, 0.11951191f, -0.24394600f, 0.08910550f, 0.01829544f, 
    0.00888860f, 0.02926411f, -0.02151332f, 0.03644615f, 0.07896934f, 0.03902738f, 0.03424370f, -0.14146157f, 
    -0.03327592f, 0.04635118f, 0.03033081f, 0.04436647f, -0.07106766f, -0.06762067f, 0.01661556f, -0.06562768f, 
    -0.09234460f, 0.03789282f, 0.09167776f, 0.08215696f, -0.11863913f, -0.18173777f, -0.11065207f, 0.08604374f, 
    -0.05100402f, -0.02379934f, 0.02087637f, 0.06813200f, -0.17730615f, 0.17085713f, -0.16754971f, -0.01327163f, 
    0.01310415f, 0.00796256f, -0.01209461f, -0.10346920f, 0.03815202f, -0.01118306f, 0.02945509f, 0.00070689f, 
    0.06328314f, 0.04161658f, -0.03744766f, -0.09464288f, -0.18513586f, 0.03360964f, 0.04279064f, 0.06554730f, 
    0.01570380f, -0.00971810f, 0.00933351f, -0.04890285f, -0.06744487f, -0.35284275f, -0.33717859f, -0.34321356f, 
    -0.01227872f, 0.05193648f, -0.01913829f, 0.14020468f, 0.14070424f, -0.06283906f, -0.00214648f, 0.03446843f, 
    -0.01866278f, 0.00359136f, 0.00901757f, 0.07980627f, 0.00293057f, -0.08471204f, -0.15781148f, -0.08395757f, 
    0.01998382f, -0.03070537f, 0.03312608f, 0.01205994f, 0.07708105f, -0.04561305f, -0.12951554f, 0.00147884f, 
    0.00925852f, 0.03099316f, 0.01445669f, -0.03793945f, -0.08772959f, 0.08055671f, -0.07509499f, -0.01347381f, 
    -0.39751136f, -0.34781003f, -0.08349273f, -0.07737034f, 0.12186219f, 0.20804477f, 0.06702544f, 0.08611426f, 
    0.00716349f, -0.00033903f, 0.02019120f, -0.01622988f, 0.04338193f, -0.41994268f, 0.38018984f, -0.55515349f, 
    -0.01079508f, -0.00752280f, -0.21385780f, 0.21864823f, 0.01829498f, -0.02168110f, 0.00955932f, -0.03988918f, 
    0.09644259f, 0.50287056f, 0.15615083f, 0.15793908f, -0.04271595f, -0.06262036f, -0.04992206f, 0.00381051f, 
    0.01536703f, -0.05066330f, 0.05538478f, -0.10716742f, -0.21989515f, 0.18290801f, -0.04512367f, -0.06899956f, 
    0.13373251f, -0.04668132f, -0.04192318f, 0.04593419f, 0.03533660f, 0.03982337f, 0.02531720f, 0.07461761f, 
    0.15343645f, -0.64703000f, -0.57346106f, -0.18640511f, -0.06771177f, -0.17177905f, 0.00685968f, 0.02378491f, 
    0.15855032f, 0.05306143f, 0.06800684f, 0.00591333f, -0.04076478f, -0.06596594f, 0.15044315f, -0.24339795f, 
    -0.03082576f, -0.01362483f, -0.03668486f, 0.02913160f, 0.06439659f, 0.01124024f, 0.02543133f, -0.06671748f, 
    0.09352364f, -0.05671907f, -0.09240203f, 0.08955797f, 0.01639858f, 0.04937476f, 0.01548877f, -0.02315886f, 
    -0.05588362f, -0.11537138f, 0.08947585f, -0.01995284f, 0.09343113f, 0.02404345f, 0.05037810f, -0.03563643f, 
    -0.02983473f, -0.08241720f, -0.05300726f, -0.05497915f, 0.02746510f, 0.01006735f, 0.06349459f, -0.03208205f, 
    -0.00441854f, -0.14074792f, 0.06322437f, -0.16571677f, -0.06764593f, -0.07122318f, -0.02916132f, -0.05509157f, 
    0.06360874f, 0.03164782f, -0.01184725f, 0.02421995f, 0.46773580f, 0.01977805f, -0.03267629f, -0.34637874f, 
    0.03768335f, -0.00053044f, -0.04490356f, -0.04050625f, 0.05406557f, 0.10726573f, -0.07375046f, -0.18553929f, 
    -0.31579506f, -0.36536744f, -0.04640359f, 0.33555061f, 0.02706903f, 0.19712421f, 0.01623163f, 0.08604875f, 
    0.16015789f, 0.04107440f, -0.00731091f, -0.00272351f, 0.01251046f, 0.03140744f, -0.02809919f, 0.02840772f, 
    0.01590438f, 0.08150742f, 0.04259444f, -0.00384302f, -0.05701973f, -0.01696414f, -0.03210960f, -0.02667779f, 
    -0.16247015f, 0.22529869f, -0.00151465f, 0.18168662f, -0.14501882f, 0.19891118f, -0.07619805f, 0.00797640f, 
    0.07533965f, 0.01657528f, -0.05692337f, -0.00550113f, 0.12349766f, 0.03282003f, 0.00461556f, -0.03414882f, 
    -0.04231716f, 0.01837369f, -0.09934395f, -0.14355433f, 0.02415342f, 0.05861329f, 0.03465514f, -0.00214481f, 
    -0.00308481f, 0.14293061f, -0.14222373f, 0.01898994f, 0.01570103f, -0.04456440f, 0.01357886f, -0.04601238f, 
    -0.10871124f, 0.02128790f, -0.00452149f, 0.02081572f, 0.10184298f, 0.05455862f, 0.04670097f, -0.18685533f, 
    0.00511532f, 0.02953003f, -0.03243272f, -0.02249122f, -0.18605569f, 0.05218524f, -0.01804243f, -0.02461650f, 
    -0.01931068f, 0.19729277f, -0.15035389f, 0.06189673f, -0.10485838f, -0.11483020f, 0.05798512f, 0.04426168f, 
    -0.11954070f, -0.11240731f, 0.01433841f, 0.03158444f, -0.16681300f, -0.03720006f, -0.02595574f, 0.09106174f, 
    -0.01169218f, 0.06795014f, 0.14768600f, -0.08407782f, 0.05919534f, 0.02174045f, -0.04466525f, 0.01302117f, 
    -0.10997891f, -0.25683874f, -0.31805941f, 0.04990206f, -0.07439592f, 0.32658383f, -0.12281711f, -0.01942262f, 
    0.07222353f, 0.02874909f, 0.00360247f, -0.02287033f, 0.21484661f, 0.07371361f, -0.17756864f, -0.19450992f, 
    0.02146072f, -0.03575769f, -0.05022544f, -0.07145141f, 0.01659954f, -0.00935680f, -0.04168483f, -0.00170649f, 
    -0.05236319f, 0.07995560f, -0.10452337f, 0.11882786f, 0.03682499f, 0.01182877f, 0.01968030f, -0.02247975f, 
    0.01617594f, -0.01520466f, 0.00218539f, -0.05052005f, -0.43591601f, -0.33282939f, 0.06365358f, 0.08746509f, 
    -0.01177487f, -0.10641038f, 0.03771294f, 0.03379354f, -0.04372171f, -0.00454501f, -0.02616668f, -0.03104242f, 
    0.16506039f, -0.25865775f, 0.22575895f, -0.31103697f, -0.08166054f, 0.02063542f, -0.21510176f, -0.00389390f, 
    -0.05674046f, -0.00748283f, -0.01559389f, -0.00252131f, -0.21848796f, -0.15623081f, -0.26740888f, 0.18648496f, 
    0.07260524f, -0.07709052f, -0.01078948f, 0.07358906f, -0.01654009f, -0.03846773f, -0.07530266f, -0.01179346f, 
    0.08485147f, -0.04599359f, 0.08450267f, -0.19023338f, 0.02661761f, 0.01901914f, -0.02727487f, -0.00080763f, 
    0.06222911f, -0.06552146f, -0.07939324f, -0.14652130f, -0.01075951f, 0.09381746f, -0.05577912f, 0.00455541f, 
    -0.05834794f, -0.09794006f, 0.03450007f, 0.04558204f, 0.07060249f, -0.01229357f, 0.10384410f, 0.03084466f, 
    0.03690513f, 0.07689932f, 0.06316358f, 0.02401379f, 0.04828287f, 0.00599715f, -0.01029464f, -0.02417220f, 
    0.04279023f, -0.04259539f, 0.00449146f, 0.04940589f, -0.00807362f, -0.65636361f, 0.29190072f, 0.24888839f, 
    -0.01147964f, 0.08465574f, 0.02645142f, 0.00522784f, -0.06485519f, 0.01280588f, 0.06259986f, -0.03108535f, 
    0.33570674f, -0.10149103f, 0.10469717f, -0.04943339f, -0.02330563f, -0.12039293f, -0.21811907f, -0.00448456f, 
    -0.03244577f, 0.06073501f, -0.01589461f, 0.04124995f, 0.06496461f, -0.03963290f, 0.04594681f, -0.07487566f, 
    -0.00287442f, 0.01061772f, -0.01952599f, -0.02029746f, -0.03812720f, 0.00550881f, -0.07615314f, -0.03956461f, 
    -0.31561905f, 0.05408438f, 0.10605589f, 0.54245394f, 0.02949951f, 0.14399394f, -0.05355196f, 0.03208904f, 
    -0.04471495f, 0.00203702f, -0.05885758f, -0.05564294f, 0.03774365f, -0.12665580f, 0.01078943f, -0.20708671f, 
    -0.02250323f, -0.00217498f, -0.03922322f, 0.02246230f, 0.06099042f, -0.09919004f, -0.03615366f, -0.11894631f, 
    0.11794796f, 0.00228987f, 0.03433012f, -0.44611517f, -0.20969042f, -0.12026465f, -0.03483764f, -0.01163912f, 
    0.06076423f, -0.00799895f, -0.00747856f, 0.13550654f, -0.60430896f, -0.12918682f, 0.15152282f, 0.16857912f, 
    -0.01984820f, 0.11633889f, -0.04665404f, 0.01318391f, -0.03933850f, 0.03209155f, -0.02855343f, -0.08258758f, 
    0.28372735f, 0.04047773f, -0.00053383f, -0.14086609f, -0.14270252f, -0.09722383f, 0.00774460f, -0.03342514f, 
    0.14151278f, 0.02971929f, 0.12107165f, 0.04955065f, 0.18657060f, -0.11168160f, 0.20192362f, 0.01885045f, 
    0.08683207f, 0.05865824f, -0.17267178f, -0.19158407f, 0.00816541f, -0.00591048f, 0.02757200f, -0.03342323f, 
    -0.05528606f, 0.16324788f, -0.08430933f, 0.15148857f, -0.07505071f, 0.00461032f, -0.11445651f, -0.06037531f, 
    -0.09706365f, 0.14050423f, 0.00825866f, -0.07340430f, -0.15426543f, -0.15743299f, -0.35786623f, 0.02968328f, 
    -0.07949781f, 0.04780712f, 0.19286557f, 0.17384547f, 0.11011168f, -0.06830891f, 0.03859111f, 0.08182842f, 
    -0.25323626f, -0.10635146f, 0.13683607f, 0.08734690f, 0.08235911f, 0.00865634f, -0.11706836f, 0.13549009f, 
    0.00521196f, 0.01292356f, -0.02446779f, 0.11299419f, 0.26942036f, 0.08665611f, -0.15144417f, -0.19574596f, 
    -0.06527518f, -0.07847745f, -0.01748454f, -0.00679251f, 0.02340364f, -0.06047376f, 0.13378723f, 0.08836969f, 
    -0.13438728f, -0.34159461f, 0.30531368f, 0.00714790f, -0.01098407f, 0.13004644f, -0.08662611f, 0.05193397f, 
    -0.06076108f, -0.02751975f, 0.07267414f, 0.07117102f, -0.16300648f, 0.10953182f, 0.04849092f, 0.09155087f, 
    0.03178658f, 0.01816927f, -0.10688131f, 0.07497561f, 0.11370230f, -0.02173655f, 0.07111546f, 0.13893747f, 
    -0.04739365f, -0.44918528f, -0.32260591f, -0.14301926f, 0.01062649f, -0.02457621f, 0.02742779f, 0.07121108f, 
    0.04145018f, 0.12008405f, -0.05603188f, 0.10625936f, -0.18785287f, 0.07483403f, 0.02539200f, -0.05930341f, 
    0.01883124f, -0.05220541f, -0.02920839f, 0.02605157f, -0.03249868f, 0.08133814f, 0.00629251f, -0.06140562f, 
    -0.04403928f, -0.36848101f, -0.44016549f, -0.15157567f, -0.08150198f, -0.07097103f, 0.03364466f, -0.04968033f, 
    0.00913960f, 0.00654620f, 0.01686458f, -0.00872459f, -0.36304522f, -0.19849482f, 0.17272812f, 0.26214904f, 
    -0.04703907f, 0.09404871f, 0.08948753f, 0.02230079f, 0.08302314f, -0.01013668f, 0.18004863f, 0.18471421f, 
    0.12181990f, -0.11944799f, -0.15480670f, -0.09856221f, 0.00449575f, 0.12730843f, 0.01251031f, 0.08850077f, 
    -0.03508653f, 0.16224135f, -0.13484687f, -0.36073282f, 0.11004118f, -0.07787414f, -0.14386407f, -0.03039621f, 
    0.09317986f, 0.00489823f, 0.02115079f, 0.05628106f, 0.12768757f, 0.06311335f, 0.05618463f, -0.01684623f, 
    0.42578056f, 0.24549513f, -0.26985219f, -0.25843915f, -0.06931896f, -0.02946402f, 0.00993257f, -0.19042598f, 
    0.00793675f, -0.04334275f, 0.03274450f, 0.01981735f, 0.02915560f, -0.03029096f, 0.13504772f, -0.07132739f, 
    -0.00363839f, 0.06126883f, 0.03593963f, -0.01592028f, -0.10871074f, 0.06044132f, -0.10616046f, 0.01752494f, 
    -0.32099104f, -0.09389709f, 0.00712560f, 0.10494500f, -0.07224896f, -0.07030248f, 0.03579662f, 0.01995728f, 
    0.09353361f, 0.07298891f, 0.14934228f, 0.16189829f, -0.60668921f, 0.03027800f, 0.23331173f, 0.23792468f, 
    -0.00000866f, -0.03675136f, -0.15235370f, 0.00946965f, -0.24031465f, -0.06018791f, 0.09487837f, -0.05262714f, 
    -0.01321113f, 0.07420629f, -0.10542319f, 0.02058394f, 0.11358957f, 0.01914602f, 0.00444429f, 0.03381076f, 
    -0.01374157f, 0.03530323f, 0.05921304f, 0.10580792f, -0.05948697f, -0.22537783f, -0.10624739f, -0.02139738f, 
    0.25631776f, 0.08804353f, 0.14553580f, 0.12811954f, -0.14479923f, -0.15225406f, -0.03807223f, -0.09536809f, 
    -0.02815886f, -0.26153728f, -0.24980626f, -0.29248753f, -0.28604251f, -0.05196505f, 0.15530802f, -0.06505436f, 
    -0.04278383f, 0.04380481f, 0.05926825f, 0.04161212f, 0.02848824f, -0.11499669f, -0.15544929f, -0.26925331f, 
    -0.06391887f, -0.07154243f, 0.04894733f, -0.01673752f, 0.13566317f, 0.02251654f, 0.13235593f, 0.11597401f, 
    -0.06895345f, -0.58515131f, -0.34415373f, 0.32597527f, -0.03789078f, 0.13838123f, -0.04414077f, -0.04507534f, 
    -0.03609674f, -0.00928808f, 0.04280143f, 0.00761545f, 0.07145798f, 0.03517247f, 0.01283382f, -0.04248050f, 
    -0.03509196f, -0.05869782f, -0.01101675f, 0.00516210f, 0.07452647f, 0.11504452f, 0.03704767f, 0.14837499f, 
    -0.06244148f, -0.03527436f, -0.04957350f, -0.06255861f, 0.07390861f, -0.03732048f, 0.07071105f, 0.06978043f, 
    0.13871802f, 0.02523175f, 0.01378261f, -0.00809341f, -0.46608427f, 0.04274143f, 0.09812789f, 0.17168544f, 
    0.11778954f, -0.13517523f, -0.01571599f, -0.02678110f, 0.04506500f, -0.04944414f, 0.01870152f, -0.02527139f, 
    -0.02079480f, -0.00384054f, -0.03664566f, 0.12311187f, 0.05064594f, -0.07321320f, -0.05590106f, 0.04764784f, 
    0.07348954f, 0.02814013f, 0.02523742f, 0.09221819f, -0.06332046f, -0.39380640f, -0.48568717f, 0.07697603f, 
    0.19710276f, 0.05118249f, 0.20227374f, 0.00209925f, -0.11798571f, -0.05489036f, 0.01304239f, -0.13794573f, 
    -0.10107993f, 0.13621873f, 0.00535709f, 0.10656717f, 0.10106270f, 0.00570991f, -0.12347367f, 0.04229695f, 
    0.08534048f, 0.04115579f, 0.02220520f, 0.05979986f, 0.15622941f, 0.07920169f, 0.17973773f, -0.02014214f, 
    -0.10660537f, -0.06570525f, -0.03080313f, -0.01241644f, 0.01191463f, -0.05297857f, 0.10116808f, -0.04870760f, 
    -0.10557567f, -0.47722179f, -0.23916630f, 0.15995127f, -0.33914471f, 0.02817725f, 0.15745349f, 0.11279544f, 
    -0.07274594f, -0.02826361f, 0.00199479f, -0.02782020f, 0.31516770f, 0.05208085f, -0.29094425f, -0.32298538f, 
    0.01281178f, -0.09593904f, 0.01576504f, -0.12050772f, 0.04328164f, 0.00579750f, -0.00485527f, 0.09080582f, 
    -0.45256832f, -0.02887029f, -0.01174231f, -0.07958078f, -0.05077975f, 0.04173737f, 0.00691448f, 0.03133315f, 
    -0.01964908f, 0.08656456f, 0.00534758f, -0.04886803f, -0.25620276f, 0.08230107f, 0.08125197f, 0.11879692f, 
    0.04745756f, 0.01205948f, -0.16610679f, -0.28040102f, -0.04762430f, -0.02293064f, -0.07629552f, -0.04786684f, 
    -0.17284431f, -0.29048628f, -0.16925044f, 0.01317293f, 0.06072067f, 0.06703705f, 0.12498613f, 0.12969521f, 
    -0.12631148f, -0.14861068f, -0.18832603f, -0.13853627f, 0.17511979f, 0.03288799f, -0.00538851f, -0.11114813f, 
    -0.01847907f, -0.03105958f, 0.01300542f, -0.00436078f, -0.06955121f, 0.04999235f, 0.00842192f, 0.05912882f, 
    -0.03899797f, -0.14676443f, -0.22324722f, 0.13294198f, 0.02007410f, 0.08745248f, -0.00041892f, 0.04895875f, 
    0.18161228f, 0.13586186f, 0.13340041f, 0.09439942f, -0.08859346f, 0.08147549f, 0.01964751f, -0.11946946f, 
    0.01891618f, -0.00215635f, -0.01084170f, -0.05457219f, -0.06021004f, -0.10945264f, -0.03080874f, -0.08602627f, 
    0.27911237f, 0.12548813f, 0.03194659f, -0.06342485f, -0.10078581f, -0.04122240f, 0.04718727f, -0.06215166f, 
    -0.01674632f, 0.06719984f, 0.06084254f, -0.05390921f, 0.04649141f, -0.16317719f, -0.20452927f, -0.24625725f, 
    0.01783397f, -0.00030650f, 0.01183382f, -0.10576243f, 0.02625062f, -0.03480836f, 0.08398353f, -0.15306453f, 
    0.01814660f, -0.33256811f, -0.35620910f, -0.38866165f, 0.02246950f, 0.11181258f, 0.04276604f, 0.14626692f, 
    -0.11630482f, -0.12553720f, -0.12270606f, -0.24456894f, -0.18198755f, 0.09640152f, 0.01309825f, 0.08006728f, 
    -0.06994335f, -0.04916253f, -0.05886593f, -0.04016863f, 0.01728153f, 0.05312891f, 0.02492762f, 0.13512000f, 
    -0.09607561f, 0.17443299f, -0.07345115f, 0.17230996f, 0.09179895f, -0.06595838f, 0.14981936f, -0.07071258f, 
    -0.02703370f, 0.01806356f, -0.08776098f, 0.07084924f, 0.26333919f, 0.17441785f, 0.09235881f, -0.12991291f, 
    0.05868075f, -0.03938135f, -0.00713791f, 0.12217046f, -0.05106506f, -0.11506542f, 0.02062757f, 0.08135159f, 
    -0.03924912f, -0.00286700f, 0.03161248f, 0.09873293f, -0.03316981f, 0.09672931f, 0.07836677f, 0.16333833f, 
    0.00682229f, 0.05541690f, 0.02632507f, -0.06985989f, -0.06471612f, -0.07114822f, 0.02495702f, -0.13644685f, 
    0.02057365f, -0.04293328f, 0.06086779f, -0.01246193f, 0.08832811f, -0.00049567f, 0.05145469f, 0.05094462f, 
    0.03726216f, 0.09889602f, 0.10320620f, 0.10321449f, 0.20474514f, -0.05695415f, -0.02502342f, 0.09912264f, 
    0.05779222f, 0.00188415f, -0.03946644f, -0.00934267f, -0.23986481f, -0.19290966f, -0.04157013f, 0.03942440f, 
    0.14331548f, 0.03983195f, -0.00712481f, -0.09452453f, -0.00839012f, -0.02720380f, -0.10334405f, 0.04294110f, 
    -0.25474262f, -0.18989125f, -0.15995888f, 0.08041534f, 0.12102574f, 0.10209745f, -0.00768188f, 0.18867284f, 
    -0.00522506f, 0.00534259f, 0.04722944f, 0.05151430f, -0.08697080f, -0.07223638f, -0.11964305f, -0.11962815f, 
    -0.02430008f, 0.13473800f, 0.03929253f, 0.07226028f, 0.11675064f, -0.05061773f, 0.09527317f, 0.05589378f, 
    -0.71883047f, 0.09832529f, 0.16423856f, 0.14156017f, -0.10127475f, -0.06413449f, -0.12981626f, -0.01120089f, 
    -0.09995532f, -0.05278424f, -0.07567937f, -0.01662678f, -0.09468877f, -0.34791279f, -0.25384584f, -0.02441166f, 
    -0.18976258f, -0.10826776f, 0.07923142f, -0.07244483f, 0.00788762f, 0.05177715f, 0.12171829f, -0.00261295f, 
    0.26963228f, 0.11208680f, -0.01487482f, -0.01932559f, 0.10525762f, -0.10919419f, -0.05522780f, -0.19616082f, 
    0.03125349f, 0.06934450f, 0.07109992f, 0.08237405f, 0.00764515f, -0.02794314f, 0.06983935f, 0.16964872f, 
    -0.15756842f, 0.12325139f, 0.03357823f, -0.10967679f, -0.03011939f, -0.02794965f, -0.07586948f, 0.01697565f, 
    0.03744794f, -0.03032429f, -0.00786636f, -0.23982179f, -0.04454560f, -0.01994213f, -0.04870765f, -0.03032293f, 
    0.02029240f, -0.02081482f, 0.07107469f, 0.02090974f, -0.07930794f, -0.02426996f, -0.04144340f, 0.00245895f, 
    -0.05751817f, 0.10602948f, 0.06208537f, -0.01497135f, -0.13871571f, -0.04387123f, -0.23472221f, -0.32122323f, 
    -0.30347604f, 0.05857121f, -0.00576563f, -0.09145796f, -0.03640151f, -0.04432469f, 0.00989907f, -0.08278152f, 
    -0.22064343f, -0.11266169f, -0.18081342f, -0.08562004f, 0.48881549f, -0.36665910f, -0.16621967f, -0.28465298f, 
    -0.05185647f, 0.14667934f, 0.11529890f, -0.02554273f, 0.00462503f, 0.12911277f, 0.04813168f, 0.05143055f, 
    0.05855074f, -0.12422530f, -0.23799397f, -0.07697546f, 0.17892161f, -0.02605734f, 0.11822993f, 0.01252372f, 
    -0.06615093f, 0.04897918f, 0.09331338f, 0.03103182f, -0.10554069f, -0.02749740f, -0.00448373f, -0.12293932f, 
    0.00270534f, -0.00445299f, 0.01128614f, -0.00324909f, 0.02209295f, 0.09807883f, 0.07674018f, 0.11855685f, 
    -0.43797439f, -0.22881079f, -0.11764994f, -0.17526652f, 0.07343924f, -0.19900639f, -0.11735382f, 0.04690079f, 
    0.11375774f, 0.07022817f, 0.04408439f, 0.06928879f, -0.18300907f, -0.07659244f, 0.01600515f, 0.21333729f, 
    -0.09580315f, 0.01108937f, 0.15454447f, -0.00536701f, 0.13263524f, -0.02028719f, 0.01132737f, 0.11513138f, 
    -0.43863901f, -0.11003341f, 0.25802621f, 0.02859520f, 0.07362062f, 0.14910726f, -0.18090661f, 0.01123858f, 
    -0.15251109f, -0.11102384f, 0.05629774f, 0.05781123f, -0.06548242f, 0.22427283f, 0.44405138f, -0.47416309f, 
    -0.03271280f, -0.11631835f, 0.04702828f, 0.06758419f, -0.03863251f, 0.21324380f, 0.09078009f, 0.01403052f, 
    -0.23999751f, -0.15235990f, 0.01798131f, -0.14787625f, 0.06505676f, -0.10290181f, -0.16940211f, 0.37115887f, 
    -0.03114281f, -0.03843161f, 0.01667646f, -0.04372452f, 0.00679761f, -0.14541535f, -0.67939907f, -0.03567059f, 
    -0.00791922f, -0.15989140f, -0.04774364f, 0.16851062f, -0.00620435f, 0.01095175f, 0.00233249f, -0.02944252f, 
    -0.10867465f, -0.03544267f, -0.16883676f, 0.11850711f, -0.09256424f, 0.04811572f, 0.03398227f, 0.17002197f, 
    0.11154912f, -0.00783555f, -0.14556460f, -0.03153697f, -0.04144819f, 0.15014392f, -0.22812663f, 0.29753622f, 
    -0.13672630f, 0.15501739f, -0.27248549f, 0.00200374f, 0.07858742f, -0.11125942f, 0.07236386f, 0.13912544f, 
    0.08728430f, 0.16326420f, -0.20056106f, -0.42908472f, -0.06551068f, -0.01531627f, 0.08907378f, -0.01810839f, 
    0.02342238f, 0.01389994f, -0.02304575f, 0.12328756f, 0.02029087f, -0.32873991f, 0.19803856f, 0.09088215f, 
    0.04686405f, 0.08835566f, -0.09660729f, -0.14227425f, -0.05858439f, 0.09284623f, -0.02574465f, 0.02434642f, 
    0.16712013f, -0.34017476f, 0.13011365f, -0.52381253f, -0.03753188f, -0.01811914f, -0.09699612f, 0.15255876f, 
    0.05623590f, 0.04251785f, 0.01323127f, 0.13500431f, -0.51111501f, -0.02797524f, -0.00546348f, -0.00830572f, 
    -0.01251816f, -0.09347896f, 0.04223863f, 0.16180094f, -0.13084574f, 0.06335595f, 0.03177077f, -0.23528872f, 
    0.13285196f, 0.26742166f, -0.00810195f, 0.32028735f, -0.14966589f, -0.04890138f, -0.17625397f, -0.16355276f, 
    0.14330047f, -0.14293334f, -0.04592435f, 0.02329067f, 0.00721105f, -0.09292289f, -0.17287831f, -0.09894496f, 
    0.04544137f, 0.13138898f, 0.13851669f, -0.02523071f, 0.17961118f, 0.12338670f, -0.01780679f, -0.02043698f, 
    -0.29581800f, 0.02709417f, 0.03152861f, -0.17269042f, 0.01842915f, -0.04573517f, 0.07482658f, 0.03734374f, 
    0.04633446f, 0.08967963f, 0.09093762f, -0.02972961f, 0.32102704f, -0.01861374f, 0.10945597f, -0.55824757f, 
    -0.00359932f, -0.17815952f, -0.06836431f, -0.01316989f, -0.15957770f, -0.06125392f, -0.03059777f, 0.07537151f, 
    -0.62663859f, 0.30818483f, -0.24608037f, -0.11230652f, -0.01520102f, -0.02146445f, 0.01998404f, -0.03392424f, 
    0.12389782f, 0.05570901f, 0.03331476f, 0.13944314f, -0.60527855f, 0.36297527f, -0.23459950f, 0.16597521f, 
    -0.23355512f, -0.15277834f, -0.18005046f, -0.12515534f, 0.14135855f, -0.03807811f, 0.04078180f, -0.13614656f, 
    -0.23670565f, -0.25338700f, 0.11807683f, -0.18346927f, -0.04157765f, -0.00731404f, -0.11100881f, 0.12233094f, 
    0.13868068f, -0.03499801f, -0.03068131f, -0.01647596f, -0.29099202f, -0.13377996f, -0.03620346f, 0.04039989f, 
    0.06285072f, 0.07574110f, -0.05590949f, 0.08280113f, 0.00534388f, -0.04534333f, -0.09637280f, 0.02270293f, 
    0.11306398f, 0.03681980f, 0.07862962f, -0.28420341f, 0.05277568f, -0.08322384f, 0.13208652f, -0.01691844f, 
    -0.17898273f, 0.04089557f, -0.09002221f, 0.02826766f, -0.11193403f, 0.32284281f, -0.49415305f, -0.16638395f, 
    -0.06291334f, 0.01238928f, 0.29142058f, 0.12813324f, 0.10815576f, -0.01650892f, -0.04759455f, 0.08174254f, 
    0.03826939f, 0.34325439f, -0.24308975f, -0.33882123f, 0.05438243f, -0.14590935f, 0.06029291f, 0.01036308f, 
    -0.00767797f, -0.02234683f, -0.15182520f, 0.03824086f, 0.28401986f, -0.10599861f, 0.27253136f, -0.37955859f, 
    -0.03522392f, -0.22924371f, -0.15836324f, 0.02778152f, -0.05790190f, -0.09087017f, 0.12248377f, 0.05981791f, 
    -0.31351632f, -0.01424003f, 0.00933672f, 0.07082988f, 0.14447075f, -0.04783498f, -0.29703459f, -0.16536434f, 
    0.00683893f, 0.09681108f, -0.12316924f, -0.03749680f, 0.12037259f, -0.12039702f, 0.06484066f, 0.22966315f, 
    0.11005978f, 0.02407409f, -0.25235891f, -0.17434616f, -0.30185330f, -0.12499580f, -0.00297964f, -0.03214042f, 
    -0.43571457f, 0.06048692f, 0.25302753f, -0.41131994f, 0.10750916f, -0.11178089f, -0.02652179f, 0.13748017f, 
    -0.01560341f, -0.01580124f, -0.00114985f, -0.02953580f, 0.01315847f, -0.13415118f, -0.04743643f, 0.10533869f, 
    0.11059579f, 0.13409086f, 0.03240875f, -0.02636663f, 0.06074480f, 0.00944261f, 0.01008108f, 0.01726780f, 
    -0.09237824f, -0.05922807f, -0.11105045f, 0.08215214f, 0.07554362f, 0.03452853f, 0.13577032f, 0.00130001f, 
    -0.03218266f, 0.02370854f, 0.01710653f, 0.02883173f, -0.16385800f, 0.12678565f, -0.52404219f, 0.11660693f, 
    0.18595867f, -0.05746052f, 0.14662421f, 0.04811780f, -0.03341137f, -0.10115050f, -0.00546528f, -0.08934375f, 
    -0.04164913f, -0.05911124f, -0.00704575f, -0.02794081f, 0.05557121f, 0.02203450f, -0.00513933f, 0.00426038f, 
    0.04541326f, -0.06957594f, -0.24931277f, 0.09326822f, 0.04908886f, -0.28670624f, 0.00876159f, -0.32917508f, 
    -0.16883649f, -0.09174339f, -0.01796265f, -0.13146351f, 0.14429729f, 0.02661347f, 0.01321772f, 0.08794153f, 
    -0.15102868f, 0.01194961f, -0.38175228f, 0.28290159f, 0.07146354f, 0.16565748f, 0.08510844f, 0.08467343f, 
    -0.01951395f, -0.10501529f, -0.09254450f, -0.08801840f, 0.03066769f, -0.15649159f, 0.06202607f, 0.18362907f, 
    0.00533578f, 0.00244523f, -0.01057224f, 0.06897822f, -0.02783128f, 0.02928904f, 0.07628900f, 0.07251303f, 
    -0.18729085f, 0.36075139f, -0.15483508f, -0.12186930f, -0.35457513f, 0.12069759f, 0.10170855f, 0.25256884f, 
    0.08965996f, 0.05368687f, -0.00506655f, -0.00486964f, -0.21515548f, 0.02251096f, 0.13742934f, 0.01322332f, 
    -0.08386049f, 0.15705833f, -0.10376522f, 0.09422134f, 0.08279114f, 0.04239934f, -0.03565615f, 0.00404191f, 
    -0.27588278f, -0.29815942f, -0.27258125f, 0.10232411f, -0.07766920f, 0.06403363f, 0.09101982f, 0.03594690f, 
    0.05664936f, 0.04666092f, -0.05740838f, -0.04283749f, 0.28760916f, -0.06275825f, -0.24570222f, -0.14275442f, 
    0.11097369f, 0.04345910f, 0.11475606f, 0.12274762f, -0.06838961f, -0.00093701f, -0.00957876f, -0.03009980f, 
    0.31443715f, -0.27108696f, 0.38013625f, 0.22280647f, 0.11131980f, -0.08834523f, -0.06349909f, -0.15427227f, 
    0.02858235f, 0.03912195f, 0.05520176f, 0.01960120f, 0.20017888f, -0.41581139f, 0.04079391f, -0.12342647f, 
    -0.00687240f, 0.03845697f, -0.03707533f, -0.06337842f, -0.03884479f, 0.00391236f, 0.01209357f, -0.14014788f, 
    -0.03088428f, 0.17396677f, 0.10641278f, -0.18346785f, -0.01366258f, -0.05542101f, -0.04809141f, -0.05367294f, 
    -0.09273450f, 0.08211649f, -0.17505261f, 0.03823598f, -0.08618986f, -0.09464430f, -0.12933075f, -0.05128296f, 
    0.11067315f, 0.06532138f, 0.13121635f, 0.02952955f, 0.07210756f, -0.09155416f, 0.08131984f, 0.03260385f, 
    -0.05091822f, -0.49148640f, -0.10999265f, -0.13482752f, 0.03763841f, 0.18523985f, 0.18942623f, -0.01943738f, 
    -0.07931107f, 0.00005921f, -0.09785505f, -0.02054939f, 0.00117990f, 0.00444179f, 0.37254390f, 0.36260787f, 
    0.06657627f, -0.07133611f, -0.24402754f, -0.14570425f, 0.12999651f, 0.07770364f, 0.06456867f, 0.07819376f, 
    -0.20099387f, 0.10643028f, -0.14391124f, 0.06770480f, -0.13332355f, -0.08422337f, -0.03607927f, -0.01956630f, 
    -0.06242637f, 0.08175804f, 0.07291814f, 0.01686009f, -0.11647909f, 0.05873740f, -0.05527574f, -0.08727258f, 
    0.01375032f, 0.00208116f, 0.02563247f, 0.01939233f, 0.07029369f, 0.05848117f, -0.07557122f, -0.01385525f, 
    -0.41846827f, -0.01943272f, -0.52868772f, -0.13496636f, -0.03919519f, -0.16850574f, 0.07547018f, -0.17192259f, 
    0.13596973f, -0.00086941f, -0.11930653f, -0.08775066f, -0.14289238f, 0.02317129f, -0.30746031f, 0.09004551f, 
    0.08758360f, 0.02104886f, 0.09467130f, 0.04582684f, 0.03273719f, 0.04775985f, 0.11135991f, 0.12369334f, 
    -0.19667578f, 0.01488910f, -0.22837506f, -0.18764396f, -0.01848799f, -0.03690908f, 0.08850598f, 0.15769051f, 
    0.16174577f, -0.04766485f, -0.09355585f, 0.04025221f, 0.05215022f, -0.09708583f, 0.02258101f, 0.09399132f, 
    0.05115408f, 0.04957401f, 0.02443949f, -0.08885954f, 0.05452914f, -0.09292585f, -0.10226506f, -0.04526315f, 
    -0.04580299f, 0.01709646f, -0.27126339f, 0.01219213f, 0.02184299f, -0.05708542f, 0.04654367f, 0.14976540f, 
    0.01023331f, -0.04133290f, 0.05601737f, -0.01402546f, 0.24467744f, -0.20308749f, -0.01095389f, -0.20592673f, 
    0.02860770f, 0.03349568f, 0.07821473f, -0.06001502f, 0.13978060f, -0.02045403f, -0.02663645f, -0.01154220f, 
    -0.25853047f, 0.10862091f, -0.35351709f, 0.00167443f, -0.14076191f, -0.05557540f, 0.03861498f, -0.04403603f, 
    0.06614272f, -0.08765567f, 0.06177960f, 0.00148503f, -0.08878805f, 0.33237427f, -0.06030653f, 0.18283741f, 
    0.06843065f, -0.10811063f, -0.06471861f, -0.02515835f, 0.04888904f, -0.17956941f, 0.05600475f, 0.05005866f, 
    -0.20502403f, -0.02514032f, -0.07792092f, 0.08806871f, 0.06300077f, 0.00350740f, 0.10727062f, 0.03725111f, 
    0.02302143f, 0.04492183f, -0.09962741f, 0.01562780f, -0.15679757f, 0.29333335f, 0.21116658f, -0.42196769f, 
    -0.28198493f, -0.13034819f, 0.15413238f, 0.13333060f, -0.04771939f, 0.05724162f, 0.04586542f, 0.00801874f, 
    -0.21398504f, -0.59427464f, 0.15201724f, -0.13514581f, -0.01358841f, 0.12239918f, -0.14175783f, -0.03635257f, 
    0.02353370f, 0.00109586f, 0.03512044f, -0.11958365f, -0.00944947f, 0.19869941f, -0.02267763f, -0.00817543f, 
    -0.05874198f, -0.09883277f, 0.12991478f, 0.12909214f, -0.04777359f, 0.03069740f, -0.02512323f, 0.05249063f, 
    0.01964956f, 0.07129087f, 0.20160599f, 0.23927622f, -0.04908824f, 0.01889308f, -0.06312210f, -0.09002506f, 
    -0.04046404f, 0.15625910f, 0.04916765f, -0.14588240f, -0.10410577f, 0.11121400f, 0.15184493f, -0.10752629f, 
    0.02823840f, 0.02521333f, 0.09433594f, -0.00581326f, 0.10689721f, 0.11867081f, 0.04861770f, 0.09253057f, 
    -0.07684754f, -0.12103748f, -0.02684633f, 0.02411146f, 0.06281783f, 0.11844673f, 0.19153239f, 0.09111764f, 
    0.11075430f, 0.09093383f, 0.06538521f, 0.01692855f, 0.07629181f, 0.05240494f, -0.05075722f, 0.13670041f, 
    0.10178004f, -0.12010662f, -0.09883482f, 0.04187101f, 0.11315028f, 0.05741000f, -0.10618150f, 0.04255065f, 
    0.00248182f, 0.10455620f, 0.15524849f, 0.17625745f, 0.02155547f, -0.01018664f, -0.04169259f, -0.08376594f, 
    0.14367452f, -0.06347044f, 0.01448339f, 0.03309339f, 0.08282735f, -0.05858416f, 0.04276221f, -0.13960378f, 
    0.10897397f, -0.22750157f, 0.03714348f, -0.02063802f, 0.03740378f, -0.06765021f, -0.03544659f, -0.07681921f, 
    -0.25715724f, 0.12299055f, -0.14437877f, -0.26284343f, -0.04494047f, -0.13270256f, 0.12088694f, 0.29498285f, 
    0.01823732f, 0.04761539f, 0.04336807f, -0.07648017f, 0.19546717f, 0.12192025f, 0.27791804f, -0.34516796f, 
    0.10797320f, 0.02169128f, -0.19505453f, 0.02977093f, 0.02444171f, -0.05213856f, -0.10300223f, 0.06023218f, 
    -0.10481117f, 0.19258665f, -0.03967753f, 0.01147945f, -0.08483563f, 0.05827593f, -0.05632574f, 0.04108144f, 
    0.01774586f, 0.01198090f, -0.08325800f, 0.08818283f, 0.04446988f, -0.01603670f, -0.05519439f, 0.17335726f, 
    -0.01575277f, -0.08865221f, -0.03448175f, -0.02872234f, -0.11823908f, -0.29339367f, -0.22029486f, -0.19972865f, 
    -0.26959211f, 0.03125439f, 0.09511206f, 0.09217309f, -0.09475707f, -0.00151324f, -0.13179781f, 0.00369746f, 
    -0.02387862f, 0.05270909f, 0.03606103f, 0.14299099f, 0.01619306f, 0.35478696f, 0.11885352f, 0.10529185f, 
    -0.01826568f, -0.05666432f, -0.23629192f, 0.25284311f, -0.03094595f, 0.10258413f, -0.02672232f, 0.00316083f, 
    -0.05169301f, -0.26410395f, 0.28037849f, -0.15922537f, -0.07840279f, 0.03844849f, 0.05233615f, -0.04207341f, 
    -0.01371534f, -0.10398678f, -0.00940710f, 0.01010053f, 0.05590633f, 0.08462095f, -0.12421590f, -0.01818883f, 
    0.14727564f, -0.09586587f, -0.05545103f, 0.12325676f, -0.26415852f, 0.23298289f, 0.01970090f, -0.15415111f, 
    0.06779493f, -0.11881674f, 0.03023563f, 0.32930502f, 0.05314367f, -0.03696843f, -0.06383932f, -0.04506601f, 
    -0.12661192f, -0.00851858f, 0.00314936f, -0.02085447f, -0.43427783f, 0.13125931f, 0.09607787f, -0.00328275f, 
    -0.00639467f, 0.07596050f, -0.01449846f, -0.05107512f, 0.07585923f, -0.04236860f, -0.06006587f, -0.05178301f, 
    -0.06466746f, -0.10197469f, 0.24285249f, 0.08728086f, 0.09399070f, 0.04710824f, -0.14423569f, 0.05950474f, 
    0.08662842f, -0.00526283f, -0.21332327f, -0.06150703f, -0.03027993f, -0.10812308f, 0.05743722f, -0.07357126f, 
    -0.02337601f, -0.01031353f, 0.01544163f, 0.06687857f, -0.04310999f, -0.02613387f, 0.11620078f, 0.03619768f, 
    -0.06523479f, 0.34069884f, 0.11124133f, 0.14745528f, -0.05849958f, -0.10728888f, 0.11839436f, 0.01146391f, 
    -0.04589320f, 0.13551234f, -0.16158350f, 0.02995504f, -0.05217023f, -0.06955656f, 0.14346534f, -0.15331507f, 
    -0.05562244f, -0.02814586f, 0.03453446f, -0.05965507f, -0.17322519f, 0.02181920f, 0.08285705f, 0.12572122f, 
    -0.02970785f, -0.31635323f, -0.29238307f, -0.08616835f, -0.04150338f, -0.05186965f, -0.03510937f, 0.07732768f, 
    0.01014037f, 0.05155930f, 0.01460555f, -0.14744455f, 0.07617645f, 0.10954937f, 0.16334584f, 0.07968088f, 
    -0.00629618f, 0.03423138f, -0.03028018f, 0.07914366f, 0.17686637f, 0.05937020f, 0.08400857f, 0.08392852f, 
    0.17509902f, -0.35887778f, 0.09935564f, -0.02482644f, -0.07900331f, 0.00242648f, 0.29060411f, 0.13049974f, 
    -0.07069319f, -0.19453065f, -0.15735260f, -0.10415252f, 0.61721432f, -0.07898302f, 0.24071337f, -0.16479044f, 
    -0.12022548f, 0.10627814f, 0.18739724f, 0.10700652f, -0.02231615f, 0.07802321f, 0.09331895f, 0.05997681f, 
    -0.16418943f, -0.16455248f, -0.17496939f, 0.10500505f, -0.04418699f, 0.09048750f, -0.02988075f, -0.00954374f, 
    -0.08698627f, -0.07293510f, 0.10036023f, -0.08232325f, 0.08575057f, -0.07212117f, 0.24616271f, -0.12348042f, 
    -0.24170330f, 0.12649184f, -0.03002917f, 0.01570023f, -0.12762886f, -0.03810238f, -0.15859461f, 0.10734730f, 
    0.25490916f, -0.05661445f, 0.02537935f, 0.22445311f, -0.28538084f, -0.08772396f, -0.01294347f, 0.04380073f, 
    0.06934825f, 0.01821355f, 0.13501026f, 0.25099096f, 0.19614421f, -0.30046356f, 0.12593508f, 0.10089820f, 
    -0.01758867f, -0.04493881f, 0.09331188f, -0.08751536f, -0.00064971f, -0.01495758f, 0.04740443f, -0.02937025f, 
    -0.05969708f, -0.04189139f, 0.28897902f, 0.13044557f, -0.09924643f, 0.09158998f, 0.16281246f, -0.05685325f, 
    0.06473082f, 0.02762705f, 0.22954759f, 0.18455830f, -0.40324745f, 0.28725660f, -0.28408411f, 0.20619541f, 
    0.00498881f, -0.06406303f, 0.00997479f, 0.06504606f, -0.11424154f, 0.13089809f, -0.01682978f, -0.09847813f, 
    0.10123839f, 0.09979771f, 0.26113105f, 0.19899018f, -0.19977406f, 0.13728911f, 0.11136182f, -0.04010689f, 
    -0.01058353f, -0.09049609f, 0.02989558f, -0.05051143f, -0.04406069f, 0.26366961f, -0.24856240f, 0.06369767f, 
    -0.01542257f, 0.09724885f, -0.05146661f, -0.04956746f, 0.07383697f, 0.01611169f, 0.18130219f, 0.15552624f, 
    -0.11963649f, -0.32642072f, 0.15459602f, 0.05218900f, -0.19915804f, 0.02572075f, 0.06693874f, 0.00085946f, 
    0.11813119f, 0.05254123f, 0.06051406f, 0.03340484f, -0.02812054f, -0.07085953f, -0.08414519f, 0.00263246f, 
    -0.04224293f, -0.03425874f, 0.03786121f, -0.09580743f, 0.09127273f, 0.09233008f, 0.03935752f, 0.14157447f, 
    -0.00292681f, -0.01756454f, 0.00444131f, -0.03627913f, 0.05922866f, 0.01536413f, 0.16929752f, -0.05833051f, 
    0.05773977f, -0.00081060f, -0.01989074f, -0.11648741f, 0.05483174f, -0.25118008f, -0.06975029f, -0.09913386f, 
    -0.18998840f, 0.08932366f, 0.06507890f, -0.04000955f, -0.04762478f, 0.06749801f, -0.02323821f, 0.03936419f, 
    -0.10438892f, -0.00135350f, 0.13845849f, -0.03948947f, -0.03561262f, 0.00213402f, -0.05242429f, -0.09802974f, 
    -0.04911554f, -0.11422422f, 0.09250144f, 0.03517736f, 0.03117932f, -0.14804800f, -0.23457834f, -0.03626815f, 
    0.01339331f, -0.14685607f, -0.07980489f, -0.03992055f, -0.07445205f, 0.01464093f, -0.09960674f, -0.31412938f, 
    -0.08871028f, 0.11415328f, -0.08742538f, 0.01578459f, -0.08001758f, -0.00589734f, 0.03024003f, -0.07578557f, 
    0.00009641f, 0.00483017f, 0.06035258f, 0.03776227f, -0.16890915f, 0.13417159f, -0.03294757f, 0.05753804f, 
    -0.00733409f, 0.02917573f, -0.04720870f, 0.11510157f, 0.08870257f, -0.11628842f, 0.09709850f, -0.04725989f, 
    -0.08573082f, -0.02684115f, 0.13393992f, -0.04550510f, -0.08652349f, -0.00802961f, -0.19142234f, -0.13124971f, 
    -0.03759101f, 0.10326307f, 0.03147776f, 0.03763128f, -0.06365849f, -0.46622613f, -0.34512454f, 0.27161679f, 
    -0.01844198f, 0.09025117f, 0.05843844f, -0.02007608f, -0.04245990f, 0.06469809f, 0.02300655f, 0.00145620f, 
    0.16040282f, -0.37820119f, 0.37058240f, 0.11830549f, -0.10964947f, 0.06609537f, -0.00774230f, -0.01182021f, 
    0.03621330f, 0.01085357f, -0.02931040f, -0.01975445f, -0.10259891f, -0.37275463f, 0.01209436f, 0.11738480f, 
    -0.09826528f, -0.11693773f, -0.34283301f, 0.03642336f, 0.01484767f, -0.07721523f, 0.03002009f, 0.00503104f, 
    -0.19694498f, 0.03285786f, -0.09332158f, 0.05554964f, -0.00617354f, -0.02678032f, -0.03396387f, 0.09351107f, 
    0.05309888f, -0.11531369f, -0.13791211f, -0.21316560f, -0.06724366f, 0.01513525f, -0.38611713f, 0.17342885f, 
    -0.09158855f, -0.10250362f, 0.03495876f, 0.02864344f, 0.05402089f, 0.11559965f, -0.11553106f, 0.01422156f, 
    0.14490904f, 0.15204990f, 0.21758580f, -0.25836590f, -0.04359388f, -0.02169733f, 0.07066241f, -0.00710955f, 
    0.03483410f, 0.14775780f, 0.13036212f, 0.14537176f, -0.12189262f, -0.18449430f, -0.17065458f, -0.18752152f, 
    -0.21123880f, -0.07158588f, -0.13065299f, -0.04173271f, -0.08602173f, -0.01220171f, -0.12018608f, -0.16193394f, 
    -0.27706653f, -0.21961690f, -0.08598870f, 0.00779683f, -0.20198521f, 0.06884038f, -0.03862405f, -0.03707887f, 
    0.05089084f, 0.05837683f, 0.01431031f, -0.04074086f, -0.45360741f, 0.28414726f, -0.12476014f, -0.34221447f, 
    0.03502039f, 0.01102397f, -0.04448909f, -0.00883736f, -0.12510161f, -0.24289002f, -0.07602969f, -0.31784028f, 
    -0.07953055f, 0.21458660f, -0.20780386f, -0.12804854f, 0.05644386f, -0.08054403f, 0.05265442f, -0.08267012f, 
    -0.06326448f, 0.04292904f, -0.16210392f, -0.09582604f, -0.00674126f, 0.02698440f, 0.16997652f, -0.20063776f, 
    -0.14511469f, 0.00999283f, -0.03742806f, -0.00525963f, 0.06591916f, 0.03469815f, 0.06293724f, 0.08635208f, 
    0.35373205f, 0.24742259f, 0.39008963f, 0.14595754f, -0.18164334f, 0.13364883f, 0.10349540f, -0.09608244f, 
    0.05479129f, -0.05663196f, -0.06510490f, -0.00816272f, -0.11209618f, 0.08092052f, -0.08097533f, -0.05626853f, 
    -0.18278828f, -0.04380836f, -0.02477608f, -0.01088877f, -0.08356825f, -0.08707260f, -0.22179407f, -0.18247545f, 
    0.20283446f, -0.14572628f, 0.16797166f, -0.07819600f, -0.02219119f, 0.06735392f, -0.03206665f, 0.05183144f, 
    -0.03858956f, -0.00309209f, 0.06454311f, 0.04795721f, -0.23998140f, 0.21027555f, -0.28217813f, 0.00297298f, 
    -0.16711868f, -0.28671044f, 0.06986997f, -0.18489514f, -0.01833774f, 0.19224441f, -0.01474093f, -0.04130029f, 
    -0.00533955f, -0.23250043f, 0.13847449f, -0.06553728f, -0.17524405f, 0.01399494f, -0.05369794f, -0.00257719f, 
    0.01683215f, -0.06555811f, -0.18585128f, -0.06942499f, -0.03833400f, 0.11293800f, -0.16365567f, 0.17256337f, 
    -0.05172510f, -0.05817816f, 0.06020026f, -0.01190609f, -0.03913813f, -0.01348136f, -0.02162615f, -0.11354144f, 
    0.14477758f, 0.15849882f, 0.16746461f, 0.01393087f, 0.01427983f, 0.07232400f, 0.12767570f, 0.04956036f, 
    -0.01109040f, 0.03490783f, 0.05068279f, 0.01383436f, 0.11636747f, 0.22415870f, 0.33130077f, -0.32752028f, 
    -0.00094105f, -0.00658321f, 0.02220139f, 0.06997847f, -0.03307438f, -0.03187898f, 0.04365692f, -0.15560907f, 
    -0.00671746f, -0.05629390f, -0.28307408f, 0.10695077f, -0.04840297f, -0.06579935f, -0.02896161f, 0.04596516f, 
    -0.06316523f, -0.05627674f, -0.11832791f, 0.05279246f, -0.15330254f, -0.28337216f, 0.00732949f, 0.01042579f, 
    -0.04915964f, -0.05168840f, 0.12169749f, 0.05765813f, 0.05428913f, 0.10199807f, 0.09131068f, -0.04905260f, 
    -0.23935160f, -0.04949148f, -0.12174632f, 0.10586175f, 0.03509183f, 0.14888586f, 0.20260423f, 0.05276993f, 
    0.03102445f, -0.01862009f, 0.00775394f, -0.01940551f, -0.10549273f, -0.21183205f, 0.13162184f, 0.06839055f, 
    0.09243681f, 0.05434801f, -0.10944021f, -0.04161615f, -0.00776623f, -0.00892468f, -0.00380638f, 0.00473679f, 
    -0.21094857f, 0.06273291f, -0.18643898f, 0.06644263f, 0.02862360f, -0.04202228f, -0.04642171f, -0.06941801f, 
    -0.01955912f, -0.17268401f, -0.14621320f, 0.03643593f, 0.01125100f, -0.00659233f, 0.11725083f, -0.08814906f, 
    0.10809203f, -0.04193325f, -0.02246389f, 0.05869873f, -0.19555773f, -0.08883403f, -0.26409391f, -0.25626510f, 
    -0.00247452f, -0.01929703f, -0.17406195f, -0.10714239f, -0.03696871f, -0.21558759f, -0.11789699f, -0.04516503f, 
    -0.12396865f, -0.05565399f, -0.07672808f, -0.05180198f, -0.40372941f, 0.18056154f, -0.07396880f, 0.06850066f, 
    0.09402414f, -0.02121191f, 0.03473014f, -0.06616286f, -0.19695632f, 0.12825172f, -0.00690636f, 0.07322762f, 
    -0.35274848f, 0.15355295f, 0.00037988f, -0.14884609f, -0.04083919f, 0.08423481f, 0.04851535f, 0.08098604f, 
    -0.03542266f, 0.09614001f, 0.13271658f, 0.03529572f, -0.01901873f, 0.17758878f, -0.27398789f, 0.04107241f, 
    -0.07871161f, 0.01504464f, 0.12858987f, 0.02079816f, -0.02421395f, 0.04545808f, 0.15853199f, 0.15350260f, 
    -0.04169036f, -0.20619871f, -0.17245370f, 0.09239516f, -0.03375689f, 0.02365481f, 0.07777741f, -0.07769955f, 
    0.12938538f, 0.05674145f, 0.11611953f, 0.09771424f, -0.16648707f, 0.02854613f, 0.20932966f, 0.17176794f, 
    -0.01092746f, -0.00088315f, -0.16064072f, 0.00327016f, -0.09727535f, -0.00068782f, 0.12204334f, -0.11421488f, 
    -0.31142223f, 0.18702693f, -0.16775554f, -0.18478042f, 0.03946029f, 0.04184630f, 0.04958624f, -0.16579688f, 
    -0.02552726f, 0.06793071f, -0.00989202f, 0.16533442f, -0.40386662f, -0.04356055f, 0.05291291f, -0.08557732f, 
    -0.02120320f, 0.04758223f, 0.02399291f, 0.16071159f, -0.07577799f, 0.12528776f, 0.08717564f, 0.00127972f, 
    0.10836165f, -0.06418490f, 0.11370426f, 0.25709870f, 0.13343857f, 0.02021127f, 0.01204337f, 0.05364736f, 
    -0.00112326f, 0.03735121f, -0.05942522f, -0.03245195f, 0.04220834f, -0.33898810f, 0.46845815f, 0.16962273f, 
    -0.02717565f, -0.04042446f, -0.01872692f, 0.17346998f, -0.03144750f, 0.01139673f, 0.01517223f, -0.02072231f, 
    0.01883100f, 0.14824165f, 0.16523312f, -0.08817452f, -0.03178499f, 0.12798180f, 0.08292513f, -0.01863187f, 
    -0.14161687f, 0.04948643f, 0.14709060f, -0.05575489f, -0.67310780f, 0.19929294f, -0.39789259f, 0.30079708f, 
    0.03466920f, -0.07678445f, 0.10074479f, -0.05748961f, -0.10057387f, -0.10298225f, -0.00376756f, 0.03598541f, 
    -0.06974440f, 0.03399263f, 0.18902948f, -0.03070552f, -0.02605736f, 0.00698215f, -0.00138022f, -0.08735429f, 
    0.13807815f, 0.09818210f, -0.02236335f, 0.15673907f, -0.07029646f, 0.02323034f, -0.21596131f, 0.09465437f, 
    -0.04344770f, 0.01046574f, -0.02466839f, -0.09384035f, -0.00116759f, 0.06939083f, -0.01961742f, 0.01385650f, 
    -0.29766390f, 0.27333748f, -0.22686322f, 0.16249280f, -0.09300203f, 0.18900298f, -0.04980239f, 0.21576199f, 
    -0.07011157f, 0.03049100f, 0.13709603f, 0.02983659f, 0.17745718f, -0.14861512f, 0.09226091f, -0.04952039f, 
    0.04282938f, 0.02353182f, 0.07564287f, 0.08673946f, -0.00790621f, -0.00515803f, 0.08867259f, -0.05702151f, 
    -0.04469830f, -0.18274617f, 0.00754958f, 0.02457813f, 0.13359265f, -0.03636416f, 0.07431311f, -0.15419999f, 
    -0.09202122f, -0.13010672f, 0.06989226f, 0.01028311f, 0.12344150f, 0.10001448f, 0.01039786f, 0.06767393f, 
    -0.03323448f, 0.14508621f, -0.04571201f, 0.04227177f, -0.12868461f, 0.00720176f, 0.04535879f, -0.00769314f, 
    -0.05054584f, -0.02379909f, -0.20508781f, -0.32251334f, -0.15969312f, -0.00824397f, 0.15775192f, -0.12284395f, 
    0.04108978f, 0.06640297f, 0.03427517f, -0.04297451f, -0.48265499f, -0.02261773f, -0.16127932f, 0.08542801f, 
    -0.03525569f, -0.07063418f, -0.02168606f, 0.02365100f, -0.36718130f, -0.04438791f, -0.18883120f, -0.15202309f, 
    -0.21181640f, -0.40667632f, 0.23272488f, -0.23731464f, 0.09187447f, 0.00771131f, -0.08490621f, 0.20385569f, 
    0.06592657f, 0.22491553f, 0.08182000f, 0.05337479f, -0.27335256f, -0.37604523f, 0.37258458f, -0.40222532f, 
    0.09230846f, 0.02569067f, 0.06806064f, -0.02624089f, -0.13235338f, -0.07024574f, 0.04237241f, 0.03537438f, 
    -0.22281927f, -0.18849255f, 0.02513680f, 0.21115819f, 0.03311270f, 0.13410486f, -0.06456204f, -0.17272130f, 
    -0.07361193f, 0.04813460f, 0.05686143f, 0.09339480f, 0.04435505f, 0.11786557f, -0.02839079f, -0.09358720f, 
    0.01589361f, 0.12794569f, 0.06901518f, 0.03640930f, 0.07471927f, -0.00167731f, 0.01226591f, -0.01686501f, 
    -0.07786547f, -0.02812047f, 0.16381261f, -0.13161704f, -0.08242933f, 0.14155561f, -0.25903887f, 0.23772502f, 
    -0.25988290f, -0.05540025f, -0.03986589f, -0.15617329f, 0.07168751f, -0.23768404f, 0.62526703f, 0.14936566f, 
    -0.00916497f, 0.02223843f, 0.09686843f, -0.04386848f, -0.05185763f, -0.04420025f, 0.04278176f, 0.23115809f, 
    0.13738012f, 0.02968082f, 0.20030072f, 0.04998606f, 0.08082838f, 0.01074539f, 0.04020114f, -0.01096627f, 
    -0.04510908f, -0.19934531f, -0.10529788f, -0.18140447f, 0.15599200f, -0.13109548f, 0.37136111f, 0.34294716f, 
    -0.24252234f, -0.07679307f, 0.01275447f, -0.02659549f, 0.02768988f, 0.01199417f, -0.17254135f, -0.01019409f, 
    -0.51461148f, -0.00047323f, -0.13008097f, 0.12258501f, -0.13018431f, 0.22082557f, -0.05685152f, 0.03592589f, 
    0.13447496f, -0.11808537f, 0.11631556f, -0.03695373f, -0.52635854f, 0.07164849f, -0.12808016f, 0.18196605f, 
    0.14620620f, -0.04953161f, 0.01976742f, 0.02114007f, -0.10562190f, 0.02020438f, 0.18711127f, -0.05633818f, 
    -0.00427062f, -0.08476265f, 0.11511632f, -0.17323637f, -0.15207399f, -0.24369167f, 0.04815955f, 0.03911192f, 
    0.07242253f, 0.06250516f, -0.05026080f, -0.13489535f, -0.21752040f, 0.06493752f, -0.17090428f, -0.00690387f, 
    -0.01894066f, -0.03873370f, -0.01846488f, -0.11811742f, -0.11299964f, 0.07721940f, -0.02105716f, -0.23269871f, 
    -0.00660901f, -0.27603838f, 0.12678355f, 0.12845990f, 0.01667343f, -0.09779280f, -0.07444263f, 0.07648993f, 
    -0.07578971f, 0.04993558f, 0.04916630f, 0.04594868f, 0.49092263f, -0.01484004f, 0.22703296f, -0.20246002f, 
    -0.05521717f, -0.04737695f, -0.21375394f, 0.06702693f, -0.13592288f, 0.07329154f, 0.00168240f, -0.03838276f, 
    -0.14270490f, 0.11024307f, -0.11148178f, -0.12426293f, 0.15325005f, -0.09000393f, -0.03002644f, -0.02490848f, 
    -0.07815526f, 0.02556820f, -0.03891781f, -0.10857661f, 0.06961710f, 0.26396218f, -0.10330754f, -0.36006847f, 
    -0.09939782f, 0.01203396f, 0.08476956f, 0.03552734f, -0.00716710f, 0.02436722f, 0.04917488f, -0.00633970f, 
    0.22079207f, -0.10509258f, 0.29743376f, 0.14688127f, 0.11759955f, -0.05661078f, -0.00095916f, -0.04392982f, 
    -0.15656070f, -0.01925393f, -0.05906305f, -0.13716424f, -0.24810094f, 0.12123367f, -0.06603573f, -0.00157744f, 
    0.04970086f, 0.04306152f, 0.04165317f, -0.10174738f, -0.03498650f, 0.02489049f, 0.07192256f, 0.26941261f, 
    -0.03850007f, -0.21242300f, 0.07046433f, -0.28633633f, 0.06333523f, -0.10923938f, -0.25688607f, -0.24663064f, 
    0.08909843f, -0.00107550f, -0.05488315f, 0.00415651f, -0.20904341f, -0.35259449f, 0.06902980f, 0.22628416f, 
    0.09228283f, 0.05737647f, -0.00596938f, -0.25667799f, -0.06557204f, -0.03696588f, 0.02035692f, -0.10427935f, 
    -0.05817319f, 0.01851131f, 0.07748279f, 0.19752768f, 0.04508771f, 0.09547483f, -0.09218241f, -0.18044887f, 
    -0.09839474f, 0.16572192f, -0.10124979f, 0.13503131f, 0.42045650f, 0.14015290f, 0.46581474f, -0.15270235f, 
    -0.05034855f, -0.09636635f, -0.06779173f, -0.04002083f, -0.05569039f, 0.06351002f, 0.05476521f, -0.07153688f, 
    -0.08176567f, -0.17581342f, -0.05687302f, -0.35719392f, 0.00211651f, -0.09658004f, -0.05210081f, 0.08296899f, 
    -0.03401035f, 0.08875489f, 0.12987141f, 0.08063142f, 0.05328185f, 0.28353792f, 0.00309402f, 0.09470301f, 
    -0.05808462f, 0.06619898f, 0.01152564f, 0.00659988f, -0.02247693f, 0.00078653f, 0.09641883f, 0.05902924f, 
    -0.19146597f, 0.04037656f, -0.24895374f, -0.04012205f, 0.03909946f, 0.03424900f, 0.07220147f, -0.01187119f, 
    -0.23650424f, 0.19048673f, -0.16316888f, 0.05494118f, 0.30953455f, 0.03648416f, -0.13540550f, -0.03010537f, 
    -0.03064859f, 0.03507918f, 0.01316221f, 0.04898225f, -0.03877702f, 0.09286235f, -0.03268984f, 0.00319779f, 
    0.28173223f, 0.32745606f, 0.03629448f, 0.01748462f, -0.00521804f, 0.04059290f, -0.03714424f, 0.04770993f, 
    -0.00265639f, 0.00372577f, -0.03825796f, -0.12612122f, -0.21042109f, -0.15897933f, -0.19378318f, 0.01185843f, 
    0.20184544f, 0.02427278f, 0.00537114f, -0.08847231f, 0.07870912f, 0.02100785f, 0.17673045f, 0.14565428f, 
    -0.20873344f, -0.41955745f, 0.01328617f, -0.00150986f, 0.04561062f, -0.14370950f, 0.05563248f, -0.16621765f, 
    0.03902848f, 0.04506797f, 0.04987485f, 0.16276640f, 0.00390951f, -0.21116382f, 0.10419760f, -0.08241675f, 
    -0.02408701f, -0.01739262f, -0.05016593f, -0.05911944f, -0.04082848f, -0.05206813f, 0.02030136f, -0.16978802f, 
    0.26954818f, -0.16493861f, 0.51391947f, -0.33179635f, 0.17466176f, -0.15835956f, -0.13982771f, -0.03039155f, 
    -0.00807991f, -0.08636244f, 0.05837505f, -0.00817548f, 0.35167453f, -0.33065546f, 0.11465362f, 0.02468639f, 
    0.04630361f, -0.03821254f, 0.16038033f, 0.14315565f, 0.04556908f, 0.18793023f, 0.10615380f, 0.04210345f, 
    -0.06407782f, 0.00746254f, 0.12039595f, -0.11787850f, 0.09933774f, -0.10347871f, 0.19786754f, 0.10974765f, 
    0.03100656f, 0.00452860f, -0.00112834f, 0.11876593f, -0.08370018f, -0.21865858f, 0.11508555f, 0.19018926f, 
    -0.05478857f, -0.03688610f, 0.00353212f, -0.05107974f, 0.08945958f, -0.06026408f, -0.00685356f, 0.10825810f, 
    0.13942058f, -0.07701995f, 0.13153741f, 0.01978514f, 0.14775601f, 0.00874937f, 0.19497839f, -0.06125722f, 
    -0.00084511f, 0.14294928f, 0.07634471f, 0.06495246f, 0.22793053f, 0.02333125f, 0.26480070f, 0.11645572f, 
    -0.15968932f, 0.11627662f, 0.09216142f, 0.08040658f, -0.07677545f, -0.04299557f, 0.04440663f, -0.08599622f, 
    0.01894047f, -0.05667669f, 0.21006677f, -0.27042791f, -0.11786105f, -0.09748556f, 0.17657299f, -0.06881385f, 
    -0.04019528f, 0.06075377f, -0.16195300f, -0.03753637f, 0.06546205f, -0.28835812f, 0.06499273f, 0.14037225f, 
    -0.01554557f, 0.04488581f, 0.07835250f, -0.07317261f, 0.01434504f, 0.14732496f, -0.17265280f, 0.05176257f, 
    0.14857990f, -0.03766513f, 0.29818469f, -0.16036905f, -0.01298289f, -0.00626138f, -0.05839114f, -0.01190952f, 
    -0.08951328f, -0.02474666f, 0.11014429f, -0.05993974f, -0.23117143f, -0.20352584f, 0.04414650f, 0.12321586f, 
    -0.05188828f, -0.10927964f, -0.04724093f, -0.01768629f, 0.00247423f, 0.08731803f, -0.10475201f, -0.00773392f, 
    -0.34910446f, 0.09361193f, -0.16746466f, 0.03084705f, -0.03862785f, -0.14792995f, 0.13992706f, -0.10698391f, 
    0.01205290f, -0.02728655f, 0.09213696f, -0.04288063f, 0.09983659f, -0.17369206f, 0.14557765f, -0.11270796f, 
    -0.06122673f, -0.25634012f, -0.08963787f, 0.03504398f, -0.01602530f, -0.03507062f, -0.07145295f, -0.08521747f, 
    -0.27889594f, -0.05281410f, -0.10209350f, 0.07711659f, -0.06218712f, -0.00513877f, -0.08696698f, -0.02255645f, 
    -0.01668759f, -0.00967143f, 0.11349011f, 0.11620535f, 0.04465918f, 0.01488564f, 0.09016435f, -0.08743135f, 
    -0.05133908f, 0.10367758f, -0.04518547f, -0.02777886f, 0.06126885f, 0.09725118f, 0.11648410f, 0.04045025f, 
    0.07397015f, 0.06986403f, -0.04393451f, 0.02050572f, -0.07201041f, 0.08097055f, -0.03975876f, 0.01846837f, 
    -0.12143888f, 0.02386932f, 0.07612251f, -0.03406951f, -0.18399830f, -0.64772373f, 0.24231435f, 0.17379703f, 
    0.01233650f, -0.14605305f, -0.01939654f, -0.03663018f, 0.03018026f, 0.04037984f, 0.07320194f, -0.01360852f, 
    -0.03032906f, -0.10578594f, -0.12496837f, 0.16197456f, 0.06790323f, -0.01799115f, -0.04046164f, -0.08717043f, 
    0.04252378f, -0.03104911f, -0.09552916f, -0.13687621f, 0.11857468f, -0.03961599f, -0.03390159f, -0.07402410f, 
    -0.01597123f, 0.15425658f, -0.07458150f, 0.11694290f, 0.01855757f, -0.16541743f, -0.03231825f, -0.09625341f, 
    -0.06711225f, -0.12846924f, -0.05501844f, -0.00628328f, -0.24847063f, -0.09010862f, -0.04238093f, -0.24807864f, 
    0.03409730f, -0.03596514f, -0.06183018f, 0.00212268f, -0.08774193f, 0.12506346f, -0.35647604f, -0.00579140f, 
    0.01475391f, 0.01376908f, 0.03577846f, 0.09557258f, -0.10415909f, 0.00267044f, 0.10111026f, 0.01484803f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13896935f, 0.11316329f, 0.11305080f, -0.06446438f, -0.07570418f, 0.08136693f, 0.07510749f, -0.13850543f, 
    0.04134241f, 0.01603910f, 0.02021200f, -0.02263846f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
